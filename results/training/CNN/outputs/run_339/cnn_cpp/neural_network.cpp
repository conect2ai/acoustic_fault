#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.95059311f, 0.65117770f, 0.08351176f, 0.70224196f, 0.13799985f, -0.63192779f, -0.18673342f, 0.20257144f, 
    -0.01125330f, 0.58521026f, 0.88084728f, 0.83094120f, -0.43779755f, -0.41207081f, -0.69189191f, 0.10686661f, 
    0.27655914f, 0.00765885f, 0.07630301f, 0.76202786f, -0.85903084f, 0.46774963f, -0.42614755f, -0.58156449f, 
    -0.00515983f, -0.02342603f, 0.23614936f, -0.12638132f, -0.65045357f, -0.52529085f, 0.59429932f, -0.79353404f, 
    0.30642053f, -0.43613255f, -0.26404235f, 0.21233788f, -0.82471544f, 0.55209887f, -0.00820060f, 0.00552566f, 
    0.90425432f, 0.24050461f, -0.00783054f, 0.40311497f, -0.07506308f, -0.50713521f, -0.69015247f, -0.49887273f, 
    0.67195123f, 0.72086036f, -0.01364053f, 0.17055438f, -0.12821774f, -0.10674624f, 0.81705034f, 0.43738878f, 
    0.55256373f, 0.54836476f, 0.25181293f, -0.14697598f, 0.22698003f, 0.48008361f, -0.05953944f, -0.20159963f, 
    -1.04428256f, -0.67627299f, -0.50949812f, 0.62000930f, 0.46858361f, -0.06324500f, 0.06938184f, 0.08288402f, 
    0.17733106f, 0.75122935f, 0.64790279f, -0.44918230f, 0.65529001f, 0.11447475f, 0.30849156f, 0.29226789f, 
    0.02081248f, -0.05788576f, 0.83177286f, 0.27807045f, -0.75962192f, -0.13390370f, 0.14237383f, -0.49423626f, 
    -0.23486745f, 0.27382722f, -0.24556509f, -0.27225846f, -0.30390084f, -0.40415347f, -0.70666885f, -0.25904134f, 
    -0.40025195f, 0.45878220f, -0.50626272f, -0.34802118f, -0.14354731f, 0.68561226f, -0.50002098f, -0.37500635f, 
    -0.55156881f, 0.38491386f, 0.12872921f, -0.18051545f, -0.61142546f, -0.29210338f, -0.46085742f, -0.71203387f, 
    -0.21152833f, -0.50333470f, 0.16729099f, 0.05701383f, 0.26524600f, 0.94371778f, 0.07289734f, -0.40029368f, 
    0.60463154f, 0.35805812f, -0.21159393f, -0.43827870f, -0.25749859f, -0.23337308f, 0.26678285f, 0.60738224f, 
    0.58823025f, 0.27862129f, -0.30201852f, 0.46999773f, -0.46559218f, -0.24341047f, -0.18500370f, 0.51199645f, 
    0.17774712f, 0.27251464f, -0.21876161f, 0.50776839f, 0.38029003f, -0.16705677f, -0.10255176f, -0.45588836f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.09971347f, 0.01567632f, 0.16080141f, 0.19960865f, -0.08364838f, 0.05041359f, 0.35594544f, 0.04353105f, 
    -0.00751631f, -0.10633653f, 0.10946862f, -0.10830823f, 0.09659965f, 0.15649818f, 0.14412588f, -0.04997059f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.31023782f, 0.04987776f, 0.15460168f, -0.22494727f, -0.25211146f, -0.00523777f, 0.05009940f, -0.04309905f, 
    -0.11802760f, 0.03575920f, -0.10766964f, 0.03164231f, 0.03931729f, -0.06000751f, 0.03472020f, -0.05862312f, 
    0.05985158f, -0.04144559f, -0.03692374f, 0.02244634f, -0.11692277f, 0.11424720f, 0.30275449f, 0.31407958f, 
    0.05900928f, -0.21000744f, -0.11695826f, -0.00460549f, -0.03497630f, 0.04849496f, -0.08780932f, -0.06963121f, 
    0.12323416f, 0.17324899f, 0.12340393f, 0.03943500f, -0.15719470f, -0.06066003f, 0.01762041f, 0.01300396f, 
    -0.12879375f, -0.11538928f, 0.04225553f, 0.01355631f, -0.07882933f, -0.12436481f, 0.09492164f, 0.04293584f, 
    -0.03772956f, 0.02133715f, 0.03624776f, -0.04272783f, 0.02003249f, -0.04666552f, -0.02679955f, -0.03250124f, 
    0.05558450f, -0.11273268f, -0.01857740f, -0.01427311f, -0.29403168f, -0.26425597f, -0.16674134f, -0.09475245f, 
    -0.06595318f, 0.01665438f, 0.04227564f, 0.04045079f, 0.07604436f, 0.11958883f, 0.10162821f, 0.12265112f, 
    0.04775547f, -0.06025388f, -0.05658509f, 0.01833580f, 0.03085067f, 0.05014246f, 0.12413022f, 0.10736577f, 
    -0.28512183f, 0.08367519f, -0.02326247f, 0.00992554f, 0.09005526f, 0.01544398f, -0.01795612f, 0.11344019f, 
    0.05346399f, 0.02172723f, 0.02870609f, -0.07679927f, -0.04678543f, 0.03042059f, 0.08365628f, -0.03843592f, 
    -0.00396442f, 0.05993733f, -0.02206364f, -0.07275000f, -0.35458210f, 0.06917099f, -0.26448873f, -0.13247582f, 
    -0.08357424f, 0.12257125f, 0.08196688f, 0.07116622f, -0.04634389f, -0.05496717f, 0.05148280f, -0.00240818f, 
    -0.03913900f, -0.05798806f, -0.00440191f, 0.20485941f, 0.12440810f, -0.02491775f, -0.00863995f, 0.01220335f, 
    0.02898322f, 0.05341422f, 0.28579435f, 0.09707538f, 0.13524538f, 0.13449594f, -0.02362807f, -0.03688477f, 
    0.03972102f, 0.08190229f, 0.07853540f, -0.09265802f, -0.04218196f, -0.07013806f, -0.00903856f, 0.04619789f, 
    0.05788768f, -0.05082372f, 0.10368685f, 0.06813452f, -0.59847146f, 0.07250405f, -0.20125294f, -0.01312630f, 
    0.03630235f, 0.08853080f, 0.02144230f, -0.06605738f, 0.09290316f, -0.00153439f, 0.02553972f, 0.02105603f, 
    -0.07787196f, -0.03595214f, -0.02222849f, 0.11545660f, -0.04004826f, 0.05997455f, 0.08173073f, -0.08452257f, 
    -0.15030535f, 0.09978105f, -0.09111645f, -0.01323596f, 0.06536154f, -0.04378013f, -0.04059526f, 0.06145252f, 
    0.01905450f, 0.01480537f, 0.13920133f, 0.01932072f, 0.05458979f, -0.03111615f, -0.04565195f, -0.01349368f, 
    -0.00685327f, 0.04781726f, 0.00150238f, -0.04626236f, 0.05546271f, 0.06983052f, 0.08532757f, 0.17836305f, 
    0.00596202f, -0.04808586f, -0.05900842f, 0.00919157f, -0.05263696f, 0.07954390f, 0.00010460f, 0.14031939f, 
    -0.04183898f, -0.05206146f, 0.08310924f, -0.11402277f, -0.02675814f, -0.01956161f, -0.00705878f, 0.05300952f, 
    -0.05473456f, -0.18016987f, -0.09618544f, 0.14459616f, 0.05128237f, -0.01163927f, -0.09893681f, 0.06426551f, 
    0.03960530f, 0.08808693f, -0.04951441f, 0.08990330f, 0.03094533f, 0.10492135f, 0.08778886f, -0.15074328f, 
    -0.00555094f, -0.09811759f, -0.06216099f, 0.01511951f, -0.14706519f, 0.04983054f, 0.15856645f, -0.04842318f, 
    -0.01173449f, -0.08741762f, -0.07371390f, -0.12445964f, -0.10245822f, -0.03693518f, 0.11510070f, -0.02239742f, 
    0.01370922f, 0.11240576f, 0.12830251f, -0.03230670f, -0.08657243f, 0.07762501f, -0.02631659f, -0.06542480f, 
    -0.11743606f, -0.14328279f, 0.04480597f, 0.05267106f, 0.07710397f, 0.09486642f, 0.07354118f, 0.02473524f, 
    -0.01831300f, 0.05491563f, 0.07741670f, 0.02299312f, 0.14633523f, 0.18576601f, 0.07034966f, -0.05239629f, 
    0.03404174f, -0.09502691f, -0.07738791f, 0.00983335f, 0.26552135f, 0.06742990f, 0.08697312f, -0.03237103f, 
    -0.01474578f, 0.08648600f, -0.01018430f, 0.02116064f, -0.01412346f, 0.00770309f, 0.06861702f, 0.03050777f, 
    0.01420664f, 0.08298686f, 0.04363637f, -0.07481407f, -0.00851769f, -0.01716436f, -0.02400758f, 0.00878005f, 
    0.20228492f, 0.10040651f, 0.21265699f, 0.03600100f, 0.10895429f, -0.07132753f, -0.11089320f, 0.04831169f, 
    -0.03872155f, 0.02729408f, 0.02568009f, 0.02404683f, 0.06714919f, -0.02261212f, 0.06372397f, -0.01707023f, 
    0.02864116f, 0.13508311f, 0.03159386f, 0.01987583f, 0.17321259f, 0.18316112f, 0.23884216f, -0.01540529f, 
    0.09210680f, -0.04194392f, 0.19777103f, -0.13663223f, 0.01188251f, 0.10072468f, 0.00086529f, 0.01794275f, 
    0.03605265f, -0.09873827f, -0.02788593f, 0.04639028f, 0.07746586f, 0.18056184f, -0.02469370f, 0.02410610f, 
    0.15239480f, 0.21206030f, -0.20102440f, 0.07072306f, 0.27283081f, 0.05855377f, 0.07577871f, 0.02673347f, 
    0.05267559f, 0.08305156f, 0.00581451f, 0.08638243f, 0.01560807f, -0.01698100f, -0.07777824f, 0.05965724f, 
    0.08805738f, 0.11787919f, -0.04550479f, -0.02972280f, -0.09034563f, 0.10210448f, 0.15052220f, -0.26433519f, 
    -0.16594501f, -0.03581416f, -0.03730718f, 0.04987522f, 0.01756260f, 0.03825072f, 0.04655243f, 0.06828779f, 
    -0.01109712f, -0.11162914f, -0.13687907f, 0.02912491f, 0.04801095f, 0.00001076f, -0.01312053f, 0.02150797f, 
    0.09910133f, -0.07027136f, 0.06084191f, 0.01586613f, 0.08316604f, 0.10352865f, 0.08662685f, 0.05845249f, 
    0.05883393f, -0.09371882f, -0.07568442f, 0.04236584f, -0.01819718f, 0.08259662f, 0.12031641f, 0.06668709f, 
    -0.05549082f, 0.25998476f, -0.12247055f, 0.03851883f, 0.20255147f, -0.01716756f, -0.04535202f, 0.00064637f, 
    0.12338243f, -0.03212310f, -0.06523477f, -0.06829654f, -0.04191928f, -0.10791624f, -0.06479605f, -0.08972329f, 
    -0.12821072f, 0.16355459f, 0.04377721f, 0.05672448f, -0.04559568f, 0.04279541f, 0.07181382f, 0.09394449f, 
    0.29210740f, -0.05370966f, 0.04477923f, -0.07079444f, -0.09609290f, 0.10074142f, 0.13709860f, 0.06225570f, 
    -0.02716231f, 0.13690346f, -0.07444646f, 0.01024948f, 0.13694221f, 0.01716364f, 0.05986339f, -0.07307290f, 
    0.08798268f, 0.03597063f, -0.08559485f, -0.13989864f, 0.24664329f, -0.15305650f, 0.07851629f, 0.14202431f, 
    0.05566861f, -0.04462403f, -0.07224698f, -0.02296806f, -0.03590031f, 0.06027471f, -0.14146259f, 0.09456775f, 
    0.16882913f, 0.15859672f, -0.04856376f, -0.06904288f, -0.01352693f, 0.06619646f, 0.04208413f, -0.06952403f, 
    -0.12499985f, 0.07357183f, -0.03074036f, -0.13770041f, -0.12081469f, -0.06203628f, -0.06052500f, -0.05205980f, 
    0.07498974f, 0.09025840f, 0.06129314f, 0.11649214f, 0.11180490f, 0.05615434f, 0.00248194f, 0.05498626f, 
    -0.07891154f, -0.03592167f, -0.09814502f, 0.01063267f, 0.37280422f, -0.07819265f, 0.09172670f, -0.01738708f, 
    0.15351401f, -0.08807991f, -0.01657191f, -0.08408740f, -0.07099332f, 0.17652006f, -0.05037712f, -0.03609603f, 
    0.12376877f, 0.16405126f, -0.01238255f, 0.04666740f, 0.03752396f, -0.08871657f, -0.09549958f, 0.04464418f, 
    -0.12017903f, 0.03635637f, 0.21471982f, 0.10272932f, 0.06306396f, 0.07270958f, -0.01135300f, -0.02215606f, 
    -0.02921539f, 0.07020274f, -0.06776846f, -0.00645687f, -0.02113161f, 0.02690393f, 0.03397476f, -0.03413773f, 
    -0.02812944f, -0.09878996f, -0.12238079f, -0.08484998f, 0.01459430f, 0.07608236f, -0.05269878f, -0.09147975f, 
    -0.06712245f, -0.04351155f, 0.08055289f, 0.10729060f, 0.00381247f, -0.08356490f, 0.02956888f, -0.08348773f, 
    -0.07552134f, -0.02359524f, -0.05105598f, 0.11384106f, 0.08784995f, 0.04783339f, -0.06263258f, 0.05652305f, 
    0.02952262f, -0.05255762f, 0.15847340f, -0.06252740f, -0.13807705f, -0.06615518f, 0.08013769f, 0.01643853f, 
    -0.03848190f, -0.00788518f, 0.03993872f, -0.05723392f, 0.05754894f, -0.07514737f, 0.03137566f, 0.07979815f, 
    -0.01735158f, 0.03648851f, 0.20935634f, 0.09353653f, 0.06256101f, -0.07079431f, -0.01045340f, 0.02117291f, 
    -0.05298492f, -0.13442208f, 0.07932036f, -0.02697095f, -0.01371246f, 0.07915861f, -0.03254726f, 0.01771028f, 
    -0.01700260f, -0.12017068f, -0.16697183f, 0.15258127f, -0.04672245f, -0.01455101f, 0.22689806f, 0.18062510f, 
    0.20855084f, -0.06699346f, -0.01571139f, -0.04816595f, 0.03428754f, -0.09697071f, 0.00940685f, 0.07716967f, 
    0.02136838f, -0.02041669f, -0.02675671f, -0.04828144f, -0.20679568f, -0.15294166f, 0.00381752f, -0.02254159f, 
    -0.01968725f, 0.10964639f, 0.30664751f, -0.02686882f, -0.24865432f, 0.09472392f, -0.08175463f, 0.05812272f, 
    -0.09847251f, 0.13884772f, 0.08617007f, 0.07911490f, 0.13320857f, 0.10345550f, -0.02167653f, -0.03542279f, 
    0.05780077f, 0.02181984f, -0.05290565f, 0.05765577f, 0.03794406f, 0.09100282f, 0.01140698f, 0.02324667f, 
    0.01160962f, 0.15033187f, -0.11481855f, -0.06032749f, -0.09339444f, -0.02145099f, 0.07517885f, 0.09249815f, 
    0.01355547f, 0.07635131f, 0.02216784f, 0.04320835f, -0.10183403f, 0.01723586f, 0.01524545f, 0.01633395f, 
    0.06261674f, -0.07418154f, -0.05889587f, 0.10261235f, -0.20322149f, -0.05523441f, 0.03874974f, -0.03664432f, 
    -0.10726009f, 0.10603900f, -0.07553796f, 0.11694902f, 0.03183577f, 0.04478973f, 0.05297891f, -0.00283894f, 
    0.00252395f, 0.11639312f, 0.06179402f, 0.02041803f, 0.08294533f, -0.14996494f, -0.06705473f, 0.03271481f, 
    0.03455037f, 0.05148447f, 0.04140272f, 0.00183635f, -0.05266990f, -0.03353947f, 0.02795029f, -0.02492886f, 
    0.02645317f, -0.05181392f, 0.05241517f, 0.04474488f, 0.03084945f, -0.00735284f, 0.01380793f, 0.01039178f, 
    -0.01409889f, 0.01745206f, -0.03101757f, 0.04284092f, 0.00576291f, 0.00254360f, 0.01711339f, 0.02472145f, 
    -0.02011944f, 0.01093575f, -0.02977806f, 0.01992691f, 0.04858458f, 0.02256673f, 0.03979986f, 0.02109142f, 
    -0.03991509f, -0.01897918f, -0.02322655f, -0.04845197f, 0.01605151f, 0.01323058f, 0.01693603f, -0.03738925f, 
    0.00063317f, 0.04111995f, 0.01815925f, 0.01584335f, -0.00512022f, -0.05772856f, 0.00725033f, 0.02173503f, 
    0.03115724f, -0.00377645f, -0.02978290f, 0.00100686f, 0.04349633f, -0.03456295f, -0.03890345f, -0.04810993f, 
    -0.03698897f, 0.03148386f, 0.01234038f, 0.01389026f, -0.04888261f, -0.00464351f, -0.00765961f, -0.05199338f, 
    -0.06085567f, 0.01491371f, -0.05830387f, 0.02201934f, -0.05077023f, 0.04752570f, -0.02834144f, 0.01091681f, 
    -0.05563542f, 0.01605015f, 0.01333511f, -0.03011891f, 0.02782401f, 0.03572571f, -0.02601532f, -0.04991240f, 
    0.00701195f, 0.01620535f, -0.03925771f, 0.04699075f, -0.02327810f, 0.02702316f, 0.03727869f, -0.02838637f, 
    -0.01536496f, -0.01965307f, 0.04132782f, -0.02781754f, 0.01856769f, 0.00720403f, 0.00122740f, 0.04602327f, 
    -0.01218027f, 0.00008678f, -0.03475503f, -0.04974037f, 0.00053683f, -0.03876022f, -0.01357729f, 0.02995814f, 
    -0.04912300f, -0.02693529f, 0.01307299f, -0.00158180f, -0.04290695f, -0.02431291f, 0.00291843f, -0.05155414f, 
    0.04057380f, -0.05255990f, -0.01794294f, -0.05079716f, 0.01797687f, 0.04618614f, -0.03565655f, -0.05503519f, 
    -0.02102705f, 0.02443889f, -0.04562013f, -0.01649840f, -0.04809402f, 0.00092294f, -0.00783383f, -0.03591540f, 
    -0.00765332f, 0.03412427f, 0.01056620f, -0.03787835f, -0.05875888f, 0.00164663f, -0.02107873f, -0.01548624f, 
    -0.05140670f, 0.01091295f, 0.00181796f, -0.00585317f, 0.01930423f, -0.03290774f, -0.02166618f, -0.00490412f, 
    0.04730552f, -0.00845978f, -0.06022413f, -0.00199475f, -0.00146978f, 0.03102235f, 0.02623926f, 0.02019882f, 
    -0.03156071f, 0.05139104f, -0.05045294f, 0.03064031f, 0.00180221f, -0.02575261f, -0.04750375f, 0.05097675f, 
    0.04763949f, -0.04743518f, -0.04934629f, -0.02132144f, 0.04787790f, 0.00220422f, -0.00421505f, -0.02940361f, 
    -0.05845699f, 0.00276160f, 0.01033287f, -0.06486133f, -0.04649873f, -0.01099253f, 0.04261512f, 0.00377702f, 
    -0.01012366f, 0.00883884f, 0.02436483f, 0.04880792f, -0.02735619f, 0.01991048f, 0.03482698f, -0.00258535f, 
    -0.00859245f, -0.01162854f, -0.02162193f, -0.00290464f, 0.05054007f, -0.04238512f, 0.04574360f, 0.02055651f, 
    -0.01999509f, 0.02945829f, -0.00203585f, -0.03836594f, -0.04307471f, 0.02798286f, -0.04158782f, -0.04930641f, 
    -0.02499888f, -0.01248560f, -0.01591056f, -0.04966282f, -0.06287041f, 0.04814823f, -0.03510725f, 0.00108134f, 
    -0.04478252f, 0.02741417f, 0.00427652f, 0.00829611f, -0.02255603f, -0.03199904f, 0.04222596f, 0.01931422f, 
    0.04063964f, -0.00411677f, -0.05678041f, 0.02070758f, 0.03074255f, 0.01388847f, -0.04275214f, -0.04728225f, 
    0.00178458f, -0.05587082f, 0.01482515f, -0.05414134f, 0.02020281f, -0.00276027f, 0.02710355f, 0.03595898f, 
    0.04466544f, -0.02826568f, -0.03093992f, -0.01719455f, 0.00473195f, 0.03261883f, -0.00500477f, -0.02326276f, 
    0.04849986f, 0.01688042f, 0.03719159f, -0.03146641f, 0.00179627f, 0.00503972f, 0.01188230f, -0.03862442f, 
    -0.00188155f, -0.01075291f, 0.04182399f, -0.04253721f, 0.04795173f, 0.02027700f, 0.00635094f, 0.02449236f, 
    -0.02636247f, -0.05572198f, 0.04253801f, 0.00279150f, -0.00944487f, -0.00770719f, -0.00036173f, -0.05161250f, 
    -0.00418721f, 0.03799354f, -0.04580719f, 0.04807037f, -0.05829759f, -0.04247383f, 0.02973640f, -0.04472556f, 
    -0.05581671f, -0.04681925f, 0.03138810f, 0.03678493f, -0.03481446f, -0.03818414f, -0.00126020f, -0.00888988f, 
    0.02519812f, -0.00023018f, -0.02786925f, 0.02395633f, -0.02805503f, 0.04491249f, -0.00910349f, -0.04268632f, 
    -0.01493178f, 0.00851994f, -0.01019589f, -0.00772814f, -0.01746756f, -0.03408815f, -0.03247235f, 0.03118096f, 
    0.03482166f, -0.01879393f, -0.04938021f, -0.02205135f, -0.05196745f, 0.01880401f, -0.00755746f, -0.01092155f, 
    0.04082399f, -0.00701725f, 0.02932604f, -0.02607445f, 0.03023442f, 0.00525003f, -0.01898568f, 0.04502040f, 
    0.04931021f, 0.04118659f, 0.04554090f, -0.03125122f, 0.04215667f, -0.01905654f, 0.05241286f, -0.05620807f, 
    -0.04169748f, -0.21488328f, 0.21941602f, 0.03669587f, -0.04816172f, 0.01605762f, -0.07581791f, 0.06786716f, 
    -0.12776089f, 0.03229844f, 0.05230306f, -0.01740194f, 0.00718471f, 0.08325343f, 0.06524117f, -0.06908993f, 
    -0.18917072f, -0.04234667f, 0.02642478f, 0.03392570f, 0.41629219f, 0.19975597f, -0.23681372f, 0.08278665f, 
    0.17527775f, -0.11654345f, -0.11139531f, 0.06145144f, 0.06340870f, -0.05905782f, -0.04029801f, -0.06126884f, 
    -0.07212723f, 0.10134652f, 0.01364548f, 0.06716990f, 0.04411207f, 0.06662702f, -0.03747403f, 0.04435260f, 
    0.20503765f, -0.02975455f, -0.12079322f, -0.11368583f, 0.25665468f, -0.11128242f, -0.12811387f, -0.00076718f, 
    -0.02286584f, 0.02457706f, 0.12152207f, 0.06090733f, -0.03816836f, 0.02591396f, -0.06663479f, 0.10649309f, 
    -0.03387028f, -0.01596314f, 0.04833308f, -0.10487410f, 0.28610140f, -0.04039718f, 0.18591496f, -0.00887948f, 
    -0.23808143f, 0.03093084f, 0.11040616f, 0.04699383f, 0.01756302f, -0.03195660f, 0.06956460f, 0.03907205f, 
    0.06200343f, -0.00869685f, -0.06639059f, 0.04227559f, -0.03426551f, -0.01347537f, 0.00747208f, -0.07325797f, 
    -0.25754127f, 0.23150168f, 0.03596134f, -0.11728463f, 0.03787277f, 0.07941130f, 0.04719705f, -0.04837354f, 
    -0.04522679f, 0.00281309f, 0.13725819f, -0.07181683f, 0.04690980f, -0.01857745f, -0.03140416f, 0.12256556f, 
    0.07595836f, -0.02499428f, 0.10819743f, -0.01897450f, 0.15716819f, 0.09782665f, 0.19598792f, -0.11401112f, 
    -0.32406303f, 0.11970244f, 0.19079731f, 0.05913814f, 0.09841665f, -0.08355384f, 0.10719432f, -0.05060285f, 
    -0.04091094f, -0.00768208f, 0.01354849f, 0.18078370f, 0.12524623f, -0.02862691f, -0.01633297f, -0.05301609f, 
    0.39351055f, -0.13021642f, 0.09181891f, -0.02425835f, 0.17695479f, -0.06321283f, -0.12698774f, 0.08804387f, 
    -0.00186196f, -0.02687635f, -0.00625585f, 0.06225549f, -0.04612054f, 0.02210081f, -0.03718675f, 0.02567324f, 
    0.05232498f, 0.11878504f, 0.07440286f, 0.03596071f, -0.15153737f, 0.12523721f, -0.05334458f, -0.02124020f, 
    -0.33167711f, 0.07572356f, 0.03043381f, 0.12912935f, -0.00942173f, -0.05427555f, 0.02528826f, 0.09509568f, 
    0.04425682f, 0.04185708f, 0.00556463f, -0.04263843f, -0.03710504f, 0.06763494f, 0.01970884f, 0.11293998f, 
    0.22826101f, 0.07888696f, -0.17947502f, -0.06752299f, 0.24331079f, -0.03946092f, -0.06504344f, -0.01283777f, 
    -0.01104072f, -0.06670562f, 0.02373388f, 0.03293834f, 0.09683957f, -0.02974828f, -0.00519296f, -0.06260980f, 
    0.01646774f, 0.02852830f, -0.01511494f, 0.08931296f, 0.00568418f, 0.15865546f, -0.06520942f, -0.06162913f, 
    0.17191914f, 0.01828428f, -0.06467080f, -0.10532925f, 0.10160602f, 0.03594191f, 0.01170686f, -0.04297841f, 
    -0.00038688f, 0.11565447f, 0.02600333f, -0.00919552f, 0.03462255f, -0.03779853f, 0.05403082f, 0.03092464f, 
    -0.11998826f, -0.13719684f, 0.05963860f, 0.03660338f, -0.00412919f, 0.08310311f, -0.10169313f, -0.10141439f, 
    0.00356532f, -0.05638588f, -0.02309663f, -0.05537805f, -0.01837513f, -0.01944472f, -0.07344704f, -0.03368125f, 
    0.08548083f, 0.03457683f, -0.21255335f, -0.14649495f, -0.14761077f, 0.04629023f, -0.22530997f, 0.10740915f, 
    -0.20048575f, 0.04104059f, -0.04323636f, -0.02044299f, 0.00810304f, -0.02342528f, 0.07182838f, 0.01651257f, 
    0.06205289f, 0.03518707f, -0.04021869f, -0.05925416f, 0.02435011f, 0.00998433f, -0.08450114f, -0.08238249f, 
    -0.07726245f, -0.00622826f, -0.04044003f, -0.04047487f, -0.08571461f, 0.04835822f, -0.09964136f, 0.06664602f, 
    0.01610014f, 0.04478852f, -0.05933554f, 0.06574646f, 0.04278839f, 0.00783016f, 0.06262157f, 0.02369379f, 
    -0.09587926f, -0.10329735f, -0.07244239f, -0.13912027f, 0.42428827f, -0.20638616f, 0.08446433f, -0.05913400f, 
    0.25410852f, -0.07888237f, -0.06224434f, -0.09658180f, -0.04301002f, -0.02183636f, -0.01693872f, 0.05045523f, 
    -0.03703198f, 0.01379622f, -0.04802591f, -0.01137434f, -0.02302556f, 0.01104546f, 0.11014287f, 0.02146778f, 
    -0.01202227f, -0.07814817f, 0.01250010f, 0.05179195f, 0.16308594f, -0.06869171f, -0.15125303f, 0.01897581f, 
    0.00473741f, -0.02139298f, -0.04099392f, 0.00252290f, 0.04650600f, -0.05049312f, -0.00611889f, 0.16213985f, 
    0.05615439f, 0.00726168f, -0.00482771f, 0.04119325f, 0.24915278f, 0.07384899f, -0.16861194f, 0.02669672f, 
    0.16442901f, -0.09496497f, 0.12228803f, -0.05817145f, 0.00836172f, 0.06257576f, -0.01274253f, 0.12108436f, 
    0.00412247f, -0.04874031f, -0.06486677f, 0.03020884f, -0.06011425f, 0.07577956f, -0.00721668f, 0.03404669f, 
    0.04626655f, -0.01170862f, -0.01401512f, -0.01501593f, -0.01007829f, 0.02633432f, -0.05659773f, -0.00677432f, 
    -0.03353042f, -0.00571259f, 0.04509031f, -0.06053890f, -0.03390937f, 0.00519323f, -0.02017543f, -0.00542197f, 
    0.04047451f, -0.00956401f, 0.03048014f, 0.01952757f, -0.03321578f, -0.00761027f, 0.00360914f, 0.00471695f, 
    0.00950635f, 0.00210600f, -0.02479883f, 0.00644419f, -0.03698293f, -0.04142258f, -0.06027491f, -0.04295813f, 
    -0.02078125f, -0.04331449f, 0.03813353f, 0.03141343f, -0.04018599f, 0.03495003f, 0.01547100f, -0.04364366f, 
    0.00925923f, 0.01456206f, -0.05319645f, -0.03306284f, 0.03187256f, -0.00424043f, -0.01653621f, -0.02823878f, 
    -0.06105341f, -0.05922752f, 0.00797208f, -0.00383668f, 0.01532808f, -0.05465157f, 0.02893478f, 0.02307212f, 
    -0.01916633f, 0.01028039f, 0.02333293f, -0.01287155f, -0.01732219f, 0.01517879f, 0.00869234f, -0.02399856f, 
    -0.05336778f, -0.00710608f, -0.04631257f, 0.00106442f, -0.01146009f, -0.00754434f, -0.05508970f, -0.04670850f, 
    -0.04128266f, -0.02131010f, 0.04671460f, -0.06029267f, -0.04293263f, -0.00293662f, 0.02071304f, -0.02112297f, 
    0.00818313f, -0.02331954f, 0.04941235f, -0.02728621f, -0.02949177f, -0.03196289f, 0.00714712f, -0.00463424f, 
    0.03589787f, -0.03818030f, -0.03198623f, 0.00037961f, -0.05101349f, 0.04389635f, -0.02898177f, 0.02946490f, 
    -0.00817967f, 0.04967574f, 0.01417631f, -0.00047045f, -0.05514815f, 0.01823054f, 0.00513296f, -0.01530353f, 
    0.03140107f, -0.05042531f, -0.00115724f, -0.04148664f, -0.02460919f, -0.03084340f, -0.01736301f, -0.03393144f, 
    -0.01031176f, -0.04840542f, 0.00554880f, 0.02154354f, -0.03558424f, -0.02624046f, 0.04306204f, -0.02703270f, 
    0.03403349f, 0.00066522f, -0.05233522f, 0.03203730f, 0.03588060f, -0.04004551f, -0.04070100f, 0.03576835f, 
    -0.03943978f, 0.02329998f, -0.01276366f, -0.03831254f, -0.01239498f, -0.04120673f, 0.02888529f, -0.01280639f, 
    0.04813156f, -0.01615852f, -0.03342620f, -0.05800549f, 0.02451679f, -0.03850373f, -0.05945425f, -0.01800811f, 
    0.03032229f, -0.06071858f, -0.03139899f, -0.02024113f, 0.02371225f, -0.04133587f, -0.04228823f, 0.03292205f, 
    -0.00704526f, 0.02707318f, 0.02773015f, 0.02114127f, -0.03172795f, 0.03129023f, -0.02302352f, 0.02863847f, 
    -0.05957469f, 0.01345912f, -0.02348583f, -0.00552264f, 0.01006316f, -0.03429270f, 0.03721153f, -0.03800000f, 
    -0.00951510f, -0.03549637f, 0.05350179f, -0.02596408f, -0.00656736f, 0.02113375f, -0.00599420f, -0.01470384f, 
    0.00187950f, 0.02709995f, 0.04917073f, -0.00827225f, -0.00246810f, -0.01392541f, 0.04338076f, 0.03404526f, 
    -0.00049721f, -0.00143549f, 0.04543922f, 0.00588288f, -0.00854950f, -0.02178972f, -0.01229567f, 0.04570979f, 
    -0.03882698f, -0.01179284f, 0.02821816f, -0.01306244f, -0.05980277f, -0.02064239f, -0.03530298f, 0.04914051f, 
    0.01832348f, 0.04053290f, -0.02423852f, -0.01010948f, -0.01366260f, -0.01678653f, -0.04749971f, -0.04033732f, 
    -0.04326096f, 0.00026190f, 0.01616857f, 0.02838995f, -0.03793279f, -0.00490261f, -0.01092784f, 0.01879774f, 
    0.02090536f, 0.02942898f, -0.00921168f, 0.04130325f, 0.02096056f, 0.02990871f, -0.01923154f, -0.02377280f, 
    -0.05190831f, -0.05325497f, 0.01450757f, -0.01959707f, 0.04136736f, -0.01522269f, -0.05881724f, -0.01011775f, 
    0.04465340f, -0.01041194f, -0.02732393f, -0.04314375f, 0.04941507f, -0.02761075f, 0.01555787f, -0.05014657f, 
    0.01001718f, -0.05322217f, 0.04647187f, 0.03496659f, 0.02831034f, 0.03689117f, -0.02264325f, -0.04261223f, 
    -0.03065588f, -0.00398583f, -0.03188053f, -0.03254455f, 0.04869907f, -0.05554933f, -0.03256160f, 0.03389883f, 
    -0.00396775f, 0.02005100f, -0.00142853f, 0.04535979f, -0.04072312f, -0.03677078f, 0.03668062f, -0.00696309f, 
    -0.06091160f, -0.03630010f, -0.01558503f, 0.01849262f, -0.05095381f, -0.00611143f, 0.04034814f, 0.04819851f, 
    -0.01015404f, -0.03531824f, -0.01791952f, 0.02473779f, -0.01291446f, -0.01777529f, 0.00149660f, 0.00028250f, 
    -0.04416282f, -0.01601965f, -0.03948337f, 0.04351706f, -0.00389183f, 0.02684727f, 0.04384070f, -0.01601532f, 
    -0.01083681f, 0.02648209f, -0.01129024f, -0.03078390f, 0.00456418f, -0.05106992f, -0.01054119f, -0.06025990f, 
    -0.04435422f, -0.02387781f, -0.04347437f, 0.03037635f, -0.01299418f, -0.02613793f, -0.06118940f, 0.03585364f, 
    -0.05034595f, 0.00436298f, -0.01247189f, -0.02468270f, 0.03967555f, 0.01418298f, -0.04353661f, -0.04968734f, 
    0.00680435f, -0.03120575f, 0.01081634f, 0.03883428f, 0.04665994f, 0.01560966f, 0.00213360f, 0.03298714f, 
    -0.02501787f, -0.12675008f, 0.03625144f, -0.19242458f, 0.14071330f, -0.06859116f, -0.01918788f, -0.06454705f, 
    0.05323381f, 0.09206246f, 0.06514683f, -0.04517488f, 0.01374334f, 0.00631356f, -0.01014758f, 0.03541644f, 
    0.02855494f, 0.03450789f, -0.07192388f, -0.00653565f, -0.14714104f, 0.05726182f, 0.29785764f, -0.15407449f, 
    0.01086185f, 0.05253313f, 0.09490583f, 0.06687103f, -0.00439720f, -0.01565839f, 0.04679238f, 0.03171697f, 
    0.01179703f, -0.02351752f, 0.01813512f, -0.03803626f, -0.04543124f, 0.03876854f, -0.07607298f, -0.07394972f, 
    -0.24288812f, -0.19005062f, 0.06339973f, -0.20661226f, -0.11867466f, 0.00113361f, -0.02816227f, 0.12192334f, 
    -0.04554543f, 0.03687883f, 0.08571064f, -0.06619203f, 0.05867831f, -0.02138295f, 0.10127025f, 0.03961256f, 
    0.03021633f, 0.04631323f, 0.08008607f, 0.07093826f, -0.28964755f, -0.05993147f, 0.02099136f, -0.08535130f, 
    -0.13243060f, 0.06128095f, 0.00122206f, 0.06264491f, -0.11475810f, 0.14338167f, 0.08019480f, 0.07960160f, 
    0.09973407f, 0.04909448f, 0.11203884f, 0.08826854f, 0.10004606f, -0.03962525f, 0.10567395f, 0.03308365f, 
    0.07501559f, -0.10043934f, -0.05800934f, 0.00232260f, 0.19294044f, -0.09089959f, 0.11030028f, 0.00242930f, 
    0.02920003f, 0.09086092f, 0.01112555f, -0.04745188f, 0.05330920f, 0.03293390f, 0.10165545f, 0.05373238f, 
    0.00547216f, -0.03543771f, 0.07763489f, 0.13049869f, 0.19457300f, -0.13197063f, -0.22747794f, 0.06124634f, 
    -0.05999154f, 0.16656847f, -0.09286494f, -0.00475485f, -0.00566979f, 0.20789857f, 0.06843919f, 0.07598226f, 
    -0.08759179f, 0.01223371f, 0.07473870f, 0.10773125f, 0.03766123f, 0.08911535f, -0.02732465f, 0.03605435f, 
    0.13219345f, 0.23598646f, 0.14242586f, -0.02426701f, 0.11456826f, 0.05484813f, 0.13631061f, 0.07852880f, 
    0.05478108f, -0.00354755f, -0.03574006f, 0.08959784f, 0.07023388f, 0.02116449f, -0.01163376f, 0.06591396f, 
    0.06740085f, -0.04520386f, 0.01381825f, 0.03904979f, 0.06505190f, -0.14711638f, -0.23681900f, 0.20411645f, 
    -0.07531743f, -0.06787376f, -0.00057338f, -0.00626284f, 0.02806648f, 0.05067405f, 0.04393426f, -0.02219821f, 
    0.01802611f, 0.00766039f, 0.08511592f, 0.06920260f, -0.02857298f, 0.04335960f, 0.04036561f, 0.15275739f, 
    -0.12009201f, 0.17987286f, 0.07799321f, -0.03324192f, 0.08470186f, 0.04109674f, 0.01250486f, 0.00798920f, 
    0.03445984f, -0.06236052f, 0.08006269f, 0.02080202f, 0.07536383f, 0.01747471f, -0.00799751f, -0.04894269f, 
    -0.05875035f, 0.00528111f, 0.01096049f, 0.05955111f, 0.15192497f, -0.09335968f, -0.12222195f, -0.06294336f, 
    0.06075495f, 0.08110205f, 0.14331980f, 0.01615918f, 0.02731314f, -0.05463555f, -0.10171376f, -0.01264065f, 
    0.01311570f, 0.19206193f, -0.06337053f, 0.01127017f, -0.05212242f, 0.03800518f, 0.02551530f, -0.07050283f, 
    -0.03158841f, -0.08745664f, 0.10948173f, -0.06607191f, -0.18582022f, 0.07358349f, 0.08174032f, 0.02076355f, 
    0.06284069f, 0.08384386f, 0.05994581f, 0.04419246f, 0.16880792f, 0.13774255f, 0.08667591f, -0.09797990f, 
    0.06001323f, 0.02225417f, -0.02441312f, 0.07683536f, -0.13304222f, 0.06754545f, -0.00844407f, -0.14392543f, 
    -0.16793628f, -0.03723952f, 0.06930134f, -0.01259975f, 0.00389741f, -0.03381630f, 0.03658743f, 0.00245021f, 
    0.09339253f, -0.02549577f, -0.11062722f, -0.05997911f, -0.03897102f, -0.04374439f, -0.02269775f, -0.02708252f, 
    0.12920335f, -0.09493903f, 0.02195361f, 0.06872754f, 0.00560474f, 0.07040685f, 0.08223057f, 0.06011150f, 
    0.03189355f, 0.04678262f, -0.05747447f, 0.04361266f, -0.06591374f, 0.06044515f, 0.11308676f, 0.05388073f, 
    0.04757925f, 0.08997636f, -0.03850502f, 0.01614021f, 0.14843349f, 0.11158835f, 0.09465198f, 0.01479851f, 
    0.10980238f, 0.05560834f, -0.01193509f, -0.01881301f, 0.10942475f, -0.00739430f, 0.04434358f, -0.01886282f, 
    -0.02803079f, 0.08745688f, 0.05163388f, 0.03383040f, 0.06787957f, 0.10890346f, 0.05441228f, 0.06693682f, 
    0.07329074f, 0.10988826f, 0.04414534f, 0.11046653f, 0.22006425f, 0.13132609f, 0.10930169f, -0.00970658f, 
    -0.00698317f, 0.04559079f, 0.04637618f, 0.02757040f, 0.05958473f, 0.09131860f, 0.01205999f, 0.06422897f, 
    -0.00988699f, 0.07700952f, 0.03721018f, -0.01808425f, 0.14106359f, 0.24841060f, 0.06605323f, 0.13883899f, 
    0.26924953f, 0.04955726f, 0.09845249f, -0.02530244f, 0.05577127f, 0.04901351f, -0.03957522f, 0.02737594f, 
    0.06961153f, 0.09779056f, 0.03692742f, -0.06141272f, 0.00545313f, 0.01963250f, 0.10135199f, 0.04626758f, 
    0.24672751f, 0.30610681f, -0.05930680f, -0.17685269f, -0.30530402f, -0.05776630f, 0.13569321f, 0.00890059f, 
    0.02665707f, 0.01923673f, -0.00174501f, 0.00912894f, -0.14230154f, 0.11914876f, 0.01952795f, -0.04412480f, 
    0.02554097f, 0.04841407f, 0.03596275f, -0.04270605f, 0.13589065f, -0.07932745f, -0.13052182f, 0.13146590f, 
    0.08713133f, -0.06774679f, -0.08372524f, 0.05134227f, -0.03688660f, -0.03573295f, 0.11872754f, 0.08094554f, 
    -0.03517616f, 0.03381348f, 0.07704917f, 0.06101518f, -0.00653903f, 0.09072652f, 0.02407654f, -0.03128071f, 
    0.15823257f, 0.09547485f, 0.08881541f, 0.04209857f, -0.05094041f, -0.01514640f, 0.08837521f, 0.04858129f, 
    -0.09768025f, -0.09163307f, 0.07302631f, 0.04448753f, -0.03641187f, 0.04035315f, 0.00877076f, 0.03574834f, 
    0.01734365f, 0.03476388f, -0.07760454f, 0.04752081f, 0.30925110f, 0.10747276f, -0.16245916f, 0.23404564f, 
    0.09864922f, 0.02120709f, 0.10182310f, -0.01366306f, 0.12913746f, -0.04612396f, 0.01649957f, 0.08814921f, 
    -0.07624947f, 0.01687646f, 0.06137760f, 0.01113276f, -0.03179400f, -0.03747312f, 0.04981681f, 0.10311469f, 
    -0.16675188f, 0.39510274f, 0.08692589f, -0.17571847f, -0.10618963f, 0.06480703f, -0.00936060f, 0.04886663f, 
    -0.06553263f, -0.00823598f, 0.02195436f, 0.00723757f, -0.09247575f, 0.08370791f, -0.09966729f, 0.02855625f, 
    0.09107089f, -0.20197140f, -0.05426678f, -0.09169414f, -0.14893618f, 0.13692153f, 0.20918679f, -0.25593144f, 
    0.01033061f, 0.04869652f, 0.10908518f, 0.14545432f, 0.11504051f, -0.03577685f, -0.08180379f, -0.16073361f, 
    0.12864554f, 0.20717022f, 0.04751096f, 0.00092493f, 0.03643275f, 0.02822480f, 0.00136553f, -0.14945921f, 
    -0.05209890f, -0.28001922f, -0.15396243f, -0.29455420f, -0.01465004f, -0.02130337f, -0.08377391f, -0.15124096f, 
    -0.04977461f, -0.02315596f, 0.15690592f, -0.09578814f, -0.08919661f, 0.03597149f, -0.00577436f, 0.01718070f, 
    -0.03451076f, -0.00797188f, -0.16869657f, -0.11467464f, -0.30115762f, 0.32765034f, 0.02844822f, 0.23835589f, 
    -0.04881475f, 0.13336664f, -0.07895793f, 0.01605785f, 0.06784743f, 0.08519074f, -0.02878834f, 0.08798400f, 
    0.03769587f, 0.09307411f, 0.01237475f, 0.07383289f, 0.07393325f, 0.01033184f, 0.04323833f, -0.13117272f, 
    -0.29277340f, -0.08375795f, -0.18839066f, -0.13624460f, 0.05238836f, 0.00825835f, -0.09093976f, 0.12335515f, 
    0.06572051f, -0.07432486f, -0.00812636f, -0.04310280f, -0.11168345f, -0.11753032f, -0.00192210f, 0.01794222f, 
    0.00199115f, -0.13646170f, -0.08236908f, -0.00835519f, -0.01797645f, 0.12143275f, -0.09440011f, 0.11307737f, 
    0.07785390f, -0.05815697f, 0.08748288f, -0.07663292f, 0.01577835f, -0.10629637f, 0.15588422f, 0.04991626f, 
    -0.08337418f, 0.03288442f, 0.04575470f, 0.00707096f, 0.01706840f, -0.06350470f, 0.02349281f, 0.10646189f, 
    0.10608077f, 0.05107373f, -0.01808855f, 0.25800243f, 0.08405682f, -0.06964358f, -0.03016001f, -0.11164016f, 
    0.05732560f, -0.06153241f, -0.12655608f, 0.06848219f, 0.00941859f, -0.03968991f, 0.09975161f, 0.07852896f, 
    0.01320253f, 0.03102727f, 0.08660390f, 0.06561695f, 0.00044694f, 0.09487596f, 0.00330037f, 0.17961144f, 
    0.19608931f, 0.05624114f, 0.07376067f, -0.01447767f, -0.03720004f, -0.01381512f, -0.07289878f, 0.12381721f, 
    0.00519671f, -0.00260541f, 0.04978441f, 0.00039904f, 0.06524328f, 0.01645686f, 0.21079612f, -0.03880366f, 
    -0.09553554f, 0.05577385f, 0.01318098f, 0.03306169f, 0.00184722f, 0.04352305f, -0.10844530f, -0.07182232f, 
    0.04530219f, -0.07207311f, 0.18053231f, -0.01562726f, 0.11766629f, 0.05480656f, -0.00046051f, -0.00540706f, 
    -0.06319788f, 0.10949998f, 0.09457271f, 0.06937636f, 0.12326159f, -0.07216595f, -0.03188030f, 0.05480032f, 
    -0.11977809f, 0.15010519f, -0.06821828f, 0.07938788f, -0.18030229f, 0.06533831f, 0.07211494f, 0.16054669f, 
    0.06206110f, 0.02125614f, -0.00667345f, -0.05685945f, 0.08819176f, -0.00321050f, -0.12333263f, -0.07590774f, 
    0.15933783f, -0.12360131f, -0.06000650f, -0.28652692f, 0.00439577f, -0.10023270f, -0.02765395f, -0.05184472f, 
    -0.02973541f, 0.00611561f, 0.05501678f, -0.02573936f, 0.05454394f, 0.11099499f, 0.07705978f, -0.03651581f, 
    0.03520722f, -0.05791543f, -0.10318869f, 0.05550116f, -0.13683228f, -0.00500267f, 0.07480148f, -0.35231420f, 
    -0.12955981f, -0.07167894f, 0.14049840f, -0.06765479f, -0.03841501f, 0.13439564f, 0.13139276f, -0.02435565f, 
    0.05473134f, -0.00738938f, 0.07946502f, 0.08652242f, 0.07661923f, 0.02484675f, -0.17900556f, 0.05146749f, 
    0.03116354f, -0.00411060f, -0.03243366f, -0.05263486f, -0.00736444f, 0.01729094f, -0.05733537f, -0.01267143f, 
    0.03256493f, 0.04319976f, 0.01760732f, 0.01449255f, -0.02759206f, 0.02079598f, 0.04031145f, -0.01522673f, 
    -0.05239665f, -0.01406620f, 0.04858556f, -0.00292694f, -0.04022948f, -0.04429854f, -0.03937525f, -0.03446300f, 
    0.01156260f, -0.04940014f, -0.04845082f, -0.03383553f, 0.02920974f, -0.00252000f, -0.03522135f, -0.00264240f, 
    -0.02581501f, -0.02442268f, -0.01641173f, 0.01698958f, 0.03207952f, 0.03257538f, -0.02363492f, 0.01939250f, 
    0.00184312f, -0.06139338f, 0.02101596f, 0.04125977f, 0.01229705f, 0.04517296f, -0.05426738f, 0.02140498f, 
    -0.02110070f, -0.04925422f, -0.02068169f, -0.00410746f, 0.04417609f, -0.04911511f, -0.01942457f, 0.02605957f, 
    0.02968819f, 0.01806226f, -0.02737884f, -0.00332574f, 0.01308400f, -0.00989890f, -0.02371329f, 0.02452753f, 
    -0.05525123f, -0.03985279f, -0.05603932f, -0.02103023f, 0.04613727f, 0.02910096f, 0.01457463f, -0.05423162f, 
    0.03657541f, -0.00140975f, 0.03695833f, 0.00447739f, -0.00516478f, -0.00503592f, 0.01246043f, 0.02487908f, 
    -0.04986439f, -0.06032147f, 0.03975536f, 0.04594888f, 0.03601072f, -0.02794188f, 0.00221272f, -0.04743896f, 
    0.04545806f, -0.04985328f, -0.03106884f, -0.02215773f, -0.05746527f, -0.05304607f, -0.03303541f, 0.00662953f, 
    -0.02929106f, 0.03780460f, 0.00162331f, 0.04671666f, -0.04370423f, -0.01038792f, -0.02171084f, 0.03278856f, 
    0.00525167f, 0.03385936f, 0.04127832f, 0.04735854f, -0.05738874f, -0.04457497f, 0.02735898f, -0.01214127f, 
    -0.05223542f, 0.04986867f, -0.01866365f, 0.02733926f, -0.02686996f, 0.00976119f, -0.01939595f, -0.01428311f, 
    0.02820241f, -0.05819003f, -0.01942737f, -0.05720502f, -0.04096830f, -0.04691584f, -0.03849426f, 0.00261543f, 
    0.03801817f, -0.05104041f, -0.00957210f, -0.00175192f, 0.01551943f, 0.04647420f, -0.03387397f, -0.03860456f, 
    0.02187560f, -0.01402222f, -0.03314388f, -0.05719407f, 0.04244597f, 0.01237358f, 0.01404043f, -0.03148219f, 
    -0.05624413f, 0.04633322f, -0.03807586f, 0.04456851f, 0.01519473f, -0.02501659f, 0.04819992f, -0.01691220f, 
    0.03567521f, -0.00141848f, -0.03505727f, -0.04062254f, 0.01957853f, -0.04055415f, 0.03006833f, -0.02967009f, 
    -0.03717850f, 0.02831381f, 0.04734688f, -0.02122377f, -0.00793114f, -0.03542260f, 0.02037323f, 0.00119826f, 
    -0.05539155f, 0.01856679f, 0.00235696f, -0.06042464f, -0.00178244f, -0.05124002f, -0.02667248f, -0.01900529f, 
    -0.05498498f, -0.03484579f, -0.05941279f, 0.03485892f, -0.04372855f, 0.01437089f, -0.01376680f, -0.06084732f, 
    -0.05523426f, -0.01021902f, 0.02972086f, 0.03045698f, -0.00971396f, 0.02648704f, 0.02658195f, 0.02167393f, 
    -0.02472086f, -0.01556431f, -0.04338531f, 0.00882197f, -0.05845298f, 0.04697544f, -0.05443981f, -0.05440525f, 
    -0.02775676f, -0.04467769f, 0.01740770f, -0.03378878f, 0.03063983f, -0.01609525f, 0.04788664f, 0.01966946f, 
    0.04533537f, -0.00419320f, 0.00051700f, -0.04540474f, 0.00751128f, -0.05536647f, -0.05759083f, -0.04698530f, 
    -0.00167327f, -0.04164531f, 0.01531895f, 0.00658436f, 0.01248373f, -0.02226338f, 0.00140831f, -0.02930016f, 
    -0.02235307f, 0.03714350f, 0.01142400f, -0.05175206f, 0.01755200f, 0.04165857f, -0.04758201f, -0.00734824f, 
    -0.03014690f, 0.04913673f, 0.02949497f, 0.04182101f, 0.02721254f, 0.01633387f, 0.01595379f, -0.02830066f, 
    0.04674275f, -0.05720469f, 0.04783484f, -0.02442803f, -0.05152932f, -0.04043205f, -0.02525810f, -0.05445451f, 
    -0.04846150f, -0.01704599f, 0.02397869f, -0.03140865f, -0.01174814f, -0.04271005f, -0.00056972f, -0.04711185f, 
    0.04193513f, -0.03870096f, -0.05255685f, -0.02591828f, 0.00395638f, -0.04168529f, -0.01060552f, -0.00873998f, 
    -0.01596827f, 0.04268951f, -0.05592055f, -0.02234532f, -0.00164642f, -0.00062990f, -0.00896610f, 0.01936744f, 
    0.01680211f, 0.04705335f, 0.01818214f, -0.02601959f, 0.01944301f, -0.03639662f, -0.04754357f, -0.01054928f, 
    -0.04613586f, -0.06081742f, -0.04475864f, 0.01916532f, -0.05941426f, 0.04581290f, 0.02382939f, -0.03974635f, 
    -0.02589238f, -0.04662431f, -0.00646606f, 0.01617881f, 0.03913779f, -0.04771162f, 0.04571473f, -0.04425813f, 
    -0.01456684f, 0.02907911f, -0.01855259f, 0.02887036f, 0.04181420f, 0.01762558f, -0.03587779f, -0.05093078f, 
    -0.00042493f, -0.01881604f, 0.03784280f, -0.01708550f, 0.03823143f, -0.05111335f, 0.04719375f, -0.05910888f, 
    -0.03138099f, 0.01319105f, -0.03957191f, -0.04272126f, 0.03303995f, -0.01055008f, -0.05383848f, -0.03609013f, 
    0.03121997f, 0.00617395f, 0.02691294f, 0.00209809f, 0.03054713f, 0.04433951f, -0.05863799f, 0.01578080f, 
    0.03355590f, 0.04426705f, 0.02006951f, -0.00897759f, -0.03641322f, 0.01685130f, 0.00242435f, -0.03950107f, 
    0.02556530f, 0.02993670f, 0.02804869f, 0.00207498f, -0.04549672f, 0.01107295f, 0.03347302f, 0.05131212f, 
    -0.03143688f, -0.04158309f, -0.03661855f, -0.02122310f, -0.02339209f, 0.04614060f, -0.02746616f, -0.05272368f, 
    0.04177935f, 0.04491127f, 0.03529885f, -0.01529610f, -0.00223476f, -0.00395334f, -0.05732930f, -0.05432336f, 
    -0.00361907f, -0.02710487f, 0.01570920f, 0.00298009f, -0.03471499f, 0.04076625f, -0.01578743f, -0.01349789f, 
    -0.00330729f, -0.02130834f, -0.01745975f, -0.00593745f, -0.02076843f, -0.02731810f, -0.02181366f, -0.04472479f, 
    -0.02466927f, -0.03507639f, -0.05603420f, -0.02797053f, -0.01534298f, 0.01010404f, -0.00491521f, 0.01348136f, 
    -0.04365423f, -0.01643643f, 0.03499001f, -0.02530438f, 0.01236192f, 0.04583882f, 0.01477009f, 0.04478267f, 
    -0.01388852f, -0.01416699f, 0.01751310f, 0.03988818f, -0.03715546f, -0.03242789f, -0.03286785f, 0.02572764f, 
    0.01598648f, -0.01294234f, -0.04021769f, -0.05061692f, 0.01901028f, 0.00983912f, -0.00538153f, -0.00017274f, 
    0.03434926f, 0.00883827f, 0.02588402f, 0.02122148f, -0.01695606f, 0.03464485f, -0.01333900f, -0.04646152f, 
    -0.05985686f, 0.00092088f, 0.01216954f, -0.05917842f, -0.04095965f, 0.02644033f, 0.00526107f, -0.01150574f, 
    -0.01853344f, 0.01528674f, 0.01506875f, 0.04228710f, 0.01167881f, -0.01872075f, 0.03494506f, -0.04755837f, 
    -0.04361982f, -0.06074208f, 0.00413569f, -0.05532689f, -0.04375841f, -0.02772290f, 0.01897263f, -0.04374789f, 
    -0.01603753f, -0.01263575f, 0.03612129f, -0.05645979f, -0.01706932f, 0.02149207f, -0.03210500f, 0.00966952f, 
    -0.01357439f, -0.02171730f, 0.03491346f, -0.01042365f, 0.00191667f, 0.03528112f, 0.01219671f, -0.05334823f, 
    0.01536880f, -0.03266090f, 0.03719700f, -0.02138881f, -0.02329375f, -0.02915225f, -0.02907405f, -0.05157932f, 
    -0.05255249f, -0.00286639f, 0.04827147f, 0.03421547f, 0.03127139f, -0.02364677f, -0.04932139f, -0.01148004f, 
    -0.02461550f, 0.02424332f, -0.00577103f, 0.01970637f, -0.03365648f, 0.03338644f, -0.05178305f, 0.00786783f, 
    -0.05687231f, 0.01756825f, -0.02542374f, -0.02553552f, -0.01391840f, -0.01766479f, 0.03807252f, -0.03612658f, 
    -0.04043872f, 0.02120224f, -0.00966190f, 0.04613537f, -0.04360632f, 0.00174596f, 0.01102272f, -0.01992614f, 
    -0.06252500f, 0.03223859f, -0.01400376f, 0.05280398f, -0.06508173f, 0.04160159f, 0.01964618f, 0.01382355f, 
    -0.00125566f, 0.03545384f, 0.02248077f, 0.01537789f, 0.00338853f, -0.04717498f, -0.03747592f, 0.01685089f, 
    -0.01925601f, -0.01544973f, -0.00293635f, -0.00418365f, 0.03168911f, 0.03168686f, -0.03704996f, -0.06025438f, 
    -0.02585723f, -0.04834661f, -0.05353790f, 0.00355095f, 0.00003764f, 0.00229233f, -0.05667985f, 0.01191155f, 
    -0.03498254f, -0.05899180f, -0.02965971f, 0.03630567f, -0.01122508f, 0.01534442f, 0.00981530f, -0.01751228f, 
    0.01685794f, 0.04734005f, -0.01930250f, -0.05226057f, -0.05163702f, -0.01148304f, 0.04049199f, -0.04689438f, 
    -0.05799259f, 0.02002508f, -0.00420125f, -0.02627085f, 0.02771793f, -0.05702307f, 0.00918239f, -0.03707625f, 
    -0.00218984f, 0.04682444f, 0.02278566f, 0.03269503f, -0.02386377f, 0.04815110f, 0.01488112f, 0.01869480f, 
    0.01900853f, 0.01661964f, 0.01659353f, 0.02955365f, 0.02586398f, 0.04017011f, 0.03441212f, -0.00742259f, 
    -0.02511718f, -0.03105696f, 0.00420955f, -0.00443850f, -0.02909793f, -0.01798900f, 0.01446192f, -0.05635536f, 
    0.04510661f, 0.01374474f, -0.02427433f, 0.01310688f, 0.02574570f, -0.01735502f, -0.02331158f, -0.00232268f, 
    -0.01335284f, -0.02887630f, 0.02469119f, -0.03606572f, -0.05305880f, 0.02963634f, -0.03480246f, -0.06086710f, 
    0.02108042f, -0.00030051f, 0.02969638f, 0.02818732f, -0.01977916f, 0.03642882f, 0.04752338f, -0.01929090f, 
    -0.02619776f, 0.02417497f, 0.03151911f, -0.04135767f, 0.02752420f, -0.01027007f, -0.03587347f, 0.02784996f, 
    -0.01699765f, -0.01237707f, 0.01803559f, -0.05552787f, -0.05711604f, 0.02858210f, -0.02801907f, -0.00779886f, 
    -0.02165314f, -0.06227420f, 0.01283207f, 0.04619560f, 0.04149602f, -0.00805234f, -0.05373748f, -0.04322360f, 
    -0.02265786f, 0.01234893f, -0.04620472f, -0.03527842f, -0.05683800f, 0.03513489f, 0.04139042f, -0.03728720f, 
    -0.05124679f, 0.01632658f, -0.00037283f, -0.04404701f, -0.02855654f, -0.05093654f, 0.03921821f, -0.00451816f, 
    -0.31982347f, -0.22900881f, 0.01682613f, 0.14151762f, -0.07024369f, -0.01862967f, -0.03782423f, -0.01337830f, 
    -0.06428851f, -0.00026609f, -0.04628063f, 0.04170237f, 0.10597976f, -0.02733543f, -0.01162301f, 0.10080236f, 
    -0.01111603f, -0.04635075f, 0.02867881f, 0.01057330f, 0.31325373f, -0.03735019f, -0.24748322f, 0.28426448f, 
    0.04738248f, 0.06053989f, 0.05730417f, 0.08344850f, -0.04196598f, -0.05758381f, 0.00347194f, -0.13389970f, 
    0.11524489f, 0.09145327f, 0.00025868f, -0.01737083f, 0.03335318f, -0.09807806f, -0.11364278f, 0.00255707f, 
    -0.10583556f, 0.00918940f, -0.13886447f, 0.05182832f, 0.13174622f, 0.10911780f, -0.17531896f, -0.00361393f, 
    0.03795454f, 0.06015811f, 0.06174013f, 0.04104959f, 0.04323418f, -0.07273005f, -0.11163078f, 0.02014379f, 
    -0.01140565f, -0.13034746f, 0.10381798f, -0.06370796f, -0.13943766f, 0.24405998f, 0.28432932f, 0.09652271f, 
    0.14768350f, -0.14218935f, 0.07224771f, 0.09005755f, 0.02804634f, 0.01981660f, 0.10221992f, -0.03180975f, 
    0.01516990f, -0.01767928f, -0.12290084f, -0.17809507f, 0.03615357f, -0.03688831f, 0.09606753f, -0.03076896f, 
    -0.16543055f, 0.05687493f, -0.09429505f, 0.05463400f, -0.02302676f, -0.01592761f, -0.06077904f, 0.00178245f, 
    -0.09031411f, -0.02076231f, 0.02708664f, -0.04165788f, -0.05336965f, 0.02724294f, -0.06819393f, 0.11317530f, 
    -0.09630796f, 0.06115538f, -0.07925209f, -0.01009051f, 0.14514677f, 0.11671960f, 0.17658748f, 0.06274757f, 
    0.07105372f, 0.02333435f, 0.09879118f, -0.07888660f, 0.06219203f, -0.07618444f, -0.00910878f, 0.02395943f, 
    -0.15440677f, -0.05591212f, 0.00378422f, 0.04958203f, 0.00731330f, -0.02009805f, -0.00337073f, -0.00876947f, 
    0.24531285f, 0.02824455f, 0.15878661f, 0.16483806f, 0.09027035f, 0.03107591f, 0.02726055f, 0.07208771f, 
    -0.07171381f, -0.05839015f, -0.02718796f, -0.02794010f, -0.00978661f, -0.01685362f, -0.03970829f, 0.00988382f, 
    -0.00896349f, -0.08780669f, 0.00465443f, -0.00623679f, 0.55511159f, -0.03701733f, 0.25370222f, -0.09979345f, 
    0.13482843f, -0.07802580f, 0.16441800f, 0.05291248f, 0.10173661f, -0.00747197f, 0.09888440f, -0.02073287f, 
    -0.00466575f, 0.01893895f, -0.09027494f, 0.08822867f, 0.06202444f, 0.03097809f, 0.08468132f, 0.06276385f, 
    0.48019114f, 0.18655062f, -0.03217452f, -0.01392635f, -0.11105654f, 0.00275996f, 0.08356426f, -0.00457856f, 
    0.00918150f, 0.00375475f, 0.05566237f, 0.07689038f, 0.05679140f, 0.05209621f, -0.08104168f, -0.01346242f, 
    0.14443748f, 0.00781614f, -0.05897070f, 0.04108773f, -0.03325608f, 0.22178367f, -0.05763187f, -0.11923824f, 
    -0.07188141f, -0.02580396f, 0.00341915f, -0.03502649f, -0.01635036f, -0.02075109f, -0.01405826f, -0.07687471f, 
    -0.03653035f, 0.13307285f, -0.02818510f, -0.00140916f, -0.05447109f, 0.03947709f, 0.02999774f, 0.02964645f, 
    -0.06038172f, 0.17967768f, -0.12545459f, -0.28939104f, 0.21826136f, 0.15329091f, -0.00997571f, -0.03680248f, 
    0.04364742f, -0.05306404f, 0.10521448f, 0.05257812f, 0.08467522f, 0.05650895f, 0.01514916f, -0.01430596f, 
    0.04039657f, 0.08387755f, -0.10379387f, -0.01454709f, 0.26885194f, -0.18218261f, -0.02515094f, -0.02104046f, 
    0.10149752f, 0.06501353f, 0.14745946f, -0.03716714f, 0.06990138f, -0.12961732f, 0.00737577f, -0.06137528f, 
    -0.04955008f, 0.11421341f, 0.13899171f, 0.01121886f, 0.06720369f, -0.00922104f, -0.05609272f, -0.01448872f, 
    0.02296890f, 0.16971876f, 0.03285636f, -0.21582094f, 0.09059492f, 0.04589377f, 0.02311311f, -0.04456144f, 
    0.07236989f, 0.14769372f, -0.02225754f, -0.03369983f, 0.10504601f, 0.05501183f, 0.01625639f, -0.00773804f, 
    0.05585659f, -0.05434474f, -0.07099646f, -0.06759953f, 0.38592491f, -0.21837871f, 0.00449402f, -0.08862583f, 
    -0.05733620f, -0.08679561f, 0.02903352f, -0.04812007f, -0.04009711f, -0.00117590f, -0.02627059f, -0.00056064f, 
    0.00546816f, -0.01892699f, -0.00095667f, -0.07229838f, -0.00832546f, -0.13441595f, 0.02897899f, -0.06588496f, 
    0.22024168f, 0.09797060f, 0.00434404f, 0.03086120f, -0.04087121f, 0.03916172f, 0.02091767f, 0.05609177f, 
    0.00344025f, 0.04044421f, -0.02688294f, -0.01870437f, 0.03075105f, 0.11079258f, -0.08517084f, -0.00146557f, 
    -0.03978473f, 0.07427252f, -0.02249667f, 0.01192461f, 0.25942126f, 0.10994267f, -0.08316936f, 0.08815341f, 
    0.08398806f, 0.05908392f, -0.11108916f, 0.06555485f, -0.03910375f, -0.02282224f, -0.00979031f, 0.09485052f, 
    -0.08469158f, 0.11830285f, -0.09514092f, -0.00724818f, -0.01229080f, 0.08824521f, -0.06680889f, -0.08943421f, 
    0.14367095f, 0.01294814f, -0.12736237f, 0.01235129f, 0.16313513f, 0.04179560f, 0.01543100f, -0.05340124f, 
    0.02610017f, 0.04048024f, 0.08045200f, 0.00999642f, 0.04601627f, -0.03644704f, 0.06428198f, -0.00114138f, 
    -0.12481461f, -0.04704308f, -0.01258404f, 0.09721308f, 0.13555509f, 0.03718063f, -0.20545165f, 0.18127263f, 
    0.18021670f, -0.01000689f, 0.06216588f, 0.06800031f, -0.03409730f, -0.02087423f, 0.14873074f, -0.00054388f, 
    -0.02313533f, 0.00723172f, -0.02259422f, 0.01962717f, 0.04847485f, 0.01246791f, -0.06204423f, 0.07159079f, 
    0.19397765f, -0.10152311f, -0.15199527f, -0.12648124f, 0.17943265f, 0.07592646f, -0.13198686f, 0.00192533f, 
    0.04858954f, -0.04624157f, 0.08399788f, 0.04798201f, 0.00224374f, -0.07361008f, 0.03948843f, 0.02333933f, 
    -0.02749817f, -0.00743955f, 0.07738054f, -0.07103010f, -0.09993052f, 0.11839227f, 0.04300119f, 0.04206803f, 
    -0.02517336f, -0.08902092f, 0.04222869f, -0.06099450f, -0.07022380f, 0.08885939f, 0.03615270f, -0.05834208f, 
    -0.05556819f, 0.07848784f, 0.00771607f, -0.02363285f, 0.03135900f, -0.12147531f, 0.13799702f, 0.02773540f, 
    -0.07265431f, 0.24297908f, 0.01639267f, -0.16495785f, -0.01889900f, -0.09420575f, 0.08719721f, -0.00311645f, 
    -0.09446570f, 0.05925661f, -0.04998244f, -0.03092755f, 0.05405899f, 0.01502187f, 0.01957387f, 0.09652814f, 
    0.00077941f, -0.02860919f, 0.10878678f, 0.00177271f, 0.34744897f, -0.02622140f, 0.00896409f, -0.02858094f, 
    -0.02633023f, -0.02081521f, -0.07187621f, -0.06789028f, 0.09938630f, 0.03859048f, -0.00259665f, -0.02482066f, 
    -0.03503576f, -0.00286727f, 0.01332296f, 0.05660854f, 0.04345554f, -0.02637305f, 0.03101294f, 0.04592165f, 
    0.14419667f, -0.01398670f, 0.10284587f, -0.00340065f, 0.09920535f, -0.10259082f, -0.03729267f, 0.03956961f, 
    0.04070162f, -0.01528263f, 0.00474103f, 0.03719670f, 0.02412848f, 0.07348588f, -0.01492115f, -0.01370236f, 
    -0.04250932f, 0.01226148f, -0.06090531f, 0.06544214f, 0.42409179f, -0.18954717f, 0.09455281f, 0.10397638f, 
    -0.09580266f, -0.17913991f, -0.04060585f, -0.00981486f, -0.01930159f, 0.08115283f, -0.02113156f, -0.00173367f, 
    0.02621111f, 0.09124635f, 0.02894495f, 0.08505996f, 0.04720092f, 0.07117118f, -0.06423753f, 0.09694152f, 
    -0.05615364f, 0.30987754f, -0.05839336f, -0.06335894f, 0.19880827f, -0.03807420f, -0.10645608f, 0.01434660f, 
    0.02002843f, -0.07517230f, 0.02394512f, 0.06786939f, -0.02133124f, -0.02225369f, -0.04399782f, -0.01243539f, 
    -0.01730356f, 0.01528595f, -0.09572299f, 0.01281713f, -0.10517444f, 0.19180588f, -0.18942641f, -0.11634401f, 
    0.06206136f, 0.07273884f, -0.00339500f, -0.00786451f, 0.02560841f, -0.10598730f, -0.03126168f, -0.07192047f, 
    -0.09119688f, 0.13095079f, 0.02230601f, 0.03952467f, -0.01632472f, 0.05572374f, -0.01215339f, -0.06579604f, 
    -0.17109153f, -0.02328663f, 0.13069828f, -0.07506774f, -0.09486738f, 0.05329922f, 0.10356008f, -0.04544917f, 
    -0.02643649f, -0.02221088f, 0.00638847f, 0.00649392f, 0.07313012f, -0.03804481f, -0.05431836f, 0.04854907f, 
    0.07075414f, 0.01823933f, -0.10026650f, 0.07469252f, -0.15582746f, -0.09484161f, -0.12730755f, 0.12370773f, 
    -0.26524827f, 0.01751712f, 0.12720689f, 0.07120655f, 0.03589862f, -0.04157701f, -0.04516818f, -0.03500005f, 
    0.04886484f, -0.07143491f, -0.08020423f, -0.00451091f, -0.02746775f, -0.08769570f, 0.05520985f, 0.03012823f, 
    0.18722095f, 0.14838988f, 0.00058346f, -0.07890586f, -0.19049758f, 0.05049352f, -0.02179156f, 0.05019498f, 
    0.03896589f, 0.03139423f, -0.02594013f, -0.00951575f, -0.04901516f, -0.07218986f, 0.05339956f, 0.02150943f, 
    -0.00894041f, 0.05080881f, -0.01434058f, -0.07444488f, 0.32803282f, -0.30558771f, 0.03688117f, 0.01408882f, 
    0.06219337f, 0.04375075f, -0.01141850f, -0.04833507f, 0.01558737f, 0.05699214f, -0.02652008f, -0.04258104f, 
    0.00047134f, -0.02625640f, -0.05011541f, -0.07391548f, 0.00691679f, -0.02950583f, 0.09759820f, 0.00165529f, 
    0.05971827f, 0.09458172f, -0.09761675f, 0.03840537f, 0.24262074f, -0.01112970f, 0.04030523f, 0.09387109f, 
    0.03483094f, 0.08525295f, 0.04175226f, -0.00883067f, 0.03001205f, 0.03176583f, 0.07664014f, 0.10040643f, 
    0.02692079f, 0.03748623f, 0.03134433f, 0.00154279f, -0.01063977f, 0.19425453f, -0.01121720f, 0.09303562f, 
    0.18812762f, 0.02312178f, -0.04770604f, -0.02018027f, 0.06407904f, 0.02078471f, -0.10248600f, 0.08264218f, 
    0.05077134f, 0.06434111f, 0.02238088f, -0.01868302f, -0.07629406f, 0.02301311f, 0.00738955f, 0.07931870f, 
    -0.04565588f, 0.04733178f, 0.00508269f, -0.04067165f, -0.03999148f, 0.01711483f, 0.03716706f, 0.00716909f, 
    0.03043258f, -0.03058659f, 0.02003410f, -0.01999054f, -0.00054076f, -0.00085429f, 0.00335582f, 0.02700274f, 
    0.04303951f, 0.01267792f, -0.04901649f, -0.05226026f, -0.03332774f, 0.03099616f, -0.00297416f, 0.02688188f, 
    -0.03174988f, -0.00737022f, -0.02857032f, -0.06140090f, 0.01998963f, 0.02221024f, 0.00366357f, 0.03359290f, 
    0.03396689f, -0.03840244f, 0.02059310f, -0.05946452f, -0.02795738f, -0.05874745f, 0.00291216f, -0.01539568f, 
    -0.01757365f, 0.03317338f, 0.01123160f, 0.02253124f, -0.00228306f, 0.01308220f, -0.04508324f, -0.05785952f, 
    -0.04863375f, -0.04000875f, -0.02591656f, 0.04404679f, -0.00922076f, 0.00555571f, -0.03380389f, 0.04798901f, 
    0.02605666f, -0.05299912f, -0.02985275f, -0.05358212f, 0.03613868f, -0.03671896f, 0.00508977f, 0.01435768f, 
    -0.05928246f, 0.04657806f, 0.03944463f, 0.00700767f, 0.00539619f, -0.03281406f, 0.02470770f, 0.01926994f, 
    0.00078046f, -0.00646879f, 0.03388249f, -0.00912013f, 0.04748663f, -0.02237802f, 0.04691391f, -0.03431163f, 
    0.04886279f, 0.04326546f, -0.02962185f, 0.04510798f, 0.02093826f, -0.03628646f, 0.01564248f, 0.00773683f, 
    -0.05095291f, -0.00005573f, -0.04909021f, 0.02642966f, -0.03530196f, -0.02169379f, -0.05017563f, 0.01066588f, 
    0.00933398f, 0.03141759f, -0.03275175f, -0.05273198f, -0.04033356f, -0.05314049f, 0.04700647f, -0.06098864f, 
    -0.00296144f, 0.02651395f, 0.03094085f, -0.04289475f, -0.03454356f, -0.06049285f, 0.00576950f, -0.05368005f, 
    -0.04138178f, -0.04662563f, 0.04273494f, -0.05852611f, 0.02561444f, 0.01750008f, -0.01002487f, -0.00485471f, 
    -0.04403206f, 0.01270133f, 0.04409238f, -0.00224080f, -0.04592292f, -0.03161912f, 0.00444816f, -0.05336003f, 
    -0.00190960f, 0.00516752f, 0.03879464f, -0.03134840f, 0.01951650f, -0.02741111f, 0.02695153f, -0.04711609f, 
    -0.00507012f, 0.01541935f, -0.05715400f, -0.03257351f, -0.03157122f, -0.02547556f, 0.01210073f, -0.05869671f, 
    -0.00401967f, 0.02629383f, 0.03277740f, -0.01187935f, -0.01491708f, -0.05884240f, 0.01777432f, 0.05021615f, 
    0.02316731f, 0.03977902f, 0.04275498f, -0.02221415f, 0.02700252f, 0.02451013f, -0.03030769f, 0.01527954f, 
    -0.03206455f, 0.04108693f, 0.02099543f, 0.00690153f, -0.02461086f, -0.02136949f, -0.04988947f, 0.02125438f, 
    -0.01340565f, -0.02076867f, -0.00782383f, 0.03064691f, -0.00203029f, 0.05074936f, 0.01386533f, -0.03117697f, 
    -0.03362151f, -0.00349179f, -0.01243440f, 0.01917392f, -0.05339908f, -0.02988036f, -0.01723049f, 0.04708653f, 
    -0.03002522f, -0.03792491f, 0.05088328f, -0.02834775f, -0.00325321f, -0.04644970f, 0.03576643f, -0.03288765f, 
    0.00873808f, -0.02402367f, -0.00948718f, 0.01051661f, -0.05089243f, 0.02244141f, 0.03874782f, 0.00148236f, 
    -0.01083243f, -0.01479712f, 0.00842931f, -0.05691778f, -0.00763484f, 0.00296177f, -0.05540978f, 0.04016351f, 
    0.03654934f, -0.03802221f, -0.05856561f, -0.00513028f, 0.01763810f, -0.00681552f, 0.00961184f, 0.03270610f, 
    -0.02871059f, 0.04904445f, 0.05205674f, 0.02187882f, -0.04760613f, 0.04280957f, 0.04519352f, -0.05226462f, 
    -0.03379789f, -0.05094662f, 0.00041442f, 0.00893216f, -0.06366077f, 0.02879833f, 0.04970452f, -0.01784895f, 
    0.04694160f, 0.00464634f, 0.04926553f, -0.04808774f, 0.01745206f, -0.02525672f, -0.05093766f, 0.05169114f, 
    0.04432879f, 0.01124851f, 0.01470517f, 0.01505405f, -0.02926232f, 0.00320003f, -0.00922527f, -0.04630683f, 
    -0.04769184f, -0.05245196f, -0.03794268f, -0.01185461f, 0.00645997f, -0.02536077f, -0.02076903f, -0.02791077f, 
    0.01033559f, -0.00357457f, -0.00592144f, -0.01336292f, -0.00934645f, 0.02893149f, -0.02626192f, -0.02454660f, 
    -0.03094009f, -0.04323060f, -0.01777020f, 0.02248576f, -0.00532679f, -0.04697965f, -0.00740178f, -0.02173599f, 
    -0.01996120f, -0.01851896f, 0.00594998f, 0.03542479f, -0.06188250f, -0.01527415f, 0.00910732f, -0.05035040f, 
    -0.02838614f, -0.04700363f, 0.02703754f, -0.00209518f, -0.05096760f, -0.00950640f, 0.02070249f, 0.00423278f, 
    0.04432563f, 0.01241519f, -0.00914091f, -0.02985422f, 0.04197377f, 0.02110542f, -0.05065583f, -0.02555824f, 
    -0.05550771f, -0.05965482f, -0.00479985f, -0.05849333f, -0.01802787f, -0.00450013f, 0.03541346f, -0.03831602f, 
    0.03018049f, 0.04548254f, 0.03659905f, 0.04910145f, 0.03151722f, 0.02102319f, 0.03004484f, 0.02246139f, 
    0.02007955f, 0.02890522f, -0.01923729f, -0.02671307f, -0.02463992f, 0.04539914f, -0.01224460f, -0.05900624f, 
    0.03732670f, 0.02633358f, -0.05589296f, 0.04673452f, -0.05010935f, 0.04346158f, 0.03935276f, -0.04839233f, 
    -0.00759880f, -0.05982924f, 0.03563926f, -0.04221747f, 0.04625993f, -0.00577646f, -0.01522997f, -0.04034893f, 
    -0.06203153f, 0.03283729f, -0.02955622f, -0.05532825f, -0.01417455f, -0.03276908f, -0.05822303f, -0.02544367f, 
    -0.03587230f, 0.03914008f, -0.06126115f, 0.01888496f, -0.03515546f, -0.03240250f, -0.04143098f, -0.03876358f, 
    0.01262531f, 0.03777398f, -0.03246605f, -0.03501062f, 0.01091087f, 0.02822351f, 0.02650002f, 0.00313349f, 
    -0.03332013f, -0.01794229f, -0.04029335f, 0.00305513f, 0.04375403f, 0.00774081f, 0.01368468f, -0.03726201f, 
    0.01463042f, -0.01467801f, 0.00472621f, -0.01183133f, -0.00102417f, -0.04223225f, 0.04434144f, 0.04348888f, 
    0.00628764f, 0.01172637f, -0.02078449f, -0.00111785f, 0.01481808f, -0.02896987f, -0.02560430f, -0.05839051f, 
    -0.04142534f, -0.01200023f, 0.00983760f, -0.01407187f, 0.00080119f, 0.03310788f, -0.04571440f, -0.03491507f, 
    -0.00302069f, -0.00233386f, -0.05714376f, 0.00839479f, -0.01523138f, -0.00931653f, 0.00996646f, -0.05416353f, 
    -0.00787947f, -0.04888777f, 0.03155843f, 0.04176718f, 0.04697437f, -0.01044169f, 0.01458221f, -0.01037740f, 
    -0.04160265f, -0.04096610f, 0.04724440f, 0.04649230f, 0.00596818f, -0.01942215f, 0.01787595f, -0.04411425f, 
    -0.05204199f, -0.01158566f, 0.04300411f, -0.01409001f, 0.02395196f, -0.01834083f, -0.03639265f, -0.03768605f, 
    0.02893854f, 0.01126870f, -0.04336581f, -0.00419713f, -0.03900351f, -0.04108979f, -0.00554446f, 0.03101327f, 
    0.02567720f, -0.04194816f, -0.03234513f, -0.05341155f, -0.02201047f, -0.05222460f, -0.01322770f, 0.00115752f, 
    -0.05446481f, 0.02887562f, -0.00974861f, -0.02077198f, 0.01118915f, 0.02812865f, -0.05623469f, 0.00321318f, 
    0.02247958f, 0.01588176f, 0.00038282f, -0.04966356f, -0.01727057f, -0.03743267f, 0.04400167f, 0.00692665f, 
    0.01132539f, 0.00735384f, 0.01844081f, -0.00274953f, 0.01248611f, 0.04241461f, 0.04003076f, -0.01328341f, 
    -0.01816946f, 0.01229368f, 0.03181644f, -0.05337394f, -0.01041827f, 0.02441145f, 0.02919240f, -0.00898989f, 
    0.00083175f, 0.00738723f, -0.03391549f, -0.01085672f, 0.00501507f, 0.03264169f, -0.00388851f, -0.03313179f, 
    -0.04596385f, -0.03772520f, -0.00955202f, -0.04288936f, -0.01096183f, 0.00782261f, -0.06299949f, -0.06040655f, 
    0.03354636f, 0.01842037f, 0.01304666f, -0.01924523f, -0.02048702f, 0.04212731f, 0.01642117f, 0.01942400f, 
    -0.04781207f, 0.01395537f, -0.05817030f, -0.05893047f, -0.02792636f, -0.02746945f, 0.04469960f, -0.05449644f, 
    -0.04487787f, 0.03464135f, 0.01146785f, -0.03130470f, -0.04818840f, -0.03731907f, 0.02829168f, -0.04161551f, 
    -0.05191683f, 0.02705455f, 0.03752707f, 0.04572598f, -0.04509065f, -0.01401745f, 0.03847392f, -0.02421915f, 
    -0.05881875f, -0.05408264f, -0.02276883f, -0.04190082f, -0.04394585f, -0.05893644f, 0.00030738f, 0.01788576f, 
    -0.03810886f, -0.04379903f, -0.02148497f, -0.05931893f, -0.03795211f, 0.04702311f, 0.01463396f, 0.02848999f, 
    0.02650118f, -0.04872717f, -0.03857994f, -0.03545427f, 0.03797018f, -0.04979098f, -0.05108223f, -0.03538892f, 
    0.02862250f, 0.03743643f, 0.02015167f, -0.00532193f, -0.05393074f, -0.01306176f, -0.06091239f, -0.02062649f, 
    -0.01376602f, -0.05831738f, -0.02934260f, -0.02299245f, -0.02975242f, -0.01797255f, -0.05427361f, -0.02632536f, 
    -0.04721005f, -0.04043915f, 0.04230295f, -0.04971007f, -0.03628182f, 0.01447151f, -0.05675378f, -0.02518027f, 
    -0.03004813f, 0.01636264f, 0.02811897f, -0.03710959f, -0.02000318f, -0.05333217f, -0.04177870f, 0.01546372f, 
    0.00176451f, -0.00587841f, -0.03635341f, -0.03705094f, 0.00286018f, -0.03900505f, 0.01181500f, 0.04301778f, 
    -0.01188294f, -0.04733131f, 0.01424414f, 0.02890551f, -0.00377088f, 0.00174473f, 0.02432397f, -0.01550474f, 
    0.04244213f, 0.03847923f, 0.00663240f, 0.04067424f, 0.00536082f, -0.02442009f, -0.01412353f, -0.06249192f, 
    0.03226374f, -0.05242600f, -0.06106869f, -0.00383891f, -0.03403863f, -0.05244305f, -0.04174592f, -0.00506896f, 
    -0.05608852f, 0.02839714f, -0.04262081f, -0.05692827f, 0.03838632f, 0.01966371f, 0.00376728f, 0.00399615f, 
    -0.01265950f, 0.03730790f, 0.00979602f, -0.00272007f, -0.02720131f, 0.04191842f, -0.05650267f, 0.02556799f, 
    -0.02821150f, -0.05580619f, -0.00281014f, -0.04033641f, -0.01610337f, -0.05167617f, -0.00284003f, -0.00604343f, 
    0.00884887f, -0.01500432f, -0.02214008f, 0.04096929f, -0.06142492f, 0.00923337f, 0.00149510f, -0.03597210f, 
    -0.19720405f, -0.03512638f, 0.19871901f, -0.00763108f, 0.02390071f, -0.04315441f, 0.01985336f, -0.04867081f, 
    -0.02888986f, -0.04853665f, -0.02829986f, -0.02661726f, -0.00794998f, -0.04729301f, -0.06760007f, 0.08364844f, 
    0.11102702f, 0.05698942f, 0.03528335f, -0.08402006f, -0.00726703f, -0.03416366f, 0.17384821f, -0.31014922f, 
    -0.19360273f, -0.08306890f, 0.03125751f, -0.07680734f, 0.08385786f, -0.03352975f, -0.10871918f, -0.06898220f, 
    -0.00658606f, -0.04186273f, 0.05939804f, -0.04447545f, 0.02479147f, 0.06910224f, 0.04724804f, -0.01395332f, 
    -0.23644862f, 0.23021495f, 0.11859557f, -0.06635080f, -0.03396435f, -0.01709100f, 0.08389552f, 0.00204964f, 
    0.09893651f, 0.05799871f, -0.05603865f, -0.07400640f, 0.06125977f, 0.01473285f, 0.02864664f, -0.03120733f, 
    0.04557759f, 0.04595431f, 0.02778580f, 0.06253153f, 0.20219776f, -0.05707277f, -0.03402441f, -0.06320247f, 
    -0.04018902f, 0.07780647f, 0.02881435f, 0.09174787f, 0.00927220f, 0.04695434f, -0.00786752f, 0.01591786f, 
    0.13528417f, -0.00867000f, 0.05962209f, 0.07030843f, 0.02166464f, 0.22371343f, -0.16742060f, 0.01678436f, 
    0.14142437f, -0.33854306f, 0.00854612f, 0.17792924f, 0.06045689f, 0.13116239f, -0.09137253f, -0.07687989f, 
    0.04341207f, -0.09053519f, -0.01703960f, 0.00106953f, 0.00418244f, 0.02906555f, -0.05950725f, 0.04418251f, 
    0.00998808f, -0.11651465f, -0.00382024f, 0.07815739f, -0.32219145f, 0.08723148f, -0.05922706f, 0.09100390f, 
    0.05794430f, 0.19193554f, 0.16328114f, 0.04523255f, -0.06904166f, 0.04487214f, 0.06848208f, 0.07278795f, 
    0.00238889f, 0.00381731f, -0.05968737f, 0.06079071f, 0.02796076f, -0.04932512f, -0.05029093f, -0.02129942f, 
    0.05498302f, 0.17855529f, -0.00715710f, 0.01195915f, -0.00583119f, 0.10302104f, 0.03963257f, -0.01255541f, 
    -0.08914007f, -0.08267294f, -0.07894620f, 0.02336006f, -0.03768721f, 0.01471324f, 0.06908157f, 0.08046973f, 
    0.01667968f, -0.00112952f, 0.06413789f, -0.02788353f, -0.22672577f, 0.18241049f, -0.07955103f, -0.02160356f, 
    0.05897626f, 0.17445292f, 0.13871342f, 0.00540404f, 0.01424883f, 0.00037490f, -0.05117047f, 0.06733031f, 
    -0.06454702f, -0.06633794f, 0.03668433f, -0.00835590f, 0.02609448f, 0.04174700f, 0.01657426f, -0.02026562f, 
    0.20541464f, -0.31768256f, 0.21450971f, -0.01228939f, -0.20368542f, -0.04668899f, 0.05037471f, -0.13710763f, 
    -0.01485194f, 0.04560032f, -0.02316306f, -0.09176496f, -0.03151554f, 0.07310693f, -0.04726600f, -0.08458748f, 
    0.01304209f, -0.06181817f, 0.10841256f, 0.05168767f, 0.28325656f, -0.27770782f, 0.15686470f, 0.06579304f, 
    0.02864503f, -0.05322752f, -0.01224820f, -0.05896083f, 0.03752348f, 0.00119146f, -0.01246568f, -0.04894577f, 
    0.09450743f, -0.02445621f, -0.09352475f, 0.04580182f, 0.02282111f, -0.01557948f, -0.03208200f, 0.02841118f, 
    0.07360006f, 0.08256865f, -0.00777469f, 0.02241355f, 0.02630638f, -0.09105317f, -0.03149819f, 0.04563219f, 
    0.00312982f, 0.10061497f, -0.03792159f, 0.03380540f, -0.05987045f, -0.00506078f, 0.12418117f, 0.00358052f, 
    0.09085371f, 0.03352127f, 0.01174021f, -0.07385660f, 0.09236284f, 0.00506981f, 0.00150983f, -0.17257491f, 
    0.23174521f, 0.00235979f, -0.06649282f, -0.02358083f, -0.03910336f, 0.04261239f, -0.00879334f, 0.01537033f, 
    0.06767599f, 0.02417028f, 0.07555865f, -0.00779885f, 0.01733368f, 0.00513291f, -0.00563204f, 0.05732982f, 
    -0.05741557f, -0.11256939f, 0.01798766f, 0.12924218f, 0.22379062f, -0.00806262f, 0.01160485f, 0.00838987f, 
    0.01924312f, -0.05074565f, 0.02157443f, -0.02986275f, 0.07862576f, 0.02884657f, -0.05511489f, -0.05321702f, 
    -0.04568553f, 0.07689858f, 0.03781679f, 0.15133876f, -0.21031703f, 0.37369406f, 0.03202382f, 0.04744843f, 
    0.10202256f, 0.06701931f, 0.07861745f, 0.02229310f, 0.02578660f, -0.05286314f, 0.03529918f, 0.02465925f, 
    0.00125869f, 0.01228301f, 0.08927197f, 0.13104711f, 0.09069525f, 0.02407175f, -0.09864584f, 0.04951968f, 
    0.01092898f, -0.06296281f, 0.01671231f, -0.04668325f, -0.11184581f, 0.00759578f, 0.00998090f, -0.07643124f, 
    -0.03873592f, -0.13787550f, -0.02544126f, -0.02419931f, 0.01807708f, -0.01520327f, -0.02213618f, 0.04248506f, 
    -0.02594450f, -0.05662389f, -0.04341155f, -0.04929449f, 0.14313574f, -0.10951578f, 0.02291137f, 0.09695196f, 
    -0.17258896f, -0.04353312f, 0.13000618f, 0.05077705f, 0.03842259f, -0.02641032f, 0.02928542f, -0.13742292f, 
    0.00838892f, 0.05323407f, 0.05152424f, 0.07549106f, 0.05509214f, 0.00090118f, -0.01569295f, 0.01478515f, 
    0.03350319f, 0.10239962f, 0.06926308f, -0.15610385f, -0.04522685f, -0.00536592f, -0.08159670f, 0.01597860f, 
    0.16194701f, 0.01895102f, -0.01394366f, 0.09824673f, 0.00658031f, 0.05719714f, -0.05433594f, 0.06520213f, 
    0.07696227f, 0.07853797f, -0.07783219f, 0.03810116f, -0.18488906f, -0.11217833f, 0.12470775f, 0.00178777f, 
    0.01367600f, -0.10712072f, -0.00792489f, -0.01281958f, -0.11352172f, -0.12612073f, -0.02087038f, 0.04742221f, 
    0.00986411f, -0.06287239f, -0.03861843f, -0.03571722f, 0.09661742f, 0.02918112f, -0.01244860f, -0.05872551f, 
    -0.18618460f, 0.18639575f, 0.20580719f, -0.15956995f, -0.00473607f, -0.06223395f, -0.01907028f, 0.05522338f, 
    0.01190344f, -0.06578861f, -0.10542928f, 0.02547348f, 0.05304966f, 0.09151807f, -0.02000623f, 0.00364389f, 
    0.02502506f, -0.00212981f, -0.07418286f, 0.06112639f, 0.10325311f, 0.13472857f, 0.03245533f, 0.07801263f, 
    0.13881099f, 0.09577995f, 0.06009299f, -0.00155097f, 0.07363201f, 0.01069320f, -0.09501703f, 0.05169357f, 
    -0.14769101f, 0.02216295f, 0.18057521f, 0.12217435f, -0.05236036f, 0.07136087f, -0.05782266f, 0.01722114f, 
    0.64132422f, 0.03673917f, 0.14199537f, 0.01379703f, -0.02123568f, 0.00627721f, -0.04873085f, 0.04673871f, 
    0.02440390f, -0.02382452f, -0.09611602f, -0.04889927f, 0.04140444f, 0.02143139f, -0.07864530f, 0.04133132f, 
    0.03423964f, -0.18056343f, -0.08657377f, 0.01750662f, -0.19472706f, 0.09223473f, 0.32340863f, 0.08355135f, 
    0.29188237f, 0.05713303f, 0.05435940f, 0.03758080f, 0.07852504f, 0.16397002f, 0.02781690f, 0.06611292f, 
    0.02710232f, 0.21721168f, -0.09338769f, 0.00923820f, -0.09515184f, 0.06284354f, 0.02605454f, 0.04923536f, 
    -0.02764951f, 0.20866235f, 0.07957465f, -0.28201434f, 0.00545042f, -0.11907117f, -0.06375255f, -0.08279236f, 
    -0.02378546f, -0.06191533f, -0.05607228f, -0.04891860f, -0.11890735f, -0.03394179f, 0.01888287f, -0.00189545f, 
    -0.00670041f, -0.01154613f, -0.04542888f, -0.02417736f, 0.25651568f, 0.14317738f, 0.21256275f, 0.14629345f, 
    0.14369699f, -0.04499517f, 0.06628250f, 0.00810428f, 0.00337363f, 0.13925277f, -0.01791367f, -0.03607938f, 
    -0.01397920f, 0.00366851f, -0.01898304f, -0.04321577f, 0.01942933f, 0.00273752f, 0.11038890f, -0.04263678f, 
    0.05177456f, -0.18117031f, 0.26561362f, -0.03192081f, -0.01127760f, 0.03236622f, 0.06747811f, 0.09053773f, 
    -0.10653123f, -0.05111977f, -0.00286658f, -0.02816084f, -0.17750181f, -0.10885888f, 0.01098540f, -0.02002127f, 
    -0.04692769f, -0.06073482f, -0.06917718f, 0.02179860f, 0.19569306f, -0.16053648f, 0.06903412f, 0.19608332f, 
    -0.09230777f, -0.01262461f, 0.13776895f, 0.00115065f, -0.14240876f, -0.10569235f, -0.00570506f, 0.03107554f, 
    -0.01674885f, -0.00030035f, -0.04062819f, 0.05454033f, 0.11928850f, -0.11397289f, -0.04150300f, 0.03559095f, 
    -0.03502030f, -0.09690917f, 0.05403413f, 0.05347822f, -0.09660954f, -0.02997386f, 0.10026432f, -0.14688273f, 
    -0.00196201f, -0.03870299f, -0.11745075f, 0.01353463f, -0.01346186f, -0.02082422f, -0.00578435f, -0.07102415f, 
    -0.01110477f, 0.02811989f, 0.12803119f, 0.07866725f, 0.03622991f, -0.15655367f, -0.01453942f, 0.02523619f, 
    0.12124950f, -0.04663917f, 0.09682367f, -0.11748310f, -0.28207868f, -0.01548312f, -0.01455970f, 0.08632189f, 
    0.04002435f, 0.02088184f, -0.04682845f, -0.00990731f, 0.01807139f, 0.00061325f, 0.13495427f, 0.04455267f, 
    0.02752563f, -0.24422552f, 0.06387822f, -0.04402358f, -0.01378596f, 0.14249153f, 0.02860836f, -0.08617042f, 
    -0.02132424f, -0.03668188f, 0.02327574f, 0.04594629f, -0.05740220f, -0.10823052f, -0.01333894f, 0.00947498f, 
    0.01088025f, 0.10165915f, 0.13458839f, 0.00564473f, 0.03136985f, 0.25234678f, 0.04373212f, 0.05557597f, 
    0.02031226f, -0.01341430f, -0.07352867f, 0.01318437f, -0.03394560f, -0.04869066f, 0.00100851f, 0.05314859f, 
    -0.00682756f, 0.05127156f, 0.05591439f, 0.04152514f, 0.03910457f, 0.03164113f, -0.34292865f, -0.10217858f, 
    0.22957776f, 0.17829162f, -0.05869242f, -0.22323820f, -0.01084804f, -0.07775053f, 0.01713205f, -0.11543561f, 
    0.05075898f, -0.12191135f, 0.01615756f, 0.02059546f, -0.01041907f, 0.08357609f, -0.06035987f, -0.06454545f, 
    -0.07049076f, -0.24563718f, -0.11625258f, -0.03065479f, 0.13813877f, 0.02397081f, 0.11001622f, -0.14713572f, 
    -0.03706685f, -0.04182606f, 0.02728942f, 0.17318889f, -0.04068721f, -0.07547875f, -0.04559015f, -0.13386360f, 
    0.08837932f, 0.04275184f, 0.05942087f, 0.06044978f, 0.01365077f, -0.03720554f, -0.12026687f, -0.06617455f, 
    0.27804422f, 0.16332074f, 0.16923606f, -0.36144155f, 0.02252064f, 0.01428768f, -0.02364899f, -0.03318221f, 
    0.04465213f, -0.04877758f, -0.02514119f, -0.00168240f, -0.06760921f, 0.07210243f, 0.02579976f, -0.02071404f, 
    -0.06269637f, 0.01295088f, -0.07463073f, -0.09779605f, -0.07156035f, 0.15449220f, 0.06176488f, 0.08331288f, 
    0.18452859f, -0.14155434f, -0.12151878f, -0.09465726f, -0.02776260f, -0.02557311f, -0.02576654f, 0.00900602f, 
    -0.15979302f, 0.02331619f, -0.03005362f, -0.02076869f, 0.02690106f, 0.02251836f, 0.02983265f, -0.07510263f, 
    0.05372360f, -0.07609552f, 0.13395102f, -0.22768177f, 0.11977456f, -0.06479248f, -0.10474749f, 0.06865568f, 
    -0.09064545f, -0.16335621f, 0.01984129f, 0.01409656f, 0.01332719f, 0.10494298f, -0.01870860f, 0.20449463f, 
    0.01458267f, 0.03899984f, -0.06049921f, -0.09411815f, 0.18240762f, -0.12673137f, -0.01961023f, 0.05878979f, 
    -0.08331637f, 0.04077658f, 0.11933668f, -0.03928457f, 0.03060918f, 0.03976605f, -0.01773340f, 0.02254938f, 
    -0.14104822f, 0.02714547f, 0.05422609f, 0.06490756f, -0.02460988f, -0.03367977f, -0.16107710f, -0.04950664f, 
    0.41074583f, 0.21901278f, 0.15576094f, -0.19802724f, 0.07417736f, -0.01043874f, 0.15959328f, 0.05827940f, 
    0.03001234f, 0.09044714f, -0.15091459f, -0.03126790f, -0.02318746f, -0.07868957f, 0.02267249f, 0.08952103f, 
    -0.01970048f, -0.15943532f, 0.20124757f, -0.06249579f, 0.27365437f, 0.11192931f, 0.28219795f, -0.35121396f, 
    -0.12807630f, 0.05564651f, -0.03863018f, 0.04163056f, 0.20565777f, -0.00549923f, 0.00267395f, -0.08114628f, 
    -0.03039913f, 0.11078791f, 0.03227620f, 0.15370661f, 0.09809833f, 0.07337791f, 0.03040854f, 0.08685330f, 
    0.15942401f, 0.04499825f, 0.08917369f, -0.27475461f, 0.20305015f, -0.25240499f, -0.10600627f, 0.07957967f, 
    0.00357458f, -0.05185187f, -0.00451140f, 0.01360008f, -0.08257936f, -0.00491057f, -0.03752995f, 0.14267533f, 
    0.00847762f, 0.03462739f, -0.03830833f, 0.06509414f, 0.11742833f, 0.20884332f, -0.36550879f, 0.10341293f, 
    -0.22294317f, -0.08460652f, 0.04239625f, 0.08715907f, 0.03277699f, 0.12588109f, 0.04503816f, 0.06837454f, 
    -0.02422174f, 0.05443751f, 0.07074659f, -0.05378993f, -0.06404571f, -0.00286854f, 0.00071689f, -0.00274503f, 
    -0.11629952f, 0.25593287f, -0.14954753f, -0.05074695f, 0.25483629f, -0.04728694f, 0.01585337f, -0.01233784f, 
    -0.03806056f, -0.00269430f, -0.14286631f, -0.03513260f, 0.00798310f, -0.10155770f, 0.06899551f, -0.09353196f, 
    -0.01521607f, -0.00730522f, 0.03827367f, 0.06056167f, -0.10264996f, 0.14337097f, -0.21429358f, 0.10711633f, 
    0.26207969f, 0.01916364f, 0.10327269f, -0.11211271f, 0.05933813f, -0.01276465f, 0.02985948f, 0.00138572f, 
    -0.00954279f, -0.03246196f, 0.04688842f, 0.00989825f, 0.09438834f, -0.14134225f, 0.06318501f, 0.05434869f, 
    -0.09945704f, -0.44918409f, 0.04477322f, 0.19635633f, -0.12026317f, -0.09120158f, 0.00633525f, -0.06774615f, 
    -0.09302451f, 0.03307107f, -0.06502995f, 0.00292337f, 0.01675441f, -0.11625646f, -0.03389591f, 0.03565778f, 
    0.06113387f, 0.03873447f, -0.02115539f, -0.07748283f, -0.12269682f, 0.06919975f, -0.23764642f, 0.23965098f, 
    -0.15545730f, 0.01642513f, 0.04345003f, -0.22520468f, -0.09705566f, -0.01768630f, -0.06071594f, -0.01278299f, 
    0.04703916f, -0.02524273f, -0.03792417f, -0.01765520f, 0.05636992f, -0.01151290f, 0.00514007f, 0.00399485f, 
    0.13022356f, -0.50466114f, -0.40169755f, -0.01532577f, -0.15745561f, 0.03379957f, -0.05640359f, -0.04766821f, 
    0.03911191f, 0.00417593f, 0.03207028f, 0.15219277f, -0.04738428f, -0.02138279f, 0.05460606f, -0.06055644f, 
    -0.04515024f, 0.06112701f, 0.06530233f, -0.02774469f, 0.20767032f, -0.00951236f, 0.10598359f, -0.01110523f, 
    0.19523755f, 0.07282341f, -0.08937467f, 0.00878411f, -0.03532954f, 0.00546525f, 0.00129148f, -0.00813417f, 
    0.01784176f, -0.02836742f, 0.07891040f, 0.10252824f, 0.00317345f, 0.04746082f, -0.18515562f, 0.01928030f, 
    0.04060892f, 0.11052758f, -0.04065342f, -0.04216063f, 0.22942510f, -0.05706760f, -0.07201575f, -0.10730310f, 
    -0.08879739f, 0.02680069f, -0.02006993f, 0.07328134f, 0.04539958f, -0.02288518f, 0.03452622f, 0.13183795f, 
    0.11279581f, -0.25236219f, -0.07865533f, 0.06937999f, 0.03441151f, 0.17177394f, -0.17555900f, -0.02386076f, 
    0.10679058f, -0.16234158f, -0.00274896f, -0.03287895f, -0.11811253f, 0.10980301f, -0.06872467f, 0.00535687f, 
    0.20553759f, -0.04750036f, 0.08119680f, 0.03067095f, 0.07077421f, -0.17578085f, -0.05823217f, -0.06526724f, 
    -0.00108982f, 0.02362077f, -0.04176864f, -0.03222144f, 0.01034002f, 0.02816925f, -0.00909808f, 0.03087439f, 
    -0.03865806f, -0.02685437f, -0.02574197f, -0.00598911f, -0.05881393f, -0.01452660f, 0.01221989f, 0.00730748f, 
    0.02737235f, 0.03331843f, -0.00567061f, 0.02379259f, 0.00919998f, 0.00773677f, -0.06047357f, 0.03250542f, 
    -0.03080443f, 0.02825198f, 0.02723297f, -0.01657638f, 0.00127922f, -0.04900152f, -0.05891666f, 0.03255467f, 
    -0.01062363f, -0.00870385f, -0.04249649f, -0.04960527f, -0.00879976f, 0.02980422f, -0.03221613f, 0.04730983f, 
    0.04780214f, -0.03088742f, 0.03409003f, -0.01470698f, -0.05146401f, -0.00013173f, 0.02713852f, 0.02158948f, 
    -0.00550962f, 0.04257693f, -0.05122722f, -0.03939863f, -0.01475347f, 0.01472742f, 0.00541398f, -0.03844091f, 
    -0.04747404f, -0.00272445f, 0.03778898f, -0.06175752f, -0.04814205f, -0.05752181f, -0.00658123f, 0.04799566f, 
    0.04711670f, 0.04987283f, 0.02813137f, -0.02045020f, -0.05804846f, -0.00994053f, 0.04866021f, -0.01898181f, 
    -0.03190688f, -0.03856930f, 0.04601688f, 0.03468835f, 0.00897434f, -0.02217886f, -0.04229324f, -0.02994856f, 
    -0.03030400f, -0.02581250f, -0.01332656f, -0.02007389f, 0.01747199f, 0.03277631f, 0.03845640f, 0.05435975f, 
    -0.00288800f, 0.02147465f, -0.05877021f, 0.04741506f, -0.03101851f, -0.03546214f, 0.00163405f, -0.04666291f, 
    0.03322957f, -0.00231260f, -0.04534213f, -0.04006074f, 0.02352706f, -0.02993364f, -0.03935257f, -0.01028004f, 
    0.03454749f, 0.02348066f, -0.00330803f, -0.05765246f, 0.01636269f, -0.04628780f, -0.00072142f, 0.04614706f, 
    -0.03634924f, -0.05346883f, -0.02229924f, -0.05321259f, -0.00118187f, -0.03315658f, 0.03731153f, 0.01658449f, 
    -0.03464113f, -0.00919715f, -0.00635686f, -0.05389193f, -0.00234693f, -0.01336584f, -0.04653763f, 0.04949175f, 
    -0.00944915f, -0.02838719f, -0.00277400f, -0.04955606f, 0.03602380f, 0.02728263f, 0.01744631f, 0.03124993f, 
    -0.02620711f, -0.03368311f, -0.05148171f, -0.06135376f, 0.00776482f, -0.01242061f, -0.01584369f, -0.05594397f, 
    -0.05006543f, -0.02098210f, 0.00892450f, -0.03392384f, 0.04558311f, 0.01052986f, 0.03942922f, 0.00824050f, 
    0.02965708f, -0.04106986f, 0.01496296f, -0.04590779f, 0.01803875f, -0.00703747f, 0.04928744f, -0.01890907f, 
    0.01883975f, -0.05470762f, -0.04287775f, 0.05374813f, -0.00226559f, -0.03680642f, -0.03879014f, -0.05940282f, 
    0.03477802f, 0.01017223f, 0.00330204f, -0.05794122f, -0.04630999f, 0.00755635f, -0.06154779f, 0.03285229f, 
    -0.03641285f, 0.02020383f, -0.03672717f, 0.04963005f, 0.00806036f, -0.03151750f, -0.04848917f, -0.01836140f, 
    0.01709931f, 0.00456818f, -0.02306072f, 0.02072588f, 0.02895247f, -0.02199150f, -0.03339699f, -0.04120575f, 
    -0.02050926f, 0.04704913f, -0.04700921f, -0.02643101f, 0.00931808f, 0.04496747f, 0.03452352f, 0.03418604f, 
    0.03335715f, -0.01919689f, -0.01536141f, -0.05897004f, -0.04915367f, -0.00364144f, 0.00150260f, 0.03890645f, 
    -0.01944070f, -0.05342429f, -0.03520138f, 0.04766595f, -0.00437868f, -0.02683377f, -0.05263729f, -0.01254787f, 
    -0.02381400f, 0.03942339f, 0.04641824f, -0.04416941f, 0.04672774f, -0.04241353f, -0.05002151f, 0.03074087f, 
    0.03914669f, -0.05084142f, 0.02116309f, -0.03241050f, -0.01327449f, 0.04405624f, 0.03848585f, -0.03761853f, 
    0.01746419f, -0.00158843f, 0.03538559f, -0.06041218f, 0.04785221f, -0.01282779f, 0.02559612f, -0.05126377f, 
    -0.03114663f, -0.02384545f, -0.00082708f, 0.02983001f, -0.06127412f, -0.01351622f, -0.00152826f, -0.00507094f, 
    -0.00088545f, -0.02369214f, -0.06048677f, 0.00617729f, 0.01790441f, -0.04505566f, -0.02589279f, 0.01433251f, 
    -0.01966336f, -0.04130029f, 0.01512662f, 0.00882279f, 0.00729441f, 0.00942482f, -0.00190819f, -0.06077074f, 
    0.00049802f, -0.03263453f, -0.02873754f, 0.01580261f, -0.05418720f, -0.05503964f, -0.00063228f, -0.00783809f, 
    0.04049153f, -0.02357277f, 0.03592058f, -0.05302518f, 0.00230504f, -0.02295082f, 0.00792849f, -0.02733079f, 
    -0.02542655f, 0.04787092f, 0.00957204f, 0.01219915f, -0.03814023f, 0.04320865f, 0.02710352f, 0.04162680f, 
    -0.00468223f, -0.04231086f, -0.03429686f, -0.04253870f, -0.05603310f, -0.04587250f, -0.03104071f, -0.04477863f, 
    -0.00334281f, -0.04641303f, -0.03832769f, 0.00536690f, -0.05607463f, 0.01738314f, 0.01517896f, 0.01958421f, 
    0.02863223f, 0.04792567f, 0.01516252f, -0.04796318f, 0.00917879f, -0.04246224f, 0.02275291f, -0.00357431f, 
    -0.01809372f, -0.02940599f, -0.03240631f, -0.00448973f, 0.03981294f, -0.00328087f, -0.02142027f, 0.04980179f, 
    -0.20302895f, -0.12955922f, -0.05890761f, 0.07245693f, 0.06577232f, -0.05528849f, -0.08898563f, 0.01101925f, 
    0.00337449f, -0.02877594f, 0.00174964f, -0.11605053f, 0.02930842f, 0.05810782f, -0.03485938f, 0.06378766f, 
    0.08009533f, 0.01461434f, -0.02918562f, -0.04144583f, 0.10614610f, -0.14969997f, -0.01812870f, -0.44756368f, 
    -0.15170789f, 0.05757029f, 0.09896658f, -0.14849320f, 0.00426631f, -0.00127104f, -0.00433744f, -0.05374166f, 
    0.03302332f, -0.02541990f, 0.04842833f, -0.11250711f, 0.00968798f, -0.00055734f, 0.01387052f, -0.00042493f, 
    -0.25496709f, 0.20397624f, 0.01704622f, -0.05290359f, 0.04144444f, -0.00120088f, 0.02706070f, -0.10470692f, 
    0.06265139f, 0.05827078f, -0.07113383f, -0.02709599f, 0.06157400f, 0.03589943f, 0.03978576f, -0.06508597f, 
    -0.01019476f, 0.03402263f, 0.03223293f, -0.01950975f, 0.22878557f, 0.12072161f, 0.16845344f, 0.01422632f, 
    -0.01185900f, 0.06625886f, -0.00855729f, 0.06414954f, -0.02076221f, -0.03491963f, -0.04602480f, 0.02021092f, 
    0.07965892f, 0.13312899f, 0.13047269f, 0.09479483f, 0.06734692f, 0.10154122f, -0.10353214f, -0.02543099f, 
    0.28068531f, -0.42015535f, -0.03069863f, 0.21441787f, 0.07524617f, 0.10715162f, -0.04591085f, -0.14349566f, 
    0.01277606f, -0.03920913f, -0.02614042f, 0.00140059f, 0.09678136f, 0.04325786f, -0.02397258f, 0.05033100f, 
    0.03402516f, -0.06189743f, -0.09666450f, 0.16876951f, -0.11278572f, 0.09680352f, 0.06713434f, 0.20143500f, 
    0.04717725f, 0.13249694f, 0.10613914f, -0.10496800f, 0.00229815f, 0.13448715f, 0.01474102f, 0.08305035f, 
    -0.02235935f, 0.02778232f, -0.00449243f, -0.07509240f, -0.06871185f, 0.01980822f, -0.01596011f, 0.05620654f, 
    0.20030043f, 0.14413473f, -0.07158887f, -0.04685840f, 0.00818152f, 0.02309258f, 0.12029635f, -0.00245470f, 
    -0.14478369f, -0.01805450f, -0.13466893f, 0.07898378f, -0.03344718f, 0.01468768f, 0.01186157f, -0.00130670f, 
    0.02358941f, -0.02864486f, 0.04620043f, -0.04487444f, 0.08740616f, 0.11888676f, 0.11545182f, 0.05921305f, 
    0.05957419f, 0.08864011f, 0.22448835f, -0.01101140f, 0.00152540f, 0.09214696f, -0.04804531f, 0.06212440f, 
    -0.02833525f, 0.04133016f, 0.17124116f, 0.03165083f, 0.00304207f, 0.02482488f, 0.03510904f, -0.03564907f, 
    0.39351395f, -0.38449088f, 0.22533445f, -0.00506208f, -0.12162558f, 0.08987036f, 0.16192435f, -0.07812302f, 
    -0.05632342f, -0.00355093f, -0.09259940f, -0.07154404f, -0.05458621f, 0.03680304f, -0.11265222f, -0.00005393f, 
    -0.02128628f, -0.00297565f, 0.09622838f, 0.03350529f, 0.24297220f, -0.37916699f, 0.07845084f, -0.09962821f, 
    -0.00015488f, -0.06125381f, -0.05005777f, -0.07435640f, 0.02563850f, -0.02529163f, -0.00199314f, -0.00821442f, 
    0.08820245f, -0.00997167f, -0.05724279f, 0.05774851f, 0.02043994f, -0.01007847f, -0.04912442f, 0.02374301f, 
    -0.02856366f, 0.09622585f, -0.04291352f, -0.11912708f, -0.00035494f, -0.07450250f, 0.06189431f, 0.06797068f, 
    0.00942519f, 0.04263769f, 0.12970735f, 0.08531369f, -0.04192374f, 0.07387926f, 0.02681225f, 0.03008252f, 
    0.05133619f, 0.02024306f, 0.07888920f, -0.00385106f, 0.07198215f, -0.05512716f, 0.01530908f, -0.16294298f, 
    0.10358619f, -0.03573456f, -0.00779152f, 0.07527643f, 0.06062750f, 0.04699950f, -0.00115497f, 0.08206257f, 
    0.10886839f, 0.06148134f, -0.09309077f, 0.00595300f, 0.02941202f, 0.00143892f, -0.03728557f, 0.03040686f, 
    0.04185754f, -0.06309467f, 0.02865129f, 0.06492404f, 0.20345877f, 0.02912819f, 0.01186476f, 0.00927736f, 
    0.04067886f, -0.04349811f, 0.01161538f, 0.02060260f, -0.02426562f, -0.02111945f, -0.08394486f, -0.01005177f, 
    0.02928050f, 0.04510475f, 0.16111998f, 0.08706903f, -0.20132162f, 0.30432749f, -0.02250432f, 0.09876399f, 
    0.06927866f, 0.04138473f, 0.04989795f, 0.01140678f, 0.00904607f, -0.05981135f, -0.01072486f, 0.03491215f, 
    0.05129628f, -0.03620258f, 0.08269376f, 0.05315270f, 0.07368581f, 0.01150869f, 0.01063361f, -0.04415326f, 
    0.07525184f, -0.08211946f, 0.01442626f, -0.15357520f, -0.04214676f, 0.05556524f, 0.10433392f, -0.04536654f, 
    0.01737073f, -0.14876911f, 0.00610538f, -0.03729564f, -0.04551828f, 0.07337725f, -0.01249581f, -0.00022874f, 
    -0.02595812f, -0.12429086f, -0.00376841f, -0.15002780f, 0.15363432f, -0.21067536f, -0.08432437f, 0.09522392f, 
    -0.05430174f, 0.05103151f, -0.02924687f, 0.09834991f, -0.00574796f, -0.00959815f, 0.08879215f, -0.04793067f, 
    -0.03764113f, -0.01365797f, 0.02218300f, 0.12230708f, -0.03197894f, 0.03474144f, 0.00613145f, -0.01397740f, 
    -0.25764784f, -0.24612871f, 0.32533294f, 0.04907168f, 0.05732170f, -0.05720908f, 0.08493412f, 0.05404476f, 
    -0.09263599f, -0.08685710f, -0.06138815f, 0.01130926f, 0.05762328f, -0.04293706f, -0.09318096f, 0.01417039f, 
    -0.07109714f, 0.03156385f, -0.01399549f, -0.04341399f, 0.22363904f, 0.30492231f, 0.00719290f, 0.08761904f, 
    -0.03661448f, 0.04674780f, 0.04836553f, 0.07401706f, -0.07189286f, 0.04268475f, -0.08900998f, -0.00265202f, 
    0.04720728f, 0.19505292f, 0.06740937f, -0.02502367f, -0.04629693f, -0.07263623f, -0.06203463f, 0.01698224f, 
    0.01923472f, -0.08263201f, 0.08061034f, -0.04765330f, 0.10203313f, 0.14040746f, -0.06629243f, 0.16461378f, 
    0.02861392f, 0.13060488f, 0.02842384f, 0.03093726f, -0.04130248f, 0.05810635f, -0.11181335f, 0.06978729f, 
    0.06888530f, 0.01926919f, -0.12023528f, 0.06035977f, -0.01309991f, -0.05147322f, -0.05598579f, -0.00128538f, 
    -0.01255595f, -0.01923314f, -0.00763926f, 0.08673213f, 0.05815186f, 0.15055005f, 0.03309167f, 0.00207981f, 
    0.09446512f, -0.04634132f, -0.03850601f, 0.00982157f, -0.01370127f, 0.00029429f, 0.03122779f, -0.05904877f, 
    -0.36235425f, -0.00923562f, -0.03979618f, -0.13982867f, -0.02362082f, -0.04205387f, -0.01939437f, 0.02664497f, 
    0.11296283f, 0.07143335f, 0.06980880f, -0.01581823f, -0.08422602f, -0.03874082f, -0.03457134f, -0.02202010f, 
    -0.01944851f, 0.11666701f, -0.06053671f, 0.06834331f, 0.38230947f, 0.05157341f, -0.18085717f, -0.16100395f, 
    -0.20140031f, 0.04078207f, 0.04418090f, -0.01615385f, 0.00622235f, -0.10164645f, 0.09561810f, -0.03372437f, 
    -0.11293973f, -0.07425267f, -0.00097703f, 0.03006124f, 0.03066887f, 0.03835784f, -0.09302118f, -0.01643984f, 
    0.05404715f, -0.11266050f, 0.10356089f, 0.09828740f, -0.07499675f, 0.05655861f, 0.07628231f, 0.18228637f, 
    -0.02406500f, 0.07412070f, -0.01776570f, 0.07905902f, 0.03517230f, -0.00654208f, -0.02659085f, 0.05591261f, 
    -0.01511607f, 0.05467321f, 0.03268545f, 0.05974229f, 0.04539232f, -0.12074549f, -0.21799377f, 0.01309031f, 
    -0.05312419f, 0.01334903f, -0.01861616f, 0.09737746f, 0.03776085f, -0.16540596f, 0.03166076f, 0.00320301f, 
    0.02412944f, -0.05684230f, -0.05965041f, -0.00768606f, -0.02189084f, -0.06272334f, -0.00408705f, 0.09199353f, 
    0.12013423f, 0.17607778f, -0.12903503f, -0.07362831f, -0.22185203f, -0.06736355f, 0.12444150f, 0.02816302f, 
    -0.00370443f, 0.07875931f, 0.07905278f, -0.03087533f, 0.11816953f, 0.09078343f, 0.04338645f, -0.03133093f, 
    -0.00953936f, 0.02569937f, 0.02670754f, 0.05596425f, -0.02312316f, 0.23659737f, -0.12921552f, -0.04286568f, 
    -0.06696473f, -0.06191162f, 0.08186841f, 0.06026028f, 0.05604482f, 0.05785997f, 0.07877231f, -0.05511693f, 
    0.03321842f, 0.07646958f, -0.03405868f, 0.01327473f, 0.02513028f, 0.02334810f, 0.04668959f, 0.05450562f, 
    0.02745056f, 0.14230312f, -0.10226205f, 0.11614963f, 0.19439425f, 0.04473727f, -0.13418567f, -0.01369785f, 
    0.03713278f, 0.06239689f, -0.09263645f, -0.03212359f, 0.11102048f, 0.03522860f, 0.04652549f, 0.08499633f, 
    0.05368961f, 0.01356804f, -0.03046036f, -0.07198989f, 0.15394728f, 0.18645282f, -0.05247742f, 0.07596895f, 
    0.06187545f, 0.05408651f, 0.06462931f, -0.02199749f, 0.10710644f, 0.00738002f, -0.11699767f, -0.05372382f, 
    0.06369304f, 0.09734399f, 0.19427091f, 0.01986585f, 0.02829695f, -0.10571623f, 0.02186774f, 0.03899053f, 
    0.03146148f, 0.02981317f, -0.07189342f, 0.03907633f, 0.09800336f, 0.01483821f, 0.06708829f, -0.01202798f, 
    0.08675057f, 0.07208291f, -0.11748555f, 0.00013955f, 0.09515421f, 0.04094896f, -0.01461246f, 0.02245571f, 
    0.09511779f, -0.02775189f, -0.08293520f, -0.00621366f, 0.07807066f, -0.28712389f, 0.03089744f, -0.14648983f, 
    0.09582438f, 0.02740271f, -0.00577100f, 0.08829039f, 0.02095283f, 0.07188781f, 0.07990214f, 0.01759758f, 
    -0.03116604f, 0.04463091f, 0.06615902f, 0.06751605f, 0.06742918f, 0.06694604f, -0.02684074f, 0.07366696f, 
    -0.12182008f, 0.04587690f, 0.02780424f, 0.07268351f, -0.17781770f, 0.08893055f, 0.04149812f, 0.16636316f, 
    0.00166011f, 0.10937892f, -0.05623593f, 0.03462676f, 0.01861071f, 0.01180443f, 0.03618836f, 0.05862420f, 
    0.04500240f, 0.03713747f, -0.02492866f, 0.06866394f, 0.01192813f, 0.01630693f, -0.05106953f, -0.03250504f, 
    0.00710453f, -0.05105366f, 0.04592764f, -0.04222085f, -0.00569573f, 0.08025938f, -0.09374812f, 0.08548804f, 
    -0.02534883f, 0.05772159f, -0.10085265f, -0.01127113f, 0.04452492f, -0.04364219f, -0.02338886f, -0.01098140f, 
    -0.00318362f, 0.03240987f, -0.00224424f, -0.02559436f, -0.02168744f, -0.06261344f, -0.01794172f, 0.00761702f, 
    0.00140649f, 0.03353576f, 0.00571436f, 0.04151826f, -0.04309838f, 0.00154854f, -0.01010880f, -0.00271521f, 
    -0.05508505f, 0.02795532f, 0.02867607f, -0.00392066f, 0.04550922f, -0.02215101f, -0.01586040f, -0.00315814f, 
    0.03755394f, -0.05403707f, -0.00869374f, -0.02598356f, 0.03954247f, -0.04140236f, -0.02338975f, -0.03208904f, 
    0.03770796f, 0.01220204f, -0.04295121f, -0.03139546f, -0.04626080f, -0.04751988f, -0.05034443f, 0.04484452f, 
    0.01608503f, -0.02126238f, -0.02374238f, -0.05808359f, -0.00473081f, -0.00054922f, 0.01139288f, -0.02554862f, 
    -0.04907988f, -0.01683252f, 0.03400996f, 0.03044210f, -0.05643245f, -0.02156566f, -0.02739717f, -0.03242158f, 
    0.02504813f, -0.04655061f, -0.06049896f, -0.03046204f, -0.02196915f, -0.02779968f, 0.03037576f, -0.02608415f, 
    -0.00434298f, -0.03557276f, 0.04640434f, 0.02961374f, 0.03835491f, 0.04520849f, 0.00812792f, -0.02268826f, 
    0.04358742f, -0.02740138f, 0.01480199f, -0.00602879f, -0.01206816f, -0.02825139f, -0.01237774f, 0.01906151f, 
    0.01015716f, 0.01166599f, -0.02507266f, -0.06198131f, 0.01098866f, 0.02183251f, -0.04901007f, -0.00032624f, 
    0.05107516f, -0.06495524f, -0.04260304f, -0.06510507f, 0.03823434f, 0.01336660f, 0.00527841f, -0.05751070f, 
    -0.02048693f, -0.01140532f, -0.03543692f, 0.02966216f, -0.00996431f, -0.04766591f, -0.00094571f, -0.05210591f, 
    -0.03352000f, -0.00558314f, -0.01053451f, -0.03592181f, -0.03091954f, 0.03161221f, 0.02591957f, 0.01197295f, 
    -0.06258570f, -0.00042041f, -0.00333260f, -0.00727338f, -0.01763567f, -0.04794423f, 0.02487008f, 0.00628367f, 
    -0.06394818f, 0.03972665f, -0.00131257f, -0.05933058f, -0.06346190f, -0.00414196f, -0.00199457f, -0.00201153f, 
    0.01813750f, -0.04635159f, -0.05613609f, 0.02485457f, 0.04194051f, 0.05151742f, 0.03864849f, -0.06088666f, 
    0.03539630f, 0.00088693f, 0.04619424f, -0.01292892f, -0.03384819f, 0.01434128f, 0.00088398f, -0.04576660f, 
    0.03167021f, -0.02062027f, -0.00089711f, -0.02578986f, 0.00272987f, -0.00655670f, -0.02309964f, 0.03519827f, 
    -0.02614645f, -0.04623061f, -0.06086763f, 0.03608524f, 0.04495109f, -0.04478253f, -0.04058149f, 0.01682085f, 
    0.02563519f, -0.02192221f, 0.04318986f, 0.03972333f, -0.01516704f, -0.06315111f, 0.02337661f, 0.04322673f, 
    0.01471003f, 0.01408478f, 0.02620404f, -0.03442916f, -0.02368821f, -0.04294884f, -0.03173291f, 0.01480947f, 
    -0.04172172f, -0.04863830f, 0.03356551f, 0.03212434f, -0.03638981f, 0.04612467f, -0.03978374f, -0.02548952f, 
    0.03541763f, 0.04274826f, 0.04508495f, 0.02941685f, -0.02486459f, -0.01090369f, -0.01518640f, -0.01643418f, 
    -0.04091865f, -0.04900830f, -0.02562150f, 0.01379931f, -0.02419855f, -0.01422751f, 0.02420268f, -0.00068647f, 
    -0.00152834f, -0.04646695f, -0.04651229f, 0.00839113f, -0.03256367f, 0.00752934f, -0.00714295f, 0.03859539f, 
    0.01868536f, 0.02118953f, -0.00674147f, 0.01750321f, 0.02068434f, 0.00862327f, -0.01989350f, 0.03761684f, 
    0.04451671f, 0.01608834f, -0.03073129f, 0.01436726f, 0.00445806f, -0.03472939f, 0.02407654f, -0.04307198f, 
    -0.02497308f, -0.05358704f, 0.04209661f, -0.01170475f, -0.01677928f, -0.04197752f, -0.02242852f, 0.00272269f, 
    -0.04431002f, -0.01558298f, -0.05991744f, -0.04510223f, 0.02531345f, 0.04454075f, 0.01266510f, -0.02628677f, 
    -0.02896037f, -0.05009491f, 0.01060015f, 0.02052594f, 0.00702070f, -0.03652582f, -0.04243939f, 0.03120762f, 
    -0.04714864f, 0.00097747f, -0.02607302f, -0.02892417f, 0.03245669f, -0.00777654f, -0.04457336f, -0.04361736f, 
    -0.00916585f, 0.00783811f, -0.00629093f, -0.02492814f, -0.02378798f, -0.01228455f, 0.03025854f, 0.04325055f, 
    -0.05648554f, -0.02630825f, 0.04544192f, 0.02951918f, -0.03443973f, 0.00222964f, 0.01722769f, 0.01559704f, 
    -0.03689815f, -0.00309174f, 0.00999927f, 0.03806730f, 0.00313369f, -0.00396197f, 0.00329062f, 0.02544194f, 
    -0.04028540f, 0.03428875f, 0.04693223f, 0.02621465f, -0.06096176f, 0.00666363f, -0.04660294f, -0.04682625f, 
    -0.05305854f, 0.02999309f, 0.02469588f, -0.01689119f, -0.02871121f, -0.04646993f, -0.03117010f, -0.03287107f, 
    0.02743567f, 0.03489355f, -0.01151747f, 0.04553330f, -0.04843547f, -0.00060794f, -0.00415551f, -0.05084775f, 
    -0.02840844f, -0.04280604f, -0.05677369f, -0.02038661f, 0.04129909f, -0.00372369f, -0.06172333f, -0.02080672f, 
    0.02694883f, -0.02583618f, 0.03849543f, 0.00110040f, 0.03734821f, 0.03668126f, -0.04250660f, 0.04265800f, 
    -0.55237430f, -0.00777239f, -0.12230527f, 0.07871126f, -0.11147311f, 0.02556924f, -0.07238326f, 0.06283168f, 
    -0.04838673f, -0.00646725f, 0.06435650f, -0.06869087f, 0.09713293f, -0.18410249f, 0.14826420f, 0.00892324f, 
    0.04387486f, 0.07813402f, 0.01782587f, 0.00779073f, -0.13461830f, 0.12243898f, 0.07235874f, -0.24643290f, 
    -0.19842532f, 0.05920844f, -0.21947742f, -0.12213252f, -0.00730134f, 0.01251497f, -0.10792573f, 0.04176714f, 
    0.08665854f, 0.11707255f, 0.10361613f, 0.01049470f, -0.06722460f, -0.06673200f, -0.04670040f, -0.03366358f, 
    -0.13907570f, -0.06547483f, 0.06623156f, 0.04995321f, 0.17189288f, 0.05451829f, -0.01035827f, 0.02070044f, 
    -0.00274441f, -0.02358973f, 0.07446153f, 0.18193991f, 0.01475737f, 0.03299976f, -0.09693839f, 0.06026080f, 
    0.03730247f, -0.13560078f, 0.08549672f, 0.04931651f, 0.22287647f, -0.01358278f, 0.16993882f, 0.06120991f, 
    0.04384763f, 0.14393896f, 0.05554190f, 0.22048166f, -0.05435428f, -0.01009948f, 0.06542980f, 0.03821667f, 
    -0.04429873f, -0.00827906f, -0.01422548f, 0.11836278f, -0.06656208f, -0.03188134f, -0.15388638f, -0.01977825f, 
    0.13808739f, -0.22631101f, -0.06146529f, 0.00926407f, -0.06761222f, -0.08645499f, -0.00394302f, -0.00532597f, 
    0.08722027f, -0.07674082f, 0.09862612f, 0.05646609f, 0.05556466f, -0.03360863f, 0.03955002f, -0.02133986f, 
    0.02563982f, 0.12433461f, -0.11862709f, 0.02572219f, 0.21589540f, 0.17639615f, 0.00688459f, 0.03362793f, 
    -0.05800260f, 0.01966643f, 0.10652434f, 0.16718103f, 0.03807350f, -0.07360537f, 0.16550136f, -0.12893276f, 
    -0.03620025f, 0.01319911f, -0.11583730f, -0.07240347f, 0.01223308f, -0.03632728f, -0.01429749f, -0.06351630f, 
    -0.49785247f, -0.38241377f, -0.17480898f, -0.22137250f, -0.13188246f, 0.05169704f, 0.09626953f, 0.07350346f, 
    -0.06705489f, 0.07958724f, 0.09060173f, 0.01955050f, 0.01274974f, 0.11675155f, 0.00096463f, 0.00328960f, 
    0.09269270f, 0.06246950f, 0.13230439f, 0.15559264f, 0.22293963f, 0.00844641f, -0.01019255f, 0.03172079f, 
    0.20342799f, 0.04380873f, 0.30938336f, 0.12405787f, 0.04328688f, 0.00343590f, -0.00137193f, 0.04402675f, 
    -0.07117819f, -0.06042362f, -0.04834253f, -0.06448420f, 0.05703642f, -0.03438026f, -0.00029403f, 0.00466157f, 
    -0.23937330f, -0.37044001f, -0.22666574f, -0.13852914f, -0.25205788f, -0.10841390f, 0.07084092f, -0.04091192f, 
    0.02582955f, 0.15564992f, -0.01873161f, 0.02005155f, -0.00899500f, 0.07085802f, -0.00764104f, 0.06481345f, 
    0.09161538f, 0.18655142f, 0.04561242f, 0.08990722f, -0.29747808f, 0.15117911f, 0.08824908f, 0.01201899f, 
    -0.04299813f, 0.03336691f, -0.11797538f, -0.09988869f, -0.03017281f, 0.09683524f, -0.01437510f, 0.09816718f, 
    0.02230346f, -0.11394427f, 0.16738619f, -0.01081590f, 0.02089634f, 0.03508624f, 0.03902164f, 0.05483490f, 
    0.23535551f, 0.03801626f, 0.02384804f, -0.03905474f, 0.09794790f, 0.13162217f, -0.00734320f, 0.00036302f, 
    -0.03840426f, -0.04735036f, 0.12568115f, 0.09564489f, -0.13370579f, -0.03023657f, -0.03205997f, -0.09620310f, 
    0.10056923f, -0.27824745f, -0.11278076f, 0.05344275f, 0.41337597f, 0.20436202f, 0.04479210f, -0.05777179f, 
    0.00630878f, -0.02126426f, -0.15034357f, -0.13095510f, 0.02273277f, -0.02785137f, -0.06465115f, 0.02635556f, 
    0.02267875f, 0.07306000f, 0.10113447f, 0.10625083f, 0.02441306f, -0.04539378f, -0.07209285f, -0.00588634f, 
    0.23665573f, -0.00868520f, -0.03043574f, 0.04616486f, 0.18456396f, 0.22011496f, 0.08474620f, 0.07337561f, 
    0.03798897f, -0.02856731f, -0.00857723f, 0.01021530f, 0.05577282f, 0.06387477f, -0.09228486f, 0.02418614f, 
    0.04689430f, -0.10143330f, -0.04209829f, 0.10049447f, -0.23854965f, -0.09189047f, 0.05194749f, -0.03843714f, 
    -0.00357694f, -0.04380107f, 0.01469578f, 0.05717853f, -0.06204478f, -0.05728117f, 0.12587121f, -0.03767768f, 
    0.03470105f, -0.07666482f, 0.04317069f, -0.00298100f, 0.01382468f, 0.07851592f, 0.06071552f, -0.07533705f, 
    -0.38101012f, 0.03425398f, 0.03293851f, -0.15327328f, -0.16221519f, 0.10801648f, 0.00395135f, -0.07289848f, 
    -0.02477937f, 0.05599924f, -0.06753168f, -0.00734076f, -0.08848739f, -0.06098557f, 0.09753875f, 0.00585365f, 
    -0.06071640f, 0.10994155f, 0.03218194f, 0.02853477f, -0.03564748f, -0.27507558f, -0.22751647f, -0.04514129f, 
    -0.17621705f, -0.17874971f, -0.02869708f, -0.01767309f, -0.10262632f, 0.00234458f, -0.04081005f, -0.03951615f, 
    -0.09021240f, -0.05270763f, 0.01923171f, 0.04020042f, -0.01382422f, 0.14613219f, -0.03229631f, -0.06372231f, 
    0.30181652f, -0.00966663f, -0.15753905f, 0.14012086f, 0.00471212f, -0.03346837f, 0.02847533f, 0.05609881f, 
    0.09333544f, -0.02059931f, 0.14109121f, -0.05483319f, -0.01718292f, 0.10546969f, 0.03478447f, 0.02465949f, 
    0.02857438f, -0.03863702f, 0.00513045f, 0.01029009f, 0.33266899f, -0.02399589f, -0.26239377f, -0.09272625f, 
    0.08498165f, 0.01953996f, 0.01754485f, -0.02568696f, 0.02118498f, 0.01586031f, 0.16065660f, -0.00395997f, 
    0.02810004f, -0.08868084f, -0.01625012f, 0.05648191f, 0.04537009f, 0.10423031f, 0.08527504f, 0.03380178f, 
    0.27904555f, 0.18458843f, -0.18675242f, 0.16017196f, 0.03993812f, 0.15388887f, 0.06867861f, -0.14514178f, 
    0.02069849f, -0.06337387f, 0.12813419f, 0.07866918f, 0.02930655f, 0.08740251f, 0.03375301f, 0.01925071f, 
    0.00895123f, 0.14185759f, -0.01294494f, -0.01047045f, 0.35639632f, 0.14547643f, 0.07241003f, -0.01760366f, 
    0.17024663f, 0.00784872f, 0.01944076f, 0.03007375f, 0.11540074f, -0.19630134f, -0.07784558f, -0.10764205f, 
    -0.00910871f, 0.10282363f, 0.05701444f, -0.08145098f, 0.04781964f, 0.00857742f, -0.09204169f, 0.02754996f, 
    0.12701099f, -0.04423770f, -0.05732668f, 0.12947704f, -0.12687288f, -0.00960564f, -0.03893921f, 0.00745540f, 
    -0.00314591f, 0.04728899f, -0.05789330f, 0.02170395f, 0.07028455f, 0.00193489f, -0.04175609f, 0.05579317f, 
    0.05580683f, -0.11348812f, 0.00543535f, -0.00035781f, 0.03804075f, -0.19792217f, 0.31293190f, 0.03705774f, 
    0.10488514f, -0.14379273f, 0.02050184f, 0.01730871f, -0.02855989f, -0.04773365f, -0.14597054f, -0.05872744f, 
    0.09258755f, 0.09867477f, 0.01678169f, -0.07553816f, -0.16315450f, 0.06990483f, -0.00372292f, 0.02765667f, 
    0.23131442f, -0.07126098f, -0.25221810f, -0.03420791f, -0.05386696f, -0.01344259f, 0.06797848f, 0.05319481f, 
    -0.07505917f, -0.01096950f, 0.05282592f, 0.04521347f, 0.01035914f, -0.00185176f, 0.01123043f, 0.07153011f, 
    0.01806273f, 0.08275633f, -0.03262090f, -0.02242657f, -0.04035011f, 0.26741305f, 0.20730978f, -0.01696498f, 
    -0.00379400f, 0.16276403f, -0.00933355f, 0.08061164f, -0.03060046f, 0.03734299f, 0.04667367f, 0.06271975f, 
    0.02459341f, 0.06318912f, 0.01774190f, -0.01090708f, 0.13793814f, -0.03132650f, 0.02306198f, -0.01938782f, 
    0.35671169f, -0.06922467f, -0.07745279f, 0.15568888f, 0.08300798f, 0.02740274f, 0.00351938f, -0.04848417f, 
    -0.07845909f, 0.08156133f, 0.02838711f, -0.04830550f, -0.07661355f, -0.07416419f, 0.04100734f, 0.09727897f, 
    -0.05270274f, -0.11098389f, 0.04892424f, 0.00034616f, -0.12222617f, 0.14895822f, 0.01525677f, -0.05017857f, 
    0.15897952f, -0.03166043f, -0.03268045f, -0.07868013f, 0.06383309f, -0.01298460f, 0.08400318f, 0.05128347f, 
    -0.00235820f, -0.01354827f, 0.04024260f, 0.04073337f, 0.00654915f, 0.07771808f, 0.05306799f, 0.05592559f, 
    0.02867297f, 0.19154948f, -0.07715861f, -0.17702901f, 0.03206766f, -0.06644283f, 0.03088982f, 0.00211586f, 
    -0.05777761f, -0.04714551f, 0.07697248f, -0.00320908f, -0.01520721f, -0.05573414f, 0.00007881f, 0.24853933f, 
    -0.00867039f, 0.12534474f, 0.12470642f, 0.00535198f, 0.30708680f, -0.03790814f, -0.04358150f, 0.12395699f, 
    0.12340223f, 0.02191801f, -0.01353878f, -0.03306260f, 0.09490176f, -0.02042811f, 0.00836998f, 0.05205691f, 
    -0.01301154f, -0.03246366f, 0.06410998f, 0.12796371f, 0.02019082f, -0.02767476f, 0.10759864f, 0.05489657f, 
    -0.13009062f, 0.16345294f, -0.03361747f, -0.19034791f, -0.10236963f, -0.09195297f, -0.10234161f, 0.00114207f, 
    -0.04083170f, -0.14826202f, 0.07223156f, 0.01502422f, -0.08589297f, -0.11591762f, -0.04286658f, 0.08938041f, 
    -0.02411626f, 0.11252049f, 0.15957247f, 0.03384003f, -0.20305620f, -0.04641335f, -0.13466263f, 0.08307577f, 
    -0.13466971f, 0.03865135f, 0.07818936f, 0.04165073f, -0.04364213f, 0.05246555f, -0.00083435f, 0.09931079f, 
    0.06106908f, -0.03196310f, -0.02864533f, -0.06883447f, 0.05378915f, -0.00128174f, 0.05159326f, -0.03226421f, 
    -0.05840646f, -0.09260668f, -0.07647162f, -0.07227501f, -0.13587849f, -0.01307631f, 0.08346301f, -0.06995196f, 
    0.04582392f, 0.01635907f, 0.02244981f, -0.02081815f, -0.02449750f, 0.03973320f, 0.04925219f, -0.03543732f, 
    0.16700916f, -0.05643731f, -0.04233459f, 0.04878170f, -0.15473670f, -0.14216335f, -0.17316408f, -0.03463298f, 
    -0.21288912f, 0.11563176f, -0.09550022f, 0.07623796f, 0.02262242f, -0.00608376f, 0.07128803f, -0.06288821f, 
    0.00417956f, 0.05259488f, 0.05953841f, 0.01162603f, -0.01443499f, -0.13437143f, -0.01802068f, -0.06364376f, 
    -0.03488894f, -0.01431988f, 0.02924452f, 0.04654228f, 0.03847705f, 0.01579434f, -0.04175150f, 0.03942754f, 
    -0.06262048f, 0.04596121f, 0.00725944f, 0.03447546f, -0.05268919f, -0.03965744f, -0.03515850f, -0.05637353f, 
    -0.01997539f, -0.04407163f, 0.03249516f, 0.01191199f, -0.00290198f, -0.03102409f, -0.06031962f, -0.03746602f, 
    -0.06107058f, -0.04562961f, -0.05281312f, -0.01415896f, -0.06090693f, 0.03585872f, 0.00476563f, -0.00911917f, 
    0.03785517f, 0.04005090f, -0.01418123f, 0.00344242f, -0.01936080f, 0.01611185f, -0.06195432f, -0.01189277f, 
    -0.01563653f, 0.03948005f, 0.04121726f, -0.04219289f, 0.03319336f, -0.02231020f, -0.06036182f, 0.02058012f, 
    -0.05682064f, -0.05815017f, -0.03782004f, 0.00639717f, -0.04447893f, -0.00134014f, -0.02227689f, 0.00366105f, 
    0.04584135f, 0.01412842f, -0.00408458f, 0.03967050f, -0.02006107f, 0.03638919f, 0.01597107f, 0.00008417f, 
    -0.02566133f, -0.02962085f, -0.00644148f, 0.01143574f, -0.02601190f, 0.03196150f, -0.02284510f, -0.04302463f, 
    -0.00959878f, 0.00965808f, -0.04486907f, 0.04088143f, -0.03660659f, 0.02734217f, 0.03605418f, 0.01096426f, 
    -0.03342430f, 0.03137949f, 0.03606032f, -0.00835700f, 0.04050443f, 0.02680878f, 0.04067799f, -0.02475864f, 
    -0.04868465f, 0.03779465f, -0.02501443f, 0.01069664f, 0.01836076f, -0.00292242f, -0.01658536f, -0.03333339f, 
    0.04141514f, -0.05870792f, 0.02436392f, -0.02091301f, -0.03176300f, -0.05260314f, -0.00716727f, 0.03516641f, 
    -0.05677022f, -0.01564889f, 0.03674696f, -0.01225725f, 0.01413993f, -0.00156053f, 0.01338748f, -0.05413314f, 
    -0.04411386f, -0.03393115f, -0.00214653f, -0.04861049f, 0.01289320f, -0.03168136f, -0.05964574f, -0.01536073f, 
    -0.00757014f, 0.01235148f, -0.02312408f, -0.00122816f, 0.00749670f, 0.04473180f, 0.00543541f, -0.01610126f, 
    0.02476638f, 0.00258424f, 0.02859195f, 0.02750932f, 0.03161596f, -0.05374665f, -0.00226887f, -0.02272675f, 
    0.00407788f, 0.00542749f, 0.00644549f, 0.03696948f, -0.05564493f, -0.03302468f, 0.04024542f, -0.03391131f, 
    -0.05575117f, 0.02832720f, -0.01239575f, -0.02139158f, -0.03299126f, 0.04836867f, 0.04728258f, 0.00799482f, 
    0.03967182f, 0.04686905f, 0.01157243f, -0.06226591f, -0.00346742f, 0.00451749f, 0.02619504f, -0.04375089f, 
    0.00171641f, 0.03147736f, -0.02350920f, 0.00378724f, -0.04517893f, -0.05652146f, -0.04886595f, 0.00527971f, 
    0.02114908f, -0.02338573f, 0.00676977f, 0.04614961f, -0.03268976f, -0.04203143f, -0.05452077f, 0.02386321f, 
    -0.04879494f, 0.02185963f, -0.00280928f, 0.04452081f, 0.00484698f, -0.05457387f, -0.04682102f, 0.01627336f, 
    -0.02591352f, 0.02654209f, -0.01677778f, 0.02640513f, 0.02793626f, 0.02230450f, -0.04907817f, -0.00016752f, 
    -0.02625269f, 0.03295157f, -0.01699836f, -0.02978343f, 0.05178384f, 0.03877447f, -0.00584149f, -0.04519200f, 
    0.04796113f, -0.04129468f, 0.01341880f, -0.05995882f, -0.04787478f, -0.02992828f, -0.03371673f, -0.05581618f, 
    -0.04137785f, -0.01378540f, -0.00281099f, -0.05254711f, -0.00290067f, 0.01444692f, 0.02634868f, -0.00627025f, 
    -0.01061847f, 0.03782606f, 0.00676494f, 0.01698281f, -0.00799593f, 0.05140477f, 0.03666108f, 0.01849290f, 
    0.02966484f, -0.01072700f, 0.00226875f, -0.03312388f, -0.00526372f, 0.02097568f, 0.04431764f, 0.04693916f, 
    0.00485182f, 0.02256321f, -0.02810021f, -0.01040221f, -0.03658045f, -0.00101175f, -0.03393202f, -0.04303494f, 
    0.04884832f, -0.04625874f, -0.03120748f, 0.00698534f, 0.00260098f, -0.03422577f, 0.02707882f, -0.03932914f, 
    0.00985348f, 0.01867532f, 0.00759882f, 0.00230011f, -0.00441760f, -0.02720726f, -0.05105464f, -0.00010593f, 
    0.03418898f, -0.01546901f, -0.01084322f, 0.04129555f, 0.04034108f, 0.03992387f, 0.02941889f, 0.01907980f, 
    -0.04349597f, 0.00182912f, 0.02014239f, -0.03793244f, -0.01071805f, 0.03278458f, -0.02667276f, -0.05500866f, 
    -0.04917197f, -0.02129936f, -0.04283886f, -0.00040268f, 0.00502541f, -0.04039718f, -0.02686948f, 0.02967075f, 
    0.02610027f, 0.04051203f, 0.01503400f, -0.04203742f, 0.01040168f, -0.03065026f, 0.00700215f, -0.02701651f, 
    0.02875542f, 0.03747820f, -0.03771226f, 0.03804367f, 0.00809641f, -0.04786988f, -0.00460874f, -0.00547686f, 
    0.04964028f, -0.03065568f, -0.02660381f, -0.05983618f, 0.04582231f, -0.04402608f, -0.05572268f, -0.00916132f, 
    -0.00836730f, -0.03637742f, 0.01908663f, -0.01044982f, -0.02937470f, -0.01115778f, -0.02226105f, 0.00873585f, 
    0.02145158f, -0.00810026f, 0.03956538f, -0.05225107f, 0.03058821f, -0.04590067f, 0.01395051f, -0.04715413f, 
    -0.04671275f, -0.01423702f, 0.04810254f, -0.03780425f, 0.02355015f, -0.03510919f, -0.05377040f, -0.00665339f, 
    0.04621081f, 0.02725812f, -0.02999300f, 0.01912433f, -0.02640005f, 0.04310322f, -0.00312326f, -0.00143060f, 
    -0.01472722f, 0.00683735f, -0.02920262f, 0.01981889f, 0.01507536f, 0.01119783f, -0.02752091f, -0.00387406f, 
    -0.04801689f, -0.03483929f, -0.01258504f, 0.01209043f, -0.02027881f, -0.05829331f, -0.02117259f, -0.00030332f, 
    0.00873475f, -0.00278035f, -0.04889760f, -0.01403425f, 0.01668646f, -0.03092967f, 0.00303221f, 0.03332333f, 
    0.00796244f, 0.00549759f, -0.01647877f, -0.00188191f, 0.01306910f, 0.04341621f, -0.01609267f, -0.04001393f, 
    0.02619214f, 0.02123577f, 0.04449389f, 0.00628319f, -0.02560618f, -0.05570170f, 0.00160881f, -0.00797636f, 
    -0.04505482f, 0.03103381f, 0.01606973f, -0.00120957f, -0.01175467f, -0.03885264f, -0.04721042f, -0.00652877f, 
    -0.01074856f, -0.03848164f, -0.03317598f, -0.04305895f, -0.04146738f, -0.00017753f, 0.04085108f, 0.03044901f, 
    -0.02267979f, -0.03442440f, -0.03367026f, -0.04907589f, -0.01022106f, -0.04483416f, 0.04122748f, -0.05401973f, 
    -0.04838070f, -0.03850363f, 0.03938373f, -0.02686859f, -0.05044270f, -0.00526535f, 0.01981170f, 0.00765569f, 
    0.03196483f, -0.03155533f, 0.00852967f, -0.01324983f, 0.03340716f, 0.03856957f, -0.04424430f, 0.04403245f, 
    0.01095453f, -0.01812924f, 0.01281120f, 0.01660347f, 0.01676190f, -0.01666009f, -0.03623401f, -0.04787748f, 
    -0.04092916f, -0.01373405f, -0.05341037f, 0.01840951f, -0.03962044f, -0.04026404f, 0.02065951f, -0.06132369f, 
    0.00718306f, -0.02990863f, -0.03381316f, 0.04785555f, 0.01648849f, 0.02553846f, -0.05621363f, -0.03198669f, 
    0.00376276f, -0.06046166f, -0.04397050f, 0.00206111f, 0.01954443f, -0.03191976f, 0.01504775f, -0.04257821f, 
    -0.00308456f, -0.03149070f, -0.05698432f, 0.03153828f, 0.00549392f, -0.03637644f, 0.04271664f, 0.03191127f, 
    0.01836701f, -0.02927737f, 0.00813257f, -0.06005145f, -0.03821810f, -0.03022293f, -0.00110093f, -0.02812801f, 
    0.01715421f, 0.00748131f, -0.03959022f, -0.00333060f, -0.04797911f, 0.02531084f, -0.04361439f, 0.02858246f, 
    0.02795416f, 0.03332635f, -0.05591314f, -0.04447548f, 0.03047374f, 0.00487621f, 0.04384245f, 0.02195202f, 
    -0.03372368f, -0.03994066f, -0.01562927f, 0.03450119f, -0.01151155f, -0.04273890f, -0.03910381f, -0.03174523f, 
    -0.02189095f, 0.02942497f, 0.03851428f, 0.03778545f, -0.06392147f, 0.04759703f, -0.04500102f, 0.04328448f, 
    -0.01801547f, -0.02845335f, 0.04410836f, -0.05918770f, -0.05203580f, 0.00576160f, 0.02582689f, -0.03295393f, 
    -0.03661784f, 0.03920080f, -0.01797604f, 0.00920366f, -0.01774764f, -0.02838366f, 0.01041932f, -0.02268804f, 
    0.00073295f, -0.05873458f, -0.02011978f, -0.02516804f, -0.00876765f, 0.03421938f, -0.01784927f, -0.06071212f, 
    -0.01002073f, -0.01483937f, -0.02335151f, -0.04974713f, -0.02869578f, 0.03813824f, 0.01526122f, -0.03180809f, 
    -0.04381169f, 0.00130074f, -0.01065584f, 0.03900595f, -0.05429266f, -0.06202133f, 0.02317186f, 0.02441070f, 
    0.00793866f, 0.02056737f, -0.06380501f, -0.02694799f, 0.00287870f, -0.01942249f, -0.00297506f, 0.03909155f, 
    0.04431782f, 0.01991518f, -0.04997492f, 0.00965579f, 0.04736340f, -0.02236539f, 0.02836893f, 0.00944872f, 
    0.03202675f, 0.01359409f, 0.04935534f, -0.01727453f, -0.04698353f, -0.01828639f, 0.02296302f, -0.01815543f, 
    -0.00273100f, -0.04400463f, 0.00178273f, 0.01038268f, -0.02090453f, -0.04347530f, 0.04155581f, 0.01789602f, 
    0.02836519f, 0.00520842f, -0.02036968f, 0.01107874f, -0.02581956f, 0.03736050f, 0.01393220f, 0.04587962f, 
    0.03972001f, 0.04627685f, 0.00496564f, 0.02033675f, 0.03631586f, 0.00907765f, -0.00999715f, -0.03419050f, 
    -0.01129726f, -0.03111557f, 0.02079624f, 0.03160495f, -0.00889292f, -0.06000110f, -0.00316630f, -0.06012151f, 
    -0.00594842f, -0.02120203f, -0.05893543f, -0.00326553f, 0.02815677f, 0.02808457f, -0.03591298f, -0.06189390f, 
    0.04470716f, -0.02865731f, -0.02339915f, -0.03026553f, -0.00083442f, 0.02662668f, 0.01418966f, 0.03860786f, 
    -0.04595713f, -0.05060373f, -0.02186151f, -0.05317308f, 0.02960540f, -0.04397207f, 0.03557410f, -0.04529490f, 
    0.03461618f, -0.00848122f, -0.03339620f, -0.04229020f, -0.03970372f, -0.02803624f, -0.00542799f, 0.00800310f, 
    -0.00967103f, -0.00538126f, 0.00130743f, -0.05741933f, -0.00644696f, 0.03921467f, -0.05933470f, -0.04716422f, 
    -0.01924200f, -0.03644546f, 0.00782572f, -0.04375188f, 0.04851263f, 0.03779814f, 0.03628926f, -0.02440229f, 
    0.03364961f, -0.05763007f, 0.04377504f, -0.02327374f, -0.02456890f, 0.05339511f, -0.01477820f, -0.01389844f, 
    0.02999731f, 0.02031272f, -0.04118022f, 0.04517105f, 0.03297361f, 0.00479633f, 0.03791989f, 0.04550699f, 
    -0.02020079f, -0.00982536f, -0.04127669f, 0.03527182f, -0.04955767f, -0.03564573f, -0.03094017f, 0.01908140f, 
    -0.00263416f, -0.03215733f, 0.01916581f, 0.03945288f, -0.06154429f, -0.00011808f, 0.02353379f, -0.02152292f, 
    -0.05013721f, -0.03332971f, -0.02813708f, 0.04517354f, -0.04597996f, -0.03108309f, -0.02510415f, -0.00002764f, 
    -0.05069855f, -0.06016910f, -0.03847850f, -0.01349080f, 0.03166857f, 0.02482512f, 0.04218831f, -0.02204238f, 
    0.02864457f, -0.02498565f, -0.05125020f, 0.01968854f, 0.02663822f, -0.02413908f, -0.00863936f, -0.05472193f, 
    -0.04857026f, -0.03435522f, 0.00191365f, -0.00949316f, 0.03542652f, -0.01874684f, 0.02312960f, 0.04813458f, 
    0.03745446f, -0.03332942f, -0.02687185f, 0.00565887f, 0.01523903f, 0.02596904f, 0.00067547f, -0.00227766f, 
    -0.04968387f, -0.03288576f, 0.00436296f, -0.03578944f, 0.04818825f, 0.00773727f, -0.01570096f, -0.03080031f, 
    -0.01218692f, -0.06315120f, -0.03295372f, -0.03908605f, -0.05016945f, -0.04003313f, 0.00946259f, 0.00640843f, 
    0.05630296f, -0.05796340f, -0.00542170f, -0.00273126f, 0.00713029f, -0.04491216f, -0.01448398f, -0.01454685f, 
    0.01659566f, 0.00357288f, 0.05119831f, 0.03998590f, -0.01400519f, -0.00126576f, 0.06677561f, -0.01816355f, 
    0.01748412f, -0.00549363f, 0.02513576f, -0.02865246f, 0.05068426f, -0.00982224f, 0.01630980f, 0.00825310f, 
    0.03922218f, 0.00147249f, 0.01818640f, -0.00191710f, -0.04583256f, -0.04377766f, -0.05928805f, 0.04319760f, 
    0.04132240f, -0.02867227f, 0.01626656f, -0.05719800f, 0.03106305f, -0.04346178f, 0.02859791f, 0.01769391f, 
    0.00032109f, -0.04229930f, 0.00889463f, -0.04269330f, 0.02399782f, 0.02497714f, 0.01892160f, -0.03822091f, 
    0.00386144f, 0.02904528f, -0.05122443f, -0.02250350f, -0.00967383f, 0.03552122f, -0.04249471f, -0.04316042f, 
    0.04369331f, -0.04666372f, -0.03150159f, 0.01383731f, -0.03673440f, -0.00816052f, -0.04210209f, -0.05033980f, 
    -0.06149379f, -0.05088603f, 0.03428803f, -0.03030696f, 0.00151098f, -0.03941223f, -0.03197125f, -0.00085690f, 
    0.01587669f, -0.02772808f, 0.02648637f, -0.02778813f, -0.06010624f, -0.00055276f, 0.01022827f, -0.04092636f, 
    -0.03577984f, -0.02149863f, 0.01901574f, 0.00216278f, -0.05418764f, -0.02324212f, -0.04716041f, 0.03862006f, 
    -0.00236625f, -0.03521710f, 0.03552442f, 0.04955620f, -0.04578172f, -0.04541813f, -0.01844225f, -0.04251508f, 
    -0.05286585f, 0.02633122f, -0.00234725f, -0.04273941f, 0.02792255f, 0.00182685f, -0.05391152f, 0.00119786f, 
    -0.02032106f, -0.02558831f, 0.04906465f, -0.01688237f, 0.03776116f, 0.02779742f, 0.00228203f, -0.00009506f, 
    0.01571019f, -0.01039161f, -0.00004432f, 0.03358537f, -0.00005535f, -0.02003085f, -0.02517881f, -0.03195021f, 
    -0.06482070f, -0.00401761f, 0.03938782f, 0.01101007f, -0.01977264f, 0.04216957f, 0.02606764f, 0.03554607f, 
    0.04604510f, -0.04432345f, -0.01814611f, -0.03921612f, 0.03708870f, 0.00196730f, 0.03395908f, 0.04134669f, 
    -0.03230138f, 0.00627125f, 0.02773171f, 0.04223775f, 0.04382747f, -0.03660198f, 0.04116191f, -0.02274424f, 
    -0.04409583f, -0.01720840f, 0.04939134f, 0.03441573f, -0.03505182f, 0.03713498f, 0.02283903f, -0.01157752f, 
    0.04652921f, 0.03512743f, -0.01431493f, -0.02733026f, 0.03566350f, -0.02695500f, 0.00671488f, 0.01419200f, 
    -0.02759719f, 0.04568289f, -0.02807207f, -0.03824206f, -0.03543874f, -0.00910283f, 0.02027915f, -0.05542120f, 
    -0.01178033f, -0.02254568f, -0.03988535f, -0.05026528f, -0.05468123f, -0.04235784f, -0.02003353f, 0.04573047f, 
    0.00753498f, 0.00341433f, 0.02608507f, 0.02150018f, 0.00133250f, 0.00030014f, 0.00828352f, -0.00663266f, 
    0.01937688f, 0.00706693f, 0.03555927f, 0.02677617f, 0.05060808f, -0.03038234f, -0.03163224f, -0.03585520f, 
    -0.02759943f, 0.04047842f, -0.01942463f, 0.03935331f, 0.02638148f, -0.04474036f, 0.04937503f, -0.01634212f, 
    -0.02755994f, -0.04127854f, -0.05272924f, 0.03818419f, -0.03829262f, -0.03684379f, -0.00346820f, 0.02312588f, 
    -0.03627656f, -0.02151698f, -0.01617799f, -0.05049324f, 0.00231687f, -0.01872786f, -0.06322533f, -0.01598725f, 
    0.00662796f, 0.05995219f, 0.05461848f, -0.02484905f, 0.05266485f, 0.05427383f, -0.04585617f, -0.04080018f, 
    0.02372594f, -0.01640227f, -0.01244480f, 0.03650344f, -0.03862867f, -0.06500852f, -0.04544442f, 0.00576176f, 
    -0.03076568f, -0.13247448f, -0.12189478f, 0.04218043f, 0.20636828f, -0.06718537f, -0.05156247f, 0.06029645f, 
    0.00849453f, 0.04381006f, 0.02623575f, -0.02289163f, -0.02924103f, -0.02974920f, -0.03691721f, 0.12252260f, 
    0.03502076f, 0.07469739f, 0.02325944f, -0.04251466f, 0.00357708f, 0.22635120f, 0.13187443f, -0.35200208f, 
    -0.11916351f, 0.15187606f, 0.19596696f, -0.07275961f, -0.05676793f, -0.05700397f, 0.05895788f, 0.11125293f, 
    -0.05764855f, -0.09892988f, -0.08397926f, 0.02222258f, -0.01792969f, -0.02877405f, -0.06828145f, 0.03977805f, 
    -0.16972329f, -0.08779215f, 0.12703356f, -0.16433440f, 0.01758080f, 0.14885408f, -0.03230747f, 0.02988821f, 
    -0.04579861f, -0.00514805f, 0.11602520f, 0.03137175f, 0.00828137f, 0.02609126f, 0.06510644f, 0.02600208f, 
    -0.00283801f, 0.16296780f, 0.04099227f, 0.02148869f, -0.08889870f, 0.02124262f, 0.14741416f, -0.12937115f, 
    0.01974595f, 0.05168316f, -0.13000000f, -0.03871370f, -0.03771826f, 0.05018489f, -0.07164954f, -0.07317097f, 
    -0.04986368f, 0.08444133f, 0.12705076f, 0.04476364f, 0.08909280f, -0.06675024f, 0.10020475f, 0.00227620f, 
    0.45006695f, -0.30307826f, -0.15835591f, 0.00819538f, 0.05010474f, 0.01225698f, -0.04701070f, -0.07630482f, 
    -0.05204723f, 0.09884687f, -0.01485622f, -0.01424383f, 0.09376367f, -0.14536719f, 0.02714732f, -0.00640624f, 
    -0.05779107f, -0.02415809f, -0.03767527f, 0.11011566f, 0.43731064f, -0.26220351f, 0.02602217f, 0.06118307f, 
    0.03506878f, -0.06435309f, -0.13875663f, -0.14345302f, 0.00111839f, 0.10497719f, 0.01504391f, 0.02314111f, 
    -0.07745352f, 0.02461256f, 0.03025512f, -0.14822488f, -0.15103082f, 0.03702013f, -0.05861758f, -0.01880530f, 
    -0.16228476f, 0.11696663f, -0.03845716f, -0.07871162f, -0.15118615f, 0.02655666f, 0.13995171f, 0.02329977f, 
    -0.02485001f, 0.03546816f, 0.07116817f, 0.13711767f, 0.09628887f, 0.12299132f, 0.04876735f, 0.01089732f, 
    -0.00037164f, 0.09193926f, 0.01582779f, 0.08435900f, 0.47941470f, -0.29236978f, -0.06763784f, -0.02620168f, 
    0.09448270f, -0.05926364f, 0.06204231f, -0.11611649f, 0.02497016f, 0.00728742f, -0.06541288f, -0.09547114f, 
    0.05122380f, 0.00720536f, 0.00139900f, -0.00653681f, -0.00017373f, -0.06637441f, -0.12895021f, 0.05975157f, 
    0.01975392f, 0.04998204f, 0.08596364f, -0.07063615f, -0.03922328f, 0.10604257f, 0.12422974f, -0.09303620f, 
    -0.10077209f, -0.02558153f, -0.02215979f, 0.00218224f, 0.01605809f, 0.09115479f, 0.00876005f, -0.06986351f, 
    0.03587873f, 0.07183221f, 0.06328505f, 0.02551824f, -0.04044594f, -0.06226877f, -0.12840891f, -0.10165658f, 
    0.03561578f, 0.12795621f, 0.17169896f, 0.01538574f, -0.03117998f, -0.02716162f, -0.02934062f, -0.04226546f, 
    0.07977666f, 0.01790794f, -0.03127449f, 0.13173752f, 0.01255436f, 0.07225850f, -0.02694283f, -0.01490382f, 
    0.07101177f, -0.08289536f, 0.06230198f, -0.14913121f, -0.22054814f, -0.05692556f, 0.08300154f, 0.03620973f, 
    0.02896100f, 0.02007879f, 0.11301297f, 0.02885601f, -0.03224628f, -0.03551019f, 0.02430436f, 0.16023964f, 
    -0.06311672f, -0.07110685f, 0.05284715f, 0.04375304f, 0.30583736f, 0.07864244f, -0.08472461f, 0.01892751f, 
    -0.02791536f, 0.07917006f, 0.06585244f, -0.00456989f, 0.09675187f, 0.08766993f, -0.01269322f, -0.00339192f, 
    0.02756695f, 0.03569664f, -0.07159364f, 0.10697556f, -0.01462960f, -0.06255709f, 0.06847540f, 0.07224382f, 
    0.18488377f, -0.09314338f, -0.16235261f, -0.04409104f, -0.01263216f, -0.01133371f, -0.03839651f, 0.04624106f, 
    0.00393528f, -0.09547650f, -0.10339040f, 0.02502917f, -0.21236032f, -0.15237685f, 0.06147145f, 0.04675999f, 
    0.08192135f, 0.03102489f, 0.13740163f, 0.07170948f, -0.37769943f, -0.01718572f, 0.01321996f, -0.00436331f, 
    -0.02534818f, 0.06252568f, 0.11252484f, 0.04091742f, 0.01199529f, -0.01305226f, 0.03245595f, 0.00740166f, 
    0.03291096f, 0.04944409f, -0.03768530f, 0.08793019f, 0.01381611f, 0.12690262f, 0.09592310f, -0.00794193f, 
    -0.23271544f, 0.01761305f, -0.01339650f, -0.05131975f, -0.10497550f, 0.12008581f, 0.16022168f, 0.04282787f, 
    0.06675313f, 0.00868027f, 0.01374415f, 0.01068806f, -0.10401770f, 0.04496743f, 0.01589080f, 0.01266198f, 
    -0.01048098f, -0.00848402f, -0.09782208f, 0.05530694f, -0.23564741f, -0.03272370f, -0.11660304f, 0.08221840f, 
    -0.03847597f, 0.01720201f, -0.11849998f, 0.06915491f, 0.00840977f, -0.05967136f, -0.06908093f, -0.04634832f, 
    0.01204058f, 0.14489603f, 0.04574314f, -0.00281750f, 0.04092748f, -0.16624923f, 0.05085139f, -0.01328457f, 
    0.00440697f, -0.05694460f, -0.01902595f, -0.03376797f, 0.01955487f, 0.04634912f, -0.06292556f, 0.03296316f, 
    -0.03793702f, -0.02582974f, -0.04635517f, 0.03610975f, 0.01103004f, -0.00707814f, -0.00528798f, 0.03508741f, 
    -0.05564433f, -0.04092041f, -0.05333842f, 0.02846190f, -0.05645698f, -0.04470330f, -0.05279408f, 0.02902807f, 
    -0.05791469f, 0.00214699f, -0.03892662f, 0.04850685f, 0.01770893f, 0.04582535f, 0.02341273f, -0.00479194f, 
    -0.01741019f, 0.01705283f, 0.00346439f, -0.05118089f, 0.01132377f, -0.01992942f, 0.02533285f, 0.02830456f, 
    0.01347840f, -0.04582262f, 0.02780910f, 0.02479287f, -0.00361095f, 0.01859741f, -0.00853955f, -0.00205884f, 
    -0.05439802f, -0.01834230f, 0.00950860f, 0.00441248f, 0.02599441f, -0.04823032f, 0.01772219f, -0.00414363f, 
    0.00371377f, -0.06490321f, -0.00757456f, -0.01219040f, 0.02376612f, -0.00945219f, -0.03206792f, 0.03919468f, 
    -0.02691536f, 0.00205357f, -0.04256798f, -0.04302714f, -0.04249667f, -0.02518262f, 0.01356029f, 0.02349254f, 
    0.01189853f, -0.01830801f, 0.00653992f, -0.04198669f, -0.03690086f, -0.02259314f, -0.00901744f, 0.04122493f, 
    -0.04208299f, 0.00888418f, 0.03599719f, 0.04102890f, 0.02179373f, 0.03144247f, 0.01516973f, 0.04200524f, 
    0.03828752f, -0.05701286f, 0.02934174f, -0.06040380f, -0.04579393f, 0.04194891f, 0.00108715f, -0.02444800f, 
    -0.04414723f, -0.00499919f, -0.03773487f, -0.03614059f, 0.03431610f, 0.01450627f, -0.05939360f, 0.04926165f, 
    0.02876534f, -0.04681474f, 0.02753607f, -0.05873329f, 0.03885615f, -0.00054438f, 0.03167976f, 0.02904398f, 
    0.03772404f, -0.01218159f, 0.00462610f, -0.03644723f, 0.03937146f, -0.04512132f, -0.03551841f, 0.03563894f, 
    0.02920873f, -0.03907615f, 0.01270407f, 0.01177114f, -0.05254858f, -0.02136720f, -0.04220687f, -0.04579506f, 
    0.02187954f, -0.01171074f, -0.00135899f, -0.05107050f, 0.01791111f, -0.05721811f, -0.05781141f, -0.00799399f, 
    0.04001651f, 0.03926272f, 0.00459494f, -0.05784252f, -0.03063063f, -0.03427404f, 0.04500138f, -0.01812791f, 
    -0.05132813f, -0.05301189f, -0.00150384f, -0.04000458f, -0.01203523f, 0.01476117f, -0.05885885f, -0.02263506f, 
    0.02677816f, -0.06097530f, 0.00246518f, -0.06191583f, 0.02318843f, -0.03526808f, 0.03398696f, 0.01167868f, 
    -0.05946084f, -0.00482161f, -0.02563932f, 0.04993224f, 0.05127459f, -0.02439556f, -0.05568059f, 0.01732014f, 
    -0.00559160f, 0.00406818f, 0.03101304f, -0.01563483f, -0.03521761f, -0.03819143f, -0.03857927f, 0.03710705f, 
    -0.00751683f, 0.00858492f, -0.03246338f, 0.03699497f, -0.00119636f, -0.01000923f, -0.04155890f, -0.03293405f, 
    -0.00282012f, -0.01036920f, -0.04201805f, -0.01944221f, -0.02876852f, -0.06011511f, 0.01253404f, -0.05565406f, 
    -0.00075946f, -0.02493883f, -0.04557908f, -0.05527415f, -0.02365481f, -0.05668392f, 0.00563349f, -0.04165331f, 
    -0.00320601f, -0.04274198f, 0.00289574f, -0.04616328f, -0.00901795f, 0.01432687f, -0.00017677f, -0.06249975f, 
    -0.00041400f, 0.04508981f, -0.06503585f, 0.02581878f, -0.02407670f, -0.00643355f, -0.02414278f, -0.04254805f, 
    -0.00625673f, 0.00146677f, -0.04986031f, -0.01710824f, -0.03536981f, 0.00088530f, 0.02269016f, 0.00667457f, 
    -0.01986334f, -0.03186687f, 0.02929132f, 0.02269697f, -0.06569353f, 0.00282215f, 0.00650053f, 0.02169915f, 
    0.02022032f, 0.02854847f, -0.01075468f, -0.01872710f, 0.00443825f, 0.01037074f, -0.03786742f, 0.02781084f, 
    0.03017779f, -0.00300826f, -0.02243220f, -0.00991246f, -0.03273107f, -0.03326852f, -0.02167372f, 0.04295805f, 
    0.02271247f, -0.06189528f, -0.06141507f, -0.00088649f, -0.02212420f, -0.00494794f, 0.02324793f, -0.05522272f, 
    -0.03012166f, -0.00855222f, 0.01809414f, -0.01402831f, 0.01552548f, -0.02233154f, -0.04901595f, -0.04195265f, 
    -0.06201218f, 0.03643136f, 0.00889742f, -0.01604067f, -0.00739835f, -0.02463909f, 0.03777106f, 0.04615636f, 
    -0.03533163f, -0.02290592f, -0.00491569f, 0.02685465f, 0.02733797f, 0.02475828f, 0.02709766f, -0.00908661f, 
    -0.04323842f, -0.03826163f, -0.04219044f, 0.04266658f, -0.04021548f, 0.02542880f, 0.00170191f, -0.05192130f, 
    -0.02233019f, -0.05971272f, -0.04298585f, 0.02079421f, 0.04167125f, -0.04992428f, 0.00515087f, 0.03933581f, 
    0.02179055f, -0.04259225f, -0.00605184f, -0.05655783f, 0.04394780f, -0.00260837f, 0.02761034f, -0.04080312f, 
    0.03515417f, -0.04339622f, -0.03741366f, -0.00032318f, -0.04150425f, 0.04243799f, 0.00424321f, 0.00860577f, 
    0.01767132f, -0.05436574f, 0.01477367f, -0.01670507f, -0.02678444f, -0.03530169f, 0.04379030f, 0.03999009f, 
    -0.00756610f, -0.06944908f, 0.29353824f, 0.00449986f, -0.17796071f, 0.02871978f, -0.03118298f, -0.00005409f, 
    -0.04045160f, -0.02637853f, -0.06310722f, 0.01605576f, -0.01699059f, 0.03265485f, 0.07001525f, -0.03394466f, 
    0.05674992f, 0.00611215f, 0.09142753f, -0.00256368f, 0.11071249f, 0.12472522f, 0.08320203f, 0.11377785f, 
    0.12277251f, -0.06600628f, 0.00180208f, -0.07215644f, 0.09167500f, -0.02327659f, -0.13890235f, -0.03015766f, 
    0.01839857f, 0.09670351f, 0.12808634f, 0.05696216f, 0.00947326f, 0.04314964f, 0.13264436f, -0.09910367f, 
    0.09929933f, 0.22992106f, 0.12600726f, 0.11557060f, -0.07794588f, -0.18487453f, 0.10946390f, 0.06718483f, 
    -0.07712352f, 0.10418416f, 0.05752240f, -0.07182498f, -0.08273347f, 0.06950766f, -0.07705348f, 0.05866004f, 
    0.07166348f, -0.07543763f, 0.00515143f, 0.04731370f, 0.12389424f, -0.14745393f, -0.11233243f, -0.02552032f, 
    -0.17624211f, 0.07274330f, 0.10360008f, 0.01398477f, 0.09232993f, 0.04631696f, 0.04467468f, 0.07773633f, 
    0.09285861f, -0.00475436f, -0.01705473f, 0.08314628f, -0.00260801f, 0.13969985f, -0.07907335f, -0.01832604f, 
    -0.14648545f, -0.04657283f, 0.12894954f, 0.06701522f, 0.05528083f, 0.10110705f, -0.02346150f, 0.05546438f, 
    0.09773390f, -0.10611162f, 0.16008233f, 0.01885124f, 0.01578237f, 0.09290562f, 0.07845018f, -0.03957039f, 
    0.01809218f, 0.03035674f, 0.15289964f, 0.00127761f, -0.29695195f, 0.06917220f, -0.11804697f, -0.15300979f, 
    -0.15061477f, 0.15724494f, 0.16738135f, 0.09695266f, 0.03403204f, -0.01837992f, 0.11665196f, 0.04852306f, 
    -0.02439726f, -0.06441510f, 0.06178055f, 0.09928629f, 0.09566573f, -0.05614530f, 0.03001321f, -0.02945065f, 
    0.07045961f, 0.00978958f, 0.03801486f, 0.06126268f, 0.10583808f, 0.01906596f, 0.01830564f, 0.02007302f, 
    -0.05094469f, -0.08080609f, -0.02624300f, -0.01446453f, -0.01082912f, 0.00615337f, 0.05646884f, 0.01586362f, 
    0.05823933f, 0.06995981f, 0.04222831f, -0.01022996f, -0.55367649f, 0.17659132f, -0.22293472f, -0.00567571f, 
    -0.10726470f, 0.24465263f, 0.13108972f, 0.04653575f, 0.03998389f, -0.10174631f, 0.06952333f, 0.12114193f, 
    -0.04458753f, -0.02970695f, -0.01456474f, -0.01702311f, -0.02683112f, 0.00822364f, 0.02438033f, 0.05979159f, 
    0.08454461f, -0.13335766f, 0.05323973f, 0.01212538f, -0.02349970f, -0.03552528f, -0.05344434f, -0.03531329f, 
    0.00606376f, -0.04152250f, 0.07780312f, 0.00751015f, 0.05512914f, 0.04702930f, 0.03018016f, -0.00083636f, 
    0.09606277f, 0.09275982f, 0.06752521f, 0.04729367f, 0.22847421f, -0.08933719f, 0.16767605f, 0.13661852f, 
    0.11581356f, -0.07464676f, -0.04616050f, -0.04841260f, -0.06772654f, 0.06222130f, -0.05089210f, 0.06464338f, 
    0.14023750f, -0.09674596f, 0.03698976f, 0.03242617f, 0.02195986f, -0.05653250f, 0.02622513f, 0.09667324f, 
    0.07362368f, -0.03889509f, -0.05913483f, 0.30554405f, 0.15763840f, 0.04354300f, -0.10606372f, 0.04193272f, 
    0.09642973f, 0.10063730f, -0.14758536f, 0.01361966f, -0.03791179f, 0.01191666f, 0.02804769f, -0.02902258f, 
    0.05454149f, 0.00989945f, -0.04936239f, -0.13216701f, 0.00817999f, 0.11714687f, 0.03737888f, -0.03849330f, 
    0.15726064f, 0.07721039f, -0.10522579f, -0.02276574f, -0.02158977f, 0.01777603f, 0.00499139f, 0.06736802f, 
    -0.00227645f, 0.05442209f, 0.11611399f, 0.00203837f, 0.03975005f, 0.09388430f, -0.05096505f, 0.02775373f, 
    -0.21821427f, -0.13579467f, 0.07501616f, 0.18992727f, 0.17872867f, 0.15112013f, 0.03355081f, -0.00475103f, 
    0.03088322f, 0.03890130f, 0.02062414f, 0.09673587f, 0.14298144f, 0.04911745f, 0.05529279f, 0.01132995f, 
    -0.04381026f, -0.05442119f, -0.18025433f, 0.04870301f, 0.09207530f, 0.15929480f, 0.14075777f, -0.02791125f, 
    0.18113233f, 0.02410577f, -0.05740564f, -0.01453348f, -0.00780357f, 0.00523436f, 0.10742321f, 0.06072467f, 
    0.02762711f, 0.12677805f, 0.05150231f, 0.13253580f, 0.07576273f, 0.00990998f, 0.01535092f, 0.00910358f, 
    0.03319982f, -0.03078391f, 0.17421997f, 0.05854908f, -0.02769499f, -0.01992198f, -0.12088794f, -0.02069202f, 
    -0.03313586f, -0.10628514f, -0.06635944f, 0.06083074f, 0.04833702f, -0.01222915f, 0.07113606f, 0.04194009f, 
    0.03356983f, -0.02496788f, 0.05380611f, 0.01099647f, 0.13845760f, 0.10067938f, -0.00332263f, -0.01766063f, 
    0.02533137f, -0.13265620f, 0.12503615f, -0.07689318f, -0.02526148f, -0.03319218f, -0.01579602f, 0.06208677f, 
    0.10599744f, -0.08702303f, 0.08306965f, 0.04156070f, 0.02483297f, 0.14278328f, 0.08681338f, 0.01738629f, 
    0.28626582f, 0.00650602f, -0.03731406f, 0.06157534f, 0.23706980f, -0.06656265f, 0.16161913f, 0.03712254f, 
    0.03069786f, -0.09413929f, -0.01549770f, 0.06522816f, -0.06373974f, 0.03537359f, -0.01299706f, 0.05898913f, 
    0.06153208f, 0.05979142f, -0.00882739f, -0.03165884f, -0.03685800f, 0.13940938f, 0.18932231f, -0.09759384f, 
    -0.10945234f, 0.07662904f, 0.02284747f, -0.03597411f, -0.04016903f, 0.04703830f, 0.03438216f, 0.08896841f, 
    0.00473725f, -0.01014426f, -0.12042527f, -0.03658533f, -0.03876911f, -0.00530566f, 0.02637113f, 0.00296159f, 
    0.20514193f, -0.07225262f, 0.12166774f, 0.10866435f, 0.02743157f, 0.04211463f, 0.14928015f, 0.03279134f, 
    0.08131267f, 0.00811123f, 0.00902866f, 0.02104693f, -0.07772470f, 0.12391498f, 0.05377392f, 0.03044144f, 
    -0.01519332f, 0.10893875f, -0.08534325f, 0.06574805f, 0.10937987f, -0.12804569f, -0.17142168f, -0.12715365f, 
    -0.05750252f, -0.01011715f, 0.01304531f, 0.02907153f, -0.07884068f, -0.03425309f, -0.07758139f, 0.11316767f, 
    -0.03223046f, 0.07852273f, 0.00820646f, 0.09352196f, 0.00652062f, 0.10131060f, 0.02289675f, 0.04245248f, 
    -0.10133313f, -0.07058870f, 0.00223130f, -0.02664009f, -0.07949045f, 0.06410178f, 0.12468932f, -0.03163815f, 
    0.07221914f, 0.15891616f, -0.07305600f, 0.09500737f, -0.01184731f, 0.00102366f, 0.00159776f, -0.04193249f, 
    0.02090273f, 0.00741321f, -0.00546948f, 0.05975484f, 0.23043126f, -0.09025559f, -0.23894487f, -0.13117516f, 
    -0.13618141f, -0.10403680f, -0.10530784f, -0.04780826f, 0.01793768f, 0.07655416f, -0.05694560f, 0.00624692f, 
    0.02976108f, 0.04360761f, 0.05954216f, -0.06725183f, -0.06570734f, 0.07222016f, -0.10262869f, 0.00414154f, 
    -0.19714078f, 0.08884703f, -0.14961214f, 0.00691760f, -0.10598406f, -0.06675316f, -0.04277126f, 0.03037022f, 
    -0.00019451f, 0.05448207f, 0.12319375f, 0.07083372f, 0.08830065f, -0.03115692f, 0.05255324f, -0.00515984f, 
    -0.03288978f, 0.01654214f, -0.04917878f, 0.02319828f, -0.12543178f, -0.15585548f, -0.25245431f, -0.10261685f, 
    -0.04634625f, 0.08221454f, -0.13657147f, 0.04953530f, -0.06461905f, 0.04550244f, -0.12720314f, 0.02807852f, 
    0.11127550f, 0.04030697f, 0.02982087f, 0.00825806f, 0.00094937f, -0.07458143f, -0.08917049f, 0.09856567f, 
    -0.27451164f, 0.09929647f, 0.00309111f, -0.03104739f, -0.02383776f, -0.02450597f, -0.01294730f, -0.06077247f, 
    -0.03230115f, 0.05384597f, 0.01183403f, -0.05530418f, 0.04052903f, 0.06646661f, 0.01109942f, 0.00291688f, 
    0.01778343f, -0.04085751f, -0.04318833f, -0.00803144f, -0.02579622f, 0.03018582f, -0.04655176f, -0.08668340f, 
    -0.06569495f, 0.00936184f, 0.04805789f, 0.06254913f, -0.03874280f, 0.00660385f, -0.03982200f, 0.00254555f, 
    0.01517177f, 0.00482975f, -0.02526957f, 0.06104856f, 0.01526374f, 0.02982582f, 0.03646344f, 0.00939139f, 
    0.07147462f, 0.11821146f, 0.08745572f, 0.10368446f, -0.11818364f, -0.01110925f, 0.10018778f, 0.06092696f, 
    0.05323464f, 0.05422916f, 0.00326547f, -0.03042471f, 0.04426710f, -0.13129467f, 0.09089077f, 0.21318361f, 
    -0.07823479f, 0.06971571f, 0.13836618f, 0.07192644f, -0.03183880f, 0.12694439f, 0.06988421f, 0.07329897f, 
    0.00764225f, 0.03648041f, 0.02638265f, -0.03985211f, 0.06498558f, 0.14768311f, -0.08912320f, 0.13663261f, 
    0.14673212f, -0.02979649f, -0.06667101f, 0.04975327f, -0.03758331f, -0.00502152f, 0.11284095f, 0.08004354f, 
    -0.09819102f, 0.02750849f, -0.05906581f, 0.06422252f, 0.05496823f, -0.07840161f, 0.12593296f, 0.07232212f, 
    0.02839655f, -0.11299774f, 0.02876009f, 0.06423070f, -0.09233943f, -0.10328490f, 0.08074853f, 0.06902688f, 
    0.12988709f, 0.06107056f, 0.16391258f, 0.06539450f, -0.28488398f, -0.06621950f, -0.06968027f, -0.00461357f, 
    0.14179569f, 0.08418972f, 0.04156303f, 0.08545206f, 0.05508589f, 0.04173975f, 0.14808118f, -0.08438178f, 
    0.02669333f, 0.07808714f, 0.05317733f, 0.11490941f, 0.07468504f, 0.12213379f, -0.01523376f, 0.16207637f, 
    -0.10807402f, 0.06461557f, -0.02306075f, 0.10178486f, -0.08894639f, -0.04351152f, 0.07010069f, 0.08488178f, 
    0.05444914f, 0.06574309f, 0.06445032f, 0.08763458f, -0.09175745f, 0.08424215f, 0.10158964f, 0.09001938f, 
    0.05882216f, -0.08428963f, -0.01277025f, -0.03198782f, -0.25235662f, -0.06623367f, 0.03991980f, -0.06859700f, 
    -0.08180358f, 0.02213088f, 0.00321682f, -0.04372767f, -0.00125125f, 0.00306170f, -0.05406245f, -0.01032373f, 
    0.08483770f, 0.09107978f, 0.00480892f, 0.05437946f, 0.04896569f, -0.20779690f, 0.01304881f, -0.00468008f, 
    -0.30188498f, 0.05273101f, 0.12840539f, -0.13158549f, 0.07438486f, 0.00217580f, -0.08634130f, -0.03776560f, 
    -0.12462626f, -0.03635934f, -0.08324395f, 0.11556380f, 0.04846302f, -0.04333389f, 0.06089564f, -0.02555560f, 
    -0.02690060f, -0.00154968f, -0.02654934f, -0.05045561f, -0.11018277f, 0.10174032f, 0.28462148f, 0.16434121f, 
    0.03332567f, -0.14803565f, -0.14055257f, 0.00281343f, 0.02981676f, 0.05090713f, -0.13329102f, 0.01079257f, 
    0.03882544f, 0.17904606f, 0.08700845f, -0.00879311f, -0.00318909f, -0.05153691f, 0.02968424f, -0.01440071f, 
    0.01311426f, -0.18380646f, 0.05956117f, 0.02158554f, 0.12720115f, -0.17794870f, -0.01637723f, 0.05599267f, 
    0.00059618f, 0.02268435f, 0.02495313f, 0.04108891f, 0.05151835f, -0.03627036f, -0.04722113f, 0.02268434f, 
    0.05373071f, -0.09690074f, 0.00234156f, -0.02003523f, -0.04378133f, -0.12498289f, -0.06424880f, -0.06770589f, 
    -0.07670997f, 0.03427389f, 0.08436685f, 0.11301003f, -0.05207530f, 0.09007180f, 0.15104766f, 0.07761733f, 
    0.06328551f, -0.07551163f, 0.03262218f, 0.03136856f, 0.01454005f, -0.06345994f, 0.06708485f, 0.04454304f, 
    -0.30987081f, 0.00567571f, -0.02026094f, -0.08805501f, -0.00481054f, 0.03800543f, 0.17287922f, 0.12053945f, 
    -0.02867884f, 0.00738996f, 0.11067764f, -0.03878588f, -0.05270560f, 0.05938166f, 0.08134665f, 0.01187380f, 
    0.07777032f, 0.15152358f, 0.01945338f, -0.07625235f, -0.03455325f, 0.22767270f, -0.29749367f, -0.07019480f, 
    -0.31616277f, 0.11717444f, 0.16356272f, 0.10320863f, 0.03551621f, -0.14427797f, 0.05064941f, 0.07560188f, 
    -0.00467331f, -0.06596349f, 0.02082645f, 0.23585464f, 0.20763825f, 0.01893624f, -0.03676238f, -0.05299941f, 
    -0.02872100f, 0.10666715f, 0.19542880f, 0.10473266f, 0.01667277f, -0.09697694f, -0.04114614f, -0.08145840f, 
    0.07867654f, 0.00259352f, 0.01982578f, -0.00987904f, 0.03095297f, -0.05537574f, -0.04395801f, -0.05391937f, 
    0.02560895f, 0.02477125f, 0.02155545f, 0.05208117f, -0.24607201f, -0.06134384f, -0.07570225f, -0.07404752f, 
    -0.01637298f, -0.00768863f, 0.06819908f, 0.01518409f, 0.03197774f, -0.04940089f, -0.04573076f, 0.02675060f, 
    0.04230046f, -0.01394472f, -0.07491548f, -0.00643920f, -0.01042280f, -0.00188630f, 0.04859285f, 0.07615741f, 
    -0.31275478f, 0.10742420f, -0.04823080f, -0.01366953f, 0.01940732f, -0.01576573f, -0.05426748f, 0.00801430f, 
    0.07767025f, 0.11994933f, 0.15080298f, 0.00406686f, 0.09508521f, 0.05150914f, -0.05674813f, -0.05187671f, 
    0.08958961f, 0.10160139f, -0.15130199f, -0.01877688f, 0.03627025f, 0.06112323f, 0.11357518f, 0.05966821f, 
    -0.09893917f, -0.01028837f, -0.09538150f, 0.01921796f, -0.00706537f, 0.09312703f, -0.06260109f, -0.00522400f, 
    -0.08562712f, 0.00719276f, 0.01269243f, 0.04494844f, -0.00641447f, -0.09817932f, 0.10935110f, 0.04510774f, 
    0.09382936f, -0.15592144f, -0.02003155f, 0.19440219f, 0.22780512f, 0.05307768f, -0.05768438f, 0.07524993f, 
    0.03407134f, 0.07416867f, -0.09456703f, -0.00263546f, 0.03106005f, 0.00468251f, 0.01803295f, -0.14565773f, 
    0.07722095f, -0.07270092f, -0.12202791f, 0.03615125f, -0.34627268f, -0.01951237f, 0.11486983f, -0.06896581f, 
    -0.10378577f, -0.07369965f, -0.07444410f, -0.10952646f, -0.13552158f, 0.05730046f, -0.01082963f, 0.11833432f, 
    -0.02776663f, 0.07222771f, -0.00031247f, -0.01305716f, -0.07584193f, 0.00383331f, -0.05900647f, 0.11395155f, 
    -0.03641020f, -0.07390504f, 0.10532252f, 0.20223723f, 0.21201737f, 0.06919745f, 0.07634063f, 0.15870757f, 
    0.08497152f, 0.10742646f, -0.04200678f, 0.07042947f, 0.02656730f, 0.14739129f, 0.06571509f, 0.02215652f, 
    -0.02217981f, -0.13079885f, -0.05646913f, -0.08598112f, 0.35101792f, -0.03624971f, -0.00645492f, 0.01141357f, 
    0.17991488f, -0.07409237f, -0.07346495f, -0.05928184f, 0.05599608f, -0.05238000f, 0.01528618f, 0.04678641f, 
    -0.00258358f, 0.06791276f, 0.01118017f, 0.00506749f, 0.07414509f, 0.02206631f, 0.07464493f, -0.00225694f, 
    0.19314390f, 0.14320607f, 0.10530911f, 0.16971977f, 0.10458452f, -0.05341655f, -0.11621650f, 0.05946610f, 
    -0.00443300f, -0.00633870f, -0.00682519f, 0.10660927f, 0.06012718f, -0.01052681f, 0.03755607f, 0.07712003f, 
    -0.00993426f, 0.06926284f, 0.08393464f, 0.00518522f, 0.34933257f, 0.08126673f, 0.11273189f, 0.14704296f, 
    0.10172333f, -0.08468647f, 0.15052158f, -0.14597511f, -0.02791796f, -0.02108992f, 0.01713198f, 0.05969995f, 
    0.05716277f, 0.00003493f, 0.00616028f, 0.02198377f, 0.14695255f, 0.02546733f, -0.05568989f, 0.06802163f, 
    0.02632974f, -0.02830777f, 0.03471001f, -0.02825885f, -0.03415485f, -0.05494434f, -0.03029766f, -0.02060411f, 
    -0.03981434f, 0.01693453f, -0.03153405f, 0.02890741f, 0.03811949f, -0.03292630f, 0.03317863f, -0.06055401f, 
    -0.03226325f, -0.01425438f, -0.05740834f, -0.00644130f, -0.03141415f, 0.02955806f, -0.02395443f, -0.02873653f, 
    0.02065754f, 0.03474922f, -0.01590356f, -0.03689888f, -0.00615717f, -0.03343288f, -0.01790041f, -0.04484021f, 
    -0.02710127f, -0.04353200f, -0.04111864f, -0.00485358f, -0.00875197f, -0.00028627f, -0.05733085f, -0.04432373f, 
    -0.05191839f, -0.01341976f, -0.05571895f, -0.02078979f, 0.04989355f, 0.00972871f, 0.01925077f, 0.00568349f, 
    -0.02171757f, 0.01681602f, 0.03936491f, 0.03191076f, 0.01768778f, -0.05610885f, -0.04956258f, 0.02190072f, 
    0.01552614f, 0.00045603f, -0.02350854f, 0.03987419f, 0.00490562f, -0.02781490f, 0.04714343f, 0.04376175f, 
    -0.04047064f, -0.01722138f, 0.00882664f, 0.03676117f, 0.01373085f, -0.05774659f, -0.02680791f, -0.01363630f, 
    -0.04342783f, 0.01841232f, -0.05517444f, -0.05185821f, -0.04185653f, 0.04048762f, 0.02392048f, 0.00335683f, 
    -0.05267798f, -0.03401486f, -0.02724989f, -0.01162098f, 0.00985328f, -0.03378809f, -0.05516622f, 0.02311059f, 
    0.00984845f, -0.00402147f, 0.01244381f, 0.02619152f, 0.01210301f, -0.03134466f, -0.00338248f, -0.00810136f, 
    -0.02338684f, -0.04673274f, -0.01254406f, 0.01829461f, 0.03438230f, 0.00355782f, 0.02877401f, -0.04768744f, 
    -0.00885926f, -0.04521028f, -0.00998226f, -0.03082622f, -0.01806068f, -0.01063422f, 0.04456215f, 0.03553313f, 
    0.00983302f, 0.03945222f, -0.00585316f, 0.01382417f, -0.05421166f, 0.04055877f, -0.03879099f, 0.03268292f, 
    -0.04881778f, 0.02010801f, -0.03242370f, -0.01711909f, -0.00651099f, -0.03533238f, 0.02161706f, -0.00295147f, 
    0.01441993f, -0.04892979f, -0.03633479f, 0.02601784f, 0.04828708f, 0.02302426f, 0.03206477f, -0.02217325f, 
    -0.02483018f, 0.00258135f, -0.01323891f, -0.04092342f, -0.04544209f, -0.00501120f, 0.04067403f, -0.04336026f, 
    -0.01508781f, -0.05561874f, -0.05338953f, -0.01904032f, -0.03045678f, -0.00199713f, -0.02366091f, -0.01984256f, 
    -0.04423802f, -0.04167423f, -0.02448647f, 0.00565862f, -0.02886267f, -0.02833438f, 0.02808580f, -0.03167988f, 
    -0.05209992f, -0.02133401f, -0.01167837f, -0.01861136f, 0.00766719f, -0.05937623f, -0.02014819f, 0.04190778f, 
    0.04106646f, -0.01606318f, 0.03943989f, -0.03459490f, 0.04019550f, -0.01086409f, -0.01876124f, 0.03740581f, 
    0.02763597f, 0.01699239f, 0.03852836f, -0.06079850f, -0.02667405f, -0.05064879f, 0.03987057f, -0.05117602f, 
    0.02081954f, -0.01185026f, 0.00439923f, 0.02653681f, -0.00017014f, 0.04570895f, 0.00289842f, 0.03967870f, 
    -0.02971055f, -0.02258534f, -0.01432358f, 0.02742696f, 0.04077889f, -0.00110919f, -0.05481766f, -0.03000993f, 
    -0.03026741f, -0.00887974f, -0.05916374f, -0.00771806f, -0.04030687f, -0.05668269f, 0.02675517f, 0.02462410f, 
    0.02143942f, -0.03301666f, -0.01036934f, -0.00846698f, -0.02895774f, -0.01219776f, 0.04530434f, -0.05864323f, 
    0.01121207f, -0.04576668f, 0.01534622f, -0.06128193f, -0.00159118f, 0.00413560f, 0.02333165f, 0.03080847f, 
    -0.02378961f, -0.04308966f, 0.01511679f, -0.02895312f, -0.00201938f, -0.01724879f, 0.03096253f, -0.01053899f, 
    0.00396850f, 0.01076826f, -0.01801264f, 0.01725362f, -0.01806180f, -0.03153576f, 0.04808702f, -0.04037010f, 
    0.02580505f, -0.04976464f, 0.00483440f, 0.02614841f, -0.05260531f, 0.02738310f, -0.00616994f, -0.05294656f, 
    0.00794138f, -0.04522653f, 0.04274642f, -0.02730071f, -0.02971659f, 0.00514535f, -0.00882406f, -0.01792726f, 
    0.04837289f, 0.01765704f, 0.01755572f, -0.03597730f, -0.03160376f, 0.02567759f, 0.03875335f, 0.00097660f, 
    -0.00513515f, -0.05066359f, -0.00600344f, -0.05395792f, -0.02478120f, -0.03935563f, -0.05260646f, -0.01474703f, 
    0.00039416f, -0.02290044f, -0.01482137f, -0.02943460f, 0.03103371f, -0.01555634f, -0.04320423f, -0.01412924f, 
    -0.02936046f, 0.03269844f, -0.01307125f, -0.04380326f, -0.03529746f, -0.02508496f, 0.00835670f, -0.03921661f, 
    0.04052455f, -0.05498152f, -0.00899599f, 0.02808334f, -0.02175496f, -0.03238025f, -0.03202832f, 0.01999110f, 
    0.03179859f, -0.01835934f, 0.00946293f, 0.04512301f, -0.00631186f, 0.00112138f, 0.02148020f, -0.04717153f, 
    0.04428485f, 0.03499441f, -0.05183862f, 0.03545882f, 0.00172046f, 0.00465923f, -0.00681528f, 0.02315291f, 
    -0.01813101f, -0.01028492f, 0.01945314f, -0.05932624f, 0.03924109f, 0.03170399f, 0.01178357f, 0.02077536f, 
    0.30389279f, 0.27783215f, -0.18133596f, 0.04675735f, 0.15243636f, 0.04729325f, 0.00115630f, 0.05029060f, 
    0.11112025f, 0.08219191f, -0.01839143f, 0.09103913f, -0.01354365f, 0.06058957f, 0.01066298f, -0.11567991f, 
    0.13324340f, -0.04310047f, -0.04988566f, 0.08194114f, -0.31035450f, -0.04050548f, -0.01483880f, 0.21577395f, 
    0.09219545f, 0.22719376f, -0.02872712f, 0.01316637f, -0.00335746f, 0.03466088f, -0.00603991f, 0.06705474f, 
    0.04370907f, 0.00459177f, -0.06243280f, 0.08351124f, 0.03948298f, -0.00919219f, -0.00934219f, -0.05298465f, 
    0.26827782f, 0.07846142f, 0.02195476f, 0.22925879f, 0.04947472f, 0.02790598f, 0.10036859f, 0.00561015f, 
    0.14214462f, 0.02835492f, 0.04538826f, 0.04690541f, 0.04864113f, 0.04987589f, 0.03681262f, -0.02371206f, 
    -0.01123989f, 0.06142288f, -0.05427693f, 0.04630951f, -0.00098229f, 0.19750082f, -0.12277637f, 0.05278733f, 
    0.01358632f, -0.04957235f, 0.03961055f, 0.15111868f, 0.02247512f, 0.04557049f, -0.07817914f, 0.13619553f, 
    -0.01945863f, -0.05936624f, -0.02422173f, -0.00125697f, 0.00054189f, 0.01928913f, 0.07370269f, 0.08116011f, 
    -0.19570757f, 0.20596331f, -0.02945485f, -0.01989590f, -0.07139993f, 0.00833235f, 0.12276926f, 0.11746611f, 
    0.06757522f, 0.09595151f, 0.04103060f, 0.08255249f, -0.16918075f, 0.07648394f, 0.07371322f, -0.04272962f, 
    0.03475150f, 0.00536052f, 0.09074229f, -0.05416417f, 0.15658568f, 0.18267994f, -0.09554305f, -0.03967541f, 
    -0.07179853f, -0.10792841f, -0.08101625f, 0.07578112f, 0.03337931f, 0.01203007f, -0.04259295f, -0.01502695f, 
    0.11570588f, 0.05963228f, 0.12184843f, 0.01841107f, 0.11471783f, 0.02222481f, 0.06132784f, -0.04444745f, 
    -0.30287009f, -0.07109593f, -0.22720431f, 0.02477501f, -0.07906441f, -0.08512621f, -0.07272148f, -0.10446834f, 
    0.08218658f, -0.02299717f, 0.13330534f, 0.00955301f, 0.06577322f, 0.01904428f, 0.08252380f, -0.06811648f, 
    0.03812357f, 0.03419359f, -0.04791579f, -0.00196186f, 0.14906234f, -0.10358707f, 0.13798477f, -0.06942894f, 
    0.08280502f, -0.05362962f, -0.11220899f, 0.05829502f, 0.01467202f, 0.09188800f, 0.00736274f, 0.02879447f, 
    0.04789876f, -0.00553178f, -0.00782338f, 0.07662426f, -0.01004476f, -0.04761056f, 0.02231122f, 0.05610745f, 
    -0.46896809f, 0.10489138f, -0.07303961f, 0.02004259f, 0.09932406f, 0.05879138f, -0.01384182f, -0.02763679f, 
    0.07790305f, 0.09730870f, -0.02074828f, -0.02593544f, 0.03214190f, -0.03213534f, 0.00217864f, 0.10048579f, 
    -0.00608460f, -0.03335646f, -0.09070132f, -0.05611441f, -0.12904347f, 0.02039824f, 0.07368182f, 0.12480804f, 
    0.01695395f, 0.07650504f, 0.00832414f, 0.05598025f, -0.12383664f, 0.07906429f, -0.03159906f, 0.08652102f, 
    -0.13322566f, 0.02766872f, 0.06730055f, 0.06757092f, -0.00079548f, -0.07505036f, 0.02369844f, -0.07673098f, 
    0.04731407f, 0.09261302f, 0.09629881f, 0.14517213f, 0.13850288f, 0.03723487f, 0.04111728f, -0.00953313f, 
    0.03619477f, 0.03562822f, -0.04994874f, 0.01589577f, -0.01282423f, 0.01923777f, 0.04889090f, 0.03689212f, 
    -0.09115098f, 0.02329546f, 0.04123004f, 0.14313170f, -0.18044972f, 0.07083674f, 0.28884965f, 0.17331995f, 
    0.11261694f, 0.09323565f, 0.06517282f, -0.00084556f, -0.07878857f, 0.10865867f, -0.00927001f, 0.15858072f, 
    0.02309758f, -0.05832947f, -0.04837554f, 0.04389013f, 0.01102205f, 0.03843163f, 0.01083776f, -0.02762209f, 
    -0.05535593f, 0.23975468f, 0.14663751f, 0.04609713f, -0.02566407f, 0.12660858f, 0.04750446f, 0.00299091f, 
    -0.09386004f, 0.04753869f, 0.01069183f, -0.10098615f, 0.05299005f, 0.04109608f, 0.10058733f, 0.14100559f, 
    0.09223340f, 0.07273839f, 0.05160278f, 0.03571532f, 0.01083791f, -0.03433233f, -0.15774441f, 0.02851040f, 
    0.01105589f, -0.01145565f, -0.01091918f, -0.00135482f, -0.01788649f, 0.02753141f, 0.03408922f, -0.08214014f, 
    0.03288437f, 0.10365576f, -0.00910400f, 0.04175516f, 0.00496073f, -0.05277397f, 0.02555494f, 0.07052696f, 
    0.02154589f, 0.03978853f, -0.16882922f, 0.18776761f, 0.04773725f, -0.03952246f, -0.09476715f, 0.04105161f, 
    -0.01303271f, 0.04525917f, 0.03706666f, 0.03176577f, 0.04940074f, 0.09499978f, 0.10047362f, 0.01183430f, 
    -0.00595336f, 0.01609771f, 0.06391831f, 0.04342414f, -0.06015911f, -0.03186392f, -0.02019066f, -0.05624293f, 
    0.04127979f, -0.01978170f, 0.01751869f, -0.07373197f, -0.00157958f, -0.01347944f, -0.05008022f, 0.00866944f, 
    0.08209532f, 0.16697648f, 0.01490918f, 0.01260617f, 0.01556549f, -0.08663902f, -0.00996049f, 0.11578586f, 
    0.35717839f, 0.15248720f, 0.02717349f, 0.06503990f, -0.11269864f, -0.02650983f, 0.10892412f, -0.04098168f, 
    0.10507398f, -0.02390492f, 0.01443301f, -0.04589824f, -0.10415626f, 0.01993472f, 0.00265059f, -0.03917532f, 
    0.09472216f, 0.00157265f, 0.08656125f, 0.02429221f, 0.02545012f, -0.08875121f, -0.02531660f, 0.17481636f, 
    0.07166744f, 0.03913141f, 0.01545024f, 0.05331461f, 0.07250399f, 0.06621176f, -0.01346906f, 0.04318505f, 
    -0.10154198f, -0.05674274f, 0.08638998f, 0.02299626f, -0.01110969f, 0.10897391f, 0.11942562f, 0.09227940f, 
    0.20508318f, 0.18976952f, 0.08724456f, 0.15290712f, -0.11735103f, 0.03284741f, 0.10830041f, -0.03921955f, 
    0.04331051f, 0.06055711f, -0.05660769f, -0.01017027f, -0.00196619f, 0.03028116f, -0.01209285f, 0.02706879f, 
    0.01564557f, 0.03226159f, -0.03265158f, 0.13555397f, 0.12050625f, 0.07011030f, -0.11499494f, 0.07272732f, 
    0.13094321f, 0.10526408f, -0.01669373f, -0.12071367f, 0.09130290f, -0.03283667f, -0.06519519f, -0.01346006f, 
    -0.02200624f, 0.00464978f, 0.00990390f, -0.00061003f, 0.03106799f, 0.12127499f, 0.01300649f, 0.05302192f, 
    -0.04268220f, 0.09543262f, 0.02780204f, -0.02971428f, -0.04236958f, -0.01811122f, -0.04650369f, 0.10314016f, 
    0.13639683f, -0.08259199f, -0.05559142f, 0.02592662f, -0.05758579f, 0.00659466f, -0.06040804f, -0.01575806f, 
    -0.04361138f, -0.00325829f, 0.03383947f, -0.04926749f, -0.33390361f, -0.05887458f, 0.07998700f, -0.02689472f, 
    0.24799089f, -0.03021525f, 0.01054889f, 0.02589701f, -0.05407000f, -0.03401778f, -0.11254483f, -0.08052894f, 
    0.07846159f, 0.03755612f, 0.03805503f, -0.10468423f, -0.10156323f, 0.00555168f, 0.00238000f, 0.02886784f, 
    -0.27175429f, -0.13754852f, -0.15804592f, -0.04385462f, -0.07704127f, 0.03739353f, 0.05192017f, 0.02392067f, 
    0.03556835f, -0.00781407f, 0.06093340f, 0.00580911f, -0.01346806f, -0.00566470f, 0.05263225f, 0.04937002f, 
    -0.06509102f, -0.02009788f, -0.03753792f, -0.01882030f, -0.19736978f, 0.14622140f, 0.01392801f, 0.03813031f, 
    0.03098821f, 0.07239934f, -0.07095162f, -0.08134408f, 0.00992738f, 0.04013086f, -0.03434752f, 0.07818875f, 
    -0.00567318f, -0.00928867f, 0.01905436f, 0.04869439f, 0.04919821f, 0.02539692f, 0.09786575f, -0.12225907f, 
    -0.25466940f, -0.05665539f, 0.06861605f, 0.05905992f, -0.01774749f, -0.06969823f, -0.04393745f, 0.09708536f, 
    0.05131256f, -0.07406346f, -0.04915822f, 0.05441020f, -0.07401070f, -0.00200517f, 0.10150825f, 0.09087785f, 
    -0.10096378f, -0.12301171f, 0.05027823f, -0.00836642f, -0.01658251f, -0.03824054f, 0.03342396f, 0.15076721f, 
    -0.02446339f, -0.06894744f, 0.00438342f, 0.07356003f, -0.06595910f, 0.02934530f, 0.03587858f, 0.09873766f, 
    -0.01109293f, 0.00119765f, -0.04722396f, -0.03938258f, -0.00116470f, -0.01778385f, 0.03553959f, 0.04500505f, 
    0.06376559f, 0.08219825f, -0.07751479f, 0.18147199f, 0.13734737f, -0.00163018f, 0.03102464f, -0.01270532f, 
    0.00562778f, 0.06148581f, 0.04137489f, -0.01608466f, -0.02723794f, -0.06350402f, 0.05409738f, 0.05995001f, 
    -0.09952942f, 0.04829105f, 0.13665707f, 0.01610794f, 0.13215406f, -0.02327553f, -0.02187704f, 0.14361522f, 
    0.26342922f, 0.03199868f, 0.11634366f, 0.04580680f, -0.01704086f, 0.08243725f, 0.00882345f, -0.08127653f, 
    -0.07037122f, 0.01797730f, 0.02754257f, 0.01475888f, 0.04134987f, 0.07478462f, 0.11362685f, -0.07461080f, 
    -0.10683764f, 0.04389063f, 0.05577250f, -0.01828671f, -0.01328386f, 0.01732393f, 0.04070279f, -0.07364866f, 
    -0.08021225f, 0.00728864f, 0.17426799f, -0.08847455f, 0.08401249f, -0.02982875f, 0.01617332f, -0.06850890f, 
    -0.00082267f, 0.07270580f, 0.03275591f, 0.01585438f, -0.19015102f, 0.18206470f, -0.11939430f, 0.01597846f, 
    -0.10104302f, 0.08765411f, 0.09151188f, 0.02646568f, -0.04073204f, 0.08564516f, -0.00782872f, 0.03659531f, 
    0.03809955f, 0.07713635f, -0.04567781f, 0.06550966f, 0.04460414f, -0.00743990f, -0.04294503f, 0.00343006f, 
    -0.12226355f, -0.08478356f, -0.06492057f, -0.08683042f, -0.16641739f, -0.03045527f, 0.04230494f, -0.01352490f, 
    -0.02391788f, -0.00143253f, 0.01149738f, -0.00835373f, 0.05127816f, 0.03524939f, -0.02249627f, -0.10828647f, 
    0.03301738f, -0.00105436f, -0.05140278f, 0.05835179f, -0.28268462f, -0.03662111f, 0.10262003f, -0.19793725f, 
    -0.16757891f, 0.07080332f, -0.04252748f, 0.00938601f, 0.05712924f, 0.02433212f, 0.00647549f, -0.07006202f, 
    -0.00099419f, -0.06326950f, 0.08139756f, 0.12872350f, 0.00186138f, -0.12797126f, -0.02121209f, 0.02632643f, 
    -0.04362206f, -0.04448123f, 0.00885869f, 0.00677312f, -0.04469147f, -0.04458199f, -0.05705355f, 0.04092737f, 
    -0.00468235f, -0.00308640f, 0.02323183f, -0.01114033f, 0.04781317f, 0.04151824f, 0.00081914f, -0.05933247f, 
    -0.03687348f, -0.01574356f, -0.04723860f, 0.04017511f, -0.00679317f, 0.02263436f, -0.05620947f, -0.03645897f, 
    0.01276503f, 0.03301793f, -0.05315555f, 0.03644343f, -0.04628937f, -0.05857000f, 0.04766563f, -0.03514038f, 
    -0.05879120f, -0.01247064f, -0.02004092f, 0.00212502f, -0.01353722f, 0.01391598f, 0.00685219f, -0.03859857f, 
    -0.01217802f, -0.04001399f, -0.04501756f, -0.05369136f, 0.04073975f, -0.03502160f, -0.05239725f, 0.03805050f, 
    0.01928205f, 0.00655221f, 0.04290897f, -0.01807829f, -0.04706867f, 0.04824460f, -0.00269003f, -0.06019885f, 
    -0.02359825f, 0.01999109f, -0.01816061f, 0.01792124f, -0.01870646f, 0.03920446f, 0.03997269f, -0.03510045f, 
    -0.04074341f, -0.05720118f, -0.03404688f, 0.00659498f, 0.04981387f, -0.03895930f, -0.05021800f, 0.01364119f, 
    0.03840094f, -0.01638288f, -0.02286335f, -0.03144507f, -0.03605684f, 0.00190324f, 0.00898585f, -0.04441367f, 
    -0.03186595f, -0.03199809f, -0.04084686f, 0.01072469f, -0.04027571f, -0.03834022f, -0.03893502f, 0.04535744f, 
    0.01274911f, -0.05212107f, -0.00853841f, -0.03103804f, -0.01955401f, -0.01401989f, -0.05915889f, -0.03950005f, 
    0.04906802f, -0.05595008f, 0.00073451f, -0.04893140f, -0.05831712f, -0.02495675f, 0.00115332f, -0.02210305f, 
    0.00676323f, 0.01343482f, -0.03394477f, 0.01921990f, 0.01346184f, -0.04837959f, -0.00993343f, -0.01316702f, 
    -0.05947203f, 0.03746693f, 0.02338623f, 0.00674898f, 0.03444680f, -0.00067107f, -0.03909966f, -0.00114131f, 
    0.00331577f, -0.01094641f, -0.01499295f, 0.01777619f, -0.03221799f, -0.00571882f, -0.03921002f, 0.04005170f, 
    -0.06095524f, -0.00838942f, -0.00126863f, -0.04936539f, -0.04752516f, -0.02426348f, -0.05491237f, 0.01349589f, 
    -0.02007953f, -0.04934165f, -0.00688415f, 0.01430529f, -0.02214979f, -0.02457157f, -0.03652646f, 0.01744105f, 
    0.02280946f, 0.03327915f, -0.04083831f, -0.00470637f, -0.03887216f, 0.03377430f, 0.01865293f, -0.03850241f, 
    -0.00636537f, 0.04122187f, -0.02388782f, -0.02470105f, -0.04460084f, 0.04884531f, 0.00803092f, -0.00130167f, 
    0.04160623f, 0.02473927f, -0.03515914f, 0.03567863f, -0.02278101f, 0.02043257f, 0.03467455f, -0.00153294f, 
    -0.05029175f, 0.00476708f, -0.01363449f, -0.04802646f, -0.01577092f, -0.00688415f, -0.05990875f, -0.03502064f, 
    0.04368478f, -0.00239641f, 0.03742252f, -0.00543314f, 0.03024308f, -0.02125097f, -0.03259175f, 0.04602139f, 
    0.01732285f, 0.03631081f, -0.05143287f, 0.02794753f, 0.04673991f, -0.00546976f, 0.02894723f, 0.02994707f, 
    0.02791792f, -0.01317052f, 0.04017978f, -0.06044206f, -0.05749781f, -0.04216557f, 0.01981957f, 0.02107071f, 
    -0.01446736f, 0.00811296f, 0.04040915f, 0.00896958f, -0.04152913f, 0.04664099f, 0.02544911f, -0.01296277f, 
    0.03806506f, -0.01698132f, -0.03362680f, -0.00631306f, 0.04728964f, 0.00148273f, -0.05445139f, -0.05832457f, 
    0.01051611f, -0.04411304f, -0.01613078f, -0.01343817f, 0.02841688f, 0.04576523f, 0.04873914f, 0.00745785f, 
    -0.02916233f, 0.02898152f, 0.01862465f, 0.00909835f, 0.01199342f, 0.00825100f, 0.01342882f, -0.05037798f, 
    0.00795254f, 0.01696247f, 0.01406155f, 0.01763760f, 0.04484076f, -0.00816801f, 0.04089295f, 0.02004452f, 
    0.04523502f, -0.01817534f, -0.04845361f, 0.03137407f, -0.05246695f, -0.00225421f, 0.01759880f, -0.03510810f, 
    0.00763654f, -0.02591384f, -0.01165391f, -0.03758356f, -0.00295120f, -0.00514314f, 0.03649358f, 0.02315520f, 
    0.01702276f, -0.00873177f, -0.00431511f, -0.03557052f, -0.05154722f, -0.03140481f, -0.02340811f, 0.01827491f, 
    0.01004628f, 0.04968727f, 0.00454552f, 0.04550092f, -0.03508668f, -0.03494380f, -0.02384096f, 0.00184303f, 
    -0.02240526f, -0.01981810f, 0.01674784f, -0.03047306f, 0.03582533f, -0.02312090f, 0.00704993f, -0.01777334f, 
    -0.01326543f, -0.05747010f, -0.04965779f, -0.01189400f, -0.02978627f, 0.04583490f, -0.06044915f, -0.05245648f, 
    0.03396439f, -0.01389798f, 0.02220464f, 0.04210582f, -0.04469829f, -0.02126645f, 0.00873077f, 0.03666149f, 
    -0.01726244f, -0.02677925f, -0.05322674f, -0.04708664f, 0.01872967f, -0.03798604f, -0.04490988f, -0.03464168f, 
    -0.00659878f, 0.04277800f, -0.05440425f, 0.01373075f, -0.04250101f, -0.00309514f, 0.03262421f, -0.04404626f, 
    0.04101823f, 0.01120347f, 0.02355496f, 0.01644160f, 0.02756812f, 0.02261291f, -0.00496411f, -0.03947475f, 
    -0.02688907f, -0.02988905f, -0.04718459f, 0.01465955f, 0.04176874f, -0.02442613f, -0.02355470f, -0.01681886f, 
    -0.01438787f, -0.04998306f, -0.00460722f, -0.04523767f, -0.02916860f, -0.04272740f, -0.05615413f, -0.02946392f, 
    0.00418090f, 0.01591826f, -0.00045382f, 0.02339047f, 0.04310705f, -0.05217361f, -0.00786605f, -0.06177638f, 
    0.03002572f, -0.05307069f, -0.02927424f, -0.03010193f, 0.04803515f, 0.03157913f, -0.04974998f, 0.00954865f, 
    0.00123343f, -0.04394628f, 0.03347154f, -0.02659087f, -0.05137325f, 0.03046399f, -0.02430640f, 0.00708024f, 
    -0.02953587f, 0.01089002f, -0.04425297f, 0.00899899f, 0.03396061f, -0.04660225f, -0.05566517f, 0.02529974f, 
    -0.05604454f, 0.03339007f, -0.02205115f, 0.01077528f, 0.00292764f, -0.01283598f, -0.04672464f, 0.02757250f, 
    -0.04405710f, -0.00046908f, -0.03875173f, 0.03267553f, -0.01369136f, 0.04500729f, -0.05158279f, 0.04191013f, 
    -0.01209208f, 0.03696527f, 0.04904169f, -0.05901738f, 0.00263461f, 0.04262767f, 0.01292847f, -0.01728682f, 
    -0.00323391f, 0.00266486f, 0.02902251f, 0.04704837f, -0.05790095f, -0.02740366f, 0.04589363f, 0.04405370f, 
    -0.04075411f, 0.04647409f, 0.04657298f, 0.01647340f, -0.04861195f, 0.00686241f, -0.05260869f, 0.02335506f, 
    0.04022054f, 0.01015610f, -0.01954945f, -0.00393534f, 0.04148072f, -0.02262382f, 0.01484603f, -0.05121860f, 
    -0.02037509f, -0.00656323f, -0.02444017f, 0.00248732f, -0.02257116f, -0.00263581f, -0.00066181f, 0.01952645f, 
    -0.06056191f, -0.04482571f, -0.05402511f, 0.01175264f, -0.03502226f, -0.04430129f, -0.05853285f, 0.03258480f, 
    -0.05529316f, -0.02119005f, -0.05700542f, -0.01651666f, 0.02543207f, 0.01524962f, -0.05575671f, 0.04451086f, 
    -0.03653819f, 0.01555347f, 0.03253218f, -0.00487128f, -0.00180547f, 0.03724359f, -0.01217824f, 0.00949338f, 
    0.03755349f, -0.01933661f, -0.04315991f, 0.01773057f, -0.02830853f, 0.04507741f, -0.01627629f, -0.01376653f, 
    -0.01723973f, -0.00636689f, -0.00896043f, -0.02759106f, -0.00215953f, -0.01369598f, 0.01062736f, -0.00963712f, 
    -0.02168232f, -0.03821379f, -0.03058670f, -0.01840327f, -0.03876258f, -0.00086818f, -0.06239657f, -0.01968423f, 
    -0.03809121f, -0.05069133f, 0.01880118f, -0.02188862f, 0.00141389f, -0.04777215f, 0.04853109f, -0.04482269f, 
    0.02626361f, -0.03625813f, -0.02691551f, -0.03940747f, -0.04684797f, -0.02261303f, 0.02086436f, -0.04468431f, 
    -0.02771417f, -0.02859350f, -0.00939419f, 0.01561376f, -0.05244166f, -0.00741872f, -0.02718329f, 0.04062764f, 
    -0.02953683f, -0.05832510f, 0.02738667f, 0.01799367f, 0.00964528f, 0.00533587f, 0.04696787f, 0.02250554f, 
    -0.04533718f, -0.02809953f, -0.06165995f, -0.02650722f, 0.04453633f, -0.02180463f, -0.05044792f, 0.04852965f, 
    0.01072606f, -0.04464349f, 0.02979054f, -0.05866257f, -0.02979936f, 0.01862581f, -0.00566851f, -0.05434177f, 
    -0.04424945f, -0.04847897f, 0.00886504f, 0.01471390f, 0.00107844f, -0.01625314f, 0.02060718f, 0.04466958f, 
    0.02782485f, -0.05093369f, -0.00061879f, 0.03016914f, 0.01732801f, 0.00662076f, -0.04729046f, -0.00373353f, 
    0.05179714f, 0.03129172f, -0.05882293f, -0.05268105f, -0.00912660f, -0.03080655f, -0.02775104f, 0.01858180f, 
    -0.02178836f, -0.01785035f, -0.05308478f, 0.02455553f, -0.04522542f, -0.00008945f, -0.01900880f, -0.04832158f, 
    -0.03922516f, -0.00557690f, 0.00751167f, 0.03817992f, -0.02403234f, -0.01348135f, -0.02118184f, -0.02484549f, 
    0.02523563f, -0.06341075f, -0.01315526f, 0.04446566f, 0.00949050f, 0.02389478f, -0.05779247f, 0.02804258f, 
    0.02700188f, -0.04388339f, -0.03647900f, -0.04131404f, -0.02952441f, 0.02309578f, 0.02679672f, -0.05240708f, 
    0.04603095f, -0.05743441f, 0.03199041f, -0.02879203f, 0.02623040f, 0.04262885f, -0.04708795f, -0.02134480f, 
    0.01303639f, -0.05253368f, -0.03404302f, -0.02114279f, 0.03388967f, -0.01175342f, -0.02004948f, -0.00576220f, 
    -0.02151310f, -0.00591839f, -0.05651043f, 0.01917530f, -0.05227044f, -0.01357069f, -0.02029799f, -0.04482939f, 
    -0.02325988f, -0.04874904f, -0.04636811f, -0.05312977f, 0.03388879f, -0.02356792f, 0.02101779f, 0.00675677f, 
    0.04628285f, 0.02004928f, -0.03631728f, 0.04554680f, -0.01835429f, -0.04949279f, 0.04415764f, -0.03015947f, 
    0.03166709f, 0.02199702f, -0.01174455f, -0.05157353f, 0.04593845f, -0.05173522f, -0.06286747f, 0.03654018f, 
    0.04901744f, 0.04086122f, -0.03506780f, 0.00503693f, -0.01459858f, -0.01312740f, -0.00201765f, -0.03923081f, 
    -0.02735984f, -0.02367109f, -0.00368899f, -0.02130928f, 0.00656856f, -0.02385067f, 0.00471250f, -0.05021683f, 
    0.00773814f, -0.02919442f, 0.01174089f, 0.05054413f, -0.02028037f, -0.01351610f, 0.01702413f, -0.01646144f, 
    -0.04518763f, 0.02366710f, 0.02515284f, -0.00789845f, 0.03578901f, -0.00956645f, -0.06442734f, -0.01490137f, 
    -0.01002380f, -0.00016243f, 0.02427126f, -0.01117254f, -0.05310936f, 0.02415213f, 0.01990878f, -0.02385036f, 
    -0.00846267f, 0.02382186f, 0.04671621f, 0.03287035f, -0.02833874f, -0.01486881f, 0.01916714f, -0.00687446f, 
    0.00456234f, -0.00077799f, -0.03875477f, 0.02544857f, -0.00293755f, -0.00673648f, 0.04380393f, 0.04894496f, 
    -0.00827790f, -0.02556140f, 0.02015983f, 0.00102402f, 0.04213167f, -0.04868390f, 0.05453661f, -0.04603273f, 
    -0.04127933f, 0.02050066f, -0.04374146f, 0.02086473f, -0.01280589f, -0.01493789f, 0.00621112f, 0.03284583f, 
    -0.01869847f, -0.06374779f, 0.03628720f, 0.00854305f, 0.02432099f, -0.03687443f, -0.03742108f, 0.04155191f, 
    0.02342715f, -0.00185266f, 0.02917628f, -0.04983736f, -0.03772500f, -0.03648139f, -0.03938184f, -0.06070852f, 
    -0.02399398f, 0.01866953f, 0.01231875f, 0.00358665f, -0.02324235f, -0.04038731f, -0.00498888f, -0.05281097f, 
    -0.02078371f, -0.05031255f, -0.01625581f, -0.02883776f, -0.00870076f, -0.03820163f, -0.01848219f, -0.00808876f, 
    0.04337819f, 0.03421624f, -0.02721710f, -0.02116118f, 0.00498898f, 0.00828535f, -0.03616849f, -0.02358293f, 
    -0.04360301f, -0.04162348f, 0.04553227f, -0.02497783f, -0.00769348f, -0.04284483f, 0.02389723f, 0.03444348f, 
    -0.05886466f, 0.01490630f, -0.05754005f, -0.05740643f, 0.03805924f, 0.04712050f, -0.05641263f, 0.03014284f, 
    0.02006243f, -0.04029892f, 0.04637921f, -0.05533117f, -0.04801134f, -0.01401521f, -0.02676332f, -0.01670792f, 
    -0.00476040f, -0.00818913f, 0.01180353f, 0.00014457f, -0.03705274f, -0.01285595f, -0.03167626f, -0.04579420f, 
    -0.01438874f, 0.04193614f, -0.04739661f, -0.02975008f, 0.01440645f, -0.03637774f, 0.01360342f, -0.02927269f, 
    -0.05930220f, -0.03586723f, 0.00438682f, -0.02947217f, -0.01084305f, 0.00652099f, 0.02082177f, 0.04054506f, 
    -0.03461103f, -0.03570450f, -0.03860967f, -0.04873187f, 0.00833273f, -0.04676922f, 0.00463412f, 0.03800887f, 
    -0.03080494f, 0.03789289f, -0.04897437f, -0.00997695f, -0.05102016f, 0.01239402f, 0.01272704f, 0.01603205f, 
    -0.05640139f, -0.02310671f, -0.01807561f, -0.04994958f, 0.00580945f, -0.02727669f, -0.04629903f, -0.02006331f, 
    0.01501503f, -0.01336009f, -0.00684411f, -0.04014026f, -0.04461479f, -0.02120003f, 0.02293327f, -0.00812595f, 
    -0.05016443f, -0.00638945f, 0.01105040f, -0.04872812f, -0.02928923f, 0.02295315f, 0.01582260f, 0.03529711f, 
    0.01134667f, 0.03059167f, 0.01362393f, 0.04021736f, -0.01880670f, 0.03487442f, -0.04542858f, -0.02641508f, 
    0.04672089f, -0.00283028f, -0.00311118f, -0.05040377f, 0.01613298f, -0.02098351f, -0.04889577f, 0.04591300f, 
    0.03227372f, 0.00426827f, 0.00667235f, -0.04734692f, 0.05222701f, 0.04459245f, -0.01186388f, -0.04197540f, 
    0.01084452f, -0.05392315f, 0.04687015f, -0.00028277f, -0.06231843f, 0.03044408f, 0.02365593f, 0.05085875f, 
    0.03940986f, 0.00025424f, -0.03851417f, -0.02377740f, 0.04496335f, -0.00488039f, 0.02354024f, -0.03922248f, 
    -0.02325231f, -0.02113842f, -0.02937721f, 0.03103990f, 0.02580669f, -0.04218043f, -0.04896008f, -0.00280716f, 
    0.02636687f, 0.01941554f, 0.05022298f, -0.05188181f, -0.06378458f, -0.00708291f, 0.04553279f, -0.05918406f, 
    0.00683891f, -0.00065708f, 0.03778907f, -0.01299062f, 0.02327896f, -0.01669817f, 0.01857762f, 0.03847979f, 
    0.01006233f, 0.03501718f, 0.04073293f, -0.05504051f, -0.06450555f, -0.02602123f, -0.04074129f, -0.01715320f, 
    -0.04355883f, 0.04198895f, 0.04687560f, 0.04035324f, 0.04667436f, 0.01002933f, -0.04273833f, -0.00947925f, 
    -0.00914305f, 0.00330998f, 0.00117935f, 0.04062130f, 0.00179911f, 0.02442547f, -0.04594512f, -0.02558561f, 
    0.03086116f, -0.00218289f, 0.03509546f, 0.03372076f, 0.04343394f, 0.04258458f, 0.04282196f, -0.02238003f, 
    -0.05306396f, 0.03206589f, 0.03071208f, -0.05242610f, -0.01959883f, 0.00909992f, -0.05368508f, -0.05437481f, 
    0.02575095f, -0.03947508f, 0.00935065f, 0.01388627f, -0.00625626f, -0.00016719f, -0.01190400f, 0.03233568f, 
    0.03710049f, -0.04236392f, -0.01286889f, 0.02798694f, -0.00697924f, -0.03104714f, -0.05500570f, -0.02732203f, 
    -0.03523269f, 0.01572957f, -0.05904607f, -0.03688025f, -0.01554808f, -0.05243790f, -0.02018405f, 0.01937881f, 
    0.04420415f, -0.04119930f, -0.00889727f, 0.04524865f, -0.03905729f, 0.03715160f, 0.00048947f, -0.03246011f, 
    -0.06101103f, 0.00970851f, -0.00498599f, -0.00978582f, 0.00686911f, -0.01751497f, 0.01152091f, -0.03860724f, 
    -0.05747015f, -0.06576876f, 0.01320955f, -0.04524377f, -0.04590504f, -0.02302703f, 0.01327995f, 0.03527381f, 
    -0.04693017f, -0.03888467f, 0.03116554f, -0.05453664f, -0.07304854f, -0.00320894f, 0.02517061f, 0.01746993f, 
    -0.00841026f, 0.02000008f, -0.08616726f, 0.04478645f, 0.01491600f, 0.00650136f, 0.03026592f, 0.03000189f, 
    -0.02441317f, -0.07580620f, -0.00444367f, -0.00744831f, 0.04639217f, 0.01942318f, -0.03045977f, 0.03593811f, 
    -0.04279671f, -0.05778280f, 0.02515093f, 0.03283432f, 0.03589393f, -0.05168708f, -0.01778335f, 0.00352647f, 
    0.04152273f, 0.00533023f, -0.01160781f, 0.02461419f, 0.03896546f, -0.00124957f, -0.04748931f, -0.03893648f, 
    0.02084440f, -0.06744623f, -0.00850363f, -0.03555718f, -0.02912631f, -0.00749638f, 0.03631902f, -0.05745903f, 
    -0.04790083f, -0.05552850f, -0.01218457f, -0.05471296f, -0.04882903f, 0.00383966f, -0.04450336f, 0.01642715f, 
    0.00688930f, -0.04392732f, -0.02880226f, -0.06971033f, -0.04509265f, -0.07426059f, 0.02544294f, -0.06785423f, 
    -0.07207516f, 0.01670243f, 0.02187101f, -0.04861366f, 0.03550540f, -0.03690592f, -0.01642277f, -0.03195957f, 
    -0.07486115f, -0.03641600f, -0.01572147f, 0.02325445f, 0.01342848f, 0.04350986f, -0.02889517f, -0.02447753f, 
    -0.02304325f, 0.02048728f, 0.00047170f, -0.04345653f, -0.06931484f, -0.02566548f, -0.01557144f, 0.02946656f, 
    0.02905458f, -0.06029345f, -0.04056064f, 0.04154781f, -0.05764120f, 0.02421646f, -0.04892645f, -0.02816518f, 
    -0.02063233f, 0.02114689f, -0.01082806f, -0.03549726f, -0.00520551f, 0.03014208f, 0.02206410f, 0.00071687f, 
    0.00603017f, -0.04605937f, -0.01077117f, -0.00916004f, -0.03656210f, 0.00289115f, -0.06955357f, -0.06746785f, 
    -0.02904701f, -0.05220444f, 0.01158104f, -0.05406420f, -0.04562805f, -0.03672785f, 0.02034163f, -0.00308806f, 
    0.03390502f, 0.02914600f, -0.00908437f, 0.00507355f, -0.04813461f, -0.02406413f, 0.00424898f, -0.04156534f, 
    0.04271153f, 0.00927519f, -0.02704794f, 0.00800637f, 0.01185561f, 0.02387854f, -0.00257637f, -0.07167466f, 
    -0.01574399f, -0.06998838f, -0.01214322f, 0.00517148f, -0.04701594f, -0.03448971f, -0.02353532f, 0.00600864f, 
    -0.01820620f, -0.02934746f, -0.00843140f, -0.00428425f, 0.01376709f, 0.04134586f, 0.00958440f, -0.05332851f, 
    -0.06583273f, 0.01808028f, -0.00165157f, 0.02740112f, 0.01803054f, -0.01227653f, 0.04018760f, -0.00614973f, 
    0.03528108f, 0.03058786f, 0.02300868f, -0.03589685f, -0.03742094f, -0.00734536f, 0.02690408f, 0.03527358f, 
    -0.00569396f, 0.00837913f, 0.01527673f, -0.02669143f, 0.02147851f, -0.00843939f, -0.03063978f, 0.02229995f, 
    0.00445651f, -0.02696694f, 0.01873699f, 0.00851173f, 0.01364068f, 0.03653347f, 0.00771598f, -0.03286460f, 
    0.01716219f, 0.00857196f, 0.00616914f, -0.02672303f, -0.05737662f, 0.04083844f, -0.05327509f, 0.00858404f, 
    -0.03083520f, 0.03753076f, -0.00174401f, -0.04329866f, -0.00881938f, 0.03735223f, -0.04498221f, -0.00716498f, 
    -0.06878234f, -0.06557630f, -0.06940048f, -0.03088152f, -0.06446020f, 0.01339561f, -0.01653908f, -0.01120936f, 
    0.01357410f, -0.02209514f, -0.05018239f, -0.02565390f, -0.03838598f, 0.04623372f, 0.00838644f, -0.04849921f, 
    -0.06251661f, 0.03721236f, 0.02965610f, -0.03107190f, -0.04283676f, 0.02598457f, -0.03822617f, -0.06317329f, 
    0.03543992f, -0.01123271f, 0.03106037f, 0.01420848f, 0.00472686f, 0.01615327f, -0.03373809f, -0.02242810f, 
    -0.05127220f, -0.02395202f, 0.02099287f, 0.00192360f, 0.03171354f, 0.00103993f, -0.04940712f, -0.07043057f, 
    -0.05810590f, -0.05486252f, 0.01483434f, -0.06501509f, -0.00262181f, 0.02134477f, 0.02606031f, 0.02161987f, 
    0.00128852f, -0.00916943f, -0.06433721f, 0.02289713f, 0.03802793f, 0.00060099f, -0.02380435f, 0.02508437f, 
    -0.06770050f, -0.02265211f, 0.00780347f, 0.02472481f, 0.03705050f, 0.01460455f, -0.00238726f, -0.01815678f, 
    -0.00486155f, -0.05445615f, -0.06040206f, -0.01565954f, 0.00359003f, -0.06021624f, -0.05840456f, 0.03330971f, 
    -0.02723692f, -0.06036602f, 0.00577133f, -0.02028240f, 0.01236268f, 0.01877548f, 0.04632727f, 0.03551112f, 
    -0.07023013f, 0.00196453f, 0.01955557f, -0.02970600f, -0.05411886f, 0.01282581f, 0.00714879f, -0.03523628f, 
    0.01084007f, 0.00019482f, 0.00108130f, -0.03261761f, -0.06150435f, 0.01462587f, -0.02613491f, -0.00963467f, 
    0.03486538f, 0.01353556f, 0.03836647f, -0.00780119f, -0.06536908f, -0.00264549f, -0.03558112f, -0.04420142f, 
    -0.05186714f, 0.01893357f, -0.05205374f, -0.04958617f, 0.01417579f, 0.00562921f, -0.02942282f, 0.03096758f, 
    0.03197708f, -0.01874778f, -0.03915536f, -0.05269207f, -0.03764839f, 0.00930836f, -0.05452000f, 0.01567277f, 
    0.03022967f, -0.05955097f, -0.02506768f, -0.02899385f, 0.03797062f, 0.04193514f, -0.03732405f, -0.00076889f, 
    0.04947303f, 0.04061663f, -0.06009386f, 0.04317630f, 0.03781004f, -0.01417568f, -0.04991204f, -0.03028410f, 
    -0.04411722f, 0.00790199f, 0.03377131f, -0.03783581f, 0.01667476f, 0.03780673f, -0.04225527f, 0.01310873f, 
    0.01654053f, -0.05840427f, 0.01490750f, -0.03639683f, 0.04212620f, 0.01783176f, -0.06014304f, -0.00178833f, 
    -0.04491412f, 0.02872306f, -0.03677278f, -0.00705103f, -0.05525748f, -0.00552061f, 0.02398318f, 0.01695651f, 
    -0.04739339f, 0.00760661f, 0.02759323f, 0.02881584f, -0.01860807f, 0.03807681f, -0.04874646f, 0.02306516f, 
    0.01355936f, -0.02654253f, 0.00512984f, -0.00691597f, -0.01605104f, 0.00913417f, -0.06000734f, 0.00574085f, 
    0.04090161f, -0.05386229f, -0.00391321f, -0.05384897f, 0.01028526f, -0.04288720f, -0.00208952f, -0.03104574f, 
    0.00100761f, 0.04759387f, -0.02003355f, 0.02026904f, 0.02363754f, -0.05225237f, 0.04400215f, -0.00083882f, 
    0.00567896f, -0.03467111f, -0.05114780f, -0.00537106f, 0.00618966f, 0.01356016f, 0.01860415f, -0.06058010f, 
    -0.04647097f, 0.01916614f, -0.03970324f, -0.03922392f, -0.03128685f, -0.05743700f, 0.03567771f, 0.03541275f, 
    -0.04802682f, 0.04962284f, -0.02853371f, 0.02594444f, -0.03165560f, -0.03097882f, 0.02968516f, -0.05432914f, 
    -0.03225823f, -0.03116199f, -0.03591523f, -0.00579923f, -0.00996325f, -0.02560484f, -0.05556878f, 0.01880088f, 
    -0.02795618f, 0.04436110f, -0.04680282f, 0.03559445f, 0.00834593f, 0.00024941f, -0.03360404f, -0.02929576f, 
    0.01514594f, 0.02379193f, -0.02746944f, 0.00788075f, -0.02330958f, 0.03232901f, -0.02970236f, 0.02442230f, 
    -0.03004743f, -0.01036388f, 0.00025611f, -0.03184418f, 0.02544578f, 0.03138563f, 0.01475250f, 0.00066489f, 
    0.04551195f, -0.00012105f, 0.00600723f, -0.01297519f, 0.01738904f, -0.02260851f, -0.04753312f, -0.02659141f, 
    -0.04127497f, -0.05448534f, -0.05173494f, 0.02577233f, -0.00753051f, 0.01815020f, 0.00972171f, -0.02234795f, 
    -0.05646524f, -0.00027751f, -0.01311002f, -0.02419784f, -0.05421387f, 0.01923149f, 0.00066089f, 0.05358203f, 
    -0.05061631f, -0.02996706f, 0.02900138f, 0.03024081f, 0.02110116f, -0.04760208f, 0.01806762f, -0.01743852f, 
    0.03296694f, 0.00107258f, 0.01263976f, 0.01527495f, -0.04778765f, 0.02278236f, 0.00930876f, -0.02512642f, 
    -0.02946189f, -0.03889962f, -0.00537786f, -0.01646217f, -0.04275156f, 0.02333459f, 0.02130342f, 0.03109563f, 
    -0.00923345f, -0.05579605f, -0.05076317f, 0.01066233f, 0.00431893f, -0.00198233f, 0.04430829f, 0.00348241f, 
    0.03561600f, -0.03983545f, 0.03755449f, -0.03027752f, -0.00401200f, -0.04901865f, 0.02153790f, 0.01197304f, 
    -0.05120167f, 0.04721551f, 0.00924023f, 0.00226068f, 0.00101261f, -0.06097484f, -0.00891061f, -0.05847752f, 
    0.00388234f, -0.06076672f, 0.04219275f, -0.05814891f, -0.02927865f, 0.00178694f, -0.01281495f, -0.02138871f, 
    -0.01197433f, 0.01141000f, -0.01300465f, -0.01185600f, 0.04024441f, -0.00504016f, 0.01223499f, -0.01765234f, 
    0.00149995f, -0.02052769f, 0.03804640f, -0.04938396f, -0.01572965f, 0.01424691f, 0.03953008f, 0.01836704f, 
    0.03742795f, 0.00442074f, -0.05125296f, -0.01863535f, -0.04252042f, 0.02117137f, -0.03605098f, -0.00416954f, 
    -0.03125114f, -0.02591035f, 0.02539744f, -0.03455636f, -0.00054853f, -0.00654436f, 0.01027181f, 0.05011790f, 
    0.04391269f, 0.01239370f, -0.00737567f, 0.02640988f, -0.03633665f, 0.03806509f, 0.00542283f, -0.05513979f, 
    -0.05330663f, 0.04100004f, -0.04998790f, -0.06054307f, 0.01160822f, 0.04736806f, -0.05478706f, -0.05502946f, 
    0.01823492f, 0.00544115f, -0.05380520f, 0.01345914f, -0.04053924f, -0.05899783f, -0.05812722f, -0.04784365f, 
    0.01181221f, -0.05667768f, 0.00229464f, 0.00404065f, 0.04724986f, -0.01950961f, -0.04649937f, -0.05277524f, 
    0.00838007f, 0.00707569f, 0.03825570f, -0.01307457f, -0.04718527f, 0.01281322f, 0.04405640f, -0.05142247f, 
    0.01495008f, 0.02287644f, 0.04069119f, -0.04968099f, -0.02610703f, 0.04044188f, -0.02822490f, 0.01927012f, 
    -0.01189988f, 0.03937842f, -0.05099731f, -0.02166678f, 0.04951472f, -0.05445309f, 0.00253191f, -0.01166155f, 
    0.04381485f, 0.01430967f, 0.03390336f, 0.00625860f, -0.03908020f, 0.02155756f, 0.02007947f, -0.01103339f, 
    -0.00406428f, 0.01314615f, -0.01655647f, 0.01335791f, -0.02054315f, -0.04515704f, -0.03211757f, -0.02657747f, 
    0.04316481f, 0.01173631f, -0.03167016f, 0.03173437f, -0.03777315f, -0.00388656f, -0.05832794f, -0.00789506f, 
    -0.00404240f, 0.00901842f, 0.01903096f, 0.04508581f, 0.03541681f, 0.01980125f, -0.05614375f, 0.04915307f, 
    0.04883027f, 0.03547990f, -0.05512561f, 0.00814423f, 0.01933751f, -0.01799423f, -0.04781863f, -0.05488586f, 
    -0.02851768f, -0.04448534f, 0.04267501f, -0.02420630f, -0.04220309f, 0.02727317f, 0.01082241f, 0.03609616f, 
    0.01780518f, -0.03291475f, 0.03703886f, 0.02540680f, 0.02172082f, 0.04233908f, -0.03549757f, -0.02682729f, 
    -0.00565238f, 0.04369767f, 0.02471015f, 0.02037548f, -0.02577587f, 0.04600144f, 0.02343222f, 0.01176366f, 
    -0.00330307f, -0.03578795f, -0.03176946f, -0.03459564f, 0.03035158f, 0.01623148f, 0.03320146f, 0.00448602f, 
    -0.06327408f, -0.01309173f, -0.06043869f, -0.00885822f, -0.01273162f, 0.00309647f, -0.01576474f, -0.04943316f, 
    -0.04206862f, -0.04231122f, -0.02398774f, -0.04947810f, 0.02772063f, -0.01925552f, -0.00630438f, 0.03551773f, 
    -0.04977049f, 0.03705701f, -0.02283981f, -0.03578703f, 0.04076052f, 0.01881670f, -0.03675960f, 0.03627663f, 
    0.00100482f, 0.01568817f, -0.02529581f, -0.00234246f, -0.01944337f, -0.03793538f, -0.02341935f, 0.01096098f, 
    -0.01590548f, -0.03054290f, -0.02185235f, 0.03375807f, -0.02982241f, 0.02852420f, 0.00675535f, 0.00515670f, 
    0.03993433f, -0.00552999f, -0.05641333f, -0.05920127f, -0.03024125f, 0.04559711f, -0.03554454f, -0.03322023f, 
    0.00879564f, -0.05819002f, 0.00800076f, -0.04264247f, -0.02006075f, -0.01759784f, 0.03919484f, 0.03165156f, 
    0.03839249f, 0.03021992f, -0.02998518f, -0.01818945f, 0.00066965f, 0.03827856f, -0.03520916f, -0.06006179f, 
    0.01352855f, -0.02648829f, -0.00549946f, 0.01271619f, -0.05069200f, -0.05857163f, -0.00111842f, -0.00182829f, 
    -0.04483371f, 0.00464404f, -0.03072815f, 0.03849817f, 0.00989584f, -0.03439052f, -0.04051831f, 0.05143086f, 
    0.02106197f, 0.04277592f, -0.02383506f, -0.02364430f, 0.03963418f, -0.03040618f, 0.00015701f, 0.04152046f, 
    0.01306252f, -0.04237822f, -0.02070879f, -0.03017867f, -0.03824050f, -0.00599215f, -0.01526202f, -0.00221839f, 
    0.01537519f, -0.01242365f, 0.00108353f, 0.04992192f, -0.02193731f, -0.05846650f, -0.02389180f, -0.07764337f, 
    0.00401237f, 0.01530242f, -0.06837028f, -0.01652500f, 0.01512736f, 0.02617610f, 0.03476612f, 0.04520652f, 
    0.00466934f, -0.04645789f, -0.05551045f, -0.01579996f, -0.04130571f, 0.02046772f, -0.00974612f, 0.03177693f, 
    -0.01167861f, 0.00132516f, 0.01479183f, -0.05259172f, 0.02730447f, 0.02404846f, -0.01558756f, -0.01357444f, 
    -0.02802446f, -0.05400748f, -0.00922998f, 0.01245642f, 0.04257440f, 0.04562581f, 0.01810198f, -0.04123946f, 
    -0.05681393f, -0.01274210f, -0.02766066f, -0.02216371f, 0.04095500f, -0.02957590f, 0.02355472f, -0.01357689f, 
    0.03481369f, -0.02937412f, -0.05526580f, 0.03458647f, -0.03722977f, 0.05442423f, -0.02774521f, 0.01831216f, 
    -0.05503033f, 0.00207081f, 0.02335391f, -0.06201191f, -0.03926725f, 0.00030777f, 0.03895241f, 0.02030104f, 
    0.04616761f, -0.03696663f, -0.01598976f, -0.04983118f, -0.03735019f, -0.01486673f, -0.00693779f, 0.01153119f, 
    0.01807404f, 0.00994591f, 0.03057824f, 0.00057879f, 0.03176356f, 0.00282654f, 0.00933375f, 0.02229134f, 
    -0.00111822f, 0.00735844f, -0.04699578f, -0.03224930f, -0.01019699f, 0.00272426f, 0.01961026f, 0.02904693f, 
    -0.00904688f, -0.02684503f, 0.03788686f, -0.01486218f, 0.00444817f, -0.01396075f, 0.01096126f, -0.02264591f, 
    0.04688086f, -0.00795630f, -0.00566295f, -0.03397141f, -0.00378085f, 0.03270597f, -0.01197654f, -0.01518340f, 
    -0.05582963f, -0.02330432f, -0.05300568f, 0.00049061f, -0.00661986f, -0.04679198f, -0.01936533f, 0.02646264f, 
    -0.05658343f, 0.03959695f, -0.02551686f, -0.01572767f, -0.05866342f, 0.01874999f, -0.04226865f, 0.00003066f, 
    0.03144791f, 0.00938341f, 0.03195231f, 0.00531245f, -0.01699928f, 0.03938312f, -0.04815040f, -0.01005260f, 
    -0.02580865f, -0.05824669f, -0.03379617f, -0.05263980f, 0.02412132f, 0.03827409f, -0.00984204f, -0.02396566f, 
    -0.05009570f, -0.02723701f, 0.01372251f, -0.03691243f, 0.02314601f, 0.02450753f, 0.02222670f, -0.02768435f, 
    0.03586309f, 0.00140767f, -0.03218437f, -0.01437515f, 0.00450227f, 0.04069592f, -0.01741496f, 0.00849861f, 
    -0.05755341f, -0.00621478f, 0.00189149f, -0.00775711f, -0.02310753f, -0.04927804f, 0.03040049f, 0.03506127f, 
    0.01200912f, -0.05315151f, -0.00934330f, 0.02782191f, -0.00668145f, 0.03257546f, -0.05338121f, -0.00112730f, 
    -0.02933626f, -0.04121982f, 0.03269516f, 0.01702664f, -0.04171964f, 0.04045923f, -0.04491849f, -0.04689470f, 
    -0.05375837f, 0.03504088f, 0.02311719f, -0.04542874f, -0.01005720f, -0.00940874f, -0.03957629f, -0.01709461f, 
    0.02641716f, -0.06335442f, -0.04901672f, 0.01340829f, -0.01670054f, -0.02846531f, 0.04019106f, -0.02385558f, 
    0.04317410f, -0.04281328f, -0.01270340f, 0.04390513f, -0.01064079f, -0.01532575f, 0.02604004f, 0.03965656f, 
    0.03285236f, 0.03049796f, -0.02082324f, 0.03506931f, -0.05248961f, -0.03113625f, 0.00937628f, 0.03493277f, 
    -0.00093063f, 0.00687952f, -0.03556829f, -0.05356335f, 0.01537657f, -0.04230268f, -0.05414359f, 0.01396781f, 
    0.01591674f, 0.02876330f, 0.04282996f, -0.02706716f, -0.05147909f, 0.03241322f, -0.01540098f, -0.00612574f, 
    -0.01162579f, -0.04206738f, 0.01594894f, 0.04246230f, -0.04006174f, -0.00828524f, 0.01788767f, 0.04777493f, 
    -0.00737583f, -0.04061837f, 0.00066705f, -0.04867245f, -0.00390290f, -0.02472688f, -0.02943625f, 0.02227100f, 
    -0.02973757f, -0.02454578f, 0.03633980f, 0.02455493f, 0.03082821f, 0.02098946f, -0.05319119f, 0.00957442f, 
    0.03967175f, 0.04974258f, -0.06451105f, -0.00990681f, -0.01061904f, 0.02709704f, 0.05260987f, -0.04241318f, 
    0.00674369f, -0.02669222f, -0.02455929f, -0.01157273f, 0.01934362f, -0.03502869f, 0.02578433f, -0.04344776f, 
    -0.00656440f, -0.04979263f, 0.03412428f, -0.02518450f, -0.05335302f, 0.01581476f, -0.01828509f, -0.04382838f, 
    -0.03410116f, -0.00994967f, 0.04555755f, 0.03628421f, -0.01620587f, 0.00781418f, -0.00911396f, -0.04846683f, 
    0.02384319f, 0.03241339f, -0.00877279f, -0.00936864f, -0.02860972f, 0.03963412f, -0.03622388f, -0.03730122f, 
    0.03718215f, -0.01445828f, -0.00863789f, 0.01930831f, -0.00563450f, 0.05260788f, -0.02677501f, 0.03619544f, 
    -0.03955196f, 0.02675274f, 0.03152238f, 0.01874100f, -0.00744766f, -0.04653496f, 0.02667318f, 0.02262325f, 
    0.04743881f, -0.06496060f, -0.04625272f, -0.03105617f, 0.04015290f, -0.02992784f, 0.00375535f, -0.02945880f, 
    -0.02850849f, 0.00481746f, -0.05784912f, 0.01019655f, 0.02924849f, -0.04426841f, 0.02627847f, 0.04341008f, 
    -0.04518205f, -0.03280942f, -0.04266503f, -0.06490967f, -0.06307919f, -0.05027500f, 0.03710474f, 0.01801340f, 
    0.02264612f, -0.04711137f, -0.02543477f, -0.03471554f, -0.02731941f, -0.05625781f, 0.03108188f, -0.05265036f, 
    0.03444465f, -0.02995885f, 0.03074757f, 0.00096686f, 0.03202192f, 0.05013521f, 0.01326497f, -0.02135415f, 
    0.02298386f, 0.02895249f, -0.01055664f, 0.02326130f, 0.04267502f, 0.02445464f, -0.04971094f, 0.01622090f, 
    -0.00514762f, 0.00480179f, 0.01890123f, -0.04463639f, -0.05151350f, -0.03708091f, -0.05305976f, 0.02188570f, 
    -0.02960872f, 0.03221786f, 0.02367695f, 0.00527381f, -0.03359444f, -0.02699941f, 0.00190283f, 0.00338389f, 
    0.00122579f, 0.02534350f, 0.01352397f, -0.04352849f, 0.00267511f, -0.05746557f, -0.04729371f, -0.04917711f, 
    -0.03136886f, -0.04538788f, 0.03439259f, -0.00386139f, 0.04390651f, 0.01401426f, -0.01432370f, 0.02798461f, 
    0.03047802f, -0.00582824f, -0.02051927f, 0.00674041f, -0.04491034f, 0.00902362f, 0.03158374f, -0.01966619f, 
    -0.03014531f, 0.00176358f, -0.04798320f, 0.02942884f, -0.03406836f, -0.05394357f, 0.05415927f, 0.05312846f, 
    0.03862953f, -0.01334531f, 0.01068688f, 0.03337483f, -0.04584375f, 0.04370372f, 0.04229629f, 0.02287868f, 
    0.03815817f, -0.02616935f, 0.02795115f, -0.02453766f, -0.02923605f, -0.03634204f, 0.00523082f, 0.00665925f, 
    0.02501329f, -0.00939564f, 0.01478157f, -0.04953666f, -0.01815213f, 0.04196189f, 0.03326529f, 0.02184155f, 
    0.02502089f, 0.03372095f, 0.01164849f, -0.01240786f, -0.04332194f, -0.03283378f, 0.01251012f, 0.01898495f, 
    0.01910103f, 0.00344140f, -0.01587517f, -0.03671873f, 0.00570921f, -0.03478064f, 0.01978334f, -0.05762559f, 
    -0.05852342f, -0.02719369f, -0.05354170f, -0.02617189f, -0.03662597f, 0.03336393f, -0.03912487f, -0.02554093f, 
    0.00700209f, -0.02747142f, -0.03499568f, 0.03811278f, 0.04889980f, 0.00612904f, -0.04304163f, -0.00496616f, 
    0.01209665f, -0.06944376f, -0.03939675f, 0.00126595f, 0.02201867f, 0.03129762f, 0.02451419f, -0.04781410f, 
    0.02577333f, 0.01314816f, -0.00983664f, -0.02914744f, 0.03853494f, 0.00826419f, -0.02444586f, 0.04548691f, 
    -0.03225020f, 0.01600227f, 0.02863759f, 0.03777915f, 0.04116569f, -0.03046247f, 0.01931475f, -0.03745029f, 
    -0.00212136f, 0.07557099f, 0.05072335f, 0.03940073f, -0.20022658f, -0.03876443f, 0.06011018f, 0.02590243f, 
    0.01055247f, -0.10007006f, 0.05562469f, -0.01631862f, 0.03398680f, -0.03824863f, -0.00149552f, 0.03112547f, 
    0.10313393f, 0.05062727f, 0.03923828f, 0.04632805f, 0.21577293f, -0.15922664f, -0.05565279f, 0.09698183f, 
    -0.01214554f, 0.00052858f, -0.03961452f, -0.12071713f, 0.02155351f, -0.04169541f, -0.00389157f, 0.02595720f, 
    0.09663881f, 0.05321324f, 0.09801473f, 0.07517657f, -0.00231148f, -0.00879548f, 0.09151209f, 0.10281869f, 
    0.01979911f, 0.12316173f, -0.04178235f, 0.11749558f, -0.08181215f, 0.11831933f, 0.08712493f, -0.11417237f, 
    -0.04050401f, 0.05598819f, 0.05030558f, -0.04206653f, 0.05499304f, -0.00814102f, -0.05761489f, -0.02787443f, 
    0.02449123f, -0.00353110f, 0.01168631f, 0.07250837f, 0.12987770f, -0.01766646f, -0.07917544f, -0.02044864f, 
    0.10939130f, -0.00193108f, -0.01268227f, 0.00636758f, 0.05350549f, -0.04975727f, 0.07399930f, -0.01618669f, 
    0.05113103f, -0.05272572f, -0.05420314f, -0.05915063f, 0.01975278f, 0.02091669f, -0.07361236f, -0.03044460f, 
    0.07046219f, -0.06879574f, -0.08660752f, 0.19138376f, -0.05865413f, -0.00189860f, -0.12748720f, 0.01984099f, 
    0.10354372f, -0.10611920f, 0.01222248f, -0.01716836f, 0.06530677f, -0.04888420f, 0.03788610f, -0.02947929f, 
    -0.11924342f, 0.05909427f, -0.08658925f, 0.00403875f, -0.21248406f, -0.12614007f, 0.15342119f, -0.01594167f, 
    0.28876474f, -0.11860766f, 0.04632364f, 0.02546264f, -0.05699521f, -0.12609036f, -0.01744525f, -0.06717713f, 
    0.03422590f, 0.01685181f, -0.01750150f, -0.10795062f, -0.10031743f, -0.03622169f, -0.06361642f, 0.01434000f, 
    0.10522697f, -0.04756985f, -0.09920885f, 0.00249554f, 0.00562434f, 0.21117564f, 0.12311243f, 0.02230252f, 
    -0.01714865f, 0.01857461f, 0.14731227f, -0.10541248f, 0.02479171f, 0.03888765f, 0.11713390f, 0.04271513f, 
    -0.06053907f, 0.01410069f, 0.07288885f, 0.03643968f, -0.33322659f, 0.29637247f, 0.02820939f, -0.01608807f, 
    0.15322895f, 0.10752342f, -0.06473390f, -0.03850066f, 0.03656298f, -0.02705735f, 0.01098714f, 0.04109821f, 
    -0.05292067f, -0.09836657f, -0.00148121f, -0.03453864f, 0.03493575f, -0.03910884f, 0.07970849f, -0.13501665f, 
    0.28303862f, -0.18363766f, -0.08548956f, 0.14106405f, -0.02358457f, -0.02887902f, 0.10076033f, -0.02585997f, 
    0.06514291f, 0.11328795f, -0.05248136f, -0.03023284f, 0.04803874f, 0.03678267f, 0.01493896f, 0.10161199f, 
    -0.09317414f, -0.00474876f, 0.05164094f, -0.03773163f, -0.07289352f, 0.08187424f, 0.10504872f, 0.17915176f, 
    -0.07391399f, -0.06664163f, -0.02470475f, -0.02133603f, -0.05472723f, 0.07144679f, 0.03869924f, 0.00335379f, 
    0.05580834f, -0.17743735f, -0.00107769f, -0.00522453f, -0.08619314f, 0.05271880f, 0.01090609f, 0.06573490f, 
    0.13716792f, 0.13876858f, -0.22267099f, -0.05586345f, 0.12784997f, -0.04357053f, -0.01110477f, 0.01736870f, 
    0.05675080f, -0.03977582f, 0.00123083f, 0.17964590f, -0.06758448f, -0.05908532f, 0.08766723f, -0.02721346f, 
    -0.07474125f, -0.00729753f, 0.05470735f, 0.03638582f, 0.30927494f, -0.13210844f, 0.06310973f, 0.00627373f, 
    0.34822157f, 0.00840933f, -0.01587648f, -0.08626079f, 0.04436249f, -0.06949469f, 0.01803814f, -0.06068445f, 
    -0.05104885f, 0.05952007f, 0.20797946f, 0.00145128f, 0.01847336f, -0.02717027f, -0.01430561f, 0.01840412f, 
    -0.06903724f, 0.12599665f, 0.05803003f, -0.07252628f, 0.08392544f, 0.00299365f, 0.00424737f, -0.09904198f, 
    0.00468797f, -0.02377895f, 0.13659926f, -0.02133789f, -0.00873478f, -0.00546813f, -0.15978801f, -0.00577418f, 
    -0.05292515f, 0.07875619f, -0.01929965f, 0.02548633f, -0.21151924f, 0.22740193f, -0.06611660f, -0.00152737f, 
    -0.15085869f, 0.08689908f, 0.07051587f, 0.15084247f, -0.06554078f, 0.01863898f, 0.07482891f, 0.09066342f, 
    -0.01364739f, -0.00839291f, 0.02737075f, 0.03053563f, 0.01950943f, -0.00478275f, -0.05306178f, -0.04906671f, 
    -0.06054410f, -0.09735996f, 0.03850293f, -0.08480801f, -0.19413291f, 0.01189091f, 0.08086296f, -0.00798364f, 
    -0.03460082f, 0.03180176f, -0.01649369f, -0.08881855f, 0.06822283f, 0.00238071f, 0.03002650f, -0.15539955f, 
    0.07982042f, 0.00601855f, 0.00915687f, 0.01214537f, -0.03230542f, -0.11177534f, 0.01391943f, -0.04791316f, 
    -0.19654527f, 0.16808383f, 0.03086646f, 0.08145899f, -0.00965515f, 0.08060208f, 0.13052790f, -0.09668120f, 
    -0.12177472f, -0.02542617f, 0.10259713f, 0.09887388f, 0.01022237f, -0.01939709f, -0.00311058f, -0.00943308f, 
    -0.02599724f, 0.12441999f, 0.10969008f, -0.22571324f, 0.02417413f, 0.02507867f, -0.00303949f, -0.01928584f, 
    -0.00248336f, 0.12130485f, -0.01482587f, 0.05818994f, 0.06592293f, 0.05058526f, 0.00427542f, 0.01764641f, 
    -0.09388186f, 0.03434332f, 0.03586928f, -0.10445329f, 0.01269008f, -0.17028514f, 0.11954556f, -0.01757289f, 
    0.04301527f, -0.26396376f, -0.08152127f, 0.06533305f, 0.02160438f, 0.08129382f, -0.03378818f, 0.00560393f, 
    -0.02652845f, -0.05525125f, 0.00457223f, 0.00190259f, 0.06870905f, 0.03857773f, 0.02838381f, -0.01810850f, 
    -0.11894877f, -0.06646456f, 0.03437100f, -0.13001125f, 0.03488263f, -0.12584934f, 0.00993259f, -0.00347552f, 
    0.03319689f, -0.02851808f, -0.10897904f, 0.01194827f, 0.05896870f, 0.02541586f, 0.06111867f, -0.04336784f, 
    0.01695246f, -0.04684453f, -0.02535844f, 0.01317950f, 0.05351903f, -0.04883825f, -0.05325809f, 0.14753745f, 
    0.01032017f, 0.04882416f, -0.00175705f, -0.02569102f, -0.05449631f, 0.01761477f, 0.13018827f, 0.01526628f, 
    -0.01449381f, 0.02625786f, 0.09647004f, 0.03562543f, -0.04214076f, -0.00203694f, 0.04906484f, 0.12836750f, 
    0.07496190f, 0.13803594f, 0.09300566f, -0.14418608f, 0.18200924f, 0.18112168f, 0.05944544f, 0.05480450f, 
    -0.11229595f, 0.01188695f, -0.03243935f, -0.01852931f, 0.05795549f, 0.13331155f, 0.01153731f, 0.06257877f, 
    0.02653690f, -0.04825842f, -0.02341913f, 0.01018017f, -0.21173698f, 0.18645030f, -0.01648483f, 0.10549691f, 
    -0.06028259f, 0.24676761f, 0.17273462f, 0.01704733f, -0.02468489f, 0.06948227f, 0.02196499f, 0.08446307f, 
    0.08111004f, 0.07073386f, -0.02142026f, 0.10031278f, 0.05853586f, -0.01438058f, 0.01928843f, -0.05484254f, 
    0.37809497f, 0.04454771f, 0.20524834f, -0.15092672f, 0.09909735f, -0.02540260f, -0.01477316f, -0.06607339f, 
    0.08761350f, 0.07562742f, -0.01830304f, -0.00225700f, 0.00465845f, 0.04731843f, 0.03246894f, 0.03340908f, 
    0.06671033f, -0.12824890f, 0.07849667f, -0.00875103f, -0.16951995f, 0.18753727f, 0.01147806f, 0.31723219f, 
    -0.01579309f, 0.03719199f, 0.00910528f, -0.00601491f, 0.07870654f, 0.09670206f, -0.02381296f, 0.03752650f, 
    0.05783202f, 0.00431513f, 0.06014783f, 0.01075765f, -0.07253946f, 0.11977490f, 0.01155101f, -0.08723052f, 
    -0.00603995f, -0.07666748f, 0.16557324f, -0.12004039f, 0.13404404f, -0.02427019f, -0.09529035f, 0.07983693f, 
    0.02807083f, 0.01924187f, 0.07393055f, 0.08353903f, 0.03863484f, -0.02204530f, -0.00391206f, -0.03770589f, 
    -0.02994568f, 0.00495591f, -0.02351233f, 0.02392670f, 0.26360524f, -0.15765280f, 0.05799793f, 0.01676593f, 
    0.03080488f, -0.02562040f, 0.03083075f, 0.02924147f, 0.10328230f, -0.04876809f, -0.06180008f, -0.02893607f, 
    -0.04569399f, -0.00286422f, -0.05320269f, 0.00953537f, 0.03789619f, -0.03613430f, 0.02752017f, 0.04824954f, 
    -0.09227730f, -0.16859002f, 0.10536562f, 0.18600027f, 0.05677612f, -0.11346635f, 0.01478264f, -0.01337173f, 
    0.05083021f, 0.09194343f, 0.02217360f, -0.02631376f, 0.10980105f, 0.02672647f, -0.05872835f, -0.13845327f, 
    0.07730205f, 0.02193654f, 0.04395580f, -0.00585010f, -0.38043633f, -0.14784996f, 0.01412336f, -0.06997202f, 
    -0.02533412f, -0.04835331f, 0.03422724f, 0.00082814f, -0.08125323f, 0.00100287f, 0.09831078f, 0.06131113f, 
    -0.00026335f, -0.05317815f, -0.12540872f, -0.03236920f, -0.05329995f, 0.01654972f, 0.04154671f, 0.06944560f, 
    0.06377129f, -0.21281385f, 0.07710231f, 0.17853563f, 0.11362028f, 0.03759013f, 0.02081009f, 0.01776243f, 
    0.18752114f, 0.07673904f, 0.04061243f, -0.01429187f, 0.07284661f, 0.04672895f, 0.02222914f, -0.07840704f, 
    -0.04190017f, -0.00069950f, 0.04803024f, -0.07882055f, 0.47043586f, 0.25801471f, 0.02267604f, 0.15211995f, 
    0.02578544f, 0.04849873f, -0.12442595f, -0.02418301f, 0.12751515f, 0.04143001f, -0.01184837f, 0.10712194f, 
    0.00844929f, 0.03342842f, 0.03294865f, 0.03974425f, 0.08183132f, 0.02209485f, 0.05165487f, -0.06002382f, 
    0.35639203f, 0.04678828f, 0.14490573f, -0.17213510f, 0.31025460f, -0.12263294f, -0.07652621f, 0.08137209f, 
    0.03400597f, 0.01505744f, 0.07677332f, 0.03613583f, 0.08622575f, -0.03690583f, -0.05799766f, 0.03288301f, 
    0.03651487f, 0.02349467f, -0.00623711f, 0.08346183f, 0.22733133f, 0.07243174f, 0.23164751f, 0.03656720f, 
    0.10302027f, 0.00713726f, 0.13441566f, -0.02640837f, 0.03015711f, 0.08081613f, 0.12364324f, 0.04050424f, 
    0.02719818f, -0.11738377f, 0.00184567f, 0.03424676f, 0.11284993f, 0.18891475f, 0.04583025f, 0.06630940f, 
    -0.04611466f, -0.01646897f, -0.04063377f, 0.01354630f, -0.02335320f, 0.01718872f, 0.00031104f, 0.00896767f, 
    -0.03056542f, 0.05086133f, -0.03669062f, -0.01335664f, -0.00573746f, -0.04480673f, 0.00258292f, 0.04342839f, 
    -0.02477344f, 0.01033328f, 0.03162409f, 0.04535277f, -0.03855176f, 0.03007630f, -0.05338451f, 0.05098257f, 
    -0.04700656f, -0.00569401f, -0.02392393f, -0.01949756f, -0.03377154f, 0.02832559f, -0.05647410f, -0.01039631f, 
    -0.00822025f, 0.03240940f, 0.05034066f, 0.00941849f, -0.05230718f, 0.02562259f, -0.02103840f, 0.05391796f, 
    0.02774516f, -0.01528518f, -0.02925501f, 0.00805628f, -0.04720971f, 0.02441742f, -0.00148908f, 0.01778479f, 
    -0.00433085f, -0.05420760f, -0.03714266f, -0.03411995f, -0.03952670f, -0.02759670f, 0.03805311f, -0.01116251f, 
    0.00109534f, 0.00225676f, -0.04845116f, 0.05184484f, 0.02940721f, -0.02587216f, -0.00821729f, -0.03752493f, 
    -0.04930154f, 0.03341827f, 0.00568050f, -0.02267807f, -0.02183826f, 0.03705336f, -0.04495912f, 0.03488724f, 
    -0.05258555f, -0.05735580f, -0.04022628f, 0.02786144f, 0.00844746f, 0.05212582f, -0.01011694f, 0.01265424f, 
    -0.00627275f, 0.02714431f, -0.02656620f, -0.03985923f, -0.00841999f, -0.04754471f, -0.02287046f, 0.01844824f, 
    0.04113514f, 0.01639667f, -0.05458926f, -0.01640519f, 0.00325485f, -0.04173631f, 0.02529767f, 0.03253889f, 
    0.03025738f, 0.03639704f, -0.02883445f, -0.06225267f, 0.01429946f, 0.04678649f, -0.05481939f, -0.03548437f, 
    0.02033418f, -0.04336004f, 0.04656550f, -0.00872321f, -0.02507716f, -0.05309410f, 0.02348078f, -0.03528365f, 
    0.04651934f, -0.04172460f, -0.03353078f, 0.03676106f, 0.00117423f, -0.00009559f, -0.05455047f, 0.04669454f, 
    -0.05590019f, -0.02730867f, -0.02691438f, -0.06177658f, -0.00499746f, 0.00905031f, 0.01061598f, 0.01880381f, 
    -0.02560920f, -0.00448022f, -0.00267007f, 0.04538905f, -0.02016116f, -0.04699193f, -0.03412542f, -0.03661154f, 
    -0.05514260f, -0.04556525f, 0.04319625f, 0.03048453f, -0.01323811f, 0.00223739f, 0.03841099f, -0.02179135f, 
    0.01172680f, -0.02068548f, 0.02790021f, -0.03088094f, -0.05059420f, -0.00910638f, 0.04076741f, -0.05811650f, 
    0.04210806f, 0.00105960f, -0.03854574f, -0.01640667f, -0.04780769f, -0.03009180f, -0.01595271f, 0.00626707f, 
    0.03266711f, -0.01152233f, -0.00367290f, 0.02608663f, 0.03758729f, -0.05997466f, 0.01647102f, -0.01688276f, 
    -0.03474196f, -0.01716798f, -0.00135136f, 0.04380391f, -0.01832913f, 0.00527003f, -0.01516620f, -0.01573169f, 
    0.00468002f, 0.01340354f, -0.03796418f, -0.02947585f, 0.04921760f, -0.01597099f, 0.01958271f, 0.01807875f, 
    -0.02889540f, -0.06353865f, -0.00614425f, 0.05738831f, -0.00858594f, -0.03525231f, -0.05458776f, -0.01610737f, 
    -0.03706560f, 0.03164782f, 0.04019683f, 0.02712232f, -0.05020072f, -0.01402267f, 0.01664388f, -0.01464525f, 
    0.05810652f, -0.02190579f, -0.01013097f, -0.03208277f, 0.02564013f, -0.02704685f, -0.02973797f, -0.04926666f, 
    0.02495264f, -0.05201777f, -0.03649207f, 0.00516446f, 0.00684132f, 0.02020956f, -0.03635199f, 0.03985158f, 
    0.04367904f, 0.05209407f, -0.04100250f, 0.02641675f, -0.04892639f, 0.03141485f, -0.05566032f, 0.03019990f, 
    0.04855932f, -0.04601439f, -0.01637927f, 0.04810975f, -0.00603246f, 0.02890683f, -0.01676231f, -0.02024622f, 
    0.03917175f, 0.02001164f, 0.03708042f, -0.00769416f, 0.04183082f, 0.04245014f, 0.03678677f, 0.01622604f, 
    -0.04286001f, -0.01229808f, 0.01534480f, -0.02225011f, -0.03816849f, -0.02417397f, -0.01144784f, 0.03106705f, 
    0.00104227f, -0.04337349f, -0.00930612f, 0.00094987f, -0.02623507f, 0.03864910f, -0.03488982f, -0.00255797f, 
    -0.04189754f, -0.00398977f, -0.03074867f, -0.01553254f, -0.03340271f, 0.02200650f, 0.00854025f, 0.05101437f, 
    -0.02807750f, -0.04348072f, 0.00007319f, 0.01866063f, -0.00627287f, 0.02428858f, -0.00070564f, -0.03641027f, 
    0.01242813f, -0.05321983f, 0.03805003f, 0.05287844f, 0.04383805f, 0.02883110f, 0.00257151f, -0.02521068f, 
    0.05424822f, -0.04125195f, 0.03311713f, 0.02910931f, 0.01162054f, -0.02982093f, -0.00917287f, -0.02352497f, 
    0.00370579f, -0.02362661f, 0.05065546f, 0.04951186f, 0.04954738f, -0.01185259f, 0.03023668f, -0.02121667f, 
    0.02824228f, -0.02134399f, 0.03911324f, -0.04616781f, -0.06011790f, 0.03676656f, -0.00519941f, -0.02933804f, 
    0.04652000f, 0.00102313f, 0.01450417f, -0.01309852f, -0.01463207f, 0.02064332f, -0.03218149f, -0.05082792f, 
    0.01607982f, 0.04631334f, 0.00116273f, -0.05473728f, -0.00093220f, -0.02075817f, -0.02499387f, -0.01735628f, 
    -0.22387527f, -0.29593933f, 0.07465644f, 0.10270353f, -0.02647359f, -0.01519082f, -0.05319183f, 0.05910618f, 
    -0.13739817f, -0.00998348f, -0.00854890f, -0.01708148f, 0.09508302f, -0.01182726f, 0.06223546f, 0.04193045f, 
    0.04402683f, 0.01287222f, 0.01146232f, -0.00244818f, 0.14463149f, 0.27153385f, 0.01256420f, 0.13241060f, 
    -0.03290756f, 0.09102146f, 0.01654299f, -0.01105737f, -0.07428204f, -0.02963421f, 0.00996001f, -0.00119878f, 
    0.11156002f, 0.11975723f, 0.09335901f, -0.00300851f, -0.04837873f, -0.02638939f, -0.09340191f, -0.06548323f, 
    -0.02182781f, -0.01476487f, -0.08229094f, -0.03398180f, 0.13385370f, 0.02479272f, -0.03425026f, 0.03851737f, 
    -0.02949807f, 0.07033654f, 0.14211807f, 0.02693808f, -0.02810610f, 0.01344173f, -0.05997226f, 0.05597153f, 
    -0.01208236f, -0.07474227f, 0.05736810f, -0.09385940f, -0.04512442f, -0.07527886f, 0.18248232f, -0.13665895f, 
    -0.04090252f, -0.00950443f, 0.07999255f, 0.10594244f, -0.02414563f, -0.01234316f, 0.03422780f, 0.05080985f, 
    0.03300468f, -0.04875584f, -0.03293194f, -0.06136119f, 0.05348998f, -0.08366501f, 0.02940614f, -0.06026537f, 
    -0.11591351f, -0.10612837f, -0.07803385f, -0.01289551f, -0.00203196f, 0.02533080f, 0.01875966f, -0.01845730f, 
    -0.01640657f, 0.03584698f, 0.11677308f, 0.00004880f, -0.01713754f, -0.07486187f, -0.00943625f, 0.04136861f, 
    -0.03673503f, 0.05839167f, 0.00103282f, 0.06793237f, 0.33958104f, -0.04642161f, 0.00470968f, -0.09699719f, 
    -0.19087546f, -0.08091423f, 0.08264402f, -0.01617063f, 0.00131562f, -0.14647731f, 0.07993678f, 0.01932060f, 
    -0.10335754f, -0.04699061f, 0.09465072f, 0.09819113f, 0.05091031f, 0.00952154f, -0.02333338f, 0.09324373f, 
    0.22434045f, 0.07827678f, 0.08718551f, 0.12571141f, 0.13236068f, 0.12357024f, 0.06274612f, 0.09919693f, 
    0.02275432f, -0.02156586f, -0.05474586f, 0.03708732f, 0.03317929f, 0.01644179f, -0.01073420f, 0.01035426f, 
    0.07972020f, 0.08639805f, 0.05291566f, 0.05908477f, 0.14466149f, -0.17048705f, -0.12423296f, -0.21544981f, 
    -0.01947156f, 0.04934890f, 0.05804964f, 0.14471163f, 0.03419568f, -0.12281880f, 0.04666400f, 0.04152561f, 
    0.01005240f, -0.00602697f, -0.06558126f, -0.03292143f, 0.00299522f, -0.04208479f, -0.04719617f, 0.15576224f, 
    0.37850025f, 0.22599527f, -0.18786816f, 0.07622944f, -0.06553875f, 0.06220550f, 0.11673221f, -0.02646767f, 
    -0.01111687f, 0.05807593f, -0.00921826f, 0.02444961f, 0.06406371f, 0.05610260f, -0.06590529f, -0.02240599f, 
    0.08452816f, 0.11796430f, 0.00473975f, -0.02783769f, -0.11660454f, 0.23756681f, 0.01467639f, -0.15899454f, 
    -0.03591980f, 0.04674128f, -0.06245272f, -0.05857287f, -0.05139624f, 0.09339488f, -0.01324654f, 0.04341155f, 
    0.06807660f, 0.06033976f, 0.05484120f, 0.02646268f, 0.05120475f, 0.02015942f, 0.03132231f, 0.02850519f, 
    -0.03825876f, 0.02767152f, -0.10452768f, -0.19965768f, 0.00014771f, 0.14049423f, -0.07618877f, -0.03306971f, 
    0.04704898f, -0.06008901f, -0.01927497f, 0.00881102f, 0.02459373f, 0.05679327f, -0.01455895f, 0.07432195f, 
    0.11988095f, -0.00205753f, -0.17571646f, 0.02657840f, 0.23590896f, 0.04952317f, -0.05780921f, -0.02722042f, 
    -0.05330115f, 0.06010534f, -0.01462364f, -0.00647354f, 0.03718359f, -0.02608171f, -0.01606735f, 0.02597347f, 
    0.09089231f, 0.11183091f, 0.12139883f, -0.01615604f, 0.02837407f, 0.00910729f, -0.12920617f, -0.00576760f, 
    0.05685029f, 0.08013856f, -0.01405544f, -0.14425410f, -0.02096815f, -0.01334192f, -0.04648686f, 0.06135119f, 
    -0.04875289f, -0.00730487f, -0.05296492f, 0.11405291f, 0.04579652f, 0.08147662f, 0.01901550f, 0.09419601f, 
    0.06790854f, -0.10798796f, -0.12144878f, -0.02343928f, 0.12754229f, -0.19955949f, 0.11584853f, -0.12037402f, 
    0.08780830f, -0.07174825f, -0.01034108f, 0.01729852f, -0.06580019f, -0.05702248f, 0.08341256f, -0.07796431f, 
    0.01398490f, -0.04177514f, 0.00252027f, -0.05747040f, -0.02950940f, 0.04208883f, 0.10085268f, -0.02881118f, 
    -0.03999575f, 0.16587436f, 0.13689260f, 0.17845301f, -0.08697030f, 0.13568605f, 0.02953030f, 0.04377724f, 
    -0.05340201f, 0.04828792f, 0.01211848f, -0.03559144f, -0.01490155f, 0.00081783f, 0.04188409f, 0.06526537f, 
    -0.01730105f, 0.02517603f, 0.05921720f, -0.02025295f, 0.25383371f, 0.14817142f, -0.08298017f, 0.17841908f, 
    0.10758988f, -0.05231109f, 0.03116435f, -0.10076930f, -0.00759707f, -0.05319139f, -0.02175703f, 0.12577954f, 
    0.03967562f, 0.08165779f, 0.04875157f, -0.02156797f, 0.02000571f, -0.02336335f, 0.06213244f, -0.04026931f, 
    -0.12353771f, 0.01100018f, -0.16844380f, -0.09770867f, 0.00704338f, 0.02934261f, 0.00073290f, -0.13081893f, 
    0.00689181f, 0.11414028f, 0.01298230f, -0.01091636f, 0.12674031f, -0.06843818f, 0.07810483f, 0.01459030f, 
    0.02662960f, -0.00738789f, -0.04078198f, 0.04578475f, -0.39060301f, -0.12290068f, -0.12038667f, 0.17426866f, 
    0.21843512f, 0.21760455f, 0.09100649f, 0.03731396f, -0.02074081f, -0.01067469f, 0.06252564f, -0.02882639f, 
    0.11540899f, 0.05195146f, 0.03529502f, -0.03746650f, -0.06662901f, -0.06709657f, -0.12540364f, -0.02646617f, 
    -0.07664994f, -0.24981412f, -0.13495059f, -0.14221956f, -0.00908345f, 0.15752663f, -0.01743835f, 0.09745859f, 
    0.03085360f, 0.02289755f, 0.05676210f, -0.00287974f, 0.01835943f, -0.08511006f, 0.02212394f, -0.03790950f, 
    0.05878579f, -0.12109557f, 0.05585404f, 0.04227838f, -0.33378953f, 0.26723066f, 0.02887048f, 0.07051279f, 
    -0.10660855f, -0.00682142f, -0.03299104f, 0.03157558f, 0.08164646f, 0.10881811f, 0.05534684f, 0.09676050f, 
    -0.04642537f, -0.04437253f, -0.04229367f, -0.08389700f, -0.02287198f, -0.02605940f, 0.07785084f, -0.06675427f, 
    -0.00804531f, 0.36786783f, -0.12365188f, -0.07652792f, 0.01490834f, -0.11432239f, -0.04845064f, -0.08988411f, 
    0.02580861f, 0.08652083f, 0.02750355f, -0.02674880f, -0.17119029f, 0.00259099f, -0.01723415f, 0.02176507f, 
    0.06710427f, 0.01388592f, 0.12798201f, 0.06049186f, 0.24267644f, 0.20272753f, -0.03762855f, 0.09846731f, 
    -0.03616778f, -0.00032397f, -0.20521732f, -0.09181235f, 0.14246497f, 0.03398331f, -0.04948265f, -0.06875665f, 
    -0.05204775f, -0.07898603f, 0.05207853f, -0.01614941f, -0.02654423f, 0.06082908f, 0.02496227f, 0.06113295f, 
    -0.25934404f, -0.09641203f, 0.16403364f, 0.05126616f, 0.11970854f, 0.09601212f, 0.00890364f, 0.01097472f, 
    -0.00272492f, -0.05606087f, -0.00146239f, -0.04987848f, 0.03694192f, 0.03456610f, -0.05162755f, -0.02418547f, 
    0.06530382f, -0.01618649f, 0.09952500f, 0.13165833f, 0.42330614f, -0.23590183f, 0.04561361f, 0.04354413f, 
    -0.04703695f, -0.25686705f, -0.02487020f, -0.00239065f, 0.06209724f, 0.07977411f, -0.01422618f, -0.00786426f, 
    0.01205815f, 0.08727850f, 0.06786862f, -0.05885986f, 0.01239153f, 0.00657575f, 0.10072754f, 0.00893919f, 
    -0.33603737f, 0.24116762f, -0.23587860f, 0.02416753f, 0.16461407f, 0.13671651f, 0.10981779f, 0.01713293f, 
    0.04342068f, -0.07783060f, -0.01024341f, 0.03164856f, -0.02847350f, 0.03736671f, -0.03816076f, 0.02201563f, 
    0.09179547f, 0.07202897f, 0.07727511f, 0.06617149f, -0.31254977f, -0.05699911f, -0.19451454f, 0.09605862f, 
    0.01636498f, 0.07002108f, 0.10085906f, -0.01501121f, -0.05320334f, -0.06565239f, -0.07312664f, -0.08221723f, 
    -0.03417274f, 0.12328686f, 0.00434711f, -0.07506675f, 0.02132489f, 0.07982671f, -0.03740318f, -0.16305244f, 
    -0.02473406f, 0.01443969f, -0.00642157f, -0.08192129f, -0.19720502f, 0.14095782f, 0.13234238f, 0.08113359f, 
    0.03374393f, 0.01593330f, 0.06612235f, 0.12789567f, 0.06131970f, 0.08951236f, 0.01830968f, -0.04647930f, 
    0.03132114f, -0.13547990f, -0.06280402f, 0.13159710f, -0.18556540f, 0.14166494f, 0.13338330f, -0.07861354f, 
    -0.10262150f, 0.08509095f, 0.11136194f, 0.01572943f, 0.09731425f, 0.00761172f, -0.05536849f, 0.01056085f, 
    0.04905888f, 0.04547665f, 0.09346786f, -0.03709196f, 0.05155598f, -0.12494997f, -0.04905524f, -0.12460054f, 
    0.30673003f, 0.10972090f, -0.12446905f, -0.17296460f, -0.23222370f, 0.05374381f, 0.00752009f, -0.04293501f, 
    -0.04185072f, 0.13698547f, -0.01733763f, 0.06288446f, 0.05363735f, 0.09879874f, 0.05922243f, 0.10237991f, 
    0.07359798f, -0.02418094f, -0.03522865f, -0.07220525f, -0.07607168f, -0.31232136f, 0.13306376f, -0.00678645f, 
    -0.11498873f, 0.00502909f, 0.01989539f, 0.06723422f, 0.00650725f, -0.07126064f, 0.08435822f, -0.01273135f, 
    -0.01967231f, -0.06922642f, -0.02489594f, -0.05384247f, 0.05208506f, -0.03343367f, 0.06828743f, 0.00099268f, 
    -0.08411643f, -0.12978142f, -0.06766145f, 0.03181428f, 0.25336125f, 0.12502182f, 0.05372705f, 0.06518467f, 
    -0.05027438f, 0.02310612f, -0.07758036f, -0.00271018f, -0.00159583f, 0.03359180f, -0.03829486f, 0.00288510f, 
    -0.00902031f, 0.14708991f, 0.06745011f, 0.04097252f, -0.06874359f, 0.06984790f, -0.03453184f, 0.10178585f, 
    0.16816404f, 0.09080786f, -0.03830566f, -0.00077138f, -0.06251451f, -0.02774964f, -0.01266920f, -0.02207562f, 
    -0.01399601f, -0.02666290f, -0.05715792f, -0.05897699f, 0.02628606f, 0.09007740f, 0.00018681f, 0.03414635f, 
    0.25390759f, 0.03383246f, -0.01718544f, 0.24511452f, 0.06015989f, -0.07715823f, 0.10162040f, 0.01528670f, 
    0.03782207f, -0.08986859f, -0.01640380f, 0.08199963f, -0.08724960f, -0.01630324f, -0.04023289f, -0.00052633f, 
    0.08602666f, -0.07391654f, 0.01671895f, 0.09789883f, 0.14597256f, 0.15234882f, -0.10274041f, 0.17516293f, 
    -0.03817875f, 0.22094890f, 0.08567648f, 0.04976458f, 0.05452111f, 0.00763551f, -0.03083191f, -0.00097803f, 
    -0.05254254f, 0.03811225f, -0.04402665f, 0.11640857f, 0.00356342f, 0.00504161f, -0.05036546f, 0.09516723f, 
    0.41765615f, 0.12956141f, -0.05613650f, 0.28812009f, 0.02630567f, 0.05831487f, 0.11272692f, -0.08220743f, 
    0.04903597f, 0.02826815f, 0.02832213f, 0.03205154f, -0.03279750f, 0.13611805f, -0.03571190f, 0.00842589f, 
    0.06002264f, 0.08910827f, -0.00896308f, -0.03274002f, 0.11755497f, 0.00081417f, -0.09593429f, -0.17513041f, 
    0.01974018f, -0.11298133f, 0.02727779f, 0.12117413f, 0.06004770f, -0.05210660f, -0.07242109f, 0.07683169f, 
    0.06177827f, -0.07850346f, -0.08579794f, 0.01536796f, 0.06813811f, 0.01827042f, 0.04533686f, -0.05528362f, 
    -0.37815040f, 0.06088913f, -0.05121724f, -0.02322426f, -0.21439655f, -0.05436634f, 0.01336007f, 0.03294211f, 
    0.11822794f, -0.01345982f, 0.02866488f, 0.09682978f, -0.16521709f, 0.07817622f, 0.04428055f, -0.07216899f, 
    -0.04943873f, 0.07023893f, -0.02178595f, 0.00674038f, 0.06020121f, -0.06917717f, -0.13633338f, -0.19765899f, 
    -0.02943465f, -0.23992766f, -0.02943355f, -0.00783527f, 0.01479411f, -0.18222362f, -0.00974948f, 0.02269840f, 
    0.08978903f, -0.06816319f, 0.16543643f, -0.04959116f, 0.01809581f, 0.01010687f, -0.05665046f, 0.06290914f, 
    -0.21761973f, -0.05794528f, -0.27079338f, 0.18922126f, -0.05446441f, -0.09148238f, -0.01917742f, 0.05537196f, 
    0.03202959f, 0.03199551f, 0.05589163f, 0.05179844f, -0.02710368f, -0.04995643f, -0.04080696f, -0.02042296f, 
    -0.02175628f, 0.05551863f, -0.07493927f, -0.09920441f, -0.14147165f, -0.11876002f, -0.02003635f, -0.28004310f, 
    0.05132258f, 0.15202354f, -0.11576249f, 0.06588645f, -0.07143670f, -0.10978159f, 0.03141616f, 0.02468618f, 
    0.08841095f, -0.02813005f, 0.00826450f, 0.02949998f, 0.08292315f, -0.04066598f, -0.02264381f, 0.11357103f, 
    -0.14465620f, 0.05319049f, -0.10388717f, 0.07098597f, -0.09115218f, -0.02364934f, -0.00021801f, -0.02690667f, 
    -0.03137836f, 0.05924998f, -0.01548728f, -0.07185262f, 0.05263450f, 0.04197437f, 0.13088115f, 0.06584463f, 
    -0.02971178f, -0.04917970f, -0.04864926f, -0.03964449f, -0.08310973f, 0.19742043f, 0.10309613f, 0.02885930f, 
    -0.06745563f, -0.00119795f, -0.05723430f, 0.02330846f, -0.08426751f, 0.09186617f, 0.09550221f, -0.02111165f, 
    -0.01617187f, -0.03024819f, 0.03897918f, 0.03689381f, -0.04831581f, 0.03513417f, 0.10396381f, 0.00904633f, 
    0.13244739f, 0.21220323f, -0.04544807f, 0.06300387f, 0.17515247f, 0.09193833f, -0.02020489f, 0.00221952f, 
    0.04394880f, 0.05599716f, -0.07957038f, -0.06283285f, -0.07395544f, -0.04764082f, 0.09038489f, 0.17039870f, 
    -0.15732381f, 0.04135713f, -0.00399657f, -0.00180062f, 0.05221991f, -0.04300763f, 0.11267493f, 0.11673220f, 
    0.22595161f, 0.17619394f, 0.01390199f, -0.04292995f, 0.03259007f, 0.06888330f, -0.09822816f, 0.05594406f, 
    0.09492099f, 0.09161028f, 0.09813501f, -0.03996859f, -0.00221318f, 0.03610560f, -0.03291415f, 0.01970712f, 
    -0.26933080f, 0.31387067f, 0.04748774f, -0.09794226f, 0.02565529f, 0.05119177f, 0.00469788f, -0.02435886f, 
    -0.08956172f, -0.01736817f, -0.01674697f, 0.00679584f, 0.08727333f, 0.07390599f, 0.03316268f, 0.03830621f, 
    0.03314361f, 0.00866709f, 0.03115360f, 0.06446564f, -0.12195027f, -0.16488135f, -0.13423410f, -0.04469777f, 
    0.05101153f, -0.08226730f, 0.11022784f, 0.01666993f, -0.09845957f, -0.01431962f, 0.02807475f, -0.03578126f, 
    -0.02959133f, 0.09851522f, 0.01395046f, -0.00265059f, 0.00638440f, 0.02292617f, 0.02919227f, 0.11581539f, 
    -0.23330681f, -0.03264695f, -0.06405677f, 0.23315026f, -0.27771321f, -0.07803855f, -0.03359511f, 0.06359147f, 
    0.00854207f, -0.02036647f, -0.04538352f, -0.03353457f, 0.03823628f, 0.00250043f, 0.10882778f, -0.00638454f, 
    0.09166878f, -0.08114504f, 0.00810692f, 0.00290401f, -0.19011496f, -0.06651405f, -0.01819263f, -0.02092215f, 
    -0.07942326f, -0.01408421f, -0.09298916f, 0.01476776f, 0.04965906f, -0.08488810f, -0.06124666f, -0.02498524f, 
    0.03690927f, 0.12254961f, 0.00235964f, 0.01249047f, 0.01674392f, -0.13845067f, -0.01378740f, -0.02382864f, 
    0.29217952f, 0.23763630f, -0.30208951f, -0.06602762f, -0.02621064f, 0.01678717f, 0.05406336f, -0.02518401f, 
    0.17507589f, 0.19131415f, 0.08599527f, 0.02859937f, 0.01862297f, 0.09829909f, 0.08677927f, 0.02788159f, 
    -0.08862788f, -0.00249097f, 0.00967308f, 0.06760429f, -0.04383369f, -0.27468798f, -0.13599639f, -0.20468286f, 
    0.07054961f, 0.02392129f, 0.03882571f, -0.07160856f, -0.02202595f, -0.01258658f, 0.09963068f, 0.06739305f, 
    0.01541707f, -0.09179681f, 0.03475543f, 0.00699286f, 0.01838695f, 0.01047287f, -0.01638838f, -0.00606703f, 
    -0.02084855f, 0.07906002f, -0.09571455f, -0.08751036f, -0.04894603f, 0.12244277f, 0.03978148f, 0.02471585f, 
    0.02877184f, -0.02080764f, -0.01414105f, 0.03180588f, 0.04321133f, 0.05860549f, 0.12637809f, 0.01976181f, 
    0.00827898f, 0.08231607f, 0.06927236f, 0.06564783f, 0.00218312f, 0.12039535f, 0.05949675f, 0.20221952f, 
    0.10266624f, -0.01110775f, -0.06513418f, -0.08563462f, -0.04005748f, -0.07635034f, 0.02291802f, 0.02010101f, 
    -0.05515874f, 0.11135269f, 0.04837312f, 0.05441121f, -0.00951329f, 0.04448657f, 0.00380687f, 0.07344224f, 
    0.31826136f, 0.20053072f, 0.01152877f, 0.08005669f, 0.13129470f, -0.02369983f, 0.00167509f, -0.04704359f, 
    0.01571231f, 0.06742174f, -0.12048440f, 0.08685351f, 0.06947347f, 0.06210479f, -0.00150131f, 0.09836256f, 
    0.07461738f, -0.07946759f, -0.01816403f, 0.00768769f, -0.00884889f, -0.14418554f, 0.13202165f, 0.21131022f, 
    0.13140894f, -0.04140991f, -0.14326195f, 0.02360197f, 0.08595508f, 0.19676995f, -0.12889226f, 0.00370856f, 
    0.05321920f, 0.06868996f, 0.02048438f, -0.11310217f, -0.03442890f, 0.11467793f, 0.12258631f, -0.02198923f, 
    0.04551136f, -0.09697293f, -0.11294302f, -0.22586443f, -0.01809090f, -0.01409069f, 0.01582604f, -0.10560664f, 
    0.01667185f, 0.03109027f, 0.02650780f, 0.00294264f, 0.02059985f, 0.10007634f, 0.05170073f, 0.04643858f, 
    0.06512499f, 0.06512338f, 0.06619958f, 0.02722227f, 0.16528942f, 0.17109220f, 0.19333223f, 0.28046983f, 
    -0.02047800f, -0.00493235f, -0.03967288f, 0.02260385f, 0.09593844f, 0.21937408f, -0.02631593f, -0.01818047f, 
    0.01880510f, 0.06614609f, 0.08864503f, 0.08440074f, -0.02552044f, 0.05904227f, -0.01080205f, -0.07570122f, 
    -0.03930160f, -0.12005998f, -0.01868136f, 0.04186870f, 0.21733010f, 0.02855668f, 0.00340256f, 0.01849671f, 
    0.06964729f, -0.04689065f, -0.02152657f, 0.06117985f, -0.09002300f, -0.07146619f, 0.00115174f, 0.14850767f, 
    -0.10496574f, -0.03535443f, 0.10035992f, 0.08309823f, -0.03817740f, -0.13425173f, 0.02292896f, 0.04621653f, 
    0.17079595f, 0.05607300f, 0.15709819f, 0.00484503f, 0.02357189f, -0.00334462f, 0.01114811f, 0.04495772f, 
    0.04860983f, 0.05917767f, 0.01497228f, 0.06845284f, 0.01872295f, 0.01405107f, -0.08122533f, -0.12962279f, 
    -0.06096920f, 0.07464776f, 0.15267755f, -0.03298665f, -0.16485460f, -0.08851199f, 0.08152398f, 0.00345906f, 
    0.00608911f, 0.02993356f, 0.13521807f, 0.06539544f, 0.03649737f, 0.07542714f, -0.03080818f, 0.00049605f, 
    -0.01098379f, 0.03780172f, 0.17434599f, 0.06800458f, 0.01148092f, 0.05214380f, 0.00507981f, -0.04448409f, 
    -0.01179098f, 0.01492933f, 0.03935280f, 0.03425280f, 0.03146094f, -0.02194205f, 0.08340713f, -0.02165920f, 
    0.02073755f, -0.06131082f, -0.08469371f, 0.04019685f, -0.04546760f, 0.00555074f, 0.15197673f, -0.05684860f, 
    0.18226069f, 0.11388572f, 0.04467558f, -0.01332666f, -0.15350141f, 0.02575257f, -0.00222239f, 0.06934211f, 
    -0.05049057f, -0.00140739f, 0.09575685f, -0.04452590f, 0.01035202f, -0.06134833f, -0.01754005f, 0.00572603f, 
    0.00671490f, 0.13761309f, 0.09507323f, -0.00268568f, -0.12187932f, 0.20770958f, 0.01385466f, 0.04381119f, 
    -0.14056197f, 0.09471957f, 0.07073353f, -0.00864645f, 0.05359387f, 0.02994494f, -0.04570637f, 0.06220498f, 
    0.09163307f, -0.01276169f, -0.02683852f, -0.03712032f, -0.01253371f, -0.03275429f, -0.01116709f, 0.03363296f, 
    0.06269404f, -0.13357668f, -0.13317247f, -0.19922219f, 0.21009818f, -0.00514691f, 0.07648061f, -0.08709460f, 
    0.08706640f, -0.03125430f, 0.09189745f, 0.01320520f, -0.06584527f, 0.02433247f, 0.01067273f, -0.06476699f, 
    0.02751713f, 0.01458293f, -0.08369786f, 0.07056218f, -0.16571660f, -0.04472507f, -0.05923570f, -0.09757766f, 
    -0.01750205f, 0.14373207f, -0.06137216f, 0.05365391f, -0.00490765f, 0.04513865f, 0.04579481f, -0.07073312f, 
    -0.01731648f, 0.03186629f, 0.00328727f, -0.04321474f, -0.02620835f, 0.03681179f, -0.00459519f, 0.04319505f, 
    0.31420478f, 0.15612641f, 0.13135503f, -0.02236282f, -0.01111876f, 0.09167669f, 0.01670247f, 0.08271883f, 
    0.02605284f, -0.07861530f, -0.07799220f, 0.07008538f, -0.07952233f, -0.04730860f, 0.01736929f, -0.02584346f, 
    0.15405333f, 0.01659566f, -0.03134190f, 0.09517503f, -0.28341836f, 0.08166500f, 0.10885678f, 0.34806946f, 
    0.11182180f, 0.15473314f, 0.06934429f, 0.05171293f, -0.01866629f, 0.05029726f, -0.06987052f, -0.02154561f, 
    -0.02069009f, 0.01631046f, 0.00709487f, 0.07067405f, -0.06243349f, 0.05286131f, 0.07027447f, -0.06526142f, 
    0.22212531f, 0.24945679f, 0.02574793f, 0.23440702f, -0.14978568f, -0.07723527f, 0.12034334f, -0.09708522f, 
    -0.02871999f, 0.02298362f, 0.00770752f, 0.00387771f, -0.02361251f, 0.05499405f, 0.01157166f, -0.06892387f, 
    0.01590974f, 0.02280818f, 0.07656860f, 0.00943339f, -0.29869676f, -0.05711930f, -0.05809367f, -0.13779479f, 
    -0.03189730f, -0.06310779f, 0.09667202f, 0.00761797f, 0.08498078f, -0.02627829f, -0.05551505f, 0.16514198f, 
    -0.00879858f, -0.11926306f, -0.06074848f, 0.03841356f, 0.00911067f, 0.07941759f, 0.05569596f, 0.05953901f, 
    -0.06567364f, 0.02333938f, 0.00150898f, 0.12217015f, -0.02180055f, -0.00145437f, 0.02764043f, 0.14330155f, 
    -0.01996501f, 0.01045348f, 0.17548995f, -0.01748637f, -0.23374920f, 0.12855102f, 0.14793573f, -0.03562274f, 
    -0.05023626f, 0.06997865f, 0.15279566f, -0.10187788f, -0.14250296f, 0.11804894f, -0.12385192f, -0.25425622f, 
    0.06036926f, -0.13245556f, -0.08520264f, 0.06512284f, -0.09236538f, -0.03995719f, 0.07718457f, 0.01864159f, 
    0.08539352f, -0.08014618f, 0.10950565f, 0.04967376f, 0.15798384f, 0.03747358f, 0.05857301f, 0.00281777f, 
    -0.38155541f, 0.13440174f, -0.08053529f, 0.19414198f, 0.08415847f, 0.03768083f, -0.02376859f, 0.00954396f, 
    0.04787198f, 0.03029844f, 0.03334847f, -0.04926227f, 0.02163341f, -0.09224997f, 0.07602669f, -0.03352629f, 
    0.02958386f, 0.00966248f, -0.06337099f, -0.04814491f, -0.24964537f, 0.01089429f, 0.03512554f, -0.28839919f, 
    0.23800553f, -0.05323694f, -0.09295802f, -0.00230009f, -0.10997330f, -0.09690526f, 0.09668802f, -0.10767262f, 
    0.01453791f, 0.01938709f, -0.09093845f, -0.05639442f, 0.06471725f, -0.02496381f, 0.08431356f, 0.05398236f, 
    -0.37964934f, 0.22220102f, 0.02973912f, 0.10825039f, 0.05223783f, 0.13717878f, -0.01628453f, 0.03239226f, 
    0.03819689f, 0.01581377f, -0.02570844f, -0.00900020f, 0.02867666f, -0.05840709f, 0.03107462f, 0.08440965f, 
    0.05397166f, 0.00711388f, 0.03896935f, -0.13281424f, -0.12328838f, 0.12260702f, 0.17079335f, 0.21007976f, 
    -0.07602093f, 0.10950058f, -0.03592037f, 0.13258377f, -0.17511947f, 0.11444492f, -0.03850984f, 0.11306156f, 
    -0.04638256f, -0.02733721f, 0.15556170f, -0.07028213f, 0.02090625f, -0.06802876f, 0.10023824f, 0.03358406f, 
    0.05675282f, 0.05062633f, 0.00992279f, 0.08442608f, 0.11157362f, 0.08681611f, 0.01704928f, 0.04795481f, 
    0.02773330f, 0.04105536f, -0.09673303f, -0.09736903f, -0.01576746f, -0.01522537f, 0.09094825f, -0.03375221f, 
    -0.07471777f, 0.06980266f, -0.08917306f, -0.00748603f, -0.06873441f, 0.02006898f, 0.22822148f, 0.07106675f, 
    -0.00436921f, 0.01134899f, -0.00110765f, -0.04452378f, -0.09159201f, 0.01227640f, -0.02384912f, 0.08554255f, 
    -0.06337953f, -0.01076965f, 0.09873922f, -0.09636563f, -0.04755995f, 0.12009929f, -0.09777240f, -0.03132680f, 
    -0.26602879f, 0.01545456f, 0.21405973f, 0.08476472f, 0.02514052f, 0.14396326f, 0.08663342f, -0.07648302f, 
    -0.21377303f, -0.01397378f, 0.02926062f, -0.04283716f, 0.09136849f, 0.07944420f, 0.06371522f, 0.03674608f, 
    0.03553820f, -0.12470227f, -0.09226167f, -0.00985931f, 0.00657747f, 0.06474605f, -0.08772260f, -0.03393030f, 
    0.17951819f, -0.03455973f, 0.02993817f, 0.00250823f, -0.06918326f, -0.02828551f, -0.00853608f, -0.07115868f, 
    0.02130275f, 0.14094505f, -0.01671963f, 0.05156038f, -0.03092684f, 0.01829629f, -0.01242243f, 0.04526853f, 
    -0.05418102f, 0.12008691f, -0.05883014f, 0.25312898f, -0.08826719f, 0.01867942f, -0.11068798f, 0.01261397f, 
    0.05986801f, 0.04325084f, -0.06517488f, 0.11131169f, 0.06259824f, -0.08057522f, 0.02424668f, -0.04101835f, 
    -0.02252186f, -0.00223499f, 0.02492921f, -0.07499404f, -0.00627463f, 0.10110764f, 0.06972095f, 0.04500638f, 
    0.11572621f, 0.02876210f, 0.00496386f, -0.09342454f, -0.05884195f, -0.03710266f, -0.06537305f, 0.02366960f, 
    0.09660885f, 0.02900905f, 0.12017547f, 0.00727656f, 0.11316672f, -0.07191766f, 0.05375515f, 0.00429512f, 
    -0.03520804f, -0.01522859f, 0.02904470f, -0.04971698f, 0.00740732f, 0.00699783f, -0.03568092f, 0.03740447f, 
    0.04819068f, -0.00100271f, -0.03127306f, -0.04228637f, -0.01825293f, -0.02559325f, -0.00905035f, -0.02224899f, 
    -0.02918665f, -0.02160692f, 0.01069924f, -0.00244939f, 0.03049900f, -0.00255372f, -0.03155158f, -0.03404558f, 
    0.02298670f, -0.00667713f, 0.01778239f, -0.00372994f, -0.04354126f, -0.05527336f, -0.03345735f, 0.00589585f, 
    -0.04791892f, -0.01650026f, 0.01726797f, 0.04420753f, -0.00365140f, -0.00116415f, -0.00798880f, -0.01796176f, 
    -0.04345361f, -0.03732550f, 0.03145885f, -0.02655462f, -0.03018581f, -0.03694396f, -0.00311559f, -0.04527550f, 
    0.00319099f, 0.02237954f, -0.03363690f, -0.02179760f, -0.05473303f, 0.02033053f, 0.04462400f, -0.04660491f, 
    -0.03135305f, 0.02844985f, -0.03678614f, 0.04692354f, 0.03710194f, -0.05054304f, -0.00533090f, 0.01154069f, 
    -0.01193419f, -0.03894391f, -0.03401965f, 0.03777334f, -0.02386994f, -0.02359572f, -0.00773250f, 0.04961725f, 
    -0.03137512f, -0.05220727f, -0.05186681f, -0.00287668f, 0.00742533f, 0.04371415f, 0.00293066f, 0.03447366f, 
    -0.04628158f, -0.04221513f, -0.04148757f, 0.01438276f, -0.03684642f, 0.00357482f, -0.03602931f, -0.04531257f, 
    0.04556293f, -0.02878829f, -0.02083349f, -0.06023589f, 0.02624947f, 0.00447605f, 0.02486786f, -0.05087355f, 
    0.01743202f, 0.02476901f, 0.02677128f, -0.01859048f, 0.00330770f, 0.04713944f, -0.00246952f, 0.01988346f, 
    0.04031973f, 0.03617570f, -0.01540119f, -0.00871363f, -0.05083094f, 0.00540918f, -0.00544592f, -0.01958037f, 
    -0.03407229f, -0.05516622f, -0.00014192f, -0.03890949f, -0.03050950f, -0.05584354f, 0.03325744f, -0.03968519f, 
    -0.00789680f, 0.02105377f, 0.02192179f, 0.02652983f, 0.02753096f, 0.04697624f, -0.00019325f, 0.02351289f, 
    -0.00564336f, -0.05992917f, 0.01709644f, -0.01606755f, -0.00536232f, -0.05020049f, -0.03437698f, -0.03747728f, 
    -0.04386343f, -0.03687066f, -0.03983148f, -0.02443878f, -0.05573315f, -0.00616877f, -0.00452287f, -0.05899966f, 
    -0.00064536f, -0.03647272f, 0.01166725f, -0.05039624f, 0.02675414f, -0.05067905f, 0.00481784f, -0.04243981f, 
    0.00537646f, -0.04799443f, 0.00349198f, -0.02778148f, 0.00018155f, -0.05036874f, -0.01112225f, -0.02244614f, 
    -0.02539894f, -0.01286982f, -0.05524299f, -0.05670013f, -0.03337323f, 0.00218693f, 0.02784601f, -0.04670681f, 
    0.02050937f, 0.03433622f, -0.01590863f, 0.00385559f, -0.02325673f, -0.01180272f, 0.01119859f, -0.00109773f, 
    0.00841792f, -0.01161252f, -0.01537231f, 0.00438995f, -0.04022181f, -0.04270963f, -0.02158309f, -0.02630798f, 
    -0.04471938f, -0.03714568f, -0.02949228f, 0.01832355f, 0.05089895f, 0.00586282f, -0.03926860f, 0.02399359f, 
    0.03191866f, -0.03278989f, -0.06054210f, 0.02195389f, -0.01096258f, 0.00223024f, 0.03514317f, 0.03320807f, 
    0.02179331f, 0.00134768f, 0.01389919f, -0.03957227f, -0.00710853f, 0.04185760f, 0.03843052f, -0.04925562f, 
    0.01496397f, -0.04303986f, -0.03973683f, -0.04577530f, -0.01325102f, 0.03963827f, -0.04909183f, -0.01037534f, 
    0.04377431f, -0.02330383f, -0.05081738f, 0.04047373f, 0.02317481f, -0.01585423f, -0.05973538f, -0.00362812f, 
    -0.05342816f, -0.02056860f, -0.01441922f, 0.02989697f, -0.05269964f, 0.00174887f, -0.02919379f, -0.03487803f, 
    0.00847099f, -0.02903150f, -0.01062604f, -0.02071534f, 0.00051832f, -0.00949548f, 0.04932979f, -0.03571866f, 
    -0.03566225f, 0.02448241f, 0.03787370f, 0.04868330f, -0.03462477f, 0.01470116f, -0.04888549f, -0.00105819f, 
    0.02185583f, -0.00389872f, -0.01456368f, 0.04452133f, 0.04283501f, -0.00268872f, 0.02671183f, 0.00168280f, 
    0.02969646f, 0.02443235f, 0.02978224f, -0.03943773f, 0.04757974f, 0.01765732f, -0.02765994f, 0.02918043f, 
    -0.02214745f, 0.03558129f, -0.03926102f, 0.02526371f, 0.04984699f, 0.04340717f, 0.00334703f, -0.02840278f, 
    -0.05117529f, -0.01983019f, -0.02182459f, -0.03775417f, -0.03571247f, -0.01563616f, -0.00740261f, 0.02591758f, 
    -0.01722106f, -0.04060962f, -0.01277143f, 0.02264797f, 0.00291887f, 0.03059950f, 0.04612254f, -0.05662689f, 
    0.03190547f, -0.03563110f, -0.00038970f, 0.00757895f, -0.05375904f, -0.04703347f, -0.05934170f, 0.02590318f, 
    0.03229161f, 0.02715382f, 0.01955841f, -0.05762671f, 0.01392401f, -0.02232483f, -0.01242387f, 0.04090906f, 
    0.02088835f, 0.03673063f, 0.01976983f, 0.02800120f, -0.03781243f, -0.00531967f, -0.04510622f, 0.04791267f, 
    0.02391488f, -0.03296287f, -0.03514797f, -0.02114791f, -0.00147087f, 0.03080726f, 0.03685392f, 0.04542192f, 
    0.17301477f, -0.03988967f, -0.05294266f, -0.04646961f, -0.23159920f, 0.00615219f, -0.04761561f, -0.08456985f, 
    0.00280725f, 0.05421947f, -0.05772493f, -0.08541442f, 0.06804936f, 0.06085803f, 0.07750113f, -0.12466837f, 
    0.13141347f, -0.09130763f, -0.02819089f, 0.00364958f, -0.03732049f, -0.40118808f, 0.02428964f, -0.01156374f, 
    0.19905320f, 0.11073089f, 0.22738488f, -0.07468231f, -0.15497771f, 0.01100353f, -0.01024270f, -0.02291332f, 
    0.10816018f, 0.03170162f, 0.19049749f, 0.03245030f, 0.03979933f, -0.02441725f, -0.03035684f, 0.01614049f, 
    -0.33689630f, 0.00675872f, -0.04516060f, -0.07634405f, -0.26379111f, 0.00946722f, 0.13135037f, -0.06461532f, 
    0.04102993f, 0.05276661f, -0.04791892f, -0.00156650f, 0.11791886f, 0.08131965f, 0.08445062f, 0.01419931f, 
    0.00818281f, -0.04695648f, 0.18380961f, 0.06495518f, -0.36891770f, -0.02003714f, -0.05501212f, -0.01355680f, 
    -0.08773410f, 0.02790236f, -0.03067845f, -0.04750345f, 0.27260816f, -0.02392854f, 0.03578063f, 0.07618967f, 
    0.01893404f, 0.01004816f, -0.00182240f, -0.01355327f, -0.01904837f, 0.05401417f, -0.07493816f, 0.05669687f, 
    0.31328419f, 0.11412362f, 0.00047736f, 0.22942097f, 0.14019924f, -0.19267383f, -0.06833465f, 0.03592781f, 
    0.09891317f, -0.02226165f, -0.01143381f, -0.01766914f, -0.02906783f, 0.19674633f, -0.05648197f, 0.03332731f, 
    -0.03466150f, -0.09688164f, 0.02479409f, 0.01507284f, -0.33645922f, -0.10639483f, 0.22570369f, 0.02417252f, 
    0.15238768f, -0.20262200f, -0.18941514f, -0.05717817f, 0.04345001f, 0.00046989f, 0.04940980f, -0.09066234f, 
    -0.00865701f, -0.08176962f, -0.03694102f, -0.03934235f, -0.00376451f, 0.08467908f, -0.00898340f, -0.03918409f, 
    0.34649321f, 0.20962724f, 0.17098829f, 0.00097432f, 0.23431093f, 0.16596720f, 0.13255371f, -0.07667790f, 
    -0.08170111f, -0.01774384f, -0.02240572f, -0.11094358f, -0.01609090f, 0.05618036f, 0.04132548f, -0.05501085f, 
    0.09083846f, -0.01514091f, 0.00967569f, -0.02139755f, -0.46564513f, 0.28145674f, 0.08280868f, 0.06102143f, 
    -0.14832357f, -0.13862002f, -0.04262235f, -0.04605469f, -0.00724818f, 0.00801308f, -0.00422200f, 0.03775178f, 
    -0.10255348f, -0.00348341f, 0.01005941f, 0.00191909f, 0.07918884f, 0.13036147f, 0.06704284f, -0.01978857f, 
    0.19298862f, 0.19284052f, 0.03159560f, 0.03319093f, 0.11080927f, 0.11665078f, 0.12870628f, 0.10265610f, 
    0.00088531f, -0.07293353f, 0.04408061f, 0.01143582f, 0.05432763f, 0.04939083f, 0.01768828f, 0.04972192f, 
    0.01032716f, -0.04195453f, 0.05542421f, 0.08734197f, -0.18502955f, -0.21107328f, -0.01887162f, 0.15182264f, 
    0.19789389f, 0.09458930f, 0.08649209f, 0.01019219f, -0.11089582f, 0.08219020f, 0.09141209f, 0.02646178f, 
    0.09874155f, 0.03343787f, 0.01414235f, 0.07113472f, -0.06726274f, -0.08759908f, -0.05517291f, 0.13349131f, 
    -0.49245358f, -0.26560849f, -0.28268090f, -0.13904186f, -0.21664014f, 0.01160589f, -0.02649057f, -0.11018430f, 
    0.11627977f, 0.00685815f, 0.14490838f, -0.01557124f, -0.02688526f, 0.10559953f, 0.13722099f, 0.08585889f, 
    0.03383623f, -0.03702534f, -0.04717619f, -0.01164093f, -0.24737398f, -0.09301739f, -0.24811368f, -0.24979514f, 
    0.00269554f, 0.06296225f, 0.11870124f, -0.01312143f, 0.07898659f, -0.04347649f, -0.05483325f, -0.08796842f, 
    0.05177186f, -0.07590223f, 0.04222156f, -0.02765989f, 0.15080237f, -0.12004428f, -0.00524690f, -0.09028653f, 
    -0.50004715f, -0.27516019f, -0.16823724f, -0.12629473f, -0.25077266f, -0.02464747f, -0.05667298f, -0.07749690f, 
    -0.03681578f, -0.01101844f, 0.05472847f, 0.04411913f, 0.09351480f, 0.04095712f, -0.02661424f, 0.06452037f, 
    0.04489947f, -0.02999484f, -0.14483216f, 0.09368196f, 0.01673924f, 0.20939532f, 0.13011381f, 0.03291170f, 
    -0.03251583f, 0.05257807f, 0.02954220f, 0.02625249f, -0.07674682f, -0.04332063f, 0.02946116f, 0.12339947f, 
    -0.01285224f, -0.00703641f, 0.09003097f, -0.03099805f, 0.01314705f, 0.12553874f, -0.02011702f, -0.03283332f, 
    0.02181876f, 0.02306659f, 0.05309283f, -0.08968743f, 0.17848027f, 0.10373560f, 0.13488345f, -0.07955555f, 
    -0.01081942f, -0.07699103f, -0.00192411f, 0.10655633f, 0.15411426f, 0.03871987f, -0.05888192f, -0.15647085f, 
    0.04139595f, 0.09846294f, -0.01641434f, -0.06587837f, 0.12498511f, 0.06559698f, 0.00664131f, -0.06254648f, 
    0.11902662f, 0.12385211f, 0.09359214f, 0.07618231f, -0.06151070f, 0.02662650f, 0.02662237f, -0.13560486f, 
    -0.03601034f, -0.13709903f, -0.04531561f, -0.04408132f, 0.06394257f, 0.18322437f, -0.01917940f, 0.08009163f, 
    0.07804812f, 0.14898171f, -0.11377273f, 0.10420638f, -0.00342191f, -0.01748598f, 0.12939896f, 0.05106422f, 
    0.12855260f, 0.09579392f, -0.01900298f, -0.00282397f, 0.01532391f, -0.06639416f, 0.00192577f, 0.07236744f, 
    0.05782152f, 0.01099484f, 0.04711846f, 0.08155438f, -0.01185296f, 0.01401639f, 0.01688456f, 0.05299095f, 
    -0.02219541f, 0.12725006f, 0.11864580f, 0.05647146f, -0.07608812f, -0.03235294f, 0.08056974f, 0.05765566f, 
    0.03572683f, -0.06904218f, 0.04468706f, 0.02129815f, 0.00293321f, -0.03998093f, -0.05654543f, 0.02429699f, 
    0.02672355f, -0.02400954f, 0.03098027f, 0.00805367f, -0.09843973f, 0.25295287f, 0.10370742f, 0.09548689f, 
    -0.01410007f, 0.01713104f, -0.02794778f, 0.08342562f, -0.00736543f, 0.07971133f, -0.06988847f, 0.02501946f, 
    0.05758186f, -0.00768736f, 0.01913808f, 0.12977694f, 0.04290375f, 0.06558749f, -0.07722535f, 0.02569426f, 
    0.17005011f, 0.07170162f, -0.07569868f, -0.04647447f, 0.00021526f, -0.00318537f, -0.06426486f, -0.06080379f, 
    -0.05491403f, 0.06659814f, 0.03333097f, -0.04624754f, 0.02883785f, -0.03258172f, -0.03426852f, 0.08545671f, 
    0.13096800f, 0.02981213f, -0.10419830f, -0.05508002f, -0.05246004f, -0.08046708f, -0.01524164f, 0.00999404f, 
    0.09522020f, 0.04108923f, -0.08966003f, 0.13269849f, 0.02556171f, -0.11104675f, -0.06772361f, -0.09926990f, 
    0.05010517f, 0.01115622f, -0.08465268f, 0.03246654f, 0.06098405f, -0.10151653f, 0.06243020f, 0.03911555f, 
    0.19592190f, -0.08015118f, -0.17881939f, 0.01126679f, 0.05082469f, -0.01752837f, -0.00652153f, 0.02630090f, 
    0.05330797f, -0.01015418f, -0.08985086f, -0.18346326f, -0.14941542f, -0.00438843f, 0.00091138f, 0.01458472f, 
    -0.23621106f, -0.14314349f, -0.13955350f, -0.03888679f, -0.12338267f, 0.04905553f, 0.07179315f, 0.08177155f, 
    -0.04165156f, 0.00227521f, 0.06017225f, 0.01049156f, -0.02110770f, 0.02781366f, 0.02290948f, 0.05854556f, 
    0.03742820f, 0.02776199f, -0.01791965f, -0.00008884f, 0.19420885f, -0.02919754f, -0.01291094f, 0.03710993f, 
    0.03557896f, 0.06018171f, -0.03059441f, -0.12296890f, -0.06064941f, 0.09442675f, 0.00539046f, 0.05345324f, 
    0.00696760f, 0.01324547f, -0.01610346f, -0.02378429f, 0.02838591f, 0.01966274f, 0.01221244f, -0.05217931f, 
    -0.07901127f, -0.07770319f, -0.00226610f, 0.05446952f, -0.11740197f, -0.06594433f, 0.14469065f, 0.04638061f, 
    0.02498137f, 0.07099277f, -0.00646353f, -0.05374479f, -0.16214852f, -0.02797474f, 0.04785629f, 0.01130022f, 
    0.02990730f, -0.07087293f, 0.02230415f, -0.02352299f, -0.15196922f, 0.11472391f, -0.04885877f, 0.13408749f, 
    0.00686366f, 0.03046889f, 0.19728847f, 0.02771075f, 0.01225642f, -0.03302457f, 0.06147344f, -0.01934047f, 
    -0.00029787f, -0.01867456f, 0.02666580f, 0.03763971f, 0.00561223f, 0.02093819f, -0.13604301f, 0.02616209f, 
    0.09379860f, 0.23815028f, -0.07408484f, 0.00059421f, 0.01647678f, -0.05038893f, 0.02822796f, 0.02334983f, 
    0.02001259f, -0.04227611f, 0.03348432f, 0.10663962f, -0.03255640f, -0.05945707f, -0.00081077f, 0.08137988f, 
    -0.05593130f, -0.05663225f, 0.17841998f, 0.04810659f, 0.34674817f, 0.16034152f, 0.04529473f, 0.09312833f, 
    0.15152709f, 0.03480595f, 0.10160215f, 0.05517432f, 0.06144948f, 0.06538633f, -0.04226250f, -0.10275178f, 
    -0.02865789f, 0.00684016f, 0.04716698f, 0.06264804f, 0.08268483f, -0.08127788f, 0.10916341f, 0.04732028f, 
    0.18332361f, 0.08221516f, -0.10459651f, -0.01641122f, -0.13019817f, -0.03465606f, 0.03592404f, -0.01593873f, 
    -0.06560257f, -0.02118854f, -0.03685893f, -0.04711930f, -0.02513839f, -0.06956843f, -0.01772119f, 0.01876093f, 
    0.07302827f, 0.08018018f, 0.07165777f, 0.15942609f, -0.42828804f, 0.03348685f, -0.04298082f, 0.02197133f, 
    -0.17004906f, 0.06448436f, 0.08712649f, 0.11868429f, -0.00004773f, 0.00612499f, 0.05033146f, 0.06020162f, 
    0.05741146f, 0.01929709f, -0.08267620f, -0.00568695f, 0.03890014f, -0.03494705f, -0.02497486f, 0.01738122f, 
    -0.18372951f, -0.04682199f, -0.04019881f, -0.09126633f, -0.14342998f, 0.06868528f, 0.08837226f, 0.05146232f, 
    -0.03731205f, 0.05713975f, -0.01569582f, -0.04297196f, -0.01714998f, 0.04103928f, 0.07473325f, -0.11260936f, 
    0.05728732f, 0.03393398f, -0.04561598f, -0.00114062f, -0.31590050f, -0.01599486f, -0.01118639f, -0.13612634f, 
    -0.09839925f, 0.02821194f, 0.00591209f, 0.11010207f, 0.01940082f, 0.01700857f, 0.03566014f, -0.11026459f, 
    -0.03600593f, 0.02668784f, -0.00287251f, 0.01543611f, 0.04063546f, -0.15151978f, 0.00498698f, 0.06440903f, 
    -0.39642316f, -0.21493748f, 0.02574916f, -0.02057399f, -0.19240300f, -0.01062380f, 0.22290282f, -0.04673718f, 
    0.00087774f, -0.00892084f, -0.07172770f, -0.05738280f, 0.14051770f, -0.14396599f, -0.08630818f, 0.00567618f, 
    0.09372412f, 0.01483248f, 0.04014086f, 0.03477057f, 0.34171557f, 0.06336574f, 0.04910309f, 0.21083345f, 
    -0.01535486f, -0.06852417f, 0.06812730f, 0.01910231f, -0.10283284f, -0.00652414f, 0.08126798f, 0.07299188f, 
    0.14781263f, 0.11713580f, 0.12722205f, 0.01707718f, -0.07050418f, -0.18134542f, -0.08258906f, 0.11572919f, 
    -0.05568618f, -0.21457162f, -0.00911978f, 0.04263191f, -0.03334100f, 0.22850381f, 0.07391614f, 0.12807219f, 
    0.04158461f, 0.10333325f, 0.03111837f, -0.02013849f, 0.01382392f, -0.01461986f, -0.00960571f, -0.03497547f, 
    0.13151787f, -0.11621040f, 0.01223309f, 0.13016517f, -0.08482561f, -0.04066890f, -0.02334525f, -0.08867440f, 
    0.16483547f, -0.02137364f, -0.07376002f, -0.01332920f, 0.10483642f, 0.14110434f, 0.07774660f, -0.02499013f, 
    0.14941980f, -0.05325976f, -0.03434589f, -0.04897378f, 0.05473294f, -0.05625535f, 0.03054200f, 0.02144453f, 
    -0.37128025f, 0.01036585f, -0.22307019f, -0.05616093f, -0.02994308f, -0.02813040f, -0.09765568f, 0.07418329f, 
    0.05938826f, 0.02430998f, 0.03293056f, -0.01949792f, 0.05296448f, -0.02404253f, -0.02666025f, -0.10896721f, 
    -0.01143529f, 0.10734928f, -0.19972108f, 0.03847516f, -0.07746027f, -0.08264249f, -0.09495003f, -0.01078873f, 
    0.16856407f, 0.02732318f, 0.02606540f, 0.02020788f, 0.02005780f, -0.03681066f, -0.04207537f, -0.05181367f, 
    -0.04378939f, -0.09231840f, -0.09653267f, -0.05542492f, -0.05481578f, -0.08108728f, -0.15460983f, -0.02683778f, 
    0.23976168f, -0.15253183f, 0.23825458f, 0.10229139f, -0.11046135f, 0.23529276f, 0.16388549f, 0.10759182f, 
    -0.04432099f, 0.05622525f, 0.01082233f, -0.05413514f, 0.10674530f, 0.06588301f, 0.00748424f, 0.04550114f, 
    0.06380628f, -0.05013983f, -0.04319604f, 0.04449512f, -0.07014617f, -0.01552224f, -0.11242680f, 0.05988382f, 
    0.16171822f, 0.10238664f, 0.05791792f, -0.03082709f, 0.05479463f, -0.03716014f, 0.07093737f, -0.00861993f, 
    -0.02073396f, -0.05964386f, -0.06666967f, 0.05110459f, 0.04193999f, 0.03209103f, 0.08628535f, 0.02692791f, 
    0.28330556f, 0.07694130f, -0.11903761f, -0.00611520f, -0.15107790f, -0.12734494f, 0.12478904f, 0.01106597f, 
    0.03624642f, 0.06737734f, 0.03238825f, 0.07572050f, 0.05534032f, 0.13688600f, -0.01318036f, 0.05602735f, 
    0.02897356f, 0.03523708f, 0.02723813f, 0.06007480f, -0.03888272f, 0.20188773f, -0.12355690f, -0.06221474f, 
    -0.14917719f, -0.10173199f, 0.10657555f, -0.06527906f, 0.03217302f, 0.05680006f, 0.06480141f, -0.00442165f, 
    -0.03562111f, 0.01277325f, 0.00986066f, 0.02605393f, -0.01500699f, -0.02463288f, -0.06829908f, -0.02298773f, 
    0.00786405f, 0.17191148f, -0.30329648f, -0.03954709f, 0.22148323f, 0.11781671f, -0.11378559f, 0.05766353f, 
    0.10068734f, -0.02123613f, 0.13735341f, 0.05586188f, 0.03876745f, 0.10004484f, 0.10835353f, 0.06004547f, 
    -0.02771700f, 0.07940419f, 0.01016013f, 0.00894053f, 0.27798110f, -0.01184938f, -0.00028635f, 0.00295007f, 
    0.26135284f, 0.00308221f, -0.01578369f, -0.12488963f, 0.14563718f, -0.02086441f, 0.03716529f, -0.13435993f, 
    0.00139147f, 0.09527105f, 0.21670391f, 0.03598312f, 0.04963655f, 0.00192951f, -0.02333516f, 0.08262840f, 
    0.09517236f, 0.16439201f, -0.08622129f, -0.07869899f, 0.03352248f, 0.02216289f, 0.02769595f, -0.05368336f, 
    0.04047624f, 0.08111260f, 0.01739938f, -0.02577371f, 0.04818059f, 0.11484426f, -0.05740456f, 0.04944214f, 
    0.10518034f, -0.04283527f, 0.04208365f, 0.02374879f, 0.00285612f, -0.24554056f, 0.03485269f, -0.06119636f, 
    -0.14400217f, 0.01852024f, 0.09423308f, 0.15217255f, -0.06541400f, 0.01944448f, 0.09041262f, 0.04957450f, 
    0.08570737f, 0.00928853f, 0.01793653f, -0.09878955f, 0.04407728f, 0.00109220f, -0.03411687f, -0.03428924f, 
    0.00419920f, 0.00110576f, 0.08836453f, -0.11817527f, -0.16995104f, 0.08482880f, 0.07485223f, 0.09020340f, 
    -0.00169011f, 0.07698962f, 0.00194838f, -0.04622462f, 0.17683621f, -0.01842379f, 0.03064105f, -0.12686816f, 
    0.03506263f, 0.15369244f, 0.01677421f, 0.02405944f, 0.05313332f, 0.06670450f, 0.08888974f, -0.04390552f, 
    -0.10853434f, 0.03530087f, 0.05330809f, 0.00879570f, 0.03141094f, -0.02320155f, 0.01036014f, 0.02671323f, 
    -0.08912300f, 0.10978132f, -0.05114413f, -0.00693507f, 0.08095568f, 0.00348678f, -0.04981225f, -0.02491926f, 
    0.01369874f, 0.02825819f, -0.05012873f, 0.03002371f, -0.02284892f, -0.04422824f, -0.06142318f, -0.01003134f, 
    0.02200850f, 0.00228503f, -0.05453585f, -0.05251655f, 0.01969511f, 0.01804930f, -0.01855136f, 0.00955985f, 
    -0.04931576f, -0.04205731f, -0.00283090f, -0.00456624f, -0.02838472f, 0.05315141f, 0.01782279f, -0.02847243f, 
    -0.00195298f, 0.01618177f, -0.00122508f, 0.02064696f, -0.05062627f, -0.05218414f, -0.04837582f, -0.06010073f, 
    -0.00831851f, -0.06348640f, 0.03355570f, -0.03193977f, 0.01058820f, -0.02273958f, 0.01035156f, -0.04412083f, 
    -0.04522628f, 0.01650140f, -0.03692686f, -0.06297161f, 0.02817091f, 0.03590078f, -0.05051602f, -0.03456625f, 
    -0.02289627f, -0.05277723f, -0.04578944f, -0.05105615f, -0.01398833f, 0.03685462f, 0.01755063f, -0.03480551f, 
    0.00237604f, 0.01832317f, -0.01379954f, -0.05170588f, 0.01887334f, -0.01247279f, 0.03143490f, 0.01370318f, 
    -0.01971947f, -0.02655612f, 0.00810320f, -0.04343709f, 0.00694050f, -0.00614209f, 0.00085600f, -0.02239028f, 
    0.03857083f, -0.02323427f, -0.03843935f, 0.04129981f, -0.03956264f, -0.05710740f, -0.03549809f, 0.04544053f, 
    -0.02687752f, 0.00691593f, 0.03360200f, -0.04355033f, 0.04684636f, -0.03775554f, 0.01933661f, 0.01953532f, 
    -0.01172649f, -0.03545273f, -0.02570185f, 0.04232597f, -0.03402871f, 0.03120685f, 0.02911339f, 0.04221842f, 
    0.03293168f, 0.01282895f, 0.01535989f, -0.04726059f, 0.00230926f, -0.06288948f, -0.00351430f, 0.01918465f, 
    -0.03859037f, -0.03616200f, -0.03445302f, 0.02795030f, -0.00626338f, 0.00030789f, 0.02929444f, -0.01209664f, 
    -0.01536952f, 0.04609679f, -0.01748470f, 0.02514450f, -0.06140779f, 0.03811366f, -0.06015202f, 0.03010106f, 
    -0.00317836f, 0.02059766f, -0.05036896f, -0.03527848f, -0.02601724f, -0.04502748f, 0.04405680f, 0.00194804f, 
    0.03856958f, -0.04325975f, -0.02052351f, -0.00526994f, 0.01723543f, -0.01531073f, -0.00893959f, -0.04376566f, 
    -0.00402945f, 0.03871643f, 0.03594957f, 0.03365362f, 0.01440277f, 0.04390761f, -0.05279866f, 0.01354135f, 
    0.01592332f, 0.04050012f, -0.04698969f, -0.01783429f, 0.03239005f, -0.02702059f, -0.05781929f, 0.03801657f, 
    0.02167217f, -0.02926211f, 0.00302159f, 0.02671581f, -0.05018936f, 0.03926543f, 0.03386414f, 0.02610783f, 
    0.00356530f, -0.01406069f, 0.04378252f, -0.04586896f, 0.01045721f, -0.04227816f, 0.01861876f, -0.04189992f, 
    0.01857487f, -0.01392269f, -0.03257844f, 0.01223864f, -0.02784284f, 0.00157239f, -0.00248263f, 0.04696490f, 
    0.04213614f, 0.00539988f, -0.05592242f, -0.02922527f, 0.03294390f, -0.01107966f, -0.05438815f, -0.06406254f, 
    0.01663409f, -0.02106691f, 0.00451558f, -0.01383616f, 0.02918905f, -0.00692314f, 0.00675442f, -0.00894364f, 
    0.01745275f, 0.01270023f, 0.03604151f, -0.00275147f, 0.02933529f, -0.02497328f, 0.00048508f, -0.00991350f, 
    0.03278692f, -0.00702604f, -0.04791340f, -0.03336532f, -0.02595548f, -0.02312094f, 0.03818537f, -0.03601252f, 
    0.01810542f, -0.02742087f, -0.02774510f, 0.00693847f, -0.00093751f, -0.06045052f, -0.03944345f, -0.04999702f, 
    0.01789026f, -0.00655423f, 0.03583089f, -0.00883058f, -0.01879781f, -0.04123795f, -0.03491482f, 0.01445225f, 
    -0.00300789f, -0.02757425f, 0.04755805f, 0.03947656f, -0.02926063f, 0.03632893f, -0.04124166f, 0.03293327f, 
    -0.00537585f, -0.03257660f, -0.05832268f, -0.04626983f, -0.01659506f, 0.01283938f, -0.02782657f, -0.03485854f, 
    -0.03709743f, -0.00361594f, -0.01990314f, 0.04316603f, -0.00516864f, 0.01990973f, -0.05116564f, 0.03591322f, 
    -0.00547357f, -0.04334414f, -0.06066604f, -0.03291517f, 0.02440999f, -0.00912507f, 0.03561921f, 0.00876296f, 
    -0.03119505f, -0.00702927f, 0.02117764f, -0.06140081f, 0.03704382f, -0.03370865f, -0.02716513f, 0.03117543f, 
    0.01841637f, -0.03188492f, 0.02651812f, 0.00012582f, -0.01057425f, -0.04117445f, -0.06317857f, -0.00302154f, 
    -0.03212989f, -0.03888884f, 0.03767430f, 0.00364227f, -0.04987168f, -0.01466482f, -0.01671616f, 0.00856399f, 
    0.01491824f, -0.03093170f, 0.00758776f, 0.04441660f, -0.04665338f, 0.03785902f, -0.06203307f, -0.04131418f, 
    -0.00976379f, 0.02722986f, 0.00911673f, -0.03285017f, -0.00567259f, 0.02850485f, -0.03633481f, -0.00021553f, 
    0.03619738f, -0.03415762f, 0.01409582f, 0.03809673f, 0.03030760f, -0.01859611f, -0.03371556f, 0.01391465f, 
    -0.04010924f, -0.03328152f, 0.00130642f, 0.03013995f, -0.00722789f, 0.00322872f, 0.02431895f, -0.01363756f, 
    0.03063575f, -0.00365429f, -0.00892660f, -0.00393059f, -0.03763168f, 0.02000721f, -0.01441644f, -0.04426990f, 
    -0.03908904f, -0.00787983f, -0.00384982f, -0.04045634f, -0.02813106f, -0.05290001f, -0.00557701f, -0.04173860f, 
    -0.05448171f, 0.04280071f, -0.05491643f, 0.02422331f, 0.01822723f, 0.02571646f, -0.00477716f, -0.03978380f, 
    0.03543519f, 0.00971619f, 0.01348710f, 0.02480472f, 0.02164843f, -0.04857782f, -0.03176399f, -0.01911720f, 
    0.01704208f, -0.04481376f, 0.04924744f, -0.01088409f, 0.03203597f, -0.02613711f, -0.05331979f, 0.00274439f, 
    -0.05372548f, -0.02098397f, 0.01735017f, -0.03300332f, 0.03711110f, -0.00340507f, 0.03102553f, -0.04106854f, 
    -0.01056053f, 0.02058194f, 0.02553828f, -0.03473415f, 0.02011768f, -0.01341952f, -0.01272490f, -0.02428859f, 
    0.05015741f, -0.01429593f, -0.03867890f, -0.03123483f, -0.03559405f, -0.00770462f, -0.00216813f, 0.04093017f, 
    -0.05278929f, -0.05447979f, 0.03784853f, 0.01976280f, -0.03341853f, 0.01663403f, 0.00464758f, 0.01915756f, 
    -0.05115164f, 0.00856483f, -0.04458362f, 0.03829103f, -0.02879926f, 0.04514942f, -0.04676289f, -0.00561468f, 
    -0.04599966f, 0.03517972f, 0.02969849f, -0.01686477f, 0.01385543f, -0.05532170f, 0.02288355f, 0.03680471f, 
    -0.03076421f, -0.05320636f, 0.03931945f, 0.04796338f, 0.01207868f, 0.01008851f, -0.01225414f, -0.05600107f, 
    0.03110241f, -0.01476251f, -0.03943023f, 0.00979346f, 0.02204309f, 0.03908937f, -0.04139824f, -0.02627537f, 
    -0.04032656f, 0.02645785f, -0.02787956f, -0.06060136f, 0.03882669f, -0.04947694f, 0.02384401f, 0.02778883f, 
    0.00572246f, -0.00891148f, -0.00423260f, 0.03276328f, 0.03824882f, -0.05402989f, -0.04613977f, -0.02457177f, 
    0.01218132f, -0.01469576f, 0.01162007f, -0.05930764f, -0.04430270f, -0.00657367f, -0.03136328f, 0.02586481f, 
    -0.05410645f, -0.05572570f, 0.01257433f, -0.04371397f, -0.03057126f, -0.00535314f, -0.04098888f, 0.02770339f, 
    -0.03101453f, 0.00812211f, 0.03732592f, 0.02485149f, -0.05981350f, -0.02102113f, -0.03401412f, 0.02282750f, 
    0.04908572f, -0.02576036f, 0.00932813f, -0.02404621f, 0.02982433f, 0.04385801f, 0.04144956f, -0.04798357f, 
    -0.05309068f, -0.01979221f, -0.00785405f, 0.01745335f, 0.04281023f, 0.03314207f, -0.03666626f, -0.04608588f, 
    -0.01890608f, -0.04063297f, -0.01198700f, 0.02392955f, 0.03047173f, 0.01513741f, -0.00394308f, -0.01185806f, 
    0.02195796f, 0.04537720f, -0.01626969f, -0.03635426f, 0.00829161f, -0.01507933f, -0.02212949f, 0.00119162f, 
    -0.04125333f, 0.02534095f, 0.03581404f, 0.03151633f, -0.05289358f, -0.01881765f, 0.05575800f, 0.02915926f, 
    0.01213600f, 0.02165604f, -0.05534645f, -0.00301368f, -0.05630509f, 0.03624612f, -0.00526791f, -0.03445094f, 
    -0.03996920f, -0.00855187f, 0.01334374f, -0.05638771f, 0.01721811f, -0.05553686f, 0.01786474f, -0.04776974f, 
    -0.03421950f, -0.04848590f, 0.02464444f, 0.02039169f, 0.03931472f, 0.05549194f, -0.00074835f, -0.01998435f, 
    -0.03841737f, -0.03136185f, 0.01416259f, 0.03909940f, 0.02352552f, -0.02527987f, -0.01222938f, 0.04328160f, 
    -0.04567591f, -0.05223180f, 0.03391429f, 0.02891921f, -0.06097189f, -0.03375658f, 0.01001078f, 0.00763470f, 
    -0.03451505f, 0.01963558f, -0.05117820f, 0.04169605f, 0.04804575f, -0.02931386f, -0.03221366f, -0.05982321f, 
    -0.03516136f, 0.01221714f, -0.00638277f, -0.03494151f, 0.00230069f, -0.03104916f, 0.00887766f, -0.03504746f, 
    -0.04357214f, -0.03829440f, -0.03618684f, -0.04942706f, 0.03741055f, 0.02871339f, 0.00814740f, -0.05996726f, 
    0.02654117f, -0.01624566f, 0.03384719f, 0.04196991f, 0.01614424f, 0.01397136f, 0.02508827f, 0.02728831f, 
    0.04749099f, 0.02186585f, 0.01757038f, -0.00653963f, 0.02042396f, 0.00700535f, 0.00786068f, -0.03645056f, 
    -0.04640667f, -0.03452523f, -0.02112092f, 0.00208334f, -0.02053834f, -0.05351916f, 0.04721883f, -0.02293394f, 
    -0.05062183f, -0.01073945f, -0.00789397f, -0.05940748f, 0.02085357f, -0.05055318f, 0.03524068f, 0.02015309f, 
    -0.05911446f, 0.01164916f, -0.00034784f, 0.03364392f, -0.00901885f, -0.02871223f, 0.04064053f, 0.04584105f, 
    0.00695443f, -0.05019102f, -0.00007829f, -0.02426567f, -0.00666977f, 0.00139206f, 0.03580861f, -0.04755351f, 
    -0.02320887f, -0.01537797f, 0.01733017f, -0.00106013f, -0.04182013f, -0.03177173f, -0.01334325f, -0.00911048f, 
    -0.04801956f, -0.05923530f, -0.03679529f, 0.01943573f, 0.00738180f, -0.03637973f, -0.04736101f, -0.05514304f, 
    0.03256853f, -0.04940393f, -0.02296559f, -0.02092082f, -0.04064485f, 0.00510033f, -0.04546918f, -0.00109657f, 
    0.03370310f, 0.05008439f, -0.04431080f, 0.00973552f, 0.02160472f, -0.01167529f, -0.05740938f, -0.01897168f, 
    -0.02148226f, 0.06520693f, -0.04646785f, -0.01647665f, -0.03871269f, -0.02189707f, -0.07725288f, 0.03274638f, 
    -0.04519017f, 0.04520990f, -0.03807543f, 0.02183337f, -0.04498169f, -0.04299216f, 0.00345633f, -0.05658101f, 
    -0.05144419f, -0.05395691f, -0.03522630f, 0.00016308f, 0.02015924f, -0.05911595f, -0.07438859f, -0.06632242f, 
    -0.00500734f, 0.05258620f, -0.05343312f, -0.02226578f, 0.04893015f, -0.05268835f, 0.01217921f, -0.02515228f, 
    -0.00756850f, -0.02701536f, 0.00614578f, -0.00939507f, -0.03322773f, -0.02734904f, -0.02768022f, 0.04016681f, 
    0.03107123f, 0.00211436f, -0.06336928f, -0.02687753f, 0.04201834f, -0.03417531f, -0.03036697f, 0.03250360f, 
    0.03009272f, 0.01001405f, 0.03431621f, 0.04117727f, -0.01005524f, -0.04796036f, 0.00153154f, -0.01735053f, 
    -0.03461555f, 0.02233461f, -0.00866601f, -0.05874150f, -0.02348175f, -0.02832193f, -0.02844389f, -0.03301279f, 
    -0.04101070f, 0.00111576f, 0.00854062f, -0.01718103f, 0.03563685f, 0.03018731f, -0.04561540f, -0.02982270f, 
    -0.02000582f, 0.01949490f, -0.01034709f, 0.00418693f, -0.04076001f, 0.00600356f, -0.02004143f, 0.01158770f, 
    -0.03155874f, 0.07376657f, -0.03464263f, 0.02311522f, 0.01208780f, 0.04521438f, -0.02490876f, -0.00099422f, 
    -0.04476430f, -0.04701094f, 0.03612226f, -0.06372587f, 0.03077945f, -0.04079571f, -0.04647730f, -0.01823214f, 
    0.00822581f, 0.04538987f, 0.02223249f, -0.04973672f, -0.02165725f, 0.02010129f, -0.02802645f, -0.02530594f, 
    0.02893123f, 0.04721534f, -0.06802189f, 0.05325358f, -0.01690257f, -0.03293953f, -0.06658074f, -0.04232970f, 
    0.00324255f, 0.04703168f, -0.02913050f, 0.04773761f, 0.03010970f, -0.05547213f, -0.02681636f, 0.02849976f, 
    -0.07782986f, 0.00576423f, -0.06671168f, -0.03435823f, -0.02560742f, -0.02032712f, 0.00673675f, 0.02021509f, 
    0.01594125f, -0.03783620f, 0.01187102f, -0.01205319f, -0.04274657f, 0.05337202f, -0.04788826f, -0.02737675f, 
    0.03447855f, -0.05442398f, -0.00219211f, 0.05328107f, -0.05658624f, 0.01386506f, -0.03098686f, -0.03085399f, 
    0.01546171f, -0.07610028f, -0.04443263f, 0.01075792f, 0.05238607f, -0.05352024f, -0.04258732f, -0.01729239f, 
    -0.03183453f, 0.00098644f, 0.01313887f, 0.00920441f, -0.05572812f, -0.04354605f, -0.05000948f, -0.03498001f, 
    -0.04133434f, -0.05156285f, -0.03867568f, -0.07439088f, -0.04585250f, -0.02673086f, 0.00120588f, -0.05114067f, 
    0.01416493f, -0.02258398f, 0.03135866f, -0.02532914f, -0.01661156f, -0.01595878f, -0.00583667f, -0.04435242f, 
    0.05103356f, -0.03041412f, 0.01243313f, 0.06154008f, -0.03740282f, -0.03687841f, -0.02684433f, -0.04785096f, 
    0.04737476f, 0.04349074f, 0.05438558f, -0.00436197f, 0.03349449f, -0.04494333f, -0.00302881f, -0.01687021f, 
    -0.02696214f, 0.03839583f, 0.05377579f, -0.01594421f, -0.03825487f, -0.04301472f, 0.00014080f, -0.02072949f, 
    0.00315390f, -0.05140939f, -0.05022186f, 0.04329778f, 0.00007434f, -0.00340807f, -0.00303392f, 0.02479765f, 
    -0.02466386f, -0.04920730f, 0.04325784f, 0.00033707f, 0.03246858f, 0.03671454f, -0.05352649f, -0.00039410f, 
    0.03445011f, -0.06735221f, 0.03731180f, 0.00673655f, 0.02123527f, 0.03228330f, -0.01607779f, 0.03200770f, 
    0.02989292f, 0.03302436f, 0.01589249f, -0.02028167f, 0.02385859f, -0.05754820f, -0.03886535f, -0.00535491f, 
    0.04132945f, -0.01312421f, -0.06516554f, 0.02039647f, 0.01948134f, -0.05008950f, -0.02100174f, 0.04071380f, 
    -0.02406302f, -0.03158072f, -0.03903969f, -0.05960733f, 0.00579426f, -0.02937851f, 0.00339114f, -0.04415184f, 
    -0.02623189f, 0.00712918f, -0.05342547f, -0.04340558f, 0.04362572f, -0.01032380f, -0.04030246f, -0.01121320f, 
    0.03889774f, -0.06764842f, -0.04774284f, -0.00330010f, 0.02000804f, 0.04404924f, -0.00142523f, -0.02447283f, 
    -0.00542794f, 0.03437862f, 0.01510272f, -0.04786968f, -0.02511150f, 0.04875590f, -0.05201901f, -0.00163564f, 
    -0.03146626f, -0.05219208f, 0.01777618f, -0.02942618f, -0.06911736f, -0.06417254f, 0.02496271f, 0.03316383f, 
    0.02218034f, -0.00099224f, 0.00385362f, -0.03864200f, -0.04920520f, 0.01468123f, -0.04756128f, -0.04063689f, 
    0.01363807f, 0.03762386f, 0.03068464f, -0.06764542f, -0.02835411f, -0.04434856f, 0.01768416f, -0.00949621f, 
    -0.02789102f, -0.03780379f, 0.03454357f, 0.04274469f, 0.03235727f, 0.01455748f, 0.01316459f, -0.01094183f, 
    -0.02563478f, -0.02183346f, 0.05215798f, -0.02096828f, -0.01779843f, -0.05500925f, -0.03698258f, -0.00280693f, 
    -0.03940734f, -0.06934567f, 0.03939243f, -0.00479613f, -0.05479782f, -0.00060232f, -0.04549871f, 0.02285933f, 
    -0.03016044f, 0.04131134f, -0.05463192f, -0.04247493f, -0.00525338f, -0.02424713f, -0.02865189f, -0.03152079f, 
    -0.01988619f, -0.03766910f, -0.03596574f, 0.03419947f, -0.05568206f, 0.00189593f, 0.04688528f, -0.02566162f, 
    -0.02758590f, -0.02277522f, -0.01643527f, 0.05012504f, -0.04933619f, -0.04127272f, 0.03810173f, 0.02407936f, 
    0.02323936f, 0.01644441f, -0.00282525f, -0.02621698f, 0.00725623f, 0.02894159f, 0.04093386f, 0.03113681f, 
    -0.05152330f, 0.03545021f, 0.02192551f, 0.04010415f, -0.00865781f, 0.01922264f, 0.04994115f, -0.05955312f, 
    -0.01755885f, -0.06041408f, 0.00867010f, -0.03390426f, 0.02782245f, -0.01945270f, -0.01767082f, -0.03213974f, 
    0.00257604f, 0.01121351f, -0.03827273f, -0.03808298f, -0.04432010f, 0.02398763f, -0.05479388f, -0.04209295f, 
    0.01445208f, -0.04926851f, -0.05481323f, -0.06075221f, 0.00289649f, 0.04658560f, -0.01297012f, 0.01570956f, 
    -0.06122041f, 0.01354305f, -0.05384075f, 0.01851196f, -0.05877971f, -0.00544861f, 0.01990449f, -0.04540732f, 
    0.05027240f, -0.01286162f, -0.02892135f, -0.05767613f, -0.02806117f, -0.00992357f, 0.00666078f, -0.00265758f, 
    0.01267119f, 0.01744511f, -0.03373620f, -0.06067394f, -0.00797740f, -0.00922205f, -0.05629100f, 0.02208142f, 
    0.03219739f, 0.03124126f, 0.03612960f, 0.02382130f, -0.01486447f, 0.02422954f, -0.05858878f, -0.00641112f, 
    -0.02589414f, 0.04212646f, -0.05805314f, 0.04125104f, -0.00771509f, 0.00793182f, 0.03279923f, 0.01464200f, 
    -0.00750126f, 0.01589690f, -0.00238872f, -0.04330205f, 0.02430009f, -0.03500891f, 0.00425024f, -0.01099820f, 
    -0.00238806f, 0.02768865f, 0.00462396f, 0.01523487f, 0.02690546f, -0.03618760f, 0.03698240f, 0.00930309f, 
    -0.00345379f, -0.03866595f, 0.03745550f, -0.05159371f, 0.04494791f, -0.03146283f, -0.00938006f, -0.00089744f, 
    -0.02854676f, -0.01288335f, 0.00618296f, 0.00823412f, -0.00574412f, 0.01950984f, 0.02632173f, -0.00465094f, 
    -0.02012254f, -0.00718062f, -0.01902066f, -0.03242030f, -0.04444018f, 0.02261873f, 0.00202672f, -0.04371880f, 
    -0.03274979f, 0.00131761f, -0.00120755f, 0.04163799f, -0.01707074f, -0.01513535f, -0.03264502f, 0.00917318f, 
    -0.05782795f, -0.04064908f, 0.04390908f, -0.02979737f, -0.01550927f, -0.04902490f, -0.02251679f, -0.05378804f, 
    0.01642333f, -0.04566047f, 0.01556299f, 0.04268147f, 0.00667589f, -0.01436129f, -0.06109430f, 0.01597303f, 
    0.04737296f, 0.03202138f, -0.04461810f, -0.00365117f, -0.00466055f, -0.05108952f, -0.01132117f, 0.01711466f, 
    -0.00375895f, 0.01255138f, 0.05026155f, 0.04009179f, -0.02404711f, 0.03708043f, -0.01862476f, 0.00721079f, 
    0.05356653f, -0.02960787f, 0.02082598f, -0.05559798f, -0.02766728f, -0.00691002f, 0.01728796f, 0.01781131f, 
    -0.05886864f, -0.02418648f, -0.01989288f, -0.01279680f, -0.01359075f, 0.04251327f, 0.00407676f, -0.04466166f, 
    0.05279348f, 0.02606255f, 0.00904324f, 0.02988522f, -0.05316553f, 0.02367090f, -0.00226105f, -0.00561627f, 
    -0.02467176f, -0.04351785f, 0.03968866f, 0.02263642f, 0.03450854f, -0.00091628f, -0.01208799f, -0.00147470f, 
    0.03059709f, -0.05150720f, -0.03119446f, -0.03892547f, -0.05126957f, 0.04681397f, -0.02816284f, -0.05795738f, 
    0.03994323f, -0.04771205f, -0.04018388f, -0.03348347f, -0.02283162f, -0.01234026f, 0.04214310f, 0.01788903f, 
    0.03345139f, -0.04933422f, 0.02738311f, 0.03676533f, 0.00539421f, 0.00310550f, 0.04247855f, -0.01494881f, 
    -0.00118524f, -0.04307518f, 0.00277228f, 0.04780897f, 0.00281012f, 0.02267191f, -0.03747636f, -0.03975084f, 
    0.01939818f, 0.04320044f, 0.00845997f, -0.05204903f, 0.00422824f, 0.02997216f, 0.02348147f, -0.04517169f, 
    -0.05465972f, -0.00083005f, -0.03696265f, 0.01351366f, -0.01678326f, -0.03435497f, -0.05485627f, 0.01623149f, 
    -0.00102178f, -0.04352771f, 0.02834382f, 0.04822183f, 0.00605224f, 0.01296553f, 0.02285970f, 0.01698017f, 
    0.02985416f, 0.00630441f, -0.02887181f, -0.02969185f, -0.00751463f, -0.02575282f, -0.01834526f, -0.03329889f, 
    -0.00494667f, 0.01637070f, -0.00769804f, -0.05657656f, -0.05507153f, -0.06039012f, 0.02003643f, 0.00581944f, 
    0.04379830f, -0.04614175f, 0.02397585f, -0.04946717f, -0.00394759f, -0.01369004f, 0.00897109f, -0.03141002f, 
    0.04505222f, -0.04453262f, 0.03636076f, 0.03113054f, -0.03444542f, -0.05380261f, 0.03896546f, -0.00016497f, 
    -0.03755100f, -0.01650148f, -0.04717471f, 0.02094809f, -0.00628407f, -0.01024403f, -0.03657876f, 0.01887552f, 
    -0.02265429f, 0.04004984f, -0.00795705f, -0.01472850f, -0.02407644f, -0.06068929f, -0.00807044f, 0.02143489f, 
    -0.10863109f, 0.34954622f, -0.23902567f, -0.10573739f, -0.13275518f, 0.12158387f, -0.02350685f, -0.01381942f, 
    -0.02419239f, 0.27451563f, -0.02323163f, -0.00661242f, 0.05511969f, -0.02497486f, 0.15255803f, -0.10332201f, 
    -0.14614423f, 0.08317225f, 0.01195300f, 0.01508151f, -0.16938263f, -0.16677175f, 0.08492485f, 0.00402230f, 
    -0.07982568f, 0.00094032f, -0.06422361f, -0.08692129f, 0.04255509f, 0.06162806f, -0.00532296f, 0.03834957f, 
    -0.08262435f, 0.12675542f, 0.01675164f, 0.11009289f, 0.07808380f, -0.05638240f, -0.02942998f, 0.03763920f, 
    -0.00603487f, -0.01406076f, -0.09944013f, 0.03217327f, -0.00681679f, 0.03297697f, -0.00474373f, 0.01478710f, 
    0.05686995f, 0.02839269f, -0.09045570f, 0.04484326f, 0.07769361f, -0.00365016f, -0.01844126f, -0.03341074f, 
    0.00603054f, -0.00303794f, 0.04954225f, 0.03937676f, 0.01151650f, 0.06111068f, -0.13111962f, 0.26095849f, 
    0.14200287f, 0.06503319f, -0.00257646f, 0.10714975f, -0.04499618f, 0.07699762f, -0.01391828f, 0.05721549f, 
    -0.05912599f, -0.06021288f, 0.08833477f, -0.01679698f, 0.03369293f, 0.00341787f, -0.02373412f, -0.00430755f, 
    -0.22838295f, 0.16772518f, -0.10516808f, -0.07771605f, -0.06320434f, -0.02118909f, 0.06578600f, -0.07407356f, 
    -0.12911290f, 0.02329184f, 0.01071960f, 0.10904443f, -0.01034434f, 0.01811155f, 0.02564620f, -0.04685203f, 
    0.04894656f, -0.04424409f, -0.00851547f, 0.10790230f, -0.03263524f, 0.20962882f, -0.02340138f, 0.05434367f, 
    0.03368675f, 0.04876413f, 0.06940994f, 0.10147275f, 0.19445468f, 0.00460752f, -0.00619769f, -0.02115564f, 
    0.03176286f, 0.03989228f, -0.01936530f, -0.09097358f, -0.00419793f, 0.02209294f, 0.07838070f, -0.04926017f, 
    -0.54577357f, -0.29588032f, -0.06271787f, -0.16776910f, -0.18502492f, 0.08356237f, -0.00586293f, -0.12511182f, 
    0.01575586f, 0.04458793f, 0.05271817f, -0.05898356f, -0.06998640f, 0.08746634f, 0.05298850f, -0.05354412f, 
    0.06861986f, 0.00497108f, 0.02604985f, 0.13859825f, 0.04134926f, 0.06613828f, 0.06084527f, 0.10143457f, 
    0.09806374f, 0.05634709f, 0.06828218f, -0.01791221f, 0.13140076f, 0.11222719f, -0.00244890f, 0.06267210f, 
    -0.01299482f, 0.04556419f, 0.05151179f, -0.05658536f, 0.05959187f, 0.05716443f, 0.03750694f, -0.07957327f, 
    -0.48822799f, -0.29538080f, -0.13554507f, -0.14311488f, -0.11299029f, -0.03459812f, 0.05129762f, -0.03218683f, 
    0.00622172f, 0.06904157f, 0.03763850f, 0.07039628f, -0.08329454f, -0.00183195f, -0.00986458f, 0.12205402f, 
    0.00669618f, 0.03036440f, -0.01850889f, 0.12872574f, -0.00109298f, -0.15285316f, 0.06101102f, 0.13385503f, 
    -0.02954972f, 0.02988695f, 0.06636285f, 0.02793227f, -0.04798678f, 0.00362985f, -0.04134362f, -0.02445929f, 
    -0.01121920f, 0.06712278f, -0.06803887f, 0.05473874f, 0.03032679f, -0.04905110f, -0.04282567f, -0.00381922f, 
    0.28564873f, 0.11872825f, 0.00845716f, 0.16440102f, 0.21408392f, 0.04428831f, 0.12544920f, 0.09212398f, 
    -0.02207875f, 0.04278057f, 0.02086735f, -0.02265356f, -0.04110207f, 0.06629085f, -0.04049471f, -0.08178963f, 
    0.10275836f, -0.13191664f, -0.02165306f, -0.00058445f, 0.10662273f, 0.16951050f, 0.23511946f, -0.04148158f, 
    -0.01135611f, -0.05244767f, 0.00986350f, 0.07143517f, 0.00298622f, 0.07226184f, -0.06601136f, -0.08242896f, 
    -0.00356454f, 0.03069441f, 0.05586691f, 0.16356753f, 0.07486693f, -0.14497903f, -0.02853794f, -0.14678583f, 
    0.29322591f, 0.14021659f, 0.13271387f, 0.04244815f, 0.11729288f, 0.16208674f, 0.08701331f, 0.05807741f, 
    0.06468154f, -0.04519581f, -0.01120815f, -0.08380643f, 0.11514127f, 0.07358672f, 0.05075901f, -0.05835354f, 
    0.02132882f, 0.03362443f, -0.01809326f, -0.03531063f, -0.15033263f, 0.01234747f, -0.01891173f, 0.05235735f, 
    -0.27267238f, 0.09449772f, -0.02685622f, 0.06473944f, -0.00790650f, -0.04316766f, -0.05239496f, 0.03111651f, 
    0.11972566f, -0.00286224f, -0.05448803f, -0.09490906f, 0.06051233f, -0.03673249f, 0.03114258f, -0.06893563f, 
    -0.09747971f, -0.18977039f, -0.06232931f, -0.19972010f, -0.11924026f, -0.01934233f, -0.10114603f, 0.02408333f, 
    -0.10032731f, 0.08264489f, -0.03026411f, -0.08394945f, 0.11374919f, 0.01680422f, -0.03938197f, -0.02838912f, 
    -0.04981332f, 0.10730201f, 0.06572096f, 0.07021510f, -0.05039404f, -0.14679366f, 0.04772376f, -0.06404564f, 
    -0.22509481f, -0.11297034f, 0.12573949f, -0.09750035f, -0.09165213f, 0.05145318f, 0.06515089f, -0.06521080f, 
    -0.04552379f, 0.02367573f, -0.00252473f, -0.06465310f, 0.03986425f, 0.12472415f, -0.13491641f, 0.13440545f, 
    0.22538550f, -0.13778284f, 0.19575688f, 0.12487254f, 0.12592666f, -0.10628194f, 0.09379067f, 0.08152560f, 
    0.05853759f, -0.10619519f, 0.07405213f, 0.04164528f, -0.07150517f, 0.06945206f, 0.02506770f, 0.04499707f, 
    0.05138109f, 0.06264869f, 0.04828494f, 0.00858832f, 0.24097258f, 0.36351568f, 0.16128026f, -0.09436382f, 
    -0.12706204f, -0.06424417f, 0.03811112f, -0.02406293f, 0.07600291f, 0.02002246f, 0.02035109f, -0.03418724f, 
    -0.06708842f, 0.01941926f, -0.03465521f, 0.07297854f, -0.03437258f, 0.08067797f, 0.07941663f, 0.05332724f, 
    0.15496014f, 0.01681228f, -0.00295811f, 0.16092740f, -0.15683228f, -0.02187774f, 0.08280576f, -0.02525484f, 
    -0.09589422f, -0.01749950f, 0.10959046f, -0.03333129f, -0.04422723f, 0.09549701f, 0.07169551f, 0.04433772f, 
    0.00085470f, 0.20716086f, -0.06498417f, 0.02937080f, 0.05489879f, -0.31647715f, -0.00347190f, -0.27812117f, 
    0.00510367f, -0.02243726f, -0.02855190f, -0.02924129f, -0.05252546f, -0.01621998f, -0.03240333f, -0.05868721f, 
    0.01795950f, 0.07275286f, 0.06706055f, 0.08631586f, 0.04667347f, 0.11597717f, 0.02817775f, 0.05682761f, 
    0.00605941f, -0.43833143f, -0.06423377f, 0.09547771f, -0.06376731f, -0.00293843f, 0.01809918f, 0.09178340f, 
    0.06314727f, 0.04229198f, 0.05552888f, 0.05232668f, 0.05326264f, 0.02849393f, 0.08674560f, -0.01350959f, 
    -0.10058953f, 0.02557240f, -0.03911464f, -0.07168189f, -0.05828125f, -0.39760521f, -0.00150202f, -0.13342792f, 
    0.05057521f, -0.07226156f, -0.02898056f, -0.05675434f, -0.10942717f, 0.02999895f, 0.00011055f, 0.03115249f, 
    -0.03148184f, 0.09649180f, 0.13658762f, 0.04560427f, -0.05191375f, -0.02333921f, -0.15055497f, 0.12310954f, 
    0.13195464f, 0.26726782f, -0.10863014f, 0.11549530f, -0.01610866f, -0.00748630f, -0.00274710f, 0.08030555f, 
    0.05132896f, 0.07300823f, 0.01780151f, 0.13074921f, 0.11608253f, 0.02225454f, -0.02226771f, 0.03029663f, 
    -0.08929767f, -0.04327843f, -0.08407512f, -0.04471936f, -0.28580877f, -0.01919970f, -0.15673397f, -0.15539877f, 
    -0.01124795f, 0.12355159f, -0.05569466f, 0.04602249f, -0.08082426f, -0.01873349f, 0.02115149f, -0.07679757f, 
    0.07059648f, 0.00378396f, -0.05509645f, 0.02789045f, -0.00388094f, -0.05318142f, -0.07194217f, 0.07545531f, 
    0.27530259f, -0.00992949f, 0.05882287f, 0.19642355f, -0.10922024f, 0.12399895f, -0.06214170f, -0.00753421f, 
    -0.07911120f, 0.08088537f, -0.00394038f, -0.05271035f, -0.00016616f, -0.00488357f, 0.12822200f, 0.02410065f, 
    -0.07118354f, -0.04166898f, 0.03133663f, -0.16328597f, 0.04580781f, 0.20229942f, 0.06783982f, -0.09246265f, 
    -0.03944788f, -0.02627274f, -0.03101398f, 0.11146197f, 0.01341014f, -0.00688359f, 0.07352115f, -0.05605747f, 
    0.05095405f, -0.03631771f, 0.07670815f, -0.00009465f, -0.01535150f, 0.09554557f, 0.06423855f, 0.10791234f, 
    0.02820704f, 0.07641415f, -0.00037841f, -0.18406145f, -0.09483815f, -0.02018965f, 0.02625940f, -0.03706237f, 
    -0.03574875f, -0.05281229f, -0.02576743f, -0.01264927f, 0.01801815f, -0.04462789f, 0.03591138f, 0.18766756f, 
    -0.07412805f, 0.10641735f, 0.13729873f, -0.02837405f, 0.22579624f, -0.08816345f, -0.04088337f, 0.09474690f, 
    -0.00030182f, -0.03826592f, -0.03092013f, 0.03646902f, 0.02115578f, 0.08195141f, 0.00861947f, 0.08449334f, 
    -0.02278434f, 0.03159199f, 0.01219507f, 0.04040357f, 0.04375086f, 0.10646834f, 0.07563793f, 0.05166164f, 
    -0.18159114f, -0.07754472f, -0.05070729f, -0.07136823f, 0.04978270f, -0.03036589f, 0.07959360f, -0.00371790f, 
    -0.02991141f, -0.13697982f, 0.03053860f, 0.08535184f, -0.10885011f, -0.02073438f, 0.02545076f, -0.00524184f, 
    0.07890714f, 0.06053649f, 0.12485635f, 0.07868982f, -0.22599852f, 0.03628650f, -0.07269161f, -0.00286364f, 
    0.15658131f, 0.03322838f, -0.00081951f, -0.06361529f, 0.02174588f, 0.02654945f, 0.00073389f, -0.00670834f, 
    0.08440283f, 0.09193349f, -0.02263862f, 0.07303303f, 0.04657360f, 0.10547085f, -0.00029615f, 0.05777755f, 
    -0.12775707f, 0.19827914f, 0.01957000f, 0.14478798f, -0.18119982f, -0.02615333f, 0.06749059f, -0.02586688f, 
    0.01259853f, 0.03399658f, 0.01048736f, 0.10684235f, 0.02922154f, -0.06817894f, 0.02291194f, 0.03397122f, 
    0.11540423f, -0.10862669f, 0.05260456f, -0.01406185f, -0.15251519f, 0.02462063f, 0.02518328f, 0.02189375f, 
    -0.09652812f, 0.10022588f, -0.01211788f, 0.04407118f, 0.09797751f, -0.03327775f, 0.04200139f, 0.00760101f, 
    0.02410305f, 0.11004659f, 0.04356373f, 0.01070316f, -0.00039414f, -0.18969348f, 0.05930762f, -0.13244881f, 
    -0.04887328f, -0.00471662f, -0.05223398f, -0.04872419f, -0.05718683f, -0.01380672f, 0.03689373f, 0.03482956f, 
    -0.05726517f, -0.00294825f, -0.00979271f, -0.02156233f, -0.00275096f, 0.00719516f, -0.00741108f, 0.02667179f, 
    -0.05410713f, -0.04816275f, 0.00657299f, -0.05340420f, -0.05344201f, -0.04660631f, -0.05688548f, 0.02181757f, 
    -0.01489367f, -0.00293259f, -0.02626949f, -0.04833092f, -0.04300185f, -0.01893191f, -0.05093408f, -0.03583137f, 
    0.00878982f, 0.04712454f, -0.03843560f, 0.01480115f, 0.01455084f, 0.02705090f, 0.01527301f, 0.03230823f, 
    0.03268481f, -0.01214924f, 0.00592965f, -0.06032070f, 0.00518802f, -0.05107427f, 0.04282234f, -0.01551103f, 
    -0.03979354f, 0.02253493f, -0.01754783f, 0.03321616f, -0.03747173f, -0.03276574f, -0.05371926f, 0.04484040f, 
    0.00591375f, -0.02002368f, -0.02312463f, -0.03436585f, 0.04672324f, 0.00569954f, -0.03157097f, -0.04980246f, 
    0.00584718f, -0.01634875f, -0.03522280f, 0.04861658f, -0.01752149f, 0.00006521f, 0.03854264f, 0.00806751f, 
    -0.04941607f, -0.01726183f, 0.03631945f, 0.01340811f, -0.02288993f, -0.02764873f, 0.03359958f, 0.03766583f, 
    0.01225784f, 0.02757569f, -0.01676241f, 0.02838277f, -0.02855850f, 0.03153419f, -0.00090282f, -0.03841089f, 
    -0.03349014f, -0.02191747f, -0.04629735f, 0.04622242f, -0.01476534f, 0.03517846f, -0.01593331f, -0.00647896f, 
    -0.03676173f, -0.05196064f, 0.00815500f, 0.02758064f, 0.03037469f, 0.03470526f, 0.00405580f, 0.04522523f, 
    0.03846419f, 0.03141971f, 0.02336907f, 0.01943255f, -0.01018934f, 0.00887262f, 0.01115295f, 0.00316413f, 
    0.04607610f, 0.02160891f, 0.02233909f, -0.00353034f, 0.02254685f, -0.06117267f, 0.01466237f, 0.02776588f, 
    -0.03068846f, -0.01708758f, -0.03762046f, 0.03489961f, -0.00180899f, 0.01934201f, 0.01810696f, 0.04933963f, 
    0.02415659f, -0.05576340f, 0.00114854f, 0.02268004f, 0.04524138f, -0.03887522f, -0.02512120f, -0.03393588f, 
    0.02226994f, -0.00866213f, -0.05233690f, -0.01074073f, 0.03158362f, -0.05078419f, 0.03357705f, -0.00312665f, 
    0.02084206f, 0.00610327f, -0.03876028f, 0.03840481f, 0.01580634f, -0.03768128f, -0.04505422f, 0.02432805f, 
    0.01181636f, -0.01392014f, -0.02391396f, -0.03806370f, -0.02722544f, -0.00648455f, 0.01903553f, -0.06323747f, 
    0.03684206f, 0.03698235f, 0.04959598f, -0.05644818f, 0.02983570f, 0.03781459f, 0.04211372f, -0.04297856f, 
    0.03751221f, -0.04773172f, -0.00428530f, 0.02861178f, -0.02842625f, 0.00772342f, -0.04661889f, -0.05312960f, 
    -0.02190860f, 0.02331628f, -0.02274423f, -0.02668181f, -0.04711385f, 0.03657099f, 0.03891350f, 0.02458246f, 
    -0.04567167f, -0.05281443f, 0.01411728f, 0.01565346f, 0.03383331f, -0.02656753f, -0.04321249f, -0.01056952f, 
    -0.05137798f, -0.04329842f, -0.00957130f, -0.03696301f, 0.03387470f, 0.02972813f, -0.00927988f, 0.00807923f, 
    0.03711200f, -0.02691048f, -0.00097510f, 0.03092721f, -0.03363426f, 0.03465731f, -0.04289926f, 0.02458452f, 
    -0.03010117f, 0.00865118f, -0.04508252f, -0.03593256f, 0.00904637f, -0.03756671f, -0.02486461f, -0.03244568f, 
    0.04491457f, -0.05832532f, -0.05588625f, 0.01932271f, 0.01968342f, -0.04516866f, -0.00970632f, 0.02157213f, 
    -0.02930203f, 0.04317635f, -0.04394253f, -0.01967980f, -0.03629736f, -0.00950083f, -0.02743332f, -0.00177905f, 
    0.01857571f, -0.04566377f, -0.02733425f, 0.04898359f, 0.03411525f, -0.04536833f, 0.00216678f, 0.01189340f, 
    0.02832149f, -0.01332026f, -0.01808600f, 0.04180079f, 0.01277763f, -0.01172128f, 0.04562251f, -0.01084164f, 
    0.02142333f, 0.01584038f, -0.00579156f, -0.02669411f, -0.03005596f, -0.04203504f, -0.06504411f, 0.01584032f, 
    -0.03372162f, 0.03765912f, -0.00576570f, 0.02091265f, 0.01303105f, 0.00802540f, -0.04873211f, -0.00700986f, 
    -0.01453304f, 0.00372367f, -0.01584295f, -0.04919908f, 0.04814354f, 0.02117369f, 0.02523790f, -0.02478368f, 
    0.01860277f, 0.01911534f, 0.04378826f, 0.03712646f, -0.03618395f, 0.00958884f, 0.02837433f, -0.05481410f, 
    0.01600854f, 0.01964589f, 0.01048785f, -0.03665876f, -0.02070305f, -0.03718488f, -0.03811657f, 0.01304668f, 
    -0.05006712f, -0.06038103f, 0.03405806f, 0.00732492f, -0.04993934f, 0.04369991f, 0.02471677f, 0.01908990f, 
    -0.02526652f, -0.04099023f, -0.05698319f, -0.01965569f, -0.02517200f, -0.04682176f, -0.02472636f, -0.00947530f, 
    -0.04157714f, 0.03752183f, 0.02627194f, -0.01683046f, 0.02152857f, 0.00265458f, -0.01597518f, -0.01883569f, 
    -0.06196648f, -0.00091466f, 0.03104627f, -0.05734789f, -0.03451905f, -0.06278542f, 0.04462356f, -0.00640787f, 
    0.01738636f, 0.02147895f, -0.03190216f, -0.00739282f, 0.02067078f, 0.03684803f, 0.00818181f, 0.04146498f, 
    -0.01214253f, -0.00489616f, 0.02192373f, 0.02462445f, -0.03385349f, 0.00064015f, 0.00775919f, 0.01000458f, 
    0.03637071f, -0.04371513f, 0.01181666f, -0.05844641f, 0.01140039f, 0.00838110f, -0.05916753f, 0.04156984f, 
    0.01507635f, 0.02972552f, 0.00239848f, 0.03715947f, -0.01641251f, 0.02564520f, 0.01896797f, -0.03741929f, 
    0.04473585f, -0.03792940f, -0.00083329f, 0.01462525f, 0.04499771f, -0.02814164f, 0.03937970f, 0.00338439f, 
    -0.04713344f, -0.04325128f, -0.01865660f, 0.03999529f, -0.02696277f, -0.03014890f, 0.00408558f, -0.04521359f, 
    -0.00497632f, 0.02087646f, -0.05582382f, -0.04678440f, -0.02463620f, -0.02148942f, 0.03978560f, -0.03551444f, 
    -0.00529156f, 0.00995817f, 0.02683439f, 0.01074752f, -0.04791272f, 0.03951327f, 0.01473590f, -0.05218193f, 
    -0.00145070f, 0.01458295f, 0.04556452f, -0.02090226f, -0.05790564f, -0.00399726f, -0.05182969f, -0.06040655f, 
    0.01175665f, 0.00686213f, -0.05899581f, -0.00619298f, -0.02063329f, -0.02267630f, -0.04865472f, -0.05590965f, 
    -0.02332387f, -0.03843974f, -0.05255765f, 0.03613335f, -0.03655612f, -0.05495428f, -0.04995678f, 0.00925098f, 
    -0.00697515f, -0.00039590f, 0.04321326f, 0.04028033f, -0.04695619f, -0.05037523f, 0.03039288f, 0.01326056f, 
    -0.03973580f, 0.03182613f, -0.02012132f, -0.04918048f, -0.00071075f, -0.01301828f, 0.00777538f, -0.01740758f, 
    0.01892787f, -0.03825423f, 0.00121102f, -0.05317688f, 0.01818082f, 0.04752303f, -0.06063698f, -0.03776781f, 
    -0.02581759f, -0.00753298f, -0.05369106f, 0.04157048f, -0.02028883f, 0.01653498f, -0.00657198f, 0.00765889f, 
    -0.03586832f, -0.03436034f, -0.00202701f, -0.00991754f, 0.04226291f, 0.00709393f, -0.05184317f, 0.00531448f, 
    -0.03940773f, 0.02221622f, 0.00375863f, -0.01943189f, 0.01128863f, -0.06589877f, -0.01842820f, 0.04541460f, 
    -0.05186236f, 0.02415807f, 0.03003202f, -0.01462967f, 0.02264462f, 0.04305882f, -0.01808944f, -0.01290637f, 
    0.02673710f, 0.02987627f, -0.04226395f, 0.04760793f, 0.01934629f, -0.05771765f, 0.03933951f, -0.02632997f, 
    -0.01699684f, 0.01140119f, -0.05639841f, 0.01067118f, 0.03194138f, 0.03650327f, 0.02769103f, 0.01887333f, 
    0.03392949f, -0.03019794f, 0.03969808f, -0.04442490f, 0.00993187f, -0.02865257f, 0.02772966f, -0.03025958f, 
    -0.04371396f, 0.02678427f, -0.03861538f, 0.01195478f, 0.01156695f, -0.06271899f, -0.01671844f, -0.02180365f, 
    0.02286691f, 0.02092591f, -0.04490264f, 0.01272206f, 0.03819295f, -0.02353706f, -0.01953875f, 0.01397987f, 
    -0.05121239f, -0.05130254f, 0.02768080f, -0.04581724f, -0.05217035f, 0.04556339f, 0.01461830f, 0.04430467f, 
    -0.04838312f, 0.01135397f, -0.03075999f, -0.04279795f, -0.04898579f, -0.00697453f, 0.03250611f, 0.01922368f, 
    0.02448424f, 0.04683496f, -0.03187678f, -0.06243189f, -0.01324176f, -0.00837094f, 0.05725776f, -0.02186951f, 
    -0.02565726f, -0.02903382f, 0.01655859f, -0.03089545f, -0.01287108f, -0.01504439f, -0.00681930f, -0.00344465f, 
    0.04301266f, -0.03666293f, -0.06128230f, -0.04572079f, -0.05648510f, 0.02472366f, 0.03369534f, -0.02891970f, 
    0.04605633f, 0.02897032f, 0.01318456f, -0.05017815f, 0.01559473f, 0.01425165f, -0.04610942f, 0.03898743f, 
    -0.00672009f, -0.03351453f, 0.00683193f, -0.05003679f, -0.01130615f, 0.02256372f, 0.03856030f, -0.02137130f, 
    -0.06390705f, 0.02521111f, -0.01785915f, 0.03609997f, 0.04579951f, -0.03709920f, 0.05026453f, -0.05825178f, 
    0.02177389f, -0.05112213f, -0.04532583f, 0.00585491f, -0.05841102f, -0.00149880f, 0.03222045f, 0.04210450f, 
    -0.02104554f, 0.01959039f, -0.01273527f, -0.04290012f, -0.02016712f, -0.02756443f, 0.01142617f, -0.02898211f, 
    -0.02610747f, -0.03389824f, -0.02416146f, -0.01433276f, -0.02162083f, 0.01783244f, 0.00185079f, -0.04262917f, 
    -0.00965221f, -0.02116599f, 0.01612486f, -0.05036229f, -0.03524647f, -0.01516817f, 0.01375478f, 0.02827186f, 
    0.01905845f, 0.00201947f, -0.02383217f, 0.02406046f, -0.05003992f, 0.04692538f, -0.04545949f, -0.00644772f, 
    0.04458920f, 0.02168558f, -0.05080921f, -0.01806078f, -0.02641680f, 0.01751960f, -0.03040066f, 0.01208781f, 
    0.04753787f, 0.03857996f, -0.01710546f, 0.04172120f, -0.00872191f, 0.00513090f, 0.03050187f, -0.03106526f, 
    -0.06336155f, 0.03995313f, -0.00845952f, -0.06541270f, 0.05104189f, 0.01800757f, -0.02961591f, 0.04640808f, 
    -0.00233406f, -0.04037083f, -0.01330835f, -0.03702204f, -0.05307113f, -0.05617097f, 0.01652750f, -0.01297039f, 
    0.31306714f, 0.28874961f, -0.02682811f, 0.07059231f, 0.02756654f, 0.02340593f, -0.00559168f, 0.03117331f, 
    0.17207025f, -0.00650014f, -0.04789615f, 0.01793226f, -0.05247831f, 0.03077129f, -0.02896743f, -0.06002619f, 
    0.13382712f, 0.01048898f, 0.10288092f, 0.01366796f, -0.22371927f, -0.12401197f, 0.04589861f, 0.01674839f, 
    0.04004759f, 0.09276412f, 0.00381993f, 0.01967997f, 0.12376833f, 0.00007845f, -0.08288412f, 0.09404986f, 
    -0.05185631f, -0.12636358f, -0.04196838f, 0.00410372f, 0.10479644f, 0.12273921f, 0.13512178f, -0.01670943f, 
    0.13393670f, 0.28497612f, 0.13177410f, 0.07507241f, -0.02108240f, -0.04572805f, 0.06420933f, -0.05067704f, 
    0.09636853f, 0.00596543f, -0.03377068f, 0.01157014f, 0.08034425f, -0.00571491f, -0.03309023f, 0.01508480f, 
    0.00801016f, 0.09261741f, 0.01816784f, 0.04625380f, 0.15604337f, 0.14478981f, -0.05801747f, 0.11160801f, 
    0.09473978f, 0.07459819f, 0.05426747f, -0.01699277f, 0.01941270f, -0.03869332f, -0.02329112f, 0.09174021f, 
    -0.05430666f, 0.04861399f, 0.03184159f, 0.03758913f, -0.05422016f, 0.10559011f, -0.08636256f, 0.07793757f, 
    0.17477107f, 0.11870442f, 0.12502867f, 0.08526841f, -0.04162418f, 0.09546617f, 0.02166372f, 0.14019173f, 
    -0.02410840f, -0.06615934f, 0.04304615f, 0.00038077f, -0.01094861f, 0.10967067f, 0.02589730f, -0.01141703f, 
    0.16258541f, -0.02996055f, 0.04528941f, -0.01322084f, -0.14578885f, 0.23433661f, 0.09035902f, 0.06485149f, 
    0.05316910f, 0.01633603f, 0.10533471f, 0.14758687f, -0.01320432f, -0.01948761f, -0.01857620f, 0.02461358f, 
    0.19151564f, 0.09922824f, 0.02801537f, 0.00489796f, 0.02633504f, 0.09085894f, 0.10735930f, -0.06570103f, 
    -0.27421579f, -0.06888335f, -0.15039353f, -0.05944370f, -0.00491426f, -0.08011882f, -0.06023773f, -0.06107442f, 
    0.03860986f, -0.06678423f, 0.02084794f, 0.02947282f, -0.06087295f, 0.03467874f, 0.01450151f, -0.04016886f, 
    -0.01425517f, 0.07134511f, -0.02466671f, -0.03752196f, 0.01073516f, 0.15323345f, 0.18073606f, 0.04310139f, 
    0.01600483f, 0.03232915f, 0.00189954f, 0.03553119f, -0.03160202f, 0.12595068f, -0.02317371f, 0.06702090f, 
    -0.05233903f, 0.02721551f, 0.01217699f, -0.06291518f, 0.04055258f, 0.05830172f, 0.05855985f, -0.10020456f, 
    -0.36066073f, -0.19356799f, 0.09031095f, -0.05305257f, 0.04449411f, 0.03653224f, 0.00436411f, 0.03183850f, 
    0.01923429f, -0.01499863f, 0.02218882f, 0.04203263f, -0.07193579f, -0.01347026f, 0.06993551f, 0.01190214f, 
    0.05872412f, -0.01780305f, -0.01725428f, 0.04222260f, 0.09552710f, -0.20843570f, 0.14667897f, 0.18050174f, 
    0.09152713f, -0.00920395f, -0.00285745f, 0.06311825f, 0.03239398f, 0.04750331f, 0.00819373f, 0.09646133f, 
    0.03651805f, -0.05312806f, 0.01844779f, 0.07209118f, -0.01134666f, -0.01144934f, 0.05839588f, 0.06740229f, 
    0.12876268f, 0.01113248f, 0.11699007f, 0.21936092f, 0.04990065f, -0.01675019f, 0.07586028f, 0.02522946f, 
    0.05261414f, -0.02096342f, -0.07475445f, -0.04421360f, -0.10526778f, -0.00080203f, 0.02591000f, -0.07774844f, 
    -0.01606637f, -0.00185415f, 0.04659683f, 0.00502973f, -0.08384055f, 0.06310813f, 0.10756847f, 0.10526056f, 
    0.14863521f, 0.04912993f, 0.02664574f, 0.01037869f, -0.13270323f, 0.10093423f, 0.00028606f, 0.11025023f, 
    0.04984462f, 0.02543255f, -0.00830135f, -0.04268342f, -0.01314508f, 0.05938114f, 0.10214002f, 0.06115690f, 
    -0.05392920f, 0.00531751f, 0.09839901f, 0.12324502f, 0.02291804f, 0.03784797f, 0.01344609f, -0.04875641f, 
    -0.01034837f, -0.04685508f, 0.09980180f, -0.04473775f, 0.05378110f, -0.00203757f, 0.09775347f, -0.00725203f, 
    -0.06582730f, 0.08801377f, 0.07715925f, 0.10911851f, -0.08425032f, 0.25054312f, -0.01468446f, 0.13710777f, 
    0.05986545f, 0.03272223f, 0.02740021f, 0.04146354f, -0.01661558f, -0.00856921f, -0.00659744f, 0.01848971f, 
    0.04036243f, 0.05754222f, -0.01999109f, 0.09844919f, -0.01692485f, -0.00292313f, -0.04558961f, 0.00463748f, 
    0.02768470f, -0.05280299f, -0.04945119f, 0.00821037f, 0.02519045f, -0.04101285f, -0.04188238f, 0.00905644f, 
    0.02939269f, -0.05558876f, 0.03221452f, 0.06433648f, 0.00140998f, 0.01315106f, 0.01311566f, 0.02831908f, 
    0.04535137f, -0.06316530f, -0.01796809f, 0.04524342f, -0.01859265f, -0.05857935f, 0.05430738f, -0.12044118f, 
    -0.08068004f, 0.01406051f, 0.03570154f, 0.03901385f, -0.01473204f, 0.03837786f, 0.01247495f, -0.04033425f, 
    0.06262533f, -0.07466344f, 0.12336240f, 0.11071934f, 0.05475171f, 0.01481223f, 0.04082927f, 0.08671379f, 
    -0.15633826f, -0.03111294f, -0.23182116f, 0.01516571f, -0.11638559f, 0.00497386f, 0.03760815f, -0.09958683f, 
    -0.00395550f, 0.08515437f, 0.11929354f, 0.02494946f, 0.02297099f, -0.03749525f, 0.03443120f, -0.00966640f, 
    -0.07276911f, -0.12853467f, 0.03509958f, 0.12606010f, 0.28344855f, -0.16391982f, -0.31077155f, 0.22642000f, 
    0.19821647f, 0.05173267f, 0.00442011f, -0.02065615f, -0.00556385f, -0.01947383f, 0.14646742f, -0.02766402f, 
    0.10226957f, 0.14289670f, 0.14430940f, 0.05047234f, 0.03019002f, -0.13026984f, -0.05853896f, 0.14936976f, 
    0.13126673f, -0.07782317f, -0.25129116f, 0.07922827f, 0.11446269f, 0.12101260f, -0.08586857f, 0.01485374f, 
    0.00287926f, 0.00344325f, 0.07804508f, 0.07038194f, 0.07600350f, 0.02362317f, 0.08141947f, 0.02292209f, 
    0.05012323f, -0.10632876f, 0.07628605f, -0.05914234f, 0.10009585f, 0.24976273f, 0.12282551f, 0.15636568f, 
    0.15376364f, -0.02291961f, -0.02618237f, 0.10700443f, 0.09278105f, 0.02985363f, 0.11657395f, -0.03007055f, 
    0.02623373f, -0.04313107f, -0.10024863f, -0.13747692f, 0.01469195f, -0.12193874f, 0.02005897f, -0.08616415f, 
    -0.17835419f, 0.23558056f, -0.12743708f, 0.03730576f, 0.06142956f, -0.10822438f, -0.07038795f, -0.06477436f, 
    0.01312673f, 0.08656359f, -0.01725510f, 0.05750145f, -0.04750751f, -0.02272665f, -0.11083094f, 0.06099316f, 
    0.03976996f, 0.04943185f, -0.06163610f, 0.00650426f, 0.06834627f, 0.04684781f, 0.18838172f, 0.12473568f, 
    0.05987761f, -0.10318591f, -0.06173446f, -0.00773104f, 0.03575558f, -0.14825164f, -0.08269125f, -0.03886992f, 
    -0.06861760f, 0.03130905f, -0.10471367f, -0.05623455f, 0.02632940f, -0.07698328f, 0.07160541f, -0.03736555f, 
    0.25700375f, -0.24700618f, -0.08363273f, -0.02682097f, 0.01884053f, 0.13211939f, 0.04355691f, 0.07542974f, 
    -0.04823161f, 0.02988020f, 0.06943496f, -0.08486775f, 0.03630515f, 0.05835147f, -0.02539354f, -0.06559753f, 
    0.01709930f, -0.00922227f, 0.08189348f, 0.01731486f, 0.17154549f, 0.05414480f, 0.22323209f, 0.16661817f, 
    0.02783465f, -0.07547120f, 0.00624502f, 0.09362601f, 0.04096394f, -0.01666671f, -0.01377885f, 0.01651503f, 
    -0.00820102f, -0.07635231f, 0.00165564f, 0.04777023f, 0.08321217f, -0.01929806f, 0.09431562f, 0.00449672f, 
    0.26111829f, 0.05010610f, -0.28664416f, 0.01453651f, 0.15282126f, -0.04845458f, 0.09384958f, 0.05293025f, 
    0.05142581f, 0.05863614f, 0.06018407f, 0.03183369f, 0.08941468f, 0.00083428f, -0.04083739f, 0.10902616f, 
    0.07760455f, 0.02928715f, 0.09539090f, 0.12993175f, -0.17620398f, 0.16148539f, -0.13051309f, -0.05543058f, 
    0.15639219f, -0.02061482f, 0.08959832f, -0.17390175f, 0.00997240f, 0.03045058f, 0.05422198f, -0.01749300f, 
    -0.03996938f, -0.00073061f, 0.05436921f, 0.05763188f, 0.05171783f, -0.06694087f, -0.01703468f, -0.02499370f, 
    0.01335892f, 0.24397124f, -0.13516207f, -0.16872224f, -0.00149970f, 0.12086118f, -0.00682842f, -0.02218793f, 
    -0.04775104f, 0.00552501f, 0.12563846f, 0.08592448f, -0.14236537f, 0.00044973f, -0.07267491f, 0.10846964f, 
    0.03554552f, -0.01890287f, -0.09820609f, 0.04068768f, 0.10482821f, 0.03250709f, 0.06496118f, 0.07665738f, 
    0.11468382f, 0.00508494f, -0.04742173f, -0.08243280f, 0.03194259f, -0.12288649f, -0.00350454f, -0.03990024f, 
    -0.10287509f, 0.04224712f, 0.05508742f, 0.09594978f, -0.01517141f, -0.03591224f, -0.00978874f, 0.01985675f, 
    0.07423704f, 0.27524972f, -0.07011266f, -0.21878909f, -0.09500896f, -0.01642638f, 0.02740455f, -0.00196874f, 
    -0.00018810f, 0.10721347f, -0.00645826f, -0.03681920f, 0.01196884f, -0.05750950f, -0.03043571f, 0.01666424f, 
    0.02237932f, 0.05373266f, -0.09031972f, -0.07816905f, 0.14240658f, -0.26843262f, 0.01217097f, -0.02829279f, 
    -0.18505488f, -0.00755652f, 0.04322804f, 0.08327988f, -0.11995613f, -0.06277687f, -0.02809262f, -0.05136900f, 
    0.03247129f, -0.03880566f, -0.01152883f, -0.13401705f, -0.01364870f, -0.17646079f, 0.05055945f, -0.15004614f, 
    0.11253129f, -0.17001227f, -0.06452841f, -0.11969747f, 0.05997706f, 0.08026320f, 0.02037940f, -0.08874758f, 
    -0.03142827f, 0.07371808f, 0.06182906f, -0.11260219f, 0.11453951f, 0.05057387f, -0.06728252f, -0.02578468f, 
    -0.03137984f, 0.12853394f, 0.00586300f, -0.02894365f, -0.01440699f, -0.05021989f, -0.19564943f, -0.05726409f, 
    0.06242782f, 0.13610089f, -0.00712884f, -0.00788100f, -0.01075733f, -0.03556881f, -0.02942579f, 0.07268752f, 
    0.02016562f, 0.01078581f, -0.04175841f, -0.07551590f, -0.04493815f, 0.07056908f, -0.04644760f, 0.03847814f, 
    -0.04779821f, -0.23437352f, 0.01292810f, -0.11136348f, 0.18551655f, -0.01512039f, 0.10528129f, -0.02404736f, 
    -0.00621674f, -0.05902314f, 0.04012338f, 0.04551507f, 0.00000901f, -0.02866176f, -0.03184038f, 0.16156515f, 
    0.06750962f, -0.03161642f, -0.12173945f, -0.00796411f, 0.01667300f, 0.19228193f, 0.30152330f, -0.04083076f, 
    -0.16144536f, -0.01610757f, 0.17315958f, 0.04626985f, -0.02429760f, 0.03337009f, 0.12066006f, -0.01235862f, 
    0.09226821f, 0.01085566f, 0.04301595f, 0.03364936f, -0.04829665f, -0.09769246f, -0.03034079f, 0.01931662f, 
    -0.15114574f, -0.19346902f, 0.05162003f, -0.02492671f, -0.09457108f, 0.09386747f, 0.06962340f, 0.02665218f, 
    -0.02589003f, 0.02783910f, 0.02081748f, -0.05682820f, -0.00187375f, 0.05943627f, 0.12101366f, -0.03737868f, 
    0.11961797f, 0.08111883f, -0.03087715f, 0.13380875f, -0.26570460f, -0.21779335f, 0.01528606f, -0.17268528f, 
    0.10209686f, 0.01465388f, -0.11487284f, -0.07421332f, -0.03265563f, 0.16501893f, 0.13215974f, 0.07686402f, 
    0.10014211f, 0.01773453f, 0.06307153f, 0.05613923f, 0.08662239f, 0.03510797f, 0.13903734f, 0.05647700f, 
    0.14756298f, -0.32871518f, -0.11609619f, 0.09032952f, 0.11575440f, 0.03244151f, -0.05014376f, -0.00243794f, 
    0.11651397f, 0.11987065f, -0.05753105f, -0.09487470f, 0.08773849f, 0.04512498f, 0.06536987f, -0.01637430f, 
    -0.14406465f, -0.00012314f, -0.14104986f, 0.01955648f, 0.09746628f, -0.19466695f, -0.27009010f, 0.01886746f, 
    0.14387050f, 0.04776108f, -0.00914495f, -0.08375861f, -0.10798020f, 0.19840233f, 0.02879216f, -0.00098870f, 
    -0.06175988f, 0.00494059f, 0.04409442f, 0.03979448f, 0.01459230f, -0.04899717f, -0.09741772f, 0.08312616f, 
    0.17166510f, 0.26853597f, 0.13623515f, 0.14339723f, -0.00269022f, 0.08065946f, 0.10785051f, 0.03255532f, 
    -0.05233231f, 0.04204770f, 0.00058002f, 0.02101215f, 0.17375202f, 0.04580813f, -0.01889188f, -0.00675490f, 
    0.03880890f, -0.08376922f, -0.06343398f, 0.05633049f, -0.02739633f, -0.07590356f, -0.20527478f, 0.08680892f, 
    0.09285673f, 0.08213504f, 0.05625885f, -0.05222395f, 0.00252102f, 0.06179339f, -0.00926757f, -0.13096073f, 
    0.04415624f, 0.03866518f, 0.01060015f, 0.04078293f, -0.03203972f, -0.02459393f, -0.01256530f, 0.09014405f, 
    0.11781698f, 0.23031245f, 0.08380469f, 0.10575814f, -0.11794288f, 0.02653029f, -0.00205189f, 0.05160923f, 
    0.03270481f, 0.03419794f, 0.04756406f, 0.02558508f, 0.03284764f, 0.04395282f, 0.00810037f, -0.01591638f, 
    -0.09390357f, -0.08003771f, -0.04295159f, -0.01491127f, 0.15641721f, 0.07455988f, -0.06262488f, -0.05030373f, 
    -0.12374677f, -0.00806167f, 0.15563604f, 0.10734666f, -0.02481242f, 0.03771266f, -0.06341851f, -0.03377559f, 
    0.01947487f, 0.02725586f, 0.03567679f, 0.00261156f, 0.02137255f, -0.02877603f, -0.07497995f, -0.00541093f, 
    -0.04347520f, -0.03300156f, -0.01202279f, -0.13968046f, -0.05862886f, -0.02394032f, 0.02915476f, 0.07665964f, 
    0.09559397f, 0.05647574f, 0.06459713f, 0.08569410f, 0.08552279f, 0.09477061f, 0.14575322f, 0.05061255f, 
    -0.02561640f, 0.11408757f, 0.10894048f, 0.13299654f, -0.02246812f, -0.08323727f, 0.00412902f, -0.06058945f, 
    -0.04698092f, -0.04096916f, 0.00748046f, -0.02986541f, 0.03848826f, -0.06099551f, 0.07564132f, 0.06122201f, 
    0.02183353f, 0.04956445f, 0.05817360f, 0.08756903f, 0.00882671f, -0.01210381f, 0.00296353f, 0.09974308f, 
    0.08965616f, -0.03147310f, 0.00762521f, 0.03037659f, 0.04831036f, -0.00019686f, 0.18492195f, 0.03049727f, 
    -0.00800913f, 0.03526115f, -0.04241242f, 0.01342188f, -0.00889867f, 0.05874084f, 0.05642680f, -0.02173508f, 
    0.15090166f, 0.03692869f, 0.11057765f, 0.14443305f, 0.01180717f, 0.09134694f, -0.01657639f, -0.03902205f, 
    -0.00973028f, 0.14808421f, 0.02542793f, -0.01855017f, 0.05759123f, 0.00294098f, 0.04513482f, 0.01182865f, 
    -0.00457682f, 0.02944288f, 0.00456377f, 0.00000707f, 0.11453833f, 0.04918403f, 0.05002892f, 0.08667807f, 
    0.06495368f, 0.27772149f, 0.10826376f, 0.08209524f, 0.00008759f, 0.07014169f, 0.19284074f, 0.01173384f, 
    0.08540974f, 0.02136817f, 0.07272914f, 0.09504074f, 0.04596572f, 0.00026506f, 0.03655167f, 0.02274194f, 
    0.06374899f, -0.03837065f, 0.03911299f, -0.00613865f, 0.06854104f, 0.13126279f, 0.12924314f, 0.15415536f, 
    0.01139494f, 0.16566575f, 0.06842469f, 0.00040311f, 0.01307164f, 0.01822537f, 0.07915877f, 0.02139349f, 
    -0.01860091f, 0.11745501f, -0.00412194f, 0.02388904f, 0.13808265f, -0.08507263f, 0.02574342f, -0.02731126f, 
    -0.08063412f, 0.00208475f, -0.18162084f, -0.21410868f, -0.08122278f, 0.09315324f, 0.02425038f, -0.03688411f, 
    -0.03710074f, 0.08191822f, 0.12599663f, 0.08355701f, 0.09778600f, -0.01103048f, 0.10443707f, -0.01517896f, 
    -0.02583173f, 0.00474180f, -0.01631751f, 0.06086902f, -0.18492733f, 0.01985812f, 0.20348834f, 0.06727459f, 
    0.11345461f, -0.04390413f, 0.00437594f, -0.02031475f, -0.11512920f, 0.00160543f, 0.06268215f, 0.01326197f, 
    0.01572147f, 0.00291595f, 0.04489221f, -0.00351849f, -0.01474006f, -0.05104433f, -0.03443968f, -0.02299030f, 
    -0.21802340f, -0.23801421f, -0.10056352f, -0.12411299f, -0.07449325f, -0.06141694f, -0.05314764f, 0.04462589f, 
    -0.03648433f, -0.06846187f, 0.03397747f, 0.00339385f, 0.04992690f, -0.04811430f, 0.12414584f, 0.00120260f, 
    0.02389353f, -0.05010933f, 0.12090687f, 0.04554651f, -0.30167457f, -0.14342108f, 0.11392878f, -0.07966269f, 
    0.04430056f, -0.05682406f, -0.02764018f, -0.07424913f, -0.07360643f, 0.05832307f, 0.13122465f, 0.06862479f, 
    -0.07801642f, 0.00684292f, 0.05319094f, 0.02820772f, -0.04519439f, -0.10574935f, 0.09700541f, 0.13644131f, 
    0.23202130f, 0.01821739f, -0.03384692f, 0.06056221f, 0.17761986f, 0.00818438f, -0.00643888f, 0.03046173f, 
    -0.08403268f, 0.09790159f, 0.01937765f, -0.03701160f, 0.08738994f, 0.01269825f, 0.04072957f, 0.06995124f, 
    0.01615647f, 0.07711550f, 0.01680481f, -0.03256300f, 0.08636586f, -0.09759094f, 0.00494269f, 0.11802716f, 
    0.04160389f, 0.01248486f, -0.04766408f, -0.03640728f, 0.00066634f, 0.13189602f, 0.08538181f, 0.04803874f, 
    -0.10522655f, 0.02798785f, -0.07737123f, 0.06920634f, 0.05370527f, 0.05005718f, 0.08073488f, -0.02227077f, 
    0.21205524f, 0.19396015f, 0.24445547f, -0.03563260f, 0.18661855f, 0.12422403f, 0.12660615f, 0.01026937f, 
    0.01666243f, 0.10193972f, 0.02025750f, -0.04550835f, 0.01957042f, -0.00681970f, -0.04395775f, -0.01166429f, 
    0.02135835f, -0.03769407f, 0.05459769f, 0.02832331f, 0.03784041f, -0.00050407f, -0.02089176f, 0.06986150f, 
    0.20036803f, -0.15992044f, 0.04863329f, -0.00203980f, 0.10373512f, 0.05186895f, 0.05928358f, -0.07706377f, 
    0.06382882f, 0.05741151f, 0.03467572f, 0.06219248f, -0.01959279f, -0.01236765f, -0.03982481f, 0.02343803f, 
    -0.03677451f, 0.24718736f, -0.09688876f, 0.03096769f, 0.24280624f, 0.17420444f, 0.00768959f, 0.10819118f, 
    -0.02247157f, -0.02466773f, 0.10600400f, 0.03295046f, 0.05073438f, -0.03594927f, -0.04032740f, 0.02657170f, 
    -0.02622583f, 0.00200197f, -0.00024272f, -0.00369726f, -0.02174104f, 0.11378971f, 0.01170994f, 0.00346228f, 
    0.01926556f, 0.12612629f, 0.10928894f, 0.06591305f, -0.03284857f, 0.00377110f, -0.07923510f, 0.00783041f, 
    0.00468293f, 0.02206919f, 0.01795579f, 0.02867712f, 0.08955166f, 0.01785265f, 0.01814310f, -0.09909327f, 
    -0.05695575f, -0.21648948f, 0.07015516f, -0.26355579f, -0.22816105f, -0.00148875f, 0.11859938f, 0.02527286f, 
    0.00632388f, 0.00359374f, 0.10903039f, 0.05171838f, 0.07815452f, 0.07809418f, -0.03426312f, -0.11567681f, 
    0.07207868f, -0.04177368f, 0.01531265f, 0.10129451f, -0.11311002f, -0.09091615f, -0.04008078f, -0.10620704f, 
    -0.29772189f, -0.14423610f, -0.05764697f, 0.02954749f, -0.05280971f, -0.06736247f, 0.07722142f, 0.00409810f, 
    -0.06444000f, -0.08813268f, -0.01783311f, 0.01348986f, 0.00033453f, 0.06173268f, 0.03875289f, 0.01801491f, 
    0.11719244f, -0.18156244f, -0.03479511f, -0.06125633f, -0.08961176f, 0.02034440f, 0.10470624f, 0.11942327f, 
    -0.02764836f, -0.02141122f, 0.09262154f, 0.03990121f, -0.04459139f, 0.00904584f, 0.06856582f, -0.03062796f, 
    -0.01548789f, -0.07123166f, 0.03724916f, 0.00547696f, 0.31226355f, 0.07269742f, 0.15483688f, -0.02822179f, 
    -0.07125700f, 0.06803919f, -0.08886973f, 0.01096132f, 0.02611732f, 0.02046084f, 0.00911951f, 0.04443967f, 
    -0.02138540f, 0.00424680f, -0.03722112f, -0.01708505f, -0.02943555f, 0.08133987f, 0.07388317f, -0.07721809f, 
    0.23899408f, 0.21433878f, 0.17547999f, -0.03739058f, 0.22970690f, 0.13244866f, 0.10141688f, -0.08906288f, 
    -0.02349890f, 0.05347891f, 0.03626407f, 0.09711972f, 0.09713522f, -0.07437507f, 0.01003732f, -0.01903609f, 
    -0.01169888f, 0.06653652f, -0.05514622f, 0.02442711f, 0.18162900f, 0.22289856f, 0.13634834f, 0.16093123f, 
    0.17707646f, 0.07030024f, -0.04011333f, -0.08020705f, -0.08051769f, -0.03191265f, 0.07332747f, 0.01566443f, 
    0.05218757f, 0.00570068f, 0.07329679f, -0.07002332f, 0.14228752f, 0.14403896f, 0.03768919f, -0.07310264f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01116816f, -0.02308047f, 0.03967591f, -0.00053077f, -0.01714968f, 0.03570499f, -0.02296133f, -0.03622655f, 
    -0.00945586f, -0.03374519f, -0.04283847f, -0.03119998f, 0.03216017f, -0.01697582f, 0.00167796f, -0.05107256f, 
    -0.04792069f, -0.03380429f, 0.12209271f, -0.00369092f, 0.06689744f, -0.04783574f, 0.04508715f, -0.01624413f, 
    -0.01555390f, 0.00359335f, -0.06689201f, -0.03781469f, 0.08702277f, 0.02805822f, -0.04640935f, 0.09175661f, 
    0.03625521f, -0.00098977f, 0.04243159f, -0.04678466f, -0.01700740f, -0.02889971f, -0.01913926f, 0.03152318f, 
    0.04633222f, 0.03617962f, -0.04498484f, -0.00862953f, 0.05685934f, 0.10041538f, 0.05734038f, 0.07034769f, 
    0.01329975f, 0.08552510f, 0.08802052f, 0.13255073f, -0.00304813f, -0.05339715f, -0.04373249f, 0.00834536f, 
    0.01050493f, -0.00193169f, -0.03364491f, -0.04349387f, -0.03778482f, -0.01145348f, 0.10848843f, 0.05345251f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13989109f, -0.07840029f, 0.11237022f, -0.24734065f, -0.10876490f, 0.04973844f, 0.36160892f, 0.03887605f, 
    0.02147153f, -0.02276418f, 0.05666262f, -0.12032518f, 0.12913734f, -0.27996877f, 0.14014176f, -0.15775439f, 
    -0.05447076f, -0.28133062f, 0.04646430f, 0.10576005f, 0.23923102f, 0.15162042f, -0.06382334f, 0.01318681f, 
    0.06062382f, 0.04144368f, -0.00385645f, -0.09678876f, -0.08123497f, -0.14247803f, -0.11853679f, 0.19036046f, 
    0.33131111f, -0.05528765f, 0.00856940f, -0.02331410f, 0.10447975f, -0.10343246f, 0.00951699f, 0.02143283f, 
    0.22330612f, -0.04505951f, -0.06263781f, -0.13862109f, 0.49842343f, 0.11018624f, 0.21829747f, 0.17000569f, 
    -0.03377873f, 0.28038892f, 0.31431964f, -0.01221372f, -0.04996399f, 0.11684421f, 0.11635426f, -0.04944892f, 
    0.27108958f, -0.16583993f, -0.05953363f, -0.08124617f, -0.00458689f, 0.24857388f, -0.04203163f, -0.00125620f, 
    -0.17470355f, -0.00506152f, -0.09683482f, 0.04463508f, -0.03459018f, -0.00893207f, 0.08423743f, -0.09902239f, 
    0.08101122f, -0.15836766f, -0.09631760f, 0.09288652f, -0.10546780f, -0.02480863f, 0.05089110f, 0.06624027f, 
    0.06236032f, 0.08352355f, -0.07025296f, -0.07103510f, -0.10139692f, 0.03783892f, -0.02708373f, 0.00594267f, 
    -0.01720918f, 0.08447646f, 0.05009218f, 0.01252006f, 0.06683457f, -0.05508633f, 0.09447752f, 0.01389702f, 
    0.04651371f, 0.10163300f, -0.05608335f, -0.00703395f, -0.07317040f, 0.07082649f, -0.12484919f, -0.02274788f, 
    0.01307254f, -0.10209768f, -0.12571488f, -0.11661612f, -0.03138012f, -0.08144370f, -0.01108383f, -0.12437218f, 
    0.07622284f, 0.00194686f, -0.10203861f, -0.08114351f, 0.04768348f, -0.04941108f, -0.02188744f, 0.00999919f, 
    0.09197661f, -0.18236789f, 0.06868425f, -0.03932120f, -0.01657488f, -0.11299227f, -0.05736291f, -0.12248349f, 
    0.17139520f, -0.05664496f, 0.04951249f, 0.04146863f, -0.00068248f, 0.05295357f, 0.04762928f, -0.04266193f, 
    -0.10529330f, 0.32690790f, 0.18217793f, -0.01205143f, 0.08019637f, -0.20650201f, -0.19234620f, -0.19634746f, 
    0.03029284f, -0.05481516f, 0.17564279f, -0.11948770f, 0.32511514f, 0.03147541f, -0.06128506f, 0.00834113f, 
    -0.06102366f, -0.00678615f, -0.09615820f, -0.04118898f, -0.17531027f, 0.02084048f, 0.07367802f, -0.06290364f, 
    -0.12246671f, -0.04020500f, -0.08965293f, 0.03068216f, -0.05095780f, 0.11216218f, 0.05007030f, 0.06783433f, 
    0.19559240f, -0.02536135f, -0.12901570f, 0.16301559f, 0.29151052f, -0.07708193f, 0.02003790f, -0.29076806f, 
    0.02394722f, 0.19207470f, 0.11212865f, 0.37392867f, 0.05652026f, 0.10303092f, -0.04385520f, 0.04201728f, 
    0.19659021f, -0.15892096f, -0.03771327f, -0.03648653f, -0.19758926f, 0.37172362f, 0.15315554f, 0.11141862f, 
    -0.26000574f, -0.04830451f, -0.02493572f, -0.02119271f, 0.05007893f, 0.07261965f, -0.29282814f, 0.12304477f, 
    -0.00436612f, 0.31288487f, 0.08003581f, -0.08728142f, 0.10855916f, 0.07875830f, 0.05684343f, -0.09496263f, 
    0.00304609f, 0.32784942f, 0.15435326f, 0.04327459f, 0.28947297f, 0.14486875f, -0.02497476f, 0.06133973f, 
    -0.09283428f, 0.29089570f, -0.02547259f, -0.02903544f, -0.21485938f, -0.15651928f, -0.08746012f, -0.08073162f, 
    -0.14127798f, 0.09510785f, 0.00407717f, 0.04072983f, 0.11256441f, 0.01006819f, -0.10819184f, 0.02748629f, 
    -0.00096231f, 0.04248319f, -0.07540829f, 0.19194217f, 0.13658459f, -0.06767738f, 0.08347477f, -0.29950067f, 
    0.11356722f, 0.10463434f, 0.06361046f, 0.36827683f, -0.04582742f, 0.04483889f, 0.03614030f, 0.02214655f, 
    -0.09282918f, -0.08179892f, -0.10770267f, -0.11212242f, 0.00001769f, 0.28958932f, 0.06573506f, 0.01285123f, 
    0.18016148f, -0.14807166f, 0.03841674f, 0.56206125f, 0.02589886f, 0.06260996f, -0.00663882f, -0.00697949f, 
    0.08358984f, 0.38501933f, 0.20868687f, 0.09930738f, -0.03863981f, -0.16528861f, -0.14264137f, 0.19022265f, 
    0.10883272f, -0.12182485f, 0.17637174f, -0.10858342f, 0.21285926f, 0.04731383f, 0.10979858f, -0.12838627f, 
    0.08083718f, -0.11039721f, -0.06421201f, 0.12620956f, -0.14620700f, 0.17742909f, -0.12042981f, -0.06059586f, 
    -0.16850598f, -0.00465255f, -0.04537775f, 0.03722392f, -0.00153188f, -0.03862835f, -0.05635683f, -0.09398972f, 
    -0.10129853f, 0.03054277f, 0.11633553f, 0.32035324f, 0.07621205f, 0.09810387f, -0.13930756f, -0.10790760f, 
    0.07734974f, -0.16748942f, -0.13744484f, 0.17397846f, -0.05775972f, -0.09786868f, 0.05359734f, 0.10765821f, 
    -0.04894571f, -0.05588495f, -0.01411492f, 0.07963578f, 0.04954705f, 0.27447447f, -0.03097969f, 0.14976865f, 
    -0.07174899f, -0.00366795f, 0.03118758f, -0.18875875f, -0.00190140f, 0.05714515f, -0.04228573f, -0.00401405f, 
    -0.02885747f, 0.10759170f, -0.00131322f, 0.09518307f, -0.00228265f, 0.01641163f, 0.16195163f, -0.38742435f, 
    0.01321375f, 0.03796048f, -0.20561180f, 0.11382861f, -0.31264436f, 0.30456227f, -0.08667476f, -0.06161698f, 
    -0.00826435f, -0.11063649f, 0.05407028f, 0.04193422f, -0.01192646f, -0.15108944f, -0.07610321f, 0.09962863f, 
    0.19910619f, -0.09829810f, 0.06184665f, 0.11507829f, -0.09070391f, -0.01197691f, 0.11913405f, 0.06860757f, 
    0.10342155f, -0.10913200f, -0.11269165f, -0.10031346f, -0.10762999f, 0.27905470f, 0.11810938f, 0.09005389f, 
    -0.11169361f, 0.38686508f, 0.07913481f, -0.00244694f, -0.11976355f, 0.07833521f, -0.06420508f, 0.00600918f, 
    -0.21261260f, 0.24134248f, 0.11879610f, 0.03841484f, 0.10617500f, 0.09997880f, 0.11304948f, -0.10182042f, 
    0.04410509f, 0.09966784f, -0.08855547f, -0.19671065f, 0.02577165f, 0.17434350f, 0.14370282f, 0.01874575f, 
    -0.08512235f, -0.42188671f, 0.08936043f, -0.00211873f, 0.02316399f, -0.10503675f, -0.04426769f, 0.43982133f, 
    0.04008563f, -0.15488902f, -0.09151778f, 0.01233859f, -0.21503158f, 0.06315854f, -0.03846375f, -0.08514261f, 
    -0.06804024f, 0.14179309f, 0.07140055f, -0.06970081f, 0.33267117f, 0.02587012f, 0.01120733f, 0.23979111f, 
    0.09867702f, -0.01705883f, -0.06221880f, -0.00949525f, -0.06614140f, 0.12360571f, 0.04191027f, -0.06257879f, 
    -0.09315056f, 0.00785743f, -0.09603294f, -0.22728652f, 0.11017088f, 0.13024579f, 0.15234531f, -0.03285706f, 
    0.04066676f, -0.14158729f, 0.10262385f, -0.02560746f, 0.00510793f, -0.03231977f, 0.03942555f, -0.09747683f, 
    0.24253583f, 0.18319470f, -0.04782803f, -0.01348460f, 0.14115213f, -0.06343005f, 0.13964705f, 0.04318501f, 
    -0.07892306f, 0.07509923f, 0.08148579f, 0.03442163f, 0.00961259f, -0.06152212f, 0.07813110f, 0.00363471f, 
    -0.06757966f, -0.00707218f, -0.00940490f, 0.10315988f, -0.11946593f, -0.00756670f, -0.07227136f, -0.06535443f, 
    -0.01530269f, -0.07211860f, 0.00028344f, -0.01107769f, -0.09292144f, 0.04305815f, -0.11548902f, 0.09287142f, 
    0.11240683f, 0.07848928f, 0.02399112f, -0.04001726f, 0.08280999f, 0.05846413f, 0.11199555f, -0.05412528f, 
    0.08842703f, -0.06319155f, -0.01042776f, -0.09727734f, 0.04927135f, 0.01871754f, 0.01711259f, 0.03535469f, 
    0.06969549f, -0.03129737f, 0.05578931f, -0.02852857f, -0.13303694f, 0.02520488f, -0.07954738f, -0.07561809f, 
    0.02343644f, 0.12408091f, 0.09355699f, -0.08368525f, -0.07399827f, 0.06704691f, -0.01717670f, 0.09782955f, 
    -0.03723286f, -0.09989710f, 0.04950358f, 0.01486288f, -0.10212281f, -0.07936081f, -0.10723383f, -0.02737877f, 
    0.05425945f, 0.01523293f, -0.05287493f, 0.02924371f, -0.04882707f, -0.08541201f, 0.09658845f, -0.07186435f, 
    0.00085418f, -0.15655790f, 0.03604230f, -0.05820762f, -0.09655584f, 0.06599776f, -0.11070636f, -0.06114331f, 
    0.05963373f, -0.05400285f, -0.03539488f, 0.03989112f, 0.04393436f, -0.02772341f, 0.05536106f, -0.03258793f, 
    -0.02772787f, -0.06135748f, -0.09722907f, -0.15143022f, 0.03626948f, -0.04255455f, 0.08920088f, -0.09413608f, 
    0.00498854f, 0.02821372f, -0.11298189f, 0.00029622f, 0.04419262f, 0.01330577f, 0.11720800f, -0.06048963f, 
    -0.14204656f, -0.08011131f, 0.07125217f, -0.06976816f, 0.01702274f, -0.12578180f, -0.01411852f, 0.03182385f, 
    0.04482889f, 0.04627789f, 0.03721298f, -0.00922979f, -0.08210796f, 0.09184605f, -0.07138913f, 0.09091127f, 
    -0.09230747f, -0.10789931f, -0.07869530f, 0.08510654f, -0.00973567f, 0.05988385f, 0.07168315f, 0.05527894f, 
    -0.02499403f, 0.12844507f, 0.07491401f, 0.30220738f, 0.10759931f, 0.19434237f, -0.15549414f, 0.07101478f, 
    -0.08861487f, 0.07291969f, 0.25277036f, 0.05828668f, -0.10197124f, -0.11834525f, -0.24060927f, 0.31440848f, 
    0.05094722f, 0.08795508f, -0.10823937f, -0.00816265f, -0.23159052f, 0.03206969f, -0.11804577f, 0.03436744f, 
    0.10551994f, 0.01956592f, 0.05548094f, -0.11793733f, 0.05543014f, 0.09350242f, -0.10146917f, 0.19778194f, 
    -0.14578277f, 0.09800177f, -0.02669912f, 0.11522291f, -0.04941436f, -0.07414190f, 0.06393404f, -0.09845459f, 
    -0.25828406f, 0.20218249f, 0.01427744f, 0.00250688f, 0.06190699f, -0.24568541f, 0.21234457f, -0.12640102f, 
    0.11145981f, -0.20045625f, -0.20665798f, -0.09676683f, -0.09822137f, -0.07551210f, 0.00279809f, 0.03152860f, 
    0.03412371f, -0.08912181f, 0.08997403f, 0.06741624f, -0.00194027f, 0.14873292f, 0.19080609f, 0.15280800f, 
    -0.32782465f, 0.26723686f, 0.01145812f, -0.20301086f, 0.03529687f, 0.07317595f, 0.02831627f, 0.04136845f, 
    -0.02890763f, -0.03876774f, 0.12298889f, 0.01306886f, -0.04140797f, -0.02983112f, 0.06725431f, -0.06847078f, 
    0.00287854f, 0.12385346f, 0.17657849f, 0.00306326f, -0.08003645f, 0.15312482f, -0.03249088f, -0.06544442f, 
    -0.03111233f, 0.39492720f, -0.07169591f, -0.12282677f, 0.23063149f, -0.11563790f, -0.07026470f, -0.09604964f, 
    0.04424584f, -0.08461539f, -0.09588732f, -0.00292301f, -0.01431812f, 0.10510481f, 0.09662862f, -0.05706104f, 
    -0.10588757f, 0.07529919f, -0.11027279f, -0.09212189f, 0.05141107f, -0.08965996f, 0.16430384f, -0.14217451f, 
    0.12718317f, -0.29150882f, 0.33821774f, 0.01542795f, -0.05095384f, -0.02607591f, -0.11093500f, 0.03722217f, 
    -0.06506585f, -0.02570465f, -0.09245968f, 0.07278525f, -0.01391266f, -0.06908169f, 0.19293530f, 0.11421397f, 
    0.25134057f, 0.11565556f, 0.06984141f, 0.03115065f, 0.00634006f, -0.02230951f, 0.48385423f, -0.09521750f, 
    -0.02044672f, -0.16773538f, -0.12721071f, -0.03222002f, 0.02558422f, -0.15288024f, 0.09130404f, 0.23949465f, 
    -0.04483265f, -0.32338753f, -0.10490719f, 0.08730447f, 0.32514310f, 0.11421125f, -0.03227811f, -0.03426759f, 
    -0.06710987f, -0.32191420f, 0.00393195f, 0.08475324f, -0.03408437f, 0.01214255f, -0.08631501f, 0.10379402f, 
    0.09323280f, 0.02455221f, 0.08744415f, -0.03232854f, 0.13398242f, 0.09350514f, 0.04988082f, 0.11725684f, 
    0.26614171f, 0.06241982f, 0.04388632f, -0.06994296f, 0.12662187f, -0.01322642f, 0.11644433f, 0.16438784f, 
    -0.05677050f, 0.35653082f, 0.17200536f, -0.05452957f, -0.11002837f, 0.06560680f, 0.01985121f, 0.11562410f, 
    0.39539036f, -0.17881526f, 0.06282498f, -0.09308762f, 0.18917316f, -0.02495827f, -0.08111831f, -0.05101640f, 
    0.05723785f, -0.15945116f, -0.01654525f, -0.09967285f, 0.09174506f, 0.08307431f, -0.36479291f, 0.12144433f, 
    -0.08508947f, -0.18607517f, -0.18532529f, 0.01149516f, 0.07670357f, 0.25541735f, -0.06740505f, -0.52861732f, 
    0.00746758f, 0.20272176f, -0.06657021f, -0.04402263f, 0.36885041f, -0.00399707f, -0.06924354f, 0.12413539f, 
    0.01136563f, 0.19254050f, 0.02224725f, 0.11228954f, 0.13236128f, 0.10226954f, 0.04387641f, 0.14502431f, 
    -0.04699442f, 0.09049672f, -0.01336941f, -0.01447599f, -0.03205058f, -0.02103145f, -0.05212220f, -0.00126926f, 
    0.14887285f, 0.00244764f, 0.11390571f, 0.17811215f, 0.00961610f, 0.22860464f, -0.10695432f, 0.23806162f, 
    0.11027241f, 0.22732975f, 0.01697142f, -0.03567868f, -0.04548114f, 0.10556422f, -0.05281782f, -0.10792112f, 
    0.05822525f, 0.05821760f, -0.05065126f, 0.08830968f, 0.16405906f, 0.01705196f, -0.02467595f, 0.09331107f, 
    0.04830901f, 0.30571187f, -0.01720451f, -0.19734307f, -0.04707304f, 0.08163542f, 0.21837817f, -0.10482707f, 
    0.00566955f, -0.14563382f, -0.07981291f, 0.08020813f, 0.11447816f, 0.12026971f, 0.51885068f, 0.54079753f, 
    -0.11045681f, 0.08695746f, -0.22167289f, 0.09643392f, 0.18762742f, 0.02562607f, -0.00532286f, -0.04007017f, 
    -0.03474674f, 0.20732093f, -0.10038996f, 0.03294631f, 0.02303407f, 0.02984197f, 0.07532996f, -0.04157399f, 
    0.09853956f, 0.03870208f, 0.01697777f, 0.05343163f, 0.07825977f, 0.03750886f, -0.07083768f, 0.02486832f, 
    -0.01401515f, 0.13747746f, 0.09678357f, -0.20949684f, -0.15570495f, -0.10272291f, 0.11368620f, -0.13466375f, 
    -0.06250093f, 0.16259930f, 0.04776518f, -0.20246898f, 0.03060950f, -0.07408383f, 0.09189225f, -0.08649626f, 
    0.30821693f, -0.11908177f, -0.00233119f, 0.07786416f, 0.10466660f, -0.05403113f, -0.09957041f, 0.18502794f, 
    -0.13354199f, 0.22322309f, 0.03594394f, -0.09332795f, 0.02261588f, 0.03579050f, 0.24793734f, -0.06558236f, 
    -0.02625148f, -0.08533358f, 0.11614612f, 0.09000685f, 0.10160225f, 0.03987068f, 0.50843143f, 0.60763711f, 
    -0.02883812f, 0.11862387f, -0.09704987f, -0.00192407f, -0.10348437f, -0.03183549f, 0.08408995f, -0.08611627f, 
    0.02001140f, 0.18987752f, -0.03925101f, -0.07138602f, 0.06087917f, 0.11247393f, 0.10330322f, 0.08693044f, 
    -0.01595131f, 0.00027469f, 0.05688265f, 0.10198340f, -0.11099143f, 0.09256948f, -0.05307792f, -0.04344736f, 
    -0.21950907f, 0.09747489f, -0.12748855f, -0.19068700f, -0.03023287f, -0.28392023f, 0.16699208f, -0.14526194f, 
    -0.04511317f, 0.09820082f, 0.15111969f, -0.03395692f, -0.12611185f, 0.08326485f, -0.04512127f, -0.04278019f, 
    0.14230500f, -0.11387984f, 0.09999207f, 0.03332202f, 0.16542122f, -0.09468475f, 0.12443057f, 0.13648738f, 
    0.07699782f, 0.03905316f, -0.04299277f, -0.11228195f, -0.02985282f, -0.11899146f, 0.03476088f, -0.01825276f, 
    -0.01823518f, -0.10501461f, -0.07003802f, 0.03709936f, 0.04410569f, -0.03628492f, -0.00837962f, 0.06701188f, 
    0.10123503f, -0.10658388f, 0.11712247f, -0.03177108f, 0.04202735f, -0.01419295f, 0.02131318f, -0.05996804f, 
    -0.01168732f, -0.03303663f, -0.01724575f, -0.09259158f, -0.10960928f, 0.00414225f, -0.08964926f, -0.09495382f, 
    -0.10102741f, 0.10280356f, -0.07505102f, 0.06388992f, 0.02254103f, -0.01214175f, -0.04680248f, 0.08146167f, 
    -0.05150811f, -0.09210706f, -0.12069011f, -0.05226283f, -0.05068584f, -0.11748974f, 0.11186942f, 0.01782395f, 
    0.06432292f, 0.11508192f, -0.06141596f, -0.01142070f, -0.01433201f, 0.02644423f, -0.00379790f, 0.09157735f, 
    -0.00175606f, 0.10902213f, 0.06367578f, 0.09848167f, -0.12292039f, -0.11003347f, -0.04987620f, 0.09277369f, 
    -0.03118060f, 0.28911018f, -0.09231404f, -0.27827936f, 0.10098995f, -0.07711384f, 0.01785360f, 0.10278112f, 
    -0.06058011f, 0.08534738f, 0.09150600f, 0.10964164f, 0.02527289f, -0.20323969f, 0.29488122f, -0.05577169f, 
    0.04265012f, 0.02053045f, 0.15746957f, 0.06216705f, -0.15382779f, 0.03819563f, 0.07345571f, -0.00902458f, 
    0.00292106f, -0.03009159f, 0.07235168f, -0.06855004f, 0.10558952f, -0.13362595f, -0.10827258f, 0.21605013f, 
    0.28721914f, 0.10994706f, 0.03969625f, 0.11708125f, 0.02973347f, 0.08369948f, -0.00958627f, 0.02295809f, 
    0.12300354f, 0.06112545f, -0.07315987f, -0.10649115f, -0.04963708f, 0.35634336f, -0.09015675f, 0.18339160f, 
    0.08245739f, -0.35714504f, 0.27076039f, 0.16498703f, -0.03449409f, -0.04874844f, 0.06006873f, 0.09428977f, 
    -0.17963420f, -0.00083021f, 0.08698675f, 0.11384749f, 0.11230443f, -0.11284846f, 0.10127319f, 0.06531816f, 
    0.07999372f, 0.05045939f, -0.02567695f, -0.15799828f, -0.10935447f, -0.17215358f, 0.06759590f, 0.04955227f, 
    0.05471896f, 0.27185389f, 0.01848696f, 0.09642534f, 0.10077325f, 0.11850263f, -0.07080887f, -0.41735733f, 
    -0.02110334f, -0.10913787f, 0.25591320f, -0.02508570f, 0.13013548f, 0.02277567f, 0.10702006f, 0.07577326f, 
    0.10807786f, -0.30034056f, 0.05380204f, -0.02676049f, 0.00520706f, 0.14457618f, -0.00063223f, 0.11888999f, 
    0.16444725f, -0.12009284f, 0.04343192f, 0.03281325f, -0.02005509f, 0.00957699f, 0.00742152f, -0.06329936f, 
    0.27555078f, 0.05575548f, -0.09407511f, -0.03208937f, -0.07781661f, 0.09711727f, -0.04823700f, 0.12148922f, 
    -0.03116664f, -0.04663929f, 0.03003331f, 0.33810401f, 0.04120941f, -0.03525365f, 0.08900055f, 0.10983159f, 
    0.25498578f, -0.06358964f, 0.09464735f, -0.02690102f, 0.14486864f, 0.27312616f, -0.06041785f, -0.12748635f, 
    0.13428454f, -0.20143583f, -0.11526175f, 0.47034577f, 0.06803734f, -0.08127423f, 0.36797786f, 0.05086809f, 
    -0.01961719f, -0.01809341f, 0.13597935f, 0.08516003f, 0.09007659f, -0.11028521f, -0.08238930f, 0.28397179f, 
    0.06783220f, -0.15370964f, 0.10231870f, 0.00238889f, -0.17971633f, 0.12799667f, -0.09598943f, -0.07765482f, 
    0.00723014f, -0.48179251f, -0.01368114f, 0.19982325f, 0.00189932f, 0.25486067f, 0.06818947f, 0.04303439f, 
    -0.01866240f, 0.07703861f, -0.05724049f, -0.08379266f, 0.00457147f, -0.04313956f, -0.12035568f, 0.00489860f, 
    -0.12469892f, 0.18046460f, 0.12924890f, 0.15229212f, 0.07647301f, 0.00265850f, -0.01737030f, 0.12342169f, 
    -0.07376994f, 0.00575474f, -0.06318273f, -0.20192303f, -0.08295362f, -0.02004099f, 0.08224808f, -0.10871668f, 
    0.16113319f, -0.18938637f, 0.05572794f, -0.11720423f, 0.10709131f, 0.11501174f, -0.14994384f, 0.04891387f, 
    0.14777307f, 0.16571210f, 0.06424455f, 0.04989760f, 0.08569933f, 0.18752058f, -0.14314927f, 0.09081833f, 
    0.06274386f, 0.10763839f, 0.30715832f, -0.02108868f, 0.06976397f, -0.22472449f, 0.15405868f, 0.27573201f, 
    0.08224336f, -0.11111147f, -0.00753353f, 0.01879431f, 0.03630337f, -0.11494251f, -0.00429678f, 0.11023287f, 
    0.08816150f, 0.18860342f, -0.00976016f, -0.18264015f, 0.01827537f, 0.03656962f, 0.12574060f, -0.10871542f, 
    -0.26645476f, -0.11852901f, -0.00819790f, -0.10442670f, 0.04648728f, -0.02312347f, -0.01012813f, 0.10549203f, 
    -0.25994259f, 0.05063124f, 0.00324104f, 0.15316564f, 0.31393805f, -0.27052256f, 0.08048556f, -0.21277310f, 
    0.00643045f, -0.07844919f, -0.02871810f, 0.09866948f, 0.08134747f, -0.07994369f, 0.01833424f, -0.11335439f, 
    -0.05581542f, -0.11701456f, 0.01123426f, -0.04950402f, 0.02957327f, 0.09613595f, 0.01925125f, 0.30915958f, 
    -0.38643372f, 0.32302889f, 0.09515285f, -0.08668718f, 0.08078340f, 0.10705958f, -0.31632578f, 0.05151516f, 
    -0.04833432f, 0.06085877f, 0.13920507f, -0.04410271f, 0.07247838f, 0.08788242f, 0.38818851f, 0.27841845f, 
    0.00664061f, -0.05096633f, 0.05064280f, 0.03962373f, -0.45048457f, -0.00574419f, 0.03653326f, 0.02759167f, 
    -0.00591450f, 0.50261468f, -0.03357429f, 0.05942048f, 0.17165707f, -0.20917872f, -0.09160355f, 0.10900280f, 
    0.06328856f, -0.07184938f, -0.12802391f, -0.10891629f, -0.06367518f, -0.09959721f, 0.09137169f, 0.11005962f, 
    -0.21688332f, -0.08020837f, 0.04072344f, 0.09211452f, 0.05874357f, 0.03502333f, -0.05294482f, 0.25262314f, 
    0.00444865f, -0.41821241f, 0.16499902f, -0.21532692f, 0.01653863f, -0.02655176f, -0.08399147f, 0.03386666f, 
    -0.37667891f, 0.18073423f, -0.06825189f, 0.03901873f, 0.19136555f, -0.28812248f, 0.14969003f, -0.08814681f, 
    0.00166190f, 0.00048467f, -0.05555607f, 0.25528470f, 0.04301712f, 0.29677507f, -0.17372578f, 0.05258961f, 
    -0.03010510f, -0.23164195f, 0.02520092f, 0.07642595f, 0.00609592f, 0.22230737f, -0.06093940f, 0.25777820f, 
    -0.03886351f, 0.25159857f, 0.31740707f, -0.00146212f, 0.13847171f, 0.03326281f, 0.04806996f, 0.04816672f, 
    0.02295071f, 0.40737247f, -0.08883841f, 0.19433166f, 0.21013644f, 0.02672418f, -0.08135229f, -0.14424948f, 
    -0.10148897f, 0.11365204f, 0.12523560f, -0.11285646f, 0.01685047f, -0.10857647f, -0.07838324f, 0.06989826f, 
    0.02680644f, 0.02959459f, -0.02566297f, 0.24070458f, -0.13956405f, -0.18855165f, 0.10180883f, -0.20717557f, 
    0.08157626f, -0.13177621f, 0.05497806f, 0.14658588f, -0.09745096f, -0.07229647f, -0.02677602f, -0.06727799f, 
    -0.21643236f, 0.25456870f, 0.05227093f, 0.01211945f, -0.10902370f, -0.02872401f, 0.28544155f, 0.21822457f, 
    0.13223147f, -0.06346679f, 0.00799204f, 0.20482156f, 0.06594775f, 0.11415924f, -0.24685627f, 0.09851578f, 
    -0.06395052f, 0.23593362f, 0.04242631f, -0.08794227f, -0.04868346f, 0.00526904f, 0.19308698f, 0.20805417f, 
    0.06396002f, -0.12904727f, 0.10624074f, -0.03697772f, -0.17932220f, -0.18558757f, -0.07406132f, -0.05449063f, 
    -0.12040435f, -0.31170690f, -0.05010572f, 0.20881295f, -0.16130589f, 0.34169564f, 0.00448287f, 0.03594287f, 
    -0.07242693f, 0.11591196f, -0.10522171f, -0.01932580f, 0.10257974f, -0.06926863f, 0.06789315f, -0.12415696f, 
    -0.13302165f, 0.19091246f, -0.05151343f, 0.14645226f, -0.00494431f, 0.00055649f, -0.04583837f, 0.31272030f, 
    0.05830962f, 0.18042879f, -0.34010652f, -0.14316297f, -0.11402421f, 0.00866319f, -0.09438841f, -0.05292551f, 
    -0.14371017f, 0.13783799f, 0.09038156f, -0.01173203f, 0.13681108f, -0.18626590f, -0.04727736f, 0.20521162f, 
    0.05452400f, -0.06024579f, 0.09297654f, -0.07149792f, 0.06591886f, 0.04646132f, -0.10063956f, -0.02252386f, 
    0.11280788f, 0.09283452f, -0.07325283f, -0.04291568f, 0.04197940f, 0.03128811f, 0.06408992f, -0.09187128f, 
    0.05965791f, -0.09851040f, -0.03439782f, -0.06342467f, -0.06184587f, -0.07248648f, 0.10765094f, -0.10299589f, 
    0.06083630f, -0.06860996f, 0.01391307f, -0.01083322f, -0.06700242f, -0.00102898f, 0.08784898f, 0.00012867f, 
    0.00591581f, 0.02343133f, 0.01059057f, 0.10611089f, -0.02048231f, -0.08363824f, 0.11750291f, 0.10785685f, 
    -0.06335125f, -0.05627457f, 0.03607582f, 0.06458443f, 0.06116003f, -0.12865025f, -0.10964859f, -0.00239934f, 
    0.01860715f, -0.03150431f, -0.11930592f, 0.08800063f, -0.05111000f, -0.04475176f, 0.10474382f, 0.11180267f, 
    -0.01982520f, -0.13676029f, -0.12530473f, -0.09469726f, 0.04174370f, 0.01331253f, -0.02489200f, -0.03764763f, 
    -0.00667673f, -0.24243557f, -0.05941324f, 0.06264552f, -0.00087430f, 0.04103903f, -0.18556692f, -0.01980279f, 
    -0.06690393f, 0.09841144f, -0.18560956f, 0.10894667f, 0.12148044f, 0.24973500f, -0.35228541f, -0.55443299f, 
    -0.09215705f, 0.15654393f, 0.22162306f, -0.03154929f, 0.40795949f, 0.19439803f, 0.12366953f, 0.04833123f, 
    -0.03332576f, 0.24842449f, -0.04551209f, 0.19702223f, 0.08956818f, 0.05535444f, -0.10601680f, -0.00281450f, 
    0.00778916f, 0.09585478f, -0.10836314f, 0.09323182f, 0.04817911f, -0.04805931f, -0.05590600f, -0.07302941f, 
    0.25620449f, -0.11507042f, -0.06959073f, 0.15882018f, -0.04255524f, 0.23759989f, -0.01886080f, -0.06506759f, 
    -0.08656169f, -0.00075332f, 0.07466681f, 0.19773893f, 0.05440008f, -0.05455616f, 0.12651624f, 0.01119548f, 
    -0.13391478f, 0.15490401f, -0.06779363f, -0.02675251f, -0.09922220f, 0.15925148f, 0.12294552f, -0.05384009f, 
    0.21723683f, -0.09788249f, -0.11092808f, 0.16506152f, -0.10561375f, 0.06378799f, 0.32759404f, -0.08583089f, 
    -0.04044001f, -0.20417078f, 0.21069925f, -0.06570930f, -0.02609452f, -0.11487395f, -0.26608130f, 0.19148681f, 
    -0.04489332f, -0.32142314f, 0.28842160f, -0.05157087f, -0.29479715f, -0.17222244f, 0.06126786f, -0.05731848f, 
    -0.10236096f, -0.18050730f, 0.12230908f, 0.23938474f, 0.15896395f, 0.07565371f, 0.10296727f, 0.13317654f, 
    0.17140636f, -0.04767933f, -0.12076686f, 0.00194996f, 0.10405410f, -0.07499348f, 0.07992999f, 0.10820486f, 
    -0.13998191f, 0.20093858f, -0.06167243f, -0.28083801f, 0.24172610f, 0.11589473f, 0.08721074f, -0.00770082f, 
    0.02581833f, -0.08032975f, 0.13938271f, 0.17830293f, 0.07684790f, 0.11692309f, 0.09079354f, 0.11583707f, 
    0.29149812f, -0.00302433f, 0.06850167f, 0.10303020f, 0.12876913f, 0.04549897f, -0.02329837f, -0.17526057f, 
    -0.27237290f, 0.23110288f, 0.09966674f, -0.07582853f, -0.00526222f, 0.13876659f, -0.27171639f, -0.02294383f, 
    -0.06600205f, 0.23293461f, 0.34412879f, -0.00906717f, -0.03586685f, -0.28007594f, -0.12126518f, -0.16138367f, 
    -0.08038604f, -0.11742457f, -0.01684011f, -0.00206083f, -0.45494723f, 0.27421179f, -0.01041729f, -0.06935535f, 
    -0.10309655f, 0.25543532f, 0.07340742f, -0.17285702f, 0.20088843f, -0.07842988f, 0.11782817f, 0.12731981f, 
    -0.11844005f, -0.04283991f, 0.07314140f, 0.07059838f, 0.09085926f, -0.07370609f, -0.06832478f, -0.00439239f, 
    -0.14846081f, -0.02049479f, 0.08215342f, 0.09266854f, 0.31097922f, 0.28169271f, 0.10706245f, 0.01140666f, 
    -0.03399001f, -0.58614850f, 0.08760776f, 0.05715593f, -0.06887796f, -0.10071187f, 0.07018100f, -0.07265787f, 
    -0.23117095f, 0.21403734f, 0.11454035f, -0.05908925f, -0.03407325f, 0.16285893f, 0.02163958f, 0.12624148f, 
    -0.04347139f, -0.02633140f, 0.06160645f, -0.02058249f, -0.01030248f, -0.04495068f, -0.14566892f, 0.11439440f, 
    -0.12165610f, 0.21051426f, 0.00242081f, 0.04938950f, -0.05848674f, 0.01039853f, 0.09005568f, -0.45325705f, 
    0.06079452f, 0.27731547f, -0.11699006f, 0.10892475f, 0.61215836f, 0.00577087f, 0.10218079f, -0.07379787f, 
    -0.01637436f, -0.08810817f, 0.11861444f, -0.03114682f, -0.11571075f, 0.03065154f, -0.01511760f, 0.19783451f, 
    -0.04123035f, -0.11302842f, 0.08381592f, 0.07470074f, -0.01657525f, 0.12399593f, 0.07745841f, 0.01675226f, 
    -0.05727441f, 0.10151193f, -0.03815389f, 0.04411125f, 0.18549131f, -0.07228232f, -0.03223874f, 0.02072013f, 
    -0.08858940f, 0.02202571f, 0.01799985f, -0.17092614f, 0.05200708f, 0.10968849f, -0.11635798f, -0.04205260f, 
    0.28231668f, -0.34039643f, 0.10874142f, -0.06006940f, 0.11561508f, 0.16853359f, -0.05506693f, 0.02433470f, 
    0.09579387f, 0.13587627f, -0.04747296f, 0.28942060f, -0.11518249f, 0.01532352f, 0.09097127f, -0.06558140f, 
    -0.10072358f, 0.04958398f, -0.01988492f, -0.06584551f, 0.04339138f, 0.07949658f, -0.27950558f, 0.02878111f, 
    -0.09996513f, -0.14289278f, 0.36999711f, -0.00834555f, -0.31109172f, 0.19024204f, -0.10381693f, -0.08196896f, 
    -0.04840756f, 0.05953614f, 0.04559508f, 0.16048469f, 0.32155907f, 0.17854512f, -0.04677403f, 0.12625906f, 
    -0.05830194f, 0.04483990f, 0.05292562f, 0.00182274f, -0.05294186f, -0.02696396f, 0.08987497f, 0.08845657f, 
    0.03702942f, 0.04994592f, -0.11398415f, 0.32190666f, -0.42657629f, 0.28374499f, -0.13457674f, 0.09676053f, 
    -0.05150014f, -0.52377284f, -0.10902020f, 0.04078107f, -0.08371054f, -0.00387229f, -0.05196803f, 0.01296766f, 
    -0.38899973f, 0.37089750f, 0.00062497f, -0.07905276f, -0.03450205f, -0.06256811f, 0.20220575f, -0.08817319f, 
    -0.03866740f, -0.10048826f, 0.03064687f, -0.07745953f, 0.01702608f, 0.02361436f, -0.00857398f, 0.05793840f, 
    -0.10784874f, -0.06240220f, -0.01026089f, -0.05419338f, -0.05821311f, 0.00104858f, -0.11402195f, 0.08500315f, 
    -0.00524950f, 0.06089482f, -0.10318239f, -0.02397734f, 0.08897670f, 0.05011932f, 0.01084419f, 0.06825787f, 
    0.06542797f, -0.07309768f, -0.06185859f, -0.04200561f, -0.01219140f, -0.02874514f, -0.04213044f, -0.00490261f, 
    0.05440231f, -0.00731687f, -0.02837923f, 0.00416842f, -0.05153111f, -0.01537746f, -0.11628398f, 0.06429713f, 
    -0.03818142f, -0.12323324f, -0.09544851f, -0.03645948f, 0.08535511f, -0.08250076f, -0.06867910f, 0.03761038f, 
    -0.08896837f, -0.09758068f, 0.01065357f, -0.07030110f, 0.01199955f, 0.01269139f, -0.07071174f, -0.06995167f, 
    -0.12079583f, 0.01881906f, -0.03530169f, 0.09336908f, 0.05349376f, 0.07488146f, -0.12333044f, -0.05753465f, 
    -0.26753041f, -0.21666501f, 0.07714090f, 0.21222492f, 0.00043026f, 0.10851036f, -0.04343044f, 0.04469877f, 
    0.06174308f, -0.23338152f, -0.01730420f, -0.11174581f, 0.04591816f, 0.28088132f, -0.07647778f, 0.14012866f, 
    -0.02023807f, 0.17920884f, 0.27894297f, 0.02857040f, -0.08058764f, 0.00864673f, 0.10686723f, -0.01261220f, 
    -0.12238565f, 0.30879325f, 0.04943665f, 0.30171245f, 0.15079917f, -0.18556730f, -0.06798723f, -0.03871696f, 
    0.33661973f, 0.06048774f, -0.01655449f, -0.05008430f, 0.02562368f, 0.03733429f, 0.08153655f, -0.01693219f, 
    0.07566195f, -0.07001442f, 0.00950619f, 0.03502392f, -0.49830225f, 0.33540288f, 0.02088341f, 0.02513650f, 
    -0.01492338f, 0.06491316f, 0.29778996f, -0.10608090f, 0.00806915f, -0.06131944f, 0.10820764f, -0.09579922f, 
    -0.27661553f, 0.16619639f, 0.06598107f, -0.10423618f, 0.16840447f, -0.20150688f, 0.00352636f, -0.26091757f, 
    0.13860369f, 0.04769911f, 0.06709898f, -0.05963505f, -0.00768809f, -0.01053024f, -0.11731343f, -0.10249604f, 
    -0.05490610f, 0.04273850f, 0.04865928f, -0.03930023f, -0.12848447f, -0.16606064f, 0.06093257f, -0.07557871f, 
    0.06498863f, -0.18884853f, 0.19035776f, -0.00615899f, 0.27435860f, -0.11996923f, 0.06620619f, 0.03907647f, 
    -0.05944942f, -0.09807780f, 0.00896047f, 0.04118610f, 0.19938517f, 0.33359614f, 0.02767321f, 0.20242327f, 
    -0.19732255f, 0.07944287f, -0.01918419f, 0.05143529f, 0.06596512f, -0.05109954f, 0.07943545f, 0.09359998f, 
    -0.22180094f, -0.07449552f, 0.12562500f, 0.14136384f, 0.24938485f, 0.14799275f, -0.16236012f, 0.27146280f, 
    -0.11043310f, -0.42547342f, -0.01487088f, 0.10162780f, 0.05698851f, 0.09833120f, -0.05695774f, -0.00591138f, 
    0.12634617f, -0.08833978f, 0.05281658f, 0.03173706f, -0.08653854f, 0.06653678f, 0.06098104f, 0.12223553f, 
    0.11054741f, -0.06272476f, -0.04608522f, -0.40340224f, 0.02390510f, 0.07691222f, -0.22160909f, -0.07335670f, 
    -0.05153586f, 0.05467911f, -0.07537588f, 0.00667499f, 0.03802777f, -0.08627555f, 0.02288195f, -0.29742286f, 
    0.06567200f, -0.01034910f, 0.04962360f, 0.06141283f, 0.17421915f, -0.23418200f, 0.03690330f, 0.01973945f, 
    0.04699027f, 0.32071406f, 0.02385482f, -0.02856147f, 0.16798170f, -0.00100038f, 0.02295265f, 0.16686283f, 
    -0.03755218f, 0.00513440f, -0.02742517f, -0.12332230f, -0.06914058f, 0.11268227f, -0.03565156f, 0.05439338f, 
    0.06138126f, -0.07440373f, 0.05745423f, 0.14653236f, 0.29520115f, 0.03012636f, 0.06705497f, 0.29767713f, 
    -0.02518356f, 0.04463534f, 0.22960907f, 0.10442130f, 0.00051838f, -0.03505486f, -0.05282290f, -0.09245171f, 
    0.10290541f, -0.11065765f, 0.03326908f, -0.01286792f, 0.03747221f, -0.09530278f, 0.12029462f, 0.17327897f, 
    -0.11832339f, 0.02363680f, -0.03511815f, -0.01792342f, -0.00575138f, -0.11334369f, -0.02771148f, -0.10270879f, 
    0.03480132f, -0.14323126f, 0.01658712f, -0.12904230f, -0.11823095f, -0.02138624f, 0.03674873f, -0.09978101f, 
    -0.08830677f, -0.13158543f, -0.03037894f, -0.09914983f, 0.21785332f, -0.13255116f, 0.09098364f, 0.04966221f, 
    0.03311280f, -0.13510366f, 0.08093022f, 0.05187195f, 0.06482703f, -0.01439177f, 0.02515802f, -0.03688779f, 
    -0.03284090f, -0.10117263f, -0.04402573f, -0.11801638f, -0.09544014f, 0.07497834f, -0.02901220f, 0.11252116f, 
    -0.02727376f, -0.11764717f, 0.03392767f, 0.05255829f, -0.04518230f, -0.12525766f, -0.12303246f, 0.04688274f, 
    0.00114077f, -0.07866950f, -0.07735912f, 0.06623325f, 0.10884800f, 0.02109294f, -0.05946947f, 0.11583142f, 
    0.06284823f, -0.02305925f, 0.04231754f, 0.06100225f, 0.07236958f, 0.01127578f, -0.06451115f, -0.00928836f, 
    -0.35032231f, 0.07354259f, 0.02965563f, 0.21896146f, 0.10795645f, -0.17703159f, 0.22241777f, 0.04725334f, 
    0.06466515f, 0.18270551f, 0.22749083f, -0.08138979f, 0.07344656f, -0.16474523f, 0.18600091f, 0.47200805f, 
    0.01637584f, -0.01681400f, -0.11940080f, -0.05581919f, -0.26330334f, 0.34355295f, -0.09284016f, -0.07239287f, 
    -0.08122533f, 0.05204906f, 0.01467259f, 0.02707019f, -0.05790893f, -0.18365024f, -0.02063238f, 0.07509776f, 
    0.19558568f, 0.03492200f, -0.06415156f, -0.08689792f, 0.03657073f, -0.01078347f, -0.08132728f, 0.01134706f, 
    0.22475888f, -0.01014581f, -0.09920841f, 0.02732508f, -0.06323388f, 0.21278073f, 0.16411871f, 0.03150014f, 
    0.11738029f, -0.23959559f, 0.16761135f, 0.07066987f, 0.08327629f, -0.05901953f, -0.05361951f, -0.03185675f, 
    -0.25690198f, 0.25555965f, 0.06970211f, 0.04757340f, 0.07583719f, 0.16233078f, -0.02274685f, -0.08149417f, 
    -0.04998162f, -0.07711254f, -0.04915553f, -0.00137410f, 0.06164268f, 0.03385856f, -0.04526717f, 0.09430602f, 
    -0.10601487f, -0.02368705f, -0.09658535f, 0.05308716f, 0.11209637f, -0.14760429f, -0.08136319f, -0.12645631f, 
    0.11448261f, 0.03377439f, 0.03444963f, -0.04038426f, 0.10749093f, -0.07220169f, -0.05233094f, -0.10655771f, 
    -0.02434989f, -0.13211045f, -0.12391347f, -0.01593352f, -0.14741488f, -0.12537350f, 0.04223651f, 0.02313646f, 
    0.02257951f, 0.02641748f, -0.03587274f, 0.02110982f, -0.06399997f, -0.04204370f, 0.00170532f, 0.08497802f, 
    -0.12019600f, -0.11512621f, 0.04183995f, 0.05355001f, -0.01599662f, -0.13587269f, -0.05574936f, 0.05823082f, 
    0.05478194f, 0.05380857f, -0.00141275f, -0.11058023f, -0.08014870f, 0.03420863f, 0.09345571f, -0.08039483f, 
    -0.09072268f, 0.05871059f, -0.12924118f, 0.10059428f, 0.02758699f, -0.14323321f, 0.07180244f, 0.00664718f, 
    0.27899888f, -0.29983073f, 0.04982973f, 0.27084410f, 0.08965708f, -0.03925834f, 0.16170859f, 0.01574637f, 
    -0.04632406f, 0.00338165f, -0.16781847f, 0.01223687f, -0.02918397f, 0.01937064f, -0.02643144f, 0.03817819f, 
    0.00294851f, -0.12472215f, 0.16013546f, -0.06758743f, -0.03926537f, 0.20313331f, 0.04917420f, 0.06365953f, 
    0.04953844f, -0.26629719f, -0.09820189f, 0.16122796f, -0.07999483f, -0.12549388f, 0.06237355f, -0.24091707f, 
    0.07716185f, -0.10224145f, 0.11889324f, -0.02794175f, -0.07042366f, -0.03253689f, -0.01657261f, 0.05515477f, 
    0.22075063f, -0.03641012f, 0.10284376f, 0.04660783f, -0.20343228f, -0.10167473f, -0.09734464f, -0.04103568f, 
    -0.02050719f, 0.59019870f, 0.07657375f, 0.27303860f, 0.11098219f, 0.00401574f, -0.04811702f, 0.10799997f, 
    -0.06440401f, 0.23047233f, -0.05742879f, 0.05549327f, 0.01009749f, 0.21648525f, 0.12418441f, 0.08843146f, 
    0.28794858f, -0.07899186f, 0.07782357f, 0.09046061f, -0.04817198f, 0.19560687f, -0.32942757f, 0.04495898f, 
    0.11629469f, 0.28176317f, 0.20643556f, 0.07797191f, -0.02370307f, -0.03651294f, 0.05666059f, -0.10072198f, 
    0.03925817f, -0.04787183f, 0.11058767f, -0.12160508f, -0.08652690f, -0.26460603f, -0.13286303f, -0.11334189f, 
    -0.01367620f, -0.24339437f, 0.10814454f, 0.05489333f, -0.07539780f, 0.24147078f, -0.04618897f, 0.05820602f, 
    -0.28228530f, -0.01158094f, 0.01475841f, -0.06368064f, -0.08620491f, -0.02125484f, -0.09674288f, -0.12457872f, 
    -0.24376981f, 0.23500623f, 0.08938023f, -0.00335340f, 0.25669804f, -0.12543386f, -0.04762835f, -0.09452256f, 
    -0.09267192f, 0.04846631f, -0.29172471f, 0.09154686f, -0.10927887f, -0.09544234f, -0.01562228f, 0.08131769f, 
    0.05129655f, -0.10662236f, -0.05564380f, -0.02973922f, -0.04899619f, -0.02904147f, 0.13169503f, 0.01973228f, 
    -0.21315353f, 0.04679593f, -0.02573130f, 0.21337511f, -0.11400853f, -0.09470779f, 0.04937379f, 0.03354166f, 
    0.10290903f, 0.04037295f, -0.00015943f, 0.08775694f, -0.05017684f, 0.22542924f, 0.17327417f, 0.22508831f, 
    -0.05574596f, 0.36594650f, -0.01339456f, -0.06466304f, 0.11453370f, 0.29128268f, 0.08098973f, -0.10248872f, 
    0.03615458f, 0.06710732f, -0.04704379f, 0.11749101f, -0.12189547f, -0.20755631f, 0.05986830f, -0.17936195f, 
    -0.09114479f, -0.06879139f, -0.10545968f, -0.01258901f, -0.05485643f, 0.02617930f, 0.00288153f, 0.07667636f, 
    0.25648290f, 0.11593223f, -0.08279632f, -0.02633478f, -0.23430005f, -0.14228344f, 0.17506227f, -0.28032425f, 
    0.06496639f, 0.45891094f, 0.04528721f, 0.12464897f, -0.10951926f, 0.00410787f, 0.01672206f, 0.08884386f, 
    0.05330506f, -0.03282047f, -0.01893242f, -0.02783260f, -0.09014253f, 0.21519710f, -0.09927121f, 0.09996109f, 
    0.19387268f, 0.16688865f, 0.11660633f, -0.06233798f, 0.12751906f, 0.23240495f, -0.17476150f, 0.09963217f, 
    0.06902980f, -0.05074534f, 0.15365322f, 0.04107121f, -0.11340703f, -0.09964218f, -0.08090167f, 0.26448897f, 
    -0.06713615f, -0.01312526f, -0.03201218f, 0.03929262f, 0.17219225f, -0.12435079f, 0.09000120f, 0.11287073f, 
    -0.10633479f, 0.08438393f, 0.02800415f, 0.00135577f, -0.12390760f, 0.13998985f, -0.02715055f, 0.06741795f, 
    -0.12010534f, 0.09445786f, -0.03154838f, 0.03542772f, -0.11331152f, 0.05586659f, -0.00318370f, 0.10515003f, 
    -0.00499104f, 0.12882039f, 0.01720648f, 0.23704229f, 0.09265251f, -0.25276282f, 0.16577098f, 0.19151793f, 
    -0.00355041f, 0.14798971f, -0.12885135f, 0.01837729f, -0.07536288f, -0.03989033f, 0.05011933f, -0.02356918f, 
    -0.18754129f, 0.32942459f, 0.06226820f, 0.05902971f, -0.04454151f, -0.11769129f, 0.26377755f, 0.35671702f, 
    -0.07288703f, -0.02639896f, -0.01614480f, -0.01647133f, -0.02118720f, 0.02018388f, -0.11219030f, 0.01781601f, 
    -0.02247248f, -0.08706503f, -0.08629657f, 0.08284169f, 0.06921214f, 0.09063527f, 0.07608818f, 0.04830503f, 
    0.05532070f, 0.04698844f, 0.03802164f, -0.00611781f, -0.05180035f, -0.13103950f, -0.12289201f, 0.02831429f, 
    0.08537998f, -0.08850139f, -0.03130986f, -0.12075049f, -0.04852657f, 0.00065896f, -0.01410516f, 0.09226919f, 
    0.06939751f, 0.10077165f, 0.10175241f, -0.00982913f, -0.01060088f, 0.08135992f, -0.03469022f, 0.11068995f, 
    -0.02744761f, -0.01855520f, -0.06349915f, -0.02290753f, 0.08401889f, 0.09748811f, -0.06993099f, -0.07226900f, 
    0.03044565f, 0.05707194f, -0.01858048f, 0.06855757f, -0.12389614f, -0.04988633f, 0.08200704f, 0.08012968f, 
    -0.09865007f, 0.00387605f, -0.04914197f, 0.10840073f, 0.05059737f, 0.07860858f, -0.08735849f, -0.11494301f, 
    0.24463157f, 0.04797637f, -0.07287506f, 0.10522279f, -0.07671072f, 0.09747147f, 0.31959635f, 0.10651039f, 
    -0.10549408f, -0.03268492f, -0.08091385f, -0.11548869f, 0.01636051f, 0.03050048f, -0.07538919f, -0.01578001f, 
    0.02238810f, -0.23970725f, 0.24747646f, 0.00739244f, -0.45079890f, -0.05003364f, 0.02262124f, 0.10323188f, 
    -0.11854239f, -0.21566145f, -0.00318386f, 0.15833586f, 0.20906080f, 0.07824110f, -0.10797790f, 0.05029477f, 
    0.22742626f, -0.11463794f, -0.07668005f, 0.04554380f, 0.05229254f, -0.02312079f, 0.01831525f, -0.08974472f, 
    0.06308226f, 0.00137575f, 0.06141026f, -0.01873794f, -0.31977794f, 0.25431493f, -0.15695959f, 0.10787869f, 
    -0.01097912f, -0.24551906f, -0.04366906f, 0.15519139f, -0.09758560f, 0.11958818f, -0.03541026f, -0.07042648f, 
    -0.32154125f, 0.11771224f, -0.08126436f, -0.11098692f, -0.00671661f, -0.00719320f, 0.09499463f, 0.05902242f, 
    -0.00505977f, 0.25122240f, 0.12745498f, -0.26108694f, 0.10850000f, -0.10392816f, 0.21816494f, -0.02140504f, 
    -0.05132376f, -0.13413623f, -0.14356670f, -0.02091204f, 0.07544479f, 0.15319920f, 0.04528569f, -0.22022869f, 
    0.06933904f, 0.08338015f, -0.14657797f, -0.08227129f, 0.41152915f, 0.04597368f, 0.05855821f, -0.09162599f, 
    -0.05531706f, -0.01224796f, 0.04570106f, -0.16159715f, 0.00071303f, 0.05359206f, 0.06968997f, 0.01520710f, 
    0.15527938f, -0.10593714f, 0.05322237f, -0.07847361f, 0.00345368f, -0.10498951f, -0.06845002f, 0.10748155f, 
    0.24053822f, 0.12227390f, 0.02357877f, -0.31258091f, 0.01431241f, 0.08077170f, 0.19351037f, 0.03058256f, 
    -0.03521366f, -0.06764349f, 0.07553041f, 0.19728492f, -0.03021300f, -0.06683435f, 0.11147380f, 0.04561761f, 
    0.28059632f, 0.11844238f, -0.12297420f, 0.03156158f, -0.04815800f, 0.06486303f, 0.10416590f, -0.09351953f, 
    -0.05822020f, -0.09657705f, 0.10263154f, 0.02416958f, 0.08305885f, 0.09186365f, -0.04402370f, -0.11486917f, 
    -0.12736471f, -0.08664293f, -0.07478420f, -0.06282056f, 0.00511511f, 0.07103745f, -0.04152550f, -0.06335618f, 
    0.01399255f, -0.11399349f, 0.00786557f, -0.02541636f, 0.12659746f, 0.09545266f, 0.04910984f, -0.01691351f, 
    -0.02250462f, -0.01309599f, -0.09654605f, -0.05301624f, -0.00782946f, 0.02971968f, -0.00170271f, -0.08562999f, 
    -0.04489538f, -0.00110602f, 0.05520397f, -0.06639070f, 0.11725078f, 0.07323948f, -0.03927740f, 0.02304677f, 
    -0.10009000f, -0.09542041f, 0.02386661f, 0.04376241f, -0.09655390f, -0.09577375f, 0.06574534f, -0.08210248f, 
    0.11052416f, -0.00222899f, 0.09231621f, -0.03700710f, 0.04148164f, 0.06034270f, -0.01786240f, 0.10142921f, 
    0.05658915f, 0.03729168f, -0.12404004f, -0.02716046f, -0.03311257f, -0.03606967f, 0.00438252f, 0.02983384f, 
    0.03964068f, -0.11437931f, -0.03137970f, -0.04380526f, -0.08265214f, -0.12984005f, -0.05925585f, -0.03165285f, 
    -0.07793833f, -0.09746270f, -0.04288283f, 0.06750964f, 0.09300718f, -0.07844090f, -0.07701741f, -0.05332184f, 
    0.01102555f, 0.01899822f, -0.06453158f, 0.02902386f, 0.10714204f, 0.09400656f, -0.01389788f, -0.01678637f, 
    -0.02037789f, 0.09856731f, 0.11778899f, 0.04339658f, -0.05970375f, -0.05701836f, 0.10213885f, -0.11396078f, 
    0.05421696f, -0.11469613f, -0.06543079f, 0.05167146f, -0.00580314f, -0.00829017f, -0.08693664f, 0.00413583f, 
    0.01156181f, -0.13172461f, -0.07177804f, -0.02456482f, -0.13490158f, 0.06316756f, -0.03335652f, 0.01826527f, 
    0.00719261f, 0.10886751f, -0.07244122f, 0.07702357f, -0.08201739f, -0.05839899f, 0.03484663f, -0.09925599f, 
    -0.12945570f, -0.12343754f, -0.03336489f, 0.07225531f, 0.03946127f, -0.01590809f, -0.13958441f, -0.07351945f, 
    0.25986201f, -0.17799532f, 0.12286403f, -0.18098234f, 0.09304486f, 0.12468811f, -0.14389439f, -0.04890978f, 
    -0.00310726f, -0.02683574f, -0.13394018f, -0.07977552f, -0.05496353f, 0.21628718f, 0.07916113f, -0.34626144f, 
    0.11343481f, 0.10371344f, 0.16059527f, -0.08269983f, 0.70939165f, -0.29125199f, 0.11028806f, -0.01982610f, 
    -0.00683515f, 0.19310088f, -0.09002244f, 0.14842679f, -0.08173523f, 0.00884806f, 0.10634185f, 0.02550355f, 
    -0.01320109f, 0.05213171f, -0.01985747f, -0.03514333f, -0.04500125f, 0.12589739f, 0.07032390f, 0.09114230f, 
    -0.05624685f, -0.04264379f, -0.08148549f, 0.00760126f, 0.11344862f, -0.12566264f, 0.10272407f, 0.04550448f, 
    0.03900881f, 0.53631949f, 0.15262355f, 0.02007285f, -0.02845429f, -0.11782273f, -0.06082416f, -0.05700770f, 
    0.34250173f, -0.17983466f, 0.04164174f, -0.11737480f, 0.01793467f, -0.17907058f, 0.13870586f, 0.01124415f, 
    -0.13222961f, -0.04849481f, 0.08630615f, 0.02871415f, 0.04109664f, 0.01362756f, 0.05878864f, -0.07100795f, 
    -0.09762415f, -0.06456954f, 0.07210137f, -0.10834348f, 0.06648807f, -0.04090105f, -0.08640502f, 0.03171128f, 
    0.09485918f, 0.08781958f, -0.12395706f, -0.09653178f, -0.00052729f, -0.00279235f, 0.11007172f, 0.06471474f, 
    -0.02295145f, -0.15374780f, 0.01316588f, 0.02761189f, -0.15150154f, -0.14869256f, 0.04809237f, -0.11512462f, 
    -0.04255166f, -0.11988415f, -0.03312908f, -0.10721226f, 0.09644847f, 0.06991078f, -0.11246477f, 0.03464598f, 
    0.06807239f, 0.02914195f, 0.08187152f, -0.11606720f, 0.03389241f, -0.08918978f, -0.12690125f, -0.10839031f, 
    -0.07446289f, -0.09451114f, 0.03211772f, -0.06183498f, -0.06207114f, -0.01247568f, -0.02886613f, 0.05421196f, 
    -0.09199296f, -0.01463239f, 0.09007078f, -0.09732680f, -0.11953746f, 0.04285873f, 0.09185392f, -0.04896893f, 
    0.20613682f, -0.11921196f, 0.10823086f, 0.04726268f, -0.04992511f, 0.06171587f, -0.09137856f, 0.09789832f, 
    -0.05191563f, 0.14031719f, 0.17514701f, -0.11723798f, -0.02361611f, 0.22753307f, 0.28012839f, 0.27092671f, 
    -0.06646188f, 0.26649907f, -0.29997945f, 0.08881327f, -0.07939380f, -0.00771379f, 0.07260461f, -0.10401728f, 
    -0.04498984f, -0.24963623f, -0.10582081f, 0.18326846f, -0.23253694f, 0.02356734f, -0.00100475f, -0.03675322f, 
    -0.03182482f, 0.00025740f, 0.10502691f, 0.03592797f, 0.08699636f, -0.08977889f, 0.09840631f, -0.03822640f, 
    -0.07158049f, 0.03321851f, 0.00556632f, 0.04055946f, -0.02129986f, -0.21157853f, 0.19418247f, -0.12781164f, 
    -0.05940025f, 0.54830950f, -0.24558304f, -0.18226857f, -0.05553643f, -0.11345034f, 0.04068036f, -0.11775485f, 
    0.05333702f, -0.16564594f, 0.10583739f, 0.01141935f, 0.14749444f, 0.02093447f, 0.06732179f, 0.09499697f, 
    0.09577533f, 0.03504441f, 0.11166279f, -0.19472943f, -0.09588049f, 0.13608465f, 0.37582329f, -0.09551279f, 
    -0.08481971f, -0.32793036f, -0.22787574f, -0.00217101f, -0.11962774f, 0.37787312f, 0.19600481f, 0.09152194f, 
    -0.06990106f, 0.08531933f, -0.01596129f, 0.02370395f, -0.26419288f, -0.06936087f, 0.08197642f, -0.00886957f, 
    0.07463452f, -0.16019155f, -0.00887871f, 0.24467789f, 0.20940810f, -0.01790510f, -0.09545527f, 0.06247550f, 
    0.26902869f, -0.02990234f, 0.02089031f, 0.02415293f, -0.03745874f, 0.00257796f, 0.06022222f, -0.07645299f, 
    0.15573809f, 0.14269508f, -0.07681259f, -0.21837267f, -0.40502071f, -0.07366568f, 0.01292715f, -0.07010231f, 
    -0.00123450f, 0.18889348f, 0.06004042f, 0.08384871f, 0.01124846f, -0.01606780f, -0.01637855f, -0.07361251f, 
    0.12693195f, 0.10200974f, -0.12033865f, 0.02268171f, 0.18456830f, -0.24397419f, 0.07057112f, -0.04220735f, 
    0.06771045f, 0.04836420f, 0.05007213f, -0.21204197f, -0.00581880f, -0.07468804f, 0.13598667f, 0.03530478f, 
    -0.11970538f, 0.07613376f, -0.18016523f, 0.05720104f, 0.07727171f, 0.34830332f, 0.06909155f, -0.38815764f, 
    -0.07979266f, 0.26259586f, 0.03225570f, 0.01028646f, 0.58017212f, 0.05378609f, -0.01449240f, -0.08525974f, 
    0.02185215f, 0.00369690f, -0.03436064f, 0.04149251f, 0.07513284f, 0.05363023f, 0.10860114f, 0.06434523f, 
    0.09362500f, -0.01139120f, 0.01294538f, -0.05130750f, 0.13938078f, 0.11572588f, 0.11764526f, 0.05318683f, 
    0.15055212f, -0.07810803f, 0.11169322f, 0.00230714f, -0.02550672f, -0.00319127f, 0.13078974f, -0.01951768f, 
    0.04362101f, 0.29309705f, 0.17150381f, 0.24638920f, 0.04375643f, -0.01932821f, 0.01995694f, 0.02293156f, 
    0.23223116f, -0.12300078f, -0.06176176f, -0.12742676f, 0.14006422f, 0.04942787f, 0.01928936f, -0.20342562f, 
    -0.09615449f, -0.13025537f, -0.02828848f, -0.04346281f, 0.08514954f, -0.11752693f, 0.10958064f, -0.08518444f, 
    0.04032843f, 0.08115802f, 0.02491995f, 0.00784689f, -0.01678553f, -0.12802286f, -0.10962233f, 0.08404598f, 
    0.01471636f, -0.06952425f, -0.00124289f, -0.09010205f, -0.05961838f, -0.07644400f, 0.07141349f, -0.06855793f, 
    -0.05736880f, 0.07761909f, 0.04685283f, -0.14899197f, -0.11492325f, -0.03808575f, -0.05604164f, -0.15163375f, 
    -0.03851576f, 0.07939258f, 0.00872001f, 0.06105728f, -0.02592364f, 0.11289544f, -0.12410010f, 0.09889761f, 
    -0.14743623f, -0.13252687f, -0.07538325f, 0.02180427f, 0.04615464f, -0.03449860f, -0.12464154f, 0.08306551f, 
    0.08583099f, 0.01098263f, -0.06996874f, 0.08886050f, -0.03825498f, -0.05207388f, 0.03893927f, -0.05930041f, 
    0.05597891f, -0.05545846f, 0.11107655f, -0.04923867f, 0.06249655f, -0.02471244f, -0.00473578f, -0.06795093f, 
    -0.55845559f, 0.05780714f, -0.03869990f, 0.04964346f, -0.11381990f, 0.08400519f, 0.09218837f, -0.10396847f, 
    0.03127231f, 0.24590197f, 0.09668490f, -0.04264417f, -0.09656498f, -0.00596644f, 0.35789844f, 0.00050897f, 
    0.10243616f, 0.22248778f, 0.09857688f, 0.08040082f, 0.23104641f, 0.10936709f, -0.08593677f, -0.00231323f, 
    0.09402034f, 0.12042479f, -0.08024269f, -0.15236861f, 0.07754200f, -0.17873417f, -0.08584911f, 0.16668662f, 
    0.10543951f, 0.11618938f, -0.09948296f, 0.07906619f, 0.03464609f, 0.09090413f, -0.01269016f, -0.06052244f, 
    -0.06516337f, -0.06817505f, -0.10872354f, -0.00182565f, 0.27268016f, -0.03447886f, 0.18914051f, -0.03985642f, 
    0.07067536f, -0.09068286f, 0.02651312f, -0.19153847f, 0.03308769f, 0.09601922f, 0.05589125f, 0.06865740f, 
    0.04742181f, -0.28030929f, -0.06763179f, 0.01467724f, 0.18780242f, 0.09599513f, -0.20604548f, -0.25206909f, 
    0.12298620f, -0.20926403f, -0.11005695f, -0.11037604f, -0.07299438f, 0.11987203f, 0.24933553f, -0.01799223f, 
    -0.07983203f, 0.14511687f, 0.11743087f, 0.05366138f, 0.04499450f, -0.25686753f, 0.02741556f, -0.14596267f, 
    -0.00774817f, -0.27709544f, 0.00073129f, -0.03381030f, -0.34819964f, 0.07041462f, -0.05802998f, 0.03554164f, 
    -0.02127251f, -0.17587692f, 0.09356520f, -0.02858108f, -0.02933075f, -0.23807967f, -0.02111726f, 0.01154345f, 
    0.28095731f, 0.04949198f, -0.05784623f, 0.04478547f, -0.00873476f, -0.04332894f, -0.02626305f, -0.00065672f, 
    0.27823636f, -0.00125502f, 0.02207938f, 0.07732812f, 0.03416892f, 0.08651131f, 0.07813072f, 0.08962889f, 
    0.05189621f, 0.37589368f, 0.01113529f, 0.30927879f, -0.07915635f, 0.10088079f, -0.06292577f, 0.03568267f, 
    -0.07950947f, 0.07301570f, 0.07475343f, -0.08831220f, -0.05356840f, 0.23909467f, 0.00973187f, 0.18513803f, 
    -0.29263809f, 0.20120136f, -0.02925737f, 0.16217466f, -0.03733240f, -0.09555136f, 0.34371775f, 0.06777150f, 
    0.08503674f, -0.06455792f, -0.06025283f, -0.09232402f, 0.07111546f, 0.03735996f, 0.13682394f, -0.05840750f, 
    -0.06033596f, 0.17233025f, 0.16481352f, 0.10149805f, 0.01773443f, 0.28027278f, -0.11608134f, 0.09374592f, 
    0.00149183f, 0.09606171f, -0.09899347f, 0.09145561f, 0.24593343f, 0.05393046f, 0.02271436f, 0.21423595f, 
    0.15490592f, -0.01691943f, -0.12542577f, -0.06273694f, -0.07092351f, -0.07455505f, -0.03470624f, 0.04307884f, 
    0.08213188f, 0.00123544f, 0.11105996f, 0.07265697f, -0.18829094f, 0.30494067f, 0.06336199f, -0.12396000f, 
    -0.00934391f, -0.31726998f, 0.07455139f, -0.02196302f, 0.03216888f, 0.00995527f, -0.05445151f, -0.07331908f, 
    0.19861791f, -0.05517385f, 0.01249488f, 0.02940428f, 0.17690319f, 0.06259338f, -0.16907676f, -0.31232226f, 
    0.06324458f, 0.02761567f, 0.11937012f, -0.10699994f, -0.00572337f, -0.00700496f, -0.09994651f, 0.10361585f, 
    0.07019426f, -0.08056308f, -0.05783674f, -0.08730698f, 0.01153085f, 0.06594673f, -0.02827497f, 0.08941002f, 
    -0.12349318f, -0.00322261f, -0.13003609f, 0.08872949f, 0.00794451f, 0.10112160f, -0.01524393f, 0.06118584f, 
    -0.12128033f, 0.00741452f, 0.10777748f, -0.07207032f, -0.03188482f, 0.04909638f, -0.07769479f, -0.08799727f, 
    -0.06486279f, -0.09840669f, -0.05672047f, -0.12332287f, 0.09608223f, 0.09174392f, -0.06050372f, 0.01714954f, 
    -0.07560085f, 0.02820442f, -0.06860026f, -0.06826448f, -0.02974292f, -0.09811496f, 0.03028243f, -0.06470732f, 
    0.05651096f, -0.05489391f, 0.05655319f, -0.10110729f, 0.03814934f, 0.04943809f, 0.01549861f, -0.11882506f, 
    0.02342406f, -0.06881571f, -0.01112742f, 0.00817826f, -0.00803102f, -0.10911679f, -0.09381749f, -0.09510762f, 
    -0.01616790f, 0.10326728f, -0.04388450f, -0.05387116f, 0.03421345f, 0.04193914f, 0.14230961f, 0.05748597f, 
    -0.06783861f, -0.12600818f, 0.17365840f, -0.09001924f, -0.07414025f, -0.24405652f, -0.19864614f, -0.09060232f, 
    0.11666401f, -0.32536468f, -0.17468019f, 0.07900256f, -0.27571464f, 0.06959280f, -0.09965231f, 0.00883502f, 
    0.11733839f, -0.25497919f, 0.03637926f, 0.11574481f, 0.10425054f, 0.10043845f, -0.04000446f, 0.20603384f, 
    0.00472827f, 0.03110799f, -0.04340424f, -0.12108099f, 0.00453744f, -0.04969525f, -0.04633163f, -0.10613206f, 
    -0.03689243f, -0.13216491f, -0.10703541f, 0.04998387f, 0.38602030f, 0.31381959f, 0.19449276f, 0.47501132f, 
    0.05616251f, -0.17029314f, -0.06854224f, -0.14248288f, 0.09713767f, -0.00932768f, -0.04498111f, -0.11833525f, 
    0.05134098f, -0.04543243f, -0.08136737f, -0.01245102f, 0.12950417f, 0.20048335f, 0.02486292f, 0.14174129f, 
    0.07184307f, -0.20679721f, -0.05721901f, 0.45761767f, -0.01616696f, 0.08146835f, 0.11209808f, 0.08072812f, 
    0.11274252f, 0.01804905f, 0.14385912f, -0.04378139f, 0.12922144f, 0.03990825f, -0.10514378f, 0.05628050f, 
    -0.02916034f, 0.01394786f, -0.06216081f, -0.12397242f, -0.07004233f, -0.09971046f, 0.03968892f, -0.05843493f, 
    -0.06665958f, -0.44541046f, -0.10242221f, 0.20043507f, -0.12663642f, 0.07323956f, -0.10441276f, 0.19359581f, 
    0.03878077f, -0.03036668f, 0.06494606f, 0.03199585f, -0.06160580f, -0.08870904f, 0.09638335f, 0.00072587f, 
    -0.15713249f, 0.12136841f, -0.04744916f, -0.01008845f, 0.12945279f, 0.08526416f, 0.06037797f, 0.11865792f, 
    0.09637365f, 0.06842999f, -0.13870919f, -0.00037347f, 0.00045587f, -0.07984935f, 0.03973205f, -0.07634309f, 
    0.38892061f, -0.29072613f, -0.00073269f, -0.01808413f, 0.15541360f, 0.23328920f, -0.16043039f, 0.00996916f, 
    0.16684586f, -0.03486573f, -0.11274169f, -0.12915073f, 0.10342836f, 0.09952365f, -0.01607511f, 0.00095401f, 
    -0.10818149f, -0.15614165f, -0.15341167f, -0.08934446f, 0.10433140f, 0.40514264f, 0.44793078f, -0.03519025f, 
    0.05804850f, 0.36831537f, -0.27857089f, -0.01971634f, -0.07378424f, -0.09346172f, -0.06680718f, 0.07965668f, 
    -0.02639715f, -0.10317906f, 0.05878976f, 0.20039040f, -0.08620121f, 0.20561105f, -0.12072507f, 0.00953931f, 
    0.07512449f, 0.04899642f, -0.09480054f, -0.04505697f, 0.05229486f, 0.06280285f, -0.11420541f, -0.01586952f, 
    0.11432663f, 0.19894387f, -0.06785037f, -0.23471831f, -0.41811529f, -0.10399338f, 0.07661980f, 0.18800980f, 
    0.08950345f, 0.53102708f, -0.17468715f, -0.14153160f, 0.04426801f, 0.02962639f, -0.07715121f, 0.07341710f, 
    0.08200358f, 0.00934588f, -0.02111577f, -0.03543119f, 0.16000473f, -0.25926775f, 0.09093513f, 0.15889224f, 
    0.23316884f, -0.00256964f, 0.07149325f, -0.01279011f, 0.08569561f, 0.03744527f, -0.26508978f, -0.05595662f, 
    0.01141986f, 0.12400456f, 0.07122771f, 0.02697357f, 0.04856108f, 0.03603140f, -0.31942248f, -0.35674602f, 
    -0.08432829f, -0.27859926f, 0.24202031f, -0.10394990f, -0.26367611f, -0.42556128f, -0.03812123f, -0.10983337f, 
    0.08999145f, -0.02045560f, 0.02000767f, 0.13950574f, -0.00610566f, 0.26867932f, 0.04770057f, -0.01876727f, 
    -0.11843519f, 0.12177943f, -0.03270535f, -0.11224176f, 0.01741454f, -0.09715170f, -0.06927208f, -0.06964254f, 
    -0.12935434f, -0.01332745f, -0.03109591f, 0.20306893f, 0.08636564f, 0.01213749f, -0.28858101f, 0.08215073f, 
    -0.06024101f, -0.03127120f, 0.08621537f, 0.37343907f, -0.04973605f, -0.02112320f, 0.13031174f, 0.01851043f, 
    -0.18384357f, -0.07081248f, -0.01938614f, -0.11623343f, -0.17018162f, 0.11029483f, 0.18947157f, 0.00416362f, 
    0.33034310f, 0.06109086f, 0.10608398f, -0.14650598f, 0.04284702f, 0.05849121f, -0.04246584f, 0.04068599f, 
    -0.05573675f, 0.02149370f, -0.28809163f, 0.09792712f, 0.10239405f, 0.35418999f, 0.17686372f, -0.32810572f, 
    0.08085905f, 0.36535171f, -0.04707055f, 0.00391122f, -0.06514459f, 0.12536454f, -0.04753667f, -0.06063227f, 
    -0.05613379f, -0.15508148f, -0.01140696f, 0.17616586f, 0.00127754f, 0.03746553f, 0.04834415f, -0.14453098f, 
    0.00135377f, -0.02536435f, -0.06850063f, 0.03494427f, 0.08077659f, 0.12273637f, -0.04200087f, 0.04716158f, 
    0.28100333f, 0.16098630f, 0.05064992f, 0.01806786f, -0.43171173f, -0.06781916f, -0.05690867f, 0.18762076f, 
    0.07032425f, 0.22416143f, 0.01506593f, 0.13715345f, 0.07519007f, 0.08658507f, -0.01268751f, 0.08783575f, 
    -0.29563785f, 0.35917145f, 0.08615073f, -0.05635749f, 0.02566865f, -0.15019181f, 0.26793069f, 0.05469317f, 
    -0.43119428f, -0.05338748f, 0.02101492f, 0.05527370f, -0.11670401f, -0.05058780f, 0.01677324f, -0.06598732f, 
    -0.06458721f, 0.20877792f, 0.21105435f, 0.05032341f, -0.03783796f, -0.08856286f, 0.32008547f, 0.05346763f, 
    -0.12392744f, 0.00678398f, -0.08852106f, -0.12285446f, 0.14050502f, 0.21156670f, -0.10136952f, 0.00336428f, 
    -0.06952612f, 0.33850685f, 0.11869702f, -0.02853762f, -0.18088594f, -0.25339186f, -0.09029099f, 0.02418795f, 
    0.11031412f, 0.03554009f, 0.01686226f, 0.05665398f, -0.00588355f, -0.10799429f, -0.04002166f, 0.06747277f, 
    0.12832555f, -0.13568032f, 0.05602252f, 0.20152831f, 0.09941527f, 0.27623221f, 0.00921181f, 0.26939470f, 
    -0.06696838f, 0.08137430f, 0.24023439f, 0.03744428f, 0.00896317f, 0.11241002f, 0.05446241f, -0.03811957f, 
    -0.10335154f, -0.00910499f, -0.09910952f, 0.10799929f, 0.05333814f, 0.20199417f, -0.14484790f, -0.10281011f, 
    -0.24934416f, 0.23884588f, -0.01875368f, -0.16899949f, 0.11706420f, 0.07646903f, -0.00534276f, -0.02653566f, 
    -0.04357848f, -0.01561491f, -0.08135720f, -0.07117640f, 0.03775317f, 0.21389328f, 0.27112132f, -0.11688247f, 
    0.09912745f, 0.23661026f, -0.10733391f, 0.10156970f, 0.36868966f, 0.22232400f, -0.01028681f, -0.10185303f, 
    0.09939180f, 0.46281770f, 0.06101737f, -0.06912050f, 0.01485314f, -0.19650772f, -0.04622486f, 0.04962134f, 
    -0.02733878f, 0.10821453f, -0.00353143f, -0.02577398f, -0.06056539f, 0.10193300f, -0.02934326f, 0.09344667f, 
    0.03140506f, 0.01344306f, 0.00116280f, -0.02233606f, 0.11278702f, 0.02701201f, 0.14101131f, -0.20338988f, 
    0.05753846f, 0.11757988f, 0.19459829f, 0.01443375f, -0.08616887f, 0.08453777f, 0.01062421f, -0.00878347f, 
    0.12791762f, -0.06252055f, -0.02974359f, -0.01511279f, 0.10672440f, 0.20199649f, -0.04082822f, 0.07535545f, 
    0.16781288f, -0.15621373f, -0.07353045f, -0.11499234f, 0.08005939f, -0.09937215f, 0.18288475f, 0.02204481f, 
    -0.10752004f, 0.26007566f, -0.03721213f, -0.07795325f, -0.11419420f, 0.05388762f, 0.20132504f, -0.24615310f, 
    0.06456010f, 0.14001986f, -0.30199009f, -0.08145552f, 0.13553941f, 0.05257649f, -0.08441133f, 0.09006238f, 
    0.07938473f, -0.31400615f, -0.00201279f, -0.05473666f, -0.20514253f, -0.04160821f, -0.08858815f, 0.06772750f, 
    0.21515803f, 0.11081965f, 0.02328016f, 0.02270880f, -0.04380342f, -0.09979060f, 0.06457055f, -0.01421309f, 
    0.24869397f, 0.12096926f, -0.03612916f, -0.13121901f, 0.24672334f, -0.17861685f, 0.06483085f, 0.13155788f, 
    0.05352364f, 0.50990099f, -0.00483873f, 0.15460697f, -0.11502015f, 0.06588776f, -0.04716718f, -0.10642160f, 
    0.13268119f, -0.22804734f, -0.06446701f, 0.08621013f, 0.05325468f, 0.09329301f, 0.11996532f, 0.23139748f, 
    0.06545655f, -0.11705286f, 0.03744612f, -0.05953712f, 0.07948582f, -0.10267444f, -0.07187786f, -0.08976574f, 
    -0.01064334f, 0.06953212f, -0.06330239f, 0.08670123f, -0.11227808f, -0.06584710f, -0.05010354f, 0.00448116f, 
    0.09946649f, -0.10284192f, 0.05615656f, -0.06079515f, 0.05918442f, 0.05412537f, -0.01577965f, 0.01206694f, 
    -0.12791885f, 0.00806392f, -0.04327191f, -0.04632000f, -0.05204370f, -0.07783740f, -0.08368129f, -0.12955697f, 
    0.07421407f, -0.03516358f, 0.05044352f, -0.08307081f, 0.01431611f, -0.04529095f, 0.00097743f, 0.05158864f, 
    0.08705775f, -0.11740847f, 0.10657502f, -0.10154939f, 0.06898119f, 0.00425658f, 0.04670175f, -0.01244314f, 
    0.11875512f, 0.00067137f, -0.09171925f, 0.02758662f, -0.00856545f, 0.05300303f, 0.09599353f, -0.11224526f, 
    -0.04999086f, 0.10632860f, 0.11345000f, 0.12019665f, 0.05056005f, -0.02023187f, -0.10761447f, -0.07893753f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02984959f, -0.11798054f, 0.11755753f, 0.02550547f, 0.03511246f, -0.04915390f, -0.04490653f, -0.10539013f, 
    -0.05675334f, 0.14679591f, -0.00643227f, -0.01811511f, 0.04245607f, 0.10574154f, 0.08102432f, -0.09296164f, 
    0.08702859f, 0.02078942f, -0.01958859f, 0.03820134f, 0.08997275f, 0.15195659f, 0.02640963f, -0.09449758f, 
    0.05059589f, -0.03188070f, 0.17823462f, -0.03946395f, 0.11383137f, 0.00392847f, 0.03214158f, -0.02369121f, 
    0.14926994f, 0.05886071f, -0.14402469f, 0.00550341f, -0.03541156f, -0.05144021f, -0.12642385f, -0.05829304f, 
    0.03937731f, 0.01999702f, -0.00094571f, -0.08991831f, -0.07617413f, -0.04191113f, -0.09145539f, 0.08051529f, 
    -0.02502025f, 0.12611435f, -0.12577903f, -0.03901976f, 0.12234938f, 0.04945814f, -0.07785916f, 0.03209852f, 
    0.09303333f, -0.10191289f, 0.03811472f, 0.17187685f, -0.03862531f, 0.04250514f, -0.01770354f, 0.05622328f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.38035098f, 0.09042158f, -0.32766858f, -0.26718470f, 0.22371642f, -0.48543307f, 0.13441710f, 0.10193435f, 
    -0.13015531f, 0.13562849f, -0.19992951f, 0.12972626f, -0.24523242f, 0.20626795f, 0.18307650f, -0.09931543f, 
    -0.09321181f, -0.33231631f, 0.33389080f, 0.03925031f, 0.13308200f, 0.16030534f, 0.18547918f, -0.04132801f, 
    -0.27266639f, 0.04978469f, -0.16482620f, -0.22100525f, 0.21386039f, 0.05808072f, 0.29761106f, 0.04231002f, 
    -0.42999187f, 0.11605104f, 0.18719263f, -0.06514043f, 0.08426675f, -0.05369809f, 0.03016594f, 0.14385566f, 
    0.00379038f, 0.10187181f, -0.46131063f, 0.01521470f, 0.06465692f, -0.43933159f, -0.09701645f, 0.06741489f, 
    -0.00785635f, -0.43986410f, -0.07108196f, -0.52147156f, -0.18189035f, 0.04058781f, 0.00600347f, -0.01423438f, 
    0.17702310f, 0.08541502f, -0.54141796f, -0.13474894f, -0.23247981f, -0.26165876f, -0.43548849f, 0.02307160f, 
    -0.25023732f, -0.00160917f, 0.24654397f, 0.12167972f, 0.21663997f, -0.36061025f, -0.02492868f, 0.07804374f, 
    -0.07589316f, 0.26641271f, -0.00267792f, -0.28642941f, -0.14319389f, -0.17982896f, 0.05082922f, 0.01089817f, 
    -0.05424461f, 0.01453932f, 0.07237363f, 0.31046706f, -0.15757540f, 0.04843886f, 0.06957777f, -0.05626025f, 
    -0.12704904f, 0.09888900f, 0.20145015f, 0.15281500f, -0.00210530f, -0.07128008f, -1.00920737f, 0.26419565f, 
    -0.01557905f, 0.00880196f, -0.23028907f, 0.01078383f, -0.07062768f, 0.37820202f, -0.22029579f, 0.10424065f, 
    -0.06360629f, 0.00636352f, 0.01471244f, 0.12298332f, -0.09337828f, -0.09255516f, -0.00946640f, 0.04460853f, 
    -0.29537582f, -0.19125871f, 0.04000345f, 0.07148984f, -0.08719989f, -0.15354164f, 0.00947172f, -0.04351839f, 
    0.16139930f, -0.11766332f, 0.32068157f, -0.08945784f, -0.44258076f, -0.20540793f, -0.09151686f, -0.02612097f, 
    0.24363180f, 0.04599988f, 0.09844533f, 0.19018289f, 0.00774762f, -0.03955068f, 0.00564922f, -0.10615725f, 
    -0.07283706f, 0.03885466f, 0.24994609f, -0.09991598f, -0.44036010f, 0.10621009f, 0.23559834f, 0.04906553f, 
    0.09113242f, -0.37842125f, -0.29897034f, 0.25605452f, 0.30977029f, 0.05057978f, -0.09733950f, 0.06388552f, 
    -0.32894415f, -0.10246762f, 0.19917436f, -0.47343862f, -0.16380441f, 0.02948153f, -0.11735396f, -0.13877209f, 
    0.14096875f, 0.08764640f, 0.22947802f, -0.09051000f, 0.00667422f, -0.01177632f, -0.00463529f, 0.19477586f, 
    0.05335027f, -0.23772511f, -0.43257257f, -0.00535026f, -0.08088839f, -0.06914259f, 0.05124532f, -0.07977365f, 
    -0.27814823f, -0.36264586f, 0.09169178f, 0.05330723f, 0.20401922f, -0.34102094f, -0.12304864f, -0.06199589f, 
    -0.29925302f, -0.23819636f, -0.32493469f, -0.24384049f, 0.15366587f, 0.10986949f, 0.01173223f, -0.05286480f, 
    0.28120062f, 0.02470600f, -0.29022908f, -0.32845473f, -0.26812115f, 0.18159063f, 0.24877903f, 0.04894218f, 
    0.08836420f, 0.01296098f, 0.02504436f, 0.08952279f, -0.05907765f, -0.09377313f, 0.02597125f, -0.12334248f, 
    0.08753163f, 0.01657248f, 0.21911171f, -0.56594318f, 0.06845696f, -0.26023772f, -0.30259115f, -0.11038009f, 
    -0.17585751f, 0.29573244f, 0.15554778f, -0.11181387f, -0.11730748f, -0.08029043f, 0.34888533f, -0.05329603f, 
    -0.08825178f, -0.06762370f, 0.18644041f, -0.02852987f, -0.39245772f, -0.24645789f, -0.22768550f, -0.35850295f, 
    -0.09198779f, -0.02269731f, -0.16417389f, -0.06004399f, -0.04771312f, -0.32122913f, 0.08923488f, 0.02146072f, 
    0.03007841f, -0.01709219f, 0.07717392f, 0.12727642f, 0.05214838f, 0.19700031f, 0.09541248f, 0.34379283f, 
    0.29878440f, -0.17672369f, -0.25899643f, -0.46718237f, 0.08282091f, -0.07245354f, -0.08237141f, -0.07396933f, 
    0.19254890f, 0.06123007f, -0.10093377f, -0.36238387f, -0.27375200f, 0.03582593f, 0.19336170f, -0.01170415f, 
    -0.00381474f, -0.10201652f, -0.15864965f, 0.33401871f, -0.04474698f, 0.23910911f, 0.13864584f, 0.09453030f, 
    0.08753499f, 0.14405067f, -0.01167062f, 0.02027869f, -0.23099187f, -0.09849192f, -0.00083676f, -0.08883245f, 
    -0.26451838f, 0.12624961f, -0.29750621f, -0.11793669f, -0.12136502f, 0.09523807f, -0.43142876f, 0.01680474f, 
    0.04086323f, 0.03055899f, -0.14555542f, -0.00501916f, 0.17117655f, 0.01165512f, -0.21210223f, 0.09430693f, 
    0.05918932f, 0.10467473f, 0.34898371f, -0.07314129f, -0.07325287f, 0.01979985f, 0.03428370f, 0.07917532f, 
    0.17976187f, -0.01549242f, -0.07554420f, -0.48155600f, 0.18188128f, -0.14151230f, -0.06023626f, 0.08629413f, 
    -0.05144621f, 0.25452334f, -0.45095450f, 0.14621487f, -0.42221621f, -0.19293372f, 0.22275488f, 0.02997745f, 
    -0.06875939f, -0.11252604f, -0.03437122f, 0.03920837f, 0.16021797f, -0.09849428f, -0.21428537f, 0.11185779f, 
    -0.05025779f, -0.25271824f, -0.32585567f, -0.08371101f, 0.18950291f, -0.44241771f, -0.41248268f, 0.04155564f, 
    -0.04352915f, 0.14813404f, 0.03846674f, -0.29588348f, -0.18164091f, 0.06510676f, 0.12277660f, 0.10312516f, 
    0.21444191f, 0.09007128f, -0.35110250f, 0.03727674f, 0.13657895f, -0.01122467f, 0.23443881f, 0.12617974f, 
    0.10652820f, 0.01854759f, -0.33398110f, 0.01325177f, 0.24582289f, 0.12195180f, -0.09078696f, -0.00198837f, 
    0.05729033f, 0.19878918f, -0.46821895f, -0.01541990f, -0.00039683f, 0.25365758f, 0.05058334f, -0.07008178f, 
    0.04512071f, 0.03719398f, 0.01282854f, 0.20981145f, 0.05513547f, -0.12118587f, -0.12052700f, -0.17938904f, 
    0.09136592f, 0.05826936f, 0.29507503f, 0.18174313f, 0.08672533f, -0.37589961f, -0.07390445f, 0.04630667f, 
    -0.35412058f, 0.05177628f, -0.36793038f, -0.10555882f, -0.20291708f, 0.21067941f, 0.10616378f, 0.01802835f, 
    0.09258209f, -0.07020874f, 0.02399774f, -0.44938117f, 0.20125978f, -0.26349890f, -0.18141831f, 0.03491360f, 
    0.22216825f, 0.03188802f, -0.39155838f, -0.29430872f, 0.37061784f, 0.10831071f, 0.01449110f, 0.10181575f, 
    0.12133915f, -0.18336581f, 0.33193630f, -0.05877405f, 0.27209958f, -0.06324568f, 0.14386369f, 0.20499444f, 
    0.18153574f, -0.06496382f, 0.04808993f, -0.07864176f, -0.13263319f, -0.12844074f, -0.51590025f, 0.10111137f, 
    0.10999507f, 0.16443165f, -0.12010784f, -0.04697222f, 0.00408688f, -0.30010986f, -0.06060395f, -0.33287925f, 
    -0.05091857f, -0.10196887f, -0.03106872f, -0.25086769f, -0.10649379f, 0.01538219f, 0.01328959f, 0.15146115f, 
    -0.44927341f, 0.02792222f, -0.02894420f, 0.22582242f, 0.02795298f, -0.15754482f, -0.35086083f, 0.02096709f, 
    0.08110125f, -0.07796799f, -0.12173901f, 0.12646945f, -0.14534034f, 0.09827774f, -0.23403026f, -0.01846731f, 
    -0.03873841f, -0.25599918f, -0.19504531f, 0.11033501f, -0.01530742f, 0.24147062f, 0.19077340f, -0.04837772f, 
    0.07254140f, 0.12381132f, -0.03331903f, 0.04789411f, 0.03091552f, -0.39335862f, -0.00600309f, -0.01750692f, 
    -0.22342020f, -0.26232389f, -0.24184200f, 0.15915063f, -0.38813534f, -0.09947614f, -0.40313789f, -0.10593158f, 
    -0.13833386f, 0.02841133f, 0.17507373f, -0.11578834f, -0.12165359f, 0.03711604f, 0.20898719f, -0.32281062f, 
    0.02739246f, -0.30979389f, 0.09871032f, 0.04563993f, 0.07026087f, 0.05222964f, -0.10996012f, 0.19127750f, 
    -0.05023847f, 0.20265022f, 0.10601509f, 0.21814026f, -0.22925295f, 0.14476652f, -0.02238243f, -0.22912081f, 
    0.07676077f, 0.19976184f, -0.01507394f, -0.04827700f, 0.29295817f, 0.20188329f, 0.24942149f, -0.07786398f, 
    0.12122476f, 0.07516886f, 0.10033083f, 0.11481766f, 0.10779736f, 0.23444426f, -0.32140824f, -0.09238003f, 
    -0.04186302f, 0.06832054f, -0.34702778f, -0.04989135f, 0.25852716f, -0.30637640f, -0.38824078f, -0.05292381f, 
    -0.36370668f, -0.24957787f, 0.09625265f, -0.14513774f, -0.42426559f, 0.02019386f, 0.03818216f, -0.07666956f, 
    0.13952523f, -0.28860363f, -0.06200255f, 0.05941845f, -0.22094113f, 0.04152060f, -0.34281343f, -0.28964013f, 
    -0.06961691f, -0.09191099f, -0.09529257f, -0.01679137f, 0.23251511f, 0.02379985f, 0.21483837f, 0.15490668f, 
    -0.06317014f, -0.41771814f, -0.00962639f, 0.04876026f, -0.02416757f, 0.04406540f, -0.07006864f, 0.28303534f, 
    -0.35791764f, -0.15089917f, 0.07427030f, -0.18043268f, 0.15637982f, -0.32923359f, 0.02354593f, 0.05489182f, 
    0.21927863f, 0.13840012f, -0.44491738f, 0.06662153f, 0.12611952f, 0.04018280f, 0.31543279f, -0.04931271f, 
    -0.35610014f, -0.06475042f, -0.25658882f, 0.04462150f, -0.44015715f, -0.01553020f, 0.14294679f, 0.00938471f, 
    -0.12827972f, 0.04652971f, 0.18670990f, -0.22776784f, 0.15226282f, 0.24262689f, 0.23381855f, -0.03984688f, 
    -0.07296667f, -0.24630930f, -0.50531566f, -0.03514907f, 0.08040030f, 0.21337207f, -0.20047542f, 0.00346767f, 
    0.01122628f, -0.04145871f, -0.17148788f, -0.20324294f, -0.06945368f, -0.09535554f, 0.29592893f, -0.29802591f, 
    -0.01420088f, -0.04229067f, -0.27678522f, -0.01578587f, -0.04091258f, -0.08382188f, 0.18678980f, 0.01058614f, 
    0.06098469f, -0.12480687f, 0.10920554f, -0.06131910f, 0.11900528f, 0.25507891f, 0.02721351f, 0.09722786f, 
    0.25996622f, 0.15363924f, 0.04552715f, -0.00919202f, -0.29371202f, 0.01611403f, 0.08987538f, -0.54888552f, 
    -0.30803528f, 0.28443190f, -0.27730316f, 0.21732719f, -0.17675275f, 0.14479862f, -0.16633153f, 0.07576814f, 
    0.23704286f, 0.09085057f, 0.20037170f, 0.11174360f, -0.06110273f, -0.31530505f, 0.11791921f, -0.09449244f, 
    -0.05392726f, -0.12276420f, 0.01277198f, 0.16412133f, 0.26810217f, -0.00849826f, -0.09833697f, 0.11156891f, 
    0.03105445f, 0.10339474f, -0.17906535f, 0.25328583f, -0.05598205f, -0.00016147f, -0.43888068f, -0.08855627f, 
    0.14715849f, -0.01599355f, 0.02193183f, 0.24600421f, -0.20213452f, -0.07531356f, -0.23223200f, 0.31297892f, 
    0.32758164f, 0.10914306f, -0.18004240f, -0.03662392f, -0.20427892f, -0.18740085f, -0.19110599f, -0.00023252f, 
    0.02001984f, -0.54165316f, 0.13719346f, 0.06884781f, 0.00738704f, 0.44447854f, 0.00602119f, -0.48848265f, 
    -0.30055824f, 0.17903067f, -0.09631211f, 0.07388733f, -0.14668161f, 0.04486764f, -0.06154191f, 0.14118388f, 
    -0.07088391f, -0.38367459f, -0.14315134f, -0.38267291f, 0.00996006f, 0.16413656f, -0.06028565f, -0.03680688f, 
    0.01318439f, -0.04226064f, 0.27962336f, 0.21098527f, 0.10206072f, 0.12060513f, -0.08293757f, -0.09534194f, 
    0.01062583f, -0.13225883f, 0.04804530f, -0.03372758f, -0.19678445f, -0.25526288f, -0.23496987f, -0.01909965f, 
    0.07114648f, 0.21292096f, -0.07050730f, -0.24789850f, -0.29414871f, 0.03924129f, -0.44818872f, 0.06760278f, 
    0.19151720f, -0.04422211f, 0.08234943f, -0.43669736f, 0.20562847f, -0.02990747f, 0.09109031f, -0.25421357f, 
    -0.28585365f, 0.02525810f, 0.30486599f, 0.09064456f, 0.33058053f, -0.44347596f, 0.28504151f, -0.13155256f, 
    0.06824908f, 0.12725760f, 0.10232531f, 0.08066960f, -0.07384063f, -0.44702131f, -0.00901060f, -0.30061549f, 
    -0.02231827f, 0.11869784f, -0.03454042f, -0.19526674f, 0.19868343f, 0.17116088f, -0.05809241f, -0.21639512f, 
    -0.23043495f, -0.27736884f, -0.14700210f, 0.02956716f, 0.07218477f, 0.02897278f, -0.06959647f, -0.02543827f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.01957220f, 0.12337318f, -0.03793851f, 0.03285630f, -0.00142564f, -0.10035865f, -0.07521086f, -0.12251487f, 
    -0.09707349f, 0.13673919f, 0.13131583f, -0.06306390f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
