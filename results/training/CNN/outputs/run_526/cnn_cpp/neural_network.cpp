#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.59075129f, 0.12802736f, -0.36200759f, -0.55182540f, -0.66441536f, 0.16110870f, 0.71695471f, 0.47621280f, 
    0.02468657f, 0.35193795f, -0.34351340f, 0.12135840f, -0.23493287f, -0.03885960f, -0.42617869f, 0.24231599f, 
    -0.01999314f, -0.07895827f, -0.23703280f, -0.04775726f, -0.15830883f, -0.06748503f, 0.16770147f, -0.15869048f, 
    0.08514333f, 1.02779889f, 0.10468126f, -1.06229270f, 0.67522299f, 0.09833216f, -0.67750949f, 0.44621187f, 
    0.16890150f, 0.12585483f, -0.23800495f, 0.29756817f, 0.11002403f, 0.22048993f, -0.30854553f, 0.17273657f, 
    0.21182835f, -0.27066362f, -0.33358818f, -0.39746997f, -0.13035682f, -0.10258891f, -0.11669300f, -0.22039676f, 
    0.14433163f, -0.08610076f, 0.04579449f, -0.15804455f, -0.44285867f, -0.47660115f, 0.07343644f, -0.01609962f, 
    0.35178685f, -0.01941901f, 0.13368016f, -0.59206957f, -0.26224002f, -0.10791528f, -0.47603095f, -0.16199614f, 
    -0.49535614f, -0.08177783f, 0.27373251f, 0.40129092f, 0.22428906f, -0.03395150f, 0.31321797f, -0.18918400f, 
    -0.00437291f, 0.43473238f, 0.42457700f, 0.04931032f, -0.45113936f, -0.58313847f, -0.50421917f, -0.32611135f, 
    0.19469441f, 0.74848497f, -0.20080535f, 0.32699552f, 0.59185612f, -0.09095135f, -0.40225497f, -0.45132142f, 
    -0.20905811f, -0.04561449f, -0.00878143f, 0.23872890f, -0.10306827f, 0.13198827f, -0.20832014f, -0.08299423f, 
    0.14088257f, -0.03585118f, -0.13606952f, -0.16541076f, 0.24732599f, 0.29915085f, 0.61289465f, 0.95384514f, 
    0.08415110f, -0.40984470f, 0.17587541f, 0.23007309f, 0.40525779f, 0.21561716f, -0.31499895f, 0.05495019f, 
    -0.20856398f, -0.01483440f, -0.36524570f, -0.34508818f, -0.04937414f, -0.13986981f, 0.04599607f, -0.15585078f, 
    -0.31615770f, 0.26561248f, -0.27946502f, -0.23173627f, 0.02426643f, 0.87705648f, -0.64377809f, 0.81362581f, 
    0.16620415f, 0.12013972f, 0.76270765f, 0.10122848f, 0.34454104f, -0.29232204f, -0.25435466f, -0.18557326f, 
    -0.15285334f, -0.11999266f, -0.00905644f, 0.01771871f, 0.08882275f, 0.31982410f, 0.14670967f, 0.17290676f, 
    0.14626467f, -0.14643399f, 0.05005582f, 0.14665231f, 0.19331184f, 0.13621211f, 0.06971850f, -0.39740798f, 
    0.24199015f, 0.17043163f, 0.62985438f, 0.16280302f, 0.82101601f, 0.43659410f, -0.34335443f, 0.41479743f, 
    -0.35250050f, 0.26472646f, 0.07925655f, 0.30598634f, -0.02539181f, -0.09222525f, 0.10825289f, 0.02960853f, 
    0.35799268f, 0.29749033f, 0.50836831f, 0.20201232f, 0.12564494f, -0.17076220f, 0.07028884f, -0.40108064f, 
    -0.81058818f, -0.62360060f, -0.65986335f, -0.49784812f, 0.00032323f, -0.61693031f, -0.39204815f, -0.41069028f, 
    -0.01418642f, 0.25876883f, 0.10690173f, 0.24095835f, 0.35329354f, -0.06374761f, -0.00705883f, 0.15334451f, 
    0.13332330f, 0.18907900f, 0.42076203f, 0.25247273f, 0.16282481f, -0.10752649f, -0.06446942f, 0.08869503f, 
    -0.88957989f, -0.56140471f, 0.32549492f, 0.22797628f, -0.39600194f, 0.02473664f, 0.50128055f, -0.38640547f, 
    0.06269750f, -0.17254740f, -0.33501884f, 0.48126063f, -0.08690374f, 0.55525851f, 0.28649172f, -0.51246578f, 
    -0.27633816f, 0.00507477f, -0.34625810f, -0.55841535f, 0.36510327f, 0.14626215f, -0.08988391f, 0.20914838f, 
    0.19234191f, 0.15940106f, -0.54851586f, 0.25681984f, -0.40237468f, -0.38744265f, -0.68612874f, 0.61194402f, 
    -0.21743180f, -0.05939624f, 0.22808917f, -0.02969638f, -0.38134754f, -0.36745811f, -0.28209591f, 0.02145742f, 
    -0.44161859f, -0.46565107f, -0.51124167f, -0.24460946f, -0.40363106f, 0.27015480f, 0.00076425f, -0.04655138f, 
    0.03956801f, -0.01472779f, -0.31627542f, 0.81020588f, -0.07984566f, -0.90364987f, -0.23927118f, 0.14687306f, 
    0.04566049f, 0.16709672f, 0.33490404f, -0.33287185f, 0.06491745f, 0.30391586f, -0.02228706f, -0.17364591f, 
    -0.04324209f, 0.47658190f, 0.05536862f, 0.32846937f, 0.17329481f, 0.17159042f, 0.33493116f, -0.37700984f, 
    0.25066453f, -0.38883060f, 0.14772871f, -0.55602032f, -0.26131392f, -0.15190525f, -0.15037237f, 0.07711726f, 
    -0.49679485f, -0.17321897f, -0.65657282f, -0.10535212f, 0.06124605f, -0.45549825f, 0.43822250f, -0.45929837f, 
    -0.24860995f, -0.27784050f, 0.03869688f, -0.18214969f, 0.60619575f, 0.15214139f, -0.33813301f, -0.30172512f, 
    0.23852253f, -0.19794278f, -0.20597290f, -0.10149314f, -0.17617136f, 0.21456955f, -0.00719079f, -0.32262310f, 
    -0.61341667f, 0.63771522f, 0.07148708f, -0.15845487f, 0.60042804f, 0.65443683f, 0.43512985f, -0.40563217f, 
    0.07609899f, -0.03321495f, 0.09606263f, 0.24225731f, -0.38713145f, -0.08501177f, -0.04223502f, 0.30736408f, 
    0.18999712f, 0.12671717f, -0.12898538f, 0.12008139f, -0.16495283f, -0.41718352f, 0.88717949f, -0.12905107f, 
    0.38217050f, 0.33206943f, 1.05262268f, -0.32911023f, -1.05060172f, -0.13183713f, -0.49423331f, 0.23223424f, 
    0.32401633f, -0.02417078f, 0.31163055f, -0.41822606f, -0.18022572f, -0.16541679f, 0.24493554f, 0.04826200f, 
    0.07719030f, -0.14611319f, -0.29508945f, -0.09501418f, -0.06270620f, -0.15905741f, 0.83349353f, -0.05519930f, 
    -0.52350950f, 1.01056325f, 0.86996102f, -0.03573564f, 0.31779701f, 0.33672792f, 0.37426278f, -0.08364752f, 
    0.12951167f, -0.35602275f, -0.29344511f, -0.12824765f, -0.23260041f, -0.01553157f, -0.28331122f, 0.06383920f, 
    -0.00054597f, -0.23555821f, 0.37438813f, -0.04078747f, 0.15643601f, 0.08395705f, -0.00328502f, -0.92482233f, 
    -0.02926233f, -0.26958981f, -0.07141232f, 0.14049448f, 0.67404288f, 1.11235571f, 0.12564225f, 0.10253590f, 
    0.55847526f, 0.05775390f, -0.40550339f, 0.30888024f, -0.24545622f, 0.54177296f, -0.06664672f, 0.06479136f, 
    -0.31815034f, 0.22360998f, -0.02018786f, -0.06495649f, -0.24477279f, 0.07176473f, 0.00866817f, -0.05855756f, 
    -0.26288903f, 0.70517159f, 0.16241480f, 0.57445240f, -0.83320302f, -0.38346115f, 0.56920135f, -0.49457791f, 
    -0.17513087f, -0.60397613f, 0.01062025f, 0.16097154f, -0.31997097f, -0.21946937f, 0.12346242f, 0.13367499f, 
    -0.20567431f, -0.11801244f, 0.18328863f, -0.17805202f, 0.22530496f, 0.10244107f, -0.07276154f, -0.13809885f, 
    -0.21350048f, -0.50322533f, -0.54404587f, -0.18084580f, 0.74801093f, 0.42445633f, 0.67633480f, 0.34217730f, 
    0.41789484f, 0.25336555f, 0.09546787f, -0.48527083f, 0.13556705f, -0.22842775f, 0.23426807f, 0.02196250f, 
    -0.08111344f, 0.13980554f, 0.00138352f, -0.34383100f, 0.18450646f, -0.34915265f, 0.20252565f, 0.17915976f, 
    -0.07320675f, -0.36678973f, -1.14640391f, -0.41161564f, 0.32450891f, -0.49007601f, 0.22159326f, 0.77923495f, 
    -0.22716312f, 0.09666971f, 0.35981938f, -0.21474814f, 0.28662670f, -0.06294580f, 0.12661354f, 0.42615905f, 
    0.22657974f, -0.12579481f, -0.12297626f, -0.19052915f, -0.20043157f, -0.25677237f, -0.02318302f, -0.08533661f, 
    -0.17406258f, -0.26231766f, -0.36751240f, -0.49059069f, -0.72047389f, -0.48111355f, 0.35243845f, 0.45564923f, 
    -0.26383734f, -0.35845113f, -0.57541317f, 0.17478395f, -0.21304460f, 0.34618866f, 0.31844339f, -0.02503878f, 
    0.25352183f, -0.22061718f, -0.26363951f, -0.06191096f, 0.36479077f, -0.11265056f, 0.00564309f, 0.02304991f, 
    -0.11684836f, -0.17423014f, 0.25723916f, 0.04320460f, 0.54457062f, -1.30149925f, 0.75906622f, 0.33683458f, 
    0.27806550f, 0.61868471f, -0.06295578f, 0.37238926f, 0.18388736f, 0.16878001f, -0.11944646f, -0.01752430f, 
    -0.28224695f, 0.45083961f, -0.22131638f, 0.23438953f, -0.10265459f, 0.03620804f, 0.01989004f, -0.17556366f, 
    0.02045040f, -0.18759704f, -0.09183317f, -0.33072579f, -0.08471662f, -0.41276148f, 0.38334978f, 0.53212446f, 
    0.24274188f, -1.00616980f, 0.33407626f, 0.40485620f, -0.57643896f, 0.23056000f, 0.63055170f, -0.25053456f, 
    -0.02222209f, 0.02939316f, -0.27821454f, -0.01698899f, -0.11202160f, -0.12856388f, -0.24000527f, -0.00830705f, 
    0.16099952f, -0.25834808f, -0.08207418f, 0.10470930f, -0.04990950f, 0.19266313f, 0.61005300f, -0.54020178f, 
    -0.19171546f, 0.28710991f, 0.89482677f, 0.87232310f, 0.34361374f, -0.19637290f, -0.34448567f, -0.51806927f, 
    -0.08901094f, 0.26740319f, 0.09044724f, -0.17904481f, 0.22754160f, 0.08748735f, 0.08621167f, -0.04024427f, 
    -0.03060382f, -0.34445745f, -0.21064924f, -0.18137780f, -0.12429304f, 0.31935591f, -0.09263381f, 0.83750910f, 
    0.31440756f, -0.39592665f, 0.55332947f, -0.49626905f, 0.01872015f, 0.26543191f, 0.17413533f, 0.68925864f, 
    0.50596368f, 0.11379182f, 0.28500590f, 0.07409310f, -0.01724373f, 0.01985350f, 0.10423163f, 0.20422015f, 
    -0.11619619f, 0.11672559f, 0.41253263f, -0.18900321f, -0.42914096f, 0.19483870f, -0.02670455f, 0.20353407f, 
    -0.42996064f, -0.31341460f, 0.14724609f, -0.08018392f, 0.75515407f, -0.62475479f, -0.34897923f, -0.62299556f, 
    -0.59769839f, -0.31511152f, 0.14202560f, 0.47205269f, 0.40767688f, -0.06015529f, 0.11831617f, -0.00424830f, 
    0.23027366f, -0.30249286f, 0.35399663f, 0.07530540f, -0.27674040f, 0.18483998f, -0.10853188f, -0.07979363f, 
    -0.07067297f, -0.86462700f, -0.65829003f, -0.38004476f, 0.22092263f, -0.50288838f, 0.16538219f, 0.68062878f, 
    0.28173599f, 0.09174615f, 0.28011069f, -0.21260980f, -0.01922082f, 0.26163456f, -0.13372557f, 0.01547805f, 
    -0.25684696f, -0.41696730f, 0.30526426f, -0.36633751f, -0.19907293f, 0.24013667f, 0.21112475f, 0.25246477f, 
    0.25950873f, -0.03127275f, -1.03446591f, 0.36577004f, 0.31114307f, 0.46115154f, -0.42768192f, 0.02353886f, 
    0.33571458f, -0.15966932f, 0.54887915f, 0.20780854f, -0.27251458f, -0.16511336f, 0.15604050f, -0.17643565f, 
    -0.09984456f, -0.44574007f, -0.04398609f, -0.06698296f, -0.34887922f, -0.24603617f, 0.22140273f, 0.38331458f, 
    -0.15223284f, 0.00678193f, 0.11855534f, -0.39467695f, 0.64834362f, 0.41044983f, 0.29387832f, 0.58115846f, 
    -0.31477985f, 0.06544419f, 0.43709803f, -0.64268732f, -0.30598813f, 0.30800903f, -0.26378027f, -0.11062928f, 
    0.12136564f, -0.10051551f, 0.37411276f, 0.40896147f, -0.27041095f, -0.02533539f, 0.49693698f, -0.37030077f, 
    -0.49199018f, -0.17060462f, 0.15165892f, 0.39699763f, -0.05071953f, 0.32558432f, -0.73393571f, -0.48319551f, 
    -0.13058060f, 0.63175815f, -0.45783815f, 0.35026264f, -0.16521960f, -0.52486968f, -0.26122093f, 0.18503067f, 
    0.32149515f, 0.19581297f, 0.06301480f, 0.02933254f, -0.51599139f, -0.15772958f, -0.22124806f, -0.09911067f, 
    0.12186549f, 0.07048196f, -0.05648416f, -0.23753309f, 0.19671007f, 0.67646366f, -0.27994204f, 0.17957999f, 
    0.65867478f, 0.28977570f, -0.41958028f, -0.34188569f, 0.35103199f, 0.71172667f, -0.38864061f, -0.35634014f, 
    -0.22124521f, -0.24191502f, -0.45191428f, -0.18964601f, -0.03744176f, -0.16431785f, -0.04607689f, 0.41882893f, 
    0.30393210f, 0.06993264f, 0.24935880f, -0.26679114f, -0.00349798f, -0.32860491f, -0.89292395f, 0.87612844f, 
    0.46986181f, -0.92165691f, -0.19671968f, 0.48529759f, 0.37130386f, 0.17577624f, 0.66837329f, 0.57120556f, 
    -0.19960664f, 0.10915013f, -0.24415207f, -0.24724196f, -0.53485703f, -0.01735536f, 0.05899333f, -0.12046932f, 
    -0.07426360f, 0.02062009f, -0.05293499f, 0.11072790f, 0.08548623f, 0.05276071f, 0.08897809f, -0.38719493f, 
    0.36508721f, 0.56342322f, 0.12207307f, 0.55537629f, 0.36483812f, 0.33389172f, 0.88871741f, -0.50768125f, 
    -0.59892017f, -0.30331904f, -0.37195289f, 0.19461718f, 0.29208714f, -0.08518678f, -0.12283000f, 0.05480305f, 
    0.29351953f, 0.12005625f, 0.14893132f, -0.00825763f, 0.24814747f, 0.00473629f, 0.32328752f, 0.06635674f, 
    0.73321253f, 0.22123270f, 0.74927306f, 0.71529013f, 0.52329087f, -0.52641094f, 0.05406893f, -0.53080356f, 
    0.12076687f, -0.38156742f, 0.29406697f, -0.15940025f, -0.05458580f, 0.12028747f, 0.05109935f, -0.22608854f, 
    -0.10285619f, 0.14041993f, -0.03797875f, -0.10768039f, -0.00418599f, 0.35642120f, 0.25899664f, 0.03134998f, 
    0.17369418f, 0.93940938f, 0.84453112f, 0.68069881f, -0.39268723f, -0.79348212f, -0.20187432f, 0.57997817f, 
    -0.35761908f, -0.29605755f, -0.22967336f, 0.32488441f, 0.37961611f, -0.11045233f, -0.09767485f, -0.24103369f, 
    0.02920458f, -0.04517575f, 0.29472968f, 0.30009374f, -0.08322246f, -0.22831555f, -0.02852806f, -0.06937727f, 
    -0.07917047f, 0.25084376f, -0.69295180f, 0.17398416f, -0.49326244f, -0.71825212f, -0.37385771f, 0.53802425f, 
    0.41625023f, -0.00715620f, 0.52592993f, 0.49948001f, -0.15344517f, -0.11973214f, -0.05417160f, -0.21564104f, 
    -0.25706416f, -0.02344132f, 0.01783505f, -0.03327730f, 0.33543885f, -0.13514902f, -0.21593963f, -0.47986773f, 
    -0.26912114f, -0.21942095f, 0.23950741f, 0.07404418f, -0.90807259f, -0.51238686f, -0.23057732f, 0.04014961f, 
    -0.26505345f, -0.17807388f, -0.39412719f, 0.52258730f, 0.42410398f, 0.30297387f, -0.33540204f, 0.16519359f, 
    -0.02579559f, -0.39162973f, 0.08286852f, 0.24365184f, 0.05763386f, 0.17806382f, 0.18044154f, -0.03512883f, 
    -0.14484882f, -0.17726359f, 0.03365967f, 0.33302683f, 0.88293654f, -0.05218911f, 0.16277052f, 0.75156069f, 
    0.71591979f, 0.16738625f, -0.36486828f, 0.07993057f, 0.20476738f, -0.02223367f, -0.12647331f, 0.36325517f, 
    -0.39918438f, 0.16695194f, 0.21499167f, -0.13637285f, -0.00318124f, -0.11996397f, 0.10416731f, 0.08131383f, 
    -0.11449278f, -0.12451303f, -0.04725172f, -0.04081096f, 0.21346626f, -1.06069362f, 0.73625159f, -0.79903507f, 
    -0.45331690f, 0.63601542f, -0.26938695f, 0.44945154f, -0.02368758f, 0.21160385f, -0.13574402f, -0.04624880f, 
    -0.24051650f, 0.02353854f, -0.15867850f, 0.15399514f, 0.07421679f, 0.09885649f, -0.00000926f, 0.12663475f, 
    -0.22838563f, 0.25626245f, 0.31634167f, -0.03198783f, 0.20973326f, -0.01034062f, -0.76402396f, -0.20062922f, 
    0.02260399f, 0.58686876f, 0.57610786f, -0.46702754f, 0.85460168f, 0.45283693f, -0.59261823f, 0.61349499f, 
    -0.27104583f, 0.26932415f, 0.31364009f, 0.17256403f, 0.24396876f, -0.08754027f, -0.26528975f, -0.00840357f, 
    0.12929502f, 0.08871550f, -0.15654366f, -0.26387450f, 0.14772958f, 0.04853775f, -0.26910532f, 0.89501178f, 
    0.28934130f, 0.77716988f, 0.52909732f, -0.38283879f, 0.18149343f, 0.00369421f, -0.09705763f, -0.10746585f, 
    -0.09507957f, 0.00392181f, 0.05499547f, 0.08959230f, 0.28178871f, -0.17467244f, 0.39119613f, -0.04851177f, 
    -0.13502392f, -0.01655543f, 0.20824398f, 0.08576158f, 0.34573546f, 0.10584838f, 0.11955646f, 0.31153992f, 
    0.31265244f, 0.47490487f, 0.70932382f, 0.32419977f, 0.66010100f, 0.76640105f, 0.22005330f, -0.14396530f, 
    -0.32752442f, 0.31693411f, 0.18800725f, 0.28436702f, -0.22940201f, -0.04804007f, 0.08043587f, 0.36740306f, 
    -0.00066662f, -0.11816442f, -0.20257893f, -0.21698831f, 0.25019282f, 0.07707839f, -0.32951239f, -0.12862730f, 
    0.25478205f, -0.66938579f, -0.69668663f, -0.75160128f, -0.63472122f, -0.07055456f, 0.26767367f, 0.07355103f, 
    -0.28344053f, 0.29337379f, 0.56585532f, 0.26108795f, -0.15895018f, 0.33095670f, -0.14352047f, -0.05094279f, 
    0.10757183f, 0.10720737f, 0.31104666f, 0.07728479f, -0.11527300f, -0.16300789f, -0.12122643f, -0.04667282f, 
    0.29204732f, -0.08769842f, -0.40602255f, -0.82631660f, 0.30682543f, 0.71831715f, -0.71114242f, -0.18451424f, 
    0.23265807f, 0.53657144f, -0.14055933f, -0.15672378f, -0.10495253f, -0.12582052f, -0.50539201f, 0.09123864f, 
    0.24382316f, 0.25396007f, 0.10259917f, 0.01702830f, -0.21743385f, 0.13183364f, -0.20109016f, -0.47267231f, 
    0.39795563f, -0.16908009f, 0.23932549f, -0.60575944f, 0.51514864f, 0.70028996f, -0.46766508f, -0.66417938f, 
    -0.32966742f, -0.10628732f, -0.45241988f, -0.24941275f, -0.18085997f, 0.27118698f, 0.54253286f, 0.19826977f, 
    0.04941279f, 0.26522562f, -0.36802247f, -0.03328965f, 0.08223217f, 0.07142603f, 0.45654881f, 0.30764055f, 
    0.10233697f, -0.17148432f, 0.27794781f, 0.26128161f, 0.73349917f, -0.47285965f, 0.12468790f, -0.54342628f, 
    -0.58418697f, 0.43402809f, 0.23521857f, -0.11680873f, 0.18647721f, -0.05155892f, -0.00857834f, 0.26591152f, 
    0.15899998f, 0.17376150f, 0.16211922f, -0.13193636f, 0.19823751f, 0.41743237f, 0.12501127f, 0.09229400f, 
    0.09314425f, 0.03564479f, 0.21870655f, 0.46046314f, -0.06852197f, -0.28545558f, -0.61767828f, -0.10157230f, 
    -0.38592118f, -0.66684711f, 0.17528212f, -0.00748354f, 0.55670023f, 0.10289797f, 0.21723175f, 0.40813848f, 
    0.18738385f, -0.42131534f, 0.23225656f, -0.32126361f, 0.17964742f, 0.31067491f, 0.02569588f, -0.22430257f, 
    0.17304011f, -0.22890000f, -0.09701689f, 0.00085545f, -0.35724202f, -0.26666099f, -0.33147898f, 0.56931698f, 
    -0.52731359f, -0.75588059f, -0.22524844f, 0.15848951f, -0.37668949f, -0.25379902f, 0.58451796f, -0.21980177f, 
    -0.26211673f, -0.45361543f, -0.53360462f, 0.30480313f, 0.14679845f, -0.27069473f, 0.35995537f, -0.42144829f, 
    0.04593938f, 0.03122695f, -0.31874391f, -0.22887063f, -0.09966771f, -0.08962671f, -0.18042451f, -0.85078245f, 
    -1.06602907f, -0.86527067f, -0.08772619f, 0.35846895f, -0.61707222f, 0.57665616f, 0.63408965f, -0.06958890f, 
    -0.25155643f, 0.47075680f, -0.09339785f, 0.12194679f, 0.09103880f, 0.31975392f, -0.01982152f, 0.08005814f, 
    -0.08063298f, -0.28831267f, -0.05504711f, -0.10543155f, -0.24211989f, -0.07800242f, 0.03975915f, 0.15074159f, 
    -0.92098731f, 0.72378397f, 0.55328751f, 0.07929090f, 0.37438539f, -0.82337129f, 0.96133214f, -0.35814112f, 
    -0.57525480f, 0.01758420f, -0.17020673f, 0.24113868f, 0.37215254f, 0.07363110f, 0.20277964f, 0.15927440f, 
    -0.24529813f, 0.27044797f, -0.12438228f, -0.12103425f, 0.21678713f, 0.22753361f, 0.05432175f, 0.14323439f, 
    -0.13518099f, 0.95346421f, 0.01226160f, 0.22226463f, -0.72544140f, -0.41419747f, 0.20655738f, -0.55994076f, 
    -0.19513120f, 0.50579661f, 0.09460308f, 0.07679345f, 0.35174534f, -0.17194594f, 0.03820283f, -0.15261149f, 
    -0.17331511f, -0.23671299f, -0.04860968f, -0.11319370f, -0.05433201f, -0.01910469f, 0.39282981f, -0.06135112f, 
    0.09644984f, 0.10965968f, 0.88142908f, -0.26543373f, 0.31624877f, 0.25493997f, 0.78009391f, 0.24097455f, 
    0.46960670f, 0.27278447f, -0.13366917f, 0.52725750f, -0.24463178f, -0.19482395f, -0.10710599f, 0.19838615f, 
    -0.29977760f, -0.17850021f, -0.15081355f, 0.06381495f, 0.09808439f, -0.26880887f, 0.17334810f, 0.05422481f, 
    -0.17512619f, -0.09735355f, 0.12012667f, -0.62049538f, 0.49784380f, -0.33689314f, -0.27610093f, -0.48629257f, 
    0.43188319f, 0.41489533f, -0.67746228f, 0.18047786f, -0.49151438f, 0.14220941f, -0.56150573f, 0.34107929f, 
    0.25013283f, 0.22915812f, -0.10012287f, -0.48320395f, 0.14160566f, -0.47466767f, 0.13781486f, 0.16029802f, 
    -0.33048818f, 0.38875940f, 0.35445568f, -0.00392398f, -0.20542312f, -0.49739093f, -0.19202369f, -0.37391719f, 
    -0.45213735f, -0.09337467f, -0.75558943f, -0.39576811f, -0.04207067f, -0.52164304f, -0.52525175f, 0.05114011f, 
    -0.06545851f, 0.09243933f, -0.39914778f, -0.37957832f, -0.14790711f, -0.06484190f, 0.23629200f, 0.14074521f, 
    0.22204888f, 0.20481385f, -0.15783998f, 0.34929046f, 0.13552983f, -0.76331824f, -0.35981554f, 0.58463079f, 
    0.46353132f, 0.18582781f, 0.37612206f, 0.07927280f, 0.38668191f, 0.21598086f, -0.18316512f, -0.13643229f, 
    -0.01400865f, -0.21237274f, -0.31426439f, -0.48151594f, 0.16594322f, 0.24317473f, -0.42595693f, 0.30067179f, 
    0.12015496f, 0.55536836f, 0.18599738f, 0.00297028f, -0.03772601f, 0.09846167f, 0.67524719f, 0.68450415f, 
    0.43245617f, 0.54656148f, 0.39244741f, 0.45206520f, 0.34516680f, 0.09138570f, -0.22116840f, 0.01131337f, 
    0.08991158f, 0.29932570f, 0.33249199f, -0.07411201f, -0.36840698f, -0.00882732f, -0.19122329f, 0.19860160f, 
    -0.15069780f, -0.21883723f, 0.09673499f, -0.20457923f, 0.35994893f, 0.04595592f, -0.20456263f, 1.05068815f, 
    0.39409325f, 0.07539309f, 0.51384819f, 0.58224976f, 0.00303078f, 0.38651606f, 0.03194330f, 0.23254545f, 
    -0.55018342f, -0.11898337f, -0.23877570f, -0.10526360f, 0.16776821f, -0.28092384f, -0.14475572f, -0.17984092f, 
    -0.13281934f, 0.18080041f, 0.17256314f, -0.04029370f, -0.16516031f, 0.06589311f, -0.01624021f, -0.02308952f, 
    0.91086084f, 0.06620938f, -0.11815231f, -0.79754704f, -0.71243238f, -0.56448841f, -0.36510730f, -0.18117316f, 
    -0.14637576f, 0.46947873f, 0.23913066f, -0.03618771f, -0.23860925f, -0.05686674f, 0.14025076f, 0.05978394f, 
    0.04555625f, -0.32444543f, -0.25184178f, 0.29742411f, 0.09933210f, 0.44629887f, 0.07852366f, -0.25615698f, 
    -0.20287688f, 0.05780150f, -0.18310401f, 0.02804765f, 0.00905827f, 0.59943563f, -0.26996222f, -0.43907472f, 
    -0.60086465f, -0.38457248f, -0.14059851f, -0.08556935f, 0.25454846f, 0.34363383f, 0.09776728f, 0.10792561f, 
    0.37403145f, 0.19572735f, -0.18147501f, 0.21148762f, 0.49947283f, -0.31643373f, 0.15083334f, 0.38835242f, 
    -0.38793939f, 0.32032734f, 0.45651239f, 0.74092960f, 0.52098238f, -0.28161120f, -0.51565391f, 0.08348960f, 
    -0.89529961f, -0.11246772f, 0.00777192f, 0.17742002f, 0.37318015f, 0.02124937f, -0.03107354f, 0.35748428f, 
    -0.01399814f, -0.17426224f, 0.24397853f, -0.05677135f, -0.09014349f, 0.22738837f, -0.36464503f, 0.23198503f, 
    0.33937278f, -0.17554180f, 0.37362579f, -0.35558212f, -1.01197839f, -0.25548723f, 0.08257849f, 0.46250686f, 
    0.01638317f, 0.67770308f, 0.39152858f, -0.53942382f, 0.10307450f, -0.14655733f, 0.16145143f, -0.33940327f, 
    -0.07131668f, -0.32624289f, -0.32869381f, -0.30539557f, 0.17589276f, -0.28900221f, -0.08560299f, 0.03577803f, 
    0.14244805f, -0.19400431f, -0.09990092f, 0.14774987f, 0.85306782f, 0.82286340f, 0.67423654f, 0.70616031f, 
    0.17076381f, -0.54184550f, 0.17133978f, -0.31842050f, -0.44867224f, 0.27518135f, 0.27305654f, 0.07300001f, 
    -0.36786643f, 0.52685714f, 0.25698391f, -0.14513986f, -0.05759541f, 0.42388049f, 0.29632586f, 0.00028316f, 
    -0.11217171f, -0.15678887f, -0.14452280f, 0.15913519f, 0.17091274f, 0.21611384f, 0.57753456f, -0.10103261f, 
    0.04157985f, 0.69629186f, -0.21252902f, -0.78216642f, -0.75554514f, -0.45777181f, -0.52792120f, 0.21027692f, 
    0.44007650f, 0.21367796f, -0.03037306f, -0.17068288f, 0.32787365f, -0.16709921f, 0.07365717f, -0.42336625f, 
    -0.17824335f, -0.13322285f, -0.01298974f, 0.02948710f, 0.38316938f, 0.05283676f, 0.58101511f, 0.72227103f, 
    0.79517633f, 0.69539183f, -0.19154331f, -0.40549678f, 0.13357624f, -0.71158665f, 0.08611238f, 0.28094062f, 
    0.12296212f, -0.11796984f, 0.18524854f, 0.15873277f, 0.31120509f, -0.10581177f, 0.05853911f, -0.01733160f, 
    -0.00441701f, -0.22542472f, -0.01537942f, -0.05785789f, -0.19312367f, 0.14150739f, -0.32906115f, -0.34931877f, 
    -0.21492635f, 0.09889580f, -0.33439592f, 0.09772240f, -0.55018842f, -0.26494554f, 0.71334577f, 0.56847966f, 
    -0.75825006f, -0.12014922f, -0.55587548f, 0.14047244f, -0.32088557f, -0.03069024f, 0.41468963f, 0.14368571f, 
    0.01842224f, -0.26051834f, -0.37618259f, -0.06003558f, -0.04260563f, 0.36427182f, 0.16536729f, -0.04905550f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17926013f, 0.12104814f, -0.06938133f, -0.00840456f, 0.07126532f, 0.19477330f, 0.19758859f, 0.10656830f, 
    0.10984009f, 0.03096365f, 0.22830012f, -0.12488958f, 0.10545026f, -0.04979263f, 0.12224919f, -0.13191935f, 
    0.28436604f, 0.15716615f, 0.24874687f, 0.46720636f, 0.22300750f, 0.01564479f, 0.03623331f, 0.26308849f, 
    0.27019161f, 0.01477647f, 0.04247999f, -0.04337095f, 0.16990125f, -0.12231765f, -0.08979962f, 0.18167399f, 
    0.02718724f, 0.17181665f, 0.06034271f, 0.29140031f, 0.08426388f, 0.18439010f, 0.33179966f, 0.26562211f, 
    0.31756842f, 0.22904587f, -0.01313583f, 0.13873950f, 0.12248839f, -0.02461382f, 0.27812299f, 0.13488644f, 
    0.02539125f, 0.17133997f, 0.19738278f, 0.05602016f, 0.03547304f, 0.13902214f, 0.25546810f, 0.13757101f, 
    0.12605233f, 0.26644570f, 0.02301296f, 0.15163049f, 0.01418092f, 0.25273204f, 0.10374782f, 0.13690449f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19917449f, 0.18584254f, 0.13591760f, -0.37619421f, 0.03495518f, 0.06130315f, 0.04179873f, 0.06461111f, 
    -0.02454664f, 0.03136312f, -0.02228503f, 0.03709240f, -0.11026998f, 0.10630115f, 0.00729288f, 0.16993631f, 
    -0.06547089f, -0.03513770f, -0.04959865f, 0.05116483f, 0.04987384f, 0.09502024f, 0.15036254f, -0.01562102f, 
    -0.22785926f, 0.14696306f, 0.03301219f, -0.17729180f, -0.01373761f, 0.02161164f, -0.03340992f, 0.16896254f, 
    -0.06970881f, 0.07056697f, 0.07150897f, 0.11916188f, 0.21184605f, 0.06012329f, 0.14850619f, -0.31677634f, 
    0.05982206f, 0.07146621f, 0.05655831f, -0.07759061f, 0.00514149f, 0.09481769f, 0.06329039f, 0.10522941f, 
    0.06211754f, -0.00701498f, -0.16671559f, 0.23921445f, -0.06961779f, 0.01684805f, 0.04402027f, -0.06956908f, 
    0.02090009f, -0.01288866f, -0.07652145f, 0.02222576f, 0.12117221f, -0.00968101f, -0.03766784f, 0.08970413f, 
    -0.08940654f, -0.02500206f, 0.01912211f, 0.03076917f, -0.11878823f, 0.00129376f, 0.04195553f, 0.05339115f, 
    -0.12496265f, -0.06185301f, -0.00466960f, -0.07387091f, -0.05262707f, 0.08612176f, -0.04426915f, 0.00944607f, 
    0.08451217f, 0.03067118f, 0.01644474f, 0.08037204f, -0.27150437f, -0.43221834f, 0.02154146f, -0.00957332f, 
    -0.05141433f, 0.02932475f, 0.13090344f, 0.00511676f, -0.04138673f, -0.05646976f, 0.02742986f, 0.01478803f, 
    -0.24616958f, -0.00867816f, 0.02360514f, 0.14305781f, 0.05375242f, 0.00517425f, 0.07893001f, 0.11242998f, 
    0.03177346f, 0.01930626f, -0.05076751f, 0.00330975f, -0.16172113f, -0.16643520f, 0.01516859f, 0.05050887f, 
    0.05878871f, 0.03132439f, -0.08100807f, -0.03156753f, 0.03608635f, 0.01562798f, -0.03090934f, 0.10614935f, 
    -0.01085802f, 0.18389413f, 0.01603009f, -0.34397042f, -0.02976149f, -0.05294396f, 0.02604858f, 0.00454376f, 
    -0.08369275f, -0.03995310f, 0.07103299f, -0.01104272f, -0.10866126f, -0.41239533f, 0.02026430f, 0.10895101f, 
    -0.13137522f, -0.02495305f, 0.03840799f, -0.01357240f, -0.01699702f, 0.10241307f, 0.01641404f, -0.05601699f, 
    0.22580038f, -0.07580985f, -0.23404332f, -0.10230038f, -0.02805292f, 0.14455017f, -0.01419639f, -0.05616457f, 
    -0.07292257f, -0.06300039f, 0.05374407f, 0.07771529f, -0.15975824f, 0.08105360f, -0.02620715f, -0.08737575f, 
    -0.14281771f, -0.11936304f, 0.11324000f, -0.10773867f, 0.08968870f, 0.08119711f, -0.08184046f, 0.06335738f, 
    0.01783991f, 0.16068365f, 0.02176715f, 0.29706523f, -0.09494893f, 0.10180511f, -0.10195857f, -0.03393813f, 
    -0.09715927f, -0.03983599f, 0.01820426f, -0.10928027f, 0.37305215f, -0.01078062f, 0.14831239f, -0.15721957f, 
    -0.00244095f, 0.19327888f, -0.19591229f, -0.01529922f, 0.09324249f, -0.00901351f, -0.02003192f, 0.05204678f, 
    -0.14910145f, 0.28816494f, 0.12504244f, -0.09125119f, -0.03811784f, 0.02730943f, -0.04180147f, -0.12524235f, 
    -0.09274558f, 0.03047224f, -0.06817950f, -0.15366381f, -0.18548100f, 0.05439896f, -0.00921913f, 0.10641183f, 
    0.14139539f, 0.08773255f, -0.12366017f, -0.00204890f, -0.07351722f, -0.11473183f, 0.09908602f, -0.01891140f, 
    -0.13339271f, -0.20674291f, 0.12505361f, 0.01356776f, -0.00719697f, 0.01492636f, -0.04436214f, -0.03224720f, 
    -0.04798528f, -0.03816019f, 0.06806210f, -0.04800959f, -0.20470616f, -0.16400911f, -0.04488541f, 0.10604651f, 
    -0.06751792f, -0.05354114f, 0.10475085f, -0.02517562f, 0.06958748f, -0.09177169f, -0.09931612f, -0.01158493f, 
    0.04914219f, -0.13021299f, -0.02297161f, 0.20578805f, -0.02036560f, 0.00275456f, 0.10829498f, -0.00217441f, 
    0.02524940f, 0.09170804f, -0.17183159f, -0.15631846f, 0.35844982f, 0.12315997f, 0.03959240f, 0.17495544f, 
    -0.14057030f, 0.06210620f, -0.07924627f, -0.04399728f, -0.03309701f, 0.02606493f, 0.04686960f, 0.05453310f, 
    0.10282387f, -0.13509674f, 0.10346714f, 0.11525992f, -0.00063290f, -0.03376034f, -0.06529611f, -0.01170347f, 
    -0.10441000f, 0.03016340f, 0.08791079f, -0.21694094f, -0.05136914f, -0.07220224f, -0.17478923f, 0.06234442f, 
    0.01754140f, -0.15255401f, -0.02885119f, -0.00028205f, 0.08574364f, 0.01568186f, -0.00680636f, 0.01804784f, 
    0.01605356f, -0.16843706f, -0.01883026f, 0.04322879f, -0.03281325f, 0.08978178f, -0.01292279f, -0.04199615f, 
    -0.14583980f, 0.00455424f, -0.05180771f, -0.03039122f, 0.15583748f, 0.14410087f, -0.11163598f, -0.09085238f, 
    0.02542375f, 0.04247580f, -0.00052224f, 0.00945037f, -0.03507867f, -0.04244056f, 0.04190298f, 0.05146153f, 
    0.30937526f, 0.13998018f, -0.03581432f, 0.18018602f, -0.00936652f, 0.04095495f, 0.01465643f, -0.09188603f, 
    0.02688600f, -0.04379243f, -0.07159533f, 0.01246819f, -0.19044103f, 0.06673725f, 0.05147475f, -0.09867174f, 
    0.10555065f, 0.00416920f, 0.11506879f, 0.07884324f, 0.08402523f, 0.04582340f, 0.15646906f, -0.11805528f, 
    0.08636260f, -0.32265365f, 0.01835498f, -0.18484157f, -0.04169357f, -0.06184133f, 0.04632838f, 0.00499061f, 
    0.00425415f, -0.00894599f, -0.00932913f, 0.07892504f, 0.21195957f, -0.03504957f, -0.01772546f, 0.20718835f, 
    0.01883093f, 0.03475263f, -0.04012637f, -0.02953561f, 0.11328095f, -0.17742285f, 0.08294019f, 0.09295272f, 
    0.23385496f, 0.00158046f, 0.05235716f, -0.02470734f, -0.01199364f, -0.01452382f, 0.12280176f, -0.19283260f, 
    -0.02129833f, -0.02272949f, -0.02198130f, 0.01046494f, -0.39328673f, 0.12358368f, -0.00619126f, -0.04845767f, 
    -0.09043653f, -0.02264059f, 0.03169874f, -0.02244176f, 0.00873322f, -0.12437765f, -0.06473212f, -0.03594788f, 
    0.22336867f, 0.05259468f, -0.22793943f, 0.17734300f, -0.23929498f, -0.12989713f, -0.06581958f, 0.00484066f, 
    0.00150594f, -0.04824021f, -0.13854976f, -0.00270200f, -0.15842175f, 0.24584366f, 0.05579481f, -0.08963884f, 
    0.02622297f, 0.07051130f, -0.03288169f, 0.09419987f, -0.03811891f, 0.02668273f, -0.06767384f, -0.06893044f, 
    0.32739800f, 0.17079821f, -0.00340267f, -0.19922259f, 0.07845207f, 0.01727243f, 0.01720008f, 0.01049874f, 
    0.04344564f, -0.01996343f, -0.07573337f, -0.00089582f, -0.02074028f, 0.00673627f, -0.02581148f, 0.03559908f, 
    0.00121723f, -0.00258530f, 0.00513802f, -0.10147207f, 0.02363058f, -0.03645568f, -0.00949828f, -0.01240834f, 
    0.21227607f, -0.17590180f, 0.04426072f, 0.15504690f, -0.11214398f, -0.08603189f, -0.03271068f, 0.04364753f, 
    -0.02904406f, 0.00568857f, 0.14413612f, -0.08282156f, 0.22678587f, 0.26927093f, 0.15600464f, -0.21111916f, 
    0.04801345f, 0.01217443f, -0.02632930f, 0.00800642f, -0.09887821f, -0.02819775f, -0.03515520f, 0.04588996f, 
    -0.22461559f, 0.00403319f, -0.05113795f, 0.02540153f, -0.05088991f, -0.03734426f, -0.19415109f, -0.02815777f, 
    0.12134283f, -0.04228294f, 0.05533544f, 0.02489839f, 0.05259374f, -0.02990643f, -0.13671237f, 0.11628582f, 
    0.02267176f, -0.07982992f, -0.03590754f, 0.04144261f, -0.02458462f, 0.01660617f, -0.15148591f, 0.04107490f, 
    -0.03554348f, -0.08861181f, 0.13313955f, -0.03957971f, -0.07969325f, -0.10038787f, 0.11836966f, -0.00614669f, 
    -0.01122666f, 0.02808579f, 0.01057130f, -0.05260647f, 0.13656373f, -0.06056381f, -0.03679732f, -0.26366851f, 
    0.09211017f, 0.02052800f, 0.00506261f, -0.01820527f, -0.00979306f, -0.03697521f, -0.02351491f, -0.03256002f, 
    -0.04917514f, 0.08552974f, -0.13258429f, 0.20799047f, -0.05707271f, 0.11420746f, 0.05687911f, -0.03331572f, 
    0.12745580f, 0.01625497f, 0.00803170f, -0.01348096f, -0.38692251f, 0.14144051f, 0.17685300f, 0.15402342f, 
    0.00289975f, 0.06571636f, 0.02824651f, 0.00732688f, 0.03763617f, 0.02302315f, 0.00055923f, 0.02622274f, 
    0.06528179f, -0.04238030f, 0.08944548f, -0.14063920f, 0.00109996f, 0.07822850f, -0.10714871f, -0.08799659f, 
    -0.19459903f, 0.04054524f, -0.06473818f, 0.03912044f, 0.01509507f, -0.07495857f, -0.07927302f, -0.17688148f, 
    -0.02503770f, 0.12841560f, 0.07142265f, 0.00158261f, -0.10024790f, -0.00183888f, 0.04808844f, -0.11571611f, 
    0.04982289f, -0.00576468f, -0.02566433f, -0.31107229f, 0.04224539f, -0.02963099f, 0.01295066f, 0.01761379f, 
    -0.09994767f, 0.00155185f, -0.06324606f, -0.07706723f, -0.48494700f, 0.26241294f, -0.09598070f, 0.05496160f, 
    0.01648204f, -0.01529341f, -0.09540520f, -0.04970356f, 0.04152366f, 0.03754072f, -0.10218179f, 0.06835820f, 
    -0.14711787f, -0.05233487f, 0.05615963f, 0.03835604f, 0.01025791f, -0.06108369f, 0.06026120f, -0.05259818f, 
    0.05515135f, 0.02269157f, 0.01008726f, -0.00792634f, 0.17393877f, -0.09805731f, 0.03006274f, -0.35250998f, 
    0.03451500f, 0.05631289f, -0.00748160f, -0.01100283f, -0.02921270f, -0.05246190f, -0.01204280f, -0.01698782f, 
    0.13573793f, -0.05368111f, 0.03332096f, 0.07723399f, -0.03029663f, -0.03917525f, 0.01101089f, 0.06151525f, 
    -0.12588419f, 0.10913095f, 0.00019096f, -0.04719335f, 0.34013256f, 0.04336241f, 0.04776667f, -0.14617434f, 
    -0.25034073f, 0.02521272f, 0.02054536f, -0.09395068f, -0.01118736f, -0.02195672f, 0.01862290f, -0.01039393f, 
    -0.27193546f, -0.18031015f, 0.04908789f, 0.05158876f, 0.05507455f, 0.09892150f, 0.11390156f, -0.02000839f, 
    0.02925763f, -0.00652457f, -0.16591586f, -0.05074401f, -0.25529149f, 0.03962954f, 0.04868804f, 0.15201850f, 
    -0.02770960f, 0.04693589f, 0.03394384f, 0.04379471f, -0.02904073f, -0.03637833f, 0.00552003f, -0.10338607f, 
    0.02223486f, 0.02304611f, -0.10351192f, -0.07692369f, -0.15524834f, 0.00569886f, -0.01720187f, 0.03334383f, 
    -0.04238455f, 0.09695919f, -0.04047266f, -0.01745881f, 0.09192510f, 0.03895668f, -0.07234664f, 0.00518473f, 
    -0.21966155f, 0.01937836f, -0.09830308f, 0.09613171f, -0.01278058f, -0.05680081f, -0.00232413f, -0.03852778f, 
    -0.25383845f, -0.10082208f, 0.07504126f, -0.12755369f, 0.00187441f, 0.00498246f, 0.06238295f, 0.07281680f, 
    -0.12191146f, -0.12062028f, 0.06272521f, 0.10637684f, 0.04991672f, -0.25211269f, -0.01332586f, -0.10207584f, 
    -0.06420397f, 0.06940067f, -0.07928908f, -0.01156122f, -0.04867305f, -0.05968982f, -0.05757262f, -0.07734359f, 
    -0.08018001f, 0.02462339f, 0.10278347f, -0.09241626f, -0.03579641f, -0.00289380f, 0.04560536f, 0.06731673f, 
    -0.02997741f, -0.03835512f, -0.05857757f, 0.05555472f, -0.29665974f, 0.07178978f, 0.04766057f, -0.12788287f, 
    -0.11079396f, -0.05384513f, 0.02462214f, 0.05258168f, -0.15544428f, -0.03811841f, 0.01736834f, 0.00673599f, 
    0.09647200f, 0.14040469f, -0.08480816f, 0.04631412f, -0.27121633f, -0.13520630f, 0.05407006f, 0.04434549f, 
    -0.01092034f, -0.02554449f, -0.10103408f, -0.01348632f, 0.07972687f, -0.00912363f, 0.23560026f, 0.02362921f, 
    -0.10511819f, -0.11126966f, 0.03321406f, 0.03379675f, 0.10768764f, -0.09435243f, -0.01873272f, -0.04446073f, 
    -0.00413073f, 0.00160898f, -0.16243935f, 0.06498770f, -0.10083782f, -0.16122478f, 0.05921927f, 0.04027858f, 
    -0.08860496f, 0.05362833f, -0.03753300f, -0.09109561f, -0.17725940f, 0.11925842f, 0.01088903f, -0.04523074f, 
    -0.03943952f, -0.04668838f, -0.07428031f, -0.12950948f, 0.01705484f, 0.09206448f, 0.02912984f, -0.08638988f, 
    -0.22861724f, -0.13165161f, -0.10072182f, -0.19766587f, 0.02041862f, -0.14933753f, -0.09865268f, -0.09694149f, 
    0.09380996f, 0.01462895f, -0.02787801f, -0.12102357f, 0.39722711f, -0.34948036f, 0.06214182f, 0.07831737f, 
    -0.10435626f, 0.09518143f, -0.04228037f, 0.02735835f, -0.07353976f, 0.02923099f, -0.25376889f, 0.00168653f, 
    0.07779527f, -0.11307862f, -0.10091270f, 0.00155083f, 0.01934525f, 0.06903490f, -0.10188398f, 0.01694333f, 
    0.14499636f, -0.01858525f, -0.04481627f, 0.02748455f, 0.14541666f, -0.10897132f, -0.12910579f, -0.18987684f, 
    0.04244733f, -0.18479097f, -0.06522684f, 0.03893824f, 0.08598673f, 0.03925543f, -0.11680849f, -0.16395171f, 
    0.13993511f, 0.06291659f, -0.04489330f, 0.27618682f, -0.01935337f, -0.03951907f, 0.05473345f, 0.01611718f, 
    0.02655655f, -0.06043947f, -0.01089768f, -0.18567061f, 0.07292267f, -0.00356826f, 0.09102762f, 0.01252645f, 
    -0.10080081f, 0.05917735f, -0.02310490f, -0.00384350f, 0.13518235f, 0.03938206f, -0.04934186f, -0.01361444f, 
    0.16924955f, 0.10154408f, 0.01095049f, 0.12197705f, -0.03491556f, -0.01747315f, -0.03348291f, 0.05646902f, 
    0.08656171f, 0.07886226f, -0.02434258f, -0.02324839f, 0.07318436f, 0.07470981f, 0.03897560f, 0.00590866f, 
    0.01571513f, 0.06279334f, 0.06031392f, 0.07014284f, -0.03274459f, 0.15681651f, 0.03048475f, 0.05497036f, 
    -0.00912581f, 0.09088963f, -0.20535137f, 0.06861550f, -0.10905144f, 0.00999930f, 0.05059141f, 0.10802472f, 
    0.01349816f, -0.23871055f, -0.12694079f, 0.02872325f, 0.09558858f, 0.03630819f, -0.19713539f, -0.04452403f, 
    0.05872588f, -0.05408968f, -0.00169822f, 0.06713551f, 0.06524441f, -0.02032000f, -0.26682454f, -0.17209937f, 
    -0.27312109f, -0.02809645f, -0.01783583f, -0.28260258f, -0.03902368f, 0.09908228f, -0.01072359f, 0.09222358f, 
    0.19166888f, -0.05497579f, 0.03938783f, 0.03101597f, 0.06570292f, 0.01599183f, -0.10599411f, -0.22098190f, 
    0.12034718f, -0.07640249f, -0.01100469f, 0.06216572f, -0.03153952f, -0.20227405f, -0.01971180f, -0.10974434f, 
    -0.18414669f, -0.00870716f, 0.04952289f, -0.06112941f, -0.01959694f, -0.10972717f, 0.01635296f, 0.04146744f, 
    -0.07259029f, 0.02910163f, -0.07839417f, 0.05046913f, -0.03469092f, -0.43879354f, -0.03033438f, -0.01706859f, 
    -0.03576338f, -0.03039601f, -0.13052504f, -0.07824457f, -0.03884521f, 0.02190077f, 0.05125964f, -0.08148657f, 
    0.13969806f, -0.12470476f, 0.09106755f, 0.24756119f, -0.07390539f, 0.06018746f, -0.03760627f, 0.04092722f, 
    0.09400815f, 0.05763514f, -0.06345782f, 0.07026410f, 0.00184793f, 0.05528767f, -0.07127520f, -0.05581396f, 
    0.11313020f, -0.01503971f, -0.01691596f, -0.14514285f, -0.01772538f, 0.12260846f, -0.13638367f, -0.02457722f, 
    0.02634614f, -0.21096683f, -0.30972433f, -0.07821757f, -0.01611364f, -0.04896170f, 0.07149926f, 0.06877292f, 
    -0.03472069f, -0.00679709f, -0.05560697f, 0.15175183f, 0.22196938f, 0.09398118f, -0.18134978f, 0.13991003f, 
    -0.03033856f, 0.01987571f, -0.04272784f, 0.00240959f, 0.05643947f, 0.09716219f, 0.10662699f, 0.06582469f, 
    -0.06448641f, 0.24068898f, -0.04360311f, 0.01792082f, 0.06877044f, -0.02107942f, -0.00398845f, -0.02669312f, 
    -0.10898285f, 0.02859803f, -0.09250294f, -0.07150605f, 0.04550447f, -0.07304677f, -0.20020054f, 0.04832862f, 
    0.07324760f, 0.04978034f, -0.04424784f, 0.11359178f, -0.04530782f, -0.19737120f, 0.02538713f, -0.02007636f, 
    0.20329629f, -0.02293373f, 0.05800730f, -0.02705317f, -0.02581641f, 0.15986522f, -0.09607046f, -0.07177270f, 
    0.11521679f, -0.09091653f, 0.11575314f, -0.04362361f, -0.31293553f, -0.05568421f, -0.06356163f, -0.06011242f, 
    0.06826721f, -0.15085681f, 0.04944593f, -0.18970431f, -0.02837479f, 0.02567939f, 0.09999917f, -0.03778101f, 
    0.09487774f, -0.18858492f, 0.03498477f, -0.18615790f, -0.00056970f, 0.03801110f, -0.10559429f, 0.06655525f, 
    0.02854559f, -0.06850445f, -0.10638557f, 0.12174615f, 0.35905996f, -0.07416974f, -0.01584831f, 0.07684087f, 
    -0.10087524f, -0.03294918f, -0.05796667f, -0.00961069f, -0.15623850f, 0.07514036f, 0.00890709f, 0.11663546f, 
    -0.10101738f, -0.14195244f, 0.02481545f, -0.09461120f, 0.02390770f, -0.01354313f, 0.07000295f, 0.07489766f, 
    0.03123665f, 0.13001665f, 0.06124120f, -0.05393359f, 0.05682561f, -0.03367436f, -0.07004418f, 0.04141248f, 
    0.10915200f, 0.05986624f, 0.00974893f, -0.09175956f, 0.02862129f, -0.08842573f, -0.03634857f, 0.07001316f, 
    -0.28369570f, 0.01264325f, -0.13433248f, 0.01787460f, 0.02423771f, 0.07391097f, 0.08602110f, 0.02882635f, 
    -0.10282879f, -0.07247439f, 0.05487308f, -0.11053465f, 0.04253080f, 0.07417824f, -0.09813136f, 0.07697947f, 
    0.06187176f, 0.10430219f, -0.03244704f, -0.02627024f, -0.09789675f, -0.01313389f, -0.10697105f, 0.09726816f, 
    -0.08022179f, -0.11490721f, 0.01640194f, -0.14602409f, -0.16652554f, -0.18669815f, -0.03510064f, -0.03871873f, 
    0.05029365f, 0.06617841f, -0.03444300f, -0.17766458f, -0.00136733f, -0.09206365f, -0.06201723f, 0.21897440f, 
    -0.04780877f, -0.04635190f, -0.02618590f, -0.03092476f, 0.05057156f, 0.02061864f, -0.27403343f, 0.09081741f, 
    -0.64834309f, 0.07700361f, -0.03542041f, 0.00650534f, 0.02159582f, 0.05185820f, 0.00725321f, 0.02946255f, 
    0.11441388f, -0.01143555f, 0.03499431f, -0.12746902f, 0.10886464f, 0.18474145f, -0.15767133f, 0.15250419f, 
    -0.04657932f, 0.04229645f, -0.00786759f, -0.01377517f, -0.03127528f, 0.13326657f, -0.02372017f, -0.05519160f, 
    0.11071710f, -0.15475109f, 0.15273896f, 0.30020359f, -0.09523669f, 0.08145598f, 0.06938647f, 0.03260604f, 
    0.03203738f, 0.00143429f, 0.05059516f, -0.03305113f, 0.24772692f, 0.00714955f, -0.10397972f, -0.04786694f, 
    -0.06012329f, -0.08229215f, -0.00769311f, -0.04967352f, 0.03699137f, -0.10174949f, 0.02764123f, 0.03594368f, 
    -0.16916738f, -0.08187789f, 0.04150088f, -0.10503509f, 0.11086328f, -0.00376254f, -0.02084380f, 0.01523008f, 
    -0.03311674f, -0.02302464f, 0.00193941f, -0.01598459f, 0.14515078f, -0.14165628f, -0.07885361f, -0.14733911f, 
    0.03904403f, 0.01834319f, -0.00868092f, 0.13850088f, -0.01581336f, -0.01495171f, 0.03524632f, 0.02254215f, 
    0.10696290f, 0.09334426f, 0.11657661f, 0.29318380f, 0.02991555f, -0.03671546f, -0.07567201f, 0.02155051f, 
    -0.07200608f, -0.02845548f, -0.11781646f, -0.01286054f, -0.06395672f, 0.06447051f, -0.22021233f, -0.40398335f, 
    0.06516521f, 0.01738095f, -0.01595213f, 0.06548399f, 0.21949118f, -0.01936459f, 0.03666273f, -0.00474883f, 
    0.05268829f, 0.09110734f, -0.05978888f, 0.05801039f, 0.01127463f, 0.02622102f, -0.01052127f, -0.03849622f, 
    -0.06135090f, 0.08398742f, -0.01634368f, 0.00296972f, 0.12125066f, 0.03850762f, 0.09485642f, 0.06059906f, 
    -0.10869335f, -0.06146951f, 0.03011470f, 0.05671451f, 0.02681812f, 0.04268625f, 0.09692036f, -0.02032591f, 
    0.18402262f, -0.04034494f, 0.07277926f, -0.05923737f, -0.24768314f, 0.09487926f, -0.00234982f, 0.00354744f, 
    -0.00551353f, -0.05389778f, -0.03635230f, 0.02074010f, 0.14967139f, 0.03363310f, 0.04054836f, -0.09134693f, 
    -0.01321696f, -0.02862849f, 0.12779087f, 0.02475140f, -0.00738419f, -0.09496790f, -0.02062497f, 0.05454457f, 
    -0.30511060f, 0.16795349f, -0.17346311f, 0.17474891f, -0.12790544f, -0.02213157f, 0.03532911f, -0.11268371f, 
    -0.03932776f, -0.00439381f, 0.03887633f, 0.03866397f, -0.48080444f, -0.03300818f, -0.05823470f, -0.07863550f, 
    -0.07081964f, -0.03055998f, 0.05165441f, 0.08988533f, -0.00625535f, 0.07518757f, 0.08853614f, -0.03403313f, 
    0.18959057f, -0.20173612f, -0.00941471f, -0.07328983f, 0.03837952f, -0.07051007f, 0.08840518f, -0.02811871f, 
    0.09034073f, 0.00127021f, 0.05602687f, -0.03273726f, -0.06477296f, 0.06025515f, -0.04752827f, 0.02824681f, 
    -0.05161123f, -0.09357949f, 0.10031297f, 0.05100586f, 0.05495252f, 0.03161876f, 0.03132793f, -0.02191140f, 
    -0.38323334f, -0.04852145f, 0.06960189f, -0.28159511f, -0.02443716f, -0.10197125f, 0.06153563f, -0.04910761f, 
    0.05483112f, 0.05992821f, -0.02798345f, -0.05392939f, 0.35043508f, 0.08260574f, -0.01420997f, 0.07966474f, 
    0.04800559f, 0.09324568f, -0.02082645f, 0.10911787f, -0.05900188f, -0.07041948f, 0.06270704f, -0.04594931f, 
    -0.20866472f, 0.13228720f, -0.03776764f, -0.28715807f, -0.08131075f, 0.10010562f, -0.00434957f, -0.02187010f, 
    -0.02506579f, -0.03647775f, 0.07229008f, 0.08147697f, 0.07386905f, -0.12216663f, -0.04289446f, -0.12719703f, 
    -0.01778005f, -0.01056889f, -0.03745782f, 0.04309074f, -0.02803181f, -0.06551930f, 0.12648290f, -0.02828913f, 
    0.24184941f, -0.00847700f, 0.03202810f, 0.00676562f, -0.01441620f, 0.04427042f, 0.00549752f, 0.06382217f, 
    0.07717835f, 0.02049970f, -0.04825795f, -0.01679425f, -0.30952659f, -0.22504738f, -0.00155166f, -0.03289035f, 
    0.08622290f, 0.02969106f, 0.10360706f, -0.00179436f, -0.02659894f, -0.08471424f, -0.00208179f, 0.05734803f, 
    -0.19331440f, -0.08918550f, 0.08644910f, -0.10446892f, -0.07102606f, -0.05756364f, -0.00548205f, 0.01436111f, 
    0.12680501f, 0.02928706f, 0.08733409f, 0.02136029f, -0.18468782f, 0.12255104f, -0.12606974f, 0.09126960f, 
    0.04026946f, -0.01302193f, -0.05008434f, -0.03515526f, 0.05870376f, 0.02991730f, -0.16041987f, 0.03737358f, 
    0.23520464f, 0.19004060f, 0.11742500f, 0.14622802f, -0.14550982f, -0.05210187f, 0.01675004f, -0.00100537f, 
    -0.00856758f, -0.12725165f, 0.08265680f, 0.05652514f, 0.21765190f, -0.11280063f, 0.12907645f, 0.22908810f, 
    -0.02617239f, 0.00331539f, 0.01286185f, 0.02059318f, -0.06073259f, 0.02303552f, -0.11665436f, 0.01815791f, 
    0.19607572f, -0.03108755f, -0.09625532f, -0.19040309f, 0.04857165f, 0.00995448f, 0.02195895f, 0.09198192f, 
    -0.13184716f, 0.08640517f, -0.03228368f, 0.01263983f, -0.07929419f, -0.07687154f, 0.05024171f, -0.01796732f, 
    0.00365599f, -0.06614023f, 0.13789551f, -0.02654374f, -0.03901058f, 0.06795996f, 0.15627997f, 0.08028610f, 
    -0.20243767f, 0.12517864f, -0.09015948f, -0.07435322f, -0.02852173f, -0.04145823f, 0.09854462f, -0.08050254f, 
    -0.03196717f, 0.01773149f, 0.13873035f, 0.07429677f, 0.24440534f, -0.10787638f, -0.13452590f, 0.02511971f, 
    0.03603447f, 0.02196664f, -0.04604603f, 0.11667876f, 0.02636361f, -0.07351546f, 0.05758612f, -0.10756461f, 
    0.11461460f, -0.08260256f, -0.03721514f, 0.16751571f, -0.08944604f, -0.06132900f, 0.02958382f, -0.05009758f, 
    0.09647338f, 0.00259115f, -0.00645804f, 0.05074762f, -0.03609341f, -0.19189443f, -0.04891234f, -0.17060542f, 
    0.04634473f, 0.04411541f, 0.06099372f, 0.03769058f, 0.05665023f, 0.06938806f, -0.08837152f, 0.01631175f, 
    0.20264012f, -0.04786726f, -0.02205836f, 0.05876543f, -0.08169204f, -0.07252236f, 0.01635069f, -0.05291727f, 
    0.07437601f, -0.06925663f, -0.06436960f, 0.14650318f, -0.38301775f, 0.01669362f, -0.07951137f, -0.22622095f, 
    -0.00540459f, -0.05106698f, -0.10280404f, 0.03264711f, 0.05772094f, -0.04990670f, -0.21199307f, 0.11263228f, 
    0.34196967f, 0.11319575f, -0.03859936f, 0.19850120f, -0.04006692f, -0.06780978f, -0.06885482f, 0.07188512f, 
    -0.05156247f, -0.03676744f, 0.05570152f, -0.00635073f, 0.26192757f, -0.02248224f, -0.11568673f, -0.10045885f, 
    0.12495895f, -0.00896671f, 0.05937433f, 0.00076066f, 0.03780629f, 0.10527419f, 0.13218161f, -0.16121259f, 
    -0.25449556f, -0.03129005f, -0.09438892f, -0.02366033f, -0.09363102f, -0.12953985f, -0.03921570f, -0.03991960f, 
    -0.04067191f, -0.04124158f, 0.02289359f, 0.08941411f, 0.15360487f, -0.12767006f, 0.22277038f, 0.24497057f, 
    -0.07806550f, -0.02280597f, 0.11168271f, 0.03633711f, -0.02509489f, -0.02110883f, 0.03576098f, 0.03853598f, 
    -0.13084956f, 0.08788999f, -0.19495557f, 0.00010052f, -0.00330819f, 0.08079136f, -0.01596437f, -0.06973201f, 
    -0.08827485f, 0.12817080f, -0.04824280f, 0.01833147f, -0.36422470f, -0.00062162f, 0.08003203f, -0.04894232f, 
    -0.01063666f, -0.00442641f, -0.03751916f, 0.06158765f, -0.06426993f, -0.04096451f, -0.07091986f, -0.04333689f, 
    0.12899016f, -0.01506716f, 0.09735951f, 0.02845592f, -0.01728091f, -0.03902827f, 0.10823353f, -0.00410627f, 
    -0.00894301f, -0.09368487f, -0.03977955f, 0.08494125f, -0.43566296f, -0.13989677f, 0.11166839f, -0.19799128f, 
    -0.16579725f, -0.10042786f, -0.07653356f, -0.07085048f, 0.01954213f, -0.07027706f, -0.05013741f, -0.08953450f, 
    0.36508089f, 0.01409092f, -0.07825878f, -0.14220093f, -0.10972302f, 0.04651101f, 0.02549309f, 0.06779922f, 
    0.04566913f, 0.01421290f, -0.06790736f, -0.07607247f, 0.06463908f, 0.01732409f, 0.09513381f, -0.03975070f, 
    -0.04296238f, -0.00541946f, 0.14139447f, -0.01449783f, 0.03604360f, -0.02641066f, 0.13802865f, -0.09751273f, 
    -0.10308761f, 0.04768483f, -0.06539939f, 0.01018457f, 0.03718911f, -0.07688765f, 0.00902310f, 0.01081943f, 
    -0.10639726f, 0.04293744f, -0.05439309f, -0.03700574f, -0.06498485f, -0.16719612f, -0.09934974f, -0.07708288f, 
    -0.12708418f, -0.04924571f, 0.02709873f, -0.06629571f, -0.05880787f, 0.06410006f, -0.06572495f, 0.02680203f, 
    0.16325751f, 0.15640253f, 0.15737009f, 0.06259127f, -0.03102114f, -0.06607507f, 0.08309009f, 0.01341544f, 
    -0.02922910f, 0.05366289f, 0.01801233f, -0.02177533f, 0.20131281f, -0.09193467f, 0.00900781f, -0.00880432f, 
    0.10770344f, -0.00169300f, 0.13711517f, 0.04634780f, -0.15464358f, 0.05501820f, -0.10773818f, 0.02615427f, 
    0.06477930f, -0.03482837f, -0.11724457f, -0.06295168f, 0.09538907f, 0.00253227f, -0.01265097f, 0.05555058f, 
    0.01858482f, 0.01660282f, 0.05359250f, -0.02894815f, 0.28321582f, 0.07539716f, 0.18859944f, -0.01376168f, 
    0.00837069f, -0.12419984f, -0.05681347f, 0.08462735f, 0.00884300f, 0.01758585f, -0.00846327f, 0.00791735f, 
    0.04582292f, 0.08223922f, -0.23680696f, -0.24123046f, -0.06693678f, -0.00611527f, -0.08043783f, -0.12825996f, 
    -0.04503063f, -0.06508606f, 0.04343006f, -0.10283800f, 0.00308191f, -0.10763668f, 0.08323870f, 0.11164117f, 
    -0.07833473f, 0.05807943f, -0.10195906f, 0.03904671f, 0.05139420f, 0.02934447f, -0.06641871f, -0.04817089f, 
    0.21744053f, 0.09135149f, -0.08300690f, -0.02174004f, -0.08742861f, -0.05949444f, -0.01501261f, 0.00950956f, 
    -0.02961996f, 0.03862346f, -0.08501858f, -0.05677075f, 0.07393148f, -0.27467614f, -0.02228961f, -0.00681756f, 
    -0.09267997f, 0.01305619f, -0.09955171f, 0.04638016f, -0.10641269f, 0.05951225f, -0.00077779f, -0.06323280f, 
    -0.21266031f, -0.03818335f, -0.08764916f, -0.00380749f, -0.04117456f, 0.04206971f, -0.04264806f, 0.07123934f, 
    -0.04767732f, -0.04304750f, -0.00186113f, -0.09895477f, 0.16569400f, -0.04177289f, 0.05288778f, -0.27480087f, 
    -0.03791392f, 0.09726194f, 0.06051232f, 0.14144726f, -0.01044712f, -0.04859253f, 0.05997359f, -0.03270952f, 
    -0.31418592f, -0.16917622f, 0.15557040f, -0.12769690f, 0.06700398f, 0.00979724f, -0.13639109f, 0.01756479f, 
    -0.10597359f, -0.12103785f, -0.04345520f, 0.02127423f, 0.10431843f, -0.09253557f, 0.01024122f, -0.01901468f, 
    -0.08372203f, -0.03336027f, -0.00696896f, 0.10361510f, -0.10019668f, -0.03825517f, 0.06890925f, -0.11716958f, 
    0.22518010f, -0.09623826f, 0.01417452f, -0.03491001f, 0.01870530f, 0.03638689f, -0.03518844f, -0.05706025f, 
    -0.12642503f, -0.08404595f, -0.03646467f, -0.10436314f, 0.23749425f, -0.05186403f, 0.06391037f, 0.20132451f, 
    -0.16420946f, -0.05569532f, -0.16517201f, 0.06599306f, 0.04889863f, -0.02590540f, 0.02684729f, -0.10194537f, 
    0.12607427f, 0.03048729f, -0.06037287f, -0.06116493f, -0.09118391f, 0.07106211f, -0.01244235f, -0.05625685f, 
    0.02438165f, 0.10440833f, -0.04102872f, 0.04345191f, 0.15847479f, 0.09007360f, -0.24131645f, 0.15652640f, 
    0.01142000f, 0.00072213f, 0.03506467f, -0.09644168f, -0.02851359f, -0.07108449f, 0.09510435f, -0.02751595f, 
    -0.16026987f, 0.05224968f, -0.02981215f, -0.01801662f, -0.05874126f, -0.17264247f, 0.00819777f, 0.00535147f, 
    -0.07012036f, 0.05877179f, -0.12641521f, -0.00681914f, -0.38822597f, 0.16561720f, -0.16678926f, 0.00471588f, 
    0.06160382f, 0.06321292f, -0.00736380f, 0.10702727f, 0.03472106f, -0.06182900f, 0.04261297f, -0.00590854f, 
    0.35580477f, 0.00391566f, -0.06783736f, 0.09734648f, -0.03939769f, 0.03863128f, 0.07271034f, 0.00338557f, 
    -0.06280539f, 0.07969498f, 0.04358339f, 0.02203772f, -0.08458170f, 0.01073993f, -0.02128533f, 0.00486146f, 
    -0.01837128f, -0.00728273f, -0.01790040f, 0.00999913f, 0.10861138f, -0.03529251f, -0.00702847f, 0.06788877f, 
    0.00340571f, 0.09515801f, -0.18778393f, 0.02824133f, 0.09310108f, -0.01412186f, -0.09538241f, 0.01642475f, 
    -0.00694929f, 0.13671444f, -0.05297340f, 0.02009119f, -0.14864400f, 0.06594820f, -0.03316034f, -0.13731381f, 
    0.02168228f, 0.02185697f, 0.01946101f, -0.02069093f, -0.05709954f, -0.08371409f, 0.03255670f, -0.07615235f, 
    0.19129290f, 0.17094664f, 0.05160632f, 0.21659075f, -0.01632041f, -0.01381215f, 0.02264535f, 0.06576803f, 
    -0.08433337f, 0.07136280f, -0.04185868f, -0.08346500f, -0.05981227f, -0.20213975f, 0.03027672f, 0.03603003f, 
    -0.13193932f, -0.05012080f, 0.01765255f, 0.01178242f, -0.04601967f, -0.06618371f, 0.01980989f, -0.06348628f, 
    -0.09229694f, 0.06039199f, 0.03056442f, -0.05660838f, 0.06233139f, 0.05939712f, -0.00047890f, 0.05056533f, 
    0.06818574f, -0.02402681f, 0.06851859f, -0.02132240f, -0.02361559f, -0.12310746f, -0.13862021f, -0.12507211f, 
    -0.04922783f, 0.03864493f, -0.08437534f, -0.05288264f, -0.00113685f, 0.00751584f, -0.05124582f, 0.11559407f, 
    0.28530177f, -0.09411905f, 0.01362029f, 0.04271471f, -0.00660555f, 0.09970353f, -0.06816701f, -0.00661019f, 
    0.00599599f, -0.03803395f, 0.02876126f, 0.03900333f, -0.18899775f, 0.04441677f, -0.01824594f, -0.00841560f, 
    0.00936086f, 0.00880065f, 0.01754875f, 0.00397201f, -0.07814921f, 0.07203063f, -0.06218118f, -0.03539353f, 
    0.02919017f, -0.17316562f, 0.04006669f, 0.07536492f, 0.11162082f, -0.03001958f, 0.06807210f, -0.05921707f, 
    0.11783586f, 0.01861344f, -0.03860391f, -0.01784479f, 0.17022721f, -0.02572438f, 0.12967144f, 0.16910529f, 
    -0.10795008f, -0.11919721f, -0.03509132f, 0.03810355f, -0.00429605f, 0.02633292f, -0.02248576f, -0.03227864f, 
    0.25176802f, -0.03874525f, -0.18014014f, -0.09875032f, -0.05854643f, -0.04456607f, -0.12409639f, 0.10533345f, 
    0.02222073f, -0.06165170f, -0.02097429f, -0.11782371f, 0.09717644f, 0.01619443f, -0.08387376f, -0.20199446f, 
    0.04483631f, 0.10659009f, 0.07551696f, 0.00563623f, 0.06956524f, -0.11677244f, -0.03255958f, -0.07381760f, 
    -0.14361161f, 0.03526171f, 0.10216948f, -0.09688202f, -0.08769469f, 0.01931383f, -0.01111000f, -0.03599523f, 
    -0.04000981f, -0.10257632f, -0.02634333f, -0.01138822f, 0.03507055f, 0.10254014f, 0.12813778f, 0.01283326f, 
    -0.13061437f, -0.05624320f, -0.01640399f, 0.11150310f, 0.01764857f, -0.05782559f, -0.07409053f, -0.05882552f, 
    -0.21293913f, -0.04466411f, -0.17182522f, -0.01234510f, 0.04090153f, 0.03892610f, 0.10566824f, -0.02934448f, 
    -0.07990779f, -0.01567582f, 0.02642233f, -0.02815801f, 0.36876938f, -0.07850695f, -0.05302102f, 0.04800832f, 
    -0.16350223f, 0.02369037f, -0.06171566f, 0.07168701f, -0.01280062f, 0.00210371f, 0.02637602f, 0.01225349f, 
    0.29370558f, 0.04511708f, -0.27833980f, -0.11794166f, 0.11009639f, 0.06197929f, -0.06434018f, -0.06795099f, 
    0.08701386f, -0.05169940f, -0.03893090f, -0.06781126f, -0.39810124f, 0.07711233f, 0.03182400f, -0.04487022f, 
    0.02090461f, -0.03810271f, 0.04732703f, 0.01355116f, -0.02723613f, 0.00981512f, 0.01623910f, 0.01748837f, 
    -0.23554946f, 0.04883570f, 0.05365215f, -0.12462927f, 0.12400710f, 0.00719083f, 0.06849682f, 0.04440200f, 
    -0.03673423f, -0.01938414f, 0.00551174f, 0.08492892f, 0.10587567f, 0.13846168f, -0.14584157f, -0.22493210f, 
    0.03983946f, -0.07251463f, -0.02686003f, 0.00395429f, 0.06798829f, -0.02698244f, -0.08238589f, -0.06931142f, 
    -0.41927341f, -0.08319341f, -0.19863868f, -0.26220644f, -0.04064401f, -0.07619552f, -0.11383756f, -0.06385531f, 
    -0.01931629f, 0.09613609f, -0.03654812f, 0.09544571f, 0.13349952f, -0.08613297f, -0.03639033f, 0.08870013f, 
    -0.12706217f, 0.00685403f, 0.04235516f, -0.11245429f, -0.00183237f, -0.00492704f, -0.01450509f, 0.00309975f, 
    0.04437928f, 0.03490880f, 0.02205562f, -0.01622660f, 0.05991639f, 0.00425346f, 0.04202371f, -0.03990064f, 
    -0.03848380f, 0.02264449f, 0.04357294f, 0.00143604f, 0.01869279f, 0.04611712f, 0.01025378f, -0.10832036f, 
    0.07061713f, -0.10410049f, 0.02578304f, 0.01153811f, -0.02086296f, 0.06962594f, -0.00192810f, 0.04799830f, 
    -0.28043464f, -0.11531422f, 0.16056365f, -0.06243454f, -0.15157479f, -0.01064218f, 0.08689176f, -0.02562334f, 
    -0.00012079f, -0.12389384f, -0.01340837f, 0.00574111f, -0.07488985f, 0.03304523f, 0.00782555f, 0.02016169f, 
    -0.00722957f, 0.06152788f, -0.06211303f, -0.05183814f, -0.07478151f, -0.04618721f, -0.05949116f, -0.01761063f, 
    -0.28810522f, 0.13841315f, -0.02214035f, -0.05686822f, 0.12111318f, 0.05950559f, 0.05663439f, -0.04563437f, 
    -0.08339499f, -0.00366912f, -0.02529666f, -0.03367604f, 0.12185118f, -0.11973391f, 0.13501512f, 0.05447504f, 
    -0.06062008f, 0.01861091f, 0.01094894f, 0.02858106f, 0.10511065f, -0.00490259f, 0.03104830f, 0.06660951f, 
    0.10968114f, 0.03127076f, -0.02496837f, 0.05196128f, 0.11028843f, 0.10291764f, 0.00875190f, -0.02262380f, 
    -0.02833424f, 0.03307833f, -0.09600794f, 0.01686362f, -0.05355509f, -0.11584407f, -0.15238321f, -0.14279139f, 
    0.11256669f, -0.03305763f, 0.02090729f, -0.07235321f, -0.03806850f, 0.05745430f, 0.04430687f, -0.19143431f, 
    -0.02115886f, 0.05652991f, -0.08916121f, -0.02483143f, -0.00789892f, 0.06573178f, -0.01506906f, -0.03092932f, 
    0.02972068f, 0.06911609f, -0.04957958f, -0.05114275f, -0.14224787f, -0.10355590f, -0.24835229f, -0.02067028f, 
    -0.14968789f, 0.06665446f, -0.04195809f, -0.01356417f, 0.08058599f, 0.02582897f, 0.03734166f, -0.07417859f, 
    -0.16004768f, 0.07297907f, 0.05496239f, -0.07436024f, -0.08685024f, 0.04025653f, -0.00427472f, 0.02252727f, 
    -0.07917365f, 0.03476480f, -0.02701569f, 0.02659723f, 0.20984042f, -0.22728170f, 0.15637089f, -0.10878761f, 
    -0.06968769f, -0.06813475f, 0.11981329f, 0.03028164f, -0.00734513f, 0.02594966f, 0.06426657f, -0.03415125f, 
    0.10861960f, -0.00917363f, 0.10686301f, -0.12102579f, -0.08549218f, 0.00607326f, 0.02554625f, 0.01368969f, 
    -0.02072036f, -0.00327800f, 0.06638949f, 0.11252341f, -0.06817830f, -0.01132750f, -0.08154130f, -0.04705409f, 
    -0.11753582f, -0.00981684f, -0.01819109f, 0.00006352f, 0.00737064f, -0.07378746f, 0.05407992f, 0.03812002f, 
    -0.20614848f, -0.14117602f, -0.14154392f, 0.04189468f, -0.11333311f, 0.07461271f, 0.08869629f, 0.05741884f, 
    -0.00106386f, 0.05009493f, 0.04307484f, 0.09402622f, -0.07885972f, -0.15796496f, -0.07715066f, 0.02206036f, 
    -0.02251756f, 0.01907370f, -0.02620797f, 0.01226566f, -0.03490359f, -0.05076497f, 0.02717203f, 0.05425135f, 
    -0.30586210f, 0.00080411f, 0.02364869f, -0.08100075f, 0.01006814f, 0.00513628f, -0.02770977f, -0.02682220f, 
    -0.08131915f, -0.11269262f, -0.00251030f, -0.00006556f, 0.07411683f, 0.03197654f, -0.07500367f, -0.06457666f, 
    -0.06221997f, -0.00920464f, -0.10755910f, -0.03055188f, -0.00752724f, -0.11850369f, 0.01709147f, 0.01074429f, 
    0.07311887f, 0.14022763f, 0.10167196f, -0.05049735f, 0.00391303f, -0.12891902f, -0.06922189f, -0.05611055f, 
    -0.12300690f, 0.03910248f, 0.05156327f, 0.20159049f, 0.04727200f, 0.17225271f, 0.04451758f, 0.11621401f, 
    0.01163661f, 0.00226560f, -0.04420021f, -0.03836411f, 0.02810687f, 0.07752775f, 0.09598961f, 0.06816327f, 
    -0.00433273f, 0.14085500f, -0.00444103f, -0.12418777f, -0.05045760f, -0.00187092f, -0.00008197f, 0.05236624f, 
    0.03395561f, -0.01122571f, 0.02179930f, -0.06827817f, -0.05828657f, 0.19817504f, 0.03902928f, 0.09545283f, 
    -0.05091309f, 0.04208486f, -0.10973398f, 0.06146563f, 0.07565854f, 0.02499290f, 0.03014413f, 0.08151707f, 
    -0.23301066f, 0.06697001f, -0.04162136f, -0.20095809f, -0.02794737f, 0.02769942f, -0.07311223f, -0.01229037f, 
    -0.01186956f, -0.07201585f, 0.01982389f, 0.06960113f, 0.77336144f, 0.18195263f, -0.00985497f, 0.28369310f, 
    0.12700000f, 0.02100862f, -0.05543560f, 0.12776719f, -0.04626932f, 0.05962894f, -0.06469143f, -0.06762132f, 
    0.00820067f, -0.21076065f, 0.03730936f, -0.13354006f, -0.01156437f, 0.11109213f, 0.05713346f, -0.06694822f, 
    0.01482769f, 0.13085510f, 0.00625493f, -0.04914894f, -0.30558023f, 0.01881288f, -0.07764166f, -0.09527772f, 
    0.08650978f, -0.12576151f, -0.10391925f, -0.05122102f, 0.03947090f, -0.19208112f, 0.02199508f, -0.01991953f, 
    -0.05159736f, 0.25603345f, -0.02087172f, 0.14099512f, 0.07173558f, 0.09424129f, -0.01640477f, 0.00302666f, 
    -0.08881515f, 0.06376310f, -0.01039914f, 0.01552807f, 0.04087637f, 0.04022801f, -0.12559907f, 0.06758030f, 
    -0.01691832f, -0.09239325f, -0.03295234f, -0.01535497f, -0.00386815f, -0.06369372f, 0.10560765f, -0.02910222f, 
    0.07008388f, 0.05145544f, -0.00103309f, -0.01350892f, 0.00295597f, 0.00311900f, -0.04766937f, 0.01155194f, 
    0.09868874f, -0.01010513f, 0.06536935f, 0.05107924f, 0.10586779f, 0.14025332f, 0.07214560f, 0.05101063f, 
    -0.00947440f, -0.05150522f, 0.09096546f, -0.06182775f, -0.07432976f, 0.05944156f, -0.04785160f, -0.04289008f, 
    0.09041721f, -0.07895825f, -0.13595779f, 0.06034840f, 0.04208536f, 0.05242614f, -0.08979565f, -0.00916467f, 
    0.02292266f, 0.10085335f, -0.09283175f, 0.03827353f, -0.29384264f, 0.06040183f, 0.03021955f, -0.09412759f, 
    0.01808237f, 0.15458113f, -0.01205255f, 0.14800949f, 0.02268539f, -0.07401375f, -0.00345264f, 0.02795974f, 
    -0.03824562f, 0.01983891f, 0.05858327f, 0.14766522f, 0.00129198f, 0.08090163f, 0.03192542f, -0.03781185f, 
    0.04315411f, -0.00792363f, 0.02980309f, 0.03032074f, 0.10161084f, -0.20287120f, -0.30047441f, -0.11512781f, 
    -0.12236417f, 0.08376733f, -0.01986202f, -0.02971475f, 0.01141690f, -0.01346625f, -0.02457944f, -0.04343765f, 
    -0.10914422f, 0.10786629f, 0.14178054f, 0.16019446f, 0.02802107f, 0.11557781f, -0.05099232f, 0.00378257f, 
    -0.00801776f, 0.00360377f, -0.06274240f, 0.02351169f, 0.14851417f, 0.01883006f, -0.01186457f, -0.14131863f, 
    -0.07667011f, -0.00533578f, 0.03395993f, -0.03688218f, -0.03988379f, 0.00735089f, -0.02053809f, 0.01764200f, 
    -0.26851490f, 0.19333047f, -0.11949596f, -0.25800723f, -0.02157277f, 0.09111834f, -0.00523682f, 0.05684556f, 
    0.00287466f, -0.03339120f, 0.02032115f, 0.04403204f, -0.18784861f, 0.00867151f, 0.24524252f, -0.05193573f, 
    0.04804728f, -0.08606183f, 0.01707559f, 0.11402339f, 0.03336909f, -0.04347086f, -0.05965075f, -0.13149858f, 
    0.12104282f, 0.05635716f, -0.04550001f, 0.10006963f, -0.00672988f, -0.03778631f, 0.06016696f, 0.00190908f, 
    0.02669417f, -0.01533440f, 0.01427585f, 0.00035544f, 0.09157950f, -0.09607945f, 0.20136200f, -0.06372837f, 
    0.03379426f, 0.02211813f, 0.05545034f, -0.02552736f, 0.05279462f, 0.08275642f, 0.04218602f, -0.04713406f, 
    -0.11092328f, 0.01881569f, 0.16185233f, -0.32385257f, -0.03444697f, 0.01035534f, -0.07779214f, 0.06423400f, 
    -0.00486898f, -0.01208574f, -0.10858658f, -0.01830113f, -0.26361814f, -0.27078620f, 0.22036502f, -0.05729915f, 
    0.00050631f, -0.15882096f, 0.04837734f, 0.00602039f, 0.06258328f, -0.06436168f, -0.06051619f, 0.06996173f, 
    -0.27549934f, -0.27631581f, -0.04365002f, 0.13004215f, 0.00338075f, 0.06353133f, 0.01794726f, -0.03843366f, 
    -0.03425472f, -0.05852324f, 0.07292140f, -0.10325789f, -0.23270816f, 0.17605597f, -0.12349057f, 0.13177049f, 
    -0.10894018f, -0.00623338f, -0.04103879f, 0.02717515f, 0.00417124f, 0.04684364f, 0.00945795f, -0.01800502f, 
    -0.13504305f, 0.14376245f, -0.00469283f, -0.12659125f, -0.05030119f, 0.00047639f, -0.00319945f, 0.04020955f, 
    -0.02298998f, -0.00937439f, -0.03839094f, 0.03864956f, 0.02005677f, 0.04406786f, -0.06778361f, -0.01150178f, 
    -0.00466746f, -0.06648784f, 0.00139437f, -0.01734857f, -0.04985762f, 0.00158460f, 0.02360907f, 0.03024846f, 
    -0.10983545f, -0.20087378f, -0.07021005f, 0.13350107f, -0.05400508f, 0.05810022f, 0.00539703f, -0.11415676f, 
    0.04982269f, -0.04543615f, 0.05318449f, -0.00277239f, 0.13325930f, 0.24990681f, 0.03063656f, 0.05326237f, 
    -0.09668640f, -0.11391900f, 0.08377295f, 0.09596626f, -0.10917345f, 0.00263014f, -0.08219921f, 0.00326958f, 
    -0.29946882f, 0.08743861f, 0.18139210f, -0.05756637f, 0.01368359f, -0.01273163f, -0.03104707f, 0.01621355f, 
    0.03223712f, 0.02815975f, -0.06720611f, -0.00661507f, -0.02995397f, -0.39144963f, -0.20167007f, 0.07622790f, 
    -0.09650399f, -0.00539742f, -0.01616372f, 0.02114447f, -0.07935495f, -0.08855680f, -0.02369020f, 0.03688060f, 
    -0.25729740f, -0.35229722f, -0.15537167f, 0.11441502f, -0.17340669f, -0.03295190f, 0.01480198f, -0.00042305f, 
    -0.07505135f, -0.00355893f, -0.03332066f, 0.03169397f, 0.02360019f, 0.11473815f, -0.07871976f, -0.07916726f, 
    -0.11268548f, -0.15538052f, -0.05505354f, 0.03754066f, -0.02529378f, -0.11520188f, -0.00683988f, 0.02475751f, 
    0.11024003f, -0.03833888f, 0.07776204f, -0.11755762f, 0.00912359f, -0.10134663f, -0.04095380f, 0.10127672f, 
    -0.16343938f, -0.05028588f, 0.03681125f, -0.09586173f, -0.07856034f, 0.16969509f, 0.00271220f, -0.06518578f, 
    0.07097832f, -0.03552572f, -0.01838045f, 0.00732437f, -0.04605829f, -0.05660993f, -0.05534176f, -0.04486767f, 
    -0.05776696f, -0.09019908f, -0.03953929f, -0.00488260f, -0.02186326f, 0.04896845f, 0.02295407f, 0.01074855f, 
    -0.04201366f, -0.02278710f, -0.04214869f, -0.00469881f, 0.04111727f, -0.19994055f, -0.03353760f, -0.19805476f, 
    -0.16358101f, 0.04684262f, -0.12432158f, 0.08055232f, 0.08763545f, 0.09056442f, -0.03660131f, -0.02800107f, 
    0.15278113f, 0.06470790f, 0.11217616f, 0.01744894f, -0.00501660f, 0.06521147f, 0.00529987f, 0.06688672f, 
    0.11042548f, -0.02120638f, 0.09434318f, 0.09150077f, 0.05335686f, -0.03365015f, -0.04767632f, 0.09960368f, 
    -0.03008879f, -0.14286768f, 0.15123533f, -0.12311459f, -0.08123699f, -0.02119637f, -0.09112024f, 0.00678507f, 
    -0.33092225f, 0.16963603f, 0.22558753f, 0.02471099f, 0.08399042f, 0.05669052f, -0.03426882f, 0.02265134f, 
    -0.06563975f, -0.00638678f, -0.10558195f, -0.00442384f, -0.00920854f, -0.15935379f, 0.03542941f, -0.01776997f, 
    -0.11166871f, 0.06123094f, -0.00150366f, 0.03599186f, -0.04573967f, 0.08126452f, -0.06040557f, 0.02733376f, 
    -0.43614867f, -0.27799711f, -0.12022211f, 0.01034001f, -0.06334320f, 0.03418456f, -0.07253900f, -0.08327884f, 
    -0.02618749f, -0.00405089f, 0.06684051f, 0.01669483f, 0.26618543f, 0.21560474f, -0.01203925f, -0.10730302f, 
    0.03117506f, -0.06383831f, -0.02339379f, -0.03690369f, 0.00728785f, -0.00845210f, -0.02993106f, -0.00703229f, 
    0.09485531f, 0.02354984f, 0.07116969f, 0.00593074f, -0.02630669f, -0.06488132f, -0.01982888f, 0.06487500f, 
    -0.00435156f, -0.01163257f, -0.03945068f, 0.00606993f, -0.16345681f, 0.04074324f, -0.04226661f, 0.07828528f, 
    0.02513101f, -0.19060649f, 0.03230897f, 0.07077286f, -0.03011331f, 0.09073802f, 0.13023220f, -0.08434846f, 
    -0.21628034f, -0.47162011f, 0.03372515f, 0.03592391f, -0.02955673f, -0.06925432f, -0.06227330f, -0.00449559f, 
    0.08700059f, 0.05282376f, -0.06489868f, 0.08242275f, -0.10114982f, -0.25184861f, 0.11473418f, -0.12233774f, 
    -0.06435371f, 0.05491540f, -0.00071057f, 0.05699736f, 0.01228730f, -0.06049183f, 0.10397454f, 0.07277194f, 
    0.06996585f, 0.02893016f, -0.12845255f, 0.04927303f, -0.00948103f, 0.04608924f, -0.10215209f, 0.07315351f, 
    0.06498086f, -0.01626168f, 0.00158222f, -0.00914027f, 0.02228556f, -0.04041167f, 0.06333144f, 0.13194171f, 
    0.09622870f, 0.05673838f, -0.08803266f, -0.02945321f, 0.01249522f, 0.01529959f, -0.13549319f, -0.05992822f, 
    0.09482522f, -0.17492871f, -0.30372864f, 0.07339848f, 0.00924119f, 0.02136941f, -0.04519625f, 0.06300518f, 
    0.06397485f, -0.02804358f, 0.04779393f, -0.07360847f, -0.03157707f, 0.01165720f, 0.04854884f, 0.05008217f, 
    0.00419225f, -0.01995619f, 0.01520831f, 0.03800528f, 0.04752716f, 0.01094624f, 0.06964078f, 0.04495079f, 
    -0.53878695f, -0.36787632f, 0.00171965f, 0.12077249f, -0.08711614f, -0.00550738f, 0.02892715f, -0.02456737f, 
    0.02816357f, -0.10655814f, 0.08328538f, -0.14920489f, 0.20060894f, -0.03687621f, 0.06244197f, 0.15473302f, 
    0.02714189f, 0.03420959f, 0.01037412f, 0.03579787f, 0.04079461f, 0.04687108f, -0.08506280f, -0.16969368f, 
    -0.22360975f, -0.26032260f, -0.20820500f, 0.09333566f, -0.02318392f, -0.00952807f, 0.12776095f, -0.04718552f, 
    0.02284599f, 0.02643279f, -0.00477870f, -0.06076211f, -0.00505870f, 0.10767571f, 0.11245523f, 0.19420406f, 
    0.01751735f, -0.08204023f, -0.01278091f, -0.06585418f, -0.10293617f, 0.07228214f, -0.02662254f, -0.00430699f, 
    -0.18469647f, -0.17668180f, 0.06090039f, 0.18468237f, 0.04388352f, 0.01784879f, 0.08598917f, 0.06624170f, 
    -0.04894730f, -0.01890619f, -0.02425007f, 0.13095553f, 0.19330208f, 0.10770346f, -0.15660125f, -0.09823287f, 
    -0.06340388f, -0.04950026f, -0.01859739f, -0.00516096f, -0.05086047f, 0.01122741f, -0.00385141f, -0.00315069f, 
    -0.03866904f, 0.03565015f, 0.01862562f, -0.05621639f, 0.08468984f, -0.16496485f, -0.03692709f, 0.01463828f, 
    -0.12515013f, -0.02859675f, 0.08723897f, 0.02396377f, -0.49013981f, 0.00655559f, 0.16767849f, 0.23910557f, 
    -0.04752741f, -0.04311150f, 0.01923108f, 0.07181734f, -0.05108070f, 0.07745507f, 0.04835964f, 0.03296936f, 
    -0.08241393f, 0.10740476f, 0.11362085f, 0.08536407f, -0.04772878f, 0.11566765f, 0.00669955f, 0.04089949f, 
    -0.05485349f, 0.01109909f, 0.06423465f, 0.04781652f, -0.08659458f, 0.26130167f, 0.07456367f, -0.26501757f, 
    0.12255513f, 0.00509236f, -0.09952680f, -0.06738863f, 0.01942820f, -0.03217186f, 0.04282794f, -0.07664078f, 
    -0.22689018f, 0.17043205f, -0.05727647f, 0.09655418f, -0.00692887f, 0.03743827f, 0.08464053f, -0.12915070f, 
    0.01174851f, -0.03603878f, 0.08037860f, -0.17888357f, 0.10338727f, 0.04222982f, 0.08361632f, 0.19392137f, 
    0.06737211f, -0.01439383f, 0.04714496f, 0.12991081f, 0.04774501f, -0.00983882f, 0.05220518f, -0.04250963f, 
    -0.18306963f, 0.09754533f, 0.01606548f, -0.35058656f, 0.03619402f, -0.08559547f, -0.13373363f, -0.06820968f, 
    0.01448803f, -0.07989274f, -0.06365753f, 0.02592754f, -0.33778119f, -0.06597684f, 0.13427195f, -0.03318907f, 
    -0.00061696f, 0.00497447f, -0.01921625f, 0.03074371f, -0.06030364f, -0.09040786f, 0.06896394f, -0.01335222f, 
    0.14177179f, 0.09403409f, -0.00904772f, -0.07409742f, -0.12862931f, -0.01284491f, 0.03455864f, -0.01379064f, 
    0.00448199f, -0.01028082f, -0.08385286f, 0.08881676f, 0.09348233f, 0.09055895f, 0.15935668f, 0.03861670f, 
    0.09572706f, 0.06045398f, -0.00441897f, 0.10766711f, 0.12667252f, 0.03257228f, 0.00845557f, 0.08716899f, 
    -0.02874018f, 0.03140922f, 0.05142462f, 0.02400372f, 0.07446770f, 0.09973203f, -0.14516188f, 0.11125381f, 
    -0.03702993f, -0.01073006f, 0.00392134f, -0.03619637f, -0.20740242f, 0.23542079f, 0.09038251f, -0.28800172f, 
    -0.11166361f, 0.15751457f, 0.07236318f, 0.07780153f, -0.08878025f, -0.07933181f, 0.03214605f, 0.07690103f, 
    0.31821117f, -0.02031756f, -0.03751355f, -0.08979486f, -0.03135561f, -0.03219555f, 0.16575728f, -0.05201558f, 
    0.04939268f, -0.01642774f, 0.03892747f, 0.05397489f, -0.44812536f, -0.01136263f, -0.13752255f, 0.08865700f, 
    -0.03571167f, -0.11436431f, 0.01687432f, 0.02914873f, 0.04231934f, -0.06184884f, 0.09229050f, 0.07450508f, 
    -0.15082349f, -0.09096946f, 0.15487197f, -0.16431227f, 0.06939569f, 0.01572218f, 0.02947045f, -0.04280373f, 
    0.08909272f, 0.06669962f, -0.05044623f, -0.10480655f, -0.24568620f, -0.08212501f, -0.24908666f, -0.08042603f, 
    -0.03739309f, 0.17918834f, 0.06518178f, 0.08009566f, 0.09750799f, 0.07275911f, -0.02390596f, 0.05096803f, 
    0.26867896f, 0.25851515f, -0.04806083f, -0.11375607f, 0.09596006f, -0.00960846f, 0.14927591f, 0.05349452f, 
    0.01274026f, -0.01237202f, -0.05824297f, 0.02257340f, -0.17826398f, 0.07504651f, 0.01262111f, 0.07222439f, 
    0.13404675f, -0.03444123f, -0.11645083f, 0.01580554f, 0.10770093f, -0.02128723f, -0.04036400f, -0.00321935f, 
    -0.31067133f, 0.19138126f, -0.03217224f, -0.13313715f, 0.05645261f, -0.11604477f, 0.07258753f, 0.10232113f, 
    0.01973438f, 0.04523004f, -0.05934798f, -0.00328184f, -0.35274547f, -0.10079638f, -0.05551336f, -0.10347863f, 
    -0.02435071f, -0.09187102f, -0.10094550f, 0.08523966f, -0.04284193f, 0.06564997f, 0.01245562f, -0.00920704f, 
    0.05487432f, 0.12317570f, -0.16856225f, -0.17595088f, -0.02464403f, -0.12246001f, -0.02125447f, 0.01256549f, 
    -0.05127766f, -0.03563376f, 0.02816275f, 0.04971707f, -0.20623711f, 0.06379012f, 0.00818936f, 0.02144996f, 
    0.02784069f, 0.08883622f, -0.03880451f, -0.09348405f, -0.06015475f, -0.03009535f, -0.02703460f, -0.09420013f, 
    -0.26636311f, -0.04801157f, 0.10329873f, 0.04968897f, 0.03252327f, -0.07915592f, -0.09286401f, -0.06461596f, 
    0.13221489f, -0.00751861f, -0.07990372f, 0.03754215f, -0.53308725f, -0.05994716f, -0.07996619f, 0.02425721f, 
    -0.02106957f, -0.04423566f, -0.04550470f, 0.07249699f, -0.05856794f, -0.04043787f, -0.11227122f, -0.12727846f, 
    -0.01049182f, 0.05007456f, -0.00103982f, -0.09664627f, 0.01821440f, 0.03610465f, 0.08707672f, 0.03976294f, 
    0.11714909f, -0.05459468f, 0.02383853f, -0.02099726f, 0.09203397f, 0.05062475f, -0.02151538f, -0.06483438f, 
    -0.09449709f, -0.00967483f, 0.04119374f, 0.08047380f, -0.10603052f, 0.01690176f, 0.03383201f, -0.24797064f, 
    0.01642099f, 0.06987692f, -0.29266876f, -0.04377899f, 0.08068439f, 0.05236575f, 0.06334959f, -0.02679633f, 
    -0.10304583f, -0.04470915f, 0.03635261f, -0.02386278f, 0.09535127f, 0.09615940f, -0.04269982f, 0.07270130f, 
    -0.06440330f, 0.00577651f, 0.03297060f, -0.01863763f, 0.00875530f, 0.01170410f, 0.03667497f, -0.04923211f, 
    0.29350445f, 0.20262232f, 0.04163456f, 0.00413960f, 0.03484514f, -0.08877041f, -0.00319319f, 0.03841911f, 
    0.06133642f, 0.02638402f, 0.03164240f, 0.11089420f, 0.17837702f, 0.17847955f, -0.07497650f, -0.03451046f, 
    0.07564379f, -0.09942149f, 0.02280821f, -0.04047716f, -0.15793364f, -0.01303139f, 0.03700316f, 0.03585862f, 
    -0.09827030f, 0.05877872f, 0.23010494f, 0.09000113f, -0.05263619f, -0.01566100f, -0.03307430f, -0.04705278f, 
    0.07387003f, 0.05939937f, -0.04642750f, -0.00914024f, -0.15104471f, -0.18849036f, 0.22956310f, -0.25108865f, 
    -0.05870578f, 0.04999511f, 0.08828519f, 0.01386235f, 0.07334257f, -0.01658243f, -0.07874151f, -0.13241982f, 
    -0.03599880f, -0.09081793f, 0.03545827f, 0.16272223f, 0.02336364f, -0.10966132f, 0.02194183f, 0.03849974f, 
    -0.02195129f, 0.08758489f, 0.04617368f, 0.07880935f, -0.04302642f, 0.15014100f, 0.00991745f, 0.24570899f, 
    0.03628777f, -0.09178144f, 0.02151598f, 0.05288298f, 0.00409519f, -0.00376567f, 0.05188769f, -0.06232972f, 
    0.07441535f, 0.04923307f, 0.02069229f, 0.11401000f, -0.04609144f, 0.01421454f, 0.03551241f, -0.02528741f, 
    0.06233229f, -0.02421744f, -0.01080888f, 0.04245798f, 0.23853506f, -0.01216004f, -0.11335888f, -0.14542931f, 
    -0.09827760f, 0.01520617f, 0.08659341f, -0.11796338f, 0.06456769f, 0.01712212f, -0.01457863f, -0.06936811f, 
    -0.38274699f, 0.13037924f, 0.00207674f, 0.12145544f, 0.01687341f, -0.07556480f, 0.05491387f, -0.00636959f, 
    -0.06317020f, 0.01650782f, -0.13595635f, 0.04042769f, -0.15494826f, 0.13192172f, 0.14231138f, -0.05073383f, 
    -0.07786607f, -0.03386657f, -0.07291055f, -0.01211734f, -0.00779503f, -0.07558849f, 0.00085656f, -0.07404730f, 
    -0.13333079f, 0.07037869f, -0.15834634f, 0.00337795f, 0.00083947f, -0.11490705f, 0.00479698f, -0.01636946f, 
    0.00592112f, -0.01374560f, -0.01156388f, -0.11667793f, -0.08996852f, 0.03095038f, -0.02121468f, 0.21965992f, 
    0.05605930f, -0.02581292f, -0.05527193f, 0.13640083f, -0.00278567f, 0.03973036f, 0.05016987f, -0.10804384f, 
    -0.25489131f, -0.25242728f, -0.01186929f, -0.16814122f, 0.08351213f, 0.10614200f, -0.09809162f, 0.03717069f, 
    -0.11765601f, -0.12183320f, -0.12782130f, 0.13354504f, 0.00086887f, -0.22011161f, 0.08134548f, -0.05923083f, 
    0.02892892f, 0.07763210f, 0.01746662f, -0.07890520f, 0.02640771f, -0.08622998f, -0.05215231f, -0.08832537f, 
    -0.17182837f, 0.06744961f, 0.11212527f, -0.02069924f, 0.00204280f, 0.01332240f, -0.07776524f, -0.03458576f, 
    0.11076558f, -0.04341447f, -0.03855145f, 0.06634112f, 0.01645228f, 0.01328754f, 0.13947000f, 0.15038078f, 
    -0.02727664f, 0.05374061f, -0.11267666f, 0.11985201f, -0.04317051f, 0.10453248f, -0.04328511f, 0.14657427f, 
    0.25215885f, 0.05397050f, -0.04599665f, 0.16820137f, -0.05120021f, -0.09046946f, 0.07307039f, 0.05532485f, 
    0.05839878f, -0.08543605f, 0.06276555f, 0.12046225f, -0.34123519f, 0.02184851f, -0.18953370f, 0.03185110f, 
    0.06249446f, -0.05135052f, 0.05404156f, 0.11954252f, -0.03928215f, -0.08394885f, 0.02675347f, 0.04280415f, 
    -0.41883007f, 0.10676386f, 0.13238116f, 0.17766604f, -0.02635164f, -0.05586622f, -0.00623157f, -0.09851750f, 
    -0.01420837f, -0.07522671f, -0.10918156f, 0.04017109f, -0.07392191f, -0.06469966f, 0.04523290f, -0.07621019f, 
    -0.05582816f, 0.10967430f, 0.02822505f, -0.07008693f, -0.04091740f, -0.00702613f, 0.08438946f, 0.02439376f, 
    -0.02788343f, 0.05203755f, -0.10896312f, 0.02003798f, 0.04479163f, -0.05539115f, 0.05232374f, -0.02940381f, 
    0.02432703f, -0.09662963f, 0.04254818f, 0.05875258f, -0.06460793f, -0.03254427f, 0.02569749f, -0.15001176f, 
    0.13695076f, 0.05800947f, -0.00238497f, -0.11593358f, 0.01501854f, -0.03355423f, -0.08677197f, -0.00587055f, 
    0.05299851f, -0.08447972f, 0.04176637f, 0.08982940f, 0.04966587f, -0.01430753f, -0.02079198f, 0.08743809f, 
    -0.11479733f, -0.12434713f, 0.07410515f, 0.08603790f, 0.12314829f, 0.12813161f, -0.07886516f, -0.14236771f, 
    -0.07706057f, 0.11713825f, 0.04851988f, 0.10649122f, -0.04431212f, -0.01296035f, 0.11305115f, -0.10210557f, 
    0.02504111f, 0.00042993f, -0.03416194f, -0.01171603f, -0.07590523f, -0.03064498f, -0.07758267f, 0.09785608f, 
    -0.05271428f, -0.08310529f, -0.05007614f, -0.01342908f, 0.36710021f, 0.10762463f, 0.01202804f, -0.09356864f, 
    0.03174791f, -0.13061762f, 0.05146049f, 0.05374214f, 0.05592483f, -0.09876461f, 0.15064721f, -0.06231530f, 
    0.09299149f, -0.16881491f, 0.06603765f, -0.04563203f, -0.05838425f, -0.07037642f, 0.10259106f, -0.09407149f, 
    0.08301952f, 0.04760052f, -0.02380684f, -0.05585979f, -0.12292494f, -0.02409568f, 0.08864120f, 0.14366463f, 
    -0.07186154f, -0.01230843f, 0.06700961f, 0.04789621f, 0.13116099f, -0.09279457f, -0.01269555f, -0.08006258f, 
    0.03067182f, -0.29764727f, 0.03925156f, -0.00998335f, -0.20490421f, 0.11425672f, -0.10279449f, -0.10450447f, 
    0.04965087f, 0.06118672f, 0.04114588f, -0.09005203f, -0.45168197f, 0.06456742f, -0.00885515f, -0.00313485f, 
    0.07146984f, 0.00949052f, -0.01396342f, -0.13801895f, -0.05764363f, 0.05999763f, 0.03654528f, 0.07012210f, 
    -0.31118703f, -0.06747475f, 0.16171268f, 0.09120981f, -0.06751815f, 0.00417022f, 0.01228108f, 0.11629930f, 
    0.14643908f, 0.03183381f, -0.05785411f, -0.04355553f, -0.14630967f, 0.00784180f, 0.10237546f, 0.12487283f, 
    -0.14285944f, 0.01611121f, -0.01681617f, -0.10721020f, -0.06135929f, -0.02928349f, 0.02341747f, 0.00782987f, 
    -0.30908629f, -0.09502276f, 0.06645785f, 0.04471761f, -0.04304236f, 0.07149727f, -0.06584946f, 0.03721351f, 
    0.03241879f, 0.00388459f, 0.06673519f, 0.04649225f, 0.26774275f, -0.04773795f, -0.06519634f, 0.05686383f, 
    0.04268292f, -0.10878479f, 0.07526227f, 0.01746574f, -0.10334433f, -0.06528787f, -0.01329913f, 0.02966944f, 
    0.10140083f, -0.07124784f, -0.21465194f, -0.01108438f, 0.07705938f, 0.04875400f, 0.02941750f, -0.03991647f, 
    0.06653342f, 0.00339699f, -0.14589538f, 0.05346937f, -0.12160824f, 0.09454877f, 0.24807942f, -0.03160600f, 
    0.00323540f, -0.05179787f, 0.04465334f, -0.14104295f, -0.08621215f, -0.18837197f, -0.12233482f, -0.02259379f, 
    0.23271947f, -0.04122716f, 0.09915056f, 0.03964138f, 0.14353275f, 0.15971071f, 0.21504185f, -0.00805452f, 
    0.18678282f, -0.07376017f, -0.01344031f, -0.09051270f, 0.12060402f, -0.02299473f, -0.27594584f, -0.08832998f, 
    0.08962359f, 0.04105768f, -0.04305008f, -0.01877858f, -0.01919514f, -0.12773645f, -0.14994787f, 0.04221436f, 
    0.01953351f, 0.04110508f, 0.06399047f, -0.05720336f, -0.07741869f, -0.02723037f, -0.11632948f, 0.00990064f, 
    0.03665515f, -0.07951520f, 0.11403701f, -0.11286812f, -0.04668886f, 0.12724869f, 0.03733509f, 0.16966100f, 
    -0.07042591f, 0.01348760f, 0.01877941f, -0.08367006f, 0.08290267f, 0.02711950f, 0.03498437f, -0.00670235f, 
    -0.15009432f, 0.12500630f, 0.07030126f, -0.23347595f, 0.11464109f, -0.01157820f, 0.02119381f, 0.10349835f, 
    0.03708847f, -0.00946624f, 0.09560999f, -0.04652072f, -0.26295406f, -0.15816388f, -0.16544914f, 0.24118178f, 
    0.06395863f, -0.07461956f, -0.02175411f, -0.00046768f, 0.05935723f, 0.12004954f, 0.13591307f, 0.09621032f, 
    -0.46398869f, -0.12534107f, -0.11532313f, 0.16240226f, 0.02787907f, 0.05019971f, -0.03016194f, 0.11962131f, 
    -0.06249444f, 0.10467865f, 0.03657309f, -0.15261333f, -0.12512927f, -0.08481558f, -0.03223221f, -0.00385650f, 
    0.06200330f, 0.08270273f, 0.09086692f, 0.01751610f, -0.06694233f, 0.05776975f, -0.10958745f, -0.15990034f, 
    0.02250292f, -0.10948876f, 0.06792202f, 0.02708211f, 0.05439959f, -0.03792740f, -0.06271565f, -0.25774065f, 
    -0.04071791f, 0.17691810f, 0.10464154f, 0.09032214f, 0.14691649f, 0.12966429f, -0.26220524f, 0.00146548f, 
    0.09980468f, 0.03495555f, -0.04587867f, 0.07390577f, 0.02255555f, -0.06389175f, 0.12864262f, -0.02819705f, 
    0.15006311f, -0.04857001f, -0.19885549f, 0.01491443f, 0.08371342f, -0.12042657f, -0.03416559f, -0.15104125f, 
    0.13418669f, -0.00007351f, -0.11992920f, -0.11241184f, -0.16249925f, -0.09120348f, 0.10928439f, 0.00540719f, 
    -0.08680604f, 0.04088135f, 0.06933942f, -0.05035931f, -0.09029625f, -0.09856817f, -0.00381145f, 0.04255264f, 
    -0.04093476f, 0.14769283f, 0.14018369f, -0.27437410f, -0.03703514f, -0.08829018f, -0.06706231f, -0.04764449f, 
    0.16927259f, -0.10001837f, -0.12303637f, 0.03169450f, -0.48235503f, 0.20080435f, -0.02181353f, -0.11019526f, 
    -0.04905884f, -0.00335852f, 0.13129598f, -0.09742988f, 0.09603748f, -0.00828714f, 0.07542700f, -0.02540577f, 
    -0.08907149f, 0.10261114f, -0.01943237f, 0.04006250f, 0.00090022f, 0.00455991f, -0.11261842f, 0.08490162f, 
    0.13844784f, 0.00060806f, 0.07150689f, -0.07626136f, -0.14556603f, 0.20181870f, 0.24777564f, -0.22369263f, 
    0.05640598f, -0.10838223f, 0.19101231f, -0.26507086f, -0.03176012f, 0.05420416f, -0.10471548f, -0.17666696f, 
    -0.40401042f, -0.38786414f, -0.02047830f, -0.04111956f, 0.00725115f, 0.04639481f, 0.04937236f, -0.06900658f, 
    -0.00520818f, -0.04022813f, -0.05351973f, 0.05202978f, -0.04424789f, -0.12932958f, -0.05051829f, -0.08858939f, 
    0.00166902f, -0.03421675f, 0.02925890f, -0.01867323f, -0.04505502f, 0.09799440f, 0.15342945f, 0.10521290f, 
    -0.41606215f, 0.14844732f, 0.06672693f, 0.18080401f, 0.07782827f, -0.17618217f, -0.09109491f, -0.07796676f, 
    0.04832900f, -0.10545447f, -0.01319834f, 0.15466495f, -0.04033091f, -0.05823690f, -0.15925746f, -0.02884899f, 
    0.11135150f, -0.03611415f, -0.02022039f, -0.06239922f, -0.10821143f, -0.11411063f, -0.02403818f, -0.09839883f, 
    -0.07718535f, 0.19243835f, 0.22558029f, 0.13165291f, 0.03803948f, 0.10961290f, 0.00580659f, -0.05331354f, 
    0.12563007f, -0.00690854f, 0.10388329f, 0.02867325f, 0.18314222f, 0.04709680f, -0.01483225f, -0.18471378f, 
    0.01693742f, -0.02467418f, 0.02022108f, -0.05967445f, -0.04523118f, -0.02633475f, -0.04258168f, 0.00593114f, 
    0.06149882f, 0.04417108f, -0.06225789f, -0.02565159f, 0.07917988f, -0.00281026f, 0.06753211f, 0.00856168f, 
    -0.18592687f, 0.03937949f, 0.08824293f, 0.22477664f, -0.45562994f, -0.01679124f, -0.19589032f, -0.03712704f, 
    0.10227379f, -0.06896236f, 0.07108273f, 0.17253126f, 0.01299419f, -0.04817082f, 0.03806128f, -0.12530667f, 
    -0.28001720f, -0.14427310f, 0.08861102f, 0.18700917f, -0.04763610f, -0.14878573f, -0.17721602f, 0.10203253f, 
    0.02825545f, -0.09750187f, 0.04963438f, -0.10679933f, -0.05554789f, -0.03304394f, 0.12085186f, 0.16718763f, 
    -0.04782502f, -0.01355002f, 0.08958874f, -0.07786304f, 0.00860288f, 0.07523929f, -0.05789113f, 0.29383096f, 
    -0.31853935f, 0.04336156f, 0.02457138f, 0.11681765f, -0.00216849f, 0.15177076f, -0.08978903f, 0.02524835f, 
    0.01125207f, 0.04524273f, 0.02018084f, 0.10623415f, 0.05067094f, 0.02137429f, 0.11871833f, -0.17572609f, 
    -0.14986308f, -0.08515937f, -0.11896593f, -0.02592980f, 0.00955505f, 0.12534682f, 0.08470023f, -0.06136723f, 
    0.16449818f, -0.24170099f, 0.04046665f, 0.03668830f, 0.03303751f, -0.10392176f, -0.16425245f, -0.12347730f, 
    -0.01960914f, -0.11658119f, -0.02475523f, -0.06053161f, -0.04451275f, -0.03630954f, 0.22129729f, 0.08799347f, 
    0.00478601f, 0.05772386f, 0.00852787f, 0.01711074f, 0.10008738f, 0.02740378f, 0.04620869f, 0.03032858f, 
    -0.05185965f, -0.03057477f, -0.07396249f, -0.01528356f, -0.03237521f, -0.05070840f, 0.04697914f, 0.09315261f, 
    -0.01267440f, -0.02964063f, 0.05935384f, 0.04754888f, -0.06596256f, 0.07139836f, -0.15108103f, 0.11860202f, 
    -0.07430225f, 0.02089053f, 0.03813359f, 0.00432376f, -0.07678843f, -0.07883125f, 0.10066673f, 0.03831954f, 
    0.08374722f, -0.01745369f, -0.14723036f, -0.10862484f, 0.12233037f, 0.14322455f, -0.10269958f, -0.19678581f, 
    0.00222100f, -0.09050111f, 0.10274966f, -0.07351765f, -0.19533154f, -0.14966102f, -0.14202814f, -0.00683875f, 
    0.04733122f, 0.11370544f, -0.08234567f, -0.08157453f, 0.06661541f, -0.09171612f, 0.02689747f, 0.06587197f, 
    -0.11398252f, -0.06633250f, -0.03229078f, -0.17358136f, 0.01036705f, 0.03401795f, -0.00213026f, -0.00550089f, 
    -0.09176076f, 0.07204182f, -0.06143941f, 0.03893344f, -0.25647110f, -0.15156886f, 0.11060234f, 0.05202361f, 
    -0.04342524f, 0.06453466f, 0.04323965f, -0.03643198f, 0.07732030f, 0.05135683f, -0.01571424f, -0.05998708f, 
    -0.05649097f, -0.01921099f, 0.04526930f, -0.39102730f, 0.01263211f, -0.03574550f, 0.10724065f, -0.00902157f, 
    -0.02577157f, -0.02318523f, 0.08162779f, -0.07405508f, 0.06424918f, 0.05312220f, 0.01792888f, 0.10113157f, 
    -0.12190479f, 0.05827438f, 0.09047171f, 0.03751300f, 0.02446656f, 0.02424902f, 0.01565153f, 0.10620778f, 
    -0.03959664f, 0.03292454f, 0.18183902f, 0.10694204f, 0.06309962f, 0.10133533f, -0.07849031f, 0.05735099f, 
    -0.03047993f, 0.11697405f, -0.09367868f, 0.08468395f, -0.26897341f, -0.21047527f, -0.13515849f, -0.07051247f, 
    0.09227133f, 0.06214419f, -0.01167903f, -0.07835479f, 0.05495711f, -0.02077526f, -0.02729513f, 0.02894431f, 
    -0.05662729f, 0.17960891f, -0.11725312f, 0.01667010f, 0.14440794f, -0.04467548f, 0.13519099f, -0.02606780f, 
    0.10488263f, 0.02011135f, -0.24528106f, -0.01925471f, -0.07368106f, 0.05839198f, 0.03281987f, 0.21905605f, 
    -0.00582256f, -0.13004713f, 0.00117239f, -0.02254356f, -0.08663281f, 0.08302612f, 0.09223451f, 0.18140402f, 
    -0.06315816f, 0.14707337f, -0.04530245f, 0.09597147f, -0.04746741f, -0.01099864f, 0.06230911f, -0.00704522f, 
    0.08108837f, -0.01675864f, 0.05096027f, -0.00940450f, -0.25747925f, -0.11790702f, -0.28752407f, 0.11662386f, 
    0.11737256f, -0.19099088f, -0.13870126f, -0.18772307f, 0.19280784f, 0.06772708f, -0.01083630f, 0.08448977f, 
    0.15667571f, -0.17721911f, 0.14293359f, 0.09155849f, 0.08842171f, -0.02294790f, -0.03797247f, -0.04679893f, 
    -0.14504477f, 0.01062070f, -0.08320548f, -0.09752442f, -0.66952902f, -0.16459200f, -0.13204587f, -0.33442101f, 
    0.11061476f, 0.00100694f, -0.06632029f, -0.12049107f, 0.03783811f, 0.06223644f, -0.11574224f, 0.06942142f, 
    0.01436557f, -0.10600283f, -0.02352508f, 0.10220360f, 0.04722878f, -0.04080258f, 0.02673117f, 0.09436285f, 
    0.01882203f, 0.04991595f, 0.08281206f, -0.03546010f, -0.05098465f, 0.01452525f, -0.03096527f, 0.10907668f, 
    -0.08153116f, -0.17421189f, 0.06659718f, 0.03329606f, 0.08285284f, -0.16571388f, -0.13033739f, 0.00604327f, 
    0.04408442f, 0.07102779f, 0.22525525f, -0.06569888f, -0.02422915f, 0.01793947f, -0.14375828f, -0.04108312f, 
    0.03464099f, -0.08509957f, 0.01617086f, -0.02441434f, -0.12195549f, -0.04473676f, 0.09830089f, 0.20621261f, 
    -0.03920180f, -0.04404663f, 0.11195388f, 0.12804949f, 0.01996183f, 0.04660491f, -0.00584743f, -0.14564690f, 
    0.01636679f, 0.00271476f, -0.16091244f, 0.22563529f, 0.09782072f, 0.04982726f, 0.04666137f, 0.00792478f, 
    -0.10932879f, 0.04438363f, 0.07103907f, -0.04809453f, -0.14253528f, -0.04154426f, 0.01425681f, -0.12203059f, 
    0.19092731f, -0.12592986f, 0.01689682f, 0.00625165f, 0.06944404f, 0.08287437f, -0.08893087f, 0.09549804f, 
    -0.11820316f, -0.07434914f, 0.17197001f, 0.10542323f, 0.02970359f, 0.06255098f, 0.07420631f, -0.00392581f, 
    0.12185864f, -0.10407743f, -0.01457912f, -0.03531984f, -0.07015622f, 0.14603892f, 0.04264381f, -0.01024485f, 
    0.01000843f, -0.03522622f, 0.02422477f, -0.16825216f, 0.00545241f, 0.01815034f, -0.07171296f, 0.01694928f, 
    -0.05189199f, -0.02817756f, 0.01096721f, 0.09913382f, 0.10317894f, -0.14913665f, -0.00438089f, -0.01068175f, 
    0.09939948f, -0.01431177f, -0.12448995f, -0.10538444f, 0.05133122f, 0.04365020f, 0.03735721f, -0.06740350f, 
    -0.01261654f, -0.12983167f, -0.02384852f, -0.03239191f, -0.03476796f, 0.06427677f, 0.05153369f, 0.22009537f, 
    -0.10879743f, 0.08862306f, -0.06994200f, 0.11860321f, 0.02483486f, -0.08363324f, 0.07073548f, 0.04546772f, 
    0.00011081f, -0.13925119f, 0.00444877f, 0.04409402f, -0.08803722f, 0.19364773f, -0.03766002f, -0.10372033f, 
    0.11869744f, 0.02233660f, -0.07797831f, 0.02110875f, -0.03586916f, -0.05633257f, -0.10908508f, -0.20056090f, 
    0.09493808f, -0.01679187f, -0.02245217f, -0.09617134f, -0.02457119f, 0.12255380f, 0.05124277f, -0.02922953f, 
    -0.21950231f, -0.03354635f, 0.24349634f, 0.10478780f, 0.03771308f, -0.00905836f, 0.15378951f, 0.24508324f, 
    -0.03827776f, 0.08151540f, 0.01397954f, -0.07082061f, -0.17263815f, -0.14493698f, 0.05734227f, 0.20306306f, 
    0.13021940f, 0.06458407f, 0.12013354f, -0.03136338f, -0.01117434f, 0.05096799f, -0.00203604f, 0.00558595f, 
    -0.07118735f, 0.04043636f, 0.02552909f, 0.10531610f, 0.13753568f, -0.14714243f, -0.06067578f, 0.21065211f, 
    0.10877906f, 0.13028552f, 0.12637867f, 0.02774679f, 0.09788925f, -0.05517070f, 0.02181354f, 0.00083856f, 
    -0.06103205f, -0.36443326f, -0.17089452f, 0.04150110f, -0.07955848f, -0.08321154f, -0.02864792f, -0.05677757f, 
    0.01531384f, -0.03949289f, 0.02849470f, 0.10238206f, -0.09297309f, 0.10664666f, -0.04156445f, 0.13503285f, 
    0.07052274f, 0.05825374f, 0.03859198f, 0.04484816f, -0.03931611f, 0.08352377f, 0.20895223f, -0.03882224f, 
    0.00691604f, -0.15261275f, -0.19999325f, -0.03381194f, 0.04543379f, -0.13390352f, -0.06081487f, 0.00481712f, 
    0.01110687f, 0.01375658f, -0.11842217f, 0.00972833f, -0.20234343f, -0.07995160f, -0.12526967f, 0.03051214f, 
    -0.05931761f, 0.16462818f, -0.05062811f, -0.02940073f, -0.07505202f, 0.03496478f, 0.08568114f, 0.02511628f, 
    0.12388580f, 0.08951391f, 0.11296053f, -0.34604391f, -0.02186619f, -0.03228457f, 0.09168062f, 0.09653288f, 
    -0.04306572f, 0.11892673f, 0.00622112f, 0.11846059f, 0.07847881f, -0.10345126f, -0.01634174f, 0.05582542f, 
    0.06313814f, -0.03751334f, -0.01590879f, 0.03926438f, -0.05918219f, 0.01317292f, -0.06362319f, -0.04851657f, 
    0.19639446f, -0.32846826f, 0.00298358f, 0.17483778f, 0.05550041f, 0.02133217f, -0.03797535f, -0.04212675f, 
    0.03048618f, -0.03078615f, -0.08212209f, 0.04364525f, -0.13452685f, 0.08360469f, -0.12602876f, -0.24635701f, 
    -0.11431726f, -0.01084810f, 0.03201969f, -0.11613719f, -0.10092270f, -0.09365927f, -0.13041106f, -0.06692744f, 
    0.20998594f, -0.05583569f, 0.10670447f, -0.21553811f, 0.04022110f, 0.01704233f, 0.05964497f, -0.15749133f, 
    -0.01689467f, 0.07567567f, 0.15214507f, -0.10857356f, 0.15944260f, 0.04045593f, -0.08075950f, 0.01697047f, 
    -0.13052861f, 0.06844687f, 0.00543853f, -0.08494353f, -0.07793036f, -0.13833632f, 0.18558635f, 0.11686604f, 
    0.05099038f, -0.06881922f, -0.18337969f, 0.33859655f, 0.05800556f, -0.07015236f, 0.14548260f, -0.03137497f, 
    0.00427774f, 0.01058516f, -0.00697189f, -0.01921213f, -0.26910332f, -0.17660709f, 0.01601861f, -0.11572348f, 
    0.03849397f, 0.00719915f, 0.08437495f, -0.07098176f, -0.05170162f, 0.05605925f, -0.11392201f, 0.15227336f, 
    -0.06773044f, -0.07770699f, -0.04713037f, 0.05614577f, -0.04486537f, 0.02596547f, 0.06731702f, -0.00152807f, 
    -0.00400614f, 0.05507596f, 0.10789710f, -0.02308924f, 0.25404605f, -0.14887391f, 0.04584909f, 0.18792939f, 
    0.00473569f, 0.11709775f, 0.02528473f, 0.02717813f, 0.21378276f, -0.02723997f, -0.08299457f, 0.12380894f, 
    0.06215817f, 0.02859690f, 0.06961291f, -0.10275941f, 0.06962050f, 0.01396455f, 0.13219301f, 0.11935687f, 
    -0.11049020f, -0.04806526f, 0.05805818f, -0.03385867f, -0.05576560f, -0.40589905f, -0.13487549f, 0.08498704f, 
    -0.04379456f, 0.04480825f, -0.00496538f, 0.07684191f, -0.03130777f, -0.02937924f, -0.02840428f, 0.07243774f, 
    0.16578433f, -0.03250043f, 0.20862713f, 0.07880151f, 0.09170500f, 0.04111086f, 0.03184848f, 0.08786805f, 
    -0.04630904f, 0.00070558f, 0.00565938f, 0.00284211f, 0.06524617f, -0.45849895f, 0.07942244f, -0.04971543f, 
    -0.06623080f, 0.13976479f, -0.00869317f, 0.11520045f, 0.05265882f, -0.10663847f, -0.01796425f, 0.02356069f, 
    0.09368719f, -0.18569309f, -0.01930715f, -0.04819019f, -0.11891618f, 0.03390312f, -0.09706004f, 0.02685837f, 
    -0.03437141f, 0.14147013f, -0.00069878f, 0.05447008f, 0.09239233f, 0.04858233f, -0.01491025f, -0.12079123f, 
    -0.02576366f, 0.08326778f, -0.00726029f, -0.11660777f, 0.02754536f, -0.05192214f, -0.11102751f, -0.08313212f, 
    0.11696410f, -0.17749994f, 0.03383441f, -0.02573652f, -0.03728813f, -0.03533592f, 0.10634810f, 0.09873754f, 
    -0.09440579f, 0.00366797f, 0.00675064f, -0.00884142f, 0.22246085f, 0.11350578f, 0.24557358f, 0.22057384f, 
    -0.11382182f, 0.13232258f, 0.04810526f, 0.02643546f, -0.01608189f, -0.04062840f, -0.00097562f, -0.11031782f, 
    0.20127386f, -0.36083513f, -0.26991901f, -0.29824564f, -0.02737540f, 0.14814220f, 0.06432636f, 0.15585454f, 
    -0.01521714f, 0.09015651f, -0.04450921f, -0.04863000f, -0.34511572f, 0.09011846f, 0.20259565f, 0.11470658f, 
    0.00865726f, 0.02278173f, -0.01343664f, -0.04224180f, -0.00357573f, -0.06624027f, 0.08458656f, -0.15713090f, 
    0.05722737f, 0.15018718f, 0.01650237f, -0.12681365f, -0.03977276f, 0.11903033f, -0.00259935f, -0.02397127f, 
    0.08451416f, -0.13235846f, -0.00783145f, -0.01902933f, 0.13632384f, -0.07520701f, 0.11307441f, -0.25987324f, 
    -0.10315289f, 0.01137705f, 0.00999428f, -0.27987164f, -0.07035249f, 0.06148720f, 0.07148743f, 0.18515606f, 
    0.36376804f, 0.06507819f, 0.17284049f, -0.06878345f, -0.02754179f, -0.07961083f, -0.04149396f, -0.02192184f, 
    -0.16643074f, 0.13393202f, 0.09836344f, 0.00892852f, 0.04933469f, 0.06410809f, 0.16194914f, -0.08025441f, 
    -0.14709085f, -0.00779592f, 0.08768773f, 0.01406840f, 0.07579793f, -0.04757320f, 0.01470034f, -0.31290615f, 
    0.25465918f, 0.07537263f, -0.12916319f, 0.08931497f, 0.00328888f, 0.04909711f, -0.00261681f, -0.04672902f, 
    -0.03400045f, -0.07790693f, 0.05158062f, -0.01932430f, -0.01630721f, 0.04196987f, 0.02634211f, -0.28734407f, 
    -0.01141910f, 0.14656396f, 0.18201432f, 0.09187692f, -0.11964478f, -0.12351340f, -0.06885514f, -0.01292275f, 
    -0.07637661f, -0.03647309f, -0.09425944f, 0.26289925f, -0.15517339f, 0.03376015f, 0.04886050f, -0.01827833f, 
    0.00438572f, 0.06247890f, 0.00144698f, 0.07783250f, 0.12299968f, -0.20902860f, -0.02579511f, -0.03025192f, 
    0.06477481f, 0.03750784f, -0.03378989f, -0.03267784f, 0.02624037f, 0.01528341f, -0.06719073f, -0.02734499f, 
    0.07715686f, 0.25312555f, 0.11403918f, -0.41774946f, 0.11022081f, -0.04940748f, -0.02246179f, 0.03395616f, 
    -0.02850184f, 0.03316797f, 0.15155295f, -0.03034745f, -0.18237491f, -0.01405252f, 0.08215069f, 0.18977986f, 
    0.09364130f, -0.04807764f, -0.03166560f, 0.01619711f, 0.02583080f, -0.01910389f, -0.07655279f, -0.08848288f, 
    -0.16534446f, -0.12425901f, -0.21005371f, 0.04810333f, -0.07198357f, 0.00054322f, -0.01993344f, -0.02026995f, 
    -0.03589733f, 0.11971390f, -0.01738361f, 0.06039161f, -0.05958239f, 0.14149638f, 0.00958989f, -0.42610958f, 
    -0.09488199f, -0.15098049f, 0.00625836f, -0.14566626f, 0.00475721f, -0.03405537f, 0.10016617f, -0.05295745f, 
    0.18049993f, 0.08533996f, 0.14815390f, -0.38773999f, -0.16992946f, -0.09170484f, 0.02373509f, 0.03516722f, 
    0.07670054f, -0.00934747f, -0.00921885f, -0.03889895f, -0.29771894f, -0.00109119f, 0.05103621f, 0.18251628f, 
    0.05953386f, 0.05429615f, 0.01776397f, 0.04519368f, -0.13163303f, 0.03662645f, -0.08813738f, -0.03535385f, 
    0.06728387f, -0.23587841f, 0.05464933f, 0.05645279f, -0.06328573f, 0.03281185f, 0.01247264f, -0.03823351f, 
    0.07417539f, -0.01159474f, -0.03660039f, 0.02275173f, -0.17779949f, 0.04293936f, 0.06020525f, 0.00686814f, 
    0.06086973f, -0.03536863f, -0.08778624f, -0.01732378f, -0.05167590f, -0.01917860f, 0.02099143f, -0.11806007f, 
    -0.01719689f, 0.10125405f, -0.00233419f, -0.00884440f, -0.02123607f, -0.07509353f, 0.10941400f, 0.05062717f, 
    -0.05529353f, -0.04988099f, 0.10429764f, -0.07532287f, -0.11673731f, -0.06437206f, -0.15821685f, -0.35208604f, 
    -0.12471466f, 0.05589496f, -0.07507594f, -0.05286213f, -0.06943246f, 0.17927277f, -0.06961284f, 0.11061307f, 
    0.15426552f, -0.13115552f, 0.04109475f, -0.16990410f, -0.05843505f, -0.03894182f, -0.09226025f, 0.03043774f, 
    0.01966559f, -0.06184465f, 0.08044080f, -0.07080662f, 0.16207391f, -0.19885075f, -0.09895495f, 0.02251033f, 
    0.04742598f, 0.06662739f, -0.08755423f, -0.00317438f, 0.00503952f, -0.06861899f, -0.16340838f, -0.15823910f, 
    -0.06090476f, -0.01038196f, -0.11596303f, 0.09439392f, -0.00179466f, 0.03200539f, -0.03803243f, -0.08586748f, 
    -0.15500234f, 0.01388288f, -0.10725831f, -0.13047017f, -0.24213730f, -0.09164421f, -0.19850415f, 0.07032008f, 
    -0.06235769f, 0.07655488f, 0.10156758f, 0.01584610f, -0.16196162f, -0.05230685f, 0.08122557f, 0.08711186f, 
    0.00050426f, 0.11510126f, -0.04008155f, 0.21391104f, -0.06826381f, 0.00685297f, -0.05594687f, -0.01203218f, 
    0.00126710f, 0.06819879f, 0.15281337f, -0.00178068f, -0.08774858f, -0.10245544f, 0.02278390f, -0.05037425f, 
    -0.05289559f, 0.07713775f, 0.06965300f, -0.05034025f, 0.05455371f, -0.05403739f, 0.05604180f, -0.04071934f, 
    0.03788118f, -0.05915340f, -0.01780391f, -0.07473558f, 0.10189068f, -0.02087711f, 0.02689757f, -0.04125263f, 
    -0.04662776f, 0.01074136f, -0.02750389f, -0.10224108f, -0.36755350f, 0.10513601f, -0.24824730f, 0.25723690f, 
    0.04406324f, 0.01577834f, -0.01251540f, -0.05961146f, -0.03307527f, 0.17952064f, 0.05364120f, -0.10800198f, 
    0.12971073f, -0.05699480f, 0.22831215f, 0.01742118f, -0.09493971f, -0.00939216f, -0.00412479f, -0.03022404f, 
    0.04057308f, -0.01141510f, 0.07860595f, 0.14267547f, 0.22972970f, -0.03968835f, -0.06342606f, 0.08166199f, 
    -0.01236136f, -0.04127092f, -0.19726083f, 0.00378213f, -0.10179608f, 0.04141948f, -0.00379433f, 0.08688489f, 
    -0.14226535f, -0.00450894f, -0.22444047f, -0.17740142f, -0.10751890f, -0.03528798f, 0.04916598f, -0.12388768f, 
    0.11392961f, 0.02470907f, 0.00450422f, 0.02164812f, 0.21164152f, -0.12485077f, -0.00488416f, 0.02545199f, 
    -0.07746498f, 0.14468311f, 0.01753015f, -0.04489675f, -0.10511297f, -0.03004728f, -0.00454973f, 0.03500323f, 
    -0.12653901f, 0.04928616f, 0.03835192f, -0.02544233f, -0.11648407f, -0.03069216f, 0.02949439f, 0.09249814f, 
    -0.01763058f, 0.14434744f, -0.01180664f, 0.06833858f, -0.16112803f, 0.10726951f, 0.03368000f, -0.15811731f, 
    0.02945103f, 0.00931275f, -0.04057641f, 0.04867576f, 0.00426889f, 0.08648676f, 0.14836757f, 0.10314599f, 
    -0.47373974f, 0.06263021f, -0.27480951f, 0.16181102f, -0.04659637f, 0.06324613f, -0.02214576f, 0.09490424f, 
    0.00994229f, -0.06209764f, 0.06699336f, -0.08307669f, 0.02877478f, 0.07203644f, -0.02048534f, -0.12067565f, 
    -0.13032305f, 0.03622299f, -0.03930308f, 0.01096431f, -0.07111990f, -0.12933038f, -0.00504378f, -0.25250044f, 
    -0.05845395f, 0.06099969f, -0.05678882f, 0.18127851f, -0.07153053f, 0.00664904f, 0.03777415f, 0.06409653f, 
    0.04832667f, -0.00577280f, -0.19982523f, -0.16651762f, 0.31229469f, -0.24135338f, -0.03502413f, 0.03884802f, 
    -0.04920878f, 0.02824264f, 0.07667976f, -0.02820083f, 0.05692579f, 0.05915660f, 0.07817531f, 0.19166632f, 
    0.08353592f, 0.28999969f, 0.18378942f, -0.24113658f, 0.03339319f, -0.09288443f, -0.00826947f, -0.00412840f, 
    0.04380863f, 0.09215768f, -0.26401186f, 0.04235520f, -0.01880503f, 0.18486048f, -0.17469467f, -0.22438769f, 
    0.02808578f, 0.00572557f, 0.00383281f, -0.00153122f, -0.03401444f, 0.02319478f, -0.08203375f, 0.01985685f, 
    0.03784640f, 0.23255408f, 0.14187442f, -0.11852250f, 0.15202177f, -0.06987048f, 0.01730594f, 0.03215361f, 
    0.01021397f, 0.02105848f, 0.03206999f, -0.07009631f, -0.21315365f, -0.10395624f, 0.04282051f, -0.10151380f, 
    -0.03853106f, 0.00674806f, -0.06200676f, -0.07258291f, -0.09205544f, 0.04765489f, 0.03655439f, 0.03161209f, 
    0.15419760f, 0.09917438f, 0.14577988f, 0.17771573f, 0.14609212f, 0.06186355f, 0.04857097f, -0.03207469f, 
    -0.00534082f, -0.05660317f, 0.00072728f, -0.00659124f, 0.02848058f, 0.14891525f, -0.05702931f, -0.14339624f, 
    -0.06215827f, -0.02550351f, -0.01830166f, -0.06415299f, -0.00356554f, -0.01059883f, 0.04134146f, -0.07260489f, 
    0.08046955f, 0.12418841f, 0.02070627f, 0.04616471f, 0.03522061f, 0.01253047f, 0.08023790f, 0.03304739f, 
    -0.08381037f, 0.06490365f, 0.00906536f, -0.03886763f, -0.07294553f, 0.20836157f, 0.10771568f, 0.11134649f, 
    0.03348913f, 0.04885921f, 0.03092600f, 0.01803580f, -0.04055524f, 0.02782886f, -0.00115722f, 0.02984818f, 
    0.10925326f, -0.03756535f, -0.01314583f, -0.24920231f, 0.00565962f, -0.02549477f, -0.05980944f, -0.15885887f, 
    -0.04206081f, -0.04684281f, -0.06863547f, -0.05087265f, -0.11186763f, -0.05632417f, -0.12288233f, -0.14574738f, 
    -0.06042357f, -0.07327703f, -0.03836221f, -0.04117650f, -0.02406231f, 0.02132565f, 0.00956109f, -0.03973110f, 
    0.04720208f, -0.17198281f, 0.03293588f, -0.05813424f, -0.06765535f, -0.00698076f, 0.02403089f, -0.03238388f, 
    -0.04865598f, 0.05126806f, -0.05893376f, -0.02127976f, 0.08384058f, 0.15259539f, 0.10800895f, 0.22241537f, 
    0.07542055f, 0.00177026f, -0.01911950f, -0.08262751f, -0.02544208f, -0.06059057f, -0.03542813f, -0.06470674f, 
    0.12676264f, -0.01755460f, 0.18480678f, 0.03848868f, 0.11188784f, 0.03014288f, -0.00479136f, -0.04334760f, 
    0.04076011f, 0.03302079f, -0.05384924f, -0.03223458f, 0.08887957f, 0.10002450f, 0.09058475f, 0.02488888f, 
    -0.02758828f, -0.00250015f, -0.02305060f, -0.00313254f, -0.02859083f, -0.06616636f, -0.01043077f, 0.08038667f, 
    0.16597378f, 0.04238515f, -0.03754307f, 0.20817657f, 0.08712617f, -0.06236877f, -0.06542835f, 0.03712646f, 
    -0.01914630f, -0.05178918f, -0.01538499f, -0.00026295f, 0.07713594f, -0.00677836f, 0.10487197f, 0.03328932f, 
    0.13224909f, 0.10153238f, -0.02726943f, -0.07940274f, -0.01823628f, -0.03761107f, -0.00200486f, -0.06484205f, 
    -0.11238158f, 0.15490693f, -0.07676505f, 0.05431379f, 0.00992482f, 0.04120162f, -0.01315444f, -0.04453166f, 
    0.03309447f, -0.06414615f, 0.00300952f, -0.05193090f, -0.53813607f, 0.13125709f, -0.03568901f, -0.00923300f, 
    -0.08084728f, -0.07415774f, -0.02227124f, -0.00926497f, -0.12671779f, 0.07515676f, 0.04328506f, -0.08249982f, 
    -0.07139530f, 0.03849688f, -0.05789061f, -0.08424519f, -0.00080619f, 0.00059821f, -0.09587926f, -0.09784123f, 
    -0.03834625f, -0.10693799f, -0.03907982f, -0.06664359f, 0.03343059f, 0.09664676f, 0.07120906f, -0.02324279f, 
    0.02291552f, -0.07263011f, 0.06874225f, 0.03089719f, -0.03013521f, 0.04232692f, 0.02660111f, -0.01122640f, 
    0.04363118f, -0.17574149f, 0.03748038f, 0.12034784f, -0.03166018f, -0.15886749f, 0.06782223f, -0.03485107f, 
    -0.08412982f, -0.06961850f, 0.02965780f, -0.03922923f, 0.02490447f, -0.06234135f, 0.07299876f, -0.09374594f, 
    -0.00324674f, 0.02256359f, -0.00716732f, 0.00046605f, -0.04193186f, -0.05035459f, -0.02200519f, -0.00919567f, 
    0.00146847f, 0.10568639f, 0.02206488f, 0.00761767f, 0.07550652f, -0.04074745f, 0.00366330f, 0.00989863f, 
    0.00770721f, -0.04844427f, -0.03233231f, -0.04072018f, -0.10950203f, -0.02677144f, 0.11441942f, -0.07315460f, 
    -0.03260630f, -0.03084250f, -0.10036887f, -0.13227127f, -0.06111303f, 0.04594200f, -0.02728312f, -0.11290112f, 
    -0.08286230f, -0.05461930f, -0.09436434f, -0.16443947f, -0.10919833f, -0.03092303f, -0.05005492f, -0.01911926f, 
    -0.02385018f, -0.08257691f, -0.12720677f, -0.02236524f, -0.03283317f, 0.02342550f, -0.13269781f, 0.02475047f, 
    0.07405958f, 0.03200627f, -0.03827437f, 0.05543593f, 0.02910906f, 0.04471143f, -0.14058749f, 0.05922987f, 
    -0.08066262f, 0.07837559f, -0.00054299f, -0.02668847f, -0.14933574f, -0.04531084f, -0.04123713f, -0.14695199f, 
    -0.03281138f, 0.02106160f, -0.12954532f, -0.14554097f, -0.18108086f, 0.11810984f, 0.00910428f, -0.10311746f, 
    -0.05985729f, 0.01087708f, -0.05183371f, -0.01369440f, 0.06464057f, 0.01806619f, -0.00254571f, -0.09220661f, 
    0.01999852f, -0.17201091f, -0.01429479f, 0.01618169f, -0.09069302f, -0.09821221f, -0.00628286f, -0.06084026f, 
    -0.01754842f, -0.02526526f, -0.05420741f, -0.08705771f, 0.03516796f, -0.00615116f, 0.14702027f, 0.08808617f, 
    0.10624558f, 0.02193376f, -0.00319243f, -0.01899815f, -0.06271815f, 0.01042193f, 0.02889460f, -0.00893859f, 
    -0.16809407f, -0.11008073f, 0.03539877f, -0.10324767f, 0.19777493f, -0.09214984f, -0.05257009f, -0.02040573f, 
    -0.01636754f, 0.08429573f, -0.02256313f, 0.01062817f, 0.04151951f, -0.28965509f, 0.08007164f, 0.10784303f, 
    -0.03390575f, -0.01152347f, -0.02633447f, 0.01686067f, 0.03622919f, -0.07241493f, -0.00007811f, -0.09328842f, 
    0.16006577f, 0.15253001f, 0.03999001f, 0.08775756f, 0.02338854f, -0.02837556f, -0.02593765f, 0.05092328f, 
    -0.02660962f, 0.06031662f, -0.04362142f, -0.01928006f, 0.22041996f, 0.05832735f, 0.01407660f, -0.03970352f, 
    0.03399133f, 0.03103368f, -0.05938299f, -0.08882171f, -0.04379352f, -0.02185505f, -0.00423463f, -0.12188846f, 
    -0.02489405f, 0.06052184f, -0.01142114f, -0.06839377f, 0.07054759f, 0.04594641f, 0.02185299f, -0.11301117f, 
    0.05552477f, 0.01098508f, -0.03204916f, -0.01763427f, 0.07609452f, -0.22691327f, 0.01179309f, 0.07141919f, 
    -0.06285091f, 0.01922912f, -0.03191579f, -0.07030873f, 0.05673532f, 0.06462409f, -0.06479055f, 0.01384444f, 
    -0.04133553f, -0.28042522f, -0.14646485f, -0.06234958f, -0.03224576f, -0.06321139f, -0.07586065f, -0.08762600f, 
    -0.04686528f, -0.04260922f, 0.01976661f, 0.05196542f, -0.15623274f, -0.37518367f, -0.03946363f, 0.03242657f, 
    -0.02805517f, 0.00753176f, 0.03404852f, -0.00592858f, -0.04734523f, -0.06082267f, -0.09614827f, -0.00962848f, 
    -0.00134564f, 0.09400220f, 0.05284401f, 0.09075870f, 0.09843976f, -0.03431057f, 0.08145262f, 0.03381218f, 
    0.05975692f, -0.00584872f, 0.02271644f, -0.02079278f, 0.03889318f, 0.19235855f, 0.04832746f, 0.01058902f, 
    -0.01520809f, 0.02289955f, -0.00484128f, -0.05599636f, -0.06348112f, 0.03966419f, -0.00417563f, -0.07248107f, 
    -0.06435885f, 0.08646285f, -0.13028847f, -0.06949519f, 0.07281756f, 0.05063199f, -0.01431148f, -0.09108099f, 
    -0.08320291f, -0.02697467f, -0.00088378f, -0.08227199f, -0.15049563f, 0.04829855f, 0.13891633f, 0.09810202f, 
    0.14215957f, -0.01685247f, -0.02704801f, 0.05587520f, -0.08019316f, -0.02044262f, 0.01830246f, 0.03636488f, 
    0.20958543f, -0.21147978f, 0.03701821f, -0.18027364f, -0.02696049f, 0.00849604f, -0.01561347f, -0.05449141f, 
    -0.03894110f, -0.00938151f, -0.02539057f, 0.02916428f, -0.05882632f, -0.10646287f, -0.12918630f, -0.09897283f, 
    -0.03670692f, -0.03424141f, -0.03089794f, -0.08019813f, 0.02768245f, -0.06985652f, -0.01662596f, 0.04746643f, 
    -0.14344344f, -0.00758208f, -0.03450090f, -0.15710554f, 0.06166671f, -0.04162450f, -0.03208151f, -0.05102863f, 
    0.01615457f, 0.04290667f, -0.00937612f, -0.03948009f, -0.13311736f, 0.16358036f, 0.08783519f, 0.09493995f, 
    0.04125824f, 0.05584515f, 0.06109228f, -0.02338454f, -0.01729192f, -0.01391022f, 0.01583474f, -0.08168104f, 
    0.26497889f, -0.01000104f, 0.18341805f, 0.03322902f, -0.02809048f, -0.01168616f, 0.05747209f, 0.10437678f, 
    -0.04098622f, 0.04596251f, -0.09030712f, -0.02997315f, 0.37947127f, 0.04612001f, 0.10802680f, 0.14114724f, 
    0.06330584f, 0.05127404f, -0.02278971f, -0.04694815f, -0.07791009f, -0.03224477f, -0.04254343f, -0.07274665f, 
    -0.02910519f, 0.06903511f, -0.13070352f, 0.04846891f, -0.05569059f, -0.03904146f, -0.04050223f, 0.02343677f, 
    0.01048266f, 0.01282568f, -0.05764098f, 0.01468203f, 0.11457483f, 0.17139997f, 0.09285773f, 0.22680025f, 
    0.11014387f, 0.07523043f, 0.01358305f, 0.01119706f, -0.04118811f, -0.02611264f, -0.04787935f, -0.02060332f, 
    0.06882961f, 0.17982796f, -0.08424117f, 0.20758435f, 0.01724594f, 0.06284741f, -0.03851636f, 0.05869778f, 
    0.00118600f, -0.12362270f, -0.05124507f, -0.03488094f, 0.13886909f, -0.11302146f, 0.16760603f, -0.04876538f, 
    -0.03668984f, 0.07096780f, -0.05989832f, -0.01958171f, -0.01293733f, 0.05962579f, -0.02859316f, 0.00834473f, 
    0.29823634f, -0.29273653f, 0.11654314f, 0.08333234f, 0.01876796f, -0.09604902f, -0.09702487f, 0.02877987f, 
    -0.02554075f, 0.05632908f, -0.03679473f, -0.05465071f, 0.08469427f, 0.02780532f, -0.28165334f, 0.20426308f, 
    -0.06624836f, -0.01113604f, -0.01138216f, 0.01723365f, 0.00971251f, 0.05333436f, 0.07633999f, -0.03899033f, 
    -0.03487077f, -0.11280434f, -0.12733492f, -0.06808627f, -0.03354419f, -0.04421251f, 0.02505425f, -0.09088591f, 
    -0.05161340f, -0.00430836f, -0.02886435f, -0.07760866f, -0.12314977f, 0.09514364f, 0.02349793f, 0.17902520f, 
    0.02156075f, -0.07638206f, -0.00571571f, -0.03974027f, 0.02808317f, 0.00173687f, -0.01849681f, 0.03147012f, 
    0.15931030f, 0.15553588f, 0.06987622f, 0.28389251f, 0.03147585f, 0.00763786f, 0.06638841f, -0.07377614f, 
    -0.05576444f, -0.06720562f, -0.12758979f, -0.01108685f, -0.04421141f, -0.02175399f, -0.01742120f, 0.00431312f, 
    0.08529054f, 0.02513973f, -0.02168731f, 0.03524200f, 0.03905327f, 0.00878651f, 0.03382018f, -0.06035874f, 
    -0.23462000f, 0.08178092f, -0.03618457f, -0.08786179f, 0.01043442f, -0.04381299f, 0.03729878f, -0.07498758f, 
    -0.04628694f, 0.03101119f, 0.00100536f, -0.04164946f, -0.15813829f, 0.00795098f, -0.01668853f, -0.04081216f, 
    -0.00927064f, 0.07984728f, -0.02506092f, -0.10457057f, -0.03444817f, -0.02426766f, -0.03716375f, -0.06992207f, 
    0.01786464f, 0.07337036f, -0.08507867f, 0.10153614f, -0.05945587f, -0.03092114f, -0.13665923f, -0.08980578f, 
    -0.08447836f, -0.01232844f, 0.02859039f, -0.09947059f, -0.00069215f, -0.02874488f, -0.05676111f, 0.04273244f, 
    -0.05976800f, -0.03810372f, -0.08261207f, -0.01854466f, -0.05476094f, -0.01058796f, -0.02638123f, -0.05030573f, 
    -0.12992105f, -0.07655318f, -0.04433363f, 0.02640780f, 0.06066732f, -0.11221269f, -0.06217702f, 0.03804476f, 
    -0.09697598f, 0.10364202f, -0.08079438f, 0.04471753f, 0.12561299f, -0.06933672f, 0.16718802f, 0.02927166f, 
    -0.07938319f, 0.01647739f, -0.04832922f, 0.01127553f, 0.01606801f, 0.06771673f, -0.04222862f, -0.08743937f, 
    0.00865366f, -0.21464007f, -0.05798689f, -0.10048254f, -0.01372337f, -0.10047732f, 0.03288136f, -0.02047819f, 
    -0.07497772f, -0.00701921f, -0.01868145f, -0.03930466f, -0.25521746f, 0.02731430f, -0.05585687f, 0.11385497f, 
    -0.03366034f, -0.13704735f, -0.16902979f, -0.03667520f, -0.02264144f, 0.01337946f, 0.09034697f, 0.01067625f, 
    -0.05135060f, -0.10954412f, -0.09613819f, -0.14910094f, -0.04825610f, -0.02147410f, -0.02921776f, -0.00434219f, 
    -0.01446379f, 0.00630815f, -0.02371000f, -0.01607837f, 0.21318804f, 0.03546315f, 0.06526483f, 0.02511498f, 
    0.04494268f, 0.00515193f, -0.03220550f, -0.01905986f, -0.04294823f, -0.02335892f, 0.08383525f, -0.00081097f, 
    0.01184179f, 0.09252106f, 0.11167059f, 0.14950387f, -0.02895783f, -0.12371849f, 0.05065383f, -0.08125456f, 
    0.03480600f, -0.04696703f, 0.00035790f, 0.05259756f, -0.13258927f, 0.05178539f, -0.14491639f, -0.10128209f, 
    0.08070352f, -0.00962749f, -0.00036543f, -0.10146073f, 0.07216738f, -0.05492810f, -0.04343783f, 0.00572445f, 
    -0.07699696f, -0.01356756f, -0.00173575f, -0.18217926f, -0.14935772f, 0.04037263f, 0.04303017f, -0.05116246f, 
    0.00883678f, -0.00689946f, 0.05312246f, 0.03997742f, -0.02935087f, 0.14869541f, -0.03670030f, 0.11408944f, 
    -0.01853835f, -0.03494246f, -0.00835007f, -0.06010676f, 0.04415533f, -0.01833670f, -0.01787010f, -0.05888547f, 
    0.05231705f, -0.09354762f, 0.00383411f, 0.10057809f, 0.12331497f, -0.10973220f, -0.03557580f, -0.09327438f, 
    0.02230658f, -0.05207871f, -0.08704010f, -0.13837542f, 0.06306948f, 0.21793029f, 0.02111178f, 0.00016088f, 
    0.03298208f, -0.09221607f, -0.01471241f, -0.12581643f, 0.03108233f, 0.00614220f, 0.06057838f, 0.07292333f, 
    0.11134051f, -0.00711627f, -0.12904336f, 0.09256720f, 0.00121762f, -0.08880706f, -0.05497470f, 0.02874262f, 
    -0.00936760f, 0.02630413f, 0.07886141f, -0.05513473f, -0.13344531f, 0.09148381f, 0.14531673f, -0.16843468f, 
    -0.03967533f, -0.07352980f, -0.06540114f, -0.02145492f, 0.02106127f, 0.00100318f, 0.06672589f, 0.03065745f, 
    0.04289855f, -0.23164459f, 0.07494340f, -0.05824598f, -0.00930530f, 0.07002036f, -0.01237032f, 0.04471670f, 
    0.05956415f, 0.10471225f, -0.02547795f, -0.02137494f, 0.06719829f, -0.02793446f, -0.12972569f, -0.22168468f, 
    0.03323378f, 0.12171344f, 0.06172689f, -0.04801553f, -0.06583417f, 0.10140290f, -0.12279306f, -0.16952717f, 
    0.08668762f, 0.25447884f, -0.09222009f, -0.03588819f, 0.05106804f, 0.00343315f, -0.07373356f, -0.02458922f, 
    -0.03045900f, -0.02952327f, 0.05889487f, 0.03734442f, -0.16165088f, -0.16821948f, -0.04216889f, -0.13255137f, 
    -0.03609310f, -0.03937586f, -0.11200415f, -0.00493046f, 0.11725485f, -0.02030829f, 0.06706287f, -0.04591452f, 
    0.05313312f, 0.06717013f, 0.00027174f, 0.10913228f, 0.00013413f, -0.02190129f, 0.10211241f, 0.08647162f, 
    -0.03248017f, 0.02263996f, -0.06145350f, -0.01849049f, 0.11020787f, -0.15550564f, -0.17730367f, 0.06779257f, 
    0.10057241f, -0.02811691f, -0.16051690f, -0.03215544f, 0.08824883f, -0.02348594f, 0.06063941f, 0.00181019f, 
    0.18014383f, -0.04267295f, 0.01992347f, 0.12130577f, 0.01275905f, -0.03461348f, 0.04530072f, -0.01540838f, 
    -0.07177547f, -0.04779555f, -0.01929716f, 0.00404582f, 0.12054412f, -0.03462267f, 0.07286494f, 0.11405099f, 
    -0.12065117f, -0.06490735f, -0.01793517f, -0.04603795f, 0.02198428f, -0.06440013f, -0.01012703f, -0.12926379f, 
    0.13732846f, -0.16044249f, -0.20156471f, -0.03158049f, -0.03626912f, -0.17635539f, 0.01300766f, -0.03597067f, 
    0.09171917f, 0.02364165f, -0.01252111f, 0.01759733f, 0.04208839f, -0.06639663f, 0.12520429f, -0.02239839f, 
    -0.06975644f, -0.16419210f, 0.01368890f, -0.02009691f, -0.02447762f, 0.03743626f, -0.11067171f, -0.04115064f, 
    -0.10738423f, -0.08757946f, 0.15030085f, 0.07498861f, -0.02044164f, -0.01321869f, -0.08562505f, -0.08745753f, 
    -0.03162886f, 0.01961805f, 0.05955963f, -0.10812289f, -0.14629699f, -0.04581483f, 0.12819798f, -0.11062514f, 
    -0.06797423f, 0.03792053f, -0.02845609f, -0.04575482f, -0.03341594f, -0.01468769f, 0.03927581f, 0.10842164f, 
    -0.01995172f, 0.06901330f, 0.16716020f, 0.09697720f, -0.03439226f, 0.04512257f, -0.03087224f, -0.08543048f, 
    0.09442067f, -0.06979509f, 0.11115686f, 0.01895608f, 0.19804935f, -0.06450212f, -0.23628795f, -0.02798161f, 
    0.02699490f, -0.04525177f, 0.05054071f, 0.00258635f, -0.00572366f, -0.04200925f, -0.07048232f, 0.07017829f, 
    -0.11736453f, -0.01287546f, -0.08862577f, 0.07166200f, -0.17902155f, -0.00311239f, 0.08794920f, -0.16601473f, 
    0.07563881f, 0.01044033f, -0.00129894f, 0.04186553f, 0.02834011f, 0.00247840f, 0.03295530f, 0.12646578f, 
    -0.05041160f, -0.06359652f, -0.05055599f, -0.11065798f, -0.02485926f, 0.01164429f, -0.00910392f, 0.14400777f, 
    -0.20273693f, -0.04911076f, -0.14353752f, -0.23719518f, -0.04794551f, -0.02825653f, -0.01022945f, -0.03295175f, 
    -0.06204619f, 0.01640913f, -0.00639488f, 0.00318766f, 0.04521796f, -0.12633069f, 0.19344582f, 0.05968713f, 
    -0.01946079f, 0.02228590f, 0.08443909f, 0.02238864f, 0.00959983f, -0.04804031f, -0.00820245f, -0.15483187f, 
    0.11821944f, -0.14145394f, 0.02186930f, -0.04162104f, 0.02836098f, 0.03892747f, -0.08512785f, 0.01443650f, 
    0.13247965f, -0.04083096f, -0.08505921f, -0.23920847f, 0.07690208f, -0.02570761f, 0.07272719f, 0.06757125f, 
    0.06092108f, 0.00536929f, -0.03542396f, -0.13491143f, -0.09409802f, 0.05101286f, -0.06553273f, 0.11815881f, 
    -0.11621404f, 0.11420133f, -0.07650040f, -0.17130321f, 0.07817301f, 0.04003601f, -0.09684333f, 0.00815731f, 
    0.15078372f, -0.01896331f, 0.00066016f, -0.10384136f, -0.17463158f, -0.11142415f, 0.15792432f, 0.07189957f, 
    0.06337585f, -0.14383180f, -0.07685988f, 0.11673608f, -0.04412275f, 0.13845900f, 0.07617595f, -0.07135198f, 
    0.28586289f, 0.13824086f, -0.05620658f, 0.09785134f, 0.03026833f, -0.02178938f, -0.03849178f, 0.05480126f, 
    0.01290764f, -0.05957297f, 0.02299764f, 0.03506611f, 0.12373070f, -0.03437153f, 0.02611259f, 0.01850498f, 
    0.01997785f, -0.01522701f, -0.07772822f, -0.02091311f, -0.02782462f, -0.01611623f, 0.07483920f, -0.03013963f, 
    -0.15786915f, -0.25458404f, 0.01452204f, 0.20043610f, 0.17525358f, 0.08661472f, -0.02313027f, -0.08154508f, 
    -0.01283848f, 0.07979036f, 0.09749407f, 0.04656539f, 0.15444510f, 0.04492070f, -0.25935766f, -0.06397817f, 
    0.09361137f, -0.03451690f, 0.00787951f, -0.06565235f, -0.08577899f, 0.01081131f, -0.00546313f, 0.08448772f, 
    -0.01546498f, 0.04721261f, 0.05354400f, 0.14789222f, -0.14891887f, 0.01327339f, -0.07906455f, -0.05465114f, 
    -0.04374072f, -0.09982570f, 0.02516706f, -0.05246384f, -0.21233548f, -0.01542686f, 0.09770360f, 0.08487645f, 
    -0.05436162f, 0.07836770f, -0.07249258f, -0.03861970f, 0.00333570f, -0.03141863f, 0.03633401f, 0.00561450f, 
    -0.17160375f, -0.06181094f, 0.14185458f, 0.14037533f, 0.06613725f, 0.02356873f, 0.01856645f, -0.05328484f, 
    -0.04339390f, 0.08391468f, -0.03383345f, 0.05299845f, -0.10910933f, -0.05306455f, -0.14412242f, -0.02956356f, 
    -0.07027587f, -0.06743722f, -0.09406685f, -0.03077144f, 0.08363917f, 0.03136475f, 0.01683150f, 0.07358075f, 
    0.10339579f, 0.04831365f, 0.03404529f, 0.11076818f, -0.05204114f, -0.07181721f, 0.04934991f, -0.14524825f, 
    -0.03420397f, -0.00716861f, 0.03109054f, -0.05504654f, 0.11295950f, 0.01311217f, -0.00366076f, 0.11478453f, 
    0.10694791f, 0.04735772f, 0.01010893f, -0.08756074f, 0.01337821f, 0.01841726f, 0.01530172f, 0.06440996f, 
    0.08556692f, 0.04894904f, -0.02192046f, 0.13136417f, 0.04813101f, -0.03126707f, -0.06206781f, -0.01548492f, 
    0.03959895f, 0.03284611f, -0.09484219f, 0.01929461f, -0.24141754f, 0.03306145f, 0.15433426f, 0.08926260f, 
    -0.06355742f, 0.03858013f, -0.03585292f, -0.11808203f, 0.00407804f, -0.00630396f, 0.07613575f, 0.05539450f, 
    -0.04273064f, -0.29572588f, 0.14289053f, -0.18432330f, 0.02204480f, -0.10032941f, 0.08453909f, -0.15264677f, 
    -0.01695954f, 0.13288468f, -0.10884694f, 0.10389414f, 0.28314263f, -0.08875131f, -0.12925495f, -0.16110338f, 
    0.02952614f, -0.01980533f, 0.02994750f, -0.03175855f, -0.00875598f, 0.04878294f, -0.00870206f, 0.10014550f, 
    0.16242446f, 0.14320993f, -0.05336136f, -0.04767341f, -0.05355237f, 0.04109866f, 0.07307344f, -0.03218472f, 
    -0.02619261f, -0.01709540f, 0.00789259f, -0.02525441f, -0.00613557f, -0.06185305f, 0.09982137f, -0.10039887f, 
    -0.02980136f, -0.08376464f, 0.00171148f, -0.09152926f, -0.00263504f, -0.10544919f, -0.01973015f, 0.06438257f, 
    -0.10808256f, -0.05610799f, -0.13321866f, -0.28147805f, 0.13188045f, -0.00458681f, -0.17700860f, -0.06497401f, 
    -0.07837396f, 0.03255351f, -0.05724270f, -0.15906580f, -0.23936595f, -0.11736652f, 0.16381562f, -0.08460379f, 
    -0.10800720f, -0.02977596f, 0.02231806f, -0.10067956f, -0.03741118f, 0.03897988f, 0.02065743f, 0.08848556f, 
    0.02409194f, -0.02177920f, -0.17857233f, 0.01835332f, -0.04206859f, -0.00584033f, -0.00171404f, -0.07522929f, 
    0.05159126f, 0.06435453f, 0.07194741f, 0.02125891f, 0.18341666f, 0.10953307f, -0.00726811f, -0.10598399f, 
    0.01166731f, -0.02475751f, -0.00908333f, -0.03763446f, 0.01985350f, -0.01658208f, 0.12142586f, 0.06128905f, 
    0.14737688f, 0.07408100f, 0.01593629f, 0.13024282f, 0.07780746f, -0.02234271f, -0.08010773f, -0.01428872f, 
    0.07385249f, -0.06232565f, 0.03469962f, -0.08912102f, 0.02588430f, -0.09177930f, -0.14347537f, -0.25275075f, 
    0.00362167f, -0.12462229f, 0.02901441f, -0.04436201f, -0.01703094f, 0.14805087f, 0.12071808f, 0.02150282f, 
    -0.09459890f, -0.07853046f, 0.05327830f, -0.23379250f, -0.03801556f, -0.02589710f, 0.14018756f, 0.04157207f, 
    -0.02338979f, -0.09225015f, 0.02445393f, -0.17199399f, 0.03669427f, -0.00911362f, 0.12683438f, 0.04117786f, 
    -0.07691402f, -0.10212608f, -0.04943172f, -0.00742051f, 0.06698342f, -0.04846860f, -0.08416243f, 0.07380775f, 
    0.16360950f, -0.02220935f, -0.02381523f, 0.16271588f, 0.10282884f, -0.03745849f, -0.01932940f, -0.05404423f, 
    -0.00363979f, -0.03205999f, 0.05699473f, -0.06619439f, 0.07409974f, -0.08446874f, 0.06762943f, 0.14478347f, 
    0.03078465f, 0.00359623f, 0.04336935f, -0.10253679f, -0.05005636f, 0.03870733f, 0.06205365f, -0.02643063f, 
    -0.05393325f, 0.11635087f, -0.11965881f, -0.23210765f, -0.05952131f, 0.08864076f, -0.05469113f, 0.01598046f, 
    0.13878618f, 0.00221025f, -0.08434497f, -0.00726682f, -0.15810753f, -0.03104093f, -0.09976639f, -0.19326966f, 
    -0.11383823f, 0.05233920f, -0.01593770f, -0.06491697f, 0.00228189f, 0.07104028f, -0.00152936f, 0.02288044f, 
    0.05592382f, 0.07086132f, -0.13870114f, -0.10363863f, -0.00051882f, 0.01978404f, -0.03288126f, -0.02814192f, 
    0.03353195f, -0.02572458f, 0.03071199f, 0.05667207f, -0.16986950f, -0.10551029f, 0.06272534f, -0.07003042f, 
    -0.12411178f, -0.09525993f, -0.11500839f, -0.02572653f, 0.09501623f, -0.07599220f, -0.23592290f, -0.06281491f, 
    -0.00954597f, -0.13611214f, -0.12141567f, 0.16829467f, 0.12953211f, -0.00425333f, -0.05695780f, -0.00258282f, 
    -0.01067159f, 0.04718390f, 0.16605683f, 0.02509801f, -0.30177435f, -0.12319428f, -0.28297555f, -0.10639573f, 
    0.05651464f, 0.07570894f, -0.02016008f, -0.00665706f, 0.03881064f, -0.03266962f, 0.02158439f, 0.06430791f, 
    0.06976608f, -0.15614186f, -0.15635403f, 0.09277177f, 0.07080289f, 0.02466310f, 0.00994707f, -0.06816305f, 
    -0.02685438f, -0.01285938f, 0.09528983f, -0.16713683f, -0.14546444f, -0.15638265f, 0.06768344f, -0.29286605f, 
    -0.01162163f, -0.00163348f, -0.01754353f, 0.01828834f, -0.03821713f, -0.02201754f, -0.04629190f, 0.07936777f, 
    -0.01234238f, -0.17462498f, 0.13530225f, 0.01386558f, 0.05451741f, 0.00029124f, -0.04196744f, 0.04468497f, 
    -0.00441809f, 0.05579640f, 0.09857508f, -0.08444391f, -0.51089126f, -0.04012008f, -0.06744891f, -0.01890044f, 
    -0.01191145f, 0.01055491f, -0.14051694f, 0.00911356f, 0.10564626f, -0.01851127f, 0.04089437f, 0.06914328f, 
    -0.17071988f, 0.07355868f, -0.06781379f, 0.11197501f, 0.06936272f, -0.02933295f, -0.11773614f, -0.11017145f, 
    -0.19969802f, -0.05951507f, 0.01890720f, -0.01768732f, -0.22260559f, -0.09369349f, -0.03205735f, -0.08450432f, 
    0.11159847f, -0.05346028f, -0.09181062f, 0.03231928f, 0.09633271f, -0.06441455f, 0.04143773f, 0.03775785f, 
    -0.04607890f, -0.09672430f, 0.12807275f, -0.00352251f, 0.01077461f, 0.02719822f, 0.02207334f, -0.10113971f, 
    -0.00640347f, 0.03812053f, -0.07475128f, 0.12922551f, 0.41295671f, 0.02907554f, -0.24602109f, -0.11432920f, 
    0.13142130f, 0.00196216f, 0.04342651f, 0.07947028f, -0.10397848f, -0.11429442f, -0.12095144f, 0.00983925f, 
    0.02332088f, 0.08925638f, -0.16302270f, -0.10414757f, 0.03271909f, 0.04331576f, -0.05844599f, -0.07999216f, 
    -0.15819967f, 0.04558097f, -0.13168401f, -0.05030191f, -0.08765996f, -0.19446170f, -0.04768649f, -0.15326495f, 
    0.15863018f, 0.08400553f, -0.13135338f, -0.05386889f, -0.02943673f, -0.08003452f, -0.11111336f, 0.03634540f, 
    -0.05982240f, -0.17131937f, -0.02590006f, 0.17437911f, 0.02465975f, -0.05094274f, 0.00494422f, -0.11551937f, 
    0.02407456f, -0.02766062f, -0.02234488f, 0.07695158f, 0.04761566f, -0.21378334f, 0.02270486f, 0.00722299f, 
    0.00506226f, -0.03739046f, -0.03679277f, -0.03661377f, 0.05726726f, 0.13805959f, -0.03861218f, 0.14693636f, 
    -0.01749294f, -0.27749535f, 0.22414671f, 0.05777998f, -0.06947603f, 0.07135839f, -0.05846881f, 0.17238797f, 
    0.00707237f, -0.02929919f, 0.01311754f, -0.14016199f, -0.02664463f, -0.20038886f, 0.01464157f, 0.13205189f, 
    -0.11391456f, 0.12347997f, 0.07164451f, -0.08667745f, -0.09538392f, 0.05700266f, 0.00595495f, -0.05216413f, 
    -0.08413556f, 0.05205389f, 0.13162431f, -0.06256815f, -0.05855659f, -0.05453504f, 0.03986299f, -0.10087722f, 
    0.05090463f, -0.02596511f, -0.00449453f, -0.03138079f, -0.38737565f, 0.30002686f, -0.12720348f, -0.21472368f, 
    0.04710444f, -0.08634424f, -0.10844162f, -0.00776165f, -0.04942215f, 0.07625874f, 0.05725609f, -0.06021779f, 
    -0.43439242f, 0.17500585f, -0.10776771f, -0.09675226f, 0.06441116f, -0.05774365f, -0.09196249f, -0.10531910f, 
    -0.10386754f, 0.06163323f, 0.09365615f, -0.02786603f, 0.18272340f, -0.05982476f, 0.12194934f, -0.05346290f, 
    0.07155734f, 0.03560126f, 0.06150648f, -0.02743129f, -0.04797360f, -0.07142735f, 0.00591357f, -0.00263034f, 
    0.00127542f, -0.04385843f, -0.04608599f, 0.06186550f, -0.09085832f, 0.03530328f, 0.05627106f, -0.01924201f, 
    0.00281609f, 0.01422208f, -0.01572087f, 0.02260279f, 0.09370612f, 0.08529738f, -0.01342660f, 0.06617248f, 
    0.00878974f, -0.04021562f, -0.11006474f, 0.07683283f, -0.03253758f, -0.03047318f, 0.03197324f, 0.05073509f, 
    -0.07858413f, -0.19214518f, -0.12973863f, 0.03997513f, 0.05025753f, -0.09557240f, 0.07819185f, -0.09080598f, 
    0.14603510f, -0.08099841f, 0.11540158f, -0.02717883f, -0.16372289f, -0.02107543f, -0.00515542f, 0.18831152f, 
    -0.06060394f, 0.00864751f, 0.02765429f, -0.03670149f, -0.02201204f, 0.06767946f, -0.01488169f, 0.01404914f, 
    0.50653493f, 0.05959255f, -0.13648684f, -0.27344427f, 0.03628197f, -0.02489039f, 0.13332804f, -0.00983817f, 
    -0.01956518f, 0.08538479f, 0.07862394f, 0.11455695f, -0.06256916f, 0.02540728f, 0.16940001f, -0.07426378f, 
    -0.02352075f, 0.04828816f, 0.10170170f, 0.02715958f, 0.12627997f, 0.09262202f, -0.01044181f, 0.00503323f, 
    -0.09903277f, 0.39718172f, -0.29415816f, 0.13793109f, 0.07576253f, -0.17418954f, 0.04368344f, -0.06932697f, 
    -0.02440940f, 0.09220093f, 0.00512736f, -0.01960890f, -0.12725788f, 0.12271710f, 0.05207667f, -0.03790490f, 
    0.06004278f, 0.03540158f, 0.08268724f, -0.00055403f, 0.14829877f, -0.05276911f, -0.00736223f, -0.01321371f, 
    0.03592450f, -0.04718128f, -0.08842596f, -0.05274389f, -0.07198156f, 0.04785489f, -0.04278595f, 0.04383380f, 
    0.02198632f, 0.01649582f, 0.01402288f, -0.05635636f, 0.03629798f, 0.02049451f, 0.14246328f, 0.09507030f, 
    0.06341311f, 0.12776221f, -0.12085857f, -0.05893467f, 0.02357936f, 0.09953608f, -0.04916898f, 0.09946407f, 
    0.05784230f, -0.03842082f, 0.06966914f, 0.03759776f, 0.02993606f, -0.09341708f, 0.07961888f, -0.04583804f, 
    0.06477551f, 0.00627881f, 0.00792066f, 0.17057069f, 0.13485950f, -0.11137857f, -0.19284049f, -0.08114940f, 
    -0.07095337f, -0.09790069f, 0.00720275f, 0.06623101f, 0.14834240f, -0.10238823f, 0.02537894f, -0.07163481f, 
    -0.34809804f, -0.11513372f, 0.35227060f, 0.10202348f, 0.02081845f, -0.01093529f, -0.03238520f, 0.08239804f, 
    0.07275076f, -0.01802425f, 0.00732222f, 0.06073865f, 0.08406465f, -0.01027574f, -0.02988653f, 0.09660448f, 
    -0.04784012f, -0.00109204f, 0.00754556f, 0.01081423f, 0.04209247f, -0.00487180f, 0.01907891f, 0.05219973f, 
    -0.09928730f, -0.32052642f, 0.17986782f, -0.13748613f, 0.02604710f, -0.02305157f, 0.00153426f, -0.04896598f, 
    -0.12637381f, -0.02001887f, 0.11847007f, 0.06942658f, 0.15446274f, -0.06639874f, -0.27110258f, -0.12127085f, 
    0.00489702f, 0.07180823f, 0.02607623f, 0.08075251f, -0.07805597f, -0.03097657f, -0.16804101f, 0.06875582f, 
    -0.24683732f, -0.01939731f, -0.17120144f, -0.44540599f, -0.01618774f, -0.06725455f, -0.04231843f, -0.09443569f, 
    -0.04040089f, -0.06650876f, -0.11357170f, 0.07919686f, 0.17175353f, 0.00065658f, 0.16443008f, 0.00454678f, 
    0.02949094f, 0.03095716f, 0.01069115f, 0.08045190f, -0.06408652f, 0.15716097f, 0.02804422f, 0.05900092f, 
    -0.11079815f, -0.20006253f, 0.15627980f, -0.01032516f, -0.01952291f, -0.01431576f, 0.09322630f, 0.11923111f, 
    0.03456475f, 0.00903462f, 0.04019162f, -0.00760080f, 0.05473435f, -0.17808475f, -0.02384491f, -0.05893351f, 
    0.16501272f, 0.05727310f, -0.03990796f, 0.03957342f, -0.11054461f, 0.11332985f, -0.04416750f, 0.12065221f, 
    -0.13729464f, 0.15641229f, -0.14253259f, -0.15011358f, 0.05962865f, -0.05630393f, -0.00990819f, 0.05542071f, 
    -0.01684664f, -0.08419465f, 0.09264886f, -0.07400788f, 0.23913221f, -0.52541465f, -0.10789432f, 0.16510625f, 
    0.01068746f, -0.06469245f, 0.00314747f, 0.08159401f, -0.14627898f, -0.09418707f, 0.02066535f, 0.02198935f, 
    0.34048510f, -0.13436757f, 0.04826375f, -0.10092681f, -0.03995981f, 0.02824307f, 0.01568565f, 0.01385934f, 
    0.06287526f, 0.04685267f, -0.02156458f, -0.03721529f, 0.16376530f, 0.04962195f, 0.01470328f, -0.13532266f, 
    0.09385362f, 0.17766978f, 0.04256003f, -0.10168968f, -0.02670043f, -0.07276000f, -0.00681807f, 0.00010206f, 
    -0.01501195f, 0.24129277f, -0.04923949f, -0.16739607f, 0.13069667f, 0.00971639f, -0.05706827f, -0.03916673f, 
    -0.03242140f, 0.00688745f, 0.05899929f, -0.02512160f, -0.16222061f, -0.31259528f, -0.10432045f, -0.03862833f, 
    0.02519953f, -0.01528766f, 0.00730225f, 0.03985162f, 0.04359221f, 0.06854476f, 0.07214119f, 0.01871695f, 
    0.22329880f, 0.12710515f, 0.02138500f, 0.07486992f, 0.01336094f, -0.05767498f, 0.06370879f, -0.03316459f, 
    0.04011219f, -0.05678425f, 0.17579231f, -0.13504550f, -0.01802584f, -0.08297654f, 0.13512692f, -0.17749959f, 
    0.03470451f, -0.06076623f, 0.04443469f, -0.07177350f, -0.15027954f, -0.09166855f, -0.02496620f, -0.01731640f, 
    0.07298744f, 0.03383723f, -0.06150531f, 0.09743261f, 0.07137176f, 0.01874197f, -0.09221738f, 0.10890543f, 
    0.01890021f, -0.01630398f, 0.01601594f, 0.03170761f, 0.22640958f, -0.03333132f, 0.02214960f, -0.04697263f, 
    0.04795606f, 0.09322494f, 0.11477441f, 0.00262139f, 0.07165201f, -0.09760965f, 0.05747696f, -0.13155812f, 
    -0.34036514f, 0.02453377f, 0.06000620f, -0.08231408f, -0.10748611f, -0.02159778f, 0.04881901f, 0.06973544f, 
    0.02391528f, -0.03846357f, 0.00961068f, 0.03925179f, 0.15881388f, -0.17354350f, -0.12682573f, 0.29654616f, 
    -0.03396271f, -0.04430412f, 0.02249179f, -0.02313533f, 0.01436434f, 0.05843422f, -0.01255888f, -0.13581809f, 
    0.43939039f, -0.28287131f, 0.10397161f, -0.12778576f, -0.03572889f, 0.03134328f, -0.06164666f, 0.14742588f, 
    -0.08097759f, -0.06556315f, -0.13586645f, 0.02475928f, 0.35470012f, 0.19895175f, 0.15937489f, -0.04181052f, 
    -0.10608215f, -0.01196595f, 0.01883324f, 0.04245543f, -0.04562357f, -0.03167833f, -0.08982289f, 0.05915388f, 
    -0.03530885f, 0.23747598f, -0.29787007f, -0.01194566f, -0.02005800f, 0.03102993f, 0.10569941f, -0.03616126f, 
    -0.11636373f, 0.02874039f, -0.02454673f, -0.11627305f, -0.35215828f, -0.09919938f, 0.16217741f, 0.14564525f, 
    -0.01277018f, 0.06248872f, -0.02243129f, 0.03433499f, 0.15445673f, -0.08595181f, 0.03224663f, -0.10069751f, 
    0.05882340f, 0.01064867f, -0.04178611f, -0.00065742f, 0.07268576f, 0.01891303f, -0.09050941f, -0.05448951f, 
    -0.00999500f, -0.03759292f, -0.01136843f, 0.10929625f, 0.22307692f, 0.02574129f, -0.01376885f, 0.06636879f, 
    0.07305162f, -0.10547756f, 0.02518531f, -0.08668331f, 0.00479232f, -0.07100412f, 0.13762255f, 0.04053235f, 
    -0.15376757f, 0.10037278f, -0.10280219f, -0.14102331f, 0.13974552f, 0.03712463f, -0.02218205f, 0.04535030f, 
    0.01574597f, 0.01553034f, -0.00468129f, -0.15739667f, -0.30985034f, 0.05447391f, -0.12739693f, 0.01011745f, 
    -0.01762702f, 0.03976414f, 0.06768678f, -0.02879898f, -0.06532133f, -0.07464151f, -0.10074116f, -0.01348490f, 
    0.14233939f, -0.04151549f, 0.10579194f, 0.12308926f, 0.02071836f, 0.10773052f, 0.03144784f, -0.12064816f, 
    -0.08509550f, -0.06057616f, -0.01904880f, 0.12654532f, 0.00405926f, 0.11050291f, -0.06546009f, -0.11877789f, 
    0.05775866f, 0.10422917f, -0.00267576f, 0.02832210f, 0.11118260f, -0.03209849f, -0.17792271f, -0.05771384f, 
    0.12753992f, -0.07759758f, 0.29156104f, -0.24664742f, 0.03836748f, 0.00145668f, -0.00208131f, -0.03684549f, 
    -0.05027780f, 0.00055149f, -0.05635343f, -0.03895755f, 0.00728795f, -0.09774359f, -0.09717471f, 0.03125761f, 
    -0.04239212f, -0.00744945f, 0.03356137f, 0.03037739f, 0.00426806f, 0.05289750f, -0.05607753f, 0.01765336f, 
    -0.24883461f, -0.06747132f, 0.04011504f, -0.17023964f, 0.10051379f, 0.06277599f, -0.11069945f, -0.01770066f, 
    -0.06022508f, -0.07326823f, -0.05023296f, -0.14033395f, -0.11923064f, 0.12923287f, -0.11203472f, -0.27829909f, 
    -0.05711798f, 0.02464268f, -0.10969044f, 0.07257147f, -0.01764174f, 0.04727968f, 0.03997845f, -0.11061382f, 
    -0.15386811f, 0.07789595f, 0.08356774f, -0.16610025f, -0.00218315f, 0.08095146f, -0.05679413f, 0.09491688f, 
    -0.01766562f, -0.07171366f, 0.01804479f, -0.04058394f, 0.24667014f, -0.04358017f, -0.22061996f, 0.12317533f, 
    -0.01908367f, -0.04254210f, -0.00665333f, 0.09212588f, -0.03290008f, 0.04127551f, 0.09103798f, -0.05504501f, 
    0.17178121f, 0.08175399f, -0.09090029f, -0.19501528f, -0.29365066f, -0.06407047f, 0.05732103f, 0.00978206f, 
    0.00084534f, -0.10803157f, 0.03531206f, -0.09163255f, -0.37017316f, -0.25308719f, -0.03174889f, 0.17208941f, 
    0.05593875f, 0.07126603f, -0.05500348f, -0.05903509f, -0.01229240f, -0.18289946f, -0.12680373f, 0.07901262f, 
    -0.01091334f, -0.07038008f, 0.04767904f, 0.07696442f, -0.17499113f, 0.07514551f, -0.05336858f, -0.01358227f, 
    0.11383043f, 0.09983312f, 0.03317176f, -0.11519511f, 0.18593933f, 0.01457639f, -0.11754008f, 0.02516039f, 
    0.01388504f, -0.00884638f, 0.15235566f, -0.02252318f, 0.07598284f, -0.01772908f, -0.11620141f, -0.07336167f, 
    -0.31989631f, -0.26909316f, -0.11069235f, -0.15695763f, 0.12028790f, -0.02028234f, -0.13450827f, -0.00862902f, 
    -0.04204964f, -0.02974577f, -0.07526232f, -0.09019964f, -0.31886941f, -0.18678701f, 0.02237128f, 0.07983150f, 
    -0.03725073f, 0.05812377f, 0.05794633f, -0.04981635f, 0.01648301f, 0.12713759f, 0.12560920f, -0.05729679f, 
    0.19001617f, -0.12950194f, -0.01719148f, 0.03631978f, -0.08410918f, -0.01309960f, -0.03852455f, 0.08890056f, 
    0.01148288f, 0.13439293f, 0.09713928f, 0.04397228f, 0.18847564f, 0.06358302f, -0.02260195f, -0.07309214f, 
    -0.05697376f, 0.05482440f, 0.08887839f, -0.01383220f, 0.06523611f, 0.12627065f, 0.07362553f, 0.02581225f, 
    0.11396396f, 0.08447765f, -0.12511750f, 0.13189773f, -0.02508790f, 0.06685302f, 0.02851107f, 0.05991171f, 
    0.12767194f, 0.04318388f, 0.00620679f, -0.13229041f, 0.13753007f, -0.06615125f, -0.03111863f, 0.10125309f, 
    0.02279890f, 0.05310615f, 0.02461490f, -0.02648044f, 0.04575872f, -0.00941222f, -0.23513542f, -0.19754206f, 
    -0.03326619f, -0.17724721f, 0.07967444f, -0.12953493f, 0.01516876f, -0.01152211f, -0.05294634f, 0.03619756f, 
    -0.02925008f, 0.05894825f, 0.02546875f, 0.05332445f, 0.16448000f, 0.10217725f, -0.04018195f, 0.05017158f, 
    0.03893632f, -0.10815571f, 0.08098252f, -0.16578054f, -0.08407266f, 0.07854462f, -0.00930428f, -0.15227570f, 
    0.12610498f, -0.12964110f, -0.01262357f, 0.08536314f, -0.00312074f, -0.03551198f, 0.05731387f, 0.03443027f, 
    0.02956789f, 0.08718235f, -0.00194465f, 0.10435461f, -0.30963644f, -0.06079442f, -0.07011500f, -0.11983145f, 
    0.09002323f, -0.03507113f, -0.01457277f, 0.09846050f, 0.10525778f, -0.05337502f, 0.04054033f, -0.07508606f, 
    -0.14251350f, -0.24964198f, -0.27853769f, -0.03110187f, -0.02323977f, -0.10108071f, 0.02983198f, 0.01791225f, 
    0.02592765f, -0.09659058f, -0.02709467f, 0.08685912f, 0.21030076f, 0.13325763f, -0.11384545f, 0.08355162f, 
    -0.07859479f, -0.10665622f, 0.01786379f, 0.01858320f, -0.02373073f, 0.02595256f, -0.09072538f, 0.02712304f, 
    -0.24806269f, -0.00980208f, 0.09892955f, 0.08577411f, 0.05761321f, -0.04377185f, 0.00036559f, 0.05859821f, 
    0.01208795f, -0.05909557f, 0.03427466f, 0.03549991f, 0.24330854f, 0.06456013f, -0.02640604f, -0.06011670f, 
    -0.03839921f, -0.22057383f, 0.06005930f, 0.06377697f, -0.04972791f, 0.02732807f, 0.02221531f, -0.01740821f, 
    0.06096699f, 0.10152611f, 0.00694194f, -0.04557851f, -0.04016079f, -0.10430361f, 0.07091088f, -0.00639170f, 
    0.00074774f, -0.07064728f, -0.12689775f, -0.08296324f, 0.27295884f, 0.12961610f, -0.03567642f, -0.00671641f, 
    0.04690416f, 0.10832490f, 0.03564364f, 0.07615176f, 0.08496159f, -0.07122582f, 0.12349869f, 0.10800040f, 
    -0.17941938f, -0.00264016f, 0.15521015f, 0.08283073f, 0.02938795f, -0.00888827f, -0.06491429f, -0.04828469f, 
    -0.06766995f, -0.05686830f, 0.01026427f, -0.10550790f, -0.28355107f, 0.11753328f, -0.13653651f, 0.12555306f, 
    0.02636877f, -0.00311855f, -0.09148490f, -0.13200341f, 0.08055519f, -0.00848471f, 0.02633600f, -0.01762453f, 
    0.07308016f, -0.06708106f, -0.02231640f, 0.06912100f, -0.01423267f, -0.15531205f, 0.07498121f, 0.05356063f, 
    -0.06178562f, 0.04542323f, 0.01859517f, 0.00385117f, -0.35835731f, -0.11097300f, -0.01202417f, 0.05239890f, 
    0.13169715f, -0.03788114f, 0.05046986f, -0.01605162f, 0.09718681f, -0.01935742f, 0.03640611f, 0.20060264f, 
    0.27076107f, 0.18822840f, -0.02272257f, -0.10180175f, -0.00496258f, -0.02288564f, 0.00154175f, 0.03452656f, 
    0.04126499f, 0.00878090f, 0.03212902f, 0.02647153f, 0.23079132f, 0.08940530f, -0.10022373f, 0.03806347f, 
    -0.02884311f, -0.13877583f, 0.11826834f, -0.07706604f, 0.12003893f, 0.04661831f, 0.03755567f, 0.01178113f, 
    0.05659234f, -0.03308968f, -0.05690920f, 0.04646258f, 0.01882363f, 0.01623560f, -0.05662508f, 0.04421076f, 
    0.02441627f, 0.03329566f, -0.01565125f, -0.04491703f, -0.27893227f, 0.01212342f, -0.20693636f, -0.05105107f, 
    0.02373853f, 0.08825959f, -0.05262936f, -0.03656369f, 0.05104873f, 0.09610415f, 0.02116255f, 0.16941975f, 
    0.08872894f, -0.10893961f, 0.07781971f, -0.16361575f, -0.08183779f, 0.02271084f, 0.04583484f, -0.02231925f, 
    -0.06165795f, -0.04159653f, -0.05374970f, -0.03965503f, -0.45077825f, -0.32583925f, -0.08238502f, -0.12094092f, 
    0.04533859f, -0.08223066f, -0.08574855f, -0.07042957f, -0.08947465f, 0.02517203f, -0.03318771f, 0.08918177f, 
    -0.41381699f, 0.05444017f, -0.23887464f, -0.04078818f, 0.01663521f, -0.05398106f, -0.05499092f, 0.01021685f, 
    -0.02615958f, -0.03597382f, -0.09387434f, -0.03452074f, -0.05885098f, -0.02443048f, -0.14865422f, -0.09400685f, 
    0.00799774f, 0.01547387f, -0.05019806f, 0.06683485f, 0.02373080f, 0.07109666f, 0.08459186f, -0.03909449f, 
    -0.22544785f, 0.00698097f, 0.06805731f, -0.21367577f, -0.00109445f, 0.00520304f, 0.04554284f, 0.09589650f, 
    0.03395427f, 0.12243216f, -0.00876158f, 0.05111194f, -0.48584089f, -0.18664235f, -0.06694783f, -0.08245234f, 
    0.10588792f, -0.04468454f, -0.08561823f, -0.03946124f, 0.03087848f, -0.00141864f, 0.00557094f, 0.11563671f, 
    0.11210421f, 0.05763455f, -0.05597579f, -0.03526091f, -0.08132143f, 0.01806442f, 0.03089405f, -0.07922009f, 
    -0.09254965f, -0.04910295f, -0.14894204f, -0.11467757f, 0.04188247f, 0.00304184f, 0.09836833f, 0.00419900f, 
    0.03223732f, 0.08370969f, 0.02812538f, 0.06028102f, 0.06072072f, -0.04963438f, -0.01875397f, -0.01435258f, 
    -0.35097325f, -0.30635741f, -0.14193723f, -0.17492180f, 0.00043577f, -0.02646868f, -0.00626564f, 0.03517660f, 
    0.06669747f, 0.05754933f, -0.09098446f, 0.00675290f, 0.06483603f, -0.13121341f, 0.03512156f, 0.07919723f, 
    0.08000445f, -0.02011837f, 0.01537348f, -0.08119942f, 0.05398044f, 0.17236644f, 0.03007231f, 0.06135782f, 
    0.04605594f, -0.09729790f, -0.14346844f, 0.11288145f, 0.00525835f, -0.01487844f, -0.04435610f, 0.03523624f, 
    0.00108223f, 0.06546275f, -0.01401189f, 0.03008692f, -0.49265659f, -0.24224164f, 0.06257211f, -0.13667867f, 
    0.08897699f, -0.02939905f, 0.02000237f, 0.01786890f, 0.08550411f, 0.06186681f, 0.00584062f, 0.08819339f, 
    -0.23155217f, -0.04403479f, -0.13742174f, -0.14637059f, 0.15932426f, 0.03903722f, -0.09174035f, -0.03630158f, 
    0.09123547f, -0.04169756f, 0.11173052f, 0.13785315f, 0.10062246f, 0.07341214f, -0.04821622f, 0.05845623f, 
    0.00485268f, -0.05857219f, 0.07731547f, -0.04515665f, 0.05877561f, 0.00296768f, 0.05058479f, 0.02571120f, 
    0.10132796f, -0.07105055f, 0.06159605f, 0.16567427f, -0.02977734f, 0.11090407f, -0.07466166f, -0.08244748f, 
    0.21138853f, 0.02784262f, 0.07630797f, 0.10312851f, -0.01585335f, 0.17187269f, -0.07088436f, 0.01302310f, 
    -0.00265858f, -0.11404087f, -0.05820520f, 0.04945437f, 0.03143995f, 0.14107588f, -0.02527352f, -0.00471120f, 
    -0.13660032f, -0.00796388f, 0.04270240f, 0.07922735f, 0.06972390f, 0.01468040f, 0.04892875f, -0.01290260f, 
    0.11263568f, 0.13002452f, 0.14968239f, 0.04324924f, 0.08822352f, 0.04862114f, -0.01543912f, -0.11614536f, 
    0.04651484f, -0.12782705f, 0.11854721f, -0.15630548f, -0.09990755f, -0.08178394f, 0.02468644f, 0.09638082f, 
    -0.05077317f, -0.09297527f, 0.03416406f, -0.05054094f, 0.07372809f, -0.02413158f, 0.01582045f, -0.00664302f, 
    -0.13680610f, 0.02942529f, -0.20791663f, -0.17110825f, 0.18750151f, -0.07506455f, -0.02027290f, 0.02173905f, 
    0.00035983f, 0.06078283f, -0.01970954f, 0.05870215f, -0.01887033f, 0.03324882f, -0.02254146f, 0.05514771f, 
    -0.14977746f, 0.08034918f, -0.22813587f, -0.03580035f, -0.01910410f, 0.02667138f, 0.06194838f, 0.01115232f, 
    0.10392883f, 0.03965994f, 0.08354697f, 0.02915789f, -0.27688852f, -0.15719324f, 0.13318965f, 0.10855850f, 
    0.10807142f, 0.07161641f, -0.02552812f, 0.02307669f, 0.02549215f, -0.03167854f, -0.07207825f, -0.01771133f, 
    -0.14174095f, -0.18321609f, -0.00330502f, -0.07599226f, -0.04528903f, 0.01655509f, -0.02836258f, -0.00636296f, 
    0.06030660f, -0.07694618f, -0.00109720f, -0.01195186f, -0.01745171f, -0.00338030f, -0.04046079f, 0.03619685f, 
    -0.02167162f, 0.03406186f, -0.00794366f, 0.03142119f, 0.07869510f, 0.04029468f, 0.03960356f, 0.00020948f, 
    0.15413924f, 0.01352554f, -0.00871435f, -0.04439690f, 0.04343719f, 0.11747752f, -0.00086827f, -0.09188300f, 
    0.13097058f, 0.00646113f, 0.05455188f, -0.12926862f, 0.08304676f, 0.00531607f, -0.04861523f, -0.13682032f, 
    0.09010912f, 0.01478322f, -0.07448450f, 0.02323542f, 0.10029922f, -0.07595127f, -0.04138109f, 0.06569072f, 
    -0.47592816f, -0.18007706f, -0.22010995f, -0.24416603f, 0.05659322f, 0.00832746f, -0.04605591f, -0.09153665f, 
    0.01121749f, -0.07181169f, 0.04119319f, -0.02790384f, -0.26211503f, -0.25182474f, -0.17075971f, -0.15641516f, 
    0.01465690f, -0.00597491f, -0.03579128f, -0.03985744f, -0.00957069f, 0.07305464f, -0.11989950f, -0.02292990f, 
    -0.12411623f, 0.03037972f, 0.13806714f, 0.06751004f, 0.13124543f, 0.02966430f, 0.05900658f, -0.04949102f, 
    0.01090429f, 0.01831906f, -0.02426860f, 0.09063753f, 0.22792639f, 0.09733643f, -0.02046148f, -0.04185264f, 
    0.10211322f, -0.06574965f, 0.14437419f, 0.05520866f, 0.03474292f, 0.07312616f, 0.06737237f, 0.10177542f, 
    -0.31930158f, 0.16317770f, 0.12604618f, 0.13354726f, 0.16078947f, -0.04527983f, 0.02172183f, 0.00955900f, 
    -0.03492250f, 0.10467384f, -0.08292978f, 0.06825054f, 0.32583714f, 0.13810965f, 0.01406746f, 0.02353451f, 
    -0.05298574f, -0.10007795f, -0.13508257f, 0.00941082f, -0.05203176f, -0.01821636f, -0.14761485f, -0.04014004f, 
    -0.49906403f, -0.11147082f, -0.04471066f, -0.08151766f, 0.06047100f, 0.02234310f, -0.13958983f, -0.05390437f, 
    -0.04589676f, 0.12550625f, 0.05008703f, 0.01913078f, 0.29506028f, 0.05705199f, 0.02220636f, -0.09986243f, 
    0.09656774f, 0.06694959f, -0.00322413f, 0.01860801f, 0.08970866f, -0.04223470f, 0.07528619f, 0.08569623f, 
    -0.35397026f, -0.15507577f, 0.14457045f, -0.03525566f, 0.07704647f, -0.02544879f, -0.15925369f, -0.09408625f, 
    -0.04397485f, 0.05790193f, -0.01987277f, -0.00955580f, 0.00586015f, -0.08668298f, 0.06297626f, -0.18097647f, 
    -0.03152382f, 0.08271253f, 0.07672866f, 0.03293885f, 0.01188144f, -0.05770187f, -0.02346894f, 0.07401162f, 
    -0.27087146f, 0.07378618f, -0.07100638f, 0.06617233f, 0.02122345f, 0.02730646f, -0.06602565f, -0.01175729f, 
    -0.16401613f, 0.03555050f, 0.10403700f, -0.22938089f, -0.39843196f, 0.10116994f, -0.04406171f, -0.00042890f, 
    0.17479661f, -0.01280795f, 0.03951369f, 0.00609587f, 0.06743643f, 0.07040475f, 0.00043507f, 0.01356461f, 
    -0.01029565f, 0.07041559f, 0.03237654f, 0.13036354f, -0.17737336f, 0.04548094f, -0.01817191f, -0.22389787f, 
    -0.13670014f, 0.06432714f, -0.12369619f, -0.15277308f, 0.15922394f, -0.07148786f, -0.02856519f, 0.11234372f, 
    0.00662183f, -0.10642892f, 0.05420823f, 0.02245120f, -0.07961424f, 0.00392520f, 0.09330827f, -0.03482292f, 
    -0.01543162f, 0.09088322f, -0.06186823f, -0.36939105f, -0.02524686f, -0.06744462f, 0.02903772f, 0.10509659f, 
    0.17147422f, 0.00510792f, -0.00300085f, -0.01690092f, -0.08067219f, -0.34750178f, 0.02385890f, -0.08576572f, 
    -0.02555100f, -0.08182074f, 0.05478795f, 0.03206132f, -0.06848475f, -0.01477612f, -0.03247104f, -0.02532703f, 
    -0.10954467f, -0.03753722f, -0.01639226f, 0.00150663f, 0.08744960f, -0.02954034f, 0.03260769f, -0.00145798f, 
    0.00436337f, -0.09450202f, -0.00521255f, 0.00724985f, 0.20246427f, -0.07330205f, -0.17426792f, -0.05481521f, 
    -0.03553410f, 0.05339094f, -0.10827111f, -0.05560259f, -0.00529160f, -0.12625383f, -0.12721319f, -0.15441889f, 
    -0.08786357f, 0.02378146f, 0.05672537f, 0.08617559f, -0.06619425f, -0.02744322f, 0.00155105f, -0.08042233f, 
    0.00953691f, 0.01833912f, 0.04939420f, 0.10511550f, 0.04974427f, 0.15956882f, -0.04861860f, 0.06398523f, 
    0.04505110f, -0.16349536f, -0.01273308f, 0.02166231f, 0.00514467f, -0.01525475f, 0.16186714f, 0.13952664f, 
    -0.05751416f, 0.00647148f, -0.02569569f, 0.26567197f, 0.03801019f, 0.11834691f, -0.00414374f, -0.10564858f, 
    -0.13163751f, -0.08886024f, -0.08511878f, -0.07751054f, 0.04554834f, 0.10135384f, -0.10279251f, -0.10614481f, 
    -0.10492589f, -0.12750098f, -0.02460739f, -0.02071451f, 0.03763978f, -0.04117667f, 0.03159130f, -0.00870760f, 
    -0.01660511f, -0.18507564f, 0.06527179f, 0.05129207f, -0.06377257f, 0.04644078f, -0.02004319f, 0.10057149f, 
    0.01722202f, 0.04559107f, -0.03558407f, -0.00786716f, 0.05760183f, -0.14528571f, -0.06329948f, 0.10436074f, 
    0.06548667f, -0.07505533f, 0.02738924f, -0.05077186f, 0.00874264f, -0.02799950f, 0.09740794f, 0.08518329f, 
    -0.25577560f, -0.07372006f, -0.01999272f, -0.07998222f, 0.07201068f, 0.02762391f, 0.01983932f, -0.00507516f, 
    -0.01230165f, 0.04472280f, 0.02074146f, -0.03855199f, -0.10976776f, -0.29004028f, 0.08168222f, 0.14300594f, 
    -0.02416034f, 0.09068444f, 0.06751756f, 0.17690445f, -0.12675929f, 0.01288437f, -0.01243255f, -0.05182740f, 
    0.39290309f, -0.05890243f, -0.03216324f, 0.03473734f, -0.10966361f, 0.02149056f, -0.01217769f, -0.07866458f, 
    -0.00629564f, -0.02724651f, 0.06204482f, 0.06239405f, -0.02368699f, 0.06593182f, 0.08301447f, -0.16266437f, 
    0.03890810f, -0.10385512f, -0.01687071f, -0.00427386f, -0.08781897f, -0.02243095f, 0.01037153f, 0.06511461f, 
    -0.01459181f, -0.05956952f, 0.08801315f, 0.03958796f, -0.04062325f, 0.15771027f, -0.01253771f, 0.09990413f, 
    0.03939670f, 0.02427169f, 0.05776870f, 0.08942240f, 0.03798785f, 0.05576078f, 0.00099387f, -0.04419417f, 
    0.03362213f, 0.01022893f, 0.08332438f, 0.03301286f, 0.02858728f, 0.07968507f, -0.08717925f, 0.02027369f, 
    -0.04622283f, -0.26025209f, -0.04183175f, -0.12964155f, -0.01551304f, -0.06903979f, -0.04177550f, 0.07212918f, 
    -0.03906782f, 0.03846269f, -0.02137488f, 0.00293082f, 0.16627909f, 0.00833124f, 0.07264099f, 0.01609159f, 
    -0.01528231f, -0.02578994f, -0.02520510f, 0.04757251f, 0.03054223f, -0.04586510f, -0.03277341f, 0.04783816f, 
    0.05969438f, -0.37346098f, 0.19147420f, 0.12398306f, 0.10288309f, -0.07611313f, 0.03415544f, -0.01689543f, 
    -0.03369210f, 0.09089582f, 0.07940605f, 0.03056959f, -0.17887782f, -0.00813106f, 0.07421532f, -0.12547915f, 
    0.05563932f, 0.01969598f, 0.00621334f, 0.16661644f, 0.08007426f, -0.00989179f, -0.06619375f, -0.02653259f, 
    -0.10498183f, -0.07298181f, -0.10865637f, 0.15171702f, -0.02909653f, -0.10147755f, 0.11236756f, 0.05407243f, 
    0.03028722f, -0.04916724f, -0.05250424f, -0.08865486f, -0.23215936f, -0.02822016f, -0.04587544f, 0.00844446f, 
    0.02754745f, 0.03988206f, -0.08023978f, 0.01538248f, 0.02496165f, -0.04078920f, 0.00992540f, -0.04891900f, 
    -0.14965844f, -0.10865396f, 0.07889618f, -0.13767982f, -0.03594548f, 0.02295538f, -0.02599656f, -0.01170464f, 
    0.01999138f, 0.10786231f, -0.08905990f, 0.05383312f, -0.17781737f, -0.02063807f, 0.03468094f, -0.00989116f, 
    0.03205301f, 0.06074583f, -0.09782460f, 0.03282059f, -0.15679367f, -0.00074542f, -0.03446835f, 0.02531833f, 
    -0.03285923f, -0.04055866f, 0.06375457f, 0.04299990f, 0.11630822f, 0.01797199f, 0.02127613f, -0.09515494f, 
    -0.04644500f, 0.03862599f, 0.04302069f, 0.13067390f, -0.25976053f, 0.19971131f, -0.06675387f, -0.28138098f, 
    0.07467140f, 0.04782696f, -0.03152650f, 0.08176798f, 0.02817573f, -0.12473138f, -0.06567293f, -0.01449774f, 
    -0.41828668f, -0.01211521f, -0.13787217f, -0.00385163f, 0.01233987f, 0.11776597f, 0.02658616f, 0.11811913f, 
    0.03088148f, -0.07191551f, -0.05435819f, -0.04663928f, -0.40593228f, -0.08200139f, 0.14557555f, -0.01756543f, 
    0.03793090f, 0.00525097f, 0.02103622f, 0.00909382f, -0.11742918f, -0.01685253f, 0.00773745f, 0.03160579f, 
    0.30602723f, -0.01521073f, -0.15154874f, -0.15297331f, 0.07768044f, -0.04668630f, -0.06078723f, -0.00609500f, 
    0.04860955f, -0.05906302f, -0.02798351f, -0.05976287f, 0.47094890f, -0.03893356f, -0.07110804f, 0.07630954f, 
    0.02251418f, -0.02850682f, -0.00975103f, -0.00382948f, 0.10793333f, 0.08405820f, -0.03903960f, 0.04979802f, 
    -0.05028369f, -0.15023576f, 0.00084221f, 0.00016820f, -0.12559900f, -0.00949440f, 0.03363132f, 0.04102348f, 
    0.03193348f, -0.01755400f, -0.03735249f, -0.01372255f, 0.23133485f, 0.01391937f, -0.01671064f, -0.09841734f, 
    -0.05703506f, -0.08953595f, 0.05436600f, 0.04255433f, -0.00953896f, 0.05360543f, -0.04852906f, -0.02466546f, 
    0.06062203f, -0.04857692f, -0.07263218f, -0.04499036f, 0.05267160f, -0.02264179f, 0.02154920f, 0.05085605f, 
    0.00964250f, 0.07665369f, -0.01915769f, 0.06341524f, 0.00461839f, 0.04750587f, 0.08277153f, 0.12572657f, 
    -0.02627239f, 0.01330883f, -0.06699347f, -0.03249058f, -0.06424475f, -0.15497060f, 0.05852577f, 0.02123246f, 
    -0.33438548f, 0.14295693f, -0.18392025f, -0.02551093f, 0.08818167f, -0.05065744f, 0.04212563f, 0.08395841f, 
    -0.01440255f, -0.01488097f, 0.05990233f, 0.02133803f, 0.35677189f, -0.09330069f, -0.01629953f, -0.05069470f, 
    0.04119859f, -0.07059836f, -0.04123551f, 0.04929379f, 0.04014555f, 0.02449245f, -0.05568247f, -0.03440655f, 
    0.30471331f, -0.20314047f, -0.12885986f, -0.06580563f, -0.01942262f, 0.02882034f, 0.03419384f, 0.00970119f, 
    0.04490859f, 0.04470678f, 0.03764717f, -0.01997754f, 0.23974900f, -0.08479683f, 0.01574503f, 0.00190336f, 
    -0.08131512f, 0.05668529f, 0.03157166f, -0.00160578f, -0.00436038f, -0.01668894f, -0.05872202f, -0.08184336f, 
    -0.23613529f, 0.09524582f, 0.11452370f, -0.05023179f, -0.04231406f, -0.03102234f, -0.09968779f, 0.07604153f, 
    -0.06139365f, 0.02808784f, 0.10174470f, 0.02703118f, 0.10056832f, -0.07707547f, -0.09911525f, 0.16864109f, 
    -0.11224140f, 0.06914901f, -0.15681450f, 0.08957756f, 0.06496635f, -0.08666422f, -0.05447984f, 0.02078924f, 
    -0.01654604f, -0.13778447f, -0.01898240f, -0.08553967f, 0.04202856f, -0.06178137f, -0.08381914f, 0.04527926f, 
    -0.11101813f, 0.02282618f, -0.11734337f, -0.04693589f, -0.01418774f, 0.04007465f, 0.02462704f, -0.14323302f, 
    -0.02104322f, -0.00654425f, -0.07514586f, -0.12582308f, -0.01957577f, 0.04289215f, -0.03487188f, -0.29068232f, 
    0.18733189f, -0.02651220f, -0.06282701f, 0.13703202f, -0.01230701f, 0.06493206f, -0.04287633f, -0.12976818f, 
    0.14064141f, 0.04784217f, 0.05795367f, 0.12813824f, -0.08898855f, 0.15337278f, 0.16999532f, -0.17736991f, 
    0.02057890f, -0.05072804f, -0.00863289f, -0.07298893f, -0.02437317f, -0.00389120f, 0.08990529f, -0.01895170f, 
    -0.02091104f, 0.17173786f, -0.09843208f, 0.09173025f, -0.08375826f, 0.02044430f, -0.04706148f, 0.06541184f, 
    -0.06890930f, -0.09961785f, 0.09902960f, -0.00098035f, 0.17517211f, 0.07857414f, -0.01277657f, -0.06452629f, 
    0.11541938f, -0.07937407f, -0.15543486f, -0.01956291f, 0.03913583f, 0.11873928f, 0.02570138f, 0.08151804f, 
    -0.28808415f, -0.12060056f, -0.31103826f, -0.14607291f, 0.01825081f, -0.07927594f, 0.11090101f, 0.01211037f, 
    -0.03800063f, 0.10099614f, -0.05538050f, 0.00964671f, 0.06077647f, -0.17462620f, -0.22399130f, 0.15649518f, 
    -0.08295534f, 0.08844219f, -0.18826556f, 0.03929804f, -0.07971039f, 0.06581791f, -0.04620695f, 0.11051667f, 
    0.03542825f, -0.00777285f, -0.10023020f, -0.07818644f, -0.05814129f, -0.03558446f, -0.13802098f, -0.14184092f, 
    -0.08744768f, 0.03988443f, -0.06634376f, -0.12641227f, -0.14795643f, -0.14886865f, 0.07248856f, -0.24899352f, 
    -0.07658654f, 0.06232401f, -0.06443946f, 0.00319758f, 0.00136529f, 0.01370940f, -0.06856269f, -0.10597880f, 
    0.25195244f, -0.11176167f, -0.17625500f, -0.08491341f, 0.12161138f, -0.01616859f, -0.02456638f, -0.08146002f, 
    -0.03749638f, 0.02365752f, 0.00869069f, -0.02217365f, -0.06786828f, -0.14035618f, 0.00628439f, -0.06787525f, 
    0.03499860f, 0.07116644f, 0.02347116f, 0.02011638f, 0.02821888f, 0.00710775f, -0.04139841f, -0.08826457f, 
    0.24230033f, 0.10005978f, 0.01523325f, -0.12408576f, 0.07008588f, -0.11086898f, -0.14641158f, -0.00673076f, 
    0.04433599f, 0.08393906f, 0.08538023f, 0.07136717f, -0.00658780f, -0.03520072f, -0.08762744f, 0.17735323f, 
    0.13610002f, -0.08993215f, 0.00296478f, -0.00576828f, 0.02462582f, -0.03710669f, -0.05752105f, -0.06993725f, 
    0.45079637f, -0.20930870f, -0.06960472f, 0.05203699f, 0.01905797f, -0.01130962f, -0.20183831f, 0.08363064f, 
    0.11746778f, 0.03922728f, -0.01608519f, 0.07739061f, -0.09712362f, -0.00316729f, -0.03428670f, -0.07019347f, 
    -0.00438198f, 0.01816065f, 0.06825288f, -0.05606794f, 0.04969584f, -0.10191142f, 0.11379138f, 0.06397323f, 
    0.45046568f, 0.11402964f, -0.20662414f, -0.07468662f, 0.03819306f, -0.10239021f, 0.02211336f, -0.03718358f, 
    0.03697987f, -0.09096482f, -0.07041568f, 0.05314979f, 0.09400898f, -0.04357808f, -0.15809681f, 0.27605289f, 
    0.12309951f, -0.06609157f, 0.06509515f, 0.12890370f, -0.03868697f, 0.11795198f, -0.01943912f, -0.00711342f, 
    0.35352871f, 0.10328100f, -0.08131063f, -0.03457050f, 0.04483854f, -0.02184891f, -0.04968895f, 0.00174525f, 
    0.00955771f, -0.02376926f, 0.07661035f, 0.08797602f, -0.15504692f, 0.21177797f, 0.16879393f, -0.21317104f, 
    -0.07218913f, 0.01158061f, -0.03002474f, 0.08008036f, 0.00796558f, -0.06594273f, 0.08252294f, -0.08567998f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04085375f, 0.01864039f, -0.03961454f, 0.03631733f, -0.02329877f, -0.00416845f, 0.02012294f, -0.08069999f, 
    0.00237487f, -0.01556215f, 0.05857734f, 0.04694195f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
