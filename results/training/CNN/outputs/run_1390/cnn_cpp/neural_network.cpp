#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.87455028f, -0.31979123f, -0.27841166f, -0.54517102f, -0.20167071f, 0.55557054f, -0.25431511f, -0.03251345f, 
    0.01586940f, 0.57866657f, -0.06682928f, -0.55088025f, -0.37131718f, -0.56928593f, -0.04525540f, 0.32912260f, 
    0.18186353f, -0.07318649f, 0.26476720f, 0.19788681f, -0.08673628f, 0.03932586f, -0.26187494f, -0.23233528f, 
    0.27897283f, -0.45631316f, -0.55679560f, -0.48345134f, -0.09356382f, -0.08130948f, -0.22122903f, -0.30975550f, 
    -0.02066120f, 0.57425553f, 0.39577943f, -0.00682165f, 0.13388869f, -0.15869693f, 0.14733657f, -0.26626137f, 
    -0.19430098f, -0.11006215f, -0.05747188f, 0.10640898f, -0.11694837f, -0.44544238f, -0.50481260f, -0.41971356f, 
    -0.44433808f, -0.42382759f, 0.07495230f, 0.69984335f, 0.39003155f, -0.01777966f, -0.06341108f, -0.35834944f, 
    -0.08067119f, -0.39926538f, -0.58505994f, -0.86113417f, -0.02481145f, -0.14851648f, -0.42855039f, -0.42241222f, 
    -0.06624082f, -0.09458447f, -0.17338178f, -0.08517545f, -0.05785026f, -0.28381890f, -0.24306943f, -0.13947012f, 
    0.16300312f, -0.14064738f, 0.03727562f, -0.20595542f, -0.17119502f, 0.26767161f, 0.36338758f, -0.40568215f, 
    0.19112936f, 0.07716578f, -0.08833904f, -0.22213459f, -0.07467473f, 0.35100493f, -0.47002798f, 0.29930323f, 
    -0.35613513f, 0.23280561f, 0.27872676f, -0.24823821f, -0.05760407f, 0.23854209f, -0.10580642f, -0.28375459f, 
    0.03658648f, 0.23232539f, -0.03466510f, 0.34052801f, 0.13236845f, 0.00019924f, 0.20932798f, -0.11802245f, 
    -0.10299642f, 0.31591269f, 0.00642226f, -0.66176838f, -0.18671697f, -0.06322788f, 0.49454045f, -0.27296004f, 
    -0.20686649f, 0.18722962f, 0.22008345f, -0.20881513f, 0.20936562f, -0.54526985f, -0.13916308f, -0.45242879f, 
    -0.29257217f, -0.33721593f, -0.23343812f, -0.09570083f, -0.52625465f, -0.00328872f, 0.19509715f, 0.15546024f, 
    0.21197574f, 0.25370392f, -0.15086418f, 0.08227684f, -0.34259793f, -0.17484812f, -0.02046956f, -0.04403141f, 
    0.16413823f, -0.39300361f, 0.03933754f, 0.10406556f, 0.21501105f, 0.35511732f, -0.14816843f, -0.22769238f, 
    0.26224366f, -0.15457308f, -0.24457023f, -0.15090473f, 0.05582756f, -0.21437941f, -0.12807815f, -0.29166311f, 
    0.24134012f, 0.07050440f, 0.16463673f, 0.65024245f, -0.36663106f, -0.23202877f, -0.19617753f, 0.05107528f, 
    0.05830018f, 0.30274907f, 0.08588152f, -0.31340280f, -0.31679690f, -0.19819391f, -0.11474431f, -0.14021961f, 
    0.24721393f, 0.22730635f, -0.31513005f, -0.12029275f, 0.02036871f, 0.23359206f, -0.24058707f, -0.57405967f, 
    -0.50499129f, -0.17003688f, -0.22859681f, -0.86632085f, 0.78689450f, -0.25823057f, -0.17597187f, 0.25719339f, 
    0.60695899f, -0.02155042f, -0.05658179f, 0.02271456f, 0.19891554f, 0.02338230f, 0.08922602f, -0.17881083f, 
    -0.00291946f, 0.11596871f, -0.27324185f, -0.18204036f, -0.08875359f, -0.20267968f, -0.04765670f, 0.13748635f, 
    -0.39102849f, -0.46794450f, -0.00067196f, 0.11178403f, 0.44212481f, 0.23404190f, 0.03133581f, -0.16172291f, 
    0.12021852f, 0.44870856f, -0.16924667f, -0.14703016f, 0.08155940f, -0.01994880f, 0.22473696f, -0.13213280f, 
    -0.02771723f, -0.20605142f, -0.19585384f, -0.14220096f, -0.14361630f, 0.29031900f, 0.27130666f, 0.20428617f, 
    0.15751624f, 0.62110424f, -0.69233102f, -0.50410968f, 0.12588286f, -0.00969989f, 0.61641538f, -0.14410363f, 
    0.10663410f, -0.53440040f, 0.30658901f, -0.09453520f, 0.10076948f, 0.02445416f, -0.48477444f, 0.21507064f, 
    0.08581153f, 0.32900602f, -0.03725107f, -0.08541817f, 0.02814786f, 0.16478972f, -0.04023458f, 0.02461712f, 
    -0.26641425f, -0.22678272f, -0.28801665f, 0.21693903f, 0.32993904f, 0.16977835f, 0.27366915f, -0.39115176f, 
    -0.06089899f, 0.16491455f, 0.14427020f, 0.20504357f, -0.21855207f, -0.20713064f, -0.25066018f, 0.21669643f, 
    0.07163546f, 0.11926965f, 0.04645511f, 0.09821383f, 0.02058615f, -0.06086222f, 0.15402076f, -0.24347478f, 
    -0.12343782f, -0.02995395f, -0.37436956f, 0.12785682f, 0.30616096f, 0.15745929f, -0.08363295f, -0.18979736f, 
    0.40291017f, 0.42700863f, -0.24166510f, -0.24048197f, -0.16234447f, 0.09875447f, 0.44757074f, -0.25418654f, 
    -0.37291896f, 0.04178659f, -0.08836673f, 0.16435641f, 0.11597361f, -0.07806267f, 0.09448977f, -0.20110926f, 
    -0.10464228f, 0.00825408f, -0.02173716f, 0.08984328f, -0.84106553f, 0.12992439f, -0.27516162f, -0.40142390f, 
    -0.65642625f, 0.41178989f, -0.05922339f, 0.36503375f, 0.45037007f, 0.26965645f, 0.23789223f, -0.13455664f, 
    0.23095007f, -0.45563802f, 0.17100117f, -0.30014837f, -0.00091128f, -0.13178499f, -0.16359377f, 0.06356109f, 
    -0.14126620f, 0.23455611f, 0.20050985f, -0.28604898f, 0.48420709f, 0.17511882f, 0.06065809f, -0.30103430f, 
    0.03069744f, -0.13425170f, 0.30371016f, 0.01650872f, 0.07253014f, -0.14594437f, 0.01142933f, -0.01155613f, 
    -0.10112628f, 0.00997171f, -0.16740337f, 0.24250181f, -0.48290977f, -0.01835297f, 0.21803129f, 0.17876956f, 
    -0.15302746f, 0.27038401f, 0.10582690f, 0.11740196f, 0.14208333f, -0.10507800f, 0.45225945f, 0.09151417f, 
    0.21239562f, -0.33104628f, -0.37485811f, -0.09911513f, -0.11455671f, -0.20676333f, 0.36482805f, 0.08148049f, 
    0.39485541f, -0.27646783f, -0.30369151f, 0.33319607f, -0.14548722f, -0.31230935f, -0.17793538f, 0.28943005f, 
    0.26438627f, -0.14208402f, 0.07675428f, -0.12319204f, 0.09254793f, -0.41206279f, 0.44472817f, 0.50168628f, 
    0.69002563f, -0.26432043f, -0.55966556f, -0.59780961f, -0.41409889f, 0.08029307f, 0.28480032f, -0.08759945f, 
    -0.16349709f, 0.22104722f, 0.23266587f, 0.61548918f, -0.21081106f, -0.27796441f, 0.04109085f, 0.24163872f, 
    0.23730379f, -0.22672692f, -0.39739439f, -0.05509471f, 0.09762900f, -0.04887117f, -0.26074928f, 0.13084203f, 
    -0.16224693f, 0.37901568f, 0.22157773f, -0.20248826f, -0.67663532f, -0.24891350f, 0.38276467f, 0.10205249f, 
    -0.19250232f, -0.11661887f, 0.22948109f, 0.08672509f, 0.16851346f, -0.12432089f, 0.13600135f, -0.23764655f, 
    0.19841208f, -0.08635999f, -0.05415882f, 0.07999673f, 0.37740943f, -0.24492624f, 0.20675652f, 0.19768886f, 
    -0.15246172f, -0.64037061f, -0.01302580f, 0.27119151f, 0.69511175f, 0.09819390f, 0.32060304f, -0.51046824f, 
    -0.21915504f, 0.14583437f, 0.06654826f, -0.35625181f, 0.24988224f, -0.05180326f, 0.21988660f, -0.15860762f, 
    -0.14201833f, 0.06311181f, 0.09416384f, -0.04692508f, 0.26672876f, 0.03933933f, 0.25116161f, 0.03561518f, 
    -0.07633130f, -0.39228088f, -0.35947129f, -0.45075199f, -0.71064484f, -0.49116716f, 0.16780068f, 0.12249003f, 
    -0.02901821f, -0.43529248f, -0.34821224f, -0.28174710f, 0.02335190f, 0.19780652f, 0.28331926f, -0.09712312f, 
    0.09981580f, 0.19460009f, 0.18697369f, 0.02823670f, 0.24291205f, -0.10264882f, -0.15202147f, -0.01786348f, 
    -0.09462663f, -0.11599306f, -0.37411067f, 0.86778629f, 0.69259465f, 0.03024808f, 0.23248570f, -0.00047453f, 
    -0.60237396f, -0.52800643f, 0.17334478f, 0.29551956f, -0.10705134f, -0.08851937f, 0.13731588f, -0.03618051f, 
    -0.30816513f, -0.17064734f, -0.04586156f, 0.24054497f, 0.06894894f, -0.22037332f, 0.10409868f, -0.04355430f, 
    -0.10399858f, -0.00157115f, 0.11456970f, -0.16057874f, -1.18385029f, -0.16085851f, -0.06213664f, -0.40778053f, 
    -0.05517108f, 0.33868012f, 0.45123634f, 0.21419786f, 0.37425032f, 0.13507883f, 0.11232652f, 0.18215476f, 
    0.33625537f, -0.02204579f, -0.07805476f, 0.17347188f, -0.17496341f, -0.05942078f, 0.01087190f, -0.20198160f, 
    0.10954484f, 0.19694102f, -0.00943542f, -0.33086756f, 0.06648752f, -0.41110939f, 0.66349238f, -0.52131718f, 
    -0.46713057f, -0.69994909f, -0.27592710f, 0.10990904f, -0.23738500f, -0.44761118f, 0.09337475f, 0.19331031f, 
    -0.07765429f, 0.42756501f, 0.17419818f, 0.22239028f, 0.05638890f, 0.08335961f, 0.06414039f, -0.20287457f, 
    -0.21572186f, 0.05923475f, -0.27070168f, -0.07102880f, -0.02161124f, 0.09971432f, -1.02985668f, 0.02134849f, 
    -0.62313569f, 0.20488395f, 0.43727571f, 0.07312874f, 0.68162495f, -0.55859679f, -0.14848399f, 0.27259272f, 
    0.12437793f, 0.01589895f, -0.13477707f, -0.15645331f, 0.19958943f, 0.09995852f, 0.12138838f, 0.21022485f, 
    -0.01832156f, -0.15121289f, -0.00811658f, -0.04303671f, -0.09545916f, 0.06943247f, -0.20676138f, 0.45738819f, 
    -0.37535876f, 0.08869624f, 0.54275429f, -0.21310709f, -0.20158553f, -0.11593887f, -0.25669840f, -0.35578004f, 
    -0.38673255f, 0.05219313f, -0.26122075f, -0.24040201f, 0.07380334f, 0.08708139f, 0.06976488f, 0.36770162f, 
    0.23141198f, -0.05001073f, 0.00364442f, -0.28219816f, -0.30247048f, -0.39568228f, -0.17704536f, 0.01309656f, 
    -0.18701054f, -0.77324408f, 0.22998621f, -0.12606600f, 0.13962239f, -0.75062406f, -0.59027737f, -0.26215321f, 
    -0.30185872f, 0.50060678f, -0.19969673f, -0.17333375f, 0.35379797f, -0.01143487f, -0.33465719f, -0.07805819f, 
    -0.23547402f, -0.25007224f, -0.35804287f, -0.58897102f, 0.14274445f, 0.16389133f, -0.16810188f, 0.03531083f, 
    0.11260658f, -0.74812764f, -0.77892923f, 0.15908158f, 0.51719153f, 0.59516758f, 0.39500374f, 0.63779211f, 
    0.03070881f, -0.19797496f, 0.29431081f, -0.19384472f, 0.06978925f, -0.39045671f, -0.25028044f, 0.06489635f, 
    0.21350092f, -0.18354939f, 0.14294057f, -0.13639814f, -0.14835916f, 0.02414704f, -0.28303781f, -0.02838863f, 
    0.09124563f, -0.16632015f, -0.51936942f, -0.73638982f, -0.57636613f, 0.08988505f, -0.13552915f, -0.12130491f, 
    -0.26483706f, 0.17581643f, 0.38041246f, -0.21237771f, 0.30227262f, -0.20454061f, -0.37293291f, -0.23027147f, 
    0.01376215f, 0.03232741f, 0.10177415f, 0.21486063f, -0.20417826f, -0.03692930f, -0.36700180f, -0.02009747f, 
    -0.02568715f, -0.20191807f, -0.23423061f, 0.03272691f, 0.08285116f, -0.78532964f, -0.86306578f, 0.48822716f, 
    0.00199350f, -0.26090413f, -0.08689942f, -0.28157195f, -0.39477533f, -0.10378340f, 0.40182239f, 0.39768553f, 
    -0.41236237f, -0.38639885f, -0.40877721f, -0.34766221f, -0.42231408f, -0.13627234f, 0.29442191f, 0.36965057f, 
    0.00025465f, -0.20741081f, 0.35867807f, -0.03521352f, -0.15006027f, 0.00011093f, -0.75013423f, -0.88087898f, 
    -0.40905789f, -0.43062389f, -0.60019118f, 0.53508794f, -0.08419354f, 0.25693357f, -0.26447725f, 0.04554726f, 
    0.33652261f, -0.12662853f, -0.32058257f, 0.22691739f, -0.09147269f, -0.13562557f, 0.16565111f, 0.02984704f, 
    0.29323038f, 0.05553398f, -0.36478326f, 0.30424628f, -0.27486995f, 0.22052419f, 0.85725588f, 0.15677978f, 
    -0.07402954f, -0.25577718f, -0.13270316f, -0.23014130f, 0.09966991f, -0.34324932f, -0.35581005f, -0.09540592f, 
    0.26972467f, 0.29717204f, 0.20909010f, -0.14037070f, -0.10689241f, 0.13925131f, 0.04578121f, -0.02136834f, 
    -0.03901173f, -0.12110741f, 0.16188784f, -0.31565124f, 0.03340624f, -0.18931803f, -0.35770121f, -0.35643154f, 
    -0.55284411f, -0.54009736f, -0.53826421f, 0.00877324f, -0.41361308f, -0.65728593f, -0.55959857f, -0.21871452f, 
    0.34440503f, 0.07857858f, 0.25270560f, 0.09510735f, -0.04304209f, 0.17880900f, 0.23281683f, 0.12362070f, 
    -0.00733528f, -0.12480752f, -0.27283749f, 0.23259789f, 0.31229833f, 0.10683148f, 0.40651789f, 0.28354883f, 
    0.08038054f, -0.09498259f, 0.16958451f, -0.14634737f, 0.34999779f, 0.02200542f, -0.16889793f, -0.06849605f, 
    -0.15676181f, 0.02031983f, -0.25231802f, 0.19043277f, 0.12975433f, 0.01440544f, -0.08868773f, -0.11377322f, 
    -0.20030975f, -0.01988960f, 0.10540713f, -0.31204399f, -0.01238923f, 0.20792018f, 0.29329666f, -0.17229562f, 
    -0.73203766f, -0.58925426f, -0.39154601f, -0.13659135f, -0.53639299f, -0.42922854f, -0.71353179f, -0.73650020f, 
    -0.65070546f, -0.61696279f, 0.06384927f, 0.02181173f, -0.06405691f, -0.46115211f, -0.39134765f, -0.08860530f, 
    -0.02076270f, -0.07789748f, 0.08178432f, 0.13147481f, 0.15014642f, -0.15611236f, -0.29495072f, 0.17760773f, 
    -0.08934338f, 0.48670262f, 0.89071727f, 0.64599138f, -0.73381853f, -0.34750295f, -0.48916543f, -0.11054560f, 
    0.04682330f, -0.04582356f, -0.60761613f, 0.02161751f, 0.06518199f, 0.24409541f, -0.06266808f, -0.03722126f, 
    0.02879651f, -0.00181839f, -0.13907938f, 0.27005538f, -0.02713369f, -0.15130307f, 0.28272322f, -0.05819087f, 
    0.01484111f, 0.15336524f, 0.58379084f, 0.28156319f, 0.04408120f, 0.48124936f, -0.07881130f, -0.29143962f, 
    0.11295261f, -0.37204960f, -0.57337081f, -0.35648382f, 0.04321039f, -0.02210491f, 0.13443808f, 0.04584505f, 
    -0.01067944f, -0.11742570f, -0.04810996f, 0.07923316f, -0.11640827f, -0.02447741f, 0.15290830f, -0.21988101f, 
    0.26428244f, 0.24362674f, -0.23408896f, -0.77336484f, 0.07584521f, 0.11270075f, 0.41619441f, 0.46545500f, 
    -0.52619117f, 0.16993314f, -0.01139440f, 0.58237851f, 0.05628898f, 0.03326629f, 0.04201531f, 0.20746955f, 
    -0.26891619f, -0.00498254f, 0.04265812f, -0.16651356f, -0.10218224f, -0.10453676f, -0.22743876f, 0.02111585f, 
    -0.03736112f, -0.19837447f, 0.29093230f, 0.11615241f, 0.36228737f, 0.20819508f, -0.01683704f, 0.19999142f, 
    0.31943926f, 0.32779434f, 0.24221618f, -0.01323431f, -0.13686979f, 0.11183053f, 0.06509364f, 0.02917176f, 
    0.08730080f, 0.08297257f, 0.23042335f, 0.25151512f, -0.19445461f, 0.08712362f, 0.05091435f, -0.18651105f, 
    -0.06661208f, 0.19084598f, -0.14626691f, -0.05457114f, 0.22291580f, 0.69074059f, 0.25648910f, 0.30448595f, 
    0.11412732f, -0.32709554f, -0.16260020f, -0.14289452f, 0.20887831f, -0.06772609f, 0.00276861f, 0.06071553f, 
    0.09550841f, -0.13618900f, -0.34413204f, 0.12596987f, -0.13401200f, -0.12734915f, -0.10178816f, 0.29266194f, 
    -0.09510630f, -0.00214264f, -0.24133000f, -0.26784313f, -0.03123620f, -0.04764759f, -0.60709053f, -0.19522442f, 
    0.62347054f, -0.05687965f, 0.09601960f, 0.05644423f, -0.08660351f, -0.42859203f, -0.08958790f, -0.01658587f, 
    0.01559780f, 0.22287124f, -0.13169627f, -0.08713493f, -0.09993726f, -0.08130419f, -0.34191501f, -0.34200838f, 
    -0.15934958f, 0.13207880f, -0.38802308f, -0.28030857f, -0.09093842f, -0.49546987f, -0.63638109f, -0.87301666f, 
    0.44794357f, 0.02838305f, 0.04072927f, 0.10903653f, 0.02406561f, -0.13790625f, -0.02691115f, 0.23346528f, 
    0.20888516f, 0.08067597f, -0.54573399f, -0.27249241f, 0.15821344f, 0.11045910f, 0.41638988f, 0.18269761f, 
    0.06678911f, 0.13202338f, -0.34693944f, -0.25581133f, -0.16239527f, -0.08344568f, -0.13381538f, -0.37360913f, 
    -0.17603379f, -1.04771519f, -0.86290419f, 0.00298777f, 0.38817877f, -0.13167261f, 0.01776741f, -0.29025054f, 
    -0.14809451f, -0.48523918f, 0.50929278f, 0.41411236f, 0.45024985f, -0.06560283f, 0.35900536f, 0.04837392f, 
    -0.17444579f, -0.13618422f, -0.45730996f, -0.39704528f, 0.03248183f, 0.14237510f, 0.11836662f, -0.17195417f, 
    -0.22113477f, -0.26657316f, -0.18370216f, -0.37100387f, -0.20107545f, 0.07060392f, 0.19613498f, 0.09399721f, 
    0.25527230f, -0.29247117f, -0.32984346f, 0.54485422f, 0.44726777f, -0.01995312f, -0.05506601f, -0.36113372f, 
    -0.40347612f, -0.28207615f, 0.02005752f, -0.29087570f, -0.28800607f, -0.13224648f, 0.20299861f, 0.41515952f, 
    0.24862540f, 0.28592733f, 0.74796140f, 0.43754977f, 0.17073964f, -0.06874175f, -0.30761755f, -0.42885321f, 
    -0.23853335f, -0.03772132f, -0.09415863f, -0.18381415f, -0.23916568f, -0.04041874f, -0.06399208f, 0.05299879f, 
    0.12964308f, 0.20431513f, 0.15754418f, 0.12759021f, 0.02015096f, -0.19651404f, -0.34706220f, -0.11420646f, 
    -0.36864698f, -0.25313270f, -0.54267669f, -1.11037874f, -0.31815585f, -0.38036013f, -0.77569550f, -0.62772167f, 
    0.55104291f, 0.30106321f, 0.34371421f, 0.42422792f, 0.70759255f, -0.22195645f, 0.37391227f, -0.14319761f, 
    -0.19418851f, -0.44259763f, -0.17784014f, 0.12372731f, -0.20212337f, -0.13012259f, 0.09433805f, 0.07589742f, 
    0.11214656f, 0.08489367f, 0.08670349f, -0.05360374f, 0.47870472f, -0.60373294f, -0.53434825f, 0.25090283f, 
    0.32708794f, 0.56080645f, 0.53643668f, 0.50487494f, -0.25134838f, -0.26724136f, 0.01436485f, -0.20284973f, 
    0.02532010f, -0.22148079f, 0.08164807f, 0.02724582f, -0.07294729f, -0.18305728f, -0.13527356f, -0.09068011f, 
    0.13563025f, -0.19089147f, -0.03323373f, 0.03639719f, -0.09822023f, 0.19688509f, 0.56910574f, 0.62674534f, 
    -0.53188318f, -0.79460454f, -0.22776303f, 0.19928874f, 0.01580092f, 0.05120512f, 0.03625821f, 0.06966523f, 
    0.10812742f, -0.04266771f, 0.27834362f, -0.27025405f, 0.03232691f, -0.26021814f, -0.06847656f, -0.08432389f, 
    0.19679461f, 0.31087771f, 0.11331923f, 0.17139007f, -0.18891463f, -0.12897210f, 0.02785799f, -0.78985119f, 
    -0.12159103f, 0.28835094f, 0.79168504f, 0.35929981f, 0.17210536f, -0.05580614f, -0.51109976f, -0.35984305f, 
    -0.08917283f, -0.22847642f, 0.29906169f, -0.38802892f, -0.04092853f, -0.21073480f, 0.04631093f, 0.07260722f, 
    0.19917256f, 0.17692603f, 0.02359704f, -0.20486534f, -0.21631879f, -0.15648812f, 0.25987819f, 0.20131928f, 
    -0.12067060f, -0.42867428f, 0.04467729f, 0.35176852f, -0.45733348f, -0.29554126f, -0.22592473f, 0.34296983f, 
    0.20259078f, 0.25683275f, -0.25009587f, 0.16483665f, 0.20603457f, -0.23613906f, -0.10575302f, -0.10150348f, 
    -0.05537425f, 0.27925828f, -0.41691467f, 0.10147946f, 0.11303731f, -0.15682855f, 0.29508087f, 0.35112634f, 
    -0.13911687f, -0.74508768f, -0.46401036f, 0.86314172f, 0.66503435f, -0.09135826f, 0.47251239f, -0.79751867f, 
    -0.69297862f, -0.65983731f, 0.17410548f, -0.12307077f, 0.27965051f, 0.02268730f, -0.04650625f, -0.01176827f, 
    -0.16485855f, 0.12801918f, 0.18559340f, 0.18430132f, -0.10355452f, -0.28084165f, 0.17852677f, 0.14269865f, 
    -0.25021836f, -0.15419193f, -0.11981084f, -0.32057768f, -0.09048890f, 0.26621369f, -0.46610013f, -0.30898705f, 
    0.51705617f, -0.03416583f, -0.25173911f, -0.40319157f, -0.17862046f, -0.01257601f, -0.17763472f, 0.07112890f, 
    0.35454628f, 0.33143079f, -0.23635562f, -0.10754330f, 0.12748908f, -0.29501590f, -0.13716958f, 0.25980005f, 
    0.01571369f, 0.38555273f, -0.03381832f, 0.43475640f, 0.51834881f, -0.32729775f, -0.79650551f, 0.05300104f, 
    0.42829451f, 0.05752814f, 0.12772381f, -0.10284605f, -0.26742586f, 0.00459856f, 0.39054778f, -0.10854778f, 
    -0.24038613f, 0.06172153f, -0.52049047f, -0.48549521f, 0.23242395f, 0.56635457f, 0.05561730f, 0.03928790f, 
    -0.06781146f, 0.01949701f, 0.00514486f, 0.45764861f, -0.19055763f, -0.33060169f, -0.12684390f, -0.33998370f, 
    0.54483330f, -0.29417676f, 0.05050458f, 0.27806696f, 0.09741053f, 0.07789874f, -0.16140182f, 0.14516471f, 
    0.12212018f, -0.15255898f, -0.20954451f, -0.41987985f, 0.23293264f, 0.23904353f, 0.11422623f, -0.39215431f, 
    0.14544898f, 0.30001792f, -0.03755223f, 0.02863977f, -0.74692053f, -0.53981048f, 0.33988103f, 0.35527191f, 
    0.09879307f, 0.22565535f, -0.08455176f, 0.19629492f, -0.21760131f, 0.10155094f, -0.25481093f, 0.24988374f, 
    0.13889250f, -0.18919742f, -0.00749510f, -0.42866617f, -0.12560950f, -0.11887530f, 0.27212477f, 0.42166293f, 
    -0.08267285f, 0.19220097f, 0.22339033f, -0.18583468f, 0.21022013f, -0.74647141f, -0.74438846f, -0.49425438f, 
    -0.72057974f, -0.71859771f, 0.22122768f, -0.12886962f, -0.26772609f, -0.22835875f, 0.31209040f, -0.26435632f, 
    -0.18458979f, 0.08802837f, 0.19226462f, 0.17623758f, -0.04097031f, -0.18351285f, -0.19450961f, -0.15586688f, 
    0.11987591f, -0.26138067f, -0.08201047f, 0.26319897f, -0.06907353f, -0.34860313f, 0.05110903f, -0.40371969f, 
    0.17719761f, 0.11452061f, -0.25505772f, 0.60693198f, 0.03864113f, -0.28405756f, -0.45636743f, 0.26470566f, 
    0.20600034f, -0.06616740f, -0.01716521f, 0.01393053f, -0.36295405f, -0.48317274f, 0.17422040f, 0.29187867f, 
    0.11293532f, -0.25129154f, -0.14298692f, 0.00814992f, -0.19053963f, 0.05306619f, -0.24348824f, -0.36919159f, 
    -0.27092603f, -0.08687159f, -0.19638048f, -0.06973531f, -0.14005469f, 0.13219684f, -0.32363185f, 0.36057410f, 
    0.39232716f, -0.33662426f, -0.10529044f, -0.00160986f, 0.01551852f, 0.10586718f, 0.07545222f, -0.11378127f, 
    -0.27015299f, -0.08368319f, 0.11770725f, 0.21620493f, 0.22508682f, 0.21312514f, 0.22874524f, -0.17017363f, 
    0.41940898f, -0.50164670f, 0.09403179f, 0.05209386f, 0.24713054f, 0.62708008f, 0.34208375f, -0.11410753f, 
    -0.24248523f, 0.33507124f, 0.17289861f, -0.29864952f, 0.04183951f, 0.07000773f, -0.29400238f, -0.22070004f, 
    0.06289801f, 0.09611710f, -0.16527763f, -0.22766748f, 0.13955845f, -0.09552050f, 0.04638385f, 0.04477689f, 
    0.08736780f, 0.49802944f, -0.74127847f, -0.29804891f, -0.36025462f, 0.41469353f, -0.22025882f, -0.50783288f, 
    -0.32811487f, 0.61426556f, -0.20700495f, 0.03504311f, 0.11429560f, 0.15171570f, 0.05053103f, 0.34489059f, 
    0.12723684f, 0.06457683f, -0.22516122f, -0.19273677f, -0.34460142f, -0.33497766f, 0.06377804f, -0.05009397f, 
    0.30029181f, 0.19863977f, 0.11060030f, -0.27311590f, -0.02822678f, -0.02818685f, 0.15328453f, -0.01267086f, 
    0.16426185f, 0.12565729f, 0.14841063f, 0.14757599f, 0.15745282f, -0.08786105f, -0.09810297f, -0.32925326f, 
    0.10795311f, -0.42670771f, 0.18728778f, -0.05716119f, 0.17471859f, -0.16016638f, 0.22757220f, 0.17422740f, 
    0.10542081f, -0.26529795f, 0.22940691f, 0.55804080f, 0.62678814f, -0.34393772f, -0.36877629f, -0.28927273f, 
    0.21594265f, 0.07608446f, 0.08544011f, -0.56534159f, -0.60389757f, 0.11150176f, 0.02408813f, -0.18974084f, 
    -0.03868965f, 0.14515392f, 0.18233438f, -0.46601245f, -0.07179423f, -0.13292755f, 0.02980208f, 0.18182205f, 
    0.21264303f, 0.15442012f, 0.00990251f, 0.11967324f, 0.24613145f, 0.53920192f, -0.22747837f, -1.01010776f, 
    -0.78321928f, -0.04607987f, -0.02292196f, 0.05767360f, 0.46282411f, 0.03632264f, 0.15463559f, 0.27280658f, 
    0.04680433f, 0.09188673f, -0.09907120f, -0.17171055f, 0.14912805f, -0.41023621f, -0.29231983f, -0.12535971f, 
    -0.21827753f, 0.38018170f, 0.28853232f, 0.01501346f, 0.17633405f, -0.59713197f, -0.15248086f, -0.23962578f, 
    -0.46956033f, -0.16076893f, -0.49305823f, -0.64783752f, -0.20557278f, -0.24190871f, -0.21061721f, -0.20686916f, 
    -0.23443107f, -0.13138394f, 0.07856701f, 0.24179268f, -0.15772887f, -0.49249631f, -0.28212142f, -0.49632776f, 
    -0.50852758f, 0.18401434f, -0.08899587f, 0.02541913f, -0.14828950f, -0.06511114f, -0.74793953f, -0.54219037f, 
    -0.72291398f, -0.10654135f, 0.24499172f, -0.31695721f, -0.31269372f, -0.44451284f, -0.80121654f, -0.78185576f, 
    -0.41578579f, -0.28861016f, -0.03710838f, 0.26744589f, -0.54734415f, -0.08791297f, -0.39683995f, -0.13142550f, 
    0.04914596f, -0.08908289f, 0.04837049f, 0.04275637f, -0.10482294f, 0.11190668f, -0.10129971f, 0.30853885f, 
    0.29600707f, 0.29821917f, -0.18678337f, 0.06102796f, -0.08545028f, -0.02007780f, 0.01969214f, -0.35301211f, 
    -0.16124712f, -0.03257577f, -0.33005115f, -0.00111527f, -0.26038423f, -0.29000792f, 0.31359243f, 0.32217824f, 
    0.23740520f, -0.06065374f, -0.13958533f, -0.06390778f, 0.02802806f, 0.01171136f, 0.19832140f, 0.00327743f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17537622f, -0.03481457f, -0.22801431f, 0.12253836f, -0.14391169f, 0.01470064f, 0.12599002f, 0.21899228f, 
    0.26399469f, 0.25950110f, 0.24572945f, 0.15176885f, 0.36812517f, 0.24296163f, 0.17490093f, 0.51798159f, 
    0.04625285f, 0.21602067f, -0.38540411f, 0.31639388f, 0.12118653f, 0.23396572f, 0.36140594f, -0.19608046f, 
    0.24141370f, 0.28474307f, -0.01520472f, 0.42128029f, 0.25582793f, 0.03461994f, -0.02437627f, 0.27611846f, 
    -0.42281064f, 0.33290574f, 0.10044666f, 0.34067202f, 0.02049386f, 0.25632709f, -0.07345653f, 0.00700743f, 
    0.24224444f, 0.15855224f, -0.07487054f, -0.05901283f, 0.46876845f, 0.29929608f, 0.10249525f, 0.28459606f, 
    0.37961885f, 0.18270671f, 0.27979928f, 0.22386894f, 0.02035606f, -0.10920000f, 0.26364589f, -0.15622842f, 
    0.12555900f, 0.20547082f, 0.21178477f, 0.19344684f, 0.32031998f, -0.07205921f, -0.50561947f, 0.04415226f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.30706134f, 0.32208654f, 0.08172596f, -0.26436862f, 0.05480187f, 0.19806004f, 0.11204349f, 0.18943284f, 
    0.07088664f, 0.06412691f, 0.04853280f, -0.17208363f, 0.06033785f, 0.14804842f, 0.07572303f, -0.00541760f, 
    0.05512261f, 0.06005410f, 0.01558231f, -0.05299406f, 0.06049722f, 0.03774234f, 0.08113000f, 0.12272740f, 
    0.00296155f, 0.06758585f, -0.18339121f, -0.00466941f, -0.16331291f, -0.18478069f, -0.14408652f, 0.03854017f, 
    -0.01490952f, 0.02584838f, 0.04178532f, 0.04651817f, 0.01415080f, 0.03644224f, -0.05853755f, -0.15961580f, 
    0.18794651f, -0.05351399f, 0.13203801f, -0.15600455f, 0.00860223f, -0.03036801f, -0.08794823f, 0.00671873f, 
    0.06418615f, -0.19287273f, -0.15699391f, -0.04067171f, -0.05460258f, -0.04336249f, -0.02149073f, 0.05015982f, 
    -0.08235612f, -0.02577642f, 0.16526525f, 0.20262431f, -0.07097742f, 0.02509843f, -0.00418338f, -0.02707496f, 
    0.05054672f, 0.00550902f, -0.02066095f, -0.00938890f, -0.00201921f, 0.04763837f, -0.11425413f, 0.01995528f, 
    0.15659766f, 0.06089550f, -0.11538151f, -0.08187944f, -0.04370593f, -0.16074419f, 0.05655637f, -0.12948655f, 
    -0.05305814f, -0.00386769f, -0.00130304f, -0.12151952f, 0.14840937f, -0.01674518f, 0.16112173f, -0.12639977f, 
    -0.01454976f, 0.04555589f, 0.04632256f, -0.08078476f, 0.06180004f, 0.03705485f, 0.01899344f, -0.02088365f, 
    -0.06871814f, 0.09874965f, 0.00797840f, 0.03158204f, -0.06181570f, 0.02257473f, 0.05892101f, -0.05235867f, 
    0.01348674f, -0.06260706f, -0.11402751f, -0.08047532f, 0.12917481f, 0.07855960f, -0.11348288f, 0.05138664f, 
    0.02348696f, -0.03741810f, 0.13072722f, -0.06587306f, -0.07856320f, 0.03154936f, -0.00932263f, -0.02674572f, 
    -0.32307234f, 0.07936753f, 0.19412041f, -0.04671471f, 0.01082240f, -0.01720845f, -0.04794921f, 0.03628352f, 
    0.00928125f, -0.05891325f, -0.08129310f, 0.04660376f, 0.06167692f, 0.01268353f, -0.12944816f, 0.05579384f, 
    0.04082045f, -0.02377990f, 0.02628450f, -0.02424777f, -0.27263206f, -0.20670040f, -0.01901514f, -0.08375217f, 
    -0.10111186f, -0.22163188f, 0.08824166f, -0.16686025f, 0.04222390f, 0.11395297f, -0.07858787f, -0.10110120f, 
    0.00035987f, -0.11909579f, -0.09144481f, -0.14570117f, -0.06299015f, -0.04927993f, -0.09261340f, 0.03068904f, 
    -0.15133113f, -0.01305850f, -0.03459819f, 0.03638137f, -0.08273282f, -0.10942755f, -0.12505141f, 0.03473716f, 
    -0.11216066f, -0.28230274f, -0.17606188f, -0.16701585f, -0.12470894f, -0.00890263f, -0.04441645f, -0.13253649f, 
    0.04297484f, -0.11889291f, -0.00501852f, -0.19993848f, 0.09016788f, -0.13477960f, -0.20721245f, -0.00372047f, 
    -0.00774690f, -0.14369610f, 0.04378220f, -0.07992025f, -0.09583153f, -0.01315595f, -0.07666146f, 0.05125707f, 
    0.09613585f, -0.18600275f, 0.18781301f, 0.05102408f, -0.14213860f, 0.04434936f, 0.03560227f, -0.09886993f, 
    -0.14601977f, -0.05832288f, -0.09137669f, -0.05344441f, -0.01779509f, 0.01663584f, 0.12891234f, -0.10057445f, 
    0.00069894f, -0.15695646f, -0.02257836f, 0.04617092f, -0.07779171f, 0.00595803f, 0.01680095f, -0.08030751f, 
    0.36187345f, 0.19091873f, -0.15373927f, 0.06910895f, 0.07421256f, 0.12019416f, 0.14914282f, -0.03646376f, 
    -0.03753839f, 0.01931037f, 0.02434815f, 0.09104703f, -0.47928980f, 0.13657238f, -0.13420299f, -0.08672813f, 
    0.00716067f, 0.06356138f, -0.01826139f, -0.00682439f, 0.01751427f, 0.00670013f, -0.00313283f, 0.01736939f, 
    -0.04085062f, 0.12857038f, 0.02818673f, 0.01767484f, 0.02828306f, 0.11584637f, 0.04110990f, 0.02162678f, 
    -0.13634279f, -0.06320567f, -0.14766292f, 0.03397548f, 0.30317244f, 0.07440075f, -0.17470892f, -0.12923118f, 
    -0.03887722f, -0.06211248f, -0.11751652f, 0.02325638f, 0.00036158f, 0.04690601f, 0.04652676f, 0.05116990f, 
    0.17712493f, 0.22646135f, 0.03400037f, -0.01371610f, -0.06570470f, 0.03712730f, 0.04404678f, -0.07581027f, 
    -0.06405716f, -0.07669246f, -0.07519621f, 0.07441305f, 0.12554052f, -0.11282013f, 0.06127245f, -0.26435545f, 
    0.07385738f, -0.02446703f, 0.06439468f, 0.09677559f, -0.07095222f, 0.05446579f, 0.00347701f, 0.10816273f, 
    0.11428310f, 0.20998192f, 0.11176590f, -0.27142012f, -0.03380044f, 0.07072902f, 0.04196859f, -0.09196346f, 
    -0.03801240f, -0.15172990f, -0.05445327f, -0.08876792f, 0.62142801f, 0.12530681f, 0.02462041f, -0.12244250f, 
    0.02779659f, -0.05692266f, 0.12436962f, -0.00016796f, -0.12448011f, -0.04278376f, 0.03442324f, 0.00405157f, 
    0.36692682f, 0.10519465f, 0.04506058f, -0.10120801f, 0.15731144f, 0.12253290f, 0.08358698f, 0.02403738f, 
    -0.00897938f, 0.01815413f, -0.06144631f, 0.09120786f, 0.15395749f, 0.20014392f, -0.28169706f, -0.07190583f, 
    0.04096831f, -0.08639058f, -0.04285530f, -0.06116128f, -0.02880920f, -0.05943502f, 0.02897192f, -0.01698564f, 
    0.12679477f, 0.10081125f, -0.04608465f, 0.05258955f, 0.14174673f, 0.08363228f, -0.10739139f, -0.01234654f, 
    0.02511618f, -0.06985053f, 0.01831222f, 0.09836018f, 0.04715973f, -0.04838396f, -0.11138288f, 0.11118589f, 
    -0.08534064f, -0.05249567f, -0.10492849f, -0.04289517f, -0.05574509f, 0.01549327f, 0.02174297f, 0.00418629f, 
    0.29588005f, 0.20095627f, -0.13843727f, -0.12452187f, 0.03053894f, -0.02094543f, -0.08696948f, -0.08734744f, 
    -0.00196423f, 0.00479212f, 0.06081337f, 0.02822000f, 0.00202301f, -0.46112186f, -0.14230408f, -0.01709221f, 
    0.05958533f, -0.01315239f, -0.02545177f, 0.01431898f, -0.15912887f, 0.02180610f, -0.01335565f, 0.08992566f, 
    0.33269805f, 0.25560284f, -0.06996826f, -0.21533816f, 0.15659332f, 0.09496257f, 0.13397104f, 0.11187062f, 
    0.00368654f, -0.03896441f, -0.00295833f, -0.03424165f, -0.00690524f, -0.20611933f, -0.06848744f, 0.08790442f, 
    -0.05488586f, -0.07232308f, -0.00907433f, -0.10193191f, -0.00425907f, 0.02807794f, -0.01836994f, -0.01776000f, 
    -0.10363527f, -0.11864478f, -0.12395855f, -0.08751123f, -0.03416621f, -0.05676208f, -0.06859618f, -0.04203648f, 
    -0.02048071f, 0.01511197f, 0.00405081f, 0.05416546f, -0.43408075f, 0.39378935f, 0.32821566f, -0.21095912f, 
    0.01907206f, -0.01263983f, 0.04961443f, 0.04533733f, -0.05539947f, -0.09203963f, 0.02594849f, -0.14686038f, 
    0.02141957f, -0.00659062f, 0.00420302f, 0.09889612f, 0.00808335f, -0.02967103f, 0.06189580f, 0.00062872f, 
    -0.09684134f, -0.02542942f, -0.07061760f, -0.03354475f, -0.54847914f, -0.31246117f, -0.03545105f, 0.04344158f, 
    0.04089576f, 0.05946133f, 0.01268348f, 0.00101038f, -0.05591621f, -0.01810844f, 0.02343483f, -0.03650680f, 
    0.11103635f, 0.05585071f, -0.10797482f, -0.09650795f, -0.06042054f, -0.05508592f, -0.04053978f, 0.04451041f, 
    -0.10727419f, -0.00389491f, 0.06645412f, -0.03735227f, -0.13670795f, 0.08609202f, 0.19343199f, 0.02128573f, 
    -0.05755425f, 0.04969997f, -0.02026473f, 0.03617525f, -0.02657872f, 0.11753986f, 0.06764975f, 0.05131172f, 
    0.29558817f, 0.22281164f, -0.27212030f, -0.14808455f, -0.02591854f, 0.05664068f, 0.10809389f, -0.21944439f, 
    -0.07227775f, -0.05558031f, -0.05192244f, -0.02797233f, 0.09400560f, 0.08225990f, -0.22235125f, -0.06797735f, 
    0.16593961f, 0.15503812f, -0.03125298f, -0.10959729f, -0.12494017f, -0.14469549f, -0.22027662f, -0.10832337f, 
    -0.08379629f, -0.00289544f, 0.08857083f, 0.04776740f, -0.01193971f, -0.00804389f, -0.06065809f, -0.05155112f, 
    -0.03523024f, 0.05097838f, -0.03385105f, 0.10869914f, 0.06082569f, -0.21060501f, 0.02126404f, -0.11534401f, 
    0.11531197f, 0.24788518f, 0.03216045f, 0.01235924f, -0.05545998f, 0.00691960f, 0.01323044f, -0.10708977f, 
    0.21370628f, -0.57627672f, -0.54643327f, 0.04176280f, -0.02811381f, 0.01943418f, 0.03303475f, -0.01273437f, 
    -0.06181788f, -0.12680049f, -0.12308700f, -0.03185374f, -0.27797759f, -0.70279366f, -0.01276062f, 0.00222612f, 
    -0.13889490f, -0.06475841f, -0.07661995f, -0.06361627f, -0.13893171f, -0.12791061f, -0.11516788f, -0.10438365f, 
    0.39511785f, -0.12283252f, -0.25667018f, 0.07315987f, -0.08638812f, -0.16415037f, 0.10154518f, 0.04979044f, 
    0.00479066f, 0.00841455f, 0.04653206f, 0.02120012f, -0.14261864f, 0.13323753f, 0.02271177f, -0.12222005f, 
    -0.01893345f, 0.00967229f, -0.17554614f, -0.13365895f, 0.00631530f, -0.06698797f, -0.04168905f, -0.04659171f, 
    0.39618886f, -0.05055566f, -0.08362455f, -0.11316982f, 0.02152092f, -0.17208478f, -0.01682420f, -0.15147018f, 
    -0.05065387f, 0.01997529f, -0.02637064f, 0.05710425f, 0.07146063f, 0.07462748f, 0.16442584f, -0.16562144f, 
    0.07734136f, -0.04898298f, -0.02821627f, 0.05453862f, -0.09586325f, 0.05218210f, 0.04091518f, -0.08669179f, 
    -0.47510543f, -0.78326517f, -0.11834814f, -0.12613524f, 0.09383064f, -0.12862098f, 0.02118989f, 0.01095455f, 
    0.03088823f, -0.04288604f, -0.13330828f, -0.10079449f, -0.01724423f, -0.07436344f, -0.16429639f, 0.02492042f, 
    0.01948999f, -0.08484234f, -0.03514119f, -0.01456780f, -0.00349979f, -0.09627236f, -0.16826281f, -0.03809806f, 
    0.20518418f, 0.12632340f, 0.27107844f, -0.09735374f, -0.03521494f, -0.11806694f, 0.01415978f, -0.17708257f, 
    -0.00944798f, -0.11599084f, -0.01307098f, -0.18458202f, 0.22434418f, 0.09764209f, -0.09043627f, -0.12423459f, 
    0.07354457f, 0.13190709f, 0.04800418f, -0.07552489f, -0.08042903f, -0.00264348f, -0.00283787f, 0.04861699f, 
    0.13765265f, -0.09685659f, -0.25015271f, -0.16521773f, -0.04297384f, -0.01853081f, -0.12105972f, -0.10078026f, 
    0.05155610f, -0.01851091f, -0.04535334f, 0.07160749f, -0.00063191f, 0.13222823f, 0.09503755f, -0.11000330f, 
    0.04820416f, 0.04506529f, -0.03857415f, -0.16796976f, -0.00613005f, -0.01394019f, 0.01465377f, -0.04578082f, 
    0.02033693f, -0.10063560f, 0.15216044f, 0.28236058f, 0.02168354f, -0.00109551f, 0.02529873f, 0.01544934f, 
    0.06517029f, 0.04223260f, 0.02966451f, 0.03168546f, 0.24531534f, 0.12205489f, -0.09730853f, -0.31609529f, 
    -0.14848375f, 0.03464449f, 0.02805385f, -0.32684520f, 0.03156438f, -0.08241406f, -0.05191179f, -0.02043728f, 
    -0.03595240f, -0.08027293f, -0.10522910f, -0.02437689f, -0.02698479f, -0.01610605f, 0.07032561f, 0.00849702f, 
    0.00820842f, -0.08705597f, -0.03591540f, -0.07136112f, 0.08561900f, -0.09913022f, -0.28798607f, 0.19994192f, 
    0.00503922f, -0.06760455f, 0.15513335f, -0.06805098f, -0.02076843f, 0.06536197f, -0.00074695f, -0.04878214f, 
    0.19936754f, -0.42375293f, -0.13622652f, 0.00459447f, -0.02668663f, 0.01753329f, -0.20530213f, -0.23971185f, 
    -0.13350523f, -0.17791405f, 0.00423356f, -0.03423984f, 0.17091098f, 0.15458354f, -0.01347420f, -0.09817735f, 
    -0.02994481f, 0.13845542f, -0.09213942f, 0.01482892f, -0.15571329f, -0.15569083f, -0.15021761f, -0.17568408f, 
    0.37419039f, 0.14845559f, -0.08606639f, -0.12018818f, 0.19435966f, 0.12480911f, 0.16578017f, 0.08547214f, 
    -0.08374367f, -0.08284816f, -0.09354588f, -0.10538572f, 0.03213127f, 0.06833671f, -0.14000703f, 0.08569480f, 
    0.01203326f, -0.04893455f, -0.09055439f, 0.05465006f, -0.01221775f, 0.05545829f, 0.00833362f, 0.01045460f, 
    0.15441567f, 0.30992937f, -0.14069998f, 0.00086875f, 0.04067874f, 0.12421818f, -0.11986212f, -0.27085775f, 
    -0.00768359f, -0.04020081f, -0.15280898f, -0.10905174f, -0.07448330f, 0.07519087f, -0.10607388f, -0.05533418f, 
    -0.01936912f, -0.01566978f, -0.02673778f, -0.12456603f, -0.12689792f, -0.34560293f, -0.11931192f, -0.12141053f, 
    0.04593080f, -0.77324384f, -0.34927326f, -0.65596825f, -0.05793236f, -0.01700379f, -0.06298813f, -0.08285943f, 
    -0.05747342f, 0.01705524f, -0.00457384f, 0.01898545f, -0.13557662f, -0.01078969f, 0.01338392f, 0.01756909f, 
    -0.13808639f, 0.26873913f, 0.06116885f, -0.10236087f, 0.12592846f, 0.13018383f, 0.03461029f, -0.12983224f, 
    -0.00172949f, -0.18423678f, 0.04257528f, -0.11487194f, -0.00730224f, -0.04743656f, 0.02297513f, -0.01537289f, 
    -0.09152389f, -0.20067316f, -0.37657398f, -0.29570836f, 0.07634106f, 0.05008722f, 0.09692821f, 0.06404477f, 
    0.01547052f, -0.06472844f, -0.00037024f, 0.00896660f, 0.08468804f, 0.09398176f, -0.10556543f, 0.06841148f, 
    0.18541110f, 0.12036997f, -0.12361808f, -0.03430463f, -0.09452073f, -0.05822654f, -0.02355036f, 0.01506419f, 
    -0.02919532f, 0.00750586f, -0.04608484f, 0.03400781f, 0.07787131f, 0.11201874f, -0.13496052f, -0.15281719f, 
    0.04883535f, 0.05655114f, 0.04655565f, -0.22067620f, -0.01478838f, 0.04915882f, 0.14486673f, -0.08898480f, 
    -0.02044518f, 0.03105125f, 0.01330447f, 0.08240593f, -0.02784114f, -0.02654434f, 0.04689676f, 0.03876755f, 
    -0.10952286f, 0.05096612f, 0.06717678f, -0.09786126f, 0.39703885f, -0.08071691f, -0.18685660f, -0.08139768f, 
    -0.10674313f, -0.10982885f, -0.07172392f, -0.09712444f, 0.07373779f, -0.09553203f, -0.04445662f, -0.01515413f, 
    -0.00286305f, 0.11193211f, 0.06202494f, 0.10004975f, 0.03864242f, -0.00812502f, 0.00177447f, 0.05006187f, 
    0.11939300f, 0.06023665f, 0.08617447f, -0.04776198f, 0.17622156f, -0.06519722f, 0.09613909f, 0.09207062f, 
    -0.10328289f, 0.01587399f, -0.14467096f, -0.01822255f, 0.13251391f, 0.08598435f, -0.07075689f, 0.06624524f, 
    -0.40978369f, 0.19655403f, -0.25902745f, -0.43042186f, 0.02764972f, 0.06942274f, -0.02333664f, -0.09131035f, 
    -0.14347707f, 0.13672218f, -0.03707514f, -0.05916744f, 0.05104427f, 0.00887733f, 0.03477401f, 0.00043317f, 
    0.14422375f, -0.01851192f, -0.00352626f, 0.03204457f, -0.07434793f, -0.00574432f, 0.02919987f, -0.02364131f, 
    0.27352244f, -0.06777501f, 0.22789335f, -0.60800827f, 0.02459909f, 0.01240449f, -0.05807314f, 0.03332785f, 
    -0.00636432f, 0.06545271f, -0.04141928f, -0.17302178f, 0.07345074f, -0.48149422f, 0.12344212f, -0.31725204f, 
    0.08105603f, 0.14033669f, 0.10363869f, 0.04338909f, -0.01873498f, 0.03017006f, -0.08384775f, 0.10686180f, 
    -0.06683055f, -0.10752020f, -0.01427774f, -0.13123628f, 0.00993700f, -0.00358564f, -0.10627130f, 0.03846819f, 
    -0.06065579f, 0.03507371f, -0.01484547f, 0.05547764f, -0.11323619f, 0.16425098f, -0.08064573f, -0.04346710f, 
    -0.02754828f, -0.08686519f, 0.03222499f, 0.09493703f, -0.05902692f, -0.06172856f, -0.02095234f, -0.01336092f, 
    0.01901371f, -0.01931641f, 0.02927906f, 0.18420126f, -0.18628347f, 0.01348272f, 0.07706351f, -0.02450525f, 
    0.00611317f, -0.02297692f, 0.00369668f, -0.01750104f, 0.13459335f, 0.05507595f, 0.35243276f, 0.10386384f, 
    0.01812864f, -0.01305343f, -0.00703318f, -0.12381903f, -0.05910567f, 0.01120706f, 0.00687819f, 0.03812892f, 
    -0.08360597f, -0.11548335f, -0.15552534f, -0.01380304f, -0.06315703f, 0.01074517f, -0.06706224f, 0.01835257f, 
    -0.15317465f, 0.17906740f, 0.05269255f, 0.03038449f, -0.14669150f, -0.23017851f, -0.03473253f, -0.11161982f, 
    0.26986760f, -0.10216486f, -0.12910497f, -0.11004876f, 0.03165783f, 0.01535573f, 0.05364274f, -0.00353835f, 
    0.00907618f, -0.08623534f, -0.10007926f, -0.12569486f, 0.00055115f, 0.03622865f, 0.02110266f, 0.09046708f, 
    0.07992761f, -0.02311162f, -0.03718667f, 0.02265726f, 0.09707238f, 0.06301949f, -0.03638936f, -0.33480567f, 
    0.00935786f, -0.00491912f, 0.02586538f, -0.15952563f, 0.10916951f, -0.08425788f, -0.09676175f, -0.00950042f, 
    -0.27857241f, -0.12905654f, -0.18655460f, 0.15371464f, -0.14341205f, 0.20047699f, -0.01890266f, 0.09531073f, 
    -0.01837704f, 0.04936094f, 0.03686324f, -0.12214255f, 0.31854579f, -0.03185899f, 0.22471404f, 0.20112184f, 
    -0.08927041f, 0.00800637f, -0.00504473f, -0.01840752f, 0.11367927f, -0.04641325f, -0.13622965f, -0.06692982f, 
    -0.22791125f, 0.17655572f, 0.03226828f, -0.12529416f, -0.06900797f, -0.13536039f, -0.03256197f, -0.18319629f, 
    0.05694105f, -0.04509428f, -0.05412369f, 0.01570550f, 0.05249624f, -0.17582296f, -0.22794136f, 0.36586529f, 
    0.08268151f, 0.03218048f, 0.08512343f, 0.15810472f, -0.03562235f, 0.07237317f, -0.11702242f, 0.08128186f, 
    -0.05964085f, -0.04522872f, -0.05600112f, 0.04990646f, -0.13583104f, 0.14687128f, -0.21320610f, -0.11568746f, 
    -0.03106745f, 0.00081697f, -0.01413196f, 0.03311060f, -0.01336508f, -0.03753693f, 0.05617867f, -0.06765011f, 
    0.11661042f, -0.14112021f, -0.01868881f, -0.01189880f, -0.06985895f, 0.02208654f, 0.00111933f, 0.12393136f, 
    0.15784244f, 0.14383665f, 0.12986641f, 0.09235661f, 0.05379482f, 0.05531398f, 0.02064043f, -0.11761517f, 
    -0.04119912f, 0.00947546f, -0.03996903f, -0.00291050f, 0.15160853f, 0.07300420f, 0.07131708f, 0.05801599f, 
    -0.01363397f, -0.11878664f, 0.05725034f, 0.03356052f, 0.04735310f, 0.09509709f, 0.04021775f, -0.08276526f, 
    0.06106220f, 0.18865144f, 0.13662563f, 0.15281999f, -0.11829647f, -0.04030707f, -0.11397794f, -0.10435810f, 
    0.01078751f, -0.01435376f, -0.02353654f, 0.02039162f, 0.32990664f, -0.20704193f, 0.07570446f, -0.10000713f, 
    -0.02384687f, 0.01248872f, 0.12048385f, -0.03325509f, -0.06242513f, -0.05311908f, -0.01786260f, 0.04554286f, 
    0.24406844f, 0.15542774f, -0.00000978f, -0.17658347f, -0.16732398f, -0.14251721f, -0.16131911f, -0.12129003f, 
    -0.06732331f, -0.02257704f, 0.02488065f, 0.06045867f, -0.30134264f, 0.05044283f, 0.06626287f, 0.23949762f, 
    -0.03834455f, -0.00472254f, 0.00953774f, -0.00939836f, 0.07020120f, 0.13880049f, -0.13767491f, 0.22088224f, 
    0.15211810f, 0.12352072f, 0.06381784f, 0.08793917f, 0.01698893f, 0.01472771f, -0.04568368f, -0.06511938f, 
    0.02139422f, -0.00024272f, 0.03838979f, -0.01503188f, 0.29512838f, 0.04270746f, 0.18684940f, -0.01889524f, 
    -0.02172242f, 0.00575606f, -0.02192581f, -0.08722250f, 0.04950076f, -0.05149789f, 0.12024880f, -0.00392220f, 
    0.09736126f, 0.07196525f, -0.01322999f, -0.17158560f, -0.02643044f, -0.00892980f, -0.05257345f, 0.07976733f, 
    -0.33696121f, -0.04246043f, -0.15310173f, -0.39347583f, -0.19003583f, 0.00377807f, -0.00909389f, 0.01275181f, 
    0.12798120f, -0.02927327f, -0.21009955f, 0.00443166f, 0.05351980f, 0.10684282f, -0.31024048f, -0.00905318f, 
    -0.46830222f, -0.12906046f, -0.04551449f, 0.02867196f, -0.10785740f, 0.07104406f, 0.05502434f, 0.15119962f, 
    -0.01590265f, 0.14578578f, 0.07194357f, 0.01973133f, -0.14328174f, -0.23183435f, -0.22395372f, -0.06268947f, 
    0.00745306f, 0.10351435f, 0.16055961f, 0.18104032f, -0.06382219f, 0.11875293f, -0.29744321f, 0.13084900f, 
    0.00185895f, -0.05566556f, 0.07048092f, -0.03782123f, 0.08015185f, -0.03692451f, -0.02483724f, 0.05528552f, 
    -0.04984347f, -0.02468991f, -0.22639938f, 0.07013422f, 0.16241921f, 0.15176702f, -0.31414241f, -0.24580847f, 
    -0.10388067f, 0.02414219f, -0.02474732f, -0.06396053f, -0.07092289f, -0.05286665f, -0.20120327f, -0.05996373f, 
    0.74202108f, -0.22504383f, 0.36780491f, 0.24189311f, -0.04993021f, -0.00506063f, -0.04880025f, -0.02614473f, 
    0.10074050f, -0.00252974f, 0.01255498f, -0.09615427f, 0.30142865f, -0.19395572f, 0.05840153f, -0.30527264f, 
    0.00375055f, -0.05004809f, -0.12098407f, 0.10029101f, 0.04213054f, -0.12798874f, 0.06473134f, 0.08130360f, 
    0.01523482f, -0.00981419f, -0.18310355f, 0.13877647f, -0.00236375f, -0.04371867f, -0.00288033f, -0.12772334f, 
    0.24729674f, -0.04349371f, -0.04976502f, -0.02515272f, -0.23830223f, 0.16970141f, 0.01334711f, 0.03867863f, 
    0.13428429f, 0.11489582f, 0.03685283f, 0.02715108f, 0.01120168f, -0.07535616f, 0.00516391f, 0.00699993f, 
    -0.22850980f, 0.04258011f, -0.04148424f, -0.11238957f, -0.09930327f, -0.03243192f, 0.12040757f, 0.08933642f, 
    0.04606096f, 0.01928665f, 0.08184502f, 0.01395759f, -0.00159046f, 0.11997800f, -0.07872181f, 0.09020249f, 
    0.01684876f, 0.09047727f, 0.18965170f, -0.19760479f, -0.04992543f, 0.04390712f, -0.08292378f, -0.06160411f, 
    0.34023234f, -0.08407006f, 0.12081800f, -0.00062581f, -0.16185528f, -0.08721504f, 0.06087482f, -0.01315455f, 
    -0.01886345f, 0.02494810f, 0.07720308f, -0.06011738f, 0.14938694f, 0.11460800f, -0.08847862f, -0.02801158f, 
    -0.01736313f, 0.02015390f, 0.07373550f, -0.00170173f, -0.04993179f, 0.20594031f, 0.10911406f, -0.13299887f, 
    -0.10868458f, 0.09301983f, -0.08157933f, -0.01622404f, 0.05518842f, 0.17434432f, 0.15848325f, 0.01309913f, 
    0.02448742f, 0.10624769f, -0.06955016f, 0.14534001f, 0.14199832f, 0.25325853f, 0.22809957f, 0.18049191f, 
    0.11585881f, 0.16777076f, -0.11316846f, -0.11147424f, -0.00669268f, 0.00063006f, 0.08221229f, -0.08334663f, 
    0.27076945f, 0.02964813f, -0.08272201f, -0.13304047f, -0.12627123f, 0.03066898f, -0.01509397f, -0.00678288f, 
    -0.02556245f, -0.23372911f, 0.08543445f, 0.01501604f, 0.00964370f, 0.24425544f, 0.09897147f, -0.03171009f, 
    -0.07159864f, -0.10979827f, -0.05600129f, 0.25750110f, -0.08124262f, -0.01279356f, 0.00851059f, -0.04336652f, 
    0.31207490f, 0.07505448f, 0.10411433f, 0.13255416f, -0.02567344f, 0.00151088f, 0.00789964f, -0.02403274f, 
    -0.06344625f, 0.03296746f, 0.05708956f, -0.02135848f, -0.25530082f, 0.09923601f, -0.44460967f, 0.13886499f, 
    -0.00769502f, 0.13637915f, 0.16676924f, -0.07222878f, 0.00447441f, 0.20735371f, 0.08534236f, -0.02920680f, 
    -0.01194455f, 0.12587531f, 0.06605713f, 0.03521356f, 0.05342555f, 0.01587228f, -0.03391906f, 0.05767569f, 
    0.02681073f, 0.01559757f, -0.14222552f, -0.03476088f, 0.24039744f, -0.16498101f, 0.08531593f, 0.00784000f, 
    -0.20439835f, -0.03800605f, 0.07612033f, -0.01087535f, -0.08124919f, -0.02155007f, -0.03091739f, 0.04411289f, 
    -0.06193276f, -0.37139240f, -0.02918588f, -0.10800594f, 0.01128252f, 0.04359172f, -0.05712793f, 0.13864395f, 
    -0.06750358f, 0.16679870f, -0.11365090f, 0.02318331f, -0.27493685f, 0.11477610f, 0.12531656f, 0.11594859f, 
    0.12489913f, 0.15067375f, 0.02125154f, 0.22615837f, -0.01872949f, 0.01815624f, 0.08058228f, -0.01024306f, 
    0.01024374f, -0.04091949f, 0.41609210f, 0.34514025f, -0.03192214f, -0.08386535f, 0.25645569f, -0.20824924f, 
    0.01612481f, 0.03783490f, 0.01655298f, -0.02369546f, 0.15111504f, -0.08311296f, 0.03193315f, -0.27796528f, 
    -0.05142159f, -0.12398385f, 0.08575860f, -0.07347243f, -0.00596199f, 0.01708055f, -0.04149369f, 0.05285678f, 
    -0.24655199f, -0.07997914f, 0.14005886f, 0.44100866f, 0.02229815f, -0.00056217f, -0.17798080f, 0.06779437f, 
    0.03500896f, 0.07556782f, -0.06118594f, 0.10770642f, -0.03903883f, 0.11902678f, -0.02389943f, 0.20737214f, 
    -0.04111148f, -0.01612625f, 0.00077108f, -0.02902618f, 0.02344649f, 0.06079724f, 0.15887678f, 0.12316556f, 
    -0.15931429f, 0.19069727f, 0.15668708f, -0.25552201f, -0.04941327f, -0.01320985f, 0.01034519f, -0.10662335f, 
    -0.02029070f, -0.00775754f, -0.02739869f, -0.04719897f, -0.04345958f, 0.06815983f, -0.00048973f, -0.06291727f, 
    -0.01432395f, -0.02205985f, -0.02327518f, 0.07667239f, -0.02608320f, -0.05479522f, 0.08207478f, 0.05465119f, 
    -0.14939968f, -0.06608158f, 0.13936675f, -0.29177552f, 0.00935414f, -0.08113161f, -0.02998805f, 0.00954170f, 
    -0.02945823f, 0.04719244f, 0.08248003f, 0.20632027f, -0.00349294f, -0.02698355f, -0.07519986f, -0.08318955f, 
    0.01730138f, -0.01493964f, 0.02507113f, 0.05860873f, -0.06371129f, 0.07179759f, -0.14175317f, 0.15001352f, 
    -0.06427406f, -0.12353431f, -0.21483620f, -0.16024607f, 0.05136053f, -0.06606539f, -0.03585423f, -0.02175475f, 
    -0.01113459f, -0.04276499f, 0.04339290f, -0.12554331f, 0.35547823f, 0.29919791f, 0.26309052f, 0.23848291f, 
    0.00059988f, 0.06110389f, -0.06414266f, 0.08233897f, -0.05591529f, -0.10829915f, 0.08366618f, 0.20036152f, 
    -0.01354375f, -0.11205546f, 0.01366200f, 0.14042670f, 0.01396483f, 0.00821113f, -0.04877818f, 0.02700436f, 
    -0.04562365f, -0.07824329f, -0.09827069f, -0.14106523f, 0.01079015f, -0.15250409f, -0.00409204f, 0.11396810f, 
    -0.05993697f, -0.02455236f, 0.09515268f, 0.03034373f, 0.09843538f, 0.12596138f, -0.10120209f, 0.06180792f, 
    0.08770500f, -0.05333975f, -0.09544785f, 0.03332363f, 0.03527969f, -0.00528192f, 0.03670854f, 0.04400383f, 
    -0.03124512f, -0.03414392f, -0.01836079f, 0.03435766f, 0.00581420f, -0.08794040f, -0.07317030f, -0.21563737f, 
    0.00525508f, -0.02232668f, -0.05577712f, -0.02309586f, -0.02382826f, 0.13948271f, 0.00987315f, 0.00497392f, 
    -0.06217249f, 0.35568196f, 0.04242083f, 0.26238647f, 0.04903775f, 0.05880948f, -0.00106139f, -0.03705738f, 
    -0.01171652f, 0.00524310f, -0.12147480f, 0.15296231f, -0.10432068f, -0.03845146f, 0.04538311f, 0.01072101f, 
    -0.02663530f, 0.03216784f, -0.03567103f, 0.01308236f, -0.01263274f, 0.06324130f, -0.00174068f, -0.08158947f, 
    -0.48473111f, 0.50602752f, -0.03377691f, -0.30518156f, 0.07643675f, 0.00824128f, -0.06297040f, 0.05407400f, 
    0.03616101f, -0.08553468f, 0.06522373f, -0.11527886f, -0.14597534f, 0.06448708f, -0.00870483f, -0.14795317f, 
    -0.00908850f, 0.02464041f, 0.02516281f, -0.23652050f, 0.06190515f, -0.03968197f, 0.04549718f, 0.08887082f, 
    0.09785492f, -0.07088626f, 0.05666544f, -0.09390430f, 0.04688200f, -0.13473821f, -0.08771557f, -0.06021646f, 
    -0.06405645f, 0.00979642f, -0.12059331f, 0.01506826f, 0.00256352f, 0.22101940f, -0.23993826f, -0.00434672f, 
    0.13869098f, -0.10384674f, 0.05889588f, 0.10184551f, -0.01750433f, 0.00532815f, 0.00382487f, 0.02107140f, 
    -0.12133568f, -0.19989763f, 0.04855615f, -0.10800678f, -0.01644054f, -0.11993133f, 0.06409926f, 0.09080230f, 
    0.03231318f, -0.01751057f, 0.06064658f, 0.01585287f, -0.54722822f, -0.06159099f, 0.32560822f, 0.03352818f, 
    -0.02468817f, 0.01996625f, -0.00978505f, 0.02178644f, -0.01369665f, 0.01450200f, -0.04537164f, 0.05141687f, 
    0.09102988f, 0.08331764f, 0.11184944f, 0.21896110f, -0.00924776f, -0.01697114f, 0.02281089f, 0.03358134f, 
    -0.10611357f, -0.24065971f, 0.14196716f, 0.06192641f, 0.15331866f, -0.15411711f, 0.08261292f, -0.15785518f, 
    0.02695511f, 0.10103070f, -0.08994087f, -0.27177152f, 0.00760006f, 0.01254120f, 0.00345492f, 0.01925083f, 
    0.13029502f, -0.26667106f, 0.10475902f, 0.02316505f, 0.05765806f, -0.00947403f, -0.02518393f, 0.06844602f, 
    0.01047194f, -0.00137959f, 0.04513649f, 0.06377120f, -0.31371909f, 0.01171919f, -0.09873971f, 0.01448213f, 
    0.02449834f, 0.05188005f, -0.17514487f, -0.15737122f, 0.08916683f, 0.03757970f, -0.06885436f, 0.01441617f, 
    0.27801245f, -0.12460925f, -0.12899303f, 0.03856278f, 0.02407931f, 0.08854676f, -0.17810208f, 0.00274564f, 
    -0.02909332f, -0.06450254f, -0.02322959f, -0.04457598f, -0.12078965f, -0.27499068f, 0.20818986f, -0.01682125f, 
    -0.00257360f, -0.02808920f, 0.02884085f, 0.08703519f, -0.02384098f, 0.06987894f, -0.02066508f, -0.01734000f, 
    -0.37290284f, 0.17186530f, 0.09879246f, 0.01305706f, -0.05803256f, -0.09009072f, -0.01845762f, 0.02400767f, 
    -0.00196956f, 0.04443726f, -0.03030244f, 0.04843211f, 0.09641781f, 0.04410467f, 0.05408211f, 0.27165008f, 
    0.09858458f, -0.09033182f, 0.14893994f, 0.02960367f, -0.00750109f, 0.02162916f, -0.05260203f, -0.09951707f, 
    0.01550303f, 0.30971706f, -0.08891695f, 0.42130750f, -0.00219734f, -0.04434938f, 0.29025221f, -0.02410430f, 
    -0.01947639f, 0.01507347f, 0.03243792f, -0.03201963f, -0.07767238f, -0.09078949f, 0.09592431f, -0.21303003f, 
    -0.05665839f, -0.27463135f, -0.27051476f, 0.00159371f, 0.00718481f, -0.12737364f, 0.02526218f, 0.00269642f, 
    -0.26677403f, -0.23241711f, 0.05051407f, 0.09974913f, -0.10964932f, 0.03398586f, 0.01524440f, 0.04371635f, 
    0.02752957f, 0.02766692f, 0.00948880f, 0.01098849f, -0.20261246f, 0.13786229f, -0.07961564f, -0.11804197f, 
    -0.00337914f, -0.04859243f, 0.07020034f, -0.03190447f, -0.06810767f, 0.08752517f, -0.05119853f, -0.01033635f, 
    -0.98844993f, -0.55326879f, -0.40912235f, -0.32010397f, 0.09250867f, 0.03045060f, 0.09705282f, 0.00298262f, 
    0.01119121f, 0.01864140f, -0.03212117f, -0.02604929f, -0.14074638f, -0.14931628f, 0.18276076f, -0.12498084f, 
    0.01178396f, -0.20151839f, -0.22955447f, -0.06249839f, 0.03754330f, 0.00163354f, -0.04172971f, 0.04732399f, 
    -0.69328493f, 0.02693734f, 0.11070211f, -0.24265057f, -0.05656635f, -0.28395814f, 0.10077313f, -0.07113787f, 
    -0.00610761f, -0.01955627f, 0.04192095f, 0.00714041f, 0.19435151f, -0.11302044f, -0.52684885f, 0.06256241f, 
    0.04138678f, 0.01790952f, 0.00512112f, 0.05928950f, -0.10689986f, -0.04643525f, 0.02769279f, 0.01913543f, 
    -0.12041552f, -0.09033679f, -0.04374611f, 0.02822444f, -0.04633860f, 0.00262316f, -0.02101743f, 0.10076281f, 
    -0.04021052f, -0.08641843f, 0.00774285f, -0.09068667f, -0.18838121f, 0.06841785f, 0.12782663f, -0.14626740f, 
    -0.04550808f, 0.07481430f, -0.04095916f, -0.00393434f, 0.09766365f, 0.01041715f, -0.01899307f, 0.02581183f, 
    0.13176343f, -0.00524784f, 0.02231625f, 0.15231051f, 0.00963592f, -0.07184339f, -0.01145828f, -0.02828007f, 
    0.12183234f, 0.20309210f, 0.08438008f, 0.12237125f, 0.13537690f, -0.07922748f, -0.08548029f, 0.05535271f, 
    0.06162067f, -0.03691947f, 0.05205519f, -0.07807731f, -0.02088487f, 0.00106340f, 0.00784550f, 0.05028625f, 
    -0.12020495f, -0.17576240f, 0.12177149f, -0.11158160f, -0.04929853f, -0.08748317f, -0.05014704f, 0.07944885f, 
    -0.01279748f, 0.00233406f, 0.00335825f, -0.00906804f, 0.01385117f, 0.04660309f, -0.08679271f, -0.34289417f, 
    0.06936934f, -0.08912568f, -0.05968649f, -0.08488664f, -0.02481630f, 0.02384234f, -0.10464204f, -0.06433490f, 
    -0.14603513f, -0.02034937f, 0.07764374f, -0.08008015f, -0.04385989f, -0.05588746f, -0.24477844f, -0.17148985f, 
    0.08507502f, 0.09276685f, -0.02270805f, 0.12848593f, -0.07837784f, 0.64792073f, 0.38898751f, 0.39846551f, 
    -0.13880400f, -0.04279519f, 0.03518819f, 0.04072173f, 0.13141705f, -0.08503089f, -0.12396418f, -0.00909694f, 
    0.07129802f, -0.11488283f, 0.26010808f, 0.04466926f, 0.00465007f, -0.01222059f, 0.06712089f, 0.02880421f, 
    0.10915955f, 0.11523803f, 0.15033841f, 0.06559978f, 0.25079447f, 0.16272254f, 0.03966379f, -0.33446959f, 
    0.13060425f, -0.14574809f, -0.16972667f, 0.19069585f, 0.04645700f, -0.02555485f, 0.02412078f, 0.06896916f, 
    0.06987814f, 0.08838718f, -0.31682897f, -0.02397164f, -0.02304005f, 0.04882216f, -0.05035604f, 0.15251610f, 
    0.06355925f, 0.05973622f, 0.03867285f, -0.07077931f, -0.20447926f, -0.13360091f, -0.08501478f, 0.06055531f, 
    0.02272051f, 0.13277932f, 0.05123857f, 0.00748179f, 0.01335126f, -0.00305308f, 0.09600711f, -0.10607937f, 
    -0.08324669f, 0.11432578f, -0.18642303f, -0.07738458f, 0.00518420f, -0.13795716f, 0.06890819f, 0.12784155f, 
    -0.00120489f, 0.08170909f, 0.04113329f, -0.12940481f, 0.09375784f, 0.02766941f, -0.05827513f, 0.13124286f, 
    0.07719186f, 0.12949613f, 0.22321542f, -0.25485542f, 0.01400706f, 0.00881735f, -0.01545560f, 0.03930364f, 
    0.20655942f, 0.16953281f, -0.01172077f, 0.09991754f, -0.00216687f, -0.07435265f, -0.09314252f, 0.12177354f, 
    -0.12073479f, 0.01786582f, 0.03323328f, -0.10583194f, -0.39262027f, 0.33362022f, 0.05985384f, -0.02153825f, 
    0.00237073f, -0.02163242f, -0.03703684f, -0.03039102f, -0.03640974f, -0.04049905f, 0.03816660f, -0.09639733f, 
    0.16766617f, 0.15033925f, -0.19189204f, 0.01898981f, 0.01439515f, 0.05300748f, -0.05086813f, -0.02159976f, 
    -0.04218118f, -0.04780221f, 0.10422341f, -0.11037519f, -0.01465030f, 0.08550023f, 0.39633247f, 0.52583176f, 
    -0.17704409f, -0.02683652f, 0.11913977f, -0.01136887f, -0.02820208f, 0.06241817f, 0.02536178f, -0.02332418f, 
    0.09794167f, 0.03918076f, 0.11389991f, -0.09895337f, 0.02806161f, -0.07713900f, -0.09228585f, 0.03893231f, 
    0.00793391f, -0.02631307f, 0.06665382f, 0.03146015f, 0.03737585f, -0.30461025f, -0.02148585f, 0.22362882f, 
    0.02663585f, -0.05239505f, 0.12518407f, -0.03096785f, -0.01915003f, -0.05725293f, -0.03906159f, -0.03504898f, 
    -0.22027248f, 0.02086490f, -0.08738993f, -0.11426247f, 0.04972449f, 0.02641844f, -0.02685010f, 0.02695639f, 
    -0.01182879f, -0.01829914f, 0.14156105f, -0.13021164f, -0.34209722f, 0.01713318f, -0.16178793f, 0.01824526f, 
    -0.14156890f, 0.03315015f, -0.14235388f, -0.19435227f, -0.01127360f, 0.05624720f, -0.10682947f, 0.04618499f, 
    -0.03740248f, -0.00625334f, -0.00632522f, 0.04133480f, 0.08219784f, 0.04413491f, -0.00897290f, 0.01397489f, 
    0.04379791f, -0.02973682f, 0.03377105f, -0.00969292f, -0.14653751f, -0.07081368f, 0.07364651f, -0.29190242f, 
    0.00588619f, 0.02038592f, -0.22478102f, 0.01152619f, 0.07895851f, 0.00090998f, -0.08644994f, 0.03210315f, 
    0.06245276f, 0.27449185f, -0.21216753f, 0.00923319f, -0.04703500f, 0.00204668f, -0.05222417f, -0.03722996f, 
    0.02565422f, -0.11735766f, -0.28833514f, 0.13626851f, -0.13145548f, -0.14688216f, -0.10567463f, -0.02004681f, 
    0.03776818f, -0.08152184f, -0.05765529f, -0.15663050f, -0.01373015f, -0.04046864f, -0.06732786f, -0.09788734f, 
    -0.70237702f, -0.50982606f, -0.24822973f, -0.34365419f, 0.05556617f, -0.16113427f, 0.12114713f, -0.02057039f, 
    0.01366956f, -0.05027542f, -0.01573703f, -0.05401188f, -0.08238480f, -0.08131769f, 0.12981611f, -0.37299028f, 
    -0.01218280f, -0.09022981f, 0.06511432f, 0.03238510f, 0.02812950f, -0.02785468f, 0.01403090f, -0.01839452f, 
    0.24690092f, -0.19809063f, -0.03365118f, 0.05360415f, 0.08637845f, -0.00401141f, -0.03512676f, 0.02866359f, 
    0.00589171f, -0.00296744f, 0.04624387f, 0.01632937f, 0.03337727f, -0.08164234f, -0.08767023f, 0.04676424f, 
    0.12371489f, 0.01607886f, -0.04569982f, -0.12160476f, 0.01575695f, -0.02341100f, 0.01135810f, 0.05264905f, 
    0.06388953f, -0.20024559f, 0.22767803f, 0.22818626f, -0.08574795f, 0.18120533f, -0.11659271f, 0.04118440f, 
    0.00038882f, 0.04920616f, -0.00229066f, 0.03474432f, -0.04362107f, 0.05173945f, 0.22716013f, -0.06549016f, 
    -0.08087852f, -0.09590416f, -0.26859313f, -0.14239661f, -0.07405253f, -0.06571747f, 0.14833619f, -0.12439583f, 
    0.05432096f, -0.01645288f, 0.19056223f, 0.11680921f, -0.10650274f, 0.08523091f, -0.00877018f, -0.07101186f, 
    0.03437536f, 0.17260295f, 0.02532324f, 0.11706284f, 0.14929621f, 0.21686913f, -0.08711405f, -0.04071450f, 
    -0.21915177f, -0.19754176f, 0.01954317f, -0.11644258f, 0.00989152f, 0.12480472f, 0.07202125f, 0.17547272f, 
    -0.65774578f, 0.24579905f, -0.07534783f, -0.18569927f, -0.04604658f, 0.04545404f, -0.05188289f, 0.11761182f, 
    0.03090873f, -0.09669967f, 0.03573992f, 0.06725918f, -0.22795786f, -0.18931332f, 0.01874293f, 0.11986111f, 
    0.13783093f, 0.00575208f, -0.15916316f, -0.03124504f, -0.15659636f, -0.03651502f, 0.03650471f, -0.09233272f, 
    0.02803810f, 0.05262973f, 0.02593380f, -0.30838579f, 0.16841090f, 0.06681377f, -0.18345144f, -0.01939806f, 
    0.07303286f, -0.01320201f, -0.04438750f, 0.04460257f, -0.36913523f, 0.29465085f, -0.20545441f, -0.09915522f, 
    0.08075881f, 0.03926974f, -0.01249032f, -0.19063610f, -0.05854660f, 0.09702261f, -0.20613569f, 0.08350310f, 
    0.30681109f, 0.23536818f, -0.16940737f, -0.26244482f, -0.25859755f, -0.02886831f, 0.01400144f, -0.12422273f, 
    -0.00306487f, 0.02200820f, 0.10759923f, 0.02608830f, -0.34969458f, 0.07566320f, 0.12154780f, 0.04565275f, 
    -0.22899865f, -0.10128247f, 0.04281923f, 0.12083942f, 0.04774917f, 0.03891569f, -0.07234368f, -0.01516073f, 
    0.47373182f, -0.16874067f, 0.05559127f, 0.11545854f, 0.15984070f, -0.01200562f, -0.08300691f, 0.04778262f, 
    0.03154849f, 0.04236346f, 0.02310716f, 0.03894774f, -0.23064987f, -0.06566585f, -0.07742935f, 0.13966270f, 
    -0.05171371f, -0.01237531f, -0.14878908f, -0.22157879f, -0.03558605f, -0.09627825f, 0.08083899f, -0.08463967f, 
    -0.45487157f, 0.00344362f, -0.07030579f, 0.10914832f, -0.04638830f, 0.27333099f, -0.05682017f, -0.25072283f, 
    -0.18409550f, 0.00284245f, -0.01856253f, -0.11635029f, -0.20753707f, -0.00791316f, -0.04536710f, 0.18208615f, 
    -0.01041215f, -0.04903182f, -0.19332585f, -0.04971216f, -0.09673706f, -0.03611381f, 0.00601934f, -0.00816251f, 
    0.15657541f, 0.06608251f, 0.18369572f, 0.25618204f, 0.19321075f, -0.19157854f, 0.03299715f, -0.21299995f, 
    -0.17041238f, 0.16405416f, 0.17768450f, 0.03547013f, -0.09959125f, 0.60382211f, -0.15375166f, -0.24411602f, 
    0.02431502f, 0.02401622f, -0.10007989f, 0.14311278f, -0.19352086f, 0.08615980f, -0.13471188f, 0.04694196f, 
    -0.10245799f, -0.05605699f, -0.10080001f, 0.19190687f, 0.16214721f, -0.09170085f, 0.07140447f, -0.07133047f, 
    0.10486240f, 0.08398206f, -0.02948329f, 0.12606026f, -0.17977898f, -0.18666220f, 0.28042668f, -0.13545530f, 
    -0.17071310f, -0.15104637f, -0.13174266f, -0.04570394f, -0.01134428f, 0.17851715f, -0.16096511f, 0.09507304f, 
    0.45689827f, -0.04833252f, 0.06751517f, 0.12603158f, 0.21160285f, 0.17250428f, -0.09439406f, -0.07428487f, 
    -0.11243271f, -0.00146809f, 0.00442861f, 0.02961830f, 0.01331410f, -0.14322552f, 0.01568792f, 0.18954228f, 
    0.05030311f, 0.06131159f, -0.04323250f, -0.04792256f, -0.00397475f, 0.01302928f, -0.00257532f, -0.06494762f, 
    0.08225994f, 0.07608494f, -0.30906865f, -0.25746718f, 0.08771586f, 0.09285091f, -0.03454818f, -0.13326885f, 
    -0.20892276f, -0.06209574f, -0.07997651f, -0.01784557f, -0.06367657f, 0.09023917f, 0.01697870f, 0.30528051f, 
    -0.07305574f, -0.07904465f, 0.14631662f, 0.08864596f, 0.04546032f, 0.15832917f, -0.14117657f, 0.00831994f, 
    0.03306742f, 0.05238435f, -0.10957745f, 0.08067036f, 0.00145644f, -0.03660981f, -0.15314308f, -0.02057710f, 
    0.06151675f, 0.01445604f, -0.06082461f, -0.00837413f, -0.57582331f, 0.59817177f, -0.53516454f, -0.43887633f, 
    0.24563086f, 0.16572240f, 0.04628905f, -0.14013857f, -0.26146626f, 0.02642187f, -0.05275413f, -0.03564294f, 
    -0.10184097f, -0.04394744f, -0.04651956f, 0.00107590f, 0.07772169f, -0.04146387f, 0.01825024f, 0.07433517f, 
    0.03549416f, 0.05737108f, -0.04482181f, 0.01558024f, 0.03028865f, 0.04807534f, 0.05047938f, 0.13399807f, 
    0.02708028f, -0.05692013f, 0.08124886f, 0.02893107f, -0.03042616f, 0.02739106f, -0.02804935f, -0.04857183f, 
    0.10926982f, 0.00030633f, -0.14733763f, 0.22065856f, -0.10738561f, 0.03853623f, 0.15242690f, -0.04588506f, 
    0.02958103f, -0.01350803f, 0.00966415f, 0.08954852f, -0.19160841f, 0.08211648f, 0.45171550f, -0.03668172f, 
    -0.01554008f, -0.09008541f, 0.11474402f, -0.04270523f, 0.15776411f, 0.09722877f, -0.04337906f, 0.17708680f, 
    -0.02506259f, -0.23901884f, -0.13118823f, 0.19998959f, 0.04523434f, -0.01903157f, -0.03404455f, -0.07170814f, 
    -0.00304955f, 0.06900641f, -0.12331653f, 0.03061009f, -0.36358923f, -0.22073950f, -0.07262896f, -0.03989497f, 
    -0.13119683f, -0.06727807f, -0.04933764f, -0.07910509f, -0.07571028f, -0.17396027f, 0.03823245f, -0.15548727f, 
    -0.10730799f, -0.15677664f, -0.05095265f, 0.16800724f, 0.09242590f, -0.01017387f, -0.00319154f, 0.01529809f, 
    -0.04364436f, 0.08333005f, -0.13532342f, 0.02213461f, -0.05065480f, -0.19686203f, 0.38990146f, -0.09299486f, 
    -0.01447024f, 0.03371013f, -0.16200361f, -0.02400482f, -0.03877626f, -0.10534953f, -0.01063571f, -0.07265572f, 
    -0.08179507f, 0.04589316f, -0.01157479f, 0.36784807f, 0.02954458f, 0.01888698f, 0.19837579f, 0.01185650f, 
    0.04340528f, 0.02040403f, 0.04935874f, 0.09324782f, 0.22704077f, 0.08113586f, -0.13131841f, -0.76394135f, 
    -0.04260297f, -0.03246326f, -0.00098051f, -0.05098885f, -0.10160424f, 0.04365633f, -0.07363248f, -0.13546415f, 
    -0.50233072f, -0.14906518f, -0.41478175f, -0.11814734f, 0.00140412f, -0.21276610f, -0.14408498f, -0.10963736f, 
    -0.13459852f, -0.01054334f, 0.01410040f, -0.11862513f, -0.59115326f, -0.15180627f, -0.15580212f, 0.01071216f, 
    -0.21423370f, -0.17781164f, -0.10350949f, -0.03862708f, 0.10606266f, 0.14884728f, -0.05132343f, 0.03972586f, 
    -0.00322620f, 0.18490908f, -0.02681473f, 0.11323068f, -0.00853743f, 0.00524718f, 0.02767039f, 0.02579706f, 
    0.09485524f, -0.08537015f, 0.02107987f, 0.02129694f, 0.58161098f, 0.26844734f, 0.01688364f, -0.09849450f, 
    -0.09025263f, 0.01812876f, 0.07314938f, -0.10717718f, -0.11205576f, -0.04246395f, 0.17621566f, -0.06593314f, 
    0.02592809f, 0.06817412f, -0.30176207f, 0.09794474f, 0.11234763f, 0.05160140f, 0.02932435f, 0.16470037f, 
    -0.03298675f, 0.08446098f, 0.01799565f, -0.04564639f, 0.07212786f, 0.01635412f, -0.04548720f, 0.12795779f, 
    0.06852835f, -0.09050755f, 0.08843169f, -0.12835020f, 0.09752793f, 0.12363960f, 0.09792814f, 0.08151296f, 
    -0.17612009f, -0.15912502f, 0.27358341f, 0.11938583f, -0.21968032f, 0.04386315f, 0.02577294f, 0.05386452f, 
    0.11964844f, 0.17272636f, 0.08676251f, 0.04201719f, 0.59138244f, -0.17365283f, 0.08245935f, 0.12040202f, 
    0.16788046f, 0.06462438f, 0.11826554f, 0.15594085f, -0.06741823f, 0.02491901f, -0.02486711f, 0.11606527f, 
    -0.20587642f, 0.84644395f, -0.26970699f, -0.10138422f, 0.13413784f, 0.16945261f, 0.01228450f, -0.08675049f, 
    -0.24534905f, -0.08814500f, 0.04871579f, -0.05565197f, 0.02080769f, 0.14085066f, 0.07485908f, 0.31189623f, 
    -0.13616227f, -0.10474744f, -0.08816417f, -0.08638141f, -0.00256155f, 0.08242124f, 0.07276344f, -0.17221832f, 
    -0.32456329f, 0.66351694f, -0.28327516f, 0.23630017f, 0.05624299f, -0.07645652f, -0.06560986f, -0.18412176f, 
    -0.00696145f, -0.12791017f, 0.08571482f, 0.05362732f, 0.04746191f, 0.14739342f, -0.16434075f, 0.13741897f, 
    -0.07961848f, -0.12858750f, -0.13936651f, -0.15686169f, -0.12686206f, -0.03167965f, 0.11495671f, -0.15726380f, 
    -0.09828956f, 0.34926322f, -0.42571595f, 0.27615350f, 0.13088930f, 0.10860620f, 0.01879802f, -0.03892707f, 
    0.02228756f, -0.07898024f, -0.02731150f, 0.05224701f, 0.15411057f, -0.09691384f, -0.19794920f, -0.09645238f, 
    -0.04983997f, -0.07504773f, -0.22064620f, -0.09811235f, -0.00558549f, -0.09541318f, -0.06556765f, -0.08593590f, 
    0.23408967f, 0.01645046f, 0.12651737f, 0.08177365f, -0.09766372f, -0.05516211f, -0.10107647f, 0.04307261f, 
    -0.04120246f, -0.05186671f, 0.20293127f, -0.09820943f, -0.63682044f, -0.22702983f, -0.04202005f, -0.11552919f, 
    0.01303540f, 0.02775159f, -0.31389546f, -0.08984740f, -0.03937254f, -0.15720905f, 0.08546071f, -0.14955120f, 
    -0.50194132f, 0.17689717f, -0.31586188f, -0.46251237f, 0.16790429f, 0.01355619f, -0.06651472f, 0.12644769f, 
    -0.04801633f, -0.12577376f, 0.03718383f, 0.05741743f, -0.02347278f, -0.17069618f, -0.07398999f, 0.19198163f, 
    0.08941152f, -0.06545943f, 0.06062695f, -0.10301143f, 0.01707727f, -0.02075525f, 0.00655766f, 0.07835665f, 
    -0.46096638f, -0.01692793f, 0.00673300f, -0.00376246f, 0.00566835f, 0.01499675f, 0.03780811f, -0.11618262f, 
    -0.10924703f, -0.01275178f, 0.02732814f, -0.00147374f, 0.35115242f, 0.05727420f, 0.05305370f, 0.02790911f, 
    0.04733018f, 0.02159058f, -0.10814229f, -0.02026088f, 0.04893953f, -0.04749746f, -0.06961088f, 0.14377302f, 
    -0.23482580f, 0.38463527f, -0.17026339f, -0.39335537f, 0.27170178f, 0.04363501f, 0.13942505f, -0.09969939f, 
    -0.21558020f, -0.01103954f, 0.08259177f, -0.01804936f, -0.21121177f, 0.00873636f, -0.11405474f, 0.06459611f, 
    -0.12117787f, -0.01478883f, 0.04873140f, 0.05717814f, -0.22204876f, 0.07934602f, -0.08095697f, -0.11647210f, 
    0.01996196f, 0.11970468f, 0.01280502f, -0.11699371f, -0.06476834f, 0.05846791f, -0.02173588f, -0.11533267f, 
    -0.06973968f, 0.13234529f, -0.01776217f, 0.00605421f, -0.19915046f, -0.04541735f, 0.39761257f, 0.26091734f, 
    -0.00047401f, 0.13369872f, -0.16915418f, 0.00605892f, 0.00668039f, -0.20674570f, 0.06409740f, -0.05947270f, 
    0.08008382f, -0.03960144f, 0.14709057f, 0.41945341f, -0.00540493f, -0.10707114f, -0.30767429f, -0.03003920f, 
    -0.10422035f, 0.11140254f, -0.06500293f, 0.07721800f, 0.15692233f, -0.07302780f, -0.05022087f, 0.10262545f, 
    -0.03208707f, -0.04648793f, 0.01312658f, 0.06751432f, -0.05542258f, -0.02897689f, 0.04905826f, -0.01814967f, 
    -0.05430057f, -0.02563365f, -0.19675291f, 0.17713517f, 0.01278262f, 0.07430894f, -0.00178203f, 0.15761276f, 
    -0.04995590f, -0.04558104f, -0.01426250f, -0.00661570f, 0.12207998f, 0.16724743f, 0.18569064f, 0.18358599f, 
    -0.10456312f, -0.09292503f, -0.00665321f, 0.02880393f, 0.00775130f, 0.02869494f, -0.07505148f, 0.02888905f, 
    -0.23420575f, -0.18361592f, -0.02411759f, 0.08100265f, -0.16799197f, -0.00441546f, 0.01180845f, 0.01769769f, 
    -0.03692579f, 0.00870792f, 0.00977130f, -0.05112404f, -0.06455554f, -0.08624351f, 0.06853615f, 0.10236076f, 
    -0.04520289f, 0.01327560f, 0.00400240f, 0.00113079f, 0.02505790f, 0.24178457f, 0.06918856f, 0.13751465f, 
    0.28582165f, 0.41487250f, 0.12121698f, 0.35000724f, 0.10388541f, -0.04624435f, 0.08643892f, 0.11270899f, 
    -0.02662550f, -0.05320664f, -0.01188501f, -0.04192659f, 0.02828547f, -0.01346152f, -0.12116300f, 0.11679668f, 
    -0.14492106f, -0.20828746f, -0.01246680f, 0.02284466f, -0.25098243f, -0.02475679f, -0.05358338f, -0.24983735f, 
    0.13643500f, 0.24382938f, -0.37884989f, 0.18425132f, 0.05732774f, -0.01205445f, -0.00023397f, 0.02644551f, 
    0.04408617f, 0.07627162f, -0.03619312f, 0.18773076f, 0.05320898f, 0.03735116f, -0.01018164f, 0.13502847f, 
    -0.07205705f, 0.08959315f, 0.05346055f, 0.13341261f, -0.02382784f, 0.02081845f, 0.05444913f, 0.03658824f, 
    0.01961345f, -0.17972793f, -0.03543586f, -0.18775380f, 0.01806371f, 0.02074333f, 0.10478355f, 0.05082583f, 
    -0.18598308f, 0.03210889f, -0.11909851f, 0.09071046f, 0.02645867f, 0.24849264f, -0.12609003f, 0.13815804f, 
    -0.12044886f, -0.10387746f, 0.05309130f, -0.05089887f, -0.07056458f, -0.09697858f, -0.03809892f, -0.05801320f, 
    0.15874016f, 0.05086006f, -0.07998700f, 0.01863444f, 0.02082348f, -0.00997379f, 0.01793593f, 0.04877577f, 
    -0.06799234f, -0.15494850f, -0.03270216f, -0.18486379f, 0.02316712f, -0.02932650f, 0.05007900f, -0.15725514f, 
    -0.10954997f, -0.05222454f, -0.05546943f, -0.24811172f, 0.04648080f, -0.06539565f, -0.02063128f, 0.04129188f, 
    -0.03683998f, -0.13824289f, -0.07101502f, 0.04764438f, -0.00353241f, 0.03388305f, -0.02271310f, -0.03428431f, 
    0.08511455f, -0.10196168f, -0.04828083f, 0.09453128f, 0.06373560f, 0.00193511f, -0.03073156f, 0.05266199f, 
    0.16566552f, 0.00290957f, 0.10964384f, -0.03331451f, -0.22480150f, -0.10075027f, 0.08528084f, -0.03854414f, 
    0.16954084f, 0.12110338f, -0.01521566f, 0.09993736f, -0.10044152f, -0.08439802f, -0.01914631f, -0.05428981f, 
    -0.03872469f, -0.16518268f, 0.06484134f, 0.00170216f, 0.04359486f, 0.01123232f, 0.00451051f, -0.01783467f, 
    0.04992144f, -0.06606154f, 0.02760453f, 0.01193191f, 0.00162366f, -0.02147409f, -0.10931686f, -0.05273244f, 
    -0.18520945f, -0.09615394f, -0.01647963f, 0.00957592f, -0.01433511f, -0.06862400f, -0.12339358f, 0.09422100f, 
    -0.01299197f, 0.06166786f, -0.10778840f, 0.03982291f, 0.06214796f, -0.00830384f, 0.00906967f, -0.02170699f, 
    -0.07504542f, -0.06420383f, -0.16650480f, -0.20105202f, -0.08789927f, -0.13881499f, 0.02055510f, -0.24367656f, 
    -0.02465188f, 0.13471788f, -0.04704455f, 0.01472106f, 0.12633878f, 0.00872533f, -0.11651752f, -0.11910483f, 
    0.13935655f, 0.02436782f, -0.04713371f, -0.03775215f, 0.08415745f, -0.30942297f, 0.16289331f, 0.10741716f, 
    -0.00958446f, 0.03588890f, 0.02010593f, -0.14511319f, 0.03390591f, -0.01114562f, -0.03784357f, 0.15521272f, 
    0.08618747f, -0.00925948f, 0.20505649f, 0.07521055f, -0.06633855f, -0.04483996f, -0.18168928f, 0.07350017f, 
    -0.02503859f, 0.03007120f, 0.00749571f, 0.06462988f, -0.00534295f, 0.06739653f, -0.18118981f, 0.03754617f, 
    -0.06447700f, -0.02817483f, 0.07185169f, 0.07633150f, 0.08857071f, -0.04407675f, 0.06251911f, -0.04979822f, 
    0.22728196f, -0.08257367f, -0.03285984f, 0.00096939f, -0.10610341f, -0.05880097f, 0.04624494f, -0.00067943f, 
    0.14783566f, -0.11326646f, 0.00649594f, -0.14848627f, 0.07705602f, 0.16807085f, 0.08906271f, 0.21147951f, 
    -0.01329010f, -0.05240090f, -0.14159244f, 0.00880080f, 0.04023682f, -0.00663543f, -0.03303413f, -0.01882040f, 
    -0.06684588f, -0.14872110f, -0.07892419f, 0.17078736f, -0.07832672f, -0.07492875f, -0.11085178f, -0.17971079f, 
    -0.15502973f, 0.04544533f, -0.02344989f, -0.07630020f, 0.08229356f, 0.09790921f, 0.08272148f, 0.05394020f, 
    0.06387708f, 0.08789089f, -0.10105277f, 0.20454475f, -0.05711682f, 0.01264029f, -0.01356377f, -0.02579447f, 
    -0.09708760f, 0.08006199f, 0.05936299f, 0.06563929f, 0.02740040f, -0.02950918f, -0.00560464f, -0.23284985f, 
    -0.14690258f, -0.13087480f, 0.06900725f, 0.03896993f, -0.03767028f, -0.40224788f, -0.22616252f, -0.00682170f, 
    0.02206906f, 0.07288540f, 0.06336167f, -0.01219177f, 0.00342020f, 0.05233286f, 0.04264918f, -0.04349467f, 
    -0.06609765f, -0.06010451f, 0.02537461f, 0.11049014f, -0.07296800f, -0.01552181f, -0.08277424f, -0.11108433f, 
    -0.03192398f, -0.00692556f, 0.04398753f, 0.02639144f, 0.07322800f, 0.03940820f, -0.00718821f, -0.05294193f, 
    -0.05493793f, -0.13536006f, -0.21373112f, -0.05539893f, 0.08235488f, -0.03275504f, -0.14541316f, -0.00502003f, 
    -0.04711914f, -0.04908884f, 0.14480323f, 0.00090186f, -0.10544346f, -0.11745808f, -0.21906419f, -0.08647258f, 
    0.05224209f, 0.04216956f, -0.01170776f, -0.01588209f, 0.12589669f, 0.06795326f, -0.04496905f, 0.16957849f, 
    0.11228509f, 0.22607526f, -0.07029435f, -0.06226758f, 0.09951505f, 0.05307276f, 0.04377072f, -0.13626598f, 
    0.10086145f, 0.20028619f, 0.06198416f, 0.06243670f, -0.07299891f, -0.09103989f, -0.02915208f, 0.06230957f, 
    0.08934070f, 0.07059881f, -0.01674255f, -0.02270320f, -0.19687697f, 0.05767636f, -0.06806248f, -0.03174455f, 
    0.02965702f, 0.10019793f, -0.03454841f, 0.05161697f, 0.04208973f, -0.04114538f, 0.01287124f, -0.09551564f, 
    0.00713933f, 0.01873820f, 0.08547890f, 0.11305507f, -0.05838143f, -0.02578813f, 0.09415708f, 0.08100372f, 
    0.00806420f, -0.00897222f, -0.02977136f, 0.04426930f, 0.01109345f, 0.14458828f, -0.12969795f, 0.01203261f, 
    -0.01513523f, 0.24269624f, 0.05042981f, -0.12597804f, 0.06449368f, 0.00556627f, -0.04987662f, -0.09096026f, 
    -0.06974515f, 0.16987555f, 0.12658729f, 0.28761068f, -0.00274920f, 0.02723294f, 0.01593508f, 0.14091784f, 
    0.02274633f, -0.01190595f, -0.00402674f, -0.03772347f, -0.14374287f, -0.21321617f, 0.00072360f, -0.19504251f, 
    0.04975846f, 0.03527042f, -0.05843146f, 0.02057925f, -0.08274270f, -0.03229008f, -0.12154932f, 0.03136295f, 
    0.00660445f, -0.01155195f, 0.04176654f, 0.00519370f, 0.17816971f, 0.11951292f, 0.01636647f, 0.03660233f, 
    0.06449924f, 0.01892043f, 0.04377483f, 0.05027473f, 0.10953941f, 0.09739498f, -0.11981048f, -0.03141444f, 
    0.04156424f, -0.00439320f, 0.00773822f, -0.02572900f, 0.07676847f, 0.04457938f, 0.00379821f, 0.02377979f, 
    -0.05580451f, -0.05239153f, -0.01894352f, 0.15377010f, 0.04629422f, -0.09719943f, 0.06063921f, -0.03376224f, 
    0.14598246f, 0.08683750f, 0.11709950f, 0.41658208f, 0.03013909f, -0.13636963f, -0.16140097f, 0.06774724f, 
    -0.07653783f, -0.05762092f, 0.01424763f, -0.09784748f, 0.07770319f, 0.05008058f, -0.13223025f, 0.23271671f, 
    0.27634975f, -0.04282487f, 0.33702135f, 0.04053908f, -0.02717938f, -0.10633873f, -0.15494871f, -0.00593948f, 
    0.20074962f, -0.08889473f, 0.05332262f, 0.03406345f, 0.18006851f, 0.05907156f, 0.17873403f, 0.14019862f, 
    -0.01259267f, -0.05220774f, -0.05485287f, -0.11686156f, -0.13179761f, -0.32772848f, 0.00785872f, -0.07676559f, 
    0.14793172f, 0.16265038f, 0.03587335f, 0.18353331f, -0.00460799f, -0.08035289f, -0.00118513f, -0.10173485f, 
    0.04493251f, 0.00038357f, 0.06280164f, 0.21489820f, -0.00248998f, 0.29632998f, 0.12670845f, 0.10416516f, 
    -0.15915929f, -0.13972934f, -0.05389352f, 0.09653791f, 0.02495744f, -0.10582156f, -0.01307536f, -0.03737036f, 
    -0.23560652f, -0.60295272f, -0.02599441f, -0.19357908f, 0.03461691f, 0.02140637f, -0.01296172f, 0.01074599f, 
    0.14530705f, -0.07450108f, -0.05805151f, 0.17163640f, 0.08249778f, 0.08133433f, -0.30235645f, 0.05789418f, 
    0.14636619f, 0.13543759f, -0.23945417f, -0.18729427f, 0.08774965f, -0.06909359f, 0.04955174f, -0.07983391f, 
    0.03989270f, -0.46832314f, 0.32183319f, -0.05049153f, 0.06202299f, 0.16264673f, -0.11734727f, 0.05553230f, 
    -0.14097317f, 0.00652454f, -0.03352041f, -0.06114852f, -0.06016517f, -0.02225235f, 0.13308123f, -0.04006790f, 
    -0.19451991f, 0.10600544f, -0.15229420f, 0.16252798f, -0.13488536f, 0.02034475f, -0.11927786f, -0.08546200f, 
    -0.04043295f, -0.17726545f, 0.24033187f, 0.10999341f, -0.02065148f, -0.06523715f, -0.26157191f, 0.02194517f, 
    -0.20796822f, 0.02486107f, -0.04507135f, 0.03137723f, -0.15905218f, -0.00056938f, -0.02606359f, -0.02537463f, 
    -0.05659722f, 0.00538675f, -0.07431708f, 0.05829439f, -0.03791565f, 0.01008250f, 0.05145765f, -0.15893096f, 
    -0.05276422f, 0.14196405f, -0.24740495f, -0.26786140f, 0.04861506f, 0.04576194f, -0.02864603f, -0.03359489f, 
    -0.13258100f, -0.13524042f, -0.25806239f, -0.08401328f, -0.02366444f, -0.05719544f, 0.11048386f, 0.04786910f, 
    -0.00840927f, -0.00063115f, 0.05762075f, -0.12412793f, -0.02830486f, -0.25814447f, -0.15366209f, 0.01036452f, 
    0.12598512f, -0.12303665f, 0.01763379f, 0.05830621f, -0.23116782f, -0.16069916f, -0.02362914f, -0.28465426f, 
    0.01661690f, -0.01482400f, -0.10626895f, -0.04673959f, -0.05859637f, 0.13600297f, 0.08091448f, 0.06339974f, 
    -0.18126757f, -0.10582528f, -0.07824978f, -0.00501342f, -0.03494011f, -0.02182662f, -0.02229876f, 0.09667180f, 
    -0.03612564f, -0.15480889f, -0.14203879f, 0.00847256f, 0.07899483f, -0.09026384f, 0.08478058f, -0.09038483f, 
    -0.02454939f, -0.02050020f, -0.19179860f, -0.12368062f, -0.08899014f, 0.06864248f, -0.13344546f, 0.00435951f, 
    -0.05517739f, 0.02207880f, 0.06462453f, 0.03081500f, -0.02721652f, 0.05121056f, -0.01552707f, -0.01203835f, 
    0.04450267f, 0.06476007f, -0.15492204f, -0.14630704f, 0.06372219f, 0.10108202f, 0.01757561f, 0.03729755f, 
    0.03740339f, -0.01389358f, -0.07179884f, -0.18259971f, 0.13913371f, 0.01019987f, 0.36267287f, 0.11516122f, 
    0.04377435f, 0.02159224f, -0.13993822f, -0.01222925f, -0.04552740f, -0.19590643f, -0.07933320f, 0.05780170f, 
    -0.01317006f, 0.04797266f, 0.01709291f, -0.07892580f, 0.10547871f, 0.09034564f, -0.03653998f, 0.06639067f, 
    0.01385867f, -0.04601170f, -0.08281156f, -0.14325458f, 0.03123317f, 0.11446664f, -0.09527580f, 0.09060850f, 
    0.16869777f, 0.12309639f, -0.00677597f, 0.05455488f, -0.00828656f, -0.07657208f, 0.02286837f, -0.06533641f, 
    -0.06060364f, 0.12012288f, 0.00355463f, 0.13231806f, 0.03878490f, 0.06868780f, -0.01718738f, -0.25178421f, 
    0.02178771f, -0.36818999f, 0.14531769f, -0.12376896f, 0.08698963f, 0.05257691f, 0.08849545f, 0.17289037f, 
    -0.07480663f, 0.03368758f, -0.00849520f, -0.07064105f, -0.07159378f, 0.02687364f, 0.03595361f, 0.14758287f, 
    -0.01766357f, -0.02156768f, 0.15115602f, 0.04048965f, -0.03238354f, 0.15642305f, -0.10318524f, 0.00608128f, 
    -0.02647644f, -0.01800054f, -0.03261616f, 0.06391811f, 0.09506743f, 0.06625172f, 0.05586818f, 0.10995856f, 
    -0.05850460f, 0.09013107f, 0.07180649f, 0.08945882f, 0.10444646f, -0.02146976f, 0.01018631f, -0.08447463f, 
    -0.30003896f, -0.00766087f, 0.04998967f, -0.17617936f, 0.09346700f, -0.14943071f, -0.00577505f, -0.07665477f, 
    -0.07962794f, -0.06463324f, 0.00831705f, 0.25476286f, -0.02960973f, -0.16399641f, 0.03627515f, -0.08273125f, 
    -0.03903857f, 0.00920468f, 0.03007133f, 0.17932624f, -0.05541126f, -0.21404685f, -0.08378034f, -0.28325632f, 
    -0.02849585f, 0.16097231f, -0.17603211f, 0.04413014f, 0.18805324f, -0.00664106f, 0.08780649f, 0.04252244f, 
    0.03926416f, -0.00872631f, 0.03154058f, -0.00152553f, 0.21162261f, -0.02362201f, -0.08569588f, -0.20917867f, 
    0.34293807f, -0.10495500f, 0.06399497f, 0.00047930f, 0.05300079f, -0.04252144f, -0.02827784f, 0.36895528f, 
    -0.14170566f, -0.00261223f, 0.09539033f, -0.16099474f, 0.07857989f, 0.02517384f, -0.00992950f, -0.02479059f, 
    0.15485789f, -0.10219172f, -0.21628854f, -0.21368465f, -0.14876668f, -0.16620243f, 0.05649973f, 0.06785586f, 
    0.10398758f, -0.02116197f, -0.15970357f, -0.07166547f, -0.01043458f, -0.18750115f, 0.26994094f, -0.15283193f, 
    0.00463596f, -0.09398009f, 0.17666529f, 0.24555056f, 0.01130729f, -0.05129235f, -0.14357759f, -0.01654834f, 
    0.21052231f, 0.06310873f, 0.08199776f, 0.01516056f, -0.29226917f, -0.40934837f, -0.05259218f, -0.28627264f, 
    0.01648734f, 0.03520788f, -0.07709521f, 0.21502003f, 0.09145205f, -0.18323806f, -0.14031617f, 0.00576520f, 
    -0.10973541f, -0.16753148f, 0.06184188f, 0.01639027f, -0.13812792f, -0.07083549f, -0.02985362f, -0.07183904f, 
    0.13537432f, 0.06336883f, -0.07134295f, 0.22714323f, -0.12430654f, -0.00969366f, 0.21368466f, -0.05800861f, 
    0.12132946f, 0.09125673f, -0.10576688f, 0.28768042f, -0.18724675f, 0.02615685f, 0.12850301f, -0.09773736f, 
    -0.19751211f, -0.23153104f, 0.10132938f, 0.04501634f, -0.00677708f, -0.04850319f, -0.01454264f, 0.01164024f, 
    -0.17164756f, 0.09680676f, -0.12386224f, -0.14267449f, -0.03444973f, 0.10211768f, -0.30166015f, -0.08952890f, 
    0.11285218f, -0.07008246f, -0.07202594f, -0.01331526f, 0.31994006f, -0.19169116f, 0.04739003f, 0.04728619f, 
    -0.18585628f, -0.22298482f, -0.20901601f, -0.00787723f, -0.10098553f, 0.00972856f, 0.13221791f, 0.16204315f, 
    0.13339604f, -0.05064183f, 0.05968959f, 0.15452032f, -0.00524916f, -0.08533353f, -0.06568168f, 0.02728000f, 
    -0.16352509f, 0.10536838f, -0.04779164f, -0.00090472f, 0.10912905f, 0.15543878f, 0.07164859f, -0.11380110f, 
    0.07283723f, 0.00502227f, -0.28947553f, 0.42983899f, 0.05250812f, -0.04663806f, 0.01405564f, 0.06884354f, 
    0.08407487f, 0.05614342f, 0.03854682f, 0.27986568f, 0.22054020f, 0.19565453f, -0.22396272f, 0.14702316f, 
    0.00984945f, -0.02036058f, -0.02169800f, 0.12214593f, 0.13304745f, -0.12822916f, 0.09187408f, 0.02334240f, 
    0.04472876f, 0.04177193f, -0.22563484f, 0.05207951f, -0.08907453f, 0.02338775f, 0.12047813f, 0.24788919f, 
    0.03532134f, 0.00130326f, -0.03255332f, -0.09585620f, 0.04336236f, -0.46690995f, 0.24950336f, 0.19890438f, 
    -0.20813888f, -0.00066477f, -0.05377517f, -0.02580733f, 0.15529089f, 0.04279699f, 0.13604756f, -0.15435201f, 
    -0.14435795f, 0.15545988f, 0.10299730f, -0.41929731f, 0.18198664f, -0.13299005f, -0.04747396f, -0.10154486f, 
    -0.03953481f, 0.02323249f, -0.00347724f, -0.02275959f, 0.33033180f, -0.08820704f, -0.32199302f, 0.00680403f, 
    0.05438439f, 0.03674375f, -0.04753226f, -0.01984261f, 0.06857228f, -0.00705986f, 0.03274258f, -0.03908586f, 
    -0.53881228f, -0.09918313f, -0.15039971f, -0.18354288f, 0.07816790f, -0.06583531f, 0.05607375f, 0.01530298f, 
    0.27381596f, -0.05436657f, -0.00156601f, 0.08534172f, 0.01207718f, 0.29399288f, 0.02330186f, -0.06826659f, 
    -0.07569549f, 0.14610863f, 0.06716885f, 0.03088163f, -0.12278581f, -0.05068401f, -0.01591073f, -0.02088536f, 
    -0.35586074f, 0.28241652f, 0.13105547f, -0.05898054f, -0.08550593f, -0.16890170f, 0.11931495f, 0.12753417f, 
    0.10778350f, -0.09683727f, 0.00605990f, 0.01424200f, 0.03723109f, -0.11435343f, 0.06287811f, 0.05755871f, 
    -0.00644895f, -0.11180510f, -0.20853953f, -0.15690263f, -0.18175140f, -0.07837468f, 0.10425467f, -0.12585711f, 
    0.20858151f, 0.02821619f, 0.32646441f, -0.08273386f, 0.15820760f, -0.01882825f, 0.08733459f, 0.11536596f, 
    0.13054700f, -0.00303432f, -0.05612877f, 0.09612584f, -0.15038355f, 0.06164368f, 0.18329322f, -0.11223162f, 
    0.01745355f, -0.06331056f, -0.02237448f, 0.06743676f, 0.03819864f, -0.19771169f, -0.13370423f, 0.00082106f, 
    0.09196348f, 0.00888367f, 0.03363679f, 0.01464809f, -0.13324028f, -0.03139751f, 0.00905510f, -0.00847059f, 
    -0.00469317f, -0.04818215f, -0.02320399f, -0.11106418f, 0.03258340f, 0.19596972f, 0.19898090f, -0.26436776f, 
    -0.04029765f, 0.27652058f, -0.14953013f, -0.08461187f, 0.09550026f, -0.02729245f, 0.07872952f, -0.03390597f, 
    0.12789877f, 0.01861318f, 0.07124019f, -0.14949910f, 0.23251352f, 0.08182272f, 0.05238990f, 0.14716232f, 
    -0.01004595f, 0.04197111f, -0.01484845f, -0.09657431f, -0.02350334f, -0.02951081f, -0.19265409f, 0.16844153f, 
    -0.09317995f, 0.13309929f, 0.04987757f, -0.02144404f, -0.07281914f, -0.02760469f, -0.01063967f, -0.11764826f, 
    -0.12216724f, 0.00500955f, 0.02156118f, -0.23402131f, 0.23672299f, 0.23852041f, 0.20029078f, 0.11253000f, 
    0.00451732f, -0.07852254f, 0.06133766f, 0.07556827f, 0.01798234f, -0.11327218f, -0.23733184f, 0.12506081f, 
    -0.04396175f, 0.08710156f, -0.00042959f, -0.05972356f, 0.01199852f, -0.05956645f, -0.02622596f, 0.06179726f, 
    0.03157976f, 0.15782017f, 0.21608254f, -0.05154645f, 0.11576358f, 0.12866500f, 0.05256702f, -0.06938398f, 
    0.04118170f, 0.03537604f, 0.04316774f, 0.03184713f, -0.29129303f, 0.12693240f, -0.36608040f, 0.16346760f, 
    0.13840492f, -0.09012435f, -0.03874086f, 0.11827588f, 0.02538944f, 0.06279229f, -0.00546843f, 0.07607201f, 
    0.10444420f, -0.20667003f, -0.19446890f, -0.22503446f, 0.29829991f, 0.04108227f, -0.04221935f, 0.18091823f, 
    -0.03785772f, -0.02982761f, -0.06006731f, -0.09255233f, -0.26569083f, -0.24543892f, 0.24604411f, 0.37051079f, 
    -0.08197708f, 0.03324416f, -0.01285998f, 0.07462974f, 0.01152411f, -0.07051966f, 0.23145115f, 0.08989468f, 
    -0.10974585f, -0.07686607f, -0.07851787f, -0.09527668f, -0.08423604f, -0.00926143f, 0.07328715f, 0.03445664f, 
    0.15580988f, 0.00144918f, -0.10550911f, 0.12107111f, -0.00602593f, -0.19229278f, -0.20904531f, 0.19035698f, 
    0.07918483f, 0.03850105f, -0.06399599f, 0.09319776f, -0.02753716f, -0.04145484f, -0.05810264f, 0.00183160f, 
    -0.14202002f, -0.02638536f, 0.10375345f, -0.08221985f, 0.04443540f, 0.01294686f, -0.04494959f, -0.05809639f, 
    -0.11087935f, -0.17698181f, -0.23156334f, -0.22085677f, -0.25761437f, -0.00533292f, 0.06096473f, -0.09482211f, 
    -0.08030164f, -0.05522433f, 0.04847128f, 0.02947984f, -0.16243425f, -0.37476471f, 0.07749273f, -0.19011684f, 
    0.28055817f, 0.06559566f, -0.02798668f, -0.09344270f, 0.11624040f, 0.00404848f, 0.09789263f, -0.08616939f, 
    -0.02752581f, -0.10988937f, -0.07380624f, -0.03793646f, -0.06582968f, 0.07435244f, 0.03403485f, -0.03140884f, 
    -0.15853211f, 0.12814081f, 0.02450143f, -0.15527113f, 0.13326046f, -0.08010399f, 0.16145532f, -0.02246952f, 
    0.07070044f, -0.07274626f, -0.14731166f, 0.03209522f, -0.00367460f, 0.15148680f, 0.04290878f, -0.01103510f, 
    -0.04281720f, -0.11819969f, 0.09957594f, -0.59926403f, -0.75015628f, -0.41388646f, -0.27986783f, -0.08895637f, 
    0.06126649f, -0.06470810f, -0.08070532f, -0.14011581f, 0.03431085f, -0.00823416f, 0.14211968f, -0.01676814f, 
    -0.36116177f, 0.20905367f, -0.26381803f, -0.23549235f, -0.00975606f, -0.06150333f, -0.02492110f, 0.08762877f, 
    -0.13460806f, 0.05900934f, -0.06268872f, -0.08309227f, -0.30682990f, 0.01016422f, -0.26367489f, 0.12892617f, 
    -0.01617151f, -0.02222328f, 0.26765367f, -0.04769029f, -0.12147266f, 0.06497940f, -0.09288342f, 0.02685371f, 
    0.09979898f, 0.07104601f, 0.20000757f, -0.08171313f, -0.11155125f, -0.06478556f, -0.00872713f, 0.12079763f, 
    -0.08308610f, 0.10996495f, -0.09517563f, 0.04659452f, 0.17334165f, -0.18756282f, 0.14794296f, -0.16579933f, 
    -0.22765918f, 0.01279017f, 0.09443764f, -0.09058973f, 0.06207069f, 0.05047573f, -0.00143705f, 0.19579166f, 
    0.23468339f, 0.18628326f, 0.07213414f, -0.28998470f, -0.09589864f, 0.00267455f, 0.18162262f, -0.06080624f, 
    0.04048517f, -0.00052726f, -0.08523288f, 0.01243036f, 0.06488203f, 0.01950353f, 0.14437038f, 0.05102016f, 
    0.12214726f, 0.06306443f, -0.14784972f, 0.03215584f, 0.04640294f, -0.09985035f, 0.04347334f, 0.20683126f, 
    -0.23589745f, -0.20111001f, -0.58208519f, 0.23738688f, 0.11525371f, -0.00708283f, 0.02977549f, -0.11624584f, 
    0.07056922f, -0.10043273f, 0.01997405f, 0.13751647f, 0.22567482f, -0.24278808f, -0.14542505f, -0.09171606f, 
    0.04293724f, 0.10734803f, -0.21342973f, 0.09862561f, 0.10914683f, -0.03309380f, 0.12539099f, 0.00985837f, 
    -0.08094261f, -0.34218043f, -0.01841914f, 0.21477540f, -0.03969776f, -0.06961506f, -0.11494454f, 0.14102602f, 
    0.07205581f, 0.10468934f, -0.01724952f, -0.06292803f, -0.08368991f, -0.06824731f, -0.03526549f, -0.22123769f, 
    0.14253367f, 0.04813045f, -0.01524589f, 0.00744517f, 0.03401032f, 0.02115398f, -0.08913872f, -0.08823051f, 
    -0.08507052f, 0.14495185f, 0.12215066f, -0.13303785f, 0.08392753f, 0.09111118f, -0.01480351f, 0.02402599f, 
    0.01975287f, 0.04824748f, 0.03926315f, -0.02538677f, -0.10699308f, -0.29128987f, 0.09137664f, 0.02451475f, 
    0.13284701f, -0.04925669f, -0.08947901f, -0.29422042f, 0.03362462f, 0.07949888f, -0.00198402f, -0.00313362f, 
    -0.16851810f, -0.10904960f, -0.16822098f, 0.02044184f, -0.02944869f, -0.04984333f, 0.01900774f, 0.04083046f, 
    0.09475035f, -0.10744780f, -0.01976612f, 0.14282665f, 0.02233065f, -0.08926740f, 0.20108166f, -0.10720814f, 
    -0.09864371f, 0.06495502f, 0.04657544f, 0.06238495f, 0.11707803f, -0.15968058f, 0.01472189f, 0.01407823f, 
    0.09735298f, -0.19256802f, -0.06044806f, 0.01469376f, -0.12165124f, -0.15161404f, 0.03723387f, -0.08066311f, 
    -0.10070378f, 0.06253971f, 0.19513083f, 0.16723263f, -0.04120157f, 0.07485498f, -0.11746849f, -0.28305057f, 
    0.08703759f, 0.04719348f, 0.15749766f, -0.03918405f, 0.06235287f, 0.00548910f, -0.01262562f, 0.00374572f, 
    -0.02299050f, 0.11004066f, -0.22939631f, -0.19439593f, -0.03529005f, -0.06771284f, 0.04113907f, 0.07381610f, 
    0.26149654f, 0.10006334f, 0.05807802f, -0.03747329f, 0.04345657f, 0.07861068f, 0.15907773f, -0.08237131f, 
    0.04069782f, -0.06598838f, 0.03153787f, -0.05918414f, 0.07586067f, 0.08280394f, -0.12085081f, -0.11334714f, 
    0.01876331f, 0.32723030f, 0.00432385f, -0.16033883f, 0.15556222f, -0.16376849f, -0.14977582f, 0.01730696f, 
    0.07123087f, 0.02908807f, 0.05588280f, 0.10696077f, -0.06048984f, 0.07841115f, -0.22053632f, 0.05778215f, 
    0.17046046f, 0.13813260f, -0.16612417f, -0.01719903f, 0.01795829f, -0.05054031f, 0.07032339f, 0.02002449f, 
    -0.27772781f, -0.27053890f, 0.24728541f, 0.26569578f, 0.00905239f, -0.12433294f, 0.15176544f, 0.12716226f, 
    -0.07197247f, 0.02904931f, 0.17053190f, -0.16894543f, -0.12064098f, 0.07687066f, 0.06996471f, 0.06054493f, 
    -0.10588706f, 0.03565192f, 0.04749352f, 0.05222167f, 0.01149391f, 0.08173085f, 0.03662677f, 0.06170546f, 
    -0.74322146f, -0.75689900f, -0.04030484f, -0.23535238f, 0.10976389f, 0.07530837f, 0.16241427f, -0.13398965f, 
    -0.00696759f, -0.02196797f, 0.02299985f, 0.06972012f, -0.11353190f, -0.07959154f, 0.25948474f, 0.20211901f, 
    -0.09100988f, -0.21818051f, -0.00680421f, 0.03095082f, -0.21005186f, 0.01192448f, -0.03141759f, -0.15420692f, 
    0.03934009f, -0.13480815f, 0.03533620f, -0.09304275f, 0.05009064f, 0.02827686f, 0.05715711f, 0.06811041f, 
    0.04963642f, 0.01120390f, 0.24032286f, -0.02483038f, -0.07216412f, -0.10613770f, -0.08477646f, 0.10776198f, 
    0.02309651f, 0.06903852f, 0.11969729f, 0.04233277f, 0.01359816f, -0.18023883f, 0.05169399f, -0.06904819f, 
    -0.20888938f, 0.01736869f, 0.21692047f, 0.14660496f, 0.04164404f, 0.11442398f, -0.06556094f, -0.06751268f, 
    0.08256328f, 0.05895552f, 0.10558026f, -0.04553393f, -0.16821682f, -0.00005503f, 0.30044588f, 0.14854082f, 
    -0.00106684f, -0.13112058f, 0.05811551f, 0.01443364f, -0.02023860f, 0.08934598f, 0.04524947f, 0.07333102f, 
    -0.08307899f, -0.13709365f, 0.01548736f, 0.04921229f, 0.02535238f, -0.08210886f, -0.08926155f, 0.16475372f, 
    0.05436515f, 0.00599887f, 0.05364368f, 0.05467672f, -0.01976814f, 0.05523265f, 0.10390681f, 0.14771098f, 
    0.14219740f, 0.02776097f, 0.06077829f, 0.02492473f, 0.02159344f, -0.02040369f, 0.10996050f, 0.03062956f, 
    0.03817158f, -0.01624860f, -0.08380590f, -0.02921859f, -0.02238802f, 0.04852339f, -0.02349339f, 0.05081013f, 
    -0.08724247f, -0.07323537f, -0.00644184f, 0.08129175f, -0.04632433f, -0.15062192f, 0.08657315f, -0.00886554f, 
    0.09055725f, 0.02653798f, 0.06989390f, -0.14058378f, -0.11368826f, -0.00697230f, 0.08218741f, -0.00117733f, 
    -0.22332704f, 0.02896071f, 0.37238890f, 0.49560428f, -0.05013210f, -0.18589035f, 0.01898422f, 0.01838286f, 
    0.06042068f, -0.01829542f, 0.09337824f, 0.07928725f, -0.03432417f, 0.02238519f, -0.01179872f, 0.03376486f, 
    -0.02767228f, -0.01597219f, -0.04907520f, -0.03916086f, -0.01492209f, -0.04225301f, -0.02037904f, 0.05937678f, 
    0.23524520f, 0.28440976f, -0.18092276f, 0.20210713f, 0.14926133f, 0.00942951f, 0.19220933f, 0.04571825f, 
    0.01071166f, -0.00752020f, -0.05350983f, 0.15608592f, 0.42046052f, -0.01155008f, -0.29000044f, -0.31742525f, 
    0.07303250f, -0.03829082f, 0.13619012f, 0.08420122f, 0.09357608f, 0.17123121f, -0.21543916f, -0.08783849f, 
    0.12417946f, -0.22364274f, 0.01008285f, -0.08481790f, -0.10304230f, -0.05827664f, 0.11564941f, -0.33668339f, 
    0.06365306f, -0.10152724f, -0.11111985f, -0.09541734f, -0.12814800f, -0.10050527f, -0.15119088f, 0.09300598f, 
    -0.06382255f, 0.28762013f, -0.01872698f, -0.04128451f, 0.11694474f, 0.03668983f, 0.01674133f, -0.00835096f, 
    -0.11454725f, -0.01912187f, -0.10339537f, -0.16318694f, -0.04988310f, 0.01375792f, -0.00294466f, -0.07613713f, 
    0.06901587f, 0.05654074f, 0.02058354f, 0.01633760f, -0.08634421f, -0.11824474f, -0.28131467f, -0.43224806f, 
    -0.04920871f, 0.01773151f, 0.13581507f, -0.02156752f, -0.03781973f, 0.01162857f, -0.01779034f, -0.02422923f, 
    -0.31575659f, 0.11405391f, 0.41389853f, -0.04972036f, -0.06345962f, -0.08242185f, 0.02174214f, -0.15785433f, 
    0.01956786f, 0.06699321f, -0.10197981f, 0.06253420f, 0.16116011f, -0.12365913f, -0.13069782f, -0.23913103f, 
    -0.08604795f, -0.05501245f, -0.08035521f, -0.03572486f, 0.00113854f, 0.01734598f, -0.00513876f, 0.00949720f, 
    -0.17627345f, -0.03824009f, 0.13571872f, -0.03484565f, 0.02902985f, -0.06753808f, 0.01054219f, 0.10477055f, 
    -0.00740956f, 0.14632998f, 0.17329232f, -0.02784682f, -0.23883641f, -0.21409112f, -0.19484471f, 0.04264984f, 
    0.06286426f, 0.09448614f, 0.21934824f, -0.27695143f, 0.04401371f, -0.03334720f, -0.00038028f, 0.10442774f, 
    -0.03244457f, -0.57711267f, -0.68309182f, -0.42665559f, 0.00634256f, -0.32432884f, 0.02799845f, 0.10666021f, 
    0.00933913f, 0.19845973f, -0.10085587f, -0.02739575f, 0.07984767f, -0.08385194f, -0.08948237f, 0.10355528f, 
    0.03564939f, -0.01855511f, -0.04475059f, 0.09835882f, 0.07864134f, -0.04035888f, 0.10005648f, 0.08576207f, 
    -0.45506990f, -0.19177666f, -0.38278514f, -0.00343248f, -0.31094879f, 0.11512333f, -0.01555321f, -0.04082551f, 
    -0.01718604f, 0.07204146f, 0.10010826f, -0.15618041f, -0.43687615f, 0.06455833f, -0.01808125f, -0.12335079f, 
    0.04190796f, -0.02525396f, -0.17359607f, -0.17247783f, -0.01655816f, 0.03487589f, -0.04838283f, 0.02828705f, 
    -0.07059953f, -0.11407743f, -0.51633030f, -0.11683491f, -0.12197606f, 0.10863735f, -0.08587848f, 0.05083805f, 
    0.03546134f, -0.00167118f, -0.01023159f, -0.00540348f, 0.07217414f, -0.16033065f, -0.02960655f, -0.16956544f, 
    -0.04395232f, 0.05872295f, 0.11936683f, 0.00325740f, -0.03063060f, -0.07045978f, -0.12120085f, 0.02740816f, 
    -0.56253046f, -0.26603061f, -0.17893247f, -0.32144719f, -0.12258670f, -0.37737909f, -0.18161088f, -0.20850967f, 
    -0.00115489f, 0.03509599f, -0.04551497f, -0.07055538f, -0.08596164f, 0.08942837f, 0.01284607f, -0.05530538f, 
    0.02571529f, 0.03976076f, 0.00853730f, 0.01479737f, 0.00636616f, -0.00361091f, -0.00726792f, 0.15487927f, 
    -0.39056191f, -0.69243467f, -0.47511354f, -0.10228892f, -0.19311917f, -0.07428006f, 0.02549714f, -0.34369954f, 
    -0.01430408f, 0.00022043f, 0.00919705f, -0.06029383f, 0.22384974f, -0.05304995f, -0.01041655f, -0.28797042f, 
    0.02448054f, 0.03108096f, 0.19890374f, -0.23658584f, -0.02223898f, -0.00197768f, -0.01440515f, -0.03695085f, 
    -0.14563876f, -0.48045549f, -0.27127379f, -0.01271705f, -0.00506946f, 0.16323785f, 0.06719255f, -0.08314045f, 
    -0.01057475f, 0.03692926f, -0.06515718f, 0.00756212f, 0.12925884f, -0.05521349f, 0.01800480f, 0.01651954f, 
    -0.02041574f, -0.01124517f, -0.00322303f, -0.01492193f, -0.07347432f, 0.08355477f, 0.07683512f, -0.00292980f, 
    0.00698745f, -0.06267010f, -0.01970085f, 0.02837384f, 0.04491067f, -0.04808238f, -0.00463506f, 0.04154176f, 
    -0.05823243f, -0.14315720f, -0.12930721f, -0.20235229f, 0.23965399f, -0.01017001f, -0.12106394f, -0.05339245f, 
    0.02710713f, -0.00018533f, 0.13882594f, -0.02936195f, -0.06530984f, -0.00757648f, 0.05317474f, 0.02251755f, 
    -0.20504792f, -0.11125892f, 0.03663861f, 0.02162707f, 0.00208329f, 0.14054674f, -0.02717836f, 0.02836378f, 
    0.11403473f, 0.02007770f, 0.26614428f, 0.12170190f, -0.04463610f, -0.01066138f, -0.06240806f, -0.01918410f, 
    -0.02295413f, 0.08970355f, -0.01486450f, 0.11456359f, 0.11042412f, 0.08082718f, 0.20740484f, -0.02791745f, 
    -0.69389540f, 0.64443403f, 0.32478726f, -0.17181604f, -0.04355319f, -0.00401647f, -0.14089501f, -0.11918529f, 
    -0.11874582f, -0.01185784f, 0.07348462f, -0.01685393f, -0.21644861f, -0.00526202f, 0.33619061f, -0.16093542f, 
    -0.10839634f, -0.13920864f, -0.18729271f, 0.07747298f, 0.02669357f, 0.10586490f, -0.14487161f, -0.11236193f, 
    0.22648707f, -0.00644410f, -0.14318366f, -0.06290942f, -0.10453771f, 0.10490386f, 0.14936027f, 0.04433766f, 
    0.06067447f, 0.08446914f, 0.02975950f, -0.00497703f, -0.48342752f, -0.12229798f, 0.34031460f, 0.53136766f, 
    -0.01531888f, -0.07478996f, -0.08460171f, -0.06866015f, -0.01180616f, 0.16016525f, -0.07061066f, 0.02640624f, 
    -0.10867095f, 0.14581442f, 0.04578699f, -0.02515506f, 0.03637777f, 0.04035741f, -0.04053751f, 0.01243971f, 
    0.17176916f, 0.03429583f, 0.12926082f, 0.12179860f, 0.30664781f, 0.01887546f, 0.08566366f, -0.02786452f, 
    0.02776758f, -0.01252337f, -0.01746852f, -0.15961403f, 0.03905959f, 0.04673307f, 0.04242619f, -0.15771779f, 
    -0.32548711f, 0.05135945f, 0.21351874f, 0.34437850f, 0.19720212f, -0.02806441f, 0.07114983f, 0.12698460f, 
    -0.02442727f, -0.04383582f, 0.09835795f, 0.11049929f, 0.10532790f, -0.00702276f, -0.28968918f, -0.00930901f, 
    -0.02007185f, -0.12768099f, 0.11764643f, 0.11157455f, 0.03761262f, 0.04293270f, -0.04207397f, -0.07036398f, 
    -0.68293828f, -0.35618854f, -0.22053844f, 0.57759744f, 0.08262654f, 0.02224695f, -0.07243793f, -0.22436850f, 
    0.01278509f, 0.07890139f, -0.00362601f, 0.02664016f, -0.22513755f, -0.27661771f, -0.06839110f, -0.07547417f, 
    -0.09417343f, -0.09629828f, 0.00167114f, 0.21132079f, 0.00830179f, -0.01990104f, 0.05157224f, -0.02849825f, 
    0.07896043f, -0.02889111f, 0.21361408f, 0.12127900f, 0.09531904f, 0.00387827f, -0.01632699f, -0.19002423f, 
    0.08959000f, -0.08700708f, 0.05708247f, 0.06987407f, 0.01652068f, 0.22590861f, 0.06124943f, 0.15051176f, 
    -0.07263558f, -0.04141108f, -0.00583539f, 0.07587580f, 0.07854544f, -0.14793418f, -0.13057384f, 0.24625742f, 
    -0.24099644f, -0.02848626f, 0.19151413f, 0.24963963f, -0.08647538f, -0.01705216f, -0.07875098f, -0.13339332f, 
    -0.17356823f, -0.01138440f, 0.05562436f, 0.10659517f, -0.49457452f, -0.22811058f, -0.07261533f, -0.13477652f, 
    -0.00296109f, 0.13891363f, -0.09420741f, 0.04985288f, 0.02506413f, -0.02859634f, 0.04889968f, 0.06166096f, 
    -0.02733251f, -0.06311292f, 0.25852826f, -0.00108606f, 0.10341579f, 0.04413693f, 0.08718005f, 0.12715423f, 
    -0.00319094f, 0.27592129f, -0.09525049f, 0.03575436f, -0.21759601f, -0.26119226f, -0.29310063f, -0.05687741f, 
    -0.12493091f, 0.00234735f, -0.14738326f, 0.09166451f, 0.01877298f, -0.01499805f, 0.08060042f, 0.05768493f, 
    -0.19984284f, -0.04334898f, 0.03797124f, -0.26924238f, 0.10099283f, -0.03374829f, -0.05842297f, 0.05347203f, 
    0.02957206f, 0.04016578f, -0.01553559f, 0.02241402f, 0.06029016f, 0.30743703f, -0.50949335f, -0.30142242f, 
    0.13290280f, -0.12427929f, -0.06198498f, 0.20618474f, -0.01184939f, -0.00121950f, 0.10680846f, -0.06002639f, 
    -0.05179150f, 0.08747602f, -0.09336702f, 0.11797021f, 0.02691831f, -0.02934653f, -0.09786850f, 0.03713715f, 
    0.08966550f, -0.09571125f, 0.03028471f, 0.05131559f, 0.09299132f, -0.08167419f, 0.03827244f, -0.27262008f, 
    0.07701641f, -0.18601374f, -0.00707983f, 0.06395963f, 0.04816701f, -0.02667436f, 0.03211121f, -0.07237842f, 
    0.46419621f, 0.47230709f, -0.10083959f, 0.14938189f, -0.03038447f, -0.14539905f, 0.05386011f, 0.14640510f, 
    0.05619609f, -0.09352257f, -0.09412768f, -0.10990949f, -0.44205230f, -0.52906138f, -0.53124225f, -0.45547137f, 
    -0.07415117f, -0.16087413f, -0.02871029f, -0.18485506f, 0.02035617f, -0.03906837f, 0.03369944f, -0.01033264f, 
    -0.28828087f, -0.43646169f, -0.55077106f, 0.08519526f, -0.24034531f, -0.22442602f, -0.09242147f, -0.36485848f, 
    -0.01121638f, -0.02094334f, -0.02265755f, 0.00964453f, -0.09706880f, -0.14060117f, -0.02381606f, -0.30860800f, 
    -0.07732005f, 0.14705132f, 0.00838325f, 0.08321174f, 0.01270698f, 0.02152472f, -0.05691905f, 0.00861024f, 
    0.02058921f, -0.32160714f, -0.14829144f, -0.25539410f, -0.02052863f, 0.10562878f, -0.05057864f, 0.10840901f, 
    0.05733318f, -0.01238533f, -0.02183560f, -0.00313342f, 0.31166774f, -0.36810550f, -0.09140979f, -0.29438543f, 
    -0.08818971f, -0.07259069f, -0.01501763f, 0.06763362f, 0.08271669f, 0.04995972f, -0.06545795f, 0.01961907f, 
    -0.23847060f, 0.37316099f, -0.09322067f, 0.16608037f, -0.01006368f, -0.14630993f, -0.05656479f, 0.02407868f, 
    0.00013710f, -0.03076601f, 0.03315891f, 0.01267232f, 0.01112608f, 0.07022779f, -0.06579549f, -0.05767350f, 
    -0.15867002f, 0.03428673f, 0.03944737f, 0.01988290f, -0.03684654f, 0.00606490f, 0.00430719f, 0.03901269f, 
    0.15559486f, -0.13556732f, 0.05637533f, 0.05284167f, -0.01043913f, 0.03746622f, -0.02505970f, 0.04930601f, 
    0.10691849f, 0.05076557f, 0.14208238f, 0.01636345f, 0.08688391f, -0.00346167f, 0.02268258f, -0.05868853f, 
    -0.03378562f, -0.02323653f, -0.01796453f, -0.04684879f, -0.07849012f, 0.03772603f, 0.00823489f, -0.05682933f, 
    -0.05152405f, 0.23875265f, 0.16451637f, -0.17856352f, 0.02287516f, 0.07597873f, -0.06307037f, 0.03389214f, 
    -0.10129318f, 0.00901004f, 0.04496518f, -0.09966703f, 0.20956582f, -0.62727046f, 0.05093964f, -0.37809804f, 
    -0.10712627f, 0.12644055f, -0.21446301f, 0.10069445f, 0.14121829f, 0.09412735f, -0.07670109f, 0.04150236f, 
    0.15495302f, -0.07774784f, -0.03132572f, -0.19046842f, 0.00339440f, 0.05010843f, 0.00385946f, -0.02185861f, 
    0.00919746f, 0.08263280f, 0.09941341f, -0.04093115f, -0.10636836f, -0.04494369f, 0.13196267f, -0.04913707f, 
    -0.14057696f, 0.01682389f, 0.04451429f, -0.19311139f, -0.00643505f, 0.03797496f, 0.03906788f, -0.08595289f, 
    0.11106510f, -0.01072870f, 0.01923331f, -0.01666256f, -0.00980486f, -0.02381816f, -0.07995758f, -0.10860051f, 
    -0.10130350f, 0.00097464f, -0.01181116f, -0.02618315f, 0.03445531f, 0.20233826f, 0.15797758f, -0.01110580f, 
    0.02350809f, -0.00331728f, 0.06110638f, 0.05184429f, -0.06642248f, -0.12913156f, -0.00954263f, -0.12861075f, 
    0.39724800f, -0.55334288f, -0.36921123f, -0.50390446f, -0.12033098f, 0.06026046f, 0.01320797f, -0.01270921f, 
    0.02618547f, -0.00774559f, 0.03767700f, -0.04385949f, 0.01802821f, 0.05414808f, 0.01134803f, -0.06702682f, 
    -0.10223323f, 0.04821396f, 0.04399011f, 0.03874280f, -0.00303544f, -0.00749363f, -0.01361888f, -0.06458782f, 
    0.07314294f, -0.13548462f, 0.14866309f, -0.08916444f, -0.17155817f, 0.09576950f, -0.01577737f, -0.03317245f, 
    -0.03456158f, 0.06696876f, 0.03876339f, -0.05676941f, -0.48694643f, 0.12713072f, -0.19588873f, 0.31593171f, 
    0.00792173f, -0.07458479f, 0.05126348f, -0.07627458f, 0.00111347f, -0.02619244f, 0.04169902f, -0.03210885f, 
    -0.07494473f, 0.10752359f, -0.11880309f, 0.16440651f, 0.00157092f, -0.07195358f, 0.08735224f, 0.04582773f, 
    0.03079850f, -0.04311313f, -0.00298956f, 0.04197149f, 0.18101174f, -0.00675331f, -0.02277835f, -0.13105479f, 
    -0.03134706f, -0.07038453f, -0.07235900f, -0.03068849f, -0.08543228f, 0.06772688f, 0.04779278f, 0.00321283f, 
    -0.27365494f, -0.27405185f, 0.03025815f, -0.08174497f, 0.11424640f, 0.21113573f, 0.03488472f, 0.13471350f, 
    0.02006063f, -0.07852972f, 0.00885260f, -0.01065081f, -0.03709953f, -0.03818335f, -0.03194689f, -0.11674743f, 
    0.01508836f, -0.01113499f, 0.00079773f, -0.06482618f, 0.06466687f, -0.01075257f, 0.04840146f, -0.03780977f, 
    0.32494944f, 0.05325310f, -0.05993811f, -0.08325534f, 0.01357638f, -0.03282227f, -0.03039072f, -0.07542164f, 
    0.07650328f, -0.23111162f, 0.08967900f, 0.10704275f, -0.33939350f, -0.24159029f, -0.13150576f, 0.05627879f, 
    0.17442696f, -0.12176611f, 0.10711773f, 0.01981041f, 0.04076556f, 0.01327670f, 0.00354747f, 0.03911702f, 
    0.47917876f, -0.21174876f, 0.02111910f, -0.18485960f, -0.12332641f, 0.02283590f, -0.13610666f, -0.11364479f, 
    -0.03500045f, 0.01340900f, 0.01574744f, -0.05960927f, 0.07923631f, -0.05109888f, 0.08636313f, -0.07748367f, 
    -0.05350374f, 0.06538894f, 0.15272155f, 0.01194470f, -0.00423183f, -0.01442510f, 0.01547433f, 0.05659954f, 
    -0.37731957f, -0.62505186f, -0.05935121f, 0.42627504f, 0.09515524f, -0.05495504f, -0.15072197f, -0.04524656f, 
    -0.04582432f, -0.14805183f, -0.03297859f, -0.02521532f, 0.25504822f, -0.22294371f, 0.03502259f, -0.19353862f, 
    0.05767229f, -0.09167747f, 0.02751152f, 0.02778061f, -0.01219959f, 0.03379738f, 0.06950641f, -0.22954723f, 
    0.24408422f, -0.41362303f, -0.13828023f, 0.10475839f, -0.04886432f, 0.14253540f, 0.00231818f, 0.16821706f, 
    -0.00761628f, 0.01762889f, -0.13537583f, -0.05431015f, -0.70330131f, 0.12952301f, 0.18644291f, 0.06011001f, 
    0.12574032f, -0.12565488f, 0.08521795f, -0.01179476f, -0.04384908f, -0.12038858f, -0.01163695f, 0.04582311f, 
    -0.54542243f, -0.38458103f, -0.36151561f, -0.15173648f, -0.03015458f, -0.04658190f, 0.14936174f, 0.06629670f, 
    -0.01415604f, -0.01121846f, -0.04096745f, 0.02742050f, -0.03279518f, 0.11349289f, -0.09808351f, -0.01950657f, 
    -0.09581263f, -0.04011368f, 0.10773162f, 0.05991238f, 0.00541877f, -0.04655026f, 0.05541733f, 0.02058150f, 
    -0.25131151f, -0.23733240f, -0.03421653f, -0.12603550f, -0.11928262f, -0.10471103f, -0.17287372f, -0.07621461f, 
    0.05107791f, 0.02404512f, 0.00715576f, 0.03818922f, 0.05891046f, -0.00180476f, 0.11375692f, -0.12528020f, 
    -0.01714624f, 0.01183800f, -0.01463626f, -0.02030464f, 0.03011637f, -0.01211629f, -0.03962173f, -0.07016595f, 
    -0.22043495f, -0.40060622f, -0.03224756f, 0.20247984f, -0.01843816f, -0.04749012f, -0.03691247f, 0.27939454f, 
    0.01709354f, -0.07306582f, -0.04890654f, -0.03352587f, -0.22781196f, 0.26682007f, -0.14413078f, 0.05651280f, 
    -0.05222675f, -0.09300441f, -0.08671497f, -0.03028724f, -0.01531532f, 0.06705866f, 0.02990774f, -0.04570202f, 
    -0.24073797f, 0.11824618f, 0.05379747f, 0.04540692f, -0.04551619f, -0.14782228f, -0.13124825f, 0.07047261f, 
    0.07891106f, 0.02504211f, 0.05345584f, -0.00766173f, 0.28548354f, 0.05814705f, -0.11046689f, -0.19766824f, 
    -0.01966905f, 0.02416304f, -0.03499728f, -0.02349802f, -0.12124825f, 0.00004612f, -0.18336032f, -0.23191004f, 
    0.03547457f, 0.03567412f, 0.05061414f, -0.04824926f, -0.04497638f, -0.04376653f, 0.02119838f, -0.04319967f, 
    0.01800653f, 0.01934324f, -0.04196661f, 0.01566355f, -0.01937269f, 0.11477776f, 0.00393000f, -0.01125045f, 
    0.02786773f, 0.02857207f, -0.08663716f, -0.03994315f, 0.06907140f, 0.08375056f, 0.01495029f, -0.00066596f, 
    0.07677041f, -0.23747215f, -0.10696785f, 0.00866275f, -0.01186819f, -0.02925532f, -0.05153435f, 0.03621171f, 
    0.07889480f, 0.04573407f, 0.10300892f, -0.04318104f, 0.20410401f, -0.09675462f, 0.16149506f, -0.00004385f, 
    -0.06637783f, 0.00739259f, -0.01609159f, -0.14431490f, -0.04708562f, -0.09563427f, -0.19061135f, -0.01409734f, 
    0.14847593f, -0.43573189f, 0.25737134f, 0.01583336f, 0.09892349f, -0.04349601f, 0.14447027f, 0.01423365f, 
    0.01731151f, 0.04092634f, 0.08542874f, 0.05297953f, 0.14163293f, 0.22332650f, -0.19781998f, 0.11994854f, 
    0.01710203f, -0.08524072f, 0.10798971f, 0.05668680f, 0.01247629f, -0.07849243f, 0.13808000f, 0.03255462f, 
    0.00576791f, 0.06260724f, -0.10375077f, 0.03389019f, -0.06646809f, 0.00547725f, 0.03429093f, 0.03126172f, 
    0.08171296f, 0.06921220f, 0.14435706f, 0.11284813f, 0.42790276f, -0.90624112f, -0.53360361f, -0.52622980f, 
    0.04442977f, 0.03819188f, -0.07339168f, 0.14800999f, 0.08300932f, -0.01253898f, 0.08575291f, 0.05902254f, 
    -0.04309850f, 0.00026769f, -0.15226538f, -0.06015963f, 0.00757845f, -0.04680259f, 0.04528119f, -0.05133596f, 
    -0.01107372f, 0.01440522f, -0.00747841f, -0.19644599f, -0.29251885f, 0.02256489f, -0.17655300f, 0.19231103f, 
    -0.05508130f, 0.03595726f, 0.01401162f, 0.07199620f, -0.04389752f, 0.07369123f, 0.02335415f, 0.05472094f, 
    0.06838390f, -0.09291113f, 0.22555992f, -0.30759582f, 0.02855407f, -0.06618378f, 0.07418652f, 0.00312130f, 
    -0.09208929f, -0.01344531f, 0.03525189f, -0.04253390f, 0.07968589f, -0.22093512f, 0.12129222f, 0.04028695f, 
    -0.03761128f, -0.05916164f, -0.09223486f, -0.06972573f, -0.03892980f, 0.02240357f, -0.01172717f, -0.01385766f, 
    -0.15348764f, -0.34754777f, 0.30852476f, -0.33118188f, -0.08204795f, -0.03823417f, 0.08136793f, 0.15134972f, 
    -0.06429437f, 0.02779371f, 0.03290935f, 0.02909225f, -0.42408100f, -0.16266955f, -0.19647972f, 0.13889994f, 
    0.11884240f, -0.19463377f, 0.10137960f, -0.01287427f, -0.05227519f, 0.05628930f, -0.01556331f, -0.07618090f, 
    -0.17850173f, 0.25910592f, -0.23410477f, 0.21640860f, 0.00448309f, 0.04724682f, -0.01198433f, 0.02300570f, 
    -0.16138609f, 0.11961814f, -0.06742139f, 0.03426829f, -0.01587626f, -0.06158878f, 0.06224197f, -0.12171063f, 
    -0.01390515f, -0.00539792f, -0.00405130f, -0.03598328f, -0.14960729f, 0.00968230f, 0.03387387f, 0.02094493f, 
    0.20900388f, 0.09908601f, 0.02528205f, -0.10732476f, -0.02502690f, -0.01282526f, -0.05582579f, 0.03824177f, 
    -0.02153665f, 0.01985948f, 0.03650877f, -0.07318578f, 0.13250639f, -0.17787060f, -0.18754353f, -0.28707993f, 
    -0.06090052f, -0.02494306f, -0.01362157f, 0.12965374f, 0.04125531f, 0.00762411f, 0.02870617f, 0.00883176f, 
    0.01542032f, 0.05454206f, 0.17032003f, -0.11566522f, -0.01532210f, -0.03754428f, -0.08976176f, 0.04659686f, 
    -0.09109392f, -0.01885780f, -0.03993203f, -0.02766241f, 0.45166218f, -0.19901927f, -0.19802663f, -0.17077428f, 
    -0.10703699f, 0.13291125f, -0.02322722f, 0.00368806f, 0.02768830f, 0.04327847f, -0.00313960f, -0.03193672f, 
    0.09800592f, -0.03536369f, 0.07664065f, -0.08923054f, 0.00485471f, 0.00029075f, 0.04218658f, -0.01054940f, 
    0.07627240f, 0.03798649f, -0.07972568f, -0.03430112f, -0.18152075f, -0.24685118f, 0.23770155f, -0.03931139f, 
    -0.08483800f, 0.01921710f, -0.00968021f, -0.15459315f, -0.05510669f, 0.12573874f, -0.05846117f, -0.08256284f, 
    0.07813325f, -0.03909253f, -0.00373218f, -0.11009540f, 0.00028261f, 0.01009525f, 0.04169957f, -0.02916639f, 
    -0.04977139f, 0.00531111f, 0.02064714f, -0.09538016f, -0.30456528f, 0.40442264f, 0.01404304f, 0.08987125f, 
    0.07484231f, -0.20466812f, 0.18460016f, -0.06178299f, -0.01964405f, 0.01515872f, -0.01228301f, -0.02436778f, 
    -0.24166629f, -0.07447744f, -0.09332056f, 0.16559032f, -0.07755727f, 0.04276371f, 0.23637758f, -0.12018035f, 
    0.07470292f, -0.12508807f, 0.12682000f, 0.01957841f, -0.06817628f, -0.06132440f, -0.07873185f, 0.56442505f, 
    0.04163034f, -0.07347500f, 0.00714605f, -0.02342053f, -0.07452795f, -0.05248445f, -0.06934264f, 0.02235063f, 
    -0.24406676f, -0.04309253f, 0.14696050f, -0.10817598f, 0.06355786f, 0.00547969f, 0.00195131f, 0.17674455f, 
    -0.00817118f, -0.06525870f, -0.11334346f, -0.00882718f, -0.18945011f, 0.05946282f, -0.15905960f, 0.03065275f, 
    0.17274718f, 0.02672329f, -0.06078189f, -0.03693791f, -0.04686346f, 0.00566758f, 0.05220913f, -0.00058789f, 
    0.04179927f, -0.07928555f, -0.42079028f, 0.01788978f, -0.08377829f, 0.00556149f, 0.15172260f, -0.03834880f, 
    -0.04730548f, -0.00797677f, -0.08106268f, -0.11219462f, 0.09277064f, -0.05256861f, -0.06929988f, -0.00834951f, 
    0.16123684f, 0.07193638f, 0.12739867f, 0.05752710f, -0.26695928f, -0.20182417f, -0.19536959f, -0.38657263f, 
    -0.43034086f, 0.17105009f, -0.02342150f, -0.15492174f, -0.05583972f, 0.00477817f, -0.06354462f, 0.01122777f, 
    -0.03719014f, -0.00130761f, -0.01144986f, 0.01091298f, 0.09119584f, -0.06872496f, 0.01110555f, 0.10817192f, 
    0.07288511f, 0.01680928f, -0.12953644f, 0.18168433f, 0.05189558f, 0.13570602f, 0.02591536f, -0.06016706f, 
    -0.02673106f, 0.10103886f, 0.00601628f, -0.22922543f, -0.02254822f, 0.00431417f, 0.02936544f, -0.01545614f, 
    -0.01610991f, -0.11477357f, -0.28055692f, -0.44486907f, -0.12020805f, 0.00184526f, 0.01069339f, -0.21479495f, 
    -0.04230691f, -0.03709412f, 0.02747895f, -0.15006840f, -0.09987448f, -0.14240511f, -0.10049606f, -0.10469635f, 
    0.16349074f, 0.03902314f, -0.05378861f, -0.05241728f, -0.07858361f, -0.10781191f, 0.04452039f, 0.00980472f, 
    0.10846693f, -0.05564880f, 0.00675930f, -0.00528498f, -0.16184562f, -0.35755002f, -0.13791537f, 0.18654934f, 
    0.10942729f, 0.03600170f, 0.14080073f, 0.03410246f, -0.04870688f, 0.00885521f, 0.01628399f, -0.12193718f, 
    -0.04054630f, -0.08494039f, -0.12523973f, -0.11150452f, -0.00696558f, 0.02325602f, -0.04689129f, -0.00926490f, 
    0.10617116f, 0.12148924f, 0.04311211f, 0.22152273f, -0.14578672f, -0.13855302f, -0.10860256f, 0.14174280f, 
    0.04606117f, 0.07215100f, 0.06412257f, -0.04279791f, 0.12900682f, -0.07270047f, -0.03797393f, -0.09069604f, 
    0.11733145f, 0.06204671f, -0.00002664f, -0.12209459f, -0.02294495f, -0.01989283f, -0.05584659f, -0.05507177f, 
    -0.03829148f, -0.03367672f, -0.04193224f, -0.07861017f, -0.20361972f, -0.06421701f, -0.00754059f, 0.04002674f, 
    -0.09008012f, -0.00469300f, -0.01486194f, 0.01343995f, -0.04555617f, 0.02254353f, -0.03995582f, 0.00034025f, 
    -0.09587122f, -0.02923936f, -0.13845296f, 0.29002085f, 0.10014821f, -0.00385079f, 0.11869276f, 0.03238085f, 
    -0.00880654f, 0.01781625f, 0.00825004f, 0.08216091f, -0.14394483f, -0.04027691f, 0.05905390f, -0.00616624f, 
    0.02385330f, -0.05002336f, 0.02907274f, -0.00495633f, 0.02523246f, -0.01512555f, 0.05303243f, 0.17438704f, 
    -0.16278189f, 0.19595225f, 0.05640427f, 0.13676369f, 0.27750635f, -0.08375901f, -0.07053407f, 0.08053592f, 
    -0.00288434f, -0.13398175f, 0.07477622f, 0.11040620f, -0.39175501f, 0.16076785f, 0.02521943f, 0.22579876f, 
    -0.00501880f, 0.10943736f, 0.01954835f, 0.15129004f, -0.10515583f, 0.12483063f, -0.06753816f, 0.08547758f, 
    -0.04956585f, -0.03279050f, -0.04423465f, 0.06450844f, -0.05035302f, 0.19429922f, 0.10374081f, 0.01599289f, 
    0.08076258f, -0.12867208f, 0.11453381f, 0.00782601f, 0.15005443f, 0.05480387f, -0.03362479f, -0.18161635f, 
    0.09081118f, -0.07019074f, -0.01888318f, -0.07934691f, -0.10723156f, 0.05180336f, -0.09655332f, 0.12773666f, 
    -0.00038911f, -0.14303154f, -0.17496359f, 0.11425945f, -0.10697787f, 0.09302422f, 0.02724371f, -0.04072863f, 
    -0.02037162f, -0.12913738f, -0.12370942f, -0.08366947f, -0.30090541f, 0.23538831f, 0.06125583f, 0.11510314f, 
    0.00585068f, -0.06016210f, -0.04685849f, -0.11501632f, 0.05065588f, -0.04956891f, -0.01967289f, -0.03043971f, 
    -0.18250944f, -0.18952356f, -0.19968356f, -0.10636285f, -0.07083912f, 0.06633550f, 0.08929767f, 0.00516551f, 
    0.08385467f, 0.17116477f, -0.05200426f, -0.10433368f, -0.20214994f, -0.33820352f, -0.12386506f, 0.05837601f, 
    0.01906809f, -0.00295416f, 0.10917497f, 0.19405651f, -0.08283833f, -0.06037587f, -0.09779761f, -0.07373469f, 
    0.21891725f, -0.01225300f, -0.16883270f, -0.13616879f, -0.05265965f, 0.03013550f, 0.09220874f, 0.07739047f, 
    0.03343819f, 0.00672516f, -0.07800136f, 0.00788964f, -0.04873360f, 0.11678302f, -0.04063531f, 0.04567019f, 
    0.06486055f, 0.02769372f, 0.14059950f, -0.28033441f, 0.02829705f, -0.04204550f, 0.01190532f, -0.03378316f, 
    0.61879373f, -0.30318704f, -0.31694719f, -0.03401513f, 0.20479213f, 0.06166578f, 0.01900083f, 0.13987018f, 
    0.07875527f, 0.12540200f, 0.13228987f, 0.06583291f, 0.17104575f, 0.04676443f, -0.15873174f, -0.29726088f, 
    -0.16673973f, -0.01308472f, -0.11745089f, -0.01730579f, 0.01432806f, 0.01043689f, 0.06527855f, -0.01398454f, 
    0.04394500f, -0.15404639f, -0.28836063f, -0.22162734f, 0.06615853f, -0.06274268f, 0.18036212f, 0.02869130f, 
    -0.02523555f, -0.02659262f, -0.15330540f, -0.02778383f, 0.14931704f, -0.33079192f, -0.19081494f, 0.14093897f, 
    -0.05932517f, -0.04670542f, 0.23710747f, -0.13494280f, -0.06633162f, 0.08632319f, 0.19178930f, 0.04490452f, 
    -0.03254865f, -0.54446220f, -0.39433697f, 0.34534928f, 0.06983548f, 0.15815233f, 0.08951280f, 0.05217170f, 
    -0.06169519f, -0.10331766f, 0.01783454f, -0.04443809f, -0.19561142f, 0.02375244f, -0.03224517f, 0.02543375f, 
    -0.08068255f, -0.05326652f, -0.04158805f, 0.02624376f, -0.00668626f, 0.00224472f, -0.07126016f, 0.01208595f, 
    -0.27207169f, -0.40788791f, -0.17755589f, 0.14488918f, 0.05138124f, -0.08722222f, 0.05287974f, 0.13560157f, 
    -0.05702361f, -0.03689931f, -0.01493250f, 0.04045042f, -0.10952461f, 0.00702570f, 0.08530574f, 0.00246879f, 
    -0.01421944f, 0.00800089f, -0.02435608f, -0.00443769f, 0.04744926f, -0.00641335f, 0.00249760f, 0.07770334f, 
    0.06224098f, -0.11797016f, -0.37115169f, -0.23344435f, -0.08602247f, -0.13798113f, -0.09805808f, -0.33293378f, 
    0.01472340f, 0.00061410f, -0.01724769f, -0.03570763f, -0.21446010f, 0.07673203f, 0.12524728f, 0.17181797f, 
    0.03097994f, 0.01427457f, -0.11518130f, 0.10095559f, 0.00589228f, -0.01407633f, 0.08625411f, 0.03677585f, 
    -0.29119521f, 0.20695820f, 0.06697612f, -0.08293381f, -0.10461849f, -0.00062482f, -0.04417436f, -0.16959693f, 
    0.03363592f, 0.06491897f, -0.00867330f, -0.02173371f, 0.40979809f, -0.04962714f, -0.31545955f, -0.30274174f, 
    -0.01552099f, 0.01380369f, -0.02079249f, -0.00827607f, 0.16282806f, 0.04069091f, 0.21146649f, 0.08293343f, 
    -0.21047413f, -0.09713712f, -0.01655327f, -0.10685527f, -0.05864680f, -0.00723915f, 0.00839840f, -0.04620807f, 
    0.00138903f, 0.02440505f, 0.00463968f, 0.02049105f, -0.18993875f, 0.03957061f, 0.16201705f, 0.05169667f, 
    -0.02935020f, 0.00604973f, -0.05819412f, -0.00989143f, -0.10709985f, -0.16651712f, -0.03643924f, -0.09829400f, 
    0.09480812f, 0.05279656f, 0.06178908f, -0.01258450f, 0.07293190f, 0.02135779f, 0.04177324f, -0.00604167f, 
    -0.06667904f, -0.08909654f, -0.24579613f, -0.25898924f, 0.00554753f, -0.04060734f, -0.12574644f, -0.15082975f, 
    0.08035217f, -0.04883465f, 0.02630764f, 0.01961567f, -0.10481541f, 0.06924509f, -0.17274031f, -0.22529262f, 
    0.00704468f, -0.52535486f, -0.45678180f, -0.37721813f, -0.12738571f, 0.12993449f, 0.01636369f, 0.01934867f, 
    -0.02479335f, 0.04504063f, -0.12404546f, -0.01155528f, -0.07139523f, -0.32228458f, -0.23029238f, -0.02081971f, 
    -0.07372808f, 0.08337552f, 0.08132832f, 0.08406147f, 0.15086901f, 0.13800630f, 0.08216631f, 0.11629122f, 
    -0.30685845f, -0.03966003f, -0.01417124f, 0.06875569f, 0.13971551f, 0.05749606f, -0.03104095f, -0.07289604f, 
    -0.31579131f, -0.29115045f, -0.08717676f, -0.20188846f, -0.41844103f, -0.34720764f, -0.25768101f, 0.34137022f, 
    -0.01953222f, 0.14286013f, 0.16626365f, 0.10936270f, 0.01797425f, 0.10833420f, 0.05289380f, 0.03268056f, 
    -0.16940084f, -0.11456224f, 0.02677080f, -0.23372015f, -0.11842357f, 0.01845251f, -0.02670956f, -0.03858176f, 
    0.04139666f, 0.01132487f, -0.07679216f, -0.06354458f, -0.29795682f, 0.15103970f, 0.03512443f, 0.22057910f, 
    0.08911083f, 0.04701519f, -0.09415248f, 0.12294681f, -0.12824397f, 0.09123964f, 0.07352586f, 0.08286625f, 
    0.34310544f, 0.09260949f, -0.16847239f, -0.07812390f, -0.05429691f, -0.10716593f, 0.06574400f, -0.14061600f, 
    0.02079628f, -0.03915693f, 0.00578400f, 0.04521380f, 0.18662859f, -0.08141374f, -0.17227769f, -0.04683791f, 
    0.21130165f, -0.11488093f, -0.00347586f, -0.06471071f, 0.03305351f, 0.07935414f, 0.15274455f, 0.13643305f, 
    0.37467399f, 0.08918883f, -0.21067785f, 0.01037182f, -0.02951813f, 0.01349535f, 0.03172381f, -0.16191170f, 
    0.12624533f, -0.01016494f, 0.01039688f, 0.06146877f, 0.20068382f, -0.03450748f, -0.06814427f, 0.08487784f, 
    0.01939773f, -0.08062227f, 0.02589748f, -0.00427640f, 0.04783083f, -0.07347907f, 0.12362974f, 0.03345245f, 
    -0.16234399f, 0.12595557f, 0.11841562f, 0.22476137f, -0.13636653f, 0.05896086f, 0.07841448f, 0.01748857f, 
    -0.01598986f, 0.04475489f, 0.11589379f, -0.07714847f, 0.01990261f, -0.09137048f, 0.07979760f, 0.02984496f, 
    0.07143743f, 0.02701373f, 0.03656099f, -0.00900314f, -0.05011184f, 0.10493662f, 0.02363585f, 0.04517201f, 
    0.19053760f, 0.01682365f, -0.08496371f, -0.09575418f, -0.08936602f, -0.20696452f, 0.10777903f, -0.00936684f, 
    0.05757384f, 0.00615096f, 0.16676345f, 0.07230766f, -0.09261548f, -0.48700774f, -0.45875564f, -0.17555033f, 
    0.07069764f, 0.13090076f, 0.17154686f, 0.02778936f, -0.00696901f, -0.10363481f, -0.02914567f, -0.03193434f, 
    0.01294444f, 0.01447861f, -0.09397817f, 0.19863378f, 0.09571414f, 0.03099032f, 0.03751026f, 0.06921966f, 
    0.03319955f, 0.02857447f, 0.02413271f, 0.10844401f, -0.17045571f, -0.28641975f, -0.13221055f, -0.07910963f, 
    -0.11127811f, 0.06379203f, 0.15796809f, 0.00849534f, 0.02030822f, -0.04430276f, 0.03835165f, 0.12535483f, 
    -0.06908827f, -0.05292483f, 0.04622720f, -0.10177889f, -0.09597462f, -0.01767157f, -0.07717690f, -0.02895963f, 
    0.02096757f, 0.02622933f, 0.06782533f, 0.08770441f, 0.46039972f, -0.33341172f, 0.02338739f, -0.07402481f, 
    0.24355265f, -0.07693360f, -0.09259105f, 0.17683436f, 0.17857279f, 0.02810659f, 0.01466681f, 0.12901790f, 
    -0.03977921f, -0.00204484f, 0.02895874f, 0.01187864f, -0.05593152f, -0.08521820f, -0.02256976f, -0.01510624f, 
    -0.02043978f, 0.07595591f, 0.02492775f, 0.14199907f, -0.32309327f, -0.05586115f, 0.02461324f, 0.00608892f, 
    -0.05248052f, 0.07266084f, -0.23729938f, -0.03524243f, -0.08021194f, 0.07195518f, 0.15990174f, 0.03856738f, 
    -0.38459951f, 0.01088893f, -0.08741907f, 0.28778166f, 0.19152077f, 0.12430437f, -0.00420679f, 0.03337559f, 
    -0.14587538f, 0.18901415f, 0.07738914f, 0.08739812f, -0.10477988f, -0.45111188f, -0.45759520f, -0.21946202f, 
    0.07993148f, -0.01248017f, 0.07892535f, 0.03905605f, 0.10237546f, 0.08677331f, 0.08015011f, 0.04694155f, 
    0.17865947f, -0.21562847f, -0.41996235f, -0.28069302f, -0.24024652f, -0.22956166f, -0.11829600f, -0.18532446f, 
    0.01239972f, 0.01837201f, 0.02697526f, 0.00389446f, -0.32493135f, 0.11092704f, 0.21339670f, 0.19487610f, 
    0.04456256f, 0.10420928f, -0.03704844f, -0.03097936f, 0.06547979f, 0.00453997f, -0.08647174f, -0.05828284f, 
    -0.04190004f, -0.16394113f, 0.10676701f, -0.20476948f, -0.22818886f, -0.09944532f, -0.09536216f, -0.05404907f, 
    0.13193394f, 0.01534521f, -0.00431950f, 0.02632745f, -0.02213074f, -0.05464843f, 0.22022374f, 0.18239772f, 
    0.09049035f, -0.07439236f, -0.09837195f, -0.07930979f, 0.07261986f, 0.12979476f, 0.05501660f, 0.17707686f, 
    -0.29852477f, -0.30900198f, -0.06638425f, 0.10142381f, -0.04765644f, 0.08555937f, 0.03595078f, 0.18497856f, 
    0.02286290f, 0.03484046f, -0.00887779f, -0.01376243f, 0.08518099f, -0.15285832f, -0.07513829f, -0.27581564f, 
    -0.03740536f, 0.17851581f, -0.16513668f, 0.23327222f, 0.09023090f, -0.15979661f, -0.24646696f, -0.21115284f, 
    0.17858291f, -0.23738833f, -0.05509502f, 0.02306038f, 0.00418403f, 0.04675201f, 0.01385915f, 0.01238227f, 
    -0.11394034f, 0.12012188f, 0.15043616f, 0.04867646f, -0.00248676f, -0.19327517f, -0.10788278f, -0.12089853f, 
    0.05498945f, 0.08263522f, 0.10340662f, 0.02519820f, -0.09898186f, 0.04326499f, -0.00654589f, -0.00821405f, 
    0.08225450f, -0.60210139f, -0.08205169f, -0.17968328f, 0.01966982f, 0.15077290f, -0.05005566f, 0.06097227f, 
    -0.04742806f, -0.06830283f, 0.00242182f, 0.03716961f, 0.19372176f, -0.00353165f, -0.06147148f, -0.22053765f, 
    -0.27737626f, -0.05731025f, -0.08801258f, -0.19451872f, 0.13524009f, 0.07486941f, 0.02865978f, 0.05657596f, 
    0.09018362f, 0.13865061f, 0.21935096f, 0.17114411f, 0.03364962f, 0.02000811f, 0.01197278f, -0.07578147f, 
    -0.12816018f, -0.24293454f, 0.00814858f, -0.09553130f, 0.10373873f, -0.23852696f, 0.18198353f, -0.37918359f, 
    -0.02356588f, -0.00113204f, -0.16255488f, 0.07469170f, 0.12981500f, 0.01703310f, -0.06182620f, 0.09746994f, 
    -0.09727802f, 0.06065674f, -0.18550673f, 0.20516695f, 0.09777072f, 0.06746234f, 0.05917384f, 0.01429156f, 
    0.10431863f, 0.06760527f, 0.05490309f, 0.03456315f, -0.02324336f, -0.27978069f, -0.03228003f, -0.06885825f, 
    -0.20298107f, 0.19662416f, -0.00621121f, 0.25253296f, 0.11342918f, 0.06075884f, -0.04469159f, 0.02132472f, 
    0.10627602f, 0.22083859f, 0.12196960f, -0.22742188f, -0.07380012f, -0.14179480f, -0.09291419f, 0.00829825f, 
    0.04020340f, -0.04183255f, -0.00460781f, -0.02176061f, 0.20187682f, -0.26299945f, 0.07402945f, -0.24815197f, 
    0.10968053f, -0.01348791f, 0.02459139f, 0.05244207f, -0.03806929f, -0.10909959f, -0.15045959f, 0.05463609f, 
    0.12689137f, 0.02201825f, -0.38432151f, -0.25419822f, -0.17396009f, -0.17857978f, -0.00549080f, -0.24526823f, 
    -0.03485562f, 0.10297589f, -0.07928191f, -0.10344820f, -0.32426107f, 0.44663739f, 0.12486893f, -0.18587451f, 
    -0.02989440f, -0.17233497f, 0.06430107f, 0.11375400f, 0.06135783f, 0.09222081f, -0.00916879f, -0.04408117f, 
    -0.19928335f, 0.38153708f, -0.29015321f, -0.08149174f, 0.12976491f, -0.10007588f, -0.07155990f, -0.03827321f, 
    0.13573040f, 0.00819258f, -0.01710272f, -0.00927411f, 0.07048542f, -0.19737136f, -0.04165889f, 0.03068777f, 
    0.03677768f, 0.24187683f, 0.03922148f, -0.06044278f, 0.06965022f, -0.17063825f, -0.04974904f, 0.02309132f, 
    -0.08316531f, -0.11439025f, 0.09663080f, -0.07868179f, -0.17814574f, 0.04392047f, -0.05122770f, 0.08721694f, 
    0.06083515f, 0.02421598f, 0.05550299f, 0.09893135f, -0.15107796f, -0.16593535f, -0.63804895f, 0.16866028f, 
    0.05650881f, 0.16722144f, 0.15422392f, 0.03061983f, -0.00855527f, -0.05576316f, 0.01824797f, -0.11374434f, 
    -0.07978420f, 0.26306361f, 0.10378122f, 0.40050370f, 0.04995460f, -0.03716258f, -0.19011807f, -0.09480733f, 
    0.07083910f, 0.02990329f, 0.00270340f, 0.17384578f, -0.27348697f, 0.37665901f, -0.06053660f, -0.28294399f, 
    -0.11465772f, -0.21919788f, 0.10523573f, 0.03494806f, 0.06775612f, 0.09441472f, 0.02822303f, 0.00631864f, 
    -0.00221814f, -0.14367877f, 0.14318006f, 0.21421525f, 0.01557635f, 0.02422700f, -0.09776555f, -0.12897949f, 
    0.09861171f, -0.05399672f, -0.05658861f, 0.04703274f, 0.03682522f, -0.18801697f, -0.13349979f, 0.03354535f, 
    0.01294450f, -0.04529019f, 0.03718148f, 0.27166310f, 0.03600670f, 0.09571691f, 0.03162811f, -0.04844008f, 
    -0.29939929f, -0.06269746f, -0.01295698f, 0.06888870f, -0.13769920f, 0.01676864f, -0.04548688f, -0.04695068f, 
    0.05364364f, -0.02843974f, -0.04028448f, -0.03758786f, -0.09507254f, 0.02451700f, 0.21814889f, 0.25871488f, 
    -0.02015485f, 0.04863493f, -0.13501762f, 0.07779526f, 0.04083502f, 0.09771580f, 0.08267901f, -0.06224224f, 
    0.06794064f, 0.06439365f, 0.38467303f, 0.28240651f, 0.18275988f, -0.07344939f, -0.06592220f, 0.15058704f, 
    0.08595695f, 0.06041117f, 0.03416648f, 0.10203876f, -0.18640570f, 0.08005473f, 0.17849585f, -0.41902646f, 
    -0.07953420f, -0.36312547f, 0.03828136f, 0.05470255f, 0.02561338f, 0.02913165f, 0.06698460f, 0.01254853f, 
    -0.14592035f, 0.30719018f, 0.32368883f, -0.54850495f, -0.11813720f, -0.26292881f, 0.07747968f, -0.11602442f, 
    0.01054660f, 0.05067607f, 0.04817699f, -0.01184025f, -0.11463597f, 0.30341697f, -0.32506350f, 0.07636175f, 
    0.13402079f, 0.00980860f, 0.14716773f, 0.09724711f, 0.11708339f, -0.01852386f, -0.05786701f, -0.01854115f, 
    0.04432141f, 0.13885459f, 0.04097187f, -0.34690827f, -0.08843280f, 0.04197133f, 0.04721030f, 0.27361110f, 
    0.00358054f, -0.03285816f, 0.01294541f, -0.03908720f, 0.14900778f, -0.16163865f, 0.02388280f, 0.00314845f, 
    0.03220927f, 0.06069039f, -0.05533851f, -0.00053298f, 0.00660863f, -0.08334403f, 0.07910462f, -0.00852371f, 
    -0.24520007f, 0.00802586f, 0.11654811f, -0.24532537f, -0.10668544f, -0.10148436f, -0.02064614f, 0.17180806f, 
    0.07224151f, 0.06927345f, 0.02739261f, -0.08522514f, -0.20048879f, 0.42920631f, -0.60759223f, -0.00860395f, 
    -0.08205284f, -0.10262219f, 0.14836101f, 0.19959947f, 0.09550487f, -0.04271034f, -0.09948047f, -0.07800628f, 
    0.25255466f, -0.41548482f, -0.06912790f, -0.04438540f, 0.07485660f, 0.15834315f, -0.10680462f, -0.08713024f, 
    0.05240270f, -0.07275777f, -0.09834035f, -0.02950088f, -0.41984287f, 0.15290894f, 0.01493488f, 0.29414356f, 
    0.06592960f, 0.01068646f, -0.04157029f, -0.10504525f, 0.07739018f, -0.04202937f, -0.17881936f, -0.07247604f, 
    0.04835851f, -0.17627579f, 0.09119379f, -0.14237195f, 0.02370319f, 0.05594867f, 0.09946712f, 0.02300338f, 
    0.11225387f, 0.05706774f, -0.07163444f, -0.02311045f, -0.10288003f, -0.11408617f, -0.21410106f, -0.00843530f, 
    -0.00726975f, 0.13816261f, 0.09966475f, 0.05101600f, 0.02345915f, 0.00881377f, 0.06640250f, 0.02440127f, 
    -0.09213486f, 0.01348072f, 0.10317421f, -0.16251618f, -0.00666661f, 0.08862558f, -0.12867120f, -0.01533732f, 
    -0.00960610f, 0.04998412f, 0.03688242f, 0.03792137f, -0.03314039f, -0.01642025f, -0.07974010f, 0.31112903f, 
    0.06973223f, 0.06518627f, -0.00209457f, -0.05650436f, 0.27989611f, 0.01455999f, 0.10144195f, 0.02125368f, 
    -0.07251684f, -0.22621569f, 0.21969268f, 0.12124357f, 0.07615538f, -0.13728425f, -0.06719640f, -0.06963637f, 
    -0.03281640f, -0.04964562f, -0.02009497f, -0.00326979f, -0.01274733f, 0.13999313f, 0.21858044f, -0.00672740f, 
    0.17605272f, -0.10794041f, -0.19215295f, 0.01723935f, -0.09870178f, 0.05365178f, 0.00788120f, 0.08287023f, 
    0.03649114f, 0.17708707f, -0.14229983f, -0.14019388f, 0.08805598f, -0.09221090f, 0.13021965f, 0.08681036f, 
    0.04438443f, 0.07442182f, 0.05341434f, 0.10325412f, 0.18269089f, 0.13075888f, 0.03507954f, -0.23907840f, 
    -0.04202061f, -0.13085002f, -0.07764793f, -0.11457581f, -0.01736588f, -0.03854920f, 0.01018990f, 0.08144537f, 
    -0.02584201f, 0.05426347f, 0.17018226f, 0.13097875f, 0.05112245f, -0.00643381f, -0.07521332f, 0.03264371f, 
    -0.09650633f, 0.09539986f, 0.05662398f, -0.01910053f, -0.21457142f, 0.47792423f, -0.48631388f, -0.22038083f, 
    0.01961118f, 0.03029466f, 0.19309750f, -0.00573139f, 0.19394410f, 0.10839661f, -0.23441219f, 0.10452492f, 
    -0.31405398f, -0.55266547f, 0.15194151f, -0.17127559f, 0.03924107f, 0.04511238f, 0.03347399f, -0.00963103f, 
    -0.01179296f, 0.01551746f, -0.06485622f, 0.04416532f, 0.02146910f, -0.01376272f, 0.07645462f, 0.12855807f, 
    0.06289233f, -0.11412351f, 0.14978226f, 0.01253249f, -0.00359748f, -0.05398855f, -0.15233515f, -0.09658626f, 
    0.04368647f, -0.68755400f, 0.22666065f, -0.47971305f, 0.13051680f, 0.01013667f, -0.32357424f, 0.18340419f, 
    -0.01579581f, -0.06106360f, -0.02347322f, -0.04046206f, -0.45175150f, 0.09579331f, -0.15286203f, 0.02997109f, 
    -0.02154830f, -0.13818896f, 0.02550528f, 0.00985351f, -0.04838597f, 0.01540294f, 0.04558581f, -0.07085449f, 
    -0.36673129f, 0.17763354f, -0.28769049f, -0.45832431f, -0.07023681f, -0.00858851f, -0.03371320f, 0.06034490f, 
    -0.02992268f, 0.04300295f, -0.03120634f, 0.21400936f, 0.19387227f, -0.11448985f, 0.09983882f, -0.36838451f, 
    0.10526054f, -0.09313001f, 0.12786327f, -0.07025651f, -0.10787682f, -0.01276919f, -0.02008841f, -0.03632400f, 
    -0.42261332f, -0.03366512f, -0.01456274f, 0.01214085f, 0.14333574f, 0.01833918f, -0.23519403f, 0.06485910f, 
    -0.02601227f, -0.16160026f, -0.05084045f, 0.01293967f, -0.11400452f, -0.00276130f, -0.02257180f, -0.16010535f, 
    -0.20950757f, -0.04033206f, -0.02904992f, 0.07278725f, 0.05737814f, -0.00702073f, 0.09303834f, 0.03365248f, 
    0.05270524f, -0.43305674f, 0.06015445f, 0.04840621f, -0.04644471f, 0.09509517f, -0.17890725f, -0.04884405f, 
    0.15581833f, -0.00649778f, -0.08460197f, 0.02593949f, -0.07628291f, 0.16409299f, -0.14889276f, 0.01241648f, 
    -0.17043270f, -0.00100764f, -0.03292892f, -0.00701546f, 0.05351379f, -0.10748778f, 0.01759168f, -0.09165922f, 
    0.18287632f, -0.47423768f, 0.18346334f, 0.15451904f, 0.02215741f, 0.02362150f, -0.01587178f, -0.09102521f, 
    -0.11084327f, 0.13039799f, -0.13266303f, -0.07836885f, 0.13391794f, -0.12111973f, 0.26480576f, 0.06362976f, 
    -0.07842405f, -0.54422510f, -0.06924930f, -0.12479352f, -0.07147341f, -0.18255459f, -0.03719513f, -0.10579719f, 
    0.23514907f, -0.15030938f, 0.19164506f, -0.04835736f, 0.09999521f, -0.05692229f, 0.13571322f, -0.00580464f, 
    0.07991462f, -0.01340913f, -0.02003771f, -0.09312581f, 0.03492791f, -0.08048908f, -0.03430166f, -0.08132719f, 
    -0.00740941f, -0.08840840f, 0.06709382f, -0.04372581f, 0.05496135f, -0.03245084f, -0.06454171f, -0.12231512f, 
    -0.18807724f, 0.33245876f, 0.20203353f, -0.57244545f, 0.01293877f, -0.22027704f, 0.09866818f, -0.03624742f, 
    -0.03151639f, 0.04061202f, 0.07365538f, -0.10592762f, -0.07732058f, 0.18188974f, 0.03773759f, 0.12207782f, 
    -0.05539306f, -0.00804111f, 0.01465043f, -0.02918879f, 0.10641637f, 0.09902159f, 0.09555814f, -0.00577690f, 
    -0.53067130f, -0.20909202f, 0.02848123f, -0.05365795f, -0.12189547f, 0.09556757f, -0.07818789f, 0.23176546f, 
    0.01877985f, -0.02982570f, 0.07397366f, -0.01723766f, -0.20626992f, -0.12501782f, -0.24486546f, -0.01268971f, 
    0.09233087f, -0.02604638f, 0.14684515f, 0.11000910f, 0.00711011f, 0.00594312f, -0.02255141f, -0.02052642f, 
    -0.12894017f, -0.19423372f, 0.05061429f, 0.16653349f, -0.00802318f, -0.01958274f, 0.02976209f, -0.13893528f, 
    -0.07989293f, 0.09305031f, 0.07509030f, -0.25525188f, -0.14963762f, 0.19827618f, -0.11452284f, -0.17324002f, 
    -0.02994885f, -0.08168484f, -0.04590628f, 0.03098174f, -0.09379971f, -0.18855901f, -0.36766115f, -0.42600378f, 
    -0.03059084f, -0.27418423f, 0.16900702f, -0.02042424f, -0.10081436f, 0.00991159f, -0.02646993f, -0.03624044f, 
    0.10700489f, -0.06907076f, -0.08132411f, -0.02506404f, 0.15418398f, -0.12773095f, 0.39019543f, 0.30295959f, 
    -0.09898116f, 0.12018891f, -0.07858929f, -0.09597491f, -0.17489725f, 0.01714856f, 0.12469959f, 0.27805811f, 
    -0.04115197f, 0.28835794f, -0.18955131f, 0.19275106f, -0.02416143f, 0.04703403f, 0.08466217f, 0.04317226f, 
    -0.18237524f, -0.01199953f, -0.24873611f, -0.41823304f, -0.05058144f, -0.20872292f, 0.19021246f, -0.16634288f, 
    -0.07189354f, -0.05949657f, -0.09757538f, -0.12638788f, -0.15720616f, 0.02934176f, 0.10770833f, -0.21386957f, 
    -0.24087258f, -0.19672681f, -0.09165113f, 0.26701549f, 0.07077888f, 0.03004017f, 0.06319036f, -0.03357905f, 
    -0.04931919f, -0.04800941f, -0.10745294f, -0.19512877f, -0.11776891f, 0.09194075f, -0.11884198f, 0.28674024f, 
    0.03095904f, -0.08200405f, -0.00842648f, -0.14169368f, -0.00047033f, 0.03728878f, -0.10158826f, -0.19350751f, 
    -0.20210493f, 0.21548076f, -0.11226456f, -0.13302450f, -0.05799900f, 0.07517576f, 0.09872057f, -0.14633058f, 
    0.02012369f, 0.21498169f, 0.18564190f, 0.10736052f, -0.39275706f, 0.29868659f, 0.11779346f, 0.17250375f, 
    -0.05017791f, 0.05806794f, -0.19723417f, 0.11245500f, -0.14509346f, -0.08343389f, 0.11678962f, -0.04811511f, 
    -0.11915717f, -0.02536535f, 0.06421940f, -0.21981931f, -0.19678788f, 0.08757366f, -0.12735286f, 0.02174752f, 
    -0.06764545f, -0.15364023f, -0.18669212f, -0.12211663f, 0.09916387f, -0.17205262f, 0.29421371f, 0.06507627f, 
    -0.11637574f, -0.13225679f, -0.19174437f, -0.01410985f, -0.09213991f, -0.08088107f, 0.02951672f, -0.06815305f, 
    0.24163382f, -0.21230327f, 0.25070047f, 0.09129532f, -0.08497449f, 0.10640299f, 0.13308825f, 0.02313870f, 
    -0.02080791f, -0.00981087f, 0.06986379f, 0.02851176f, -0.10501431f, 0.16588221f, 0.00656749f, 0.20186585f, 
    0.06640442f, -0.01084762f, 0.09090217f, 0.00332536f, 0.00068541f, 0.12196519f, 0.02714653f, 0.18119389f, 
    -0.08036186f, 0.13757004f, -0.06012017f, -0.01074860f, -0.13314041f, -0.25003523f, 0.13954027f, 0.06150540f, 
    0.02551893f, 0.06005019f, -0.18165725f, 0.09902733f, -0.04461589f, -0.33806971f, 0.17142315f, 0.16368003f, 
    -0.09216851f, -0.05089837f, -0.01413408f, -0.01193568f, -0.08819167f, -0.18007495f, -0.03423972f, 0.14308777f, 
    0.01272201f, -0.28639635f, 0.32874161f, 0.19260006f, -0.14369155f, 0.20746760f, -0.05222498f, 0.12835792f, 
    0.03741832f, 0.08094965f, 0.13336088f, 0.16026126f, -0.18871842f, 0.22730635f, -0.15780018f, 0.06455050f, 
    -0.11946865f, 0.15875901f, 0.09601384f, 0.01289096f, -0.07092527f, -0.06647477f, 0.06856319f, 0.01318878f, 
    -0.04409203f, 0.03305759f, -0.13476732f, -0.05424482f, -0.03206919f, -0.00406094f, -0.03317829f, -0.05376657f, 
    -0.06312355f, -0.02655157f, -0.00268910f, -0.10833806f, -0.09837761f, -0.07702835f, -0.19002093f, -0.14451809f, 
    -0.21669050f, -0.07323357f, -0.01663101f, -0.04768520f, -0.11103750f, 0.04897915f, 0.09765513f, 0.04433202f, 
    0.51483625f, -0.07305929f, 0.26472425f, -0.33143878f, 0.01462718f, -0.05983565f, 0.01531847f, 0.00035121f, 
    -0.14838178f, -0.00417323f, -0.02517517f, -0.02755525f, 0.06503496f, -0.29747903f, 0.16617584f, 0.24665818f, 
    -0.04450754f, 0.10171841f, 0.22964229f, 0.05754122f, -0.02636135f, -0.07417377f, -0.00154964f, -0.02843810f, 
    -0.08729523f, 0.02331076f, 0.29168260f, 0.06972022f, 0.06059201f, 0.08014777f, -0.03534494f, 0.08338238f, 
    -0.10524282f, 0.07262083f, 0.07968923f, -0.06453529f, -0.15101537f, 0.13608249f, -0.19323483f, -0.09863615f, 
    0.02029236f, 0.11752708f, -0.16485304f, -0.10797987f, -0.14414355f, 0.00195640f, 0.10265226f, -0.17765738f, 
    -0.40217188f, 0.12073199f, 0.21979950f, 0.13752544f, -0.15859687f, 0.10758963f, 0.11771518f, 0.08438753f, 
    -0.03071317f, 0.04362028f, 0.07327424f, 0.22545153f, -0.28547215f, 0.07518225f, 0.11663912f, -0.10383861f, 
    -0.00151443f, 0.09408875f, -0.01740774f, -0.01777635f, 0.02824303f, -0.00814236f, -0.02589060f, -0.02727645f, 
    -0.26436731f, 0.05273705f, -0.37480214f, 0.10106548f, 0.05549141f, 0.10636207f, -0.05571603f, 0.07192928f, 
    -0.17053224f, -0.02478727f, -0.13871990f, -0.15690592f, 0.00958296f, -0.20277509f, 0.20628753f, -0.00567693f, 
    0.02218212f, 0.22975871f, -0.03915679f, 0.09166143f, 0.05264426f, -0.17291166f, 0.12680636f, -0.09281047f, 
    -0.09168530f, -0.13938354f, 0.18064199f, 0.12329555f, -0.03877475f, 0.12145256f, -0.01439643f, 0.03163827f, 
    0.09878330f, 0.01997418f, -0.04189804f, 0.05718083f, -0.13115185f, -0.37577212f, 0.02763657f, -0.03524687f, 
    -0.08906840f, 0.09519123f, 0.10539986f, -0.19939306f, -0.13484274f, 0.04570107f, -0.05204467f, -0.17174099f, 
    -0.19220617f, -0.15848812f, -0.05504739f, 0.20658503f, -0.01835670f, 0.03700754f, 0.12648544f, -0.05275331f, 
    0.00758382f, 0.04849289f, 0.11888259f, 0.09636838f, -0.01033879f, 0.04999290f, -0.05424865f, 0.13815080f, 
    -0.00752695f, 0.07657395f, -0.00114046f, -0.00208494f, 0.02436116f, 0.10673875f, -0.13103494f, 0.01226564f, 
    -0.15835188f, -0.46831486f, -0.33330908f, 0.01088265f, -0.01303223f, 0.10819558f, -0.19124472f, -0.04932966f, 
    -0.00693289f, 0.10383591f, -0.01691195f, -0.02666672f, -0.03284458f, -0.13930956f, 0.10831101f, 0.02069055f, 
    -0.04661076f, -0.00694425f, 0.19301213f, 0.07262520f, -0.11609564f, 0.13827154f, -0.00478480f, 0.05088182f, 
    -0.23038644f, -0.55990213f, 0.13539328f, 0.06710873f, -0.08924993f, 0.26088032f, -0.10882883f, 0.01085105f, 
    0.09597834f, 0.01979560f, -0.00204227f, 0.01880550f, -0.17078415f, 0.14825672f, 0.30911613f, -0.13802201f, 
    -0.17598136f, 0.02067879f, -0.08353199f, -0.07694722f, 0.16026387f, -0.16261382f, 0.00421287f, -0.06062813f, 
    -0.17545724f, -0.13950050f, -0.19492380f, -0.23612654f, -0.11136136f, -0.12467138f, -0.00792937f, -0.14520267f, 
    -0.00387060f, -0.01558446f, 0.05879757f, -0.01681464f, -0.14280985f, -0.06003217f, -0.01595077f, -0.12551463f, 
    -0.06159704f, -0.22247590f, -0.22216357f, 0.08578143f, -0.09872828f, 0.01534847f, -0.12779380f, -0.11492703f, 
    0.09165672f, -0.00319449f, 0.04757157f, -0.04367868f, 0.12205832f, 0.00727486f, 0.18003680f, 0.08133255f, 
    -0.00635830f, 0.09545076f, -0.33728099f, -0.19188808f, 0.03592940f, 0.02994349f, -0.12510245f, -0.13082349f, 
    -0.13397667f, 0.03715425f, 0.08995154f, 0.14246589f, -0.12247384f, -0.17057723f, -0.22563423f, -0.05389892f, 
    -0.44704032f, 0.29251289f, -0.05004932f, 0.36166304f, 0.04359196f, 0.01007572f, -0.07618474f, -0.01013708f, 
    0.04019423f, -0.01058591f, -0.06204494f, 0.11888286f, 0.23320028f, -0.00679884f, 0.06402480f, 0.19379063f, 
    -0.14769608f, -0.06207617f, -0.13145083f, 0.02123026f, 0.12540412f, -0.02418552f, 0.18187694f, 0.20168808f, 
    -0.16862504f, -0.04865709f, -0.04833373f, -0.16340302f, -0.09417310f, -0.28331995f, -0.14835259f, 0.08035243f, 
    -0.27578458f, -0.19265293f, -0.38817182f, -0.26295874f, 0.27347183f, -0.17193215f, 0.13357027f, -0.11255424f, 
    0.02947043f, -0.16028427f, -0.07112679f, -0.08845307f, -0.08285712f, -0.01269841f, -0.05326944f, -0.34030232f, 
    -0.17192097f, 0.23484489f, -0.01596955f, 0.17695114f, -0.04330975f, -0.00817634f, -0.19704053f, 0.04234648f, 
    0.08395908f, -0.14034097f, -0.26018110f, 0.06729347f, 0.17135221f, -0.06552994f, 0.19634211f, -0.05740096f, 
    -0.04542183f, -0.12845787f, 0.13059445f, 0.12649615f, -0.02136403f, -0.02143833f, 0.01225506f, 0.02946084f, 
    -0.35850823f, -0.01230062f, -0.08223753f, 0.04744154f, -0.14315507f, 0.14871922f, -0.09787525f, -0.05907413f, 
    -0.04793442f, -0.19178867f, 0.18380193f, -0.17724590f, -0.13079798f, 0.06265100f, -0.33666083f, 0.11395008f, 
    -0.19069006f, 0.13123167f, 0.22195636f, -0.06846688f, 0.17101903f, 0.18130650f, 0.08652881f, 0.16490938f, 
    -0.42859414f, 0.05430000f, 0.06631899f, 0.21877387f, -0.04539016f, 0.15808874f, -0.23640282f, -0.05088609f, 
    0.01575358f, -0.10235022f, 0.06461605f, 0.02039343f, 0.02628026f, -0.08096217f, 0.07028576f, 0.16034010f, 
    -0.09835348f, 0.20081680f, 0.05909358f, 0.05601773f, -0.03460951f, 0.12346405f, -0.01792220f, 0.00329343f, 
    0.27728039f, -0.10207883f, 0.42311141f, -0.20618555f, -0.03271921f, 0.11157770f, -0.08008377f, 0.10014746f, 
    0.13361350f, -0.02023616f, -0.06127326f, -0.10261866f, -0.09950799f, 0.02880521f, -0.22633746f, 0.34197217f, 
    -0.09090074f, -0.14381838f, 0.12145740f, 0.04089630f, 0.10229988f, 0.15479372f, -0.09975109f, 0.01772151f, 
    -0.08178557f, -0.11566583f, 0.08483435f, 0.11476309f, -0.08431368f, 0.06279970f, 0.09966245f, 0.21758455f, 
    -0.07713596f, 0.10198033f, 0.06719735f, 0.08310322f, -0.20267673f, -0.00506222f, -0.06942790f, -0.00088406f, 
    0.01224998f, -0.23743306f, -0.07880738f, 0.05607250f, 0.00630749f, 0.14030769f, -0.05659837f, -0.03770017f, 
    -0.05342717f, 0.15968326f, -0.11531607f, 0.29511240f, 0.06159322f, 0.03891772f, -0.05452483f, 0.05265963f, 
    -0.14513075f, -0.06751624f, -0.14876127f, -0.18400079f, -0.10610237f, 0.21781373f, 0.10999496f, 0.07384399f, 
    -0.04537162f, -0.03133193f, -0.04434694f, 0.00255271f, -0.05212942f, 0.09701346f, -0.00547822f, -0.02688248f, 
    -0.20853198f, -0.01018456f, -0.23691726f, 0.21708378f, -0.06755016f, -0.03874239f, -0.03920811f, 0.08068655f, 
    -0.00668631f, 0.05472744f, -0.13749200f, 0.12225470f, -0.42515969f, 0.36790675f, -0.22961336f, 0.07418676f, 
    0.08255167f, 0.11575256f, 0.11349919f, 0.20193006f, 0.01506756f, 0.11366081f, 0.02827189f, 0.01014180f, 
    -0.20144986f, 0.13447480f, 0.05490321f, -0.03595863f, -0.04153755f, -0.06476709f, 0.12588510f, 0.08115996f, 
    0.04763626f, -0.03792056f, 0.06622577f, 0.06816131f, 0.08458467f, -0.31293809f, 0.08637832f, 0.27863362f, 
    0.00649473f, -0.10513379f, 0.04013571f, 0.03342772f, 0.05752226f, 0.01001284f, 0.01091879f, 0.14474328f, 
    0.24715415f, -0.07340050f, 0.11744259f, -0.14519536f, -0.07882920f, -0.02926205f, 0.20944744f, -0.19452231f, 
    -0.04877402f, -0.02843539f, 0.02886130f, 0.10155909f, -0.06226677f, -0.07581455f, -0.22708943f, -0.04033754f, 
    0.00202718f, 0.12982349f, 0.04831133f, 0.02231628f, 0.01888886f, 0.07663999f, -0.00181293f, -0.05993400f, 
    -0.09716447f, -0.00579208f, -0.53850019f, 0.10059537f, -0.09522302f, 0.14338435f, -0.16194721f, 0.09606043f, 
    0.08696905f, 0.10423888f, -0.00006137f, -0.00954147f, 0.05713744f, -0.19325835f, -0.03372806f, 0.12250257f, 
    -0.17303386f, 0.16713525f, -0.01299006f, -0.10119480f, -0.03882620f, -0.02895824f, 0.03881704f, 0.04847580f, 
    0.07909036f, 0.20743927f, -0.09163640f, -0.30027401f, 0.01833330f, -0.02386486f, 0.12831007f, 0.03720292f, 
    -0.02156142f, -0.07056958f, 0.15118688f, 0.02620378f, 0.00299301f, -0.14798571f, -0.10041679f, -0.13941473f, 
    0.08328274f, -0.12391085f, -0.01466096f, -0.03807308f, 0.04711325f, 0.06826300f, 0.09730971f, 0.01381018f, 
    0.30796859f, 0.09388494f, 0.12524036f, -0.14394988f, 0.01141900f, 0.08283202f, -0.13598958f, -0.12987988f, 
    0.01351347f, 0.08811720f, 0.00707946f, -0.02624688f, -0.27272221f, 0.02904852f, 0.06626781f, 0.08179051f, 
    0.05623407f, -0.05758488f, 0.24169895f, -0.19424553f, 0.05663062f, -0.20352970f, 0.05248715f, -0.04820911f, 
    -0.26573989f, 0.14645852f, -0.00607804f, 0.24281423f, 0.02310759f, 0.02947453f, 0.01800518f, -0.01795440f, 
    0.05343363f, 0.07098808f, 0.16596647f, 0.23326798f, 0.10251942f, 0.18456814f, -0.12046508f, 0.04232161f, 
    -0.05831267f, 0.03425403f, 0.03678371f, 0.03467879f, 0.14271577f, 0.01227391f, 0.00268302f, -0.04724874f, 
    0.04092582f, 0.07717266f, 0.07840889f, 0.12529549f, 0.02499810f, 0.06362906f, 0.10454725f, -0.07968388f, 
    -0.10442320f, 0.08574087f, -0.13316026f, 0.13897388f, -0.09147453f, 0.21156070f, -0.09834328f, 0.29091933f, 
    0.08690751f, -0.11992969f, 0.08437945f, 0.04004894f, -0.01370228f, 0.10588684f, -0.05950393f, 0.06912377f, 
    -0.26247552f, 0.04119972f, -0.24951604f, -0.03102137f, 0.12880889f, -0.09225310f, -0.03501498f, -0.12259791f, 
    -0.13914655f, -0.20490833f, -0.14205606f, -0.15295707f, -0.37350944f, 0.24507317f, -0.25919545f, 0.20299453f, 
    -0.06440709f, -0.10235623f, 0.23619883f, 0.07652996f, -0.18953881f, 0.03599327f, -0.04051004f, -0.05536346f, 
    0.11439796f, -0.02270811f, -0.04274172f, -0.04076797f, 0.00932999f, 0.00460209f, 0.15443373f, 0.02978482f, 
    -0.01981559f, 0.14502540f, 0.03252814f, 0.00743378f, -0.21017163f, 0.12439984f, -0.12237050f, 0.07872341f, 
    -0.24856730f, 0.11708291f, 0.04691536f, 0.04979718f, -0.06371956f, 0.20067227f, -0.00816360f, -0.00813839f, 
    -0.07298163f, -0.13256501f, 0.05377338f, -0.22193012f, 0.01432802f, -0.00496572f, 0.00581908f, -0.01101540f, 
    -0.02601620f, -0.03047218f, -0.12807378f, -0.25398117f, -0.00782824f, 0.05376419f, -0.06467153f, 0.01144162f, 
    -0.01797442f, 0.01601531f, 0.09066965f, -0.00461113f, -0.08121153f, 0.01099024f, -0.07704871f, -0.05393657f, 
    0.22686499f, -0.39845577f, 0.48524365f, 0.33638433f, 0.05968656f, -0.10718434f, 0.19319330f, -0.10491267f, 
    -0.00645864f, -0.13985012f, 0.15049464f, 0.08471683f, 0.07249427f, -0.08116014f, 0.40044758f, -0.08088675f, 
    0.07047267f, 0.09064787f, -0.00969829f, -0.00653651f, 0.00562317f, 0.14805561f, 0.11042687f, -0.10492375f, 
    -0.02514441f, 0.12667105f, 0.00339065f, -0.10287081f, 0.06422403f, -0.01431188f, 0.03864675f, 0.04266183f, 
    -0.09303125f, 0.02223154f, -0.07667651f, 0.02072078f, -0.11259355f, 0.04844496f, -0.06186452f, 0.04103984f, 
    0.20890495f, -0.10959940f, 0.03085269f, 0.03730964f, 0.02607102f, -0.03081549f, -0.00134005f, -0.05614094f, 
    -0.27362856f, -0.11527292f, -0.07517948f, 0.21983150f, -0.01863966f, 0.04856985f, 0.02780384f, -0.07880784f, 
    -0.06059251f, 0.00505736f, 0.00960152f, -0.06810311f, 0.56795919f, 0.05640475f, 0.24702054f, 0.21316917f, 
    -0.05815420f, -0.06788483f, -0.13470969f, 0.11794561f, -0.13892063f, 0.02473574f, -0.05136874f, -0.04616075f, 
    -0.25598866f, -0.27699360f, -0.07314967f, 0.01535952f, -0.00786720f, 0.02059478f, -0.05222115f, -0.05288700f, 
    -0.14254239f, -0.04615161f, 0.06730924f, -0.28332150f, -0.27733541f, -0.04334234f, 0.03627301f, -0.05341197f, 
    -0.08054466f, 0.00169523f, -0.15925516f, 0.10106308f, 0.04007803f, 0.01697069f, -0.05896540f, 0.00603364f, 
    -0.59648937f, 0.14006448f, -0.28639731f, 0.50301337f, 0.13225012f, -0.04781200f, 0.04158871f, -0.00501143f, 
    0.00783798f, 0.08274935f, 0.12515230f, -0.03201013f, -0.05380078f, 0.14039512f, 0.13688245f, 0.09645808f, 
    0.01659828f, -0.16437243f, 0.07195430f, 0.12253521f, 0.16993959f, 0.12162200f, 0.03304338f, -0.00539228f, 
    -0.24634017f, -0.04174403f, 0.03135778f, -0.05038856f, 0.02553181f, -0.37780789f, 0.15597619f, -0.14203767f, 
    0.00187372f, 0.01287774f, 0.16868021f, -0.04695452f, -0.55668736f, 0.06952544f, -0.51032585f, 0.17039248f, 
    0.06479246f, -0.04011732f, 0.10445199f, -0.11797848f, 0.07064714f, 0.13624288f, 0.13353987f, 0.16538467f, 
    0.11634777f, -0.30404428f, 0.17762020f, 0.11636434f, -0.00102254f, 0.04964564f, -0.01397830f, -0.01796929f, 
    0.02423090f, 0.08526349f, 0.20995352f, 0.02458557f, -0.27259782f, -0.41321045f, 0.29747334f, -0.06369988f, 
    -0.11507130f, 0.06273305f, -0.05072295f, 0.02934850f, 0.06578190f, 0.08582737f, 0.02357910f, -0.12213147f, 
    0.11338905f, -0.01692463f, 0.37160215f, -0.60129350f, 0.06893525f, -0.14438269f, 0.03103910f, 0.10313749f, 
    -0.00732842f, 0.11244614f, -0.01104563f, -0.14554906f, 0.32193628f, -0.00531238f, 0.31276318f, -0.23748556f, 
    0.08441551f, 0.01301208f, -0.19748636f, 0.03203266f, -0.09766144f, 0.08554480f, 0.09188645f, 0.06151792f, 
    0.00144700f, 0.06386795f, 0.12078229f, 0.10786388f, -0.11125239f, -0.10158037f, -0.20032325f, -0.21648671f, 
    0.01358536f, -0.06701947f, -0.10596520f, -0.11105253f, 0.11705542f, 0.04204234f, 0.11183173f, 0.01716582f, 
    0.00798540f, -0.00578357f, 0.08280482f, 0.05293768f, -0.11878346f, -0.03559711f, 0.05278882f, 0.10930096f, 
    0.04218034f, -0.27297574f, -0.17369582f, 0.06326120f, -0.14653152f, -0.23635378f, -0.06828471f, -0.06841419f, 
    0.03155525f, 0.04114324f, -0.05491088f, -0.07263438f, 0.32233837f, -0.12328233f, 0.39719498f, -0.06795025f, 
    0.03405997f, 0.10192644f, -0.17174353f, -0.05682360f, -0.05954139f, -0.02539601f, 0.02931660f, 0.06033206f, 
    0.51480198f, 0.29224348f, 0.12438085f, -0.02028795f, 0.02931989f, -0.07478552f, 0.14382085f, 0.07051969f, 
    -0.06881274f, 0.00949933f, 0.01287239f, 0.02071556f, -0.12109925f, -0.13593514f, -0.14462368f, -0.11392515f, 
    0.16632526f, -0.09062744f, -0.05822685f, 0.06457315f, -0.05641626f, 0.08720433f, 0.08612326f, -0.09400050f, 
    0.10259997f, 0.11665913f, -0.19705629f, -0.03313762f, -0.03690130f, 0.03405532f, -0.02057566f, 0.03019186f, 
    -0.08143049f, -0.01801855f, 0.00358455f, -0.06324945f, 0.24059530f, 0.11688481f, 0.11822188f, 0.06435126f, 
    -0.10008066f, -0.02497948f, 0.07656788f, 0.06031200f, -0.06871212f, 0.02292733f, -0.03583657f, 0.03902611f, 
    -0.15020134f, -0.15918016f, -0.10166479f, -0.07869481f, -0.01977925f, 0.04813214f, 0.09756209f, -0.05536099f, 
    0.05146881f, -0.01473208f, 0.02288329f, 0.06539899f, 0.16100532f, 0.00245364f, -0.08378086f, 0.05326696f, 
    -0.00556240f, 0.03613724f, 0.09832585f, 0.14441127f, 0.07567358f, 0.21651277f, 0.25031680f, 0.09010379f, 
    -0.55513889f, -0.49589297f, -0.29734400f, 0.24933110f, -0.14427559f, -0.01844064f, -0.04323014f, 0.00014255f, 
    -0.04259216f, 0.05818842f, 0.07083265f, -0.15987435f, -0.27533984f, -0.11880472f, -0.22687273f, -0.05356493f, 
    -0.17640157f, -0.05543759f, -0.16675510f, 0.13291040f, -0.18795954f, 0.08669561f, -0.00573133f, -0.12226585f, 
    0.22289361f, -0.07105307f, 0.09008335f, -0.05102837f, 0.04209357f, -0.00697469f, -0.18018460f, 0.08243805f, 
    0.03040144f, 0.10813511f, 0.09373097f, 0.10120212f, -0.22931814f, 0.04779004f, -0.22925396f, -0.59305876f, 
    0.05160568f, -0.00202876f, 0.03667355f, -0.02235450f, -0.09891858f, -0.04914942f, 0.02728716f, -0.11100600f, 
    -0.47790119f, 0.03185499f, -0.11447483f, 0.02419412f, -0.00379144f, 0.06659431f, 0.02533595f, 0.09853977f, 
    -0.07363535f, -0.00752797f, 0.11854533f, 0.01410818f, -0.07652222f, -0.24345292f, 0.57460845f, -0.07904959f, 
    0.10281605f, 0.05318663f, 0.20847070f, -0.19662614f, -0.08633496f, -0.01187314f, 0.08912808f, 0.04503950f, 
    -0.43249896f, 0.20801157f, -0.15178326f, -0.13152558f, 0.01392923f, 0.15940449f, -0.01892703f, -0.14625403f, 
    -0.06658643f, 0.08578970f, -0.00530218f, 0.03210781f, 0.34728938f, -0.10721544f, 0.08643872f, 0.10259939f, 
    0.24655776f, -0.04813708f, -0.11646257f, 0.09790062f, -0.00636050f, -0.04448326f, -0.00177809f, -0.06314660f, 
    -0.35821116f, 0.12057088f, -0.00893835f, 0.28598464f, -0.07547977f, 0.00238825f, 0.12465470f, -0.05580283f, 
    0.06806763f, 0.01098138f, -0.00044797f, -0.04627850f, 0.16610861f, -0.09555063f, 0.33946976f, -0.11648627f, 
    -0.05649673f, -0.05418525f, -0.25615945f, 0.10049943f, 0.04608704f, -0.06680325f, -0.06588625f, -0.05616324f, 
    0.10829331f, -0.32621706f, 0.37032413f, -0.25282583f, 0.05224128f, 0.06284945f, 0.07894429f, -0.07983912f, 
    0.05854012f, 0.12151989f, -0.17858565f, 0.08107113f, 0.04146228f, -0.05356298f, 0.12950094f, 0.14903609f, 
    0.02064005f, 0.09871349f, 0.07714672f, 0.09660316f, -0.00419072f, 0.08725207f, 0.00350383f, 0.00746597f, 
    -0.10029009f, 0.11333516f, -0.19885765f, -0.15917248f, 0.12900372f, 0.15543425f, -0.03124893f, -0.04343045f, 
    -0.03868442f, -0.05394751f, -0.08399957f, -0.03263966f, 0.09875268f, -0.04363567f, -0.15088208f, -0.34359184f, 
    -0.22810100f, -0.23980863f, -0.02014518f, -0.05665135f, 0.07105963f, -0.02066217f, 0.00191810f, -0.04451837f, 
    -0.24742910f, 0.17850769f, -0.16205375f, 0.22002283f, -0.01204445f, -0.08677131f, 0.26839730f, 0.02833694f, 
    -0.02048783f, 0.00078934f, 0.15683465f, 0.00120735f, -0.04812922f, 0.01865752f, 0.14273468f, 0.00775184f, 
    0.21096079f, -0.05181132f, 0.11993214f, -0.23662397f, 0.06311239f, -0.00698594f, -0.13580103f, -0.07268144f, 
    -0.59397602f, 0.24573904f, -0.25524014f, 0.13175075f, -0.01797740f, -0.08265112f, 0.03449198f, -0.07265816f, 
    -0.11229542f, -0.01162348f, 0.07518262f, 0.02582523f, 0.03301304f, -0.37191507f, 0.29674006f, 0.13506480f, 
    0.05569170f, 0.07550625f, -0.06471073f, 0.16103593f, -0.10026643f, -0.12109291f, 0.06600300f, -0.01448499f, 
    -0.04932060f, -0.02656877f, -0.11644407f, 0.05847917f, -0.00024792f, 0.06436709f, 0.06654665f, -0.11682864f, 
    -0.02990811f, -0.06222255f, 0.09092790f, 0.05126558f, -0.04751306f, -0.03255137f, 0.08603148f, -0.09829407f, 
    -0.07092328f, 0.17376928f, -0.26753494f, 0.11749572f, -0.03494411f, 0.10032647f, 0.02732695f, -0.05356420f, 
    -0.14627030f, -0.40748677f, 0.37211046f, -0.19098668f, -0.02161797f, 0.11409628f, 0.05149427f, 0.09902941f, 
    -0.12089553f, -0.00783281f, -0.03413671f, -0.07811096f, -0.37103969f, -0.39364254f, -0.05172555f, -0.27521223f, 
    -0.22915711f, -0.27459365f, -0.15184543f, -0.23954260f, -0.00674446f, 0.01286800f, 0.03722021f, 0.14639090f, 
    -0.06980207f, -0.55242407f, 0.04381429f, 0.00929354f, -0.14590095f, -0.05735610f, -0.14905353f, 0.00720058f, 
    0.04014314f, -0.05554119f, -0.01158765f, -0.01213463f, 0.04611941f, 0.08753718f, 0.22090967f, -0.07375310f, 
    -0.12593324f, -0.12130101f, -0.12433582f, -0.05284776f, -0.04535497f, -0.02956396f, 0.00673311f, -0.11704732f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14537457f, 0.05974683f, 0.07849369f, -0.06747217f, -0.07863186f, 0.11017089f, 0.02555001f, -0.12888375f, 
    0.04087297f, 0.03843614f, 0.03092872f, -0.00818670f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
