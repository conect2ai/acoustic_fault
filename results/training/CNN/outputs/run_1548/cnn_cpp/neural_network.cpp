#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.30837220f, 0.28576267f, 0.27507335f, 0.24509391f, 0.10739615f, -0.69825357f, 0.41250941f, 0.78137547f, 
    0.36710238f, -0.56254387f, -0.32465452f, -0.41104156f, -0.04986225f, -0.54670542f, -0.53570968f, -0.41255826f, 
    -0.61712974f, -0.47079656f, 0.71981907f, 0.72562647f, 0.79339170f, -0.19424978f, -0.59375423f, -0.62404019f, 
    0.07791571f, -0.03683446f, -0.03124442f, 0.50963908f, 0.47349235f, 0.43015224f, -0.84306979f, 0.78588635f, 
    -0.02134614f, -0.14867093f, 0.40633690f, 0.54536307f, -1.13637459f, 1.33751845f, -1.15459645f, -0.50274098f, 
    -0.13692443f, 0.76613337f, -0.37312543f, -0.46577349f, 0.00766265f, -1.22884083f, -0.41237223f, -1.10232127f, 
    0.66918778f, 0.30931357f, 0.84626555f, 0.80504978f, 0.05318483f, 0.24987042f, -1.17439032f, -0.23275965f, 
    0.29138762f, -0.63065314f, -0.52209693f, -0.96237582f, 0.09536353f, 0.10870530f, -0.51015484f, -0.46191013f, 
    -0.57301247f, 0.41690400f, 0.36707994f, 0.45711496f, 0.02837776f, -0.24645889f, -0.46539041f, 0.88355547f, 
    0.37065366f, -0.17765069f, 0.60207444f, 0.21106941f, 0.02379179f, 0.05524118f, -0.10953033f, 0.06703909f, 
    0.38825518f, 0.12372486f, 0.11932498f, 0.51258832f, 0.63056743f, -1.14985275f, -0.67520875f, 0.05328061f, 
    0.05055360f, 0.75177675f, -0.70440203f, -0.51322794f, -0.90364450f, -0.11544260f, -0.44008309f, -0.15514517f, 
    0.57077998f, 0.76617891f, 0.49439672f, 0.59896785f, -1.33743429f, 0.78990561f, 0.89805448f, -0.40618142f, 
    -0.55721229f, -0.21587235f, 0.55274600f, -0.31399831f, 0.70196563f, 0.55374539f, 0.06879546f, 0.74506831f, 
    -0.44279668f, -0.81589770f, -0.25022486f, -0.28947783f, -0.26478130f, 0.02157828f, -0.65085882f, -1.07702923f, 
    0.45427659f, -0.51854575f, -0.36976889f, -0.37165427f, 0.70066756f, -0.60396081f, -0.38117412f, -0.44294766f, 
    0.29810679f, 0.78056157f, 0.73004699f, -0.01156006f, -0.69205868f, -0.81481749f, 0.04983449f, -1.07029116f, 
    0.37392065f, 1.18375707f, 0.32220837f, 0.30203077f, -0.37539071f, -0.39346224f, -0.54643321f, -0.10628825f, 
    1.01169848f, -0.74235535f, -0.70786887f, -0.68778998f, -0.59862655f, -0.70691311f, -0.25439256f, -0.47549233f, 
    -0.32211018f, -0.84704584f, -0.76044536f, -0.96840757f, 0.67471880f, 0.71705157f, 0.43672985f, 0.03613940f, 
    -0.34804407f, -0.76083583f, 0.80695301f, 0.56156355f, 0.75742912f, 0.39164582f, 0.05065539f, 0.26046276f, 
    0.28253686f, -0.18911988f, -0.00204286f, -0.35711253f, 0.58195704f, 0.31635803f, 0.43843973f, 0.86511230f, 
    0.89174467f, -0.02460216f, 0.43825072f, -0.01159567f, -0.10173534f, -0.21976799f, -0.06040613f, -0.45542049f, 
    -0.71662658f, -0.95277876f, 0.80951029f, 0.72091246f, 0.26379040f, -0.00198130f, -0.71142614f, -0.26700664f, 
    0.47528610f, -0.46958491f, -0.77407831f, -0.36814564f, -0.44427416f, 0.03772169f, -0.49568492f, 0.52510077f, 
    -0.25863373f, -0.12666619f, 0.18703981f, -0.06975182f, -0.30999362f, 0.91371053f, -0.61543620f, -0.76272470f, 
    -0.67907691f, 0.30135471f, -0.36534375f, 0.03714285f, -0.15558779f, -0.49527264f, -0.64258820f, -0.05718133f, 
    -0.80800098f, 1.15007591f, -0.55759412f, -1.04383218f, 1.35816991f, -0.55660015f, -0.20600653f, -0.27900264f, 
    0.02425667f, 1.08908868f, -0.01174544f, -0.33026814f, 0.65155578f, 0.63814944f, 0.40730906f, -0.77036721f, 
    0.55814916f, -0.72799385f, 0.10443076f, 0.21449684f, 0.79821593f, -0.52206063f, 0.18769322f, 0.21250671f, 
    0.25252283f, 0.38640374f, -0.80371934f, -0.16526487f, 0.73682851f, -0.30514002f, -0.74015075f, -0.79910707f, 
    -0.85742551f, -0.14609921f, -0.48029450f, 1.00153577f, 0.91231662f, 0.11085055f, -0.99208844f, -0.54097778f, 
    -0.33841011f, 0.68058383f, -0.14217737f, 0.40589333f, 0.41023067f, 0.78640062f, -0.71696371f, -1.42474759f, 
    0.01995322f, 1.33687675f, 0.20096573f, -0.18940820f, 0.04501238f, -0.16500600f, -0.38278127f, -0.13535401f, 
    0.04947317f, 0.18599270f, 0.42689383f, 1.02993596f, -0.09142918f, -0.13460767f, 0.64011115f, 0.09844058f, 
    1.08696556f, -0.69367409f, -0.03270656f, -0.04164523f, -0.03398841f, -0.62680554f, 0.66793478f, -0.00329546f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.35992503f, -0.11155189f, -0.01059941f, 0.46808058f, 0.39452904f, 0.13276054f, -0.54236180f, 0.21505335f, 
    0.50462765f, -0.19507840f, -0.06170358f, -0.06723422f, 0.57141471f, -0.34453085f, 0.03650488f, 0.22944966f, 
    0.06912084f, 0.27122971f, 0.13128249f, 0.22447129f, -0.21392012f, 0.32234955f, 0.73759043f, -0.63014036f, 
    -0.09549783f, -0.08008622f, 0.47831208f, 0.41001838f, 0.34919640f, -0.08040920f, -0.32817376f, -0.15403859f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.24936852f, -0.09529538f, 0.04728086f, -0.02577896f, -0.07864603f, -0.09833719f, 0.15694812f, -0.08532297f, 
    0.01240690f, -0.22329819f, -0.20970784f, -0.24028331f, -0.21632683f, -0.15161283f, -0.01155025f, -0.04179245f, 
    0.01958760f, 0.03129503f, 0.08251290f, -0.16381943f, -0.18600249f, -0.18560255f, -0.10040043f, -0.16540667f, 
    -0.02016808f, 0.06131106f, 0.03523798f, 0.16658880f, 0.05190588f, 0.05833489f, 0.01200330f, 0.05050578f, 
    0.06994859f, -0.03122818f, 0.04357263f, -0.12719716f, 0.15916950f, -0.00117958f, -0.50028801f, -0.07340238f, 
    0.07978571f, 0.28550285f, 0.08167226f, 0.05189164f, -0.01301024f, 0.15043305f, 0.11903052f, -0.32869443f, 
    -0.09135336f, 0.08357866f, 0.14582525f, 0.03754228f, 0.09921284f, -0.06377706f, 0.02881545f, -0.17244327f, 
    -0.34208298f, -0.19638473f, -0.06874408f, 0.08062954f, -0.03458556f, -0.02692532f, -0.00778325f, -0.01966589f, 
    0.13755000f, -0.14664248f, 0.02947391f, 0.04219925f, -0.23058268f, 0.14485702f, -0.11101624f, 0.19810978f, 
    0.13909082f, 0.08724245f, -0.10784087f, -0.08593812f, -0.00600169f, 0.08982277f, 0.12790927f, -0.03002951f, 
    -0.06590619f, -0.53134656f, 0.15972780f, 0.61443669f, -0.09036396f, -0.10412075f, -0.05620601f, 0.03611267f, 
    0.11586317f, 0.18310705f, -0.08533042f, 0.18484551f, -0.24606059f, -0.07476281f, 0.01138508f, -0.17921595f, 
    -0.16881874f, -0.10228013f, -0.17018016f, -0.71574396f, -0.44173282f, 0.48094556f, 0.06792898f, 0.28442293f, 
    0.06731115f, 0.28086114f, -0.01852136f, -0.01619673f, 0.01538274f, 0.11357395f, 0.07789707f, -0.09384489f, 
    -0.00278088f, -0.15736271f, 0.08656691f, 0.09855433f, 0.18757474f, 0.07328778f, -0.00982916f, -0.11275925f, 
    0.00141350f, 0.04063299f, -0.01974113f, -0.09928624f, 0.00170824f, 0.12766550f, 0.22792481f, -0.19106367f, 
    -0.11401428f, 0.03132506f, 0.13211775f, -0.17939572f, -0.03664665f, -0.09456280f, 0.26105011f, 0.09709327f, 
    -0.12985729f, -0.20551759f, -0.05295404f, 0.07116631f, -0.25788492f, 0.30193782f, 0.17983755f, 0.19280361f, 
    -0.54432875f, -0.86817956f, -0.35655913f, -0.16150071f, 0.04261379f, 0.22561215f, 0.04604043f, 0.07757564f, 
    0.03656964f, 0.01944247f, -0.08027777f, -0.35738114f, 0.24621232f, 0.20570201f, 0.14188471f, -0.20302059f, 
    0.13156593f, 0.10201047f, 0.25107068f, 0.09433237f, -0.14029966f, -0.16354713f, -0.08564342f, -0.20916528f, 
    0.01663178f, 0.07645462f, -0.03790986f, 0.11898687f, -0.05490670f, -0.20923704f, -0.01807191f, -0.12482180f, 
    0.13848028f, 0.01524626f, -0.20562673f, -0.02128105f, -1.01269913f, -0.66986442f, 0.29647839f, -0.06271916f, 
    0.07402829f, -0.30907425f, -0.00286891f, -0.03940627f, -0.05283601f, -0.38680434f, -0.39684439f, 0.13248031f, 
    -0.20084952f, -0.06085070f, 0.02793443f, 0.00894271f, -0.05947698f, 0.08741242f, 0.23873304f, 0.23909397f, 
    0.53069592f, 0.21527557f, 0.09939961f, 0.10741705f, 0.29281014f, 0.14920942f, 0.18030496f, -0.30984765f, 
    -0.11745868f, -0.52348542f, -0.25124344f, -0.05229785f, 0.10276700f, -0.01419334f, 0.02651246f, -0.04144336f, 
    -0.59075373f, -0.18353318f, 1.15340710f, 0.09291725f, 0.19562788f, 0.28195095f, 0.10495970f, 0.03682853f, 
    -0.27610722f, -0.10108631f, -0.10546332f, 0.18621010f, -0.01731847f, -0.06743649f, -0.08558542f, 0.01859457f, 
    0.04087856f, 0.06287393f, 0.22888437f, -0.01593740f, 0.05004374f, -0.10764460f, -0.06944568f, -0.16048308f, 
    -0.17455006f, 0.21932228f, 0.15537314f, -0.75959551f, -0.16258800f, 0.07262921f, 0.07649066f, -0.03833884f, 
    0.09590641f, 0.07142775f, 0.05161849f, 0.12910810f, 0.32581705f, -0.28942239f, -0.26466963f, 0.03859141f, 
    -0.00493574f, 0.26669961f, 0.10412043f, 0.04110665f, 0.09605078f, -0.37538809f, -0.36466557f, 0.28201461f, 
    0.12474996f, -0.05555984f, 0.07455366f, -0.05279632f, 0.00616228f, -0.10126224f, -0.01394622f, 0.13220944f, 
    -0.50616860f, -0.11824154f, -0.02489377f, -0.06151646f, 0.04387822f, 0.00036224f, 0.10785349f, -0.11853403f, 
    -0.08037883f, 0.40069860f, 0.10087325f, -0.27323169f, 0.19002977f, 0.12547562f, -0.21150827f, 0.12877227f, 
    -0.04792831f, -0.15498853f, -0.17501962f, 0.02525663f, -0.03269206f, -0.24192640f, 0.01423713f, 0.09021720f, 
    -0.05978376f, 0.18585634f, -0.16422470f, -0.11255258f, -0.09182729f, -0.03181194f, -0.03613855f, -0.02229206f, 
    0.08582189f, 0.07614082f, 0.34044743f, -0.02051735f, 0.02008377f, -0.03159672f, 0.05160389f, -0.12397426f, 
    0.09538373f, 0.00750508f, 0.04295761f, 0.22323680f, 0.00439399f, 0.02990165f, 0.03003267f, -0.02926100f, 
    0.08123337f, -0.01929157f, 0.15520138f, 0.02983020f, -0.39674011f, 0.23329128f, -0.24774559f, -0.03169414f, 
    -0.08190883f, -0.22268826f, 0.09460080f, -0.07729197f, 0.01804029f, -0.59732866f, 0.01866651f, 0.15672034f, 
    -0.12912434f, 0.04306161f, 0.07452621f, -0.15851122f, 0.08697907f, -0.00813738f, -0.25579903f, -0.15157448f, 
    0.12166172f, -0.01796353f, -0.11459900f, 0.08355049f, 0.03786898f, 0.14805800f, 0.11675491f, -0.23602271f, 
    0.09522337f, 0.19228384f, -0.05220423f, 0.03111562f, -0.03033115f, 0.09699894f, -0.12127825f, 0.00019186f, 
    -0.01379816f, 0.00747694f, 0.07667107f, -0.01739183f, 0.09961574f, 0.04193198f, -0.02837557f, -0.01849703f, 
    -0.05611894f, 0.10863554f, -0.07640472f, 0.03209217f, -0.05164984f, -0.01054758f, -0.11213259f, 0.20840310f, 
    0.08221347f, 0.02333128f, -0.36927474f, 0.28962910f, -0.01248075f, 0.02051119f, 0.02797298f, 0.03691780f, 
    0.02853900f, -0.02984806f, -0.02980491f, -0.02429437f, -0.50902790f, 0.63743544f, -0.30321023f, 0.45251986f, 
    0.40027764f, 0.09885401f, 0.10283124f, 0.03756233f, -0.02333983f, -0.11799841f, 0.19238971f, 0.03628940f, 
    0.10366444f, -0.01957990f, 0.05734145f, -0.07432292f, 0.04420196f, 0.21893254f, 0.08546332f, -0.11630796f, 
    -0.06994950f, 0.07587720f, -0.16623665f, 0.08443486f, 0.01844504f, -0.03470857f, -0.11896797f, 0.05228182f, 
    0.10467415f, -0.08022584f, 0.07406938f, -0.10405128f, 0.00176264f, -0.06192839f, -0.00640587f, -0.43390626f, 
    0.05807068f, 0.36839309f, 0.03536890f, 0.03506522f, -0.07230919f, 0.09482410f, 0.06748067f, 0.05429623f, 
    -0.11958425f, -0.49199677f, -0.33115599f, -0.00044423f, -0.06182265f, 0.18531545f, -0.06373011f, 0.15325379f, 
    0.05914541f, -0.03208578f, -0.04427443f, -0.16640197f, 0.03636250f, -0.13444529f, -0.21768816f, -0.22029120f, 
    0.01273464f, 0.10011122f, 0.12303839f, 0.03314534f, 0.15566543f, 0.02853743f, -0.01950232f, -0.09685119f, 
    -0.05661353f, -0.12341277f, 0.02956981f, -0.19271916f, -0.13325801f, -0.02754744f, 0.04009351f, -0.08956897f, 
    -0.05869091f, 0.06600446f, 0.04104637f, 0.14630039f, -0.18116325f, 0.08641782f, -0.38212126f, 0.05419390f, 
    0.03807678f, -0.20569734f, 0.05835347f, 0.18880641f, -0.06618484f, 0.16061589f, -0.25564721f, -0.02377921f, 
    -0.12064587f, -0.09023324f, 0.01621118f, 0.06871852f, -0.00141218f, 0.00487343f, -0.12181921f, 0.03313989f, 
    0.18218780f, 0.20386215f, 0.11977141f, 0.24745116f, 0.20526463f, 0.07768651f, 0.22294278f, 0.06114946f, 
    -0.14888540f, 0.17287046f, -0.05281912f, -0.07041214f, 0.04459998f, 0.02843274f, 0.05999200f, 0.10826837f, 
    -0.48803738f, 0.01873145f, 0.78188711f, -0.14247723f, 0.05670536f, -0.02401442f, 0.12551987f, -0.05876011f, 
    0.06407575f, 0.04726742f, -0.11546748f, 0.15610202f, -0.00624381f, -0.02575531f, -0.18418968f, -0.18985219f, 
    -0.02908671f, 0.13171269f, 0.11287914f, 0.07776436f, 0.17368364f, 0.00784450f, 0.06008107f, -0.11549879f, 
    -0.07201485f, 0.11254666f, 0.08923811f, 0.07426763f, 0.24567623f, -0.51348561f, 0.15841664f, -0.07991240f, 
    0.11868726f, 0.25570962f, 0.13673502f, 0.10974126f, 0.28409332f, 0.12918554f, -0.19055384f, 0.02195122f, 
    0.10293692f, 0.17044462f, 0.09262881f, 0.12081347f, 0.07596913f, 0.10770484f, -0.04328743f, -0.07880042f, 
    0.15044904f, 0.05682213f, -0.16326140f, -0.01634354f, -0.11495967f, -0.01997007f, -0.14053774f, 0.03716016f, 
    -0.08512104f, -0.07189052f, -0.11007087f, -0.03443037f, -0.06772155f, -0.03812084f, 0.00210600f, 0.15256889f, 
    -0.12680794f, 0.13072424f, 0.09832461f, 0.17561099f, -0.12493049f, -0.03863283f, -0.06748854f, 0.05417687f, 
    -0.16942392f, -0.23646359f, -0.26371324f, -0.13116854f, 0.07357220f, -0.05577067f, 0.16148469f, 0.32725397f, 
    0.04347785f, -0.28795391f, -0.06730469f, 0.08637235f, 0.07579182f, -0.01534192f, 0.05840257f, 0.03128649f, 
    0.02287129f, -0.03320873f, -0.47906858f, -0.29438633f, -0.48424107f, 0.00671425f, -0.00815669f, 0.07072752f, 
    0.09129688f, 0.09115185f, -0.12507516f, -0.37098524f, -0.25952411f, -0.36839274f, -0.05882312f, 0.02348798f, 
    0.04080484f, -0.03623120f, 0.26187229f, 0.02845504f, 0.36297876f, 0.02532035f, 0.03157540f, -0.00671741f, 
    0.21954948f, 0.17487147f, -0.03991755f, 0.20482549f, -0.40217668f, -0.49718785f, 0.13065237f, 0.09852801f, 
    0.17528379f, 0.22356750f, 0.18147494f, -0.02733777f, 0.00754881f, -0.01409752f, -0.23697197f, -0.30970824f, 
    0.10185762f, -0.09037623f, -0.20528321f, -0.01997313f, -0.19382691f, 0.10995726f, -0.28091764f, 0.04924379f, 
    0.00519900f, -0.17388403f, -0.02445314f, 0.04824347f, -0.09808322f, 0.10067253f, 0.03072270f, 0.14058025f, 
    0.22176285f, -0.19403851f, -0.20623496f, -0.02944199f, 0.10671045f, -0.12743568f, -0.04580302f, 0.13771179f, 
    0.15455145f, -0.23648086f, -0.15508196f, -0.12568155f, -0.11438857f, 0.14541554f, -0.19077013f, 0.10242071f, 
    0.13831858f, -0.02118350f, -0.14018306f, -0.28636789f, 0.25553662f, -0.15027522f, 0.08632249f, 0.08554123f, 
    0.00640955f, 0.02617365f, 0.08269431f, 0.38653749f, -0.19585793f, -0.45782128f, -0.13594851f, 0.14175741f, 
    -0.02498658f, -0.17273174f, 0.13707173f, 0.14421494f, -0.00031255f, 0.12491564f, 0.12906089f, 0.14169513f, 
    -0.10411890f, -0.21261548f, 0.14513423f, 0.11773235f, 0.25263065f, -0.22079328f, -0.11634272f, 0.17578161f, 
    -0.04062803f, -0.07575589f, 0.23340914f, 0.13695116f, -0.13223313f, 0.02827190f, 0.02899363f, 0.03850754f, 
    0.02562624f, 0.09400459f, -0.06838568f, -0.28705791f, -0.01050759f, -0.07718872f, -0.19207725f, 0.39852804f, 
    0.20528473f, 0.41104004f, -0.04843125f, -0.18922997f, -0.22616982f, -0.15170097f, -0.12144920f, 0.08196970f, 
    0.13743705f, 0.09437108f, 0.05852168f, -0.03206290f, -0.04433542f, 0.14946465f, 0.11227722f, -0.03955671f, 
    0.00265609f, -0.20774092f, 0.36057416f, 0.08207805f, 0.21014230f, 0.05804607f, 0.17049053f, 0.04647854f, 
    -0.11864300f, -0.10293058f, -0.05350572f, -0.16362785f, -0.25696382f, -0.05963177f, -0.22040823f, -0.11643196f, 
    0.00133725f, 0.18579020f, 0.11131016f, -0.16732568f, -0.26742080f, -0.34937325f, -0.00847242f, 0.03782904f, 
    -0.25426117f, 0.01590402f, 0.00054677f, -0.06144107f, -0.12239262f, -0.32449093f, 0.06004404f, -0.08744879f, 
    -0.09928603f, -0.07064754f, 0.07294117f, -0.03914459f, 0.19876570f, -0.08510195f, 0.10117230f, 0.15069102f, 
    0.14649300f, -0.12101495f, -0.03464287f, 0.16458353f, -0.22314604f, 0.00471637f, 0.10984644f, 0.14291225f, 
    0.34705117f, 0.06199423f, -0.00563681f, 0.17161453f, 0.10637162f, -0.05680211f, 0.38475543f, -0.09884994f, 
    0.02281161f, 0.13142699f, -0.06924805f, -0.19176908f, -0.26559013f, 0.02554769f, -0.00311019f, -0.30177259f, 
    0.08427227f, -0.05691500f, 0.03436531f, -0.33755106f, -0.06624214f, -0.00624220f, 0.08892876f, 0.03319239f, 
    -0.06760870f, -0.26961285f, -0.00009400f, 0.00187717f, 0.15965900f, -0.20587939f, -0.43325305f, -0.16318464f, 
    0.03829223f, 0.18503407f, 0.11222272f, -0.16987243f, -0.00029356f, 0.02413495f, 0.13958387f, -0.18110536f, 
    0.00599258f, 0.21446739f, 0.28936028f, -0.01715064f, -0.04078112f, 0.20829119f, -0.01829459f, 0.10778783f, 
    0.02168486f, 0.04855884f, 0.11958243f, -0.01542277f, 0.48426765f, 0.10265134f, 0.37203246f, 0.05076011f, 
    -0.04507811f, 0.04153732f, 0.10732953f, 0.17925684f, 0.13669108f, 0.20414951f, 0.47677010f, 0.15108882f, 
    0.08081718f, -0.02624011f, -0.11412966f, 0.00819939f, -0.48594159f, 0.09332720f, -0.26791236f, -0.03420608f, 
    -0.14260495f, -0.05930044f, 0.03115375f, -0.26421294f, 0.13253117f, 0.08247738f, -0.16973995f, -0.16337293f, 
    -0.07330159f, 0.15980864f, 0.00831324f, -0.28165361f, 0.10576139f, 0.11060668f, -0.09462888f, 0.11217545f, 
    -0.03866035f, -0.00157891f, -0.07485577f, -0.07828178f, 0.07830845f, 0.06844740f, 0.22367685f, -0.06016692f, 
    0.19440807f, -0.08785645f, -0.01065064f, -0.12896478f, -0.12705082f, -0.11169328f, -0.00900586f, 0.14329965f, 
    0.06399139f, -0.13573851f, 0.11596458f, 0.17537832f, 0.01545621f, -0.08991457f, -0.29461151f, -0.13328461f, 
    0.05517737f, 0.17857349f, 0.12320362f, 0.18116440f, -0.12099873f, 0.10853969f, -0.09629408f, -0.10667572f, 
    -0.04892576f, 0.06996227f, 0.10988168f, 0.03438690f, 0.04072996f, 0.13667600f, -0.03191384f, 0.18725149f, 
    0.04938706f, 0.20729357f, -0.02186477f, 0.07798892f, -0.12742876f, -0.05668863f, -0.01162446f, -0.08834604f, 
    -0.13056780f, 0.19666414f, 0.02688644f, 0.03887603f, 0.01692292f, -0.09111864f, -0.23521756f, -0.10827070f, 
    -0.34251297f, -0.10212863f, -0.04302015f, -0.21494059f, 0.03857938f, 0.02286608f, 0.14371377f, 0.07497516f, 
    0.08642840f, 0.02289955f, -0.02768745f, 0.10385834f, -0.01936630f, 0.02878432f, 0.16972579f, -0.17977667f, 
    0.25859153f, 0.14907128f, 0.01478350f, -0.05146584f, 0.04727170f, -0.04905547f, 0.09185987f, 0.16098672f, 
    -0.00617005f, -0.48889515f, 0.09353993f, -0.09815137f, 0.16238600f, -0.18612717f, -0.09710150f, 0.16737445f, 
    0.30216280f, 0.05067930f, -0.05969734f, 0.01198184f, -0.13866790f, -0.01403114f, -0.02058574f, -0.10230821f, 
    0.10061146f, -0.08092632f, 0.10357885f, -0.10099443f, 0.12085380f, -0.27798921f, -0.01625243f, -0.05233544f, 
    0.28406787f, 0.11637599f, 0.08526601f, 0.00893757f, 0.15478714f, 0.19249053f, 0.09636853f, 0.07465644f, 
    -0.00537541f, -0.19848312f, 0.01827983f, 0.17056012f, 0.08515035f, 0.39542484f, 0.20355973f, 0.24155401f, 
    -0.04034019f, -0.03255624f, 0.14089781f, -0.01559350f, -0.03008431f, -0.09453087f, -0.13680921f, -0.12049443f, 
    0.06829844f, -0.05036853f, 0.10092305f, -0.21978860f, -0.02608556f, -0.10061099f, -0.27107847f, 0.16110350f, 
    0.06088155f, 0.02508280f, 0.08370522f, 0.00684544f, -0.30078247f, 0.18042438f, 0.01263129f, -0.00019014f, 
    -0.11146850f, 0.00874825f, -0.32436451f, 0.05149527f, -0.04993118f, -0.20388855f, -0.01863749f, 0.18353114f, 
    -0.09590104f, -0.13727595f, 0.20735492f, 0.08955427f, -0.01638362f, 0.18397842f, -0.22269286f, -0.05109757f, 
    -0.12897636f, -0.34777772f, 0.26328772f, 0.16568151f, 0.07963933f, -0.16745760f, -0.12584355f, -0.13660163f, 
    0.03248397f, -0.00700132f, 0.12903981f, 0.14852929f, -0.04747161f, -0.03051624f, -0.06820865f, -0.02750278f, 
    -0.05644425f, 0.04734089f, -0.19370094f, 0.07930414f, -0.35239518f, -0.05203366f, -0.19174959f, -0.04448652f, 
    -0.07286162f, -0.10499708f, 0.24378322f, -0.00681508f, 0.27936313f, 0.08133344f, -0.07663627f, 0.22546992f, 
    0.00438456f, -0.09222441f, -0.03912091f, 0.02305859f, 0.05942689f, -0.09879328f, 0.12645367f, 0.04451658f, 
    0.25196075f, 0.01084004f, 0.02532728f, 0.14899325f, 0.18971148f, -0.20482013f, 0.33824277f, -0.15884897f, 
    -0.06910676f, -0.09267472f, -0.34995735f, -0.19309144f, -0.01797334f, 0.02898450f, 0.09951697f, -0.15322782f, 
    -0.22193535f, -0.79575437f, 0.35798812f, 0.13742919f, -0.00445792f, 0.04628512f, -0.26309016f, -0.10690425f, 
    -0.17572919f, 0.05963072f, -0.04830533f, 0.01881484f, -0.15143293f, -0.05230717f, -0.12619443f, -0.02624104f, 
    0.01250731f, -0.00568829f, 0.20414570f, 0.07769124f, 0.31206277f, -0.04100388f, -0.06547240f, -0.11339039f, 
    0.06645539f, -0.06990939f, 0.18670630f, -0.39220148f, -0.05320753f, 0.10559540f, 0.04582077f, 0.05793530f, 
    -0.09435342f, 0.00654731f, 0.19315746f, -0.09848843f, 0.16774131f, -0.20487140f, 0.04489373f, 0.19034983f, 
    0.11499410f, -0.19884168f, 0.10481427f, 0.27832791f, 0.01567435f, -0.05136015f, 0.12575097f, 0.17461625f, 
    -0.05342438f, 0.10707167f, -0.22942679f, -0.04395130f, -0.32764664f, -0.07850381f, -0.00759613f, 0.03959177f, 
    -0.07071732f, 0.00656168f, 0.10256548f, -0.10344967f, 0.00458670f, 0.07593796f, 0.11020333f, 0.22713198f, 
    -0.31316507f, 0.26069841f, -0.15672234f, 0.00678945f, 0.13348296f, -0.11663339f, 0.06624209f, -0.02155953f, 
    0.16121697f, -0.16021407f, 0.14980122f, 0.14738847f, -0.14259481f, -0.01762679f, 0.05957098f, 0.15117230f, 
    -0.20992950f, 0.41942382f, 0.21238068f, 0.37712947f, 0.15863688f, 0.18351457f, 0.09604068f, 0.07734701f, 
    0.02948099f, -0.05458814f, 0.06280883f, -0.64753139f, -0.03262780f, -0.19258435f, -0.25981990f, -0.21312605f, 
    0.02574277f, 0.02563461f, 0.12239593f, 0.67533630f, -0.32367888f, 0.00273913f, -0.01958089f, 0.08544725f, 
    -0.06192812f, 0.12257442f, 0.26592162f, 0.09189926f, -0.82485974f, 0.17548072f, 0.22179519f, 0.02491912f, 
    0.06634904f, 0.06023119f, 0.18185161f, -0.11946397f, -0.13194682f, -0.26447865f, -0.34405953f, -0.47874644f, 
    0.04292110f, 0.17367768f, 0.18884464f, -0.15285128f, 0.15138490f, 0.07491218f, 0.27739015f, 0.25190747f, 
    0.12648092f, 0.00393276f, -0.07709195f, -0.23993783f, -0.00394960f, -0.01080556f, 0.12046422f, -0.33831385f, 
    -0.16731018f, 0.34012035f, -0.18122554f, -0.10573713f, 0.32521015f, -0.04953487f, -0.14649832f, 0.27328503f, 
    -0.00438874f, 0.11035725f, -0.22829857f, -0.00806241f, 0.06582428f, 0.16728245f, 0.06127917f, 0.13362619f, 
    0.08283016f, -0.37251866f, -0.47970304f, -0.41767058f, -0.09858825f, -0.26933485f, -0.16190577f, -0.12757201f, 
    -0.02877086f, 0.08902052f, -0.10663176f, 0.17326316f, -0.01498022f, -0.10847858f, 0.03403761f, -0.03076989f, 
    -0.15913503f, 0.08157167f, -0.00071520f, 0.25292322f, -0.94918209f, -0.56966352f, 0.05866669f, -0.60110652f, 
    0.04845709f, 0.15023260f, -0.31475365f, -0.02835099f, -0.20076005f, -0.18357092f, -0.55584329f, 0.00138115f, 
    -0.08225155f, -0.13551202f, -0.10620011f, 0.05806062f, 0.02144346f, 0.31285685f, 0.31817088f, 0.15530625f, 
    -0.25186715f, 0.12296094f, 0.04299179f, 0.00615035f, 0.09994985f, -0.08795922f, 0.31254926f, -0.36518312f, 
    0.42804807f, 0.05297674f, 0.00719824f, 0.05780207f, 0.26230913f, -0.04120300f, 0.11294473f, -0.79739088f, 
    -0.55855185f, -0.34160361f, 0.04710348f, 0.01295521f, -0.05550820f, 0.14843661f, 0.05967239f, -0.14727028f, 
    0.22702138f, 0.27562743f, 0.26088217f, 0.05796078f, -0.12134870f, -0.03147455f, 0.01135198f, -0.00257989f, 
    -0.03156118f, 0.42023957f, -0.07769720f, 0.44727308f, 0.16811487f, 0.02016367f, 0.19110654f, 0.21393538f, 
    0.04518888f, -0.17364776f, 0.28657499f, -0.06389108f, 0.23634297f, -0.11492135f, 0.01669046f, 0.00788319f, 
    -0.00816618f, 0.08502230f, 0.07202119f, -0.45461696f, -0.11446588f, -0.23652481f, -0.23431937f, -0.23445256f, 
    -0.01746649f, 0.20054461f, 0.09932386f, 0.14993429f, 0.03080024f, 0.27352390f, 0.17175765f, -0.36624023f, 
    -0.06200419f, 0.00950053f, 0.09391345f, 0.14634006f, -0.03597402f, 0.34873277f, 0.13324180f, 0.23743105f, 
    0.06701259f, 0.12807907f, 0.14280728f, 0.12368660f, 0.02502092f, 0.18200311f, -0.33230391f, -0.35032302f, 
    -0.05933504f, -0.02910854f, 0.00191163f, -0.09674439f, -0.18312934f, 0.15934576f, -0.25790441f, 0.57494080f, 
    0.07424917f, 0.35334870f, 0.01779985f, 0.00410530f, 0.15662338f, 0.20674425f, -0.04427068f, 0.04376354f, 
    -0.73218787f, -0.96761072f, 0.02161753f, 0.05901070f, -0.06891081f, -0.06546332f, 0.24695450f, 0.36459768f, 
    -0.04156753f, 1.71461499f, -0.31436113f, -0.43896675f, -0.02738114f, -0.51718676f, -0.00846561f, -0.18532622f, 
    0.20193592f, -0.05538319f, 0.08127107f, -0.35848144f, 0.15093662f, -0.09738471f, 0.12495989f, -0.24405482f, 
    -0.06001886f, -0.10788397f, 0.07532866f, -0.02999172f, -0.03665632f, 0.04089419f, 0.10858694f, -0.33102494f, 
    -0.16009001f, -0.00646281f, 0.05776616f, 0.22082046f, 0.15226480f, -0.09135167f, 0.10875083f, -0.02515375f, 
    0.00797571f, 0.13438885f, 0.24603768f, 0.05009907f, 0.00457209f, 1.12535179f, -0.62532628f, -0.16410698f, 
    -0.03512134f, -0.01913221f, 0.16538899f, 0.10611221f, -0.07314058f, 0.12873261f, -0.23693354f, -0.59190893f, 
    -0.26220837f, -0.49845502f, 0.04004491f, -0.09004071f, 0.29409125f, 0.01561501f, 0.25394124f, -0.65066427f, 
    -1.38524389f, -0.64472020f, 0.06317120f, -0.19542740f, -0.03504058f, -0.09660803f, 0.00104560f, -0.34141791f, 
    0.00958731f, -0.05150863f, 0.02319709f, 0.03571665f, -0.02925495f, -0.04478508f, 0.04208157f, -0.01257679f, 
    0.03259733f, -0.01148876f, -0.04833426f, 0.02640786f, 0.04840563f, -0.03079130f, 0.00796238f, 0.02858005f, 
    0.02683225f, 0.01862276f, 0.00738789f, -0.02922515f, -0.03647527f, 0.03924303f, -0.00322341f, 0.00573693f, 
    -0.01889839f, 0.00678462f, 0.01458148f, -0.03869446f, -0.03659440f, 0.04738456f, -0.02447495f, -0.03998762f, 
    -0.00425552f, 0.04977323f, 0.03405124f, 0.04430065f, -0.04194278f, -0.04251510f, -0.06138877f, -0.06237668f, 
    0.00821033f, -0.03369484f, -0.00493206f, 0.03154113f, 0.00676533f, 0.00118599f, -0.03379524f, -0.03683490f, 
    -0.03764121f, -0.04392634f, 0.01826652f, -0.00299384f, -0.05627906f, -0.02087516f, 0.03475773f, -0.06504735f, 
    0.04850911f, 0.00740612f, 0.04836963f, -0.00152152f, 0.01543035f, -0.03974562f, 0.01434115f, -0.05734716f, 
    0.04026815f, -0.01961525f, 0.00029468f, -0.05649696f, 0.05397225f, -0.06698935f, -0.03048256f, -0.03859359f, 
    -0.04083088f, -0.03720772f, -0.03112738f, 0.00499733f, -0.04380598f, -0.05325917f, -0.01453320f, -0.02159917f, 
    -0.02194457f, 0.03289647f, 0.05990514f, 0.05803983f, 0.01998969f, 0.00175291f, 0.00898612f, -0.00160346f, 
    -0.00938028f, 0.05119309f, 0.06165493f, -0.05831655f, -0.01116487f, -0.04886626f, -0.00217020f, 0.04075587f, 
    0.01536088f, 0.05270256f, -0.03765095f, -0.02671304f, -0.04901606f, -0.04683987f, -0.03624099f, 0.02289588f, 
    -0.03123883f, -0.06704899f, 0.04745580f, 0.02339098f, 0.02848998f, -0.00771467f, -0.02393206f, 0.04068709f, 
    0.01076159f, -0.02394525f, 0.03597240f, -0.04164279f, 0.04254220f, -0.00156982f, -0.05858591f, -0.01626997f, 
    -0.06438804f, 0.01362841f, 0.02924761f, 0.04764476f, 0.04898612f, -0.02366492f, 0.01055688f, 0.02657362f, 
    0.02028332f, -0.05358975f, 0.01895889f, 0.02757195f, -0.05077446f, -0.04810515f, 0.00672476f, -0.00183619f, 
    0.00569557f, 0.00730682f, 0.01552731f, -0.02900515f, 0.03148017f, -0.04607871f, -0.05045228f, -0.02979316f, 
    0.02334836f, -0.02344907f, -0.06916247f, -0.05793698f, -0.03177211f, -0.04759089f, -0.05334174f, -0.04653674f, 
    0.04248024f, 0.03080777f, 0.03675652f, -0.01071492f, -0.05108329f, -0.02202757f, 0.03259313f, -0.02631404f, 
    0.03668034f, 0.01406271f, 0.01717956f, 0.03689579f, -0.01403117f, 0.02783983f, 0.02346555f, 0.02621006f, 
    -0.05890021f, -0.05853228f, 0.04635773f, -0.01489623f, -0.02722764f, 0.05943310f, -0.03441217f, -0.02450533f, 
    -0.04687339f, 0.03510262f, -0.00271780f, 0.01051540f, -0.04611932f, -0.04786907f, 0.01244105f, -0.03919397f, 
    -0.00043003f, -0.00775963f, 0.04993268f, 0.00293572f, -0.05318293f, -0.03764036f, -0.03432442f, -0.04317750f, 
    -0.06951158f, 0.02581437f, -0.02605175f, -0.00661434f, -0.03054095f, -0.03025479f, 0.02832715f, 0.03271294f, 
    -0.00422445f, 0.03067776f, -0.05153040f, -0.01854873f, 0.01383673f, -0.05499301f, 0.05089200f, -0.03341125f, 
    -0.00224541f, -0.03416328f, -0.02186414f, 0.01017312f, 0.04908359f, -0.00708147f, 0.00661078f, -0.00211405f, 
    0.04432756f, -0.06291697f, 0.01251126f, -0.04916763f, 0.01939290f, -0.04576989f, -0.02194169f, -0.03559214f, 
    0.04439577f, -0.01705211f, 0.01956809f, -0.05393833f, 0.01080081f, -0.00547611f, 0.02286549f, 0.04216888f, 
    -0.01206613f, -0.00376758f, -0.02027560f, -0.01417813f, -0.05132886f, -0.05053750f, -0.04650826f, 0.04707515f, 
    -0.01364704f, -0.04516892f, -0.01684481f, -0.02806870f, 0.02287431f, -0.00284340f, -0.00130703f, 0.02221746f, 
    -0.01576184f, 0.00423913f, 0.01893649f, -0.01993196f, -0.02202340f, -0.06060324f, -0.01500533f, -0.04575793f, 
    -0.03186154f, 0.00185342f, 0.01351462f, -0.06290452f, -0.03182478f, 0.01451511f, 0.02322861f, -0.06208989f, 
    0.03925339f, 0.00100525f, -0.03901621f, -0.03086453f, 0.00260861f, 0.02402824f, -0.01191806f, 0.03679116f, 
    0.02365328f, 0.03087417f, 0.02032677f, -0.05686326f, -0.01058697f, 0.01162305f, -0.03249805f, -0.05378180f, 
    0.00382604f, 0.05937498f, 0.02662622f, -0.04556150f, -0.04039466f, 0.02810298f, 0.03910338f, -0.03620529f, 
    0.01886681f, -0.00803340f, -0.02840273f, -0.02867313f, 0.04999455f, -0.02524293f, -0.01323720f, -0.06111969f, 
    -0.03433273f, 0.03361691f, 0.03786939f, 0.00378665f, 0.01081777f, -0.01458455f, 0.02330970f, 0.04091620f, 
    0.00890175f, -0.02250414f, 0.05189385f, -0.02369530f, 0.05120529f, 0.05325378f, 0.05661654f, 0.01514379f, 
    0.03452278f, -0.00216644f, -0.00323721f, 0.01286010f, -0.03836318f, 0.00752716f, -0.02452230f, -0.02947970f, 
    -0.06359819f, 0.02210845f, 0.00071072f, -0.05471887f, -0.03273337f, -0.06091782f, -0.04199675f, 0.02187688f, 
    0.04846062f, -0.03659116f, 0.00634151f, 0.01710613f, -0.03657597f, 0.03819063f, 0.04601882f, -0.01530439f, 
    0.03856440f, -0.04732431f, 0.00547643f, 0.04897365f, 0.05879603f, 0.01859646f, 0.04398678f, -0.00126307f, 
    -0.00892822f, 0.01162727f, -0.00324702f, -0.01127216f, -0.03835092f, 0.01381502f, -0.03213773f, -0.03770338f, 
    0.00004314f, -0.04492753f, -0.02163091f, 0.01148400f, -0.00062349f, -0.03813726f, -0.05231431f, 0.03065778f, 
    -0.04220231f, 0.03107228f, -0.05717453f, -0.05989372f, -0.00636994f, 0.03246849f, 0.03579390f, -0.02363304f, 
    0.01098054f, 0.03366240f, -0.06370567f, 0.01820208f, 0.00023022f, -0.02248163f, -0.01504257f, 0.04955287f, 
    -0.04033294f, 0.01438112f, 0.05212224f, 0.03620029f, -0.00308236f, 0.04376743f, -0.00426747f, -0.02966276f, 
    0.03608251f, -0.02932508f, 0.00968551f, -0.00931042f, -0.00086437f, 0.00742021f, 0.02940608f, 0.02635022f, 
    -0.03904323f, -0.02666761f, 0.05211655f, -0.03233354f, 0.02882238f, -0.02889873f, -0.00956083f, -0.05407247f, 
    -0.04845753f, -0.02881515f, -0.05150499f, -0.02570560f, -0.04179209f, 0.04977765f, 0.01124302f, 0.02071962f, 
    -0.02623404f, 0.00240999f, -0.00638797f, 0.00632395f, 0.00466473f, 0.00471021f, -0.04019361f, -0.02532930f, 
    0.03587102f, -0.02642095f, -0.00405236f, 0.01821017f, 0.04683151f, -0.03082234f, -0.05173342f, 0.03522689f, 
    0.00129269f, 0.04942382f, -0.02855275f, -0.04929772f, -0.03724904f, -0.06129788f, -0.06472431f, -0.04161208f, 
    -0.05030753f, 0.04941886f, 0.00121951f, -0.00070509f, 0.04221521f, 0.02364995f, 0.00345280f, -0.00654002f, 
    -0.06008836f, -0.03087672f, -0.01047227f, 0.02069453f, -0.00476218f, 0.05333379f, -0.00617026f, -0.00477445f, 
    -0.04320631f, -0.00494636f, -0.06150941f, 0.03070482f, -0.04883666f, -0.01948296f, -0.05772753f, 0.04314854f, 
    0.01981623f, 0.01764294f, -0.04809977f, 0.01715109f, -0.00226327f, -0.01347423f, 0.04039924f, 0.02307684f, 
    0.00112981f, 0.01728956f, -0.05967015f, 0.01921520f, -0.03301048f, -0.04364189f, -0.06472499f, -0.03842992f, 
    -0.05468211f, -0.02072817f, -0.06362267f, 0.03164574f, -0.04751021f, -0.01018077f, -0.05328061f, -0.05052713f, 
    -0.06324520f, -0.01802994f, -0.06469486f, 0.01136371f, 0.02832412f, 0.05288795f, -0.00221679f, -0.01577091f, 
    0.02264757f, 0.01809737f, 0.04403376f, -0.04807636f, 0.02616902f, 0.00644325f, -0.04519425f, 0.03182537f, 
    -0.04709280f, 0.02486549f, 0.03034939f, 0.05188680f, -0.05007201f, -0.04328771f, -0.00632326f, 0.03010118f, 
    0.01507348f, -0.04901217f, -0.02843583f, -0.05331337f, -0.03519513f, -0.06224106f, 0.04138159f, -0.01005556f, 
    -0.05380160f, -0.03617611f, -0.04815532f, 0.01307918f, 0.01389463f, 0.00062114f, 0.02121021f, -0.05707969f, 
    0.01756655f, 0.05260321f, -0.03392429f, 0.02063253f, 0.00236832f, -0.02751786f, -0.03477866f, -0.00261190f, 
    0.00163153f, 0.02345412f, -0.00252186f, -0.02264737f, 0.02800846f, 0.00456499f, -0.01676509f, 0.02268455f, 
    0.01499779f, -0.00562913f, -0.02554187f, -0.04672332f, -0.00814062f, 0.03283473f, -0.02043864f, 0.01161526f, 
    0.05236038f, 0.04111457f, -0.03762002f, 0.00508808f, 0.04591145f, -0.02117417f, 0.02522818f, -0.03842421f, 
    0.03656908f, 0.01506870f, 0.04267493f, 0.01209270f, -0.01220446f, -0.06377139f, -0.02720926f, -0.00978969f, 
    -0.03081071f, 0.00833714f, -0.05581104f, -0.06310734f, -0.03231353f, -0.01860936f, -0.00338217f, -0.05855993f, 
    -0.00076992f, 0.01694252f, -0.04030855f, 0.00480469f, 0.00457099f, 0.04948118f, -0.03397134f, 0.03731939f, 
    0.06662448f, -0.07277954f, 0.07421471f, -0.16661867f, 0.09524647f, -0.20665249f, 0.01353561f, -0.14147462f, 
    0.09790036f, -0.12602574f, 0.11787022f, 0.10963722f, -0.10832458f, 0.16142230f, 0.03486737f, 0.02558635f, 
    0.09372099f, 0.01947067f, -0.53523320f, -0.11972164f, 0.11484078f, -0.13999781f, -0.03366184f, 0.20385307f, 
    0.02846006f, 0.10984875f, -0.00070021f, -0.42307231f, -0.17277361f, -0.13096026f, -0.12832485f, 0.10939415f, 
    -0.02261458f, -0.06812013f, -0.14381196f, -0.12097800f, 0.07692730f, -0.12078834f, -0.15439561f, 0.13253942f, 
    0.17645106f, 0.11281694f, 0.02463328f, 0.11349681f, 0.00473070f, -0.04461692f, -0.08500396f, 0.39016145f, 
    -0.11782324f, 0.05447144f, 0.07426608f, 0.12248316f, 0.05783426f, 0.08505075f, -0.24275792f, -0.04130813f, 
    0.14163351f, -0.07019333f, -0.00932788f, -0.18169667f, 0.07410482f, 0.02612852f, 0.05828299f, 0.34363613f, 
    0.03321486f, -0.05826032f, -0.19863443f, 0.05623692f, -0.10674258f, 0.04138441f, 0.13236748f, 0.04732091f, 
    -0.11602367f, -0.17113911f, -0.16961117f, -0.04214415f, -0.02577051f, -0.06428705f, -0.02300786f, 0.08526212f, 
    -0.04623425f, -0.19131108f, -0.34014726f, 0.02869769f, 0.05158026f, -0.07853682f, -0.33337799f, -0.15970513f, 
    0.23255838f, 0.14931497f, -0.20543572f, -0.13287759f, 0.31709555f, 0.12129588f, -0.00682677f, -0.06272709f, 
    0.14477141f, 0.07977443f, 0.12778164f, -0.13334058f, -0.67507339f, 0.01630008f, 0.14836943f, -0.32287067f, 
    -0.35274720f, 0.07303039f, -0.17190376f, 0.02998242f, -0.34518373f, -0.11412873f, 0.24021481f, 0.09687386f, 
    -0.12934951f, 0.02847743f, 0.18347152f, 0.14470273f, 0.11724534f, -0.15682532f, -0.05092182f, 0.68328774f, 
    -0.05459653f, -0.09165716f, -0.31124908f, -0.00451270f, -0.09917982f, 0.12218051f, -0.25353929f, 0.04413917f, 
    0.23397134f, 0.08599760f, -0.04778801f, 0.10807702f, 0.03948565f, -0.08989788f, -0.02500900f, 0.30610859f, 
    -0.15574384f, 0.13875274f, 0.09758773f, -0.11304028f, 0.01394762f, 0.21101111f, -0.08696274f, -0.10914170f, 
    -0.03993304f, 0.25067371f, 0.12222694f, -0.06737967f, 0.01272418f, 0.05355265f, 0.01631289f, 0.04195144f, 
    -0.04292565f, 0.07499330f, 0.29624173f, 0.49691093f, 0.00523410f, 0.01471647f, -0.05650126f, 0.05813796f, 
    0.07995038f, -0.18242323f, -0.51622188f, -0.40690535f, -0.01540554f, -0.04506534f, -0.15134920f, 0.00580666f, 
    0.02094408f, -0.00115223f, 0.09245462f, -0.05622392f, -0.18889567f, -0.02778291f, -0.15499477f, -0.07229818f, 
    -0.03674712f, 0.01839337f, -0.11271306f, 0.04578059f, -0.21112868f, 0.00907871f, 0.29224372f, 0.08262549f, 
    0.03622137f, 0.16491194f, 0.18853903f, 0.00921778f, 0.12929641f, -0.05228847f, 0.13269164f, 0.34743005f, 
    0.00960132f, 0.08466098f, 0.06543450f, -0.07245395f, 0.00504663f, -0.03460208f, 0.20973630f, -0.01315409f, 
    0.32432315f, -0.18719801f, 0.13220470f, 0.08716254f, -0.02334379f, -0.19998609f, 0.00002636f, -0.35278779f, 
    0.02666290f, -0.10588621f, -0.15318571f, -0.04192530f, -0.11009488f, 0.02667045f, 0.13242441f, -0.01042242f, 
    0.37936065f, -0.63267648f, -0.08905773f, 0.07180595f, 0.09222799f, -0.01756451f, -0.10341828f, -0.07812770f, 
    -0.23926128f, 0.00186413f, -0.24834871f, -0.02203941f, -0.08230463f, -0.12345792f, -0.03108229f, 0.04762677f, 
    -0.09959177f, 0.10304826f, -0.11605600f, -0.21716918f, 0.15106122f, -0.03283480f, -0.07194956f, 0.01170497f, 
    0.19282588f, 0.09793752f, 0.10387675f, -0.11674020f, -0.00353548f, 0.42904621f, 0.10828136f, 0.07479814f, 
    0.03440410f, 0.02906304f, 0.09373759f, 0.11939404f, -0.76026624f, 0.20137668f, 0.02408597f, 0.05324335f, 
    -0.13556628f, 0.15466924f, 0.10534367f, -0.04990449f, -0.01032863f, -0.07743121f, 0.46258363f, 0.63686842f, 
    -0.03459252f, -0.28197244f, -0.09046286f, -0.23012953f, -0.11198328f, -0.01683588f, -0.01378250f, -0.25084084f, 
    -0.02231029f, -0.07365712f, 0.02910368f, -0.04745831f, -0.04896601f, 0.15332898f, -0.01245419f, -0.22435182f, 
    -0.46159452f, -0.13033241f, -0.14755462f, -0.22902645f, 0.24164754f, 0.01038557f, -0.04301802f, -0.00535895f, 
    0.02372473f, 0.26123753f, 0.01147186f, 0.11415667f, -0.16314687f, 0.03243167f, 0.14839751f, -0.13303576f, 
    -0.13210273f, -0.05777698f, 0.20923884f, 0.15946423f, 0.00173458f, 0.07851081f, 0.13623616f, 0.02990964f, 
    0.06440787f, 0.10743728f, -0.18329580f, 0.15184689f, 0.09566060f, 0.01495871f, -0.06427566f, -0.00801839f, 
    -0.08526139f, -0.12976220f, 0.03569420f, -0.33863980f, -0.14344403f, -0.00009396f, -0.02278055f, 0.04923525f, 
    0.00869366f, 0.13294879f, -0.05449895f, -0.13188750f, 0.07222772f, 0.15755253f, -0.14475514f, 0.09206745f, 
    0.01285031f, 0.16253839f, 0.13316329f, 0.21300857f, -0.17483090f, 0.05982723f, 0.28684473f, 0.32254812f, 
    -0.41934568f, -0.21154356f, -0.12712386f, 0.03951521f, 0.07671910f, 0.24464509f, -0.37834138f, -0.05495533f, 
    0.13725142f, -0.10849141f, -0.20270014f, -0.07569303f, 0.03593387f, -0.13167821f, -0.13270289f, 0.11196826f, 
    0.11985776f, 0.20454103f, -0.16364360f, -0.14284399f, -0.04366293f, 0.22233112f, 0.20012763f, -0.00359270f, 
    -0.15751041f, -0.04045234f, -0.09010922f, -0.07595787f, 0.07684696f, 0.02979214f, 0.29314089f, 0.12028276f, 
    0.01854304f, -0.21855770f, -0.02046430f, -0.25604871f, 0.15816897f, 0.00870980f, -0.09852025f, -0.00609413f, 
    0.13096103f, -0.21866421f, 0.04956882f, -0.08579928f, 0.15056551f, -0.02360740f, -0.09075750f, 0.05437640f, 
    -0.05838184f, -0.10450736f, -0.21510080f, -0.23972343f, -0.02959965f, -0.14715272f, -0.05025458f, 0.07277519f, 
    -0.04702080f, 0.25495973f, -0.02768176f, 0.23336947f, -0.05449067f, -0.02588210f, -0.10302953f, 0.04356878f, 
    0.00722599f, 0.00941281f, 0.19248253f, -0.07872068f, 0.00044109f, -0.20073944f, 0.03940394f, 0.09541092f, 
    -0.08533283f, -0.02250973f, -0.19452377f, 0.12667546f, -0.21396297f, 0.19542629f, -0.21983437f, 0.00425264f, 
    0.17470008f, -0.01870507f, -0.11903735f, -0.17431308f, 0.13280490f, 0.05717737f, -0.04420194f, -0.34013873f, 
    -0.27495092f, 0.10938014f, -0.15827633f, -0.02390872f, 0.11840861f, 0.02499657f, -0.08340064f, -0.07149883f, 
    0.31847042f, 0.03083470f, 0.04128581f, -0.04777441f, 0.15015347f, 0.04865448f, 0.13646619f, -0.09042106f, 
    0.07640263f, -0.12021755f, 0.32315779f, 0.06846392f, 0.06323925f, 0.11094174f, -0.01524372f, 0.21069814f, 
    -0.05082588f, 0.27350768f, -0.45210576f, -0.12616356f, -0.05609743f, -0.00450442f, 0.02751754f, 0.11524218f, 
    0.11321642f, -0.06433118f, 0.27961949f, -0.00700354f, -0.05657991f, 0.02724881f, -0.13995135f, 0.04728824f, 
    -0.14826672f, 0.19363424f, -0.00162470f, 0.19722058f, 0.26056483f, 0.12816015f, 0.37162727f, 0.00032062f, 
    -0.22847968f, 0.07609490f, 0.01496237f, -0.19475037f, -0.20162056f, 0.06361639f, 0.34830871f, 0.21164660f, 
    0.03054449f, 0.25190338f, 0.05883382f, -0.01462758f, -0.01778389f, -0.02976039f, 0.00801762f, 0.17151846f, 
    0.07596081f, -0.02890234f, 0.12879679f, -0.01618502f, 0.17696345f, 0.16924545f, 0.12631179f, -0.39680943f, 
    -0.08933423f, -0.13511109f, 0.00970542f, -0.16307831f, 0.02197062f, 0.26389739f, 0.10007197f, -0.06991190f, 
    -0.17936306f, -0.20554689f, -0.37013209f, 0.12725428f, -0.09985240f, 0.21197118f, -0.02457938f, -0.04850835f, 
    -0.13025989f, -0.21018887f, -0.40988141f, -0.31837630f, -0.16764234f, -0.11113784f, -0.08287449f, 0.23275247f, 
    -0.08753671f, -0.09703665f, -0.40028271f, -0.24579512f, 0.22022177f, 0.11581370f, 0.01989200f, -0.04077097f, 
    0.11552983f, 0.07260367f, 0.13098763f, -0.02845324f, 0.42517731f, 0.09377084f, 0.17196056f, 0.07494864f, 
    -0.14640120f, -0.17452782f, 0.10345388f, -0.07733218f, -0.02411029f, 0.28815514f, -0.15771937f, 0.00610522f, 
    0.01082760f, -0.21145248f, -0.05252028f, 0.06983198f, -0.21572745f, -0.37712839f, 0.01184547f, -0.41372755f, 
    -0.10763431f, 0.01136888f, -0.14416106f, 0.11745611f, 0.02448922f, 0.07816058f, -0.15186703f, -0.15513575f, 
    0.11305484f, -0.49704373f, -0.01806984f, -0.52997458f, 0.09001776f, 0.12974636f, -0.07651431f, -0.47889525f, 
    -0.87361795f, -0.62983364f, -0.18397056f, -0.03028420f, -0.29704577f, 0.16511884f, 0.03925964f, -0.18461621f, 
    -0.00729809f, 0.01270512f, 0.04827318f, -0.05732584f, -0.04806352f, -0.06287424f, -0.04491355f, -0.02706735f, 
    -0.02863014f, -0.01741149f, 0.04583672f, -0.04071268f, 0.03428522f, -0.05461121f, 0.00528263f, -0.03162742f, 
    0.03896658f, 0.03637639f, -0.05439084f, -0.05560599f, -0.01843795f, 0.01026063f, 0.03185120f, 0.01315068f, 
    0.01563421f, 0.04421776f, 0.00084013f, -0.03085544f, -0.04971683f, 0.00349359f, -0.00467664f, -0.06521799f, 
    -0.00784364f, -0.03156922f, 0.01222464f, -0.01592849f, -0.06375900f, -0.06004869f, 0.03941192f, 0.03054015f, 
    0.02838116f, -0.03839691f, -0.00057468f, -0.05970193f, -0.03788005f, -0.01467967f, -0.05841644f, 0.01991311f, 
    -0.06195507f, -0.06216728f, -0.00878933f, -0.01232647f, 0.04759623f, -0.02430901f, 0.00121781f, 0.04952042f, 
    0.00206881f, 0.01983926f, 0.00674587f, -0.01514221f, 0.01809218f, -0.04049589f, 0.00232722f, 0.03582289f, 
    -0.03291211f, 0.01933234f, -0.00523334f, -0.05032798f, 0.01923089f, -0.01874993f, -0.01683364f, -0.05776015f, 
    0.03899245f, 0.04133913f, 0.03967125f, -0.03693902f, -0.00802713f, 0.00926213f, 0.03588072f, 0.04707142f, 
    0.02538262f, -0.05662471f, -0.04282145f, -0.02270974f, -0.03476401f, 0.03147288f, -0.04984641f, 0.02526266f, 
    -0.05716606f, 0.02193418f, -0.06398020f, 0.01596427f, -0.05813948f, 0.00524165f, -0.00621238f, -0.00074559f, 
    -0.01814112f, 0.00942272f, 0.04029076f, 0.02596753f, -0.04244565f, -0.03867575f, -0.06353614f, 0.01355553f, 
    0.00223176f, -0.04890143f, -0.03137965f, 0.05474853f, -0.02242672f, 0.00240040f, -0.05813538f, -0.00248989f, 
    0.02821576f, 0.01295398f, -0.02815421f, -0.03583103f, -0.04958320f, 0.00648872f, -0.04879371f, -0.04495531f, 
    0.00230409f, -0.02025851f, -0.01904194f, 0.00817079f, -0.04791850f, -0.02151793f, 0.00096434f, 0.00381063f, 
    -0.02921732f, 0.00002367f, -0.03286845f, -0.04806798f, 0.03158967f, 0.04357027f, 0.05127338f, 0.00285738f, 
    -0.01869925f, 0.03548131f, -0.06107254f, -0.05633095f, -0.04200286f, -0.02344009f, -0.05168847f, -0.00400327f, 
    -0.00007086f, 0.04716544f, 0.03734697f, -0.05181941f, -0.04061576f, -0.06577031f, 0.01560651f, 0.04514162f, 
    0.04289248f, -0.06185760f, 0.04217817f, 0.01354901f, -0.05304686f, 0.01077479f, -0.03888125f, 0.01135075f, 
    -0.03275786f, -0.01555803f, -0.02292760f, 0.00511492f, 0.00884849f, 0.03884035f, -0.04338584f, -0.03066032f, 
    -0.01939259f, 0.05564406f, 0.02747338f, -0.02193481f, 0.00526164f, 0.01708845f, 0.02487543f, -0.01117946f, 
    0.04745586f, 0.02906797f, -0.05124540f, 0.02630850f, -0.06306010f, -0.05389274f, 0.01672685f, 0.01639307f, 
    0.04383152f, -0.03414057f, -0.01985865f, -0.05638102f, 0.03199250f, 0.03975634f, -0.06271182f, -0.03212393f, 
    -0.00562600f, -0.06329586f, 0.02551996f, 0.04188200f, 0.03020146f, -0.05333468f, -0.06052181f, -0.04315283f, 
    0.04450302f, -0.01688903f, 0.02316795f, 0.00607649f, -0.03723988f, -0.05672169f, -0.02915547f, 0.02285828f, 
    0.04052914f, -0.00187465f, 0.03087208f, -0.04571385f, 0.02953605f, -0.03365581f, -0.05288078f, 0.04803555f, 
    0.03792126f, 0.04625150f, 0.02333143f, 0.01951975f, 0.03729171f, 0.04591386f, -0.01659705f, 0.03848719f, 
    0.04716605f, -0.00609739f, -0.02723008f, 0.04889835f, -0.03953832f, 0.03813652f, 0.04353634f, -0.01248351f, 
    0.00000365f, 0.00971172f, 0.00206729f, 0.05157871f, -0.01413325f, -0.00013255f, -0.04801887f, -0.00204905f, 
    -0.05486738f, -0.02545271f, 0.02244850f, -0.05534115f, -0.02880317f, 0.02117730f, -0.05630879f, -0.02280706f, 
    -0.04391244f, -0.06103583f, 0.03909953f, -0.01593916f, -0.01249558f, 0.03088254f, 0.03260665f, -0.01067226f, 
    -0.01271284f, -0.05147121f, 0.02421712f, 0.03131759f, 0.02716643f, -0.04750617f, -0.04756722f, 0.03246488f, 
    -0.05926551f, -0.02890040f, -0.03426937f, 0.01380583f, -0.00595638f, -0.03088203f, -0.01040278f, -0.03323364f, 
    -0.02342073f, -0.01983391f, -0.04260826f, -0.01283765f, -0.05663826f, -0.03702461f, -0.03406175f, 0.01499269f, 
    0.00769919f, -0.01222491f, -0.05768475f, -0.05404552f, 0.04259511f, -0.00436069f, -0.05694583f, 0.06238640f, 
    -0.55458808f, -0.32388502f, 0.06888849f, -0.12375603f, -0.00756177f, -0.09382268f, -0.18467914f, -0.26883116f, 
    -0.06408125f, -0.13689916f, 0.02086567f, 0.11674958f, -0.25379553f, -0.03881777f, 0.16031466f, 0.06658754f, 
    -0.04021635f, 0.19455068f, -0.07163444f, -0.40781575f, 0.03570112f, 0.03789936f, -0.06894998f, -0.22037151f, 
    -0.14350982f, -0.07625042f, -0.24118669f, -0.06625814f, -0.10694966f, -0.07288419f, -0.04688806f, 0.10261551f, 
    -0.33432600f, 0.08709319f, 0.11067754f, -0.17688873f, 0.09574043f, -0.26791680f, -0.14024979f, -0.09097145f, 
    -0.06808245f, 0.15476757f, 0.02035896f, 0.07296494f, 0.05405449f, 0.62937182f, 0.70703810f, 0.11315199f, 
    -0.15109102f, -0.19735254f, -0.15221789f, -0.09470818f, -0.04671719f, 0.02257170f, 0.14663982f, -0.02845949f, 
    -0.06409395f, -0.25995058f, -0.19792579f, -0.17355385f, 0.05664074f, -0.10622295f, 0.03238150f, 0.41942164f, 
    0.23572624f, 0.05832374f, 0.09707957f, 0.04697488f, 0.09415243f, 0.03959437f, 0.07143062f, 0.08566710f, 
    0.07051093f, 0.08643871f, 0.04118096f, -0.02408133f, 0.02620115f, 0.06579384f, 0.16307366f, 0.00239177f, 
    -0.10990905f, -0.49178398f, -0.03271700f, 0.55561048f, -0.27566341f, -0.08870284f, -0.16018631f, 0.00953671f, 
    -0.15279293f, -0.27421442f, 0.34572715f, 0.61026537f, 0.03147792f, -0.01632422f, -0.12852560f, -0.13819849f, 
    -0.12845893f, -0.11587317f, -0.14891632f, -0.97517049f, -0.21817417f, -0.08126232f, 0.24246779f, -0.05744034f, 
    -0.01830926f, 0.10711019f, 0.27628571f, -0.15762171f, -0.04200846f, 0.17168689f, 0.24329630f, 0.05455374f, 
    -0.09488460f, -0.11820614f, 0.21980272f, 0.01004263f, 0.41138795f, -0.74061257f, 0.48439917f, -0.15143333f, 
    -0.10625072f, -0.21361749f, -0.03125605f, -0.12646528f, 0.08855483f, 0.17900653f, -0.04491915f, 0.00502579f, 
    -0.03845505f, 0.01903900f, -0.23974495f, 0.01183921f, 0.21863818f, 0.23794900f, 0.34493926f, 0.05896195f, 
    0.19218101f, 0.05401127f, -0.03517813f, 0.03558134f, -0.07280532f, 0.04446077f, 0.15067060f, 0.26973036f, 
    -0.49353513f, -0.23747402f, -0.54879695f, -0.10229453f, 0.17490321f, 0.08467451f, 0.08831155f, -0.19242124f, 
    -0.02596725f, 0.10891739f, 0.09312867f, 0.44349387f, -0.17748304f, -0.12011562f, 0.18308380f, 0.23617965f, 
    0.28315064f, 0.26618624f, -0.03793680f, 0.04627371f, 0.00127828f, -0.03540727f, -0.17687304f, -0.15278055f, 
    0.08705218f, 0.07168358f, 0.02403291f, 0.17802554f, 0.17731203f, 0.04285535f, -0.23298599f, -0.21972977f, 
    -0.40798351f, 0.13852262f, 0.00694280f, -0.04634329f, -0.83205056f, -0.04246038f, -0.16258454f, -0.14369012f, 
    -0.08265109f, -0.16417672f, -0.21197437f, -0.03830319f, -0.20203911f, -0.47547278f, -0.31830081f, -0.12179385f, 
    -0.14704658f, -0.00658939f, 0.16008805f, 0.08698254f, 0.14358906f, 0.09956100f, 0.50725675f, 0.23845339f, 
    0.41693377f, 0.25516137f, 0.01696135f, 0.22717592f, 0.27563357f, 0.29274744f, 0.17463474f, 0.34135896f, 
    -0.36658838f, 0.20577493f, -0.32749215f, 0.08885995f, 0.08455504f, 0.06698745f, -0.09499829f, -0.01883253f, 
    -0.62314564f, 0.12695265f, 0.07555534f, 0.00770460f, 0.14480987f, 0.00935564f, -0.15299028f, -0.07035121f, 
    0.30165046f, -0.24968766f, 0.03059937f, -0.08579060f, -0.18924831f, 0.06693902f, -0.19546895f, 0.11974197f, 
    0.19935384f, 0.37811497f, 0.00272998f, -0.12109581f, 0.06026759f, -0.07696135f, 0.07072378f, -0.24832569f, 
    0.08275896f, 0.12733829f, 0.14917068f, -0.24642438f, -0.75936800f, -0.16386528f, 0.03664491f, 0.06020547f, 
    -0.07658999f, -0.01605646f, -0.10715058f, -0.03354568f, 0.29755071f, 0.26314533f, -0.82360148f, 0.02634790f, 
    -0.08864212f, 0.08558179f, 0.08797713f, 0.02814297f, -0.26986825f, -0.63374263f, 0.07036199f, -0.13828014f, 
    -0.06306744f, -0.25244981f, 0.23072304f, 0.01575691f, -0.04158443f, 0.14652739f, 0.16636649f, 0.09668762f, 
    -0.16255639f, -0.40037867f, -0.19500074f, -0.68597937f, 0.03913025f, 0.14973755f, -0.12196775f, 0.05192560f, 
    0.14240667f, -0.35770977f, -0.28762037f, -0.19169077f, 0.28793150f, -0.01662355f, -0.16143055f, -0.35589311f, 
    -0.27219486f, -0.30294821f, -0.22101305f, -0.15471062f, -0.14690953f, -0.23806743f, 0.02357549f, 0.17927523f, 
    0.07255385f, -0.00803847f, -0.22781903f, 0.06679864f, -0.02191830f, -0.02284429f, 0.07081801f, 0.09705547f, 
    0.07706764f, -0.07688154f, -0.35224503f, -0.35717997f, 0.02915865f, -0.03294535f, -0.07877050f, -0.09907246f, 
    -0.01162146f, 0.03482242f, -0.24183436f, -0.23490836f, -0.11831415f, -0.10353734f, 0.01325657f, -0.11141238f, 
    -0.03072970f, 0.04584341f, 0.12466880f, 0.14262551f, 0.21004415f, -0.32080844f, 0.11724457f, -0.07720876f, 
    0.14991200f, 0.10421696f, 0.11523186f, 0.01985692f, 0.08497900f, -0.13892269f, 0.15043783f, 0.18945508f, 
    -0.08769393f, -0.02363700f, 0.19306324f, -0.03711545f, 0.03629735f, 0.03902341f, -0.02438327f, -0.17932434f, 
    -0.17349964f, 0.03917316f, -0.11304577f, 0.03556643f, -0.08997791f, 0.06062960f, 0.06743258f, 0.15355982f, 
    0.19299912f, 0.12793224f, -0.03881369f, 0.09635162f, -0.07428535f, 0.09573275f, 0.02413319f, 0.12393543f, 
    -0.09174787f, -0.10742126f, -0.05522563f, 0.16156805f, 0.13399471f, 0.11687969f, 0.08904773f, 0.11970831f, 
    0.12953176f, -0.50969756f, -0.73362982f, -0.05105688f, 0.13309589f, 0.08976788f, -0.30529946f, 0.24306872f, 
    0.23432666f, -0.02904277f, -0.41741800f, -0.17545769f, -0.29338083f, -0.13918278f, -0.02547711f, 0.01640192f, 
    0.09432071f, 0.13599889f, 0.14718822f, 0.05535624f, 0.01199990f, -0.62909746f, 0.17491984f, 0.13939299f, 
    -0.03595452f, -0.06476625f, 0.32056874f, 0.01011036f, -0.32578564f, -0.16595437f, 0.18482763f, 0.07458529f, 
    0.11122270f, -0.10236453f, 0.26698092f, 0.15354723f, 0.05017498f, -0.02999918f, -0.21362726f, 0.02613555f, 
    -0.11711195f, -0.02725209f, 0.00627688f, -0.17631301f, 0.09589615f, -0.01907300f, 0.04799244f, 0.02729871f, 
    -0.07136920f, -0.20260158f, -0.10405225f, -0.11871534f, 0.19498517f, -0.06391592f, -0.14603856f, 0.09236546f, 
    0.14639217f, 0.10542294f, -0.13234207f, -0.05411067f, -0.09880999f, 0.01802762f, 0.00391677f, 0.16948026f, 
    -0.10912662f, -0.07421303f, -0.08174194f, -0.12995294f, 0.07991095f, 0.13375629f, 0.02436081f, 0.20620656f, 
    0.01414977f, 0.08642557f, 0.07151525f, 0.38171107f, -0.01353800f, -0.11725843f, 0.11500023f, -0.04608340f, 
    0.09366909f, -0.08189818f, -0.29007730f, -0.24606001f, -0.06433178f, 0.00766873f, -0.00828795f, -0.15671068f, 
    0.02064146f, 0.15889420f, 0.09297135f, -0.01243796f, -0.10777754f, -0.00503705f, -0.11749043f, -0.02059950f, 
    -0.22841136f, 0.03931815f, 0.01974660f, 0.10078181f, -0.26958618f, -0.32401109f, -0.40695944f, -0.25800204f, 
    -0.05401280f, -0.12422828f, 0.09528640f, 0.15118353f, 0.12402017f, 0.05110562f, -0.13307242f, 0.06572358f, 
    -0.03011737f, -0.06324765f, 0.04830918f, 0.16895716f, 0.18733642f, -0.13314332f, 0.42759165f, 0.20435134f, 
    0.24679397f, 0.10951141f, 0.17616111f, -0.02902033f, 0.31626025f, 0.12650113f, 0.16557324f, -0.07157960f, 
    -0.18351348f, -0.10939366f, -0.01652822f, -0.18334970f, -0.14119636f, -0.12027165f, 0.04889173f, -0.22795275f, 
    -0.19704759f, -0.53403151f, -0.18503918f, -0.13191655f, -0.05632575f, 0.12322441f, -0.03786279f, -0.00440887f, 
    0.06707790f, -0.15459232f, -0.08421925f, -0.21125937f, -0.23906352f, -0.23709621f, -0.13466924f, -0.05618793f, 
    0.11017451f, 0.30668157f, 0.06519870f, -0.04340173f, -0.02299316f, 0.12175050f, -0.04371732f, -0.02507065f, 
    0.28838420f, 0.34013566f, 0.20035486f, -0.01880515f, -0.50106996f, -0.23401797f, -0.00777600f, 0.14649098f, 
    -0.08819295f, 0.24538812f, 0.14550000f, 0.27367562f, -0.11344629f, 0.22198577f, 0.03727569f, 0.13283320f, 
    0.09458543f, -0.15325418f, 0.36540174f, 0.14489044f, 0.20790710f, 0.37947163f, 0.07638669f, -0.01969831f, 
    -0.02220576f, -0.23004062f, 0.02453082f, -0.05244655f, 0.09725937f, -0.03557213f, -0.15264921f, -0.23372592f, 
    0.02144181f, -0.09865282f, -0.27062601f, -0.26121566f, 0.04177043f, 0.01013118f, 0.13223442f, -0.23750123f, 
    -0.12701575f, -0.08271129f, -0.29921317f, -0.23454927f, -0.13493618f, 0.16541298f, -0.35019338f, -0.05082377f, 
    0.01145437f, 0.11171278f, 0.04593478f, 0.03162858f, 0.29162833f, -0.03211220f, -0.06412382f, 0.05246200f, 
    0.07118489f, -0.13380888f, -0.03538611f, 0.19027442f, 0.15067492f, -0.12042568f, 0.06249382f, -0.01816320f, 
    -0.12752737f, 0.09923667f, -0.04513508f, -0.14051281f, 0.05754232f, 0.19686261f, 0.08314020f, -0.06394675f, 
    0.05363667f, 0.12408787f, -0.01159996f, -0.11021319f, -0.11785069f, -0.14570706f, 0.08785148f, 0.15394889f, 
    -0.05709379f, -0.07461556f, 0.10540437f, -0.17344582f, 0.13972759f, 0.08710197f, -0.06528930f, -0.01975165f, 
    -0.16270576f, 0.13565385f, -0.21985106f, 0.01880902f, -0.05385085f, -0.00957038f, -0.19551232f, -0.29287302f, 
    -0.04777119f, 0.06875522f, 0.02267584f, -0.23844124f, -0.13584286f, 0.17955370f, -0.06751717f, 0.16482380f, 
    0.39190438f, 0.13922332f, -0.20775947f, 0.04517520f, 0.01516660f, 0.00008030f, 0.08044788f, 0.13767244f, 
    -0.12978832f, -0.24601497f, 0.21067539f, -0.07694674f, -0.12862502f, -0.03199565f, -0.13879086f, -0.15534975f, 
    -0.10620753f, -0.11674871f, -0.06613809f, 0.05763772f, -0.02090361f, -0.02776736f, -0.06887843f, -0.12494998f, 
    -0.14142165f, -0.08936515f, -0.06839608f, 0.12686794f, 0.17530169f, 0.29698521f, 0.16539726f, 0.11213291f, 
    0.07827526f, -0.10248993f, 0.05889190f, 0.01431792f, -0.00401242f, 0.04943870f, -0.15547778f, 0.05135123f, 
    0.29374316f, -0.13438696f, 0.09718440f, -0.04092249f, 0.04294967f, 0.10846973f, 0.11855693f, 0.06113087f, 
    -0.52564842f, 0.10566665f, -0.03555964f, -0.12942931f, -0.10166858f, -0.18557194f, 0.06560512f, -0.08326998f, 
    -0.08860735f, -0.13481939f, 0.03532512f, 0.12123837f, 0.01741264f, -0.12496590f, -0.14126953f, 0.11681537f, 
    0.06473387f, 0.09060538f, 0.00001548f, 0.06715490f, 0.01112102f, 0.12992780f, 0.03807519f, -0.10505215f, 
    -0.28356087f, 0.14348681f, -0.02084664f, 0.05572917f, -0.09923249f, -0.12942865f, -0.00824288f, -0.48396021f, 
    0.16970143f, 0.28221831f, 0.09695629f, -0.09963147f, -0.07858098f, 0.01951776f, -0.03374813f, -0.23776357f, 
    0.01215142f, 0.11848723f, 0.29943609f, 0.22639318f, 0.02016047f, -0.06446905f, 0.10457631f, -0.12289958f, 
    -0.00997629f, -0.15096308f, -0.15726310f, -0.36575735f, 0.13843440f, 0.20309892f, 0.17590275f, -0.12390903f, 
    -0.02625038f, 0.14442892f, -0.04482918f, -0.08561547f, -0.07166085f, 0.04776314f, 0.00506207f, 0.05478824f, 
    -0.04372875f, 0.01083244f, 0.06708968f, 0.01833075f, 0.09066542f, -0.21702537f, 0.02801255f, 0.08600416f, 
    -0.05516674f, -0.26439121f, -0.05724329f, 0.13194427f, 0.11567499f, 0.01449619f, 0.09807164f, 0.20596761f, 
    0.08468875f, 0.01232183f, 0.20930631f, -0.11982495f, 0.06160401f, 0.00747001f, 0.00221053f, 0.20507908f, 
    0.06759215f, -0.19302881f, -0.17114566f, 0.05952207f, -0.13594127f, -0.00440001f, -0.06214622f, 0.26327696f, 
    -0.04126840f, -0.21441096f, 0.13348751f, 0.15238957f, -0.00672606f, -0.04745174f, 0.19119354f, 0.15175028f, 
    0.15778625f, 0.15584360f, 0.07670031f, -0.13893011f, -0.15780133f, -0.05107816f, 0.02048450f, 0.09178667f, 
    -0.07123671f, 0.47888526f, 0.17934154f, -0.11906467f, -0.02321567f, -0.02583684f, -0.11462418f, 0.24339806f, 
    -0.06208660f, -0.26051068f, 0.24233238f, 0.11193538f, -0.03893074f, 0.13958366f, -0.01349955f, 0.11422288f, 
    0.06625815f, 0.04072993f, -0.08883984f, 0.04089923f, -0.05255600f, 0.08540335f, -0.03360568f, -0.06941190f, 
    0.08099120f, 0.14265949f, 0.06525525f, 0.05534695f, 0.26286238f, -0.05429385f, 0.10256412f, 0.04820704f, 
    -0.20732477f, -0.03923181f, 0.09677388f, 0.08874857f, -0.03305565f, 0.11340649f, -0.34900096f, -0.00017036f, 
    -0.10681453f, -0.16909246f, 0.03079445f, 0.15880050f, 0.00272621f, -0.66684937f, 0.28054282f, -0.38322145f, 
    0.00546975f, 0.18229324f, -0.02988749f, -0.20796506f, 0.34339774f, -0.00850257f, 0.14341286f, -0.03410927f, 
    -0.11282965f, 0.06814125f, 0.05287817f, -0.05439876f, -0.33097437f, 0.06260261f, 0.12982579f, 0.19333543f, 
    0.41420543f, -0.17912790f, -0.02767920f, 0.18563569f, 0.10022883f, 0.00034268f, 0.29929945f, 0.09879067f, 
    -0.21375763f, -0.04124817f, 0.02736041f, 0.12750214f, 0.03803755f, 0.10140752f, 0.14677472f, 0.11912441f, 
    0.15578403f, -0.11803265f, -0.15455857f, -0.44603315f, -0.01634173f, 0.00723240f, -0.16782309f, -0.03686843f, 
    0.14997901f, -0.18845092f, -0.16686410f, -0.20757964f, -0.09422331f, -0.03233883f, 0.03069402f, 0.07306650f, 
    0.04269954f, -0.04155917f, 0.16040851f, -0.01143521f, -0.07759000f, 0.13585363f, 0.00410254f, 0.04864902f, 
    0.00347606f, 0.14902666f, 0.02638885f, 0.12400580f, -0.07837619f, -0.03768047f, -0.29241842f, 0.10215846f, 
    0.02764069f, -0.04280305f, -0.02513073f, -0.02271511f, 0.09715419f, -0.07031751f, 0.07170264f, -0.21978085f, 
    0.02933998f, -0.00691652f, -0.02610467f, -0.00874573f, 0.04064015f, 0.01128521f, -0.20094934f, 0.05652385f, 
    -0.24675709f, 0.04294726f, 0.08061037f, 0.08152663f, 0.10046380f, 0.09607660f, -0.20641442f, 0.09012368f, 
    0.14344668f, -0.04892156f, 0.00726243f, -0.00261448f, 0.01193926f, 0.17564875f, 0.03041766f, -0.00864870f, 
    0.02680768f, 0.05366180f, -0.00869503f, -0.02988032f, -0.02537790f, 0.13324270f, 0.15205607f, -0.02204735f, 
    0.07200754f, -0.27966821f, 0.05858513f, 0.10438575f, -0.03643943f, 0.09098639f, 0.14173582f, 0.05777399f, 
    0.19490665f, -0.08732048f, 0.05715962f, 0.20067321f, 0.00195032f, -0.18341669f, -0.05505560f, 0.00746196f, 
    0.08256086f, 0.03219211f, -0.02133393f, 0.40246269f, 0.32219586f, -0.02786510f, 0.12292492f, 0.17251894f, 
    0.45921651f, -0.07470278f, 0.00571141f, -0.14511877f, 0.00475523f, -0.13148060f, -0.12775756f, -0.01717361f, 
    -0.00683865f, -0.01275878f, -0.04668965f, 0.09249501f, 0.07175680f, 0.02637769f, -0.03170091f, -0.50558829f, 
    0.01539274f, -0.11292602f, -0.01500372f, -0.00154026f, -0.10383150f, -0.00447885f, -0.03637252f, -0.02167946f, 
    0.00026412f, 0.00335752f, 0.10677741f, -0.03238115f, 0.21623345f, -0.23133242f, -0.13269058f, -0.13954337f, 
    0.07606015f, -0.13010912f, 0.04577437f, 0.11394693f, -0.05115027f, 0.03459702f, 0.02262847f, -0.20255226f, 
    -0.23825923f, -0.35549960f, -0.45360368f, 0.07284192f, 0.16545233f, 0.05327458f, -0.01903963f, -0.05934965f, 
    -0.23319955f, -0.10311206f, -0.26843530f, -0.29040650f, -0.15087962f, -0.14408475f, -0.20033027f, 0.03355642f, 
    -0.09248313f, 0.09248216f, -0.01301377f, 0.00654120f, -0.01832311f, -0.09085489f, -0.01297956f, -0.10475890f, 
    0.12915105f, 0.01132646f, 0.07179160f, -0.03011551f, 0.01732033f, -0.04594933f, 0.13373736f, -0.03424118f, 
    0.00627230f, 0.10981083f, -0.15839638f, -0.05139659f, -0.06059173f, -0.08519048f, -0.14030665f, -0.08454627f, 
    -0.15512903f, 0.05938051f, 0.02497947f, 0.03250626f, -0.03846762f, -0.13531649f, -0.18643849f, -0.50547671f, 
    0.01150659f, -0.03249605f, 0.01222956f, 0.02992609f, -0.03413453f, -0.12521240f, 0.24979019f, 0.17345215f, 
    0.55544227f, 0.31502050f, 0.04651229f, 0.18500841f, 0.25358728f, 0.24093026f, 0.19816069f, -0.17396152f, 
    0.16557355f, -0.28029653f, 0.03977356f, 0.01897567f, 0.01226274f, -0.18417563f, -0.00635257f, -0.24986148f, 
    -0.01564938f, 0.32282814f, 0.34932494f, 0.24712448f, 0.13474506f, 0.11856376f, -0.22442323f, -0.23225714f, 
    -0.13918643f, 0.02723255f, 0.00810808f, -0.03328287f, 0.07304927f, -0.06965745f, 0.05466273f, -0.00359193f, 
    0.08124024f, -0.03706322f, 0.03875967f, -0.02523457f, 0.05885370f, -0.11609814f, 0.06214376f, 0.03697173f, 
    0.04404479f, -0.01689781f, 0.09765431f, -0.38082734f, -0.27853689f, -0.27788928f, 0.19899894f, 0.15583713f, 
    0.08278878f, 0.07755318f, 0.09220191f, -0.12699491f, 0.37936094f, -0.19602153f, -0.10450774f, 0.18141362f, 
    0.11907738f, 0.06046074f, 0.12824409f, -0.13009275f, 0.19271509f, 0.14185940f, -0.01227484f, 0.00373006f, 
    0.02118632f, 0.01836962f, -0.03508530f, -0.07582403f, -0.14724110f, 0.05881981f, -0.08286606f, -0.07150164f, 
    -0.11445720f, 0.10356808f, -0.00596616f, -0.09251501f, 0.00991963f, -0.08393180f, 0.00977977f, 0.15626861f, 
    -0.00202883f, 0.03354359f, 0.17880176f, -0.07142103f, 0.18544905f, 0.10091256f, 0.19915126f, 0.03191954f, 
    0.09031039f, -0.11582410f, 0.03131510f, -0.38265273f, -0.18230772f, -0.16805585f, 0.25901368f, 0.15671295f, 
    -0.33138371f, 0.19450052f, 0.11441081f, -0.15645346f, -0.19935930f, -0.17734869f, 0.07012307f, 0.07299887f, 
    0.16231516f, -0.04218155f, -0.41679287f, 0.27247742f, 0.15865836f, 0.01189167f, -0.08363819f, -0.07551944f, 
    -0.04740557f, -0.00430675f, 0.04010532f, -0.01796191f, 0.26628196f, -0.00805956f, 0.02220758f, 0.08181107f, 
    -0.01643745f, -0.00580502f, 0.12191000f, 0.10279199f, 0.53013539f, -0.14356814f, -0.33128828f, 0.24844182f, 
    0.16861606f, 0.06279261f, 0.10641605f, 0.08385245f, 0.14116821f, -0.32007796f, -0.66469121f, -0.62114245f, 
    0.08465852f, 0.24168165f, 0.18584646f, 0.21913618f, -0.04149615f, -0.03887797f, 0.23109449f, 0.30021340f, 
    -0.15693893f, -0.24934025f, -0.17178769f, 0.07307032f, -0.03997017f, 0.12728082f, 0.05108791f, -0.11325958f, 
    -0.19394659f, 0.06482609f, -0.04149265f, 0.21637675f, 0.07169940f, 0.29346842f, -0.15290119f, 0.12873055f, 
    0.06292218f, 0.07118115f, 0.00573286f, 0.14454688f, 0.08406439f, 0.16408612f, 0.17080286f, 0.06736062f, 
    0.12093494f, -0.02470072f, -0.71184707f, 0.27183932f, -0.18688512f, 0.07924311f, -0.20957983f, 0.11231619f, 
    -0.03900991f, 0.06739712f, -0.08891957f, -0.18248773f, -0.31222102f, -0.06375932f, -0.11466791f, -0.07612053f, 
    0.01355625f, -0.16373220f, -0.26049960f, 0.75109577f, -0.55024880f, -0.79105353f, -0.11113443f, -0.15351267f, 
    0.07486411f, 0.03593634f, -0.06265908f, 0.04457191f, -0.90153116f, -0.03436247f, -0.02382047f, 0.03071463f, 
    -0.01911174f, -0.03201827f, 0.25218937f, 0.03198362f, 0.14875573f, 0.24912149f, 0.08771944f, -0.19849384f, 
    -0.07280184f, -0.07147861f, -0.20301732f, 0.08146489f, -0.05664053f, 0.14303775f, 0.01516983f, -0.06963680f, 
    0.01437321f, -0.02487328f, 0.02252444f, -0.05669139f, 0.18076266f, -0.14879958f, -0.04632973f, 0.32875422f, 
    0.25867543f, 0.01543056f, 0.07074382f, -0.04097175f, -0.08918829f, 0.09190034f, 0.06061659f, 0.14640141f, 
    0.17712556f, -0.23529118f, -0.28744659f, -0.22126417f, -0.16979025f, 0.04421646f, 0.08542396f, 0.15311360f, 
    0.10508065f, 0.37296623f, 0.02098083f, 0.00938490f, -0.02966777f, 0.21846387f, 0.18495163f, 0.02740727f, 
    -0.08916187f, 0.14224763f, -0.39426076f, 0.47011438f, 0.11130597f, 0.05908066f, 0.00272692f, -0.01622859f, 
    -0.00065025f, -0.07722958f, 0.04443044f, -0.23996858f, 0.05495606f, 0.15830931f, -0.29865688f, 0.01095533f, 
    -0.24262063f, 0.16233377f, 0.05352471f, 0.07297713f, 0.21273966f, -0.08003687f, -0.18750852f, -0.17287885f, 
    -0.00469922f, -0.11549831f, -0.00120718f, -0.15835106f, -0.01727173f, 0.28105837f, 0.02541868f, -0.24684951f, 
    -0.05325903f, -0.22993119f, 0.26049033f, 0.17041381f, 0.07323273f, 0.09687907f, 0.33193201f, 0.07430302f, 
    -0.07243544f, 0.23754084f, 0.10723142f, 0.06822568f, 0.22928990f, 0.06707681f, 0.08207668f, 0.23046803f, 
    0.13499406f, -0.07712992f, -0.24944316f, -0.22950147f, -0.08675012f, 0.10603125f, 0.11777364f, -0.13407621f, 
    0.33157766f, -0.66579407f, -0.66767859f, 0.10862378f, 0.09850395f, -0.00403004f, 0.01604695f, 0.06544823f, 
    -0.01134868f, -0.92076856f, -0.05099602f, 0.36030096f, -0.20463191f, -0.05685621f, -0.24493453f, -0.10210449f, 
    0.11146784f, 0.18915777f, 0.02434959f, 0.25749612f, 0.31529072f, -0.05607657f, -0.00684772f, -0.15447846f, 
    0.04185126f, 0.12146554f, 0.25774580f, 0.01391254f, -0.32788849f, 0.00865974f, -0.12680113f, 0.07614783f, 
    0.20138311f, 0.03870345f, 0.04672256f, 0.19983460f, -0.28926355f, -0.20768654f, -0.14022429f, 0.14978951f, 
    -0.00374026f, 0.15073930f, 0.09643529f, 0.04170756f, 0.06741542f, -0.04441793f, -0.77812970f, -0.15637064f, 
    -0.35260409f, 0.12190747f, -0.02415259f, 0.08439456f, 0.05170451f, -0.02977889f, -0.29314053f, -0.37377307f, 
    -0.13789396f, -0.10285131f, -0.04071474f, -0.19190967f, 0.18386449f, 0.07894947f, 0.11323436f, -0.88162559f, 
    -0.95790642f, -0.22027205f, -0.29310155f, -0.07976723f, -0.00469128f, -0.15633674f, -0.12152750f, -0.19152653f, 
    0.05145020f, -0.10610745f, -0.00404920f, 0.22611678f, 0.09495785f, 0.03265769f, -0.67904925f, -0.36237228f, 
    -0.15597437f, -0.00022896f, 0.14650968f, 0.22805524f, -0.05367337f, 0.16876657f, -0.10126828f, -0.01756025f, 
    -0.03016122f, 0.13812613f, 0.29506084f, 0.20777540f, 0.02247752f, -0.15854600f, -0.06995332f, 0.03398375f, 
    0.05607664f, 0.10480871f, -0.03135888f, 0.12561548f, 0.14906132f, 0.02088078f, 0.02428827f, 0.04978275f, 
    0.01637872f, 0.14314054f, -0.10312438f, -0.13120872f, 0.04675115f, -0.23777235f, 0.22525029f, 0.05569777f, 
    0.14931287f, 0.00191820f, 0.01160719f, 0.07937398f, 0.12103524f, 0.08409207f, -0.01149947f, 0.25224504f, 
    -0.02541280f, 0.01844093f, -0.14750242f, 0.13803686f, 0.01562178f, -0.25864583f, 0.16916934f, 0.12427994f, 
    -0.16461977f, 0.04986772f, 0.13037460f, 0.08857924f, -0.06860428f, -0.11226999f, -0.03302685f, 0.06374689f, 
    0.09828918f, -0.19161814f, 0.02033623f, -0.07899207f, 0.06330168f, 0.05902101f, -0.06763807f, -0.01675994f, 
    0.18599185f, 0.21804549f, -0.09374315f, 0.08995254f, -0.06386237f, 0.00873417f, 0.08599047f, -0.06025164f, 
    -0.13097788f, 0.37511614f, 0.00235863f, -0.15526067f, -0.18266442f, 0.19512855f, 0.11561239f, -0.26958176f, 
    0.06208512f, -0.08725198f, 0.08302157f, -0.00070086f, -0.03431844f, 0.23385860f, -0.01368960f, -0.41182196f, 
    -0.14038442f, -0.28944048f, -0.13020162f, 0.17046438f, -0.05296111f, 0.20409630f, -0.03720861f, -0.11199520f, 
    -0.02784159f, -0.21005994f, 0.04627985f, -0.18125823f, -0.13288462f, 0.08702701f, 0.16904126f, 0.04342932f, 
    -0.03192236f, 0.07179845f, 0.02163719f, 0.15687682f, -0.06040975f, 0.00212031f, -0.04507151f, 0.10956562f, 
    0.08068909f, 0.15397930f, 0.02883997f, -0.02096604f, -0.05266631f, 0.12476800f, -0.28568110f, -0.19824061f, 
    -0.17190857f, 0.06110816f, 0.06773876f, 0.03412224f, 0.06664595f, 0.27550504f, 0.12476502f, 0.03583777f, 
    -0.23205359f, -0.30584624f, 0.10589924f, 0.11720060f, 0.01918825f, 0.12102275f, 0.06818213f, -0.17339198f, 
    -0.10738073f, 0.34378341f, 0.35858858f, 0.09878529f, 0.11800557f, 0.10632939f, -0.19088663f, 0.01640649f, 
    0.05909280f, 0.03618425f, -0.14809765f, 0.33457959f, -0.08600263f, 0.08396443f, 0.17171286f, 0.13106059f, 
    0.22651155f, 0.10966059f, 0.16732393f, 0.16528466f, -0.02576055f, -0.02859073f, 0.08107407f, 0.04460015f, 
    0.09150390f, 0.04214214f, -0.14266373f, 0.01186745f, 0.07412843f, 0.04517349f, 0.01846077f, 0.10642859f, 
    0.11472932f, -0.22180185f, -0.21302350f, -0.09986480f, 0.02774513f, -0.01546278f, -0.05222290f, 0.36988223f, 
    0.12269937f, -0.27613521f, -0.40072182f, -0.28027198f, -0.24683845f, -0.00841909f, 0.17591320f, 0.27443889f, 
    -0.07254297f, 0.23724005f, -0.14089270f, 0.02332477f, 0.07354131f, 0.12911698f, 0.04852888f, -0.19818991f, 
    -0.08270293f, -0.05898590f, -0.17976670f, 0.12555757f, -0.23434347f, -0.23532893f, -0.02928636f, 0.14540169f, 
    0.13534807f, 0.01643917f, -0.09813571f, 0.27203190f, 0.19076653f, -0.07282031f, -0.14086831f, 0.00670917f, 
    0.36385122f, -0.14041787f, -0.05264029f, 0.38460717f, 0.12670672f, 0.21800311f, -0.02227111f, 0.11284507f, 
    0.19438393f, -0.11355293f, 0.08937836f, 0.13472742f, 0.09162758f, -0.01403811f, 0.16476363f, 0.23511536f, 
    0.07570105f, -0.25490201f, 0.04594700f, 0.13466445f, -0.20676687f, -0.14511524f, -0.00614054f, -0.02784926f, 
    0.19965373f, -0.10675320f, -0.26924577f, -0.18299709f, 0.11570781f, 0.11667886f, -0.01144094f, -0.07126427f, 
    -0.11403985f, 0.05689793f, -0.24127467f, -0.08952906f, -0.17499556f, 0.04212855f, 0.09398390f, 0.13098660f, 
    0.02736012f, -0.17453042f, 0.02427072f, -0.14208250f, 0.17585458f, -0.29141948f, -0.23287532f, 0.51650566f, 
    -0.14893088f, -0.01524345f, -0.00688773f, -0.09000430f, 0.19600736f, 0.04978918f, -0.03145825f, 0.04256841f, 
    -0.04061126f, 0.01901780f, 0.12750868f, -0.03505262f, -0.08823062f, -0.37101427f, -0.37466905f, -0.23270777f, 
    -0.13463400f, -0.00367529f, 0.07721774f, -0.16992158f, 0.16155896f, 0.16133545f, 0.15282105f, -0.01634368f, 
    -0.23980434f, -0.01436493f, -0.30485362f, 0.03709723f, -0.00606641f, -0.15213205f, 0.02097595f, -0.10347380f, 
    -0.04664049f, 0.06458305f, -0.32810161f, -0.00399375f, 0.07943184f, -0.03141600f, -0.22102074f, 0.01584721f, 
    0.08665957f, 0.24102855f, -0.11698354f, -0.03780274f, -0.23309371f, 0.06463937f, 0.28519648f, -0.29528925f, 
    -0.10087027f, 0.01152528f, -0.07017984f, -0.23062661f, 0.08025213f, -0.27060968f, 0.03686040f, 0.02761733f, 
    -0.14919549f, -0.11265105f, -0.21545774f, -0.06238944f, -0.25869659f, -0.29202116f, -0.24082027f, 0.07990073f, 
    0.19184539f, 0.17536096f, 0.03000005f, 0.01224461f, -0.00056262f, -0.18722193f, 0.17412367f, 0.36804041f, 
    -0.24043652f, -0.05493285f, -0.15407725f, 0.25388423f, -0.10990435f, -0.09316853f, 0.23566952f, -0.15572010f, 
    0.19467594f, -0.08549991f, 0.01188430f, -0.31857759f, -0.01663685f, 0.09570581f, 0.23040548f, 0.01798980f, 
    0.14596972f, -0.18944918f, -0.21239623f, 0.03606072f, 0.09787692f, 0.20051959f, 0.07555684f, -0.07653594f, 
    -0.01511656f, -0.19113114f, -0.27033135f, -0.16697179f, -0.01623153f, -0.03069921f, -0.02453212f, 0.07971972f, 
    -0.06813747f, -0.01644062f, 0.31973574f, 0.32233942f, -0.09830322f, 0.10464583f, 0.16816092f, 0.05451509f, 
    0.02535368f, -0.02772623f, 0.17848018f, 0.12016212f, 0.05732571f, 0.04836658f, -0.08116420f, 0.10911486f, 
    0.05467333f, -0.04434051f, -0.15771644f, 0.10568449f, 0.13573475f, 0.09120426f, -0.43015733f, 0.07310006f, 
    0.09664745f, -0.02559783f, 0.24516492f, -0.35789362f, -0.31837341f, -0.00041821f, 0.22712438f, -0.18547435f, 
    -0.16123833f, -0.00199372f, 0.05488655f, 0.02909830f, -0.06293447f, 0.10002552f, -0.03467027f, 0.24049129f, 
    -0.14072457f, -0.13997388f, -0.26584041f, -0.03379415f, 0.13810353f, 0.19734265f, -0.19269338f, 0.15698588f, 
    -0.15545204f, 0.01339041f, 0.11718208f, 0.06628036f, 0.25841910f, 0.01924197f, 0.00484633f, -0.09336207f, 
    0.14007702f, -0.59675652f, -0.09969123f, 0.16996056f, -0.16739817f, 0.02410294f, -0.09356113f, 0.11814797f, 
    0.14980438f, -0.30869830f, 0.33291462f, -0.11581483f, 0.01746040f, 0.13335013f, -0.03788127f, -0.02471892f, 
    0.11415810f, -0.00420015f, -0.06608641f, 0.17535558f, 0.07825411f, 0.19182800f, 0.12436187f, 0.03989279f, 
    0.18732399f, 0.00685579f, -0.23679072f, -0.31356046f, -0.37690446f, -0.09434675f, 0.09734117f, -0.12567428f, 
    -0.02717513f, -0.05723911f, -0.00264615f, -0.03983406f, 0.20756046f, -0.18151359f, -0.07953180f, -0.00406509f, 
    0.04201601f, 0.00216507f, -0.24605565f, 0.06708138f, 0.15728565f, 0.04500644f, 0.29153711f, 0.19701067f, 
    0.02340426f, 0.01152511f, -0.13841231f, 0.01937471f, -0.07843665f, -0.00144355f, -0.12666935f, -0.02871201f, 
    -0.02610410f, -0.01061025f, -0.15364011f, 0.00239911f, 0.09008567f, 0.09404824f, -0.02736886f, 0.30334049f, 
    0.08185552f, 0.01030521f, 0.31822568f, 0.10703229f, -0.00921394f, 0.25840944f, -0.12473930f, 0.10084561f, 
    0.14200468f, -0.18120076f, -0.06938653f, 0.15089852f, -0.14284039f, 0.02224963f, 0.04118472f, 0.21098271f, 
    -0.34784827f, 0.56586254f, 0.49571368f, 0.23811306f, -0.03704444f, -0.25799510f, 0.03973680f, 0.24986631f, 
    0.10067870f, -0.27820009f, 0.50201672f, 0.04892049f, -0.04819729f, 0.02362241f, -0.08068180f, 0.24253073f, 
    0.22859217f, 0.04565229f, -0.43477505f, 0.26193592f, -0.58303159f, -0.12498543f, 0.19460750f, -0.15319227f, 
    -0.03929951f, 0.06135064f, -0.07190500f, -0.08713600f, 0.22631921f, 0.37403509f, 0.03730565f, -0.03914899f, 
    -0.02528398f, -0.04984773f, -0.03201771f, -0.10546976f, -0.20439932f, -0.23810345f, -0.17883943f, 0.04472085f, 
    -0.04372192f, -0.04370165f, -0.18129742f, -0.11720759f, -0.00188101f, 0.13165131f, 0.27231100f, 0.46678200f, 
    -0.10605402f, -0.21041821f, 0.10150959f, -0.00587858f, -0.02155606f, -0.16364534f, 0.05084748f, 0.16726878f, 
    0.02615150f, -0.00830427f, -0.03590103f, 0.03022093f, 0.03704380f, 0.01758685f, 0.18372361f, -0.11443873f, 
    0.44149595f, -0.14746614f, 0.20671128f, 0.04296436f, -0.02508921f, 0.05624767f, 0.28056166f, 0.10748957f, 
    -0.07910383f, -0.05819678f, -0.04026289f, 0.04264021f, 0.01612050f, 0.07861187f, -0.05534171f, 0.27285638f, 
    -0.08053145f, 0.18365027f, 0.24238156f, 0.12360328f, 0.03076286f, -0.07151607f, -0.03407324f, -0.04965916f, 
    -0.01164914f, -0.03248304f, -0.08392726f, 0.05527649f, -0.13556813f, -0.08129169f, 0.01611838f, -0.12009273f, 
    0.03058096f, -0.04028775f, 0.03624468f, -0.15933828f, -0.00697702f, 0.16822001f, -0.08293289f, -0.09797771f, 
    -0.01501715f, -0.09283495f, 0.00543300f, -0.10637512f, 0.19845916f, 0.02623328f, -0.07153010f, 0.02346840f, 
    0.09516176f, 0.09074214f, -0.00675099f, 0.02946189f, 0.12686464f, -0.18162085f, -0.38163447f, 0.03264268f, 
    0.15041596f, 0.18877256f, 0.17819482f, -0.02057517f, 0.09120767f, 0.03238916f, 0.42750964f, 0.41081715f, 
    -0.09927920f, 0.11287689f, 0.02405828f, 0.02823126f, 0.03094952f, -0.06501016f, -0.07187870f, 0.05414944f, 
    -0.18488875f, -0.20386758f, -0.09043157f, 0.05320399f, -0.03255109f, 0.20084395f, -0.06076167f, -0.06850204f, 
    -0.03601930f, -0.08028766f, -0.05216125f, 0.09017039f, -0.11878645f, -0.00523634f, 0.13349417f, 0.09557904f, 
    0.08035725f, 0.16384931f, 0.16074964f, -0.01075073f, 0.04847101f, -0.14782581f, -0.16417030f, 0.17609277f, 
    0.06939647f, 0.07661223f, 0.08640021f, 0.04851094f, 0.02337976f, 0.23731118f, -0.06760778f, 0.21874726f, 
    0.04528244f, 0.12571803f, -0.06527367f, -0.63695258f, 0.59480995f, -0.28756395f, -0.28601983f, -0.59664667f, 
    0.33445251f, 0.00267842f, 0.20714082f, -0.02515566f, -0.19795004f, -0.06020132f, -0.02795520f, -0.10547127f, 
    -0.14133297f, -0.08037640f, 0.04273443f, -0.18491064f, -0.03540423f, 0.23135443f, 0.07481426f, 0.08555570f, 
    0.12309866f, -0.01677008f, 0.23212571f, 0.00083372f, 0.04969125f, 0.08317797f, 0.23609748f, 0.19998372f, 
    -0.18911825f, -0.18981689f, 0.09287043f, 0.15239593f, 0.10725538f, 0.16592841f, 0.11925550f, 0.48361966f, 
    0.52381051f, 0.07894548f, -0.01575866f, 0.01589551f, -0.02001526f, 0.14006685f, -0.17570034f, 0.08891600f, 
    -0.00289948f, 0.24551976f, 0.14549844f, -0.10843489f, -0.04972880f, -0.17395613f, -0.06712151f, 0.04444982f, 
    -0.05296086f, 0.09144793f, 0.02713767f, -0.08095575f, -0.14388759f, 0.17957757f, 0.24981204f, -0.02600388f, 
    0.11281803f, 0.12182647f, -0.08912846f, -0.01447529f, -0.13064951f, 0.02410748f, -0.00528181f, 0.01957977f, 
    0.07946081f, 0.11897564f, 0.06551988f, 0.12479876f, 0.05952116f, 0.00991507f, -0.03328842f, -0.03092095f, 
    -0.07595087f, 0.09412675f, -0.20385987f, -0.06719089f, 0.29338518f, 0.21596761f, -0.20349222f, 0.15393840f, 
    0.02105090f, 0.04798583f, -0.01361585f, 0.10560872f, -0.00609153f, -0.06280741f, 0.11752714f, -0.01976072f, 
    0.01989505f, -0.03446826f, 0.05766917f, -0.04356141f, 0.10595094f, -0.02254286f, 0.17147733f, -0.14004457f, 
    -0.05640194f, -0.10600302f, -0.13573457f, -0.07065854f, 0.02159183f, -0.20936903f, -0.10745019f, 0.25229260f, 
    0.38717514f, 0.29402289f, 0.08670481f, 0.01211532f, 0.17706195f, -0.03772131f, 0.08656249f, -0.05881899f, 
    0.61629444f, -0.00003318f, 0.01961947f, -0.09562902f, 0.02418360f, -0.05826255f, 0.14547962f, 0.13367571f, 
    0.15162943f, -0.17651473f, 0.16141328f, -0.01399871f, -0.03101623f, -0.03203284f, 0.02614926f, 0.09063686f, 
    0.07823274f, -0.14635998f, -0.10867615f, -0.21632005f, -0.23481832f, -0.17930865f, 0.00976257f, -0.02605915f, 
    -0.03967084f, -0.19845870f, -0.02986834f, 0.04927908f, 0.05159738f, -0.02518404f, 0.02812000f, -0.03170244f, 
    -0.19663246f, -0.03833960f, -0.05859340f, 0.02611159f, -0.06816880f, 0.01866732f, 0.05784050f, -0.05198199f, 
    -0.21173689f, 0.04170059f, -0.11276115f, 0.12519217f, -0.04431767f, 0.73377711f, 0.33400774f, -0.02531585f, 
    0.01116431f, 0.14619273f, 0.01000601f, -0.07477417f, 0.15135111f, -0.20310444f, 0.06854128f, -0.11167838f, 
    0.06781911f, 0.05410019f, -0.01354539f, -0.21350549f, 0.16491790f, 0.01354387f, -0.03759506f, -0.40431777f, 
    0.17892271f, 0.42462355f, 0.24855079f, -0.26798221f, 0.08226085f, 0.09619612f, 0.06357680f, -0.29692236f, 
    0.18092382f, 0.20369440f, 0.09911967f, -0.04917122f, -0.24011430f, 0.02477792f, 0.15180185f, 0.14196932f, 
    0.14124975f, 0.00110972f, -0.01797569f, -0.02344404f, -0.05010141f, -0.11648422f, -0.06861416f, 0.05541040f, 
    0.06330464f, -0.05171023f, 0.02315354f, 0.01055556f, 0.01580286f, 0.05025161f, -0.04551640f, 0.05183201f, 
    -0.05965130f, 0.26014358f, -0.00524197f, 0.04352786f, 0.01919688f, 0.09461275f, -0.03101405f, 0.03124506f, 
    -0.05778970f, 0.23964457f, -0.12350300f, 0.14232756f, -0.07804591f, -0.21034671f, -0.33316824f, -0.10519992f, 
    0.20798698f, 0.07249628f, -0.14635624f, 0.11109730f, 0.03778136f, 0.25940114f, -0.11164092f, -0.37099165f, 
    -0.25299284f, 0.12988748f, -0.03411384f, 0.16268620f, 0.06178172f, -0.04537921f, 0.58588547f, -0.02783854f, 
    0.36232528f, -0.11616952f, -0.06963915f, -0.08264647f, 0.15683925f, 0.06951593f, -0.18205035f, 0.28499424f, 
    0.00226347f, -0.18918195f, -0.12067015f, -0.05843868f, 0.10300640f, -0.01567352f, 0.05138982f, 0.04058082f, 
    0.22285694f, 0.06149132f, -0.00298953f, 0.11895321f, -0.02685778f, -0.10835372f, 0.05105167f, -0.04233829f, 
    0.07841679f, 0.01141807f, 0.20795554f, 0.04347151f, -0.07710537f, -0.05588789f, 0.13841173f, 0.01108978f, 
    0.33320549f, 0.00066595f, 0.23839188f, 0.07088520f, 0.03424734f, 0.15499215f, -0.05677694f, 0.13056248f, 
    0.09657763f, 0.05113013f, 0.10004435f, 0.43821046f, -0.01674776f, -0.30323157f, 0.14228819f, 0.00558908f, 
    -0.18850312f, 0.01800547f, 0.22076981f, 0.18254495f, 0.02987218f, 0.05832968f, -0.03882300f, 0.08644968f, 
    0.09106698f, 0.15925553f, -0.12500590f, -0.13661127f, -0.04124790f, -0.07214100f, -0.13452569f, -0.33115345f, 
    -0.12793289f, -0.07400277f, -0.07086007f, -0.06486223f, -0.07198044f, 0.05477075f, -0.10447084f, 0.04254909f, 
    0.20805077f, 0.13088468f, -0.00066967f, -0.08129200f, -0.15499711f, -0.20108986f, -0.11395370f, 0.04906235f, 
    -0.00816545f, 0.03212931f, 0.10940027f, -0.18002477f, -0.04074835f, 0.03462074f, -0.01348605f, -0.12287366f, 
    0.06053960f, -0.00199316f, 0.01239096f, 0.01360047f, 0.04598036f, 0.04070392f, 0.02158045f, -0.01941517f, 
    -0.00640978f, -0.04027021f, -0.29342583f, -0.21192260f, -0.25807986f, -0.07538515f, -0.03836160f, -0.01337305f, 
    -0.10444205f, -0.13210599f, 0.10925470f, 0.16965035f, 0.17521067f, 0.06590096f, -0.09083039f, -0.14625280f, 
    -0.08052600f, -0.17167971f, -0.09907816f, 0.27833995f, 0.19330755f, 0.07520512f, -0.26361582f, -0.08509667f, 
    -0.30902886f, -0.21331623f, -0.18617640f, 0.07706867f, 0.15299687f, 0.18366653f, -0.05681338f, 0.45355767f, 
    -0.19000004f, 0.07772712f, 0.08832205f, 0.12660840f, 0.15076450f, -0.02247375f, -0.06714194f, -0.31320468f, 
    -0.02988258f, -0.07939529f, -0.01482511f, -0.03932502f, 0.08355557f, 0.00849702f, -0.19546801f, 0.24023840f, 
    0.19832909f, -0.02116578f, 0.05308035f, 0.00747109f, 0.03613128f, 0.08209097f, 0.20537803f, 0.03224021f, 
    0.03912273f, -0.12187811f, -0.01382898f, -0.05838370f, -0.15572590f, -0.10216361f, -0.05346284f, -0.05969731f, 
    -0.49471501f, -0.07811980f, -0.28704169f, -0.24432452f, 0.16039319f, 0.07723069f, 0.05787305f, -0.10050736f, 
    -0.09856212f, 0.12778592f, 0.30176252f, 0.33428690f, 0.29477167f, 0.12302651f, -0.16204517f, -0.17753585f, 
    -0.26962599f, 0.00984569f, 0.05976113f, 0.24624732f, 0.07873146f, 0.01329841f, -0.04474373f, 0.05262486f, 
    -0.14972107f, 0.09819607f, 0.17926095f, -0.42130527f, 0.10234872f, -0.15667213f, -0.09790086f, 0.02731607f, 
    0.07725964f, -0.17036958f, 0.14736226f, 0.07076996f, -0.26361492f, -0.18857162f, -0.27708980f, 0.00481888f, 
    0.03521308f, -0.04047827f, 0.09524802f, -0.13090177f, 0.23709413f, 0.00331659f, -0.03638087f, 0.25714666f, 
    -0.30935779f, 0.29799211f, -0.10715130f, -0.04544178f, -0.15488693f, -0.01906692f, 0.22296426f, -0.11790051f, 
    -0.01643835f, -0.32456800f, -0.28599232f, -0.18876868f, -0.10743099f, 0.01549372f, 0.06944279f, -0.09203839f, 
    0.25015146f, -0.03823614f, -0.22706619f, 0.19018580f, 0.03517677f, -0.21439448f, -0.43017471f, 0.08720997f, 
    0.21026306f, -0.06402508f, -0.04583656f, 0.11915599f, -0.05832339f, 0.00598935f, 0.31306812f, -0.05952555f, 
    -0.05019402f, 0.05662251f, -0.20733447f, -0.13182163f, -0.14837226f, -0.13839611f, -0.04145743f, 0.02386795f, 
    0.00259576f, 0.09729587f, 0.06867463f, 0.14846592f, -0.08460519f, 0.18258551f, 0.07948279f, 0.06214173f, 
    -0.09287745f, -0.03730642f, -0.05606508f, -0.08700953f, -0.01909287f, -0.04490559f, 0.22559826f, 0.03054523f, 
    0.03140345f, 0.21447423f, -0.00873846f, 0.02010324f, -0.22208634f, -0.38330147f, -0.00127244f, 0.04266221f, 
    0.09650941f, 0.12382724f, 0.12749144f, 0.11967742f, 0.00565611f, -0.11612252f, -0.09949847f, 0.04708853f, 
    -0.02446527f, 0.01739047f, -0.02905543f, 0.07467819f, -0.01971181f, -0.15152311f, -0.05909343f, -0.09079892f, 
    -0.27073696f, -0.41147083f, -0.07086083f, 0.37055853f, 0.00587891f, -0.03668674f, 0.13842700f, 0.00684232f, 
    0.07731606f, 0.18691432f, -0.10145272f, -0.10955463f, 0.00296467f, 0.09746453f, -0.06169277f, -0.17183928f, 
    0.00875660f, -0.11630733f, 0.05632983f, 0.07384016f, -0.00368333f, -0.00957485f, 0.13350931f, 0.06983737f, 
    -0.02398583f, -0.04767006f, 0.08372345f, -0.17210750f, 0.24459635f, -0.06634168f, -0.14409052f, -0.07080843f, 
    -0.18047397f, -0.09330573f, -0.15634288f, -0.01027673f, 0.15275644f, 0.02024501f, 0.07927030f, 0.13819195f, 
    0.02536113f, -0.28749287f, 0.11462601f, 0.54407376f, -0.34594175f, -0.37690374f, -0.06779736f, 0.29754001f, 
    0.09122706f, -0.18082882f, -0.03772540f, -0.09507281f, 0.03789973f, -0.09470759f, 0.29509285f, 0.07395419f, 
    -0.23558566f, 0.06058125f, 0.00065703f, 0.12750450f, 0.05208472f, -0.09766115f, -0.63860452f, -0.20119712f, 
    -0.23946366f, -0.12774847f, 0.06840616f, -0.10349238f, -0.05277691f, 0.06589828f, 0.15392320f, 0.20753378f, 
    0.35205361f, -0.25098392f, 0.02010849f, -0.00684548f, 0.01274357f, 0.16190612f, -0.26822737f, -0.04165220f, 
    0.14484259f, 0.29525477f, -0.30583936f, -0.03838376f, 0.03345909f, 0.18600175f, -0.01679264f, -0.16855852f, 
    0.15966181f, -0.21239790f, -0.41268688f, -0.11044279f, -0.28804690f, 0.01834807f, -0.04672313f, 0.11389604f, 
    0.00316988f, 0.22117557f, 0.33085719f, 0.28384972f, -0.36176109f, -0.07506924f, 0.02801436f, -0.13234062f, 
    -0.03599782f, -0.21248107f, -0.05865264f, 0.04233874f, 0.00826326f, 0.17741232f, 0.08179594f, 0.04991707f, 
    0.07636821f, 0.05629193f, -0.02116675f, 0.10637503f, 0.02435581f, 0.17230406f, 0.09270687f, -0.07261792f, 
    -0.03168314f, 0.09282987f, -0.05286678f, 0.16132928f, 0.36232874f, 0.26752952f, 0.13929139f, -0.03614223f, 
    -0.18477984f, 0.06257312f, -0.18315585f, -0.21264645f, 0.01475524f, 0.04950629f, -0.10173180f, -0.48003349f, 
    -0.06645689f, -0.07913265f, 0.20747010f, -0.07980293f, 0.02304647f, 0.07344684f, 0.04261567f, 0.26067400f, 
    0.20344450f, 0.11870982f, 0.08876491f, -0.03868464f, 0.22358409f, 0.01580689f, 0.04671123f, -0.10841139f, 
    0.00587352f, -0.64955354f, -0.45873520f, -0.27136835f, 0.01896078f, 0.02199172f, -0.00177255f, 0.05514335f, 
    -0.19089358f, -0.41030484f, -0.19752941f, 0.05294849f, 0.03512390f, -0.33022603f, 0.18908478f, 0.11969429f, 
    -0.04968028f, 0.19801190f, 0.08808421f, 0.19671965f, 0.12196492f, -0.07851308f, 0.10686853f, 0.01738538f, 
    0.10000037f, -0.06622096f, -0.08956802f, 0.03413449f, 0.13407448f, -0.00429802f, 0.09037202f, -0.08587421f, 
    0.13885184f, 0.02510900f, 0.05831704f, 0.15499786f, 0.37693125f, -0.54818010f, -0.03616159f, 0.08563733f, 
    -0.03173951f, -0.05210135f, -0.14170597f, 0.09087470f, 0.15109664f, 0.00532412f, -0.08974605f, 0.13636698f, 
    -0.01235887f, 0.15697700f, -0.00724488f, -0.06349854f, 0.04779290f, 0.46129140f, -0.17432117f, -0.20730340f, 
    -0.23357555f, -0.09268727f, 0.22826456f, -0.19511193f, -0.20365115f, -0.09231410f, 0.00286391f, -0.05197971f, 
    0.15159586f, -0.04538635f, -0.09212495f, -0.07905851f, 0.14208746f, -0.07206988f, -0.00608969f, 0.00560255f, 
    -0.12019601f, -0.11873049f, 0.21399817f, -0.19096732f, 0.06782790f, 0.01130151f, -0.02049535f, -0.13151391f, 
    0.43377003f, 0.09036475f, 0.23065048f, 0.00390467f, 0.07261705f, 0.05844206f, 0.03443682f, -0.08359849f, 
    -0.13495822f, 0.03765665f, 0.03000234f, 0.19209380f, -0.04758405f, 0.02076030f, 0.06095606f, 0.08129358f, 
    0.04355481f, -0.04808544f, 0.13848987f, -0.31872302f, -0.10726872f, 0.24858584f, -0.07130983f, -0.04870454f, 
    0.06268035f, 0.02695506f, -0.13151634f, -0.09333908f, -0.22195527f, -0.21520209f, 0.06563251f, -0.06496822f, 
    0.04459257f, -0.18043108f, 0.00812783f, -0.21731378f, 0.25023800f, 0.32321683f, -0.26913598f, -0.04961678f, 
    -0.12947328f, 0.04466873f, 0.08629487f, -0.02014376f, -0.04533913f, -0.23477346f, -0.33335859f, 0.00877648f, 
    0.08113998f, 0.06322077f, 0.01678189f, 0.05597830f, -0.12408599f, 0.10797586f, 0.02070951f, -0.14189555f, 
    0.46754780f, 0.15023018f, 0.02024002f, -0.05646747f, 0.08676059f, 0.13456279f, -0.07864662f, 0.33137205f, 
    -0.25684252f, -0.18948959f, 0.09751391f, -0.07877814f, -0.02632534f, 0.24373572f, 0.00587417f, -0.07299215f, 
    0.00525274f, -0.25258493f, -0.55459177f, 0.03590454f, 0.04314060f, 0.05712956f, -0.09489919f, -0.06439570f, 
    -0.22974949f, 0.14963359f, -0.30644315f, -0.07875165f, 0.09988963f, 0.11950918f, 0.23754807f, 0.25170001f, 
    0.23631692f, -0.41780782f, 0.11987840f, -0.04922022f, 0.22934394f, 0.04093910f, 0.13942672f, -0.07313147f, 
    0.10625857f, -0.01857009f, -0.36344218f, 0.32744676f, 0.03404259f, -0.30153552f, -0.08330646f, 0.12659146f, 
    -0.01697038f, 0.04886845f, -0.10041711f, -0.06682935f, -0.05419925f, -0.06311463f, -0.04423326f, -0.14373742f, 
    0.02874406f, 0.01347892f, 0.10721719f, -0.06508000f, -0.12002916f, -0.10805087f, -0.13394503f, 0.38300341f, 
    -0.02350532f, -0.12052258f, -0.06009072f, 0.06589702f, -0.09347735f, -0.04275408f, 0.26311466f, -0.30438533f, 
    -0.05110158f, -0.02430359f, 0.13830818f, 0.06131613f, -0.02304662f, 0.01824231f, 0.00674138f, -0.00293157f, 
    -0.20619704f, 0.06429797f, 0.02007739f, -0.01207564f, 0.04766557f, 0.07151812f, -0.02691922f, 0.00355834f, 
    -0.10392969f, 0.43695554f, 0.07329131f, 0.18889172f, -0.01706757f, -0.15168214f, 0.07178961f, -0.02400085f, 
    -0.08440480f, -0.19525287f, -0.09523978f, 0.09263180f, 0.14634392f, -0.04230642f, 0.04897484f, -0.07695843f, 
    0.03573259f, 0.13654956f, 0.05408731f, -0.36514661f, -0.21124169f, 0.08469553f, -0.01682928f, -0.10766634f, 
    -0.11604501f, 0.01307748f, -0.04096055f, 0.04643793f, -0.07909428f, -0.50299263f, 0.01073227f, 0.04884950f, 
    0.15345672f, -0.25990582f, -0.09414127f, 0.23901466f, 0.33640942f, 0.10366049f, 0.19445129f, 0.05707601f, 
    0.12670922f, -0.16823553f, 0.01064367f, -0.13179785f, -0.12665179f, 0.12878603f, 0.18018718f, 0.23615769f, 
    -0.07375730f, -0.02972067f, 0.02228470f, -0.00435959f, -0.11692406f, -0.09761265f, -0.20516568f, 0.04686933f, 
    -0.14752588f, -0.08117818f, -0.11905389f, 0.06002181f, 0.00852875f, -0.04982287f, 0.06618918f, 0.53821862f, 
    -0.07361294f, 0.15485588f, 0.10613441f, -0.13431624f, 0.04912664f, -0.06652000f, 0.13824192f, -0.08381646f, 
    0.13813967f, 0.19948021f, 0.02110885f, -0.03685885f, -0.04725477f, 0.15172495f, 0.11582132f, -0.02992813f, 
    0.02351592f, -0.11890929f, 0.12520975f, -0.00668599f, 0.00377299f, -0.05437090f, 0.06864174f, 0.08695360f, 
    -0.12858270f, 0.14993919f, 0.07075434f, -0.14821698f, -0.25275710f, 0.13601278f, -0.07755306f, -0.25665823f, 
    0.09441791f, -0.09385082f, 0.02775873f, 0.00167584f, 0.13543102f, 0.11811938f, 0.04754588f, 0.00151383f, 
    0.03681393f, -0.06154006f, -0.04207995f, -0.08395524f, -0.19332622f, 0.48259816f, -0.10673089f, 0.07254843f, 
    0.07287797f, -0.07838760f, 0.06943032f, -0.00983816f, -0.26449144f, -0.47643986f, 0.33072233f, 0.04704352f, 
    -0.01315152f, 0.09052701f, 0.11894072f, 0.10961310f, 0.08412440f, 0.22036152f, -0.05340973f, -0.33986899f, 
    -0.30446512f, -0.06735760f, 0.05759697f, 0.17007956f, -0.00965778f, -0.09019794f, -0.09757153f, 0.23256640f, 
    0.36691904f, -0.90867603f, -0.17311725f, -0.13089800f, 0.33338061f, 0.04822950f, 0.10920384f, 0.09376651f, 
    0.09391376f, -0.01899371f, -0.06332564f, -0.02226277f, 0.01206521f, -0.12362850f, 0.21611656f, 0.20664260f, 
    0.10545722f, -0.33345276f, 0.00117062f, 0.06908337f, -0.01714598f, 0.08214014f, 0.04467265f, 0.12231497f, 
    0.00146395f, -0.08619345f, 0.11664552f, -0.14371878f, 0.05214962f, 0.10384211f, 0.00240709f, -0.14516263f, 
    -0.03555168f, 0.17327233f, 0.02825318f, 0.05339088f, -0.10859702f, -0.20738170f, 0.18684272f, 0.08555026f, 
    -0.09356316f, 0.11997546f, 0.13171223f, 0.07308150f, 0.15996799f, 0.07112490f, 0.15171747f, 0.03830941f, 
    0.15185614f, 0.06586402f, -0.03289588f, -0.11588050f, -0.01423131f, -0.07999947f, -0.02109664f, -0.04121791f, 
    -0.08112652f, -0.28382647f, -0.08429339f, 0.21744888f, 0.18475974f, 0.05787712f, -0.38234088f, -0.23165649f, 
    0.31911328f, -0.02297323f, -0.06478796f, 0.17955677f, 0.08051483f, -0.04949504f, 0.03095840f, -0.24680312f, 
    -0.20330618f, 0.02195907f, 0.00768451f, 0.01176826f, -0.06517084f, 0.20589362f, -0.06353910f, -0.12477802f, 
    -0.05244717f, -0.21353611f, 0.05006923f, 0.05797381f, -0.07791644f, -0.05257333f, -0.04221105f, -0.00036236f, 
    -0.13591391f, -0.17870209f, -0.46987706f, 0.52644324f, 0.13849345f, -0.14828287f, -0.07707314f, 0.13054654f, 
    0.12960045f, -0.41909179f, -0.12340946f, -0.05742330f, 0.02213621f, -0.16435944f, -0.12466004f, -0.22725895f, 
    0.12522599f, 0.14597984f, 0.04237614f, 0.86533719f, -0.30778527f, 0.10535210f, 0.17073666f, -0.10751008f, 
    0.17903920f, 0.46081802f, -0.41416606f, -0.14516939f, 0.07196628f, -0.02786072f, 0.02228651f, 0.11006434f, 
    0.04429433f, -0.01869987f, 0.01046694f, -0.15793611f, -0.26237246f, -0.13542910f, -0.05324069f, 0.15176579f, 
    -0.02014576f, 0.02965154f, 0.06927834f, -0.03800306f, -0.18533520f, 0.10186615f, -0.37145793f, -0.08836019f, 
    -0.05695705f, -0.00452727f, 0.07831469f, 0.03842643f, -0.11442645f, -0.50293845f, -0.41411605f, -0.31899196f, 
    -0.25163332f, 0.11633943f, -0.01658463f, -0.08620745f, 0.07074617f, -0.12010133f, -0.38014746f, -0.67372233f, 
    0.33294958f, 0.11893597f, -0.00665775f, 0.08807991f, 0.05660972f, -0.03396388f, 0.04505427f, 0.02313785f, 
    -0.07106660f, -0.38431096f, -0.04238421f, 0.09799192f, 0.04823696f, 0.06606899f, 0.16753298f, -0.24927406f, 
    -0.14671509f, -0.02771464f, -0.05064670f, 0.01518218f, -0.00832450f, 0.09155530f, -0.02454875f, -0.02319998f, 
    0.06407695f, -0.13354926f, -0.19893138f, -0.00207030f, -0.03327638f, -0.13063033f, 0.06689571f, 0.01869437f, 
    0.06546509f, 0.16562285f, 0.17210972f, -0.01575489f, 0.06037765f, -0.00648640f, 0.26197413f, -0.14973414f, 
    -0.19201058f, 0.10951363f, 0.18185414f, 0.06888679f, 0.13283966f, 0.00955400f, 0.08704563f, 0.13298108f, 
    0.05400126f, -0.00158616f, 0.10387876f, 0.01995637f, -0.11971000f, -0.22012509f, 0.18179710f, 0.17096846f, 
    0.08520442f, 0.03162260f, 0.07440750f, 0.14512056f, 0.04367113f, -0.07928196f, -0.07038033f, -0.37830603f, 
    -0.25903526f, 0.11616113f, -0.06318762f, 0.12311643f, 0.02679449f, 0.09414152f, 0.19259657f, -0.09717266f, 
    0.03990475f, 0.24631433f, 0.14112113f, -0.11122983f, 0.02169559f, -0.05251783f, 0.13768819f, -0.21377283f, 
    0.29014331f, -0.06942970f, -0.09645046f, -0.09250794f, 0.22376846f, 0.02192027f, 0.01764081f, 0.13514774f, 
    -0.30790606f, -0.00268383f, -0.06571461f, -0.14247049f, -0.00168976f, 0.01164171f, 0.09224958f, 0.05628630f, 
    -0.07233476f, 0.10556353f, -0.34794289f, 0.09013544f, 0.18622820f, 0.53488898f, 0.11903616f, 0.14163654f, 
    0.10479657f, 0.02966567f, 0.15036778f, -0.07236196f, 0.23787640f, -0.07556272f, 0.01343468f, 0.06723047f, 
    0.00752291f, -0.09784692f, 0.24938452f, 0.21136150f, 0.04561831f, -0.47081065f, -0.29490891f, 0.11004748f, 
    0.09370321f, 0.20859012f, 0.31314051f, -0.00327141f, -0.05124278f, 0.05515131f, 0.04541259f, -0.01210945f, 
    -0.09583687f, 0.02414373f, -0.04207778f, 0.14346384f, 0.18354417f, 0.19749022f, 0.05573260f, 0.48165238f, 
    -0.16513702f, -0.31340799f, 0.05805440f, 0.05971013f, 0.07934571f, -0.35273111f, 0.10220921f, 0.04506384f, 
    -0.08500688f, -0.09272129f, -0.01604247f, -0.06844729f, -0.00905390f, 0.04864590f, -0.25663939f, -0.18386018f, 
    -0.11236795f, -0.19913115f, -0.17439684f, 0.08180576f, 0.13999337f, 0.10981540f, 0.20095535f, -0.10111549f, 
    -0.06021220f, 0.05817946f, -0.18362114f, -0.23952058f, -0.09938737f, -0.05128916f, 0.13927975f, -0.01744525f, 
    -0.07780110f, 0.04143972f, 0.05080443f, -0.00453621f, -0.05705906f, -0.04996107f, 0.08264663f, 0.25615841f, 
    0.00688160f, -0.05788151f, -0.10728935f, 0.01908376f, 0.00907054f, -0.11557287f, 0.00353440f, -0.03543576f, 
    0.02534559f, 0.18599388f, -0.02319719f, 0.01503673f, 0.32764736f, -0.33708626f, 0.25935367f, 0.42556030f, 
    -0.02854997f, 0.00419571f, 0.06135694f, -0.37394077f, -0.07236664f, 0.02265382f, -0.47675523f, -0.64822096f, 
    -0.15288040f, 0.09649656f, 0.12942176f, -0.32256070f, -0.13525100f, -0.02304993f, 0.06367680f, 0.13837694f, 
    0.19100113f, 0.08872795f, 0.09634901f, 0.16850030f, 0.03358748f, 0.00810761f, -0.08512594f, 0.31561559f, 
    0.09581935f, 0.04152585f, 0.06472552f, 0.09756391f, 0.20584713f, 0.12406193f, 0.14197738f, 0.02247165f, 
    0.05085478f, -0.07915467f, 0.02336782f, -0.13096115f, -0.26018795f, -0.09819777f, -0.08205156f, 0.06027946f, 
    0.04078979f, 0.16804232f, -0.19260764f, 0.25196975f, 0.21140800f, -0.28227299f, -0.24366625f, -0.23964092f, 
    -0.01763031f, 0.14656146f, -0.23352692f, -0.78986830f, -0.14063032f, -0.00534359f, -0.14533004f, 0.05292173f, 
    0.06537366f, 0.20941694f, 0.27660906f, 0.41587448f, -0.23644307f, -0.11680265f, -0.01832063f, 0.06269030f, 
    0.07525209f, 0.06368054f, 0.07621823f, 0.24496461f, 0.07198657f, -0.45117658f, -0.37865636f, 0.41708693f, 
    0.10726212f, -0.22162114f, 0.09884977f, -0.01981608f, 0.02681287f, 0.19455178f, -0.30139196f, 0.03399260f, 
    -0.15489544f, -0.14703533f, 0.04860280f, -0.07648481f, 0.39053106f, 0.03645989f, 0.24842396f, -0.19293047f, 
    0.18267962f, 0.14051092f, 0.05246070f, 0.16131884f, -0.08535986f, 0.08374501f, 0.23825446f, 0.02182940f, 
    -0.49909213f, -0.10943263f, -0.11156219f, 0.11943103f, -0.13916677f, 0.02524352f, 0.00471454f, 0.03043044f, 
    0.08277782f, -0.26100007f, 0.07405370f, 0.42258114f, -0.13753408f, 0.02533970f, 0.08060218f, 0.11537521f, 
    0.20401916f, 0.42906621f, -0.02664590f, -0.00936020f, 0.09430271f, 0.00331581f, 0.15791780f, 0.07056515f, 
    0.00461138f, 0.06391747f, 0.00500537f, -0.05206602f, -0.07554488f, -0.14158283f, 0.08194400f, 0.08328897f, 
    0.04877405f, 0.06160254f, 0.31511530f, 0.09700370f, -0.23094055f, 0.00537776f, -0.12649609f, -0.16999944f, 
    -0.00536133f, -0.09153721f, 0.03495654f, 0.00200820f, -0.08602361f, -0.05258615f, -0.10477621f, 0.07463547f, 
    0.09584237f, 0.04795697f, 0.07907351f, 0.01788750f, 0.05712319f, 0.02106499f, 0.17349167f, -0.12858112f, 
    0.12292290f, 0.20870844f, 0.14554925f, 0.10298847f, 0.04534454f, 0.18836547f, 0.28180325f, -0.39733583f, 
    -0.41548780f, -0.06109286f, -0.12497474f, 0.12908225f, -0.00856418f, -0.03505852f, -0.11488189f, -0.00090496f, 
    -0.30291256f, -0.49529225f, 0.39963070f, -0.50777358f, 0.02151572f, 0.13204931f, 0.12025011f, -0.06269581f, 
    0.25478414f, -0.10089197f, -0.26674366f, -0.03537741f, -0.05667876f, -0.00352620f, -0.01593139f, 0.08014823f, 
    -0.00453698f, 0.05179582f, -0.03373990f, 0.03145805f, 0.08016789f, 0.09155573f, 0.14275452f, 0.08538871f, 
    0.07498455f, 0.11814357f, 0.10293004f, -0.29456607f, -0.42059809f, -0.35570449f, 0.04001160f, -0.14722003f, 
    -0.20242879f, 0.11337972f, 0.01149875f, 0.08862041f, 0.03033266f, 0.44308072f, 0.03343851f, -0.02425519f, 
    0.20830050f, -0.20413744f, 0.02990177f, 0.26284581f, -0.25210190f, -0.15989026f, -0.02956850f, 0.63103867f, 
    -0.12930572f, 0.00531157f, 0.09992126f, 0.21322951f, 0.26942044f, 0.16804676f, -0.03648652f, 0.05144299f, 
    -0.11253922f, 0.02811537f, 0.14000538f, -0.01516074f, -0.15631443f, 0.13240165f, -0.05700124f, -0.00902209f, 
    -0.58730835f, -0.18923518f, -0.02926069f, 0.04986249f, 0.15766034f, 0.07999207f, 0.03905131f, 0.10875443f, 
    0.35377905f, 0.13190421f, -0.13269101f, 0.01425262f, 0.01234295f, 0.02113961f, -0.32089251f, -0.31375620f, 
    -0.08085433f, 0.02019288f, 0.17340843f, -0.01678786f, 0.18605395f, -0.10189271f, 0.17342435f, 0.01517407f, 
    0.00643710f, -0.06808476f, -0.46691665f, -0.56361800f, -0.05513085f, 0.00794378f, -0.02771139f, 0.02642268f, 
    -0.11900937f, 0.00593881f, -0.03032812f, -0.09148529f, -0.36609155f, -0.21910825f, -0.10410226f, 0.06433167f, 
    0.05102284f, -0.13249643f, -0.13744314f, -0.03087421f, 0.01462918f, 0.22101353f, 0.01465692f, 0.09557195f, 
    0.14915647f, 0.15323687f, 0.12332995f, -0.01576011f, -0.07752883f, -0.71499145f, -0.14830199f, -0.01473190f, 
    0.11079326f, 0.08168527f, 0.01701741f, -0.12005623f, 0.05175419f, -0.12874104f, 0.01706191f, 0.02036694f, 
    0.30979300f, -0.08173274f, -0.23695509f, -0.15552405f, 0.07922388f, 0.08388311f, 0.01387541f, -0.37233660f, 
    -0.32218739f, -0.04848504f, 0.11210616f, 0.12743747f, 0.02708839f, 0.05465039f, 0.16418441f, 0.22375745f, 
    -0.25786713f, -0.12538879f, -0.01249583f, -0.03280653f, 0.04495124f, 0.00439801f, -0.14499848f, 0.20186527f, 
    0.06074506f, -0.01953486f, -0.20034654f, -0.11716584f, -0.23013462f, -0.15867935f, -0.15175419f, -0.36812466f, 
    0.05196700f, 0.22303610f, 0.07899927f, 0.14330292f, -0.08821260f, -0.05218615f, -0.07168768f, -0.00731386f, 
    -0.02948865f, -0.19269121f, 0.11296503f, -0.24910821f, -0.21236120f, 0.14380918f, 0.04480806f, 0.25340438f, 
    0.07220521f, 0.08800860f, -0.08612779f, 0.57415676f, 0.12443748f, -0.29407316f, -0.13855809f, -0.01298106f, 
    -0.03115068f, 0.13076302f, 0.10673629f, 0.08379293f, 0.15883899f, 0.05881244f, 0.26557514f, -0.10251071f, 
    -0.12874578f, -0.26706550f, -0.02668478f, -0.04063413f, -0.12293202f, 0.06126680f, 0.10927922f, -0.12350593f, 
    0.11534484f, 0.14803275f, 0.09727313f, -0.09456970f, 0.23727544f, 0.11528084f, -0.04965531f, -0.24561958f, 
    -0.29554796f, 0.08872674f, 0.02443506f, -0.07075790f, -0.00660789f, 0.22494984f, -0.00249655f, -0.00483182f, 
    0.28718245f, 0.20034134f, -0.17927650f, 0.02964847f, -0.01855229f, 0.17988865f, -0.03501546f, -0.10660536f, 
    0.07091767f, -0.32357642f, 0.08721932f, -0.19401345f, 0.23330384f, -0.01040868f, -0.15444627f, 0.02676554f, 
    -0.12630576f, -0.31631562f, -0.24470119f, -0.35311124f, 0.06542471f, 0.08362104f, -0.05208103f, -0.12341705f, 
    0.03893363f, -0.14195327f, 0.17626236f, -0.14214087f, -0.35621777f, -0.14631981f, -0.16737448f, 0.02658683f, 
    0.00588812f, 0.11874869f, 0.07066312f, 0.25148183f, 0.26654288f, 0.15271044f, -0.01030071f, -0.12719551f, 
    -0.11042552f, -0.08549729f, -0.07346799f, -0.16335115f, 0.04834182f, 0.11553930f, 0.13343517f, 0.00567354f, 
    0.16257191f, 0.03853222f, 0.07496475f, -0.06976114f, -0.05930760f, 0.02573072f, 0.03227821f, 0.22631526f, 
    0.31284332f, 0.00750652f, 0.05652301f, 0.07091928f, 0.12353053f, 0.15286182f, 0.14200620f, -0.29860315f, 
    -0.06484626f, 0.11442257f, -0.03923253f, -0.20462054f, -0.18022653f, 0.14779532f, -0.01962046f, -0.09101588f, 
    -0.07074399f, 0.20904322f, 0.37432775f, 0.00017618f, 0.03010979f, -0.00920869f, 0.09344234f, -0.06069650f, 
    0.08530445f, 0.43216974f, -0.30671436f, -0.17504589f, 0.01499646f, 0.04282790f, -0.12823981f, 0.08290601f, 
    0.08315600f, 0.03409805f, -0.02535866f, -0.12852621f, 0.27859718f, 0.04748342f, -0.01385012f, -0.01530050f, 
    -0.02510057f, 0.07786016f, -0.02740153f, 0.17936054f, 0.38216582f, 0.01481839f, -0.11307260f, 0.03077075f, 
    0.06461167f, -0.15435606f, -0.04573413f, 0.16542560f, 0.34194830f, 0.33378851f, -0.08661030f, -0.04107599f, 
    -0.13899377f, 0.07917420f, -0.00307219f, -0.07395709f, -0.08464299f, -0.31764156f, 0.16247563f, 0.00034313f, 
    0.11665255f, -0.25531816f, -0.02676120f, 0.28012887f, -0.01580358f, -0.00057812f, -0.24088609f, -0.30697122f, 
    -0.02208280f, -0.09732793f, -0.08283710f, 0.06536190f, -0.01830748f, 0.01175970f, 0.20250772f, 0.46813112f, 
    -0.01834887f, -0.07995975f, 0.10702887f, 0.34449577f, 0.14949584f, -0.25332659f, 0.30798256f, 0.01798966f, 
    0.03005957f, -0.34409261f, -0.11270972f, -0.03018745f, -0.02866990f, -0.08052317f, 0.16639815f, -0.18363945f, 
    -0.21259512f, 0.14558750f, 0.20186864f, 0.11817114f, 0.04586494f, 0.02778769f, 0.03616690f, 0.05411561f, 
    0.13935515f, 0.18424495f, 0.34337553f, -0.36686733f, -0.34162188f, 0.07312501f, 0.08909872f, -0.00036719f, 
    0.01320385f, -0.08176782f, -0.06679332f, 0.03157795f, -0.17471984f, -0.10142283f, 0.18703951f, 0.03117420f, 
    0.15465212f, 0.27420226f, 0.01717965f, -0.05671209f, -0.64783061f, -0.29741442f, -0.47527081f, -0.01539306f, 
    0.01295866f, 0.22676259f, 0.05643988f, 0.04476710f, -0.04392723f, -0.38024193f, 0.08090007f, 0.29345334f, 
    0.05454170f, -0.04016806f, -0.18031430f, -0.04829732f, -0.03809526f, -0.00494183f, -0.50720054f, -0.25103551f, 
    -0.03911451f, -0.00385693f, -0.33935332f, -0.11993841f, -0.04480051f, 0.06917730f, 0.09973538f, -0.07247474f, 
    0.11170410f, 0.24932906f, -0.15286720f, -0.02418996f, 0.08517896f, -0.02636043f, 0.09099212f, 0.11611973f, 
    0.06980090f, -0.00736588f, -0.05065307f, 0.15982188f, 0.03273636f, 0.10285555f, 0.14257623f, -0.02246507f, 
    0.01997995f, 0.27814588f, -0.38158000f, -0.41410533f, -0.08165807f, 0.05055164f, -0.07917506f, 0.18716790f, 
    -0.25713637f, -0.21801548f, -0.51785636f, 0.07249314f, 0.23380841f, -0.02588096f, 0.02508415f, -0.21128443f, 
    -0.06794655f, -0.10221236f, -0.03487009f, 0.17939350f, -0.68933505f, -0.36378393f, -0.23030131f, 0.02097419f, 
    0.24550162f, 0.37921312f, -0.07527553f, 0.01930637f, 0.25953510f, -0.22734524f, 0.01046890f, 0.19342627f, 
    0.21013953f, 0.19131267f, 0.12277241f, 0.00749898f, 0.15579545f, -0.10503376f, -0.18927844f, -0.03185922f, 
    -0.10954518f, -0.43480524f, -0.15373038f, 0.01703065f, 0.10159809f, -0.06683769f, -0.22897728f, 0.14526863f, 
    0.20110667f, -0.06628395f, 0.07608864f, 0.01936343f, 0.33152929f, 0.25119010f, 0.49829835f, -0.51868242f, 
    0.07199277f, 0.25567377f, -0.11627273f, -0.04201661f, 0.06808848f, 0.17317575f, -0.00350468f, 0.25985652f, 
    0.00775757f, -0.11801200f, -0.70806307f, -0.07140703f, 0.01405149f, 0.06780171f, 0.04787061f, 0.06824689f, 
    -0.03336270f, -0.06017434f, 0.25137690f, 0.55998194f, 0.11083962f, 0.11986300f, -0.18109675f, 0.17376600f, 
    0.05463228f, 0.27046192f, 0.10097365f, -0.10510043f, -0.02072218f, 0.04010542f, 0.03637066f, -0.03361641f, 
    0.13351101f, -0.13494682f, -0.02094985f, -0.03091430f, 0.05398041f, 0.20425113f, -0.04871336f, -0.03471696f, 
    -0.04406492f, 0.08928055f, 0.00949924f, 0.10552184f, 0.07185069f, 0.03644978f, -0.02026961f, 0.05255878f, 
    0.04181182f, -0.09561875f, -0.22426195f, -0.16003789f, -0.06710824f, 0.06550784f, -0.10581326f, -0.29896140f, 
    0.11145750f, 0.03636178f, 0.08693232f, 0.06067969f, 0.17001584f, 0.04356072f, -0.33663949f, 0.19533792f, 
    0.20605381f, 0.30251017f, 0.06781132f, 0.24132261f, 0.15296862f, 0.16119885f, 0.16698982f, -0.29165283f, 
    0.13851151f, -0.10573626f, -0.07410396f, -0.11989370f, -0.00416905f, 0.05147238f, 0.09508558f, 0.10245235f, 
    -1.41871071f, -0.67410445f, -0.73178500f, -0.03406423f, -0.01661981f, 0.34376916f, -0.15231766f, 0.02162569f, 
    -0.05813173f, 0.22146797f, -0.12613118f, -0.05722059f, -0.06217926f, -0.06988597f, 0.00684776f, -0.11740874f, 
    0.15412097f, 0.14414440f, -0.06949490f, -0.00075112f, -0.17728561f, 0.14031500f, 0.10244913f, -0.00375977f, 
    0.10055875f, 0.18733987f, 0.04556403f, -0.11943705f, -0.12286685f, -0.64955777f, 0.15007153f, 0.04008949f, 
    0.05337245f, 0.03726599f, -0.00547909f, -0.06845858f, 0.14226277f, 0.44266102f, -0.04627398f, -0.02899536f, 
    -0.10665622f, -0.03596603f, 0.21879892f, 0.09292352f, -0.05937138f, 0.06851605f, -0.00220557f, -0.08426863f, 
    -0.11845990f, -0.19781052f, -0.06031530f, 0.12938578f, -0.04714847f, 0.04257067f, -0.19151105f, -0.02160571f, 
    0.12194027f, -0.17173029f, -0.13291891f, -0.09604067f, -0.09397270f, -0.00727987f, -0.21091317f, -0.09042197f, 
    -0.39067325f, -0.51186252f, -0.10802215f, -0.16346590f, 0.14796764f, 0.16457088f, -0.40803391f, -0.13582525f, 
    0.03718187f, 0.03052178f, -0.03219223f, 0.05589455f, 0.00075632f, -0.03543185f, -0.02135018f, 0.00484223f, 
    -0.01176195f, -0.01527788f, -0.03243158f, -0.05315145f, 0.03365251f, -0.04731661f, -0.01477201f, 0.01572769f, 
    -0.04327401f, -0.01126208f, 0.00223733f, 0.03991135f, -0.00425194f, -0.04252176f, -0.03714651f, 0.04623422f, 
    0.02436023f, 0.04956463f, -0.03615031f, -0.00341120f, 0.04536077f, -0.02500514f, 0.05249789f, -0.05171793f, 
    0.00258650f, 0.01816529f, -0.02926938f, -0.05807050f, 0.04706753f, -0.02319800f, -0.00866611f, 0.00473623f, 
    0.03139745f, 0.03360838f, -0.06140707f, -0.01566782f, -0.05367844f, 0.06129347f, -0.01515095f, 0.01851467f, 
    -0.05227887f, 0.03256778f, -0.00721838f, 0.03019431f, -0.04489972f, 0.03750753f, 0.02279472f, 0.01538650f, 
    -0.04150095f, -0.05556711f, 0.04261708f, -0.02898514f, -0.02904680f, -0.02884217f, -0.00067886f, -0.04534804f, 
    -0.02473116f, -0.03494413f, -0.05196745f, -0.04436778f, -0.01914343f, -0.03174014f, -0.01450190f, -0.01997331f, 
    0.01112607f, -0.03311063f, -0.00119536f, -0.01163994f, 0.01887953f, -0.01992138f, -0.05098620f, 0.02621533f, 
    0.02210628f, -0.00630822f, -0.05345340f, 0.01435650f, 0.04670773f, 0.02188308f, -0.06401017f, 0.04288755f, 
    -0.05547670f, -0.02004025f, -0.06434824f, 0.01599200f, -0.04888766f, -0.06190359f, -0.06788075f, -0.06391601f, 
    -0.02423315f, -0.03837262f, -0.03431491f, -0.05988204f, -0.02195359f, 0.04647494f, -0.01916297f, 0.04006493f, 
    -0.01467004f, -0.04670952f, 0.00483182f, -0.00207588f, 0.00113609f, 0.05055977f, -0.04701984f, -0.06649572f, 
    0.00154016f, -0.04198775f, 0.01395774f, -0.05347643f, 0.00896152f, 0.04967080f, 0.02942255f, -0.02477386f, 
    -0.02415454f, -0.04458439f, 0.04447116f, -0.01653471f, -0.06523415f, 0.03402902f, -0.02101209f, 0.04997378f, 
    -0.05674832f, -0.00075048f, 0.01323915f, 0.03313699f, -0.01469469f, -0.00187387f, 0.04756129f, -0.04352985f, 
    0.02330793f, -0.05049999f, -0.06485850f, -0.01670519f, -0.01874634f, 0.02142595f, -0.01805438f, -0.06772387f, 
    0.02307074f, 0.01574284f, -0.03282900f, -0.02341647f, -0.05136090f, 0.01700515f, 0.01534079f, -0.02659526f, 
    0.00159412f, -0.00358733f, 0.04886292f, -0.00225334f, -0.00657356f, -0.02731015f, -0.03750845f, -0.02919404f, 
    -0.00585390f, 0.00730281f, -0.01153519f, -0.04412887f, 0.03709714f, 0.01961065f, 0.03455758f, 0.02517831f, 
    0.00702318f, -0.06209011f, 0.01669945f, -0.00109954f, 0.01265382f, -0.03846590f, 0.01368605f, -0.01961599f, 
    0.04720518f, -0.01900414f, -0.03211794f, -0.05191265f, 0.03433580f, -0.01406672f, -0.01233372f, -0.01776058f, 
    -0.03429216f, -0.03509785f, -0.00637083f, -0.01972076f, -0.05020541f, -0.00068489f, -0.04843635f, 0.03170181f, 
    0.03970322f, 0.02252694f, -0.02169516f, 0.04958315f, 0.03115715f, -0.02728392f, 0.03705929f, -0.02740993f, 
    0.00515076f, -0.01848752f, -0.04537673f, -0.05210834f, 0.04153912f, 0.03274639f, -0.01245286f, 0.01213328f, 
    0.04766128f, -0.02410191f, 0.04128299f, -0.03421210f, -0.00551002f, -0.03617083f, 0.03328672f, -0.05558782f, 
    -0.00772413f, -0.04840652f, 0.04194446f, -0.04740166f, -0.01347079f, 0.01585515f, -0.01359498f, 0.01421171f, 
    0.03462177f, -0.03463852f, 0.03851256f, 0.03055887f, -0.03819969f, -0.01196671f, 0.01015681f, 0.00232442f, 
    -0.04475656f, 0.04862135f, 0.01703536f, -0.06349225f, 0.00760278f, -0.00511628f, -0.00966818f, 0.04203928f, 
    -0.00477228f, -0.03987559f, -0.05377147f, -0.04569944f, 0.02074008f, -0.05252157f, -0.03189864f, -0.03043555f, 
    0.03525049f, -0.02155438f, 0.04533414f, -0.01041385f, -0.00437427f, 0.00977570f, -0.06380608f, -0.04089631f, 
    -0.01803244f, -0.05887907f, 0.02466219f, -0.05944097f, -0.05433237f, -0.02125006f, 0.04568374f, 0.04744172f, 
    0.01418835f, -0.01586358f, -0.02282622f, -0.04963331f, 0.02830931f, -0.06402386f, 0.04410165f, -0.02479517f, 
    -0.00669810f, -0.01591260f, -0.05405204f, 0.01089896f, -0.01154511f, 0.03558880f, 0.01334130f, -0.01047135f, 
    0.03801323f, -0.05730798f, -0.02238001f, -0.03611514f, -0.01932446f, -0.01094110f, 0.02294173f, 0.01659888f, 
    -0.11929634f, -0.24342541f, 0.10987433f, -0.04849229f, -0.20965379f, -0.15008852f, 0.14307584f, -0.08157068f, 
    -0.18840559f, -0.26850733f, 0.06337801f, 0.25868267f, 0.01578476f, 0.05256129f, 0.03272144f, -0.00476753f, 
    -0.04123387f, -0.01006298f, 0.19031610f, 0.20721126f, -0.24986318f, -0.07843934f, -0.05736278f, -0.03752183f, 
    -0.03385676f, -0.28872475f, -0.10651729f, 0.08626399f, -0.05150263f, -0.19863418f, 0.03781462f, -0.12404923f, 
    0.06449130f, 0.00653628f, -0.20129323f, -0.00415338f, 0.22352742f, 0.07824018f, -0.07110385f, 0.11104891f, 
    0.04985166f, 0.21590103f, 0.02410741f, 0.07993861f, 0.14015467f, -0.00987349f, -0.05620471f, -0.07364926f, 
    -0.17414965f, -0.14502351f, 0.05567193f, 0.10808563f, -0.06778317f, -0.03625264f, -0.23805602f, -0.17500898f, 
    0.41847640f, 0.11019751f, -0.00338441f, -0.06316388f, 0.20709744f, -0.02548765f, 0.13090160f, 0.08423985f, 
    -0.06427956f, -0.27473241f, -0.07210661f, -0.11948251f, -0.11778493f, 0.16267441f, 0.05191921f, -0.05781542f, 
    0.02847116f, -0.07493950f, -0.10585642f, -0.02481693f, 0.08035517f, 0.07888906f, 0.00369094f, -0.04397181f, 
    -0.19480647f, 0.04715677f, -0.07984763f, 0.12540706f, -0.42366230f, -0.08888933f, -0.16443010f, 0.04570593f, 
    -0.08573474f, -0.00928419f, -0.01562483f, -0.17615430f, 0.35622716f, 0.07169352f, 0.00267685f, 0.05534347f, 
    0.09676468f, -0.21518299f, -0.37940368f, -0.24036686f, 0.13545473f, -0.13418034f, -0.26017639f, 0.19104789f, 
    -0.09243419f, -0.01450408f, -0.05381706f, 0.24756785f, 0.31080061f, -0.04216278f, -0.02820487f, -0.12983820f, 
    0.07731143f, -0.12706301f, 0.09043759f, 0.15759744f, -0.03801277f, -0.26327345f, -0.20846359f, 0.52732950f, 
    0.21807314f, -0.20746887f, 0.10644154f, -0.10052134f, -0.05978236f, 0.22337283f, -0.09904540f, -0.02609159f, 
    -0.53044283f, -0.17953061f, -0.10085648f, 0.05190150f, 0.11960901f, 0.16158676f, 0.01701084f, -0.05862911f, 
    -0.03091616f, 0.16049850f, 0.01622136f, -0.05165046f, 0.03503936f, 0.01040335f, 0.07390931f, 0.10634595f, 
    0.00892219f, -0.01101205f, 0.43626025f, 0.06200284f, 0.14543837f, -0.10515863f, 0.03371818f, 0.17301211f, 
    0.02050176f, -0.04816133f, 0.06380527f, -0.10993595f, -0.13803791f, 0.04037339f, 0.06862560f, -0.12026626f, 
    -0.02418871f, 0.17131656f, 0.03901295f, 0.16906150f, -0.08446939f, -0.06135338f, 0.06625295f, 0.09575102f, 
    0.08086015f, 0.01475572f, -0.13280815f, 0.09372939f, -0.25202510f, -0.16902030f, -0.00396529f, 0.03005652f, 
    -0.02333045f, 0.13948150f, -0.20613299f, -0.18172236f, 0.01615927f, -0.10811637f, 0.32821384f, 0.10333607f, 
    -0.04551232f, -0.10607901f, -0.03574015f, -0.18674965f, -0.16509722f, -0.06001369f, 0.24341178f, 0.33269158f, 
    -0.08236894f, -0.00246448f, -0.12367312f, -0.07580215f, 0.10745320f, -0.03432743f, 0.13487789f, 0.16166456f, 
    -0.00311432f, 0.16458185f, 0.06263737f, 0.11487358f, 0.10496128f, 0.05402610f, 0.25189528f, -0.17176649f, 
    -0.08156920f, 0.14158195f, 0.06465486f, 0.07640351f, 0.09401302f, 0.07403588f, 0.01095683f, -0.10913077f, 
    -0.03795808f, 0.13673992f, -0.10293435f, 0.06212274f, -0.03406407f, -0.09737466f, -0.14231510f, -0.15187380f, 
    0.12926660f, -0.20437846f, -0.03684524f, 0.33259797f, -0.13315637f, -0.13377438f, -0.08057943f, 0.18910642f, 
    -0.05917635f, 0.04618682f, -0.08602771f, 0.16650955f, -0.14536899f, 0.12462430f, 0.06275159f, 0.09908576f, 
    0.01292640f, -0.01548523f, 0.06866586f, 0.23253013f, 0.05636141f, 0.19627939f, -0.04484927f, -0.02112499f, 
    -0.14574911f, -0.02243366f, -0.01918630f, 0.18071924f, 0.21913897f, -0.06787824f, 0.35484630f, 0.17798217f, 
    -0.10472623f, -0.25950009f, -0.08492751f, 0.00030306f, -0.00341649f, -0.12348485f, -0.40124798f, 0.34565049f, 
    -0.17440449f, -0.04033760f, 0.21617784f, -0.10403975f, 0.22646485f, 0.16128018f, 0.07237488f, -0.13528873f, 
    -0.04363311f, -0.00479270f, -0.04440241f, -0.09199404f, 0.11712702f, -0.20661783f, -0.11698206f, 0.46428752f, 
    -0.12678200f, -0.55324268f, -0.00763949f, -0.10020062f, 0.01404738f, -0.13336019f, -0.06958397f, -0.05512789f, 
    -0.14713964f, -0.20756051f, -0.14243871f, -0.00628199f, -0.06197161f, 0.04684036f, 0.20668377f, 0.18438980f, 
    0.11959720f, 0.16905683f, 0.10302049f, 0.07914567f, 0.09388898f, -0.00763034f, 0.05754935f, 0.08466347f, 
    -0.01514418f, -0.03250014f, -0.22687562f, -0.60267168f, 0.08721153f, -0.23172209f, -0.03304241f, -0.09799210f, 
    0.17981127f, 0.12333400f, 0.00881460f, -0.25040096f, -0.24586345f, -0.13574643f, 0.06864507f, 0.11695857f, 
    0.00714932f, 0.24811271f, 0.18682835f, 0.22661944f, 0.01626005f, -0.06447324f, 0.02072067f, -0.14848082f, 
    0.01042683f, 0.21312165f, 0.00131546f, -0.10071921f, -0.00753882f, 0.27456406f, -0.00735966f, -0.07325649f, 
    -0.03363356f, -0.06773986f, 0.00360864f, -0.02199374f, 0.17528082f, 0.13029736f, 0.25864482f, 0.46007010f, 
    0.20892443f, -0.19802210f, 0.02641276f, -0.16710614f, 0.13546969f, 0.01383857f, 0.02531069f, 0.13322486f, 
    -0.22255921f, -0.09393884f, -0.03435639f, -0.17971157f, -0.00610250f, -0.07058780f, 0.13768193f, -0.05585607f, 
    -0.46798339f, -0.31395626f, -0.06447119f, 0.04614042f, 0.03815203f, -0.04623083f, 0.11885804f, 0.04195965f, 
    -0.04322090f, -0.17019558f, -0.17342176f, -0.12893119f, -0.27174115f, -0.15632804f, -0.09282669f, 0.13118960f, 
    0.06769054f, -0.05655824f, 0.39896789f, 0.53044474f, 0.36080799f, 0.09407230f, 0.15971252f, -0.01215387f, 
    0.11926238f, 0.06144510f, 0.03223120f, -0.39903012f, -0.04726468f, 0.12058913f, -0.07731991f, 0.22424325f, 
    0.08894009f, -0.02171847f, 0.19200891f, -0.13105729f, -0.55986345f, -0.28978676f, -0.07877443f, 0.00652065f, 
    0.04512418f, 0.06543390f, -0.02278872f, -0.00288942f, -0.13975571f, 0.03335247f, 0.31725422f, 0.06457432f, 
    0.01236576f, -0.04750359f, -0.01128895f, 0.00186049f, -0.00526079f, -0.09092917f, 0.42844644f, -0.10336629f, 
    -0.06158729f, -0.07730772f, -0.25513029f, 0.02050431f, -0.03431457f, 0.03272706f, -0.07567844f, -0.50702775f, 
    -0.02300119f, -0.19264369f, 0.06938270f, -0.09465792f, -0.00766500f, 0.04935835f, -0.07386485f, -0.22784591f, 
    0.07537497f, 0.05010457f, 0.29036823f, -0.16495207f, 0.14754096f, 0.21320543f, -0.05756518f, -0.09572048f, 
    -0.07774884f, 0.58437717f, -0.19864412f, -0.13391027f, -0.09830547f, -0.16354184f, 0.04440903f, 0.01439872f, 
    -0.04293175f, 0.01658457f, -0.57298857f, -0.55702436f, -0.10873456f, 0.06623728f, -0.00887325f, -0.11592838f, 
    0.06150031f, 0.06805471f, -0.16434452f, 0.26766646f, -0.07551982f, -0.11262980f, 0.00766244f, -0.18862577f, 
    -0.04349412f, 0.05135394f, 0.04865351f, 0.13240781f, 0.49887708f, 0.48359245f, 0.40421060f, -0.20619513f, 
    -0.09340272f, -0.10511252f, 0.11920682f, 0.14964901f, 0.06400201f, 0.17142138f, 0.11461997f, 0.05726313f, 
    0.07497293f, 0.00401901f, 0.06567665f, 0.03425049f, -0.05618409f, 0.04626285f, -0.02353976f, -0.06937994f, 
    -0.02429237f, -0.04700349f, 0.27162516f, 0.09954797f, 0.03522807f, 0.24559009f, 0.07379885f, 0.44259825f, 
    -0.04248646f, -0.01783029f, 0.14870273f, 0.01432814f, 0.29747680f, 0.07484404f, 0.04692119f, -0.11399855f, 
    -0.42098841f, -0.19337779f, 0.45037353f, -0.29349446f, 0.02951344f, 0.07963690f, 0.12208978f, 0.06042012f, 
    -0.05104736f, -0.38740966f, -0.05813410f, -0.22047535f, -0.05465967f, -0.03563772f, -0.06247729f, 0.11938567f, 
    -0.11307333f, -0.06608911f, -0.72565377f, -0.22290884f, 0.25195646f, 0.07919233f, -0.04721850f, -0.03564967f, 
    -0.02376868f, 0.21199000f, -0.10095269f, 0.46278000f, 0.39352027f, 0.36737034f, -0.11480914f, -0.15627810f, 
    -0.00544119f, 0.04227719f, 0.10151880f, 0.05153131f, 0.03722622f, 0.03433332f, -0.09058847f, -0.15309343f, 
    -0.08214714f, -0.11739221f, 0.09551849f, 0.06489562f, 0.13714676f, 0.16448410f, -0.72612274f, -0.57006270f, 
    -0.16240014f, -0.22033764f, 0.08697137f, 0.19104975f, 0.12037205f, -0.10513598f, 0.21321313f, -0.09507429f, 
    -0.05651472f, -0.07282630f, -0.15554844f, -0.15108581f, 0.05602538f, 0.10115013f, 0.08326852f, -0.10440207f, 
    -1.03956997f, -0.70713913f, -0.09806396f, 0.22349298f, -0.01787668f, 0.07777569f, 0.13729668f, -0.05470823f, 
    0.36792064f, -0.29161769f, -0.18476400f, 0.05184990f, -0.06714684f, -0.16985309f, -0.16239698f, -0.28425077f, 
    -0.10872380f, 0.01937498f, -0.02041557f, 0.13913532f, 0.09325349f, -0.05231212f, -0.01932566f, -0.09522406f, 
    -0.02176634f, -0.13629340f, -0.74975723f, 0.80224854f, 0.40735301f, 0.37704781f, 0.06266176f, -0.30356407f, 
    0.03979837f, -0.10714146f, -0.17405517f, -0.30744895f, -0.30180681f, -0.19788012f, 0.08158641f, -0.27141190f, 
    -0.37385538f, -0.07410084f, -0.26544186f, -0.00972698f, -0.20534918f, -0.36726531f, 0.02484345f, 0.11358397f, 
    -0.04385303f, 0.12952475f, 0.07688739f, 0.08620887f, 0.12808433f, -0.49110326f, 0.22480938f, 0.48497194f, 
    -0.05102926f, -0.25738513f, -0.26039106f, -0.01639584f, 0.02088929f, 0.22366226f, 0.25621432f, -0.05012514f, 
    0.30074784f, 0.03466812f, 0.00981070f, -0.19334224f, -0.07011440f, 0.06748242f, 0.05045187f, 0.24207067f, 
    -0.16501014f, -0.51173675f, 0.19297431f, -0.11794605f, -0.24761246f, 0.13722028f, 0.20146987f, -0.17103231f, 
    -0.39358759f, -0.07935981f, -0.39636806f, 0.18834366f, -0.27107945f, -0.17625830f, 0.05777306f, -0.14155610f, 
    -0.26231763f, 0.21125154f, 0.94750196f, 0.23978807f, 0.12886751f, -0.11460608f, 0.07064860f, -0.20437367f, 
    0.07045178f, -0.33971453f, 0.18551323f, 0.07841834f, 0.23801431f, -0.19794294f, 0.03622445f, -0.01797234f, 
    0.17028113f, 0.04662652f, 0.10135338f, 0.54961467f, 0.19884206f, 0.15829591f, -0.27248660f, 0.33160454f, 
    -0.24339157f, 0.27836937f, -0.21885163f, -0.13506444f, -0.36852986f, 0.44455263f, 0.28133467f, 0.11885532f, 
    0.03905362f, 0.21251848f, -0.16542260f, 0.01336162f, 0.17826858f, -0.16712521f, -0.00279377f, 0.14832270f, 
    -0.17114069f, -0.17381841f, 0.03075393f, 0.01121760f, -0.06756741f, -0.09551942f, 0.07960762f, -0.62912542f, 
    -0.32400665f, 0.03925784f, 0.04225225f, -0.11466125f, 0.12707673f, 0.22414325f, 0.09073698f, 0.66776484f, 
    0.02769385f, -0.59279561f, 0.18007489f, 0.02031976f, -0.24430020f, 0.08848506f, 0.28576079f, 0.03527467f, 
    0.03374439f, -0.01292042f, 0.54870886f, -0.08459553f, 0.14236476f, 0.15329400f, -0.18928403f, -0.07000144f, 
    -0.10175968f, -0.14506337f, -0.09170142f, 0.22141576f, 0.15955389f, -0.24250348f, -0.05451279f, 0.01349731f, 
    0.06544090f, 0.18831398f, -0.69877851f, -0.14797762f, -0.29259011f, 0.60404044f, -0.15749724f, -0.27910957f, 
    -0.14041458f, 0.08638691f, -0.01979669f, -0.26832551f, -0.55921370f, 0.08113884f, -0.46850428f, -0.59460950f, 
    -0.71628147f, -0.08803146f, 0.01525101f, 0.20237176f, 0.28465655f, 0.08077484f, 0.31527489f, -0.12309361f, 
    0.14030558f, 0.03836853f, 0.03071359f, -0.12887731f, 0.07697757f, 0.11529505f, -0.00907040f, 0.22526070f, 
    -0.01403334f, 0.06866062f, -0.13512540f, -0.07168349f, -0.07788456f, -0.04286272f, 0.14037521f, -0.15829426f, 
    0.10950567f, -0.07247519f, 0.01241829f, 0.00104427f, -0.19732004f, -0.17149879f, 0.18190363f, 0.20501865f, 
    -0.04765620f, -0.24053234f, 0.16314882f, 0.06096139f, -0.20264794f, -0.26206884f, -0.14256066f, 0.00099874f, 
    0.21986756f, -0.45737949f, -0.04779170f, -0.01160234f, 0.02740093f, -0.17005613f, -0.11888003f, 0.13404782f, 
    0.09909432f, -0.90235603f, 0.00380784f, 0.31806380f, -0.12972733f, -0.02834511f, 0.14005899f, -0.13181230f, 
    -0.00889713f, 0.25475898f, -0.36584675f, -0.04391133f, -0.45894054f, -0.15130483f, 0.16336922f, -0.20574732f, 
    0.03279818f, 0.08998270f, 0.12360843f, 0.22562511f, 0.17492318f, 0.30726185f, 0.12550350f, -0.12005997f, 
    0.05461025f, -0.03497190f, 0.00296604f, -0.10965236f, -0.17563821f, 0.14038925f, -0.06413447f, -0.08040302f, 
    0.04740180f, -0.12596962f, -0.02811746f, 0.04006221f, -0.12048829f, -0.26403323f, -0.20717174f, 0.40800324f, 
    -0.17235868f, -0.48887679f, -0.35172254f, 0.01466005f, -0.11834050f, 0.24546990f, -0.34117398f, -0.55855787f, 
    -0.04456446f, 0.06334417f, -0.39171785f, -0.41472936f, 0.07061854f, 0.14228250f, 0.10874087f, -0.13835104f, 
    0.41334295f, -0.45651829f, -0.17917636f, -0.36561826f, 0.00833786f, -0.03498339f, -0.20831743f, 0.47495526f, 
    0.16548716f, 0.07501673f, 0.05244092f, -0.16815238f, 0.08124157f, 0.05119865f, 0.03521424f, -0.02888983f, 
    0.01459621f, 0.16450296f, 0.15356703f, -0.32944995f, 0.09637573f, -0.03501090f, -0.03150895f, 0.19006792f, 
    -0.11473390f, 0.07377838f, -0.19532779f, 0.07320236f, -0.03261426f, -0.00045398f, 0.09122914f, 0.04006718f, 
    -0.16117448f, -0.00068843f, -0.02035477f, -0.09753144f, 0.07517345f, 0.28728116f, -0.10951324f, 0.18551248f, 
    -0.02175312f, 0.07432509f, 0.06382313f, 0.10763285f, 0.22149773f, 0.29961225f, 0.08058535f, 0.05384738f, 
    0.02768954f, 0.20709743f, -0.05922413f, 0.06649586f, -0.29071772f, 0.03457850f, -0.16201438f, 0.27987823f, 
    0.27298516f, -0.03571825f, -0.12561436f, -0.03039305f, 0.00997000f, 0.06445160f, 0.41002735f, 0.36417857f, 
    -0.55121130f, 0.13041027f, -0.03449408f, 0.01029910f, 0.00903559f, -0.05426544f, -0.03145119f, 0.05633901f, 
    -0.04016083f, 0.07265979f, -0.05026279f, -0.05643281f, -0.22676000f, 0.01141882f, -0.01673258f, 0.08079424f, 
    -0.05554767f, 0.03446411f, 0.06969886f, 0.00607524f, -0.03504456f, 0.00478405f, 0.12858142f, 0.00326773f, 
    0.13901006f, 0.34970501f, 0.22831643f, -0.42326060f, 0.02240570f, 0.00270295f, 0.03408812f, 0.12590021f, 
    -0.01511482f, 0.10774735f, 0.29373199f, 0.16800597f, -0.00859871f, -0.14661618f, -0.04980390f, -0.03714127f, 
    0.06076503f, -0.12526260f, 0.01660949f, -0.83596689f, -0.03164705f, 0.01574764f, -0.27522179f, -0.06029649f, 
    0.33571735f, 0.01975109f, 0.19939484f, 0.05236704f, -0.21772623f, -0.31862345f, 0.04714750f, -0.14845173f, 
    -0.05480395f, 0.02640858f, -0.12956238f, -0.00647586f, -0.05864774f, 0.07957441f, 0.07139479f, -0.12608317f, 
    -0.01726342f, 0.18225016f, 0.02191379f, 0.10245494f, -0.08767873f, 0.12282937f, 0.05616485f, -0.02345905f, 
    -0.04514345f, 0.02050959f, -0.04320830f, -0.15031502f, 0.02212735f, 0.02392939f, -0.18214975f, -0.02654851f, 
    0.03512314f, 0.08533491f, 0.03296830f, 0.04096124f, 0.10539763f, -0.28109181f, 0.04226967f, -0.23546633f, 
    0.03217377f, 0.21868356f, -0.23542674f, -0.05315819f, 0.05371402f, 0.04511737f, -0.04917033f, -0.00460318f, 
    -0.01268185f, 0.20440651f, -0.22968745f, -0.13088188f, -0.00461561f, 0.07000589f, -0.33244297f, -0.06414976f, 
    0.04307363f, -0.06586210f, -0.09424572f, -0.04584268f, 0.10650513f, -0.10370288f, 0.00894662f, 0.09636129f, 
    0.05881662f, 0.12313757f, -0.01863582f, 0.13060357f, 0.05903336f, 0.21487086f, -0.30003724f, -0.22540712f, 
    -0.19131471f, -0.03275514f, 0.15726732f, 0.06124117f, 0.24663121f, 0.14249247f, -0.31031707f, -0.06979196f, 
    -0.02104657f, 0.03639718f, 0.08565266f, -0.04942663f, -0.07828686f, -0.01753130f, 0.07724321f, -0.39577878f, 
    -0.00206154f, 0.03535495f, -0.05128601f, 0.09494491f, -0.04794966f, 0.07874230f, 0.16352160f, -0.18813941f, 
    0.26301506f, -0.18054950f, -0.01498784f, 0.06203572f, -0.03739683f, 0.00801233f, 0.09582997f, 0.26282474f, 
    0.23131752f, -0.07386158f, 0.14921194f, 0.06235679f, -0.22190945f, 0.26549289f, 0.03889887f, 0.23959757f, 
    0.16643980f, -0.28899252f, 0.38400537f, -0.07244565f, 0.00753082f, -0.09327823f, -0.00766838f, 0.13046396f, 
    -0.13074110f, 0.00372250f, -0.07810079f, 0.19142628f, -0.24367070f, 0.10036696f, 0.07468620f, 0.11134499f, 
    -0.08935811f, 0.08870400f, -0.21689299f, 0.04877979f, 0.22704290f, 0.00405954f, 0.11520194f, -0.05273829f, 
    -0.00719595f, 0.03585594f, 0.01453684f, 0.16451980f, 0.05705633f, -0.10301632f, -0.03774370f, 0.08105510f, 
    0.03019178f, 0.01527519f, -0.16518854f, -0.04818151f, -0.40156901f, 0.03075751f, 0.42840543f, -0.19498083f, 
    0.01436146f, -0.11793281f, -0.02367278f, 0.03500886f, -0.02359036f, 0.31874296f, -0.43478957f, 0.29396591f, 
    -0.01518767f, 0.12514178f, -0.55441296f, 0.00520177f, 0.04242461f, -0.08310233f, -0.02391686f, 0.06038070f, 
    0.17836572f, -0.15225343f, -0.16964415f, -0.31215134f, -0.04963651f, 0.03555682f, 0.08264871f, -0.11675601f, 
    0.02131469f, 0.27283823f, -0.13120852f, 0.06450091f, 0.15467136f, -0.09162042f, 0.22318009f, 0.24404037f, 
    -0.00848609f, -0.18710481f, -0.10063724f, 0.14467588f, -0.00998941f, -0.13053842f, 0.08706615f, 0.09218697f, 
    -0.01435926f, -0.18933541f, -0.16619200f, 0.07269678f, -0.09104407f, 0.05899864f, 0.10428860f, 0.11099782f, 
    0.00534487f, -0.01066889f, 0.17813797f, 0.65156287f, -0.02090650f, -0.08312792f, -0.18526424f, -0.15462373f, 
    -0.00212292f, 0.04557663f, -0.01515266f, 0.20217165f, 0.32558206f, 0.04038728f, 0.17443325f, -0.01939397f, 
    -0.03472234f, 0.02901562f, 0.02470851f, 0.00778828f, -0.51420116f, 0.01949012f, -0.54751009f, 0.20221543f, 
    -0.08931030f, 0.20882648f, -0.00928202f, 0.12940821f, -0.07315727f, -0.07873851f, -0.36404854f, -0.26572755f, 
    -0.07841551f, -0.07698464f, -0.01588425f, 0.00614237f, -0.00456883f, 0.06790985f, -0.65702802f, -0.56181365f, 
    0.15321103f, -0.01086974f, -0.02640735f, -0.07200502f, 0.05403392f, -0.02602096f, -0.07240964f, -0.05515300f, 
    -0.03689894f, -0.13901959f, -0.06340621f, 0.09150390f, -0.21484976f, 0.10634654f, 0.01682405f, -0.00674317f, 
    0.23436579f, 0.31046572f, -0.05923307f, -0.11392813f, 0.05758276f, -0.14934091f, 0.18803068f, -0.04667960f, 
    -0.20818081f, 0.14109004f, 0.37026989f, 0.24528573f, -0.31000924f, -0.00113314f, -0.18529280f, -0.07965857f, 
    0.00083909f, -0.04362893f, -0.17439163f, -0.42680126f, 0.06614955f, 0.20713416f, 0.10550198f, 0.04912848f, 
    -0.00838425f, 0.01342709f, -0.10148871f, 0.05144197f, 0.09089378f, 0.38808125f, -0.42875162f, -0.05836047f, 
    -0.09761801f, -0.20508280f, 0.22173452f, 0.00420096f, 0.26328766f, 0.24704374f, 0.29203936f, 0.03047946f, 
    -0.02243207f, 0.04439260f, 0.16692121f, 0.06005111f, 0.04716584f, 0.32383388f, 0.13329908f, 0.11582544f, 
    -0.09476025f, -0.21664226f, 0.06813917f, 0.06696605f, -0.05978476f, -0.14382644f, -0.07265221f, -0.40143716f, 
    -0.07179353f, -0.03856739f, 0.03200390f, -0.09707972f, -0.00084699f, -0.06792452f, 0.28824601f, -0.11183932f, 
    0.01607967f, -0.05109470f, -0.03043907f, 0.15720607f, 0.00316454f, 0.11941901f, 0.12497591f, 0.08824088f, 
    -0.13941361f, -0.56764877f, 0.01070656f, -0.00327579f, 0.04570198f, 0.34823954f, -0.02860341f, -0.03443765f, 
    -0.21937619f, -0.06360102f, -0.44491005f, -0.13957419f, -0.06577391f, -0.12784265f, -0.09550801f, 0.01610237f, 
    -0.06047118f, 0.17035779f, 0.14341722f, 0.28200677f, 0.10842099f, -0.16496807f, -0.04839090f, -0.08366309f, 
    0.11499400f, 0.05231082f, -0.09823309f, 0.06780010f, 0.07921103f, -0.11082447f, 0.05410738f, -0.04473777f, 
    -0.14365807f, -0.15298282f, -0.11918301f, -0.05829565f, -0.24448235f, -0.09905174f, 0.34293336f, 0.03580091f, 
    -0.06045454f, -0.08723852f, -0.10336898f, 0.04838315f, -0.13891301f, -0.10855048f, -0.01274405f, 0.28777802f, 
    -0.07280324f, 0.21411043f, 0.03148051f, -0.05391536f, -0.08722477f, -0.12943657f, 0.13227522f, 0.03093561f, 
    0.27850640f, 0.10718254f, 0.12627733f, -0.14319004f, 0.27933651f, -0.03099915f, 0.27517390f, -0.03177725f, 
    -0.39406082f, -0.32488206f, 0.11233127f, 0.07513124f, 0.13227119f, 0.17006077f, 0.10456278f, 0.08549469f, 
    -0.59325022f, -0.59460086f, 0.38239634f, 0.09709176f, -0.08612572f, -0.13682570f, 0.05572667f, -0.01237949f, 
    -0.01013224f, 0.08032513f, -0.16744903f, 0.18125622f, -0.11524083f, -0.06106978f, -0.19966719f, -0.16945079f, 
    -0.00683109f, 0.23372820f, -0.01393389f, 0.30607411f, 0.18544140f, 0.05339619f, 0.02077512f, -0.14661466f, 
    0.00370415f, 0.21047580f, -0.07375918f, -0.27996007f, 0.35981742f, -0.39060819f, 0.05025093f, 0.06834797f, 
    0.02160875f, 0.00025819f, 0.05766092f, 0.11889430f, -0.35459238f, 0.12920374f, 0.44962475f, 0.34760711f, 
    -0.02374505f, 0.33391166f, -0.04622165f, 0.04909950f, -0.19703871f, -0.13605256f, -0.50126421f, 0.27418697f, 
    -0.16804305f, -0.09914312f, 0.30102971f, -0.11976057f, 0.10712633f, -0.06638602f, -0.02149908f, -0.02085618f, 
    -0.32355848f, 0.01358359f, -0.16631424f, -0.15056521f, -0.11178415f, -0.01281523f, -0.10583436f, -0.31604648f, 
    -0.01614355f, 0.22336160f, -0.12196032f, 0.00355453f, 0.04572625f, 0.31745717f, -0.17591476f, 0.02600189f, 
    0.05063679f, 0.02741592f, 0.01667007f, 0.05869523f, -0.19876885f, 0.04493623f, -0.12037183f, 0.20706660f, 
    -0.08494302f, 0.24988027f, 0.22389159f, 0.08177396f, 0.05967184f, 0.04264902f, -0.02047466f, 0.08613031f, 
    -0.13702461f, -0.26229534f, -0.23378886f, -0.39256540f, 0.22677059f, -0.06921980f, -0.02240686f, -0.06567270f, 
    -0.01740909f, -0.01417164f, 0.11134549f, -0.22691031f, -0.28720421f, -0.10603371f, -0.09631419f, -0.02794795f, 
    0.05638736f, -0.02132404f, 0.05228985f, 0.15334296f, -0.31640676f, 0.33398902f, 0.43823439f, 0.04705844f, 
    0.12796791f, -0.03796668f, 0.33951619f, -0.12081616f, -0.01767205f, 0.09214540f, -0.22105819f, -0.12800694f, 
    -0.16335699f, 0.08110583f, -0.14580758f, 0.05712133f, 0.20298162f, 0.02667162f, 0.24430570f, 0.21914268f, 
    0.20067318f, 0.04476495f, 0.04407590f, 0.03552587f, -0.03028352f, 0.07719364f, 0.00178202f, 0.01085054f, 
    -0.17609370f, -0.00427406f, -0.25696906f, 0.04960812f, -0.08666055f, -0.01085148f, 0.13212046f, -0.00755741f, 
    -0.21792786f, -0.20271173f, -0.07071250f, -0.06885596f, -0.03420166f, 0.02656544f, 0.05404500f, 0.07149197f, 
    0.00466538f, 0.04668994f, -0.19700690f, -0.02698446f, -0.11321853f, 0.11997504f, -0.01930642f, 0.15899277f, 
    0.14041989f, 0.03775792f, 0.18178253f, 0.31161976f, 0.38086674f, -0.03234174f, 0.01408898f, 0.02260259f, 
    0.05873788f, 0.06435943f, 0.03568445f, -0.03246026f, -0.44721839f, 0.34327367f, -0.25133792f, 0.16669735f, 
    0.40468976f, -0.11469155f, 0.27433774f, -0.21147293f, -0.31629038f, -0.36704424f, -0.20219955f, -0.06544524f, 
    0.04801380f, 0.00637948f, -0.08462562f, -0.14612108f, -0.29285610f, 0.05776661f, 0.18933563f, 0.24247551f, 
    -0.00557271f, 0.12471901f, -0.19859441f, -0.06462059f, -0.16491048f, 0.07256355f, 0.16282907f, -0.08426343f, 
    -0.02752388f, -0.04295081f, 0.22804485f, -0.09797934f, -0.00121715f, -0.13445273f, -0.12056465f, -0.16456209f, 
    -0.23733002f, 0.04614215f, 0.10532806f, -0.03077189f, 0.03890706f, -0.01958225f, 0.01484983f, -0.37142733f, 
    -0.05441385f, 0.46110037f, 0.26962087f, 0.02980825f, 0.07325647f, -0.21297234f, -0.16344170f, -0.21625189f, 
    -0.43968561f, 0.31597850f, -0.09548039f, -0.05488018f, -0.05932190f, -0.03890616f, -0.22331588f, -0.08027104f, 
    -0.13629529f, -0.12192370f, -0.26786527f, -0.35332832f, 0.08868692f, -0.02938237f, -0.07416207f, -0.00953404f, 
    -0.04250845f, -0.11875553f, -0.10075661f, -0.02023632f, -0.22493048f, -0.14411539f, 0.06859914f, -0.06089399f, 
    -0.21561711f, 0.00106619f, -0.11915034f, 0.02169137f, 0.14077465f, 0.45746106f, 0.41830078f, -0.02983555f, 
    -0.05625259f, 0.12565982f, 0.04046162f, 0.07786501f, 0.03598242f, 0.16225468f, 0.18087457f, 0.04820478f, 
    -0.04086136f, -0.03502068f, 0.00175383f, -0.04389585f, -0.21814260f, -0.29246983f, 0.03115853f, 0.00492336f, 
    0.41114870f, 0.00513604f, 0.06502143f, 0.17083509f, -0.08982424f, 0.14089355f, -0.04562546f, 0.26829207f, 
    0.07658627f, 0.29723293f, 0.07252277f, 0.07071474f, 0.12822372f, -0.00537724f, -0.03220114f, -0.22346756f, 
    -0.39416978f, -0.03766000f, 0.47315526f, -0.10781273f, -0.00287471f, 0.31733388f, 0.21436626f, 0.22541234f, 
    -0.25058243f, -0.01871780f, -0.10184150f, -0.23867962f, 0.09525292f, 0.08784328f, -0.07862160f, 0.05110607f, 
    -0.03475422f, 0.04719658f, -0.10401782f, -0.11705802f, 0.40137860f, 0.05229750f, 0.10663383f, 0.07296529f, 
    -0.18977080f, 0.09759554f, 0.06295192f, 0.36620864f, 0.20772941f, 0.23240742f, -0.01255496f, 0.16416949f, 
    0.10325602f, 0.07115923f, -0.05681049f, 0.08206194f, -0.07538668f, 0.08192872f, -0.28845224f, 0.10766219f, 
    0.03821539f, 0.02214541f, 0.16266252f, 0.00476022f, 0.25010017f, 0.32172400f, -0.06342334f, 0.06804419f, 
    -0.05368409f, -0.02099930f, -0.24851768f, 0.17978117f, -0.00527889f, 0.14226171f, -0.06505177f, -0.19275258f, 
    -0.02515626f, -0.13503389f, 0.00675526f, -0.17171174f, 0.06797555f, -0.12335315f, 0.12643948f, -0.04580508f, 
    0.12112601f, 0.05424920f, -0.00854504f, 0.11340558f, 0.39104739f, -0.06754229f, 0.29200834f, 0.04019744f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.12229590f, 0.12581840f, 0.21846680f, 0.13148043f, 0.07212844f, 0.03597187f, 0.02698439f, 0.09605114f, 
    0.19410631f, 0.03017186f, 0.29000849f, 0.37497959f, -0.15749772f, 0.17098370f, 0.31373048f, -0.07030600f, 
    -0.11741113f, -0.12137792f, 0.09516712f, 0.23588173f, -0.03944869f, 0.06278177f, 0.25868574f, 0.05205063f, 
    0.43142995f, 0.02449583f, 0.15290941f, 0.10871744f, -0.00606921f, -0.07411744f, 0.22512870f, 0.08963714f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.34733978f, -0.14159049f, -0.80004191f, -0.28251544f, 0.54611564f, -0.14351818f, 0.07643083f, -0.51673400f, 
    -0.05366029f, -0.05314687f, 0.42107302f, -0.33790109f, -0.09934385f, -0.14731318f, -0.16302054f, 0.12568161f, 
    -0.17556247f, 0.22190943f, 0.14419872f, -0.06475490f, -0.00108564f, -0.44470498f, -0.27006716f, -0.09946586f, 
    -0.00502097f, 0.00419061f, -0.48766533f, 0.52487379f, -0.16886155f, 0.48500234f, -0.28520963f, 0.30582786f, 
    -0.04030738f, 0.07620972f, -0.12000255f, 0.14876522f, 0.97899550f, -0.09901664f, -0.07928860f, 0.25319657f, 
    -0.26088759f, -0.09853194f, -0.34246016f, -0.00242888f, -0.35775971f, 0.26193282f, -0.11175834f, -0.19701891f, 
    -0.50042439f, -0.15680094f, 0.19907765f, 0.14613396f, -0.14803448f, -0.20827445f, -0.07356878f, 0.42764336f, 
    0.18067276f, -0.06575712f, -0.52118522f, -0.13318108f, -0.52830207f, -0.13218875f, 0.19769132f, 0.32076511f, 
    -0.61020011f, -0.26963332f, 0.53909308f, 0.16732962f, -0.40145800f, -0.00136689f, -0.14748116f, 0.57734078f, 
    0.57423192f, 0.08919532f, 0.11388005f, 0.61366463f, -0.13115934f, -0.22478318f, -0.30668834f, 0.00213474f, 
    -0.41884145f, -0.07571656f, 0.02108593f, -0.08026107f, -0.00814035f, -0.20685652f, 0.36822584f, 0.13949709f, 
    0.01171760f, -0.00548988f, 0.01297785f, -1.39208078f, -0.34337780f, -0.05407248f, -0.67976648f, -0.43973720f, 
    -0.25526386f, -0.43657434f, 0.21310547f, -0.41615114f, -0.69597828f, 0.08061186f, -0.07682653f, -0.04385294f, 
    -0.26966050f, 0.16918282f, -0.48606867f, 0.36664668f, 0.15059967f, -0.26403368f, 0.33774257f, 0.03269006f, 
    0.23085329f, 0.58194298f, 0.05756803f, 0.53518093f, 0.11809271f, -0.52647132f, -0.12167208f, -0.14202164f, 
    -0.58455229f, 0.14673239f, 0.11572064f, -0.10191061f, 0.79151297f, 0.13409601f, -0.38561961f, -0.09151923f, 
    -0.50405264f, -0.11728376f, -0.56803727f, -0.08845253f, 0.01393391f, -0.16561265f, -0.12487821f, 0.41153714f, 
    0.33027968f, 0.03578316f, -0.20070598f, -0.75228256f, 0.02896069f, -0.11634969f, -0.82197344f, 0.21582375f, 
    0.24254793f, -0.38762474f, 0.20590419f, 0.28964841f, 0.15446332f, 0.18469928f, -0.13564232f, 0.28295240f, 
    0.12188887f, -0.13587719f, -0.13419035f, 0.30708757f, 0.32500118f, -0.30030221f, -0.06675972f, 0.14528891f, 
    -0.41297993f, 0.29803070f, 0.16894527f, -0.08135845f, -0.06425383f, -0.15937340f, -0.06199488f, -0.29340091f, 
    0.19304015f, 0.08731898f, -0.67821890f, 0.03811732f, 0.36098376f, -0.18942067f, 0.06646586f, -0.42251939f, 
    -0.74763536f, -0.27480373f, 0.04460720f, -0.00609450f, 0.40132377f, 0.47164336f, 0.04600227f, 0.32434747f, 
    -0.11654037f, -0.12410321f, 0.33294839f, 0.16806087f, -0.59975016f, 0.02476077f, -0.24571627f, 0.13414633f, 
    0.28728771f, 0.24112222f, -0.03586826f, -0.23261693f, -0.16430701f, 0.17205821f, 0.15274528f, -0.80325425f, 
    -0.85100776f, -0.09061012f, 0.71006274f, 0.10299994f, -0.25127771f, 0.16519909f, -0.48267993f, 0.18830155f, 
    0.23523629f, 0.01908726f, -0.10805564f, -0.03015365f, -0.27561998f, 0.02700222f, 0.28285372f, -0.11155745f, 
    0.47663802f, 0.11961842f, -0.14961928f, -1.07392240f, 0.08746301f, -0.55974233f, -0.77591002f, -0.94752502f, 
    0.47430131f, -0.35470259f, -0.36851552f, 0.19807398f, 0.03114471f, -0.01265130f, 0.15950194f, 0.22289813f, 
    -0.35345203f, 0.06381105f, 0.47892553f, -0.59414828f, 0.20684913f, 0.05288622f, -0.18777791f, 0.03275870f, 
    0.14754727f, 0.03886992f, 0.24182241f, -0.28370759f, 0.51435858f, -0.13320599f, -0.13642363f, -0.11923184f, 
    -0.41345647f, 0.12006555f, -0.16160835f, -0.47394690f, -0.02036783f, 0.09420320f, 0.11902980f, -0.23313770f, 
    0.23501146f, -0.04500408f, 0.24716987f, 0.14319256f, -0.44622445f, -0.06060560f, -0.08680103f, -0.09720454f, 
    -0.64489174f, 0.06680813f, -0.52043724f, 0.20209138f, -0.38308221f, 0.11908244f, 1.31098557f, -0.32503897f, 
    -0.00912586f, -0.11826941f, -0.03323712f, 0.19347587f, -0.49436578f, 0.49089974f, -0.25119847f, -0.47564024f, 
    -0.16135477f, -0.03142806f, -0.36930084f, 0.07147592f, -0.46940047f, -0.02122056f, -0.00001214f, -0.05817189f, 
    -1.09680998f, -0.10244498f, -0.41817486f, -0.68008381f, -0.04107755f, -0.03039993f, 0.11042280f, -0.10078882f, 
    0.39148623f, -0.12746519f, 0.40791592f, 0.32912901f, -0.00843928f, -0.10584391f, -0.73267519f, 0.20726086f, 
    -0.19472116f, 0.08678250f, -0.27782860f, 0.29764473f, 0.15892145f, -0.10762264f, 0.11403380f, -0.62833667f, 
    0.57338893f, -0.05960963f, 0.32293212f, 0.02427970f, -0.48162866f, 0.06708275f, 0.49894428f, -0.22979605f, 
    0.22418638f, 0.17042035f, 0.03194821f, 0.17015101f, -0.56624442f, 0.02448375f, -0.03847092f, 0.42782918f, 
    -0.52853888f, 0.07313497f, -0.17712745f, 0.16956891f, 0.06843418f, 0.23708750f, -0.69611192f, -0.83657396f, 
    0.67197919f, -0.02239451f, -0.39778242f, -0.16261554f, -0.65410644f, 0.02854653f, 0.02388651f, 0.21543968f, 
    -0.46100265f, -0.13778219f, -0.29933375f, -0.28181359f, -0.63150984f, 0.38984260f, -0.55203927f, 0.49877697f, 
    0.44316682f, 0.43618354f, 0.02406511f, 0.30790165f, -0.09255366f, -0.07895722f, 0.02518549f, -0.11985421f, 
    -0.22287230f, 0.05154808f, -0.45681992f, -0.58038306f, -0.26589647f, -0.22039492f, -0.08688729f, 0.27367827f, 
    -0.12366069f, 0.13331808f, -0.83074671f, -0.26134291f, -0.71456540f, -0.05623013f, 0.41777405f, -0.49530542f, 
    -0.35361305f, -0.00934290f, 0.32308009f, 0.21085742f, -0.41258264f, 0.04317404f, 0.43684012f, -0.67310238f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33681500f, -0.00462160f, 0.06521345f, 0.10055541f, -0.15192030f, 0.05758172f, 0.13683042f, -0.14407939f, 
    -0.02009492f, 0.16205464f, 0.12435577f, 0.04035887f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
