#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.51579982f, -0.45224294f, -0.42880249f, 0.77161306f, 0.12747097f, -0.42387795f, -0.15077302f, -0.23344994f, 
    -0.30115119f, 0.09385526f, 0.11625130f, 0.35055193f, 0.30603608f, -0.27303144f, -0.57152975f, -0.01998281f, 
    0.33574870f, -0.04931720f, -0.35926428f, 0.02019449f, -0.08119415f, -0.38888845f, 0.12771216f, -0.11779491f, 
    0.09466153f, 0.09793863f, -0.34502286f, 0.55312735f, 0.68644553f, -0.76039404f, -0.24989699f, -0.14241439f, 
    -0.24279919f, -0.00662161f, 0.14087163f, 0.20316853f, -0.27048185f, 0.61290300f, -0.58073992f, 0.32019666f, 
    0.15387487f, -0.18413173f, -0.15825891f, 0.23802029f, -0.05217681f, -0.58923358f, 0.19335720f, 0.45527557f, 
    0.02978141f, 0.09041969f, -0.22594728f, 0.39032364f, 0.41725999f, -0.06727947f, 0.07022025f, 0.50075752f, 
    0.12060302f, 0.06802495f, 0.35811371f, 0.01157627f, 0.04160338f, -0.30062765f, -0.26409170f, -0.27030995f, 
    -0.25619948f, -0.48182407f, -0.00891570f, 0.12665063f, 0.50944704f, 0.26450622f, 0.22501321f, 0.52370965f, 
    0.90179592f, -0.09820133f, -0.04004854f, 0.40220088f, 0.15727401f, 0.09273615f, -0.10383292f, 0.16171117f, 
    -0.25809586f, -0.49549592f, -0.34131700f, 0.24748527f, -0.32187542f, 0.64671957f, -0.45489034f, 0.07277442f, 
    0.02124973f, 0.20968486f, -0.52553213f, 0.34441245f, 0.52923322f, -0.55739301f, -0.27730405f, 0.38827032f, 
    -0.13916937f, 0.26559627f, 0.29443410f, -0.49601007f, -0.50415158f, 0.87008220f, 0.29665005f, 0.03941002f, 
    -0.00345128f, -0.28106081f, -0.09307308f, -0.10227308f, 0.09472635f, 0.06767806f, -0.37221646f, -0.22680025f, 
    -0.57963848f, -0.29898003f, -0.23175137f, -0.29034951f, -0.16029829f, 0.34740579f, -0.05669836f, 0.51627260f, 
    0.24962650f, 0.11563505f, 0.05059405f, 0.00711033f, 0.49236798f, -0.07434180f, -0.07328131f, 0.02141807f, 
    -0.08542552f, -0.40020683f, -0.48679709f, -0.50050110f, 0.49856216f, 0.42155486f, 0.20259620f, -0.44118568f, 
    -0.20451415f, 0.01533628f, -0.13079374f, -0.49724209f, -0.46339127f, -0.32207534f, 0.59037018f, -0.17631501f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01061309f, 0.16469710f, 0.28734130f, -0.00945244f, 0.05099558f, 0.17017017f, 0.29421338f, 0.33964896f, 
    -0.13008793f, -0.12439953f, 0.03710959f, -0.16517882f, -0.18931012f, 0.04756390f, -0.10989802f, -0.14244901f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.13182111f, -0.07134577f, -0.12255425f, -0.01116203f, -0.05815706f, -0.06171438f, 0.00273437f, -0.00276045f, 
    -0.02443694f, -0.05209402f, 0.01245388f, 0.15900299f, 0.09304816f, 0.08824607f, 0.08857609f, -0.03675584f, 
    0.08467047f, -0.04511008f, -0.08032347f, -0.25976858f, -0.20017184f, 0.05959311f, -0.11484691f, -0.11310113f, 
    0.11837707f, -0.12806030f, -0.03713573f, -0.20975506f, 0.05047107f, 0.17397951f, 0.04328175f, -0.02215071f, 
    0.05121484f, 0.07212339f, -0.12936634f, -0.05140764f, 0.20854834f, -0.00455144f, 0.00999540f, -0.13326946f, 
    -0.05181500f, -0.04238245f, -0.02274450f, -0.09758119f, -0.07223925f, 0.18041942f, 0.11569883f, 0.18427882f, 
    -0.07888890f, -0.27270448f, 0.06865619f, 0.23513198f, -0.04657714f, 0.23116904f, 0.11228639f, 0.05351052f, 
    -0.04467751f, 0.06272467f, 0.00157248f, -0.05696240f, -0.09577420f, -0.10073850f, 0.05059649f, 0.17934166f, 
    -0.04725809f, -0.02219974f, 0.00654267f, -0.22373369f, -0.12636466f, -0.11103372f, 0.05950360f, -0.17253542f, 
    0.39083636f, 0.06440116f, 0.22053145f, -0.05297307f, -0.24008963f, -0.09210934f, -0.02789865f, -0.06847280f, 
    0.08879360f, -0.06972637f, 0.06736860f, -0.01092549f, -0.02468699f, -0.24275590f, -0.11412527f, -0.00109876f, 
    -0.06240735f, 0.02171499f, -0.07849472f, 0.16756876f, 0.20908040f, 0.11364277f, 0.09147684f, -0.13569136f, 
    -0.05825261f, -0.13511954f, -0.00179039f, -0.33869359f, -0.03258623f, 0.08567525f, -0.17243753f, -0.03462334f, 
    -0.15577559f, 0.00387763f, -0.08840387f, 0.02681003f, 0.04569786f, -0.30413258f, 0.09112401f, -0.04495180f, 
    0.05679847f, 0.05868170f, -0.02983619f, -0.04490564f, 0.05716186f, 0.22064438f, 0.15318505f, 0.28963947f, 
    0.03522553f, -0.03171617f, -0.05437293f, 0.08060322f, 0.09225237f, 0.08152215f, 0.26222631f, -0.03813249f, 
    0.04536573f, 0.08070720f, 0.06638354f, 0.21831645f, 0.11567880f, 0.01738872f, 0.08008970f, 0.03096998f, 
    0.15897880f, 0.19778746f, -0.06690850f, -0.11590366f, 0.16791064f, 0.04874155f, -0.13453971f, -0.04259349f, 
    -0.21675499f, 0.06693415f, 0.11198753f, -0.16590516f, -0.09593280f, -0.17790318f, 0.06224798f, -0.10652251f, 
    -0.04499223f, -0.20772448f, -0.03276842f, -0.09401505f, 0.22231448f, 0.02043534f, -0.04041458f, 0.07459297f, 
    0.11982208f, 0.03565756f, -0.16816570f, 0.10503712f, 0.02524716f, 0.01115019f, -0.00094093f, 0.03086380f, 
    0.03507883f, 0.06468334f, -0.07309774f, 0.14248091f, -0.17813620f, -0.29465756f, 0.18597764f, 0.06487504f, 
    -0.00183817f, -0.17077687f, 0.07861875f, 0.07229534f, -0.21899332f, 0.00933391f, 0.14174657f, 0.18697913f, 
    0.06403433f, -0.00123521f, 0.18653648f, -0.02440277f, -0.08436505f, -0.18916640f, -0.00467783f, 0.09371836f, 
    0.01424150f, -0.01448452f, 0.02318861f, 0.22009848f, 0.00020155f, 0.05852988f, -0.11839584f, 0.19401129f, 
    -0.03903203f, 0.03935837f, -0.07428169f, 0.10754868f, -0.07664149f, 0.20066866f, -0.00979400f, 0.14914575f, 
    0.35109833f, 0.16281112f, 0.05678421f, 0.02894170f, 0.11685847f, -0.00966707f, 0.01725417f, 0.24467362f, 
    -0.12990560f, -0.13704096f, -0.08799678f, 0.14376101f, -0.11218297f, -0.14836957f, -0.14059654f, 0.05989016f, 
    -0.21872872f, -0.10814779f, -0.20003106f, -0.01258467f, -0.00485180f, -0.10143679f, -0.08763837f, -0.04974321f, 
    -0.20594129f, 0.07458054f, -0.18115570f, -0.21160719f, 0.04486705f, -0.00830987f, -0.07053065f, 0.16664775f, 
    0.06277715f, 0.06469131f, 0.10100817f, -0.00279348f, -0.01197583f, -0.05515577f, -0.11251558f, -0.12551315f, 
    -0.03558270f, -0.17484723f, -0.21221070f, -0.08129272f, -0.15451500f, -0.05235894f, -0.27917832f, 0.18646792f, 
    0.05413460f, -0.10404429f, 0.13550395f, 0.08174800f, -0.02956273f, 0.11304365f, -0.19680232f, -0.07706733f, 
    0.09375245f, 0.16499124f, 0.01635576f, 0.06536871f, -0.00851355f, 0.13004595f, -0.01655582f, 0.04950021f, 
    -0.17005336f, 0.12390371f, -0.11271933f, -0.07786515f, 0.08515298f, 0.07957645f, 0.07759322f, -0.10335595f, 
    -0.41774130f, -0.21350373f, 0.12248050f, 0.11327974f, -0.04681334f, -0.01525165f, -0.11847107f, 0.10792946f, 
    -0.15969163f, 0.16724433f, 0.01571506f, -0.09228593f, 0.13339320f, 0.04937233f, -0.05448140f, -0.24338765f, 
    -0.28638443f, 0.04862032f, 0.16368543f, 0.09100971f, 0.10270318f, -0.02778657f, 0.11296673f, 0.15909669f, 
    0.09493212f, 0.03261654f, 0.04073543f, 0.20302381f, 0.02944852f, 0.02555516f, -0.00916638f, 0.11159780f, 
    -0.11517691f, 0.00966005f, 0.02249455f, -0.11295468f, -0.17374034f, 0.04628026f, 0.04836483f, 0.10389851f, 
    0.07329592f, 0.12009944f, 0.08420972f, 0.04282825f, 0.10351607f, 0.01507140f, 0.23761517f, 0.03400497f, 
    0.04351915f, 0.23233253f, -0.00792089f, 0.24574976f, 0.01002012f, 0.13229054f, 0.12167618f, 0.03016277f, 
    -0.05945345f, -0.07121418f, -0.02020975f, 0.00533207f, -0.03148023f, 0.19911237f, -0.15469401f, -0.28540811f, 
    -0.11754274f, 0.05228036f, 0.01894758f, 0.02905458f, -0.12367426f, -0.23235081f, -0.04860583f, 0.08457462f, 
    -0.17247216f, 0.11443302f, 0.15662490f, 0.06288067f, 0.07226920f, 0.02232095f, 0.18336304f, 0.09364489f, 
    -0.36026967f, -0.18374765f, -0.25252691f, 0.18569139f, 0.08744878f, 0.06814331f, -0.07526249f, -0.05461777f, 
    0.02187285f, -0.02541927f, -0.16012764f, 0.03281924f, -0.15795119f, 0.10498575f, -0.01123484f, -0.04972612f, 
    -0.05666360f, 0.07174049f, 0.14712583f, -0.19714260f, 0.17141227f, 0.01801616f, 0.12639813f, -0.02715754f, 
    0.22773135f, 0.27273032f, 0.07805112f, 0.01873371f, 0.11669012f, -0.04664508f, 0.16807202f, -0.12521754f, 
    -0.10055101f, -0.12333118f, -0.15023468f, -0.23183513f, -0.13936155f, -0.05600192f, -0.09955576f, 0.25916785f, 
    0.07866772f, -0.03558496f, -0.07900415f, 0.00794659f, 0.13068379f, 0.08353029f, -0.00600739f, 0.00445658f, 
    -0.00081978f, 0.03608192f, 0.00005755f, -0.05058059f, 0.07635192f, 0.13338454f, -0.09914482f, -0.06856176f, 
    -0.04474222f, -0.09160865f, 0.08182529f, 0.05863461f, 0.14937399f, 0.19417860f, 0.14662860f, -0.12013545f, 
    -0.14826995f, -0.06722988f, 0.05659246f, -0.07587665f, -0.07980840f, 0.07931299f, 0.03417412f, -0.07912995f, 
    0.01804878f, -0.54398257f, -0.27751344f, -0.04119658f, -0.05930581f, 0.04386762f, 0.02496810f, -0.05275726f, 
    0.08373666f, -0.11464477f, 0.04426331f, -0.09061354f, 0.08380337f, 0.04888818f, -0.09734108f, 0.15711731f, 
    0.01423948f, 0.01411624f, -0.10416657f, -0.24581753f, -0.13739191f, -0.06315275f, 0.17980124f, 0.26594859f, 
    0.09658084f, 0.10853181f, -0.02919369f, 0.22385243f, 0.03656981f, -0.31967178f, 0.09700435f, -0.00052511f, 
    0.13353597f, 0.00129547f, -0.10906715f, 0.04721430f, -0.41230345f, -0.16885696f, 0.05083187f, 0.03674626f, 
    0.10217824f, 0.13761649f, 0.12167563f, -0.01150613f, 0.00166332f, -0.07142293f, -0.19759378f, 0.07402168f, 
    -0.11803588f, -0.04249829f, 0.02685650f, 0.05238507f, 0.01171441f, 0.09629641f, 0.00724633f, 0.33306724f, 
    0.21135083f, -0.01992522f, -0.00620374f, 0.02367724f, 0.06964365f, 0.08141454f, 0.37279931f, -0.25762928f, 
    0.19916031f, -0.30123135f, 0.02072446f, 0.16067718f, 0.02354912f, 0.12950757f, -0.10201799f, -0.11699820f, 
    0.03412679f, 0.29543370f, 0.07389020f, 0.05039432f, -0.13842790f, -0.01199493f, -0.10823803f, 0.00900422f, 
    -0.01100788f, -0.16161588f, -0.41145456f, 0.09543485f, -0.05439627f, 0.02594932f, 0.08689784f, 0.18634504f, 
    -0.02229324f, -0.03398060f, 0.01190162f, -0.05708069f, -0.16392855f, -0.26378921f, -0.11519001f, 0.11273013f, 
    0.02825673f, 0.01060212f, 0.10161451f, -0.04027950f, -0.15079528f, -0.38173288f, -0.12833208f, -0.02560773f, 
    0.03521997f, 0.05872786f, -0.10806746f, 0.14782871f, -0.40617222f, -0.11998551f, 0.14415345f, -0.25160062f, 
    -0.02169071f, -0.22809115f, 0.11083654f, -0.00123062f, -0.04255484f, 0.15650822f, 0.11043188f, 0.00855993f, 
    0.01683410f, -0.09896225f, 0.12158754f, 0.03447662f, -0.05159361f, -0.00949107f, -0.50894517f, -0.33876196f, 
    -0.09855478f, -0.05409483f, -0.05980787f, -0.21904272f, -0.04805439f, 0.03951638f, 0.02771291f, 0.34377334f, 
    -0.02886157f, -0.15372911f, 0.05451568f, 0.07943521f, -0.21548931f, -0.12093060f, 0.04974796f, 0.03112267f, 
    0.06730517f, 0.25823981f, 0.13846143f, -0.03993989f, 0.00927714f, 0.13851219f, 0.16034319f, 0.06773310f, 
    -0.07437554f, 0.06333372f, 0.15973248f, 0.12092149f, -0.12924947f, -0.21489643f, -0.13290703f, 0.10267796f, 
    -0.06922108f, 0.27819079f, -0.03713641f, -0.00262678f, 0.09629316f, 0.13371862f, 0.11261061f, 0.23321378f, 
    0.14890543f, 0.08429744f, 0.03771414f, 0.10285017f, -0.35632259f, -0.19493057f, 0.15591456f, -0.01381969f, 
    -0.11095263f, -0.03975395f, -0.15070221f, 0.09511817f, -0.33443367f, 0.11815980f, -0.08852649f, -0.03581971f, 
    0.01195122f, 0.05083931f, 0.03369869f, 0.08976487f, -0.09375342f, -0.15037586f, 0.02495844f, 0.08975481f, 
    -0.04451921f, 0.07168379f, -0.09948385f, -0.01046559f, -0.04682192f, 0.04964429f, -0.10415144f, 0.02000234f, 
    0.00755180f, 0.21514690f, -0.12611252f, -0.21757878f, 0.06184872f, 0.08034559f, -0.02614413f, -0.26245016f, 
    -0.21281601f, -0.10120805f, 0.14639105f, 0.14747462f, 0.08102605f, 0.07621740f, -0.01861594f, 0.14307289f, 
    0.53197575f, -0.16220139f, 0.04413579f, -0.13843688f, -0.00936778f, -0.22702530f, -0.05675435f, -0.02779474f, 
    -0.03798671f, -0.11644875f, -0.29247782f, 0.06574228f, -0.05521815f, 0.12288553f, 0.21596846f, 0.04157434f, 
    -0.12657735f, 0.05575383f, -0.36386287f, -0.03876024f, -0.19668618f, -0.00114983f, -0.09234331f, -0.02408270f, 
    0.04965912f, 0.11072171f, 0.00264605f, -0.29227555f, -0.46264049f, -0.06521193f, -0.26651621f, 0.01675891f, 
    0.04306188f, -0.11317226f, 0.04541712f, 0.11648003f, -0.13504334f, 0.08806248f, -0.03735875f, 0.02857810f, 
    -0.02169739f, -0.15364084f, 0.12548499f, -0.02284544f, 0.13969797f, -0.05042760f, 0.03515057f, 0.15001351f, 
    -0.04388831f, 0.07017550f, -0.01464605f, 0.01982981f, 0.17450778f, -0.02133198f, -0.24169709f, -0.07481629f, 
    -0.20059748f, -0.03770877f, -0.06868419f, -0.07281762f, -0.01567041f, -0.00669035f, 0.00534504f, -0.07520986f, 
    0.06802087f, 0.16838880f, -0.38831940f, -0.21353416f, -0.22448467f, -0.04593438f, 0.09691679f, 0.12643534f, 
    0.27708176f, -0.17067857f, -0.11884481f, 0.15552990f, 0.09947553f, -0.12199405f, 0.00860252f, -0.01809156f, 
    -0.02886057f, -0.23752424f, 0.10978726f, 0.01997452f, -0.15463626f, 0.17944473f, -0.03045500f, 0.10310555f, 
    0.06133594f, -0.09971244f, 0.27634034f, 0.21032572f, 0.03576173f, 0.17830780f, 0.04736580f, 0.13505529f, 
    -0.01842424f, 0.01985659f, -0.06063326f, -0.33011088f, -0.04251801f, 0.10497835f, -0.14671308f, 0.25499833f, 
    0.15546979f, 0.02053431f, -0.21203595f, 0.15144534f, -0.11061263f, 0.11577368f, -0.00872966f, 0.04395876f, 
    0.08359620f, 0.02445002f, 0.05814076f, 0.04733531f, 0.06244561f, 0.13995121f, 0.12030874f, -0.17575738f, 
    0.00705626f, -0.07579317f, -0.04979661f, 0.09967828f, 0.08638351f, -0.06406429f, -0.05996124f, -0.02378036f, 
    0.11836265f, -0.16505794f, 0.05536125f, -0.04425398f, -0.13949189f, -0.06731109f, -0.14383562f, 0.03062803f, 
    0.13158539f, 0.12359364f, 0.01846600f, -0.11374822f, -0.02955757f, 0.13639937f, -0.04670771f, 0.09795693f, 
    -0.12747072f, -0.20795718f, -0.02618413f, -0.04263373f, -0.09294718f, -0.04502407f, -0.01836065f, 0.04771758f, 
    -0.04626998f, 0.31202275f, 0.15760240f, 0.02059443f, -0.02636161f, 0.14595708f, 0.01422038f, 0.04570575f, 
    -0.06651840f, -0.08707655f, -0.22510819f, 0.13975605f, -0.16900176f, 0.11517625f, 0.02154787f, -0.06615612f, 
    0.10317749f, -0.04582717f, 0.03596325f, 0.19662994f, 0.13929455f, -0.17204732f, 0.02184692f, 0.19278495f, 
    -0.04968825f, -0.15957654f, 0.05427026f, -0.21090062f, 0.12435824f, 0.06868598f, -0.09778839f, 0.08418953f, 
    -0.06711358f, -0.05248342f, -0.09329823f, 0.11858699f, -0.14887850f, -0.15141214f, 0.09280688f, -0.04835767f, 
    0.03845815f, 0.02917049f, -0.09638441f, -0.01127899f, 0.16054317f, -0.03845818f, 0.01517150f, -0.12502843f, 
    -0.02902233f, -0.00680902f, -0.01641695f, 0.09710987f, 0.04329144f, -0.05929242f, 0.14818008f, 0.31336471f, 
    -0.00759128f, -0.03054867f, 0.05379868f, 0.17733011f, 0.10163514f, 0.01275673f, -0.00026202f, 0.04805002f, 
    -0.23127323f, 0.04610465f, 0.26057306f, 0.09791794f, -0.05213661f, -0.00619730f, 0.12457583f, 0.13718152f, 
    -0.04282633f, -0.22854757f, 0.05274593f, 0.20408796f, 0.15822355f, 0.05479480f, -0.10111006f, 0.10080514f, 
    0.25492555f, 0.20472872f, 0.17677331f, 0.03217336f, 0.12601280f, -0.01334224f, 0.06580377f, 0.14103894f, 
    -0.04691825f, 0.04843940f, 0.09634271f, 0.31621033f, 0.21202075f, 0.16106886f, -0.07832722f, 0.06883195f, 
    -0.09429047f, 0.02757028f, 0.05866542f, -0.01634857f, 0.10900262f, -0.00915830f, 0.10966202f, 0.09418960f, 
    -0.17002620f, 0.05042155f, 0.03167717f, -0.16269135f, 0.13019003f, 0.26350406f, -0.05497401f, -0.28100678f, 
    0.04444928f, -0.01085577f, 0.18775208f, 0.05580032f, -0.03176935f, 0.10112090f, 0.17288272f, -0.24507007f, 
    -0.01223338f, 0.00942815f, -0.10852617f, 0.13490675f, -0.06945867f, 0.02833352f, -0.08828297f, -0.00547709f, 
    0.17251056f, 0.29558632f, -0.04031701f, 0.07631087f, 0.03330501f, 0.08083050f, 0.01961721f, -0.03591173f, 
    -0.13433273f, -0.06203266f, -0.24678509f, -0.11793765f, -0.04991443f, -0.31270814f, 0.04664889f, 0.05544302f, 
    0.03755155f, -0.22556081f, 0.10289124f, 0.19022475f, 0.03273783f, 0.02923677f, -0.06196730f, -0.18922977f, 
    -0.07440895f, 0.06486627f, 0.21962680f, -0.19675097f, -0.42255619f, -0.16061918f, -0.01723487f, -0.19166520f, 
    0.03354923f, 0.14731959f, 0.00101646f, 0.32544300f, 0.17263712f, -0.16083099f, -0.05555654f, 0.10477207f, 
    0.00298448f, -0.05358760f, -0.06839766f, -0.13396539f, -0.03667542f, 0.08094712f, 0.06115644f, -0.10775355f, 
    -0.06763136f, -0.11261187f, -0.12865618f, 0.00729698f, -0.18849163f, 0.02070916f, 0.13144970f, 0.05047936f, 
    -0.32893187f, 0.02492858f, 0.00982243f, -0.04426485f, -0.04471928f, 0.14760536f, -0.29032084f, -0.25328979f, 
    -0.09475933f, -0.14323898f, -0.01616164f, -0.06181600f, 0.02467858f, -0.08629259f, -0.02362482f, -0.00396641f, 
    -0.09649277f, 0.07534191f, -0.05241186f, -0.06407443f, 0.02339967f, -0.06464657f, -0.18931173f, 0.11487314f, 
    -0.03268072f, -0.25088236f, -0.39808971f, 0.09395503f, -0.07611427f, -0.06126229f, 0.08341119f, -0.08043677f, 
    -0.02001337f, -0.16318230f, 0.10312344f, -0.12879337f, 0.14198683f, 0.08872487f, -0.01204488f, 0.06587182f, 
    0.00997637f, -0.04829048f, -0.14048824f, -0.27815112f, -0.00935376f, 0.03754351f, -0.09020204f, -0.11795339f, 
    -0.01589763f, 0.00261522f, -0.02099581f, 0.00584491f, 0.35446507f, 0.17954019f, -0.06717000f, 0.05164257f, 
    -0.05866456f, 0.03461806f, 0.14497229f, 0.01394153f, -0.03981536f, 0.47706068f, 0.05331724f, -0.06357493f, 
    0.26709247f, 0.15108530f, 0.09796472f, 0.17597364f, -0.18774486f, 0.01058808f, 0.09024122f, -0.11496806f, 
    0.08465397f, 0.08780709f, 0.08451218f, 0.02611241f, 0.06048385f, -0.04145528f, -0.01208801f, 0.22439821f, 
    0.05346505f, 0.00435251f, -0.20620450f, 0.09628912f, -0.04617772f, -0.03002395f, -0.19379762f, 0.03546727f, 
    -0.11624333f, -0.13951871f, -0.04465999f, 0.02727058f, -0.00522977f, -0.07631887f, -0.10517965f, 0.06109163f, 
    0.22069214f, -0.11007311f, 0.27273086f, -0.09224718f, -0.01670980f, 0.03290388f, 0.03852654f, -0.16410525f, 
    -0.03503914f, -0.08442160f, 0.04946629f, -0.09712437f, 0.05487271f, -0.08256782f, -0.00017232f, 0.22257589f, 
    -0.00454663f, 0.02468753f, 0.06845386f, 0.03839239f, 0.06764854f, 0.03491761f, 0.00082276f, 0.12771401f, 
    -0.05855246f, 0.11850909f, -0.01121038f, -0.28010368f, 0.18154795f, -0.13500707f, -0.06112566f, -0.01011380f, 
    0.02105041f, -0.03071526f, -0.02723263f, -0.01127527f, 0.11019525f, 0.01307185f, -0.09582198f, -0.00338512f, 
    0.00184541f, -0.00966543f, -0.00974391f, 0.03853412f, 0.08914416f, 0.01436503f, 0.34879091f, 0.19379367f, 
    0.12485015f, 0.09928398f, -0.23348148f, -0.02085294f, -0.07908748f, -0.01967390f, -0.07061025f, -0.01148707f, 
    -0.07294524f, 0.03542536f, 0.03343581f, 0.08812090f, 0.06053125f, -0.04650713f, 0.04929228f, 0.03672974f, 
    0.05490631f, 0.14368930f, 0.05745872f, 0.18482473f, -0.07608005f, 0.00083634f, -0.11280251f, 0.03722978f, 
    0.35551569f, -0.02134753f, 0.07488124f, -0.09749140f, -0.06915006f, -0.06510085f, 0.07643846f, 0.01213911f, 
    -0.02857113f, 0.05362441f, -0.21421632f, -0.07361007f, -0.12806296f, 0.00157766f, 0.03313621f, -0.02350999f, 
    -0.05800541f, 0.06117273f, -0.06927277f, 0.06240370f, 0.20039323f, -0.01859606f, 0.03715783f, 0.05779710f, 
    -0.06588247f, 0.03395160f, -0.03744882f, -0.07208651f, -0.18890774f, -0.39591807f, -0.01994379f, -0.01566522f, 
    -0.09564465f, 0.02808499f, 0.07813396f, -0.04176412f, -0.31386623f, -0.14887503f, -0.42558831f, -0.05460052f, 
    -0.05943859f, -0.01097876f, 0.01786473f, 0.05253948f, 0.07852127f, -0.07991835f, -0.03366389f, 0.26455104f, 
    0.04963188f, -0.02173069f, 0.05546871f, -0.02049842f, 0.14036418f, 0.13301322f, 0.03858151f, -0.10071801f, 
    0.13550301f, 0.02274416f, -0.18417728f, -0.06807184f, 0.08304349f, -0.05631284f, -0.02853728f, 0.06649449f, 
    0.05806501f, -0.12797791f, 0.03634440f, 0.03961908f, 0.05552286f, 0.08999046f, 0.06015455f, 0.14230219f, 
    -0.20039673f, 0.04862432f, -0.17040463f, 0.03622597f, 0.05500064f, -0.08492008f, 0.04796076f, -0.02256311f, 
    -0.05657980f, 0.35318914f, 0.05801645f, 0.02770730f, -0.18877237f, -0.08727404f, -0.01971287f, -0.09579829f, 
    -0.04889293f, 0.03370700f, -0.15281531f, -0.30985162f, 0.03082876f, -0.02820771f, 0.11056531f, -0.04575991f, 
    0.21149769f, 0.14859176f, 0.21767545f, 0.01223784f, -0.18965334f, -0.19540587f, -0.01658930f, -0.07984689f, 
    0.06164266f, 0.01491315f, 0.09887074f, -0.06920974f, 0.09124680f, 0.24649434f, 0.24654070f, -0.00987400f, 
    -0.02808328f, 0.04099873f, 0.07117766f, -0.08143243f, -0.01151764f, -0.04895762f, -0.22972751f, -0.32913283f, 
    0.00751168f, -0.03843237f, 0.04811347f, 0.04330341f, 0.18049759f, 0.09999857f, 0.29301855f, 0.22963262f, 
    0.24024045f, -0.11266653f, -0.02630488f, -0.14928193f, -0.09499897f, 0.13539560f, -0.02821626f, 0.12120941f, 
    0.31862077f, 0.30508742f, 0.04032258f, 0.08348468f, -0.09308210f, -0.01521837f, 0.00097272f, 0.04457653f, 
    -0.11847903f, -0.00884450f, 0.09372870f, 0.09904578f, 0.10696317f, -0.03025791f, 0.01102492f, 0.12972236f, 
    0.22888255f, 0.03938964f, -0.01446780f, -0.11644039f, -0.08885729f, -0.02441409f, 0.11125679f, -0.09606639f, 
    -0.02653270f, 0.02721745f, 0.03454156f, 0.03955957f, -0.02691475f, -0.04605338f, 0.02474035f, -0.19389482f, 
    0.04762556f, 0.06457879f, 0.15473910f, 0.08077832f, 0.26261505f, -0.05020585f, -0.02665155f, -0.07758131f, 
    -0.11634262f, -0.01549850f, -0.01238118f, -0.02667122f, 0.08297739f, -0.24205187f, -0.17048542f, 0.02756569f, 
    -0.05729183f, -0.05667153f, 0.05100824f, -0.05534403f, -0.14756057f, 0.08992726f, -0.22608028f, 0.00777850f, 
    0.16244993f, -0.06377418f, 0.19564037f, 0.04615099f, -0.19774698f, -0.04874952f, 0.03951271f, 0.02117934f, 
    -0.14575104f, 0.12025697f, 0.21504049f, 0.13008843f, 0.13520725f, -0.07087742f, 0.05138697f, 0.05630825f, 
    -0.00564366f, 0.18395618f, -0.03633301f, 0.05658549f, 0.07476526f, -0.03487020f, 0.03662968f, -0.23000719f, 
    0.02422032f, -0.09211010f, -0.32297343f, -0.03079992f, -0.00005449f, 0.22881377f, 0.05261917f, 0.01050808f, 
    0.10989928f, -0.14981924f, 0.12390502f, -0.24208124f, -0.09936409f, 0.06394532f, 0.08996646f, 0.06896935f, 
    -0.00512844f, 0.02113398f, -0.03409669f, -0.03302637f, -0.19578834f, -0.04240235f, 0.00803955f, 0.08145994f, 
    -0.03698659f, 0.03817431f, -0.04483612f, -0.06087837f, 0.06110550f, -0.22658992f, -0.03101239f, -0.04404778f, 
    0.13277115f, -0.10201287f, 0.18365769f, -0.12014636f, 0.07710996f, 0.18718791f, 0.26957932f, -0.00171792f, 
    0.05540359f, -0.07033577f, 0.05098740f, 0.13523553f, 0.09768059f, 0.07356320f, 0.01983561f, -0.13355622f, 
    -0.05879000f, -0.05380510f, 0.14386879f, -0.03787246f, -0.04771896f, 0.01884136f, 0.12372811f, -0.07588842f, 
    -0.03561839f, 0.21907316f, 0.06899253f, 0.15966605f, -0.17676525f, -0.15185016f, -0.19660528f, -0.08202971f, 
    -0.10699717f, -0.10782512f, 0.19094431f, 0.05981077f, 0.04347330f, 0.02692767f, 0.04480353f, -0.01887443f, 
    0.14058992f, 0.01817711f, 0.01755130f, 0.01138623f, 0.05161400f, -0.02480972f, -0.04856431f, -0.06345996f, 
    -0.12370656f, -0.00393017f, 0.19121616f, 0.21563230f, -0.05143531f, 0.05470924f, -0.20893168f, 0.11000833f, 
    0.05900886f, 0.12315484f, -0.15257220f, 0.01511864f, -0.20461093f, -0.10159273f, -0.09010227f, 0.08326684f, 
    -0.06742508f, 0.13102704f, -0.07816552f, -0.06632380f, 0.01125932f, -0.07602526f, -0.06717146f, 0.06133422f, 
    0.01099844f, -0.08714685f, -0.03587195f, 0.10097989f, -0.14770393f, 0.00078210f, 0.08027634f, 0.08669419f, 
    -0.11791290f, 0.01263255f, 0.05697067f, -0.06803233f, 0.07249234f, 0.09247619f, -0.03427377f, 0.20439149f, 
    0.04757410f, 0.09793090f, -0.01666562f, -0.18939203f, 0.07428264f, 0.04500283f, -0.15511847f, -0.04580386f, 
    0.02404718f, 0.19288160f, -0.15568751f, -0.19082353f, 0.12283945f, -0.09971679f, 0.05978185f, -0.21351321f, 
    -0.06520092f, -0.38947275f, 0.16593494f, 0.10312603f, -0.00586038f, 0.05059512f, 0.09349717f, 0.04548599f, 
    0.12472782f, -0.03618294f, 0.23020844f, -0.08458852f, 0.04344902f, -0.07792848f, -0.04830030f, 0.07487077f, 
    -0.08551455f, -0.13494922f, 0.06756487f, 0.47011787f, -0.11793794f, 0.04730866f, -0.21329492f, -0.03714469f, 
    0.12467498f, -0.11994939f, 0.06636589f, 0.20993501f, 0.12232292f, 0.16507292f, 0.06867065f, -0.04822141f, 
    0.04717346f, 0.03414314f, 0.17709659f, -0.34419969f, -0.22405000f, -0.18277624f, 0.10639229f, 0.41611037f, 
    0.12220103f, -0.00737776f, -0.15255460f, -0.15501830f, -0.05708717f, -0.24652985f, -0.06239847f, -0.22640081f, 
    -0.04827720f, 0.08780942f, -0.10329805f, -0.03342985f, 0.01909792f, 0.08764598f, 0.11044692f, 0.34688038f, 
    -0.03085786f, 0.11495238f, -0.03442502f, -0.11986618f, 0.01789013f, 0.02113817f, -0.17837732f, -0.22445746f, 
    -0.21148212f, -0.12102709f, -0.14977162f, -0.00813855f, 0.03724297f, 0.04285568f, 0.04601700f, 0.01109295f, 
    -0.17303500f, 0.30100793f, 0.00297218f, -0.05477347f, 0.01796908f, 0.01511868f, 0.12418570f, 0.02156646f, 
    0.03023292f, -0.20625924f, 0.00211407f, 0.08219445f, 0.00033298f, 0.15524568f, 0.06227861f, 0.07576732f, 
    0.23077090f, 0.25777245f, -0.00828844f, 0.02999376f, -0.04427646f, 0.17617483f, 0.13716365f, -0.10275393f, 
    0.10223292f, -0.01411672f, -0.05058634f, 0.02703469f, -0.06435455f, 0.05761066f, 0.06280734f, -0.03538266f, 
    0.09656659f, 0.03163818f, 0.08680150f, -0.24010800f, 0.32267806f, 0.07013785f, 0.06175412f, -0.05677839f, 
    -0.08203790f, -0.02557616f, -0.00798852f, 0.00848282f, 0.04290785f, -0.02245113f, -0.06308769f, -0.02266432f, 
    0.05155823f, 0.14512664f, 0.02081074f, 0.02417475f, -0.04688859f, -0.10008058f, 0.03924981f, -0.03816236f, 
    -0.04437056f, 0.12235214f, -0.05305824f, -0.08435497f, 0.02806780f, 0.02241059f, -0.00977220f, 0.33406284f, 
    0.17799969f, 0.01923109f, 0.16392575f, -0.06402791f, 0.16102420f, 0.08036350f, 0.05652429f, -0.02674495f, 
    -0.14259954f, -0.14028981f, 0.12220969f, -0.09229583f, 0.06747641f, -0.18948178f, -0.19536439f, -0.10082303f, 
    -0.13123780f, 0.11199827f, 0.14899141f, 0.10109009f, 0.03175213f, 0.14252371f, 0.00870240f, 0.11169714f, 
    -0.09251983f, 0.06757299f, -0.22479621f, -0.11194623f, 0.01868922f, 0.07933836f, 0.09980696f, 0.10375661f, 
    -0.03866696f, -0.05870492f, -0.01771245f, 0.17886877f, -0.07002169f, -0.07083414f, -0.04036533f, 0.19225244f, 
    0.00578080f, -0.18123020f, -0.15393892f, 0.16689619f, 0.03278418f, -0.14053532f, 0.15571135f, 0.00336876f, 
    -0.04764177f, 0.09587181f, -0.03453162f, -0.00451781f, 0.16535389f, 0.06713936f, 0.18587299f, 0.20986795f, 
    -0.04907467f, 0.01554022f, 0.05236550f, -0.18523005f, 0.16384332f, -0.02199290f, -0.02329793f, -0.07356156f, 
    0.06760415f, 0.04291456f, 0.07201970f, 0.00373204f, -0.08747178f, -0.08894638f, 0.00763193f, -0.23955572f, 
    -0.25935975f, 0.06076578f, 0.11247561f, -0.08283035f, -0.01426225f, 0.02260936f, -0.12617986f, -0.02228005f, 
    0.01980673f, -0.09308119f, 0.06867831f, -0.00292268f, -0.07397439f, 0.14710020f, -0.00157815f, 0.09809431f, 
    0.00312578f, -0.26165694f, 0.12107316f, -0.17074725f, 0.01734245f, -0.12169293f, -0.01660927f, -0.08976245f, 
    0.06778946f, 0.01121130f, 0.24031234f, 0.34546733f, 0.05822881f, 0.12976420f, -0.14261787f, 0.12541768f, 
    0.02934692f, 0.22019747f, 0.00379616f, 0.10950457f, 0.10722141f, -0.17276439f, 0.00177129f, 0.00908871f, 
    0.07394146f, 0.11441574f, 0.00991285f, 0.03232335f, 0.50961673f, 0.28537026f, -0.07496883f, 0.15975414f, 
    -0.02494465f, 0.05919995f, -0.02952274f, -0.03896725f, 0.08787341f, -0.07264624f, -0.01336161f, -0.05499123f, 
    0.14811471f, -0.04013197f, 0.11297265f, -0.09497574f, 0.13483486f, 0.08851630f, -0.14142787f, -0.34287697f, 
    -0.08801634f, 0.15503708f, -0.15189779f, -0.00370328f, 0.17114952f, 0.00540721f, 0.05624525f, -0.01272089f, 
    0.02556337f, -0.00796934f, 0.05295156f, -0.16431953f, 0.16022620f, 0.03711974f, 0.05396648f, -0.11454462f, 
    0.23325956f, 0.22897947f, -0.11800621f, -0.02151820f, -0.03871009f, 0.04347562f, 0.05236765f, 0.00424653f, 
    0.04174278f, -0.24781014f, 0.27522972f, -0.06975814f, -0.36137730f, -0.01125559f, 0.08667002f, 0.03614668f, 
    0.16805895f, -0.26724291f, 0.06397901f, 0.43031591f, 0.05735819f, -0.14413403f, -0.27125490f, 0.09169140f, 
    -0.10860054f, -0.07130057f, -0.39398891f, 0.01420438f, -0.36426905f, -0.06043316f, -0.10134432f, -0.07399487f, 
    0.11924029f, -0.12995051f, 0.02496793f, -0.78314823f, -0.29576290f, -0.08277636f, -0.22255255f, 0.17138565f, 
    0.00724100f, -0.05108354f, -0.16823125f, 0.12952432f, 0.07517396f, -0.09888603f, 0.22169885f, -0.13195537f, 
    -0.13588658f, -0.04334532f, 0.00565214f, -0.00307510f, -0.05200221f, 0.00335436f, 0.00954441f, 0.17703889f, 
    -0.22785623f, 0.16954578f, 0.02321080f, 0.08261839f, 0.07710643f, 0.11628575f, -0.17529611f, 0.05066786f, 
    0.16145717f, -0.03634179f, 0.00159786f, -0.09881515f, 0.05451847f, -0.11437286f, -0.12147605f, -0.02074281f, 
    0.37444597f, 0.20469837f, -0.18972296f, -0.03976062f, -0.08252690f, 0.13232693f, -0.00628982f, 0.14383951f, 
    0.09675662f, -0.00312203f, 0.04296921f, 0.14571950f, 0.09947666f, -0.06548944f, -0.09918486f, 0.12791531f, 
    0.21474180f, 0.04946785f, -0.03768339f, 0.06260823f, 0.12770602f, 0.00698519f, -0.14560844f, 0.10992344f, 
    0.10606953f, -0.08794098f, -0.10682697f, -0.04278493f, -0.07158067f, 0.07271383f, -0.02864297f, -0.07006343f, 
    -0.00623486f, 0.11059365f, 0.11876129f, 0.39981547f, 0.27086604f, -0.15947047f, 0.07883706f, -0.09741221f, 
    0.02610242f, 0.03585590f, -0.02964186f, -0.04068699f, -0.18548539f, -0.25100902f, -0.10100237f, 0.09513866f, 
    -0.07701163f, -0.04769232f, 0.13877767f, -0.00055596f, 0.01067454f, -0.28194475f, -0.12876910f, 0.00134306f, 
    -0.08017641f, 0.00462617f, -0.05709328f, 0.11411209f, -0.02793336f, -0.07480803f, 0.10893351f, 0.19067250f, 
    0.13761020f, 0.10233843f, -0.06661776f, -0.10601716f, -0.08041804f, 0.12262113f, 0.33042288f, -0.06213430f, 
    0.31964961f, -0.03561887f, 0.03112083f, 0.10148325f, 0.02234824f, 0.03758506f, 0.05629877f, -0.06387953f, 
    0.07241032f, 0.04917446f, 0.21524772f, 0.06024797f, 0.10516362f, 0.04870102f, -0.11915821f, -0.04526352f, 
    0.07675780f, -0.33288425f, -0.45956129f, 0.22399648f, -0.14893275f, 0.08743861f, -0.26916373f, 0.07193764f, 
    -0.03273513f, 0.17577010f, 0.06338073f, 0.08271363f, -0.19552158f, 0.01506794f, 0.09515473f, 0.14036442f, 
    0.08731019f, 0.03520045f, -0.11053434f, -0.36089647f, -0.08790661f, 0.11349019f, 0.06190945f, 0.24740446f, 
    0.10438277f, 0.00295167f, -0.02204726f, 0.01050007f, -0.02857154f, 0.02015209f, -0.33923411f, -0.25475156f, 
    -0.06232873f, -0.06052690f, 0.09008972f, 0.00329937f, -0.02602563f, 0.25870886f, 0.00686276f, 0.02913801f, 
    0.00606209f, 0.15486532f, -0.04830121f, -0.07895858f, -0.02280979f, -0.03358589f, -0.07921164f, 0.07732138f, 
    -0.27480340f, -0.08378198f, -0.08109649f, -0.10889771f, -0.04001983f, -0.12624873f, -0.18276742f, -0.03898029f, 
    -0.26909521f, -0.15556876f, -0.05631744f, -0.04837852f, -0.03598796f, 0.02440212f, 0.04495722f, -0.08838420f, 
    -0.32413161f, -0.11665373f, -0.17291750f, 0.01406159f, -0.07214785f, 0.00914668f, 0.05164131f, 0.05828124f, 
    0.00709726f, -0.28754669f, 0.07736636f, 0.18641843f, 0.01250663f, -0.00311053f, -0.10967139f, 0.07210232f, 
    0.05883309f, 0.08626620f, -0.14828843f, 0.09041904f, 0.31130454f, -0.08575667f, 0.06292666f, 0.01022167f, 
    -0.06734171f, 0.02730175f, 0.05488876f, 0.40548825f, -0.00680639f, -0.51136708f, 0.00642102f, 0.15076385f, 
    0.10215962f, -0.06483380f, 0.04031653f, 0.03713984f, 0.12474065f, 0.30005634f, -0.36224908f, 0.07620717f, 
    0.12128302f, 0.26786909f, 0.00157791f, 0.08445148f, 0.05460260f, -0.15296492f, -0.03866723f, -0.11236900f, 
    0.00362920f, 0.13290970f, 0.09738423f, 0.09267850f, -0.03049414f, 0.03534662f, 0.02133113f, 0.14914927f, 
    0.09809858f, 0.13713403f, -0.00468908f, -0.24515744f, 0.07859295f, -0.02535835f, 0.04506446f, 0.36745030f, 
    -0.18258615f, -0.08923584f, -0.10916929f, -0.08044768f, -0.04097563f, 0.00907482f, 0.04369404f, 0.05148680f, 
    -0.35141140f, 0.07986160f, 0.15806340f, -0.26746577f, -0.04445724f, -0.27767819f, 0.14872672f, -0.04070985f, 
    0.05249013f, -0.41125041f, -0.28623086f, -0.07655160f, 0.05389251f, -0.07308495f, -0.16989437f, 0.04879022f, 
    -0.05174550f, -0.01983149f, -0.07301586f, -0.47619569f, -0.02712179f, 0.05857675f, 0.08555695f, -0.06645948f, 
    0.05187482f, 0.02829384f, -0.15680155f, -0.31139976f, -0.50019968f, -0.09076988f, 0.13749015f, 0.05528313f, 
    0.15595627f, -0.04762901f, -0.04938136f, 0.04704552f, 0.15923966f, 0.10097465f, 0.01636360f, 0.15306528f, 
    0.01911158f, -0.00771910f, 0.09989826f, 0.04258568f, -0.02607714f, -0.12000035f, 0.27373815f, -0.09025501f, 
    0.01873367f, -0.21896021f, -0.14490457f, -0.08429801f, 0.03340735f, 0.07858910f, 0.05050898f, 0.01294046f, 
    0.22867540f, -0.07225174f, -0.02941787f, -0.02511491f, -0.04364558f, -0.00016362f, -0.08234765f, -0.00654612f, 
    0.17126533f, 0.29565611f, -0.16376695f, 0.02899896f, -0.02434644f, 0.02278545f, 0.03347034f, 0.13172542f, 
    0.02375993f, -0.07427575f, -0.01663473f, -0.02783598f, -0.03892740f, -0.09003263f, -0.08656513f, -0.05243809f, 
    -0.04887107f, -0.07768155f, -0.01620785f, -0.07566455f, -0.04882978f, -0.07812279f, 0.03250923f, -0.04693510f, 
    0.04924075f, -0.07092109f, -0.07219023f, -0.04725997f, -0.07234976f, 0.10578130f, 0.01573134f, -0.08839498f, 
    0.04322807f, -0.07505488f, 0.03989668f, 0.03903330f, -0.00163742f, -0.04761122f, -0.08309960f, 0.02886249f, 
    -0.06264241f, -0.06481978f, 0.02355577f, -0.07753915f, 0.01559585f, -0.05216699f, -0.00036543f, -0.00390279f, 
    0.04230985f, -0.02724524f, -0.04967702f, -0.02918124f, -0.06652729f, 0.01295625f, -0.09371505f, -0.09502058f, 
    0.03239504f, -0.02461426f, -0.03001238f, -0.03085536f, -0.08786872f, -0.09008720f, -0.03624132f, 0.00430478f, 
    -0.03330159f, -0.01354288f, -0.06421573f, 0.01459233f, -0.05242527f, -0.10191747f, 0.03111566f, 0.01815392f, 
    -0.08182169f, -0.06239097f, -0.06988443f, -0.07437020f, 0.00119801f, 0.00739004f, -0.04520889f, -0.03820539f, 
    -0.07216735f, -0.11288476f, 0.09945670f, -0.03104001f, 0.04599986f, -0.00102923f, -0.01128430f, -0.05488356f, 
    -0.04030636f, -0.09299388f, 0.06038225f, -0.10471684f, 0.00891414f, 0.00008629f, -0.10608642f, 0.00080271f, 
    -0.05315470f, -0.07411543f, 0.03998122f, -0.06644090f, -0.05617056f, 0.04444665f, -0.03499819f, -0.04625097f, 
    -0.07505780f, -0.07264253f, -0.10631601f, 0.02452333f, -0.03551203f, -0.02301852f, 0.03897259f, 0.00218838f, 
    -0.07795740f, -0.04519761f, -0.06098228f, 0.05381143f, -0.04430306f, 0.05749872f, 0.04273479f, 0.05348099f, 
    -0.01561224f, 0.09822060f, -0.05123327f, -0.05126375f, -0.00822154f, 0.05057650f, -0.07894254f, 0.04493369f, 
    -0.00582403f, -0.05459831f, -0.07813271f, -0.06977650f, 0.02207518f, 0.02192853f, -0.04117528f, -0.02757476f, 
    -0.08019525f, -0.06310474f, -0.10005408f, -0.06883314f, -0.04574776f, -0.01721759f, -0.09590637f, 0.06029422f, 
    0.00070625f, -0.03488205f, 0.04964810f, 0.05462781f, 0.05468244f, -0.04419402f, 0.04879334f, -0.11115957f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.07032447f, 0.26477987f, 0.06766323f, 0.18203285f, 0.20794013f, -0.01354195f, 0.07591835f, -0.02927694f, 
    0.09827033f, -0.12721629f, -0.00270356f, 0.00141456f, 0.03660635f, 0.10285345f, 0.09451351f, 0.05237459f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05869798f, -0.37547073f, -0.31076154f, -0.24294586f, -0.49619496f, 0.14285807f, 0.26481372f, -0.25663939f, 
    0.33704320f, 0.35506806f, -0.33941126f, 0.06801317f, -0.07504062f, -0.22211279f, -0.33000514f, 0.15421502f, 
    -0.02657799f, 0.00266823f, 0.36719409f, 0.14314052f, -0.37309396f, -0.12864426f, -0.09530789f, 0.15597160f, 
    -0.11823890f, -0.04336402f, 0.05638149f, 0.17101066f, -0.18035941f, -0.08217826f, -0.27221316f, 0.14331666f, 
    -0.13456067f, 0.27269426f, -0.23132315f, 0.33080980f, 0.22705661f, -0.27527869f, 0.51195997f, -0.02944776f, 
    0.01820641f, -0.11976070f, 0.14717436f, -0.05481333f, -0.01127934f, 0.11491919f, -0.17970112f, -0.14275981f, 
    0.19213812f, -0.06156671f, -0.20243812f, 0.28170601f, -0.03369970f, -0.03192652f, -0.26058099f, 0.15101336f, 
    -0.00218527f, 0.01813466f, -0.18292165f, 0.28668278f, 0.17537539f, 0.16525839f, 0.31162405f, 0.21112481f, 
    -0.24901620f, 0.12021384f, -0.04048768f, 0.41340899f, 0.26400670f, -0.02414907f, -0.09311449f, 0.50158674f, 
    0.08963276f, -0.24808435f, -0.03471732f, -0.22317122f, 0.25119537f, -0.30775437f, -0.01177863f, 0.08600835f, 
    0.20218010f, 0.12740009f, 0.02982862f, -0.50395387f, 0.03864453f, -0.21190679f, -0.00891841f, 0.02127581f, 
    0.18932356f, 0.12708537f, -0.35320529f, 0.29170737f, 0.24233718f, -0.09167777f, 0.07138880f, -0.06473682f, 
    -0.05613267f, 0.15622285f, -0.20234810f, 0.10434702f, 0.00226655f, -0.14549541f, 0.12099601f, -0.06399167f, 
    0.00860493f, 0.17419371f, -0.25016457f, -0.20127775f, 0.10084922f, 0.04955924f, 0.28565061f, 0.08973214f, 
    -0.25968853f, -0.18166675f, -0.04117638f, -0.64518005f, 0.08377887f, 0.24802656f, 0.43506551f, -0.26526138f, 
    -0.30155265f, 0.23122758f, -0.00531621f, 0.02609522f, 0.23970066f, -0.05308417f, 0.07286785f, -0.14676814f, 
    0.17492260f, -0.11913158f, -0.19385888f, -0.14897047f, -0.21535493f, 0.19206259f, 0.11768892f, -0.04358225f, 
    -0.19183370f, -0.24179469f, -0.02357109f, 0.28129268f, -0.11102924f, -0.15503219f, 0.43339151f, -0.21424139f, 
    -0.46712112f, 0.20170875f, 0.18777220f, 0.59613174f, 0.37713337f, 0.19470640f, 0.22906615f, 0.26716277f, 
    -0.09798460f, -0.27165201f, -0.12551996f, -0.22301452f, 0.02793839f, -0.35568690f, 0.05977215f, -0.16742933f, 
    0.14635430f, 0.21110259f, 0.21003002f, -0.03766943f, 0.53948021f, 0.11070424f, -0.07947639f, -0.22373024f, 
    0.25015354f, -0.28875822f, -0.13555378f, -0.13213158f, -0.17290127f, 0.15686098f, -0.19934630f, -0.23703085f, 
    0.25135237f, -0.29573044f, 0.11496858f, 0.20166537f, -0.37094498f, 0.34791481f, -0.00502192f, 0.16363946f, 
    0.06616718f, 0.10872518f, -0.29325765f, 0.00133880f, 0.14724261f, -0.45497030f, -0.16950050f, -0.08326696f, 
    -0.00542323f, -0.29335767f, 0.23710735f, 0.25461572f, -0.09770135f, 0.29398924f, 0.23511866f, 0.17770819f, 
    0.06932151f, -0.20519385f, 0.33221483f, -0.16362460f, -0.03772566f, -0.36385730f, 0.33404598f, -0.16358232f, 
    -0.09717326f, -0.00650595f, 0.30404624f, 0.31338638f, -0.04891534f, 0.01334626f, -0.05529845f, -0.26708636f, 
    0.14748496f, -0.33547977f, 0.22357853f, 0.23497617f, -0.21520619f, 0.26956460f, -0.41578931f, 0.09549686f, 
    0.09149309f, 0.33790544f, 0.33864379f, 0.34007546f, -0.54598457f, 0.27121219f, -0.19435728f, 0.00414100f, 
    -0.24703670f, -0.04859985f, -0.00914635f, 0.08028251f, -0.16455038f, -0.32062313f, -0.13342391f, -0.05971700f, 
    -0.58559173f, 0.26818618f, 0.19076756f, -0.07882159f, 0.01208846f, 0.03109311f, 0.50962406f, -0.33564124f, 
    -0.28068587f, 0.09147315f, -0.07207772f, 0.09612845f, -0.12143411f, 0.08849224f, 0.29415447f, -0.11977354f, 
    -0.15972674f, 0.33075804f, 0.25945392f, 0.39400756f, -0.13565227f, -0.22387049f, -0.26786879f, -0.32793149f, 
    0.28092602f, 0.01939858f, 0.05297238f, 0.02344604f, -0.15280512f, -0.03027080f, -0.03506104f, 0.02798677f, 
    0.12862810f, -0.21804528f, 0.27638316f, 0.20082924f, -0.02730623f, 0.01440624f, 0.32900989f, -0.14014548f, 
    -0.10738496f, 0.18083476f, 0.15955631f, -0.18667610f, -0.25515446f, -0.27956849f, 0.43457070f, -0.22266796f, 
    -0.06704381f, -0.26107451f, -0.00256887f, -0.81464124f, -0.16452651f, -0.19519296f, 0.01909612f, -0.41067070f, 
    0.31819102f, 0.21586080f, -0.25316215f, 0.26345548f, 0.24683923f, 0.19211231f, 0.00224695f, -0.16475339f, 
    0.08308180f, 0.05245940f, -0.22886679f, -0.02267635f, 0.26053289f, -0.05127887f, -0.20673694f, -0.05634061f, 
    0.31591734f, -0.19891602f, 0.35995224f, 0.11375233f, 0.17783158f, 0.32461241f, 0.37416169f, -0.17647669f, 
    -0.20553708f, -0.21758004f, -0.11102944f, 0.01967799f, 0.09817283f, 0.04611472f, -0.09480124f, -0.04505317f, 
    -0.18742421f, -0.13198072f, -0.08928522f, -0.04646244f, 0.18000649f, 0.16628723f, -0.09488777f, 0.11833471f, 
    -0.13065456f, 0.27438238f, 0.08898508f, -0.49122450f, 0.23950104f, 0.08575231f, 0.14395162f, -0.20392191f, 
    -0.29292831f, 0.17207219f, 0.08272368f, 0.08408565f, 0.19328842f, -0.15515809f, -0.13025860f, -0.04020341f, 
    0.22321220f, -0.05634839f, 0.24250343f, -0.25083879f, -0.08666979f, -0.03330593f, -0.25952137f, 0.04217857f, 
    0.33892921f, -0.07829744f, -0.11553472f, -0.00939241f, -0.21243337f, 0.16539364f, -0.14749089f, 0.05034234f, 
    -0.17140619f, -0.10220066f, 0.29134768f, 0.12066129f, -0.45456588f, 0.07868902f, 0.20565946f, 0.06291977f, 
    -0.31040850f, -0.02377999f, -0.01882053f, 0.22987825f, 0.23927958f, -0.10550195f, 0.55745453f, -0.16694103f, 
    -0.38993233f, 0.15509647f, 0.20474370f, -0.05467810f, 0.11213585f, -0.14537981f, 0.12976661f, -0.13149132f, 
    -0.07144265f, -0.30369914f, 0.42768732f, -0.06069326f, 0.33158040f, 0.29324412f, -0.41947722f, 0.18922716f, 
    0.09631366f, 0.22041331f, -0.07424593f, -0.31671754f, 0.25065020f, 0.11744756f, 0.23944931f, -0.40367365f, 
    0.30485550f, 0.19559172f, -0.25825694f, -0.02100802f, -0.03366569f, -0.17949538f, -0.42841801f, -0.01410921f, 
    -0.18999222f, -0.04449760f, -0.22696808f, 0.04873599f, -0.04339113f, -0.22876674f, -0.05485547f, 0.17468224f, 
    0.00849145f, 0.13809936f, -0.10184179f, 0.27140021f, 0.31226337f, 0.33035862f, 0.43001696f, -0.13752677f, 
    -0.17037372f, -0.12688248f, 0.11564631f, -0.40663651f, -0.15821654f, -0.11386783f, -0.10931130f, 0.05546445f, 
    0.11853838f, -0.14422904f, 0.03230051f, -0.18232223f, 0.32775721f, 0.37326619f, 0.47692087f, 0.04433201f, 
    -0.25146618f, 0.20749716f, 0.30128208f, -0.28441876f, 0.35368785f, 0.10614920f, -0.15809846f, 0.14462741f, 
    0.17045905f, -0.16357107f, -0.19881576f, -0.06111678f, 0.15841775f, -0.35777900f, -0.18786484f, 0.09697878f, 
    -0.11592446f, 0.17537691f, 0.23470144f, 0.27303946f, 0.30341941f, 0.15669091f, 0.18897906f, 0.07569823f, 
    -0.16716376f, -0.21343602f, 0.14554714f, -0.18120116f, -0.16976340f, -0.22221224f, -0.16971770f, -0.00897856f, 
    0.14390767f, 0.04896577f, -0.20707485f, 0.10436461f, -0.34636092f, 0.05220423f, -0.20751491f, 0.28323412f, 
    0.32517081f, 0.11201784f, -0.34024939f, 0.17843443f, -0.12458055f, 0.00159490f, 0.53457046f, 0.18287693f, 
    0.26062950f, -0.03953017f, -0.11526677f, 0.29782367f, 0.68275326f, -0.09795010f, -0.25130236f, 0.21595736f, 
    -0.00583575f, 0.14682478f, 0.24845633f, -0.15353248f, -0.20385945f, 0.15848854f, -0.33410147f, -0.09491700f, 
    0.07258193f, 0.20881106f, -0.11680157f, 0.23470032f, 0.54276013f, -0.17950213f, 0.15030982f, -0.00215870f, 
    0.11771060f, 0.20144789f, -0.01327419f, -0.24851279f, 0.02374773f, 0.08688941f, -0.43514118f, 0.14757261f, 
    -0.11972497f, 0.19016168f, -0.32510802f, 0.23422620f, 0.14812075f, 0.20392990f, -0.03955590f, -0.17659222f, 
    -0.06084997f, 0.02263164f, 0.40908974f, 0.19098569f, 0.14182770f, 0.29263332f, -0.05955110f, -0.24351996f, 
    -0.14458443f, -0.00822703f, -0.17608698f, 0.19906361f, -0.11415631f, 0.06552969f, 0.49164575f, 0.09017024f, 
    -0.25943384f, 0.10307407f, 0.13794337f, 0.11207344f, 0.20704067f, -0.24501006f, 0.64479089f, 0.12952104f, 
    -0.17029241f, 0.00256693f, -0.29497302f, 0.26518777f, -0.03912592f, 0.08201102f, 0.13527663f, -0.27930853f, 
    -0.10967827f, -0.07949180f, -0.01356711f, 0.29643309f, 0.30151057f, 0.25309274f, 0.02813462f, -0.16018623f, 
    -0.13894679f, -0.06906618f, -0.09215561f, -0.05238983f, 0.47540033f, 0.21192475f, 0.30324587f, 0.19893385f, 
    -0.29950190f, -0.24618894f, 0.29923329f, 0.15024495f, 0.16977736f, 0.16089338f, -0.30007339f, 0.10201586f, 
    0.02542934f, 0.11162671f, -0.26082489f, 0.25180036f, 0.34247300f, -0.14997062f, -0.04010973f, 0.00767964f, 
    0.08979622f, -0.09928167f, 0.21091366f, -0.22371820f, 0.39067167f, 0.21059936f, -0.40270895f, -0.12859325f, 
    0.08134022f, -0.24262635f, -0.27399954f, -0.04917812f, -0.27344403f, -0.05617550f, 0.24011479f, -0.38167438f, 
    0.30768606f, 0.28250965f, 0.11319597f, 0.31247678f, 0.12783498f, 0.42533365f, -0.14493273f, -0.28081533f, 
    -0.15477562f, -0.11375549f, -0.07278836f, -0.16345666f, 0.62978357f, 0.29339340f, 0.23057660f, 0.22228175f, 
    0.07551716f, -0.03122326f, 0.14747711f, -0.14594147f, 0.22296934f, -0.35349095f, -0.16289599f, 0.20724818f, 
    0.31855005f, -0.04224575f, 0.17165276f, -0.43147767f, -0.01950171f, -0.15400481f, 0.25228533f, 0.12182574f, 
    -0.26592276f, -0.07148421f, 0.18147844f, -0.13871442f, 0.37156796f, -0.08718716f, -0.38861889f, -0.03309203f, 
    -0.12776618f, 0.13317107f, 0.08122817f, -0.10950251f, -0.23906898f, -0.21606591f, -0.08451211f, -0.16449212f, 
    -0.13292950f, 0.19988950f, -0.08799011f, -0.18176797f, 0.18988243f, -0.22210601f, -0.05184998f, 0.03402653f, 
    -0.20976503f, 0.22780769f, -0.19390193f, 0.14341979f, 0.09680312f, -0.19482824f, 0.15306126f, 0.33278212f, 
    0.04839922f, -0.11235634f, -0.37391129f, 0.30497941f, 0.02043091f, 0.26026991f, -0.00244392f, -0.09716716f, 
    -0.07821924f, -0.43677956f, 0.04009430f, -0.24042499f, 0.22136939f, 0.23100248f, 0.12101305f, 0.25709417f, 
    -0.18434323f, 0.12677044f, 0.14664775f, -0.01430764f, 0.40485477f, -0.29530996f, -0.14913556f, 0.20091048f, 
    -0.51775885f, 0.09550075f, 0.38912621f, -0.04530165f, 0.05322516f, 0.08075594f, 0.03835791f, -0.19291194f, 
    -0.18628764f, -0.20018344f, 0.14913198f, -0.08062008f, 0.34038761f, -0.12900472f, 0.13318527f, 0.22503951f, 
    0.00542448f, 0.15076192f, 0.11093847f, 0.59777009f, -0.21448402f, -0.01121253f, -0.10474458f, -0.03275621f, 
    -0.06917898f, -0.16795678f, 0.07225715f, 0.08467682f, 0.06447765f, -0.02345447f, -0.00976308f, 0.20451298f, 
    -0.18064055f, 0.01286740f, -0.02295865f, -0.13926356f, -0.29525059f, 0.37198389f, -0.00186849f, 0.02272908f, 
    0.35619047f, -0.12279764f, -0.15526602f, -0.16309796f, 0.02044055f, -0.14123467f, -0.23467110f, -0.25732505f, 
    0.12978187f, 0.40083197f, -0.04930155f, 0.39087781f, -0.48822302f, 0.19373599f, -0.22527632f, 0.09208450f, 
    0.07063168f, 0.09126712f, -0.40784660f, -0.09239563f, 0.02214805f, 0.02423721f, 0.14183761f, 0.19960926f, 
    0.14011320f, -0.28362277f, -0.09906004f, -0.50250000f, 0.11218043f, 0.10069237f, 0.10217751f, 0.19156991f, 
    0.16158947f, 0.00625694f, -0.30089504f, 0.11157229f, 0.40248939f, 0.11682002f, 0.45786169f, 0.05869112f, 
    -0.08107978f, -0.08705425f, -0.33146721f, -0.00523928f, -0.08741253f, -0.18030120f, 0.16494888f, 0.03624314f, 
    0.01581814f, 0.25654784f, 0.05184315f, 0.14319156f, 0.27834505f, 0.39373824f, -0.07767563f, 0.03574957f, 
    -0.06538575f, 0.14135127f, 0.10518380f, -0.14183414f, 0.14579827f, 0.19255976f, 0.05601303f, 0.23151164f, 
    0.07605824f, -0.03314980f, 0.03437802f, -0.16537449f, -0.13127260f, -0.36616543f, 0.34571433f, -0.05398044f, 
    -0.09725226f, -0.14794537f, 0.20104407f, -0.16472006f, -0.64236659f, -0.10328818f, -0.13443023f, -0.24497579f, 
    0.14393878f, 0.24389084f, 0.11946363f, 0.32615468f, -0.05015478f, 0.03788837f, -0.03783970f, 0.06697138f, 
    0.30245993f, -0.22338971f, 0.04673976f, 0.19183639f, 0.03892561f, -0.59535098f, -0.34405535f, 0.29429874f, 
    -0.70943934f, -0.20222504f, 0.03571229f, 0.09454715f, 0.04004349f, -0.09158446f, 0.18128243f, 0.11950687f, 
    0.11578374f, 0.13016562f, -0.09459291f, -0.08836195f, 0.09794964f, 0.07616925f, -0.23925410f, -0.33019829f, 
    0.48326483f, -0.10628633f, -0.14982449f, 0.23154949f, -0.19391167f, 0.24070318f, 0.07892811f, 0.17390282f, 
    -0.25764105f, 0.04889219f, 0.34772840f, 0.43794131f, 0.21622546f, 0.29554683f, -0.16641006f, -0.05802030f, 
    -0.26344371f, -0.10307509f, -0.15669432f, -0.11754675f, -0.01461063f, 0.11115942f, -0.01817078f, -0.18409847f, 
    -0.25026119f, 0.12094785f, 0.20513245f, 0.20264088f, 0.11380789f, -0.10158260f, 0.22992723f, -0.26972869f, 
    -0.29932198f, 0.26672488f, 0.23472713f, 0.17681742f, 0.20669456f, 0.03182395f, 0.41667897f, -0.02694977f, 
    0.19743629f, 0.12212214f, 0.26408842f, -0.16696435f, 0.55271327f, -0.17012733f, -0.17814207f, 0.20765816f, 
    0.43958700f, -0.39467782f, 0.26428989f, -0.26152292f, -0.18408437f, 0.08997569f, -0.20825142f, -0.17716883f, 
    -0.24371357f, -0.01859735f, -0.05642288f, -0.03342060f, 0.08756793f, -0.16804188f, 0.14995512f, -0.02996675f, 
    -0.20487650f, 0.16394112f, 0.13603698f, 0.32013279f, 0.30119821f, 0.43399763f, 0.58805579f, -0.04992240f, 
    -0.14103492f, -0.40379524f, -0.15018402f, 0.00692104f, 0.13978887f, 0.02107447f, 0.08447199f, 0.03331466f, 
    -0.11349108f, 0.05348457f, 0.44105908f, -0.05791833f, 0.33872399f, 0.36149597f, -0.45179021f, 0.24293891f, 
    0.02066657f, -0.52309442f, -0.12617677f, -0.11411603f, 0.08107302f, -0.18368819f, -0.02849038f, 0.17154858f, 
    0.11109380f, 0.14873655f, 0.17168538f, -0.05057241f, 0.09162307f, -0.03190537f, 0.65033340f, -0.12757227f, 
    -0.08541517f, 0.15855798f, 0.32765612f, 0.10235747f, -0.01025944f, 0.18840525f, -0.12935691f, 0.20001096f, 
    -0.22772537f, -0.39216998f, 0.13024408f, 0.12560205f, 0.12219119f, -0.30185279f, 0.45628899f, -0.03399297f, 
    -0.38081670f, 0.18240619f, 0.17045315f, 0.12671743f, -0.01526435f, 0.02790895f, 0.21836798f, -0.07999192f, 
    -0.36288217f, -0.03933016f, -0.20001970f, 0.33577764f, -0.30927265f, 0.23825194f, 0.17641897f, -0.19193524f, 
    -0.40996394f, -0.29366815f, 0.03607064f, -0.02597283f, -0.23251556f, -0.04844159f, 0.26130301f, 0.07333188f, 
    0.18479733f, 0.00439369f, 0.27055067f, -0.02948172f, 0.27722609f, 0.32194933f, 0.86010104f, -0.22204854f, 
    0.25334638f, -0.18168375f, -0.18001820f, 0.09475185f, -0.31178039f, -0.39324561f, -0.30649978f, 0.02545621f, 
    -0.61750579f, 0.00525014f, 0.18004355f, -0.24286206f, -0.01904009f, 0.24940507f, 0.07003630f, 0.02930117f, 
    0.05427714f, 0.23871961f, 0.09281813f, 0.00600463f, 0.25984100f, 0.04943584f, 0.35400259f, -0.29487124f, 
    0.19755708f, -0.21375357f, -0.02464929f, -0.04714512f, -0.13901873f, -0.24389620f, -0.27345657f, -0.02512919f, 
    -0.10723320f, -0.04812610f, 0.07764982f, 0.38817251f, 0.57225823f, -0.18081039f, 0.24462244f, -0.18431735f, 
    0.09903928f, 0.14859396f, 0.21495903f, -0.03808945f, -0.21803658f, 0.14930566f, -0.26869392f, -0.04012140f, 
    -0.13550821f, 0.02921188f, -0.22788295f, 0.04345313f, 0.08642367f, -0.22259438f, 0.17519358f, 0.05343407f, 
    -0.16980642f, -0.22518772f, -0.18933228f, -0.20140412f, -0.19488302f, -0.08507931f, -0.17403439f, -0.06638256f, 
    -0.27652603f, 0.15771545f, -0.29381621f, 0.03995270f, -0.08488388f, 0.13083664f, 0.27408379f, 0.00550575f, 
    0.08434971f, -0.11491585f, 0.10297161f, 0.12188319f, 0.34154901f, 0.15586630f, -0.29164869f, -0.06596018f, 
    0.04182821f, -0.12452471f, 0.17237611f, -0.16742077f, 0.16014922f, -0.27286404f, -0.20353508f, -0.24396348f, 
    -0.27286306f, 0.10043132f, -0.13503504f, -0.14387372f, -0.11657118f, 0.02895431f, 0.08184504f, -0.21222326f, 
    0.31471381f, -0.05969299f, -0.12088584f, -0.35818806f, -0.55707341f, 0.05078351f, -0.20611677f, 0.19330640f, 
    0.16828783f, 0.03433696f, -0.40292206f, 0.10750183f, 0.30092692f, -0.09082874f, 0.32654548f, -0.22951540f, 
    0.02518680f, 0.07771507f, 0.01447988f, -0.25494555f, 0.27394786f, 0.24619928f, 0.11447978f, -0.15678194f, 
    0.15853278f, -0.10703600f, 0.36118633f, -0.04304302f, -0.02857374f, 0.10745128f, 0.18290614f, -0.00645304f, 
    -0.27109727f, -0.09504431f, -0.00156623f, 0.43544951f, -0.02197228f, -0.29471615f, 0.35031530f, 0.09538788f, 
    -0.06172512f, -0.04069901f, -0.04728670f, 0.32861122f, 0.41470799f, 0.40147689f, 0.53275132f, 0.03010866f, 
    -0.40335056f, 0.20387658f, -0.14950351f, 0.12059940f, -0.11018596f, 0.03042872f, 0.02512201f, -0.23927730f, 
    -0.24085920f, 0.29483035f, -0.38985494f, 0.07593642f, 0.37525550f, 0.14098202f, -0.06142708f, 0.25333637f, 
    0.29502735f, 0.14386208f, -0.24044989f, 0.00378370f, 0.07635425f, 0.12304223f, 0.28644958f, -0.05139821f, 
    0.08916705f, 0.25341254f, 0.19208783f, -0.20881398f, -0.26648232f, 0.04645078f, -0.68948865f, -0.04510066f, 
    0.12665516f, 0.16808647f, -0.36768249f, 0.13429438f, 0.37114874f, 0.16711442f, 0.10177521f, 0.05452725f, 
    -0.31074491f, 0.15728316f, 0.25982311f, 0.11293405f, 0.06928987f, 0.14043650f, -0.13094145f, -0.18896064f, 
    0.26763144f, -0.46344969f, -0.27967414f, 0.34191746f, -0.34240845f, 0.13269818f, 0.21459031f, 0.01292003f, 
    0.27234712f, 0.09590039f, 0.17072429f, 0.24045557f, -0.01293756f, -0.02143415f, -0.10794511f, 0.05563473f, 
    0.13578546f, -0.14787672f, -0.11572630f, 0.03664981f, 0.15318850f, 0.08078969f, -0.00013016f, 0.07532779f, 
    -0.23544468f, -0.12612835f, 0.10053715f, -0.20641595f, -0.08423205f, -0.21185134f, -0.00957737f, 0.09680274f, 
    -0.29729378f, 0.44551826f, -0.24998190f, 0.41611138f, -0.09868880f, 0.25430635f, -0.02721027f, -0.00546272f, 
    0.25015977f, -0.05011412f, -0.24930315f, -0.12319620f, -0.15916070f, 0.29603976f, 0.26833579f, -0.13821982f, 
    0.07973844f, -0.04724078f, 0.24762224f, -0.56831121f, -0.27079740f, -0.10134415f, -0.22412296f, 0.08156816f, 
    -0.05082383f, 0.13831699f, 0.21687904f, -0.27045584f, 0.22767910f, 0.31402934f, -0.22469221f, 0.21211250f, 
    -0.16363938f, 0.26849064f, 0.07551064f, -0.73710167f, -0.25901660f, -0.00317986f, -0.01881357f, 0.42374408f, 
    0.03108543f, -0.11842932f, -0.43945086f, 0.06882961f, 0.48889586f, -0.31152689f, 0.08095364f, 0.01729867f, 
    -0.42017269f, 0.12762693f, 0.22139186f, 0.32176924f, -0.46177706f, 0.23969173f, 0.34810171f, 0.06842323f, 
    0.06198876f, 0.08322680f, 0.04149913f, -0.01158807f, 0.18028758f, -0.20862867f, 0.91013968f, -0.17338525f, 
    0.27406612f, 0.06132134f, 0.19527085f, -0.37951142f, -0.12066164f, 0.19360319f, -0.15779394f, 0.07554274f, 
    0.21707681f, 0.10510723f, 0.00485825f, -0.35214296f, 0.04973321f, -0.02157610f, 0.02588397f, -0.17323869f, 
    -0.02181006f, -0.06271426f, 0.14210047f, -0.38578770f, -0.37914762f, -0.02978974f, 0.40658629f, -0.19912313f, 
    -0.03679404f, 0.25970539f, -0.37285677f, 0.34291422f, -0.14210223f, -0.22298589f, -0.25455180f, -0.20467971f, 
    -0.14546330f, -0.07234007f, 0.14148356f, -0.11099121f, -0.13919204f, -0.03293547f, -0.26105392f, 0.31408912f, 
    0.19709881f, -0.07667024f, -0.17355391f, 0.24498571f, 0.22692060f, -0.12602980f, 0.62580657f, 0.15103270f, 
    -0.20776537f, -0.16205341f, 0.19774449f, 0.25771055f, 0.42969581f, 0.23946930f, -0.17859544f, 0.23712234f, 
    0.37996617f, -0.21892315f, 0.23163202f, -0.25936332f, 0.09509844f, -0.35513878f, 0.07169534f, -0.00558051f, 
    -0.12264755f, -0.06720501f, -0.14142323f, 0.06174433f, 0.10324648f, -0.07467955f, -0.05174877f, 0.07164422f, 
    0.05239343f, -0.06502334f, -0.14110610f, 0.06867850f, -0.14081344f, -0.14306837f, 0.01253140f, 0.01976246f, 
    0.03822700f, 0.18094231f, 0.05180790f, -0.42364788f, -0.20050941f, -0.03103209f, -0.26444802f, -0.03917709f, 
    0.27071825f, 0.25662309f, -0.14638826f, 0.26365122f, -0.18660834f, -0.15939137f, 0.45684329f, -0.02946794f, 
    0.16490570f, -0.30605090f, 0.13798970f, -0.02429373f, 0.05348574f, 0.19251055f, 0.33366621f, 0.14918050f, 
    -0.32160985f, 0.06224089f, 0.18655723f, -0.07104875f, 0.06195995f, -0.33424693f, -0.20556274f, -0.19153070f, 
    -0.14999111f, 0.07675811f, 0.17913565f, -0.12098414f, -0.21010776f, -0.25704193f, 0.28151590f, -0.21700554f, 
    -0.04843447f, -0.01274088f, -0.09462363f, 0.04415696f, 0.33749050f, 0.25598401f, 0.16516785f, -0.08440201f, 
    -0.17853844f, -0.26618439f, -0.09676489f, -0.21636845f, -0.33935636f, -0.34157777f, -0.20003533f, 0.13770306f, 
    0.25375623f, 0.40454543f, -0.01885499f, 0.16588396f, 0.34461302f, 0.00566355f, -0.02052084f, 0.21198972f, 
    -0.25891161f, -0.17505167f, 0.10814331f, -0.63552845f, 0.52975595f, -0.26268712f, 0.05155918f, -0.21009539f, 
    0.32061118f, 0.08009750f, -0.13739453f, 0.12468490f, 0.24642819f, 0.00318294f, 0.06473473f, 0.02656575f, 
    0.23430863f, -0.35444576f, 0.21044029f, 0.03981407f, -0.14799060f, 0.30257231f, -0.33841607f, -0.44828683f, 
    0.37622184f, 0.00601629f, 0.10427586f, 0.29462674f, -0.04912064f, -0.33445644f, -0.41644898f, -0.03536746f, 
    0.09844247f, -0.23616515f, -0.19813272f, 0.37944615f, -0.44252956f, 0.36988279f, 0.26332656f, -0.40287247f, 
    -0.09957347f, 0.36851507f, 0.20205915f, 0.00650938f, -0.04059136f, -0.34524161f, -0.31214175f, -0.03909184f, 
    -0.13525064f, 0.13736705f, 0.17561452f, 0.20945857f, -0.49167415f, 0.02782630f, 0.48777479f, 0.04351702f, 
    -0.24792235f, 0.36310077f, -0.31691185f, -0.07847583f, -0.07751250f, -0.17115982f, 0.37006977f, 0.04469630f, 
    -0.06207697f, 0.30984834f, 0.22404499f, 0.07544655f, 0.02763027f, 0.24785562f, -0.16538820f, -0.42153299f, 
    0.24362279f, 0.26762399f, -0.29545617f, -0.16282828f, -0.37102792f, 0.12073877f, -0.14687477f, 0.15269648f, 
    -0.38689584f, 0.00372255f, 0.03241675f, -0.40223384f, 0.43203542f, -0.19658798f, 0.38817438f, -0.22485261f, 
    0.04114537f, 0.41245049f, 0.03448698f, -0.17315240f, 0.12073053f, -0.19133769f, 0.49675101f, -0.00929017f, 
    0.08978140f, 0.27842164f, -0.27479771f, -0.12182896f, 0.08974081f, -0.26912558f, -0.28986013f, 0.06694100f, 
    0.29149464f, -0.02293987f, 0.03795413f, 0.24900940f, 0.18452363f, 0.02774248f, 0.37020296f, -0.14155747f, 
    0.21207502f, -0.22165519f, -0.23967591f, 0.20054875f, 0.29300672f, -0.12551641f, -0.27098686f, 0.34097007f, 
    0.31213868f, -0.23705636f, 0.15642078f, -0.03727418f, 0.03175398f, 0.15430875f, 0.45586208f, -0.05969203f, 
    -0.27503654f, -0.16797243f, 0.21713702f, -0.47556069f, -0.21516421f, 0.07518329f, 0.02190455f, 0.10590811f, 
    0.13576518f, 0.09179189f, -0.30389842f, 0.22741929f, -0.17312931f, -0.00564531f, -0.05048710f, 0.20729560f, 
    0.21923080f, -0.08057499f, -0.12845904f, -0.01226211f, 0.05759245f, -0.03048575f, 0.11414465f, -0.05473450f, 
    -0.06698415f, -0.17243370f, -0.18369165f, -0.16599339f, -0.13294286f, -0.11947581f, -0.00649562f, -0.06360438f, 
    -0.24011475f, 0.09468223f, 0.21421106f, 0.05051023f, 0.05924686f, -0.16543417f, -0.34845734f, -0.20540930f, 
    -0.10604513f, 0.12815179f, -0.09577410f, 0.14673501f, 0.37713167f, 0.21258710f, -0.15271279f, -0.00206116f, 
    0.17804387f, -0.11101894f, -0.14189185f, -0.04252625f, 0.01213133f, 0.18142660f, -0.25706369f, 0.31566989f, 
    0.25338832f, -0.03852585f, -0.13784793f, -0.09841276f, -0.08697798f, 0.07743834f, 0.54421526f, -0.22831540f, 
    -0.08222261f, -0.10190380f, 0.08854800f, -0.05938834f, -0.20507738f, -0.10807565f, -0.19788530f, -0.12265152f, 
    -0.22479478f, 0.03241175f, -0.15928280f, 0.01403800f, 0.03640023f, -0.09706178f, -0.05950433f, -0.06296474f, 
    0.05983167f, -0.00092620f, -0.03962511f, 0.36403531f, 0.39995217f, 0.26716769f, -0.15790761f, -0.29947150f, 
    0.20262359f, -0.21983549f, 0.30894846f, -0.09414046f, -0.07969892f, -0.03635905f, 0.19504546f, -0.16693775f, 
    -0.32168275f, -0.28004068f, -0.06481154f, -0.23433699f, -0.19533126f, 0.03677417f, 0.28583887f, -0.04511928f, 
    -0.27651316f, -0.03418832f, -0.27336887f, 0.31119061f, 0.39961082f, 0.34909686f, 0.11298524f, 0.21170799f, 
    0.24081066f, -0.33361170f, 0.24666941f, 0.31414500f, 0.46486443f, 0.13351786f, 0.16325736f, -0.21578312f, 
    0.34513646f, -0.20282409f, 0.21329692f, -0.07772696f, -0.06571869f, -0.35997733f, 0.00178213f, -0.22460696f, 
    -0.36923352f, 0.20584753f, 0.20324023f, -0.07017795f, -0.07750655f, 0.18004647f, 0.20290579f, -0.11190131f, 
    0.18635727f, -0.11212429f, 0.19093573f, -0.05530070f, -0.28032258f, -0.27246785f, -0.11228883f, -0.19533555f, 
    0.31992039f, -0.17711930f, 0.31089455f, -0.01365597f, -0.03351673f, 0.15184228f, -0.16071194f, 0.10555078f, 
    0.27137348f, 0.15548383f, 0.35692152f, -0.15049364f, -0.44303858f, 0.10172050f, -0.75568032f, -0.00532331f, 
    -0.35198686f, 0.49195555f, 0.05625876f, 0.24034260f, -0.34397164f, -0.06777284f, 0.05404967f, -0.11384929f, 
    0.06702647f, 0.10185563f, -0.33412692f, 0.25798979f, 0.03697831f, -0.08106758f, 0.03797664f, 0.06831323f, 
    -0.04914961f, 0.40285340f, -0.01907308f, -0.09396582f, -0.03816049f, -0.21643540f, 0.15549327f, -0.21118334f, 
    -0.00209351f, -0.26963907f, -0.08648390f, 0.22006972f, 0.20850763f, 0.13128130f, 0.40906203f, -0.07098633f, 
    0.26354787f, 0.03711485f, 0.32817426f, -0.11564853f, 0.49984816f, -0.07241760f, -0.22215007f, -0.23624879f, 
    0.14343356f, -0.03550474f, 0.08781122f, -0.02648298f, -0.32874176f, 0.12867980f, -0.17752200f, -0.23104413f, 
    -0.49555987f, 0.46324983f, -0.03658009f, -0.42455983f, 0.26352277f, -0.24217364f, 0.32796183f, -0.27896884f, 
    0.04009314f, 0.24536130f, -0.24264500f, 0.01959363f, -0.13290192f, -0.01304485f, 0.65995044f, -0.00450807f, 
    -0.11794572f, 0.23789538f, -0.08598667f, -0.25008830f, 0.38460347f, -0.04747126f, -0.19402860f, -0.29462263f, 
    -0.02818466f, -0.13697527f, 0.04874565f, 0.35519835f, 0.22239314f, 0.25876182f, -0.23083262f, -0.03954026f, 
    -0.02174642f, 0.07692929f, -0.02218852f, -0.16080070f, 0.32800138f, 0.30081263f, 0.07074549f, -0.08038014f, 
    0.38076320f, -0.18080173f, 0.33912149f, -0.22361998f, 0.18926100f, -0.21729203f, 0.03724667f, 0.11548121f, 
    -0.04035140f, 0.03652047f, -0.24172270f, 0.48632592f, -0.06786539f, -0.07043508f, -0.21622084f, 0.06774179f, 
    0.32629648f, -0.10396272f, 0.36417595f, 0.16221631f, 0.04844906f, 0.33111987f, 0.00145426f, -0.05030188f, 
    -0.22066869f, 0.20129724f, 0.29858586f, -0.33890095f, -0.11858360f, 0.11537701f, 0.48603779f, -0.02184427f, 
    -0.28187740f, 0.10026967f, 0.01786298f, -0.28438744f, 0.27526638f, 0.05161476f, -0.18148424f, 0.03098675f, 
    -0.27187243f, -0.35291585f, -0.26283693f, -0.38441512f, -0.34801784f, 0.15572336f, -0.12315930f, 0.08195031f, 
    0.36991277f, 0.32186887f, -0.19937581f, 0.16836642f, 0.10832250f, -0.41990152f, -0.26376209f, 0.18232496f, 
    -0.22269939f, -0.07917752f, -0.09941020f, 0.41035193f, 0.19932625f, -0.05376012f, 0.05535451f, 0.17952654f, 
    -0.22870965f, -0.13413580f, 0.17061754f, 0.18865411f, 0.28495705f, 0.05466424f, 0.00828863f, 0.10111246f, 
    -0.06435633f, 0.23920143f, -0.18067193f, -0.19110501f, 0.10565317f, -0.17399707f, -0.24744692f, -0.15517840f, 
    -0.15835550f, -0.05752280f, -0.05628452f, 0.01600954f, -0.13213086f, -0.24930936f, -0.19948673f, 0.11103821f, 
    -0.46451747f, 0.33171034f, 0.13759288f, -0.03349023f, -0.30378142f, -0.14855748f, -0.17708792f, 0.14459844f, 
    0.07244486f, -0.43041527f, -0.05405714f, 0.09623314f, 0.28856313f, 0.27727577f, 0.12244174f, 0.00950270f, 
    0.31344670f, 0.25218585f, 0.07827195f, -0.39555043f, -0.51410282f, 0.00478479f, -0.17562941f, 0.25722393f, 
    -0.00014296f, 0.09718007f, -0.28620684f, -0.12435084f, 0.24556816f, 0.23626161f, -0.26662368f, -0.19545364f, 
    -0.49206540f, 0.41769269f, -0.28388679f, 0.14557706f, 0.03025675f, -0.13420899f, 0.25507632f, -0.18454297f, 
    0.06139546f, 0.12772390f, -0.52350032f, 0.18851896f, 0.14714980f, 0.35659927f, 0.07177780f, -0.16566034f, 
    0.26185167f, -0.32533437f, 0.09150013f, -0.39272234f, 0.25713626f, -0.00382796f, 0.19285980f, 0.22357352f, 
    0.24884376f, 0.13347037f, 0.13000163f, -0.18004286f, -0.00850475f, 0.03975125f, 0.09295150f, 0.11529552f, 
    -0.38500521f, 0.04959605f, 0.07278777f, 0.26488653f, -0.14964186f, -0.17607440f, -0.00122571f, -0.03598282f, 
    -0.27683166f, 0.20311531f, 0.07320058f, 0.30124751f, -0.12385261f, 0.31793591f, 0.08504128f, -0.01513174f, 
    -0.25593489f, 0.04133394f, -0.00916039f, -0.62860018f, 0.39631680f, 0.04377319f, -0.09225986f, -0.17852303f, 
    -0.14870627f, 0.20384018f, 0.26011023f, 0.16988170f, -0.06481478f, 0.10967559f, 0.26677448f, -0.16661641f, 
    -0.16403255f, 0.10062984f, 0.06570869f, 0.16153890f, 0.20969602f, 0.18921545f, 0.09146769f, -0.36484393f, 
    -0.23014548f, 0.19323418f, -0.20465511f, 0.09948914f, -0.09954210f, 0.33528122f, -0.30764273f, 0.15318665f, 
    0.18508263f, -0.15631019f, -0.10310487f, -0.41613778f, -0.10429941f, 0.12869464f, -0.20211728f, -0.29189590f, 
    0.24612585f, -0.01365157f, -0.46413040f, -0.08354552f, 0.25273445f, -0.17322734f, 0.43196458f, 0.03241284f, 
    -0.17310612f, 0.15634671f, -0.18823268f, -0.13153224f, -0.15399265f, 0.16836558f, -0.20194194f, -0.12840301f, 
    -0.21116059f, 0.18577418f, -0.19638866f, -0.26067063f, -0.14851111f, -0.26096150f, -0.24420092f, 0.06757450f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.16838782f, -0.07689770f, 0.42740586f, -0.30625659f, 0.14766325f, 0.00772587f, -0.20245141f, 0.20950919f, 
    -0.04334021f, 0.20079106f, 0.06983420f, -0.00680396f, 0.30690679f, 0.05512559f, -0.03354570f, 0.43197858f, 
    0.04795038f, 0.05568653f, 0.32156080f, -0.26380417f, -0.16755943f, 0.38835540f, -0.20331834f, 0.02712063f, 
    0.42445537f, 0.02704420f, 0.24671841f, 0.10439409f, 0.35877138f, 0.35783187f, -0.15172359f, -0.09232426f, 
    -0.17003328f, -0.32298949f, -0.08920243f, 0.02249155f, 0.24484996f, 0.20815395f, -0.02376657f, 0.33424973f, 
    -0.19559105f, -0.24273349f, 0.20576878f, 0.24244656f, 0.43925059f, -0.28558391f, -0.24250776f, -0.04196298f, 
    0.02837345f, 0.27719131f, -0.21269843f, 0.27051315f, 0.60817581f, 0.40135068f, 0.29753110f, -0.04674057f, 
    0.24010257f, 0.12252744f, 0.17541158f, -0.33889693f, -0.02860953f, 0.14426829f, 0.07464032f, 0.34825900f, 
    0.47962874f, 0.07076553f, -0.14884591f, 0.24372585f, -0.09444005f, 0.23501870f, -0.45695335f, -0.04604356f, 
    0.36771503f, 0.00854824f, -0.46207908f, -0.33898723f, 0.22637621f, 0.40482795f, -0.05217860f, -0.10319759f, 
    0.03143003f, -0.36946630f, 0.33680025f, -0.27397844f, 0.19121401f, -0.08059251f, -0.25063595f, 0.30242601f, 
    0.03267506f, 0.22764392f, 0.22625230f, -0.09659576f, 0.34189865f, 0.28303748f, 0.18927024f, 0.25957134f, 
    -0.25880632f, 0.23432222f, 0.03423666f, -0.24220964f, 0.09726799f, -0.07591604f, 0.03776231f, 0.23052126f, 
    0.28018135f, 0.30331445f, 0.27312577f, -0.31809646f, 0.12901427f, 0.36682472f, -0.20250829f, 0.14604001f, 
    0.55622029f, 0.25391120f, -0.09230045f, 0.20271382f, -0.15240994f, 0.29914001f, 0.09274864f, 0.12666605f, 
    -0.16637953f, 0.10460009f, -0.41012952f, 0.36395371f, 0.37506837f, -0.19470130f, 0.15754671f, 0.08064844f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09015145f, 0.04022841f, 0.47042105f, 0.00247544f, 0.08844731f, 0.00831370f, -0.03593265f, 0.12285603f, 
    -0.04345559f, 0.09650294f, 0.06030628f, -0.22496392f, -0.27665353f, -0.09715886f, 0.13565974f, 0.22776392f, 
    -0.14979354f, -0.03169825f, 0.06528362f, -0.00620076f, -0.06717338f, 0.05817685f, -0.09589846f, -0.04992435f, 
    -0.07966980f, 0.01511668f, 0.17506133f, 0.21878810f, -0.17895749f, 0.03116076f, 0.12109979f, 0.07907443f, 
    0.07957239f, -0.00559849f, 0.06038884f, -0.06287482f, -0.02039596f, 0.07198457f, 0.21350847f, -0.01832503f, 
    -0.08021250f, 0.11989048f, 0.16523787f, -0.21398959f, -0.06775706f, -0.02228313f, -0.02768341f, 0.17283694f, 
    -0.02932251f, 0.20159529f, -0.05703700f, -0.03352236f, 0.21726350f, 0.06766573f, 0.07843332f, 0.05165251f, 
    -0.11055168f, 0.09395514f, -0.25372931f, 0.19020036f, -0.20448124f, 0.15488516f, -0.04996531f, 0.31822750f, 
    0.10214821f, 0.07525779f, 0.08079746f, 0.19395687f, 0.08487196f, -0.16533418f, 0.05538313f, 0.21081167f, 
    0.30942380f, 0.07932208f, 0.08915976f, -0.13024510f, 0.03113069f, 0.40876722f, 0.04691245f, -0.00111810f, 
    0.06668991f, -0.03866659f, 0.01304570f, -0.10699059f, -0.16135532f, -0.07693356f, 0.04519976f, -0.09503797f, 
    0.10589585f, -0.02781626f, -0.00274614f, -0.41417354f, -0.27845693f, 0.26008412f, 0.27195302f, 0.15492660f, 
    -0.05078675f, 0.03852041f, -0.04589674f, 0.08529556f, 0.05203200f, 0.06875945f, 0.08307359f, -0.07755568f, 
    0.08612962f, -0.31697288f, -0.02769837f, -0.01279362f, 0.21250859f, 0.01372631f, -0.03555031f, 0.33672270f, 
    0.13786021f, -0.08104617f, -0.06272601f, 0.05952078f, -0.35207197f, 0.01588181f, -0.05173200f, -0.00517221f, 
    0.10030424f, 0.71708900f, -0.00725995f, 0.12763192f, 0.06275953f, 0.34699211f, 0.14727706f, 0.03566645f, 
    0.34461609f, -0.08367291f, -0.24081427f, -0.07264539f, -0.00810269f, 0.15570411f, -0.04823285f, 0.01427444f, 
    0.09077463f, -0.27908373f, -0.28966764f, 0.12478821f, 0.19104120f, -0.22933476f, 0.08753178f, -0.32296169f, 
    -0.08932202f, 0.01888198f, 0.06824321f, 0.08734468f, -0.00464935f, -0.25069791f, 0.01293386f, 0.16760299f, 
    -0.42767149f, 0.03156215f, 0.10964497f, 0.32353777f, 0.01212321f, -0.37460700f, 0.37343869f, -0.20562331f, 
    -0.24765505f, -0.13727294f, 0.21913871f, 0.10212820f, -0.25837243f, -0.11905719f, 0.24103965f, -0.12460277f, 
    -0.12187138f, -0.04720040f, 0.03726320f, 0.06474122f, -0.16870101f, 0.06978466f, 0.35580495f, -0.03918172f, 
    0.15792906f, 0.02741354f, 0.11221597f, 0.16416001f, -0.04822918f, -0.01958858f, -0.20164350f, -0.00503923f, 
    -0.27248800f, 0.06674960f, -0.17037109f, 0.61603105f, -0.09531064f, -0.27659777f, 0.23128310f, -0.35830846f, 
    -0.15872569f, -0.43394074f, 0.01076954f, 0.10924086f, -0.00682315f, 0.42458141f, -0.00019557f, 0.11472560f, 
    -0.05409165f, -0.32152775f, -0.18825965f, 0.28422502f, 0.08087984f, -0.04089243f, -0.05826152f, 0.21896704f, 
    0.09238058f, 0.14849007f, 0.02774471f, 0.23206270f, -0.04924481f, 0.02079429f, 0.11605242f, -0.17624632f, 
    0.12505658f, 0.24761131f, 0.09188671f, 0.25124088f, 0.11949696f, 0.06922075f, 0.04675653f, 0.05844421f, 
    0.11196196f, 0.11231676f, 0.13902238f, 0.01228384f, -0.00339968f, 0.22027904f, 0.08686019f, -0.23291798f, 
    0.12184073f, -0.11285899f, -0.08152240f, -0.30114901f, 0.13349234f, -0.10778549f, -0.41813919f, -0.14738871f, 
    -0.24121685f, -0.01071912f, 0.05976649f, -0.10200122f, 0.65354842f, -0.18444981f, -0.07362206f, -0.03138613f, 
    -0.22683451f, -0.12443429f, 0.03754121f, -0.17501144f, -0.12915201f, -0.22651383f, 0.21098047f, -0.04658047f, 
    0.14195183f, 0.02017569f, 0.34830573f, -0.21393465f, -0.19509037f, -0.15071973f, -0.02101939f, 0.04623456f, 
    0.13739049f, 0.21392202f, 0.09311085f, 0.12738898f, 0.17630441f, 0.36447278f, 0.14233439f, 0.21255402f, 
    0.28444901f, 0.23932342f, -0.05381535f, -0.18754025f, -0.03695783f, 0.10673881f, 0.03013888f, -0.02140535f, 
    0.04857501f, 0.03922268f, -0.33558020f, -0.25576675f, 0.09853309f, 0.24126557f, -0.16280776f, -0.01714410f, 
    0.12822957f, -0.12633546f, -0.10330754f, 0.07282743f, -0.06841759f, -0.21306272f, 0.07863133f, 0.05637435f, 
    -0.31570098f, 0.00376237f, -0.14695880f, -0.05978137f, 0.15133223f, 0.04601562f, 0.18889299f, -0.02143119f, 
    -0.16810632f, -0.20934811f, 0.05218993f, 0.08466731f, 0.12819397f, 0.05078485f, 0.29841089f, 0.08407296f, 
    -0.03855996f, -0.13426331f, 0.22294804f, -0.24236822f, -0.07198616f, 0.36730072f, -0.07566211f, 0.07539623f, 
    0.24477911f, 0.29298195f, 0.02800257f, -0.01126863f, -0.02546373f, -0.22618973f, 0.04735137f, -0.28332487f, 
    0.05578488f, 0.11775359f, -0.31967193f, 0.05526681f, -0.08278906f, 0.04834278f, -0.39075327f, -0.56769866f, 
    -0.03163038f, -0.10998549f, 0.24182199f, -0.15949185f, 0.15782781f, 0.07946996f, 0.01201439f, 0.20826232f, 
    0.01179854f, -0.20820194f, 0.02829110f, 0.36487040f, 0.53103834f, 0.11196021f, 0.18955602f, -0.18296643f, 
    -0.43757838f, -0.36228365f, 0.10395888f, -0.08510762f, -0.01002778f, -0.24170670f, 0.02891736f, 0.14523211f, 
    -0.03852526f, 0.13995130f, 0.24115168f, 0.14506382f, 0.07252063f, -0.15255918f, 0.14680754f, -0.08129850f, 
    0.02564539f, 0.15028383f, -0.07780436f, 0.08748978f, 0.16036105f, -0.00445453f, 0.08102039f, 0.00157387f, 
    -0.45381227f, -0.09624861f, -0.13066629f, 0.19057475f, -0.02478606f, 0.12965341f, 0.00572477f, 0.05982299f, 
    0.15110867f, -0.10382380f, 0.01230843f, 0.02411035f, 0.13640414f, -0.03421838f, -0.09671202f, -0.14002992f, 
    0.13754737f, 0.01191602f, -0.11307343f, 0.18947898f, 0.23988976f, 0.04306859f, -0.00533021f, -0.19196393f, 
    0.06776545f, 0.13644443f, -0.04960511f, 0.01348477f, -0.06177375f, -0.14694081f, -0.05684338f, 0.14505467f, 
    0.00010379f, -0.06278510f, -0.04966862f, -0.07972358f, 0.16251165f, 0.02443038f, 0.04715441f, -0.05243827f, 
    -0.09850226f, -0.02566352f, -0.00774191f, -0.00453092f, 0.00224774f, -0.04647710f, -0.00506979f, -0.01287050f, 
    -0.12739022f, -0.06989533f, -0.05949814f, -0.00348860f, 0.02992678f, 0.01143725f, 0.26902792f, 0.10295299f, 
    0.13939400f, -0.11828177f, 0.10360073f, 0.09282506f, 0.06527201f, 0.09601787f, 0.10947719f, -0.00368483f, 
    -0.15965809f, 0.02374201f, 0.07089212f, 0.23292971f, 0.00878783f, 0.09243754f, 0.14829683f, 0.19832209f, 
    -0.03192049f, -0.15804662f, 0.02406783f, -0.01431313f, 0.07523385f, 0.41269520f, 0.02286818f, 0.01213442f, 
    -0.24800631f, -0.05337090f, 0.06188666f, 0.14777242f, 0.06953824f, 0.25144416f, -0.20101079f, 0.20606470f, 
    0.15008155f, -0.07162906f, -0.21209933f, 0.10605740f, 0.17715977f, 0.04010873f, 0.04499563f, -0.16049047f, 
    -0.00121106f, -0.08631224f, -0.02663287f, 0.15595488f, 0.16120458f, 0.08755461f, -0.01071740f, -0.16132505f, 
    -0.15351567f, 0.09268336f, -0.02552360f, 0.03523112f, -0.11300075f, 0.18432562f, -0.01800406f, 0.03025291f, 
    -0.08066149f, 0.09333766f, 0.12979943f, -0.06939954f, 0.04756494f, -0.12515683f, -0.12293284f, -0.23743980f, 
    -0.15391330f, 0.14596930f, -0.00076651f, -0.01263001f, 0.33828551f, -0.06079783f, 0.00555067f, 0.11306310f, 
    -0.19777364f, -0.38622186f, -0.01653550f, 0.08661843f, 0.17196253f, 0.01501696f, 0.10762755f, -0.04537848f, 
    -0.15857577f, 0.00479784f, 0.20711681f, -0.15808921f, 0.15118003f, -0.15185459f, 0.17548065f, -0.05775793f, 
    -0.29375982f, 0.28165653f, 0.07637762f, -0.10355060f, 0.12008253f, 0.16560501f, -0.15093426f, 0.36582252f, 
    0.10294804f, 0.10231814f, -0.13115959f, -0.10088264f, 0.06761736f, 0.19804396f, -0.13479431f, 0.07220039f, 
    0.21832801f, 0.01190772f, -0.12723581f, 0.09456234f, 0.12556647f, 0.11654358f, -0.44437402f, -0.38181672f, 
    -0.11319205f, 0.01205639f, 0.13449992f, 0.15071958f, 0.01641978f, -0.02375912f, -0.13634479f, 0.08724277f, 
    -0.24247791f, -0.07720008f, 0.10026797f, 0.02203330f, 0.44894877f, -0.09049182f, -0.02002710f, -0.10293881f, 
    0.00478245f, -0.01526017f, 0.03115464f, 0.16261916f, -0.07638822f, 0.01342403f, 0.31542903f, 0.07830401f, 
    -0.02961554f, 0.07191171f, 0.35460392f, -0.36366087f, 0.06024301f, 0.26476449f, 0.12577020f, -0.27551541f, 
    0.23536013f, 0.03798634f, 0.06504607f, 0.07484958f, 0.08559959f, -0.46814904f, -0.01822874f, 0.01346638f, 
    0.19735299f, -0.28018540f, -0.10229480f, -0.33001581f, 0.08435357f, 0.14803427f, -0.24047151f, -0.03854599f, 
    0.06528717f, -0.20346573f, 0.08015559f, -0.01526538f, 0.12358867f, -0.07384782f, -0.20609555f, 0.08173966f, 
    0.12940858f, -0.15253498f, -0.02968508f, -0.06799681f, 0.04810831f, 0.04559134f, 0.02733132f, 0.09436351f, 
    -0.36178529f, -0.30658475f, 0.06548825f, 0.03115570f, 0.10893907f, -0.28721061f, -0.08742391f, 0.12116021f, 
    0.05147170f, 0.17896789f, 0.17577401f, -0.22203399f, 0.10422871f, 0.15412863f, -0.24987225f, 0.14826642f, 
    0.09076047f, 0.10747180f, -0.08526889f, 0.23250712f, -0.30171871f, 0.03587647f, 0.00929803f, 0.20574555f, 
    -0.44955167f, 0.06486269f, -0.10399349f, 0.11330952f, -0.04037044f, 0.04488136f, 0.02343956f, 0.06661797f, 
    -0.07128163f, -0.00889979f, -0.06670438f, 0.03082565f, 0.04751458f, -0.04912943f, 0.00063506f, -0.05659597f, 
    0.01248525f, 0.00642263f, -0.09769204f, -0.01048206f, -0.03994965f, -0.07559957f, 0.02992479f, -0.01787355f, 
    -0.07502770f, -0.04937064f, 0.04386648f, 0.05046656f, -0.02030390f, -0.07706901f, -0.03009250f, 0.05549818f, 
    -0.00239836f, -0.09472606f, -0.08312804f, 0.00475081f, -0.03650631f, 0.03283966f, 0.03217002f, 0.08520138f, 
    -0.08290784f, -0.01901635f, -0.05470625f, 0.05870081f, -0.07200310f, -0.00062598f, 0.07947864f, 0.03189867f, 
    -0.03617150f, 0.06706879f, 0.02827437f, 0.08298190f, -0.02604764f, -0.01864544f, 0.06630407f, -0.05087413f, 
    -0.00341448f, 0.00629188f, -0.05153118f, 0.03253129f, 0.00242722f, 0.02827343f, -0.08799167f, 0.07877765f, 
    -0.02473140f, -0.08066166f, -0.05100917f, -0.01397443f, -0.08865511f, -0.08675455f, 0.07576957f, -0.04501962f, 
    -0.01864189f, 0.07208377f, 0.06757836f, 0.01355183f, 0.00334240f, -0.01490263f, -0.03602228f, -0.06194928f, 
    -0.04329633f, 0.03727807f, 0.00671819f, -0.07047107f, 0.05920785f, -0.05772164f, 0.03560815f, -0.08828659f, 
    0.03391268f, 0.00656703f, 0.08125496f, -0.09059563f, -0.03331116f, 0.05262289f, -0.03528628f, -0.01398885f, 
    0.03304690f, 0.03117170f, -0.04692856f, 0.02737696f, -0.08177027f, -0.08147873f, 0.04917199f, 0.01198172f, 
    -0.03020224f, 0.02578087f, -0.06340183f, 0.05725051f, 0.03687260f, -0.02849910f, -0.07798466f, -0.02216608f, 
    0.05972717f, 0.00709167f, -0.00507713f, -0.05257322f, -0.07005792f, -0.04946496f, -0.05158490f, 0.04541039f, 
    -0.08170091f, -0.06918118f, -0.08769816f, -0.01629314f, -0.02850213f, 0.03022129f, 0.07488191f, 0.07513077f, 
    -0.06747777f, -0.02606308f, -0.06219408f, 0.03992594f, 0.03556037f, -0.07143604f, -0.07044786f, 0.01795590f, 
    -0.01741570f, -0.00309892f, 0.08094718f, -0.08548453f, -0.06950110f, 0.07123946f, 0.04869262f, 0.05559370f, 
    0.02024640f, -0.05375095f, -0.07934862f, 0.01352416f, -0.05460561f, -0.00062596f, 0.02232855f, -0.01438975f, 
    -0.10894173f, 0.06301405f, -0.05396352f, -0.02873703f, 0.03946734f, -0.06236497f, -0.10575249f, 0.01480043f, 
    0.06198492f, -0.04299686f, -0.08010875f, -0.01324883f, 0.01382003f, -0.11091352f, 0.03401587f, -0.02014063f, 
    0.03100542f, -0.02563935f, -0.01476153f, -0.04699768f, 0.04727839f, -0.04006634f, 0.04435154f, -0.00578853f, 
    0.01487170f, 0.07741008f, -0.02962482f, -0.01686572f, -0.06432641f, 0.05017423f, 0.01672562f, -0.00033069f, 
    -0.01244595f, -0.05863962f, 0.04673978f, 0.00155490f, -0.08813891f, 0.02150640f, 0.04204416f, 0.05179184f, 
    -0.05672270f, 0.02835359f, 0.04119396f, 0.06947450f, 0.01768601f, -0.08247910f, 0.02819376f, -0.07653930f, 
    0.00607337f, -0.10691135f, 0.07640956f, -0.00062562f, 0.00792228f, -0.03930296f, -0.08672009f, -0.07753924f, 
    0.00644574f, 0.01872450f, -0.06769697f, -0.05940510f, 0.02588662f, -0.04167768f, -0.01868402f, 0.01438662f, 
    -0.03040579f, -0.01717538f, 0.00348067f, -0.00732500f, -0.03396608f, 0.00591138f, 0.04232002f, 0.00770968f, 
    -0.09094708f, -0.08380722f, -0.05545269f, 0.00181527f, -0.05948415f, -0.02649054f, -0.03941103f, 0.07267570f, 
    -0.07284786f, -0.10999520f, 0.00278484f, -0.04131128f, -0.10290024f, 0.00764560f, -0.02890240f, 0.00821197f, 
    0.05315632f, -0.06154805f, -0.10102172f, 0.03587454f, -0.05552704f, 0.01501102f, 0.00142856f, -0.00428579f, 
    -0.01115623f, 0.05579556f, 0.00264914f, -0.02630256f, -0.02471273f, -0.01655717f, -0.02748608f, -0.06701964f, 
    0.00036391f, -0.00411821f, 0.05272774f, 0.04674865f, -0.03387007f, 0.05836058f, -0.08337866f, 0.04774442f, 
    0.04238288f, 0.09763346f, 0.22792545f, -0.29545403f, -0.01550095f, -0.01127718f, 0.10564415f, 0.06903634f, 
    -0.00415898f, 0.20337389f, 0.02182555f, -0.02416390f, -0.02653085f, 0.24827319f, 0.50801653f, 0.36640486f, 
    0.26536167f, 0.13355266f, -0.04322591f, -0.25678009f, 0.03778526f, 0.19911201f, -0.13160542f, 0.16195340f, 
    0.10825673f, 0.08558599f, -0.11641373f, -0.23798847f, 0.17007688f, 0.06826933f, -0.26960495f, -0.46492112f, 
    -0.22886442f, -0.18311843f, 0.13749786f, 0.17984061f, 0.12138847f, -0.33117709f, -0.06924860f, 0.06644219f, 
    -0.45413166f, 0.08712455f, 0.04671516f, 0.09489927f, 0.27662238f, 0.00319009f, -0.01634466f, -0.05915081f, 
    -0.04610025f, 0.05574600f, -0.02405009f, 0.10027002f, -0.08918060f, 0.03290326f, 0.30163810f, 0.16362712f, 
    -0.19219561f, 0.06947272f, 0.20019817f, -0.56102270f, 0.00454010f, 0.32813755f, 0.00586603f, -0.27568531f, 
    0.12974301f, -0.05825752f, 0.06108772f, 0.08125234f, 0.03861462f, -0.15921032f, -0.02434502f, 0.10010538f, 
    0.38981149f, 0.03719422f, -0.41208255f, -0.21323064f, 0.07152030f, 0.11869275f, -0.59912515f, -0.03715449f, 
    0.16436921f, -0.28148559f, 0.33615077f, -0.11592361f, -0.05040153f, 0.05340650f, -0.15935282f, 0.20955437f, 
    0.04735981f, 0.03164074f, -0.12444119f, 0.02652408f, 0.21147330f, 0.30886650f, 0.08301715f, -0.05633042f, 
    -0.38951606f, -0.44499141f, 0.09782583f, -0.08747084f, 0.07824643f, -0.42514348f, 0.04902430f, -0.09424876f, 
    0.30138606f, 0.07592001f, 0.15852775f, 0.00695714f, 0.17599154f, 0.17861183f, -0.08515327f, 0.11516423f, 
    0.19891888f, -0.09741985f, -0.14237577f, 0.24859042f, -0.17790192f, 0.07537076f, -0.00823465f, 0.16148183f, 
    -0.43769103f, 0.32117632f, -0.24306971f, 0.14485998f, -0.06140717f, 0.07793489f, -0.08934269f, 0.07462681f, 
    0.16252224f, 0.00079681f, 0.33152077f, -0.16702960f, 0.05266553f, -0.07315865f, 0.05917951f, -0.00742600f, 
    -0.23080593f, 0.30663002f, -0.01697917f, 0.25663596f, 0.42604065f, 0.14585686f, 0.01199889f, 0.04378751f, 
    -0.01326127f, 0.27999958f, -0.17480129f, -0.47353560f, -0.08109172f, 0.07852287f, -0.08517229f, 0.11089906f, 
    0.16344364f, 0.07033497f, -0.31218785f, -0.04220518f, 0.11456484f, 0.27743730f, -0.03277676f, -0.08497907f, 
    0.06913810f, -0.26279733f, 0.11063266f, -0.14900854f, 0.17405377f, -0.12430606f, -0.07455058f, 0.11403644f, 
    0.17655575f, 0.10293445f, -0.20848143f, 0.14978218f, 0.13710503f, -0.05001424f, 0.31652477f, 0.03084364f, 
    0.03059514f, -0.19120246f, 0.11102071f, -0.04232233f, 0.29191607f, 0.00271212f, 0.14966121f, -0.03202156f, 
    -0.07630235f, -0.13200986f, 0.24320519f, -0.21458703f, 0.08379760f, 0.11490776f, -0.05472855f, 0.25512397f, 
    0.02506036f, 0.07781367f, 0.05105295f, 0.07824636f, 0.04122252f, 0.00490837f, 0.00419827f, -0.16905311f, 
    -0.22044426f, 0.16390043f, -0.15904018f, 0.08940686f, -0.01178718f, 0.11111625f, -0.04909275f, 0.08122557f, 
    0.16470625f, -0.03638298f, 0.06266896f, 0.07057892f, 0.12007679f, -0.04332077f, -0.05607820f, 0.51166368f, 
    -0.06137889f, -0.13191609f, -0.10840088f, 0.19390438f, 0.42702374f, 0.23038913f, -0.00187786f, -0.12363105f, 
    -0.74517190f, -0.21004313f, 0.04965144f, -0.07179791f, -0.06014244f, -0.06087316f, -0.07577999f, 0.07374331f, 
    -0.05414153f, 0.14329246f, 0.18075137f, 0.03423048f, 0.03990864f, -0.17310889f, -0.03820157f, -0.21485865f, 
    -0.05612422f, 0.17245431f, -0.17308263f, 0.22231597f, 0.14539783f, -0.05988786f, 0.08727749f, -0.03645729f, 
    -0.17191036f, -0.34845808f, 0.08267122f, -0.01910756f, -0.20771158f, -0.08759681f, -0.02093321f, 0.05958800f, 
    0.04713740f, 0.06750113f, 0.19757612f, -0.28826344f, -0.27280831f, -0.09494838f, 0.07207865f, 0.20056708f, 
    0.28297475f, 0.06338242f, -0.00047609f, -0.01458724f, 0.10882091f, 0.04511374f, 0.42575374f, 0.35417095f, 
    0.14727883f, 0.19052455f, -0.00144432f, -0.44412282f, 0.01252452f, 0.31120145f, -0.16477686f, 0.06693667f, 
    -0.05037957f, 0.04626444f, -0.08923060f, -0.31269950f, 0.02563288f, 0.18664506f, -0.31387576f, -0.37293425f, 
    -0.16114116f, -0.38723445f, 0.17158766f, -0.04554923f, -0.00312966f, -0.36683169f, -0.10069515f, -0.03564353f, 
    0.06723329f, -0.06011378f, -0.15461707f, 0.10736549f, 0.26215598f, -0.07275564f, -0.17878518f, -0.20591800f, 
    -0.02474938f, -0.11929316f, 0.06697997f, 0.15652315f, -0.05548834f, -0.06675640f, 0.20784493f, 0.07300888f, 
    -0.18616511f, -0.05208736f, 0.06840935f, -0.31549501f, 0.01595320f, 0.18995436f, -0.07881033f, -0.00643959f, 
    0.18767548f, 0.09538548f, -0.06713749f, -0.04208795f, -0.04821056f, -0.11403602f, -0.04101737f, -0.08251088f, 
    0.13923711f, 0.08871907f, -0.39224762f, -0.13287126f, -0.01356023f, -0.00609538f, -0.23555256f, 0.06249469f, 
    0.13342674f, -0.14490548f, 0.33656529f, -0.11823262f, -0.08341444f, 0.02696220f, -0.06711381f, 0.39415270f, 
    -0.04709196f, -0.05316724f, -0.07557374f, -0.03663134f, 0.25547343f, 0.33943757f, -0.04084782f, 0.15090640f, 
    -0.36928713f, -0.38365510f, 0.08317264f, -0.07312969f, -0.07401429f, -0.29092339f, 0.02710105f, -0.08854990f, 
    0.18632933f, 0.11277565f, 0.03985608f, 0.06745203f, 0.06970586f, 0.17404622f, -0.05292306f, 0.16931389f, 
    0.00542052f, -0.00567306f, -0.35938635f, 0.29765579f, -0.19849662f, -0.01252008f, -0.02938931f, -0.07260465f, 
    -0.13188641f, -0.11849364f, -0.09548724f, 0.09609189f, 0.20780885f, 0.04272925f, -0.05540372f, 0.09059851f, 
    0.06508765f, -0.08099867f, 0.03829674f, 0.04873066f, -0.08496296f, -0.07831106f, 0.03875568f, 0.05018988f, 
    -0.03393335f, 0.02331148f, -0.03008921f, -0.02164394f, -0.08460819f, -0.08191268f, 0.02346063f, 0.03660980f, 
    0.01136412f, 0.06792992f, 0.06901516f, 0.06419718f, 0.01909011f, 0.06173282f, 0.04722825f, -0.03182609f, 
    -0.00968019f, -0.06212319f, 0.03532748f, 0.05863459f, 0.04034454f, 0.01998234f, 0.01866507f, -0.04657993f, 
    -0.08466616f, -0.06184634f, -0.01043563f, 0.01543013f, -0.01973664f, 0.04152157f, 0.05578668f, -0.03822866f, 
    0.00041279f, 0.03208118f, -0.03126357f, -0.07898616f, -0.04915597f, -0.08502816f, 0.03392485f, -0.01695025f, 
    0.00314330f, 0.08271918f, -0.06198577f, -0.00693240f, -0.04561522f, 0.02490644f, 0.04705453f, -0.03610166f, 
    -0.03360130f, -0.00500721f, -0.08476160f, 0.05217696f, -0.07269926f, -0.00507911f, -0.07394726f, -0.06750408f, 
    0.04547548f, 0.01743707f, -0.00989223f, -0.06824851f, -0.00200202f, -0.05202814f, -0.02025732f, -0.01787833f, 
    0.01123562f, -0.06223463f, 0.05236143f, -0.00715064f, -0.04841942f, 0.03591479f, -0.00957395f, 0.04549912f, 
    0.00863409f, 0.02740332f, -0.00614886f, -0.06039228f, -0.08553639f, -0.03492877f, -0.03777827f, -0.01189922f, 
    -0.01096292f, 0.00940443f, -0.08758678f, 0.03876549f, 0.01117170f, 0.01981655f, -0.05462102f, -0.05545817f, 
    -0.08742107f, 0.02176057f, -0.07429357f, -0.04915508f, -0.08187140f, -0.08910327f, 0.02324713f, 0.06482736f, 
    0.02542718f, 0.05119125f, -0.02448328f, -0.07183028f, -0.00042137f, 0.01519153f, -0.04650946f, -0.08428658f, 
    -0.07481983f, 0.07883554f, 0.03351773f, -0.03033353f, 0.07168085f, -0.05148296f, 0.04076898f, -0.01614610f, 
    0.01509659f, -0.01652153f, -0.02550391f, -0.04514555f, -0.02824263f, -0.07551587f, 0.00090875f, -0.08483417f, 
    0.21032605f, -0.30924389f, 0.41967803f, -0.04041153f, 0.04021252f, 0.04143181f, -0.06223734f, 0.12554578f, 
    0.00637862f, 0.06643641f, 0.09932064f, -0.13362281f, 0.06701647f, -0.08471654f, -0.65769768f, -0.01270244f, 
    0.03078037f, 0.17363147f, 0.23788813f, -0.00954847f, -0.03072340f, 0.03081260f, -0.01025990f, -0.23737492f, 
    -0.12009145f, 0.24883069f, 0.01405463f, -0.15572754f, -0.04352207f, -0.08618610f, -0.01011734f, 0.22338924f, 
    0.11189485f, -0.01785030f, 0.09554339f, -0.02509711f, -0.08643787f, 0.11657599f, 0.18390571f, 0.24121019f, 
    -0.39528316f, -0.02397551f, 0.02340093f, -0.08211017f, -0.16518319f, -0.24647883f, 0.18690792f, -0.22561552f, 
    0.06410459f, 0.09556640f, 0.08805964f, 0.01440232f, -0.41687009f, 0.31584585f, -0.17716731f, -0.00268345f, 
    0.04541822f, 0.00680407f, -0.05254356f, -0.02185927f, -0.23355936f, -0.07270608f, 0.11064713f, 0.01040941f, 
    0.20277339f, 0.23636365f, 0.08315215f, -0.01747787f, 0.01360010f, -0.13066748f, 0.11572141f, -0.12792720f, 
    -0.02461274f, 0.22747242f, 0.07000107f, 0.25950512f, -0.08121809f, 0.21883889f, -0.12684517f, -0.39223886f, 
    -0.03633722f, 0.00675303f, 0.09026079f, -0.16208683f, 0.18730003f, 0.06607910f, 0.08088554f, -0.08675193f, 
    -0.00179468f, 0.06990487f, 0.23892905f, 0.20000394f, 0.54434872f, 0.00826529f, 0.11955528f, 0.26422057f, 
    -0.15097626f, 0.01970549f, -0.02597914f, -0.00781526f, -0.11047083f, 0.07825796f, -0.06416547f, 0.31181532f, 
    -0.12374289f, 0.30984652f, -0.00115513f, -0.09528834f, -0.10932226f, -0.13417239f, -0.13353656f, 0.14485644f, 
    0.13176619f, 0.11907930f, 0.02899032f, -0.11365458f, 0.31430641f, -0.08622883f, 0.01577064f, -0.20708461f, 
    -0.24846469f, 0.01482125f, 0.04330257f, -0.05427418f, 0.06660731f, -0.08882230f, 0.11322037f, 0.07877499f, 
    -0.03918704f, 0.00691967f, -0.05824006f, -0.00557379f, 0.04492776f, -0.07104219f, -0.04178345f, -0.10579535f, 
    0.03436695f, 0.00352385f, -0.06992014f, -0.02692321f, -0.09691262f, -0.02622416f, -0.08021699f, 0.05644781f, 
    -0.07553334f, -0.09394194f, 0.00783500f, -0.10076280f, 0.00131717f, -0.04938779f, -0.07414355f, 0.04816036f, 
    -0.10370979f, -0.06181386f, -0.09315506f, -0.03213391f, -0.01925918f, -0.01910769f, 0.00608134f, -0.00479645f, 
    -0.05430538f, 0.00088756f, 0.04652874f, -0.10295782f, 0.01970751f, -0.02999850f, -0.04223208f, 0.06570932f, 
    -0.07878628f, -0.08307315f, -0.06564970f, -0.10779156f, -0.08822265f, 0.02542361f, 0.00315120f, 0.02641540f, 
    -0.07887487f, 0.04980975f, 0.04753870f, -0.04467780f, 0.04459394f, -0.09687945f, -0.09670784f, -0.07699786f, 
    -0.05882819f, -0.10434243f, 0.06724144f, 0.02099719f, 0.03943729f, -0.03404509f, 0.04564134f, 0.04756739f, 
    0.02328200f, -0.07762466f, -0.04891076f, -0.09615437f, 0.06211303f, 0.00870358f, 0.04234285f, 0.04765549f, 
    -0.06447879f, -0.07369734f, 0.00787067f, -0.08036156f, 0.06609446f, -0.06810169f, 0.02990581f, -0.06419211f, 
    0.00445915f, -0.05052034f, -0.00408591f, 0.03640647f, -0.00871777f, -0.01793985f, 0.05906319f, -0.10888080f, 
    0.03426980f, 0.06402208f, 0.06230718f, -0.10065943f, 0.07953516f, -0.01345737f, -0.07478109f, 0.03832281f, 
    -0.04761379f, -0.09823243f, -0.06133980f, -0.01479192f, 0.04249242f, -0.05476106f, -0.08306094f, -0.04750681f, 
    -0.01318263f, -0.05219473f, -0.06390136f, -0.07791653f, 0.03944176f, -0.03231225f, -0.00620955f, -0.06180627f, 
    -0.06936765f, 0.04550500f, 0.00694537f, -0.07248068f, -0.04965112f, 0.02866341f, -0.03628762f, -0.04231364f, 
    -0.03370636f, 0.05710541f, -0.09883300f, -0.07514045f, -0.02876037f, 0.01250300f, -0.09735195f, -0.01537016f, 
    0.23683247f, -0.02429208f, 0.37046415f, -0.07820097f, -0.30848688f, -0.03091581f, 0.02197453f, -0.07360082f, 
    0.03503474f, -0.05254340f, 0.06285277f, 0.05250861f, -0.09239201f, 0.10970325f, 0.32418534f, 0.27680522f, 
    0.35822171f, 0.02537572f, 0.04947425f, -0.06257889f, 0.08771970f, 0.18338096f, -0.02134895f, 0.13359866f, 
    -0.04224118f, 0.07520224f, 0.00927098f, -0.17226043f, -0.00046110f, 0.14815563f, 0.03302337f, -0.37278521f, 
    -0.10611469f, 0.09874979f, 0.07957405f, -0.05162442f, 0.01552613f, -0.23719338f, 0.00562294f, -0.05318322f, 
    -0.14586525f, 0.13900799f, 0.06553749f, -0.25325897f, 0.01234212f, 0.06934574f, 0.05189056f, 0.19946472f, 
    -0.00427128f, -0.12229048f, 0.12837411f, 0.12054221f, -0.19480333f, 0.13218218f, 0.12563527f, 0.00848835f, 
    -0.12078966f, 0.00353395f, -0.42385060f, -0.11529180f, 0.02331359f, 0.37136424f, 0.04490272f, -0.05697374f, 
    0.18084200f, 0.06334008f, 0.03864223f, 0.15128243f, -0.01998094f, -0.11409552f, 0.12757169f, -0.01230548f, 
    0.30582374f, 0.04211356f, -0.13761570f, -0.22553693f, -0.11395622f, 0.38325471f, -0.20984106f, -0.28834495f, 
    0.15974241f, 0.01619824f, 0.35377419f, -0.07830325f, -0.13235819f, 0.02710756f, 0.10565468f, -0.17405120f, 
    0.04782417f, -0.04710599f, -0.11651971f, -0.00521039f, 0.38304326f, 0.28040808f, 0.23165062f, 0.04728679f, 
    -0.05523736f, -0.34970549f, 0.05213262f, -0.05847901f, -0.02162743f, -0.08657080f, 0.00549005f, -0.00932708f, 
    0.06575727f, -0.10438749f, 0.15409796f, 0.08689218f, 0.30519551f, 0.18723424f, 0.03977997f, 0.34601259f, 
    0.07029166f, -0.05209493f, -0.00566113f, 0.05664989f, 0.13352586f, -0.12377948f, -0.03170530f, 0.11079991f, 
    -0.18026134f, 0.47495714f, -0.20400600f, 0.14893404f, 0.18648481f, 0.09041330f, 0.15586193f, 0.08432739f, 
    0.01526411f, 0.04409387f, 0.02915769f, -0.03498042f, 0.04420285f, -0.04795517f, -0.04891487f, -0.07758749f, 
    -0.00861174f, 0.02226594f, -0.02554092f, -0.06921536f, -0.05106501f, 0.02844668f, -0.03490319f, -0.01839086f, 
    0.04229490f, -0.04358316f, 0.06268343f, 0.00440383f, -0.06328663f, -0.02085860f, -0.04992891f, 0.01768957f, 
    0.06438573f, 0.01354499f, 0.04048912f, 0.01496421f, -0.02822067f, -0.00907939f, -0.01800065f, -0.06479529f, 
    0.05834756f, 0.01567164f, -0.05337320f, 0.03138903f, 0.07114383f, 0.01444171f, -0.05777872f, 0.03660429f, 
    -0.07507765f, 0.07049469f, 0.02325713f, -0.04894515f, -0.05480658f, 0.03764814f, -0.03680225f, 0.04588288f, 
    -0.09017653f, 0.02078296f, -0.07357186f, 0.03613826f, 0.00737297f, -0.06222314f, -0.07140286f, -0.07272961f, 
    -0.08779680f, -0.01439519f, -0.08134399f, 0.08501776f, -0.01273046f, -0.05671102f, -0.02097290f, 0.06155823f, 
    0.07696087f, -0.00026777f, -0.01065091f, 0.05024067f, -0.07981239f, 0.03792680f, 0.01440786f, 0.07302405f, 
    0.01541439f, -0.04358611f, -0.04665967f, 0.03381400f, 0.06686953f, 0.03462093f, 0.00413468f, -0.06673698f, 
    -0.09263875f, -0.03329204f, -0.06154051f, 0.04389951f, -0.06678303f, -0.04815586f, 0.03708744f, -0.00212239f, 
    -0.09757766f, -0.06853691f, 0.05095547f, -0.05331938f, -0.02946776f, -0.02183932f, 0.08330596f, -0.07247136f, 
    0.00552270f, -0.08587499f, 0.01151763f, -0.04503198f, 0.06971332f, 0.03974209f, -0.08313123f, -0.02502925f, 
    -0.04303738f, -0.02651967f, 0.04835129f, -0.06108863f, -0.03489973f, -0.03787357f, -0.08729948f, -0.05017944f, 
    -0.07704974f, 0.02251283f, -0.02536814f, 0.07925378f, -0.03324833f, -0.03990846f, -0.03965767f, 0.01012612f, 
    0.01343586f, -0.06859201f, -0.02671822f, 0.07172085f, -0.05402580f, -0.02186245f, -0.04052123f, -0.05785893f, 
    -0.08511770f, 0.01786487f, -0.03452214f, -0.08869335f, 0.02528341f, 0.05159600f, 0.08478583f, 0.02289806f, 
    0.05355940f, 0.06108511f, -0.06563797f, -0.05484451f, -0.02791845f, -0.01835706f, 0.02975181f, 0.00251965f, 
    -0.04360560f, -0.07667579f, -0.05274699f, 0.03425283f, 0.00427542f, -0.02065778f, 0.03868238f, -0.05037848f, 
    0.00472354f, -0.11966629f, 0.02398091f, 0.00245257f, 0.03894399f, 0.01010580f, -0.03886586f, 0.00239902f, 
    0.03208214f, -0.06956938f, -0.04407262f, 0.06690338f, -0.10151292f, 0.01477765f, 0.06156407f, -0.02690442f, 
    -0.06199516f, -0.07739514f, 0.01900399f, 0.05249742f, 0.02037589f, -0.10555961f, 0.08383565f, -0.12453134f, 
    0.01063703f, 0.02944162f, 0.00357411f, 0.01421238f, 0.00785592f, 0.01223530f, -0.02099033f, -0.08036619f, 
    -0.04421100f, -0.10359325f, 0.05881850f, -0.07715333f, -0.00742077f, 0.01496437f, -0.07577439f, 0.09053387f, 
    0.03981678f, -0.05749528f, 0.07118549f, -0.04196729f, -0.02977930f, -0.11372675f, -0.07212011f, -0.01106246f, 
    0.04400292f, -0.03293670f, 0.01436502f, -0.03631524f, -0.02714213f, 0.01835653f, -0.08928812f, 0.00708400f, 
    -0.10141827f, -0.12327901f, -0.10274067f, -0.06911256f, 0.06659544f, 0.06903262f, -0.03925233f, -0.13695373f, 
    0.05256842f, 0.06037460f, -0.08735440f, -0.03743621f, -0.05894842f, -0.09400802f, -0.03985171f, 0.00410437f, 
    0.02720320f, -0.07385608f, -0.09828943f, -0.04846914f, -0.06320821f, -0.01257193f, -0.03208502f, 0.00864228f, 
    0.02312815f, -0.06176422f, -0.06065946f, 0.04626352f, -0.05083189f, -0.12844864f, -0.07213328f, -0.04486241f, 
    0.00381079f, -0.08850540f, -0.06708817f, -0.11243260f, -0.05783306f, -0.02638810f, 0.03114114f, -0.08307865f, 
    0.04522022f, 0.01886379f, -0.11200520f, -0.00261260f, 0.05405209f, -0.09815484f, 0.05690419f, -0.01487540f, 
    -0.06717692f, -0.05725345f, -0.01241002f, -0.08306324f, 0.02658601f, 0.05418300f, -0.06877051f, -0.07080451f, 
    -0.03585900f, 0.06214561f, -0.07326998f, -0.04479351f, -0.07850002f, -0.00789598f, 0.05785699f, 0.00680229f, 
    0.04287527f, -0.04235817f, -0.09014589f, -0.09432805f, 0.01836189f, 0.05112659f, -0.08337713f, -0.01500135f, 
    -0.09041824f, 0.04497382f, -0.00482247f, -0.02968155f, -0.00152710f, -0.08275468f, -0.00784148f, -0.07219028f, 
    -0.07844015f, 0.07415059f, 0.03416556f, -0.06970230f, -0.04269570f, 0.04508081f, -0.06857258f, -0.10017423f, 
    -0.00008906f, -0.01175249f, -0.07732578f, 0.01533833f, -0.00744701f, 0.01968917f, -0.00755914f, -0.07760344f, 
    0.04671830f, -0.00386968f, 0.01047666f, 0.00445124f, 0.01096205f, -0.02854533f, -0.08731540f, -0.08062146f, 
    -0.08374007f, 0.05010924f, -0.01036540f, -0.06156166f, -0.01761849f, -0.10577045f, 0.02938258f, -0.08191039f, 
    0.06502906f, -0.07674333f, -0.03026362f, -0.08365513f, 0.03574752f, -0.09012768f, -0.01605775f, 0.04083188f, 
    -0.04068573f, -0.07655513f, -0.01258503f, -0.04427091f, -0.02552990f, 0.04937128f, -0.05632880f, -0.11609155f, 
    0.03672876f, -0.02239772f, -0.02515678f, -0.06032613f, 0.04672524f, -0.08353819f, -0.07224274f, 0.02538817f, 
    -0.04565280f, 0.05499031f, -0.08184285f, 0.01809546f, -0.02877976f, 0.00534607f, 0.03329834f, 0.00342876f, 
    -0.03342635f, -0.04705652f, 0.06045286f, 0.07705651f, -0.05080440f, -0.07126626f, 0.07419397f, 0.06047738f, 
    -0.10123347f, -0.04156591f, -0.03498597f, -0.02121167f, 0.00504933f, 0.01044151f, -0.01352205f, -0.07032291f, 
    -0.07297014f, 0.00539558f, 0.01157204f, -0.07919557f, -0.06105132f, -0.08749207f, -0.00211967f, -0.07546822f, 
    0.07769573f, -0.05599384f, -0.01574674f, 0.05193305f, -0.01415805f, 0.06561911f, -0.05633641f, 0.06093731f, 
    -0.18404397f, -0.23549514f, -0.14219148f, -0.09073525f, 0.20646459f, -0.04850724f, 0.04843215f, -0.04866327f, 
    0.06094906f, 0.22876370f, 0.18357287f, 0.10618618f, 0.15558252f, -0.11638210f, -0.07743070f, 0.02795506f, 
    0.02993738f, 0.04918692f, -0.18487342f, -0.17469338f, -0.02794442f, 0.10933368f, 0.06005727f, -0.14017777f, 
    0.10536764f, 0.08432528f, -0.29417065f, -0.15135257f, 0.18002591f, 0.04231170f, -0.31037807f, 0.03706786f, 
    0.21866828f, -0.15442854f, -0.13975218f, -0.02945462f, 0.02204829f, 0.08886927f, -0.32122326f, 0.28543925f, 
    -0.06927645f, -0.03579177f, -0.22117695f, 0.25893340f, 0.25894836f, -0.12413754f, 0.19331732f, -0.21488214f, 
    0.08980335f, -0.43424970f, 0.09092522f, -0.15876694f, -0.14816064f, 0.06534570f, 0.31046098f, -0.03039862f, 
    0.17494214f, -0.24905354f, -0.14303727f, -0.41108087f, 0.06212433f, -0.07449377f, -0.14161438f, -0.06828620f, 
    0.10872640f, 0.05062979f, -0.05466837f, -0.00024034f, 0.06570035f, -0.08948471f, -0.03072706f, -0.28789347f, 
    -0.10905663f, -0.06397227f, 0.06938992f, -0.42854771f, -0.07643242f, -0.16039948f, -0.00912637f, 0.16792612f, 
    -0.10023089f, 0.08964255f, -0.27954376f, -0.08260527f, 0.32217181f, -0.03453286f, -0.03044347f, 0.11538516f, 
    -0.05683417f, -0.27087626f, 0.06070410f, 0.25935867f, -0.33288458f, -0.16115850f, 0.14192651f, -0.02067700f, 
    -0.18305004f, -0.20066829f, 0.02052381f, -0.05632195f, 0.14181930f, -0.11494337f, -0.07392915f, 0.17041662f, 
    -0.14610432f, 0.25795469f, 0.06832388f, -0.21386729f, -0.07611090f, 0.02713400f, 0.26529154f, -0.12338264f, 
    0.20001534f, 0.27031854f, -0.29955676f, 0.10009386f, -0.50815821f, -0.07991110f, 0.02343579f, 0.01928753f, 
    -0.05114253f, -0.25814149f, 0.05403601f, -0.23023167f, 0.08268221f, 0.08571327f, -0.14527315f, 0.02292153f, 
    0.06882985f, -0.05712505f, -0.10082734f, -0.12537195f, 0.11076295f, 0.21076594f, -0.10365141f, 0.24504961f, 
    0.05061908f, 0.06194369f, 0.03452037f, 0.12411815f, 0.08187234f, -0.27128130f, 0.03285761f, 0.05769653f, 
    -0.05211049f, -0.13986878f, 0.19712022f, -0.17863770f, -0.05871341f, 0.27700436f, -0.04019404f, 0.09660493f, 
    0.05683629f, 0.01585457f, -0.08070181f, 0.17291631f, 0.32387343f, -0.05686517f, -0.20402765f, -0.10969037f, 
    0.01774960f, -0.29842734f, 0.00048808f, -0.04636540f, 0.07910425f, -0.12646577f, -0.09828827f, 0.23659380f, 
    0.10513651f, -0.06562344f, -0.08264834f, 0.32590821f, 0.15859927f, -0.30502605f, -0.16722679f, -0.19373839f, 
    0.21928392f, -0.00227819f, 0.07948530f, 0.11552599f, -0.28640655f, 0.03084799f, -0.00303520f, -0.08375325f, 
    0.14991349f, -0.08715346f, -0.07551716f, -0.11329361f, 0.04337933f, -0.08331363f, 0.04901942f, -0.23025471f, 
    0.18935752f, -0.15762594f, 0.04492534f, 0.11579989f, 0.02828542f, 0.27140215f, -0.03773261f, -0.02034529f, 
    -0.04119587f, 0.03628283f, -0.24034777f, -0.21683991f, -0.02810179f, -0.08027294f, 0.14277133f, 0.51780802f, 
    -0.00330698f, 0.06903831f, 0.22859956f, 0.12528901f, 0.07969511f, 0.06322271f, 0.07514422f, 0.05932393f, 
    0.00007755f, 0.22291225f, 0.16814947f, 0.00849262f, 0.03080362f, 0.01157741f, -0.00655698f, 0.34426901f, 
    -0.10594676f, -0.00017667f, 0.13683692f, 0.02165889f, 0.02038631f, -0.09123629f, -0.05533146f, -0.11414868f, 
    0.24433559f, 0.03661661f, 0.01287776f, -0.10225698f, 0.02071126f, 0.09705245f, -0.01169021f, 0.17927140f, 
    0.20841002f, 0.13295972f, -0.25863227f, 0.28829271f, -0.08123209f, -0.02786016f, -0.07966927f, 0.09019253f, 
    0.30344832f, -0.22128661f, 0.10876340f, -0.19184510f, 0.05813569f, -0.06325332f, -0.07833184f, -0.05530702f, 
    0.05189071f, 0.01298920f, -0.16301143f, -0.07659925f, -0.04730006f, -0.01325212f, 0.17742164f, 0.34305629f, 
    -0.10899039f, 0.10134029f, -0.13497436f, -0.02792423f, 0.09945020f, -0.22645250f, 0.19259195f, 0.10393557f, 
    -0.40533647f, 0.18210328f, -0.03336446f, -0.00309759f, 0.07392912f, 0.31479791f, -0.16228847f, 0.07339566f, 
    0.22681288f, -0.01318735f, 0.04626194f, 0.13796684f, -0.04188544f, -0.00694609f, -0.28954962f, 0.04079004f, 
    -0.05435157f, 0.36995986f, 0.20068666f, 0.11192621f, 0.15402775f, 0.05806660f, 0.12804918f, 0.17144033f, 
    0.05211532f, -0.05444526f, -0.05274042f, 0.37181890f, 0.36494035f, -0.11414555f, -0.09847525f, -0.29608727f, 
    0.09514766f, 0.09714898f, -0.06500329f, -0.02980886f, -0.81529087f, -0.01219690f, 0.28933001f, 0.19876398f, 
    -0.05415196f, 0.25530761f, 0.61963117f, -0.08791757f, -0.05755571f, 0.05342446f, 0.19647245f, -0.32718328f, 
    -0.05589149f, 0.16591460f, -0.08213729f, 0.09821147f, 0.05512944f, -0.22492297f, 0.14183186f, 0.29283476f, 
    0.24964367f, -0.11141449f, 0.07601430f, 0.04295959f, -0.03301674f, -0.26140323f, 0.17619440f, 0.32954440f, 
    0.13583580f, -0.12710056f, 0.09653773f, 0.05708776f, -0.05440689f, 0.01050048f, -0.18663889f, 0.32007524f, 
    0.08559983f, 0.07075981f, -0.01951478f, -0.11557568f, 0.18764283f, 0.07454915f, -0.16676262f, 0.12046255f, 
    -0.09598400f, -0.08863571f, 0.04181584f, -0.08168061f, 0.23460607f, -0.10363161f, 0.01741596f, -0.03086279f, 
    0.28034770f, 0.07703716f, -0.06161663f, -0.05458203f, -0.13469435f, -0.03967214f, 0.06596132f, 0.01810328f, 
    0.18109062f, 0.03472570f, -0.11580654f, 0.20061898f, -0.08144262f, 0.16840360f, 0.02646605f, 0.07950867f, 
    -0.01121518f, -0.00287619f, 0.07642902f, -0.00661996f, 0.12147680f, 0.13252118f, -0.06944137f, 0.03458242f, 
    0.03751498f, -0.07923420f, -0.00873949f, 0.00378635f, -0.05857379f, -0.04846437f, -0.04862196f, -0.06718969f, 
    0.05836300f, -0.04988107f, -0.06308120f, 0.02302284f, 0.03889482f, -0.00072410f, -0.08134191f, 0.01171881f, 
    -0.06952708f, -0.00088959f, 0.07022970f, -0.04368784f, -0.07352342f, 0.05622532f, -0.07607509f, -0.04402469f, 
    0.03270168f, -0.00109793f, -0.07848678f, 0.00238185f, 0.06756210f, -0.09682737f, -0.03453602f, -0.08381587f, 
    0.01652588f, -0.01795782f, 0.05810374f, -0.03555068f, 0.08430593f, -0.11866714f, 0.07067836f, -0.05027137f, 
    -0.01297820f, 0.07994607f, 0.02806884f, -0.04973073f, -0.06431443f, -0.07146435f, 0.03986054f, 0.05044837f, 
    -0.05361620f, -0.04475393f, -0.08739713f, -0.07310671f, 0.05051585f, -0.10098001f, -0.06077768f, 0.03867490f, 
    0.00436779f, -0.01647077f, 0.01864694f, -0.09894972f, -0.07006400f, 0.02012384f, 0.00519070f, 0.07901140f, 
    0.07245931f, 0.02961699f, 0.05075607f, 0.07551763f, -0.07796805f, -0.04747092f, -0.06197125f, -0.10797574f, 
    0.04269606f, -0.00570284f, 0.09054662f, 0.05496535f, -0.07799681f, -0.08655434f, -0.06555427f, -0.04875251f, 
    -0.03720337f, 0.07235414f, -0.00723838f, -0.08625545f, 0.01576792f, 0.05336374f, -0.04245785f, -0.02579607f, 
    -0.07580888f, -0.02607452f, -0.02077236f, 0.03250039f, -0.03767879f, -0.08805645f, -0.04279988f, -0.07322524f, 
    0.06830329f, 0.07489071f, -0.07860675f, -0.02697309f, 0.05077196f, 0.05232964f, 0.06946725f, -0.01195932f, 
    -0.02783729f, -0.03520523f, -0.02974169f, -0.03316041f, -0.03321019f, 0.01848681f, 0.03425443f, 0.07224121f, 
    0.05578059f, -0.00562142f, -0.05669870f, -0.02015343f, -0.03545434f, -0.02648613f, -0.04181398f, 0.03095964f, 
    -0.08649973f, 0.04917736f, -0.07232854f, 0.00932883f, 0.05299348f, -0.09816103f, 0.02911781f, -0.08158543f, 
    -0.02469202f, -0.03492997f, -0.00734858f, -0.07292033f, 0.05899202f, -0.06417335f, -0.01524380f, -0.04488806f, 
    -0.09997275f, -0.06187576f, -0.08991044f, -0.09488121f, 0.01244981f, 0.03182204f, -0.02084174f, -0.10829997f, 
    -0.16039050f, -0.06146944f, 0.04848709f, -0.11371656f, -0.04503939f, 0.02128322f, -0.01971506f, -0.07821775f, 
    -0.03953139f, -0.01811323f, -0.00217202f, 0.04651478f, 0.06053939f, -0.02397527f, -0.08289021f, -0.09441221f, 
    0.04779338f, 0.01096396f, -0.04515897f, -0.04923914f, 0.02261622f, 0.04969592f, -0.14775132f, 0.05135625f, 
    -0.04411721f, 0.04268713f, -0.10118198f, -0.00797880f, 0.02141365f, -0.10190961f, 0.07031366f, -0.07818185f, 
    0.03600752f, 0.01803736f, -0.13213424f, -0.04198116f, 0.00533113f, -0.08007224f, 0.01990569f, -0.09574264f, 
    -0.02328062f, -0.00636693f, 0.05891771f, 0.07769911f, -0.10844950f, 0.00666914f, -0.09455787f, -0.00675228f, 
    0.07401709f, -0.00077151f, -0.01920350f, -0.04177485f, -0.01420590f, 0.03352976f, -0.09499499f, -0.07573788f, 
    -0.07595540f, -0.01089029f, -0.10516097f, 0.04131551f, 0.07502374f, -0.04187618f, -0.10591149f, -0.01505292f, 
    -0.00213617f, 0.03080695f, -0.05523763f, -0.05167431f, -0.07845048f, -0.07293108f, -0.03946603f, -0.06290819f, 
    -0.03499751f, -0.05321066f, 0.05821401f, -0.00491569f, -0.11894704f, 0.01550216f, -0.11331253f, -0.08175690f, 
    -0.06739421f, 0.00049891f, -0.09526718f, -0.07106744f, -0.07211429f, 0.01522587f, 0.02957067f, -0.10247264f, 
    -0.01301583f, -0.01120799f, -0.07793666f, 0.00303549f, -0.01194136f, 0.00983639f, 0.01716561f, -0.10594922f, 
    -0.11623019f, 0.12380088f, -0.02092414f, -0.03622369f, -0.04928936f, 0.05249212f, -0.05125670f, -0.09631994f, 
    0.04391946f, -0.07330196f, -0.13709983f, 0.03941535f, -0.15724294f, -0.07568938f, -0.08448389f, -0.03808347f, 
    0.54754883f, -0.03699136f, -0.30934703f, -0.09764640f, -0.23221119f, -0.00497805f, 0.04158952f, 0.14412966f, 
    0.05642551f, -0.32055938f, -0.23338534f, 0.36821562f, 0.24646616f, 0.08122625f, 0.00952334f, -0.17077841f, 
    0.11762873f, 0.13667782f, 0.14698291f, -0.02858933f, 0.01315099f, -0.11637277f, 0.05834674f, 0.12663674f, 
    -0.32105765f, 0.16010281f, 0.11558738f, 0.14674287f, -0.06773698f, -0.20762594f, 0.16268915f, -0.08473999f, 
    -0.42806357f, -0.06279986f, 0.05443141f, 0.16927736f, -0.20400490f, -0.00799781f, 0.33778867f, -0.00607100f, 
    -0.18519406f, -0.05963118f, -0.38303491f, 0.17629206f, -0.08648422f, -0.07202542f, 0.44533017f, 0.05360594f, 
    0.09687911f, 0.04676091f, -0.01158771f, 0.31969187f, -0.03000230f, 0.13050403f, -0.05445964f, -0.03278564f, 
    -0.44464317f, -0.01470229f, 0.50907004f, 0.61712736f, -0.13464949f, -0.24995163f, 0.11443909f, -0.40483558f, 
    -0.04554151f, -0.33851871f, -0.05422848f, 0.12931658f, -0.00892938f, 0.34610042f, 0.10370553f, 0.08132334f, 
    0.12296544f, -0.06328845f, -0.13159823f, 0.52951521f, 0.13988143f, 0.17786817f, -0.01992760f, -0.08376016f, 
    0.20290802f, 0.07101972f, 0.27362564f, 0.01069290f, -0.02708084f, 0.01814826f, 0.12940766f, 0.05061394f, 
    -0.05658147f, 0.32300332f, -0.06896096f, 0.48294213f, 0.76809371f, 0.14956267f, 0.18225189f, -0.05649455f, 
    -0.37717193f, -0.11405892f, 0.18304677f, -0.06593438f, 0.08249164f, -0.06086055f, 0.03363229f, 0.05371206f, 
    0.21741307f, 0.15038091f, 0.08662037f, -0.08458017f, 0.17152296f, -0.16650666f, -0.48754176f, -0.27661997f, 
    -0.08774981f, 0.22318037f, 0.06077432f, 0.04051091f, 0.63453943f, -0.10120832f, -0.04917497f, -0.00314690f, 
    -0.33629435f, -0.22485881f, 0.02186750f, 0.13433467f, 0.01970427f, -0.12309924f, 0.22288784f, -0.05854527f, 
    0.07268937f, 0.00956426f, -0.03102167f, -0.02058779f, -0.02812994f, -0.02110489f, -0.03761580f, 0.03086442f, 
    -0.01969370f, 0.03091879f, -0.06304564f, -0.06910160f, 0.01736497f, -0.00876940f, -0.01895560f, 0.05862574f, 
    -0.08376698f, 0.05782509f, 0.08115669f, -0.06225855f, 0.06061666f, -0.04054358f, -0.08145844f, -0.06104508f, 
    0.03548528f, 0.01760735f, -0.07814990f, 0.00771599f, -0.06807632f, -0.05385947f, -0.07011881f, -0.05063044f, 
    -0.05220830f, -0.04714433f, 0.00063506f, -0.00915658f, -0.03031551f, -0.06809641f, 0.01421994f, 0.07603195f, 
    -0.03543230f, 0.02501855f, 0.03091703f, -0.01290112f, -0.04445151f, -0.06000238f, 0.04667714f, -0.05196951f, 
    0.05808177f, 0.06080884f, -0.00047479f, 0.07446238f, 0.08412295f, -0.06211634f, -0.04539879f, 0.01588748f, 
    0.06000078f, -0.01184604f, -0.06286387f, 0.02472719f, -0.05657753f, -0.00269103f, -0.09075961f, 0.02956041f, 
    -0.07880726f, -0.00935555f, -0.05834189f, 0.05888758f, 0.00835410f, -0.06617042f, -0.02389499f, 0.04675613f, 
    -0.05331485f, -0.05214488f, -0.08560988f, -0.04572686f, -0.01166642f, 0.00024709f, -0.02127972f, -0.00937759f, 
    -0.05971356f, 0.00934021f, -0.06107905f, -0.04257418f, 0.03812563f, -0.06980703f, -0.06067061f, -0.04086950f, 
    -0.01291500f, -0.08832371f, -0.08207187f, -0.02567664f, 0.04191646f, -0.07434271f, -0.03035215f, 0.06485138f, 
    -0.00851877f, 0.04319304f, -0.03202511f, 0.07554188f, -0.01309783f, 0.01891565f, 0.01508059f, -0.00854913f, 
    0.02173732f, 0.06092738f, -0.06288639f, 0.04011505f, -0.07103375f, 0.03616981f, -0.05333076f, 0.06672993f, 
    0.01747075f, -0.05280808f, -0.06809351f, -0.00545056f, -0.05158094f, 0.03995232f, 0.05307621f, -0.00572557f, 
    0.03490892f, 0.05671389f, -0.05384434f, 0.05092925f, -0.00301602f, 0.08786222f, 0.05762874f, -0.00501838f, 
    0.13433686f, -0.07690608f, 0.00607151f, -0.20214552f, 0.03634423f, 0.27458903f, -0.08049163f, 0.27857944f, 
    0.08274683f, -0.05736866f, 0.09040303f, 0.19022937f, 0.01834523f, -0.13938680f, 0.01302576f, -0.12969679f, 
    0.20372459f, -0.02588369f, 0.30490553f, -0.16337490f, -0.01952144f, 0.04580444f, 0.20586087f, 0.00319067f, 
    0.08397073f, 0.01310049f, -0.11972297f, 0.15191023f, 0.31074938f, -0.07055658f, 0.01292361f, -0.12106723f, 
    0.05719115f, -0.29930824f, 0.02022293f, -0.04472797f, -0.15167369f, -0.09166503f, 0.04669139f, 0.24624084f, 
    -0.01787379f, 0.03400563f, -0.12364628f, 0.18166323f, 0.29106972f, -0.12580870f, 0.15037818f, -0.06521203f, 
    0.18570860f, -0.15040104f, 0.19885698f, 0.17886859f, -0.36199600f, 0.16545409f, -0.05830630f, -0.13052280f, 
    0.12173311f, -0.06308562f, -0.10120863f, -0.35693252f, -0.09211709f, -0.20493564f, 0.18160482f, -0.34002045f, 
    0.26411617f, -0.27173293f, -0.02827722f, 0.04978025f, -0.04693206f, 0.44673747f, -0.00622628f, -0.10024367f, 
    0.06761961f, 0.07455613f, -0.22116727f, -0.03714156f, -0.08186930f, 0.08291488f, 0.16804934f, 0.38265756f, 
    0.07634016f, 0.20530565f, 0.26884040f, 0.06604958f, 0.27400100f, -0.08171652f, 0.16487803f, -0.01905132f, 
    0.05591254f, 0.07924025f, 0.37049335f, 0.21767929f, 0.08966111f, -0.13006227f, 0.12691416f, 0.10142907f, 
    0.07256956f, -0.10503995f, 0.24173021f, -0.02657275f, 0.04692411f, 0.08446337f, 0.04893125f, 0.15210173f, 
    0.23447461f, 0.27060410f, 0.04282033f, 0.05660239f, -0.00646542f, 0.05383353f, -0.01896260f, -0.04128180f, 
    0.13688102f, 0.34999618f, -0.20198026f, 0.04060078f, 0.28530088f, -0.08655426f, 0.03685154f, 0.18006651f, 
    0.16903831f, -0.12257499f, 0.04206645f, -0.19000740f, 0.20622174f, -0.22853722f, 0.13503367f, -0.06837606f, 
    0.10608674f, 0.01551243f, 0.04911007f, -0.15778692f, 0.10835351f, 0.03945136f, 0.03300181f, 0.25653636f, 
    -0.03024842f, 0.18874316f, -0.07642445f, 0.06403711f, -0.07796737f, -0.25878337f, 0.46605769f, 0.23331310f, 
    -0.04510158f, 0.09605213f, 0.03666370f, -0.21836880f, -0.05210368f, 0.23066056f, -0.35334575f, 0.24444917f, 
    -0.04718947f, 0.06942934f, 0.18544106f, 0.02149449f, -0.02072917f, 0.01454776f, -0.07024281f, -0.40443867f, 
    -0.16570364f, -0.22724110f, 0.24489897f, 0.08731867f, 0.00418075f, -0.31324375f, 0.04919975f, 0.05572412f, 
    -0.12708145f, 0.05402192f, 0.11204512f, 0.05323673f, 0.11877801f, 0.00085672f, -0.14169383f, 0.09500585f, 
    0.09128554f, 0.13995861f, -0.05652601f, 0.04812200f, 0.20420855f, -0.10924032f, 0.02691383f, 0.18507141f, 
    -0.34806219f, 0.19280645f, -0.16700880f, -0.29025874f, 0.12573630f, 0.18749349f, 0.11977032f, -0.34320244f, 
    0.08790623f, -0.20238832f, -0.04343246f, 0.20275810f, -0.04091558f, -0.00265963f, -0.03792410f, 0.28470162f, 
    0.50844204f, -0.28364167f, -0.21121772f, -0.09278300f, -0.08156860f, 0.03431012f, -0.43225244f, 0.39650571f, 
    0.17956731f, -0.05390667f, 0.26690558f, 0.14041740f, -0.15122218f, 0.01087284f, 0.02361492f, 0.15910707f, 
    0.17871730f, 0.06203760f, -0.05691666f, -0.17055437f, 0.19160913f, 0.28507197f, 0.00497883f, 0.26567516f, 
    -0.13983557f, -0.14626333f, 0.01685459f, 0.06041367f, 0.12794550f, -0.26542836f, 0.06434798f, -0.15490651f, 
    0.35316673f, -0.16400659f, -0.00814453f, -0.30369186f, 0.18110704f, 0.20478787f, -0.48275784f, 0.36926693f, 
    0.02460859f, -0.18891546f, -0.17713170f, 0.15028782f, -0.01139594f, 0.05438717f, 0.04444298f, 0.05889877f, 
    0.13859941f, 0.57701218f, -0.13443674f, 0.01152688f, 0.02638306f, -0.11027125f, 0.07954837f, -0.06576069f, 
    -0.08604351f, -0.00782843f, -0.02443342f, -0.06326178f, -0.00076380f, 0.01545790f, -0.00215714f, 0.02542302f, 
    0.02109731f, 0.04637093f, 0.01827084f, 0.00857249f, -0.13096982f, -0.08339947f, -0.02209701f, -0.05010237f, 
    -0.07700442f, -0.03126330f, -0.04608319f, 0.03251747f, -0.04295746f, 0.09135760f, 0.07414612f, -0.06669383f, 
    -0.06557971f, -0.08176996f, -0.03800021f, -0.11978591f, -0.01469330f, -0.15147583f, 0.02838663f, 0.08242343f, 
    -0.06009817f, 0.04648655f, -0.09812190f, -0.12201577f, -0.01011561f, -0.03481618f, 0.02154943f, -0.05839183f, 
    0.04564883f, -0.01738378f, -0.03911107f, -0.09078444f, -0.11085846f, 0.00112135f, -0.09562565f, 0.00414280f, 
    -0.13669041f, -0.02383306f, -0.02139118f, -0.17392270f, 0.09425639f, -0.00204928f, -0.04987194f, -0.04946076f, 
    -0.09095829f, 0.03348105f, -0.01549990f, -0.00561548f, -0.05126573f, -0.05340579f, -0.08462369f, 0.03933516f, 
    -0.03523882f, 0.02940107f, -0.05547899f, -0.01130291f, -0.08185364f, 0.02241527f, 0.01007420f, 0.00301715f, 
    0.01983376f, 0.08639187f, -0.05904899f, 0.06176832f, 0.05920249f, -0.12822001f, -0.03523722f, -0.02282600f, 
    -0.13686834f, -0.07020020f, -0.06127254f, -0.01180550f, -0.02856815f, -0.02973211f, -0.07019842f, 0.07718565f, 
    0.00054806f, -0.02614543f, -0.02869055f, -0.03131180f, -0.01639964f, 0.05920385f, -0.04201565f, 0.01189612f, 
    0.03167413f, -0.08664915f, -0.07477427f, -0.02623674f, -0.02697550f, -0.00099956f, 0.03213835f, 0.00501034f, 
    0.01729473f, -0.14606859f, -0.00622425f, -0.00140876f, -0.07149093f, -0.13306448f, -0.00378255f, 0.02915299f, 
    -0.06998517f, -0.09150174f, 0.00561787f, -0.09153404f, -0.00332365f, -0.06071654f, 0.04284147f, -0.18098432f, 
    -0.05019798f, -0.01773082f, -0.04760224f, -0.06069148f, 0.04428974f, -0.07498416f, -0.11570042f, 0.01582270f, 
    -0.00084697f, 0.02829390f, -0.07025214f, -0.00808639f, -0.02748094f, 0.03308969f, -0.02639321f, 0.06841974f, 
    0.06095399f, -0.05640363f, -0.06994174f, -0.01302031f, -0.10523073f, 0.02272878f, 0.02577687f, -0.04122119f, 
    -0.01144868f, 0.00003355f, -0.09337462f, -0.10227316f, 0.02070994f, 0.00378632f, -0.01416801f, -0.05191842f, 
    -0.02851197f, -0.06704421f, 0.01756964f, -0.03997609f, -0.12533469f, -0.03796314f, 0.00784315f, -0.02678222f, 
    -0.00155409f, -0.07421535f, 0.04208712f, 0.06796020f, -0.08327034f, -0.04221373f, 0.03173780f, -0.04498489f, 
    -0.02552958f, -0.01776866f, 0.05290474f, 0.05639162f, 0.01380271f, -0.10419597f, -0.07322646f, -0.01897010f, 
    -0.03411763f, 0.02149777f, -0.07245063f, -0.00109148f, -0.10595334f, -0.04038505f, 0.03998819f, 0.04856218f, 
    -0.01459538f, 0.03235360f, -0.02209708f, -0.05429173f, 0.00770103f, -0.09506897f, -0.07440332f, 0.05181753f, 
    -0.06645442f, 0.04667758f, 0.03399959f, -0.07620480f, 0.02300618f, -0.09020767f, -0.02508935f, -0.02689609f, 
    -0.07553129f, -0.11507532f, 0.00853250f, -0.09407279f, -0.01805892f, 0.05061409f, -0.08297297f, -0.08807033f, 
    0.02682484f, -0.11246742f, -0.07286819f, -0.01948539f, 0.05793852f, 0.05080145f, -0.10684886f, -0.12382973f, 
    -0.07683852f, -0.03802847f, -0.05159973f, -0.05156976f, -0.00060494f, 0.01416570f, 0.00505242f, -0.00790106f, 
    -0.06415895f, -0.03962484f, -0.10395979f, 0.03421450f, -0.05084941f, -0.08381677f, -0.03018166f, -0.09584080f, 
    -0.03799922f, -0.05939948f, 0.01576503f, 0.01440504f, -0.08949001f, -0.09417062f, -0.01047836f, -0.06745798f, 
    0.07271710f, -0.01642643f, 0.00056666f, 0.01620456f, -0.03057261f, -0.02929384f, 0.02943110f, -0.07827633f, 
    0.00280099f, -0.01621274f, -0.09491011f, 0.01282019f, -0.08422741f, -0.10131779f, 0.00915742f, 0.06436364f, 
    -0.00376071f, -0.06303141f, 0.04854323f, 0.01067618f, 0.02158832f, -0.10758144f, -0.04550843f, 0.04452110f, 
    0.01959529f, 0.00785134f, 0.06209074f, 0.04432039f, 0.01505900f, -0.00148279f, 0.06031621f, -0.08809455f, 
    0.01569764f, -0.08436492f, 0.02431446f, -0.06940299f, 0.01735924f, -0.06130246f, -0.00161219f, 0.01049616f, 
    0.02062019f, 0.02943944f, -0.01971595f, -0.00551321f, -0.01264750f, 0.06192901f, -0.05036400f, -0.09948611f, 
    -0.06083453f, 0.01574385f, 0.03104611f, 0.03401984f, 0.00181839f, 0.02539700f, -0.08644801f, -0.05865117f, 
    0.04331194f, 0.02288641f, -0.03097684f, 0.04576410f, -0.03392310f, -0.11784554f, 0.02754494f, -0.04047573f, 
    -0.07641021f, -0.12529525f, 0.09053942f, 0.00115858f, -0.03818255f, -0.10724568f, -0.05608197f, -0.09656893f, 
    -0.06260571f, 0.00427500f, 0.03549899f, 0.01118365f, -0.02846460f, -0.02489274f, 0.00096129f, 0.01193295f, 
    -0.04582896f, -0.12105275f, -0.06118862f, -0.04281075f, 0.00761439f, -0.01806012f, -0.04779221f, -0.05043444f, 
    -0.00577723f, -0.03188659f, -0.00165166f, -0.09799386f, 0.01434581f, 0.00089773f, 0.05517316f, 0.06022428f, 
    -0.06267954f, -0.00994295f, -0.06100159f, -0.09032267f, 0.11540270f, -0.08748949f, -0.04766254f, -0.01497923f, 
    -0.07081995f, -0.09360123f, 0.05191100f, 0.03047877f, -0.05517273f, 0.04865528f, -0.08215685f, 0.02010074f, 
    -0.11253461f, -0.04944488f, -0.03970918f, -0.06676687f, -0.10021265f, -0.02310286f, -0.06831113f, 0.06902178f, 
    -0.02007729f, 0.01100662f, -0.09374631f, 0.01462642f, -0.01677319f, -0.09827484f, 0.01932772f, -0.04989212f, 
    0.00913945f, -0.00702158f, -0.07304303f, 0.08011304f, -0.05895058f, 0.02270245f, 0.07346616f, 0.04331788f, 
    -0.03899485f, -0.09873274f, -0.04009709f, 0.02402928f, -0.07328267f, 0.06083651f, -0.08443582f, 0.05300004f, 
    0.03818871f, 0.00643866f, -0.04401594f, -0.09341428f, -0.01735972f, -0.02907779f, 0.03354863f, 0.05262846f, 
    0.02591600f, 0.03644732f, -0.08871555f, 0.07316253f, 0.05481095f, -0.08201890f, -0.01005032f, -0.08449689f, 
    0.01173102f, -0.00458674f, -0.02889400f, -0.03211184f, -0.01057882f, -0.09278420f, 0.06420880f, -0.05122645f, 
    -0.07606412f, -0.07744125f, -0.08099186f, 0.02595379f, -0.03407383f, -0.10170899f, 0.02705637f, -0.02897089f, 
    0.01748092f, 0.00724332f, 0.02270537f, -0.00565837f, -0.10085162f, 0.01519466f, 0.05004221f, 0.02595131f, 
    -0.04936690f, -0.02895345f, -0.07184371f, -0.05382372f, -0.01276084f, -0.01402806f, -0.01954375f, 0.02554418f, 
    -0.10054635f, -0.05174772f, -0.00989027f, -0.03929690f, 0.08195677f, -0.06050745f, 0.01575638f, 0.05506154f, 
    -0.05117909f, -0.02497697f, 0.07979027f, 0.00211970f, -0.06915101f, 0.02100621f, 0.01388591f, -0.03624425f, 
    -0.04306246f, 0.01199573f, 0.06577964f, -0.05753920f, -0.08566149f, 0.03963216f, -0.05982157f, -0.05470379f, 
    -0.05939071f, -0.04761825f, 0.05002259f, 0.01027524f, -0.00328205f, -0.03870795f, 0.07433483f, 0.00012484f, 
    -0.05650470f, -0.09673115f, -0.01661208f, -0.06045191f, -0.00627070f, -0.04484060f, 0.06048655f, -0.03987482f, 
    0.06053474f, 0.06530785f, -0.03459386f, 0.04517822f, -0.06522176f, -0.04054899f, -0.07628677f, -0.00471422f, 
    0.07388368f, -0.03206716f, 0.01791612f, -0.07237653f, -0.07641301f, -0.00542523f, 0.00597846f, -0.02738639f, 
    -0.04582376f, -0.05707680f, 0.02726919f, -0.05511364f, 0.02131398f, 0.03315463f, 0.00911144f, -0.06099953f, 
    -0.01867276f, 0.04475723f, 0.03764303f, 0.06732699f, -0.06600422f, -0.07016304f, 0.08758043f, -0.05733911f, 
    0.03480228f, -0.03355943f, -0.04876315f, 0.05038883f, 0.06142604f, -0.00732383f, 0.03300186f, 0.01963234f, 
    -0.12409269f, 0.05924345f, -0.16802454f, 0.09698106f, 0.02851878f, 0.14408323f, -0.03490957f, 0.09491747f, 
    0.01328297f, 0.05575860f, -0.02614698f, -0.09781748f, 0.01594026f, 0.06707051f, 0.03465422f, 0.28083265f, 
    0.04074315f, 0.10199204f, 0.11004092f, 0.04644276f, 0.00011593f, 0.43361482f, -0.03373465f, 0.37299666f, 
    0.29247895f, 0.01031484f, 0.16116461f, -0.09907980f, 0.02404512f, 0.05895782f, 0.05039226f, -0.07082107f, 
    -0.04404537f, 0.02147288f, 0.09543011f, 0.14626169f, 0.26678824f, -0.09820266f, -0.06033321f, -0.17702577f, 
    -0.05650225f, -0.07812532f, 0.14926873f, 0.11590083f, 0.18963960f, 0.12969090f, -0.24611539f, 0.03271594f, 
    0.14099151f, -0.01430155f, -0.02906461f, 0.24963933f, -0.13384737f, 0.03349232f, 0.29954860f, 0.19532949f, 
    0.00058451f, 0.27560133f, 0.13883218f, -0.28369656f, 0.24790186f, 0.33567855f, 0.15196387f, -0.11179846f, 
    0.03527634f, 0.00484720f, -0.01564830f, 0.06706671f, 0.10045061f, 0.03609823f, 0.01233999f, 0.33683005f, 
    0.21147780f, -0.01775452f, -0.11081701f, -0.15651557f, -0.06144467f, -0.07758411f, -0.04911900f, 0.18153381f, 
    0.14949727f, 0.03489876f, 0.07936117f, 0.14285326f, -0.14154331f, 0.02028817f, -0.00877671f, 0.17212340f, 
    0.22671568f, 0.20162348f, -0.01918179f, -0.17903085f, -0.04549542f, 0.20353831f, 0.03611283f, 0.04829869f, 
    -0.08718293f, -0.04257224f, 0.01550939f, -0.04691861f, 0.08141237f, 0.00219111f, -0.03102801f, -0.09295674f, 
    0.27017456f, -0.15156144f, 0.00167530f, -0.06425804f, 0.07518444f, 0.26128283f, -0.06555344f, 0.16779917f, 
    0.12531400f, -0.23959211f, -0.11321583f, 0.43400148f, -0.13962458f, 0.09833086f, 0.03824739f, 0.19385818f, 
    0.00185053f, 0.26653284f, 0.02754864f, 0.16492066f, 0.07219288f, 0.06914781f, -0.03694452f, -0.04293139f, 
    -0.20755677f, -0.01996227f, 0.21645199f, -0.09092768f, 0.35156465f, 0.07563262f, 0.02147903f, -0.10341053f, 
    -0.38807932f, 0.30969077f, 0.03010580f, -0.11971393f, 0.09262223f, -0.32929441f, -0.01313632f, 0.16153532f, 
    0.04233822f, 0.14609915f, -0.13157164f, 0.04456336f, -0.13775223f, -0.04525815f, -0.03831552f, 0.11513858f, 
    -0.06389879f, -0.05863850f, 0.01732383f, 0.06579776f, 0.07865289f, 0.03477403f, 0.12762953f, -0.18135501f, 
    -0.13723551f, -0.07090260f, 0.18573427f, -0.04416025f, -0.12310161f, -0.12601380f, -0.21495371f, 0.08993584f, 
    -0.12691855f, 0.09764346f, 0.19153085f, -0.04173037f, 0.12432320f, -0.11396423f, -0.07544258f, 0.06435455f, 
    0.02454430f, -0.16988966f, 0.24476621f, -0.13933489f, 0.57799321f, 0.01037080f, 0.04081118f, 0.05595699f, 
    0.03153962f, 0.14247297f, -0.87694383f, 0.46305010f, 0.00248267f, -0.06977381f, 0.09086441f, -0.42451480f, 
    0.06852299f, 0.12397552f, 0.02065663f, 0.04530459f, 0.01712137f, -0.17815748f, 0.06745024f, 0.21626966f, 
    -0.07375909f, -0.44163403f, 0.04740123f, -0.19387347f, -0.02778238f, 0.22697902f, -0.24156702f, 0.02357492f, 
    0.18516444f, 0.02270702f, -0.25145262f, 0.13359590f, 0.05177051f, 0.05506759f, -0.03853054f, -0.14803150f, 
    -0.01583487f, -0.05154502f, 0.01929194f, -0.24883093f, -0.57311291f, 0.17526640f, 0.00717164f, 0.14135443f, 
    0.19406326f, 0.18853486f, 0.12299508f, -0.02074196f, 0.07373936f, 0.07772201f, 0.04330069f, 0.06986944f, 
    -0.23020786f, 0.05534141f, 0.06092595f, -0.36841139f, 0.08537009f, 0.10887811f, -0.12311691f, 0.39118654f, 
    -0.12515301f, 0.09436718f, -0.04675760f, 0.10871305f, -0.22378278f, -0.09287943f, 0.08572561f, 0.07343546f, 
    -0.07625653f, 0.21493377f, 0.03870441f, -0.09571004f, 0.04246401f, -0.13420847f, 0.08211771f, 0.02016483f, 
    -0.41964120f, -0.17086600f, 0.20596600f, 0.09645388f, 0.20279773f, -0.08528562f, -0.11649022f, -0.14376365f, 
    0.06061253f, -0.09175131f, 0.05935882f, -0.20368584f, -0.17963703f, 0.04724896f, -0.21342358f, 0.08691763f, 
    0.03146553f, -0.13373424f, -0.05838904f, 0.10506178f, -0.03431788f, 0.03785667f, -0.23169577f, -0.00098285f, 
    0.14723857f, -0.31004703f, 0.23784748f, 0.18623930f, -0.07747353f, 0.05275144f, 0.13918571f, -0.03019342f, 
    -0.10124408f, 0.18295024f, 0.11581027f, 0.24353875f, 0.08642632f, 0.22651364f, 0.13812834f, 0.00327092f, 
    -0.27057621f, -0.06382491f, 0.15174310f, 0.14127974f, 0.01272785f, -0.07135887f, -0.49193716f, 0.11846729f, 
    0.11818733f, 0.11132594f, -0.16907384f, -0.07784638f, 0.26764607f, 0.18957718f, 0.16477440f, 0.02764527f, 
    -0.10001153f, 0.08076269f, 0.25344276f, -0.20519854f, 0.03427642f, 0.12656006f, 0.16385405f, 0.21643789f, 
    -0.09575852f, -0.14764196f, 0.00075408f, 0.26574180f, -0.00573291f, 0.10897472f, -0.05807052f, 0.24892358f, 
    0.31650689f, -0.21406849f, 0.03065176f, -0.04796398f, 0.04375072f, 0.34981054f, -0.13413134f, 0.08868946f, 
    -0.02532673f, -0.25544295f, -0.35057104f, 0.03646174f, 0.06799730f, -0.03436609f, -0.12954637f, -0.21324347f, 
    -0.03184671f, 0.23094937f, -0.28270921f, 0.08162513f, -0.12253544f, -0.02396522f, -0.00256516f, -0.40180182f, 
    0.08535081f, 0.19414285f, 0.01940322f, -0.03635694f, 0.14981611f, -0.02672096f, 0.02808110f, 0.35466909f, 
    0.13696329f, -0.26055664f, -0.16091830f, -0.25676331f, -0.02273032f, 0.07056881f, -0.22855502f, -0.27794114f, 
    0.30691969f, -0.06130104f, 0.16703844f, -0.04112054f, -0.11623580f, 0.17890590f, -0.00881806f, 0.09390937f, 
    -0.08396185f, 0.15654042f, -0.27732894f, 0.11957372f, -0.10208284f, 0.08970057f, -0.17964737f, -0.04747994f, 
    0.23333506f, 0.01254808f, -0.22499421f, 0.14294270f, -0.06851599f, 0.15865122f, -0.10793193f, 0.20107503f, 
    0.23841152f, -0.15718639f, -0.25449166f, 0.11155208f, -0.11185446f, -0.14163113f, 0.19525088f, 0.13439782f, 
    -0.17591098f, -0.00145036f, 0.27309132f, -0.05790400f, -0.01911668f, 0.04428793f, -0.26196453f, 0.24578525f, 
    -0.01965519f, 0.14534676f, 0.32900271f, 0.01069497f, 0.00928980f, -0.22002588f, 0.04800866f, -0.05014120f, 
    -0.27095249f, -0.11817919f, 0.12508185f, 0.36567771f, 0.01732770f, -0.13982536f, 0.30161971f, -0.09587639f, 
    -0.19870514f, -0.01518421f, 0.22720456f, 0.09962614f, 0.07421693f, 0.14743514f, -0.06005391f, -0.09560654f, 
    0.07745091f, 0.28958130f, -0.15348552f, 0.11577474f, 0.13143906f, 0.01169110f, 0.03749959f, 0.04306407f, 
    -0.38290983f, 0.17980883f, 0.15303838f, -0.01274447f, 0.06335977f, 0.13299033f, 0.09286029f, -0.14406563f, 
    -0.01090595f, -0.06403547f, 0.04501009f, 0.04359442f, 0.01874423f, 0.26877126f, -0.15727963f, 0.32265729f, 
    0.26215801f, -0.45405421f, 0.00642125f, 0.23215324f, 0.08412218f, -0.12544475f, -0.22246933f, 0.26597181f, 
    -0.02236580f, -0.36213520f, 0.37752438f, 0.13761427f, -0.28539029f, -0.01143937f, 0.07553965f, 0.07162641f, 
    0.15514138f, 0.34695995f, 0.18347724f, -0.00680234f, 0.46360022f, 0.09848898f, -0.15222262f, 0.05896362f, 
    0.00182443f, 0.03705635f, 0.02855948f, -0.06815850f, 0.15716363f, -0.17999141f, 0.08803996f, -0.29692572f, 
    0.40151092f, -0.16675840f, 0.05463863f, -0.43407565f, 0.23452921f, 0.06691197f, -0.49127209f, 0.05360866f, 
    0.07060537f, -0.26693943f, -0.07700184f, 0.01729895f, 0.33485922f, 0.20784648f, -0.04361616f, 0.11942060f, 
    -0.09366256f, 0.22690651f, -0.11566407f, 0.18738112f, -0.05310450f, 0.00985766f, 0.03508333f, -0.04831144f, 
    -0.07386634f, -0.00070027f, -0.10898271f, -0.06671681f, 0.07035097f, 0.05129380f, -0.03709808f, -0.00204053f, 
    0.02476871f, -0.00071015f, 0.03609300f, 0.06887520f, 0.03640540f, 0.03040331f, -0.01937042f, -0.09872071f, 
    -0.11028709f, 0.07492904f, -0.07321215f, 0.00640193f, -0.01457883f, 0.02390525f, -0.01055586f, 0.01547037f, 
    -0.08423965f, -0.00033244f, -0.08852849f, -0.00405697f, 0.00923283f, -0.09313605f, 0.04601808f, -0.04586292f, 
    -0.01753423f, -0.10835832f, -0.03410753f, 0.05295368f, -0.01709167f, 0.05306740f, -0.00081387f, -0.02846513f, 
    -0.05407283f, 0.02910054f, -0.09259618f, -0.11004473f, 0.04977479f, -0.06583764f, 0.01299496f, -0.08789041f, 
    -0.06158892f, 0.05750411f, 0.06464268f, 0.03553564f, 0.07602701f, 0.02361179f, -0.00488114f, -0.03656469f, 
    -0.02863180f, 0.03902235f, -0.01367810f, 0.05272700f, -0.08991791f, 0.05958145f, 0.00529539f, -0.03096123f, 
    -0.08302315f, -0.00604849f, -0.03421820f, -0.08200294f, 0.07439973f, 0.03002855f, -0.02131083f, 0.00400571f, 
    -0.08391805f, -0.07275633f, 0.05113213f, 0.05388889f, -0.06517460f, -0.03185208f, 0.03818494f, -0.01118693f, 
    -0.01991973f, 0.02085591f, 0.00546960f, -0.05408059f, -0.05412387f, -0.00000787f, 0.05717979f, -0.04310738f, 
    -0.08017410f, 0.00837296f, -0.00966830f, -0.08494266f, -0.02093020f, -0.07703128f, 0.00320064f, 0.03623931f, 
    -0.00675235f, -0.04653802f, -0.07003482f, -0.06588923f, 0.03117093f, -0.08341949f, -0.00726411f, -0.03757448f, 
    -0.00090341f, -0.07238287f, -0.00704955f, -0.01488213f, 0.06149937f, -0.02684304f, -0.03784057f, -0.10199784f, 
    -0.02705481f, 0.06773206f, -0.02346875f, 0.03250429f, 0.06661600f, -0.08653397f, 0.07601460f, -0.06449267f, 
    -0.07732361f, -0.02198317f, -0.10138723f, -0.01146924f, -0.11927617f, 0.02550152f, -0.06975099f, 0.08645339f, 
    0.14889511f, -0.09314478f, 0.20543322f, -0.01378831f, -0.17723076f, 0.12644741f, 0.03872087f, 0.37199497f, 
    0.19852188f, -0.22346033f, -0.30023420f, -0.24459893f, -0.38902977f, -0.04586697f, -0.43095660f, 0.21655682f, 
    -0.12019268f, -0.33627304f, 0.36705893f, 0.09268630f, 0.06611208f, 0.09436488f, -0.14280100f, -0.04024829f, 
    0.15965255f, -0.00644490f, 0.26662391f, 0.03224762f, -0.04060726f, -0.23545681f, -0.11507009f, -0.07948281f, 
    -0.06396193f, 0.21560076f, 0.00171324f, 0.17826745f, 0.12699662f, 0.13633770f, 0.33054632f, -0.01970122f, 
    -0.10109051f, -0.04437253f, 0.30063304f, 0.04191331f, 0.03428157f, -0.17752385f, -0.17233396f, -0.13984396f, 
    0.15179323f, 0.36140805f, -0.13012940f, 0.02386938f, -0.42008606f, 0.01029345f, -0.04648183f, 0.04844919f, 
    -0.28086016f, 0.16371946f, 0.55173600f, -0.26977602f, -0.21099317f, 0.19928557f, 0.13787691f, -0.27821949f, 
    -0.06026538f, 0.08194170f, 0.01946972f, 0.07825391f, -0.02172784f, -0.00921568f, -0.08705164f, 0.18015787f, 
    0.26103643f, -0.04627790f, 0.01015366f, -0.05383636f, -0.06631130f, 0.15829128f, 0.14619598f, 0.21009345f, 
    0.01147869f, -0.37944308f, 0.23592077f, -0.00683771f, -0.22814187f, -0.02738333f, -0.09622709f, -0.12840313f, 
    0.06771064f, 0.24725837f, 0.18320045f, -0.12281622f, 0.24484426f, -0.09047464f, -0.19877024f, 0.13143568f, 
    -0.00981572f, -0.02079000f, 0.03661745f, 0.03485233f, 0.11567257f, -0.13495475f, -0.00587312f, -0.21554956f, 
    0.55288661f, -0.27660537f, 0.00595652f, -0.14997181f, -0.06201828f, -0.00443223f, -0.35309896f, 0.07108232f, 
    0.22864470f, -0.06644211f, -0.04216761f, 0.01996117f, 0.27827674f, -0.00848293f, -0.02364081f, 0.17151254f, 
    0.18086451f, 0.39823702f, -0.10262760f, 0.18845347f, 0.36993816f, 0.19302410f, 0.11825625f, -0.00958541f, 
    -0.05015410f, 0.00914281f, -0.05954588f, -0.00904333f, 0.04954422f, 0.06032244f, 0.00997888f, 0.02945631f, 
    0.01343167f, -0.05204364f, -0.09066796f, 0.05711056f, 0.02147445f, -0.10941992f, -0.08403559f, -0.04302114f, 
    0.01016486f, -0.05691274f, 0.06041811f, -0.04281747f, 0.04086783f, 0.07277652f, -0.11319059f, -0.09212278f, 
    -0.09188266f, -0.02753926f, -0.11060196f, 0.06594680f, 0.02730303f, 0.02447742f, -0.11381473f, -0.01161588f, 
    -0.09221760f, -0.08460308f, 0.01848070f, -0.03378658f, -0.05838939f, 0.04242575f, -0.04504961f, 0.00563852f, 
    0.02246490f, 0.05887798f, -0.08123711f, -0.07482502f, -0.06914575f, -0.00336509f, -0.08135147f, -0.01207284f, 
    0.06632544f, 0.04646393f, -0.06895737f, -0.04500137f, 0.02172742f, -0.05048397f, 0.00030546f, 0.00582575f, 
    0.04856257f, -0.07965933f, -0.06561365f, -0.06167142f, -0.01254642f, -0.01772294f, -0.01433227f, -0.08933354f, 
    -0.04916639f, 0.01719360f, 0.06912102f, -0.08095334f, 0.00981756f, -0.09535397f, -0.03238834f, 0.03743844f, 
    0.08606463f, 0.04441417f, 0.03098461f, -0.00254453f, 0.03097736f, 0.01426574f, 0.00025050f, -0.06963298f, 
    -0.07560839f, -0.06539012f, -0.03678487f, -0.10298733f, -0.01977731f, 0.08024812f, -0.10883788f, -0.10389283f, 
    -0.11336980f, 0.01758379f, 0.05672877f, 0.03936994f, 0.07110090f, -0.06905302f, -0.08609386f, -0.03136265f, 
    0.03031944f, -0.01991185f, 0.01269519f, -0.01510404f, -0.02608640f, 0.00642841f, -0.05011947f, -0.06511384f, 
    -0.03075366f, -0.04562637f, 0.05015438f, 0.05034080f, -0.06540530f, 0.01973089f, -0.00884510f, 0.03691092f, 
    -0.06457341f, 0.05627936f, -0.05836223f, 0.04183617f, 0.01276983f, -0.04647737f, 0.01471786f, 0.06534730f, 
    0.03958818f, 0.00831253f, -0.11402732f, -0.05924622f, -0.06095637f, 0.04343017f, -0.05636769f, 0.06405699f, 
    0.18457669f, -0.06663954f, 0.16171406f, 0.08490810f, 0.04754839f, 0.15685745f, -0.05083761f, 0.01699258f, 
    -0.02259982f, 0.03779367f, 0.05964412f, -0.05290456f, 0.05783749f, -0.06480707f, -0.18362933f, -0.14521216f, 
    -0.12900780f, -0.06197743f, -0.02317434f, 0.14828846f, -0.06558745f, -0.04735228f, 0.09239434f, -0.37747565f, 
    -0.32295638f, 0.16483741f, 0.02431051f, 0.04383532f, -0.03419393f, -0.07506515f, 0.10862324f, 0.14649788f, 
    0.10294165f, 0.24745922f, 0.06808701f, -0.08450431f, -0.05399853f, 0.02132588f, 0.26781729f, 0.23163705f, 
    -0.01742811f, 0.10798652f, 0.02163406f, 0.12671508f, -0.24488260f, -0.04599370f, 0.22332424f, 0.00403352f, 
    0.13884941f, 0.04893040f, -0.03556844f, -0.00963674f, -0.07652842f, 0.24472505f, -0.39242473f, -0.07590312f, 
    -0.01377476f, -0.04334761f, -0.36890423f, 0.36686057f, -0.27733365f, -0.17935376f, 0.05091362f, 0.05786120f, 
    0.11470502f, 0.22471289f, 0.08386826f, 0.06147009f, 0.02640321f, 0.08583976f, 0.02887808f, -0.02649444f, 
    -0.29510143f, 0.20604835f, 0.15937988f, 0.29140419f, -0.12212798f, 0.15195058f, -0.02341396f, -0.17131786f, 
    -0.10490310f, -0.01420820f, -0.17299704f, -0.12121452f, 0.19361290f, 0.01357237f, 0.12117108f, -0.10034251f, 
    -0.10222485f, -0.11647781f, 0.16226162f, -0.00802619f, -0.12504564f, -0.09311035f, 0.04485017f, 0.33508480f, 
    0.26810682f, 0.15917261f, -0.04071189f, 0.00215951f, -0.11499719f, 0.13755444f, -0.06213288f, 0.16822353f, 
    -0.36692163f, 0.30896863f, 0.01120098f, 0.00863161f, -0.07463889f, -0.11112367f, 0.00383597f, 0.24034068f, 
    -0.04408094f, 0.22761239f, 0.13677433f, -0.33424035f, 0.23617193f, -0.13055120f, -0.02158001f, -0.32544491f, 
    0.03378675f, -0.11328684f, 0.15525238f, -0.05230967f, -0.04430426f, 0.05948048f, 0.17426938f, -0.02978279f, 
    -0.07097127f, 0.05968649f, 0.03702820f, 0.00975808f, -0.08864931f, 0.07990463f, 0.01044748f, -0.00403278f, 
    -0.04936481f, -0.01945182f, -0.06866590f, -0.04348799f, -0.04577773f, 0.07613230f, -0.07561482f, 0.02968266f, 
    -0.07803053f, -0.02970814f, 0.02419928f, 0.00558964f, -0.07331084f, -0.03739552f, -0.03047459f, -0.06589285f, 
    -0.04421010f, -0.03042722f, 0.02379844f, -0.01141345f, 0.05843503f, 0.06316007f, -0.05276728f, -0.05608912f, 
    0.05092370f, 0.01353178f, -0.02090965f, 0.01750644f, -0.09189131f, 0.07446419f, 0.08456939f, 0.00554369f, 
    -0.01835510f, -0.04875927f, -0.07479408f, 0.06915871f, -0.04054937f, 0.07986778f, -0.00952386f, 0.08684192f, 
    0.03413452f, 0.07026347f, 0.03152945f, -0.06670818f, -0.05487053f, -0.08400673f, 0.03694724f, -0.07252052f, 
    0.03396075f, -0.02460922f, 0.04550724f, 0.02565991f, -0.00228433f, 0.00213556f, 0.00393964f, 0.04225759f, 
    0.03290005f, -0.02485288f, -0.00120400f, -0.01452205f, -0.03010532f, 0.02749632f, 0.01020118f, -0.03025224f, 
    0.01407022f, 0.06798232f, -0.07794945f, -0.04135362f, -0.05801066f, -0.04730920f, -0.07841202f, -0.06009254f, 
    -0.00580360f, -0.08902273f, 0.08792392f, -0.05382119f, -0.03166287f, -0.02078572f, 0.00151536f, -0.07127270f, 
    0.03028144f, -0.02716168f, 0.07499719f, 0.03842100f, -0.08067287f, 0.05273184f, 0.08003528f, -0.08779291f, 
    -0.03007964f, -0.00348046f, 0.01201994f, 0.01731704f, -0.02312300f, -0.02423498f, -0.08808103f, 0.07636254f, 
    -0.03375526f, -0.03341814f, -0.01121762f, 0.00949315f, -0.05542374f, -0.01224759f, -0.06969283f, 0.06416631f, 
    -0.01277608f, -0.02868053f, 0.05015674f, -0.07337720f, -0.01491106f, -0.09165760f, -0.00349726f, 0.00328261f, 
    -0.03525700f, -0.00190278f, -0.00870113f, 0.02248835f, -0.05159783f, -0.08161137f, 0.01731675f, -0.08271597f, 
    -0.19034362f, -0.03051177f, 0.36913303f, 0.01672729f, 0.23219688f, -0.16825828f, 0.04256624f, -0.04941173f, 
    -0.07507686f, 0.27988154f, 0.10737979f, -0.36121944f, 0.10484264f, 0.14390390f, -0.46559617f, 0.16411851f, 
    0.05338005f, 0.09720825f, -0.13327459f, 0.08520629f, 0.09013949f, 0.08149679f, -0.19175164f, -0.05472897f, 
    0.27562502f, 0.07176128f, -0.01207481f, -0.12195620f, -0.00153772f, 0.18073244f, -0.31711560f, 0.17459652f, 
    0.10538463f, 0.21959363f, -0.04389296f, 0.05034187f, 0.14097470f, 0.30809438f, -0.15153447f, 0.19047004f, 
    0.09975210f, -0.08617628f, -0.01801472f, -0.05769860f, 0.36613435f, 0.03212477f, 0.05751684f, -0.24164787f, 
    -0.13814700f, 0.08346656f, 0.06021911f, -0.14225776f, 0.37778383f, 0.05271200f, 0.22066401f, 0.14035039f, 
    0.10272222f, 0.10182519f, 0.55760705f, -0.19897179f, -0.03086763f, 0.10392954f, 0.09811576f, 0.33332312f, 
    0.08156975f, 0.23519213f, -0.04749209f, 0.03061340f, 0.03462086f, -0.49306625f, -0.06247029f, 0.05886463f, 
    -0.09926856f, -0.11150134f, 0.04009004f, 0.00985886f, -0.05607079f, 0.07850378f, -0.06019453f, -0.31919336f, 
    0.00332101f, -0.21831992f, -0.20654757f, -0.09830667f, 0.10943920f, -0.07666849f, -0.19283888f, 0.10384744f, 
    -0.03360352f, -0.25987515f, 0.04629400f, -0.03596304f, -0.43733642f, -0.13732708f, 0.08235413f, 0.14684315f, 
    0.02988539f, 0.10895154f, 0.02113056f, 0.03590117f, -0.03537120f, 0.01510431f, -0.05664439f, 0.40450767f, 
    -0.20051278f, 0.33789572f, 0.06885104f, -0.06643412f, -0.08379584f, 0.01342889f, -0.03178409f, 0.13146366f, 
    0.05933650f, 0.16152973f, 0.06614709f, 0.12355917f, -0.37165326f, 0.14876172f, -0.03535008f, 0.05539891f, 
    -0.28507710f, -0.15334411f, 0.02649544f, 0.03400138f, 0.17240427f, -0.00680244f, -0.04061118f, 0.02882319f, 
    -0.17868514f, -0.31282443f, -0.09447508f, 0.06321301f, 0.37018287f, -0.14724138f, 0.01209704f, -0.05459805f, 
    -0.00011238f, 0.06334696f, 0.06185869f, 0.04023300f, 0.36304775f, 0.04772087f, -0.38399270f, -0.10873335f, 
    -0.16084988f, 0.06471995f, -0.03520244f, 0.13185702f, 0.04366598f, -0.10761494f, -0.12464727f, 0.08429178f, 
    0.15131956f, -0.01872146f, -0.00164416f, 0.13083667f, 0.15610223f, 0.06418458f, -0.01217149f, 0.03900696f, 
    -0.02132105f, 0.12399676f, 0.08185193f, -0.01388140f, 0.10474850f, 0.17475364f, 0.03036685f, 0.19647852f, 
    -0.24148355f, -0.09254326f, -0.06635234f, 0.24107295f, 0.11109847f, -0.04679891f, 0.08447228f, -0.14156535f, 
    0.17781973f, 0.06526286f, -0.01610702f, 0.01084941f, -0.36605614f, 0.09762817f, 0.15044293f, -0.01470682f, 
    0.11996619f, -0.08606396f, 0.17653438f, 0.17784369f, 0.04332177f, -0.21511014f, 0.10305559f, -0.02391944f, 
    -0.04945150f, 0.04682022f, 0.07561505f, 0.14527048f, 0.03552042f, -0.09069731f, 0.08578630f, 0.04153932f, 
    -0.20810537f, -0.16484374f, 0.01486053f, 0.21183075f, 0.00035906f, -0.02284751f, -0.17335467f, -0.04532272f, 
    0.13619941f, -0.01053672f, -0.25805119f, 0.06755210f, 0.41084915f, -0.01426457f, -0.16988739f, 0.14739434f, 
    0.02054370f, 0.16009960f, 0.15758348f, 0.19687560f, -0.02146384f, -0.28145081f, -0.15296480f, -0.00053509f, 
    -0.12966807f, 0.24129495f, -0.00615890f, -0.00647866f, 0.01348648f, 0.09634039f, 0.00450000f, 0.34871981f, 
    -0.11751634f, 0.40928560f, -0.04545307f, -0.26654348f, -0.26929304f, -0.03609993f, -0.20213859f, -0.31069911f, 
    -0.05090029f, 0.24911551f, 0.05647005f, -0.15961887f, -0.06495611f, 0.12739223f, 0.05066457f, 0.08609682f, 
    -0.36131954f, -0.42843273f, 0.00114124f, -0.18110672f, 0.16384356f, 0.00046589f, -0.04527232f, 0.01837072f, 
    -0.27407345f, -0.01853655f, -0.00180037f, -0.01719009f, -0.07729978f, -0.25631833f, 0.00919666f, -0.10654474f, 
    0.37199455f, -0.23163854f, -0.24934235f, 0.08158872f, 0.32614422f, -0.04157985f, 0.00472618f, -0.09081197f, 
    -0.28027472f, 0.25181842f, 0.04358139f, -0.02592368f, -0.06835622f, 0.00568890f, -0.15023911f, 0.18495931f, 
    0.08532572f, -0.49365681f, 0.14868611f, 0.02818720f, -0.14537261f, 0.02804309f, 0.12381169f, -0.13028677f, 
    -0.11869197f, 0.10370161f, 0.20419750f, 0.20987551f, 0.10935409f, -0.01159501f, 0.37393525f, -0.22000983f, 
    0.02951150f, 0.06326627f, -0.02792338f, 0.24453992f, 0.00933622f, -0.07222224f, -0.91303688f, -0.06811906f, 
    0.20335998f, 0.17323892f, -0.13955604f, 0.24911298f, -0.07035995f, 0.11857764f, 0.02965297f, 0.04387286f, 
    -0.14829819f, 0.21370007f, 0.24070427f, -0.28478959f, 0.15095501f, -0.05382904f, 0.09532897f, -0.13782530f, 
    -0.13044569f, 0.04577407f, -0.03440539f, 0.01285597f, 0.02747288f, 0.25885144f, 0.01097710f, 0.26846424f, 
    -0.10091367f, -0.10553658f, -0.05585603f, 0.32749918f, 0.04436626f, -0.06498811f, -0.07438727f, -0.21618861f, 
    0.08804850f, -0.36415941f, -0.27119693f, 0.04991223f, -0.08033367f, 0.00780799f, -0.02536019f, 0.18466030f, 
    0.05008735f, 0.04989157f, -0.26329035f, 0.23229636f, 0.14179496f, 0.04739389f, -0.26091942f, -0.27866304f, 
    -0.01733308f, 0.09072559f, -0.11108397f, 0.06864204f, 0.01025874f, 0.09462625f, -0.04633255f, 0.33814859f, 
    -0.09749119f, 0.26660189f, -0.15558694f, -0.19242047f, -0.43118635f, 0.03636155f, -0.23906031f, -0.40232179f, 
    -0.02318577f, -0.08426620f, 0.02005641f, -0.08232933f, -0.29531974f, 0.14923717f, -0.00010725f, 0.00522033f, 
    -0.16129132f, -0.38781869f, -0.04729575f, 0.07310729f, 0.21006408f, -0.12412025f, -0.34385407f, -0.04896834f, 
    0.29856259f, -0.19106627f, 0.07571222f, -0.04986253f, -0.12935989f, 0.04146158f, 0.16569571f, 0.36190534f, 
    0.10618313f, -0.03898563f, -0.05991025f, -0.01472259f, -0.13359696f, -0.04123735f, -0.42736107f, 0.12385584f, 
    -0.32795471f, -0.23117590f, 0.32458261f, 0.01774130f, 0.07155231f, 0.12597565f, -0.37532067f, 0.06039143f, 
    0.36509439f, 0.14296593f, 0.12890261f, 0.20696132f, 0.01861268f, -0.04220996f, -0.51800871f, -0.11947531f, 
    0.08064841f, 0.25851688f, 0.08880795f, 0.35186452f, 0.22916777f, 0.26904482f, 0.37511939f, 0.14677866f, 
    -0.08454636f, 0.05319188f, 0.03214711f, 0.26509917f, 0.20943280f, -0.04423930f, -0.08986646f, -0.34109089f, 
    0.03556426f, 0.16233896f, -0.26108471f, 0.09442461f, -0.43866661f, -0.02471405f, 0.09215827f, 0.03562327f, 
    -0.14892991f, 0.16179752f, 0.69112802f, -0.49187011f, -0.11302695f, 0.01807669f, 0.16158535f, -0.13766703f, 
    0.02672011f, 0.12358605f, -0.01095845f, 0.25654167f, -0.04353375f, -0.17525704f, -0.02473978f, 0.13251536f, 
    0.40589744f, -0.13700910f, 0.00922920f, 0.15189672f, -0.03714558f, -0.18597797f, 0.03205436f, 0.10761300f, 
    0.00950159f, -0.48846596f, 0.32055458f, -0.13721266f, -0.19854201f, 0.06487093f, -0.37529552f, 0.04434404f, 
    0.17797516f, 0.22122084f, 0.13013762f, 0.11877798f, 0.65077150f, -0.18386412f, -0.12348284f, 0.21058515f, 
    -0.05685641f, -0.24061763f, -0.01050924f, 0.02269667f, 0.19702579f, -0.45939404f, 0.07239331f, -0.02957038f, 
    0.55247265f, -0.14470054f, -0.02991850f, -0.24940166f, -0.18255217f, -0.00845846f, -0.21812765f, -0.02779736f, 
    0.17764775f, 0.02508331f, -0.01677794f, 0.16005096f, 0.14086488f, 0.02509257f, 0.07047112f, 0.11736368f, 
    -0.12244859f, 0.14109185f, -0.02805714f, 0.08584126f, 0.10415932f, 0.19724642f, 0.10654395f, -0.00521252f, 
    -0.00443291f, 0.02940236f, -0.07817505f, 0.02666315f, 0.03733457f, -0.02818060f, -0.04048787f, -0.03915465f, 
    0.05736041f, -0.09398746f, -0.03938016f, -0.07381988f, -0.02773382f, -0.11172522f, -0.03492105f, 0.07631799f, 
    -0.09724172f, 0.01188855f, 0.03261871f, -0.02457477f, -0.04964924f, -0.02897672f, 0.03000610f, -0.07705113f, 
    0.01333584f, -0.08580443f, 0.00568275f, 0.07251016f, -0.10420667f, -0.06203810f, 0.06721578f, -0.00471879f, 
    -0.11480733f, -0.10916140f, 0.02411088f, -0.01451796f, -0.09739283f, -0.08676024f, -0.03768821f, -0.08177731f, 
    0.03739807f, 0.01990297f, -0.03604276f, -0.07487440f, 0.02831339f, 0.01852704f, -0.07738883f, -0.06254038f, 
    -0.02149775f, -0.04309935f, -0.09074888f, 0.06185916f, -0.04771348f, 0.05621057f, 0.03887716f, -0.00409534f, 
    0.03230966f, -0.04356138f, -0.07626130f, 0.05339818f, -0.04428526f, -0.05777234f, -0.02498594f, 0.04747870f, 
    -0.01770415f, -0.08271547f, -0.07710984f, 0.02013792f, 0.07887046f, 0.02312271f, -0.00427399f, -0.05741959f, 
    -0.06747879f, 0.04654767f, 0.03321889f, -0.03608613f, -0.03034273f, -0.03888257f, 0.01501822f, -0.06146614f, 
    0.05601637f, 0.06210909f, 0.01804970f, -0.04347518f, 0.04816745f, 0.08286344f, -0.04139055f, -0.01340713f, 
    -0.01364846f, -0.01820469f, -0.06986966f, 0.02654876f, -0.03749149f, -0.09714660f, -0.08776499f, -0.07429302f, 
    -0.06461983f, 0.06959187f, 0.01869144f, -0.01252615f, -0.06269602f, -0.04863235f, 0.06786046f, 0.00151547f, 
    0.07160690f, -0.01845579f, 0.05596061f, 0.03514851f, -0.02559108f, -0.07950798f, -0.11062394f, -0.03123633f, 
    -0.03972404f, -0.00505697f, 0.06237798f, 0.02956796f, -0.06020107f, 0.04558212f, -0.00235516f, -0.00043998f, 
    -0.03333234f, -0.07708986f, 0.01863312f, -0.03997412f, -0.02077344f, 0.04441581f, -0.07816240f, 0.06225335f, 
    -0.06858043f, -0.09527903f, -0.02850426f, -0.04999935f, 0.01281323f, -0.06731342f, -0.00003318f, 0.04282212f, 
    0.01971877f, 0.00060233f, 0.03828782f, -0.04097622f, -0.05412561f, 0.06197495f, -0.00684820f, -0.05743823f, 
    -0.10504736f, -0.05372472f, 0.04754720f, -0.00961761f, -0.07527032f, -0.16224477f, 0.04221812f, -0.06664079f, 
    -0.07350173f, -0.02710985f, -0.03325971f, 0.03562583f, 0.00593290f, -0.00187380f, 0.00667186f, 0.04008515f, 
    -0.09470187f, -0.03012648f, -0.09002832f, -0.13324192f, 0.00537784f, 0.07114212f, -0.05796591f, -0.04837251f, 
    -0.07502232f, -0.04930687f, -0.00172077f, -0.01861063f, -0.06497096f, 0.05452653f, -0.11776131f, -0.10180854f, 
    -0.06559493f, 0.04804521f, -0.07654247f, -0.07435934f, 0.01203199f, -0.08027737f, -0.07205818f, -0.07955861f, 
    -0.06372561f, -0.00332070f, -0.00368981f, -0.07063372f, 0.04066789f, -0.02604541f, -0.11006421f, 0.00267915f, 
    -0.01163116f, -0.02602756f, 0.00110795f, 0.04305211f, 0.03315159f, -0.11394324f, -0.04577633f, -0.00203866f, 
    -0.09256360f, 0.01043363f, -0.04122913f, -0.11207001f, 0.04300833f, -0.05386408f, 0.04138621f, 0.04685869f, 
    -0.09497373f, -0.06431834f, -0.10889469f, -0.10780717f, -0.08361694f, -0.08170322f, -0.12640764f, -0.06545335f, 
    -0.11129850f, 0.02879724f, -0.01658144f, 0.02489077f, -0.09805077f, -0.10829443f, -0.03048158f, 0.01310393f, 
    -0.08594785f, 0.03129102f, 0.03235505f, 0.06809754f, -0.00412817f, -0.05448228f, 0.06468920f, -0.08450152f, 
    -0.01241656f, 0.07303707f, -0.08886565f, 0.03828138f, -0.12533626f, 0.06097023f, 0.05824223f, -0.07692207f, 
    -0.12484342f, -0.01954773f, -0.03773228f, -0.13534471f, 0.06406095f, 0.01991219f, 0.07620137f, -0.03098099f, 
    -0.02575601f, -0.04569745f, -0.09495585f, 0.03751226f, -0.00102833f, -0.17097872f, -0.09162926f, -0.04559686f, 
    -0.31729847f, 0.09166699f, -0.09832898f, 0.04157222f, 0.25295004f, -0.04310759f, -0.04790266f, -0.06113669f, 
    0.00900332f, 0.15058292f, 0.05654822f, -0.09894060f, 0.37057367f, 0.18947130f, -0.07219708f, -0.16359629f, 
    -0.16064242f, 0.05358412f, 0.00793822f, 0.20101486f, 0.02465514f, -0.02282127f, -0.01897148f, 0.08093438f, 
    -0.00557321f, -0.07150907f, 0.14632474f, -0.05118571f, 0.14536576f, 0.02504172f, 0.09632434f, -0.01304460f, 
    -0.10855724f, 0.17660962f, 0.03649079f, 0.01574137f, 0.23845005f, -0.04997344f, -0.07243636f, 0.17322940f, 
    -0.00651738f, -0.04111759f, 0.08649050f, 0.01063061f, 0.11713420f, 0.06707749f, -0.10889301f, -0.12115208f, 
    0.14523298f, 0.00980869f, 0.14062926f, -0.06446241f, -0.05204977f, 0.07169386f, 0.14727232f, 0.16482289f, 
    0.20293182f, 0.19451030f, -0.25811082f, 0.05244812f, 0.25709981f, -0.07379752f, 0.01180852f, -0.17455189f, 
    -0.07852315f, 0.07743003f, 0.07499896f, -0.00991093f, 0.04859879f, -0.10340144f, 0.16177964f, 0.19363390f, 
    -0.19081712f, -0.11399450f, 0.04570679f, -0.07162783f, 0.07235213f, -0.20373188f, -0.12331722f, 0.13025714f, 
    0.02615022f, -0.05331003f, -0.32334694f, 0.12626377f, 0.24412537f, -0.00591063f, 0.08456509f, 0.17081235f, 
    -0.03393614f, -0.12693754f, 0.05072888f, -0.04309947f, -0.64668727f, -0.19802980f, -0.24725804f, -0.00289664f, 
    0.16677059f, 0.17913049f, -0.02607253f, 0.01320010f, 0.13596545f, 0.15583400f, 0.06347385f, 0.13280231f, 
    -0.20033556f, 0.22770028f, -0.08491018f, -0.10530910f, -0.10693411f, 0.19686952f, 0.09335704f, -0.17673405f, 
    0.05994277f, 0.20379171f, 0.15898329f, -0.03351913f, -0.22347321f, 0.19183305f, 0.07558056f, -0.00243572f, 
    -0.09576972f, -0.49887383f, 0.06917965f, 0.09237096f, -0.04931466f, -0.13422997f, -0.09169590f, -0.07514519f, 
    -0.18565857f, -0.21872869f, 0.25062814f, -0.20204890f, 0.22577201f, 0.01909996f, 0.03573418f, 0.20163387f, 
    -0.14680596f, 0.13179585f, 0.02470405f, -0.03139508f, 0.13667718f, -0.24345303f, -0.20695537f, 0.26472902f, 
    -0.23179200f, 0.04123473f, -0.02231166f, -0.11660701f, -0.05785177f, 0.29377604f, -0.27878723f, -0.00581774f, 
    0.23318626f, 0.07384714f, -0.09546922f, 0.06103215f, 0.20774934f, 0.17269562f, -0.41916281f, 0.07012793f, 
    0.00793340f, 0.09519558f, 0.12905718f, -0.04066001f, 0.22958255f, 0.20501779f, -0.07688440f, 0.33461261f, 
    0.18966648f, 0.02719785f, -0.00356507f, 0.30580628f, 0.36830148f, -0.21617699f, 0.02090780f, -0.30332690f, 
    0.08801648f, -0.04149275f, 0.13097392f, -0.07931770f, -0.36852786f, -0.08624425f, 0.22519138f, 0.07246629f, 
    0.00176189f, 0.15830605f, 0.45491937f, -0.11690183f, -0.00972063f, 0.02946591f, 0.03051152f, -0.03614391f, 
    0.04755127f, 0.17901292f, -0.08539408f, 0.08873484f, 0.04020816f, -0.30998221f, 0.02605784f, 0.12052689f, 
    -0.01576648f, -0.17213854f, -0.05115887f, -0.32810611f, -0.04370045f, -0.09247053f, 0.23533937f, 0.27599788f, 
    -0.00218304f, -0.12227670f, 0.04166765f, 0.02947771f, 0.16907957f, 0.05256858f, -0.17173783f, 0.26221544f, 
    -0.04335042f, -0.13489313f, 0.05619263f, -0.22216548f, -0.04624425f, 0.11670865f, 0.09170470f, 0.38679698f, 
    -0.13304605f, 0.03295777f, 0.03500583f, -0.08368968f, 0.06924404f, -0.21949376f, 0.03332243f, 0.04774816f, 
    0.17209442f, 0.16269739f, 0.10329164f, -0.19308931f, -0.04129683f, -0.03416909f, -0.01324029f, 0.32185993f, 
    0.17556827f, 0.19775482f, -0.18650623f, 0.23275767f, -0.38892218f, 0.00471649f, -0.05372399f, 0.10467253f, 
    0.07171109f, 0.00043650f, 0.05893750f, -0.02882388f, 0.27154249f, 0.05151536f, -0.16322452f, -0.02747874f, 
    -0.02437218f, -0.03374476f, 0.05739267f, -0.07913311f, 0.06927441f, -0.01887052f, -0.01257562f, -0.07955156f, 
    -0.05455336f, 0.02079292f, 0.00978387f, 0.03533759f, -0.08604750f, -0.04715617f, -0.11578166f, 0.01958923f, 
    -0.08866723f, -0.01431823f, 0.00861587f, 0.00597814f, -0.01846064f, -0.10246209f, -0.10061616f, -0.03915520f, 
    -0.02277465f, -0.05685585f, -0.02432263f, 0.07019813f, -0.04752478f, -0.03477684f, -0.01593811f, -0.00299851f, 
    -0.11774396f, -0.10034417f, -0.05234442f, 0.00760558f, -0.11006613f, 0.05567607f, -0.08219998f, 0.05526404f, 
    -0.02677799f, 0.04842507f, -0.12189765f, 0.01285854f, 0.08103123f, -0.11125068f, -0.02108163f, 0.01901124f, 
    -0.03614234f, -0.05981718f, -0.06478313f, -0.09170087f, 0.07102970f, -0.03214612f, 0.02306714f, 0.02005576f, 
    -0.12990655f, -0.09795237f, 0.04728648f, -0.06183267f, -0.09511774f, -0.01249446f, -0.01724216f, -0.04990040f, 
    -0.04995777f, -0.09985101f, -0.06617083f, 0.06567582f, 0.07187514f, 0.04041478f, -0.11591198f, 0.04761580f, 
    -0.07322250f, 0.02556121f, -0.00009933f, 0.02354532f, 0.07883843f, -0.06358931f, -0.00774402f, -0.04615552f, 
    0.03043312f, -0.04282949f, 0.02153903f, -0.08745925f, -0.08697686f, 0.03907359f, 0.03774175f, -0.03581607f, 
    0.04211441f, -0.06314922f, -0.05249176f, -0.09988081f, -0.06658509f, 0.02220058f, -0.08658670f, 0.00657050f, 
    -0.08789591f, -0.00364712f, -0.03312726f, -0.06542218f, -0.01997099f, -0.08349013f, -0.04454394f, 0.03633494f, 
    -0.08786891f, -0.00658513f, -0.06649077f, 0.00408181f, -0.08553941f, -0.05705899f, 0.03811487f, -0.04708557f, 
    0.06731687f, 0.03396484f, -0.09103264f, -0.00608442f, 0.03035836f, -0.09756356f, 0.07462168f, -0.03075960f, 
    -0.07375401f, 0.08324376f, -0.11344020f, -0.00682500f, -0.10500199f, 0.02212909f, -0.08551061f, -0.02460317f, 
    -0.05240911f, -0.05300957f, -0.00632647f, -0.11967793f, 0.24823868f, 0.25281599f, -0.19675203f, 0.04059337f, 
    0.26297465f, 0.19491841f, 0.16351411f, 0.10806727f, 0.27513883f, -0.06166588f, -0.05220523f, -0.11595080f, 
    0.10427671f, -0.07235047f, 0.08593134f, -0.09564212f, -0.08544215f, 0.17086154f, 0.06124622f, -0.04302748f, 
    -0.05030259f, 0.02624510f, 0.05169899f, 0.03410554f, 0.28470668f, -0.01460604f, 0.06151851f, -0.13602898f, 
    0.00256625f, -0.32257709f, 0.04354042f, -0.11116487f, -0.04942202f, -0.01155480f, -0.18651484f, 0.27700683f, 
    -0.00380549f, 0.02345447f, 0.07279869f, 0.33313432f, 0.16803452f, -0.13565099f, 0.18477140f, -0.07681016f, 
    0.31044060f, -0.11635325f, 0.26845369f, 0.14504133f, -0.16495349f, 0.18541622f, -0.04800107f, -0.07009588f, 
    0.10030703f, -0.14373659f, -0.16013640f, 0.09046644f, 0.02250739f, -0.04848102f, 0.20294413f, -0.11957256f, 
    0.24630320f, -0.16491780f, 0.07335424f, 0.08189081f, 0.05451311f, 0.55211496f, -0.04047907f, 0.00570095f, 
    -0.26413625f, -0.00219173f, -0.17281638f, -0.07906691f, -0.10384923f, -0.00685261f, -0.08413523f, 0.51451522f, 
    0.15988323f, 0.09250791f, -0.08271368f, 0.14519073f, 0.31787699f, 0.02271228f, 0.17740634f, 0.03430254f, 
    0.10108237f, 0.09099055f, 0.27566138f, 0.02814818f, -0.39353356f, -0.00146988f, 0.10477474f, 0.10543866f, 
    0.02317115f, -0.02393359f, 0.14104427f, -0.06168360f, 0.10942320f, 0.06548108f, -0.00052202f, 0.16301432f, 
    0.01867143f, 0.28636533f, 0.03489990f, -0.17960764f, 0.04811630f, 0.14618866f, 0.01417885f, -0.04005260f, 
    0.17801221f, 0.27672631f, -0.14468396f, 0.04672056f, 0.01373332f, -0.12647559f, -0.02825491f, 0.13777852f, 
    0.06692136f, -0.45180145f, 0.03268247f, -0.18358798f, 0.17469421f, -0.15161513f, 0.05442115f, 0.01154693f, 
    0.00378907f, -0.01566220f, 0.03792170f, -0.04813828f, -0.06155325f, -0.12282208f, 0.03047086f, -0.03532133f, 
    -0.07599059f, -0.11353700f, -0.09715610f, 0.02235374f, 0.00064318f, 0.01483264f, -0.02922724f, -0.07031918f, 
    0.06861917f, -0.04907886f, -0.11098886f, 0.02013742f, 0.06907008f, -0.00935384f, -0.09784513f, 0.02001040f, 
    0.00839266f, -0.11423981f, 0.00043392f, -0.11316916f, 0.00501051f, -0.06744888f, 0.00998134f, -0.05022822f, 
    -0.01132644f, -0.05006390f, -0.03788577f, 0.06479329f, -0.10016241f, -0.05045941f, 0.03780853f, -0.09644622f, 
    -0.05244583f, 0.07032777f, -0.08060566f, -0.02668954f, -0.00618642f, -0.03911489f, -0.11812077f, -0.09276642f, 
    0.02906012f, -0.04869602f, -0.08145306f, 0.02230379f, 0.03233301f, -0.01539319f, -0.11107925f, -0.06205760f, 
    -0.04442491f, -0.09064526f, -0.07994957f, -0.03009851f, 0.02492791f, 0.00956716f, -0.06502920f, -0.03227881f, 
    -0.01022822f, 0.06503619f, 0.01144605f, -0.00546843f, 0.05912751f, -0.09662975f, 0.00574090f, -0.10290592f, 
    0.05844119f, 0.05712377f, 0.03523752f, -0.06511973f, -0.02314968f, 0.02984121f, 0.03420778f, 0.05476344f, 
    0.04168703f, 0.01846672f, -0.11252638f, -0.03882258f, -0.06587859f, 0.04195542f, -0.04180915f, 0.03304561f, 
    -0.07948729f, -0.11701102f, 0.02508809f, 0.04880218f, -0.06883601f, -0.08537204f, -0.00986775f, -0.03958589f, 
    -0.03577488f, -0.04111134f, -0.11899769f, 0.03106277f, -0.08775868f, 0.04136544f, -0.01289095f, -0.09567424f, 
    -0.10985021f, -0.08179168f, 0.02992985f, -0.08374941f, 0.00859418f, -0.04398674f, -0.02992046f, -0.07280626f, 
    -0.07870129f, 0.00628512f, -0.11116641f, -0.11568889f, -0.11972170f, -0.08499808f, -0.02829238f, 0.01805830f, 
    -0.04443981f, 0.01302170f, 0.04934177f, 0.05037729f, -0.00256788f, -0.09374816f, 0.05391994f, -0.08041360f, 
    -0.05335942f, 0.01092193f, -0.03339072f, 0.00998457f, -0.12365714f, 0.00906019f, -0.04756887f, -0.03523973f, 
    0.01257861f, -0.08083276f, -0.01313420f, -0.05129018f, 0.00143135f, 0.04508992f, -0.09379257f, -0.00023568f, 
    -0.04239558f, -0.03368370f, -0.06635989f, -0.02098877f, -0.06758273f, 0.02065092f, -0.03569525f, -0.00022653f, 
    0.03416675f, 0.05565256f, 0.04457749f, 0.02909973f, 0.02110356f, -0.08194496f, 0.00800810f, 0.03303949f, 
    -0.04189625f, -0.00057362f, -0.10465471f, -0.00680879f, -0.02474779f, -0.03762053f, -0.07551435f, 0.04689100f, 
    -0.07432464f, 0.07027899f, -0.05665725f, -0.09027407f, -0.04931000f, -0.10334471f, -0.09040818f, -0.03809901f, 
    0.01414019f, -0.07869655f, 0.01661601f, -0.06866287f, -0.01065900f, -0.03459252f, 0.07742398f, -0.01754787f, 
    0.03886176f, -0.00929096f, -0.00154584f, 0.07812379f, -0.10997720f, -0.10502402f, -0.02416255f, -0.08514059f, 
    -0.10966746f, -0.10608475f, 0.01629201f, -0.10151580f, -0.05703951f, 0.05436945f, 0.05693655f, 0.05978137f, 
    -0.03824582f, -0.09967679f, 0.01870722f, 0.03912298f, 0.08363818f, -0.06977800f, 0.03495524f, -0.05934809f, 
    0.04302617f, 0.04324405f, -0.05788235f, -0.02075168f, -0.06818898f, 0.00635397f, 0.03519065f, -0.14990476f, 
    -0.01671679f, -0.05598213f, -0.03809156f, 0.02067775f, 0.08173218f, -0.09751772f, -0.06916760f, 0.06138267f, 
    0.03882603f, -0.06492735f, -0.00158231f, -0.07205036f, -0.04536461f, -0.05497865f, -0.08361489f, -0.07994284f, 
    0.06037304f, 0.03515296f, -0.08068716f, 0.01491905f, -0.03248808f, -0.03302188f, -0.12963925f, -0.02874676f, 
    -0.09940998f, -0.07817215f, 0.03084877f, -0.00506941f, -0.01804038f, 0.02827495f, -0.06671637f, -0.08467340f, 
    -0.02509255f, -0.03809654f, 0.02074131f, 0.00785107f, -0.09976835f, -0.09468864f, 0.02965307f, 0.01519287f, 
    -0.15668103f, -0.02930425f, 0.07083876f, -0.23969211f, 0.11730580f, 0.13290253f, -0.00830882f, -0.11680488f, 
    -0.16963209f, 0.19363968f, 0.10803942f, -0.12497006f, -0.02041582f, 0.12039842f, 0.09864976f, 0.22249727f, 
    0.38474146f, -0.00538122f, -0.06398121f, -0.00454374f, 0.08076949f, 0.13007748f, -0.08182950f, 0.14130045f, 
    -0.02392290f, -0.07107330f, 0.05701731f, 0.09755830f, 0.13255368f, 0.04980691f, 0.00652055f, -0.40340835f, 
    -0.28338879f, 0.08267040f, -0.02252283f, -0.01964522f, -0.05080779f, -0.37793896f, -0.18095993f, -0.00978216f, 
    -0.38820180f, 0.07190144f, 0.15207438f, -0.13340765f, 0.10050849f, 0.07655184f, -0.05572267f, 0.11140058f, 
    0.07954837f, -0.15302688f, -0.00980931f, -0.00335202f, -0.26034954f, 0.15247372f, 0.15002146f, 0.07784083f, 
    0.00331823f, 0.02873411f, -0.75990355f, -0.04170398f, 0.01625100f, 0.16257235f, 0.12639846f, -0.00373184f, 
    0.07033262f, -0.09624734f, -0.04354990f, 0.08009377f, -0.01160727f, -0.02990728f, 0.05804313f, 0.10755105f, 
    0.14427169f, -0.47060624f, -0.33561727f, -0.22392401f, -0.03615626f, 0.23160757f, -0.52742171f, -0.03452861f, 
    0.18590549f, -0.06654241f, 0.02076950f, 0.09891979f, -0.05796831f, 0.05578802f, 0.15381375f, -0.33814475f, 
    0.07788210f, 0.05189311f, 0.12469561f, -0.11358052f, -0.51477087f, 0.12214785f, 0.14463547f, 0.00914202f, 
    0.05179507f, -0.04568985f, 0.02414433f, 0.00999405f, 0.08737452f, -0.04566362f, -0.06207013f, -0.07175375f, 
    0.12598599f, -0.05370683f, 0.19018172f, -0.32213157f, 0.24335958f, 0.20216885f, -0.09258880f, 0.39122862f, 
    0.14054434f, 0.07450283f, -0.11891489f, -0.00456870f, -0.01757805f, -0.07843417f, 0.01662752f, 0.23064925f, 
    -0.18332326f, 0.30016556f, -0.07022957f, -0.00403645f, 0.05059798f, 0.05418401f, 0.00056391f, -0.11328349f, 
    -0.03693267f, 0.06567513f, 0.04916956f, 0.07329902f, -0.04265815f, 0.03710338f, -0.08006138f, -0.02541968f, 
    0.04463496f, -0.01476099f, 0.03259793f, 0.01069509f, -0.01610352f, -0.01276108f, 0.04871496f, 0.01819133f, 
    -0.08440635f, -0.08029000f, -0.09617337f, -0.02916149f, 0.01749237f, -0.06962907f, -0.06060096f, -0.05978708f, 
    -0.01656217f, -0.02707858f, 0.05793294f, 0.00548851f, 0.07520324f, -0.05640759f, -0.09951685f, -0.07907116f, 
    0.03080748f, 0.02714466f, 0.01859479f, -0.05470201f, -0.04271935f, 0.00810162f, -0.09841760f, -0.01839819f, 
    0.07090246f, 0.04622286f, 0.04571876f, -0.02885713f, 0.02253162f, 0.01383600f, -0.08673585f, -0.08767235f, 
    -0.00778192f, 0.00924868f, -0.07520929f, -0.02876987f, -0.00195949f, -0.03554548f, -0.08407652f, -0.00892928f, 
    -0.06817481f, 0.06142517f, 0.04410477f, 0.07873551f, -0.09542631f, 0.04867155f, 0.00362225f, -0.07681909f, 
    -0.04899330f, 0.04436687f, -0.02307584f, 0.03240351f, 0.08655414f, -0.07562390f, 0.06913138f, 0.02391638f, 
    0.03592639f, -0.03369226f, -0.02701755f, -0.03210320f, 0.00380948f, -0.09670630f, 0.02886935f, 0.03738796f, 
    -0.08941983f, 0.02015756f, 0.07341887f, 0.01889166f, -0.03841295f, 0.03310214f, 0.01451360f, -0.10914955f, 
    0.03198212f, -0.01055775f, 0.05890169f, 0.02948954f, -0.07960585f, -0.01148188f, 0.05429858f, -0.03421035f, 
    -0.05557033f, -0.02427426f, 0.07068288f, 0.07083110f, -0.00426028f, -0.05565532f, 0.06553794f, -0.06694841f, 
    -0.09223353f, 0.00955888f, 0.01404175f, 0.01075993f, -0.05521821f, -0.09965551f, -0.09362154f, 0.05993684f, 
    0.01684754f, -0.08393651f, -0.02333781f, -0.09791659f, 0.01509301f, 0.03825513f, 0.00262580f, -0.02868930f, 
    -0.05611184f, 0.02568560f, 0.01273845f, -0.07206962f, -0.05946680f, -0.01124100f, -0.05055452f, 0.00557633f, 
    0.23877555f, -0.09537768f, -0.26277542f, -0.20279445f, -0.40556985f, 0.33425176f, -0.19217464f, 0.18466206f, 
    0.23411074f, -0.32233703f, 0.16449162f, -0.05467615f, 0.06431956f, 0.25979540f, -0.12476649f, -0.12308333f, 
    0.24860838f, -0.05036417f, 0.49660611f, 0.10733298f, 0.09443814f, -0.02022145f, 0.24162179f, 0.00134506f, 
    -0.14623146f, 0.22176313f, 0.04762487f, -0.00609816f, 0.12382426f, -0.28401297f, 0.13476272f, -0.04571713f, 
    -0.16762529f, -0.14032698f, -0.04221032f, -0.01303595f, -0.20535924f, -0.27595150f, 0.39331365f, -0.00699523f, 
    -0.39310881f, -0.05118820f, -0.10704491f, -0.00608250f, -0.12443481f, -0.23464221f, -0.14652263f, -0.13055836f, 
    0.15883631f, 0.02052969f, -0.01981139f, 0.32375851f, -0.10532125f, 0.40787825f, -0.20102479f, -0.16858082f, 
    0.09736567f, 0.05717560f, 0.05528327f, 0.26755735f, -0.22539735f, -0.04028130f, 0.10580236f, -0.04046414f, 
    0.15380989f, 0.01859373f, -0.02995003f, 0.03007285f, 0.00492642f, 0.19948868f, 0.01217371f, 0.02227909f, 
    -0.11343953f, -0.02106503f, -0.25917819f, 0.07975554f, -0.02974619f, -0.00159804f, -0.00648982f, -0.15318295f, 
    0.05378200f, -0.06274278f, 0.32443020f, 0.10348404f, 0.09916588f, 0.06017501f, 0.25843069f, -0.28029272f, 
    0.00201032f, 0.18430480f, 0.40990314f, 0.43583372f, -0.21148579f, -0.20095897f, 0.05758106f, 0.26511270f, 
    0.05132527f, -0.00261927f, 0.20674010f, -0.01894243f, 0.09298687f, 0.06033069f, -0.04923335f, 0.04799209f, 
    0.09737875f, 0.19782108f, 0.09754615f, -0.01820657f, -0.00948364f, -0.00219069f, 0.16239254f, 0.24236092f, 
    0.25102240f, 0.15761755f, 0.10321467f, -0.16349180f, 0.28636959f, -0.22219077f, 0.07294729f, -0.05246974f, 
    -0.08284782f, 0.02306459f, 0.04468162f, -0.00983637f, 0.25273380f, -0.09276384f, 0.20986280f, 0.04736871f, 
    0.12225993f, 0.18596202f, -0.55012566f, -0.17457685f, -0.16413413f, -0.05094384f, -0.00892654f, 0.13223961f, 
    -0.04509668f, -0.11574898f, 0.04227581f, 0.18422681f, -0.06728925f, 0.22750339f, 0.25897822f, 0.00449423f, 
    0.41624177f, 0.08240996f, 0.01292940f, -0.23576117f, 0.08618672f, -0.02768877f, 0.09713670f, -0.11662965f, 
    -0.00671437f, 0.21224315f, -0.35984510f, -0.06556149f, 0.09218763f, 0.16415170f, -0.14073057f, 0.05525111f, 
    0.18604553f, -0.35842407f, -0.05304075f, 0.11013497f, -0.34998718f, 0.01678526f, 0.00773309f, 0.09991281f, 
    0.21074146f, -0.04971783f, -0.41124108f, -0.12297001f, -0.08752295f, 0.17897576f, 0.19770846f, -0.01245291f, 
    -0.08897968f, -0.20100562f, 0.08867202f, 0.04817895f, 0.45378360f, -0.02570143f, -0.00226029f, -0.05806435f, 
    0.10670733f, -0.43093261f, 0.55442017f, -0.10990547f, 0.02191192f, -0.14713649f, -0.12418205f, 0.05232465f, 
    0.12518935f, 0.00119483f, -0.01371842f, 0.06955625f, 0.05436987f, 0.00247534f, 0.01227842f, -0.39877132f, 
    0.21861047f, 0.08465879f, -0.11357101f, 0.04233979f, 0.08786602f, 0.04609815f, 0.11063010f, -0.05446475f, 
    -0.02565480f, 0.18500416f, 0.15968318f, -0.11124219f, 0.09821937f, 0.02875642f, -0.05379768f, -0.01850436f, 
    -0.09046315f, -0.01791831f, 0.00253851f, 0.22615656f, 0.30173975f, -0.01801746f, 0.13780594f, 0.03762700f, 
    -0.10093897f, -0.28912699f, -0.02683700f, -0.02960616f, -0.04196313f, -0.16857246f, 0.04021685f, 0.20796600f, 
    -0.07104149f, 0.15297312f, 0.10065591f, 0.07930572f, 0.09882690f, -0.11684640f, 0.21530925f, -0.00286645f, 
    0.09094096f, 0.17781810f, 0.01036520f, 0.08690970f, 0.11138665f, -0.28288296f, 0.08008268f, -0.14191678f, 
    0.02063153f, 0.05072184f, -0.02489433f, -0.00114038f, -0.02177413f, 0.02853884f, 0.14075916f, -0.05136328f, 
    0.15829666f, -0.53635156f, -0.06085550f, -0.08478530f, -0.11603682f, 0.19179210f, -0.01458733f, -0.03990208f, 
    0.04180520f, -0.02388921f, 0.19014089f, 0.11380348f, 0.06454049f, 0.04138919f, -0.74047095f, -0.18516047f, 
    0.17769417f, 0.02911382f, 0.32942533f, 0.03399456f, 0.06498972f, -0.13010992f, 0.21324663f, -0.27708361f, 
    -0.07473569f, 0.20255272f, -0.34899336f, -0.06102080f, 0.05283317f, -0.05354578f, -0.20298330f, 0.07689404f, 
    0.23557985f, -0.33671579f, -0.24572664f, -0.07727941f, -0.10630584f, 0.06945968f, 0.22206528f, 0.23040782f, 
    -0.40847120f, 0.06419583f, -0.17866015f, 0.13938323f, -0.10939521f, -0.57384229f, 0.16608196f, -0.50239396f, 
    0.15855357f, -0.07357503f, -0.07626355f, -0.03548716f, 0.02785594f, 0.10794289f, -0.12373094f, -0.05634857f, 
    0.25550991f, -0.32194847f, -0.16736852f, 0.03079604f, -0.17958434f, -0.23179702f, -0.05925602f, -0.00249144f, 
    0.06529053f, 0.22067425f, 0.08356976f, 0.02819415f, 0.01887974f, -0.08843555f, 0.08836254f, -0.24847959f, 
    -0.19301634f, 0.06226527f, 0.01284208f, -0.03994644f, -0.00612571f, -0.24407592f, -0.14844297f, -0.31554604f, 
    -0.04169428f, 0.13950330f, 0.14189631f, 0.06544589f, 0.21916673f, -0.05451004f, -0.01409947f, -0.16928795f, 
    0.01574286f, 0.23703842f, 0.30542561f, 0.38384727f, -0.03065614f, -0.56093383f, 0.14046486f, 0.16544230f, 
    0.08633164f, 0.04318202f, 0.06133150f, -0.03567324f, -0.01500116f, -0.02708391f, -0.05664428f, 0.13202162f, 
    -0.03787505f, 0.33086661f, 0.10900659f, 0.10513108f, -0.03696601f, -0.27327576f, 0.26708585f, 0.03474412f, 
    0.16636661f, 0.20119911f, 0.04437472f, -0.19943261f, 0.05004948f, -0.30090761f, -0.05772843f, -0.07685224f, 
    -0.38679767f, -0.11996792f, 0.08105234f, -0.46839359f, 0.17792183f, 0.07716849f, 0.11933129f, 0.02075350f, 
    0.27859539f, -0.06820560f, -0.13029985f, 0.06866391f, -0.27193016f, -0.10971919f, 0.07502262f, 0.32488883f, 
    -0.10191389f, 0.07269621f, -0.18745998f, -0.03402196f, -0.05232875f, -0.13882233f, -0.01487384f, 0.17576437f, 
    -0.15601201f, 0.14889470f, 0.00198265f, 0.07777527f, -0.01906113f, -0.13620085f, -0.05969441f, -0.09874500f, 
    -0.37302467f, 0.08883468f, 0.12522286f, -0.01592492f, -0.12577856f, -0.16116582f, 0.13262665f, 0.04264341f, 
    0.03914308f, 0.12169105f, 0.17847468f, -0.10570157f, -0.08266802f, -0.04527849f, 0.34747124f, -0.05683545f, 
    -0.00931233f, -0.02471553f, 0.05915127f, 0.05536743f, -0.20138212f, 0.02696117f, 0.00752034f, -0.12537037f, 
    0.08144427f, 0.17378722f, -0.05915879f, -0.02134382f, 0.08780099f, -0.03657173f, -0.23170687f, 0.08793603f, 
    -0.19937371f, 0.15186585f, -0.20804064f, 0.42532262f, -0.26382488f, 0.02429502f, 0.15333648f, -0.22171758f, 
    -0.01342532f, 0.18979320f, -0.06461423f, -0.07009874f, -0.03208479f, -0.08654769f, 0.08382012f, 0.05261447f, 
    0.08950653f, -0.05107081f, 0.00191054f, 0.30006319f, -0.06445520f, -0.09152891f, -0.12609275f, -0.17352226f, 
    0.14550190f, -0.01024806f, 0.24118382f, 0.02843322f, -0.13513766f, 0.02330801f, -0.04405267f, 0.01502283f, 
    0.05997130f, 0.12674122f, 0.12896314f, -0.13262096f, 0.20589767f, 0.08147814f, -0.09411342f, 0.47508928f, 
    0.10084450f, 0.04570720f, -0.01607343f, -0.02295220f, -0.03150046f, 0.08501340f, -0.02247822f, -0.03638395f, 
    0.10736176f, 0.04911363f, 0.03426636f, 0.12647000f, 0.03719969f, -0.11418317f, -0.05632409f, 0.38367480f, 
    -0.07094075f, 0.05234264f, 0.01172165f, -0.10771183f, 0.30415416f, -0.01437578f, 0.08652593f, -0.21891722f, 
    -0.02288763f, 0.20856546f, 0.14168215f, 0.07711634f, 0.08921575f, -0.14780673f, 0.13799062f, 0.04431738f, 
    -0.06415297f, -0.05238153f, 0.06114310f, 0.01786864f, -0.06159553f, 0.03251617f, 0.01172291f, -0.04699060f, 
    0.04038546f, -0.07518966f, 0.01625628f, -0.03589586f, -0.06131533f, -0.06890683f, -0.02732381f, -0.06469895f, 
    -0.09828302f, 0.04894134f, -0.02024504f, -0.00632626f, -0.06036320f, -0.00749038f, 0.00379028f, -0.04580840f, 
    -0.09943943f, 0.02630198f, 0.04943822f, 0.02290269f, -0.06638701f, -0.02181019f, 0.06683465f, 0.05105329f, 
    0.01780050f, -0.02625030f, -0.06422614f, -0.01030250f, -0.05337854f, 0.05543387f, 0.07838525f, -0.09000517f, 
    -0.07912788f, -0.00652959f, -0.04486416f, -0.04055666f, -0.06604635f, 0.04794559f, 0.07612210f, 0.00664256f, 
    -0.11075193f, -0.06529474f, -0.07096383f, -0.11227376f, -0.09846012f, 0.02966937f, -0.12011676f, -0.11820170f, 
    -0.08683596f, 0.00366170f, -0.02264877f, 0.00532028f, 0.03031710f, 0.00980650f, 0.01131006f, -0.10183895f, 
    0.03235738f, -0.06777629f, 0.06260049f, -0.09906687f, -0.07143294f, -0.01217077f, -0.12943463f, -0.00673999f, 
    -0.07239329f, 0.00782856f, 0.05957802f, -0.07746395f, 0.06257507f, 0.05540858f, -0.06410355f, -0.07687265f, 
    -0.09316604f, -0.05399614f, 0.03477408f, -0.04641597f, -0.09574092f, 0.04718585f, 0.00944721f, 0.01175488f, 
    0.04650998f, 0.00197885f, 0.00504914f, -0.05734328f, 0.10131046f, -0.01447443f, -0.10842185f, -0.05331691f, 
    -0.07378957f, -0.05701875f, -0.13661470f, 0.05436819f, -0.10020189f, -0.03434866f, -0.01331421f, -0.04199548f, 
    -0.04113789f, -0.02150880f, 0.03372933f, 0.01118600f, 0.00314642f, -0.08812363f, -0.09327468f, -0.06790072f, 
    -0.04738716f, -0.10787202f, -0.08189172f, -0.10767183f, -0.07911871f, -0.00900351f, 0.00231543f, -0.01786232f, 
    0.02348869f, -0.06772927f, 0.02453784f, -0.03119485f, -0.04310495f, 0.03949314f, 0.01962246f, -0.00420695f, 
    0.07603873f, -0.05409408f, -0.01312216f, 0.04155262f, -0.08902855f, -0.00225140f, -0.06451213f, 0.07913072f, 
    -0.08733954f, -0.07017339f, 0.01058730f, 0.04635276f, 0.03878420f, 0.01312777f, -0.06259445f, -0.04648547f, 
    -0.07550139f, 0.00222784f, 0.07571739f, -0.00212761f, -0.02307739f, -0.07946426f, 0.01518521f, -0.10785980f, 
    -0.06903450f, -0.03985007f, 0.00240038f, 0.01272449f, -0.05268575f, -0.06757725f, 0.01035863f, 0.00611566f, 
    -0.01103700f, -0.09602445f, 0.02900835f, -0.07916065f, 0.04705539f, -0.07054204f, 0.03459585f, -0.00270523f, 
    -0.04495876f, -0.07908641f, 0.06830847f, 0.04679269f, -0.08709320f, -0.00025531f, -0.00046064f, -0.08722788f, 
    -0.00418985f, 0.02482845f, 0.02077152f, -0.02870878f, 0.09668153f, -0.03772373f, 0.00776853f, -0.04366503f, 
    -0.03285777f, -0.00548598f, -0.01991606f, 0.03418694f, 0.04781827f, 0.03148469f, -0.10713761f, -0.05292145f, 
    0.03704910f, -0.06336027f, -0.00832890f, -0.07413594f, -0.00328466f, -0.01480434f, -0.07267285f, -0.01749232f, 
    0.03341091f, -0.06279961f, 0.06929822f, -0.06351708f, 0.06654126f, -0.00454267f, 0.00251611f, -0.09096296f, 
    -0.01469687f, 0.00653514f, -0.01036420f, -0.10395016f, 0.05153534f, 0.04542227f, 0.00904363f, -0.08540963f, 
    -0.00785711f, -0.02015724f, -0.01120597f, -0.07501403f, -0.00345649f, -0.01884853f, -0.00227058f, 0.01707843f, 
    -0.05223479f, 0.00602309f, -0.07290479f, -0.06219373f, -0.03807339f, 0.00278605f, -0.06258510f, -0.07482372f, 
    -0.03622411f, 0.03872787f, -0.00492801f, -0.08052292f, -0.10525849f, -0.03410373f, -0.04463995f, 0.01571883f, 
    -0.06135831f, -0.05300647f, 0.02575253f, -0.01527321f, 0.07859135f, -0.05576438f, -0.07263307f, -0.03345615f, 
    -0.04500997f, 0.05845638f, -0.02506693f, 0.06196795f, 0.03870527f, 0.03040395f, -0.02546338f, -0.08777797f, 
    -0.04728987f, -0.05845273f, -0.08911335f, -0.08378685f, -0.08277469f, -0.08705370f, -0.02261788f, -0.09044465f, 
    0.02421661f, 0.03648687f, -0.12533224f, 0.00628289f, 0.01307686f, -0.07978118f, 0.04269267f, -0.08524898f, 
    0.00758026f, -0.07769210f, -0.01246136f, -0.11745041f, -0.06123017f, 0.05440105f, -0.05980110f, -0.00695734f, 
    0.03061760f, 0.00233080f, 0.00020342f, -0.06622129f, 0.03631771f, -0.02120634f, -0.01660988f, -0.04512890f, 
    -0.03899566f, 0.05043149f, -0.03872608f, -0.02341943f, -0.06709754f, -0.02122924f, -0.04382815f, -0.01159892f, 
    -0.07691906f, 0.02078079f, -0.12170994f, -0.06516103f, 0.05095669f, 0.04303773f, 0.04920093f, -0.02626006f, 
    0.02125119f, -0.07020420f, 0.00570800f, -0.06307083f, -0.10543960f, -0.11357537f, 0.00422002f, -0.06710266f, 
    -0.06187435f, -0.11602902f, 0.06638044f, -0.07945123f, 0.01221376f, -0.00097650f, 0.02639455f, 0.00691535f, 
    -0.02118887f, -0.08399186f, 0.04282376f, -0.05942072f, -0.08609267f, -0.02848938f, -0.04581434f, 0.06005219f, 
    0.07379670f, -0.06255805f, -0.06165890f, -0.02707571f, 0.08136671f, -0.12780918f, -0.07415590f, -0.04589526f, 
    -0.10881382f, -0.06148097f, 0.01894393f, -0.10650759f, -0.11331663f, 0.04913427f, -0.09004606f, 0.02035350f, 
    -0.04739685f, -0.06391796f, 0.00598174f, 0.00363234f, 0.08611262f, -0.04566538f, -0.11539935f, 0.01825719f, 
    0.01547928f, -0.11271220f, 0.03408702f, -0.02705710f, -0.09085004f, -0.01201446f, -0.05851752f, -0.12241977f, 
    -0.02450140f, -0.11214934f, -0.07047187f, -0.03765597f, 0.02111893f, -0.11004059f, -0.00865485f, -0.05622958f, 
    -0.01120098f, -0.07438026f, 0.03312157f, -0.08047362f, 0.04938222f, -0.09144861f, -0.05469780f, 0.01252107f, 
    -0.03213095f, 0.04712100f, -0.01343655f, -0.05138739f, 0.01108189f, 0.04517248f, 0.02591929f, 0.04918745f, 
    -0.32677168f, 0.00540947f, 0.52391088f, 0.08958058f, 0.09505185f, 0.08163437f, 0.03095383f, -0.06922714f, 
    0.06740050f, 0.18813081f, 0.12365575f, -0.25900596f, -0.04779613f, 0.19046362f, -0.12874338f, 0.27678686f, 
    0.13031852f, 0.01738161f, 0.07087838f, 0.00465443f, -0.02926059f, 0.16943562f, 0.01746399f, -0.09438128f, 
    0.15205891f, 0.12212561f, 0.08704130f, -0.31218332f, 0.07564064f, 0.02970099f, -0.11070287f, -0.00800549f, 
    0.05363695f, -0.08882203f, -0.12136482f, -0.07699166f, 0.09096604f, 0.14501289f, 0.08807911f, -0.04229514f, 
    -0.17760989f, -0.05377495f, 0.31437004f, -0.20804936f, 0.01649206f, -0.07202656f, -0.14134753f, -0.09601314f, 
    -0.12701075f, 0.16571046f, -0.17189571f, -0.00141673f, 0.50068927f, 0.20513625f, 0.18804045f, 0.06381851f, 
    0.11314783f, 0.09893421f, -0.05873607f, -0.37522620f, -0.06701877f, 0.36681208f, -0.00385566f, 0.34234464f, 
    0.16458194f, 0.24491331f, 0.02919679f, 0.10212569f, 0.08286601f, -0.59049207f, -0.14121144f, 0.15527275f, 
    0.07891336f, -0.04290476f, -0.12382696f, -0.26777315f, -0.04375152f, 0.30982536f, -0.29795861f, -0.42539367f, 
    -0.13550255f, -0.38141161f, 0.12089598f, -0.15120873f, -0.05920354f, -0.08427931f, -0.14489558f, -0.15704867f, 
    -0.00012104f, -0.13375372f, 0.12424862f, 0.00518701f, -0.15536423f, -0.00820367f, 0.22441103f, 0.06839042f, 
    -0.08062438f, 0.04984423f, 0.07158940f, 0.03244591f, 0.06987271f, -0.22177787f, -0.04082475f, 0.17690162f, 
    -0.05555600f, 0.24967246f, 0.02685577f, -0.02721035f, 0.04458280f, 0.28160986f, 0.01441613f, 0.04439218f, 
    0.33643255f, 0.02742294f, 0.04969312f, -0.17198382f, -0.86676711f, 0.10611072f, 0.08542313f, 0.03790763f, 
    -0.14402579f, 0.23902026f, -0.25590873f, 0.22003067f, 0.05078991f, 0.35906157f, 0.06100539f, 0.03145128f, 
    -0.04437984f, 0.00819635f, -0.06149919f, 0.07016900f, -0.08266522f, -0.06609391f, -0.06712490f, 0.00982131f, 
    0.07337493f, 0.01492823f, -0.08031027f, 0.08952273f, 0.02178947f, -0.01237650f, -0.07930547f, -0.02982952f, 
    -0.00860628f, 0.04976635f, -0.00709708f, 0.05397910f, 0.05069241f, -0.02111824f, 0.08532474f, -0.05959331f, 
    -0.02989888f, -0.08244630f, 0.02795019f, -0.00671315f, -0.02203814f, -0.00181918f, 0.02494649f, 0.04799996f, 
    0.00296898f, 0.04575649f, -0.05492837f, -0.07879839f, 0.04408450f, -0.02364048f, 0.02733296f, -0.07524284f, 
    0.08519144f, 0.06358685f, -0.03066816f, -0.02103466f, 0.04679283f, -0.05169161f, -0.05372311f, 0.01521273f, 
    -0.05158878f, -0.08480804f, -0.06801142f, -0.04090289f, -0.01216102f, -0.09601361f, -0.04559429f, -0.08100973f, 
    -0.06651545f, -0.06279297f, 0.02167858f, -0.04252831f, -0.08057107f, -0.11453353f, -0.09076641f, -0.03781206f, 
    0.04817814f, -0.09238701f, 0.05526373f, -0.08691615f, 0.05944078f, 0.00350219f, 0.02128494f, -0.10603249f, 
    0.03458663f, -0.07939104f, -0.08734667f, -0.09181250f, -0.06586524f, 0.00963875f, 0.04331322f, 0.04040043f, 
    -0.04217658f, 0.05830779f, -0.10896643f, 0.02396659f, 0.04016758f, 0.03476679f, 0.02322967f, -0.04107394f, 
    0.05728317f, -0.07793517f, -0.08587728f, -0.00965459f, 0.01964261f, 0.01373694f, -0.06968465f, -0.08121431f, 
    -0.09190235f, -0.06435695f, -0.09410968f, 0.05645379f, -0.08998748f, 0.05868593f, 0.02215345f, 0.04733609f, 
    0.04655617f, 0.04351496f, -0.01306447f, -0.07898505f, -0.03639981f, -0.05842283f, 0.00339570f, -0.02474044f, 
    -0.09988011f, -0.11108721f, 0.00650717f, -0.05882955f, -0.02186853f, 0.07260114f, 0.04789704f, -0.09170601f, 
    -0.00404694f, -0.08171337f, 0.03507118f, -0.02860319f, -0.04553702f, 0.04616074f, 0.02499559f, -0.01989651f, 
    -0.06494718f, -0.09506992f, -0.01346818f, -0.04507949f, -0.07327183f, -0.06348749f, -0.01494036f, 0.01057803f, 
    -0.04509092f, -0.06800414f, -0.04062435f, 0.01628119f, -0.03891834f, 0.04670797f, -0.00867985f, -0.07417893f, 
    0.04428910f, -0.06959002f, 0.05217978f, -0.03316293f, -0.00088966f, -0.06275198f, 0.06504197f, 0.03506367f, 
    -0.05035854f, 0.07274507f, -0.05003629f, 0.06762376f, 0.07529423f, 0.02209340f, -0.06633106f, -0.04938027f, 
    -0.09036245f, -0.00171169f, -0.09921456f, -0.01581158f, -0.01513779f, 0.01996058f, -0.07205748f, 0.07635246f, 
    -0.03837176f, -0.01691880f, 0.01802406f, -0.05678551f, -0.03372604f, 0.05379453f, -0.03342428f, 0.03755555f, 
    0.00038347f, -0.01887952f, 0.05112829f, 0.01359780f, -0.05426576f, 0.00649483f, -0.02925280f, -0.10138473f, 
    -0.10124996f, -0.04480773f, 0.00713498f, -0.07270444f, -0.00311880f, -0.01235295f, 0.02331699f, -0.04177262f, 
    0.07137055f, -0.03986818f, -0.06702312f, -0.00138271f, -0.04536787f, -0.02431701f, -0.03958623f, 0.00751814f, 
    -0.07777953f, 0.01451517f, 0.03714217f, -0.09519077f, -0.00231658f, 0.04141856f, -0.03568770f, 0.04461179f, 
    0.04013383f, 0.00272100f, 0.03831375f, -0.01881172f, -0.02122754f, 0.05889223f, -0.08932248f, -0.04161876f, 
    -0.05361158f, -0.03663213f, 0.04527503f, -0.08927225f, 0.02466456f, 0.01216804f, -0.02441607f, -0.01791838f, 
    -0.00638869f, -0.06145280f, -0.08280323f, 0.07458874f, -0.02946426f, 0.05421489f, -0.07662569f, 0.00174929f, 
    -0.04706242f, 0.05980435f, -0.07425598f, 0.00918252f, 0.06231860f, -0.04724979f, -0.04165079f, 0.00033159f, 
    -0.09221494f, 0.02283670f, -0.05615947f, -0.01990572f, 0.03976508f, -0.03625351f, 0.05716218f, -0.07998978f, 
    -0.00822927f, 0.01350335f, -0.04903289f, 0.00982985f, 0.03114087f, -0.10564781f, -0.04662392f, 0.03026465f, 
    -0.09444452f, -0.05517972f, -0.23528530f, 0.08407037f, 0.03473976f, -0.05564998f, -0.08003864f, -0.00158726f, 
    -0.09271375f, -0.18767783f, 0.03306957f, -0.36123678f, 0.00381914f, 0.06337950f, -0.14927739f, -0.03041713f, 
    -0.05822561f, -0.09471060f, 0.21385884f, 0.19738044f, 0.06780088f, -0.05383515f, 0.08129209f, 0.01564036f, 
    0.14784765f, -0.14824274f, 0.14422455f, 0.24077554f, 0.08436827f, -0.03708409f, 0.12378453f, -0.00650304f, 
    -0.04106554f, 0.19771510f, 0.07272617f, 0.04634673f, 0.11339729f, -0.10335654f, 0.25587073f, -0.15695509f, 
    -0.00243536f, 0.05542443f, 0.04034953f, -0.08698207f, 0.10261397f, 0.10755853f, -0.18854256f, -0.14559819f, 
    0.11084384f, 0.18883221f, 0.03289076f, 0.03814599f, -0.32887551f, 0.06272364f, -0.23482488f, 0.08350170f, 
    0.08246281f, 0.25108135f, -0.06186251f, -0.04921957f, -0.04950394f, -0.01983501f, 0.21662083f, -0.41312060f, 
    -0.13209194f, 0.02960806f, -0.02581676f, 0.01534454f, 0.01437329f, 0.07121105f, 0.19957961f, 0.31660330f, 
    0.03864067f, -0.09009426f, -0.04090643f, 0.07684186f, 0.08818295f, -0.10541254f, 0.04998140f, 0.25078809f, 
    0.12206315f, 0.01738643f, 0.00051440f, 0.19958195f, -0.01167385f, 0.08391529f, -0.00203763f, -0.20166072f, 
    0.14892775f, 0.14745723f, 0.06841709f, -0.19901846f, -0.58540601f, -0.08835486f, -0.33956471f, 0.20263547f, 
    0.09654927f, 0.18755455f, -0.01579118f, -0.03221167f, -0.07143442f, 0.08915791f, -0.03730666f, -0.05882803f, 
    0.18002060f, -0.15182915f, 0.03358997f, -0.11044860f, -0.11735623f, 0.19586794f, -0.02048873f, 0.13563815f, 
    -0.08224977f, -0.00402630f, 0.11842049f, 0.07102735f, -0.22576012f, 0.11676057f, -0.08447681f, 0.20044741f, 
    0.06315719f, -0.02783850f, 0.14129406f, 0.07194548f, 0.07777922f, -0.16262634f, -0.02029954f, 0.07627814f, 
    0.00520819f, -0.00838940f, -0.03559770f, -0.12269385f, -0.06577136f, -0.02455105f, -0.06946200f, 0.02090006f, 
    -0.06557937f, -0.01982014f, -0.05344336f, -0.04738594f, -0.02219561f, 0.04210076f, 0.03012490f, -0.00069696f, 
    -0.04766594f, 0.04203521f, -0.02025378f, 0.00363430f, -0.01248140f, 0.05019501f, 0.01014147f, -0.09846631f, 
    -0.05883240f, 0.06110201f, -0.01692552f, 0.00340113f, -0.11000105f, -0.01012061f, -0.02346896f, -0.05914901f, 
    -0.05174162f, -0.13219903f, -0.10865811f, 0.01243201f, -0.00316971f, -0.06162319f, -0.05046361f, -0.01074911f, 
    -0.02099650f, 0.08584809f, 0.01053527f, -0.07173030f, -0.10017236f, -0.07481029f, 0.03809177f, -0.00803750f, 
    -0.01566874f, -0.11836586f, -0.04068056f, -0.09839743f, -0.04315076f, -0.05623376f, -0.08124263f, -0.00056036f, 
    -0.06040141f, -0.05523198f, 0.01866067f, -0.04717195f, -0.06283332f, -0.01143906f, 0.02733895f, -0.07320914f, 
    -0.06906035f, -0.01227735f, -0.03002139f, -0.05638120f, -0.02279457f, 0.00553018f, -0.00649607f, 0.03664863f, 
    -0.10406607f, 0.04812768f, 0.00754959f, 0.01550123f, -0.05502625f, -0.03699403f, -0.08545665f, -0.11499503f, 
    -0.04963455f, -0.01667950f, 0.03582015f, -0.04045596f, -0.02684590f, 0.02728565f, -0.09207595f, -0.00866986f, 
    -0.06628955f, -0.06529199f, -0.09234547f, 0.00995372f, 0.07014356f, -0.07238775f, -0.06533875f, -0.10817974f, 
    0.03086181f, 0.02810478f, -0.05114802f, 0.02585610f, -0.09988493f, -0.00655128f, 0.01527900f, -0.01126109f, 
    0.00004007f, 0.07173961f, -0.07608426f, -0.06851025f, 0.03031573f, 0.00539147f, 0.05612902f, -0.08246209f, 
    -0.04100354f, 0.02646567f, -0.02868975f, 0.02164561f, 0.00362583f, -0.10060844f, -0.03216644f, -0.10861924f, 
    -0.06377290f, -0.06023258f, 0.05093744f, 0.03201609f, -0.03887628f, -0.08288335f, 0.03985020f, 0.02120077f, 
    -0.17714587f, 0.01031452f, 0.18020301f, 0.08543343f, -0.02567726f, 0.10395739f, -0.12017980f, -0.41717082f, 
    0.14873596f, 0.02175907f, 0.11609709f, -0.14127298f, -0.05895924f, 0.11949071f, -0.19876345f, 0.07152503f, 
    0.38541594f, -0.17174590f, -0.02042952f, 0.02325927f, 0.06284454f, -0.03872437f, 0.07875177f, 0.10773514f, 
    -0.03951820f, 0.00836479f, 0.11039106f, 0.02784644f, 0.05727378f, -0.00181391f, 0.27362761f, -0.18353550f, 
    -0.20393547f, 0.03536232f, -0.05310653f, -0.04378295f, -0.12164991f, 0.00466055f, -0.05182073f, -0.07111280f, 
    -0.29006848f, 0.03354698f, 0.16201812f, -0.37258881f, 0.00926033f, -0.02964605f, -0.00979078f, 0.19183715f, 
    -0.08200333f, -0.00590673f, -0.05088919f, 0.20451093f, 0.36332268f, 0.17704949f, 0.09312216f, 0.07333379f, 
    -0.08983622f, 0.09622399f, -0.26111379f, 0.07175764f, 0.02070787f, 0.03420126f, 0.09265203f, 0.16497719f, 
    0.01069363f, -0.06278823f, -0.03502000f, 0.02070888f, -0.00062869f, 0.25894615f, 0.04120055f, 0.00924607f, 
    -0.17089215f, -0.33382410f, -0.09714176f, -0.07369459f, -0.01387997f, 0.32360405f, -0.31612596f, -0.14563356f, 
    0.11378060f, -0.08638041f, -0.00362853f, 0.05716985f, 0.15601292f, -0.06547345f, 0.19231717f, -0.34898096f, 
    0.04713841f, -0.09127077f, -0.00061298f, 0.27475560f, -0.53227848f, -0.02445450f, 0.11923338f, -0.11158647f, 
    0.16622883f, 0.17109396f, 0.01053714f, 0.05513962f, 0.03155987f, 0.19499654f, 0.04994415f, 0.07633933f, 
    -0.24511966f, 0.00621791f, 0.12563558f, -0.19101222f, 0.18020745f, 0.22865871f, -0.15922156f, 0.04703206f, 
    0.19308484f, 0.05778101f, 0.12666737f, -0.12623075f, -0.03749707f, -0.01237341f, -0.07247967f, 0.25203803f, 
    -0.24909760f, -0.13365997f, -0.16328658f, 0.07335835f, 0.12029309f, -0.16038832f, 0.21634404f, 0.02509038f, 
    0.19112705f, -0.15394966f, -0.07627688f, -0.06410053f, -0.13941041f, 0.10689696f, -0.08077879f, 0.18119925f, 
    0.31077987f, -0.04776867f, -0.24471052f, 0.08841228f, -0.03326196f, -0.30164003f, 0.08717178f, -0.04987290f, 
    -0.16328020f, -0.03806082f, 0.10680859f, -0.10059303f, 0.10324215f, 0.07303010f, -0.19044372f, -0.01923044f, 
    -0.05786534f, 0.05054980f, 0.06253023f, 0.00253956f, -0.01013515f, -0.20449522f, -0.05278326f, -0.00083647f, 
    0.04971505f, -0.21227522f, 0.05426447f, 0.15711805f, -0.10100040f, -0.15528707f, 0.15556732f, 0.09385727f, 
    -0.00108058f, 0.11082008f, 0.04823223f, 0.07671932f, -0.06371246f, -0.03613189f, 0.05433890f, -0.09069075f, 
    0.02138051f, 0.12500931f, -0.12036580f, 0.09590530f, -0.09846278f, 0.00665280f, -0.18010899f, 0.00474381f, 
    -0.25393721f, 0.02524535f, -0.02321893f, -0.11338841f, -0.13057955f, -0.11886356f, -0.06607524f, -0.03614289f, 
    -0.01493241f, -0.12596361f, -0.08076228f, 0.08282504f, 0.05554091f, 0.11141630f, 0.01802230f, 0.08106010f, 
    0.16089103f, -0.03443634f, -0.07013597f, 0.22003090f, -0.09039645f, -0.11355233f, -0.10390194f, 0.04425690f, 
    -0.01125766f, -0.09028980f, 0.10664675f, -0.05405458f, -0.01076052f, 0.04361307f, -0.00408366f, 0.03422061f, 
    0.03175361f, 0.20198072f, 0.06428920f, 0.11522763f, 0.52072793f, 0.09229391f, -0.07293909f, 0.07482734f, 
    -0.03098242f, -0.05066019f, -0.00882863f, -0.03917791f, 0.03870014f, -0.07651912f, -0.01623884f, -0.06216277f, 
    0.25283772f, -0.10688959f, -0.08579116f, -0.15408035f, 0.05536517f, -0.06954277f, -0.20420328f, -0.00605044f, 
    0.02246027f, -0.08512850f, -0.10487603f, 0.02259142f, 0.34072605f, 0.05940849f, 0.07073313f, -0.19831860f, 
    -0.13003165f, 0.12133835f, -0.06308728f, -0.01586905f, 0.00981702f, -0.07581973f, 0.10627886f, -0.02007838f, 
    -0.04692927f, 0.01929704f, -0.09512901f, -0.09968285f, 0.02398147f, 0.04599426f, 0.00547375f, -0.06910407f, 
    -0.01971821f, -0.07166831f, 0.07179278f, 0.07488833f, -0.04824758f, -0.09033381f, -0.07696225f, -0.07631774f, 
    0.05778370f, -0.06381998f, 0.08216610f, 0.03241684f, -0.07320394f, 0.01945188f, -0.07147399f, -0.01339493f, 
    -0.00229217f, -0.02910524f, -0.03024809f, 0.07402050f, -0.08544610f, -0.03310598f, 0.02388216f, 0.02827385f, 
    -0.04009348f, 0.03919335f, -0.01128233f, 0.04412133f, -0.08115324f, -0.09630118f, -0.07159371f, -0.05629916f, 
    0.05900664f, 0.05664219f, 0.04344032f, 0.01856198f, 0.00677679f, -0.01869286f, -0.08365430f, 0.02868921f, 
    -0.08175133f, 0.03921145f, -0.09648540f, -0.05554084f, -0.06474020f, -0.10103570f, 0.03053807f, 0.03577577f, 
    -0.05144468f, 0.06217774f, -0.00670263f, 0.05456864f, 0.02270840f, -0.10230105f, 0.04181065f, -0.05675874f, 
    0.00722618f, 0.01457579f, 0.04753606f, -0.02424498f, 0.07658214f, -0.00359207f, -0.08751709f, -0.06551557f, 
    -0.07501531f, -0.04015142f, 0.05594828f, -0.02437612f, -0.02012316f, 0.03190482f, -0.03689618f, -0.00027965f, 
    0.04302728f, -0.09126842f, -0.06550416f, -0.08915218f, -0.03025252f, -0.00436738f, 0.06031935f, 0.03104274f, 
    -0.07803676f, 0.03947025f, -0.00967341f, -0.00226209f, 0.06228846f, 0.03643777f, -0.04982664f, -0.00324984f, 
    -0.00340334f, -0.05144795f, 0.05618932f, -0.08364187f, 0.06465541f, -0.01652724f, -0.04866306f, 0.05948393f, 
    0.00614579f, -0.07371403f, -0.03959043f, -0.00126945f, -0.06459086f, -0.04682858f, -0.07060558f, -0.05034207f, 
    -0.04633803f, 0.04596824f, -0.03460195f, 0.05546148f, 0.07356262f, -0.04797885f, -0.04853801f, -0.07156114f, 
    -0.00713927f, -0.03126995f, 0.03891655f, -0.09363861f, -0.06708698f, -0.06603093f, -0.05439457f, -0.04132650f, 
    -0.04922224f, -0.11711670f, 0.42305100f, -0.18109703f, 0.25186989f, -0.07054330f, 0.12596117f, 0.09203169f, 
    -0.20287429f, 0.25679213f, 0.03329245f, -0.22253275f, 0.24649696f, -0.13765965f, -0.56431639f, 0.16212745f, 
    -0.14224486f, 0.20658000f, -0.06574146f, -0.07086244f, 0.04725214f, 0.26395357f, -0.39788175f, -0.06714568f, 
    0.17296690f, -0.03665109f, 0.00793038f, 0.04419734f, -0.06222559f, 0.16398145f, -0.35634118f, 0.12919770f, 
    0.22308198f, 0.15434788f, 0.12590700f, 0.03766979f, 0.18584615f, 0.31517065f, 0.11129463f, 0.33643860f, 
    0.07359845f, -0.01536743f, -0.07373416f, 0.27241069f, 0.32717958f, -0.18006724f, -0.07755711f, -0.32654393f, 
    -0.03918101f, 0.10558676f, 0.06483319f, -0.10461871f, -0.62976253f, 0.00823393f, 0.04534920f, 0.13879150f, 
    0.05497127f, 0.04073438f, 0.53006339f, -0.17123114f, -0.02274296f, -0.11025408f, 0.15718037f, -0.30916199f, 
    0.16063350f, 0.33431235f, 0.08227275f, 0.07262710f, -0.03014938f, -0.43439659f, 0.07590014f, 0.14867067f, 
    0.06274135f, 0.10827859f, -0.02392504f, -0.15472662f, -0.03979091f, -0.09894700f, 0.04641170f, -0.10451911f, 
    0.06527655f, -0.21802169f, -0.07049111f, -0.18514533f, 0.21105447f, -0.03354678f, -0.25633979f, 0.30675378f, 
    0.11252856f, -0.10121939f, 0.05450757f, -0.23089993f, 0.05626451f, 0.06783210f, 0.00252441f, 0.22271827f, 
    -0.11943434f, -0.02166335f, -0.07255733f, 0.02278232f, 0.03164520f, -0.23538445f, 0.03618633f, 0.13777423f, 
    -0.02745896f, 0.25135118f, -0.08519498f, -0.04761473f, -0.26496562f, 0.04605080f, -0.05093142f, 0.05783528f, 
    -0.02824304f, 0.23088224f, 0.03874510f, 0.28123692f, -0.30095181f, 0.13484506f, -0.03177511f, -0.09847043f, 
    -0.27971917f, -0.07942206f, 0.14497381f, -0.07731674f, 0.00988164f, 0.09871927f, -0.05384251f, -0.01014320f, 
    -0.15607542f, 0.08726238f, 0.09809430f, -0.03352224f, -0.17532027f, -0.18013349f, 0.08582567f, -0.22155483f, 
    0.19209135f, -0.25363904f, -0.08381681f, -0.21552846f, 0.37387410f, 0.28846878f, -0.02032301f, -0.21090028f, 
    -0.00994780f, 0.13859007f, 0.07742409f, 0.07083949f, -0.08646952f, -0.16377887f, -0.02942882f, 0.13479875f, 
    0.08220563f, -0.10303840f, 0.05156616f, -0.14284667f, -0.03456530f, 0.04065307f, -0.01863799f, -0.08629256f, 
    -0.00615812f, 0.12302796f, 0.06358265f, 0.07692094f, 0.02024136f, 0.18547368f, 0.37203160f, -0.23899992f, 
    -0.00524122f, 0.08349919f, -0.04492100f, -0.07735109f, -0.01369585f, 0.07486796f, -0.36958480f, -0.01600123f, 
    0.01468348f, 0.15161711f, -0.20675635f, 0.26364100f, -0.10736275f, 0.05687907f, -0.15759200f, -0.00189868f, 
    0.09539547f, 0.09805630f, 0.32480592f, -0.15380926f, 0.07367818f, -0.03312277f, 0.21562773f, -0.04018686f, 
    0.02656941f, 0.03432931f, -0.01964132f, 0.00349567f, -0.02625440f, -0.08304574f, 0.02896929f, 0.18254949f, 
    -0.29229781f, 0.07261401f, 0.00713684f, 0.35441709f, -0.05083483f, 0.06295128f, -0.09082476f, -0.29959372f, 
    0.02597148f, -0.24145988f, -0.12581764f, -0.09317072f, -0.03765158f, 0.03703715f, -0.10554952f, 0.04352379f, 
    0.06986065f, -0.05540830f, 0.09322578f, 0.31578189f, -0.15752457f, 0.00958450f, -0.22337849f, -0.10206992f, 
    -0.12241597f, 0.17139825f, 0.02667124f, -0.03743008f, -0.06117292f, -0.02250099f, 0.06278956f, 0.02875121f, 
    -0.28200072f, 0.28616589f, -0.06574162f, 0.01824211f, -0.42318320f, 0.19663090f, -0.08923834f, -0.32286888f, 
    -0.04841803f, -0.03796601f, 0.23702547f, 0.03728141f, -0.05868471f, 0.07603768f, -0.02699292f, -0.05220330f, 
    -0.08309759f, -0.51904798f, -0.00479374f, 0.15587299f, 0.01213137f, -0.21099570f, -0.04456719f, -0.03098458f, 
    -0.48628134f, -0.02022615f, 0.10521605f, 0.03221590f, 0.34370568f, -0.02088371f, 0.04144910f, -0.12579760f, 
    0.16537599f, -0.09095217f, -0.05979017f, -0.26486129f, -0.20020860f, 0.04035804f, -0.30048063f, -0.18280353f, 
    0.25053135f, -0.53391695f, 0.18746179f, 0.06238633f, -0.03401029f, 0.00093802f, -0.06895142f, -0.10541387f, 
    0.27209491f, -0.14324346f, 0.19499202f, 0.25599697f, 0.14268461f, -0.11722429f, -0.05440773f, -0.08653915f, 
    -0.02275054f, -0.04336441f, -0.16827752f, 0.18943574f, -0.05222485f, 0.30651239f, 0.08888681f, 0.02164827f, 
    -0.11336669f, 0.04745057f, 0.08717033f, 0.04684139f, 0.20252280f, 0.12980591f, 0.00886351f, -0.00765150f, 
    -0.06505287f, 0.08079193f, -0.31033945f, 0.08051319f, 0.22912237f, 0.02047179f, 0.01852980f, -0.04992114f, 
    0.14943479f, -0.00530596f, 0.22421752f, -0.25977349f, -0.09369524f, -0.18004903f, 0.01270219f, 0.19894078f, 
    -0.07907660f, -0.16244246f, -0.00886930f, 0.14802447f, 0.08832925f, -0.00796615f, -0.02723297f, 0.07165031f, 
    0.13469094f, -0.11619765f, -0.23318441f, -0.15709847f, 0.01323630f, 0.14605685f, -0.17216899f, 0.30480188f, 
    0.02296033f, -0.22061358f, -0.20683582f, 0.07883227f, 0.14307016f, -0.02053657f, -0.28292388f, -0.40296736f, 
    -0.03515697f, 0.30915663f, 0.15258142f, 0.22895846f, -0.15348628f, -0.38744348f, -0.09389549f, -0.21042629f, 
    0.13444325f, 0.15189047f, -0.08906983f, -0.04125421f, 0.23553267f, -0.12035256f, -0.01085497f, 0.07875053f, 
    0.13373198f, -0.02410867f, 0.03815842f, -0.15685070f, -0.01907999f, 0.16903262f, -0.07879133f, -0.45526290f, 
    0.22957800f, 0.25167009f, 0.24740772f, -0.07596885f, -0.26754391f, 0.04095334f, -0.00735319f, 0.37411532f, 
    -0.05400486f, 0.14417782f, -0.20532088f, -0.00058271f, -0.17905065f, -0.01210878f, -0.42937645f, 0.02615367f, 
    -0.05306454f, 0.06902739f, 0.26637876f, -0.24071068f, 0.02980671f, -0.11098301f, 0.03906630f, 0.19208859f, 
    -0.04044504f, 0.20570752f, 0.06526017f, 0.04404160f, 0.26314032f, 0.09146384f, 0.19147547f, 0.23369452f, 
    -0.02193984f, 0.21568389f, -0.08190143f, -0.39499468f, -0.03670927f, 0.20250736f, -0.28679475f, 0.10404522f, 
    0.22130689f, 0.14907235f, -0.15023367f, -0.17013749f, 0.06250273f, 0.23014328f, -0.38480151f, -0.16261695f, 
    0.16888554f, -0.20717327f, 0.09911612f, -0.06846517f, 0.07671680f, 0.01247012f, 0.00885875f, 0.18675657f, 
    -0.05986207f, 0.00076747f, -0.05054347f, 0.21621175f, 0.13769282f, -0.16963767f, 0.05544221f, -0.18163145f, 
    -0.05740095f, 0.03480681f, 0.08824193f, -0.02135302f, -0.18882464f, -0.09082859f, 0.14437710f, 0.05026287f, 
    -0.06270161f, -0.07550649f, 0.29133800f, -0.42441711f, -0.09283237f, 0.18210794f, 0.04008704f, -0.25603846f, 
    0.17893738f, 0.21821260f, -0.03921088f, 0.00064280f, -0.05405776f, -0.48477951f, -0.01857647f, 0.10282562f, 
    -0.00471090f, 0.19336092f, -0.11853052f, -0.04335626f, -0.03408720f, -0.13131987f, -0.32717770f, -0.13300891f, 
    0.06256800f, -0.20478271f, 0.06784690f, -0.14364254f, -0.01514902f, 0.00956144f, -0.14882600f, 0.43362114f, 
    0.05691458f, -0.10624044f, -0.12190346f, -0.03390609f, 0.47908705f, 0.20979495f, 0.08507195f, 0.07825658f, 
    -0.43444133f, -0.34546104f, -0.00530576f, -0.06660738f, -0.05807431f, -0.29876670f, -0.01914104f, 0.07553601f, 
    0.06252523f, 0.26281765f, 0.12943023f, 0.02328492f, 0.00788179f, 0.06258596f, 0.08813313f, 0.05258572f, 
    -0.03380819f, 0.06027278f, -0.32805246f, 0.18741499f, -0.20446998f, 0.04743923f, -0.07421841f, 0.00913204f, 
    -0.52820116f, -0.15876146f, -0.00804233f, -0.00770358f, -0.07278693f, 0.18349345f, -0.16668643f, -0.04181140f, 
    0.08216897f, 0.02164353f, 0.05513040f, 0.00921016f, -0.02895361f, -0.14135960f, 0.08677279f, -0.27931315f, 
    0.20791484f, -0.09403063f, -0.11330753f, 0.10862389f, 0.42813712f, -0.00625504f, 0.12493610f, -0.22974037f, 
    -0.04510354f, 0.26974204f, -0.10302109f, -0.01923199f, -0.05233890f, -0.27031019f, -0.01289124f, 0.20995143f, 
    -0.30661643f, -0.12392408f, 0.07298548f, -0.11368071f, -0.14791891f, 0.11250786f, 0.23663090f, -0.03214301f, 
    0.02380868f, -0.13455294f, 0.23681863f, 0.03812051f, 0.04003283f, 0.02781418f, 0.00267788f, -0.10184932f, 
    0.03182479f, 0.04252959f, 0.03110250f, -0.09814577f, -0.61877412f, 0.07988258f, 0.11108633f, 0.04569210f, 
    0.10118419f, -0.00710870f, 0.24857517f, 0.02795023f, 0.19062959f, -0.01957216f, 0.03387015f, 0.03380900f, 
    -0.01869952f, -0.01395917f, -0.38171941f, 0.21083714f, 0.13369173f, 0.04266138f, 0.15756471f, -0.08526359f, 
    -0.13761298f, -0.10407265f, -0.02541835f, 0.04290121f, -0.07295346f, 0.15224409f, -0.03344655f, -0.02186941f, 
    -0.41203380f, 0.03739889f, 0.02815447f, 0.19530502f, 0.03643316f, 0.05545262f, -0.08987620f, -0.46281537f, 
    0.20743261f, -0.04452979f, -0.20257214f, 0.19454290f, 0.02243026f, -0.03409701f, -0.05643743f, 0.27119803f, 
    -0.05647154f, -0.04415191f, -0.16080029f, 0.15777108f, 0.15581138f, 0.11559456f, -0.19703835f, -0.16116731f, 
    0.08116816f, 0.22369787f, 0.08148526f, -0.03263494f, -0.12972941f, 0.14966488f, -0.03319167f, 0.10525383f, 
    -0.22017530f, 0.09666902f, -0.05161224f, 0.03611439f, -0.04256602f, 0.13209939f, -0.02791906f, -0.34385940f, 
    -0.28577837f, -0.06091675f, 0.08475897f, -0.16266736f, 0.13692261f, 0.10519975f, 0.06456598f, -0.20720313f, 
    -0.15400113f, -0.31499234f, 0.00015546f, 0.07901980f, -0.39138287f, -0.27531156f, 0.08257500f, -0.03638062f, 
    0.08155752f, -0.07338958f, 0.03811339f, -0.04824186f, -0.11542128f, -0.03171903f, 0.02936006f, -0.03141678f, 
    0.03286535f, 0.00540982f, -0.02373053f, -0.07573793f, -0.00513063f, -0.03593678f, -0.08725521f, -0.02286244f, 
    0.02764343f, 0.00104763f, -0.06110478f, -0.06559695f, -0.08521108f, 0.04880365f, 0.01119937f, 0.02577711f, 
    -0.07175498f, -0.00926216f, -0.00122638f, 0.00510510f, -0.04264889f, -0.03073439f, 0.06776448f, -0.08815227f, 
    -0.00513501f, 0.04875647f, 0.02056779f, 0.00457122f, 0.05653280f, 0.00094780f, -0.01361706f, -0.04837473f, 
    0.05593133f, 0.05435948f, -0.05136899f, 0.03604269f, 0.02510017f, -0.02428746f, 0.06798098f, -0.00461604f, 
    -0.07755207f, 0.05711007f, 0.00891916f, -0.02859133f, -0.05634125f, -0.01300244f, -0.01609607f, -0.06428737f, 
    0.04160320f, 0.05100551f, -0.04619657f, 0.00844556f, -0.05614724f, -0.02478339f, 0.03272511f, -0.07614536f, 
    0.05010533f, -0.08851346f, 0.04431678f, -0.02187321f, -0.02328745f, -0.03482876f, 0.04199227f, -0.10167644f, 
    -0.06287530f, -0.05547861f, -0.03798337f, -0.10818269f, -0.02621942f, -0.00910566f, 0.05877337f, -0.05535125f, 
    0.08739420f, 0.02461164f, -0.06991524f, 0.05653625f, -0.05628637f, -0.07966214f, -0.06388809f, -0.07607446f, 
    -0.08855069f, 0.05618446f, -0.00684348f, 0.00114136f, -0.08931563f, -0.01555295f, -0.06882224f, 0.08353164f, 
    0.03307328f, 0.02342261f, -0.04258398f, -0.08364160f, 0.04649733f, 0.01463022f, -0.01488667f, 0.00507122f, 
    -0.09012376f, -0.00228109f, -0.07508689f, -0.05514779f, 0.02463786f, -0.05613687f, -0.01411643f, -0.05786102f, 
    0.08828778f, -0.00462800f, -0.11650867f, -0.11165889f, 0.04027835f, -0.01655101f, -0.01948157f, 0.02466431f, 
    0.01864949f, -0.05271868f, -0.06508551f, -0.07917490f, 0.07825755f, -0.02983779f, 0.02866494f, 0.06539035f, 
    -0.17250095f, -0.11911570f, 0.00297753f, 0.09125531f, 0.31544748f, -0.21810152f, 0.00869136f, -0.21322545f, 
    -0.28610247f, 0.18371236f, 0.13783862f, 0.22675620f, 0.29089370f, 0.00176813f, -0.38541314f, -0.04206125f, 
    0.06268089f, 0.21069658f, -0.10381462f, 0.13726535f, 0.03883433f, -0.12826584f, -0.01812233f, 0.05424027f, 
    -0.03994320f, 0.05069655f, -0.03802306f, -0.00858773f, 0.14625722f, 0.19708863f, 0.05479196f, 0.02766749f, 
    -0.09440277f, -0.12600414f, 0.12745553f, -0.04410423f, 0.02577174f, -0.05227377f, -0.13719341f, 0.01576428f, 
    -0.21340348f, 0.03326973f, -0.03268242f, 0.10049954f, 0.02581733f, 0.09114356f, 0.19265182f, 0.02913560f, 
    0.07573698f, -0.20143628f, 0.17114826f, 0.03140376f, 0.42106128f, 0.08318343f, 0.20530640f, -0.05536876f, 
    0.09128956f, -0.02199017f, 0.00069231f, 0.37484896f, 0.10316819f, -0.05217563f, 0.03054216f, -0.05927845f, 
    0.00639799f, 0.13509502f, -0.06626562f, 0.01521813f, -0.07988922f, -0.07785642f, 0.06167621f, 0.11926541f, 
    -0.30805475f, -0.37997383f, -0.03879007f, 0.08412623f, 0.00013921f, 0.07036700f, -0.49794593f, -0.16498536f, 
    0.17702013f, 0.07780597f, -0.14615488f, 0.14805637f, 0.34739020f, 0.07129698f, -0.01760011f, 0.18059568f, 
    -0.00068146f, -0.10617758f, -0.03286312f, 0.15903907f, -0.03978820f, -0.06493489f, 0.01164179f, -0.20832086f, 
    -0.13128807f, 0.20122787f, 0.06713425f, 0.06619131f, -0.12311473f, 0.21279186f, 0.03359668f, 0.27950045f, 
    -0.30487704f, 0.29639137f, 0.00123597f, -0.12249377f, -0.03287201f, -0.10543064f, -0.12441076f, -0.19127056f, 
    -0.11732496f, 0.08591516f, 0.19289620f, -0.18531205f, -0.03359497f, -0.00621325f, 0.07564596f, -0.07348246f, 
    -0.66089720f, -0.40756306f, 0.05580070f, -0.08875563f, -0.20709790f, -0.11836280f, -0.02038889f, -0.02438836f, 
    -0.07819657f, 0.16719608f, 0.06589202f, -0.12818944f, 0.14195131f, -0.05426445f, -0.03925745f, 0.06251791f, 
    -0.11249194f, 0.35890013f, 0.07851946f, 0.21436629f, 0.38095009f, -0.06453578f, 0.20133097f, 0.14182977f, 
    -0.02225942f, 0.25875920f, -0.22937031f, -0.36391276f, -0.12369441f, 0.14639707f, -0.11219165f, 0.30510092f, 
    -0.01746948f, -0.12724692f, -0.26238987f, -0.15020585f, 0.09523903f, 0.19020122f, -0.20297654f, -0.17824776f, 
    -0.25965577f, -0.28758159f, 0.07723691f, -0.26448110f, 0.01718835f, -0.35759646f, -0.29062355f, 0.11745732f, 
    0.10071985f, -0.01682503f, -0.18916239f, 0.07322144f, 0.16392662f, 0.03680252f, 0.12302756f, 0.00692984f, 
    0.02173256f, -0.32546780f, 0.23282726f, 0.03641805f, 0.02796953f, -0.08943450f, 0.31728724f, 0.10339817f, 
    -0.01283698f, -0.01818530f, -0.17824596f, -0.16910739f, 0.18307102f, 0.06708743f, 0.00298353f, 0.04245226f, 
    0.07666595f, -0.16136901f, -0.04611232f, -0.06249272f, 0.02644556f, -0.00707095f, 0.11198582f, -0.01132017f, 
    -0.02898195f, -0.06284684f, -0.09038151f, -0.25658524f, 0.05006390f, 0.02347158f, -0.04773691f, 0.33233362f, 
    0.18466365f, 0.03362712f, -0.12420826f, -0.00086400f, 0.07141285f, 0.05774159f, -0.05483974f, 0.41562259f, 
    0.03203287f, -0.19040290f, -0.21790417f, -0.16665132f, -0.05259117f, 0.33406976f, 0.07027911f, 0.10453089f, 
    -0.31340653f, -0.31270343f, 0.03162039f, 0.00182684f, -0.02318657f, -0.08218427f, 0.04662716f, 0.06913587f, 
    0.06450714f, 0.13311926f, 0.19731236f, -0.02697783f, 0.13697018f, 0.05690069f, -0.06728135f, 0.13844307f, 
    -0.20306171f, 0.19650562f, -0.33746919f, 0.23405172f, -0.16490482f, 0.00213300f, -0.07982302f, 0.00920743f, 
    -0.05146573f, -0.24811123f, 0.01602720f, -0.09982783f, -0.13784096f, -0.11676090f, -0.09588885f, -0.08675826f, 
    -0.05339143f, 0.04101139f, 0.01013968f, 0.03605106f, 0.00503860f, -0.08581211f, 0.01994378f, -0.01358583f, 
    0.05280604f, -0.03682075f, -0.07246388f, 0.00883785f, -0.08213677f, -0.01019968f, 0.01908454f, -0.03092307f, 
    -0.03294430f, -0.05703694f, -0.06604556f, 0.01676323f, 0.02170289f, 0.02623812f, 0.00365287f, -0.02497105f, 
    -0.00247912f, 0.03954596f, -0.05558148f, -0.05480915f, -0.06128176f, 0.02152105f, -0.09171727f, -0.02549412f, 
    0.01203423f, -0.00998994f, -0.07730900f, -0.03620791f, 0.05567078f, -0.00050043f, -0.10487321f, 0.04151962f, 
    0.04181808f, 0.01455689f, -0.10718123f, 0.05499943f, -0.01561740f, 0.02575709f, -0.02495068f, 0.04221464f, 
    -0.08434752f, -0.10462364f, 0.02760067f, -0.05047042f, -0.05078160f, 0.00824967f, -0.05694972f, -0.10535335f, 
    -0.11827501f, -0.08659625f, 0.05069742f, 0.07124727f, -0.06122831f, -0.08033701f, -0.01782427f, -0.09183597f, 
    -0.06989076f, -0.05962218f, -0.04071300f, 0.02915195f, -0.04092626f, 0.05780914f, -0.09157258f, -0.00007878f, 
    -0.05346605f, -0.08719619f, 0.01793757f, -0.08375251f, 0.05586999f, -0.02442447f, -0.00395559f, 0.06785687f, 
    -0.02065188f, 0.02214876f, 0.06761211f, -0.10736893f, -0.02271996f, 0.01703768f, 0.04959789f, -0.03722872f, 
    -0.06318462f, 0.08127981f, 0.02820822f, 0.05336400f, -0.00118179f, 0.05329805f, 0.02736955f, -0.07909036f, 
    0.00613404f, -0.02778537f, 0.04963200f, 0.05578034f, -0.08188484f, -0.00400457f, -0.00891417f, -0.09751815f, 
    -0.07732896f, 0.02353220f, 0.03323287f, -0.00898109f, 0.01150006f, -0.03339742f, -0.05887345f, -0.07529143f, 
    -0.00864092f, -0.07690392f, -0.08985116f, -0.06509392f, 0.04182219f, 0.02376227f, 0.00364924f, -0.01331777f, 
    -0.06629451f, -0.00278884f, -0.02144300f, 0.01354001f, 0.07274526f, -0.06543148f, 0.06466198f, 0.04231384f, 
    -0.14251055f, -0.13520558f, -0.52402264f, 0.08311941f, 0.39035070f, -0.00284287f, -0.14108977f, 0.02319646f, 
    0.10986704f, 0.23746170f, -0.04063639f, 0.28666630f, 0.38764921f, -0.15980895f, -0.09366798f, -0.15473159f, 
    -0.22713360f, 0.14214820f, -0.21267429f, 0.08731510f, 0.05204495f, -0.05456762f, -0.17041701f, 0.25387180f, 
    -0.25107649f, -0.12779643f, -0.00328920f, 0.20374346f, 0.04226889f, -0.05825163f, 0.16465229f, -0.14838968f, 
    -0.34665102f, -0.09811744f, 0.27280414f, -0.10189982f, 0.07676511f, -0.22544740f, -0.17012346f, 0.22416714f, 
    -0.00992149f, 0.01167285f, -0.15680733f, 0.36799115f, 0.09458111f, -0.08835349f, 0.38637012f, 0.06251479f, 
    0.17323065f, -0.13725191f, 0.25659883f, 0.03023862f, -0.06051367f, -0.00846250f, 0.21581419f, 0.04185065f, 
    0.01259152f, -0.01697296f, -0.23909749f, 0.48047125f, 0.23045501f, -0.21505490f, 0.15041944f, -0.37358668f, 
    0.02560876f, -0.18968681f, 0.04119045f, 0.08909088f, -0.03356054f, 0.30794996f, 0.10278241f, 0.13851731f, 
    -0.23240227f, -0.31359389f, -0.08344310f, 0.12169819f, -0.02756322f, 0.02924616f, -0.21654364f, 0.33407733f, 
    0.27013570f, 0.20008148f, -0.30728653f, 0.26875439f, 0.40031484f, 0.07210235f, 0.11880232f, 0.19067486f, 
    0.04836611f, 0.04733583f, -0.09856332f, -0.13017857f, -0.37338176f, -0.00065461f, -0.05891289f, 0.13305545f, 
    -0.09625283f, 0.11350317f, 0.04882813f, 0.02251105f, 0.01751504f, 0.19490577f, 0.00446723f, 0.15258777f, 
    -0.14556800f, 0.27548286f, 0.06972819f, -0.28732568f, -0.06718601f, -0.06169044f, -0.28930292f, -0.17573619f, 
    -0.09776987f, 0.21285158f, -0.05002462f, 0.01931665f, -0.12261967f, 0.12645951f, -0.04834868f, 0.06310857f, 
    -0.16086121f, -0.36871454f, 0.13403971f, -0.03261969f, 0.12237044f, -0.12224696f, -0.09761415f, -0.02010929f, 
    -0.02691589f, 0.05954303f, 0.33853936f, -0.04580865f, 0.41800427f, -0.15848395f, -0.01862201f, 0.01795189f, 
    0.09665647f, 0.14449702f, -0.25958830f, -0.21995835f, -0.00974014f, 0.01247456f, -0.20514287f, 0.06786704f, 
    -0.07925972f, -0.09571584f, -0.40852806f, -0.08467244f, 0.06121188f, 0.21538872f, -0.05668002f, 0.07929689f, 
    0.17294376f, -0.28927013f, 0.16163652f, -0.09632022f, -0.05567084f, 0.12391435f, -0.10675514f, 0.09001521f, 
    0.03634948f, -0.02787430f, 0.10235665f, 0.03215771f, 0.07271527f, 0.19720465f, -0.36153641f, 0.11301734f, 
    0.14601885f, 0.03257202f, 0.19621369f, 0.01600214f, 0.06864533f, 0.06477122f, -0.79711396f, -0.03792667f, 
    -0.15326124f, 0.09935500f, -0.11323511f, 0.06137544f, 0.46207544f, -0.19322091f, 0.10321190f, 0.00288823f, 
    0.10609838f, 0.03537384f, 0.26768026f, 0.04463334f, 0.08112948f, 0.13411719f, -0.10601416f, 0.35285932f, 
    -0.00207478f, 0.10086528f, -0.05018102f, 0.00176639f, 0.05317944f, -0.06744156f, -0.29136631f, 0.28871453f, 
    -0.00290266f, -0.12948373f, -0.01628236f, -0.13500585f, 0.07452754f, 0.16936241f, 0.13825673f, 0.43330693f, 
    -0.12717831f, -0.20852192f, 0.08515695f, -0.06595653f, -0.02971358f, 0.01614706f, -0.36625752f, 0.03126530f, 
    -0.09109229f, 0.11079428f, -0.66546720f, -0.04679167f, 0.12528011f, 0.00607089f, -0.36523491f, -0.70251709f, 
    -0.01787202f, 0.15609676f, -0.04742892f, -0.07693747f, -0.01667467f, -0.00770048f, -0.07049947f, 0.09479964f, 
    -0.20677632f, -0.14608844f, 0.02376346f, -0.13856764f, -0.24139445f, 0.04687290f, -0.22313428f, -0.70504051f, 
    0.09340768f, -0.00716496f, 0.08451983f, 0.16159894f, -0.16259895f, 0.15615046f, 0.02471103f, 0.21807882f, 
    0.02020412f, -0.25177664f, -0.14951771f, 0.08307988f, -0.35550386f, -0.34296566f, -0.23007195f, 0.03863372f, 
    -0.56689692f, 0.09822359f, 0.20800631f, 0.01137836f, 0.22804120f, -0.09310541f, 0.18217416f, -0.56095439f, 
    0.25207305f, 0.19776174f, 0.08418483f, 0.15164772f, 0.11456443f, 0.28439870f, -0.04586343f, -0.06977788f, 
    0.35644570f, 0.06601638f, 0.00351203f, -0.10484319f, -0.04590579f, -0.09566776f, -0.13736640f, 0.08822361f, 
    0.08802481f, 0.01461580f, 0.00899234f, -0.19519810f, 0.02912674f, 0.03854433f, 0.02993643f, -0.32013252f, 
    -0.03826216f, -0.10883693f, 0.04321770f, 0.05992506f, -0.04136255f, -0.04625084f, 0.02314535f, -0.19813764f, 
    -0.42686713f, 0.07859442f, 0.10810114f, -0.34126636f, 0.02870612f, 0.17774113f, -0.23010954f, -0.01249452f, 
    -0.11082327f, -0.10899077f, -0.06187280f, 0.20362088f, 0.36352491f, 0.12506185f, 0.18743607f, 0.04017938f, 
    0.07458180f, -0.01943447f, -0.20816521f, 0.04375992f, 0.07320673f, 0.14638369f, 0.09597488f, -0.51055562f, 
    0.09430259f, 0.12207664f, 0.03263239f, 0.11608761f, -0.07343914f, -0.54245234f, 0.01934491f, 0.23366693f, 
    0.05324712f, -0.26244897f, -0.17840962f, 0.06510493f, 0.10770374f, 0.17218305f, -0.50760752f, -0.43719578f, 
    0.18000276f, -0.30664465f, -0.04029017f, 0.21713342f, 0.02519611f, -0.04814530f, -0.11955096f, -0.17101899f, 
    0.08656611f, 0.28431693f, -0.35183817f, 0.52218950f, -0.14964841f, 0.06843614f, 0.14128047f, -0.52828664f, 
    -0.00250293f, -0.05668564f, 0.14325175f, -0.08346231f, 0.06853919f, -0.06946048f, 0.06969204f, 0.12390827f, 
    -0.25942007f, 0.14817697f, 0.23362213f, -0.17276385f, 0.45610219f, 0.13901863f, -0.12695514f, -0.27046970f, 
    0.04113833f, -0.06738260f, 0.07598465f, -0.01091328f, -0.24270424f, 0.06564862f, 0.01234854f, 0.12143361f, 
    -0.57961512f, 0.12648082f, -0.22632451f, 0.10755959f, -0.51119792f, 0.02061668f, -0.33710784f, -0.00715206f, 
    -0.05573057f, -0.00609394f, 0.12688109f, 0.07681842f, -0.01083025f, -0.06869299f, -0.01259082f, -0.52658349f, 
    0.30817986f, -0.16400898f, 0.04663696f, 0.21268351f, 0.14378725f, -0.17468831f, 0.01476352f, -0.18736283f, 
    -0.16300821f, 0.10086230f, -0.20724505f, -0.09440437f, -0.00867295f, 0.00876142f, -0.06661096f, 0.05689482f, 
    -0.28067657f, -0.32532236f, 0.10572909f, -0.18698640f, -0.01132508f, 0.04927494f, 0.04927214f, -0.00171150f, 
    -0.06405597f, -0.06463817f, 0.18126665f, 0.15072729f, -0.06289969f, 0.02389918f, 0.23715192f, 0.12373582f, 
    -0.07462000f, -0.00642690f, -0.05528131f, -0.17372720f, -0.66272485f, 0.00439685f, -0.07675949f, 0.03316331f, 
    0.04538611f, -0.03811163f, 0.03342460f, 0.02202399f, 0.12666793f, 0.09648363f, 0.11244035f, 0.07580683f, 
    -0.01630914f, -0.02534203f, -0.10939539f, -0.58586425f, 0.05312195f, -0.05910840f, -0.06442899f, 0.32526356f, 
    0.05749548f, 0.01421856f, 0.06070359f, 0.09643178f, 0.05517809f, 0.11656702f, -0.06307443f, 0.04359153f, 
    -0.19249828f, 0.00565756f, 0.00340454f, 0.02362703f, -0.03140019f, 0.19999315f, -0.07828391f, 0.08268414f, 
    0.17461748f, 0.05265209f, -0.11355027f, 0.06297026f, -0.07679249f, -0.03319770f, -0.12558328f, 0.20571133f, 
    -0.02069214f, -0.21210660f, -0.43899715f, -0.13985911f, -0.34454733f, 0.12976640f, 0.03876793f, -0.69272882f, 
    -0.04620965f, 0.01602334f, -0.00425044f, 0.05539440f, -0.05897954f, 0.10484297f, -0.03773620f, -0.02217877f, 
    -0.14986464f, 0.11101376f, -0.29967985f, 0.05142302f, -0.02010110f, 0.02682977f, 0.06722455f, -0.59973121f, 
    -0.16819519f, 0.27184454f, 0.02139463f, -0.11688980f, -0.35827088f, 0.04156058f, 0.01276581f, -0.18741830f, 
    -0.06844092f, -0.08021442f, 0.06235994f, -0.06404751f, -0.41758391f, 0.08603097f, 0.10424501f, 0.07522418f, 
    0.03711483f, -0.04598418f, 0.07773872f, -0.00734653f, 0.28372476f, -0.04131872f, 0.02291239f, -0.19714613f, 
    -0.08329839f, 0.32549122f, -0.16499004f, 0.51831555f, 0.53883386f, -0.04823059f, -0.21710368f, -0.13319151f, 
    -0.26600030f, 0.19393472f, -0.14454351f, -0.17688438f, -0.08100452f, -0.12716323f, 0.00983569f, 0.05896155f, 
    -0.19451226f, -0.01406311f, -0.08983343f, -0.04781033f, 0.13137841f, 0.12512752f, 0.01543224f, 0.01960942f, 
    -0.09109760f, -0.23657437f, 0.21347782f, -0.22050658f, 0.01723332f, 0.00096869f, -0.11122126f, 0.28661975f, 
    -0.02823759f, 0.11258342f, -0.02404238f, 0.33989501f, -0.14726898f, -0.06404530f, 0.37926000f, -0.06685129f, 
    0.01359420f, -0.06119549f, 0.13878307f, 0.13441138f, 0.12825665f, -0.09636291f, 0.10997193f, -0.09496533f, 
    -0.06556928f, -0.17321004f, -0.15813611f, 0.50550205f, 0.11384033f, -0.11363316f, 0.20187488f, -0.05724451f, 
    0.00315254f, 0.08720382f, -0.03935680f, 0.06638552f, -0.00734410f, 0.18509457f, 0.05016866f, 0.08445866f, 
    -0.45249188f, -0.16868725f, -0.12624729f, 0.27019936f, 0.03263259f, 0.01189410f, -0.16292049f, 0.07548132f, 
    0.20648649f, 0.01519199f, -0.10273411f, 0.21707797f, 0.36605877f, 0.06511940f, 0.07509897f, 0.33908483f, 
    -0.05408834f, 0.07351571f, -0.11153606f, 0.00448036f, 0.09503891f, 0.19970237f, -0.01160008f, -0.06481463f, 
    -0.20297934f, 0.13805109f, 0.06330658f, 0.04626958f, -0.08839279f, 0.22168069f, -0.01101257f, -0.04800008f, 
    -0.21662575f, 0.31653515f, 0.16445854f, 0.02625967f, 0.00765488f, -0.12498628f, -0.15957193f, -0.24452193f, 
    -0.29620540f, 0.06869408f, -0.09513368f, 0.05538608f, 0.25312319f, 0.08178955f, -0.01920603f, 0.01031526f, 
    -0.15518455f, -0.38251719f, 0.06543443f, -0.02817854f, -0.31781748f, -0.27723378f, 0.05232231f, 0.03178049f, 
    -0.18459716f, -0.05634047f, -0.10122664f, 0.16271022f, -0.03833409f, 0.05086585f, -0.00874273f, 0.15528786f, 
    0.11178178f, -0.07479232f, -0.34847188f, -0.06981764f, -0.20206395f, -0.06383688f, -0.04228710f, 0.21459013f, 
    -0.16594493f, -0.05369468f, -0.04785297f, -0.16474742f, -0.00899021f, 0.09318809f, -0.23187074f, 0.17380770f, 
    0.12349020f, -0.07650501f, 0.26625574f, -0.09187430f, -0.12161487f, -0.07359880f, -0.10330079f, -0.24713771f, 
    -0.14171714f, 0.08349533f, 0.20725541f, 0.21949145f, 0.16114326f, -0.12858948f, 0.15276177f, -0.11507785f, 
    -0.14922622f, 0.09223839f, 0.29533064f, 0.08609418f, 0.15488958f, -0.05964335f, -0.38752848f, -0.10998100f, 
    0.14149179f, 0.12097925f, -0.19225980f, 0.09724888f, 0.31248036f, -0.17622775f, 0.04208580f, 0.23632768f, 
    -0.32514155f, 0.21041867f, 0.24577525f, 0.11560757f, 0.11718729f, 0.37708727f, 0.14906774f, -0.20654443f, 
    -0.08352349f, -0.01548274f, -0.08294146f, 0.02765485f, -0.06454540f, -0.19117063f, -0.12563263f, 0.38785607f, 
    0.25160229f, -0.29945824f, 0.05618985f, 0.00978910f, 0.07572655f, -0.17405702f, -0.08316613f, -0.03122756f, 
    0.06168749f, -0.39339018f, 0.33144641f, 0.07966498f, -0.35529464f, -0.08575364f, -0.03171381f, 0.25180012f, 
    0.10702977f, 0.15815775f, -0.06234694f, -0.26454282f, 0.22118568f, 0.24936956f, -0.13494778f, 0.07339176f, 
    -0.06675640f, -0.04701595f, 0.12937443f, -0.08347031f, 0.21668896f, -0.10894529f, 0.06484000f, -0.39547500f, 
    0.30719280f, -0.28434455f, -0.03222180f, -0.12228262f, 0.19698752f, 0.15416433f, -0.12280542f, 0.09077623f, 
    0.09832474f, -0.28831056f, -0.13352096f, 0.09027670f, -0.24930771f, 0.11755583f, 0.05165011f, 0.12387081f, 
    -0.33320957f, 0.36139113f, -0.07512420f, 0.30710098f, 0.01757767f, 0.09597478f, -0.40143558f, 0.07139437f, 
    -0.06017284f, 0.06328468f, -0.08189289f, -0.03734167f, 0.03589945f, -0.01530781f, 0.07818717f, 0.03320491f, 
    0.05808638f, 0.06040524f, -0.01951382f, 0.00502959f, 0.08096404f, 0.05760993f, 0.07540516f, 0.05951448f, 
    0.04885128f, 0.03676987f, 0.05515386f, -0.07098076f, 0.06203730f, 0.01737485f, 0.02532818f, 0.03160426f, 
    -0.05670102f, 0.08143048f, -0.10203063f, -0.11201009f, 0.05066700f, 0.05559350f, -0.10304673f, 0.01351591f, 
    0.04150068f, -0.00462089f, 0.07213607f, 0.07944962f, -0.00553532f, -0.06720991f, -0.02233304f, 0.03358154f, 
    0.03167226f, 0.05707050f, -0.05920732f, 0.01041828f, -0.10511784f, -0.03497517f, -0.06497079f, -0.00692042f, 
    -0.07479028f, -0.06035454f, -0.03799515f, 0.08373191f, -0.06028900f, 0.01120666f, -0.06652736f, -0.07848322f, 
    -0.03385638f, -0.03163802f, -0.03843094f, -0.06402249f, -0.10164133f, -0.04712030f, -0.06229629f, -0.04865984f, 
    0.04232366f, -0.07563157f, -0.01155164f, 0.04536248f, 0.01483756f, -0.00555090f, -0.08323505f, -0.07747041f, 
    -0.01174476f, 0.05792106f, -0.07426098f, -0.08546621f, 0.11208565f, -0.07261849f, 0.04740416f, -0.00939193f, 
    -0.05745881f, -0.10480315f, -0.02219565f, -0.06999294f, 0.07349513f, 0.08568384f, 0.00407061f, -0.08892857f, 
    0.03619823f, 0.00139181f, 0.06126750f, 0.02407505f, 0.15407005f, -0.07023007f, -0.10436168f, 0.14253554f, 
    -0.06955394f, -0.02334106f, 0.02532952f, 0.06903874f, -0.12501504f, -0.11147001f, 0.02537606f, -0.01431418f, 
    0.07121249f, 0.11697502f, -0.04794997f, -0.04125489f, -0.12467834f, -0.02586746f, 0.05639336f, -0.02418146f, 
    0.13245362f, -0.09455455f, -0.04630709f, -0.02426557f, -0.04062785f, -0.15558940f, -0.00426504f, 0.00716698f, 
    0.03600802f, 0.00584959f, 0.01670049f, -0.00323706f, 0.04368366f, 0.05440799f, -0.08826818f, -0.07293636f, 
    -0.04925483f, -0.10406600f, 0.22693741f, -0.00922438f, 0.10548396f, 0.10474281f, 0.09125417f, -0.04172821f, 
    -0.05084693f, -0.05376348f, 0.10108653f, -0.17451416f, -0.34044424f, -0.02194405f, -0.28302339f, -0.02213020f, 
    0.15695815f, -0.28700399f, 0.05417825f, 0.15496667f, -0.00837356f, -0.04010917f, 0.00130450f, -0.08464076f, 
    -0.02835444f, 0.03770688f, 0.22759403f, 0.08181385f, 0.12661885f, -0.10802897f, 0.04302180f, -0.17809533f, 
    -0.10470261f, -0.03640424f, -0.00862020f, 0.17156968f, -0.09385473f, 0.07036799f, 0.02219225f, -0.00249841f, 
    -0.15075165f, -0.01848748f, 0.33644563f, -0.10285731f, -0.11643301f, -0.01010147f, -0.14740086f, -0.09140005f, 
    0.20343474f, 0.12212774f, -0.14440040f, 0.02467857f, 0.54527467f, 0.03833633f, -0.15436360f, -0.01807021f, 
    0.15432258f, 0.15196902f, -0.40911171f, 0.09929343f, -0.15313654f, -0.10243014f, -0.00365083f, 0.29112285f, 
    0.02701887f, 0.00009017f, -0.04658411f, 0.07073269f, -0.11568675f, -0.06078381f, -0.03681517f, 0.25225288f, 
    0.21495554f, -0.30261901f, -0.07349344f, -0.21239376f, -0.09740471f, 0.11050417f, -0.12807140f, 0.30342847f, 
    -0.11634096f, -0.00035609f, -0.09415750f, 0.14894648f, -0.13350789f, 0.00165921f, 0.02666852f, -0.38940006f, 
    0.10627385f, 0.12921830f, 0.09864694f, -0.17929909f, -0.61646378f, -0.07161894f, 0.04415740f, 0.11422163f, 
    0.32334870f, 0.02253398f, 0.09225900f, -0.06729200f, 0.19736321f, 0.03101337f, -0.00273727f, -0.09892933f, 
    0.07058521f, -0.10486376f, 0.00239185f, -0.28374434f, 0.16120924f, 0.27129218f, -0.18190284f, 0.21084280f, 
    0.21624476f, 0.02402025f, 0.02118510f, -0.03031733f, -0.10300099f, 0.07602522f, 0.00342030f, 0.15926534f, 
    0.03233963f, 0.57223272f, -0.00426239f, -0.13220371f, -0.07114093f, -0.00945748f, 0.04694967f, -0.05496052f, 
    0.02638349f, -0.04747698f, -0.03735896f, 0.01075369f, -0.04514617f, -0.01368776f, 0.07527062f, -0.01774650f, 
    -0.02958559f, -0.12883143f, -0.14126381f, -0.06290449f, -0.15620974f, -0.12845309f, -0.07610840f, -0.05697050f, 
    -0.02984840f, -0.01896896f, 0.05545996f, -0.09847827f, -0.05693251f, 0.03065601f, 0.02298976f, -0.05644570f, 
    0.07004364f, 0.03654114f, -0.05313186f, -0.00408408f, 0.00218218f, -0.06518003f, -0.03779631f, -0.06375910f, 
    -0.09440979f, -0.01216057f, -0.06513456f, 0.03831702f, -0.07150523f, 0.02551248f, 0.07675751f, -0.10749453f, 
    -0.00231845f, 0.08339193f, -0.00257650f, -0.09889107f, -0.04619095f, -0.04313309f, -0.03470269f, -0.03615388f, 
    -0.05797265f, -0.02285137f, -0.02297875f, -0.03480292f, 0.05781305f, 0.05353913f, -0.05063190f, -0.06645328f, 
    -0.02947303f, 0.02323387f, 0.02835101f, -0.05662847f, -0.06324647f, -0.07740472f, -0.12267766f, 0.04162735f, 
    -0.07360730f, -0.07205251f, -0.05303784f, -0.08047108f, -0.04694214f, -0.01382728f, -0.09063894f, -0.02758348f, 
    -0.11789545f, -0.00999321f, 0.02219256f, -0.03197057f, 0.03686845f, 0.05446381f, 0.04693442f, -0.02391963f, 
    -0.10448763f, -0.02260027f, 0.03384798f, -0.00087731f, -0.05101549f, 0.07343482f, -0.02132225f, 0.01861251f, 
    -0.07691374f, 0.05874502f, -0.10991703f, -0.10936385f, -0.12835260f, -0.13749740f, -0.07848101f, -0.07471108f, 
    -0.01977702f, -0.09646559f, 0.01946439f, 0.00761393f, -0.08316002f, -0.07952857f, 0.03634249f, -0.17384835f, 
    0.03902857f, -0.03633730f, -0.06155480f, -0.09051192f, 0.04178248f, 0.03795888f, -0.10004244f, 0.00222684f, 
    -0.00394542f, -0.05121178f, 0.04253646f, -0.07172299f, -0.02287145f, -0.09403897f, 0.00308851f, 0.00877180f, 
    -0.03533057f, -0.04336155f, -0.08120947f, -0.10163057f, -0.02998489f, -0.07850488f, -0.09373492f, -0.05915940f, 
    -0.24797136f, 0.03737406f, 0.34191731f, -0.20379429f, 0.08268115f, -0.05576488f, 0.12006833f, -0.00435700f, 
    -0.36963421f, 0.35696819f, 0.10047942f, -0.20065100f, 0.15999424f, -0.09481449f, 0.11929745f, 0.43518794f, 
    0.20158720f, 0.09961066f, -0.17715374f, -0.08518028f, -0.03694527f, 0.15246320f, -0.21345495f, 0.12525330f, 
    0.02252788f, -0.03547189f, -0.00253327f, -0.00543362f, 0.13466002f, 0.19740199f, 0.01548136f, -0.31880078f, 
    -0.26434204f, -0.01758298f, 0.04002617f, 0.03181345f, -0.08488717f, -0.23114310f, -0.24618520f, -0.03702507f, 
    -0.19010663f, -0.00013797f, 0.11361350f, -0.25027084f, 0.12195110f, -0.13517243f, -0.08054665f, 0.13768990f, 
    -0.13404517f, -0.21168581f, 0.16589470f, 0.00960686f, 0.06040346f, 0.07134304f, 0.22279514f, 0.05597585f, 
    0.01339775f, 0.04179427f, -0.77456313f, 0.00523964f, 0.21611254f, 0.39181736f, 0.02487228f, -0.06156592f, 
    0.03541364f, -0.00022315f, 0.04699205f, 0.03804413f, 0.01977938f, -0.21838556f, 0.10190984f, 0.10860452f, 
    0.10963083f, -0.24996710f, -0.16709501f, -0.56244606f, -0.00258932f, 0.32853967f, -0.50269771f, -0.12747729f, 
    0.17037868f, 0.05619266f, -0.07492117f, 0.08922059f, 0.06536204f, 0.06710438f, 0.07593630f, -0.14137945f, 
    0.12718488f, -0.32606187f, -0.05883609f, -0.26792842f, -0.41795617f, 0.32087445f, 0.12793018f, 0.02216607f, 
    -0.15078464f, -0.08361870f, 0.10624067f, -0.07782603f, -0.03945197f, -0.07518461f, 0.04561632f, 0.08593518f, 
    -0.04368407f, -0.11179407f, 0.17539506f, -0.35932216f, 0.19512306f, 0.21881564f, -0.21596058f, 0.40814093f, 
    0.05314422f, -0.09990843f, -0.18852316f, 0.14220887f, -0.65957165f, -0.07677764f, -0.04620187f, 0.27102268f, 
    -0.32812333f, 0.26833251f, -0.18965255f, 0.15675233f, 0.14775448f, 0.11259934f, -0.01668369f, -0.05995857f, 
    -0.09220827f, -0.00629455f, 0.04579032f, 0.03403766f, 0.02572259f, -0.06218402f, 0.01721254f, -0.01146476f, 
    -0.04217960f, 0.01132918f, 0.03724059f, -0.08034547f, 0.00733320f, 0.03592238f, 0.01189411f, 0.06609073f, 
    0.05994085f, 0.00244552f, 0.07215825f, 0.02060705f, -0.00521011f, -0.05157474f, -0.08666968f, -0.00300524f, 
    0.04517172f, -0.04862386f, -0.09433991f, -0.03386362f, -0.07922027f, -0.00771597f, -0.05266520f, 0.03406298f, 
    -0.06038701f, -0.04739556f, 0.07700012f, -0.09268500f, -0.09552394f, -0.04617583f, -0.04353251f, -0.06461884f, 
    -0.02826550f, 0.04124472f, -0.06261735f, -0.02314789f, -0.02306461f, 0.01502744f, -0.06165370f, 0.02046777f, 
    0.07732337f, 0.07822651f, -0.05497681f, 0.05109411f, 0.04355955f, -0.05522157f, -0.08429476f, 0.00190465f, 
    -0.07852147f, 0.03516182f, -0.06326916f, 0.00428635f, -0.10673203f, -0.08093206f, 0.02304659f, -0.11065394f, 
    -0.09639012f, -0.04281493f, -0.02448289f, -0.06880288f, -0.03826432f, 0.01551224f, -0.02403826f, 0.01957843f, 
    -0.02182796f, -0.05058252f, -0.08021583f, -0.03956003f, -0.02619236f, -0.08553283f, -0.07935077f, -0.02945489f, 
    -0.05708380f, -0.07440695f, 0.02700100f, -0.02956902f, 0.04415203f, -0.05176989f, 0.00842775f, 0.02530410f, 
    -0.07112025f, 0.03170425f, -0.03687514f, 0.04025396f, 0.00736971f, -0.07172731f, 0.06150824f, -0.08824778f, 
    -0.01410526f, 0.00132478f, -0.00984637f, -0.06983011f, -0.02073792f, 0.00079075f, 0.01298180f, 0.04126342f, 
    0.00418612f, 0.02768599f, -0.08828580f, 0.00455271f, 0.00476608f, -0.01114247f, 0.01091890f, 0.07171156f, 
    -0.08727762f, 0.05594175f, -0.00867601f, -0.01993416f, 0.05469393f, 0.00121807f, 0.05807527f, 0.07974781f, 
    -0.10739532f, 0.09221975f, -0.09449217f, -0.03718811f, -0.08944353f, 0.00957360f, -0.00317753f, 0.05654940f, 
    0.04851571f, 0.00604755f, -0.00079140f, -0.06934963f, -0.04823852f, -0.08681809f, 0.03529672f, -0.09284332f, 
    0.02187079f, 0.04125816f, -0.03512546f, 0.02103242f, -0.05381989f, 0.05901413f, -0.03693839f, 0.03378573f, 
    -0.02292071f, -0.03614723f, -0.03862745f, -0.05074339f, 0.03628434f, -0.09493792f, 0.02994019f, -0.01341995f, 
    -0.07349700f, -0.03880181f, 0.07473466f, 0.07769496f, 0.06922410f, -0.05582809f, -0.00057014f, 0.00493192f, 
    -0.06616248f, -0.01365235f, -0.04834299f, 0.06444450f, 0.05745075f, 0.02980340f, -0.00444302f, -0.09264668f, 
    -0.01305612f, 0.06817414f, -0.04954407f, -0.04132648f, -0.04615576f, -0.02289473f, 0.08148407f, -0.00857951f, 
    -0.06402566f, -0.06645030f, 0.04402199f, 0.06321414f, 0.02966454f, -0.00461989f, 0.00864468f, 0.05697422f, 
    -0.01883077f, -0.01351542f, -0.07369782f, -0.01579833f, -0.04837947f, -0.04803011f, 0.05366426f, -0.05428728f, 
    0.03850961f, 0.07949971f, -0.00716454f, 0.00249207f, 0.00856512f, 0.06326231f, -0.04805511f, 0.06082093f, 
    0.07682496f, -0.01429577f, -0.02168073f, 0.02981126f, 0.08232149f, 0.01730210f, 0.01466914f, -0.05014553f, 
    -0.02620439f, -0.03562385f, -0.05002102f, -0.06282528f, -0.05823057f, -0.01110829f, -0.09438194f, -0.07277726f, 
    -0.05978781f, 0.02039842f, -0.06906749f, 0.02457246f, -0.09377263f, -0.09134667f, 0.02777440f, 0.04702587f, 
    -0.07917008f, -0.05754600f, 0.07772677f, 0.07472722f, -0.03642460f, -0.07411444f, 0.05856705f, -0.06974507f, 
    0.02823272f, 0.03297767f, -0.07978189f, -0.02216827f, 0.03269096f, 0.01340128f, 0.07313132f, -0.01463540f, 
    -0.00364220f, 0.07284863f, 0.01805919f, 0.08349091f, -0.09061059f, 0.07214384f, 0.08261663f, 0.04121980f, 
    -0.07708810f, -0.04505921f, 0.06704561f, -0.05470609f, 0.07529574f, -0.06056394f, -0.00201257f, -0.08158859f, 
    -0.24441110f, -0.03946912f, 0.01181032f, -0.04123600f, 0.15401475f, -0.10763806f, 0.02769100f, -0.00291862f, 
    -0.33578882f, 0.22716500f, 0.17748463f, -0.26011384f, 0.12482329f, 0.22386457f, -0.10780927f, 0.07683291f, 
    -0.27119929f, 0.06853752f, -0.05342790f, 0.17985244f, -0.00991151f, -0.00052033f, -0.05339382f, 0.03581673f, 
    0.08778705f, -0.07795406f, 0.10853719f, 0.06581717f, 0.04699956f, 0.15552019f, -0.02029297f, 0.12283283f, 
    0.06395692f, 0.15296118f, 0.07920596f, -0.14987807f, 0.23087822f, 0.14955814f, -0.08084396f, 0.07125450f, 
    -0.00219803f, -0.05121974f, 0.14801681f, -0.00946712f, 0.21779156f, -0.01137479f, -0.22471341f, -0.19851126f, 
    0.08805961f, 0.00465673f, 0.00859121f, -0.13334118f, -0.06800020f, -0.01150485f, -0.00225110f, 0.12698430f, 
    0.23890744f, 0.18049811f, 0.10898757f, 0.02422141f, 0.12679486f, -0.04513625f, 0.17410821f, -0.09561597f, 
    0.08209548f, 0.28965595f, 0.02618166f, -0.00937240f, 0.09345118f, -0.31061730f, 0.09071951f, 0.12085073f, 
    -0.20240499f, -0.01097861f, -0.00581951f, -0.11737067f, 0.09578303f, -0.19116996f, 0.08799976f, -0.06077272f, 
    -0.09872378f, -0.06224378f, -0.26048401f, -0.00307621f, 0.16818400f, 0.05842667f, -0.02855348f, 0.01196153f, 
    0.11430813f, -0.09466148f, 0.11223974f, -0.14439496f, -0.46953207f, -0.13501304f, -0.14191227f, 0.12669864f, 
    -0.00310594f, 0.22641319f, -0.07591224f, -0.05542878f, -0.03632643f, -0.02080594f, -0.00766347f, 0.15689467f, 
    -0.13483216f, 0.20976879f, 0.01892239f, 0.02463972f, -0.21111061f, 0.14472184f, 0.09453878f, 0.04849149f, 
    -0.03687015f, 0.07138541f, 0.03412747f, 0.08768037f, -0.19316767f, 0.09669285f, -0.00983760f, -0.10205407f, 
    0.03084612f, -0.22366780f, 0.12910050f, 0.02259604f, -0.00949337f, -0.11161438f, 0.01578319f, -0.02022124f, 
    0.14595969f, -0.20704298f, 0.40080634f, -0.14978777f, -0.16892806f, 0.05623299f, 0.03844181f, 0.29972839f, 
    -0.03718229f, -0.14000368f, -0.08623138f, -0.23862757f, -0.22590761f, -0.14880231f, -0.47795728f, 0.20746113f, 
    -0.06684279f, -0.00746626f, 0.20776992f, 0.14934719f, -0.02833603f, 0.21552300f, -0.09718171f, 0.02770089f, 
    0.01908989f, 0.00335468f, 0.07314405f, 0.41522825f, 0.03390475f, -0.20662203f, -0.11365809f, -0.04910974f, 
    0.07709398f, 0.32488424f, -0.00331000f, 0.16444884f, 0.08962956f, 0.09281057f, 0.39092252f, 0.18123782f, 
    0.00197698f, 0.01207485f, 0.10994971f, 0.10565048f, 0.03885111f, -0.30638653f, -0.07801919f, -0.27039039f, 
    0.22809102f, 0.27701032f, -0.06114772f, 0.02166974f, -0.50897539f, 0.17266512f, -0.08122073f, 0.09183902f, 
    -0.13953803f, 0.09572210f, 0.52570289f, -0.25267503f, -0.28823894f, -0.05371955f, 0.13009746f, -0.17244533f, 
    0.14554898f, 0.08172528f, 0.07212847f, 0.21940991f, -0.00437207f, 0.03349775f, 0.16861975f, 0.10286028f, 
    0.29495680f, 0.20392342f, 0.16017246f, 0.10328726f, -0.02899811f, 0.16203710f, 0.24289338f, 0.12543593f, 
    0.09425261f, -0.03008882f, 0.01405673f, -0.07699069f, -0.06978944f, -0.06638460f, 0.12299763f, -0.17088489f, 
    0.02697672f, 0.22063468f, 0.15329106f, -0.23811564f, -0.17705978f, -0.08552419f, -0.01708540f, 0.23706439f, 
    0.09201094f, -0.12728754f, -0.04542464f, 0.03004029f, -0.02516438f, -0.14247009f, 0.01982743f, -0.01130032f, 
    0.28254366f, -0.12707314f, -0.09052357f, -0.13984144f, 0.03483930f, 0.07103502f, -0.14909856f, 0.51826280f, 
    0.24692427f, 0.06638695f, -0.05211059f, 0.18334687f, 0.34339410f, -0.08516296f, 0.02620695f, 0.12995471f, 
    0.11001822f, 0.72023129f, -0.00090042f, 0.09129773f, 0.31606510f, 0.13656880f, 0.18168354f, 0.01822514f, 
    0.09303629f, -0.10664072f, -0.20859474f, -0.04234070f, -0.10481514f, -0.04450911f, 0.02005353f, 0.06772426f, 
    0.23444325f, -0.05929703f, 0.12722497f, -0.02751422f, 0.03092835f, -0.07934842f, -0.42281762f, 0.06113655f, 
    0.06491342f, 0.12615852f, 0.05126052f, 0.16455753f, -0.01898942f, 0.05685477f, 0.05921961f, -0.08995528f, 
    -0.15846539f, 0.18249410f, -0.18171766f, -0.02861409f, -0.02433933f, -0.08598369f, 0.09272680f, -0.13774225f, 
    -0.21205193f, -0.06578438f, -0.06936705f, -0.08666896f, -0.06695026f, -0.41044614f, 0.05690472f, 0.01436428f, 
    -0.05826510f, -0.05583498f, -0.29289800f, -0.08105940f, 0.03236267f, -0.27186280f, 0.06444655f, -0.18323526f, 
    0.13278502f, -0.26486591f, 0.20203036f, 0.00615029f, -0.01705796f, 0.13162118f, -0.00645749f, -0.09356941f, 
    0.05945791f, -0.17961615f, -0.12643601f, 0.18093464f, -0.03181503f, -0.03583182f, 0.02636446f, 0.06283337f, 
    0.07209207f, -0.10979005f, 0.06084263f, -0.01244802f, -0.01661482f, 0.01097334f, 0.06488369f, -0.13512760f, 
    -0.02694449f, 0.01010383f, 0.04038172f, -0.04859999f, 0.10145009f, -0.00420335f, -0.10048752f, -0.25100106f, 
    -0.01184392f, 0.17661573f, -0.07800386f, 0.09096380f, 0.07451308f, 0.07199810f, 0.12743106f, -0.08676833f, 
    0.02802048f, -0.03132345f, 0.19060220f, 0.23670030f, -0.00785438f, -0.15971959f, 0.09558262f, 0.25406402f, 
    0.09152212f, 0.03645916f, 0.02389021f, -0.04724951f, -0.09722448f, 0.24124859f, -0.04863295f, 0.22828139f, 
    -0.27929461f, 0.09275571f, 0.05309708f, -0.05924531f, -0.13051514f, 0.05368192f, 0.10104448f, 0.35355443f, 
    0.01681929f, 0.19234642f, -0.12668073f, -0.06472389f, 0.00891010f, -0.26648757f, 0.03246025f, -0.11545514f, 
    -0.12008067f, -0.07577015f, 0.13367645f, -0.07784112f, 0.16742542f, -0.08363281f, 0.13018705f, 0.05434061f, 
    -0.03013033f, -0.08606117f, 0.09577823f, -0.07502368f, -0.10295917f, 0.08770986f, 0.00284312f, -0.21051566f, 
    -0.27182412f, -0.19835952f, 0.13891794f, -0.00436217f, -0.31089401f, 0.07939103f, 0.04678209f, -0.21629471f, 
    0.29864144f, -0.06113665f, -0.26546064f, -0.02276834f, -0.04560878f, 0.42144981f, -0.06386538f, -0.01467854f, 
    0.02418458f, 0.10875499f, -0.08130328f, -0.27619445f, 0.17543745f, 0.09066943f, -0.12262643f, -0.07121529f, 
    -0.03482419f, -0.00868930f, -0.42726874f, -0.21977670f, 0.06563833f, 0.15788460f, -0.34070173f, 0.02822890f, 
    0.06842136f, -0.04037778f, -0.20685019f, 0.05605232f, -0.22417562f, -0.08044711f, -0.01250722f, 0.02197729f, 
    0.06398005f, -0.15872991f, 0.16171618f, 0.09241961f, -0.13668172f, 0.12391093f, 0.18917629f, 0.07944304f, 
    0.02572145f, 0.10534767f, -0.01897829f, -0.09745590f, 0.16187042f, 0.17694105f, -0.44787368f, 0.04625789f, 
    0.20815352f, -0.12380685f, 0.03587466f, -0.12772587f, -0.02982294f, -0.04260632f, 0.13742968f, -0.10692155f, 
    -0.06949060f, -0.01691927f, -0.03477596f, -0.29565182f, 0.12652484f, -0.07077187f, 0.07911099f, 0.16563289f, 
    -0.05556419f, 0.09929536f, -0.07234678f, 0.04771746f, -0.00113510f, -0.01216656f, 0.02540510f, 0.03465778f, 
    0.00705554f, -0.15723529f, -0.06738862f, 0.10816690f, 0.10554405f, -0.14562297f, 0.06755717f, -0.28436276f, 
    -0.06766224f, -0.19770868f, 0.01463130f, -0.01301041f, 0.23967977f, -0.13182166f, 0.07561898f, -0.04999178f, 
    -0.20872167f, -0.02503936f, -0.01212019f, 0.04651001f, 0.07513190f, 0.34750995f, 0.03109026f, -0.26836470f, 
    0.46159646f, 0.00463732f, -0.13486311f, 0.20752399f, -0.17893504f, -0.05542623f, -0.07577644f, 0.04505209f, 
    0.06925262f, -0.01116106f, -0.14154030f, 0.00438927f, 0.37026256f, 0.09216829f, -0.19706276f, 0.02084109f, 
    -0.11547454f, -0.03904320f, -0.07978788f, 0.14097463f, -0.11399811f, 0.09852212f, 0.00192802f, 0.01601471f, 
    0.06667867f, -0.25591812f, -0.04182225f, -0.22219612f, -0.22865175f, 0.15617208f, -0.14122699f, 0.13187119f, 
    0.22595076f, -0.10926828f, 0.23289952f, 0.23135300f, -0.05998150f, -0.06999402f, 0.10395423f, -0.01753116f, 
    0.02417349f, 0.09159873f, 0.26522174f, 0.19665779f, -0.07889983f, -0.06028248f, 0.19425723f, -0.04749704f, 
    -0.05762066f, 0.13935082f, -0.00660413f, 0.03013929f, -0.00019204f, 0.07072149f, 0.26327640f, -0.30285653f, 
    -0.14630319f, -0.03177710f, 0.19162081f, -0.24668571f, 0.01719730f, -0.02906745f, -0.32762295f, 0.06114809f, 
    0.18383001f, 0.22780615f, 0.04116093f, 0.18824913f, -0.16573495f, 0.26999822f, -0.15461583f, 0.10256029f, 
    0.10015742f, 0.16295105f, -0.22620177f, 0.05302997f, 0.05649213f, -0.05103958f, 0.13480535f, -0.10130911f, 
    -0.00340429f, -0.04815779f, 0.02711469f, -0.00498438f, -0.04433848f, 0.09847667f, 0.11893662f, 0.27701676f, 
    0.21748760f, -0.00537733f, -0.01197169f, 0.09684606f, -0.07573442f, 0.30308929f, 0.04265510f, -0.01175270f, 
    0.11185138f, 0.02383557f, 0.11437605f, 0.17764072f, -0.18063302f, 0.08400978f, 0.03297769f, -0.27272835f, 
    0.15401149f, 0.19437853f, 0.17105933f, -0.22167380f, -0.58995491f, -0.05474277f, -0.00298606f, 0.15932089f, 
    0.21541919f, 0.20805618f, 0.09980145f, -0.00007406f, -0.04984456f, 0.14994349f, 0.08777221f, -0.17084953f, 
    0.19500683f, -0.10171861f, 0.00030228f, -0.02185829f, 0.29575366f, 0.32815921f, -0.06192823f, 0.36683616f, 
    0.01182920f, -0.10083740f, 0.18529455f, -0.00963474f, 0.01474842f, 0.05318448f, -0.06743950f, 0.20444788f, 
    0.06178870f, 0.34951335f, 0.08287004f, 0.01072827f, 0.17983274f, -0.08001698f, 0.04014732f, -0.09931991f, 
    0.04357876f, -0.09159468f, -0.48736376f, -0.19637954f, -0.26204178f, 0.17191412f, -0.02480432f, 0.15960768f, 
    0.19350365f, -0.25587389f, 0.20662196f, 0.00512177f, 0.03383275f, 0.20602195f, -0.32874277f, -0.07161210f, 
    0.30265769f, -0.02809164f, 0.26579812f, 0.18102412f, -0.02234435f, -0.03374096f, 0.35153556f, -0.04417371f, 
    -0.17187081f, 0.20155202f, -0.07535677f, 0.28169274f, 0.08074684f, -0.13289988f, 0.03689280f, -0.19700734f, 
    -0.21790950f, -0.34027639f, -0.03109798f, -0.18643337f, -0.14636961f, -0.28457403f, 0.15409628f, 0.06489985f, 
    -0.09832665f, -0.05317244f, -0.29360884f, 0.05959416f, 0.08527531f, -0.32363105f, 0.11469845f, -0.12708627f, 
    0.06442211f, -0.27634826f, 0.10588037f, 0.11058494f, -0.42586815f, 0.18030193f, -0.09889658f, -0.16081280f, 
    0.11870794f, -0.11442432f, -0.07701685f, 0.30651611f, -0.09759970f, -0.13441060f, 0.03880714f, 0.00223961f, 
    0.01094247f, -0.12402667f, 0.04973822f, -0.05678945f, 0.01368491f, 0.25421253f, 0.16182049f, -0.27673742f, 
    -0.08967991f, -0.13384922f, -0.20070837f, 0.00281763f, -0.04414193f, -0.01055594f, 0.17327124f, -0.11795248f, 
    0.02213019f, 0.20091605f, 0.06927308f, 0.18793146f, 0.20760043f, 0.04698276f, 0.11882331f, -0.26703247f, 
    -0.01843906f, 0.14298014f, 0.22702427f, 0.27769995f, -0.23836921f, -0.23387378f, 0.11268677f, 0.15407518f, 
    0.12809798f, 0.11959644f, 0.13564412f, -0.01440004f, 0.08917710f, 0.17150943f, -0.05263467f, 0.21974818f, 
    0.09945784f, 0.17296043f, 0.15125640f, -0.10877236f, 0.10114712f, -0.06865035f, 0.25215390f, 0.13748807f, 
    0.05422742f, 0.21400252f, 0.04434353f, -0.10307044f, 0.11348266f, -0.31737575f, 0.00909764f, 0.10936860f, 
    -0.08866324f, -0.23256367f, 0.13944170f, -0.28441709f, 0.13037805f, -0.14450417f, 0.19767873f, -0.00341491f, 
    -0.02785317f, -0.03489811f, -0.11127075f, -0.00829299f, 0.14068057f, 0.27877700f, 0.14778817f, 0.12317879f, 
    -0.17658280f, 0.12965806f, -0.10303880f, -0.06499211f, -0.20668595f, -0.34712836f, 0.01838532f, 0.14293787f, 
    -0.14570656f, 0.12544140f, 0.05285925f, 0.00692458f, -0.02582545f, 0.01791701f, -0.21818087f, 0.12912616f, 
    -0.10370643f, 0.04007528f, 0.27850145f, 0.05158875f, -0.01129530f, -0.14820054f, 0.12741759f, -0.20534050f, 
    -0.08456451f, -0.12314580f, 0.15305054f, 0.10699689f, -0.03545209f, -0.20359547f, 0.07918584f, -0.10889563f, 
    -0.01748400f, 0.01801934f, 0.14458713f, 0.01037114f, 0.10991883f, 0.00722034f, -0.13080491f, 0.04509390f, 
    0.23535295f, 0.08003338f, 0.03754963f, 0.01937238f, 0.54409003f, -0.11032721f, 0.04188825f, 0.11458337f, 
    -0.28208709f, 0.29017672f, -0.26819316f, 0.33901882f, 0.08126032f, 0.13911526f, 0.12697318f, -0.02023152f, 
    -0.08194311f, -0.03997708f, -0.02971482f, 0.02808300f, -0.01712119f, 0.27222893f, 0.02174930f, 0.32187635f, 
    0.30025715f, -0.59995711f, -0.12407252f, -0.07256962f, 0.01873716f, 0.02710591f, -0.04541500f, 0.38582242f, 
    0.11905034f, -0.02815835f, 0.07548364f, 0.09474624f, -0.06649199f, 0.06960221f, 0.13669135f, -0.17717882f, 
    0.19852781f, 0.21267924f, 0.06562706f, -0.15623234f, -0.24501483f, 0.27318698f, -0.03068919f, 0.26072153f, 
    0.20137762f, 0.06618205f, -0.01382292f, 0.00112904f, 0.07421362f, -0.06455062f, -0.00944694f, -0.13791461f, 
    0.20555110f, -0.12524170f, 0.05636748f, -0.50903070f, 0.31997943f, 0.19378749f, -0.25166553f, 0.40268630f, 
    -0.00695483f, -0.04346458f, -0.16983205f, 0.05426775f, 0.06629261f, 0.08426810f, -0.00077507f, 0.08156945f, 
    0.12392735f, 0.45577154f, -0.05192551f, -0.02467037f, -0.07660243f, -0.01067459f, 0.13288833f, -0.01566541f, 
    0.16792926f, -0.11630679f, 0.15702479f, -0.01189096f, 0.03827029f, 0.02954367f, 0.09051051f, -0.08580612f, 
    -0.05892012f, -0.02961074f, 0.19593373f, -0.15259218f, 0.05726116f, 0.19503103f, -0.07742202f, -0.06662129f, 
    -0.00602406f, -0.10467483f, 0.15079531f, 0.29170308f, 0.01961712f, -0.20954017f, 0.12074936f, -0.10104416f, 
    0.07254316f, 0.15404430f, -0.06385077f, 0.06993589f, -0.04421823f, -0.06492066f, -0.03664478f, 0.09763886f, 
    0.01786133f, 0.16286993f, -0.08330483f, 0.09529835f, 0.07243509f, 0.07619443f, 0.34484258f, 0.02307847f, 
    -0.02540514f, -0.05710166f, 0.10336260f, 0.01108766f, -0.08779888f, 0.07028638f, 0.09472161f, -0.15331016f, 
    0.00175505f, 0.14596328f, -0.04809878f, 0.00652933f, -0.23419654f, 0.08665410f, -0.17529219f, -0.12733305f, 
    0.22923185f, -0.02756475f, -0.03534418f, 0.38460308f, -0.13198324f, -0.09600342f, 0.20018859f, -0.12845856f, 
    0.21226051f, 0.26317516f, 0.05127271f, 0.15293615f, 0.07457451f, -0.15671283f, 0.13621698f, 0.09351392f, 
    -0.10536160f, -0.04725313f, 0.00789242f, 0.33949029f, 0.01913619f, -0.03520517f, 0.00696860f, -0.37466019f, 
    -0.03788317f, -0.02270288f, -0.04807550f, -0.04170639f, 0.12581226f, -0.03435847f, 0.01441039f, -0.31578580f, 
    0.05348528f, 0.17865038f, 0.26780796f, 0.18274388f, -0.17260940f, -0.28598604f, -0.07445964f, 0.08351207f, 
    0.14950357f, 0.17132860f, -0.03805311f, -0.04446848f, -0.01563618f, 0.00147857f, 0.08047348f, 0.16766685f, 
    -0.07810278f, 0.33952999f, 0.02385188f, 0.08303136f, -0.28092614f, 0.04298284f, 0.17181751f, -0.04258208f, 
    0.05067945f, 0.16912900f, 0.25856721f, -0.25467616f, 0.15536997f, -0.06994834f, -0.08429208f, -0.01206215f, 
    -0.05409525f, 0.16757563f, 0.12868342f, -0.16960432f, -0.11104850f, -0.00040134f, 0.08068074f, 0.00556229f, 
    0.05004808f, -0.16365914f, -0.15181443f, -0.24617599f, -0.03236179f, 0.29380637f, -0.04477482f, 0.34165427f, 
    0.20910278f, -0.04986681f, 0.02123360f, -0.15008171f, -0.14485209f, -0.25018051f, -0.29824740f, 0.06145754f, 
    -0.25597697f, -0.01334840f, 0.37260640f, -0.16779286f, -0.01443228f, 0.29309654f, -0.02286212f, 0.07857949f, 
    0.24154110f, 0.18044491f, 0.00953765f, 0.37781596f, 0.08514961f, -0.12575176f, -0.36203936f, -0.06826843f, 
    -0.09805237f, -0.40163597f, -0.02707821f, -0.09994988f, 0.14616250f, 0.08512986f, -0.07475749f, 0.25112101f, 
    0.14179255f, -0.04729031f, -0.09526791f, 0.23553419f, 0.19963433f, -0.29447150f, -0.06797630f, -0.42202500f, 
    0.20781054f, 0.11951727f, 0.04060346f, -0.09355830f, -0.22567710f, -0.06040562f, 0.01909046f, -0.04001633f, 
    0.05818522f, 0.13371849f, 0.46680316f, -0.32467210f, -0.07919957f, -0.08201893f, 0.00207191f, -0.27520937f, 
    -0.01396934f, -0.25098151f, 0.01189958f, 0.03648547f, -0.08648190f, 0.32426393f, 0.11569504f, -0.03404003f, 
    0.15924455f, -0.05403523f, -0.19552302f, -0.39165807f, -0.10294899f, -0.27576670f, 0.31504545f, 0.49251103f, 
    -0.01687925f, -0.04571340f, 0.20349343f, 0.01342331f, 0.00854811f, 0.00425621f, 0.09953054f, 0.14159977f, 
    0.05407935f, 0.16979779f, 0.25972071f, -0.10241500f, 0.14711361f, -0.20111418f, -0.10468976f, 0.29624110f, 
    0.01482597f, -0.12644054f, 0.14757094f, 0.00190005f, 0.02624392f, -0.18287602f, 0.07269873f, -0.20511855f, 
    0.27786455f, -0.05536178f, 0.09937998f, -0.20561621f, -0.18851510f, 0.02851652f, -0.11565129f, 0.23684801f, 
    0.28735355f, 0.10845554f, -0.27866739f, 0.17128100f, -0.05392698f, -0.04353907f, -0.08051769f, 0.17330572f, 
    0.16569035f, -0.02205844f, 0.11797148f, -0.16650440f, 0.26647541f, -0.08514778f, -0.01712083f, 0.08027513f, 
    0.01445457f, 0.03995453f, 0.03075704f, -0.04898829f, 0.02148913f, -0.11704415f, 0.01886272f, -0.02734267f, 
    -0.08794833f, 0.06175719f, -0.07168520f, 0.01127090f, -0.04328002f, -0.08270903f, 0.00119595f, -0.04556913f, 
    -0.03691611f, 0.06051872f, -0.11338729f, 0.03511418f, -0.01087338f, 0.03517368f, -0.03062012f, -0.10358930f, 
    -0.05969824f, -0.03475012f, 0.00020303f, -0.04869776f, -0.08090454f, -0.08008365f, -0.03947902f, 0.00166762f, 
    -0.06187011f, -0.07206102f, 0.02048610f, -0.07864073f, -0.10728592f, -0.10278121f, -0.11917925f, -0.06959502f, 
    -0.08152302f, -0.03303939f, -0.03492053f, -0.05134642f, -0.08588399f, 0.02566285f, -0.08525923f, -0.10875895f, 
    -0.01057652f, -0.10795113f, -0.07788832f, -0.07472113f, -0.02438026f, 0.01802298f, 0.00483765f, 0.04721309f, 
    -0.04272424f, -0.02055014f, -0.00208127f, -0.07622261f, -0.01237948f, -0.05171958f, -0.05234486f, 0.07699047f, 
    -0.09612753f, -0.07589017f, 0.03748309f, -0.03630997f, -0.06180882f, -0.04069470f, -0.04934910f, -0.06486256f, 
    -0.10342252f, 0.06068083f, 0.05484708f, 0.06544623f, -0.01433221f, 0.00042453f, 0.06157008f, -0.04092463f, 
    -0.03552153f, -0.09643415f, -0.11244422f, -0.01425963f, 0.03541822f, 0.08536877f, 0.01052591f, 0.06170047f, 
    -0.04790883f, -0.05737912f, 0.02043392f, -0.08810883f, 0.03344510f, 0.03428956f, -0.09123654f, -0.07644689f, 
    0.03227185f, -0.05957012f, 0.02751536f, -0.03453140f, -0.03304356f, -0.01581941f, -0.00893597f, -0.01471508f, 
    -0.13396360f, -0.03514357f, -0.10052672f, 0.03153025f, -0.03320458f, 0.00538506f, -0.00849168f, -0.09257270f, 
    -0.03563457f, -0.04750299f, -0.07090790f, 0.01012434f, -0.11013031f, -0.06482483f, -0.03357673f, -0.12202246f, 
    0.01998846f, -0.03061246f, -0.01964912f, 0.00631540f, -0.05479932f, -0.07391611f, -0.12440886f, 0.00725734f, 
    0.17513466f, 0.08938753f, 0.09131210f, -0.12507369f, -0.42112604f, 0.05016874f, 0.00052148f, 0.16651812f, 
    0.03993043f, -0.16775835f, -0.08764642f, 0.25376344f, 0.02686495f, 0.12041024f, -0.06081447f, 0.10338217f, 
    0.06314044f, 0.27457488f, -0.10006227f, -0.22683063f, 0.00728610f, 0.10033194f, 0.03537463f, 0.02168662f, 
    0.07796193f, -0.00467016f, -0.04316672f, -0.04782502f, -0.02631680f, -0.08892144f, -0.11357833f, -0.01512219f, 
    0.05022538f, -0.14342646f, -0.02272070f, -0.09828542f, 0.07313100f, -0.06720688f, 0.12849405f, -0.03765276f, 
    0.15581526f, -0.04530676f, -0.10842445f, 0.08066364f, -0.05552645f, -0.07293487f, 0.15037760f, 0.06922393f, 
    0.01472471f, 0.14976344f, -0.09413144f, 0.15871699f, -0.04074770f, 0.08707093f, -0.10848450f, 0.04303852f, 
    -0.16562113f, -0.01935752f, 0.79008460f, -0.31823835f, -0.18332557f, 0.14905769f, -0.02940162f, 0.00018718f, 
    0.06006881f, 0.17106839f, -0.08311535f, 0.07047947f, 0.05607362f, 0.08764771f, -0.04017570f, -0.18315125f, 
    0.19126004f, 0.20367104f, -0.10479579f, 0.22833098f, -0.04870986f, -0.14299284f, 0.16813217f, -0.19898927f, 
    -0.06624407f, 0.11181094f, 0.20089912f, -0.04922660f, -0.03618354f, 0.04658313f, 0.03866954f, 0.14074248f, 
    0.01500489f, -0.13483571f, -0.19607992f, 0.10759171f, 0.50998735f, 0.29026881f, 0.10837194f, -0.17599905f, 
    -0.31051141f, -0.27564204f, 0.12881991f, 0.07258744f, -0.06411621f, -0.19618988f, 0.04969861f, -0.16437204f, 
    0.09614863f, -0.03903882f, 0.15081689f, 0.15711033f, 0.03862161f, -0.19073085f, 0.07113155f, -0.05148814f, 
    -0.06770956f, -0.02991875f, -0.05139448f, 0.08692552f, 0.17756154f, -0.02022527f, 0.03376408f, 0.05033448f, 
    0.03979386f, -0.01949334f, 0.01094913f, 0.13936332f, 0.10580064f, 0.12340333f, -0.15418115f, 0.01672366f, 
    0.29715711f, -0.02398320f, 0.07548497f, -0.07564559f, -0.18809062f, 0.26168880f, 0.10303684f, 0.22186674f, 
    0.07087605f, -0.05117223f, -0.27181208f, -0.02794903f, -0.33296826f, -0.47468960f, 0.14935346f, 0.21350802f, 
    -0.08195116f, -0.02172883f, 0.18777046f, -0.06093546f, -0.09977531f, 0.00968597f, -0.32635787f, 0.10470638f, 
    -0.28716338f, 0.05931958f, 0.19331144f, 0.12387489f, -0.00338705f, -0.21406099f, 0.25313827f, -0.25833455f, 
    -0.06062580f, -0.07427539f, 0.23992364f, 0.08331367f, -0.10222432f, -0.14200898f, 0.12972219f, 0.02041465f, 
    -0.00063876f, 0.04431015f, 0.12628821f, -0.11185410f, -0.13641401f, -0.13420953f, 0.03649438f, 0.03188729f, 
    0.18898749f, 0.07033844f, -0.09506515f, -0.03133965f, 0.41136536f, -0.07975684f, -0.17450565f, 0.13855618f, 
    -0.34849524f, 0.19007957f, -0.29815650f, 0.42376739f, -0.19629113f, 0.11580084f, 0.15823807f, 0.07723439f, 
    -0.00505778f, -0.17406203f, 0.01985419f, -0.06273425f, 0.04978863f, 0.40851557f, -0.11514881f, 0.21999937f, 
    0.36689213f, -0.39958134f, -0.00844339f, -0.03777597f, -0.06343433f, 0.11355376f, -0.08096740f, 0.19497703f, 
    0.04987995f, -0.05671045f, 0.16812567f, 0.09245154f, -0.16191521f, -0.00807104f, 0.16333725f, -0.22844948f, 
    0.02762870f, 0.15382539f, 0.05232905f, -0.03130425f, -0.07621995f, 0.22407943f, 0.00530836f, 0.25840038f, 
    0.21023917f, -0.07131135f, 0.05530249f, -0.04115172f, -0.01083103f, -0.09631384f, -0.08380884f, -0.20678261f, 
    0.34234086f, -0.16195279f, 0.07808653f, -0.42914185f, 0.27450985f, 0.13505541f, -0.25465816f, 0.42291790f, 
    0.02835473f, -0.14066911f, -0.13556239f, 0.09328086f, 0.35358629f, -0.04117015f, 0.05005895f, -0.00645399f, 
    0.18137577f, 0.60406876f, -0.05533437f, 0.13407899f, -0.00387588f, -0.04018364f, 0.33242482f, 0.04875264f, 
    -0.01996253f, 0.03227508f, 0.13168284f, -0.00805872f, -0.06418527f, -0.29513764f, 0.14409818f, -0.12968741f, 
    -0.12803946f, -0.02679731f, -0.16029215f, -0.20314647f, -0.07456964f, 0.05645856f, 0.07775930f, -0.00467764f, 
    0.13416421f, 0.04420871f, 0.10300829f, 0.14986877f, -0.04636920f, 0.03833285f, -0.13599038f, -0.08601411f, 
    -0.09423481f, 0.02891947f, 0.05382841f, -0.17823844f, -0.03394021f, 0.04947199f, -0.00556998f, 0.11578067f, 
    0.10227101f, 0.05606534f, -0.14183709f, 0.00337621f, 0.07736266f, 0.20779455f, -0.20334013f, -0.06836058f, 
    0.03653816f, 0.04161970f, 0.03105666f, 0.00534263f, -0.36386243f, 0.12610646f, -0.09036513f, -0.03185625f, 
    -0.48570985f, 0.03630317f, -0.32866159f, 0.02943668f, 0.95620942f, -0.26498312f, -0.03617157f, 0.06041473f, 
    0.13140087f, 0.05038692f, 0.06128478f, 0.65694886f, 0.11122567f, -0.20609686f, -0.35690260f, 0.65120804f, 
    0.45741013f, 0.05268149f, 0.02234017f, -0.34335592f, -0.02739587f, -0.05011855f, -0.27637291f, 0.02926415f, 
    -0.03619938f, -0.03827140f, 0.09353440f, 0.01135000f, -0.00452694f, -0.24682146f, -0.07975037f, -0.12953801f, 
    -0.27125838f, -0.15304135f, -0.14590578f, -0.10228524f, 0.03278729f, -0.06356487f, -0.20047459f, 0.03084273f, 
    -0.16277550f, -0.08945832f, -0.06681584f, -0.00242422f, -0.15134637f, -0.13162120f, -0.25329262f, -0.07928700f, 
    0.04537353f, 0.17872138f, -0.11266059f, -0.05381409f, -0.13654074f, -0.09969160f, -0.03710258f, 0.21722235f, 
    -0.25186172f, 0.46959743f, -0.21857336f, 0.09505786f, 0.13010277f, 0.13345489f, 0.02964577f, -0.14697935f, 
    0.08395192f, 0.08332591f, 0.08827545f, -0.17728949f, 0.05142612f, 0.01366516f, 0.02167381f, -0.32307822f, 
    -0.00330231f, -0.03042943f, -0.11350524f, 0.06806137f, -0.30764458f, -0.31408229f, 0.04508169f, 0.03991069f, 
    -0.09334552f, 0.06051593f, -0.02476416f, -0.08987474f, -0.12582035f, 0.04728947f, -0.02458357f, 0.02706259f, 
    0.05871272f, -0.04628774f, -0.05897677f, -0.05320707f, -0.05899866f, -0.09330817f, -0.09683930f, 0.00638610f, 
    -0.07754491f, -0.02276282f, -0.04741037f, -0.00292215f, 0.03684485f, 0.07472004f, -0.08813012f, -0.08202298f, 
    -0.09031379f, 0.00431101f, -0.03660811f, -0.04821513f, -0.10679777f, 0.02273396f, 0.05408559f, -0.05846986f, 
    -0.10661487f, -0.06385767f, -0.03468527f, -0.10933743f, -0.07126285f, -0.00340678f, -0.09395571f, -0.11682855f, 
    0.01375751f, 0.04746495f, 0.00031314f, 0.04024247f, -0.07255977f, 0.01636443f, 0.04672594f, 0.04448522f, 
    0.01157271f, -0.06331167f, -0.08046655f, 0.04998411f, -0.02029112f, 0.00887948f, -0.02495709f, -0.02637147f, 
    0.03804918f, -0.03325162f, -0.03028918f, 0.02452501f, 0.03885700f, 0.02095690f, -0.07855698f, -0.06835219f, 
    -0.00256661f, -0.14718041f, 0.00352120f, -0.10420401f, 0.08806995f, 0.06098897f, -0.09945750f, -0.02035223f, 
    0.03713197f, -0.03591538f, -0.01884277f, -0.13674532f, -0.00052892f, 0.01883132f, 0.02446190f, -0.01158564f, 
    -0.07783165f, -0.03570866f, 0.08080611f, -0.05772936f, -0.00002836f, -0.03500757f, -0.08648723f, -0.03598372f, 
    0.00315284f, -0.00297970f, -0.00114294f, -0.07925922f, -0.04257954f, 0.01468048f, 0.06457406f, -0.01903054f, 
    -0.10211053f, -0.08423917f, -0.01711838f, -0.07864112f, -0.00090357f, -0.06710310f, -0.03107892f, -0.04745683f, 
    -0.02918297f, -0.08033063f, -0.09178110f, 0.03926630f, -0.02114789f, -0.11033832f, -0.00065453f, -0.06958638f, 
    0.01769499f, -0.02479705f, 0.01594183f, -0.03650848f, 0.05441907f, -0.11227787f, 0.04935588f, -0.13126127f, 
    -0.04905973f, -0.10516251f, -0.02442910f, -0.03837927f, -0.09424388f, 0.06022119f, -0.03431157f, 0.04300119f, 
    -0.14611168f, -0.12181578f, 0.11579335f, 0.09223806f, -0.07341903f, -0.01984458f, 0.03779160f, 0.03210955f, 
    -0.00103794f, -0.02826122f, -0.12013250f, -0.35365093f, -0.44313893f, -0.09888528f, -0.35646859f, 0.21116908f, 
    -0.11477952f, -0.21613958f, 0.11256376f, 0.04816819f, 0.07174297f, 0.11255375f, -0.15767081f, 0.05664990f, 
    0.20649369f, -0.15483212f, 0.24671394f, 0.14333078f, -0.18570046f, -0.10025758f, -0.08970986f, -0.19744265f, 
    -0.07491130f, 0.12150157f, 0.10191225f, 0.30529949f, 0.13370652f, 0.10371300f, 0.09705109f, -0.16634965f, 
    -0.14969948f, 0.00922484f, 0.18144479f, -0.04670332f, 0.06242073f, 0.05139563f, -0.43592197f, -0.00470679f, 
    0.04835920f, 0.26100281f, -0.32459447f, -0.00286291f, 0.29438344f, 0.12460957f, 0.10094164f, -0.01460506f, 
    -0.25164038f, 0.22879598f, 0.37937367f, -0.16686124f, -0.11463907f, 0.15298329f, 0.06033057f, 0.28177136f, 
    -0.10769782f, 0.02581424f, -0.01161672f, 0.17632298f, -0.04809014f, -0.27273864f, -0.00068540f, 0.27192700f, 
    0.35407051f, -0.22902969f, 0.01898114f, -0.08380654f, -0.05427446f, 0.25822112f, -0.32744202f, -0.13564540f, 
    -0.01047936f, -0.44628486f, 0.06304018f, -0.07561100f, -0.28705588f, -0.00487574f, -0.10680237f, -0.30069956f, 
    0.10400099f, 0.10111330f, -0.12644432f, -0.29612654f, -0.05179993f, -0.04018973f, -0.00361911f, -0.19063796f, 
    0.02887154f, 0.00829384f, -0.00168748f, -0.01513402f, 0.09267067f, -0.16314590f, -0.00323421f, 0.00978814f, 
    0.32540536f, -0.39394668f, 0.02409937f, -0.22592118f, 0.19625774f, 0.20548914f, -0.29483750f, 0.16100085f, 
    0.23107125f, -0.26553687f, -0.02554936f, 0.08138273f, -0.37203303f, 0.05660832f, -0.03043629f, 0.16794211f, 
    -0.26237333f, 0.49542844f, -0.16464593f, 0.19446507f, 0.00957326f, 0.09759443f, -0.22193007f, 0.04990700f, 
    -0.23131141f, -0.01649614f, 0.39801395f, -0.07080557f, 0.32187125f, -0.25645211f, 0.13375232f, -0.27620924f, 
    -0.29405388f, 0.13288780f, -0.15023106f, -0.69873405f, 0.04776155f, 0.12552410f, -0.18746363f, -0.06843377f, 
    0.02357438f, 0.00636517f, -0.21457420f, 0.03447526f, 0.01868706f, 0.08286709f, -0.12919565f, 0.00005361f, 
    0.40562984f, -0.34677255f, 0.12147318f, 0.20295204f, -0.10762256f, 0.02857939f, -0.20864941f, 0.05608262f, 
    -0.00047918f, 0.08276398f, 0.04357292f, 0.17302449f, 0.01110931f, 0.19506116f, 0.23546137f, -0.12671630f, 
    0.19528241f, 0.04851029f, 0.02216808f, -0.18376108f, 0.17166840f, 0.00283231f, -0.20232579f, -0.14239697f, 
    -0.18900797f, 0.15802974f, -0.31043366f, 0.00894884f, 0.16228031f, -0.19026990f, -0.08655483f, 0.04548800f, 
    0.12995815f, 0.17687285f, 0.55411726f, -0.08599223f, -0.07866785f, 0.02945583f, 0.17193858f, 0.19538894f, 
    -0.11363041f, 0.16662449f, -0.04483671f, 0.11131647f, 0.05408929f, -0.50820976f, -0.10360144f, 0.21824497f, 
    0.24956654f, -0.00680043f, 0.02422551f, -0.02283140f, -0.09791150f, 0.16205981f, 0.08679575f, 0.01452822f, 
    -0.01471000f, -0.22792596f, -0.45030591f, -0.10387589f, -0.00349574f, -0.00026521f, -0.34128100f, -0.10209592f, 
    0.02899361f, 0.03705713f, -0.33090624f, 0.24774806f, 0.03278148f, -0.10478917f, -0.25009829f, -0.39566475f, 
    -0.02178999f, -0.01333667f, -0.41507119f, 0.00516785f, 0.13636643f, -0.13580285f, -0.06850220f, 0.25156474f, 
    -0.16245073f, 0.04909191f, -0.13350914f, -0.08818659f, -0.08552001f, 0.07578417f, -0.02328345f, -0.13008289f, 
    0.11128377f, -0.04105818f, 0.16679032f, 0.24020955f, -0.07165380f, 0.06209999f, -0.00735784f, 0.22916865f, 
    -0.10123423f, 0.16575779f, 0.00937782f, 0.01450723f, 0.02266143f, 0.01222829f, -0.00098989f, 0.01142551f, 
    0.01695496f, -0.61771220f, -0.38141716f, -0.06256969f, 0.09851612f, 0.22859615f, -0.02433514f, 0.15138741f, 
    0.03619509f, -0.04778275f, 0.21884312f, 0.10251865f, -0.00503915f, 0.10133053f, -0.94549918f, -0.11882083f, 
    -0.06128338f, -0.06715081f, 0.27023524f, -0.02915896f, 0.09569239f, 0.03609915f, 0.13829111f, -0.07861603f, 
    0.04369439f, 0.10965288f, -0.15382712f, 0.12412116f, 0.14186552f, -0.13414738f, -0.27914643f, 0.16125062f, 
    0.20814699f, -0.31756741f, -0.07619140f, 0.04834600f, 0.02173835f, 0.13721272f, 0.10788482f, 0.27942950f, 
    -0.30772144f, -0.08956952f, -0.15073581f, 0.31363624f, 0.07313880f, -0.47410437f, 0.08666716f, -0.62416565f, 
    0.09804747f, -0.15935610f, -0.02138746f, 0.05033486f, -0.03887104f, 0.07611200f, -0.13672316f, -0.14027712f, 
    0.22214589f, -0.21859129f, 0.04852151f, 0.13266410f, -0.18960139f, -0.18039490f, 0.09891761f, -0.03104132f, 
    0.13817360f, 0.13800932f, -0.01833206f, 0.07746662f, 0.02701991f, 0.01358480f, -0.02553296f, -0.18525206f, 
    -0.10507477f, -0.24662510f, 0.03579714f, -0.14012992f, 0.09703523f, -0.32000181f, -0.07902291f, -0.07465459f, 
    -0.13186887f, 0.02182183f, 0.08969348f, 0.10129996f, 0.23626313f, -0.05907745f, 0.04189833f, 0.11415295f, 
    -0.01362782f, 0.15314253f, 0.27091327f, 0.34052899f, -0.23892999f, -0.53904158f, 0.00243818f, 0.10333422f, 
    0.02165920f, 0.06350140f, 0.10807022f, 0.03875221f, 0.15331736f, -0.01904928f, 0.00416096f, 0.05645820f, 
    0.03411451f, 0.27181640f, 0.07930735f, -0.17860298f, -0.09751043f, -0.21578775f, 0.21591456f, -0.18207054f, 
    0.04642068f, 0.15208586f, -0.04228838f, 0.00273359f, -0.06007262f, -0.04755722f, -0.06286923f, 0.02595550f, 
    -0.18784533f, -0.22541408f, 0.19878365f, -0.45269018f, -0.01057738f, 0.12742133f, 0.02194571f, 0.00417584f, 
    0.09445874f, -0.14543055f, 0.40221667f, -0.08392102f, 0.22761407f, -0.91513473f, 0.07652093f, -0.02025981f, 
    0.09365106f, 0.13367283f, -0.17424530f, -0.27899346f, 0.25887090f, -0.00470543f, -0.09909537f, -0.02279339f, 
    0.07067946f, 0.10318597f, -0.03860369f, 0.00129500f, 0.07904556f, -0.03869684f, -0.23957245f, -0.14769475f, 
    0.20934933f, 0.02847999f, 0.11152247f, -0.24422863f, -0.00743697f, 0.00968539f, 0.00270032f, 0.09882036f, 
    0.08814524f, 0.03214806f, 0.12669082f, 0.08081607f, 0.08734164f, 0.25689283f, -0.04529154f, 0.10077302f, 
    -0.10508321f, -0.04162104f, 0.14541250f, -0.03646308f, 0.11414596f, 0.05175292f, -0.10911562f, -0.07117292f, 
    -0.29022005f, 0.22759619f, -0.03743796f, -0.03922359f, 0.18798202f, -0.10816278f, 0.07482998f, -0.03531491f, 
    0.05007175f, -0.06008204f, 0.26063654f, -0.25439352f, -0.16586849f, -0.13794343f, 0.03807975f, 0.32568806f, 
    -0.10955366f, 0.11868010f, 0.05432583f, 0.17699279f, 0.00240429f, -0.31705052f, -0.16887605f, 0.16259056f, 
    0.01869212f, 0.07465101f, -0.02627046f, 0.08532895f, 0.01814505f, 0.46930531f, -0.06144824f, 0.01026849f, 
    0.14709218f, -0.21537463f, -0.17907466f, -0.25220799f, 0.03137520f, -0.05001160f, -0.43374985f, -0.10286449f, 
    -0.03084115f, -0.09510987f, -0.42024755f, -0.15583484f, 0.27746615f, 0.20006150f, -0.01051379f, -0.23736356f, 
    -0.11958492f, 0.12855338f, -0.28044015f, 0.01769662f, -0.21881850f, 0.01465982f, 0.06741053f, 0.09577417f, 
    -0.41485965f, -0.01397166f, 0.12966716f, -0.02953572f, -0.46976647f, -0.11076557f, -0.27692801f, -0.45724955f, 
    -0.23515779f, 0.12578823f, 0.03799364f, 0.11273365f, 0.02377501f, 0.06009298f, -0.03139363f, 0.03618136f, 
    -0.16419731f, -0.37515438f, -0.06074060f, 0.03968403f, 0.00425076f, 0.03988804f, 0.07468010f, 0.01638629f, 
    -0.07367155f, -0.08001760f, -0.40954116f, 0.15661497f, 0.30232304f, 0.18232001f, 0.01048623f, 0.07398903f, 
    0.24098948f, 0.08213893f, -0.24322073f, 0.24541247f, 0.06067966f, -0.40785182f, 0.21275699f, -0.23751539f, 
    -0.24526116f, -0.11119392f, 0.04800753f, -0.02903866f, 0.05267238f, -0.08478956f, -0.03446180f, 0.14680189f, 
    -0.30843943f, 0.00849510f, 0.18713406f, 0.15066390f, 0.13357271f, -0.06763713f, 0.21738358f, -0.19866206f, 
    -0.15360634f, -0.24972454f, 0.16149598f, 0.00815191f, 0.05237275f, -0.30708903f, -0.00195220f, 0.10249162f, 
    -0.10250257f, 0.07212776f, 0.17900743f, 0.18574783f, -0.01325318f, 0.00406584f, -0.06816089f, 0.13099928f, 
    0.26934329f, 0.07150468f, 0.16355997f, 0.06628244f, -0.37964287f, -0.02854320f, -0.01888834f, -0.05247371f, 
    -0.19121459f, 0.05512148f, -0.52273518f, 0.31051978f, 0.03067327f, 0.00783922f, 0.11595144f, -0.21437342f, 
    -0.11728749f, -0.34675857f, 0.02151083f, 0.04771772f, 0.01488215f, 0.55700624f, -0.05505114f, 0.10149116f, 
    -0.15788308f, -0.25083357f, -0.01995046f, 0.12309790f, 0.13087137f, -0.18229853f, -0.20659864f, 0.59881461f, 
    0.06350709f, -0.07230428f, -0.04749679f, 0.15988269f, 0.13251898f, -0.00641283f, 0.03355189f, 0.08589881f, 
    -0.00993769f, 0.17561100f, 0.19477171f, -0.28701490f, -0.24452175f, 0.11484031f, -0.25874698f, 0.02343898f, 
    0.17598431f, 0.11535347f, 0.10637698f, -0.05110990f, -0.00882215f, 0.20026188f, -0.06603621f, -0.34343958f, 
    0.17158277f, -0.16381763f, -0.16562749f, -0.20674698f, -0.03600241f, 0.08257916f, -0.43231452f, -0.24680699f, 
    -0.12675329f, 0.07425904f, -0.10312759f, -0.13693754f, 0.07236490f, 0.07549980f, 0.06211700f, 0.06714109f, 
    0.21619685f, -0.29953584f, 0.11992868f, -0.11791426f, -0.02590548f, -0.09430326f, -0.14072528f, 0.02304951f, 
    -0.18469255f, -0.06756655f, -0.23078936f, -0.06905930f, 0.00049726f, 0.05982574f, -0.26764977f, 0.08693586f, 
    0.14913414f, 0.05241803f, 0.01689154f, -0.17500564f, 0.08291126f, -0.22892877f, -0.17715819f, 0.09422456f, 
    -0.10698479f, -0.07026727f, 0.06990797f, 0.06963772f, -0.02821938f, 0.12363736f, -0.03399109f, 0.05622143f, 
    0.04461860f, -0.05709099f, 0.01980845f, 0.29529008f, 0.12838316f, -0.00541795f, 0.04710725f, -0.25490367f, 
    -0.48916146f, -0.08932383f, 0.02728788f, -0.17782795f, -0.15711424f, -0.27439737f, -0.23933281f, 0.08759333f, 
    -0.17773968f, 0.04556915f, -0.20782876f, -0.04660533f, 0.10042155f, -0.20739704f, 0.06672115f, 0.02931724f, 
    0.09307385f, -0.15787038f, 0.05177352f, -0.08725666f, 0.58187062f, 0.03443138f, 0.01975683f, -0.02202920f, 
    -0.05136038f, 0.04947132f, -0.30281171f, 0.09544538f, 0.01355909f, 0.12123530f, 0.07157969f, -0.13078278f, 
    0.04600365f, -0.27211609f, -0.02114944f, -0.10591106f, 0.07936977f, 0.17884161f, 0.00676526f, -0.02302727f, 
    0.08301471f, -0.20187677f, -0.22432919f, -0.30676398f, -0.00034492f, 0.07514399f, 0.12852381f, 0.17197019f, 
    0.10773287f, 0.08060795f, -0.06957181f, 0.09175280f, 0.02077637f, 0.04675630f, 0.13450846f, -0.12232596f, 
    -0.02966339f, -0.17176898f, -0.03973642f, -0.08959739f, -0.35693169f, 0.04583513f, 0.00799860f, 0.07474542f, 
    0.00212306f, -0.04097796f, 0.06385580f, -0.07522102f, -0.06791197f, 0.16069971f, 0.06819044f, 0.01968244f, 
    0.10339752f, -0.11728039f, 0.04979141f, -0.16864149f, 0.03113717f, -0.01186980f, -0.23247671f, 0.29321772f, 
    -0.06722496f, 0.13519990f, -0.29662737f, 0.11682311f, -0.12378991f, -0.07495235f, 0.05510876f, 0.12067968f, 
    0.06659568f, 0.02197117f, -0.06525082f, -0.07078870f, 0.19619718f, -0.12597962f, -0.00778374f, -0.09535166f, 
    -0.13548863f, -0.05470742f, 0.16796926f, 0.08556417f, -0.04608960f, 0.14517009f, -0.13055159f, -0.42519897f, 
    0.10579496f, 0.07145644f, 0.14268787f, -0.07763052f, -0.17684352f, -0.01605595f, -0.01899483f, 0.05708110f, 
    0.22195852f, -0.08562259f, 0.01374838f, 0.10997080f, -0.02691568f, -0.06872936f, 0.04593764f, -0.02719171f, 
    0.02092959f, 0.02171213f, 0.01816894f, -0.14062241f, 0.07080918f, 0.06938294f, 0.20311584f, -0.05777838f, 
    -0.04938899f, -0.00400574f, -0.13698825f, 0.05069709f, -0.06813737f, 0.02583949f, 0.03856759f, -0.22209351f, 
    -0.04262443f, 0.00630912f, 0.13968171f, -0.28537452f, -0.27476886f, -0.02952142f, 0.07805084f, 0.24921505f, 
    -0.02744233f, 0.03039842f, -0.03002212f, 0.08369930f, 0.17312028f, 0.31124157f, 0.07899806f, -0.02995974f, 
    0.04747701f, 0.03937052f, -0.18695848f, -0.13523716f, 0.08848226f, 0.22178064f, -0.03217591f, 0.14967832f, 
    0.17921267f, -0.02468834f, 0.07129440f, 0.05369004f, -0.04760943f, 0.37999976f, -0.04894093f, 0.00544008f, 
    -0.06797142f, -0.03431159f, -0.05731692f, -0.16839947f, 0.10190429f, 0.43910077f, 0.02835660f, -0.40363565f, 
    0.05912827f, 0.01782478f, -0.01374920f, 0.14527181f, -0.09771325f, 0.08736921f, 0.17728078f, -0.16603473f, 
    0.01176115f, 0.09623411f, -0.07664122f, 0.20649005f, -0.33021078f, 0.12858653f, 0.29498228f, -0.28724542f, 
    0.16448087f, -0.00951997f, 0.13469502f, 0.03274500f, 0.07870071f, 0.09403884f, -0.07396568f, 0.09820284f, 
    -0.25411084f, -0.07572586f, 0.15484738f, -0.06100385f, 0.32623532f, 0.24669324f, 0.03163115f, 0.12487388f, 
    0.16267462f, -0.03851964f, -0.03261848f, -0.03499201f, 0.12938544f, 0.04837610f, 0.04411867f, 0.11612189f, 
    0.01927874f, 0.21772769f, 0.01607480f, 0.17736714f, -0.02946336f, -0.01017638f, 0.10671671f, 0.02441681f, 
    0.04146679f, -0.04210072f, 0.05449171f, -0.07453981f, -0.07243690f, -0.02118010f, -0.08059265f, -0.02944360f, 
    -0.06183001f, 0.03453811f, 0.07147866f, 0.03641387f, 0.03317508f, 0.02865147f, -0.00849738f, -0.05685768f, 
    0.01435050f, -0.10723072f, 0.06211425f, -0.04587324f, -0.04527180f, -0.08509938f, -0.04492732f, -0.06716695f, 
    -0.00645081f, 0.00203349f, 0.05482475f, 0.00618270f, 0.06766379f, -0.11312653f, -0.05767517f, 0.02917696f, 
    0.05721781f, -0.06642499f, -0.04573553f, 0.00232383f, -0.08809347f, -0.08131169f, -0.07469619f, -0.02035646f, 
    -0.04805184f, 0.05905451f, -0.10936053f, -0.00691249f, 0.05274127f, -0.03544617f, -0.01956692f, -0.04780104f, 
    -0.08582178f, -0.04648376f, -0.01444654f, -0.02162816f, 0.00075855f, 0.00738644f, 0.02929526f, 0.02214523f, 
    -0.09434193f, -0.00737375f, -0.02387833f, -0.08497367f, -0.01705041f, 0.00863773f, -0.02009471f, 0.02304084f, 
    -0.05189700f, 0.02261719f, 0.07254940f, -0.00183239f, -0.04303782f, 0.07823943f, -0.11132551f, -0.07843078f, 
    -0.00939763f, 0.02889988f, 0.05201834f, -0.10261974f, -0.07950872f, 0.05040906f, -0.00956407f, -0.05319052f, 
    -0.02870653f, 0.02619815f, -0.01242132f, -0.06879020f, -0.05849404f, -0.00857287f, -0.08400967f, 0.06205017f, 
    -0.07437053f, 0.02847119f, -0.02574512f, -0.05364140f, 0.05611907f, 0.04709802f, -0.07232471f, -0.08260256f, 
    -0.01138124f, -0.02026587f, 0.01181102f, -0.00358170f, -0.02998053f, -0.07559585f, -0.06569687f, 0.03098439f, 
    -0.07963330f, -0.09499799f, 0.07998694f, -0.08204084f, -0.06883170f, -0.01557040f, 0.04377820f, 0.07268257f, 
    0.06951617f, 0.04142544f, 0.03261696f, 0.05785171f, -0.00157672f, -0.04060784f, -0.03366428f, -0.00206272f, 
    -0.00811610f, 0.11749040f, -0.12366356f, 0.03528177f, -0.01138104f, -0.01287156f, 0.08202792f, 0.03395591f, 
    -0.09100949f, -0.08214869f, -0.48942938f, 0.02336078f, 0.16523854f, -0.06946591f, -0.04234355f, -0.04198891f, 
    -0.29722163f, 0.01610684f, -0.04963934f, -0.15221204f, 0.19072165f, 0.06583168f, -0.08282526f, -0.18268408f, 
    -0.26626024f, -0.00515207f, -0.02530882f, 0.28423399f, 0.08523254f, 0.08640324f, -0.03219046f, 0.23419608f, 
    0.19963536f, -0.10684885f, 0.12720409f, 0.26738486f, 0.13225621f, 0.05881305f, -0.13819915f, -0.09174914f, 
    -0.03905031f, 0.17987429f, 0.08375722f, 0.03059756f, 0.18991344f, -0.01138843f, -0.07943566f, 0.12437395f, 
    0.11302711f, -0.07535675f, -0.23497365f, 0.26262015f, 0.37337163f, 0.04256458f, 0.11871441f, -0.13590460f, 
    0.12123082f, 0.01514048f, 0.18150182f, 0.01018223f, -0.41225275f, -0.23573530f, 0.07717293f, 0.21315163f, 
    0.06620670f, 0.25993016f, 0.50452662f, 0.05916131f, 0.15998074f, -0.07930564f, 0.28494957f, -0.42043903f, 
    -0.12676634f, -0.08381101f, 0.07412900f, -0.05773849f, 0.08304544f, -0.02947494f, 0.15818395f, 0.16941506f, 
    -0.00739211f, -0.28668490f, -0.00513908f, 0.01689493f, -0.04425732f, -0.23686686f, 0.25236067f, 0.51900584f, 
    0.12179515f, 0.10572363f, -0.25045434f, 0.27374119f, 0.24538653f, -0.05987942f, -0.08712914f, 0.08059421f, 
    0.17129181f, 0.09229124f, -0.01634442f, -0.08858400f, -0.47349867f, -0.32346657f, -0.39807299f, 0.11786109f, 
    0.00300495f, 0.04856657f, -0.09510506f, 0.07309489f, 0.21353354f, 0.01644997f, 0.00745452f, 0.05696757f, 
    0.06517445f, -0.01628210f, -0.01393177f, -0.15345649f, -0.09641194f, 0.01102449f, -0.04367913f, -0.13810343f, 
    -0.01565463f, 0.06539277f, 0.02427355f, 0.24064998f, -0.13568810f, 0.11580822f, -0.03637824f, 0.26702273f, 
    0.13092750f, -0.34990197f, 0.06929591f, 0.00747069f, 0.06190536f, -0.08683906f, -0.09619639f, -0.01586519f, 
    -0.41047439f, -0.19079849f, 0.09490879f, 0.04386581f, 0.15262096f, -0.03340426f, -0.08097177f, -0.16627100f, 
    0.12003233f, -0.13599192f, 0.05704330f, -0.24010722f, -0.10178161f, -0.07605399f, -0.09992386f, -0.06654537f, 
    0.01937708f, -0.13040563f, -0.03051216f, 0.06300984f, 0.08020591f, 0.00544626f, -0.18757516f, 0.09721109f, 
    0.08615217f, -0.33301553f, 0.31289381f, 0.14494523f, -0.15594654f, 0.05240943f, 0.13803072f, -0.01206958f, 
    -0.10709901f, 0.23800904f, 0.05398099f, 0.19764580f, 0.10548149f, 0.11126614f, 0.24552611f, -0.24325013f, 
    -0.28965846f, 0.10172339f, 0.18735124f, -0.11286201f, -0.05592462f, 0.02425886f, -0.19482982f, 0.03135932f, 
    0.12172764f, 0.18921024f, -0.13510321f, -0.03205280f, -0.04943930f, 0.40004492f, 0.31849071f, 0.03651672f, 
    -0.01810988f, 0.13548875f, -0.01235982f, -0.24791741f, -0.03471288f, 0.17301968f, 0.07493950f, -0.05239639f, 
    -0.07947531f, -0.02424657f, 0.02692071f, 0.22021395f, 0.08510108f, 0.21661434f, -0.05246564f, 0.08442638f, 
    0.25416780f, -0.15335457f, 0.03657081f, 0.05784879f, -0.02124569f, 0.43162346f, -0.18404098f, 0.16768391f, 
    0.07029771f, -0.39955926f, -0.24281955f, 0.04245605f, 0.00993191f, -0.06203734f, 0.06012763f, -0.25498411f, 
    -0.00379209f, 0.08249623f, -0.25545827f, -0.08134714f, -0.36178416f, -0.00768804f, 0.16071220f, -0.33495173f, 
    0.17745633f, 0.13601439f, 0.00210152f, 0.05002012f, 0.11871537f, 0.11805218f, 0.07824331f, 0.19185181f, 
    0.16304180f, -0.22271772f, -0.11871899f, -0.28862035f, -0.08042277f, 0.25760365f, -0.21085142f, -0.29264808f, 
    0.38339189f, -0.03839218f, 0.15998006f, -0.23693830f, -0.39771312f, 0.03235337f, 0.07661748f, 0.10063583f, 
    -0.10830932f, 0.10962401f, -0.23299032f, 0.13621941f, 0.05567988f, 0.22631393f, -0.03347169f, -0.07274283f, 
    -0.02019899f, 0.04297404f, -0.03748066f, -0.04819621f, -0.09205470f, 0.00265615f, 0.07828397f, 0.02039059f, 
    -0.01714188f, -0.00508268f, 0.04563659f, 0.06503803f, -0.00081789f, -0.03916404f, -0.06791363f, -0.04439508f, 
    0.06410893f, -0.07032291f, 0.05600930f, -0.01713094f, 0.07193063f, 0.00732690f, -0.00952644f, 0.06616165f, 
    -0.09911286f, 0.01144871f, 0.01171645f, -0.05910895f, 0.01899278f, -0.04422602f, -0.05104443f, 0.01103949f, 
    0.03178812f, -0.05748750f, -0.05176678f, -0.02967684f, 0.02037944f, 0.01276420f, 0.01441646f, -0.00833724f, 
    0.00641194f, -0.07419231f, 0.05854679f, -0.05859331f, 0.02727462f, 0.05763624f, -0.00479087f, -0.01734773f, 
    -0.08537306f, -0.08483591f, 0.02515580f, -0.06848702f, 0.02276716f, 0.07881901f, -0.08003101f, -0.09749280f, 
    0.06363051f, -0.04998924f, -0.05613690f, 0.00740751f, 0.06027839f, -0.08381768f, 0.05622231f, 0.04473502f, 
    0.04267997f, 0.00283448f, 0.06995548f, -0.06614571f, -0.05703670f, -0.02283189f, -0.06498083f, 0.01131431f, 
    0.08321698f, -0.04532100f, -0.02754057f, 0.04171695f, 0.05340865f, -0.07037808f, -0.04316883f, 0.06398920f, 
    -0.07472231f, 0.01783947f, -0.08496036f, -0.08429466f, -0.00121704f, -0.00258451f, -0.05070196f, 0.01514264f, 
    -0.03373825f, -0.00134895f, -0.01272652f, -0.08044344f, -0.07853796f, 0.06374449f, -0.05641850f, -0.00941691f, 
    -0.07823880f, -0.01062405f, 0.00591021f, -0.03325571f, -0.01673085f, 0.01715853f, 0.05932327f, -0.06807688f, 
    0.00309753f, 0.07020444f, -0.06889267f, 0.02535910f, 0.08066849f, 0.02997752f, -0.03979834f, -0.01185953f, 
    0.07082586f, -0.04076977f, 0.05275432f, -0.05941046f, 0.02169549f, -0.08618313f, 0.06675049f, -0.06537788f, 
    -0.07999898f, -0.04354939f, -0.05483222f, -0.07478749f, -0.05462162f, -0.01583979f, 0.02346496f, -0.04108132f, 
    0.21775332f, -0.20343995f, 0.16828215f, -0.25326657f, -0.03317352f, 0.15245084f, -0.16858801f, 0.35604903f, 
    -0.03038244f, -0.03079946f, -0.07034158f, 0.08692504f, 0.03407032f, -0.32751429f, -0.39305070f, 0.27998120f, 
    -0.23484251f, 0.02754127f, 0.21824470f, -0.35485002f, -0.05697915f, 0.22207876f, -0.27404344f, -0.01969491f, 
    0.14460056f, 0.09641493f, -0.08426625f, 0.02734549f, 0.14530069f, 0.04909032f, -0.29459369f, -0.13406429f, 
    -0.00225042f, -0.30450886f, 0.06331313f, 0.02298845f, 0.03995908f, -0.06063882f, 0.03566506f, 0.18605569f, 
    0.24046695f, 0.04295464f, 0.07210273f, 0.31628224f, 0.20975392f, -0.39002341f, 0.14535633f, -0.34156194f, 
    0.04613502f, 0.04132877f, -0.05539337f, -0.05723390f, 0.74604744f, -0.01483628f, -0.12866208f, 0.05461512f, 
    -0.08042248f, -0.06763560f, 0.29938284f, -0.24009296f, -0.07946282f, 0.02247996f, -0.01538650f, 0.18653870f, 
    0.10514978f, 0.00702698f, -0.00023367f, 0.06647053f, -0.03505287f, 0.14341533f, -0.08452026f, -0.03399410f, 
    0.24080393f, 0.13833761f, -0.13021755f, -0.18908356f, 0.06452055f, -0.15800661f, 0.09151527f, 0.33445123f, 
    -0.04727555f, -0.21587273f, 0.27738321f, -0.09954125f, -0.13949195f, -0.04585927f, -0.14942831f, 0.25106496f, 
    0.11025699f, 0.15258338f, 0.09838010f, 0.02193981f, 0.53891802f, 0.14094628f, 0.00470716f, 0.29464185f, 
    -0.27746874f, -0.36792997f, -0.00317661f, 0.01538696f, 0.00372842f, -0.35881418f, -0.08336709f, -0.10459841f, 
    0.36233470f, 0.03674218f, 0.15262915f, -0.36851034f, 0.02193355f, -0.02710099f, -0.28116661f, 0.24318816f, 
    0.17397702f, -0.01200861f, -0.59556359f, 0.27195382f, 0.00790910f, -0.13918567f, 0.00520450f, 0.00372022f, 
    0.14516571f, 0.08385035f, -0.03254767f, 0.07100803f, 0.16910608f, -0.00952529f, 0.03771603f, -0.04457312f, 
    0.25968310f, -0.03962922f, -0.17507386f, -0.20558871f, -0.41486198f, 0.24704711f, -0.06647861f, 0.38385820f, 
    0.19765377f, -0.17458202f, 0.04358063f, -0.07572877f, -0.08832742f, -0.15223294f, 0.03216323f, 0.13226224f, 
    0.08851320f, -0.01005164f, 0.26056522f, -0.16685891f, -0.03361959f, 0.15153554f, -0.08635537f, 0.06712598f, 
    -0.03968973f, 0.25611287f, -0.00396711f, 0.13430098f, -0.02511035f, 0.00162639f, -0.15508388f, -0.38156366f, 
    -0.19057490f, -0.58764839f, 0.04473122f, -0.11250731f, -0.14666957f, -0.53431851f, 0.16278386f, 0.04675253f, 
    0.04171514f, 0.07750949f, -0.11789344f, 0.02293081f, 0.11872032f, -0.29951525f, 0.03506950f, -0.15203775f, 
    0.04855634f, 0.00434146f, -0.05970464f, 0.11305661f, 0.33792141f, 0.01174720f, -0.24608371f, -0.07407419f, 
    -0.07204848f, -0.01671221f, -0.06910460f, -0.00379072f, -0.13123658f, 0.05311228f, 0.04678096f, 0.08696437f, 
    0.10225509f, -0.08199735f, -0.01539799f, 0.07660226f, -0.08478637f, 0.13625260f, -0.01542786f, -0.09853637f, 
    0.12123319f, 0.14263758f, -0.28190181f, -0.26727030f, -0.10818488f, -0.10869934f, 0.28624505f, 0.14133811f, 
    0.06041989f, 0.06240606f, 0.42717588f, 0.00711764f, -0.15019946f, -0.06786129f, 0.19141565f, 0.04939846f, 
    0.11120096f, 0.12277282f, 0.18082239f, 0.04350778f, 0.37354061f, 0.11639478f, 0.13639918f, 0.32226199f, 
    -0.22187203f, -0.40524766f, 0.17799810f, -0.08121824f, -0.09608594f, -0.26631260f, -0.08398627f, -0.21647337f, 
    0.17325829f, 0.00402205f, 0.09843179f, 0.05345080f, 0.13439588f, 0.06316911f, -0.00793405f, 0.52673846f, 
    0.09566708f, 0.12311534f, -0.47568339f, 0.22883490f, 0.19708262f, -0.08626334f, 0.08698453f, -0.03751465f, 
    0.34818843f, 0.02147959f, -0.04728701f, 0.01048234f, 0.21018170f, -0.00813466f, 0.14094611f, 0.01346232f, 
    0.03046160f, 0.17515022f, -0.08380763f, -0.00188328f, -0.18066154f, 0.17655525f, -0.13076496f, 0.20610157f, 
    0.08930357f, -0.00569710f, -0.18907732f, -0.13334793f, -0.06481790f, -0.16390449f, -0.09671437f, 0.23341089f, 
    0.01498294f, 0.05395100f, 0.01992114f, 0.01915325f, 0.00407492f, 0.11083035f, -0.15927598f, 0.20467156f, 
    -0.13023034f, 0.01630960f, 0.16284099f, 0.09001201f, -0.01352286f, -0.09931285f, -0.01573680f, -0.23609997f, 
    -0.21678072f, -0.21143894f, 0.09929837f, 0.10716308f, 0.03077467f, -0.12115391f, -0.04216037f, -0.11740110f, 
    0.23714884f, 0.07887298f, 0.08220766f, -0.08720218f, 0.14259750f, -0.00934446f, -0.10413872f, -0.09645235f, 
    0.12339028f, 0.01567701f, -0.06074256f, 0.08936012f, 0.33635128f, 0.04556135f, -0.05917379f, 0.16321050f, 
    -0.17472766f, 0.24036023f, -0.01144589f, -0.06613465f, 0.09265795f, 0.12735872f, 0.12432417f, 0.22109322f, 
    -0.03784719f, -0.32058474f, 0.05703182f, -0.01550195f, -0.06579656f, 0.15282279f, -0.06629685f, 0.15393192f, 
    0.11138394f, -0.09580916f, -0.23366782f, -0.15428343f, -0.02868479f, 0.03727069f, 0.18700908f, 0.62984902f, 
    0.18161625f, -0.04633231f, 0.28678671f, 0.13079041f, -0.18850283f, 0.00504206f, 0.01034841f, -0.08139658f, 
    0.11678426f, 0.11988895f, -0.10308480f, -0.13902655f, -0.06217451f, 0.22138014f, -0.02005769f, 0.22841835f, 
    0.04712556f, -0.12810081f, 0.08668994f, -0.02152668f, 0.00548294f, -0.03889724f, -0.02352224f, -0.20601329f, 
    0.21711451f, -0.14932106f, 0.06918069f, -0.06324469f, 0.10990333f, 0.28195003f, -0.22885522f, 0.34877321f, 
    0.10002976f, -0.10354991f, -0.21547920f, 0.21074426f, 0.07341141f, 0.02436126f, 0.06608570f, 0.18067673f, 
    0.33714393f, 0.20576108f, -0.10167158f, 0.02271412f, 0.19693716f, -0.24785124f, 0.06790254f, -0.06135078f, 
    -0.10576327f, 0.00704025f, -0.04015926f, -0.05732470f, -0.08064336f, -0.02790949f, -0.01245940f, -0.04185459f, 
    -0.01925800f, 0.04819505f, 0.01461004f, 0.02891031f, -0.08976467f, -0.10654480f, -0.06284466f, 0.06417426f, 
    0.00833277f, -0.07190938f, -0.06853481f, -0.00535884f, -0.00626696f, -0.02565018f, -0.07643984f, -0.07278923f, 
    0.02613743f, 0.02122990f, -0.03377486f, -0.01286624f, -0.02438236f, 0.01151879f, -0.05860740f, -0.08753462f, 
    0.04341947f, -0.08254443f, -0.03486484f, -0.03488581f, 0.02710392f, -0.04685114f, -0.05442822f, -0.09637315f, 
    -0.03101619f, 0.02822994f, -0.07566696f, 0.05588650f, -0.03657196f, -0.03744235f, -0.08884259f, -0.00318817f, 
    -0.02284792f, 0.08245210f, -0.12003805f, -0.08934931f, 0.13621324f, -0.12409312f, -0.08913185f, 0.04177657f, 
    -0.09771513f, -0.04728094f, 0.10925490f, 0.06514645f, -0.11133023f, 0.03167052f, -0.04941200f, -0.01991859f, 
    -0.08289164f, -0.09603839f, -0.03585135f, 0.01447576f, -0.06709721f, -0.10735826f, -0.10861892f, -0.01673476f, 
    -0.13481486f, -0.00546796f, -0.07038538f, -0.06083330f, -0.02677512f, 0.05738379f, 0.08008708f, 0.06871927f, 
    0.00330113f, -0.07048927f, -0.04267010f, 0.02657388f, 0.00642060f, -0.01554612f, -0.08320902f, -0.00469680f, 
    0.00715029f, -0.04472654f, 0.03970101f, -0.02432917f, -0.07083610f, -0.07681422f, -0.10650712f, -0.06078125f, 
    -0.02225471f, 0.02463932f, -0.09530252f, 0.00708972f, -0.08267398f, -0.07328582f, 0.05585828f, -0.05081138f, 
    -0.00796514f, 0.00874007f, -0.06283558f, -0.02400895f, -0.05856422f, -0.09964603f, -0.00704171f, -0.07018398f, 
    -0.00060863f, -0.03240464f, 0.07216176f, 0.06705253f, 0.04397133f, 0.06702187f, 0.07204347f, -0.07944926f, 
    0.10100713f, -0.06616422f, -0.11941802f, -0.10001627f, -0.11348460f, -0.00730451f, -0.06405582f, -0.05244936f, 
    -0.11601958f, -0.00339601f, -0.09825619f, 0.10596026f, -0.10630386f, 0.22979823f, 0.01575232f, -0.02301674f, 
    0.03256479f, 0.18646921f, -0.06449657f, 0.20779383f, -0.13239461f, -0.08277900f, -0.01159078f, -0.26218668f, 
    -0.08216545f, 0.27355000f, -0.51214385f, -0.05558603f, -0.01804556f, 0.35639164f, 0.06227380f, 0.11830273f, 
    -0.18903010f, -0.42596245f, 0.04632767f, 0.31972671f, 0.16136299f, 0.05815507f, 0.04631890f, 0.13730805f, 
    -0.01126248f, -0.23705706f, 0.00330965f, -0.22012939f, 0.02396856f, -0.09511089f, -0.21167372f, 0.44598368f, 
    -0.00915958f, 0.00288555f, -0.04254653f, 0.48352179f, -0.13282216f, -0.12261867f, 0.05271868f, -0.07777204f, 
    0.36001843f, 0.02111900f, -0.00269545f, -0.05955010f, 0.64138573f, -0.18741387f, 0.14349629f, 0.07675295f, 
    -0.05298826f, 0.04468178f, 0.20848857f, 0.28349996f, 0.02416153f, -0.04940167f, -0.16833414f, 0.32507709f, 
    -0.08800571f, 0.09533843f, -0.01208214f, -0.33415073f, -0.02014765f, 0.08602315f, -0.12575185f, -0.03905091f, 
    -0.60470223f, -0.08896150f, 0.03845380f, 0.04133805f, -0.09597625f, -0.42338571f, 0.05826723f, 0.23132826f, 
    -0.16755660f, 0.08066393f, -0.54023665f, 0.06204361f, 0.00205186f, -0.05512743f, 0.07596160f, 0.42418531f, 
    -0.04528443f, 0.11413673f, -0.20457630f, -0.47948512f, -0.55491543f, 0.14425763f, 0.18246749f, -0.28026423f, 
    -0.16093676f, 0.06916334f, 0.04587531f, 0.07532486f, 0.10819578f, 0.05749978f, 0.04785654f, 0.09888425f, 
    -0.24612063f, 0.09622505f, -0.23010026f, 0.02761284f, -0.56387043f, -0.14777963f, 0.04782128f, -0.12241366f, 
    0.44125792f, 0.11799999f, -0.13303076f, 0.08849765f, 0.09065004f, 0.05978781f, 0.04287754f, -0.11999907f, 
    -0.03692304f, -0.51848179f, 0.12414153f, 0.06311470f, 0.23596381f, 0.10537785f, -0.04490358f, 0.02487030f, 
    -0.00462746f, 0.01312444f, -0.16764574f, -0.05689871f, -0.07609192f, 0.44839701f, -0.08775459f, 0.15475497f, 
    0.12492633f, -0.15184458f, 0.07032264f, 0.26123518f, 0.09894905f, 0.04022039f, 0.01412539f, -0.02443839f, 
    -0.05029594f, -0.06433031f, 0.28794521f, -0.15955508f, -0.06375393f, 0.15942478f, 0.03752916f, 0.03369448f, 
    0.07388091f, 0.07992399f, -0.09170193f, 0.15710996f, 0.30442870f, -0.06837384f, -0.01408057f, -0.13871546f, 
    -0.21378410f, -0.30031502f, -0.15232457f, -0.00673535f, -0.03859233f, -0.12420116f, -0.07964941f, 0.18229893f, 
    -0.01059072f, -0.08060891f, -0.04868639f, 0.18301803f, 0.37795785f, -0.13230212f, -0.16137575f, -0.00024719f, 
    0.18888603f, -0.08472932f, 0.05823058f, 0.12461739f, -0.15553866f, 0.19181144f, -0.03326699f, -0.06392745f, 
    0.05668187f, -0.04925820f, 0.10613073f, -0.48223156f, 0.06254449f, -0.06124160f, -0.00907991f, -0.11865476f, 
    0.09761010f, -0.18979241f, -0.04967052f, 0.06678387f, 0.09508985f, 0.62142354f, 0.02512039f, -0.04961063f, 
    0.00598526f, -0.00210885f, -0.22219759f, -0.28434533f, -0.01400498f, -0.18032065f, 0.11896560f, 0.45249364f, 
    0.03326356f, 0.07787208f, 0.24741647f, 0.09674920f, 0.18092030f, -0.01125332f, 0.16318852f, -0.04623434f, 
    0.12412453f, 0.18472585f, 0.20763572f, 0.27622432f, 0.14387716f, -0.06576931f, 0.12366930f, -0.04894010f, 
    -0.05151895f, -0.10075993f, 0.03141046f, -0.02482039f, 0.10504049f, -0.05274130f, -0.06883471f, -0.06122564f, 
    0.16407284f, 0.21817075f, -0.06215301f, -0.14486051f, -0.00766748f, 0.19314800f, 0.00923621f, -0.16053182f, 
    0.32073653f, 0.24358550f, -0.18122859f, 0.04728524f, 0.00232498f, -0.08342344f, -0.04622581f, 0.15228859f, 
    0.07267484f, -0.24840263f, -0.09424038f, -0.03730167f, 0.15409718f, -0.07555185f, -0.09018078f, -0.01912331f, 
    0.00620608f, -0.21238668f, -0.35111174f, -0.18566585f, -0.35134473f, 0.10195299f, 0.00109042f, 0.12660450f, 
    0.02802322f, -0.05224620f, 0.20739390f, 0.02979092f, 0.12324437f, 0.01372635f, -0.58618277f, 0.09355386f, 
    0.13771538f, 0.14055762f, 0.28110000f, 0.10576406f, -0.06986699f, -0.02884392f, 0.37236801f, -0.02023840f, 
    -0.07473217f, 0.16533296f, -0.41732088f, 0.07647747f, 0.09785037f, -0.03536632f, 0.01067099f, -0.10385003f, 
    -0.17375414f, -0.49717218f, -0.08374108f, -0.14241813f, -0.18823586f, -0.66111606f, 0.12470414f, 0.08103238f, 
    -0.15222242f, -0.11673895f, -0.53667659f, -0.01197190f, -0.03865566f, -0.51222265f, 0.06142196f, -0.38873065f, 
    0.04491288f, -0.47719070f, 0.13091487f, 0.00772437f, -0.10580921f, 0.23900874f, -0.02059872f, -0.07563957f, 
    0.22459285f, -0.18558657f, -0.30307794f, 0.09719106f, -0.03537521f, -0.00829060f, 0.06972155f, 0.05142242f, 
    0.05927623f, -0.00158861f, 0.04835533f, -0.13524128f, -0.08104195f, -0.02105528f, 0.23218213f, -0.27813396f, 
    -0.17726272f, 0.06171994f, 0.09716737f, -0.04943592f, 0.04130628f, -0.14217137f, 0.10472199f, -0.40446639f, 
    0.00500039f, 0.29771295f, 0.05996922f, 0.12616849f, 0.18303700f, -0.05172268f, 0.29163858f, -0.12002739f, 
    -0.02322077f, -0.16099845f, 0.33488089f, 0.25847962f, -0.13085738f, -0.30795944f, 0.30398670f, 0.18788402f, 
    -0.01008599f, -0.02963001f, 0.11354787f, -0.07929169f, -0.09871048f, 0.10036267f, -0.03273452f, 0.23815113f, 
    -0.11386106f, 0.30300128f, 0.19453683f, -0.05011429f, -0.12132270f, -0.04293523f, 0.42921001f, 0.38261178f, 
    0.13296039f, 0.24367334f, -0.24595295f, -0.12741061f, 0.01555785f, -0.34732813f, -0.08354073f, -0.10625426f, 
    -0.27269667f, -0.07986889f, 0.15433450f, -0.34573027f, 0.27832556f, 0.03402923f, 0.25237021f, -0.07838342f, 
    -0.06863344f, -0.07856130f, 0.00232467f, -0.03233346f, 0.07129652f, -0.00058409f, -0.05843324f, 0.04235069f, 
    0.07719637f, -0.02224309f, 0.01577532f, -0.00743762f, -0.04655199f, 0.04141532f, -0.02920960f, 0.02324341f, 
    -0.05139843f, 0.01273930f, 0.03878029f, 0.06051339f, -0.06031169f, 0.02549179f, -0.08894420f, -0.09327088f, 
    -0.08844972f, 0.02522077f, -0.08110140f, 0.04383744f, 0.07627528f, 0.02788626f, -0.02087243f, 0.02554460f, 
    -0.03081296f, 0.03108261f, -0.07797956f, 0.06496669f, -0.03538826f, -0.04427512f, 0.06900691f, 0.07064445f, 
    0.02738594f, -0.03765654f, -0.02614803f, -0.06600782f, 0.06816452f, -0.01666387f, -0.05932953f, 0.03065100f, 
    -0.08753204f, 0.00368483f, -0.04152148f, 0.03265041f, -0.13100943f, -0.03075157f, -0.07678842f, -0.05732678f, 
    -0.02951781f, 0.03465024f, -0.13175021f, -0.08178215f, -0.08880602f, 0.06853451f, -0.07479723f, -0.06729926f, 
    0.02903028f, -0.01530781f, -0.04331073f, -0.07361187f, -0.04447374f, -0.05843822f, 0.04939977f, 0.07713542f, 
    -0.06092720f, 0.00806316f, -0.01599823f, -0.02363893f, 0.03236499f, -0.08340345f, -0.04218540f, 0.00456771f, 
    0.05250320f, -0.07769580f, 0.01364943f, -0.00158516f, 0.02505070f, 0.00225045f, -0.02297773f, -0.08855270f, 
    -0.08317091f, -0.07200217f, 0.04354447f, 0.04985526f, -0.08190697f, -0.07113899f, -0.01409590f, -0.02342383f, 
    0.00683510f, 0.06333414f, -0.06751268f, 0.06562148f, 0.07334770f, -0.05988977f, -0.05366608f, -0.01274451f, 
    -0.08217967f, -0.03287188f, 0.06210359f, 0.05101902f, 0.06856406f, 0.01081373f, -0.01242827f, -0.10171805f, 
    -0.07656419f, -0.05393181f, 0.07839248f, -0.05044759f, 0.07437243f, 0.02173406f, -0.02176537f, -0.00096629f, 
    -0.10741188f, -0.07020258f, 0.00045272f, -0.00628908f, -0.06194951f, -0.02665232f, -0.03182334f, -0.03538029f, 
    -0.08876921f, -0.21038935f, 0.11776092f, -0.10122867f, 0.20291552f, 0.16658039f, -0.08134607f, 0.25636688f, 
    0.00580366f, 0.25920361f, 0.03762288f, 0.02781323f, 0.23811638f, -0.19620711f, -0.46079138f, 0.09654051f, 
    -0.15836419f, -0.03356437f, 0.04733089f, 0.08487025f, -0.03267002f, 0.09765467f, -0.02556389f, -0.08444180f, 
    -0.00610587f, -0.05411510f, -0.08021881f, 0.13434379f, 0.25499833f, 0.03500984f, 0.02140033f, 0.10026583f, 
    -0.03205103f, -0.13992865f, 0.00859675f, -0.09364817f, -0.01520301f, 0.15710279f, -0.14995545f, 0.50798893f, 
    0.08024866f, -0.08482336f, 0.07687572f, 0.23135649f, 0.10301272f, -0.16794352f, 0.15316539f, -0.21626072f, 
    0.09151267f, -0.07833505f, 0.21336703f, -0.05649526f, -0.28521544f, 0.15562367f, -0.00837814f, 0.03184798f, 
    0.10522250f, 0.03890183f, -0.18109669f, -0.13325417f, -0.05829231f, -0.19191389f, 0.16085218f, 0.06462237f, 
    0.22592613f, -0.03100037f, -0.05337974f, 0.12149357f, -0.00285643f, 0.30804592f, 0.00436467f, -0.14787236f, 
    -0.08931120f, -0.05355648f, -0.06338542f, -0.06528509f, 0.05891034f, 0.06762032f, 0.09647717f, 0.42461765f, 
    0.02925006f, -0.00691026f, -0.03355671f, 0.02985577f, 0.23521237f, -0.03599807f, 0.02860153f, 0.09781912f, 
    -0.08230134f, -0.07665043f, 0.28675497f, 0.03976945f, -0.10812765f, -0.07340971f, 0.04946717f, 0.40615559f, 
    0.00485380f, 0.18216892f, 0.14963304f, 0.01441492f, -0.00898959f, 0.08282828f, 0.05448036f, 0.26012701f, 
    0.00568055f, 0.25679606f, 0.04745618f, -0.15926006f, -0.09545122f, 0.03710055f, -0.17036940f, 0.16166739f, 
    0.05916864f, 0.39733252f, -0.20304957f, 0.12450697f, -0.07624993f, 0.02455443f, -0.00669076f, 0.05665147f, 
    0.09332848f, -0.15488377f, 0.08331963f, -0.11709410f, 0.32060760f, -0.24430333f, 0.13500309f, -0.06952062f, 
    -0.27752146f, -0.13500907f, 0.38154435f, -0.22448310f, 0.03445425f, -0.13181314f, 0.20935546f, -0.09578721f, 
    -0.32109484f, 0.19550051f, 0.17490737f, -0.27554902f, 0.19970754f, 0.04717332f, -0.31543994f, 0.41737989f, 
    0.16823106f, 0.13519455f, -0.02903221f, 0.03543483f, 0.08751918f, 0.18559748f, -0.12382220f, 0.00386816f, 
    0.36935690f, 0.02035278f, -0.06297208f, 0.04851131f, 0.04127328f, 0.13927415f, -0.42030331f, -0.23856699f, 
    -0.12408002f, 0.01974180f, 0.07564320f, 0.00594046f, 0.04180012f, 0.07306580f, -0.09576134f, 0.05448569f, 
    -0.06659757f, -0.00597295f, -0.01978980f, -0.16295172f, 0.31384662f, 0.00361289f, -0.06579154f, -0.10481730f, 
    -0.16756462f, -0.15617684f, -0.00864323f, -0.02997315f, -0.05733569f, 0.04487611f, 0.31164128f, 0.15652695f, 
    0.10112824f, 0.08974548f, 0.42968062f, -0.13814394f, 0.01369880f, 0.16726881f, 0.03568162f, -0.23767769f, 
    0.19301941f, 0.13014415f, 0.04481968f, 0.13486192f, 0.04783463f, -0.35218626f, 0.01557805f, -0.00225404f, 
    0.08341487f, -0.29680464f, -0.05202797f, -0.52454430f, 0.11175739f, 0.20643553f, -0.16263875f, -0.25332478f, 
    0.16847606f, -0.16823176f, -0.08123838f, -0.05634481f, 0.19089377f, -0.02692130f, -0.07240247f, 0.00030229f, 
    0.16971640f, -0.14109384f, -0.01787122f, -0.19226009f, -0.30223122f, 0.09817281f, 0.01892865f, 0.03926258f, 
    -0.10773338f, -0.16566761f, -0.06830969f, 0.00950087f, 0.18100785f, -0.25666630f, 0.07209224f, 0.13173848f, 
    -0.04511691f, 0.20715220f, 0.13253288f, -0.25123200f, 0.07532025f, 0.28604579f, -0.10676003f, 0.19874245f, 
    0.16721267f, 0.03869533f, -0.06646585f, 0.15046278f, -0.38771638f, 0.07344368f, -0.01904389f, 0.13936390f, 
    -0.49598217f, 0.16139542f, -0.13477345f, 0.09150142f, -0.03075865f, 0.09467012f, -0.01184504f, 0.03774526f, 
    -0.36122090f, -0.00925239f, -0.19245198f, 0.15885858f, -0.05588747f, -0.07393449f, 0.00678317f, -0.19498667f, 
    0.01485887f, -0.01062661f, -0.12327276f, -0.07463831f, -0.04657420f, -0.04265868f, -0.10139354f, 0.06554150f, 
    0.08427309f, 0.11940284f, 0.01598281f, 0.15367836f, 0.12923948f, 0.07623328f, -0.10030936f, 0.22219370f, 
    -0.06146193f, -0.32275584f, 0.27001461f, 0.28961378f, -0.25273204f, -0.00416984f, 0.06591755f, -0.07943226f, 
    -0.00610793f, 0.22813283f, 0.10745961f, 0.17641555f, 0.06849401f, 0.03993235f, 0.11604502f, -0.26428404f, 
    -0.16189365f, 0.08543031f, 0.09566870f, 0.00958708f, -0.11362854f, 0.13226603f, -0.35658535f, 0.11039641f, 
    0.19923244f, 0.18027940f, -0.02388544f, 0.09056526f, 0.14332549f, 0.17594405f, 0.26801321f, 0.15100431f, 
    -0.15766849f, 0.18619010f, -0.09115301f, 0.11418252f, 0.05445410f, 0.04692997f, 0.19069462f, -0.10781673f, 
    -0.03395909f, -0.11670563f, -0.03826562f, -0.02043597f, 0.01572947f, 0.09494918f, 0.08922374f, 0.34692264f, 
    0.25057933f, -0.19927405f, 0.00444746f, -0.00795709f, -0.02249816f, 0.17546915f, -0.20947152f, -0.20183404f, 
    0.09669169f, -0.17629020f, -0.22982009f, 0.15019709f, -0.02173559f, -0.05500843f, 0.01853440f, -0.08783039f, 
    0.03826684f, 0.10186315f, -0.39697680f, -0.08496768f, -0.30310366f, 0.07766075f, 0.08036135f, -0.31797019f, 
    0.17071557f, 0.15208980f, -0.02982898f, 0.08347695f, 0.15929797f, 0.12815449f, 0.03548693f, 0.20653443f, 
    0.17731355f, -0.14451669f, -0.12761068f, -0.20148312f, 0.07748120f, 0.12406705f, -0.10289176f, -0.13904080f, 
    0.10940205f, -0.26985469f, 0.02132249f, -0.16913779f, -0.52155334f, 0.09362996f, 0.04481619f, 0.05853508f, 
    -0.16559131f, 0.20305972f, -0.08559292f, 0.06224122f, -0.11355660f, 0.15265541f, 0.04233490f, 0.02741290f, 
    -0.03770629f, -0.14580415f, -0.01947717f, -0.11115374f, -0.12672555f, -0.02565792f, -0.04822016f, -0.05108560f, 
    0.03454427f, -0.06337292f, 0.01081278f, 0.01584306f, 0.03328259f, -0.09095601f, 0.04803795f, 0.02292144f, 
    -0.07468580f, -0.14443456f, 0.06789558f, -0.08587586f, -0.08052253f, -0.04045116f, -0.03111102f, -0.14384481f, 
    0.04528104f, -0.12529370f, -0.06112607f, 0.01936168f, -0.07295045f, -0.12991326f, -0.00647045f, -0.00308222f, 
    -0.11772877f, -0.12666991f, -0.04244570f, -0.02447281f, -0.12412247f, 0.05071918f, -0.00639308f, 0.05152237f, 
    -0.06235884f, 0.05942460f, -0.04016093f, 0.02167252f, -0.09602299f, -0.12766302f, -0.02994828f, -0.01137589f, 
    -0.11376857f, -0.00257231f, -0.10306297f, -0.05656844f, 0.12479272f, -0.11360290f, -0.13606030f, -0.01345977f, 
    -0.06290049f, -0.06042125f, 0.03418870f, -0.06719905f, -0.06437301f, -0.00322818f, -0.17311510f, 0.16081592f, 
    0.02437430f, -0.06691647f, 0.04659727f, -0.08421510f, -0.06381261f, 0.03930323f, 0.01824151f, -0.00140865f, 
    -0.06161401f, 0.00187472f, -0.03205923f, 0.00516610f, -0.01977340f, -0.10179227f, -0.05030609f, 0.02125428f, 
    -0.02462966f, -0.07092006f, -0.13660522f, -0.12067315f, -0.08849571f, -0.03155768f, -0.12782688f, -0.11668474f, 
    -0.00897830f, -0.07559189f, 0.02460179f, -0.15951638f, -0.05081042f, -0.04555100f, -0.12107138f, 0.04431034f, 
    -0.03653250f, -0.10153949f, -0.04984355f, -0.06003463f, -0.13819674f, -0.00886918f, -0.06165034f, -0.00729498f, 
    -0.13407294f, 0.00434003f, -0.05199014f, 0.04457565f, -0.01395015f, -0.02568478f, -0.00789481f, -0.00953696f, 
    -0.03386258f, 0.02106251f, 0.00672266f, -0.09069639f, 0.00265253f, -0.13690217f, -0.07664512f, -0.12934454f, 
    0.00366618f, -0.11960066f, 0.01927949f, -0.01056894f, 0.05594099f, -0.01156114f, -0.04738118f, 0.04205308f, 
    -0.32941970f, 0.10011743f, -0.07126766f, -0.00853619f, -0.00750266f, -0.03938481f, 0.11434180f, -0.09251802f, 
    -0.40572363f, 0.22830145f, -0.18676290f, -0.23351043f, 0.04219316f, -0.05879804f, 0.00283090f, 0.22042106f, 
    0.07463747f, 0.25101951f, -0.17300116f, 0.04014172f, -0.05540837f, -0.01641240f, -0.16302502f, 0.18920149f, 
    -0.01703409f, -0.15259953f, -0.04150991f, 0.15158665f, 0.08361537f, -0.05053426f, 0.11229663f, -0.09530730f, 
    -0.18539171f, 0.05097293f, 0.16758794f, -0.01293701f, -0.12122476f, -0.32048601f, -0.17422335f, -0.27862510f, 
    -0.16451062f, 0.04563503f, 0.03811586f, -0.21727584f, 0.11827838f, 0.02518828f, -0.08866717f, -0.06334369f, 
    0.00443248f, -0.06256869f, 0.18906531f, 0.08190887f, 0.46022075f, -0.20061186f, 0.08251538f, 0.21109900f, 
    -0.13571353f, 0.09957036f, -0.14771912f, 0.51603156f, 0.11143343f, 0.22659856f, 0.23990478f, -0.01105797f, 
    -0.06078127f, 0.06091528f, 0.08244079f, -0.08969649f, 0.01593298f, -0.27041537f, -0.00017581f, 0.20544602f, 
    0.20338650f, -0.29988322f, -0.00355535f, -0.16595174f, 0.03808656f, 0.14658025f, -0.01396872f, -0.08530339f, 
    0.22165057f, -0.02034585f, 0.05271113f, 0.15319361f, 0.00185845f, -0.04469000f, 0.05281800f, -0.13607909f, 
    0.00830440f, -0.14248475f, -0.15125833f, -0.25360620f, -0.13824551f, 0.27701026f, 0.02989668f, 0.12791324f, 
    0.03830317f, -0.12050093f, 0.07826532f, 0.06071299f, 0.06967421f, 0.04665778f, -0.08210108f, -0.01459624f, 
    0.04827683f, -0.09064141f, 0.10098980f, -0.02791544f, 0.40695718f, 0.01342742f, -0.02454417f, 0.39519924f, 
    -0.17460547f, -0.12802041f, -0.04780401f, 0.08412984f, -0.36149585f, -0.08380665f, -0.03432098f, 0.10226216f, 
    -0.10855617f, 0.23067716f, 0.01101629f, 0.13513176f, -0.09907733f, 0.00009954f, -0.07416553f, -0.01703470f, 
    -0.13549964f, 0.02553917f, 0.09958177f, -0.00813016f, -0.19362877f, -0.00032817f, 0.01176109f, 0.06534400f, 
    -0.04221366f, 0.16626793f, 0.11978038f, -0.03326036f, -0.00435252f, 0.23649196f, 0.01231559f, 0.32312110f, 
    0.04484611f, 0.15553781f, -0.09490494f, -0.05652761f, 0.14837748f, 0.21040642f, -0.00566790f, 0.26326269f, 
    0.25531173f, -0.03084118f, -0.05726445f, -0.03612512f, 0.00699410f, -0.02353635f, -0.16669084f, 0.00709055f, 
    -0.09988312f, -0.00692538f, -0.06944616f, 0.04918529f, 0.08411767f, -0.04108270f, -0.03932721f, -0.11980040f, 
    -0.00768143f, -0.04466305f, -0.12931326f, -0.10146945f, 0.35592824f, -0.02578270f, -0.12321988f, 0.01915887f, 
    -0.09493287f, 0.00968922f, -0.02250257f, 0.25400102f, -0.04138537f, 0.11837296f, 0.30596900f, 0.15074913f, 
    0.02533476f, 0.16931969f, 0.51904058f, -0.18867511f, 0.08818617f, 0.25797144f, 0.09011425f, -0.01258075f, 
    0.14723536f, 0.15643473f, -0.06315661f, -0.04625306f, 0.01110232f, -0.14960715f, 0.14803383f, 0.02256554f, 
    0.03193669f, -0.00880616f, -0.02716733f, -0.23939015f, -0.08384155f, -0.03344554f, 0.09466412f, -0.47916055f, 
    -0.00386363f, 0.04410912f, -0.06487973f, 0.01016164f, -0.08439979f, -0.02796709f, 0.05544988f, -0.01935193f, 
    0.12330768f, -0.18050383f, 0.01324176f, 0.20625801f, 0.04780518f, 0.12026648f, 0.32453904f, -0.11425918f, 
    -0.05259076f, -0.11146075f, -0.02205067f, -0.03196017f, 0.13196072f, -0.06840328f, -0.05978069f, 0.18852027f, 
    -0.12672092f, 0.08763090f, 0.06131485f, 0.03633676f, -0.07420950f, 0.14266524f, 0.19544122f, 0.08649863f, 
    0.20388366f, -0.07150936f, 0.00816502f, 0.08166809f, -0.17883795f, -0.00064353f, -0.03303191f, 0.06610154f, 
    -0.02634518f, 0.02206944f, -0.02380847f, 0.12696899f, 0.14300917f, 0.22363429f, 0.14074747f, 0.08168698f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09745291f, -0.14276145f, 0.20608325f, 0.02609869f, 0.06845447f, -0.05523880f, 0.00674724f, 0.08157913f, 
    0.15957490f, 0.09725237f, -0.03359736f, 0.11637030f, -0.08099286f, 0.10756628f, -0.08507555f, -0.03394196f, 
    -0.05150220f, 0.06409229f, 0.27240810f, 0.07646535f, 0.07085569f, -0.05752892f, -0.05026605f, 0.01081065f, 
    0.28602389f, 0.09775741f, -0.05542199f, -0.06608500f, -0.10958922f, -0.07180505f, 0.17244996f, 0.13462760f, 
    0.17127429f, 0.06653027f, -0.00041126f, 0.01904563f, -0.04741073f, -0.07178678f, 0.00297428f, 0.13852061f, 
    -0.01163215f, 0.33878186f, -0.05214697f, -0.08889218f, -0.03679413f, 0.19397376f, 0.22814794f, -0.00935545f, 
    0.30911887f, -0.08005292f, -0.10694045f, 0.02376170f, -0.02438449f, 0.13307121f, 0.02559263f, -0.00433259f, 
    -0.13511908f, 0.04311580f, -0.05462346f, -0.04068475f, 0.37936765f, -0.01053598f, -0.07620209f, -0.14189959f, 
    -0.08873987f, 0.10356819f, -0.01968807f, -0.07259159f, 0.18475141f, 0.28948364f, 0.08175272f, 0.15185909f, 
    0.14529634f, 0.05076041f, 0.00223053f, -0.00529228f, 0.04992167f, 0.00170594f, 0.45282117f, -0.00231689f, 
    0.27989167f, 0.15436225f, -0.01213066f, -0.04198945f, 0.00845434f, -0.10500697f, 0.16374975f, 0.07443262f, 
    -0.03098929f, -0.03543043f, 0.13036223f, 0.01210685f, 0.13743167f, -0.00820550f, -0.02546259f, -0.03597136f, 
    -0.11596557f, 0.12843235f, -0.03704226f, 0.12823318f, -0.10956731f, 0.14104454f, -0.05359336f, 0.06872517f, 
    0.04393227f, -0.10841204f, 0.11808170f, 0.04525002f, 0.02942824f, 0.16168608f, -0.09222036f, -0.13650613f, 
    0.28355145f, -0.09700029f, 0.11989742f, 0.13701157f, 0.13612622f, -0.01332789f, 0.06633539f, 0.34095842f, 
    0.08043037f, -0.09505089f, 0.29872909f, 0.09874044f, 0.15368542f, -0.00821769f, -0.17183067f, 0.16718304f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.06363776f, 0.18110889f, 0.10653096f, 0.18736742f, -0.43159008f, 0.01445838f, -0.09032103f, -0.52955019f, 
    0.17926846f, -0.41187331f, -0.08328539f, 0.15917246f, 0.05591226f, -0.01607499f, -0.01387448f, 0.00291531f, 
    -0.00525573f, -0.00841564f, -0.03935109f, -0.68753171f, 0.02024998f, 0.03959159f, 0.29733983f, -0.05593725f, 
    0.09428466f, -0.59658587f, -0.03156963f, -0.00254499f, -0.02027495f, -0.02839125f, -0.62965685f, -0.24312735f, 
    -0.25812343f, -0.21579945f, -0.05855183f, -0.20518385f, 0.04148277f, 0.17990318f, -0.04014097f, -0.14949095f, 
    0.08590342f, -0.36617920f, -0.27270108f, -0.08580769f, 0.00476235f, -0.16151784f, -0.54504538f, -0.05083687f, 
    0.06090797f, -0.05516399f, 0.01000915f, -0.29504612f, 0.03980760f, 0.16773246f, 0.06060991f, 0.18473786f, 
    -0.00998046f, -0.08195815f, -0.01553363f, -0.05114288f, 0.08948746f, -0.13880804f, -0.03649809f, -0.24586289f, 
    -0.05982450f, 0.13269639f, 0.04297178f, 0.01318211f, -0.37818304f, 0.03948922f, -0.30840492f, -0.35200772f, 
    0.28402942f, -0.03730788f, 0.16635218f, -0.23840913f, -0.02481055f, 0.01619615f, -0.18339659f, -0.04690817f, 
    0.00170929f, 0.17722949f, -0.29677504f, -0.14264257f, -0.41396120f, -0.02405052f, -0.28661832f, -0.04587541f, 
    -0.04725127f, -0.37106556f, -0.00508145f, 0.17222355f, -0.20185900f, -0.18617010f, 0.20179819f, -0.35322818f, 
    0.15208769f, -0.12827720f, -0.09280507f, 0.02524660f, -0.07761480f, -0.41949081f, 0.03370130f, -0.07559019f, 
    0.01796003f, 0.10015563f, -0.02026430f, 0.00517026f, 0.10488191f, 0.11089105f, 0.07074685f, -0.21412754f, 
    -0.11452173f, -0.05231170f, -0.04705794f, -0.03320296f, -0.41972944f, -0.00561255f, -0.01137618f, -0.00764415f, 
    0.16022921f, 0.03477134f, 0.09747932f, -0.22631398f, -0.09069835f, -0.09353539f, -0.12571208f, -0.31429872f, 
    0.05295547f, -0.53560746f, 0.03534185f, -0.10352294f, 0.04271185f, -0.01045844f, 0.04570541f, -0.15149614f, 
    -0.02076525f, -0.06670011f, -0.04247689f, 0.11632394f, -0.08175029f, -0.28984556f, -0.04366769f, 0.04073492f, 
    -0.04827887f, 0.23772316f, 0.03341556f, -0.11364094f, 0.06103237f, -0.07551187f, -0.70469373f, -0.02003267f, 
    0.04043898f, -0.45889774f, 0.05780508f, 0.04421246f, -0.01912248f, -0.05989653f, -0.06388140f, 0.05576615f, 
    0.24340525f, -0.62057394f, 0.03144052f, -0.43427557f, -0.07285187f, 0.00021847f, -0.02329706f, 0.21639825f, 
    0.18720284f, 0.19936904f, -0.14462529f, -0.03380483f, 0.03328077f, 0.09886318f, 0.12164351f, -0.00731059f, 
    0.09588080f, -0.06508218f, -0.02543690f, -0.09623845f, -0.00682517f, 0.09263934f, -0.00990015f, 0.38594621f, 
    -0.22583076f, -0.04894321f, 0.02326389f, -0.09837726f, 0.34735876f, -0.11375480f, -0.03153599f, -0.14641900f, 
    -0.00272991f, 0.00907489f, -0.02270541f, -0.02527741f, 0.21664834f, 0.07312400f, 0.11568698f, 0.12791295f, 
    0.06749393f, -0.04968046f, 0.16615826f, -0.13300040f, 0.02939342f, -0.01133536f, 0.09118569f, 0.09042717f, 
    0.01357188f, 0.03004104f, -0.62688935f, -0.02469289f, -0.02395456f, -0.05244204f, -0.02290895f, -0.03068182f, 
    -0.00424208f, 0.10236669f, -0.13948184f, 0.15175208f, 0.00682070f, -0.11726534f, 0.12978117f, -0.55050647f, 
    0.02478640f, 0.04839819f, 0.02713674f, 0.00447843f, -0.59457451f, 0.02471125f, -0.09415851f, -0.22321717f, 
    0.03042730f, 0.34032315f, 0.19436184f, 0.13625868f, -0.05670920f, 0.01252501f, -0.04767965f, -0.22138993f, 
    0.35744804f, -0.03040001f, 0.03351674f, -0.08337557f, -0.52265358f, 0.03532198f, 0.03700501f, 0.06582879f, 
    0.25770542f, -0.08056262f, 0.13339196f, 0.17657727f, 0.17415565f, -0.00753990f, -0.45616952f, 0.11222052f, 
    0.13547648f, -0.67954832f, 0.05377449f, -0.26110196f, 0.04829603f, -0.05636229f, -0.03206344f, 0.18656980f, 
    0.02294531f, 0.29864234f, 0.03981956f, 0.09032945f, 0.03210014f, 0.21769960f, 0.06061944f, 0.01224155f, 
    0.06120894f, -0.45619947f, 0.00615583f, 0.06474506f, -0.08059814f, -0.07566146f, -0.52797174f, 0.06358498f, 
    -0.17034705f, 0.20115551f, 0.03135162f, -0.12108616f, -0.04918834f, -0.07725222f, 0.03371669f, 0.05501832f, 
    -0.40360305f, 0.04931943f, 0.05907254f, 0.19128715f, -0.06475613f, -0.08401163f, -0.07083038f, -0.07073822f, 
    -0.53686422f, -0.52567989f, 0.13499273f, -0.10744143f, -0.01358823f, -0.36671275f, 0.18209656f, -0.00868987f, 
    -0.22868980f, -0.06085211f, 0.03627214f, -0.01391705f, 0.03376651f, -0.06864598f, -0.00549769f, -0.49100414f, 
    0.10529454f, 0.00546953f, 0.03775261f, -0.12284625f, 0.12205526f, -0.12508240f, 0.07420053f, -0.16590287f, 
    -0.00490895f, -0.22892524f, 0.01694440f, -0.04020956f, 0.20453040f, -0.52800184f, -0.50148427f, 0.30917576f, 
    0.09198411f, 0.03879359f, -0.42708454f, 0.09347541f, -0.00240366f, -0.46333650f, 0.19497587f, -0.52223551f, 
    0.09155761f, -0.07722065f, 0.13395956f, -0.01447552f, 0.02601295f, -0.10189208f, 0.13967511f, 0.07177887f, 
    0.06124274f, -0.08507790f, 0.13968556f, -0.15516847f, -0.04650633f, -0.10937957f, -0.44870481f, -0.03660284f, 
    -0.03103168f, 0.10592629f, 0.00174926f, 0.07994764f, 0.09069336f, 0.16082783f, -0.12665080f, 0.04966188f, 
    -0.52369100f, -0.43360028f, -0.21871459f, -0.21655186f, -0.02457018f, -0.07120380f, -0.03282951f, -0.26793048f, 
    -0.31116700f, -0.05897160f, 0.30123645f, 0.23583536f, 0.07813644f, 0.05458898f, 0.11108550f, -0.08445202f, 
    -0.55902177f, 0.00147671f, -0.04030684f, 0.10695641f, -0.22444044f, -0.00918495f, 0.08542800f, -0.05034068f, 
    -0.69605303f, -0.00934977f, 0.29840204f, -0.01398560f, -0.15058289f, 0.01998082f, -0.07099584f, 0.08237278f, 
    0.21393569f, 0.25320563f, 0.06550561f, 0.09114715f, 0.02899740f, 0.08384731f, -0.03250693f, -0.01009359f, 
    0.02773818f, -0.05193530f, 0.08009082f, 0.02591646f, 0.05331958f, -0.00507771f, 0.17586517f, -0.08316924f, 
    0.06291927f, 0.09225353f, -0.01437906f, -0.04857183f, -0.11054714f, -0.07740251f, -0.07355893f, -0.41450900f, 
    -0.45788509f, 0.24332392f, -0.02739996f, 0.10166630f, 0.03468772f, -0.06671617f, -0.01293725f, -0.33864528f, 
    -0.14000408f, 0.19516268f, 0.23714831f, 0.03800833f, 0.00797829f, -0.29524285f, -0.12227463f, -0.02597721f, 
    0.00108850f, -0.03709623f, -0.00565852f, -0.21746358f, -0.03897590f, 0.09850805f, 0.35541484f, -0.00878983f, 
    0.10860553f, 0.02266684f, 0.07005367f, 0.03971807f, -0.26010963f, -0.06220025f, -0.01283398f, -0.16987084f, 
    0.03064256f, -0.16307122f, 0.18398000f, 0.01515532f, -0.05649000f, -0.10664789f, -0.14064826f, 0.11412533f, 
    -0.17230456f, 0.04227999f, -0.14231050f, 0.03300934f, 0.04795685f, -0.12419261f, -1.49431682f, 0.20907402f, 
    -0.56928861f, 0.00934183f, 0.12440848f, -0.14879967f, -0.26421601f, -0.03548939f, -0.28117338f, 0.03241165f, 
    -0.09252198f, -0.30311826f, 0.02806661f, 0.00516249f, 0.30493608f, -0.18769284f, -0.02759959f, -0.00692928f, 
    -0.12130243f, 0.12119067f, 0.00258754f, 0.29560050f, 0.06697326f, -0.19005445f, 0.02032595f, -0.50465727f, 
    -0.48694515f, 0.01020978f, -0.16021392f, 0.00197851f, -0.02964679f, -0.07184885f, -0.05933623f, -0.14012581f, 
    -0.41869092f, -0.08480922f, 0.18423693f, 0.15434884f, 0.02142849f, 0.03992963f, -0.45475087f, 0.10525134f, 
    -0.06160264f, 0.02424153f, 0.04680162f, -0.27217340f, -0.12454209f, -0.00129025f, -0.06630706f, 0.07783127f, 
    0.03858338f, 0.12141225f, -0.34677920f, -0.01826959f, -0.35634425f, -0.07031531f, -0.04103152f, -0.31130350f, 
    -0.19054438f, -0.20203716f, 0.02256374f, 0.07703096f, -0.04520451f, -0.02768176f, -0.09531342f, 0.00685663f, 
    0.02539548f, -0.21957175f, 0.08811632f, -0.14698020f, -0.00759518f, -0.05942545f, -0.03505575f, -0.05232595f, 
    0.09984389f, -0.04981099f, -0.00381283f, -0.10023066f, -0.06909671f, -0.00552549f, -0.07843380f, 0.02317508f, 
    -0.62047660f, 0.08801722f, 0.00563681f, 0.08873795f, -0.13304490f, 0.12155144f, -0.03176890f, -0.28283852f, 
    0.00044594f, -0.55769479f, -0.02071936f, 0.04213247f, -0.10256879f, 0.03603800f, -0.15640461f, -0.04889845f, 
    0.15184894f, 0.02386595f, -0.02199088f, -0.00066055f, 0.05472453f, 0.17957391f, -0.26938969f, 0.04831359f, 
    0.07074950f, 0.07514045f, -0.02880188f, 0.00973925f, -0.33806485f, 0.02544069f, -0.04671601f, 0.18189919f, 
    0.00835967f, -0.02054591f, 0.09529440f, -0.06136699f, -0.06157662f, 0.08840053f, -0.02051564f, -0.39109811f, 
    -0.08157411f, 0.07068499f, -0.08213246f, -0.17266597f, -0.00077556f, -0.03039661f, -0.34972554f, 0.30796328f, 
    -0.07561791f, 0.04386827f, -0.71871209f, -0.12413690f, 0.16073765f, -0.11649345f, -0.56900913f, 0.00245588f, 
    -0.01902004f, 0.06650025f, 0.13048311f, -0.02170343f, 0.09344383f, 0.20472436f, 0.10885887f, 0.12724948f, 
    0.24066277f, 0.10077220f, 0.04049347f, -0.21986072f, 0.12597361f, 0.01646578f, -0.03739693f, -0.46322173f, 
    -0.46485147f, 0.14144689f, -0.08350855f, 0.18001001f, -0.06681015f, 0.10965748f, -0.03020765f, -0.04546257f, 
    -0.40877479f, 0.05430770f, 0.02666378f, 0.10007884f, 0.03392601f, 0.02942763f, -0.23826751f, 0.11142126f, 
    -0.09309085f, -0.05627879f, 0.05498090f, -0.34665489f, -0.44560587f, -0.07933323f, -0.13827266f, -0.21255364f, 
    0.06832901f, -0.14926818f, -0.12074488f, 0.02245300f, -0.01247983f, 0.08035521f, -0.06379909f, -0.12560536f, 
    0.05862888f, -0.01248630f, -0.01656935f, 0.02550181f, 0.05018964f, -0.03055148f, -0.05652255f, 0.01502190f, 
    -0.07153519f, 0.01076685f, 0.04960554f, 0.00333581f, -0.07944503f, -0.10749304f, -0.05509128f, -0.05684242f, 
    0.04381744f, -0.03341818f, 0.00589705f, -0.01846984f, -0.00031459f, 0.05094111f, -0.03635678f, 0.25252461f, 
    -0.23674935f, -0.52135092f, -0.09038323f, -0.16403781f, 0.03222218f, 0.14210978f, 0.05838286f, 0.12713829f, 
    -0.04255579f, 0.27375138f, -0.49407139f, -0.07667017f, -0.08614876f, 0.05650466f, 0.08272251f, -0.07204472f, 
    0.09029530f, -0.10931166f, 0.06807118f, 0.19017278f, 0.05195478f, 0.04516996f, -0.24793702f, -0.13610512f, 
    0.11075951f, 0.03100823f, -0.07820889f, -0.06794537f, -0.17687210f, -0.05126178f, 0.06697039f, 0.13215852f, 
    -0.03989190f, 0.08171138f, -0.28322789f, 0.07172062f, 0.14562817f, 0.19730993f, -0.58213288f, -0.04428757f, 
    -0.15205115f, -0.04200164f, 0.02656440f, 0.14499356f, -0.06146105f, 0.12426965f, -0.56640238f, -0.48310876f, 
    -0.02135487f, 0.06809090f, -0.39974234f, -0.12523580f, -0.05354254f, -0.01704758f, 0.17707200f, -0.06458209f, 
    0.02211579f, 0.10485794f, 0.07862245f, 0.08911330f, -0.22676432f, 0.07006864f, 0.05998810f, 0.01176855f, 
    0.05960440f, -0.04178860f, -0.06429183f, 0.18248200f, -0.04413804f, -0.48722062f, -0.04473491f, -0.23694617f, 
    0.23864743f, -0.05469655f, -0.60315019f, -0.17164078f, 0.14882426f, 0.03481709f, -0.03642328f, 0.08419453f, 
    -0.08453086f, 0.03152401f, -0.08618457f, 0.04876579f, 0.06790489f, 0.05781871f, -0.14749829f, 0.01981946f, 
    0.09394601f, -0.04239079f, 0.12017672f, 0.07970957f, -0.10537816f, -0.00197403f, 0.20435791f, 0.04411136f, 
    0.17517161f, -0.30158034f, -0.40902323f, -0.48089853f, 0.12339265f, -0.00073026f, 0.06386850f, 0.17531045f, 
    -0.58862913f, -0.02977007f, -0.05778786f, -0.67936122f, 0.03448383f, 0.17316836f, -0.06328414f, -0.01155335f, 
    -0.05727854f, -0.15012012f, -0.77962333f, 0.05385569f, 0.00756378f, -0.10654578f, -0.57214725f, 0.00539910f, 
    -0.91142690f, 0.23194829f, -0.01670624f, 0.04342558f, -0.03093906f, 0.02792408f, 0.05738926f, 0.05060926f, 
    0.21727797f, 0.06560900f, -0.06196059f, 0.10445837f, 0.06751969f, -0.10884660f, -0.03235041f, -0.05574780f, 
    -0.31860965f, -0.15550981f, 0.11593747f, -0.07373555f, -0.05682427f, -0.20164818f, -0.17234884f, 0.05504506f, 
    -0.94092405f, 0.02689413f, -0.04571979f, 0.22133152f, 0.02166471f, -0.54904646f, -0.03693534f, -0.09171914f, 
    -0.04486263f, -0.01299077f, -0.06280226f, -0.01019624f, 0.03907881f, -0.03889427f, 0.04198372f, -0.01814385f, 
    -0.00065705f, -0.02224611f, 0.05981509f, -0.02799148f, -0.10883269f, -0.31341058f, 0.19591410f, -0.12624323f, 
    -0.24763057f, 0.05699650f, -0.08211982f, -0.26767415f, 0.03902228f, -0.59538579f, 0.00651927f, 0.22615208f, 
    -0.08071650f, -0.42650306f, 0.24585906f, -0.19852619f, 0.24927846f, -0.02035875f, 0.25099337f, 0.05195221f, 
    0.04734457f, -0.13815965f, 0.16664091f, -0.13327345f, 0.00224275f, 0.11470944f, -0.21459529f, 0.22626643f, 
    -0.05112872f, -0.43867287f, -0.04894460f, 0.09135633f, 0.17500116f, -0.18120688f, -0.11281135f, 0.24983203f, 
    0.10699693f, -0.20506594f, -0.35426134f, -0.46614760f, -0.27496064f, 0.13921031f, 0.01228849f, -0.01660636f, 
    0.13381176f, -0.00981175f, -0.73819488f, -0.42325473f, 0.01360111f, 0.10473831f, 0.18755436f, -0.71420413f, 
    -0.14514060f, -0.06675597f, -0.90205234f, 0.19716631f, 0.18442288f, -0.05367856f, 0.16389640f, 0.07742384f, 
    -0.11121479f, 0.55861282f, -0.07470157f, 0.00306481f, -0.07797989f, -0.03002146f, 0.02564370f, -0.10761742f, 
    -0.08379866f, -0.27366272f, -0.04553739f, -0.31926781f, 0.04943233f, 0.07413904f, -0.04428524f, 0.03483688f, 
    -0.09213088f, -0.15644504f, -0.65730518f, 0.12630515f, 0.06209262f, -0.07317202f, 0.52076620f, 0.07746190f, 
    -0.64700752f, 0.07744665f, -0.10694772f, -0.03276569f, 0.02484823f, -0.01594072f, 0.06661268f, 0.17198306f, 
    -0.17384323f, 0.24481152f, -0.03434652f, -0.55005991f, -0.05122811f, -0.00072721f, -0.05889306f, -0.32235047f, 
    0.14241570f, 0.18322316f, -0.22863740f, 0.08297738f, -0.05133716f, 0.19143924f, -0.19240002f, 0.02155513f, 
    -0.24620138f, -0.00777732f, 0.01600650f, -0.20575239f, 0.00765318f, -0.33634633f, -0.12980133f, -0.10260756f, 
    0.21841788f, 0.01523496f, -0.07467442f, 0.02402622f, -0.35101992f, -0.02873285f, -0.05596180f, 0.07442975f, 
    0.05614912f, -0.20916112f, 0.00388240f, -0.04360609f, -0.15592906f, 0.13827333f, -0.43915901f, -0.01248088f, 
    0.21278743f, -0.05275970f, 0.17743209f, 0.07879864f, 0.06822334f, 0.32962832f, -0.30398333f, 0.00069696f, 
    -0.04647370f, 0.17704268f, 0.15501958f, -0.03060068f, -0.09481661f, -0.04163909f, 0.00079545f, 0.06252587f, 
    -0.06280858f, 0.10035532f, -0.54033297f, 0.14072832f, -0.00877834f, 0.00556442f, -0.25073409f, 0.29548880f, 
    0.05251266f, -0.65245426f, 0.03895795f, -0.22527295f, 0.17006557f, 0.07216257f, -0.03036074f, -0.20638755f, 
    -0.31904814f, -0.21946560f, -0.23186462f, 0.38378182f, -0.49776301f, -0.21963991f, 0.03553570f, 0.30391321f, 
    -0.08687300f, 0.01570367f, -0.37258652f, -0.54094434f, -0.04945828f, -0.04490208f, -0.02198288f, -0.53229260f, 
    -0.32844931f, 0.03677297f, -0.53090620f, -0.22273262f, 0.15413232f, -0.07610568f, 0.29596832f, -0.10368237f, 
    -0.11993417f, -0.33055958f, 0.39407587f, 0.12193438f, 0.21107791f, -0.06925249f, -0.01825281f, 0.25202167f, 
    0.21832296f, 0.14386088f, 0.01009661f, -0.33353475f, 0.02274102f, 0.10419546f, -0.00255668f, -0.04142842f, 
    0.02234069f, 0.12405711f, -0.05263064f, -0.12007629f, -0.04864435f, -0.04366484f, -0.19584435f, -0.03770056f, 
    -0.07093328f, -0.01579226f, -0.07578593f, -0.08593061f, -0.12373115f, 0.03213919f, 0.17747541f, 0.07060917f, 
    -0.07751730f, 0.09719875f, 0.06152120f, -0.23805058f, 0.00034056f, -0.60122943f, 0.05631480f, 0.14616874f, 
    -0.02988796f, -0.04009216f, -0.61358458f, -0.05763693f, -0.04844062f, 0.10345161f, -0.17706648f, -0.03032857f, 
    0.01878408f, -0.07413337f, 0.06710830f, 0.28676438f, -0.05121369f, -0.08234428f, -0.56276298f, -0.22013168f, 
    -0.18394154f, -0.02430658f, -0.04313781f, -0.02536850f, 0.13715716f, -0.02356993f, 0.00841731f, -0.01220962f, 
    0.09209037f, 0.24044375f, -0.11448012f, -0.00964706f, -0.07459196f, 0.14761494f, -0.01148899f, 0.21717855f, 
    -0.07959501f, 0.00728884f, 0.31783998f, 0.14121017f, -0.05265232f, 0.00357839f, 0.24207462f, 0.44304320f, 
    -0.25279209f, 0.08564330f, -0.05956642f, 0.01862771f, -0.02044513f, -0.01647732f, 0.23619720f, -0.04515099f, 
    0.00959034f, 0.04455559f, -0.63141412f, -0.46393287f, 0.16917185f, -0.01627323f, -0.33145216f, -0.15536903f, 
    -0.21977426f, -0.90063095f, -0.02809551f, 0.04482427f, -0.33820170f, -0.04239206f, -0.04395292f, 0.03278428f, 
    0.12589487f, -0.27064687f, 0.18524596f, -0.29690421f, -0.34596345f, 0.24544467f, -0.03018017f, 0.08051749f, 
    -0.11536729f, -0.06689209f, -0.48818225f, -0.66938126f, 0.08084969f, -0.04812998f, 0.04715130f, 0.23654099f, 
    -0.53274518f, -0.01277137f, -0.20803340f, 0.21971865f, -0.12108015f, -0.00689796f, 0.18915828f, 0.19353779f, 
    0.01188844f, -0.11314650f, -0.45220903f, -0.09093249f, -0.13995107f, -0.01422035f, -0.08882710f, 0.02872715f, 
    -0.72404599f, -0.02242458f, -0.08137410f, -0.17432536f, -0.02002433f, 0.02718939f, 0.06036043f, -0.00480275f, 
    -0.03022469f, -0.26760098f, -0.11714569f, -0.13891704f, 0.00754673f, -0.02146123f, -0.28576502f, 0.01263070f, 
    -0.01742639f, 0.11143188f, -0.11129121f, 0.00419259f, 0.02400422f, -0.03179058f, 0.13329318f, -0.03050349f, 
    0.09549669f, 0.27710539f, -0.01891281f, 0.12559752f, -0.10791226f, -0.22689284f, -0.07731500f, -0.39602202f, 
    -0.38489503f, 0.00751883f, -0.17396423f, 0.03391819f, -0.09649479f, 0.08117520f, -0.18137586f, -0.11227581f, 
    -0.06822016f, 0.06621013f, -0.10459547f, 0.10523629f, -0.01752041f, 0.12412294f, -0.36127689f, -0.25442624f, 
    -0.03003478f, -0.08801548f, -0.06007136f, 0.03001860f, -0.01549513f, 0.00747238f, 0.05050643f, 0.17359063f, 
    -0.05281535f, 0.23099326f, 0.00761023f, -0.06086345f, -0.50695974f, 0.06444540f, 0.08270752f, -0.41600478f, 
    0.22262576f, -0.02508760f, -0.78259701f, -0.32882336f, -0.07912591f, -0.24514788f, -0.03161057f, -0.11556394f, 
    0.18509497f, -0.58522040f, 0.06131799f, -0.11509427f, 0.19903868f, 0.03688639f, 0.04833427f, -0.06591959f, 
    -0.06943101f, -0.02246062f, 0.05055860f, 0.10110054f, -0.02664465f, 0.24240626f, -0.02540090f, 0.21983732f, 
    -0.24063347f, 0.17118454f, -0.05881692f, -0.34030920f, 0.20505171f, -0.64717412f, 0.05294527f, 0.11472680f, 
    -0.30179727f, -0.43407640f, 0.04871343f, 0.22245283f, 0.18880524f, 0.17491145f, -0.04026664f, -0.01382354f, 
    0.19932371f, -0.06004588f, -0.03473740f, 0.04036051f, 0.17962444f, 0.08764730f, -0.19952559f, -0.01164290f, 
    -0.41668680f, 0.02060075f, -0.00809994f, -0.23961087f, 0.09468929f, -0.02770592f, 0.00592298f, -0.02853305f, 
    -0.60932767f, -0.08858038f, -0.16008060f, 0.11789651f, 0.08476072f, 0.05704955f, 0.00840819f, -0.01853031f, 
    0.15739182f, 0.04766263f, 0.06122919f, -0.20134217f, -0.04566982f, -0.36706430f, 0.00723822f, -0.06570376f, 
    0.02405589f, 0.27322158f, 0.10988154f, 0.15940432f, 0.03313388f, 0.01424398f, -0.45138502f, -0.05671759f, 
    -0.00093395f, 0.08586107f, -0.11159378f, -0.07679070f, -0.02702922f, -0.09178764f, -0.03620244f, 0.10662187f, 
    -0.18738158f, -0.23735984f, -0.01976542f, -0.40816656f, -0.02025933f, -0.10826361f, -0.05821715f, 0.04475651f, 
    0.18023555f, -0.23732029f, -0.12738277f, 0.06105049f, -0.03966757f, 0.13931535f, 0.24440864f, -0.03251789f, 
    0.16359058f, 0.04193809f, -0.04076986f, -0.06451092f, 0.00028599f, -0.55710596f, -0.13810825f, -0.44871274f, 
    -0.33683133f, 0.03057616f, 0.02451746f, 0.00252244f, -0.30013767f, -0.02037226f, 0.08144468f, -0.10074605f, 
    -0.02215063f, -0.66687500f, -0.26685524f, -0.00241716f, 0.18700217f, -0.38426486f, 0.17305337f, 0.12185225f, 
    -0.53958178f, -0.01634713f, 0.12762119f, 0.21806137f, -0.05895941f, 0.29641736f, -0.74109179f, -0.32120308f, 
    0.08227776f, 0.16071770f, -0.23019475f, -0.07983493f, -0.02431261f, -0.10162041f, 0.07015376f, 0.01373180f, 
    0.00555531f, 0.06522219f, -0.26925349f, -0.44355381f, 0.27342823f, -0.55632252f, -0.38605368f, 0.05951362f, 
    -0.51626050f, 0.00375627f, -0.01930545f, -0.20977482f, -0.22400863f, -0.07238491f, 0.07820636f, 0.02230892f, 
    -0.42686582f, 0.05047747f, -0.56030351f, 0.38776457f, 0.12483713f, -0.41486809f, 0.04527527f, 0.23555411f, 
    -0.40666476f, 0.00339147f, 0.21053849f, -0.26997983f, 0.01989833f, 0.06069354f, 0.48278457f, 0.08268449f, 
    -0.53881365f, 0.04862580f, 0.13123268f, 0.02676483f, -0.40982157f, 0.01588424f, -0.05562053f, -0.19895755f, 
    -0.12242448f, -0.52117181f, -0.30541059f, -0.09891466f, 0.11537626f, -0.03154369f, -0.08742003f, 0.03215237f, 
    -0.57677883f, 0.04545026f, -0.01508078f, 0.08960281f, -0.08887517f, -0.19113670f, -0.02087828f, -0.01559824f, 
    -0.00753307f, -0.44559613f, -0.04486079f, 0.18246603f, -0.02182425f, -0.03438512f, -0.01859111f, -0.05384729f, 
    -0.01981021f, -0.06632296f, 0.00900541f, 0.01917665f, -0.10169225f, 0.02494601f, 0.06223395f, -0.20148380f, 
    0.12882859f, -0.04884103f, -0.02397168f, 0.18527205f, -0.06618311f, -0.25062969f, -0.08004107f, 0.16719709f, 
    0.08823434f, 0.10770021f, 0.34805509f, 0.02584067f, 0.03962085f, 0.01003862f, 0.12902305f, -0.09053955f, 
    -0.19520546f, 0.04035202f, 0.06892127f, -0.13704452f, -0.00739743f, 0.03897399f, -0.06747528f, -0.28822064f, 
    -0.10087015f, -0.02624866f, 0.00408605f, -0.12553522f, 0.02341974f, -0.03548927f, -0.00225579f, 0.14941855f, 
    -0.00336265f, -0.19398433f, -0.00826807f, -0.09941848f, 0.21015361f, 0.13890383f, 0.20305744f, -0.02833261f, 
    -0.18259346f, -0.04216096f, -0.07090818f, -0.11787231f, 0.04330759f, -0.21923625f, -0.02689403f, -0.13114280f, 
    -0.19189365f, -0.44759211f, 0.06318247f, -0.05647695f, -0.08055280f, 0.00764373f, -0.18799300f, 0.05122802f, 
    -0.05438395f, 0.09667618f, 0.07069165f, -0.12315848f, -0.36458305f, 0.00691152f, 0.02922096f, -0.21388954f, 
    0.16663419f, 0.18558237f, -0.05973718f, -0.20407918f, -0.22477248f, -0.75074059f, 0.04049943f, 0.15406090f, 
    0.24205200f, -0.18052624f, 0.12541641f, -0.37411064f, 0.11579037f, -0.34509084f, -0.06715196f, 0.18452442f, 
    0.08714149f, -0.09295632f, 0.05668601f, 0.07335068f, -0.15599534f, 0.02137977f, -0.58160114f, 0.12385646f, 
    0.10051984f, 0.07970554f, -0.12492062f, 0.14269243f, 0.01980435f, -0.03927355f, -0.04999951f, 0.11962803f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.30610999f, 0.26288992f, 0.06396641f, 0.10853992f, 0.01286964f, -0.09883428f, -0.12218968f, -0.15035811f, 
    0.10856284f, 0.21394758f, -0.04432648f, -0.13042811f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
