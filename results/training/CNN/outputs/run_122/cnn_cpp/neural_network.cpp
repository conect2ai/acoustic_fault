#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.19902097f, 0.53004456f, -0.24793768f, -0.58034658f, -0.65585047f, -0.44194567f, 0.14954986f, -0.05692246f, 
    0.31887817f, -0.55432218f, -0.54627395f, -0.46329173f, 0.15421431f, -0.40001506f, 0.26365969f, -0.12248046f, 
    -0.08917288f, -0.01646531f, -0.51813358f, -0.43634605f, 0.27436852f, 0.56204170f, 0.27505398f, 0.41843891f, 
    0.20312870f, -0.28951430f, 0.07798116f, -0.04728446f, 0.66469228f, -0.34903389f, 0.72886473f, -0.32433128f, 
    -0.32838336f, -0.29817137f, -0.13527817f, -0.31724745f, 0.25034323f, -0.25908437f, 0.36156511f, 0.38290405f, 
    0.21082576f, 0.30537072f, -0.24376330f, -0.49443227f, 0.08797695f, -0.84393287f, 0.08695603f, 0.18922397f, 
    0.40059558f, 0.24316248f, -0.07159284f, -0.24855733f, -0.34928513f, -0.36323532f, -0.54510772f, -0.12693931f, 
    -0.44184816f, 0.20065431f, 0.72333294f, 0.61764801f, 0.23445065f, 0.02037136f, 0.12417334f, 0.62505794f, 
    -0.32781884f, 0.58176267f, 0.26344809f, -0.54867375f, 0.44259647f, -0.00597862f, -0.05770056f, -0.05704762f, 
    -0.38734290f, -0.38308752f, -0.39913872f, -0.44882894f, 0.22037262f, 0.17433190f, -0.26949269f, 0.35997260f, 
    -0.50884992f, 0.36183581f, 0.02270043f, -0.18351026f, -0.79700100f, 0.29990482f, 0.27088019f, 0.07575805f, 
    0.18604100f, 0.30406377f, 0.15753067f, -0.11631999f, -0.18768653f, 0.38813624f, 0.74677873f, -0.24131906f, 
    0.57725537f, 0.08270510f, -0.31603041f, 0.36686131f, 0.72950351f, 0.49775115f, 0.15639308f, -0.02755534f, 
    0.24247800f, -0.08776625f, 0.24166618f, 0.11152189f, 0.56882674f, 0.42088744f, 0.73053050f, -0.07473917f, 
    -0.04239752f, -0.32150397f, 0.18212938f, -0.12272103f, -0.15677479f, 0.32336357f, -0.34383270f, -0.48828259f, 
    0.53446251f, 0.29545617f, -0.44173977f, -0.23905052f, -0.09061113f, 0.02498468f, -0.13345307f, -0.53998750f, 
    0.27648720f, -0.33300680f, -0.65001649f, -0.18463063f, 0.11115767f, 0.09448159f, -0.09136488f, 0.45355958f, 
    -0.83521277f, -0.52911168f, -0.49524069f, -0.09333906f, -0.25683329f, -0.09788737f, 0.12339346f, 0.25196683f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12503627f, 0.10102313f, -0.42024666f, 0.05539497f, 0.27122313f, 0.03931453f, -0.18684247f, -0.05372019f, 
    -0.12037760f, -0.32197320f, -0.08311551f, 0.19258916f, 0.40170082f, 0.17024320f, 0.30593139f, 0.09317847f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.14108053f, 0.17196120f, 0.04734465f, 0.00579075f, 0.04505655f, 0.06079625f, 0.00726275f, -0.01902980f, 
    0.16209470f, -0.04552704f, 0.20788668f, -0.39496785f, 0.07845485f, 0.17287709f, -0.03587940f, 0.00165342f, 
    0.11758693f, -0.07273088f, 0.38333842f, -0.07180695f, 0.11510346f, -0.12180002f, -0.00985050f, 0.14388792f, 
    0.07453196f, 0.00143799f, 0.07324196f, -0.43039623f, -0.01922675f, 0.15225786f, -0.01557581f, -0.07930573f, 
    0.01080563f, 0.01716396f, -0.04203117f, -0.02657552f, 0.23780726f, -0.30438992f, 0.11106244f, 0.07567599f, 
    0.04725131f, 0.00512876f, 0.09515356f, 0.16196948f, 0.12323640f, 0.00185270f, -0.29951036f, -0.02407416f, 
    0.11400723f, 0.02147759f, -0.20787963f, 0.05841385f, 0.05034016f, -0.19833526f, 0.14240870f, -0.25244340f, 
    -0.22653815f, 0.10519416f, -0.02593669f, -0.07153456f, -0.07838651f, 0.05166840f, -0.16437721f, 0.52945209f, 
    0.10953782f, -0.00734253f, 0.02997644f, -0.03515680f, 0.12522919f, -0.19948523f, 0.10344838f, -0.01859125f, 
    -0.36569840f, -0.28742546f, -0.24930163f, 0.03433754f, 0.10791805f, -0.10933539f, -0.03126713f, -0.03996194f, 
    0.15901133f, -0.10015930f, -0.17168094f, -0.04143890f, -0.17006975f, -0.01169972f, 0.12037797f, -0.08127318f, 
    0.00889851f, 0.06476030f, -0.12020838f, -0.33330509f, -0.22973074f, 0.01637585f, 0.25274777f, -0.00729973f, 
    -0.02826346f, 0.02309812f, 0.08963052f, 0.17072561f, 0.06449813f, 0.22618139f, -0.07636067f, 0.06762373f, 
    -0.01401758f, -0.02610758f, 0.14926854f, -0.02262853f, 0.10056865f, 0.21334976f, 0.16555521f, 0.03927544f, 
    0.02377990f, 0.14166242f, 0.09910659f, -0.00431505f, 0.07019987f, -0.45679483f, 0.05960418f, 0.11387818f, 
    0.17746581f, -0.02015026f, -0.06893281f, 0.11583760f, -0.00969608f, -0.01177466f, 0.04400790f, 0.24971519f, 
    -0.14081705f, -0.01223221f, 0.01438732f, -0.03485826f, 0.06764830f, -0.04777883f, 0.12432340f, -0.08787754f, 
    0.07054067f, -0.20183285f, 0.14307830f, 0.09889542f, -0.01731331f, -0.17766607f, -0.15991417f, -0.14535029f, 
    0.08907637f, -0.30187505f, 0.02226737f, -0.09533254f, -0.06745285f, 0.17537650f, -0.16081706f, -0.04416021f, 
    -0.32332122f, 0.35788336f, 0.62763101f, 0.09981982f, 0.10082425f, 0.10334086f, -0.03770650f, 0.24957156f, 
    0.09396984f, -0.03458446f, -0.21482432f, -0.00385705f, 0.09376029f, -0.05409194f, 0.12334466f, -0.04199748f, 
    0.17078474f, 0.16823296f, 0.07834315f, -0.40936124f, 0.02684427f, -0.15792891f, -0.10179212f, 0.16856258f, 
    -0.01857820f, -0.12252995f, -0.04951793f, -0.25538343f, -0.06688071f, -0.00354233f, -0.06036174f, 0.16127190f, 
    0.18631944f, -0.09596207f, -0.04782953f, -0.12741749f, 0.04147645f, -0.04496824f, 0.14774089f, -0.02041959f, 
    -0.00554172f, 0.02596966f, -0.16556582f, -0.32000503f, -0.02548723f, 0.19654645f, 0.23283656f, -0.09888461f, 
    0.12609895f, 0.28096128f, 0.15341988f, -0.08597582f, 0.13275380f, -0.07413686f, 0.03086132f, 0.19418725f, 
    0.12653065f, -0.02892666f, 0.06353434f, -0.14224577f, -0.06643938f, 0.03801654f, -0.02738553f, 0.13877612f, 
    -0.01168363f, 0.17375076f, 0.05930329f, 0.02734020f, 0.02979690f, -0.06621749f, 0.04675423f, -0.10345501f, 
    0.05340205f, -0.02052248f, -0.16785823f, 0.03637934f, 0.09718984f, -0.14518686f, -0.12414724f, 0.19552024f, 
    -0.09801459f, 0.16368775f, 0.14889543f, -0.09272370f, 0.04978205f, 0.01472664f, -0.01247832f, 0.09024303f, 
    0.16928211f, -0.06986341f, 0.05741967f, 0.16186981f, -0.12198965f, -0.22344325f, -0.14019763f, -0.00512172f, 
    -0.08182658f, 0.07680771f, -0.06922247f, 0.08511464f, -0.03717688f, -0.07405011f, 0.06158426f, 0.08765469f, 
    -0.06532983f, -0.03115386f, -0.00012639f, 0.12178317f, 0.16853553f, 0.28857666f, -0.00336954f, 0.05711908f, 
    0.05677488f, 0.01264125f, -0.01704396f, 0.06461589f, 0.13189742f, 0.10005075f, -0.07373545f, 0.02461608f, 
    -0.17884566f, 0.04986067f, 0.07655544f, -0.00876187f, -0.13262741f, 0.10901186f, -0.09291012f, 0.14432642f, 
    -0.23264371f, 0.02441220f, 0.18513997f, -0.03522960f, -0.05466650f, -0.12797591f, -0.00072253f, -0.08723039f, 
    -0.03853592f, 0.06454363f, -0.00664383f, -0.06973882f, 0.06468418f, -0.02524420f, -0.03411461f, -0.08687567f, 
    -0.08453707f, 0.04357275f, 0.01965056f, 0.01843123f, 0.04972679f, -0.01198997f, -0.04542926f, -0.00656853f, 
    0.04449984f, 0.03824958f, -0.08548823f, 0.03154992f, 0.01858995f, -0.07005443f, 0.05822255f, -0.07860605f, 
    -0.02928415f, 0.07146517f, -0.04924075f, -0.02834521f, 0.03281472f, 0.02178202f, -0.07117612f, -0.00133731f, 
    -0.01764616f, 0.05886539f, -0.05848708f, 0.00569292f, -0.08542854f, -0.02300312f, -0.06869106f, 0.01179128f, 
    -0.05330133f, -0.06454381f, -0.01630765f, -0.02601461f, -0.00469721f, -0.05554061f, -0.05352852f, 0.01175543f, 
    -0.08124060f, -0.02178843f, -0.00659982f, 0.06659152f, -0.00811493f, -0.04239122f, -0.03913624f, 0.03832067f, 
    0.00074489f, -0.04173209f, 0.06665866f, -0.00625666f, -0.04910950f, 0.02395187f, 0.02152228f, -0.09593215f, 
    -0.06059712f, -0.03406653f, 0.03483564f, 0.03966487f, 0.05500542f, 0.02314148f, 0.00803801f, 0.05245609f, 
    -0.03343704f, 0.03737866f, 0.04932859f, 0.03792020f, 0.02954666f, 0.02120603f, -0.04540860f, 0.04929036f, 
    0.00453641f, 0.05329001f, -0.10140814f, -0.03595337f, -0.06026609f, 0.04403458f, -0.08231223f, 0.04524883f, 
    -0.04622412f, -0.00805620f, 0.05463795f, -0.07439692f, -0.08554576f, 0.04439687f, 0.02552523f, -0.05215341f, 
    0.04297610f, -0.06207537f, -0.00778083f, -0.05636453f, 0.04632168f, 0.05059389f, 0.05796010f, -0.08439662f, 
    -0.10021411f, -0.07619650f, -0.04296361f, -0.10239621f, -0.06125810f, 0.06290566f, -0.03188758f, 0.01873095f, 
    -0.08107816f, -0.04731956f, -0.03507963f, -0.06799110f, 0.03221794f, -0.09448058f, -0.03788368f, 0.04535329f, 
    -0.04835950f, -0.05419030f, -0.03954188f, 0.00964100f, 0.03958032f, 0.01559877f, -0.03370328f, 0.03947211f, 
    -0.07593683f, -0.03829036f, -0.01603615f, -0.00718862f, 0.02343579f, -0.04763748f, 0.05401500f, -0.04986683f, 
    -0.05514903f, -0.07217637f, 0.02077752f, -0.07590773f, -0.01601812f, 0.03787337f, -0.05186801f, -0.02652830f, 
    0.11360408f, -0.24278256f, -0.12537618f, -0.11750181f, -0.03757763f, -0.06916615f, -0.06761905f, -0.05221209f, 
    -0.06878886f, 0.11247300f, 0.09293001f, 0.25157452f, 0.01509436f, 0.22603847f, 0.00086070f, 0.19886747f, 
    0.04814434f, -0.05853018f, 0.08543026f, -0.16446659f, 0.11184677f, 0.19526426f, 0.10708221f, 0.05722046f, 
    -0.12340584f, 0.03139861f, -0.03056880f, 0.25545558f, -0.04170792f, 0.09569205f, 0.02418529f, -0.05591836f, 
    -0.06930480f, -0.02290574f, -0.01267407f, 0.12516990f, -0.20534578f, -0.37257925f, -0.37080660f, 0.01226827f, 
    0.02519866f, 0.08394069f, 0.00764000f, 0.14721954f, -0.08807240f, 0.15883642f, 0.03052610f, 0.07375138f, 
    -0.06542514f, -0.05658314f, 0.04942175f, 0.00221757f, 0.10187918f, 0.07696416f, -0.04358005f, 0.00928165f, 
    0.25698355f, 0.19576684f, -0.05813459f, -0.06561424f, 0.00552986f, 0.14949465f, 0.20237973f, 0.02817064f, 
    -0.19123101f, -0.08592114f, 0.04798322f, 0.01558898f, 0.00761828f, -0.05095095f, 0.04381940f, 0.16215500f, 
    -0.05825196f, 0.23709814f, -0.01259156f, 0.06125011f, -0.13401997f, -0.08732000f, -0.04708425f, 0.03641265f, 
    -0.31646582f, -0.33413064f, -0.05104437f, -0.04776811f, -0.04222875f, -0.00124039f, -0.35539150f, -0.00775498f, 
    -0.02461850f, 0.15677990f, 0.01830149f, 0.05762536f, 0.06075794f, 0.08433551f, -0.19227646f, -0.21338600f, 
    0.08351139f, 0.02270153f, -0.08854129f, -0.20220309f, 0.26136115f, 0.01234990f, -0.17277153f, 0.06984649f, 
    0.32139799f, 0.09087611f, 0.13265535f, 0.15929705f, -0.38375911f, -0.03875163f, 0.14128627f, 0.06997083f, 
    0.05387432f, 0.17752522f, -0.04429398f, 0.09481944f, -0.02437430f, 0.14620116f, -0.07011367f, -0.16110577f, 
    0.00657833f, 0.02506389f, 0.00781364f, 0.03732456f, 0.03868391f, -0.01222345f, 0.11876824f, -0.22951157f, 
    -0.03831462f, -0.00383281f, -0.11007092f, -0.11458181f, 0.19157848f, -0.14289230f, -0.03222018f, 0.02802548f, 
    -0.17816161f, 0.05628162f, -0.16421722f, -0.21114656f, 0.03097437f, 0.00844152f, 0.09507719f, 0.00229343f, 
    -0.02446085f, 0.09557030f, 0.05847312f, 0.09247419f, -0.03707573f, 0.19877841f, -0.07960382f, -0.03318914f, 
    0.03075846f, -0.18266669f, 0.07475216f, -0.08036809f, 0.09665825f, 0.07247656f, -0.15019001f, -0.07692751f, 
    0.09370005f, -0.04168184f, 0.03416256f, 0.30440181f, 0.20279881f, 0.10195766f, -0.02949460f, -0.12016421f, 
    -0.03642632f, 0.00515789f, 0.00323573f, 0.05190087f, -0.16683787f, 0.07293241f, 0.17899621f, 0.01964706f, 
    0.10779449f, -0.16511315f, 0.04585596f, -0.06352603f, -0.05536199f, 0.04386684f, 0.20784417f, -0.03762452f, 
    0.01310085f, -0.14157300f, 0.09154883f, 0.16575094f, 0.22668275f, 0.30013725f, 0.11316815f, 0.00576786f, 
    -0.01432568f, 0.05184180f, -0.01439644f, 0.04223512f, -0.05967834f, -0.08169448f, 0.42465976f, 0.37611488f, 
    -0.20783952f, -0.06201369f, 0.04124677f, 0.06384367f, 0.00957323f, -0.09139867f, -0.01327135f, -0.42392674f, 
    0.06842488f, -0.21202359f, 0.07276571f, -0.04673634f, 0.02969257f, -0.06147074f, 0.02185378f, 0.01664523f, 
    -0.17030372f, -0.07466617f, -0.33117127f, 0.12516123f, -0.02824765f, 0.06461298f, 0.03071892f, -0.12533520f, 
    -0.02788932f, 0.27386221f, 0.15918832f, -0.21967249f, 0.01033989f, -0.05586389f, 0.10405844f, -0.13151529f, 
    0.07321976f, 0.02627965f, 0.07342581f, -0.36404020f, -0.08734933f, -0.06323893f, -0.01745927f, 0.03315978f, 
    0.01583283f, 0.02065974f, 0.05409409f, -0.14519833f, 0.14825666f, -0.11665249f, -0.01260128f, 0.01516647f, 
    0.06828031f, -0.07524560f, 0.09189568f, 0.03083685f, 0.11492785f, 0.16477042f, -0.01213068f, -0.04232011f, 
    0.07564270f, 0.06337401f, 0.02226352f, -0.00650335f, 0.11588393f, -0.19912916f, -0.28460354f, -0.14496028f, 
    -0.20576526f, -0.05562071f, 0.12158082f, 0.01194734f, 0.00876648f, -0.01349691f, -0.12931237f, -0.20750485f, 
    -0.12598403f, 0.04202087f, 0.08343653f, 0.06264913f, 0.07660540f, -0.01111516f, 0.10517428f, 0.00704291f, 
    -0.43931568f, 0.07760666f, -0.18439619f, 0.09562609f, -0.07159453f, 0.10297090f, -0.09723533f, 0.00731821f, 
    -0.04896097f, 0.01366710f, 0.03000702f, -0.05660694f, 0.04357891f, -0.00234380f, -0.02666836f, 0.04190002f, 
    -0.05144737f, 0.03441244f, -0.00784426f, 0.02043660f, 0.04425587f, -0.05814289f, 0.02977990f, 0.02851291f, 
    0.03448408f, -0.04237208f, -0.05030650f, -0.02171948f, 0.05639969f, -0.07135629f, -0.04935605f, 0.04157906f, 
    -0.04191019f, -0.01349266f, -0.05214829f, -0.03007172f, 0.04547123f, -0.09960265f, -0.01861808f, -0.05466652f, 
    -0.08465512f, 0.03723993f, 0.00313062f, -0.04247297f, -0.11273997f, -0.07970694f, -0.02109984f, 0.03143370f, 
    -0.01755666f, 0.04508754f, -0.10797766f, 0.06214564f, 0.01654404f, -0.10713445f, 0.00515168f, -0.02505570f, 
    -0.01874272f, -0.03213678f, -0.09353669f, -0.06278229f, 0.01963494f, -0.08907980f, -0.03663764f, 0.04010012f, 
    -0.00969816f, 0.03735378f, -0.02426736f, 0.04139871f, -0.08585307f, -0.08858049f, 0.00630455f, 0.03445626f, 
    -0.02507488f, 0.03600803f, 0.05551221f, 0.01924146f, 0.02832588f, -0.08749071f, 0.04439013f, -0.01090509f, 
    -0.09570722f, -0.08391502f, -0.08742023f, 0.04548754f, -0.10026912f, 0.01383333f, 0.01404072f, -0.01766159f, 
    -0.01084807f, -0.02844078f, -0.09332382f, 0.05276619f, -0.02066888f, 0.06547372f, -0.07664926f, -0.00243806f, 
    0.02012424f, -0.05354650f, -0.07287103f, -0.05464586f, 0.00166999f, -0.02602593f, 0.06255046f, 0.04793793f, 
    0.05029089f, -0.05408325f, -0.07996987f, -0.03790797f, -0.06214392f, -0.03941511f, -0.04035414f, 0.04578666f, 
    0.07171258f, -0.06520883f, -0.01404428f, 0.04609639f, 0.04758320f, -0.10411625f, 0.04272799f, -0.04969590f, 
    -0.09949040f, -0.06114023f, 0.02807179f, -0.09758301f, -0.08144128f, 0.02815332f, -0.01123351f, -0.04390869f, 
    -0.01120363f, -0.05648072f, -0.06801508f, -0.05849293f, 0.02114302f, -0.11218981f, 0.04063009f, -0.05294518f, 
    -0.09215219f, -0.00690247f, -0.02489755f, -0.05165287f, 0.02857730f, -0.08207928f, 0.01320902f, -0.01466254f, 
    0.02179567f, 0.04047057f, -0.05787788f, 0.03601053f, -0.09393317f, -0.01124515f, -0.07433797f, 0.00537389f, 
    0.17175949f, -0.04990055f, -0.00974882f, 0.17520078f, 0.05924987f, 0.09171335f, -0.14275511f, -0.01552416f, 
    0.04735262f, -0.05803147f, -0.12532403f, 0.03967953f, -0.05679856f, 0.08277449f, -0.09820611f, 0.04178621f, 
    0.15128136f, -0.12274239f, 0.24239676f, -0.00849453f, -0.25514248f, -0.02782534f, -0.14719826f, -0.04786176f, 
    -0.09042304f, 0.08303844f, -0.23311315f, 0.18118164f, 0.00472950f, -0.29354560f, 0.05943708f, 0.05546213f, 
    -0.01573873f, 0.09557490f, -0.14745517f, -0.06726628f, -0.19653960f, -0.10878626f, -0.06513070f, -0.06477719f, 
    0.00617660f, -0.07925536f, -0.08636849f, 0.04142583f, -0.04080117f, 0.19081397f, -0.08740474f, -0.14107460f, 
    -0.14768918f, -0.05497412f, -0.08698987f, 0.13370286f, -0.05962270f, -0.06918681f, 0.25179026f, 0.06419729f, 
    0.00805284f, 0.04871443f, 0.05111235f, -0.13620664f, 0.23313166f, 0.09181689f, -0.01616300f, -0.36714026f, 
    0.05197746f, 0.16745287f, 0.01289324f, 0.13817367f, 0.03916092f, 0.17155384f, 0.07252221f, 0.02478160f, 
    0.15400551f, 0.01943331f, 0.16032790f, -0.11926872f, 0.11642765f, 0.01676513f, 0.02679760f, -0.07992663f, 
    -0.00901090f, -0.42488644f, 0.01567643f, -0.25769553f, 0.02778340f, 0.02786226f, 0.05037470f, 0.15897968f, 
    -0.09401784f, 0.14176312f, -0.10657136f, -0.05438444f, -0.24218455f, 0.00403199f, 0.05698530f, 0.12492242f, 
    -0.07741342f, 0.15688580f, 0.03999101f, -0.75779301f, -0.16886984f, 0.06905477f, -0.12316616f, -0.05522965f, 
    0.07421612f, -0.05555256f, -0.00461727f, 0.09713814f, -0.51630574f, 0.25010207f, 0.20300049f, 0.03686536f, 
    0.20705780f, 0.10469421f, -0.00487683f, 0.03263024f, 0.11412486f, 0.07931349f, -0.05535887f, -0.10659567f, 
    -0.13947813f, 0.03478708f, 0.04079735f, 0.10320907f, 0.02042067f, -0.01731403f, 0.39468515f, 0.21837972f, 
    0.14909644f, -0.01787171f, -0.15119670f, 0.03389016f, -0.06431401f, 0.15854545f, 0.10321290f, -0.21500559f, 
    -0.09598223f, 0.28373030f, -0.02968724f, -0.11644170f, -0.00110823f, 0.03897087f, 0.11440251f, -0.03854724f, 
    -0.02617814f, 0.00417239f, -0.10267194f, -0.12950914f, -0.07122476f, 0.20517312f, -0.04712036f, -0.01754438f, 
    0.12901567f, 0.20247523f, 0.07610620f, 0.05505489f, 0.05868429f, -0.08163724f, 0.14065671f, -0.12710020f, 
    0.07829639f, -0.00881794f, 0.03619955f, 0.14837112f, 0.09309073f, 0.09628143f, 0.09748984f, -0.01557940f, 
    -0.05147228f, 0.14800429f, 0.01832226f, 0.44896099f, 0.08538380f, 0.14579602f, 0.02648018f, -0.13970447f, 
    -0.11170216f, 0.10033861f, -0.06120549f, -0.17331713f, -0.04553784f, -0.13885739f, -0.22537468f, -0.13798976f, 
    0.03415618f, 0.07179463f, 0.09821760f, 0.03869240f, -0.11319932f, 0.15028974f, 0.17598654f, 0.23490413f, 
    0.24582489f, 0.02177984f, 0.05530418f, 0.07293809f, -0.13577057f, 0.17924316f, 0.23331805f, 0.20370291f, 
    -0.06171113f, 0.01211897f, 0.02844420f, -0.04153951f, 0.17263043f, -0.03858459f, 0.09436458f, 0.29256421f, 
    -0.19425863f, -0.17333737f, -0.10267198f, 0.04168138f, -0.01566608f, -0.01512723f, -0.03545471f, -0.06821276f, 
    -0.02256350f, 0.05169172f, -0.16240440f, 0.10701106f, 0.06730879f, -0.06323845f, 0.03582457f, -0.02059156f, 
    -0.26294193f, -0.21538474f, -0.08700541f, -0.26015648f, -0.06463888f, -0.09515105f, -0.12959655f, -0.15667422f, 
    0.08627008f, 0.09694342f, 0.14929742f, 0.21391369f, -0.07825801f, -0.11617539f, 0.17900027f, -0.03698725f, 
    -0.08854868f, -0.09232462f, 0.00719345f, 0.00589752f, -0.18221247f, -0.18122084f, -0.13633400f, -0.20377550f, 
    0.15991400f, 0.07477406f, 0.12156887f, -0.16867207f, -0.28057483f, -0.18533127f, 0.08232585f, 0.03616657f, 
    0.12144873f, 0.01735157f, -0.10473504f, -0.03294928f, 0.07778011f, -0.06049611f, 0.06058278f, -0.22937617f, 
    -0.03423167f, -0.00905307f, 0.07384188f, 0.01891794f, 0.02451748f, 0.00665049f, 0.07677256f, 0.02034236f, 
    0.09264811f, 0.06018210f, -0.01467051f, 0.09270576f, -0.06182639f, -0.02403097f, 0.08324242f, 0.03597329f, 
    0.26575443f, 0.00641027f, -0.15764421f, -0.01282449f, -0.07606340f, -0.06509323f, -0.16416596f, -0.11193844f, 
    0.02578690f, -0.03903111f, -0.07137567f, 0.04878435f, 0.02972904f, -0.04793191f, -0.06477839f, 0.05401919f, 
    -0.05905809f, -0.03884808f, -0.04022827f, 0.06885567f, -0.07356588f, 0.08296257f, -0.08105733f, -0.07399268f, 
    0.01269816f, -0.07738461f, 0.02224171f, -0.06606099f, -0.00796817f, -0.00966281f, -0.00795916f, -0.00644868f, 
    -0.07580776f, 0.04763931f, 0.03582669f, 0.07820516f, -0.00963959f, 0.07636469f, -0.03292204f, -0.00502813f, 
    -0.06597444f, -0.03244553f, 0.04545505f, 0.02508087f, 0.00836347f, 0.07522976f, -0.00307703f, -0.05240860f, 
    -0.01609692f, -0.00268328f, -0.05572236f, 0.02066901f, 0.06630185f, -0.08351817f, 0.01068941f, -0.03535247f, 
    0.04624844f, 0.01958796f, 0.02511672f, -0.07627653f, -0.00782831f, -0.02725673f, -0.00746659f, -0.00579405f, 
    -0.01385076f, 0.05118833f, 0.06023557f, -0.06517822f, -0.04313119f, -0.07528639f, 0.06898070f, -0.07222367f, 
    -0.04913115f, 0.02423961f, -0.03084776f, 0.04215712f, -0.02074554f, 0.04646161f, -0.06130537f, -0.04582067f, 
    0.02567540f, -0.05916193f, -0.07031254f, -0.03007084f, -0.06639124f, 0.06374216f, -0.07078694f, 0.03670409f, 
    0.01345575f, 0.07281048f, -0.01785983f, 0.00702042f, -0.01100014f, -0.07620957f, -0.06884653f, 0.00303233f, 
    -0.07471997f, -0.08008594f, 0.04735299f, 0.01984062f, -0.06770532f, 0.05882400f, 0.05739520f, -0.04602048f, 
    0.07010585f, -0.02088231f, -0.05978905f, 0.04707544f, -0.05823353f, 0.01942129f, -0.03838478f, -0.06836849f, 
    -0.02336541f, 0.07715194f, -0.03819649f, -0.04629970f, -0.00716062f, 0.06019203f, -0.07076865f, -0.05211126f, 
    -0.06479254f, 0.03763719f, -0.05369227f, -0.01256802f, -0.07115201f, 0.05323295f, -0.08256102f, -0.07930057f, 
    -0.07673417f, 0.06348057f, -0.05604540f, -0.04056443f, 0.05313942f, -0.06451452f, -0.02863093f, 0.01541649f, 
    0.02461583f, -0.07195806f, -0.07359744f, 0.00980576f, -0.04295323f, -0.07825655f, 0.00984322f, -0.08872809f, 
    -0.03891508f, 0.01930657f, 0.01764152f, -0.03365008f, -0.00357464f, -0.04148544f, 0.01981081f, -0.03858344f, 
    0.34074470f, 0.16926631f, -0.12450077f, 0.10984623f, -0.04705365f, 0.01084343f, 0.16067870f, 0.00609091f, 
    -0.02585885f, 0.16281302f, 0.02813454f, -0.03160415f, -0.12102691f, -0.07655425f, -0.03644198f, 0.08020761f, 
    0.03831347f, -0.01128215f, -0.34410721f, -0.16041578f, -0.11856029f, 0.01880853f, 0.00502663f, 0.11962868f, 
    0.05377971f, 0.11935060f, 0.08027283f, 0.30252811f, -0.13248304f, 0.06900736f, -0.09558199f, 0.06765497f, 
    -0.04268456f, -0.03876877f, -0.09992874f, 0.03264624f, -0.43932483f, -0.02236558f, -0.04816441f, 0.02673350f, 
    0.11918209f, 0.08437477f, 0.02118568f, 0.00645958f, 0.06308910f, -0.41504681f, 0.01579531f, 0.06606300f, 
    0.01648780f, -0.07065129f, -0.01429595f, -0.25505459f, 0.01172925f, 0.03426512f, -0.24513908f, -0.01732525f, 
    0.01330334f, -0.01011765f, 0.04077567f, -0.08175575f, -0.01700494f, 0.02076682f, 0.06450572f, 0.13755649f, 
    -0.20316584f, 0.08600339f, 0.19310299f, 0.06095058f, 0.05517211f, 0.00205476f, 0.03495396f, 0.02190949f, 
    0.08230768f, 0.27410161f, -0.20935936f, -0.18055186f, -0.11102018f, -0.14837269f, -0.03175648f, -0.10380483f, 
    0.02973979f, -0.18342774f, 0.04546282f, 0.12479512f, 0.07748902f, -0.04710426f, 0.13317764f, 0.07535793f, 
    0.18491197f, -0.07695711f, -0.02637502f, -0.17867319f, 0.04187289f, 0.08910107f, 0.00280886f, -0.04787709f, 
    -0.05397142f, 0.15005730f, -0.19603814f, 0.48738948f, 0.12323009f, 0.01271404f, 0.19973981f, -0.00050474f, 
    -0.02027150f, 0.02417176f, -0.06992682f, 0.13786948f, 0.41649598f, -0.00208521f, -0.02133479f, -0.00045282f, 
    0.03644815f, 0.19968179f, 0.04428418f, 0.18016502f, -0.03462720f, -0.04987136f, -0.05300043f, -0.29473507f, 
    0.07288313f, -0.09683998f, -0.07246636f, -0.10919444f, 0.02495623f, -0.03759277f, -0.10571177f, 0.20055458f, 
    -0.15525922f, 0.12313104f, -0.05302963f, 0.17187415f, -0.14814356f, 0.07029948f, 0.01349897f, -0.06674677f, 
    0.02528783f, -0.39848593f, -0.02950070f, -0.04402849f, -0.17956820f, 0.06191745f, -0.04311963f, -0.10110956f, 
    0.08541972f, 0.11537365f, 0.13264388f, -0.00801888f, -0.11521907f, 0.02186381f, -0.01727291f, 0.12963134f, 
    0.12847677f, -0.52458334f, -0.25153890f, -0.23962039f, 0.18416229f, 0.15136045f, 0.12514916f, 0.13018595f, 
    -0.08176687f, 0.00737155f, -0.11906831f, -0.14921188f, -0.26481825f, 0.08429133f, 0.07607394f, 0.11350669f, 
    -0.23656385f, -0.11352893f, -0.15366036f, -0.11867215f, 0.08966082f, 0.11842062f, 0.15328917f, 0.12260954f, 
    -0.03067406f, 0.06403879f, 0.08030018f, 0.10085922f, 0.09186885f, -0.02757515f, 0.02513651f, 0.01326254f, 
    0.03431398f, 0.06244617f, -0.02358290f, -0.05570348f, 0.10562395f, 0.27920961f, -0.01763540f, -0.03343204f, 
    0.06215400f, -0.03565294f, 0.05141344f, 0.22084878f, -0.12307388f, -0.03714360f, -0.21426673f, 0.06063359f, 
    -0.06398133f, 0.20966674f, 0.07570098f, -0.00821695f, 0.02811501f, -0.15422679f, -0.04066334f, -0.44029516f, 
    -0.09469438f, 0.02944158f, -0.04352951f, -0.05533665f, 0.02548310f, 0.16831696f, -0.00752294f, -0.09381448f, 
    0.10357285f, -0.01861264f, 0.02055571f, 0.12197525f, -0.02935142f, 0.07434455f, 0.01440801f, 0.08666289f, 
    0.05633651f, -0.17709468f, 0.08883348f, -0.07819889f, -0.15780155f, -0.10674478f, 0.01586884f, 0.04697189f, 
    -0.22085692f, 0.16910174f, -0.28414470f, 0.01644407f, -0.18084817f, -0.11041528f, 0.16569583f, 0.00470963f, 
    0.08522227f, 0.03899043f, -0.05972878f, -0.03611242f, 0.20739113f, 0.28624040f, 0.04877175f, 0.01032759f, 
    -0.00691733f, -0.04616156f, -0.03342018f, -0.02964323f, 0.12150222f, 0.20442009f, 0.35265046f, -0.13854566f, 
    0.02185291f, 0.13874003f, 0.04084475f, 0.04981774f, 0.11947013f, -0.06018252f, -0.50603831f, 0.03444223f, 
    0.05286563f, 0.04225511f, -0.05950313f, -0.01056091f, -0.20630771f, 0.03668163f, -0.08140774f, -0.03855897f, 
    -0.07511052f, -0.00702980f, 0.00687575f, 0.10310894f, 0.03536617f, 0.00843562f, 0.17122334f, -0.18485650f, 
    -0.02518566f, -0.32595947f, 0.01311092f, -0.07717392f, -0.25971353f, 0.05858705f, 0.01458572f, -0.01247246f, 
    0.27718964f, 0.27149799f, 0.11786249f, -0.00031968f, 0.13502176f, -0.12021570f, 0.00851045f, 0.02433412f, 
    0.01721535f, -0.19050926f, -0.16029124f, 0.30951759f, -0.00784661f, 0.27615845f, 0.01399778f, 0.09537117f, 
    0.05663817f, -0.08830666f, 0.09431547f, 0.02056329f, 0.12246173f, 0.00597739f, -0.11138891f, 0.01139533f, 
    0.16144098f, -0.17591758f, 0.05277143f, 0.04384217f, 0.00784960f, -0.18387774f, -0.07291532f, 0.15367703f, 
    -0.10294254f, -0.01836816f, -0.26784751f, 0.12293204f, 0.10068742f, 0.10170569f, -0.08084302f, 0.08234948f, 
    0.12036327f, 0.16294959f, 0.09888703f, 0.08667516f, 0.10591643f, 0.10080138f, -0.05294457f, -0.27365959f, 
    -0.27531445f, -0.10968576f, 0.01739624f, -0.12002909f, 0.14107704f, 0.05422357f, 0.07187206f, -0.02361432f, 
    0.36200017f, -0.24272992f, -0.00630441f, -0.08710749f, -0.07483615f, -0.00745682f, 0.13028723f, -0.05571960f, 
    -0.00466411f, -0.23854148f, 0.26888275f, 0.16006573f, 0.00208272f, -0.08972130f, 0.05855851f, -0.04689740f, 
    -0.10301614f, 0.15368988f, -0.09423585f, -0.20147644f, -0.14460149f, 0.06706638f, 0.03427561f, 0.08177368f, 
    0.19898352f, 0.29384515f, 0.05908250f, -0.40017411f, 0.14171275f, -0.20666146f, -0.00057667f, -0.01593073f, 
    0.01069285f, -0.05777701f, 0.15899332f, -0.12025383f, 0.29548785f, 0.19214208f, -0.11977881f, 0.09450938f, 
    -0.01083686f, 0.20421796f, -0.06706285f, 0.08125645f, -0.11856859f, -0.27379569f, 0.24856858f, 0.10360349f, 
    -0.02135632f, 0.10211292f, -0.15800937f, 0.05302514f, 0.22661744f, 0.14741802f, -0.20201874f, 0.05400392f, 
    0.21033831f, 0.01893439f, -0.01019837f, 0.07633989f, -0.01476239f, -0.18164133f, 0.02019662f, 0.25821415f, 
    0.02874350f, -0.12623295f, 0.15936236f, -0.17796047f, 0.08470213f, -0.02760401f, 0.16532660f, -0.11642370f, 
    -0.30796093f, 0.14758088f, 0.08255924f, -0.13507983f, 0.10779951f, 0.01808777f, 0.08169252f, 0.40511283f, 
    -0.25356504f, -0.10036828f, -0.16132082f, -0.07982050f, -0.08943079f, 0.19988266f, -0.05325265f, -0.26072821f, 
    -0.01133601f, 0.02885841f, 0.15775795f, -0.24087064f, 0.20143798f, -0.14851974f, 0.01348307f, 0.10905702f, 
    -0.15699700f, 0.07367503f, 0.01270640f, 0.17490943f, -0.00838384f, 0.05610647f, -0.03665982f, 0.02349102f, 
    -0.07276249f, 0.08613976f, 0.10527413f, -0.04573403f, -0.27637094f, 0.10169181f, 0.11773705f, 0.03734341f, 
    -0.01191560f, -0.08261884f, -0.18513103f, 0.20030211f, -0.06721667f, 0.03425800f, -0.13343804f, -0.03894757f, 
    0.14043450f, -0.00037379f, 0.02732205f, -0.14846464f, -0.02283152f, 0.01803770f, -0.13123021f, 0.06167588f, 
    -0.09500217f, 0.05581693f, 0.08244408f, 0.19013721f, 0.11599759f, 0.10372752f, 0.09382220f, -0.03054564f, 
    0.08063085f, -0.10569894f, 0.13411419f, 0.00838678f, -0.04964294f, 0.18933602f, 0.11465282f, -0.00637149f, 
    -0.08678831f, 0.18235411f, 0.11752677f, 0.18350814f, -0.02269843f, -0.08208561f, 0.18334331f, 0.17352310f, 
    0.05049669f, -0.01281100f, -0.24104445f, 0.27851978f, 0.08129455f, -0.13349281f, -0.00556211f, -0.10583490f, 
    -0.04194012f, 0.12527910f, 0.18942083f, -0.09652968f, -0.06750561f, -0.12092432f, -0.19805892f, 0.16780946f, 
    0.18809739f, -0.30832940f, 0.04873120f, -0.20321628f, -0.02464909f, -0.01291910f, -0.13489972f, 0.11053742f, 
    -0.10371762f, -0.35835475f, -0.11033352f, 0.11152139f, -0.16776654f, 0.03385919f, 0.15435471f, -0.02961462f, 
    -0.13225043f, 0.02555075f, -0.07017522f, 0.03727520f, 0.00082609f, 0.10123848f, -0.03754848f, 0.05906362f, 
    0.07107093f, -0.13417341f, -0.09198778f, -0.02828444f, -0.10574582f, 0.21660550f, 0.01745439f, 0.09210532f, 
    -0.07814369f, -0.07256375f, 0.10317729f, 0.18087350f, -0.11371169f, -0.13152333f, 0.10538741f, 0.19054610f, 
    -0.10002492f, -0.16184644f, 0.08363919f, -0.02002399f, 0.20370854f, 0.14003280f, 0.21932170f, -0.07220607f, 
    0.11041640f, -0.04341111f, -0.14538570f, 0.01492292f, 0.27054814f, -0.07127338f, 0.21670130f, 0.04882159f, 
    0.11341275f, 0.11582340f, 0.01079709f, 0.00002939f, -0.17175108f, 0.06129985f, 0.02029153f, 0.19148973f, 
    0.31207249f, -0.39784569f, -0.22244236f, 0.05362963f, -0.00220487f, 0.10771225f, 0.00041654f, -0.20047359f, 
    -0.08705533f, -0.12640823f, 0.43328816f, 0.03837190f, 0.01990006f, -0.23447715f, -0.05173030f, 0.12431723f, 
    0.07363737f, -0.00880838f, -0.12521027f, 0.14692572f, 0.18687335f, -0.00813831f, 0.22402467f, -0.14099734f, 
    0.01546534f, 0.00080540f, 0.00281359f, -0.12140293f, -0.49752176f, -0.14147228f, -0.05595328f, 0.14824183f, 
    0.10481341f, -0.02061788f, -0.01684377f, 0.04777532f, 0.12061295f, 0.02066168f, 0.04498013f, 0.02969638f, 
    -0.14137557f, 0.00227435f, -0.02584750f, 0.15720043f, 0.08202218f, -0.13971688f, 0.04810514f, -0.02609147f, 
    -0.00489827f, -0.00882556f, 0.09570754f, 0.02611019f, 0.19548827f, -0.16424553f, 0.23087029f, 0.25240722f, 
    0.17586951f, -0.07721213f, -0.00879543f, 0.02909500f, -0.03890316f, 0.01343209f, 0.06107018f, 0.10872068f, 
    -0.07079201f, -0.03147624f, 0.03502549f, -0.05709682f, 0.00839529f, -0.08442545f, 0.07942576f, 0.09090178f, 
    -0.06023778f, -0.26912677f, 0.03695648f, -0.03773344f, 0.15190102f, 0.15848683f, 0.02625069f, 0.09509449f, 
    0.07328745f, -0.09580184f, -0.09411550f, 0.12704758f, -0.07174809f, 0.10625009f, 0.05620336f, 0.02489123f, 
    0.15051736f, -0.15432036f, 0.16049477f, -0.12749690f, 0.06369211f, -0.17160825f, -0.18545175f, 0.06250294f, 
    -0.01834183f, 0.16522442f, 0.14199363f, -0.23676322f, -0.04894330f, 0.03649936f, 0.16521890f, -0.08559593f, 
    0.04130447f, 0.05051792f, -0.10196946f, -0.23907030f, -0.04757065f, -0.18328397f, 0.20548974f, 0.05695802f, 
    0.08031765f, -0.09490902f, -0.12348744f, -0.12825850f, 0.06921103f, 0.18912940f, 0.06521042f, 0.07646643f, 
    -0.11603615f, -0.03969778f, -0.05644906f, -0.05426788f, 0.11476363f, -0.01585094f, -0.39227811f, 0.04521051f, 
    0.03566065f, -0.10226675f, -0.17154519f, -0.06395745f, -0.10800079f, -0.03154834f, 0.15853305f, 0.40044564f, 
    0.11139823f, -0.03456419f, 0.00835378f, -0.09734325f, -0.01420000f, 0.07253429f, 0.05284683f, -0.09101877f, 
    -0.11134819f, 0.04294074f, 0.01140778f, 0.04496712f, -0.07075605f, -0.06024254f, 0.06560139f, -0.04350328f, 
    -0.02072439f, 0.05395085f, -0.11107561f, 0.02714271f, -0.08264419f, 0.03275311f, -0.06903440f, 0.00863778f, 
    0.03832301f, -0.03820466f, 0.03380444f, 0.04338257f, -0.00417152f, -0.04772772f, -0.02684789f, 0.06810787f, 
    -0.05110616f, -0.01040224f, -0.03839535f, -0.06193735f, -0.08015893f, -0.04042141f, -0.03063713f, -0.07023446f, 
    -0.05282154f, -0.01433718f, -0.03052949f, -0.10201013f, -0.08258679f, -0.00402532f, 0.00397982f, -0.11476387f, 
    0.04118389f, 0.04571940f, -0.08120548f, -0.12862867f, -0.03748488f, -0.05616860f, -0.08662803f, -0.03986034f, 
    -0.12916595f, -0.10407586f, -0.05821563f, -0.03309343f, 0.04288589f, -0.07467485f, -0.03216580f, -0.05933506f, 
    0.02120560f, -0.09892612f, -0.02057243f, -0.05008563f, -0.11242472f, -0.08817323f, -0.10706336f, 0.02593257f, 
    0.05831574f, -0.08651779f, -0.00698881f, -0.03792550f, -0.03376151f, -0.00818368f, -0.06876188f, -0.05084400f, 
    -0.08202908f, -0.05495299f, -0.11420476f, 0.04442372f, -0.10656915f, -0.02344477f, -0.09555952f, 0.01145890f, 
    -0.04201918f, -0.05728833f, 0.02137421f, -0.07061664f, -0.07084853f, -0.09486102f, -0.09678627f, -0.11248990f, 
    0.08318420f, 0.04020503f, -0.09991662f, -0.09074716f, -0.11487072f, -0.08385476f, -0.10254680f, -0.04059812f, 
    -0.09246203f, 0.06226118f, -0.00955277f, 0.03505936f, -0.03356533f, -0.00881334f, 0.04791227f, -0.11577302f, 
    0.01179315f, -0.07323077f, -0.05500153f, -0.03892095f, -0.02995541f, -0.03045498f, -0.02092126f, 0.04675644f, 
    -0.07141681f, -0.07124958f, -0.03151359f, -0.05525207f, 0.00536962f, -0.01776583f, 0.02920448f, 0.00026941f, 
    -0.11121712f, -0.02827141f, 0.01025645f, -0.00817410f, -0.12118739f, -0.00067566f, -0.00823305f, -0.06527101f, 
    -0.02972970f, -0.01656747f, -0.03930187f, -0.09529661f, -0.04135197f, 0.02790103f, -0.03798385f, -0.10323539f, 
    0.01496333f, 0.01007337f, 0.02333807f, -0.08923393f, -0.02223838f, -0.09187020f, 0.03211894f, 0.03417191f, 
    -0.13030669f, 0.06539924f, -0.26130405f, 0.11378673f, 0.04566614f, 0.11259557f, 0.10752738f, 0.13662183f, 
    -0.02757311f, -0.31989083f, -0.01393066f, 0.20549539f, -0.23175940f, -0.02491238f, 0.14862119f, -0.04345527f, 
    0.13617817f, 0.09326591f, 0.31409246f, -0.06978011f, 0.13738368f, -0.13308187f, -0.12370895f, -0.15209426f, 
    -0.02140362f, -0.04536851f, -0.05559838f, -0.22677104f, -0.10191748f, -0.25012210f, -0.10267770f, -0.09762448f, 
    0.09626845f, 0.06243586f, -0.05411758f, -0.04017473f, 0.11197235f, 0.22883590f, 0.11492000f, -0.12370603f, 
    -0.06162190f, -0.02036979f, -0.04909903f, 0.05993022f, -0.04584678f, -0.08485094f, -0.26199037f, 0.05298876f, 
    0.15895835f, 0.13732617f, -0.09344293f, 0.07516550f, -0.00127978f, 0.04423537f, -0.12562774f, -0.24541435f, 
    0.06363828f, -0.19812080f, 0.00221475f, 0.09162546f, -0.16429944f, 0.17726538f, -0.04722605f, -0.13915361f, 
    -0.02178913f, 0.00884122f, -0.00528906f, 0.10563815f, 0.09888277f, 0.07545985f, -0.02266883f, 0.09268077f, 
    -0.27870849f, 0.20446977f, -0.20002791f, 0.05982510f, -0.04677656f, -0.07218620f, -0.00292324f, -0.11890043f, 
    -0.17694692f, 0.23951700f, -0.28994501f, -0.19624594f, -0.05764475f, 0.01440888f, -0.08816664f, 0.09856281f, 
    -0.00865533f, 0.13432305f, -0.14465605f, 0.02161805f, -0.20939901f, -0.02944838f, -0.03023895f, -0.17782636f, 
    -0.00004657f, -0.06103987f, 0.10816169f, 0.18182224f, -0.00967087f, 0.05555204f, 0.19442096f, 0.13312307f, 
    -0.03496234f, 0.01962628f, 0.09410390f, 0.02987254f, -0.15202343f, 0.16105075f, 0.07133089f, 0.08833574f, 
    0.23204376f, 0.05100166f, 0.10526315f, -0.02355534f, 0.07265814f, -0.13488455f, 0.03021227f, -0.09980556f, 
    0.04807994f, -0.09576005f, 0.04366423f, -0.08321239f, 0.01132199f, 0.01577652f, -0.05948937f, -0.19963133f, 
    0.03702369f, 0.18410198f, 0.03637943f, 0.12969315f, 0.00896493f, 0.02140394f, 0.07198808f, -0.60897696f, 
    0.34737512f, 0.03674024f, 0.08263069f, 0.02103465f, 0.05216176f, -0.07713790f, -0.01513087f, -0.04031613f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.10230795f, -0.04317442f, 0.03470763f, -0.20994864f, 0.08665325f, 0.05266081f, -0.00412337f, -0.13117777f, 
    0.07097302f, 0.01206038f, 0.11734477f, 0.18309940f, 0.18559608f, 0.00139252f, -0.06813502f, 0.10017946f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06918734f, 0.27992406f, -0.04503021f, 0.06506126f, 0.36448148f, -0.15226482f, 0.12431293f, -0.13806883f, 
    -0.14700913f, 0.43076855f, -0.38877597f, -0.02886797f, -0.17072640f, 0.28231263f, -0.07804102f, 0.14632128f, 
    -0.05163871f, -0.31884569f, -0.09006372f, 0.21776673f, 0.11858483f, 0.15850371f, 0.15635651f, 0.17051451f, 
    0.04580652f, 0.01291730f, -0.30661091f, 0.36480230f, 0.27173370f, 0.01994185f, 0.23516579f, -0.18661535f, 
    -0.05470053f, 0.31202447f, -0.21668553f, 0.50857055f, -0.14858724f, -0.15262447f, 0.07654417f, 0.47501096f, 
    0.10294520f, -0.02178660f, 0.25515017f, -0.31385541f, 0.18329738f, 0.22103626f, 0.00669429f, 0.11089505f, 
    0.17762850f, 0.08526899f, -0.04790444f, -0.11954151f, -0.04234156f, 0.04317225f, 0.27669087f, 0.02144316f, 
    0.20699564f, 0.36456251f, -0.29469103f, -0.03263957f, 0.29839721f, -0.27269977f, -0.06967638f, -0.35155544f, 
    -0.17364596f, 0.28403515f, 0.23351409f, -0.02671863f, 0.00611264f, -0.18089968f, -0.60060298f, 0.14020598f, 
    -0.03452366f, 0.28026235f, 0.30158427f, -0.00789979f, -0.20928669f, 0.50948781f, -0.19454695f, 0.22105640f, 
    -0.20194370f, -0.25235862f, -0.14404425f, 0.15326339f, -0.07787183f, 0.21959636f, 0.04091033f, -0.18232319f, 
    0.10657623f, 0.23199582f, 0.00295596f, -0.25955299f, 0.21995933f, 0.03941498f, -0.11046952f, -0.01423205f, 
    -0.16885734f, -0.21316230f, -0.14456110f, 0.07844801f, -0.15512085f, 0.02635941f, 0.07351676f, -0.13107160f, 
    0.07861284f, -0.22250471f, -0.01235558f, -0.10125346f, -0.17033902f, 0.21042417f, 0.11993184f, 0.23625255f, 
    -0.33351767f, 0.04186458f, -0.16407490f, 0.15509683f, 0.24631235f, 0.05578046f, 0.57536989f, -0.06701607f, 
    0.17786881f, -0.24959011f, -0.16604607f, 0.00311213f, 0.34985787f, 0.25621647f, -0.04165040f, -0.12938018f, 
    -0.41581678f, 0.20968430f, -0.19815153f, 0.39690253f, -0.28627801f, 0.22945751f, 0.25812039f, 0.21735659f, 
    -0.11863298f, -0.07836235f, -0.15916742f, 0.20537405f, 0.23393282f, 0.23945053f, 0.16983879f, -0.24565271f, 
    -0.13291134f, 0.04643971f, 0.02821502f, 0.39042065f, -0.16090022f, -0.14657103f, 0.15289681f, -0.02601498f, 
    -0.05848426f, -0.19502525f, 0.29907802f, 0.35555515f, -0.01601415f, -0.19614956f, 0.24139941f, -0.43095958f, 
    0.17654832f, -0.24384052f, 0.09734067f, 0.03992715f, -0.15514241f, 0.28543156f, -0.23075494f, -0.29543877f, 
    0.16307390f, -0.73431778f, -0.19402413f, 0.35354084f, 0.36049521f, 0.09888434f, -0.22002736f, -0.45239156f, 
    -0.05945857f, 0.11875180f, -0.22706661f, -0.42959255f, 0.17191680f, 0.04407317f, -0.49998546f, -0.03038002f, 
    -0.06758260f, -0.01400564f, 0.33964226f, 0.30034187f, -0.06868799f, 0.02242963f, 0.10670225f, -0.13591088f, 
    -0.14636599f, 0.45232344f, 0.23270302f, -0.13203041f, -0.10469759f, 0.00610438f, -0.17217298f, -0.04507331f, 
    -0.23578109f, 0.04412097f, 0.36560285f, -0.26534382f, 0.23033847f, 0.38637587f, 0.24727692f, -0.60893261f, 
    -0.30929270f, 0.29196104f, 0.11708845f, -0.56616807f, -0.02316806f, -0.16470523f, 0.00341490f, 0.02143591f, 
    0.17275113f, 0.24326517f, -0.08795939f, 0.23668112f, -0.29720899f, 0.57468069f, -0.02581860f, 0.07736852f, 
    0.46591771f, 0.34416959f, 0.18335265f, 0.03340689f, -0.04875427f, 0.03872395f, -0.25820422f, -0.10593827f, 
    0.03457075f, 0.26059324f, 0.26942536f, -0.29996985f, 0.11037359f, -0.03201509f, 0.07693231f, -0.03567328f, 
    0.12410742f, 0.08111931f, 0.04481356f, 0.01774667f, -0.23487575f, -0.24397118f, 0.35346568f, 0.51435035f, 
    -0.01400871f, -0.03680525f, -0.34312966f, -0.20950605f, 0.37373745f, 0.25009015f, -0.18742803f, -0.05081600f, 
    0.03332986f, -0.32997593f, 0.08260865f, -0.04206947f, -0.14224137f, 0.13843602f, 0.30675215f, -0.25705925f, 
    -0.06953090f, 0.55280256f, 0.04452424f, -0.02301784f, 0.17911381f, 0.31639716f, 0.09501194f, -0.27017409f, 
    0.08036943f, -0.26816812f, -0.22826423f, -0.23126136f, 0.37721017f, 0.14327203f, 0.03971349f, -0.21244624f, 
    -0.22015731f, -0.07494269f, 0.13632996f, -0.08281957f, -0.22489980f, 0.18565023f, -0.06052239f, 0.70321733f, 
    0.19388291f, 0.02848549f, -0.19584090f, -0.36197662f, 0.17385262f, 0.16827551f, 0.20404537f, -0.07566368f, 
    0.18115100f, 0.16752720f, -0.40023172f, 0.10278727f, -0.02490896f, 0.23506834f, 0.15892906f, 0.45135111f, 
    -0.17250288f, -0.03416884f, 0.11935058f, -0.19199014f, -0.28281391f, -0.19308119f, 0.46447539f, 0.26618975f, 
    -0.14047319f, -0.16992784f, 0.07505376f, 0.06413534f, 0.27354640f, -0.00467067f, -0.13965969f, -0.15441571f, 
    -0.31247991f, -0.04009705f, 0.09601796f, -0.71186125f, 0.53387594f, -0.22299016f, 0.15230305f, 0.00051369f, 
    -0.03979827f, 0.13499539f, -0.39788419f, 0.29116631f, 0.24951047f, -0.03843166f, -0.22836015f, 0.16313639f, 
    0.45443138f, -0.01246800f, -0.04706205f, 0.04180683f, -0.49917808f, -0.00669337f, -0.49283955f, -0.17543145f, 
    -0.23012680f, -0.20621708f, -0.04269031f, 0.11905569f, 0.34669769f, -0.32249334f, -0.23106109f, 0.38045597f, 
    -0.34041482f, -0.09721861f, -0.07486597f, 0.26993725f, -0.00996986f, 0.02843346f, -0.17521417f, -0.27888289f, 
    0.01073136f, 0.32733229f, 0.46231878f, -0.01206625f, 0.25603274f, -0.10779598f, 0.11662471f, -0.37097749f, 
    0.17551896f, 0.00305101f, -0.20831558f, -0.21201140f, -0.15519506f, 0.12225282f, 0.03818476f, -0.22258347f, 
    -0.19018167f, -0.02517197f, -0.14756507f, -0.01068336f, -0.19719708f, -0.11435187f, 0.19023454f, -0.17297429f, 
    -0.33376202f, 0.09790016f, -0.16297081f, 0.10110812f, 0.23441273f, -0.23241293f, 0.06834539f, 0.19270287f, 
    0.04118823f, 0.28628165f, -0.05006267f, 0.22885768f, 0.00045381f, 0.37315008f, 0.15385380f, -0.23040660f, 
    0.08483266f, 0.34632969f, -0.09948508f, -0.29568648f, 0.40290177f, 0.04858899f, 0.24745576f, -0.13406220f, 
    -0.00253285f, 0.03993976f, 0.33943146f, -0.11343410f, -0.19750254f, 0.03765178f, -0.06903989f, 0.21437921f, 
    -0.02839427f, 0.22975563f, -0.03753101f, 0.15536810f, 0.17596728f, 0.13942367f, 0.07952709f, -0.28468651f, 
    -0.16477393f, 0.31574333f, 0.01751459f, -0.01461868f, -0.35755175f, 0.45934001f, 0.12679416f, 0.30674669f, 
    0.28205022f, 0.12934491f, 0.06212530f, -0.34427473f, 0.28207204f, 0.17924851f, -0.31411988f, -0.07219951f, 
    0.23741116f, -0.21541251f, 0.13182782f, -0.00558339f, 0.07437687f, -0.00307471f, -0.11779752f, 0.24306083f, 
    0.09481188f, 0.34032676f, -0.00397388f, 0.01444482f, 0.17105512f, 0.05577462f, -0.22131276f, -0.36882612f, 
    -0.07224704f, 0.14326258f, 0.19053669f, 0.27208915f, -0.08663765f, -0.29737422f, -0.11308748f, -0.16042347f, 
    0.24628094f, -0.05947849f, 0.18769635f, -0.43763602f, 0.42037672f, -0.08327240f, 0.11521151f, -0.35978535f, 
    0.12736340f, -0.36179662f, 0.24490204f, 0.34895384f, 0.08783786f, 0.05644488f, -0.14114690f, -0.07479767f, 
    -0.22581241f, -0.22583413f, -0.14360002f, -0.04398823f, -0.22752208f, -0.17607209f, 0.07871726f, -0.11255449f, 
    -0.10445330f, -0.14936215f, -0.11775500f, -0.01957726f, -0.09461096f, -0.01238924f, -0.12881145f, -0.06315526f, 
    0.06461283f, -0.09337686f, -0.13190183f, -0.12437245f, 0.20751250f, -0.09025532f, 0.19990714f, 0.36208495f, 
    -0.16561037f, -0.23877852f, -0.11378460f, -0.11807234f, 0.17594910f, -0.16622812f, -0.09866489f, -0.09832246f, 
    0.26089948f, 0.06801710f, -0.06868324f, 0.12370695f, -0.12550634f, 0.03828810f, 0.30861482f, 0.44160375f, 
    -0.00178749f, -0.08147320f, -0.10505369f, -0.14316742f, 0.15754405f, 0.05646747f, 0.14632994f, -0.11460882f, 
    0.16665393f, 0.25449842f, -0.13501763f, -0.33205324f, 0.47414577f, -0.00894672f, -0.53585315f, 0.00921087f, 
    0.13848409f, -0.31259975f, -0.04804884f, -0.20901936f, 0.20243369f, 0.31333184f, 0.18619753f, -0.45633981f, 
    -0.52226132f, 0.00391754f, 0.11688489f, -0.29015610f, -0.16952543f, 0.23272929f, -0.21491265f, 0.16288979f, 
    0.21961513f, 0.21187666f, 0.00806836f, 0.11530238f, 0.52913058f, -0.10194641f, -0.06276101f, -0.04494295f, 
    -0.34358391f, 0.03909281f, -0.05084360f, -0.26747105f, 0.44824553f, -0.03025174f, -0.20832700f, 0.07351406f, 
    0.16842923f, -0.32622600f, -0.57483077f, 0.00309113f, 0.31458503f, 0.14339904f, -0.04778412f, -0.55499780f, 
    -0.04625108f, -0.13166666f, 0.21174385f, -0.29684049f, -0.52454317f, -0.04864271f, -0.50909984f, -0.06079438f, 
    0.12545973f, 0.00920914f, 0.05234291f, 0.31372848f, 0.27774975f, 0.27492285f, 0.14481223f, 0.61610508f, 
    0.29347900f, -0.41878203f, 0.00908792f, -0.21189591f, -0.08791579f, -0.18380757f, 0.21648414f, 0.18751477f, 
    -0.01794164f, 0.13900447f, 0.27777031f, -0.10738093f, 0.13759793f, -0.30224288f, 0.17885570f, 0.03723772f, 
    -0.23336647f, 0.12289540f, -0.02319695f, -0.15505126f, 0.22161850f, -0.13383189f, 0.38502738f, -0.26012197f, 
    0.09364198f, -0.60344315f, 0.03799912f, 0.05265410f, 0.01362926f, 0.41477114f, -0.18497190f, 0.41960859f, 
    0.15074837f, -0.20172864f, -0.20789352f, -0.10453403f, 0.04756692f, 0.06227368f, 0.11988336f, -0.06851560f, 
    0.02725741f, 0.04231554f, -0.18697956f, -0.12125698f, -0.23782030f, -0.03390181f, -0.24803650f, -0.02068511f, 
    0.36543080f, 0.38575104f, 0.10777180f, -0.03466791f, -0.19588690f, -0.13730985f, 0.17434740f, 0.27297130f, 
    0.22472054f, -0.03715033f, -0.19556920f, -0.19099706f, -0.02283264f, 0.25629130f, -0.04146046f, 0.40402669f, 
    0.41062686f, -0.09128548f, -0.12616247f, -0.00396857f, -0.07450893f, -0.02831524f, 0.13370903f, 0.23496394f, 
    -0.22145265f, 0.18127754f, -0.18619388f, 0.14013672f, -0.26655060f, 0.42466268f, -0.04395225f, -0.04940475f, 
    -0.42708522f, 0.27228069f, 0.03604080f, -0.22424816f, -0.11353108f, 0.14341806f, 0.35189870f, 0.09157547f, 
    -0.01476382f, 0.08788875f, 0.52166766f, -0.02205361f, -0.06597959f, 0.10605490f, 0.03052320f, -0.41845527f, 
    0.06707746f, 0.05776319f, -0.04040098f, -0.05700199f, -0.12961926f, 0.15798749f, -0.14873724f, -0.22338136f, 
    0.14691404f, 0.04540373f, 0.02113785f, -0.15178522f, -0.26786616f, 0.10125858f, -0.07015261f, -0.20322946f, 
    0.45203590f, -0.19548410f, 0.20414397f, 0.04819511f, 0.07302801f, -0.13039413f, 0.35913002f, 0.23854749f, 
    -0.11952940f, 0.07385662f, 0.00514392f, 0.07059495f, -0.35083362f, 0.19393785f, 0.00465722f, -0.44094139f, 
    -0.17956322f, 0.17586809f, 0.02750758f, 0.35724810f, 0.36529517f, 0.07897428f, -0.43230820f, -0.03029018f, 
    -0.06545161f, -0.14006002f, -0.10881616f, 0.19384789f, 0.33330879f, -0.47701010f, -0.25738063f, -0.16790688f, 
    0.01624929f, -0.06518696f, -0.24687459f, -0.09676519f, -0.19653127f, -0.01468171f, -0.07240431f, -0.00769971f, 
    -0.13545072f, -0.02220718f, 0.00797432f, -0.07360920f, -0.05855398f, -0.21180761f, -0.10804331f, 0.04083461f, 
    0.02096341f, -0.13989198f, 0.03247803f, -0.05672114f, -0.19718799f, -0.13969380f, 0.06982277f, 0.39677778f, 
    0.16468798f, 0.27760357f, 0.14539780f, -0.18818252f, 0.28371835f, 0.33554202f, -0.10114297f, -0.39441231f, 
    0.04986660f, -0.26348850f, 0.02526976f, -0.11813260f, 0.40090421f, -0.14936851f, 0.04122825f, -0.07854071f, 
    -0.09817143f, -0.03527322f, 0.38091090f, 0.15833621f, 0.26491281f, -0.38603860f, -0.08056126f, -0.40840647f, 
    0.18558970f, 0.45847991f, -0.15255849f, 0.09492910f, -0.03007800f, -0.19430462f, -0.09307352f, 0.09464457f, 
    -0.11382359f, 0.04815590f, -0.22332384f, 0.02269355f, -0.25085959f, 0.27564287f, 0.17738158f, 0.47677857f, 
    0.05855008f, -0.14104097f, 0.18849018f, 0.39561537f, 0.17835635f, 0.18249252f, -0.22818506f, 0.00163901f, 
    0.16636112f, -0.61663288f, 0.25759098f, -0.27786645f, 0.41721699f, 0.22269823f, -0.03953688f, -0.49959108f, 
    -0.20082161f, 0.05485469f, -0.22514164f, -0.19546181f, -0.18348813f, -0.04651293f, -0.17071196f, -0.24433309f, 
    -0.04053158f, -0.07435885f, 0.02562487f, -0.12763551f, -0.23568875f, 0.11703977f, -0.03067955f, 0.20667255f, 
    0.44825765f, -0.19402164f, -0.03375339f, -0.30371007f, -0.31541497f, -0.21526778f, -0.02364194f, -0.30214152f, 
    0.04305902f, -0.14943124f, 0.32018140f, 0.35494816f, 0.23772100f, -0.16367540f, -0.12125222f, -0.12021064f, 
    0.24782579f, 0.14726855f, 0.05019626f, 0.72936583f, 0.09390834f, 0.23609221f, -0.54229969f, -0.43029299f, 
    0.18108541f, 0.23998125f, -0.28717861f, 0.04771276f, -0.02273170f, -0.13244371f, -0.06873476f, 0.51563293f, 
    0.31288180f, -0.00883494f, 0.04134210f, -0.20667961f, -0.46968424f, 0.07140845f, 0.36968929f, -0.26878861f, 
    -0.20995140f, 0.22985117f, 0.42959458f, 0.10715801f, 0.00320310f, -0.47221184f, -0.25673476f, 0.08642088f, 
    0.04707742f, -0.20460279f, 0.15780298f, -0.23854147f, 0.06168885f, 0.01750159f, 0.22828458f, -0.29023647f, 
    -0.08888146f, 0.72006613f, -0.15276508f, -0.05439954f, 0.16436666f, 0.14652696f, -0.11935998f, -0.06742363f, 
    0.05286149f, 0.21168080f, 0.06964355f, 0.37552044f, -0.28350773f, -0.07554537f, 0.02923507f, 0.28884891f, 
    -0.02011240f, 0.17233376f, -0.26909819f, 0.21792558f, -0.06516987f, 0.00294085f, -0.18820108f, -0.02698763f, 
    -0.05587319f, -0.07230849f, -0.12693253f, -0.16659600f, -0.39988786f, 0.18896247f, -0.00179313f, -0.35253695f, 
    -0.16090542f, 0.38809702f, 0.02445466f, 0.43046227f, 0.11271068f, -0.07873002f, -0.04009420f, -0.18642208f, 
    -0.01462944f, 0.35034442f, 0.14960270f, 0.15464239f, 0.33552477f, 0.26177487f, -0.10663792f, -0.41063723f, 
    -0.00692049f, 0.13178170f, -0.24115855f, 0.31349468f, 0.02127341f, -0.46294919f, -0.21209638f, 0.19083309f, 
    0.31355172f, 0.38225114f, 0.05844146f, 0.31026196f, 0.10032617f, -0.05397069f, -0.34922716f, 0.42561236f, 
    0.05489102f, -0.53859550f, -0.23878200f, -0.13706914f, 0.03518277f, 0.16680816f, 0.08602544f, -0.50186396f, 
    0.07507488f, 0.29012299f, 0.03422128f, 0.11026853f, 0.32202846f, 0.12672226f, -0.02653810f, 0.10902471f, 
    -0.13664292f, -0.25968540f, 0.22625612f, -0.02316071f, 0.04739997f, -0.67751938f, -0.16504604f, -0.27754143f, 
    0.05327778f, -0.15567824f, 0.05381517f, -0.03811407f, -0.09865095f, 0.23801613f, -0.25017723f, -0.00509327f, 
    -0.15549958f, -0.06058327f, -0.12317517f, -0.27788073f, 0.07686399f, 0.15307623f, 0.06367603f, -0.17609090f, 
    -0.05521512f, -0.27794179f, 0.15790814f, 0.23660575f, -0.18481803f, 0.20144863f, 0.05380510f, 0.43108839f, 
    -0.24115792f, 0.16516970f, 0.18624704f, -0.00201646f, 0.27743199f, -0.04026692f, -0.05114362f, -0.28412074f, 
    -0.07691320f, 0.38004705f, -0.08707025f, -0.16234975f, 0.43060562f, 0.16079085f, -0.00178043f, -0.15611611f, 
    0.22019282f, -0.26448897f, 0.03846420f, 0.01470031f, -0.14510204f, -0.04482678f, -0.07944783f, 0.04793132f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13584816f, -0.30020046f, -0.04750084f, 0.47602215f, 0.10418559f, -0.11327089f, 0.08332871f, 0.20113115f, 
    0.10120375f, -0.10623781f, 0.18117209f, 0.30938122f, -0.09486537f, 0.26559311f, -0.12036943f, 0.03043334f, 
    0.22637762f, 0.07087665f, -0.00548780f, 0.51151806f, 0.11998567f, 0.17264259f, 0.30770141f, 0.04259604f, 
    -0.35716525f, 0.41335669f, 0.03544679f, 0.52925265f, 0.37521651f, 0.42122504f, 0.24810460f, -0.38191339f, 
    -0.16613017f, -0.02134810f, 0.22425742f, -0.27965286f, -0.13845672f, 0.42986870f, -0.08665337f, -0.08863738f, 
    0.03514136f, 0.13321018f, 0.27093130f, 0.09926138f, -0.49667692f, -0.16394790f, 0.19210523f, -0.01577350f, 
    0.32581419f, -0.05782432f, 0.16143222f, -0.19840702f, 0.04804992f, -0.24233839f, 0.17432144f, 0.40739053f, 
    -0.36529475f, 0.24477598f, 0.11544435f, -0.13908163f, 0.28544167f, -0.09861659f, -0.19272675f, 0.55669874f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12806869f, -0.21496758f, 0.09874917f, 0.13538785f, 0.20518599f, -0.03359732f, 0.07489494f, -0.17768766f, 
    -0.14513299f, -0.05901504f, -0.08873835f, -0.03481891f, 0.68919373f, -0.00678064f, 0.48093376f, -0.00546557f, 
    -0.10322979f, -0.00514699f, -0.10347912f, -0.27087450f, -0.29029417f, 0.24407761f, 0.20540009f, 0.04570319f, 
    0.10213934f, 0.10843280f, -0.10185588f, 0.14437778f, 0.30271196f, -0.11135811f, -0.01016113f, -0.00383695f, 
    0.11500419f, 0.34947032f, 0.06929374f, 0.40144610f, -0.38746199f, -0.11273614f, -0.47168931f, 0.04070015f, 
    0.00484787f, -0.14595334f, 0.12474603f, -0.09517477f, -0.22331767f, 0.33721322f, 0.11521693f, 0.05123591f, 
    0.13103156f, 0.09798365f, -0.02570242f, -0.04724634f, 0.11118724f, 0.56217563f, 0.14020835f, 0.03230164f, 
    0.14000204f, -0.29144049f, 0.29312843f, 0.09212854f, 0.21816711f, -0.05541279f, 0.07335336f, 0.03718641f, 
    -0.37179253f, -0.21096095f, -0.16423297f, 0.20450099f, -0.09257910f, 0.11986194f, 0.00253117f, -0.04612497f, 
    0.00748328f, 0.13461806f, 0.59531516f, 0.31908855f, 0.18239380f, -0.12063204f, 0.04107266f, -0.09700867f, 
    -0.05484410f, -0.38678682f, -0.09716527f, 0.26746815f, 0.02053017f, 0.45267618f, 0.17339559f, 0.02844708f, 
    -0.23688962f, -0.09451070f, -0.60431844f, 0.29603338f, 0.21900599f, 0.27417186f, -0.07759224f, 0.00522971f, 
    -0.11401416f, 0.64776433f, -0.06648165f, 0.16011518f, 0.17531005f, 0.26725557f, -0.07188046f, 0.10984004f, 
    -0.18820804f, -0.31525153f, -0.08151476f, -0.06266115f, -0.63378429f, 0.25877389f, 0.05233466f, -0.14157510f, 
    0.41584983f, -0.13891265f, 0.55631018f, -0.05103490f, 0.42027345f, -0.25677812f, 0.19429709f, -0.04771618f, 
    -0.24005230f, 0.20313194f, 0.21092151f, 0.20457937f, 0.24657668f, 0.00613482f, -0.04063220f, 0.30625436f, 
    -0.08526710f, 0.05336506f, 0.25545371f, -0.18308792f, 0.00476080f, 0.18209256f, 0.12062199f, 0.11707677f, 
    0.05182123f, 0.24948430f, 0.00055737f, -0.06246243f, 0.18942060f, -0.08412030f, 0.29858100f, 0.23787956f, 
    -0.11635015f, -0.41824237f, -0.16034187f, 0.04693132f, -0.32349554f, 0.17775364f, 0.05530719f, 0.12075920f, 
    0.12417337f, -0.24759200f, -0.05044645f, -0.04293285f, -0.35205030f, -0.21658595f, 0.03956333f, 0.20973094f, 
    0.26143467f, -0.08290618f, 0.08238997f, 0.06722183f, 0.25748557f, 0.04988976f, 0.24298890f, 0.00500795f, 
    0.24077097f, -0.07717375f, 0.20899184f, -0.00186075f, 0.42150366f, -0.11006239f, 0.04234716f, 0.11714792f, 
    -0.08964476f, 0.17973930f, 0.31382757f, -0.09444338f, -0.07907997f, -0.32430488f, -0.12661655f, -0.41508597f, 
    0.30477422f, -0.43341917f, -0.27371305f, 0.40419763f, -0.05589555f, 0.05580135f, 0.16728543f, -0.12527688f, 
    -0.19169295f, 0.08003269f, 0.06957321f, 0.13791656f, -0.09292360f, -0.04154507f, -0.08707664f, -0.02882648f, 
    -0.07520746f, -0.24423248f, 0.12638910f, 0.06269588f, 0.17349513f, -0.39880654f, 0.15047044f, 0.16833591f, 
    0.47827888f, -0.10758138f, 0.03120359f, 0.31728107f, -0.05004656f, 0.52214473f, 0.15831456f, 0.09930539f, 
    -0.08486673f, -0.09621030f, -0.37567312f, 0.04313584f, -0.06566672f, 0.07131522f, 0.09369588f, -0.25351852f, 
    0.13171625f, 0.04118127f, 0.01647988f, -0.23347916f, 0.16786334f, 0.37284586f, -0.36208549f, 0.01065931f, 
    0.09379841f, -0.13585714f, 0.00630050f, -0.03127715f, -0.21857730f, -0.18105137f, 0.09029071f, 0.35230041f, 
    0.10835240f, -0.35350159f, -0.34158045f, -0.05673453f, 0.26985884f, 0.18799892f, 0.36807087f, 0.28554407f, 
    -0.24864866f, 0.22827418f, -0.08475872f, -0.24492230f, -0.06094929f, -0.07801609f, 0.21951717f, -0.29078186f, 
    0.19940178f, -0.13565457f, -0.13675457f, 0.16347373f, 0.09520505f, 0.04285306f, 0.06430797f, 0.06341583f, 
    -0.21693495f, -0.15000504f, -0.28852195f, 0.16988841f, 0.15318327f, 0.61281985f, 0.22183944f, -0.02398790f, 
    0.19766250f, 0.28805879f, 0.16460088f, 0.11785062f, 0.14038713f, -0.32968307f, 0.08511544f, -0.06289408f, 
    0.02993257f, 0.39718005f, 0.24515919f, 0.20465381f, 0.12485354f, 0.25429842f, 0.10331759f, 0.09581663f, 
    0.04652210f, 0.18249933f, -0.06183059f, 0.38293678f, -0.48697042f, 0.10195701f, -0.00918389f, -0.09520167f, 
    -0.02772363f, -0.10096483f, 0.14139618f, -0.09380163f, -0.14913513f, -0.07520372f, 0.07334404f, 0.19778167f, 
    0.32842582f, -0.11080482f, -0.00129823f, 0.09141541f, -0.04307089f, -0.55209631f, 0.04553471f, 0.19750366f, 
    -0.17849854f, -0.21926062f, -0.11530710f, -0.19387378f, 0.12198816f, -0.12087132f, -0.09033509f, 0.27099797f, 
    0.01850965f, 0.07921381f, 0.07007059f, -0.09724490f, -0.11304388f, 0.04351021f, -0.13102558f, -0.10593662f, 
    -0.02346388f, 0.05859816f, -0.14352350f, 0.03261553f, -0.07725140f, 0.10477512f, -0.00497429f, -0.05272784f, 
    -0.03105941f, 0.04690902f, -0.08133582f, -0.00145621f, -0.09584855f, 0.05461873f, 0.02372650f, 0.04899400f, 
    -0.12476917f, -0.14098516f, -0.11955655f, -0.03301264f, 0.06971226f, 0.05030006f, 0.12104696f, -0.10345700f, 
    -0.08367799f, 0.06143788f, -0.04877766f, 0.06850906f, -0.14089108f, -0.04286657f, -0.12982868f, 0.07218246f, 
    -0.07064298f, 0.08187477f, -0.05150086f, -0.07564051f, -0.10018313f, 0.05731064f, -0.08157273f, -0.09268775f, 
    -0.03936512f, -0.08355658f, 0.00926440f, -0.03307162f, -0.05016885f, 0.03924716f, -0.02010082f, -0.01435947f, 
    0.03280423f, 0.05440276f, -0.06477780f, 0.09294130f, 0.00326122f, 0.07838695f, -0.07726101f, 0.01216042f, 
    0.02946249f, 0.02752144f, 0.01536199f, -0.01031541f, 0.00200576f, -0.07498357f, -0.09284015f, -0.15001610f, 
    -0.18435413f, -0.08575633f, -0.05298221f, -0.01649399f, -0.00353943f, -0.11178695f, 0.04740714f, -0.04504222f, 
    0.01915854f, -0.15896219f, 0.02168011f, -0.01902090f, -0.16836061f, -0.03802679f, 0.04615432f, -0.10785554f, 
    -0.04588427f, 0.06332973f, 0.02527652f, -0.00421196f, -0.13961384f, -0.09327676f, -0.05882986f, -0.09061392f, 
    -0.16466095f, 0.08640070f, 0.09464572f, 0.07058944f, -0.03240112f, -0.12444766f, 0.03810322f, 0.06607600f, 
    0.03197942f, -0.02633581f, 0.09811619f, 0.06606646f, -0.10816006f, -0.06864791f, 0.08627743f, -0.17691991f, 
    -0.09076628f, -0.09422462f, 0.06270221f, -0.01622398f, -0.13519843f, -0.06735097f, 0.00224287f, -0.08602151f, 
    -0.03605205f, -0.00526186f, 0.01867514f, 0.01785254f, 0.07897986f, -0.08912510f, -0.11927536f, 0.04400477f, 
    -0.01186451f, 0.28567165f, 0.07257414f, 0.23283125f, -0.33133131f, -0.19351634f, 0.04524632f, 0.30690324f, 
    0.27617535f, -0.15668818f, -0.40665716f, -0.28125846f, 0.01454980f, -0.09872714f, -0.37326068f, 0.38788790f, 
    -0.20119724f, -0.38211167f, 0.09673846f, 0.21823882f, 0.10646714f, -0.02198776f, -0.11452029f, -0.01685655f, 
    0.03402715f, -0.31123370f, -0.10708863f, -0.24302186f, -0.45248941f, -0.32664740f, 0.02851041f, 0.49787074f, 
    0.15256390f, 0.31160861f, 0.39462146f, 0.42818037f, 0.17862076f, 0.10139723f, 0.24692598f, 0.04303885f, 
    0.18739256f, -0.16575764f, 0.23867548f, 0.02404694f, -0.01303161f, 0.12034193f, -0.11336392f, 0.19587593f, 
    -0.25117210f, -0.06369716f, -0.33910814f, 0.09606193f, -0.43955860f, -0.28136408f, -0.37863272f, 0.05527888f, 
    0.17650010f, -0.05244828f, -0.22618920f, 0.03680547f, -0.05878695f, 0.02937592f, 0.26696655f, -0.34912187f, 
    0.17939800f, -0.14098574f, 0.01706628f, -0.02818478f, -0.00501146f, 0.11749861f, -0.08618549f, 0.02275600f, 
    -0.02482638f, -0.12795003f, -0.09161717f, -0.00059118f, -0.30026355f, 0.11078332f, 0.16456367f, 0.14066666f, 
    -0.03270182f, 0.43252495f, 0.22319648f, 0.04011567f, -0.05036087f, 0.19660296f, -0.30350453f, -0.01933721f, 
    -0.07435624f, 0.17210284f, 0.24368191f, 0.06246071f, 0.01723080f, 0.15395035f, -0.12456493f, 0.07912665f, 
    0.18743451f, 0.17996466f, -0.58091766f, -0.31524163f, 0.04678001f, 0.28038448f, 0.70064437f, 0.08544660f, 
    0.40646598f, 0.24056962f, -0.28889993f, 0.04105498f, -0.04893864f, -0.10507932f, 0.05051172f, 0.05552380f, 
    -0.08204711f, 0.07416863f, 0.19207352f, 0.05678254f, -0.00487199f, -0.17957124f, 0.03195433f, 0.03995493f, 
    0.01395261f, -0.27616629f, 0.03137558f, 0.12200762f, 0.18075310f, 0.03876710f, -0.15221258f, 0.25730330f, 
    0.24852379f, -0.04733063f, 0.07677335f, -0.04352641f, 0.22927713f, 0.11941636f, -0.00538254f, 0.07133078f, 
    0.21974987f, -0.07983240f, -0.02152446f, 0.07486647f, 0.21870878f, 0.12134674f, 0.06771871f, -0.11748896f, 
    0.42532641f, -0.30102324f, 0.12889752f, -0.13993123f, -0.02220543f, 0.22935815f, 0.22876117f, -0.03806390f, 
    0.13112311f, -0.14963333f, 0.31276909f, -0.05271420f, 0.04257375f, 0.03309391f, 0.09027956f, -0.23417367f, 
    -0.07010728f, -0.20064165f, 0.62590975f, -0.84608084f, 0.77264965f, -0.12853871f, 0.09870982f, -0.07481073f, 
    0.08079711f, 0.18850392f, 0.15993245f, -0.09486072f, 0.08804708f, -0.13161977f, 0.05010647f, 0.25408807f, 
    -0.12802064f, 0.27533033f, 0.16580640f, -0.12128010f, 0.10606973f, 0.22391956f, 0.07096066f, 0.27091566f, 
    0.15446621f, 0.56337148f, -0.22533697f, -0.26184997f, -0.18211296f, 0.13473040f, -0.01108404f, -0.25161943f, 
    -0.29137251f, -0.18270721f, -0.06447104f, -0.10681557f, 0.10386334f, 0.07955445f, -0.01507609f, -0.01449781f, 
    0.04967711f, 0.31088749f, 0.02891233f, 0.18087219f, 0.50925374f, 0.17139757f, -0.00632707f, -0.25908759f, 
    0.19742729f, -0.32282314f, -0.47767577f, 0.24272400f, -0.39667127f, 0.21301700f, 0.53454447f, 0.05027573f, 
    -0.12708303f, -0.07718936f, -0.21771899f, 0.02581960f, 0.28327590f, 0.13861662f, 0.09234126f, -0.31261787f, 
    -0.08568249f, -0.23681855f, -0.17142983f, -0.35963455f, 0.24964447f, 0.15259625f, -0.50676477f, 0.07370530f, 
    -0.15929857f, -0.23202762f, 0.65064400f, -0.07403523f, -0.46193177f, 0.07312515f, -0.11393054f, -0.01828095f, 
    0.26283678f, -0.26779300f, -0.06373504f, -0.04138817f, 0.10033432f, 0.02627733f, 0.33819580f, -0.12396614f, 
    -0.39404261f, 0.55203432f, -0.00494168f, -0.44694242f, 0.16961250f, -0.02253936f, 0.09023701f, 0.01055681f, 
    -0.16194792f, 0.44416249f, -0.69891822f, 0.17053963f, -0.31609026f, 0.29004148f, -0.08127123f, 0.08721370f, 
    -0.25098386f, 0.00668947f, 0.35499454f, -0.01168238f, -1.00407243f, -0.14179754f, -0.31472826f, -0.45467931f, 
    0.20207049f, 0.14724684f, 0.09877139f, -0.18499148f, 0.44880807f, 0.07299493f, 0.23234479f, 0.05639705f, 
    0.00289781f, -0.11786439f, -0.41168848f, -0.03854788f, 0.05545786f, 0.05822995f, 0.00128125f, -0.03736846f, 
    -0.31752235f, 0.11813393f, 0.11860179f, 0.60441118f, 0.03795579f, 0.09035264f, -0.07073702f, -0.05476007f, 
    -0.61797178f, -0.22506419f, -0.32675102f, -0.09734663f, -0.19208410f, 0.36378539f, -0.03777504f, -0.30360198f, 
    0.40978393f, -0.52561992f, -0.21064006f, -0.03491239f, 0.28950411f, 0.02487447f, 0.27724609f, 0.16790156f, 
    -0.28944916f, 0.44778889f, 0.32872716f, -0.49668202f, 0.03677643f, 0.01065472f, 0.06738850f, -0.14919464f, 
    0.12652560f, 0.12401740f, -0.18860269f, 0.03382911f, 0.34318793f, 0.12518288f, -0.06376663f, -0.17502822f, 
    0.09762253f, 0.10763635f, -0.31237862f, 0.17677654f, -0.09239269f, 0.66463572f, -0.35737815f, -0.25913444f, 
    -0.10380647f, 0.18585831f, 0.02076866f, -0.11993886f, 0.42130354f, -0.28071311f, 0.15665078f, 0.01785320f, 
    0.24627103f, 0.11336959f, 0.23814933f, 0.03883677f, 0.21442394f, 0.10813788f, 0.01761557f, 0.04276495f, 
    -0.36612174f, -0.29287273f, 0.12964037f, 0.57858449f, 0.27769858f, -0.30406305f, 0.04292105f, 0.11751138f, 
    -0.16482541f, 0.00938009f, 0.45844743f, 0.10522079f, -0.13499385f, 0.16057433f, 0.05555833f, -0.10281160f, 
    -0.06490992f, 0.24437436f, -0.78623599f, 0.07608524f, -0.14325994f, 0.06383657f, 0.03318848f, 0.08623365f, 
    0.22379602f, 0.65323883f, 0.38876832f, -0.55393851f, 0.05065905f, 0.11057957f, -0.15605199f, 0.22004408f, 
    0.06791224f, 0.29721031f, -0.12570879f, 0.23811798f, -0.33312026f, 0.16607484f, 0.10911049f, 0.16878642f, 
    -0.08871630f, -0.05732337f, 0.50608557f, -0.02908156f, -0.02338599f, -0.47462004f, 0.10952202f, 0.03592642f, 
    0.25525457f, -0.14615317f, 0.05053551f, 0.06345163f, -0.17739713f, 0.34197807f, 0.08254776f, -0.04369757f, 
    0.06994926f, 0.01101875f, -0.09830860f, 0.05598918f, 0.06918520f, 0.11309402f, -0.02019854f, -0.53746933f, 
    0.00374472f, -0.00130077f, -0.10298767f, -0.62640786f, -0.30780435f, 0.16093740f, -0.11414135f, -0.05122909f, 
    -0.03857557f, -0.06705450f, 0.21920666f, -0.01127968f, -0.02457180f, 0.33910310f, 0.13003850f, -0.00727791f, 
    0.29901424f, -0.04019373f, -0.07705762f, 0.08749254f, -0.05791188f, 0.14594451f, 0.16064920f, 0.25623628f, 
    0.07216977f, 0.09282617f, 0.20249160f, -0.13862391f, -0.03012474f, 0.13931300f, 0.07626012f, 0.17621587f, 
    0.08975808f, -0.44114366f, -0.10376573f, 0.30876926f, 0.07257457f, 0.03112336f, 0.09110519f, 0.14359377f, 
    -0.04675068f, -0.18743017f, -0.25558594f, 0.05348482f, 0.13987200f, 0.78281420f, 0.27329692f, 0.00668604f, 
    -0.12771809f, 0.31067210f, 0.18624398f, 0.17725034f, -0.08506744f, 0.03261571f, -0.28391328f, 0.05922019f, 
    -0.11995367f, 0.35042414f, 0.27462152f, 0.19079976f, 0.09514709f, 0.11286942f, -0.01213829f, -0.12475206f, 
    0.04689256f, 0.12459649f, -0.48112530f, -0.04443789f, -0.32670784f, 0.23516351f, 0.40142930f, 0.06630787f, 
    0.36110783f, 0.17229953f, 0.07782504f, -0.11093642f, -0.34771830f, -0.27522752f, -0.08128276f, -0.10332342f, 
    -0.10154738f, 0.29445925f, -0.21574904f, 0.12049137f, 0.10475934f, -0.48402873f, 0.34717545f, 0.12483638f, 
    0.02404977f, -0.18635522f, -0.03918955f, -0.12665164f, 0.14854521f, 0.05654780f, -0.21536915f, 0.23914945f, 
    -0.07887413f, -0.01634498f, -0.18267003f, -0.03644997f, 0.44567630f, 0.22274728f, -0.03355118f, -0.12736931f, 
    -0.16260932f, -0.06392049f, 0.44762671f, 0.31878164f, -0.18952779f, 0.37619641f, 0.38348287f, -0.22204982f, 
    -0.06725066f, -0.23495236f, 0.10415089f, -0.32566401f, 0.10133395f, 0.59242433f, 0.19329752f, -0.09556791f, 
    0.01675924f, 0.10915161f, -0.03650990f, 0.23395459f, 0.36629736f, 0.33736458f, -0.06830943f, -0.24656105f, 
    -0.21646379f, 1.03425992f, 0.30526707f, 0.06705855f, 0.48043773f, 0.07592755f, 0.16859248f, -0.02421039f, 
    -0.25954875f, 0.07309376f, -0.63379163f, -0.09235132f, -0.42786527f, 0.40270209f, -0.08475016f, -0.00138431f, 
    0.22565235f, 0.02754796f, 0.58840346f, -0.08614886f, 0.27781579f, 0.04163523f, 0.09786478f, -0.08000688f, 
    -0.22536020f, 0.17428978f, 0.26798397f, 0.40921688f, 0.03936297f, 0.15127301f, 0.00347995f, 0.26119426f, 
    0.06077119f, 0.04491784f, 0.03595460f, 0.01235803f, -0.08696421f, -0.03761036f, -0.06264381f, -0.09573810f, 
    -0.01733840f, -0.10338269f, -0.07657563f, -0.03817124f, 0.00100085f, 0.08550868f, 0.00791994f, 0.05707915f, 
    -0.01801686f, 0.07054067f, -0.12279449f, 0.06409690f, 0.06444705f, -0.09254713f, 0.01155395f, 0.06378470f, 
    -0.12561761f, -0.11599829f, -0.05103340f, -0.12966426f, -0.09470484f, -0.04675154f, -0.05875984f, 0.04598675f, 
    -0.12146319f, 0.01013876f, -0.01772572f, 0.14266434f, -0.06044892f, 0.08982113f, -0.00820550f, -0.03112082f, 
    0.10563666f, -0.10927859f, -0.09166987f, 0.09050918f, -0.10237048f, -0.13897794f, 0.12634420f, 0.03580482f, 
    0.05880425f, -0.02365060f, -0.12442846f, -0.02687867f, -0.01587299f, 0.02629696f, -0.03675678f, 0.02326634f, 
    -0.08040837f, 0.01261235f, -0.04856271f, -0.08867000f, -0.10895243f, -0.11382273f, -0.01842466f, -0.13777737f, 
    -0.24518837f, 0.05160841f, 0.32174003f, -0.07384574f, 0.17247842f, -0.06400323f, 0.00958019f, 0.15176272f, 
    0.15979511f, 0.23157685f, -0.07763969f, 0.04648023f, 0.37713987f, -0.36447883f, -0.21461415f, 0.11458315f, 
    0.02828602f, -0.36065927f, -0.29579899f, 0.18979248f, 0.01359383f, -0.30244866f, 0.15719832f, -0.00281404f, 
    0.17998214f, -0.10672586f, -0.13239540f, -0.14260404f, -0.27341554f, -0.16804191f, 0.06139998f, 0.42889363f, 
    0.01428699f, 0.15236735f, 0.19316076f, -0.42103893f, 0.52088678f, -0.05121882f, 0.25901958f, -0.11305106f, 
    -0.21923046f, -0.11990989f, 0.26816675f, 0.10825954f, 0.20324780f, 0.02514781f, -0.09137131f, 0.23056418f, 
    0.20165677f, -0.32239562f, 0.28492469f, 0.12391329f, -0.16655228f, -0.02465197f, -0.17424943f, -0.09397644f, 
    -0.08139208f, -0.35421446f, -0.47997308f, -0.04739638f, 0.12192031f, -0.03303731f, 0.36065820f, -0.20806088f, 
    0.07033931f, 0.02548228f, -0.08164017f, -0.09507970f, -0.06845915f, -0.07098518f, -0.11272351f, 0.01526759f, 
    0.01347404f, -0.07027804f, 0.10515811f, -0.02460442f, -0.12045120f, 0.07398291f, 0.09137018f, -0.09463776f, 
    -0.04014547f, 0.01483981f, 0.09433823f, -0.00382908f, -0.06329265f, 0.03409482f, 0.04972709f, 0.11162813f, 
    -0.01874761f, -0.00853752f, -0.01494741f, -0.08212437f, -0.06970287f, -0.03396413f, -0.01543491f, -0.04682706f, 
    0.08204348f, 0.09144963f, -0.10829820f, 0.10282457f, 0.02589797f, 0.05032798f, 0.01538295f, -0.02860656f, 
    0.04548309f, 0.06461256f, 0.08742127f, 0.06026724f, -0.10187489f, -0.10861489f, 0.09807597f, -0.01798718f, 
    0.01405621f, -0.10687446f, -0.00183010f, -0.09183817f, -0.11014301f, -0.04895944f, -0.01173693f, -0.03470111f, 
    0.04275076f, 0.03539020f, -0.08322462f, -0.02160607f, -0.03505799f, 0.05390313f, -0.11328573f, -0.08921164f, 
    -0.16370934f, -0.20503536f, -0.00504642f, 0.32770985f, -0.10278077f, 0.34827471f, -0.01133722f, 0.07117016f, 
    0.14715056f, 0.13028497f, 0.52241355f, 0.01793465f, 0.20495966f, -0.09194818f, -0.11426453f, -0.13848151f, 
    0.11044908f, -0.17983837f, -0.13553190f, 0.20950390f, -0.09536829f, 0.03686445f, 0.06036872f, -0.04356003f, 
    -0.05212210f, 0.17010729f, -0.26558053f, 0.07519305f, 0.27612445f, 0.21194063f, -0.04480417f, -0.21627954f, 
    -0.12678225f, 0.24379370f, -0.10193591f, -0.10456017f, -0.26896012f, 0.09648981f, -0.20760819f, 0.12166968f, 
    -0.23828541f, -0.00573141f, 0.04702624f, 0.02304351f, -0.11800038f, 0.04398375f, -0.07897369f, -0.03734002f, 
    0.23817988f, -0.18797627f, 0.17814809f, -0.10921608f, 0.28034166f, -0.63824821f, 0.51551795f, 0.24557775f, 
    -0.25097093f, 0.47372371f, 0.16754401f, -0.08742131f, 0.15502854f, -0.07426624f, -0.03514959f, 0.17967331f, 
    -0.03039697f, -0.18170203f, -0.31314188f, -0.04501131f, 0.00659457f, -0.12379679f, 0.09183964f, -0.35711211f, 
    -0.22018380f, -0.10435412f, 0.10405166f, 0.18341540f, -0.59543753f, 0.30367756f, 0.06030732f, -0.30739814f, 
    0.05806634f, 0.60284024f, 0.19002335f, -0.35517454f, 0.13074282f, 0.73593891f, -0.15012518f, -0.11894006f, 
    -0.02406735f, 0.07588951f, 0.01258838f, 0.27744490f, 0.20473310f, 0.25801933f, 0.00143181f, 0.29251957f, 
    -0.22138949f, -0.03181065f, -0.54225516f, 0.48441821f, 0.22557719f, 0.10986182f, 0.26771834f, -0.10135067f, 
    -0.03200811f, -0.08521283f, -0.70221412f, -0.09885332f, -0.28058571f, 0.00077341f, -0.08096626f, -0.31441489f, 
    0.05342742f, 0.07858667f, -0.32178348f, -0.05198236f, 0.41235283f, 0.27255812f, 0.46834290f, 0.07112218f, 
    -0.21617253f, 0.35316822f, 0.32855651f, -0.23458104f, -0.14610580f, 0.02249778f, -0.22950108f, 0.02322162f, 
    -0.06495771f, 0.40484104f, -0.21847999f, 0.06165782f, -0.05530429f, -0.00870236f, -0.05719053f, 0.23502468f, 
    0.06439608f, 0.17682207f, 0.68916941f, 0.25150248f, -0.08684324f, -0.27877927f, -0.59105974f, -0.18873809f, 
    -0.24661839f, -0.24479610f, 0.12168100f, 0.19512337f, 0.43085328f, 0.20748934f, 0.10594358f, 0.05116016f, 
    0.14777681f, -0.30309349f, -0.38986593f, 0.12182248f, -0.04531213f, 0.03228535f, 0.05055940f, -0.20336090f, 
    -0.21690065f, 0.24857002f, 0.69720483f, -0.44091049f, 0.54115790f, -0.21077575f, 0.27152094f, -0.09076002f, 
    -0.39096352f, -0.23683159f, 0.08086122f, 0.07675597f, -0.72831386f, 0.58640438f, -0.04371841f, -0.12127873f, 
    0.07672949f, -0.20913513f, 0.13345940f, 0.09000850f, 0.05911821f, 0.11828172f, -0.31649247f, -0.11883630f, 
    -0.12358390f, 0.37846607f, 0.27465597f, -0.17509687f, 0.00249990f, -0.03416444f, 0.17092410f, 0.06688835f, 
    -0.10138278f, 0.28037456f, -0.09587675f, 0.08164719f, -0.39957637f, -0.01296676f, 0.04866348f, 0.20547840f, 
    0.14515705f, 0.01720393f, 0.46649539f, -0.09535161f, -0.26535991f, -0.80430216f, -0.17143601f, 0.11599592f, 
    0.15897577f, 0.03821011f, 0.21327004f, 0.05393643f, -0.01313536f, 0.05740346f, -0.13066800f, 0.03643650f, 
    -0.07396589f, 0.00605882f, -0.13230237f, -0.10678277f, 0.08173103f, 0.24643680f, -0.07045858f, -0.46287435f, 
    0.15091822f, 0.14304961f, -0.42512482f, -0.32309979f, -0.45920202f, 0.07195297f, 0.43110868f, -0.08624446f, 
    0.06946227f, 0.11390462f, 0.10484760f, 0.04171586f, 0.14948450f, -0.10193257f, -0.00951433f, -0.12630613f, 
    0.09613479f, -0.06647565f, 0.00215566f, -0.00336659f, 0.07181127f, -0.38070139f, 0.17443353f, -0.02704927f, 
    -0.03250117f, 0.09696604f, 0.05832298f, -0.11745972f, 0.08954681f, 0.13126719f, -0.11918914f, -0.01852963f, 
    -0.03639197f, -0.09705834f, -0.16253799f, -0.11376240f, -0.13717976f, -0.03286400f, 0.06742765f, 0.02543706f, 
    -0.12672278f, -0.13998181f, 0.12975779f, -0.02095799f, -0.03284068f, 0.08547432f, 0.00837283f, -0.10332018f, 
    0.02270861f, -0.01202879f, -0.05142147f, 0.06383434f, 0.03033720f, -0.02815646f, -0.00910553f, -0.10219243f, 
    -0.04357394f, -0.08085173f, -0.05404735f, -0.09073398f, -0.03578842f, -0.11612629f, -0.06818183f, -0.10987432f, 
    0.09066949f, -0.10150354f, -0.04763091f, -0.08053628f, -0.06655875f, 0.03146268f, 0.05135476f, -0.01094985f, 
    0.09124989f, -0.03098639f, -0.17711304f, -0.05878504f, -0.02489420f, -0.06113063f, -0.04345265f, 0.09294715f, 
    0.05431132f, 0.03084591f, -0.15778299f, -0.06450605f, -0.01884287f, -0.03058414f, -0.12857257f, 0.05783419f, 
    0.01362754f, 0.02730054f, 0.05090594f, -0.10472719f, 0.00263711f, -0.10439770f, -0.09039299f, 0.00397396f, 
    0.15449768f, 0.06490207f, -0.01771552f, -0.07295031f, 0.33482528f, -0.06555674f, 0.10475960f, -0.13965519f, 
    -0.15189816f, 0.06201908f, -0.26610488f, 0.05836986f, 0.55327463f, -0.05698393f, 0.12094458f, 0.00074402f, 
    0.00369628f, 0.02434073f, -0.01550060f, -0.05464281f, 0.04278869f, -0.04544676f, 0.42160356f, 0.02304384f, 
    0.02906326f, 0.11860760f, 0.20111166f, 0.14395392f, 0.21695352f, 0.09878486f, -0.04970019f, 0.13618252f, 
    -0.19263260f, -0.10525074f, 0.19640256f, 0.54027063f, -0.13985674f, 0.05410393f, -0.31362265f, 0.04132937f, 
    -0.32367092f, -0.20703308f, 0.27350041f, -0.02603456f, -0.13657984f, 0.28395838f, -0.00966845f, 0.01018515f, 
    0.21381474f, -0.02501884f, -0.12241118f, 0.01904570f, 0.01845501f, 0.51233697f, -0.03528882f, -0.00932770f, 
    -0.18055701f, 0.09977909f, 0.19761032f, -0.18728730f, 0.06250298f, -0.02582465f, 0.03018340f, -0.02755285f, 
    -0.21544339f, 0.19510314f, -0.10608715f, 0.14746165f, 0.06059507f, 0.16583812f, -0.04003934f, 0.13745651f, 
    -0.01132193f, 0.35494980f, 0.25908753f, 0.22998115f, 0.08287520f, -0.21197815f, -0.10474395f, -0.13615854f, 
    0.39940807f, -0.06411599f, 0.02986410f, 0.20450713f, -0.13464010f, -0.05540698f, 0.38720253f, 0.08445701f, 
    0.11866952f, 0.04746606f, -0.15622218f, 0.06608243f, 0.09596732f, 0.06158812f, 0.10114570f, -0.26331866f, 
    -0.12697358f, -0.17669015f, -0.09802089f, -0.06084745f, -0.09640531f, 0.24378002f, -0.36767808f, -0.09488045f, 
    -0.34518969f, -0.01094555f, 0.28834850f, 0.09294558f, 0.40671849f, -0.12228163f, 0.03729668f, 0.10709275f, 
    0.19415380f, -0.39198115f, -0.16110356f, 0.12175740f, 0.35506848f, -0.31579518f, 0.33933732f, 0.22735691f, 
    -0.20286265f, 0.48446694f, -0.09295960f, -0.46047670f, -0.10802487f, 0.06950714f, 0.28289035f, -0.21397799f, 
    0.02408052f, 0.03584094f, 0.02475576f, -0.05077024f, -0.05097393f, -0.05859113f, -0.11620168f, 0.07071164f, 
    -0.03085676f, 0.03300711f, 0.05418651f, -0.10780815f, 0.01363800f, -0.10495317f, -0.09525243f, -0.01110339f, 
    -0.05702986f, -0.12392490f, -0.04776783f, -0.05524064f, 0.05076366f, -0.16176903f, -0.07635114f, 0.04120679f, 
    -0.03740288f, 0.05961249f, -0.03744685f, 0.06447250f, -0.06825913f, -0.15145603f, 0.10694070f, -0.09867384f, 
    -0.07179739f, 0.02873121f, -0.07437100f, 0.08905714f, -0.05292746f, -0.14616680f, -0.08191783f, 0.04767837f, 
    0.00543863f, -0.02085317f, -0.06529306f, 0.00850988f, -0.10827443f, -0.04783940f, -0.08195373f, -0.03429274f, 
    0.01960395f, -0.09713007f, -0.03209458f, -0.07246770f, 0.07015730f, 0.06129487f, 0.05365337f, 0.08938175f, 
    -0.02005147f, -0.03007532f, 0.09962567f, 0.10073005f, -0.00468018f, -0.03064820f, 0.07805068f, 0.03737177f, 
    -0.03699943f, -0.10256109f, 0.00130468f, -0.11160889f, -0.08122874f, 0.01966816f, -0.10143477f, 0.06356082f, 
    -0.01013162f, -0.08879571f, 0.04635430f, -0.13076845f, -0.00026206f, -0.06251725f, -0.05707663f, 0.09801318f, 
    -0.13755865f, -0.12926206f, -0.00968175f, -0.12417298f, -0.11362323f, -0.03913203f, 0.04652568f, 0.05094343f, 
    -0.12972017f, -0.12732372f, -0.02514922f, 0.07529432f, -0.09840013f, 0.10038286f, -0.10709217f, 0.03539710f, 
    -0.07272609f, -0.05831487f, -0.12860973f, 0.02700444f, 0.07653402f, 0.01593444f, 0.07582112f, 0.01250830f, 
    -0.01739923f, -0.04574937f, 0.07989161f, -0.04181705f, -0.06680879f, -0.02771529f, 0.06207815f, -0.13813956f, 
    -0.03695258f, 0.07776803f, -0.12090190f, -0.11547512f, 0.04617601f, -0.04990545f, -0.10731837f, -0.12316986f, 
    -0.06590690f, 0.09595265f, -0.12025038f, -0.13409425f, -0.10265469f, -0.12331991f, 0.06724663f, -0.09363299f, 
    -0.05696942f, -0.02275856f, 0.11980173f, -0.07537055f, 0.10500236f, 0.03394285f, -0.00904344f, 0.04698801f, 
    -0.00189582f, -0.06201394f, -0.08351669f, -0.08622958f, -0.11214384f, 0.00341541f, 0.10792530f, -0.05949493f, 
    -0.06626874f, -0.05775481f, -0.00178617f, -0.02712122f, 0.05673660f, -0.12093501f, 0.11323059f, 0.00929463f, 
    0.00545667f, -0.09237656f, 0.08808409f, -0.12249391f, -0.03487052f, -0.12478864f, -0.01921293f, -0.12318470f, 
    -0.07250038f, -0.04164511f, -0.10750429f, 0.08785473f, -0.12067771f, -0.09661070f, 0.00863063f, 0.02570809f, 
    -0.01525612f, -0.08974867f, 0.08160724f, -0.05544373f, -0.06089455f, -0.01909296f, -0.06430757f, -0.06250116f, 
    0.10274951f, -0.11953594f, 0.00973016f, -0.12240320f, 0.11718738f, -0.03354777f, -0.11735564f, 0.09828480f, 
    0.02844821f, 0.01188482f, -0.07720046f, 0.01295140f, -0.07652077f, -0.05527577f, 0.06122713f, -0.05453557f, 
    0.45503932f, 0.08736163f, -0.13447462f, 0.01871418f, -0.02539386f, 0.09691130f, 0.09596536f, 0.31579006f, 
    0.20015374f, 0.02235793f, 0.24674648f, 0.10081705f, -0.11627143f, 0.37184793f, -0.25496835f, -0.18124428f, 
    -0.15110068f, 0.55682302f, 0.20025589f, -0.03303050f, 0.29612774f, -0.19878361f, 0.09412997f, -0.04213709f, 
    -0.01706252f, -0.01207868f, 0.34537950f, -0.05464787f, 0.26609704f, 0.03295455f, 0.05715546f, -0.08417209f, 
    -0.13478681f, -0.23536916f, 0.31135952f, -0.03281265f, 0.01844690f, -0.24012323f, 0.44118038f, -0.06367610f, 
    -0.03130564f, -0.11082540f, 0.04643736f, -0.00853375f, -0.15087457f, 0.22220552f, -0.02742566f, -0.15832803f, 
    -0.07063662f, 0.08403433f, -0.03015127f, -0.08299576f, -0.03384926f, 0.35789022f, -0.06988526f, 0.01302535f, 
    0.05711959f, 0.18022805f, 0.39680514f, -0.21525122f, 0.06051179f, 0.01370968f, -0.25113618f, 0.30171707f, 
    0.10087807f, 0.19192745f, 0.00464070f, 0.20398696f, -0.29556483f, -0.13550782f, -0.05898704f, 0.44166234f, 
    0.15370959f, 0.07028024f, 0.05409532f, -0.15129012f, -0.12456874f, -0.25427529f, -0.48171830f, 0.35167789f, 
    -0.09785663f, 0.15187085f, 0.17968176f, 0.46422434f, 0.31605724f, -0.52504128f, 0.02814769f, 0.05691350f, 
    0.10778604f, -0.03807763f, -0.00997025f, 0.09392115f, -0.18872346f, 0.09354061f, -0.11966243f, -0.00896909f, 
    0.03621542f, 0.39240056f, 0.28711015f, -0.32430020f, -0.24699910f, -0.14575920f, 0.37017930f, -0.08119822f, 
    0.01285703f, -0.05455567f, 0.32307941f, 0.06748093f, -0.02976871f, 0.00291175f, 0.08943824f, -0.04977784f, 
    -0.04275373f, -0.18301302f, -0.15979561f, 0.06384820f, -0.28513175f, -0.24858786f, -0.34537101f, 0.13095066f, 
    -0.04306597f, 0.04567883f, 0.03783470f, -0.24922122f, 0.20160304f, 0.05584023f, -0.03992844f, 0.19249274f, 
    -0.38487029f, 0.10667754f, 0.31854942f, -0.13792014f, -0.22102068f, 0.16343006f, -0.04496337f, 0.19767413f, 
    0.07636543f, 0.27696544f, 0.16357706f, -0.17928816f, 0.15634039f, -0.58505994f, 0.22484243f, 0.25724196f, 
    -0.20986210f, -0.47632912f, -0.36008459f, 0.23002936f, -0.65248585f, 0.14108223f, 0.08801918f, 0.07681486f, 
    0.04019945f, -0.07552297f, -0.27359971f, -0.19374359f, -0.12183222f, -0.01928698f, 0.03246476f, 0.18442406f, 
    0.26195741f, -0.07168724f, -0.16957650f, 0.37343696f, -0.07718764f, -0.14546166f, -0.14272645f, 0.07885027f, 
    0.08815399f, -0.00352850f, 0.04314246f, -0.01589932f, 0.31554639f, 0.05096379f, 0.04857148f, 0.22103578f, 
    0.01380220f, 0.08096503f, 0.46335682f, 0.07473356f, 0.01166747f, -0.23378606f, -0.13614136f, -0.51313579f, 
    0.21710941f, -0.35775468f, -0.18757215f, 0.13715704f, 0.02729104f, -0.00743197f, 0.29462487f, -0.17568859f, 
    0.30334327f, -0.24451102f, 0.18286753f, -0.03002291f, 0.07607815f, 0.15353899f, -0.00314794f, 0.15362023f, 
    -0.04198043f, 0.11319306f, -0.11241129f, -0.05020808f, 0.13495208f, 0.53486162f, 0.17772998f, -0.10508279f, 
    -0.26527569f, 0.74439645f, 0.05013069f, 0.08639368f, 0.13726848f, -0.06309213f, 0.03473386f, 0.06121354f, 
    0.14902143f, 0.34018743f, 0.39583561f, 0.06738696f, 0.09646398f, 0.10192665f, 0.06369765f, 0.20969807f, 
    -0.06319459f, -0.10283288f, 0.02134370f, -0.46036354f, 0.11941475f, -0.04454491f, 0.55777270f, 0.02978584f, 
    0.22022392f, -0.09514327f, -0.11011510f, 0.00409463f, -0.35267377f, 0.25697672f, 0.10904521f, -0.27224579f, 
    -0.04167922f, 0.24163708f, 0.43220881f, -0.11193125f, -0.11046073f, 0.03638027f, -0.04797141f, -0.18497850f, 
    0.03240070f, -0.32720143f, 0.30058005f, 0.09400941f, 0.22300348f, -0.02865591f, -0.20459636f, 0.40150282f, 
    0.09869625f, -0.22999406f, -0.09290978f, 0.12829331f, 0.05536703f, 0.04083975f, -0.12033031f, -0.12335911f, 
    -0.07339746f, -0.19711873f, 0.10978600f, 0.07365254f, 0.28772372f, 0.40099382f, 0.27232626f, 0.09127437f, 
    0.05534811f, 0.00481978f, 0.15526606f, -0.06723518f, 0.01583019f, 0.41098449f, -0.23393331f, 0.11332051f, 
    0.07257000f, 0.09603354f, -0.00934040f, 0.17345160f, 0.04084736f, 0.09547137f, 0.03577809f, -0.12518206f, 
    -0.08714484f, 0.25984654f, -0.22622816f, 0.55975002f, -0.41872019f, -0.07863132f, 0.22234438f, 0.03672868f, 
    0.22356004f, 0.11944110f, 0.05283207f, -0.04334149f, -0.38723299f, -0.20299761f, -0.09084578f, 0.08051540f, 
    -0.03458745f, 0.06661351f, 0.03249110f, 0.08362356f, 0.20455566f, -0.38815650f, 0.27141857f, 0.17110990f, 
    -0.05474517f, 0.05340504f, 0.09987628f, 0.03478278f, 0.08391661f, -0.07736812f, -0.14912102f, 0.00574198f, 
    -0.03205231f, 0.14024043f, 0.13365391f, 0.14951107f, 0.01671108f, -0.06286930f, 0.01477550f, 0.36445725f, 
    0.41414973f, 0.29963061f, 0.25941202f, 0.10332870f, 0.32350275f, -0.20395148f, -0.29988450f, 0.22093514f, 
    -0.32797736f, -0.76390427f, -0.26122651f, 0.26731318f, 0.05115993f, -0.16126803f, -0.05308923f, 0.11889817f, 
    0.08785056f, -0.13019492f, -0.36954963f, -0.09605334f, -0.10173671f, -0.08841272f, -0.03408252f, 0.24792188f, 
    0.15026335f, 0.65526748f, 0.06189380f, -0.30555394f, -0.06898388f, -0.14714277f, 0.26171410f, -0.04139267f, 
    -0.06927762f, -0.36836338f, 0.10515235f, 0.07780643f, -0.24371177f, 0.30969870f, -0.04461347f, 0.16950907f, 
    0.14666229f, -0.15755749f, 0.39308438f, 0.06686494f, -0.20285116f, -0.33811614f, -0.42639688f, -0.19056357f, 
    0.22384736f, -0.14693749f, 0.04282020f, 0.63031679f, 0.23766671f, -0.07166942f, -0.05565851f, 0.22109234f, 
    0.09892328f, -0.14023240f, -0.10979778f, -0.12241339f, -0.08324140f, -0.05216798f, 0.09949134f, -0.02111431f, 
    -0.13240933f, -0.07521216f, -0.02703364f, -0.02823815f, 0.10974418f, 0.02690843f, 0.04532085f, 0.07086688f, 
    -0.12671296f, -0.09812401f, 0.02072013f, 0.00244981f, -0.02737205f, 0.07633096f, -0.13872890f, 0.07366134f, 
    0.05476555f, 0.00509119f, 0.07599951f, -0.12839124f, -0.13955538f, -0.13800205f, -0.03247926f, 0.05966797f, 
    0.07207125f, -0.02470466f, -0.12111926f, 0.05020405f, -0.01203687f, -0.11718351f, 0.00061010f, 0.04239252f, 
    -0.12213029f, -0.05017429f, 0.00860475f, 0.04241917f, 0.08227561f, 0.00014830f, -0.07585256f, -0.10092903f, 
    -0.05548777f, -0.10418681f, 0.08329758f, 0.03140850f, -0.12298121f, 0.07667115f, -0.09686565f, 0.01222787f, 
    0.09204345f, 0.10760693f, 0.04860571f, -0.07458027f, -0.11550545f, -0.10303695f, -0.08892529f, -0.10502871f, 
    0.25793874f, 0.11611925f, 0.06258613f, 0.06125326f, 0.15620792f, -0.03557408f, 0.04656432f, 0.07710151f, 
    0.19922414f, -0.27032673f, -0.12433237f, -0.27900490f, -0.44068062f, 0.46773514f, -0.09624519f, 0.28649881f, 
    0.02145905f, 0.40577638f, 0.34863099f, -0.03227914f, 0.15170568f, 0.18956088f, -0.30736467f, 0.03347047f, 
    0.05224171f, -0.08595522f, 0.29380032f, -0.09959505f, -0.13290030f, -0.24927372f, 0.12203199f, 0.21322779f, 
    0.07133767f, 0.01435636f, 0.25997975f, 0.46825385f, 0.63961095f, -0.23550478f, 0.23718919f, 0.08691177f, 
    0.34472877f, 0.09527311f, -0.26139495f, 0.06242788f, -0.06797422f, -0.09773483f, 0.11318452f, -0.00808309f, 
    -0.38501641f, 0.35435846f, -0.38488707f, 0.06913245f, -0.15373017f, 0.05601043f, -0.36474550f, 0.22518960f, 
    0.24044670f, -0.01678315f, -0.10627689f, 0.00446685f, -0.26989198f, 0.03464736f, -0.01753108f, -0.11735674f, 
    0.17126474f, -0.00097252f, -0.06329664f, 0.10823613f, -0.02500800f, -0.09988337f, -0.09201210f, 0.30144531f, 
    0.00125918f, -0.06412735f, 0.08485553f, -0.00234592f, -0.40479738f, -0.04634041f, -0.06543237f, 0.01518593f, 
    0.21334189f, 0.09295805f, 0.33931538f, 0.26386702f, 0.34352437f, -0.48494869f, 0.01950403f, -0.04811855f, 
    0.06333284f, 0.47115979f, 0.14753036f, 0.17594180f, -0.05152605f, 0.35757613f, -0.05693401f, 0.02059570f, 
    0.03541587f, 0.44436905f, -0.35989493f, -0.36542106f, -0.55080158f, 0.23463917f, 0.48235688f, 0.03567933f, 
    0.09000461f, 0.09253042f, -0.05108986f, 0.07177725f, 0.12596300f, -0.25487873f, 0.06723052f, -0.05606294f, 
    0.36877355f, 0.07646339f, 0.04539867f, -0.06307536f, -0.06121096f, -0.53804159f, -0.04686713f, 0.27685526f, 
    -0.10480979f, -0.20884132f, -0.13316213f, -0.13847411f, 0.00505981f, 0.05078293f, -0.09633669f, 0.39038602f, 
    -0.14990284f, 0.20181912f, 0.17047207f, 0.02688753f, -0.04130242f, -0.01552707f, 0.00555006f, 0.19203876f, 
    0.09956813f, 0.02220514f, 0.16878118f, -0.00792681f, -0.27496547f, -0.74090660f, -0.05187939f, 0.10586009f, 
    0.22799404f, -0.11351722f, -0.06808408f, 0.15292172f, -0.24546079f, 0.23736042f, 0.18706334f, 0.10022408f, 
    0.07905478f, 0.11164889f, -0.25889972f, 0.00618793f, -0.14232956f, -0.02134143f, -0.06186365f, -0.16949838f, 
    0.19431943f, -0.05336983f, -0.07883173f, -1.06635678f, 0.17832792f, 0.08876396f, 0.05187317f, 0.10112402f, 
    -0.00621923f, -0.01674347f, -0.08589391f, -0.03121262f, 0.15188357f, -0.02641456f, 0.02866228f, 0.29992533f, 
    0.01455208f, -0.06299711f, 0.09546711f, 0.04294394f, 0.10217497f, -0.10871468f, -0.10216143f, -0.08107971f, 
    -0.12339111f, -0.21012726f, -0.20346668f, -0.05542471f, 0.22062577f, -0.14473534f, 0.29562616f, 0.04225769f, 
    0.17292385f, 0.37863407f, -0.11659826f, 0.31546435f, -0.29158938f, -0.06663501f, -0.09062048f, 0.34654820f, 
    0.16400547f, -0.25222826f, 0.01662306f, -0.15550944f, -0.29373902f, -0.23990569f, -0.30307823f, 0.31558558f, 
    0.40581495f, -0.32794291f, 0.23844966f, 0.23354359f, 0.49078929f, -0.22184587f, -0.01962672f, -0.02048782f, 
    0.10830042f, -0.08112673f, -0.12662432f, -0.10912775f, -0.11896496f, -0.11334556f, -0.04995026f, -0.30761108f, 
    0.13118908f, -0.11200408f, 0.36101347f, -0.84591198f, 0.02370842f, 0.08452556f, -0.05028035f, 0.06218918f, 
    0.21268289f, 0.19255313f, -0.06255643f, -0.10837057f, 0.13896535f, -0.22774792f, -0.09501199f, 0.17336830f, 
    0.05864007f, -0.14998682f, -0.20410669f, 0.05006409f, -0.05472457f, -0.12122185f, -0.22378889f, 0.56322753f, 
    -0.05858344f, 0.46638402f, -0.02980722f, -0.46839991f, -0.08443649f, 0.02337869f, 0.05471690f, -0.19934830f, 
    0.22451679f, 0.30479488f, -0.03842418f, -0.09481162f, -0.04090374f, -0.16007623f, 0.09972015f, 0.27404258f, 
    0.16092074f, 0.21809424f, 0.15442060f, 0.07167859f, -0.16268495f, -0.12245801f, -0.40588778f, 0.03086510f, 
    0.13019781f, 0.09514014f, 0.13876839f, 0.11437777f, 0.42706573f, -0.27977693f, -0.03992228f, 0.00785385f, 
    0.25024068f, -0.07428741f, 0.04009408f, 0.00283307f, -0.06880029f, 0.14937086f, 0.02674401f, -0.00357762f, 
    -0.05106793f, -0.03371686f, 0.67215723f, -0.09398688f, -0.22270820f, -0.07561193f, 0.07636623f, -0.11640562f, 
    -0.08657014f, 0.13155371f, 0.42450133f, 0.11230182f, 0.28544572f, 0.12750337f, 0.06316911f, -0.12719306f, 
    -0.07081717f, -0.09061967f, -0.18674935f, 0.06663400f, -0.04953318f, -0.05509060f, -0.26392171f, -0.01106450f, 
    0.20287132f, 0.39781553f, -0.10198022f, -0.25620455f, -0.05077494f, -0.01743008f, 0.08065020f, -0.05275206f, 
    0.32527402f, 0.21399294f, 0.17843066f, 0.12276971f, -0.00819586f, -0.19466875f, -0.11518426f, 0.16255233f, 
    0.08827171f, -0.16697723f, -0.05043791f, -0.02211931f, -0.27594626f, 0.31487399f, -0.17817910f, 0.24166742f, 
    0.02312789f, 0.18558228f, 0.15237179f, 0.12764138f, 0.28739959f, -0.31796595f, 0.05134270f, 0.01890947f, 
    0.13770027f, -0.03709936f, 0.25998029f, 0.07780334f, -0.20065045f, -0.06394653f, -0.09337613f, -0.01343570f, 
    0.21635725f, 0.08304559f, 0.76752126f, -0.69952482f, 0.16559732f, 0.12415732f, 0.11673472f, -0.04064365f, 
    0.03308724f, 0.27232370f, 0.04333667f, 0.03064092f, 0.01582111f, -0.13377823f, 0.09048586f, 0.10393728f, 
    -0.11142036f, 0.13730775f, 0.06222400f, 0.06163505f, -0.22312100f, 0.02597566f, -0.39312154f, 0.21062665f, 
    0.17309660f, 0.07524069f, -0.16162875f, -0.07661437f, -0.00663789f, 0.12403424f, 0.02765562f, 0.04497747f, 
    -0.04704956f, -0.05983895f, 0.08839564f, -0.03560269f, 0.00164762f, 0.00121592f, 0.11098482f, -0.10093245f, 
    -0.09396471f, -0.01901620f, -0.09397209f, -0.14449061f, 0.05207030f, 0.03351079f, 0.08055890f, -0.06303826f, 
    -0.14966618f, -0.10979273f, -0.09029166f, -0.07132752f, 0.05013260f, 0.03591676f, 0.07976133f, 0.09895687f, 
    -0.06085654f, 0.07795048f, -0.00018119f, -0.03307419f, 0.02344760f, 0.01134249f, 0.05757745f, -0.09850542f, 
    0.04498056f, 0.01855543f, -0.13511831f, -0.05152544f, 0.04686290f, -0.14491273f, -0.13049312f, -0.08111002f, 
    0.01938147f, -0.08503771f, 0.01802223f, 0.04039861f, -0.03643480f, -0.07021720f, 0.08450398f, 0.05149034f, 
    0.09720648f, -0.05674327f, -0.05763399f, 0.03370771f, -0.15708990f, -0.05740256f, -0.03372032f, -0.00443615f, 
    0.02732874f, 0.01063220f, -0.00873376f, -0.07225219f, -0.14207362f, 0.03149433f, -0.12246131f, -0.13318460f, 
    -0.14155094f, 0.30885112f, -0.12770203f, 0.15265761f, -0.12526405f, 0.28580165f, -0.08869288f, 0.12849721f, 
    0.03281559f, 0.20709343f, 0.60298872f, 0.03173228f, -0.04087771f, -0.40138349f, -0.04887662f, -0.06733589f, 
    0.40575546f, -0.31939861f, 0.03604750f, 0.38377535f, 0.06745998f, 0.03554608f, 0.27121565f, 0.06445679f, 
    0.02822283f, 0.01592372f, -0.21594220f, 0.15545067f, 0.18983915f, 0.24294552f, 0.05880024f, -0.25236201f, 
    0.05325923f, 0.47289270f, -0.49225840f, -0.07076296f, -0.32444015f, 0.29197150f, -0.34198236f, 0.05413717f, 
    -0.16953117f, -0.06806427f, -0.07320713f, 0.09582622f, 0.21958525f, 0.23552403f, -0.04720197f, -0.01174167f, 
    0.45185202f, -0.16016975f, 0.16312999f, -0.10966983f, 0.25500509f, -0.17246202f, 0.32779476f, 0.06117231f, 
    -0.22593832f, 0.10290773f, 0.14376909f, -0.07790664f, 0.18971604f, -0.04639395f, 0.01536194f, 0.14538760f, 
    -0.17913939f, -0.29303187f, -0.00462215f, -0.02170721f, 0.49209782f, 0.02433597f, 0.02783236f, -0.29334739f, 
    -0.10561774f, -0.03959098f, 0.17295714f, 0.33464241f, 0.06769302f, 0.56857848f, 0.34696934f, 0.00776213f, 
    -0.16175194f, -0.37612250f, 0.10288222f, -0.24765451f, 0.04269123f, 0.28392118f, -0.10966993f, 0.04163629f, 
    0.11581117f, 0.05244295f, 0.07259637f, 0.30854267f, 0.07060326f, 0.16625577f, 0.11295742f, -0.04340234f, 
    0.08887643f, 0.78263986f, -0.21798059f, 0.48287535f, 0.38112259f, 0.06229243f, -0.00960831f, 0.11645055f, 
    0.18742324f, 0.23750845f, -0.53259432f, 0.00564006f, -0.06566551f, -0.02837158f, 0.00205874f, 0.07627401f, 
    0.16050196f, 0.11175460f, 0.29690859f, 0.03151338f, 0.29223248f, -0.31330854f, -0.01025571f, 0.08492135f, 
    0.04600688f, -0.14319211f, -0.08830809f, 0.60352767f, 0.01550087f, -0.10644437f, -0.01369790f, 0.06354033f, 
    0.36787060f, -0.09176457f, -0.08304963f, -0.15300612f, 0.09643020f, 0.18305755f, -0.06068605f, 0.04384771f, 
    0.07696227f, 0.09591462f, 0.05965789f, 0.11909416f, 0.33537757f, 0.26144019f, 0.08372381f, -0.12646858f, 
    0.10215758f, 0.29075631f, -0.08174325f, -0.02617539f, 0.07975610f, -0.20420057f, 0.17069314f, 0.11107475f, 
    0.16085792f, 0.16815446f, 0.55037141f, 0.05702842f, 0.22102448f, 0.15204960f, -0.03710914f, -0.23296724f, 
    -0.17227848f, -0.32063860f, 0.37410071f, -0.10755375f, 0.05124826f, -0.09510043f, -0.02574149f, 0.04377265f, 
    -0.21609026f, 0.04068837f, 0.40638873f, -0.01058334f, 0.03834488f, -0.20027663f, -0.00226826f, -0.07763020f, 
    -0.13414201f, 0.21185544f, -0.05291008f, 0.01255825f, 0.00874324f, 0.13441584f, 0.05280100f, 0.29015583f, 
    0.02843461f, 0.45183900f, 0.05729378f, -0.34815720f, -0.05315569f, -0.06673510f, -0.14411078f, 0.07794241f, 
    0.04894358f, 0.24174358f, 0.14875761f, 0.06809375f, 0.00926482f, -0.18298921f, 0.02151047f, 0.23088348f, 
    0.15187371f, -0.14003691f, -0.24299866f, -0.16494897f, 0.05808181f, -0.39036357f, -0.02469323f, 0.16015142f, 
    0.10624908f, -0.06792210f, 0.01155156f, 0.20129000f, 0.13184050f, -0.39340279f, 0.16955601f, -0.09438749f, 
    -0.00967245f, -0.05843529f, -0.01448042f, -0.11299387f, -0.05699294f, -0.20151246f, -0.04636794f, 0.63653600f, 
    0.19753405f, 0.26230845f, 0.64808822f, -0.05451318f, -0.11159670f, 0.05908322f, -0.35730973f, 0.10623975f, 
    -0.16807784f, 0.07481965f, 0.18211678f, -0.08394342f, 0.22857891f, 0.10290160f, 0.02241160f, 0.30702630f, 
    -0.00176258f, -0.28773963f, 0.24001767f, -0.09807806f, -0.31126416f, 0.65614319f, -0.25223440f, 0.05571324f, 
    0.00029490f, -0.29151306f, -0.20633374f, 0.04121705f, 0.11525167f, 0.10703573f, 0.29390544f, -0.11776611f, 
    0.12126858f, 0.13315505f, -0.08031785f, 0.06010399f, -0.05166454f, -0.16248055f, -0.02646285f, -0.05440329f, 
    0.24256001f, 0.13156615f, 0.29542333f, -0.01320000f, -0.31736720f, 0.13409157f, -0.19317254f, 0.29066372f, 
    0.19275819f, -0.03740308f, 0.22225398f, 0.19786577f, 0.25396743f, 0.24133277f, -0.34880966f, 0.06607066f, 
    -0.00935742f, -0.23679344f, 0.03513931f, 0.06282134f, -0.11581352f, -0.11927701f, 0.07889284f, -0.19553183f, 
    0.20243591f, 0.01617703f, 0.10885447f, -0.54403037f, 0.44016728f, -0.07653731f, 0.25255200f, -0.11779788f, 
    0.24179628f, 0.38129953f, -0.06667060f, 0.08388109f, 0.27468491f, -0.15915646f, -0.01902240f, 0.01048103f, 
    -0.33413467f, 0.15525435f, 0.09318568f, -0.06911799f, 0.12817030f, -0.05029416f, 0.01375556f, 0.02393075f, 
    0.34310153f, 0.51039046f, 0.13957909f, 0.06228514f, 0.05603928f, -0.03716149f, -0.04000864f, -0.04089800f, 
    0.35982662f, 0.29425663f, 0.07323050f, 0.01422450f, 0.43854663f, -0.14254254f, 0.06618089f, 0.03858693f, 
    0.26765391f, 0.07120617f, -0.16049059f, 0.10312450f, -0.03289046f, 0.32081383f, -0.19294055f, -0.06830584f, 
    -0.16627532f, 0.52442682f, 0.03444052f, -0.10796488f, 0.33703107f, -0.44491893f, 0.05913158f, -0.08164904f, 
    0.31792289f, -0.21288121f, 0.23614293f, -0.23665385f, 0.04588419f, -0.23957971f, 0.10943273f, 0.20360668f, 
    0.00740166f, 0.34337541f, 0.85243767f, 0.98649603f, 0.03348916f, -0.51802588f, 0.03643617f, -0.04599209f, 
    -0.15431249f, -0.01069605f, 0.22754461f, 0.07408150f, -0.14555027f, 0.13690580f, -0.03692475f, 0.01966600f, 
    -0.05534406f, 0.08414575f, -0.51140416f, -0.02250874f, -0.36269370f, 0.24065237f, -0.26453614f, -0.08937895f, 
    0.33129129f, 0.08041003f, 0.04401309f, -0.05431553f, -0.11639549f, 0.08733474f, 0.04842974f, 0.02000958f, 
    -0.20998941f, 0.37208599f, -0.16525403f, -0.01365313f, -0.15262088f, -0.05620942f, 0.04471296f, -0.20444474f, 
    0.11871580f, 0.26482660f, 0.37951654f, -0.03774833f, -0.15015373f, -0.17044564f, -0.15261766f, 0.03664029f, 
    0.00349961f, -0.29906860f, 0.22203028f, 0.13392192f, 0.01096863f, 0.39676061f, -0.27075097f, -0.03956510f, 
    0.07643574f, -0.20647591f, -0.13703685f, -0.11670963f, 0.11629703f, -0.03734174f, -0.02052793f, -0.17675672f, 
    0.14635466f, -0.29447305f, -0.29372412f, 0.00201766f, 0.29099217f, 0.01454096f, -0.20569423f, 0.02542873f, 
    0.06536322f, 0.34479740f, -0.16988266f, -0.11254773f, 0.44347623f, -0.02592960f, 0.02310142f, -0.04193960f, 
    -0.11482151f, 0.01060926f, -0.17459008f, 0.09444383f, 0.23887821f, -0.09206651f, 0.19394542f, -0.10095370f, 
    0.28263658f, 0.45515108f, 0.05913124f, 0.19208223f, 0.06973582f, -0.04908673f, 0.07545616f, -0.19908795f, 
    0.21430394f, -0.14880601f, 0.24559708f, 0.30272481f, -0.02511880f, -0.03280821f, -0.04715917f, 0.02215890f, 
    0.13100880f, 0.01981948f, -0.18926933f, -0.05601407f, 0.42332622f, -0.06023965f, 0.31127137f, 0.23781051f, 
    0.31254110f, -0.02327402f, 0.14684713f, 0.35386053f, -0.07571613f, 0.30810443f, 0.30124262f, 0.01524971f, 
    0.00525549f, -0.05859558f, -0.00924042f, -0.03958117f, -0.06865354f, -0.11919068f, -0.02808896f, -0.10088698f, 
    -0.00684253f, -0.19987869f, 0.21019708f, -0.27202934f, 0.19196284f, 0.19809781f, -0.35706919f, 0.05531329f, 
    0.11117753f, -0.13911039f, 0.44956818f, 0.03180055f, -0.40442130f, 0.03843011f, -0.12540615f, 0.34760121f, 
    0.03876853f, -0.01325084f, -0.32578433f, 0.06080137f, 0.06048516f, 0.24103986f, 0.13561071f, 0.21177998f, 
    -0.14071698f, 0.17038892f, -0.05759183f, -0.59054363f, 0.15244295f, -0.09875481f, 0.05077045f, -0.17160457f, 
    -0.11277070f, 0.25439411f, 0.31512609f, -0.14050034f, 0.32213730f, 0.25283611f, 0.08684526f, 0.10385830f, 
    0.27091569f, 0.23795076f, -0.03367094f, -0.21307661f, 0.22298877f, -0.27235121f, -0.01692978f, 0.07840154f, 
    -0.14768191f, -0.16143581f, 0.00383570f, -0.09673597f, -0.34917039f, 0.27124968f, 0.06898342f, -0.06854683f, 
    0.23915002f, -0.15554671f, 0.08849394f, -0.17340310f, -0.04047395f, -0.20209551f, 0.06241016f, 0.22002664f, 
    0.12183394f, -0.32533476f, 0.13277060f, -0.24882872f, 0.43975580f, -0.26737699f, 0.18409219f, 0.00041167f, 
    0.28550649f, 0.08108287f, 0.13252006f, 0.04721256f, 0.33288988f, 0.01598301f, -0.02107072f, 0.10278910f, 
    -0.11895102f, 0.21365888f, 0.15491770f, -0.10918331f, -0.19230597f, -0.15724897f, -0.43845862f, -0.47895873f, 
    0.30912447f, -0.50045460f, -0.21383895f, 0.38127330f, -0.09021497f, -0.02289465f, 0.14319412f, -0.13978221f, 
    0.12932801f, -0.14086808f, -0.02073451f, 0.14255100f, -0.02638886f, 0.16360570f, -0.05142378f, -0.09397482f, 
    -0.00265160f, -0.05084807f, -0.11038829f, 0.11914829f, 0.22396576f, 0.75015038f, -0.03606112f, 0.07477549f, 
    -0.07511629f, 0.31792313f, 0.22067370f, 0.03219410f, 0.22702092f, -0.05937939f, 0.00772406f, -0.05506925f, 
    -0.11358926f, 0.11474769f, 0.04340309f, 0.18951115f, 0.11724865f, 0.01821102f, 0.03197530f, 0.06809226f, 
    0.09536821f, 0.27718714f, -0.07527187f, 1.05458069f, -0.54228878f, 0.17862596f, -0.05472333f, 0.04541788f, 
    0.01832460f, -0.15171389f, 0.02830739f, 0.00470419f, -0.28983036f, -0.07373165f, 0.07509927f, 0.00262697f, 
    0.06935134f, 0.09558789f, -0.16013128f, -0.11030954f, 0.05892506f, -0.15966153f, 0.10122801f, 0.22058465f, 
    0.02580969f, -0.08992919f, 0.19579008f, -0.04606420f, 0.03783166f, 0.04336064f, -0.14185336f, 0.24087550f, 
    -0.00946485f, -0.22243582f, 0.12831074f, 0.00561525f, 0.35707617f, 0.20047471f, -0.01554646f, -0.06918146f, 
    -0.27236855f, 0.03898663f, -0.33979359f, 0.24675186f, -0.02122443f, 0.41075024f, 0.20389311f, -0.20818600f, 
    -0.21824709f, 0.26085207f, -0.16976313f, -0.04426235f, 0.03335494f, -0.30874488f, 0.10604025f, -0.11915316f, 
    0.11414509f, 0.33434740f, 0.17707483f, 0.13785356f, 0.24873526f, 0.14648025f, -0.11150986f, 0.47726446f, 
    0.03484882f, 0.27140129f, -0.31451097f, 0.53992039f, -0.47183740f, 0.26604056f, -0.19026063f, 0.06654298f, 
    -0.10041016f, -0.12667172f, -0.14559792f, -0.09795924f, 0.01498856f, 0.28769988f, -0.03239476f, 0.10938293f, 
    0.28943315f, -0.26836255f, 0.16754135f, 0.09336706f, 0.10597424f, -0.39476505f, 0.12192218f, 0.02790426f, 
    -0.21795201f, -0.41830254f, 0.10742266f, 0.13237269f, 0.35832548f, 0.06819170f, 0.19387603f, 0.23041491f, 
    0.16642088f, -0.18897763f, 0.32157293f, 0.32187077f, -0.08019312f, 0.15321065f, -0.09110644f, 0.18493173f, 
    0.31320441f, -0.01929506f, -0.10459017f, -0.02983820f, 0.39409307f, 0.09758356f, 0.12921679f, 0.35881683f, 
    -0.05466585f, 0.09381733f, 0.01678168f, 0.40591890f, -0.12868345f, 0.43904179f, 0.10359772f, -0.10958149f, 
    0.00196743f, 0.08485676f, -0.03527820f, -0.05182285f, 0.07883801f, -0.25473177f, -0.09655064f, 0.12542169f, 
    0.23475532f, -0.34960094f, 0.11183155f, -0.18538514f, 0.34298220f, 0.08551348f, -0.03463358f, -0.10442828f, 
    0.24087304f, -0.12674379f, 0.22975554f, 0.09683960f, -0.69738835f, 0.04569835f, -0.03916596f, 0.02558145f, 
    -0.17494918f, 0.18329820f, -0.15605357f, -0.11923312f, -0.21926452f, 0.34699392f, -0.08903299f, 0.13048373f, 
    0.14265101f, -0.02593095f, 0.24357316f, -0.06359890f, 0.08855359f, 0.12882042f, -0.00888869f, 0.11719284f, 
    0.28338832f, 0.45683244f, -0.09033825f, 0.14645965f, -0.09243699f, 0.02882324f, -0.01204266f, 0.10196327f, 
    0.15704049f, 0.32264757f, -0.01167431f, -0.13343368f, -0.21395557f, -0.15767117f, -0.40183273f, 0.08827094f, 
    0.10798491f, 0.35757709f, 0.05157179f, -0.09402014f, 0.17381249f, -0.42053741f, -0.07260529f, 0.05538701f, 
    0.08439913f, -0.13412540f, 0.20541503f, -0.19398534f, -0.01946600f, 0.16568361f, 0.03332968f, -0.06321383f, 
    0.05782452f, -0.72705668f, 0.31444305f, 0.81980586f, -0.55766428f, -0.17198552f, -0.20875403f, -0.02335401f, 
    -0.17396477f, 0.06586414f, 0.15004133f, 0.04379813f, 0.31214800f, 0.04300192f, -0.01117462f, -0.01670633f, 
    0.11411715f, -0.13170950f, -0.37576881f, -0.06798105f, -0.08790846f, 0.17122301f, 0.07757573f, -0.02114525f, 
    0.37564874f, 0.23875260f, 0.24750197f, -0.20405014f, -0.01936149f, 0.04610415f, 0.07615889f, -0.05902855f, 
    -0.03915836f, 0.40201190f, 0.05710710f, 0.04544654f, -0.16375756f, 0.11947471f, -0.08258110f, 0.31586504f, 
    0.17196192f, 0.11202747f, 0.28121457f, 0.00053555f, -0.07392374f, -0.53853488f, -0.39369342f, -0.05593320f, 
    -0.06341704f, -0.21035568f, -0.09841762f, 0.25031173f, 0.06175331f, -0.15204701f, 0.02648933f, 0.02112459f, 
    0.03310648f, 0.00729474f, -0.14778756f, 0.09870358f, 0.05161063f, 0.23418006f, -0.06563810f, 0.14333609f, 
    0.09871946f, 0.24579857f, -0.58233404f, -0.19811410f, -0.17834619f, -0.04556319f, 0.02105095f, -0.04018570f, 
    -0.21473303f, -0.04316517f, -0.03843720f, 0.01681164f, 0.28515765f, 0.37047797f, -0.06842419f, -0.01593586f, 
    0.16260953f, -0.12167954f, 0.11438171f, 0.11465985f, -0.02457433f, -0.00880470f, -0.18011044f, -0.03928960f, 
    -0.02366622f, -0.06991494f, 0.23142071f, 0.13934222f, 0.26726395f, -0.05333392f, -0.00622481f, 0.13499431f, 
    -0.09732845f, 0.02394443f, 0.31396607f, 0.06037063f, -0.08398883f, 0.02845371f, 0.07942493f, 0.17232773f, 
    0.14966957f, -0.05641272f, 0.00227220f, -0.01404393f, 0.06935471f, -0.47529358f, 0.10396720f, 0.25062928f, 
    -0.25997034f, -0.12453821f, -0.20916322f, 0.27032569f, -0.28462565f, 0.31250507f, 0.10970623f, 0.09946263f, 
    0.01687746f, 0.08920097f, -0.18256171f, 0.06062876f, -0.03994131f, -0.00775714f, 0.09136388f, 0.31662580f, 
    0.19278058f, 0.16029750f, -0.09212483f, -0.29057994f, 0.17232844f, 0.05230227f, -0.17987782f, 0.02285983f, 
    0.11179999f, -0.17816177f, -0.16273698f, 0.13582411f, -0.26596513f, 0.20787777f, -0.02000567f, 0.10539738f, 
    0.19650716f, 0.01622209f, 0.36083511f, -0.00484452f, 0.01401211f, 0.05395556f, 0.02350683f, -0.07769623f, 
    0.05224850f, -0.36210626f, -0.02596157f, 0.20978884f, 0.26024711f, -0.07034118f, 0.09871942f, -0.00045861f, 
    0.00422817f, -0.08385801f, -0.03808016f, -0.14051528f, -0.00008123f, -0.11473542f, 0.02694225f, -0.08336046f, 
    -0.04706462f, 0.06209726f, 0.06888603f, -0.09929631f, 0.09223726f, -0.06466342f, -0.02162815f, 0.12226768f, 
    -0.13553913f, -0.10544953f, -0.09236597f, 0.01739934f, 0.04256510f, -0.10714733f, -0.05357510f, 0.03938936f, 
    -0.05975200f, 0.04565752f, 0.02472731f, -0.10145959f, 0.09135330f, 0.09978904f, -0.09985059f, -0.06658638f, 
    -0.13699530f, -0.06039472f, -0.07216856f, 0.11568671f, -0.01985519f, 0.04209311f, -0.06001034f, -0.04964423f, 
    -0.06865039f, -0.10702954f, -0.06735192f, -0.01827563f, 0.07427913f, -0.12662861f, 0.02611829f, -0.05718710f, 
    -0.02760835f, -0.11394463f, 0.01457171f, -0.05514786f, -0.03092742f, -0.07179208f, 0.01078564f, -0.10762661f, 
    -0.11350812f, 0.05259069f, -0.09547637f, 0.05393073f, 0.00515122f, 0.10080391f, -0.09469895f, -0.08506810f, 
    0.02101015f, -0.09684368f, -0.08200285f, 0.01928273f, -0.11218291f, 0.06336111f, -0.08083867f, -0.04564866f, 
    -0.05414753f, 0.04054892f, -0.03846088f, 0.07590014f, 0.12855037f, 0.09313480f, -0.08513971f, 0.09911079f, 
    -0.00096176f, -0.08471420f, -0.12247127f, 0.10956918f, 0.01127748f, -0.09615389f, -0.11921994f, -0.12464771f, 
    0.09105634f, 0.03101351f, 0.00699061f, -0.10745877f, -0.03534554f, -0.06267712f, 0.05454592f, 0.02857989f, 
    -0.01777175f, -0.10101669f, -0.06423739f, -0.12791738f, -0.02132152f, -0.09029585f, 0.02555688f, 0.10926099f, 
    -0.04463435f, -0.08036302f, -0.10566194f, -0.12068014f, 0.07784134f, 0.06931689f, -0.03323313f, -0.01402109f, 
    0.06549554f, -0.12438624f, 0.02613284f, 0.10750872f, 0.04034621f, 0.10475290f, 0.02588409f, -0.12499399f, 
    -0.07701186f, 0.01795499f, 0.03483852f, -0.09064899f, 0.02455422f, 0.12062207f, -0.10285274f, 0.10795593f, 
    -0.07574821f, 0.17716141f, -0.08192694f, 0.17555620f, -0.15365891f, -0.16777273f, -0.10108364f, 0.00884114f, 
    0.05470432f, 0.13658117f, 0.06213472f, -0.04401606f, 0.08564602f, -0.13643405f, 0.04903176f, 0.14447859f, 
    0.69735140f, -0.34437299f, 0.08196785f, 0.32752815f, -0.02828289f, -0.05012286f, 0.08929076f, 0.09010892f, 
    0.13329226f, -0.07524496f, -0.06087121f, 0.00520900f, -0.22066191f, 0.06140979f, 0.12282781f, -0.27610591f, 
    0.07456002f, -0.06046268f, -0.18646601f, -0.03539772f, 0.10777437f, 0.27476886f, -0.62302798f, 0.07862155f, 
    -0.19090129f, 0.26960430f, 0.31668460f, -0.05441429f, 0.40085423f, -0.18521939f, -0.02006818f, 0.42288658f, 
    0.14627425f, -0.28133246f, -0.20953725f, -0.04579015f, 0.24746242f, -0.05998900f, 0.24597326f, 0.36560524f, 
    -0.09945746f, 0.31074268f, -0.27722526f, -0.33427143f, -0.22269927f, -0.03441637f, 0.28205100f, -0.23948248f, 
    0.36033931f, 0.02642325f, -0.03443295f, -0.20209914f, 0.33613053f, -0.06516115f, -0.09154525f, 0.14791678f, 
    -0.03576961f, -0.12770525f, -0.15939885f, 0.20843294f, -0.17571877f, 0.44785580f, -0.19174218f, -0.20021635f, 
    0.31643566f, 0.38429201f, 0.18754493f, -0.16028833f, 0.52220118f, -0.51504743f, 0.08782045f, -0.05378824f, 
    0.22266471f, 0.24617749f, 0.54181111f, 0.07771636f, 0.00647948f, 0.23054527f, -0.03281796f, -0.12295222f, 
    -0.14214404f, 0.05224215f, 0.29869965f, 0.20128265f, -0.03051900f, -0.08105715f, 0.09309544f, -0.11241904f, 
    -0.14782976f, 0.32257608f, 0.39698237f, -0.00404863f, 0.48962292f, -0.16932322f, 0.03516422f, 0.07779758f, 
    0.06525537f, 0.12251373f, -0.24611837f, 0.03754145f, -0.02250323f, 0.01303021f, 0.00158937f, 0.23387128f, 
    -0.06533998f, 0.29580683f, -0.13624460f, -0.40499729f, 0.02566486f, -0.04781204f, -0.06720030f, 0.03935539f, 
    0.13822539f, 0.37386638f, -0.05730570f, 0.01516254f, -0.19398619f, 0.08829196f, -0.03388630f, 0.30270842f, 
    0.26005739f, 0.24920705f, 0.35781789f, 0.05576023f, -0.07323694f, -0.36550191f, -0.15786846f, -0.14155535f, 
    -0.03067234f, -0.27267477f, 0.09309871f, -0.06483977f, 0.39658585f, -0.48343882f, 0.19167548f, -0.10520458f, 
    0.16707410f, -0.06129959f, -0.04878011f, -0.10606532f, 0.06719585f, -0.04004687f, -0.09971818f, -0.13226931f, 
    -0.03612988f, -0.18295324f, 0.58615398f, -0.32214376f, -0.28951919f, -0.12962548f, -0.09973421f, 0.02336727f, 
    -0.23481007f, -0.00976374f, 0.14898217f, -0.01858735f, 0.33381903f, 0.40293124f, 0.05043249f, -0.13805991f, 
    0.08539043f, -0.01690137f, -0.14135395f, -0.02171096f, 0.03435021f, 0.04783244f, -0.08981091f, -0.07053941f, 
    0.27224705f, 0.30459881f, 0.06232262f, 0.01930310f, -0.05643900f, -0.06977238f, 0.05529753f, 0.13588873f, 
    -0.06905673f, 0.07453395f, -0.09259432f, -0.06078911f, -0.10015689f, -0.10633254f, 0.08404306f, -0.11090910f, 
    -0.04287428f, -0.09731483f, -0.14084388f, -0.00342555f, -0.05196075f, 0.08753379f, -0.13492024f, -0.08008053f, 
    0.05104484f, -0.01661773f, 0.09206691f, -0.03831390f, -0.06423327f, 0.07722366f, 0.00786275f, -0.00836253f, 
    -0.02061816f, -0.12903418f, 0.00101304f, -0.01954543f, 0.08987030f, 0.00694856f, 0.03693186f, -0.10966377f, 
    0.01949358f, 0.04048149f, -0.05716126f, -0.12053950f, 0.01890393f, 0.00635638f, 0.06372061f, 0.02907544f, 
    0.05696956f, 0.07962859f, -0.10809445f, -0.09935091f, -0.01614057f, -0.11296252f, -0.02832143f, 0.04701752f, 
    -0.15023012f, -0.06755692f, -0.08657541f, 0.07283543f, 0.01690064f, 0.04014964f, -0.02509040f, -0.10103506f, 
    -0.03381702f, 0.02720810f, 0.07484214f, -0.03006822f, -0.06415002f, 0.04529069f, -0.12841368f, -0.11614560f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03408621f, 0.37884018f, -0.35553852f, 0.07038748f, 0.07173903f, -0.04386294f, -0.12352233f, -0.15216294f, 
    0.04273186f, -0.01347387f, 0.15831356f, -0.02309727f, 0.12579967f, 0.05752122f, 0.42196807f, 0.05719933f, 
    -0.03714743f, -0.15221658f, 0.09288299f, 0.53027809f, 0.10200757f, 0.20441557f, 0.09384979f, -0.14471054f, 
    -0.05840557f, 0.14173426f, 0.07173463f, -0.03672291f, -0.10944988f, 0.14835294f, 0.26291305f, -0.21354683f, 
    0.18557498f, 0.04972081f, 0.03476765f, 0.10571004f, 0.03057460f, 0.47843242f, 0.11069699f, 0.32707480f, 
    -0.06612926f, 0.20428422f, -0.00283030f, 0.45452663f, 0.13737251f, 0.06545973f, -0.06380186f, 0.14355364f, 
    -0.11056793f, -0.14485766f, 0.08108398f, -0.34999785f, 0.22336452f, 0.05584615f, 0.24797639f, -0.10113063f, 
    0.25947517f, 0.13540259f, 0.08362417f, -0.00439752f, 0.00385988f, 0.01967325f, -0.13062786f, -0.02196883f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.09829742f, 0.17379504f, -0.37283185f, -0.09814623f, 0.01918216f, -0.12235167f, -0.03128275f, -0.46946633f, 
    0.01949193f, -0.02804150f, -0.45460585f, -0.64746261f, -0.49808228f, -0.06277001f, -0.08299289f, 0.10678066f, 
    0.07874289f, 0.07414519f, 0.02135604f, 0.03305006f, -0.48769224f, 0.16040562f, -0.20945273f, -0.03121567f, 
    -0.12630983f, -0.19373381f, 0.10711133f, 0.07571455f, -0.10033026f, 0.03416915f, 0.12725423f, -0.33798406f, 
    0.13609837f, -0.07528561f, 0.37440169f, 0.07123601f, -0.36462706f, 0.31396466f, 0.04244415f, 0.06005205f, 
    -0.12717226f, 0.25323105f, 0.10852502f, 0.11475883f, 0.13050844f, -0.12939505f, 0.27814144f, 0.03264973f, 
    -0.73112279f, -0.06238236f, -0.17157337f, -0.41186082f, 0.01063698f, 0.10028572f, 0.09782683f, -0.33557886f, 
    0.17597228f, 0.16242489f, -0.03655916f, 0.00802327f, -0.01840959f, -0.06900898f, 0.05237420f, 0.09667420f, 
    0.20623425f, 0.00618701f, 0.21671525f, 0.03158477f, 0.18672349f, 0.01763553f, -0.10664232f, 0.30311966f, 
    0.25759915f, -0.13697705f, -0.80030042f, -0.43989089f, -0.17175220f, 0.04814051f, 0.21742769f, 0.17112672f, 
    0.03842331f, -0.00729718f, -0.08433574f, -0.00190736f, 0.23883466f, -0.84480858f, -0.15968928f, -0.12233090f, 
    -0.05313037f, -0.32593489f, -0.12754065f, -0.14736074f, -0.02890603f, 0.08607784f, -0.03500720f, -0.13520426f, 
    0.24926515f, 0.23380059f, -0.26344147f, -0.04122041f, -0.22501929f, 0.26039660f, -0.06630204f, -0.07923932f, 
    -0.17984720f, -0.04589285f, -0.07567286f, -0.03845913f, 0.08784316f, 0.00222784f, -0.33003974f, -0.27171180f, 
    0.16973996f, -0.60630953f, -0.04071002f, 0.19206892f, 0.20156524f, 0.14874759f, 0.06293709f, -0.63633758f, 
    -0.22985199f, 0.02744626f, -0.10717548f, 0.11372962f, -0.50655001f, -0.03633167f, -0.55445802f, 0.12068632f, 
    -0.25288686f, -0.08126623f, 0.50866377f, -0.52558827f, 0.13843815f, 0.05713229f, -0.00995564f, -0.79679000f, 
    -0.22542799f, -0.20567213f, -0.68634313f, 0.59992808f, 0.34943631f, -0.16164826f, -0.17774169f, 0.20245944f, 
    -0.06197615f, 0.04529160f, 0.10498425f, -0.00526588f, 0.08975288f, 0.40485695f, -0.10108253f, 0.05896807f, 
    0.14261477f, 0.08710548f, 0.06522939f, -0.04506171f, -0.04591420f, 0.25952819f, -0.02184167f, 0.45094681f, 
    0.01033816f, -0.02954389f, -0.77426744f, -0.07222426f, -0.97365320f, 0.16368102f, -0.45819438f, -0.03917386f, 
    0.17500354f, -0.17707086f, -0.00789204f, 0.13826202f, 0.09508929f, 0.08705348f, -0.07024706f, -0.20608106f, 
    -0.28126535f, 0.12517390f, -0.79681545f, 0.09007525f, 0.05494733f, 0.23848072f, -0.88656938f, 0.23772725f, 
    0.12740876f, -0.48043397f, -0.13210152f, -0.09038709f, -0.05019263f, 0.29110038f, 0.35828602f, -0.03063020f, 
    -0.14702195f, -0.77875996f, 0.05522781f, 0.27840871f, -0.13469560f, -0.03074074f, 0.02271204f, 0.26661095f, 
    0.00043543f, 0.08385894f, -0.33323380f, -0.57829893f, -0.36701828f, 0.02355682f, -0.40440029f, -0.48606303f, 
    -0.05715962f, 0.25002927f, 0.06148169f, -0.31171483f, 0.27739865f, -0.00719941f, 0.05274718f, 0.02838161f, 
    -0.09858929f, 0.14923853f, -0.06182212f, -0.13504922f, -0.09365316f, -0.31756237f, 0.22000028f, -0.30213001f, 
    -0.52583587f, -0.32414100f, -0.07738615f, 0.08402071f, 0.08257485f, 0.12321552f, 0.15327847f, 0.29811352f, 
    0.19747224f, 0.16997994f, -0.07217149f, -0.05783476f, -0.36792424f, -0.11949062f, 0.25446278f, 0.08454117f, 
    0.11692219f, 0.07167207f, 0.11896127f, -0.14847097f, -0.18905070f, -0.84645110f, 0.00606615f, 0.09503357f, 
    0.04205882f, -0.11641754f, -0.07988153f, -0.05540074f, 0.30951706f, 0.24157533f, 0.06416041f, 0.08664744f, 
    -0.10036084f, 0.07756168f, 0.07664344f, 0.07860895f, -0.19102785f, 0.00486420f, -0.08271350f, -0.37425074f, 
    -0.05199818f, 0.19715415f, 0.29266679f, -0.28532058f, -0.13724649f, 0.14323628f, -0.25856376f, -0.00547311f, 
    -0.12428463f, 0.19894035f, -0.05295978f, 0.08777896f, -0.04246540f, 0.42985338f, 0.03730468f, -0.11340539f, 
    0.02363000f, 0.20182228f, 0.02288792f, 0.05759158f, 0.03779308f, 0.09937146f, -0.01178229f, 0.25978643f, 
    0.03486208f, -0.08673475f, 0.08789269f, 0.07295163f, -0.06375654f, -0.08936317f, 0.13980179f, 0.02349405f, 
    -0.10192670f, -0.03725617f, -0.14029454f, 0.15953584f, -0.21016750f, 0.10868416f, -0.05743661f, -0.03515856f, 
    -0.72599632f, 0.04617264f, 0.01434725f, 0.07722744f, -0.32717913f, -0.22381239f, 0.09266333f, -0.28030887f, 
    0.16849211f, 0.06181317f, 0.08412614f, 0.07408562f, 0.06744052f, -0.20058896f, 0.10961226f, -0.02915891f, 
    0.23980741f, 0.13248417f, 0.08378868f, 0.05331865f, 0.07915359f, 0.06940757f, 0.03468626f, 0.16800688f, 
    -0.07753956f, -0.28626102f, 0.31067848f, 0.11771743f, 0.17739554f, 0.01549576f, 0.04868586f, -0.09232190f, 
    0.09379216f, 0.11062141f, 0.06712914f, 0.12739214f, 0.20553549f, -0.83833289f, -0.32335913f, -0.05268687f, 
    0.24926814f, 0.09402262f, -0.07483302f, -0.13645820f, -0.10050303f, 0.11833401f, -0.05764683f, 0.34588721f, 
    0.15878817f, -0.01053757f, 0.11965807f, 0.02205255f, -0.05258770f, -0.08382870f, 0.00425855f, -0.60928732f, 
    -0.37421933f, -0.26439029f, 0.04973043f, 0.12166777f, -0.15997890f, -0.00250567f, 0.09783296f, -0.47705662f, 
    0.28907338f, -0.21460287f, 0.04068360f, 0.01851238f, 0.16802999f, 0.21535970f, 0.16214700f, 0.23995474f, 
    0.04976374f, 0.10342094f, -0.02650183f, 0.05255650f, -0.08648117f, -0.19092576f, -0.32184052f, 0.10713911f, 
    0.08091664f, 0.13426094f, -0.34219155f, 0.23046778f, 0.23320328f, 0.01905014f, -0.07304245f, -0.23139288f, 
    -0.18381771f, 0.03646033f, 0.15338489f, 0.13527992f, -0.28153580f, 0.02443274f, 0.02655903f, -0.03561767f, 
    -0.00292312f, -0.34522772f, -0.02223941f, 0.14059623f, -0.44216049f, -0.50404638f, -0.15837844f, -0.13156468f, 
    0.04935561f, 0.22851075f, -0.08237177f, 0.00194461f, -0.00612350f, -0.59473068f, -0.28852236f, -0.39671236f, 
    -0.35293850f, 0.08574580f, -0.65132183f, -0.09055261f, 0.59116501f, 0.07239525f, 0.14206934f, 0.34270447f, 
    -0.32893318f, -0.05655409f, -0.03913606f, 0.21921875f, 0.09126262f, -0.00969672f, -0.24383619f, -0.28389716f, 
    -0.31442881f, -0.08646820f, 0.16122808f, -0.60503483f, -0.00236604f, 0.26823378f, -0.01547759f, -0.17095335f, 
    -0.01573686f, 0.02554409f, -0.12805225f, -0.03438595f, 0.33673337f, -0.02925982f, -0.18452682f, -0.11914834f, 
    0.11035700f, -0.62685841f, 0.26211727f, -0.23207124f, -0.52244508f, 0.08453313f, 0.06942596f, 0.33085927f, 
    -0.35102862f, -0.16519712f, -0.36742333f, -0.28748646f, -0.48566672f, -0.26157480f, -0.57992214f, 0.21503843f, 
    -0.06786884f, 0.27941966f, -0.05846066f, -0.90160435f, -0.10973699f, 0.22938298f, -0.22926176f, -0.07121560f, 
    -0.02548149f, -1.04125202f, 0.01337347f, -0.00358754f, 0.11377697f, -0.10709684f, 0.02457654f, 0.30953991f, 
    0.02583367f, -0.55079663f, 0.25959140f, -0.10796334f, 0.22390756f, -0.78193647f, 0.09180375f, -0.18031760f, 
    0.03205611f, 0.08205703f, 0.01715742f, -0.62331915f, -0.08756339f, -0.34431589f, 0.18693328f, -0.03807985f, 
    0.34987539f, 0.20105195f, -0.01592937f, 0.39626920f, -0.44825536f, 0.36483166f, 0.20321341f, 0.09490454f, 
    -0.02597915f, 0.25352737f, -0.06732966f, -0.09493563f, -0.34014368f, -0.21589844f, 0.04754128f, -0.01623235f, 
    -0.31661290f, -0.93170094f, 0.08047601f, -0.31826308f, -0.09284603f, 0.07570904f, -0.00330282f, -0.40665108f, 
    0.30093807f, 0.28860810f, -0.22752483f, -0.84852856f, 0.41627002f, -0.88826752f, 0.21787998f, 0.01472058f, 
    -0.11172441f, -0.83064145f, -0.05392425f, -0.62298316f, 0.21914637f, -0.42865035f, -0.55857050f, 0.03800018f, 
    -0.20248036f, -0.69978106f, 0.07981107f, -0.07926443f, -0.06935781f, 0.10198489f, -0.58906204f, 0.38098821f, 
    0.27773476f, 0.06548747f, -0.37391981f, -0.02524081f, 0.34166402f, -0.27288795f, -0.32240885f, -0.29616043f, 
    -0.24525484f, 0.13731223f, -0.03058999f, -1.00309181f, 0.23491102f, 0.17631111f, -0.40408978f, 0.24430096f, 
    -0.15788895f, 0.10349113f, -0.16366835f, -0.15515533f, 0.02881267f, 0.01260973f, 0.10128342f, -0.25309032f, 
    -0.77478415f, -0.33430493f, -0.04314652f, 0.10762179f, -0.29046413f, 0.13082083f, -0.36339352f, -0.05506314f, 
    0.05358541f, 0.23346074f, 0.22420555f, 0.20007332f, -0.31863135f, -0.11067230f, -0.08222854f, 0.11756047f, 
    0.01557949f, -0.07082165f, -0.02362857f, 0.37472540f, 0.22575827f, 0.11841462f, -0.01713172f, 0.12075704f, 
    0.00582656f, -0.20735310f, 0.03416162f, 0.11672261f, 0.29280275f, 0.04467140f, 0.35320082f, 0.06355522f, 
    -0.18599972f, 0.11193158f, 0.00206468f, 0.07963076f, -0.00925419f, -0.17904539f, -0.18895921f, 0.35090870f, 
    -0.24463998f, 0.12971294f, 0.17528279f, -0.06548423f, -0.34609923f, -0.28648016f, 0.02961832f, -0.13914448f, 
    -0.30507994f, -0.35728323f, 0.02263277f, 0.20236331f, 0.16111454f, -0.32866520f, -0.23994586f, 0.19394326f, 
    0.23372337f, 0.51095575f, -0.09857105f, 0.12364342f, -0.05875420f, -0.27336526f, 0.06868295f, -0.28244001f, 
    0.19219555f, 0.05825858f, -0.08321410f, -0.06900858f, 0.13135116f, -0.68431348f, -0.24022666f, 0.02157074f, 
    -0.93563050f, -0.25192365f, -0.37401986f, -0.14729816f, 0.02505668f, -0.09475415f, -0.00951811f, -0.04899311f, 
    0.03784981f, -0.16092224f, -0.27867496f, -0.79081839f, 0.12287111f, 0.05042326f, 0.19512123f, -1.10779762f, 
    -0.12029052f, -0.30427960f, 0.05688664f, 0.15664147f, -0.02727995f, -0.17173557f, 0.42848042f, 0.00962126f, 
    -0.54948032f, -0.11480483f, -0.12321824f, 0.01994297f, 0.00319867f, 0.10064494f, 0.34778449f, -0.51146823f, 
    -0.06986048f, 0.01081827f, -0.05699036f, 0.11439986f, 0.08979986f, 0.42609662f, -0.04303290f, 0.37065884f, 
    0.16414230f, 0.08284199f, 0.04369856f, 0.10937341f, -0.66342229f, -0.04151895f, -0.13558337f, 0.15030295f, 
    0.01937713f, 0.08763508f, -0.08044567f, -0.45103562f, 0.10687799f, -0.16002253f, 0.05977707f, 0.17330104f, 
    0.12852781f, -0.23065375f, 0.10510955f, 0.10163614f, -0.00490629f, 0.08093863f, 0.13678244f, -0.10123171f, 
    0.22701339f, -0.04137845f, -0.52559072f, -0.01979323f, -0.02275264f, 0.09302674f, -0.06467299f, -0.50824225f, 
    -0.47158301f, 0.23575553f, 0.08318459f, 0.08902237f, 0.27466574f, 0.01943375f, -0.05085204f, -0.23361526f, 
    -0.06894486f, -0.33202618f, 0.05750643f, 0.05737878f, -0.67550910f, 0.26787233f, -0.36884314f, -0.09327155f, 
    0.28613356f, 0.00832599f, 0.03758137f, -0.03542467f, 0.01281205f, 0.19219634f, 0.04924539f, -0.37774137f, 
    -0.12330783f, 0.06143110f, -0.33261958f, -0.08818817f, -0.12333373f, -0.32130253f, -0.36367008f, 0.16701329f, 
    0.12262565f, 0.13006836f, 0.00928985f, -0.17666323f, -0.25573617f, 0.19253276f, 0.19857746f, 0.00337265f, 
    0.25984016f, -0.26272741f, 0.12904447f, -0.25967288f, 0.13286605f, -0.37918249f, 0.14223531f, 0.15981129f, 
    -0.42085370f, -0.36453107f, -0.14024577f, -0.08603535f, 0.10304902f, 0.16659786f, 0.15537524f, 0.07773122f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.36420134f, 0.05429578f, -0.31719953f, -0.19852501f, -0.08399951f, 0.26918828f, -0.02776063f, -0.36531129f, 
    -0.05179279f, -0.03455799f, 0.22166276f, -0.04944555f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
