#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.46934640f, -0.05784557f, -0.97990727f, 0.71863991f, 1.33009899f, -0.70500338f, 0.29711434f, -0.14219257f, 
    0.14892082f, 1.39672875f, 0.94693685f, 1.13678420f, -0.94787037f, -1.07374787f, 0.03174584f, -0.30219349f, 
    -0.00419041f, -0.09713145f, 1.11124444f, 1.70584524f, -0.26412240f, -0.44640797f, 1.01862884f, 0.85665196f, 
    -0.02938807f, 0.10136301f, 0.44999498f, -1.72881901f, 0.68290013f, -0.36370721f, 0.26540774f, 1.27376664f, 
    -1.14799702f, -0.46126166f, 0.31779414f, 0.40020820f, -0.42355973f, 0.48790449f, -0.54203641f, 1.25049627f, 
    1.38094532f, 0.72991598f, -0.20850725f, -0.61159325f, -0.22007163f, -0.44633651f, -1.63818896f, 1.07025933f, 
    0.63346601f, -0.66254884f, 0.95237726f, 0.11127774f, 0.07812919f, -0.13690409f, 1.18468559f, 0.74963367f, 
    1.11493659f, 0.84932214f, -1.17788839f, -0.23871438f, 0.55404568f, 0.51365197f, 0.34335738f, 0.71859622f, 
    1.09334266f, -1.35132325f, 0.64406562f, -1.20916057f, -0.74697989f, 0.03613053f, 0.64670193f, 0.37271300f, 
    1.60026836f, 0.61623728f, -0.97616875f, 0.48361596f, 0.51840711f, -1.10620928f, -0.25692588f, -0.33968121f, 
    -0.11390509f, 0.29189721f, 1.45937645f, 1.12636650f, 0.63253802f, 0.64296019f, 0.59501982f, -0.66930014f, 
    0.64191699f, -0.01721657f, -0.75468725f, -1.18688834f, 0.55832571f, -1.37895799f, -0.97262847f, -0.89240712f, 
    0.38236341f, 0.16292530f, -0.64464808f, -1.13560724f, -1.79389226f, -0.94893330f, -0.99915701f, 1.06459177f, 
    0.87289798f, -0.09815298f, -0.31939617f, -0.18272881f, 1.71681082f, 0.21772748f, -1.02663469f, -1.06843722f, 
    -0.34638235f, -0.14330763f, -0.33530548f, -0.35135388f, 0.45042980f, -1.45275140f, 1.19117260f, 0.35043138f, 
    -0.47473657f, 0.91162288f, 1.06262946f, -0.46677932f, 0.31890035f, 0.07985900f, -0.61206448f, -2.24344850f, 
    -0.87624615f, 0.91728890f, 0.70398223f, -0.02545030f, -0.11330549f, -0.08435331f, -0.09653173f, -1.68010306f, 
    0.85310906f, 1.54461229f, 0.73089087f, 0.72199005f, 0.37041584f, 0.10723327f, -0.26211357f, 0.07642550f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04663885f, 0.38471341f, 0.51638782f, 0.02680551f, 0.19850168f, 0.05133676f, 0.04418075f, 0.15397935f, 
    -0.01771065f, 0.39381281f, 0.53458506f, 0.06310244f, 0.00654848f, 0.14900337f, 0.52205873f, 0.26692444f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.49804702f, 0.22573690f, 0.23382665f, -0.20650095f, -0.12618561f, -0.11449324f, 0.00734460f, -0.12873515f, 
    -0.04209999f, -0.10754906f, 0.10282157f, 0.14287905f, -0.06698198f, 0.13148020f, 0.11490958f, 0.07846837f, 
    0.03396874f, -0.00565832f, -0.12748961f, -0.05504334f, 0.31256229f, 0.21918449f, -0.04728978f, -0.21650717f, 
    0.13851713f, -0.17905530f, -0.23923980f, -0.31858802f, 0.16585983f, -0.01731535f, -0.04455389f, -0.09972975f, 
    0.03686725f, -0.09469672f, 0.07033629f, 0.10122838f, 0.02047729f, -0.01998208f, 0.08819082f, 0.13235754f, 
    -0.24561803f, 0.00827146f, -0.05442669f, -0.61333215f, 0.41305852f, -0.22565797f, -0.06799360f, -0.09542074f, 
    0.18058677f, -0.02680276f, -0.05159418f, -0.03887959f, 0.12467924f, 0.02235033f, 0.13660684f, -0.16962835f, 
    0.02400742f, -0.02615027f, -0.07512993f, 0.00849689f, 0.66220319f, 0.05883860f, 0.23548490f, -0.20254663f, 
    -0.13973179f, -0.04447889f, -0.00361759f, 0.04389975f, -0.04843884f, -0.03102475f, 0.07398032f, 0.13147341f, 
    -0.14265428f, 0.03430279f, 0.02876417f, -0.14542527f, -0.20310847f, 0.03239808f, -0.09497590f, -0.01728916f, 
    0.42202532f, 0.19161035f, 0.27119023f, -0.21346530f, -0.08330850f, 0.15279271f, 0.16242193f, -0.04029018f, 
    0.03564297f, -0.14197479f, -0.01629550f, 0.04445320f, -0.12219245f, -0.07926339f, 0.06252876f, 0.02239193f, 
    0.24861945f, -0.06009495f, 0.05982802f, 0.05429547f, -0.07993069f, -0.22477029f, 0.10773993f, -0.01280885f, 
    -0.73572206f, -0.01254893f, 0.25261277f, 0.04927807f, -0.04413690f, 0.04477399f, 0.00395232f, 0.06684581f, 
    -0.10453185f, -0.01606537f, -0.07164430f, 0.03316328f, -0.10911880f, -0.02167086f, 0.05459768f, -0.05043679f, 
    0.14487463f, -0.22036643f, 0.19184378f, -0.42911679f, -0.20671636f, -0.26318601f, -0.11752210f, 0.09169728f, 
    0.00947889f, -0.02321355f, -0.03825031f, 0.01916974f, -0.11469208f, 0.07920245f, -0.11147299f, 0.06158285f, 
    -0.06859580f, 0.11015892f, 0.00378342f, -0.05162184f, 0.06864596f, -0.16949265f, 0.32137886f, -0.39830729f, 
    0.26666534f, -0.22862720f, -0.02817932f, -0.02211768f, -0.04137956f, -0.08226115f, -0.23474579f, 0.02110621f, 
    0.05811730f, 0.10141958f, -0.01616399f, 0.09227891f, -0.01028540f, 0.15248996f, -0.00953297f, -0.01855016f, 
    -0.08854511f, -0.12040289f, 0.09887723f, 0.17564765f, 0.65808201f, -0.35602859f, -0.15875491f, 0.02488914f, 
    0.11549189f, 0.04280244f, -0.02902866f, 0.18383321f, 0.04468394f, -0.10775217f, -0.15499996f, 0.05213914f, 
    -0.06178033f, 0.02948431f, -0.03979809f, -0.05323030f, -0.28850669f, 0.16221921f, 0.02783330f, 0.01174079f, 
    0.24335672f, -0.11019906f, -0.16171591f, 0.03342907f, -0.02357830f, -0.02735233f, 0.03898251f, -0.13086417f, 
    0.00402304f, 0.05644163f, -0.06052645f, -0.10531491f, 0.10877915f, -0.06873269f, -0.18903439f, -0.07076478f, 
    -0.06252456f, -0.74126166f, -0.26968029f, 0.10618392f, -0.27414039f, -0.14948897f, -0.24372855f, 0.02478587f, 
    0.04900126f, -0.01803849f, -0.08676025f, -0.04869484f, -0.26128304f, -0.12187588f, -0.18643776f, 0.03262231f, 
    -0.00429022f, 0.06029597f, -0.04477596f, 0.13166675f, -0.60086638f, 0.38923582f, -0.20384207f, -0.17128402f, 
    -0.42064837f, 0.09874223f, 0.17198308f, 0.00390230f, 0.13510481f, 0.02480321f, 0.04972642f, 0.07753389f, 
    -0.03649712f, 0.20223391f, 0.05825605f, -0.08576728f, -0.15144730f, 0.06775481f, 0.03383289f, -0.02461953f, 
    -0.09544154f, -0.18580072f, 0.21010680f, 0.31728503f, 0.25308564f, -0.19295160f, -0.13519229f, -0.07936190f, 
    0.11147812f, 0.06714762f, 0.03113429f, -0.03944219f, 0.15135832f, 0.10398861f, -0.04980532f, 0.10679906f, 
    -0.08890822f, -0.15354754f, 0.17189999f, -0.10135759f, 0.12877916f, 0.21151544f, 0.19801401f, -0.05028199f, 
    0.32365811f, 0.05478271f, -0.06243776f, 0.08129712f, 0.14664115f, -0.18726517f, 0.01526865f, -0.06096499f, 
    -0.12926814f, -0.11648931f, -0.02046848f, 0.00731180f, -0.02513898f, -0.03958803f, 0.16051406f, -0.03850483f, 
    -0.14794438f, -0.16262445f, -0.15499039f, -0.11685954f, -0.45478630f, 0.16174246f, 0.01702766f, 0.08281603f, 
    0.05658242f, -0.10053983f, -0.04493856f, -0.07497448f, 0.09901412f, -0.06164897f, 0.03374451f, 0.12843475f, 
    0.09952627f, -0.06472776f, -0.12877579f, 0.14683321f, 0.16282225f, -0.10420749f, 0.39562869f, 0.11491715f, 
    0.11158833f, -0.22323865f, 0.01577261f, 0.07353104f, 0.08472551f, 0.03805585f, 0.01251920f, -0.12086936f, 
    0.15962362f, -0.10111926f, -0.04297974f, 0.05315082f, -0.24149609f, -0.11819586f, 0.10538115f, -0.01393315f, 
    -0.21383364f, -0.17560196f, -0.40419155f, -0.06094826f, -0.05430007f, -0.00912901f, 0.00989505f, -0.08273965f, 
    -0.01448917f, 0.11471906f, -0.00804753f, -0.00196097f, -0.07837398f, -0.13083336f, -0.08629391f, 0.06995263f, 
    -0.05685052f, -0.07754877f, 0.03484731f, 0.04436744f, 0.23444226f, 0.08114146f, -0.09677033f, 0.14020820f, 
    -0.11663102f, 0.15085112f, -0.14995125f, 0.14525343f, 0.04222007f, 0.02367763f, -0.05577113f, -0.06803167f, 
    -0.04284861f, 0.06285533f, 0.02922209f, 0.13198180f, -0.15930760f, -0.01607140f, -0.16796990f, -0.05161482f, 
    0.63000560f, 0.38160473f, 0.10684412f, 0.06373700f, 0.16090694f, 0.02868175f, -0.04827746f, -0.07382396f, 
    0.03931430f, -0.11130107f, 0.07114331f, 0.05048514f, -0.07449105f, 0.14617451f, -0.06445131f, -0.10720398f, 
    0.08632028f, 0.10809594f, -0.08909603f, 0.00408199f, -0.80895978f, -0.23154084f, -0.28942692f, -0.09657205f, 
    0.31687430f, -0.17587471f, -0.03977272f, -0.02493060f, 0.00363592f, 0.22495642f, 0.05203356f, -0.12439522f, 
    0.10626884f, -0.08114477f, -0.07801533f, -0.01328681f, 0.00340093f, -0.02852369f, 0.04499735f, -0.19672066f, 
    -0.15377560f, -0.02144239f, -0.04185088f, 0.04335456f, 0.05622042f, 0.00731341f, -0.06813519f, -0.17405845f, 
    -0.12473978f, -0.06733792f, 0.23137222f, 0.16794702f, -0.01278263f, -0.03258687f, 0.04566770f, -0.03172750f, 
    0.11338232f, 0.01709794f, -0.02123841f, 0.07558345f, -0.17960410f, 0.16935849f, -0.02731719f, 0.10691564f, 
    -0.57118255f, 0.03946930f, 0.00167603f, 0.05744399f, 0.12751982f, 0.23334017f, 0.10021000f, 0.01439487f, 
    0.04904600f, 0.06866290f, -0.01648182f, -0.05592119f, 0.15422480f, 0.00115328f, 0.08023859f, 0.07640292f, 
    -0.04623934f, 0.16867331f, 0.30359185f, 0.08624260f, 0.34746969f, -0.11039549f, -0.16730772f, -0.00729149f, 
    0.00123738f, 0.03458962f, 0.07100143f, 0.02364165f, 0.20647582f, 0.05145527f, -0.12743428f, -0.20699780f, 
    0.08921117f, -0.15840769f, -0.02452290f, 0.11741035f, -0.15908346f, -0.39456341f, 0.08699788f, -0.19052137f, 
    0.26546571f, 0.13367975f, -0.27874067f, 0.20765844f, 0.02636821f, -0.02327390f, 0.12473278f, 0.11220696f, 
    0.05752132f, -0.14517912f, 0.08796365f, 0.02198075f, 0.08579561f, -0.25429085f, 0.11843303f, -0.16462713f, 
    0.50753313f, -0.47736844f, 0.18540491f, -0.36990619f, -0.07721114f, -0.17438827f, -0.26936793f, -0.19055150f, 
    -0.03162637f, -0.02030192f, -0.20251082f, -0.20437862f, -0.03524474f, 0.02171939f, 0.12573832f, -0.22194067f, 
    -0.04167230f, -0.22179313f, 0.12244482f, -0.01656420f, 0.34343639f, 0.53635156f, 0.10216156f, 0.09415996f, 
    0.39005646f, 0.03844265f, 0.02226198f, -0.00560053f, 0.02147206f, 0.11753823f, -0.06899872f, 0.09841590f, 
    0.02302802f, -0.12531228f, 0.00403231f, 0.04265513f, 0.05749482f, 0.03490313f, 0.06676501f, -0.00518591f, 
    -0.23578563f, 0.03151868f, 0.00530704f, -0.00474668f, -0.37963933f, 0.14721459f, 0.06978189f, 0.04135214f, 
    0.15176208f, -0.01665034f, -0.08338369f, -0.10116854f, 0.14519350f, 0.18780853f, 0.02795128f, -0.11899652f, 
    0.11433558f, -0.13356617f, -0.28885317f, -0.17484777f, 0.45654452f, -0.20782228f, -0.12646635f, 0.14587404f, 
    -0.33161652f, -0.25818306f, 0.13545370f, -0.04790164f, 0.11269061f, 0.10814545f, 0.02318682f, -0.05136522f, 
    -0.05856106f, 0.07434624f, -0.04749666f, 0.07591147f, 0.04585168f, 0.07663377f, -0.27595931f, 0.02168259f, 
    0.48176593f, -0.59829223f, -0.07428753f, -0.37085837f, -0.24081272f, -0.03474103f, -0.17202233f, 0.02714619f, 
    0.05448023f, -0.06932915f, -0.18964547f, 0.05257870f, -0.25675926f, 0.08213799f, -0.06445202f, -0.11508200f, 
    -0.32870671f, -0.17418128f, -0.07840586f, -0.06078091f, -0.54082221f, 0.20954780f, -0.13168420f, -0.27963307f, 
    -0.14903121f, 0.07409690f, 0.15339425f, -0.05715518f, -0.09093761f, -0.13031201f, 0.01055222f, -0.01475019f, 
    0.08988495f, -0.03399177f, -0.02905482f, 0.00923977f, 0.03880766f, 0.12405378f, -0.01556726f, 0.04927762f, 
    0.46716040f, 0.03358472f, -0.30300778f, 0.01565744f, -0.39599791f, -0.00692521f, 0.17281398f, 0.02020151f, 
    -0.10147182f, 0.11280148f, 0.09736915f, 0.01351231f, -0.04139745f, 0.18442768f, -0.13732158f, 0.03099731f, 
    0.19139284f, -0.06947272f, 0.03512112f, -0.08248877f, -0.45015207f, 0.17361283f, -0.02027772f, -0.04317896f, 
    0.06663775f, -0.01589754f, 0.18596140f, 0.09505247f, -0.05233704f, -0.16391450f, -0.13204817f, 0.04504576f, 
    0.07577571f, -0.00609784f, -0.06860263f, 0.16086920f, -0.24904117f, 0.06948442f, 0.06806452f, 0.04162466f, 
    0.44268644f, -0.01463862f, 0.28466851f, -0.08280447f, 0.14841883f, 0.22413301f, -0.09694013f, -0.11899801f, 
    0.12809539f, 0.11501557f, 0.07540701f, -0.02581007f, -0.03201734f, -0.01705153f, -0.01188238f, 0.08695712f, 
    -0.07306959f, 0.05607613f, 0.00395732f, 0.03844963f, -0.48959774f, 0.33971921f, -0.20279318f, -0.12293797f, 
    0.17161170f, 0.04013590f, 0.13066861f, 0.08197451f, -0.06108853f, -0.25542334f, -0.16093148f, 0.00996059f, 
    -0.06195294f, 0.00722426f, -0.19240525f, -0.18219531f, -0.02145636f, 0.08592320f, -0.09139694f, -0.17995884f, 
    0.11691928f, 0.14537531f, -0.08363081f, -0.04115155f, 0.02365800f, -0.04232093f, -0.01303357f, 0.25386989f, 
    -0.01657886f, -0.01839718f, -0.06315124f, -0.02929996f, 0.21627933f, 0.00385414f, -0.12024698f, -0.02026465f, 
    -0.13927051f, 0.08750831f, -0.02394430f, -0.12550846f, 0.47237641f, -0.19939052f, -0.14206420f, -0.41567266f, 
    -0.09010557f, 0.16684401f, 0.06341554f, -0.26953518f, 0.00914727f, -0.01134155f, 0.06657492f, 0.04148338f, 
    0.02181389f, -0.04789528f, 0.02762248f, -0.07629430f, -0.13832359f, -0.00383752f, -0.03899013f, -0.11064649f, 
    0.30022216f, 0.27054629f, 0.18879144f, 0.12372620f, 0.28375646f, 0.08037484f, -0.15208913f, -0.11388829f, 
    0.23557687f, 0.33753753f, 0.04453048f, -0.08757656f, 0.05008020f, 0.04759984f, -0.19031315f, -0.05307017f, 
    -0.10914887f, 0.00737328f, -0.08687932f, -0.04991781f, -0.42275497f, 0.04010562f, 0.09730475f, -0.12542510f, 
    -0.00984474f, -0.26575407f, -0.08871588f, -0.11452315f, -0.09661281f, -0.27548739f, -0.03872085f, -0.07653870f, 
    0.09116486f, -0.12969147f, 0.08792993f, 0.07156249f, 0.00792881f, 0.00306987f, 0.06588567f, -0.00724827f, 
    -0.15949717f, 0.15544446f, 0.17987949f, -0.10083316f, 0.01483227f, 0.10800432f, 0.17261443f, 0.05250737f, 
    -0.13260546f, -0.06300458f, -0.16013952f, 0.02846487f, -0.05595067f, -0.16658807f, -0.00670730f, 0.09513851f, 
    -0.06281948f, -0.05628584f, -0.25724825f, 0.09964055f, -0.17009281f, -0.20029265f, -0.00018605f, -0.47929782f, 
    -0.45810050f, 0.04863502f, -0.20005718f, 0.12263755f, -0.12401458f, -0.04785376f, -0.06710850f, 0.03054121f, 
    0.07020748f, -0.24557917f, 0.01004428f, 0.16535674f, 0.12754889f, 0.17812212f, 0.01935411f, -0.04795062f, 
    0.34107259f, -0.68850350f, 0.01872376f, -0.36021978f, -0.21498308f, 0.01939918f, -0.18995503f, 0.05517601f, 
    0.05184893f, 0.14791803f, -0.07959073f, 0.07243055f, 0.03528899f, -0.01072953f, -0.02902409f, 0.00612895f, 
    -0.09764291f, 0.19366427f, 0.02118444f, -0.10038455f, 0.23753561f, -0.14396529f, -0.09750042f, 0.00427540f, 
    -0.14510328f, -0.07319009f, 0.04693170f, 0.07929130f, 0.00398709f, 0.01190510f, -0.01453676f, 0.01441477f, 
    -0.01858412f, 0.08807778f, 0.08212092f, -0.10335679f, -0.20640904f, -0.04510076f, -0.08125117f, 0.04285413f, 
    0.44758704f, -0.55109936f, -0.25172541f, -0.22186299f, -0.64763004f, -0.11306562f, 0.02354551f, -0.14335978f, 
    0.07392944f, -0.17880891f, -0.00731311f, 0.03043575f, 0.05534313f, -0.02216869f, -0.12613711f, 0.01087585f, 
    -0.06670266f, 0.01140082f, 0.09409042f, -0.23702349f, 0.79009587f, -0.20670447f, -0.03213504f, 0.31286851f, 
    0.14725935f, -0.28884187f, 0.04087629f, -0.23694341f, -0.00995508f, 0.05078901f, 0.18806373f, 0.09522101f, 
    0.12011751f, 0.06760922f, -0.08835384f, -0.01789783f, -0.09217569f, 0.03848151f, 0.03477018f, -0.02990205f, 
    -0.21313782f, -0.22779134f, -0.24227501f, -0.30678579f, -0.32387376f, 0.00175046f, -0.03949607f, 0.24101602f, 
    0.06708197f, 0.11311579f, -0.02570330f, 0.00319173f, 0.00617229f, -0.10949286f, -0.08774417f, -0.03773382f, 
    0.01096398f, 0.06504005f, 0.13329497f, 0.11348912f, 0.41540632f, 0.17180267f, -0.42721379f, -0.04904420f, 
    0.01258392f, -0.10202076f, -0.03872541f, 0.11256257f, 0.08059047f, 0.07507709f, -0.14486121f, 0.03715345f, 
    0.05753495f, -0.05132627f, -0.06312463f, 0.06232594f, -0.06751519f, -0.14804746f, -0.07694911f, 0.06863866f, 
    0.07631179f, -0.30838469f, 0.26605093f, 0.11540514f, 0.31945112f, -0.29971623f, -0.19913198f, -0.22467817f, 
    -0.04765070f, 0.09241193f, 0.18553613f, -0.16886549f, -0.03994476f, -0.03507899f, 0.08936258f, -0.05108702f, 
    0.04650192f, -0.05882584f, 0.02885376f, -0.03734117f, 0.56466866f, 0.02086306f, -0.14752413f, -0.00862671f, 
    0.02121510f, -0.07121782f, -0.00493700f, 0.14529604f, 0.09294895f, -0.05127356f, -0.00616037f, 0.03095010f, 
    0.06114129f, 0.08458574f, 0.11989066f, 0.08277702f, -0.11382063f, -0.17735723f, -0.03868511f, -0.07906668f, 
    -0.06599560f, 0.17709684f, -0.32227251f, -0.02381893f, 0.04063803f, 0.03866683f, -0.06633504f, 0.12215336f, 
    0.03000784f, -0.18893266f, -0.09306686f, -0.11343518f, 0.02019562f, 0.21808097f, -0.09193476f, -0.08082195f, 
    0.02939053f, 0.02462040f, 0.00074769f, -0.10291741f, -0.11578964f, -0.53942019f, -0.31180289f, 0.18966113f, 
    0.42428845f, 0.07807091f, 0.08278242f, 0.15270981f, -0.03923699f, -0.19461523f, 0.00401838f, -0.00327183f, 
    -0.04563662f, -0.00492290f, 0.06529336f, -0.07817702f, 0.00276593f, 0.00737333f, 0.00427704f, 0.00244037f, 
    -0.16480647f, -0.75940871f, -0.38850436f, -0.17545100f, 0.02235054f, -0.24012944f, -0.13743524f, -0.11134955f, 
    0.07979192f, -0.03643854f, -0.06783897f, 0.07072867f, 0.08950123f, 0.03822788f, 0.00033764f, -0.03882368f, 
    -0.06691045f, -0.14561647f, -0.05704829f, 0.04217542f, 0.49103338f, 0.58602035f, 0.05084638f, 0.15008166f, 
    0.04731267f, 0.10461650f, 0.00224956f, -0.10189248f, 0.00039904f, 0.02445956f, -0.10757900f, 0.02452842f, 
    -0.05222385f, 0.19611764f, -0.14301084f, -0.13631666f, 0.02320806f, -0.10342661f, 0.12947254f, 0.05881041f, 
    -0.47334296f, -0.05286456f, -0.16947630f, -0.15990658f, -0.35725269f, -0.07636615f, -0.00825888f, 0.08907653f, 
    -0.03359333f, -0.01053404f, -0.15030193f, -0.16957942f, 0.10108213f, -0.05540125f, -0.03111629f, 0.01673681f, 
    -0.05829273f, 0.02408751f, 0.06401286f, 0.14809328f, 0.56827265f, -0.06937563f, 0.25405598f, -0.14934850f, 
    -0.04923720f, -0.02788446f, 0.11161163f, -0.04766179f, -0.16132861f, -0.04093491f, -0.01636554f, 0.02499262f, 
    0.04884388f, 0.09176306f, -0.08096889f, -0.08469553f, 0.09742190f, 0.08230072f, 0.05456915f, -0.02607156f, 
    -0.07974169f, -0.65170705f, -0.36370340f, 0.44535297f, 0.15858069f, 0.04464008f, 0.09363057f, 0.09431738f, 
    0.15907115f, -0.18505795f, -0.02465766f, 0.05654310f, -0.21411157f, -0.24289256f, -0.01590900f, -0.06553399f, 
    0.03740770f, 0.19686100f, -0.13316855f, -0.15585046f, 0.28636530f, 0.07774440f, -0.12791061f, 0.36954316f, 
    0.11008336f, 0.04949526f, 0.09159991f, -0.02553024f, 0.17428730f, 0.11913835f, 0.03246246f, 0.00640718f, 
    -0.26754346f, 0.02710860f, 0.04297952f, -0.00815268f, 0.04418711f, 0.09828448f, -0.06372816f, 0.10357702f, 
    -0.03304967f, -0.31357455f, 0.14962322f, -0.07133304f, 0.01051611f, -0.12079994f, 0.02217832f, 0.01761175f, 
    -0.00103477f, 0.08757301f, -0.11790196f, -0.15332332f, -0.11171599f, 0.16277298f, -0.06382719f, 0.03895843f, 
    0.01049783f, -0.01107330f, 0.04080596f, 0.03203437f, -0.28037864f, -0.95937645f, -0.16856098f, -0.19222853f, 
    -0.09499662f, -0.18989769f, -0.07361048f, 0.14194098f, 0.09715371f, -0.22852987f, -0.10508469f, -0.02510845f, 
    -0.05853471f, 0.04433101f, 0.09174434f, 0.13242115f, 0.03363163f, 0.02340658f, 0.01523056f, 0.08762162f, 
    -0.19940391f, 0.53284264f, 0.33522835f, 0.34945068f, -0.00237190f, 0.07032813f, -0.00952186f, -0.00730524f, 
    -0.15014508f, 0.09396487f, -0.07101571f, -0.02222287f, -0.00981472f, -0.03648961f, -0.08326303f, -0.07043347f, 
    0.14700113f, 0.10741845f, 0.23676853f, -0.13962129f, -0.10018080f, -0.11842902f, 0.14905711f, 0.09225188f, 
    -0.19935697f, -0.11916058f, -0.30027270f, 0.15795587f, -0.01251449f, 0.04698132f, -0.16095908f, 0.06304032f, 
    -0.10537262f, 0.00013195f, 0.12135942f, 0.05799941f, 0.12448173f, 0.10634118f, 0.16086376f, -0.09194402f, 
    0.19885151f, -0.21743986f, 0.33623421f, -0.16772331f, 0.17286959f, -0.09724804f, 0.11991693f, 0.01031963f, 
    -0.00948071f, 0.03574484f, 0.21199650f, 0.00643058f, -0.09302698f, -0.11205981f, -0.01334194f, 0.07634982f, 
    -0.12534586f, 0.00406912f, 0.10451227f, 0.15515999f, -0.66254854f, 0.47297460f, 0.15998279f, -0.31295520f, 
    -0.07974851f, -0.08293466f, 0.04271349f, -0.11331610f, 0.19001514f, -0.00793341f, 0.10219335f, -0.02573481f, 
    -0.15349089f, -0.02376096f, -0.00449458f, -0.04390495f, 0.05116349f, -0.22062515f, 0.13385627f, 0.03117096f, 
    0.13511799f, 0.00105849f, -0.10647709f, -0.09504485f, -0.11183098f, -0.08506966f, -0.11293365f, -0.10621707f, 
    0.03021560f, -0.04216360f, -0.06264308f, -0.03222473f, 0.03907530f, -0.02182363f, 0.17611809f, -0.10252578f, 
    -0.06391799f, 0.05109725f, -0.10192823f, 0.05255038f, -0.33009195f, 0.05573428f, 0.18521060f, -0.26676339f, 
    -0.09477311f, 0.08463932f, -0.14024243f, -0.03105985f, 0.13921408f, -0.06069732f, 0.24705118f, 0.00869229f, 
    0.05220307f, -0.07346190f, -0.09114071f, -0.14441387f, 0.03523610f, -0.05186882f, 0.03452993f, 0.06316274f, 
    -0.59398156f, -0.18404163f, 0.12144134f, -0.07889306f, 0.09599414f, -0.04630898f, -0.02916824f, 0.15328342f, 
    -0.16113050f, -0.03427521f, -0.07261318f, -0.03081797f, 0.10997012f, 0.01306142f, -0.09222150f, 0.10962132f, 
    0.03376336f, 0.17408504f, 0.13469076f, 0.12292597f, -0.02505068f, -0.52606624f, 0.37699676f, 0.32740095f, 
    0.03698613f, -0.18793903f, 0.07072299f, -0.04670860f, -0.05399502f, 0.08299617f, 0.16766626f, 0.14396514f, 
    -0.01574250f, -0.27915388f, 0.00630604f, -0.04808008f, 0.12148305f, 0.00270482f, 0.08618394f, 0.10214087f, 
    0.33383331f, -0.51749408f, 0.15091830f, -0.06971883f, -0.06858686f, -0.03281711f, -0.06470274f, 0.08008116f, 
    -0.07751950f, 0.04142530f, -0.04028910f, 0.10288648f, -0.15188497f, -0.02130000f, -0.07201974f, 0.16022937f, 
    0.00111437f, -0.13716726f, 0.16075574f, -0.21713117f, -0.52213585f, 0.29590589f, 0.18814862f, -0.44278130f, 
    -0.41044307f, 0.19248165f, -0.01854244f, 0.03257718f, -0.13720691f, 0.02282774f, 0.13557051f, -0.02027774f, 
    -0.06359093f, -0.02376279f, 0.07920501f, -0.16274518f, 0.12527752f, 0.06172278f, 0.00751878f, -0.02461007f, 
    -0.44519341f, -0.46104157f, -0.06393176f, 0.22716689f, 0.15745573f, 0.11583512f, -0.09142901f, 0.11044213f, 
    -0.01378611f, 0.00807205f, 0.01407773f, -0.03611109f, 0.11481505f, 0.19859013f, 0.11483523f, -0.00742825f, 
    0.03567391f, 0.08299348f, 0.08629551f, -0.11457757f, -0.01192217f, -0.16703686f, -0.03679757f, -0.36553028f, 
    0.20230199f, 0.08894885f, 0.02097067f, -0.01678255f, 0.09399630f, -0.09440894f, 0.02050226f, 0.08343078f, 
    0.02132872f, 0.02509095f, -0.24518225f, -0.08887752f, -0.22178629f, -0.43613905f, -0.02284139f, 0.05218217f, 
    -0.49293917f, -0.30952734f, 0.16228721f, 0.05072846f, 0.10484592f, -0.08389510f, -0.00134445f, -0.35340726f, 
    -0.06936596f, 0.11917970f, -0.00176385f, -0.15384436f, 0.09631591f, -0.00155711f, 0.01916577f, -0.14508110f, 
    -0.17966101f, -0.14616784f, 0.01198963f, -0.05634750f, -0.24690334f, -0.28214917f, -0.14436667f, 0.10253135f, 
    -0.38278055f, -0.11470587f, -0.02139247f, 0.05846443f, -0.08417963f, -0.13470671f, -0.19064373f, -0.16043141f, 
    0.05643547f, 0.10468321f, 0.11198856f, -0.18767625f, -0.09383442f, -0.02257853f, -0.08464862f, -0.00545680f, 
    0.15653116f, 0.23442122f, 0.12912424f, -0.01400122f, -0.45150572f, 0.02871493f, -0.00801622f, -0.01218373f, 
    0.07325986f, 0.02029244f, 0.06119099f, 0.00835282f, -0.01184273f, 0.14274259f, -0.09294426f, -0.10203969f, 
    0.08238609f, -0.00499441f, -0.13902362f, 0.09838856f, -0.11840601f, 0.05156286f, 0.14671516f, -0.10190942f, 
    0.16818130f, 0.01446538f, -0.09588423f, 0.04433416f, 0.14580427f, 0.06823670f, 0.02591206f, 0.05785562f, 
    0.07010777f, -0.00807123f, 0.03548121f, 0.10432695f, 0.11972990f, 0.04215231f, 0.02934969f, 0.01786578f, 
    -0.08665457f, -0.05378408f, 0.13517347f, 0.11645422f, 0.00021721f, -0.00801061f, 0.11937696f, 0.06528028f, 
    0.00258109f, 0.13538755f, 0.18217298f, 0.19230375f, 0.07010563f, -0.08982409f, 0.06941953f, -0.10143082f, 
    -0.13559376f, 0.03084194f, 0.14446469f, -0.01535129f, -0.88446248f, 0.12067789f, -0.05379583f, 0.12575601f, 
    0.29334706f, 0.13850863f, 0.03949717f, -0.02521724f, 0.17520490f, 0.21327417f, -0.01203673f, -0.07888450f, 
    0.06605040f, 0.12328169f, -0.01568327f, -0.11691653f, 0.19251953f, 0.09925144f, 0.24356838f, -0.18172896f, 
    0.28278801f, -0.04477299f, -0.17412455f, 0.07666244f, -0.36286277f, -0.10657235f, -0.04651441f, -0.03811380f, 
    -0.20654352f, -0.08250751f, -0.04032788f, 0.09246723f, 0.00299399f, -0.08887478f, 0.01839750f, -0.04243580f, 
    0.14171770f, 0.16484404f, 0.09311509f, -0.02232968f, 0.24880518f, 0.15705030f, 0.07531073f, 0.01591995f, 
    0.00235055f, -0.05444270f, 0.07347077f, 0.18132639f, 0.06263302f, -0.00127221f, -0.09748020f, -0.03680116f, 
    -0.14465864f, -0.01282568f, -0.01300726f, -0.00830385f, -0.13084526f, -0.03775920f, -0.11270227f, -0.26051915f, 
    -0.65657753f, 0.32127047f, -0.12602840f, 0.17246412f, 0.15395997f, -0.00344912f, -0.15922566f, 0.04530343f, 
    0.09993492f, -0.02812945f, -0.04143304f, 0.00804097f, -0.01753468f, 0.07047177f, 0.08223313f, 0.17222598f, 
    -0.08674227f, 0.20913176f, 0.00092757f, 0.05380802f, 0.46063051f, 0.73681289f, -0.55919284f, -0.22146197f, 
    -0.02332526f, 0.05188422f, 0.03587272f, 0.12112705f, 0.19581071f, 0.06818552f, 0.01673803f, -0.02370352f, 
    0.00223975f, -0.03196798f, -0.08908194f, 0.03904011f, 0.21708584f, -0.22497949f, -0.16677713f, -0.07887212f, 
    -0.39798152f, 0.15696971f, -0.00797988f, -0.20874670f, -0.01388228f, -0.04239900f, -0.00833060f, 0.14269623f, 
    0.04506562f, -0.11497922f, 0.15361616f, -0.01625361f, 0.02020872f, -0.14978386f, 0.13237287f, -0.11660594f, 
    0.12626900f, -0.08017801f, -0.05334051f, 0.09236015f, 0.18502393f, 0.18687202f, 0.05080758f, 0.14600778f, 
    0.11592472f, -0.16569510f, -0.14268976f, -0.06270146f, -0.08500760f, 0.11837925f, -0.00194290f, -0.17769749f, 
    0.12413105f, 0.24120101f, 0.17100568f, -0.03369499f, -0.08568956f, 0.12577185f, -0.00733378f, 0.02464875f, 
    0.06367850f, 0.13595326f, 0.13092020f, 0.12943397f, -0.07779524f, -0.22322106f, -0.01303462f, -0.07510141f, 
    -0.23799177f, 0.21280828f, 0.17169851f, -0.04905198f, -0.01319693f, -0.05001042f, -0.06797471f, 0.10442188f, 
    -0.05301453f, 0.12993364f, 0.16865063f, 0.10664387f, -0.61720443f, -0.36176682f, 0.02590968f, 0.03839222f, 
    -0.18905407f, -0.14973600f, 0.04569191f, 0.07352556f, 0.00728661f, -0.20222695f, -0.13515049f, 0.09899518f, 
    0.17345700f, -0.05399366f, 0.05453847f, -0.07626615f, 0.04481908f, -0.18015712f, -0.08586623f, 0.02780213f, 
    0.08595313f, 0.55057734f, 0.04344447f, -0.11971946f, 0.01872492f, -0.06549444f, -0.03420590f, 0.11687371f, 
    0.00277841f, -0.16464104f, 0.17214161f, -0.14706567f, -0.12716433f, -0.21352056f, -0.04029822f, 0.25979277f, 
    -0.07896432f, -0.02030542f, -0.02590446f, -0.01632919f, -0.73645908f, 0.01945253f, -0.16213396f, 0.34818754f, 
    -0.14102851f, 0.03099522f, -0.16170265f, 0.00268496f, -0.09497243f, 0.03928876f, 0.10049525f, 0.02238620f, 
    -0.00819436f, 0.02699542f, -0.04530652f, 0.06757596f, -0.07937714f, 0.09117664f, -0.17751408f, -0.13974163f, 
    0.20239823f, 0.09098215f, 0.00032150f, 0.37854278f, 0.04401712f, -0.04277771f, 0.08647266f, 0.09379068f, 
    0.07892701f, 0.08119509f, -0.10939024f, -0.12803210f, -0.03886892f, 0.02351610f, 0.17786384f, 0.05321521f, 
    0.11069169f, 0.12053122f, 0.10484452f, 0.01293444f, 0.01234203f, 0.25053731f, 0.17041755f, 0.11518426f, 
    -0.27616206f, -0.11731775f, -0.03485443f, 0.03354168f, 0.01035359f, 0.24226066f, -0.08390167f, -0.11442566f, 
    -0.03005170f, -0.00516610f, -0.15077516f, -0.04924899f, -0.04503529f, -0.15036295f, 0.09410784f, 0.00739738f, 
    0.01868113f, -0.12963217f, -0.10456616f, -0.04844806f, 0.23803018f, 0.02448401f, -0.04685326f, 0.09929320f, 
    -0.11968221f, 0.06436031f, 0.16299865f, 0.04623390f, 0.09811912f, 0.01936788f, -0.02057780f, -0.01491481f, 
    0.04535046f, -0.14429073f, 0.05632806f, -0.04234400f, 0.08436139f, -0.12285379f, 0.20405160f, 0.04630483f, 
    -0.39573705f, 0.02885449f, 0.09986500f, -0.01737811f, 0.01389047f, -0.05333044f, -0.03686622f, -0.00852970f, 
    -0.00124116f, 0.12640278f, 0.05788980f, 0.08167853f, -0.10435247f, 0.09071763f, 0.09058446f, -0.00847474f, 
    0.09804531f, -0.05517335f, -0.12159752f, 0.07817515f, 0.35932791f, -0.03124318f, 0.07071224f, -0.03848710f, 
    0.19137095f, 0.00351072f, 0.00011250f, -0.01778189f, 0.14548022f, 0.17610146f, 0.30494186f, -0.11464526f, 
    -0.03626879f, -0.02969122f, -0.45905179f, -0.06816623f, -0.71842813f, -0.14996387f, -0.55716318f, -0.25395024f, 
    -0.06450514f, 0.26011354f, 0.12778893f, 0.10032912f, -0.03325408f, -0.19520950f, 0.03253393f, 0.04143219f, 
    -0.15805516f, -0.13571125f, -0.11926071f, 0.02444538f, -0.09296566f, -0.05025983f, -0.14048824f, 0.06461740f, 
    -0.04542131f, -0.04484442f, 0.14225052f, 0.01597618f, 0.34604359f, -0.00476096f, -0.19480193f, -0.04452731f, 
    -0.01387200f, 0.15800035f, -0.06574926f, -0.08345000f, 0.09261286f, -0.01207585f, 0.04579430f, -0.04604191f, 
    -0.13508055f, -0.15518057f, -0.13336918f, 0.10888985f, -0.20355329f, -0.12274717f, -0.01413013f, 0.25797251f, 
    0.11600778f, 0.01591072f, 0.12617652f, -0.07138518f, -0.05051107f, 0.22017902f, 0.22725770f, -0.01099553f, 
    -0.07670555f, 0.10166377f, 0.03891324f, -0.07217682f, -0.02948284f, 0.09651001f, 0.03245516f, 0.06751637f, 
    -0.49776727f, 0.02471731f, -0.54117608f, -0.12844416f, -0.01873793f, 0.24639134f, 0.20056355f, -0.10134184f, 
    -0.01818833f, -0.11121295f, 0.03583744f, 0.09991284f, 0.05635466f, -0.15960765f, 0.03136190f, 0.09214802f, 
    0.05838501f, -0.02862868f, 0.16798507f, -0.06762864f, -0.51049411f, -0.28036636f, 0.23927112f, 0.10467744f, 
    -0.62393838f, 0.08018141f, -0.07563899f, 0.03475861f, -0.17823511f, -0.09401787f, 0.02867417f, -0.02384216f, 
    -0.07530516f, -0.00712188f, -0.07764184f, -0.15245129f, 0.18007357f, 0.29667073f, -0.02276239f, 0.05329451f, 
    -0.06034088f, -0.18187894f, -0.02119516f, 0.26819474f, 0.15561078f, -0.05745280f, 0.08660055f, 0.00110194f, 
    -0.00390295f, -0.05640133f, -0.08217458f, 0.13920179f, 0.07507509f, 0.10976499f, 0.24312581f, -0.02902086f, 
    -0.06881555f, 0.09414139f, -0.17130351f, -0.02182093f, -0.27514401f, 0.47009775f, 0.18134907f, -0.00720501f, 
    -0.49310875f, 0.08031487f, 0.11220439f, -0.03954921f, 0.08171101f, 0.01983500f, -0.05544705f, 0.09149186f, 
    -0.06741685f, 0.05212443f, -0.03222078f, 0.12789506f, 0.11292651f, -0.18153180f, 0.12523958f, -0.06636957f, 
    -1.00828338f, 0.43514529f, 0.05235533f, 0.29775289f, -0.07794086f, 0.20168550f, 0.01815816f, 0.06488247f, 
    0.14308120f, -0.12460599f, -0.03924415f, -0.01507609f, 0.16056889f, 0.00226268f, -0.14387931f, -0.09319168f, 
    0.03633685f, -0.15838315f, -0.07054374f, -0.12721661f, 0.15547702f, -0.14078526f, -0.06098199f, 0.25623950f, 
    0.28661045f, 0.07972966f, 0.11451694f, 0.04582018f, -0.01033270f, -0.20083174f, 0.05996375f, -0.05578860f, 
    -0.07566283f, -0.00199788f, -0.03471492f, 0.05000974f, 0.12924939f, 0.26573548f, 0.09985094f, 0.22596417f, 
    0.01486719f, -0.58282465f, -0.18077542f, 0.05580842f, -0.02033331f, -0.07052224f, 0.15098578f, -0.16969232f, 
    0.09446990f, 0.06230391f, -0.15008843f, 0.04770425f, 0.10751357f, 0.19507131f, -0.07491717f, 0.02073718f, 
    -0.10560457f, -0.00093684f, -0.15469620f, -0.11026894f, -0.12282188f, -0.51702434f, -0.07792131f, 0.16206148f, 
    0.08804375f, 0.04983459f, 0.11067250f, 0.11874536f, -0.13492419f, -0.01776859f, -0.18880074f, 0.01965325f, 
    -0.05651181f, -0.03690048f, 0.22075790f, -0.04931417f, -0.08944797f, 0.07765231f, 0.26839632f, 0.08920500f, 
    -0.33983743f, 0.50511789f, -0.10940441f, 0.25694412f, -0.14716120f, -0.20248060f, 0.03540218f, -0.00095292f, 
    0.01522881f, -0.03258077f, 0.06303788f, 0.14979100f, -0.07569356f, -0.07080099f, -0.26349878f, -0.00141817f, 
    -0.12300033f, 0.08778396f, -0.09621554f, 0.01928359f, 0.31623757f, -0.13450260f, -0.16966371f, 0.20874394f, 
    -0.20465259f, -0.10825317f, 0.21052161f, -0.20419724f, -0.04914398f, 0.06567308f, 0.07212836f, 0.02158407f, 
    -0.07093741f, 0.03194990f, 0.09933231f, -0.14074269f, 0.05779589f, 0.23829786f, -0.23017253f, 0.05985811f, 
    -0.20560701f, 0.01191841f, -0.27256033f, 0.27804706f, -0.27318525f, -0.05628272f, 0.20748289f, -0.03865154f, 
    0.03297930f, 0.03382089f, -0.09753042f, 0.04486901f, -0.04136090f, 0.03318045f, -0.10430761f, 0.18147303f, 
    -0.06613424f, 0.12498583f, -0.11663890f, 0.05649572f, -0.15744224f, 0.30858237f, -0.11548980f, 0.27581406f, 
    -0.29460877f, -0.14499216f, -0.10694224f, 0.08824298f, 0.00662265f, 0.14768538f, 0.07342272f, -0.01963225f, 
    -0.02987114f, 0.12935385f, 0.03327275f, -0.14131950f, 0.02821472f, -0.09882346f, -0.17288654f, -0.15477575f, 
    -0.02370572f, 0.07166367f, -0.26136032f, -0.37482935f, -0.11759904f, 0.07047103f, -0.01384340f, 0.07434168f, 
    -0.25407335f, 0.09949872f, -0.09576000f, -0.03207942f, -0.20190547f, -0.10256120f, -0.15814139f, 0.05444878f, 
    -0.04473259f, 0.21235117f, 0.20778973f, 0.15902185f, -0.00349511f, -0.37639904f, -0.10192113f, -0.67237520f, 
    0.20236082f, 0.06563912f, -0.11828651f, 0.10197999f, -0.16364487f, -0.11345770f, 0.00158089f, -0.20660459f, 
    0.31238526f, 0.08153234f, -0.05029412f, 0.03706520f, -0.06610069f, -0.10840084f, 0.02465909f, 0.14278191f, 
    -0.08203392f, -0.03767293f, -0.15064308f, 0.00041377f, -0.12933305f, 0.11554288f, 0.26881963f, -0.00097280f, 
    0.05771629f, 0.03532042f, 0.02216727f, 0.00497519f, 0.16549583f, 0.11433789f, -0.25903150f, -0.00136806f, 
    0.05101218f, -0.01482794f, 0.10979603f, 0.07319621f, 0.14589049f, -0.36125597f, 0.00832476f, 0.02621243f, 
    -0.33711904f, -0.00176100f, -0.25820246f, 0.21117401f, -0.14962985f, 0.03809712f, -0.10216369f, 0.01957450f, 
    -0.02515497f, -0.04759595f, 0.01546673f, 0.05975196f, -0.05513437f, 0.05396955f, 0.00438664f, -0.09735453f, 
    0.21108818f, -0.25510523f, 0.01001137f, -0.67478353f, 0.32115504f, -0.14314191f, -0.11502644f, -0.03035377f, 
    0.08552655f, 0.02941647f, 0.03136848f, -0.01822004f, 0.01358087f, 0.10888827f, 0.02610252f, -0.01423724f, 
    -0.02912754f, -0.10835671f, -0.15410452f, 0.20286465f, 0.56546277f, -0.65336180f, -0.09033103f, 0.19895637f, 
    0.02221368f, -0.00954510f, -0.08456256f, 0.07831275f, -0.02148048f, 0.18047065f, 0.07032977f, 0.07893091f, 
    -0.16477272f, -0.06907023f, 0.06716976f, -0.05008725f, 0.02268553f, -0.03456671f, -0.11912380f, 0.01079293f, 
    -0.37072593f, 0.27393115f, 0.24806882f, 0.04279233f, 0.05678784f, -0.00930388f, -0.06689042f, 0.03722571f, 
    0.10739326f, -0.00621043f, 0.00420291f, -0.06989937f, 0.00888778f, -0.03693489f, -0.17896868f, 0.02499700f, 
    -0.02127613f, 0.08764178f, -0.01460670f, -0.04029408f, -0.20440796f, -0.29630369f, -0.53516757f, -0.15509707f, 
    -0.05821501f, -0.01703262f, -0.14248940f, -0.03165078f, -0.03466188f, -0.11716896f, -0.30913511f, 0.07396244f, 
    0.05223430f, -0.05011864f, -0.14167604f, -0.14600892f, 0.00924538f, -0.15141687f, -0.03083950f, 0.01626716f, 
    -0.43940377f, -0.12545779f, 0.09130456f, -0.21753833f, -0.38101181f, 0.04234112f, 0.01958999f, -0.05101623f, 
    -0.03263444f, -0.01035490f, -0.00168664f, 0.06928996f, 0.01867136f, -0.09161503f, -0.15041123f, 0.01733016f, 
    0.03298116f, -0.07989593f, -0.04615177f, 0.05773914f, 0.00757424f, 0.22327514f, 0.17517780f, 0.06741442f, 
    -0.06302541f, 0.22741465f, -0.09601336f, 0.12679788f, 0.12709500f, -0.04881735f, -0.05984506f, 0.09679048f, 
    -0.02528881f, 0.03495039f, -0.12704530f, 0.13211076f, 0.11157053f, 0.04255646f, 0.00449530f, 0.02544920f, 
    -0.17029636f, 0.00299802f, 0.13541879f, -0.11055156f, -0.11668535f, -0.05453451f, -0.15988465f, 0.04894228f, 
    -0.05949695f, -0.10577314f, 0.09969628f, 0.02406258f, 0.09994432f, 0.13292885f, -0.14178298f, -0.04906448f, 
    0.05094865f, -0.02713901f, -0.02251370f, -0.03701195f, 0.08987843f, -0.16112636f, -0.08420192f, 0.23086849f, 
    0.52982688f, -0.07459544f, -0.01616000f, -0.09654839f, 0.13270468f, 0.01061129f, -0.05989211f, -0.02961456f, 
    -0.15540218f, -0.13021585f, -0.01050820f, -0.09345241f, -0.20592539f, -0.07233545f, -0.10121972f, -0.04324600f, 
    -0.50910705f, -0.03175510f, -0.36449215f, -0.38867223f, 0.07283856f, 0.10644548f, -0.11128014f, -0.04012046f, 
    0.06642403f, -0.00091311f, -0.28153253f, 0.07895151f, -0.07530364f, -0.00751317f, 0.03650378f, -0.01688275f, 
    -0.21617803f, 0.06014280f, -0.05419228f, 0.16184473f, 0.02854043f, 0.25896385f, -0.11415592f, -0.02252370f, 
    0.16592349f, -0.11941750f, -0.09489672f, -0.20469396f, 0.10063045f, 0.00494031f, -0.04964216f, 0.09253561f, 
    0.05372987f, -0.05978419f, -0.08977060f, 0.00656886f, -0.01776762f, 0.07308633f, -0.00495681f, -0.06483790f, 
    -0.33042040f, 0.32660994f, -0.22125892f, 0.04763298f, 0.00579597f, -0.06792835f, 0.08321347f, -0.05661446f, 
    -0.00147478f, -0.06931608f, -0.02424615f, 0.04123658f, -0.12431931f, -0.02253183f, -0.04117534f, -0.07903741f, 
    -0.04741140f, -0.01981618f, 0.03679736f, -0.03094603f, -0.12062067f, -0.29027256f, -0.09431779f, -0.30986750f, 
    -0.25596541f, -0.00076578f, -0.20634539f, 0.01996941f, -0.08393095f, -0.15384437f, 0.08261426f, 0.04700796f, 
    -0.11389736f, -0.00156452f, -0.24753332f, 0.06149051f, -0.05961503f, 0.02107618f, -0.00296289f, 0.09060480f, 
    0.24592435f, -0.03777276f, 0.09577534f, 0.07560286f, 0.37353164f, 0.05817582f, 0.05625540f, -0.11971398f, 
    -0.10670775f, -0.01634406f, -0.15336742f, 0.01677215f, -0.14399779f, -0.11170317f, -0.06727511f, -0.09028206f, 
    -0.06833079f, 0.02562900f, 0.05438244f, 0.06631959f, 0.40084690f, 0.10605342f, 0.46596935f, -0.00322482f, 
    0.30661169f, 0.14175510f, 0.28217041f, -0.12089901f, -0.06370951f, -0.00813345f, -0.03139454f, 0.07725958f, 
    -0.04573827f, 0.00334851f, -0.15605143f, -0.09004440f, 0.06197772f, -0.08174375f, 0.07914036f, -0.20029846f, 
    0.04379620f, 0.39166093f, -0.05641927f, 0.02636195f, 0.34684867f, 0.00393195f, 0.19682319f, -0.10857966f, 
    -0.04741788f, -0.08668422f, -0.13370469f, -0.01294245f, 0.02049045f, -0.10227396f, -0.04886791f, 0.09749760f, 
    0.03949734f, 0.04635054f, -0.00406450f, 0.01392887f, 0.26502398f, -0.88518620f, 0.14390251f, 0.05856793f, 
    -0.28443769f, 0.23364767f, -0.10474835f, 0.01065174f, -0.31693909f, -0.00498627f, 0.00059808f, 0.03342773f, 
    -0.13921350f, 0.04280214f, -0.14549011f, -0.09181695f, 0.13890067f, -0.10640649f, -0.02901798f, -0.09814617f, 
    -0.09833688f, 0.20053017f, 0.37533218f, 0.11666176f, 0.30604658f, 0.01362777f, 0.19760452f, 0.02024389f, 
    -0.00168628f, -0.14475171f, -0.00248577f, 0.10501560f, 0.02426664f, -0.11468793f, -0.12104481f, -0.03997907f, 
    0.07502532f, 0.00970321f, 0.09694315f, -0.09686594f, 0.22538321f, -0.27855811f, 0.06128814f, 0.05515590f, 
    -0.11403818f, 0.18855290f, -0.11200920f, -0.02251374f, -0.08908008f, 0.12077307f, -0.08951399f, -0.04718849f, 
    0.01283546f, -0.03808663f, 0.07383624f, 0.04713695f, 0.00599048f, -0.03475437f, -0.02786234f, 0.05062230f, 
    0.11277108f, -0.01265641f, -0.12337621f, 0.05716289f, 0.10893635f, -0.08657639f, -0.09307218f, -0.02059695f, 
    -0.04355809f, 0.13459356f, -0.00334791f, -0.06934822f, -0.05427900f, 0.00818497f, 0.06478805f, 0.11592977f, 
    0.07483724f, -0.17547342f, 0.08627011f, -0.06438380f, -0.09084399f, -0.22546141f, -0.18414217f, -0.12965915f, 
    0.34056300f, 0.14325392f, 0.12945382f, -0.13056788f, -0.13107122f, -0.08571184f, 0.15437077f, -0.00255283f, 
    0.12907866f, 0.01299223f, 0.00121056f, -0.12451202f, 0.17016566f, 0.18212581f, -0.06607699f, -0.09701187f, 
    0.22127949f, 0.05595439f, -0.38793433f, 0.16196123f, 0.02258260f, 0.16629303f, -0.08612180f, -0.09082569f, 
    -0.13073778f, -0.03011083f, -0.07608716f, 0.14432292f, -0.05484309f, -0.06193925f, -0.09262817f, 0.03484872f, 
    -0.06889845f, -0.07416507f, 0.17892724f, 0.03538502f, 0.00771330f, -0.08577302f, -0.19601510f, 0.06079180f, 
    -0.31094351f, 0.09878713f, -0.09129833f, -0.23660360f, -0.16321695f, 0.04715505f, 0.14593934f, -0.01031667f, 
    0.02312378f, 0.05517139f, 0.02652629f, 0.14716509f, -0.02201331f, -0.25192052f, 0.10171027f, 0.05228736f, 
    0.20034634f, 0.07535859f, -0.12879355f, 0.02025123f, 0.16666523f, -0.24210666f, -0.18964344f, -0.12417027f, 
    -0.11340608f, 0.08468720f, -0.14579810f, -0.18183210f, -0.22994052f, -0.15232354f, 0.12877038f, 0.09825727f, 
    0.07277519f, 0.02966966f, 0.12776931f, 0.00479106f, -0.29710847f, 0.01935595f, 0.13867450f, -0.15227810f, 
    0.07358468f, -0.10636618f, -0.15387537f, -0.06578513f, -0.08526515f, -0.30173492f, 0.05893104f, 0.05426000f, 
    -0.03920260f, 0.06754977f, 0.05634858f, 0.08137140f, -0.01398152f, 0.11976732f, -0.13586737f, 0.07537507f, 
    0.22302109f, 0.14693668f, -0.14416204f, 0.01035680f, 0.07454674f, 0.06007561f, 0.15679610f, -0.04426222f, 
    -0.02723409f, -0.15568559f, 0.22533526f, 0.06731474f, -0.01048061f, 0.08656184f, -0.12548701f, -0.08334772f, 
    0.06955040f, 0.15391834f, 0.19119975f, -0.06758945f, -0.00687461f, 0.04093909f, -0.32385030f, -0.03318067f, 
    -0.08651293f, -0.07404709f, 0.06202251f, -0.22551219f, 0.00026002f, -0.00110830f, 0.17651303f, 0.10134675f, 
    -0.02863236f, -0.03880139f, 0.08152545f, 0.02792061f, -0.02696355f, -0.00508142f, 0.19148543f, 0.06608991f, 
    0.22377580f, 0.10989494f, -0.13439927f, 0.15020324f, -0.08995462f, -0.00613077f, 0.03374110f, -0.06106766f, 
    -0.15181571f, -0.07772102f, 0.13719980f, -0.07384961f, 0.17160654f, -0.19584680f, 0.09701128f, -0.13771769f, 
    -0.15469022f, -0.17939378f, 0.20025997f, -0.07075318f, 0.31353909f, 0.08342803f, -0.03330584f, 0.14633359f, 
    0.21999626f, -0.00583380f, 0.10082056f, -0.19086216f, -0.03737386f, 0.00640209f, -0.14666516f, -0.02521489f, 
    -0.03359051f, -0.10389224f, 0.01966793f, -0.11692196f, -0.00453287f, 0.11905410f, 0.09911365f, 0.09402890f, 
    -0.38961440f, -0.32838950f, 0.00093933f, -0.59661371f, -0.33773944f, 0.08435071f, -0.07761657f, -0.12691428f, 
    -0.10549188f, -0.16472614f, 0.05159248f, 0.06116673f, -0.01605003f, 0.12950034f, -0.07142878f, -0.01551019f, 
    -0.00198083f, -0.04271434f, -0.69727075f, -0.11567516f, -0.40138951f, -0.18151130f, 0.37208226f, -0.12216581f, 
    0.14227535f, -0.04331603f, -0.10227362f, 0.26989836f, -0.25860098f, 0.04942703f, 0.08392633f, -0.10406266f, 
    -0.02851731f, -0.02833299f, 0.08268322f, -0.00587140f, -0.03615782f, 0.03930185f, -0.08324528f, 0.18501683f, 
    -0.34254852f, 0.06687029f, -0.49667373f, -0.32960284f, -0.42146245f, 0.00198202f, 0.00333944f, -0.07199192f, 
    -0.01556080f, -0.09244607f, 0.21633166f, -0.05414937f, -0.02491878f, 0.08286051f, 0.02437495f, -0.10193861f, 
    -0.04646677f, -0.17622557f, 0.11696794f, 0.04548623f, 0.18342549f, 0.01996583f, 0.10397800f, 0.16308233f, 
    0.26996672f, -0.13433653f, 0.02794881f, -0.01381046f, -0.38550657f, 0.08781506f, -0.08173232f, -0.03127562f, 
    -0.02598369f, 0.01844837f, -0.11161720f, 0.05902009f, -0.12942590f, 0.07597185f, 0.08826770f, -0.02443078f, 
    -0.27677736f, 0.01419411f, 0.45041808f, 0.06202039f, 0.03887746f, -0.02928909f, -0.10239565f, 0.07237884f, 
    0.01885752f, 0.06742472f, -0.03682280f, 0.04931686f, -0.16360338f, -0.00762185f, -0.00169456f, -0.04765709f, 
    0.01219611f, -0.08490771f, 0.07099881f, 0.03477378f, 0.16050923f, 0.02470597f, 0.04798842f, 0.11518588f, 
    0.23144932f, -0.05342059f, -0.12036864f, -0.09979956f, -0.05292297f, -0.02099636f, -0.12465367f, 0.04674860f, 
    0.02665032f, -0.17843576f, -0.01355150f, 0.01966843f, -0.05461733f, 0.05792496f, 0.09425887f, 0.06356570f, 
    -0.36131245f, -0.23281975f, 0.17164503f, 0.22325899f, 0.07216351f, 0.11093865f, 0.07780050f, -0.18532321f, 
    -0.04627823f, 0.23658033f, -0.01116301f, 0.11044198f, -0.01074364f, -0.03566282f, -0.17383671f, -0.12983662f, 
    -0.09943171f, 0.06415541f, 0.00665451f, 0.07590906f, 0.03502741f, -0.48373169f, 0.17224577f, -0.18034984f, 
    -0.58786309f, -0.02326227f, 0.04493329f, 0.02002038f, -0.08153409f, -0.09181396f, -0.00667887f, -0.01414510f, 
    0.03264885f, -0.18314953f, -0.11120296f, -0.07762166f, 0.02151901f, -0.06358743f, 0.08585179f, -0.07046568f, 
    0.11877004f, -0.30175066f, 0.24891257f, 0.08485105f, -0.13542226f, -0.08915439f, 0.13384192f, 0.19149397f, 
    0.01898263f, -0.07384998f, 0.01892698f, -0.08256800f, 0.07456703f, -0.10319932f, -0.01092186f, 0.06026436f, 
    0.01132007f, 0.12217303f, -0.23938927f, 0.05516460f, 0.19487640f, -0.57672465f, 0.06889892f, 0.19811495f, 
    0.47198883f, -0.08015995f, -0.09815185f, 0.01752193f, 0.14398533f, -0.09578738f, -0.08799908f, 0.01635131f, 
    -0.08319552f, 0.02768449f, -0.10452176f, -0.02636380f, -0.10218293f, 0.13038099f, -0.09459285f, 0.06278734f, 
    -0.19502759f, -0.16209690f, 0.08814479f, -0.01091027f, -0.03288151f, 0.15326108f, 0.15167437f, 0.03190036f, 
    -0.05806736f, 0.08900142f, -0.12212789f, 0.07293544f, -0.06101773f, 0.04455874f, 0.02458187f, -0.19164665f, 
    -0.09523168f, -0.10898171f, -0.02895373f, 0.17745619f, 0.95779729f, 0.05778818f, -0.57098156f, -0.33701319f, 
    0.11140851f, 0.14202739f, -0.15259032f, 0.06059608f, 0.00101510f, -0.24864899f, -0.14263543f, -0.00671285f, 
    0.13006286f, 0.04267612f, -0.05506765f, 0.03085962f, 0.08945019f, -0.00209426f, 0.03923416f, 0.10843732f, 
    0.28219756f, 0.10336924f, 0.00799168f, -0.76938277f, -0.61881000f, -0.07498875f, 0.09136402f, 0.07631223f, 
    -0.01339589f, 0.04792435f, -0.02575309f, -0.16425604f, -0.00274653f, -0.20709914f, 0.08565824f, 0.12801431f, 
    0.15113866f, -0.21584108f, -0.01794929f, 0.02654396f, -0.49745852f, 0.23471151f, 0.19067568f, -0.36826470f, 
    -0.07281185f, 0.09390645f, 0.17993817f, -0.05974597f, 0.02521875f, -0.06722857f, -0.17456162f, -0.11872228f, 
    0.06939337f, 0.06263034f, -0.03494099f, 0.03148495f, 0.03690306f, 0.03950302f, 0.11114203f, 0.09052563f, 
    -1.01160789f, 0.47391909f, 0.27563199f, -0.02811055f, 0.08757079f, 0.13428633f, 0.04057386f, -0.07500225f, 
    0.02994507f, -0.07013471f, 0.00392410f, 0.15285128f, -0.04022620f, -0.05170106f, 0.23559073f, 0.20025054f, 
    0.02120004f, 0.24395153f, -0.17280173f, 0.04357547f, 0.08873592f, -0.42709428f, 0.23805180f, -0.10496484f, 
    0.07276004f, 0.06423604f, 0.05166536f, -0.00407900f, -0.02722690f, -0.16920327f, -0.03294939f, 0.14327197f, 
    -0.00277720f, -0.07968250f, -0.06562009f, -0.04537920f, 0.03005743f, -0.34518728f, -0.09416009f, -0.11962693f, 
    0.01740306f, -0.23339204f, -0.12847976f, -0.00708015f, -0.07697102f, -0.06750709f, 0.06347581f, 0.05254477f, 
    -0.04192321f, 0.10734387f, 0.24945031f, 0.16683425f, 0.06567013f, -0.08744678f, -0.11012571f, 0.00963579f, 
    0.01712026f, -0.01027283f, 0.25781435f, 0.13451752f, 0.22619408f, -0.18247086f, -0.28944758f, 0.31625390f, 
    0.02092938f, -0.09595647f, 0.00397211f, -0.07266991f, 0.07214030f, 0.17142870f, -0.15086409f, 0.14910330f, 
    -0.10006053f, -0.05703478f, 0.14942373f, 0.10197981f, -0.09730334f, 0.01512730f, 0.00697661f, 0.04304402f, 
    -0.71478707f, -0.00531213f, 0.10105179f, 0.14638704f, -0.27875236f, 0.00456873f, -0.07379645f, 0.02525524f, 
    -0.12539263f, 0.09081164f, -0.00600947f, -0.14711940f, -0.07408383f, 0.08427856f, 0.13976376f, 0.10469792f, 
    0.16798379f, 0.14392234f, 0.02630075f, -0.00051323f, 0.41577679f, -0.63440585f, 0.13584305f, 0.09075382f, 
    -0.09642852f, -0.06267450f, -0.05897497f, 0.02231793f, 0.13054492f, -0.02711914f, -0.00164585f, -0.01130433f, 
    0.17849870f, -0.00405704f, 0.10832901f, -0.02123570f, 0.00531985f, -0.19493634f, 0.00610796f, 0.13697474f, 
    0.20519996f, -0.24758443f, -0.10298682f, 0.25088856f, 0.01871636f, 0.14794098f, -0.06446094f, 0.01981437f, 
    -0.09076604f, 0.23075633f, -0.18080308f, 0.09888363f, 0.00731091f, 0.12657061f, 0.14038539f, -0.08053765f, 
    -0.20471036f, 0.04801405f, 0.00135021f, -0.21589079f, -0.11772448f, -0.20133147f, 0.11666892f, -0.18506214f, 
    0.07833648f, 0.13510978f, 0.04531866f, -0.10500685f, -0.04640318f, -0.03380048f, 0.12377875f, -0.13148054f, 
    0.00511639f, 0.17018798f, 0.08508925f, 0.04228027f, -0.06183768f, -0.13001269f, -0.03551537f, -0.13122213f, 
    0.38097990f, 0.15478721f, -0.21471295f, 0.14196260f, -0.14512129f, -0.11174800f, -0.06834799f, 0.06705073f, 
    0.02165321f, 0.01218525f, 0.05647848f, 0.07490834f, -0.10742310f, -0.19293229f, 0.08870937f, 0.02365926f, 
    0.00950747f, -0.03785791f, 0.06546033f, 0.01166272f, -0.85595882f, -0.09396230f, 0.09679846f, -0.20655130f, 
    -0.39919549f, 0.20970216f, -0.02169728f, -0.01461564f, -0.08279318f, 0.11088934f, 0.07292853f, 0.07319804f, 
    -0.09740000f, 0.32480481f, 0.10219918f, 0.12222254f, -0.10372119f, -0.02612712f, -0.12426770f, -0.15090084f, 
    -0.84988803f, -0.28148949f, -0.22895728f, -0.07183804f, 0.16596082f, 0.13836126f, 0.14834087f, 0.01208967f, 
    -0.09840239f, -0.04848831f, 0.05507809f, -0.02831695f, -0.04024382f, 0.04103416f, 0.10034488f, 0.06233414f, 
    0.11203485f, 0.27840254f, 0.16989219f, 0.12572236f, -0.10937102f, 0.12903763f, -0.29803085f, 0.22385724f, 
    0.05093332f, -0.06841622f, -0.05513114f, -0.06519368f, 0.05350698f, 0.12201430f, 0.01971398f, -0.04344628f, 
    0.05399732f, -0.10052130f, 0.07689138f, 0.02264615f, 0.01541319f, 0.04934797f, -0.14233251f, -0.12372135f, 
    0.38424653f, 0.12488685f, -0.20816779f, 0.01682834f, -0.17560014f, -0.08049995f, -0.04139932f, -0.03183546f, 
    0.14758928f, -0.10573578f, -0.08427625f, 0.03185438f, -0.13013864f, -0.09845345f, 0.18200837f, -0.12299486f, 
    0.00649110f, 0.08465922f, 0.00379725f, -0.07889370f, -0.17601620f, 0.13497512f, 0.06094785f, 0.13957639f, 
    -0.00674171f, 0.03294837f, 0.05979873f, 0.12095535f, -0.03285087f, 0.18454978f, -0.05512638f, 0.10162725f, 
    0.02087925f, -0.09188608f, 0.02634936f, -0.03045858f, 0.11667547f, 0.13212363f, -0.02418263f, 0.19088878f, 
    -0.75073159f, -0.63040036f, -0.06216554f, -0.29614776f, -0.14724857f, 0.15879568f, -0.08225800f, -0.02044862f, 
    -0.00531180f, 0.09972030f, -0.08305568f, 0.02380459f, -0.03216913f, 0.19716159f, 0.02344535f, 0.07005554f, 
    0.05582617f, -0.02538674f, 0.11767141f, -0.00807335f, 0.01992830f, -0.31757483f, 0.02879094f, -0.05651113f, 
    0.32116032f, 0.04920191f, 0.05696045f, 0.19379365f, 0.12240954f, -0.04665200f, 0.03936004f, -0.01583637f, 
    0.09358524f, 0.05921931f, -0.07183384f, 0.11455018f, 0.08278533f, -0.13569760f, 0.11044828f, -0.03144713f, 
    -0.69032937f, -0.51693618f, 0.03276850f, -0.15534854f, -0.28620496f, 0.09288356f, 0.14604500f, 0.18957229f, 
    -0.11245536f, -0.13347185f, 0.44489795f, -0.00406705f, -0.02660280f, -0.14179325f, 0.02541016f, -0.01996529f, 
    -0.11070415f, 0.02861826f, 0.05904771f, -0.00159259f, -0.97096950f, -0.31509617f, -0.38452202f, -0.33894196f, 
    -0.29979286f, 0.11063582f, 0.20122328f, -0.16818601f, 0.02636185f, 0.13204376f, 0.11504149f, -0.15333398f, 
    -0.03390386f, -0.06142308f, -0.00247997f, -0.06647999f, 0.00849019f, 0.12092896f, 0.10944448f, 0.18415305f, 
    0.42049143f, 0.34777784f, 0.24351375f, 0.04557750f, -0.06380205f, 0.08050789f, -0.13991569f, 0.07452610f, 
    -0.02199214f, 0.02446110f, -0.08101518f, -0.04117456f, 0.03418622f, -0.15077145f, -0.00476913f, 0.23558097f, 
    0.06026175f, -0.26915368f, -0.25809121f, 0.10154035f, 0.35649920f, -0.07543064f, -0.12435728f, -0.04120681f, 
    0.00718336f, -0.16054700f, 0.09255929f, -0.09373892f, -0.09228270f, -0.10536640f, 0.07864258f, 0.11430494f, 
    -0.08781524f, -0.08794974f, -0.12038877f, -0.07683077f, 0.03383887f, -0.11079039f, -0.32019597f, 0.10598861f, 
    -0.62149787f, -0.54463553f, 0.25399947f, 0.11953031f, 0.08629133f, 0.10121885f, 0.11005382f, 0.12042568f, 
    -0.09656902f, -0.09481073f, 0.18902688f, 0.07600071f, 0.00240958f, 0.09039343f, 0.09462385f, -0.06827674f, 
    -0.04951945f, -0.28494751f, -0.19505256f, -0.09087099f, -0.36524895f, 0.03314519f, -0.17201777f, -0.13598709f, 
    0.11926082f, 0.09704375f, 0.20942722f, -0.12309196f, 0.05071858f, 0.02757312f, -0.05123507f, 0.17547478f, 
    0.09327121f, 0.06768215f, 0.17047405f, 0.06314339f, 0.03095869f, 0.22659194f, -0.07597298f, 0.05959915f, 
    0.31774309f, 0.14635138f, -0.12756588f, 0.00741813f, -0.10022948f, -0.17039366f, -0.19068451f, 0.16714516f, 
    0.05170317f, -0.02516375f, -0.00799405f, -0.04357798f, -0.05053755f, -0.08756338f, 0.00360317f, 0.01572318f, 
    -0.06363382f, -0.01960308f, -0.01262115f, -0.02320711f, -0.68343383f, 0.25133023f, -0.40014464f, -0.14500208f, 
    0.10143306f, 0.16108365f, 0.07217899f, -0.10692059f, 0.04624079f, 0.08960590f, 0.05663164f, -0.01695072f, 
    0.00561321f, 0.00662678f, 0.12595777f, -0.06516574f, 0.01106025f, 0.25821039f, 0.05361376f, 0.09427400f, 
    0.39598227f, -0.41735107f, 0.13762207f, 0.03375450f, -0.22601891f, -0.02724041f, 0.08485033f, 0.10297684f, 
    0.04772298f, 0.02821031f, -0.29266378f, -0.19107977f, 0.01405790f, -0.00484927f, -0.14656641f, 0.01082583f, 
    0.00684585f, -0.10595737f, -0.14817925f, -0.12855625f, 0.65783483f, 0.49161246f, -0.28772676f, -0.31288657f, 
    0.08487790f, -0.04326259f, -0.00772574f, 0.09713472f, 0.10602868f, 0.08433383f, 0.20306762f, 0.02627104f, 
    -0.01454853f, -0.01275707f, 0.05119176f, 0.06318063f, -0.15739082f, 0.05188736f, -0.02060334f, 0.17740442f, 
    -0.04580892f, 0.09455049f, -0.10886995f, 0.09991493f, -0.38921520f, 0.19884589f, 0.22680841f, 0.10530238f, 
    0.07805342f, 0.06428433f, -0.01340374f, -0.02382871f, -0.04162512f, -0.04777211f, 0.27915499f, -0.10945152f, 
    0.04468198f, 0.07238179f, -0.15536623f, 0.11551645f, 0.10840692f, 0.06008545f, -0.00698511f, 0.07396330f, 
    -0.27600470f, -0.00644921f, 0.17562807f, -0.06448207f, 0.03508392f, -0.08512095f, -0.06266373f, -0.02328816f, 
    0.15002690f, 0.11959065f, 0.03164685f, 0.13852476f, -0.02193086f, -0.06149390f, -0.17219602f, -0.02637929f, 
    -0.21325268f, -0.48071748f, -0.12842588f, -0.17279923f, -0.05829769f, -0.11986023f, 0.16493285f, 0.10885837f, 
    0.10861797f, 0.12309264f, -0.30628744f, 0.14112039f, 0.11809175f, 0.06768896f, -0.21166798f, -0.19215672f, 
    -0.10172318f, -0.17113529f, -0.30117860f, -0.06847043f, -0.62565958f, 0.20976533f, -0.04888350f, -0.20152175f, 
    0.21838014f, -0.22966403f, -0.00812508f, -0.09955247f, 0.17009693f, 0.15445459f, -0.04986613f, -0.09897512f, 
    0.03800907f, -0.10522931f, 0.00291594f, 0.06866574f, 0.00366294f, 0.06407273f, -0.17684866f, -0.34360331f, 
    0.68128800f, -0.28156257f, -0.37644216f, -0.01325641f, -0.03495355f, 0.10518148f, -0.02284695f, -0.10996737f, 
    0.03297497f, 0.03735653f, 0.22162151f, -0.03737313f, -0.00146618f, 0.04333178f, 0.12896939f, 0.16815239f, 
    -0.05602021f, -0.03946798f, 0.04713863f, 0.15638982f, 0.12345736f, 0.16587141f, -0.25998583f, 0.35706121f, 
    0.32487375f, 0.27382296f, -0.04758759f, -0.08173434f, 0.03465794f, -0.06532311f, 0.19841489f, 0.09502491f, 
    0.07463482f, 0.15561610f, -0.08049954f, 0.05574967f, -0.09598998f, 0.07918239f, -0.24814764f, 0.02881886f, 
    0.23792015f, 0.01008951f, -0.31296709f, 0.12565045f, -0.28641990f, 0.09903401f, 0.05347690f, 0.00479540f, 
    -0.03220806f, -0.02317796f, -0.01469664f, 0.06177497f, -0.02553607f, 0.02717041f, -0.03458868f, -0.11781927f, 
    0.10313714f, -0.14743796f, -0.18447183f, 0.01001243f, -0.07457463f, -0.26296097f, -0.16600962f, -0.11328560f, 
    -0.32796377f, 0.03433584f, 0.12859556f, 0.05570395f, 0.01603925f, 0.05773403f, 0.21999367f, -0.18251273f, 
    -0.05610605f, -0.21787409f, -0.03308565f, -0.05369018f, -0.01008506f, -0.06084460f, 0.07405115f, 0.07271085f, 
    -0.05793470f, 0.15500055f, -0.36113480f, -0.31497008f, 0.35552123f, 0.00326708f, -0.22435160f, -0.05759080f, 
    0.15664376f, -0.09952789f, 0.09726436f, -0.09861629f, -0.02793108f, 0.07139385f, 0.14000331f, 0.08255686f, 
    -0.01306492f, 0.00432445f, 0.15318364f, -0.02023760f, -0.44035590f, 0.42815283f, 0.03277510f, 0.05395734f, 
    -0.13732995f, -0.01341344f, -0.24743256f, -0.05293237f, -0.20979607f, -0.29290339f, 0.06355687f, -0.04856778f, 
    0.07698803f, -0.20048431f, -0.02683785f, 0.01028768f, 0.07210184f, -0.04179031f, 0.10141417f, 0.08555423f, 
    -0.07982106f, 0.68170148f, -0.20293272f, 0.03334983f, 0.23940244f, 0.11369107f, 0.03012401f, -0.04516797f, 
    0.04078401f, -0.04574657f, 0.10711441f, 0.13840139f, -0.06465331f, -0.05314382f, 0.15126705f, 0.05003941f, 
    0.27529004f, 0.10341899f, -0.09238706f, 0.11466293f, -0.84491694f, 0.31254545f, -0.08463097f, -0.03945752f, 
    0.03857620f, -0.01817171f, -0.05591817f, -0.10490581f, 0.05458982f, 0.01657068f, -0.11573569f, 0.01093444f, 
    0.04265464f, 0.05971340f, -0.00893159f, 0.08646415f, 0.09109556f, -0.09234428f, -0.19209401f, -0.05727576f, 
    -0.01001540f, -0.21651743f, 0.24770662f, -0.04050840f, 0.00312424f, -0.09136434f, -0.05437338f, 0.17181553f, 
    -0.05781142f, -0.27657813f, 0.00714190f, -0.11366412f, 0.00109696f, 0.04201404f, -0.24647124f, -0.14058077f, 
    -0.07023007f, -0.08219893f, -0.09379136f, 0.01376676f, -0.63012892f, -0.23790769f, -0.02515150f, 0.07113350f, 
    0.13859379f, -0.15112419f, 0.20188364f, -0.12796474f, 0.07205848f, -0.07684379f, -0.13271286f, 0.03866308f, 
    0.10359716f, 0.13426816f, 0.04623078f, 0.06204697f, -0.04049449f, -0.09387904f, -0.10466276f, 0.05035302f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12567356f, 0.13222767f, -0.04081821f, -0.05466900f, -0.05611910f, 0.03884471f, -0.02029698f, -0.15504670f, 
    -0.09289455f, -0.02440143f, 0.09001545f, 0.01641686f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
