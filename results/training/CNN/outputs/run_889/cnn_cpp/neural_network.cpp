#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.46822345f, 0.15587433f, 0.37011859f, 1.21106172f, 1.18625987f, -0.22385752f, 0.20331587f, 0.16307397f, 
    -0.27879485f, -0.32067421f, -0.03958424f, -0.16118738f, -0.33075097f, -0.26138997f, 0.06257241f, 0.00566483f, 
    0.15793848f, 0.02080949f, -0.03694398f, 0.21045753f, 0.09788358f, 0.07209691f, 0.21076316f, 0.08080419f, 
    0.31352791f, -0.86076075f, -1.44560206f, -0.92711014f, -0.03173888f, 0.47869629f, -0.71109682f, -0.01179476f, 
    -0.13820027f, -0.09794503f, -0.13138887f, 0.42609534f, 0.30089453f, 0.38316292f, -0.07533117f, -0.17769802f, 
    -0.08428223f, -0.01512470f, -0.26890051f, -0.49499971f, -0.17272946f, -0.05336578f, -0.21545751f, -0.07962646f, 
    0.13017921f, -0.10579111f, -1.28534448f, -0.88412493f, -0.61630625f, -0.57465261f, -0.75980800f, -0.39028499f, 
    -0.13531372f, 0.25164700f, 0.48282567f, 0.39817914f, 0.17135748f, 0.22582722f, -0.08238785f, 0.03813639f, 
    -0.24078663f, 0.14502022f, 0.07634176f, 0.05351152f, 0.16689646f, -0.03570587f, 0.14620337f, -0.32490319f, 
    -0.16450088f, -0.25657761f, 0.23370299f, 0.58317500f, 1.21977937f, 0.28222758f, 0.88570070f, 0.45351040f, 
    -0.10374105f, 0.52277255f, 0.55181485f, 0.31307542f, 0.77393711f, -0.69677532f, -0.17831662f, -0.07798528f, 
    -0.48717466f, -0.34707618f, -0.23435266f, -0.16642264f, -0.16225307f, -0.36494046f, -0.18529688f, -0.16385914f, 
    -0.02746985f, -0.31248456f, -0.21547295f, -0.25714225f, -0.40108624f, -0.02979894f, 0.65988410f, 0.60007644f, 
    0.32490903f, -0.93236589f, -0.75433874f, -0.74877203f, -0.79716259f, -0.74866879f, 0.30850852f, 0.39099139f, 
    0.29211327f, -0.02211177f, -0.26342112f, -0.13096014f, -0.05819689f, 0.38363546f, 0.29675096f, -0.12684888f, 
    0.13131328f, 0.11962815f, 0.02469188f, 0.11725394f, -0.19177143f, 0.89772260f, 0.79758006f, 0.09392384f, 
    -0.72572160f, 0.05844119f, -0.04767199f, -0.39695814f, 0.47113359f, -0.45808050f, 0.27836540f, 0.26016748f, 
    0.64591551f, 0.40075019f, 0.35104951f, -0.07695376f, 0.42242017f, 0.12550399f, 0.11168136f, 0.18735921f, 
    0.63350129f, -0.19509095f, 0.23693554f, 0.24598409f, -0.29129052f, 0.14361635f, -0.28048757f, -0.04661072f, 
    0.38206437f, -0.62271744f, 0.09795994f, -0.97115391f, 0.56114388f, -0.64502090f, -0.34228048f, 0.31020054f, 
    -0.83454990f, -0.00948275f, -0.39465752f, 0.09032895f, -0.05494161f, -0.77843571f, -0.37260035f, -0.12853509f, 
    0.09358420f, -0.40549743f, 0.21494970f, -0.29898402f, -0.09506360f, 0.01104399f, 0.18841663f, -1.30888081f, 
    0.30839169f, 0.52976900f, 0.38799897f, -1.71167755f, 0.58961445f, 0.20506507f, -0.38387284f, 0.08053763f, 
    0.47985232f, -0.12672339f, -0.00060461f, 0.08817612f, -0.07652032f, 0.03448003f, 0.13420305f, 0.07080324f, 
    -0.02321866f, -0.16182151f, 0.05320330f, 0.27041543f, 0.19289143f, 0.12323342f, 0.05147652f, 0.16115770f, 
    -1.01128089f, 0.53590894f, 0.09763270f, -0.50398624f, 0.72466058f, -1.04497826f, 0.72535640f, 0.16827039f, 
    -1.01132190f, -0.32208616f, -0.15128325f, 0.18180214f, 0.20354770f, -0.11024611f, 0.14468238f, 0.41776624f, 
    0.28310221f, 0.14491932f, 0.36156973f, 0.04642446f, 0.19168417f, -0.07577058f, 0.26323879f, -0.05048608f, 
    -0.22185151f, 0.47369447f, 0.63687724f, -0.70204753f, -0.88699675f, -1.00598204f, 0.61886060f, 0.75609463f, 
    -0.45617256f, 0.47253847f, 0.92002183f, 0.32970107f, -0.19121391f, -0.37030232f, -0.36731839f, -0.02550833f, 
    0.09838670f, 0.02300046f, -0.15071839f, 0.33390224f, 0.00180674f, -0.08629424f, -0.28153348f, -0.13311195f, 
    -0.38423476f, 0.02260889f, 0.91252452f, -0.44434091f, -1.03716862f, -0.76897997f, 0.78939950f, 0.74766105f, 
    -0.07033897f, -0.60985595f, 0.21636294f, 0.48757508f, -0.30924168f, -0.08145999f, -0.01983355f, 0.26135078f, 
    0.19349070f, -0.13357379f, 0.13989653f, -0.44973835f, 0.03188537f, 0.17899267f, 0.04129199f, -0.06808643f, 
    0.10666192f, 0.13237713f, -0.32256389f, -0.47213870f, 0.13949358f, 0.13722344f, -1.03357625f, -0.49655315f, 
    -0.12574390f, -0.43452448f, 0.39367586f, 0.40662035f, -0.98160106f, -0.45144829f, -0.57993329f, 0.38696492f, 
    -0.12107740f, -0.28911954f, -0.25022250f, 0.12025557f, -0.01941961f, -0.12386570f, -0.14947245f, 0.17601472f, 
    0.59088367f, -0.03810933f, 0.46111238f, -0.26994193f, 1.32833445f, 0.97692996f, 0.95262510f, 0.66125822f, 
    0.19649415f, 0.43349662f, -0.49573541f, -0.29565322f, -0.82087541f, -0.30099624f, 0.06621613f, 0.39890313f, 
    -0.19948857f, -0.02034649f, 0.00636268f, -0.03348195f, -0.06303151f, 0.09786467f, 0.24517113f, 0.00164741f, 
    -0.05884714f, -0.14029418f, 0.17583914f, -0.26228020f, 0.16073076f, 1.07643509f, 0.09502310f, 1.12429392f, 
    -0.19502474f, -0.44995141f, 0.39898950f, -0.96674013f, 0.37598160f, 0.19792816f, 0.37291726f, 0.54599404f, 
    -0.13388029f, -0.40432614f, 0.18515070f, -0.20669486f, -0.13217770f, 0.03562557f, 0.16410498f, -0.37821350f, 
    0.00992117f, -0.16901308f, 0.39210704f, 0.31762031f, 0.59524632f, -0.16298553f, -0.76708263f, -0.83847022f, 
    0.01711591f, 0.30080292f, 0.36143202f, 0.24701478f, 1.12066722f, 0.90818644f, 0.15806064f, 0.45904762f, 
    -0.11018761f, -0.36450720f, 0.32061973f, 0.14407724f, 0.32019836f, -0.02485026f, 0.05881060f, -0.46569073f, 
    0.26461264f, -0.38746056f, 0.54723048f, 0.17987911f, -0.10965212f, 0.46363702f, -0.20301275f, -0.35807595f, 
    0.74456167f, 0.92366105f, -0.46196473f, -0.12706837f, -1.01110613f, 0.23253921f, -0.59871161f, -0.46419081f, 
    0.00078461f, 0.12654838f, 0.51711279f, -0.69321191f, -0.32851872f, -0.14349790f, -0.06383839f, -0.43356764f, 
    -0.34977138f, -0.53727859f, 0.36987829f, -0.02397647f, 0.07676752f, -0.18377219f, 0.12809329f, -0.18883586f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17787915f, 0.39363980f, 0.28942880f, 0.50807559f, 0.54835194f, 0.18341017f, 0.35130975f, 0.07717855f, 
    0.24072847f, 0.08263326f, 0.24345542f, 0.43528655f, 0.10475852f, 0.21611679f, 0.39888582f, 0.23961276f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16169344f, 0.01778390f, -0.11955840f, 0.63320071f, -0.30787864f, 0.05675744f, 0.11748625f, -0.03296544f, 
    0.11897305f, 0.00511169f, 0.03842584f, -0.07374893f, 0.08975884f, -0.29588193f, -0.00305345f, -0.09031283f, 
    0.08371540f, -0.11399477f, 0.11520945f, 0.14822958f, -0.02767050f, -0.08543936f, 0.13792369f, 0.04141556f, 
    0.47590476f, 0.18368199f, 0.17290691f, -0.08588852f, -0.09265949f, 0.19852473f, 0.16436145f, 0.07924922f, 
    0.12800503f, -0.04271162f, -0.14577143f, 0.01699068f, 0.37393120f, 0.11326341f, -0.11993441f, 0.13991882f, 
    -0.03121856f, 0.06714685f, -0.15854748f, -0.01623856f, -0.01227168f, -0.01668592f, -0.01457028f, -0.26313242f, 
    -0.10346688f, -0.15792659f, -0.06738324f, 0.17892346f, 0.07942548f, -0.07786230f, -0.00508042f, 0.02408433f, 
    -0.00992659f, 0.09771286f, 0.17646557f, -0.03278271f, 0.12314927f, 0.12743723f, 0.14014241f, -0.49371138f, 
    0.12173267f, -0.06343653f, 0.13722923f, 0.05473852f, 0.02504729f, 0.02732110f, 0.18261755f, 0.22021590f, 
    -0.05184573f, 0.00562183f, -0.16374943f, 0.11622053f, -0.09617069f, 0.07897364f, -0.01244319f, 0.30861616f, 
    -0.03195173f, 0.08588845f, -0.19478719f, -0.37263170f, -0.29095739f, 0.15068232f, -0.16020288f, 0.17676173f, 
    0.15113370f, -0.06385718f, 0.06578688f, -0.04825745f, 0.00389911f, -0.19771945f, -0.15582855f, 0.02689880f, 
    -0.30938596f, 0.27041730f, 0.09927603f, -0.25501418f, 0.22635679f, 0.01809787f, -0.01334027f, 0.00782431f, 
    0.08595958f, 0.13159482f, 0.23160674f, 0.32026893f, 0.26131162f, 0.00177813f, 0.11444439f, -0.60801756f, 
    0.08384866f, -0.07545295f, -0.04120612f, -0.10039096f, -0.00117218f, 0.06740126f, 0.00518437f, 0.13489629f, 
    0.31432855f, -0.60985565f, 0.09599955f, -0.23085847f, -0.16475508f, -0.14726631f, 0.22340287f, 0.02428468f, 
    -0.18077613f, 0.13278013f, -0.13535526f, 0.08572552f, -0.11097237f, -0.05646752f, 0.13027301f, -0.20293765f, 
    0.19690594f, 0.10102769f, 0.11296273f, -0.12229806f, 0.04799661f, 0.11357922f, 0.03028450f, -0.10770035f, 
    0.13825485f, -0.07542692f, 0.09771197f, 0.16455853f, -0.23568842f, 0.02336123f, -0.08028901f, -0.07081819f, 
    -0.08528461f, -0.16326259f, -0.04436813f, 0.08653462f, -0.16492905f, -0.11972853f, 0.05101056f, 0.20728166f, 
    0.03369945f, -0.12081660f, -0.05044001f, -0.16739649f, 0.04588356f, 0.05835991f, 0.07818195f, 0.03337501f, 
    -0.15647799f, 0.50401342f, -0.26485574f, 0.02568764f, 0.21757914f, 0.07865519f, -0.01853292f, 0.08359574f, 
    0.18093388f, 0.05740746f, -0.15386756f, 0.00948232f, -0.08894938f, 0.15841387f, 0.04367080f, 0.02116754f, 
    0.14194857f, -0.12741697f, -0.07253053f, -0.10587586f, 0.03253952f, 0.16212699f, 0.00494350f, -0.12327185f, 
    -0.40963858f, -0.06886242f, 0.25192288f, -0.30582631f, 0.36545298f, -0.10121693f, 0.06550150f, -0.07312389f, 
    0.16902512f, 0.24697925f, 0.15471080f, 0.20876458f, 0.19046848f, 0.25774598f, 0.01605911f, -0.12967934f, 
    -0.02146742f, 0.07341996f, -0.03043376f, 0.00164911f, 0.17692526f, 0.07227555f, 0.07289425f, 0.13193382f, 
    -0.09652995f, -0.08530100f, 0.27688900f, 0.23851469f, -0.07732995f, -0.05458929f, 0.06021129f, -0.04516674f, 
    -0.01366165f, 0.03720314f, 0.11477993f, 0.12854704f, -0.05039346f, -0.30595496f, -0.11179724f, -0.10599993f, 
    0.26306775f, -0.11258051f, -0.04990720f, 0.01994311f, -0.02507454f, 0.11711688f, 0.09604917f, 0.14993976f, 
    0.22325516f, 0.32953259f, 0.43046936f, 0.09338731f, 0.06307693f, 0.22301610f, 0.05259366f, 0.16711326f, 
    0.02717425f, 0.01058555f, 0.05275579f, 0.05869328f, -0.06565808f, -0.06403799f, -0.18379556f, 0.31291276f, 
    0.02783545f, 0.00580542f, -0.03578194f, -0.04713881f, -0.02663578f, 0.19545242f, -0.01130803f, 0.13321897f, 
    0.21293743f, 0.40385163f, -0.01326200f, 0.17391367f, 0.21758041f, 0.14077310f, 0.08527571f, -0.13321425f, 
    -0.04069425f, 0.07180750f, 0.36677030f, 0.00316560f, -0.34980866f, -0.34497079f, -0.02916118f, -0.15036300f, 
    -0.03015780f, -0.02365446f, -0.02066549f, -0.02405635f, 0.02014741f, 0.02193986f, 0.13817683f, 0.19121377f, 
    0.17083652f, 0.07253712f, 0.24234118f, 0.16033620f, 0.06101878f, -0.11363377f, -0.03537508f, 0.04069633f, 
    0.06390414f, 0.23148023f, 0.10850323f, 0.13932727f, -0.39151293f, -0.10582337f, -0.06902833f, 0.47374207f, 
    -0.04776214f, 0.05310127f, 0.05699543f, 0.01596599f, -0.01845140f, -0.08991726f, -0.03324399f, 0.08869192f, 
    -0.29124311f, 0.03917797f, -0.27279186f, 0.29810899f, 0.06137845f, 0.01803708f, 0.10957157f, 0.08017422f, 
    0.27937236f, -0.00016262f, -0.03855108f, -0.02606752f, 0.39579859f, 0.04663544f, -0.07738493f, -0.02341634f, 
    0.06324929f, 0.05950420f, 0.03498135f, 0.11908843f, 0.06702663f, 0.04757329f, 0.05726083f, 0.01037024f, 
    -0.58817160f, -0.14680417f, 0.23154233f, 0.18570139f, 0.34901989f, 0.29591161f, 0.05930492f, -0.19975404f, 
    0.07511420f, 0.10883822f, 0.24637844f, -0.06042463f, -0.41074347f, 0.07488404f, -0.01467425f, 0.09056428f, 
    0.26920775f, 0.19615404f, 0.13165952f, 0.16167718f, 0.16060510f, 0.05311960f, 0.19012952f, 0.14882988f, 
    0.25524884f, 0.09367040f, -0.02070513f, 0.01189200f, -0.38974872f, -0.11192935f, 0.16725126f, 0.15977122f, 
    0.01832036f, 0.04577379f, 0.10955377f, 0.01135798f, 0.07093503f, 0.30944324f, 0.16934808f, 0.00841902f, 
    -0.05081777f, 0.00290294f, 0.03450146f, 0.28828329f, 0.11230507f, 0.17486359f, -0.18487437f, 0.05070537f, 
    -0.25709221f, -0.04518675f, -0.07243308f, -0.03750958f, -0.03564463f, 0.02686571f, 0.14799462f, -0.06449351f, 
    0.16614257f, -0.08933595f, -0.03468785f, 0.07971436f, -0.92399293f, 0.00058382f, 0.11126909f, 0.12944518f, 
    0.08186884f, -0.08095638f, 0.03591218f, 0.04581847f, 0.08210775f, 0.26675823f, -0.04524187f, 0.19951032f, 
    -0.15414068f, -0.14257815f, -0.17115776f, 0.13173659f, 0.29314303f, 0.21353923f, -0.00882835f, -0.04200751f, 
    0.12737775f, 0.01408862f, -0.00514774f, 0.09794824f, -0.05003898f, -0.01717168f, 0.08196004f, 0.09357797f, 
    -0.06779880f, -0.16755022f, -0.16535069f, -0.05988176f, 0.06784174f, 0.07235785f, 0.04512170f, -0.11359950f, 
    0.03562655f, -0.05408992f, 0.12553138f, 0.10780211f, -0.08911972f, -0.13660985f, -0.00786077f, -0.10465813f, 
    -0.00041346f, -0.01327092f, -0.11314005f, 0.12450547f, 0.22152375f, 0.10027753f, 0.00794203f, 0.02977919f, 
    -0.18921040f, 0.14843108f, -0.27125257f, -0.05651445f, 0.05794968f, 0.06573869f, -0.00840441f, 0.09691544f, 
    0.11330076f, -0.17464322f, 0.01971918f, 0.05286880f, 0.13530384f, 0.25839734f, 0.05811922f, -0.00604430f, 
    -0.22432230f, 0.17149867f, 0.11822031f, -0.17617667f, 0.19269346f, 0.12720932f, -0.12528725f, 0.07605392f, 
    -0.00266230f, -0.22343123f, -0.02563352f, -0.06010205f, 0.05862400f, -0.04207125f, 0.07965068f, -0.00809672f, 
    -0.24917972f, -0.29985416f, 0.13071424f, 0.28116450f, -0.21352021f, -0.12648252f, 0.07297035f, 0.05170654f, 
    0.07521926f, 0.06814868f, 0.14158000f, 0.14266786f, 0.16372386f, 0.25831187f, -0.10899692f, -0.07755105f, 
    0.19086924f, 0.14009479f, -0.14584599f, -0.08701538f, 0.03093101f, -0.20033000f, 0.02625786f, 0.17813726f, 
    -0.05986403f, 0.51021302f, -0.18288657f, 0.36789492f, -0.05886839f, -0.06580447f, -0.04437204f, 0.00655034f, 
    -0.01293617f, 0.07086959f, 0.14450742f, -0.01761249f, 0.26582661f, 0.01480993f, 0.29290879f, 0.43145993f, 
    0.16593711f, 0.29734567f, 0.03151283f, 0.12616751f, 0.14444377f, -0.02065438f, 0.03480396f, -0.18331286f, 
    -0.15604673f, 0.08978174f, -0.08393420f, 0.16550860f, -0.05300017f, 0.11263655f, 0.13806035f, 0.11028120f, 
    -0.12097745f, 0.16391116f, 0.15745535f, 0.00920363f, 0.55158520f, -0.17035979f, -0.09019254f, -0.02150251f, 
    0.05336624f, 0.07814568f, 0.06809450f, -0.08122750f, 0.04934725f, -0.16205479f, -0.03204539f, -0.02667477f, 
    -0.35496679f, 0.12496106f, 0.17689039f, -0.32934290f, 0.07092491f, 0.03165389f, 0.01122683f, 0.24262777f, 
    -0.01769569f, -0.11526101f, 0.14822997f, -0.17380200f, 0.25678927f, -0.17863631f, 0.36419591f, 0.33228728f, 
    -0.05814392f, -0.30272689f, -0.03408806f, -0.03792606f, -0.05295496f, 0.18285848f, -0.20065023f, 0.18692483f, 
    0.02601457f, 0.01810513f, -0.12418914f, -0.10492570f, -0.09159410f, -0.18345800f, 0.00771122f, -0.02653822f, 
    -0.17699844f, 0.05826589f, 0.16813752f, -0.10636237f, 0.66091537f, 0.25894913f, 0.21934178f, 0.22599249f, 
    0.08862357f, 0.03830821f, 0.17742954f, 0.21011256f, 0.11380596f, -0.12683252f, -0.05565881f, -0.13207270f, 
    0.35114428f, 0.44859424f, 0.45691633f, 0.05969701f, 0.00822514f, 0.11880617f, 0.02494424f, 0.23088732f, 
    -0.03950412f, 0.09623847f, 0.04999330f, -0.15434243f, -0.16067803f, -0.01340590f, -0.23621669f, -0.13458660f, 
    0.15186822f, 0.29621881f, 0.11504827f, 0.10788603f, -0.01179980f, -0.07546310f, -0.03854768f, 0.18861404f, 
    -0.14723362f, 0.05974992f, 0.04918437f, -0.06335667f, 0.08473137f, 0.05990608f, -0.05309974f, 0.09472260f, 
    0.16017123f, -0.00688824f, 0.01943160f, -0.16273414f, -0.07547854f, -0.43396044f, -0.10875171f, 0.13007125f, 
    0.09446827f, 0.04320006f, -0.03551131f, -0.03239208f, -0.02747305f, 0.04927895f, -0.06924926f, -0.21829121f, 
    -0.00182834f, -0.12353177f, 0.34311131f, 0.13671130f, -0.00425491f, -0.19579621f, -0.00925529f, 0.21353762f, 
    0.27272370f, -0.03261902f, -0.13479687f, 0.43760183f, -0.33245698f, -0.08134959f, -0.14762042f, 0.14168398f, 
    0.18356457f, 0.30385062f, 0.12515424f, -0.00665993f, 0.09490609f, 0.23255488f, -0.06929342f, -0.01282596f, 
    0.41043207f, 0.28341532f, 0.16001749f, 0.20027670f, -0.02641424f, 0.27080950f, 0.02454367f, 0.05546767f, 
    -0.06523386f, 0.12137114f, -0.11862046f, -0.11491030f, -0.82737780f, 0.00189243f, 0.34250829f, 0.04866582f, 
    -0.06054220f, -0.10171921f, 0.28430739f, 0.17271629f, 0.21440153f, 0.32313395f, -0.09602214f, 0.01986182f, 
    -0.04622844f, 0.01330757f, -0.29008484f, 0.48931301f, 0.23090760f, 0.18552904f, 0.01450049f, 0.03381805f, 
    -0.01217746f, -0.01312666f, -0.07034434f, -0.00246584f, 0.42140836f, 0.26056352f, -0.01285608f, -0.21455432f, 
    -0.01430737f, -0.08006474f, 0.05780182f, 0.06488053f, -0.05764575f, -0.01568794f, 0.00822327f, 0.22913094f, 
    -0.18568458f, -0.04981315f, -0.08204804f, -0.28646693f, 0.08466258f, -0.25321105f, -0.09894671f, 0.03022044f, 
    0.14708595f, -0.20789577f, -0.12809154f, -0.03553913f, -0.08731365f, -0.05774497f, 0.23776297f, -0.26300234f, 
    0.13320521f, 0.16178159f, -0.07302291f, -0.04654073f, -0.00430395f, 0.30601737f, 0.07517296f, 0.17060618f, 
    0.36423254f, -0.16344343f, -0.06474186f, 0.05615523f, 0.07601748f, 0.03536904f, -0.00057843f, -0.08621982f, 
    -0.02593403f, 0.21349576f, -0.04317410f, 0.15565273f, -0.04873758f, -0.17552795f, 0.13960779f, -0.14110704f, 
    0.11777614f, 0.23918173f, 0.00800547f, -0.05256063f, 0.10895482f, -0.18217906f, 0.35392192f, -0.00191165f, 
    0.04368999f, 0.05783970f, 0.15108927f, -0.32115820f, -0.20556127f, 0.17170608f, 0.04935888f, 0.12238828f, 
    -0.03347014f, 0.14586307f, -0.04772622f, 0.30395547f, 0.02954042f, 0.25683162f, -0.01279407f, -0.31416902f, 
    -0.06480427f, 0.09248149f, 0.17010957f, -0.08426379f, 0.04806700f, -0.30474412f, 0.11489488f, 0.09577795f, 
    -0.30467752f, 0.33155793f, 0.04470729f, -0.08163609f, 0.07388274f, 0.14522113f, -0.09427571f, -0.15397765f, 
    -0.01728599f, 0.00861480f, 0.03014891f, 0.11886230f, -0.10590151f, 0.61558980f, 0.20865542f, -0.31801444f, 
    0.19187464f, -0.08909368f, -0.12008942f, 0.05105177f, -0.02197344f, -0.15619771f, -0.10998566f, -0.07382766f, 
    0.35576648f, -0.12928149f, -0.30820328f, -0.18323837f, -0.00530290f, -0.06721689f, 0.10548750f, 0.14464293f, 
    0.02895624f, 0.04945575f, 0.22775099f, 0.10972920f, 0.38366264f, 0.52099895f, -0.05266776f, 0.20376277f, 
    0.19748029f, 0.08711082f, -0.10200156f, -0.09689405f, 0.17166924f, 0.05660211f, 0.16178010f, 0.01915977f, 
    0.33521345f, -0.02512413f, -0.31331143f, 0.05783851f, -0.00676377f, 0.14129034f, 0.08950993f, 0.07486958f, 
    0.07714244f, -0.06035482f, -0.09954705f, -0.14050527f, -0.48425511f, -0.29759446f, 0.26576445f, 0.61333835f, 
    -0.10519004f, -0.08567402f, 0.08147373f, -0.22457109f, -0.01280122f, 0.06096423f, 0.10371719f, -0.05928393f, 
    -0.23490243f, -0.03643721f, -0.00011156f, 0.04581869f, 0.01016110f, -0.06200321f, 0.08231273f, 0.10650209f, 
    -0.01554224f, 0.16593802f, 0.13463865f, 0.10729407f, -0.02774488f, 0.10085133f, -0.66206002f, 0.20492429f, 
    0.20550983f, -0.05701551f, -0.19808000f, 0.00386699f, -0.06242458f, -0.00408603f, -0.14042906f, -0.05678659f, 
    0.33937961f, -0.24196984f, 0.07464175f, -0.38516709f, -0.08193066f, -0.19595189f, -0.03542287f, -0.11891659f, 
    0.07256306f, 0.19249409f, -0.00445670f, 0.03086065f, -0.01600172f, 0.10907806f, 0.15931989f, 0.08529094f, 
    0.15935604f, -0.17278820f, -0.22847997f, 0.04436879f, 0.16812865f, -0.13940080f, -0.15705757f, -0.26834041f, 
    0.16858022f, 0.13442682f, -0.06233415f, 0.10177504f, -0.08322295f, -0.07137110f, 0.12385555f, -0.05056280f, 
    0.11859173f, 0.16216412f, -0.03870284f, 0.11135186f, -0.15397321f, 0.25766975f, -0.08862735f, 0.26727289f, 
    0.37052524f, -0.25882685f, 0.01396612f, 0.00610376f, 0.11676317f, 0.04070473f, 0.02300586f, 0.01505266f, 
    -0.04137559f, -0.26728415f, 0.10605833f, 0.05744731f, 0.15483122f, 0.15991218f, -0.02862790f, 0.00742031f, 
    0.03267382f, 0.00513868f, -0.08737507f, 0.11806197f, 0.23421384f, -0.09968492f, -0.30938128f, 0.12557274f, 
    0.14902602f, 0.03659354f, -0.11668614f, 0.07877530f, 0.11592805f, -0.00968532f, -0.15792756f, 0.09048877f, 
    -0.04706109f, -0.01388377f, -0.05039655f, -0.05444075f, -0.02029693f, 0.04895662f, -0.07160083f, -0.01786284f, 
    0.05444890f, 0.06108846f, 0.06366790f, 0.03634579f, -0.06585792f, 0.03611502f, 0.06499933f, -0.01950224f, 
    -0.06499306f, -0.02524104f, -0.01641705f, -0.07775404f, 0.03364504f, -0.04957026f, 0.00314090f, 0.03544100f, 
    -0.06452192f, -0.06766334f, -0.07121864f, 0.02715539f, -0.06741306f, 0.03576224f, 0.04308740f, 0.03988902f, 
    0.04003219f, -0.04031803f, 0.03131296f, 0.02031380f, -0.01686413f, -0.06843415f, -0.02935269f, -0.00377346f, 
    -0.01485496f, 0.02635064f, 0.04294485f, -0.00658609f, 0.05854627f, -0.06398724f, 0.06398582f, -0.06890657f, 
    -0.01934401f, -0.01242644f, -0.06360880f, -0.01355640f, 0.05527180f, 0.00803198f, 0.02632336f, -0.04278352f, 
    0.04880689f, -0.05026912f, -0.03828196f, -0.01851168f, 0.01586225f, 0.05602400f, -0.01366300f, -0.07028240f, 
    -0.03276572f, -0.04874811f, 0.02542283f, 0.02425173f, -0.03336680f, 0.02568919f, -0.03256321f, 0.07069440f, 
    0.01279735f, -0.02583078f, -0.02870295f, -0.03271697f, -0.02235447f, -0.01940659f, -0.06317808f, -0.00690716f, 
    0.01069693f, -0.06855988f, 0.04142619f, 0.02004943f, -0.02129119f, -0.03527981f, -0.02158688f, -0.03251030f, 
    0.01692649f, -0.01928770f, -0.04132307f, 0.05155103f, 0.06314056f, -0.04420986f, 0.01900561f, -0.03850095f, 
    -0.03514498f, -0.03658230f, 0.02706097f, 0.04004166f, -0.04548847f, 0.01627453f, -0.03951033f, 0.02670746f, 
    0.03451259f, -0.02355497f, -0.06818497f, -0.07551084f, -0.03851552f, 0.00411006f, -0.04157629f, -0.01891796f, 
    -0.04700593f, -0.07095294f, 0.03665853f, -0.05563875f, 0.05634467f, 0.00451447f, -0.07782737f, -0.02356961f, 
    -0.06776656f, -0.03445579f, 0.05975629f, -0.05584340f, -0.04632025f, -0.07699069f, 0.05412309f, -0.00988792f, 
    -0.07771924f, 0.06000972f, -0.05902452f, -0.03836866f, -0.03050019f, 0.02207631f, 0.01820267f, 0.01843715f, 
    0.04152493f, 0.03998125f, -0.07351343f, -0.06835131f, 0.02814825f, -0.04727752f, -0.02925286f, -0.07684562f, 
    -0.07006667f, -0.05590395f, -0.00327405f, -0.01082174f, -0.05358264f, -0.00639769f, -0.03824798f, -0.04092392f, 
    -0.01186098f, -0.05375893f, 0.03787473f, 0.01236328f, -0.02561558f, 0.04891616f, 0.00735991f, 0.02536902f, 
    -0.06301256f, 0.04034575f, 0.00606529f, -0.01250828f, -0.00000633f, -0.07486205f, -0.07695668f, 0.01308318f, 
    0.03848011f, -0.05555410f, -0.04957938f, -0.01960977f, 0.01087494f, 0.02309661f, 0.04378700f, 0.01849116f, 
    0.04405432f, 0.06070210f, -0.07797849f, 0.04907566f, -0.06358854f, 0.05898363f, 0.02137714f, -0.04378068f, 
    -0.04495753f, -0.04303335f, -0.07704218f, -0.01331064f, 0.05071415f, 0.00729398f, -0.00353269f, -0.03563311f, 
    0.03541986f, -0.03858721f, -0.04921649f, -0.02519668f, -0.06290597f, 0.01003261f, 0.03194496f, -0.01703872f, 
    0.05898038f, 0.02664557f, -0.01656415f, -0.01414304f, 0.03481527f, 0.05048173f, -0.05443016f, 0.03839611f, 
    0.00196062f, 0.03148742f, 0.01744118f, -0.02112313f, 0.05610145f, -0.02947216f, -0.00156063f, 0.04498531f, 
    0.00288720f, -0.00383695f, -0.06540006f, 0.01876134f, -0.03204991f, 0.00496124f, 0.01245098f, 0.02157192f, 
    0.03234559f, 0.05869684f, 0.01178289f, -0.00843678f, 0.01413706f, -0.01855189f, -0.02049717f, 0.00546956f, 
    -0.01625732f, -0.05059979f, -0.00786076f, -0.00774497f, 0.02314638f, -0.04164447f, -0.02356023f, 0.03739534f, 
    -0.08401887f, 0.03143648f, -0.06830374f, -0.04530118f, 0.02111505f, -0.08331394f, 0.03879763f, -0.00206883f, 
    0.04301298f, -0.05453918f, -0.02484787f, 0.02436800f, 0.04722500f, 0.00190847f, -0.05021545f, -0.04561835f, 
    -0.05454801f, 0.00097528f, -0.07370967f, -0.05466264f, 0.05334194f, 0.00310022f, 0.00236481f, -0.03505467f, 
    -0.03418703f, 0.04984940f, -0.07648110f, 0.05528529f, -0.05345521f, -0.04936844f, -0.05140562f, -0.08160417f, 
    0.01847619f, 0.03147632f, -0.03875917f, -0.02154500f, 0.03096426f, -0.08309905f, -0.03646117f, 0.00084466f, 
    0.04426934f, 0.04221420f, -0.00809421f, -0.07769849f, -0.01016363f, -0.08097509f, -0.02286385f, -0.04128429f, 
    -0.01264937f, -0.01645992f, -0.07814589f, -0.03757709f, 0.02742177f, -0.01612580f, -0.03084148f, -0.03300209f, 
    -0.00469686f, 0.04715429f, -0.03990990f, 0.03684442f, -0.00529049f, -0.07329577f, -0.04512828f, 0.04785083f, 
    -0.05453840f, 0.02459546f, 0.01737141f, -0.03700628f, 0.01793367f, -0.05752671f, -0.01724663f, 0.01084523f, 
    -0.06872360f, 0.04126606f, 0.01561731f, -0.02475375f, -0.01801497f, -0.00059754f, -0.03871563f, 0.04369064f, 
    0.00212801f, -0.01640345f, 0.00205520f, -0.00299712f, -0.00447033f, 0.01801517f, -0.01704665f, -0.03764822f, 
    -0.03416718f, -0.07373101f, -0.04861088f, -0.01830746f, 0.02379883f, 0.01394795f, -0.05526884f, -0.07487377f, 
    0.01631241f, 0.01851609f, 0.04815298f, 0.00405539f, 0.05504477f, -0.01908849f, -0.05311213f, 0.03434402f, 
    -0.03372305f, -0.02699114f, 0.06050424f, 0.03613654f, 0.02056963f, 0.03646475f, 0.01435545f, 0.00335472f, 
    0.03047998f, 0.04762274f, -0.01315899f, 0.04166316f, 0.04395980f, 0.00441139f, 0.02146135f, -0.06115344f, 
    -0.07581931f, -0.06594225f, -0.02222233f, 0.03062281f, 0.00846042f, 0.02201962f, -0.00152971f, 0.05255301f, 
    0.01749241f, -0.02125179f, 0.03134409f, 0.05183627f, -0.01057900f, -0.05000165f, -0.04175152f, -0.03136552f, 
    -0.05663313f, 0.01583000f, 0.02195012f, -0.03171627f, -0.06105465f, 0.02481141f, -0.00141967f, -0.04741614f, 
    0.28024894f, 0.16351929f, -0.10956176f, 0.64168441f, -0.01421927f, 0.04691609f, -0.06880055f, 0.06689104f, 
    -0.07297815f, -0.04728616f, -0.01775128f, 0.08852286f, -0.09220089f, -0.44561541f, 0.29192445f, 0.11566417f, 
    0.03433118f, 0.23313071f, -0.18332906f, 0.20075111f, -0.07180414f, 0.12652163f, -0.02704531f, -0.02072700f, 
    0.31142280f, -0.21743600f, 0.14235403f, 0.39488235f, 0.30246374f, 0.11182681f, -0.12310319f, 0.26848108f, 
    0.19993763f, -0.05681594f, -0.01827228f, 0.16410109f, 0.69902092f, 0.04786361f, 0.34641880f, 0.60064173f, 
    -0.15909460f, 0.01183274f, 0.09800212f, -0.07703827f, -0.05016884f, 0.00909575f, 0.11399231f, -0.06985957f, 
    -0.43299183f, -0.46842891f, -0.11269479f, -0.25735560f, -0.03825638f, -0.19409671f, -0.03512954f, -0.07900786f, 
    -0.10453896f, 0.01219535f, -0.03412155f, 0.05374802f, 0.05762560f, 0.24994324f, 0.24556103f, -0.43814662f, 
    0.01385558f, 0.08625494f, 0.34742650f, -0.08958391f, -0.05376449f, -0.11000422f, -0.00719422f, 0.17505342f, 
    -0.22909427f, -0.26650181f, -0.03196521f, -0.18740453f, 0.05866961f, 0.06854359f, -0.05205131f, 0.02079036f, 
    -0.02495459f, -0.15057601f, -0.14505340f, -0.19876145f, 0.13350187f, 0.20953834f, 0.10042705f, -0.00520061f, 
    0.33897367f, -0.04717822f, 0.05428622f, 0.14752978f, 0.04652622f, -0.02967659f, 0.01799330f, 0.12035288f, 
    0.61579752f, -0.21211472f, -0.26095560f, -0.23250663f, -0.10169679f, 0.09397885f, 0.01630241f, -0.15097234f, 
    0.14680454f, -0.07688729f, 0.03125089f, -0.07196365f, 0.69168639f, 0.27436271f, 0.23358116f, -0.38247970f, 
    0.06192978f, -0.06065550f, 0.00126947f, 0.10003448f, 0.05057756f, -0.10041586f, 0.00451722f, 0.01431814f, 
    0.07318011f, 0.19933541f, 0.49513873f, -0.53173697f, -0.04156180f, 0.14437723f, -0.10960542f, -0.04886504f, 
    -0.14089219f, -0.04475374f, -0.05654823f, -0.02421093f, -0.20832333f, -0.10231948f, 0.04189494f, 0.03922075f, 
    0.17963047f, -0.11637386f, -0.03644500f, 0.24180715f, 0.08788687f, -0.04405504f, -0.11691722f, 0.03164517f, 
    0.02485135f, 0.43438968f, 0.11462336f, 0.17596863f, -0.09016068f, 0.13236636f, -0.05496551f, 0.15093300f, 
    -0.23868611f, 0.09315571f, -0.12014066f, 0.14487134f, 0.24103667f, 0.13420673f, 0.11195332f, 0.18322103f, 
    -0.15322013f, -0.00329672f, 0.02095576f, -0.23449939f, 0.08248422f, -0.09561964f, 0.00035889f, -0.19271661f, 
    0.28502896f, 0.04966791f, 0.12282851f, 0.11496280f, 0.14903747f, 0.04720222f, -0.23015529f, -0.05703114f, 
    0.03563108f, -0.02748809f, 0.04396717f, -0.04400212f, -0.23959842f, -0.41968954f, 0.00512657f, -0.14306122f, 
    0.08254347f, -0.21583536f, 0.09700945f, -0.15233371f, -0.07301176f, 0.00462613f, -0.01165376f, 0.06503557f, 
    0.33836609f, 0.09410833f, -0.10954700f, 0.04782721f, -0.21836589f, -0.00577065f, 0.00977035f, 0.10225302f, 
    -0.01335947f, -0.03988724f, 0.04435614f, -0.07298306f, -0.12843212f, -0.05957840f, -0.20103925f, 0.18937440f, 
    0.11303614f, -0.05528215f, 0.27837878f, 0.28479186f, -0.10466674f, 0.15072359f, -0.00457057f, -0.04168978f, 
    0.01889313f, -0.09684089f, -0.26183653f, -0.39023858f, -0.03082086f, -0.02790627f, 0.10166649f, 0.23973025f, 
    0.06034975f, 0.17462820f, 0.05670660f, -0.13313866f, 0.11126129f, 0.11556805f, 0.02877290f, 0.10542986f, 
    -0.23648629f, 0.12795101f, 0.02006171f, 0.21387261f, 0.21154477f, 0.08895794f, 0.04971337f, -0.02196076f, 
    -0.23271152f, 0.03672628f, -0.15450558f, 0.13534540f, -0.04738931f, -0.07272644f, -0.00090819f, -0.05479170f, 
    0.01376773f, -0.05028158f, 0.01356934f, -0.07961612f, 0.31868899f, -0.00413394f, 0.28389239f, -0.04461863f, 
    -0.24223183f, -0.07834347f, 0.12004755f, 0.04596559f, 0.17093420f, -0.10671331f, 0.00680596f, 0.01374008f, 
    -0.24851227f, -0.13116013f, 0.18749334f, -0.07574709f, -0.14400731f, -0.01581475f, 0.00390385f, 0.09439930f, 
    0.04739143f, -0.02790791f, -0.03165704f, 0.10787368f, -0.33600348f, 0.16211128f, -0.11263903f, -0.07365997f, 
    -0.00051522f, 0.08617632f, 0.05601583f, 0.00641875f, 0.09000225f, 0.16863310f, -0.12036368f, -0.00539400f, 
    -0.20203577f, 0.23252597f, -0.21871838f, -0.11060032f, -0.00115133f, 0.22288464f, 0.02948808f, 0.13948706f, 
    0.02768972f, -0.10749222f, 0.01623860f, 0.01296117f, 0.16489989f, -0.38138634f, 0.31091917f, -0.39298141f, 
    0.11693399f, -0.05833071f, 0.12265430f, 0.14364362f, 0.09322014f, 0.15601417f, -0.00417549f, 0.04879342f, 
    0.17117745f, -0.08416120f, 0.15661886f, -0.00655280f, 0.10957853f, 0.07287902f, 0.01777660f, 0.00733658f, 
    -0.08233109f, -0.00276572f, 0.07060616f, 0.12283864f, -0.24571204f, -0.29109451f, 0.10208954f, 0.14729312f, 
    -0.10156436f, -0.02418468f, 0.13310179f, -0.09294660f, 0.08299117f, 0.03358998f, -0.14224231f, 0.25579977f, 
    0.97882885f, 0.10254777f, -0.16055486f, -0.10254022f, -0.25460780f, -0.04357490f, 0.05944962f, 0.07882781f, 
    0.05817809f, -0.10052043f, -0.03183981f, 0.15118203f, 0.84328723f, -0.07004350f, 0.05872076f, -0.06120685f, 
    -0.13888940f, -0.21465664f, -0.07321541f, -0.00956842f, 0.10500643f, -0.07849035f, 0.05331361f, -0.00295044f, 
    -0.31846991f, 0.05177978f, -0.17373310f, -0.06865319f, 0.40643778f, 0.13645430f, -0.03064494f, -0.00344828f, 
    0.12443932f, -0.00137340f, -0.12791178f, 0.27545086f, -0.00235710f, -0.04540315f, 0.12857307f, -0.04511255f, 
    -0.13330539f, 0.19584768f, -0.02648360f, -0.09259197f, -0.02737372f, 0.02246118f, 0.25715414f, -0.12214590f, 
    0.03397329f, -0.05477753f, -0.04967572f, 0.05069156f, -0.03238703f, -0.04903323f, 0.04862237f, -0.05119663f, 
    -0.00959179f, -0.00470954f, 0.01814141f, -0.03617758f, 0.03325437f, -0.00710626f, 0.00572698f, 0.01374794f, 
    -0.03823330f, 0.01711490f, 0.01158172f, 0.04989404f, -0.01647888f, -0.01052459f, -0.01112217f, -0.02069485f, 
    0.06641569f, -0.06385220f, 0.05037837f, -0.05916080f, 0.05338292f, 0.02806193f, 0.00854907f, -0.01334805f, 
    -0.01915394f, 0.01010639f, 0.06629527f, -0.00537939f, 0.04951448f, -0.04388187f, 0.02591240f, -0.06809286f, 
    0.04343278f, -0.03754127f, 0.00714419f, 0.02793356f, -0.07992739f, 0.04454210f, 0.00631278f, -0.05622719f, 
    0.01523630f, -0.03068656f, -0.05322988f, 0.03396882f, 0.06568497f, -0.04687738f, -0.04755151f, -0.06566354f, 
    0.05324540f, 0.01130139f, 0.00074965f, -0.02832598f, 0.01141307f, -0.04191754f, 0.01909296f, -0.07517286f, 
    -0.04676284f, -0.01277796f, 0.05214912f, -0.01695119f, 0.03165247f, -0.05462176f, 0.01261027f, -0.04030302f, 
    -0.02107191f, 0.03032226f, 0.00206595f, 0.02875075f, 0.06628279f, 0.03901187f, -0.04978085f, -0.02307907f, 
    0.04708806f, -0.00526026f, -0.07184021f, 0.02379489f, -0.07191473f, 0.02279372f, 0.05900896f, 0.04766875f, 
    -0.04664727f, -0.07747729f, -0.03518902f, 0.06207436f, -0.06716567f, -0.02754343f, -0.05760808f, 0.00399976f, 
    -0.03868766f, -0.04030185f, -0.00889884f, 0.03711554f, 0.02402192f, 0.02235172f, -0.01517390f, 0.05073901f, 
    0.04927942f, -0.00265598f, 0.01163021f, -0.06952289f, 0.02596151f, -0.02472532f, -0.02529326f, 0.02475962f, 
    -0.03930435f, -0.03382694f, -0.08011626f, -0.06004228f, -0.06192087f, 0.05297547f, -0.06576542f, -0.05669713f, 
    0.01127225f, -0.05576200f, 0.04915049f, -0.07447898f, 0.01057999f, 0.00524728f, 0.03149314f, -0.03179555f, 
    -0.01589194f, -0.00140708f, -0.02407558f, -0.01024751f, -0.01175255f, -0.08068082f, 0.06468070f, 0.01595258f, 
    -0.03234562f, -0.00891558f, -0.06705496f, -0.07662006f, -0.03780735f, -0.01968482f, -0.04445285f, -0.02825509f, 
    -0.01018689f, 0.00820181f, 0.01638342f, -0.07337741f, -0.05160514f, 0.03010327f, -0.06695956f, 0.00791383f, 
    -0.03011642f, -0.00792958f, -0.00207582f, 0.03686980f, 0.04398033f, -0.05429368f, 0.04213662f, -0.00697864f, 
    0.02799634f, -0.00168536f, -0.01185390f, -0.00828299f, 0.01469451f, -0.06064647f, 0.00721211f, 0.06071066f, 
    0.03853137f, -0.05108773f, -0.01226323f, -0.03828109f, 0.05413604f, 0.02661541f, 0.00697473f, 0.05871733f, 
    0.04718584f, -0.00966546f, 0.01748654f, 0.04297074f, -0.06414644f, -0.01744663f, -0.00748634f, 0.06699202f, 
    -0.03155843f, -0.03029549f, -0.00459388f, -0.01822651f, -0.03152907f, 0.02668558f, 0.00542790f, -0.06999616f, 
    -0.42632911f, -0.32128066f, -0.25647813f, 0.41024381f, 0.21050023f, 0.05186084f, -0.10061664f, 0.10975581f, 
    0.03316660f, -0.03262296f, -0.02329678f, 0.07734993f, 0.60241067f, -0.05822205f, 0.00043375f, 0.05490704f, 
    -0.05560783f, -0.08632243f, 0.02727717f, 0.10239486f, -0.13591549f, -0.03395821f, 0.13695465f, -0.05115278f, 
    0.36299911f, 0.13662913f, 0.27805555f, -0.19483113f, -0.25413305f, -0.02427370f, 0.09947439f, -0.00750054f, 
    0.06132362f, -0.00986533f, -0.22769891f, 0.06101763f, 0.27702278f, -0.34554824f, -0.27908054f, -0.26391360f, 
    0.36385769f, -0.03880725f, -0.10673177f, -0.02652833f, 0.11545461f, 0.01390989f, -0.11177279f, -0.15611693f, 
    0.19338322f, 0.32675463f, -0.31156057f, 0.41919097f, 0.07699613f, 0.04448316f, 0.00917864f, 0.02895557f, 
    -0.18500473f, 0.19618434f, 0.18031247f, -0.11422628f, 0.19236480f, 0.25288409f, 0.31967404f, -0.19293107f, 
    0.23146905f, -0.22460009f, 0.32819846f, 0.08417612f, 0.11298293f, 0.04784178f, 0.09038766f, 0.10494067f, 
    0.12955651f, 0.21211874f, -0.25115693f, -0.07874752f, -0.07011224f, 0.07069402f, 0.24625704f, 0.16713366f, 
    0.04682787f, 0.17854357f, -0.09277420f, -0.30269718f, -0.57940847f, 0.21863334f, -0.07937100f, -0.01989879f, 
    -0.03590873f, 0.07166269f, 0.04657368f, 0.02686950f, -0.01228807f, -0.03551031f, -0.01483226f, 0.03848505f, 
    0.18667547f, 0.19326001f, -0.29537100f, -0.31233981f, 0.03268869f, 0.08978422f, -0.06532215f, 0.00548751f, 
    0.06639408f, -0.07022950f, 0.16269337f, 0.11672177f, 0.55618602f, -0.11963790f, 0.21435872f, -0.37130216f, 
    -0.09189396f, -0.10715645f, 0.00174705f, -0.10572468f, -0.08257437f, -0.07701321f, -0.09847535f, 0.02213854f, 
    0.30007857f, -0.10095444f, 0.20501290f, 0.05616299f, -0.01763161f, -0.02451097f, 0.09525900f, -0.00227770f, 
    0.00174362f, 0.09391709f, 0.03041877f, 0.07491335f, -0.62473673f, -0.13070370f, 0.12758447f, 0.06374523f, 
    -0.12777671f, 0.22629847f, -0.01036672f, -0.04261596f, 0.02537140f, 0.06467270f, -0.00489279f, 0.03011699f, 
    0.39606717f, -0.36707178f, -0.21341871f, 0.20735878f, 0.10680214f, -0.04242207f, 0.09113448f, -0.16276385f, 
    -0.01193353f, 0.10229439f, 0.08226671f, 0.20191602f, 0.19161500f, 0.05291896f, 0.13148104f, 0.07897982f, 
    -0.22294560f, 0.04253244f, 0.11894715f, 0.06686255f, 0.10114207f, -0.10235755f, 0.13375008f, -0.03841260f, 
    0.28498390f, 0.38092694f, -0.04219360f, 0.16829476f, -0.05615227f, 0.19044165f, -0.12854008f, 0.11387637f, 
    0.18531123f, 0.10368434f, -0.10226283f, 0.08493306f, 0.46980754f, 0.32030860f, -0.10885427f, 0.02067148f, 
    -0.10960452f, 0.14771353f, -0.08204020f, 0.05776251f, 0.02736286f, 0.13898936f, -0.11468115f, -0.06716632f, 
    -0.01316194f, 0.03683880f, -0.07654727f, -0.05567509f, -0.01038972f, -0.04478955f, 0.01808270f, -0.05417392f, 
    0.05580566f, -0.01810613f, -0.06717182f, -0.03610066f, 0.01282864f, -0.03775096f, 0.03635037f, -0.05204709f, 
    -0.00078932f, 0.02606998f, 0.00423623f, -0.04260854f, 0.02602889f, -0.01049811f, -0.06092065f, -0.03641355f, 
    -0.00689459f, 0.04280527f, 0.00871223f, -0.04752971f, -0.01441302f, 0.00958887f, -0.02813469f, 0.05347714f, 
    0.04066202f, -0.07375921f, 0.06478494f, -0.00755372f, 0.02829363f, -0.02700422f, -0.00248398f, -0.06908252f, 
    -0.06464246f, 0.02385759f, 0.00206178f, -0.05306645f, -0.03344279f, 0.04601147f, -0.05244591f, -0.06886595f, 
    0.04752439f, 0.01255209f, 0.05504863f, 0.03092293f, -0.05338205f, -0.07567681f, -0.04311432f, -0.03980352f, 
    -0.03056392f, 0.02158889f, -0.01238037f, -0.02686507f, 0.00116052f, -0.05224789f, 0.05008641f, -0.01013796f, 
    -0.03486617f, -0.04990780f, -0.06858024f, -0.06702721f, -0.03712211f, -0.00534749f, 0.04430616f, 0.04142127f, 
    -0.00195341f, 0.05076938f, 0.03260704f, -0.05730720f, 0.01843272f, -0.01754568f, -0.05335417f, 0.00920715f, 
    0.04677180f, -0.03709981f, 0.00656307f, 0.00119801f, -0.07521375f, 0.00052629f, -0.05971483f, -0.05506089f, 
    -0.02217798f, -0.02015457f, -0.01029433f, 0.00390099f, 0.03025507f, -0.03877217f, -0.03968793f, 0.01760617f, 
    0.04009527f, 0.05619513f, -0.01149188f, -0.00351662f, 0.00323113f, 0.02897480f, -0.03773574f, -0.01723610f, 
    0.04689795f, -0.00112949f, 0.02684560f, -0.06919775f, 0.04571134f, 0.04816410f, -0.01625490f, 0.04417709f, 
    -0.02243708f, -0.06875660f, -0.05835296f, 0.02600863f, -0.02288495f, 0.02746381f, 0.02243183f, -0.03307231f, 
    0.00796715f, 0.00055686f, 0.03250874f, -0.01863588f, 0.06449862f, -0.07737646f, 0.06555889f, -0.00089658f, 
    -0.07152940f, -0.05131957f, -0.04640887f, -0.04919176f, -0.02764039f, 0.03650609f, 0.01591330f, 0.04000215f, 
    0.06686391f, -0.04741982f, -0.00328585f, -0.07568848f, -0.00348009f, 0.01493908f, 0.00982120f, -0.05109902f, 
    -0.05526603f, 0.04857432f, 0.05240249f, -0.01562125f, -0.07030103f, -0.02678023f, -0.05983083f, -0.02829970f, 
    0.03228931f, 0.02657115f, -0.07279695f, -0.02116062f, -0.07089579f, 0.00158999f, -0.02264374f, -0.01316541f, 
    -0.00768956f, -0.06340146f, 0.03462844f, 0.00047893f, 0.02579491f, -0.05999493f, -0.05966404f, -0.01155484f, 
    -0.05315826f, 0.04307074f, -0.02745895f, -0.03303139f, 0.00170453f, -0.04408547f, -0.01341706f, 0.03083550f, 
    0.01141727f, -0.03685975f, -0.03882772f, 0.01184614f, -0.00686290f, -0.01984606f, -0.02288648f, 0.01548731f, 
    -0.06385543f, 0.03445764f, 0.05291539f, 0.05239551f, 0.00469587f, -0.01679012f, -0.05285412f, 0.00025492f, 
    -0.04736643f, 0.04551505f, -0.02331613f, -0.07035655f, -0.04363248f, -0.07432045f, 0.03196157f, -0.03180736f, 
    0.06466620f, 0.05985696f, -0.05356425f, -0.02273796f, 0.05171438f, -0.06665718f, 0.01157312f, 0.02215703f, 
    0.04143738f, -0.05905417f, -0.02099025f, 0.03470933f, -0.05591052f, 0.00101466f, -0.01387306f, -0.04172821f, 
    0.05301703f, -0.07383465f, 0.04766731f, 0.03229710f, 0.05148502f, 0.05696256f, -0.01051717f, -0.06035265f, 
    0.03743342f, -0.01563761f, -0.07633498f, 0.05114760f, -0.04741852f, -0.05992445f, -0.01340891f, 0.00168493f, 
    -0.03017717f, -0.01042450f, -0.01029697f, 0.04373261f, -0.05278629f, -0.06687593f, 0.01533543f, 0.03128489f, 
    0.02161063f, 0.03874653f, 0.01177148f, -0.03353893f, 0.00564009f, -0.00413041f, 0.06326052f, 0.04433618f, 
    -0.04929085f, 0.04935255f, 0.02259328f, -0.02790064f, -0.06060316f, -0.06932873f, -0.02461611f, 0.04145434f, 
    -0.03541636f, 0.05609550f, -0.06013715f, 0.00625434f, 0.02891910f, -0.03256969f, 0.04815252f, -0.06829605f, 
    0.03621288f, -0.00842644f, -0.04502695f, -0.04446790f, 0.02198935f, -0.03716909f, -0.00975351f, -0.07280102f, 
    -0.04814526f, -0.05908019f, -0.03685619f, 0.00859910f, -0.01359765f, 0.05437789f, -0.03209896f, 0.03497895f, 
    -0.00410363f, -0.06101229f, -0.02760983f, -0.00723566f, -0.02285043f, 0.02808178f, 0.01889271f, 0.03261239f, 
    -0.01523272f, -0.00536453f, -0.01464328f, 0.00577368f, -0.01138704f, -0.06054810f, 0.05759182f, -0.00475250f, 
    0.01871455f, -0.04101990f, -0.07261008f, -0.07240223f, -0.02628347f, 0.00570768f, 0.03305011f, -0.04032364f, 
    0.03143270f, -0.05022170f, 0.05050815f, 0.05560412f, 0.01904820f, 0.03166628f, -0.00759777f, 0.00895542f, 
    0.06047310f, 0.04429371f, 0.01259339f, 0.05281461f, -0.00706796f, -0.00242271f, 0.05614493f, -0.04521639f, 
    -0.07054892f, -0.06423894f, 0.03175456f, 0.01497444f, -0.03590524f, 0.00266141f, 0.03445635f, 0.01091375f, 
    -0.01070866f, 0.01658777f, -0.07131705f, -0.07267290f, -0.00047793f, 0.05297512f, 0.01954071f, -0.00165761f, 
    0.03505759f, 0.01296259f, -0.07100730f, 0.05299366f, 0.00396255f, -0.04243207f, -0.01646239f, 0.01926554f, 
    0.04549119f, 0.02660913f, 0.01343191f, -0.07904332f, 0.00881209f, -0.06803209f, -0.05169586f, 0.00066296f, 
    -0.04995003f, -0.03975756f, -0.01385425f, -0.04561447f, -0.05502560f, 0.04537555f, -0.07353017f, 0.05294022f, 
    -0.00568702f, 0.02170744f, 0.01011194f, 0.03970511f, -0.03884318f, -0.03657085f, -0.04915455f, 0.01407940f, 
    -0.01358640f, -0.01030868f, -0.03609673f, -0.07253921f, -0.07507392f, -0.07479949f, 0.02712730f, -0.06139610f, 
    -0.07012773f, -0.00705492f, 0.00883565f, -0.07158043f, 0.01883486f, -0.05256343f, -0.03119686f, -0.01024544f, 
    0.02694508f, -0.00609446f, -0.05233534f, -0.00306170f, -0.01318787f, -0.04403600f, -0.07081125f, 0.00513865f, 
    -0.02858127f, 0.01404385f, -0.05955051f, -0.06847216f, 0.03138907f, -0.01485478f, -0.04344570f, -0.08332164f, 
    0.00536387f, -0.06060513f, -0.06433821f, -0.05205583f, 0.03817185f, 0.01007749f, -0.06414212f, 0.02212468f, 
    0.03931207f, 0.02181673f, -0.04174739f, -0.03123906f, -0.02282859f, -0.02875530f, 0.05197284f, -0.04344413f, 
    0.02468210f, -0.08796622f, 0.04530906f, 0.04370079f, -0.07414497f, -0.09175828f, -0.02413903f, 0.04585119f, 
    0.00098328f, 0.00907720f, -0.06705222f, -0.03100439f, 0.03745234f, 0.03720042f, -0.08857053f, 0.02839586f, 
    0.02583572f, 0.03018311f, 0.04829845f, -0.04845661f, -0.02430311f, -0.05921286f, -0.05762462f, -0.09176885f, 
    -0.06073159f, 0.00417835f, -0.04307236f, -0.01840931f, -0.09146532f, -0.01857967f, 0.01664474f, -0.10082655f, 
    -0.01337880f, 0.01604569f, -0.01152662f, 0.04148906f, -0.05557181f, -0.04225317f, -0.01299328f, -0.06789555f, 
    0.01781326f, -0.08328056f, 0.01586520f, -0.03260874f, -0.03053700f, -0.02507371f, -0.02619753f, -0.03032893f, 
    -0.04303698f, 0.01968918f, -0.04186448f, -0.03632022f, -0.01468788f, -0.03886257f, 0.02990879f, -0.04770478f, 
    0.02659163f, -0.00016482f, 0.01161255f, -0.04214511f, -0.03162998f, 0.01378081f, 0.02174499f, 0.02183673f, 
    0.02843623f, -0.07927676f, -0.03157314f, 0.02419013f, 0.03768621f, 0.00666485f, 0.02492965f, -0.00851986f, 
    0.02438277f, 0.01668394f, 0.05021940f, 0.02955977f, 0.06602610f, -0.02949867f, -0.01681188f, -0.04825980f, 
    -0.06391286f, -0.00253186f, 0.03646636f, 0.00371672f, -0.07075164f, 0.04993971f, -0.01936612f, -0.04162464f, 
    -0.07686005f, -0.04913148f, 0.00435758f, -0.04563554f, -0.06804421f, -0.02723641f, -0.02302218f, -0.01600462f, 
    0.00693905f, 0.01183400f, 0.03325829f, 0.01784279f, -0.00688687f, 0.05483609f, 0.01072232f, -0.03619838f, 
    -0.04178168f, -0.00785061f, 0.02851407f, -0.04483244f, 0.05804277f, 0.05352354f, -0.08337373f, 0.04538218f, 
    0.00535341f, 0.05778565f, 0.01733094f, -0.04607274f, -0.07097661f, -0.04936483f, -0.03820121f, 0.01342696f, 
    -0.07260322f, -0.04560409f, 0.02341436f, -0.08557349f, -0.01892248f, -0.08885428f, -0.02645035f, 0.02926556f, 
    -0.03384064f, -0.08417311f, 0.00906021f, -0.08447060f, 0.00900550f, -0.03752745f, 0.03752941f, 0.02805924f, 
    0.00818143f, -0.01498543f, -0.02619196f, -0.07614749f, 0.02640253f, -0.04431794f, -0.07267499f, 0.01519058f, 
    -0.04680701f, -0.03322377f, -0.04506845f, -0.00432941f, 0.03988855f, 0.03294203f, -0.02939811f, -0.04003289f, 
    -0.01571868f, -0.07708459f, 0.01751412f, 0.06518817f, 0.05930727f, 0.00126639f, -0.03630760f, 0.00357237f, 
    -0.04785115f, -0.00860808f, 0.04103840f, 0.05864590f, 0.00547660f, 0.03317341f, -0.00689679f, 0.01925394f, 
    0.01996939f, 0.03325879f, -0.00810439f, -0.02583188f, 0.01033896f, -0.01696077f, 0.01747845f, -0.01913645f, 
    -0.02278560f, 0.00217837f, -0.01146895f, -0.03670095f, 0.04354613f, -0.06523474f, -0.05266709f, -0.00935547f, 
    -0.00753211f, -0.03373944f, -0.06748531f, -0.07159986f, 0.04837205f, -0.05576981f, -0.06405946f, -0.04396620f, 
    -0.06300019f, 0.02000048f, -0.05651506f, 0.03883995f, -0.01208313f, -0.01856231f, 0.02527406f, -0.06445040f, 
    0.00173260f, 0.04951598f, 0.02734364f, -0.00212108f, -0.02275795f, -0.05898156f, -0.04328902f, 0.00871659f, 
    0.04445618f, -0.04716719f, -0.05904040f, 0.07366247f, 0.04006866f, -0.00365941f, 0.00242905f, -0.04133580f, 
    -0.06963577f, 0.00214779f, -0.00578035f, -0.01121407f, 0.03764627f, -0.02120085f, -0.03781435f, -0.02217065f, 
    0.04636741f, -0.01807790f, 0.01663975f, -0.03535471f, -0.00367845f, 0.01549468f, 0.03723757f, -0.00601216f, 
    -0.05484041f, -0.03810291f, -0.04694545f, -0.02527546f, -0.05581649f, -0.04168085f, -0.06717384f, -0.02012390f, 
    0.01088490f, 0.04134573f, -0.03897367f, 0.03916392f, 0.03508926f, -0.02633934f, -0.04114521f, 0.02972473f, 
    -0.04657574f, 0.03480537f, -0.03729813f, 0.03436698f, 0.01569959f, 0.03112261f, 0.01487199f, -0.03769366f, 
    -0.03369498f, 0.03083802f, -0.04627300f, -0.03176764f, -0.07762925f, -0.04839256f, -0.04634984f, -0.06435405f, 
    0.04037061f, -0.08585943f, 0.02834835f, -0.07252484f, 0.02481890f, -0.07397727f, -0.03558635f, -0.08483034f, 
    0.02116100f, 0.00090150f, 0.04462348f, 0.02195724f, -0.02003656f, -0.01372140f, 0.03854103f, -0.04711382f, 
    0.03210631f, -0.06628767f, -0.06105629f, -0.01637939f, -0.05456568f, -0.04558986f, -0.03629149f, 0.00643950f, 
    0.02660341f, -0.00600647f, 0.04528854f, 0.02011533f, -0.08994756f, -0.02970283f, -0.05856152f, -0.04765696f, 
    -0.07418745f, -0.00579100f, -0.01814124f, -0.08145631f, 0.05626386f, -0.02753381f, 0.02710064f, -0.02623064f, 
    -0.05716213f, 0.00485755f, -0.06468845f, -0.00510209f, -0.06692482f, -0.01843617f, -0.01604092f, -0.01093405f, 
    -0.07723758f, -0.01295573f, 0.03218277f, -0.01673958f, -0.05905458f, -0.03160113f, -0.04261607f, -0.05756541f, 
    0.01386483f, 0.04432788f, 0.01928447f, 0.06093712f, 0.01904250f, 0.00621770f, -0.05381963f, -0.03220897f, 
    0.04627706f, 0.05333025f, -0.06113271f, 0.02832937f, -0.05452034f, 0.03129277f, -0.04313349f, -0.01852228f, 
    -0.01039802f, -0.06112013f, 0.02469827f, -0.07780273f, -0.03812361f, -0.05201271f, -0.07608643f, 0.02036213f, 
    -0.08165969f, -0.04192464f, -0.05863192f, -0.03589955f, -0.07602438f, -0.05944835f, 0.03597726f, -0.01938962f, 
    -0.02017039f, -0.06906953f, -0.03753763f, 0.00325986f, 0.04051276f, -0.01632553f, -0.04513599f, -0.04821744f, 
    0.03386882f, -0.04815008f, -0.06668583f, -0.05883809f, 0.00837140f, 0.01551091f, 0.01112508f, 0.02991903f, 
    0.06262882f, -0.01013718f, 0.01250922f, -0.04339131f, 0.05794199f, -0.03583078f, -0.04374203f, -0.06252044f, 
    0.00926345f, 0.05661473f, -0.05772841f, 0.05550983f, -0.07872211f, 0.02532781f, -0.03330432f, 0.01865495f, 
    0.02091852f, 0.03202200f, 0.02590983f, 0.05790941f, 0.00900805f, -0.06273358f, 0.04064370f, -0.07786085f, 
    -0.01433025f, 0.01243921f, 0.03530688f, 0.03516985f, -0.02401749f, -0.07508559f, -0.06404969f, 0.03949893f, 
    -0.03445387f, 0.06211685f, 0.06078362f, -0.07416187f, -0.01351465f, -0.05807709f, 0.03493824f, -0.03904134f, 
    -0.07484102f, 0.03930496f, 0.02540655f, 0.04047812f, 0.00625271f, -0.03240595f, -0.06244371f, 0.06153728f, 
    -0.06829157f, 0.04763332f, -0.07764857f, 0.04279058f, -0.01041220f, -0.06343351f, -0.05461075f, -0.02046493f, 
    0.02502192f, 0.00429500f, -0.06885264f, -0.04415335f, -0.00268016f, -0.04712312f, -0.06658562f, 0.01436826f, 
    0.01233799f, 0.01938060f, -0.03108252f, -0.05109018f, -0.06599265f, -0.04744279f, 0.00844354f, -0.03901016f, 
    0.03660263f, -0.00057907f, -0.06578999f, 0.04779091f, -0.07645462f, 0.01557546f, -0.04983643f, -0.01487533f, 
    0.02590528f, 0.03319371f, -0.04283292f, 0.01479073f, -0.05455513f, 0.01028924f, 0.00313676f, -0.00109226f, 
    -0.01500771f, 0.06074917f, -0.01206414f, -0.00807436f, -0.05353361f, -0.02379197f, -0.01683241f, -0.01067146f, 
    -0.00529205f, 0.01296597f, -0.01987826f, 0.05685564f, 0.05325558f, 0.02243477f, -0.03315952f, -0.00722352f, 
    0.01547194f, 0.03191036f, -0.04181857f, -0.04391638f, 0.04600999f, -0.02422868f, -0.05499987f, -0.05832063f, 
    0.02148906f, 0.00094714f, -0.03734034f, -0.04563845f, 0.02891080f, -0.00034100f, -0.03840645f, -0.06149324f, 
    -0.06950984f, -0.02441506f, 0.02643550f, -0.03961215f, 0.04481772f, -0.03944357f, -0.02937763f, -0.05563621f, 
    -0.03753495f, -0.04046809f, 0.04061640f, -0.03185178f, 0.00730379f, -0.06307096f, -0.03525580f, 0.05233875f, 
    0.00127875f, -0.04045875f, 0.00308529f, -0.01892333f, 0.04381638f, 0.04617781f, 0.05120126f, 0.02082808f, 
    0.00349680f, -0.06938989f, 0.03420021f, -0.05794834f, -0.00728137f, 0.04691221f, 0.01133746f, -0.00071447f, 
    -0.05580461f, -0.07754841f, -0.05270883f, 0.03306666f, -0.04534274f, 0.03444126f, 0.02052635f, 0.06387122f, 
    0.01181338f, -0.02024225f, -0.07515300f, 0.05118911f, -0.05604206f, -0.04985344f, -0.00750611f, 0.05830230f, 
    -0.03571260f, -0.06246607f, -0.07342667f, -0.07132621f, -0.03199061f, -0.01920720f, -0.00883103f, -0.00275628f, 
    -0.05601054f, -0.06480151f, -0.03697220f, -0.02321326f, 0.05023945f, 0.02646698f, -0.04237021f, 0.00936103f, 
    0.02479108f, -0.06508505f, -0.06140299f, 0.03656304f, 0.01172958f, 0.01360334f, -0.05015365f, 0.00838418f, 
    0.02049459f, 0.06002367f, -0.07586156f, -0.00215621f, -0.05164710f, -0.01208967f, -0.00731594f, -0.01287048f, 
    0.01713761f, -0.02451955f, 0.01505950f, 0.02177276f, 0.03466949f, 0.00070817f, 0.05262810f, -0.00049891f, 
    -0.03236891f, -0.05121772f, -0.06596938f, -0.06748905f, -0.04945927f, -0.06206075f, -0.01828337f, 0.05936252f, 
    0.01271037f, 0.02460788f, -0.03884884f, 0.04162734f, 0.03668870f, -0.01759331f, -0.00999813f, 0.04507501f, 
    -0.04828118f, -0.04021110f, -0.03487515f, -0.00658587f, -0.02505236f, 0.04359059f, 0.00914299f, -0.06728909f, 
    -0.01486047f, 0.03065619f, -0.00609638f, -0.05370208f, 0.02380975f, 0.02759511f, -0.00453216f, -0.05029912f, 
    -0.04515181f, 0.01002071f, 0.05141879f, -0.01558851f, 0.06773715f, -0.03491166f, 0.05110170f, -0.06638961f, 
    -0.07050862f, 0.06213542f, -0.06027393f, -0.00305372f, 0.00776028f, -0.05177033f, -0.06255258f, -0.05889777f, 
    -0.05589880f, 0.06131500f, -0.00260994f, -0.03366632f, -0.00652501f, -0.01704520f, -0.07157866f, -0.07622341f, 
    0.06282771f, 0.03011726f, 0.00700314f, -0.06357513f, -0.05212481f, -0.07709838f, 0.01195158f, 0.06350892f, 
    -0.05032509f, 0.04641627f, -0.03382604f, -0.04088256f, 0.04747704f, -0.03745037f, 0.04802907f, -0.03886533f, 
    0.04846525f, -0.04303317f, -0.05146435f, -0.04310700f, -0.06208476f, 0.05624310f, 0.00763888f, -0.03166711f, 
    -0.05616515f, -0.01368098f, -0.01061781f, 0.02402864f, -0.02438147f, 0.02010979f, -0.04691378f, -0.01518295f, 
    0.04557014f, 0.04313483f, -0.03485727f, -0.01606200f, -0.02961257f, 0.04693381f, -0.03745354f, 0.02252296f, 
    -0.00711684f, -0.05370783f, -0.02288189f, 0.04754518f, 0.00480185f, -0.01959897f, 0.00902303f, 0.01364640f, 
    -0.05781625f, 0.02423527f, -0.00963875f, -0.02702405f, -0.06100805f, -0.03366116f, -0.03948084f, -0.01081448f, 
    -0.00386916f, -0.06054943f, -0.07188302f, 0.03330845f, 0.02932950f, 0.06296084f, -0.00513310f, 0.00072333f, 
    0.02099410f, 0.06059936f, 0.02952683f, -0.07122076f, 0.00645108f, 0.02261742f, 0.00923052f, -0.04958618f, 
    -0.05765556f, -0.06883600f, 0.00630282f, -0.04816826f, 0.04182365f, 0.06541298f, -0.05673533f, -0.07785881f, 
    0.05724517f, 0.03466219f, -0.06718128f, 0.06609556f, -0.07522807f, 0.05852530f, 0.04160519f, 0.03226214f, 
    -0.03671990f, 0.05958895f, -0.05984643f, 0.05570115f, -0.06473221f, 0.03867653f, -0.01637261f, 0.01266591f, 
    -0.02386480f, 0.02862374f, -0.06889129f, -0.03536272f, -0.03082266f, 0.04574731f, 0.02602829f, 0.05594270f, 
    0.74039578f, 0.17827830f, 0.28034773f, 0.11196788f, 0.30998218f, 0.14805232f, 0.02987078f, -0.04709728f, 
    0.28423896f, 0.02445708f, -0.04084711f, -0.04556030f, -0.01492739f, 0.03965830f, 0.04209887f, -0.39535636f, 
    0.08382865f, -0.11791288f, 0.07414939f, -0.08282785f, 0.05319641f, 0.08587486f, 0.07914118f, -0.00848810f, 
    0.15363623f, 0.27313259f, -0.02634745f, 0.64362925f, -0.06068159f, -0.03829783f, 0.06426525f, 0.06464281f, 
    -0.06664488f, 0.15623006f, 0.02069228f, -0.08592948f, 0.14661682f, 0.22819187f, 0.19238071f, -0.17232011f, 
    -0.10695147f, 0.12982690f, 0.08000242f, 0.17486927f, 0.05528489f, -0.00576401f, 0.07391514f, 0.14502017f, 
    0.03236452f, -0.53422099f, 0.04793113f, 0.25432181f, -0.09095734f, 0.09283033f, -0.11969618f, -0.06301550f, 
    0.13162735f, -0.26646125f, -0.07511102f, 0.01772562f, -0.01097310f, 0.02454784f, -0.01061134f, 0.14407325f, 
    -0.14123316f, -0.08093241f, 0.15012592f, -0.08770189f, -0.10972385f, -0.06635062f, -0.06991330f, -0.08954769f, 
    0.16261739f, 0.19800366f, 0.00754131f, -0.05192781f, 0.03148939f, -0.23693594f, -0.11372574f, 0.02295514f, 
    0.10616349f, -0.00406101f, 0.03327343f, 0.14479716f, 0.48422998f, -0.45004666f, 0.10713257f, -0.20497409f, 
    0.02419935f, 0.18382294f, -0.17330669f, -0.03250790f, -0.02820125f, 0.03499543f, -0.08067567f, -0.07724810f, 
    -0.29198131f, -0.00935420f, 0.06408627f, 0.16231734f, 0.02346483f, -0.27966195f, -0.00026930f, -0.01898508f, 
    -0.15200040f, -0.06746878f, -0.07493079f, -0.08940899f, 0.03593973f, 0.14878264f, 0.03089961f, 0.32247448f, 
    0.12633340f, 0.07223112f, -0.02939298f, -0.03464177f, -0.02104274f, 0.13843590f, 0.14655079f, -0.09815316f, 
    0.04337680f, -0.42019418f, -0.09551263f, 0.01340392f, 0.02463867f, -0.11717685f, 0.18800509f, 0.06332786f, 
    -0.02876494f, 0.00581190f, -0.02361817f, 0.04986769f, 0.13224886f, 0.35399500f, -0.20136744f, -0.02159202f, 
    -0.09882998f, -0.03129758f, 0.10302553f, -0.11574342f, -0.18244366f, -0.17927717f, -0.20508876f, -0.13960394f, 
    0.47083291f, 0.24706373f, 0.22749980f, 0.03574001f, 0.03052478f, 0.21791309f, 0.16510844f, 0.05258618f, 
    0.04643923f, -0.06674116f, -0.02420666f, -0.03835503f, -0.26495770f, 0.15968205f, -0.10088081f, -0.14459610f, 
    0.05096688f, 0.04913471f, -0.16457975f, 0.19453757f, 0.14933729f, 0.09612668f, 0.06344381f, -0.15274176f, 
    -0.70746559f, 0.11126405f, 0.04295201f, -0.10313084f, 0.01509602f, -0.25550932f, 0.11928695f, -0.06823921f, 
    0.06879649f, -0.03002288f, -0.02720063f, 0.01774324f, 0.43831378f, -0.09200282f, -0.10999577f, 0.15791060f, 
    -0.04766596f, 0.11717322f, 0.07693305f, 0.03045682f, -0.14264791f, 0.00795928f, 0.09336678f, -0.10254402f, 
    0.39748713f, -0.08602759f, 0.29682839f, 0.34369627f, 0.14273606f, 0.05966040f, -0.05234673f, 0.06096541f, 
    -0.01246697f, -0.01147719f, 0.04565329f, -0.03914201f, 0.12829006f, 0.19028053f, 0.06016139f, -0.31025556f, 
    -0.04998047f, -0.22636300f, 0.20778835f, -0.18998212f, 0.08547670f, 0.01417596f, -0.02298886f, -0.04596625f, 
    -0.26095334f, 0.15528370f, 0.03346064f, -0.37986654f, -0.30416417f, -0.20587811f, 0.04265678f, -0.07225401f, 
    -0.11685313f, -0.02074955f, -0.01325963f, -0.25380844f, -0.20401710f, 0.08618949f, -0.28304890f, 0.00222395f, 
    0.11813025f, -0.07859421f, 0.06433681f, 0.09017702f, 0.02492343f, 0.06338598f, 0.10530338f, 0.10331044f, 
    0.02604680f, -0.13669525f, 0.02794841f, 0.06909074f, 0.00742249f, 0.10055399f, 0.03655241f, -0.00448151f, 
    0.18736166f, -0.09377906f, -0.15445986f, -0.12016598f, -0.07426566f, 0.12898639f, -0.33703676f, 0.09164460f, 
    0.07347626f, 0.10619456f, 0.00192705f, 0.12969457f, 0.05044085f, -0.12638550f, 0.08262432f, -0.20980024f, 
    0.12328938f, 0.16837339f, -0.03408072f, 0.01993847f, 0.01246915f, -0.18916188f, 0.15121514f, -0.04083660f, 
    0.22584058f, 0.07047095f, 0.02493586f, 0.39996627f, 0.90261871f, -0.04324072f, 0.34863785f, -0.17688370f, 
    -0.30596358f, 0.32810086f, 0.04140780f, 0.08704537f, 0.08249220f, -0.03834701f, -0.06729198f, 0.02733400f, 
    -0.56701404f, 0.24480750f, 0.08761275f, 0.09846761f, 0.13044459f, -0.00436505f, 0.01501091f, 0.02107540f, 
    -0.21379733f, -0.10448764f, -0.16821316f, -0.16238181f, 0.17755213f, 0.12165931f, -0.07281576f, 0.26718283f, 
    0.05866506f, 0.21195178f, 0.07841660f, -0.09285615f, 0.11675483f, 0.10127743f, 0.18150678f, -0.03301660f, 
    0.06596655f, -0.10555427f, 0.02771589f, 0.08724374f, 0.03089476f, 0.09060770f, -0.01419725f, 0.06703344f, 
    -0.08195227f, 0.08768896f, 0.02465241f, 0.10736031f, -0.22146982f, 0.35093662f, -0.23731755f, -0.28635955f, 
    -0.23318462f, -0.00381663f, -0.02608563f, -0.13781984f, -0.17398226f, 0.01023190f, 0.14511147f, 0.10338657f, 
    0.61725837f, -0.03122644f, -0.02603639f, -0.02746497f, 0.00089604f, 0.01291034f, -0.11986467f, 0.03453096f, 
    0.24609178f, 0.00510546f, -0.00268095f, -0.07539329f, 0.22245868f, 0.09570917f, -0.08964755f, -0.09447852f, 
    0.04027648f, 0.08826723f, -0.01655046f, 0.10416217f, -0.17857862f, 0.15022923f, 0.02403092f, 0.03314725f, 
    -0.04548283f, -0.16554601f, 0.21894440f, 0.32402283f, 0.01533869f, 0.01588430f, 0.09991703f, 0.04525657f, 
    0.02485212f, -0.00097682f, -0.02613590f, -0.12393294f, 0.27001262f, 0.22126128f, -0.17160729f, -0.14466834f, 
    0.22947434f, 0.27022669f, 0.00813574f, 0.05754599f, 0.11719900f, -0.05645416f, 0.21105747f, -0.05406229f, 
    -0.03433230f, 0.05427513f, 0.05468313f, -0.04295085f, -0.05592080f, -0.03832551f, -0.01879468f, -0.00906342f, 
    -0.01586647f, -0.01689104f, -0.01265551f, -0.05473977f, -0.05699769f, 0.00280072f, -0.02659236f, -0.05692815f, 
    0.00620723f, 0.01078582f, 0.01532037f, 0.02212875f, 0.01358021f, -0.06116526f, -0.07690948f, 0.04954182f, 
    -0.05417965f, -0.06242011f, -0.05606470f, -0.01547974f, -0.02954770f, 0.03695276f, -0.04961934f, 0.00421558f, 
    -0.04664940f, -0.01514619f, 0.03663863f, 0.04296305f, -0.01474682f, -0.04736595f, -0.07767279f, -0.05682227f, 
    -0.01419878f, -0.06120705f, -0.02502091f, -0.06956337f, 0.03709498f, -0.04055619f, -0.07054967f, 0.00837114f, 
    0.00993647f, 0.05618517f, 0.01585550f, 0.05995402f, 0.04105281f, -0.06459102f, -0.03732048f, -0.05505904f, 
    0.01042634f, 0.01460929f, -0.05445300f, -0.01972657f, -0.00849029f, -0.08033680f, 0.05408318f, -0.06927492f, 
    -0.06834026f, 0.01350937f, -0.07353009f, 0.06207647f, -0.06503976f, 0.05621475f, 0.03689016f, 0.01344497f, 
    0.04906245f, -0.05521424f, -0.00973948f, -0.06101015f, -0.05815218f, 0.05414331f, -0.05324932f, -0.05901817f, 
    0.00232572f, 0.02092839f, 0.02839823f, -0.04410165f, 0.03144529f, -0.02571565f, 0.06084685f, -0.04042351f, 
    -0.07014082f, -0.04623348f, 0.05826762f, -0.01916688f, -0.01116802f, -0.03575526f, 0.03834138f, -0.07417617f, 
    -0.05810544f, 0.02127346f, 0.01703944f, -0.06992053f, -0.05820483f, 0.05852950f, 0.04446900f, 0.05501004f, 
    -0.07829286f, 0.00158873f, -0.07335375f, 0.00537818f, 0.00947199f, 0.04894778f, -0.01143203f, 0.04561845f, 
    0.02776860f, -0.01339291f, 0.06163954f, -0.03229104f, 0.02515474f, -0.00364026f, 0.03244805f, -0.00491372f, 
    -0.03210058f, -0.00174782f, 0.01056904f, -0.03353098f, -0.05865355f, -0.07768704f, 0.05867220f, -0.02514021f, 
    -0.04575143f, -0.04060668f, 0.05387915f, -0.03309866f, 0.05320610f, 0.02358278f, -0.02700957f, -0.04232056f, 
    0.01058252f, 0.00946498f, 0.05398016f, -0.03955448f, 0.04660237f, -0.07389092f, -0.01630180f, -0.07063466f, 
    0.00073344f, -0.00983059f, 0.01459399f, -0.07294358f, -0.03148329f, 0.00453993f, -0.00872734f, -0.04165518f, 
    -0.02620755f, 0.01034942f, 0.03524720f, -0.02602660f, -0.06533120f, 0.00085043f, -0.02707951f, -0.02104676f, 
    -0.00379797f, -0.02698255f, -0.03318874f, 0.01665067f, 0.04111403f, -0.00619410f, 0.02270541f, -0.06806030f, 
    -0.03660608f, -0.00250052f, -0.01647980f, -0.06319989f, 0.05261364f, 0.01416817f, 0.05889807f, 0.00393627f, 
    0.04876857f, 0.04990110f, -0.05316603f, -0.07535200f, 0.06063953f, -0.05853825f, 0.01526373f, -0.01708397f, 
    0.05463021f, 0.03246015f, 0.05771986f, -0.05162472f, 0.01958144f, -0.04731835f, 0.03347220f, -0.01047025f, 
    -0.06254364f, 0.20121293f, -0.10516268f, -0.02169334f, -0.16267727f, 0.02764827f, 0.03191723f, 0.19288507f, 
    0.07663602f, 0.13078657f, -0.16591784f, 0.25176635f, -0.20387480f, -0.08977760f, -0.15190151f, -0.20060100f, 
    0.19248727f, 0.24817774f, -0.00222602f, 0.20792042f, 0.03266999f, -0.28697443f, -0.00891599f, 0.25225663f, 
    -0.20306610f, -0.24529874f, -0.08308645f, 0.17183879f, 0.09267261f, 0.19142699f, -0.02325709f, 0.06201967f, 
    -0.01000287f, 0.03934318f, 0.02715097f, 0.28157008f, 0.46682543f, 0.09541900f, 0.05478985f, 0.08561327f, 
    0.19137201f, -0.00727475f, -0.06113401f, 0.05539712f, 0.04447635f, -0.00396928f, 0.10386125f, -0.14233658f, 
    0.19103906f, 0.31156695f, 0.05093163f, -0.05981060f, 0.06611737f, 0.13110209f, 0.05977200f, 0.14466931f, 
    0.02528613f, -0.02820904f, 0.33068275f, 0.27247402f, 0.11685366f, 0.07108548f, 0.01252321f, -0.00425109f, 
    -0.02193723f, -0.03198329f, -0.04462916f, -0.14308542f, -0.01530104f, 0.17242910f, 0.34910724f, 0.35242838f, 
    -0.19729142f, -0.01657340f, -0.12524214f, -0.01132015f, -0.06129073f, 0.25810218f, -0.07617397f, 0.16640253f, 
    0.02488641f, 0.08930304f, 0.00516971f, -0.54942250f, -0.24215189f, -0.13139267f, -0.07827926f, -0.00406427f, 
    -0.16169341f, -0.26728565f, -0.08705658f, -0.17648180f, 0.06092671f, 0.03389120f, 0.15215859f, 0.03641766f, 
    -0.05944859f, 0.14038910f, -0.36860362f, -0.20836668f, -0.06889463f, -0.01414281f, 0.18750158f, 0.01064143f, 
    0.11666843f, 0.17951274f, 0.29585552f, 0.22024745f, 0.36451662f, -0.29212466f, -0.22122216f, -0.13444173f, 
    0.07674798f, -0.03232580f, 0.02673972f, -0.23159285f, -0.09784666f, -0.11469841f, 0.02457781f, -0.06700887f, 
    -0.04527814f, -0.39145026f, 0.21440034f, -0.16093956f, 0.08588170f, -0.23894180f, 0.29329118f, 0.04240615f, 
    0.25666213f, 0.00301322f, -0.17584981f, 0.03240152f, -0.05358553f, -0.12294676f, 0.12603509f, -0.18161294f, 
    0.09113614f, 0.12640914f, 0.07028755f, 0.03215472f, 0.14284801f, 0.20687906f, -0.05620632f, -0.06028069f, 
    -0.49510136f, 0.15613790f, 0.19526979f, -0.12589793f, 0.00890403f, 0.18627103f, 0.00634107f, 0.01122378f, 
    0.10985061f, 0.09270503f, 0.02769984f, 0.07596341f, -0.41918775f, 0.10768455f, 0.27127653f, 0.38600996f, 
    0.14999446f, 0.01659380f, 0.10531324f, -0.17205890f, 0.29534039f, 0.00221985f, 0.08669123f, 0.19563334f, 
    -0.04065556f, 0.15354903f, -0.26681632f, 0.20883033f, 0.00326245f, 0.04005640f, 0.12475450f, 0.32026428f, 
    0.05886178f, 0.01688749f, 0.02945643f, 0.03909722f, -0.28335437f, 0.08633139f, -0.02444561f, -0.13607189f, 
    -0.16572773f, -0.29710302f, 0.01694153f, -0.03536260f, 0.25583905f, 0.07123368f, -0.36686310f, 0.09380614f, 
    0.00297334f, -0.04596422f, -0.02893741f, -0.05895634f, -0.07248836f, 0.01566316f, 0.03047085f, -0.04449524f, 
    -0.08854365f, -0.05344574f, -0.07667447f, -0.04341744f, -0.04987672f, -0.01793926f, 0.02581776f, 0.01088111f, 
    0.02571984f, -0.07181603f, -0.04837011f, -0.07461580f, 0.05038248f, 0.02369708f, -0.03033208f, -0.03941426f, 
    -0.06133119f, -0.00318604f, 0.00712717f, -0.01108626f, -0.06726462f, -0.02450829f, -0.04361934f, -0.03334958f, 
    -0.08128132f, -0.02284011f, 0.04908953f, -0.02703388f, -0.03067163f, 0.02610422f, -0.07498080f, 0.03242847f, 
    0.03465572f, -0.00153516f, 0.04499282f, 0.02379891f, 0.02686073f, -0.05371815f, 0.03379015f, 0.00130461f, 
    0.04204804f, -0.00640314f, 0.00569308f, 0.04582876f, -0.01593519f, 0.00134211f, -0.01643702f, -0.01969852f, 
    -0.01108722f, -0.05515730f, -0.00083517f, 0.05214516f, -0.07180800f, -0.01659904f, -0.01033974f, 0.03553918f, 
    0.00023536f, -0.06631350f, -0.06481742f, 0.03183782f, 0.02818710f, -0.06814242f, 0.00907462f, 0.00477252f, 
    -0.01962163f, 0.05685807f, -0.00468997f, 0.06149961f, 0.00983091f, 0.06129708f, -0.04019611f, -0.04471391f, 
    -0.02691293f, 0.01421187f, -0.04011843f, -0.02962792f, -0.07390656f, 0.04250244f, -0.01443938f, 0.04946908f, 
    -0.01805887f, -0.07048603f, -0.02855279f, -0.06021025f, -0.04647009f, -0.06895781f, -0.00886473f, -0.02215105f, 
    -0.05876336f, -0.07112969f, -0.06057877f, -0.02134502f, -0.06845392f, 0.01714853f, 0.03367111f, -0.07650433f, 
    -0.06746201f, -0.02350729f, 0.02725276f, -0.04839904f, 0.03362504f, 0.00748928f, -0.04506399f, 0.05632393f, 
    0.02159067f, -0.05802014f, -0.00192471f, -0.02139769f, 0.01544485f, 0.04969198f, -0.00222038f, -0.03626663f, 
    0.03944571f, -0.03250296f, -0.01273848f, -0.08429071f, -0.05285376f, -0.03676965f, -0.06226357f, 0.00367469f, 
    0.03652842f, -0.05782950f, -0.05756692f, 0.03236773f, -0.06379037f, -0.03343850f, 0.05146911f, 0.03607019f, 
    -0.04457846f, -0.03915758f, -0.05761439f, 0.04191510f, -0.06421033f, 0.00343202f, -0.08610553f, 0.03701928f, 
    0.05098650f, -0.08423305f, -0.05132204f, 0.00355367f, -0.07645246f, 0.03347329f, 0.01120853f, 0.04664459f, 
    -0.01190977f, -0.01887997f, 0.00706362f, -0.05349709f, -0.00868698f, -0.04896819f, -0.04488326f, -0.05804938f, 
    0.02672548f, -0.00037043f, -0.04519946f, -0.05126091f, -0.03392256f, 0.04099629f, 0.01067080f, 0.00657591f, 
    -0.04879292f, 0.02707718f, 0.01113050f, -0.02248759f, -0.00713875f, 0.02360978f, -0.03765744f, 0.03052556f, 
    -0.01105439f, -0.05511947f, 0.00369177f, -0.01258988f, -0.07082300f, 0.06602205f, -0.03465826f, 0.05059407f, 
    -0.01791943f, -0.04080165f, 0.04479365f, 0.03365052f, -0.04598746f, -0.07158987f, 0.03991006f, -0.07668754f, 
    -0.06134428f, 0.04221660f, -0.07231978f, -0.06967085f, -0.04472535f, 0.05619639f, -0.01697758f, 0.01883561f, 
    -0.00982464f, -0.05560984f, -0.01760152f, -0.00027030f, 0.03645169f, 0.01805001f, -0.08148386f, -0.00999663f, 
    -0.02543662f, 0.05000901f, 0.05383512f, -0.07974077f, 0.01149080f, 0.02477985f, -0.06403176f, 0.06392257f, 
    0.03114139f, -0.00026149f, 0.01607576f, 0.05671471f, -0.03155349f, 0.03246652f, -0.06429598f, 0.01746277f, 
    -0.06863629f, 0.05912371f, -0.02497454f, -0.01431360f, 0.04953229f, 0.02064367f, 0.07317650f, -0.07382155f, 
    -0.05234453f, -0.06074772f, 0.03937873f, 0.02704519f, 0.00938251f, 0.01898376f, 0.00363651f, -0.03179862f, 
    -0.03737053f, -0.05202050f, 0.00315659f, -0.01999719f, -0.06906545f, -0.04687789f, 0.05206309f, -0.05692549f, 
    -0.00177607f, 0.04950889f, -0.05951698f, -0.06297033f, -0.01417272f, 0.00124195f, -0.02585005f, 0.04177999f, 
    0.03693772f, -0.04519878f, 0.00212275f, -0.02584913f, 0.05634089f, -0.07617385f, -0.00562199f, -0.00692112f, 
    0.04827766f, -0.05791762f, -0.04782553f, 0.05247504f, -0.08077052f, -0.08226052f, -0.07246695f, -0.03770589f, 
    -0.05732496f, 0.06246916f, 0.04308470f, 0.00287227f, -0.08179942f, 0.04230720f, -0.06255802f, 0.02888718f, 
    -0.06419807f, 0.05629971f, 0.03108477f, 0.05532182f, -0.03770626f, 0.05275981f, 0.03939989f, -0.05484891f, 
    0.04825156f, 0.03887668f, -0.03803150f, -0.03412041f, 0.05773224f, 0.02262750f, -0.06964038f, -0.00841734f, 
    -0.05753096f, -0.06581558f, -0.04296153f, 0.00347507f, -0.03505551f, 0.04912513f, 0.02617458f, 0.05388854f, 
    0.00313913f, -0.05472906f, -0.06323717f, 0.02646518f, 0.02717406f, 0.01329002f, -0.07042966f, 0.00355935f, 
    -0.06848507f, -0.07450207f, -0.04275241f, -0.00794194f, -0.00784836f, -0.05858416f, 0.03817370f, 0.01845536f, 
    -0.06143655f, 0.02780527f, 0.05671464f, -0.05228474f, 0.00352677f, 0.00192353f, 0.01530813f, 0.05447863f, 
    0.01353560f, -0.06099121f, -0.00000790f, 0.03300921f, 0.00759103f, 0.01644190f, 0.03257767f, -0.00006381f, 
    -0.07564148f, 0.04751162f, -0.06693655f, -0.07218219f, -0.03376612f, 0.01815495f, 0.04883168f, -0.05218070f, 
    -0.02737913f, -0.03766141f, -0.04903056f, -0.04527850f, 0.04080588f, 0.05984491f, -0.03696684f, -0.03607931f, 
    0.05770689f, -0.04640587f, -0.04875779f, 0.00532241f, -0.00675312f, -0.04883894f, 0.06077460f, -0.04807452f, 
    -0.02774947f, -0.04350443f, 0.03942402f, 0.00523369f, -0.07179277f, -0.02025377f, -0.03987457f, -0.02034163f, 
    -0.00445211f, 0.03485829f, 0.03290840f, 0.00730513f, -0.04963177f, -0.05981938f, 0.02154468f, 0.02313681f, 
    0.06083045f, 0.02710668f, -0.04905724f, -0.02396851f, -0.04659062f, 0.06162847f, -0.04519623f, -0.06632272f, 
    0.31805298f, 0.46005949f, 0.00278472f, -0.23897538f, 0.01599531f, -0.16448635f, -0.05176130f, 0.02355201f, 
    -0.09481479f, 0.03003363f, 0.03765218f, -0.12968580f, 0.25636747f, -0.08302400f, -0.03340239f, 0.17946450f, 
    0.02911990f, 0.06414347f, 0.04079574f, 0.02712465f, 0.11076133f, 0.10646711f, -0.20505157f, -0.14361039f, 
    0.25452450f, -0.01417697f, -0.44258928f, 0.15315548f, 0.01172075f, 0.02750117f, 0.19589919f, 0.09565675f, 
    0.06013854f, 0.07410184f, 0.06049040f, -0.23810264f, -0.20474930f, 0.07982112f, 0.03754766f, 0.06292395f, 
    0.01780593f, 0.16188358f, 0.22760318f, 0.04211762f, -0.07870170f, 0.03073536f, 0.07580572f, 0.30103081f, 
    0.14914422f, 0.24566492f, 0.30970559f, -0.16373000f, 0.09009542f, 0.18231113f, -0.02554392f, 0.02142803f, 
    0.18183117f, -0.19812427f, -0.08397792f, 0.04864612f, -0.54410571f, -0.36179549f, 0.07932638f, 0.11400729f, 
    0.01142648f, 0.16123867f, 0.10487378f, 0.03350822f, -0.07908799f, -0.07989838f, -0.01098237f, -0.22076264f, 
    -0.09727087f, -0.36131319f, 0.48281810f, -0.01819914f, 0.07578788f, 0.00697533f, -0.09059592f, -0.02477604f, 
    0.01732966f, 0.02226479f, -0.13721041f, 0.48960978f, 1.04390752f, 0.33716092f, -0.13402386f, 0.08026435f, 
    -0.04510731f, 0.24765804f, 0.05658379f, -0.01855855f, 0.00085590f, 0.21385542f, 0.01959300f, -0.07094030f, 
    0.32383436f, -0.11356271f, -0.11750586f, 0.19714464f, 0.05717307f, 0.20067759f, -0.00315801f, 0.18877435f, 
    -0.04794844f, -0.04703946f, -0.19538942f, -0.06674875f, -0.28518820f, -0.21968748f, 0.44424716f, 0.28386578f, 
    0.04831810f, 0.02595575f, 0.42436102f, 0.21845232f, 0.21013525f, 0.28585795f, 0.24081333f, -0.01238935f, 
    -0.22967665f, 0.00852787f, -0.03995535f, 0.17497227f, 0.16102107f, 0.21856824f, 0.11530126f, 0.17310944f, 
    -0.05668434f, -0.14147602f, -0.02803672f, -0.00352180f, 0.33723801f, 0.02407345f, -0.16824257f, -0.04315355f, 
    0.00558331f, 0.10287166f, 0.16474642f, -0.07652631f, 0.05063147f, -0.00329583f, 0.13473435f, 0.29590464f, 
    -0.24962956f, 0.42227015f, 0.14419605f, -0.49793512f, 0.00300599f, -0.06923223f, -0.08541789f, 0.19574621f, 
    0.00071745f, -0.08565927f, -0.02576176f, -0.05922763f, -0.07507705f, 0.03724004f, 0.17014703f, -0.15893610f, 
    -0.18527421f, 0.22055677f, -0.06256568f, -0.02589650f, -0.20518564f, 0.22429778f, -0.07307165f, 0.09341903f, 
    0.32220021f, -0.25760406f, -0.05370472f, 0.03577249f, 0.10681103f, -0.14882781f, 0.13669844f, -0.10343970f, 
    -0.02762547f, -0.00710895f, 0.10006445f, 0.12479933f, -0.10575563f, -0.30260223f, 0.23747621f, -0.03767172f, 
    0.04470653f, 0.18175757f, 0.08997013f, -0.18927631f, 0.02003723f, -0.12659444f, 0.51449347f, -0.04242664f, 
    -0.20960255f, 0.48855472f, -0.06582807f, -0.28762296f, 0.40686750f, -0.17677096f, -0.07450867f, 0.08601941f, 
    0.01399307f, -0.11891982f, -0.06848805f, 0.14090164f, -0.15252097f, -0.20973454f, -0.20403491f, -0.19683738f, 
    -0.13027084f, 0.11984354f, -0.03212981f, -0.10648140f, 0.02709147f, 0.05432073f, -0.01570420f, 0.08091273f, 
    -0.59456986f, -0.41561547f, -0.28244731f, -0.26080972f, 0.02848968f, 0.07122639f, 0.04481363f, -0.16539635f, 
    -0.01348997f, -0.13087988f, 0.04797095f, -0.14731561f, 0.11422785f, 0.32888514f, 0.13598083f, -0.11470018f, 
    0.35531187f, -0.14928582f, -0.03396661f, -0.19809707f, 0.14285992f, -0.01272267f, 0.01793536f, 0.07217032f, 
    0.28355211f, 0.05816986f, -0.20612714f, -0.42501628f, 0.00884448f, -0.07840408f, 0.08498291f, -0.11618159f, 
    -0.11356192f, 0.03723299f, 0.00832645f, 0.06519891f, 0.28804272f, 0.47142532f, -0.17394114f, 0.24791880f, 
    0.24870692f, 0.30942973f, -0.02847260f, -0.11784344f, 0.16093114f, -0.08111143f, -0.19626446f, -0.23308200f, 
    -0.07649469f, -0.41865405f, -0.07492884f, -0.10253686f, -0.02232045f, 0.06819975f, 0.23886982f, -0.11778796f, 
    0.07864415f, 0.16600506f, 0.12932122f, 0.16964240f, 0.21868981f, -0.00448570f, 0.19856068f, -0.14269041f, 
    -0.12963054f, -0.05401362f, 0.01867201f, -0.00443736f, -0.01579640f, 0.14200452f, 0.19948013f, 0.10097073f, 
    0.35215899f, -0.50066191f, -0.55226672f, -0.16346642f, 0.06008022f, 0.15866947f, 0.11690828f, 0.12041479f, 
    -0.23748671f, 0.00783284f, 0.04921547f, -0.24073248f, 0.40396795f, -0.00812936f, -0.05818165f, 0.25045240f, 
    -0.00144142f, 0.16957992f, 0.09199863f, 0.23579212f, 0.14895749f, 0.08400024f, -0.03007788f, -0.00258974f, 
    -0.31269285f, 0.55691773f, 0.14525427f, 0.07670645f, -0.00698845f, 0.09482721f, -0.21220222f, 0.03759782f, 
    0.03521562f, 0.05431464f, 0.05819308f, 0.04474640f, -0.34317115f, -0.03351120f, -0.00351388f, 0.09963781f, 
    0.10790797f, -0.02139379f, -0.10650151f, 0.19007732f, 0.28354010f, 0.07025911f, 0.05818511f, 0.02782647f, 
    0.11603839f, 0.52319986f, 0.06321476f, -0.02025971f, 0.26329920f, 0.03334982f, -0.00179293f, -0.10174008f, 
    0.03293180f, 0.23263840f, -0.14865096f, 0.01872550f, 0.63860410f, 0.54035646f, 0.16076019f, 0.01747328f, 
    -0.00336213f, -0.14858714f, 0.11603675f, -0.14989412f, -0.11709607f, 0.00432787f, 0.12238417f, 0.09630335f, 
    0.55712909f, -0.66861981f, 0.27205002f, 0.14088643f, -0.01336414f, -0.06332367f, 0.07132829f, 0.18540117f, 
    -0.00142439f, -0.00039674f, 0.16845454f, -0.06704316f, 0.43885347f, -0.46057552f, -0.06741656f, 0.14200298f, 
    0.02577307f, 0.20711328f, -0.02593632f, 0.13550919f, 0.14374897f, -0.05307642f, 0.07569726f, 0.28754672f, 
    0.18530607f, 0.24616438f, -0.08642934f, -0.22323433f, 0.04528744f, -0.20738198f, 0.06416569f, -0.11293835f, 
    0.07047956f, 0.01530169f, -0.09575494f, -0.04813241f, -0.71635854f, 0.02054039f, -0.19410637f, 0.05382552f, 
    0.22298349f, -0.17322145f, 0.08501691f, -0.02261186f, -0.01283203f, 0.15622765f, 0.06283560f, 0.10302529f, 
    0.32581753f, 0.05849994f, -0.28243455f, 0.46535635f, 0.20356107f, 0.10983989f, -0.04740000f, 0.01434563f, 
    -0.09007486f, -0.12174486f, 0.03553373f, -0.09457213f, -0.13002761f, -0.16046642f, 0.16802236f, -0.03416859f, 
    -0.15809011f, 0.00159686f, -0.03436703f, 0.10529700f, 0.09946235f, 0.07088523f, 0.04150048f, 0.10884666f, 
    0.07793830f, -0.07813514f, 0.11524464f, 0.33455428f, -0.06603932f, -0.15209399f, -0.16161370f, -0.00912266f, 
    0.13582706f, -0.09802940f, 0.09368168f, 0.10487146f, -0.09845745f, -0.07519730f, 0.13254151f, 0.25123513f, 
    -0.29005709f, 0.00446659f, -0.09083896f, -0.07162610f, 0.07714985f, 0.07403565f, -0.10133927f, 0.07442776f, 
    0.09531419f, -0.16383532f, 0.09451677f, 0.05172274f, 0.11322461f, -0.02396059f, -0.06982305f, -0.03773566f, 
    -0.05775174f, -0.10326568f, 0.19793651f, -0.11570723f, 0.26091558f, -0.05774855f, -0.21455184f, -0.05354761f, 
    0.00829842f, 0.03313606f, -0.26961756f, -0.15112413f, 0.08135448f, 0.12853946f, -0.10997875f, -0.00549212f, 
    -0.15347482f, -0.09817540f, -0.20603368f, 0.30835909f, -0.16576399f, -0.27033731f, -0.01164316f, 0.01171543f, 
    0.11023539f, -0.11866750f, 0.20999002f, -0.01477818f, -0.10777951f, -0.11237492f, 0.28313619f, 0.04467545f, 
    0.23073404f, 0.06177821f, 0.18233864f, 0.04119854f, -0.03779657f, 0.03326229f, 0.08059426f, 0.10320471f, 
    -0.05344713f, 0.01226030f, -0.28175700f, 0.58789557f, 0.11007755f, 0.07837738f, 0.26081958f, 0.08657999f, 
    0.14605150f, -0.03968179f, -0.02247864f, 0.07286918f, 0.54820597f, 0.05505772f, 0.08246231f, 0.31343287f, 
    0.03161441f, 0.32710478f, -0.06156927f, -0.07983176f, -0.08272380f, -0.07176067f, 0.07200050f, 0.04018446f, 
    -0.14133851f, 0.09375672f, 0.08228949f, -0.14165111f, 0.06360614f, 0.18486451f, -0.06670061f, -0.01608853f, 
    -0.00499936f, -0.15959387f, 0.20162395f, -0.00252719f, 0.38890994f, -0.15531617f, 0.12403876f, -0.08562394f, 
    0.07250976f, 0.20235325f, -0.16855986f, 0.05183981f, 0.21757044f, -0.02662019f, 0.01558717f, 0.03919332f, 
    -0.62780368f, 0.30434704f, -0.03897069f, -0.29286754f, 0.12337556f, 0.09623674f, 0.06644868f, 0.22262041f, 
    -0.03119559f, -0.16982365f, 0.08376673f, 0.00960892f, 0.13743667f, -0.31240100f, 0.31495750f, 0.22291683f, 
    -0.30681551f, -0.13501018f, -0.11955296f, -0.05466636f, -0.08900051f, 0.02521350f, 0.05374792f, 0.02269242f, 
    -0.18186845f, -0.30730030f, 0.16455810f, -0.31730652f, -0.07956295f, 0.09293468f, 0.06641616f, 0.01777176f, 
    0.12492868f, -0.09710744f, 0.10984798f, -0.07207736f, -0.14365698f, 0.31470558f, -0.02726366f, 0.36948282f, 
    -0.02843894f, -0.16221535f, 0.03818187f, -0.03178696f, -0.01927371f, 0.29333201f, 0.20534015f, 0.06991954f, 
    -0.03790630f, 0.06248347f, -0.31815755f, -0.25647342f, 0.05274338f, -0.05375541f, 0.05458896f, -0.10295802f, 
    -0.07185294f, 0.00629907f, 0.05974055f, -0.00332994f, -0.81830359f, -0.04182183f, -0.06800175f, -0.20632432f, 
    -0.17200811f, -0.05665156f, -0.08587795f, -0.06893115f, 0.10423266f, 0.10569560f, 0.04037301f, 0.09935251f, 
    0.32676268f, 0.27626488f, 0.26555070f, 0.27728388f, -0.01699839f, 0.09237138f, 0.07575779f, -0.10403214f, 
    -0.00826811f, 0.06106602f, -0.11122224f, 0.08647035f, -0.15782821f, -0.08669903f, 0.04794579f, 0.11408849f, 
    -0.06876806f, 0.06737645f, -0.26889175f, 0.15128610f, 0.12407165f, -0.07891620f, -0.16887140f, -0.14383410f, 
    0.37539139f, 0.24322015f, 0.22922149f, 0.29486504f, 0.16089667f, 0.10510308f, -0.01474891f, 0.03390666f, 
    -0.22035487f, 0.12728679f, 0.10509007f, 0.07813203f, 0.22359084f, 0.39377907f, -0.02426812f, 0.47185677f, 
    0.06475456f, 0.02553253f, 0.07282405f, 0.00956439f, 0.01254657f, -0.06255690f, 0.02841403f, -0.16365398f, 
    -0.40959221f, -0.08581308f, 0.50841492f, 0.30594164f, 0.24310310f, -0.06840020f, -0.09962145f, 0.22210267f, 
    0.03202633f, 0.03869694f, 0.00143424f, 0.00145298f, -0.19623084f, 0.03373029f, -0.33024356f, 0.06457183f, 
    0.01755907f, 0.18758078f, -0.00790304f, 0.07330458f, -0.01895776f, -0.01140022f, -0.04758763f, 0.16801955f, 
    0.10215060f, 0.20503969f, -0.08107024f, 0.17033647f, -0.08157802f, -0.03586481f, -0.02096649f, 0.02916365f, 
    0.03274524f, 0.12783177f, 0.21729422f, -0.00286786f, 0.23535810f, -0.08154035f, 0.12135161f, 0.61499298f, 
    0.07471421f, 0.26426190f, 0.10578783f, 0.05527405f, 0.05121059f, 0.07851911f, 0.15727426f, -0.03819562f, 
    0.06470364f, -0.30979070f, -0.17572792f, 0.05503132f, -0.08603569f, 0.11434790f, 0.04433021f, 0.11355102f, 
    -0.11172499f, 0.02790357f, 0.11439861f, 0.09692756f, -0.07809779f, -0.33996001f, -0.23923314f, 0.10106078f, 
    -0.03745376f, 0.16982907f, 0.06965800f, 0.28243735f, -0.10646777f, -0.08382445f, -0.03513382f, 0.05311734f, 
    -0.35928714f, 0.26712009f, 0.00264936f, -0.43647733f, 0.09891580f, 0.12933032f, 0.04426512f, 0.04085474f, 
    0.02585399f, -0.04634222f, 0.09640703f, 0.00981378f, 0.18396328f, 0.33921456f, 0.32597530f, 0.46385205f, 
    0.14568980f, 0.11492582f, -0.03415543f, 0.23210306f, -0.15270539f, 0.18834570f, -0.00179783f, 0.06609587f, 
    0.54643273f, 0.02579181f, 0.38084412f, 0.14306387f, -0.24604733f, 0.30284256f, -0.07467386f, 0.07563981f, 
    0.12749308f, -0.06032725f, 0.02794021f, -0.01139913f, -0.17204773f, -0.01914603f, -0.14080529f, 0.01673243f, 
    0.06200198f, 0.11361045f, -0.06264222f, 0.10584776f, -0.20054242f, 0.16663635f, 0.13201685f, 0.03160708f, 
    -0.34995019f, -0.35939747f, -0.51261210f, -0.47151339f, 0.09330982f, 0.09125479f, -0.04916149f, 0.06435157f, 
    0.04791137f, 0.00394745f, 0.13954763f, 0.18859398f, -0.10568064f, 0.29078016f, 0.42893866f, 0.34392500f, 
    -0.37037361f, 0.00407851f, 0.12475745f, -0.02201560f, -0.00782108f, 0.11777238f, 0.07031141f, -0.05219119f, 
    -0.00057981f, 0.15470254f, 0.14374146f, 0.06319574f, 0.08373702f, 0.03283282f, 0.02003333f, -0.08620793f, 
    -0.08083099f, -0.08489338f, -0.12312222f, 0.24694815f, 0.00564855f, 0.14270814f, 0.20116338f, -0.14288743f, 
    -0.00078440f, 0.06230081f, 0.14379567f, 0.17250820f, 0.14982301f, -0.09264796f, 0.06200036f, 0.04296945f, 
    -0.10141508f, 0.28286126f, 0.15855677f, -0.04515249f, -0.08104307f, 0.17874369f, -0.15958159f, 0.09946278f, 
    -0.12832883f, 0.01472308f, -0.01606558f, -0.12979698f, 0.17866854f, 0.28268242f, 0.34134278f, 0.17238779f, 
    -0.00857318f, -0.03060181f, -0.00961154f, -0.03162075f, 0.03246106f, -0.09604916f, -0.01512444f, -0.09009667f, 
    -0.35393181f, 0.18368436f, 0.22222690f, -0.14803855f, 0.31351197f, 0.00658111f, -0.11287192f, 0.02109614f, 
    0.12950508f, -0.01923180f, 0.06209437f, 0.08011513f, 0.41990963f, -0.27641433f, -0.39396018f, -0.09158320f, 
    0.04641604f, 0.17373459f, 0.02328174f, 0.06701269f, -0.01984554f, 0.01108280f, 0.02021947f, -0.02649247f, 
    0.02984020f, -0.33420146f, 0.58419138f, -0.87662661f, -0.00061095f, -0.10382944f, 0.01185199f, 0.07538006f, 
    0.05174751f, 0.09911489f, 0.12405293f, -0.00492386f, -0.23594512f, -0.27912661f, -0.06020426f, 0.26866555f, 
    0.09905033f, -0.20262679f, 0.13961542f, 0.02307181f, 0.06364131f, 0.03050247f, -0.03303466f, 0.02147127f, 
    0.35914201f, 0.07528062f, 0.28763154f, 0.30137250f, -0.38203982f, 0.13523847f, 0.00080024f, 0.16275349f, 
    0.00652288f, 0.01396841f, 0.01235964f, 0.21945043f, -0.49721339f, -0.06890178f, -0.22436289f, 0.42529589f, 
    -0.22802101f, -0.10968956f, 0.19153832f, 0.09753665f, -0.04325812f, -0.17101261f, -0.01619831f, -0.11347441f, 
    -0.26644972f, 0.14538094f, -0.09522686f, -0.15128580f, 0.18407448f, 0.11321864f, 0.02630970f, -0.06050814f, 
    0.09426952f, 0.04023170f, -0.03690182f, 0.13110808f, -0.53000605f, 0.48310614f, -0.00712333f, 0.04834445f, 
    0.19133720f, 0.15339682f, 0.06093462f, 0.01217456f, -0.11856010f, 0.09344556f, 0.03096425f, 0.03004768f, 
    0.43583569f, -0.16551286f, 0.34790909f, 0.50303811f, -0.07027377f, 0.07466246f, 0.10106169f, -0.00300181f, 
    0.02522768f, 0.07942021f, 0.30002293f, 0.05790319f, -0.31493384f, 0.22169226f, 0.11493260f, -0.08425702f, 
    0.19920513f, -0.12823293f, 0.10055662f, 0.05598922f, -0.10283554f, 0.05107320f, 0.05934088f, 0.07557948f, 
    -0.03258031f, 0.00797686f, 0.48319507f, 0.08548302f, -0.00134047f, -0.03201456f, -0.10145637f, 0.19632079f, 
    0.09694777f, 0.08747990f, 0.16895767f, 0.14494982f, 0.38196030f, -0.09955220f, -0.07326729f, 0.43777370f, 
    -0.03056297f, 0.05812214f, 0.07827353f, 0.14043170f, 0.13625708f, 0.17832977f, 0.05063938f, -0.09226248f, 
    -0.66540426f, -0.45151246f, 0.12660307f, 0.10381936f, 0.01866690f, 0.15749945f, -0.01756563f, 0.00944765f, 
    0.11036985f, 0.05709693f, -0.07590277f, -0.06084749f, 0.49404749f, -0.22896953f, -0.17963253f, -0.04613678f, 
    -0.29470196f, -0.03558493f, -0.00886077f, 0.07198999f, -0.02104140f, 0.17015693f, 0.05577849f, 0.11520865f, 
    -0.25246108f, 0.40413129f, 0.05217879f, 0.10334054f, -0.05910772f, -0.18045600f, -0.05737594f, 0.03433773f, 
    0.16926765f, -0.06798813f, 0.16102079f, 0.13036735f, -0.58248913f, -0.42745432f, -0.02120371f, -0.47261071f, 
    0.10575910f, 0.03966838f, 0.00246467f, 0.15521540f, 0.03411408f, -0.16018526f, -0.13263847f, 0.17224264f, 
    -0.38204062f, 0.47418287f, 0.39090666f, 0.20191638f, -0.16867904f, -0.14337197f, 0.07106250f, -0.09478494f, 
    0.00163759f, 0.21250570f, -0.07536940f, -0.06875602f, -0.42081684f, 0.13630569f, -0.07387714f, -0.05403294f, 
    0.07752333f, 0.16123676f, -0.24542958f, -0.08885664f, 0.06316015f, 0.07098998f, -0.15055747f, 0.21213712f, 
    0.20199569f, -0.13634512f, -0.06487423f, 0.20095536f, 0.08002366f, -0.03521004f, -0.06350537f, -0.04806020f, 
    -0.11728786f, 0.04684942f, 0.01849204f, 0.10214679f, 0.20465338f, 0.15520231f, 0.07677769f, -0.53621083f, 
    -0.08202124f, -0.26314947f, 0.19971415f, 0.01212355f, -0.11750218f, -0.01153247f, 0.04413477f, -0.01914677f, 
    0.22801250f, -0.22435655f, 0.16430078f, 0.26816022f, 0.06270588f, 0.00145926f, -0.11117484f, -0.05944157f, 
    0.18063247f, -0.20591414f, 0.10629395f, -0.10646495f, 0.21634874f, -0.16714795f, 0.02028412f, -0.14782673f, 
    0.31937471f, -0.12703295f, -0.12907961f, -0.03749781f, 0.26769239f, 0.00688735f, -0.05625783f, -0.03549602f, 
    -0.23617390f, 0.24815965f, -0.19459379f, 0.16560924f, 0.03844011f, 0.03165905f, -0.04191863f, -0.03530420f, 
    0.03440098f, 0.05237967f, -0.12590139f, -0.00756394f, -0.33639592f, 0.41220775f, -0.13931552f, -0.22174822f, 
    0.01100896f, -0.12504208f, 0.11156337f, 0.00286274f, 0.04905230f, 0.13854468f, -0.09951908f, -0.04230950f, 
    -0.02369801f, 0.05818713f, -0.00982830f, -0.01802620f, -0.03076503f, -0.05946586f, 0.04480566f, 0.03278878f, 
    -0.01810517f, -0.04773236f, -0.07757154f, 0.01722098f, -0.05143011f, 0.03307972f, -0.05882018f, 0.01408051f, 
    -0.02373936f, 0.06049080f, -0.03769430f, -0.03499021f, 0.05669174f, -0.07095384f, -0.03126644f, -0.01369710f, 
    -0.08059477f, -0.05318466f, -0.04276703f, 0.00985283f, -0.06731682f, 0.03753968f, -0.03948135f, 0.03438297f, 
    -0.05628642f, -0.00242379f, 0.01613748f, -0.02133805f, -0.01846174f, 0.03240211f, 0.05472453f, 0.04758800f, 
    0.04564028f, -0.00374463f, -0.00571206f, -0.00031653f, -0.01184568f, 0.03219663f, -0.02609660f, 0.04652426f, 
    0.03240474f, -0.01473689f, -0.05287863f, 0.04399195f, 0.01199094f, -0.07272483f, 0.06406042f, -0.06861603f, 
    -0.07947556f, -0.00927049f, -0.03100179f, -0.06470317f, 0.00515843f, 0.03481579f, 0.04695056f, -0.02808448f, 
    0.04542664f, 0.00409823f, 0.04004026f, 0.02716077f, 0.05339342f, -0.01394719f, -0.01932265f, -0.02163902f, 
    0.00118894f, -0.00567811f, -0.05738173f, 0.02479026f, -0.07743385f, -0.03288650f, 0.02908536f, 0.05632358f, 
    0.01500298f, -0.01136919f, 0.00172213f, -0.07347218f, 0.03033101f, 0.00368127f, 0.05126536f, -0.00700961f, 
    -0.02629263f, -0.01821082f, -0.06486104f, 0.03976967f, -0.05312744f, -0.04554677f, 0.02526616f, -0.07270700f, 
    -0.01365081f, 0.04639924f, -0.00158418f, -0.02976489f, 0.00632763f, -0.05734212f, 0.01324088f, 0.05775463f, 
    -0.01162415f, -0.04401778f, 0.04460690f, -0.01912518f, -0.05354081f, -0.03522411f, 0.00464115f, -0.02613969f, 
    0.06062990f, 0.02511271f, -0.07747095f, -0.06222510f, 0.03988481f, -0.02356501f, -0.05814694f, 0.04620520f, 
    -0.00813580f, -0.01498486f, 0.05748001f, 0.05745186f, 0.04407692f, -0.00099736f, 0.05645124f, -0.01353826f, 
    -0.07134881f, 0.03014654f, -0.07415051f, 0.06423271f, -0.04427825f, 0.02045329f, -0.03619311f, -0.02019105f, 
    0.01312018f, -0.01570776f, -0.01302469f, 0.00094559f, 0.00097595f, -0.07430787f, 0.02480995f, -0.00589368f, 
    0.02719394f, -0.06938813f, 0.02002028f, -0.06336498f, 0.02779634f, -0.03718455f, 0.00446637f, -0.05049193f, 
    -0.02701434f, -0.03675830f, -0.02484542f, -0.05566191f, -0.07744509f, -0.03340156f, -0.07559999f, -0.05757474f, 
    -0.04571860f, 0.02834840f, -0.04922486f, 0.05683040f, 0.03215046f, 0.01884365f, -0.07261384f, 0.02374724f, 
    -0.05012035f, -0.07311664f, -0.01737307f, 0.06096365f, -0.01855913f, -0.05204241f, -0.04412762f, 0.06303965f, 
    0.06342045f, -0.04812765f, 0.01119100f, -0.05450527f, -0.02095588f, 0.05821157f, -0.07119603f, 0.01845152f, 
    -0.00431617f, -0.01166660f, -0.02585275f, -0.07324099f, -0.07714186f, 0.00428374f, 0.03316389f, 0.02434661f, 
    -0.04059933f, 0.06054471f, -0.01010749f, 0.04188614f, 0.04049373f, -0.06127759f, -0.02788048f, 0.01480601f, 
    -0.04442561f, -0.00308362f, -0.00505325f, 0.00325030f, -0.01917990f, 0.05119366f, 0.04883152f, -0.00455158f, 
    -0.06891859f, -0.05320887f, 0.05578554f, -0.04391051f, -0.03531509f, -0.00702039f, 0.04561986f, -0.01489026f, 
    -0.01712867f, 0.05421243f, -0.00795094f, 0.01628440f, 0.05161508f, 0.03617761f, 0.00463197f, -0.01717685f, 
    -0.03584246f, -0.04404055f, 0.00097080f, -0.05786924f, -0.03651969f, 0.03260713f, -0.06418914f, -0.07536918f, 
    0.02442021f, 0.06439434f, -0.07114544f, 0.06083923f, 0.05364098f, -0.01467371f, -0.01584896f, -0.01995111f, 
    0.01236371f, 0.06439047f, -0.01609562f, -0.04018025f, -0.05965808f, 0.02473293f, 0.03034492f, -0.03201206f, 
    -0.02993480f, -0.03660065f, 0.01601305f, -0.00324806f, 0.05975474f, 0.00433973f, -0.02364096f, -0.05999905f, 
    -0.04759994f, 0.03224231f, 0.02567162f, -0.05074329f, -0.00131279f, 0.03451420f, 0.02145387f, 0.04269290f, 
    0.01103743f, 0.04366515f, -0.04129322f, 0.02090782f, 0.06006548f, -0.03571374f, -0.02821099f, -0.02254223f, 
    -0.01915901f, -0.02703262f, -0.07073004f, 0.01165575f, -0.01366739f, -0.00074052f, 0.04863509f, -0.04180521f, 
    0.01254546f, 0.02687970f, -0.04715547f, 0.03934838f, -0.04380507f, -0.01880855f, 0.01041239f, -0.04991657f, 
    -0.02612427f, 0.02909143f, -0.01261038f, -0.03452073f, -0.05580909f, -0.05439436f, 0.04444825f, -0.00067339f, 
    0.04683003f, 0.05423772f, -0.05533600f, 0.05165370f, 0.00456044f, 0.02807734f, 0.04805496f, -0.00820479f, 
    0.02889258f, -0.05331858f, -0.02519947f, 0.01780690f, -0.05268782f, -0.07425025f, -0.05592886f, -0.01736210f, 
    0.04688042f, -0.01697688f, -0.02743909f, 0.01807009f, -0.06336444f, 0.02715267f, -0.06110949f, 0.06196296f, 
    -0.03972169f, -0.01018112f, -0.07332715f, -0.06845577f, 0.06082639f, -0.04890429f, -0.01639342f, -0.05198066f, 
    0.01056653f, -0.01465676f, -0.02270797f, 0.05224764f, -0.04586420f, 0.00351585f, -0.06738434f, 0.05137770f, 
    -0.06602568f, -0.06696241f, 0.03270693f, -0.02543395f, -0.00260274f, 0.05781361f, 0.05118884f, -0.06110760f, 
    0.05196292f, -0.03260424f, -0.06332928f, 0.00122131f, -0.05738396f, -0.02619783f, 0.00425706f, 0.04334100f, 
    -0.01452304f, 0.02231048f, 0.01709094f, -0.02862296f, 0.00128114f, -0.04093617f, -0.02635858f, -0.05421180f, 
    0.01575115f, -0.05257357f, -0.05688035f, -0.06920978f, -0.04380979f, -0.01603506f, -0.06085825f, -0.04236902f, 
    -0.04141748f, -0.04297057f, 0.05411279f, 0.03832688f, 0.05514768f, 0.05873723f, -0.03524479f, -0.06875162f, 
    0.02857070f, -0.03914746f, 0.05785564f, -0.07109638f, 0.05661497f, -0.04973398f, 0.01348258f, -0.00000664f, 
    0.06507546f, 0.09324663f, 0.15572006f, -0.15493648f, 0.19432646f, 0.02119154f, 0.03127226f, -0.03526134f, 
    0.11563192f, -0.03711895f, 0.03898116f, 0.17016000f, 0.15512854f, 0.00639163f, -0.02671679f, -0.16328815f, 
    0.04363687f, 0.09332561f, -0.04657565f, 0.09580497f, -0.22096227f, -0.03532278f, 0.10036491f, -0.00634275f, 
    -0.13816112f, -0.12244790f, 0.29538748f, 0.29346082f, 0.09285954f, -0.01947314f, 0.04871004f, 0.12901387f, 
    -0.08558563f, 0.07008249f, 0.00111046f, 0.27140835f, 0.45662367f, -0.01246492f, 0.29383755f, -0.00729086f, 
    0.11448035f, -0.12449760f, 0.09409131f, 0.11783753f, 0.00484865f, 0.11219400f, 0.06173663f, 0.02973792f, 
    -0.14074454f, -0.19334571f, -0.06194521f, -0.07504091f, -0.00642814f, -0.01717734f, -0.07155424f, 0.14592996f, 
    -0.01127493f, 0.03314886f, -0.05129351f, 0.05009639f, 0.42891961f, 0.18126941f, 0.08638712f, 0.22189148f, 
    -0.02746045f, -0.16145550f, 0.18868168f, -0.05989205f, -0.02885918f, 0.15455440f, -0.18399337f, 0.04430586f, 
    0.01495339f, 0.42173499f, -0.26206490f, -0.17594457f, 0.00474477f, -0.04245397f, 0.13269839f, 0.05728824f, 
    -0.06569947f, -0.15502901f, 0.40469438f, -0.12315230f, -1.20327687f, -0.44212922f, 0.06529673f, -0.23083335f, 
    0.25543231f, -0.02810669f, -0.16308078f, 0.13840729f, -0.03014682f, 0.01188248f, -0.06132745f, 0.02542525f, 
    0.39119858f, -0.01501267f, 0.07117617f, -0.07635691f, -0.05353038f, 0.10151558f, 0.06532780f, -0.15420070f, 
    0.02739562f, 0.10647976f, -0.06614474f, -0.18848796f, -0.07406825f, -0.17610306f, -0.12227053f, 0.12097353f, 
    -0.10167724f, -0.04911891f, -0.14757550f, 0.09314978f, -0.12328950f, -0.10579340f, -0.15480542f, -0.05830121f, 
    -0.02660035f, 0.00143313f, 0.00756076f, -0.17473000f, 0.06720120f, -0.16347541f, -0.09284659f, 0.10869194f, 
    0.26073173f, -0.04418528f, -0.02874231f, 0.03078071f, -0.07618626f, -0.12416160f, 0.05990021f, 0.10038569f, 
    0.01165873f, -0.21654111f, -0.05408224f, 0.10679635f, 0.03461163f, -0.00972529f, -0.04371327f, 0.09328100f, 
    0.18395735f, 0.12191758f, 0.29895279f, 0.53543144f, 0.11740237f, 0.08067578f, 0.01989085f, -0.15569530f, 
    -0.01449074f, -0.05374836f, 0.03675453f, 0.00778719f, -0.12412769f, 0.14758737f, 0.02114136f, 0.18912956f, 
    0.26117843f, -0.17981927f, 0.01485522f, 0.10246009f, 0.36241934f, -0.20257123f, 0.17686066f, -0.20112160f, 
    0.10823722f, 0.04625795f, -0.13377719f, -0.13587964f, -0.10822869f, -0.04290184f, -0.05046238f, -0.11569784f, 
    0.06351591f, 0.08509103f, -0.03261619f, 0.05339059f, -0.05098463f, 0.08519836f, -0.12629691f, -0.05417508f, 
    -0.10907100f, -0.10929199f, 0.12139142f, 0.20788603f, -0.06080581f, 0.10703940f, -0.18676016f, 0.10595462f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02667076f, 0.12767412f, -0.05106241f, 0.17062961f, 0.12729734f, -0.03133286f, 0.04370510f, -0.13940614f, 
    0.05499747f, -0.07524255f, 0.02948338f, -0.05168131f, -0.04263230f, 0.04635851f, -0.02873647f, -0.03739460f, 
    -0.04917282f, -0.06363923f, -0.11585348f, 0.05371306f, 0.23905019f, -0.04686484f, 0.02893230f, 0.03273018f, 
    0.11363328f, -0.04975249f, 0.01509627f, -0.00646090f, -0.06906680f, -0.05037401f, -0.04211361f, 0.09087250f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.38912398f, -0.54910511f, 0.15708430f, -0.23121861f, -0.35644841f, 0.03071121f, 0.08094636f, 0.41365984f, 
    0.43953204f, -0.13858537f, 0.00154304f, -0.04213950f, 0.06629471f, 0.09985573f, -0.03500678f, -0.11839241f, 
    0.15374655f, -0.04882751f, 0.14726306f, -0.02313486f, 0.02351430f, 0.03196979f, 0.15420683f, 0.20133530f, 
    -0.23658180f, -0.01770598f, 0.04541009f, 0.44055495f, -0.19900663f, 0.01534623f, -0.02273175f, -0.71202737f, 
    0.36511958f, -0.17234552f, -0.51449788f, 0.08417574f, 0.20941210f, 0.05380712f, -0.08844852f, 0.32340768f, 
    0.28818044f, 0.03028568f, 0.25403374f, -0.04391633f, 0.11949067f, 0.01923109f, 0.13139024f, 0.10537226f, 
    -0.14524706f, -0.08115426f, -0.37510166f, -0.14420657f, 0.12681095f, 0.00811535f, 0.11196337f, -0.27629244f, 
    -0.20882905f, -0.70341241f, -0.27337176f, 0.23075739f, 0.27600914f, -0.17722619f, -0.09954426f, 0.49089643f, 
    -0.19828373f, 0.16790636f, -0.77647811f, -0.00795688f, -0.52745879f, -0.04015987f, 0.17216420f, 0.36925298f, 
    -0.47707385f, 0.03961656f, 0.48595756f, -0.00595709f, 0.13133430f, 0.11094589f, 0.16670065f, -0.08765426f, 
    0.00502527f, 0.29164690f, 0.21043123f, 0.16499247f, -0.02411400f, -0.11175472f, 0.13037175f, 0.27176687f, 
    0.14577398f, -0.57995516f, -0.36164498f, -0.17954576f, -0.66791373f, 0.07778431f, 0.14454272f, 0.10048313f, 
    -0.24999303f, 0.32995862f, -0.00657398f, 0.13347535f, -0.55804718f, 0.12331713f, 0.04604988f, -0.80522174f, 
    -0.09905008f, -0.07393228f, 0.16293161f, 0.14094472f, 0.16430691f, -0.14456066f, 0.08846490f, 0.06210234f, 
    -0.02306760f, -0.40496665f, 0.27092648f, 0.03732553f, -0.60663390f, 0.11174289f, 0.05069715f, -0.07380321f, 
    -1.02829874f, -0.36466604f, 0.47749093f, 0.30288652f, 0.50754529f, 0.15898569f, 0.02460034f, 0.05582570f, 
    -0.22496878f, 0.16120006f, -0.03195826f, 0.17175488f, -0.45858479f, 0.06596982f, -0.02513804f, -0.08336855f, 
    -0.02093594f, -0.13680263f, -0.55582470f, -0.04710715f, 0.14874405f, 0.03574398f, -0.13785979f, -0.04369580f, 
    -0.05362868f, 0.40494516f, -0.18959898f, 0.16980697f, 0.10212705f, -0.07092387f, 0.12291490f, 0.25857916f, 
    -0.47856924f, 0.62167048f, -0.12298411f, -0.14445855f, 0.45915762f, 0.02955588f, 0.08945386f, 0.12992874f, 
    -0.15171103f, 0.14560559f, 0.46364078f, -0.50759417f, 0.10068623f, 0.15517472f, -0.08991486f, 0.07919189f, 
    -0.06546661f, 0.11401093f, 0.02633448f, 0.00213703f, 0.08968661f, -0.07225975f, -0.05560340f, -0.14669381f, 
    0.04082035f, 0.02677967f, -0.60073018f, -0.14967825f, 0.26274285f, 0.10931689f, 0.11344837f, -0.26778936f, 
    -0.00313565f, 0.29793352f, 0.18959117f, 0.32811826f, -0.38667771f, 0.09799606f, -0.08286905f, 0.30917680f, 
    -0.96782154f, 0.05302936f, -0.30710807f, 0.03459077f, 0.37970200f, -0.09949038f, -0.16900595f, -0.25819895f, 
    -0.16290483f, -0.05367102f, -0.82837433f, -0.02791974f, -0.15712850f, -0.11889470f, -0.11857705f, -0.12173966f, 
    0.01775092f, 0.20484018f, 0.34205964f, -0.06350646f, -0.03808372f, -0.05800078f, -0.00705958f, 0.35542974f, 
    0.29046044f, -0.32678556f, 0.07661294f, 0.39439371f, -0.46141660f, -0.07171215f, 0.15824535f, -0.04954601f, 
    0.05193618f, 0.02071001f, 0.42805862f, 0.34615859f, 0.13619824f, 0.02806961f, -0.16353364f, 0.20827323f, 
    -1.01308334f, 0.01919358f, -0.40732929f, -0.02214392f, 0.00398455f, 0.01151993f, 0.09190849f, 0.16512612f, 
    -0.17076305f, 0.29945764f, -0.33739504f, -0.16877113f, -0.60965669f, 0.03324858f, -0.05815245f, 0.25134936f, 
    -0.23166355f, 0.36932933f, 0.28785557f, -0.65009892f, -0.38041380f, 0.01558274f, 0.05757451f, -0.38685071f, 
    -0.09433815f, 0.12190261f, 0.43909809f, -0.28210828f, 0.22359031f, 0.03966504f, 0.17958751f, 0.26133391f, 
    -0.77076817f, -0.03082633f, -0.10482042f, 0.13178636f, 0.06075905f, -0.15026142f, -0.07263055f, -0.12820010f, 
    0.06409787f, -0.15271518f, 0.28664771f, -0.04525489f, 0.20809861f, -0.05035285f, -0.03992270f, -0.67698753f, 
    0.37151980f, -0.69033086f, -0.36503607f, -0.32609308f, 0.59741944f, 0.14346901f, 0.09980199f, 0.22386143f, 
    -0.86438340f, -0.02368094f, 0.28869861f, 0.25678948f, -0.44988856f, 0.04271182f, 0.08182287f, 0.27793953f, 
    0.31018159f, 0.15044066f, -0.00000876f, -0.07399166f, 0.16145006f, 0.07300131f, 0.04543761f, 0.07971594f, 
    0.07057007f, -0.74883586f, -0.48997313f, 0.00471939f, -0.12943271f, 0.10411593f, -0.05726136f, 0.35021847f, 
    0.54634386f, 0.19969743f, -0.06303751f, -0.46438882f, -0.55988038f, -0.08117472f, -0.17530018f, 0.03173273f, 
    0.22399502f, 0.39079222f, -0.28910145f, 0.29106537f, 0.18977524f, -0.04015909f, 0.01518729f, -0.89698642f, 
    -0.83402830f, 0.10712444f, 0.37585002f, 0.12242983f, -0.15813456f, -0.00689011f, 0.10967546f, -0.13508050f, 
    -0.05775885f, -0.98639685f, -0.26597902f, 0.14141883f, 0.56028599f, 0.01366852f, 0.15792331f, 0.16279812f, 
    -0.34516907f, -0.11788677f, 0.09034815f, -0.39994130f, -0.53666174f, -0.04525846f, -0.06822797f, -0.54481339f, 
    -0.15579572f, -0.10505679f, 0.02024358f, 0.01961269f, 0.21763301f, 0.00801638f, 0.01295738f, -0.96501511f, 
    0.42175969f, 0.02944874f, 0.34336418f, -0.02791147f, -0.14464010f, -0.01893550f, 0.11240511f, 0.16126822f, 
    -0.01648768f, 0.52613240f, 0.48801097f, 0.07121599f, -0.31894937f, -0.09513268f, -0.04522036f, -0.17917134f, 
    -0.09680877f, 0.28944987f, 0.11725337f, -0.42988583f, -0.06001676f, -0.01155469f, 0.00653207f, -0.02496717f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00665065f, 0.12390536f, -0.11787752f, -0.03669114f, 0.15455125f, -0.00677812f, 0.19678076f, -0.21045761f, 
    0.03759033f, 0.19706739f, 0.21145204f, -0.14367172f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
