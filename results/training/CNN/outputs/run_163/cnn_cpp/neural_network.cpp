#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.04107660f, 0.60573882f, 0.63842827f, 0.67268968f, 0.78788340f, 0.68224847f, 0.23765334f, -1.01664710f, 
    0.81912589f, -0.47183031f, -0.30435947f, 0.11502431f, -0.54127598f, 0.58985949f, -0.53637660f, -0.20220064f, 
    -0.16536242f, -0.30772233f, -0.21527030f, -0.30650559f, 0.01648749f, -0.05134629f, -0.35758519f, -0.32830203f, 
    -0.05211240f, -0.14236315f, -0.91145259f, -0.49207416f, 0.49816972f, 0.93855947f, 0.80146450f, -0.89802110f, 
    -0.74645394f, 0.15017392f, -0.06638066f, -0.53800297f, 0.01490475f, 0.34235042f, 0.21214391f, 0.29867455f, 
    0.16063555f, -0.17964190f, 0.07173654f, -0.03547771f, -0.05035417f, 0.00108936f, -0.25034454f, -0.48527470f, 
    0.15929927f, -0.31591961f, -1.23694456f, -0.40097475f, -0.14288831f, -0.61419195f, -1.18796229f, 0.36649442f, 
    -0.07996975f, -0.69319522f, 0.51338649f, 0.48404011f, 0.36414173f, -0.30245903f, 0.31842053f, 0.29970565f, 
    0.13822401f, 0.41132548f, 0.12790293f, -0.09808289f, -0.05966866f, 0.20915850f, -0.16060020f, -0.25880435f, 
    -0.12810242f, -0.36806461f, 0.01644408f, 1.13864398f, 0.56396008f, -1.20961940f, -1.21543610f, -1.07713366f, 
    0.35434297f, -0.20476308f, 0.18578595f, 0.30421439f, -0.17768322f, -0.27371678f, 0.22830871f, -0.07961755f, 
    0.25082549f, -0.26269257f, 0.14312762f, 0.06753921f, 0.07263044f, -0.06430283f, -0.08450235f, -0.11836220f, 
    0.04996442f, 0.05222952f, -0.23614790f, 0.06817029f, -0.17864762f, -0.74810863f, 0.48788607f, -0.44975513f, 
    -0.87126052f, -0.49421731f, -0.93064982f, -0.26432291f, 0.15638803f, 0.18525349f, 0.17970988f, 0.02317232f, 
    -0.28014758f, -0.41109082f, 0.08502776f, -0.16573408f, -0.50573605f, -0.57461315f, -0.39813980f, -0.42993206f, 
    -0.06992921f, 0.12770626f, 0.20910557f, 0.30462658f, 0.36493424f, -1.35037410f, 0.78373784f, 0.91018087f, 
    -0.15788455f, -0.04092429f, -0.89536905f, 0.84353405f, -0.25473827f, -0.44104528f, -0.16542806f, -0.45323318f, 
    0.30231515f, -0.36044607f, 0.45650595f, 0.31250739f, -0.06281472f, -0.19297796f, -0.04615868f, -0.17003888f, 
    -0.37596387f, 0.22811560f, 0.25001323f, 0.16979319f, 0.21861888f, -0.36843231f, 1.05597186f, 0.66874254f, 
    0.64848185f, 0.96699238f, 1.11697829f, 0.67993367f, -0.26416516f, 0.32122639f, 0.01116915f, 0.19868258f, 
    -0.13575637f, 0.04645003f, -0.16073895f, -0.03615042f, -0.41507196f, 0.26008826f, -0.08084980f, -0.04299536f, 
    -0.06953193f, -0.44052225f, 0.39693952f, 0.12267695f, 0.33228543f, -0.16725592f, 0.34005204f, -0.46027887f, 
    -1.32895088f, -0.74256653f, 0.11915059f, -0.45097557f, -0.23208155f, 0.95352542f, 0.81270987f, -0.26319298f, 
    0.51876831f, -0.19884138f, 0.36147067f, 0.21453646f, 0.20065950f, -0.21121444f, -0.56066447f, -0.16999315f, 
    -0.08243863f, -0.09268036f, -0.22230947f, 0.33101454f, -0.04365645f, -0.25103197f, 0.04721574f, 0.12838234f, 
    1.54287302f, 0.77187508f, -0.83749044f, 0.58920622f, 1.01778460f, 0.51913738f, 0.34493211f, 0.03483071f, 
    0.70877069f, 0.09968396f, -0.20161316f, -0.08444422f, -0.00051405f, -0.01404406f, 0.30222529f, -0.00775928f, 
    0.03267072f, -0.07395513f, -0.18449099f, 0.20769870f, 0.02417593f, -0.04216820f, 0.09006706f, 0.03682459f, 
    0.08658899f, -1.03991306f, 0.33222711f, 0.81937951f, -0.80622828f, 0.34349069f, 0.97927290f, 0.43765131f, 
    -0.45125479f, 0.14771710f, -0.91998166f, 0.17390482f, -0.12296183f, -0.23135801f, -0.26796287f, -0.45878398f, 
    -0.21013702f, -0.04619583f, 0.25740120f, -0.19079863f, -0.07795633f, 0.15232463f, -0.00452741f, 0.09923764f, 
    0.12991615f, 0.10508955f, -1.41300619f, -0.63384134f, -0.25888914f, 0.62755787f, -0.45481199f, 0.60979372f, 
    1.16554606f, 0.10615798f, 0.44472766f, -0.16311775f, 0.04400408f, -0.41383946f, 0.02938089f, -0.01999025f, 
    -0.03011573f, 0.18919988f, 0.03271668f, -0.39031148f, -0.50547010f, -0.38844290f, -0.04204034f, 0.00147958f, 
    0.08672767f, -0.01479252f, -0.12072124f, -0.50091636f, -0.74444091f, -0.72381568f, -0.35438213f, -0.12782103f, 
    0.63116407f, 0.80634940f, 0.30394360f, 0.64732772f, 0.71883816f, -0.17655608f, -0.29933554f, -0.50787044f, 
    -0.05607978f, 0.20767839f, -0.17204587f, 0.18577687f, 0.00116555f, 0.41890913f, -0.14930463f, -0.36356428f, 
    -0.28110915f, -0.24514546f, -0.44149920f, -0.07162246f, -0.26694265f, 0.83929253f, 0.39683118f, -0.16157277f, 
    0.64749688f, -0.61906230f, -0.32613832f, -0.88056505f, -0.86412793f, -0.72998697f, 0.15552182f, -0.19893768f, 
    0.40315366f, -0.03570326f, 0.44836119f, 0.02283182f, 0.21487732f, -0.19753473f, 0.04184349f, 0.28190041f, 
    -0.02560561f, 0.09838884f, -0.00522906f, -0.03292136f, 0.23590544f, -0.48956770f, -0.17132951f, 0.43387824f, 
    0.10476392f, -0.74597251f, 0.69325703f, -0.63385242f, -0.27563065f, -0.18912996f, -0.38368779f, -0.30797651f, 
    -0.41434804f, 0.27137476f, -0.20613831f, 0.03646094f, -0.05854664f, 0.26542053f, 0.23389131f, -0.15696105f, 
    0.17019387f, 0.57953197f, 0.39888424f, 0.21241902f, -0.14738962f, -0.67092180f, 0.56923264f, 0.01540020f, 
    -0.62766075f, -1.00034511f, 0.65957117f, 1.07329154f, -0.37279731f, -0.85052520f, -0.18125613f, -0.13067581f, 
    0.44378033f, 0.56322473f, 0.10182197f, 0.12893605f, -0.03208862f, 0.00728412f, 0.46999365f, 0.18382929f, 
    0.41014165f, 0.36297235f, 0.30209601f, -0.07804418f, 0.23503940f, 0.05344016f, -0.08865230f, 1.20677280f, 
    -0.08495597f, 1.07823324f, -0.23858555f, -0.41437799f, 0.74357808f, -0.91062856f, 0.71378505f, 0.89541429f, 
    0.59728378f, -0.32988378f, 0.11679495f, -0.46002212f, 0.01839506f, -0.19640885f, 0.12576675f, -0.05507276f, 
    -0.22698018f, -0.38601109f, -0.10770951f, -0.02293884f, -0.19333182f, -0.18221499f, 0.01721561f, -0.27420729f, 
    -0.86220855f, -0.81880754f, -0.98927188f, -0.73776716f, -0.19160077f, -0.97244287f, 0.51445967f, 0.78712887f, 
    -0.05866082f, 0.28337154f, 0.13767265f, -0.10888214f, 0.21850128f, -0.49087036f, 0.01905115f, 0.30151644f, 
    0.34212580f, 0.10711464f, 0.35247496f, -0.23669261f, -0.23719130f, -0.11982553f, 0.10197292f, 0.06856725f, 
    0.11340856f, -0.21667393f, -0.17555973f, -0.92585361f, -0.61561584f, -0.31390956f, 0.54216313f, -0.88544124f, 
    -0.72626877f, -0.59946364f, -0.22439703f, 0.07523302f, -0.08273991f, 0.50406396f, 0.32531285f, -0.23560837f, 
    -0.20373249f, 0.17102346f, 0.17542575f, -0.31882307f, -0.31091711f, 0.21190527f, 0.23490928f, 0.38339612f, 
    0.10281722f, 0.02408949f, 1.05784357f, 0.37627876f, -0.77126223f, -1.03470886f, -0.10640167f, -0.10595471f, 
    -0.48724762f, -0.35891530f, -0.27173850f, -0.36549181f, -0.30190605f, -0.47571266f, 0.17808053f, 0.43508729f, 
    -0.13463344f, -0.17127322f, -0.14501858f, -0.44039208f, -0.05315742f, 0.50478005f, -0.13541313f, 0.38805729f, 
    0.00221871f, -0.22530071f, -0.42582750f, -0.63095129f, -0.81580752f, -0.37391102f, 0.59167629f, -0.01950083f, 
    0.10812681f, 0.40775266f, 0.64484841f, -0.83019561f, -0.51976204f, -0.32125518f, 0.19251609f, -0.21400057f, 
    0.30356961f, 0.40041253f, -0.11393337f, -0.40218487f, -0.15260345f, 0.23127468f, 0.05285926f, 0.23473848f, 
    0.35593328f, -0.27666438f, 0.84427011f, -0.40877670f, -0.37727442f, -0.43534684f, 0.45657477f, 0.62287933f, 
    0.31265604f, 0.48782435f, -0.16977404f, 0.01426027f, -0.60629314f, -0.08256168f, 0.11155812f, 0.31041092f, 
    -0.24872538f, -0.09035917f, -0.03598628f, -0.10151383f, 0.47378075f, -0.13333727f, -0.46797377f, -0.64855462f, 
    -0.52950782f, -0.15310629f, 0.52484810f, 0.50878996f, 0.05440440f, 0.55247468f, 0.85174596f, 0.92521876f, 
    0.46206966f, 1.06799579f, -0.41165158f, -0.57277185f, -0.43572310f, -0.14267175f, -0.74850154f, 0.29907706f, 
    0.18293475f, -0.42765775f, -0.15298450f, 0.12487977f, 0.07260493f, 0.00870922f, 0.15550028f, 0.04912155f, 
    0.65724498f, -0.08629426f, -0.05238968f, -0.07589347f, -0.09078956f, -0.16392957f, 1.27225602f, 0.62574083f, 
    -0.64180094f, 0.71580487f, -0.87432045f, -0.87957716f, 0.14061704f, 0.01073424f, 0.36706042f, 0.33933151f, 
    0.28909898f, 0.24360137f, 0.48327810f, -0.12286248f, -0.32455614f, -0.01218554f, -0.20364913f, 0.16823316f, 
    0.13259344f, 0.03234070f, 0.27167413f, 0.06680542f, 0.24636665f, 0.27143496f, -0.18155782f, 0.08488026f, 
    0.87636614f, 0.81676358f, 0.81827658f, -0.38438207f, -0.62372899f, -0.11260796f, -0.80216038f, -0.71539575f, 
    0.13133135f, 0.29712433f, 0.16292243f, 0.23308882f, 0.15523604f, 0.21709786f, -0.31251046f, -0.48674187f, 
    0.38797301f, -0.12044480f, -0.00264980f, 0.21494541f, 0.04627024f, -0.06585456f, -0.04683423f, -0.08462210f, 
    1.51155972f, 0.97897583f, 1.08443367f, -0.28991169f, -0.41955048f, 0.24152389f, -0.64357173f, 0.06999576f, 
    -0.35629612f, 0.00829773f, 0.61484951f, 0.16045304f, 0.10259070f, 0.13211745f, -0.27587235f, 0.03771226f, 
    0.05851495f, 0.29422864f, -0.12346885f, -0.26131815f, -0.17530689f, 0.18021703f, 0.41735062f, 0.05450964f, 
    0.32952824f, -0.14341924f, 0.14157960f, -0.72795200f, -0.17458756f, 0.10447481f, 0.89684761f, -0.75138783f, 
    0.55884105f, 0.50675428f, -0.66128767f, -0.56194425f, -0.19052282f, -0.24354292f, -0.05913749f, 0.22349794f, 
    -0.09873417f, -0.19309135f, -0.32539493f, 0.06578917f, 0.42084718f, -0.29494709f, 0.18303384f, -0.32608446f, 
    0.05924181f, -0.37020478f, -1.09275007f, 0.97481102f, 0.31713408f, -1.31536996f, 0.55524677f, 0.12522046f, 
    -0.60759127f, 0.35815269f, -0.02890415f, -0.47511697f, 0.39613494f, 0.08305251f, -0.26554334f, 0.07190193f, 
    -0.40110049f, 0.15737405f, 0.05884656f, -0.26454809f, -0.01636857f, 0.23325302f, -0.17945462f, 0.13808136f, 
    0.21783100f, -0.14354445f, 0.40653887f, -0.85131854f, -0.50374240f, -0.01092018f, -0.22865398f, -0.15659162f, 
    -1.27865541f, -0.09976879f, -0.56683284f, -0.74825585f, -0.08673779f, -0.14517194f, 0.34075662f, 0.06346279f, 
    0.06534903f, -0.71250188f, -0.40383008f, -0.38287440f, 0.15178464f, -0.32701787f, 0.12675439f, 0.05043108f, 
    0.14718609f, -0.10081025f, 0.28081822f, 0.03913052f, 0.01257483f, -0.04753045f, -0.37015003f, 0.59845984f, 
    1.01736641f, 0.54991776f, 0.74451274f, 0.83870971f, -0.02930089f, 0.31517032f, -0.44633847f, -0.54444069f, 
    -0.13618141f, -0.20089260f, 0.28304508f, -0.08875520f, -0.23977065f, 0.34756970f, -0.29199341f, -0.11863329f, 
    0.17527641f, -0.04381202f, 0.01746118f, 0.39091220f, -0.16642776f, 1.02905691f, 0.36249843f, 0.50167537f, 
    1.08465242f, 0.41392007f, 0.44010663f, 0.12087181f, -0.72489738f, -0.11219174f, 0.12735213f, 0.02341106f, 
    0.16920383f, 0.19362845f, 0.14237010f, -0.49822643f, -0.26734737f, 0.00410636f, 0.56857169f, 0.18048497f, 
    0.06336135f, 0.15437903f, 0.59735715f, -0.23902412f, -0.00625493f, 0.43213809f, -0.49465728f, -1.32849538f, 
    -0.37428567f, 0.93863022f, 0.39386925f, 0.21392120f, 0.58054870f, 0.42512700f, 0.43037695f, 0.04114778f, 
    0.38300392f, 0.26766500f, -0.11133040f, 0.43948424f, 0.31443864f, -0.19455543f, 0.27146134f, 0.36969003f, 
    -0.22627074f, 0.41032672f, -0.01219430f, 0.27836767f, 0.06595854f, 0.05161505f, -0.02683541f, -0.61389869f, 
    -0.15372090f, -0.84312385f, -0.60659564f, -0.59774619f, 0.64742959f, 0.06865399f, 0.02229873f, 0.42210326f, 
    0.40605152f, -0.76917422f, -0.58360451f, 0.30287400f, -0.53845125f, -0.66267776f, -0.11343541f, -0.31268936f, 
    0.30971149f, -0.43229237f, 0.12262653f, 0.08557386f, -0.55720991f, 0.05920258f, 0.11011313f, 0.29255033f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06587896f, 0.33198640f, 0.12872867f, 0.22635035f, 0.36024651f, 0.15544838f, 0.26295370f, 0.23851621f, 
    0.36573815f, -0.02861039f, 0.20317948f, 0.01318244f, 0.32600114f, 0.33525175f, 0.43792626f, 0.09002765f, 
    0.29091099f, 0.44648409f, 0.32030565f, 0.17236304f, 0.28450981f, 0.36750934f, 0.25909492f, 0.29405200f, 
    0.40391856f, -0.04001069f, 0.27105492f, 0.19182503f, -0.05524238f, 0.23359482f, 0.54560870f, -0.29125348f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18571082f, 0.00563315f, -0.04322441f, 0.16450901f, -0.09018293f, -0.20504317f, 0.02016916f, 0.02282239f, 
    -0.01538498f, 0.08210932f, -0.03919221f, 0.00097186f, -0.08672304f, -0.44126883f, 0.43711755f, 0.27985400f, 
    0.20819227f, -0.01272221f, 0.03074499f, -0.24402228f, -0.06460056f, -0.16696569f, -0.16282693f, -0.02401570f, 
    0.49311158f, -0.08615445f, -0.15566492f, -0.03045089f, -0.01025584f, -0.04970265f, -0.06638885f, 0.13250388f, 
    0.14483106f, -0.02621543f, -0.05212356f, -0.03317196f, -0.01953860f, 0.00761608f, 0.01419760f, -0.71619540f, 
    -0.15309887f, -0.04170577f, -0.05354649f, -0.09346369f, -0.11733817f, 0.03325412f, -0.14655671f, 0.02766391f, 
    -0.08835146f, -0.33440885f, -0.18244842f, 0.14114098f, -0.06937763f, 0.01246024f, -0.23854937f, -0.03248814f, 
    -0.10112077f, 0.15623614f, 0.03909899f, -0.02209101f, -0.23868801f, 0.01853767f, 0.14027365f, 0.12318040f, 
    0.17978139f, -0.06498015f, -0.00831449f, -0.02563125f, -0.04663872f, -0.09360566f, 0.07589469f, 0.00888035f, 
    0.23758321f, -0.18807583f, 0.16110826f, 0.18868354f, -0.17656027f, 0.02727496f, -0.03055033f, 0.04486248f, 
    -0.12636423f, 0.07039572f, -0.04507677f, -0.33323085f, -0.28784475f, 0.05600863f, -0.19690457f, -0.23516352f, 
    -0.09395742f, 0.07388055f, -0.09575195f, 0.11200169f, 0.07300507f, -0.06913994f, -0.02327844f, 0.08584452f, 
    0.22776589f, -0.03618902f, 0.09142249f, 0.18353875f, -0.32348207f, 0.11750423f, -0.00692866f, 0.12217367f, 
    -0.09345547f, 0.04235265f, 0.11255039f, -0.09829547f, -0.28351709f, 0.09098040f, 0.46577609f, -0.12528250f, 
    0.05829168f, 0.06762765f, 0.09402172f, -0.05423873f, 0.03466117f, -0.07222704f, 0.21930754f, 0.06530386f, 
    0.38305146f, 0.16609983f, 0.11286001f, -0.06029310f, 0.09125777f, 0.17603351f, -0.06747286f, 0.03306285f, 
    0.03002885f, -0.02655319f, -0.03902537f, 0.01012831f, 0.15989928f, 0.08293131f, 0.04371366f, -0.15409420f, 
    0.13817072f, 0.05218277f, 0.06555549f, -0.01851640f, 0.00494551f, -0.00173915f, -0.04145390f, 0.18068904f, 
    -0.06150499f, 0.31570297f, 0.14045990f, -0.02239825f, -0.06363857f, -0.09188691f, 0.07763866f, 0.05709699f, 
    -0.03004513f, -0.07704464f, -0.06268854f, 0.00735657f, -0.09508881f, 0.06299300f, -0.05465246f, 0.08878197f, 
    0.02053077f, 0.03531162f, -0.04540150f, -0.08469708f, -0.17864989f, -0.03055001f, -0.07583763f, -0.09590118f, 
    -0.11154187f, -0.39098039f, 0.33352059f, -0.35815769f, -0.11108627f, 0.09644762f, 0.15630221f, -0.10397242f, 
    0.06846072f, 0.01825267f, 0.11626820f, 0.04829421f, 0.53456479f, -0.19430500f, -0.08917062f, 0.21274076f, 
    -0.03056817f, -0.06425017f, -0.00342412f, 0.06386999f, -0.00336903f, 0.03451408f, 0.09672885f, 0.04993705f, 
    -0.35195810f, 0.24353699f, -0.07697966f, -0.35386205f, 0.15406390f, -0.09913579f, 0.03243184f, 0.08002736f, 
    0.10360017f, 0.03507909f, -0.04557746f, 0.06177891f, -0.17759927f, -0.31170809f, 0.12394251f, -0.04764560f, 
    -0.05846824f, 0.05102210f, 0.11388590f, 0.00543659f, -0.15257525f, 0.04682744f, -0.08621180f, -0.00173080f, 
    -0.10387224f, 0.03802012f, 0.30228174f, -0.54942578f, -0.02745350f, 0.06950846f, 0.12798758f, 0.12312017f, 
    0.06677135f, -0.09724297f, -0.09710272f, -0.10736207f, -0.36231884f, 0.15277064f, -0.20663252f, 0.01627637f, 
    0.10181288f, -0.00574295f, -0.11812533f, -0.14454700f, 0.22118357f, -0.10828074f, -0.02820192f, -0.16533427f, 
    -0.28484577f, -0.08961251f, -0.00068598f, -0.08392855f, 0.02790571f, -0.02679843f, -0.04374101f, 0.03762690f, 
    -0.08765768f, 0.10103606f, 0.13424741f, -0.03599654f, 0.16211936f, 0.12602781f, 0.11966088f, -0.13264225f, 
    -0.23230956f, -0.05883970f, 0.01739853f, 0.07231903f, 0.10421648f, -0.13668782f, -0.05360426f, -0.01555799f, 
    -0.19174145f, 0.03872317f, -0.04649562f, 0.15159042f, -0.04692876f, -0.17264163f, -0.24545316f, 0.08062298f, 
    0.01948299f, 0.12183522f, 0.10081882f, -0.08586119f, -0.12163956f, 0.19574302f, -0.14781015f, 0.15725382f, 
    -0.09663107f, 0.02776050f, 0.07808174f, -0.13823187f, -0.01977700f, 0.10705347f, -0.01085792f, -0.02906401f, 
    0.19801153f, -0.09649703f, 0.02153461f, -0.40919417f, -0.23606473f, -0.20218430f, 0.01125083f, 0.03598098f, 
    -0.00781696f, 0.01403170f, -0.16410823f, 0.10147614f, 0.28803787f, -0.22767721f, 0.12759984f, 0.07358652f, 
    -0.05828866f, 0.00270024f, 0.02444690f, -0.12755442f, 0.03551274f, 0.02637539f, 0.00067716f, 0.18410403f, 
    -0.48632610f, 0.11405284f, 0.19880238f, -0.19188881f, 0.02112113f, 0.04755687f, -0.12621950f, 0.06653271f, 
    0.11950746f, -0.11208591f, 0.09028676f, -0.10360822f, -0.35343900f, -0.46809188f, -0.09871668f, 0.17741759f, 
    -0.27903098f, 0.00617502f, -0.00052138f, 0.13168904f, -0.07852320f, -0.02050793f, -0.01247645f, 0.10699595f, 
    -0.13811633f, 0.08684483f, 0.20357877f, 0.22133809f, -0.05849262f, 0.07221108f, -0.19324145f, -0.14484853f, 
    0.14602423f, -0.00178828f, 0.06474583f, 0.01630699f, 0.19273169f, -0.04979874f, -0.14688200f, 0.35272366f, 
    -0.19781215f, -0.05259033f, 0.00511068f, 0.00738857f, 0.00251800f, 0.15835230f, -0.30442402f, 0.12877032f, 
    -0.40635493f, 0.10623721f, -0.36755639f, 0.16116340f, 0.10672735f, 0.09619948f, -0.12939511f, 0.05115876f, 
    -0.02141937f, -0.10925978f, -0.01437082f, 0.07732635f, 0.48852065f, 0.19346280f, -0.17859483f, -0.31506217f, 
    0.10142263f, 0.10588789f, 0.00910260f, 0.18958692f, -0.24400494f, 0.05060672f, -0.01993637f, 0.11615659f, 
    0.36305240f, -0.11388778f, 0.04865510f, 0.19381736f, -0.11131820f, 0.11831996f, 0.09305163f, 0.04178564f, 
    -0.08959228f, -0.17143360f, 0.09661384f, -0.30513293f, 0.04753470f, 0.08671112f, -0.08605644f, -0.25073558f, 
    -0.11329754f, 0.07763285f, -0.12303598f, 0.02820927f, -0.14454573f, -0.11090829f, 0.02833989f, 0.13730791f, 
    -0.59940040f, 0.13052033f, 0.16947033f, 0.08453382f, 0.04800250f, 0.06489979f, 0.10823512f, 0.08542956f, 
    -0.16147070f, 0.11515242f, -0.00348108f, 0.10180268f, 0.25443584f, -0.36375996f, 0.04180480f, -0.54821545f, 
    0.00457819f, -0.12416793f, 0.08892119f, 0.07220352f, -0.04022768f, -0.09303971f, 0.15728453f, -0.11068426f, 
    -0.29404768f, 0.19770509f, -0.04241177f, -0.09877798f, 0.14358431f, 0.05167749f, -0.06539976f, 0.30380169f, 
    -0.00913141f, -0.16229220f, -0.26618373f, -0.01662268f, -0.43898347f, 0.13021044f, -0.24609271f, -0.27910593f, 
    -0.16027232f, 0.14547698f, -0.04061793f, -0.17547143f, 0.00527999f, -0.11752690f, -0.04700251f, -0.05807497f, 
    0.34380451f, 0.04672410f, 0.17906263f, 0.26679608f, -0.09842001f, 0.02411711f, 0.04977608f, 0.09712484f, 
    -0.04633323f, -0.10612799f, -0.02927920f, 0.17412530f, 0.34873572f, -0.15815179f, -0.15403102f, -0.00949308f, 
    0.04726730f, -0.06946232f, 0.01331737f, -0.00976427f, -0.05930958f, -0.19578110f, 0.00579575f, -0.00737857f, 
    0.24528459f, -0.25189626f, 0.10682308f, 0.17035703f, -0.08756075f, -0.15744375f, -0.10378820f, -0.05075677f, 
    -0.09128619f, 0.18300979f, -0.19816929f, 0.02371366f, -0.58314341f, -0.21914475f, -0.29833415f, -0.11088733f, 
    -0.09219602f, 0.22480206f, 0.00877877f, -0.03199420f, -0.00440950f, -0.03378624f, -0.21101749f, -0.03378781f, 
    -0.24378522f, 0.19051623f, -0.33785167f, 0.03235073f, -0.07455972f, 0.05196593f, -0.05062795f, -0.00689899f, 
    -0.02168430f, 0.03744787f, -0.07059052f, -0.09646904f, 0.21394193f, 0.02186757f, -0.09433153f, -0.17507814f, 
    0.20131373f, -0.04116651f, -0.17897204f, -0.01173326f, 0.08329558f, 0.11367076f, -0.09247442f, -0.07574737f, 
    -0.08930985f, -0.04640758f, -0.17077409f, -0.23842362f, 0.13653244f, 0.06356291f, 0.03127484f, -0.10661325f, 
    0.14966898f, -0.02990079f, 0.00052210f, 0.08670249f, -0.34359324f, -0.04870244f, 0.07879329f, 0.27822909f, 
    0.02861769f, -0.23446378f, 0.04957680f, -0.07475618f, 0.21104658f, 0.05754714f, -0.03849246f, 0.01119415f, 
    0.14360392f, -0.22668527f, 0.22834416f, -0.32171243f, -0.08849285f, -0.13476776f, 0.00948844f, 0.05464147f, 
    -0.07452047f, 0.10460227f, 0.07055166f, -0.05326717f, 0.19522247f, 0.16391781f, 0.10318936f, -0.03702641f, 
    -0.02761331f, -0.14165534f, -0.07227820f, -0.03907884f, 0.11469638f, -0.12684830f, 0.02485664f, -0.18476866f, 
    0.42704344f, -0.12602329f, 0.00545426f, -0.16300389f, -0.05984407f, -0.03331174f, -0.07291790f, 0.07473344f, 
    0.03496905f, -0.04941011f, -0.01033353f, -0.00641298f, -0.16329326f, 0.00003589f, -0.16260095f, -0.17683384f, 
    0.13109978f, -0.09032144f, 0.16390316f, 0.02258939f, 0.07196860f, -0.11642683f, -0.00268913f, -0.11746112f, 
    0.13045816f, -0.38461116f, -0.07683423f, -0.38322487f, 0.04314152f, -0.26503187f, 0.09484882f, 0.00191244f, 
    -0.28189170f, 0.07049280f, 0.03516462f, -0.04865681f, 0.09370328f, -0.00022221f, -0.20524846f, 0.32816032f, 
    -0.07520728f, -0.00149727f, -0.10204504f, -0.05712079f, -0.02866468f, 0.08686002f, -0.03282876f, 0.18353407f, 
    -0.06000596f, 0.14027105f, -0.11739571f, 0.38853800f, 0.10966112f, 0.06831817f, 0.02472697f, 0.09819879f, 
    0.00089995f, -0.20650260f, -0.07377505f, 0.06964348f, 0.05971147f, -0.07304811f, 0.06718077f, 0.25400609f, 
    -0.00742390f, -0.12658595f, -0.01716097f, -0.02399753f, -0.18663952f, -0.08101571f, 0.01789066f, 0.04156766f, 
    0.54336780f, -0.25815827f, -0.14873949f, 0.05355645f, -0.13109086f, -0.17719314f, 0.00727313f, 0.09078250f, 
    -0.04760093f, 0.02255796f, -0.09142095f, 0.16567793f, -0.03752945f, 0.03903218f, -0.14845002f, 0.03685815f, 
    -0.12452304f, 0.08661718f, 0.04037848f, -0.03406667f, 0.02835169f, -0.08242772f, 0.12236983f, -0.00980254f, 
    0.07642996f, 0.14668007f, 0.03137869f, 0.17334935f, -0.02597968f, -0.13859412f, 0.04773650f, -0.03633012f, 
    0.07777830f, -0.00769079f, 0.16667582f, 0.00246875f, -0.38417420f, 0.05224546f, -0.09524868f, -0.10231312f, 
    0.02648989f, 0.02385582f, -0.08227305f, -0.02030451f, -0.01751658f, 0.16794123f, 0.09117961f, -0.08092556f, 
    -0.06776429f, 0.08489534f, -0.17339148f, -0.56878948f, 0.00458821f, 0.03664883f, 0.03691002f, -0.00602127f, 
    0.05603498f, 0.31679517f, 0.07134964f, 0.00898177f, -0.08611673f, 0.02585135f, -0.08224488f, -0.20241739f, 
    0.05928031f, -0.02156942f, -0.01660038f, 0.24640810f, 0.01250474f, -0.01821815f, 0.17359883f, -0.29852286f, 
    0.22381173f, -0.04916788f, -0.00000106f, 0.00338920f, 0.01163007f, 0.12858300f, -0.03458625f, 0.06644850f, 
    -0.04957784f, 0.23195134f, 0.06547926f, 0.09055072f, 0.24630365f, -0.11093766f, 0.29509258f, 0.05649174f, 
    -0.20557581f, -0.00590268f, 0.00756855f, 0.08792914f, -0.03166262f, -0.01944818f, 0.14590806f, -0.16386952f, 
    0.38302478f, 0.02941839f, -0.11898904f, 0.14030977f, 0.03995341f, 0.01914736f, 0.00650228f, 0.05341128f, 
    0.04053115f, -0.01278913f, 0.15283869f, 0.14321738f, -0.30620787f, -0.27441293f, 0.13923974f, -0.17908478f, 
    0.11844828f, -0.01579991f, 0.03854907f, 0.07312758f, 0.24128750f, -0.08105358f, 0.13069403f, -0.10467138f, 
    0.30660212f, -0.38523468f, -0.11357193f, 0.09864081f, 0.06815173f, 0.01448571f, -0.04751934f, -0.16766618f, 
    -0.01982813f, 0.10365578f, -0.06263414f, 0.08713788f, -0.34098780f, -0.25561860f, 0.23878920f, -0.06078377f, 
    0.05911221f, 0.12341956f, -0.16185310f, -0.00117318f, -0.10108519f, 0.00860367f, -0.10381947f, -0.06733584f, 
    0.49463716f, 0.10266192f, 0.02749919f, -0.18602136f, 0.03868541f, -0.03528699f, -0.16044039f, 0.10579829f, 
    -0.01165211f, 0.08663920f, -0.08988559f, -0.10407998f, -0.29663882f, -0.02396216f, -0.08767150f, -0.02466924f, 
    0.04947843f, -0.15805446f, 0.23557986f, -0.06856170f, -0.04710241f, 0.00195775f, 0.05435414f, -0.00152494f, 
    -0.40797034f, -0.22249292f, 0.16047634f, -0.19435441f, -0.03962395f, 0.11659980f, -0.27200785f, -0.10809466f, 
    0.13259640f, 0.10747105f, 0.18889175f, 0.00947179f, 0.55863577f, 0.17980804f, -0.57644987f, -0.33831385f, 
    0.07944558f, 0.02032107f, -0.09311417f, -0.08338138f, 0.03721449f, -0.03756573f, 0.01625071f, -0.03082425f, 
    -0.17445098f, 0.00778075f, -0.10837940f, -0.00125784f, 0.18599626f, -0.02527691f, 0.03962353f, -0.01008376f, 
    0.00839757f, 0.15931988f, 0.00794946f, -0.07683521f, 0.46535689f, 0.16372763f, 0.07448182f, 0.39586830f, 
    -0.13260531f, -0.12683107f, 0.10717821f, 0.02536998f, -0.02405499f, -0.04857900f, -0.01173091f, -0.10171396f, 
    0.35821262f, -0.18993066f, 0.00431975f, -0.22244723f, 0.21522716f, -0.03024382f, 0.13053608f, 0.02280615f, 
    -0.08454740f, -0.03310438f, 0.01743268f, -0.01495465f, 0.34036696f, -0.32680812f, -0.12465884f, -0.02115416f, 
    -0.02750929f, -0.18890238f, 0.08545263f, -0.11977744f, 0.02705820f, 0.06525267f, -0.05256189f, 0.02286535f, 
    0.39105123f, -0.08388565f, 0.06749966f, 0.00010970f, -0.12905931f, -0.16623890f, -0.12280862f, 0.10071785f, 
    0.13598053f, 0.04352814f, 0.01750131f, -0.08174570f, 0.28646407f, 0.04201212f, 0.11699104f, 0.33103049f, 
    -0.18223178f, -0.01157359f, 0.01300555f, 0.27542177f, -0.10867643f, -0.12029712f, -0.01659476f, -0.05184928f, 
    0.02367619f, 0.04898736f, -0.30072936f, -0.09432247f, 0.13105394f, 0.06073846f, -0.09662914f, -0.10522135f, 
    -0.06011675f, -0.08553880f, -0.01666737f, -0.11006941f, -0.23978058f, -0.10698028f, 0.12576216f, -0.32186452f, 
    -0.31345093f, 0.06075867f, -0.06075356f, -0.07428336f, 0.00525163f, -0.04606186f, -0.00763373f, 0.10753492f, 
    -0.38997898f, -0.29935980f, 0.14548798f, -0.12864564f, -0.00649198f, -0.03055643f, 0.01378239f, -0.14003730f, 
    -0.10548515f, -0.10970911f, -0.02650305f, -0.08559151f, -0.36758682f, 0.19637282f, -0.08308628f, 0.07302337f, 
    -0.02103003f, -0.03309173f, 0.06663719f, 0.08421769f, -0.02992702f, 0.04569406f, 0.13905530f, -0.14207998f, 
    0.30222055f, 0.05240970f, -0.11155456f, 0.46762103f, -0.23224193f, -0.15942718f, -0.11182173f, 0.03873694f, 
    -0.00964333f, 0.09257136f, 0.03856923f, -0.01695460f, -0.59447289f, -0.07882130f, 0.01766995f, -0.37145191f, 
    0.02809828f, -0.10520457f, -0.25570816f, -0.00783928f, 0.00304457f, -0.08992705f, -0.09675714f, -0.02224526f, 
    -0.70858067f, -0.07423715f, -0.09042758f, -0.29960307f, 0.11519467f, 0.12476041f, 0.16177450f, -0.12871806f, 
    0.06339895f, 0.08083904f, 0.04086431f, 0.02847264f, 0.31133598f, -0.13638835f, -0.07227483f, -0.04983560f, 
    -0.18916595f, -0.09713982f, -0.14427041f, 0.04970689f, 0.08571064f, -0.15730010f, 0.11026885f, -0.22271679f, 
    0.14052668f, -0.14949907f, -0.06006763f, -0.01583995f, -0.18564588f, 0.00350497f, -0.25399035f, 0.11273178f, 
    0.00921904f, -0.06315202f, 0.00657080f, -0.17039438f, -0.03861735f, 0.09997222f, -0.20184521f, 0.14082643f, 
    0.15100986f, 0.16700764f, 0.00150826f, -0.16695368f, -0.16338640f, -0.10244285f, 0.05441795f, -0.06157451f, 
    0.03724192f, 0.27662140f, -0.06719615f, -0.06283609f, -0.00953247f, -0.08502001f, 0.10092060f, 0.04592791f, 
    -0.13387300f, 0.04394716f, -0.05052864f, -0.15305357f, -0.08492514f, 0.17835736f, -0.08823131f, -0.07816572f, 
    -0.01676658f, 0.18417722f, 0.03588400f, -0.07695773f, 0.04888214f, 0.05681023f, -0.11689541f, -0.01523526f, 
    -0.37386614f, 0.08803225f, 0.10495166f, -0.14546891f, 0.09426209f, -0.00603756f, 0.08884198f, 0.05418373f, 
    -0.09999918f, 0.10945623f, -0.02362109f, -0.01085885f, -0.51978511f, 0.09159713f, 0.02703500f, 0.08801194f, 
    -0.10411749f, 0.08646944f, 0.05488292f, 0.05516042f, -0.03418904f, -0.10030196f, -0.06838926f, -0.00443036f, 
    0.31166685f, -0.22192793f, -0.21557572f, 0.09103536f, 0.01169397f, -0.02733639f, 0.10741527f, -0.04585942f, 
    -0.14679775f, -0.00447828f, -0.14072460f, -0.07753863f, 0.20210293f, -0.04796621f, -0.24519692f, -0.24769519f, 
    0.07796582f, 0.00865186f, -0.13095711f, 0.01568219f, 0.10630890f, 0.10134035f, 0.04156487f, -0.00841409f, 
    0.02475869f, -0.10950717f, 0.10744704f, 0.01920854f, 0.05210100f, -0.16654131f, -0.07778977f, 0.03196996f, 
    0.19405340f, 0.01059049f, 0.02221728f, 0.12916879f, 0.06754012f, 0.01036217f, 0.05272597f, -0.01066387f, 
    0.04889039f, 0.05378948f, 0.00147022f, 0.02121368f, -0.05183939f, 0.17382486f, 0.02356999f, -0.01476995f, 
    0.30258706f, -0.06402326f, 0.17414215f, 0.13806552f, -0.14028274f, 0.07660990f, -0.07023555f, 0.00016384f, 
    -0.01422826f, -0.09850151f, 0.02804440f, -0.09919700f, 0.12972973f, 0.13810557f, -0.00578350f, 0.28847015f, 
    -0.02454344f, -0.03568678f, -0.06796573f, 0.09865908f, 0.12626803f, 0.12075580f, -0.03670659f, 0.10731466f, 
    0.75978547f, -0.24244300f, -0.15420631f, 0.18417038f, 0.00533519f, 0.01441478f, -0.01141841f, 0.04541656f, 
    -0.04279045f, 0.08536366f, 0.19669187f, -0.01868371f, 0.14905253f, 0.06172908f, -0.09825058f, 0.35452083f, 
    0.04706537f, 0.09996072f, 0.03507984f, -0.10267562f, 0.00877868f, 0.04269337f, -0.00769707f, -0.19669342f, 
    -0.17766272f, 0.02020745f, -0.08358243f, -0.27091917f, -0.05874211f, -0.01161713f, -0.02668483f, 0.03857260f, 
    0.02237938f, -0.11114435f, 0.09894224f, -0.00731737f, 0.00102914f, -0.29380000f, 0.10593320f, 0.07366866f, 
    -0.18130319f, 0.01785755f, 0.01949343f, 0.13543637f, -0.01127887f, 0.15878324f, -0.02076198f, 0.05440843f, 
    0.36505428f, 0.09709229f, 0.10074246f, 0.07083219f, 0.04241052f, -0.01359856f, 0.01944258f, -0.04822473f, 
    0.14266232f, 0.00021029f, 0.12846094f, -0.07586505f, -0.15323074f, 0.47392333f, 0.29501089f, -0.01022062f, 
    -0.01971203f, 0.03991310f, -0.13082170f, -0.04752818f, -0.01996567f, 0.01462339f, 0.05526415f, 0.01726895f, 
    -0.37189111f, -0.54366410f, -0.31876823f, 0.22002666f, -0.12459930f, -0.06182541f, 0.02565552f, -0.17732930f, 
    0.06842662f, -0.08570447f, -0.07322298f, -0.01237620f, 0.22912507f, -0.14494951f, 0.03897704f, -0.10100519f, 
    -0.08361547f, -0.05578054f, -0.05535774f, -0.09974600f, -0.18274233f, 0.08059300f, -0.05931443f, 0.04339210f, 
    -0.12863052f, -0.32010013f, -0.37375408f, -0.23433299f, -0.01010846f, 0.04841154f, -0.05730646f, 0.05823866f, 
    -0.05136782f, -0.17986320f, 0.02992911f, -0.07710848f, 0.29751524f, 0.06640188f, 0.14870389f, 0.13980523f, 
    0.08764260f, -0.15143393f, 0.06362467f, 0.22145665f, 0.05418964f, -0.11783972f, 0.05826382f, -0.08584873f, 
    -0.04495393f, 0.11440121f, -0.07430849f, 0.03040514f, 0.05317454f, -0.08651284f, 0.06038956f, -0.02438533f, 
    -0.06459611f, 0.00907630f, 0.03119841f, -0.17322963f, -0.28117341f, -0.02953255f, -0.06718092f, -0.28657857f, 
    -0.18829399f, -0.13953814f, 0.03559774f, -0.11434715f, -0.04219185f, -0.24576980f, 0.12170392f, -0.04724709f, 
    0.07233098f, 0.05866507f, 0.20476715f, 0.02928635f, 0.11030302f, 0.10154824f, -0.04866981f, 0.10083401f, 
    0.03722681f, -0.03565409f, -0.01806475f, -0.09669910f, 0.22624794f, -0.00921915f, -0.14153934f, 0.14172319f, 
    0.00550161f, 0.10599265f, 0.03123005f, 0.13303289f, 0.02712359f, 0.06370289f, -0.06767631f, 0.00098638f, 
    0.27071401f, 0.13236634f, 0.06978722f, 0.01301487f, -0.07739254f, 0.08456714f, 0.00064227f, -0.07477121f, 
    0.00170095f, -0.05027551f, -0.06951131f, -0.00771080f, -0.26833320f, -0.31561953f, -0.28760675f, -0.14250608f, 
    -0.13137862f, 0.03544647f, 0.11454137f, 0.01132459f, -0.04136698f, 0.16122475f, -0.01237395f, 0.05455671f, 
    0.10650640f, -0.06969204f, 0.01382310f, -0.17401351f, -0.05432970f, -0.30307278f, -0.03535643f, -0.05393920f, 
    -0.06527576f, 0.08005485f, -0.05690774f, 0.00871996f, 0.36641499f, 0.22787665f, -0.03937956f, 0.00449142f, 
    -0.00831043f, -0.08264642f, -0.11058771f, -0.11152408f, 0.12685503f, 0.01298578f, -0.05377727f, -0.10267749f, 
    0.09664557f, 0.01846079f, 0.12845041f, -0.05263791f, -0.16745533f, -0.03770956f, 0.12515904f, 0.07967410f, 
    0.08476116f, -0.06521834f, 0.00883267f, 0.07844868f, 0.17806147f, 0.14541297f, 0.14158724f, -0.04978999f, 
    0.04908945f, -0.04696503f, 0.03627757f, -0.03034308f, 0.01781076f, -0.03821509f, -0.00628325f, 0.01756595f, 
    -0.13286982f, -0.13288780f, 0.10943735f, -0.03307272f, 0.13703203f, -0.08596104f, -0.08041412f, 0.07489505f, 
    0.04197507f, 0.12734689f, -0.01232985f, -0.10543165f, -0.05488886f, -0.20981395f, 0.01758865f, 0.27772096f, 
    0.04107002f, -0.00464998f, 0.02570106f, 0.01428330f, -0.12531105f, -0.05180966f, 0.10339414f, -0.31413823f, 
    0.15000926f, -0.59375298f, -0.44786134f, 0.00854713f, -0.12760347f, 0.05178320f, -0.09346832f, 0.02685246f, 
    0.03626112f, -0.04734690f, -0.19330874f, -0.04672535f, -0.33924443f, -0.04656246f, 0.03788501f, 0.18276554f, 
    0.03755876f, 0.07688786f, 0.00156927f, 0.00649264f, 0.03166031f, -0.02747793f, -0.05482361f, -0.05505455f, 
    -0.10189237f, -0.73982650f, -0.36775830f, 0.15513912f, -0.04434076f, -0.06877647f, 0.10035252f, 0.09886628f, 
    -0.13823359f, 0.06963713f, -0.05773484f, -0.13148770f, -0.13329618f, 0.13917227f, -0.05735037f, 0.29678631f, 
    -0.02219441f, -0.00790366f, 0.13112503f, -0.03917527f, 0.00499451f, -0.20380202f, 0.06396729f, 0.04212175f, 
    0.27335837f, 0.23818415f, 0.12992813f, 0.12034742f, 0.13504376f, -0.12375741f, 0.01160411f, -0.03657671f, 
    0.09847452f, -0.01611659f, -0.09712491f, -0.04482486f, -0.19805539f, 0.42112470f, 0.16370067f, 0.19326209f, 
    -0.03341649f, -0.03220165f, -0.14715254f, 0.05997832f, 0.05898075f, -0.07093325f, 0.04376705f, 0.12985684f, 
    -0.41841093f, -0.02324613f, -0.06910609f, 0.00072995f, -0.13731875f, 0.04093562f, 0.16162278f, -0.10892404f, 
    0.07324372f, 0.01263914f, -0.02918679f, -0.02057819f, -0.10613672f, -0.45061001f, -0.30101466f, 0.26143146f, 
    0.02048787f, -0.02359263f, 0.01040012f, 0.00736165f, -0.02585385f, -0.04698440f, -0.08801614f, 0.16582090f, 
    0.24072240f, 0.05448812f, -0.11096150f, -0.07192148f, -0.15957239f, -0.02841294f, 0.14253817f, -0.01280594f, 
    -0.10477547f, -0.11404751f, -0.00263344f, -0.05156166f, -0.01862443f, 0.06235928f, -0.01298058f, -0.18044527f, 
    -0.12212247f, -0.09692112f, 0.02138364f, -0.01694601f, -0.08446544f, 0.08376358f, 0.04403954f, 0.08335984f, 
    0.06075953f, 0.39525408f, -0.08420111f, -0.03757928f, -0.13833207f, -0.09286755f, -0.03167289f, 0.08955336f, 
    -0.03025227f, 0.09387060f, -0.06970495f, 0.12397251f, -0.24877508f, 0.01477067f, -0.17377490f, 0.17312142f, 
    -0.02564831f, 0.04489869f, 0.03821100f, 0.01249803f, 0.17224702f, -0.18322434f, 0.01230336f, -0.10061278f, 
    0.45745853f, -0.11759301f, 0.09366271f, 0.12849234f, 0.03308951f, 0.01347947f, 0.06282001f, 0.06144917f, 
    0.06958825f, 0.05224460f, 0.08387647f, 0.06805595f, -0.11712893f, -0.11933163f, -0.05535550f, 0.06313449f, 
    -0.23517171f, 0.20823371f, 0.10931245f, 0.08458186f, -0.03261292f, 0.06203181f, -0.00464459f, 0.06031473f, 
    0.21036050f, -0.26327884f, -0.11830960f, -0.03559221f, 0.03998916f, 0.10966688f, 0.08080915f, -0.04422877f, 
    -0.09104118f, 0.04849118f, 0.07079560f, 0.03699344f, -0.15220703f, 0.20141256f, 0.19583248f, 0.06669704f, 
    -0.10180409f, -0.02907999f, -0.08187046f, -0.06925157f, 0.07855605f, -0.00970162f, -0.05023257f, 0.05654765f, 
    0.21495916f, 0.01047887f, -0.06254593f, 0.28390658f, -0.11833276f, -0.04444939f, -0.00363417f, 0.14681102f, 
    0.09366839f, 0.00163936f, -0.03703852f, -0.00765729f, -0.76574689f, 0.24986924f, 0.09795608f, 0.11935978f, 
    0.14743626f, 0.06049983f, -0.00666718f, 0.02924858f, -0.09324104f, 0.00060181f, 0.08999387f, -0.10018577f, 
    0.44502670f, -0.08066374f, -0.20915404f, 0.09510151f, -0.06947460f, 0.02145154f, 0.00334481f, 0.05372954f, 
    -0.00983550f, -0.03041935f, -0.00688863f, 0.03335406f, 0.39389858f, 0.69384801f, -0.22562170f, -0.43324184f, 
    -0.00881477f, -0.09658016f, 0.11925489f, -0.12205034f, -0.06528803f, 0.08071795f, -0.04475295f, 0.07295262f, 
    -0.57640147f, -0.20229732f, -0.10147767f, -0.08204189f, 0.11519808f, 0.02828177f, 0.02427968f, 0.14091913f, 
    0.07243265f, -0.19184321f, -0.12079946f, 0.08495066f, -0.25708663f, 0.04627672f, 0.07918640f, 0.33021912f, 
    -0.04347438f, 0.07369821f, 0.05091957f, 0.13733755f, -0.12375017f, 0.15654948f, 0.06775861f, 0.15483107f, 
    -0.33209255f, 0.07352214f, 0.27831018f, 0.19741724f, -0.04233203f, 0.02557039f, -0.02003743f, -0.11077093f, 
    0.08782035f, -0.02039670f, 0.03456973f, 0.03233379f, 0.17511779f, 0.06666186f, -0.04273765f, -0.34530774f, 
    0.04046930f, 0.14687693f, 0.17286848f, 0.03431175f, -0.07864127f, -0.07386675f, -0.04819018f, 0.21065879f, 
    -0.20896327f, -0.07161500f, 0.01542909f, 0.24523181f, 0.03834892f, -0.11330038f, 0.02798421f, 0.06925321f, 
    0.00110523f, -0.13025333f, -0.11844581f, -0.12946537f, -0.39131254f, -0.07426325f, 0.14937758f, -0.09265628f, 
    0.01927979f, 0.15170065f, 0.08345967f, -0.02648303f, 0.12806493f, 0.08296324f, 0.11170864f, 0.15885033f, 
    -0.26359487f, -0.03870917f, -0.03671706f, 0.27298656f, -0.02108588f, -0.04515631f, 0.07735905f, 0.15452021f, 
    0.08332659f, -0.00879894f, 0.08790147f, -0.01761479f, -0.00511658f, -0.04588470f, 0.05281060f, 0.16887614f, 
    -0.07618208f, 0.10626718f, 0.05554336f, 0.06194594f, -0.00370105f, -0.00526549f, 0.04293317f, 0.06675938f, 
    0.12532815f, -0.07955103f, -0.11561844f, 0.07011981f, -0.16347398f, -0.02520509f, 0.05285171f, 0.15451901f, 
    -0.04451010f, 0.01616209f, 0.00105357f, 0.06499968f, -0.49068180f, 0.13254000f, -0.09279152f, -0.26078063f, 
    -0.03582453f, 0.01153359f, -0.03930881f, 0.06074166f, -0.27708808f, -0.01302415f, 0.03369649f, -0.03416561f, 
    -0.03980274f, -0.06393730f, 0.15652969f, -0.22907503f, -0.01424599f, -0.09921015f, -0.13097209f, 0.02373947f, 
    0.01274159f, 0.10579565f, -0.10306834f, 0.03505689f, -0.18597277f, -0.12538327f, 0.13551594f, 0.01642777f, 
    -0.05539287f, 0.04412932f, -0.00669412f, -0.06121381f, 0.07069800f, -0.14591897f, 0.01658255f, -0.15178618f, 
    -0.07263912f, -0.31661382f, -0.17590526f, 0.03112657f, -0.19551092f, 0.11266103f, 0.00123500f, -0.21813512f, 
    -0.07893136f, 0.03416850f, -0.07295305f, -0.13631199f, -0.63153452f, -0.34032446f, 0.35715044f, -0.08489936f, 
    -0.10113364f, 0.09297431f, -0.15575626f, -0.02862184f, 0.12553148f, -0.13983391f, -0.18542820f, 0.04536994f, 
    -0.20784293f, 0.06816608f, 0.23517373f, -0.07629178f, -0.16980997f, 0.30697885f, -0.10001093f, 0.03819652f, 
    0.10506850f, 0.05090026f, -0.04076384f, 0.02008465f, 0.17634276f, 0.06891437f, -0.40848187f, -0.08515774f, 
    0.15760437f, 0.28408852f, 0.00169384f, -0.12897028f, 0.04438187f, -0.08156438f, 0.08085949f, -0.06119660f, 
    0.51304245f, 0.18173279f, -0.33628353f, -0.30762607f, -0.12297454f, -0.22271231f, -0.06043921f, -0.03187231f, 
    -0.13103479f, -0.16110905f, 0.02170522f, -0.16153096f, -0.05513848f, -0.38017482f, 0.24793920f, 0.09443989f, 
    0.15211901f, -0.03969060f, 0.02088078f, 0.00276054f, -0.01286386f, 0.13525844f, 0.00949041f, 0.07403236f, 
    0.17662625f, -0.10930581f, -0.34020948f, 0.09579223f, -0.14404753f, -0.07482650f, 0.11729387f, -0.03252373f, 
    -0.07478046f, -0.03388135f, -0.03230002f, 0.05196749f, -0.09870210f, 0.17252092f, -0.00181259f, 0.11170950f, 
    -0.01024527f, 0.11756332f, -0.09878816f, 0.14337759f, 0.11146548f, -0.20803873f, -0.08502731f, 0.00944602f, 
    -0.54309738f, -0.01824939f, -0.08552311f, -0.08697776f, 0.03617655f, 0.07219359f, -0.00600090f, -0.04014866f, 
    0.10791712f, -0.06177456f, -0.07013275f, -0.05110881f, -0.43623111f, -0.16458479f, -0.12716012f, 0.44265258f, 
    0.08321974f, -0.18418488f, -0.09985049f, -0.04774140f, -0.16293053f, 0.11073329f, -0.04297941f, 0.01776377f, 
    -0.17159736f, -0.17099807f, 0.19674683f, -0.05254095f, 0.16511951f, 0.12218714f, -0.03864979f, 0.02526765f, 
    -0.01403575f, -0.08963702f, -0.23971090f, -0.02168742f, -0.20957756f, -0.06202852f, -0.07629199f, -0.51557130f, 
    -0.10924457f, 0.03940276f, -0.15286082f, 0.05853562f, -0.02586605f, 0.27846825f, 0.24658240f, 0.05106488f, 
    -0.59884799f, -0.34025007f, -0.18793084f, -0.03945876f, 0.00712361f, -0.03944487f, -0.25422996f, -0.49707186f, 
    0.09047063f, -0.09038106f, 0.12797587f, 0.05234915f, -0.07515081f, 0.05537825f, -0.14940010f, -0.03728081f, 
    0.04981197f, -0.05403956f, -0.09269781f, -0.12752578f, -0.06953888f, 0.03312300f, -0.03063362f, 0.04352565f, 
    -0.21480292f, -0.15094714f, 0.06781458f, 0.31005615f, -0.09591337f, -0.06657320f, 0.33819124f, 0.02783745f, 
    0.02631590f, -0.11322345f, -0.13794605f, -0.07829852f, -0.02042923f, -0.12887774f, 0.01967103f, 0.17536071f, 
    0.01773270f, -0.07169414f, 0.10685208f, 0.27578384f, 0.03471488f, 0.00097707f, -0.01766131f, -0.06223354f, 
    -0.00079868f, -0.00893850f, 0.14561960f, -0.07970260f, 0.10364922f, -0.00150107f, 0.09474938f, -0.08764973f, 
    0.16701476f, 0.05256929f, -0.09880737f, 0.24694209f, -0.53627253f, -0.06390570f, -0.38641518f, -0.08320700f, 
    0.05703442f, 0.03196009f, -0.10263344f, 0.14671429f, 0.00999680f, 0.03838988f, 0.16155334f, -0.22816466f, 
    0.10428203f, 0.13468981f, 0.18023527f, -0.33949724f, 0.03831559f, -0.03552901f, -0.08945179f, -0.14662308f, 
    -0.03450439f, 0.02004140f, -0.07495661f, 0.05931889f, -0.05603927f, -0.49214128f, 0.36349678f, 0.28267232f, 
    0.01675490f, -0.10174066f, -0.00859054f, -0.00086511f, 0.09849516f, 0.05513335f, -0.11010470f, -0.11999711f, 
    -0.94580942f, 0.04916536f, -0.14290212f, -0.11393078f, -0.04510931f, 0.04916047f, 0.10948017f, -0.08865502f, 
    -0.01549595f, -0.07413128f, -0.05067237f, -0.07318752f, -0.03242508f, 0.23338322f, -0.26654524f, -0.17794065f, 
    0.12632722f, 0.02034790f, -0.11397150f, -0.36373380f, 0.04054572f, -0.07528248f, -0.01483322f, -0.08470628f, 
    0.12684722f, -0.02439229f, -0.03563920f, 0.22601588f, -0.08077190f, -0.06193863f, 0.11875648f, -0.04015696f, 
    -0.25127992f, 0.12265702f, 0.15240724f, 0.26659766f, -0.15948218f, -0.21851249f, 0.08392855f, 0.02538258f, 
    0.10078411f, 0.03743460f, -0.09885464f, 0.07420295f, -0.02704297f, 0.05032022f, 0.14067362f, -0.26378551f, 
    -0.22064140f, -0.00244671f, -0.21678986f, -0.01882946f, 0.04326319f, 0.02109683f, 0.10321081f, 0.07899198f, 
    0.18193282f, 0.09669704f, 0.00794670f, 0.17778912f, -0.00849108f, -0.00477948f, 0.16050234f, 0.10237932f, 
    0.03520790f, -0.26710513f, -0.18147501f, -0.19890243f, -0.01473770f, -0.09782707f, -0.02843131f, -0.05124734f, 
    -0.49968576f, -0.32564828f, -0.19472767f, -0.18740280f, 0.11264818f, 0.17506282f, 0.04588713f, -0.12917867f, 
    0.02687913f, -0.04544375f, -0.09310257f, 0.25624806f, -0.20273207f, -0.11346548f, 0.01186606f, 0.20121965f, 
    0.02202499f, 0.08007855f, -0.06806767f, 0.07808467f, 0.15912764f, 0.06979303f, 0.16621186f, 0.05180114f, 
    0.11063042f, 0.01744509f, 0.22850417f, 0.19143067f, 0.01894304f, -0.10515577f, -0.06224866f, -0.07271872f, 
    0.03630203f, -0.02737908f, -0.00876887f, -0.15609226f, -0.26799905f, 0.05023108f, -0.01250853f, -0.32243574f, 
    0.12804626f, 0.10012275f, 0.13776317f, 0.14406233f, -0.27975780f, 0.06872222f, 0.12074024f, -0.18065363f, 
    0.01074558f, 0.06835131f, 0.33335298f, 0.11992685f, -0.07133897f, 0.02134857f, 0.34929103f, -0.02910939f, 
    0.11297217f, -0.09148744f, -0.04338584f, 0.04253528f, 0.10799976f, 0.02059138f, -0.01155379f, 0.04603813f, 
    -0.05695930f, -0.02421267f, 0.01801241f, 0.08129474f, -0.09655110f, 0.18367191f, 0.01864356f, 0.31224224f, 
    0.07316606f, 0.20205463f, 0.08552593f, -0.03883020f, -0.07409268f, -0.00585966f, 0.06185834f, -0.00722505f, 
    0.13485371f, -0.24648666f, 0.09323364f, -0.03180088f, 0.14648934f, 0.12629710f, 0.07463194f, 0.15697278f, 
    0.02128835f, -0.12925534f, 0.08462367f, 0.16463524f, -0.13409935f, 0.05848690f, 0.01102387f, 0.10681026f, 
    0.07234055f, 0.09582987f, 0.05810165f, 0.28019080f, -0.09885454f, 0.14140604f, 0.08777889f, -0.04532062f, 
    -0.00988815f, -0.29181996f, 0.01126198f, -0.01080080f, -0.00630863f, 0.13185601f, 0.29664201f, -0.05501536f, 
    -0.02281565f, -0.01628337f, -0.07312876f, -0.20046681f, -0.22921778f, 0.02158181f, -0.26058012f, -0.16699605f, 
    -0.09599420f, -0.29574102f, 0.23785439f, 0.36323240f, -0.09489112f, 0.00050691f, 0.02591633f, -0.10014160f, 
    -0.04014392f, -0.01951968f, -0.04210452f, 0.18960142f, 0.10054369f, -0.02675385f, -0.17115530f, 0.42944235f, 
    0.19860879f, -0.13505524f, 0.14983755f, -0.03951716f, -0.02803495f, 0.02120974f, 0.02684313f, 0.13991053f, 
    -0.01893970f, 0.40287316f, 0.25300783f, -0.35501221f, -0.02244550f, 0.09533256f, 0.11654897f, 0.02717280f, 
    0.21859822f, -0.17849661f, -0.05153018f, -0.31716529f, -0.04866135f, -0.16958532f, 0.08247606f, -0.01083041f, 
    0.02150363f, 0.02059582f, 0.04702283f, 0.01413565f, -0.01644801f, -0.00674157f, 0.20285542f, 0.06152560f, 
    -0.71163386f, 0.23398867f, 0.05365966f, -0.25328511f, 0.19828925f, -0.07913440f, -0.03953345f, -0.01653686f, 
    -0.03753357f, 0.14911534f, 0.10488750f, 0.05744821f, 0.35490286f, -0.07903881f, -0.33783811f, -0.14709669f, 
    0.10690386f, 0.18997280f, 0.09995903f, -0.04658603f, -0.05732330f, -0.26004615f, 0.04368165f, -0.37760776f, 
    0.05045828f, 0.02698414f, 0.00623679f, -0.24217989f, 0.01089200f, 0.03165749f, 0.08402952f, 0.12463657f, 
    0.01425830f, 0.14437737f, 0.20153250f, 0.12499011f, 0.09195336f, -0.14681567f, -0.05756376f, -0.33026791f, 
    0.02094417f, 0.05146027f, 0.11518321f, -0.02902754f, 0.08811942f, -0.15380248f, -0.13750930f, -0.09462497f, 
    -0.14090943f, 0.08500826f, -0.11955599f, 0.09329029f, -0.17544948f, 0.11494548f, -0.03226721f, 0.15288396f, 
    -0.02203314f, 0.18320748f, 0.00838350f, -0.00126840f, 0.19090472f, -0.07539874f, -0.18107414f, 0.57171845f, 
    0.24358404f, 0.05455577f, 0.07788855f, 0.01982547f, 0.06405696f, -0.09218201f, 0.10621928f, 0.01091776f, 
    -0.30329236f, -0.03228404f, -0.06570928f, -0.02745628f, 0.03241246f, 0.00533006f, -0.19410239f, -0.08830689f, 
    -0.10745923f, 0.02679713f, 0.21437936f, -0.14780560f, 0.13517830f, -0.26708445f, -0.07418355f, -0.09467132f, 
    0.22765277f, 0.10239013f, 0.12088647f, -0.09869391f, -0.24920899f, 0.21717060f, 0.03600362f, 0.07899007f, 
    -0.07179983f, 0.23079297f, 0.30519095f, -0.32814112f, -0.26688021f, 0.01512226f, 0.01720366f, 0.08761580f, 
    -0.07001703f, 0.08993609f, 0.08349899f, -0.03225335f, 0.07745200f, -0.24278359f, 0.23324330f, -0.29388586f, 
    -0.02795049f, 0.04859105f, 0.12943505f, -0.17432664f, 0.01947534f, 0.00194728f, 0.06223278f, 0.29142237f, 
    -0.61015427f, 0.20273240f, 0.12590888f, 0.03185751f, -0.10069316f, -0.01922068f, 0.01941682f, 0.18484543f, 
    -0.01144765f, -0.07704371f, -0.06303997f, -0.04170613f, 0.42266038f, -0.33328059f, -0.46708244f, 0.15992972f, 
    -0.08620045f, 0.10530112f, -0.03544274f, 0.17061807f, 0.04630879f, -0.07389354f, 0.01847633f, 0.11560956f, 
    0.52381974f, -0.44509470f, 0.15514112f, -0.08482276f, -0.04176832f, 0.01454135f, -0.06723528f, -0.14896379f, 
    -0.06811783f, 0.06092034f, 0.19878948f, 0.03691737f, -0.24601521f, -0.44829360f, -0.16137151f, -0.15549503f, 
    -0.00571788f, 0.01129654f, -0.08424554f, 0.12878777f, 0.06417813f, 0.10235289f, 0.07353743f, 0.14591974f, 
    0.14243071f, 0.10781565f, -0.03213431f, -0.16117847f, 0.00386989f, 0.03250226f, -0.00190516f, 0.16411841f, 
    0.04022262f, -0.14667341f, -0.03774010f, -0.18372113f, 0.14489685f, 0.02474418f, 0.01301637f, -0.03388770f, 
    -0.03079492f, 0.01302020f, 0.04089963f, 0.01850549f, 0.04581270f, 0.03833299f, 0.28563032f, 0.02437180f, 
    0.02241543f, -0.19314569f, -0.27842835f, -0.07791909f, 0.01424131f, 0.12331274f, -0.05484511f, 0.05148701f, 
    -0.10910861f, -0.06885101f, -0.08773677f, -0.10374591f, -0.74108243f, 0.20967288f, 0.08666707f, 0.29474217f, 
    -0.05650967f, 0.06642139f, 0.15075074f, 0.10953854f, -0.02596423f, 0.05409105f, -0.13456625f, 0.01144059f, 
    -0.40673363f, -0.25372502f, -0.22958617f, -0.22190784f, 0.03697740f, 0.11390692f, -0.04922922f, -0.06789022f, 
    0.12964796f, -0.09139719f, 0.04493218f, -0.02047642f, 0.18351907f, -0.08254523f, -0.21493085f, 0.00327754f, 
    -0.06550195f, -0.03785629f, -0.15616523f, -0.07683343f, -0.17241232f, -0.00949585f, 0.01776109f, 0.04772505f, 
    -0.11308580f, -0.06751881f, -0.32244283f, 0.12626149f, 0.04576584f, 0.08281250f, -0.03024733f, 0.02566264f, 
    0.11849885f, -0.04309431f, -0.03492341f, 0.08172532f, 0.19954599f, -0.03139363f, 0.05694415f, -0.00224867f, 
    0.00446927f, 0.07577080f, -0.00095189f, -0.23641145f, 0.27788314f, 0.05943562f, 0.00754379f, -0.01135214f, 
    0.14436865f, -0.13552679f, -0.03170644f, -0.15588340f, -0.04062955f, 0.01618403f, 0.20455420f, 0.03325853f, 
    0.08179299f, 0.09177191f, 0.05747529f, -0.06090783f, 0.06586127f, 0.29615870f, 0.16159786f, -0.35871923f, 
    -0.00409311f, 0.10498243f, 0.06733687f, 0.02669073f, 0.01951166f, -0.05220599f, -0.14872088f, -0.10126770f, 
    -0.25937659f, 0.25996605f, 0.26791883f, 0.24323899f, 0.05449764f, 0.12446813f, -0.10482772f, 0.01224145f, 
    -0.09605502f, 0.13801423f, -0.15158726f, 0.09230420f, 0.10916062f, 0.05489582f, -0.01678677f, -0.21201859f, 
    0.15526043f, -0.08196513f, 0.02254878f, 0.03255810f, 0.07806379f, -0.11667212f, -0.14600372f, -0.04856735f, 
    -0.24491468f, 0.11544241f, -0.21464895f, 0.19767584f, 0.03899388f, 0.00889361f, -0.06530439f, 0.09378844f, 
    -0.03196507f, 0.18013854f, -0.07692615f, -0.03469741f, -0.11995949f, -0.23548624f, -0.21589980f, -0.03320707f, 
    -0.10956499f, -0.04668466f, 0.05694028f, -0.04122587f, 0.25971657f, 0.04440732f, 0.05378412f, 0.21221186f, 
    -0.06011636f, -0.02607912f, -0.12444790f, 0.23013529f, -0.02738677f, 0.05218149f, 0.09369592f, -0.00864318f, 
    -0.06038452f, -0.13489124f, 0.02619735f, -0.02983224f, -0.01555163f, -0.11453912f, -0.42799294f, -0.21065107f, 
    -0.02382510f, 0.14053726f, -0.06095422f, -0.25443012f, 0.06080097f, -0.21268651f, -0.16574559f, 0.14952695f, 
    -0.14242865f, -0.26049605f, 0.15146568f, -0.10273181f, 0.02432371f, -0.03640948f, -0.13311969f, 0.09495638f, 
    -0.16530858f, -0.09213299f, -0.08250069f, 0.24857061f, -0.07002083f, 0.15388647f, -0.00872239f, -0.24640845f, 
    -0.11782863f, -0.03114131f, 0.05557955f, -0.16004354f, -0.01264223f, 0.00266166f, -0.03578443f, -0.03498663f, 
    0.21554801f, -0.38620418f, 0.11992627f, -0.16507395f, -0.07474253f, -0.00337641f, 0.21730684f, 0.03449843f, 
    0.01041491f, -0.12528020f, -0.15806156f, -0.18996599f, 0.04907673f, 0.08135783f, -0.11683888f, -0.24478588f, 
    -0.31846672f, -0.02361524f, 0.03444390f, -0.17200312f, -0.11817155f, 0.22659342f, -0.02457321f, 0.41271237f, 
    -0.36971468f, 0.17228504f, -0.06543694f, -0.16955517f, 0.03678581f, -0.04004852f, 0.08911590f, -0.13115744f, 
    -0.14629380f, -0.01640501f, 0.00813276f, -0.00052426f, 0.05372611f, 0.09323189f, -0.01953009f, -0.24552210f, 
    -0.08757014f, -0.09856892f, -0.11646295f, -0.09292455f, -0.07958811f, -0.14730112f, -0.12116807f, -0.11782964f, 
    0.04112774f, 0.23991217f, 0.05645302f, 0.27585664f, 0.18428934f, 0.06126437f, -0.00097238f, -0.10263930f, 
    0.02667542f, -0.06745618f, -0.03691806f, -0.09148157f, 0.12806599f, 0.23932055f, -0.27313572f, 0.13585307f, 
    -0.02863257f, -0.01634688f, -0.09883162f, 0.08671540f, 0.00798330f, 0.05377510f, 0.03197836f, -0.11394209f, 
    0.07307944f, 0.05750820f, -0.05658447f, 0.21981098f, -0.12520720f, 0.04391408f, 0.00127614f, -0.03234739f, 
    -0.14223269f, 0.14554903f, -0.02990259f, -0.07143957f, 0.32677701f, -0.20875452f, 0.18055093f, 0.05290221f, 
    0.21859497f, -0.12945043f, 0.00840700f, -0.08294440f, -0.02534842f, 0.08288492f, 0.06442600f, -0.01070500f, 
    -0.15986392f, 0.20244412f, -0.22948398f, -0.22038309f, 0.09986840f, 0.08804812f, -0.05387605f, -0.09404220f, 
    -0.13325165f, -0.02653151f, -0.02496927f, -0.10017083f, 0.18630762f, -0.01047054f, 0.20635624f, 0.05572366f, 
    -0.04442964f, 0.02351640f, -0.03543317f, -0.06983885f, 0.00527558f, 0.12801804f, -0.12092735f, 0.02568677f, 
    -0.27722612f, 0.35829413f, 0.01747363f, -0.02714123f, -0.07522033f, 0.02322576f, -0.02304820f, -0.05581608f, 
    -0.01735936f, -0.04058233f, -0.12362991f, -0.11720438f, 0.06096243f, 0.18359888f, 0.03980610f, 0.06337016f, 
    -0.04454324f, -0.02650574f, 0.02300033f, -0.03125767f, -0.07012814f, -0.01937289f, 0.03943827f, 0.00545347f, 
    -0.10040905f, 0.02186675f, 0.24900118f, 0.05493644f, 0.13958731f, 0.03073212f, -0.05269672f, -0.07984669f, 
    -0.14467846f, 0.02353518f, 0.09050730f, 0.01222451f, -0.27015918f, 0.14455731f, 0.13637710f, 0.05089238f, 
    0.01351739f, 0.03801037f, 0.08314094f, -0.10260183f, -0.06297878f, 0.07199752f, 0.04735405f, -0.04081632f, 
    -0.04527586f, -0.15565114f, 0.09761655f, 0.15032773f, -0.11370519f, -0.18065590f, -0.08770966f, 0.01504606f, 
    -0.08582164f, 0.00026910f, 0.04418004f, -0.02897901f, 0.21618174f, 0.10117002f, -0.05867079f, 0.32140732f, 
    0.11513507f, 0.03329184f, -0.03762152f, -0.01712413f, -0.15896100f, -0.13149819f, -0.00096045f, 0.02500745f, 
    -0.14267527f, 0.22735453f, -0.26260346f, 0.15301129f, -0.02411296f, -0.07670569f, -0.19786924f, -0.02066597f, 
    0.06741937f, -0.00029321f, -0.03361254f, -0.15333208f, 0.14028162f, 0.01868803f, -0.27680644f, -0.18138486f, 
    -0.15394872f, 0.02592784f, -0.07513854f, 0.04340078f, 0.00413153f, 0.02688515f, -0.05910334f, -0.15503687f, 
    0.20748152f, 0.05727367f, 0.27581018f, 0.07811715f, 0.20747815f, 0.09961177f, 0.04808532f, -0.05232902f, 
    -0.05639926f, 0.13142905f, -0.01210683f, -0.10815207f, -0.11802861f, 0.14244437f, 0.07393546f, 0.26890406f, 
    -0.09215915f, -0.04460421f, -0.09108348f, -0.03857789f, -0.13752688f, 0.03502198f, -0.05610859f, -0.02267365f, 
    0.00714251f, 0.13707699f, -0.13811961f, 0.23040301f, -0.10033248f, -0.02720503f, -0.06364676f, -0.01918791f, 
    -0.13516846f, -0.00417306f, 0.00723831f, 0.00362258f, 0.18625021f, -0.20896144f, 0.18562704f, -0.12466749f, 
    -0.01143900f, -0.06372210f, 0.04898555f, -0.04415655f, 0.07241729f, 0.11858795f, -0.06983328f, -0.04792649f, 
    -0.22502217f, -0.22602226f, -0.15372467f, -0.11319298f, -0.07723165f, -0.02998037f, -0.10172137f, -0.09495394f, 
    -0.04769643f, 0.06533867f, 0.02021733f, -0.10838278f, -0.40414792f, -0.21528600f, -0.12596586f, 0.01330377f, 
    -0.09269986f, 0.04673624f, -0.00780157f, -0.09161760f, -0.12021434f, -0.01223336f, 0.00043000f, -0.04872821f, 
    -0.07864960f, 0.24761938f, -0.14556861f, -0.26313356f, -0.11292635f, -0.01610664f, -0.16247608f, 0.01633731f, 
    -0.05690007f, 0.01566733f, 0.04703991f, -0.13706152f, 0.08872465f, -0.43851411f, -0.04044636f, -0.01506318f, 
    -0.13494530f, -0.06396522f, -0.07006594f, -0.12262377f, -0.14015009f, 0.00846039f, 0.09424519f, -0.00784422f, 
    -0.36430046f, -0.09498961f, -0.15182605f, -0.30979690f, 0.06724630f, -0.09498074f, 0.03609147f, -0.03189686f, 
    -0.11113452f, 0.08847059f, 0.04734313f, -0.01262859f, 0.51943827f, 0.19131170f, 0.06464911f, 0.09858521f, 
    0.03493615f, 0.03674377f, -0.00706791f, 0.04656694f, -0.03601362f, -0.05874206f, -0.07253541f, -0.00984952f, 
    0.00271297f, 0.01131050f, 0.15705830f, 0.24002537f, 0.12269943f, -0.12007947f, -0.14814451f, -0.08183046f, 
    0.01919497f, -0.11639460f, -0.11246406f, -0.14242837f, 0.12973155f, 0.07050890f, 0.24068765f, 0.10935630f, 
    0.01395202f, 0.01778765f, -0.07556031f, -0.07318538f, -0.02205964f, 0.04520288f, -0.19906093f, -0.15751991f, 
    -0.21922070f, -0.09074081f, -0.00573051f, -0.10600504f, -0.09910972f, 0.02460885f, -0.12861016f, -0.09853806f, 
    -0.04673748f, -0.05221782f, 0.04856948f, 0.07592700f, -0.21580750f, 0.21494353f, -0.21982357f, -0.14869042f, 
    -0.02720885f, -0.00639944f, 0.03784042f, -0.13822229f, -0.17233261f, -0.00155163f, -0.12721467f, 0.03764265f, 
    0.00878094f, -0.03933394f, 0.05122041f, -0.08285186f, -0.05268413f, -0.02571801f, -0.09099035f, 0.04188284f, 
    -0.03684593f, 0.08701374f, -0.03551096f, -0.09291201f, 0.15657817f, 0.32521245f, 0.19901717f, 0.33881912f, 
    0.18019649f, -0.03151419f, 0.10633444f, 0.02442911f, -0.14377680f, 0.05760778f, -0.00501443f, -0.17416291f, 
    0.04301541f, -0.38306174f, 0.07150728f, 0.30750230f, 0.03086250f, -0.14402018f, -0.15166202f, -0.03625162f, 
    0.10788978f, -0.25650334f, 0.19571565f, -0.08830336f, -0.44126940f, -0.00049346f, 0.06566467f, 0.07659882f, 
    -0.19091862f, -0.13306797f, 0.13635729f, 0.03596775f, 0.08338238f, 0.24633451f, -0.06060028f, -0.13015121f, 
    0.04041116f, -0.22233917f, 0.24021390f, -0.11069945f, 0.03591540f, -0.10493474f, 0.06987844f, -0.14786543f, 
    -0.06875406f, 0.03567572f, 0.04984106f, 0.09307890f, 0.03926212f, 0.37947327f, -0.15409385f, -0.00858646f, 
    0.05573445f, 0.02546081f, -0.27956620f, 0.07100965f, 0.12244283f, -0.15025277f, 0.02054058f, 0.04513107f, 
    -0.16198047f, 0.08624551f, -0.02069794f, -0.16080908f, 0.03511133f, 0.04037287f, 0.12014544f, 0.09001329f, 
    0.02478751f, -0.13566847f, -0.02215779f, 0.03347973f, -0.21762730f, -0.11217918f, -0.32222468f, -0.03947800f, 
    -0.12652349f, -0.05338705f, 0.02489944f, -0.17218256f, 0.15217124f, 0.12429222f, 0.06456970f, -0.00912837f, 
    0.10761713f, 0.06743661f, 0.15852298f, 0.19511975f, 0.14364345f, 0.05090603f, -0.07632276f, -0.07666273f, 
    -0.00211761f, -0.03278141f, -0.02665189f, -0.20686336f, 0.00784907f, -0.05542307f, 0.30500472f, 0.03615410f, 
    0.01881520f, 0.07166728f, -0.16233447f, 0.18602166f, 0.07527017f, -0.13381773f, -0.07360131f, -0.02693300f, 
    0.16677356f, -0.03871774f, 0.12108600f, 0.17307842f, 0.03800508f, 0.04179679f, -0.10738900f, -0.11592086f, 
    0.00790475f, 0.09924862f, -0.02297679f, 0.05756053f, 0.00250563f, 0.16751254f, -0.14299324f, -0.00969971f, 
    0.08609781f, -0.13058603f, -0.15195599f, 0.08100834f, 0.00374115f, 0.01026265f, -0.07936101f, 0.06089508f, 
    -0.01103874f, -0.28186211f, 0.32533389f, -0.04560043f, -0.04103144f, -0.17281371f, 0.07679564f, -0.17193826f, 
    -0.08423737f, -0.02338521f, -0.17153670f, -0.14676487f, -0.00027353f, 0.03583629f, 0.26689538f, 0.17737502f, 
    -0.11455393f, -0.02529210f, -0.14440976f, -0.12409686f, -0.05302271f, -0.03690261f, 0.03250805f, -0.25454658f, 
    -0.20074226f, -0.27332503f, -0.14349815f, -0.22857632f, -0.00178222f, -0.08150195f, -0.05490199f, -0.03681496f, 
    0.18103608f, 0.09080435f, -0.05255257f, 0.02595392f, -0.09020467f, -0.01764107f, -0.07809073f, -0.38322639f, 
    0.02502651f, -0.25261939f, 0.01161706f, 0.16458517f, 0.10762986f, 0.05506467f, -0.09084969f, -0.11697400f, 
    -0.06594197f, 0.29595581f, -0.04663623f, -0.04793575f, -0.18669547f, -0.01575620f, 0.00817904f, 0.07976799f, 
    0.05751323f, -0.06347697f, -0.00603458f, 0.17306276f, 0.16031897f, 0.14643382f, -0.11984760f, -0.13672231f, 
    -0.01442404f, 0.10376554f, -0.08011572f, -0.15032074f, 0.02743302f, 0.18271846f, -0.23299760f, 0.08423731f, 
    -0.27626258f, -0.01102639f, 0.29657784f, -0.06878765f, -0.20042989f, 0.08130566f, 0.07443226f, -0.27924305f, 
    -0.00500935f, -0.12802237f, 0.03066253f, 0.11141255f, -0.31003824f, 0.27183700f, 0.09449619f, -0.29549393f, 
    -0.00326989f, -0.08748880f, -0.01490336f, 0.02888327f, 0.08898367f, 0.05839829f, 0.11822879f, -0.03651433f, 
    -0.25507626f, 0.08580216f, -0.38389477f, -0.25895655f, -0.04345175f, -0.03225500f, -0.20586084f, 0.00798655f, 
    0.05168195f, 0.03601966f, -0.07653742f, -0.15627952f, -0.32187286f, -0.07966070f, -0.05921737f, -0.11140923f, 
    0.10480583f, -0.09722392f, 0.14337957f, -0.04055336f, 0.09932914f, 0.06263617f, -0.03323971f, 0.04080889f, 
    -0.20591971f, -0.18730345f, -0.13662818f, -0.11661585f, -0.08678380f, -0.05205589f, 0.06987428f, -0.25797263f, 
    0.00970307f, -0.10191160f, -0.15586413f, 0.14445236f, -0.29027498f, -0.31907380f, 0.12657942f, 0.25650015f, 
    0.19544289f, -0.00785025f, -0.10731457f, -0.01248175f, 0.01234556f, 0.18130681f, -0.08978001f, 0.11853392f, 
    0.13761932f, -0.04286694f, -0.24874192f, -0.04663043f, 0.11284284f, -0.13187727f, 0.02216047f, 0.06361338f, 
    0.02742671f, -0.01846119f, 0.11583862f, 0.10610418f, 0.23239730f, -0.23739664f, -0.28585640f, -0.06035635f, 
    0.02089576f, -0.07927689f, -0.01139157f, 0.04299266f, 0.04135340f, 0.06254292f, 0.18113986f, -0.11804079f, 
    0.20172179f, 0.33402118f, -0.05188346f, 0.09693372f, 0.13371548f, 0.06752099f, -0.03580235f, -0.06078623f, 
    0.00461114f, -0.08199995f, 0.10221642f, 0.03018903f, -0.17174894f, 0.10563494f, -0.10445028f, -0.29295826f, 
    0.00728473f, -0.26258850f, -0.04108274f, 0.23621123f, 0.01299208f, 0.03809858f, -0.07126123f, -0.11019374f, 
    0.05052591f, 0.17421550f, -0.07092481f, -0.16386002f, 0.15711297f, 0.11657584f, -0.26816532f, -0.02633402f, 
    -0.00642889f, 0.03671008f, -0.09445736f, 0.15260196f, -0.16877286f, -0.23116492f, -0.06793346f, -0.40920284f, 
    0.07689717f, -0.16784719f, 0.06771556f, -0.01436277f, 0.10013209f, -0.04321611f, -0.05118829f, 0.06534821f, 
    0.42730996f, 0.19922034f, -0.07993032f, 0.11289415f, -0.16934802f, -0.11138382f, 0.00938009f, -0.06349523f, 
    -0.09852581f, -0.01330628f, -0.19752747f, -0.12651388f, 0.18015020f, -0.03051090f, 0.07261360f, 0.24272163f, 
    0.13967055f, 0.11871959f, -0.04021883f, -0.02211092f, 0.04659586f, -0.02084979f, 0.19754250f, -0.01375472f, 
    0.00439113f, -0.03401967f, 0.21563378f, 0.08676981f, -0.12270179f, -0.09184514f, -0.02856966f, 0.04248993f, 
    0.00535232f, 0.07213021f, -0.00021853f, 0.05732805f, -0.10614175f, -0.06959386f, 0.18572959f, -0.10266078f, 
    -0.08420353f, 0.05617951f, 0.04106107f, -0.08153462f, 0.04489237f, -0.22635584f, -0.01050640f, -0.27045655f, 
    -0.54708594f, 0.35577330f, -0.00902032f, -0.32537127f, 0.07996245f, -0.10968407f, -0.00350276f, -0.04924623f, 
    0.00542900f, -0.00969481f, -0.02274562f, 0.09509675f, -0.17743020f, 0.33762628f, -0.23064493f, 0.08303313f, 
    -0.02372442f, -0.09501722f, 0.01812581f, 0.05648938f, 0.04389631f, 0.11892393f, 0.02831883f, 0.10548952f, 
    -0.21693243f, -0.03485587f, -0.13910152f, -0.23874868f, 0.05511698f, -0.08336692f, 0.12749761f, 0.20984936f, 
    -0.00663221f, -0.07825325f, 0.00835991f, -0.06675861f, -0.09323940f, 0.22877245f, 0.54592180f, 0.07676190f, 
    0.01491300f, 0.09062029f, -0.05532789f, 0.27138060f, 0.11757027f, 0.05416800f, -0.09435387f, 0.09968306f, 
    0.34339154f, 0.18168640f, -0.09548613f, -0.17030914f, -0.09147681f, -0.20888299f, 0.05705344f, -0.04656286f, 
    0.11798671f, 0.11082619f, 0.02281787f, -0.00921664f, 0.39092955f, -0.68519348f, 0.08979632f, -0.05860158f, 
    -0.03404355f, -0.05250532f, -0.00901756f, 0.13991585f, 0.07196313f, -0.13443139f, -0.07749445f, -0.01040677f, 
    -0.26975065f, 0.31951338f, -0.28881738f, -0.21011443f, 0.09351707f, 0.01236372f, 0.01984288f, -0.14475505f, 
    -0.11804475f, -0.06869845f, 0.03612944f, -0.10009369f, 0.02290715f, -0.25016758f, 0.01483745f, -0.03744013f, 
    0.06439951f, -0.03649964f, 0.06991706f, -0.06015136f, -0.07427951f, 0.13237932f, -0.25226465f, 0.05269009f, 
    -0.62105721f, 0.49058494f, -0.14061439f, -0.05906624f, 0.24116363f, 0.14145842f, -0.04204241f, -0.07079934f, 
    0.04385035f, -0.12345689f, 0.24585332f, 0.01906653f, -0.29351011f, -0.00983160f, -0.10795829f, -0.20869450f, 
    0.16715869f, -0.10865838f, -0.05755401f, -0.04327737f, -0.06446625f, -0.06794591f, 0.18064021f, -0.17943709f, 
    0.14881077f, -0.04355178f, -0.14141251f, 0.48863238f, 0.00976804f, -0.00977223f, -0.02015075f, 0.11883334f, 
    0.17486687f, 0.11317322f, 0.07641581f, 0.04650291f, -0.22061889f, -0.31581914f, -0.03770490f, -0.17545573f, 
    0.13513991f, -0.03189108f, 0.17597669f, 0.09752662f, -0.00841503f, -0.03879135f, 0.13052399f, -0.00611394f, 
    0.20610505f, -0.24410942f, -0.22027287f, -0.46746883f, -0.17846595f, -0.09901781f, -0.05769174f, 0.10336775f, 
    -0.02552980f, -0.11281525f, -0.01379291f, -0.10900289f, 0.06631032f, 0.18934287f, -0.01240459f, -0.16317199f, 
    -0.12576319f, -0.06632153f, -0.08224589f, -0.06743781f, -0.05539247f, -0.05208230f, -0.09228372f, -0.01597529f, 
    -0.07318497f, 0.46748543f, 0.03148108f, -0.00957081f, -0.01180988f, 0.09177765f, -0.09361221f, 0.05229648f, 
    0.04477919f, 0.07715406f, 0.04562103f, -0.08258529f, 0.73973286f, 0.03699815f, 0.13073596f, -0.18741255f, 
    -0.04361346f, 0.16885401f, 0.01278896f, 0.12020842f, -0.03292821f, -0.05538153f, 0.14687708f, 0.10047328f, 
    0.19935071f, -0.32699007f, -0.29413617f, 0.23821302f, 0.03488322f, -0.04044023f, -0.10057025f, 0.25475156f, 
    -0.19425678f, 0.04182959f, 0.02100442f, -0.24046509f, -0.33726794f, -0.12950698f, 0.06852772f, 0.00784939f, 
    0.13954639f, 0.02570684f, 0.00619529f, -0.04777474f, -0.05635758f, -0.15804330f, -0.10797053f, 0.07761537f, 
    -0.12716873f, 0.08826249f, 0.17794582f, 0.12183136f, -0.03955993f, 0.23117782f, -0.11620982f, -0.14061321f, 
    -0.15166751f, -0.03097176f, -0.05187652f, 0.09428539f, 0.15959974f, -0.13076335f, -0.31032830f, 0.06806462f, 
    0.01242052f, 0.05143281f, -0.06756661f, 0.09534979f, -0.09276544f, -0.07928219f, -0.14228635f, 0.07595076f, 
    0.13655068f, 0.17827055f, -0.25809816f, 0.02857739f, 0.27833483f, 0.04516944f, -0.25204304f, 0.06552777f, 
    -0.03442547f, 0.10401892f, 0.19941324f, 0.03903237f, -0.04815324f, -0.04691152f, -0.12617306f, -0.27918687f, 
    -0.03987615f, -0.18018535f, -0.00545483f, 0.00357247f, 0.04305109f, -0.04932710f, -0.03128883f, -0.18489636f, 
    -0.36112964f, 0.19422543f, 0.23911732f, -0.01715313f, 0.03642152f, 0.06898878f, 0.11354902f, -0.11771822f, 
    -0.10993345f, -0.07450867f, -0.05328600f, 0.04976850f, -0.18178725f, 0.14662158f, 0.06980687f, -0.32756701f, 
    0.01699723f, 0.01914644f, 0.01586692f, 0.04161042f, -0.19359954f, 0.06369128f, 0.01893666f, -0.05501961f, 
    0.33054137f, -0.05426132f, 0.28715315f, -0.20591357f, 0.06308700f, 0.11607224f, 0.01605249f, 0.00401515f, 
    -0.08474469f, -0.04542933f, -0.09208915f, -0.11560177f, -0.08985420f, 0.15574791f, -0.02692218f, 0.18047713f, 
    0.01905158f, -0.09563373f, 0.06991088f, 0.29181603f, 0.05495053f, -0.10279835f, 0.10128722f, 0.09953538f, 
    -0.16181664f, -0.57037270f, -0.19016545f, -0.20191810f, -0.04694435f, -0.03554377f, 0.01941928f, 0.19666141f, 
    0.02824369f, 0.07410265f, 0.13162124f, 0.09598516f, -0.06988351f, -0.14689475f, -0.02562893f, -0.08202353f, 
    -0.14060634f, 0.00893216f, 0.11915015f, -0.02956965f, -0.17270072f, 0.10217877f, -0.01611947f, -0.03312575f, 
    0.09189131f, 0.06835620f, -0.12270941f, -0.05292576f, 0.21729359f, 0.18106861f, -0.10549945f, -0.01730822f, 
    -0.09405705f, -0.01528106f, 0.16901800f, -0.04831348f, -0.32357919f, 0.45643210f, -0.18829654f, -0.34126070f, 
    0.13308246f, -0.02905152f, 0.04663403f, -0.05698631f, -0.17744866f, 0.00953465f, -0.17622826f, -0.11500338f, 
    0.07827225f, -0.00687691f, 0.05281133f, 0.15918601f, -0.04862535f, 0.03083079f, -0.08705102f, -0.12878047f, 
    -0.01474592f, -0.00233715f, -0.09490491f, -0.07606101f, -0.17848624f, -0.11496056f, 0.24953789f, -0.16696106f, 
    0.02399257f, 0.03268177f, -0.03950499f, 0.06164581f, 0.08018284f, 0.10209048f, 0.12101749f, 0.17628054f, 
    -0.54367465f, -0.02250188f, -0.05755069f, -0.19795999f, 0.12162195f, -0.00796530f, -0.13242139f, 0.00309238f, 
    0.03694391f, -0.24836552f, -0.20050880f, -0.06073577f, 0.30550304f, 0.17367132f, 0.01643894f, 0.10963399f, 
    0.04693285f, -0.18218035f, -0.03589235f, 0.00525831f, -0.02219285f, -0.00546807f, 0.02611076f, -0.08546781f, 
    0.19082722f, 0.11890234f, -0.09179496f, 0.06660603f, -0.04818629f, -0.16437165f, 0.12216198f, -0.14596558f, 
    -0.20769043f, -0.08122823f, 0.08649741f, 0.04021299f, -0.40611944f, -0.10259537f, 0.05491877f, -0.04475502f, 
    -0.06469459f, 0.00615776f, -0.04895822f, -0.13882956f, -0.01494962f, -0.21387631f, -0.06203383f, -0.19464393f, 
    0.05100006f, 0.17794931f, -0.05727384f, 0.11341895f, 0.15184355f, 0.10968351f, -0.00140342f, -0.13792522f, 
    0.07254654f, 0.00725727f, -0.20361170f, -0.00405418f, -0.46768180f, -0.04281411f, -0.25215858f, 0.02046717f, 
    -0.08263966f, 0.07263034f, 0.13811943f, 0.08537708f, 0.15454087f, -0.14242093f, -0.00647702f, -0.02889256f, 
    -0.51652771f, -0.45024329f, -0.14766859f, -0.44071034f, 0.06553721f, -0.07814527f, -0.05867398f, -0.06543390f, 
    -0.01243067f, -0.06304972f, 0.03978471f, 0.09769529f, 0.32697913f, 0.08948935f, -0.05041471f, -0.15153672f, 
    -0.33728859f, -0.09478421f, -0.03105219f, 0.14921327f, 0.08335313f, -0.11356715f, 0.02689996f, -0.06154025f, 
    -0.67570609f, -0.56533170f, -0.26942134f, 0.03773135f, -0.08832809f, -0.00537436f, 0.07095756f, -0.08253583f, 
    0.08677699f, 0.11118714f, 0.05300917f, 0.06480821f, -0.16717964f, 0.07470462f, -0.21030858f, -0.27821699f, 
    0.14667429f, 0.09010851f, -0.09396370f, 0.08486359f, 0.03881682f, -0.06486994f, -0.10237031f, 0.05478344f, 
    0.36322546f, 0.06568399f, -0.07107836f, 0.07854868f, -0.21309045f, -0.08793124f, 0.04504393f, 0.01429132f, 
    0.06752838f, -0.05031629f, -0.06061304f, -0.04108313f, 0.34404540f, 0.09949439f, 0.01402332f, -0.07238738f, 
    -0.10432891f, -0.03799494f, -0.07714932f, 0.07101560f, -0.02404778f, 0.09522782f, -0.30885538f, -0.01042704f, 
    0.08147719f, 0.20104836f, -0.05576310f, -0.10715586f, 0.16379938f, 0.00021434f, 0.03266897f, -0.00221661f, 
    0.02064754f, 0.11754069f, -0.00512329f, 0.11752958f, -0.06976823f, 0.05426658f, -0.01582672f, 0.20178969f, 
    0.01445612f, -0.11013960f, 0.18848927f, -0.16925344f, -0.01411898f, 0.09752449f, 0.07968789f, 0.03301162f, 
    -0.02163121f, 0.02633326f, -0.09439204f, 0.01689374f, 0.07713393f, -0.06284165f, 0.03946228f, -0.02705720f, 
    0.07250951f, 0.02453465f, 0.14427993f, 0.15344664f, -0.55711645f, -0.22478622f, -0.00179550f, 0.08505251f, 
    0.12738912f, 0.10319692f, -0.10315119f, -0.18312125f, -0.02608886f, -0.15826435f, -0.21604870f, -0.02302495f, 
    0.18191114f, 0.10788906f, 0.14863168f, -0.14273490f, -0.12349373f, 0.21121076f, 0.04163701f, -0.07419097f, 
    0.06701972f, -0.05121861f, 0.06625435f, 0.04514813f, 0.15792973f, 0.09899430f, -0.03963351f, -0.00081488f, 
    0.07269873f, 0.13612331f, 0.13236907f, 0.12749381f, -0.03484644f, 0.03590376f, 0.15698777f, 0.00294779f, 
    -0.17052576f, -0.22037163f, 0.06588587f, 0.02994665f, 0.16060767f, 0.12744847f, -0.06304380f, 0.02729820f, 
    0.04521137f, -0.05067096f, -0.10327329f, -0.12017489f, 0.29574892f, -0.17939141f, -0.01079642f, 0.26930356f, 
    -0.07086487f, -0.00980979f, 0.03812699f, 0.15076903f, -0.15674184f, 0.03511433f, -0.01923914f, 0.13474482f, 
    -0.00784498f, 0.04381785f, 0.07509217f, 0.12140409f, -0.07710929f, 0.06804047f, 0.01022202f, -0.02582130f, 
    0.10765128f, -0.01646828f, 0.03676431f, 0.10428137f, -0.43920326f, 0.09643166f, -0.07471037f, -0.37803695f, 
    0.11706552f, -0.19826174f, -0.04577779f, 0.13173780f, 0.10599817f, 0.15099794f, -0.02279880f, 0.18743050f, 
    -0.44920728f, -0.36117786f, 0.23365037f, 0.03791500f, 0.10799546f, 0.02039351f, 0.12166806f, -0.04520236f, 
    0.05910918f, 0.05566441f, 0.07616946f, 0.24975649f, -0.14253998f, 0.20705195f, 0.03829111f, 0.00337078f, 
    0.06680190f, 0.07165997f, -0.04383780f, 0.07192273f, 0.02013164f, 0.06686692f, 0.02533947f, -0.13612466f, 
    -0.75948793f, -0.20277679f, 0.04115099f, -0.10989431f, 0.13217637f, -0.04085403f, -0.01757392f, -0.03912795f, 
    0.12452583f, -0.07757600f, 0.05117248f, 0.14692333f, 0.21216910f, -0.43698823f, 0.05530290f, -0.25472593f, 
    0.05628721f, -0.12901036f, 0.06184829f, 0.03605845f, -0.03634223f, 0.24091533f, -0.18339777f, -0.19713055f, 
    -0.10172766f, 0.19318098f, 0.11743206f, -0.30266553f, 0.16604206f, 0.20390293f, 0.04996954f, -0.02061408f, 
    0.17303535f, 0.18723953f, -0.10978987f, 0.17592330f, 0.41675299f, 0.26265636f, 0.08257182f, -0.16384338f, 
    -0.05941707f, 0.03758812f, 0.04115697f, -0.11254707f, -0.03528691f, -0.00051059f, 0.07997024f, -0.03608513f, 
    0.26638302f, -0.02924082f, -0.19413547f, 0.06737126f, -0.01383689f, -0.07877751f, -0.06844871f, 0.16032538f, 
    0.04367819f, 0.10960966f, -0.00293228f, -0.09678412f, -0.34931409f, -0.48048934f, -0.02607094f, -0.29375234f, 
    -0.02831576f, 0.10297973f, -0.02797556f, 0.04992811f, 0.12381106f, 0.22187184f, 0.23506743f, 0.10850668f, 
    0.20944783f, -0.03645966f, -0.15218009f, 0.06492714f, -0.02890883f, -0.11528702f, -0.04667165f, 0.17843752f, 
    -0.05712930f, 0.15498470f, 0.07605273f, 0.19749095f, -0.00894590f, 0.08169708f, -0.14044406f, 0.01471863f, 
    -0.33266744f, -0.02418786f, -0.04963730f, 0.14277467f, -0.02768420f, -0.09787360f, -0.02073177f, -0.11913179f, 
    0.08923087f, -0.22740708f, -0.06149518f, -0.25979793f, -0.15173478f, 0.02232746f, -0.00025611f, 0.05215866f, 
    0.17275383f, 0.07390402f, 0.06421558f, -0.01842467f, 0.50404388f, -0.04365814f, -0.02192792f, 0.31282136f, 
    -0.05705551f, 0.00651371f, 0.04990353f, 0.27122059f, 0.03403654f, -0.00910635f, -0.05768408f, 0.04985264f, 
    0.18221584f, -0.05912494f, -0.05255449f, 0.00085948f, -0.10750589f, 0.19182777f, 0.00294438f, 0.03087258f, 
    0.08568938f, -0.13639003f, -0.23687528f, 0.04042075f, 0.04530568f, 0.04510642f, -0.18184878f, -0.02933313f, 
    0.18099776f, -0.04597950f, 0.00020229f, -0.33674026f, 0.01213897f, 0.05632741f, 0.04598810f, -0.08330083f, 
    -0.04030796f, 0.11349676f, 0.04645902f, -0.18856236f, -0.08905064f, -0.12655286f, -0.05369866f, -0.05161498f, 
    -0.07192862f, 0.04326678f, 0.10457147f, 0.18434927f, 0.00793956f, 0.08866519f, 0.00060826f, 0.05189750f, 
    -0.15773842f, -0.07492453f, -0.06627643f, 0.09140886f, 0.04843923f, -0.04815290f, 0.20083357f, 0.12789959f, 
    0.20328425f, -0.18788417f, -0.30953529f, -0.23273773f, -0.00149290f, -0.09006952f, -0.03119406f, 0.00731779f, 
    -0.02238971f, 0.09255299f, 0.14011477f, -0.12017830f, -0.40783089f, 0.21254304f, -0.15321581f, 0.03141560f, 
    0.06028934f, 0.05010962f, -0.02194976f, -0.07967059f, 0.16393794f, -0.03593677f, 0.03041694f, -0.07055546f, 
    -0.19594830f, -0.08634968f, -0.04926240f, 0.18129581f, 0.06802554f, 0.03447390f, 0.11985245f, -0.02190414f, 
    0.09308387f, -0.01767883f, -0.03849148f, -0.04627592f, -0.26129210f, -0.33357778f, 0.01917174f, 0.33335155f, 
    -0.16293773f, 0.11335839f, -0.19459511f, -0.06547929f, -0.15842712f, 0.13022038f, 0.00141412f, -0.11808725f, 
    -0.04932902f, -0.03403619f, 0.13768941f, -0.25345191f, 0.10860693f, -0.04726965f, -0.04054595f, -0.08961561f, 
    -0.16308090f, 0.09908914f, 0.16965798f, 0.13856195f, -0.04431335f, -0.14519535f, 0.07826076f, 0.00256987f, 
    -0.05436240f, -0.01593291f, 0.04301801f, 0.14641429f, -0.09206367f, 0.00355490f, -0.00452512f, -0.07668287f, 
    0.11866459f, -0.20702930f, -0.14906542f, 0.34334821f, -0.00503436f, 0.04417465f, 0.06896719f, 0.11124094f, 
    -0.05635538f, -0.06753619f, 0.04457294f, -0.16109461f, -0.04265524f, -0.12299579f, 0.03727958f, 0.15490627f, 
    -0.24517006f, 0.11122002f, -0.13516718f, -0.01028109f, 0.18226905f, -0.22110933f, -0.17263632f, -0.13198934f, 
    0.29017153f, -0.32424569f, -0.15513258f, 0.45553219f, 0.09134550f, -0.12332277f, -0.02773727f, -0.07122433f, 
    -0.14496446f, 0.01088560f, -0.08255454f, -0.14411998f, -0.19369833f, -0.14027524f, -0.21321692f, -0.34924808f, 
    -0.00455319f, 0.02983442f, -0.08557622f, 0.30117652f, -0.10218436f, -0.01051908f, 0.04192065f, -0.00043285f, 
    -0.28908944f, 0.52300626f, 0.01102012f, 0.02705918f, -0.19563280f, -0.07615802f, -0.08325931f, -0.19515592f, 
    -0.09435304f, 0.12002459f, -0.00128676f, -0.20275277f, 0.29375425f, -0.38150817f, -0.25566092f, -0.01128369f, 
    -0.04847384f, 0.03050592f, -0.09004671f, 0.06945878f, 0.01041270f, 0.03381701f, -0.04270646f, 0.02393580f, 
    0.32055336f, 0.19620374f, -0.27112743f, 0.29814744f, 0.12640858f, -0.03051678f, -0.06686044f, -0.05725103f, 
    0.07863816f, 0.06855266f, 0.11833260f, 0.11353268f, -0.21797073f, 0.06823811f, 0.30123791f, 0.07831947f, 
    0.01769306f, 0.02688956f, -0.02277378f, -0.08132304f, 0.02538190f, -0.03912941f, 0.14709495f, 0.16330147f, 
    0.02009279f, -0.04653606f, -0.04563029f, -0.15117924f, -0.19914854f, -0.11728131f, 0.03775818f, -0.03086191f, 
    -0.17222042f, 0.06889897f, 0.09444899f, 0.04650198f, 0.41822138f, -0.05162875f, -0.28602797f, 0.18443465f, 
    0.03289005f, 0.05406472f, -0.01831385f, 0.06528685f, 0.10298879f, -0.06007982f, 0.04216597f, -0.10339145f, 
    0.06524648f, 0.27333155f, -0.14596249f, -0.15661131f, 0.23140651f, 0.05549314f, -0.08082815f, 0.06682783f, 
    0.02436799f, 0.00812242f, 0.02636266f, 0.03484318f, 0.58175671f, -0.03420629f, -0.03467646f, 0.07554516f, 
    0.06080183f, -0.07570049f, -0.02780931f, 0.00097116f, 0.10487930f, 0.01064519f, 0.05936912f, -0.01203747f, 
    0.68572402f, -0.12026118f, -0.16796973f, -0.13225155f, -0.06277356f, -0.24232684f, -0.04230350f, 0.00898448f, 
    -0.01464172f, 0.09578320f, -0.07381914f, -0.03746502f, 0.12482335f, -0.09757038f, 0.18839857f, 0.01199650f, 
    0.09086765f, 0.02132127f, -0.07338555f, 0.10890098f, -0.20732465f, -0.10040493f, 0.14568189f, -0.04771832f, 
    -0.25095215f, -0.23065527f, 0.21710743f, 0.44607884f, 0.02571598f, 0.13615581f, 0.02883731f, 0.13707857f, 
    -0.02678367f, 0.01280198f, 0.06351664f, -0.00923502f, -0.15445539f, 0.13550894f, -0.31294304f, -0.12064258f, 
    -0.08887957f, 0.06404801f, -0.14506501f, 0.03306049f, 0.09872862f, -0.07006195f, -0.04754672f, -0.18889843f, 
    -0.35437304f, -0.35640606f, 0.01743423f, -0.07377433f, 0.08320244f, -0.12599491f, 0.05842976f, -0.02772297f, 
    -0.05409165f, -0.13833623f, 0.05746238f, 0.01002588f, 0.26871139f, -0.10353163f, -0.13832472f, -0.10259365f, 
    0.15607066f, -0.08681419f, 0.00326569f, -0.06381861f, 0.08798585f, -0.07687921f, -0.20375422f, -0.11125454f, 
    0.02614284f, 0.06608696f, 0.06564555f, -0.04883580f, 0.05045684f, -0.06300265f, -0.00555614f, -0.11786963f, 
    -0.09236944f, -0.17621914f, 0.04505631f, -0.02871290f, -0.13728128f, -0.17188206f, -0.09961160f, 0.02970919f, 
    -0.07697010f, -0.09784538f, -0.04227223f, 0.00823784f, 0.07932153f, -0.07819598f, -0.13168515f, -0.13624358f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05240585f, 0.07510407f, -0.02991437f, 0.01133586f, 0.01166999f, -0.00871786f, 0.05486260f, -0.04026561f, 
    -0.05367974f, 0.00705523f, 0.10301209f, 0.08285444f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
