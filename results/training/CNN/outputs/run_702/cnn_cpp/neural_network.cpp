#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.14947583f, -0.36927372f, 0.94596958f, 0.45434248f, 1.19563055f, -0.10240852f, -0.56739771f, -0.73544908f, 
    -0.41618216f, -0.21495934f, 0.81487399f, 0.25727165f, 0.14591210f, 0.13935183f, 0.29210639f, -0.21455315f, 
    0.36737025f, -0.04872312f, 0.29425445f, 0.60483468f, 0.27748740f, -0.18684198f, -0.10638871f, -0.01114016f, 
    0.05271027f, 1.17456317f, 0.74995059f, 0.59969211f, 1.15473092f, 0.77359062f, 0.29930034f, -0.05276423f, 
    -0.40140083f, -0.11733206f, -0.24656539f, -0.19341446f, 0.12575939f, 0.05038327f, 0.11026826f, 0.14918192f, 
    0.21888806f, 0.40462667f, 0.34659898f, -0.22164983f, 0.22660758f, 0.01770596f, 0.13941896f, 0.39025640f, 
    0.11161502f, 0.31032932f, 0.57158214f, -0.77037823f, 0.41110906f, 1.13697398f, -0.24194072f, 0.42414930f, 
    0.70384800f, 0.28760499f, 0.06110897f, 0.73618346f, -0.43548253f, 0.14914949f, 0.10939969f, -0.12750641f, 
    -0.40977892f, 0.01145627f, 0.01865529f, 0.11249378f, 0.09012444f, -0.36219099f, 0.05569542f, -0.05877262f, 
    -0.55672187f, -0.20834573f, 0.05933963f, 0.38969111f, -0.49264029f, 0.26831070f, -0.82737595f, -0.53627121f, 
    0.86324006f, 0.09482087f, 0.91636246f, 0.68180776f, 0.26715785f, -0.37778845f, -0.28383443f, -0.36623180f, 
    -0.37310261f, -0.15951228f, -0.19929175f, 0.22884859f, 0.12677614f, -0.08262541f, 0.24458404f, -0.07425510f, 
    -0.24809018f, -0.00596515f, -0.08826074f, -0.30034384f, 0.89433163f, 0.63309819f, -0.98292428f, 1.08158827f, 
    0.29442668f, 0.92662764f, -0.07722737f, -0.93576854f, 0.05979967f, 0.11003651f, -0.01510761f, 0.11900568f, 
    0.06770121f, 0.09883504f, -0.31879151f, -0.13521293f, 0.04392668f, 0.19385409f, -0.10974665f, -0.25485870f, 
    -0.24315128f, -0.12024796f, 0.05739315f, -0.22546218f, 0.03793201f, -0.37835079f, 0.64392877f, -0.34070399f, 
    0.03257237f, 0.42196229f, -1.09560609f, -0.33708224f, 0.63914376f, -0.42688888f, -0.16716352f, 0.54130989f, 
    -0.20581342f, -0.21609452f, 0.27776876f, 0.61128128f, 0.48216641f, 0.20766287f, 0.16207919f, 0.09454650f, 
    0.69032907f, 0.11316912f, -0.40670225f, -0.05390703f, 0.02744322f, -0.31824216f, 0.74103278f, 0.57709247f, 
    1.02948654f, 0.77840489f, 0.38312939f, 0.21157762f, -0.07318930f, -1.06045461f, -0.60823101f, -0.05043530f, 
    -0.19633949f, -0.11517251f, 0.24051462f, 0.04701217f, -0.45481983f, -0.57454044f, -0.20941247f, -0.32570156f, 
    0.10257035f, 0.03674284f, 0.15177394f, 0.51453763f, -0.08446239f, -0.30683759f, 0.38612974f, -0.14346619f, 
    -1.04093969f, -0.56389558f, 0.30885217f, 0.46764338f, -0.69164330f, 1.30407643f, 0.89471912f, -0.56559044f, 
    0.17130032f, 0.58173984f, -0.27647427f, 0.20426753f, -0.36514205f, 0.40758106f, -0.04533545f, 0.13644379f, 
    -0.11268471f, 0.05870665f, 0.00018213f, 0.47455257f, 0.03729022f, -0.31978789f, 0.00541604f, 0.11634351f, 
    0.72638702f, 0.18272485f, 0.56215709f, -0.23533402f, -0.72099185f, 0.49226043f, 0.55851018f, -0.99999738f, 
    -0.49487168f, -0.73715001f, 0.41999933f, 0.57263839f, -0.66071230f, 0.12029935f, 0.18822995f, 0.03251765f, 
    -0.77708524f, -0.35384595f, -0.32480559f, 0.03958151f, -0.04515160f, 0.09687630f, 0.14690530f, -0.02386641f, 
    -0.12867378f, -0.73606437f, 0.88869435f, 0.93081403f, 0.49709871f, -1.51692152f, -0.45679325f, -0.31083986f, 
    0.13681567f, -0.37677142f, -0.23260438f, -0.27903873f, 0.13672505f, -0.42555100f, 0.25822660f, 0.22105524f, 
    0.01280482f, 0.42212567f, 0.12841530f, 0.14685185f, -0.47808427f, 0.06073675f, -0.17398430f, -0.40682971f, 
    -0.15826893f, -0.16391252f, 0.35806262f, 0.11151207f, 0.93670303f, 1.02549827f, -0.17823339f, 0.64585471f, 
    -0.61375594f, 0.14187105f, 0.00302738f, -0.67784357f, -0.06222257f, 0.14405832f, -0.14818515f, 0.14418629f, 
    0.09554137f, 0.50871068f, 0.39177260f, -0.06125092f, -0.14351352f, 0.00052981f, 0.02079995f, -0.07866697f, 
    0.32341361f, 0.07360537f, 0.07018642f, -0.32718170f, 0.61597127f, 0.83904809f, 0.98152214f, 0.02316981f, 
    -0.67425275f, 0.63295883f, -0.21980987f, -0.03939181f, 0.78501326f, -0.02798177f, 0.34857038f, 0.24064459f, 
    -0.03798583f, -0.02623643f, 0.05880702f, -0.26849321f, 0.12718941f, -0.06666303f, 0.15335529f, -0.13074265f, 
    0.03050303f, -0.13522924f, 0.02754705f, -0.56392181f, 0.61171293f, -0.77728164f, 0.75601542f, 0.32048771f, 
    -0.46853998f, 0.71060979f, 0.30760327f, 0.26985866f, 0.48688737f, -0.01031528f, 0.39968428f, -0.30505738f, 
    -0.31297696f, 0.41586989f, -0.31704691f, 0.32174131f, -0.61005002f, -0.18166322f, -0.45772463f, -0.19430293f, 
    -0.09408247f, 0.05984849f, -0.03453442f, 0.03313156f, -0.19065617f, 0.10694147f, 1.32739198f, -0.25998071f, 
    -0.51387465f, -1.12235928f, 1.09391904f, -0.63535976f, 0.05512790f, 0.24055241f, 0.62831897f, 0.45818165f, 
    0.32649732f, 0.01890632f, 0.41127571f, -0.08045529f, 0.13099797f, -0.24778198f, 0.17538241f, 0.04572482f, 
    -0.12440844f, -0.31954056f, 0.24802689f, -0.07790093f, 0.04714791f, 0.12349203f, -0.05527766f, -0.98954439f, 
    -0.33923706f, -0.84374964f, -0.22285198f, 0.16478707f, -1.19855416f, -0.73872095f, -0.64193797f, -0.51499313f, 
    0.13380550f, 0.65551603f, 0.15016507f, 0.05169749f, -0.04039076f, 0.14116615f, 0.34533402f, 0.07065096f, 
    0.22537659f, -0.39369977f, 0.05892658f, -0.02677587f, 0.03243246f, 0.28090796f, 0.31842497f, -1.49175322f, 
    -0.24330626f, 0.12377374f, 0.75458324f, 0.72249240f, 0.23532565f, 0.66519028f, -0.31638804f, -0.32863268f, 
    -0.70026755f, 0.30315131f, 0.33912498f, 0.40177104f, 0.11838745f, 0.03574794f, -0.21818112f, 0.44685438f, 
    0.40967485f, -0.05020165f, -0.06294388f, -0.28545937f, -0.22126272f, -0.56186521f, 0.02259874f, -0.26598901f, 
    0.05853470f, 0.80655330f, 0.47965458f, 1.01244307f, 0.59693730f, -0.01070169f, 0.07683519f, -0.42725205f, 
    0.35715228f, 0.36040393f, -1.01778579f, -0.55366415f, 0.09274766f, 0.59084326f, -0.19253272f, -0.23466262f, 
    0.20812938f, 0.14186954f, -0.28815660f, 0.05713826f, -0.35248819f, -0.28510025f, -0.64833611f, -0.25376189f, 
    -0.25003281f, 0.14979154f, 0.76596481f, 0.84192234f, -0.97634798f, 0.03452229f, 0.52906066f, -0.20140243f, 
    0.24298793f, 0.37931943f, 0.05479820f, 0.45165145f, 0.57857037f, -0.02524258f, 0.48534524f, 0.52594584f, 
    -0.17837161f, -0.28583109f, -0.49768350f, -0.01462164f, -0.20456623f, 0.45972872f, 0.28545326f, -0.22170743f, 
    0.30627090f, 0.25452295f, -1.47026038f, 0.47784138f, -0.52352947f, -0.85802764f, -0.63807499f, 0.25589690f, 
    -0.06561176f, -0.34680972f, 1.02710831f, 0.64262813f, -0.11425917f, -0.16153157f, -0.30445477f, -0.11327925f, 
    -0.30146334f, 0.30890128f, 0.45527318f, 0.13637772f, 0.19412060f, 0.13399151f, -0.07962179f, 0.03251420f, 
    0.08056043f, -0.30869827f, 0.35561427f, -0.49746221f, -1.29786944f, -0.75622922f, -0.33865932f, -0.71596038f, 
    -0.22621803f, 1.03513825f, 0.74437535f, -0.43700534f, 0.37467435f, -0.39417356f, -0.34977087f, -0.49005714f, 
    -0.26933688f, -0.18504755f, -0.18648182f, -0.12071823f, -0.11744723f, -0.18620388f, -0.10665614f, -0.25108221f, 
    -0.03301146f, 0.14421222f, 0.13222888f, 0.11212654f, 1.25867236f, 0.81495202f, 1.04139888f, 0.08231287f, 
    -0.00387595f, -0.70471638f, -0.52036846f, -0.28512648f, 0.48231751f, -0.20100875f, 0.15338166f, 0.07818593f, 
    -0.34452361f, 0.57909632f, 0.05317779f, 0.13369747f, -0.11883215f, 0.00629765f, -0.09645203f, -0.19819392f, 
    0.06122921f, 0.44080082f, 0.20723425f, 0.31818342f, 0.50718302f, 1.35800052f, -0.01291060f, 0.25902802f, 
    0.01195945f, 0.14863315f, 0.37387404f, -0.48810643f, 0.07781810f, 0.46718925f, 0.58654934f, -0.44819513f, 
    -0.11517399f, -0.62704194f, 0.31816489f, 0.05727324f, 0.34270048f, 0.10586759f, 0.02164759f, -0.05147322f, 
    0.32512450f, 0.39578304f, -0.06246655f, 0.38539898f, -0.14158693f, 0.07024128f, -0.31654787f, 0.33653563f, 
    -0.41017762f, -1.06090689f, -0.63568825f, 0.67548335f, 0.19803973f, 0.26032266f, 0.26204327f, -0.44030988f, 
    -0.21465191f, 0.81044292f, 0.02435410f, -0.32999173f, 0.17584555f, -0.08950571f, 0.21486299f, -0.03905834f, 
    0.23939258f, 0.29623714f, 0.28624481f, -0.04305178f, 0.04451960f, 0.24063598f, -0.04814163f, 0.88464808f, 
    -0.01755071f, -0.86250031f, -0.30059111f, 0.09916827f, 0.69549280f, 0.74996841f, 0.71926624f, 0.93773723f, 
    0.60156417f, -0.05045204f, -0.00911843f, -0.51587051f, -0.05856242f, -0.27250871f, -0.05321667f, -0.45257601f, 
    -0.05090089f, -0.14858225f, 0.26811740f, 0.06947846f, -0.21187976f, -0.38750616f, 0.08469120f, 0.12145827f, 
    -0.79198182f, 0.08927398f, -0.49098870f, -0.64537710f, -0.83772951f, 0.86721456f, -0.47553426f, -0.07043143f, 
    0.46154228f, -0.38849777f, -0.16981974f, -0.54630822f, 0.32323512f, 0.55909663f, 0.35418642f, -0.32179296f, 
    -0.14102489f, -0.28553188f, -0.39003128f, -0.29647809f, -0.08538119f, -0.03798957f, -0.34826425f, -0.11135336f, 
    -0.42057645f, 0.08354173f, -0.99270767f, -1.04012597f, -0.52769059f, 0.06739919f, 0.61169738f, 0.32237285f, 
    -0.09644965f, 0.40037596f, 0.65798473f, 0.10713875f, 0.04213630f, 0.15878037f, -0.00797647f, 0.08390774f, 
    0.01691884f, 0.23834226f, 0.52812272f, 0.35203341f, -0.25562996f, -0.16063423f, -0.39235398f, -0.27904946f, 
    -0.43294087f, 0.16234365f, -1.14891112f, -0.61283064f, -0.56431526f, -0.74597913f, -0.71186531f, -0.48782197f, 
    0.11729876f, 0.65417874f, 0.20371893f, -0.16793910f, 0.40061885f, 0.00891354f, 0.32290974f, 0.13291316f, 
    0.15379407f, -0.01421214f, -0.25516304f, 0.10518947f, -0.64876556f, 0.05331692f, 0.42885327f, 0.07907742f, 
    0.18742667f, 0.25956389f, -0.09279626f, -0.41811353f, 1.14147103f, -0.56134951f, -1.01655865f, 0.25710717f, 
    -0.28185022f, -0.35739765f, -0.59942991f, -0.17997798f, -0.57147646f, -0.24430540f, 0.42665288f, -0.20925538f, 
    0.12587772f, -0.36056590f, -0.11963538f, 0.06115736f, 0.25794446f, 0.18241414f, 0.22188389f, -0.34501821f, 
    0.02458735f, -0.18858041f, -0.03586673f, 0.42509118f, -1.23778975f, -0.52972770f, 0.85623020f, 0.33299363f, 
    -0.08837131f, -0.45278713f, 0.05589643f, 0.61432165f, 0.03837724f, -0.36918953f, -0.39920634f, -0.16520874f, 
    0.27568436f, 0.03412781f, -0.02824800f, 0.19712138f, -0.35783938f, -0.00795313f, 0.02273691f, 0.04336664f, 
    0.24633387f, 0.65356255f, -0.12204523f, 0.57374674f, -0.37163177f, 1.07994139f, 0.20532949f, 0.40355694f, 
    1.16258538f, 1.39641917f, 0.30154097f, 0.57388407f, 0.57864416f, 0.52123606f, 0.15766217f, -0.36549664f, 
    0.24129967f, -0.23075183f, 0.40193599f, -0.18205544f, -0.07915456f, -0.26844585f, -0.35132247f, 0.22043759f, 
    -0.17438892f, 0.16902821f, -0.11970163f, 0.04698018f, -0.29211321f, 0.02791475f, -0.39497486f, -1.20537186f, 
    -0.39584997f, 0.22435197f, 0.08014713f, 0.18452534f, 1.07162702f, -0.61044216f, 0.21022961f, 0.67101490f, 
    -0.27401406f, 0.26774859f, -0.43191212f, 0.01980712f, 0.20582674f, -0.30995578f, 0.24944980f, -0.28385198f, 
    -0.41839510f, -0.02550619f, -0.01629704f, -0.03805568f, 0.25255820f, -0.20630436f, -0.05364292f, -0.42000312f, 
    -0.47214982f, 0.04286068f, 0.05335351f, 0.93667036f, -1.43026376f, -0.42586961f, -0.32245216f, -1.17509496f, 
    0.15447485f, -0.20951714f, 0.60567737f, 0.08036280f, 0.09240653f, 0.25352702f, 0.23968612f, -0.10967109f, 
    0.03632974f, -0.10775974f, -0.26110280f, 0.19069417f, 0.31189772f, -0.08115270f, -0.16954921f, 0.12139553f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03963638f, 0.30716193f, 0.18986849f, -0.15447602f, 0.22161926f, 0.46379024f, 0.11176228f, 0.30928683f, 
    0.17127241f, 0.10312782f, 0.13175657f, 0.45745146f, 0.14009379f, -0.02694065f, 0.49617639f, 0.25057521f, 
    0.00423508f, -0.08695833f, 0.23548898f, 0.10343605f, 0.23330618f, 0.36175981f, 0.34389174f, 0.17381318f, 
    0.25002581f, 0.05939783f, 0.36072692f, 0.10613152f, 0.33695480f, 0.26299989f, 0.21882853f, 0.16044705f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12948859f, -0.27025515f, -0.04421712f, -0.09805254f, -0.16227651f, 0.03330324f, 0.12625976f, -0.06523491f, 
    0.16273288f, 0.00614337f, 0.01137078f, -0.02110727f, 0.13515949f, -0.02788649f, -0.06788006f, 0.19070110f, 
    -0.33016622f, -0.10928681f, 0.03802195f, 0.07760359f, -0.07314131f, -0.01990282f, -0.14135738f, -0.03306742f, 
    0.00655276f, 0.17659198f, -0.26880097f, 0.32372460f, -0.08738250f, 0.05413002f, 0.07449721f, -0.01415553f, 
    0.00580344f, -0.06020339f, -0.24998526f, 0.00049312f, 0.39805493f, 0.20540504f, 0.10175860f, -0.20209442f, 
    0.14376475f, 0.17708859f, 0.04972282f, -0.16095386f, -0.23449320f, 0.06243676f, -0.10111294f, 0.13864148f, 
    0.17331311f, 0.04734046f, 0.05078716f, 0.36281878f, -0.45322263f, 0.01746994f, -0.05079786f, 0.01131932f, 
    -0.06605072f, 0.14357647f, -0.15278955f, -0.05047242f, -0.01122271f, 0.17102417f, 0.01973914f, 0.09220222f, 
    -0.18681268f, 0.01721291f, -0.03195499f, -0.06686800f, -0.04709392f, 0.06059710f, 0.15710151f, -0.09026926f, 
    0.14920764f, 0.06413784f, 0.05078612f, 0.04734062f, -0.07718660f, 0.03672496f, -0.09822710f, 0.01556812f, 
    -0.13323891f, 0.07274620f, -0.18559322f, 0.14042082f, -0.76157165f, 0.31141210f, -0.02663321f, -0.07003824f, 
    -0.00289419f, 0.00239399f, -0.03067322f, -0.02529154f, -0.00348619f, -0.10380244f, -0.01064576f, 0.21946444f, 
    -0.42767626f, 0.25872383f, 0.20332246f, -0.15335581f, -0.17833458f, -0.09874384f, 0.01286333f, -0.08452486f, 
    -0.04527988f, 0.02627523f, 0.11026291f, -0.13967681f, -0.52165782f, 0.53501767f, -0.18976878f, 0.42981020f, 
    -0.11121389f, 0.04161054f, 0.15170208f, -0.17917085f, -0.00334474f, 0.08786180f, -0.09350551f, 0.02335753f, 
    -0.08228172f, 0.03606671f, -0.16862671f, 0.30850476f, -0.05269561f, 0.00188299f, 0.05174770f, -0.04062101f, 
    -0.15765339f, 0.12200375f, -0.08124615f, -0.12221229f, -0.01693060f, 0.07418067f, -0.17847420f, 0.28373525f, 
    -0.20478061f, 0.06253517f, -0.12928498f, -0.14725500f, 0.04035648f, 0.11690789f, 0.00039350f, -0.08561030f, 
    0.07159110f, -0.04834361f, -0.19404821f, 0.20682359f, -0.21176243f, 0.02048891f, -0.00070895f, 0.01116728f, 
    0.02634403f, 0.02853985f, -0.09217255f, -0.08012139f, 0.26177609f, -0.07897643f, -0.18197240f, -0.13486980f, 
    -0.19941293f, 0.03513229f, 0.14561091f, -0.25090671f, -0.17388670f, 0.08126494f, -0.09842832f, 0.03905726f, 
    -0.74948418f, -0.51312232f, 0.34512866f, -0.06793626f, -0.12124202f, 0.04161450f, 0.10566568f, -0.10030176f, 
    -0.03571585f, 0.02257677f, -0.09110524f, -0.05362621f, -0.59575570f, 0.01417723f, -0.08648416f, 0.03273810f, 
    0.05750898f, -0.09689270f, 0.13321874f, 0.03524520f, 0.11355025f, -0.07886353f, -0.15673439f, -0.00013245f, 
    0.09828115f, 0.06710035f, -0.11860479f, 0.26686057f, -0.15880775f, -0.05026752f, 0.13669018f, -0.03806809f, 
    0.02838243f, -0.05892402f, -0.01957040f, 0.05243940f, -0.11803602f, -0.15618171f, 0.24906048f, -0.16215484f, 
    -0.06756923f, -0.01523111f, 0.15287822f, -0.09384501f, 0.18803298f, 0.08645263f, 0.28144705f, 0.26627150f, 
    0.78195733f, 0.18811069f, -0.37886661f, -0.38982913f, 0.04257184f, 0.03581951f, -0.09619661f, -0.06778423f, 
    0.15732296f, 0.00380140f, -0.01848372f, -0.11247065f, -0.23683724f, 0.15040931f, 0.05894328f, -0.40364346f, 
    0.01522035f, 0.03984017f, -0.11545619f, 0.01020614f, 0.10059019f, -0.10024631f, 0.00734307f, 0.03186465f, 
    0.24629495f, -0.00567099f, -0.15962543f, -0.17156027f, -0.07694794f, -0.23980410f, -0.09582555f, 0.04883959f, 
    -0.01235597f, 0.00060602f, -0.05862779f, 0.01564652f, 0.39673346f, -0.37970921f, -0.07968079f, 0.10684860f, 
    0.06761961f, -0.11149594f, -0.19668479f, 0.04046943f, 0.05091502f, 0.02499827f, 0.05882467f, 0.09082062f, 
    0.18880436f, 0.10908350f, 0.09526373f, -0.29688111f, 0.14538890f, -0.02743976f, 0.00527720f, -0.07638364f, 
    -0.10373318f, -0.17117055f, -0.10050043f, -0.02568312f, 0.17436223f, 0.23504171f, -0.00604668f, -0.14994718f, 
    0.02561383f, -0.07311815f, 0.07135742f, 0.13996737f, -0.11949493f, 0.02624709f, 0.01363330f, -0.04345242f, 
    0.36556298f, -0.33887592f, -0.10621023f, -0.08114315f, 0.00476121f, -0.02871868f, 0.12165781f, 0.04087260f, 
    0.10983421f, -0.05138674f, 0.06491066f, 0.05770161f, 0.16281739f, -0.18919674f, 0.03352227f, -0.09514546f, 
    0.18227525f, 0.03736127f, -0.04315660f, -0.06303051f, 0.09312264f, 0.05125627f, -0.03341661f, 0.14264269f, 
    0.04499454f, -0.22367178f, -0.18887784f, -0.04553859f, -0.11778139f, 0.11079407f, 0.01589539f, 0.03927723f, 
    -0.04864436f, -0.01898518f, -0.05066693f, -0.01753383f, -0.29454464f, 0.00885662f, 0.26271203f, -0.23946451f, 
    0.02223272f, 0.14273942f, -0.02484633f, 0.07186869f, -0.07162663f, -0.08647315f, -0.27792034f, -0.12980559f, 
    -0.40316221f, 0.08740295f, -0.04032512f, 0.38124430f, -0.04358078f, 0.06356859f, -0.09332238f, 0.06338368f, 
    0.05999522f, -0.07744434f, -0.16324878f, -0.05593570f, 0.12378961f, -0.07126937f, -0.01066779f, 0.29857889f, 
    -0.14543930f, 0.03372688f, -0.08594239f, 0.08812322f, -0.06454059f, 0.11483234f, 0.08504265f, -0.05706662f, 
    -0.10119656f, -0.10004361f, 0.14400959f, 0.04056169f, -0.06971813f, 0.00018174f, -0.10139100f, -0.10960058f, 
    -0.08049812f, 0.07004160f, 0.10862161f, 0.25198954f, 0.11466810f, -0.10419054f, -0.01791124f, 0.18660596f, 
    -0.05918832f, -0.03137895f, -0.04363278f, 0.07370424f, -0.28932142f, -0.01616189f, -0.06163207f, 0.07857647f, 
    -0.22720037f, -0.06210131f, 0.11956331f, 0.01814967f, 0.02375839f, 0.02399510f, -0.14470083f, 0.11581098f, 
    -0.15664124f, 0.08681361f, 0.00780809f, -0.04475118f, 0.24944718f, 0.05613577f, 0.17323487f, 0.27000201f, 
    -0.11406305f, 0.05537039f, 0.01435745f, 0.04989544f, 0.03079929f, -0.02008520f, 0.03398417f, 0.03637169f, 
    0.28564316f, 0.06173221f, 0.13525864f, 0.24702884f, 0.03253438f, 0.14936142f, -0.02299263f, -0.07474451f, 
    0.15562254f, -0.15784411f, 0.13332859f, -0.25097477f, -0.08958198f, -0.26581126f, -0.00162682f, -0.06243058f, 
    0.15525551f, 0.02752466f, -0.05518696f, -0.01677157f, 0.15001388f, 0.04263132f, 0.01571285f, -0.06448397f, 
    0.01292930f, -0.29812327f, -0.05161421f, -0.09597778f, 0.11086291f, -0.08394247f, -0.13806064f, 0.02807700f, 
    -0.01334944f, -0.18317883f, -0.04668995f, -0.01026207f, -0.16750288f, 0.00330967f, -0.10523237f, -0.04576199f, 
    0.09562784f, -0.04113878f, -0.18930291f, 0.18754146f, -0.03912093f, 0.08888377f, 0.07096425f, 0.10711464f, 
    0.24431537f, -0.12839495f, 0.08179185f, 0.11607935f, -0.15762031f, -0.03515909f, 0.07292362f, 0.08046303f, 
    -0.10097720f, -0.03494462f, 0.15164566f, -0.27687311f, 0.38692379f, -0.02192151f, -0.06066591f, 0.09168226f, 
    -0.10612499f, 0.06629253f, -0.10151926f, -0.01737878f, 0.14608286f, -0.02278306f, 0.04830315f, -0.00606091f, 
    -0.08453472f, -0.30076757f, -0.03200043f, -0.28056741f, -0.14683093f, -0.10243401f, 0.02633400f, 0.01543521f, 
    -0.24909788f, 0.00813060f, -0.25450668f, -0.00701295f, -0.68087715f, -0.00603473f, -0.30841720f, -0.06199255f, 
    -0.03074617f, 0.01656085f, -0.06841449f, -0.14064199f, 0.08395057f, -0.09427776f, -0.04240843f, -0.07776932f, 
    0.00844434f, 0.20856294f, -0.01838786f, 0.11412518f, -0.16132332f, 0.03533940f, 0.00001111f, 0.09916300f, 
    0.20739359f, 0.03631247f, 0.05505448f, 0.27407774f, 0.10603209f, 0.07045896f, 0.05316864f, 0.08333099f, 
    0.04907003f, -0.00620296f, 0.04356753f, -0.15417284f, -0.03018632f, -0.18639785f, 0.10289223f, 0.08229172f, 
    0.12676226f, 0.05908834f, 0.05892723f, 0.01322776f, 0.02780246f, -0.04037447f, 0.03758000f, 0.05316156f, 
    -0.05598960f, 0.03067678f, 0.05731580f, 0.00097229f, -0.34287757f, -0.20055382f, -0.12282156f, -0.27922252f, 
    0.00094813f, -0.00576483f, -0.07994700f, -0.00978993f, 0.11079238f, 0.15780398f, 0.07088050f, 0.02752524f, 
    0.18310925f, 0.26293805f, 0.05784787f, 0.00434941f, -0.10945644f, 0.13035971f, 0.04198669f, 0.09158255f, 
    0.10791565f, 0.01055433f, 0.10100805f, 0.15608412f, -0.05423065f, 0.13926637f, -0.18641186f, 0.02073080f, 
    0.02806402f, 0.13511048f, -0.26712510f, -0.12416141f, -0.21134712f, -0.18857248f, 0.26817319f, -0.08612494f, 
    0.29764509f, -0.11710364f, -0.14465694f, 0.23774585f, -0.07832909f, 0.10099545f, -0.01720532f, -0.03252302f, 
    -0.01606384f, -0.11185152f, 0.03260271f, -0.36623046f, -0.20878793f, 0.09408567f, 0.04403249f, -0.07625365f, 
    -0.01662907f, 0.00564126f, -0.08291966f, 0.15667714f, -0.04236853f, -0.13180862f, -0.21698897f, -0.14527936f, 
    -0.59874284f, -0.05567287f, -0.08571464f, -0.28724539f, 0.02122515f, -0.08637910f, 0.09507104f, 0.23129149f, 
    0.14760618f, 0.04019033f, -0.03753141f, 0.03246957f, 0.20130849f, -0.09245137f, -0.07194499f, -0.04764479f, 
    -0.13248019f, -0.11700550f, -0.01977734f, -0.23784260f, 0.08938110f, -0.01583855f, -0.18309093f, -0.01183225f, 
    0.07155263f, 0.03349046f, 0.05669641f, 0.28562242f, 0.02947092f, -0.06812115f, 0.10250437f, 0.03863189f, 
    0.06829740f, 0.03069859f, -0.02952911f, -0.06215406f, 0.51919293f, -0.09036810f, 0.07481083f, -0.15004623f, 
    -0.14684242f, -0.13832957f, -0.04715580f, 0.06157039f, -0.11245070f, -0.01773806f, -0.07026014f, -0.01322514f, 
    -0.07360046f, -0.22544234f, 0.09925496f, -0.34981892f, 0.00235350f, 0.00176821f, 0.17803784f, -0.03460782f, 
    0.11131354f, 0.07607340f, 0.00849936f, 0.01685409f, 0.36182773f, -0.25800467f, 0.16570444f, -0.04555993f, 
    0.15225476f, 0.02340739f, -0.21334115f, 0.08768231f, 0.03541145f, -0.01784580f, -0.03736202f, 0.12290896f, 
    -0.35504037f, 0.11840419f, 0.01470744f, 0.00550327f, 0.02883632f, -0.16848435f, -0.11213741f, -0.10753265f, 
    -0.12270794f, 0.01795079f, -0.15511706f, -0.15857831f, 0.42314759f, -0.03924718f, 0.10050897f, -0.22236340f, 
    0.07509829f, 0.13065530f, -0.19600198f, 0.01084380f, 0.01432322f, -0.05727375f, 0.09784015f, -0.03704714f, 
    0.21120882f, 0.03347205f, 0.15808898f, -0.07439801f, -0.00811316f, -0.00899163f, 0.12197540f, 0.17751607f, 
    0.15586802f, -0.27152678f, 0.01146686f, 0.03848815f, -0.09324577f, -0.02720784f, -0.22404356f, -0.62561274f, 
    -0.04046619f, 0.06206018f, 0.02309346f, -0.02103154f, 0.09106582f, 0.05707094f, 0.16971013f, 0.01655653f, 
    -0.35868767f, 0.07433293f, -0.30199727f, -0.03008961f, -0.01860218f, -0.13393311f, -0.02675934f, -0.25699189f, 
    -0.17834023f, 0.05130977f, -0.09329341f, 0.02465388f, 0.48624668f, 0.03058183f, 0.04941151f, 0.39375442f, 
    -0.03530118f, -0.03107523f, -0.10944575f, 0.13076228f, 0.03334244f, 0.03193693f, -0.02181208f, 0.06557435f, 
    0.39324078f, -0.13650753f, -0.33506286f, -0.08517150f, 0.13220014f, 0.01494802f, 0.08841184f, 0.02856790f, 
    0.03006042f, -0.08701149f, 0.01756633f, -0.04835144f, -0.28742936f, -0.29727882f, 0.15597357f, -0.39400253f, 
    -0.01271292f, -0.03706206f, 0.01017143f, 0.10929789f, 0.05887319f, 0.10692006f, 0.00418478f, -0.03753848f, 
    0.19761597f, 0.10276799f, -0.11438674f, 0.26049036f, -0.08638710f, 0.12185960f, -0.04370701f, -0.08603950f, 
    -0.05691849f, -0.31746340f, 0.05060465f, -0.09750219f, 0.06671036f, -0.02631794f, -0.03306755f, 0.02831891f, 
    0.11070051f, 0.02081465f, -0.01954026f, 0.00788532f, -0.00611407f, -0.02290899f, -0.08910110f, -0.04377796f, 
    -0.00833398f, -0.09559163f, -0.00607979f, -0.04483182f, -0.18235031f, -0.01671825f, 0.23453572f, 0.11748938f, 
    -0.03079469f, 0.12246149f, -0.10583465f, -0.07431816f, -0.11583588f, 0.32554498f, 0.09830151f, 0.23593618f, 
    -0.11995330f, 0.05614053f, 0.05870666f, 0.20382702f, -0.17024432f, 0.00734891f, -0.03195167f, -0.10669319f, 
    0.41111016f, -0.48699984f, -0.03266762f, -0.26566350f, 0.24234025f, -0.09222433f, 0.04565700f, -0.00992769f, 
    -0.05569770f, 0.06711942f, -0.02294482f, -0.02163395f, 0.24949870f, -0.02943067f, -0.27758238f, -0.01113201f, 
    0.00233029f, 0.03661689f, 0.01364898f, -0.03628241f, -0.12212338f, -0.07490508f, 0.02439646f, 0.01363727f, 
    -0.15964425f, 0.09378611f, -0.00583116f, -0.00735473f, 0.05871695f, 0.01166047f, -0.09876122f, -0.07280676f, 
    0.02750131f, 0.12304959f, -0.10392577f, 0.10387668f, 0.66524583f, 0.03328240f, 0.09946454f, 0.03960476f, 
    -0.02662279f, -0.07456548f, 0.06700542f, 0.03653433f, 0.12604348f, 0.09436912f, 0.01414698f, 0.05967280f, 
    0.14685634f, -0.13750134f, -0.06031553f, -0.61816734f, 0.01101180f, 0.06492119f, 0.04941657f, -0.05583046f, 
    0.12929121f, -0.11633563f, -0.01397501f, -0.11563838f, -0.17807560f, 0.01751395f, -0.50102067f, -0.35250312f, 
    -0.01670281f, 0.08094942f, -0.02814507f, 0.12128348f, -0.08746923f, -0.02332393f, -0.09589390f, -0.00232091f, 
    -0.14674650f, 0.00805369f, -0.15759200f, -0.03660480f, -0.05257852f, 0.10548341f, -0.16000606f, -0.07798060f, 
    0.10651655f, -0.07087532f, -0.07641753f, -0.18914609f, 0.21453875f, 0.07392284f, -0.23720105f, 0.15855452f, 
    -0.01650874f, 0.07499019f, -0.03604797f, -0.11259214f, 0.03502217f, 0.02742622f, -0.01192062f, -0.18994501f, 
    -0.03281621f, -0.00796662f, -0.09554899f, -0.13202468f, -0.03023927f, -0.04273754f, -0.01035622f, 0.10827108f, 
    0.05725661f, 0.19279484f, 0.01810165f, -0.15836711f, 0.13220604f, 0.31497177f, 0.18521680f, -0.08720542f, 
    -0.09419598f, -0.10049468f, 0.08456100f, -0.02156373f, -0.13204019f, 0.14058147f, 0.06649422f, -0.06521523f, 
    -0.71153480f, -0.54833078f, -0.09564927f, -0.59416878f, -0.04831518f, -0.02904541f, -0.17483689f, 0.12326327f, 
    -0.06448723f, 0.00006867f, -0.08743834f, -0.20712887f, 0.52280754f, -0.21816090f, -0.08056813f, -0.07627818f, 
    -0.10650373f, -0.08651720f, -0.10146570f, 0.05943244f, -0.15357643f, -0.01880771f, -0.18232571f, 0.04895997f, 
    -0.02544246f, -0.21209876f, 0.04323472f, 0.06802905f, 0.14812854f, 0.10687043f, 0.00021116f, -0.28739458f, 
    -0.00791084f, 0.11158348f, -0.20419426f, 0.04845510f, -0.03310499f, 0.09704488f, 0.08131543f, -0.01461233f, 
    -0.19344729f, 0.06629317f, 0.08557232f, -0.13369808f, -0.01753631f, -0.07527287f, 0.03276662f, 0.05919575f, 
    0.22421405f, 0.04181311f, 0.15048124f, 0.26149026f, 0.09996016f, 0.00704479f, 0.09665077f, -0.05290086f, 
    -0.09215240f, 0.05511445f, 0.05144899f, -0.07572909f, 0.44902539f, 0.06743953f, 0.01692940f, 0.38279170f, 
    -0.28462312f, -0.17014261f, -0.16851343f, 0.04320840f, 0.11870249f, 0.20071322f, 0.07508844f, -0.00860720f, 
    -0.00415038f, 0.15847614f, -0.27352962f, -0.17159000f, -0.01800379f, 0.08717236f, -0.03642000f, -0.00642337f, 
    -0.07003308f, 0.08566576f, 0.08251790f, -0.04286259f, -0.14536901f, 0.05928250f, 0.04179441f, 0.00126973f, 
    0.09103312f, 0.02302613f, 0.09371140f, 0.02165081f, -0.04001579f, -0.15564057f, 0.07526921f, -0.09988089f, 
    0.09336501f, 0.21653621f, 0.11910366f, -0.07032450f, -0.17934427f, -0.16510160f, -0.07084282f, 0.02141474f, 
    -0.21372394f, -0.12911066f, 0.01473267f, -0.00847940f, 0.10860632f, 0.09851769f, 0.03070323f, 0.22007754f, 
    -0.09029587f, -0.13446774f, 0.10334350f, 0.13920544f, -0.06598734f, 0.01399818f, 0.11950178f, -0.08884861f, 
    -0.09871408f, 0.29465649f, -0.05285457f, -0.09982002f, -0.03462905f, -0.06405433f, -0.01262977f, 0.02007654f, 
    -0.10825321f, 0.02385983f, -0.15087381f, 0.02712057f, 0.05225530f, -0.02304801f, 0.09535700f, 0.17148572f, 
    -0.26348215f, -0.18289526f, 0.00823469f, 0.06690150f, -0.18694830f, -0.08932035f, 0.00907674f, -0.04489972f, 
    0.13525037f, 0.00658979f, 0.06124168f, 0.07359982f, -0.24247746f, 0.07022245f, -0.23188321f, -0.09979546f, 
    -0.04797529f, 0.03218837f, -0.03951257f, -0.08671866f, -0.39290494f, -0.24826522f, -0.28150660f, -0.35314974f, 
    0.00948492f, -0.09374017f, -0.00886491f, -0.19334811f, -0.10556994f, 0.02002661f, -0.02045565f, -0.08590260f, 
    0.23560256f, -0.30832878f, -0.27012557f, -0.03890866f, -0.09468142f, -0.02914347f, 0.02053763f, -0.09316073f, 
    0.06317534f, 0.06445440f, -0.01517553f, -0.13259242f, -0.08600435f, 0.05704653f, 0.07062478f, -0.19051078f, 
    0.16113371f, -0.05864242f, 0.05606622f, 0.00161534f, -0.00518351f, 0.02462701f, 0.02868073f, -0.04396056f, 
    0.48244166f, -0.30954075f, 0.24532636f, -0.10681183f, -0.09531600f, -0.01622941f, -0.07047579f, 0.11505037f, 
    0.09001951f, 0.00068973f, 0.04129758f, 0.07023823f, 0.65083945f, -0.28820106f, -0.13271323f, -0.25529802f, 
    0.15582070f, 0.00319848f, -0.08406997f, -0.18582517f, 0.03318414f, 0.10073532f, -0.08913017f, -0.11047231f, 
    -0.32311466f, 0.03759255f, 0.09533191f, 0.30237809f, 0.13723093f, 0.12450540f, 0.03422211f, -0.18369788f, 
    -0.13318966f, -0.03968992f, -0.08229255f, -0.18014984f, -0.21495132f, -0.64406002f, -0.17110592f, 0.10560749f, 
    -0.04016563f, -0.00582651f, -0.11543965f, 0.00991047f, -0.01877316f, -0.25476748f, -0.10450938f, 0.00213730f, 
    -0.12323677f, -0.12261864f, -0.03297820f, -0.13516445f, -0.01306413f, 0.04775212f, 0.13294661f, -0.00484161f, 
    -0.05554753f, 0.20869863f, 0.13689819f, -0.05696837f, -0.31791413f, -0.32044458f, 0.02688417f, -0.29090634f, 
    -0.02559729f, 0.10285984f, -0.09284236f, 0.04299410f, 0.01941809f, 0.07271428f, 0.08229203f, -0.02781210f, 
    0.60138047f, 0.04803669f, -0.16783006f, 0.24329153f, 0.07120574f, 0.06523428f, 0.18761507f, 0.02096992f, 
    0.00776939f, -0.06311286f, 0.01285813f, 0.13337843f, -0.17615509f, 0.24198127f, 0.09156949f, -0.06273157f, 
    -0.06101095f, 0.02377834f, 0.11707324f, -0.09517526f, 0.12617911f, -0.15303367f, -0.03130677f, -0.13682358f, 
    0.10613301f, -0.62075913f, -0.19693419f, 0.35245210f, 0.04326795f, 0.00910707f, -0.02088563f, 0.05868106f, 
    0.06825519f, -0.02442586f, -0.04378593f, 0.10178179f, 0.04444292f, -0.10239437f, 0.09026735f, 0.14660577f, 
    0.07660369f, -0.01186143f, 0.01807864f, -0.08070620f, -0.13165313f, 0.15811893f, -0.11003682f, 0.02784958f, 
    0.02272207f, 0.23484038f, 0.01377043f, 0.22349213f, -0.06230884f, 0.01037341f, -0.19174430f, 0.09537664f, 
    0.01213794f, 0.02262062f, 0.04413149f, -0.12850401f, -0.27541313f, 0.11984849f, -0.01755367f, 0.02874858f, 
    0.00263530f, 0.09407970f, 0.15692058f, 0.17361169f, 0.02410099f, 0.00002805f, 0.01971532f, 0.27468824f, 
    -0.07098702f, -0.70687932f, -0.14557095f, 0.25477105f, -0.09145454f, -0.10763344f, 0.07400642f, 0.11467619f, 
    -0.00459054f, 0.02474287f, -0.06227526f, -0.15000406f, -0.97430831f, 0.18664001f, 0.09800506f, 0.06096135f, 
    0.00504848f, 0.04984922f, 0.01391142f, 0.08420336f, -0.06447539f, 0.11736974f, -0.13771018f, 0.11659659f, 
    -0.18572631f, -0.17610058f, -0.10160462f, -0.10965519f, 0.03070811f, 0.02906117f, -0.12322063f, 0.07503761f, 
    0.12927744f, 0.08280306f, -0.03234373f, -0.18208244f, -0.09381748f, 0.21694313f, -0.02350324f, 0.11732273f, 
    -0.20466314f, 0.05496540f, -0.16595583f, 0.22071919f, 0.07885536f, -0.08725785f, -0.27519241f, 0.02914653f, 
    0.19427212f, -0.07702807f, -0.07630387f, 0.19959350f, -0.07738356f, -0.08076990f, -0.02750581f, -0.04959535f, 
    0.06745102f, -0.02326988f, -0.13998820f, -0.01222016f, -0.02247852f, 0.16461860f, 0.19490993f, 0.01372217f, 
    0.16045611f, 0.06360554f, 0.14206615f, 0.09665348f, 0.03135403f, 0.17672111f, -0.21507789f, 0.12008964f, 
    0.23730746f, -0.07951692f, -0.33002076f, 0.21444961f, -0.19450530f, -0.17438377f, 0.07233918f, -0.04869394f, 
    -0.07590928f, 0.08310290f, 0.12827505f, 0.20499875f, 0.18260120f, -0.25654829f, 0.15590198f, -0.16017272f, 
    -0.05337507f, 0.03685542f, 0.09062537f, -0.25692981f, 0.03643765f, 0.04017191f, 0.09570171f, -0.08797469f, 
    -0.03632734f, 0.36402175f, 0.03760440f, -0.26782957f, -0.11713866f, 0.10971802f, -0.04372254f, 0.09612283f, 
    0.01711330f, -0.24692711f, 0.00105855f, 0.08490846f, 0.18022132f, -0.30481929f, 0.14903919f, -0.04656938f, 
    -0.10404141f, 0.04301612f, 0.18324225f, 0.12363330f, -0.19551511f, -0.10831558f, 0.03957428f, -0.01737390f, 
    -0.27748036f, -0.45215467f, -0.35844222f, -0.09600725f, -0.06876133f, -0.04289640f, 0.04367651f, -0.07326379f, 
    -0.11180097f, 0.06169806f, 0.07541401f, -0.03074740f, -0.30455709f, -0.35469773f, -0.43041107f, 0.06965505f, 
    -0.06029659f, -0.03407377f, -0.13043068f, -0.14803723f, -0.08145673f, -0.02420167f, -0.08757369f, 0.08339103f, 
    -0.15063895f, -0.14320363f, 0.02492910f, -0.15899943f, -0.09142584f, 0.00366683f, 0.01114288f, 0.05854873f, 
    -0.02528755f, -0.15645280f, -0.08760203f, 0.08429471f, -0.13152106f, -0.01194193f, -0.18341884f, -0.17724048f, 
    -0.12875065f, 0.00235695f, -0.00109296f, -0.09589539f, -0.06369214f, 0.04328219f, 0.07735735f, -0.10252718f, 
    0.18967053f, 0.16168486f, -0.16888186f, 0.02466764f, -0.06066597f, -0.03707684f, 0.12111825f, 0.01004499f, 
    -0.07522502f, 0.10832689f, 0.03010171f, 0.11480281f, 0.03428344f, 0.06132402f, -0.28592199f, -0.06179102f, 
    -0.29992649f, -0.17597607f, 0.02352733f, -0.11773758f, 0.05810192f, -0.17164062f, -0.02648154f, 0.08639319f, 
    0.11838875f, 0.04710320f, -0.04107850f, -0.17893198f, -0.06386761f, -0.12247662f, -0.01725072f, -0.09255369f, 
    -0.06099482f, -0.04354273f, 0.13701850f, 0.08813646f, 0.45004284f, 0.28627014f, 0.00983162f, 0.09427911f, 
    -0.14088394f, 0.14839010f, 0.03897891f, 0.11005667f, 0.05287105f, 0.08517145f, -0.13395983f, 0.11780211f, 
    0.18472438f, 0.23405758f, 0.23958203f, 0.03451026f, -0.04931283f, -0.14021914f, 0.05363124f, 0.02011822f, 
    0.02974245f, -0.00348789f, -0.06680544f, 0.02028793f, -0.46981919f, -0.47433883f, -0.09805789f, -0.20633431f, 
    -0.12551042f, -0.06828380f, -0.04242507f, -0.17201169f, 0.09826170f, -0.03319824f, 0.07811125f, -0.00339973f, 
    -0.06268611f, 0.02953133f, -0.03774991f, 0.21419597f, -0.01736998f, 0.06718245f, -0.07094938f, -0.01571504f, 
    0.01222709f, -0.06116826f, 0.21729262f, 0.05025447f, 0.02857926f, 0.31225908f, 0.22168614f, 0.41898608f, 
    0.07333144f, 0.13338712f, -0.06949456f, -0.29526949f, -0.02343742f, 0.04499250f, -0.08613868f, 0.02573085f, 
    -0.54453993f, -0.08695711f, 0.21095161f, -0.01795772f, 0.10611967f, -0.14919408f, -0.09465297f, -0.05983861f, 
    0.07897327f, -0.06292821f, -0.26580507f, -0.11330613f, 0.16395664f, 0.11477949f, 0.18276878f, 0.04532656f, 
    -0.01067471f, -0.00501181f, -0.12410488f, 0.06824820f, -0.03297448f, 0.08639791f, 0.03443374f, -0.00064774f, 
    -0.49555618f, 0.32030115f, 0.07931098f, 0.00327771f, -0.01769552f, 0.04205723f, 0.00205879f, 0.05297369f, 
    -0.14784020f, 0.10497464f, 0.04062623f, 0.13760027f, -0.29116535f, -0.10140238f, 0.13456725f, 0.06742176f, 
    -0.21034209f, 0.03494880f, -0.13322346f, -0.11952890f, 0.06912635f, 0.07916993f, 0.13245794f, 0.09166256f, 
    0.22272091f, 0.02276804f, -0.06945944f, -0.06978812f, -0.19248854f, 0.08586601f, 0.06556785f, -0.13457875f, 
    -0.17620386f, -0.13551359f, 0.02405097f, 0.07370158f, 0.12587883f, -0.00414203f, -0.19993903f, 0.21816911f, 
    -0.17639701f, -0.11762358f, -0.02883816f, -0.09744131f, 0.03234810f, -0.08038764f, -0.10224792f, -0.00386387f, 
    -0.27289662f, 0.13218154f, 0.12278136f, 0.07552394f, -0.02133871f, -0.00729056f, -0.04897959f, 0.11370188f, 
    0.11620252f, -0.32062420f, -0.04668639f, 0.08580264f, -0.37457338f, 0.07831128f, -0.19189037f, -0.16322689f, 
    -0.15789941f, -0.07819291f, -0.00920004f, -0.05056804f, -0.07684396f, -0.08823489f, -0.00777591f, 0.01817734f, 
    -0.57837957f, 0.12673116f, 0.34475017f, -0.20850511f, 0.03237622f, -0.01077744f, -0.02976064f, -0.01925647f, 
    0.00778663f, 0.08940063f, 0.13730803f, 0.04491524f, 0.17738503f, -0.46015242f, 0.13253871f, -0.48109078f, 
    -0.01465360f, 0.19214949f, 0.20923871f, 0.10519271f, 0.09444874f, 0.05620636f, -0.16115850f, 0.18949977f, 
    -0.09047962f, 0.11390235f, 0.10336711f, -0.11754512f, -0.18821281f, -0.00191738f, -0.04433287f, -0.01183246f, 
    -0.04935908f, -0.22007485f, 0.15452300f, -0.06900171f, -0.58900028f, 0.08998656f, 0.06437156f, 0.11524782f, 
    -0.18260039f, 0.16027394f, 0.08663820f, 0.02979994f, 0.02955475f, -0.05799552f, -0.12496865f, 0.00689583f, 
    -0.33760759f, 0.18170781f, 0.11579939f, -0.32067293f, 0.00412731f, 0.04014330f, -0.08484469f, 0.21170163f, 
    -0.06745829f, -0.00501805f, 0.00824544f, 0.09302797f, 0.10660560f, -0.29717940f, -0.05327234f, 0.03186332f, 
    0.07704632f, -0.08141766f, -0.07159220f, 0.02816600f, 0.01695775f, -0.14871244f, 0.08299236f, -0.07411909f, 
    -0.02638049f, -0.12718150f, 0.23082557f, 0.09719209f, 0.15177722f, 0.16843793f, 0.01522508f, 0.13947244f, 
    -0.03649722f, -0.08203183f, 0.03570274f, 0.04516689f, -0.42675337f, 0.22994727f, 0.02851948f, -0.37765491f, 
    -0.00558932f, -0.07464822f, 0.05383594f, -0.16110756f, 0.11780389f, 0.17895450f, -0.10028852f, 0.08550162f, 
    -0.11263562f, 0.33613315f, -0.16392645f, 0.11669113f, -0.08451851f, 0.20018612f, 0.04828752f, 0.15026341f, 
    -0.05667434f, -0.02429480f, 0.04672280f, 0.03776835f, 0.17518942f, -0.14453496f, -0.46554220f, -0.23251310f, 
    -0.00722248f, -0.16746883f, -0.14010526f, -0.24626254f, -0.10272855f, 0.05887832f, -0.04877810f, -0.25297272f, 
    0.35505837f, 0.00344128f, 0.00624575f, 0.17420794f, 0.02223655f, -0.09491510f, 0.00891862f, 0.01513508f, 
    -0.01268108f, 0.05469703f, 0.17055359f, 0.15406482f, -1.02008080f, -0.22654551f, 0.14558245f, 0.23646395f, 
    0.20801271f, 0.08724079f, -0.01490467f, 0.04544988f, -0.17749687f, -0.01382440f, 0.10215186f, 0.10678530f, 
    -0.21045771f, -0.07667600f, 0.18125808f, 0.11449909f, -0.19202320f, 0.00478014f, -0.07799357f, -0.08100454f, 
    0.14686058f, 0.19418140f, -0.00955679f, -0.08915454f, -0.16108862f, -0.02291928f, 0.04120098f, -0.02062483f, 
    0.08134523f, 0.03351624f, 0.22064582f, -0.04188288f, 0.12566537f, -0.04158086f, -0.02757499f, -0.10572671f, 
    -0.07483035f, 0.05452736f, 0.05334264f, 0.05011880f, 0.14509964f, 0.04315385f, -0.00396474f, -0.00519281f, 
    -0.02992542f, -0.05138134f, -0.06510648f, 0.00372656f, -0.36758322f, -0.20179781f, -0.13108484f, 0.10311636f, 
    0.02755683f, 0.06424836f, 0.13216862f, -0.09037040f, -0.03633075f, -0.07884759f, 0.02743990f, 0.11231077f, 
    0.20374452f, -0.01024849f, 0.06636502f, 0.00775992f, 0.14936028f, 0.10410375f, 0.16753876f, -0.04497832f, 
    0.02160830f, 0.01142770f, -0.11000931f, 0.09507965f, -0.39535624f, -0.03308595f, 0.00786741f, 0.40864083f, 
    -0.00482986f, -0.22787295f, 0.30065435f, 0.00643861f, -0.10195919f, 0.05141247f, -0.01487440f, -0.02857374f, 
    0.21877910f, 0.06053203f, -0.15737888f, 0.00453774f, 0.19793841f, 0.04693735f, 0.14445798f, 0.00956312f, 
    -0.06534474f, 0.02246862f, -0.07763864f, -0.07250486f, 0.16966753f, 0.12365840f, 0.17958412f, -0.00324155f, 
    0.10533465f, -0.14837171f, 0.04832265f, 0.16971369f, 0.09514453f, -0.10785156f, 0.04457116f, -0.01823387f, 
    0.06121353f, 0.13661276f, -0.15525004f, -0.30193526f, -0.03075044f, 0.07723397f, 0.13172922f, 0.11339099f, 
    -0.00797943f, -0.14358674f, -0.00353448f, -0.02653826f, 0.35302019f, 0.03004834f, -0.17739870f, 0.19104999f, 
    -0.11125650f, -0.11404754f, 0.21578258f, 0.11415064f, -0.05204207f, 0.11581355f, 0.02753377f, 0.08249922f, 
    -0.79073107f, 0.20116095f, 0.06519178f, 0.10165894f, 0.02884520f, -0.05830514f, -0.13104524f, 0.08548939f, 
    -0.09983702f, -0.04114834f, -0.08176946f, 0.08387692f, -0.45178393f, -0.11935595f, 0.19626367f, 0.30831164f, 
    0.08923266f, -0.13638219f, -0.05346653f, -0.21545216f, 0.15958768f, -0.01562419f, -0.05682459f, -0.04296067f, 
    0.08500267f, 0.06106706f, -0.01220080f, -0.12525991f, -0.01489851f, 0.23671108f, 0.04585654f, 0.09759329f, 
    -0.16006912f, 0.16647080f, 0.13852654f, 0.34592944f, 0.08944850f, 0.04105280f, 0.06418400f, 0.01210042f, 
    -0.03452784f, -0.04683319f, 0.15169676f, -0.01689589f, 0.11087420f, 0.05915337f, 0.15826403f, 0.25632858f, 
    0.11987750f, 0.14104034f, 0.17873448f, -0.13733132f, 0.10009774f, -0.25060889f, -0.34271255f, 0.07998642f, 
    -0.10010995f, -0.03536848f, 0.07009949f, -0.03489026f, 0.05499359f, 0.01027716f, -0.17707787f, -0.07346716f, 
    0.04233568f, -0.29178357f, 0.01645225f, -0.26739475f, -0.09764721f, -0.00149732f, 0.00938848f, -0.15294573f, 
    -0.17604680f, 0.09980692f, 0.30691734f, -0.23808794f, -0.07635148f, 0.00696343f, 0.12442029f, 0.01020022f, 
    0.05778020f, -0.08919170f, 0.12967801f, 0.05328257f, 0.01670502f, -0.34558257f, 0.09478812f, 0.15918924f, 
    -0.00418952f, -0.20039785f, -0.07301211f, 0.00393114f, -0.04964715f, 0.08198345f, -0.04938450f, 0.25582147f, 
    -0.00923408f, -0.12845929f, 0.14058456f, 0.22566351f, 0.01169088f, -0.01257774f, 0.09994006f, -0.01461509f, 
    -0.06122689f, -0.11417827f, -0.10828456f, -0.01289276f, -0.80023557f, 0.16935839f, 0.10529138f, -0.22170573f, 
    0.10011370f, 0.01002169f, -0.21887375f, 0.10305518f, 0.04318797f, 0.02407445f, -0.11136463f, -0.14449592f, 
    -0.25720787f, -0.00359073f, -0.02401813f, 0.47590038f, -0.09292409f, 0.09270531f, -0.01235471f, 0.08939296f, 
    -0.10809917f, -0.01816856f, -0.16876240f, -0.10850518f, 0.17093261f, 0.07383902f, 0.07557475f, -0.19013338f, 
    0.03410530f, -0.14946949f, -0.26055166f, 0.17320701f, 0.11131965f, 0.06244856f, 0.10160141f, -0.06850253f, 
    -0.04166907f, -0.00516287f, 0.15575019f, 0.27506539f, -0.00966837f, -0.08298790f, 0.07409655f, 0.07598577f, 
    -0.02478519f, 0.14389163f, -0.05687228f, 0.00170880f, 0.10064639f, -0.06886810f, -0.00569157f, -0.19379553f, 
    0.07578336f, -0.05883810f, -0.03486658f, 0.10996741f, 0.09620769f, 0.07638635f, 0.04623354f, -0.08071184f, 
    -0.32839569f, 0.07049537f, -0.09454311f, 0.12924041f, 0.06678464f, -0.07747329f, 0.01625163f, -0.13793314f, 
    0.03664981f, -0.07184889f, -0.21205334f, 0.02517542f, 0.08625551f, 0.13143305f, -0.20936295f, -0.14583351f, 
    0.05919332f, 0.15075886f, 0.09753393f, -0.02176109f, -0.07831485f, -0.25754684f, 0.19114834f, -0.04347585f, 
    -0.18343614f, 0.00780548f, -0.04035007f, 0.34867474f, 0.07411557f, -0.11742225f, -0.13782459f, 0.12232792f, 
    0.10827617f, 0.01697242f, 0.25451508f, 0.25791439f, -0.35652074f, -0.20707011f, 0.17499851f, -0.20115340f, 
    0.10815892f, 0.04422243f, -0.05215289f, -0.11889569f, 0.11950101f, -0.01461469f, 0.09516693f, 0.00287683f, 
    0.04205142f, -0.04403340f, 0.53164440f, -0.20894347f, 0.01744720f, -0.00019636f, -0.08707659f, -0.14269558f, 
    -0.20685522f, -0.00268288f, 0.04987714f, -0.06715551f, -0.14121743f, 0.03854353f, -0.01186102f, 0.11617143f, 
    -0.14290369f, -0.08240302f, 0.00910025f, 0.11025156f, 0.05264375f, 0.08158471f, -0.04293496f, 0.13189255f, 
    0.21044576f, -0.16796666f, 0.19269176f, 0.06530023f, 0.20785895f, -0.02624545f, -0.26859644f, -0.25005248f, 
    -0.03695006f, 0.00780641f, -0.05620285f, 0.05183011f, -0.17786272f, 0.38345757f, -0.66270441f, -0.19879572f, 
    0.14791523f, -0.06755761f, 0.03516520f, 0.09784439f, -0.00886218f, 0.01416323f, -0.06556072f, -0.10847327f, 
    0.02428316f, 0.16625600f, -0.06214338f, 0.12823519f, -0.14681546f, 0.01509171f, 0.17408219f, 0.05636047f, 
    -0.14063935f, -0.21503323f, 0.16516510f, 0.09574104f, -0.06270105f, -0.01262488f, 0.04940424f, -0.07392796f, 
    0.04881676f, -0.19927965f, -0.05496340f, 0.00162099f, 0.17310391f, 0.20380567f, -0.02207700f, 0.08484004f, 
    -0.24892063f, -0.20805803f, -0.01733162f, 0.03316386f, 0.08749154f, -0.04893829f, -0.02654568f, 0.06582568f, 
    0.06642172f, 0.05788768f, 0.03824154f, 0.18317598f, 0.18424480f, 0.23821500f, -0.09192992f, -0.29485539f, 
    -0.09146001f, 0.01660516f, -0.29897553f, -0.25721166f, 0.00385197f, -0.02253003f, -0.15567549f, -0.02771999f, 
    -0.58273029f, -0.36072600f, 0.02222581f, -0.19287135f, -0.00738734f, 0.15016590f, -0.09119777f, 0.05914641f, 
    0.16775741f, -0.00324888f, 0.06127036f, -0.05298542f, -0.27745831f, 0.08103503f, -0.33441347f, -0.16008338f, 
    0.12962215f, 0.11224193f, -0.19940957f, -0.04609897f, 0.23715481f, -0.10668399f, 0.13511306f, 0.02094371f, 
    -0.71912700f, -0.40697187f, -0.31360996f, 0.22989717f, 0.09166378f, -0.08952199f, 0.02382102f, 0.04686263f, 
    0.14220271f, 0.30508614f, -0.00789701f, 0.17049383f, 0.01458229f, 0.10179918f, 0.14520611f, 0.14045024f, 
    0.07813159f, -0.17374973f, 0.06620219f, 0.07585429f, -0.19061729f, -0.19572930f, 0.13085453f, 0.16513160f, 
    -0.08092123f, -0.05420544f, -0.16412596f, -0.05866564f, -0.04565583f, 0.08201319f, 0.01331279f, 0.23962919f, 
    -0.00701549f, 0.03561899f, 0.01039115f, -0.18259551f, -0.17277421f, 0.13672872f, 0.27282149f, -0.29631820f, 
    0.04354702f, 0.06796850f, -0.07899185f, -0.06520166f, 0.03236192f, -0.19275162f, -0.11753003f, 0.04487535f, 
    -0.42796794f, 0.32328081f, -0.09059745f, -0.18855751f, 0.00883945f, 0.08662648f, 0.14581573f, -0.04824457f, 
    -0.08017127f, -0.09448160f, -0.14860727f, -0.29738024f, 0.14610855f, 0.12082472f, 0.07667092f, 0.00604941f, 
    -0.08664506f, 0.22772254f, -0.12310450f, -0.04939074f, -0.21772896f, -0.12328452f, 0.11892767f, 0.01542091f, 
    0.34010214f, 0.12412159f, 0.22054860f, -0.32564002f, -0.13668884f, -0.22438103f, 0.13784453f, -0.09394555f, 
    0.19661500f, -0.27541995f, -0.08605785f, -0.07311414f, -0.16655999f, 0.21018414f, 0.06467155f, -0.31925035f, 
    -0.06070335f, -0.03153224f, -0.04255576f, -0.03546861f, 0.04091201f, -0.03444166f, -0.03773939f, -0.20449348f, 
    0.22392146f, -0.41117299f, 0.13777405f, -0.11479954f, -0.10769006f, -0.07671844f, -0.00588964f, -0.07866293f, 
    0.03198177f, 0.05632708f, 0.05124492f, 0.01619939f, -0.41590723f, 0.00560516f, -0.26469740f, 0.23280422f, 
    0.02708723f, 0.10174048f, 0.11628425f, 0.14852941f, 0.05196439f, -0.06256731f, -0.06619288f, 0.12222829f, 
    0.14442192f, 0.03535300f, -0.09146398f, 0.18753508f, -0.11320893f, 0.08006706f, -0.04865987f, 0.08286642f, 
    0.13098189f, 0.17754948f, -0.18989848f, -0.07640881f, -0.07834166f, 0.19098003f, 0.28144383f, 0.01660144f, 
    0.07881783f, 0.06915070f, 0.11357756f, -0.11059904f, 0.04530170f, -0.13778640f, 0.07586028f, -0.28992099f, 
    0.08519264f, 0.27782682f, -0.01839225f, -0.44312993f, 0.05339252f, -0.00760527f, -0.07071160f, 0.00094145f, 
    0.10148579f, -0.04977921f, 0.14688537f, 0.02815727f, 0.15333290f, -0.42335248f, 0.11841560f, 0.05832132f, 
    -0.01733849f, 0.08699757f, 0.26771107f, 0.08817090f, 0.06001954f, -0.09269576f, 0.09152970f, -0.01202657f, 
    0.08786075f, -0.11330392f, -0.12569989f, 0.05584514f, 0.08934326f, 0.08329537f, 0.06722907f, 0.16307917f, 
    -0.14539549f, 0.00193972f, 0.06018130f, -0.00300064f, 0.31316036f, -0.01267203f, 0.33368883f, 0.05899324f, 
    0.08498865f, -0.23678255f, 0.05007959f, 0.13292427f, 0.05108383f, 0.08157588f, 0.05400100f, -0.02108166f, 
    0.00673693f, 0.10670860f, 0.05773436f, -0.35957614f, -0.11815044f, 0.12044998f, 0.06659950f, -0.19610666f, 
    0.01244775f, -0.03340181f, -0.02804984f, -0.14233454f, 0.15221968f, 0.07191573f, 0.15192281f, -0.23920961f, 
    -0.03336885f, -0.02305644f, 0.07180323f, -0.03688027f, 0.00442384f, 0.00055448f, 0.05434678f, -0.10599923f, 
    0.21340540f, -0.23961252f, 0.04584488f, 0.06007632f, -0.01252229f, 0.01070036f, 0.08617168f, -0.03783343f, 
    -0.15341790f, -0.05475403f, 0.16944127f, 0.06095767f, 0.00535691f, 0.15421395f, -0.09308282f, 0.75098109f, 
    -0.19221114f, 0.15402026f, -0.14963217f, 0.03708492f, -0.10332796f, 0.08972957f, -0.26616845f, -0.04618619f, 
    0.02642712f, -0.26417392f, -0.29403159f, -0.25501058f, 0.03468877f, -0.08162794f, -0.10156036f, -0.05130114f, 
    -0.15807016f, -0.18996939f, -0.23037225f, -0.09262682f, 0.37429607f, -0.23293221f, -0.10936741f, 0.31512201f, 
    -0.07722197f, -0.05816117f, 0.08197597f, 0.16406140f, 0.16950971f, 0.06636453f, -0.12317050f, -0.03970356f, 
    0.13649252f, 0.24779382f, 0.08962309f, -0.25319669f, -0.08388746f, -0.03376369f, 0.24067394f, 0.06389798f, 
    -0.00339951f, 0.14121491f, -0.00435038f, 0.12508550f, -0.41763431f, 0.21591996f, -0.25449884f, 0.36526552f, 
    0.08448513f, 0.06220686f, -0.27224985f, 0.21137047f, -0.11299475f, 0.01315395f, 0.07031679f, -0.16812511f, 
    -0.20007344f, -0.08685887f, -0.10286327f, -0.02458288f, -0.11283801f, 0.03886877f, 0.04743044f, -0.08518428f, 
    -0.21541192f, 0.17634840f, 0.03912143f, -0.04408756f, -0.00664424f, -0.46691072f, -0.17808561f, -0.36362123f, 
    0.05432889f, 0.04666783f, -0.07906505f, -0.06494453f, -0.05966359f, -0.00630695f, 0.05966998f, 0.16957630f, 
    -0.36411828f, 0.19467157f, 0.04167362f, -0.05922074f, 0.13406050f, -0.07923729f, -0.04589835f, -0.03740297f, 
    -0.00374062f, -0.02976797f, -0.07876379f, -0.07144277f, -0.44913036f, 0.31084192f, 0.20278135f, -0.02001453f, 
    -0.11644519f, 0.03154871f, -0.01405830f, 0.05412192f, -0.03485181f, -0.09712968f, 0.07038598f, -0.12168658f, 
    0.33906817f, -0.07681882f, -0.31120917f, 0.19930832f, 0.00112597f, -0.06909037f, -0.02047788f, -0.06176271f, 
    0.01006561f, -0.07791031f, 0.01330908f, -0.11050503f, -0.30346203f, -0.20656385f, 0.06088111f, 0.08115208f, 
    -0.01746177f, -0.18407579f, 0.10045753f, -0.01585783f, 0.04425337f, -0.05239901f, 0.08189147f, 0.12154366f, 
    0.45476615f, 0.05648365f, 0.06218820f, 0.12587455f, -0.16227341f, 0.02499031f, -0.17751084f, -0.10706619f, 
    -0.16326976f, 0.07250679f, 0.01330964f, 0.12680000f, -0.40954155f, -0.21111155f, -0.27822837f, -0.40144753f, 
    -0.04311493f, 0.02532836f, 0.08018976f, 0.05782636f, -0.04230155f, 0.08121561f, -0.08415359f, 0.06431606f, 
    -0.12459695f, 0.07286526f, -0.33187449f, -0.18396914f, -0.05935685f, 0.05143843f, -0.02076219f, -0.29297772f, 
    -0.10638552f, -0.03837568f, 0.07701481f, 0.07162745f, -0.14339861f, -0.38375914f, -0.17005663f, 0.21172208f, 
    0.03972514f, 0.01004433f, 0.23304382f, -0.08003831f, 0.27585417f, 0.00989428f, -0.28161418f, 0.07269485f, 
    0.17182374f, -0.46549132f, 0.10664358f, -0.18254024f, 0.16893668f, -0.02410782f, -0.09178494f, -0.15163723f, 
    0.00380806f, -0.05491399f, 0.00077571f, 0.03026249f, 0.05842176f, -0.01018788f, 0.21339600f, -0.24945869f, 
    -0.04796444f, -0.07951573f, 0.10172214f, 0.16715525f, -0.07947377f, 0.03482249f, 0.06474189f, 0.11057660f, 
    0.29531911f, -0.34226480f, -0.01354316f, -0.06571773f, -0.07882419f, 0.02409996f, -0.06652883f, 0.10095937f, 
    0.03268895f, 0.02020780f, 0.17263298f, 0.05719117f, 0.06780506f, 0.16060089f, -0.27534395f, -0.13924071f, 
    0.04745131f, 0.11020407f, -0.01762749f, 0.10772873f, -0.05773176f, -0.26786852f, 0.01264403f, -0.06433506f, 
    -0.31520122f, -0.16118112f, -0.32075009f, 0.06885884f, -0.04499488f, 0.00841474f, 0.04029230f, -0.00945478f, 
    -0.06910224f, -0.14818275f, -0.02940886f, -0.01253261f, -0.49381071f, 0.10240798f, 0.00905538f, -0.13422008f, 
    -0.04859392f, 0.00082353f, 0.01582705f, -0.08800106f, -0.01784977f, 0.06236969f, 0.04698922f, -0.04631951f, 
    -0.04697536f, 0.08146472f, -0.07958074f, -0.17977205f, -0.10572468f, -0.05420469f, -0.03128495f, -0.10361606f, 
    -0.06590340f, 0.00291270f, -0.18161596f, -0.09362638f, 0.24908015f, 0.20924161f, -0.08454800f, 0.09187446f, 
    0.13104576f, -0.00920534f, 0.07650035f, 0.02522112f, 0.02355040f, -0.03902539f, -0.04346745f, -0.06316637f, 
    -0.55763710f, 0.36487919f, 0.05503725f, 0.08226818f, -0.20363267f, -0.05316984f, 0.01196250f, 0.07346778f, 
    -0.13472219f, 0.07335539f, 0.02537837f, -0.17496768f, 0.27125636f, -0.25263956f, -0.06374352f, -0.17306812f, 
    0.05321331f, -0.01979809f, -0.02288104f, -0.04176396f, 0.00755476f, -0.00357464f, -0.12174606f, -0.10199110f, 
    -0.31404209f, 0.06651341f, -0.08702348f, 0.06412615f, -0.08245479f, -0.04764282f, -0.02312324f, -0.02786760f, 
    -0.21739881f, -0.01606385f, 0.02279428f, 0.09679309f, 0.33247492f, -0.15134737f, 0.15928803f, -0.25029796f, 
    -0.12755539f, 0.08154680f, 0.08062391f, -0.07015759f, 0.01163166f, 0.09663564f, -0.16596471f, -0.09463695f, 
    -0.01645132f, -0.16801909f, -0.10230026f, 0.38960332f, -0.28493702f, -0.04636193f, -0.08389731f, 0.00530645f, 
    -0.02022518f, 0.00909229f, -0.01440467f, 0.18913770f, 0.30004841f, -0.09478834f, 0.02014117f, 0.38361335f, 
    0.26376897f, -0.16147460f, 0.13244073f, -0.09325425f, -0.01665975f, 0.02719524f, -0.03609271f, -0.15798448f, 
    0.05926162f, -0.04060835f, 0.09217297f, -0.11158903f, -0.12071952f, 0.01158153f, 0.04554486f, -0.02580297f, 
    -0.03723366f, 0.01739192f, 0.04304671f, -0.14166361f, -0.04620613f, -0.18876247f, -0.16024967f, -0.39691848f, 
    0.11606070f, 0.00604826f, -0.04437711f, 0.07456264f, -0.03427322f, -0.02804037f, -0.07605158f, 0.01197577f, 
    -0.13125451f, 0.06484381f, -0.11352462f, -0.12507519f, -0.33326006f, 0.04307790f, -0.06200360f, -0.04401767f, 
    0.01662463f, -0.08041620f, -0.14110857f, -0.01401584f, -0.09032566f, 0.06125228f, 0.06747472f, 0.03082823f, 
    0.06725512f, -0.06103902f, 0.02343780f, -0.02057504f, -0.04589549f, 0.00137523f, -0.00912620f, -0.02248355f, 
    0.10484077f, 0.14528649f, 0.07630824f, 0.28534958f, -0.06506216f, 0.04410276f, -0.20637512f, -0.07657035f, 
    -0.06280734f, -0.08585123f, -0.05969074f, -0.27279717f, -0.10078954f, -0.43048525f, 0.24766873f, -0.05270554f, 
    0.07916774f, -0.07435748f, -0.09376213f, -0.04396037f, -0.01920335f, 0.12785526f, -0.03200940f, -0.12676348f, 
    -0.41293585f, 0.12040272f, 0.11835776f, -0.12913302f, 0.07829878f, -0.03357252f, -0.00392758f, -0.10731319f, 
    -0.07745360f, -0.05034212f, 0.03452178f, -0.11453892f, 0.03636252f, -0.10146636f, -0.03408678f, -0.01560479f, 
    0.13162428f, 0.04407989f, 0.01456411f, -0.04784856f, -0.17054909f, 0.02604132f, 0.07423630f, -0.15572691f, 
    -0.13519345f, 0.14469279f, 0.06867452f, 0.26771674f, 0.27171573f, -0.01146905f, 0.13021739f, 0.05204887f, 
    -0.06300033f, -0.04391191f, -0.01226772f, -0.07858260f, 0.27184999f, 0.22960095f, 0.34732765f, 0.30005676f, 
    0.12769818f, 0.12504879f, 0.09405932f, 0.12091603f, -0.05774400f, 0.05394057f, -0.04835993f, -0.02451745f, 
    -0.19014747f, -0.16533788f, -0.31821609f, -0.20989257f, 0.09864721f, -0.04000850f, -0.03064691f, -0.06285849f, 
    -0.16553323f, 0.03656711f, 0.09264622f, -0.01280216f, -0.28028384f, 0.03515085f, -0.21563858f, -0.15177897f, 
    -0.07760678f, 0.03973723f, -0.02417235f, -0.08758604f, -0.07622617f, -0.00796013f, -0.01422102f, -0.02031260f, 
    0.22409041f, 0.14456081f, -0.08822227f, 0.25526083f, 0.06785267f, -0.03757867f, -0.10035201f, -0.08331688f, 
    0.08950590f, 0.09157477f, -0.03140759f, -0.16135314f, -0.19650178f, -0.01436864f, -0.13887170f, -0.09485014f, 
    -0.12541252f, 0.04157519f, -0.09219969f, -0.15190870f, 0.03092476f, 0.15420878f, 0.07483521f, -0.08979562f, 
    0.14196615f, 0.25246924f, -0.03192097f, 0.25972575f, 0.13751280f, 0.07157154f, -0.03922012f, -0.00281874f, 
    -0.09918821f, -0.09601727f, -0.00597717f, -0.12316743f, -0.08445751f, 0.10336760f, -0.01898616f, -0.04766048f, 
    0.04548443f, 0.09287155f, 0.05412876f, -0.15659937f, -0.07939211f, 0.06271344f, -0.01440714f, -0.07851569f, 
    0.13121639f, 0.08311231f, 0.07031421f, 0.27403501f, 0.21924530f, 0.02423698f, 0.02075501f, -0.05084782f, 
    -0.10045385f, -0.03871374f, -0.10538017f, -0.14104341f, 0.03706811f, 0.14388138f, 0.05976018f, 0.36384827f, 
    0.16232948f, -0.14493407f, -0.13491429f, 0.00448602f, 0.04246081f, -0.01342121f, -0.05409943f, -0.07741728f, 
    0.26563102f, -0.25964364f, 0.06388019f, 0.01466488f, 0.17668486f, 0.05144843f, -0.04468681f, -0.04016767f, 
    -0.10803241f, 0.14591621f, -0.02220740f, -0.17577103f, -0.24878354f, 0.00487027f, -0.19236013f, -0.10308255f, 
    -0.08458961f, 0.11189655f, 0.05963103f, -0.09128428f, -0.15954247f, -0.12053622f, -0.00027895f, -0.12975319f, 
    -0.14923376f, 0.09991634f, 0.18744275f, -0.07715441f, 0.00052327f, -0.01878349f, -0.00157131f, 0.06312802f, 
    0.04272544f, 0.04416769f, -0.11838973f, 0.05421184f, 0.23312752f, -0.31304437f, 0.17756751f, 0.11049544f, 
    -0.16366100f, -0.23922551f, 0.00136783f, -0.09628575f, -0.04926095f, 0.02618918f, -0.01289486f, -0.05445725f, 
    -0.08963475f, -0.17754853f, 0.04591664f, -0.02467048f, 0.00232922f, 0.01091010f, -0.07677187f, -0.13457943f, 
    0.12701701f, 0.22339563f, -0.07735471f, 0.16838802f, 0.12510924f, -0.10667676f, 0.06371324f, 0.21834084f, 
    0.10626293f, 0.03176113f, -0.07561589f, -0.08808233f, 0.13557202f, 0.04352976f, 0.12117320f, 0.09778371f, 
    0.28036866f, -0.04873137f, 0.07006823f, 0.02159924f, -0.01961160f, -0.14010094f, -0.16464220f, -0.05612236f, 
    0.05366058f, -0.12352064f, -0.01197878f, 0.04891321f, 0.14611149f, 0.24698377f, -0.00401940f, -0.01237202f, 
    -0.27875176f, -0.03007007f, 0.05174687f, -0.15259007f, -0.06642797f, 0.07871315f, 0.07728466f, -0.05077983f, 
    0.29220784f, -0.07065692f, -0.04660954f, 0.16173951f, -0.01419858f, -0.04215328f, -0.09636900f, -0.21946247f, 
    0.10089150f, -0.13221976f, 0.04464283f, -0.15085718f, -0.09398273f, -0.04613233f, -0.11438596f, -0.21906288f, 
    0.13011427f, -0.03367007f, 0.03628851f, -0.03552512f, -0.08167335f, 0.15311058f, -0.01996472f, 0.17351604f, 
    -0.17384894f, -0.27588162f, -0.13266404f, 0.30507833f, 0.03313120f, -0.04168541f, -0.04306517f, -0.06538448f, 
    0.06016985f, 0.01620958f, 0.13789922f, -0.16804178f, 0.07445766f, 0.04101057f, -0.03668430f, -0.11011366f, 
    -0.01257031f, -0.06059001f, -0.08401205f, -0.15202142f, 0.10681331f, 0.12908621f, -0.09522092f, 0.04133637f, 
    0.49659756f, -0.00569492f, -0.58913451f, -0.15332440f, -0.07135516f, -0.01326029f, 0.11429323f, -0.11354974f, 
    -0.00847729f, -0.13374101f, -0.14951898f, 0.04022734f, 0.03763165f, -0.29869565f, -0.16927171f, -0.41370064f, 
    -0.13181214f, -0.23101920f, -0.08188950f, -0.03579123f, 0.01845689f, -0.04084421f, -0.09302545f, 0.00452944f, 
    0.03573933f, 0.00377156f, 0.10130408f, 0.15352184f, -0.06243285f, -0.13575190f, -0.06412051f, -0.03933470f, 
    0.21413489f, 0.15003693f, -0.07069246f, 0.17900722f, 0.25648335f, -0.16146663f, -0.04541479f, 0.21986406f, 
    0.03967813f, -0.20711172f, -0.09240360f, -0.08192414f, 0.04035297f, 0.03423341f, 0.07626032f, -0.16327232f, 
    0.15783648f, 0.00000320f, 0.19956207f, 0.10722034f, 0.02697022f, 0.05718573f, -0.16027652f, -0.21404091f, 
    -0.06757940f, -0.04537478f, -0.00860654f, -0.19524427f, 0.13970532f, 0.46645921f, -0.12468138f, -0.03024841f, 
    0.01750783f, -0.11578981f, -0.11735590f, -0.05198848f, -0.11630011f, -0.02205009f, 0.08579747f, 0.15595390f, 
    -0.21203063f, 0.19700865f, -0.08661958f, -0.49383479f, -0.16550311f, 0.04232914f, 0.04749529f, -0.05264773f, 
    0.08231511f, -0.07723305f, 0.05286931f, 0.17843708f, -0.03883912f, -0.32638380f, -0.00903434f, -0.02272017f, 
    -0.10104591f, -0.09725518f, -0.04800083f, -0.23310478f, -0.04225238f, -0.11769173f, 0.03108326f, 0.06822775f, 
    0.13603665f, -0.16244245f, -0.00047058f, 0.22861126f, 0.18380727f, -0.07325987f, -0.23395404f, -0.01089013f, 
    0.08594181f, -0.14988828f, 0.26910365f, -0.16251980f, 0.32135454f, 0.16009083f, -0.12511425f, 0.11165478f, 
    0.09003645f, -0.01589889f, 0.03017010f, 0.06674124f, 0.16810448f, 0.15477683f, 0.05461881f, 0.17533597f, 
    -0.30736202f, -0.03655351f, -0.00834967f, 0.23858267f, 0.04294957f, -0.12425423f, -0.12254609f, -0.06523790f, 
    0.16444586f, -0.12940723f, -0.07783718f, 0.15006134f, -0.29518086f, -0.07709662f, 0.05466694f, -0.12421361f, 
    -0.04057943f, -0.09136797f, 0.17066239f, -0.14543678f, 0.10302720f, 0.03901114f, -0.20161644f, -0.19241470f, 
    0.04484079f, -0.39295548f, -0.10986472f, 0.11785652f, 0.18027507f, 0.08178560f, -0.01724596f, 0.01615468f, 
    0.13778973f, -0.12584729f, 0.17132515f, 0.00850386f, -0.18719031f, 0.14896823f, 0.04680924f, 0.06116433f, 
    -0.16784447f, 0.10167337f, -0.06704323f, -0.13122544f, 0.07803468f, 0.09890492f, 0.05092013f, -0.10217363f, 
    0.12423176f, 0.15936624f, -0.24620575f, 0.03078053f, -0.05935607f, -0.09122941f, 0.09515219f, -0.03126565f, 
    -0.02601168f, 0.00874801f, -0.04555532f, 0.16522710f, 0.09110793f, 0.20191453f, -0.02374189f, 0.18148929f, 
    -0.15959951f, 0.07759554f, -0.05823513f, 0.03253197f, -0.06101595f, -0.02059608f, -0.09674848f, -0.06968301f, 
    -0.23538500f, 0.04523369f, 0.01608938f, -0.46172374f, -0.02756587f, -0.12145327f, -0.02728773f, 0.00071392f, 
    -0.11074769f, 0.15868156f, 0.04603133f, -0.24918340f, -0.25211680f, 0.21367463f, 0.27260140f, 0.16447656f, 
    -0.20112188f, 0.19474892f, -0.16525716f, -0.07587470f, -0.07032411f, 0.04764435f, 0.04723844f, -0.05454834f, 
    -0.10255846f, 0.00163458f, 0.25731206f, -0.09401580f, 0.25076205f, -0.09936064f, 0.18127795f, 0.03808891f, 
    -0.03510951f, -0.00485950f, 0.22572744f, 0.15371482f, -0.28650448f, -0.00078476f, -0.38663745f, -0.42327341f, 
    0.04894885f, 0.08789895f, -0.62717098f, 0.05260887f, -0.01342626f, -0.13160051f, 0.23532838f, -0.00714221f, 
    -0.11638095f, -0.19578899f, 0.27046663f, -0.15300618f, -0.06929553f, -0.07876746f, 0.04977188f, 0.09849581f, 
    0.06485015f, 0.02120702f, 0.05298862f, 0.01204951f, 0.13253529f, -0.12401929f, 0.03120751f, 0.22835876f, 
    0.17750870f, 0.01096553f, -0.01092001f, -0.10709818f, -0.12216293f, -0.06725440f, -0.00488233f, -0.22910219f, 
    -0.03381707f, 0.03908056f, 0.09716906f, 0.02037233f, -0.10544480f, -0.17501976f, -0.02151212f, -0.11296681f, 
    0.02981181f, 0.05682579f, -0.24893425f, -0.03798772f, -0.10956063f, 0.07053650f, -0.30687940f, -0.15198028f, 
    -0.23857501f, -0.10158968f, -0.11374924f, -0.09494010f, 0.18026266f, 0.01805910f, 0.10267532f, 0.11867902f, 
    -0.18160640f, 0.35509312f, -0.47583714f, -0.40367749f, -0.03560259f, -0.19054222f, 0.02330155f, -0.05742423f, 
    0.05100659f, -0.13714787f, 0.09597547f, -0.12330579f, -0.31441393f, 0.19899443f, -0.21875632f, -0.42645666f, 
    0.06093470f, 0.08142042f, -0.11875688f, -0.03798864f, -0.08567421f, -0.10434099f, -0.10237827f, -0.27893847f, 
    -0.15099712f, -0.10608980f, -0.10189425f, -0.18163221f, 0.09078375f, 0.04514380f, 0.13988271f, -0.02523999f, 
    -0.07002955f, 0.10715819f, 0.01502743f, 0.14272167f, 0.39023605f, -0.14866801f, 0.06634588f, 0.08058493f, 
    0.00670598f, 0.09149440f, -0.05822613f, 0.23333283f, 0.10097028f, -0.12652750f, -0.00418885f, 0.14335658f, 
    -0.86581284f, 0.48046848f, -0.09629442f, -0.22890368f, 0.09580109f, 0.00294729f, 0.03037713f, 0.17987408f, 
    0.00009078f, 0.11343142f, 0.03391425f, 0.00669839f, 0.11931918f, -0.32493803f, 0.04623290f, -0.29234248f, 
    -0.11313630f, 0.06218884f, 0.09221321f, -0.04408325f, 0.22222199f, -0.15545651f, 0.08682361f, -0.22243908f, 
    -0.23760457f, 0.14244564f, -0.12699635f, -0.46044290f, -0.05602427f, 0.09260469f, -0.11385731f, 0.02429411f, 
    -0.24015391f, -0.03863046f, -0.02132183f, -0.01132404f, 0.02012226f, -0.09816086f, -0.32217371f, 0.17530057f, 
    0.16693954f, -0.10134231f, -0.08821417f, -0.12284640f, -0.14799590f, 0.09470037f, -0.00245128f, 0.00157452f, 
    0.11701567f, 0.11444459f, -0.02942933f, -0.14785689f, -0.02730136f, -0.06659599f, -0.09675480f, -0.05999430f, 
    0.10300803f, 0.08495889f, 0.14965113f, 0.23466863f, 0.17338008f, 0.12428204f, 0.18968183f, 0.16629191f, 
    -0.04080074f, 0.01810514f, -0.12380540f, -0.15066493f, -0.09529281f, 0.07348505f, -0.00660614f, 0.03226294f, 
    0.32984757f, 0.13630542f, -0.11510142f, -0.22633713f, 0.30090004f, -0.00734243f, -0.20841658f, -0.08326391f, 
    -0.21611254f, -0.01195650f, 0.08436791f, -0.09737484f, 0.20192067f, -0.12178671f, 0.26647595f, -0.09699916f, 
    0.01738451f, 0.06295322f, 0.06155395f, 0.03865323f, 0.00707389f, -0.04124044f, -0.07338929f, 0.05557785f, 
    0.56757259f, 0.17094992f, 0.02277945f, -0.08199135f, -0.11723494f, -0.12874943f, 0.18790036f, -0.15565668f, 
    0.21763141f, 0.13041446f, 0.12448286f, 0.13529587f, -0.01086764f, -0.10528418f, 0.54229587f, -0.27766305f, 
    -0.02814924f, 0.02255199f, 0.16960323f, -0.04882479f, 0.11690670f, -0.04026243f, 0.05370863f, -0.05781503f, 
    0.16873077f, 0.22549213f, -0.29109213f, -0.00203541f, 0.05842319f, 0.01799665f, 0.00466507f, -0.14906958f, 
    -0.06065524f, 0.01534845f, -0.11472222f, -0.09764059f, 0.37756142f, 0.08410999f, -0.24323575f, 0.30364949f, 
    -0.12231577f, 0.04840310f, 0.03639424f, 0.12659949f, -0.02000393f, -0.13787207f, 0.01989096f, -0.01703238f, 
    -0.06746355f, -0.11477057f, 0.07637914f, -0.14298615f, 0.06130514f, -0.17053553f, -0.04959085f, 0.02749488f, 
    0.07264191f, 0.03555884f, -0.13045600f, 0.25070047f, 0.25268045f, -0.13399796f, 0.25429434f, -0.17777151f, 
    0.01586762f, 0.02842244f, 0.05496905f, -0.23230554f, -0.07383388f, -0.17644902f, 0.04550324f, -0.03269200f, 
    -0.27521822f, -0.68027627f, 0.04467690f, -0.09203569f, -0.09240616f, 0.01229666f, 0.11806919f, 0.23566845f, 
    -0.15494680f, -0.17781611f, 0.06135455f, 0.07494218f, -0.00192787f, 0.06245508f, -0.04721215f, -0.01776299f, 
    0.02461812f, 0.02750599f, -0.16984409f, 0.05309535f, -0.10581665f, 0.04285945f, 0.06276614f, 0.00716132f, 
    0.21610352f, -0.10916819f, 0.35247543f, -0.24646896f, -0.02528670f, 0.14710636f, -0.06302718f, -0.29176101f, 
    -0.15362322f, -0.08993705f, 0.02664680f, -0.01813406f, 0.15936683f, 0.28022769f, -0.04207255f, 0.13386115f, 
    -0.03385477f, 0.17332286f, -0.02130899f, 0.05666486f, -0.08810623f, -0.03942290f, 0.03494543f, -0.06290954f, 
    -0.30222246f, -0.02368452f, 0.14099139f, 0.10546063f, -0.03442762f, -0.18784791f, 0.02402497f, 0.09224677f, 
    0.14387898f, 0.10674406f, 0.18653318f, -0.08261929f, -0.40611908f, 0.43114501f, 0.21623677f, 0.21263726f, 
    0.05847505f, 0.06861118f, 0.02648270f, 0.12475469f, 0.01067247f, 0.08091301f, 0.09709036f, -0.03134532f, 
    -0.66997272f, 0.00608501f, 0.17315465f, 0.13402997f, -0.03861202f, -0.08011641f, 0.07586950f, 0.08380131f, 
    0.21088295f, -0.18176255f, 0.01044358f, 0.02528206f, -0.07783775f, -0.07994652f, 0.16501650f, 0.05555840f, 
    0.07844771f, -0.00733623f, -0.08359895f, 0.15253007f, -0.13499457f, 0.12278298f, -0.06256887f, 0.01507393f, 
    -0.20899168f, -0.21939975f, 0.07885945f, 0.16571106f, -0.02282313f, -0.13203675f, -0.17709574f, 0.09699830f, 
    0.01741499f, -0.00384588f, -0.03556143f, -0.23090346f, -0.04648550f, -0.20312692f, 0.14035404f, -0.28885508f, 
    -0.09953862f, 0.04690894f, -0.00508993f, 0.10221552f, -0.14083821f, 0.22732857f, -0.01575915f, -0.01936168f, 
    0.32545805f, 0.06842320f, -0.00210902f, 0.20389800f, 0.06748115f, 0.01885295f, -0.05525758f, 0.09077204f, 
    -0.07484482f, 0.06618450f, -0.03306811f, 0.18533733f, -0.47561416f, 0.36630425f, -0.21793616f, -0.18543018f, 
    0.07966408f, 0.05688426f, 0.00703125f, -0.20581219f, -0.01637972f, 0.00249139f, -0.01005620f, 0.04987016f, 
    -0.57453144f, -0.28052703f, -0.15375182f, -0.03234625f, 0.04502306f, 0.05529206f, -0.03244662f, -0.11404124f, 
    0.13725092f, 0.08373809f, 0.08375721f, 0.00237461f, -0.15108649f, -0.14209412f, -0.12080730f, -0.02591278f, 
    -0.13678943f, 0.05421034f, 0.06105119f, -0.12106925f, 0.11840288f, -0.05626309f, -0.07627059f, -0.06748829f, 
    0.29743409f, 0.14486429f, 0.05694890f, -0.26831147f, 0.01911343f, -0.01999668f, -0.06766468f, 0.21282196f, 
    -0.01270195f, 0.21464016f, 0.19814283f, 0.18548380f, -0.69574577f, -0.52981347f, -0.21107687f, -0.33771923f, 
    0.05837595f, -0.14779560f, -0.00461391f, -0.05013897f, 0.01504887f, 0.10174209f, 0.21331044f, 0.12216135f, 
    -0.01605595f, -0.02416998f, -0.17297517f, 0.03802635f, 0.05617502f, -0.09275693f, -0.21872480f, -0.02143897f, 
    0.06770033f, -0.33952659f, -0.04777213f, 0.00711124f, 0.03135019f, 0.03939819f, 0.13049749f, -0.06015728f, 
    -0.10171741f, -0.02781762f, 0.06965344f, -0.12028196f, -0.00280752f, 0.02586500f, -0.19649619f, -0.07739384f, 
    -0.56349134f, -0.38091165f, -0.13258806f, 0.07439107f, 0.20962882f, -0.14727633f, -0.00979725f, 0.04283897f, 
    0.12953809f, -0.01829532f, 0.09945002f, -0.06827791f, 0.05703023f, 0.13377362f, 0.06083674f, 0.04455242f, 
    0.19563861f, 0.01053505f, -0.07490961f, 0.20944795f, -0.07956550f, 0.16294478f, 0.16008291f, 0.22389120f, 
    -0.23222214f, 0.00141355f, 0.13082772f, -0.35410088f, 0.16952245f, 0.00545181f, -0.05502056f, 0.02283218f, 
    0.16455987f, 0.10006836f, 0.04948885f, -0.06099339f, 0.23423019f, 0.09432085f, -0.01778646f, 0.09348639f, 
    -0.11115295f, 0.11964382f, -0.09711973f, 0.18393408f, -0.15045622f, 0.13668308f, 0.00343231f, 0.08083072f, 
    -0.39318091f, 0.15241003f, 0.18979238f, 0.00462108f, 0.37709326f, -0.06103252f, 0.14143874f, -0.09808607f, 
    0.16691802f, -0.14300469f, -0.04528541f, -0.03654255f, -0.73828983f, 0.04130647f, -0.05938290f, 0.37530744f, 
    0.09295982f, 0.05903925f, -0.11279727f, -0.28858811f, -0.19734117f, -0.19410226f, 0.01119828f, -0.15338166f, 
    -0.63630760f, -0.16404195f, -0.18883982f, -0.18683667f, 0.13717000f, -0.11491860f, 0.11217386f, -0.03772183f, 
    -0.01504347f, 0.00859646f, 0.03772328f, 0.23364240f, -0.24460618f, -0.13752159f, -0.14884214f, 0.06264480f, 
    0.16550992f, -0.20078245f, -0.17553870f, 0.02889375f, -0.11073621f, 0.05874295f, 0.12727152f, 0.18362400f, 
    -0.27879661f, -0.04554665f, 0.22135025f, 0.06819379f, 0.02012776f, 0.05478560f, -0.08545046f, -0.16019230f, 
    -0.17454378f, -0.13782829f, -0.01842757f, -0.03352350f, -0.60436547f, -0.11609326f, -0.16797674f, -0.07005435f, 
    0.09762415f, -0.01292100f, 0.15798329f, -0.05899285f, -0.01812066f, 0.06587985f, 0.07084997f, 0.10924813f, 
    0.23589726f, 0.11883657f, -0.11340566f, -0.16517417f, 0.27717555f, 0.17523867f, 0.13649720f, -0.04628244f, 
    -0.03849718f, -0.01689584f, 0.08665452f, -0.00894043f, 0.15276696f, 0.12352073f, -0.21801896f, 0.21180314f, 
    0.00238593f, -0.04009856f, -0.03979005f, -0.01115666f, -0.03922489f, -0.16576751f, 0.13065480f, -0.09275206f, 
    -0.72267598f, -0.39315885f, -0.27202985f, -0.34336773f, 0.16569114f, -0.16501454f, -0.39241731f, 0.03248238f, 
    -0.00675180f, -0.16018985f, -0.14179115f, -0.15691091f, -0.33595815f, -0.08626652f, -0.10999407f, -0.03889624f, 
    0.01536376f, 0.07036866f, 0.01390736f, 0.16354614f, 0.19083019f, 0.14885588f, -0.01266117f, 0.00999190f, 
    -0.20525670f, 0.10972741f, 0.06410049f, 0.08267643f, -0.07542089f, -0.08444485f, 0.07905684f, -0.09973653f, 
    -0.06083177f, 0.20290546f, -0.00371902f, -0.02546011f, 0.36950046f, -0.02726221f, -0.07901895f, -0.06308184f, 
    -0.17143299f, -0.16428956f, -0.06297109f, -0.16571778f, 0.15600652f, -0.03917326f, -0.12090904f, -0.12159389f, 
    -0.51293570f, -0.13070424f, 0.27432677f, 0.03332815f, 0.21004736f, 0.10709757f, 0.10972349f, 0.15308104f, 
    0.06689946f, 0.19699238f, -0.08190695f, 0.18505317f, -1.04486966f, -0.58256882f, 0.22297797f, 0.15857898f, 
    0.18067585f, 0.05081656f, 0.06024922f, -0.06928102f, 0.10821277f, 0.05745109f, 0.03129150f, 0.19729611f, 
    0.14863643f, -0.06554789f, -0.02971605f, -0.06012090f, -0.19128419f, 0.09285825f, 0.03747464f, -0.01274834f, 
    0.14161402f, 0.13798955f, -0.04773476f, 0.12521832f, -0.00952931f, -0.14002596f, -0.14947674f, -0.09906153f, 
    -0.11496121f, 0.01385683f, 0.03483560f, 0.05281051f, 0.12933791f, -0.14158368f, -0.17270057f, 0.01199985f, 
    0.06713022f, -0.23749183f, -0.03916356f, -0.14719656f, -0.06022181f, -0.03819484f, 0.07476414f, -0.01705953f, 
    -0.08522651f, 0.05713533f, -0.06294990f, -0.21387495f, 0.11117383f, 0.03979364f, -0.06292155f, 0.07662739f, 
    0.09335385f, 0.15216754f, 0.02863674f, -0.08710421f, -0.13677043f, -0.11622168f, -0.00107690f, 0.05204528f, 
    0.06738365f, 0.02411684f, 0.17678005f, -0.21110284f, -0.17269534f, 0.02918656f, 0.09522620f, -0.08785380f, 
    -0.09215131f, 0.08370349f, 0.01937017f, 0.13581304f, -0.08166662f, 0.05144485f, -0.11880574f, 0.06916350f, 
    0.03471760f, 0.11379706f, -0.02474504f, -0.12556078f, -0.09640205f, 0.13653818f, -0.01005979f, -0.03398193f, 
    0.02544440f, 0.17783193f, -0.13285269f, -0.03948160f, 0.11618745f, 0.07663447f, 0.10695923f, 0.17440000f, 
    0.02232519f, 0.07738673f, 0.19693491f, 0.20449549f, -0.23523127f, -0.21272644f, -0.29034558f, -0.28421396f, 
    0.00225369f, 0.03779269f, -0.03855861f, -0.04774438f, -0.08456907f, -0.06134728f, -0.16895030f, 0.01459493f, 
    0.33976585f, 0.08878280f, -0.22603847f, 0.20170921f, -0.05461159f, -0.11320243f, 0.13943996f, -0.06798196f, 
    0.17650758f, -0.05228620f, -0.10930658f, -0.09293366f, 0.36500975f, 0.21724589f, -0.04901052f, -0.15115362f, 
    0.18456934f, 0.07034843f, 0.13817471f, 0.23388942f, 0.01431034f, 0.20756890f, 0.04226305f, 0.04638194f, 
    0.22850701f, -0.19147059f, -0.15723845f, 0.49917251f, 0.04108863f, -0.02942292f, 0.05311866f, 0.15414308f, 
    0.01656700f, 0.03068537f, -0.03194352f, -0.11019885f, 0.26092610f, -0.12603109f, -0.06914686f, 0.03405137f, 
    0.10067000f, 0.02393805f, 0.04294388f, -0.02304370f, 0.00664835f, -0.04120640f, -0.07038990f, -0.11587224f, 
    -0.26738861f, -0.18057215f, -0.12129191f, -0.37073666f, 0.06509729f, -0.05046545f, 0.01744075f, 0.06979311f, 
    0.17902657f, -0.00530592f, -0.06088639f, 0.09438547f, -0.36108121f, -0.20160422f, -0.06942542f, -0.12788719f, 
    0.02201336f, -0.11166010f, -0.03669478f, 0.10041329f, -0.18022315f, -0.10642951f, 0.12295620f, -0.13385718f, 
    0.13345997f, -0.33102560f, 0.06816024f, -0.08060798f, 0.17480955f, 0.08352097f, -0.01498805f, -0.12353655f, 
    0.00777269f, 0.09214064f, 0.10540240f, 0.02932163f, -0.23527437f, 0.13132612f, -0.09479054f, 0.05871730f, 
    0.05703721f, 0.14036445f, -0.05892206f, 0.10443593f, -0.03379587f, -0.11637920f, -0.39471981f, -0.13968778f, 
    0.57963926f, -0.05129780f, -0.29472822f, -0.08959259f, 0.10589483f, -0.00968837f, 0.01562602f, -0.10803888f, 
    0.07468329f, 0.12129598f, 0.00948609f, 0.02514611f, -0.27306709f, 0.18203168f, 0.12463824f, 0.16606006f, 
    0.15826163f, 0.00009262f, 0.13390099f, -0.14522019f, -0.07830230f, -0.14386486f, 0.12428714f, 0.11221471f, 
    0.62181008f, -0.27168444f, -0.14178190f, 0.15448533f, 0.09056503f, 0.05843383f, -0.06310189f, -0.14037262f, 
    0.17310677f, 0.02028039f, 0.07552132f, 0.01664811f, 0.33227363f, -0.07800382f, 0.20886771f, 0.04654933f, 
    -0.24139892f, 0.06426076f, -0.08800036f, -0.02755809f, 0.03606463f, -0.06846831f, 0.03465261f, 0.08742383f, 
    0.18393882f, -0.27369618f, 0.13574402f, -0.16810554f, -0.04340336f, -0.03846592f, -0.18833898f, 0.04748541f, 
    -0.16216329f, -0.08031633f, -0.01390386f, -0.06658354f, 0.21797097f, 0.00027547f, -0.16849835f, -0.08391886f, 
    0.02506885f, -0.06308975f, -0.00411511f, 0.12723325f, 0.00488510f, 0.00760020f, 0.01504162f, 0.10271176f, 
    -0.25729671f, -0.44036338f, 0.07825868f, 0.04189868f, 0.13896602f, 0.03296497f, -0.06535450f, 0.20153993f, 
    -0.09196826f, 0.05763499f, -0.09837160f, 0.11975560f, 0.08773880f, -0.44279316f, 0.02834492f, -0.05073803f, 
    0.07777967f, -0.03981453f, -0.20648012f, -0.07369582f, 0.13455322f, 0.17638600f, -0.10116015f, 0.16720466f, 
    0.00129168f, -0.14025177f, -0.37625644f, -0.02622076f, -0.13125178f, -0.07200879f, 0.09838779f, -0.00352603f, 
    0.01756677f, 0.08907083f, -0.10906047f, -0.12760933f, 0.03819015f, 0.04606513f, 0.25872236f, -0.03536014f, 
    -0.00690118f, -0.00763104f, 0.08280654f, -0.06125352f, -0.20858221f, 0.17923190f, 0.16061315f, 0.03809265f, 
    -0.28625911f, -0.14913662f, -0.16871887f, -0.41733843f, 0.04246353f, -0.05938221f, 0.02844000f, 0.11421245f, 
    0.18476133f, 0.04348788f, -0.19979788f, 0.12053601f, 0.12195180f, -0.30009252f, 0.01784235f, 0.20090449f, 
    0.00793464f, 0.00739129f, -0.03270812f, 0.13601086f, 0.08682001f, -0.06744742f, -0.09098049f, 0.09833795f, 
    0.07726850f, 0.09672642f, -0.11560237f, -0.07277509f, -0.30098283f, -0.04491314f, 0.05681608f, -0.12904750f, 
    -0.09064201f, 0.01992235f, -0.23335880f, -0.06564765f, -0.23591663f, 0.11485282f, 0.11054731f, 0.16391850f, 
    -0.00895881f, -0.05647172f, 0.04281482f, 0.05048397f, 0.09099924f, 0.01172160f, 0.13103831f, -0.03713316f, 
    0.61473769f, 0.25331885f, -0.23065655f, -0.14586727f, 0.02996927f, -0.04236735f, -0.07824326f, 0.08995764f, 
    0.03747653f, -0.05953901f, -0.08610903f, 0.03265502f, 0.13015239f, 0.14615691f, -0.11268067f, 0.00640393f, 
    0.15856884f, 0.02204004f, -0.03829862f, 0.03310453f, -0.10570052f, -0.15334123f, -0.08543271f, -0.01465454f, 
    -0.21247296f, -0.01696182f, -0.05027504f, 0.14922132f, -0.02950856f, 0.14801407f, -0.15501918f, -0.01149353f, 
    -0.16506729f, -0.01823211f, -0.08737545f, -0.26332641f, -0.58733636f, -0.22846253f, -0.00069338f, -0.09605653f, 
    0.03557008f, 0.04367030f, 0.19553861f, 0.03138199f, 0.06479494f, 0.04550854f, -0.12207888f, -0.07640407f, 
    0.27532890f, -0.14240788f, -0.19075760f, 0.09919623f, 0.11176798f, 0.12304204f, -0.03676523f, 0.00230964f, 
    0.05724009f, -0.12646684f, 0.27552322f, 0.12634265f, 0.30557477f, -0.13833208f, 0.05006813f, 0.02411144f, 
    -0.01609412f, -0.07506482f, 0.05814821f, -0.06163517f, 0.09455883f, 0.02111375f, -0.16055372f, -0.16230401f, 
    -0.32309148f, 0.21989332f, 0.08802339f, -0.04643898f, -0.16028395f, 0.04670773f, -0.21099894f, -0.24155010f, 
    -0.00763743f, 0.06072523f, 0.08649330f, -0.14734027f, 0.01982416f, 0.02119970f, -0.08336655f, 0.46449807f, 
    -0.01278933f, -0.08065946f, -0.03587497f, -0.08312503f, 0.13668215f, -0.11081055f, -0.04231102f, -0.12600547f, 
    -0.48463860f, 0.23400792f, 0.21898794f, -0.08356673f, -0.11263225f, 0.06523389f, -0.11735400f, -0.00498966f, 
    0.12361322f, 0.05543558f, 0.06653441f, -0.08124572f, -0.25790364f, -0.28072235f, -0.12220931f, -0.23111960f, 
    0.02931821f, 0.07476599f, 0.09328123f, 0.00504798f, 0.12801482f, -0.04898068f, -0.09632467f, -0.11349901f, 
    0.28969139f, 0.11811738f, 0.02919075f, -0.05279986f, -0.00860070f, -0.08178112f, 0.32214862f, 0.16342422f, 
    -0.11784933f, -0.03949684f, 0.03527581f, -0.09065244f, -0.29338771f, 0.07903083f, -0.40995142f, -0.06658615f, 
    -0.02723039f, -0.18327814f, 0.25235093f, 0.17462380f, -0.01991623f, -0.04797892f, -0.07952738f, 0.04170873f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08540180f, 0.05285954f, -0.08633493f, -0.00392770f, -0.00318640f, -0.03450812f, 0.00253337f, -0.14645302f, 
    -0.08307729f, -0.01344263f, 0.14395724f, 0.06934018f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
