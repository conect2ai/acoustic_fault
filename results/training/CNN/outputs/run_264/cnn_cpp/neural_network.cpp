#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.61854553f, 0.55717295f, -0.17576458f, -0.15577529f, 0.69580007f, -0.52816910f, -0.00190294f, 0.07449692f, 
    -0.33917180f, -0.64467192f, 0.38669837f, -0.07427010f, 0.55239588f, 0.92701048f, 0.56211984f, -0.29565665f, 
    0.25011566f, -0.03614802f, 0.66127157f, 0.48726648f, 0.63578373f, 0.10935407f, 0.44154954f, -0.52124035f, 
    0.25216630f, 0.34309801f, 0.08065560f, 0.03540825f, -0.43862531f, 0.66021073f, -0.56740195f, -0.30715960f, 
    -0.31907967f, 0.11571903f, -0.41176283f, -0.31529370f, 0.49732667f, 0.52759463f, 0.01031111f, -0.33613446f, 
    -0.15339075f, 0.51581883f, -0.21594605f, 0.44883958f, 0.64993232f, 0.80553669f, 0.60110402f, 0.28227001f, 
    -0.49627107f, 0.49646121f, -0.22103596f, -0.21813193f, -0.07037330f, -0.00328448f, 0.46879560f, 0.23300295f, 
    -0.31429064f, -0.03970162f, 0.59284049f, 0.53545415f, 0.37591174f, -0.50424474f, -0.67542803f, -0.71970308f, 
    -0.50998777f, -0.22522718f, 0.42344958f, 0.64803761f, 0.47827992f, 0.17618392f, -0.01283672f, 0.41234335f, 
    0.48494890f, -0.76621044f, -0.07700613f, -0.69102895f, -0.34851420f, -0.55889904f, 0.24601214f, 0.43931705f, 
    0.01628196f, -0.25596848f, 0.77312934f, 0.68160647f, 0.54165870f, -0.42461261f, -0.59155381f, -0.11718894f, 
    -0.21971020f, -0.03081370f, -0.39348486f, -0.50096530f, -0.07253116f, 0.35077682f, -0.03777203f, -0.49547058f, 
    -0.23192738f, -0.24764585f, -0.57829136f, -0.39892840f, 0.23657463f, 0.50553775f, -0.54505199f, -0.21055084f, 
    -0.64802319f, 0.12669696f, 0.01501205f, 0.23245324f, 0.09491058f, -0.66776019f, -0.64228231f, -0.12010849f, 
    0.28019542f, 0.22980328f, -0.36356372f, 0.00688640f, 0.36835036f, 0.10717329f, 0.29336426f, 0.15149356f, 
    -0.28502515f, -0.47714719f, 0.61277646f, -0.28602263f, -0.57340401f, 0.00893209f, -0.19058442f, -0.32541257f, 
    0.01980536f, -0.55788183f, -0.38708085f, 0.46718919f, 0.41081649f, 0.16054159f, 0.51323384f, -0.86297941f, 
    -0.57347494f, -0.40854338f, 0.00618576f, -0.35548794f, -0.04815266f, 0.13822174f, 0.38988474f, -0.13814962f, 
    -0.30420452f, -0.47139800f, -0.65971714f, 0.07087594f, 0.16245425f, 0.61406958f, -0.41046160f, -0.20446154f, 
    -0.54364860f, -0.03636223f, -0.60521656f, -0.51092565f, 0.03285794f, -0.60854971f, -0.37059692f, -0.48271704f, 
    0.36116588f, 0.59520197f, 0.46970731f, -0.78627563f, -0.20818558f, -0.25107113f, 0.56146365f, -0.36536917f, 
    0.40571144f, 0.06063741f, 0.19597222f, -0.38063970f, 0.26334110f, 0.52857256f, -0.37331572f, -0.49618122f, 
    0.22895557f, -0.77567703f, -0.01611050f, 0.08420514f, 0.57090044f, 0.08716744f, -0.88894850f, -0.27771235f, 
    0.30721295f, -0.63609767f, -0.15523033f, 0.40726736f, -0.32602450f, 0.73047960f, 0.24245104f, 0.72997218f, 
    0.57981765f, 0.00559527f, -0.52126992f, 0.21657129f, -0.04811643f, 0.09002440f, -0.65569633f, -0.50185847f, 
    -0.58726233f, 0.09077088f, -0.31756553f, 0.52407444f, 0.46045831f, -0.16758806f, -0.11919662f, 0.07438229f, 
    -0.39666915f, 0.07898569f, -0.47606796f, -1.01566100f, 0.21945336f, -0.08443779f, 0.64586806f, -0.45871186f, 
    -0.24737369f, 0.18759610f, -0.07995203f, 0.23831221f, -0.63510972f, -0.94194776f, -0.20259388f, 0.30917388f, 
    -0.17019227f, -0.25046852f, 0.17837390f, 0.39309907f, 0.30587050f, -0.01106224f, 0.42705810f, -0.46307614f, 
    -0.56008244f, -0.75563896f, 0.05136175f, -0.07634206f, 0.26922262f, 0.08641306f, -0.71111423f, 0.11155470f, 
    0.39753079f, -0.06003539f, 0.37633181f, -0.17099102f, -0.29406303f, -0.16828914f, 0.69213772f, 0.86986202f, 
    -0.62276572f, 0.24190333f, 0.19532217f, -0.08024301f, 0.53339475f, 0.71998739f, 0.46978548f, 0.14964433f, 
    -0.12704797f, 0.40202332f, -0.29857451f, 0.25583333f, -0.48361126f, 0.12445939f, -0.46762517f, -0.50138289f, 
    -0.28264821f, -0.57264405f, -0.46546781f, -0.32718480f, -0.51433259f, -0.06026506f, 0.12534367f, 0.44426596f, 
    0.35823771f, 0.55426764f, 0.26698059f, 0.50891751f, -0.05373897f, -0.29406819f, 0.56323934f, -0.39432865f, 
    0.54794794f, -0.83996272f, -0.01978308f, -0.10516035f, -0.29507533f, -0.22609404f, 0.18528445f, -0.08976431f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03476585f, -0.13158332f, 0.08845982f, 0.21466848f, -0.31704074f, 0.31628865f, -0.04660030f, 0.17840019f, 
    0.27030635f, -0.08627079f, -0.44361770f, 0.35996363f, -0.16387801f, 0.19321869f, 0.16126111f, 0.17253919f, 
    0.09385579f, 0.16258246f, 0.11954162f, 0.04312559f, 0.00469732f, -0.23013623f, 0.02711743f, -0.31841421f, 
    0.08226682f, 0.16033198f, 0.16000597f, -0.19496442f, 0.16891772f, 0.09622476f, -0.04948457f, 0.09314469f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01382042f, -0.05435463f, -0.01064178f, -0.02960315f, 0.02196445f, 0.03323288f, -0.01122272f, -0.02613234f, 
    0.04974851f, -0.06456587f, -0.06053384f, -0.04356795f, 0.02344176f, -0.00030410f, -0.04999816f, 0.00488218f, 
    -0.02297539f, 0.00191749f, -0.01183747f, 0.01060667f, 0.01274024f, -0.02836190f, -0.03687840f, 0.04706963f, 
    -0.05232875f, -0.03554224f, -0.01174848f, -0.03055893f, 0.04860666f, 0.01632773f, -0.03122225f, -0.05376625f, 
    -0.05035754f, 0.02108285f, -0.05133957f, -0.03186857f, 0.04568016f, -0.06389859f, -0.06619634f, -0.00174465f, 
    0.05467816f, 0.04298775f, 0.01960277f, 0.00494626f, 0.02059251f, 0.03180448f, -0.04952134f, -0.04742883f, 
    -0.01670870f, -0.00314460f, -0.01122767f, -0.05763525f, -0.01781807f, -0.00139442f, -0.04399214f, -0.04128922f, 
    0.01871854f, -0.05048377f, -0.01315016f, -0.00541380f, -0.06402499f, 0.03121951f, 0.02674689f, 0.02645311f, 
    0.04587045f, -0.05650516f, -0.00824516f, 0.02205257f, 0.03559261f, -0.02841458f, 0.01893564f, -0.05619457f, 
    0.05118882f, 0.00090139f, -0.05738702f, -0.00487455f, -0.05733336f, 0.00492158f, 0.00562213f, 0.02328741f, 
    -0.00760259f, -0.00646262f, 0.03495992f, -0.00734989f, -0.02907271f, -0.04389894f, -0.04053646f, -0.03042825f, 
    0.01129161f, 0.02108992f, -0.03897193f, -0.04934779f, 0.01779042f, -0.01011701f, 0.01539217f, 0.02086824f, 
    -0.02011347f, 0.01803060f, -0.00194666f, 0.02163544f, 0.00114940f, -0.00480617f, 0.04175257f, 0.04125094f, 
    -0.02765521f, -0.04030141f, -0.01613231f, -0.04362291f, 0.01705636f, -0.04236557f, -0.00280051f, 0.02520643f, 
    0.01597219f, -0.01296485f, -0.06003689f, -0.04595724f, -0.00864179f, 0.03017303f, 0.00691620f, -0.02256418f, 
    0.02557635f, -0.04324464f, -0.05871380f, -0.01256870f, 0.01462779f, 0.02267755f, 0.05582315f, -0.03981675f, 
    -0.04960220f, 0.03918745f, -0.00540320f, -0.05136546f, -0.05706167f, -0.00132852f, 0.04788704f, -0.01683742f, 
    0.04096551f, -0.01995422f, -0.06439249f, 0.05488883f, -0.03643084f, -0.05692812f, 0.00546187f, -0.02824706f, 
    0.03753350f, -0.04039802f, 0.01851325f, -0.06754380f, 0.04901937f, -0.03119736f, -0.05754511f, -0.02001531f, 
    -0.00043401f, 0.02288127f, 0.03551092f, 0.03411346f, -0.03879146f, 0.02852483f, 0.00875882f, 0.00208074f, 
    0.01493674f, 0.06059364f, 0.00108272f, 0.04679712f, -0.03049927f, -0.03479722f, 0.02164372f, -0.04083595f, 
    -0.04125430f, -0.02799571f, -0.01624523f, 0.01423871f, -0.05137762f, -0.05084610f, -0.03116444f, -0.06140945f, 
    0.06303207f, -0.00212368f, -0.00265981f, 0.01140211f, 0.00732610f, -0.03818462f, -0.00923708f, -0.00192701f, 
    0.01450148f, -0.05769329f, -0.01039816f, 0.02465096f, 0.03856562f, -0.01225205f, 0.00275678f, -0.04123150f, 
    0.03185021f, -0.05155570f, -0.00391949f, -0.03477751f, 0.00601229f, -0.05102839f, 0.01699829f, 0.00161855f, 
    -0.04799344f, 0.01034181f, -0.02401261f, 0.05745673f, -0.01861822f, 0.04742607f, -0.03029862f, -0.00088561f, 
    -0.01411397f, 0.05112187f, 0.01688565f, -0.03424738f, -0.00994526f, -0.02973004f, -0.04161376f, 0.00320649f, 
    -0.01330778f, -0.05382046f, 0.02404222f, -0.04137946f, -0.02328302f, 0.04175681f, -0.05666337f, 0.01302526f, 
    0.02991645f, -0.00984858f, 0.01828581f, 0.02025806f, -0.00512839f, -0.01851789f, -0.04757642f, -0.03130375f, 
    -0.02165381f, -0.04693262f, -0.04727180f, -0.04990502f, -0.04883032f, -0.03523060f, -0.00363140f, 0.02711847f, 
    0.02641930f, 0.01150913f, -0.02525784f, -0.01616114f, 0.00285187f, 0.03896910f, 0.05012810f, 0.01196918f, 
    -0.04079061f, -0.04048756f, -0.05977966f, 0.00166071f, -0.05602927f, -0.04497263f, 0.02492181f, -0.05473812f, 
    -0.00295379f, 0.00825874f, 0.01307658f, 0.01304997f, -0.02147749f, -0.00722877f, 0.03028386f, -0.03438706f, 
    -0.00863472f, -0.04573762f, -0.05727655f, 0.04208258f, -0.06929586f, 0.04451407f, -0.02260782f, 0.04104107f, 
    -0.03721157f, -0.03620928f, -0.02776725f, -0.03798033f, 0.02700911f, 0.01050132f, 0.00105817f, -0.06294609f, 
    0.01886081f, 0.05834077f, -0.04181093f, 0.01441599f, -0.02674937f, -0.04316728f, -0.00335531f, 0.03233725f, 
    0.25466758f, 0.14563300f, -0.02302201f, -0.07846581f, -0.11058705f, -0.01712454f, 0.03330592f, 0.06194223f, 
    0.03822522f, 0.03704777f, 0.08343741f, -0.21092407f, -0.10064575f, 0.06585322f, 0.09046408f, 0.03566116f, 
    -0.08538117f, 0.03919290f, -0.19164553f, -0.26368573f, 0.04457432f, -0.03286833f, 0.11651905f, 0.11748844f, 
    0.17833857f, 0.08209890f, -0.10288395f, 0.13561873f, 0.10131643f, 0.14503126f, 0.08966120f, 0.09731437f, 
    -0.15744181f, 0.11733294f, 0.06058380f, 0.16938196f, -0.52192014f, -0.19316962f, -0.06905628f, 0.02005300f, 
    0.22545466f, -0.10152072f, 0.08045837f, 0.00129979f, -0.25641459f, -0.17442313f, -0.04252741f, 0.14638925f, 
    0.09435702f, 0.02667317f, 0.09147856f, 0.05314305f, 0.01988943f, 0.03468832f, -0.34975359f, 0.13701862f, 
    -0.04064777f, -0.03488847f, 0.11553761f, -0.07480467f, -0.05907240f, 0.02091244f, -0.16945951f, 0.24341184f, 
    -0.03517430f, -0.17982548f, 0.03541728f, 0.01834684f, -0.07060750f, 0.18016997f, -0.01883578f, -0.02877108f, 
    0.13753678f, -0.05521492f, 0.00208847f, -0.02399268f, 0.06656288f, 0.02339882f, -0.01392173f, 0.10918672f, 
    0.04861610f, 0.04755091f, -0.08782498f, 0.01841186f, -0.02035730f, -0.03167479f, -0.14266513f, -0.10054698f, 
    0.05014120f, -0.21357642f, -0.18065315f, -0.46695933f, 0.22807883f, -0.12338057f, -0.02925807f, 0.00241308f, 
    -0.26667520f, 0.07320754f, -0.07497679f, 0.19690217f, 0.11999460f, 0.07821678f, 0.12839527f, -0.03124417f, 
    -0.15127864f, 0.08516755f, 0.03654089f, 0.03624114f, 0.02221767f, -0.18532230f, 0.36318314f, -0.02736877f, 
    0.06137133f, -0.07250876f, -0.04906280f, 0.02493288f, -0.13475493f, -0.04365456f, 0.10812977f, -0.07747874f, 
    0.11143360f, 0.01429659f, 0.17017657f, 0.19081599f, -0.12150897f, -0.07912626f, -0.00160494f, -0.02579975f, 
    -0.06493308f, -0.02304425f, 0.11038502f, -0.28543243f, 0.11704475f, -0.01893912f, -0.06728975f, -0.01570818f, 
    -0.12337328f, 0.04136914f, -0.04549453f, 0.08367609f, 0.11292086f, 0.09579813f, 0.03993417f, 0.07707099f, 
    -0.03075568f, -0.16066229f, 0.05771720f, -0.12671764f, 0.10491765f, 0.06410138f, -0.06988841f, 0.06963690f, 
    0.02574653f, 0.10321914f, -0.16725655f, -0.03367218f, 0.01032835f, -0.00703070f, -0.01882105f, 0.07311345f, 
    0.05856315f, 0.08214048f, -0.16825965f, 0.11384431f, 0.07939510f, 0.08457973f, -0.14775021f, 0.05109733f, 
    0.14190796f, 0.08881072f, 0.14742808f, -0.13008094f, 0.04834263f, 0.15018936f, 0.14254455f, -0.00503653f, 
    -0.00378423f, 0.05308822f, -0.01905754f, -0.12786520f, 0.02320215f, -0.09574023f, 0.16605480f, 0.00134822f, 
    -0.05002167f, -0.08925666f, 0.15829132f, 0.04784118f, 0.04907990f, -0.53824794f, -0.20666036f, -0.01636212f, 
    -0.11382464f, 0.01330795f, 0.08972875f, -0.00239336f, -0.02976594f, 0.12384637f, 0.04023892f, -0.23713325f, 
    -0.01355550f, -0.10744706f, 0.14208977f, -0.16948761f, 0.00434523f, -0.09580248f, 0.04292409f, 0.10474253f, 
    -0.13192113f, 0.02534267f, 0.07963290f, 0.07136945f, -0.01014010f, -0.04607094f, -0.02977479f, 0.03512823f, 
    0.27523765f, 0.01566495f, 0.20324561f, 0.09306523f, -0.07409077f, 0.03138800f, 0.02713098f, -0.06350846f, 
    -0.00463177f, 0.08657728f, 0.21676008f, -0.03157410f, -0.11013090f, 0.14704369f, 0.16691199f, 0.06624985f, 
    -0.01760321f, 0.02674012f, 0.01798258f, 0.01960380f, 0.06000778f, 0.01787638f, 0.05822356f, -0.17053226f, 
    0.20600389f, 0.13311000f, -0.08866643f, -0.08638540f, 0.01286288f, 0.02576630f, -0.03147120f, 0.01478398f, 
    -0.09970793f, 0.04789617f, 0.14271046f, 0.11365800f, -0.25426650f, -0.18813625f, 0.03693818f, 0.15239529f, 
    0.08386505f, 0.17029999f, -0.01315411f, -0.08333203f, -0.18772826f, -0.06257590f, 0.02081370f, 0.06153531f, 
    0.13561210f, 0.09941062f, 0.08419631f, -0.12341397f, -0.02523544f, 0.00413784f, -0.15188497f, -0.02127351f, 
    -0.24864236f, 0.06158423f, -0.08546243f, 0.11192312f, 0.13140085f, -0.11895934f, -0.23251042f, 0.18037736f, 
    -0.03175129f, 0.03889220f, -0.00550677f, -0.00958376f, 0.00442240f, 0.05349082f, -0.12091230f, 0.02256582f, 
    -0.05103288f, 0.01732030f, -0.05670283f, 0.01585991f, -0.03129451f, 0.04772011f, -0.03150834f, 0.02248575f, 
    -0.01025920f, -0.03345001f, -0.03850039f, -0.04287833f, -0.03830468f, -0.00662817f, 0.02772527f, 0.03234168f, 
    0.04506462f, 0.03118522f, 0.01862605f, -0.04296394f, -0.04535775f, 0.03942863f, -0.00545284f, -0.04441037f, 
    0.03373860f, 0.03789232f, -0.00422785f, -0.05752967f, -0.04916113f, -0.03383936f, 0.05300751f, -0.01753173f, 
    -0.02733978f, 0.03784203f, 0.04485054f, 0.01153930f, 0.05370904f, -0.02998386f, 0.00224478f, 0.00054499f, 
    -0.05947561f, 0.04901587f, 0.02739303f, -0.01089277f, -0.02489551f, 0.04047733f, -0.00602533f, -0.01230318f, 
    -0.03424688f, 0.04281862f, 0.04131695f, -0.03630627f, -0.00117163f, -0.02315986f, -0.02989423f, -0.02442795f, 
    -0.00840761f, -0.03394165f, 0.01692346f, 0.03595271f, 0.00998163f, -0.06217701f, 0.00935975f, -0.04610718f, 
    0.04133331f, -0.05713107f, -0.00750371f, 0.03549774f, 0.01690767f, -0.02745872f, 0.00461777f, -0.00871260f, 
    -0.05921227f, -0.00038244f, 0.02747931f, -0.03962027f, -0.02342095f, 0.02465444f, -0.03923639f, -0.03729399f, 
    -0.04158338f, -0.05353549f, -0.03497037f, 0.02810325f, -0.06592341f, 0.00811974f, -0.01973983f, -0.06421107f, 
    -0.03729849f, -0.00738924f, 0.01845528f, -0.04589307f, -0.05712094f, -0.03000804f, -0.03780687f, -0.03869657f, 
    0.00835856f, 0.02730767f, 0.03137887f, 0.00089503f, 0.04324865f, -0.04248151f, -0.03839447f, -0.01024982f, 
    -0.04659126f, -0.06449407f, -0.05484758f, 0.01467457f, -0.04852993f, 0.02458412f, -0.01967722f, 0.00803822f, 
    0.03402264f, 0.03894145f, -0.03738914f, -0.01319118f, -0.02692148f, -0.01005243f, 0.04922818f, 0.03068857f, 
    -0.05847830f, 0.03980226f, 0.00112789f, -0.03528541f, 0.04422015f, 0.03872699f, -0.05807448f, -0.03579236f, 
    -0.01499386f, -0.03852953f, 0.01413676f, -0.02759166f, 0.02178147f, -0.00237391f, -0.05061797f, -0.01895680f, 
    -0.05488400f, 0.04227592f, 0.01439283f, 0.02547072f, -0.01916654f, -0.04964585f, 0.02711613f, -0.03429757f, 
    -0.00522057f, -0.06561805f, -0.04564680f, 0.04413499f, 0.04139869f, 0.05391804f, -0.04431671f, 0.04693913f, 
    -0.02481750f, -0.04896973f, -0.05383756f, -0.05152589f, -0.03003646f, -0.01544737f, 0.01460398f, -0.06263269f, 
    -0.06280378f, -0.02369279f, 0.00606018f, -0.06359455f, -0.06127525f, -0.04472097f, 0.04588947f, -0.00904385f, 
    -0.00014103f, -0.02075733f, -0.04085865f, 0.03574024f, -0.02703561f, 0.02747579f, -0.05051686f, -0.03941014f, 
    -0.02850026f, 0.04464522f, -0.04794124f, 0.00585973f, 0.02832429f, -0.02906998f, -0.01497298f, -0.05012475f, 
    0.04424433f, 0.02729814f, -0.01525454f, 0.04214606f, -0.00555720f, -0.00246969f, 0.03376755f, 0.04097534f, 
    0.02258090f, 0.04052743f, 0.01256909f, 0.01467332f, 0.03867503f, -0.01458785f, -0.05633951f, 0.01193625f, 
    -0.00743937f, 0.00978633f, -0.04045475f, -0.05078127f, -0.06497105f, -0.03762916f, -0.02887095f, -0.00593210f, 
    0.03272089f, -0.01843321f, 0.03934907f, 0.00997215f, -0.05712609f, -0.03800648f, 0.02757836f, 0.01763864f, 
    0.00938446f, -0.00405333f, -0.03810074f, 0.02980624f, -0.03821377f, -0.03242273f, -0.03134573f, -0.02997545f, 
    -0.04281048f, -0.02852849f, 0.02332433f, -0.06283311f, -0.03511130f, -0.05730772f, 0.02593018f, -0.02639603f, 
    -0.05241143f, 0.04447811f, 0.03242884f, -0.01874249f, 0.02518944f, -0.06282533f, 0.03461523f, 0.02120615f, 
    0.02514858f, 0.01354882f, -0.02540907f, -0.02414635f, -0.03100364f, 0.01296117f, 0.01807694f, 0.04169157f, 
    -0.02048315f, 0.01781923f, -0.05750487f, 0.03342784f, 0.05012000f, -0.01471323f, -0.01592682f, -0.02622506f, 
    -0.04972089f, -0.04234211f, -0.01965147f, 0.04308981f, -0.01822738f, -0.00983637f, 0.01228160f, 0.01861927f, 
    -0.01334706f, 0.05167006f, 0.04618810f, 0.00078270f, 0.04783073f, -0.01314831f, 0.03252731f, 0.04922838f, 
    0.03912233f, 0.01697183f, 0.02398054f, -0.04629942f, -0.03006830f, -0.05156412f, -0.02061148f, 0.04207367f, 
    0.02014576f, -0.04010459f, -0.02763101f, 0.02790149f, -0.03993814f, 0.04470261f, -0.04276301f, -0.04235187f, 
    0.00935451f, 0.00332846f, 0.04527546f, 0.01262022f, 0.00936899f, 0.02190367f, -0.04939975f, -0.01946010f, 
    0.03367247f, -0.01330965f, 0.02074737f, 0.01221370f, -0.05133728f, -0.03505363f, 0.00304117f, 0.01173123f, 
    -0.04031990f, 0.03582151f, -0.03392049f, -0.06177326f, -0.03210295f, -0.00176817f, -0.03748138f, -0.01109466f, 
    0.02173072f, -0.01773202f, 0.03669583f, 0.03777685f, -0.04442167f, -0.01763337f, -0.01294724f, 0.00367349f, 
    -0.02679172f, 0.04267668f, 0.01178187f, 0.04374433f, 0.03430839f, -0.00727103f, -0.01574686f, -0.06279235f, 
    -0.00828278f, 0.01785880f, -0.02386052f, 0.04268739f, 0.02837305f, 0.04479525f, 0.03354090f, -0.04473794f, 
    0.04644036f, -0.03864771f, -0.00567726f, -0.03341870f, -0.04858924f, 0.03152821f, -0.00698335f, -0.02363393f, 
    -0.03570896f, -0.03017900f, -0.05609740f, 0.02900235f, -0.02055893f, 0.06497326f, 0.03715980f, 0.01266914f, 
    0.00481567f, -0.05385958f, -0.00042572f, 0.04075070f, -0.02106288f, -0.06095859f, -0.06048096f, -0.00833286f, 
    -0.01508857f, 0.04960002f, 0.03140384f, -0.00297759f, -0.02886221f, -0.02792935f, -0.03430785f, -0.01333953f, 
    -0.02363000f, -0.01764847f, -0.04310631f, -0.06098617f, -0.03791356f, -0.01847748f, 0.01510862f, -0.03425235f, 
    -0.03197951f, -0.01446724f, -0.04122561f, 0.04296752f, -0.01737561f, 0.01847717f, 0.01757451f, -0.04011092f, 
    -0.06343392f, 0.04334948f, 0.00231171f, -0.06588949f, -0.00279210f, 0.03997794f, 0.03790408f, -0.02956397f, 
    -0.04570803f, 0.00140654f, 0.03219109f, -0.05217281f, -0.02879616f, -0.01583830f, -0.03409192f, 0.00631681f, 
    -0.03278495f, -0.01902651f, 0.00795545f, -0.01543557f, -0.01659343f, -0.00567273f, -0.01045275f, 0.03999215f, 
    0.02198086f, 0.02203102f, 0.03397657f, -0.00063618f, -0.01392081f, -0.05173362f, -0.04404957f, 0.02460728f, 
    -0.04440358f, -0.03964368f, -0.03251673f, -0.02145655f, -0.06497727f, 0.04607449f, -0.05994343f, 0.02208642f, 
    -0.00412877f, -0.04544868f, -0.02567996f, 0.01641410f, 0.04221706f, -0.02145599f, -0.02411908f, 0.03678454f, 
    -0.01670533f, -0.04833876f, 0.01029757f, -0.03562571f, 0.03315239f, -0.02136269f, 0.04304550f, -0.01722447f, 
    0.02765256f, 0.00598277f, -0.05357543f, 0.03215639f, -0.02671460f, -0.03731878f, 0.04270815f, 0.02534805f, 
    -0.05448886f, 0.00789551f, -0.04218856f, -0.04365008f, 0.02077240f, -0.01042621f, -0.03926592f, -0.03535743f, 
    -0.03314301f, 0.00070377f, -0.05081102f, -0.00661836f, 0.03927785f, -0.02157231f, -0.00827918f, 0.02687004f, 
    0.01387901f, -0.01709279f, 0.02567880f, 0.04986054f, 0.01581996f, -0.02451513f, -0.01309657f, -0.03076447f, 
    0.02879941f, -0.04410144f, -0.04616274f, -0.05278026f, 0.03339460f, -0.00584077f, 0.01965711f, -0.01759249f, 
    0.04743836f, -0.05731491f, -0.00927766f, 0.02790192f, -0.00981170f, 0.05670629f, 0.02563120f, 0.00367146f, 
    -0.02626411f, 0.01011310f, 0.00235443f, 0.00405697f, 0.02894034f, -0.05760995f, -0.06627654f, -0.06647425f, 
    0.02962750f, 0.02896892f, -0.05197863f, -0.04253246f, -0.02812661f, -0.05134913f, -0.06118065f, 0.01313014f, 
    0.03478882f, 0.02760411f, -0.02107036f, -0.01639232f, 0.00687100f, 0.00768325f, 0.03479033f, -0.04943808f, 
    -0.04175210f, 0.01605384f, -0.05589537f, 0.03798895f, 0.01209641f, -0.03419649f, -0.01675520f, 0.01343533f, 
    -0.05770472f, -0.04333413f, -0.02829823f, 0.03078303f, 0.04462005f, -0.00142803f, -0.01243070f, 0.05954424f, 
    -0.01709647f, -0.02612854f, -0.05330099f, 0.00519901f, 0.04618941f, 0.01516862f, 0.05351135f, 0.01467583f, 
    0.02914315f, -0.05643672f, -0.03173492f, -0.00512978f, 0.04357888f, -0.01420487f, 0.03061203f, -0.06023967f, 
    -0.03287039f, 0.00051288f, 0.02908912f, -0.00559471f, -0.05645394f, -0.04141135f, -0.01919321f, -0.00735279f, 
    0.01985715f, 0.02678992f, 0.02969562f, -0.04277001f, 0.00611453f, 0.00140257f, -0.00222339f, -0.00534559f, 
    -0.01726677f, -0.04407577f, -0.06359641f, 0.00773484f, 0.02592762f, -0.03850324f, -0.00590929f, -0.05729195f, 
    0.02942123f, 0.04348443f, 0.03654639f, 0.00660644f, 0.02986664f, -0.04126064f, 0.00297907f, -0.05336134f, 
    -0.19392994f, -0.20884372f, -0.18176131f, 0.04920721f, -0.00237783f, 0.03256961f, 0.09323186f, 0.07502258f, 
    0.18311234f, 0.16474313f, -0.16330555f, -0.09505682f, 0.01953432f, -0.25648132f, -0.06970051f, 0.06286499f, 
    0.03015886f, -0.09677421f, 0.12054414f, 0.17026919f, 0.03188268f, -0.09429603f, 0.00955713f, -0.11831252f, 
    0.04577333f, -0.00377872f, -0.02517510f, -0.17884620f, -0.23765813f, 0.04236689f, 0.08881173f, 0.12657058f, 
    0.04308695f, 0.09774521f, -0.07565691f, 0.10396743f, 0.27247566f, 0.09159014f, -0.01519335f, -0.07763690f, 
    -0.10006534f, -0.14144239f, 0.05907039f, 0.07858381f, -0.03238196f, 0.01511886f, -0.22409430f, 0.01971129f, 
    -0.01058081f, 0.00838215f, 0.08591183f, 0.03315504f, -0.07942717f, 0.04494277f, 0.01097184f, 0.05294070f, 
    -0.26216507f, 0.14816928f, 0.06797964f, -0.06769581f, 0.01301511f, 0.07844252f, -0.18601242f, 0.00586037f, 
    -0.13653931f, 0.06186749f, -0.03939531f, -0.09534067f, 0.01343683f, 0.01255544f, -0.07330897f, -0.01343263f, 
    0.08389026f, 0.06417341f, 0.11415187f, -0.05346489f, 0.10876358f, 0.06254822f, -0.09794728f, 0.06336106f, 
    -0.07354879f, -0.10165381f, 0.05906931f, -0.04707243f, 0.12795903f, -0.14353199f, -0.06783302f, 0.06261333f, 
    0.07469651f, -0.01493973f, -0.27870515f, -0.03425037f, -0.03613940f, -0.00462250f, 0.10452315f, -0.02483183f, 
    -0.01783893f, -0.08081738f, 0.03967246f, -0.16231246f, -0.04483344f, -0.07448141f, 0.16308513f, -0.07690909f, 
    -0.00092470f, -0.02526490f, 0.02142535f, -0.01625847f, -0.48797435f, 0.16694814f, 0.11527164f, -0.02096717f, 
    -0.06818523f, 0.04646012f, -0.10545222f, 0.04854480f, -0.04184163f, 0.20245484f, 0.10293651f, 0.20801404f, 
    -0.07504844f, 0.01056510f, -0.06571920f, 0.06210716f, 0.07568411f, -0.06609612f, 0.07578615f, 0.00491789f, 
    0.17547217f, -0.02771191f, 0.09957448f, 0.09254184f, 0.03678356f, -0.01798605f, 0.02922793f, -0.44145608f, 
    -0.08553755f, 0.28692028f, -0.09774716f, -0.06258863f, -0.08402125f, 0.00456116f, -0.04324574f, 0.05876396f, 
    -0.05762244f, 0.00637670f, -0.07730048f, 0.07282826f, -0.02539363f, -0.09169113f, 0.00157519f, 0.09861214f, 
    -0.01437475f, -0.25402528f, 0.09943469f, 0.09155138f, -0.09312414f, -0.00339830f, 0.08214758f, -0.10822204f, 
    -0.07609429f, 0.00441739f, -0.17644088f, -0.05121956f, 0.06690331f, 0.02822945f, 0.03012550f, -0.00588034f, 
    0.04559419f, -0.07149169f, 0.06871762f, -0.09753632f, -0.20071192f, 0.13223861f, 0.08348063f, -0.05505279f, 
    0.06594841f, -0.17442268f, 0.02280577f, -0.04728164f, -0.11042330f, 0.32494709f, -0.21793412f, 0.00128549f, 
    -0.08905540f, 0.10239092f, -0.04492874f, 0.09289280f, 0.02914240f, 0.08316247f, 0.27785537f, -0.11114019f, 
    0.06485800f, -0.01640988f, -0.11686048f, 0.03069959f, 0.03718903f, -0.02952631f, -0.15914282f, -0.09105692f, 
    0.10446304f, -0.18769713f, -0.06188498f, -0.14122365f, -0.03101611f, 0.10481186f, -0.11198822f, 0.11772065f, 
    0.01415136f, -0.18316600f, 0.02354659f, -0.05803760f, -0.01621767f, 0.00784302f, 0.06600365f, -0.00799987f, 
    -0.21853609f, -0.13234724f, -0.15502244f, -0.08643003f, 0.10968779f, 0.06293452f, 0.02079417f, 0.05107755f, 
    0.02977288f, 0.13142730f, 0.01477708f, 0.08189897f, -0.16983083f, -0.12881111f, 0.02281759f, 0.16699611f, 
    -0.03533933f, 0.04948789f, 0.09611852f, 0.32760465f, 0.06789114f, 0.14029658f, -0.07581337f, 0.05267613f, 
    0.09298027f, 0.08022608f, 0.11521433f, -0.15887864f, 0.01811578f, -0.19689588f, -0.07647964f, 0.07085794f, 
    0.05934227f, -0.06695568f, 0.06455265f, 0.01445533f, -0.03038444f, 0.06231887f, 0.07500549f, 0.04511526f, 
    -0.05692184f, 0.00075141f, 0.10237762f, 0.06815685f, -0.00796499f, 0.06577358f, 0.04523377f, -0.00849724f, 
    0.07219107f, -0.07142878f, 0.06341445f, 0.04469502f, 0.06124772f, 0.08911318f, 0.11629940f, 0.29851565f, 
    0.10482080f, -0.04132447f, -0.07779592f, -0.03156198f, -0.01010642f, 0.02920998f, 0.01397610f, 0.10949825f, 
    -0.05893080f, -0.42759678f, 0.04634697f, 0.07483647f, 0.01041128f, 0.10341160f, -0.09026045f, -0.14047185f, 
    -0.12076212f, -0.04439287f, 0.04135158f, 0.11163490f, 0.08790740f, -0.15022597f, 0.07537775f, -0.04853181f, 
    -0.10013156f, 0.01130102f, -0.19439751f, 0.08991998f, 0.27684858f, -0.13137774f, 0.01662943f, 0.10450280f, 
    0.15577367f, 0.11557209f, -0.15406829f, -0.18242770f, -0.20261990f, -0.08203912f, 0.03565421f, -0.01072645f, 
    0.06909975f, 0.00820778f, 0.23317076f, 0.09379283f, 0.10080639f, 0.01661574f, 0.07925249f, 0.06899470f, 
    0.00364246f, -0.16374525f, 0.15677863f, -0.14082377f, -0.01327026f, -0.28442094f, 0.05924920f, -0.07346427f, 
    -0.13165003f, -0.24295378f, 0.11758263f, -0.19617574f, -0.02694085f, -0.16143045f, -0.23491806f, 0.09419221f, 
    -0.04622807f, 0.07598355f, 0.01791830f, -0.03894503f, -0.05228328f, 0.20713763f, 0.10033393f, -0.06511424f, 
    0.01443787f, -0.01354083f, 0.14653920f, -0.28350505f, 0.23673083f, -0.01979531f, 0.08853666f, 0.26028115f, 
    0.14943279f, 0.08948492f, 0.00750019f, 0.06933615f, -0.10488153f, 0.07710475f, 0.03489703f, 0.16747886f, 
    0.11468322f, -0.07883382f, 0.08195266f, 0.20928296f, -0.21978550f, 0.04676922f, -0.02884347f, -0.16026223f, 
    -0.24710707f, -0.23488371f, -0.11909811f, -0.10393206f, 0.00316501f, 0.03338832f, 0.16710268f, 0.03619249f, 
    -0.00789766f, -0.13560584f, 0.21742117f, -0.09320283f, 0.03468040f, -0.06678779f, 0.06856763f, 0.05173655f, 
    0.03703583f, -0.04251670f, 0.05697072f, 0.07902278f, 0.07194212f, -0.07895652f, 0.12277230f, 0.09854282f, 
    0.13842729f, -0.15946376f, 0.06417151f, -0.17273206f, 0.15275729f, 0.20873027f, 0.01769583f, -0.08552786f, 
    0.15346591f, -0.30332690f, 0.08059662f, 0.19699302f, 0.01823858f, 0.07217358f, 0.05965488f, -0.01347332f, 
    -0.00343920f, -0.08635661f, -0.00689608f, -0.19643524f, -0.01758558f, 0.10801251f, -0.03447497f, 0.06545305f, 
    -0.01057058f, 0.00465650f, -0.11062006f, 0.10840884f, 0.05122653f, 0.01734958f, -0.01199728f, 0.13295557f, 
    0.13507088f, -0.02407015f, -0.03155115f, -0.01690463f, -0.03763092f, -0.03408504f, 0.12090654f, 0.11675370f, 
    0.26776943f, 0.18058036f, 0.03844147f, 0.22999075f, 0.09151147f, -0.16726437f, 0.06201573f, 0.11531431f, 
    -0.08864079f, 0.20469163f, 0.14743881f, -0.05047140f, -0.00887333f, 0.04278115f, 0.16313851f, -0.02923805f, 
    0.11658710f, -0.11165138f, 0.06086549f, 0.00533731f, 0.06049169f, 0.22375716f, 0.07643283f, -0.07398099f, 
    0.21237002f, 0.00428492f, 0.03275323f, 0.07557306f, -0.08267627f, -0.09431987f, -0.12063783f, 0.06569165f, 
    0.06994265f, -0.13876726f, 0.14458615f, -0.02934333f, 0.01661508f, 0.08558173f, 0.22875388f, 0.06962485f, 
    -0.00973663f, 0.13108458f, -0.09640060f, -0.00615155f, -0.17891037f, -0.04031256f, -0.14219648f, -0.10904078f, 
    -0.14264855f, 0.14514349f, -0.06115642f, 0.07179213f, 0.07742184f, -0.08813823f, 0.01017741f, 0.21351588f, 
    -0.04340675f, 0.00621245f, 0.02827243f, -0.04157198f, 0.26045033f, 0.08443704f, -0.09158771f, 0.27217802f, 
    0.10370516f, -0.17558412f, -0.05361419f, -0.18709105f, 0.05919965f, -0.09561568f, -0.02315682f, -0.34076136f, 
    -0.04598224f, -0.07246450f, 0.04453751f, -0.05098991f, -0.00616217f, 0.03420064f, -0.12309480f, -0.01412238f, 
    -0.26461244f, -0.05772677f, -0.08429066f, 0.01298051f, 0.20967068f, 0.05235997f, -0.04593924f, -0.12464456f, 
    -0.10121258f, -0.00565674f, -0.00855976f, 0.00164553f, 0.12755482f, -0.00193624f, 0.02305928f, 0.03900983f, 
    0.28647530f, 0.04729686f, -0.10559820f, 0.31715968f, 0.03712000f, -0.13041742f, -0.14038844f, 0.06781520f, 
    0.03555217f, 0.21113428f, 0.09641341f, -0.04561350f, 0.15045404f, -0.06794380f, -0.04967770f, 0.03865048f, 
    -0.13745289f, -0.10244904f, 0.04844296f, -0.06231655f, 0.09041572f, 0.08684241f, -0.09091762f, -0.15761517f, 
    0.12506348f, 0.14062318f, 0.13505851f, -0.18873051f, -0.07219607f, -0.15513347f, -0.12829918f, -0.23473860f, 
    -0.13250789f, 0.09492330f, -0.21301799f, -0.09231035f, 0.00017676f, -0.11880189f, 0.22521192f, 0.24121493f, 
    -0.01130018f, 0.04432045f, -0.00539922f, 0.14436726f, -0.05505911f, -0.03139637f, -0.01813156f, 0.02520724f, 
    -0.14341238f, 0.14705515f, -0.08616497f, 0.21523507f, 0.03395020f, 0.22514148f, 0.09082199f, 0.03684701f, 
    -0.05846926f, 0.34592015f, 0.43523645f, -0.24507700f, 0.02890951f, 0.03849339f, -0.16656759f, 0.04587280f, 
    0.02144097f, 0.05953097f, -0.01667374f, 0.00755263f, -0.03360803f, -0.01683678f, 0.07705574f, -0.03472704f, 
    0.24186192f, 0.05533287f, 0.02408684f, -0.00669189f, -0.09904848f, 0.17009442f, -0.06992623f, -0.00980700f, 
    -0.07470489f, -0.01451743f, 0.10901288f, -0.00737481f, 0.09019211f, -0.09578871f, -0.18215908f, -0.11565677f, 
    -0.12128124f, 0.04012578f, -0.18502606f, -0.15363866f, -0.06369783f, 0.19831292f, 0.05470623f, -0.03794875f, 
    -0.16701326f, -0.01905295f, -0.05328011f, -0.01264916f, -0.08374690f, 0.08613737f, -0.17120427f, -0.12626809f, 
    -0.32399192f, 0.10300507f, 0.00956434f, -0.07748478f, 0.08540491f, 0.13695258f, 0.04884392f, 0.36173496f, 
    0.24918292f, -0.21508518f, 0.07113719f, 0.00174831f, 0.01395082f, -0.12875247f, -0.13069402f, 0.04151386f, 
    -0.54917049f, 0.10961726f, 0.25085124f, -0.11251091f, 0.09638377f, -0.05199432f, 0.06331706f, -0.10209012f, 
    0.07905582f, -0.15888153f, 0.43592650f, -0.05229915f, -0.18468766f, -0.28278196f, -0.05664082f, 0.00856614f, 
    -0.02102089f, 0.16921054f, -0.28181460f, -0.12551709f, -0.10598984f, 0.08073390f, 0.08617514f, 0.16180578f, 
    -0.29840121f, -0.18285127f, 0.19394331f, -0.08546904f, -0.12833285f, 0.08053927f, 0.07047340f, -0.02168459f, 
    -0.06886384f, 0.01349061f, 0.08241103f, 0.06828321f, 0.16596444f, -0.09771165f, -0.28485200f, -0.23396589f, 
    0.13798544f, -0.15024607f, -0.08017325f, 0.04619863f, 0.00726931f, 0.00365139f, 0.07822771f, 0.05194263f, 
    -0.12156230f, -0.09416588f, -0.12020084f, 0.04669978f, 0.15551096f, 0.02165847f, -0.27368918f, -0.33827537f, 
    -0.08718412f, 0.10276059f, -0.03157754f, 0.00196174f, -0.20510033f, 0.06538068f, 0.06957417f, -0.26922208f, 
    -0.01350653f, 0.05467185f, -0.05158255f, 0.01545531f, 0.10610494f, 0.06960576f, -0.18528304f, 0.04266583f, 
    0.36743084f, -0.31252897f, -0.20269074f, 0.00694902f, 0.04311198f, 0.09974830f, -0.07585156f, 0.31535441f, 
    0.17930359f, -0.22441278f, 0.10324768f, -0.04426065f, -0.11116612f, 0.14327897f, 0.02954324f, 0.03626540f, 
    -0.04657604f, 0.15922374f, -0.38091588f, -0.04344605f, 0.09074660f, -0.09377427f, 0.09397737f, -0.08691780f, 
    0.10342824f, -0.14486879f, 0.00259699f, -0.04519407f, 0.22939223f, 0.45233676f, 0.10388205f, 0.05431655f, 
    -0.13748458f, -0.03704599f, 0.04014748f, -0.02867600f, -0.32991117f, 0.13663654f, 0.02250613f, 0.17302968f, 
    -0.12050588f, 0.02295890f, -0.17555232f, -0.10322844f, 0.14698595f, -0.18962994f, 0.21038672f, -0.04791118f, 
    -0.12568846f, -0.01028852f, 0.04797540f, 0.15370452f, 0.07549405f, 0.05664745f, 0.29972398f, 0.00607842f, 
    -0.13811445f, 0.22398642f, 0.00823685f, 0.02969216f, 0.07849462f, 0.00159391f, -0.07431524f, -0.16190802f, 
    -0.05120575f, -0.04418729f, -0.12353405f, -0.14530650f, -0.08912187f, 0.13643816f, 0.07712688f, -0.19698091f, 
    -0.15195176f, 0.09204160f, 0.10226119f, -0.02715536f, -0.07378191f, -0.05998957f, 0.12827550f, -0.08010009f, 
    0.20924242f, 0.01778706f, 0.07837541f, 0.09603295f, -0.04618118f, -0.02147934f, 0.03003680f, 0.05906516f, 
    0.19493347f, 0.23980749f, 0.07373895f, 0.03135089f, -0.06544378f, 0.13187101f, 0.02800830f, -0.22012174f, 
    -0.03227226f, -0.13195030f, -0.04080391f, 0.06485943f, 0.18178354f, -0.22288944f, 0.12407281f, 0.20465659f, 
    0.30061749f, 0.09140838f, 0.08871492f, 0.10719276f, 0.20462084f, 0.19914281f, 0.00962965f, -0.37027249f, 
    -0.00946299f, -0.20642506f, -0.03451345f, -0.03946366f, 0.11751486f, -0.25744393f, -0.16121468f, 0.02448112f, 
    0.09440366f, 0.02949934f, -0.14602935f, 0.00248241f, 0.06370600f, 0.25247598f, -0.25006321f, 0.12318452f, 
    0.02553434f, 0.00875950f, -0.05627825f, 0.00448500f, -0.07271274f, 0.01545724f, -0.00023274f, 0.09513175f, 
    0.05955821f, -0.29730231f, 0.10750113f, 0.00359638f, 0.18814547f, -0.04040448f, 0.14821626f, -0.06388909f, 
    0.24734591f, 0.16369995f, -0.05886747f, 0.03673677f, -0.10691776f, -0.08273356f, -0.12335236f, -0.01217537f, 
    0.05712180f, -0.15494336f, 0.18045616f, 0.00227310f, 0.19374658f, 0.15403903f, 0.01420848f, -0.15941663f, 
    0.06394180f, 0.09911756f, 0.22947563f, -0.32070154f, 0.09517256f, 0.01034552f, 0.01789076f, 0.19916056f, 
    -0.03219562f, 0.09637117f, 0.08356170f, 0.15663165f, 0.10978846f, 0.13150509f, 0.01447354f, 0.08470611f, 
    0.16615918f, -0.04059263f, 0.22142465f, -0.03313744f, 0.02529914f, 0.04883252f, 0.19942328f, 0.08263609f, 
    -0.05834239f, -0.05709923f, 0.04410931f, -0.09575098f, 0.05820556f, 0.09163990f, -0.19356193f, -0.07671452f, 
    0.08137234f, 0.02178854f, 0.11622003f, 0.09646841f, 0.00832509f, 0.08057352f, -0.22543539f, -0.11306272f, 
    -0.13080344f, -0.03290618f, 0.16183966f, -0.12930447f, 0.00461672f, 0.02399380f, -0.08908175f, 0.07694589f, 
    0.17637178f, 0.11711451f, 0.09995660f, 0.05560860f, -0.06246705f, -0.02352926f, 0.05484736f, 0.19034520f, 
    -0.05204635f, -0.12209424f, 0.07176764f, -0.08423104f, -0.04658177f, -0.00646523f, 0.07965057f, 0.02137130f, 
    -0.16926996f, 0.19865860f, -0.34791225f, 0.17148048f, -0.00356880f, -0.09058327f, 0.04497294f, 0.01218264f, 
    -0.05198270f, -0.12470678f, 0.06363665f, -0.00613614f, 0.05483523f, -0.08297513f, 0.05444098f, -0.00676931f, 
    -0.29980242f, 0.01173762f, 0.15072948f, -0.08998953f, -0.04974100f, 0.11216737f, -0.12542002f, 0.03869921f, 
    0.19710031f, 0.07540583f, -0.03300647f, -0.10041908f, -0.03545945f, 0.11237206f, -0.16991504f, 0.15247802f, 
    -0.34472054f, -0.17672120f, 0.14233299f, 0.10111629f, -0.05260918f, -0.05558727f, -0.20262235f, -0.13656268f, 
    -0.11099518f, 0.05539022f, 0.04334074f, -0.01349505f, 0.02177248f, -0.08800691f, -0.23509404f, -0.04697683f, 
    -0.00412554f, -0.10003898f, 0.11135942f, -0.02284240f, 0.12109201f, -0.05164862f, 0.02842969f, 0.11532410f, 
    0.13804032f, 0.07906612f, -0.17815968f, -0.08085293f, -0.08401465f, 0.04989722f, -0.03503878f, -0.13645965f, 
    0.06375860f, 0.30226171f, 0.12756860f, 0.10441069f, 0.00723699f, -0.06607521f, -0.09111875f, 0.04514372f, 
    0.12567854f, 0.30256453f, -0.08073816f, -0.13719633f, 0.16087477f, -0.05975028f, -0.07729702f, 0.32541749f, 
    0.07120749f, -0.00109805f, -0.10712603f, -0.05894850f, -0.02648647f, 0.02235748f, -0.03971145f, 0.09168120f, 
    -0.03828443f, -0.05216379f, -0.00417066f, -0.19269733f, -0.12692785f, 0.09281013f, -0.19932428f, -0.01637983f, 
    0.02871375f, 0.02018213f, -0.09482170f, 0.18603505f, -0.12421357f, 0.09196060f, -0.09581426f, 0.02079236f, 
    -0.00961040f, -0.14457172f, 0.02068512f, -0.04652091f, -0.10332828f, 0.04319206f, -0.24262318f, -0.00934627f, 
    -0.06941555f, -0.07598060f, 0.16952251f, -0.08333115f, 0.03059998f, 0.10623458f, 0.08770379f, 0.03671752f, 
    -0.04411961f, -0.03712956f, 0.08633421f, -0.06195833f, -0.00252257f, 0.18448843f, -0.00968290f, 0.03062122f, 
    -0.09937596f, 0.01050517f, -0.09507034f, 0.00797334f, -0.00606248f, 0.08372324f, -0.01727878f, -0.18134169f, 
    0.07709281f, -0.48423594f, 0.20220041f, -0.04394984f, -0.04084634f, -0.06147995f, 0.07025213f, -0.02237520f, 
    -0.01866706f, -0.10383337f, -0.02286804f, -0.05672122f, 0.04003686f, 0.06950595f, 0.03311946f, -0.18166961f, 
    0.16894858f, 0.01572553f, -0.04167487f, -0.34423763f, 0.00317623f, 0.21120425f, 0.00680260f, 0.22562672f, 
    0.09793659f, -0.12358187f, -0.11640474f, 0.21841270f, 0.10008658f, -0.11664591f, 0.10779394f, 0.13510634f, 
    -0.12501998f, -0.07534828f, 0.08414219f, 0.05805812f, 0.11651058f, -0.10882077f, -0.05582905f, 0.10551365f, 
    0.04672490f, 0.01665872f, 0.00723406f, 0.03688826f, 0.07185215f, 0.32478687f, 0.21411861f, -0.25143939f, 
    -0.07466196f, 0.00306627f, -0.14729284f, -0.09225635f, 0.06422970f, -0.10542813f, -0.45504007f, -0.14125700f, 
    -0.06384166f, 0.05390627f, 0.07484586f, 0.00354308f, 0.15024196f, 0.10667932f, -0.14701720f, 0.30813092f, 
    -0.05783714f, 0.00630605f, -0.05315582f, 0.01607465f, 0.03708481f, 0.05057217f, -0.13523066f, 0.10405900f, 
    0.16992059f, 0.22286169f, -0.26583317f, 0.00886558f, -0.05781336f, -0.00455417f, -0.13150556f, 0.06327432f, 
    0.11285051f, 0.01105107f, 0.02961729f, -0.11389579f, 0.03913793f, -0.15187731f, -0.19722337f, 0.06732938f, 
    -0.05897591f, 0.02625915f, -0.39420319f, -0.07484858f, 0.11715750f, -0.01690616f, 0.07892676f, 0.01260309f, 
    0.02343268f, 0.10617244f, -0.04776446f, 0.06847187f, 0.11180117f, 0.13592738f, 0.08940220f, -0.02541076f, 
    -0.07395653f, -0.01919779f, 0.16957572f, -0.00084054f, -0.24508248f, -0.26301619f, -0.00041734f, 0.15385033f, 
    0.14784931f, -0.18299426f, -0.01720709f, -0.14857361f, 0.13734539f, -0.53779727f, -0.08265085f, 0.07688405f, 
    -0.05349268f, 0.13507342f, 0.02094069f, 0.12043659f, 0.01460498f, -0.02896276f, -0.03395834f, -0.16207725f, 
    -0.07354914f, -0.12807763f, 0.05240877f, -0.18686263f, 0.06562359f, 0.08722037f, -0.04528482f, 0.13572648f, 
    0.14752012f, -0.05929209f, -0.02172165f, -0.03181627f, 0.04024054f, 0.12551166f, 0.09656655f, 0.00661327f, 
    0.01116310f, 0.03041075f, 0.06894851f, -0.02820642f, -0.11351956f, 0.00898883f, -0.16813883f, 0.00814467f, 
    0.03868587f, 0.19520625f, -0.02207012f, -0.16274028f, 0.12170034f, -0.12036091f, 0.02738017f, -0.10505457f, 
    0.04748812f, 0.00721706f, 0.06279173f, 0.05307315f, 0.12370399f, -0.01410832f, 0.09790026f, 0.08654557f, 
    0.07512283f, -0.15485564f, -0.08580824f, 0.12388332f, 0.05555207f, 0.04171395f, 0.11899697f, -0.00773586f, 
    -0.13488510f, -0.08775070f, -0.07760495f, 0.11942184f, 0.05965158f, -0.00409565f, 0.05878548f, 0.03687806f, 
    -0.00340628f, 0.07393938f, 0.09969340f, 0.03014600f, -0.11105035f, -0.08953920f, -0.40138298f, 0.05422281f, 
    -0.01508680f, 0.15765131f, 0.10626723f, 0.21673276f, 0.01847092f, -0.03291229f, -0.04124151f, -0.15839437f, 
    -0.06449154f, -0.18062022f, 0.05732021f, -0.09051848f, 0.03257440f, 0.01609039f, -0.04439408f, -0.00686285f, 
    -0.08084355f, 0.18388638f, -0.04644510f, 0.03322862f, 0.01377063f, -0.07086650f, 0.09536554f, -0.00963495f, 
    0.02665406f, -0.04601588f, 0.19633074f, 0.05835130f, 0.07988027f, -0.00364941f, -0.10101043f, -0.12895162f, 
    0.06480563f, 0.19341426f, -0.02723861f, 0.09846699f, 0.00946619f, -0.10571142f, 0.01825455f, 0.03003822f, 
    0.07838091f, 0.09726873f, -0.14047962f, 0.17729458f, 0.02583182f, 0.00532917f, -0.16044141f, 0.03623618f, 
    -0.02727669f, -0.03436194f, -0.10438796f, -0.06563365f, -0.13077663f, 0.14681175f, 0.00173940f, -0.11668227f, 
    0.18421002f, 0.08612873f, -0.04960408f, -0.01735351f, -0.08171143f, -0.23999946f, 0.07108550f, 0.03437524f, 
    -0.00289295f, -0.04595555f, -0.00581976f, -0.03934911f, -0.00525950f, -0.55042690f, 0.00683036f, -0.09208161f, 
    0.12459049f, -0.10209925f, -0.00287973f, -0.05300876f, 0.13598931f, 0.20154342f, 0.02629865f, -0.10523216f, 
    0.19490163f, -0.02150588f, 0.02428756f, -0.05851723f, -0.03261584f, 0.10265063f, -0.02004293f, 0.07490658f, 
    0.05225478f, 0.10519713f, 0.09614098f, -0.04445557f, 0.11605401f, -0.07900382f, 0.04946928f, -0.03389045f, 
    0.43162262f, -0.07466080f, -0.11323197f, 0.07637329f, 0.05245810f, -0.01421915f, -0.01909497f, 0.10113545f, 
    0.04050390f, 0.19629930f, 0.05841833f, -0.04959985f, 0.03305111f, 0.09090255f, 0.07636128f, -0.01937673f, 
    -0.10536198f, 0.07919796f, 0.09461042f, -0.22243582f, -0.14191380f, 0.01658434f, 0.17346542f, -0.12464023f, 
    -0.12018765f, -0.02907014f, 0.20023370f, -0.11403703f, 0.19251756f, -0.20045313f, -0.12596619f, -0.01090452f, 
    0.02383297f, 0.07754594f, 0.16020729f, -0.06176409f, -0.31671253f, -0.14181770f, 0.08316571f, -0.07978769f, 
    -0.02386783f, 0.01138098f, 0.04931087f, -0.02070732f, -0.08677791f, 0.04261572f, 0.04733892f, 0.06983093f, 
    -0.00318002f, -0.02701635f, -0.05070971f, 0.10602679f, -0.21841905f, 0.04771913f, 0.10957383f, -0.06708380f, 
    -0.04227518f, 0.23397090f, -0.18126068f, 0.21836992f, -0.04865006f, 0.13381732f, 0.10255212f, 0.18193741f, 
    0.01578652f, -0.14610440f, -0.09698439f, 0.10994875f, -0.12384800f, -0.01045613f, 0.00307324f, 0.00485222f, 
    0.04709592f, -0.24387218f, -0.05360680f, -0.27452180f, -0.07497869f, 0.08010035f, -0.08055692f, 0.11968965f, 
    -0.02894549f, -0.10527539f, 0.06481171f, 0.14066902f, -0.08648928f, -0.04420150f, 0.02041044f, -0.23306820f, 
    0.08516581f, -0.14279582f, 0.08943333f, 0.04146744f, -0.01834987f, 0.11252619f, 0.12838483f, 0.05881652f, 
    -0.08450056f, 0.00828479f, -0.16452692f, 0.07076822f, 0.42140165f, -0.02071678f, 0.12028197f, 0.02346970f, 
    -0.10013901f, -0.10700120f, -0.04485182f, 0.02280506f, -0.08647181f, -0.08781170f, 0.17904660f, 0.09556761f, 
    0.06567561f, 0.11020528f, -0.01864641f, 0.14476560f, -0.07758005f, 0.17194977f, -0.16675766f, -0.04939581f, 
    0.16146621f, -0.01236912f, 0.02141783f, 0.03053303f, 0.00741206f, -0.24567260f, -0.02433526f, -0.41829047f, 
    0.07578525f, 0.04161191f, -0.08172978f, 0.04762213f, -0.00048683f, -0.06528317f, 0.11017994f, 0.03524838f, 
    0.08262954f, 0.19569357f, -0.07074065f, -0.17604093f, -0.09281168f, 0.11808459f, 0.07485063f, 0.01181909f, 
    0.39431456f, 0.30456936f, -0.28719702f, 0.16010830f, 0.01549204f, 0.00290856f, 0.02937277f, -0.02482393f, 
    -0.02936337f, 0.52222556f, -0.22560844f, 0.05653128f, 0.00860490f, 0.07180724f, -0.10064693f, 0.00086958f, 
    -0.14282404f, -0.12116033f, -0.37740791f, -0.16531049f, -0.35727301f, -0.18238160f, -0.04258312f, -0.00269089f, 
    0.06542554f, 0.03799839f, 0.04088974f, -0.07367567f, 0.10172527f, -0.11395705f, 0.03256030f, 0.08605435f, 
    0.06511023f, -0.00068436f, -0.08321874f, -0.01597475f, 0.38131925f, 0.05653591f, -0.04465188f, 0.08016538f, 
    -0.20276314f, 0.07260133f, 0.05205508f, 0.12893343f, -0.05916085f, -0.13124648f, 0.03771831f, 0.13950416f, 
    0.04873757f, 0.07479667f, -0.04157968f, 0.06992885f, -0.09114835f, 0.01356071f, 0.04047341f, 0.07606254f, 
    -0.02907733f, -0.04946079f, -0.03025595f, -0.16535085f, -0.01052035f, 0.17901148f, 0.14495131f, -0.05983359f, 
    0.18591280f, -0.02991002f, -0.11558851f, -0.17202227f, -0.10040404f, 0.01970516f, 0.06557891f, 0.03028311f, 
    -0.09827211f, 0.05345812f, 0.13287449f, -0.02387947f, 0.02130075f, 0.00004234f, 0.00166776f, 0.00029845f, 
    -0.05817492f, 0.12854935f, 0.11794243f, -0.07508338f, 0.09146599f, -0.27040300f, 0.01955699f, -0.00605906f, 
    0.05663222f, -0.09994123f, 0.03850068f, -0.20140105f, 0.03385027f, -0.06023703f, 0.03275134f, -0.09952704f, 
    0.00020997f, 0.21672723f, 0.09869325f, -0.31046224f, 0.17167564f, -0.06961899f, 0.07482857f, 0.12059767f, 
    -0.06367173f, -0.04804304f, -0.16354787f, 0.08445555f, 0.13757947f, 0.21529403f, -0.22237012f, -0.16213027f, 
    0.05904343f, -0.01928328f, 0.11449482f, -0.04094914f, -0.06470370f, -0.05900919f, 0.05728408f, 0.13044415f, 
    0.07437209f, 0.12703855f, -0.03812865f, -0.06745548f, -0.03943281f, 0.06467007f, 0.12519205f, 0.13928042f, 
    -0.09710305f, -0.12738648f, -0.11243834f, 0.03718555f, 0.02546807f, -0.05912270f, 0.13122205f, -0.42720535f, 
    0.28645477f, 0.13803126f, 0.22816125f, -0.14163640f, -0.02438273f, -0.12418204f, -0.20714055f, 0.09756327f, 
    0.04892300f, 0.12878998f, -0.08624520f, -0.05077785f, -0.08792884f, 0.01140225f, 0.01947051f, 0.08943311f, 
    -0.04656620f, -0.20470129f, 0.04224329f, -0.02776640f, 0.09548900f, -0.02304343f, 0.05246260f, 0.06068433f, 
    0.00013354f, 0.12572247f, 0.11429820f, 0.05321067f, 0.18274346f, -0.04997188f, 0.03813679f, -0.13056457f, 
    -0.03602299f, 0.03868013f, 0.03729026f, -0.12450682f, 0.01238301f, 0.07145453f, -0.08830090f, -0.09939349f, 
    -0.11552721f, -0.04653179f, 0.21775468f, 0.13142757f, 0.02295859f, -0.34781641f, -0.06649002f, 0.17165834f, 
    0.12594315f, 0.07678479f, 0.03982393f, -0.21557538f, 0.00692180f, 0.12282594f, 0.27784145f, -0.12681556f, 
    0.06135097f, 0.03823638f, 0.04005671f, 0.04766587f, 0.08964418f, -0.21662870f, -0.03056979f, -0.16930626f, 
    -0.04911763f, -0.09855186f, -0.00742910f, 0.10166888f, -0.03340942f, 0.12108473f, -0.14532587f, -0.09674363f, 
    -0.15043162f, -0.15218763f, -0.00651114f, 0.04385582f, 0.14915910f, 0.05782231f, 0.05516699f, 0.13261385f, 
    -0.01813993f, 0.04778165f, 0.02759892f, 0.03199987f, 0.01067217f, -0.02627415f, 0.02045473f, -0.03816001f, 
    0.03054824f, -0.09014685f, 0.00807712f, -0.03384692f, -0.08154747f, -0.00686491f, 0.02979825f, -0.02529224f, 
    0.02857271f, 0.01676216f, -0.03326947f, -0.01328562f, 0.00226048f, 0.00839523f, 0.00158927f, -0.05065933f, 
    -0.03013000f, -0.04327163f, -0.03944251f, -0.00728855f, 0.01951308f, -0.02523914f, 0.02110716f, 0.04208394f, 
    -0.07590624f, -0.05107209f, -0.02820550f, -0.02625794f, -0.00406208f, 0.02174021f, 0.02454276f, -0.00141698f, 
    -0.04779071f, -0.00425440f, -0.02345729f, -0.07224038f, -0.05160335f, 0.03159978f, -0.07845742f, -0.00041805f, 
    -0.03917071f, -0.00296396f, -0.02502907f, -0.05543111f, 0.05439344f, 0.06064805f, 0.03188036f, -0.03047426f, 
    -0.02058669f, 0.01681573f, -0.04305024f, 0.02351465f, 0.00670331f, -0.05601508f, -0.00925740f, -0.06342427f, 
    -0.06761478f, 0.03172435f, -0.01975300f, -0.00648822f, -0.02356033f, 0.01446143f, -0.01248919f, 0.02146331f, 
    -0.07368653f, -0.01119110f, -0.02159686f, 0.02434974f, -0.05203132f, -0.07098228f, -0.06173236f, -0.03512622f, 
    0.04208439f, -0.08424407f, -0.00610460f, -0.08643073f, 0.00702836f, -0.02242927f, 0.03712788f, 0.01027361f, 
    0.04555136f, -0.06501492f, -0.03035655f, -0.06091439f, 0.04772516f, 0.03418390f, -0.03876168f, -0.04496362f, 
    -0.03123593f, 0.07531526f, 0.00119567f, -0.01596591f, 0.01617436f, -0.01144320f, -0.01545849f, 0.04877458f, 
    -0.00926205f, -0.02982941f, -0.01668879f, 0.01867086f, -0.08166111f, -0.04370073f, 0.01467327f, 0.01718007f, 
    -0.04345337f, -0.09273896f, 0.06861931f, -0.04882833f, 0.01529102f, -0.00891877f, 0.01049290f, -0.03040347f, 
    0.01270867f, 0.00851220f, 0.01755667f, 0.03296542f, -0.05254190f, -0.00788313f, -0.05281886f, 0.01933567f, 
    0.01631416f, 0.05843978f, -0.04197073f, -0.03109578f, 0.00828659f, -0.05318683f, 0.00278280f, 0.02289195f, 
    -0.06981127f, 0.05997057f, 0.00508683f, 0.00623676f, -0.03258080f, -0.03703638f, -0.04522660f, -0.03389199f, 
    -0.02408913f, -0.05133561f, -0.06820498f, 0.00885507f, 0.00685036f, 0.00752704f, 0.01211282f, 0.03787757f, 
    0.03924458f, -0.06532697f, -0.05064566f, 0.03717874f, 0.03317311f, -0.04146004f, -0.07977170f, 0.01056644f, 
    0.03214939f, -0.03387794f, -0.06144439f, -0.03130999f, -0.02496200f, -0.03143800f, -0.01963898f, 0.00407797f, 
    0.01510145f, 0.03153093f, -0.03158223f, 0.04458875f, -0.06900485f, 0.02972854f, -0.05059062f, -0.01116004f, 
    -0.00981655f, 0.02553307f, -0.06818701f, 0.01458312f, 0.05434048f, 0.03511216f, -0.05421287f, -0.05041605f, 
    0.00642747f, -0.03915222f, -0.04541150f, -0.04878014f, -0.01357157f, -0.01989068f, -0.04450627f, 0.01198790f, 
    -0.05698075f, 0.01292485f, 0.01748107f, -0.05849940f, -0.04141572f, -0.00268127f, -0.05275147f, -0.02528306f, 
    0.04329744f, -0.04431611f, -0.04538021f, -0.08963136f, -0.04934821f, 0.00800029f, -0.05657095f, -0.01842913f, 
    -0.01818810f, 0.01864456f, 0.01360779f, -0.02432894f, -0.08854111f, -0.04415283f, 0.00406383f, 0.07104617f, 
    0.02555242f, -0.01709532f, 0.00447640f, -0.06042811f, -0.04728705f, 0.01928973f, 0.01868813f, -0.00372531f, 
    0.00099540f, -0.06422073f, -0.06939036f, -0.10602411f, -0.01281677f, 0.05351351f, 0.04273374f, 0.05438042f, 
    -0.05584617f, 0.00102528f, 0.01735169f, 0.04136854f, 0.02904307f, -0.01862547f, -0.02655814f, -0.00424485f, 
    -0.02464119f, -0.03681096f, 0.04654555f, -0.04312958f, 0.00172813f, 0.04811111f, -0.09700580f, -0.06376495f, 
    0.00492705f, 0.02258547f, 0.01615554f, -0.03809401f, -0.03631992f, -0.00710730f, -0.06212910f, -0.09723565f, 
    0.02417274f, 0.03075069f, 0.01810878f, 0.01413797f, -0.00617007f, 0.01251987f, -0.01815669f, -0.04118256f, 
    0.04114871f, 0.06050974f, -0.05460966f, 0.04649322f, -0.04970967f, -0.00561859f, 0.00862363f, 0.02495210f, 
    -0.03780734f, -0.00821725f, -0.01530250f, -0.00050872f, -0.01486247f, 0.02898215f, -0.01451884f, -0.04065398f, 
    -0.04115244f, -0.03723310f, -0.02613387f, 0.04240804f, 0.01415692f, 0.02175579f, -0.05931698f, 0.02130399f, 
    -0.03784705f, 0.02476507f, -0.06826700f, -0.04847929f, -0.05775493f, -0.02703134f, -0.00492333f, 0.02369126f, 
    0.03885358f, -0.05497017f, 0.03549952f, 0.01956418f, 0.01525528f, 0.04143056f, 0.04940656f, 0.00991669f, 
    0.00566590f, 0.01593694f, 0.03557302f, -0.04653892f, 0.00508183f, -0.02905446f, -0.06414948f, 0.03363581f, 
    0.01196961f, 0.02912557f, -0.00475767f, -0.05637614f, -0.01071432f, 0.04742036f, 0.00674447f, -0.02793910f, 
    -0.04196803f, -0.06178718f, 0.03973094f, -0.04013955f, 0.01453820f, -0.00074252f, -0.01845601f, -0.04677812f, 
    0.00350150f, 0.01184612f, -0.04906360f, -0.01150557f, 0.04233483f, 0.00240496f, -0.05982212f, 0.03085510f, 
    -0.05104081f, -0.05663669f, -0.06553496f, -0.03099173f, -0.00664924f, 0.01810284f, -0.05036444f, -0.00648242f, 
    -0.02846704f, -0.00085889f, -0.06424254f, 0.03693682f, -0.03862726f, -0.00045414f, -0.00007710f, -0.02195264f, 
    -0.01104400f, -0.04174684f, 0.01059859f, 0.01571450f, -0.01369716f, 0.01951039f, 0.01226441f, -0.01488360f, 
    0.02401376f, 0.01377935f, -0.02888009f, -0.06401240f, -0.04863255f, -0.06586091f, -0.00998275f, -0.04845797f, 
    0.03826706f, 0.00356074f, -0.01696161f, -0.04326208f, 0.04354040f, -0.03651497f, -0.05400010f, -0.01142431f, 
    -0.02810313f, 0.02851256f, -0.06039587f, 0.01427175f, 0.03931293f, -0.01004773f, 0.00473290f, -0.00771604f, 
    -0.03509163f, 0.03479024f, -0.03372300f, 0.01395052f, 0.01074683f, 0.00146717f, -0.04171337f, -0.02274573f, 
    -0.00431984f, 0.04445539f, -0.03121201f, -0.01110484f, -0.05241429f, 0.04364706f, -0.00546623f, 0.00616868f, 
    0.04242601f, 0.00410007f, -0.03844678f, -0.06492752f, -0.00925357f, 0.01015819f, -0.03624282f, 0.04628877f, 
    -0.00871509f, 0.02468569f, 0.03938866f, 0.02934722f, 0.03907732f, 0.00733916f, -0.03680296f, -0.05269148f, 
    -0.05506741f, 0.02653826f, 0.02720814f, -0.04163459f, -0.04489594f, -0.04486391f, 0.00598220f, -0.00256006f, 
    0.02105238f, -0.05707547f, -0.02658049f, 0.03351562f, -0.04638272f, -0.06503948f, -0.06156592f, -0.04938392f, 
    -0.00076793f, -0.00104052f, 0.00290787f, -0.05331574f, 0.05275174f, -0.00613177f, 0.01403845f, -0.00523075f, 
    0.03968411f, -0.02339464f, -0.01060958f, -0.01189131f, -0.05080263f, -0.02066371f, 0.01198684f, -0.06560363f, 
    -0.00254127f, -0.05763828f, -0.01259560f, 0.03632641f, -0.04862354f, -0.01834396f, 0.04941504f, 0.03790540f, 
    -0.01319358f, -0.05617379f, -0.06160951f, 0.02613028f, -0.04935028f, -0.05700598f, -0.05581496f, -0.00753561f, 
    0.00351705f, -0.03191576f, -0.04301374f, -0.05191327f, 0.02113468f, -0.00180345f, -0.00383828f, -0.01695803f, 
    0.03252803f, -0.03674124f, -0.02270216f, 0.00512471f, -0.06363408f, 0.02649751f, 0.00133273f, 0.03675389f, 
    -0.01259041f, -0.03344027f, 0.03324093f, -0.03959301f, -0.01768803f, 0.01092164f, 0.04938293f, -0.01805275f, 
    0.02090044f, -0.03269937f, -0.06032131f, 0.04723464f, -0.03897483f, -0.03829836f, -0.03457383f, -0.01429126f, 
    0.01447892f, -0.01652397f, -0.06082058f, 0.03327839f, -0.00746017f, 0.05448747f, -0.05368630f, -0.03047564f, 
    0.04621173f, 0.01778665f, -0.03659308f, -0.06596228f, -0.02762732f, 0.03021058f, -0.06296168f, 0.01874095f, 
    0.01320068f, 0.04155004f, 0.02761722f, -0.01860274f, 0.03261663f, -0.04149422f, 0.01356509f, -0.03346490f, 
    0.02623367f, 0.00081806f, -0.03364099f, 0.02921230f, 0.00307651f, 0.03638409f, -0.04171490f, -0.04051375f, 
    -0.04688000f, -0.01614725f, -0.04662663f, -0.02488326f, 0.00750674f, -0.06753460f, -0.02184378f, -0.02416070f, 
    0.00029326f, 0.03420781f, 0.03376226f, -0.04463876f, 0.02767862f, -0.00546476f, 0.04580276f, 0.04272266f, 
    0.04221146f, -0.01978652f, 0.01161698f, -0.00561701f, -0.03231626f, 0.00125473f, -0.04884643f, 0.01081013f, 
    -0.04568585f, -0.05749898f, -0.04366159f, 0.00015050f, 0.01743706f, -0.04768134f, -0.00982782f, -0.02995144f, 
    0.01591305f, 0.04777782f, 0.03335712f, 0.01990068f, 0.03270284f, 0.01167871f, -0.00235205f, 0.05144573f, 
    0.03986859f, 0.04426197f, 0.04842259f, -0.02747584f, -0.04543911f, 0.00442724f, -0.01659444f, 0.00585648f, 
    -0.23385051f, -0.30749679f, -0.14813921f, 0.02595029f, 0.10364828f, 0.08745040f, 0.10986250f, -0.06464709f, 
    0.03075371f, 0.04678968f, 0.14777978f, -0.10239729f, 0.01237161f, -0.06680234f, -0.17915441f, 0.07798872f, 
    0.06169991f, -0.02907494f, 0.02852925f, 0.03602875f, 0.05198450f, -0.05722579f, 0.00132076f, -0.03566011f, 
    -0.09085289f, 0.00110001f, 0.12805071f, -0.23481160f, -0.11804827f, 0.05189120f, 0.05820895f, 0.01646688f, 
    0.04501441f, -0.00547725f, 0.07610244f, -0.05186097f, -0.11593026f, 0.18655711f, -0.12480972f, 0.18528621f, 
    -0.14962420f, -0.20537645f, 0.01174487f, 0.07476458f, 0.16760883f, 0.19489031f, 0.09921238f, -0.01175261f, 
    -0.08788306f, -0.02816179f, 0.10182862f, 0.00713636f, 0.12755077f, -0.02798023f, 0.05842979f, -0.07650535f, 
    -0.13215071f, 0.09599207f, -0.05261170f, -0.07188170f, 0.08489097f, 0.09445558f, -0.06178436f, 0.18550466f, 
    0.30588648f, -0.15564013f, 0.03426719f, 0.03157067f, 0.07110965f, -0.08823080f, -0.01771423f, -0.10188518f, 
    -0.01564833f, -0.10187825f, 0.24421963f, 0.03911481f, 0.06450983f, 0.20251831f, -0.00826115f, 0.06704669f, 
    0.05979787f, 0.04567859f, -0.08883418f, 0.12413095f, -0.06374753f, 0.00059198f, 0.07619589f, -0.05465037f, 
    0.03434871f, 0.04886230f, -0.04275664f, 0.10155174f, -0.22887702f, 0.05203552f, -0.03002784f, -0.01187631f, 
    -0.01046755f, 0.12290698f, -0.23403420f, 0.03439649f, 0.00440241f, -0.27903017f, 0.23581745f, 0.02352928f, 
    0.05313933f, -0.05827732f, 0.00551492f, 0.20972769f, -0.16111510f, -0.27944303f, -0.12912889f, 0.05260622f, 
    0.04447660f, -0.18013997f, 0.06352671f, -0.04103536f, 0.08714692f, 0.03064846f, 0.13853103f, -0.13722277f, 
    0.05884074f, -0.05388610f, -0.01324311f, -0.07969707f, 0.07215305f, -0.25233483f, 0.05318232f, 0.02783589f, 
    -0.06698628f, 0.09538779f, -0.01113575f, 0.05987804f, 0.01711025f, -0.04994500f, 0.00799508f, -0.10835131f, 
    0.10990055f, -0.09762672f, 0.03503990f, 0.01152589f, 0.09808440f, 0.03274377f, 0.03543924f, -0.02145753f, 
    0.19834727f, 0.01908463f, -0.28674185f, 0.14893480f, -0.13410078f, -0.04603279f, 0.13743448f, 0.01514103f, 
    -0.01194751f, -0.08494076f, -0.04127406f, -0.05178527f, -0.16922094f, 0.18343490f, 0.02772646f, 0.07608205f, 
    0.11113584f, 0.13439961f, -0.12487772f, -0.39482349f, 0.23364899f, 0.07532088f, -0.03893810f, -0.08744561f, 
    0.04266147f, 0.02341251f, 0.16868046f, 0.06122105f, -0.01880767f, -0.13621205f, 0.09821104f, -0.06213497f, 
    0.01389428f, 0.01977780f, -0.05973413f, -0.07974064f, 0.12010982f, -0.18865858f, 0.00892646f, 0.02584448f, 
    -0.03155987f, 0.07149830f, -0.06411576f, -0.05231456f, -0.13408002f, -0.31977642f, -0.07035633f, 0.24683854f, 
    -0.01800143f, 0.14119761f, 0.00095594f, -0.06340837f, -0.12178096f, 0.14657693f, 0.11676943f, 0.31562999f, 
    -0.06677452f, -0.01453152f, -0.17676634f, 0.07625309f, 0.16629259f, 0.08681598f, -0.04104863f, -0.22860868f, 
    0.11905240f, 0.15579958f, 0.09502890f, -0.20807871f, 0.20448695f, -0.04183723f, 0.01634623f, 0.15584983f, 
    0.03904089f, -0.09693902f, -0.11181281f, -0.00592168f, 0.07390331f, 0.02213052f, 0.00485169f, -0.09944040f, 
    0.19830467f, 0.04928384f, -0.00132361f, -0.05501860f, 0.11860382f, -0.03591899f, -0.10212509f, 0.10504606f, 
    0.10929126f, -0.12367863f, -0.10257933f, 0.11837420f, 0.19168743f, -0.10437006f, 0.07392116f, -0.03865970f, 
    0.03147237f, 0.00953857f, 0.08914578f, -0.03509206f, -0.18290390f, 0.11342327f, -0.16434774f, 0.09455222f, 
    0.06047485f, -0.00610085f, 0.04713777f, -0.08300310f, -0.01760324f, 0.01544842f, -0.02590752f, 0.06021749f, 
    -0.09699526f, 0.03704052f, -0.09002862f, 0.07683853f, -0.03792463f, -0.09003559f, -0.12901036f, -0.09900628f, 
    -0.07403047f, 0.12130352f, 0.04888608f, -0.10684175f, -0.02472492f, -0.02108061f, -0.03689331f, 0.06454114f, 
    0.20533934f, -0.07934413f, 0.00962260f, 0.02977230f, -0.03631085f, 0.07118851f, -0.09017501f, 0.15298943f, 
    -0.13997595f, -0.31021869f, 0.03444416f, 0.02155705f, 0.06252184f, 0.06660609f, -0.03806842f, -0.02005584f, 
    0.07368390f, -0.10457976f, -0.26165205f, -0.22031647f, -0.07670828f, 0.06792530f, 0.02427028f, -0.07120404f, 
    -0.02114346f, 0.18444164f, 0.00434876f, 0.02271892f, -0.00303149f, 0.05235475f, 0.02928686f, -0.22661261f, 
    0.00065750f, -0.02486050f, 0.03273601f, 0.11533838f, -0.10968459f, 0.15251283f, 0.09253308f, -0.01763210f, 
    -0.07071330f, 0.14674722f, -0.02639561f, -0.06549568f, -0.09020337f, 0.01305127f, 0.02930677f, 0.03759015f, 
    -0.11575295f, 0.09470456f, -0.07623085f, 0.10142842f, 0.22074619f, 0.00638231f, 0.18745357f, 0.07955968f, 
    -0.06734044f, -0.00245163f, 0.11040351f, -0.05153202f, 0.04705572f, 0.04027035f, -0.10178571f, -0.06274246f, 
    0.13725621f, 0.00437453f, -0.06391773f, -0.07342983f, 0.05016318f, -0.00270649f, 0.04044287f, 0.07364323f, 
    0.04130956f, 0.03986476f, 0.00408941f, -0.07821027f, -0.01808651f, -0.04876002f, -0.03684141f, 0.11177130f, 
    -0.07538708f, 0.20604426f, -0.28834018f, -0.09756424f, 0.06196140f, -0.04576596f, 0.02096670f, 0.03638923f, 
    0.05379888f, 0.09459813f, 0.06490261f, -0.02425208f, 0.07519850f, 0.02496413f, -0.05726089f, 0.13896777f, 
    -0.19183332f, -0.00751234f, -0.20187713f, -0.08425807f, 0.06351262f, 0.07032069f, -0.10943588f, -0.06769800f, 
    -0.11380017f, -0.04850553f, 0.04226907f, -0.17105947f, 0.09741043f, -0.03416358f, 0.02243468f, -0.01591948f, 
    0.09348590f, -0.15843354f, 0.04952005f, 0.03749160f, -0.06473077f, -0.02009750f, 0.03647905f, 0.01569144f, 
    0.01146526f, 0.19072711f, 0.01377211f, -0.09644970f, -0.18746814f, 0.11531615f, -0.05139909f, -0.00832719f, 
    -0.04410353f, 0.06187255f, -0.07637181f, 0.15101627f, 0.01414518f, 0.08383656f, 0.16221547f, 0.13183782f, 
    -0.02989814f, -0.02825126f, -0.01809654f, -0.01041555f, 0.01749749f, 0.12442717f, 0.24913056f, 0.10352489f, 
    0.16353388f, -0.10965659f, -0.02805523f, 0.04616393f, 0.07504548f, 0.05369310f, 0.14402987f, -0.21494693f, 
    -0.07018805f, 0.06704446f, -0.01910648f, -0.04552406f, -0.08209252f, 0.10561650f, 0.06198333f, -0.04755759f, 
    -0.00032714f, 0.00406590f, 0.09013716f, -0.08106708f, 0.01776957f, 0.10010961f, 0.04674168f, -0.04745286f, 
    -0.18234393f, -0.28420863f, 0.01220208f, 0.09043140f, 0.04718997f, -0.12019901f, 0.06536712f, -0.13694462f, 
    0.03877846f, 0.10811751f, -0.13655192f, 0.09668653f, 0.07082526f, 0.07441460f, -0.07430822f, 0.00325568f, 
    -0.02242803f, 0.09290155f, -0.01443548f, -0.15958732f, -0.04399080f, 0.10919359f, 0.02850782f, -0.01154187f, 
    -0.05888293f, -0.06387918f, 0.01659421f, 0.03131144f, -0.09265734f, 0.13741586f, -0.24326392f, -0.12785234f, 
    0.00393801f, -0.00956538f, 0.15864699f, 0.07486095f, -0.11798711f, -0.08071096f, 0.07545973f, 0.07807135f, 
    0.17136282f, -0.05994880f, -0.16474235f, -0.03142456f, -0.10034543f, 0.03251100f, -0.11356492f, 0.05641122f, 
    0.14908916f, -0.08944961f, 0.03281100f, -0.09933361f, 0.05966791f, 0.13116187f, -0.04147357f, 0.09282727f, 
    -0.00763818f, -0.07096060f, 0.03085703f, 0.02509725f, 0.09028800f, 0.09983276f, 0.03171323f, -0.28573060f, 
    -0.00111300f, -0.22053066f, 0.01191264f, -0.04370153f, -0.02649910f, 0.08869714f, 0.06684548f, -0.05285586f, 
    -0.02315538f, 0.19005693f, 0.04643476f, 0.08387245f, -0.00089102f, 0.01869776f, 0.00544284f, -0.03558772f, 
    -0.04214900f, 0.06488917f, 0.20932348f, 0.22009088f, 0.17996643f, -0.07286526f, 0.01303760f, 0.03337700f, 
    -0.06080474f, 0.06700851f, 0.05754617f, 0.05286832f, 0.02970821f, 0.04004299f, -0.24916418f, -0.14032878f, 
    0.02466202f, -0.01199801f, -0.04935177f, 0.08641006f, 0.07416381f, -0.09764630f, 0.10171603f, 0.13276967f, 
    0.03386034f, -0.05785093f, -0.00521483f, 0.09492503f, -0.04349542f, -0.09592079f, 0.03257537f, -0.01488414f, 
    0.04738276f, -0.00315809f, 0.09635263f, -0.08799941f, -0.06635380f, 0.07242846f, 0.05227938f, 0.12775916f, 
    0.12654626f, 0.16300733f, 0.01497339f, 0.01363105f, -0.00987037f, 0.16969623f, 0.03530719f, -0.06680796f, 
    -0.04109904f, -0.43490818f, 0.08265926f, -0.10621005f, -0.06618310f, 0.11474043f, 0.09639922f, -0.10566494f, 
    0.03632192f, 0.02032837f, -0.03098503f, -0.00091196f, -0.03703124f, -0.04700225f, -0.03210350f, -0.06689524f, 
    0.02311064f, 0.03273345f, -0.01164796f, -0.05718121f, -0.02056104f, -0.02541764f, -0.05245231f, 0.01155268f, 
    0.03563417f, -0.02238333f, 0.00303258f, 0.01766188f, 0.04071911f, -0.00358460f, 0.04813800f, 0.05178799f, 
    -0.06034905f, -0.01453055f, 0.02752635f, 0.02631121f, 0.03133493f, -0.03009369f, 0.04133800f, -0.03108593f, 
    0.04407249f, 0.02718017f, -0.02229075f, -0.05148635f, -0.01082850f, -0.01549011f, -0.02578029f, -0.00994190f, 
    0.04586253f, -0.00756630f, 0.02588173f, -0.05811549f, -0.04236441f, 0.03107937f, 0.02937941f, -0.01140939f, 
    0.01111928f, 0.03496346f, -0.01126397f, 0.02795644f, 0.02819094f, -0.04348144f, -0.04510516f, -0.04846201f, 
    -0.03948987f, -0.00767422f, 0.02331189f, -0.03171058f, 0.02962415f, 0.00500895f, -0.02885497f, -0.02954692f, 
    -0.05405072f, 0.02161471f, -0.02941213f, 0.03133909f, 0.03817810f, -0.03692549f, 0.04799023f, -0.04911932f, 
    0.01796902f, -0.04151560f, -0.02067755f, 0.05100319f, -0.00356641f, -0.05858824f, 0.01930371f, -0.06247922f, 
    0.03360189f, -0.00972376f, 0.01293343f, 0.05471088f, -0.01300931f, -0.01501428f, 0.03839681f, 0.04280705f, 
    -0.03670534f, -0.03401001f, 0.02755670f, 0.00220097f, -0.00751785f, 0.03049623f, -0.01845523f, -0.05710245f, 
    -0.04813100f, -0.06471424f, 0.04089998f, -0.06460491f, -0.03083092f, -0.00605069f, 0.05905461f, -0.00137584f, 
    -0.01465392f, 0.03902375f, -0.06983770f, -0.06909307f, 0.04317232f, 0.04770442f, -0.03304549f, 0.01818919f, 
    -0.00956745f, -0.01662802f, -0.05641321f, 0.01217194f, 0.04042199f, -0.06266277f, 0.01871342f, 0.02913811f, 
    0.04309382f, -0.03491946f, -0.01711650f, 0.00676314f, -0.02737657f, -0.02591662f, 0.04743861f, 0.01698755f, 
    -0.05273742f, 0.00656025f, -0.06210656f, 0.01994025f, 0.00856552f, 0.03231645f, -0.05217076f, -0.03267715f, 
    -0.00508846f, 0.02994368f, -0.04178240f, 0.04129242f, 0.04514784f, -0.03130370f, 0.00711253f, 0.01653475f, 
    -0.05252974f, 0.00297556f, -0.04702115f, -0.01765863f, 0.04723962f, -0.01408244f, 0.03955114f, 0.03180431f, 
    -0.01955280f, 0.00159776f, -0.01074440f, 0.04132164f, -0.05249850f, -0.00183011f, -0.00798948f, 0.04262161f, 
    -0.01107779f, -0.06705837f, 0.03583556f, 0.00104854f, 0.00115816f, 0.03911597f, 0.02712959f, 0.00916614f, 
    0.00423288f, -0.05172385f, 0.01500239f, -0.03053847f, -0.02675135f, 0.04294613f, 0.02407799f, -0.03016356f, 
    0.05084404f, 0.01043751f, -0.04508457f, -0.00507767f, -0.04778716f, -0.04034234f, -0.01224946f, -0.03779505f, 
    -0.02539210f, -0.05125293f, 0.02393110f, 0.01971062f, 0.02764134f, 0.03468788f, -0.00325406f, -0.05903534f, 
    0.03166594f, -0.03222778f, 0.05010131f, 0.05033375f, 0.00124041f, 0.00620786f, -0.06217822f, -0.05913173f, 
    -0.07114862f, 0.01188338f, 0.04725062f, -0.05821022f, 0.01782382f, -0.03548943f, -0.03598264f, -0.02866986f, 
    0.03308649f, 0.00247424f, 0.01557761f, -0.06575737f, -0.05386299f, -0.01187039f, -0.01223538f, -0.02817266f, 
    -0.00907153f, -0.01895219f, -0.05391951f, -0.04090508f, -0.03023537f, 0.03942556f, -0.02794804f, -0.04256249f, 
    -0.05428754f, -0.03219576f, 0.02123291f, -0.04472049f, -0.01022311f, 0.03946931f, -0.04727029f, -0.03620503f, 
    0.03007940f, -0.02090679f, -0.03810606f, -0.03958819f, 0.00275031f, 0.00073229f, -0.02277878f, 0.03562690f, 
    -0.04373394f, 0.02172687f, -0.06367846f, 0.02488472f, 0.03827015f, 0.04563460f, 0.00332875f, -0.01095415f, 
    0.00941471f, 0.00280882f, 0.01939611f, 0.00614654f, -0.04969275f, -0.00024074f, 0.02129702f, -0.06718434f, 
    0.02350798f, -0.04123708f, -0.03517339f, 0.04206127f, -0.04925429f, 0.03061846f, -0.00166240f, 0.04336811f, 
    0.02144686f, 0.00510727f, 0.04917867f, 0.01911713f, -0.02223391f, 0.02104247f, -0.04140083f, 0.00577969f, 
    -0.00599677f, -0.03023136f, -0.00649054f, -0.05245740f, -0.01062799f, 0.02314637f, 0.01485438f, 0.01009939f, 
    0.00159146f, -0.06387094f, -0.05632167f, 0.04531136f, -0.02175424f, -0.01842287f, -0.05848554f, -0.01231693f, 
    0.04868871f, 0.06040958f, 0.12844795f, 0.10084356f, 0.01394735f, 0.09678440f, -0.09195709f, -0.08992998f, 
    0.10950210f, 0.25038105f, 0.09953632f, 0.01094900f, 0.15643525f, 0.04667028f, 0.19557811f, 0.02069484f, 
    0.00180911f, 0.09848593f, -0.14957832f, 0.12739626f, 0.05715273f, 0.01868008f, -0.05283967f, 0.15366660f, 
    -0.08062382f, 0.07958794f, -0.05700079f, 0.25432697f, -0.07476273f, 0.22387849f, -0.10016459f, -0.10180449f, 
    -0.23714751f, 0.11716696f, 0.12282828f, -0.07338881f, -0.26178336f, 0.09024298f, -0.10282568f, -0.05010014f, 
    0.03690016f, 0.10686190f, -0.15294783f, 0.14504877f, -0.10566579f, -0.09804125f, 0.11613515f, 0.02422555f, 
    -0.05429538f, -0.07011849f, 0.08173341f, -0.00454630f, -0.04296080f, -0.09314473f, -0.10127766f, 0.10556915f, 
    -0.24463874f, -0.01787363f, 0.11558156f, 0.13586123f, 0.12438220f, -0.02285492f, -0.02252712f, -0.06225052f, 
    -0.01458607f, -0.13611059f, 0.27519467f, 0.10941505f, 0.09756176f, 0.05323973f, -0.00433377f, 0.15501364f, 
    0.15414965f, 0.22704536f, 0.04518112f, -0.14686272f, 0.04089424f, -0.12063326f, 0.14475597f, 0.01906575f, 
    0.17443077f, -0.08930962f, 0.17095920f, 0.04978544f, -0.00863301f, -0.10039087f, -0.01347477f, -0.11739453f, 
    -0.11358562f, -0.11484266f, -0.14947504f, 0.14369416f, 0.18147132f, 0.19455920f, 0.17426412f, 0.22650768f, 
    0.06101327f, -0.48109311f, -0.00437216f, 0.10207064f, 0.11884060f, 0.09027924f, 0.00921974f, -0.09403852f, 
    -0.09740483f, 0.10247845f, -0.00319236f, 0.10232991f, 0.05488917f, -0.14013796f, 0.29867235f, 0.00346124f, 
    -0.01759291f, 0.04377143f, 0.16003464f, -0.11247873f, 0.03084143f, 0.09423017f, -0.12627096f, 0.01228416f, 
    -0.00125527f, 0.06416700f, 0.01147780f, 0.12331603f, 0.09225710f, -0.14065754f, -0.02239118f, -0.18147521f, 
    -0.13681090f, 0.07457083f, 0.08448368f, 0.09940734f, 0.11934567f, 0.03074615f, 0.04573376f, -0.17389661f, 
    0.01590336f, 0.14460996f, 0.22283702f, 0.04033368f, 0.09115200f, 0.15042727f, -0.03175185f, -0.16286522f, 
    0.20176789f, 0.00220630f, 0.25320217f, 0.13967422f, 0.13692676f, 0.02654145f, 0.00817804f, -0.07172417f, 
    0.03124502f, 0.01121512f, -0.02657184f, 0.03684923f, 0.07637228f, 0.13165168f, -0.03716022f, 0.05542923f, 
    0.07988378f, -0.06596742f, 0.11036604f, 0.06536420f, -0.08848889f, -0.12043190f, 0.02477441f, -0.05250512f, 
    -0.03693816f, 0.21883824f, -0.08820552f, 0.21601585f, -0.13723177f, 0.00012173f, -0.05700240f, 0.05370994f, 
    -0.05138439f, -0.04481967f, 0.02372830f, -0.09742711f, -0.12472976f, 0.20336883f, -0.00850224f, 0.04424288f, 
    0.01031525f, -0.17885439f, -0.03916295f, -0.05529155f, 0.00800989f, -0.01093585f, 0.09552027f, -0.11284472f, 
    0.10678931f, -0.00068076f, 0.19563645f, 0.01473837f, -0.08494964f, 0.01734871f, -0.33181462f, -0.02890109f, 
    0.06932915f, 0.26592520f, 0.18299715f, 0.04167711f, 0.09458168f, -0.06582751f, 0.05625493f, 0.15151033f, 
    -0.26062366f, 0.04310874f, -0.07585246f, 0.14114591f, -0.01455124f, 0.10084248f, 0.05967113f, -0.06054648f, 
    -0.07690235f, 0.07102402f, -0.01533703f, 0.10045358f, 0.04856059f, -0.09289447f, -0.00624743f, 0.00775374f, 
    0.11011461f, 0.39885876f, 0.29172692f, -0.07104667f, 0.08219520f, 0.03509124f, 0.00739606f, 0.19819458f, 
    -0.03785697f, -0.01672977f, -0.03179985f, -0.11786475f, -0.02125728f, 0.00115687f, -0.18771690f, -0.12457627f, 
    0.00798459f, 0.01828130f, 0.02654843f, -0.56622797f, -0.05108431f, -0.00419063f, 0.28100613f, -0.16395846f, 
    0.07189053f, 0.02726469f, 0.14792188f, -0.29310572f, -0.08047110f, 0.24490722f, -0.00120815f, 0.04513348f, 
    0.34798893f, -0.00365810f, 0.04404905f, -0.02746120f, -0.15308174f, 0.19946592f, 0.14537935f, 0.12201598f, 
    0.14951393f, 0.14450929f, -0.00453283f, 0.07120960f, -0.08842310f, -0.06296492f, -0.01973199f, -0.04061297f, 
    -0.20131555f, 0.19671874f, 0.24043077f, -0.10239827f, 0.01301135f, 0.16453640f, -0.04391840f, 0.21205886f, 
    -0.03564175f, 0.22160485f, -0.04550375f, 0.09961901f, -0.05233852f, 0.03295352f, -0.15127932f, 0.04049360f, 
    0.17512344f, -0.15240677f, -0.37913421f, -0.07600234f, 0.09757701f, 0.02290470f, -0.16394725f, 0.05783693f, 
    0.07099063f, 0.37882546f, 0.06730416f, 0.01138712f, -0.22245802f, -0.23045084f, 0.07791764f, 0.02670789f, 
    0.02973638f, 0.01156577f, -0.15312138f, 0.09046725f, -0.03412994f, 0.07195416f, 0.04466329f, 0.04274692f, 
    0.02723628f, -0.00689233f, -0.04598114f, 0.03611754f, -0.03673337f, -0.15513000f, -0.00305198f, 0.04314303f, 
    -0.08639824f, 0.03578500f, -0.01001159f, 0.23815048f, -0.25336337f, 0.12953407f, -0.21322508f, -0.08635069f, 
    0.09797095f, 0.05485713f, -0.14346735f, 0.00409269f, -0.10021961f, -0.17950417f, 0.16425559f, -0.05194143f, 
    -0.00197562f, -0.03272978f, 0.17364356f, -0.01968746f, -0.07001244f, 0.03402290f, -0.05794290f, 0.09975153f, 
    -0.07319397f, -0.00777630f, -0.18975040f, -0.00648206f, -0.04304378f, 0.01745402f, 0.20160945f, 0.07459942f, 
    0.06943969f, 0.17456026f, -0.10188852f, -0.16319430f, -0.10313436f, 0.08572283f, 0.02363010f, 0.09132203f, 
    0.31314054f, 0.20121703f, -0.04549319f, 0.12095356f, 0.06635748f, -0.08308556f, 0.06383043f, 0.03883621f, 
    -0.15108639f, 0.01494734f, 0.02109164f, -0.11276405f, -0.09404755f, 0.16797331f, -0.04619041f, -0.21946587f, 
    0.02180771f, -0.15047334f, -0.08171274f, -0.06948658f, 0.01457920f, -0.20071276f, 0.10026810f, -0.05380006f, 
    0.11775187f, -0.06739637f, 0.12690909f, 0.23176463f, -0.00404017f, -0.09106843f, 0.02507318f, 0.06814598f, 
    0.02067475f, -0.01104796f, -0.12743212f, -0.11874925f, 0.58872294f, -0.04960510f, 0.23096772f, -0.11893702f, 
    0.00907656f, -0.04161428f, 0.22126731f, 0.03638314f, 0.18405083f, -0.16511823f, 0.02758644f, -0.26367790f, 
    0.13741824f, 0.03062371f, 0.08402061f, -0.11089037f, 0.13936792f, -0.06432038f, 0.34597820f, 0.04406663f, 
    -0.10849918f, -0.07116584f, 0.10676741f, -0.11832415f, 0.00870078f, -0.00678244f, -0.04225788f, 0.02385337f, 
    0.05470511f, 0.00184878f, -0.00473509f, -0.05299496f, -0.01410701f, -0.05515286f, -0.06868663f, 0.02549842f, 
    0.05464672f, 0.11573903f, 0.04464322f, 0.04420945f, 0.04827297f, 0.05424614f, 0.04828597f, -0.09643650f, 
    0.10576231f, -0.44559020f, -0.12676483f, 0.02659555f, -0.03628762f, -0.13617410f, -0.00185853f, 0.07274576f, 
    0.06659566f, -0.16947101f, 0.23639664f, -0.20693202f, 0.02762400f, 0.00675246f, -0.05083067f, -0.00310946f, 
    -0.01513938f, 0.04031140f, -0.08940431f, 0.06637241f, 0.12145488f, -0.21228482f, -0.03888980f, 0.11425690f, 
    0.06251869f, -0.14650181f, -0.03871543f, -0.04872840f, 0.17646311f, -0.03347379f, 0.06226280f, 0.01877442f, 
    -0.02924069f, -0.02053961f, -0.04800848f, 0.02616140f, -0.21569918f, -0.18839589f, -0.10441066f, -0.03518863f, 
    0.00083140f, 0.16172703f, -0.02024563f, -0.02844432f, -0.02389600f, 0.03234837f, -0.09730756f, 0.10907165f, 
    0.02986848f, -0.14832911f, 0.11356091f, 0.18945108f, -0.08122431f, 0.00012483f, 0.01280414f, -0.41799843f, 
    -0.00228974f, -0.30594647f, -0.08241741f, 0.12614791f, -0.18482369f, 0.09611119f, -0.05905338f, -0.00501866f, 
    -0.11103468f, -0.06576872f, -0.15039307f, 0.01755128f, 0.06283233f, -0.03562865f, 0.09666207f, 0.06650592f, 
    0.04764348f, 0.10391625f, 0.12005730f, -0.12821490f, 0.09283189f, -0.02996773f, 0.15410618f, 0.07015918f, 
    0.04932253f, 0.04139740f, -0.24120368f, 0.24429895f, -0.00421204f, 0.00284736f, 0.09410643f, -0.04662478f, 
    -0.04526168f, -0.02076444f, -0.22063404f, 0.32399261f, -0.33158645f, 0.09042399f, 0.01783698f, 0.07967109f, 
    -0.02569056f, -0.04816867f, 0.09795350f, -0.03972541f, 0.07045863f, -0.11798850f, 0.05283418f, -0.01266380f, 
    -0.02258111f, 0.07267803f, -0.04237555f, 0.09816587f, 0.03542746f, -0.32665181f, -0.14033836f, -0.02852892f, 
    0.00960839f, -0.06462596f, -0.03554391f, 0.12278483f, 0.01965827f, 0.10454312f, 0.04973486f, 0.05380961f, 
    0.13753957f, 0.10327081f, 0.03638465f, -0.16877715f, 0.13623878f, 0.04717664f, 0.11492263f, -0.12157127f, 
    -0.28146511f, -0.19331120f, -0.08328420f, -0.04975669f, -0.00909404f, -0.05406878f, 0.03743037f, -0.04289697f, 
    -0.26611727f, -0.18862742f, -0.08160593f, 0.00857656f, 0.11195084f, 0.05895475f, -0.05135933f, 0.01884459f, 
    -0.08599702f, -0.01311249f, -0.56349218f, -0.17814776f, 0.01157656f, 0.22672415f, 0.05905864f, -0.04039488f, 
    -0.01401476f, -0.01418912f, 0.17550994f, 0.28342727f, 0.25011972f, -0.06972539f, 0.04907901f, 0.01555155f, 
    -0.03592422f, 0.08148660f, 0.09436345f, 0.03924366f, 0.00390505f, -0.00102770f, -0.07952259f, 0.03447457f, 
    -0.10790422f, 0.02434381f, -0.01479576f, 0.06504384f, 0.01375445f, 0.13130783f, 0.18560483f, -0.00297740f, 
    0.03150513f, -0.07428692f, 0.10296432f, -0.04890466f, -0.13694115f, 0.19223748f, 0.36226469f, 0.35130963f, 
    0.00637234f, 0.00982580f, -0.15042204f, -0.09344092f, 0.01109188f, 0.02407623f, -0.00410912f, -0.05751988f, 
    0.08059207f, -0.09220469f, 0.01797462f, -0.04209796f, 0.09292069f, 0.13561891f, -0.01794848f, -0.03039089f, 
    -0.36229512f, -0.14787067f, 0.12418704f, 0.10574591f, -0.02877027f, 0.02721090f, -0.09960137f, -0.10524237f, 
    0.14177403f, -0.09024411f, -0.18035135f, -0.10032551f, 0.01121334f, 0.10585079f, -0.03014934f, 0.04568876f, 
    -0.06274510f, 0.11016041f, 0.15716410f, 0.06933149f, -0.02988102f, -0.06348364f, -0.14601445f, 0.00773915f, 
    -0.05428452f, 0.14556660f, -0.01993414f, -0.00497847f, -0.16525379f, -0.02558334f, 0.02270762f, -0.07002775f, 
    0.15815397f, -0.04225886f, 0.05268022f, 0.02443453f, 0.06151433f, 0.01496355f, -0.01340999f, 0.02392174f, 
    0.00397147f, -0.07067639f, -0.03605414f, 0.03122923f, -0.08763040f, -0.16724116f, 0.08489937f, 0.00025032f, 
    -0.04704191f, -0.00649805f, -0.21009536f, -0.10838106f, 0.05129423f, 0.07121567f, 0.04018945f, 0.09595196f, 
    0.00448298f, 0.10083445f, -0.09857807f, -0.03489632f, 0.03742310f, 0.02621733f, -0.10211243f, 0.03001404f, 
    -0.19898649f, 0.18028551f, -0.03522229f, 0.06771543f, 0.04475384f, -0.04327408f, -0.10957731f, -0.05891070f, 
    0.06570940f, -0.21292810f, 0.05185608f, 0.01275051f, -0.04648004f, -0.08258914f, -0.00378839f, -0.18741435f, 
    0.05481722f, -0.09753753f, -0.07122380f, -0.04197187f, 0.06036033f, 0.06060971f, -0.08688255f, -0.01223325f, 
    0.05634447f, 0.03933145f, 0.07138263f, -0.22068457f, 0.06946806f, 0.01176456f, -0.04527530f, -0.09075683f, 
    -0.11648992f, 0.01687144f, 0.19208686f, -0.09833556f, -0.20705967f, 0.02213357f, -0.03547043f, 0.04625020f, 
    0.03532076f, -0.08529854f, 0.08338691f, -0.08916522f, -0.00316621f, -0.07883354f, -0.07212845f, 0.01959397f, 
    0.06052518f, 0.14031109f, 0.06303737f, 0.11689514f, 0.16002300f, -0.28692061f, -0.03379372f, -0.00348816f, 
    0.03011693f, 0.03257406f, -0.00327676f, 0.04879513f, 0.06101805f, 0.06551820f, 0.17179164f, 0.17494956f, 
    0.03670376f, -0.03780990f, 0.09573208f, 0.12507018f, -0.02110853f, 0.08692048f, -0.20110410f, -0.02062872f, 
    -0.20421341f, 0.08702709f, -0.02929503f, 0.02824571f, -0.10182582f, -0.00759383f, -0.02889461f, -0.14110178f, 
    -0.05256586f, -0.20339686f, -0.15965191f, -0.09244222f, -0.02347773f, 0.06116572f, 0.20464531f, 0.03399801f, 
    0.05093282f, 0.07728391f, -0.23999088f, 0.09189090f, 0.14013688f, 0.05044886f, 0.12139414f, -0.05096830f, 
    0.11389475f, 0.12535474f, -0.05865039f, -0.01120458f, 0.18170230f, 0.06603669f, 0.04174095f, -0.03803275f, 
    -0.03665096f, 0.01879399f, -0.02249860f, -0.01559995f, -0.04595423f, -0.01495805f, 0.02718112f, 0.12018109f, 
    0.04477835f, -0.07575257f, -0.00537830f, -0.51321739f, -0.44838178f, -0.23545730f, 0.24666615f, -0.03410356f, 
    -0.03804960f, -0.01983249f, -0.18529144f, -0.17390704f, 0.06720361f, 0.27016810f, 0.30068052f, 0.23823021f, 
    0.03709319f, 0.19491754f, 0.17884493f, 0.01298333f, -0.01049220f, 0.04424873f, 0.05479126f, -0.10487098f, 
    -0.03157864f, 0.08262329f, 0.03613066f, 0.07511554f, 0.02168864f, 0.17612320f, 0.27942738f, 0.04602517f, 
    0.07285886f, 0.10998822f, 0.13455033f, -0.12533462f, 0.14365074f, -0.04361238f, -0.05929409f, -0.06687300f, 
    0.05021645f, 0.27996582f, -0.11758301f, 0.00166296f, -0.08489401f, 0.07847308f, -0.06612770f, 0.07586008f, 
    0.16890867f, -0.04136885f, 0.11104255f, -0.00837505f, 0.17481965f, -0.07099155f, -0.12922999f, -0.02429099f, 
    0.06914576f, 0.32242656f, -0.01718246f, -0.10530497f, -0.10805365f, -0.01566094f, 0.04123092f, -0.03653943f, 
    -0.02387181f, 0.00231148f, -0.15493916f, 0.01649992f, 0.17177631f, 0.24200557f, 0.04089606f, 0.06540345f, 
    0.22708620f, -0.04809102f, 0.08736785f, 0.35171524f, 0.01887780f, -0.01359279f, 0.12848754f, -0.22380264f, 
    -0.04994505f, 0.01528054f, -0.03057682f, 0.07597567f, -0.26570454f, -0.06343541f, -0.04063072f, 0.07979187f, 
    0.34641829f, -0.13231783f, 0.14127755f, 0.00094758f, -0.30706748f, -0.04852078f, 0.37196755f, 0.31379348f, 
    0.22534510f, 0.14797837f, 0.01019142f, 0.20820594f, -0.02042820f, 0.02924071f, -0.32890677f, -0.03452963f, 
    -0.03506297f, 0.06860362f, 0.11116646f, 0.12603864f, 0.07746357f, 0.17196003f, -0.06429484f, 0.59478760f, 
    0.08422063f, -0.21352783f, -0.06075681f, -0.21601476f, -0.10933266f, 0.11137276f, -0.04261839f, 0.00834008f, 
    0.28620180f, 0.01308213f, 0.03958564f, 0.13441770f, 0.11628468f, -0.10973723f, 0.04738105f, 0.12835513f, 
    0.22525182f, 0.45670369f, 0.05697548f, 0.01014429f, 0.18849820f, -0.21906625f, -0.14373685f, 0.03089689f, 
    0.05371933f, 0.06169933f, -0.15771194f, -0.29885757f, -0.30392739f, -0.35889348f, 0.01678683f, -0.13474582f, 
    0.08282753f, -0.13397807f, -0.28914723f, 0.45102811f, 0.09543929f, 0.19199404f, 0.30258733f, -0.21118322f, 
    -0.11333484f, 0.13487548f, -0.01120651f, 0.21812126f, -0.04462675f, -0.32018191f, 0.06186674f, -0.12220616f, 
    -0.26809388f, -0.01680038f, -0.03163735f, -0.25654253f, 0.19045612f, -0.30878913f, 0.01195881f, 0.20858228f, 
    0.18042548f, 0.19381097f, -0.16067967f, 0.06655382f, -0.00629432f, 0.00284038f, 0.23773001f, 0.05638156f, 
    0.12602530f, 0.03415098f, 0.10035280f, -0.17672901f, 0.25544995f, 0.08642761f, 0.00250120f, 0.30064252f, 
    0.05890284f, 0.00776594f, -0.14621300f, -0.03170450f, 0.15797712f, 0.12758739f, 0.03426167f, 0.01032201f, 
    -0.03062910f, -0.24452576f, -0.00742612f, -0.24557461f, -0.03555013f, 0.07669329f, 0.04679741f, -0.06854437f, 
    0.13289925f, 0.04446082f, -0.26676002f, 0.13567935f, 0.08993548f, 0.07422809f, -0.00235257f, 0.20430425f, 
    -0.08363326f, 0.24794626f, 0.17910893f, -0.15301020f, 0.06347570f, -0.17560272f, -0.04400026f, -0.03656299f, 
    0.03448361f, 0.17942065f, 0.28185374f, 0.00685080f, 0.13241293f, 0.02243145f, 0.08537618f, 0.05639182f, 
    -0.03786131f, 0.01178152f, 0.08593292f, 0.15232186f, 0.13177024f, -0.24132197f, -0.14762321f, 0.11874509f, 
    -0.03763948f, -0.02511292f, 0.03620706f, 0.04172659f, 0.20818308f, -0.64540660f, -0.17396374f, 0.06770836f, 
    0.34050918f, 0.03268469f, 0.07492067f, 0.00740949f, -0.04157745f, 0.06158152f, 0.17516643f, -0.09734046f, 
    -0.23182757f, -0.26360303f, -0.00978058f, 0.03305598f, -0.03381495f, -0.10953453f, 0.00414018f, 0.35673037f, 
    0.07294479f, 0.16283736f, 0.09301899f, -0.14686681f, -0.13393043f, -0.10945943f, -0.00220234f, 0.12014543f, 
    0.34456113f, -0.06931305f, 0.17545822f, 0.08610635f, -0.07755527f, 0.02994411f, 0.13709895f, 0.07250965f, 
    0.14526366f, 0.15109360f, 0.06170909f, 0.14989375f, -0.02466332f, 0.10793218f, 0.03858184f, 0.35358173f, 
    -0.06313064f, -0.01819144f, 0.02124130f, -0.00126655f, 0.11902134f, 0.27976310f, 0.11301496f, -0.10463326f, 
    -0.14775236f, 0.13810663f, 0.04952591f, 0.40554860f, -0.22354445f, -0.04614346f, -0.14494660f, -0.14907058f, 
    -0.01497028f, -0.08400391f, -0.06235072f, -0.14601617f, -0.30701783f, 0.18998575f, 0.29103220f, 0.14136565f, 
    0.16321278f, 0.14554535f, 0.18731518f, 0.02386782f, -0.02435364f, -0.15376154f, -0.10286707f, 0.14235857f, 
    0.08242561f, 0.07174918f, 0.00466780f, 0.00099668f, -0.04900797f, 0.16182335f, -0.10664035f, 0.03490346f, 
    -0.04054889f, 0.07295117f, -0.01465024f, -0.04383029f, 0.03271357f, 0.03282390f, -0.17498319f, -0.05506635f, 
    -0.14951292f, 0.09361599f, -0.04779186f, 0.24022679f, 0.03079525f, 0.24213427f, -0.10652180f, 0.26350081f, 
    -0.14332105f, -0.22553685f, 0.06583732f, 0.09926721f, 0.11632095f, 0.04588228f, 0.05652886f, 0.08635485f, 
    -0.10180958f, 0.26819727f, 0.07344858f, -0.12570031f, 0.04675094f, 0.09739981f, -0.07942401f, 0.04222416f, 
    -0.00103476f, 0.11202458f, -0.11348625f, 0.12231342f, 0.06118043f, -0.04783542f, -0.01829774f, 0.15783617f, 
    -0.09778200f, -0.01561095f, 0.02093747f, -0.12971693f, -0.08103837f, -0.03838231f, -0.07147508f, 0.17919083f, 
    0.04766510f, -0.10986280f, -0.11911302f, -0.06484081f, -0.13874482f, 0.01801992f, -0.09573053f, 0.05627261f, 
    -0.09400745f, 0.03485046f, 0.00185448f, 0.20201956f, -0.13716890f, -0.15489922f, -0.03223934f, 0.06171874f, 
    -0.06077056f, -0.01362559f, 0.11241604f, 0.02633338f, 0.11897882f, 0.05476264f, 0.13303483f, 0.09030045f, 
    -0.32625315f, 0.10165885f, -0.15897335f, -0.14118156f, 0.07744883f, -0.12856056f, 0.01995564f, -0.09015408f, 
    0.12198643f, -0.20472138f, 0.06366083f, 0.07057778f, 0.10469238f, 0.02791146f, -0.08807112f, -0.00156917f, 
    -0.03032371f, -0.07457669f, 0.10054827f, -0.19875263f, -0.00935219f, 0.11400948f, -0.05337609f, -0.04355167f, 
    -0.04971545f, -0.22589204f, -0.03642656f, 0.11241310f, -0.02514272f, 0.00417995f, 0.06969494f, 0.01294154f, 
    0.14463165f, -0.04283466f, -0.13722348f, 0.04186718f, 0.04399147f, 0.13114466f, 0.17118132f, -0.07211584f, 
    0.09356140f, -0.03700303f, -0.20297992f, 0.07932861f, 0.02673358f, -0.00988945f, 0.04514395f, 0.02536673f, 
    0.11148828f, 0.15776530f, 0.02096740f, -0.05698518f, -0.12195420f, -0.13070209f, -0.19967605f, 0.22335559f, 
    0.03166090f, -0.10532800f, -0.09474912f, -0.05031651f, -0.22978944f, -0.01980881f, -0.00120395f, 0.13393877f, 
    -0.06593922f, -0.14436939f, -0.00523192f, 0.29725635f, -0.05432496f, 0.18206249f, -0.11408576f, -0.18244389f, 
    0.12886873f, 0.09940645f, 0.01235371f, 0.00893063f, -0.00948690f, 0.15502048f, 0.02288717f, -0.39143482f, 
    -0.01896978f, 0.03328033f, 0.07047737f, 0.13018116f, -0.04746099f, 0.12182514f, -0.05685418f, -0.12593962f, 
    0.14842208f, 0.33714408f, -0.13681979f, 0.00750143f, -0.07965535f, 0.02302144f, 0.13244686f, -0.31636342f, 
    -0.21830161f, -0.12325858f, 0.08098201f, 0.04600409f, -0.07224853f, 0.08641113f, -0.06064250f, 0.02309051f, 
    -0.20718099f, -0.07211092f, -0.13982251f, -0.17102835f, 0.05493594f, -0.00733283f, 0.03859273f, 0.08119512f, 
    0.08867414f, 0.01939299f, -0.07719213f, 0.02899023f, 0.05373590f, 0.08364511f, -0.03402648f, 0.14641787f, 
    -0.13443853f, 0.03623565f, 0.04966864f, 0.05506845f, -0.20440686f, 0.04170007f, 0.02397520f, -0.01540054f, 
    -0.02394191f, 0.02083163f, 0.07507344f, -0.06116882f, 0.05616180f, -0.04352273f, 0.12015548f, -0.05054768f, 
    -0.06117046f, -0.01135262f, 0.19073252f, -0.03489746f, 0.08273565f, 0.14185940f, -0.18662046f, 0.08884658f, 
    0.12318902f, 0.10633071f, 0.05302085f, 0.20594706f, -0.02869609f, -0.02789832f, -0.03016456f, 0.13109744f, 
    0.13863309f, 0.15110515f, -0.16603082f, 0.05721886f, 0.09002506f, -0.00228776f, 0.02600654f, -0.11354657f, 
    0.01016750f, 0.04306694f, -0.02428183f, 0.03931632f, -0.08446222f, 0.04922550f, 0.12944874f, -0.00174947f, 
    0.04379920f, 0.13879046f, 0.02881901f, 0.07726834f, -0.19665517f, -0.02812037f, -0.14708136f, 0.17028317f, 
    0.00192684f, 0.05401010f, -0.18842597f, 0.10807059f, 0.05723108f, 0.02465748f, -0.04139356f, 0.03425716f, 
    -0.01569258f, -0.03375673f, 0.05747781f, -0.34103113f, -0.08973753f, -0.08684144f, 0.21070462f, 0.22036289f, 
    0.09503981f, 0.11292815f, -0.07740540f, -0.08047289f, 0.03386841f, 0.01267151f, 0.09173243f, -0.00371807f, 
    -0.12894030f, -0.08798722f, -0.01141088f, 0.07028698f, 0.08585238f, 0.00589405f, -0.07305910f, -0.06125534f, 
    0.19446515f, -0.03999698f, 0.04264449f, 0.04964508f, -0.14343166f, -0.08928772f, 0.03675593f, 0.09214582f, 
    0.01503274f, -0.20094891f, 0.09555924f, -0.10806324f, 0.17169912f, 0.06909174f, 0.05050113f, -0.02800838f, 
    -0.01683832f, 0.09946907f, 0.02296166f, -0.00206380f, -0.05157049f, 0.01905944f, -0.24533245f, -0.02482185f, 
    0.25851226f, 0.36224911f, 0.06877419f, -0.19974566f, 0.01355764f, -0.08081972f, 0.04014428f, -0.00283791f, 
    -0.16256946f, 0.29095963f, 0.11061943f, 0.22614576f, -0.10447212f, 0.02319301f, -0.05724166f, 0.03166692f, 
    -0.03312160f, -0.00986902f, 0.08078969f, 0.01809779f, 0.10304777f, -0.01673077f, -0.04376144f, 0.10310403f, 
    0.08836112f, -0.08953319f, -0.02279268f, 0.04145643f, 0.10968810f, -0.01539578f, -0.13286650f, 0.04412040f, 
    -0.08162864f, -0.06877007f, 0.08085128f, -0.17653020f, -0.13826267f, 0.00428933f, 0.14593740f, 0.13724144f, 
    -0.02850473f, 0.12520252f, -0.35854778f, 0.12419241f, 0.16484061f, -0.14237687f, 0.19189565f, -0.09296402f, 
    0.00500060f, 0.11526061f, 0.05336260f, 0.09121625f, -0.13972749f, -0.05889194f, -0.24335113f, 0.18671188f, 
    -0.09329865f, 0.04361733f, 0.09378725f, -0.00121291f, -0.03362022f, -0.03590550f, -0.11503785f, 0.17893107f, 
    0.13434011f, 0.19160166f, 0.15134220f, -0.02237256f, 0.05131393f, -0.03002918f, -0.08879511f, -0.02741947f, 
    0.15306120f, -0.11521205f, 0.15647659f, -0.20930888f, 0.02066214f, 0.01453108f, 0.03871968f, -0.14247259f, 
    0.00541500f, -0.14980526f, 0.17941260f, -0.38276532f, 0.28973007f, 0.11900066f, 0.02078056f, -0.18821955f, 
    0.21935956f, -0.02334669f, 0.12233265f, 0.02292334f, 0.44015095f, 0.12241296f, -0.06738495f, 0.23454972f, 
    -0.21750805f, 0.09790439f, -0.08732875f, 0.07401168f, -0.20570956f, -0.09340463f, -0.10279767f, -0.03985795f, 
    -0.15312265f, -0.10950788f, 0.09190776f, -0.00431406f, 0.02093978f, 0.19582656f, 0.04196097f, -0.11381872f, 
    0.03970069f, 0.05254200f, -0.11597142f, -0.05834950f, 0.06704191f, -0.09963517f, -0.19006647f, -0.39105681f, 
    0.00561304f, -0.00331201f, 0.07784524f, -0.02186929f, -0.05867320f, -0.05398072f, -0.02252495f, -0.28577605f, 
    -0.12318501f, -0.01876455f, -0.08252896f, -0.05072501f, 0.01582794f, 0.02252461f, -0.10714205f, 0.32836667f, 
    0.10126238f, 0.00807256f, 0.09044767f, -0.02223932f, -0.00468710f, -0.04248080f, 0.04323708f, -0.17340107f, 
    0.24538484f, 0.14921242f, 0.40552351f, 0.04018877f, 0.08276298f, 0.08713665f, 0.06793477f, -0.07094298f, 
    -0.00974964f, 0.02233871f, -0.01218187f, -0.14799760f, 0.11887133f, 0.10247078f, 0.01521056f, 0.05475648f, 
    -0.14206891f, -0.08501113f, -0.02350706f, 0.00242412f, -0.02120835f, 0.03728051f, 0.01577561f, 0.02696509f, 
    0.02432383f, -0.00898921f, 0.07540797f, -0.00897898f, -0.07649064f, -0.13453588f, 0.05473808f, -0.02458692f, 
    0.13781013f, -0.16093558f, 0.19706960f, 0.07867976f, -0.25467589f, -0.23102534f, -0.04868415f, 0.05275368f, 
    -0.00134057f, -0.05700818f, -0.02018645f, -0.02146634f, -0.19320972f, -0.00754475f, -0.00588669f, -0.16479549f, 
    0.22721747f, -0.06546572f, 0.10288651f, -0.04934954f, 0.07870852f, 0.08314849f, 0.15810888f, 0.08555657f, 
    0.03235034f, 0.15881756f, 0.11890877f, -0.00824100f, 0.17557828f, 0.05641450f, -0.10457965f, -0.06126827f, 
    -0.14013116f, -0.00964996f, -0.13941948f, 0.13869119f, -0.12158111f, 0.11792658f, 0.08052031f, -0.12945314f, 
    -0.03909757f, -0.24420683f, -0.12629601f, -0.08452262f, 0.10322497f, -0.07360040f, -0.07966428f, 0.21442813f, 
    0.04053002f, 0.24035415f, -0.09774074f, -0.01057618f, 0.07347798f, 0.07700659f, 0.03259815f, 0.10250574f, 
    -0.07527496f, -0.12384650f, -0.28593647f, 0.05788575f, -0.10581268f, -0.15308620f, -0.19552995f, -0.02548763f, 
    -0.13400887f, 0.05681675f, -0.01676470f, 0.03048984f, 0.31893486f, 0.11047878f, -0.05150979f, -0.10846943f, 
    -0.01986754f, 0.07488010f, 0.11047845f, -0.24516596f, -0.23400517f, 0.08514743f, -0.11203814f, 0.15852699f, 
    -0.10074943f, 0.08978851f, -0.00889405f, 0.00658892f, 0.06223492f, -0.01530399f, 0.03577605f, -0.19598177f, 
    0.06959327f, 0.12398104f, 0.00790768f, -0.05734295f, -0.02440381f, 0.04191182f, -0.02756678f, 0.03501883f, 
    0.01390443f, -0.00901884f, 0.00674923f, 0.11281274f, -0.07917428f, 0.07752422f, -0.10763052f, -0.05394856f, 
    -0.04351441f, -0.03638695f, -0.03687947f, -0.02854356f, -0.02996741f, -0.00084259f, -0.01661907f, 0.00193633f, 
    -0.03804061f, -0.04523558f, -0.06447960f, -0.02029145f, 0.02132245f, 0.04418114f, 0.04078854f, -0.02085455f, 
    -0.04495047f, 0.00283602f, -0.01300606f, 0.00403620f, 0.03559079f, -0.04061319f, 0.01104579f, 0.00744948f, 
    -0.05887566f, -0.01542770f, -0.04133148f, -0.02970231f, -0.01944832f, -0.01983873f, 0.04125989f, 0.00384609f, 
    -0.02564957f, -0.05538323f, 0.03983756f, -0.06716908f, 0.04671314f, 0.04186208f, 0.04906499f, -0.02263060f, 
    -0.00991824f, 0.04891234f, -0.02894450f, 0.00083278f, 0.01296713f, -0.01749859f, -0.03365346f, -0.00294137f, 
    -0.04694964f, 0.04066318f, -0.01438708f, -0.03885469f, -0.04511856f, -0.02363681f, 0.03650944f, 0.03947764f, 
    0.05064067f, -0.03201747f, -0.04596674f, -0.06513037f, 0.01217290f, -0.05167509f, -0.06703168f, 0.00361611f, 
    0.04971559f, -0.03445538f, 0.04934944f, -0.00388745f, -0.03220969f, -0.00423855f, 0.02253906f, -0.00998879f, 
    0.00624645f, -0.01132286f, 0.01002296f, -0.03317412f, -0.00101086f, -0.01027622f, -0.06523057f, -0.04894382f, 
    -0.04411676f, 0.03237664f, -0.04712535f, 0.03771568f, 0.00420159f, -0.04140925f, 0.04682057f, 0.04741762f, 
    -0.00724618f, -0.05284720f, 0.01320508f, -0.05868856f, -0.01869831f, -0.02927089f, -0.04396965f, 0.02902057f, 
    -0.03025531f, -0.02655065f, 0.04313784f, 0.00670701f, -0.06374916f, -0.00831245f, -0.02281320f, 0.03165877f, 
    -0.03993545f, 0.04351871f, -0.05697198f, 0.02314250f, -0.05572729f, -0.00961807f, -0.02146812f, 0.05019064f, 
    0.02103993f, -0.04639070f, -0.04085265f, -0.05844565f, -0.01214085f, 0.03308154f, -0.05006227f, 0.02555289f, 
    -0.00014496f, -0.04460932f, -0.02406591f, 0.03557845f, -0.06854226f, -0.02015161f, 0.00920538f, 0.03047838f, 
    -0.03105601f, 0.02199993f, -0.00934302f, -0.02110686f, 0.02257659f, 0.02664858f, -0.03330459f, -0.02505006f, 
    0.04953930f, -0.01378892f, -0.04460241f, 0.03510407f, -0.02474933f, -0.01302765f, -0.00976042f, -0.04249001f, 
    -0.05947625f, -0.01046809f, -0.06269509f, 0.01844201f, -0.01140219f, 0.00557339f, 0.03646211f, 0.02856361f, 
    -0.06301866f, 0.03538353f, 0.01172321f, -0.00492397f, 0.02724653f, -0.00684318f, -0.06496677f, -0.00725010f, 
    0.02552063f, -0.06266222f, -0.06367890f, 0.03589544f, -0.06174400f, 0.03298965f, 0.00582207f, -0.01285444f, 
    0.03883703f, -0.05076683f, -0.04628236f, -0.05251969f, 0.04992475f, 0.00474843f, 0.02878484f, -0.05941155f, 
    0.01635502f, -0.06433080f, -0.04125736f, -0.02733188f, -0.05001327f, 0.03967482f, -0.04641688f, -0.05459133f, 
    -0.02102955f, -0.04166121f, -0.01483416f, -0.01497681f, 0.03984537f, -0.00231844f, 0.02341203f, -0.01527095f, 
    0.01075226f, 0.04701543f, 0.00330975f, -0.01894653f, -0.01771814f, -0.06468412f, 0.00313871f, 0.00795365f, 
    0.02636077f, 0.04725821f, -0.06045274f, -0.02682204f, -0.01129099f, -0.03666763f, -0.02491426f, -0.01660213f, 
    0.03235807f, 0.05226763f, -0.06165286f, 0.01629450f, -0.01649855f, -0.06148389f, -0.01158271f, -0.00893097f, 
    -0.06062122f, -0.06418975f, -0.02169190f, -0.00718688f, -0.06679139f, -0.03386829f, 0.00253176f, -0.03631929f, 
    -0.02581662f, -0.06055806f, 0.04563195f, 0.02412918f, 0.00451517f, -0.06693202f, 0.02748041f, -0.03014806f, 
    -0.04710881f, -0.04581603f, -0.05730456f, -0.04317798f, 0.01629243f, -0.01175991f, 0.02969321f, 0.01853766f, 
    0.02767738f, -0.01880978f, -0.01502037f, 0.01427973f, 0.03811428f, 0.02363648f, 0.02879704f, -0.01440377f, 
    0.01220606f, 0.01161419f, 0.04282067f, 0.02925918f, 0.00730716f, -0.05664777f, 0.01031739f, -0.02864225f, 
    0.02288268f, -0.02216177f, -0.01153381f, -0.05471948f, -0.01691073f, 0.04511160f, -0.00253620f, -0.05064523f, 
    0.00841330f, -0.03449929f, -0.04559704f, 0.00553631f, 0.04065755f, 0.00881984f, -0.02665779f, -0.01014032f, 
    0.03857554f, -0.00055485f, -0.03374507f, -0.03440634f, -0.04585639f, 0.01723036f, -0.03958021f, 0.03956415f, 
    -0.00222421f, -0.02180519f, 0.03248145f, -0.03973931f, 0.01684812f, 0.02177172f, 0.02360083f, -0.01285147f, 
    0.00072648f, 0.04258127f, 0.02607168f, -0.04079193f, 0.01471305f, 0.03123546f, 0.00125070f, 0.03314950f, 
    0.03889240f, 0.02083813f, 0.00284436f, -0.03776988f, -0.03389313f, -0.01006609f, 0.00524458f, 0.04830110f, 
    0.03038833f, 0.04867907f, 0.00091367f, -0.01203292f, -0.03173822f, -0.01460272f, 0.01302169f, 0.03874458f, 
    -0.03936748f, -0.06456229f, -0.05499926f, 0.03326505f, -0.06496007f, 0.00389140f, -0.05056481f, -0.01949006f, 
    0.02392289f, 0.00063125f, -0.03905496f, -0.01908843f, -0.05825338f, 0.03616765f, -0.06246799f, -0.05048589f, 
    0.00015968f, -0.05558150f, -0.03189996f, 0.02908286f, 0.00850850f, 0.02291465f, 0.04929723f, 0.04137922f, 
    -0.00856315f, -0.05560124f, 0.01479666f, -0.06169845f, -0.01259689f, 0.01681910f, -0.05926315f, 0.00596731f, 
    -0.01017502f, -0.01949563f, -0.00326185f, 0.02601076f, -0.01896423f, -0.01025867f, -0.05092737f, -0.02649261f, 
    -0.02685700f, 0.00706276f, 0.00445968f, -0.02803858f, -0.04113588f, -0.01447550f, 0.01914180f, 0.03457879f, 
    -0.02271155f, 0.03461023f, -0.00790831f, -0.00417698f, 0.00670169f, -0.00122004f, 0.00472833f, -0.00713776f, 
    -0.01585180f, -0.03267562f, -0.01012800f, 0.00134997f, -0.02962773f, 0.02063623f, -0.00718387f, 0.04170206f, 
    -0.05728677f, 0.01381511f, -0.02411528f, -0.00747926f, -0.02019404f, -0.03096328f, -0.05923615f, -0.01761125f, 
    0.02709336f, 0.02975274f, 0.04813299f, 0.04150253f, -0.04496270f, 0.00043493f, -0.02439717f, 0.02468782f, 
    -0.00232907f, 0.04825451f, 0.00470505f, 0.00488009f, 0.04283234f, 0.04929892f, -0.02127439f, -0.05174353f, 
    -0.05864047f, -0.01303266f, -0.01868234f, 0.00352484f, -0.04600249f, -0.02374432f, -0.02485688f, -0.01158958f, 
    -0.03656276f, 0.04674213f, 0.00606269f, -0.01278899f, 0.01190322f, -0.00575701f, 0.04059218f, -0.03002292f, 
    -0.03942003f, -0.02684527f, -0.04627942f, 0.03415543f, 0.03439313f, -0.03884640f, -0.02756289f, 0.00844410f, 
    0.01857876f, -0.02416331f, -0.00897676f, -0.05070670f, 0.02896298f, -0.01210029f, -0.03575515f, -0.05062772f, 
    -0.03836832f, 0.03706818f, 0.01078273f, 0.00887943f, 0.04263165f, -0.00131164f, -0.00267440f, 0.02533607f, 
    -0.03015005f, -0.03038026f, -0.05007936f, -0.06209715f, -0.03359238f, 0.04516452f, 0.02190889f, 0.02085055f, 
    -0.04602823f, 0.01488810f, -0.01942880f, -0.04267874f, -0.03251600f, -0.02693502f, -0.06037774f, -0.04606677f, 
    -0.00025102f, -0.00271884f, -0.03802137f, 0.03361855f, -0.02022319f, 0.02861423f, -0.00441425f, -0.06022006f, 
    -0.01771688f, -0.05144703f, 0.02828646f, -0.03342979f, -0.00107510f, 0.00777272f, -0.04191913f, -0.06175456f, 
    0.00413039f, -0.05565077f, -0.01310617f, 0.02797864f, 0.02102790f, 0.04551144f, -0.01565327f, -0.06347337f, 
    0.01878344f, -0.02926584f, 0.01526667f, -0.01717062f, -0.01995517f, 0.04873187f, -0.00754394f, -0.04283946f, 
    0.04439324f, -0.02598777f, -0.01719996f, -0.05600433f, -0.00894392f, -0.00767550f, 0.03529278f, -0.04135098f, 
    -0.00220138f, 0.02672821f, 0.04467420f, 0.00021204f, -0.03739069f, 0.04960997f, -0.02964833f, -0.04041855f, 
    0.03215096f, -0.05828685f, -0.03964854f, -0.03805113f, 0.00586950f, -0.04553719f, -0.03625361f, -0.01133156f, 
    -0.00362441f, 0.03224523f, 0.02567776f, 0.02650728f, -0.05875925f, -0.00781000f, -0.01966817f, 0.01413801f, 
    0.03440849f, -0.01885561f, 0.01421703f, -0.05151168f, 0.04329823f, -0.03836410f, 0.03186138f, -0.03375119f, 
    0.01126157f, -0.00799682f, -0.03103174f, 0.00548962f, -0.00956816f, -0.06600899f, -0.01255166f, 0.03892865f, 
    0.02137731f, 0.03107301f, 0.00111241f, -0.01316105f, 0.01699358f, 0.00474284f, 0.01086210f, -0.03083088f, 
    0.01147273f, 0.02496527f, -0.01654067f, 0.00158368f, -0.04202331f, -0.00145301f, -0.03450308f, -0.06004035f, 
    0.03665493f, 0.04303949f, -0.03269615f, 0.03837130f, -0.00906377f, 0.00308006f, -0.05692782f, 0.04849818f, 
    0.01063929f, -0.05586159f, -0.03965099f, -0.03163940f, -0.04251434f, -0.05394527f, -0.04421788f, -0.06063091f, 
    0.01013159f, -0.05863952f, -0.04928139f, 0.03909742f, -0.04263637f, 0.02905748f, -0.02728523f, -0.02087160f, 
    0.00052393f, 0.02399798f, -0.01117012f, 0.01276598f, -0.03874144f, -0.01084426f, -0.01581017f, 0.00449563f, 
    0.02212278f, 0.27219164f, 0.16654627f, -0.01301021f, -0.19786844f, 0.06459726f, -0.05603174f, -0.03752959f, 
    0.07982601f, -0.04779201f, 0.04033050f, 0.06377097f, 0.06913199f, 0.04936500f, 0.27459720f, 0.00542838f, 
    0.00822847f, 0.01435674f, 0.38511053f, 0.08388392f, -0.13191546f, 0.15023415f, 0.03256217f, 0.03120630f, 
    -0.07896544f, 0.03869711f, -0.04302115f, 0.03773303f, 0.06041973f, -0.03569879f, 0.18579198f, 0.09784030f, 
    -0.02384656f, 0.11760131f, 0.06054430f, 0.23504689f, -0.09607968f, -0.01266073f, -0.10139452f, 0.18928564f, 
    0.01042056f, 0.01028693f, -0.03267762f, 0.00277091f, -0.19563898f, 0.06391512f, 0.07720432f, -0.23590462f, 
    0.21349189f, 0.04551234f, 0.06637870f, 0.06261976f, 0.04421439f, -0.00478954f, -0.17293172f, 0.21687756f, 
    0.01496781f, 0.00806915f, 0.18890820f, 0.04170531f, 0.28209907f, 0.14893685f, -0.11924805f, -0.25382298f, 
    -0.05752412f, 0.12304429f, 0.20879832f, 0.15583006f, 0.04913518f, -0.06404556f, -0.13316667f, 0.00617268f, 
    -0.03878337f, -0.03942996f, -0.20636185f, -0.01741430f, 0.08283751f, -0.07184234f, 0.11054108f, 0.04355595f, 
    0.03931887f, -0.10000671f, -0.08289168f, -0.27999452f, -0.11467977f, -0.03645336f, -0.10348175f, 0.01721845f, 
    -0.02745713f, 0.05697159f, -0.27623191f, -0.06130255f, 0.08739745f, -0.09647156f, -0.13851063f, -0.02784976f, 
    0.05618114f, 0.02883515f, 0.11839540f, -0.02577074f, 0.03002561f, -0.04460584f, 0.06141808f, -0.09828658f, 
    -0.05031219f, -0.02798610f, 0.12281098f, 0.10554557f, 0.07592428f, -0.07612538f, 0.23109537f, -0.10788179f, 
    -0.12378705f, -0.07913323f, 0.01467824f, -0.07625250f, 0.08994212f, -0.14055742f, 0.09804071f, -0.23865183f, 
    0.18874145f, 0.04765422f, 0.10624812f, 0.08185381f, 0.20775491f, -0.01322025f, -0.09860454f, -0.02852746f, 
    -0.14951381f, 0.18945380f, 0.06020223f, 0.12787351f, -0.00725667f, -0.07857259f, -0.13451061f, -0.22593780f, 
    -0.00014470f, 0.20876332f, 0.06370213f, 0.03171838f, -0.09595978f, -0.02719196f, -0.02191193f, -0.05694162f, 
    -0.04055579f, -0.14366293f, 0.32113481f, -0.10751822f, 0.06619369f, 0.04831577f, -0.13066541f, 0.05656113f, 
    0.23246776f, 0.13690519f, -0.13605617f, 0.07959259f, -0.09698964f, 0.02214706f, 0.05145613f, 0.11454610f, 
    0.07654639f, 0.10476796f, 0.00858742f, -0.01735581f, 0.10367497f, 0.07590090f, 0.09387691f, -0.01607878f, 
    -0.16331868f, -0.01299918f, -0.01225570f, -0.25820115f, -0.16665587f, 0.03258784f, -0.07539690f, 0.23143326f, 
    -0.17620128f, -0.08299402f, 0.07921072f, 0.19434495f, -0.06630103f, 0.29360184f, -0.00943107f, -0.12812650f, 
    -0.00901385f, -0.20388435f, 0.07938718f, 0.12944727f, 0.02686157f, 0.33110783f, -0.12018233f, -0.17358465f, 
    -0.04492955f, 0.07189843f, 0.05757526f, -0.01443470f, 0.07966541f, -0.07922786f, -0.24134836f, -0.20188762f, 
    0.32767490f, 0.15111192f, 0.20998238f, -0.11735481f, -0.04137123f, -0.05585740f, 0.06930816f, 0.06480185f, 
    -0.38459444f, -0.22440809f, -0.14557934f, 0.01504786f, -0.14604132f, -0.14222077f, 0.05758487f, -0.08376268f, 
    -0.10696722f, -0.06097685f, -0.05853535f, -0.09038341f, 0.02036500f, -0.03606383f, 0.17553975f, 0.07598215f, 
    0.07464097f, 0.08453669f, 0.14658977f, -0.09217273f, -0.08050816f, 0.16212569f, 0.17877132f, 0.16130558f, 
    0.24054679f, -0.05308641f, 0.09262422f, 0.10130471f, -0.19934885f, 0.18742441f, -0.17357533f, 0.05736761f, 
    0.15482701f, -0.18767305f, -0.04120774f, -0.04767120f, -0.04885206f, -0.09333439f, 0.40353692f, -0.10023984f, 
    -0.05121965f, -0.18731076f, -0.02396338f, -0.24728557f, 0.14455290f, 0.08703870f, -0.10875277f, 0.18370573f, 
    0.29287314f, 0.09191390f, 0.09839883f, -0.01733883f, -0.16268735f, 0.29815769f, 0.14967161f, 0.07585208f, 
    -0.20378362f, -0.08978738f, 0.08440514f, 0.16631398f, 0.19525605f, 0.13437191f, -0.21651746f, 0.08705279f, 
    -0.22461998f, 0.33219042f, -0.02827269f, 0.15163587f, -0.04952031f, 0.06084420f, -0.27603632f, 0.04030856f, 
    0.35862815f, 0.23021665f, -0.18681087f, -0.01495520f, -0.03255492f, -0.19472989f, 0.09390225f, -0.04937878f, 
    0.24640238f, 0.21071818f, -0.15212612f, 0.15153465f, -0.22357114f, 0.05119869f, 0.18441211f, -0.12759854f, 
    0.01363255f, 0.30546591f, 0.20783541f, -0.01238204f, -0.00161676f, -0.12437553f, -0.13066511f, 0.08373586f, 
    -0.00336445f, 0.09159751f, -0.22103260f, -0.07005628f, -0.03063052f, 0.09889866f, 0.12655580f, -0.01231390f, 
    -0.01579288f, 0.06879957f, 0.00449718f, 0.05847064f, 0.12845159f, 0.12306482f, -0.01989177f, 0.05239327f, 
    -0.01319426f, 0.01540257f, 0.24802695f, 0.13780886f, -0.05198712f, 0.04117153f, -0.01973278f, 0.13859802f, 
    -0.13612695f, 0.00377386f, 0.09279882f, -0.09504317f, -0.14399287f, -0.33020854f, -0.30065304f, -0.07319805f, 
    0.04854344f, 0.14939690f, -0.06058119f, -0.17681620f, -0.10596287f, -0.17189957f, -0.12788731f, 0.07049976f, 
    -0.24962740f, 0.03563653f, 0.11922561f, 0.09492648f, -0.06120499f, 0.03504113f, -0.24049185f, 0.17774665f, 
    0.21468145f, 0.18280464f, -0.11830585f, -0.21937607f, -0.06569196f, 0.01655032f, 0.04458279f, 0.05415658f, 
    0.19717523f, 0.03771153f, 0.07070880f, -0.14281648f, -0.08822597f, -0.06746285f, -0.02102653f, 0.07051484f, 
    -0.01746035f, 0.01300502f, -0.02994117f, -0.12003633f, 0.02438559f, -0.09497673f, 0.05880427f, 0.01587356f, 
    0.02168452f, 0.11634379f, 0.02100662f, 0.02943136f, 0.23925100f, -0.02070674f, 0.03067035f, -0.03476932f, 
    -0.01412001f, 0.12419806f, -0.05645268f, -0.14375402f, 0.05743904f, 0.02395540f, -0.01510454f, -0.13461250f, 
    -0.18491346f, -0.03715245f, 0.07270031f, 0.10884674f, 0.13893409f, 0.33467132f, -0.01969582f, -0.05760015f, 
    -0.09682144f, -0.02113805f, -0.09439893f, 0.10609169f, -0.12184436f, -0.15981250f, -0.28059229f, -0.19730291f, 
    0.07014655f, 0.20528451f, 0.07324914f, 0.09074585f, 0.07052126f, -0.00781879f, 0.11466520f, 0.04565471f, 
    -0.18101087f, -0.18088618f, 0.05305450f, -0.22998023f, 0.03832397f, 0.06159353f, 0.09704079f, -0.10248251f, 
    0.03632547f, 0.20379189f, -0.14292777f, -0.08409964f, -0.06202053f, 0.02548546f, -0.05813143f, -0.06014585f, 
    0.10089546f, 0.11468984f, 0.15990870f, 0.00323005f, 0.07928473f, -0.00781767f, -0.05034595f, 0.03074643f, 
    0.04222784f, 0.10798779f, 0.02515364f, -0.12873641f, 0.03360203f, -0.22824223f, -0.10978041f, 0.13416837f, 
    -0.02280831f, 0.02773550f, 0.02431714f, 0.08995339f, -0.10407413f, -0.18020980f, 0.00156392f, -0.00646104f, 
    0.14631632f, 0.00920786f, 0.05901615f, -0.09080335f, -0.01322566f, 0.12496445f, 0.11789068f, 0.01033313f, 
    -0.14939824f, -0.05905708f, 0.06172419f, -0.08551954f, -0.24077061f, -0.14342964f, 0.27938697f, 0.14639880f, 
    -0.02237077f, 0.02169758f, -0.17727968f, 0.01683119f, -0.20740406f, -0.18195592f, -0.10096683f, -0.10183106f, 
    -0.17145589f, 0.05592282f, 0.03245163f, 0.14614190f, -0.02454803f, 0.05499629f, -0.06701186f, 0.12036505f, 
    0.02988931f, 0.04310041f, 0.05645312f, -0.00603309f, -0.05467367f, 0.09545439f, 0.00744699f, 0.11409523f, 
    0.06189984f, -0.21684144f, -0.17610165f, 0.04252707f, -0.03040366f, 0.32450169f, 0.04964565f, -0.01897399f, 
    0.20351805f, -0.12262321f, -0.00811516f, -0.09482926f, -0.09025575f, -0.03418387f, 0.05338743f, -0.01878952f, 
    0.12730178f, 0.07471267f, -0.15618919f, -0.03191112f, 0.14245869f, 0.11991488f, -0.05749708f, -0.07495846f, 
    0.14926724f, 0.07242844f, -0.01974299f, 0.05872004f, -0.17057724f, 0.03928249f, 0.01362762f, -0.06652567f, 
    -0.06291033f, -0.01430978f, -0.05079811f, 0.22291267f, 0.34516951f, -0.10878921f, -0.16405247f, -0.06244818f, 
    0.01757604f, 0.26689658f, 0.13067354f, 0.06757981f, -0.02023681f, -0.10327674f, 0.05912298f, 0.11490923f, 
    0.07586496f, 0.05569392f, -0.02006004f, -0.06586105f, -0.15203422f, 0.10503787f, -0.02785557f, 0.09056231f, 
    -0.00530426f, -0.06918436f, -0.01095762f, -0.00332178f, 0.06494927f, 0.02565278f, 0.04350704f, 0.00827441f, 
    -0.08371134f, 0.17343780f, 0.12520771f, 0.12320290f, 0.09201191f, -0.10144150f, -0.07137021f, 0.09011887f, 
    -0.15216058f, -0.11410699f, 0.11475437f, -0.08312417f, -0.05076963f, -0.04712275f, 0.09269235f, 0.15995862f, 
    0.02652435f, 0.04914326f, -0.03593377f, -0.00754922f, 0.02018449f, 0.00246132f, 0.03320558f, 0.03817520f, 
    -0.00502947f, 0.02285244f, 0.03820178f, 0.03982518f, 0.01760121f, -0.03160349f, -0.04240501f, 0.04743152f, 
    0.02358828f, -0.06342725f, -0.00544696f, 0.03557998f, -0.06163877f, 0.02728962f, -0.02703288f, 0.02463761f, 
    0.01256323f, -0.02825681f, -0.06482131f, 0.02908466f, -0.05858278f, 0.00459223f, -0.06114452f, -0.01208314f, 
    0.00183206f, 0.04118443f, -0.03542485f, -0.03551719f, 0.05595262f, 0.03455923f, -0.02642920f, -0.01258961f, 
    0.02740724f, 0.02376661f, 0.03109138f, -0.03541762f, -0.02389278f, 0.04953425f, 0.01700541f, 0.02497151f, 
    -0.03120149f, 0.01187553f, -0.02254960f, 0.01617532f, -0.01988449f, 0.00730709f, -0.02947415f, -0.05018644f, 
    0.01726169f, 0.03628072f, 0.00513144f, 0.02435716f, -0.00063427f, -0.06057387f, 0.03561095f, -0.02635483f, 
    -0.05461514f, -0.05956449f, -0.06708000f, 0.03666517f, -0.02991852f, 0.02355374f, -0.05867513f, 0.00696313f, 
    0.02791209f, -0.05943004f, -0.06316338f, -0.00283599f, -0.00247882f, -0.04092507f, -0.03582529f, -0.04369663f, 
    -0.04496186f, 0.01913322f, -0.06082487f, 0.02502284f, -0.06799538f, -0.05200294f, -0.06884074f, -0.04746335f, 
    0.03716046f, 0.01015088f, 0.04794563f, -0.04168719f, 0.00297398f, -0.05412369f, 0.05288326f, 0.01212990f, 
    -0.01359200f, -0.01224178f, 0.01851969f, -0.02879522f, 0.02330300f, 0.01465110f, -0.05110294f, 0.00050859f, 
    -0.06865989f, 0.03742649f, 0.00932873f, 0.02918277f, -0.05641679f, -0.00938335f, -0.06859034f, -0.01438310f, 
    -0.06368306f, 0.04659783f, 0.05262482f, 0.03053896f, -0.00483924f, 0.01984925f, 0.04779905f, -0.02548341f, 
    0.01340381f, -0.06026253f, -0.02501720f, -0.04342631f, 0.04751611f, -0.04288683f, -0.02413851f, -0.04109879f, 
    -0.03371545f, -0.03301242f, -0.05761236f, 0.02334419f, -0.00569549f, -0.00615075f, -0.04308581f, -0.02607107f, 
    0.01601767f, 0.00234360f, 0.03378218f, 0.01411935f, -0.04072811f, -0.03053889f, 0.03007600f, -0.00686778f, 
    0.00448720f, 0.01016918f, -0.03205543f, 0.01657740f, 0.04787204f, -0.02470618f, -0.02395718f, 0.02744223f, 
    -0.06817206f, -0.02017429f, -0.05086652f, -0.05181384f, 0.04127433f, -0.04221612f, 0.00868631f, -0.01009280f, 
    -0.06823097f, 0.00534778f, -0.05438982f, 0.04052716f, -0.03985839f, -0.01382816f, 0.00030305f, -0.05479504f, 
    -0.05228875f, 0.00520058f, -0.03237952f, -0.03577677f, -0.06110159f, 0.03353892f, -0.02254094f, -0.00904891f, 
    -0.01147709f, -0.04089897f, -0.00454748f, 0.03777463f, 0.03846471f, 0.01201769f, -0.04071898f, 0.01468705f, 
    -0.05138140f, -0.04560224f, -0.03146884f, -0.01091566f, -0.02826963f, 0.01040254f, -0.04931975f, 0.00144361f, 
    0.04588616f, 0.02792641f, 0.02351750f, -0.01747269f, -0.04387011f, 0.05316662f, -0.04232205f, 0.04775180f, 
    0.00647010f, 0.03927586f, -0.03489026f, 0.03071913f, -0.02176345f, -0.01697297f, -0.01325509f, 0.02810953f, 
    -0.06600553f, -0.01141110f, -0.02730760f, -0.04630234f, -0.03216924f, -0.02879955f, -0.03841485f, -0.03417494f, 
    0.01930572f, -0.04384087f, 0.04406982f, 0.00793972f, -0.00819835f, 0.00915363f, -0.05359822f, -0.03584199f, 
    0.00853947f, -0.06396895f, 0.01337071f, 0.00102689f, -0.04240604f, -0.01234870f, -0.04193389f, 0.03496911f, 
    0.00811845f, 0.01258260f, -0.02950423f, 0.03981023f, 0.01567155f, -0.05292417f, 0.02130649f, -0.03469121f, 
    0.04270389f, -0.00441843f, -0.01173387f, 0.04248554f, -0.04031028f, 0.03428176f, -0.01719947f, 0.01879671f, 
    0.01998958f, -0.00281173f, -0.03868452f, 0.02938622f, -0.04923286f, -0.01994455f, 0.00973182f, -0.00947649f, 
    0.02504612f, -0.06490605f, 0.02155403f, -0.03405490f, -0.00112061f, 0.04448608f, -0.00049415f, -0.03716291f, 
    0.02783670f, 0.04447325f, -0.03644367f, 0.00594861f, -0.01411171f, -0.02990304f, 0.05229995f, 0.04652682f, 
    -0.00645962f, 0.05076777f, -0.02563577f, 0.01122859f, -0.00735470f, 0.00271834f, -0.03298711f, -0.05562574f, 
    -0.02599128f, 0.00879320f, -0.03324337f, -0.05305949f, -0.00391357f, 0.03510693f, 0.01661435f, 0.02460226f, 
    -0.30746490f, -0.14557119f, -0.27785587f, 0.08348646f, 0.21951441f, 0.03748147f, -0.10362495f, 0.04001956f, 
    -0.19493896f, -0.14028436f, -0.01078915f, -0.04652284f, 0.02686506f, 0.04570573f, 0.01555353f, 0.20377842f, 
    -0.14361298f, 0.06695996f, 0.15393493f, 0.16022176f, 0.05216041f, -0.05946530f, 0.07234985f, 0.01867874f, 
    -0.25794142f, 0.10760216f, -0.16387829f, -0.06620498f, -0.03505697f, -0.09450004f, 0.08924432f, -0.05552540f, 
    0.14568815f, 0.02660595f, -0.08830047f, -0.04793813f, 0.13834988f, 0.14286587f, -0.02617969f, -0.01792038f, 
    -0.26956084f, 0.03676748f, -0.15557277f, -0.13980049f, 0.17833751f, 0.14695497f, 0.11540724f, 0.19073842f, 
    -0.05030830f, 0.06659405f, 0.09012599f, -0.09021024f, 0.03239593f, 0.04670875f, 0.09179758f, -0.02680899f, 
    -0.12903549f, -0.02682517f, 0.01456598f, -0.07072187f, 0.08486214f, 0.14353389f, 0.08287324f, -0.12264998f, 
    -0.17830029f, 0.01233167f, -0.06063046f, -0.08546560f, 0.08535127f, 0.12369189f, -0.07024500f, 0.02077470f, 
    -0.02938989f, 0.04834031f, -0.04024363f, -0.00682677f, 0.05941631f, 0.13555385f, -0.12958427f, -0.01964816f, 
    -0.04256830f, 0.10837882f, 0.03022583f, 0.14336042f, -0.03279354f, 0.03262856f, 0.18121971f, -0.03913265f, 
    0.08646937f, -0.06018661f, 0.10648239f, 0.07879983f, -0.00840934f, 0.07161223f, -0.04711313f, -0.12238715f, 
    0.22583467f, 0.11047973f, -0.09082752f, 0.13008897f, 0.10852528f, -0.08487630f, -0.00672813f, 0.05061569f, 
    0.18496512f, -0.07187492f, -0.02207232f, 0.18864027f, -0.29186118f, -0.27432925f, -0.24349207f, 0.04094882f, 
    -0.03231080f, 0.01424342f, 0.00565071f, -0.00840244f, 0.04808670f, -0.07747917f, 0.00297422f, -0.06372915f, 
    -0.00188626f, -0.01761136f, 0.19498008f, 0.06102375f, 0.07183999f, 0.14514387f, -0.15774785f, 0.11892301f, 
    0.01262019f, 0.01713980f, 0.01468119f, -0.10709587f, 0.07388860f, -0.12909298f, 0.06476784f, 0.03363338f, 
    -0.07841523f, -0.14781711f, -0.11589970f, 0.05725801f, 0.04087623f, 0.02261391f, 0.10804218f, -0.04680053f, 
    0.02278098f, 0.18491231f, -0.33794880f, 0.03189655f, -0.02270948f, 0.02426050f, -0.09376393f, 0.00750886f, 
    -0.11074555f, -0.13932997f, 0.06488558f, -0.17789713f, 0.06986046f, 0.09830052f, -0.07857769f, -0.06862702f, 
    0.09790331f, 0.06182535f, -0.22369011f, -0.15111797f, -0.13872249f, 0.01119448f, 0.03244264f, 0.02842898f, 
    0.05557453f, -0.01235458f, 0.06456641f, -0.03336483f, 0.03703462f, -0.07037822f, 0.03886662f, 0.07627025f, 
    0.10338504f, -0.01510130f, 0.11245829f, 0.17281392f, 0.05050226f, -0.24270102f, 0.04475434f, 0.09373557f, 
    -0.10612683f, -0.12061747f, -0.17202659f, -0.17420535f, 0.06774376f, 0.11080820f, 0.11387789f, 0.09107617f, 
    0.02896195f, 0.04652975f, 0.10913481f, -0.07914875f, 0.09391865f, -0.17806283f, -0.08287208f, 0.15646456f, 
    -0.10189710f, -0.06902517f, -0.05172125f, 0.18663777f, 0.03268601f, 0.08935904f, -0.15098768f, -0.12969209f, 
    0.27537873f, -0.01903304f, -0.13454036f, -0.06211530f, 0.05144340f, -0.22792128f, -0.01287108f, -0.08534985f, 
    0.05704472f, 0.08810472f, -0.23903464f, 0.04277390f, 0.16356455f, -0.00546088f, 0.03978506f, 0.12467346f, 
    0.03587842f, -0.07243971f, 0.01982512f, 0.11437412f, 0.07090596f, 0.05870324f, -0.10601953f, 0.00892479f, 
    0.14141478f, 0.03623857f, -0.08668559f, 0.05007351f, 0.08884164f, -0.01183918f, 0.00061072f, 0.05179159f, 
    -0.03424640f, -0.10331462f, -0.00334638f, -0.25949967f, -0.31411698f, -0.18712670f, 0.01324405f, 0.04014207f, 
    0.12855420f, 0.14755993f, -0.20207016f, -0.10975404f, 0.04964921f, 0.11057575f, 0.06976417f, -0.00008864f, 
    -0.07965148f, 0.09224610f, 0.18700825f, 0.02351115f, 0.05882343f, -0.13588215f, -0.04866615f, -0.13194513f, 
    0.00147759f, 0.09511498f, -0.20249751f, 0.11213175f, -0.05053972f, -0.15280432f, 0.05079250f, 0.05206784f, 
    0.18648134f, -0.01288329f, 0.09588261f, 0.02936710f, 0.13478315f, 0.01571653f, -0.03240267f, -0.02429398f, 
    0.14423122f, 0.02247247f, 0.07860962f, 0.00610144f, -0.12759371f, -0.06383070f, -0.09494137f, 0.04099285f, 
    -0.04764343f, -0.37077898f, -0.41991368f, -0.12759972f, -0.06870368f, 0.06809880f, -0.06459181f, 0.04320264f, 
    0.03619948f, 0.07677894f, 0.08936703f, 0.01924279f, 0.19792652f, -0.17717271f, -0.01792674f, -0.07179007f, 
    -0.07116852f, -0.12998587f, 0.40658966f, -0.00639278f, -0.00257063f, -0.12973735f, -0.04390107f, 0.05399532f, 
    0.10914560f, 0.11211883f, -0.02019684f, 0.05134403f, -0.24743703f, -0.04170909f, 0.06295272f, 0.20167434f, 
    0.10203049f, 0.05198673f, 0.07712600f, -0.02447633f, -0.05471751f, 0.05530115f, -0.02326458f, 0.20048621f, 
    -0.10875580f, -0.13600755f, 0.03424336f, -0.05930570f, -0.03892851f, 0.37324303f, 0.22779067f, -0.01674291f, 
    -0.17492814f, -0.07296533f, 0.17113915f, 0.17115709f, -0.05076399f, 0.17513305f, 0.03571159f, -0.03685758f, 
    -0.17476723f, -0.01919371f, -0.13358884f, 0.01715213f, -0.13573372f, -0.22276764f, -0.17264330f, 0.16891062f, 
    0.08664601f, 0.08123692f, 0.22892283f, -0.01850064f, 0.07985748f, 0.07695714f, -0.21281728f, 0.02726250f, 
    -0.19553627f, -0.04983228f, -0.21124709f, 0.15094194f, 0.05206743f, 0.14067625f, -0.03831642f, 0.09019291f, 
    -0.03330308f, 0.15819730f, 0.12704307f, -0.00367636f, 0.01970734f, 0.03635744f, -0.18154606f, 0.08352905f, 
    -0.08092672f, 0.05079855f, 0.04865448f, -0.34533647f, -0.21275419f, 0.09630824f, 0.15405664f, -0.08465956f, 
    0.09230911f, 0.05421321f, -0.11658756f, 0.11842494f, -0.03427817f, -0.32119006f, 0.18046510f, 0.16440199f, 
    0.16445602f, 0.01825985f, -0.07625408f, 0.09157142f, 0.38579309f, -0.16096219f, -0.10647726f, 0.18692230f, 
    -0.13729966f, -0.05359282f, 0.10555833f, 0.00134531f, 0.03515086f, 0.14237653f, 0.19457191f, 0.04243582f, 
    -0.24129863f, -0.15159285f, 0.04140481f, -0.14563900f, -0.00729741f, 0.14368439f, -0.23247947f, 0.04171388f, 
    0.18613376f, 0.15861470f, -0.05814928f, -0.02359560f, -0.06579028f, 0.01614902f, -0.08263783f, 0.19378589f, 
    0.21464804f, 0.19777405f, 0.12187377f, 0.03345104f, -0.08707539f, -0.06326248f, 0.02201573f, 0.12630200f, 
    0.30332518f, 0.02509904f, -0.06788921f, 0.19666009f, -0.04792571f, 0.06989379f, 0.00936227f, -0.04760113f, 
    -0.01031641f, 0.05438393f, 0.12084097f, -0.08887593f, 0.14556935f, 0.09063686f, 0.03173723f, 0.01947824f, 
    -0.16872999f, -0.09951558f, 0.06628735f, -0.18174657f, 0.01466225f, -0.14538990f, 0.07733537f, -0.02266420f, 
    -0.14918876f, -0.02972632f, 0.10786826f, 0.06311686f, 0.12438715f, -0.11813083f, -0.00902331f, -0.15246285f, 
    -0.02243767f, 0.04215422f, 0.10583241f, 0.04126114f, 0.04892883f, 0.12056849f, -0.26910242f, -0.05609675f, 
    0.01674813f, 0.14437036f, -0.28110319f, -0.11373460f, 0.12510180f, 0.28591299f, 0.06511375f, -0.08242293f, 
    -0.02305108f, -0.16428803f, -0.07227246f, 0.02836930f, 0.11253218f, -0.12476086f, 0.22039971f, 0.31740141f, 
    0.03141881f, 0.08396535f, -0.19744281f, 0.17850322f, -0.11682154f, 0.05695337f, 0.09706105f, -0.35177687f, 
    -0.02859858f, 0.05496359f, 0.17204642f, -0.08482322f, 0.14943922f, -0.02907885f, -0.05363620f, 0.12308009f, 
    -0.10082906f, -0.12804645f, -0.18223943f, 0.10494130f, 0.10459851f, -0.01399216f, -0.06031993f, 0.00081525f, 
    0.04721954f, 0.07479294f, 0.00331390f, 0.07533149f, 0.08801509f, -0.05131641f, -0.21731117f, 0.03136207f, 
    -0.02637993f, -0.09503098f, -0.24013604f, -0.00709828f, 0.12078176f, 0.14720134f, -0.00814666f, -0.04200155f, 
    -0.10434268f, -0.19922782f, -0.08395164f, 0.20428911f, -0.29956400f, 0.03245668f, 0.03316564f, 0.15698989f, 
    0.03574561f, -0.11779256f, -0.14805722f, 0.06612790f, 0.46707764f, 0.17118947f, 0.18972236f, 0.00265678f, 
    -0.15887822f, -0.12356576f, -0.09746446f, 0.02331661f, 0.01092936f, 0.09256449f, -0.06386642f, -0.06296530f, 
    0.07288906f, -0.07774570f, 0.09388504f, 0.00378646f, 0.10487214f, -0.04879133f, -0.17457238f, -0.00751926f, 
    -0.01851655f, 0.08860595f, 0.04887466f, 0.04817177f, 0.02715744f, -0.00335955f, -0.16161910f, 0.04445894f, 
    -0.13560827f, -0.32666659f, 0.04621482f, -0.14805675f, 0.19297990f, -0.10772739f, -0.05092168f, -0.01366786f, 
    -0.16195515f, -0.03398242f, -0.24134527f, -0.03705447f, 0.02406611f, 0.08735673f, -0.08357017f, -0.01410013f, 
    -0.02359010f, 0.01809224f, -0.06138979f, 0.01886314f, -0.18184024f, -0.00228735f, -0.09981639f, -0.02585941f, 
    0.07002743f, -0.06044456f, -0.00189924f, -0.10770781f, -0.09312222f, 0.15740143f, -0.05282452f, -0.00889382f, 
    -0.10879166f, 0.03118729f, 0.19394784f, -0.06983478f, 0.10435894f, -0.03515181f, 0.04421546f, 0.03074649f, 
    0.06416571f, -0.20212005f, 0.09128439f, 0.07781699f, -0.02808646f, -0.00279227f, 0.04091893f, 0.05036488f, 
    -0.17891745f, -0.11980162f, 0.12140912f, -0.04648180f, 0.11798228f, -0.18196966f, -0.12415339f, 0.11354013f, 
    0.18750167f, -0.07588691f, 0.04504103f, 0.00291841f, -0.05523228f, -0.07620391f, 0.01550786f, -0.29138854f, 
    0.05038503f, 0.04959682f, -0.11367229f, -0.09844651f, 0.13991496f, -0.03193251f, 0.03275289f, 0.15893704f, 
    0.33070254f, 0.22011639f, -0.09674130f, 0.18215448f, -0.08693422f, -0.06080616f, 0.03400103f, -0.05229679f, 
    0.24503036f, -0.02916105f, -0.15519758f, 0.01438301f, 0.03289832f, 0.01797650f, -0.07559559f, -0.05566946f, 
    0.05305593f, -0.35590523f, -0.03103004f, -0.04353952f, -0.08300754f, -0.02969744f, 0.03425097f, -0.00544248f, 
    -0.22802210f, -0.14986259f, 0.12793063f, 0.09637587f, -0.21914658f, -0.00337764f, 0.00303921f, 0.11443459f, 
    0.04216715f, -0.02448941f, 0.09129827f, -0.10946932f, 0.07019555f, -0.08179384f, -0.14405315f, 0.03180263f, 
    0.15356016f, -0.01641326f, 0.03831897f, 0.02399901f, 0.16607000f, 0.20759018f, 0.16360915f, -0.12051527f, 
    0.05619663f, -0.01378463f, 0.02145709f, -0.12204914f, 0.08560704f, 0.05756046f, 0.10423434f, -0.18440270f, 
    -0.03873065f, -0.00339674f, 0.00904694f, -0.08889327f, -0.02986606f, 0.03194428f, 0.02888386f, 0.08579656f, 
    -0.15494150f, 0.07175541f, -0.13287783f, 0.06127541f, 0.19162722f, 0.02612234f, 0.19192478f, -0.00337067f, 
    0.35385904f, 0.05289092f, 0.04541160f, -0.05356145f, 0.00738703f, 0.04349205f, 0.01974432f, 0.03098410f, 
    0.23630342f, 0.10164431f, -0.00274645f, 0.06051698f, 0.03348897f, 0.00341608f, -0.03488200f, -0.07872771f, 
    -0.01818767f, 0.04170630f, 0.16746368f, -0.06309243f, -0.00187958f, 0.03489883f, 0.18602204f, -0.08224176f, 
    0.05436672f, 0.00893767f, 0.24719660f, -0.02367719f, -0.01931248f, 0.08599380f, 0.02072228f, -0.01000934f, 
    0.15109956f, 0.04319047f, 0.04313977f, -0.05847732f, 0.03049315f, -0.16962066f, 0.01831681f, -0.10105755f, 
    -0.04093704f, 0.00968990f, 0.14178300f, 0.09786452f, 0.02054432f, -0.30769113f, -0.02208236f, -0.03783932f, 
    -0.06934482f, 0.07028472f, -0.01073873f, -0.09528055f, -0.14505821f, 0.00095200f, -0.26716611f, -0.00267746f, 
    0.12029091f, -0.05896294f, -0.04164105f, -0.05199053f, -0.02634729f, 0.08938792f, 0.12019564f, 0.32496500f, 
    0.06833360f, 0.07722949f, -0.06733056f, 0.26941553f, 0.04557381f, -0.04641663f, -0.01139797f, -0.19281542f, 
    -0.12202696f, -0.22207107f, -0.04987772f, -0.03227492f, 0.04904713f, 0.08963304f, -0.05729868f, 0.22031528f, 
    -0.44829398f, -0.20803291f, -0.00925726f, 0.08311348f, 0.10453899f, -0.09979814f, -0.06598930f, 0.02713435f, 
    0.06900430f, -0.00323548f, -0.01597757f, -0.05947430f, 0.03160592f, 0.00054378f, 0.06153678f, -0.08694756f, 
    -0.08842843f, 0.01200382f, 0.03408718f, -0.09792339f, -0.00457325f, 0.07064702f, 0.01323018f, -0.08869603f, 
    0.07592306f, 0.03639907f, -0.16319299f, 0.12686212f, -0.09068146f, -0.06299659f, -0.17693271f, -0.10711493f, 
    0.07731543f, 0.17260386f, 0.10271879f, 0.02268389f, -0.03250308f, 0.01636460f, -0.02206445f, -0.05111801f, 
    -0.02929609f, -0.11862791f, -0.00825088f, 0.01883633f, 0.00736010f, 0.00276913f, -0.12935853f, -0.19163674f, 
    -0.11799698f, 0.03457221f, 0.00371260f, -0.13474225f, -0.11575025f, 0.06742525f, 0.16604696f, -0.14739697f, 
    0.00344363f, -0.04324326f, -0.00285792f, 0.00599197f, 0.02584833f, 0.03388724f, -0.06732904f, -0.08128436f, 
    -0.02729614f, -0.17966150f, -0.08819310f, 0.01789820f, 0.05344477f, 0.06544146f, 0.03600976f, 0.03118975f, 
    -0.05769670f, -0.16199008f, 0.11840399f, 0.11174604f, 0.00187037f, -0.01874501f, 0.02780571f, -0.11653080f, 
    -0.10138681f, 0.22942016f, 0.08962072f, -0.09364135f, 0.23888834f, -0.12980528f, -0.07234114f, -0.01833852f, 
    -0.16162650f, -0.01415012f, -0.04974730f, 0.18714416f, 0.02848982f, -0.01063259f, -0.05140585f, 0.08554755f, 
    -0.01389154f, 0.14239150f, -0.05279532f, 0.11352070f, -0.11404024f, -0.18598863f, -0.01326945f, 0.04683385f, 
    0.08778307f, -0.17237777f, 0.02377818f, 0.20711671f, -0.32069978f, 0.04209691f, -0.22325568f, -0.21291620f, 
    0.00449128f, -0.03234030f, 0.06011533f, -0.01862295f, 0.02159310f, -0.01843995f, 0.18655229f, 0.05686286f, 
    0.05561560f, -0.15345515f, 0.01679629f, -0.08171993f, 0.02414152f, 0.11509081f, 0.12236907f, 0.18891610f, 
    -0.16513203f, -0.22313510f, -0.05773046f, -0.17684358f, 0.07144812f, 0.10772330f, 0.08817437f, 0.13236478f, 
    0.01382534f, -0.05386261f, 0.02852303f, -0.05129587f, 0.08237187f, -0.03927658f, 0.03218814f, -0.09159177f, 
    -0.03567249f, -0.26763636f, 0.03058417f, 0.05034956f, 0.07606614f, 0.08902319f, 0.00865806f, 0.06774483f, 
    -0.15519039f, -0.16352287f, -0.18148558f, 0.07927282f, -0.13786957f, 0.02041630f, -0.00612768f, -0.02091511f, 
    0.05737142f, -0.00324928f, -0.48194841f, -0.19597392f, -0.16236170f, -0.02616353f, 0.03937703f, -0.16116418f, 
    -0.05967596f, 0.11074635f, 0.03953801f, 0.16282088f, 0.06540748f, 0.04028033f, 0.17927964f, 0.01304260f, 
    0.13124515f, 0.02201967f, 0.10855521f, 0.09685027f, -0.19097807f, -0.16008736f, -0.23326489f, -0.04382130f, 
    -0.14389463f, 0.03335623f, -0.29483458f, -0.04181055f, -0.07607232f, 0.11872628f, -0.01060634f, 0.16244256f, 
    -0.01494375f, -0.09675585f, 0.02788974f, 0.16719283f, 0.10481569f, 0.19609314f, -0.21001327f, -0.09725137f, 
    -0.27052739f, 0.08548912f, 0.10093732f, 0.06366095f, 0.15644738f, 0.05973992f, -0.08184397f, -0.39958265f, 
    -0.16105729f, 0.10845352f, 0.08446337f, 0.00369157f, -0.01593255f, 0.11050096f, -0.00668063f, 0.11974861f, 
    0.32503724f, -0.00519994f, -0.19796091f, -0.04764289f, 0.14635706f, -0.12228820f, -0.06591917f, -0.04728655f, 
    0.00616052f, -0.31096762f, -0.08985510f, -0.04183727f, 0.06239342f, 0.07580154f, -0.19241123f, 0.12304972f, 
    0.03843159f, -0.01141647f, 0.01755121f, -0.37790096f, 0.17049731f, 0.03118064f, 0.03735245f, -0.03946864f, 
    0.04522504f, -0.00748600f, 0.02523229f, -0.03551772f, -0.05189678f, -0.01401011f, 0.13457967f, 0.03824943f, 
    -0.04553454f, 0.02675493f, -0.00623441f, 0.23044491f, -0.20207360f, 0.08274899f, 0.17111632f, 0.07263085f, 
    -0.10188939f, 0.12404259f, -0.01924936f, 0.12624814f, -0.00845124f, 0.11015706f, 0.02747748f, 0.02488334f, 
    0.00136463f, -0.07777023f, 0.00411512f, -0.26322457f, 0.21111730f, -0.08425609f, -0.29990429f, -0.13593154f, 
    0.04911903f, -0.06703467f, -0.02904139f, 0.05623551f, -0.13246131f, 0.03975961f, 0.02631105f, -0.08344082f, 
    -0.18835744f, 0.01328794f, 0.09180134f, 0.00659786f, -0.17795087f, -0.06023108f, 0.06373212f, 0.09883372f, 
    -0.01109510f, 0.08915400f, -0.29160216f, -0.02259219f, 0.08816535f, -0.07110474f, 0.05582065f, 0.22103806f, 
    0.00816335f, -0.05553171f, 0.10324027f, 0.08083732f, -0.13378908f, 0.10305858f, -0.07003649f, 0.21277262f, 
    0.11987372f, 0.05783692f, 0.22222227f, -0.03631344f, -0.26331872f, -0.07639188f, 0.01339115f, 0.18764018f, 
    -0.00743916f, -0.04908314f, -0.09245961f, -0.45924017f, -0.04455239f, -0.05462461f, 0.00590999f, 0.00514185f, 
    -0.14685874f, -0.03203266f, -0.08354332f, -0.03578393f, -0.18656491f, 0.13342024f, 0.22187828f, 0.09605338f, 
    -0.05920758f, 0.16702168f, 0.04890186f, 0.14669265f, -0.08073234f, -0.17382064f, -0.13498284f, 0.01529843f, 
    0.03230581f, 0.10398475f, 0.05140625f, -0.01715811f, 0.16944024f, 0.01127618f, -0.07018037f, 0.01176844f, 
    -0.01069213f, -0.10484041f, 0.03375758f, 0.02611003f, 0.30511993f, -0.04875667f, -0.01953355f, -0.09173962f, 
    -0.07603114f, 0.12256910f, 0.18314609f, 0.00994565f, 0.00978796f, -0.00347064f, -0.18829586f, 0.00965037f, 
    -0.01255841f, 0.00055736f, 0.00881639f, -0.05526278f, 0.04959166f, 0.03073508f, 0.01414163f, -0.05020994f, 
    0.01343830f, -0.02333606f, 0.05017652f, 0.00988285f, -0.02457032f, 0.00134135f, 0.01821164f, 0.02473295f, 
    0.04267393f, 0.05638440f, -0.00997256f, -0.00956415f, 0.01899130f, -0.05311694f, -0.03895095f, -0.05153098f, 
    -0.05340689f, -0.03568191f, -0.05722319f, -0.01779818f, 0.04361109f, 0.02805604f, 0.03258975f, 0.00420625f, 
    0.03949092f, 0.00235890f, 0.03051604f, 0.00352269f, 0.01614784f, 0.01356867f, 0.04368158f, -0.00023205f, 
    -0.05734444f, 0.02906256f, 0.04303568f, -0.03829597f, 0.01106754f, 0.01644925f, -0.01021813f, 0.00274121f, 
    -0.06685913f, -0.03974636f, -0.04320440f, -0.01889364f, 0.03661800f, 0.01083400f, 0.04591359f, 0.04724286f, 
    -0.05219358f, 0.03815164f, 0.04230542f, -0.03222521f, -0.04606396f, -0.03961437f, -0.03582016f, -0.00600322f, 
    -0.03268306f, -0.03772220f, -0.01316957f, -0.00656736f, -0.00594596f, -0.04509049f, -0.00838151f, 0.03586414f, 
    -0.02289619f, 0.00468091f, 0.00112121f, -0.01499841f, -0.00217273f, -0.01232280f, -0.01813550f, -0.01555110f, 
    -0.05177907f, 0.00211278f, 0.01638555f, -0.04315808f, -0.02134020f, -0.02949085f, -0.05729925f, -0.04629275f, 
    -0.00722828f, -0.00709637f, -0.01519332f, 0.03941450f, -0.01451223f, -0.01722640f, 0.04300779f, -0.02709163f, 
    0.03096904f, 0.03045581f, 0.01587365f, -0.02835558f, 0.03212239f, -0.04926941f, -0.05706080f, 0.04971441f, 
    -0.01543170f, -0.05942766f, -0.05406744f, 0.03414938f, -0.04063742f, 0.03169651f, 0.00932312f, -0.05963988f, 
    -0.06224180f, -0.01970544f, -0.01880300f, 0.01468564f, -0.04027529f, -0.04898648f, -0.02995682f, -0.01637442f, 
    -0.05421259f, 0.03797332f, -0.06480817f, -0.01942861f, 0.01728676f, -0.05811111f, 0.02615982f, -0.02383961f, 
    0.01770889f, 0.03416068f, 0.05001043f, 0.00538775f, -0.05957221f, 0.04720470f, -0.01216962f, -0.00310983f, 
    -0.02538718f, -0.05270650f, -0.00077674f, 0.01245006f, -0.00445578f, 0.01478769f, -0.04138566f, -0.04310776f, 
    -0.04931406f, -0.01388066f, 0.02391354f, -0.03725600f, -0.02373720f, 0.02639514f, 0.02639756f, -0.05054171f, 
    -0.06173743f, -0.02676165f, 0.02783715f, -0.05766614f, -0.06037189f, 0.01456488f, 0.03300867f, -0.00714378f, 
    0.02169533f, -0.03444971f, -0.03552069f, -0.01565040f, 0.03081519f, -0.00330119f, -0.01899596f, -0.06322061f, 
    -0.01841867f, -0.04769907f, 0.05619493f, 0.00723984f, -0.05499946f, 0.04139079f, 0.02875759f, -0.00873651f, 
    -0.05143022f, -0.02773572f, 0.00293612f, 0.02445397f, -0.06248678f, -0.03831274f, -0.04357747f, 0.02504797f, 
    -0.00392383f, 0.00608683f, -0.01367855f, -0.05442112f, -0.01698519f, 0.04712223f, -0.01016082f, 0.03622283f, 
    -0.04141003f, 0.04686040f, -0.00387220f, -0.02546756f, 0.00127988f, 0.03319787f, 0.01184054f, -0.00226598f, 
    0.03072180f, -0.06455356f, -0.01948294f, -0.06492470f, -0.02402723f, -0.00253975f, 0.02889204f, -0.04377568f, 
    0.00239348f, 0.04760823f, -0.01921527f, -0.02906660f, 0.01685884f, 0.02901189f, 0.03689470f, 0.01206939f, 
    0.04479400f, 0.01520416f, 0.02405931f, 0.03797518f, 0.03521733f, 0.02316732f, 0.03626338f, 0.03700056f, 
    -0.06659602f, -0.04000759f, -0.02626327f, 0.05195704f, -0.03220385f, 0.00673340f, 0.00124956f, 0.01367832f, 
    0.03247374f, -0.00993917f, -0.00017253f, -0.06734579f, -0.02767601f, -0.00643420f, 0.02850842f, 0.04766733f, 
    -0.06563784f, -0.04455758f, 0.04013541f, 0.00729234f, 0.02201375f, -0.02292723f, 0.01313632f, -0.03821246f, 
    0.02718968f, 0.04258363f, -0.04974196f, 0.00305960f, -0.01685555f, -0.03468725f, -0.03071762f, -0.01488983f, 
    -0.05544697f, 0.00512447f, 0.00779755f, -0.03405867f, -0.00539653f, 0.04047531f, 0.05280795f, -0.03768265f, 
    0.04459913f, 0.01269941f, -0.03492623f, -0.00354862f, -0.06855471f, -0.02303170f, -0.05543514f, 0.04420709f, 
    -0.01535876f, -0.02716579f, 0.00025019f, -0.00339644f, 0.03637356f, 0.03863303f, 0.01066105f, -0.00149854f, 
    0.00056589f, -0.06542835f, 0.03860033f, 0.02461759f, 0.04181012f, 0.01382641f, -0.06238801f, -0.01796309f, 
    -0.04698731f, -0.20204706f, -0.04742847f, -0.15064578f, 0.01611762f, 0.11008895f, 0.09322026f, 0.00549727f, 
    -0.14690512f, 0.15204191f, 0.02377094f, -0.11089291f, -0.10186628f, -0.07158552f, -0.07728171f, -0.08415622f, 
    -0.12272513f, -0.01995480f, 0.14121875f, 0.02781132f, -0.12975430f, 0.02986094f, 0.21755427f, -0.04153433f, 
    0.14397642f, 0.00938660f, 0.12272800f, 0.11742958f, 0.07611961f, -0.10103304f, 0.14438722f, 0.07975566f, 
    0.05503234f, 0.02046512f, -0.04416260f, -0.01130254f, 0.03115495f, -0.13069384f, -0.19228840f, 0.11861084f, 
    -0.01017116f, 0.02658829f, -0.05592319f, 0.08266099f, 0.07873169f, 0.03113945f, -0.10935785f, -0.09457923f, 
    0.06339763f, 0.00311066f, 0.02320478f, 0.08661943f, 0.05448226f, 0.06374482f, 0.03057499f, -0.04761392f, 
    0.03863585f, -0.04133268f, 0.10549116f, 0.02064826f, 0.14224188f, -0.07142492f, 0.07534750f, 0.11845963f, 
    -0.02604798f, 0.00210800f, -0.14501506f, 0.02307267f, 0.12583502f, -0.09440949f, -0.12677000f, 0.12548506f, 
    0.01481011f, 0.12740509f, 0.06230195f, 0.19760838f, 0.04859927f, 0.02289175f, -0.15089579f, 0.08356268f, 
    -0.05147507f, -0.22286037f, -0.11299200f, -0.33370465f, 0.12503660f, -0.06262903f, -0.04646243f, -0.11774136f, 
    0.02631676f, 0.16494210f, -0.19533585f, -0.21260683f, -0.18865693f, -0.01285430f, -0.04270536f, -0.06094843f, 
    -0.05593646f, -0.22817613f, -0.13562892f, 0.33005485f, 0.13902773f, -0.17410633f, 0.10167317f, 0.04451719f, 
    0.22864348f, 0.00306441f, 0.12339308f, -0.01916616f, -0.12957479f, -0.15443580f, -0.07187250f, -0.04515004f, 
    -0.00454553f, 0.01301264f, 0.04935596f, -0.09925745f, -0.09118016f, 0.03818316f, 0.16622004f, 0.12207264f, 
    0.08409975f, 0.05515100f, 0.06165659f, 0.08327501f, 0.16984041f, -0.11367207f, 0.27221262f, 0.18573475f, 
    0.06753919f, 0.14110076f, 0.13690147f, 0.08870534f, 0.07013060f, 0.28074825f, 0.05898997f, -0.23745002f, 
    -0.09678381f, 0.15116915f, 0.06317434f, -0.07439888f, 0.06662067f, 0.09027076f, 0.03306437f, -0.12526631f, 
    0.18978445f, -0.02660725f, 0.04152727f, -0.07358345f, 0.09787376f, -0.09849069f, -0.15409005f, 0.05140055f, 
    -0.02532177f, -0.12528926f, -0.09312772f, -0.25116786f, 0.02396559f, -0.05798079f, 0.15933122f, 0.06590220f, 
    -0.02198016f, -0.11952981f, -0.15231112f, -0.09602099f, -0.01668219f, -0.02186842f, 0.05368925f, 0.03237079f, 
    0.04171146f, -0.06503594f, 0.13527958f, 0.12970605f, 0.08305453f, -0.07034857f, 0.29356048f, -0.09758660f, 
    0.06337857f, -0.02134170f, 0.07684817f, -0.02727305f, -0.11299401f, 0.24723350f, 0.05682687f, 0.04218075f, 
    -0.07479178f, 0.10498407f, 0.07482348f, 0.00653216f, 0.00667810f, 0.18996757f, -0.03623428f, -0.11225563f, 
    0.05649953f, 0.00768161f, -0.02341768f, 0.02322016f, -0.01775345f, 0.09707531f, -0.00482232f, -0.17432076f, 
    0.09036119f, -0.05125730f, 0.00292386f, 0.02714206f, -0.00821952f, -0.07751267f, 0.07783131f, 0.06544475f, 
    0.04778268f, -0.04648449f, 0.15538095f, 0.10579593f, -0.10407306f, 0.08636534f, -0.12742744f, -0.01964492f, 
    0.21843539f, -0.03427516f, -0.30447802f, 0.16037995f, -0.00078695f, 0.15933946f, -0.07155532f, 0.00759056f, 
    0.03356201f, -0.06536715f, 0.02512041f, 0.08650192f, 0.05652243f, -0.19550343f, -0.06170322f, 0.15477148f, 
    0.06844674f, 0.13376218f, 0.25607952f, 0.31071490f, 0.08683643f, -0.00810725f, 0.01563874f, 0.00652842f, 
    -0.03935303f, 0.24907248f, 0.06652898f, -0.02671100f, -0.06917480f, -0.19309412f, -0.05589351f, 0.00427754f, 
    0.25254142f, 0.09291148f, -0.28662956f, -0.16721042f, -0.05614519f, -0.10005778f, -0.06968013f, -0.15028332f, 
    -0.01617393f, -0.08938895f, 0.05281472f, -0.00839248f, 0.03644394f, -0.00486089f, -0.16361226f, -0.02774544f, 
    0.07250729f, -0.00301388f, 0.07103959f, -0.05136893f, -0.01929965f, -0.28581473f, -0.25098491f, -0.03771709f, 
    -0.19498061f, 0.28285673f, -0.06040793f, -0.09851857f, -0.01906745f, 0.12765114f, 0.08434185f, 0.00393429f, 
    -0.01861887f, 0.03148616f, 0.07655602f, -0.05281311f, 0.04942041f, 0.02413020f, -0.02977028f, -0.05135091f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04983623f, 0.11303663f, -0.03612559f, -0.02019914f, -0.00170872f, -0.01424204f, 0.07599540f, 0.03884510f, 
    0.06390606f, 0.00825271f, -0.01990736f, -0.06759447f, 0.09300011f, 0.08565131f, 0.04160735f, 0.06809297f, 
    -0.03274005f, 0.05442837f, 0.18436860f, 0.03366941f, -0.01147897f, 0.02439214f, -0.03860933f, 0.12501860f, 
    -0.03882794f, -0.06436366f, 0.08143541f, 0.01813935f, -0.02205449f, 0.16819751f, 0.04743591f, 0.10021441f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15812384f, -0.13372743f, 0.15961364f, -0.11773653f, 0.46185017f, 0.27788001f, -0.04268971f, 0.11223072f, 
    -0.51954621f, -0.07685991f, -0.01703795f, 0.08084757f, 0.40930715f, 0.40020820f, 0.13818987f, -0.16876756f, 
    0.12849632f, -0.20053823f, -0.00584101f, 0.06145503f, -0.18230420f, 0.06394994f, 0.12769203f, 0.11371469f, 
    0.08914070f, 0.08376799f, -0.09530311f, 0.34878576f, 0.40821594f, -0.06094353f, 0.07537451f, 0.30911157f, 
    0.15225376f, -0.02003202f, -0.02741166f, -0.03009738f, 0.49025100f, 0.07355402f, 0.45865080f, -0.17505853f, 
    0.00685303f, -0.04969178f, -0.01283482f, 0.00992433f, 0.46029192f, 0.27956200f, 0.10671826f, -0.09025034f, 
    0.22004360f, -0.14394788f, 0.16519092f, 0.32772872f, -0.24025965f, -0.02696347f, 0.01842242f, -0.12613240f, 
    -0.13247196f, 0.13842529f, 0.04084180f, 0.46096447f, 0.26831514f, 0.03408564f, 0.15077692f, 0.09746000f, 
    0.02000334f, -0.18236358f, 0.13488956f, 0.07659984f, 0.21467564f, 0.01896947f, 0.00215245f, 0.03608982f, 
    -0.46806300f, -0.09050626f, -0.12927042f, -0.00005758f, 0.08426278f, 0.08820782f, 0.00875784f, 0.10795097f, 
    -0.37157452f, 0.33969536f, -0.10897719f, 0.20484166f, -0.04194905f, 0.01834648f, -0.06540845f, 0.27201024f, 
    -0.01985388f, 0.05354360f, 0.33734176f, 0.21891521f, 0.52431631f, 0.36839226f, -0.01789514f, 0.01578978f, 
    0.05110511f, -0.08855616f, 0.09746762f, 0.01570103f, -0.24551769f, -0.13134226f, 0.30669945f, 0.29150832f, 
    0.16869037f, -0.15588169f, 0.01723017f, -0.09264731f, -0.28743085f, -0.23145518f, 0.13648093f, 0.34567359f, 
    -0.10368165f, -0.18014987f, 0.04260246f, -0.05421402f, 0.27397260f, 0.02767505f, 0.03954236f, 0.20328914f, 
    0.23124745f, -0.08424160f, -0.15380442f, -0.16712813f, -0.19967012f, 0.23883393f, -0.03809565f, -0.09416477f, 
    -0.08384725f, 0.14817768f, -0.00993403f, 0.09951866f, 0.01650903f, 0.59883338f, 0.03531941f, 0.15740974f, 
    0.33158121f, -0.60059404f, -0.06616455f, -0.10635325f, 0.35826927f, 0.11518032f, -0.15248917f, 0.19695838f, 
    -0.11547155f, -0.13300365f, 0.09826026f, 0.15909845f, 0.42306843f, -0.12509790f, -0.03076111f, -0.09476737f, 
    0.19053970f, -0.17017284f, 0.13637504f, 0.05347298f, 0.38708299f, -0.03607162f, 0.04059307f, 0.23116675f, 
    0.10128237f, 0.06259136f, 0.10484495f, -0.04487402f, 0.34474590f, 0.05858712f, -0.12616271f, 0.33699474f, 
    -0.55156136f, 0.26787880f, 0.15402362f, -0.16109429f, -0.08223754f, 0.31589830f, -0.00901029f, -0.05489141f, 
    0.04310247f, 0.16783968f, 0.02124520f, -0.12116065f, -0.43004155f, 0.03241744f, 0.11631259f, 0.12746431f, 
    -0.22381042f, -0.05614620f, -0.11970197f, 0.62822837f, 0.24691194f, -0.07971124f, 0.16596094f, 0.08984659f, 
    -0.08553808f, 0.38830596f, -0.17532164f, -0.11862873f, 0.10319489f, 0.18664064f, -0.17248832f, 0.02548873f, 
    0.10937189f, 0.40006351f, -0.20823090f, 0.15914319f, 0.05860978f, -0.02277179f, -0.13770288f, -0.30377242f, 
    -0.08846504f, -0.15702079f, 0.23127137f, -0.14081708f, -0.12386161f, -0.16681617f, -0.02687728f, -0.10888168f, 
    -0.11053530f, -0.05498429f, 0.20259342f, -0.05759296f, -0.28820831f, -0.56795496f, 0.04704773f, 0.36601016f, 
    0.13439967f, 0.34802848f, -0.00190426f, -0.01452545f, 0.28793219f, 0.08958380f, 0.33663160f, 0.22381635f, 
    0.25822869f, 0.45140463f, -0.03253843f, -0.14401633f, 0.20493098f, 0.44469121f, 0.11608366f, -0.24108592f, 
    0.45269173f, -0.38328615f, 0.12425718f, -0.27580193f, 0.07993292f, -0.09555778f, 0.00813409f, 0.00479709f, 
    0.11813019f, 0.12151113f, -0.20368175f, 0.18304807f, -0.22022654f, -0.21563746f, 0.12935835f, 0.39114252f, 
    -0.06080896f, 0.35763749f, 0.01001721f, 0.10556270f, -0.39866897f, -0.21948776f, -0.05543655f, 0.33435798f, 
    0.04344449f, 0.34377706f, -0.09250436f, -0.03050147f, -0.22462103f, 0.08311855f, 0.00561688f, 0.11983546f, 
    0.44014388f, 0.03119236f, 0.19879597f, -0.45359105f, 0.31405854f, -0.02485001f, -0.15913714f, 0.09150419f, 
    0.14697705f, -0.01633148f, -0.14902529f, 0.21478818f, -0.26387933f, -0.47196361f, 0.04273062f, -0.28907576f, 
    -0.13398790f, 0.02606747f, 0.03595180f, 0.08812985f, 0.18797725f, -0.19374558f, 0.02283826f, 0.03303289f, 
    -0.06165123f, -0.17953409f, 0.02797505f, -0.10142168f, -0.07462300f, -0.03234694f, 0.07980435f, -0.03185930f, 
    -0.03254251f, -0.14883950f, 0.01467385f, -0.00830600f, 0.05043817f, 0.05246572f, -0.13485752f, -0.06849258f, 
    -0.07113917f, 0.03710352f, -0.12328232f, -0.00817539f, -0.04909930f, 0.05082420f, 0.02376254f, -0.00403306f, 
    -0.00961461f, 0.20717935f, -0.06759283f, 0.10889281f, -0.25981653f, -0.14143682f, -0.40395975f, -0.52814043f, 
    0.09469823f, 0.03033268f, -0.16487296f, 0.10463119f, -0.29446664f, -0.42161575f, -0.06000358f, 0.25650451f, 
    -0.02901199f, 0.61817753f, 0.35012907f, 0.22534999f, -0.06916454f, -0.07294516f, -0.08612221f, 0.06166202f, 
    -0.14999719f, -0.11233110f, 0.30429509f, -0.19421948f, -0.23707061f, 0.30097905f, -0.15824693f, 0.01295074f, 
    -0.01132295f, -0.36614844f, 0.06407067f, 0.02465653f, -0.11096964f, 0.28587121f, 0.22484247f, 0.27049437f, 
    0.06167379f, -0.31789377f, -0.14300311f, 0.08728492f, 0.37722006f, -0.21282578f, -0.12111777f, 0.14812696f, 
    -0.55591899f, 0.09125451f, -0.06305443f, 0.30211195f, 0.23081809f, -0.17413208f, 0.11707688f, -0.06157422f, 
    -0.05301765f, 0.13599592f, 0.41920292f, 0.15672481f, 0.43882525f, 0.26129872f, -0.03315306f, 0.08039238f, 
    -0.10835938f, 0.24347554f, -0.09383553f, 0.09210969f, 0.52304578f, -0.18763722f, 0.00083523f, -0.38419062f, 
    0.13003288f, 0.37677661f, 0.14116879f, 0.02991672f, 0.18299773f, 0.26791710f, 0.02503765f, -0.05508455f, 
    0.01991718f, 0.40170649f, 0.10349101f, 0.12416354f, -0.57152599f, 0.01820549f, -0.04527176f, -0.00627744f, 
    0.08186912f, -0.04045043f, 0.26755169f, -0.07526772f, 0.31555063f, 0.22398216f, -0.12379783f, 0.25907159f, 
    0.12109885f, 0.01327330f, 0.16204096f, 0.09352485f, -0.06015517f, 0.10732446f, -0.07269530f, -0.18124861f, 
    -0.08997145f, -0.13712773f, 0.10840248f, -0.06525599f, 0.00368909f, -0.15109794f, -0.06185675f, -0.03439019f, 
    -0.11764325f, -0.15977398f, -0.18947288f, 0.06711529f, -0.05907452f, 0.04709645f, -0.13762841f, 0.00884858f, 
    -0.18633217f, 0.09668960f, -0.02920892f, 0.11964564f, -0.03334072f, -0.03140899f, -0.17342675f, 0.08386201f, 
    0.11992514f, 0.12979542f, 0.11774682f, 0.14236043f, -0.46008551f, -0.12350015f, -0.08418192f, 0.33710039f, 
    0.38476005f, -0.02843190f, 0.12728821f, 0.07829515f, -0.20074815f, -0.18014246f, -0.14281374f, 0.08675244f, 
    -0.46156755f, 0.26157904f, 0.13573207f, 0.01531908f, -0.14757143f, -0.07244713f, 0.16057207f, 0.23812827f, 
    0.16193968f, -0.07978880f, 0.10698781f, -0.31285056f, -0.13257302f, 0.21703224f, -0.13516061f, -0.06217400f, 
    -0.08674037f, 0.09866668f, -0.07407858f, 0.08034719f, -0.29289231f, 0.05483477f, -0.38886765f, 0.37576199f, 
    0.22895552f, 0.20694739f, -0.12947483f, 0.07003112f, -0.17059100f, -0.07454409f, -0.14912085f, 0.08582354f, 
    -0.11641362f, 0.07742033f, 0.25591317f, -0.21286093f, 0.34201303f, -0.01097928f, 0.17674348f, 0.11453131f, 
    0.21922201f, 0.08885072f, -0.10446499f, -0.22119664f, -0.00614177f, -0.33459374f, 0.14712334f, -0.22251302f, 
    -0.09902699f, -0.26378331f, 0.07804247f, -0.03845137f, 0.26224446f, -0.00871944f, 0.03665870f, -0.35411164f, 
    -0.26326227f, 0.39841846f, -0.02410053f, -0.10549044f, -0.05507241f, 0.42547473f, 0.15707169f, 0.07263354f, 
    0.62546825f, -0.13266550f, -0.07577515f, -0.20589343f, 0.02726333f, -0.08111090f, 0.05948353f, -0.08329223f, 
    0.30176058f, 0.16127916f, 0.07905213f, -0.17603867f, 0.24854048f, 0.06388184f, -0.05729229f, 0.20599201f, 
    -0.03044779f, 0.05438058f, 0.02590673f, -0.10279851f, 0.08951674f, -0.04732095f, 0.14317773f, -0.57423967f, 
    -0.20962313f, -0.25984597f, -0.12279568f, 0.00381944f, -0.16004199f, -0.25389707f, 0.14496218f, 0.08339038f, 
    0.53570700f, 0.15843675f, 0.21355160f, 0.31183168f, -0.30686206f, -0.15451787f, -0.08043849f, 0.08123262f, 
    0.06687061f, 0.02212355f, 0.36000395f, 0.36573967f, -0.10356328f, 0.42270097f, -0.12438086f, 0.51805735f, 
    -0.10773116f, 0.28723279f, 0.01336034f, 0.09693373f, -0.06214310f, -0.03478786f, 0.34121495f, 0.21298449f, 
    0.09258791f, 0.32546094f, 0.06978790f, -0.13475662f, -0.46523917f, -0.19293144f, 0.08759145f, 0.21619657f, 
    -0.31953207f, -0.27201715f, -0.05879783f, -0.00036511f, -0.24431534f, -0.13240841f, 0.09354681f, 0.24800763f, 
    0.21735822f, 0.02960425f, -0.34947339f, -0.06425316f, -0.39159137f, 0.20893773f, -0.08394032f, 0.10449774f, 
    0.06079998f, 0.41590866f, -0.06513261f, 0.05501115f, -0.12104567f, 0.06940726f, -0.04290472f, 0.37026349f, 
    0.19574735f, -0.09194909f, 0.09786460f, 0.14086194f, -0.08569935f, -0.02050513f, 0.06292609f, 0.19145504f, 
    0.11289984f, -0.37968010f, -0.03761730f, -0.52183616f, 0.02398235f, -0.15512508f, -0.17036641f, 0.20540081f, 
    0.30373418f, 0.15353416f, -0.45087767f, -0.16905899f, -0.03054512f, -0.11574619f, 0.03208686f, 0.37315887f, 
    -0.04931454f, 0.18899745f, 0.02463602f, 0.12550777f, -0.35843420f, -0.32268018f, 0.42052200f, 0.01582067f, 
    -0.15720201f, -0.16743647f, -0.01435993f, 0.13964725f, -0.09668325f, -0.18322517f, 0.13849814f, 0.25577217f, 
    0.24674919f, 0.19139802f, 0.19326217f, -0.24808218f, 0.17236558f, -0.15470754f, 0.10425992f, 0.22987846f, 
    -0.12560563f, -0.06049633f, -0.29820073f, 0.26179159f, -0.58067471f, -0.10832901f, -0.00609173f, -0.30853817f, 
    -0.06338917f, 0.45078668f, -0.16739853f, 0.06354941f, 0.27770188f, -0.05758845f, 0.28768721f, -0.01968436f, 
    0.51807582f, -0.09776892f, 0.09330340f, -0.14138672f, 0.39739588f, 0.27845243f, -0.10084427f, -0.00775157f, 
    0.17977536f, -0.23629345f, 0.09913699f, -0.07737214f, 0.44242901f, 0.14954272f, 0.14502810f, -0.19721498f, 
    0.30938047f, 0.15941955f, 0.12710455f, 0.07088322f, 0.12897179f, -0.16158068f, -0.07296640f, 0.30631423f, 
    -0.03579787f, -0.15106697f, 0.09695020f, -0.12463988f, -0.12959009f, -0.11610986f, -0.13881047f, 0.11316356f, 
    -0.15340994f, 0.13452648f, -0.09403441f, -0.04858743f, 0.08743683f, -0.13308609f, -0.09756298f, -0.02319978f, 
    0.05482576f, -0.06891511f, -0.04732728f, -0.11358360f, 0.03972192f, -0.13533148f, 0.02403873f, -0.10988684f, 
    0.09401048f, 0.08899891f, -0.06084541f, 0.12421887f, -0.09866967f, -0.19811806f, 0.15013678f, -0.11897472f, 
    -0.18778995f, -0.24270718f, 0.14534391f, -0.12352546f, 0.05352940f, 0.09298749f, 0.08954158f, -0.40408123f, 
    -0.19926418f, -0.31749398f, 0.04902284f, -0.12128329f, -0.32511678f, -0.02207172f, -0.07646571f, 0.14422983f, 
    -0.42142248f, 0.27992293f, 0.22421905f, 0.22324651f, -0.43150643f, -0.10385992f, -0.15439074f, 0.28057957f, 
    -0.31144211f, -0.06567591f, 0.41064218f, 0.03533924f, -0.00948284f, 0.58156681f, -0.14582440f, 0.28939965f, 
    -0.03960115f, 0.24711342f, -0.01314993f, 0.09487268f, -0.50863898f, 0.02060534f, -0.16723867f, 0.26542863f, 
    -0.08318990f, 0.10498053f, 0.02958635f, 0.10328507f, 0.01774843f, 0.12255393f, 0.07455539f, -0.10176006f, 
    -0.00592903f, 0.43738857f, 0.21567349f, -0.35367084f, -0.43124104f, -0.05146192f, 0.06829017f, 0.26639053f, 
    -0.37283370f, 0.02980188f, 0.24004140f, 0.20855221f, -0.24485517f, -0.19973570f, -0.05182040f, 0.06131526f, 
    -0.14895245f, 0.04688454f, -0.01434559f, -0.01285217f, 0.19495912f, -0.23718971f, 0.43767053f, -0.21522231f, 
    0.27173612f, 0.19379283f, 0.14647581f, 0.01014962f, 0.19910832f, -0.21573737f, 0.02127382f, -0.07277984f, 
    0.26337585f, 0.06006253f, 0.29218611f, 0.10452621f, 0.31646794f, -0.06130939f, -0.04163866f, -0.22470580f, 
    -0.34071678f, 0.07761998f, 0.28545350f, 0.06568766f, -0.21399680f, -0.10936166f, 0.12639195f, -0.30259413f, 
    -0.08117352f, 0.13759087f, -0.07517871f, -0.06604150f, 0.03392261f, -0.11516857f, 0.04631136f, -0.01935815f, 
    0.09695117f, 0.09544562f, -0.03380554f, 0.13231197f, -0.00136295f, -0.05752325f, 0.14291795f, -0.06173554f, 
    0.05070314f, -0.03952166f, -0.07125700f, -0.06565379f, -0.16487023f, 0.04629089f, -0.18138970f, -0.11824267f, 
    0.00131181f, -0.02343637f, -0.11669822f, -0.00168038f, -0.08240951f, 0.03808298f, 0.09433006f, -0.05675000f, 
    0.00789857f, -0.11513633f, -0.07351371f, -0.15105790f, 0.09436233f, -0.05197470f, -0.02168441f, 0.13608314f, 
    0.17006336f, -0.17180495f, 0.05558782f, -0.04058887f, -0.04960364f, 0.00476825f, -0.03360127f, 0.02202369f, 
    -0.00264142f, -0.18128927f, -0.13373712f, 0.07572643f, 0.03400175f, -0.02974177f, 0.12256809f, 0.00169641f, 
    -0.10095757f, 0.11211794f, 0.16887973f, -0.10320728f, -0.08448336f, -0.13025847f, 0.14579219f, -0.00570399f, 
    0.02296631f, 0.04560288f, -0.08051276f, 0.05365489f, -0.10192263f, 0.39814430f, 0.27973372f, 0.20233421f, 
    0.32324257f, -0.38035968f, 0.13543352f, 0.14140593f, 0.52207369f, -0.14708005f, 0.01204284f, 0.03010706f, 
    -0.52594233f, -0.02603825f, 0.12907453f, 0.05492505f, 0.25136763f, -0.10035126f, 0.01304383f, -0.06877184f, 
    -0.07789221f, 0.09657449f, 0.30549160f, -0.08458708f, 0.34367639f, 0.19430174f, 0.12282372f, -0.27571335f, 
    0.03462714f, -0.05771052f, 0.05569514f, -0.04255701f, -0.19636352f, -0.32745388f, -0.08959723f, 0.04526000f, 
    -0.28070122f, -0.26263133f, 0.12072913f, -0.16053614f, -0.33959678f, -0.17190956f, 0.16328742f, 0.34052914f, 
    0.23585951f, 0.14268622f, 0.09026421f, 0.18259242f, 0.18395568f, 0.06420206f, -0.01825909f, 0.23364523f, 
    -0.13245197f, -0.01052726f, 0.17752172f, 0.15361215f, -0.46967259f, 0.18333758f, -0.05802483f, 0.08750996f, 
    0.04617015f, 0.01082998f, -0.07542577f, -0.15407376f, 0.07069173f, -0.16839367f, 0.65408570f, -0.04707373f, 
    0.11907650f, -0.25325397f, 0.02177588f, -0.08159684f, 0.44847068f, -0.07299775f, 0.14809299f, -0.08431468f, 
    0.07322534f, -0.42461765f, 0.01094767f, 0.07489756f, -0.01495324f, 0.09629838f, -0.08658920f, 0.00980761f, 
    -0.07582637f, -0.02841678f, -0.13020945f, 0.07235335f, -0.30588281f, 0.21548200f, 0.07723816f, 0.13608158f, 
    -0.14433217f, -0.01960831f, 0.03144570f, 0.13490880f, -0.04063527f, -0.19218740f, 0.05812492f, -0.10523035f, 
    0.02662410f, 0.12915416f, -0.09441103f, -0.07935307f, -0.09620333f, 0.05882647f, -0.12646687f, -0.10615188f, 
    0.03871180f, 0.17263271f, -0.03282363f, -0.07798482f, -0.03402418f, 0.07027854f, -0.06724934f, 0.04585381f, 
    -0.01327429f, -0.00856173f, 0.11656833f, -0.13353290f, -0.12763311f, -0.12627763f, -0.02821110f, 0.11727300f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10692025f, 0.00516969f, 0.23741426f, -0.11181880f, 0.14008576f, 0.07844110f, 0.06000536f, 0.29900104f, 
    0.00357273f, 0.08783130f, 0.00064472f, -0.05564292f, 0.32948261f, 0.04785892f, 0.14412145f, 0.10083500f, 
    -0.10471328f, 0.12153941f, 0.10691375f, 0.15242475f, 0.17508894f, 0.27374011f, -0.00230730f, 0.24014844f, 
    0.13860193f, 0.11499154f, 0.11160872f, -0.12636614f, -0.05548569f, 0.21659124f, -0.00620446f, -0.18102704f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.36189079f, 0.27795932f, -0.10245845f, -0.18066418f, 0.29211515f, -0.06323152f, 0.22150743f, 0.43865937f, 
    0.38105482f, 0.07649361f, -0.28557155f, -0.18336830f, 0.10962695f, 0.00679248f, -0.58208269f, -0.00814851f, 
    0.67080569f, -0.07505090f, -0.31745112f, 0.52267450f, 0.10022767f, 0.47819078f, -0.13302454f, -0.47937450f, 
    -0.20069179f, 0.22014123f, 0.11867120f, -0.04860523f, -0.05979930f, -0.03583641f, 0.43139914f, 0.06785557f, 
    -0.25258410f, -0.15377571f, -0.15402818f, 0.44122139f, -0.06285522f, -0.43550280f, 0.15526904f, 0.24625431f, 
    0.26213002f, -0.05062177f, 0.25884643f, -0.21518131f, 0.00409792f, -0.10804819f, 0.23710649f, 0.33033714f, 
    0.10618969f, 0.20537217f, 0.37784591f, 0.41103294f, 0.05026403f, 0.35911125f, 0.09250381f, -0.09980427f, 
    0.07735123f, 0.11890680f, -0.08218945f, 0.04049947f, -0.12215438f, 0.06686754f, 0.20569676f, 0.06230011f, 
    0.30570734f, -0.06667969f, 0.18619998f, -0.03815977f, 0.21281806f, -0.05643276f, 0.20968534f, 0.15871727f, 
    -0.49132431f, -0.09620319f, -0.10431253f, 0.27665001f, 0.02406441f, 0.09137371f, 0.01361165f, -0.15248391f, 
    0.64668131f, 0.09985078f, -0.42524353f, -0.30282703f, -0.42970881f, -0.03112436f, -0.04695242f, 0.22562356f, 
    0.12987193f, -0.08623072f, -0.13818562f, 0.17513004f, 0.33972543f, 0.08648351f, -0.24162492f, -0.21275957f, 
    0.28491455f, 0.34532574f, 0.06823559f, -0.32174397f, -0.05152724f, 0.52515292f, 0.48468706f, 0.14040430f, 
    0.07539923f, -0.06151109f, 0.22849193f, -0.14212650f, 0.25355276f, -0.04914727f, -0.11122711f, -0.32096827f, 
    -0.40080434f, 0.33916727f, 0.01054718f, -0.07240400f, 0.36494187f, 0.09258324f, 0.03416964f, 0.18025962f, 
    0.37682042f, 0.17220835f, 0.00097944f, -0.09546006f, -0.16540883f, 0.11764827f, -0.05637481f, -0.17736998f, 
    -0.00459148f, 0.27513990f, 0.00717054f, 0.47227332f, 0.24977666f, -0.03882768f, -0.46074679f, 0.06919250f, 
    0.08053371f, 0.12586486f, -0.51213825f, 0.40880409f, -0.47951162f, -0.12507361f, -0.31456536f, -0.18835506f, 
    -0.11070781f, -0.02574693f, 0.22579998f, 0.09835785f, 0.45639390f, 0.17121936f, -0.10367586f, -0.25156870f, 
    -0.06389279f, 0.38114825f, 0.01407750f, -0.07860959f, 0.44943404f, 0.21711960f, 0.81129313f, -0.03587180f, 
    0.05320253f, -0.11960827f, -0.25009876f, -0.02860471f, 0.12673053f, 0.16960576f, 0.42785358f, 0.37772253f, 
    0.46731430f, -0.06239532f, -0.42775521f, -0.38269299f, -0.10133382f, 0.06217076f, -0.06193064f, 0.36586389f, 
    -0.58051008f, -0.37108269f, 0.12822156f, 0.53075165f, 0.23305431f, 0.10339659f, 0.08772060f, -0.23250762f, 
    0.40579054f, -0.16343330f, 0.06965767f, -0.07894251f, 0.17991538f, -0.31138510f, 0.11271814f, -0.12065446f, 
    -0.14893290f, -0.16495065f, 0.00526528f, 0.42660949f, 0.03483785f, -0.05867796f, 0.02609182f, 0.06596403f, 
    0.51235497f, -0.07679891f, 0.29395983f, 0.15111195f, -0.32514817f, -0.01466134f, 0.38149729f, 0.44100934f, 
    -0.27893153f, -0.11801420f, -0.14752677f, -0.14052613f, 0.63671458f, 0.15696637f, -0.07597041f, -0.10829710f, 
    0.25084075f, 0.43038678f, -0.15845326f, -0.16539624f, 0.09645716f, 0.35081959f, -0.00556236f, 0.07585817f, 
    0.07710104f, 0.16306774f, -0.05378722f, -0.04755297f, 0.16655844f, -0.18135916f, 0.20653720f, 0.31493223f, 
    -0.18999819f, 0.03298021f, -0.13944770f, -0.20861070f, 0.09324344f, -0.07928400f, -0.17837729f, -0.01328335f, 
    0.77434438f, 0.22374654f, 0.04943276f, 0.19155769f, -0.42281765f, 0.37221822f, -0.02755841f, -0.07343373f, 
    -0.20392333f, -0.08782705f, -0.13282914f, 0.11812761f, -0.13024533f, -0.32453665f, 0.57422709f, 0.05302380f, 
    0.15746593f, 0.22976288f, 0.22664258f, -0.28192949f, -0.01143731f, 0.02525355f, 0.01602906f, 0.02218039f, 
    0.01262979f, -0.15325978f, 0.22132142f, 0.22021320f, 0.24667303f, -0.08034203f, -0.22730044f, -0.01262734f, 
    0.25640500f, -0.02306162f, -0.59809291f, -0.63136202f, -0.16064778f, 0.10280176f, -0.00777534f, -0.04300103f, 
    0.01968584f, 0.59719408f, -0.00796294f, -0.04477577f, 0.25262558f, -0.20709862f, 0.14596610f, -0.03190451f, 
    0.05472364f, -0.11253182f, 0.30073124f, 0.29788896f, 0.16808893f, 0.18441394f, -0.75302136f, -0.24473892f, 
    0.16968852f, 0.16593243f, -0.22218102f, 0.36743405f, -0.45296726f, -0.10884037f, 0.18101339f, 0.40592790f, 
    0.13574818f, -0.19809099f, -0.13980602f, 0.41030154f, 0.03922762f, 0.07615404f, -0.03971683f, -0.27172971f, 
    0.08590982f, -0.26662081f, -0.02247576f, 0.15323064f, 0.24788532f, 0.09842175f, -0.53730661f, -0.06426868f, 
    -0.15894504f, 0.06476688f, -0.11191026f, 0.13290229f, -0.07567404f, -0.02127853f, 0.44522086f, 0.26407394f, 
    0.29038882f, -0.07936024f, 0.03056460f, -0.33418000f, 0.03797284f, 0.09967601f, -0.02050346f, 0.01393058f, 
    0.13847896f, -0.00839497f, -0.10075825f, 0.08178113f, 0.23153910f, 0.16105248f, 0.01190345f, -0.24449545f, 
    0.06682807f, 0.27414075f, -0.14884786f, 0.06713106f, -0.18173185f, 0.17218617f, 0.28878251f, 0.03365787f, 
    -0.16784817f, -0.04528964f, -0.03619902f, 0.12548646f, -0.09558547f, -0.17052141f, -0.24617355f, -0.20699444f, 
    -0.17780346f, -0.02661517f, -0.12704569f, -0.15095644f, 0.10476394f, 0.12295236f, 0.10536597f, 0.13096151f, 
    -0.10518970f, -0.07260990f, -0.10990127f, 0.11967371f, -0.10169496f, 0.10012709f, 0.12060190f, -0.16823167f, 
    -0.15556866f, 0.11558638f, 0.16777109f, 0.03614052f, -0.17778735f, -0.19002825f, 0.03696807f, 0.07308059f, 
    0.35772368f, 0.28202587f, 0.25828922f, 0.06806955f, -0.14680485f, 0.16080636f, -0.47761351f, 0.14119545f, 
    -0.52425861f, -0.13802123f, -0.20596096f, 0.03615186f, 0.21040621f, 0.12326323f, -0.36955869f, -0.37030509f, 
    0.72879833f, -0.05836850f, 0.23389126f, 0.19724517f, 0.05141293f, 0.18581992f, 0.06011745f, 0.27717921f, 
    -0.22630104f, -0.07257395f, 0.15435123f, 0.14624111f, 0.00271829f, -0.10744436f, 0.41219541f, 0.11251582f, 
    -0.01476585f, -0.07914130f, 0.03004720f, 0.04753152f, -0.15758145f, 0.06140113f, -0.08835819f, 0.06282644f, 
    -0.02122127f, 0.09270326f, -0.10305630f, -0.21437365f, 0.24979068f, 0.05025584f, -0.07574970f, 0.08566806f, 
    0.06591468f, -0.08934043f, 0.22461435f, 0.14974239f, 0.24643609f, 0.09748458f, 0.02025678f, 0.13532349f, 
    -0.08485771f, -0.00539021f, -0.06856146f, 0.01538597f, -0.17420588f, 0.15840606f, 0.06526572f, 0.16956437f, 
    -0.27233559f, 0.03128755f, -0.33954069f, 0.46737871f, 0.35068053f, -0.66919696f, 0.07372496f, 0.06997256f, 
    0.04766819f, -0.11617464f, 0.16537978f, 0.17505698f, -0.09397925f, 0.12511156f, 0.27374920f, 0.13631868f, 
    0.48770103f, -0.02603378f, 0.21443391f, 0.32814515f, -0.24817324f, 0.18855420f, -0.08958875f, -0.32807791f, 
    -0.35822648f, -0.24446559f, 0.14536594f, 0.13023074f, 0.30786347f, -0.28447887f, 0.04753561f, 0.02023429f, 
    -0.01562069f, 0.13313997f, -0.15594155f, -0.10858078f, -0.18071412f, -0.09603474f, -0.16541384f, -0.08202200f, 
    -0.13213940f, -0.16352227f, -0.09118731f, -0.08203272f, 0.01710083f, -0.16322151f, 0.13185599f, -0.17011395f, 
    0.07656746f, -0.03782028f, 0.08077792f, 0.09803548f, -0.11709610f, 0.01951526f, -0.15596077f, -0.08588784f, 
    0.14744900f, 0.10486911f, -0.12514578f, 0.11201159f, -0.00880083f, 0.09292965f, -0.00949230f, 0.08132363f, 
    -0.05226965f, -0.00636678f, -0.07612260f, -0.18321010f, 0.04524437f, 0.10142814f, -0.11023141f, -0.04666134f, 
    0.01427532f, 0.07515951f, -0.00534719f, -0.16276105f, -0.08042026f, 0.09885342f, -0.09466926f, 0.04867866f, 
    -0.15922515f, -0.10618936f, -0.04292674f, -0.05696559f, 0.03058529f, 0.10211189f, 0.02469525f, -0.02398426f, 
    -0.17073512f, -0.00921476f, -0.15650943f, -0.11927283f, 0.01532127f, -0.00726036f, -0.17169003f, -0.02424379f, 
    -0.05656316f, -0.00703301f, 0.27496225f, 0.63324863f, 0.00354046f, -0.12740728f, -0.42226818f, -0.03308880f, 
    -0.20276758f, -0.00900876f, 0.05368816f, 0.27083027f, 0.24106875f, -0.15150568f, 0.87224758f, 0.06675193f, 
    -0.53858024f, -0.10521960f, 0.74490738f, 0.18432869f, 0.13612777f, 0.06080545f, -0.14915767f, 0.40581280f, 
    -0.09469333f, -0.08981353f, -0.08551958f, 0.06029797f, 0.48075876f, 0.15332624f, 0.10539802f, 0.06800526f, 
    0.28301948f, 0.22567426f, 0.24227014f, -0.26690072f, 0.13721286f, 0.44294843f, 0.50882894f, 0.21717139f, 
    -0.29536632f, 0.14106403f, 0.01476111f, 0.14640516f, 0.10749895f, 0.15510860f, 0.07776004f, -0.38812786f, 
    -0.51096207f, 0.13587347f, 0.00276005f, 0.09426076f, -0.35794231f, -0.05842213f, 0.03446044f, 0.21001133f, 
    0.32993168f, -0.66387361f, 0.15285213f, 0.16232158f, 0.02484518f, -0.08800887f, -0.21487071f, -0.30159053f, 
    0.32304642f, 0.18070716f, 0.20249921f, -0.46221352f, -0.00009974f, 0.39722115f, 0.87689197f, 0.29973260f, 
    0.15525623f, -0.04224000f, -0.30592993f, 0.08358832f, 0.33325461f, -0.04882992f, -0.03848649f, 0.18759400f, 
    -0.18523657f, -0.22505170f, -0.16401577f, -0.03596592f, -0.56577677f, 0.28891206f, -0.07494996f, -0.28068140f, 
    0.26009628f, -0.05189000f, -0.01072765f, 0.03072312f, 0.24486464f, -0.55845618f, -0.31185609f, -0.15832753f, 
    -0.14519362f, -0.12798926f, -0.10417181f, -0.10618035f, 0.11154788f, -0.04694982f, -0.08505143f, -0.08231793f, 
    -0.00531084f, -0.10153861f, -0.17361981f, 0.01456753f, -0.12361078f, 0.01382897f, 0.12397788f, 0.05079274f, 
    0.12249845f, -0.12899926f, -0.15942056f, -0.18224210f, 0.01378534f, 0.03475491f, -0.05171926f, 0.05587151f, 
    0.00151325f, -0.14175168f, 0.04166968f, 0.16456182f, -0.03510501f, -0.02204234f, 0.08596867f, 0.13645867f, 
    0.13483194f, -0.31983849f, 0.10686982f, 0.30419597f, 0.10868171f, 0.05311488f, -0.06076603f, -0.01414139f, 
    0.40381175f, 0.13712442f, 0.21272095f, -0.23159750f, 0.03325247f, 0.14052577f, 0.33193412f, 0.57392955f, 
    0.07816027f, -0.30977932f, 0.19375230f, 0.61758012f, -0.10680594f, -0.00609516f, 0.19627364f, -0.28268263f, 
    0.06695899f, -0.34484810f, -0.03957993f, 0.08445402f, 0.12591639f, -0.11291143f, -0.36439925f, -0.04483932f, 
    0.06027987f, 0.31531101f, 0.38433316f, -0.09616120f, 0.27520150f, -0.00736937f, 0.10102389f, -0.21482210f, 
    -0.40789071f, 0.04066852f, 0.63835287f, 0.28389430f, 0.33231914f, -0.10818467f, 0.11071230f, -0.13829932f, 
    -0.07050277f, 0.41135424f, -0.32141376f, -0.23027050f, -0.14391088f, 0.09378636f, 0.01280508f, 0.80637920f, 
    0.35350698f, -0.25597256f, -0.14572217f, -0.11206666f, 0.25745866f, 0.52463686f, -0.21989772f, 0.09927738f, 
    -0.05870099f, -0.14131606f, 0.10362047f, -0.00853691f, -0.10399303f, -0.00614261f, 0.14275825f, -0.10780104f, 
    -0.07150223f, 0.13874462f, 0.11812168f, 0.13715594f, -0.12239137f, 0.07723865f, 0.00610345f, -0.06352341f, 
    -0.17439786f, -0.17590967f, -0.13271917f, 0.02513975f, 0.01136294f, 0.12062982f, -0.09899357f, -0.05066641f, 
    -0.04024185f, -0.17215066f, -0.06575584f, -0.02410823f, -0.00819293f, 0.03079320f, -0.10354303f, 0.14113759f, 
    0.52294940f, 0.34926045f, -0.07529738f, -0.28179643f, 0.36906520f, 0.07672486f, 0.17918982f, 0.08995425f, 
    -0.38282904f, 0.01809285f, -0.30834055f, 0.36297992f, -0.13563979f, -0.09678889f, -0.11286079f, -0.25361907f, 
    0.24291694f, 0.12321720f, -0.11708698f, 0.04284960f, -0.43979737f, 0.22854720f, -0.15746906f, 0.01005926f, 
    -0.20566984f, -0.17709865f, 0.09434514f, -0.00265696f, 0.33512303f, -0.32905427f, 0.16955452f, -0.03944374f, 
    -0.17408673f, -0.07602312f, -0.10411160f, 0.03694128f, -0.07882600f, -0.12403186f, 0.07174815f, -0.02129897f, 
    0.04838597f, -0.03190618f, -0.04520258f, 0.01100538f, 0.03115922f, -0.14243348f, -0.17875013f, -0.01857021f, 
    -0.07368509f, -0.05561699f, 0.10568067f, 0.00297926f, 0.14330849f, -0.10241195f, 0.15987481f, 0.14455602f, 
    0.04973092f, -0.04811605f, 0.16741605f, -0.05903102f, 0.07702045f, -0.17691958f, 0.09337328f, 0.00331675f, 
    -0.34099182f, 0.07179517f, 0.04657940f, -0.14078204f, 0.21452405f, -0.28422165f, -0.05862791f, -0.16863647f, 
    -0.24384104f, -0.12800482f, 0.47006184f, 0.17993791f, 0.20065193f, -0.09762291f, 0.12373820f, 0.00800108f, 
    -0.56163090f, 0.18246786f, -0.16381481f, -0.65994632f, 0.29486027f, 0.21759319f, -0.02776866f, 0.20269558f, 
    0.12300356f, 0.71720290f, 0.11663570f, -0.09521182f, 0.55520606f, -0.07705663f, 0.40077794f, 0.01782958f, 
    0.04458968f, -0.01821494f, -0.10563349f, -0.15443645f, -0.16764352f, 0.04900509f, 0.06949376f, -0.15386468f, 
    -0.08983085f, 0.07280044f, 0.03063439f, -0.16606414f, -0.13651368f, -0.14495435f, 0.12454212f, -0.06277436f, 
    0.12935877f, -0.16416714f, 0.09615618f, 0.12184215f, -0.08228451f, 0.14809598f, 0.00405290f, 0.00010155f, 
    -0.13542189f, -0.12477035f, -0.16309626f, 0.12001212f, 0.08620929f, 0.06949337f, -0.13767359f, -0.03870935f, 
    0.43977699f, -0.00273475f, 0.42617753f, 0.01762494f, 0.01847885f, 0.34314394f, -0.31746349f, -0.10281703f, 
    0.18739133f, 0.15583795f, 0.31115493f, -0.07811186f, 0.09918426f, 0.07693891f, -0.14565745f, -0.13827826f, 
    0.53344822f, 0.44131711f, -0.21514317f, -0.21663254f, 0.34414396f, -0.11740576f, -0.06756531f, 0.56875187f, 
    0.11263166f, -0.37780792f, -0.07971716f, 0.16939895f, -0.26933643f, 0.52765661f, -0.29207230f, -0.12422393f, 
    0.09890945f, 0.12541555f, 0.11132558f, 0.15798457f, -0.13971142f, 0.57972288f, -0.06680551f, 0.22385769f, 
    0.21898864f, 0.16952790f, -0.08133190f, -0.17629007f, 0.10959163f, 0.13261700f, -0.05395508f, -0.04439180f, 
    0.61476070f, 0.18244888f, 0.57797837f, 0.31555945f, 0.26826409f, 0.00649876f, 0.06618695f, -0.06627148f, 
    0.23369363f, -0.31336090f, 0.00526608f, 0.15761189f, -0.62815744f, 0.26390234f, -0.16847882f, -0.07623211f, 
    -0.23820998f, 0.16563137f, -0.30446067f, -0.10561642f, -0.02174336f, 0.08018575f, 0.37433743f, 0.26208529f, 
    0.48780936f, 0.05105768f, 0.20646062f, -0.54489172f, 0.08066053f, 0.17963023f, 0.24714950f, 0.07345339f, 
    -0.11075032f, 0.06471652f, 0.24800672f, 0.18375310f, 0.51357949f, 0.05724877f, 0.13242775f, -0.13555689f, 
    0.33316827f, 0.30004483f, 0.06314103f, -0.11591349f, -0.10954967f, 0.15471680f, 0.27970544f, 0.31696337f, 
    0.05471248f, 0.09784827f, -0.10103871f, -0.05661659f, 0.00937104f, -0.13544509f, -0.01624738f, -0.16119315f, 
    0.01538656f, 0.10150297f, -0.01530986f, -0.17804913f, 0.10331587f, -0.05106974f, 0.04796876f, -0.06613858f, 
    -0.08943681f, -0.18622322f, 0.07614033f, 0.09011290f, 0.08039641f, -0.16421415f, -0.02492567f, 0.00530765f, 
    0.13493745f, -0.08631015f, 0.11677907f, 0.03003304f, -0.17424423f, -0.00820004f, -0.04713690f, 0.03395706f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.22925696f, 0.09453837f, -0.06153989f, -0.09024179f, 0.15265293f, 0.23664114f, 0.18970568f, -0.00710232f, 
    0.02243168f, -0.22105341f, -0.07668120f, -0.02722359f, 0.25623435f, 0.03393951f, -0.04581097f, 0.00598015f, 
    0.14728184f, 0.18683016f, -0.05682712f, 0.04855821f, -0.17225315f, 0.13677786f, 0.19492359f, -0.16312562f, 
    0.25592786f, -0.10852902f, 0.11670752f, -0.06731678f, 0.35494670f, 0.11963116f, 0.12810643f, -0.10818602f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.05565427f, 0.16691032f, -0.40648142f, -0.15037611f, 0.57776970f, -0.03434306f, 0.08597747f, 0.07443658f, 
    -0.29202801f, -0.43606979f, -0.19644536f, 0.09182802f, 0.13218161f, -0.13519672f, -0.04035247f, -0.12978984f, 
    0.09496409f, 0.26859403f, -0.12736891f, -0.14460327f, 0.07118613f, -0.69678527f, -0.10013866f, -0.02934306f, 
    0.12371903f, 0.08544802f, 0.04318228f, -0.03973251f, -0.29823774f, -0.07351575f, -0.08563226f, -0.00721073f, 
    0.00125659f, -0.64348722f, 0.03061333f, 0.20071563f, 0.00528821f, 0.07888623f, -0.38748083f, -0.06826917f, 
    0.43756202f, 0.07510781f, -0.28923324f, -0.09007706f, 0.23152485f, -0.02585544f, -0.26429629f, -0.00599599f, 
    -0.03761353f, -0.14150748f, 0.14405762f, 0.30131873f, -0.05787252f, 0.16218148f, 0.03327676f, 0.06353007f, 
    0.36036524f, -0.15559684f, 0.26320997f, -0.04083638f, -0.18164974f, -0.41868258f, -0.29086861f, 0.08166422f, 
    0.47133416f, 0.01807037f, -0.19146676f, 0.16627358f, 0.03422922f, -0.24456939f, -0.01916547f, 0.18013924f, 
    0.01120380f, -1.02576995f, 0.30294326f, -0.04200374f, -0.24127929f, -0.03624103f, -0.48833370f, 0.14631104f, 
    -0.08742742f, -0.89585727f, -0.23468743f, -0.40901572f, 0.01778081f, -0.44227988f, -0.04744655f, -0.01880422f, 
    -0.15545128f, 0.13075438f, -0.35509476f, -0.01861748f, 0.30368751f, 0.24254024f, 0.11377902f, -0.03710533f, 
    -0.23953646f, 0.31901589f, -0.36448687f, -0.00299404f, -0.24892421f, 0.33029878f, 0.06468029f, -0.17648625f, 
    -0.04242865f, -0.20069988f, 0.19180129f, -0.05620822f, -0.06390272f, 0.18361756f, -0.06537636f, -0.04749794f, 
    0.14763349f, 0.12938866f, -0.03135373f, 0.26646954f, 0.15477668f, 0.21175165f, -0.44612020f, -0.06449872f, 
    -0.66122347f, -0.03291996f, -0.18683223f, -0.15036750f, -1.26062596f, 0.08404453f, 0.34274304f, -0.01864147f, 
    -0.11578070f, 0.18594484f, -0.84078270f, -0.11210393f, -0.04574444f, -0.15477276f, 0.23438787f, -0.37667292f, 
    -0.01190421f, 0.14415808f, 0.06914725f, 0.07670718f, -0.11675645f, 0.11202148f, -0.23198140f, -0.07316710f, 
    0.06607918f, 0.15177754f, -0.42897078f, -0.65237433f, -0.10131990f, 0.17173317f, 0.05275016f, 0.08845250f, 
    -0.68982875f, -0.14749302f, 0.08044733f, -0.14195967f, 0.03858023f, -0.02856697f, 0.33149123f, -0.03562736f, 
    -0.63037574f, -0.23837173f, 0.55519134f, -0.16489552f, 0.08966017f, -0.02420236f, 0.07656260f, -0.46668023f, 
    -0.02334816f, 0.22826864f, -0.76628917f, 0.16367140f, -0.02189687f, -0.39930901f, 0.25320563f, -0.13334428f, 
    -0.11977996f, 0.19815303f, 0.20084059f, -0.26878056f, -0.10805165f, -0.32679045f, 0.31216186f, -0.14848134f, 
    0.19120359f, 0.10443126f, 0.10615049f, -0.07140040f, 0.10222752f, -0.53930122f, -0.44811797f, -0.18139872f, 
    -0.78598034f, 0.12597123f, -0.49054098f, 0.03659566f, -0.49335822f, -0.58545756f, 0.29714474f, -0.72322911f, 
    0.14273411f, -0.73502111f, -0.21344483f, -0.01489149f, -0.95682937f, -0.23538253f, -0.94007504f, 0.13827196f, 
    -0.14135690f, 0.15888089f, -0.05333106f, 0.12145915f, 0.04894878f, -0.35603806f, 0.29096594f, 0.02249900f, 
    -0.62218118f, -0.10971539f, 0.48191893f, -0.04113117f, 0.13654870f, -0.19712362f, 0.02476322f, 0.04777075f, 
    0.04656165f, 0.26325685f, 0.02990776f, -0.84672111f, 0.21907260f, 0.13782281f, 0.24805345f, -0.06601532f, 
    0.22984795f, 0.41716522f, -0.14669791f, -0.06480911f, 0.36664799f, -0.13287699f, 0.34503937f, 0.08568288f, 
    0.06907658f, 0.16529518f, -0.69544566f, -0.02431603f, 0.04231308f, 0.32425269f, -0.66538614f, 0.03093067f, 
    -0.14633590f, 0.12113718f, -0.30350524f, -0.16043630f, -0.08609639f, -0.33410805f, -0.30894250f, -0.14991777f, 
    0.13305376f, -0.43716744f, 0.40084904f, -0.25355884f, -0.53966260f, -0.13198073f, -0.71745169f, 0.39385822f, 
    0.22780006f, 0.03753255f, -0.22677663f, -0.01967510f, 0.40664020f, -0.05014983f, -0.25233307f, 0.00059957f, 
    -0.13657627f, -0.23771116f, 0.16023466f, 0.58159482f, -0.13698356f, -0.13411111f, -0.00146313f, -0.04765424f, 
    0.43353578f, -0.20383905f, -0.69006503f, 0.11203319f, 0.10267130f, 0.23918582f, -0.70231998f, -0.09318156f, 
    -0.64686078f, -0.01356360f, -0.42187667f, 0.12690280f, -0.21539997f, -0.72720420f, -0.18436584f, -0.16474347f, 
    -0.61534446f, 0.38370261f, -0.57337421f, -0.08121125f, 0.27824026f, 0.23467313f, 0.13236575f, 0.04474492f, 
    0.03916423f, 0.31057334f, 0.26321262f, -0.81811059f, -0.10351589f, 0.13948753f, 0.18365623f, 0.05617808f, 
    -0.27393076f, -0.02325054f, -0.10960044f, -0.07554121f, 0.31585038f, 0.37948284f, -0.08878350f, 0.05619299f, 
    0.28041646f, 0.21677186f, 0.04489360f, -0.16341256f, -0.35720807f, 0.17108372f, -0.26698127f, 0.50381982f, 
    0.00776553f, -0.29406813f, -0.09014501f, -0.02197446f, -0.16764641f, -0.26301250f, 0.24988280f, -0.00296534f, 
    -0.16550298f, -0.10657381f, 0.05045119f, 0.30672848f, 0.10427200f, 0.04778706f, -0.04275304f, 0.00960154f, 
    0.36930186f, 0.03856981f, -0.13983153f, 0.05435403f, -0.50114918f, -0.31755912f, -0.10500505f, 0.10520980f, 
    0.05889544f, -0.16502602f, -0.28617126f, 0.09041124f, 0.07670222f, 0.41286576f, 0.22645396f, -0.49772695f, 
    -0.43967912f, 0.26165187f, 0.08461298f, -0.16894044f, -0.58968049f, -0.04453146f, -0.81161296f, -0.08385105f, 
    0.10214940f, -0.05596818f, 0.24744169f, 0.31233189f, 0.13027620f, 0.01977038f, -0.16882524f, 0.06858023f, 
    0.02509221f, 0.00344831f, -0.48197508f, 0.15867586f, 0.08246712f, 0.13910890f, 0.06901590f, -0.12286849f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00588794f, 0.07937627f, -0.06189907f, -0.06148831f, 0.04416358f, 0.00734475f, 0.10134277f, -0.21253531f, 
    -0.06960922f, 0.05641046f, -0.07009688f, -0.14553039f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
