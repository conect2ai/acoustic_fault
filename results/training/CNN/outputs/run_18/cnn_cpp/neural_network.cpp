#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.24603060f, 1.50240886f, -0.60707986f, -1.49896359f, -0.59639126f, 1.25554705f, -0.45038819f, 0.03074735f, 
    -0.09640291f, 0.16249296f, 0.70170009f, -0.30349460f, -0.01274919f, 0.42621657f, -0.17758383f, 0.36245868f, 
    0.25152245f, -0.34580675f, -0.06567772f, 0.50661129f, -0.13977696f, 0.04987743f, -0.24541065f, -0.48808926f, 
    0.11052155f, 0.63366580f, 0.51586372f, -0.74711376f, -0.88362175f, -0.39338541f, -0.98271036f, -0.69352651f, 
    0.31660780f, -0.44219983f, -1.14197779f, -0.55634689f, -0.46517241f, 0.62826967f, -0.41876745f, -0.51502210f, 
    -0.19368403f, -0.05706667f, -0.48457915f, 0.02724857f, 0.03044827f, 0.20975703f, 0.22943768f, 0.10107590f, 
    0.01718463f, -0.23079680f, 0.65911120f, 1.45138741f, 1.08626616f, 0.06848210f, 0.41952384f, -0.95916963f, 
    0.86882299f, 0.14682657f, -0.09558608f, 0.56846112f, 0.30307326f, 0.33677495f, -0.31737500f, 0.05525651f, 
    -0.41739804f, -0.07588535f, -0.47972068f, -0.10866176f, -0.17469946f, -0.56774759f, -0.11330520f, 0.20662211f, 
    -0.00899625f, 0.21135694f, -0.13732563f, -0.31833205f, -0.37019852f, 0.26379529f, 0.29579231f, -0.08326778f, 
    0.18350160f, -1.12968564f, -1.15581656f, -0.75621134f, -0.69800436f, 0.29410985f, 0.51557690f, 0.05594879f, 
    -0.01280987f, 0.56736892f, -0.27600855f, -0.08386838f, -0.01202263f, 0.42446929f, 1.13906932f, 0.20212577f, 
    -0.03386559f, -0.08975548f, 0.42152885f, 0.56101489f, -1.81648147f, 1.89137280f, 0.20361762f, -0.27059868f, 
    0.21448943f, -1.19710636f, 0.74446857f, 0.08380882f, 0.08607616f, -0.50817192f, 0.07955765f, -0.14712375f, 
    0.10902080f, -0.40503892f, 0.09066023f, 0.06543695f, 0.15646274f, 0.26723939f, -0.17379615f, -0.22170150f, 
    0.08440820f, 0.06974117f, -0.23928554f, 0.16818592f, 0.05725092f, -0.06476263f, -0.90360743f, -1.21060085f, 
    -0.65468627f, -0.31810206f, 0.69955695f, 0.07818225f, -0.61232793f, -0.09170331f, -0.05087177f, -0.45034486f, 
    -0.24945518f, 0.01746360f, -0.10024830f, 0.37000120f, -0.32656935f, 0.42684674f, -0.14339413f, 0.38625091f, 
    -0.25674328f, 0.38356352f, -0.58051020f, -0.04601651f, 0.20219770f, 0.02578918f, 1.88684297f, 0.72886145f, 
    1.23403621f, 1.52650726f, 0.86536288f, 0.12293526f, 0.09152089f, -0.59515506f, -0.36837959f, 0.07584124f, 
    0.15454301f, 0.38556325f, -0.01208176f, 0.29230702f, -0.12945612f, -0.04736599f, 0.28504696f, 0.46767402f, 
    -0.00826379f, 0.17170072f, 0.04729786f, 0.10257344f, -0.14873745f, 0.27019122f, 0.66372234f, 1.47626686f, 
    0.69822830f, 1.29777241f, -0.90414882f, -1.25611246f, 0.07270031f, -1.12908185f, 0.52107239f, -0.10921013f, 
    0.44175670f, 0.47312805f, 0.25846553f, -0.02148494f, -0.03098010f, -0.07140349f, -0.11826262f, 0.13910323f, 
    0.14972752f, 0.03657126f, 0.19047977f, 0.19439375f, 0.34260920f, -0.04561654f, 0.16579917f, 0.23827049f, 
    -0.19734490f, 1.17597437f, 1.18806732f, 0.25797403f, 0.73786074f, 0.70015264f, -0.53160352f, -1.34001470f, 
    -0.49299011f, -0.68137646f, 0.17752297f, -0.02308959f, 0.51219898f, 0.35355082f, -0.21249473f, -0.09178380f, 
    -0.05584067f, 0.09026472f, -0.23020461f, 0.00959087f, -0.14570287f, -0.16769172f, 0.06972510f, -0.50742513f, 
    -0.47695491f, -1.10696661f, 0.75037181f, 0.02538548f, 0.02724638f, 0.35918552f, -0.24401160f, -0.29922441f, 
    -0.73116976f, 0.16262758f, 0.23986669f, 0.47470102f, 1.05095220f, -0.61604309f, -0.03658863f, -0.38979116f, 
    0.46190569f, 0.32862151f, -0.07940619f, 0.19201152f, -0.06442843f, -0.55501354f, -0.09678928f, 0.44260484f, 
    0.03801125f, 0.06525992f, -1.65235507f, -0.66854596f, 0.03273360f, 0.31498218f, -0.69724274f, 0.88951415f, 
    1.59672713f, 0.25064835f, -0.09774349f, 0.06230167f, -0.46932465f, -0.43043202f, 0.01682681f, -0.32129428f, 
    0.03505621f, -0.01473604f, 0.04753015f, -0.31645283f, -0.26607043f, -0.09799131f, 0.07475020f, 0.12613924f, 
    0.13694742f, 0.04885390f, -0.03781522f, 0.84497857f, -0.19660631f, -0.95936757f, -0.82971746f, 1.45074034f, 
    0.90074295f, -0.15760455f, 0.98116773f, 0.42916545f, 0.64728594f, -0.34925526f, 0.26367939f, -0.44128111f, 
    0.26340389f, 0.19332474f, 0.31366694f, 0.04875354f, 0.23345922f, 0.32832289f, 0.39107326f, 0.10616186f, 
    -0.23660286f, 0.09470824f, -0.00549733f, -0.35535735f, -0.93244112f, -0.91095573f, -1.34736013f, -0.67039973f, 
    0.13802733f, -0.48581800f, -0.50412029f, -0.31240174f, -0.31561288f, 0.51222402f, -0.01522406f, 0.52478951f, 
    0.15779541f, -0.23621801f, 0.16399111f, 0.26940480f, 0.33857861f, 0.49069595f, -0.03312620f, -0.07784703f, 
    0.16935703f, 0.04566570f, -0.05920890f, -0.47295234f, 0.09709962f, 0.54770267f, -1.78256488f, -1.28424871f, 
    -0.10423803f, 0.39896995f, -1.12425113f, 1.29157352f, 0.46759394f, -1.05367792f, 0.17460410f, 0.34884691f, 
    -0.01259694f, -0.15157279f, -0.35968521f, -0.15906315f, -0.25357026f, -0.19715902f, -0.43302688f, -0.38694495f, 
    -0.36104986f, -0.01380738f, -0.25413218f, 0.17378607f, 0.22185335f, -0.05713746f, 0.44028726f, 1.03401721f, 
    -1.23250878f, 0.20677972f, 0.48786539f, 0.19090921f, -1.00768757f, -1.29824686f, -1.08003652f, -0.15905893f, 
    0.38267100f, 0.30479121f, -0.13366222f, 0.14622757f, -0.33405980f, -0.22581905f, -0.41740265f, -0.12269653f, 
    -0.43694127f, -0.30045664f, -0.23023927f, 0.40415716f, 0.50916666f, 0.32354653f, 0.07962774f, -0.78782564f, 
    -0.25637954f, -0.87947822f, -1.10459232f, -1.02050757f, -0.13449870f, 0.05716283f, -0.03403961f, 1.03641140f, 
    -0.09690151f, -0.56774217f, -0.60396421f, -0.36028960f, -0.21587193f, -0.50427109f, 0.22262283f, -0.22793373f, 
    0.03187829f, 0.27286911f, 0.14639564f, 0.11992373f, -0.07638221f, -0.05989714f, -0.26689547f, 0.77660835f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35866809f, 0.36487988f, 0.37935045f, 0.58098090f, 0.36790016f, 0.12071171f, 0.25549781f, 0.33377898f, 
    -0.04146000f, 0.37343600f, 0.18035498f, 0.33348560f, 0.44784528f, 0.44685140f, 0.42414314f, 0.17277732f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25555447f, -0.36962676f, -0.00906690f, -0.67045951f, -0.08282738f, -0.05175288f, 0.16077666f, -0.11027209f, 
    -0.06240893f, 0.10831673f, 0.04605606f, 0.04607620f, -0.50723606f, -0.09375159f, 0.20936890f, -0.19270976f, 
    -0.13710569f, 0.16993359f, 0.02601657f, -0.06975627f, 0.00613406f, -0.00263119f, -0.03165646f, 0.06820226f, 
    -0.07544270f, 0.11485829f, 0.03422426f, 0.04019683f, -0.21159324f, -0.14971888f, -0.00907327f, -0.10923037f, 
    -0.01136057f, -0.02591205f, 0.06576227f, -0.11796641f, -0.46712968f, -0.19692139f, 0.10808873f, -0.15335235f, 
    0.09106708f, -0.02751306f, 0.14014274f, 0.01941180f, 0.18769589f, -0.16856892f, 0.14565621f, 0.02927721f, 
    0.05445926f, 0.14741935f, 0.05395370f, -0.28956571f, 0.02484810f, -0.26040867f, 0.17917849f, -0.23581101f, 
    -0.07945856f, -0.01785289f, -0.01292149f, 0.09331112f, -0.01581842f, -0.43911088f, 0.14902054f, -0.39137080f, 
    0.02327120f, -0.17056999f, -0.18957573f, 0.09359598f, -0.02478720f, 0.06852789f, -0.07985321f, 0.25837243f, 
    0.42476439f, -0.13775398f, -0.18845801f, 0.46139172f, -0.40220597f, -0.29176679f, 0.11606850f, 0.22344424f, 
    -0.02355321f, 0.07185926f, -0.20285091f, 0.06713992f, -0.24265024f, 0.01353711f, -0.02016828f, -0.13749409f, 
    0.06419815f, -0.16310625f, 0.04482089f, -0.12095310f, -0.16904309f, -0.08014230f, -0.19129848f, 0.04288422f, 
    -0.19986400f, 0.01282363f, 0.12581204f, -0.03367375f, -0.14392343f, -0.21917534f, -0.02034598f, -0.05251298f, 
    0.09974748f, 0.10848342f, -0.16683102f, 0.13218673f, -0.36984348f, -0.27296263f, 0.19463043f, -0.03644218f, 
    0.18310080f, -0.01682050f, 0.02476746f, -0.07433268f, 0.18337579f, -0.03074915f, -0.11637120f, -0.08655559f, 
    0.63781589f, 0.49087316f, 0.53747231f, 0.00332002f, 0.04054177f, 0.31305203f, -0.08888470f, 0.17679001f, 
    0.07696281f, -0.06524277f, 0.11252021f, -0.04799632f, 0.50371766f, -0.09824062f, 0.05836191f, -0.27593365f, 
    -0.16259141f, 0.31464267f, 0.17030685f, 0.00473094f, -0.05944243f, -0.05171355f, -0.16944715f, 0.10798343f, 
    -0.10597518f, -0.66172886f, 0.37840837f, 0.02716370f, 0.07410289f, -0.19007020f, 0.17183998f, 0.20604546f, 
    -0.03915721f, -0.25521445f, -0.05372791f, 0.01630401f, -0.81052220f, 0.06398017f, 0.04125268f, 0.18992940f, 
    -0.12261485f, -0.17691168f, -0.11182953f, -0.16770329f, -0.11000647f, 0.03465768f, -0.00419714f, 0.01741605f, 
    0.56813079f, -0.18004300f, 0.41950616f, 0.08995646f, -0.14007911f, -0.11090150f, -0.09117218f, -0.01008635f, 
    -0.06162589f, 0.04309772f, -0.02298384f, 0.00544813f, 0.47738743f, 0.00540367f, -0.36028087f, -0.51145285f, 
    0.22536585f, 0.12714827f, 0.07075298f, -0.05327427f, 0.15734269f, -0.06999085f, -0.05040345f, -0.01459574f, 
    -0.26712349f, -0.09030618f, 0.17765975f, -0.43296659f, -0.12434535f, 0.06478507f, 0.05237427f, 0.00154530f, 
    -0.11789893f, 0.20770280f, 0.08742702f, 0.03266354f, -0.00204860f, -0.41432974f, -0.05674613f, -0.55067825f, 
    0.07358185f, -0.07083835f, 0.13417044f, 0.14538586f, -0.08088676f, 0.01931921f, -0.18194062f, 0.09254687f, 
    0.24416655f, 0.26185453f, 0.07832382f, 0.21501453f, -0.14050409f, 0.01263755f, 0.15676881f, 0.09488326f, 
    0.08334748f, -0.07068738f, 0.06879678f, 0.04855381f, -0.62123352f, 0.04463006f, -0.17336269f, -0.05018856f, 
    -0.03900168f, 0.05409069f, -0.08429124f, -0.06292999f, -0.20278765f, 0.14911443f, 0.03636201f, -0.02807930f, 
    -0.26747102f, 0.22035708f, -0.63998795f, -0.67976671f, 0.03049728f, 0.26668048f, -0.03380545f, -0.04039147f, 
    -0.09815155f, -0.23555766f, 0.00511462f, 0.03912237f, 0.23539662f, 0.23266013f, 0.03089113f, -0.12981001f, 
    0.23661017f, 0.29557049f, 0.11812382f, -0.05494186f, -0.00497048f, -0.03843826f, -0.15618983f, -0.08362275f, 
    0.53381193f, -0.01727715f, 0.36791450f, 0.47723985f, -0.23093495f, 0.04451856f, 0.01783881f, 0.02887921f, 
    0.06329606f, -0.13599393f, 0.21297438f, -0.06829647f, 0.08571832f, 0.32853404f, -0.02797945f, -0.10422021f, 
    0.08215439f, -0.18968841f, 0.07125868f, 0.10381852f, 0.06082120f, 0.02272616f, 0.30571726f, 0.02125139f, 
    0.20351368f, -0.16572323f, -0.09398561f, -0.01579771f, 0.03865672f, -0.13697255f, 0.01979079f, -0.19788365f, 
    -0.04324639f, -0.03773820f, -0.10725079f, 0.00803172f, -0.23002146f, -0.22995575f, -0.23670016f, -0.05724569f, 
    -0.07253202f, -0.08478201f, 0.04194500f, -0.21290226f, 0.23560308f, 0.07542567f, -0.06431866f, 0.02284603f, 
    -0.43211007f, -0.04324250f, -0.33177906f, 0.02347749f, 0.00696943f, 0.04709936f, -0.03742820f, -0.11694974f, 
    -0.00236877f, 0.12115683f, -0.03965406f, -0.00947698f, 0.48965204f, -0.48882774f, 0.35860366f, -0.46085694f, 
    0.17591539f, -0.01577109f, -0.15994565f, 0.25937340f, 0.11241166f, 0.06820591f, -0.02984042f, -0.02536092f, 
    0.20750651f, 0.32483602f, 0.07189196f, -0.30448836f, -0.02578506f, -0.07663926f, 0.21164517f, 0.18300056f, 
    0.06666521f, -0.04324884f, 0.25829232f, 0.06911979f, 0.71866935f, -0.44202262f, 0.06632829f, -0.15508994f, 
    -0.25422207f, 0.03405315f, -0.08572716f, 0.11103389f, -0.09851294f, -0.20254503f, -0.14204231f, -0.15885885f, 
    -0.15824018f, -0.61853170f, -0.11480628f, -0.61702430f, 0.16724050f, -0.11559496f, 0.07781205f, 0.04611621f, 
    0.18739273f, 0.07774296f, -0.13350897f, -0.13234419f, -0.49071386f, -0.24381976f, 0.16772680f, -0.28644755f, 
    -0.02673577f, -0.17546441f, -0.07577168f, 0.44983974f, 0.25988132f, 0.12926862f, -0.00617891f, 0.07432760f, 
    0.06233547f, 0.29256803f, 0.04287543f, -0.23839414f, 0.10152546f, 0.07665332f, 0.21671888f, -0.05584225f, 
    -0.03891636f, -0.08870326f, -0.18297172f, 0.08747573f, -0.98772717f, 0.03205257f, -0.45218733f, -0.35928985f, 
    0.13960512f, -0.00549454f, 0.16987862f, -0.13908574f, -0.05730724f, 0.00172847f, -0.00318018f, 0.03090076f, 
    0.15758063f, 0.19917110f, -0.15962282f, -0.03627253f, 0.10910942f, 0.05878029f, 0.04733466f, -0.05799601f, 
    -0.12569702f, 0.03006204f, 0.10544931f, 0.01948276f, -0.06307206f, -0.18014786f, -0.08757871f, -0.37903214f, 
    0.04858202f, 0.07750575f, 0.01979475f, 0.16582195f, 0.04670602f, -0.05410903f, 0.26075873f, -0.16030522f, 
    0.29173309f, -0.15644535f, -1.07874215f, -0.09667764f, 0.01124351f, 0.17966151f, -0.06205892f, -0.15206410f, 
    -0.10705581f, -0.04861355f, -0.01477688f, 0.03198313f, -0.05215215f, -0.07628246f, 0.31772289f, 0.04280227f, 
    -0.33507690f, -0.46551734f, -0.18819237f, 0.38416815f, 0.05973992f, -0.32702792f, -0.00586150f, 0.00044141f, 
    -0.05407093f, 0.04438931f, -0.02088208f, 0.10835181f, 0.27672133f, 0.21507852f, -0.03038786f, -0.03727404f, 
    -0.04241584f, 0.08576693f, -0.01226893f, 0.04057400f, -0.84506005f, 0.10541821f, 0.21904324f, -0.33806366f, 
    -0.14916085f, 0.14598390f, 0.14064746f, -0.12890354f, -0.14264712f, -0.13503812f, 0.02819541f, -0.03635258f, 
    0.36640811f, 0.08552046f, 0.02951637f, 0.20574646f, 0.07374354f, 0.07864062f, 0.04185411f, -0.18386701f, 
    0.02830515f, 0.20114881f, -0.10638978f, -0.08613889f, 0.42140791f, -0.35998046f, -0.03191831f, 0.01693214f, 
    -0.09846947f, 0.03079025f, 0.01180923f, 0.01731967f, -0.22947119f, -0.10782024f, 0.12609492f, -0.31587848f, 
    0.86813438f, -0.02447195f, 0.28117090f, 0.00110553f, -0.21395682f, -0.47289124f, -0.19740322f, 0.14984399f, 
    0.26054978f, 0.02931236f, 0.16326714f, -0.17669457f, -0.21104355f, 0.28944725f, 0.01095641f, 0.14908515f, 
    -0.02591492f, 0.14272097f, 0.18153757f, 0.07794165f, -0.07433401f, -0.35254467f, 0.01490407f, -0.04513432f, 
    0.26737031f, -0.63282639f, 0.22659542f, 0.03568337f, -0.26577643f, -0.38787043f, 0.01427293f, -0.07069213f, 
    0.03547234f, -0.00098576f, -0.13489527f, 0.01058691f, 1.03576231f, -0.07505897f, -0.00782847f, 0.08110629f, 
    -0.26255399f, 0.07310397f, -0.15792872f, -0.10956447f, -0.02931440f, -0.06589875f, 0.08698694f, 0.00589649f, 
    -0.21925500f, -0.21100527f, -0.20601721f, -0.58866507f, 0.21298422f, -0.22314519f, -0.00768357f, -0.22658147f, 
    -0.00925465f, 0.02241782f, -0.15436934f, -0.26766953f, -0.18095513f, 0.29116884f, -0.05039666f, 0.65021420f, 
    -0.17421213f, -0.28472278f, -0.25415492f, -0.01788014f, 0.02633261f, -0.02435648f, 0.02815066f, 0.07683691f, 
    0.19884849f, 0.42072234f, 0.02960242f, -0.08237589f, -0.01049014f, -0.16014928f, -0.04189546f, 0.16712447f, 
    0.04197001f, -0.24173246f, -0.17974393f, -0.06945274f, 0.41991255f, -0.16475680f, 0.05721816f, 0.01973739f, 
    0.07550092f, -0.03122072f, -0.00700736f, 0.01056158f, 0.04732618f, 0.15685545f, -0.15549286f, 0.16240899f, 
    -1.44813728f, -0.41424686f, -0.34339437f, 0.06280783f, -0.16654925f, 0.00682396f, 0.07037419f, -0.05026626f, 
    -0.12018620f, 0.15615384f, 0.07218617f, -0.08275142f, 0.01864237f, 0.00668343f, 0.12900566f, 0.15290046f, 
    0.19345456f, -0.16240998f, -0.16465974f, 0.07247686f, -0.05903327f, -0.18316053f, -0.09134906f, -0.38522026f, 
    -0.46707812f, 0.67384100f, 0.06681336f, -0.18233456f, 0.01834151f, -0.06519597f, 0.04869494f, 0.21290123f, 
    -0.07106311f, 0.11708461f, -0.06178688f, -0.02781208f, 0.08254916f, -0.25285345f, -0.05170432f, 0.03490148f, 
    -0.21385373f, -0.05767638f, 0.04750753f, -0.08479307f, -0.23863253f, -0.05433591f, 0.07709661f, 0.08876846f, 
    -0.83655000f, -1.29375112f, -0.37524295f, 0.41359326f, -0.09298154f, 0.01368960f, -0.03604114f, -0.14083610f, 
    0.04856321f, -0.19698241f, -0.01020070f, 0.08644470f, -0.06263382f, -0.89424676f, -0.51880783f, 0.16065262f, 
    -0.12930350f, -0.07935307f, 0.12208489f, 0.22753395f, -0.08625133f, 0.08589269f, -0.17322583f, 0.06660641f, 
    0.99361014f, -0.24233115f, -0.09166605f, 0.56198919f, 0.11810777f, 0.20905337f, 0.02626527f, -0.02638698f, 
    0.03542587f, 0.15393877f, -0.14714827f, -0.05176670f, 0.34803864f, 0.28667599f, 0.09435829f, 0.21999112f, 
    0.17051621f, 0.22154035f, 0.11023787f, 0.20817040f, -0.05372228f, 0.03338723f, -0.01396158f, -0.15645327f, 
    -0.20458540f, -0.02203729f, 0.11662405f, -0.19776535f, 0.01477299f, -0.24389012f, 0.06729744f, 0.03567427f, 
    -0.06632705f, -0.12139412f, 0.07309771f, -0.06867662f, -0.39659846f, -0.04784665f, -0.36085346f, -0.17681900f, 
    -0.09154346f, 0.15412383f, 0.10095548f, -0.14883617f, -0.09399588f, 0.05443796f, -0.06323237f, -0.05062599f, 
    -0.05055936f, 0.16093361f, -0.14985268f, 0.00392527f, -0.29801553f, -0.28113037f, -0.12765080f, -0.12820148f, 
    -0.05931937f, 0.04083467f, -0.16425271f, -0.02017547f, 0.07755239f, -0.08106137f, 0.31684268f, 0.18724288f, 
    0.05148670f, -0.08607157f, 0.11802138f, 0.04149646f, -0.13047090f, 0.16879576f, -0.04841690f, -0.02997374f, 
    0.50863868f, 0.25102276f, 0.03656231f, 0.26252541f, 0.13690439f, -0.13627124f, -0.14173184f, 0.12806609f, 
    -0.10775059f, 0.13812742f, 0.05900433f, -0.04463847f, -0.09730653f, 0.04306572f, 0.08846588f, -0.14394952f, 
    -0.19521442f, 0.16896528f, 0.13705602f, 0.05553545f, -0.09982428f, -0.09052934f, 0.09611461f, 0.09089761f, 
    0.49265346f, -0.07838261f, 0.00697303f, 0.37458515f, 0.04128810f, -0.20733999f, 0.05731452f, 0.20395720f, 
    -0.09946400f, -0.12397194f, 0.04823253f, -0.05536853f, 0.29984751f, -0.20783393f, -0.09037801f, -0.00806710f, 
    0.03468762f, -0.04729705f, 0.08229633f, -0.12744613f, 0.04376596f, -0.00679741f, 0.15602893f, -0.06718397f, 
    -0.47861058f, -0.03195666f, 0.03885742f, 0.12608826f, -0.32658601f, -0.15478374f, 0.14321910f, 0.07622341f, 
    0.10084038f, 0.07787222f, 0.00443671f, -0.21390384f, -0.40165672f, 0.05033429f, 0.54051858f, -0.09445760f, 
    0.13125503f, 0.26757509f, -0.02858873f, 0.18273361f, 0.04728141f, -0.32162005f, -0.06816828f, -0.02318239f, 
    0.02370470f, 0.46569076f, 0.24246749f, 0.04281958f, 0.08563492f, -0.11963291f, 0.23045780f, -0.02706289f, 
    0.14493106f, 0.03807136f, -0.29547343f, -0.02508504f, -0.49612939f, 0.09778902f, 0.04982837f, 0.29645249f, 
    0.19914764f, -0.10779487f, 0.25967351f, 0.15585245f, -0.16521959f, 0.04138810f, -0.13485616f, -0.05790609f, 
    0.09635592f, 0.18653075f, 0.23804399f, 0.03667332f, -0.14873657f, -0.00033213f, -0.06282278f, 0.08966370f, 
    0.03347588f, -0.02577688f, -0.23892573f, -0.14088014f, -0.17286226f, -0.60991716f, 0.11785879f, -0.58168471f, 
    -0.20126207f, 0.14605622f, -0.11400875f, -0.25511268f, 0.15745018f, 0.08731417f, -0.06517790f, -0.02885021f, 
    -0.60256577f, 0.30551907f, 0.06532327f, -0.04516966f, 0.03288810f, 0.14337143f, -0.06517194f, 0.20478725f, 
    0.01923637f, 0.21615602f, 0.12840492f, 0.12745914f, 0.38808179f, 0.16470949f, 0.24959536f, -0.16543807f, 
    -0.18089512f, 0.03295477f, -0.14772505f, 0.03736713f, -0.21563028f, 0.29577109f, -0.01743867f, -0.03043009f, 
    -0.89864612f, -0.21683183f, -0.27964088f, -0.01133337f, 0.07492033f, -0.25292891f, 0.00402604f, 0.17127040f, 
    0.11783087f, -0.13942394f, -0.21422113f, 0.18727624f, -0.05257692f, -0.46505389f, -0.50796211f, 0.24528581f, 
    0.11092134f, -0.11480147f, 0.08275943f, -0.29238805f, 0.06954618f, -0.17914076f, -0.02415742f, -0.00317307f, 
    0.14341655f, 0.03062257f, 0.21599983f, 0.36801276f, 0.21116447f, 0.01256176f, 0.04220490f, 0.12556696f, 
    0.11816057f, 0.16339691f, 0.03430994f, -0.04451049f, -0.64702213f, 0.14043318f, -0.32940298f, -0.13620843f, 
    0.13704033f, -0.04418782f, 0.03959673f, -0.07197431f, 0.10482328f, -0.03215690f, 0.01198748f, 0.02091881f, 
    -0.45661223f, 0.04825269f, 0.14808764f, -0.00139623f, -0.27156818f, 0.04589046f, -0.00581010f, -0.07320409f, 
    -0.08070447f, -0.10926204f, 0.12074467f, 0.09739779f, 0.00208075f, -0.20012197f, 0.08163505f, 0.22879076f, 
    0.10809071f, -0.11398331f, 0.07215159f, -0.08825813f, -0.15869331f, -0.01788709f, 0.18154818f, 0.05916671f, 
    -0.26325083f, -0.11339272f, 0.03361992f, 0.14203860f, 0.14346623f, -0.04290548f, -0.14594658f, -0.31765389f, 
    -0.02963948f, 0.03881878f, 0.01011438f, 0.06617643f, 0.32366282f, -0.07550743f, 0.27524945f, 0.28426445f, 
    0.06960735f, -0.19839452f, 0.04004293f, 0.12276968f, 0.08111158f, -0.17615503f, -0.06147179f, -0.07395051f, 
    0.22865741f, -0.09358203f, 0.06148332f, 0.00545728f, -0.17671998f, -0.08386735f, -0.19503044f, -0.07382738f, 
    -0.04109111f, -0.16102159f, -0.11082245f, -0.08038557f, 0.07076192f, -0.09283162f, -0.18637945f, 0.19304530f, 
    -0.28027427f, -0.17573176f, 0.07383995f, -0.07061914f, -0.23108482f, 0.28407377f, 0.19542231f, 0.32977730f, 
    -0.35675851f, -0.36682358f, 0.25271118f, 0.56890732f, -0.20735940f, -0.29248869f, -0.04703985f, 0.16053692f, 
    0.27004862f, 0.05020596f, 0.18418622f, 0.04522820f, -0.15090629f, -0.17469925f, -0.12223868f, -0.16832063f, 
    0.15720439f, 0.18964975f, -0.08738603f, -0.03975338f, 0.47308621f, 0.03814346f, 0.25557598f, -0.23120780f, 
    0.11262051f, -0.07318565f, 0.14127758f, -0.13097249f, -0.13154300f, 0.16201313f, 0.08265848f, -0.08634075f, 
    0.03527375f, -0.04490715f, 0.22713007f, 0.25192556f, 0.16417749f, -0.01301723f, 0.02966734f, 0.34864604f, 
    -0.07542430f, 0.00476577f, -0.05756052f, 0.19271441f, 0.17633630f, 0.01082050f, 0.10375009f, -0.09146926f, 
    -0.02306961f, -0.25987411f, 0.16589172f, 0.24113625f, -0.22879398f, 0.05226665f, 0.03939411f, 0.09402825f, 
    -0.14812113f, 0.01931800f, 0.10668015f, 0.10809673f, -0.10069148f, -0.13139491f, -0.17044874f, -0.18317202f, 
    -0.03432544f, -0.01794048f, 0.12343749f, -0.11645710f, 0.05932735f, -0.03415707f, -0.09542327f, 0.39596906f, 
    -0.96362072f, 0.09610946f, -0.18928127f, -0.27540043f, 0.15085956f, 0.13188781f, 0.08510033f, -0.13078029f, 
    -0.02619315f, 0.02356257f, -0.11573202f, -0.15675800f, 0.15587808f, 0.38622865f, 0.29677907f, -0.42070717f, 
    0.11857986f, -0.14966911f, -0.23342867f, -0.11813187f, 0.07121263f, 0.04105768f, 0.05418905f, -0.04991337f, 
    -0.64607286f, -0.08658649f, -0.39609170f, -0.05813836f, 0.12975465f, 0.29834253f, -0.31617278f, 0.02078668f, 
    -0.06252381f, 0.23681156f, 0.05521221f, 0.12968479f, -0.81106263f, -0.15408590f, -0.00614758f, -0.40113798f, 
    0.08678722f, 0.03992874f, 0.05574213f, 0.04450383f, 0.04752845f, -0.00623245f, -0.17484291f, -0.09184454f, 
    -0.10776150f, -0.21151453f, 0.27662086f, 0.44687501f, -0.37353823f, 0.06575440f, 0.00019554f, 0.12186642f, 
    -0.08456937f, -0.20810220f, -0.22972573f, -0.05539984f, 0.52490771f, -0.35776466f, -0.35437560f, 0.09636845f, 
    0.32426816f, 0.22297078f, -0.08061731f, -0.15885377f, -0.03648822f, -0.11272556f, -0.01257712f, -0.01523465f, 
    -0.00331698f, 0.04425065f, -0.50929540f, 0.54692233f, -0.12688303f, 0.27628040f, 0.03408029f, -0.11951711f, 
    -0.03450729f, -0.25196335f, -0.11192314f, -0.11436372f, -0.25002718f, -0.24910173f, -0.23470601f, 0.14713362f, 
    0.03565168f, 0.02129844f, -0.12092039f, 0.03086285f, 0.07446347f, -0.09677605f, 0.11157934f, 0.14032939f, 
    -0.44321379f, 0.50082296f, 0.02217815f, 0.03314727f, 0.15177023f, 0.04154733f, -0.02688313f, 0.26360223f, 
    -0.11590900f, -0.00950861f, 0.14129584f, 0.30689114f, 0.11422446f, -0.17063056f, -0.04039389f, -0.04060157f, 
    0.22004317f, 0.10330421f, 0.00128064f, -0.20367351f, 0.13768202f, -0.49942064f, -0.07257914f, -0.27637523f, 
    0.34450495f, -0.00501747f, 0.11874430f, 0.12954782f, 0.10021102f, -0.09655168f, 0.21510732f, 0.07320291f, 
    -0.20394048f, 0.07379102f, -0.15419531f, -0.05364840f, -0.08961598f, -0.14809249f, -0.40350249f, -0.20394798f, 
    -0.22163396f, -0.07903735f, -0.25747919f, -0.22701889f, -0.12102965f, 0.02217586f, -0.01440983f, 0.28968456f, 
    -0.08106459f, 0.45549035f, 0.20151255f, -0.82573467f, -0.04791644f, -0.18828772f, -0.15722701f, -0.01168768f, 
    0.13164370f, 0.06094547f, -0.04197437f, -0.13459738f, -0.66895741f, 0.22502062f, -0.17070578f, 0.70773709f, 
    0.00710856f, 0.10564477f, -0.01622193f, 0.24427985f, -0.11917854f, -0.23624867f, -0.22612771f, -0.33475387f, 
    0.24364944f, 0.16299850f, 0.01511513f, -0.37937123f, -0.18500088f, 0.03445533f, 0.12078673f, 0.21811149f, 
    0.12870039f, -0.00435834f, -0.03104567f, 0.01130197f, -0.21028370f, 0.19672343f, 0.00905806f, 0.21290904f, 
    0.20419045f, 0.12466330f, 0.05512888f, -0.01804420f, -0.05781385f, 0.01733653f, -0.01654271f, -0.18241249f, 
    0.63857454f, -1.01812804f, -0.09099471f, -0.16163300f, -0.02164179f, 0.19920640f, 0.02371672f, -0.04659825f, 
    -0.02636712f, 0.02457465f, 0.18422206f, 0.30652115f, -0.69299906f, -0.12729537f, 0.21842287f, -0.10083579f, 
    -0.02343105f, 0.04859091f, 0.05571270f, 0.16300403f, 0.10841045f, -0.01798565f, 0.06571622f, -0.10785077f, 
    -0.38530970f, -0.02464934f, 0.00927811f, -0.17776974f, -0.09381671f, 0.03647351f, -0.12558970f, -0.07789040f, 
    0.01418617f, -0.20484081f, -0.11825101f, 0.19991058f, 0.51684952f, 0.28430310f, 0.05475730f, -0.18410568f, 
    0.02550542f, 0.10615108f, 0.00370336f, -0.03115578f, 0.04041399f, 0.02851488f, 0.30894870f, 0.12225707f, 
    0.05908325f, 0.04773568f, -0.58363372f, 0.12491707f, -0.03787244f, 0.06467616f, -0.07391869f, 0.04024058f, 
    -0.03793174f, 0.07457317f, -0.07097106f, 0.14499065f, -0.29507524f, -0.06244585f, -0.07134946f, -0.15726568f, 
    -0.20784378f, -0.03928815f, 0.20047939f, -0.20018359f, -0.09376644f, -0.05276401f, 0.03756482f, 0.01154981f, 
    -0.30357221f, 0.41883117f, -0.09682452f, 0.41419253f, 0.18199202f, -0.11389619f, -0.30669677f, 0.02125722f, 
    0.07248796f, -0.00505431f, -0.12177456f, -0.17191820f, 0.21859521f, 0.25677380f, 0.07340879f, 0.60378426f, 
    -0.06327295f, -0.21298100f, -0.26923302f, -0.01916422f, -0.08882499f, -0.16800918f, -0.19222502f, -0.14009379f, 
    0.17737757f, -0.55555570f, -0.13913977f, -0.37443787f, 0.17755266f, 0.10316841f, -0.09592746f, -0.08691363f, 
    -0.23491862f, -0.22478469f, -0.12076931f, -0.03706722f, 0.19688119f, -0.05424494f, -0.25150585f, 0.29563081f, 
    -0.05915222f, -0.14723726f, 0.04937844f, -0.17039347f, 0.02905977f, -0.09668402f, -0.08723707f, -0.06656137f, 
    0.31067857f, -0.66938925f, 0.60492146f, 0.16612795f, 0.22869340f, -0.12524399f, -0.30433738f, -0.15321317f, 
    -0.12978756f, -0.11218836f, 0.05538438f, 0.06463200f, -0.09674424f, 0.33510104f, 0.10220625f, 0.27670032f, 
    -0.03622839f, 0.09770555f, 0.11257931f, 0.06460433f, -0.23229823f, 0.07837281f, -0.05774934f, -0.11556308f, 
    -0.37871936f, 0.03040317f, -0.36837402f, -0.28654847f, 0.14822906f, -0.07070940f, -0.01040374f, -0.16533649f, 
    -0.01831848f, 0.07848108f, -0.02432651f, -0.31012934f, -0.26038352f, -0.21637572f, -0.32045934f, -0.26006684f, 
    -0.00790599f, -0.28663447f, -0.03811016f, 0.00470715f, -0.26678750f, 0.08110473f, -0.17518933f, -0.08582278f, 
    -0.73614180f, 0.09939569f, 0.03159391f, 0.24585727f, -0.12906906f, 0.01648714f, 0.12299383f, -0.06921238f, 
    -0.26192060f, 0.14006531f, 0.09117249f, -0.25134417f, -0.51854616f, -0.12573288f, 0.17794581f, 0.09573179f, 
    0.12674521f, -0.07509053f, -0.13511693f, -0.12317244f, 0.16902244f, -0.21302891f, 0.14910072f, -0.20944043f, 
    0.13687873f, 0.31156152f, 0.25850967f, 0.27611524f, 0.38912237f, 0.10903363f, 0.02302119f, 0.08857292f, 
    -0.10368477f, 0.02533970f, 0.19603501f, 0.08424806f, -0.11415200f, 0.18775785f, -0.11553212f, 0.20129146f, 
    -0.01514093f, -0.04653171f, -0.23129676f, -0.33080232f, -0.05062061f, 0.07469423f, -0.09607273f, -0.09410529f, 
    -0.04826754f, -0.02473654f, 0.26569664f, 0.16154569f, 0.22548549f, 0.14797829f, -0.21462104f, -0.13888039f, 
    -0.04489334f, 0.03006298f, -0.15413676f, 0.01056267f, 0.34148419f, -0.03244438f, 0.37880975f, -0.11399677f, 
    -0.17063157f, 0.03590962f, -0.09067453f, -0.06649470f, 0.10862526f, 0.07966000f, -0.26834944f, -0.16168791f, 
    -0.62876946f, 0.32596406f, -0.23274539f, 0.22930676f, -0.17868003f, -0.26801533f, -0.20300859f, -0.11288369f, 
    -0.08254038f, 0.18897459f, -0.03652520f, 0.12989731f, 0.12520184f, 0.36689839f, -0.08860318f, 0.40603381f, 
    0.21780998f, 0.12108178f, 0.28450206f, -0.13213454f, 0.02056371f, -0.06832367f, -0.04047554f, -0.23934372f, 
    0.10737775f, 0.69412231f, -0.18409546f, -0.22049959f, 0.08753002f, -0.24774861f, -0.40977350f, 0.01339915f, 
    0.01011314f, -0.08063573f, 0.08410749f, 0.24436525f, -0.38489431f, -0.05578179f, -0.31585005f, -0.70396245f, 
    0.10010155f, -0.09597112f, -0.08939953f, 0.32432416f, 0.14379755f, -0.11511479f, 0.18041326f, -0.22792147f, 
    0.31965628f, -0.00034519f, -0.17078625f, 0.28333041f, 0.29210138f, -0.13403538f, -0.06834021f, -0.06051258f, 
    0.05138620f, 0.09348762f, -0.17107514f, -0.00600151f, -0.08016922f, -0.13239802f, -0.40013394f, -0.45835572f, 
    -0.14921524f, -0.06973599f, 0.19635804f, -0.18852246f, 0.07678773f, 0.20358454f, -0.28089550f, 0.36120865f, 
    -0.37651470f, -0.07527374f, -0.04214584f, -0.09856953f, -0.13784371f, 0.11870731f, -0.16493964f, -0.26946756f, 
    0.16608356f, 0.11512949f, -0.11001895f, -0.12547116f, -0.39472070f, 0.17467581f, 0.11742902f, -0.21759124f, 
    -0.20983627f, -0.01399168f, 0.14670530f, -0.00553033f, -0.12251256f, -0.01888603f, -0.10366756f, -0.24145536f, 
    -0.24925010f, 0.01121872f, 0.05695276f, 0.45557284f, 0.16683935f, -0.00003282f, -0.05287277f, -0.12491520f, 
    -0.07950026f, -0.08480388f, 0.30126786f, 0.08248372f, 0.43309140f, 0.45908889f, -0.50988847f, -0.18657748f, 
    0.10859306f, 0.07347018f, 0.08543546f, -0.01332815f, 0.19460507f, 0.06271000f, 0.09713304f, 0.22924405f, 
    -0.13759746f, -0.48500952f, -0.10193226f, 0.13133927f, 0.22638187f, -0.14845330f, -0.09601809f, 0.15125866f, 
    0.19175065f, 0.08583689f, 0.29546520f, -0.36837196f, -0.31218031f, 0.32324046f, -0.63774312f, 0.00725022f, 
    0.07140571f, 0.12427267f, -0.13022062f, 0.01069861f, 0.10189426f, -0.32079369f, -0.06386280f, 0.46243176f, 
    0.09599226f, -0.30924070f, 0.30631438f, -0.03453833f, -0.19231099f, -0.22939217f, 0.04370639f, -0.18236320f, 
    -0.07987388f, -0.05250111f, -0.14238416f, -0.27367154f, -0.12145682f, 0.30041489f, 0.10586370f, 0.21994969f, 
    -0.24120624f, -0.19626251f, 0.01822060f, -0.16074519f, -0.08869427f, 0.10712685f, 0.10809992f, 0.01017448f, 
    -0.61618978f, 0.30897766f, 0.16138822f, -0.10135117f, -0.04426263f, -0.01932894f, -0.25059035f, -0.03508901f, 
    0.27007279f, 0.04694977f, -0.04920344f, -0.03494205f, -0.31775004f, 0.48226282f, -0.16342455f, -0.19428158f, 
    -0.10704257f, -0.05079469f, 0.07413106f, -0.07252875f, -0.01448891f, -0.00060537f, -0.15173061f, 0.16498159f, 
    -0.39412633f, 0.02091159f, -0.48466027f, 0.03885049f, 0.08171437f, 0.23272994f, 0.09146432f, 0.13620487f, 
    0.21417800f, -0.19388661f, -0.05085275f, 0.04281018f, -0.30578139f, -0.09622965f, 0.22009042f, 0.01084330f, 
    0.03612242f, 0.18055566f, -0.19055548f, 0.03310434f, 0.03232196f, -0.13999751f, -0.03928109f, -0.44060519f, 
    -0.48965406f, -0.06196032f, 0.51387691f, -0.29571593f, -0.10745060f, 0.11160621f, -0.00123764f, 0.23426288f, 
    0.05712568f, -0.01452942f, -0.01442164f, -0.03201455f, -0.04636272f, -0.24324155f, -0.13862519f, 0.06237404f, 
    -0.10834347f, 0.02207075f, -0.20218481f, -0.02290639f, -0.04284181f, 0.14392270f, -0.16459060f, 0.10659496f, 
    0.41524282f, -0.61893582f, 0.38934574f, -0.37692338f, 0.10261218f, 0.05274924f, -0.05781242f, -0.06941049f, 
    -0.02382398f, -0.02954996f, 0.04568028f, 0.09874666f, 0.21115690f, 0.22395004f, -0.19807146f, -0.06678256f, 
    0.07735489f, -0.23345146f, -0.06544899f, -0.07466272f, -0.08701577f, -0.13054591f, -0.00248779f, -0.35944131f, 
    0.73096269f, -0.72236842f, -0.10536744f, -0.00341725f, -0.10834394f, 0.06287546f, -0.05707838f, 0.24483433f, 
    -0.15600078f, 0.02596010f, 0.23290184f, -0.07476155f, -0.40254647f, -0.07809013f, -0.02798119f, -0.02862139f, 
    0.23076221f, 0.09359939f, -0.00710727f, -0.08074774f, -0.05545298f, -0.09943990f, 0.07968818f, 0.20680438f, 
    -0.66413212f, 0.33014876f, -0.20483749f, -0.67694235f, 0.28903401f, 0.01011033f, -0.12315098f, 0.05243854f, 
    -0.12739471f, -0.03902166f, -0.09820483f, -0.10650516f, 0.73104739f, 0.17867447f, 0.44829252f, -0.01294294f, 
    0.06062057f, -0.00347779f, 0.11238606f, -0.06994011f, -0.12049403f, 0.02262237f, -0.21590786f, -0.04161770f, 
    -0.44704914f, 0.19068928f, -0.04332860f, -0.68377274f, -0.12812008f, 0.04157473f, -0.09793948f, 0.08690109f, 
    0.01140955f, -0.08231201f, -0.18923169f, 0.01271628f, -0.20720695f, -0.01798261f, 0.31901926f, -0.06618796f, 
    0.07434009f, 0.12344063f, 0.01253216f, 0.27569595f, 0.07250055f, -0.15998183f, -0.01791904f, -0.36578897f, 
    0.27715468f, 0.00187997f, -0.06801809f, 0.13773830f, 0.37933868f, -0.05475901f, 0.00353999f, -0.04764868f, 
    0.00736775f, 0.01035156f, 0.04704494f, 0.26652738f, 0.03414801f, 0.56126380f, -0.35924199f, 0.28819558f, 
    -0.16925916f, -0.07771809f, -0.07109316f, 0.04784521f, -0.10267574f, 0.12451197f, 0.12412628f, 0.11921138f, 
    0.05729664f, -0.58038384f, -0.14378844f, -0.02963387f, -0.07498434f, 0.12974449f, 0.08688313f, -0.19030812f, 
    -0.01396308f, -0.04177728f, -0.27067596f, -0.09363715f, -0.42325738f, -0.08217781f, -0.24295598f, 0.52646720f, 
    0.15532260f, 0.12954891f, -0.00508728f, 0.04311450f, -0.06619478f, 0.29278904f, 0.26346084f, 0.00144693f, 
    -0.65608656f, 0.35523990f, 0.01817468f, -0.28988048f, 0.06000751f, 0.25813720f, -0.01941563f, -0.06426375f, 
    -0.15413234f, -0.20045768f, 0.17373145f, 0.05936296f, -0.42790362f, -0.27295324f, 0.17073697f, 0.08263362f, 
    -0.03974259f, -0.20752004f, 0.03031947f, 0.12537983f, -0.14091966f, -0.08953288f, -0.12775607f, 0.32474545f, 
    -0.21052934f, -0.24651010f, -0.15197755f, -0.03919113f, 0.07322914f, 0.12338877f, 0.18789202f, -0.01403620f, 
    0.08098797f, 0.23889264f, -0.09317935f, 0.20164602f, -0.14468287f, 0.24575944f, 0.26721099f, 0.06427304f, 
    -0.07792235f, 0.27461812f, 0.01665061f, -0.13163349f, -0.06797930f, -0.02126589f, 0.12966999f, 0.02208633f, 
    -1.25411582f, 0.05975069f, -0.51775622f, -0.13210617f, 0.09764246f, 0.08685061f, -0.31997806f, -0.18468273f, 
    0.04892154f, -0.17747360f, -0.19283596f, 0.18951228f, 0.65322608f, 0.34103745f, 0.17627306f, 0.06922562f, 
    0.09276083f, 0.08412369f, 0.09066293f, -0.04537059f, 0.11756646f, 0.42951027f, 0.02160145f, 0.29829445f, 
    -0.58560348f, 0.12760033f, -0.27807769f, -0.08475531f, 0.05902073f, 0.13241065f, -0.07404569f, 0.01899437f, 
    0.02476212f, 0.04130081f, 0.06841239f, 0.13696162f, 0.40420741f, -0.04528765f, -0.22675601f, 0.14633375f, 
    -0.23423070f, -0.15431841f, -0.16525505f, -0.03799106f, 0.06636138f, 0.16232780f, -0.25566047f, -0.18821731f, 
    -1.27248418f, -0.59307820f, -0.26556087f, -0.48646593f, 0.03524162f, 0.10208683f, -0.09510326f, -0.21010509f, 
    0.19315889f, 0.18061425f, 0.14390709f, 0.12678866f, -1.12550509f, -0.08410040f, 0.23206094f, 0.11068606f, 
    0.31327406f, 0.04390111f, 0.05149170f, -0.12797663f, 0.05425357f, 0.12475177f, -0.04253929f, 0.18295690f, 
    -0.43999350f, -0.13822892f, -0.07866458f, -0.43165818f, 0.24341670f, -0.27948788f, -0.29173490f, -0.00572048f, 
    0.01214951f, -0.29105711f, 0.22891603f, -0.28861102f, 0.24719219f, 0.29812077f, -0.30193084f, -0.05592739f, 
    0.00448703f, -0.31476599f, 0.13384551f, -0.08072014f, -0.05041056f, 0.15131147f, 0.14298071f, 0.22991525f, 
    0.46944466f, 0.20368475f, -0.24009560f, 0.07099602f, -0.54026330f, -0.33301055f, 0.11625666f, -0.17714040f, 
    0.10137442f, 0.01709425f, -0.11651453f, -0.28680572f, -0.25086319f, -0.09894193f, 0.03901311f, 0.10279715f, 
    0.19409901f, -0.19181377f, -0.01593349f, 0.30892238f, 0.07831605f, 0.03696579f, 0.13461319f, 0.14571755f, 
    0.38458893f, 0.19696042f, -0.25376788f, -0.30654851f, -0.04596074f, -0.21205857f, 0.13870390f, -0.04108437f, 
    -0.02470965f, 0.12153463f, 0.18238659f, 0.03748590f, 0.21288943f, -0.14530028f, -0.06456299f, 0.02862732f, 
    -0.09423432f, 0.04495972f, 0.04003258f, -0.00260719f, -0.17022522f, -0.21056524f, -0.31917736f, -0.19277248f, 
    0.39250720f, -0.16548407f, 0.20629776f, -0.14249027f, 0.21520591f, 0.26747715f, 0.24128832f, 0.11402385f, 
    0.19268014f, -0.05311040f, 0.05459521f, -0.09683827f, 0.18643363f, 0.08981496f, 0.10075394f, -0.13213278f, 
    -0.23630360f, -0.00247028f, -0.08641060f, -0.16003020f, 0.13901228f, 0.14495225f, -0.19867563f, -0.15036941f, 
    0.08708636f, -0.71774960f, -0.24062465f, 0.32379326f, 0.01392738f, 0.09885798f, -0.15965699f, -0.09944068f, 
    0.08247798f, 0.02839078f, -0.04704722f, -0.02511840f, -0.26150101f, 0.68861639f, 0.02196695f, 0.07050151f, 
    -0.21157503f, -0.15076640f, 0.13560170f, -0.19557910f, 0.01172956f, -0.12230082f, -0.16093910f, -0.20227863f, 
    0.60115212f, 0.00188157f, -0.42701405f, -0.20612669f, 0.03344885f, 0.12086855f, 0.04254088f, 0.16361003f, 
    0.14485866f, 0.13937181f, 0.17102790f, -0.07075863f, 0.20362541f, -0.25956148f, -0.09021131f, 0.34327853f, 
    -0.10471766f, -0.18043324f, -0.08402847f, 0.06696267f, 0.09337151f, -0.22284895f, -0.29135579f, -0.08354255f, 
    -0.39366913f, 0.08188690f, -0.07283988f, 0.04625981f, -0.28835797f, 0.30182546f, -0.00366504f, 0.04652330f, 
    -0.20364852f, 0.07094725f, 0.08026233f, 0.06056278f, 0.29021010f, -0.25518543f, 0.03236074f, 0.07319377f, 
    -0.21034233f, -0.03935476f, 0.07044683f, -0.19953975f, -0.00612338f, -0.03542288f, 0.18510096f, 0.06810168f, 
    0.28633255f, -0.22229791f, -0.36114708f, -0.21544269f, 0.13695793f, -0.11001669f, 0.02516994f, -0.12839402f, 
    -0.09827299f, 0.00454760f, -0.17843652f, 0.13594443f, 0.55771738f, -0.10408866f, -0.18382467f, -0.02054987f, 
    -0.14153406f, -0.16792153f, -0.12734014f, 0.00284668f, 0.09140269f, 0.12321297f, 0.06278854f, 0.27451730f, 
    0.26444942f, -0.22173351f, -0.21194088f, 0.37954476f, -0.01343516f, 0.05576424f, 0.18660188f, -0.11904314f, 
    0.11586601f, -0.31122157f, 0.06305315f, 0.19475575f, 0.20172268f, 0.03196520f, 0.01620386f, 0.27200893f, 
    -0.15757251f, 0.02857087f, 0.02754567f, 0.18803503f, -0.09550972f, -0.13765055f, 0.04191554f, -0.09501468f, 
    -0.65764427f, -0.27170217f, -0.08302621f, 0.02276818f, -0.19172250f, 0.14932728f, -0.02508580f, -0.07685457f, 
    0.03661678f, 0.09463509f, 0.26787549f, -0.12614354f, -0.20557186f, -0.00955468f, -0.34608197f, 0.31677252f, 
    0.12174619f, -0.24107194f, 0.07563696f, -0.00335352f, -0.16682579f, -0.04299966f, -0.02796997f, -0.10053624f, 
    0.40106171f, 0.15574145f, -0.20748594f, -0.12993473f, -0.39605552f, -0.05476021f, 0.04776713f, -0.45787719f, 
    -0.13139510f, 0.01312147f, -0.10390238f, -0.08671195f, -0.32528698f, 0.29664007f, -0.19289553f, 0.15716231f, 
    0.24933155f, -0.06081760f, 0.08283446f, 0.02276051f, -0.03495792f, 0.08965205f, 0.02799398f, 0.07751723f, 
    0.31182390f, 0.06235115f, -0.38213697f, 0.10487141f, 0.32519630f, -0.05621981f, 0.02709452f, 0.02540291f, 
    0.03826096f, 0.15882297f, 0.07941148f, -0.00605842f, -0.02343809f, 0.50786275f, -0.13757437f, -0.04538325f, 
    -0.45070845f, -0.12899433f, -0.12879536f, -0.00412843f, -0.02234376f, 0.05405730f, 0.01119338f, -0.22142442f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06105602f, -0.01809287f, -0.16545206f, -0.11553159f, 0.00915073f, 0.00376294f, -0.02423949f, -0.23843315f, 
    -0.12865354f, 0.06545641f, 0.16515508f, 0.07100829f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
