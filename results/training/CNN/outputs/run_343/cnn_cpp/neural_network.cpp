#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.57678384f, -0.73096311f, -1.36259675f, -1.18227100f, -0.64286506f, 0.96947634f, 0.53625560f, 0.03577656f, 
    0.88935250f, 0.90061939f, -0.42535663f, -0.52987802f, 0.05969389f, -0.43687591f, -0.30128944f, 0.07566512f, 
    -0.05196650f, 0.27563363f, 0.31843108f, 0.02053812f, 0.21690620f, -0.46994483f, -0.03470431f, -0.05507686f, 
    0.32622164f, -0.18419504f, 0.91788208f, 1.33692825f, 0.23583049f, 0.58919317f, -1.85358644f, -0.40517810f, 
    -0.08467185f, -0.79732376f, -0.97026998f, -0.03213885f, -0.04794888f, 0.15290193f, 0.50516540f, 0.13490732f, 
    -0.04206613f, 0.07192457f, 0.02467640f, -0.10197043f, 0.34862843f, 0.12993559f, 0.03212233f, -0.25272259f, 
    0.24824210f, -0.11101779f, 1.89239013f, 0.32030222f, -0.16841039f, 2.22706056f, 0.82177585f, -0.59746426f, 
    0.18911591f, -0.20320047f, 0.66698128f, 0.33963552f, -0.40158752f, -0.31180480f, -0.01810978f, 0.00219381f, 
    -0.30368572f, 0.04756790f, -0.18593271f, 0.05357821f, 0.16675460f, -0.02597401f, 0.16419685f, -0.15955700f, 
    -0.36593586f, -0.20545760f, 0.04713970f, -0.87880272f, -2.00680447f, -0.63013393f, 0.34446415f, 0.73166120f, 
    0.06537894f, 0.90402359f, -0.24258405f, 0.11244655f, 0.13411060f, 0.06840309f, 0.56200552f, -0.21726675f, 
    0.22197826f, -0.03727064f, 0.10020176f, 0.20243977f, -0.00668377f, 0.08153377f, -0.22572647f, 0.15977280f, 
    -0.06018345f, -0.03668967f, -0.16535911f, 0.07677247f, -1.37619710f, -1.23790014f, -0.64081287f, 0.29171863f, 
    0.13393007f, 1.11334991f, 0.32691628f, 0.33915973f, 0.74135089f, -0.52893305f, -0.09999169f, 0.29367656f, 
    -0.09698750f, 0.72399968f, 0.74660367f, 0.11990361f, 0.04899036f, -0.33560088f, -0.55329597f, 0.12596433f, 
    -0.18086617f, -0.27848950f, -0.30584288f, -0.37544122f, -0.28328955f, -0.54294258f, 1.01934564f, -1.28118217f, 
    -1.42435491f, -0.07425904f, -0.09985526f, -0.93599766f, -0.73743349f, -0.25966361f, 0.17641838f, 0.07979829f, 
    0.15708107f, -0.05775753f, 0.44794956f, 0.06860866f, -0.04552483f, 0.71542215f, -0.04421897f, 0.31692100f, 
    0.46841431f, 0.00942568f, 0.04486898f, 0.11190753f, -0.36138424f, 0.46142387f, 1.81015849f, 0.91984987f, 
    1.28549182f, -0.49465156f, 0.10326706f, -0.46910998f, -0.34310317f, -0.05708655f, 0.54317075f, 0.51719433f, 
    0.15977120f, 0.35281652f, -0.06732334f, 0.15976815f, 0.57952642f, 0.43197447f, -0.13400182f, 0.27004090f, 
    0.02293193f, 0.24269272f, -0.24785052f, 0.72959614f, 0.16531916f, -0.02768602f, 0.33935139f, 1.29095817f, 
    -0.47333211f, -0.56311488f, -0.33217061f, 0.65855217f, 1.37096763f, 0.21542363f, -1.03479242f, -0.85922962f, 
    0.32989088f, -0.12077745f, 0.82596141f, 0.00060070f, 0.10755996f, 0.21654944f, 0.03179510f, -0.07182331f, 
    -0.13529932f, 0.05433684f, -0.19803667f, -0.09955085f, -0.27901244f, -0.18670277f, -0.04316709f, 0.50500274f, 
    0.76352417f, 1.30930316f, 0.09136886f, -0.52180082f, -0.16932602f, 0.41100001f, -1.34503937f, -0.23041423f, 
    -0.73062849f, 0.12583229f, -0.31329122f, -0.61152124f, -0.19982557f, -0.34963712f, -0.80506891f, -0.31013584f, 
    -0.01380587f, -0.32003438f, 0.04381080f, -0.32997262f, 0.37162641f, 0.57316166f, 0.05199302f, -0.12002246f, 
    0.00088578f, 1.10011840f, 0.64576924f, 1.19701278f, 0.91076148f, 0.30636546f, 1.05864382f, 0.23605573f, 
    0.28515226f, 0.27313513f, 0.12261335f, -0.53490609f, -0.25581700f, -0.15937948f, 0.24106617f, 0.47929662f, 
    -0.01669719f, -0.16015707f, 0.27154645f, -0.04096006f, 0.45886019f, -0.29443884f, 0.16366197f, 0.98328543f, 
    0.24059784f, 0.49654341f, -0.10587483f, -0.60956633f, -0.38255015f, -1.03364289f, 0.52392077f, 0.11375115f, 
    -0.74357867f, -0.68752772f, -0.75212175f, -1.14571714f, -0.33480892f, -0.32096887f, 0.56552428f, 0.49964738f, 
    -0.22032465f, 0.14141312f, -0.57151604f, -0.34302789f, -0.00660943f, 0.24601528f, -0.41700077f, 0.37787226f, 
    0.49637184f, 0.28378123f, 0.22397020f, 1.22903705f, 0.39460108f, -0.77976030f, -0.48548979f, -1.35922956f, 
    -0.75940126f, -0.45884615f, 0.39188626f, 0.10460940f, -0.19385239f, -0.37727699f, -0.15088874f, -0.36291620f, 
    -0.50729102f, -0.69597691f, -0.28812021f, -0.45020136f, -0.67307192f, -0.32691789f, -0.32987526f, -0.27062249f, 
    0.27621299f, 0.11623652f, 0.02169333f, -0.41946205f, 1.02068353f, 1.72841930f, -0.81038958f, -0.00943767f, 
    -0.25215113f, 0.52174193f, 0.44903538f, -0.82622290f, 0.35040995f, -0.40475839f, 0.79508579f, 0.15280539f, 
    -0.20662093f, 0.30220792f, -0.47369844f, -0.02994707f, -0.36407903f, 0.24205662f, -0.01667434f, -0.22016707f, 
    -0.08092385f, -0.29261178f, -0.04974500f, 0.06075706f, 0.49543339f, -1.26903188f, 0.61415863f, 0.54758072f, 
    1.30982041f, 0.52139521f, 0.59857273f, 1.61337984f, 0.46741781f, -0.33202520f, -0.00369587f, -0.03593902f, 
    -0.19194414f, 0.39868984f, 0.14443138f, 0.43265337f, -0.18145652f, 0.12164473f, 0.10424531f, 0.24192779f, 
    0.05173364f, 0.29826772f, 0.36490041f, 0.05361061f, 0.34818268f, -0.28379062f, -1.46793282f, 1.01660275f, 
    0.49245539f, -0.69437706f, 1.05486691f, 0.09420920f, 0.59843409f, 1.18018246f, -0.17287301f, 0.03498685f, 
    -0.59044546f, -0.29005939f, 0.12010670f, 0.01091467f, -0.32808071f, 0.03414276f, 0.00850049f, 0.08526216f, 
    0.22040330f, 0.29621825f, 0.04194845f, -0.10789324f, -0.06993082f, -0.17908016f, 0.28786498f, -1.45481706f, 
    0.48422161f, 0.71407783f, -0.70288581f, 0.95785618f, 0.55792284f, -0.52074879f, -0.98819691f, -0.65948254f, 
    -0.83366090f, -0.07066227f, -0.19184425f, 0.51024514f, 0.16417462f, -0.43615353f, 0.09220666f, -0.05872256f, 
    -0.42506638f, 0.24385528f, 0.60937434f, 0.10505202f, -0.03636665f, -0.14551742f, -0.28380913f, 0.16711617f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13797988f, 0.35695079f, 0.43430337f, 0.48193517f, 0.16781907f, 0.53733736f, 0.15557215f, 0.28010437f, 
    0.21624349f, 0.41738299f, 0.47730899f, -0.05334040f, 0.37848729f, 0.26606655f, 0.17761657f, 0.27485892f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.75612962f, 0.07047060f, -0.15157649f, -0.78239602f, 0.33781451f, -0.00216267f, 0.04872523f, 0.11734021f, 
    0.00624860f, -0.01749783f, -0.04951094f, 0.26673126f, -0.19542004f, 0.43750742f, -0.03365652f, 0.13515861f, 
    -0.16369049f, -0.18114549f, -0.08033511f, -0.18178412f, -0.16454287f, -0.12546822f, -0.00570613f, -0.22452986f, 
    0.38155070f, -0.09518485f, -0.18496753f, 0.95989591f, -0.23265058f, 0.06374749f, -0.13359714f, 0.04849755f, 
    -0.00740177f, -0.06059390f, -0.00118774f, -0.04489526f, -0.81393969f, -0.04629494f, 0.05712124f, 0.25604916f, 
    -0.03862511f, -0.06955478f, 0.13156514f, -0.03513996f, -0.00351020f, -0.00221126f, -0.18065572f, -0.07835470f, 
    -0.21533878f, -0.14001808f, 0.12683290f, -0.13608398f, 0.21595474f, 0.04591052f, 0.00214291f, 0.19042106f, 
    0.19549535f, -0.17965490f, 0.12230857f, -0.14245120f, -0.00808439f, -0.16356501f, 0.19718491f, -0.24128653f, 
    0.17594637f, 0.09164049f, 0.12997936f, -0.09525923f, 0.19099654f, 0.05731577f, 0.03667370f, -0.01898867f, 
    0.44069061f, 0.10534714f, -0.19049892f, -0.68548059f, -0.11755357f, -0.11778955f, -0.34545624f, 0.12911421f, 
    0.13347119f, 0.04098878f, 0.09389571f, 0.04928900f, 0.23116410f, -0.32147723f, 0.45297486f, -0.21203433f, 
    -0.26273963f, -0.12730379f, -0.03537204f, 0.12192883f, 0.04337642f, 0.23018739f, 0.09501438f, -0.01086177f, 
    0.07924787f, 0.07413664f, 0.36447820f, -0.49118903f, -0.10099485f, -0.21861753f, 0.05483563f, -0.04647216f, 
    -0.13685589f, -0.07933522f, -0.08171310f, 0.01663082f, 0.24122305f, -0.22889340f, -0.24931504f, 0.34766957f, 
    -0.14047571f, -0.03081969f, -0.13918893f, 0.14483353f, -0.12517568f, -0.07013083f, 0.05673202f, 0.07037575f, 
    -0.46192443f, -0.34750575f, 0.40658957f, -0.39691269f, 0.01671858f, 0.06059129f, 0.08715609f, 0.04591690f, 
    0.01539385f, -0.13563196f, -0.23635119f, -0.37292913f, -0.38146123f, -0.15698448f, 0.11611970f, 0.03632985f, 
    -0.03966568f, -0.02359666f, -0.25065449f, -0.11110544f, 0.03304612f, 0.04595907f, 0.18023795f, 0.06021783f, 
    -0.13891800f, 0.20075563f, 0.25125030f, -0.29035500f, -0.21417196f, 0.07262824f, 0.04210336f, 0.14996192f, 
    -0.01701262f, 0.07696562f, 0.03977396f, 0.02933327f, -0.16749673f, 0.34467167f, 0.19259499f, 0.14569825f, 
    -0.31769431f, -0.03590603f, 0.03040566f, -0.09905151f, 0.04922427f, -0.17220099f, -0.09500741f, 0.01091593f, 
    -0.33118132f, 0.09334134f, 0.44852224f, -0.09376609f, 0.12248968f, 0.06828780f, 0.05187440f, 0.09863350f, 
    0.07254092f, -0.15933992f, -0.20650539f, 0.02339772f, -0.78229904f, -0.31160873f, 0.32634413f, -0.19250768f, 
    0.08560613f, -0.03348046f, 0.03109716f, -0.08936494f, -0.00640401f, -0.12403811f, 0.01468839f, 0.00877160f, 
    -0.25007805f, -0.24567521f, 0.15842681f, -0.32616180f, 0.10936967f, -0.12851101f, -0.00031362f, 0.19292732f, 
    0.15420002f, 0.09360065f, -0.08356675f, 0.05014595f, -0.31612748f, 0.07450145f, -0.18897219f, -0.03526795f, 
    0.08520624f, -0.04118722f, -0.20052983f, -0.01268131f, 0.06429489f, 0.05806743f, -0.00013546f, 0.08534629f, 
    0.39798874f, -0.33886743f, 0.10920204f, 0.38404167f, -0.09403154f, -0.03096699f, -0.21430527f, 0.13837026f, 
    0.12494643f, -0.05179798f, -0.21668589f, -0.08364487f, 0.74192244f, -0.17448698f, -0.26228264f, -0.09851336f, 
    -0.06399902f, 0.16691527f, -0.06282117f, 0.04023835f, -0.14791179f, -0.26251388f, -0.07066731f, 0.25875446f, 
    0.21041340f, 0.30309752f, -0.18883191f, 0.18333720f, -0.04566047f, 0.21115354f, -0.05486339f, -0.14237708f, 
    -0.23266585f, 0.21449524f, -0.08998837f, 0.01740976f, -0.46458393f, -0.04652602f, 0.04890588f, -0.63734990f, 
    -0.10909387f, 0.00742230f, 0.15160564f, 0.18365572f, 0.20379697f, 0.24656537f, 0.15891591f, -0.09413405f, 
    0.27465391f, -0.03794348f, -0.04158385f, 0.24774799f, 0.23798209f, -0.18070741f, 0.18577331f, -0.03563272f, 
    0.01768265f, 0.01652044f, -0.16576333f, 0.01755274f, 0.42292383f, -0.23369302f, 0.05745919f, -0.39574894f, 
    -0.05362242f, 0.01044904f, -0.07376120f, -0.15989859f, -0.02908610f, -0.24946615f, -0.19919027f, 0.03939723f, 
    0.00039582f, 0.06541061f, 0.01881729f, -0.07365238f, 0.03978186f, 0.01452781f, 0.16364494f, 0.16508622f, 
    0.05706968f, -0.06397756f, 0.07942460f, -0.09101674f, 0.34331337f, 0.08597063f, 0.34158865f, 0.26452258f, 
    -0.37522462f, -0.20735855f, 0.10097044f, 0.00420565f, -0.10043626f, 0.00853437f, 0.11294762f, 0.02842316f, 
    -0.15051287f, -0.26367941f, 0.06702726f, -0.34159279f, -0.13479228f, -0.06725462f, 0.27913982f, -0.15931483f, 
    -0.12359717f, 0.18045682f, -0.13186662f, 0.14509226f, 0.41350633f, -0.42829874f, -0.06300332f, -0.28144380f, 
    -0.12376903f, -0.13051282f, 0.03479370f, 0.18415898f, -0.09444146f, -0.19097993f, -0.39723352f, -0.26715326f, 
    0.15240881f, -0.22033405f, 0.07939739f, -0.05875114f, -0.24541728f, -0.03859856f, -0.12777367f, 0.06093890f, 
    -0.10927261f, -0.05186971f, -0.14778389f, 0.03412350f, 0.03508214f, 0.30975434f, -0.06874923f, 0.26558438f, 
    0.03608285f, 0.19752540f, -0.05762493f, -0.02961886f, -0.04782581f, 0.16689181f, 0.10511889f, -0.08754917f, 
    -0.24732733f, 0.02797167f, -0.50876355f, -0.61861730f, 0.15123993f, 0.12951916f, -0.07056276f, 0.02436874f, 
    0.16049010f, 0.15630491f, 0.12206738f, -0.01465635f, 0.21207273f, -0.32727462f, -0.19727260f, -0.01837257f, 
    -0.10067117f, 0.12044356f, -0.14075696f, -0.22731926f, 0.02327464f, 0.25604686f, -0.05521904f, 0.04822789f, 
    0.20095761f, 0.21327288f, 0.40734223f, 0.76329970f, -0.21242754f, -0.26097891f, 0.16541165f, 0.11374640f, 
    -0.01836473f, -0.02920100f, -0.01422374f, -0.00729564f, 0.26521912f, 0.26649702f, -0.86193711f, -0.04045507f, 
    0.16501561f, 0.16203830f, -0.13248025f, -0.21281219f, -0.01312338f, -0.11240967f, -0.15652101f, -0.08505114f, 
    0.03527254f, 0.05176647f, -0.29069269f, -0.18062416f, 0.27841219f, 0.09347696f, 0.00357148f, -0.05571993f, 
    -0.17120990f, 0.26570702f, 0.02221226f, -0.16840717f, 0.67983741f, -0.58048970f, 0.17206261f, 0.07469866f, 
    -0.47311822f, -0.11075339f, 0.05098304f, 0.07749819f, -0.08036221f, 0.02966523f, -0.03802307f, -0.11284679f, 
    0.59955877f, 0.02320230f, 0.15688583f, 0.04393813f, -0.12598720f, 0.00105771f, -0.09493817f, 0.17371403f, 
    -0.12014468f, -0.13868274f, -0.20739301f, -0.03389087f, -0.76155514f, -0.26625380f, -0.35398659f, -0.35813451f, 
    0.01197126f, -0.12617858f, 0.19989137f, -0.14031211f, -0.08624049f, -0.08489005f, -0.14396672f, -0.06655116f, 
    -0.51037163f, 0.25949982f, 0.07100916f, -0.23870079f, 0.03061684f, 0.12671323f, 0.22619165f, 0.10375621f, 
    -0.06827767f, -0.08584608f, 0.11379884f, -0.03058761f, -0.47900027f, -0.44100812f, 0.01578738f, -0.55496854f, 
    0.26745939f, -0.05745797f, 0.08623935f, 0.15396686f, -0.15542504f, 0.06765289f, -0.07176150f, -0.04549228f, 
    -0.24523966f, -0.33353654f, -0.15925136f, -0.32701942f, 0.29821527f, -0.17826781f, 0.10230665f, -0.37463230f, 
    0.15104252f, 0.13760020f, 0.03006150f, 0.16865902f, -0.22314204f, -0.20213738f, 0.03257959f, -0.16047953f, 
    0.26934323f, 0.10109968f, -0.13416049f, 0.20904200f, -0.10595959f, 0.07829132f, -0.08474180f, -0.00556233f, 
    -0.48292077f, -0.21823606f, -0.39156494f, -0.79256558f, 0.13750334f, -0.02041832f, -0.31882730f, -0.10748508f, 
    -0.15405166f, 0.24636802f, -0.11826268f, -0.12012998f, -0.26631629f, -0.08446340f, -0.15153414f, 0.02186425f, 
    0.02880956f, -0.18902211f, 0.24967633f, 0.17482083f, -0.08710978f, 0.08553254f, 0.14035924f, 0.09448480f, 
    0.71389645f, -0.42675397f, -0.03068656f, -0.11594484f, 0.05236281f, -0.07637803f, 0.22675364f, -0.11813935f, 
    -0.16840518f, 0.17296472f, 0.05488557f, 0.00916331f, 0.18560681f, -0.10564182f, 0.05856694f, -0.14810313f, 
    0.03359783f, -0.13059244f, -0.16342790f, 0.04083330f, 0.22266485f, -0.17168376f, -0.03346693f, -0.01957740f, 
    0.78382707f, -0.00026348f, -0.23083296f, 0.29014325f, -0.28767127f, -0.09371410f, -0.00547559f, 0.09071823f, 
    -0.03347795f, 0.00785109f, -0.08887380f, 0.24603079f, 0.58205205f, 0.08160993f, 0.01967358f, -0.03816932f, 
    0.18856189f, -0.02459377f, 0.13288353f, -0.10712873f, 0.08596870f, 0.05663053f, -0.04424746f, -0.26577735f, 
    -0.17463154f, 0.00279846f, -0.13557792f, -0.38421097f, -0.19395731f, -0.20739718f, -0.04656996f, -0.07897276f, 
    -0.26137984f, -0.11320872f, 0.07505872f, -0.04620311f, -0.53217191f, 0.36739284f, 0.21931387f, 0.32564911f, 
    0.07526262f, 0.12082229f, 0.23274332f, 0.07523240f, -0.03895729f, 0.05296258f, -0.07433574f, -0.05568559f, 
    0.31020242f, -0.59330720f, -0.39728796f, -0.10037680f, -0.07619676f, -0.26436779f, 0.24144380f, -0.21935561f, 
    0.18023026f, 0.04987853f, 0.11574828f, 0.10657452f, 0.04679498f, 0.11744863f, -0.01094550f, 0.14710484f, 
    -0.28422546f, -0.22695659f, 0.02831213f, -0.10124191f, -0.24829583f, -0.01342765f, 0.02973747f, -0.05814191f, 
    0.08609653f, 0.01596220f, -0.29987222f, 0.01585179f, 0.00063891f, 0.11142268f, 0.09254382f, -0.27913791f, 
    0.02611507f, -0.12716424f, 0.20282607f, -0.07678061f, 0.47688794f, 0.40656069f, 0.02012224f, -0.02824023f, 
    -0.11596651f, 0.00026688f, -0.00636814f, -0.11020428f, 0.05493888f, -0.03364079f, -0.15195616f, -0.01226372f, 
    -0.74537951f, -0.76330662f, -0.64258480f, 0.14154781f, -0.07787980f, 0.02816195f, 0.20950015f, -0.02453148f, 
    0.01693308f, 0.01518754f, -0.00259339f, -0.21878079f, -0.30551058f, 0.03026152f, 0.12264558f, 0.52323711f, 
    0.17175198f, 0.18048428f, 0.23250817f, 0.08369046f, -0.06616447f, -0.14385238f, -0.16796853f, 0.09360330f, 
    0.18201648f, -0.13750240f, -0.29786643f, 0.20311502f, -0.17422625f, 0.10562488f, -0.27470595f, 0.01467869f, 
    0.01760210f, 0.01050575f, -0.23924622f, 0.13319549f, -1.00155425f, -0.27326766f, -0.64063263f, -0.16545267f, 
    -0.09698905f, -0.09080233f, -0.15546481f, -0.08178288f, 0.10443242f, -0.20971185f, -0.05640671f, -0.06320973f, 
    0.23837312f, 0.11662740f, 0.16236557f, 0.19889432f, 0.04159076f, 0.03010431f, -0.15968098f, 0.04308263f, 
    0.21196769f, -0.01776999f, -0.03511443f, -0.18965901f, 0.25089189f, -0.39992586f, -0.03901980f, 0.10440733f, 
    -0.31219235f, 0.18390685f, 0.03165525f, 0.30928984f, 0.10984109f, 0.32078886f, -0.06888644f, 0.06224978f, 
    0.57061315f, 0.42324033f, -0.25124422f, -0.19807170f, -0.05294836f, -0.06840488f, 0.16985199f, 0.08892822f, 
    -0.13878570f, -0.00390731f, 0.13012387f, -0.12693037f, -0.83333778f, 0.11520591f, 0.24260433f, 0.00141618f, 
    -0.05464271f, -0.08203627f, -0.04146026f, 0.13403049f, 0.09458809f, -0.07036767f, -0.08290706f, 0.08175377f, 
    -0.50000966f, 0.13245349f, 0.24253526f, -0.07487888f, 0.07313474f, -0.24124673f, -0.04047296f, 0.14676036f, 
    0.12998815f, -0.19448811f, 0.00831786f, -0.00968435f, 0.74802303f, -0.00458879f, 0.26769212f, 0.29727080f, 
    0.35709503f, -0.04194047f, 0.07457005f, 0.11478636f, 0.12691388f, -0.12672053f, -0.20911500f, -0.10737526f, 
    -0.72071844f, -0.15501612f, 0.20989928f, 0.62590355f, 0.05983480f, -0.17526077f, 0.10196124f, -0.05468035f, 
    -0.30203003f, 0.15190254f, 0.20657121f, -0.06048130f, -0.43263897f, -0.21471184f, 0.36675209f, 0.16640680f, 
    -0.05361442f, -0.04733399f, 0.10876199f, -0.22081095f, 0.02304026f, -0.01530560f, -0.08400934f, -0.17693897f, 
    0.43212342f, 0.35016969f, -0.08114514f, -0.00993925f, -0.15704797f, 0.23985484f, 0.23393798f, 0.06786373f, 
    0.11760078f, -0.04106388f, 0.10897462f, 0.01897057f, -0.72454804f, 0.46369189f, 0.04806048f, -0.03529133f, 
    0.09613241f, -0.07885135f, -0.06292179f, -0.07344864f, 0.19443929f, 0.16238107f, 0.01854767f, -0.14638332f, 
    -0.41505542f, 0.17531820f, -0.26715145f, -0.29400969f, 0.13293572f, -0.04920044f, 0.04417958f, 0.16288629f, 
    0.14305706f, -0.24645497f, -0.13711874f, 0.02864423f, 0.40507317f, -0.06303021f, 0.06669679f, 0.17111829f, 
    -0.20222026f, 0.04040086f, 0.20481503f, 0.03448917f, 0.08971620f, -0.10047480f, 0.00084744f, 0.10061634f, 
    -0.49669924f, -0.52978718f, 0.00252853f, -0.00373923f, -0.35057697f, -0.09583685f, -0.10674366f, -0.13063538f, 
    0.14682187f, 0.15453160f, -0.06843959f, -0.09613300f, -0.28632981f, 0.21524733f, 0.07545711f, 0.07863425f, 
    0.19585638f, 0.04887791f, 0.09723418f, -0.19287868f, -0.02631201f, -0.03723523f, 0.06899355f, 0.04604646f, 
    0.01362924f, -0.06165033f, -0.04726870f, 0.38112792f, -0.20817651f, -0.06582147f, 0.00780880f, -0.03571727f, 
    -0.24856584f, -0.03200294f, -0.07719503f, -0.09363647f, -0.08240872f, 0.42125967f, 0.00917472f, -0.16411990f, 
    0.21846360f, -0.24392474f, -0.20110558f, 0.06391560f, 0.03936772f, -0.13027240f, 0.08723377f, 0.01988755f, 
    -0.13346490f, 0.07872889f, 0.25393000f, 0.08991243f, 0.06369086f, -0.08714290f, -0.01303153f, 0.20537840f, 
    -0.09586122f, -0.28177208f, 0.13440405f, 0.13662110f, -0.03932813f, -0.17276603f, -0.01137061f, -0.06557506f, 
    0.02493051f, 0.22413382f, 0.09553115f, -0.02858578f, -0.09711283f, 0.34128800f, 0.03711857f, 0.03505369f, 
    -0.16850151f, -0.01650161f, -0.04633390f, -0.37426275f, -0.04882494f, 0.09319542f, 0.11114504f, 0.01649071f, 
    -0.00111469f, 0.01136028f, -0.03044202f, -0.19652700f, -0.53460360f, -0.00779334f, 0.01585899f, -0.02482999f, 
    0.10576970f, -0.00699738f, 0.29091436f, 0.14192629f, -0.10384340f, 0.01183312f, -0.07104129f, -0.19452178f, 
    0.27047819f, 0.25147450f, -0.52539665f, -0.14210647f, -0.18580858f, -0.02341991f, 0.19112881f, -0.16868228f, 
    -0.09887490f, -0.25280672f, 0.08090095f, 0.18192837f, -0.37099314f, 0.46154663f, -0.16064812f, -0.27785289f, 
    -0.13572133f, -0.12710346f, -0.14214239f, 0.26975423f, 0.02503279f, -0.03853548f, 0.04788578f, 0.07617578f, 
    -0.07817588f, -0.24350303f, -0.46529040f, -0.25532335f, 0.16458914f, 0.44964916f, -0.16597199f, -0.22529784f, 
    0.13629369f, -0.08090679f, -0.02662845f, -0.14533079f, 0.42691711f, -0.13393565f, 0.02736998f, 0.34397799f, 
    -0.27042037f, -0.09584884f, 0.15256044f, 0.23188649f, -0.22729826f, 0.06204065f, 0.18202068f, 0.40763611f, 
    -0.10915559f, -0.11869967f, 0.23700590f, -0.41314742f, 0.05515322f, -0.25266796f, 0.11531176f, -0.10888738f, 
    -0.00732116f, -0.05834691f, 0.01724729f, 0.03115715f, -0.62651819f, 0.03599685f, -0.62763757f, -0.40179572f, 
    0.21676996f, 0.10708293f, -0.16847636f, -0.07896547f, -0.08419309f, 0.03001324f, 0.05981450f, -0.08154541f, 
    -1.29715788f, -0.38184503f, -0.03589539f, -0.26746562f, -0.16523583f, -0.04862336f, 0.02000064f, -0.17952719f, 
    0.04799408f, 0.34584624f, -0.17156360f, 0.06630399f, -0.42868894f, -0.33501098f, 0.24494062f, 0.07482783f, 
    -0.03763657f, -0.14607780f, -0.16417424f, -0.22068876f, -0.16914634f, 0.08125322f, 0.07675202f, 0.17753991f, 
    0.17050470f, 0.28720462f, 0.13598356f, 0.10232315f, -0.12532009f, -0.09902549f, 0.02729596f, -0.03045950f, 
    -0.14168131f, -0.13622394f, 0.10319838f, 0.13527308f, 0.08421301f, -0.12381838f, 0.24935909f, 0.13272130f, 
    -0.09814432f, 0.14173429f, -0.08205283f, 0.02388203f, 0.07166690f, -0.05389310f, -0.03692267f, 0.10693666f, 
    -0.23310943f, -0.12893716f, 0.31523278f, 0.24824299f, 0.22489442f, -0.09770002f, 0.10826863f, 0.27129877f, 
    0.37032482f, -0.06956967f, -0.10328506f, -0.39906424f, 0.22265719f, 0.09312805f, 0.03258565f, 0.26292202f, 
    -0.02641657f, 0.21628879f, 0.29245064f, -0.17348178f, 0.04810150f, 0.18071590f, 0.11724325f, -0.04775980f, 
    0.13677885f, -0.01773349f, 0.07385291f, 0.24566908f, -0.16107064f, 0.15151109f, -0.05213825f, 0.17153901f, 
    -0.02526464f, 0.03577669f, 0.34987813f, 0.09003270f, 0.23850210f, 0.28273347f, -0.12263687f, -0.04187747f, 
    0.03938804f, 0.06383580f, 0.24200863f, -0.06393304f, -0.07202285f, -0.36108652f, -0.21602480f, -0.40961316f, 
    0.01185934f, 0.03431086f, -0.10778496f, 0.28759611f, -0.09468777f, 0.16342963f, -0.02958327f, -0.10008082f, 
    -0.01681699f, -0.28316459f, -0.19272144f, -0.06756756f, -0.71824980f, 0.22784606f, 0.31539643f, -0.26117927f, 
    0.07034870f, 0.03677448f, 0.04953226f, 0.01916997f, 0.12715966f, 0.05870895f, -0.05447074f, -0.01850965f, 
    0.10125683f, 0.04936184f, 0.39273348f, 0.04622179f, 0.03775884f, -0.09404957f, -0.12842834f, -0.33336365f, 
    0.07954386f, 0.09412100f, 0.06521942f, -0.19415200f, -0.24870199f, -0.38375732f, -0.10931178f, 0.22718474f, 
    0.15348610f, 0.04601891f, 0.06748910f, -0.03181981f, -0.24822129f, 0.29040954f, 0.04521693f, 0.21270041f, 
    -0.17062731f, -0.20563465f, -0.53133672f, -0.31706002f, -0.34969527f, -0.08847160f, 0.02243461f, -0.08397801f, 
    -0.12170863f, 0.06257340f, -0.07628098f, 0.21454060f, 0.14998119f, 0.20471054f, 0.11429787f, -0.55567908f, 
    0.18649341f, 0.08988447f, 0.10516497f, 0.10710210f, 0.08950353f, -0.06795817f, 0.01497921f, -0.05029802f, 
    -0.01026721f, 0.44858941f, 0.16390295f, -0.67495245f, -0.23232292f, 0.13376325f, -0.06093312f, 0.07023256f, 
    -0.22623323f, 0.14288211f, 0.08445942f, -0.02323226f, 0.52174067f, -0.24955083f, 0.17396799f, -0.10878083f, 
    0.07685666f, -0.09031969f, 0.15429829f, 0.26237139f, 0.15278517f, -0.05999679f, 0.04842611f, 0.14805621f, 
    -0.09706592f, -0.51421887f, 0.19406675f, -0.12446199f, -0.05646276f, -0.10510668f, -0.05993033f, -0.12266763f, 
    0.03480877f, 0.03957098f, 0.05966200f, 0.09543308f, -0.07018419f, -0.08638848f, -0.10115095f, 0.28640392f, 
    0.03721588f, 0.16780879f, 0.07110011f, 0.09549233f, -0.10069835f, -0.19309765f, -0.02628276f, -0.19154711f, 
    -0.75211674f, 0.39907750f, 0.26410469f, 0.49672624f, -0.06556727f, 0.04734593f, -0.13456987f, 0.22569959f, 
    0.10669115f, 0.16620426f, -0.09811240f, -0.24884704f, 0.18683949f, -0.29634580f, -0.42460766f, -0.19155437f, 
    -0.07917462f, -0.08087408f, 0.03709388f, 0.07792524f, -0.01501045f, -0.15621589f, 0.00249804f, -0.02611727f, 
    -0.17190783f, 0.17255023f, -0.47084227f, 0.04213393f, -0.25880170f, 0.39345524f, 0.03104645f, -0.05227817f, 
    -0.35082766f, 0.00217922f, 0.20984355f, 0.18200530f, -0.16430470f, 0.21876472f, 0.22333555f, -0.09020939f, 
    -0.24108788f, 0.02693767f, -0.01328148f, 0.17720585f, -0.06307758f, 0.03711308f, -0.19515721f, -0.19319597f, 
    0.22921403f, 0.11699106f, -0.39848155f, -0.25159696f, 0.00286596f, -0.24110050f, -0.08288670f, -0.21689844f, 
    0.15991262f, -0.04841797f, -0.08442273f, -0.17303170f, -0.47087222f, 0.01032339f, -0.03839360f, 0.38147557f, 
    0.20726019f, 0.06351722f, -0.21874660f, -0.06670986f, 0.03407266f, 0.01383876f, 0.11591110f, 0.31770912f, 
    -0.19809002f, 0.15124924f, -0.15149245f, 0.49388400f, 0.30492404f, -0.19625485f, -0.13287857f, 0.26329547f, 
    0.25509724f, 0.31740895f, -0.02186531f, -0.06494106f, 0.78448093f, -0.65705419f, -0.07075817f, 0.06021055f, 
    0.09908152f, -0.14080194f, -0.06328331f, 0.12140772f, -0.02531390f, 0.06828373f, -0.03446452f, -0.14800887f, 
    -0.24276870f, -0.45894977f, -0.28550705f, 0.24577422f, 0.04542781f, 0.01099014f, 0.05917400f, -0.05116148f, 
    -0.02323842f, 0.05486215f, -0.32059520f, 0.12911928f, 0.31703293f, -0.12282328f, 0.03667093f, -0.14461631f, 
    -0.06266608f, 0.07269421f, 0.03768355f, 0.06802984f, 0.14718899f, -0.18384090f, -0.09404387f, 0.06791344f, 
    0.41572413f, 0.59232908f, 0.15664165f, 0.48039383f, 0.05927756f, 0.27638820f, 0.05374643f, -0.16172269f, 
    0.05858649f, 0.13276707f, 0.07989191f, -0.18783303f, 0.14469440f, -1.16141427f, 0.19380777f, 0.07070547f, 
    -0.07388289f, -0.20037606f, -0.04168751f, -0.06918620f, 0.00453228f, 0.10679653f, -0.00714200f, -0.14342807f, 
    -0.28403646f, 0.51689464f, -0.13869032f, -0.45243526f, -0.02483712f, 0.10143390f, 0.01246072f, -0.12525058f, 
    -0.34403306f, -0.23291178f, -0.09562331f, -0.22278911f, 0.05551387f, -0.03427934f, 0.53362554f, -0.26236024f, 
    -0.01321318f, 0.15417516f, -0.07381285f, 0.00630230f, -0.20099646f, 0.15618496f, -0.22370569f, -0.08250953f, 
    -0.14902747f, 0.17940903f, 0.16545674f, -0.05924104f, -0.05508363f, -0.08991285f, -0.01353333f, -0.03505043f, 
    -0.01117348f, -0.12340160f, -0.04767808f, 0.02333154f, 0.17274663f, 0.38563183f, 0.12367564f, 0.39016622f, 
    0.25789049f, -0.24142724f, -0.25431487f, 0.06045881f, 0.13814324f, -0.10406448f, -0.18749110f, -0.30534703f, 
    -0.44053715f, -0.21554117f, -0.64473242f, -0.14200330f, 0.05971933f, 0.04668744f, -0.02390394f, -0.06705775f, 
    -0.19580083f, 0.08525573f, 0.11212749f, -0.15142807f, -0.56494761f, 0.00273836f, -0.47060367f, 0.07199484f, 
    -0.11596195f, -0.03316779f, -0.04039109f, -0.11716565f, -0.00946873f, 0.06105211f, -0.34478971f, -0.26568261f, 
    0.20042841f, 0.06495178f, -0.23107207f, 0.06348691f, -0.06214529f, -0.27701822f, -0.15478298f, 0.03480782f, 
    -0.16402046f, 0.13290161f, 0.11020590f, 0.18490683f, 0.00245016f, -0.08998026f, -0.16472042f, -0.34343103f, 
    -0.08578208f, 0.01819352f, 0.00238256f, -0.11227671f, -0.03729777f, -0.04586694f, -0.15001185f, 0.25465378f, 
    0.12513751f, 0.27497110f, 0.14683276f, 0.57130009f, -0.03591456f, 0.09107586f, -0.05851562f, 0.02858485f, 
    -0.10109218f, -0.18708545f, -0.02729943f, -0.14579648f, 0.17113876f, 0.28607950f, -0.20500343f, 0.40834367f, 
    -0.00036770f, 0.15380374f, -0.15297532f, 0.03969269f, -0.13330407f, 0.13794224f, 0.12261917f, -0.32246935f, 
    -1.16829658f, 0.11926407f, -0.09670753f, -0.25592321f, -0.00053796f, -0.11540380f, 0.13142276f, -0.02868523f, 
    0.08342277f, -0.02321342f, -0.01247649f, -0.06073890f, 0.15468618f, -0.18575403f, 0.07355924f, -0.32706442f, 
    0.10030089f, -0.03492627f, 0.02129339f, -0.11215879f, 0.02461674f, 0.05856900f, 0.10789553f, -0.05584108f, 
    0.07962871f, -0.18335027f, 0.23884872f, 0.15782589f, 0.10774160f, -0.08267802f, 0.01951513f, -0.21135612f, 
    -0.09121427f, -0.14694101f, -0.11095838f, 0.00215319f, -0.00007336f, 0.35874468f, 0.01952686f, 0.44175643f, 
    -0.06290794f, -0.09401808f, -0.03806642f, 0.09727243f, -0.09099726f, -0.02553901f, -0.03723057f, -0.08893563f, 
    -0.40833354f, 0.17926824f, 0.18872479f, 0.14957236f, -0.29290462f, 0.24461041f, -0.26252496f, 0.01838937f, 
    -0.07611728f, -0.06120279f, -0.01712814f, -0.27920577f, -0.14893882f, -0.69864839f, -0.17542513f, 0.02318365f, 
    0.13725893f, 0.05273688f, -0.08894960f, -0.01119563f, 0.29885814f, 0.14364463f, 0.05038262f, 0.28686911f, 
    0.17289799f, -0.29444057f, 0.18985786f, 0.34607425f, 0.27525747f, -0.20250988f, -0.11641271f, -0.08294906f, 
    0.04696162f, -0.01397836f, 0.12058570f, -0.18499060f, -0.54571843f, -0.17336282f, 0.24021223f, 0.13483390f, 
    -0.11052046f, 0.07360598f, -0.12568222f, -0.12469293f, 0.02283610f, -0.22262739f, 0.05974339f, 0.08597371f, 
    -0.04879906f, -0.20606366f, 0.38209996f, -0.02292260f, 0.00557323f, -0.14581622f, 0.03518331f, -0.10260153f, 
    -0.23553626f, 0.04316322f, 0.05497377f, -0.14822783f, -0.21947359f, 0.44968259f, -0.36442029f, -0.42313299f, 
    0.11263744f, 0.15222433f, -0.58269000f, 0.10382782f, -0.01759128f, 0.07476268f, 0.15986994f, 0.11019397f, 
    0.27834320f, 0.12596273f, -0.42164940f, -0.11176787f, 0.16197810f, 0.14024830f, -0.09746254f, -0.06466585f, 
    0.03314153f, -0.04105835f, 0.06232917f, 0.30404854f, 0.07962478f, 0.29696074f, -0.29894629f, -0.10318390f, 
    -0.24601161f, 0.06500377f, 0.07412645f, -0.27798298f, 0.04964266f, 0.00272859f, 0.12706870f, 0.18064062f, 
    -0.33817935f, 0.13228649f, -0.27998659f, -0.17400299f, -0.03636664f, -0.02565936f, -0.27991202f, 0.17949684f, 
    0.21695365f, 0.07128228f, 0.04851215f, -0.45468533f, 0.33222705f, 0.12791175f, 0.04476588f, 0.24541743f, 
    0.11399503f, 0.15118480f, -0.07215341f, -0.21173394f, -0.04728865f, 0.15789795f, -0.11162721f, -0.12231272f, 
    -0.57500982f, 0.16405044f, -0.31938496f, -0.70154023f, 0.10082737f, 0.31816217f, 0.02490596f, -0.25268137f, 
    0.14004701f, -0.04486238f, 0.16073076f, -0.18065672f, -0.06578866f, -0.14432633f, -0.11375040f, -0.39694434f, 
    -0.06232979f, -0.22169179f, 0.12744986f, 0.13146304f, 0.23088661f, -0.22171898f, -0.24565981f, -0.08045384f, 
    0.21169230f, 0.10822801f, -0.50807840f, 0.13615921f, 0.18300565f, 0.09779908f, -0.11067776f, -0.09815707f, 
    -0.10226101f, -0.11923208f, 0.25109500f, 0.22546667f, 0.14535743f, -0.02930634f, 0.02972506f, 0.23174514f, 
    0.07916471f, -0.14346091f, -0.02172888f, -0.06992130f, -0.03694506f, -0.15607861f, -0.02458330f, 0.11746806f, 
    0.38120735f, 0.08547033f, 0.25196767f, 0.18457437f, -0.20936874f, -0.09583970f, -0.33333951f, -0.31891689f, 
    -0.08336596f, 0.01111120f, 0.26622227f, -0.16002007f, -0.01728134f, -0.27908757f, -0.12744543f, -0.38072795f, 
    0.08628288f, -0.15125398f, -0.32078019f, -0.24751717f, 0.09531344f, 0.09121270f, 0.03067453f, -0.31109226f, 
    -0.40775114f, -0.37057391f, 0.10331817f, -0.16279969f, 0.27113828f, -0.01146810f, 0.15209065f, 0.18135914f, 
    0.19441676f, -0.08710170f, -0.02104189f, 0.25424683f, 0.26682493f, -0.43485239f, -0.12022918f, -0.49132392f, 
    -0.23344338f, -0.05763711f, 0.09049147f, -0.04573306f, -0.01666337f, -0.03752822f, -0.02579978f, -0.11818855f, 
    -1.13311052f, 0.21758179f, 0.10293923f, -0.24959123f, -0.00708733f, -0.05745778f, 0.07967699f, -0.09010075f, 
    -0.02211100f, -0.00935027f, 0.04209960f, 0.24480379f, 0.11852919f, -0.12110297f, -0.16212828f, 0.21637370f, 
    0.09337208f, -0.01612249f, 0.17228092f, -0.25247690f, 0.15643549f, 0.10363898f, -0.00989676f, 0.08086487f, 
    0.24413992f, 0.32706130f, -0.32638213f, 0.64664376f, -0.00136935f, 0.06665245f, -0.01223122f, 0.03263541f, 
    0.22495517f, -0.15941663f, 0.18492149f, -0.06142772f, -0.11332424f, -0.43597019f, 0.11527038f, -0.34348682f, 
    0.07322333f, 0.02617783f, -0.13403775f, 0.10048638f, -0.22172990f, -0.18708584f, -0.18602072f, -0.02940140f, 
    0.48037493f, -0.02237723f, 0.57191318f, -0.16171576f, 0.11153082f, 0.14363204f, -0.06803416f, -0.03982592f, 
    -0.27563688f, -0.07609247f, -0.14813431f, -0.08364809f, -0.15643562f, 1.06834817f, -0.05874732f, -0.02923691f, 
    0.11869203f, 0.01866143f, -0.10552365f, 0.13025625f, 0.04590631f, 0.29637241f, 0.18328899f, -0.25012910f, 
    0.03485185f, 0.00611962f, 0.09810708f, -0.04962929f, -0.15553394f, -0.00615934f, -0.02099707f, -0.26317227f, 
    -0.07319633f, 0.04690179f, 0.03269933f, 0.28292349f, -0.15314662f, -0.12243306f, -0.20744884f, -0.47667381f, 
    0.26647815f, 0.14400260f, -0.23818709f, 0.07783031f, -0.07113020f, -0.17787631f, 0.18025938f, 0.07404172f, 
    -0.03003044f, -0.17304063f, -0.64073271f, 0.39284232f, -0.03725244f, 0.12673686f, -0.06164043f, -0.12478579f, 
    0.11490415f, -0.12095094f, -0.05847663f, 0.10530704f, 0.12677212f, 0.48024008f, 0.21033287f, 0.11927067f, 
    -0.05323015f, -0.19419143f, -0.06375910f, -0.00096431f, 0.07479603f, 0.00243733f, 0.18628094f, 0.19583291f, 
    -0.46092290f, 0.13571124f, 0.61893994f, -0.08012261f, 0.00944244f, -0.10017802f, -0.01813081f, -0.02220014f, 
    0.00118753f, 0.05560952f, 0.06052113f, -0.11513072f, 0.60867840f, -0.05372892f, -0.19265711f, -0.24643254f, 
    0.04491216f, 0.13576539f, 0.04043120f, 0.10712373f, -0.24806620f, -0.29356292f, -0.18554209f, 0.06124063f, 
    0.42825636f, -0.75529283f, -0.17197971f, 0.07096186f, 0.05402783f, -0.00580789f, 0.08263962f, 0.09990654f, 
    -0.17737930f, 0.11492067f, -0.03058458f, 0.05038017f, -0.08230672f, 0.14443959f, -0.22579689f, -0.50511986f, 
    -0.05155807f, -0.14390364f, 0.08365205f, 0.11420064f, -0.04895177f, -0.13569283f, -0.07861464f, -0.08300783f, 
    0.24895361f, 0.12505613f, -0.01566352f, 0.08729839f, -0.13661429f, -0.22876902f, 0.07726761f, -0.13170309f, 
    0.16309048f, -0.11600625f, 0.00222164f, -0.11614645f, -0.27575499f, 0.21961987f, 0.01717722f, -0.33780092f, 
    0.08854830f, 0.07296432f, -0.12064692f, 0.19039875f, -0.00338864f, 0.18879551f, 0.09559862f, 0.10779421f, 
    -1.13748109f, -1.30300105f, 0.00031782f, -0.52187997f, -0.01230967f, -0.13418153f, -0.21336164f, 0.15320010f, 
    0.12190972f, -0.03491117f, -0.12160330f, 0.05850489f, 0.41973394f, 0.03394814f, -0.02097069f, 0.14458443f, 
    0.11569155f, -0.00424769f, -0.18664432f, 0.01977735f, -0.22451858f, -0.07962864f, 0.05172305f, -0.02137073f, 
    0.56610596f, -0.00480035f, 0.04647553f, -0.03497665f, -0.06678696f, -0.12918507f, 0.13595353f, 0.07604206f, 
    -0.06737602f, -0.07874983f, -0.22980480f, -0.05298464f, 0.17591263f, 0.03931903f, -0.09791098f, 0.13277000f, 
    0.43359005f, 0.19287947f, 0.06737711f, -0.09549566f, -0.10563306f, 0.43181860f, 0.08796587f, 0.14614451f, 
    -1.05881691f, -0.49450263f, 0.19820142f, 0.02483234f, 0.10824993f, 0.03071640f, -0.13310738f, 0.06023839f, 
    -0.00416307f, 0.28773147f, 0.04406257f, 0.38949984f, -0.07127535f, -0.09588366f, -0.06552515f, 0.02959872f, 
    0.17346947f, -0.01550739f, 0.17495649f, -0.08561981f, 0.06167917f, 0.03558839f, 0.07947338f, 0.12646013f, 
    -0.84019190f, -0.02100357f, 0.29050818f, -0.09431970f, 0.30917224f, -0.02524312f, 0.02998559f, -0.03510462f, 
    0.16334407f, -0.03778845f, -0.07012483f, -0.31355280f, -1.05921364f, -0.36946574f, 0.01516122f, -0.31568262f, 
    0.05248714f, 0.11027054f, 0.12282453f, -0.03366376f, 0.17037439f, 0.31934810f, 0.17605723f, 0.22604261f, 
    0.60867727f, 0.10586196f, -0.07977445f, -0.18517922f, 0.15763816f, 0.15087038f, 0.01425138f, -0.05834760f, 
    0.06678180f, 0.22345905f, -0.08060144f, 0.15239471f, -0.77241749f, -0.19046697f, 0.38466531f, -0.03233875f, 
    -0.01566276f, 0.13940613f, 0.06255504f, -0.21821719f, 0.07127851f, -0.46201932f, -0.46770167f, -0.17766906f, 
    -0.90388584f, -0.47762275f, -0.05831699f, 0.09849295f, -0.03429673f, 0.12465013f, -0.05916702f, 0.03854596f, 
    0.09683113f, 0.00967975f, 0.08122985f, -0.03445520f, -0.05949824f, -0.05464594f, -0.65985310f, -0.16718577f, 
    -0.16592215f, -0.21280026f, -0.09650179f, -0.08186139f, 0.10434838f, -0.09247486f, 0.14199361f, 0.03103413f, 
    -0.26667094f, 0.27491260f, -0.16753362f, -0.33689368f, 0.04020538f, 0.19601187f, -0.11802265f, 0.12040871f, 
    0.11556308f, 0.07839289f, 0.08597753f, 0.10505245f, 0.03771483f, 0.38043809f, -0.18489173f, -0.06685214f, 
    0.13347150f, -0.05455811f, -0.03932083f, 0.09363048f, 0.22863626f, 0.11450244f, 0.06032250f, 0.13982126f, 
    0.22646241f, -0.28111315f, -0.24509716f, 0.12083303f, -0.18242209f, -0.11957235f, -0.06468499f, 0.04666591f, 
    0.03090263f, -0.04590375f, -0.03020821f, -0.25801829f, 0.18875918f, 0.21353340f, -0.09549814f, 0.13367018f, 
    -0.05051661f, 0.07552786f, -0.14861217f, 0.20079035f, 0.24053605f, -0.01758767f, -0.10318941f, -0.06195173f, 
    -0.38982290f, 0.07128360f, -0.23547111f, -0.64839768f, 0.22926615f, 0.11401934f, 0.05324009f, -0.04653211f, 
    -0.03964441f, -0.04073384f, -0.06367038f, 0.11582800f, -0.19542581f, 0.23662575f, -0.02653313f, -0.14272098f, 
    -0.01964641f, -0.18992844f, 0.09033933f, -0.06245755f, -0.07476258f, -0.03271972f, -0.01569866f, -0.09088563f, 
    0.39243203f, -0.47322017f, 0.28637952f, -0.08714663f, 0.14706002f, -0.02417959f, 0.19589937f, 0.11967393f, 
    -0.15300265f, -0.08060402f, 0.21181878f, 0.11695801f, 0.22623025f, -0.01885243f, -0.46002942f, 0.33480674f, 
    -0.01804991f, 0.05706887f, -0.15231678f, -0.30022445f, 0.10676607f, -0.03847285f, -0.17429632f, 0.06498348f, 
    0.76120567f, 0.35377181f, -0.06830423f, -0.06892145f, -0.05577782f, 0.12682657f, -0.06781942f, 0.05594428f, 
    0.17709878f, 0.02648941f, -0.03278315f, 0.02588469f, 0.12117347f, -0.57234663f, -0.15163372f, 0.26559463f, 
    0.05138395f, -0.29928499f, 0.10776269f, 0.09324929f, 0.01160191f, 0.06621408f, -0.18517615f, -0.02002990f, 
    0.65659016f, 0.25681886f, -0.23083188f, -0.20042907f, 0.00472466f, -0.11780601f, -0.11636356f, -0.10755029f, 
    0.04780753f, -0.10218475f, 0.19268601f, 0.01093097f, 0.21745560f, -0.54125220f, -0.08928400f, -0.39375857f, 
    0.09076704f, -0.02426044f, 0.05720176f, 0.05418856f, -0.07229766f, -0.22565667f, -0.08740409f, -0.12864687f, 
    0.00540884f, -0.01174918f, -0.06325602f, 0.19162311f, 0.03307903f, -0.18221056f, -0.03735297f, 0.05552959f, 
    -0.08493802f, -0.05858434f, 0.05470603f, 0.11229122f, -0.20464030f, 0.51910990f, -0.01775065f, -0.26625222f, 
    0.28753519f, -0.27268323f, -0.36497867f, -0.18470331f, -0.09304545f, 0.15648340f, 0.31972450f, -0.02340191f, 
    0.37421229f, -0.48516512f, -0.10914699f, 0.21506079f, 0.03517161f, -0.08585066f, -0.01173078f, -0.26104823f, 
    0.10993472f, 0.17985685f, 0.07962629f, 0.14691706f, -0.24174891f, -0.59566456f, 0.05022159f, -0.13635486f, 
    0.02507626f, 0.02058763f, -0.03524029f, -0.16311488f, -0.25291598f, 0.04719424f, 0.00774369f, 0.13410252f, 
    -1.23267519f, 0.23720084f, 0.04607596f, 0.05837788f, -0.06850614f, -0.04761866f, 0.13639338f, 0.41749367f, 
    -0.22042885f, -0.04678122f, 0.12428974f, -0.08928621f, -0.15960288f, -0.10203786f, 0.25780374f, 0.67532772f, 
    -0.10560761f, 0.20563810f, 0.02448600f, -0.14964233f, -0.00550433f, -0.09413178f, 0.07764928f, -0.06948559f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17676294f, 0.13840963f, -0.04006021f, 0.01701950f, 0.02600934f, -0.03411868f, 0.06435258f, -0.10835411f, 
    0.01933728f, 0.07335945f, 0.19516039f, 0.03181119f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
