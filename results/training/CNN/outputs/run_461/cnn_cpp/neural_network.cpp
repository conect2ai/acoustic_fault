#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.49553674f, -0.44552225f, -0.76484871f, -0.12556583f, 0.09091169f, -0.46290848f, -0.59124798f, -0.32978892f, 
    -0.33841616f, 0.18069814f, -0.08463266f, 0.33237082f, 0.15551564f, 0.13152021f, 0.08479483f, 0.09112161f, 
    0.09443110f, -0.28334296f, -0.12021475f, -0.12994517f, 0.05461203f, 0.12296657f, 0.26403013f, 0.02360270f, 
    -0.02013599f, -0.86485219f, 0.70894158f, -0.45833400f, -0.24873438f, 0.43926901f, 0.25121319f, -0.23346159f, 
    -0.10547038f, 0.45559263f, -0.26943052f, -0.12210020f, -0.05308809f, -0.37696716f, 0.11225931f, -0.10674954f, 
    -0.14731011f, 0.14287058f, -0.07792424f, -0.16481386f, -0.13621593f, -0.12347388f, 0.12325998f, 0.05462081f, 
    -0.00721829f, -0.09178349f, 0.04147561f, 0.12275843f, 0.00133004f, 0.83387315f, -0.12786406f, -0.75841051f, 
    -0.56648844f, -0.21892807f, 0.16074727f, 0.31507003f, 0.21819164f, 0.34132868f, -0.01798471f, 0.04024737f, 
    -0.27358538f, 0.17175464f, 0.16936944f, -0.21953635f, 0.13030109f, 0.16291915f, -0.14039309f, -0.27341971f, 
    0.10923770f, -0.26380676f, -0.11687587f, 0.34784207f, -0.11143739f, -0.77807176f, -0.67375743f, -0.49384922f, 
    0.26181820f, 0.19676675f, 0.43290347f, 0.34247562f, 0.12915283f, -0.19352569f, 0.17309147f, -0.20168829f, 
    0.03456134f, -0.12568063f, -0.22846052f, -0.06846382f, 0.02542742f, -0.09220087f, -0.08763585f, -0.16814063f, 
    0.00847966f, -0.11642585f, -0.00089564f, 0.31146419f, -0.62512869f, 0.40208873f, 0.64677161f, -0.40043712f, 
    0.67905480f, -0.49908406f, 0.29606596f, 0.27638441f, -0.08055889f, 0.07686187f, 0.14875014f, 0.31699228f, 
    0.21654159f, 0.03261460f, 0.18066941f, 0.13633657f, 0.16398008f, 0.08532435f, 0.19773003f, 0.44024903f, 
    0.12447906f, 0.01130385f, 0.18437377f, 0.23840007f, -0.00264754f, -0.12051468f, -0.47216782f, -0.47616857f, 
    -0.42063606f, -0.38123012f, -0.48424366f, 0.66267347f, 0.50781292f, -0.22094706f, -0.01168433f, -0.37563899f, 
    -0.12279136f, -0.31415758f, -0.26568043f, -0.05513052f, -0.03869598f, 0.22048648f, 0.07883371f, 0.11159696f, 
    -0.12513767f, 0.03271137f, 0.08054909f, 0.14938200f, -0.18412881f, 0.14626983f, 0.59411889f, 0.46028617f, 
    -0.49407870f, -0.55675590f, -0.10045490f, 0.63551229f, 0.25840250f, -0.51916760f, 0.15045625f, 0.54395461f, 
    0.28927478f, -0.04947451f, -0.15551557f, -0.12497443f, -0.12242324f, 0.18641317f, 0.11562811f, 0.33568966f, 
    0.16280124f, -0.03971118f, -0.01811786f, -0.16031985f, -0.11403695f, -0.07043392f, 0.20975433f, 0.70358157f, 
    0.59241855f, 0.52418828f, 0.69313604f, 0.92607671f, -0.18681936f, -0.52265161f, 0.13485092f, -0.26013881f, 
    -0.10178833f, -0.05261069f, -0.06056136f, -0.18099660f, 0.25011387f, -0.01078131f, 0.04997128f, -0.13894987f, 
    -0.04764162f, 0.15618950f, 0.04434572f, -0.00159832f, 0.02128011f, 0.08225532f, -0.19407278f, -0.03974129f, 
    -0.50939262f, 0.61780906f, 0.00051473f, -0.70771790f, -0.59869319f, 0.41505799f, -0.32568958f, -0.31387573f, 
    -0.25875771f, -0.18522942f, 0.33935255f, -0.17742692f, -0.39104980f, 0.00724844f, 0.13679697f, -0.18422914f, 
    -0.00968802f, -0.31563875f, -0.03582339f, 0.26261401f, -0.04995918f, 0.00113965f, 0.01650858f, -0.01359706f, 
    -0.07647443f, 0.12723613f, -0.58791751f, 0.63158768f, 0.69672489f, 0.47731295f, 0.84923655f, 0.16899697f, 
    0.11319564f, 0.09647833f, -0.06557278f, -0.00533357f, -0.02996005f, -0.32349947f, 0.29373166f, 0.05461286f, 
    0.01639946f, 0.12026811f, -0.30328998f, -0.00418984f, -0.13050750f, -0.04259363f, 0.02576784f, -0.08839204f, 
    -0.04772039f, 0.02033887f, 1.06604326f, 0.56457740f, 0.86001909f, -0.41925848f, -0.73110038f, -0.35160473f, 
    -0.27844751f, 0.12317315f, 0.09111223f, -0.10867757f, 0.23075855f, 0.16942523f, -0.10929459f, 0.06521598f, 
    -0.18438269f, 0.11037572f, -0.11621568f, 0.09267280f, -0.03631668f, -0.00793020f, -0.07435603f, 0.16084312f, 
    0.07712168f, 0.01813582f, -0.06165864f, -0.01762102f, 0.39780423f, 0.20112294f, -0.65955549f, 0.21902961f, 
    0.47713301f, -0.58810771f, -0.63571638f, -0.16335338f, -0.58728987f, 0.26751310f, 0.50947058f, 0.27636698f, 
    -0.03135775f, -0.12110759f, 0.09471224f, 0.09823989f, 0.18562269f, 0.03642987f, 0.22714633f, 0.08707258f, 
    0.25813314f, -0.07466029f, 0.29140595f, 0.03469020f, 0.00568684f, -1.11268175f, 0.15798162f, 0.67535698f, 
    -0.04773005f, -0.52591497f, 0.42662486f, 0.42622608f, -0.45431376f, -0.13207611f, 0.30291131f, 0.19088747f, 
    -0.01711804f, -0.03597295f, 0.05579034f, -0.18004800f, 0.00669556f, -0.05602032f, -0.04470621f, -0.30946034f, 
    -0.02563538f, 0.00505795f, -0.02080184f, 0.08120906f, 0.01029718f, -0.86139452f, 0.40183723f, 0.11849229f, 
    0.07542014f, -0.15737824f, 0.45773071f, 0.72996080f, 0.21390243f, 0.48155162f, 0.52012420f, -0.26404658f, 
    -0.06291740f, -0.11815384f, -0.43698412f, 0.09264502f, -0.07058134f, -0.07353347f, -0.17022461f, -0.15684876f, 
    -0.04263918f, 0.09135851f, -0.08035289f, -0.02334096f, -0.04642480f, 0.00432927f, 0.78828841f, 0.38802418f, 
    -0.40004697f, 0.32453778f, -0.21749255f, 0.54493201f, 0.57067317f, 0.36419219f, 0.61605346f, 0.32145721f, 
    0.09552661f, -0.18749844f, -0.42897829f, -0.38846087f, 0.12083496f, -0.06720132f, -0.28748396f, -0.12195971f, 
    0.10341048f, 0.17147051f, -0.15938205f, -0.14870927f, -0.10837661f, -0.12309993f, -0.31809524f, -0.78981566f, 
    -0.52522987f, -0.66688412f, -0.29895341f, -0.36766917f, 0.52260154f, 0.64967197f, -0.11386892f, 0.31993055f, 
    0.60530651f, -0.01522302f, -0.14950648f, 0.39405921f, 0.17886008f, 0.15583421f, -0.04833544f, 0.09728575f, 
    0.17165226f, 0.11897415f, 0.01314602f, 0.04776621f, -0.03546406f, 0.02755680f, -0.06691250f, 0.10628795f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20002677f, -0.05391446f, -0.01546147f, 0.08341245f, 0.29760769f, -0.03349439f, 0.13812189f, -0.05842632f, 
    0.23525082f, 0.24690461f, 0.21866260f, 0.37243330f, -0.06658653f, -0.03139934f, 0.19076271f, 0.30796024f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00630660f, 0.05138041f, 0.04572596f, -0.06018587f, 0.05071518f, 0.06159094f, 0.03693200f, -0.05557170f, 
    0.03969716f, 0.06473339f, -0.05102557f, 0.05919755f, -0.06660668f, -0.07825512f, -0.05212024f, -0.00503330f, 
    0.05881611f, -0.07356676f, 0.01292724f, -0.05189456f, -0.03560643f, 0.03857606f, 0.04078971f, 0.05914761f, 
    0.01958926f, -0.07482170f, 0.00452945f, 0.06154200f, 0.01961848f, 0.00797495f, -0.01709285f, 0.01873692f, 
    -0.03779817f, -0.02371225f, -0.00647852f, -0.05037669f, 0.00536593f, 0.04176014f, 0.04036567f, -0.08966976f, 
    -0.02312048f, 0.00528209f, -0.04006824f, 0.00048608f, 0.00390910f, -0.03807919f, -0.06292355f, -0.04164457f, 
    0.03313434f, 0.02514317f, 0.03477922f, -0.04903121f, -0.04714454f, 0.04669815f, -0.01309319f, 0.01212808f, 
    0.00906435f, -0.07446858f, -0.01619877f, 0.03465966f, 0.03521604f, 0.05675885f, -0.02013776f, -0.06039534f, 
    -0.02737745f, -0.06701946f, 0.04090252f, 0.01024221f, -0.03804615f, 0.05215220f, 0.00027475f, 0.06718899f, 
    -0.05637744f, -0.01792024f, -0.07626154f, -0.01949365f, 0.00072581f, 0.03490439f, 0.04037463f, -0.04294467f, 
    0.02986916f, 0.05995878f, -0.06364775f, -0.01342274f, 0.00467663f, 0.03570522f, 0.03953618f, 0.00498833f, 
    -0.06460387f, 0.00076433f, 0.06562161f, -0.01986916f, -0.06991252f, -0.04186202f, 0.01289234f, -0.06600693f, 
    0.05648304f, -0.02507621f, -0.03284358f, -0.03073026f, -0.01882254f, 0.04083351f, -0.05719640f, -0.06391018f, 
    0.02896465f, -0.03714301f, 0.00895757f, -0.03452292f, 0.04264128f, 0.00373049f, -0.04329655f, 0.04661690f, 
    0.01956949f, -0.04428820f, -0.06954066f, 0.03744488f, 0.05876370f, 0.06397000f, -0.06897591f, -0.02159034f, 
    0.00771067f, -0.02465637f, -0.04868226f, 0.05510199f, 0.00932623f, -0.06940071f, -0.04716098f, 0.01940234f, 
    -0.00657498f, -0.04097589f, 0.04522980f, 0.01132843f, 0.02571702f, -0.05020064f, -0.06901237f, 0.06447123f, 
    -0.07392386f, 0.03751551f, -0.07523111f, -0.04597387f, -0.04436049f, -0.00429945f, 0.05323940f, -0.07341196f, 
    0.05568720f, 0.01348379f, -0.00127047f, -0.02751958f, 0.00647293f, 0.02730100f, -0.06377087f, -0.05061482f, 
    0.02980266f, -0.00918446f, 0.03106172f, -0.01610538f, -0.01097774f, -0.01692033f, 0.00866564f, -0.07545165f, 
    -0.01197991f, -0.02656692f, -0.03395275f, -0.04430143f, -0.01327671f, -0.07084898f, -0.02362069f, 0.04959311f, 
    -0.06301244f, -0.01193828f, -0.03949278f, -0.05373240f, -0.05258730f, 0.00757975f, 0.00578030f, -0.07399747f, 
    -0.04027452f, 0.05948612f, 0.04818193f, -0.07091054f, -0.07436806f, -0.04685663f, -0.05779020f, -0.03040754f, 
    -0.06336946f, -0.06930345f, -0.06680755f, -0.01485143f, -0.04854368f, 0.02974480f, 0.03828584f, 0.02597471f, 
    0.23132758f, -0.09849923f, 0.16976556f, -0.08369213f, 0.08648563f, 0.00169753f, -0.11708651f, 0.01939407f, 
    -0.09702358f, -0.06588651f, -0.03443177f, 0.06800836f, -0.03901814f, 0.20049433f, 0.10120274f, -0.02824752f, 
    0.02199616f, 0.02953770f, 0.10990300f, 0.00311538f, 0.07294897f, 0.16872774f, -0.13521871f, 0.01261548f, 
    0.18587151f, 0.18206707f, 0.03203172f, 0.23806694f, 0.10399762f, 0.07377341f, 0.08928279f, 0.01715617f, 
    0.09397183f, -0.07940883f, 0.04612992f, -0.10523897f, 0.18508488f, -0.24601133f, -0.16252999f, -0.12303163f, 
    0.06594533f, 0.00797148f, 0.15379275f, -0.15570936f, 0.04676958f, -0.08618695f, 0.12050368f, -0.07277995f, 
    -0.29344833f, 0.07799713f, 0.09981156f, -0.00223980f, -0.00734742f, 0.14088826f, -0.02874806f, 0.07869390f, 
    0.05948003f, -0.03228565f, -0.00027239f, 0.02756542f, 0.12753102f, -0.11511056f, 0.10807198f, -0.07588601f, 
    -0.00940613f, 0.02791383f, 0.04831105f, 0.06757581f, 0.01535801f, -0.02890723f, -0.03580907f, 0.07477531f, 
    -0.01111480f, -0.04617752f, -0.08282288f, -0.15030935f, -0.07398457f, 0.07159319f, 0.03933179f, -0.03226282f, 
    0.00459649f, 0.06965087f, 0.03045460f, -0.06406081f, 0.13852623f, 0.06674907f, 0.18333271f, -0.03648768f, 
    -0.18564636f, 0.08905970f, -0.03700509f, 0.01974747f, -0.00863880f, -0.02402231f, -0.06348157f, 0.00608238f, 
    0.03579271f, 0.22907251f, 0.00684107f, 0.08715194f, -0.01647310f, 0.10804804f, 0.19126335f, 0.02278281f, 
    -0.00713895f, -0.04974584f, 0.09344295f, 0.01418297f, -0.02976694f, -0.06307671f, 0.00383197f, 0.23959669f, 
    -0.06886147f, 0.03616510f, 0.05166556f, -0.05129149f, 0.02583899f, 0.00156908f, 0.05349486f, -0.07468787f, 
    -0.40966320f, -0.02993109f, -0.16383524f, 0.23802829f, -0.04727925f, -0.06016809f, -0.03023784f, 0.12274471f, 
    -0.05065772f, 0.02469950f, -0.14557791f, 0.00797990f, 0.04752366f, -0.19167458f, 0.18344378f, 0.08445742f, 
    0.03796953f, 0.04218250f, 0.09283457f, -0.05887682f, -0.08864841f, 0.08693155f, -0.13032562f, -0.12551719f, 
    0.46358418f, -0.08516503f, 0.20073447f, 0.26622325f, -0.13450116f, 0.07761154f, 0.17790109f, -0.04668659f, 
    0.07331258f, 0.01645696f, -0.07442034f, -0.05335132f, 0.14390208f, 0.11542995f, 0.01572373f, -0.11094555f, 
    -0.02557683f, 0.09204101f, 0.00571187f, -0.14875548f, -0.04307957f, 0.02507547f, 0.08819799f, 0.02948483f, 
    0.16788602f, -0.07569771f, -0.04514228f, -0.09305862f, -0.05593411f, -0.03288533f, -0.00267811f, 0.03790259f, 
    0.01429713f, -0.03360053f, 0.07196404f, 0.01615271f, 0.00997356f, 0.18263695f, -0.14682384f, -0.16940510f, 
    -0.00356334f, 0.03136229f, -0.00900626f, -0.08684462f, 0.02063021f, -0.02291813f, 0.02708885f, 0.14696530f, 
    0.08361467f, -0.37332147f, 0.06144996f, -0.13063569f, 0.11987986f, 0.08113711f, 0.17658094f, 0.12096413f, 
    -0.08195518f, -0.15454628f, 0.00087376f, -0.00088470f, 0.05827560f, 0.08211876f, -0.16470991f, -0.35360587f, 
    0.10923273f, -0.00241483f, 0.09203775f, 0.15336357f, 0.03678949f, -0.00113318f, 0.05047772f, -0.02413578f, 
    -0.00781293f, -0.29591447f, -0.21027808f, 0.15557595f, -0.08557788f, 0.02950575f, -0.10435849f, -0.03347212f, 
    -0.13295801f, -0.09252577f, 0.04253263f, 0.12501957f, -0.04632612f, -0.10020462f, 0.11552048f, -0.17075813f, 
    -0.00746062f, -0.10570241f, -0.05291210f, 0.03531438f, -0.00030689f, -0.00758185f, 0.15331413f, -0.03445016f, 
    -0.08296338f, 0.19694863f, -0.18596250f, 0.08447518f, -0.11530873f, 0.02128384f, -0.00049350f, -0.05439461f, 
    0.12576526f, 0.10816012f, 0.09112877f, 0.02733857f, 0.29279351f, 0.13599946f, 0.27909032f, -0.03013857f, 
    -0.05344885f, -0.15589203f, 0.03080651f, 0.01159117f, 0.00022177f, 0.03534314f, 0.08581924f, -0.04730345f, 
    -0.05536363f, -0.23764563f, 0.13688120f, -0.19973770f, 0.06311125f, -0.04325759f, 0.12700227f, 0.04661578f, 
    0.02970039f, 0.03016382f, -0.03808553f, -0.08877149f, -0.00175358f, 0.02208830f, -0.09298084f, 0.24244402f, 
    0.11000299f, -0.04698279f, -0.00463579f, -0.00017960f, -0.04206286f, -0.10177574f, -0.12913702f, -0.08184753f, 
    -0.06432699f, -0.01453681f, 0.00022073f, -0.00940241f, 0.03967770f, -0.00965696f, 0.05447672f, -0.10637829f, 
    -0.09170529f, 0.06177105f, 0.06412320f, 0.00886485f, 0.27434462f, 0.03488851f, 0.01528056f, -0.00084329f, 
    -0.03964924f, 0.09952588f, -0.05779317f, 0.09913842f, -0.07098541f, -0.02982937f, 0.04862930f, -0.02305403f, 
    -0.36386412f, -0.07404783f, 0.08755492f, -0.21673091f, 0.10004087f, -0.04639550f, 0.14531143f, -0.03895622f, 
    -0.09174358f, 0.03525424f, 0.06192804f, 0.05758671f, -0.18132393f, -0.09703106f, 0.02085771f, -0.33928546f, 
    0.01804524f, 0.03442462f, -0.04969253f, -0.00623701f, 0.08492775f, 0.06042284f, 0.14026383f, -0.07144343f, 
    0.00579922f, -0.07972345f, -0.02792649f, 0.23072894f, -0.15246025f, 0.05569228f, 0.01030208f, 0.01887788f, 
    -0.06305031f, 0.03699074f, -0.09553816f, 0.08368140f, 0.02094009f, 0.15133752f, 0.07307420f, 0.08435178f, 
    0.02048045f, 0.17307135f, -0.13573124f, 0.01505322f, -0.01176847f, 0.08931854f, 0.02568815f, -0.03840822f, 
    0.18631642f, -0.11544180f, 0.18049815f, 0.08253274f, -0.01109682f, 0.03019323f, 0.12822795f, 0.09746392f, 
    -0.08487935f, -0.15486334f, -0.17390175f, 0.01502609f, 0.35314527f, 0.17085247f, 0.08427986f, 0.10456841f, 
    -0.05887213f, -0.05114891f, 0.10666484f, 0.02902048f, 0.03254929f, 0.10859578f, 0.05352809f, -0.05256126f, 
    -0.02553700f, -0.04650033f, -0.00545605f, -0.00340845f, 0.00912100f, 0.04546605f, 0.02010512f, -0.04175897f, 
    -0.00500142f, -0.05457966f, -0.04921842f, -0.02217381f, -0.05242433f, -0.01308495f, -0.00217104f, -0.07757634f, 
    -0.03156973f, 0.07315803f, -0.06162136f, -0.04158887f, 0.01979958f, -0.00903245f, 0.05793726f, 0.00640044f, 
    -0.00601469f, -0.06940969f, 0.01104204f, -0.06951106f, -0.02030586f, 0.03916406f, -0.03799105f, 0.05243538f, 
    -0.02131009f, 0.03608088f, -0.04388917f, -0.05490328f, -0.05739609f, -0.07727749f, 0.04413602f, -0.06983908f, 
    -0.03387747f, -0.06604510f, -0.01508536f, -0.01623020f, 0.00962625f, -0.07057899f, 0.05430701f, -0.03487713f, 
    0.01857584f, -0.07665825f, -0.00282704f, -0.06007043f, 0.05953185f, 0.06265401f, -0.03537924f, -0.04537683f, 
    -0.07561978f, 0.00464682f, 0.02316952f, 0.04719686f, 0.06601691f, 0.05628551f, -0.07035986f, -0.00043595f, 
    -0.03221235f, 0.05907726f, 0.04424659f, 0.03138679f, -0.03404294f, -0.03180685f, 0.02821735f, -0.01268427f, 
    -0.05050725f, 0.00883693f, -0.01966567f, 0.02205521f, 0.01447369f, 0.03109894f, -0.06955512f, -0.06781308f, 
    0.03478684f, -0.06019510f, -0.06515873f, -0.04964002f, -0.02482637f, -0.03851260f, -0.07024457f, -0.03917209f, 
    -0.02492500f, 0.04498802f, -0.05118054f, -0.01438906f, 0.06765703f, 0.00309607f, 0.05161559f, 0.01040946f, 
    -0.03023446f, -0.06793604f, -0.03351455f, 0.00554091f, 0.00264564f, 0.02969914f, 0.05701352f, 0.02158851f, 
    0.01609781f, -0.05989444f, 0.02301482f, -0.06652793f, 0.02040304f, 0.05784415f, -0.00708687f, 0.01886331f, 
    0.00840523f, 0.06010291f, 0.01421192f, -0.02568335f, -0.04548588f, -0.00827385f, -0.05977023f, -0.00770901f, 
    -0.04920823f, -0.05685125f, -0.07223255f, -0.06069270f, 0.06424008f, -0.00720466f, 0.00908101f, 0.01110706f, 
    -0.05789642f, 0.00532009f, -0.05612782f, 0.02434409f, -0.06322621f, -0.00836698f, -0.02150376f, 0.01116117f, 
    0.02405964f, -0.05108887f, -0.06164804f, 0.05125754f, 0.00363375f, 0.03569698f, -0.04300638f, 0.00550360f, 
    -0.03314989f, 0.04621043f, -0.03972475f, 0.03461650f, -0.03385929f, -0.06434215f, -0.07146189f, 0.05710737f, 
    -0.06990753f, -0.05614670f, -0.00868086f, 0.02282408f, 0.05636147f, -0.06672022f, -0.02213257f, 0.05886820f, 
    0.01549301f, 0.01581839f, 0.05923985f, 0.04553528f, -0.07208177f, -0.01807618f, 0.04071128f, -0.05550861f, 
    -0.07576723f, 0.01498778f, -0.05436673f, -0.05406380f, -0.01554511f, 0.06237137f, 0.03470054f, -0.04096359f, 
    0.04306792f, -0.00511114f, 0.04070741f, 0.02924048f, -0.02058509f, 0.05366064f, 0.00761564f, -0.08054717f, 
    0.02635889f, -0.04156875f, -0.00083425f, 0.00304171f, -0.05234392f, -0.05400068f, 0.03490856f, 0.00160658f, 
    -0.09321985f, -0.02671544f, -0.08291820f, 0.05672980f, 0.20132850f, 0.14078458f, 0.05042363f, 0.05516221f, 
    -0.05655376f, -0.07115714f, -0.01253520f, 0.03296272f, -0.06035445f, -0.17284070f, -0.09202401f, 0.10905057f, 
    0.00512933f, 0.05297529f, 0.01516855f, 0.20152275f, 0.02920712f, -0.01687046f, 0.18322387f, -0.04353454f, 
    -0.16090184f, 0.03998510f, 0.05396603f, -0.00082276f, -0.11547083f, -0.08735123f, -0.02870119f, -0.04587920f, 
    -0.03202088f, 0.04933488f, 0.11885614f, 0.10602652f, -0.11556885f, -0.04003937f, 0.21792766f, -0.11267826f, 
    0.17195332f, -0.03498402f, -0.10555167f, 0.02897261f, 0.05170453f, -0.03747160f, 0.03109997f, 0.09895407f, 
    -0.06037648f, -0.03722697f, -0.05975563f, -0.07782949f, 0.01095710f, -0.03138397f, -0.06091559f, 0.03790035f, 
    0.04023851f, -0.06156133f, -0.00839962f, 0.03758680f, -0.10221881f, 0.01537438f, -0.09118699f, -0.04452462f, 
    0.10330386f, -0.03514696f, -0.00601001f, 0.00597749f, 0.02220294f, -0.08325778f, 0.02529412f, -0.09403347f, 
    0.09904539f, -0.12248847f, 0.16583838f, 0.06776794f, 0.09481067f, -0.14319877f, 0.03859517f, 0.01290729f, 
    -0.06976756f, 0.14116731f, -0.00499722f, -0.04371244f, 0.11963919f, 0.13147496f, -0.02813019f, -0.15755817f, 
    0.03401634f, -0.14502068f, 0.07947734f, 0.12366186f, 0.01404937f, 0.05445293f, -0.10885083f, -0.00006937f, 
    -0.05219472f, -0.22243346f, 0.06603786f, -0.10559333f, -0.14559564f, -0.00748390f, -0.06365374f, -0.08775641f, 
    0.00284715f, -0.01167555f, 0.13610189f, 0.16547987f, 0.34309107f, 0.09448567f, 0.01862732f, -0.04928928f, 
    0.16323023f, -0.06678174f, 0.01780017f, 0.11033567f, -0.04730543f, -0.00662076f, 0.08785859f, 0.07591864f, 
    0.46008554f, 0.02054804f, 0.30424196f, -0.12306362f, 0.07685450f, -0.02247875f, 0.07176757f, 0.02289497f, 
    0.08038427f, 0.00977342f, 0.06663260f, 0.04715338f, -0.07439286f, 0.00755749f, -0.05810898f, -0.20067754f, 
    0.06582467f, 0.00398962f, 0.00273412f, 0.03122503f, 0.01679658f, -0.03593340f, 0.15077923f, 0.09053507f, 
    -0.32942259f, 0.11390811f, -0.24070042f, 0.18810071f, 0.08418640f, -0.04454130f, -0.03272773f, -0.07136270f, 
    0.04909175f, -0.01050430f, 0.10521826f, 0.11335339f, -0.08197655f, -0.07825853f, 0.00806385f, 0.11501198f, 
    0.11951004f, 0.06080899f, -0.02118337f, -0.02412319f, -0.10488584f, 0.02752498f, 0.01605732f, 0.02960793f, 
    -0.28088543f, -0.14081191f, -0.01388550f, 0.23513138f, 0.11347902f, 0.05738115f, 0.09804466f, 0.06420308f, 
    0.13728993f, 0.06406409f, -0.01648504f, 0.02622667f, 0.11349393f, -0.09324405f, 0.03506868f, -0.12010679f, 
    0.06088147f, 0.12265956f, 0.01978383f, 0.12514569f, -0.04185228f, 0.11487412f, -0.05862944f, 0.05157851f, 
    -0.12819560f, -0.13395035f, 0.13102789f, -0.03957808f, 0.06174832f, -0.07306072f, -0.06530482f, -0.02492959f, 
    -0.02774787f, -0.02344953f, 0.09982414f, 0.15622409f, -0.28279203f, -0.18485604f, 0.06596276f, 0.14174862f, 
    -0.07193723f, 0.02657832f, 0.05958077f, -0.04089039f, 0.00699582f, 0.15418677f, -0.14326803f, -0.00151726f, 
    0.01486813f, -0.03148448f, 0.18443011f, 0.07017554f, -0.00254779f, -0.08060914f, 0.00150049f, 0.05111469f, 
    0.08588481f, 0.04555454f, -0.00133560f, 0.07180077f, -0.00967750f, -0.21227734f, -0.08405217f, -0.16953214f, 
    0.01264422f, -0.03988486f, 0.03615163f, 0.06281636f, 0.01662635f, -0.16946146f, -0.02268353f, 0.17877927f, 
    -0.08729648f, 0.04770034f, 0.08973277f, -0.12647830f, 0.03323909f, 0.10279067f, 0.04877875f, 0.07863012f, 
    0.10430834f, -0.02271447f, 0.04317442f, 0.02638550f, -0.24959818f, -0.13031231f, -0.22963540f, 0.00236642f, 
    0.07480559f, 0.11138812f, -0.03231690f, 0.13123100f, 0.10402319f, -0.07603493f, 0.03128256f, -0.03482461f, 
    0.12759387f, -0.25659335f, 0.04809961f, -0.00050286f, 0.07352220f, 0.06743153f, -0.03859226f, 0.07097412f, 
    0.10613135f, -0.04326942f, 0.14426136f, 0.02851475f, 0.25740010f, 0.32820207f, 0.23977454f, -0.02649340f, 
    -0.16198918f, -0.09783332f, -0.01567293f, 0.01355086f, 0.03966539f, 0.07236427f, -0.04208453f, 0.25591233f, 
    -0.29015991f, -0.10856626f, -0.12755558f, 0.06009001f, 0.10109860f, -0.04142128f, 0.15655454f, 0.04406125f, 
    -0.01216035f, 0.12022356f, -0.04582183f, 0.02369542f, 0.12529363f, 0.18820557f, 0.13565680f, 0.15366080f, 
    0.08583661f, 0.12463280f, -0.00588256f, -0.04190607f, 0.16379340f, 0.04483330f, 0.07826457f, 0.02354142f, 
    0.06867139f, 0.40801051f, 0.04923926f, 0.18436493f, 0.07447416f, -0.06534135f, 0.00007307f, 0.03848753f, 
    0.00046406f, -0.12450342f, 0.02863089f, 0.13395621f, -0.15533578f, -0.11743310f, -0.02875836f, 0.03195716f, 
    0.04647132f, 0.05964704f, 0.05169604f, -0.06312244f, 0.04365440f, 0.00914159f, 0.08320034f, 0.22684047f, 
    -0.21226026f, -0.03787884f, -0.05125518f, -0.04654239f, 0.10930035f, 0.05341241f, 0.00549154f, 0.07128044f, 
    0.00007429f, -0.16532855f, 0.00748766f, -0.05041061f, 0.15041080f, 0.06768072f, 0.04705101f, -0.01785554f, 
    0.05654563f, 0.11279533f, 0.08391558f, -0.09812160f, -0.03153199f, 0.09709360f, 0.05228830f, -0.01864007f, 
    0.23288520f, 0.19475652f, 0.14576125f, 0.11243431f, 0.01774608f, -0.15441841f, -0.04848664f, -0.05964660f, 
    -0.05993139f, 0.15005510f, -0.01816200f, -0.03359405f, -0.28224772f, -0.20079295f, -0.17756651f, -0.08627898f, 
    0.10077024f, 0.09543191f, -0.01834706f, 0.04686907f, 0.03459241f, -0.06650647f, 0.07932132f, 0.03791150f, 
    0.12975465f, -0.12429410f, 0.09451561f, -0.14647432f, -0.02538742f, -0.02739174f, -0.07495549f, 0.12385882f, 
    0.03353955f, -0.00495320f, 0.08312937f, 0.14253265f, -0.26496115f, -0.07699866f, 0.03029045f, 0.14026004f, 
    -0.04175683f, 0.11063137f, 0.06588349f, 0.02120044f, -0.05529494f, -0.00180932f, -0.13101617f, -0.08519173f, 
    0.21896096f, -0.04951676f, -0.02204402f, 0.11512474f, 0.15566397f, -0.13274330f, 0.07895211f, 0.08735662f, 
    -0.15625359f, -0.05800905f, 0.05370377f, 0.08551366f, 0.15867504f, -0.09311970f, -0.07795162f, -0.13914801f, 
    -0.11143421f, -0.03036734f, -0.01118947f, 0.07008489f, -0.03835041f, -0.05685241f, -0.11377788f, 0.10963156f, 
    -0.03413214f, 0.08238149f, 0.06521291f, -0.22653589f, 0.03080201f, 0.00722017f, 0.05258748f, 0.05559915f, 
    0.03485205f, 0.07502075f, 0.13859239f, 0.21428363f, 0.13285269f, 0.03666027f, -0.34354910f, 0.06863937f, 
    -0.01788138f, 0.04062395f, 0.09836841f, 0.05605997f, 0.16217941f, 0.05506154f, -0.13399950f, 0.06391618f, 
    0.29665878f, -0.08938002f, 0.04702808f, -0.21648107f, -0.09724765f, -0.00666297f, -0.00190692f, -0.10330848f, 
    -0.02700907f, -0.13191451f, 0.05258057f, 0.15766020f, -0.13562235f, -0.15354328f, -0.04422133f, 0.10612312f, 
    0.13115221f, 0.03511950f, 0.00403982f, -0.00057998f, 0.05562294f, -0.03581423f, 0.05065439f, 0.14863846f, 
    -0.29622954f, 0.02411816f, 0.06432273f, -0.05453557f, 0.09693621f, -0.01028019f, 0.00640139f, 0.00215904f, 
    0.06851236f, 0.12340134f, -0.05782355f, 0.04149533f, -0.13753495f, 0.01315968f, 0.17052488f, 0.32118887f, 
    0.06473693f, 0.09634047f, -0.01928684f, -0.08865923f, 0.02648510f, 0.08275039f, -0.08167084f, -0.05485402f, 
    0.01793531f, 0.24358575f, -0.00982498f, 0.03458408f, 0.05477298f, -0.02459774f, 0.08225824f, 0.00109832f, 
    -0.08991694f, -0.14238627f, 0.00768142f, 0.07954028f, 0.04005916f, -0.09118391f, 0.12632026f, 0.01975108f, 
    0.15163338f, 0.00098158f, 0.13754395f, 0.04237165f, 0.06631800f, 0.11082746f, 0.05168170f, 0.08350515f, 
    0.04261399f, -0.02675476f, 0.13431574f, 0.07923553f, 0.04975843f, -0.01274531f, -0.02378636f, -0.01449896f, 
    0.07502929f, -0.02774743f, 0.00714456f, -0.07238076f, -0.07273261f, 0.10405011f, -0.15492344f, -0.17776443f, 
    0.08095956f, -0.03722814f, -0.00152741f, -0.13742438f, 0.10654467f, 0.07942067f, 0.00509614f, -0.03863262f, 
    0.38333455f, -0.04041371f, -0.06151177f, -0.10063261f, 0.05893349f, -0.21972091f, -0.00118353f, 0.01837475f, 
    -0.13557369f, 0.09709259f, -0.01840421f, -0.10821379f, 0.12155302f, 0.09030996f, -0.18787938f, -0.07666686f, 
    0.00254298f, -0.08653780f, 0.05204577f, 0.05254797f, 0.04268709f, -0.04857106f, 0.02993260f, -0.00583805f, 
    -0.11155006f, 0.03879217f, -0.05637884f, 0.12956470f, -0.05005812f, 0.05392832f, -0.06048140f, -0.08339363f, 
    0.09333914f, -0.02364515f, 0.08459220f, -0.00247535f, -0.01206926f, -0.19566888f, 0.14936261f, 0.26211315f, 
    0.04190391f, 0.04995956f, 0.03995301f, -0.04716852f, -0.07057558f, -0.03639947f, 0.01949633f, 0.08686931f, 
    0.12340271f, 0.10841426f, 0.10684413f, -0.27784798f, 0.01178538f, 0.05797603f, -0.02592999f, 0.01559787f, 
    0.04158083f, 0.08761309f, 0.00496672f, 0.08384225f, -0.10201091f, 0.21644785f, -0.03602678f, 0.28766131f, 
    -0.05586904f, -0.00877013f, 0.00849026f, -0.03259756f, 0.01803397f, 0.08193902f, -0.00375385f, 0.08462575f, 
    0.20587380f, -0.18172812f, 0.06630416f, -0.05169027f, 0.07409295f, -0.01400729f, 0.00649115f, -0.05182864f, 
    -0.01740638f, 0.03170230f, 0.06507527f, -0.07820968f, 0.14804322f, 0.04607894f, -0.10814017f, 0.11949144f, 
    0.12430399f, 0.15518707f, -0.05723048f, 0.08867255f, -0.03881575f, 0.03451836f, -0.00915510f, 0.02814517f, 
    -0.10565310f, 0.05146562f, -0.13862896f, -0.03703613f, 0.12988091f, 0.12312508f, -0.06047662f, -0.09609785f, 
    0.07727745f, -0.05574435f, 0.03582234f, -0.01608344f, -0.17002180f, 0.14173110f, -0.11535963f, -0.10968278f, 
    -0.06064298f, -0.00493268f, 0.00318322f, 0.00846351f, -0.10078304f, 0.09102229f, 0.11097254f, 0.14796644f, 
    -0.06402449f, -0.09141165f, 0.04788097f, 0.26033935f, 0.08754323f, -0.08007156f, 0.05003019f, 0.10174072f, 
    0.05895018f, 0.11750289f, -0.01009602f, 0.04760208f, -0.32694641f, 0.08305833f, 0.13923860f, -0.10384034f, 
    0.07557487f, -0.02015332f, 0.00945189f, -0.08706082f, -0.00094864f, -0.06355786f, -0.13561696f, 0.03436308f, 
    0.01777315f, 0.11920659f, 0.12425410f, 0.17858106f, -0.05848901f, 0.13510485f, 0.05683935f, 0.05220785f, 
    0.04944530f, -0.02209069f, 0.02155099f, 0.07639972f, -0.16181090f, 0.08437173f, -0.11321402f, 0.10518056f, 
    -0.06048201f, -0.05603814f, -0.06263961f, -0.04723373f, -0.05292537f, -0.13897143f, 0.11073932f, 0.03800969f, 
    0.11816717f, 0.04952546f, 0.03466795f, -0.29525781f, 0.01863649f, 0.01997862f, -0.07490040f, 0.16389807f, 
    -0.05598140f, -0.04661082f, 0.04662795f, -0.06011257f, 0.09504429f, 0.03666805f, 0.05985216f, 0.09109097f, 
    -0.10431781f, -0.06365525f, 0.11936701f, 0.02319782f, 0.06716324f, -0.06175658f, -0.10183174f, -0.02531353f, 
    0.08449565f, 0.31037560f, -0.01620273f, -0.10252914f, -0.10331248f, -0.06619962f, -0.10464653f, -0.11258889f, 
    -0.09153480f, 0.03123376f, 0.01508037f, 0.01763709f, -0.34713808f, -0.09878580f, -0.02894711f, 0.15073855f, 
    0.06556415f, 0.03937108f, -0.00607210f, -0.01283953f, 0.00823393f, -0.07632855f, 0.02442247f, -0.04498257f, 
    0.12543805f, -0.07720418f, -0.02473198f, -0.14059564f, 0.19677016f, -0.06564026f, 0.04664730f, 0.09389789f, 
    -0.04420151f, -0.00939061f, 0.01015814f, -0.01894867f, -0.01582438f, 0.15754433f, -0.09421252f, -0.07145733f, 
    -0.03542073f, 0.06543269f, 0.05119280f, 0.14255089f, -0.01810642f, 0.10856713f, 0.05508382f, 0.13731267f, 
    -0.09007625f, 0.14260839f, -0.01465489f, 0.15274282f, -0.00980075f, 0.14320870f, 0.00813570f, 0.01685410f, 
    0.04206042f, -0.04017832f, 0.06638781f, -0.00439855f, -0.04677295f, -0.18686001f, 0.11089856f, -0.05729859f, 
    0.05348019f, -0.10918521f, 0.07569918f, -0.02616096f, -0.00272674f, 0.02440487f, 0.06427204f, 0.03960052f, 
    -0.12307053f, 0.02274775f, -0.13461709f, 0.02561373f, -0.01152173f, 0.16782969f, 0.05063621f, 0.02829859f, 
    -0.03380649f, -0.07529431f, -0.04304103f, -0.09370501f, -0.10118832f, -0.01802962f, -0.09750824f, 0.01994682f, 
    -0.05345958f, -0.10673663f, 0.07726794f, -0.07657993f, 0.08705521f, -0.06597188f, 0.08322092f, -0.01340778f, 
    0.22963706f, -0.12539241f, 0.12836160f, 0.04432659f, -0.08874470f, -0.09185894f, 0.14285591f, 0.01372336f, 
    -0.05803262f, 0.13231774f, -0.10002910f, -0.03500013f, 0.29348159f, 0.07043233f, 0.11272214f, 0.00758242f, 
    0.01356057f, -0.00424457f, -0.06243498f, 0.13929324f, 0.09284469f, -0.14463651f, -0.04404138f, -0.03526276f, 
    0.03341315f, -0.00586814f, -0.08780954f, -0.17996700f, -0.07852654f, 0.17437413f, -0.04187740f, 0.06851766f, 
    0.07981212f, -0.16484648f, 0.17115876f, 0.00734434f, 0.36777326f, -0.13264146f, -0.06438569f, 0.15194896f, 
    -0.03852079f, 0.01770880f, 0.06112896f, 0.03187639f, -0.06164824f, 0.04014880f, 0.15915252f, 0.03160609f, 
    -0.03824731f, 0.04829273f, -0.09955573f, -0.02295698f, 0.07819720f, -0.02717946f, 0.00729125f, 0.00580032f, 
    -0.08259899f, 0.06700860f, -0.01489107f, -0.09112792f, 0.03345104f, -0.16440678f, 0.14972852f, 0.03091897f, 
    -0.02433470f, 0.03020045f, 0.05817046f, 0.00415948f, -0.05180186f, 0.04205590f, -0.13093483f, -0.17157710f, 
    0.24756673f, -0.07072826f, -0.00483986f, 0.28578621f, -0.14178750f, 0.04391115f, 0.02798302f, -0.04204099f, 
    0.12146980f, 0.11436220f, 0.04778237f, 0.00029454f, 0.15352651f, 0.02300930f, -0.01151367f, -0.08747155f, 
    0.01777835f, 0.07253741f, -0.02963440f, 0.05952326f, -0.02565327f, 0.04451747f, 0.13593343f, 0.06746110f, 
    -0.03771343f, -0.20602554f, -0.05348960f, 0.13200124f, 0.00380721f, 0.02991948f, 0.08719569f, 0.22266880f, 
    0.01646042f, -0.01686277f, 0.18730226f, 0.06177800f, 0.40384787f, 0.03174422f, -0.08334369f, -0.14877744f, 
    -0.16590150f, -0.00891932f, 0.03658189f, 0.07386690f, 0.02898534f, 0.02425514f, -0.14057899f, 0.10640617f, 
    0.30498591f, 0.16087624f, 0.12476353f, 0.21863733f, 0.06946842f, -0.00424039f, 0.07020190f, -0.04599735f, 
    -0.19442615f, 0.05479201f, -0.02678032f, 0.04177484f, -0.00408352f, 0.26594794f, -0.15190306f, 0.00201471f, 
    -0.12586951f, -0.06419311f, 0.17904137f, 0.15585402f, -0.10549827f, 0.04500643f, 0.18665117f, 0.16897696f, 
    -0.16789092f, -0.05377815f, -0.10154240f, -0.08095231f, -0.02781531f, -0.08082398f, -0.10192841f, -0.01742448f, 
    -0.05954221f, -0.06079413f, -0.01387234f, 0.09471539f, 0.34906456f, 0.09443034f, 0.21132892f, 0.21088535f, 
    -0.07031466f, 0.05608554f, 0.02946820f, 0.23885290f, -0.02576591f, 0.13883010f, 0.07650048f, 0.11669417f, 
    -0.07602595f, -0.11814928f, 0.04908277f, -0.12966065f, -0.11529899f, -0.17025572f, -0.06235033f, -0.02525277f, 
    -0.19554731f, -0.23381056f, -0.15542135f, -0.12336680f, 0.33640939f, 0.10144746f, 0.19385204f, 0.40862325f, 
    0.09274679f, 0.04601759f, -0.04029172f, 0.18048652f, -0.09865677f, 0.03978702f, -0.12902887f, -0.00439253f, 
    0.08134463f, -0.08204475f, -0.13892348f, -0.06393384f, -0.02486463f, -0.13224155f, 0.14487472f, 0.04854601f, 
    0.07902648f, -0.08746683f, 0.09828604f, -0.13502276f, 0.08594280f, -0.05902556f, -0.04231858f, 0.12286748f, 
    -0.13116720f, -0.05857088f, -0.02203001f, 0.03490401f, -0.03346127f, -0.11970010f, -0.16441652f, -0.03021864f, 
    0.04262704f, 0.03849763f, 0.25420290f, 0.30188572f, 0.03814042f, 0.01562440f, 0.00320964f, -0.03629613f, 
    -0.13609226f, 0.11181822f, -0.01721214f, -0.02347002f, -0.24723046f, -0.14967948f, -0.10519323f, -0.13031140f, 
    0.01596748f, -0.03634876f, 0.07167844f, -0.05626485f, 0.00789022f, -0.08729520f, 0.15533559f, -0.18456684f, 
    0.31932867f, -0.24543941f, -0.12517612f, -0.02872071f, 0.00729678f, -0.00385977f, 0.00637550f, -0.04779494f, 
    0.05086152f, 0.01975979f, 0.07015637f, 0.02025133f, -0.13712017f, -0.00982289f, -0.16028756f, 0.03591378f, 
    -0.06733647f, -0.11251950f, -0.12390190f, -0.01840075f, -0.11560728f, -0.00220692f, -0.06853105f, -0.16886076f, 
    0.00084178f, 0.12376043f, 0.19674753f, 0.16806836f, -0.09757781f, 0.00634272f, -0.01140849f, 0.16661566f, 
    -0.17821434f, -0.01353768f, 0.11992312f, 0.05905536f, -0.59971476f, 0.02888995f, 0.12681228f, -0.00071157f, 
    0.08182821f, -0.02623275f, 0.04346825f, 0.02000892f, -0.11827750f, -0.17285085f, 0.18765838f, -0.05002490f, 
    0.15720956f, 0.00855978f, 0.09263164f, 0.01622167f, 0.04451501f, -0.02372275f, 0.07003038f, -0.08975752f, 
    0.19236304f, 0.00761387f, 0.03387350f, -0.03803441f, 0.07858863f, 0.24445565f, 0.27413419f, 0.16772008f, 
    0.11097144f, 0.12681378f, 0.10039160f, 0.03957468f, -0.18970549f, -0.05020532f, -0.09587772f, -0.11483259f, 
    -0.02691606f, 0.03780841f, -0.07569139f, -0.04497114f, -0.03182267f, -0.02096196f, -0.03599912f, 0.04936611f, 
    0.03171721f, -0.06803212f, -0.04937400f, 0.05310997f, 0.02937950f, 0.05493987f, -0.03201317f, 0.01047783f, 
    -0.01845384f, -0.06967258f, 0.02386424f, 0.04790448f, 0.04245155f, -0.06623412f, 0.03551128f, -0.01738827f, 
    0.01925375f, 0.04174373f, 0.02038550f, 0.04401266f, -0.03948370f, -0.05021794f, -0.01855284f, 0.05907878f, 
    0.02333812f, -0.06702777f, -0.00922417f, -0.00122090f, 0.05957736f, -0.08133673f, 0.00625187f, 0.00909933f, 
    -0.05600785f, 0.04222688f, 0.02810177f, 0.00063980f, -0.04197117f, -0.05432095f, 0.06154282f, 0.03873956f, 
    -0.05401572f, 0.04364102f, -0.00556405f, 0.00437379f, 0.02937055f, 0.04690611f, 0.01914728f, 0.00092688f, 
    0.01291313f, -0.03054729f, 0.02747574f, -0.00493409f, 0.01802372f, -0.05453987f, -0.02123924f, -0.03180874f, 
    0.06586371f, -0.02493053f, 0.00777809f, 0.01884247f, -0.05533544f, -0.08727298f, 0.00995882f, -0.04674079f, 
    -0.00660968f, -0.03421249f, 0.02449683f, -0.06259453f, 0.06303802f, 0.00452563f, -0.00141131f, 0.05983727f, 
    0.04181442f, -0.01534809f, -0.08289946f, 0.02918122f, -0.05616022f, 0.04343141f, -0.01527554f, -0.03894042f, 
    0.05783455f, -0.00142480f, 0.00982931f, -0.06547428f, -0.07910907f, -0.03834745f, -0.00074210f, 0.05502702f, 
    0.04312995f, -0.03162211f, -0.07879907f, -0.06644791f, -0.01681357f, -0.06687567f, -0.05680995f, -0.03819422f, 
    -0.07252019f, -0.02337901f, 0.05427421f, 0.00152017f, 0.00835838f, -0.04222113f, 0.02257344f, 0.04316816f, 
    0.02470859f, 0.05626411f, 0.02491444f, -0.08311217f, -0.08086128f, -0.04991604f, 0.03021666f, -0.01374993f, 
    -0.02914528f, 0.03175433f, -0.00570152f, 0.04436979f, 0.00920183f, 0.03240442f, 0.03580580f, 0.05365652f, 
    -0.03360347f, 0.02971255f, 0.01993276f, 0.00488990f, -0.08049621f, 0.00813980f, -0.02211097f, -0.06327986f, 
    0.05889174f, -0.01432546f, 0.00352367f, 0.04042734f, -0.06759022f, 0.04035687f, -0.06118780f, -0.07754365f, 
    -0.03102095f, 0.00018255f, -0.07311019f, 0.00562098f, 0.05035944f, 0.01679773f, -0.06295061f, -0.04660301f, 
    0.01805247f, 0.02199005f, -0.04132289f, 0.00487964f, -0.06306557f, -0.04438144f, 0.00888432f, 0.04426372f, 
    -0.03702879f, -0.07786998f, -0.00388750f, -0.07496236f, -0.01225198f, -0.06573778f, -0.07231149f, -0.07242025f, 
    -0.07464472f, -0.03397417f, 0.02081645f, -0.04745138f, 0.02791491f, 0.01591594f, 0.03393413f, 0.04075750f, 
    -0.03815129f, -0.01159068f, -0.04170845f, -0.05959753f, 0.00987815f, 0.05348854f, 0.02966784f, 0.04761197f, 
    -0.02693230f, 0.02254004f, -0.02712806f, -0.00910677f, 0.01689546f, 0.00216771f, -0.04394259f, -0.00137864f, 
    -0.00235624f, -0.06873520f, -0.03705606f, -0.01512570f, -0.07971577f, -0.03321500f, 0.01895085f, 0.03340548f, 
    -0.07465824f, 0.04389567f, 0.04667056f, -0.02629231f, -0.04806991f, -0.01649561f, -0.03436556f, -0.03074850f, 
    -0.02798108f, -0.04001091f, -0.02855072f, -0.06087953f, -0.05274683f, 0.05571232f, -0.06260465f, 0.05807782f, 
    0.03501245f, -0.00761278f, -0.06661499f, -0.03587030f, -0.02126230f, 0.01697220f, 0.01613058f, 0.01800554f, 
    0.01399291f, -0.01016817f, -0.01288472f, 0.03693489f, -0.00653045f, -0.00990535f, 0.05515647f, -0.01876847f, 
    -0.03643949f, -0.01739283f, -0.02829293f, 0.04277210f, 0.03091019f, 0.04484789f, -0.07137116f, -0.08456773f, 
    -0.03480653f, -0.08007263f, 0.00503506f, -0.07489102f, 0.06142231f, 0.01521195f, -0.06750785f, -0.06357367f, 
    -0.06581549f, 0.01472552f, 0.05252009f, -0.04116093f, -0.07167933f, 0.04201124f, -0.00632227f, 0.06040520f, 
    -0.01885819f, 0.01414000f, -0.04350915f, 0.02093296f, -0.01080525f, 0.05872919f, -0.01651804f, -0.03818952f, 
    0.03379139f, 0.01633946f, 0.01810343f, -0.03227630f, -0.01639024f, 0.04066259f, -0.03725125f, -0.05499153f, 
    0.05504447f, -0.02714068f, 0.02661113f, -0.05290738f, 0.01214548f, -0.00772109f, -0.06387343f, 0.00980598f, 
    -0.04846202f, -0.00362822f, 0.06705690f, 0.01383407f, 0.03486241f, 0.05802901f, -0.05358177f, -0.07346460f, 
    0.05144825f, 0.05347451f, -0.05533223f, -0.04139803f, -0.07767999f, 0.01253755f, -0.01215404f, -0.06165434f, 
    0.01253197f, 0.06610176f, -0.05509746f, 0.04066023f, -0.06253229f, -0.03570896f, 0.02376615f, -0.05038802f, 
    -0.06114799f, 0.01645556f, -0.05841562f, 0.04334854f, 0.05205872f, -0.03627284f, -0.03485572f, -0.05968626f, 
    0.03654223f, -0.02569014f, 0.05959080f, 0.06079815f, -0.06975123f, 0.00523675f, 0.01374535f, -0.02151797f, 
    -0.05212070f, -0.04251398f, 0.00059388f, -0.01268960f, -0.05189913f, 0.06017160f, 0.05791486f, -0.01127644f, 
    0.05924840f, -0.01265741f, -0.06967648f, -0.04595900f, 0.00462143f, 0.04392184f, 0.02245782f, 0.07747632f, 
    0.02811171f, 0.05882103f, 0.00038203f, -0.01902342f, 0.05221684f, -0.07514784f, -0.07244123f, -0.05280020f, 
    -0.05497035f, 0.03608721f, -0.04296114f, -0.03901968f, 0.03705447f, 0.04570833f, 0.00274562f, -0.05329183f, 
    0.04435711f, -0.06070223f, 0.04390676f, -0.05937610f, -0.01509792f, 0.01708925f, 0.01541946f, -0.00447372f, 
    -0.06839161f, 0.00249039f, -0.00845664f, 0.03314710f, 0.04254796f, -0.01789582f, 0.06916426f, 0.03817032f, 
    -0.03002598f, 0.03590447f, -0.07809755f, -0.07814971f, -0.01068095f, -0.00150988f, -0.06085177f, -0.04783683f, 
    0.04518856f, -0.03625204f, -0.02245098f, -0.04316304f, -0.05838877f, -0.03139256f, 0.02167361f, -0.03936810f, 
    -0.18265222f, 0.14944381f, -0.00134891f, -0.06431673f, -0.00411906f, 0.13134518f, 0.01004836f, -0.11333027f, 
    0.08948911f, -0.00110037f, 0.04470868f, -0.01947014f, -0.30849832f, -0.16759303f, -0.03779402f, 0.16668299f, 
    0.04759972f, 0.07419524f, -0.09194827f, -0.00445868f, -0.04636810f, -0.09621707f, 0.04230470f, -0.15331316f, 
    0.06103487f, 0.12246291f, 0.03087671f, -0.14557628f, -0.02597868f, -0.05471306f, -0.08901596f, 0.01599944f, 
    0.05280100f, 0.10386198f, -0.02659462f, -0.02988502f, -0.02014906f, 0.39480814f, 0.13809419f, 0.14882535f, 
    0.01750732f, 0.02822035f, -0.02931754f, 0.03953254f, 0.09018679f, 0.02755284f, -0.15409040f, -0.04848686f, 
    0.33577952f, -0.22990316f, -0.02727435f, 0.02397455f, 0.00234177f, 0.00952488f, -0.01633514f, -0.15142716f, 
    0.08022760f, -0.05456405f, 0.09425116f, 0.04039237f, 0.37790859f, 0.06809554f, -0.02431932f, 0.17579384f, 
    0.12244507f, -0.06847694f, 0.10415285f, -0.02672404f, -0.04510079f, 0.00395351f, 0.02456295f, -0.06047168f, 
    -0.15778126f, 0.10697221f, 0.14530261f, -0.00975644f, 0.09805995f, 0.03786639f, 0.01882176f, -0.04337503f, 
    0.02932850f, 0.02496850f, -0.06649987f, 0.09850165f, -0.56886858f, -0.08616767f, -0.28742912f, -0.08477705f, 
    0.20065606f, -0.07080921f, -0.04248470f, -0.05191292f, -0.08792417f, 0.12521027f, 0.03097479f, -0.03374572f, 
    -0.04576577f, -0.02716194f, 0.04191022f, 0.04305467f, 0.03064569f, -0.08200666f, -0.16993123f, -0.02490762f, 
    0.08468170f, 0.03573572f, -0.10160532f, 0.03749906f, 0.01709864f, 0.04806010f, 0.03377687f, -0.04460819f, 
    0.10106598f, -0.04532020f, -0.15101695f, -0.05741853f, -0.04937924f, -0.01559877f, -0.05108645f, 0.02907324f, 
    0.07750567f, -0.18945566f, 0.19549614f, -0.16332990f, 0.08372410f, -0.02487464f, 0.06738083f, 0.03304198f, 
    -0.06967934f, -0.01477956f, -0.01253806f, 0.09207539f, 0.03596368f, 0.25672126f, -0.11601817f, -0.20852120f, 
    0.09497229f, -0.18977527f, 0.00720457f, 0.01966525f, 0.04009081f, -0.02098796f, 0.09882187f, -0.00262041f, 
    0.26719609f, 0.08358040f, -0.08214018f, -0.14223939f, 0.01063974f, 0.01746544f, -0.01218946f, 0.05386754f, 
    0.02376617f, 0.04854042f, 0.10921246f, -0.07101575f, 0.30706513f, -0.08185446f, -0.03841002f, 0.00722740f, 
    0.09556261f, -0.00201223f, -0.02034985f, 0.03299767f, -0.00531943f, -0.04276747f, -0.08721272f, 0.03251771f, 
    -0.11039209f, 0.16886880f, -0.01539954f, -0.03563211f, 0.01690968f, -0.03276281f, 0.08451250f, 0.00590725f, 
    0.03130466f, -0.01593290f, -0.05096438f, -0.08248349f, 0.18512963f, 0.03625155f, 0.12865204f, 0.21261983f, 
    0.06241624f, 0.02334976f, -0.01188681f, 0.17500369f, 0.03105830f, 0.03120429f, 0.04724164f, -0.00034844f, 
    0.06425012f, 0.18565197f, -0.13435152f, -0.05288345f, 0.07590734f, 0.01450517f, -0.02241345f, 0.08813086f, 
    0.05952509f, 0.04941630f, 0.06779808f, -0.10327955f, -0.06914702f, 0.14744052f, 0.07417942f, 0.02084238f, 
    0.10139070f, 0.01857805f, -0.03461190f, 0.01946063f, 0.04531136f, 0.08306929f, 0.16139370f, 0.21631409f, 
    0.02700550f, 0.17273098f, -0.03177212f, -0.09034294f, 0.10408521f, 0.07656078f, 0.12529095f, 0.04163597f, 
    0.11937680f, 0.04380275f, -0.00626865f, -0.12701781f, -0.10098507f, 0.23162283f, -0.01405808f, 0.07507405f, 
    -0.00891000f, 0.06639044f, 0.11728405f, -0.03221072f, 0.14710672f, 0.02524280f, 0.15283644f, -0.09154024f, 
    0.06085909f, -0.02153440f, -0.05573688f, 0.27757680f, 0.00721351f, 0.00952907f, 0.03998905f, 0.05824845f, 
    -0.05126650f, 0.00673859f, -0.07446481f, -0.08519594f, 0.04215822f, -0.04981244f, 0.31564039f, 0.02423114f, 
    -0.03857256f, -0.08561958f, 0.07885958f, -0.10622498f, 0.00712238f, 0.00206128f, -0.01924322f, 0.04011075f, 
    -0.14639880f, 0.19437647f, -0.15138429f, 0.22086422f, 0.04420221f, 0.04134851f, 0.08246045f, 0.10867546f, 
    0.05112526f, 0.06784706f, -0.01369074f, -0.02368580f, -0.03122220f, 0.02784211f, -0.06314306f, -0.25166130f, 
    0.11846375f, 0.00535267f, -0.01837552f, -0.00347655f, 0.06624078f, -0.06394778f, 0.09586597f, -0.14996265f, 
    0.30977669f, 0.12962313f, -0.04593452f, 0.02652344f, -0.10054909f, 0.03912311f, 0.03330335f, 0.03799628f, 
    0.05222273f, -0.13778336f, 0.01123718f, 0.04652333f, 0.09669478f, -0.33850226f, -0.07008077f, -0.02580039f, 
    -0.07601082f, -0.10929225f, 0.01654190f, -0.03130206f, 0.01332217f, 0.07989252f, 0.03901215f, -0.03154474f, 
    -0.09306405f, -0.10862481f, -0.16915850f, 0.05427431f, 0.10641397f, 0.01211970f, -0.08746839f, 0.00395145f, 
    0.02509364f, 0.11890224f, -0.07144361f, 0.00648397f, 0.31043437f, 0.00176751f, -0.00744806f, 0.12191691f, 
    0.04045985f, -0.04185122f, 0.05480475f, 0.00841302f, -0.10374313f, 0.03286942f, -0.15039307f, -0.15003465f, 
    0.43132883f, -0.06484056f, 0.09802639f, -0.11704167f, 0.03369673f, 0.01468239f, 0.07448015f, -0.10715750f, 
    0.09878736f, 0.18342367f, 0.09612893f, 0.01225613f, 0.20349713f, -0.10804985f, -0.15706024f, -0.02245010f, 
    -0.14162950f, -0.01949231f, -0.04850585f, 0.16174130f, -0.05139253f, 0.02315207f, 0.04449771f, 0.10042243f, 
    -0.36804813f, -0.16587064f, -0.22162291f, -0.00977787f, -0.09968600f, 0.07704153f, 0.17627518f, 0.09401403f, 
    0.04586999f, 0.02701319f, 0.15437432f, 0.00185360f, 0.31896365f, 0.11264553f, 0.06439559f, -0.00329681f, 
    -0.23006022f, 0.10319132f, 0.07635738f, -0.02807801f, -0.04478125f, 0.11188404f, -0.06486990f, 0.13230975f, 
    -0.03851037f, 0.05959004f, -0.00336274f, -0.05625558f, -0.05459918f, 0.02270984f, 0.01956203f, -0.00190819f, 
    -0.06343835f, -0.00223061f, 0.00195527f, -0.00461356f, -0.07385612f, 0.04596283f, -0.08071366f, 0.00407080f, 
    -0.05374276f, 0.06334434f, -0.07744821f, -0.04263213f, 0.01841924f, -0.04063598f, 0.03606375f, -0.01981381f, 
    -0.00236992f, -0.04482232f, -0.05511195f, 0.02707473f, 0.05076651f, 0.03237799f, -0.07460844f, 0.04671297f, 
    -0.04891084f, -0.02331810f, 0.01169176f, -0.01966530f, 0.01164005f, -0.03526352f, -0.04180932f, 0.06958255f, 
    0.04750638f, -0.03171414f, -0.00051680f, 0.03747805f, 0.05578381f, -0.00088386f, -0.02589471f, -0.01033102f, 
    -0.00557638f, -0.00285320f, -0.06267893f, 0.04833850f, -0.03992379f, 0.01958011f, -0.01242667f, 0.03895982f, 
    0.05020920f, 0.00474843f, -0.06877811f, 0.03185371f, 0.00380032f, 0.02708649f, -0.03046557f, 0.05162565f, 
    0.01238031f, -0.02725267f, -0.06963369f, -0.06661023f, 0.01450693f, -0.04998472f, -0.02695685f, -0.07975078f, 
    0.02180679f, -0.05738205f, -0.07337737f, -0.06925590f, 0.01894139f, -0.08353241f, -0.06592565f, -0.00463604f, 
    -0.04595209f, 0.02028661f, -0.03053178f, 0.06477251f, -0.00425208f, -0.04249278f, -0.03693359f, -0.02072629f, 
    -0.04363596f, 0.05023561f, 0.00702972f, -0.02381354f, -0.01515117f, 0.05077082f, -0.04435978f, 0.04593943f, 
    0.02880094f, -0.04919335f, -0.06510524f, -0.01004835f, -0.01581602f, 0.02488852f, -0.01111647f, -0.05184126f, 
    -0.05474297f, -0.00963712f, 0.02417744f, 0.06688091f, 0.02933612f, -0.08755127f, -0.05736832f, -0.00172151f, 
    0.02152868f, -0.01322231f, -0.03505566f, 0.05117686f, 0.02518684f, -0.05496154f, -0.04854323f, -0.06192303f, 
    -0.07578158f, 0.06373404f, 0.01573918f, -0.08146140f, -0.06037493f, -0.01223360f, -0.04983323f, 0.03945999f, 
    0.02865675f, -0.03561379f, -0.07195592f, -0.00304285f, -0.00824054f, -0.05565428f, 0.03406818f, 0.05066433f, 
    -0.03153972f, -0.02972143f, -0.05641064f, 0.05374111f, 0.02771114f, 0.06410028f, 0.06614522f, -0.03930840f, 
    0.05072095f, -0.01719014f, -0.07754819f, -0.01021224f, -0.01723259f, -0.07844156f, -0.03275649f, -0.01512140f, 
    0.00467431f, -0.06233471f, 0.02404296f, 0.03512497f, -0.04882121f, -0.06570673f, 0.01899959f, 0.04327801f, 
    -0.02443456f, -0.04517546f, 0.01265122f, 0.01675731f, -0.03146161f, -0.04260877f, -0.01644888f, 0.05771019f, 
    -0.05421243f, -0.03546879f, 0.00534415f, -0.01680653f, 0.06863748f, 0.00356415f, 0.00047287f, 0.02449902f, 
    -0.06887329f, -0.02589229f, 0.05573496f, 0.01830401f, 0.04536285f, 0.00132201f, 0.02800468f, -0.04088306f, 
    -0.07970941f, 0.02911402f, 0.06901553f, 0.05432094f, 0.05111351f, 0.05098405f, 0.02138221f, 0.03670714f, 
    0.03568110f, -0.32033911f, 0.21268627f, 0.17967555f, 0.02611176f, 0.04042893f, 0.13385922f, -0.05299009f, 
    -0.01423909f, 0.05759076f, 0.01997094f, 0.06071765f, 0.15730277f, -0.29136303f, 0.15446971f, 0.08729143f, 
    0.00408076f, -0.02553774f, 0.13905220f, 0.07793182f, 0.08978128f, 0.01201151f, -0.18709305f, -0.16062219f, 
    0.15727180f, -0.08436250f, 0.25444159f, 0.21987991f, 0.09062465f, 0.04699381f, -0.08999527f, -0.00700341f, 
    -0.06136171f, 0.03457217f, -0.06121266f, 0.15403043f, -0.04365417f, -0.20025603f, -0.08690147f, -0.15197790f, 
    0.08941817f, -0.01731089f, 0.09010199f, -0.06993576f, -0.03260220f, -0.15148892f, -0.01382211f, 0.05849566f, 
    -0.15648253f, 0.05945702f, -0.08578117f, -0.20896478f, -0.00500039f, -0.01721190f, 0.07033227f, 0.01417148f, 
    0.08720906f, 0.12940124f, 0.10373212f, 0.13386755f, -0.07972416f, -0.00879279f, -0.08578487f, -0.07346602f, 
    0.07814498f, 0.05893135f, -0.15681267f, 0.06388669f, 0.11258987f, -0.09548697f, -0.03720961f, -0.12501253f, 
    -0.00514391f, -0.38373408f, 0.01153562f, -0.05687047f, 0.13863356f, -0.02116825f, 0.06141865f, 0.05258714f, 
    0.07358254f, -0.03179710f, 0.04425105f, 0.04759445f, -0.04068524f, 0.13182576f, 0.10092626f, -0.08558647f, 
    -0.12761375f, -0.02108011f, 0.02911234f, 0.00662602f, -0.01071529f, 0.12195284f, -0.06269813f, 0.27197754f, 
    -0.24986251f, -0.11252324f, 0.01495793f, 0.16048916f, 0.13840246f, 0.01711403f, 0.11400653f, -0.00848196f, 
    -0.04023857f, 0.16719046f, 0.06233446f, 0.01543092f, -0.24230339f, 0.31014648f, -0.01028324f, 0.01004601f, 
    0.05256115f, 0.02021381f, 0.11948495f, 0.15672949f, 0.12192893f, 0.00825049f, 0.03294154f, 0.09395044f, 
    -0.31116539f, -0.01301896f, 0.28996372f, 0.16587304f, 0.03101105f, -0.08255749f, 0.07874160f, -0.00057769f, 
    0.08017524f, 0.03236796f, 0.09832915f, 0.11677179f, -0.19683559f, 0.10559192f, -0.02348347f, -0.06785342f, 
    0.00223430f, 0.11757329f, 0.06749693f, -0.04559262f, -0.02473169f, -0.02579648f, 0.09805656f, 0.15148807f, 
    -0.49067691f, 0.19107437f, -0.11272346f, 0.15434465f, -0.00596631f, 0.03555650f, -0.09976701f, -0.02871914f, 
    -0.09541342f, -0.19871634f, -0.01943874f, 0.01512028f, 0.02912872f, 0.12424684f, -0.00989568f, -0.03570925f, 
    0.04371919f, 0.10447930f, 0.07492828f, -0.14235955f, 0.02270743f, -0.00092625f, -0.06399259f, 0.03192102f, 
    0.10033095f, 0.09450053f, 0.04822839f, -0.06374147f, 0.02702802f, -0.05961945f, 0.05396210f, -0.11738337f, 
    0.02982293f, 0.05324927f, -0.09393796f, 0.05468309f, -0.06360218f, -0.04708314f, -0.13296075f, -0.00750630f, 
    0.11976973f, 0.07645936f, -0.00026858f, 0.01553124f, -0.02362694f, -0.00786479f, 0.10228126f, -0.00730596f, 
    -0.01807931f, -0.00756468f, 0.05176539f, -0.23728366f, -0.05310404f, -0.11237230f, -0.22205488f, 0.00600980f, 
    0.10087468f, 0.08591551f, 0.00343179f, 0.08951726f, -0.06584351f, -0.15544681f, 0.15533604f, 0.03781079f, 
    -0.01124981f, -0.00390190f, -0.04309259f, -0.18765591f, 0.04385231f, -0.15381490f, -0.06336355f, 0.06829334f, 
    0.23446742f, -0.04551519f, -0.22964279f, -0.24399450f, 0.18383518f, -0.02277837f, -0.08396496f, -0.01663087f, 
    -0.05226967f, -0.02049479f, 0.04969552f, 0.07462518f, -0.01468724f, 0.24130890f, -0.08932179f, 0.21062009f, 
    -0.07398508f, 0.04173420f, 0.07775266f, 0.00522446f, 0.01552960f, 0.07968903f, -0.03722966f, -0.04085927f, 
    0.28471288f, -0.01908713f, 0.16346972f, 0.17575854f, -0.02975970f, -0.02470829f, 0.07693949f, -0.03967560f, 
    -0.06072840f, 0.04042191f, 0.08738920f, 0.07797876f, 0.21327317f, 0.14769912f, 0.13449764f, 0.18137236f, 
    -0.02830273f, -0.08477279f, 0.03344904f, 0.07880527f, 0.00061599f, 0.03980343f, -0.16448717f, -0.07408237f, 
    0.15569030f, 0.11632480f, 0.11843012f, 0.02694990f, 0.08746288f, 0.05066300f, 0.01542385f, 0.06747730f, 
    -0.04138558f, -0.14513463f, -0.06251244f, 0.05038675f, -0.07562523f, 0.03168540f, -0.16634817f, 0.19611020f, 
    0.08774510f, 0.04022834f, -0.01243263f, -0.02993580f, -0.14323758f, 0.06433456f, 0.12998344f, 0.14902107f, 
    -0.02270283f, 0.10945502f, 0.02575592f, 0.05891845f, -0.03514239f, -0.08944458f, -0.08936239f, 0.04090787f, 
    -0.04894973f, -0.08820639f, -0.09432083f, -0.05432929f, -0.24495350f, -0.13261150f, -0.02555096f, -0.01602831f, 
    -0.13874568f, 0.09305223f, -0.08427469f, -0.09956303f, 0.03341528f, 0.07103420f, -0.18208128f, 0.07992028f, 
    0.02674451f, 0.13443591f, -0.18275148f, -0.12524022f, 0.00013237f, 0.08347900f, 0.11896206f, 0.08625376f, 
    0.08429115f, -0.13966878f, -0.05687396f, 0.03433684f, -0.09902215f, -0.09832799f, 0.03788392f, 0.23648997f, 
    0.02250695f, -0.02420388f, -0.06861769f, -0.03033354f, 0.06185627f, -0.00653041f, 0.05423242f, 0.11002335f, 
    0.24662261f, -0.05925506f, 0.02465013f, -0.19961910f, -0.00791615f, 0.02715075f, 0.02293020f, 0.02441679f, 
    -0.02275933f, -0.07079510f, -0.03464130f, -0.13593899f, -0.01016861f, -0.00048807f, -0.13460301f, 0.00130944f, 
    0.01850282f, 0.05577850f, 0.11170892f, 0.14806040f, 0.19704635f, 0.01147759f, 0.01238845f, -0.02731028f, 
    0.26209030f, 0.19710486f, -0.04107112f, -0.18566242f, -0.05241212f, -0.07295019f, -0.03430230f, -0.04880035f, 
    -0.13820285f, 0.08261791f, 0.14135739f, -0.03640786f, -0.08759567f, 0.00493438f, 0.21142824f, 0.28971705f, 
    -0.02892274f, -0.04456118f, -0.03792948f, 0.12141740f, -0.02173112f, -0.16829924f, 0.00600111f, -0.13450114f, 
    0.01498455f, -0.25058654f, 0.15363035f, 0.21234706f, -0.00250298f, 0.01502438f, 0.13623874f, -0.12123607f, 
    -0.05365992f, -0.03298714f, 0.08154629f, 0.00869294f, -0.18772690f, -0.35784972f, 0.18787788f, 0.35620967f, 
    -0.15523946f, 0.03586983f, 0.20251049f, -0.02992650f, -0.13145392f, 0.03155605f, -0.00995752f, -0.03842466f, 
    0.16199136f, 0.04094512f, 0.23891187f, -0.01270464f, 0.10196443f, 0.03926424f, -0.08161426f, 0.07739724f, 
    0.07465093f, 0.01304132f, 0.05223633f, 0.05620011f, -0.11720461f, 0.02195840f, 0.01266008f, 0.15500696f, 
    0.08062071f, -0.06659364f, -0.00452233f, -0.01318100f, -0.02368581f, 0.02031309f, -0.10331756f, 0.08013676f, 
    0.16176118f, -0.19142483f, -0.17809393f, -0.08169612f, -0.03922750f, -0.02989881f, 0.02710776f, 0.03255855f, 
    0.05550690f, 0.06096391f, 0.07226657f, 0.04738482f, 0.22377969f, 0.00155327f, -0.16453339f, 0.10002282f, 
    0.12186660f, 0.06101805f, -0.07523878f, 0.04462818f, -0.09965944f, -0.02617827f, -0.00579049f, -0.04103804f, 
    -0.05687408f, -0.19113491f, 0.03931545f, -0.07235661f, 0.20580368f, 0.01099188f, 0.08121814f, 0.03453625f, 
    0.11742578f, -0.06060944f, 0.03196088f, -0.02383089f, -0.22578484f, 0.06044946f, -0.08544795f, -0.50778621f, 
    -0.02610420f, -0.00888092f, 0.03031586f, 0.00607365f, -0.09376751f, 0.17969131f, 0.03738725f, 0.10165912f, 
    -0.26500046f, -0.16580194f, 0.18415284f, 0.22356552f, 0.00833676f, 0.08601168f, 0.02421034f, 0.01288333f, 
    -0.00715120f, 0.04485424f, 0.17910838f, 0.02282856f, -0.08377792f, 0.20319700f, -0.14334816f, -0.05336411f, 
    0.22864020f, 0.07379352f, 0.06368219f, -0.01055242f, 0.04500435f, -0.00107043f, -0.02506642f, 0.14749914f, 
    -0.27447423f, -0.10696729f, 0.42177746f, 0.12940060f, -0.09700986f, -0.00980147f, 0.01084264f, 0.07203727f, 
    -0.08073688f, -0.10189050f, -0.02337589f, 0.05777021f, -0.14124033f, 0.04927296f, 0.01622350f, -0.03914369f, 
    0.05593241f, -0.02192153f, -0.04853026f, 0.01176549f, 0.05017484f, -0.05739670f, 0.11149184f, 0.04426137f, 
    0.18900111f, 0.14826891f, -0.12443805f, -0.03661251f, 0.00084803f, -0.06717882f, -0.03906785f, 0.12135514f, 
    0.00968992f, -0.04667307f, 0.06325690f, 0.04789115f, 0.18401694f, 0.08676209f, 0.08387034f, 0.00051897f, 
    0.03655114f, -0.01687020f, 0.01463999f, -0.18113589f, -0.07041157f, -0.08805548f, 0.05395233f, 0.01502131f, 
    -0.11002417f, 0.27394637f, 0.06149987f, -0.17948231f, 0.05027855f, -0.02334519f, 0.06824844f, -0.01035243f, 
    -0.04917815f, -0.03604218f, -0.04386671f, 0.01424050f, 0.00211083f, 0.06597788f, -0.08853560f, 0.04281088f, 
    0.11828039f, -0.01699177f, 0.01672554f, 0.05476172f, 0.00343278f, -0.04177706f, 0.07379222f, 0.03881519f, 
    -0.03548442f, 0.02693839f, 0.00472030f, 0.04502638f, -0.02283349f, 0.02755409f, 0.06013067f, -0.03991823f, 
    -0.06904782f, 0.01367215f, 0.01625695f, -0.00204679f, 0.01515006f, 0.03314818f, 0.01917619f, -0.05822015f, 
    -0.07908474f, 0.01373112f, 0.03538927f, -0.06185338f, 0.03705664f, -0.01159332f, -0.07789701f, -0.06238005f, 
    0.02614204f, 0.04419212f, -0.05550167f, -0.00975579f, -0.06938788f, 0.00733686f, -0.03404510f, -0.00950238f, 
    -0.03721880f, 0.03851026f, -0.00737127f, -0.03477063f, 0.04244317f, 0.04502932f, -0.05671154f, -0.04392670f, 
    -0.03101853f, -0.00539083f, -0.04012999f, 0.06139506f, -0.03105903f, 0.02568997f, 0.04901300f, -0.02906634f, 
    -0.03440688f, -0.04214045f, -0.00000246f, 0.06331273f, -0.00370269f, -0.03974529f, 0.00112919f, -0.00821777f, 
    -0.03327261f, 0.04693242f, 0.00529393f, 0.01947086f, -0.04707158f, -0.07781813f, 0.01562343f, 0.05488750f, 
    -0.02556624f, 0.02584069f, -0.01788939f, -0.06778102f, -0.00689587f, -0.06466372f, 0.01113531f, -0.06088584f, 
    0.00661290f, -0.07727306f, 0.04239184f, 0.02240596f, 0.03660128f, -0.04468703f, -0.06269635f, -0.06854826f, 
    0.02861978f, -0.01852898f, -0.05488585f, -0.08037640f, -0.06758604f, -0.02957119f, -0.03446669f, 0.06281000f, 
    -0.00709400f, -0.04448806f, 0.00677559f, -0.02049252f, -0.00065943f, -0.08348526f, 0.04956656f, 0.02702421f, 
    0.04486373f, -0.07860848f, 0.04724408f, 0.01038154f, -0.08188004f, -0.05001381f, -0.06612419f, 0.00469394f, 
    -0.05955663f, -0.06230056f, 0.03625621f, 0.06113434f, 0.03754919f, -0.06231587f, -0.03861880f, -0.04256730f, 
    0.00062290f, 0.01620686f, -0.06890412f, -0.03008082f, 0.01585066f, -0.01860337f, -0.01327475f, 0.04331043f, 
    -0.08026882f, -0.04645903f, -0.03971352f, 0.05023058f, -0.01333797f, 0.02872966f, -0.02297519f, -0.08998922f, 
    0.05814704f, 0.07124767f, -0.08413031f, 0.04496568f, 0.02494073f, -0.05607815f, -0.03207530f, 0.06553714f, 
    -0.00224372f, 0.00600817f, -0.02080174f, 0.02721516f, 0.04030351f, -0.00007519f, -0.07659823f, 0.00559854f, 
    0.03242468f, 0.00312108f, -0.05059919f, -0.07836102f, -0.00130363f, -0.07287504f, -0.06576325f, 0.03764351f, 
    -0.04650994f, 0.00384932f, -0.06319553f, -0.07614700f, 0.00737607f, -0.04216761f, -0.01935800f, -0.00051938f, 
    -0.06945626f, 0.05602888f, 0.06493381f, 0.02164726f, 0.05333134f, -0.04335215f, -0.05667937f, -0.00990999f, 
    -0.02543643f, -0.02525939f, 0.04478193f, -0.01623377f, -0.03365762f, 0.02373276f, -0.01756590f, -0.02841240f, 
    0.03295774f, -0.00189191f, -0.03086302f, -0.09188449f, 0.05499093f, 0.03094018f, 0.02238580f, 0.02631300f, 
    -0.00792809f, -0.04577159f, 0.04588842f, -0.02475250f, 0.05349274f, -0.02343444f, -0.08735017f, 0.00560465f, 
    0.05436336f, -0.05135875f, -0.13489337f, -0.01032799f, 0.01661212f, -0.01801837f, 0.12402748f, -0.01954496f, 
    -0.01043017f, -0.04443203f, -0.05364669f, -0.09276073f, 0.24812397f, -0.29156196f, -0.11288071f, -0.05931279f, 
    -0.07037058f, 0.10232183f, -0.06121927f, 0.00813922f, -0.09757202f, -0.04048131f, -0.00417731f, 0.03937668f, 
    0.06024849f, -0.22791034f, 0.18816645f, 0.06106870f, 0.07083771f, -0.07717033f, -0.07113049f, 0.02583316f, 
    -0.03141844f, 0.04332064f, -0.03503908f, 0.12771444f, -0.14347737f, 0.21140243f, 0.04942320f, 0.10691098f, 
    -0.02512239f, 0.03939321f, 0.06015876f, 0.03612228f, -0.04263947f, 0.00825434f, -0.10418750f, -0.03526432f, 
    0.12105909f, 0.02892424f, -0.13975808f, 0.05001670f, 0.05608825f, -0.07910479f, -0.01560996f, -0.07062331f, 
    0.02345061f, 0.10547651f, 0.01592189f, 0.11233942f, 0.05724609f, 0.01868257f, -0.08912189f, 0.01075402f, 
    -0.05706153f, -0.14163980f, 0.06807159f, -0.00299296f, -0.00392165f, 0.05604315f, -0.00323015f, -0.05364427f, 
    -0.17812592f, -0.09296402f, 0.16309814f, 0.09797555f, 0.14914337f, 0.10893895f, 0.11057438f, 0.02479511f, 
    -0.06360298f, -0.02327508f, -0.02926825f, 0.00793799f, -0.33879170f, -0.10936419f, -0.07185430f, -0.00974017f, 
    0.22663568f, -0.01878990f, 0.01025151f, -0.09582542f, 0.04463456f, 0.06516995f, -0.00964983f, -0.03635274f, 
    -0.01646020f, -0.01067345f, 0.02039579f, -0.19799235f, 0.02583292f, 0.04832372f, 0.00246400f, -0.03054156f, 
    0.08030127f, 0.08523153f, 0.00609630f, 0.03017260f, -0.13705878f, -0.04925051f, 0.03256042f, -0.01166889f, 
    0.09826855f, -0.12360949f, -0.09682094f, 0.02191779f, 0.02423112f, 0.04311315f, 0.09423900f, 0.09031154f, 
    -0.40980515f, -0.05386838f, 0.28677711f, -0.08645258f, 0.20370239f, 0.09464365f, 0.08297337f, -0.02944508f, 
    -0.02430460f, 0.01916366f, -0.04232451f, 0.09011995f, 0.00372824f, 0.29046628f, -0.11226150f, -0.25348851f, 
    0.12382564f, 0.02544703f, 0.02428754f, 0.04131599f, 0.03567806f, -0.02360394f, 0.08913641f, 0.03715076f, 
    0.12846917f, -0.02655333f, -0.00172328f, -0.00861749f, 0.07745966f, 0.05240534f, -0.00649882f, -0.01878411f, 
    -0.06331434f, 0.08623499f, -0.07123424f, 0.01399126f, 0.35811847f, 0.03109894f, -0.16290271f, -0.00969750f, 
    -0.00856006f, -0.02367280f, -0.00735323f, 0.09334828f, 0.06671193f, -0.02968875f, 0.00479242f, 0.05658235f, 
    -0.08622098f, -0.20902660f, -0.09864374f, 0.01414528f, 0.05580948f, 0.02008968f, 0.10055789f, 0.12178152f, 
    0.02615907f, -0.02047056f, 0.00550979f, 0.16465645f, 0.25871721f, 0.17047592f, 0.08126046f, 0.12404974f, 
    -0.02154873f, -0.05266637f, 0.06658891f, 0.03111961f, -0.03556151f, 0.00516867f, -0.02579836f, 0.00767533f, 
    0.00763140f, 0.01839337f, -0.06518926f, 0.04854223f, -0.09668397f, 0.05666188f, -0.12345155f, -0.05822427f, 
    0.07483765f, -0.01280756f, 0.05354756f, 0.03888980f, -0.10678634f, 0.04156860f, 0.22886370f, 0.44164947f, 
    -0.08038163f, -0.04214369f, 0.10217373f, 0.04304833f, -0.08913890f, 0.02493190f, 0.03926405f, 0.10414086f, 
    0.14180668f, 0.29432675f, 0.12985459f, -0.18425491f, 0.10692145f, 0.15695119f, -0.00322044f, 0.03865677f, 
    0.10790668f, -0.04519745f, 0.09838867f, -0.05095975f, 0.01694428f, 0.04938921f, -0.00925406f, 0.20741686f, 
    -0.14487408f, 0.05548306f, 0.08321019f, -0.04138569f, 0.06188296f, 0.09013353f, -0.02620847f, 0.09010912f, 
    0.07746661f, -0.22519226f, 0.21130261f, 0.00418060f, 0.10605462f, 0.08300290f, 0.01495034f, 0.00847350f, 
    0.08057365f, 0.12806278f, -0.09328262f, 0.02286259f, 0.08387153f, -0.22917166f, -0.13435356f, -0.07081030f, 
    0.08848495f, 0.08174407f, -0.01509975f, 0.10216263f, -0.05433575f, -0.02670678f, 0.03643573f, -0.01652731f, 
    -0.07871713f, 0.19544142f, -0.19959566f, 0.06872079f, 0.07710810f, 0.10787218f, -0.02437957f, -0.01989035f, 
    0.03856984f, 0.04789186f, 0.02837209f, -0.05904625f, -0.21599688f, 0.04864964f, -0.01220567f, -0.23181050f, 
    -0.03869445f, 0.15533881f, 0.02816079f, -0.03174895f, -0.06233763f, -0.06950725f, 0.10853656f, 0.01001912f, 
    -0.02885734f, 0.08725087f, 0.03981045f, 0.12165049f, 0.01088783f, 0.03249138f, 0.08496739f, 0.14733973f, 
    0.00613347f, 0.08400029f, 0.00233575f, 0.04362329f, -0.14483397f, -0.00624210f, 0.06289929f, 0.07536924f, 
    -0.01601532f, -0.09108069f, 0.04184312f, -0.14165762f, -0.02881628f, 0.02167060f, -0.04478012f, -0.01572512f, 
    0.00443269f, 0.06396902f, -0.07038791f, 0.26830053f, -0.05508652f, 0.07517964f, 0.09305244f, 0.08868066f, 
    0.00824394f, -0.05425417f, 0.05897757f, -0.02863130f, 0.16739070f, -0.00846380f, 0.09591193f, 0.21231216f, 
    0.09678277f, -0.00217468f, 0.00708015f, 0.03369302f, -0.10750678f, -0.06715757f, -0.06486218f, -0.03614657f, 
    0.35536894f, 0.11193658f, 0.26549894f, -0.19328812f, 0.04692494f, 0.06165573f, 0.08387078f, 0.01987300f, 
    0.05148127f, -0.02776238f, 0.00635558f, 0.02363789f, -0.11854538f, -0.06058880f, 0.00390997f, -0.07132693f, 
    -0.10534054f, -0.06894834f, -0.05797739f, -0.03179420f, -0.02460221f, 0.00572235f, 0.06427359f, -0.07462459f, 
    -0.07399952f, 0.21821707f, -0.07933065f, -0.17425570f, -0.05818892f, -0.00039636f, -0.09158742f, -0.12389059f, 
    0.03913805f, 0.06636918f, 0.02670417f, -0.01040749f, -0.34769583f, -0.12475908f, -0.20520610f, -0.19985081f, 
    0.00188941f, 0.01054048f, -0.07404443f, -0.03727037f, 0.04404609f, -0.09569436f, -0.00469469f, 0.02574445f, 
    -0.21342753f, -0.11248884f, 0.06014775f, 0.03059527f, -0.02078158f, -0.08051179f, 0.18861842f, -0.03627069f, 
    0.04542660f, 0.01900882f, 0.00903261f, -0.01715400f, 0.23938490f, -0.09791562f, 0.16330676f, -0.05802017f, 
    -0.00404710f, 0.00392605f, 0.05842210f, 0.10272700f, 0.11490753f, -0.01492458f, -0.03974976f, -0.04408881f, 
    -0.05851567f, -0.01882541f, -0.00660502f, 0.14329696f, -0.15254727f, 0.05323127f, 0.00435230f, -0.02009731f, 
    0.04299866f, 0.08687261f, 0.02711834f, 0.05489431f, -0.17689796f, -0.16090213f, -0.13710107f, -0.20836927f, 
    0.09317105f, 0.03070731f, 0.03968917f, -0.00829542f, -0.10196217f, 0.03883342f, 0.04839753f, -0.04313130f, 
    -0.04044374f, 0.06922437f, -0.18807882f, 0.06590277f, 0.00744660f, 0.05885721f, 0.03417949f, 0.11805739f, 
    -0.04415338f, -0.02353424f, 0.03902589f, -0.03341750f, -0.32550019f, 0.10289308f, 0.01409396f, 0.08661103f, 
    -0.02459958f, 0.01682742f, -0.00772188f, -0.04821414f, 0.04582147f, -0.15511087f, 0.03798480f, -0.03091243f, 
    0.21102723f, -0.27669731f, 0.24695346f, -0.11847966f, 0.11823074f, -0.08788485f, 0.12566213f, 0.14687081f, 
    -0.00316929f, 0.08057617f, -0.08569071f, -0.02863762f, 0.45396525f, 0.09526616f, 0.00170775f, 0.16734326f, 
    0.03282900f, -0.18669759f, -0.02082928f, -0.13501185f, 0.03760105f, 0.11865830f, -0.06005811f, 0.14351438f, 
    0.02074329f, -0.31156522f, -0.04752953f, 0.18139888f, -0.01118420f, 0.02255553f, -0.09824409f, -0.06747270f, 
    0.07988638f, -0.10320467f, 0.19129378f, 0.06571151f, 0.03688615f, 0.13166562f, 0.05161601f, -0.25580907f, 
    0.11707588f, 0.09948338f, -0.02231245f, 0.10944154f, -0.03411650f, -0.02504184f, -0.13935208f, 0.16482221f, 
    0.34716058f, 0.26856747f, 0.23299196f, -0.08778670f, -0.00901448f, 0.03859270f, 0.01833696f, -0.06381037f, 
    -0.00372378f, -0.02423255f, 0.08030829f, 0.03813058f, -0.20574978f, 0.01327624f, 0.14027512f, 0.14545685f, 
    -0.16267700f, 0.03778126f, -0.04399537f, -0.02629312f, -0.04175922f, 0.01591138f, -0.02402712f, 0.07920528f, 
    -0.68243086f, 0.14548935f, -0.28310609f, 0.09244416f, 0.00211496f, -0.01548518f, -0.12540276f, -0.05934421f, 
    0.01776857f, -0.06416306f, -0.02868498f, 0.10525434f, -0.11178201f, -0.10878868f, 0.12718457f, -0.01817403f, 
    0.14441872f, 0.08549330f, 0.10037320f, 0.11061697f, 0.03632902f, 0.07808155f, -0.03885820f, 0.14045152f, 
    -0.10949464f, -0.06293451f, 0.01728687f, -0.04210865f, 0.03479806f, 0.08193790f, 0.11469340f, 0.04060222f, 
    -0.02617294f, 0.07224692f, 0.09477150f, 0.04191702f, -0.02843696f, -0.06696694f, -0.04983063f, -0.09650951f, 
    0.22278710f, 0.13317370f, 0.05973085f, 0.11925031f, -0.04262595f, 0.03190413f, -0.17511599f, -0.13245127f, 
    0.01803686f, -0.09991771f, 0.03766933f, -0.23426503f, -0.00750794f, -0.07945970f, -0.05755340f, 0.17078871f, 
    0.08804309f, -0.08769562f, 0.00042356f, 0.13065508f, -0.25048715f, -0.21407995f, -0.03394123f, -0.09488174f, 
    0.07754351f, 0.02355405f, -0.13002388f, -0.03938068f, 0.11390325f, 0.09942660f, -0.07736818f, -0.05883109f, 
    0.20628734f, -0.16119951f, 0.09765746f, -0.05954407f, 0.10008677f, -0.09858999f, -0.10533894f, -0.03198595f, 
    -0.05065127f, 0.05911658f, -0.05981026f, 0.20505594f, 0.09509099f, -0.08657791f, -0.15158671f, -0.12984134f, 
    0.01981082f, -0.01474326f, -0.08731273f, -0.07912800f, 0.03198282f, -0.15613967f, 0.01846788f, -0.09066083f, 
    0.02373008f, 0.21708755f, -0.10333479f, -0.00870024f, 0.04700269f, -0.04120283f, 0.00079979f, 0.09942295f, 
    0.10323672f, 0.13303024f, 0.10230176f, 0.12117945f, 0.07913553f, -0.02937339f, -0.05542532f, -0.08831625f, 
    0.00575981f, 0.11220946f, -0.12434921f, -0.07730941f, 0.17107384f, 0.04579001f, -0.03030533f, -0.07361007f, 
    0.20690252f, -0.23678468f, -0.09005820f, 0.10178774f, 0.07525194f, 0.08570694f, 0.03838957f, -0.08256735f, 
    0.08043177f, -0.14962652f, 0.07042635f, -0.00196293f, 0.01951184f, 0.15181164f, 0.10446068f, -0.08535547f, 
    0.05501925f, -0.02435970f, -0.05090764f, 0.03578885f, 0.01955908f, 0.11485204f, -0.08690781f, -0.02101500f, 
    -0.19967742f, 0.03008404f, -0.11539398f, 0.03583186f, -0.01386080f, 0.03698505f, 0.02261902f, -0.08123611f, 
    -0.11800569f, 0.16018018f, -0.15645142f, 0.04724824f, -0.00818732f, -0.05176956f, 0.05398824f, 0.17931649f, 
    -0.03285044f, 0.12169656f, 0.02846105f, -0.00720641f, -0.00073362f, 0.07823093f, 0.12330388f, 0.03842335f, 
    -0.28308114f, 0.07458340f, -0.01211387f, 0.03466187f, 0.16164729f, -0.17914055f, 0.05268152f, -0.00206257f, 
    0.02773045f, 0.04306623f, -0.02445428f, 0.16472265f, -0.03857783f, -0.06050728f, -0.02984459f, -0.07101356f, 
    0.04976465f, 0.10545745f, 0.00661137f, -0.02341006f, 0.05876780f, 0.15225655f, 0.11816807f, 0.21342210f, 
    -0.10207175f, -0.08954827f, -0.08237839f, 0.15262641f, -0.02371410f, 0.04243027f, 0.04745146f, 0.00547047f, 
    0.08345778f, -0.09237123f, 0.02432094f, -0.02058123f, 0.21684630f, 0.18611363f, -0.09374733f, 0.11176153f, 
    -0.06810451f, 0.04375370f, -0.05928278f, 0.01532216f, 0.08555771f, -0.04239313f, -0.00827612f, -0.00881335f, 
    0.29298815f, -0.16904312f, -0.08779843f, 0.09026197f, 0.02901502f, -0.05951017f, -0.06234979f, -0.04295593f, 
    -0.01163812f, 0.03110030f, -0.20320521f, 0.01494408f, 0.22644426f, 0.05117055f, 0.07282168f, 0.20755881f, 
    -0.11506079f, 0.18291646f, 0.14685129f, 0.00448327f, -0.00162059f, 0.00276171f, 0.14967804f, -0.01363893f, 
    0.14088462f, -0.04867969f, 0.15474059f, 0.18690978f, -0.13306989f, -0.05245509f, 0.02072604f, 0.00965043f, 
    0.00592192f, -0.03689906f, -0.08344550f, -0.05449456f, 0.32473195f, 0.07588772f, 0.22675091f, -0.12819488f, 
    0.04803183f, -0.11420033f, 0.06257277f, -0.15221162f, 0.12004744f, 0.05501176f, -0.08568494f, 0.03199924f, 
    0.21991901f, -0.06362322f, 0.04717705f, 0.18228996f, 0.03000077f, 0.02466367f, -0.08511508f, -0.01662960f, 
    0.13599586f, -0.05182345f, -0.02408216f, -0.08016453f, 0.06883415f, -0.03168175f, -0.29437461f, 0.02958894f, 
    0.07088533f, 0.13112128f, 0.14519677f, -0.12108044f, -0.00202390f, 0.04897479f, 0.05266906f, -0.09070802f, 
    -0.19884188f, 0.08169504f, 0.07456136f, 0.08588295f, 0.06076525f, 0.08793936f, 0.00247719f, 0.16926214f, 
    -0.00522465f, 0.06193496f, -0.08294885f, 0.06908582f, -0.22250678f, -0.02202301f, 0.47471577f, -0.17363448f, 
    0.07554451f, 0.10388204f, -0.03778410f, -0.05622342f, -0.00291382f, 0.00175440f, 0.06490779f, 0.00480273f, 
    -0.13063107f, 0.03536675f, -0.12234236f, 0.08221401f, 0.03800010f, 0.04941626f, 0.06998041f, -0.01841556f, 
    0.05913421f, 0.03592793f, 0.03957312f, -0.05553370f, 0.30188495f, 0.04255717f, 0.16062161f, -0.06793645f, 
    -0.22913963f, 0.05601349f, -0.03350977f, 0.02543862f, 0.08228753f, -0.00416891f, -0.02638676f, -0.16283414f, 
    0.28738692f, 0.12246481f, -0.01580484f, 0.31301507f, 0.08862995f, -0.00239298f, 0.12600671f, 0.06263502f, 
    -0.07422780f, -0.02787100f, 0.11045928f, -0.01384031f, -0.27784783f, 0.00196636f, -0.06509556f, 0.06390367f, 
    -0.09682246f, -0.05069021f, 0.05093232f, 0.06357405f, -0.02530073f, -0.11407704f, 0.02321676f, 0.07408503f, 
    -0.38613713f, -0.06163398f, 0.04091850f, 0.15098606f, -0.02227932f, -0.01615639f, -0.09926104f, -0.04402890f, 
    0.10763567f, 0.05384900f, -0.10624371f, -0.07717718f, -0.22427569f, 0.11799485f, 0.17391099f, 0.06365382f, 
    -0.09724100f, 0.03887419f, -0.09513423f, 0.05004209f, 0.02145452f, -0.03139733f, -0.08251162f, 0.08822762f, 
    -0.13574299f, 0.03995908f, -0.02758663f, 0.05636442f, 0.08803499f, -0.08340760f, 0.10577245f, -0.10351297f, 
    0.01315921f, 0.04853186f, -0.06048403f, 0.04699825f, 0.19016761f, 0.09739032f, 0.08965636f, 0.06968365f, 
    0.00534736f, -0.01252334f, 0.14649814f, -0.04690382f, -0.06778304f, -0.14572550f, -0.06775791f, 0.07078200f, 
    -0.11063674f, 0.03402845f, -0.07772600f, 0.04283964f, -0.09076063f, 0.07516970f, -0.04827400f, -0.09368271f, 
    -0.02165044f, -0.06012027f, 0.00211811f, 0.11437435f, -0.12839957f, 0.06724440f, -0.00661448f, 0.06312254f, 
    0.09020545f, 0.06160481f, -0.01162434f, 0.00085471f, 0.05721451f, -0.02322722f, 0.00441999f, 0.09945975f, 
    0.06491204f, -0.08358970f, 0.05935070f, 0.28608456f, 0.09003656f, 0.14411484f, 0.08876221f, -0.14021312f, 
    -0.13475552f, 0.03122629f, 0.03351537f, -0.08179963f, 0.17648268f, -0.00430359f, 0.17912027f, 0.18937704f, 
    -0.00942241f, -0.11433550f, -0.05045274f, 0.02154440f, -0.13357240f, 0.13841468f, 0.06480937f, 0.11629986f, 
    0.10425436f, 0.32636207f, 0.13344541f, 0.22250053f, 0.11870582f, 0.07574604f, 0.09535421f, 0.05415080f, 
    -0.01339431f, 0.05195602f, 0.04049061f, -0.08950593f, -0.02479821f, 0.13214070f, 0.05325048f, -0.03968693f, 
    0.17841944f, -0.00920872f, 0.21462440f, 0.05055276f, -0.06255743f, 0.12271126f, -0.08801005f, 0.07696838f, 
    -0.05699668f, -0.29256925f, -0.08832715f, 0.00336664f, -0.03020423f, 0.03244967f, -0.14440480f, -0.09895036f, 
    0.02073452f, -0.10636660f, -0.10113593f, -0.09508285f, 0.09909357f, 0.02331723f, 0.05553102f, 0.06448920f, 
    -0.06879653f, 0.01609902f, -0.00487586f, -0.00057168f, -0.04634507f, -0.10206774f, 0.11901917f, 0.02810789f, 
    -0.14437650f, 0.13283224f, 0.11848150f, -0.11273992f, 0.08549035f, -0.05218579f, 0.10001764f, -0.09060898f, 
    0.09392745f, 0.02868609f, -0.17678361f, 0.01274606f, -0.02333841f, -0.04419546f, -0.02791952f, -0.28070194f, 
    -0.04390503f, 0.00539317f, -0.10273255f, -0.01769077f, 0.00536884f, -0.11480125f, 0.14536996f, -0.02905906f, 
    0.11863207f, 0.10825189f, 0.14951877f, -0.01871601f, 0.03083741f, 0.10012204f, 0.08220170f, 0.11982565f, 
    0.03071380f, -0.08745076f, 0.25228104f, 0.04707963f, -0.00779100f, -0.10381412f, -0.19905533f, -0.05620210f, 
    0.19781537f, -0.12288628f, 0.04446121f, 0.03878561f, -0.10137469f, -0.07580952f, 0.08458035f, 0.07121396f, 
    -0.27038452f, -0.11250405f, 0.07424585f, 0.15595554f, 0.02949445f, 0.00001636f, -0.00134861f, -0.10534111f, 
    -0.07107023f, -0.06873534f, -0.05737569f, 0.04555786f, 0.11039372f, 0.11287843f, 0.07374674f, -0.22889937f, 
    0.01149298f, -0.06482580f, 0.04348220f, 0.01042593f, 0.04867055f, -0.05298813f, -0.05075118f, -0.09828942f, 
    0.46469080f, 0.03248991f, -0.08126554f, 0.18818098f, -0.01731501f, -0.02944048f, 0.08332235f, 0.07969847f, 
    -0.03455573f, 0.15231723f, -0.01208420f, -0.03119054f, 0.55342239f, -0.10806204f, -0.13560729f, -0.07652624f, 
    -0.09030775f, 0.12215468f, 0.00545607f, -0.02478322f, -0.09640179f, -0.05580983f, 0.10073756f, 0.09306189f, 
    -0.25074846f, 0.00135207f, -0.18512756f, -0.09017958f, 0.06763069f, 0.07975470f, 0.05782720f, -0.07041775f, 
    0.18324047f, 0.01168462f, 0.18470420f, 0.11727300f, 0.23576266f, 0.15348566f, -0.03945375f, -0.25902030f, 
    0.01951884f, 0.00829759f, 0.05841867f, -0.00707867f, 0.01915433f, -0.11503648f, -0.14858688f, 0.15697560f, 
    -0.07026669f, 0.29357603f, -0.20724986f, 0.09601555f, 0.10079589f, 0.12085509f, 0.01760581f, 0.07869841f, 
    0.06635277f, -0.00139987f, -0.06788667f, -0.00578569f, 0.19861430f, 0.34861359f, -0.16485499f, -0.04969243f, 
    0.18445784f, -0.03274518f, -0.06666916f, 0.17625898f, -0.05234114f, -0.05714199f, 0.14231122f, 0.02554712f, 
    -0.13348836f, -0.03022666f, -0.01654184f, -0.18074475f, 0.02023371f, -0.03956613f, 0.10847042f, -0.05318847f, 
    -0.01807067f, 0.04602494f, 0.08959348f, -0.05487032f, -0.00164832f, 0.21724470f, 0.21121857f, 0.13765472f, 
    -0.08317592f, 0.00804387f, -0.04569362f, 0.03600413f, 0.06110585f, 0.14600806f, 0.09681837f, 0.08114657f, 
    -0.05833011f, -0.06302053f, 0.02189969f, 0.16820771f, -0.02767736f, 0.03242300f, -0.10620941f, 0.09225128f, 
    -0.06130653f, -0.06718882f, -0.10842082f, -0.11495000f, 0.05159019f, 0.13055339f, 0.26645020f, 0.10864261f, 
    -0.07897905f, 0.05233588f, 0.06001060f, 0.08872411f, -0.07867716f, 0.01210202f, -0.05812335f, 0.04869748f, 
    0.05226313f, 0.19808331f, -0.06617121f, 0.14202829f, -0.15257883f, -0.07031120f, 0.01793810f, 0.07102247f, 
    -0.07437048f, 0.16121885f, 0.04359068f, 0.00676445f, -0.13462751f, -0.21671696f, -0.11376722f, 0.08687930f, 
    0.03777865f, 0.01665818f, -0.09734496f, -0.08914081f, 0.08341856f, -0.19727774f, 0.10144256f, -0.09844400f, 
    0.28272292f, 0.05203754f, 0.04544688f, -0.08135687f, 0.02772816f, 0.05378993f, -0.18066132f, 0.07258276f, 
    0.06458858f, 0.01451620f, -0.12081788f, 0.08890841f, 0.01903148f, -0.25501713f, -0.05848543f, -0.19468567f, 
    -0.07064851f, -0.03764110f, -0.03635408f, 0.00848874f, -0.04770761f, 0.01806090f, 0.15111072f, 0.08197288f, 
    0.35723311f, -0.10214172f, -0.15677890f, -0.06708303f, -0.01064218f, 0.09883633f, -0.05990801f, -0.04395013f, 
    0.16582222f, 0.11952901f, -0.01312109f, 0.06100379f, 0.26855728f, 0.06123601f, -0.03710611f, 0.17832296f, 
    0.13317387f, -0.09329441f, -0.10900400f, 0.08793549f, 0.02921764f, 0.01452494f, -0.05773606f, -0.14614189f, 
    -0.24383438f, 0.05026931f, 0.11472918f, -0.02819869f, 0.01510241f, 0.05291563f, 0.06311486f, -0.01049798f, 
    -0.06921389f, 0.11097835f, 0.03430713f, 0.09482389f, -0.46788037f, -0.04210378f, -0.09631451f, -0.10616814f, 
    -0.06686051f, -0.05497571f, -0.00300371f, 0.17299867f, -0.00055593f, 0.05214322f, 0.12280026f, 0.14682910f, 
    -0.17793426f, -0.15479942f, -0.20707330f, 0.06316397f, -0.03224374f, 0.05641522f, 0.04494640f, -0.03621925f, 
    0.09055286f, 0.02115413f, 0.18888798f, 0.05024357f, 0.06074484f, 0.07159784f, 0.19811963f, 0.09849018f, 
    -0.10800625f, 0.11499391f, 0.10255897f, -0.04095414f, -0.05703287f, 0.07845996f, -0.02513740f, -0.07719908f, 
    0.15503623f, 0.01206447f, -0.00839232f, -0.08258471f, -0.09589306f, 0.01756086f, -0.16597305f, 0.00563197f, 
    0.23322983f, 0.03601402f, 0.02317728f, 0.14483923f, 0.14403300f, 0.00973806f, 0.06489382f, -0.10128731f, 
    -0.06873756f, -0.01233887f, -0.02888395f, -0.09521130f, 0.04282647f, 0.01607560f, -0.10800949f, 0.10616755f, 
    0.06155614f, -0.10854163f, 0.00114554f, -0.09774872f, 0.16710261f, -0.02261414f, -0.00353251f, 0.02759238f, 
    0.01732511f, 0.05174357f, -0.13508880f, 0.04487489f, 0.02010141f, -0.04261691f, -0.16977970f, 0.20108898f, 
    -0.04085129f, 0.05975316f, 0.03449651f, 0.02615005f, -0.04766572f, -0.14816956f, 0.04698609f, 0.04048579f, 
    0.15333922f, 0.13119760f, 0.20633069f, -0.04379685f, 0.07452971f, -0.07163450f, 0.08509828f, -0.10594942f, 
    0.04312739f, 0.07528596f, -0.01147544f, -0.01246576f, -0.04369867f, -0.10936340f, -0.14352620f, -0.05894823f, 
    0.08068755f, 0.08727703f, -0.08735391f, 0.06870607f, 0.00000099f, -0.04904250f, 0.02053957f, 0.13550399f, 
    -0.13387416f, 0.19504435f, -0.16011986f, 0.06746820f, -0.04357969f, 0.12047885f, -0.02030289f, 0.01119925f, 
    0.05774449f, -0.00796220f, 0.08989993f, 0.07489978f, -0.06455336f, 0.03218253f, 0.24918889f, 0.18983792f, 
    -0.03050274f, 0.12243383f, 0.08912314f, -0.08336283f, -0.10813256f, -0.02115059f, 0.09747694f, 0.09925305f, 
    0.09751259f, 0.15590644f, 0.02537575f, -0.05866693f, 0.08399624f, -0.10868364f, 0.16534527f, 0.02605701f, 
    -0.03438139f, 0.12209596f, -0.21673447f, -0.03945706f, -0.08492500f, 0.05408634f, 0.09835095f, 0.12860562f, 
    -0.07743397f, -0.04564234f, 0.01235587f, -0.00750879f, 0.13578311f, -0.00470536f, -0.05222134f, -0.10693574f, 
    -0.34478793f, -0.05926651f, -0.26219848f, 0.19693159f, 0.06864718f, 0.15016167f, 0.12906756f, 0.04760823f, 
    0.14254278f, 0.04582479f, 0.05499047f, 0.01838365f, 0.06439482f, 0.09346113f, 0.00851265f, -0.03804173f, 
    0.09365064f, 0.03853866f, -0.04822380f, 0.08199753f, -0.06204214f, -0.09093104f, 0.05597391f, 0.16399738f, 
    0.20060895f, -0.12662835f, 0.23300670f, -0.23995416f, 0.06256111f, -0.00309485f, 0.07217130f, 0.06821807f, 
    0.04428460f, -0.08481301f, -0.10521936f, -0.02765148f, 0.01564066f, 0.00571488f, -0.04570053f, 0.06237752f, 
    -0.06666616f, -0.02518321f, 0.01328455f, 0.08103749f, 0.00444388f, -0.03926940f, -0.03570877f, -0.06297089f, 
    0.50402945f, 0.18933906f, -0.07669555f, 0.06666348f, -0.11407071f, 0.00919983f, -0.05229153f, -0.07115752f, 
    0.02717132f, 0.02080645f, -0.06051696f, 0.08038512f, -0.39499420f, -0.00016273f, 0.07460627f, 0.02975879f, 
    -0.09181656f, 0.00048070f, 0.03431040f, -0.03262180f, -0.08668821f, 0.02258185f, 0.17443861f, 0.05616386f, 
    -0.01370144f, -0.01609825f, -0.02805067f, -0.02743194f, -0.02698976f, 0.01938498f, -0.03591421f, 0.02621680f, 
    -0.05155492f, 0.02073555f, -0.03190850f, -0.05977596f, -0.05721069f, 0.03735209f, -0.01434935f, -0.06376299f, 
    -0.01973047f, 0.05824728f, -0.06933854f, 0.04405802f, 0.01913227f, 0.02488494f, -0.01900890f, -0.03314316f, 
    0.02977473f, -0.05786587f, 0.05591924f, -0.03927253f, 0.03109543f, 0.05734272f, 0.01706957f, -0.01175420f, 
    0.05201772f, 0.05476309f, -0.01384693f, 0.03091167f, -0.04220190f, -0.07486472f, 0.02333383f, 0.02620376f, 
    -0.01570412f, -0.06494413f, -0.04568809f, -0.02784796f, 0.05617563f, -0.07032042f, -0.02363847f, -0.00931694f, 
    0.01163093f, -0.00696614f, 0.01586166f, -0.04938866f, 0.06604177f, 0.06057463f, -0.02332716f, 0.06007716f, 
    0.04231089f, -0.03299502f, -0.01791769f, 0.00965934f, -0.04259723f, 0.05810826f, 0.01302082f, -0.01927000f, 
    0.02168318f, -0.03360733f, -0.07357934f, 0.01141034f, -0.06866387f, -0.06078295f, 0.00231190f, -0.06947860f, 
    -0.04094632f, 0.03645476f, -0.02310579f, -0.04636883f, -0.05333931f, -0.00520276f, 0.02523766f, -0.04257144f, 
    0.06795306f, -0.03919059f, -0.01552255f, 0.03051317f, -0.07364485f, 0.04015820f, 0.06235334f, 0.05160625f, 
    -0.03050710f, 0.05904938f, -0.05617428f, -0.03039239f, -0.06541220f, 0.02158880f, 0.04952674f, -0.00270272f, 
    0.02901483f, 0.01033949f, -0.06686920f, -0.01771546f, 0.01629296f, -0.05987633f, -0.06451796f, -0.07801627f, 
    0.02686472f, 0.05735374f, -0.04813030f, 0.00769437f, -0.00623154f, -0.07528581f, 0.00398038f, -0.04222745f, 
    -0.03655459f, -0.05823518f, 0.03064752f, 0.06057729f, -0.07101906f, -0.03553594f, -0.00604652f, -0.03116250f, 
    0.00595377f, -0.03363568f, 0.05088799f, 0.00150429f, -0.04131059f, -0.06928794f, -0.00013062f, -0.01748776f, 
    -0.07486760f, 0.00602538f, -0.05967007f, 0.03954785f, -0.01616857f, 0.04359912f, 0.06005756f, 0.01120518f, 
    0.03360999f, -0.03988548f, -0.06770571f, 0.03555829f, -0.06996327f, -0.06121174f, -0.07665031f, 0.00471078f, 
    -0.07163466f, -0.01390665f, 0.01105728f, 0.04761348f, -0.00584015f, 0.01661979f, -0.04596538f, -0.02749631f, 
    -0.07537228f, 0.01037985f, 0.00420997f, 0.00166340f, 0.03078933f, 0.03707002f, 0.01150015f, 0.05474608f, 
    -0.03023978f, -0.00711942f, 0.00803396f, 0.02901921f, 0.03557879f, 0.00040840f, 0.05591201f, 0.04223860f, 
    0.06079796f, 0.06443103f, -0.07228246f, -0.05526508f, -0.04268904f, 0.00350925f, -0.02230393f, -0.01166324f, 
    -0.01719697f, -0.07429530f, -0.06039710f, -0.06605442f, 0.06562525f, -0.04366705f, -0.03046647f, -0.04935885f, 
    -0.04943572f, -0.01973131f, -0.01124603f, -0.05751492f, 0.01615817f, 0.01345706f, -0.00369200f, -0.02959882f, 
    -0.38861966f, -0.02058570f, 0.15231133f, 0.11519618f, 0.03848686f, 0.13104649f, -0.01951671f, -0.04308699f, 
    -0.02291559f, -0.07345952f, -0.10564271f, 0.02120078f, 0.29117113f, 0.00162306f, -0.09198041f, 0.05432997f, 
    0.02097534f, -0.08159261f, -0.03804103f, 0.05197834f, -0.03074520f, 0.06370325f, 0.08715745f, -0.09412838f, 
    -0.13030517f, -0.09972183f, 0.23283631f, 0.25126967f, -0.05318758f, -0.07212616f, -0.08002612f, 0.02006079f, 
    0.11700750f, -0.00590131f, -0.06523830f, 0.05177739f, -0.20227762f, -0.00011541f, 0.09801326f, -0.20607464f, 
    0.16727266f, 0.05102898f, -0.00322781f, 0.12561455f, 0.08790172f, 0.03514307f, -0.03130221f, -0.00367799f, 
    0.09915712f, -0.02732588f, 0.04995036f, -0.05699695f, 0.02813600f, -0.03801826f, -0.02137984f, 0.09536545f, 
    0.11575082f, -0.06578655f, -0.05067613f, -0.02488269f, -0.34720457f, -0.18021950f, -0.06671225f, -0.03374081f, 
    0.09267501f, 0.08408032f, -0.07241323f, 0.07631365f, -0.03153574f, -0.12279695f, -0.03867423f, 0.00136554f, 
    -0.37637073f, 0.19066255f, 0.08132476f, -0.01885813f, -0.01289045f, 0.03706093f, -0.05989670f, 0.05979692f, 
    -0.00946851f, 0.11279677f, 0.02098699f, 0.14390710f, 0.06429508f, -0.19250718f, 0.05170639f, 0.01294769f, 
    -0.05184370f, -0.01690108f, 0.00002427f, 0.01191128f, 0.03460958f, 0.03895124f, 0.09843854f, 0.12008321f, 
    0.00147605f, 0.11251914f, -0.07217167f, -0.36432216f, -0.01229149f, -0.01583539f, 0.06587459f, 0.05670916f, 
    0.01033710f, -0.03074858f, -0.08550079f, -0.04571698f, 0.22603576f, 0.16075526f, -0.04612040f, 0.05115807f, 
    -0.00111033f, 0.00235534f, -0.00481517f, 0.07501937f, -0.00136252f, -0.01760368f, 0.11607758f, 0.08980723f, 
    0.09943043f, -0.02881854f, 0.09659321f, -0.02114747f, 0.04647461f, 0.05475267f, 0.02499095f, -0.03043779f, 
    -0.02876516f, 0.05263268f, 0.04623901f, -0.02333168f, -0.06155293f, 0.20229533f, -0.10726748f, -0.44815093f, 
    -0.01260613f, 0.01246026f, 0.05211286f, -0.02419941f, 0.03265123f, 0.03065042f, 0.02059854f, 0.05093196f, 
    -0.17434090f, -0.18110731f, -0.03682084f, 0.08211569f, 0.00782833f, 0.02293377f, 0.04154092f, 0.13807815f, 
    0.03754713f, 0.05110674f, -0.11509023f, 0.15472506f, 0.19730124f, -0.02492509f, -0.00315000f, 0.19069934f, 
    0.10125567f, 0.04061555f, 0.03221802f, -0.07904037f, 0.02459524f, 0.10361659f, -0.00672004f, 0.10847764f, 
    -0.06917688f, 0.10087045f, -0.02909384f, 0.22364280f, 0.01743198f, -0.08906967f, -0.03486973f, 0.08673465f, 
    0.10378292f, 0.04198349f, 0.08927035f, 0.06456119f, -0.23523174f, -0.13044710f, 0.00440250f, -0.15768799f, 
    0.03274665f, 0.04555039f, -0.01483665f, 0.09256128f, 0.09817984f, -0.00287042f, 0.01018717f, 0.01635782f, 
    -0.03222549f, -0.03646296f, -0.07003818f, 0.00463042f, 0.03239389f, 0.06263500f, 0.05880403f, -0.07955969f, 
    -0.00382548f, -0.04214710f, -0.05940643f, -0.02240685f, -0.02339491f, 0.00951578f, 0.05395009f, 0.03338729f, 
    0.04573198f, 0.01371383f, 0.03097389f, 0.05115897f, -0.02712588f, -0.01960104f, -0.06919492f, -0.03089788f, 
    -0.06572382f, -0.01594921f, 0.00579007f, -0.02540585f, 0.04702381f, 0.05274044f, 0.05077199f, -0.02007631f, 
    -0.06819008f, -0.04761843f, 0.00213665f, 0.04666726f, -0.00088955f, -0.03742695f, -0.00676508f, 0.01779156f, 
    -0.03781293f, 0.05209748f, 0.00226816f, -0.04210280f, -0.03763444f, -0.05549126f, 0.05152341f, -0.01754572f, 
    -0.05502361f, 0.01235375f, -0.01507186f, -0.05555430f, -0.04825818f, -0.03552802f, -0.02829910f, 0.02811643f, 
    0.04010551f, -0.00440553f, 0.00107348f, -0.06245333f, 0.04890544f, -0.06502907f, -0.05313036f, -0.01419736f, 
    0.00478730f, -0.02756616f, -0.01695805f, 0.03673182f, 0.03560008f, -0.06216776f, -0.01436699f, -0.02985775f, 
    -0.04057064f, -0.07599477f, 0.06123457f, -0.03660887f, 0.02666273f, -0.00982727f, -0.01895409f, -0.04689477f, 
    -0.05503844f, -0.03139530f, -0.05383186f, -0.00139761f, 0.05047140f, 0.05972802f, -0.01729503f, -0.01355324f, 
    0.04092447f, -0.07242761f, 0.04798484f, -0.02445081f, -0.07312134f, -0.07927611f, 0.01773991f, 0.03431807f, 
    0.02828482f, 0.01397104f, -0.02416012f, -0.04231689f, -0.01228360f, 0.00664355f, -0.02754703f, -0.00187250f, 
    0.01341806f, 0.02495253f, -0.03228977f, 0.02733311f, -0.05820409f, 0.05806416f, -0.01536066f, -0.06607270f, 
    0.01417248f, 0.05798243f, 0.00669377f, -0.00251344f, -0.04193964f, -0.05070752f, 0.03977513f, 0.00091075f, 
    -0.07857931f, -0.01608830f, -0.04945865f, -0.02783185f, -0.00708095f, -0.05685414f, -0.03247076f, -0.00781965f, 
    -0.00925382f, 0.01207966f, 0.04102223f, -0.03645314f, 0.05740847f, 0.00628112f, -0.05371534f, 0.01631959f, 
    -0.05789864f, -0.03986648f, 0.03473599f, 0.06086933f, -0.03729755f, 0.00579478f, -0.05156096f, -0.00932185f, 
    -0.00828178f, -0.07891170f, -0.06671941f, 0.01030596f, -0.03014016f, -0.01859725f, -0.00422369f, 0.05319165f, 
    0.04423109f, 0.05434210f, -0.02721601f, 0.02773669f, -0.05615262f, 0.03874111f, -0.04516615f, 0.04993763f, 
    0.03814752f, 0.00678136f, -0.03817002f, 0.01637735f, 0.05250414f, -0.05424645f, -0.07104561f, -0.03714061f, 
    0.02657084f, 0.01069553f, -0.04387383f, -0.06064709f, -0.07092369f, 0.04905807f, -0.07885142f, -0.06731415f, 
    -0.07157784f, 0.05526023f, -0.03611832f, 0.00588662f, -0.00874442f, -0.04682092f, 0.06841824f, -0.06812138f, 
    0.03280756f, 0.05194605f, -0.06664656f, 0.04955558f, -0.00187112f, 0.01074049f, 0.02842923f, 0.05549411f, 
    -0.06723081f, 0.00907488f, 0.15306424f, 0.12995370f, 0.00192226f, -0.08044358f, 0.09208038f, 0.04598049f, 
    0.03294865f, 0.11649102f, -0.00806243f, 0.06551717f, 0.20361681f, -0.10794473f, 0.00633705f, -0.16614437f, 
    0.02060277f, 0.05330844f, -0.00315793f, -0.04870481f, 0.04056612f, -0.08124968f, -0.01758814f, -0.07736295f, 
    -0.10188065f, -0.27514586f, 0.00929368f, 0.05240159f, -0.04286021f, -0.01871862f, -0.09155133f, -0.05693862f, 
    0.01645930f, 0.04000396f, -0.08056069f, 0.18701272f, 0.09983876f, -0.08750571f, -0.15119377f, -0.05639955f, 
    0.03698833f, 0.11680286f, -0.04508863f, -0.00621890f, -0.07833297f, 0.02470089f, -0.08142462f, 0.03914531f, 
    -0.03814871f, 0.17193004f, -0.02970169f, -0.10278778f, 0.04258011f, -0.12379958f, 0.00557315f, 0.00586595f, 
    -0.01360657f, 0.00657069f, 0.02681484f, 0.07725833f, -0.37613618f, 0.07748485f, -0.05613111f, 0.00571215f, 
    0.08479675f, 0.09998080f, -0.05230724f, 0.09822766f, 0.00858955f, 0.08953076f, 0.04478056f, -0.00399529f, 
    0.19481090f, -0.09932081f, -0.03627180f, -0.06923829f, -0.02290968f, 0.04206235f, -0.00255743f, -0.01408749f, 
    0.05528717f, -0.08704650f, 0.03605773f, 0.06679588f, 0.23975661f, 0.10551813f, 0.03168872f, 0.29838938f, 
    -0.01415532f, -0.09827118f, 0.02411778f, 0.05155894f, 0.08298946f, 0.00924593f, -0.02930216f, 0.13316816f, 
    -0.10195291f, -0.11252396f, 0.05509363f, -0.05494679f, 0.07388993f, -0.11367713f, -0.03467368f, -0.03144843f, 
    -0.02059365f, 0.07334570f, -0.00468382f, 0.11051293f, -0.16569996f, 0.19848581f, 0.15809681f, 0.12769386f, 
    -0.05806112f, 0.00325956f, 0.07388483f, -0.04410249f, 0.08608727f, -0.05509345f, -0.09682060f, 0.01064554f, 
    0.28178367f, 0.19973288f, 0.00816729f, -0.12853231f, -0.02168776f, 0.06377230f, 0.07392575f, -0.11174705f, 
    0.09218499f, 0.03465982f, 0.07919498f, 0.11547918f, -0.19720493f, 0.06377853f, 0.00434511f, 0.00959848f, 
    -0.06349971f, -0.00824870f, -0.10983161f, -0.00937767f, 0.13123499f, 0.04291900f, 0.12457711f, 0.24252488f, 
    -0.68704587f, 0.10014576f, -0.10667229f, -0.04628528f, 0.11998239f, 0.02206246f, -0.07940388f, 0.04408758f, 
    0.00684732f, -0.18142596f, 0.06122991f, 0.11406970f, -0.21270546f, 0.06912381f, 0.13266101f, 0.14831887f, 
    0.05295833f, 0.06712229f, 0.02446489f, 0.03616285f, 0.12223504f, -0.06279683f, -0.08340839f, -0.03845903f, 
    0.30648339f, 0.13953349f, 0.09610453f, 0.12731989f, 0.07945884f, 0.00780980f, -0.12459087f, 0.00603033f, 
    -0.08729009f, 0.10312839f, -0.03015161f, 0.10205368f, -0.28827316f, -0.10494103f, 0.01973500f, 0.02050000f, 
    0.07271720f, 0.07796207f, -0.00291460f, 0.07502311f, -0.01857201f, 0.04428678f, 0.10056158f, -0.08685228f, 
    0.06698091f, -0.07787175f, 0.11524492f, -0.08281533f, 0.00159019f, 0.02435290f, -0.12887798f, 0.04964558f, 
    0.01691297f, -0.05452484f, 0.04495928f, 0.07876128f, -0.19118816f, 0.16824920f, -0.04370354f, -0.21378934f, 
    0.15369143f, -0.02187513f, 0.08749496f, -0.10627377f, 0.11643513f, 0.08529279f, -0.00816404f, 0.08280358f, 
    -0.00930230f, -0.00399457f, -0.03645709f, -0.00853006f, -0.01640602f, -0.07146414f, 0.01016197f, -0.05338957f, 
    -0.13339053f, 0.02538170f, -0.00453117f, -0.07028020f, 0.16578507f, -0.20355643f, -0.12689909f, -0.14288661f, 
    0.12280042f, 0.03872723f, -0.00721776f, -0.08812457f, -0.05063571f, -0.09100718f, 0.17763011f, -0.02666673f, 
    -0.09518725f, 0.20105053f, 0.11264547f, -0.05247630f, 0.02599546f, 0.09280194f, 0.01843836f, -0.04468489f, 
    0.03971146f, 0.02106898f, -0.07206775f, -0.01171445f, 0.15987323f, -0.04797869f, 0.10513492f, -0.08509616f, 
    0.06126132f, 0.12770046f, -0.03503179f, 0.02354830f, 0.02156471f, -0.01294912f, 0.00452458f, -0.02147160f, 
    0.01704136f, -0.18550837f, -0.13277255f, -0.05914810f, -0.00216034f, -0.04746882f, -0.00915494f, -0.01844152f, 
    -0.01296557f, -0.01813059f, -0.04202873f, -0.07288206f, 0.39067751f, 0.33912206f, 0.25394258f, -0.05436896f, 
    -0.15424663f, -0.02745626f, 0.09556579f, 0.02442784f, -0.02407257f, 0.00575344f, -0.13883600f, 0.04384777f, 
    -0.05410166f, 0.03238290f, -0.03686335f, 0.22927555f, 0.02421331f, 0.04687699f, 0.12781955f, -0.07990196f, 
    -0.18474720f, 0.09250045f, -0.12020166f, -0.01606820f, 0.29344019f, 0.07004392f, 0.05246307f, -0.00219374f, 
    -0.02973582f, 0.07391620f, 0.08005320f, 0.07341311f, -0.02643119f, -0.08419050f, 0.03981921f, -0.04559097f, 
    -0.08088750f, 0.05861834f, -0.14651522f, 0.13528982f, -0.00046107f, -0.00608599f, 0.06631999f, -0.00660653f, 
    0.00097557f, -0.06198439f, 0.03079330f, -0.05188350f, -0.14309084f, -0.29111803f, -0.04889275f, 0.02323789f, 
    -0.01344642f, -0.00943044f, -0.03617519f, -0.05753660f, 0.06941139f, 0.11489107f, -0.07688685f, -0.02406653f, 
    0.04842801f, -0.16486681f, 0.18088818f, 0.17571145f, -0.00824675f, -0.03103265f, 0.10468803f, -0.05693480f, 
    0.08153909f, -0.05360455f, 0.06707980f, 0.02153232f, -0.23181325f, 0.01423402f, 0.11957956f, 0.00894377f, 
    0.02378203f, 0.14123079f, 0.09394982f, -0.07563283f, -0.00481779f, -0.04048649f, 0.10031272f, -0.01877726f, 
    0.26595515f, -0.01290563f, 0.06868814f, 0.09217755f, -0.05037336f, 0.08055774f, -0.08605073f, 0.02466651f, 
    0.04476899f, 0.04378325f, -0.13971944f, 0.03227357f, -0.16199602f, -0.02608398f, -0.03621458f, 0.03642587f, 
    -0.00454806f, 0.12185335f, 0.12842007f, -0.12388909f, -0.00894568f, 0.06513071f, 0.01709868f, -0.01610018f, 
    -0.08981948f, -0.11233710f, 0.10628249f, -0.18151061f, 0.02562974f, 0.03712265f, 0.06840462f, 0.09423301f, 
    -0.06544858f, -0.07596293f, -0.07496319f, -0.05675075f, -0.39065790f, 0.03878289f, -0.10934718f, -0.19386992f, 
    0.00465002f, 0.04232418f, -0.01664600f, 0.04137156f, 0.13295767f, -0.02425188f, 0.08473384f, -0.06568530f, 
    -0.12481484f, 0.01304056f, -0.02303236f, 0.19135228f, -0.17241909f, 0.01199559f, -0.03622983f, -0.03786355f, 
    0.07669435f, 0.02753426f, -0.09873302f, -0.01846224f, 0.06580688f, 0.05889592f, 0.25791889f, -0.20403235f, 
    0.11176177f, -0.13469160f, 0.02330932f, 0.05372404f, 0.08455397f, -0.12335689f, -0.01177450f, 0.00160036f, 
    0.14524907f, 0.03574859f, -0.06983186f, 0.00568020f, -0.08321641f, 0.02464614f, -0.17604926f, -0.02748352f, 
    -0.00546468f, -0.09466342f, 0.06617461f, 0.03547924f, 0.03233407f, -0.00233467f, -0.12699127f, -0.06923173f, 
    -0.04856303f, -0.09381392f, 0.06420233f, 0.05030182f, 0.06278659f, -0.00027643f, -0.01995865f, -0.04256843f, 
    0.02701846f, 0.00008019f, 0.15531047f, -0.00728199f, -0.04197769f, -0.02135133f, 0.06206767f, 0.10795702f, 
    -0.01561846f, 0.10502301f, 0.04748091f, -0.03962380f, 0.11346088f, 0.05347816f, 0.11472608f, 0.02290981f, 
    0.08344463f, -0.04458093f, -0.03386313f, 0.08992544f, 0.04556554f, 0.04118414f, 0.00641571f, -0.06870237f, 
    -0.15678933f, -0.02919627f, -0.13176347f, -0.22559090f, -0.15409383f, 0.11648919f, -0.00314541f, -0.08700138f, 
    -0.06944979f, -0.15658650f, 0.04327364f, 0.03568750f, 0.37134865f, 0.00838268f, 0.06354238f, 0.07840470f, 
    0.08488446f, 0.10490103f, -0.12106720f, 0.03604515f, 0.08365035f, 0.02259333f, 0.16306727f, 0.00278506f, 
    0.02470281f, 0.00604747f, 0.16340892f, -0.09396997f, 0.03148893f, -0.04138517f, -0.04439580f, -0.03582289f, 
    -0.00251322f, -0.06076271f, -0.07991382f, -0.05600619f, -0.18623468f, 0.05527585f, -0.04740163f, -0.35710528f, 
    -0.01712472f, -0.07049106f, 0.10786174f, -0.02421172f, 0.09607417f, 0.05038058f, -0.01428133f, -0.06467587f, 
    0.43668362f, -0.31912562f, -0.18065342f, 0.22793116f, -0.03490685f, 0.07627705f, 0.04383254f, 0.00734349f, 
    0.08669097f, 0.04102602f, -0.04240185f, 0.12077413f, 0.46234193f, 0.10044342f, -0.02035064f, 0.13221587f, 
    0.12113176f, 0.03568251f, -0.02153480f, -0.02803328f, -0.01605698f, 0.06318131f, 0.02054680f, 0.09498719f, 
    0.03756236f, 0.05582465f, 0.12337358f, 0.25493848f, -0.02597829f, -0.08452751f, 0.09370823f, 0.16065726f, 
    0.06073833f, -0.02910479f, -0.10090464f, 0.07833438f, 0.42446214f, 0.09832460f, 0.07448711f, -0.11666120f, 
    0.02303664f, -0.03827325f, 0.05721187f, 0.04252809f, -0.01750082f, 0.11478737f, -0.09433861f, 0.00363188f, 
    -0.03045008f, 0.01382562f, -0.04196773f, 0.02382542f, 0.02599335f, 0.18949245f, -0.02994995f, -0.00575509f, 
    0.04092039f, -0.08516876f, -0.00643176f, -0.00945623f, -0.23602128f, -0.16266282f, -0.13126479f, 0.12723218f, 
    -0.04522082f, 0.00909313f, -0.11535378f, 0.04980557f, -0.03106949f, 0.09803103f, -0.03677052f, -0.13936841f, 
    -0.05707610f, 0.04363225f, 0.21870919f, -0.17502031f, 0.06452496f, -0.04501852f, -0.03732231f, 0.00196790f, 
    0.00470669f, 0.02566499f, -0.04949231f, 0.14214005f, -0.07016559f, 0.19227462f, 0.27368423f, 0.09014909f, 
    0.03542936f, 0.12079355f, -0.13609855f, 0.19435011f, 0.07970593f, -0.00827566f, 0.11520296f, 0.03004223f, 
    0.24670289f, -0.02296083f, 0.04469763f, -0.13660334f, -0.09227284f, 0.00217667f, -0.01396250f, -0.04444341f, 
    0.07196756f, -0.01730672f, 0.09841312f, 0.12400902f, 0.18862247f, -0.17100552f, -0.12851459f, -0.00325917f, 
    0.09281842f, 0.11494862f, -0.09133538f, -0.08440737f, 0.04567054f, -0.07065470f, 0.05205113f, -0.10974141f, 
    -0.18559010f, -0.08472282f, -0.02283471f, 0.08311152f, 0.02194576f, 0.10588420f, -0.11439244f, 0.02647238f, 
    -0.02019189f, -0.03912191f, 0.10553506f, -0.03281988f, -0.24184027f, 0.10722756f, -0.00384381f, -0.38508597f, 
    0.11343046f, -0.06368655f, 0.09370753f, 0.04453306f, -0.07857611f, 0.13655894f, -0.09599950f, 0.03954284f, 
    -0.25380316f, -0.02212727f, 0.00723256f, -0.05180837f, -0.01329428f, -0.06823625f, 0.06214428f, -0.08739763f, 
    -0.03918620f, 0.14202733f, -0.13117403f, -0.01328882f, 0.29287463f, 0.13777409f, -0.00158137f, -0.03314692f, 
    0.06686284f, -0.11897136f, -0.01812523f, 0.11612340f, 0.02154152f, 0.00943200f, 0.08914809f, 0.07383063f, 
    -0.01464960f, -0.14029106f, 0.30561063f, 0.11192235f, 0.19305328f, -0.00156319f, 0.15892652f, -0.10334349f, 
    0.00029513f, -0.05586321f, 0.07573608f, 0.04638553f, 0.08356425f, 0.05965590f, -0.24805588f, -0.35779595f, 
    0.03256365f, -0.04131015f, 0.08026853f, -0.03665817f, 0.12193446f, -0.02939431f, 0.20210235f, 0.14038697f, 
    0.14213540f, -0.06995738f, 0.03269330f, -0.04253764f, -0.04431843f, -0.07242632f, 0.01087381f, 0.09489449f, 
    0.02976077f, -0.00977559f, 0.07449470f, -0.02691892f, 0.19155358f, -0.00281203f, 0.01399346f, 0.08219139f, 
    0.10091154f, 0.06982686f, -0.01710380f, -0.05205867f, -0.01064736f, 0.02272353f, -0.02451823f, 0.02720107f, 
    -0.06497916f, 0.04561440f, 0.06638199f, 0.11609575f, 0.10320128f, 0.04616069f, -0.06829032f, -0.02026947f, 
    0.11944278f, 0.05124738f, -0.13441449f, 0.03346340f, -0.07407557f, -0.05329866f, 0.04299482f, 0.08024742f, 
    0.04085101f, 0.10692167f, 0.00065298f, -0.03929456f, -0.02295365f, 0.00687051f, 0.03210958f, 0.05499049f, 
    -0.25472626f, 0.11552705f, 0.10502145f, 0.13799934f, 0.00308587f, 0.08237708f, 0.02318076f, -0.07368362f, 
    0.06005127f, 0.15469958f, 0.12554616f, 0.10721623f, 0.01319294f, -0.03700072f, 0.17008606f, 0.28869000f, 
    0.06837659f, -0.08865689f, 0.06314439f, 0.00756721f, -0.08930217f, -0.09376600f, 0.09980108f, -0.12973288f, 
    -0.01230820f, 0.09354500f, 0.13161871f, -0.07333849f, 0.04995291f, -0.05987849f, 0.02132782f, 0.06488843f, 
    0.02639785f, 0.04354147f, 0.04096479f, -0.01498614f, 0.01391955f, 0.16856281f, -0.05999099f, 0.02625527f, 
    0.00143489f, 0.01962441f, -0.00538929f, -0.04775505f, 0.08190603f, 0.05122518f, -0.19915549f, 0.09180564f, 
    0.06441993f, -0.21469617f, 0.04969568f, -0.02099270f, 0.06813922f, 0.00788709f, -0.00355792f, 0.00753988f, 
    0.00827600f, -0.01268619f, 0.00251090f, 0.07606643f, -0.05130873f, 0.14295593f, -0.14508256f, -0.06583355f, 
    0.14488336f, 0.15624523f, 0.01976771f, 0.09432638f, -0.00187813f, -0.01612337f, -0.04991774f, 0.05493251f, 
    0.08225977f, 0.22260231f, 0.04538907f, 0.01372160f, 0.10698128f, 0.08737753f, -0.11586478f, 0.00252541f, 
    -0.01363169f, -0.05142951f, -0.05339376f, 0.00343983f, -0.06580143f, -0.10677385f, -0.11225294f, -0.07783605f, 
    -0.02410973f, 0.05253411f, 0.05225798f, 0.00569504f, 0.04695656f, 0.00648913f, 0.06588349f, 0.10902511f, 
    -0.17160320f, -0.14531459f, 0.14670236f, 0.16618192f, 0.07692157f, -0.11557464f, -0.08593073f, 0.09451465f, 
    0.04162795f, -0.02243581f, 0.08512682f, 0.02608133f, -0.17231448f, 0.16675098f, 0.05432097f, 0.04991542f, 
    0.08378155f, -0.08811071f, -0.00487646f, -0.04651229f, -0.06871571f, 0.04669744f, -0.06673374f, 0.01487524f, 
    0.52591741f, 0.13703147f, 0.10575893f, -0.00772243f, -0.08110671f, 0.14961016f, -0.00157487f, -0.04170194f, 
    -0.02340668f, -0.02299970f, -0.00550591f, 0.06083534f, -0.06220899f, 0.12632269f, 0.04761963f, 0.16298176f, 
    -0.13287373f, -0.08927973f, -0.05368215f, 0.07857817f, 0.07068229f, -0.06278288f, 0.08782607f, 0.14395015f, 
    -0.39501646f, 0.29437232f, -0.19874671f, -0.14881875f, 0.08091675f, -0.02651451f, -0.07727439f, 0.07339211f, 
    0.01811573f, -0.02834161f, -0.04564477f, 0.01719512f, 0.00208729f, -0.03691337f, 0.07539653f, 0.05808050f, 
    0.06919920f, -0.06825829f, 0.05088434f, -0.01653779f, 0.12040880f, -0.01417247f, -0.11863823f, -0.01454105f, 
    -0.10480643f, 0.27445158f, 0.00913815f, -0.07979330f, 0.04067376f, -0.09555533f, -0.00678991f, -0.14121783f, 
    -0.07319206f, 0.02467511f, 0.08511809f, -0.04323550f, -0.22070014f, -0.13203588f, -0.05807823f, -0.11389191f, 
    0.19290885f, 0.00565942f, -0.09399924f, 0.02300313f, 0.09889228f, -0.14549313f, 0.12268526f, -0.05941058f, 
    -0.03469984f, 0.04810271f, -0.04545785f, 0.03985557f, -0.04457464f, 0.04789560f, 0.03530804f, -0.04861194f, 
    -0.02018997f, -0.01949564f, 0.03509964f, -0.06356607f, 0.03944135f, 0.05702079f, 0.05097945f, -0.05943515f, 
    -0.07190888f, -0.01569744f, -0.01812299f, 0.00094091f, 0.01874305f, -0.07959916f, -0.04175112f, 0.00204226f, 
    -0.06763477f, -0.00644073f, -0.00177594f, 0.02208737f, -0.00938474f, 0.00976545f, 0.06328801f, 0.04160544f, 
    0.04923491f, -0.06264627f, -0.06549875f, -0.02900231f, -0.02692494f, 0.03816528f, -0.01522571f, -0.01913280f, 
    -0.05369603f, 0.01894847f, -0.00786562f, -0.05325584f, -0.04252405f, 0.01722671f, 0.04681148f, -0.00348911f, 
    0.03008508f, -0.04889908f, -0.01004897f, 0.01769416f, 0.00599024f, 0.00350997f, -0.07229730f, 0.05915735f, 
    -0.04371990f, 0.03770994f, 0.00208662f, -0.07863148f, -0.01987827f, -0.04772558f, 0.05837103f, -0.06383345f, 
    -0.04843563f, 0.01586347f, -0.07242227f, -0.03541747f, -0.00785203f, 0.01623832f, 0.02993510f, -0.04196971f, 
    0.03977353f, -0.03726055f, -0.07720662f, 0.05148889f, 0.01788411f, -0.00029442f, 0.01594415f, -0.07241733f, 
    0.03428112f, 0.04962824f, 0.04255491f, 0.05031874f, -0.02428149f, 0.00358883f, -0.05693447f, 0.06551122f, 
    -0.02595870f, -0.00976255f, -0.05190614f, -0.07656844f, -0.02508226f, 0.01610926f, -0.02782610f, 0.05360738f, 
    -0.00062446f, -0.06484331f, 0.01946700f, 0.02268722f, -0.06552709f, -0.08302223f, -0.06552491f, -0.05696591f, 
    0.01242232f, 0.02092985f, -0.05818409f, 0.02292197f, 0.01110200f, 0.02572937f, -0.02896731f, 0.00123354f, 
    -0.01205783f, -0.06669854f, -0.06493462f, -0.01536026f, 0.06866783f, 0.02799712f, -0.02641920f, -0.03493317f, 
    -0.05935165f, -0.03348976f, 0.02365920f, -0.00323577f, 0.02698317f, 0.04074014f, 0.04069411f, 0.03383143f, 
    0.02338700f, -0.03303752f, -0.04683596f, 0.01171576f, 0.00084885f, 0.03135770f, -0.07792744f, -0.00815635f, 
    -0.06931925f, -0.04632973f, -0.03978327f, -0.02462206f, 0.06113711f, 0.03533441f, -0.01041205f, 0.04451254f, 
    0.01965704f, -0.06967558f, -0.02157685f, 0.07147256f, -0.05154772f, -0.07101379f, -0.00798540f, -0.02996935f, 
    -0.05985333f, 0.00051801f, 0.05674136f, -0.02929698f, 0.02208621f, -0.07021283f, -0.05464807f, -0.01085710f, 
    0.04035646f, 0.02371126f, 0.03875184f, 0.06148356f, -0.01643112f, 0.01213123f, -0.03344164f, -0.01383381f, 
    -0.05688228f, -0.00843129f, 0.05975822f, -0.01326558f, -0.05454851f, 0.04215748f, 0.01053857f, 0.03077954f, 
    0.02873538f, 0.01446602f, 0.04362372f, -0.06450383f, 0.06667870f, -0.05578532f, -0.01057654f, 0.02059056f, 
    -0.05095743f, 0.06915768f, -0.01350073f, -0.06934426f, 0.01415727f, -0.05540814f, 0.01988699f, -0.05945638f, 
    -0.01874252f, 0.00487737f, 0.10886663f, 0.18800722f, 0.06090889f, -0.00575193f, 0.18279277f, -0.09069671f, 
    -0.30208638f, 0.10630877f, 0.00682702f, -0.04759664f, 0.09059373f, 0.03559545f, 0.26278281f, 0.03467993f, 
    0.05483253f, -0.13191201f, 0.03166111f, -0.06313795f, -0.06101554f, -0.00798824f, 0.06482707f, 0.06618009f, 
    0.18287772f, 0.12237934f, 0.04197547f, 0.16947848f, -0.00244350f, 0.08055657f, -0.00079396f, 0.09636516f, 
    -0.02169587f, 0.10867579f, 0.12078581f, -0.08844106f, 0.05023289f, 0.32918817f, -0.02115872f, -0.14326112f, 
    0.15731153f, -0.06362746f, 0.10426369f, 0.02304966f, -0.04562158f, 0.17729932f, -0.10790821f, 0.09305561f, 
    0.05917296f, -0.19314614f, -0.16854592f, -0.01784901f, 0.08505855f, 0.04689898f, -0.17703095f, -0.03560299f, 
    0.03096912f, -0.08098396f, -0.03882122f, -0.09838255f, 0.10426761f, 0.13667436f, 0.11688869f, 0.09469572f, 
    -0.06957568f, 0.03398717f, 0.09890843f, 0.03388965f, -0.14851207f, -0.04388395f, 0.10615297f, -0.00212633f, 
    -0.03097269f, 0.09540590f, 0.28961474f, -0.16196030f, 0.24355368f, -0.07464630f, 0.14931898f, -0.06502293f, 
    0.11286783f, 0.03380619f, -0.11312978f, -0.07409743f, 0.06175085f, -0.13006698f, -0.08898170f, -0.08874741f, 
    0.02190530f, -0.15608525f, -0.26312956f, -0.12061831f, -0.06459295f, -0.11584779f, 0.07758610f, -0.00659655f, 
    0.17313606f, -0.06290297f, 0.16276005f, 0.17412673f, 0.01328928f, 0.10523629f, -0.01430146f, 0.01576471f, 
    0.05419392f, -0.05102554f, 0.15048207f, 0.20926109f, -0.16663755f, -0.03226658f, -0.11726078f, -0.06845215f, 
    0.05708938f, -0.05974331f, -0.05191668f, -0.02340105f, 0.00630208f, 0.00057609f, 0.07691609f, -0.00007872f, 
    0.17967813f, -0.01134077f, 0.26148653f, -0.12763554f, -0.08025742f, -0.03726416f, -0.07309807f, -0.07187426f, 
    -0.13897215f, 0.00262987f, -0.02002531f, -0.03484412f, -0.22532372f, 0.16154963f, 0.17686751f, -0.05213878f, 
    -0.07076482f, -0.11284581f, -0.03090889f, 0.01188041f, 0.08789790f, 0.02875659f, -0.06098311f, -0.12278215f, 
    0.05741048f, 0.13963270f, -0.37492681f, 0.10845013f, 0.02135006f, -0.10852540f, -0.06058286f, -0.13428740f, 
    0.06150643f, 0.18848859f, 0.01868092f, 0.07017063f, 0.51440889f, 0.00706271f, -0.06784835f, -0.10797216f, 
    0.06594225f, 0.08674163f, -0.00968287f, 0.06175295f, 0.05685936f, -0.07616355f, 0.01541625f, 0.23010683f, 
    -0.18849885f, 0.07280639f, -0.14627884f, -0.30349141f, 0.03398697f, 0.09726821f, 0.10774150f, -0.05927505f, 
    0.05982209f, 0.01564735f, 0.19382609f, 0.01540135f, 0.38570651f, 0.12497877f, 0.03955825f, -0.19311039f, 
    0.08728599f, 0.02714670f, -0.02110372f, 0.06028767f, 0.04670164f, -0.20731393f, -0.17298068f, 0.03706215f, 
    -0.06610808f, -0.06155305f, -0.03857057f, -0.02421350f, -0.06689031f, -0.04378538f, 0.03220988f, -0.08872154f, 
    -0.05638915f, -0.04366904f, -0.09037001f, -0.10026108f, -0.09115794f, 0.08327778f, -0.05272418f, -0.04707316f, 
    -0.00386865f, -0.03861330f, 0.09191685f, -0.01883150f, -0.01200142f, -0.01084029f, -0.02151066f, -0.06461358f, 
    -0.00988327f, -0.06154663f, -0.04522156f, -0.04064810f, -0.04314331f, 0.02108319f, 0.01234571f, -0.01387149f, 
    -0.05870951f, -0.06155983f, 0.00982813f, -0.10108413f, 0.02275054f, -0.00044325f, -0.05121092f, 0.06031730f, 
    0.01380257f, 0.00461391f, -0.03897522f, -0.08697332f, -0.08908857f, -0.01449347f, 0.04275472f, -0.01678594f, 
    -0.04373567f, -0.00339984f, 0.00761566f, 0.01124109f, -0.05916129f, 0.03017532f, 0.04070479f, -0.04075076f, 
    0.06901436f, 0.06265115f, -0.04691232f, -0.01721325f, 0.03251468f, -0.07553662f, 0.01444441f, -0.03353525f, 
    -0.04897165f, -0.10307007f, 0.04594508f, 0.02037688f, -0.03908799f, -0.04089582f, -0.08004593f, 0.00690220f, 
    -0.03701731f, -0.02608723f, -0.03695239f, -0.03174626f, 0.03680895f, -0.06051319f, -0.09361409f, -0.00395954f, 
    0.06180137f, -0.02564071f, 0.01616118f, 0.04899566f, -0.08704019f, -0.09344651f, -0.10428923f, -0.05605171f, 
    -0.07698444f, 0.07850829f, 0.00915153f, 0.05804341f, 0.02713465f, 0.02603569f, 0.02379314f, 0.00383461f, 
    -0.01081650f, -0.01650249f, 0.00979223f, -0.00074752f, -0.01967065f, -0.10534977f, -0.09100134f, -0.07760578f, 
    -0.08272628f, -0.09387981f, -0.03057666f, -0.04785809f, -0.12590370f, -0.03929031f, -0.03695291f, 0.02602824f, 
    0.05053570f, 0.02485307f, -0.01644699f, 0.01307531f, 0.03044850f, 0.00450943f, -0.01116840f, -0.06036416f, 
    -0.05886045f, -0.11726142f, -0.01135936f, -0.02762138f, -0.05359093f, -0.06285210f, -0.02854336f, 0.06957307f, 
    -0.07548428f, -0.05765864f, -0.01257591f, -0.05476398f, -0.09224374f, -0.08159187f, -0.07349347f, -0.01153931f, 
    0.04810693f, 0.01152246f, -0.00749393f, -0.02068912f, -0.02561641f, -0.09448805f, 0.04803954f, 0.03540518f, 
    -0.02598200f, -0.06701445f, 0.00005478f, -0.06195781f, -0.07117148f, 0.01842549f, 0.01139723f, -0.08775047f, 
    -0.05938676f, 0.00443426f, -0.07503562f, -0.07662086f, -0.00246208f, -0.05782993f, -0.02433484f, 0.03726321f, 
    -0.06175274f, -0.14845364f, 0.00728296f, -0.03107406f, 0.04664636f, -0.03257754f, -0.01884343f, -0.08020508f, 
    0.01459403f, -0.02831833f, 0.04688403f, -0.06768447f, -0.00445358f, -0.06205539f, -0.05440684f, 0.05385617f, 
    -0.02291876f, 0.05786516f, -0.06692216f, -0.09627312f, -0.03707375f, -0.05687728f, 0.01012402f, -0.00272835f, 
    -0.02309544f, 0.01657534f, 0.01020307f, -0.04146234f, 0.02927999f, -0.01099203f, -0.03957354f, -0.02159947f, 
    0.15219726f, 0.05440415f, -0.08745270f, -0.26723787f, 0.19238117f, -0.02285995f, -0.05720664f, 0.03778820f, 
    0.05871405f, -0.02187264f, 0.02952470f, 0.03487083f, -0.05136835f, -0.10009962f, -0.02645695f, 0.00368861f, 
    -0.08441708f, 0.04133591f, 0.03613989f, 0.00422994f, -0.04857862f, 0.00113432f, -0.01323965f, 0.09537387f, 
    0.22828966f, 0.06019029f, -0.03223254f, -0.08385102f, 0.09946380f, 0.05134124f, 0.02394397f, -0.02058428f, 
    -0.03125152f, -0.00657857f, 0.14959615f, 0.11646236f, -0.04727788f, -0.00355014f, -0.02154116f, 0.10862339f, 
    -0.07451068f, -0.08255170f, -0.00861268f, -0.07026292f, -0.02741829f, 0.02399961f, -0.05826474f, -0.03787161f, 
    -0.00457526f, 0.10040087f, -0.10554832f, 0.11435484f, 0.00816618f, 0.11730741f, -0.00715509f, 0.14684732f, 
    0.02601595f, 0.03222664f, -0.04521739f, 0.09502289f, 0.09149593f, 0.17293879f, -0.00370162f, 0.15447083f, 
    -0.07367948f, -0.15600722f, 0.13041286f, -0.14154558f, 0.15088470f, 0.03911312f, 0.01886562f, 0.08840821f, 
    0.32586959f, -0.07650162f, 0.02528500f, 0.09015628f, 0.09993585f, -0.08356162f, 0.15995148f, -0.00200569f, 
    -0.04575824f, -0.06881493f, -0.03519066f, 0.01921380f, -0.11339864f, -0.09444918f, -0.17827579f, 0.10864361f, 
    0.05449428f, 0.11810283f, -0.03734300f, -0.02256786f, 0.06754335f, -0.05339881f, 0.01293340f, 0.04116581f, 
    0.03441945f, -0.08726314f, -0.10716916f, -0.11557926f, -0.05838938f, 0.02249104f, -0.09554460f, -0.09308422f, 
    0.11782560f, 0.06035647f, 0.06755631f, 0.01062700f, -0.04472616f, -0.40044972f, 0.11952447f, 0.12226289f, 
    -0.04411273f, 0.05014133f, -0.08644731f, -0.06705901f, -0.03322680f, 0.06815273f, -0.04548563f, 0.02566870f, 
    -0.00273947f, 0.19173846f, -0.15098460f, -0.17701720f, 0.04131200f, -0.09464154f, 0.07477825f, -0.02695828f, 
    0.03510913f, 0.05570014f, 0.03900225f, 0.06356859f, 0.09811308f, -0.04865635f, 0.06991112f, 0.31076783f, 
    0.09324867f, 0.11193126f, -0.02741460f, -0.01305818f, -0.07900628f, 0.08439554f, 0.03471597f, -0.09422357f, 
    -0.10530647f, 0.07382670f, -0.07469866f, -0.04793252f, -0.05241750f, 0.08407116f, 0.04504911f, -0.16024698f, 
    -0.09063342f, 0.00224001f, 0.10792220f, -0.17253958f, -0.19616379f, 0.07212391f, -0.14983355f, -0.09946445f, 
    -0.06801678f, 0.01410999f, -0.04016697f, 0.21887216f, 0.00585068f, -0.01386848f, 0.01005971f, 0.01530756f, 
    -0.07037398f, -0.26071319f, -0.13241038f, -0.18141334f, 0.14735229f, -0.04970272f, 0.13744977f, 0.12625916f, 
    0.09184813f, 0.01915030f, -0.01457686f, -0.13650846f, 0.33226281f, 0.16072305f, 0.01567837f, 0.14213319f, 
    -0.11561188f, 0.04350379f, 0.12294449f, 0.11959986f, -0.08469875f, -0.04558666f, -0.05986546f, -0.06040455f, 
    -0.26228642f, -0.04975655f, 0.04864354f, -0.01338471f, 0.00659330f, -0.06288907f, 0.12148031f, -0.02099087f, 
    0.16098778f, -0.02581802f, -0.12445832f, -0.09784484f, -0.02394148f, -0.19826382f, -0.09037353f, -0.09791045f, 
    0.03712677f, 0.12627712f, 0.03691573f, -0.01452359f, 0.01348957f, -0.00596324f, 0.03793598f, -0.05987545f, 
    -0.07777818f, -0.02244646f, 0.01562500f, 0.00675446f, -0.10699040f, -0.04357812f, -0.17125013f, 0.00682908f, 
    0.17318156f, -0.06217824f, 0.09428508f, -0.04338250f, -0.19693628f, -0.03745311f, -0.01374853f, 0.01961191f, 
    0.01807129f, 0.07057709f, 0.09579342f, 0.14342517f, -0.02906108f, -0.04480619f, 0.12210260f, 0.07811990f, 
    0.31291851f, 0.04395320f, -0.15802070f, 0.00968179f, 0.03711969f, 0.01961004f, 0.02766297f, -0.08744907f, 
    -0.06780588f, -0.06388436f, 0.00791790f, -0.16279256f, 0.03756641f, -0.03952070f, -0.11976993f, 0.24325639f, 
    0.06510550f, -0.09222507f, -0.00603021f, 0.06386073f, -0.06059224f, -0.04909562f, -0.09959836f, -0.00671302f, 
    -0.03478249f, -0.27785075f, 0.25346190f, -0.14590077f, -0.02224217f, -0.04154327f, 0.16200353f, 0.15394576f, 
    0.00585886f, 0.09521214f, 0.05817351f, -0.11163110f, 0.41032004f, 0.33355507f, 0.21379745f, 0.30437940f, 
    0.05722147f, -0.19489580f, 0.08728823f, -0.16327175f, 0.04171962f, -0.00621313f, 0.07381917f, 0.15335740f, 
    -0.00168099f, -0.17268409f, -0.02882173f, 0.09758700f, -0.05216971f, 0.05642937f, -0.01567827f, -0.08300416f, 
    -0.11933546f, -0.00044093f, -0.00472894f, -0.02461867f, 0.28693891f, 0.22856617f, 0.07089214f, -0.25706196f, 
    0.17131232f, 0.15410236f, -0.07256109f, -0.04004601f, 0.09411921f, 0.04369663f, 0.05503594f, 0.04093153f, 
    0.15964946f, 0.17080756f, 0.21711682f, 0.04578552f, -0.14631414f, -0.01151349f, 0.18806723f, 0.01178162f, 
    0.04856726f, -0.08211453f, 0.12333367f, -0.03168242f, -0.26540744f, 0.03036892f, 0.00435704f, -0.01952215f, 
    -0.20796639f, 0.02025167f, -0.11172391f, -0.05944793f, -0.00469805f, -0.04182441f, 0.05247236f, 0.00860210f, 
    0.05249082f, -0.16276634f, -0.05520479f, -0.10058882f, -0.06735387f, 0.03906096f, -0.05668592f, 0.02968323f, 
    0.10900374f, -0.02486352f, 0.07228056f, -0.00314398f, -0.02431995f, -0.17467552f, 0.03061950f, -0.10652722f, 
    0.25909764f, 0.15224595f, 0.04043819f, -0.05784362f, 0.07026570f, 0.16862552f, 0.10956029f, 0.05232460f, 
    0.22945499f, 0.05285906f, 0.15249537f, 0.12254840f, 0.06386575f, 0.00686593f, 0.09352016f, 0.12288046f, 
    0.13893737f, 0.00135555f, 0.08288208f, 0.10897855f, -0.26747414f, -0.20903662f, -0.02156176f, -0.07602862f, 
    0.29973620f, 0.08599526f, 0.09652276f, 0.16118596f, 0.01944457f, 0.12021516f, -0.18901230f, -0.12906043f, 
    0.01937994f, -0.02873724f, 0.02143256f, 0.18405375f, 0.03221877f, -0.07666070f, 0.05119461f, 0.05814071f, 
    -0.01143489f, 0.10372450f, 0.01748206f, 0.05181127f, 0.09158108f, 0.07218917f, 0.18794711f, 0.16200684f, 
    -0.07059561f, 0.10144895f, 0.12444320f, 0.12458882f, -0.06154513f, -0.07534755f, -0.04532174f, -0.06799629f, 
    -0.07042675f, 0.07365981f, 0.11496987f, 0.09595890f, 0.04516134f, -0.03965458f, 0.13368605f, 0.05682726f, 
    0.02887883f, 0.01625827f, 0.04246075f, 0.10151760f, -0.00431719f, -0.19787294f, -0.00438273f, 0.01253278f, 
    0.02580136f, -0.00974701f, -0.07247198f, -0.00108794f, -0.03208167f, 0.13277683f, -0.09724776f, 0.11181566f, 
    -0.19478725f, -0.00086342f, 0.04166389f, -0.12625019f, 0.05179951f, 0.07659885f, 0.06714496f, 0.02663491f, 
    -0.05117945f, -0.00121724f, 0.07581256f, 0.05983796f, -0.24974807f, 0.12493511f, -0.32635143f, 0.05178289f, 
    0.04724292f, 0.02710510f, 0.07528744f, 0.14302365f, 0.00395373f, 0.02353890f, -0.07965932f, -0.01367462f, 
    0.44070712f, 0.03901113f, 0.21856609f, -0.04222782f, 0.00219777f, 0.00733964f, -0.00405846f, 0.00017640f, 
    0.01787604f, 0.00471159f, -0.02829535f, 0.14285959f, 0.06409745f, -0.17617205f, -0.09773552f, 0.22839768f, 
    0.03469867f, 0.03425793f, 0.04720039f, -0.04621109f, 0.08367790f, -0.10780665f, 0.09723201f, 0.14096650f, 
    -0.14869282f, -0.04004962f, 0.06422972f, -0.13820660f, 0.01646154f, 0.07628934f, -0.04975540f, 0.09442542f, 
    0.18811499f, 0.03126934f, 0.15072712f, 0.12864251f, -0.22361232f, 0.12429838f, 0.02345250f, 0.13044928f, 
    0.14112607f, 0.00127905f, -0.01495873f, 0.00834296f, 0.02471431f, 0.00501880f, -0.06035045f, 0.07816217f, 
    0.52747786f, 0.20571588f, 0.03561186f, -0.07279827f, -0.02486560f, 0.03565091f, -0.01274578f, 0.05409180f, 
    0.03750404f, -0.09482761f, 0.02925701f, 0.03656757f, 0.09296494f, -0.00195035f, 0.15781827f, 0.23105614f, 
    0.01779930f, 0.05179906f, -0.01574483f, -0.00481708f, 0.03489961f, 0.05382655f, 0.04924789f, 0.01902395f, 
    -0.53293562f, 0.27738908f, -0.08615317f, 0.01562581f, 0.13137750f, 0.02118763f, -0.04495116f, 0.09780796f, 
    -0.02322714f, -0.03404856f, 0.06391701f, 0.00295580f, -0.26924744f, 0.07131049f, 0.01454723f, -0.08816390f, 
    -0.05904269f, 0.00280793f, -0.03981894f, -0.06703870f, -0.00140078f, 0.08296605f, -0.01523306f, -0.09058588f, 
    0.07605706f, 0.05942656f, 0.00391962f, -0.03670072f, 0.09323742f, -0.12537828f, -0.04003951f, -0.02949543f, 
    -0.09872349f, 0.10264150f, 0.10224923f, -0.06082705f, -0.08437826f, -0.10770617f, -0.10271956f, -0.23289682f, 
    0.00925970f, 0.00005896f, -0.01550746f, 0.04869765f, 0.02943671f, -0.13371079f, 0.02352582f, -0.03943468f, 
    -0.22344320f, 0.08980261f, -0.05766580f, 0.01104805f, 0.04573075f, 0.10026422f, 0.01736720f, -0.06221180f, 
    0.04113863f, 0.00884971f, -0.07328433f, -0.06365710f, 0.04332068f, -0.02221528f, -0.41663101f, -0.01094784f, 
    -0.03118613f, -0.02239736f, -0.00262314f, 0.12733549f, -0.11627606f, -0.10538909f, 0.14610362f, -0.05898087f, 
    -0.28921375f, -0.14487480f, 0.00226679f, 0.01521205f, -0.11454229f, -0.00312377f, 0.05591824f, -0.01790968f, 
    -0.04292335f, -0.00007445f, -0.01332435f, 0.01170205f, -0.05379662f, 0.08109056f, 0.34600854f, 0.09795512f, 
    -0.08185820f, 0.03472535f, -0.09487806f, 0.27552196f, 0.00374647f, 0.12627591f, 0.02168955f, 0.08728569f, 
    0.18140259f, 0.05659070f, 0.11210876f, 0.04337213f, -0.03172852f, -0.11476842f, -0.12918893f, -0.10148606f, 
    0.03296569f, 0.04478108f, -0.01388689f, 0.00351418f, 0.06473060f, 0.00143906f, -0.19842483f, 0.09301919f, 
    -0.01854508f, -0.07534169f, 0.07371148f, 0.13346107f, -0.10645247f, 0.05898244f, 0.04925633f, 0.07745831f, 
    -0.13181624f, 0.23842691f, 0.30038369f, -0.10111646f, -0.16807450f, -0.06062611f, -0.11294448f, 0.05404937f, 
    -0.11024436f, 0.02479046f, -0.01114897f, 0.11802752f, -0.22313401f, -0.17994483f, -0.02584470f, 0.36976650f, 
    0.17693338f, 0.05670191f, -0.01167303f, -0.12883681f, 0.00241033f, -0.10557750f, -0.01551662f, -0.01354790f, 
    -0.02053594f, 0.06561170f, 0.08269219f, -0.32000670f, 0.03091971f, -0.01658570f, -0.04145386f, -0.03770755f, 
    0.01658806f, 0.03707909f, 0.00008426f, -0.06683076f, 0.28010011f, 0.04932242f, 0.02885322f, 0.01444146f, 
    0.01695628f, 0.01409979f, -0.04608463f, -0.02523036f, -0.07052603f, 0.01419441f, 0.11345972f, 0.04889369f, 
    0.26460835f, -0.22246532f, 0.01630494f, -0.07414684f, 0.00962987f, 0.07385267f, 0.17731689f, 0.01917382f, 
    -0.08235672f, 0.07365262f, -0.00501997f, 0.08397282f, 0.19120975f, 0.13767676f, -0.14723410f, -0.26569727f, 
    0.13575539f, -0.14481947f, -0.02628366f, -0.03780901f, 0.14493933f, 0.02114173f, 0.14007574f, -0.00233241f, 
    0.03807785f, -0.20742308f, 0.15950643f, 0.01524366f, -0.02495740f, -0.00902567f, -0.03134283f, 0.11213344f, 
    -0.02186702f, 0.05258402f, 0.03558828f, 0.16050702f, 0.03590613f, -0.02315031f, -0.08371373f, -0.02259599f, 
    0.09579509f, 0.06736130f, -0.03194831f, 0.08266082f, 0.05623499f, 0.06913921f, -0.06504796f, 0.03742604f, 
    0.03104198f, 0.02649092f, 0.05451626f, 0.12126453f, 0.02560782f, 0.04647180f, -0.01129532f, 0.02525344f, 
    0.01182090f, 0.05508860f, 0.10134768f, -0.01557504f, 0.04723883f, -0.01732759f, 0.16777003f, -0.02201644f, 
    -0.00578104f, -0.05586416f, -0.01188352f, 0.04251872f, 0.02739307f, 0.10408589f, -0.02448547f, -0.00325901f, 
    0.08897392f, -0.10081233f, -0.02194509f, -0.26248273f, 0.06759160f, -0.04340160f, 0.02397305f, 0.15169132f, 
    0.07543474f, 0.03637378f, 0.11800324f, 0.06867256f, -0.35511574f, -0.04504022f, -0.00839098f, 0.04124651f, 
    -0.01036008f, 0.09216370f, -0.05098093f, 0.08017056f, 0.09946065f, 0.04952331f, -0.01357984f, -0.01346290f, 
    0.03043063f, 0.04328232f, 0.06819940f, -0.15817732f, 0.03105035f, -0.04420175f, 0.02285545f, -0.03222168f, 
    -0.02449600f, 0.05095040f, 0.04342454f, 0.03965407f, 0.00388314f, -0.05440797f, -0.09513881f, -0.04086854f, 
    0.04139955f, -0.03341114f, -0.05720928f, -0.02001588f, -0.00476982f, -0.07615896f, 0.05202040f, 0.06850144f, 
    0.11110791f, 0.09354281f, -0.12388205f, 0.06532826f, 0.05649255f, 0.08812798f, 0.00628332f, -0.03041395f, 
    -0.04936925f, 0.05100889f, 0.03902500f, -0.00137234f, -0.07048380f, -0.02244208f, -0.16764902f, 0.02695384f, 
    -0.08982462f, 0.08415279f, -0.00120156f, -0.10442162f, 0.04333454f, 0.06247490f, 0.01665024f, -0.01687568f, 
    0.34498808f, -0.19063772f, -0.10166308f, 0.10383166f, 0.01305791f, -0.06359893f, -0.01305712f, 0.08277978f, 
    0.01458796f, -0.03006555f, 0.02031020f, -0.01634320f, 0.13049452f, 0.32799584f, 0.00775218f, -0.05388903f, 
    0.05543545f, -0.07370187f, 0.06439535f, 0.06252617f, -0.00012134f, -0.03871579f, -0.12817046f, 0.09872310f, 
    -0.17099293f, -0.04047815f, -0.15560696f, -0.08094950f, -0.09015042f, -0.00463566f, 0.03717989f, -0.04174848f, 
    -0.04631180f, 0.13869299f, 0.00551309f, 0.03162571f, 0.26608995f, -0.13671865f, 0.13672537f, 0.10169186f, 
    0.03737781f, 0.12663175f, -0.00606213f, 0.00327745f, -0.00576822f, 0.04835232f, 0.05160501f, -0.04266646f, 
    0.18843703f, 0.37267649f, -0.08183248f, -0.06291033f, 0.18501836f, -0.10893939f, 0.00942622f, 0.06487326f, 
    0.00603818f, -0.02396024f, 0.04271064f, 0.12461612f, 0.06394685f, -0.23002292f, -0.03428067f, 0.16701335f, 
    0.06008592f, 0.11518577f, 0.01370880f, -0.05850288f, 0.06501965f, 0.06275164f, 0.06478282f, 0.02540955f, 
    0.14403759f, -0.11487143f, -0.02063384f, 0.05003462f, 0.02568325f, 0.02237969f, 0.12489498f, -0.05979490f, 
    0.12356345f, -0.12363217f, 0.14485221f, -0.09055667f, 0.02716502f, -0.04713052f, -0.00103244f, 0.04458285f, 
    -0.05017451f, 0.04446193f, -0.07233071f, 0.01029008f, -0.04632360f, 0.05531270f, 0.04561203f, -0.03098401f, 
    0.29426104f, -0.20110552f, -0.02660792f, 0.09574151f, 0.13068807f, -0.07356790f, 0.05406468f, 0.12811168f, 
    0.02344745f, -0.03151245f, -0.04564903f, -0.03816780f, 0.24733369f, -0.08645622f, -0.03930700f, 0.12236263f, 
    -0.07867029f, 0.14454049f, 0.06010142f, 0.00890866f, 0.01721802f, 0.09043401f, 0.04147905f, -0.03001775f, 
    0.17821442f, 0.06739310f, 0.11280457f, 0.22034389f, -0.04490264f, 0.04695101f, -0.01217460f, -0.03393945f, 
    0.11835922f, 0.10711019f, 0.01282691f, 0.05177519f, 0.37260216f, 0.02395425f, 0.01453316f, -0.14221022f, 
    0.03505647f, -0.06264808f, 0.01882440f, 0.02250880f, 0.00667399f, 0.00029567f, -0.03690586f, -0.05816808f, 
    0.16223629f, -0.21567784f, 0.01047216f, -0.03950317f, 0.08320684f, -0.00561634f, -0.01961166f, -0.05819584f, 
    -0.14330837f, 0.00739649f, -0.08436450f, 0.17420025f, 0.14619289f, -0.08677948f, -0.00289963f, 0.02356259f, 
    -0.16442288f, 0.10624412f, -0.00286685f, 0.09408075f, -0.08929071f, -0.02342617f, 0.05931688f, 0.04436745f, 
    0.03646982f, 0.18375573f, 0.07404684f, -0.17181221f, 0.04015822f, -0.11963803f, 0.07438096f, 0.02392024f, 
    0.06517870f, 0.13947023f, 0.13256258f, 0.08571995f, 0.16001487f, 0.03850100f, 0.08822213f, 0.04313732f, 
    0.04261094f, 0.04459229f, -0.03723868f, 0.10626144f, 0.07596659f, 0.07580548f, 0.03703796f, -0.01381514f, 
    -0.15633781f, -0.05215919f, -0.08926663f, -0.09389129f, 0.02300824f, 0.07229262f, -0.07219814f, -0.01613672f, 
    0.03654759f, -0.16553129f, 0.03287455f, 0.16885050f, -0.16347153f, -0.13475136f, -0.06164992f, 0.18754570f, 
    -0.00548763f, -0.07096288f, 0.05945515f, -0.09181776f, 0.08838801f, 0.08781213f, -0.01826311f, 0.14020558f, 
    0.05535034f, 0.04159923f, 0.08724876f, 0.13255835f, 0.19631682f, -0.11874490f, 0.01608706f, 0.05005577f, 
    -0.04097569f, 0.26375097f, -0.16547389f, 0.01857658f, -0.28293058f, 0.25262529f, -0.00313858f, -0.12450373f, 
    -0.00756106f, 0.05217830f, -0.00129058f, 0.09425148f, 0.02862636f, -0.03724137f, -0.08997240f, 0.02184907f, 
    -0.02988932f, -0.13088503f, 0.04746401f, -0.01150887f, 0.02889783f, 0.01960392f, 0.08962800f, -0.01558753f, 
    0.07190213f, 0.06778990f, 0.08223905f, 0.06077536f, 0.00277622f, 0.10471436f, -0.03139522f, -0.00981772f, 
    0.03682403f, -0.02235479f, -0.09141812f, 0.05512209f, 0.05905782f, 0.01766681f, 0.22388086f, 0.08420295f, 
    -0.60026681f, 0.25261536f, 0.06600633f, -0.13279991f, 0.10146346f, 0.04414355f, -0.15697506f, 0.08170903f, 
    -0.15867233f, -0.01769860f, 0.01073095f, -0.00287156f, -0.35063210f, 0.09112072f, -0.04078595f, -0.07482301f, 
    0.04130668f, -0.01240311f, 0.08909628f, -0.02672181f, 0.09113620f, -0.04329346f, -0.00728683f, -0.06573840f, 
    0.27986610f, 0.03551290f, 0.05375883f, -0.05871799f, 0.02900285f, -0.04192032f, -0.00576664f, -0.20567399f, 
    -0.01877439f, -0.04073352f, -0.12046929f, 0.00273494f, -0.36579904f, 0.04603026f, -0.04249782f, 0.21631400f, 
    0.10438234f, -0.01684002f, 0.12493449f, -0.07451750f, -0.06612034f, 0.01808169f, 0.11597548f, -0.05939853f, 
    -0.05327778f, -0.06032648f, -0.05443799f, 0.01903062f, 0.04786969f, 0.05558058f, 0.03892493f, 0.01036271f, 
    0.00467940f, 0.05317273f, 0.06054029f, 0.02214676f, -0.06080396f, -0.02889163f, -0.06531889f, 0.02483149f, 
    0.04253601f, 0.04706843f, 0.03414402f, 0.05343543f, -0.00633621f, -0.06047518f, -0.07591051f, -0.03502230f, 
    0.02069317f, 0.00145235f, 0.00435148f, -0.03553894f, -0.08525182f, -0.07764456f, 0.01366017f, 0.03481515f, 
    0.03179879f, 0.00709410f, -0.02209853f, 0.05257762f, 0.03013863f, 0.00519149f, 0.01099839f, 0.04829847f, 
    -0.06610995f, 0.00279161f, 0.00362374f, -0.03827490f, 0.06396212f, -0.06411075f, -0.07755153f, -0.03892572f, 
    -0.07420228f, 0.00661529f, -0.00718827f, 0.06235013f, -0.02335060f, -0.06253316f, 0.04510281f, 0.02497642f, 
    -0.06095165f, -0.00599315f, -0.02814062f, -0.05151606f, -0.06271056f, 0.03422622f, 0.01445985f, 0.02890253f, 
    0.04644230f, 0.02506909f, 0.06331322f, 0.04980007f, -0.06031712f, 0.06604344f, 0.05790402f, 0.05659720f, 
    -0.04921469f, 0.03311012f, -0.06504608f, -0.04178389f, -0.01567583f, -0.02716280f, -0.00565825f, -0.06531761f, 
    -0.06726762f, 0.01482230f, 0.03860535f, -0.07910606f, 0.03121259f, -0.02189794f, -0.00207854f, -0.08099288f, 
    0.04712580f, -0.06761167f, -0.05779477f, -0.01807390f, -0.02772431f, 0.01766336f, -0.05791552f, 0.00041232f, 
    0.04830982f, -0.07411498f, -0.06261250f, 0.04048990f, -0.04637136f, 0.05367202f, -0.07196697f, -0.02827471f, 
    -0.01014805f, -0.00601442f, -0.03098664f, -0.03574279f, -0.02940197f, 0.00901769f, -0.04270668f, 0.02856773f, 
    -0.02286626f, -0.02877291f, -0.03905920f, -0.05712893f, -0.00277870f, -0.02352438f, -0.06396180f, 0.05673536f, 
    -0.05964936f, -0.04655172f, 0.02272519f, -0.03076962f, -0.00812818f, -0.01879275f, -0.04743287f, 0.06485644f, 
    -0.02582846f, 0.05036876f, -0.04957717f, -0.02049717f, -0.03907464f, -0.00354249f, -0.06998783f, -0.02584969f, 
    -0.04373803f, -0.07526386f, -0.00233641f, 0.04131665f, 0.04627561f, 0.02114752f, 0.06512543f, -0.04113873f, 
    -0.00431555f, -0.00978150f, -0.03446142f, -0.04772573f, -0.02495904f, -0.03133816f, 0.04093771f, 0.06389768f, 
    -0.07024313f, 0.01565789f, -0.04185901f, -0.04119510f, 0.06428291f, -0.02676306f, 0.04364192f, 0.04081639f, 
    -0.02239503f, -0.02486741f, 0.05302075f, 0.02761163f, -0.05690503f, 0.03016171f, -0.04855245f, -0.04794196f, 
    -0.01719050f, -0.01366601f, 0.00820637f, 0.04151001f, 0.06943178f, -0.01507048f, -0.08398501f, -0.06988551f, 
    -0.07052156f, 0.01894890f, -0.05296243f, -0.01766556f, 0.05436769f, 0.04603218f, 0.02879377f, 0.00941906f, 
    -0.04818399f, -0.05750934f, -0.04566095f, -0.03016581f, -0.01477768f, -0.01801278f, -0.02681886f, -0.06852487f, 
    -0.10614678f, 0.22528358f, -0.14400698f, 0.15096995f, 0.00545472f, 0.01927085f, -0.12525660f, -0.00135756f, 
    0.18969937f, 0.04643324f, 0.01739332f, -0.14017244f, 0.20923144f, 0.02145361f, -0.02313340f, 0.26104549f, 
    -0.08029848f, -0.00439947f, 0.14122966f, 0.06703828f, -0.13619606f, -0.09526288f, 0.17968699f, 0.02715686f, 
    -0.06649491f, 0.11598654f, 0.11142597f, -0.19906652f, -0.00009124f, 0.15539680f, 0.02589519f, 0.01311649f, 
    0.11734984f, 0.03294710f, 0.05357049f, -0.16613854f, -0.19282165f, 0.12268311f, 0.17885941f, 0.31567332f, 
    -0.00719696f, 0.08117162f, 0.08643345f, -0.01565535f, 0.08730952f, 0.21896568f, -0.11934599f, 0.13239126f, 
    0.13694662f, -0.19600034f, 0.11897257f, 0.12715672f, 0.03522993f, 0.00168037f, 0.06697231f, -0.07523223f, 
    -0.06934787f, 0.00781561f, 0.00835089f, -0.03261015f, -0.11711614f, -0.05322039f, -0.06539155f, 0.10400151f, 
    0.16620131f, -0.05478553f, 0.07810125f, 0.00016246f, -0.05274688f, 0.03314041f, 0.10834505f, 0.10322534f, 
    -0.05823019f, 0.18064313f, 0.04892108f, 0.10813060f, -0.00603931f, -0.05462100f, -0.01826188f, 0.03322110f, 
    -0.00960150f, 0.01577887f, -0.05640163f, -0.07057928f, -0.10389952f, -0.08434159f, -0.06786377f, 0.00020079f, 
    0.09141446f, 0.09959209f, -0.03183824f, -0.06451567f, -0.10155862f, -0.08461460f, 0.06061410f, -0.03868730f, 
    0.16429837f, -0.02475238f, 0.10451513f, -0.00588289f, 0.05299666f, 0.04767177f, -0.14862767f, 0.10677848f, 
    0.06273287f, -0.03338115f, 0.05915118f, -0.11373211f, -0.00991850f, 0.04670298f, -0.07259767f, -0.20945084f, 
    0.11278266f, -0.02467202f, 0.07221629f, 0.00307852f, -0.11452276f, 0.02777494f, -0.02205393f, 0.06292342f, 
    0.26043394f, -0.09232592f, 0.02540785f, 0.11836045f, -0.13264805f, 0.08692281f, 0.07132382f, 0.11118625f, 
    -0.04305653f, -0.02026022f, -0.03924742f, -0.07655993f, 0.19946532f, 0.06492040f, -0.01431541f, 0.24630249f, 
    0.03438249f, 0.03696048f, -0.01062951f, 0.06308391f, -0.03192072f, -0.19336419f, -0.06928340f, -0.12927271f, 
    0.01655889f, 0.15868960f, 0.06721089f, -0.22424641f, 0.03966971f, 0.10875464f, -0.00657360f, 0.01180655f, 
    0.05907779f, 0.06990360f, 0.07027556f, -0.02062890f, -0.15981521f, -0.16740753f, -0.02562913f, -0.06326798f, 
    -0.05491874f, 0.05033811f, -0.01280408f, 0.05118756f, -0.04682340f, -0.05004030f, 0.01773690f, 0.12336860f, 
    -0.21635664f, 0.16766159f, 0.03929555f, -0.05270597f, 0.06542070f, 0.01170550f, 0.02595174f, -0.00062270f, 
    0.04258699f, 0.04683851f, 0.23707326f, -0.00937087f, -0.21544842f, -0.08359659f, -0.01008287f, -0.03046478f, 
    0.01036294f, -0.08144123f, -0.13313906f, -0.00489055f, 0.04710796f, -0.13662170f, -0.04970985f, 0.04619868f, 
    0.16128239f, -0.09178975f, 0.03750001f, -0.04673527f, 0.11307722f, 0.12092409f, -0.03849514f, 0.07751004f, 
    -0.04190212f, -0.11637509f, 0.07143042f, 0.00066349f, -0.11555859f, -0.04539189f, -0.02717270f, 0.11417159f, 
    -0.03634172f, 0.01684902f, -0.06459835f, 0.08585631f, 0.11206497f, 0.14816076f, 0.03838179f, -0.02358378f, 
    -0.08383219f, 0.06214659f, 0.13881373f, 0.23797128f, -0.01379341f, -0.05310028f, 0.04120849f, -0.01805374f, 
    -0.03501761f, -0.08369231f, 0.00256946f, 0.04814301f, 0.03657451f, -0.22737280f, 0.05881671f, -0.16608018f, 
    0.12664819f, 0.00553790f, 0.07525168f, 0.02304393f, 0.02312686f, -0.08754727f, 0.04204552f, 0.04880179f, 
    -0.12639759f, 0.13709679f, 0.02510770f, -0.04020645f, -0.01028894f, 0.00997858f, -0.02466184f, 0.13895278f, 
    0.03625641f, 0.02875816f, -0.04669275f, 0.05647316f, -0.07561953f, -0.19129585f, -0.13743019f, -0.05064417f, 
    -0.08122381f, -0.01588578f, 0.02696021f, -0.08103020f, 0.10810620f, -0.08867735f, -0.07675067f, -0.01277038f, 
    -0.11276500f, 0.02577824f, 0.03328596f, 0.03257867f, -0.10639429f, 0.06508575f, -0.04912317f, 0.08696156f, 
    -0.01255923f, -0.02538219f, 0.03329377f, -0.03908683f, -0.01491571f, -0.04038330f, 0.18505375f, -0.27640298f, 
    0.08981755f, 0.07452067f, 0.09996079f, 0.15916997f, -0.04863010f, -0.06444974f, 0.00818569f, -0.04132905f, 
    -0.07846686f, 0.08772528f, -0.02343566f, -0.18576637f, -0.09855138f, 0.15220013f, 0.09169365f, 0.08431593f, 
    0.00466297f, 0.05974953f, -0.01004126f, 0.00979863f, 0.38532797f, -0.09017565f, 0.01546768f, 0.17525834f, 
    0.09050661f, -0.06986657f, -0.00042347f, 0.08073094f, -0.00127783f, -0.00833535f, 0.24383473f, 0.10270233f, 
    -0.27300185f, -0.14162526f, 0.08275878f, 0.15304418f, 0.13678475f, -0.01378599f, -0.01807835f, 0.08643146f, 
    0.03991714f, 0.05510343f, -0.04371389f, 0.10052418f, 0.25233603f, -0.10880668f, 0.04267474f, -0.13835235f, 
    0.09108390f, 0.09693506f, 0.04063226f, -0.01431111f, 0.00255323f, 0.08222231f, 0.02124402f, -0.00168837f, 
    0.16778851f, -0.03282936f, 0.07277864f, 0.18204397f, -0.04528601f, 0.05429420f, 0.07879299f, -0.03726122f, 
    0.06191203f, -0.01695898f, 0.08613762f, -0.02344292f, 0.14413492f, -0.01992325f, -0.05316161f, -0.00099830f, 
    -0.02782841f, 0.04640191f, 0.00705345f, -0.09815711f, -0.03986370f, 0.08740537f, -0.04294506f, 0.00014146f, 
    -0.15086854f, -0.28798527f, -0.05260875f, 0.10396248f, 0.09762985f, 0.09887861f, 0.15351105f, 0.13712543f, 
    0.07542944f, -0.06568915f, -0.01405912f, 0.14269000f, 0.33661747f, -0.07297811f, -0.13538773f, -0.20779377f, 
    -0.21111301f, 0.05292194f, 0.14180677f, -0.05360489f, -0.06965821f, 0.12046950f, -0.05128512f, 0.02895656f, 
    -0.03090669f, -0.02756610f, -0.04246568f, -0.04614092f, 0.04817409f, -0.01327904f, -0.02805137f, 0.00487085f, 
    0.04068675f, -0.00475342f, 0.02034090f, -0.02561412f, 0.05846571f, 0.06516125f, 0.05908682f, 0.00439201f, 
    0.04021667f, -0.01294565f, -0.06825121f, -0.02540822f, -0.02523158f, 0.03571849f, -0.03689343f, 0.01874060f, 
    -0.03614537f, 0.05896067f, 0.02079089f, -0.05334427f, -0.01263441f, 0.02118676f, -0.01724911f, 0.00731501f, 
    -0.04875714f, -0.01558425f, 0.00360696f, -0.07452071f, 0.03447238f, -0.05849716f, -0.07405461f, -0.07189878f, 
    0.06165111f, -0.02440143f, -0.06087384f, -0.02866329f, -0.01998030f, -0.06442091f, -0.03755274f, 0.02732820f, 
    -0.05883969f, -0.05499633f, 0.00568847f, -0.00779454f, 0.04665434f, -0.04348918f, 0.07720805f, -0.02530758f, 
    -0.00771614f, 0.01971127f, -0.04975514f, 0.02176313f, 0.00655417f, -0.03000534f, 0.05947203f, -0.06033856f, 
    -0.03159491f, -0.05702321f, -0.06940717f, -0.01170433f, -0.03739183f, 0.06496662f, -0.02155926f, -0.03149869f, 
    -0.05947423f, -0.02448023f, -0.00241364f, 0.07290786f, 0.05505817f, 0.02135658f, -0.03053062f, 0.04913775f, 
    0.00157317f, 0.02435378f, -0.06274176f, -0.04444960f, -0.04389894f, -0.02063097f, -0.04749360f, -0.04714170f, 
    0.01976347f, -0.02177020f, -0.02591523f, -0.01696374f, 0.00874651f, -0.07559094f, -0.02476649f, 0.00848941f, 
    -0.04839176f, 0.03131305f, 0.05409108f, -0.04706151f, -0.04910784f, -0.01710062f, 0.01434439f, 0.05081054f, 
    -0.02702007f, -0.01008297f, -0.01477883f, 0.01844656f, -0.05351568f, 0.01736135f, -0.03321621f, 0.01705465f, 
    0.01096809f, -0.02168377f, -0.03957680f, -0.01388766f, -0.03229208f, -0.05089394f, -0.01475038f, -0.03985621f, 
    0.04352627f, -0.01999533f, 0.02769605f, 0.05461459f, -0.00052444f, -0.07178614f, -0.05829772f, 0.04064408f, 
    0.02766603f, -0.03421754f, 0.02952118f, -0.03458143f, 0.04351061f, 0.02117826f, 0.02759470f, -0.01225325f, 
    -0.01554686f, 0.00933960f, -0.01658339f, -0.02426656f, -0.02637423f, 0.01606901f, 0.06183159f, -0.05863046f, 
    -0.02036817f, 0.04966717f, 0.02483524f, -0.00337923f, -0.04930577f, 0.00894228f, 0.00482427f, 0.03935303f, 
    -0.04211796f, -0.07142552f, -0.02216962f, 0.01457136f, -0.05332479f, -0.06351182f, -0.02582590f, -0.05224663f, 
    -0.04291177f, 0.02830583f, -0.03940266f, 0.06273696f, -0.00256280f, -0.04759473f, -0.01020899f, -0.02747801f, 
    -0.00999851f, 0.05898327f, 0.05748956f, -0.03386201f, -0.04495856f, 0.00398574f, 0.05314932f, -0.04157522f, 
    0.00647181f, 0.02134843f, -0.06886999f, -0.01284138f, 0.04045556f, 0.04361586f, 0.00542448f, -0.03613567f, 
    0.05247574f, 0.00707352f, -0.02570263f, -0.06626973f, 0.04181073f, -0.04806681f, -0.00698914f, 0.03424906f, 
    0.35640803f, 0.00175887f, 0.16991320f, 0.25260606f, -0.03893450f, -0.08999192f, 0.01946521f, -0.01851515f, 
    -0.00923929f, 0.09167956f, -0.01865910f, 0.02372870f, 0.46547794f, 0.13643704f, 0.18839763f, -0.23532876f, 
    0.05969463f, -0.06857426f, 0.05152310f, -0.00558726f, -0.00165452f, -0.00347609f, -0.07139273f, 0.13739857f, 
    0.21016136f, -0.06541533f, 0.04792089f, 0.31537732f, 0.03022921f, -0.07099384f, -0.00219314f, 0.04808475f, 
    0.06977764f, -0.01990531f, 0.03034381f, 0.05941311f, 0.13161349f, -0.06017203f, -0.46455392f, -0.24072161f, 
    0.06713775f, 0.00373132f, 0.22567555f, -0.06704374f, -0.07100624f, 0.06129364f, 0.14142083f, 0.06060305f, 
    -0.30872819f, 0.03106542f, -0.00788016f, -0.23887900f, -0.05847698f, -0.16502777f, -0.14233586f, -0.04235304f, 
    -0.02488644f, -0.09274766f, -0.04525882f, -0.11214193f, -0.31393212f, 0.10997427f, 0.18619032f, -0.11749431f, 
    0.12403721f, 0.17412145f, 0.04188934f, 0.20741327f, 0.11588180f, -0.03490172f, 0.16619760f, 0.00940929f, 
    -0.11006510f, 0.01754451f, -0.13681678f, -0.15235564f, 0.00528961f, 0.06059985f, 0.07692505f, -0.14916404f, 
    0.10812591f, -0.11410494f, -0.02519492f, 0.15220569f, 0.31816033f, 0.01588510f, 0.22280909f, 0.33448902f, 
    -0.26051542f, 0.04503473f, -0.29266310f, -0.22750305f, -0.00553305f, -0.02443825f, 0.05980460f, -0.10007337f, 
    0.24041447f, 0.20473962f, 0.07025222f, 0.15629341f, 0.14990510f, 0.09423212f, 0.14812838f, 0.07636393f, 
    0.06699263f, -0.04581099f, 0.08023039f, 0.08529118f, -0.46575391f, 0.10403921f, 0.02223598f, 0.19174591f, 
    -0.01134804f, -0.06307847f, -0.07295701f, -0.11377764f, 0.12340435f, -0.17061049f, -0.01511841f, 0.06029462f, 
    -0.10850559f, 0.00748785f, -0.02186978f, -0.05030946f, -0.09841753f, -0.08298218f, -0.12438644f, -0.18725233f, 
    0.05155061f, 0.09786212f, 0.03364222f, 0.06768572f, -0.19839822f, 0.22403367f, 0.20591399f, -0.02445838f, 
    -0.06504095f, -0.00665846f, 0.06153987f, 0.08643778f, -0.04749587f, 0.02770292f, -0.13909110f, -0.03012622f, 
    -0.52853346f, 0.07728978f, 0.00760701f, 0.03318891f, 0.06526582f, -0.05082678f, -0.15888548f, -0.04064710f, 
    -0.12866479f, -0.00330295f, -0.08382598f, 0.00454635f, 0.05877158f, 0.12717421f, -0.04337124f, -0.10578136f, 
    0.01050441f, 0.03898987f, 0.09504846f, -0.10148842f, 0.01107066f, -0.03240108f, -0.04073498f, 0.05867034f, 
    0.21131277f, -0.09041524f, -0.09581986f, -0.14887473f, -0.00663822f, 0.07047397f, -0.08623510f, -0.13079637f, 
    0.01360990f, 0.06368063f, 0.08470974f, 0.18953708f, -0.13030128f, 0.09983747f, -0.06616361f, -0.15892947f, 
    0.13944834f, 0.10397793f, 0.09526474f, 0.05950685f, 0.13445213f, -0.02003488f, 0.02067410f, 0.03432863f, 
    -0.12449437f, 0.12661329f, -0.16451775f, 0.19921209f, -0.02783136f, -0.03880029f, 0.02162722f, -0.12750062f, 
    0.07114887f, -0.02352579f, -0.00478754f, -0.13749993f, 0.13731201f, 0.01771826f, 0.01928980f, 0.18190444f, 
    -0.02761184f, -0.05987970f, 0.10887539f, -0.13046674f, -0.10808732f, -0.05850235f, 0.18467803f, 0.11336075f, 
    -0.08521952f, 0.16426581f, -0.01567627f, -0.17223969f, -0.13439967f, 0.20289661f, 0.05294872f, -0.02165260f, 
    0.08814634f, -0.04111197f, 0.05555493f, -0.23449023f, -0.19337766f, 0.10468399f, 0.12613618f, 0.34168226f, 
    0.01605642f, -0.04117923f, 0.05453495f, -0.07373302f, 0.06506158f, 0.16818939f, 0.06769021f, 0.02833676f, 
    0.12024062f, -0.21996148f, -0.13484173f, 0.19729586f, 0.03347902f, -0.05946414f, 0.04528551f, -0.00229006f, 
    0.01094783f, -0.04115864f, 0.01753274f, -0.15923300f, 0.03857340f, 0.07195509f, 0.14004110f, 0.16800596f, 
    0.11725899f, -0.06539286f, -0.05327820f, 0.07122937f, -0.08107980f, 0.03453796f, 0.11541142f, 0.02480757f, 
    -0.18671902f, 0.08615971f, 0.01766676f, 0.07676147f, 0.15871343f, -0.02504913f, 0.09346607f, 0.07983948f, 
    0.07180232f, 0.14322789f, -0.09528473f, -0.06837094f, 0.10853582f, 0.13723306f, -0.13304749f, -0.19673131f, 
    0.08923936f, 0.00560261f, -0.02496541f, 0.03466584f, -0.03203721f, 0.05457483f, 0.03269614f, -0.05486510f, 
    0.22283982f, -0.07017545f, 0.07498808f, 0.10254746f, -0.09256502f, -0.03040828f, -0.09918389f, 0.11526459f, 
    -0.05384895f, -0.07263318f, 0.18112203f, -0.06041046f, 0.01161917f, 0.04863041f, -0.15238558f, -0.33361211f, 
    0.02592165f, -0.00749361f, 0.06583774f, 0.09813429f, -0.03328760f, 0.07390171f, -0.06674661f, 0.04547048f, 
    0.09609581f, -0.14587058f, 0.13775530f, 0.03789589f, -0.06685942f, 0.15486871f, -0.02429160f, 0.07579997f, 
    0.06921332f, 0.06799725f, -0.01513476f, -0.12503198f, -0.09714202f, 0.01476110f, -0.00839798f, 0.18796265f, 
    -0.03919840f, 0.06120935f, -0.02393412f, 0.08900548f, -0.07981522f, -0.06866775f, -0.09055374f, -0.03562948f, 
    0.14935809f, 0.06616816f, 0.01987760f, -0.24912937f, 0.01302892f, -0.01499526f, -0.00963152f, 0.02874035f, 
    -0.07102031f, 0.12923084f, 0.06674968f, -0.06728777f, -0.09688187f, -0.07847195f, 0.09004708f, 0.07646897f, 
    0.02863927f, -0.00310222f, 0.06992923f, 0.10053805f, -0.11363111f, 0.01379407f, 0.04573467f, 0.14304636f, 
    -0.26734874f, 0.10574839f, 0.11611111f, -0.03494802f, -0.03958943f, 0.12651388f, 0.11038218f, 0.05731859f, 
    0.04908546f, -0.00798951f, 0.21803966f, 0.05644900f, -0.21511427f, -0.05930036f, 0.00010432f, 0.10832519f, 
    -0.04538178f, 0.05835927f, -0.07885365f, 0.01168992f, 0.09729546f, 0.05667137f, -0.15411890f, 0.01558798f, 
    -0.03755675f, 0.27524871f, 0.13272031f, 0.25162941f, 0.01766480f, 0.10946891f, 0.07494511f, -0.01685552f, 
    -0.03402436f, 0.08244555f, 0.02205135f, 0.04166821f, -0.07264842f, 0.24813165f, -0.12560970f, 0.10007904f, 
    -0.00832234f, 0.04773020f, 0.03188635f, 0.13765866f, -0.03497030f, -0.04196001f, 0.15995835f, -0.11366591f, 
    -0.15212047f, 0.09139484f, -0.16881175f, -0.13373397f, -0.09718484f, -0.03660607f, 0.06044029f, -0.01148327f, 
    0.05961560f, -0.01758741f, 0.08727776f, -0.08045140f, 0.12075892f, 0.16394442f, 0.30038574f, 0.21301849f, 
    0.03570089f, 0.04681904f, -0.00429556f, 0.15268202f, -0.04350386f, 0.20612779f, -0.06848904f, 0.05967436f, 
    -0.03444173f, -0.28403759f, 0.10178646f, -0.02175882f, -0.03522573f, -0.01833336f, -0.06368071f, -0.07348231f, 
    -0.05059145f, -0.02592572f, -0.07201042f, -0.00920671f, 0.26772821f, 0.08849506f, 0.17335400f, 0.19933936f, 
    0.04506602f, 0.06272049f, 0.11075646f, 0.02831358f, -0.20268255f, 0.03660131f, -0.08303762f, -0.03675004f, 
    -0.06267021f, 0.24465887f, 0.09312107f, -0.05209850f, -0.08256766f, -0.11195867f, 0.03188993f, 0.04197273f, 
    -0.08367132f, 0.02613237f, -0.05969073f, 0.11145071f, -0.08118702f, -0.18401030f, -0.26941773f, 0.09596324f, 
    0.05499615f, -0.02192068f, 0.00417963f, -0.14464864f, 0.08679790f, -0.00029473f, -0.00542459f, -0.08810364f, 
    0.11716765f, 0.11562345f, 0.20264694f, 0.22824562f, 0.00704973f, -0.04839021f, -0.16256319f, 0.01903230f, 
    0.07925264f, -0.02897553f, 0.04636364f, 0.02497818f, -0.03422529f, -0.09683966f, -0.14167076f, -0.24625646f, 
    0.11564858f, -0.09775297f, -0.05041208f, -0.06721486f, -0.04734088f, -0.04351053f, 0.03379860f, 0.08488912f, 
    0.62522554f, -0.11097126f, 0.04537099f, -0.06511571f, -0.26175740f, 0.05057958f, -0.05338512f, -0.06098634f, 
    0.01273082f, 0.08258198f, 0.07196368f, -0.07613047f, 0.00595289f, 0.13596469f, -0.07449532f, 0.01049217f, 
    -0.05355917f, -0.10263503f, -0.00169687f, 0.00506619f, 0.01317934f, -0.00200152f, 0.04318608f, -0.13899077f, 
    -0.12907800f, 0.06728844f, 0.17608477f, 0.14227553f, 0.01388881f, 0.01681280f, -0.02391444f, 0.09090026f, 
    -0.16444594f, 0.13870904f, 0.00674090f, 0.04885617f, -0.41835323f, -0.15966897f, -0.04294378f, -0.20456490f, 
    0.18871728f, -0.03811339f, 0.05124184f, -0.06740462f, 0.16655701f, 0.06884626f, 0.11114700f, 0.11716410f, 
    -0.21241622f, 0.01486590f, -0.02530965f, -0.08519004f, 0.03390438f, 0.00938346f, -0.08603098f, 0.01011966f, 
    0.19990459f, 0.04063524f, 0.13507266f, 0.03981720f, -0.06917833f, 0.12858625f, 0.07556687f, 0.02687919f, 
    0.14329250f, 0.01613742f, 0.01546949f, -0.01323085f, -0.05646057f, 0.03802058f, -0.09776531f, 0.00438469f, 
    -0.05693448f, 0.02347372f, 0.04876961f, -0.03649608f, -0.03470002f, 0.04608146f, -0.04338164f, -0.06664784f, 
    0.00020801f, -0.05574493f, 0.00247551f, 0.02895515f, 0.02200311f, 0.01848980f, -0.03530350f, 0.05118968f, 
    0.02116228f, -0.04725834f, -0.05691369f, -0.00687417f, 0.01006824f, 0.07532591f, -0.03155733f, -0.02115701f, 
    0.05770177f, 0.06669570f, -0.04920066f, -0.05041149f, -0.07838345f, 0.00331942f, -0.03750468f, -0.07274633f, 
    0.00924744f, 0.02569091f, -0.01746534f, -0.02969286f, -0.02351480f, -0.01618507f, -0.05960895f, -0.06474731f, 
    -0.07020128f, 0.04017589f, 0.02515963f, 0.00324173f, 0.01408079f, -0.02881852f, 0.02638423f, -0.03519198f, 
    -0.02091661f, 0.01082650f, -0.01014808f, 0.01355812f, 0.05804878f, -0.07829848f, -0.02123863f, -0.06877331f, 
    0.01537272f, -0.02629618f, -0.05704291f, 0.03364491f, 0.03434846f, 0.02357407f, -0.04367631f, 0.03903487f, 
    -0.02394937f, -0.05278693f, -0.06881572f, 0.02328321f, 0.05419172f, 0.02687180f, -0.00434337f, 0.00303714f, 
    0.06642709f, -0.03106602f, -0.05517544f, -0.05990092f, 0.05282238f, -0.01552584f, 0.06795000f, 0.01652019f, 
    -0.01055233f, 0.01442829f, -0.02010342f, -0.02579894f, 0.01877057f, 0.04165942f, 0.03281016f, 0.05052460f, 
    -0.06876794f, -0.02053578f, 0.06391547f, 0.01444350f, -0.08775554f, 0.03170965f, 0.01057420f, 0.02001891f, 
    0.06755136f, -0.06305777f, 0.03124030f, -0.06872296f, -0.06993423f, 0.01209654f, -0.03029558f, 0.05760966f, 
    -0.05216702f, -0.05321844f, 0.05359224f, -0.06854403f, -0.03425604f, -0.03925047f, 0.01976480f, 0.00727530f, 
    0.04919007f, 0.02733472f, -0.06777700f, -0.04442623f, 0.01224722f, -0.04200942f, 0.02954509f, 0.02428978f, 
    0.00667886f, 0.01376790f, 0.02610176f, 0.00228431f, 0.04328325f, -0.00233377f, 0.02843419f, -0.01223695f, 
    -0.03158922f, -0.04222585f, -0.03172053f, 0.05060008f, -0.04192234f, 0.02796272f, -0.01845823f, -0.03051529f, 
    -0.03028628f, 0.03731251f, -0.00841905f, 0.00702405f, 0.06029200f, 0.03925171f, -0.05691676f, 0.03969505f, 
    -0.05870451f, 0.02131067f, -0.03308828f, -0.02092856f, -0.04713434f, -0.02043900f, -0.00274070f, 0.03629445f, 
    0.02135056f, -0.06496625f, -0.04973877f, 0.03157958f, -0.03644847f, -0.03688019f, 0.05748476f, -0.06413269f, 
    -0.08187976f, -0.04395199f, -0.03860474f, 0.00358218f, 0.03458282f, -0.01984700f, 0.05055195f, 0.01635648f, 
    -0.02383925f, 0.00836184f, 0.03875171f, 0.00684020f, 0.00740943f, 0.03554499f, -0.03790687f, 0.05777334f, 
    0.06821750f, -0.04278670f, 0.00863393f, 0.04095554f, -0.06651105f, -0.06020589f, -0.02852635f, 0.04105323f, 
    -0.00122250f, -0.07812358f, -0.08592812f, -0.00453479f, -0.01824988f, 0.03546304f, -0.03493765f, -0.04952731f, 
    -0.16206759f, -0.10943360f, 0.05369050f, -0.36892730f, 0.11776120f, -0.04683469f, -0.07964863f, 0.12988904f, 
    0.16379014f, -0.11127754f, -0.08403481f, -0.05761449f, -0.20891245f, -0.10616275f, -0.02186896f, -0.02599134f, 
    0.04497236f, 0.03401312f, -0.09815495f, -0.01543873f, 0.13462053f, 0.17388509f, -0.03207824f, -0.15889421f, 
    0.28445232f, 0.18851250f, -0.03357470f, -0.13005011f, 0.02475560f, -0.11380906f, 0.03991121f, 0.09471043f, 
    0.06243966f, 0.03836865f, 0.07142071f, 0.05513038f, -0.26145527f, -0.44919834f, -0.11344000f, -0.31132931f, 
    -0.02722671f, -0.02222092f, 0.04576058f, 0.04135936f, -0.00568366f, -0.09556293f, 0.12902807f, -0.10393196f, 
    -0.03230215f, 0.33589137f, 0.06981710f, 0.07877126f, 0.05354767f, 0.16608772f, 0.10142641f, 0.17263362f, 
    0.02476770f, 0.14301619f, 0.20269461f, 0.06677134f, 0.06774276f, -0.36327422f, -0.11201403f, -0.34035736f, 
    0.07511500f, -0.06605433f, 0.09758114f, -0.06774198f, 0.21033633f, 0.04886612f, -0.05586706f, -0.28030032f, 
    -0.18823063f, -0.13236813f, -0.02578261f, 0.00485363f, -0.23319735f, -0.01229755f, -0.02571921f, -0.01722765f, 
    0.03516199f, -0.05147438f, 0.01691445f, 0.05558610f, 0.08336790f, 0.09243476f, 0.16965695f, 0.14924465f, 
    0.09700929f, 0.11371218f, 0.08536534f, -0.01810093f, -0.12901983f, 0.03339935f, -0.02042555f, 0.17813931f, 
    -0.25321576f, -0.03971439f, -0.40535396f, 0.05047571f, -0.00266557f, 0.01597022f, -0.02773697f, -0.21716541f, 
    -0.02913985f, 0.05099296f, -0.24602298f, -0.16491576f, 0.42475253f, 0.19651268f, 0.22506915f, 0.02955194f, 
    0.09390463f, 0.15230046f, -0.08939919f, 0.15106705f, 0.00065341f, 0.10212936f, 0.02366204f, 0.20081306f, 
    -0.34778762f, 0.13035944f, -0.11053009f, 0.13873033f, -0.05339658f, -0.07833718f, 0.22884394f, 0.04028295f, 
    0.18567131f, 0.02066208f, 0.09581300f, 0.03207500f, 0.10191154f, -0.12321135f, 0.01970661f, 0.13694426f, 
    -0.06912711f, 0.08603983f, 0.05579628f, 0.04257102f, 0.04105051f, 0.09298199f, 0.10560608f, 0.04694015f, 
    0.02508694f, -0.15783446f, 0.33403292f, -0.02255617f, 0.10759743f, -0.00834955f, 0.11149001f, -0.00617029f, 
    0.15024179f, -0.03172357f, -0.05644195f, 0.09637707f, -0.00393018f, 0.12070975f, -0.32075223f, -0.23498918f, 
    -0.00767862f, 0.08403474f, -0.13710316f, 0.02078234f, 0.11793677f, 0.10092934f, -0.08796214f, 0.06007840f, 
    0.19736707f, -0.00009623f, 0.20088053f, -0.11376809f, -0.14809406f, -0.00489561f, -0.14689742f, -0.09464219f, 
    -0.09089813f, -0.03090941f, -0.19460563f, 0.01541353f, -0.33527026f, -0.28870568f, -0.41985181f, -0.21441698f, 
    0.05573426f, -0.02391428f, 0.14191261f, -0.03418785f, 0.02978641f, 0.06531631f, 0.06226255f, -0.11098249f, 
    0.18634892f, 0.04117703f, 0.09219361f, 0.05152220f, 0.08938246f, -0.08260611f, 0.01730539f, 0.12294818f, 
    0.06444711f, 0.06192156f, 0.11582195f, 0.06403011f, 0.15996043f, 0.09323274f, 0.25118589f, 0.05358012f, 
    0.04613587f, -0.04226857f, -0.00947027f, 0.13293752f, -0.02043936f, 0.02699226f, -0.04851781f, 0.02866581f, 
    0.36837587f, 0.00410874f, -0.07969019f, 0.09279210f, 0.14116938f, 0.04868533f, 0.02275080f, 0.13851622f, 
    -0.02961229f, -0.00951869f, 0.04783422f, 0.01644958f, 0.02388811f, -0.17468835f, -0.14833601f, -0.05953516f, 
    -0.12319902f, 0.04137431f, 0.03979054f, -0.11130075f, -0.02465818f, 0.05446754f, 0.00818709f, 0.02244945f, 
    -0.26750875f, 0.15453835f, -0.08412182f, -0.00062383f, -0.02795105f, 0.11600105f, 0.03206092f, 0.20858942f, 
    0.01573348f, 0.09130963f, 0.15085201f, 0.12660305f, -0.00908358f, 0.13491051f, 0.17059624f, 0.07614834f, 
    0.00985174f, 0.02007021f, 0.03532352f, -0.04334768f, 0.10980172f, 0.11374187f, 0.03085828f, -0.06458388f, 
    0.23852508f, -0.17273213f, -0.05355951f, -0.04572029f, 0.07101519f, 0.00315963f, 0.09805431f, -0.11448022f, 
    -0.01548669f, -0.07946043f, -0.01043257f, 0.05490829f, -0.01090301f, -0.08801587f, -0.19549052f, 0.08510347f, 
    -0.02747427f, 0.02721824f, -0.12596281f, 0.00314864f, 0.07914963f, -0.00533356f, 0.04245119f, 0.05662594f, 
    0.02666446f, 0.09457123f, 0.00452435f, 0.18680654f, 0.13851495f, 0.06374195f, -0.02915421f, -0.00511598f, 
    0.08731791f, 0.06142936f, 0.14716981f, 0.00213176f, -0.36494580f, -0.08412687f, 0.06836114f, 0.03933027f, 
    0.05375770f, 0.06468941f, 0.03944179f, -0.09328925f, -0.00058515f, 0.09345699f, -0.09930838f, -0.00628129f, 
    -0.07942314f, 0.07357662f, -0.13258056f, 0.00457538f, 0.05364273f, -0.08477707f, 0.05996327f, 0.05953852f, 
    0.05474972f, -0.01017418f, -0.02778523f, 0.12415320f, 0.04874764f, -0.10564750f, 0.19041015f, 0.32914841f, 
    0.13542280f, 0.17044149f, 0.08414145f, -0.01747263f, -0.07608478f, 0.09375583f, -0.01050841f, -0.05141233f, 
    -0.18094103f, 0.24689855f, 0.01790942f, 0.11512218f, 0.00838365f, 0.06848798f, 0.01474712f, 0.01440289f, 
    -0.12500946f, -0.06887760f, -0.03766122f, -0.02853003f, -0.31495035f, 0.07898837f, -0.14115614f, -0.08742041f, 
    -0.00483074f, 0.04528000f, 0.03122208f, 0.06447233f, 0.03377983f, -0.01852119f, 0.00064797f, -0.05624466f, 
    0.08919632f, -0.15563178f, -0.06199827f, -0.22637810f, 0.00318659f, -0.09509557f, -0.01099540f, -0.06374220f, 
    -0.01578430f, -0.02516196f, -0.01323036f, -0.00964222f, 0.10650396f, 0.25681970f, -0.13264105f, 0.07206519f, 
    0.02091610f, -0.06243228f, 0.04625359f, 0.06997416f, -0.00972827f, -0.00152127f, 0.00642927f, -0.05320238f, 
    -0.03413205f, 0.09004670f, -0.06878373f, -0.12895417f, 0.02949799f, -0.00615336f, -0.09987420f, 0.07001092f, 
    0.13105436f, 0.11524469f, 0.05975706f, 0.07019182f, -0.39145061f, -0.22105423f, 0.10791449f, 0.22900945f, 
    0.04522328f, -0.05155273f, -0.10839458f, 0.04561262f, 0.11939739f, -0.08571768f, -0.04075757f, -0.08185305f, 
    0.04712632f, 0.07377757f, 0.04191348f, -0.22838348f, 0.09532826f, -0.14700411f, 0.05506722f, -0.06213987f, 
    -0.05770453f, 0.04371106f, 0.11484616f, 0.16582316f, -0.01233380f, 0.14927445f, -0.02891457f, 0.03494949f, 
    -0.01662015f, 0.05408218f, -0.17138097f, -0.01824854f, 0.08959732f, -0.08487981f, -0.07519940f, -0.06379434f, 
    0.20300122f, 0.01353033f, -0.08492465f, 0.05119034f, -0.02854909f, 0.12416898f, 0.00408577f, -0.01923419f, 
    -0.00069085f, 0.15967214f, 0.15722801f, 0.17434689f, 0.19746418f, 0.06602463f, -0.23802392f, -0.01137139f, 
    -0.08116613f, 0.06296592f, -0.08111387f, -0.03572801f, 0.10653026f, -0.01218954f, -0.11857967f, -0.07328167f, 
    0.22044784f, -0.09841505f, -0.06552232f, 0.08808378f, 0.20239358f, -0.03052244f, -0.02310709f, -0.01579763f, 
    0.04677412f, -0.08216053f, 0.05803946f, 0.06029159f, -0.29889095f, 0.05374713f, -0.24850397f, -0.29267037f, 
    0.10487480f, -0.08725493f, -0.01071718f, 0.02862938f, -0.00407038f, 0.11759064f, 0.03433455f, 0.12372489f, 
    -0.26298809f, -0.17764632f, -0.07063635f, 0.12244595f, 0.04634557f, -0.01865143f, -0.12689216f, -0.08558767f, 
    0.16922413f, 0.20754580f, -0.03481658f, 0.15605040f, -0.00132641f, -0.12367758f, 0.01978322f, 0.02877783f, 
    0.05397435f, 0.04805385f, 0.01346550f, 0.05032415f, 0.06570981f, 0.09344208f, -0.01957027f, 0.01856024f, 
    0.24293126f, 0.25384659f, 0.13084400f, -0.08905475f, 0.13291526f, -0.02290664f, 0.01621138f, 0.03432913f, 
    0.03544803f, -0.02342794f, 0.14591616f, 0.19047740f, 0.09019174f, 0.05557128f, -0.07658807f, 0.16679589f, 
    0.06646042f, -0.04096873f, 0.07403544f, 0.05287699f, -0.00556888f, 0.09669346f, 0.14447796f, 0.16236968f, 
    -0.16028832f, 0.12693694f, -0.01216764f, -0.02375111f, 0.03056553f, -0.03095027f, 0.09602058f, 0.06630430f, 
    0.00682705f, -0.07192804f, 0.13912149f, -0.00839975f, -0.18545723f, -0.11181511f, -0.18501745f, 0.01347328f, 
    0.01980580f, 0.05964695f, -0.00670187f, 0.05261653f, 0.08580316f, 0.01768252f, -0.03664159f, -0.06632527f, 
    -0.02329514f, -0.00417821f, -0.11743145f, -0.12291764f, 0.07525473f, -0.00459701f, 0.06496625f, -0.10970285f, 
    0.04870679f, 0.11067314f, -0.13742334f, 0.02899574f, 0.20197698f, -0.07192146f, 0.00891289f, 0.06080224f, 
    -0.00642087f, 0.05235077f, -0.02528003f, -0.07884628f, 0.04890154f, -0.03032235f, 0.07813703f, -0.07853587f, 
    -0.03784539f, 0.05864599f, -0.20752609f, 0.14884529f, 0.06485782f, 0.06155923f, 0.06504658f, -0.00253254f, 
    0.15461570f, -0.00045979f, -0.02082104f, -0.02238206f, 0.36364406f, 0.00588225f, -0.17539048f, -0.02157654f, 
    -0.06600418f, 0.02242473f, 0.02221348f, 0.08410633f, 0.03245300f, 0.02142241f, 0.20418958f, 0.03436426f, 
    -0.27243695f, -0.18375881f, 0.08116738f, 0.06857329f, 0.02108035f, 0.13446406f, 0.15818681f, 0.00896893f, 
    0.04185683f, -0.05089976f, 0.05004809f, 0.06078074f, -0.04650049f, -0.10376766f, 0.02959813f, 0.01011475f, 
    -0.06760843f, 0.02273730f, 0.02411576f, 0.11904398f, -0.03492814f, 0.13725834f, 0.09731832f, 0.10198537f, 
    0.00451847f, 0.03500777f, 0.09000734f, -0.01173950f, 0.04345872f, -0.09291340f, 0.12280684f, 0.02958910f, 
    -0.01343273f, -0.08195629f, -0.10283528f, -0.05097455f, -0.33673728f, 0.00869973f, -0.02223881f, -0.00600936f, 
    0.00922614f, -0.10181943f, -0.05263632f, 0.00432359f, -0.07290686f, 0.00326337f, 0.01586760f, 0.08018737f, 
    -0.01740812f, 0.12497585f, 0.00373160f, 0.09789927f, -0.04142275f, 0.00370549f, -0.01908360f, -0.02139829f, 
    0.01811645f, 0.11469512f, -0.04912997f, -0.03326938f, 0.06765065f, -0.04102172f, 0.04930490f, 0.18076426f, 
    0.10766343f, 0.06609417f, -0.00949617f, 0.01371878f, 0.07064647f, -0.08852708f, 0.03235789f, -0.01819407f, 
    0.15889238f, -0.08216199f, 0.09356655f, -0.09889716f, -0.02420932f, 0.03795335f, -0.03411067f, 0.13024107f, 
    0.10119967f, 0.09422543f, -0.04626201f, 0.04825700f, 0.17870203f, 0.12359224f, 0.05235457f, -0.17815782f, 
    0.01044202f, 0.02816877f, 0.12781227f, 0.09862301f, -0.06752261f, -0.05724676f, 0.00289691f, 0.01088295f, 
    0.24022980f, 0.01407098f, -0.02393984f, 0.06316628f, 0.08703936f, 0.14182805f, 0.11065269f, 0.02886130f, 
    0.17548217f, 0.04527596f, 0.00973823f, -0.07387032f, 0.19638027f, 0.04599528f, -0.09212148f, 0.03506064f, 
    0.06591667f, 0.04093742f, -0.06575757f, 0.14831086f, -0.08183186f, -0.09914917f, 0.07226721f, 0.04491712f, 
    -0.46007094f, 0.07577100f, 0.05553504f, -0.17786311f, 0.06778975f, -0.00461511f, -0.01719792f, 0.07055393f, 
    -0.08049694f, 0.07180075f, 0.09204511f, 0.06363343f, -0.46652651f, -0.08950360f, 0.08565561f, 0.08717851f, 
    -0.02065230f, -0.03642964f, -0.01996031f, 0.05171344f, -0.10950735f, -0.04303924f, 0.00477023f, 0.03653807f, 
    -0.06910244f, -0.07940271f, 0.08394655f, 0.18592338f, 0.05200332f, 0.16554980f, 0.08882721f, 0.10465273f, 
    0.03302311f, -0.02758294f, 0.20148158f, 0.05634902f, -0.17098925f, -0.09435985f, 0.02812241f, -0.06102417f, 
    -0.09585442f, -0.02935373f, -0.01664952f, -0.07867698f, -0.04194538f, 0.04567190f, -0.05929047f, -0.04899234f, 
    -0.12354308f, -0.00047473f, -0.26585913f, 0.21986558f, 0.00619875f, 0.09486169f, -0.02962070f, -0.08775657f, 
    0.11357193f, -0.12940715f, -0.03796854f, 0.02476905f, -0.02300045f, -0.21780446f, -0.17928433f, 0.15438831f, 
    -0.21993683f, 0.05198736f, 0.13876402f, -0.02096362f, -0.05950480f, -0.04529886f, 0.06274793f, 0.07325032f, 
    -0.31457266f, -0.03256844f, 0.28164715f, -0.01605130f, -0.08434308f, 0.16655685f, 0.07644659f, 0.06922662f, 
    0.12016615f, -0.02136094f, -0.02018438f, -0.03664148f, -0.22620925f, 0.16206846f, 0.22699830f, 0.26932475f, 
    0.05532903f, -0.00351511f, 0.10725504f, 0.13036165f, 0.01281612f, 0.06685563f, 0.02160596f, 0.07144647f, 
    0.24577636f, -0.10787418f, -0.03893411f, -0.05373587f, -0.06056335f, -0.09968528f, 0.11901893f, -0.10872696f, 
    0.02185034f, -0.07806232f, 0.01706198f, -0.12218067f, -0.24377510f, -0.07520688f, -0.19888006f, 0.13251761f, 
    0.02176696f, -0.12679547f, -0.06746612f, -0.01718931f, -0.08301111f, -0.05838180f, 0.11653600f, -0.01838533f, 
    -0.14343506f, 0.14714287f, 0.04023221f, 0.13634039f, 0.05221063f, 0.03679582f, -0.06942470f, 0.02967029f, 
    0.01409012f, 0.03252006f, -0.06691883f, -0.06543232f, -0.14657429f, -0.06963944f, 0.03454059f, -0.21929695f, 
    0.13544631f, 0.08506506f, 0.06285981f, 0.04653818f, 0.04573189f, 0.09184684f, 0.07817397f, 0.08079329f, 
    0.02154841f, -0.15613635f, 0.02905444f, -0.16894563f, -0.00740529f, -0.00774268f, 0.00296204f, 0.07901097f, 
    0.01829553f, -0.03558240f, 0.04416556f, 0.02451935f, 0.21755615f, 0.05641489f, -0.08081590f, -0.19947141f, 
    0.20749953f, -0.01546903f, 0.09085776f, 0.18102965f, -0.03545140f, -0.04031959f, 0.09555175f, 0.12651446f, 
    0.05509787f, -0.12662965f, 0.17652956f, 0.16481595f, 0.00487009f, 0.19882996f, 0.16981417f, -0.03417364f, 
    -0.01658235f, 0.09845921f, 0.09116478f, 0.05290420f, 0.08215948f, 0.14180999f, -0.06863701f, -0.21040459f, 
    0.03404442f, -0.00353727f, -0.05147961f, 0.00637384f, -0.07673475f, -0.15018526f, -0.00809394f, -0.00667369f, 
    0.19076502f, 0.05239196f, 0.01376637f, -0.17387284f, 0.03469208f, 0.00659737f, 0.00577671f, 0.09898692f, 
    0.07746428f, 0.14318174f, 0.11354303f, -0.03811591f, 0.15794532f, -0.15194474f, -0.03126396f, 0.01668264f, 
    -0.00243062f, 0.00895929f, -0.06390058f, 0.13007949f, -0.11835058f, -0.05308484f, -0.11209802f, 0.11930574f, 
    -0.13796762f, 0.09332899f, 0.07828271f, 0.12288961f, 0.07353094f, 0.14060368f, 0.13752179f, 0.13157822f, 
    0.08886723f, -0.03728147f, 0.19270910f, -0.00593458f, -0.01095079f, -0.13667162f, 0.01482606f, -0.07436657f, 
    -0.08922631f, -0.05564379f, -0.01321594f, -0.04354494f, 0.08457098f, 0.02165320f, -0.00764380f, 0.03965547f, 
    -0.08992584f, 0.17208530f, -0.12822005f, 0.02225310f, -0.15771703f, 0.00701023f, -0.13096136f, -0.02193039f, 
    0.24858938f, 0.06009245f, 0.04467816f, 0.04333396f, 0.16942230f, -0.09155335f, 0.02623825f, 0.06970739f, 
    -0.12040561f, -0.07771836f, 0.00674697f, -0.15128876f, -0.16113864f, -0.07245560f, 0.03056631f, 0.08780925f, 
    0.01876946f, -0.12685141f, 0.09537546f, -0.15899648f, 0.15074025f, 0.11303073f, -0.00810825f, 0.05146233f, 
    -0.02593863f, -0.04472286f, 0.02931241f, 0.03377145f, 0.02711772f, 0.30360907f, -0.00031954f, 0.37643167f, 
    -0.15709808f, 0.06774101f, -0.00324598f, 0.13225512f, -0.05358186f, 0.13521630f, -0.07808606f, 0.03074003f, 
    0.30520189f, -0.11200194f, 0.10239525f, 0.09405397f, 0.04771471f, -0.17416447f, 0.09305649f, -0.17437664f, 
    0.05344104f, 0.03962373f, -0.03735594f, -0.05073636f, 0.00624382f, 0.03436315f, -0.08445038f, 0.09407999f, 
    0.00917762f, -0.01052945f, 0.06547600f, 0.14951110f, -0.00532593f, 0.07182389f, 0.02343484f, 0.17240359f, 
    -0.10197702f, 0.27536500f, -0.05447048f, 0.03517838f, 0.03646543f, 0.12115302f, -0.08897291f, -0.01225262f, 
    -0.00722415f, -0.02205751f, 0.03433959f, 0.01996647f, -0.14965983f, 0.01224637f, -0.01885333f, 0.26886383f, 
    0.08355750f, 0.11193695f, -0.00831368f, -0.13494077f, -0.06347035f, -0.02179071f, 0.10851229f, 0.10870931f, 
    0.03746682f, 0.04595560f, 0.06623930f, -0.14253613f, 0.16450280f, -0.09994239f, -0.04788182f, 0.02557000f, 
    0.00242711f, 0.02674554f, -0.09029526f, -0.11736135f, -0.16206531f, 0.16712928f, 0.13569963f, -0.08315423f, 
    -0.02967070f, -0.08442231f, -0.09060387f, -0.09725615f, 0.11336892f, -0.11793747f, -0.07808866f, -0.10903752f, 
    -0.05783544f, -0.04420702f, -0.09276113f, -0.00228416f, 0.00603994f, 0.10823327f, 0.10414563f, -0.02456906f, 
    0.09545691f, -0.01978693f, 0.03480804f, -0.02027429f, 0.01201478f, 0.22748680f, -0.08687041f, 0.00793336f, 
    0.09600361f, -0.08085740f, -0.05071936f, -0.01893316f, -0.02358313f, -0.03772232f, 0.01978485f, -0.03481629f, 
    0.28763857f, -0.05294012f, 0.23132382f, -0.39080200f, 0.03745473f, 0.03666487f, 0.00771435f, 0.16895318f, 
    -0.03896362f, -0.01687393f, 0.01762697f, 0.01651610f, -0.02963209f, 0.00400092f, -0.02205862f, 0.01847194f, 
    -0.02052001f, -0.03120557f, 0.01256857f, 0.06684590f, 0.01653286f, -0.04994319f, -0.03360780f, 0.05061805f, 
    0.21477249f, 0.24967754f, 0.04098809f, 0.00580385f, -0.01402790f, 0.03963968f, 0.03539789f, -0.02093574f, 
    0.00778260f, 0.03480055f, 0.14382753f, 0.02710210f, -0.34082058f, -0.00975206f, 0.06899898f, 0.09636644f, 
    -0.02360968f, -0.02305617f, -0.07809473f, 0.01571011f, -0.06181077f, -0.08317267f, 0.14908290f, -0.02347887f, 
    0.00123340f, -0.00907501f, -0.05741988f, 0.03097129f, 0.03598806f, -0.02137347f, 0.04028586f, -0.08306934f, 
    -0.06151414f, -0.02598603f, 0.01840199f, 0.00246529f, -0.03075280f, 0.03941669f, -0.01891179f, -0.04082254f, 
    -0.04690356f, 0.05086172f, 0.05192422f, 0.00140933f, 0.04315018f, -0.07239129f, -0.00864590f, 0.04566307f, 
    -0.02599662f, 0.01261935f, 0.02709429f, -0.00625424f, 0.04368279f, -0.04922702f, -0.01648697f, -0.04664456f, 
    -0.00069010f, -0.06722115f, 0.00526762f, -0.07263864f, 0.03275702f, -0.00386575f, -0.00426073f, 0.06128017f, 
    0.01334172f, -0.06212277f, -0.05952294f, 0.01233974f, 0.03855261f, -0.05729743f, 0.04690530f, -0.04707517f, 
    -0.06810976f, -0.00161158f, -0.00332753f, -0.00790807f, -0.05579270f, 0.02012572f, -0.03932313f, 0.05054744f, 
    -0.05928454f, 0.01402360f, 0.03159064f, -0.05147570f, -0.03329038f, -0.06934971f, 0.04148495f, 0.01863708f, 
    0.04685203f, -0.05523879f, -0.02066808f, 0.05427219f, 0.05675429f, -0.02864001f, 0.05255847f, 0.00263253f, 
    0.03346257f, 0.00760069f, -0.06729524f, -0.01600745f, 0.03170707f, -0.02433672f, -0.06897338f, 0.01643387f, 
    -0.04218213f, -0.06214472f, -0.05934662f, -0.07351149f, -0.07429802f, -0.02526067f, 0.05914012f, -0.01746473f, 
    0.02407494f, -0.05417738f, -0.02889545f, -0.02352103f, 0.05149500f, -0.05977824f, -0.04416934f, 0.04855325f, 
    0.03899715f, 0.00488151f, 0.03418771f, 0.05673443f, -0.05432644f, -0.01579922f, 0.00227727f, 0.00806529f, 
    -0.07037175f, 0.03782926f, -0.05353475f, 0.03333370f, -0.00559036f, 0.05367817f, 0.03510836f, 0.05053970f, 
    0.04961873f, -0.00231900f, -0.00260399f, -0.06916207f, 0.06138443f, 0.01944606f, 0.04276637f, -0.05911384f, 
    -0.02564625f, 0.05830852f, 0.05121071f, 0.02313372f, 0.00901271f, -0.00126065f, 0.04862712f, -0.04590761f, 
    0.04903402f, 0.04687897f, -0.02325075f, -0.03850960f, -0.07785720f, -0.02201976f, 0.01991805f, -0.08312999f, 
    -0.04700502f, -0.00061566f, -0.01929046f, -0.02075716f, 0.01889532f, 0.00806322f, -0.01769109f, -0.05557830f, 
    -0.00812534f, -0.00085832f, -0.04332811f, -0.05464874f, -0.08108838f, -0.00843416f, -0.04700626f, 0.02348165f, 
    -0.05095109f, -0.05618382f, 0.02006356f, -0.07838461f, -0.03126297f, -0.02595561f, -0.06180134f, 0.00893876f, 
    -0.03380077f, 0.04322578f, 0.03106009f, 0.01560234f, -0.04593172f, -0.06510189f, 0.02553394f, -0.07214221f, 
    -0.04956818f, -0.03178602f, -0.06833795f, 0.05931468f, -0.05267451f, 0.02010888f, 0.04707792f, -0.06376939f, 
    0.03408345f, 0.05203801f, -0.00417080f, 0.05314898f, -0.00521686f, 0.02947784f, -0.07274580f, -0.07590251f, 
    0.03400774f, 0.01408366f, 0.02148018f, -0.05148318f, 0.01938334f, 0.01546196f, -0.00280288f, -0.04634012f, 
    -0.04518149f, -0.03112089f, -0.01682322f, -0.01087890f, 0.05660929f, -0.05109049f, -0.01290163f, 0.01109953f, 
    -0.00277245f, 0.01051085f, 0.04836857f, -0.05622703f, -0.05924447f, 0.04708403f, -0.05288471f, 0.05379637f, 
    -0.03092678f, 0.03265624f, -0.03427021f, 0.04393898f, 0.04198971f, -0.00763892f, 0.03722448f, 0.01179460f, 
    0.00282940f, 0.04214350f, -0.02226939f, 0.01033683f, 0.03644665f, -0.07015936f, 0.01818334f, 0.02516047f, 
    0.00042726f, -0.05508997f, 0.01174067f, -0.06442498f, -0.05558849f, -0.00385865f, 0.02199260f, 0.02908011f, 
    0.01075124f, 0.03987419f, -0.04495023f, 0.02473993f, -0.07772323f, 0.04587886f, -0.03559353f, 0.05561765f, 
    -0.06980981f, 0.01435742f, 0.01713805f, -0.07670705f, 0.03882903f, -0.05425428f, 0.02091093f, -0.05154100f, 
    0.03764295f, 0.06632238f, -0.04915409f, 0.03068736f, 0.02168721f, -0.06970122f, 0.01967331f, 0.00070468f, 
    0.06699790f, -0.06297472f, -0.04865030f, -0.01106582f, -0.03221578f, -0.05292789f, 0.02848899f, -0.03994679f, 
    -0.01685632f, -0.00052444f, 0.01612293f, -0.00758543f, -0.05124843f, 0.02050388f, -0.05253172f, 0.00995960f, 
    0.02168724f, -0.03853873f, 0.05772347f, -0.04316781f, -0.02875968f, -0.02006573f, -0.01185963f, -0.00066601f, 
    -0.04392738f, -0.00932228f, -0.00411473f, 0.03417079f, 0.03890714f, -0.05669734f, 0.00891393f, -0.01095669f, 
    -0.00491141f, -0.03231594f, -0.05310665f, -0.03397077f, -0.07515293f, -0.02238454f, 0.04664147f, -0.01305276f, 
    -0.01150430f, 0.05020149f, -0.01793768f, 0.05970385f, 0.03062400f, -0.05364300f, -0.03498282f, -0.04474247f, 
    0.03407173f, -0.07919247f, 0.05275817f, -0.01906356f, -0.05331066f, -0.06638622f, -0.02873175f, 0.02133128f, 
    -0.02887498f, -0.04225546f, 0.04507709f, -0.01103276f, 0.03841969f, 0.02509653f, 0.00980399f, -0.08858151f, 
    -0.02664230f, -0.02570413f, -0.00499412f, -0.04965862f, -0.02004714f, -0.03236051f, -0.02324260f, -0.01982644f, 
    -0.03070521f, -0.04490877f, 0.01675160f, 0.01771218f, -0.04645457f, -0.02346856f, 0.06330662f, -0.07787252f, 
    -0.00556518f, 0.01388754f, -0.01803731f, -0.06415594f, -0.00663074f, -0.01587432f, -0.06204925f, -0.05114096f, 
    0.04739886f, -0.06223680f, -0.02985893f, -0.02397704f, 0.01313670f, 0.05011270f, -0.06549000f, -0.02261110f, 
    0.01665925f, 0.02785224f, -0.02809640f, 0.03725954f, -0.07716221f, 0.01886536f, -0.00915429f, -0.04282642f, 
    -0.04134608f, 0.02510348f, 0.05405023f, -0.07307127f, 0.05210524f, 0.05079805f, -0.04946616f, -0.05042984f, 
    0.01022564f, -0.06937420f, 0.01474592f, 0.05585711f, -0.04695616f, -0.06677458f, -0.00286096f, 0.01190057f, 
    0.06394894f, -0.04272098f, 0.01705628f, 0.06098225f, -0.00441285f, 0.06009391f, -0.02775115f, -0.01519746f, 
    0.01007333f, 0.07879529f, 0.13012092f, 0.07925536f, 0.05115756f, 0.12181055f, 0.19764607f, -0.05941726f, 
    -0.04438943f, -0.00356785f, -0.09733029f, 0.03171202f, 0.00530759f, 0.08305810f, -0.14457680f, -0.16758268f, 
    0.18200827f, -0.03626455f, 0.03141707f, -0.12559968f, 0.06418675f, 0.03562726f, 0.10338546f, -0.00926766f, 
    0.03666039f, -0.08411917f, -0.01466487f, -0.17002828f, -0.10308523f, -0.05763650f, -0.10181073f, -0.07066868f, 
    -0.03174447f, 0.06674419f, -0.12575226f, 0.00021215f, 0.10110431f, 0.23892769f, 0.03836305f, 0.14292972f, 
    0.00092926f, 0.18234077f, 0.10855824f, 0.05146538f, 0.00336270f, 0.09888431f, 0.21558030f, 0.08176111f, 
    0.15592293f, -0.03691394f, -0.12632421f, -0.03797464f, -0.06943823f, -0.05475415f, -0.13898627f, -0.19054398f, 
    -0.04708989f, 0.00761944f, 0.05050774f, 0.02801909f, 0.35564867f, 0.05451739f, 0.38984546f, 0.11486693f, 
    0.01147726f, 0.08204979f, 0.04315140f, 0.02877262f, -0.08456688f, 0.02025403f, 0.03371895f, 0.03924245f, 
    -0.36674342f, -0.06217818f, -0.26778486f, 0.10582943f, 0.10586788f, 0.12455200f, 0.00009740f, -0.05980966f, 
    0.13436401f, -0.11496451f, 0.11912630f, -0.06072879f, -0.11330137f, 0.00583442f, -0.01410957f, 0.05422933f, 
    -0.05858741f, -0.05151942f, -0.04977694f, -0.12174752f, -0.17321719f, 0.08277547f, -0.09300082f, -0.01012752f, 
    0.15913263f, -0.00318608f, 0.23232080f, 0.29636726f, 0.14131032f, -0.03939739f, 0.08454339f, 0.01223802f, 
    -0.15674542f, -0.00629662f, -0.14602272f, -0.01352878f, -0.26818496f, -0.01067032f, -0.15580808f, -0.25320682f, 
    0.01759725f, -0.08719871f, -0.11675860f, -0.07675497f, 0.08564583f, -0.00564266f, 0.03347275f, 0.01094090f, 
    -0.22441231f, -0.26369876f, 0.12594105f, -0.08972447f, 0.08150730f, 0.05431314f, 0.12722206f, -0.11037338f, 
    0.04374015f, 0.07805105f, -0.04137703f, 0.04668435f, -0.18274897f, 0.17235498f, -0.18197672f, -0.27452195f, 
    -0.02646660f, 0.07782077f, 0.01698769f, 0.04965026f, -0.02109231f, 0.05289023f, 0.04867207f, -0.00469220f, 
    0.06360772f, -0.11784478f, 0.05555145f, 0.02570225f, -0.05994531f, 0.17736124f, -0.02402428f, -0.03857322f, 
    -0.00574710f, 0.05921261f, -0.00844872f, -0.04255718f, -0.14001621f, -0.06398981f, 0.01084041f, 0.04903848f, 
    0.03057948f, 0.11769801f, 0.09497085f, -0.02205589f, 0.02913760f, -0.05362187f, 0.02389036f, 0.01625449f, 
    0.13909961f, 0.02362648f, -0.02165519f, -0.09472109f, -0.08539388f, -0.04919321f, -0.02986493f, -0.11571369f, 
    0.07016782f, 0.00076595f, -0.08272874f, 0.13347755f, -0.18549876f, 0.08179285f, 0.20751320f, 0.36702046f, 
    0.07571968f, 0.19156221f, 0.06489920f, 0.01651743f, 0.01318889f, 0.10875808f, 0.05637834f, 0.07659273f, 
    -0.04291736f, -0.03958104f, 0.05445453f, 0.02002106f, -0.00255080f, -0.04579564f, 0.06090039f, 0.01701918f, 
    0.03942166f, 0.01199968f, 0.02544711f, -0.05698292f, 0.01998442f, 0.01600854f, -0.01792657f, 0.03515107f, 
    0.04669756f, -0.02561647f, -0.00978390f, -0.04468846f, 0.00171070f, 0.04278588f, -0.00163521f, -0.00825585f, 
    -0.05499012f, -0.07296528f, -0.01588712f, -0.02474503f, 0.03247094f, -0.04476847f, 0.01866876f, 0.00004703f, 
    0.03121302f, 0.00627519f, 0.04348075f, -0.01195018f, 0.03293062f, 0.05623198f, -0.06185536f, 0.04130194f, 
    0.01200280f, -0.00510286f, -0.05981576f, 0.03782176f, -0.03953107f, 0.01390827f, -0.05636045f, -0.07345834f, 
    -0.05532167f, -0.03131094f, 0.06525905f, 0.05298070f, -0.07803598f, -0.00378512f, 0.03911429f, 0.05070440f, 
    -0.03311695f, 0.01675335f, -0.07605110f, -0.05708675f, -0.06614386f, 0.04116194f, -0.00004250f, -0.00874262f, 
    -0.01949993f, -0.05492264f, -0.07008047f, -0.03654852f, 0.02760968f, 0.05144498f, -0.03516148f, 0.04195040f, 
    -0.03184027f, 0.01814733f, -0.02187218f, 0.03543578f, -0.04664888f, -0.04110276f, -0.05990748f, -0.05864081f, 
    -0.07182968f, -0.01677131f, -0.00313431f, -0.01309397f, 0.00923481f, 0.02208994f, -0.03960482f, 0.00828278f, 
    -0.03092299f, -0.00407875f, 0.03377206f, -0.05845458f, -0.00930540f, -0.00182082f, 0.00658013f, -0.05494967f, 
    -0.02029370f, -0.08154288f, -0.04263542f, -0.00130624f, 0.02162958f, -0.03441287f, 0.03507077f, -0.06931502f, 
    0.06474628f, -0.04195691f, -0.08135761f, 0.03797984f, -0.06864548f, 0.01946802f, 0.02258725f, 0.01170021f, 
    0.06117328f, 0.01022909f, 0.05610423f, -0.05357507f, 0.02225664f, 0.02753203f, -0.07514794f, -0.02147984f, 
    -0.05865097f, -0.04611958f, 0.02506986f, -0.07767222f, 0.02323130f, 0.05155753f, 0.04295594f, -0.02660332f, 
    -0.04727942f, -0.00490387f, -0.04308109f, 0.01586532f, -0.04707171f, 0.02519648f, 0.02006418f, 0.05432814f, 
    -0.06349725f, -0.03691719f, 0.05743703f, 0.05688899f, 0.01949591f, -0.03184292f, 0.01191731f, -0.00547924f, 
    -0.06801820f, -0.05400336f, -0.00756077f, 0.04410837f, -0.02175577f, 0.00044188f, -0.00938426f, -0.02449790f, 
    -0.02366591f, -0.05618592f, -0.02811112f, 0.04357329f, 0.00236057f, 0.03307127f, -0.01119950f, -0.04500664f, 
    -0.03760110f, -0.06890853f, 0.01015773f, -0.06556349f, 0.02882006f, -0.07975359f, 0.00207543f, -0.06672493f, 
    -0.00060975f, 0.04364635f, -0.06974889f, 0.01230993f, 0.02381812f, 0.01913554f, -0.00706828f, 0.01256515f, 
    -0.01728750f, -0.02574526f, -0.01260371f, 0.00415754f, -0.00991711f, 0.00469890f, -0.02028780f, -0.01817846f, 
    0.02418992f, 0.05660851f, 0.03046392f, 0.06281634f, -0.05488437f, -0.00589262f, -0.07597258f, 0.01734785f, 
    -0.22817270f, -0.04185040f, 0.08171040f, -0.11864123f, -0.09439178f, 0.04572340f, -0.16805217f, 0.09173482f, 
    0.11923044f, -0.06031761f, 0.02982476f, -0.01857925f, -0.44255951f, 0.01018959f, 0.12096745f, 0.12705749f, 
    0.00917372f, -0.03381157f, 0.04480746f, 0.00918051f, -0.04790074f, 0.03703529f, 0.06688322f, -0.01914445f, 
    0.08730291f, 0.22422929f, 0.11611173f, -0.20417748f, 0.05097901f, -0.01911052f, 0.00175468f, 0.10165894f, 
    0.05244602f, 0.06697494f, -0.00276947f, -0.05748676f, -0.03264239f, -0.07957178f, -0.02327053f, -0.11112824f, 
    0.12702027f, 0.02164308f, 0.05064793f, 0.03082227f, 0.02660695f, -0.05517640f, 0.09836248f, 0.12350149f, 
    0.17174618f, -0.11685071f, 0.26149303f, -0.07147043f, -0.03402333f, 0.13244070f, -0.00349556f, 0.05843318f, 
    0.07098698f, 0.06444441f, 0.05667782f, 0.05548407f, 0.16444412f, -0.18664494f, -0.41557634f, -0.04944574f, 
    0.11774026f, 0.23528618f, -0.08174449f, 0.08373979f, 0.04373447f, 0.02020701f, 0.01419554f, -0.00032139f, 
    -0.02563474f, 0.10866936f, -0.00816398f, -0.18899009f, -0.08334421f, 0.05785250f, -0.15989728f, 0.11647886f, 
    0.08870392f, 0.00994711f, -0.05622113f, -0.06328449f, 0.11185090f, 0.24460267f, 0.26704112f, -0.03146966f, 
    -0.06305730f, 0.07258355f, 0.09334663f, -0.04798909f, -0.11010765f, 0.08396352f, 0.04368498f, 0.18653722f, 
    -0.20510283f, 0.02968362f, -0.12029962f, 0.08486589f, -0.01839039f, -0.00535250f, 0.08368022f, -0.00546283f, 
    -0.07231360f, -0.02790436f, -0.09175259f, -0.09231224f, 0.31738561f, 0.23437655f, 0.10281468f, 0.09248955f, 
    0.03257035f, 0.06874816f, -0.07865182f, -0.05424778f, -0.03121867f, -0.02685736f, 0.02881472f, 0.01921995f, 
    0.10216534f, 0.17489170f, -0.02240218f, 0.20339999f, -0.07916871f, -0.00280044f, 0.10660695f, 0.08277022f, 
    0.03182718f, -0.19774406f, 0.10156886f, -0.06899632f, -0.04311879f, -0.04705599f, -0.04108955f, -0.06058667f, 
    -0.02139081f, -0.13406879f, 0.03945126f, 0.04402832f, -0.01093007f, -0.01983653f, -0.05019497f, 0.04223987f, 
    0.38806346f, -0.08545437f, 0.08666141f, -0.08225274f, 0.05638801f, 0.06327468f, 0.02991098f, 0.15048139f, 
    0.05756592f, -0.00375937f, -0.02558264f, -0.00040209f, 0.12549010f, 0.03703646f, 0.02183192f, -0.00499356f, 
    0.05440016f, 0.03949783f, -0.07415475f, -0.11067259f, 0.08340079f, -0.04722824f, 0.00237886f, 0.09039024f, 
    0.20365204f, 0.36478156f, 0.17396227f, -0.02811537f, -0.13137829f, -0.07078534f, -0.05696162f, -0.06052351f, 
    0.06820126f, 0.10103718f, -0.17781946f, -0.06029846f, -0.46489334f, -0.29153696f, -0.17266139f, -0.19001283f, 
    0.08657941f, 0.11138754f, 0.01500153f, -0.06774151f, 0.04491932f, -0.00607677f, 0.02848560f, 0.00657701f, 
    -0.10861096f, 0.25004160f, -0.21324578f, 0.01892141f, 0.10257162f, -0.02878698f, -0.08953094f, -0.03692352f, 
    0.10251883f, 0.07091573f, 0.11739876f, -0.06737728f, -0.03410918f, -0.00063044f, -0.03930778f, 0.20934755f, 
    0.03645369f, 0.01303015f, -0.01086754f, -0.08400131f, -0.02419216f, -0.02265302f, 0.21519308f, 0.22841975f, 
    -0.16565634f, 0.20159373f, 0.00650749f, -0.23989464f, -0.00056459f, 0.20076182f, 0.05295951f, 0.03591472f, 
    0.06980819f, 0.00556213f, 0.12322024f, -0.05640716f, -0.14980063f, 0.18508881f, 0.03476965f, 0.29566005f, 
    -0.08306652f, 0.04338720f, -0.00351734f, -0.05687178f, 0.03939532f, 0.14658417f, -0.02251175f, 0.04614385f, 
    0.26519725f, -0.18484417f, -0.08965696f, 0.29001877f, 0.04217318f, 0.08499509f, -0.05485819f, -0.11931732f, 
    -0.01848361f, 0.05409087f, -0.12112959f, -0.15601812f, -0.00920341f, -0.02652801f, 0.05203829f, 0.20204771f, 
    -0.02010114f, 0.00120225f, 0.00314057f, -0.09115495f, -0.06383981f, -0.01966591f, 0.11025631f, 0.06538545f, 
    -0.11737452f, 0.11914228f, 0.03655513f, 0.18784729f, 0.00790305f, -0.12853754f, 0.05232822f, 0.00647744f, 
    -0.06095441f, 0.16386418f, -0.00147938f, -0.07806094f, -0.07828620f, 0.08051172f, -0.14823700f, -0.27848923f, 
    0.05869276f, 0.08841891f, 0.03094938f, 0.05607232f, 0.07153960f, -0.01153899f, -0.00488723f, -0.18706675f, 
    0.25729516f, -0.03016372f, 0.08595691f, 0.09176245f, -0.07244910f, -0.08126850f, -0.00941620f, 0.14049892f, 
    0.07969130f, -0.06869595f, 0.14830229f, 0.10167544f, 0.05345214f, -0.11830559f, -0.08730736f, -0.23780346f, 
    0.08969601f, -0.07481231f, 0.05188018f, -0.00715476f, -0.11547927f, 0.00534704f, -0.04445042f, 0.05330409f, 
    0.11904169f, -0.02418332f, 0.13353848f, 0.03029861f, -0.03293026f, 0.18999927f, 0.04263159f, 0.00290831f, 
    -0.01468822f, 0.10873137f, 0.03246038f, -0.04318653f, 0.15664247f, -0.03992843f, -0.16286151f, 0.19668259f, 
    0.00241998f, 0.04293119f, -0.02638317f, 0.08509620f, -0.06441674f, -0.08083418f, -0.02625474f, -0.14999256f, 
    0.39555171f, 0.03994616f, 0.07308701f, -0.19667800f, 0.05800581f, 0.05817305f, -0.03737957f, 0.05777058f, 
    -0.00233952f, 0.21693125f, 0.11619993f, 0.04619880f, 0.01065618f, -0.21239361f, -0.02013121f, -0.01762103f, 
    -0.17648475f, 0.00078928f, -0.05989651f, 0.15026830f, -0.16926280f, 0.05136716f, 0.07073515f, 0.12623422f, 
    -0.28377444f, -0.03661417f, -0.08128583f, -0.06492631f, 0.05159114f, 0.14497617f, 0.10295189f, 0.03704404f, 
    0.00884827f, -0.08118264f, 0.19230239f, 0.01456480f, -0.03787835f, -0.11707115f, 0.11389232f, 0.07562450f, 
    -0.05485900f, 0.05461624f, -0.05766003f, 0.04292206f, 0.04011866f, -0.03718694f, -0.15591614f, -0.02850543f, 
    0.18638769f, -0.04439239f, -0.05310883f, 0.21854511f, -0.01647252f, 0.06555001f, 0.10269983f, -0.06907983f, 
    -0.00635759f, -0.04327872f, -0.02080379f, -0.14605632f, 0.42968133f, 0.16764957f, 0.10234930f, -0.08467044f, 
    -0.14010628f, 0.03087164f, 0.20781037f, 0.02738968f, 0.05452785f, 0.03154866f, -0.04356402f, 0.18883733f, 
    -0.04817833f, 0.04146234f, -0.03055225f, 0.33754346f, -0.01487336f, 0.22356847f, 0.07274426f, 0.08255283f, 
    0.14142045f, -0.04009677f, -0.03917513f, -0.09962644f, -0.10211378f, -0.19713916f, -0.05821725f, -0.01867017f, 
    -0.03991208f, -0.01835315f, 0.20374590f, -0.01168421f, -0.05409366f, 0.01659059f, 0.03138385f, 0.03098577f, 
    -0.30123827f, 0.03398949f, -0.07412376f, 0.07675555f, 0.02964052f, 0.05106412f, 0.07536201f, -0.01246398f, 
    -0.01415912f, -0.02109463f, -0.02857666f, -0.08975393f, -0.33374324f, -0.11930255f, 0.08071531f, -0.07030807f, 
    -0.05979272f, -0.12781255f, 0.01199664f, 0.08508851f, -0.03548366f, -0.02472462f, 0.08630005f, 0.11997068f, 
    -0.11189248f, 0.06893038f, 0.11613740f, 0.06093303f, -0.01887594f, -0.11537140f, 0.07951703f, 0.06238897f, 
    -0.04477748f, 0.12974955f, -0.12186244f, 0.00538015f, 0.24192996f, -0.01067423f, 0.22186033f, 0.12040525f, 
    -0.08142402f, 0.06886828f, -0.04182761f, -0.01198572f, 0.07394007f, -0.10037263f, 0.04366164f, -0.11871463f, 
    0.27004650f, 0.13464868f, 0.10236356f, -0.07139534f, 0.01900063f, 0.15582892f, 0.05335806f, 0.09394092f, 
    -0.01325051f, -0.08627941f, 0.16522036f, -0.03424082f, 0.00329374f, 0.03941019f, -0.18343669f, 0.02384789f, 
    0.08741135f, 0.01683519f, 0.15250824f, 0.06380348f, 0.05068184f, -0.02892227f, 0.07018884f, 0.04635069f, 
    -0.28627011f, -0.04360671f, -0.09581980f, 0.16178961f, -0.13728625f, 0.04810960f, -0.02621984f, 0.05076775f, 
    -0.03903158f, 0.14989975f, -0.03727299f, -0.03359501f, 0.00390512f, -0.01384567f, 0.13586292f, 0.07050093f, 
    0.09622168f, 0.10281720f, -0.04547578f, 0.07465129f, -0.11709478f, -0.02502212f, -0.10098900f, -0.11321479f, 
    0.08831638f, -0.06808808f, 0.04314817f, 0.04099309f, -0.11089899f, 0.01163726f, 0.05672724f, -0.01951122f, 
    0.01813287f, 0.07813091f, -0.02119935f, 0.08852849f, 0.08436068f, -0.01307971f, 0.09804025f, -0.01302476f, 
    -0.03058341f, -0.05340259f, 0.00502523f, 0.08985652f, -0.15020169f, 0.04909229f, 0.11056826f, 0.03613928f, 
    -0.17578255f, -0.06330919f, 0.06132032f, 0.15710548f, 0.02039051f, 0.09893254f, 0.08866912f, 0.13329373f, 
    -0.01388104f, -0.08255120f, 0.25564992f, -0.02447225f, -0.05355811f, 0.10225761f, -0.11056348f, -0.17008375f, 
    -0.10251267f, -0.04035243f, -0.01293190f, -0.00348555f, 0.06540116f, 0.07448664f, -0.09868171f, 0.00547909f, 
    -0.00162191f, -0.07290421f, -0.00339750f, 0.04295631f, -0.05225189f, 0.04941846f, 0.02693649f, -0.05809460f, 
    -0.00854785f, 0.01220214f, -0.06345502f, -0.04880458f, -0.02143567f, -0.02541273f, 0.03237126f, 0.05976333f, 
    -0.02050876f, 0.03592731f, 0.01246448f, 0.02126576f, -0.00093632f, 0.02403986f, 0.01721953f, 0.04751394f, 
    -0.07838504f, -0.03581673f, -0.02762733f, -0.07112201f, -0.00269403f, -0.03032262f, -0.00259020f, -0.00918732f, 
    0.02211865f, 0.03778447f, -0.05971562f, 0.04279191f, 0.06152334f, 0.01801019f, -0.02404613f, 0.00885610f, 
    -0.05179582f, -0.03289776f, -0.01201749f, -0.04186317f, -0.03194670f, -0.02401892f, -0.06994569f, 0.03856506f, 
    -0.03780434f, 0.00048855f, -0.05554760f, 0.01912848f, -0.04218032f, -0.04578620f, -0.05635684f, -0.00170313f, 
    -0.01888054f, -0.01553117f, -0.04020980f, -0.07345110f, 0.00011188f, -0.08348016f, 0.00384346f, -0.05517781f, 
    0.04321166f, -0.03368406f, 0.03310731f, -0.06614523f, -0.02048516f, 0.05385405f, 0.05108503f, -0.01824257f, 
    -0.00693252f, 0.04597049f, -0.07266017f, 0.00549487f, 0.02681118f, -0.06090601f, -0.02179410f, 0.04698531f, 
    -0.04906271f, -0.02894056f, 0.01666009f, 0.04349707f, 0.04213706f, -0.02822341f, -0.01340920f, 0.04842520f, 
    -0.00976216f, -0.04037646f, -0.00296778f, -0.05018014f, 0.03592872f, 0.03990401f, 0.05191207f, 0.05088963f, 
    0.06670058f, -0.05161887f, 0.00682477f, -0.06216545f, 0.03553211f, -0.04693765f, 0.00459738f, -0.03069144f, 
    -0.07732299f, -0.03022354f, 0.01319728f, 0.01592545f, -0.03754543f, -0.07060854f, 0.05432817f, 0.01231684f, 
    0.00977512f, 0.01306571f, 0.02420419f, -0.02235686f, 0.04497917f, -0.07066068f, -0.07291049f, -0.05031179f, 
    0.01468345f, -0.03925454f, -0.04971926f, 0.00517778f, -0.05835034f, -0.06830264f, 0.04260456f, 0.02803339f, 
    -0.01662700f, -0.05532559f, -0.07186422f, 0.04141125f, -0.02274168f, -0.04397026f, 0.06125220f, 0.01881271f, 
    0.00762504f, 0.02796878f, 0.03615059f, 0.04452080f, 0.03114340f, 0.06401717f, 0.01842703f, 0.02161134f, 
    -0.01039351f, 0.03957159f, 0.01845154f, -0.03553143f, -0.01844357f, -0.00744745f, 0.04588877f, -0.07048731f, 
    -0.05016292f, 0.05265188f, 0.05954085f, 0.00088237f, -0.02470256f, -0.04295838f, 0.05806847f, 0.05438385f, 
    -0.06870164f, -0.00166289f, -0.02360532f, 0.03595442f, 0.06113443f, -0.05017659f, 0.05836488f, -0.06206735f, 
    -0.04470709f, 0.00540224f, -0.08226963f, 0.04510082f, 0.01336467f, 0.05907313f, -0.08156668f, 0.02178562f, 
    -0.04039393f, -0.03032905f, -0.06278009f, 0.04540259f, -0.05639214f, -0.00633484f, -0.06555972f, -0.05449980f, 
    -0.07136731f, 0.02866797f, -0.02061880f, -0.01170546f, -0.01123070f, -0.03109495f, -0.07429155f, -0.05672288f, 
    0.09897572f, -0.03689244f, 0.03497861f, 0.28127962f, -0.08242340f, 0.05547331f, 0.01734634f, -0.15493694f, 
    0.03958506f, 0.08935326f, -0.03001249f, -0.10612148f, 0.53367126f, 0.07580283f, 0.03008451f, -0.02722033f, 
    -0.05632537f, 0.02145322f, 0.06281073f, 0.02272028f, -0.14032495f, 0.02803064f, 0.00705847f, 0.10618383f, 
    0.04719566f, -0.12255546f, 0.01084585f, 0.26721063f, 0.05753341f, 0.20499501f, 0.12721360f, 0.07167920f, 
    -0.01209382f, -0.09285335f, -0.04634930f, -0.06133687f, -0.06522001f, -0.15164222f, 0.08389103f, 0.13399002f, 
    -0.04523542f, 0.04089647f, 0.12998362f, -0.01556988f, -0.10381617f, 0.05177720f, -0.09845371f, 0.03489154f, 
    -0.08797878f, 0.10182791f, 0.06459556f, -0.15619712f, 0.05181462f, -0.04216352f, 0.05316727f, 0.06816679f, 
    -0.09858863f, 0.03530733f, -0.04322644f, 0.07578545f, -0.07209428f, 0.02486726f, 0.02480093f, 0.10506312f, 
    -0.01655888f, -0.08501156f, 0.07594235f, 0.09390951f, -0.08621366f, 0.01527380f, 0.06319235f, 0.05356882f, 
    -0.12923084f, 0.02080604f, 0.08586195f, -0.12175190f, -0.12443294f, -0.00359695f, 0.03424532f, -0.03139021f, 
    0.04409762f, 0.02300398f, 0.03214606f, 0.02170871f, 0.01141195f, -0.19019689f, 0.11787885f, 0.28522977f, 
    0.05187075f, 0.09453282f, 0.01200748f, -0.00408600f, -0.02988109f, -0.11284275f, 0.05711117f, 0.09049616f, 
    0.10182156f, 0.15504794f, 0.09484065f, -0.06908949f, 0.05789003f, 0.07623553f, 0.09530360f, 0.11103164f, 
    0.05317597f, -0.02197670f, 0.10137738f, -0.15978906f, -0.32142329f, 0.14991285f, -0.17428178f, -0.00685795f, 
    0.01676329f, -0.02381951f, 0.03669462f, 0.07409222f, 0.11557406f, -0.05458742f, 0.02711048f, 0.02805138f, 
    -0.28861338f, -0.21783081f, 0.01536265f, 0.09485283f, -0.05611686f, 0.05867370f, 0.11221032f, 0.10611590f, 
    0.01624958f, 0.00106869f, -0.03662544f, -0.04441797f, 0.10598370f, 0.15735982f, 0.14901042f, 0.00511215f, 
    0.01570043f, -0.00965143f, 0.09129379f, 0.04602635f, 0.00070918f, -0.02182550f, -0.07392257f, -0.01576145f, 
    -0.04288179f, 0.00442286f, 0.05542131f, -0.00820340f, -0.00337749f, 0.03032611f, -0.12451655f, 0.08884424f, 
    -0.03588285f, 0.11265460f, -0.10177510f, -0.00546523f, -0.28824198f, 0.03994782f, 0.06241044f, -0.13821146f, 
    0.04052610f, -0.01210967f, 0.00715676f, -0.03941771f, -0.00565248f, 0.01432053f, 0.03776481f, -0.06493974f, 
    -0.04993884f, 0.04823894f, 0.04056569f, -0.12026650f, -0.04434080f, 0.12236120f, 0.01647967f, -0.08173335f, 
    -0.06685927f, 0.01384239f, 0.15941679f, 0.07397047f, -0.21984203f, 0.14123063f, -0.00583071f, -0.08228032f, 
    0.01235535f, -0.23524830f, -0.03633229f, 0.06053061f, 0.06107984f, -0.02156514f, 0.00209035f, -0.02896216f, 
    0.04773929f, -0.41027388f, -0.02613591f, -0.17357360f, -0.07824581f, 0.11996944f, 0.11147343f, 0.13458595f, 
    -0.02215585f, -0.04027170f, -0.02638162f, 0.00425045f, 0.21945365f, 0.05676287f, -0.13931224f, -0.34456182f, 
    0.00735049f, 0.14413178f, -0.11482096f, 0.07636667f, 0.02184265f, -0.10228089f, 0.03051604f, 0.00265063f, 
    -0.16292492f, -0.45460799f, -0.19157055f, 0.26175034f, 0.08273084f, -0.03157346f, -0.04772643f, -0.02948289f, 
    -0.03592426f, -0.11789865f, -0.01619891f, 0.04647022f, 0.15457559f, -0.04771933f, 0.03936098f, -0.08819518f, 
    -0.13883924f, 0.03991683f, -0.04501487f, 0.01605561f, -0.06485776f, -0.09469552f, 0.06476047f, -0.01357123f, 
    0.16355701f, 0.40392110f, -0.09822272f, 0.17969653f, 0.03017051f, -0.09930670f, 0.09130857f, -0.03931323f, 
    -0.02995030f, -0.01405690f, 0.12872928f, -0.02809454f, -0.06072280f, -0.08602333f, 0.07041410f, -0.18651101f, 
    -0.13988002f, -0.11991026f, -0.08250848f, 0.00184091f, 0.01728310f, 0.14062318f, 0.13840130f, -0.02878318f, 
    0.18010922f, -0.07158159f, 0.15423495f, -0.17352568f, -0.13729724f, -0.03858722f, 0.01766605f, -0.06349551f, 
    0.03971799f, -0.04107428f, -0.04017369f, 0.02641509f, -0.07039980f, -0.03250476f, -0.01806646f, 0.54084116f, 
    0.18891327f, -0.00403842f, 0.00581688f, 0.05149014f, 0.07512461f, -0.06960023f, 0.05594012f, -0.21662436f, 
    0.04928369f, 0.15442806f, -0.12859985f, -0.43798503f, 0.00132282f, 0.02269164f, 0.07230921f, -0.05550382f, 
    -0.06261021f, -0.04208558f, -0.10424925f, 0.05460550f, 0.23442645f, 0.13019174f, 0.25916463f, 0.25990063f, 
    -0.06429734f, 0.09661134f, -0.05429903f, -0.02506520f, -0.01408651f, -0.00429935f, -0.02146899f, -0.09593789f, 
    -0.27959940f, -0.02120258f, -0.27512959f, -0.25183022f, 0.22962762f, 0.14297864f, 0.11098159f, 0.03647763f, 
    0.02364363f, 0.09455484f, -0.02269470f, 0.10241887f, -0.18670510f, -0.03121033f, -0.12999804f, -0.30506760f, 
    -0.00139954f, 0.05555382f, 0.07167125f, 0.02010075f, -0.04092767f, 0.02582770f, 0.14251587f, 0.05643473f, 
    0.07376982f, -0.22360305f, -0.06324023f, 0.09418558f, -0.05346702f, 0.00548494f, 0.06206819f, 0.08716952f, 
    -0.09366269f, 0.08266911f, 0.05479712f, 0.09870758f, 0.18786901f, 0.21013741f, 0.17287853f, 0.20331246f, 
    -0.00891897f, 0.00570796f, -0.09045235f, 0.07449013f, 0.06813386f, -0.04727346f, 0.00284569f, -0.05667448f, 
    0.38779756f, -0.02286801f, 0.11015800f, 0.23108388f, -0.04628018f, -0.02788672f, 0.08899689f, -0.04420144f, 
    -0.00561148f, -0.10917245f, -0.06620997f, -0.00580609f, 0.26500273f, 0.13996129f, 0.05530512f, 0.13021146f, 
    -0.06782960f, -0.15336819f, -0.00275265f, -0.06248815f, -0.02201749f, 0.06581510f, 0.09428463f, -0.05135392f, 
    -0.03147388f, -0.00036699f, 0.01373933f, 0.12005118f, -0.10541776f, 0.02039834f, -0.01947780f, -0.12133551f, 
    -0.00467206f, 0.00389475f, 0.06507139f, 0.07554947f, -0.16793400f, -0.22041520f, 0.25015479f, 0.25976804f, 
    -0.08185545f, -0.02693512f, -0.01406066f, -0.08731078f, -0.06413211f, -0.05040513f, 0.11551210f, -0.02007801f, 
    -0.01077329f, 0.33119598f, 0.20207179f, -0.04308600f, 0.02066053f, -0.00704718f, -0.08096189f, -0.07825141f, 
    0.16903621f, 0.13244158f, -0.06905791f, -0.04884556f, 0.04841152f, 0.27036309f, 0.04994927f, 0.03666305f, 
    0.03809779f, -0.05953566f, 0.06670480f, 0.01372781f, 0.07838117f, 0.04421512f, -0.09274259f, 0.03122731f, 
    0.16931503f, -0.31484017f, 0.07658470f, -0.03658346f, 0.05229300f, 0.08888844f, 0.06678719f, -0.01033445f, 
    0.05555665f, -0.04462015f, 0.02565678f, -0.01735151f, -0.04232699f, -0.01771761f, -0.18299998f, -0.09788873f, 
    0.18761761f, 0.04362810f, -0.09151862f, -0.00221568f, -0.10770783f, -0.12360758f, 0.04981720f, 0.04435626f, 
    -0.12423126f, 0.22183777f, 0.02269625f, 0.00147313f, 0.20294365f, 0.14680089f, -0.08530608f, 0.02172302f, 
    0.11524889f, -0.00695288f, 0.07070391f, 0.06243928f, -0.16575950f, -0.00826206f, 0.04381570f, -0.31607980f, 
    -0.05025455f, 0.08944046f, 0.02025301f, 0.04922400f, -0.03779170f, 0.15003701f, 0.12083694f, 0.07737518f, 
    0.02199014f, -0.06903630f, 0.09606206f, 0.04570794f, 0.04485409f, -0.02385136f, 0.11452021f, 0.04960677f, 
    0.00927119f, -0.09847657f, 0.12314861f, -0.03722793f, -0.05280747f, 0.18312351f, -0.02734533f, 0.07017358f, 
    0.08811659f, -0.00003345f, 0.12687889f, 0.04130420f, 0.03201273f, -0.06733575f, -0.00239491f, 0.06184602f, 
    -0.04029633f, -0.13394076f, 0.17562689f, 0.09116045f, -0.09781500f, 0.09638219f, -0.08660948f, 0.03330633f, 
    -0.05950688f, -0.09606769f, -0.06910531f, -0.09312648f, -0.12553251f, 0.24023107f, -0.01958884f, -0.16418341f, 
    -0.00429048f, -0.06308872f, 0.01384460f, -0.12227029f, -0.02109051f, -0.10772502f, -0.09691067f, 0.04738255f, 
    0.24092253f, 0.03974850f, -0.08492861f, -0.04395014f, 0.13232203f, -0.08615609f, -0.02972764f, 0.06382017f, 
    0.06141194f, -0.00666150f, 0.00545747f, 0.04424661f, 0.53246069f, -0.06128996f, 0.21902521f, 0.20089641f, 
    -0.03428344f, 0.04741640f, 0.04850803f, -0.11150688f, -0.06328545f, -0.08536194f, -0.02167766f, 0.07303905f, 
    -0.16871460f, 0.27348602f, -0.02021913f, 0.05302316f, -0.01079109f, 0.04474099f, 0.04316456f, 0.04642454f, 
    -0.03838278f, 0.05401604f, -0.05256927f, 0.01169633f, -0.15691063f, -0.11761191f, 0.01498242f, -0.03470540f, 
    0.10572015f, 0.04072257f, -0.11873468f, -0.00535523f, 0.09076346f, -0.05812842f, 0.00315448f, 0.10561900f, 
    -0.12742952f, -0.17124273f, -0.02325496f, 0.11554823f, 0.06876609f, -0.03548370f, 0.08509462f, 0.02415073f, 
    0.00976118f, -0.01960724f, -0.03352190f, -0.06339988f, 0.15035830f, -0.08791727f, 0.24021865f, 0.19788854f, 
    -0.14770910f, 0.03032623f, 0.10441677f, -0.00542165f, 0.08974008f, -0.04841534f, 0.04243588f, 0.10611565f, 
    -0.19086556f, -0.01973254f, 0.16300520f, 0.14034858f, 0.01216007f, 0.10810908f, -0.06166803f, 0.16746974f, 
    0.11056364f, 0.00839033f, 0.12412933f, -0.05509123f, -0.10108526f, -0.10995141f, -0.07501181f, -0.12172236f, 
    0.17277047f, -0.11145531f, 0.04599508f, -0.03579235f, 0.07791834f, 0.00114976f, 0.04442568f, 0.15035997f, 
    -0.17392021f, -0.07348961f, -0.18880828f, -0.02422722f, 0.07518484f, 0.04756116f, 0.03965519f, -0.00275419f, 
    0.06430554f, -0.13405795f, 0.01199964f, -0.06884269f, -0.53620458f, 0.05369936f, -0.19205242f, -0.03191910f, 
    0.11706739f, 0.05299072f, -0.07208575f, 0.09991262f, -0.04335032f, 0.01019229f, -0.03640550f, 0.09112886f, 
    0.39607778f, -0.00797072f, 0.20789437f, 0.06703436f, 0.17523807f, -0.07707256f, 0.13636032f, -0.00205875f, 
    0.11433755f, 0.11368942f, -0.02771935f, -0.06468949f, 0.39653325f, 0.26868376f, 0.11819515f, -0.11572539f, 
    -0.12828085f, -0.07059622f, -0.08211257f, 0.03758662f, 0.07543743f, 0.02773726f, 0.01236791f, 0.08460787f, 
    -0.04500474f, -0.15145040f, 0.03314555f, -0.02341866f, -0.03635291f, 0.14789598f, 0.05892037f, 0.07650196f, 
    0.01118776f, -0.06439269f, 0.24600244f, 0.13220866f, -0.00393543f, 0.08938485f, 0.03260319f, 0.06510895f, 
    0.18521515f, -0.02374968f, 0.15733768f, 0.04488374f, 0.01487409f, 0.00374929f, 0.01638785f, 0.07061589f, 
    0.32631239f, 0.38062763f, 0.15064919f, -0.03517135f, -0.12364411f, 0.05460618f, -0.05912818f, 0.05285748f, 
    0.03816453f, -0.05038241f, -0.00429748f, -0.01830211f, -0.21695790f, 0.01654474f, 0.10053018f, 0.14479463f, 
    -0.11953105f, 0.10848065f, 0.01247057f, -0.00632418f, -0.01060140f, -0.08868506f, -0.17549177f, 0.02508722f, 
    -0.35086268f, 0.09350112f, -0.32157332f, 0.03920529f, 0.08827683f, -0.00229244f, -0.07580008f, -0.00741765f, 
    0.01620821f, 0.07659855f, 0.05740867f, 0.08034221f, 0.21320358f, 0.04433716f, 0.15354909f, 0.01941433f, 
    -0.05524616f, 0.03993011f, 0.03032837f, 0.01435365f, 0.02663949f, 0.02328971f, 0.08990582f, 0.12556598f, 
    -0.10667083f, 0.17418163f, 0.12101638f, 0.15657339f, 0.11045024f, 0.07417065f, -0.03057972f, 0.15890700f, 
    0.02816773f, 0.09566728f, 0.21361074f, 0.00582541f, -0.01148740f, -0.18395363f, -0.14664000f, -0.21957886f, 
    0.04746048f, 0.10794695f, -0.04531036f, 0.07047369f, 0.15275580f, -0.00954023f, -0.13294791f, -0.02880580f, 
    0.05258688f, -0.15539369f, -0.15424550f, -0.11439455f, 0.04893115f, -0.00955860f, 0.00795277f, 0.06447549f, 
    0.13898326f, -0.11094268f, -0.00522948f, 0.04981094f, -0.18722093f, -0.17980051f, 0.02615291f, 0.05911941f, 
    0.06428237f, -0.02219437f, -0.03410560f, 0.15126579f, -0.01968458f, 0.16991514f, -0.09663868f, 0.09726753f, 
    0.15141658f, 0.14620526f, 0.17169230f, -0.24173789f, 0.16123025f, -0.06146214f, 0.01743782f, -0.02254164f, 
    -0.03095437f, 0.09468590f, -0.02914935f, 0.12371438f, -0.21505243f, -0.28517330f, -0.07225911f, 0.12024626f, 
    -0.05967232f, 0.05208088f, -0.01308193f, 0.03045661f, 0.09837425f, -0.10393289f, 0.19002678f, 0.00535375f, 
    0.03346414f, 0.04366671f, 0.11001192f, -0.09382358f, -0.00049658f, -0.01379727f, 0.06390993f, 0.11320847f, 
    0.06990436f, 0.18051535f, 0.01146610f, 0.04984886f, -0.10262576f, -0.34861055f, -0.29238877f, -0.09835303f, 
    0.07427610f, 0.10933562f, -0.02519455f, 0.00402141f, 0.11702594f, -0.02962258f, 0.01363626f, -0.11804662f, 
    -0.10481232f, -0.20482492f, -0.25653929f, 0.07620517f, -0.05851233f, 0.02648690f, 0.02836654f, 0.04798299f, 
    0.10942600f, -0.05562525f, 0.15011325f, -0.13119750f, 0.05621219f, 0.27283165f, 0.13750899f, -0.17643219f, 
    0.05041326f, -0.06334352f, -0.03831635f, -0.07950235f, -0.12097453f, 0.02215278f, 0.00485004f, 0.23289274f, 
    -0.14443211f, -0.14181131f, -0.23519391f, 0.23668860f, 0.12425169f, -0.01682818f, 0.09939190f, -0.05929273f, 
    0.00444173f, 0.17332841f, -0.10231435f, -0.06488191f, 0.09247835f, 0.11300909f, 0.13969706f, 0.03096291f, 
    0.06024925f, 0.09152236f, 0.03143540f, 0.05227863f, 0.12544179f, 0.01746894f, 0.06394729f, 0.08821338f, 
    -0.28622508f, 0.04460733f, 0.02047950f, 0.37538075f, 0.11600921f, -0.01871556f, 0.11220899f, -0.09382419f, 
    0.11169632f, -0.05898776f, 0.10847181f, -0.01531985f, 0.21757595f, -0.15231910f, -0.08501855f, 0.19393583f, 
    0.11410517f, 0.04778144f, 0.05807131f, -0.01747048f, -0.04496080f, 0.06276511f, 0.11489944f, 0.02817283f, 
    0.08191802f, 0.03779620f, 0.14808953f, -0.31158790f, 0.09687340f, -0.02919759f, 0.03011359f, 0.09723626f, 
    -0.06419010f, -0.00647477f, 0.05409555f, -0.00919247f, -0.14714691f, 0.09523973f, -0.07870433f, -0.03366677f, 
    -0.05780198f, -0.02196597f, 0.02969551f, -0.04836097f, 0.00851205f, 0.06933597f, -0.04189714f, -0.12862231f, 
    0.14111280f, 0.09416454f, 0.10085507f, 0.00428156f, 0.04504042f, -0.09443586f, -0.09420247f, -0.09253100f, 
    0.01167167f, -0.06990226f, -0.13943812f, -0.04900821f, -0.37885359f, -0.27160344f, -0.31875429f, -0.12713885f, 
    -0.02221442f, 0.02439322f, 0.07580876f, -0.05753260f, 0.04339782f, 0.06856878f, 0.14969544f, -0.01478603f, 
    0.00313307f, 0.06849366f, -0.01971946f, 0.03561838f, 0.08382453f, 0.02967885f, 0.01715999f, -0.07282552f, 
    -0.05136877f, -0.05163345f, 0.05322798f, -0.06566896f, 0.05273869f, -0.00688026f, 0.07501803f, 0.00379975f, 
    0.09793217f, 0.00848055f, 0.08942725f, -0.05037810f, -0.00660329f, 0.03726441f, -0.01991281f, -0.00237558f, 
    0.23347084f, 0.19641523f, -0.02851062f, -0.02103133f, 0.02747401f, 0.10597710f, -0.07471312f, 0.04157086f, 
    0.04014660f, -0.07226887f, 0.03704370f, -0.09119948f, -0.04529704f, 0.11655552f, -0.05544621f, 0.17708637f, 
    -0.02136028f, 0.00409878f, 0.06858106f, -0.02833316f, 0.05198214f, 0.05811090f, -0.03858026f, -0.13870473f, 
    -0.04207971f, -0.16222525f, -0.15165697f, 0.08371808f, -0.01054298f, 0.10075258f, 0.01856363f, 0.07424158f, 
    0.00618352f, 0.09700453f, 0.19447964f, 0.07700038f, 0.29495874f, 0.06749802f, 0.35290489f, 0.14625578f, 
    -0.06725758f, 0.01992898f, 0.03626441f, -0.04681005f, 0.03324500f, -0.02020301f, 0.05838675f, -0.10548571f, 
    -0.22749086f, -0.03033012f, -0.05090317f, 0.14968792f, 0.26201200f, 0.03857300f, 0.09801985f, 0.02890760f, 
    0.12795223f, 0.06514216f, 0.02333806f, 0.04485251f, -0.25305516f, -0.08257187f, -0.20754689f, -0.39881647f, 
    0.01710990f, -0.03061608f, -0.06756547f, -0.00176614f, -0.09339583f, 0.02650525f, 0.03853310f, -0.10551485f, 
    0.17826322f, 0.00173774f, 0.02852227f, 0.27184629f, 0.05078929f, 0.05821374f, 0.03427156f, -0.03374259f, 
    -0.06148854f, -0.07598500f, 0.07202110f, 0.05349470f, -0.16481338f, -0.11167724f, -0.06212550f, -0.09280171f, 
    -0.01172838f, -0.02106125f, -0.00713206f, 0.05874319f, 0.03522485f, 0.08701059f, -0.06921891f, 0.00785834f, 
    -0.41303918f, -0.12699687f, 0.22356349f, 0.06251483f, -0.05988141f, 0.06260797f, -0.05724125f, -0.02243241f, 
    -0.08184270f, -0.03435965f, 0.04979720f, 0.00166647f, -0.02515094f, 0.12530589f, 0.07097950f, 0.16539147f, 
    0.03805834f, 0.06166159f, -0.00588391f, -0.05871715f, -0.05659204f, -0.02302348f, -0.06373889f, -0.03497845f, 
    0.37288049f, 0.03783396f, -0.06415688f, 0.04108904f, -0.09630266f, -0.00745955f, -0.04269482f, 0.00024051f, 
    -0.04760591f, 0.05236848f, 0.03411857f, -0.11918769f, 0.32447302f, -0.00370940f, -0.00292442f, -0.02645317f, 
    -0.03699515f, 0.01747467f, 0.06120516f, 0.02014168f, -0.04464412f, 0.02267853f, 0.06168843f, 0.02800683f, 
    -0.32932520f, -0.07250846f, -0.02653993f, -0.08749058f, -0.10249638f, 0.09984872f, 0.11567957f, 0.07307424f, 
    -0.02006880f, 0.04222384f, 0.03390248f, -0.01296245f, 0.20247985f, 0.19158117f, -0.03295903f, 0.09145434f, 
    -0.01187927f, 0.04247588f, 0.05103992f, 0.13496487f, -0.00004369f, 0.03198897f, -0.02310482f, 0.05187345f, 
    0.04103256f, -0.05759815f, -0.03352990f, -0.03499338f, -0.05175728f, -0.01416253f, 0.00834423f, 0.05994377f, 
    0.02205316f, -0.03832803f, 0.01942890f, -0.07641643f, 0.00749089f, -0.01496562f, 0.03500728f, -0.03988162f, 
    -0.00947848f, -0.00694871f, 0.01207795f, 0.01475665f, -0.07673623f, -0.04515108f, 0.03983669f, 0.02449982f, 
    -0.00925890f, 0.04244422f, 0.04125686f, -0.01759075f, -0.01379401f, 0.03966623f, -0.06807799f, 0.03586355f, 
    -0.04562515f, 0.01544476f, 0.03920249f, -0.00162014f, -0.00892391f, -0.06156509f, 0.05884467f, -0.00719043f, 
    -0.03316257f, -0.03970249f, 0.01868491f, -0.01127272f, 0.04815837f, -0.01704869f, -0.03715500f, -0.02829422f, 
    -0.00158624f, 0.03456056f, -0.01917416f, -0.06236351f, -0.02433610f, -0.00378678f, -0.07389835f, -0.01814077f, 
    0.04314743f, -0.00072622f, -0.07125293f, 0.05248005f, 0.06621871f, -0.03426802f, -0.06011036f, -0.03734630f, 
    -0.00412540f, -0.00070600f, -0.02242212f, -0.01142587f, -0.04660644f, -0.02469671f, -0.01008024f, -0.02727419f, 
    -0.04232635f, 0.03309716f, -0.04544736f, -0.05557033f, 0.00706019f, 0.04863233f, 0.05746996f, 0.06327198f, 
    0.01245752f, -0.01925923f, -0.03868310f, 0.05831905f, 0.00440800f, 0.06529288f, 0.04027946f, -0.04758678f, 
    0.01556474f, 0.04225293f, 0.02280713f, -0.01823173f, 0.00888234f, -0.02237378f, 0.04833175f, -0.04863511f, 
    -0.07033611f, -0.05965574f, -0.07591153f, -0.07581314f, -0.00612707f, -0.05160886f, -0.02355857f, 0.06648900f, 
    0.05770060f, -0.04222018f, -0.01818617f, -0.00015724f, -0.04574269f, 0.06541073f, 0.06405019f, -0.07308000f, 
    -0.06478769f, -0.05861879f, 0.01663677f, -0.07353056f, -0.04142599f, -0.07273900f, 0.01967744f, -0.04071170f, 
    0.06226781f, 0.03229292f, 0.06183242f, -0.01804788f, 0.04590882f, 0.05887227f, 0.01349332f, 0.01552778f, 
    0.05587326f, -0.02959245f, 0.00576137f, 0.03376633f, -0.04699634f, -0.05545361f, -0.02904803f, -0.01205367f, 
    -0.01385812f, 0.01867949f, -0.00650033f, 0.04140897f, -0.03146336f, -0.03737361f, 0.04540115f, 0.06152349f, 
    -0.05450237f, 0.04086526f, -0.02921171f, -0.04368713f, -0.00060531f, 0.01399654f, -0.02352897f, -0.01423587f, 
    0.01186790f, 0.04529918f, -0.04059447f, -0.04152960f, -0.00480777f, 0.06516054f, -0.06422991f, -0.03661551f, 
    -0.07004108f, -0.03816174f, 0.01986652f, 0.01906075f, -0.03039234f, -0.05924856f, -0.07396378f, -0.02698170f, 
    0.02110938f, -0.02922307f, -0.01494480f, 0.03405992f, -0.07679580f, -0.01204812f, -0.00139087f, -0.04415653f, 
    -0.04957832f, -0.00661753f, -0.04377122f, 0.04979449f, -0.06953936f, -0.07016555f, 0.00247399f, -0.07476101f, 
    0.06529391f, 0.03264830f, -0.07291898f, -0.02602050f, -0.05798194f, 0.04264564f, -0.03893401f, -0.05079134f, 
    -0.07031684f, 0.00144168f, -0.05084142f, -0.00107081f, -0.06808135f, -0.06025839f, -0.06938366f, 0.01564572f, 
    -0.06157288f, -0.04912041f, -0.03271977f, 0.04115192f, 0.01308623f, 0.01096233f, -0.06484082f, -0.03543114f, 
    -0.01439900f, -0.04854994f, -0.03102158f, 0.02555554f, -0.00112362f, -0.05700252f, -0.01777883f, 0.01314425f, 
    -0.01114005f, -0.01937898f, 0.00193196f, 0.06494228f, -0.04629442f, 0.03959619f, 0.01151582f, -0.05846032f, 
    -0.07475965f, -0.06957707f, 0.02414978f, -0.07594862f, 0.04447735f, -0.03871487f, -0.02062821f, -0.02554155f, 
    -0.06128396f, 0.01226474f, -0.06245538f, 0.01644565f, 0.04464643f, 0.03672259f, -0.05743647f, -0.04136123f, 
    0.05925921f, -0.03969871f, -0.01180981f, -0.06446058f, -0.03444267f, -0.03354402f, 0.00129827f, -0.00050963f, 
    -0.00099581f, 0.03408034f, 0.00120244f, -0.05073752f, 0.03475091f, 0.03028383f, -0.04617214f, -0.00654076f, 
    0.03107180f, -0.04322465f, 0.01123915f, 0.00868646f, 0.04116104f, -0.04074541f, 0.04395011f, 0.02264201f, 
    -0.02049102f, 0.06004466f, -0.00490103f, -0.05759899f, -0.06060928f, 0.02830183f, 0.01405048f, 0.05321456f, 
    -0.02630544f, 0.01131132f, -0.06274255f, -0.05430520f, -0.00075610f, -0.06637914f, -0.04448067f, 0.04696375f, 
    0.03993471f, -0.03211503f, 0.04757122f, 0.00034785f, 0.05568207f, -0.01135909f, -0.05364766f, 0.05060087f, 
    -0.07749891f, 0.05459208f, 0.00634888f, -0.07147957f, -0.02079603f, 0.03971436f, 0.02579564f, -0.01775350f, 
    -0.02153628f, -0.06820948f, -0.02046571f, 0.00849181f, 0.06046112f, -0.04813474f, -0.05754282f, -0.03280985f, 
    -0.04652184f, 0.01877960f, -0.06830464f, -0.04912533f, 0.00343822f, 0.03471205f, -0.04340898f, -0.01721330f, 
    0.02333491f, 0.02658454f, 0.00291880f, -0.02044965f, -0.06159608f, 0.05035447f, -0.06832248f, -0.01646225f, 
    0.02673711f, -0.03416728f, 0.02977869f, 0.01945940f, 0.02727100f, -0.02589878f, 0.06470894f, 0.01121280f, 
    -0.01431949f, -0.02456930f, -0.04042612f, 0.04764717f, 0.06577627f, -0.01520605f, 0.00345976f, -0.02787137f, 
    -0.05030544f, -0.06285979f, -0.04698182f, -0.01764819f, -0.07082992f, 0.04728661f, 0.06578846f, -0.06879243f, 
    -0.03314464f, -0.01406715f, -0.00097280f, -0.04761626f, -0.03794704f, 0.01734159f, -0.07090747f, 0.02705908f, 
    -0.02132524f, 0.03363340f, -0.04763695f, -0.01665343f, 0.03004095f, 0.01158530f, 0.00888214f, -0.06569463f, 
    -0.06440800f, -0.00068224f, 0.01793186f, 0.02024384f, -0.00558163f, -0.03250429f, -0.00370254f, -0.05849301f, 
    0.04533747f, 0.02558490f, -0.03485129f, 0.01605291f, -0.05656799f, -0.02656397f, -0.05060447f, 0.01053988f, 
    0.03572266f, 0.03698512f, 0.01578223f, 0.06141079f, -0.07260695f, 0.01512723f, 0.02351274f, -0.06056231f, 
    -0.21637841f, 0.04591771f, 0.05488561f, -0.16667706f, 0.01252487f, 0.00476259f, -0.13151325f, 0.05697848f, 
    -0.08190963f, -0.05047382f, 0.10945947f, -0.02980868f, -0.44947344f, 0.15486383f, 0.14623153f, 0.19515420f, 
    0.05634236f, 0.04783056f, 0.02770464f, -0.09145723f, -0.04712177f, -0.04605542f, 0.09996291f, 0.01725570f, 
    0.00958684f, 0.40565255f, -0.05328687f, -0.02253514f, 0.06697864f, 0.04313361f, -0.00042725f, -0.08555645f, 
    0.05147846f, 0.09598884f, 0.06016774f, -0.09031674f, 0.11712684f, 0.24615955f, -0.00210189f, 0.05351919f, 
    0.08985711f, 0.04047919f, 0.06760599f, -0.02986352f, 0.10207479f, -0.04870394f, -0.04949696f, -0.01127921f, 
    0.13244829f, -0.27848426f, 0.11134974f, 0.13816586f, 0.12892583f, 0.11023689f, -0.13268821f, 0.03870486f, 
    0.00238080f, -0.00805922f, -0.02853033f, 0.04385608f, 0.16784924f, 0.01627547f, 0.06470373f, -0.13916841f, 
    0.02737599f, 0.19759841f, 0.09476034f, -0.12929417f, -0.08577802f, 0.06542786f, 0.03697411f, 0.09507731f, 
    -0.07615191f, 0.35219923f, -0.00651541f, 0.00596982f, 0.05910020f, 0.08800436f, -0.03414013f, 0.03353041f, 
    0.05223680f, 0.12690736f, -0.00210611f, 0.01598942f, -0.03617989f, 0.11318503f, -0.02083393f, -0.17543137f, 
    -0.11885330f, 0.04446010f, -0.09333237f, 0.00365367f, -0.04277749f, 0.05943828f, 0.10650568f, -0.16676755f, 
    -0.02697786f, 0.08057408f, -0.08106631f, 0.07263984f, -0.11886222f, 0.06602841f, 0.05266152f, 0.02659155f, 
    0.04061078f, -0.14679489f, 0.00945738f, -0.00125077f, 0.20196298f, -0.16343805f, -0.04650361f, 0.12666014f, 
    0.06068761f, -0.02157813f, -0.00364866f, -0.12419690f, -0.08744492f, -0.01332370f, 0.04148028f, 0.03514600f, 
    0.09573262f, 0.00851054f, -0.03387467f, 0.08770796f, -0.11040387f, 0.00073788f, -0.08328699f, 0.04798033f, 
    -0.07585221f, -0.01837606f, 0.01786018f, -0.10640410f, -0.03473852f, -0.02886144f, -0.07603760f, -0.03793694f, 
    -0.12147474f, -0.04763189f, -0.03855076f, -0.13339919f, -0.00419608f, 0.00342349f, -0.08696581f, 0.03132211f, 
    0.71586490f, -0.17046709f, 0.01643331f, 0.01680406f, -0.00126719f, -0.06328356f, 0.13352728f, -0.03299358f, 
    0.17342778f, 0.14705837f, -0.06963425f, 0.01569508f, 0.57317019f, -0.09684498f, 0.07728877f, 0.12283213f, 
    -0.05043088f, 0.03398462f, 0.02452315f, -0.07951570f, 0.09454938f, -0.06939987f, 0.12467664f, 0.08648086f, 
    -0.10709254f, 0.24713327f, 0.00057216f, 0.11306994f, -0.07835537f, -0.01906457f, -0.05145014f, -0.00147321f, 
    0.09270719f, 0.02632259f, 0.04797310f, -0.09225047f, 0.08449204f, -0.03785203f, 0.08031338f, -0.07239639f, 
    0.05669853f, 0.10249645f, -0.06254583f, 0.05146197f, 0.00753990f, 0.02205885f, -0.10579618f, 0.10856137f, 
    -0.10477031f, -0.05415611f, 0.06189660f, 0.24983425f, -0.00860898f, 0.09951355f, 0.00788434f, -0.15380281f, 
    -0.17262624f, -0.05283876f, -0.04542531f, -0.07581630f, 0.19819623f, -0.17276268f, 0.02213713f, 0.09215914f, 
    -0.04260626f, -0.11759447f, -0.07258201f, 0.06788125f, -0.10160880f, 0.02647006f, -0.02671104f, -0.08193349f, 
    -0.02054877f, -0.08548156f, 0.05912853f, 0.26250270f, 0.06504962f, -0.02006342f, 0.05575893f, 0.05705085f, 
    0.01259650f, 0.11460592f, -0.02682114f, -0.01029272f, 0.01503670f, 0.31349725f, 0.12019525f, 0.01005838f, 
    0.06592116f, 0.05250625f, 0.01850832f, 0.05725310f, -0.01518326f, -0.00748922f, -0.12418957f, -0.03079852f, 
    0.14868234f, -0.28250301f, -0.01724771f, -0.04841541f, 0.01165472f, 0.00452194f, 0.00293649f, -0.06826547f, 
    0.07797626f, -0.04192951f, 0.01956520f, 0.08945481f, -0.15968084f, 0.05255393f, -0.13717216f, 0.01833893f, 
    0.02603249f, 0.08701793f, -0.00475305f, 0.08942356f, -0.03155610f, 0.01608204f, 0.03890394f, 0.08331102f, 
    -0.23073463f, 0.18626510f, 0.16517095f, -0.05126279f, 0.14510621f, 0.13316797f, 0.00312715f, -0.01852037f, 
    -0.00491641f, -0.06755953f, -0.10890585f, 0.09859406f, -0.10696003f, -0.15133488f, 0.04852624f, -0.07955680f, 
    0.01735620f, 0.00284538f, -0.12673406f, -0.06606932f, -0.09034308f, -0.04360109f, 0.11946059f, -0.09003402f, 
    -0.04926247f, 0.06119517f, 0.06860509f, -0.18510999f, 0.09093006f, -0.01760870f, -0.00543721f, 0.09253419f, 
    0.03228137f, -0.03072679f, 0.15067261f, -0.00462283f, -0.02808330f, 0.07588156f, -0.10397781f, 0.12357015f, 
    0.09435019f, -0.17591593f, -0.00702435f, 0.01724440f, 0.00173336f, -0.04629738f, 0.09082359f, -0.04252054f, 
    -0.01348079f, -0.11771004f, 0.16363512f, -0.09969094f, 0.12288511f, 0.03219053f, -0.00892114f, -0.05879139f, 
    -0.03765199f, -0.06319248f, -0.07926352f, 0.05863497f, -0.04710497f, 0.34743673f, 0.08072672f, -0.31134355f, 
    0.06669478f, -0.10283506f, 0.07670692f, -0.03253622f, 0.04754363f, 0.03136586f, -0.02022772f, 0.04789235f, 
    0.15826060f, -0.05606324f, -0.20202504f, 0.14439283f, 0.06214730f, -0.10503769f, -0.05250377f, -0.01415220f, 
    0.02640853f, 0.14478371f, -0.08133253f, 0.04992663f, 0.50638926f, 0.03387208f, -0.02564389f, 0.07496109f, 
    -0.02160105f, 0.04373069f, 0.06998256f, 0.07004561f, 0.00172892f, -0.01452358f, -0.03948962f, 0.06611476f, 
    -0.12597361f, 0.11729302f, -0.12795220f, -0.11481008f, -0.02499984f, 0.00762453f, 0.06799352f, 0.02201333f, 
    0.11767569f, -0.01381142f, 0.07396876f, 0.06423052f, 0.29689598f, 0.11706208f, 0.06903765f, -0.15749131f, 
    0.05139706f, -0.01908575f, 0.02924278f, 0.03342828f, -0.00272882f, -0.18338348f, -0.07908885f, 0.08755844f, 
    -0.02586862f, -0.25972676f, 0.14383245f, -0.09253078f, -0.06148969f, 0.00788469f, 0.15104149f, 0.02480062f, 
    -0.02682538f, 0.01842388f, -0.17469124f, -0.00729465f, 0.30206129f, 0.00018713f, -0.10769178f, -0.28897792f, 
    0.07416766f, 0.09291778f, 0.05552673f, -0.00205549f, 0.04212835f, -0.05179035f, 0.02001651f, 0.01183798f, 
    -0.04991284f, -0.37829766f, -0.07445394f, 0.21883403f, -0.17504227f, 0.03653982f, -0.12916020f, 0.03493528f, 
    -0.01694793f, -0.06260284f, -0.03438212f, -0.01599317f, 0.03696024f, -0.01989333f, -0.12210760f, -0.08811918f, 
    0.01022823f, -0.05696844f, -0.00580607f, 0.03837300f, -0.08760588f, -0.01339182f, 0.06551804f, -0.07975993f, 
    0.08814068f, 0.24926634f, -0.17838192f, 0.04758668f, -0.03561310f, -0.13699903f, 0.07934938f, -0.04629588f, 
    -0.05456579f, 0.01300519f, 0.03667374f, -0.05292743f, -0.13761942f, 0.12560177f, 0.13645481f, 0.01026847f, 
    -0.09719962f, -0.12236225f, -0.09308365f, 0.00186782f, 0.00480509f, -0.01169430f, 0.16223858f, -0.02661331f, 
    0.06531164f, -0.26339662f, 0.06507551f, 0.03297262f, -0.06324502f, 0.00252765f, 0.15216869f, -0.06662680f, 
    0.00096699f, 0.02624605f, -0.07203418f, 0.01607245f, 0.31174394f, 0.21720608f, 0.00313151f, 0.35178831f, 
    0.09746013f, -0.03028694f, 0.01560194f, -0.04383888f, 0.11754337f, -0.04965731f, -0.01746537f, 0.04300308f, 
    0.09561483f, -0.08850221f, 0.01824806f, -0.15793030f, 0.07437019f, 0.02643586f, 0.02627093f, 0.04217969f, 
    -0.17142572f, -0.10077848f, 0.04450933f, -0.02908896f, -0.00393386f, 0.24428920f, 0.03862749f, -0.06668045f, 
    -0.02945798f, 0.19395679f, -0.04746263f, 0.08025450f, 0.08745556f, -0.03916434f, 0.02716860f, -0.06011074f, 
    -0.14682536f, 0.03492390f, 0.00828523f, -0.20677912f, 0.07576486f, 0.02405002f, 0.14557862f, -0.01465973f, 
    0.04582895f, -0.07649877f, 0.04833126f, 0.01376343f, -0.27446699f, -0.01507142f, 0.03855627f, -0.10893708f, 
    -0.06691837f, 0.18890536f, -0.05371562f, -0.02530410f, -0.02986724f, 0.00692124f, 0.00311412f, -0.00232554f, 
    -0.08452824f, -0.12688045f, -0.11164566f, 0.01427583f, -0.13553116f, 0.07763027f, -0.01231831f, -0.04496815f, 
    -0.06284492f, -0.05604299f, 0.02385424f, -0.05971322f, -0.08514165f, 0.03949197f, 0.09320249f, 0.06981508f, 
    0.11179001f, 0.00720056f, -0.00650851f, 0.01033986f, -0.00813576f, 0.07103996f, 0.00815187f, 0.04135459f, 
    0.31442943f, 0.04532152f, 0.11808560f, 0.12473512f, 0.01394387f, -0.01653953f, 0.05132026f, 0.15093656f, 
    -0.02340223f, 0.01135360f, -0.05315738f, 0.12397774f, -0.09520382f, 0.15183985f, -0.03188466f, 0.15418792f, 
    0.05942993f, -0.06184432f, 0.06824850f, 0.10143366f, 0.10284498f, 0.04943120f, 0.01293235f, -0.06256035f, 
    0.05684328f, 0.00007800f, -0.11092942f, -0.28496054f, 0.01249114f, -0.11424455f, 0.00543958f, 0.13549522f, 
    0.03443392f, -0.02531833f, -0.03389442f, 0.09884769f, -0.21607527f, -0.07069340f, -0.01789269f, -0.13380143f, 
    0.07057340f, 0.05804757f, 0.00844325f, -0.08019622f, 0.00003639f, 0.08962811f, -0.00657400f, 0.16348983f, 
    0.09751615f, -0.16221802f, -0.18343996f, -0.34961489f, 0.10679913f, 0.08116729f, -0.10564545f, -0.02127410f, 
    0.02143084f, -0.03590270f, 0.08716224f, 0.01613835f, 0.03405843f, 0.10324104f, -0.06606059f, 0.13268512f, 
    -0.09029349f, 0.00848251f, 0.09541412f, -0.12211739f, -0.03510346f, -0.02353654f, 0.03587556f, -0.09512136f, 
    0.15376426f, 0.17966686f, -0.00028326f, 0.21746722f, 0.03400370f, 0.08147599f, 0.02649437f, -0.05367916f, 
    -0.04010494f, 0.07184573f, 0.01370708f, -0.07236455f, 0.17205107f, 0.12505284f, -0.11043353f, 0.10058684f, 
    -0.26408407f, -0.06515228f, 0.10795587f, -0.07179237f, 0.09720951f, 0.09467986f, -0.03064005f, 0.03594157f, 
    0.31899583f, -0.05780620f, 0.03847403f, -0.02006703f, 0.06779526f, 0.07141841f, 0.13679382f, 0.01142564f, 
    0.08809903f, -0.04886100f, 0.04390756f, -0.15649572f, 0.09972835f, 0.25579658f, -0.14510252f, 0.19739224f, 
    0.07394268f, 0.06778862f, -0.08242194f, 0.01686706f, -0.00354348f, -0.06845544f, 0.00692943f, 0.05106163f, 
    -0.09253567f, -0.02574042f, -0.04532656f, -0.07621811f, 0.00205932f, -0.11977366f, -0.06387397f, -0.09417044f, 
    -0.09752305f, 0.05953251f, -0.05485495f, -0.10251892f, 0.07128272f, -0.15160730f, 0.03140237f, -0.04356510f, 
    -0.12642117f, 0.07605147f, -0.00141000f, 0.00823312f, -0.00092870f, 0.02941168f, -0.07638658f, -0.07730132f, 
    -0.03703802f, 0.35226327f, -0.11656809f, -0.12743154f, 0.02781279f, -0.09209581f, 0.12865554f, -0.00333303f, 
    0.09937003f, -0.03055888f, -0.05165971f, -0.05309393f, 0.08705035f, -0.14528091f, 0.02783647f, 0.19287662f, 
    0.01567221f, 0.05948390f, 0.04054302f, -0.03873116f, -0.08219952f, 0.02631222f, 0.06466022f, -0.00193584f, 
    0.28854564f, -0.18119629f, -0.07354833f, -0.13480420f, 0.00618780f, 0.07087868f, 0.01192157f, -0.00620191f, 
    0.00677838f, -0.12439450f, 0.04474565f, -0.04772612f, -0.02789746f, -0.00885039f, -0.07558077f, -0.10062852f, 
    -0.09311158f, 0.04283798f, 0.08736581f, 0.17753431f, -0.01657326f, 0.14167486f, -0.02841114f, 0.00151469f, 
    0.42049575f, -0.00686182f, -0.02826883f, -0.06509368f, -0.06853900f, -0.11577382f, 0.01469398f, -0.05644551f, 
    -0.01787060f, 0.07508965f, 0.07526135f, 0.04817026f, 0.08372197f, -0.04720907f, 0.09827447f, 0.22669216f, 
    -0.02565962f, 0.09355981f, -0.01407316f, 0.08185593f, -0.12880293f, 0.01730355f, 0.10619207f, -0.14818047f, 
    -0.29152033f, 0.24854013f, -0.19952512f, 0.05666455f, 0.05219919f, 0.00265907f, 0.02419857f, 0.00240125f, 
    0.15871915f, 0.05839107f, 0.01129846f, -0.03252414f, 0.19940241f, -0.09698736f, -0.07843584f, -0.00194363f, 
    -0.01606739f, -0.11105505f, -0.01241886f, 0.07902694f, 0.10673901f, -0.02244668f, 0.17820244f, 0.20697263f, 
    -0.30544445f, -0.10060796f, 0.13389723f, -0.11319545f, 0.04514665f, 0.08917654f, 0.08364442f, 0.03520651f, 
    0.12773865f, 0.05337479f, 0.00856454f, 0.05758862f, -0.29652408f, 0.11968134f, -0.03598065f, 0.03146628f, 
    -0.00009311f, 0.02028643f, 0.05263533f, 0.05386926f, 0.04849258f, -0.00055783f, 0.06714500f, 0.07875218f, 
    0.19392194f, 0.03035610f, 0.01892602f, 0.10551919f, -0.00817257f, -0.02064611f, -0.00273594f, 0.03075064f, 
    0.04293726f, 0.00878727f, -0.15651642f, -0.12682632f, -0.46317825f, 0.04736841f, -0.09496691f, -0.00532818f, 
    0.04414349f, -0.12215596f, -0.07738697f, -0.11331688f, -0.14380419f, -0.08276384f, 0.00755512f, 0.06324299f, 
    -0.08950744f, 0.17518638f, -0.07650027f, 0.17792314f, 0.02011663f, 0.00988411f, 0.08198746f, 0.05410944f, 
    -0.01029890f, 0.07812987f, 0.05547358f, 0.06792276f, 0.12118669f, 0.17025238f, 0.04821912f, -0.05610751f, 
    0.08260331f, -0.03588144f, -0.14361228f, 0.02192483f, -0.04124934f, 0.00576018f, 0.01160960f, 0.01681313f, 
    0.21056922f, -0.04723918f, -0.13241288f, -0.15961426f, -0.06885122f, 0.04141956f, -0.03854032f, 0.06162513f, 
    -0.03782580f, -0.06931939f, 0.03207395f, 0.04687783f, 0.34646693f, 0.00925295f, 0.04948764f, -0.11916959f, 
    0.06495132f, -0.11928806f, -0.03281393f, 0.14621533f, -0.04733565f, 0.03353705f, 0.06563197f, 0.02610988f, 
    0.16428086f, 0.02406867f, 0.10190331f, -0.01612208f, 0.13915721f, 0.23790225f, 0.05081242f, -0.10035180f, 
    0.08569041f, 0.16260955f, 0.01755064f, -0.06977480f, 0.18070716f, 0.10049894f, -0.22695443f, 0.00264184f, 
    0.06437064f, 0.00772468f, -0.04012316f, 0.08462314f, -0.04607655f, -0.05409632f, -0.03712261f, -0.00506739f, 
    -0.21375145f, 0.00654804f, 0.05662407f, -0.25112826f, 0.06008668f, 0.04057812f, 0.04383551f, 0.06280034f, 
    0.02969768f, 0.05207917f, 0.08132562f, 0.07802240f, -0.08473611f, -0.16982073f, -0.02838435f, 0.05893806f, 
    -0.07213950f, 0.01200391f, 0.10021085f, 0.12331551f, -0.16798010f, 0.01804299f, 0.05595770f, 0.08054166f, 
    -0.17537247f, -0.06249638f, -0.10594741f, 0.21902427f, 0.06420443f, 0.20167409f, 0.05346036f, 0.13391891f, 
    0.11281804f, -0.02157027f, 0.13512328f, 0.14369529f, -0.12908034f, -0.18575655f, 0.01790970f, -0.13469753f, 
    -0.10251722f, 0.00904666f, 0.06036911f, -0.01265798f, -0.06777263f, -0.00852162f, -0.05165822f, -0.07279255f, 
    0.02638068f, -0.04889327f, -0.07567614f, 0.04340141f, 0.03773306f, 0.05014946f, -0.06129272f, -0.03193052f, 
    0.01504359f, 0.02272529f, 0.05658808f, -0.00810407f, -0.07048665f, 0.04614374f, 0.03508439f, -0.03739810f, 
    0.02214612f, -0.00302274f, -0.01814105f, -0.06268648f, 0.02528302f, 0.03647567f, 0.01246620f, -0.04407258f, 
    -0.03105804f, -0.02874901f, 0.05327248f, 0.03502455f, -0.06095180f, -0.03615315f, 0.03524068f, 0.02016316f, 
    0.00086843f, -0.02085675f, 0.02723451f, -0.04921502f, -0.05181660f, 0.03725109f, 0.02821027f, -0.02871621f, 
    -0.06880159f, 0.02528088f, 0.03201401f, -0.02570344f, 0.03247341f, 0.04849142f, 0.00989493f, 0.00742298f, 
    -0.04105396f, 0.00617057f, -0.07065612f, 0.00229642f, -0.01610876f, -0.03870015f, 0.04561674f, 0.04218669f, 
    -0.07056436f, 0.00533920f, -0.05775408f, -0.05446498f, 0.02094088f, -0.07860760f, 0.03960976f, 0.00924144f, 
    -0.03060910f, 0.01665659f, -0.07122684f, -0.07015338f, -0.03655593f, -0.07652241f, -0.01922273f, -0.02156866f, 
    -0.01272000f, 0.05405704f, -0.02997572f, -0.08311258f, -0.03840237f, 0.01039113f, -0.05473382f, 0.05312078f, 
    -0.02260331f, 0.04990875f, -0.00366675f, -0.03752257f, 0.05745053f, -0.06910437f, -0.04882385f, 0.05343320f, 
    -0.05827027f, -0.05413714f, -0.02010245f, 0.04760782f, 0.04748082f, -0.04660318f, -0.01089731f, -0.05722910f, 
    -0.00348839f, -0.05959952f, -0.05891300f, 0.01250512f, 0.05816176f, -0.06135545f, -0.06105979f, 0.05401024f, 
    -0.00637150f, 0.05481780f, -0.03215354f, 0.02815658f, -0.03883164f, -0.03478864f, -0.01757984f, 0.01570934f, 
    -0.04673699f, -0.02345489f, -0.00860295f, 0.03613259f, -0.06713472f, 0.05155669f, 0.03452954f, -0.00779266f, 
    -0.01677868f, -0.06114121f, -0.00467723f, 0.05212918f, 0.03757194f, -0.05061860f, -0.05161240f, -0.02859786f, 
    -0.05688266f, 0.01633972f, 0.00811691f, -0.01499768f, -0.03975614f, 0.05320873f, -0.02886033f, -0.06424501f, 
    -0.07091742f, -0.03159192f, -0.08041485f, 0.05066012f, -0.05053346f, -0.04421120f, 0.02304726f, -0.03317528f, 
    0.02957561f, -0.00005990f, 0.04218774f, 0.00846059f, 0.02090337f, -0.05218195f, 0.00373045f, 0.01332522f, 
    -0.07757245f, 0.02779425f, -0.05567683f, -0.06141213f, -0.05385555f, -0.07666598f, 0.00324272f, 0.01324053f, 
    0.04620658f, -0.06682837f, -0.08401950f, -0.00577821f, -0.02036743f, -0.00290241f, -0.04363016f, 0.04143498f, 
    0.06055050f, 0.03031728f, -0.02203285f, -0.05731832f, -0.06469227f, 0.00225829f, -0.06418025f, -0.02068492f, 
    -0.05287540f, 0.02876095f, 0.02300007f, -0.06767728f, 0.05633281f, -0.00057757f, -0.05690848f, -0.01711426f, 
    0.05543293f, -0.00524094f, 0.00183253f, 0.05572873f, -0.05020306f, 0.00819847f, -0.02101391f, 0.05031814f, 
    0.06501139f, 0.00567931f, -0.02498740f, 0.05180218f, -0.06340764f, 0.02489035f, -0.01081241f, -0.03863246f, 
    -0.03673045f, -0.04715754f, -0.01060447f, 0.04891427f, -0.01695119f, -0.03592700f, 0.04319382f, 0.03749643f, 
    -0.01917083f, -0.03145352f, -0.03447523f, 0.03194707f, -0.03981702f, -0.03069620f, -0.05252620f, -0.03656183f, 
    0.00117308f, -0.07049904f, 0.03474905f, 0.05831099f, 0.03696420f, 0.01531663f, 0.01527751f, -0.06528103f, 
    -0.05559562f, -0.03638435f, -0.07332366f, -0.03884531f, 0.00427401f, -0.05898285f, 0.04574144f, 0.02466906f, 
    -0.04637817f, -0.04502451f, -0.01375514f, 0.05734924f, 0.00680541f, 0.00893108f, -0.05110946f, -0.05549225f, 
    -0.01313864f, -0.02582323f, -0.00225687f, 0.05811651f, 0.05411007f, -0.03193112f, -0.01241393f, 0.01951022f, 
    -0.02086284f, 0.05890295f, -0.06456627f, -0.06096679f, 0.05009270f, -0.04278665f, -0.01524003f, -0.07116374f, 
    0.04332045f, -0.01851982f, 0.02979228f, 0.04102501f, -0.03979764f, 0.01196070f, -0.04184479f, -0.06643362f, 
    0.06040094f, 0.04895728f, -0.06372195f, -0.05422580f, 0.03561311f, -0.06667738f, -0.07154474f, -0.01489589f, 
    -0.05099105f, -0.05515197f, -0.04813537f, -0.01647122f, -0.03050466f, 0.05508325f, 0.04430943f, -0.05937060f, 
    -0.02355479f, -0.05949203f, -0.07910327f, -0.05382559f, 0.01499142f, -0.03070278f, 0.05769702f, 0.04850133f, 
    -0.05599548f, 0.00772112f, -0.02720037f, -0.06628703f, 0.04062019f, -0.03573026f, 0.01855108f, 0.00059897f, 
    -0.06976987f, 0.02595204f, -0.06908199f, -0.04546880f, 0.01149874f, 0.06084130f, -0.01751143f, 0.04958129f, 
    -0.04790955f, 0.00683022f, 0.04685209f, -0.07465535f, 0.00259421f, -0.07104106f, 0.06186558f, 0.01494307f, 
    0.02616596f, -0.02157480f, -0.04927656f, -0.07171661f, 0.04088122f, -0.00758458f, 0.04683314f, -0.05311437f, 
    0.05915193f, -0.02523754f, -0.04648295f, 0.01242137f, -0.05709385f, 0.03960459f, -0.07385743f, 0.05495577f, 
    0.02037490f, -0.07158571f, 0.05170566f, -0.01478186f, -0.06104878f, 0.00800403f, -0.06480903f, -0.04282460f, 
    0.03438419f, -0.07813960f, -0.03208730f, -0.02843857f, 0.05125171f, -0.04678024f, 0.03610991f, 0.00075669f, 
    -0.05343410f, -0.00252272f, 0.06182883f, -0.00708461f, 0.04834541f, 0.03195827f, 0.01345968f, -0.01730714f, 
    -0.03843581f, 0.03747548f, -0.06272156f, -0.07763742f, 0.02028180f, 0.05480779f, 0.03016030f, 0.03765887f, 
    0.04618540f, -0.06701791f, 0.02958578f, 0.04429728f, 0.04484872f, -0.02363705f, -0.04059938f, -0.06563215f, 
    0.05199877f, -0.03317011f, -0.02524080f, -0.03233260f, 0.03254527f, -0.00879019f, -0.07376345f, 0.05057670f, 
    0.04997342f, 0.00558809f, -0.06503547f, -0.03715088f, -0.07669280f, -0.03771515f, -0.05910653f, -0.03394252f, 
    0.05263291f, 0.20427577f, 0.06815062f, 0.20150109f, -0.01187161f, -0.09097299f, 0.04451096f, 0.00954746f, 
    0.06294482f, 0.19125058f, -0.04452321f, -0.02538617f, 0.50540572f, 0.23613161f, 0.07334005f, -0.22103339f, 
    0.08778025f, 0.00334318f, 0.05881407f, 0.04433282f, 0.08186188f, 0.00139643f, 0.00926570f, -0.04969279f, 
    0.06648087f, -0.29730183f, -0.25774673f, 0.13127767f, -0.11692768f, 0.07697950f, -0.08867738f, 0.05245112f, 
    -0.00988957f, -0.06144412f, -0.10339988f, -0.09789544f, 0.15004937f, 0.06678705f, -0.12319553f, 0.10699889f, 
    -0.11611005f, 0.02850112f, 0.05118433f, 0.03782348f, -0.05453939f, 0.13337411f, 0.00823239f, 0.05562570f, 
    -0.19056274f, 0.02679482f, 0.08904964f, -0.00038163f, -0.00866966f, -0.06271990f, 0.06433997f, 0.01815788f, 
    -0.11571788f, 0.00924819f, -0.07282652f, -0.03582683f, -0.19964333f, 0.20588380f, 0.39185816f, 0.09922225f, 
    -0.02170661f, 0.06993587f, 0.03058303f, 0.05781168f, 0.03740198f, 0.10435513f, 0.01623549f, 0.09622609f, 
    0.01963380f, 0.15800513f, 0.03462347f, 0.00496325f, -0.12012944f, -0.08591724f, 0.04112295f, -0.03518572f, 
    -0.05127771f, -0.02758365f, 0.05106921f, 0.08045825f, 0.31310481f, -0.21754809f, -0.01004636f, 0.52352601f, 
    -0.09021993f, 0.00205306f, -0.14363147f, -0.07683443f, 0.08299943f, -0.11640303f, 0.03763192f, -0.09087025f, 
    0.30037060f, 0.11971174f, 0.07484187f, 0.03331937f, 0.11642603f, -0.09388243f, 0.01399847f, 0.01443002f, 
    0.00788709f, -0.00910816f, 0.04416770f, 0.04507042f, -0.34918475f, 0.11634788f, 0.05656764f, -0.12085912f, 
    -0.05597641f, -0.10711839f, 0.07809945f, -0.03048658f, -0.04202352f, -0.01182193f, -0.13468646f, -0.03623051f, 
    0.26671147f, 0.00225051f, -0.10466758f, -0.24697921f, -0.12475729f, 0.03401850f, -0.07907014f, -0.03926003f, 
    0.02804164f, 0.04081365f, 0.07543565f, -0.03091889f, -0.08638298f, 0.14269271f, 0.06404898f, 0.14476258f, 
    -0.01649111f, -0.04750928f, -0.09128522f, 0.05123447f, -0.03514443f, -0.05577409f, -0.02460597f, 0.02121302f, 
    -0.55866593f, 0.15051438f, 0.04658556f, -0.10397474f, 0.13429049f, -0.01069916f, -0.05054751f, -0.03604762f, 
    -0.11739022f, 0.13298595f, -0.01384507f, 0.10489345f, -0.27264977f, 0.03769888f, 0.13680951f, 0.01515613f, 
    0.13991889f, -0.06730571f, 0.11063799f, 0.13771093f, 0.00689155f, -0.01852478f, 0.02430370f, -0.01714944f, 
    0.12646921f, -0.00227239f, 0.04599164f, -0.01778795f, -0.07127447f, 0.03929348f, -0.09382105f, 0.01243114f, 
    -0.10906032f, -0.04347361f, 0.13718697f, -0.06606278f, -0.12822193f, 0.13619992f, 0.09002457f, 0.19499293f, 
    0.07064834f, -0.06569818f, 0.09052214f, 0.02914473f, 0.02025101f, 0.03762248f, 0.11222180f, -0.00249574f, 
    0.13413781f, 0.06663638f, -0.04910783f, 0.00995821f, 0.02281740f, 0.03431321f, 0.05628608f, -0.03574935f, 
    0.01458324f, 0.00300302f, 0.01900017f, 0.01273621f, 0.32498679f, 0.07301177f, 0.23423535f, 0.02499379f, 
    0.02978782f, -0.10214278f, -0.02072003f, -0.08469186f, 0.03868297f, 0.07975969f, 0.01579162f, 0.19859487f, 
    0.31723991f, 0.01647943f, -0.01649220f, 0.05854948f, 0.15246159f, 0.07946358f, 0.06958191f, 0.08213286f, 
    0.18373245f, -0.03660726f, -0.01210443f, -0.14395584f, -0.03607854f, 0.08927488f, -0.25644752f, 0.13941580f, 
    -0.12134672f, 0.03486266f, 0.18571077f, -0.13808365f, 0.03075443f, 0.06968053f, 0.12656093f, -0.01361759f, 
    -0.21534632f, -0.04593150f, -0.06729152f, 0.17046246f, 0.10505906f, 0.09261955f, 0.01060389f, 0.06610066f, 
    0.09153662f, 0.02280519f, 0.05266139f, 0.04993251f, 0.02664880f, -0.02571853f, 0.30844125f, -0.08093726f, 
    -0.00896345f, 0.06540757f, 0.06300762f, -0.01076387f, 0.02149766f, 0.01039310f, 0.10982178f, 0.04820085f, 
    -0.17346901f, 0.02773115f, -0.21815571f, 0.08220628f, 0.02412832f, 0.08526937f, 0.08193839f, -0.07148652f, 
    0.12641545f, 0.08991124f, 0.06175193f, 0.03101066f, 0.01228406f, -0.14788596f, 0.06230753f, -0.16447930f, 
    -0.03863697f, 0.08614879f, -0.10436351f, -0.00897326f, -0.04585814f, 0.07853526f, 0.11338881f, -0.10040490f, 
    0.23546913f, 0.12313254f, 0.06423900f, 0.28372756f, 0.00878604f, 0.04515997f, 0.08266131f, -0.01215928f, 
    0.03481769f, -0.04147398f, 0.00110090f, 0.00274061f, -0.34610564f, -0.15425858f, -0.16478047f, 0.05907483f, 
    -0.05084235f, 0.00507694f, 0.08275319f, -0.00999582f, -0.00321786f, 0.04691934f, -0.00918995f, 0.03833269f, 
    -0.46671614f, -0.13088611f, -0.03376850f, 0.06672432f, -0.03215764f, -0.00710221f, -0.12798262f, 0.06667659f, 
    0.01569971f, 0.10710163f, -0.10540888f, -0.07370958f, 0.09291455f, 0.14101368f, 0.13665764f, 0.16086014f, 
    0.01303060f, 0.06502124f, 0.00225713f, 0.02415334f, -0.11527627f, -0.07787880f, -0.12189601f, -0.03738294f, 
    0.21037139f, 0.04213073f, 0.10070602f, 0.00655188f, -0.02973668f, -0.01731658f, 0.01027578f, -0.01433298f, 
    -0.00362911f, 0.00482509f, -0.05053121f, -0.05393775f, 0.18573633f, 0.02311144f, -0.06464066f, 0.02615804f, 
    -0.12311890f, -0.02399077f, 0.07153682f, 0.08534849f, -0.08245663f, 0.02952153f, 0.04144865f, -0.00617112f, 
    -0.19690628f, -0.07462345f, -0.05640045f, -0.16932762f, -0.18292339f, 0.05758855f, 0.12808333f, -0.02365128f, 
    0.06589796f, -0.09205718f, 0.03209976f, -0.01637801f, 0.08622537f, 0.13601519f, -0.03732430f, 0.08320221f, 
    -0.06062398f, 0.06111041f, 0.01031854f, -0.04676079f, 0.06731168f, -0.01860199f, 0.08673420f, 0.05164442f, 
    -0.12258960f, -0.12512049f, 0.11961468f, -0.19163637f, 0.09697343f, -0.05429227f, -0.04028030f, 0.16683610f, 
    -0.03479165f, 0.09699845f, 0.07241132f, 0.04518229f, -0.36935487f, -0.09584986f, 0.13886429f, 0.19606557f, 
    0.02443338f, 0.01303010f, 0.09773050f, -0.04869687f, 0.10193669f, 0.04133250f, -0.07604714f, 0.00845854f, 
    0.08814429f, 0.23882487f, 0.06805539f, -0.25933927f, -0.02200811f, 0.04678708f, -0.02693115f, 0.05426256f, 
    0.09177143f, -0.01669289f, 0.12168336f, -0.00128975f, -0.07085249f, -0.07124630f, -0.15305197f, -0.05123769f, 
    0.12629597f, -0.02532484f, -0.03102287f, -0.13768068f, 0.09570593f, -0.06590566f, -0.00749629f, 0.00293920f, 
    0.14454100f, -0.05612887f, -0.09162408f, 0.13052301f, -0.00158912f, 0.18324867f, 0.04927105f, 0.04529107f, 
    -0.01835457f, -0.08334541f, 0.02056167f, -0.06730732f, 0.01758558f, 0.08051043f, -0.19768041f, 0.00505996f, 
    0.15830189f, 0.09706682f, -0.02547721f, -0.07931856f, 0.02496575f, 0.07668575f, 0.04252051f, -0.08396763f, 
    0.36069512f, -0.26227522f, -0.04706815f, 0.01515062f, 0.09933618f, 0.00434708f, 0.08198914f, 0.10745373f, 
    -0.01288435f, 0.02390036f, 0.04787684f, -0.20962162f, 0.40884259f, 0.40148699f, 0.08195701f, -0.25924692f, 
    0.00860811f, -0.17425367f, 0.03213068f, 0.09698580f, -0.09988007f, 0.08422662f, -0.04647399f, 0.03306888f, 
    -0.22804205f, -0.19739550f, -0.07150546f, 0.22999482f, -0.00278374f, -0.02070706f, 0.07013986f, -0.08747124f, 
    -0.00543129f, 0.00852589f, 0.15975471f, 0.05154303f, 0.20339784f, -0.01780310f, 0.12667385f, 0.02929935f, 
    0.06402277f, 0.09507167f, 0.04093271f, -0.02798776f, -0.04854091f, 0.04872878f, -0.02532035f, 0.05973545f, 
    0.29018113f, 0.46871254f, 0.06337748f, 0.06626079f, -0.05487353f, -0.13572939f, 0.04533252f, -0.06182517f, 
    0.02620248f, -0.16765702f, 0.01362825f, 0.02714281f, -0.09867731f, -0.20748557f, 0.00629546f, 0.17950414f, 
    -0.17104518f, 0.03432892f, -0.02648952f, -0.06184565f, -0.03061529f, -0.03517479f, -0.08065058f, 0.00733578f, 
    0.18414611f, 0.01123397f, -0.18285607f, 0.09358722f, 0.04120794f, 0.05292044f, 0.06786235f, -0.03451456f, 
    0.12281030f, -0.08420487f, 0.10702587f, 0.00468319f, 0.17588069f, -0.06956343f, 0.12369434f, -0.04671467f, 
    0.02514779f, 0.03913165f, -0.01761337f, -0.04805556f, -0.03175071f, 0.11712083f, 0.08489635f, 0.07363027f, 
    0.21519811f, 0.09075031f, 0.07948746f, -0.08179765f, 0.10592780f, -0.11482289f, 0.02558166f, 0.09633170f, 
    -0.02736312f, 0.08536364f, 0.04941716f, -0.07594313f, 0.11807455f, -0.17831184f, -0.09276590f, 0.02564975f, 
    0.04385323f, 0.22334619f, 0.00769460f, 0.06999955f, 0.04930793f, 0.04241690f, -0.11794792f, 0.06267499f, 
    0.04591064f, 0.02027427f, 0.04136353f, 0.01885981f, 0.04391952f, -0.00108115f, -0.08474877f, 0.00979613f, 
    -0.04789887f, 0.00836336f, 0.02488466f, -0.06520208f, -0.03871668f, -0.03756403f, -0.00510572f, 0.02618907f, 
    -0.05207474f, -0.07195517f, 0.02040359f, 0.02280737f, 0.01641192f, -0.04087788f, -0.07180423f, -0.04533966f, 
    -0.07689906f, -0.04413655f, 0.04717178f, 0.02346724f, 0.04618207f, -0.05365814f, -0.05222779f, 0.02295127f, 
    -0.04321356f, -0.05596022f, -0.07014808f, -0.02218250f, -0.05266204f, -0.01262558f, -0.07626551f, -0.03178551f, 
    -0.00739346f, -0.08296614f, 0.04390145f, 0.04543841f, 0.00589594f, -0.03101276f, -0.01056122f, 0.04135912f, 
    -0.01499730f, -0.01143141f, -0.04991065f, 0.01076623f, -0.07966796f, 0.04113205f, 0.04614352f, 0.00663602f, 
    0.02122969f, -0.00775366f, 0.04312767f, -0.08449473f, -0.04845216f, 0.02072557f, 0.05023062f, -0.00315043f, 
    -0.04591728f, -0.06738710f, 0.04915313f, -0.07542694f, -0.03531218f, 0.01032879f, -0.05176806f, 0.01155838f, 
    0.02133030f, 0.05074577f, 0.05519543f, 0.05603502f, -0.04788842f, 0.03853108f, -0.03664579f, -0.05478070f, 
    -0.03145806f, -0.01654668f, -0.02811600f, 0.03029573f, 0.01428596f, -0.02073156f, 0.05482820f, 0.00841700f, 
    -0.06034077f, -0.00174650f, -0.01948693f, -0.07817964f, 0.05593473f, -0.03816702f, 0.02123206f, 0.00905642f, 
    0.01929467f, -0.04612991f, -0.07838417f, 0.03923038f, -0.03728229f, -0.04994158f, -0.06149221f, -0.05254463f, 
    0.00605182f, 0.00212630f, 0.05313724f, 0.04104079f, 0.07393883f, 0.02056721f, -0.07372843f, 0.02934078f, 
    -0.04069442f, -0.07197180f, 0.02761413f, -0.05951026f, 0.03759537f, -0.03178035f, 0.01278912f, -0.05027615f, 
    -0.02730892f, -0.06416836f, -0.06184530f, -0.02144765f, -0.01370418f, -0.00260857f, 0.03849850f, 0.02847519f, 
    -0.03770387f, -0.07357738f, -0.01444299f, -0.06670099f, 0.05062475f, 0.01628615f, 0.00934417f, 0.05728366f, 
    0.05017435f, 0.02299167f, 0.00706507f, 0.04312077f, -0.06859562f, 0.05258784f, 0.03577206f, 0.01205401f, 
    -0.05248233f, 0.02951653f, -0.05346715f, -0.03699509f, 0.02272385f, -0.00468275f, 0.00043560f, 0.03819426f, 
    -0.06353588f, 0.00008963f, 0.01012617f, 0.00608086f, -0.03543490f, -0.02059336f, -0.05140860f, -0.07424174f, 
    0.03405098f, -0.00682054f, -0.02928854f, 0.00844199f, 0.02243891f, 0.01958365f, -0.07626285f, -0.08679525f, 
    -0.06757902f, -0.04158117f, -0.03828277f, -0.00995114f, -0.08335236f, 0.04409408f, -0.00921912f, 0.05344778f, 
    0.01890447f, 0.04776074f, 0.05572988f, -0.00717335f, 0.01081521f, 0.04755457f, -0.08452404f, 0.00055899f, 
    0.03600005f, -0.02890027f, -0.05705859f, -0.02442494f, 0.03580641f, 0.05694618f, -0.00252713f, -0.00039435f, 
    -0.08728036f, 0.19348717f, -0.15968241f, 0.09408576f, 0.06194291f, 0.17707478f, 0.07721908f, 0.02264989f, 
    -0.05923247f, 0.03966708f, -0.02407235f, -0.03133091f, -0.05164902f, -0.01075726f, -0.09655470f, 0.04310555f, 
    0.08368380f, -0.08608434f, 0.04159766f, 0.07701653f, 0.00214967f, 0.13505153f, 0.13963412f, -0.00057432f, 
    -0.15596713f, 0.08695497f, 0.04888601f, -0.09747832f, -0.13096398f, 0.05457351f, 0.03794323f, -0.08748803f, 
    0.04448516f, 0.11461803f, -0.02794362f, -0.03595970f, -0.10307997f, 0.12526108f, 0.11837040f, 0.11943202f, 
    0.06450215f, 0.07615518f, -0.07180366f, 0.07883019f, 0.08077502f, 0.09882107f, 0.11817124f, -0.10969949f, 
    0.16521312f, -0.16157702f, -0.05500149f, 0.08232845f, -0.05343991f, 0.02676342f, -0.10558013f, 0.01100703f, 
    0.02857250f, 0.02069568f, -0.00038987f, -0.06198733f, 0.12642965f, -0.04001039f, 0.26231435f, 0.12086464f, 
    0.02744565f, 0.09714351f, -0.03189337f, -0.17075382f, -0.06811186f, -0.06696054f, 0.13736600f, -0.07713477f, 
    -0.32448456f, -0.11428978f, -0.03880404f, 0.14524913f, 0.10786790f, -0.11650274f, 0.07160383f, -0.00569533f, 
    -0.06163628f, 0.04304066f, -0.08867398f, -0.14535147f, -0.04257573f, 0.17966205f, -0.05744977f, -0.29529157f, 
    0.15617855f, -0.13859022f, -0.00781769f, 0.11722650f, -0.03730835f, 0.06713682f, -0.02812517f, -0.05182515f, 
    0.07261972f, -0.15826169f, -0.03364784f, 0.14776227f, -0.10973360f, 0.06518348f, -0.04771846f, -0.08865277f, 
    0.01534542f, -0.02601343f, 0.08158071f, 0.08083253f, 0.29805437f, -0.04218163f, -0.05995643f, -0.34669077f, 
    0.06556617f, -0.12491465f, 0.05701626f, 0.17116556f, -0.10187402f, -0.05812990f, 0.03869508f, -0.00294668f, 
    0.17007871f, -0.23517843f, 0.23317242f, 0.08572853f, 0.09754180f, 0.07157563f, 0.05063029f, -0.08939142f, 
    0.00719551f, 0.05609713f, 0.05327757f, -0.01552593f, 0.04085435f, 0.04680854f, -0.24450552f, -0.13364322f, 
    -0.00709586f, 0.00090972f, -0.00451980f, -0.06244075f, 0.01985475f, 0.06047456f, 0.04367521f, -0.03863711f, 
    0.05999181f, 0.02662105f, -0.09178238f, 0.00009898f, -0.05907430f, 0.05111850f, 0.06001859f, 0.01638983f, 
    0.01577532f, 0.04717454f, 0.03526194f, 0.01521968f, -0.06468493f, -0.22771271f, 0.09127156f, 0.11743721f, 
    0.03257049f, -0.00662997f, 0.04846950f, 0.12076478f, -0.03495988f, 0.01002708f, 0.07394361f, 0.12135101f, 
    -0.37128732f, -0.01782056f, 0.04423998f, 0.18040162f, 0.02602955f, 0.16017075f, -0.00267781f, 0.11842375f, 
    0.15085445f, -0.10125792f, 0.00092958f, 0.08848768f, 0.09528267f, -0.06295825f, 0.00649759f, 0.04963686f, 
    0.01044408f, 0.14013092f, 0.02278099f, -0.02945018f, -0.06352399f, 0.08247995f, -0.10956165f, 0.06739987f, 
    -0.12573725f, -0.11992896f, 0.05464258f, -0.23658389f, 0.02717350f, -0.04006884f, 0.08323005f, 0.16730690f, 
    -0.00835009f, 0.03366368f, 0.02622776f, 0.13207519f, -0.49501437f, -0.10631225f, -0.02574227f, 0.02653167f, 
    0.05054976f, 0.13403593f, -0.01385348f, -0.03230280f, 0.17303973f, 0.12530154f, 0.03238773f, -0.06665017f, 
    -0.05347338f, 0.00694646f, -0.06967417f, -0.19636068f, -0.01887386f, -0.08737905f, -0.12576477f, 0.03577397f, 
    0.03452638f, 0.07424048f, -0.00177437f, 0.10938556f, 0.07016762f, 0.00423180f, -0.05840303f, -0.29535839f, 
    0.02031082f, -0.11891494f, -0.07886396f, -0.01949115f, 0.03680315f, -0.10769772f, 0.09069736f, -0.04488635f, 
    0.09939467f, 0.09342486f, 0.00242389f, 0.09558477f, -0.02640917f, 0.02364192f, -0.07554971f, 0.04911942f, 
    0.07267334f, -0.02144880f, 0.02106253f, 0.04622610f, -0.00113019f, 0.03778723f, -0.10419246f, -0.17243990f, 
    -0.02473358f, 0.00273598f, 0.01897176f, 0.01512465f, 0.13543439f, 0.02991211f, 0.02244968f, -0.09213802f, 
    0.37310714f, -0.16089679f, 0.04144622f, 0.06865544f, 0.13843763f, -0.09587003f, 0.08612651f, 0.05157576f, 
    -0.06031254f, -0.00007377f, 0.09097980f, -0.11644448f, 0.21639921f, 0.39184287f, 0.02172369f, -0.04282855f, 
    0.07241740f, -0.12707624f, -0.02852361f, 0.05724410f, 0.02235664f, 0.02012070f, -0.10601746f, 0.07623390f, 
    -0.30388317f, -0.19064865f, -0.16704498f, 0.01283181f, -0.08556370f, -0.02155321f, -0.04344464f, -0.07604916f, 
    -0.02507952f, 0.06703803f, 0.01685311f, 0.08065382f, 0.31172734f, 0.03271371f, 0.19437024f, 0.04996685f, 
    -0.08870678f, 0.10257865f, -0.06611014f, 0.09803796f, 0.00548147f, 0.03033063f, 0.04273002f, 0.05578167f, 
    0.37245926f, 0.31819952f, 0.11547358f, -0.09297918f, 0.11500832f, -0.11079472f, 0.03415211f, -0.12546149f, 
    0.03146453f, 0.02294222f, -0.00485256f, 0.08879369f, -0.17169499f, -0.10783926f, -0.01669846f, -0.12023325f, 
    -0.10673565f, -0.00765615f, 0.04820645f, -0.04752922f, 0.12354204f, 0.01561012f, 0.08698760f, 0.03999635f, 
    -0.11581227f, -0.05346273f, -0.10900788f, 0.19825085f, -0.02175303f, 0.05037278f, 0.01542651f, -0.06573040f, 
    0.05619559f, -0.05704273f, 0.05073505f, 0.03983643f, 0.17417391f, 0.12518468f, 0.10582232f, 0.14553864f, 
    0.02591730f, 0.04356150f, 0.01975241f, -0.10465866f, 0.04729187f, 0.12658024f, 0.04861086f, 0.01184914f, 
    0.21867348f, -0.07238512f, 0.11706953f, 0.15398051f, 0.06383721f, -0.13071451f, -0.01379224f, 0.11898214f, 
    0.07898918f, 0.01567556f, -0.07777964f, 0.03794451f, 0.29244575f, -0.09126509f, 0.09119665f, 0.07470754f, 
    0.04431086f, 0.07033420f, -0.00605053f, 0.02012302f, -0.02094913f, 0.15581478f, 0.00760988f, -0.06728511f, 
    0.00391978f, -0.04423264f, -0.07788936f, -0.03041204f, 0.02541753f, -0.03415647f, -0.00837381f, -0.04348765f, 
    0.11123850f, -0.03540628f, 0.03468629f, 0.03625458f, 0.33956024f, -0.20486128f, 0.14479932f, -0.02563929f, 
    -0.07485840f, 0.06114230f, -0.02726244f, -0.09828863f, 0.01414670f, -0.07759941f, -0.07703444f, 0.10349593f, 
    0.00493856f, -0.14935902f, 0.21112058f, -0.06645045f, 0.11063673f, 0.07697038f, 0.07188354f, 0.15235235f, 
    0.04776503f, -0.01852662f, 0.02385458f, 0.10792977f, -0.12596817f, 0.06173319f, -0.20311515f, 0.10869685f, 
    -0.12309325f, 0.03579214f, 0.06263144f, -0.08353348f, -0.05977876f, 0.01066335f, 0.01382649f, 0.13966712f, 
    0.05510041f, 0.00342253f, -0.08952876f, 0.05364372f, 0.06055886f, -0.11416249f, 0.11411326f, -0.03973239f, 
    -0.00069318f, 0.03602083f, 0.01020974f, -0.01114209f, -0.47994834f, 0.01554671f, -0.12721084f, 0.04539249f, 
    0.01427801f, -0.01638710f, -0.01620188f, -0.00589166f, 0.03923745f, -0.01257067f, -0.02396325f, 0.17456345f, 
    0.11458156f, 0.00179549f, -0.09209971f, 0.15320425f, 0.06999308f, 0.14275013f, 0.11251602f, -0.08936533f, 
    0.03305554f, -0.06182337f, 0.08528579f, 0.06157118f, -0.04439573f, -0.01180848f, 0.11989395f, -0.00093076f, 
    -0.01216189f, 0.13164823f, -0.07930209f, -0.07293974f, 0.11527326f, 0.02360097f, 0.06082157f, -0.00660534f, 
    0.08599824f, 0.11028958f, -0.11764885f, -0.17275794f, 0.13567461f, 0.06101851f, 0.11319970f, 0.14489366f, 
    -0.01843109f, 0.02442482f, 0.03505169f, 0.12319125f, -0.26361844f, -0.03508530f, 0.04000764f, 0.12565543f, 
    -0.06120723f, 0.02135621f, 0.07724514f, 0.01211913f, 0.10989033f, 0.00159467f, -0.11444420f, 0.06994742f, 
    -0.29771408f, 0.19928218f, -0.07607985f, 0.01916930f, 0.10733895f, 0.07361721f, 0.00646974f, 0.06309893f, 
    0.04235015f, 0.00518638f, -0.06568853f, 0.01554082f, -0.03064962f, 0.23599200f, -0.00166459f, -0.05931256f, 
    0.11036348f, 0.12243284f, -0.03722378f, 0.02468042f, 0.03185457f, -0.12665944f, -0.07904714f, 0.08809406f, 
    0.07821324f, -0.18476513f, -0.01033093f, -0.34956005f, 0.17370267f, 0.08255812f, 0.05139227f, 0.01649866f, 
    0.00103356f, -0.02092675f, 0.03016126f, -0.05110427f, 0.34808967f, -0.08731807f, -0.02018802f, 0.16879737f, 
    -0.08436312f, -0.04768870f, 0.06557045f, 0.14413981f, -0.02044766f, 0.02708630f, -0.06682187f, -0.05316999f, 
    0.10309591f, 0.11527990f, -0.17796332f, 0.09025482f, -0.02110022f, 0.03703618f, -0.01333881f, 0.04019166f, 
    -0.07477143f, -0.01198211f, 0.05632748f, 0.04936561f, -0.06194939f, -0.01394027f, 0.03296554f, 0.06582019f, 
    -0.15724671f, 0.03032308f, -0.09946685f, -0.03485790f, -0.01157734f, -0.11709578f, 0.13041118f, 0.00025295f, 
    -0.03735509f, -0.00477111f, -0.07039263f, 0.05704360f, -0.05712896f, 0.01799041f, 0.03975514f, -0.01867631f, 
    -0.05616502f, -0.01437109f, -0.07627718f, -0.05703149f, 0.00924955f, -0.04540692f, -0.04479143f, -0.04810057f, 
    0.02651250f, -0.01299932f, -0.01453556f, -0.04267313f, 0.06053099f, 0.03279067f, 0.03444869f, 0.03434155f, 
    -0.01252306f, -0.04345744f, -0.06454627f, 0.06019465f, -0.06673728f, -0.06914759f, -0.05825573f, -0.05460516f, 
    -0.06805764f, -0.02636406f, -0.03638090f, -0.01762204f, -0.06770274f, -0.05321041f, 0.06519721f, 0.01219874f, 
    0.03227130f, -0.02403197f, -0.05963653f, -0.00879514f, 0.05527092f, -0.03198222f, 0.04053329f, -0.06165514f, 
    -0.03548200f, -0.01579258f, -0.07356524f, -0.02816067f, -0.07310271f, 0.02017052f, 0.03858760f, -0.03109938f, 
    -0.04755097f, -0.04858316f, -0.00586248f, 0.03484583f, 0.00952595f, -0.02720855f, 0.02360350f, -0.05462684f, 
    -0.00647647f, -0.07195114f, 0.06533588f, 0.05571555f, 0.00568428f, -0.03767605f, -0.06959865f, 0.02470133f, 
    -0.01334011f, 0.00636853f, 0.02131152f, -0.05493491f, 0.02999200f, -0.01782466f, -0.00555113f, 0.00900915f, 
    -0.05209186f, 0.00278506f, 0.00220115f, -0.02743441f, -0.06584661f, 0.04778753f, 0.05870831f, -0.07354404f, 
    0.01576386f, 0.06501129f, -0.05142076f, -0.05903808f, 0.03231141f, 0.00575946f, -0.05270183f, 0.02200289f, 
    0.00610695f, 0.03016928f, -0.02681750f, -0.05656034f, -0.06788082f, 0.00731572f, 0.03653694f, 0.02972455f, 
    0.02784852f, -0.00210090f, -0.05782551f, -0.07581827f, -0.02971271f, -0.00621689f, 0.04846081f, -0.05080584f, 
    -0.01495219f, -0.07756338f, 0.01476354f, 0.00294345f, -0.04284493f, -0.01123195f, -0.05161689f, -0.06350821f, 
    -0.00710905f, -0.00761104f, -0.04995339f, -0.06212087f, -0.03085961f, -0.07685828f, -0.00323521f, 0.03823799f, 
    0.00377360f, -0.07282078f, 0.03436949f, -0.03405241f, -0.02516639f, 0.03522151f, 0.03379939f, -0.06835901f, 
    0.01092090f, 0.04409466f, 0.00189442f, 0.01024252f, -0.05412313f, -0.00809184f, 0.04317499f, -0.06421839f, 
    -0.04795836f, 0.02465253f, 0.05091987f, -0.05434845f, -0.05747932f, 0.03139449f, 0.02109103f, -0.04259279f, 
    -0.03743780f, 0.02411292f, 0.05710060f, -0.00714456f, -0.03321144f, -0.00630224f, 0.05509014f, -0.02573312f, 
    -0.02568158f, -0.00354775f, 0.01677439f, 0.06358881f, 0.04904860f, 0.04928571f, 0.01048520f, -0.00964936f, 
    -0.03599495f, 0.06272555f, -0.01447920f, 0.04905818f, -0.06920349f, 0.04553872f, 0.06340996f, -0.01534579f, 
    -0.07095613f, 0.05585623f, 0.06272302f, -0.01274077f, -0.00538618f, -0.05212935f, -0.06499636f, 0.01149581f, 
    0.00699773f, 0.00289118f, -0.06960512f, -0.05933397f, -0.01277702f, 0.02849808f, -0.05101147f, 0.04410982f, 
    -0.03768020f, 0.02773166f, -0.04107847f, 0.01776975f, 0.04528836f, 0.04109477f, -0.08137574f, -0.06510245f, 
    -0.01486191f, -0.00893853f, -0.04830278f, 0.02090969f, -0.06251267f, -0.01495871f, -0.04228541f, 0.00869978f, 
    0.04109130f, -0.04677428f, -0.04410683f, -0.06555671f, 0.05946505f, -0.02974123f, -0.04623616f, -0.02125892f, 
    -0.05045899f, 0.01139630f, 0.01704467f, 0.06021921f, -0.05305925f, 0.04877988f, 0.05759350f, -0.07129028f, 
    0.03770859f, -0.01686802f, 0.01067778f, -0.01255974f, -0.01453432f, 0.04277501f, -0.01626732f, 0.03003235f, 
    0.00438830f, 0.01326988f, 0.04458407f, 0.04415455f, -0.05830128f, -0.04197241f, 0.02878428f, 0.02461714f, 
    -0.06093906f, 0.02240429f, -0.01265516f, -0.02103078f, 0.06043515f, -0.02085395f, -0.03017225f, 0.00563262f, 
    -0.03280163f, -0.00318644f, -0.06157693f, -0.01814035f, 0.00071502f, -0.01133380f, -0.07654675f, -0.03632823f, 
    -0.05378322f, -0.02214161f, -0.00475398f, -0.06801048f, 0.03846884f, -0.02237560f, -0.03284162f, -0.06939030f, 
    0.01542753f, -0.03520665f, -0.01329253f, 0.02397742f, 0.04479392f, -0.03031921f, 0.04600660f, -0.05513073f, 
    0.02421894f, 0.04040781f, -0.04622516f, -0.05226037f, 0.03324970f, -0.01681273f, 0.00899149f, -0.00893192f, 
    0.06317455f, -0.04910275f, -0.02994767f, -0.05923842f, 0.05225494f, -0.06927145f, 0.05439399f, 0.00092833f, 
    -0.00462068f, -0.00502641f, -0.03563001f, -0.07249522f, -0.00902929f, -0.05008813f, 0.03077681f, 0.02871032f, 
    -0.06280553f, -0.03175081f, 0.02167933f, -0.06724066f, 0.04928288f, 0.02906931f, -0.07092900f, 0.04074412f, 
    -0.06523744f, -0.02130493f, -0.07443456f, -0.06635629f, 0.05416030f, 0.05831683f, -0.00773774f, 0.01474529f, 
    -0.02386608f, -0.02525072f, -0.02022875f, -0.00752844f, -0.01955122f, -0.02395772f, -0.05483329f, 0.04803210f, 
    0.03679698f, 0.00443859f, 0.05423332f, -0.06622780f, 0.01057952f, -0.07191690f, 0.02639873f, 0.05499210f, 
    -0.00563775f, 0.06407451f, -0.03159222f, -0.04477227f, 0.01090506f, -0.04405307f, 0.04063400f, 0.04401049f, 
    -0.04046533f, -0.00805343f, -0.04816907f, -0.01946858f, -0.03910781f, 0.00461125f, 0.01803872f, -0.01922158f, 
    -0.06605853f, 0.03538505f, -0.04310837f, 0.01009089f, -0.03700010f, 0.04052138f, -0.00548125f, -0.03976106f, 
    -0.07225879f, 0.04223066f, -0.03407287f, 0.03291738f, -0.06743808f, 0.04497741f, -0.07679551f, -0.03533148f, 
    -0.05185555f, -0.00572685f, 0.06250129f, 0.03207920f, -0.00991284f, 0.00326077f, 0.01921161f, -0.01202099f, 
    0.05862039f, 0.04190845f, -0.00762026f, -0.05309138f, -0.07928571f, 0.04913702f, -0.08104316f, 0.04306613f, 
    0.04537021f, -0.06739581f, -0.00796876f, -0.04388901f, -0.03532070f, -0.01686562f, 0.00355837f, -0.01387703f, 
    0.21521969f, -0.09674863f, 0.18522489f, -0.14002016f, -0.00475857f, -0.05912443f, -0.08066547f, 0.04133230f, 
    -0.07130136f, 0.08568341f, 0.03840474f, 0.17396814f, -0.24215294f, -0.04752336f, 0.05476913f, 0.06928448f, 
    0.00348513f, 0.09675650f, 0.04055335f, 0.02643185f, -0.02241169f, 0.06460813f, -0.10192469f, -0.14047565f, 
    0.19665471f, -0.03085405f, -0.00904980f, -0.01492458f, 0.09651221f, -0.14406395f, -0.00575014f, -0.03630549f, 
    -0.09354535f, -0.06504735f, -0.04394171f, 0.08222196f, 0.14731443f, -0.27071759f, 0.00010097f, -0.08345417f, 
    0.03206859f, -0.00697280f, -0.09768094f, 0.05199219f, 0.06272174f, -0.17202656f, 0.01918834f, -0.01168616f, 
    -0.11597578f, 0.20975924f, 0.05979364f, -0.11578969f, 0.02877623f, 0.04800576f, 0.03580296f, 0.09527087f, 
    -0.02400199f, 0.12514903f, 0.02106591f, 0.20239508f, 0.37509602f, 0.03210100f, -0.23138288f, 0.02259533f, 
    -0.02088451f, 0.05368856f, 0.00055457f, 0.01684276f, 0.16389079f, 0.03180445f, 0.01068308f, -0.12452897f, 
    0.25992492f, -0.28951439f, -0.08248640f, -0.05549810f, -0.02748226f, -0.01787066f, -0.09222019f, -0.07647157f, 
    0.04208052f, -0.10843828f, 0.08519060f, -0.01624763f, -0.06295719f, 0.12103901f, -0.08438288f, 0.05826973f, 
    0.04790369f, 0.02457818f, 0.05257771f, -0.04523831f, -0.04943635f, 0.07323451f, 0.00639274f, 0.24546322f, 
    -0.26979563f, 0.00930837f, 0.01283149f, 0.07331111f, 0.06778882f, -0.06869698f, 0.03084333f, -0.11305075f, 
    -0.01913655f, 0.20832452f, -0.04167201f, 0.02161712f, -0.06982715f, 0.00675178f, 0.09390307f, 0.17153895f, 
    -0.02505699f, 0.12964928f, -0.04711861f, -0.11415415f, 0.10012928f, 0.07135437f, -0.07227498f, -0.08426955f, 
    -0.13287112f, 0.16447973f, -0.01908684f, 0.08238960f, 0.09442271f, -0.15479982f, 0.06523254f, 0.01870035f, 
    0.02196790f, -0.12326764f, 0.10692390f, 0.09266321f, -0.05723203f, -0.10080896f, 0.05137340f, 0.16911298f, 
    0.00431057f, -0.02542553f, -0.00706628f, 0.03840936f, 0.09349203f, 0.15001857f, 0.05409181f, 0.06627403f, 
    -0.02404305f, 0.09170454f, 0.05189944f, 0.16891448f, -0.05260689f, 0.09010527f, -0.04277223f, -0.04738434f, 
    0.06529054f, -0.14431980f, 0.06557366f, -0.03957980f, -0.14253241f, 0.18384632f, -0.10903567f, -0.03775448f, 
    0.11056592f, 0.07070522f, -0.03806101f, -0.10446423f, 0.03810867f, 0.09674381f, -0.01848187f, -0.14133251f, 
    0.38605869f, 0.04108583f, 0.10844106f, -0.16864617f, 0.11126677f, -0.09457481f, -0.04533226f, -0.08905108f, 
    -0.10584480f, 0.10934111f, -0.20833135f, 0.01116490f, 0.05451268f, 0.02602024f, -0.08451519f, 0.02067052f, 
    0.05320124f, 0.02166841f, 0.11269572f, -0.04765327f, -0.04850481f, -0.10383242f, 0.05476763f, 0.03956014f, 
    -0.12349112f, -0.15113899f, 0.10911419f, 0.12521379f, 0.11817925f, 0.01667850f, 0.14070846f, -0.07949767f, 
    -0.07796089f, -0.11694447f, -0.06998465f, -0.10591633f, 0.01153503f, 0.06387068f, -0.11861897f, -0.10242025f, 
    -0.06164620f, 0.02486180f, 0.13192584f, -0.08457864f, 0.00345921f, 0.00267203f, 0.08037508f, 0.03238067f, 
    -0.17683722f, -0.01317619f, -0.07425329f, 0.24819972f, -0.10785101f, 0.06278911f, -0.05544958f, -0.01595717f, 
    0.09355754f, 0.03652785f, -0.08166438f, -0.05667566f, -0.10624304f, -0.15872528f, 0.25100854f, -0.01482758f, 
    0.13455842f, -0.00481345f, 0.15646367f, 0.15566045f, -0.05230787f, -0.04073246f, 0.03827004f, 0.05609344f, 
    0.05967675f, -0.06177123f, -0.07907187f, 0.01513666f, 0.04233471f, 0.09090240f, -0.04768935f, -0.04388480f, 
    -0.03643602f, -0.06157154f, -0.06833784f, -0.08709569f, -0.13845205f, -0.08312128f, -0.08725930f, 0.04663457f, 
    -0.01464004f, -0.10785211f, 0.04250653f, 0.06641735f, -0.03622853f, -0.10695509f, 0.06097542f, 0.02702886f, 
    -0.05825756f, -0.03282135f, 0.29874420f, -0.03101993f, -0.10229763f, -0.01144917f, -0.02805108f, 0.13046262f, 
    -0.04175954f, 0.03709587f, -0.06335202f, -0.05436993f, 0.19597660f, 0.08315275f, 0.19587031f, 0.07079087f, 
    -0.04253617f, 0.02942584f, -0.01488724f, 0.05000612f, 0.06767555f, -0.02848212f, -0.04826545f, -0.13146307f, 
    -0.06912788f, 0.05453973f, -0.02094711f, -0.17393036f, -0.07503048f, 0.17127052f, 0.11425606f, 0.04540999f, 
    -0.07318033f, -0.14647248f, 0.14102951f, -0.02553244f, 0.25412127f, 0.07888338f, -0.19405611f, 0.01074036f, 
    0.04469271f, 0.04675976f, 0.03981720f, 0.12107846f, 0.03337290f, -0.07189453f, 0.14426750f, 0.08383826f, 
    -0.14971684f, -0.09230916f, 0.11013820f, -0.08051828f, -0.02999069f, -0.03740963f, 0.00611123f, 0.06702200f, 
    -0.03345717f, 0.04280077f, -0.10052507f, -0.02212889f, -0.22088738f, 0.08503348f, 0.03259409f, -0.27119938f, 
    -0.03331145f, 0.04062427f, -0.02183825f, -0.08074742f, -0.03478457f, 0.02449931f, -0.13323474f, -0.03867343f, 
    0.45472401f, -0.17834288f, -0.07825734f, 0.21950002f, -0.07257675f, 0.07047226f, 0.04844981f, -0.00140763f, 
    0.09060438f, 0.08767848f, -0.03105120f, 0.00455586f, 0.39137268f, -0.00219663f, 0.07716559f, 0.07032795f, 
    0.02503343f, 0.01342073f, 0.04225455f, -0.00208933f, 0.04232742f, -0.01764012f, 0.10891560f, 0.09120146f, 
    -0.03756418f, 0.03026995f, 0.06889784f, 0.27194366f, 0.03514178f, 0.09568377f, 0.04965810f, 0.14818209f, 
    0.00836754f, -0.08999901f, 0.07817592f, 0.08243619f, 0.05371800f, -0.00665211f, 0.07285077f, -0.13947944f, 
    -0.05151976f, -0.07961256f, -0.03338246f, 0.07842937f, 0.09665877f, 0.12753908f, -0.15301438f, 0.11402179f, 
    -0.03554036f, -0.00937488f, 0.03734973f, -0.05966905f, 0.02955025f, -0.01573044f, -0.01950391f, 0.03551308f, 
    0.01907167f, 0.05209133f, -0.02437265f, 0.01902319f, 0.00667172f, 0.06550236f, 0.03765053f, 0.05743725f, 
    0.05758172f, -0.06249051f, -0.01063333f, 0.00507430f, 0.06696538f, 0.02613795f, 0.00065231f, 0.01731848f, 
    -0.06544409f, -0.00184281f, -0.04516448f, 0.03462445f, -0.05972941f, 0.00619738f, 0.01962986f, 0.04319153f, 
    0.00497794f, -0.05247654f, -0.04537859f, -0.04358605f, -0.00116858f, 0.01629722f, 0.04223713f, 0.02404681f, 
    -0.04155036f, 0.00515346f, -0.02063599f, 0.05369141f, 0.02619763f, -0.07380205f, -0.03085013f, 0.03265739f, 
    -0.06546130f, -0.03402919f, -0.04067541f, -0.01160553f, 0.06068442f, 0.02427411f, -0.03889300f, -0.03803692f, 
    -0.00297313f, 0.06614848f, -0.03852534f, 0.05117879f, 0.02825649f, -0.04455793f, -0.03960473f, 0.01865769f, 
    -0.05183377f, 0.00838000f, 0.05899492f, 0.02595599f, -0.03670231f, 0.01981027f, 0.01950909f, -0.02248573f, 
    -0.03904946f, -0.08074498f, 0.05038066f, 0.03741479f, -0.02880513f, 0.00753432f, -0.02743702f, 0.06157872f, 
    -0.00701337f, 0.06165919f, -0.07646829f, 0.05385570f, 0.00147438f, 0.00644032f, -0.06601681f, -0.04008290f, 
    -0.04928758f, -0.02323873f, -0.03952022f, -0.04913842f, 0.01425091f, 0.01309764f, 0.04767397f, -0.02428926f, 
    0.00623927f, 0.04662094f, 0.01557200f, -0.04906098f, 0.03796149f, -0.07478365f, -0.06754114f, 0.05887203f, 
    -0.03359997f, -0.06315142f, 0.04819028f, 0.01862466f, -0.06916842f, -0.03558718f, 0.00489480f, -0.01936043f, 
    -0.04337737f, -0.07717312f, 0.04466266f, 0.02321502f, -0.01050049f, -0.00230288f, -0.04630415f, 0.00962624f, 
    -0.05086113f, 0.01087231f, 0.04481780f, -0.01697178f, 0.00125809f, -0.05101522f, -0.07059527f, 0.05426895f, 
    0.05284826f, -0.01678780f, 0.04320164f, -0.00180433f, -0.03887527f, 0.05793568f, 0.04893046f, -0.05561554f, 
    0.01387184f, -0.05585793f, -0.07697244f, -0.07336731f, 0.02168727f, 0.00634103f, -0.04955762f, -0.02857805f, 
    -0.05567127f, -0.05273203f, 0.03134876f, -0.05301276f, 0.05256054f, 0.03423290f, -0.03294130f, -0.08002489f, 
    -0.08270428f, -0.04251052f, -0.02227780f, 0.05831800f, 0.01648933f, 0.01740236f, -0.01511995f, -0.04573109f, 
    -0.03889129f, -0.04250399f, -0.06335074f, 0.03866006f, -0.07284150f, 0.00766129f, -0.01930122f, 0.01902747f, 
    -0.00919904f, 0.05200878f, 0.05623034f, -0.03359022f, 0.02330878f, 0.04971883f, -0.01040490f, -0.07381871f, 
    -0.04159507f, -0.06137226f, 0.02507640f, 0.02189077f, 0.03687647f, -0.00244925f, 0.03720866f, -0.04065592f, 
    -0.05855466f, 0.03072317f, -0.01909265f, 0.03859011f, -0.06488655f, -0.03658501f, 0.00215106f, -0.02537086f, 
    -0.07910452f, -0.05867562f, 0.15277898f, 0.09996607f, 0.11906888f, 0.10643965f, 0.09298395f, 0.05457889f, 
    0.04972842f, 0.02110381f, -0.05250524f, 0.04521823f, 0.07110901f, -0.11001593f, -0.07951559f, 0.01611217f, 
    0.05506573f, -0.01532819f, -0.05472577f, 0.22547992f, 0.08074954f, 0.10018757f, -0.11450096f, -0.24625060f, 
    0.19999498f, -0.28026611f, 0.03229120f, 0.08836864f, 0.14522107f, -0.21144886f, -0.02714053f, -0.04695736f, 
    -0.13576339f, -0.01392509f, 0.01074581f, 0.22364841f, 0.15747750f, -0.00904572f, 0.02297983f, -0.12078353f, 
    -0.13336717f, 0.07535650f, -0.14143582f, 0.11088348f, 0.05708902f, -0.10897855f, -0.12512828f, -0.06895944f, 
    -0.03529439f, 0.15285197f, -0.04124139f, -0.25293797f, 0.02613783f, 0.01815495f, 0.08304894f, 0.00968966f, 
    0.08626137f, 0.08937707f, 0.19194981f, 0.25721079f, 0.13346373f, 0.02964238f, -0.14004938f, -0.00897237f, 
    -0.04608417f, 0.01828818f, 0.02635398f, 0.09062246f, 0.09624442f, -0.00376004f, -0.09250448f, -0.10473612f, 
    0.07840343f, -0.10280865f, 0.03515384f, -0.07441705f, 0.06481081f, 0.00086303f, -0.02126261f, 0.03867897f, 
    0.04333181f, -0.14157031f, 0.10454737f, 0.15614079f, -0.25538582f, -0.17000386f, -0.10256347f, 0.17228323f, 
    0.05789043f, -0.10712994f, 0.03557979f, -0.07106405f, 0.11009763f, 0.05572069f, -0.01196634f, 0.25322917f, 
    -0.22795086f, -0.00731631f, -0.00512472f, -0.04464579f, 0.07141025f, -0.09780730f, -0.03407547f, -0.02426602f, 
    0.12250987f, 0.20047282f, -0.10124795f, -0.03179860f, -0.16306737f, 0.20764630f, 0.11191688f, 0.08161147f, 
    0.02482073f, 0.04628606f, -0.00209858f, -0.05793700f, 0.02011747f, 0.06330128f, 0.02453368f, 0.00240462f, 
    0.12132220f, 0.00189999f, 0.10443528f, -0.06406189f, 0.06424587f, -0.01804661f, 0.10134743f, -0.12152250f, 
    0.04462710f, -0.04918012f, 0.04672930f, 0.20363328f, -0.04450770f, 0.12689009f, -0.05963225f, -0.21501645f, 
    0.08587038f, 0.04635878f, 0.01487901f, 0.12091350f, 0.15130854f, 0.09870901f, 0.24980175f, 0.13229521f, 
    -0.53003865f, 0.19092755f, -0.10353292f, 0.04273210f, 0.03727654f, -0.00288327f, -0.09738074f, 0.01234803f, 
    -0.11479099f, -0.03035534f, 0.00289551f, 0.06949758f, -0.30180746f, 0.16721646f, -0.12655331f, -0.10488636f, 
    0.09294633f, 0.07907942f, -0.09286986f, -0.06502075f, 0.18775952f, -0.04312029f, 0.02168229f, -0.08656548f, 
    0.25211427f, 0.04432673f, 0.04505885f, -0.04693958f, 0.07908557f, -0.15470622f, 0.02802934f, -0.19310363f, 
    0.03347930f, 0.09349515f, -0.14988871f, 0.03327172f, 0.06333872f, 0.13461180f, -0.09335904f, 0.01298192f, 
    0.09369846f, 0.05418837f, 0.11124389f, 0.01310738f, 0.04094335f, -0.04428184f, 0.10382171f, -0.03914725f, 
    0.13995430f, -0.01890058f, -0.08292965f, 0.23279162f, -0.08182720f, -0.00404754f, -0.05111642f, 0.01917642f, 
    0.02548101f, 0.01365508f, 0.01967901f, -0.07686311f, 0.42428264f, 0.00136601f, 0.27211672f, 0.05234950f, 
    -0.08210035f, -0.07166194f, 0.08520339f, -0.03518457f, 0.03534095f, -0.00824749f, -0.10132376f, 0.12162507f, 
    0.07148509f, -0.06917341f, 0.10731652f, -0.05516027f, 0.13991632f, 0.10919497f, 0.05709080f, 0.00068519f, 
    0.06681640f, 0.03515029f, 0.05464466f, -0.07848819f, -0.12265386f, 0.02676297f, -0.19017781f, 0.20040581f, 
    -0.08166932f, 0.13199258f, 0.13859051f, -0.20599799f, 0.01125483f, 0.08891944f, 0.01393422f, 0.07620313f, 
    -0.09742500f, 0.02629169f, -0.05335496f, 0.02534821f, 0.11626532f, -0.05867755f, 0.10804649f, 0.06424047f, 
    -0.01441388f, 0.11258329f, 0.08088225f, 0.01039880f, -0.10870035f, -0.05934171f, 0.21835631f, 0.02146630f, 
    0.01768312f, 0.00152761f, -0.04273198f, 0.06278143f, 0.05401485f, 0.01204695f, -0.03528384f, 0.04228060f, 
    -0.23034994f, -0.00273738f, -0.23009528f, 0.11784036f, 0.03501023f, 0.03872974f, 0.00368811f, -0.00613198f, 
    0.07098319f, -0.00656599f, 0.09156242f, 0.01408277f, 0.05850565f, 0.02575565f, 0.10043774f, -0.27852356f, 
    -0.16579151f, 0.08688468f, 0.08518720f, -0.03440124f, -0.04898993f, 0.11791999f, 0.14691326f, -0.01433850f, 
    0.09875150f, 0.05854751f, 0.05202170f, 0.22473034f, 0.01610330f, -0.07628512f, 0.10532190f, 0.15880074f, 
    -0.13673624f, -0.02041377f, 0.08025707f, -0.08092853f, -0.40201524f, 0.01816439f, -0.11181551f, -0.12180018f, 
    -0.03265127f, 0.03460987f, 0.09242604f, -0.04056720f, 0.06288169f, 0.01708262f, -0.07928914f, -0.07389987f, 
    -0.48023731f, -0.18307802f, 0.14698486f, 0.16698751f, -0.15601556f, 0.08743137f, -0.00569832f, 0.03509451f, 
    0.03165733f, 0.03700333f, 0.02043689f, -0.03930842f, -0.12589602f, 0.05898581f, 0.02895509f, 0.26684889f, 
    -0.02601874f, 0.10367484f, -0.06610311f, 0.09255816f, -0.06913476f, -0.05918368f, -0.03131359f, 0.11191821f, 
    -0.04865154f, 0.15736730f, -0.00004469f, -0.27840003f, 0.05292204f, 0.08409699f, 0.08482998f, 0.10102282f, 
    -0.06624652f, 0.01268221f, 0.03305093f, -0.06389406f, -0.04474140f, -0.02901809f, 0.11217552f, 0.05671748f, 
    -0.09141617f, -0.01758622f, 0.09497336f, 0.09517229f, -0.04580494f, -0.10425296f, 0.00309956f, 0.02575165f, 
    -0.18590806f, 0.11023338f, 0.00377573f, -0.08895490f, -0.04926419f, 0.11105799f, 0.08800662f, 0.01435967f, 
    -0.00387037f, -0.07515162f, 0.08534791f, 0.05654587f, -0.33846295f, -0.02991076f, -0.05661230f, 0.14636704f, 
    0.03491648f, 0.04304560f, 0.01921923f, -0.08581869f, 0.00077423f, -0.02700723f, 0.09310654f, 0.02633936f, 
    -0.07547048f, 0.05815027f, -0.02840921f, 0.04160079f, 0.03176500f, -0.03444703f, -0.02774167f, 0.05052239f, 
    -0.01358514f, -0.07658689f, -0.03340477f, 0.04814735f, -0.02320332f, 0.03558337f, 0.04832822f, -0.00075396f, 
    0.03420150f, -0.02315861f, -0.02932305f, 0.06264727f, -0.06095900f, 0.01962496f, -0.05678527f, 0.04951914f, 
    -0.01315309f, -0.07157829f, -0.04314492f, -0.02353319f, 0.03657341f, -0.02220775f, 0.00046773f, -0.06328449f, 
    -0.03214218f, -0.08122354f, 0.06517822f, 0.00414255f, -0.04119275f, -0.06826751f, 0.03611263f, -0.01995906f, 
    -0.01515599f, -0.03105715f, 0.03781774f, 0.04606494f, 0.06031348f, -0.00858509f, 0.04803341f, 0.01973299f, 
    0.00023022f, 0.05703031f, 0.05633249f, -0.06350810f, -0.04675516f, -0.06295976f, 0.01862133f, 0.05398120f, 
    0.03323808f, -0.05459809f, 0.00909954f, 0.03884546f, 0.04180349f, 0.00563274f, 0.00569598f, 0.01653076f, 
    0.03656612f, 0.02448133f, 0.02027712f, 0.00799138f, -0.01705321f, 0.02161894f, -0.01487611f, -0.00477475f, 
    0.03369981f, -0.01861190f, 0.04546577f, 0.05689608f, -0.03612585f, 0.05744998f, 0.05238993f, -0.04419703f, 
    0.02492844f, -0.01139334f, -0.05376416f, -0.06806906f, -0.02164435f, 0.04868633f, 0.04559574f, -0.05212769f, 
    0.05625407f, -0.02250955f, 0.06509281f, 0.04378968f, -0.06226918f, -0.00318565f, -0.02830538f, -0.04114921f, 
    0.05380266f, -0.05114382f, -0.04895316f, -0.01607918f, -0.05369227f, -0.02146699f, -0.01432042f, -0.05353107f, 
    -0.05408781f, 0.00336781f, -0.00994396f, -0.02871446f, -0.06170115f, 0.05389313f, -0.02642173f, -0.02287998f, 
    0.02472772f, 0.05647494f, -0.03085518f, 0.00868850f, -0.02429673f, 0.00102594f, 0.05662793f, -0.07146368f, 
    -0.00090108f, 0.04853530f, -0.05894649f, -0.05432171f, -0.03783776f, -0.00408901f, 0.02641993f, 0.06156940f, 
    0.05413400f, -0.06560621f, -0.02005028f, -0.04004161f, -0.02792033f, 0.05784404f, -0.01338213f, 0.03031766f, 
    -0.04775321f, -0.00863757f, -0.02164156f, -0.04002261f, -0.05095870f, -0.00076737f, -0.03046653f, -0.08312085f, 
    0.03598679f, -0.00625842f, 0.00160953f, 0.00310698f, 0.01845356f, 0.05707931f, 0.02234034f, -0.00138331f, 
    -0.06471307f, -0.06773245f, 0.00895845f, 0.01503394f, -0.07733881f, -0.06640083f, 0.02717021f, -0.07538483f, 
    0.01191537f, -0.03095699f, -0.07064472f, -0.00871607f, 0.05453380f, -0.07474127f, 0.03853712f, -0.00635848f, 
    0.02607292f, 0.03320483f, -0.00479843f, -0.04277429f, -0.05203103f, -0.02241291f, 0.04367604f, -0.05187086f, 
    -0.04609901f, -0.01202178f, -0.00121384f, -0.02878090f, -0.00887057f, 0.04215569f, 0.04413622f, -0.04747468f, 
    -0.06865097f, -0.01857621f, -0.04469175f, -0.02627956f, -0.04182632f, -0.07155092f, -0.05407142f, -0.02065131f, 
    0.14299102f, 0.00308760f, -0.11757254f, 0.07342678f, 0.08891701f, 0.10204817f, 0.10355748f, 0.03392440f, 
    0.08821546f, 0.08539063f, -0.07689334f, -0.00055397f, 0.39807999f, 0.16425999f, -0.27355352f, -0.02157895f, 
    0.02927697f, 0.02288043f, 0.06459232f, 0.20263427f, -0.02166724f, 0.01041085f, 0.01770638f, 0.00899146f, 
    0.01802662f, -0.26624423f, -0.13806576f, 0.15327613f, -0.12570310f, 0.11994030f, 0.01691539f, -0.01642019f, 
    0.00101268f, -0.02739039f, -0.01133167f, 0.13794494f, 0.00308081f, -0.18970238f, 0.25662252f, 0.09006075f, 
    -0.06298635f, 0.00794669f, 0.07654059f, 0.07049585f, -0.00420850f, 0.11520155f, 0.00483173f, 0.08236261f, 
    -0.08550226f, 0.14689983f, -0.12867790f, 0.02086900f, -0.11669607f, -0.07003496f, 0.04413817f, 0.08671992f, 
    -0.10535309f, 0.04185983f, 0.05427106f, 0.08350586f, 0.17646302f, 0.03401417f, 0.01085517f, 0.16909933f, 
    -0.14005277f, -0.11956622f, 0.09568945f, 0.13399889f, -0.02088086f, 0.04398341f, 0.02445325f, -0.07604773f, 
    -0.02907824f, -0.08001734f, 0.22080684f, -0.04018125f, -0.03427234f, -0.18616669f, 0.13422801f, 0.01950154f, 
    -0.02231924f, 0.03059023f, -0.03562707f, 0.16182606f, -0.18371606f, -0.30218697f, -0.22129945f, 0.40637121f, 
    0.10945743f, 0.02158627f, 0.00035053f, -0.11566897f, 0.12992568f, -0.06115873f, 0.07008170f, -0.02565390f, 
    0.10679831f, -0.02825999f, 0.06493948f, -0.19047944f, -0.00510060f, 0.08957738f, -0.05195976f, 0.01820797f, 
    0.06318820f, 0.05002077f, 0.06178237f, -0.03068842f, -0.03089803f, 0.09260254f, -0.04447496f, -0.03976850f, 
    0.09298342f, 0.03837422f, -0.05997232f, 0.06232344f, 0.04238667f, 0.02516832f, 0.03250809f, -0.03601557f, 
    0.18998174f, -0.11567497f, 0.04001779f, -0.18558231f, -0.03475581f, 0.05837452f, 0.04568703f, -0.04626004f, 
    -0.00268690f, -0.01328243f, 0.04771084f, 0.03812855f, 0.15992950f, 0.05165501f, 0.10128246f, 0.03029834f, 
    0.12132300f, 0.07745037f, -0.03973884f, 0.02116207f, -0.02921697f, 0.05923286f, 0.12347907f, -0.12127916f, 
    -0.28209314f, 0.07015989f, 0.01058649f, 0.08684904f, 0.03982603f, 0.06810010f, -0.05012932f, 0.00181713f, 
    -0.01967581f, 0.07117165f, -0.00854678f, 0.02398378f, -0.41727176f, 0.07295061f, -0.18614481f, -0.11465137f, 
    -0.01789927f, -0.06056037f, 0.00936008f, 0.08524385f, 0.04109960f, 0.04052421f, 0.04241410f, 0.05906655f, 
    -0.08399377f, -0.29739958f, -0.03154129f, -0.03747463f, 0.05780446f, 0.07856801f, -0.00071013f, 0.09986935f, 
    -0.00756450f, 0.02503809f, 0.15716983f, 0.04235859f, 0.10640007f, 0.19822656f, 0.02297072f, 0.01960226f, 
    -0.05428774f, -0.10816209f, 0.05598106f, 0.12338651f, -0.04489164f, 0.01464248f, -0.01403760f, -0.03727172f, 
    -0.18653606f, -0.18787883f, 0.10710555f, -0.13087085f, -0.07209241f, -0.15751654f, -0.06703451f, 0.06263988f, 
    -0.01978821f, -0.02906537f, -0.00271066f, 0.10645239f, -0.04178869f, -0.08854295f, 0.20315227f, -0.02687973f, 
    0.01001708f, 0.06135507f, 0.04513678f, -0.21984847f, 0.15001750f, -0.02245415f, -0.01119795f, 0.06448930f, 
    0.03824500f, 0.00577298f, -0.03738545f, 0.09357424f, 0.01758030f, -0.09044787f, -0.10402424f, 0.09179362f, 
    0.11630124f, 0.01771921f, -0.10508090f, -0.01363968f, 0.09771857f, -0.01401550f, -0.28486198f, -0.14785802f, 
    0.11309016f, -0.03103372f, 0.12352400f, -0.10618606f, -0.03035254f, -0.08263145f, -0.04393253f, 0.05603267f, 
    0.11597318f, -0.00969948f, 0.12481990f, -0.04563094f, 0.07442964f, 0.03205612f, 0.08903836f, -0.05504350f, 
    0.02408448f, -0.06232775f, 0.02258972f, 0.00931788f, -0.43136227f, -0.01862395f, -0.13130718f, -0.24130802f, 
    0.08543184f, 0.10648076f, -0.12599544f, 0.10058933f, 0.06991619f, -0.04560738f, -0.01506630f, 0.12821625f, 
    0.27031985f, 0.07353805f, -0.08975876f, 0.01715069f, 0.03731073f, 0.12292919f, 0.02711166f, -0.01498706f, 
    0.10041881f, 0.06151159f, 0.10257617f, 0.07153670f, 0.40758687f, 0.19569641f, 0.32949954f, 0.19965999f, 
    -0.12708774f, 0.04435339f, -0.01743427f, 0.01135823f, -0.01073054f, 0.03065035f, 0.13420223f, -0.09057549f, 
    -0.12385719f, 0.04645246f, -0.10796818f, 0.00521114f, 0.09228819f, 0.01055519f, 0.13854410f, -0.00009206f, 
    -0.17204323f, -0.01452693f, 0.00870754f, 0.04177747f, -0.05879279f, 0.12489287f, 0.07228632f, 0.33047155f, 
    -0.04407144f, 0.07028371f, 0.06993993f, -0.08369073f, 0.01337286f, -0.06219314f, -0.01486084f, -0.03975512f, 
    -0.04568869f, 0.22679317f, -0.17521532f, -0.04287563f, -0.08255342f, -0.06164834f, -0.16565366f, 0.07865203f, 
    0.00977385f, -0.09850413f, -0.05032703f, -0.07536621f, -0.16491634f, 0.05955420f, 0.05063786f, -0.00834329f, 
    -0.10632767f, 0.07615773f, -0.07655036f, -0.06262045f, 0.01108810f, 0.04465165f, -0.05952663f, 0.17864138f, 
    0.06894193f, -0.22001231f, -0.08847092f, -0.05601515f, 0.13336892f, -0.02269943f, -0.00611791f, 0.00993671f, 
    0.07383209f, -0.02796241f, -0.02211346f, 0.06248795f, 0.41454628f, 0.07256623f, 0.23073360f, 0.21461098f, 
    0.07478143f, 0.07862114f, 0.11637456f, -0.06023634f, 0.06550296f, -0.04321203f, -0.08168110f, 0.08810715f, 
    0.28561038f, 0.23988886f, -0.03451301f, 0.20306078f, -0.09131604f, -0.02524655f, -0.10170905f, -0.04585611f, 
    -0.15382415f, 0.09838203f, -0.06590158f, 0.07875918f, -0.05300051f, -0.10308526f, 0.04756003f, -0.04799088f, 
    0.10150702f, -0.00017906f, 0.01768355f, -0.03816499f, 0.07478527f, -0.01856531f, 0.07212310f, 0.02620765f, 
    0.00063761f, -0.21532439f, 0.12644362f, 0.16798595f, -0.01815419f, 0.15492335f, 0.10740241f, -0.05885990f, 
    -0.01432372f, -0.01769522f, -0.04598799f, 0.02279441f, 0.03125255f, -0.21236178f, -0.11916960f, -0.17560905f, 
    0.03683762f, 0.06561735f, -0.01521576f, 0.05230947f, -0.04750971f, 0.04250519f, -0.00781259f, -0.22207351f, 
    0.01557748f, -0.15180610f, 0.05918264f, 0.19244684f, 0.00279133f, -0.14597775f, -0.01187547f, -0.04017114f, 
    -0.13045490f, 0.00434754f, -0.03234520f, 0.15974955f, 0.10654864f, 0.03830185f, 0.16427086f, -0.16127044f, 
    -0.01336574f, 0.05530961f, -0.03087125f, 0.19274653f, -0.01674308f, -0.01913417f, -0.08529318f, -0.05729048f, 
    0.11325140f, 0.05582827f, -0.02183995f, -0.23795605f, 0.04038815f, -0.01806007f, 0.01943607f, -0.00852242f, 
    0.11288056f, 0.01686526f, 0.16886067f, 0.14046641f, 0.21285829f, -0.10070916f, 0.02710970f, -0.05713066f, 
    0.00829042f, 0.00586986f, -0.03043806f, -0.01005245f, 0.10245826f, 0.04207065f, -0.03884264f, -0.13311724f, 
    -0.26259413f, -0.09369677f, 0.19006477f, -0.10416193f, 0.07958931f, -0.03066017f, -0.01307256f, 0.07100503f, 
    0.04710249f, -0.00704248f, -0.01057354f, 0.06559964f, -0.21934836f, -0.00247171f, -0.06538336f, -0.04180275f, 
    -0.00812566f, -0.10809791f, 0.03963483f, 0.02705340f, -0.01075553f, 0.12765305f, 0.02635971f, 0.09436356f, 
    -0.28134945f, -0.05874786f, 0.04824710f, -0.03230626f, 0.04291572f, -0.00971850f, -0.02028601f, -0.11062256f, 
    0.07661706f, 0.12078889f, -0.06609344f, -0.07832140f, -0.03711079f, 0.33594289f, -0.10290135f, -0.02440676f, 
    0.10175719f, 0.02479765f, 0.09038552f, 0.06370898f, 0.01576013f, -0.00793015f, 0.09456199f, 0.03849679f, 
    -0.02545747f, -0.22460690f, 0.28790915f, -0.10797404f, 0.05634696f, 0.03931458f, 0.07311004f, -0.03743924f, 
    -0.07438208f, -0.01677768f, 0.09994888f, 0.17651522f, -0.22543974f, 0.12776737f, 0.03516362f, -0.34305239f, 
    0.01177911f, -0.04502797f, 0.01337237f, 0.09486409f, 0.13910684f, 0.18158670f, 0.22261563f, 0.12975481f, 
    -0.28038535f, -0.02282999f, -0.17966753f, 0.23162027f, 0.01337695f, 0.01868192f, -0.13494892f, 0.13656519f, 
    -0.01900313f, -0.05781418f, -0.09166501f, 0.03506619f, -0.06011648f, 0.11766760f, 0.01753841f, 0.05589500f, 
    0.17258143f, 0.00736667f, -0.06737708f, -0.01900607f, 0.11967080f, -0.01392591f, -0.10206255f, 0.03216324f, 
    0.09725629f, 0.06118692f, 0.13070250f, 0.03437592f, 0.06931352f, 0.01872906f, -0.06095433f, -0.02912609f, 
    -0.03110085f, -0.04003717f, -0.14389770f, 0.01552533f, 0.00763235f, 0.03912584f, 0.05533717f, 0.10925155f, 
    0.08867116f, 0.03051054f, 0.10113774f, 0.09095668f, 0.08216274f, 0.09465197f, 0.05565088f, 0.00285285f, 
    0.17950235f, 0.00708094f, 0.00142282f, 0.09258012f, 0.04030619f, -0.03639260f, 0.01596342f, -0.01191239f, 
    -0.11202210f, 0.03864340f, 0.08796913f, -0.06189059f, 0.21982886f, 0.18867242f, 0.25200498f, 0.03942608f, 
    0.05904803f, -0.02048246f, 0.12617324f, -0.00279969f, 0.05213477f, 0.08937082f, -0.06823026f, 0.08443182f, 
    0.29418126f, 0.18452051f, -0.04303725f, 0.06324860f, 0.10210045f, 0.03875650f, 0.07764937f, 0.01381215f, 
    0.07489965f, 0.02091176f, -0.05216252f, -0.06183666f, 0.06482222f, -0.16938293f, -0.19293836f, -0.07752711f, 
    0.02266736f, 0.07974353f, 0.06304687f, -0.23094440f, -0.02207141f, 0.05538373f, 0.06838938f, -0.12289294f, 
    -0.37638143f, 0.13819505f, 0.02153572f, 0.03404137f, 0.02529570f, 0.06091137f, 0.00015963f, 0.13091663f, 
    0.01432626f, -0.00667559f, -0.01638586f, 0.09736207f, -0.04554823f, 0.00776898f, 0.47571346f, -0.05588582f, 
    0.05147539f, 0.04038388f, 0.06824511f, -0.07966324f, -0.02338558f, -0.08717107f, 0.04807946f, -0.04683444f, 
    -0.11493967f, -0.09642052f, -0.25293177f, 0.09601339f, 0.14222288f, -0.06167789f, 0.08677089f, 0.07231445f, 
    0.02898483f, 0.06165791f, -0.04936898f, -0.06321935f, 0.16206327f, 0.05951248f, 0.11852442f, -0.27276242f, 
    -0.16612920f, 0.00543693f, 0.01431935f, 0.12877041f, 0.02895722f, 0.04344625f, -0.00445976f, -0.11444531f, 
    0.29551747f, -0.02870077f, -0.00702106f, 0.33491901f, -0.05254132f, 0.07248949f, 0.15550575f, -0.01084692f, 
    0.02188097f, -0.03522542f, 0.17570265f, 0.06789679f, -0.10230783f, -0.21569282f, -0.02715567f, 0.02434332f, 
    0.00844798f, 0.03502911f, 0.16315901f, 0.07403108f, -0.08603296f, 0.01992123f, -0.02699612f, 0.03705740f, 
    -0.36946160f, -0.04299378f, -0.03486478f, 0.05288956f, -0.04122718f, -0.03143969f, -0.02364191f, 0.04647712f, 
    -0.02257928f, 0.12036532f, -0.04146178f, 0.02104081f, 0.09631582f, -0.14462733f, 0.14200434f, 0.24098617f, 
    -0.04199811f, 0.11746345f, -0.00543843f, 0.06603091f, -0.09544189f, -0.00679514f, -0.16058077f, 0.02795980f, 
    -0.06702850f, 0.22278225f, -0.01747622f, 0.16954558f, 0.04039159f, 0.01920657f, 0.07055170f, -0.12210940f, 
    0.01823177f, 0.00836009f, 0.02987717f, -0.02103535f, 0.07046451f, 0.06426189f, -0.01157401f, 0.05206414f, 
    -0.08125055f, 0.07098190f, -0.04441004f, -0.07069995f, -0.12596478f, 0.02728967f, 0.05657838f, 0.09055224f, 
    -0.19569445f, -0.15275910f, 0.00090777f, -0.12395544f, 0.02557719f, 0.10342937f, 0.02149204f, -0.05988655f, 
    0.06849516f, -0.05332680f, 0.08534609f, 0.01803337f, 0.19253032f, 0.11524422f, -0.19242845f, 0.08146186f, 
    -0.03639682f, 0.05722731f, 0.05423150f, -0.03192135f, 0.00086841f, -0.01291318f, -0.07235008f, 0.09359533f, 
    -0.03454992f, 0.11575989f, -0.08496317f, 0.10996436f, 0.02511880f, 0.01344054f, -0.08103672f, 0.05404032f, 
    -0.17525309f, -0.02998601f, -0.00311643f, -0.04762257f, 0.03238064f, 0.35379073f, -0.06458923f, 0.01237628f, 
    0.00340606f, -0.10196176f, 0.05267465f, 0.02684786f, 0.05729114f, 0.00748720f, 0.14888851f, 0.10504210f, 
    -0.17103268f, 0.20946127f, -0.10326983f, -0.05659227f, -0.13359503f, 0.15565681f, 0.02938912f, -0.07816531f, 
    -0.00258145f, 0.01694357f, 0.06078975f, -0.22660576f, -0.01624309f, 0.02558340f, 0.12768571f, 0.18786718f, 
    0.07776236f, -0.05278510f, 0.10128511f, 0.08621226f, -0.07277209f, 0.15332744f, 0.10668193f, 0.05104029f, 
    -0.05716526f, -0.06558856f, -0.08739990f, 0.13718632f, 0.02738807f, 0.12562978f, 0.00729287f, 0.03069261f, 
    -0.03082212f, -0.13346979f, -0.14153308f, -0.21988185f, 0.03340543f, 0.00279945f, 0.24630326f, 0.07043210f, 
    -0.03206415f, -0.12112095f, -0.03455556f, -0.01458460f, -0.17798620f, -0.04814111f, 0.03558728f, 0.08433696f, 
    0.11379566f, 0.15938152f, 0.12273870f, 0.09125461f, 0.02970625f, -0.07883985f, 0.08160739f, 0.05939277f, 
    -0.09978894f, 0.23123464f, -0.12289344f, -0.05007346f, 0.26125562f, 0.10500701f, -0.10501373f, -0.13946761f, 
    0.07150073f, -0.02925982f, -0.11181945f, 0.06517657f, 0.04017848f, 0.00138093f, 0.02825498f, -0.12470087f, 
    0.26544473f, 0.03151508f, 0.02661027f, 0.05354714f, -0.14767700f, 0.13177988f, -0.08925413f, 0.03706931f, 
    -0.05984723f, -0.18575044f, 0.17756528f, 0.00567543f, 0.33858848f, -0.25088322f, -0.05456155f, -0.24137571f, 
    -0.02733033f, 0.04545734f, -0.00457215f, 0.14259428f, -0.10214677f, 0.14196953f, 0.11869560f, -0.03263814f, 
    0.27783358f, -0.03687352f, -0.10692508f, 0.02908703f, -0.05272068f, -0.02890911f, -0.03054778f, 0.06931607f, 
    -0.01055515f, 0.12171827f, 0.08251268f, -0.12802665f, 0.07506055f, -0.09538004f, 0.03060485f, 0.20629165f, 
    0.03456578f, 0.02882072f, 0.01031944f, -0.05622074f, -0.09094681f, -0.09229531f, -0.14376581f, -0.21770088f, 
    0.28281644f, -0.03390081f, -0.01784639f, 0.10391835f, -0.11006612f, 0.00580643f, 0.10390248f, -0.06611034f, 
    -0.06198644f, 0.11959352f, 0.01220777f, 0.01120187f, -0.02676801f, -0.13783744f, -0.00344689f, 0.00715763f, 
    -0.03685732f, -0.06364889f, -0.04219049f, 0.10600673f, -0.05405155f, 0.00000624f, 0.08941618f, 0.09069876f, 
    -0.36171103f, -0.08993115f, -0.00534113f, 0.04960722f, 0.01755873f, 0.16666645f, 0.05383039f, 0.23432054f, 
    0.16411996f, -0.07543531f, 0.24375859f, 0.01003037f, -0.01882129f, -0.04031832f, 0.13112238f, -0.04594267f, 
    -0.04986523f, 0.05296461f, -0.09260760f, -0.03700510f, 0.02669392f, 0.04037750f, -0.17153858f, 0.06688333f, 
    0.03539736f, 0.03400965f, -0.04627938f, -0.02386198f, 0.02908966f, 0.03697927f, -0.06998341f, -0.03631825f, 
    -0.03970172f, 0.03212994f, 0.04806902f, -0.06798472f, 0.01964674f, -0.03483338f, -0.00411212f, 0.02329996f, 
    -0.00753717f, -0.03229191f, -0.01420785f, 0.06012918f, 0.03098252f, -0.05732855f, 0.00964772f, 0.01033648f, 
    -0.04666084f, -0.03275679f, -0.06413438f, -0.03620202f, -0.07295633f, 0.04436794f, 0.00614868f, -0.06878088f, 
    -0.02644672f, -0.04716981f, -0.01371391f, 0.04003641f, -0.03462168f, -0.00611539f, 0.04974157f, -0.01629638f, 
    -0.01893955f, 0.06387968f, -0.05404617f, 0.03001335f, -0.01686518f, -0.03337248f, 0.03016194f, -0.00212340f, 
    -0.06320012f, -0.07322664f, -0.07737872f, 0.00256487f, -0.05261532f, 0.06182303f, 0.06558507f, -0.00690188f, 
    0.03210461f, 0.01715290f, -0.00353228f, -0.05275752f, -0.03455605f, 0.01685082f, -0.06048393f, -0.06998918f, 
    0.02802101f, -0.04467720f, 0.03807345f, 0.01791998f, -0.06439172f, 0.05375302f, -0.07802374f, -0.05034143f, 
    -0.06591421f, 0.00301865f, 0.06251720f, -0.03726764f, 0.02054076f, 0.05445320f, -0.01243542f, -0.04021626f, 
    -0.07516106f, -0.02468549f, 0.01676391f, 0.01162687f, 0.03933248f, -0.00440639f, -0.01165675f, -0.05179241f, 
    0.06502860f, -0.06552935f, -0.04860450f, -0.02425109f, -0.01450620f, 0.06543515f, 0.02153321f, 0.05306168f, 
    0.00613431f, -0.04535368f, -0.04259908f, 0.04389098f, -0.06959565f, 0.01268502f, 0.06464473f, 0.02556297f, 
    0.04430537f, 0.04654436f, 0.01133345f, -0.01337608f, -0.02651107f, 0.03823269f, -0.05657353f, -0.03790633f, 
    -0.01039347f, 0.00729238f, 0.01242488f, -0.04679523f, 0.06181775f, -0.06551917f, -0.04901982f, -0.07320047f, 
    -0.03194727f, -0.04529919f, 0.00638237f, -0.01889896f, -0.06799345f, 0.04212999f, -0.03013491f, -0.05103384f, 
    0.05551270f, -0.04568774f, 0.04907822f, 0.03867397f, 0.01419148f, 0.04334362f, -0.00215574f, 0.03619522f, 
    -0.07252874f, -0.02865740f, 0.00500215f, 0.05343799f, -0.01405875f, 0.05313452f, -0.06221005f, -0.00875668f, 
    0.02991186f, 0.00346907f, -0.07413431f, -0.07151363f, -0.03127668f, -0.04232327f, -0.00967880f, 0.00584964f, 
    0.05886817f, 0.06585737f, -0.00817218f, 0.06591862f, -0.07769334f, 0.00885439f, -0.01594134f, -0.00343898f, 
    -0.05446331f, -0.00645455f, -0.03258523f, 0.04300832f, 0.03129653f, -0.05546556f, 0.05613666f, -0.06221633f, 
    0.02043479f, -0.05989337f, -0.07284162f, -0.04840202f, 0.01940796f, -0.06096764f, -0.07740206f, 0.03156026f, 
    -0.04117253f, -0.06397288f, -0.02038905f, -0.00072912f, -0.05979694f, -0.06404578f, -0.05269505f, -0.02428094f, 
    -0.07752427f, 0.02147657f, 0.03049840f, 0.02645262f, -0.04965793f, -0.04428095f, 0.05983609f, -0.05635818f, 
    -0.06423467f, 0.02318398f, -0.01320739f, -0.03301935f, 0.02118010f, -0.05047818f, 0.05303249f, -0.07338650f, 
    0.04525355f, -0.07321966f, -0.00784850f, 0.00507191f, -0.06912809f, -0.01435007f, 0.00151395f, -0.06568554f, 
    -0.06267898f, -0.01170169f, 0.00567396f, 0.01794763f, -0.02138969f, -0.01492771f, -0.02608307f, 0.03609536f, 
    -0.03562035f, -0.07520121f, -0.00952840f, -0.00827180f, -0.06540415f, -0.07260566f, -0.05439087f, 0.06619663f, 
    0.02334441f, 0.04777115f, 0.03445020f, -0.01512111f, -0.02163053f, -0.02196382f, -0.07520447f, -0.02604283f, 
    0.03657683f, -0.02525551f, -0.02691183f, -0.02369408f, -0.06944708f, -0.07250130f, -0.07254774f, -0.05694798f, 
    -0.03310861f, -0.06367914f, 0.04724782f, -0.02815292f, 0.03319421f, 0.03098999f, -0.05065698f, -0.01193241f, 
    0.04751310f, -0.04943576f, 0.01520365f, -0.02015326f, -0.07525890f, -0.00052420f, 0.02667101f, 0.03155294f, 
    -0.05201078f, 0.00458928f, 0.03726307f, 0.05768801f, 0.02837410f, 0.05540710f, 0.04888867f, -0.06431550f, 
    0.04109611f, -0.03846307f, -0.03240250f, -0.02216168f, -0.01009322f, -0.05744356f, -0.05828807f, 0.06346592f, 
    -0.02920503f, -0.03290958f, -0.06621855f, 0.01782730f, -0.01087949f, 0.05733996f, 0.02435332f, -0.00271486f, 
    -0.04469136f, 0.05278163f, 0.02167262f, -0.06091219f, -0.07282954f, -0.07044513f, -0.05174597f, 0.00413659f, 
    0.02167327f, 0.05071640f, -0.05025945f, 0.04900192f, -0.00605281f, -0.02048951f, 0.04425481f, 0.01770015f, 
    -0.04484199f, 0.03834761f, 0.05611391f, -0.03065207f, -0.00497459f, -0.00513575f, 0.01451072f, 0.01219486f, 
    -0.03166385f, 0.01017743f, -0.07649110f, 0.03666056f, -0.01421815f, 0.04409370f, 0.01473473f, 0.00456530f, 
    0.03158269f, 0.03372313f, 0.00977680f, -0.03459578f, -0.07256267f, -0.07203762f, -0.02365988f, 0.00248506f, 
    -0.01666556f, -0.05802500f, 0.06444596f, -0.04670186f, -0.05960197f, -0.03071439f, 0.00663304f, -0.00163581f, 
    -0.00918680f, -0.03668326f, -0.02313949f, 0.05844714f, -0.04765333f, 0.03165920f, -0.03730914f, -0.00996011f, 
    0.04910993f, 0.06060942f, -0.04159900f, -0.06496684f, 0.01932753f, 0.05692380f, 0.03910512f, 0.03525731f, 
    0.02362856f, -0.03114855f, -0.07339312f, 0.01741366f, 0.01153063f, 0.00211195f, -0.00380559f, -0.01416776f, 
    0.01641900f, 0.02633639f, -0.04625292f, 0.04968477f, -0.02731279f, -0.02247522f, 0.06041436f, -0.06284994f, 
    0.01561774f, -0.07333160f, 0.01003659f, 0.05449763f, -0.05622144f, 0.02405130f, -0.04233925f, -0.02305020f, 
    -0.02034218f, -0.04248474f, -0.04094023f, 0.01624879f, -0.05467093f, 0.05094567f, -0.03465287f, 0.00844914f, 
    0.03051741f, -0.04175468f, -0.06554954f, -0.06174724f, -0.06398929f, -0.05987792f, -0.04432683f, -0.02194171f, 
    -0.23352751f, 0.14861843f, -0.07111009f, 0.23075767f, -0.04473508f, 0.08718071f, 0.19074003f, -0.13742958f, 
    -0.07031370f, -0.02931959f, -0.02646475f, -0.10057578f, 0.05191315f, 0.02862833f, -0.12858358f, 0.05668212f, 
    -0.06020523f, -0.00077612f, 0.13707419f, 0.04442476f, -0.12018491f, -0.11248774f, 0.06519629f, -0.00343442f, 
    -0.17303991f, 0.00657575f, 0.07018391f, -0.01087818f, -0.14319253f, 0.14259005f, 0.00465589f, -0.08301307f, 
    0.11448430f, -0.05183772f, -0.00233311f, -0.13484718f, -0.12963250f, 0.15594742f, 0.28083920f, 0.12618092f, 
    0.02310042f, -0.06773113f, -0.00566409f, 0.08155533f, 0.00022028f, 0.15391673f, -0.05221985f, 0.10655270f, 
    0.16809501f, -0.16293372f, -0.15257424f, 0.02111480f, -0.04911270f, -0.04653323f, 0.00502122f, -0.06403062f, 
    0.02595556f, -0.01240600f, 0.00351520f, -0.15237218f, 0.16861893f, 0.05877568f, 0.03586173f, 0.20956525f, 
    0.11618811f, -0.00698429f, 0.06839990f, 0.03760467f, -0.21102160f, -0.01295515f, 0.05485884f, 0.03572801f, 
    -0.17758477f, 0.05978072f, 0.25863448f, -0.03353712f, 0.05439727f, -0.02355903f, -0.05101546f, 0.09815276f, 
    -0.01727998f, 0.05868446f, -0.06298622f, 0.03313363f, -0.01381008f, -0.06969913f, -0.12904049f, 0.04137942f, 
    0.18070531f, -0.16558802f, 0.00654730f, -0.10693729f, -0.00751431f, 0.04372954f, -0.01819346f, 0.01556518f, 
    0.09217359f, -0.20599878f, 0.20708811f, -0.00919209f, -0.10134518f, 0.04920151f, -0.07508750f, 0.04055102f, 
    0.06294420f, -0.10452073f, 0.06422172f, -0.03493728f, 0.13850498f, 0.25307274f, -0.14839032f, -0.38697061f, 
    0.19500297f, 0.09217661f, 0.02858664f, 0.04531781f, -0.09794632f, 0.04289054f, -0.02366463f, 0.01844527f, 
    0.32688141f, -0.16053976f, 0.26711389f, -0.01491201f, -0.10060992f, 0.16180047f, 0.11225884f, 0.05348921f, 
    -0.02441327f, 0.05294854f, 0.10111058f, -0.02064482f, -0.22280312f, 0.21660593f, -0.09336361f, -0.14623100f, 
    -0.08706249f, -0.04689950f, -0.05593370f, -0.01396272f, -0.03940541f, -0.16410980f, 0.06781487f, -0.07788768f, 
    0.03159921f, 0.10892142f, -0.15475972f, -0.01076471f, -0.01819425f, 0.00099123f, -0.02483749f, 0.01348622f, 
    -0.10146549f, 0.03553617f, 0.06250389f, 0.09066857f, -0.02849316f, -0.16823718f, 0.20386302f, 0.00178895f, 
    0.15524305f, 0.09333093f, -0.01717274f, -0.01473387f, 0.02437734f, 0.10828668f, -0.03625807f, 0.09854852f, 
    -0.29399651f, 0.09215350f, 0.11032987f, 0.00189497f, 0.00374352f, 0.09107975f, 0.10177377f, 0.08980008f, 
    0.10632351f, -0.02972415f, 0.17646748f, -0.00183069f, -0.02911894f, -0.00576203f, 0.13438962f, -0.03829658f, 
    0.08016854f, 0.00377900f, -0.12704204f, 0.03287025f, 0.06554753f, 0.07469749f, -0.08980465f, -0.00850294f, 
    0.01849562f, 0.05235435f, 0.01178664f, -0.00444955f, 0.00941643f, -0.04942628f, -0.03902695f, -0.04591677f, 
    -0.03572067f, -0.05597061f, -0.07958262f, 0.03152262f, 0.00924313f, 0.00183531f, 0.04083096f, -0.01670584f, 
    0.01469980f, -0.04121475f, 0.04716879f, -0.05958956f, -0.04082000f, 0.00888475f, 0.06257297f, 0.02487796f, 
    0.06200400f, -0.01510319f, -0.06572426f, 0.00756901f, -0.05649579f, -0.01676596f, 0.04827426f, -0.00790811f, 
    -0.02316887f, -0.04128432f, 0.04243078f, -0.04995842f, 0.04938971f, 0.00591900f, 0.03881151f, -0.06554783f, 
    -0.00181818f, 0.03160761f, 0.00653604f, 0.04851620f, -0.05078938f, -0.00670966f, 0.03212775f, -0.04503307f, 
    -0.01661738f, 0.00873725f, 0.06200957f, 0.00547633f, -0.05236101f, -0.04557018f, 0.00367886f, -0.07426641f, 
    0.03852546f, -0.05163663f, 0.00910442f, -0.05030685f, -0.03297116f, -0.07017440f, -0.07336990f, -0.06748807f, 
    -0.03906129f, -0.00987266f, -0.07073195f, 0.02688443f, 0.06272487f, -0.01307817f, 0.06334704f, 0.04601478f, 
    -0.00742383f, -0.02636491f, 0.02456806f, 0.02192664f, 0.05965000f, -0.03346627f, -0.03401698f, 0.03641421f, 
    -0.02066644f, -0.01691364f, -0.03139919f, -0.00522501f, -0.01857725f, -0.07222273f, -0.01500360f, -0.05239438f, 
    -0.04049974f, -0.02188058f, -0.06692890f, -0.07686470f, 0.02690353f, -0.06626401f, -0.01482467f, 0.00840753f, 
    -0.07320231f, 0.04441639f, -0.07332474f, -0.02745788f, -0.02609191f, -0.06173906f, 0.02422724f, -0.01856400f, 
    0.04097193f, 0.01082535f, -0.02297845f, 0.00546013f, -0.05453325f, 0.02234429f, 0.03221505f, 0.00841327f, 
    -0.05401669f, -0.03166877f, -0.05921959f, -0.04899931f, -0.05410095f, -0.01020145f, -0.04030640f, -0.01517384f, 
    -0.03926392f, 0.05046528f, -0.05910435f, -0.03286768f, -0.07747200f, -0.02524724f, 0.01014683f, -0.04960557f, 
    -0.04227357f, 0.02135341f, -0.05659197f, -0.02605945f, -0.07118047f, -0.04293288f, 0.05646871f, -0.07956926f, 
    0.05724381f, 0.00774705f, -0.01771399f, -0.03130684f, -0.06612905f, 0.05911288f, -0.00100540f, 0.04150188f, 
    -0.06256332f, -0.01978937f, -0.05217513f, -0.07937039f, -0.07771605f, 0.03609033f, 0.01289502f, -0.03117720f, 
    -0.02770849f, 0.04084738f, 0.06189414f, 0.00253826f, 0.02165152f, 0.03361937f, -0.04494545f, -0.05127655f, 
    -0.00740810f, 0.03841261f, -0.05716003f, 0.06007957f, -0.03614032f, 0.04273473f, 0.04706377f, -0.03610130f, 
    0.00372470f, -0.01253027f, -0.03984490f, 0.00695942f, 0.04463201f, 0.04993755f, -0.06553247f, -0.06721260f, 
    -0.06576039f, -0.04166538f, -0.00219351f, -0.02329255f, 0.00888956f, 0.01943151f, -0.01415852f, -0.03275849f, 
    0.06181714f, -0.03654276f, 0.02405562f, 0.01988002f, 0.05142007f, -0.04199716f, -0.01295184f, 0.06240128f, 
    0.18891437f, -0.04489404f, -0.07913809f, 0.04999052f, 0.01323318f, 0.01051944f, -0.05411773f, -0.02214980f, 
    0.01688866f, -0.02214669f, -0.10105422f, -0.09082741f, 0.23256204f, 0.12140066f, -0.21563023f, -0.21387407f, 
    -0.11794777f, 0.08128288f, 0.12524341f, 0.07393979f, -0.00397002f, 0.06219899f, 0.03226633f, 0.13336466f, 
    -0.07415336f, -0.03247966f, 0.00419866f, 0.21294858f, -0.14856252f, 0.16538249f, 0.06467149f, -0.07185403f, 
    0.01956914f, 0.01750488f, 0.04335356f, -0.04064064f, 0.05142587f, -0.38426539f, 0.12701176f, 0.01785076f, 
    -0.04106805f, -0.02780132f, 0.10781454f, 0.03064959f, -0.10563471f, 0.06816408f, 0.10963171f, 0.08396602f, 
    -0.15103652f, 0.20728882f, -0.03715721f, -0.03404513f, 0.04605618f, -0.06301288f, 0.11779205f, 0.06549577f, 
    -0.09453531f, -0.04059018f, -0.11904503f, 0.01091940f, -0.00947434f, -0.12797339f, -0.02193130f, 0.15888341f, 
    -0.04011738f, -0.09479623f, 0.00476787f, 0.09500101f, 0.03002968f, -0.05065830f, -0.00667421f, 0.11076216f, 
    0.04890137f, -0.09575942f, 0.11682303f, -0.08579750f, -0.20200957f, -0.11744462f, 0.02450510f, 0.01647800f, 
    -0.02915049f, -0.03956362f, -0.04872834f, -0.11848892f, 0.16643114f, 0.14847118f, 0.22646475f, 0.21548322f, 
    0.03444914f, 0.04932571f, 0.10172224f, 0.08125480f, 0.01908341f, -0.05741252f, -0.06391712f, 0.04367281f, 
    0.02334167f, -0.02214440f, 0.09883363f, -0.14185628f, 0.05468290f, 0.00096759f, 0.03793031f, 0.08816679f, 
    -0.14111488f, 0.01598850f, 0.00952183f, -0.08646208f, 0.13032278f, 0.10908965f, 0.02887495f, -0.09570989f, 
    -0.04658245f, 0.09939204f, -0.02876843f, 0.10315292f, -0.04076613f, 0.00253763f, 0.11828731f, -0.03902800f, 
    -0.02338804f, -0.11940882f, 0.00137307f, 0.16560626f, -0.02083457f, -0.01645979f, 0.15808980f, 0.07545232f, 
    0.07747580f, 0.05176957f, 0.01142865f, 0.00173379f, 0.01069821f, -0.22079392f, 0.01982682f, -0.01734280f, 
    0.12421121f, -0.01180033f, 0.08512048f, -0.01147098f, -0.01587290f, 0.06664052f, 0.04432782f, -0.06848847f, 
    0.05963067f, -0.04868573f, 0.12877305f, 0.05531674f, -0.12438142f, 0.02977988f, -0.00598173f, 0.06139175f, 
    -0.02486481f, -0.02782761f, -0.01798645f, 0.04057216f, -0.47937214f, 0.04723474f, -0.03465651f, -0.11573181f, 
    0.09442957f, 0.09500793f, 0.08542677f, -0.00881493f, -0.11540550f, 0.06412034f, 0.00462363f, 0.08030481f, 
    0.12030648f, -0.06710159f, 0.12921292f, 0.15579215f, 0.09477770f, 0.02036102f, -0.07145805f, 0.09577276f, 
    0.06656567f, -0.06318484f, 0.15600926f, 0.03417346f, -0.19128355f, -0.05494789f, -0.04176940f, -0.01399720f, 
    -0.00378771f, -0.15901040f, 0.08286278f, -0.04794279f, -0.03305686f, 0.02333119f, -0.09856781f, 0.01524618f, 
    0.03365543f, 0.04707026f, 0.03555574f, 0.03818667f, -0.06165659f, -0.06079742f, 0.04979170f, 0.02570288f, 
    0.03754922f, 0.02943861f, -0.04519471f, -0.06955172f, -0.06719097f, 0.02921829f, -0.01344860f, -0.03853359f, 
    0.03842412f, 0.04330957f, 0.06111426f, -0.04831071f, 0.00175535f, 0.02951131f, 0.00619273f, -0.01264320f, 
    0.02646109f, -0.07739698f, -0.00599694f, -0.03201838f, -0.00344384f, 0.00884976f, 0.02031934f, 0.00381769f, 
    -0.02974919f, -0.04869181f, 0.05316081f, 0.04599163f, -0.00562079f, -0.03444925f, -0.06884091f, 0.00463302f, 
    -0.03426781f, 0.06293855f, -0.07221372f, -0.00989531f, 0.03526747f, 0.06612118f, 0.06180258f, 0.00018906f, 
    0.07259813f, 0.04710070f, -0.05053206f, 0.05188125f, -0.02241135f, 0.04365631f, 0.04307113f, -0.00165521f, 
    0.01278586f, 0.01851626f, -0.02510897f, -0.07778951f, 0.00865727f, 0.06591001f, -0.06932511f, 0.06280296f, 
    -0.06858372f, -0.02420632f, 0.00412377f, -0.04531161f, -0.02797361f, -0.06697862f, -0.06823445f, 0.00168762f, 
    -0.05603193f, -0.04246775f, -0.01012990f, -0.00435490f, -0.04596790f, -0.07380024f, 0.02730865f, 0.00964006f, 
    0.03586810f, 0.04027347f, 0.02654254f, -0.01577814f, -0.07262880f, 0.05440515f, -0.06533679f, -0.04562500f, 
    0.02280362f, 0.00751646f, -0.03497032f, -0.02230690f, -0.06468935f, 0.02204905f, 0.04677562f, 0.03250503f, 
    -0.02803875f, -0.00644487f, -0.06125784f, 0.06468682f, -0.07096882f, -0.05025217f, -0.04874426f, -0.00403541f, 
    -0.04740278f, -0.05561271f, -0.04903489f, -0.04106442f, -0.00543763f, -0.04222474f, -0.04011108f, -0.01896686f, 
    -0.00906055f, -0.06462183f, -0.04923227f, -0.06163710f, -0.02175591f, 0.00673058f, 0.05895649f, 0.03770405f, 
    0.03836052f, -0.02929126f, -0.07741522f, -0.01383787f, 0.03953027f, 0.03133899f, -0.02488959f, 0.02740254f, 
    0.02487920f, -0.06239061f, 0.06912327f, -0.01638563f, -0.05081576f, -0.06751567f, -0.00058661f, -0.06310542f, 
    -0.02826661f, -0.01803917f, -0.02564977f, -0.03825699f, 0.04579962f, -0.02126978f, 0.03962962f, 0.00021514f, 
    -0.03078931f, -0.03746627f, -0.06525736f, 0.08024940f, -0.05481238f, -0.03055627f, -0.03899518f, 0.04510947f, 
    -0.05778711f, -0.01369044f, 0.03018207f, 0.00262941f, 0.02287427f, 0.05649667f, 0.04610298f, 0.01238568f, 
    0.03009330f, 0.00501026f, 0.05263724f, -0.03266213f, 0.04916273f, -0.01849258f, -0.03792956f, 0.04435042f, 
    -0.03612567f, 0.04953374f, 0.04835404f, -0.04658660f, -0.02772716f, -0.03404008f, 0.02704510f, 0.06718560f, 
    0.01301898f, 0.06564117f, 0.00642190f, -0.07413253f, -0.01632745f, -0.04695344f, -0.05028125f, 0.00310810f, 
    0.01143767f, -0.05527304f, -0.04360767f, 0.01095294f, -0.02841291f, -0.03327640f, -0.03114513f, -0.03403565f, 
    0.22111933f, -0.11390287f, 0.24707904f, -0.13958444f, -0.01311694f, 0.06262045f, 0.04436050f, 0.12637351f, 
    -0.11276481f, 0.04440476f, 0.08618926f, 0.06235937f, -0.11471349f, 0.22079906f, 0.17756046f, -0.02715318f, 
    0.06772166f, -0.02679767f, -0.01346776f, -0.06444009f, 0.11048979f, 0.06220180f, -0.14873318f, -0.03896678f, 
    0.31307453f, -0.04984809f, -0.12264445f, 0.14075054f, 0.11499433f, -0.17131861f, 0.07415899f, 0.00785689f, 
    -0.06756008f, -0.00059476f, 0.04279531f, 0.11318734f, 0.22737235f, -0.22814746f, -0.11066946f, -0.32183385f, 
    0.04351991f, 0.08225219f, -0.00465567f, -0.06846966f, -0.04426012f, -0.02259562f, -0.02293458f, -0.07999478f, 
    -0.28618962f, 0.20484078f, 0.14183021f, -0.02338865f, 0.02530697f, 0.08201008f, -0.02068553f, 0.09642123f, 
    -0.03586900f, 0.01240459f, 0.08887398f, 0.15928626f, 0.21973264f, -0.01737514f, 0.08031902f, -0.22020815f, 
    -0.06946111f, 0.04218714f, 0.08377372f, 0.03535695f, 0.13359895f, 0.15821211f, 0.01295658f, -0.05968530f, 
    0.10639717f, -0.03888174f, -0.04599775f, -0.18324360f, -0.10346316f, 0.13919330f, -0.04792220f, -0.07822773f, 
    -0.00677634f, -0.04892489f, 0.00183521f, 0.04239448f, 0.05567085f, -0.13109215f, 0.04579733f, 0.15237880f, 
    -0.04187771f, 0.04514021f, -0.05541603f, 0.11076234f, -0.00781776f, 0.00385383f, -0.08080423f, 0.06703252f, 
    -0.09986845f, 0.23598883f, -0.14067191f, 0.01957125f, 0.02847229f, 0.10162106f, 0.06600280f, -0.06845252f, 
    0.02286119f, 0.14875121f, -0.12926695f, 0.09411187f, -0.09808610f, -0.15214610f, 0.08693890f, 0.29218471f, 
    -0.09359406f, 0.09515738f, -0.09283623f, -0.00911163f, -0.00301406f, 0.01365475f, 0.05522778f, -0.03536934f, 
    -0.16903436f, -0.00429546f, -0.20264605f, -0.11651830f, 0.07767969f, -0.17587270f, -0.04789194f, 0.07391845f, 
    0.05849482f, -0.08568929f, -0.03879877f, 0.02459310f, 0.11259068f, -0.04288034f, 0.16181087f, 0.04115030f, 
    0.15450457f, 0.08855545f, 0.01106939f, 0.00403061f, 0.02693186f, 0.05544791f, 0.12476600f, 0.03237160f, 
    -0.09485423f, -0.01405216f, 0.06922263f, 0.32472515f, 0.00007855f, -0.07753528f, 0.06019782f, -0.02672844f, 
    -0.01310324f, -0.00408032f, 0.01311650f, 0.03159200f, -0.05144712f, 0.24512824f, -0.18422382f, -0.01531029f, 
    0.13555796f, 0.03733519f, 0.03321567f, -0.03541292f, 0.06863454f, -0.02032347f, -0.08666682f, -0.06247280f, 
    0.17215796f, -0.14340965f, -0.05003087f, -0.08830241f, -0.00327631f, -0.08345515f, 0.00891165f, -0.06584638f, 
    -0.05155787f, 0.08034828f, -0.20805198f, 0.01738033f, 0.28686902f, 0.19075830f, -0.12916903f, -0.02343460f, 
    0.05410089f, 0.09859823f, 0.18768631f, 0.11559959f, 0.00568953f, 0.02984633f, 0.14874333f, 0.09070189f, 
    0.04315609f, -0.05124170f, -0.01465708f, 0.02463476f, 0.02145703f, 0.03885439f, -0.05756092f, -0.07560572f, 
    -0.03855506f, -0.06632840f, 0.03810203f, -0.01350986f, 0.04731979f, 0.01398872f, -0.01146532f, -0.04634592f, 
    -0.05370329f, -0.06483749f, -0.06291033f, -0.05517040f, 0.01780388f, 0.05597573f, 0.06263418f, -0.06444669f, 
    -0.05970302f, -0.07089821f, 0.02579328f, 0.01608764f, -0.04437842f, -0.06544383f, -0.05276374f, 0.04256854f, 
    -0.04715080f, -0.03844631f, -0.02622930f, 0.03707993f, 0.00175079f, -0.02481119f, -0.03786895f, -0.03620239f, 
    0.00174841f, 0.00928102f, 0.00581744f, 0.03443656f, -0.06257159f, 0.05737953f, -0.01783620f, 0.05319974f, 
    0.01172945f, 0.00666195f, 0.02823679f, 0.00084653f, 0.04777016f, -0.07717209f, -0.07927577f, 0.02793441f, 
    -0.03259337f, 0.01540590f, -0.01754915f, -0.06125126f, -0.06520507f, -0.03382242f, 0.05451836f, -0.00743918f, 
    -0.04363286f, 0.00874487f, -0.06160613f, -0.01904279f, -0.02110074f, -0.03994630f, -0.03999475f, -0.03319770f, 
    -0.05752947f, -0.03075442f, -0.07068237f, -0.04845383f, -0.03320983f, -0.06313055f, 0.05601149f, -0.07699493f, 
    0.03791588f, 0.01865170f, 0.00937652f, 0.02106617f, 0.00046304f, 0.00087551f, -0.03530402f, 0.01472456f, 
    0.04685467f, -0.06550573f, -0.06908467f, 0.00647956f, 0.05276142f, -0.07578041f, 0.05072823f, -0.02703083f, 
    0.03666969f, -0.05964879f, 0.01993061f, 0.02486858f, -0.04694180f, -0.07168335f, -0.01162189f, 0.03734713f, 
    0.04588935f, 0.00750442f, 0.03221615f, -0.04602513f, -0.03253846f, -0.04697166f, 0.05523299f, -0.05625710f, 
    -0.06933326f, -0.00671666f, 0.01621422f, 0.04200396f, 0.00956831f, -0.07764815f, 0.01627461f, -0.06138322f, 
    0.01565929f, -0.00002465f, 0.05714718f, -0.03483693f, 0.00695474f, -0.07986777f, 0.03802861f, 0.00808658f, 
    0.01265093f, -0.02704817f, 0.01999698f, -0.05605431f, -0.04984540f, -0.02112236f, -0.03049219f, -0.05611540f, 
    -0.05826397f, -0.00414674f, -0.04329519f, 0.04276707f, -0.04833882f, 0.06411134f, 0.00404397f, 0.04279458f, 
    -0.01395219f, -0.07240266f, -0.01810186f, 0.03596926f, 0.02785870f, 0.06327397f, -0.01075301f, -0.02365627f, 
    0.05237547f, 0.05926970f, 0.01708674f, 0.00213156f, 0.04817530f, 0.05400683f, 0.00308919f, -0.06917169f, 
    -0.00084905f, -0.01923130f, 0.01042773f, -0.04210960f, 0.02516186f, -0.02488958f, -0.05771477f, -0.01228196f, 
    -0.02689966f, -0.06449101f, -0.00182462f, -0.06032469f, 0.00500386f, 0.04042450f, 0.02676626f, -0.06599040f, 
    0.03048393f, -0.03016835f, -0.03370450f, -0.06228040f, -0.01337134f, -0.04114947f, 0.03569242f, 0.03465946f, 
    -0.05918189f, 0.03243973f, -0.01593894f, -0.06139976f, 0.04971305f, 0.02726808f, 0.05416068f, -0.03293658f, 
    -0.18713687f, 0.07664578f, -0.09875834f, -0.14250882f, 0.08764190f, 0.00608478f, 0.08000629f, 0.06911296f, 
    0.01649562f, 0.10020590f, -0.00717745f, 0.01999998f, -0.01065251f, -0.10779382f, -0.08962750f, -0.17964083f, 
    0.10358348f, 0.13661377f, -0.17011973f, -0.02705055f, 0.06308835f, -0.02288785f, -0.03490847f, -0.01442059f, 
    0.01524584f, -0.17356929f, -0.14780788f, -0.03730896f, 0.00674317f, -0.09173525f, -0.06261598f, 0.02484438f, 
    0.00046991f, -0.02399567f, 0.00510138f, 0.06121719f, 0.00313897f, 0.27678359f, 0.10934252f, 0.02005057f, 
    -0.17422326f, -0.08107249f, -0.18502015f, 0.07050922f, 0.00783054f, 0.07882306f, -0.06213140f, -0.11291033f, 
    0.17754640f, 0.18752310f, -0.10600661f, 0.19437508f, 0.04869113f, -0.01134761f, -0.02007181f, -0.00335338f, 
    0.07120169f, -0.00169219f, 0.12717803f, 0.03070920f, 0.12972504f, 0.21669123f, 0.21948212f, 0.05494155f, 
    -0.08007434f, -0.08579709f, 0.06230915f, -0.01039474f, 0.01736817f, 0.15935439f, -0.00147108f, -0.03832017f, 
    0.00548670f, 0.04843068f, 0.11066318f, 0.09861901f, 0.03701163f, -0.04552975f, 0.07758273f, 0.01567990f, 
    0.07126538f, -0.06701685f, 0.01928590f, 0.04499960f, -0.15970106f, -0.00220705f, -0.20338920f, 0.35153505f, 
    0.12298718f, -0.09530990f, 0.01736369f, -0.08156103f, 0.09249643f, -0.03379686f, -0.02205485f, -0.04790553f, 
    0.13960728f, -0.05313104f, -0.13754264f, -0.05424237f, 0.03992026f, -0.10148742f, -0.01860798f, -0.15362771f, 
    0.05393655f, 0.03122772f, -0.12592186f, -0.00058778f, -0.04966751f, -0.01984711f, 0.17115545f, 0.01247817f, 
    -0.06607159f, -0.00885075f, -0.18375558f, -0.00218705f, -0.00663030f, 0.10863221f, -0.05230317f, 0.02648579f, 
    0.10114582f, 0.05060013f, -0.01136656f, -0.25953853f, 0.06580153f, -0.08258895f, -0.07700667f, -0.02614260f, 
    0.04301829f, 0.02679201f, -0.07777119f, 0.06090879f, -0.05627185f, 0.13933994f, -0.07061650f, -0.11883545f, 
    -0.03104909f, -0.07635514f, -0.03370630f, -0.05060630f, 0.17006518f, 0.12364825f, 0.08973849f, -0.03053005f, 
    0.02242959f, -0.05947255f, 0.00100978f, 0.03868422f, 0.05907137f, 0.07883754f, -0.03240642f, 0.00348708f, 
    -0.05154405f, -0.07957446f, -0.10529626f, 0.07844518f, 0.10237721f, 0.00147552f, -0.09875145f, 0.08054942f, 
    0.05815985f, 0.07496028f, -0.08179071f, 0.10410000f, 0.20438418f, -0.04421116f, -0.07686672f, -0.10299666f, 
    0.02892389f, -0.04927868f, -0.01618981f, 0.06968594f, -0.10778101f, -0.07479394f, -0.01737181f, 0.04473417f, 
    0.09349860f, 0.03414966f, -0.20864764f, 0.07902376f, 0.32302743f, 0.22283931f, 0.28032458f, 0.22572948f, 
    -0.00375599f, -0.05570520f, -0.04826608f, 0.04276945f, 0.03896864f, 0.08211491f, 0.15758209f, -0.07962851f, 
    -0.02334298f, -0.02131444f, -0.07561608f, -0.05928414f, -0.00628019f, 0.04224778f, 0.01100966f, -0.01627767f, 
    0.01832683f, -0.04408608f, -0.02319894f, 0.04801296f, -0.02663618f, 0.04744188f, 0.00631499f, 0.05641703f, 
    -0.00153454f, -0.00148664f, -0.07493664f, 0.03646409f, 0.01252416f, 0.01773943f, -0.07596991f, -0.00694119f, 
    -0.07550246f, -0.02654591f, -0.04188061f, -0.00163438f, 0.05075499f, 0.00844825f, -0.01270261f, 0.01774473f, 
    -0.02489159f, 0.03434387f, -0.04182963f, -0.05950610f, -0.04992519f, -0.05497789f, -0.04093779f, 0.00703605f, 
    0.06353121f, -0.00981675f, -0.04467951f, 0.01697887f, -0.05043692f, 0.03194268f, 0.01638158f, 0.04736267f, 
    -0.00468143f, 0.06048341f, 0.01840593f, -0.04966483f, -0.02723944f, -0.03305746f, -0.00235968f, 0.00097436f, 
    0.01832164f, 0.01430064f, 0.04741276f, 0.02314300f, 0.05942541f, -0.05651679f, -0.05910402f, -0.02196822f, 
    0.04173259f, -0.04251872f, 0.05145846f, 0.03718289f, -0.06160356f, -0.06409913f, -0.05901835f, -0.06660458f, 
    0.01865605f, -0.06391948f, -0.01613988f, 0.03197065f, -0.02808604f, -0.04308743f, -0.04656973f, 0.01424900f, 
    0.03160379f, 0.02891791f, 0.05673872f, 0.03714959f, 0.05392453f, 0.00481518f, -0.05557800f, -0.01727146f, 
    -0.04835470f, -0.02148600f, 0.03113473f, -0.07821406f, 0.03185013f, 0.05733005f, 0.05523516f, 0.01052455f, 
    -0.07449327f, -0.06730192f, -0.06038112f, 0.05922711f, -0.04585792f, -0.00189933f, 0.03907146f, -0.01039638f, 
    0.02051535f, -0.02886588f, -0.05786058f, -0.02449607f, -0.00343759f, -0.06215630f, -0.04481884f, -0.01014111f, 
    -0.04377175f, -0.06286629f, -0.07418695f, -0.05316985f, 0.03542501f, -0.00492243f, -0.07383297f, -0.00365471f, 
    0.04531429f, -0.03096838f, -0.04579766f, -0.04479960f, -0.05342305f, 0.03597169f, 0.00539772f, 0.03055358f, 
    -0.00169856f, 0.04398804f, 0.01269381f, 0.04374148f, 0.04558130f, -0.06331125f, 0.05050479f, -0.04364583f, 
    -0.05169691f, -0.04803931f, -0.06340922f, 0.02619200f, 0.01218378f, -0.01432369f, -0.00434107f, 0.02657159f, 
    -0.00392107f, 0.03002865f, -0.03256828f, -0.05683812f, 0.02089608f, -0.04210060f, 0.01234181f, 0.02228894f, 
    -0.04667870f, -0.03442864f, -0.07099348f, -0.01689052f, -0.00248673f, 0.02533383f, -0.03579758f, -0.06057012f, 
    0.02053123f, -0.00736772f, -0.04265255f, -0.05993503f, 0.06303702f, -0.04646808f, -0.01275035f, -0.07024287f, 
    -0.05719835f, 0.03784344f, -0.07552958f, -0.04968770f, -0.00495151f, 0.03416380f, -0.00878671f, 0.00671636f, 
    0.03268576f, 0.05735019f, -0.03763332f, 0.03755445f, 0.05993773f, -0.01922858f, 0.04868736f, 0.00311200f, 
    0.05927391f, -0.02868165f, 0.06096531f, 0.03900229f, 0.05227819f, -0.03389889f, -0.02438415f, -0.00222978f, 
    -0.05095804f, -0.07841823f, -0.05760646f, 0.03517418f, 0.01502423f, 0.00329562f, -0.04784606f, -0.06556436f, 
    0.01062165f, 0.03290498f, 0.02671540f, -0.00208435f, -0.00256683f, -0.03186645f, 0.01814435f, -0.07360561f, 
    -0.01304044f, -0.03982975f, -0.02331689f, 0.05304007f, -0.05305672f, -0.07668944f, -0.05646903f, 0.01753907f, 
    -0.04440722f, -0.01450090f, -0.02248680f, 0.05292845f, 0.00545443f, -0.02133766f, -0.04437599f, 0.03639733f, 
    -0.06524936f, -0.03393597f, 0.01561671f, -0.03460489f, -0.00318555f, -0.00904947f, 0.05232063f, 0.04871644f, 
    0.04945071f, 0.01623464f, -0.00823899f, -0.05875639f, -0.00262292f, 0.01571819f, 0.04152605f, 0.05658462f, 
    0.02879297f, 0.02809258f, 0.05770599f, 0.01243678f, -0.08660391f, 0.05048048f, -0.01592625f, -0.06088228f, 
    0.01379373f, -0.01926130f, 0.05939355f, -0.06740928f, -0.06562985f, -0.03536823f, -0.06007854f, -0.07125191f, 
    0.05376473f, 0.02924430f, -0.02788538f, 0.05136173f, -0.02000526f, 0.01954049f, 0.01097463f, -0.04152351f, 
    -0.05518659f, -0.00610575f, -0.00931051f, 0.02808080f, 0.03059606f, -0.02849647f, -0.00380153f, -0.00949007f, 
    -0.05211240f, 0.01565288f, -0.04578116f, -0.07626598f, -0.01628594f, 0.05850645f, -0.02456195f, 0.01889766f, 
    -0.06826793f, 0.03564339f, -0.05136861f, 0.00490620f, -0.02609920f, -0.01155710f, 0.00947990f, -0.02651376f, 
    -0.04911293f, 0.05485653f, -0.05161368f, 0.05173901f, -0.04238436f, -0.05745127f, 0.04860550f, 0.04940590f, 
    0.03946652f, -0.01505578f, -0.02622344f, 0.01161846f, 0.01471885f, -0.03568779f, 0.03769346f, -0.07258563f, 
    -0.00278844f, 0.00079326f, 0.00098725f, -0.00883021f, -0.02642342f, -0.00880166f, 0.05328285f, -0.00037243f, 
    0.01063141f, -0.00532554f, -0.06670777f, -0.00378776f, 0.02571177f, -0.04473165f, -0.01866277f, 0.04148049f, 
    0.00311524f, -0.07902902f, -0.00542480f, 0.00192405f, -0.00239457f, -0.03498786f, 0.00881060f, 0.01534973f, 
    -0.05538072f, -0.07502284f, -0.01775978f, 0.03530028f, -0.00891817f, 0.04690941f, 0.03140831f, 0.00852735f, 
    0.04932362f, 0.00151607f, -0.08411680f, 0.04871415f, -0.05799985f, -0.07972067f, -0.01136224f, -0.05249931f, 
    -0.01388842f, -0.06115024f, 0.03804690f, -0.07372926f, -0.02150248f, -0.01356495f, 0.02785925f, 0.05166230f, 
    -0.01569255f, 0.03743742f, -0.04545141f, -0.01314049f, -0.01898295f, -0.01104386f, -0.05112205f, 0.04670803f, 
    0.01072441f, -0.00719535f, 0.01535139f, -0.00374231f, 0.06694666f, -0.04788710f, -0.07305456f, -0.04633079f, 
    -0.05123070f, 0.05127424f, 0.06246514f, 0.00437031f, -0.03948556f, -0.03437691f, -0.08052236f, 0.03623199f, 
    -0.02766613f, 0.01067479f, -0.04449772f, -0.07719316f, 0.01863760f, -0.05916667f, -0.02629812f, -0.00303558f, 
    -0.00812125f, 0.01590794f, 0.03660844f, -0.03667521f, -0.03143906f, 0.04049551f, -0.00766989f, -0.07532860f, 
    -0.01350274f, 0.04074315f, -0.02569330f, 0.02439031f, -0.05471555f, 0.03064900f, 0.02832619f, -0.02904182f, 
    -0.04551071f, -0.02086870f, -0.04960601f, -0.03476039f, -0.07394230f, -0.04631676f, -0.04080709f, 0.00430695f, 
    0.04841643f, -0.06655017f, -0.01393579f, -0.02098473f, -0.01438418f, 0.04661119f, -0.05907442f, -0.07431158f, 
    0.00817528f, -0.03806957f, -0.05053294f, -0.00088750f, -0.04007233f, 0.02896164f, -0.03499002f, 0.01331793f, 
    0.03769539f, -0.00813642f, -0.03880265f, -0.03208750f, 0.00583275f, 0.05080495f, 0.00152456f, -0.01021056f, 
    0.04064029f, -0.03867499f, -0.07242726f, -0.04630205f, 0.05432462f, -0.04565593f, -0.04017342f, 0.05740078f, 
    -0.06479439f, -0.01845718f, -0.02624255f, -0.03341421f, -0.01553512f, -0.06670599f, -0.04956354f, -0.03995879f, 
    -0.00783610f, -0.01074815f, 0.05645405f, -0.03050748f, -0.04943444f, -0.02574672f, -0.01009833f, -0.01071095f, 
    0.04911898f, 0.00513825f, 0.00695804f, -0.05482812f, -0.04844121f, 0.03671320f, 0.00874711f, 0.04851181f, 
    -0.03582095f, -0.01163265f, 0.01835356f, 0.05417429f, -0.00922071f, -0.01763887f, -0.03329781f, -0.07647898f, 
    -0.00627685f, -0.01097572f, -0.01727717f, -0.07049325f, -0.08486944f, -0.01973934f, 0.03327298f, -0.02226585f, 
    0.02113963f, -0.04319857f, -0.05298475f, 0.04460886f, 0.06779024f, -0.00192447f, -0.05064256f, -0.01922633f, 
    0.03334485f, -0.07386654f, 0.02340437f, 0.00708968f, -0.04998471f, 0.01627916f, 0.00722626f, -0.01426531f, 
    0.01281855f, 0.02090110f, 0.05258601f, -0.06292870f, 0.00880356f, -0.05007078f, 0.00280111f, 0.02691090f, 
    -0.02240129f, 0.02798504f, -0.04190775f, 0.03231415f, -0.00257460f, -0.05146458f, -0.05947674f, 0.05447998f, 
    -0.05060755f, -0.07835075f, -0.00007456f, -0.01530500f, -0.00950062f, -0.03558956f, 0.04345929f, -0.00485705f, 
    0.05505243f, 0.01307048f, -0.03437596f, 0.04138944f, -0.04354743f, -0.00685217f, -0.05726981f, 0.03704893f, 
    0.05440587f, 0.05680258f, -0.07236207f, -0.03345061f, -0.06475624f, 0.05125661f, -0.02517127f, -0.03331928f, 
    0.01160639f, -0.02640203f, 0.00998719f, -0.03519474f, -0.01837382f, -0.02953737f, 0.04956296f, 0.05405250f, 
    0.04956549f, 0.04217524f, 0.01476523f, -0.06728605f, 0.04053033f, -0.05712598f, -0.03110610f, -0.06316757f, 
    -0.05042573f, 0.07598465f, 0.05581009f, -0.00290901f, 0.06382986f, -0.06954716f, 0.04624708f, 0.05062361f, 
    -0.02354664f, -0.06207144f, -0.02391836f, 0.03598838f, -0.00472508f, -0.00779439f, 0.00899720f, -0.03262358f, 
    0.02953868f, 0.00053089f, -0.06406584f, -0.01545635f, -0.04376917f, 0.05961737f, 0.04676144f, 0.05173939f, 
    0.12908968f, 0.01788332f, -0.16135953f, 0.07177319f, 0.13042511f, 0.01581900f, 0.17088394f, 0.04215053f, 
    0.14847487f, 0.12628236f, -0.01187433f, -0.07187960f, 0.51004618f, -0.18735299f, 0.01222252f, -0.02048434f, 
    -0.00628249f, -0.01618446f, -0.03655639f, 0.09979877f, 0.04691885f, 0.01575723f, 0.08283394f, 0.07050753f, 
    0.00865212f, -0.14744627f, 0.09987091f, -0.05256034f, 0.11818075f, 0.08855536f, 0.09718341f, 0.04256399f, 
    0.02293076f, 0.09126676f, 0.05575569f, 0.20724851f, -0.15424949f, 0.18577954f, -0.12524854f, 0.00912216f, 
    -0.11181973f, 0.04213959f, -0.04555092f, 0.00142515f, -0.02781489f, 0.04052487f, 0.07643158f, -0.02626722f, 
    0.03045159f, 0.23196934f, -0.16439444f, 0.10261809f, 0.03311807f, -0.10097130f, 0.04114777f, 0.10404969f, 
    0.02532051f, 0.01248625f, 0.08555336f, -0.04286990f, -0.31297845f, 0.15711620f, 0.06291215f, 0.05366581f, 
    -0.12930284f, -0.17375508f, 0.04385272f, -0.09003196f, 0.01945396f, 0.00826432f, -0.04194359f, -0.01416963f, 
    0.04243449f, -0.11599660f, 0.06201987f, 0.20800050f, 0.11613058f, 0.01275246f, 0.22021914f, -0.03194142f, 
    0.04093749f, -0.04891134f, 0.02428083f, 0.02195352f, -0.08328796f, -0.17433594f, -0.24440031f, 0.05320834f, 
    0.25661615f, -0.13579869f, -0.04979395f, 0.02231717f, 0.04250273f, 0.04745749f, 0.00951544f, -0.07525300f, 
    0.21806814f, -0.05850926f, 0.00820440f, -0.05374951f, -0.00212265f, -0.00331232f, -0.03925323f, -0.04999107f, 
    0.08845042f, 0.09870523f, 0.10302125f, 0.06589465f, -0.22563577f, -0.10246548f, -0.00128032f, -0.00516779f, 
    0.04597999f, -0.08666075f, -0.07399143f, 0.04399478f, 0.02116598f, 0.11852446f, -0.02547675f, 0.01428321f, 
    -0.06974006f, 0.11544099f, 0.18900293f, -0.15207630f, 0.19195411f, 0.16755098f, 0.02762303f, -0.09253168f, 
    0.05915198f, 0.07324102f, 0.00289133f, 0.06396543f, 0.07759127f, 0.15033998f, -0.06556948f, 0.02971477f, 
    0.04962424f, -0.03051146f, -0.02688080f, 0.07065079f, -0.01940557f, -0.04103252f, 0.06064034f, 0.09456085f, 
    -0.55153745f, 0.22137925f, -0.12593128f, -0.21519890f, 0.08921788f, 0.07661001f, -0.08471894f, -0.10912495f, 
    -0.06938470f, 0.01452816f, -0.00488262f, 0.00123612f, -0.05327512f, -0.05860557f, -0.12189095f, 0.03490215f, 
    -0.03538343f, -0.01673931f, 0.06852615f, 0.27958375f, 0.02889282f, -0.01965041f, -0.02203450f, 0.00814901f, 
    -0.21805331f, -0.32996032f, -0.18639688f, -0.06195061f, 0.13261485f, 0.07887917f, 0.08789507f, 0.10744657f, 
    -0.01554520f, -0.09596045f, -0.00550640f, 0.13311420f, 0.31531319f, 0.04850114f, 0.03201798f, 0.17417128f, 
    -0.15796746f, -0.00232850f, 0.05130662f, 0.07822397f, 0.03411822f, -0.09995755f, 0.07980940f, -0.18658504f, 
    -0.09241428f, 0.09179711f, 0.01541458f, -0.07368787f, -0.10353515f, -0.04329423f, -0.18726514f, 0.08174046f, 
    0.10791410f, 0.00095491f, 0.08783037f, 0.20945460f, -0.26872662f, 0.10434736f, 0.16505219f, 0.21698424f, 
    0.07020105f, -0.07787190f, -0.13878684f, 0.09384461f, 0.00734189f, 0.11189036f, 0.03375268f, 0.06259842f, 
    0.15830682f, 0.20284490f, -0.00102469f, -0.26046985f, 0.15442942f, -0.10723837f, 0.13492516f, -0.01239182f, 
    -0.10444243f, 0.12066793f, 0.05699712f, 0.03259886f, 0.21421975f, 0.05804391f, 0.00849865f, 0.06204850f, 
    -0.10617744f, 0.11089406f, -0.14583576f, -0.05667539f, 0.05540277f, -0.02147947f, 0.02026364f, 0.05455227f, 
    0.03995919f, -0.02385471f, 0.22205918f, 0.08560171f, 0.06582361f, 0.06221882f, 0.06390285f, 0.05274186f, 
    0.06827550f, 0.07361010f, -0.01632441f, 0.07283048f, 0.08346371f, -0.00892591f, -0.12221050f, -0.06766778f, 
    0.07362045f, 0.09302375f, 0.03537472f, 0.00864789f, 0.07232881f, -0.01168149f, -0.02261677f, 0.03026302f, 
    0.05923770f, 0.23282270f, -0.25512594f, 0.05646893f, 0.00481477f, 0.14297539f, -0.09431984f, -0.06248790f, 
    -0.03958093f, 0.01578026f, 0.07215481f, 0.04685032f, -0.03265670f, -0.04316896f, 0.00831500f, 0.03377006f, 
    0.00536914f, 0.03678806f, 0.02795592f, -0.02711686f, -0.04218759f, 0.08206033f, 0.02702860f, 0.18732779f, 
    -0.00719221f, 0.13147202f, -0.10295970f, 0.12466179f, 0.01501282f, -0.12400629f, -0.05199141f, -0.00677726f, 
    0.07701708f, 0.12972295f, -0.18576926f, -0.00550221f, -0.02586123f, -0.06747191f, 0.18691115f, 0.15528543f, 
    -0.09275404f, -0.09994507f, -0.02674656f, -0.03945417f, 0.04823789f, 0.02971794f, 0.01000544f, -0.03705641f, 
    0.28568164f, 0.24190363f, -0.25474906f, 0.11108643f, 0.06806265f, 0.01179214f, 0.01710756f, 0.09962512f, 
    0.04762545f, 0.01112763f, 0.01198981f, 0.06060300f, 0.28819901f, -0.03294349f, 0.02396873f, 0.28807360f, 
    -0.01567496f, -0.02366381f, -0.05577942f, 0.07811718f, 0.00467645f, 0.11095379f, 0.05118525f, 0.09886312f, 
    0.02234099f, 0.04158320f, 0.22368942f, -0.17035955f, 0.04517223f, -0.06912639f, 0.07697590f, 0.01072389f, 
    0.08853039f, 0.04162471f, 0.04021381f, 0.04697034f, -0.20885974f, -0.03406667f, -0.05757731f, 0.04559251f, 
    -0.03653196f, 0.06749730f, -0.03647764f, 0.05371261f, 0.08156013f, -0.09580088f, 0.05232681f, -0.06739134f, 
    0.21778992f, 0.13300568f, -0.07625353f, -0.03963951f, -0.08870076f, -0.09696797f, -0.04348782f, -0.04528607f, 
    -0.04279380f, 0.05222155f, -0.08064552f, -0.07514269f, -0.15922181f, -0.09558159f, 0.03503079f, -0.05133633f, 
    -0.02940446f, 0.14605665f, -0.02378125f, -0.02776407f, 0.02230002f, -0.14521487f, 0.13560006f, 0.02268184f, 
    -0.08890533f, 0.15443085f, 0.11568347f, 0.17144291f, -0.15448929f, -0.09059079f, 0.04537612f, -0.01181859f, 
    0.01100155f, 0.11582370f, -0.02932068f, 0.03061138f, 0.47483817f, 0.25171438f, 0.11552964f, -0.09431387f, 
    0.13678610f, 0.06258474f, 0.01399897f, 0.03711930f, 0.12714529f, -0.06088004f, 0.06124981f, 0.00237786f, 
    -0.03721874f, -0.23032176f, -0.15511288f, 0.16728796f, -0.05386649f, 0.01015132f, 0.01418479f, 0.01662765f, 
    -0.03718217f, 0.03568737f, -0.00424269f, -0.02237579f, 0.15790729f, -0.06799665f, -0.13247216f, -0.13274068f, 
    -0.01453788f, 0.07612742f, -0.07261203f, 0.05699722f, -0.04123524f, 0.00732549f, -0.09324747f, 0.05077310f, 
    -0.17840849f, 0.15315987f, 0.13144180f, 0.07028333f, 0.03658663f, -0.10095818f, 0.03388944f, 0.02433702f, 
    -0.03262583f, -0.08249851f, 0.00496094f, -0.04041849f, -0.26179269f, 0.20682178f, 0.10233626f, -0.04182888f, 
    0.01420502f, -0.00311796f, 0.04519884f, 0.10706231f, -0.00137220f, -0.02291853f, -0.06680215f, -0.00112744f, 
    0.14416245f, 0.12184939f, 0.01800365f, -0.08501476f, -0.12106941f, 0.02809487f, -0.03681663f, 0.04561790f, 
    -0.03683461f, 0.01314096f, -0.04340173f, 0.16375136f, 0.31031966f, -0.09816916f, 0.09330527f, 0.54870206f, 
    -0.02805543f, 0.06325556f, -0.07900206f, -0.06791406f, 0.15518422f, -0.00916102f, 0.01845675f, 0.03179226f, 
    0.09746607f, 0.16762552f, -0.03985796f, -0.02961263f, 0.01330054f, -0.02230371f, 0.01112816f, 0.08566625f, 
    0.04815651f, -0.02207286f, 0.02715637f, -0.03308499f, -0.22173327f, 0.24341932f, 0.05306531f, 0.03296652f, 
    -0.15008689f, 0.03173577f, 0.05605510f, -0.08175956f, -0.05010506f, -0.05199958f, -0.15011603f, -0.04016261f, 
    0.43291146f, 0.15783238f, -0.22653455f, -0.20129922f, 0.01024517f, 0.06467754f, -0.05307220f, 0.04217400f, 
    0.08395709f, -0.03580619f, 0.07564508f, -0.11926924f, -0.05912729f, 0.06466962f, 0.10585205f, 0.20804898f, 
    -0.15082255f, 0.08370746f, -0.00248752f, 0.03928041f, 0.04869717f, 0.07364351f, -0.08555058f, 0.09692321f, 
    -0.62273079f, 0.05180977f, -0.01788028f, 0.02479959f, 0.05870602f, -0.03842441f, -0.08657862f, -0.03983947f, 
    -0.11617139f, 0.07561023f, -0.04182798f, 0.08530522f, -0.27603647f, 0.11336577f, 0.18029575f, 0.05496456f, 
    0.04186196f, 0.02413792f, 0.05251773f, 0.08405968f, 0.04561729f, -0.01881186f, -0.01756008f, -0.00656336f, 
    0.16268536f, 0.07678393f, 0.08177521f, 0.03502930f, 0.03035904f, -0.08371465f, -0.02894815f, -0.08535903f, 
    -0.08663676f, 0.00677037f, 0.11799621f, -0.03444488f, -0.29734376f, 0.01335128f, 0.07108152f, -0.02171640f, 
    0.16101865f, -0.05156353f, 0.02925551f, -0.00755613f, 0.00915640f, -0.07324345f, 0.08500068f, -0.10379029f, 
    0.07558330f, -0.00348523f, 0.07534124f, 0.12147988f, 0.04379052f, 0.12401935f, -0.09576598f, -0.00743055f, 
    -0.10869680f, -0.03374624f, 0.00934109f, 0.06891001f, -0.24199021f, 0.15151227f, 0.06065987f, 0.12747125f, 
    0.01439777f, -0.01853019f, -0.01154487f, 0.21692744f, 0.05629275f, 0.06282606f, 0.09868692f, -0.10378433f, 
    0.22541542f, 0.12342831f, 0.06527993f, 0.05894306f, 0.03779722f, -0.16479534f, 0.05535053f, 0.01334180f, 
    0.00371128f, -0.08329287f, 0.01923437f, 0.10242935f, 0.14417472f, -0.24038640f, -0.07459519f, -0.27210334f, 
    0.08530730f, -0.00924599f, 0.01604624f, -0.04013119f, 0.04314402f, -0.04398773f, 0.10594931f, 0.00146632f, 
    -0.20452254f, 0.01873185f, 0.08597007f, -0.17224433f, 0.00523848f, 0.00578613f, -0.05542879f, 0.11089493f, 
    0.07511283f, 0.01060621f, 0.03083275f, 0.13885140f, 0.27632260f, -0.18575224f, 0.13827337f, -0.12208958f, 
    0.04432436f, 0.16934483f, -0.07020701f, -0.00213405f, 0.09486417f, -0.09222441f, 0.01617779f, 0.01109271f, 
    -0.10396381f, -0.14410922f, -0.12635118f, -0.07996871f, -0.00980714f, 0.01722336f, 0.03646738f, 0.04341586f, 
    0.00776339f, 0.04483579f, 0.04190663f, 0.05841966f, -0.01094474f, -0.15577652f, 0.04096559f, -0.28102398f, 
    -0.07833325f, -0.00151229f, -0.02050090f, 0.09294234f, -0.03604364f, -0.00633565f, -0.00286358f, 0.10347258f, 
    -0.10297979f, 0.10806191f, 0.06968223f, 0.25137132f, 0.05550097f, 0.02162362f, 0.12863095f, -0.00846444f, 
    -0.03198366f, 0.17808346f, -0.02005362f, 0.05267733f, 0.11276332f, 0.02998742f, -0.07425390f, -0.06318513f, 
    -0.04456081f, -0.01970138f, 0.00830700f, 0.04599244f, 0.06246648f, -0.04424992f, 0.04835164f, 0.05539956f, 
    -0.10835247f, -0.01957558f, 0.09464110f, 0.18786187f, 0.02519514f, -0.06846646f, 0.03519747f, -0.10853446f, 
    -0.02908144f, -0.02594453f, 0.06265885f, 0.09768319f, 0.22645345f, -0.08622126f, 0.02206249f, 0.11108850f, 
    0.03059820f, 0.03006196f, -0.01040681f, 0.16918069f, 0.07006232f, 0.12522675f, 0.07379844f, 0.08189005f, 
    -0.08742544f, 0.26689121f, 0.24105643f, 0.19724944f, -0.04245995f, -0.14567661f, 0.05648657f, 0.06831510f, 
    0.01401811f, -0.02622743f, -0.03492055f, -0.01352914f, -0.24723327f, 0.08074237f, -0.06837145f, -0.11827400f, 
    -0.00923902f, 0.04467055f, -0.04498054f, -0.06934165f, -0.00036897f, -0.02427789f, -0.02683444f, 0.02804612f, 
    -0.08087072f, -0.12641816f, -0.01862345f, -0.21212944f, 0.02352752f, 0.01334311f, -0.02050851f, -0.13261624f, 
    0.10862530f, -0.05113677f, -0.20882955f, 0.08919164f, 0.03389444f, 0.08083940f, -0.17211099f, -0.04985715f, 
    0.00732560f, 0.09779344f, 0.16210014f, 0.00192586f, 0.02950813f, 0.00523394f, 0.05653377f, 0.17823602f, 
    -0.02181597f, -0.05038513f, 0.09892460f, 0.33052614f, -0.04619758f, 0.12182433f, -0.12768194f, -0.21467221f, 
    0.02303220f, -0.05268908f, -0.00183627f, 0.05006789f, 0.09917453f, 0.02201249f, -0.13911912f, 0.01691424f, 
    -0.09290504f, -0.00437921f, 0.07832398f, -0.01147027f, -0.13001150f, -0.02874093f, -0.01927079f, 0.00148376f, 
    -0.05881328f, 0.03458434f, -0.00647448f, 0.19876844f, -0.03986855f, 0.17574474f, 0.06403250f, -0.03066753f, 
    -0.02486781f, -0.03322591f, 0.00052612f, -0.14393978f, 0.05353275f, 0.12472232f, 0.27979717f, 0.28618613f, 
    0.00845594f, 0.02571067f, 0.00995661f, 0.15832113f, 0.02008223f, 0.09695616f, -0.05323353f, 0.14602628f, 
    0.11890308f, -0.14900295f, 0.06863547f, -0.03956137f, -0.02124884f, -0.06324922f, 0.04441319f, -0.18507986f, 
    0.04884329f, 0.04013176f, 0.03754577f, 0.00853340f, 0.21832040f, -0.12797570f, 0.00239681f, 0.09775096f, 
    0.03437292f, -0.00199181f, 0.04494027f, 0.03921698f, -0.04850918f, -0.04983237f, 0.03792436f, 0.09399894f, 
    -0.18923266f, 0.12270172f, 0.22080866f, -0.03196162f, -0.03528728f, 0.04453890f, -0.10499711f, 0.05942163f, 
    0.01971614f, 0.07299762f, -0.01741013f, -0.00939541f, -0.17321263f, -0.02532825f, -0.06478025f, 0.07954366f, 
    -0.09296834f, 0.15374228f, 0.13348602f, -0.09035035f, -0.10730812f, 0.10264691f, -0.02803771f, 0.03593482f, 
    -0.00778852f, 0.02070384f, 0.19467138f, 0.02497905f, 0.12198702f, -0.06177579f, 0.08167776f, 0.03995555f, 
    0.06573032f, 0.04146955f, 0.02506278f, -0.12311406f, -0.06985760f, 0.26632151f, -0.20602374f, -0.27804360f, 
    0.08366554f, 0.03870723f, 0.08076719f, 0.05699534f, 0.04169943f, -0.01481354f, -0.00252597f, -0.06256030f, 
    -0.14771852f, -0.20242536f, 0.12759082f, 0.11517244f, -0.13526350f, 0.12545207f, 0.11526861f, 0.06021268f, 
    -0.15328212f, -0.06578051f, -0.02765264f, 0.02215527f, -0.12205236f, 0.20163524f, 0.06870653f, -0.15247746f, 
    0.07719407f, -0.17943031f, 0.03820246f, 0.03332170f, 0.03962112f, -0.04845813f, 0.04036279f, -0.10526203f, 
    0.32424256f, -0.11740562f, 0.13682754f, -0.06014054f, -0.04128660f, 0.07685749f, -0.03633756f, 0.11147136f, 
    0.06060215f, 0.11445662f, -0.06670024f, -0.04236663f, -0.01111268f, 0.00832062f, 0.01431537f, -0.05071242f, 
    0.00188907f, 0.00994639f, -0.03407120f, 0.02065436f, -0.00349045f, 0.01848337f, 0.03275938f, 0.00308775f, 
    0.10722733f, 0.29770777f, 0.06105988f, -0.13391656f, -0.12725410f, 0.02020751f, 0.00816536f, 0.07204032f, 
    0.02257767f, -0.04281036f, 0.04599101f, 0.03437507f, -0.29097489f, 0.10360872f, 0.07321257f, -0.05002958f, 
    0.07704682f, -0.07976716f, -0.04383612f, -0.01065648f, 0.02237600f, 0.05064616f, -0.00667996f, -0.02844014f, 
    0.10009773f, -0.11253972f, 0.11411802f, 0.01089587f, 0.00711883f, 0.07442794f, 0.11412098f, -0.11419141f, 
    -0.05283742f, -0.07950003f, -0.00793420f, 0.08969924f, 0.01677067f, -0.19023149f, -0.20249046f, -0.21771263f, 
    0.00652366f, 0.14849713f, -0.11177028f, -0.01289666f, 0.03249850f, 0.12997276f, -0.09588797f, -0.17160378f, 
    0.11944903f, -0.23390633f, 0.08107396f, 0.11692760f, -0.05774476f, -0.15082501f, -0.07495519f, -0.05229085f, 
    0.03734293f, 0.02516150f, -0.10017453f, 0.09823597f, 0.06517655f, -0.00479809f, 0.12432428f, -0.06707336f, 
    0.09194113f, -0.02226575f, 0.00809208f, 0.14335893f, -0.03184912f, -0.13510010f, -0.08675313f, -0.02464880f, 
    0.04459136f, 0.15941043f, -0.01006666f, -0.22849233f, -0.05407464f, -0.07477082f, -0.05230044f, 0.05247119f, 
    0.06618632f, 0.05860418f, 0.15745927f, 0.10976734f, 0.14108771f, -0.10055599f, -0.09428809f, -0.03057552f, 
    -0.04057226f, -0.00378961f, -0.07878351f, 0.09212042f, 0.12250373f, -0.02985904f, -0.01280960f, -0.15657291f, 
    -0.15229519f, -0.16240042f, 0.20793526f, -0.04041127f, 0.08521806f, 0.08222975f, -0.01309197f, -0.01861363f, 
    -0.04403709f, -0.15607904f, 0.10103694f, 0.03085538f, -0.08369662f, 0.03886937f, -0.01462329f, 0.00443068f, 
    0.02908867f, -0.02224186f, 0.00402565f, -0.04672204f, 0.05162914f, 0.08271584f, 0.05693161f, 0.11906306f, 
    -0.21213783f, 0.01820834f, 0.05384114f, -0.14772531f, 0.08064695f, 0.04593832f, 0.12277725f, 0.04263489f, 
    -0.06230426f, 0.13219902f, -0.02873557f, -0.07761325f, 0.04517558f, 0.11376055f, 0.01523391f, 0.07758439f, 
    0.08371679f, 0.09579882f, 0.03172991f, 0.03882517f, 0.05502507f, -0.05941172f, 0.15366198f, 0.04915368f, 
    -0.24584986f, -0.17943496f, 0.11430883f, -0.15297644f, 0.16601376f, -0.07100785f, 0.04404536f, -0.06177100f, 
    -0.09839093f, -0.00145422f, 0.13256809f, 0.10951294f, -0.10159761f, 0.14231919f, 0.00637864f, -0.36573794f, 
    0.00336187f, 0.04617890f, 0.02209491f, -0.00332110f, 0.17042013f, 0.15722623f, 0.20614322f, 0.05740327f, 
    0.07272652f, -0.15819912f, -0.13841295f, 0.24888875f, -0.00505607f, 0.00567401f, -0.07639877f, 0.05089218f, 
    -0.01908223f, -0.00223363f, -0.07376616f, 0.02963483f, 0.22954857f, 0.11646058f, -0.04914701f, 0.06383996f, 
    0.09855819f, 0.06362949f, -0.00929483f, -0.01301225f, 0.11463326f, -0.00528521f, -0.10059049f, 0.04919501f, 
    0.15527001f, 0.01236550f, 0.03099915f, 0.10504022f, 0.13815373f, -0.03902318f, -0.01175517f, -0.04254144f, 
    0.01685272f, 0.07396989f, -0.07635307f, 0.06576110f, 0.09810925f, 0.10487171f, 0.03371309f, 0.11325836f, 
    0.11282796f, -0.08654424f, 0.02805028f, 0.07934588f, -0.00652407f, 0.06570268f, 0.04729464f, 0.02591709f, 
    0.16393974f, -0.00917115f, -0.16209732f, 0.16499840f, -0.07980353f, 0.07758658f, 0.07366400f, 0.03925681f, 
    0.21821611f, 0.10317220f, 0.01309345f, 0.08573542f, 0.43772241f, -0.08608608f, 0.01709601f, 0.02831937f, 
    0.05207605f, 0.02713113f, 0.00174338f, 0.08965232f, 0.06642175f, -0.02789013f, 0.01274590f, 0.04942307f, 
    -0.06794618f, -0.21204700f, 0.18791504f, 0.01262480f, -0.02805435f, 0.10387821f, 0.08185189f, 0.02234260f, 
    -0.09265361f, -0.05730193f, 0.04835668f, 0.05335306f, -0.10843652f, -0.09731769f, -0.14542454f, 0.12211955f, 
    -0.11521105f, 0.14279711f, 0.04530936f, -0.04968689f, -0.04188466f, 0.01056868f, 0.00490584f, 0.00802915f, 
    -0.09583469f, 0.22033544f, -0.02247201f, 0.00252055f, -0.07639457f, -0.04755459f, 0.14241511f, 0.06142034f, 
    -0.01814633f, 0.01185963f, -0.05483518f, -0.03540049f, -0.37099627f, 0.00994048f, 0.15084597f, 0.05806816f, 
    -0.07185034f, -0.02038752f, 0.04089973f, -0.02477579f, 0.00520008f, 0.04755244f, 0.07936008f, 0.03662594f, 
    0.02439054f, -0.20872572f, -0.09276691f, 0.14638050f, 0.06761476f, 0.02754636f, 0.06803289f, -0.04211740f, 
    0.02221028f, -0.05475892f, 0.01834357f, -0.03108236f, 0.05216622f, 0.02731420f, -0.01035867f, 0.12303626f, 
    -0.03123355f, -0.01683429f, 0.04561414f, 0.03018011f, 0.03946947f, 0.08209259f, -0.02555080f, 0.05374431f, 
    0.21922639f, -0.01292232f, 0.04710815f, 0.11766949f, 0.03229834f, -0.06046918f, -0.00815666f, 0.03333871f, 
    -0.03069546f, 0.08731215f, 0.05544525f, -0.04159450f, -0.24355565f, 0.09171707f, 0.02355247f, -0.17848055f, 
    0.00424878f, 0.01746329f, 0.01819218f, 0.06966041f, 0.05639227f, -0.07886866f, -0.08370674f, 0.03494026f, 
    0.00220316f, 0.05336648f, 0.13312870f, 0.04293512f, 0.00384269f, 0.12002052f, 0.14864781f, -0.06637423f, 
    0.06139367f, 0.08347937f, -0.01033147f, 0.08993095f, 0.00847158f, 0.11614133f, 0.06238784f, 0.19680367f, 
    0.06343341f, 0.14726612f, 0.03600097f, 0.08171760f, -0.13243073f, 0.02285894f, 0.08243214f, 0.05316326f, 
    -0.75252759f, 0.33718494f, -0.02893017f, -0.28047603f, 0.11824568f, 0.00763111f, -0.09405681f, 0.01681549f, 
    -0.05476342f, -0.02964349f, -0.02921876f, 0.02623152f, -0.37724873f, 0.03101311f, -0.06566814f, -0.03797539f, 
    -0.05648883f, -0.00338246f, -0.01071122f, 0.13960099f, -0.07298093f, 0.02276111f, -0.08620336f, 0.02108773f, 
    -0.00723274f, -0.06615957f, -0.00267391f, -0.08266526f, 0.04988797f, 0.11840096f, 0.06022125f, -0.03613802f, 
    -0.00713306f, -0.00662282f, 0.04053739f, 0.10271897f, -0.22672082f, -0.06430665f, -0.01766835f, 0.14066677f, 
    0.01677788f, -0.01701551f, 0.05492159f, 0.02047814f, 0.05726580f, -0.04527982f, 0.10610215f, -0.13309036f, 
    -0.01386209f, 0.05173696f, 0.02371356f, -0.00786538f, 0.00324217f, -0.01794451f, -0.00734570f, -0.02828704f, 
    0.01706588f, -0.04900392f, -0.05285334f, 0.05289759f, -0.03620389f, -0.06657308f, -0.07282697f, -0.04595909f, 
    -0.07603610f, 0.00192321f, 0.01710653f, 0.02750297f, -0.02479926f, 0.03662648f, -0.07513884f, -0.02377454f, 
    0.00647881f, 0.03839185f, -0.04601450f, -0.00067939f, 0.03886661f, 0.03721815f, -0.05359849f, -0.03249137f, 
    0.00143759f, -0.06725926f, -0.05822520f, 0.06179403f, -0.01372359f, -0.07725205f, 0.04019429f, -0.04551196f, 
    -0.04422740f, 0.04495139f, -0.01829652f, -0.00251629f, 0.02946650f, -0.01232276f, 0.05193833f, -0.01739319f, 
    0.03675063f, 0.06133769f, -0.02282756f, -0.00697218f, -0.01538946f, -0.00767447f, -0.00328412f, -0.05748690f, 
    0.02196279f, 0.00845996f, -0.03864226f, -0.06225300f, 0.01652595f, -0.06658066f, -0.06505177f, 0.06056824f, 
    -0.02531789f, 0.03297296f, 0.04963298f, -0.01731767f, -0.05653205f, -0.04915348f, -0.04344046f, 0.00987413f, 
    -0.02612052f, -0.06312224f, 0.03126841f, -0.02633114f, -0.04330823f, -0.07860025f, 0.05563521f, -0.03380906f, 
    0.05964425f, -0.07419965f, 0.00886605f, -0.02473762f, -0.01780205f, 0.05354153f, -0.00072512f, -0.00230219f, 
    -0.03540794f, -0.02506258f, -0.04043655f, -0.01700833f, -0.00708692f, -0.01222317f, 0.02629782f, -0.06654749f, 
    -0.01710278f, -0.03054271f, 0.03134436f, 0.05783455f, -0.07643031f, -0.02744915f, -0.00792907f, -0.06496406f, 
    -0.01855595f, 0.05075440f, -0.05408153f, -0.05110711f, -0.06106960f, 0.05235329f, 0.03005510f, -0.04072633f, 
    0.03651960f, -0.06149075f, -0.03948249f, 0.00636555f, 0.03299313f, -0.01853689f, 0.00012412f, -0.04296298f, 
    -0.03768032f, 0.01656312f, -0.04273642f, 0.04476745f, 0.04619284f, 0.03646009f, -0.03658339f, 0.01496639f, 
    -0.03846574f, -0.00137748f, 0.04939429f, 0.02585640f, 0.04306510f, -0.05511848f, -0.02591784f, 0.04929394f, 
    -0.04018364f, -0.03157893f, -0.05821312f, -0.00355788f, 0.04098933f, 0.01460152f, -0.01911536f, 0.02466563f, 
    0.04703554f, -0.04256288f, -0.00273000f, 0.01810900f, 0.00978769f, 0.01389826f, 0.00799811f, -0.04098428f, 
    0.06197277f, -0.04629770f, -0.06916200f, 0.03629354f, -0.02116042f, -0.04502159f, 0.00035292f, 0.00819143f, 
    -0.06154018f, 0.01342594f, -0.04248903f, 0.02890916f, 0.04410308f, -0.03967373f, -0.06297579f, -0.03964657f, 
    0.06085462f, -0.07601269f, 0.05195532f, 0.04304802f, 0.05829884f, 0.04377133f, -0.07229222f, 0.06285281f, 
    0.00113722f, 0.01119203f, -0.03151275f, 0.05623596f, -0.06400131f, -0.07107648f, -0.02261365f, 0.04450703f, 
    -0.01540130f, -0.06985220f, -0.07370713f, 0.01356395f, -0.06839664f, 0.01185281f, -0.05484432f, 0.04426014f, 
    0.12954631f, 0.16459192f, -0.07625452f, -0.02427910f, 0.07351211f, 0.04450748f, -0.06606493f, 0.10587960f, 
    0.17347510f, 0.09494404f, 0.06644155f, 0.05715523f, 0.18206771f, 0.07355899f, 0.10591513f, 0.02109502f, 
    0.04808624f, 0.00068971f, -0.07308886f, -0.08231629f, 0.02089332f, 0.01994803f, -0.06052719f, 0.22022168f, 
    0.22946577f, 0.09265266f, -0.11690787f, -0.21094202f, 0.10414010f, 0.11021007f, 0.03384990f, 0.11477403f, 
    -0.05425942f, 0.05641361f, -0.00275870f, -0.04624950f, -0.01210996f, 0.04421053f, -0.19483139f, 0.22256860f, 
    -0.16109644f, 0.06917287f, 0.07661301f, -0.16794592f, -0.03237031f, -0.02977834f, 0.16017096f, 0.02855302f, 
    -0.05535593f, 0.14891253f, 0.04308909f, 0.26274833f, 0.05434887f, -0.00384007f, 0.02653031f, 0.12501805f, 
    -0.03921783f, 0.13057198f, 0.03644022f, 0.00865794f, 0.14020720f, 0.04926717f, 0.21270463f, 0.14496541f, 
    -0.11294156f, 0.06504599f, 0.03525443f, 0.01704705f, 0.04062495f, 0.04631194f, 0.09918875f, -0.03863971f, 
    -0.00369387f, -0.08936512f, -0.28204101f, 0.10492793f, 0.02709226f, -0.01625703f, 0.03750160f, -0.02450113f, 
    0.05296637f, 0.06017907f, 0.08567981f, -0.07830480f, -0.05765797f, 0.01511653f, -0.12043311f, -0.11275434f, 
    0.05533168f, 0.06841788f, -0.00793893f, -0.02978660f, -0.06264064f, -0.03233222f, 0.01470635f, -0.04864062f, 
    0.23436508f, 0.09821255f, 0.04380649f, 0.16287960f, 0.04592812f, -0.06697386f, -0.00408119f, 0.06580328f, 
    -0.05168610f, 0.14066595f, -0.11982735f, 0.02953030f, -0.15144521f, -0.26675424f, 0.06982412f, -0.07002810f, 
    -0.07622532f, -0.02875896f, -0.06517410f, -0.01909488f, -0.01534403f, 0.03903900f, 0.01274132f, -0.07813415f, 
    -0.36929885f, 0.06032341f, -0.16235811f, 0.14464645f, 0.08369719f, 0.13493927f, -0.01420097f, 0.04240988f, 
    0.03300291f, 0.00828988f, 0.06512065f, 0.10135301f, 0.21210299f, -0.04850026f, -0.02396701f, 0.33114925f, 
    0.13652040f, 0.03744212f, 0.00456942f, 0.04868034f, -0.14864218f, 0.02727001f, -0.00998807f, 0.03071382f, 
    0.10422360f, 0.13693650f, 0.17641282f, -0.17001826f, 0.04697746f, 0.04921864f, 0.06128804f, -0.00458061f, 
    -0.02383323f, 0.06083861f, -0.02031235f, -0.05998340f, -0.15922056f, -0.09665551f, -0.15122728f, -0.05975540f, 
    -0.14093435f, 0.02856410f, 0.01116857f, 0.16970439f, -0.01317286f, -0.06528264f, -0.04366643f, -0.04042904f, 
    0.09620649f, -0.11801321f, -0.18101549f, -0.19552612f, 0.02695119f, 0.08565892f, 0.04809751f, -0.01975288f, 
    0.00437849f, 0.03818795f, 0.00472593f, -0.00735558f, 0.06563127f, 0.10073946f, 0.02131929f, 0.17979559f, 
    -0.01308852f, 0.02631850f, 0.00883634f, -0.08715653f, 0.02754375f, -0.04161990f, 0.02465580f, -0.00355829f, 
    0.14944567f, -0.20106818f, 0.11828597f, -0.15187667f, 0.00749516f, -0.05338998f, 0.12953883f, 0.03039995f, 
    -0.13388510f, 0.06937730f, -0.09156536f, -0.02314845f, -0.07881466f, 0.15642935f, -0.03162663f, -0.26527444f, 
    0.05393090f, 0.13814893f, 0.00583063f, -0.05650388f, -0.05602279f, -0.03585756f, -0.06805141f, -0.11878844f, 
    0.07192735f, -0.08078236f, -0.13766114f, 0.25485992f, -0.11578554f, 0.03606494f, -0.06215993f, -0.02693575f, 
    -0.00724254f, -0.02982202f, -0.05915520f, -0.10345681f, 0.13179062f, -0.00939150f, 0.07502739f, -0.10979137f, 
    0.06615362f, -0.08792444f, 0.13857907f, 0.05329979f, -0.10288945f, -0.05012329f, -0.05055267f, -0.03591573f, 
    -0.07070232f, 0.09413249f, -0.09858257f, -0.05875756f, -0.01123467f, 0.10754175f, -0.11227833f, 0.09519840f, 
    0.04146786f, -0.04326556f, 0.16455966f, 0.11788113f, 0.40792832f, 0.01413385f, 0.15447123f, 0.03759968f, 
    -0.09364741f, -0.06336351f, 0.04144894f, 0.04394564f, 0.06753685f, 0.04057981f, 0.06519849f, -0.04608848f, 
    -0.06905882f, -0.01809152f, 0.21358797f, -0.16947277f, -0.06345037f, -0.05026361f, 0.06606349f, -0.01413003f, 
    -0.01421329f, -0.01422875f, -0.10675810f, 0.13502029f, 0.06174718f, -0.04679436f, 0.00015110f, 0.29573196f, 
    -0.02623905f, 0.03259508f, -0.04590588f, -0.04018934f, 0.01131058f, -0.07755166f, 0.03743254f, -0.06576632f, 
    -0.00555066f, 0.15240055f, 0.00696806f, -0.13155383f, 0.00159532f, 0.13033111f, 0.06874012f, -0.08779178f, 
    0.01958488f, -0.08890092f, 0.08444855f, -0.06416864f, 0.16115361f, -0.01014612f, -0.06771332f, 0.15877898f, 
    0.08215792f, 0.14909357f, -0.03097346f, -0.09033377f, 0.04918665f, -0.05635821f, 0.07715994f, -0.01063257f, 
    -0.28198057f, -0.13749395f, -0.05770512f, -0.12176087f, -0.09967450f, -0.10847339f, -0.02042949f, 0.07593456f, 
    -0.10199674f, -0.06054462f, -0.00759558f, -0.05629456f, -0.11082153f, 0.03449453f, 0.19384712f, -0.13815974f, 
    0.05078282f, 0.01241627f, -0.03288059f, -0.12436449f, 0.13477530f, 0.08190278f, -0.01555709f, -0.14877139f, 
    0.39609185f, -0.24974200f, 0.01504711f, 0.25738093f, -0.10909307f, 0.05173417f, -0.03779528f, -0.09302908f, 
    0.07126557f, 0.10463765f, -0.01443810f, 0.00744728f, 0.28784895f, 0.16788791f, -0.05637934f, -0.08780140f, 
    0.17190367f, 0.07548466f, 0.02024348f, -0.06560421f, 0.06701048f, 0.03040878f, 0.07768255f, 0.01451000f, 
    0.14907250f, -0.11719251f, 0.10809356f, 0.01420777f, 0.04255344f, -0.07672974f, 0.08975098f, 0.14957248f, 
    -0.06601904f, 0.02356962f, -0.05291775f, -0.02750932f, 0.37304455f, 0.26905662f, 0.02451040f, -0.06839935f, 
    0.10395040f, -0.05853693f, 0.02404946f, 0.11973868f, 0.01320678f, -0.00168079f, 0.01230631f, 0.08159818f, 
    -0.02602329f, 0.07455738f, -0.15358236f, -0.17661358f, -0.04024415f, -0.04057824f, -0.02067495f, 0.12453372f, 
    0.07177798f, 0.00670978f, -0.03639732f, 0.13858487f, 0.00805918f, -0.18270439f, 0.12360555f, -0.07996158f, 
    0.15598778f, -0.08167065f, -0.14051051f, -0.03739036f, 0.13898687f, -0.00228581f, -0.01550056f, 0.03279553f, 
    0.13723749f, 0.01316837f, 0.12270819f, -0.18922886f, 0.08109607f, -0.16379088f, -0.11827736f, 0.01438564f, 
    -0.09241628f, 0.09891018f, 0.04852175f, 0.04441775f, -0.08377478f, 0.02364366f, -0.35962725f, 0.01442930f, 
    -0.03354736f, 0.14241615f, -0.02134054f, -0.15498549f, 0.02363536f, -0.10120557f, 0.14036828f, -0.10026335f, 
    0.06686302f, 0.20157859f, 0.02574388f, 0.19687378f, 0.07165326f, 0.01939267f, 0.04334795f, 0.12243147f, 
    0.12113777f, 0.03789530f, 0.01743736f, -0.02138825f, -0.03906257f, -0.00180793f, 0.23320763f, -0.07893018f, 
    0.05365002f, 0.12213225f, -0.02497154f, -0.01968272f, 0.10457902f, 0.00036251f, -0.01742789f, -0.10136808f, 
    0.08386622f, -0.14771301f, -0.39619070f, 0.19666032f, 0.20991376f, 0.03934831f, 0.04857391f, 0.05753576f, 
    0.02183814f, -0.05206027f, 0.05402813f, 0.03211087f, 0.13379264f, 0.07614184f, 0.02144949f, -0.22430545f, 
    0.01933607f, -0.06333500f, -0.06500334f, 0.10329298f, -0.07726861f, 0.12459898f, -0.10158063f, 0.02286315f, 
    0.16925302f, -0.07067293f, -0.10594574f, 0.25465137f, 0.01789804f, -0.02651140f, 0.00709773f, 0.01120258f, 
    -0.07298782f, 0.08055686f, -0.17962314f, -0.00823659f, -0.14510123f, -0.08644539f, 0.10686240f, -0.11568964f, 
    -0.05104136f, 0.06765092f, 0.09076991f, 0.16776097f, 0.00112432f, -0.05456137f, 0.07208782f, 0.04308444f, 
    -0.00882312f, 0.08843403f, -0.06274283f, 0.05416894f, 0.09367896f, 0.05156017f, -0.04332824f, -0.12317375f, 
    0.20854653f, -0.04800732f, 0.09326003f, 0.04151027f, 0.06351292f, 0.02626434f, -0.03974247f, 0.07959514f, 
    0.03381621f, 0.04084788f, -0.06753907f, 0.07693188f, 0.06073449f, -0.02106570f, 0.02710433f, 0.18839073f, 
    -0.36676636f, 0.04623312f, -0.01692883f, -0.16250879f, 0.16167264f, -0.03592920f, 0.02293077f, -0.08578894f, 
    -0.02248401f, 0.05085168f, -0.01995598f, 0.00877195f, -0.11462980f, -0.12058759f, -0.09651293f, 0.09929814f, 
    -0.00095472f, 0.04102046f, 0.06364175f, 0.02241723f, -0.12598987f, -0.15924805f, -0.12800400f, 0.10123924f, 
    -0.00629021f, -0.06940476f, -0.12989372f, -0.00233264f, 0.08259837f, 0.04404455f, 0.02104417f, -0.10618749f, 
    0.07041309f, -0.05526093f, -0.14247839f, 0.00782154f, -0.02043745f, -0.10618187f, -0.05038171f, 0.26898542f, 
    -0.04271102f, 0.23362894f, 0.08431699f, 0.03872506f, -0.02542095f, 0.05177100f, 0.12466273f, 0.04286660f, 
    -0.34918430f, 0.15972260f, 0.00495747f, 0.00682162f, -0.03076017f, 0.11252715f, -0.02697676f, 0.01004990f, 
    -0.12004208f, 0.04287174f, -0.01222569f, 0.06053566f, -0.09336653f, 0.15543784f, -0.16517486f, -0.21236734f, 
    0.11969244f, -0.04069303f, -0.04762132f, 0.03855280f, -0.02318072f, -0.03944241f, 0.14437532f, -0.14854471f, 
    -0.33225781f, -0.04222233f, -0.06652886f, 0.16453379f, -0.09279078f, -0.03374217f, -0.03195271f, -0.05968305f, 
    -0.00897171f, -0.02617839f, 0.02376095f, 0.06257296f, 0.16425216f, -0.02338963f, 0.20340477f, -0.18062827f, 
    0.16773172f, 0.10038398f, -0.12944575f, 0.14129536f, -0.00856816f, 0.02530958f, -0.02388277f, -0.02489582f, 
    0.10299487f, 0.03402064f, 0.25615612f, 0.00670346f, -0.06769166f, 0.01846107f, -0.05782339f, 0.03656947f, 
    -0.05490037f, 0.01750966f, -0.05478191f, 0.01698448f, -0.10356195f, -0.01947808f, 0.03246051f, -0.13840957f, 
    0.04673453f, 0.04052131f, 0.01385080f, 0.06409577f, -0.04587732f, 0.00956485f, -0.01721654f, -0.11554702f, 
    -0.01868683f, 0.15915217f, 0.05764835f, -0.05616484f, -0.16079529f, 0.03523993f, -0.12748241f, 0.09950112f, 
    -0.03476762f, 0.10352081f, -0.03572122f, 0.10408031f, 0.11124756f, -0.02377898f, 0.08682571f, 0.44494092f, 
    0.02000012f, -0.02159118f, 0.01969221f, 0.00450489f, -0.00567481f, -0.01031242f, 0.08629679f, 0.03395231f, 
    -0.00856690f, -0.07148222f, 0.05984022f, -0.13070843f, -0.11795709f, -0.06048032f, -0.02177389f, 0.03281720f, 
    0.07168734f, -0.06684078f, -0.09533728f, 0.02453133f, 0.18248302f, 0.18607545f, 0.01550695f, 0.15201594f, 
    -0.04089244f, -0.01465734f, 0.05302548f, -0.04638008f, -0.02608375f, 0.10415304f, 0.03747255f, 0.01236616f, 
    0.64011496f, -0.10394030f, 0.04877003f, -0.13427463f, 0.04906188f, -0.10112319f, 0.01820200f, -0.03216305f, 
    -0.11092643f, -0.00202084f, -0.01156511f, -0.00667525f, -0.03871728f, 0.01532816f, -0.01024369f, -0.28971943f, 
    -0.12033309f, -0.15280133f, 0.05842281f, -0.02887415f, 0.11130592f, 0.12795436f, 0.09624887f, 0.02860710f, 
    -0.32413390f, -0.18938120f, -0.07191523f, 0.24727263f, -0.06715529f, -0.10906702f, -0.05641824f, 0.01328938f, 
    -0.05124409f, 0.01293944f, 0.00384632f, 0.14788693f, -0.00908714f, -0.02632768f, 0.14648570f, 0.11211719f, 
    0.10886733f, 0.07171144f, 0.01466425f, -0.10637531f, 0.06963797f, 0.01787002f, -0.02180748f, 0.07332291f, 
    -0.01305632f, 0.18249893f, 0.03592373f, 0.20012112f, -0.08178897f, 0.06025148f, 0.00628556f, 0.01185074f, 
    -0.00616328f, 0.03253198f, -0.10025192f, 0.01303606f, -0.03244723f, 0.08426530f, 0.18336837f, -0.09675906f, 
    -0.00056835f, 0.00489217f, 0.04356435f, -0.06425346f, 0.00794800f, -0.02250031f, 0.04194001f, 0.00457146f, 
    0.07731510f, 0.01038056f, 0.14580271f, -0.17711829f, -0.04302194f, 0.12851425f, -0.02591270f, 0.08613268f, 
    -0.09144586f, -0.04263383f, -0.01779922f, 0.13369980f, -0.08003969f, 0.32708117f, 0.04002666f, -0.13867147f, 
    0.06375812f, -0.05208793f, -0.06497326f, -0.00025316f, 0.05827304f, 0.08899600f, -0.02758828f, 0.00690304f, 
    0.18169750f, -0.08246640f, -0.16277052f, 0.10836729f, 0.10357844f, -0.13469361f, 0.11110654f, -0.10290197f, 
    -0.09464205f, -0.03957050f, -0.12835535f, 0.17797837f, 0.22355814f, 0.02927810f, -0.05551975f, -0.19803593f, 
    0.06011325f, 0.01452999f, -0.01821744f, -0.04666837f, 0.00761471f, -0.00571135f, 0.04177968f, 0.06945214f, 
    -0.20509346f, 0.10086306f, 0.01837059f, -0.02285439f, 0.08144553f, 0.04026610f, -0.03617813f, 0.12022500f, 
    -0.00784484f, 0.09810230f, 0.02200212f, 0.05846853f, 0.20593120f, -0.04304982f, 0.18312298f, -0.23721224f, 
    -0.10907720f, 0.05484319f, 0.01570546f, -0.01897405f, 0.09927811f, 0.12622957f, 0.00208024f, 0.03044672f, 
    -0.04559093f, 0.11119211f, -0.17773671f, 0.05839174f, -0.07866241f, 0.04663670f, 0.02125453f, -0.07855758f, 
    -0.06616379f, -0.00153065f, 0.03683620f, 0.09419844f, -0.16205028f, -0.35541964f, -0.03301788f, 0.05108574f, 
    0.03651598f, 0.09264354f, 0.03836837f, 0.01477808f, 0.00438709f, 0.00858124f, 0.05591160f, -0.00907872f, 
    -0.08271946f, 0.26633024f, -0.06070766f, -0.10184424f, -0.02022664f, 0.01609775f, -0.01641973f, -0.06268601f, 
    0.05245396f, 0.03430026f, -0.09447834f, 0.11266219f, 0.01909998f, -0.18319391f, 0.11766149f, 0.19878060f, 
    -0.06901532f, 0.03845264f, 0.00206882f, 0.04817121f, -0.01051979f, 0.04910429f, 0.16910213f, 0.01090332f, 
    -0.06437322f, -0.23858654f, -0.22221452f, -0.05131567f, 0.14395911f, 0.03267028f, -0.10569676f, -0.06446759f, 
    -0.02953330f, 0.06597044f, -0.02018435f, 0.08862702f, 0.19233392f, 0.06738897f, -0.00804000f, -0.19610342f, 
    0.08190537f, 0.01628281f, 0.03428595f, 0.01278914f, 0.07947695f, 0.10268495f, 0.09813481f, 0.07219266f, 
    0.01115110f, -0.15677898f, 0.24429618f, 0.25629321f, 0.06257849f, -0.00746454f, 0.17789024f, 0.00305196f, 
    -0.02828402f, 0.01579779f, 0.01037246f, 0.06059348f, 0.02215751f, 0.06944056f, -0.21728685f, -0.01058903f, 
    0.02804734f, -0.01389245f, 0.01378245f, 0.05967053f, 0.02186279f, 0.04489983f, -0.11480822f, 0.02367453f, 
    -0.03073858f, -0.24763298f, -0.13781218f, -0.01622278f, 0.02875872f, -0.02249014f, 0.00425957f, -0.02306359f, 
    0.13426284f, 0.02785876f, -0.08172201f, 0.00350965f, 0.28537911f, 0.21577990f, 0.07948356f, -0.01961800f, 
    -0.14941168f, -0.09005953f, 0.19685446f, 0.00345701f, -0.07777470f, 0.00811199f, 0.09505908f, 0.03728299f, 
    0.12441307f, 0.01725652f, -0.05312274f, -0.06958766f, 0.12498327f, 0.04630205f, -0.10834137f, -0.04065128f, 
    -0.09589889f, -0.03860142f, 0.02564257f, -0.05980803f, -0.20793927f, 0.11647243f, 0.03670922f, 0.19423945f, 
    -0.00428327f, -0.02668042f, 0.03562859f, 0.00253634f, -0.07007440f, 0.07099245f, -0.00243510f, 0.12189114f, 
    0.21598513f, 0.43207181f, -0.04776881f, -0.06251815f, 0.05939017f, 0.16622262f, 0.05050438f, 0.12040546f, 
    0.00560981f, -0.01022120f, 0.06463315f, -0.08736391f, -0.04917177f, 0.11674828f, 0.03921596f, 0.12687826f, 
    0.03318072f, -0.10672313f, 0.05100114f, -0.16358070f, 0.05010108f, 0.05627318f, 0.03144437f, -0.08957530f, 
    -0.07320396f, -0.13229074f, -0.03292316f, 0.10110679f, -0.02020924f, 0.18422303f, -0.04072996f, 0.13401303f, 
    0.04460497f, -0.04499865f, 0.04732027f, 0.08683480f, 0.31211078f, -0.02293494f, 0.22023086f, 0.03366685f, 
    -0.00413277f, -0.00790614f, 0.12995195f, -0.05548442f, -0.01341948f, -0.02333811f, 0.00339850f, 0.03899124f, 
    -0.10897738f, -0.05051798f, 0.01549919f, 0.10825881f, 0.12385014f, -0.01107092f, 0.01471578f, 0.04578978f, 
    0.00225841f, 0.12241615f, -0.00543685f, -0.06320337f, -0.22737429f, 0.01023629f, -0.17219912f, -0.45056534f, 
    0.06391686f, 0.07317313f, -0.04198908f, -0.00340427f, -0.04967835f, -0.03879766f, 0.03062795f, -0.08138522f, 
    0.09691918f, 0.05684761f, -0.02959073f, 0.14367689f, 0.00540377f, 0.16679356f, -0.06879324f, -0.01085211f, 
    0.05027128f, -0.04014358f, 0.15910427f, 0.07494199f, 0.09560688f, -0.34873599f, -0.01556404f, -0.03058134f, 
    0.10559622f, -0.07427853f, 0.08241089f, 0.00371780f, -0.09249300f, 0.12392351f, 0.04815482f, -0.03249476f, 
    -0.36300310f, -0.11145956f, -0.01387458f, 0.18651015f, -0.07959030f, 0.03752303f, 0.04867258f, 0.03647954f, 
    0.02011343f, -0.02161286f, -0.00622685f, 0.03323584f, 0.25273356f, -0.05040985f, 0.07607401f, 0.24869494f, 
    0.18423194f, -0.00380868f, 0.14549321f, 0.03404519f, -0.02007615f, 0.04949358f, -0.10625184f, -0.13394229f, 
    0.65021706f, 0.10832339f, 0.04547100f, 0.08270523f, -0.01827607f, 0.07348971f, 0.09306065f, -0.07881285f, 
    0.01571034f, 0.16733523f, -0.01285797f, -0.03209641f, 0.24025129f, 0.02207385f, -0.02360239f, -0.15583973f, 
    -0.13601260f, 0.01230204f, -0.10782524f, -0.04136727f, -0.04213337f, 0.03366996f, 0.07724915f, 0.00926341f, 
    -0.31167445f, -0.17392607f, -0.07390162f, -0.15158780f, -0.03680466f, 0.13887222f, 0.16405636f, 0.03553135f, 
    0.06102522f, 0.01768185f, 0.04546465f, -0.03609288f, 0.36577219f, 0.18058376f, -0.09687188f, -0.02487165f, 
    -0.06749846f, 0.05185352f, 0.01037361f, 0.03928174f, 0.04390759f, 0.06090392f, -0.09975942f, 0.12553214f, 
    0.05283572f, -0.05680921f, -0.03519161f, -0.04222101f, -0.03239419f, 0.02563071f, 0.04640038f, -0.03836304f, 
    -0.00852697f, -0.04505824f, -0.02783806f, 0.05093309f, -0.01489536f, 0.02795431f, -0.04148003f, -0.02555592f, 
    -0.04452797f, 0.04375334f, 0.05315924f, 0.03144801f, -0.04610969f, -0.03079144f, 0.03081603f, -0.03140312f, 
    -0.07061300f, 0.04454542f, -0.02271371f, 0.03832769f, -0.00982746f, -0.03667513f, -0.04503066f, 0.06356414f, 
    -0.06121862f, -0.04869711f, -0.02256722f, 0.00589041f, -0.06051489f, -0.05942013f, 0.03879450f, 0.04094269f, 
    -0.02402128f, -0.02789192f, 0.01730966f, -0.06560352f, 0.02191025f, 0.01577615f, 0.01750608f, -0.03168293f, 
    0.03534539f, 0.01931933f, 0.06232217f, -0.03850650f, -0.01872573f, 0.01966820f, 0.04610276f, 0.00150065f, 
    -0.04325850f, -0.04753261f, -0.04864817f, -0.05438211f, -0.02896969f, -0.06297021f, 0.01334166f, 0.02826610f, 
    -0.07242493f, -0.04947808f, -0.03412173f, -0.03292569f, -0.04350931f, -0.01569033f, -0.03409339f, -0.07653524f, 
    0.06408441f, -0.01591574f, 0.01165264f, -0.02677187f, -0.05635474f, -0.03890349f, -0.05778618f, -0.07413394f, 
    0.02433996f, -0.07712682f, 0.04869679f, 0.04312259f, 0.04565169f, -0.00206733f, -0.06705241f, -0.00542113f, 
    -0.05950178f, -0.04645003f, -0.07288432f, -0.01670023f, 0.03900250f, 0.02791668f, 0.03398284f, 0.04906976f, 
    -0.01379379f, 0.02701239f, -0.05681739f, -0.06561765f, -0.06723947f, -0.04449079f, -0.04905315f, -0.04423250f, 
    0.00954090f, -0.02374341f, 0.02620630f, -0.05294508f, 0.06196684f, 0.01761965f, -0.01856942f, -0.01890567f, 
    -0.04550547f, 0.03163939f, -0.00243924f, 0.02816019f, -0.02456877f, -0.03543712f, 0.04188418f, 0.04740762f, 
    0.04213399f, 0.00833172f, -0.01978306f, -0.05253068f, 0.04781617f, -0.04043978f, -0.06285642f, 0.03506876f, 
    0.02912997f, -0.06721710f, -0.04999806f, 0.05167548f, -0.05060761f, -0.01416038f, -0.07719034f, -0.03416913f, 
    -0.02267468f, -0.02468937f, 0.05848803f, 0.02888834f, 0.06070645f, -0.07152415f, -0.07231782f, 0.03535009f, 
    -0.04993225f, -0.00380923f, -0.07616244f, -0.04758209f, -0.00063664f, -0.03696613f, 0.01870470f, 0.03511873f, 
    0.05393684f, 0.02332036f, -0.01934862f, -0.04734222f, -0.05761911f, -0.00650497f, 0.02266431f, 0.02651966f, 
    0.02134455f, -0.04079421f, 0.04319227f, 0.00904465f, 0.00221921f, 0.05704620f, -0.06647272f, -0.06340861f, 
    -0.01681820f, -0.01515181f, 0.02587143f, -0.04396053f, -0.04724690f, -0.00499783f, 0.02291914f, -0.06734948f, 
    -0.06906607f, -0.05859471f, 0.02815634f, 0.03704665f, 0.06481971f, -0.00586886f, -0.04426704f, -0.05178943f, 
    0.02786878f, 0.03765326f, -0.04879420f, -0.05709663f, -0.01936805f, -0.01295148f, 0.04402640f, 0.02212244f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05316883f, -0.07513718f, 0.05344478f, -0.04596586f, 0.13421425f, 0.12232838f, -0.02693815f, 0.01019010f, 
    0.06248932f, 0.05139970f, -0.03581771f, -0.01046688f, -0.06265001f, -0.03746935f, -0.01165245f, 0.15935358f, 
    -0.06889168f, 0.02277113f, -0.01013566f, 0.11543779f, 0.07839400f, 0.06593643f, 0.04125485f, -0.02537658f, 
    0.02525585f, 0.12711522f, 0.03265432f, -0.06538122f, 0.06115621f, 0.04404437f, 0.06719558f, 0.02172251f, 
    -0.00055547f, -0.00567712f, -0.00948230f, -0.06291617f, -0.07451893f, -0.10183072f, 0.04122858f, -0.00983681f, 
    0.09455072f, -0.02215262f, -0.00022399f, 0.12047171f, -0.08021933f, 0.04905282f, 0.10939769f, 0.02773600f, 
    -0.01756200f, 0.00172816f, -0.03477259f, 0.00262657f, 0.09394547f, 0.01938883f, 0.11566640f, 0.13753113f, 
    -0.00322101f, -0.05633114f, -0.07123193f, 0.05088828f, -0.02574952f, 0.04169956f, -0.02628840f, 0.04339493f, 
    0.00400413f, -0.03921100f, -0.03441425f, -0.08970373f, -0.06474235f, 0.00464677f, 0.09748745f, 0.01511950f, 
    0.01353215f, -0.07374692f, -0.11680181f, 0.05809902f, -0.04698425f, 0.06259037f, 0.12786351f, -0.01973023f, 
    -0.01746323f, -0.03359653f, 0.01712918f, -0.01543086f, 0.03983104f, 0.04335857f, 0.07981235f, 0.09432392f, 
    0.03151025f, -0.04296120f, -0.00857203f, -0.07335581f, -0.05746233f, 0.14238904f, 0.02439767f, -0.07345470f, 
    0.02535435f, -0.11082059f, 0.00571047f, 0.11705535f, -0.09804461f, 0.02591527f, -0.04777743f, 0.02561188f, 
    0.06067125f, 0.03262442f, 0.03951948f, -0.05590252f, -0.03114101f, 0.03425848f, -0.02644704f, 0.03306036f, 
    -0.00797405f, 0.05866062f, 0.02441949f, 0.04671946f, 0.12183779f, 0.00144103f, -0.01771660f, 0.07178157f, 
    -0.01167396f, 0.10836147f, -0.01559492f, 0.00512671f, 0.02764116f, -0.03604557f, -0.01610618f, -0.05497314f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05228075f, 0.20337090f, 0.03695906f, -0.04700042f, 0.05623636f, 0.09295154f, -0.00358056f, -0.33878949f, 
    0.15388873f, -0.48082307f, -0.00116175f, -0.06297915f, -0.25659111f, -0.12047882f, -0.05869737f, 0.13348341f, 
    -0.20042093f, 0.02568045f, -0.02604357f, -0.08081289f, -0.24068455f, 0.17992030f, 0.04622571f, 0.28890574f, 
    0.23959719f, -0.39100733f, -0.17644948f, 0.02537206f, 0.08718804f, 0.04943085f, 0.07487858f, -0.01334804f, 
    0.15786283f, -0.21469763f, 0.03667406f, 0.03316813f, 0.37246370f, -0.08978824f, -0.15685681f, -0.05119744f, 
    0.07705414f, -0.25118247f, -0.05261745f, -0.25709555f, 0.04030550f, -0.29463023f, 0.03404061f, 0.03696472f, 
    0.34027165f, -0.16021663f, -0.34098274f, -0.03490134f, -0.43700284f, 0.03434955f, -0.27337143f, -0.18780780f, 
    -0.22617114f, -0.46311006f, -0.07240368f, -0.03917616f, -0.38871861f, 0.02122032f, -0.05194723f, -0.38123432f, 
    0.15257628f, 0.00995560f, -0.02331077f, 0.03807352f, 0.15051703f, 0.20020135f, -0.50883251f, 0.01744281f, 
    0.04682206f, 0.00107097f, 0.14209853f, 0.27313647f, 0.02576743f, -0.22080682f, -0.30277786f, 0.04817643f, 
    0.06338859f, 0.12523405f, 0.06554868f, 0.08768433f, 0.05177482f, -0.27187508f, 0.05473535f, 0.01939523f, 
    -0.08242651f, -0.05852794f, -0.05908201f, 0.19426842f, -0.02448935f, -0.04829995f, 0.01528927f, 0.04906720f, 
    -0.16144043f, 0.27136937f, 0.01372446f, 0.15312457f, -0.02069124f, 0.06215538f, 0.00483579f, -0.13548239f, 
    -0.03012302f, -0.13011922f, 0.02207957f, 0.18632311f, -0.04252511f, -0.01825524f, 0.01201528f, -0.05747785f, 
    -0.06681766f, -0.10523369f, -0.15855141f, 0.16392775f, 0.00004005f, -0.13556837f, 0.05892769f, -0.21772565f, 
    0.04343224f, -0.35839257f, 0.25019723f, -0.15045896f, 0.13245815f, 0.06607334f, -0.02480903f, -0.03771519f, 
    -0.07833556f, 0.06017121f, 0.32692453f, 0.00310752f, 0.15150143f, 0.12523936f, 0.09181589f, -0.40613717f, 
    0.09558579f, 0.50900269f, 0.01102025f, -0.05575321f, -0.26997623f, -0.30700195f, 0.02695832f, 0.09337821f, 
    -0.22672541f, -0.14601004f, -0.01141240f, -0.14944445f, -0.38537520f, 0.11261193f, 0.12910178f, -0.17925693f, 
    -0.47486535f, 0.03458769f, 0.00546944f, 0.00489976f, 0.07258406f, 0.01962385f, 0.12701844f, 0.27670535f, 
    0.13338953f, 0.08553594f, -0.20382051f, -0.05926150f, -0.48646116f, -0.00298160f, -0.08261412f, 0.26055723f, 
    -0.00752113f, 0.12636235f, 0.11374066f, 0.12012485f, 0.06397881f, -0.32069337f, 0.11444519f, -0.03824672f, 
    -0.17505744f, -0.25112885f, 0.20934181f, 0.02578904f, 0.62189913f, -0.06634777f, -0.06341445f, 0.03119703f, 
    -0.11400934f, -0.24863668f, -0.05616866f, -0.08069785f, 0.16722961f, 0.03469484f, 0.14829311f, -0.37500644f, 
    -0.07328831f, -0.04874607f, -0.08054391f, 0.22157870f, -0.26475820f, -0.06180652f, 0.15665022f, -0.34557876f, 
    0.06357452f, 0.07502748f, -0.20061067f, -0.45381564f, 0.18161856f, 0.06188844f, -0.09426104f, -0.05584980f, 
    0.02073975f, 0.01999409f, -0.38857177f, 0.06099585f, 0.03652426f, 0.01030202f, 0.16577306f, -0.25920594f, 
    -0.05241519f, -0.05728711f, 0.18223660f, 0.11507297f, 0.03919387f, 0.13901205f, -0.46719623f, 0.05424609f, 
    0.11908629f, -0.04748192f, 0.17847869f, -0.09604093f, -0.00275349f, 0.02061224f, -0.06289412f, -0.05452172f, 
    0.05028976f, 0.25907978f, 0.06425548f, 0.17125280f, -0.01817117f, 0.00506039f, -0.00392787f, -0.06869301f, 
    -0.01032166f, -0.22888054f, -0.03297475f, 0.06548094f, 0.12395819f, -0.03835082f, 0.12696780f, -0.10477524f, 
    -0.08019280f, -0.23759079f, 0.15444256f, -0.05346680f, 0.20087259f, 0.13892046f, -0.23882428f, -0.08129120f, 
    0.05303301f, 0.07947292f, 0.16514407f, 0.06250478f, -0.17747766f, -0.02037120f, 0.14420931f, 0.04395008f, 
    0.18869416f, -0.33257616f, -0.04857812f, 0.02027664f, 0.16606866f, 0.03928305f, 0.01868347f, -0.10487660f, 
    0.21559352f, 0.12436096f, -0.04505257f, 0.21133511f, -0.11784013f, -0.22688170f, 0.07925148f, -0.31219536f, 
    0.11494093f, -0.29150307f, 0.06644106f, -0.08186992f, -0.24106972f, 0.04767911f, -0.18777312f, -0.18440224f, 
    0.20476675f, -0.03459320f, -0.32057208f, 0.06427034f, 0.14261685f, 0.06313320f, 0.19103874f, 0.16653207f, 
    -0.20825744f, 0.11565331f, 0.12642036f, -0.39520347f, -0.03962331f, -0.03186041f, -0.01851423f, -0.06928211f, 
    -0.25768051f, 0.02291671f, -0.38491660f, 0.00602215f, -0.41117102f, -0.05091890f, -0.08383325f, -0.24656746f, 
    0.11744425f, 0.21182053f, -0.01009324f, -0.08200480f, -0.04601197f, 0.02910920f, -0.09009510f, 0.08271003f, 
    0.03729414f, 0.06640776f, -0.01421452f, 0.17774604f, -0.01551389f, -0.03227129f, -0.21096836f, 0.13221031f, 
    -0.02750118f, 0.06221852f, 0.06617226f, 0.09983411f, 0.16537060f, 0.33134538f, -0.21264888f, 0.05099837f, 
    -0.05959795f, -0.27892846f, -0.02429272f, 0.13821368f, 0.00348403f, -0.19693841f, 0.02169922f, 0.21443087f, 
    -0.07134563f, 0.02346263f, 0.00265449f, 0.21352687f, 0.01223066f, -0.19357221f, -0.08764505f, -0.01799647f, 
    0.04834852f, 0.02142442f, -0.15975124f, -0.19968221f, -0.04319793f, -0.03091533f, -0.03541456f, 0.03932187f, 
    -0.04228032f, 0.03681571f, 0.05257924f, -0.11047582f, -0.07568859f, 0.16853006f, 0.06784973f, 0.00457088f, 
    0.01768472f, 0.01333717f, -0.24232922f, -0.41979346f, -0.46933249f, 0.13642624f, 0.10249785f, -0.30819201f, 
    -0.05877167f, 0.04373413f, 0.29404691f, -0.30676338f, -0.31458360f, -0.17384255f, 0.17079726f, 0.07907883f, 
    0.03653538f, 0.20320562f, -0.21900843f, 0.02560440f, -0.24997623f, -0.23399614f, 0.14178838f, -0.25588599f, 
    0.08645477f, 0.00340991f, 0.06123333f, -0.00771530f, -0.23802978f, 0.11542483f, -0.03845486f, -0.24010707f, 
    -0.00043109f, -0.26233146f, 0.04338272f, -0.06254973f, 0.16896138f, -0.41182539f, -0.24579440f, -0.00603642f, 
    0.11749494f, 0.22015594f, 0.16598400f, -0.02121465f, 0.12760754f, -0.07575111f, -0.15514469f, -0.27010676f, 
    -0.45215738f, -0.34054554f, -0.03620221f, -0.04325815f, -0.07570904f, -0.00945465f, 0.11908071f, -0.63880581f, 
    0.21337117f, 0.19755255f, -0.20054974f, 0.12588769f, -0.03388008f, 0.18763630f, 0.08246201f, -0.04187948f, 
    0.23480967f, -0.04792360f, 0.07244250f, 0.04646650f, -0.17506686f, 0.20971869f, -0.20102645f, 0.15201987f, 
    -0.03951205f, 0.14345272f, -0.07677087f, -0.05104005f, -0.23930617f, 0.07288128f, -0.19438480f, -0.01399734f, 
    0.25302431f, 0.06737114f, 0.29043555f, -0.07532318f, -0.26599616f, -0.21939330f, -0.04142754f, -0.07429755f, 
    -0.03387090f, 0.02467024f, -0.14692336f, 0.03780055f, -0.29890174f, -0.11473957f, -0.05018899f, -0.01623005f, 
    -0.08347986f, 0.21540350f, 0.10630107f, -0.55135339f, 0.07812440f, -0.32165667f, -0.60327905f, 0.02557436f, 
    -0.01978551f, 0.04511687f, -0.05869487f, -0.07380057f, -0.00000069f, 0.01888224f, 0.02441520f, 0.06820504f, 
    0.28298813f, -0.34830832f, -0.24893068f, 0.06656097f, 0.07388698f, -0.01904849f, -0.05207965f, -0.18170695f, 
    0.06911404f, 0.21862505f, -0.06408567f, 0.12232771f, -0.06678304f, -0.07499740f, -0.02773628f, 0.07888597f, 
    -0.06093413f, 0.05393978f, 0.10119566f, 0.20378956f, 0.07773138f, 0.08617257f, -0.21019472f, 0.06098087f, 
    0.00362753f, 0.13779326f, 0.06215744f, -0.26037988f, -0.06291505f, 0.16798165f, 0.12487528f, 0.00703193f, 
    0.06784093f, -0.20292455f, 0.17454840f, -0.00994594f, 0.05210781f, -0.06257024f, -0.41598246f, -0.00290436f, 
    -0.15593381f, 0.00364374f, -0.04474295f, 0.02063994f, -0.18528908f, -0.13404875f, 0.03694755f, 0.11517078f, 
    -0.16111407f, -0.02053554f, 0.06107155f, 0.05290554f, -0.20998853f, 0.23895089f, -0.09825175f, 0.20630665f, 
    -0.07832960f, 0.05981201f, 0.05794240f, 0.07244939f, 0.11756736f, -0.06964594f, 0.17927587f, -0.06707424f, 
    -0.20770578f, -0.07155364f, -0.00802606f, 0.00245333f, 0.00146167f, 0.02064985f, -0.26324135f, 0.13390705f, 
    -0.04095146f, -0.01655312f, -0.19528596f, 0.26058689f, -0.01369314f, 0.09064231f, -0.14561608f, 0.07404028f, 
    0.30032691f, 0.19051640f, 0.00373336f, -0.01049942f, -0.37597519f, -0.07303327f, -0.25974926f, 0.21970165f, 
    0.11067095f, 0.10267040f, -0.06155099f, -0.04065397f, 0.21768017f, 0.03593175f, -0.32214823f, 0.03626484f, 
    0.16873893f, -0.03629313f, 0.16028506f, 0.40537238f, -0.03175846f, 0.04409481f, -0.13309789f, -0.04839640f, 
    -0.08205500f, 0.03736657f, -0.41600475f, -0.00623481f, 0.31703922f, -0.14767644f, 0.24216752f, -0.04404945f, 
    -0.07763018f, 0.32951045f, 0.02350827f, -0.21440694f, -0.02604707f, 0.09495690f, -0.19099903f, 0.13852288f, 
    -0.04027263f, -0.04855743f, -0.36735725f, 0.06451004f, 0.03432550f, -0.02995071f, 0.31180385f, -0.01815358f, 
    0.11047588f, -0.06984162f, 0.07936757f, 0.02973478f, -0.00917265f, -0.05999892f, -0.02651762f, 0.16777936f, 
    0.02830797f, 0.12028193f, -0.06732743f, -0.32730678f, -0.01030308f, 0.04051337f, 0.00312642f, -0.00183096f, 
    0.03921552f, 0.24666137f, -0.21063845f, 0.19232160f, -0.07812965f, 0.08456156f, -0.01182849f, 0.29172450f, 
    -0.02931230f, -0.01855186f, -0.15889212f, 0.11287270f, 0.00207716f, -0.35612872f, -0.26432708f, 0.02389083f, 
    -0.09128191f, 0.02783463f, -0.43080500f, 0.03325644f, -0.06368285f, 0.19496307f, 0.20552714f, 0.32086858f, 
    -0.25649080f, -0.16136657f, 0.07588351f, -0.04740900f, -0.02737961f, -0.40861577f, -0.05490709f, 0.24530475f, 
    0.33738559f, 0.19029900f, -0.05436599f, -0.20105539f, 0.23828480f, 0.04644874f, 0.04877558f, 0.00751433f, 
    -0.22765309f, -0.39945364f, 0.16556820f, 0.02511946f, -0.11723295f, -0.02489925f, 0.19844280f, 0.06275649f, 
    -0.34616426f, -0.00354043f, 0.25319943f, 0.03491190f, -0.20700166f, -0.03285764f, -0.06099381f, 0.00955630f, 
    0.23504376f, -0.27769461f, 0.02399711f, 0.26282352f, -0.00970266f, 0.01901035f, -0.16120157f, -0.07941293f, 
    0.20498782f, -0.05979845f, -0.27603510f, 0.04854343f, 0.16948293f, 0.10897584f, 0.17777449f, -0.02184210f, 
    -0.07697021f, 0.16938712f, -0.01295771f, -0.07746565f, -0.23270376f, -0.06255887f, 0.22099267f, -0.19420834f, 
    -0.13425726f, 0.05144788f, 0.00457460f, -0.39204156f, 0.12467185f, 0.08553369f, 0.29148585f, -0.22267835f, 
    0.02153644f, -0.06018477f, -0.14606282f, -0.22315745f, -0.07524332f, 0.08317871f, -0.17089477f, -0.01061885f, 
    0.05455460f, 0.05608384f, -0.11465566f, 0.18576556f, 0.04753642f, -0.29063976f, -0.00434891f, 0.08991689f, 
    -0.08703493f, 0.03233215f, 0.25483850f, -0.19687116f, -0.03734919f, 0.13593848f, 0.13179992f, -0.07287721f, 
    -0.20337932f, 0.11841193f, 0.02125174f, -0.02265453f, -0.35931441f, -0.04828564f, -0.03247302f, -0.17913322f, 
    0.03442201f, -0.01881954f, -0.05401075f, 0.00510396f, -0.03491228f, -0.19019787f, -0.03934629f, -0.06724565f, 
    -0.01372092f, -0.13891193f, 0.16546692f, 0.12916392f, 0.05417173f, 0.05795315f, -0.07336168f, 0.11128248f, 
    -0.04531540f, 0.00008670f, -0.32406715f, 0.05279153f, -0.11146776f, -0.26333326f, -0.19759601f, 0.00575958f, 
    -0.08370081f, 0.23699528f, -0.31836942f, -0.03374703f, 0.02083339f, 0.05878872f, -0.24163605f, -0.03304846f, 
    0.16403802f, -0.50881886f, -0.00081584f, 0.03166536f, -0.23718271f, 0.28604847f, -0.01291674f, -0.08112613f, 
    -0.25420502f, 0.03228536f, -0.01578996f, -0.14519632f, 0.19054362f, -0.19248492f, 0.04700165f, 0.14697042f, 
    0.17008761f, -0.04826973f, 0.14440449f, 0.01554091f, -0.01935848f, 0.00415524f, -0.22513103f, 0.20156945f, 
    0.00212362f, 0.10975599f, -0.18227395f, -0.08296806f, -0.23397279f, -0.05459449f, -0.11396015f, -0.04610191f, 
    -0.24261288f, -0.24238157f, 0.10432482f, -0.40121889f, -0.08064127f, 0.03090696f, 0.22915377f, -0.00874354f, 
    -0.33484375f, 0.12489907f, -0.37477458f, 0.00589109f, 0.23827554f, -0.19549423f, -0.04269483f, 0.01671862f, 
    0.11969084f, -0.05935919f, 0.06408138f, 0.08147413f, -0.21598174f, 0.07178372f, 0.19325668f, 0.18538271f, 
    0.15513815f, 0.02102323f, -0.18088727f, -0.35837507f, 0.18268287f, 0.02332463f, 0.21905743f, 0.04220024f, 
    0.07234274f, -0.06825623f, 0.25723821f, -0.11620206f, -0.33425581f, 0.01656849f, 0.19639648f, 0.02409087f, 
    -0.05936557f, -0.56768066f, 0.13484734f, 0.15666592f, 0.04148141f, 0.16840123f, -0.01543268f, 0.11350415f, 
    -0.05111720f, 0.06234701f, -0.15913332f, 0.13970019f, 0.01897658f, -0.51090086f, 0.16033161f, 0.03393981f, 
    -0.41631949f, 0.06396994f, -0.38473782f, 0.17825888f, 0.20000149f, -0.07831297f, -0.04083040f, -0.20050731f, 
    -0.01271355f, 0.03287580f, -0.09261846f, -0.12623622f, 0.06181401f, -0.43518490f, -0.05174941f, 0.03086172f, 
    -0.06090448f, -0.20428932f, 0.09175345f, -0.37084043f, 0.09334211f, -0.06595948f, -0.21222198f, -0.13240899f, 
    0.01379647f, 0.13681242f, -0.21441904f, 0.16760354f, -0.21945277f, 0.08771533f, 0.28076705f, -0.08956660f, 
    -0.04010196f, 0.08065280f, 0.13112180f, -0.07585390f, -0.35264140f, -0.39752260f, -0.27613249f, 0.18015032f, 
    -0.33017924f, 0.15861759f, 0.02650652f, -0.04148358f, 0.22710674f, 0.13831767f, -0.08740612f, -0.46621615f, 
    0.26019037f, 0.00655589f, -0.04582976f, -0.18843831f, 0.09303582f, -0.21177234f, -0.13622947f, 0.12730260f, 
    0.03888592f, 0.09546570f, 0.01251652f, -0.03115008f, -0.40772584f, 0.02905057f, -0.28402758f, 0.06230795f, 
    -0.02455251f, -0.08162736f, 0.01400921f, 0.04986691f, 0.19246365f, 0.04095913f, -0.12494612f, 0.04283169f, 
    -0.42306426f, -0.08115019f, -0.23822951f, 0.08000959f, 0.04373321f, 0.06953941f, -0.36598849f, -0.02476871f, 
    -0.08229986f, 0.21526818f, 0.22349794f, -0.02223229f, 0.06340261f, 0.03070060f, -0.12104724f, -0.27734709f, 
    -0.26858425f, 0.16364934f, 0.05427808f, -0.01546313f, 0.36407837f, -0.08134539f, 0.13757604f, 0.14302756f, 
    -0.15317282f, 0.04369457f, -0.04235063f, 0.00724413f, 0.02635303f, -0.53930622f, -0.23398520f, 0.20183028f, 
    -0.07298474f, 0.05386845f, 0.26228365f, -0.08995848f, -0.01574942f, 0.07033839f, -0.40811005f, -0.04787702f, 
    -0.00283336f, 0.17965145f, 0.18008040f, -0.08350910f, -0.07489689f, 0.15900587f, -0.05852190f, -0.44755164f, 
    0.03347630f, 0.00856911f, -0.07574758f, -0.12080858f, -0.07694908f, -0.20240825f, 0.09362843f, -0.08283417f, 
    -0.07197341f, -0.10429182f, -0.05718864f, 0.07288239f, 0.14576280f, -0.06110188f, 0.01361942f, 0.16125529f, 
    0.03676119f, -0.14104719f, 0.02992682f, 0.00990009f, -0.01113100f, 0.13267682f, -0.02789359f, -0.09118365f, 
    0.01914922f, -0.31981757f, 0.08110961f, -0.00837811f, 0.06013529f, 0.22513402f, -0.14849482f, -0.25000292f, 
    -0.03141659f, 0.19335520f, 0.14096636f, -0.01343711f, 0.01678925f, 0.04416956f, 0.20568269f, 0.01274133f, 
    0.02083581f, -0.36280823f, -0.17934601f, -0.01182807f, 0.01464337f, 0.02940605f, 0.02563391f, 0.16665667f, 
    -0.27969021f, -0.18387893f, -0.03208615f, -0.09721504f, 0.22823976f, 0.01226651f, 0.04979844f, -0.26778206f, 
    0.21517207f, -0.43523061f, -0.09556907f, 0.10040820f, -0.06286355f, -0.36153907f, 0.16981590f, -0.15004778f, 
    -0.43551424f, 0.16537869f, 0.28472129f, -0.05889773f, 0.22376440f, -0.06319452f, 0.20525776f, -0.14338559f, 
    0.07043935f, 0.13220535f, 0.14138447f, -0.04660502f, -0.37829062f, -0.00223846f, -0.06654010f, -0.18013337f, 
    -0.04077533f, 0.24377039f, 0.07904027f, 0.08597036f, -0.03048433f, -0.08744173f, -0.06130623f, -0.04249991f, 
    -0.20967008f, -0.25109529f, -0.11556112f, -0.04177745f, -0.24737123f, -0.27974138f, 0.15592118f, 0.03039352f, 
    -0.00879898f, 0.33092770f, 0.05076224f, -0.03857752f, 0.13098986f, 0.04126889f, 0.06454042f, -0.07695736f, 
    -0.49603876f, 0.06243808f, -0.39794615f, 0.19924849f, 0.07507920f, -0.15826003f, -0.05057803f, -0.36593544f, 
    0.01687110f, 0.07131939f, 0.12505116f, 0.14028423f, -0.11450263f, 0.12255805f, 0.28761038f, 0.02319530f, 
    -0.01405965f, 0.15490389f, -0.23214005f, -0.12975612f, -0.03139929f, -0.16599402f, 0.10730027f, 0.25322148f, 
    -0.05146987f, 0.01798017f, -0.06679599f, -0.15163891f, -0.08386046f, 0.10913804f, -0.24482514f, 0.04333484f, 
    -0.13376901f, 0.24681927f, 0.02390731f, -0.34590042f, -0.30327186f, 0.04582356f, -0.04267117f, -0.31242308f, 
    0.07622579f, -0.36110044f, -0.07487715f, 0.01694349f, -0.08730062f, 0.28991520f, 0.04815964f, 0.06988841f, 
    -0.05187916f, 0.10968705f, 0.24415593f, 0.16994525f, -0.17771392f, -0.19571495f, 0.06337507f, -0.11838932f, 
    -0.02733318f, -0.06792142f, -0.14598826f, 0.18407176f, 0.25413418f, 0.21182545f, -0.47101960f, -0.03001522f, 
    -0.03310469f, -0.24658507f, -0.21961133f, -0.08745389f, 0.27167720f, -0.01607329f, -0.06607991f, 0.06760641f, 
    -0.03881202f, 0.02998662f, 0.06410930f, -0.07399941f, 0.31941652f, -0.09260888f, 0.04645605f, -0.01904348f, 
    -0.36894205f, 0.21485573f, -0.01173632f, 0.03486741f, 0.06311633f, 0.01015188f, -0.28616735f, -0.31796199f, 
    0.20090498f, 0.02557759f, -0.23155859f, 0.02102723f, 0.22380090f, 0.04408308f, -0.08425365f, -0.31489813f, 
    0.13282485f, 0.25260815f, 0.23101774f, -0.04799297f, 0.17163789f, -0.10046074f, -0.33771676f, 0.09463163f, 
    0.11273726f, 0.31618223f, -0.13144217f, -0.14098080f, 0.05120870f, 0.23672077f, 0.03977722f, 0.07741661f, 
    -0.54192632f, 0.17833582f, 0.23297818f, -0.04250817f, -0.28708765f, -0.36270294f, 0.08928760f, 0.09050405f, 
    0.29826757f, 0.03386126f, 0.01795194f, -0.00520650f, -0.11935358f, -0.09570932f, 0.12630610f, 0.14334881f, 
    -0.03990887f, 0.04669870f, -0.02483192f, -0.51461285f, 0.34434986f, 0.08930722f, -0.08751004f, -0.04645669f, 
    0.06973504f, -0.01713847f, 0.15705791f, 0.28558096f, -0.29422015f, -0.49654880f, 0.13271083f, -0.08149214f, 
    -0.06642038f, -0.24284132f, -0.28619269f, -0.01889893f, -0.00203589f, 0.27817428f, -0.03801121f, -0.16596846f, 
    -0.04318375f, -0.01731377f, -0.28569654f, 0.17854193f, 0.01862792f, -0.00486157f, -0.16094658f, 0.02996909f, 
    0.01968321f, -0.24995315f, 0.18159819f, -0.19247799f, 0.09368623f, -0.01416664f, -0.04483053f, 0.39940190f, 
    0.01161303f, -0.05000681f, 0.07043219f, -0.44159162f, -0.00524828f, -0.07720443f, -0.04666531f, 0.06578782f, 
    0.07654257f, -0.11806609f, -0.08543662f, -0.18440846f, -0.01374684f, 0.24677187f, 0.00866248f, -0.17410907f, 
    -0.03737811f, -0.42792949f, -0.08265223f, -0.32797679f, 0.30481920f, -0.24526276f, 0.04597314f, -0.04382365f, 
    -0.03463855f, 0.01756005f, 0.27474540f, -0.02330328f, 0.03241676f, -0.10406160f, 0.08210025f, -0.01421138f, 
    -0.15053274f, -0.13038175f, -0.05851957f, 0.04475139f, 0.19291401f, 0.02961378f, 0.06828918f, 0.30392876f, 
    -0.16842754f, 0.27211785f, -0.01848959f, 0.25520134f, -0.10100280f, -0.28440124f, 0.26137739f, 0.05365740f, 
    0.10084675f, -0.06825434f, -0.09996793f, -0.03383061f, -0.18219897f, 0.06693233f, -0.17094088f, -0.15279356f, 
    -0.05303741f, 0.26245990f, -0.13502043f, -0.06912396f, 0.01015675f, -0.05027851f, 0.10501088f, -0.60324615f, 
    -0.17134139f, -0.16615699f, -0.02238871f, 0.20319082f, 0.06271723f, -0.24570467f, 0.16724303f, 0.00042041f, 
    -0.11459620f, -0.18043347f, -0.18326139f, -0.05403547f, -0.12377430f, 0.17382573f, 0.27559316f, -0.20814057f, 
    -0.05510828f, -0.25168443f, 0.05038442f, -0.05291902f, 0.23313616f, 0.08007199f, -0.44304156f, -0.13120605f, 
    -0.18934998f, -0.03636753f, -0.06623334f, -0.05893930f, -0.03791723f, -0.33949661f, 0.01303321f, 0.21559727f, 
    -0.06041517f, -0.07076780f, -0.25271094f, 0.11682934f, -0.22490036f, -0.12590307f, -0.30908340f, -0.06154087f, 
    0.04009367f, -0.22671548f, 0.15444387f, -0.21188198f, -0.04062162f, 0.12549248f, -0.06614288f, -0.03184202f, 
    0.05551772f, -0.03764304f, 0.16964911f, -0.19170709f, -0.03235928f, 0.27097172f, 0.12358180f, -0.09426651f, 
    0.07037883f, -0.51513064f, 0.30653065f, 0.15183809f, -0.31914544f, 0.00127262f, 0.03558986f, -0.27201322f, 
    0.06493889f, -0.22248226f, -0.02993822f, 0.16434877f, -0.00961933f, 0.11165369f, 0.00229413f, -0.04682812f, 
    0.00796602f, 0.24872118f, -0.06727621f, -0.39886561f, 0.21169803f, -0.07335945f, 0.23379295f, 0.05335966f, 
    0.02270643f, 0.14596194f, 0.03717647f, 0.19471298f, -0.37732449f, 0.19781753f, 0.23196726f, -0.07123739f, 
    -0.00109642f, -0.17907371f, 0.01930693f, 0.07043695f, 0.22815429f, -0.06221492f, -0.06431067f, -0.16410132f, 
    0.17428374f, -0.10170409f, -0.01545716f, 0.06271182f, -0.04954778f, 0.13267985f, 0.05792689f, -0.15769850f, 
    0.00613894f, -0.14045469f, 0.04047488f, -0.12379514f, -0.10868637f, 0.30271897f, -0.01681032f, -0.16128168f, 
    -0.17607464f, 0.24769518f, -0.44047999f, 0.04337071f, -0.43888611f, 0.04028369f, 0.03850371f, -0.08268894f, 
    -0.22512774f, -0.23405962f, 0.10685085f, 0.00815410f, 0.16080254f, 0.03915036f, 0.32454851f, -0.03293991f, 
    0.23500796f, -0.16356963f, 0.19183871f, -0.15279925f, -0.01481408f, 0.07649524f, -0.07709385f, -0.00714885f, 
    -0.23670802f, 0.11557704f, 0.08580621f, -0.02997730f, -0.40789837f, 0.19706260f, 0.26417994f, 0.10032546f, 
    -0.08075456f, -0.30075204f, -0.00282272f, 0.04792139f, -0.50156122f, -0.01550151f, -0.36860448f, 0.19898340f, 
    -0.08087834f, -0.07870099f, -0.25996307f, -0.33024710f, -0.34329820f, 0.17823429f, -0.17126873f, -0.03858291f, 
    -0.04489119f, -0.06128810f, -0.12592946f, -0.31514016f, -0.16167684f, 0.20699938f, 0.15227814f, -0.04261214f, 
    0.05213154f, 0.12969306f, -0.07525626f, 0.27606347f, -0.05323344f, 0.13083571f, 0.16745482f, -0.12188010f, 
    -0.00767426f, -0.08879898f, -0.06199908f, -0.27146599f, -0.07238821f, -0.04717547f, -0.13819563f, -0.00525427f, 
    0.13766743f, -0.30024114f, -0.33916131f, 0.09908500f, 0.23087415f, -0.00807711f, -0.02338624f, 0.01331137f, 
    -0.02376103f, -0.07200937f, -0.03276237f, -0.02918533f, 0.05639094f, 0.11291323f, -0.04686375f, -0.05456599f, 
    -0.04840385f, 0.26704246f, 0.05423928f, 0.08606064f, -0.02455336f, -0.48937118f, -0.41571543f, 0.10455514f, 
    0.03800436f, 0.11852346f, -0.28323847f, 0.15554972f, -0.01074645f, -0.09788584f, 0.11359467f, 0.07922573f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04736012f, 0.07303844f, -0.04291860f, 0.02177399f, -0.00468605f, -0.00251831f, 0.09516782f, -0.05430901f, 
    -0.02584600f, -0.06166347f, -0.01629742f, -0.06512141f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
