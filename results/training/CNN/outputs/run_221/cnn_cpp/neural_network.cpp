#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.17206991f, -0.23646267f, -0.87959522f, -1.04428709f, 0.89873093f, 1.25089979f, 0.19789678f, -0.25112912f, 
    0.07731218f, -0.37225145f, -1.05859542f, -1.20302951f, -0.37444484f, 0.05410216f, -0.27959347f, -0.97475874f, 
    -0.30690086f, 0.27565190f, 0.94773620f, 1.34039974f, -0.16161899f, -1.10434616f, -0.41073644f, -0.52612245f, 
    0.07771420f, 0.31429893f, 0.24287893f, 1.14335299f, -1.02095318f, -0.86333072f, -0.38673064f, -1.37745702f, 
    -0.73915893f, 0.02689800f, 0.19744444f, 0.11125311f, -1.16492641f, -0.34289736f, 0.33613673f, 0.51617467f, 
    1.33704627f, -0.06727569f, -0.09083661f, -0.10941102f, -0.32413578f, 1.21463513f, 0.89885342f, 1.08267975f, 
    0.10592744f, 0.61692512f, -0.71496481f, 0.69747013f, 0.73065734f, 0.14534345f, -0.34567878f, -0.58585662f, 
    -0.89799088f, 0.34775594f, -1.07076931f, 0.64984041f, -0.42188874f, -0.50772697f, -0.55869007f, -0.70126462f, 
    1.22139466f, -0.58280128f, -0.54785460f, -0.48012847f, -0.82547075f, 0.26594019f, 0.28472474f, -0.20146954f, 
    0.49530932f, 0.06990387f, 0.66975629f, 0.16992822f, -1.40188861f, 1.20561230f, 0.19579053f, -0.04207585f, 
    -0.02785208f, 1.36871231f, 0.15361631f, 0.36763602f, -1.02952266f, 0.08653411f, 0.93967867f, -0.12468199f, 
    0.58802307f, 0.48744708f, 0.81787616f, -0.15038210f, -0.69425780f, 1.41824937f, 0.84621537f, -0.93148136f, 
    0.53405106f, 0.74463695f, -0.24791804f, -0.88500947f, -1.62330544f, -0.61828184f, -0.86331958f, -0.09846756f, 
    -0.26459384f, 0.45158100f, 0.33810884f, 0.37903264f, -0.93137330f, -0.97237992f, -0.73426414f, 1.28002393f, 
    0.75029433f, 1.01542914f, 0.57213765f, -0.16206780f, -0.08500227f, -0.73609394f, -0.13985725f, 0.68379444f, 
    0.93586332f, 0.02279781f, -1.63566613f, -0.09766084f, -0.40398884f, -0.68959975f, 1.40839946f, 0.88351518f, 
    0.88133311f, 0.51222229f, -0.28021917f, -0.34220436f, 0.00162167f, -0.45642862f, -0.09046491f, -0.63024926f, 
    1.33651578f, -0.25065047f, -0.41165674f, 0.15328652f, -0.59326434f, -0.46992740f, -0.83824724f, 0.12298366f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.46075314f, 0.30945268f, 0.45541343f, 0.39088437f, 0.01200462f, 0.52796638f, -0.25353312f, 0.28390107f, 
    0.19492653f, -0.40230492f, 0.14105466f, 0.13016972f, -0.17768386f, -0.07210319f, 0.47219974f, 0.32988918f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.53777951f, -0.15234634f, -0.22780065f, 0.08010191f, 0.26727298f, 0.13427390f, -0.19114608f, -0.32496971f, 
    0.09110000f, 0.05775862f, -0.09674837f, 0.10718600f, 0.02536793f, -0.13211939f, 0.22172323f, -0.03204992f, 
    -0.12504676f, 0.31536949f, 0.02500579f, 0.03824869f, 0.29893243f, -0.25433284f, -0.28141010f, -0.17710575f, 
    0.07652409f, 0.08670144f, -0.20956476f, 0.20626400f, -0.08349781f, -0.60569286f, -0.25505897f, 0.05243485f, 
    0.05378572f, -0.03652230f, 0.21103531f, 0.10351280f, -0.08511642f, -0.36864254f, -0.10779825f, 0.11711043f, 
    -0.01995003f, 0.04275106f, 0.03094892f, -0.05001588f, -0.07458425f, -0.04556391f, 0.41769046f, 0.33792806f, 
    -0.25856841f, -0.11324872f, -0.09946730f, 0.01792853f, 0.02999627f, -0.12478256f, -0.27187794f, -0.24307103f, 
    -0.37476146f, -0.19283187f, 0.46315256f, 0.18072684f, 0.07213941f, -0.27291715f, 0.24493368f, -0.31672975f, 
    0.41056767f, 0.34052968f, -0.06236444f, -0.11376601f, -0.03245141f, -0.07217451f, 0.03227709f, 0.18545716f, 
    -0.10151634f, -0.56384015f, -0.17193586f, -0.01230298f, 0.15873232f, 0.18072709f, 0.04544608f, 0.14647761f, 
    -0.09033283f, -0.08818657f, 0.05419554f, 0.04639899f, -0.11209323f, -0.14563735f, -0.00289073f, -0.15855031f, 
    0.20130147f, -0.36653438f, -0.10265502f, -0.19278127f, 0.07207838f, 0.24940445f, -0.17966358f, -0.17462359f, 
    -0.01602243f, 0.04927171f, -0.15721056f, -0.34763202f, -0.12382211f, 0.06439020f, 0.50605839f, 0.26377255f, 
    0.02565093f, 0.10395455f, -0.05978553f, -0.22834229f, -0.25962448f, -0.03882294f, 0.34942624f, 0.42110494f, 
    0.26710865f, 0.32149926f, -0.11087470f, -0.02418152f, -0.09669323f, 0.05048469f, 0.31831375f, -0.34664598f, 
    0.05430237f, -0.08414830f, 0.05869021f, 0.24728185f, -0.19026004f, 0.46779680f, 0.05721579f, 0.41808417f, 
    0.52214259f, 0.10126474f, -0.07732274f, -0.05305381f, 0.03243371f, 0.12679547f, 0.19247822f, 0.39417905f, 
    0.14544390f, 0.16786388f, 0.41925225f, 0.02521609f, -0.00635750f, 0.13754205f, 0.19727913f, -0.27449247f, 
    -0.06819886f, -0.06629472f, -0.07716399f, -0.09365082f, -0.11631592f, -0.03790606f, -0.03667907f, -0.02518126f, 
    0.03046324f, 0.02099340f, -0.05126311f, 0.01026753f, 0.00017076f, -0.08204255f, -0.08933863f, 0.02215329f, 
    -0.04181965f, -0.05419186f, -0.05761792f, -0.03450120f, -0.00873542f, -0.05171633f, -0.02019476f, -0.09550049f, 
    -0.08301941f, 0.00509067f, -0.01348407f, -0.05610294f, 0.00769317f, -0.05365204f, 0.05790735f, 0.00086615f, 
    -0.07238927f, -0.01860953f, -0.03289833f, -0.02325491f, -0.10625775f, -0.09958727f, 0.04900125f, 0.04192620f, 
    -0.09765234f, 0.05231725f, -0.00714032f, 0.04358776f, 0.01675400f, -0.04640379f, -0.00364406f, -0.02489185f, 
    -0.00825213f, 0.05910634f, 0.07167546f, 0.03961407f, 0.06018060f, -0.05766212f, -0.04499335f, -0.07433268f, 
    0.02672809f, 0.07885841f, -0.08476939f, -0.09821557f, 0.07145673f, 0.02395151f, -0.03075628f, -0.09986080f, 
    -0.06262813f, -0.07952373f, 0.05498931f, 0.04760259f, -0.08566169f, 0.00183660f, -0.06512976f, -0.03190058f, 
    -0.07737305f, -0.01592948f, -0.08207715f, -0.05207292f, -0.09482855f, -0.02287096f, 0.06086338f, 0.06487679f, 
    -0.00748812f, -0.06690459f, 0.00177127f, -0.05944578f, -0.04298459f, 0.05208725f, 0.06779505f, 0.03097744f, 
    0.06650508f, 0.06099188f, -0.03014852f, -0.02434760f, -0.01650384f, -0.06888686f, 0.00530355f, -0.04291359f, 
    0.05948124f, -0.06807449f, -0.06396002f, -0.08151856f, 0.02432198f, 0.07579279f, 0.08697800f, 0.00519068f, 
    -0.09326892f, 0.02735874f, -0.11508510f, -0.02138095f, -0.06992937f, -0.02001450f, 0.03807203f, -0.06315642f, 
    -0.00430164f, -0.06605121f, -0.06399848f, -0.00333888f, -0.10157944f, 0.02807654f, -0.10147576f, -0.04671103f, 
    0.05549488f, -0.01782737f, -0.09607504f, -0.02645430f, -0.01829951f, -0.02079635f, -0.00223189f, -0.00377011f, 
    -0.05946745f, -0.04808906f, 0.02414791f, 0.01365259f, -0.01850146f, 0.04525093f, 0.00100031f, -0.07267962f, 
    -0.12269018f, -0.05581100f, 0.04022468f, -0.00440254f, 0.02593601f, 0.05615826f, -0.03838312f, -0.08098804f, 
    -0.57420045f, -0.19478270f, 0.03199949f, -0.01577274f, 0.02045860f, 0.06717287f, 0.04577287f, -0.04270723f, 
    0.01096588f, -0.26254621f, -0.19252433f, -0.46287954f, -0.04978506f, 0.08903152f, 0.05275349f, -0.13179334f, 
    -0.03974247f, 0.08487954f, 0.66216874f, 0.07482300f, 0.11096062f, 0.26634079f, 0.15453871f, 0.02359668f, 
    0.10930546f, -0.26387677f, -0.00417892f, -0.31615940f, 0.11861665f, -0.47362828f, -0.06831598f, -0.03107062f, 
    -0.11187586f, -0.00597114f, -0.02906514f, -0.06706970f, -0.71117467f, -0.48822141f, -0.35880178f, -0.19699571f, 
    0.18190943f, -0.14206418f, -0.05319895f, 0.03123813f, -0.02186232f, 0.47395366f, 0.44975445f, -0.04155191f, 
    -0.01342251f, 0.06143884f, -0.00502714f, -0.00155318f, 0.23880509f, 0.05492565f, -0.58771884f, 0.45641291f, 
    -0.10466906f, -0.05418221f, -0.05359376f, -0.10446548f, 0.04430428f, -0.28405881f, -0.03940595f, -0.05722499f, 
    -0.16277716f, -0.18896745f, -0.13893008f, 0.02394936f, -0.05879210f, 0.13798371f, 0.07219896f, -0.01423193f, 
    0.21562217f, 0.22576153f, 0.29341891f, 0.06578425f, 0.24580748f, 0.17520976f, 0.10021287f, -0.19571620f, 
    0.02073224f, 0.42150608f, 0.32690796f, 0.11371008f, 0.07990396f, -0.19946980f, -0.18782407f, 0.02742529f, 
    -0.03995271f, 0.37839988f, -0.40041858f, -0.56701481f, 0.00637810f, 0.12759522f, -0.03029058f, -0.08570523f, 
    0.05382819f, -0.25960010f, 0.10828984f, 0.25285664f, 0.25222418f, -0.26321548f, -0.02107612f, 0.31087017f, 
    0.03212475f, 0.19159363f, 0.15479402f, 0.08514914f, -0.42304030f, -0.21287549f, -0.05579458f, -0.05925703f, 
    -0.08154549f, -0.09861696f, -0.03546987f, 0.14172901f, -0.18236320f, 0.03494085f, -0.36257318f, -0.16224843f, 
    -0.04597284f, 0.21003616f, -0.03051265f, 0.15659063f, 0.07796839f, 0.08854128f, 0.34060031f, 0.18939148f, 
    0.15615653f, 0.09279222f, 0.19108990f, 0.12556824f, 0.09593420f, 0.19565533f, -0.14995962f, -0.09161443f, 
    -0.10297148f, 0.20785873f, -0.17644133f, 0.04855779f, -0.09943740f, 0.07507396f, 0.03718437f, 0.19186963f, 
    -0.55337435f, -0.03203458f, 0.36285526f, -0.06676223f, -0.01418065f, -0.15213026f, -0.08705603f, -0.01592754f, 
    0.04079129f, 0.21307148f, -0.22634971f, 0.46479374f, -0.20380612f, -0.09739703f, 0.12694232f, 0.21097818f, 
    0.17952842f, 0.13876709f, 0.34183013f, 0.35452989f, -0.08910644f, -0.15985402f, 0.21118003f, -0.24959049f, 
    0.14062330f, 0.01693247f, -0.04553641f, 0.13101213f, 0.27650490f, -0.03541291f, 0.00427700f, -0.15060328f, 
    -0.13915224f, 0.12969048f, 0.08445573f, -0.01731182f, -0.61469948f, -0.17736943f, 0.12748028f, 0.05011967f, 
    -0.04346868f, 0.05533833f, -0.20803183f, 0.16175216f, 0.24253407f, 0.43513283f, -0.18578096f, -0.22832963f, 
    0.30098099f, 0.09331200f, 0.04230678f, 0.17548601f, 0.01489143f, 0.11526578f, 0.45863757f, -0.06642758f, 
    -0.01319212f, 0.09867500f, 0.04069781f, 0.15514998f, -0.29347664f, 0.27327564f, 0.03383254f, -0.06191857f, 
    0.06286533f, -0.34904703f, -0.04691551f, -0.02614468f, 0.10392123f, -0.00631127f, -0.03755619f, -0.03157201f, 
    -0.33926967f, -0.33078697f, -0.50352156f, 0.35836378f, 0.10171023f, 0.05515307f, -0.15087187f, -0.01379032f, 
    -0.14206475f, -0.47369084f, 0.24262479f, 0.12935731f, 0.21237910f, 0.16730638f, -0.02110475f, 0.11263989f, 
    0.14122213f, -0.02113472f, 0.34610552f, -0.09918410f, 0.09384430f, -0.06221740f, -0.01440607f, 0.03153131f, 
    -0.13340724f, 0.03445597f, -0.13260612f, 0.05619901f, 0.03589748f, 0.04534455f, -0.01464165f, -0.12355076f, 
    -0.13015668f, 0.03654261f, -0.24926382f, -0.12933455f, -0.09375758f, -0.09830391f, 0.35232234f, 0.15019450f, 
    0.17770562f, 0.33845973f, -0.16190448f, 0.07068419f, 0.10154466f, -0.18772241f, -0.51631027f, -0.42456317f, 
    -0.12614907f, -0.17041586f, 0.06869293f, 0.11805224f, 0.13130124f, -0.04859402f, 0.79839343f, 0.34076637f, 
    -0.01916302f, 0.12674673f, 0.00222183f, -0.06710939f, 0.08098542f, 0.15331623f, -0.03770410f, -0.23622590f, 
    -0.13818327f, -0.22113293f, 0.00396796f, 0.09869350f, -0.12010458f, -0.19116253f, -0.19245972f, 0.16602951f, 
    0.09970748f, 0.13257854f, -0.08360050f, 0.12140281f, -0.13078639f, -0.03977256f, -0.02249808f, -0.13316235f, 
    0.14792265f, 0.10932904f, 0.30408531f, 0.11359496f, -0.01546851f, -0.07488203f, -0.07279532f, 0.11657137f, 
    0.14145893f, -0.20721872f, -0.30565247f, 0.13490091f, 0.19689034f, -0.01614324f, -0.17366518f, 0.13581795f, 
    -0.27024287f, 0.10013374f, -0.08158424f, -0.57875806f, 0.08627085f, 0.07342689f, 0.17808226f, 0.17172094f, 
    0.09543824f, -0.19648753f, -0.08890511f, 0.07882161f, 0.52093375f, 0.44583514f, 0.28810433f, -0.02080819f, 
    -0.13263427f, 0.13760607f, 0.10384480f, 0.12559877f, 0.12802124f, -0.22505663f, -0.07181348f, 0.03702217f, 
    0.26854515f, 0.19985539f, 0.00606250f, -0.09934339f, 0.04375340f, 0.15256366f, -0.13154860f, -0.04134979f, 
    0.40258193f, 0.24552186f, -0.05707771f, -0.22563019f, -0.02969347f, -0.18753958f, 0.24216737f, -0.10689549f, 
    -0.09416126f, 0.01439641f, 0.08883128f, 0.07111125f, -0.10008828f, 0.12126173f, -0.06275670f, -0.05966895f, 
    -0.08936737f, -0.11960787f, -0.50034434f, 0.20597699f, 0.09588110f, -0.27106664f, -0.21482269f, -0.00569074f, 
    0.01931583f, -0.01489618f, -0.09822828f, -0.38245371f, -0.02175479f, -0.18201251f, -0.16161434f, 0.00030494f, 
    0.19394551f, 0.06556294f, -0.43394193f, 0.05239686f, 0.00494783f, 0.08454444f, -0.04740100f, 0.13432455f, 
    0.32310149f, 0.22061859f, -0.16404329f, -0.13551642f, 0.31396106f, -0.30847374f, 0.04029382f, -0.09461840f, 
    -0.07622574f, 0.05908464f, 0.03290724f, 0.00389776f, 0.06164986f, 0.36706176f, 0.10280026f, -0.08727994f, 
    0.00211343f, 0.08568945f, 0.20349029f, -0.10484362f, 0.15966626f, -0.25310156f, -0.01380439f, -0.21859913f, 
    0.02613350f, -0.05610868f, 0.08211353f, 0.01762953f, 0.20067325f, 0.09678824f, -0.08509825f, 0.46224836f, 
    -0.06634580f, 0.01201500f, -0.01505235f, 0.03410605f, 0.11171101f, -0.01621173f, 0.19691546f, -0.51346815f, 
    0.17947662f, 0.20854871f, 0.07398909f, 0.14733531f, -0.09895504f, 0.21823166f, -0.00260125f, -0.06476235f, 
    0.20835359f, -0.03258378f, -0.39524174f, 0.19617388f, 0.03458713f, -0.03276424f, 0.02245423f, -0.03877318f, 
    -0.17055155f, -0.35311240f, -0.26905152f, -0.35105273f, 0.07807582f, 0.08443419f, 0.11375444f, 0.03480339f, 
    0.05056262f, 0.02823447f, 0.07230242f, 0.47820675f, 0.11487443f, -0.06849260f, -0.28899953f, 0.11377957f, 
    -0.32854226f, -0.02680989f, 0.28073323f, -0.39163357f, -0.26741922f, 0.04987737f, -0.06653243f, 0.12092454f, 
    0.08011594f, 0.11102909f, 0.17732787f, 0.06875600f, 0.13356014f, 0.34568176f, 0.24619783f, 0.10331016f, 
    -0.25416163f, -0.09386638f, -0.18387771f, 0.02531210f, -0.22458264f, 0.34552687f, 0.16508822f, 0.03134975f, 
    -0.13485725f, 0.13895343f, 0.32792729f, 0.08159176f, 0.05525607f, 0.12756868f, -0.11995166f, 0.17620938f, 
    -0.24653797f, 0.14404452f, 0.13419041f, -0.43986437f, 0.01933916f, 0.07177502f, -0.02968810f, -0.05897840f, 
    -0.20681141f, 0.03652127f, -0.04322441f, 0.01996463f, 0.07075088f, -0.07251040f, -0.08445793f, 0.15920764f, 
    -0.14812243f, 0.16513696f, 0.28292432f, 0.13607189f, -0.02598703f, 0.21489859f, 0.08085583f, 0.17273577f, 
    0.09208356f, -0.30429104f, -0.38190934f, -0.41598031f, -0.09549931f, -0.05621253f, -0.04994632f, -0.09085552f, 
    -0.09941401f, 0.01962692f, -0.27678382f, 0.09758275f, -0.05815459f, 0.01969793f, -0.15234447f, -0.01839207f, 
    0.07910769f, 0.19132374f, -0.01150645f, -0.63604325f, -0.29318917f, -0.11805648f, 0.22188987f, 0.02849988f, 
    0.34423479f, 0.36337888f, -0.25567493f, 0.10906167f, 0.25801077f, -0.24405983f, -0.80949426f, 0.29503685f, 
    0.05581549f, -0.03141163f, 0.14666200f, -0.10201976f, -0.02304061f, -0.62481976f, -0.23925819f, -0.10452254f, 
    0.02796366f, -0.05180202f, -0.06155846f, 0.03210441f, 0.22577021f, 0.19361317f, -0.13310769f, 0.24011688f, 
    0.03987759f, 0.06196934f, -0.02612063f, -0.10993712f, 0.06085858f, 0.12755209f, -0.03096722f, 0.46137181f, 
    -0.09170364f, -0.25168365f, -0.09401187f, -0.14224151f, 0.17833169f, 0.05540939f, 0.12941302f, 0.06706045f, 
    0.02271588f, 0.01614645f, 0.06101769f, -0.04792169f, -0.06682934f, -0.04086852f, -0.08741040f, 0.05624655f, 
    0.00577812f, 0.00696716f, -0.01210411f, 0.01695750f, -0.04084717f, -0.06746054f, -0.03970789f, -0.03342505f, 
    -0.08859760f, 0.01973774f, -0.02653470f, -0.08737702f, 0.04378741f, -0.07545824f, -0.03793310f, -0.04626912f, 
    0.02556000f, -0.04233481f, -0.02762803f, 0.00844644f, 0.01633307f, 0.05732542f, 0.03801869f, -0.03331101f, 
    -0.00474236f, -0.03823236f, 0.02924248f, -0.07808190f, -0.02413649f, -0.07956561f, -0.06337240f, 0.07013300f, 
    0.02658684f, -0.01796136f, 0.01008566f, -0.02576253f, -0.07307626f, 0.03942698f, -0.02320058f, 0.01635307f, 
    0.05653252f, 0.00849808f, 0.05197865f, -0.06407827f, -0.02948908f, -0.02367572f, -0.05523865f, -0.05613418f, 
    -0.04595974f, 0.06478824f, 0.06548017f, -0.06902341f, -0.06128812f, -0.06954166f, -0.04487305f, 0.00040894f, 
    -0.07490714f, 0.02905727f, -0.00974948f, -0.05736371f, -0.07448353f, -0.08053263f, 0.01298532f, -0.08138233f, 
    -0.07050084f, 0.02859149f, 0.02423591f, -0.00496540f, 0.02503695f, -0.04503679f, -0.08848707f, -0.01983065f, 
    -0.02495825f, 0.01770386f, 0.04420137f, 0.03151083f, -0.07851461f, 0.01335633f, 0.03933235f, 0.03782976f, 
    -0.03190722f, -0.03125480f, -0.07513906f, 0.05863496f, -0.02618690f, 0.04751349f, 0.05973443f, -0.05554112f, 
    0.05806929f, -0.04885138f, -0.03306682f, -0.03312457f, -0.03431761f, -0.06298492f, -0.00688373f, -0.04897580f, 
    0.01851088f, 0.06659582f, 0.07351941f, -0.08950572f, -0.02795555f, -0.00200833f, 0.00047370f, -0.04211042f, 
    0.05659531f, 0.06571355f, -0.02636352f, -0.03513054f, -0.07215090f, -0.08468147f, 0.03004699f, -0.00677818f, 
    0.06405948f, -0.09235810f, 0.04838287f, -0.04162264f, -0.02498453f, -0.06432442f, 0.05353275f, -0.00177364f, 
    -0.04301269f, 0.04840923f, 0.04872602f, 0.00774675f, -0.03872772f, -0.07638969f, -0.08178101f, -0.09632333f, 
    0.05463362f, -0.08017963f, 0.01647807f, -0.02134795f, 0.05355040f, -0.05820238f, 0.01288619f, 0.07330622f, 
    0.33398730f, 0.54841667f, -0.30636615f, -0.00510052f, -0.14141071f, 0.17885691f, 0.09967259f, -0.08887079f, 
    0.14774269f, -0.08938263f, 0.08246824f, -0.19705114f, -0.12466102f, 0.00227018f, 0.09465817f, 0.04945908f, 
    -0.11494538f, 0.04513936f, 0.44648498f, -0.12534922f, 0.09647223f, -0.08426625f, -0.12358453f, 0.06023818f, 
    0.13072719f, -0.01833851f, -0.04127336f, -0.39325330f, -0.25360754f, 0.19675443f, 0.23314714f, 0.18354116f, 
    -0.15109478f, -0.24317443f, 0.02396304f, 0.16061038f, -0.25358081f, 0.17177601f, 0.17063366f, 0.03510703f, 
    0.01489644f, 0.21941157f, 0.08951955f, 0.04189565f, 0.17265679f, 0.29309162f, 0.00817666f, 0.27028939f, 
    -0.13319573f, 0.02544635f, 0.14457361f, -0.16591777f, 0.05138504f, -0.14732471f, 0.12951416f, -0.18414879f, 
    -0.14954388f, 0.05836736f, 0.10363077f, 0.08865719f, 0.00794107f, 0.22617832f, -0.03370419f, -0.11221273f, 
    -0.07602227f, -0.84620428f, -0.15182690f, 0.20398694f, 0.06801337f, 0.18380401f, 0.14646739f, -0.12934387f, 
    -0.14458045f, -0.10979907f, -0.03446095f, 0.23865871f, -0.34424511f, 0.04616085f, 0.03818578f, -0.10960181f, 
    -0.14003652f, -0.03131025f, -0.12482999f, -0.36686641f, 0.06554048f, -0.41609505f, -0.19949037f, 0.10778514f, 
    -0.04783395f, 0.13961160f, 0.12095531f, -1.11178267f, -0.06991227f, -0.27624115f, 0.00731245f, -0.16626707f, 
    0.01749970f, -0.11974915f, 0.17848943f, -0.03908668f, 0.42899251f, 0.06492544f, 0.01999221f, 0.05947185f, 
    0.14847387f, 0.20664831f, -0.06432178f, -0.20934889f, 0.08409236f, 0.34766561f, -0.16790299f, 0.18256214f, 
    0.33473375f, -0.09024906f, 0.00779081f, 0.14407040f, -0.00028844f, -0.52420092f, -0.38820258f, 0.02087351f, 
    -0.19987065f, 0.18612890f, 0.03931710f, -0.06123633f, -0.13311154f, -0.09220628f, 0.39356321f, -0.22914478f, 
    0.49120733f, 0.02649136f, -0.04245168f, 0.10574999f, 0.08369026f, 0.18844435f, 0.31306940f, 0.12830561f, 
    -0.00797195f, -0.52020496f, -0.06027202f, 0.20106432f, -0.10848746f, -0.08858089f, 0.05479027f, -0.17533249f, 
    -0.01318250f, -0.02363276f, -0.02686327f, -0.08843155f, -0.00086064f, 0.04351572f, 0.01381734f, -0.09142245f, 
    -0.09185310f, 0.05136335f, -0.04098693f, 0.02291979f, -0.07311185f, -0.10891572f, 0.00931131f, 0.03815436f, 
    0.02837626f, -0.05135038f, 0.05245714f, 0.00660035f, 0.03498119f, -0.02079772f, 0.05403387f, 0.05486007f, 
    -0.03406936f, -0.01861382f, -0.01360766f, -0.07430581f, -0.04589867f, -0.04201613f, 0.01852657f, -0.09692287f, 
    -0.01535696f, 0.08770977f, -0.08168285f, -0.07329559f, -0.06330538f, 0.05299637f, -0.03283098f, 0.01860336f, 
    0.00115657f, 0.01654720f, 0.04379912f, -0.09029660f, -0.02110804f, -0.02747684f, -0.01903895f, -0.10448222f, 
    -0.07615054f, -0.08444136f, -0.01229335f, 0.03947183f, 0.02412844f, -0.06037354f, -0.01686608f, 0.02418847f, 
    -0.04959438f, -0.05408587f, -0.09400212f, -0.04627628f, 0.02761214f, -0.04273937f, -0.00397557f, -0.00744414f, 
    -0.07564714f, -0.04215573f, -0.08433829f, -0.11259137f, 0.02489028f, 0.01301844f, -0.05385802f, 0.05633017f, 
    -0.09235050f, 0.00969119f, 0.04144777f, 0.03664226f, -0.05833525f, 0.05966384f, -0.07405385f, 0.05052201f, 
    0.03808742f, -0.07137302f, 0.00656603f, 0.01956703f, -0.07598776f, -0.01032989f, -0.02240578f, -0.07483636f, 
    0.02882041f, -0.02470386f, -0.00360949f, -0.00289003f, 0.05646771f, 0.00456392f, 0.01501596f, 0.05426976f, 
    -0.02716044f, 0.04829579f, 0.06162244f, -0.02220610f, 0.02331643f, -0.08415645f, -0.11709636f, -0.05858594f, 
    -0.06513793f, -0.02533051f, 0.04950022f, -0.10464963f, -0.00312087f, -0.05408221f, 0.03900281f, 0.04590302f, 
    0.01206787f, 0.00580974f, 0.03346928f, -0.07710481f, 0.00611637f, -0.07526150f, -0.00034642f, 0.03641462f, 
    -0.05027634f, 0.00032187f, -0.05126661f, -0.07837641f, 0.00245335f, 0.04993482f, -0.05329846f, 0.01753891f, 
    -0.05391308f, -0.06859441f, -0.02884533f, 0.04223415f, 0.03588131f, -0.03624831f, -0.06300077f, -0.03677468f, 
    -0.13319932f, -0.07566425f, -0.01661447f, -0.04394684f, -0.01005829f, -0.07397325f, -0.04855373f, 0.03939420f, 
    -0.18180192f, -0.30532038f, 0.16513135f, 0.10125457f, -0.23048694f, 0.02261818f, 0.06322391f, 0.22046646f, 
    0.08853755f, -0.06170787f, -0.33243001f, 0.47279546f, 0.06638066f, -0.19259053f, 0.14378925f, 0.06941484f, 
    -0.25575769f, -0.13049693f, -0.54224628f, -0.20136511f, -0.27531299f, 0.11855981f, 0.25274584f, -0.24286042f, 
    -0.17861710f, -0.01604716f, -0.11636526f, 0.80662721f, 0.47162044f, 0.07504930f, -0.26452243f, 0.00688996f, 
    -0.05460094f, -0.16607635f, -0.01865415f, 0.15603828f, -0.20710500f, 0.40510717f, 0.10711545f, 0.17356120f, 
    -0.20263605f, -0.18285094f, -0.17568466f, -0.03974263f, 0.17703684f, -0.74625546f, 0.02026459f, 0.07960167f, 
    -0.12026030f, 0.03932222f, 0.17096618f, 0.01022452f, -0.01155351f, -0.24798600f, -0.16674526f, -0.08591751f, 
    0.38358000f, 0.09354372f, 0.12789279f, -0.13418651f, -0.17380252f, -0.12016971f, -0.00809036f, 0.18345225f, 
    0.19059844f, -0.34898579f, 0.00542251f, 0.09794676f, 0.13958414f, -0.18833537f, 0.12363368f, -0.03090528f, 
    0.39526069f, -0.23832746f, -0.19015799f, -0.01173393f, 0.19380131f, -0.11161792f, 0.02921529f, -0.01975247f, 
    0.01564237f, -0.30176693f, -0.06361675f, -0.12721521f, -0.28161564f, 0.16869584f, -0.28709930f, -0.17629384f, 
    0.13387337f, 0.34792995f, 0.24095330f, 0.06222971f, -0.13140579f, -0.24778083f, -0.16195884f, -0.10459028f, 
    -0.11800832f, 0.21670899f, -0.20213167f, -0.38067532f, -0.03400506f, 0.54896247f, -0.24193975f, -0.23067683f, 
    -0.18498193f, 0.00473250f, -0.01080533f, 0.18774010f, 0.14344312f, -0.05968422f, 0.21210025f, 0.02424166f, 
    0.05675147f, 0.23992522f, -0.05601604f, 0.00537150f, 0.23094967f, 0.82136595f, -0.07761566f, -0.11852167f, 
    -0.02123808f, -0.00582396f, 0.07568908f, -0.07052159f, 0.00905971f, 0.12123618f, -0.48621032f, 0.04176232f, 
    -0.19564758f, 0.13566008f, -0.00098309f, 0.11361243f, 0.17633721f, -0.09017809f, 0.20884623f, 0.36741251f, 
    0.21621646f, -0.01380746f, 0.07092319f, 0.21100065f, -0.11122337f, -0.10604399f, 0.03787727f, -0.10760354f, 
    0.05313385f, -0.04616508f, 0.01430296f, -0.01687335f, -0.06027444f, -0.00864353f, -0.02865124f, -0.02124589f, 
    -0.02034980f, -0.04516605f, -0.01105727f, -0.03740948f, 0.07972789f, -0.03305002f, 0.05005397f, 0.02700055f, 
    -0.06731968f, -0.06795173f, 0.05640639f, 0.01056603f, 0.06628653f, -0.01030035f, 0.08050510f, -0.01945346f, 
    0.00331166f, -0.03267626f, 0.06065379f, -0.00451593f, 0.05091834f, -0.00296594f, -0.03157489f, -0.06475362f, 
    -0.01749733f, -0.03647381f, -0.03822795f, -0.04396416f, 0.05084647f, -0.06546612f, -0.04819927f, -0.06431228f, 
    0.00020427f, -0.08237635f, -0.05128145f, 0.05614736f, 0.03877368f, -0.00874763f, -0.05642413f, -0.06555662f, 
    -0.02691212f, -0.02281868f, -0.07529475f, 0.04977462f, -0.01813988f, 0.05630227f, -0.07718599f, 0.07100504f, 
    -0.07805844f, 0.00071937f, -0.03963100f, 0.00602622f, 0.06787806f, 0.04557235f, 0.03630447f, -0.04460420f, 
    -0.03103167f, -0.02673396f, 0.04637017f, -0.04760233f, -0.02066365f, -0.03679832f, -0.02743712f, -0.01288114f, 
    0.06272768f, -0.06273007f, -0.01368372f, -0.07843961f, -0.06683968f, -0.07278870f, -0.02379447f, -0.01785868f, 
    -0.01124597f, 0.02804562f, 0.01065697f, -0.06595644f, -0.02654803f, -0.00040704f, -0.05028304f, 0.05163614f, 
    0.06340258f, -0.03747235f, -0.01109680f, -0.05531150f, -0.06893198f, 0.02523877f, 0.02256246f, -0.03145195f, 
    -0.07144847f, -0.00579451f, -0.06077701f, 0.02133306f, 0.01071734f, -0.05390645f, -0.04289931f, 0.02634185f, 
    0.05479614f, 0.00287353f, 0.01161267f, -0.05254082f, -0.00143256f, -0.07649459f, -0.03687058f, 0.06057420f, 
    -0.02747348f, 0.00496663f, -0.01936970f, 0.05862982f, -0.05424107f, 0.02562126f, 0.02006066f, 0.01020230f, 
    -0.02071036f, -0.02788706f, -0.03496045f, -0.00606744f, -0.05684394f, 0.06422073f, -0.02754714f, 0.07408355f, 
    0.01982899f, -0.02361135f, -0.06442767f, -0.01113048f, -0.02890830f, -0.04158675f, 0.02294257f, -0.02707170f, 
    0.05407060f, 0.02364431f, -0.06759363f, 0.03675715f, 0.05193701f, -0.02271791f, -0.03997785f, -0.05153790f, 
    0.11809853f, -0.23379591f, 0.04688099f, 0.29253528f, 0.17253970f, -0.24245073f, -0.13175553f, -0.05768187f, 
    -0.12500635f, 0.35727212f, 0.29699486f, 0.28714165f, 0.21934189f, -0.06341478f, 0.09427100f, -0.41280544f, 
    0.07365733f, -0.19066592f, -0.44135264f, -0.16935986f, -0.19508986f, -0.17960373f, -0.45184529f, -0.17126475f, 
    -0.10690777f, -0.13999380f, 0.00404970f, 0.34950751f, 0.29952320f, -0.18859534f, -0.33564061f, -0.03123312f, 
    -0.02722009f, -0.06563669f, -0.15904829f, -0.21331590f, 0.08929101f, 0.51646078f, 0.49777514f, 0.24051060f, 
    0.24030739f, -0.14242397f, -0.19697246f, 0.06471284f, 0.19382074f, 0.01319519f, -0.19158295f, -0.03803236f, 
    -0.10193306f, -0.31640187f, 0.11554599f, -0.01910191f, 0.23043174f, -0.07697401f, 0.74736321f, 0.43294966f, 
    0.35322213f, 0.20863460f, 0.12911144f, 0.22580749f, -0.35939980f, 0.11502621f, -0.09149230f, -0.33743748f, 
    -0.30940151f, -0.04375598f, -0.02825390f, -0.09602980f, -0.35212275f, -0.01483623f, -0.16601844f, -0.11501556f, 
    0.38852245f, -0.29213104f, -0.43991464f, -0.02524066f, -0.40102202f, -0.11565222f, -0.22409357f, -0.07763493f, 
    -0.00057222f, 0.26290265f, -0.16032180f, -0.37487260f, -0.16546971f, 0.08456463f, 0.00476481f, -0.04737231f, 
    -0.02469547f, 0.22054957f, -0.18671595f, 0.32882494f, 0.18094414f, -0.09949878f, -0.06764062f, -0.05287925f, 
    0.05800244f, 0.26701969f, -0.15352619f, 0.25643715f, 0.11313501f, 0.36028236f, -0.13975705f, -0.15285790f, 
    -0.09663632f, 0.14361876f, 0.07200416f, -0.33926538f, 0.10789759f, -0.08324615f, 0.25935116f, 0.30192515f, 
    0.10485491f, -0.07951867f, 0.10934572f, 0.17670055f, 0.29662126f, 0.23878041f, 0.30697310f, 0.20097859f, 
    0.13158135f, 0.01384568f, 0.23807718f, 0.02782221f, -0.03389311f, 0.01175551f, -0.00755410f, -0.26428053f, 
    0.08853319f, 0.05041136f, -0.26067305f, -0.04097363f, -0.00578454f, -0.12786625f, 0.07662503f, -0.45755860f, 
    -0.25686675f, 0.07898502f, 0.08417023f, 0.14263251f, 0.05615212f, -0.11970991f, -0.00820991f, -0.24216715f, 
    0.11724906f, -0.03661102f, 0.18963587f, 0.04867354f, 0.07380137f, -0.24651083f, 0.07822749f, 0.19231768f, 
    0.00518605f, 0.30205178f, -0.05462444f, -0.02913259f, -0.04826457f, -0.17101102f, 0.00115423f, -0.12825933f, 
    0.33836228f, -0.18210308f, 0.19113067f, -0.19800906f, 0.19085070f, 0.06338956f, -0.13310166f, -0.06010375f, 
    -0.18547253f, -0.19535464f, -0.03753287f, 0.80284631f, 0.08576134f, 0.16283377f, 0.03282670f, 0.02307291f, 
    0.22016343f, 0.15069404f, -0.11716410f, -0.02181317f, -0.06845272f, 0.17810299f, -0.22504826f, -0.16890316f, 
    0.17469011f, -0.28545097f, 0.10255220f, 0.23651585f, -0.20070320f, -0.39017603f, -0.79886484f, -0.12819465f, 
    0.24192643f, 0.03076637f, 0.00641454f, -0.02707687f, -0.00188923f, 0.16316232f, -0.14537703f, 0.13599126f, 
    -0.01857671f, 0.14081439f, -0.16292614f, 0.09400894f, -0.15376996f, 0.08786876f, -0.15434887f, 0.38146988f, 
    0.04485425f, -0.23108767f, 0.01503036f, -0.08819257f, -0.00081972f, 0.06199047f, -0.14023566f, 0.15675214f, 
    -0.56725645f, -0.23604649f, 0.00168235f, 0.08530080f, -0.15729420f, 0.19763580f, 0.10226206f, 0.07510864f, 
    0.49506244f, -0.84669650f, -0.52538747f, -0.08518546f, -0.03776044f, 0.07989007f, -0.10151943f, 0.48358488f, 
    0.01797402f, 0.27562281f, 0.19009620f, 0.04095520f, -0.26734036f, -0.44613087f, -0.14929353f, -0.05756639f, 
    0.18688078f, 0.32922301f, 0.37523040f, -0.06976803f, 0.40258339f, 0.06378278f, 0.02349425f, -0.22586173f, 
    0.13485317f, -0.05606447f, 0.31660095f, 0.29279840f, 0.60244018f, 0.52825803f, 0.25446260f, 0.03126001f, 
    0.24701487f, 0.02167703f, -0.02605399f, 0.24096243f, 0.08342954f, -0.35314214f, 0.17166908f, -0.25625995f, 
    0.04219588f, 0.01528038f, 0.16213554f, -0.14359041f, -0.07575747f, 0.01916896f, -0.59980547f, -0.52597791f, 
    0.34398943f, 0.07745077f, 0.14967929f, 0.08250698f, -0.20498356f, -0.16280590f, 0.00415238f, -0.05039808f, 
    -0.33911538f, -0.14545861f, 0.14131072f, 0.20358917f, 0.19439538f, -0.33663276f, -0.06573467f, -0.14702006f, 
    0.36819974f, -0.30231565f, -0.13617630f, -0.09652822f, 0.22701780f, 0.00800531f, -0.08939035f, 0.01611514f, 
    0.08071601f, 0.12715153f, -0.47161061f, 0.51027155f, -0.14895827f, -0.03321708f, 0.00609377f, -0.04154361f, 
    -0.15405884f, 0.28252798f, -0.21390742f, 0.04389205f, 0.24638475f, 0.15111673f, 0.03814937f, -0.25932530f, 
    0.09676664f, 0.09408180f, 0.04050673f, 0.31993413f, -0.07538410f, 0.34557959f, -0.12090211f, 0.21372694f, 
    -0.40342405f, 0.12068450f, 0.13455544f, -0.25553906f, 0.15149903f, -0.04243803f, -0.11268558f, -0.18790646f, 
    -0.10561408f, 0.26942089f, 0.20656271f, 0.00055279f, 0.03997947f, -0.32699430f, -0.03153250f, 0.41512570f, 
    -0.02475074f, 0.05011597f, 0.00029429f, -0.13326314f, 0.10850596f, -0.22197579f, 0.07026985f, -0.18194933f, 
    -0.27649650f, -0.05230002f, 0.10786171f, -0.03891764f, -0.08887774f, -0.07494907f, 0.42336380f, 0.45619437f, 
    0.19084303f, 0.27432075f, -0.19320421f, -0.14846958f, -0.06322337f, -0.03794686f, 0.08539256f, 0.14055438f, 
    -0.07687436f, -0.12512428f, 0.11630785f, 0.17462921f, 0.05896344f, 0.12446234f, 0.32745698f, -0.08044636f, 
    -0.26296324f, -0.07746065f, -0.05307704f, -0.05516135f, 0.01754668f, -0.02818408f, 0.02815806f, 0.03149992f, 
    -0.03296622f, -0.30559978f, -0.22603677f, -0.27340534f, 0.16784278f, 0.23736811f, 0.03708898f, -0.06132566f, 
    -0.11450893f, -0.00241195f, -0.39191997f, 0.19466770f, -0.31906047f, 0.01494706f, -0.29269037f, -0.33302143f, 
    -0.03211302f, 0.17857771f, 0.01152971f, 0.07171962f, 0.21556130f, -0.16613056f, -0.53136861f, 0.13958849f, 
    0.21253975f, 0.07368778f, -0.15999936f, -0.02956123f, -0.08349011f, 0.12260285f, 0.00039909f, 0.40953833f, 
    -0.02236070f, -0.39036897f, 0.10633910f, 0.26575720f, 0.17380726f, -0.10082131f, -0.63348782f, -0.13195364f, 
    0.30945608f, 0.16588466f, 0.15865259f, 0.32387382f, 0.09579952f, 0.11019795f, -0.07088809f, 0.51503932f, 
    -0.06008140f, -0.02255246f, -0.03204669f, -0.20916487f, -0.02700114f, 0.15284990f, 0.07190401f, 0.01611131f, 
    0.78058183f, 0.15736338f, -0.12611990f, 0.10908393f, 0.02347820f, 0.02020277f, -0.03293541f, 0.01529969f, 
    0.00570421f, -0.02278042f, -0.30626935f, 0.17933933f, -0.04253928f, 0.15822884f, -0.02890075f, 0.08770935f, 
    0.10353938f, 0.39546207f, 0.14256208f, 0.21353365f, 0.14012472f, -0.11831312f, 0.13034011f, 0.07679828f, 
    -0.05442233f, 0.04769472f, -0.20630230f, -0.85055929f, -0.12650160f, -0.11960861f, 0.03369663f, 0.22727309f, 
    0.30257958f, 0.03412481f, -0.00384118f, -0.18101637f, 0.41860408f, -0.07778017f, -0.32378155f, -0.16714624f, 
    -0.10375690f, 0.00774588f, 0.30561742f, 0.10053306f, -0.05809670f, -0.28426087f, 0.27704841f, -0.17096825f, 
    0.18614496f, 0.14313102f, 0.02615291f, 0.06329444f, 0.11230306f, -0.00459012f, -0.19926451f, 0.09709647f, 
    -0.00060831f, 0.06346256f, 0.26247680f, -0.20729612f, -0.11660615f, -0.08599490f, -0.16911259f, 0.01569250f, 
    -0.24652804f, -0.47957486f, 0.26609349f, 0.07535531f, 0.11411887f, -0.03353009f, -0.00753086f, -0.15517369f, 
    -0.79555333f, 0.20322883f, -0.30422097f, 0.07990713f, -0.24051255f, 0.14424135f, 0.02964905f, 0.13188007f, 
    0.24001203f, -0.06679437f, 0.09247541f, -0.07777634f, 0.19262503f, -0.18804356f, 0.14646308f, -0.41314343f, 
    -0.14565614f, 0.17537490f, 0.02972721f, -0.51090109f, 0.31592196f, -0.10851141f, -0.11990851f, 0.07924695f, 
    0.07217404f, 0.03964231f, 0.05746841f, 0.79534751f, -0.36031607f, -0.07016008f, -0.05724145f, 0.08499065f, 
    -0.12465093f, 0.06477218f, -0.03463722f, -0.03461303f, 0.23809962f, 0.72637707f, -0.03660358f, 0.04834159f, 
    -0.07960898f, 0.11944953f, -0.02630462f, -0.02458214f, 0.01354710f, -0.00370357f, -0.72633481f, -0.32889390f, 
    -0.01593165f, 0.10053318f, -0.07872184f, -0.15840125f, 0.01672881f, 0.07403481f, -0.38080296f, -0.23706734f, 
    -0.15055960f, 0.16448472f, 0.00404406f, 0.21062800f, -0.12882191f, 0.10740876f, 0.23517695f, -0.07143421f, 
    0.05070779f, -0.26282483f, -0.11699569f, 0.05487563f, -0.03956231f, -0.23730600f, 0.02589538f, 0.02355343f, 
    -0.00955075f, -0.26747796f, 0.26269051f, -0.11587735f, 0.07581484f, 0.03875135f, 0.01563069f, 0.04264801f, 
    0.09915137f, -0.08247872f, 0.13556412f, -0.19516838f, -0.07739954f, -0.01270819f, 0.11919136f, -0.03451812f, 
    0.07796285f, -0.04850652f, 0.13505827f, 0.32418701f, -0.30404249f, 0.10178974f, -0.25184447f, -0.05410905f, 
    0.14601038f, -0.05784825f, -0.02064681f, 0.55417669f, 0.15401842f, 0.05918175f, 0.17569216f, -0.01267029f, 
    -0.00542736f, 0.01426316f, -0.00541175f, -0.04805785f, -0.29766452f, -0.26100653f, -0.10339089f, -0.00239024f, 
    -0.04047730f, -0.10077588f, 0.03770578f, -0.06375128f, 0.03195617f, 0.42244890f, 0.09427730f, -0.29810616f, 
    -0.09622572f, 0.15840805f, -0.13968050f, -0.08718235f, 0.04186009f, -0.04614170f, -0.14594635f, -0.15893920f, 
    0.13418683f, 0.20069046f, -0.04003410f, 0.08725103f, 0.06011709f, 0.01744119f, -0.00761230f, -0.80945629f, 
    -0.54007918f, -1.09432399f, 0.06554420f, 0.23600414f, -0.05516321f, -0.10414830f, 0.15742150f, 0.01026093f, 
    0.24228323f, 0.07809066f, 0.07694006f, 0.05831715f, 0.21376103f, 0.00950434f, -0.00686097f, 0.07140344f, 
    0.05788036f, 0.33683848f, -0.08407596f, 0.11588889f, 0.18657629f, -0.04198000f, -0.04391757f, 0.12391645f, 
    0.06772590f, -0.02737510f, 0.59330827f, 0.30235910f, -0.23585571f, -0.08882188f, -0.31134331f, -0.02994008f, 
    0.04163657f, -0.13338031f, 0.18242842f, -0.12681881f, 0.31636006f, 0.46608797f, 0.41497076f, -0.01726646f, 
    -0.09104717f, -0.12626384f, 0.03559015f, 0.05056653f, 0.06484825f, -0.06900892f, 0.50252438f, 0.12931331f, 
    -0.01766965f, 0.07448075f, -0.09431297f, 0.06977887f, 0.05819749f, -0.80539638f, -0.64389610f, -0.03583542f, 
    -0.12736043f, 0.00039030f, 0.11704439f, -0.15709214f, 0.03008481f, 0.22700606f, -0.08030857f, 0.47210899f, 
    0.07981157f, -0.23904255f, 0.05647050f, -0.24323608f, 0.06843972f, -0.07979207f, -0.08621734f, -0.62523544f, 
    0.05539917f, -0.66913539f, 0.37300783f, -0.19428678f, 0.13057895f, 0.05383613f, 0.09791148f, 0.11293540f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.03321718f, -0.08966467f, 0.06178133f, 0.05191081f, 0.14653106f, 0.35603657f, -0.08220363f, -0.00273108f, 
    -0.04059190f, 0.02101431f, -0.07631135f, -0.31275588f, 0.14607510f, 0.09289795f, 0.29818323f, 0.17343988f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12443437f, -0.20227791f, -1.26664865f, -0.42873132f, 0.67865354f, 0.80055165f, 0.16662303f, 0.54990631f, 
    0.03607185f, -0.08081532f, -0.12917852f, -0.20948628f, -0.31303260f, 0.05362073f, -0.21705395f, -0.16183932f, 
    -0.25916260f, 0.11879314f, 0.12279829f, -0.59186596f, -0.35862875f, 0.36541227f, 0.11480976f, 0.76142412f, 
    -0.04522501f, -0.02679278f, 0.03327152f, 0.00391409f, -0.16588032f, 0.02763221f, 0.40047416f, 0.42823011f, 
    -0.00125347f, -0.21625610f, -0.09434491f, -0.09502103f, -0.07565597f, -0.49081871f, -0.24218641f, -0.26787224f, 
    -0.15753348f, -0.15790588f, 0.10212004f, -0.99116737f, -0.57070762f, -0.24253352f, 1.23243296f, 0.43821883f, 
    -0.69938868f, -0.01240699f, 0.16037329f, -0.10335089f, -0.70667529f, -0.48011959f, 0.22878338f, -0.04375826f, 
    -0.18498491f, 0.75640041f, 0.22069049f, -0.48621669f, 0.62722063f, 0.57154411f, -0.20493853f, -0.51159185f, 
    0.47439378f, -0.15868041f, -0.41702330f, 0.19024760f, 0.17662369f, -0.09492840f, 0.21940956f, -0.30689692f, 
    -0.10309205f, 0.18962669f, 0.02277410f, -0.42618179f, -0.35112447f, 0.25087306f, -0.16765559f, -0.23880932f, 
    -0.03143658f, -0.09487836f, 0.31493524f, -0.32031998f, 0.15594725f, 0.60131419f, -0.04654517f, 0.08292922f, 
    -0.04103545f, -0.42575821f, 0.17239416f, 0.58302748f, -0.22576539f, 0.01025897f, 0.01624609f, -0.65065432f, 
    0.45151317f, 0.05701708f, 0.81512332f, -0.01600905f, -0.44361219f, 0.01457579f, -0.13840489f, 0.01794867f, 
    -0.12763728f, 0.01209159f, -0.18544647f, -0.71140909f, -0.13694710f, 0.13827603f, -0.43709284f, -0.65350050f, 
    -0.38219061f, 0.12038499f, 0.14162458f, -0.56901097f, 0.58976853f, -0.17458551f, -0.00669747f, 0.10936540f, 
    -0.01206206f, 0.45418188f, -0.00842351f, 0.96701187f, -0.29130185f, -0.39820248f, -0.22780141f, -0.13416274f, 
    -0.36185575f, 0.04306306f, 0.38263974f, 0.04077328f, -0.02584533f, -0.23143663f, -0.00099632f, 0.28586453f, 
    0.20765154f, -1.21221995f, 0.01739681f, -0.45021224f, 0.60025501f, -1.18079066f, -0.49268889f, 1.04942060f, 
    0.42603609f, 0.00602222f, -0.41829515f, 0.43522802f, -0.18854980f, 0.43130583f, -0.17701949f, -0.89069849f, 
    -0.19216792f, -0.08624186f, -0.19097582f, 0.15283424f, -0.46849218f, 0.17037347f, -0.32593581f, 0.39410654f, 
    -1.02199030f, 0.01652234f, 0.19904932f, -0.31601641f, 0.39055163f, -0.51181811f, -0.00038436f, -0.42698658f, 
    0.16086149f, -0.07190917f, -0.18707743f, -0.71479589f, 0.89450079f, -0.09913825f, 0.31602123f, -0.17634347f, 
    -0.35192314f, -0.05988759f, -0.13672851f, 1.01242423f, -0.64034671f, -0.51072645f, -0.11964338f, 0.48228538f, 
    0.06087635f, -0.83220643f, 0.17149150f, -0.18215483f, 0.16938671f, 0.25502503f, -0.05057189f, -0.40649879f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12032951f, -0.09705857f, -0.46062016f, -0.19991083f, 0.22810577f, 0.21556926f, -0.00522003f, -0.65783811f, 
    -0.33440742f, -0.14531499f, 0.59313601f, 0.27244213f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
