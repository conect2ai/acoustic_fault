#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.12655270f, 0.29889995f, -0.41474524f, -0.52693284f, 0.65669018f, 0.11223847f, 0.24525523f, 0.67287970f, 
    0.88830692f, -0.20905501f, -0.11224899f, -0.08187989f, 0.11233665f, -0.30844781f, -0.06983448f, 0.10810056f, 
    -0.15605213f, -0.20973149f, 0.04464660f, 0.02215934f, 0.04373556f, -0.05869351f, 0.06403363f, 0.11778940f, 
    -0.02100922f, 0.13163334f, 0.00600410f, -0.28821942f, -0.48190394f, -0.12835655f, -0.23804076f, -0.13679628f, 
    0.20038569f, 0.01617060f, -0.29338366f, 0.30725843f, -0.08409417f, -0.13879871f, -0.47762534f, -0.22765656f, 
    -0.24595734f, -0.16780777f, -0.50333321f, -0.59496826f, -0.67807364f, -0.37721056f, 0.11835303f, -0.14315608f, 
    -0.39131513f, -0.47859618f, -0.28060737f, 0.43377432f, -0.18197940f, -0.34649521f, -0.22610317f, -0.15004675f, 
    -0.12994787f, -0.22441134f, 0.47710350f, -0.14719087f, -0.05202676f, -0.16886875f, 0.48898494f, 0.58568096f, 
    0.23625918f, 0.36492836f, -0.16751517f, -0.29863200f, -0.18716273f, -0.23844588f, -0.25501335f, -0.22458410f, 
    -0.11383609f, -0.05213937f, -0.19207229f, -0.45942223f, -0.29322100f, -0.26967502f, -0.07751776f, -0.51524168f, 
    -0.74696553f, -0.52307701f, -0.50299823f, -0.05931421f, -0.68358564f, 0.43650171f, 0.22058243f, 0.38467932f, 
    -0.16312832f, -0.03928998f, 0.03187346f, 0.16005351f, 0.01869090f, -0.27489388f, 0.03274263f, 0.22990854f, 
    0.22157112f, -0.14440431f, 0.20183869f, 0.54811001f, -1.29076862f, 0.20225719f, 0.88609135f, 0.52596682f, 
    -0.53302884f, -0.48448285f, -0.96608675f, -0.21066105f, 0.55455744f, 0.52319002f, 0.14853591f, -0.02611941f, 
    -0.27923560f, 0.68457538f, -0.24625228f, -0.05157534f, -0.05469948f, 0.08323127f, 0.01985451f, -0.00386938f, 
    0.11953674f, -0.12404316f, 0.11782271f, -0.15184328f, 0.02951564f, 0.46695921f, -0.42327148f, -0.88703722f, 
    -0.41883448f, 0.31483230f, 0.50973982f, -0.18659572f, -0.05304909f, -0.04747857f, -0.07347767f, 0.45746925f, 
    -0.14460325f, 0.10068239f, 0.29445285f, -0.09765118f, -0.09511587f, -0.31794000f, -0.03489776f, 0.13613556f, 
    -0.58012950f, -0.33699819f, 0.36123973f, 0.45505345f, -0.10840494f, 0.21332337f, 0.92959499f, 0.44539365f, 
    0.44933820f, 0.04685301f, -0.30055299f, -0.33083421f, -0.41326201f, 0.07067075f, 0.31994382f, 0.06854029f, 
    0.36217222f, -0.31288278f, -0.14798111f, 0.10528908f, -0.28121674f, -0.18934789f, 0.00262498f, 0.08033790f, 
    -0.22527419f, 0.14660825f, -0.09550455f, 0.26083174f, 0.10963438f, -0.21316332f, -0.01727656f, 1.12247205f, 
    -1.74811566f, -0.11629402f, 0.03667137f, 0.82144254f, -0.00449506f, -0.28550583f, -0.00922501f, -0.20871462f, 
    0.03014952f, -0.25166115f, -0.24391499f, -0.10461881f, -0.41139838f, 0.45598316f, -0.14701393f, 0.34307075f, 
    -0.13933405f, 0.10577038f, 0.13314876f, -0.13417827f, -0.17455401f, -0.25207883f, -0.16726038f, -0.08445439f, 
    -0.68490618f, 0.47297859f, 0.04343513f, -0.05012242f, 0.44047377f, -0.24169359f, -0.07805672f, 0.18674783f, 
    0.11965220f, -0.10964810f, -0.17470071f, -0.05137173f, 0.05606583f, -0.09216319f, -0.12406779f, 0.43017429f, 
    -0.31536433f, -0.04145002f, -0.30748188f, -0.44730061f, -0.40266019f, 0.38682953f, 0.31668150f, 0.23578736f, 
    -0.05766316f, -0.03981697f, -0.39492303f, 0.16420299f, 0.13146280f, 0.43573439f, -0.39059654f, -0.10574549f, 
    0.29764926f, 0.24358840f, 0.20409790f, -0.02908986f, 0.00365929f, 0.20693471f, -0.15245716f, 0.43735316f, 
    -0.31619814f, 0.17821100f, -0.27223295f, -0.38113979f, -0.32604685f, 0.01931286f, 0.02490070f, -0.08460521f, 
    0.16774885f, 0.14597787f, -0.55924022f, -0.80613905f, -0.62226647f, -0.19242400f, -0.92939711f, 0.27325714f, 
    0.80110085f, -0.18422334f, -0.06986644f, 0.12139000f, -0.04623249f, -0.53242767f, -0.27137107f, -0.49795416f, 
    -0.59033763f, 0.00521732f, -0.02239339f, -0.19002901f, 0.21508981f, -0.02895434f, -0.04588157f, -0.15259127f, 
    -0.17105450f, 0.03260053f, -0.25224781f, -0.17474005f, 0.09900445f, -0.60736525f, -0.84447348f, -0.75390679f, 
    0.03521729f, 0.20230584f, 0.18710639f, -0.08549103f, 0.01463032f, -0.22547254f, -0.13568716f, 0.22871184f, 
    0.07537091f, 0.15583622f, 0.27851668f, 0.35642105f, 0.01976347f, -0.15481447f, 0.10750999f, -0.03281424f, 
    0.50813448f, -0.43871754f, -0.19659054f, -0.44463071f, -0.45436826f, 0.30130261f, 0.15071987f, 0.58749086f, 
    0.60184896f, 0.03047048f, -0.23479125f, -0.31002355f, 0.27460051f, 0.57386565f, 0.02806876f, 0.27388293f, 
    -0.11418860f, -0.28214049f, -0.07485188f, -0.04948232f, -0.06584942f, 0.15927078f, 0.31514746f, -0.05016879f, 
    -0.35741001f, -0.28585094f, -0.25577563f, -0.23031281f, -0.34111378f, 0.02544714f, -0.68919557f, -0.68581516f, 
    -0.22645168f, -0.61827970f, 0.21586227f, 0.11478907f, 0.19272473f, 0.09329570f, -0.43323952f, -0.34627116f, 
    -0.36862785f, -0.02438403f, 0.46762532f, 0.19590098f, -0.07498784f, -0.06269917f, -0.29342201f, -0.50452310f, 
    -0.42112163f, 0.09012565f, -0.34912360f, 0.45272380f, 0.16012421f, 0.14107072f, 0.35333148f, 0.16785184f, 
    -0.72888470f, -0.51735097f, 0.08034617f, 0.47818285f, 0.18258822f, 0.14074610f, -0.39407098f, -0.10328016f, 
    -0.35064998f, 0.20388256f, 0.22376582f, -0.06206584f, -0.06472206f, -0.57962620f, 0.09398083f, 0.38938382f, 
    -0.08184732f, -0.22035575f, 0.16759740f, 0.24962100f, -0.17686562f, 0.30493230f, 0.47989327f, -0.05708727f, 
    0.23658913f, 0.07353793f, 0.46126804f, 0.31769207f, -0.10605823f, 0.19237030f, 0.46856722f, 0.05289060f, 
    0.00822227f, 0.39529002f, 0.24069962f, 0.18503885f, 0.10629760f, -0.39956078f, 0.13681895f, 0.13096763f, 
    0.01408143f, -0.01019434f, -0.05398402f, 0.20679398f, 0.25261030f, 0.10972854f, 0.14675078f, 0.07457871f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.42567754f, -0.15608574f, 0.09174351f, -0.06175773f, 0.05768387f, 0.22818448f, 0.50845212f, 0.20336084f, 
    0.02946106f, 0.32103103f, -0.30274177f, 0.23663881f, 0.05309020f, -0.30576685f, 0.35741058f, -0.20203279f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22896238f, 0.22307681f, 0.18532427f, 0.32093900f, 0.20322408f, -0.15041928f, -0.26624620f, 0.14184585f, 
    -0.00588312f, -0.10860347f, 0.01987480f, -0.02781171f, -0.08658579f, 0.09451164f, 0.08667319f, 0.35135159f, 
    0.16140874f, 0.03114189f, -0.02767244f, -0.10304169f, 0.14908546f, 0.20411013f, 0.27102810f, 0.21171188f, 
    0.27191216f, 0.00132868f, 0.09223311f, 0.06906559f, -0.33366680f, 0.05500491f, 0.02509145f, -0.09589545f, 
    0.20269023f, 0.06227659f, 0.17726560f, 0.19313049f, 0.15975334f, 0.08263572f, -0.05397053f, -0.01334740f, 
    0.11080313f, 0.03493962f, 0.13088760f, 0.17901865f, -0.03593331f, -0.01247721f, -0.06174733f, -0.30645090f, 
    0.77353311f, 0.06198960f, 0.07992447f, 0.38674566f, -0.01146326f, -0.00629091f, 0.12051713f, -0.25868419f, 
    0.24973163f, 0.00471353f, -0.01013700f, 0.09872931f, -0.07280260f, -0.14402275f, 0.31058329f, -0.13416095f, 
    0.02549473f, -0.06755245f, 0.06779891f, 0.03759251f, -0.09753828f, -0.23422372f, 0.01461720f, -0.23232670f, 
    -0.04472568f, -0.01484264f, 0.01322946f, 0.13990721f, 0.02786738f, 0.16560675f, -0.15605286f, -0.21906933f, 
    0.05385695f, -0.04692927f, 0.04422197f, 0.02309769f, 0.01490941f, -0.29935601f, 0.24264619f, -0.11292598f, 
    0.08176421f, -0.15425473f, 0.23747496f, 0.10592224f, 0.08981559f, 0.03408477f, 0.11943005f, 0.20512927f, 
    0.19632095f, 0.22603810f, 0.09912001f, 0.16636249f, 0.14739199f, 0.00253325f, -0.13530728f, -0.11959655f, 
    -0.12327071f, -0.21688990f, -0.00356824f, -0.08221545f, 0.25183240f, -0.08289727f, -0.06442662f, -0.13466519f, 
    0.12997150f, -0.14599492f, -0.22712171f, -0.25949964f, -0.09096381f, -0.05722932f, -0.20127827f, -0.19616543f, 
    -0.42411545f, 0.00683547f, 0.05902154f, 0.17802848f, 0.01046290f, 0.00074852f, 0.07453857f, 0.28569680f, 
    0.08679881f, 0.02541528f, 0.23447417f, 0.14094988f, 0.01198272f, 0.40877110f, 0.02901154f, -0.04506659f, 
    0.02740131f, -0.05050495f, 0.09509982f, 0.07075658f, 0.08410089f, -0.06573228f, -0.11649314f, 0.07128146f, 
    0.14317003f, -0.12667091f, 0.03342710f, 0.07205202f, -0.00839845f, 0.00740435f, -0.09675131f, -0.14471772f, 
    0.24521750f, 0.17369734f, 0.13152988f, 0.30795541f, 0.14947161f, 0.04665914f, -0.06628247f, -0.00886452f, 
    -0.17625344f, -0.02080291f, 0.04783593f, 0.15048651f, 0.18524987f, -0.07517146f, 0.02831749f, 0.13234198f, 
    -0.24447565f, 0.24979812f, -0.02776292f, -0.15025124f, -0.15029226f, 0.06657293f, -0.17755346f, -0.21040200f, 
    -0.30431321f, -0.18289071f, -0.29055920f, -0.26044795f, -0.10691859f, 0.07192142f, -0.20245926f, -0.22355638f, 
    0.10771866f, 0.08732277f, 0.03154752f, 0.30124587f, -0.10217705f, -0.05758252f, -0.21174979f, -0.42175484f, 
    -0.13904399f, 0.27558827f, -0.03223987f, 0.02385786f, 0.10369059f, -0.02874498f, -0.20496462f, -0.07098122f, 
    0.00005546f, -0.04476832f, 0.15054597f, 0.08216313f, 0.22971435f, -0.08269641f, 0.15217240f, 0.19462186f, 
    0.04498108f, 0.11888888f, 0.16218913f, 0.09198330f, -0.05970222f, -0.07271525f, 0.13094851f, 0.06027583f, 
    0.02954057f, 0.18007278f, -0.12994047f, 0.05364989f, 0.02354542f, 0.00431440f, -0.00993644f, 0.05432276f, 
    0.11077546f, 0.09874940f, 0.03345944f, 0.05018547f, 0.34161627f, 0.44188222f, 0.39065883f, 0.09619189f, 
    0.12961768f, -0.00300289f, 0.33798385f, 0.21254687f, 0.06946407f, -0.13037138f, -0.00359887f, -0.10711952f, 
    -0.06912713f, 0.50030375f, 0.11620395f, -0.19824368f, -0.04699780f, -0.00258575f, 0.05601187f, -0.15916605f, 
    0.08186532f, -0.04079296f, -0.02066894f, 0.04635708f, 0.37443382f, -0.12209069f, -0.05466533f, 0.04241647f, 
    0.00418349f, -0.15046415f, 0.10294932f, -0.18096948f, -0.08850333f, -0.03372465f, -0.21632986f, -0.00919922f, 
    -0.00616968f, -0.27040079f, -0.43685451f, 0.10856775f, -0.06408193f, -0.10076358f, 0.13923071f, -0.02756144f, 
    -0.01873892f, 0.00136832f, -0.05133956f, 0.03083400f, 0.15717667f, -0.34485096f, 0.31841519f, -0.35884318f, 
    0.10886292f, 0.06173958f, 0.11090250f, 0.17649573f, 0.05903371f, -0.00441552f, 0.01108768f, 0.11619751f, 
    -0.39199555f, 0.21821918f, 0.23600702f, 0.24531515f, 0.25794280f, 0.03445901f, -0.17567214f, -0.13294598f, 
    -0.19823590f, -0.13476497f, 0.01233261f, -0.12053952f, -0.11344070f, -0.03598102f, 0.28969738f, 0.14060357f, 
    -0.00567696f, 0.00559139f, -0.14007977f, -0.40491489f, -0.13888934f, -0.08953492f, 0.04947733f, -0.06313575f, 
    0.19785056f, 0.07453782f, -0.28146783f, -0.04983926f, 0.12120165f, 0.03273324f, -0.12923737f, 0.13731539f, 
    0.11333720f, 0.03931667f, 0.01457883f, 0.12936491f, -0.16794576f, 0.15300658f, -0.09387708f, -0.08736599f, 
    0.12464923f, -0.07246722f, -0.13712186f, -0.11497340f, 0.10874423f, 0.12269612f, 0.01025721f, 0.12023681f, 
    -0.16562234f, -0.31518176f, 0.12553205f, 0.32992035f, 0.07603330f, 0.05265173f, -0.10617579f, -0.10687771f, 
    0.04524965f, 0.15691288f, 0.10612362f, 0.05631620f, 0.37205458f, -0.06088882f, -0.26800942f, 0.07964499f, 
    0.13723393f, -0.05482598f, 0.01468040f, 0.17531401f, 0.01549592f, -0.10783328f, -0.07819072f, -0.03004999f, 
    -0.02883370f, -0.04689610f, -0.34494984f, -0.12983826f, -0.05891909f, 0.07210126f, 0.01448514f, -0.01770798f, 
    -0.10564815f, -0.09644269f, -0.25849199f, -0.00030356f, -0.11975400f, 0.05196781f, 0.11261880f, 0.25594386f, 
    -0.01130980f, 0.05709824f, -0.01358536f, -0.00397231f, -0.04163015f, -0.07278340f, -0.07914700f, -0.14572482f, 
    -0.07687973f, -0.06539950f, -0.02212638f, 0.03290650f, 0.06118354f, 0.02071528f, 0.05603432f, 0.03371132f, 
    -0.06655680f, 0.02485131f, -0.02823133f, 0.01542860f, 0.04277038f, -0.04810916f, 0.03148637f, 0.00529489f, 
    0.03075998f, -0.07643650f, -0.04114759f, 0.04088332f, -0.07175773f, 0.05494917f, 0.05653634f, 0.05207029f, 
    0.02442767f, -0.04883312f, -0.06614316f, -0.05114238f, -0.04043965f, -0.02616866f, -0.02060087f, -0.06899276f, 
    -0.04979506f, -0.00596319f, -0.04376727f, 0.04406595f, -0.04333624f, 0.00658318f, -0.04935042f, -0.04109130f, 
    0.02827590f, -0.02728935f, 0.03427353f, 0.00645295f, -0.03362069f, -0.07466412f, 0.06020044f, -0.00239274f, 
    -0.04043103f, 0.01637125f, 0.02616508f, -0.05019311f, -0.07855505f, -0.00005310f, 0.01912235f, -0.05454554f, 
    0.06532387f, 0.05957340f, -0.00138703f, 0.00835415f, -0.03908335f, -0.05448518f, -0.06154286f, 0.03541601f, 
    0.01793299f, -0.06667726f, -0.05641227f, -0.02937820f, 0.05974029f, 0.05257812f, -0.02218950f, -0.07312500f, 
    -0.05233606f, -0.06675962f, 0.00243215f, -0.07073226f, -0.05290893f, 0.04806609f, 0.02098533f, -0.02878821f, 
    -0.06678031f, -0.06366907f, -0.03312007f, 0.02637732f, -0.00410994f, -0.06224672f, 0.04871307f, -0.05029495f, 
    -0.04697384f, 0.00821913f, -0.05028145f, -0.06192069f, 0.02981671f, -0.01468126f, -0.01435788f, 0.01350385f, 
    -0.01306250f, 0.01261745f, -0.05963734f, -0.01442921f, -0.00127606f, 0.03204273f, 0.01116476f, -0.04606243f, 
    -0.05470260f, -0.01458793f, -0.06584306f, 0.02793041f, -0.05077853f, -0.05476291f, 0.00483425f, -0.05324827f, 
    0.01014777f, -0.04391388f, -0.05585654f, 0.03181098f, 0.03026706f, -0.00457120f, 0.02512378f, 0.02322092f, 
    0.02254975f, 0.02705449f, -0.01597937f, -0.02275210f, -0.06099138f, -0.06434792f, 0.05214609f, -0.06071677f, 
    0.06003612f, -0.00662728f, -0.06070999f, -0.04820658f, -0.07390010f, -0.07953848f, 0.05593394f, 0.00408576f, 
    0.00493668f, -0.02052572f, 0.06284737f, -0.03117422f, -0.03339580f, 0.05189297f, -0.00624253f, -0.00813135f, 
    0.03664616f, 0.02011382f, -0.03700526f, -0.01538495f, 0.06117100f, -0.06160724f, 0.05622872f, 0.00452867f, 
    0.00516794f, 0.01875424f, -0.07158081f, 0.03496106f, 0.00205127f, -0.01932442f, -0.06418844f, 0.04263138f, 
    0.02076697f, -0.05322648f, 0.02891428f, -0.03759998f, 0.05006982f, 0.05930427f, 0.03479014f, -0.03394888f, 
    -0.02239382f, -0.00289295f, 0.05242264f, -0.06175157f, -0.07515847f, 0.02973781f, -0.03523052f, 0.01164320f, 
    0.03775075f, -0.00797706f, -0.00683304f, -0.04273724f, 0.05536511f, -0.02813078f, -0.00782480f, 0.03925376f, 
    -0.06347092f, -0.00633478f, -0.07269490f, -0.06831106f, 0.06641699f, 0.00050749f, 0.02356826f, -0.01905134f, 
    -0.74893701f, -0.02017633f, 0.41462386f, -0.02442448f, -0.23751865f, 0.01384820f, 0.04723348f, -0.07358541f, 
    0.29552662f, 0.23222445f, -0.03824012f, 0.15585124f, -0.03710951f, 0.18390037f, 0.00588719f, -0.39466670f, 
    0.03180805f, 0.08627674f, 0.16568506f, 0.29280326f, 0.05276001f, -0.19134144f, -0.04508711f, -0.21049084f, 
    -0.20139554f, 0.03101070f, -0.10977616f, -0.11896662f, 0.14635672f, -0.13106339f, -0.04521047f, 0.01704674f, 
    -0.05511438f, 0.03283629f, -0.14735824f, -0.01127543f, -0.39201471f, -0.08608792f, 0.01547764f, 0.03191044f, 
    -0.12499480f, 0.18980004f, -0.18074910f, -0.18552145f, -0.06502719f, -0.23511204f, -0.03383486f, 0.05969203f, 
    -0.84518737f, -0.29768577f, -0.36222959f, 0.30657941f, 0.13210374f, 0.09109179f, 0.18149133f, 0.26270956f, 
    -0.09711280f, 0.11468437f, 0.10635347f, 0.06870289f, 0.03290148f, 0.08000925f, -0.06731216f, 0.06466500f, 
    -0.11105081f, 0.14057139f, 0.17722918f, 0.33039808f, 0.11752980f, 0.27128467f, -0.02085928f, 0.15264949f, 
    0.73083729f, 0.53520483f, 0.02677981f, 0.14109764f, 0.02719071f, -0.13937196f, 0.11544811f, 0.07047697f, 
    0.02286222f, -0.04554571f, 0.03846909f, 0.09921018f, 0.15222205f, 0.12907037f, -0.02751497f, -0.05705810f, 
    0.03021928f, 0.26443177f, -0.02997739f, 0.30986834f, 0.07876245f, -0.01795076f, 0.13306452f, -0.03764660f, 
    -0.22485968f, -0.12297229f, 0.05743215f, -0.03588900f, -0.15319811f, -0.08525220f, 0.15300693f, -0.07746015f, 
    0.08711541f, 0.13082287f, 0.00456124f, 0.22167048f, -0.15302706f, 0.05563122f, 0.04708362f, 0.18995392f, 
    -0.18813497f, 0.02289283f, -0.00484776f, 0.06992193f, 0.15604778f, 0.06422181f, 0.36025822f, 0.18095595f, 
    0.13660309f, 0.08613361f, 0.24918118f, 0.00484909f, -0.20025474f, 0.04413074f, -0.02194019f, -0.06442586f, 
    -0.02038871f, -0.12912875f, -0.11961947f, -0.10796110f, -0.15877880f, -0.02421360f, 0.26172689f, -0.11351474f, 
    0.33359301f, 0.04690351f, 0.06180253f, 0.24668483f, -0.01776602f, -0.10705155f, 0.10619200f, -0.07105623f, 
    0.04584893f, 0.03078365f, -0.19880407f, 0.10523532f, -0.15538406f, -0.14097494f, -0.25476345f, -0.17012256f, 
    -0.10306652f, -0.19256882f, -0.18347074f, -0.11667100f, -0.11056094f, 0.29620954f, 0.28785598f, -0.13189961f, 
    0.03106343f, 0.06812277f, 0.13758549f, 0.01129496f, 0.13855310f, -0.04203291f, -0.00188576f, -0.04655330f, 
    0.05689111f, -0.13373931f, 0.14088267f, -0.19000301f, 0.19119854f, 0.19638564f, 0.18809196f, 0.22722346f, 
    0.20072639f, 0.14533404f, 0.11632735f, 0.02229759f, 0.02416507f, -0.10688733f, -0.01307764f, -0.08312485f, 
    -0.03633990f, -0.06476297f, -0.13787492f, -0.26533243f, -0.02813525f, -0.04425855f, 0.00060129f, 0.03716731f, 
    0.53760427f, 0.01594255f, -0.39786252f, 0.09825167f, -0.11130372f, 0.10645981f, 0.11398625f, -0.14483827f, 
    -0.13685545f, 0.00550655f, 0.10465696f, 0.22683601f, 0.26558900f, 0.16011906f, 0.18179008f, 0.37919199f, 
    -0.01001754f, 0.04646492f, -0.01635586f, -0.12044328f, 0.06117827f, 0.09685264f, -0.16132243f, -0.00998110f, 
    -0.11032832f, -0.13007534f, -0.02464904f, 0.07528146f, -0.12027287f, 0.03592902f, 0.12921625f, -0.11687539f, 
    -0.15837020f, 0.04820717f, -0.14632455f, 0.00497417f, 0.33644083f, 0.24042377f, 0.13254528f, 0.14494729f, 
    0.10846668f, 0.22329284f, 0.15055104f, 0.22296126f, 0.04280636f, -0.00314477f, 0.02894208f, 0.11368758f, 
    0.39074850f, 0.54253703f, 0.21407767f, -0.12747918f, 0.04787096f, 0.01913173f, -0.29555193f, 0.15800031f, 
    0.01810393f, -0.10485650f, 0.06196551f, 0.01362681f, 0.17513472f, 0.12245958f, -0.20488240f, 0.01179547f, 
    -0.04426403f, 0.02602698f, 0.31523046f, -0.14431734f, -0.10571689f, -0.08070946f, 0.15386392f, -0.01103668f, 
    -0.88906562f, -0.32938251f, -0.01336143f, 0.01436886f, -0.22797292f, 0.11026423f, -0.14290950f, -0.14963706f, 
    0.06027462f, -0.05674231f, -0.00080719f, 0.09267938f, -0.02566838f, 0.43784195f, 0.19585918f, 0.27994809f, 
    -0.02913984f, 0.02223076f, -0.00529919f, 0.01055915f, -0.10565286f, 0.02492738f, -0.11807592f, 0.01919672f, 
    0.05383744f, 0.01078087f, 0.21488924f, 0.31672823f, 0.02155116f, 0.01791926f, -0.11285190f, 0.09430205f, 
    -0.07531563f, -0.20669170f, 0.08289517f, -0.00686508f, -0.06359391f, -0.08468863f, 0.10236862f, 0.11052808f, 
    -0.05151566f, -0.10744172f, -0.01691582f, 0.00523436f, -0.08475864f, 0.16746213f, -0.20884790f, 0.07690029f, 
    0.15728842f, 0.16328998f, 0.09141626f, 0.00371777f, 0.22598231f, 0.22603267f, 0.03776867f, -0.12148862f, 
    -0.01676763f, -0.02315212f, -0.03957054f, -0.00911310f, 0.31995508f, -0.30768660f, 0.01560891f, 0.41049755f, 
    0.09967040f, 0.12252236f, 0.10054070f, -0.01684085f, -0.01607608f, 0.05199684f, -0.05741686f, 0.16523066f, 
    -0.37082413f, -0.03299262f, 0.09533921f, -0.20276596f, 0.04549756f, -0.06632696f, -0.10935119f, 0.03882570f, 
    -0.08112209f, -0.09142017f, 0.10396589f, -0.18085633f, 0.11152697f, 0.12452802f, -0.14063033f, 0.24483483f, 
    0.16797079f, 0.19648582f, 0.09005743f, 0.24185571f, 0.06767515f, 0.12994547f, -0.00211384f, -0.10737698f, 
    0.00068747f, -0.24282223f, -0.14101267f, 0.02878824f, 0.14146969f, 0.11667215f, 0.05277299f, -0.04971860f, 
    0.01911806f, -0.04510227f, 0.29582927f, 0.13431369f, -0.15363637f, -0.22505084f, -0.17457211f, 0.07476184f, 
    -0.12151998f, -0.07824775f, -0.28601453f, -0.08674103f, -0.03308878f, -0.05591462f, 0.04567180f, 0.09642006f, 
    0.34090731f, -0.08698128f, -0.21193381f, 0.13331002f, -0.06292915f, 0.11548287f, 0.12269066f, -0.05560436f, 
    0.17161988f, 0.07821342f, 0.11817298f, 0.09967710f, -0.11893621f, 0.04591172f, -0.08448989f, -0.02798129f, 
    0.01914516f, -0.06659788f, 0.02282657f, 0.04156021f, 0.08217017f, 0.11687480f, -0.11924288f, -0.11614689f, 
    -0.03338498f, -0.24156727f, 0.04038851f, 0.02021994f, -0.01374970f, 0.09210046f, -0.00059044f, 0.00012470f, 
    -0.01185996f, -0.02286852f, -0.05483437f, -0.08929265f, -0.22455598f, -0.43527865f, -0.26218593f, 0.08333902f, 
    0.14978662f, 0.10493947f, -0.15187176f, -0.06572530f, -0.03160421f, 0.20036310f, -0.02840369f, 0.11963878f, 
    0.51047111f, -0.21529658f, -0.12265354f, 0.12592849f, 0.13529016f, -0.04487982f, -0.20704630f, 0.27609938f, 
    0.10558000f, 0.06302668f, 0.05187353f, -0.05759541f, -0.13228652f, 0.12249056f, 0.21307160f, -0.07995116f, 
    0.04719231f, -0.05213742f, 0.13344084f, 0.05484462f, -0.03436883f, 0.06028562f, 0.15642397f, 0.05188860f, 
    -0.32505286f, 0.10069259f, 0.16977511f, -0.13037202f, -0.03281946f, -0.01417578f, -0.19883065f, -0.18108343f, 
    0.02765473f, 0.09605121f, 0.09248086f, 0.05602025f, 0.14516713f, 0.34344238f, -0.22972123f, 0.33692098f, 
    0.00324851f, -0.04153502f, -0.08936290f, -0.18544494f, 0.24208832f, -0.00400460f, -0.03347073f, -0.02436775f, 
    0.52503228f, 0.07550147f, -0.21469080f, -0.23482363f, -0.07103305f, -0.13325328f, -0.00643032f, 0.06597380f, 
    0.12310307f, 0.19566150f, 0.11448583f, 0.37392870f, 0.09288950f, -0.06204991f, -0.13591114f, -0.07684970f, 
    0.00725867f, 0.00433187f, 0.02262373f, 0.20865345f, 0.03632010f, 0.15349913f, -0.03717257f, 0.13176762f, 
    -0.16260609f, -0.02633068f, 0.25345325f, -0.07656729f, -0.07833773f, -0.01278975f, 0.00556426f, -0.24682936f, 
    -0.01171001f, 0.09744542f, -0.02217238f, -0.02465767f, 0.04015216f, -0.06495304f, -0.07038783f, 0.26891345f, 
    0.09306962f, 0.11636432f, 0.07823715f, 0.19582224f, -0.02399809f, -0.14933428f, -0.06581226f, 0.06392063f, 
    0.22667383f, 0.15521155f, -0.19477734f, -0.31422490f, -0.12658334f, -0.08323954f, 0.05855999f, -0.03680696f, 
    0.02917197f, 0.07718471f, -0.06461933f, -0.00660127f, -0.23349145f, 0.08977305f, 0.16937451f, -0.04876636f, 
    0.05028608f, 0.20276365f, -0.06742857f, -0.01070766f, 0.05864211f, -0.04102770f, 0.03276069f, 0.02405826f, 
    -0.22147594f, 0.13363147f, 0.18767229f, 0.06313693f, 0.10459677f, 0.01869706f, 0.08300675f, -0.11204208f, 
    0.22096509f, 0.07799645f, -0.01282942f, 0.19930576f, -0.19527304f, -0.20876518f, -0.29298893f, -0.23390150f, 
    -0.16178504f, -0.11310039f, -0.06499618f, -0.16392137f, 0.01667953f, 0.05352736f, -0.00472171f, -0.04743163f, 
    -0.47484323f, 0.15010770f, -0.04880522f, -0.00217655f, 0.13645872f, -0.12956303f, 0.04764330f, -0.14177722f, 
    0.06209782f, 0.08174709f, -0.03610062f, 0.06362616f, -0.15891749f, -0.03329452f, 0.14519741f, 0.13214213f, 
    -0.06152502f, -0.04101151f, -0.04699770f, 0.01696989f, 0.13740586f, -0.02371610f, -0.17074768f, 0.00146494f, 
    -0.29313681f, -0.27686328f, -0.04612548f, 0.02103807f, 0.11569629f, 0.09920558f, 0.02870451f, 0.00611238f, 
    0.02085190f, 0.01844127f, -0.02651537f, -0.13918333f, 0.12192968f, 0.29843277f, -0.03870324f, 0.10196283f, 
    0.15774661f, -0.01363159f, -0.06390949f, 0.04302054f, 0.03836027f, 0.00618341f, -0.00276684f, -0.02579801f, 
    -0.28142938f, -0.29132736f, 0.25926459f, 0.34869578f, 0.07537028f, -0.10441298f, 0.03671599f, 0.00961758f, 
    0.26570156f, -0.00876056f, 0.14667061f, -0.12588000f, 0.09244642f, -0.17289090f, 0.23600285f, -0.26849464f, 
    -0.07277709f, -0.03964494f, 0.15628721f, 0.01348393f, 0.15290424f, 0.15388966f, 0.01450718f, -0.11819104f, 
    0.33246094f, -0.05023552f, 0.17627558f, -0.09709857f, -0.02072355f, -0.03648243f, 0.03695043f, -0.00473702f, 
    0.06905321f, 0.00337519f, -0.03815989f, 0.10605696f, 0.47119662f, -0.53606647f, 0.15096773f, -0.33661902f, 
    0.00599884f, -0.17253867f, 0.03634657f, -0.19300303f, -0.03185618f, -0.08353484f, -0.04374639f, -0.01156282f, 
    -0.51221597f, 0.06680445f, 0.11592735f, 0.24060152f, 0.08867480f, 0.02311991f, 0.02454634f, -0.08520800f, 
    -0.00654657f, 0.08062362f, -0.11020795f, -0.03516142f, -0.05468591f, -0.11223161f, 0.05883432f, 0.25619867f, 
    -0.08957046f, 0.02240692f, 0.04095496f, -0.02122220f, 0.02214723f, -0.13590573f, 0.05672942f, -0.13592377f, 
    0.37580234f, 0.28082210f, -0.08990767f, -0.25355217f, 0.01189833f, -0.14131157f, 0.09187090f, 0.37036562f, 
    0.02147863f, -0.17603606f, -0.00345156f, 0.11378995f, -0.26538438f, 0.32963812f, 0.21257983f, -0.07272241f, 
    0.05715632f, 0.00888612f, -0.19182999f, -0.19492392f, -0.04636876f, -0.07506186f, -0.06393952f, -0.11842713f, 
    0.17363052f, -0.15646598f, 0.29720792f, 0.15126312f, 0.04899983f, -0.04392623f, -0.14651814f, -0.04710623f, 
    0.00249978f, -0.03420385f, 0.13882798f, 0.02076425f, 0.20457441f, 0.07434180f, 0.26139918f, -0.23374665f, 
    0.24575008f, -0.06337925f, 0.05679908f, -0.05475232f, 0.08072593f, 0.01858792f, 0.11814481f, -0.13772176f, 
    0.28483081f, 0.00234067f, 0.14702283f, -0.16067997f, -0.03489506f, 0.13587202f, -0.03026019f, 0.11268465f, 
    -0.03749402f, 0.02444488f, -0.00789293f, -0.01644590f, -0.04269060f, 0.06290276f, 0.06987998f, 0.09856184f, 
    0.00022257f, 0.17642310f, 0.07597793f, -0.08434214f, -0.03862073f, 0.00647561f, 0.02285921f, 0.08789104f, 
    -0.05021796f, -0.03463859f, 0.00072579f, 0.03128337f, -0.04286917f, -0.07930746f, 0.03022740f, -0.07303824f, 
    0.00955994f, -0.03371539f, -0.07642356f, -0.02111184f, 0.00273947f, -0.05001938f, 0.02462214f, -0.00563542f, 
    -0.02163044f, -0.01751841f, -0.06662023f, 0.00616710f, -0.02236740f, -0.04398714f, -0.00691871f, -0.07589063f, 
    -0.06903866f, -0.06813147f, 0.02591239f, 0.02318156f, 0.00951249f, -0.07976384f, 0.00203288f, 0.01830097f, 
    -0.02375816f, 0.01303011f, 0.04389615f, -0.04847406f, 0.05175010f, -0.05574818f, 0.04987475f, 0.00225476f, 
    -0.05916306f, 0.03838311f, 0.02834803f, 0.00159461f, 0.04507552f, 0.02032834f, -0.00365821f, 0.02295535f, 
    -0.01710515f, -0.00164749f, 0.03453788f, 0.00773049f, 0.04014231f, -0.02887484f, -0.02256008f, -0.05408800f, 
    -0.02139284f, 0.05876569f, -0.00007020f, 0.01880725f, -0.01877175f, 0.02417999f, 0.01200645f, -0.04038858f, 
    -0.00389536f, -0.02173214f, -0.01769210f, 0.03448138f, 0.01531316f, 0.01199901f, 0.04901903f, -0.02351986f, 
    -0.04997871f, -0.05147184f, -0.04577285f, 0.03002186f, -0.05356140f, -0.04589900f, -0.01886645f, 0.00305012f, 
    -0.06312098f, -0.04849754f, -0.02565658f, -0.06205022f, 0.01732768f, -0.02317459f, 0.03398424f, 0.01533477f, 
    0.00902932f, 0.05818384f, 0.02452515f, -0.02490259f, -0.01607698f, -0.03130990f, 0.00911560f, 0.04229644f, 
    -0.08064595f, 0.02717290f, 0.02659365f, 0.03389345f, -0.07966064f, -0.05046170f, -0.02156841f, -0.07252206f, 
    -0.06064402f, 0.02344594f, -0.06977192f, -0.06254139f, 0.03420101f, 0.01318982f, -0.01672278f, -0.03208707f, 
    -0.04212682f, 0.02423666f, -0.06564786f, 0.04606612f, -0.05980935f, 0.00611122f, -0.00028877f, -0.08083294f, 
    -0.03444573f, -0.03630587f, 0.03583274f, 0.01318398f, 0.03462760f, -0.05201621f, 0.05295880f, -0.07221980f, 
    -0.00345157f, -0.04829808f, -0.07291961f, 0.02386915f, 0.05573749f, -0.01892417f, -0.05399150f, 0.00917093f, 
    -0.00762781f, -0.05088881f, 0.00393604f, 0.00890413f, -0.02023425f, 0.00076692f, -0.06921228f, -0.00561071f, 
    -0.01035461f, -0.03422771f, -0.00392814f, -0.07031006f, 0.03805521f, -0.06009814f, -0.03459213f, -0.00078549f, 
    0.02394429f, 0.03264518f, -0.00475994f, -0.02085428f, 0.04811529f, 0.01568146f, 0.00226691f, -0.04335830f, 
    0.02368560f, -0.03792325f, 0.05870465f, 0.03376156f, -0.04398494f, -0.04570519f, -0.01916715f, -0.02031641f, 
    0.00480453f, -0.05581576f, -0.03755173f, -0.06689658f, -0.05635226f, 0.01322782f, 0.02870351f, -0.00903333f, 
    0.02811586f, -0.04574328f, -0.06965911f, 0.02063940f, -0.02753349f, -0.08006474f, -0.04834601f, 0.02630547f, 
    -0.02913178f, -0.05448626f, -0.00565275f, -0.01718427f, 0.03892520f, -0.07861482f, -0.01669753f, -0.05540263f, 
    -0.17872447f, -0.02164392f, 0.39836508f, 0.30563292f, 0.22512220f, 0.08165688f, -0.14493336f, 0.04323915f, 
    0.09424304f, 0.12168742f, 0.03988804f, 0.11540952f, -0.16945779f, -0.03112436f, 0.15974689f, -0.05564312f, 
    0.09308501f, 0.08197951f, -0.17493743f, 0.07269265f, 0.12741432f, 0.29013363f, -0.15758619f, 0.14193422f, 
    -0.25139245f, -0.33386517f, -0.04858923f, -0.01944807f, 0.01269317f, 0.09971756f, -0.06482276f, -0.04002945f, 
    0.03140515f, 0.03361746f, 0.16733561f, 0.20129614f, -0.16652450f, -0.08480892f, -0.10472061f, -0.08280179f, 
    0.08598712f, 0.02266351f, -0.31819856f, -0.08119097f, -0.07330970f, -0.09550568f, -0.12840061f, -0.06149950f, 
    -0.18004358f, -0.28755286f, -0.06819608f, 0.34074885f, 0.19438232f, -0.15691763f, -0.09950691f, 0.05009426f, 
    0.10663230f, 0.04377441f, 0.14029895f, 0.10394502f, -0.07651825f, -0.03491914f, 0.03805343f, 0.10365658f, 
    -0.14370392f, 0.08499483f, 0.04464747f, 0.33372432f, 0.01315775f, 0.19773984f, 0.20984995f, -0.11758581f, 
    0.42572382f, 0.40442339f, 0.48271734f, 0.18038233f, -0.12961504f, 0.01303949f, -0.13378738f, -0.03567817f, 
    0.02836664f, 0.00438539f, 0.00640492f, 0.13761494f, -0.19430099f, 0.41556904f, -0.17811786f, 0.45921591f, 
    -0.07677286f, 0.15309274f, -0.14089443f, 0.08978151f, 0.15976301f, 0.16779019f, -0.06883371f, 0.27845395f, 
    0.13899165f, -0.07549196f, 0.13970995f, 0.04716333f, 0.02304712f, -0.12285273f, -0.10291140f, 0.03620683f, 
    -0.14216876f, 0.11391571f, 0.13134889f, 0.06406052f, 0.21121088f, 0.27229679f, 0.06547439f, 0.02821013f, 
    0.01551643f, -0.08102253f, 0.01349266f, 0.03489668f, 0.11064848f, 0.10796777f, -0.04118942f, 0.07488795f, 
    0.09591322f, 0.26392800f, 0.40165669f, 0.40662029f, 0.07292844f, -0.00894480f, -0.08810531f, -0.23521760f, 
    -0.00663218f, 0.11721572f, 0.11742145f, 0.21728443f, 0.14705293f, -0.02552243f, 0.24047495f, 0.23749602f, 
    -0.08720531f, 0.05293589f, -0.07198642f, 0.10424996f, -0.03777791f, -0.03243995f, -0.01431991f, -0.13957861f, 
    -0.14220086f, -0.04102360f, -0.18260822f, 0.09334063f, -0.11526223f, -0.07438229f, -0.20022994f, -0.06855489f, 
    0.17971253f, 0.13720644f, 0.06696475f, 0.17601901f, -0.05997162f, -0.04837214f, 0.53924698f, 0.14090829f, 
    -0.17664257f, 0.16478482f, 0.36801544f, -0.02597271f, -0.02809099f, -0.08303240f, 0.01942023f, -0.17492546f, 
    0.05477950f, -0.05395720f, 0.16545473f, 0.07379421f, 0.01499488f, 0.01014816f, 0.01211251f, -0.07225029f, 
    -0.23184611f, 0.00122446f, 0.03159310f, -0.20548970f, -0.00665387f, -0.02729132f, 0.08590594f, -0.01968084f, 
    0.00383629f, -0.00356801f, -0.03723470f, 0.07656100f, -0.04889098f, 0.06217416f, -0.01274868f, -0.22086979f, 
    -0.14440565f, -0.16280836f, 0.44441390f, -0.12101958f, 0.11857817f, 0.12807930f, -0.22148199f, 0.44220820f, 
    0.00387739f, 0.08379035f, 0.11377802f, 0.05024170f, -0.13266711f, -0.09128451f, -0.22122063f, -0.30676270f, 
    0.13480511f, 0.02874480f, -0.20626532f, -0.02858021f, 0.16519000f, 0.10263982f, 0.30241618f, 0.09644753f, 
    0.26225743f, -0.00936791f, 0.36248234f, -0.08965892f, -0.11589237f, 0.03504967f, -0.00820538f, 0.14699373f, 
    0.15146534f, -0.01747891f, 0.30858228f, 0.33712414f, 0.08626927f, -0.23260058f, 0.29291394f, -0.06379711f, 
    -0.10067180f, -0.09334241f, -0.13869269f, -0.16150665f, 0.01161128f, -0.02401675f, -0.11348006f, -0.11139587f, 
    -0.10051200f, -0.74517220f, 0.09601690f, 0.53933275f, 0.28762507f, 0.03706947f, 0.21610567f, -0.15619649f, 
    0.07010061f, 0.14194691f, 0.04745455f, 0.05960905f, -0.29039076f, 0.23357825f, 0.31783834f, 0.33518767f, 
    -0.02774118f, 0.00777018f, -0.40780491f, 0.48682028f, 0.02129427f, -0.22141817f, 0.09680244f, -0.02120113f, 
    0.40738359f, -0.17695741f, 0.02148716f, 0.06162969f, -0.05152115f, 0.09246634f, 0.02104610f, -0.12991925f, 
    0.03086686f, -0.06255236f, 0.12136823f, -0.06831077f, -0.31864128f, 0.06250611f, 0.14612909f, 0.38822255f, 
    -0.03226724f, 0.04613138f, 0.11516354f, 0.49042740f, 0.07116589f, 0.09460157f, 0.21893209f, 0.28764105f, 
    0.28980944f, -0.19234346f, -0.06160293f, -0.46681580f, -0.02988278f, 0.16732334f, -0.17917365f, 0.19390054f, 
    -0.00501302f, -0.02319764f, 0.10431426f, 0.00429147f, 0.04185297f, 0.01068312f, -0.15454677f, -0.32661423f, 
    0.08694039f, 0.00224902f, 0.00712944f, 0.28688690f, -0.00701638f, -0.00139138f, 0.12325510f, 0.07476786f, 
    -0.59502298f, -0.23574954f, 0.06093668f, 0.45654917f, -0.02971024f, 0.11661989f, -0.07430033f, -0.23040293f, 
    -0.13089530f, 0.16479272f, 0.16755025f, 0.13249610f, 0.14023660f, 0.33483914f, 0.06895825f, -0.05131262f, 
    -0.17814736f, 0.16297792f, 0.20007910f, 0.17664926f, 0.09564912f, -0.11658619f, -0.05752589f, -0.14215888f, 
    -0.16744049f, -0.28702256f, -0.47618482f, -0.06362295f, 0.01998825f, -0.08687493f, 0.13441181f, 0.01457140f, 
    0.09114864f, 0.34722242f, 0.06464956f, 0.13825084f, -0.10566515f, -0.04447528f, 0.02037027f, 0.08199127f, 
    -0.14966023f, -0.09721743f, -0.12430609f, -0.05823316f, 0.02970323f, 0.01309384f, -0.03186653f, 0.23244998f, 
    -0.37456334f, 0.21042377f, 0.04403516f, 0.07097898f, -0.04031749f, -0.05422605f, -0.18192102f, 0.01652237f, 
    -0.21146938f, 0.02101345f, -0.23637007f, -0.33369705f, -0.04968416f, -0.10912973f, -0.14645709f, -0.14044710f, 
    0.08138224f, -0.07916950f, -0.02405296f, 0.26413435f, 0.17376743f, 0.00520153f, -0.05638003f, -0.27644101f, 
    0.02180349f, 0.02223432f, -0.03808014f, -0.00698399f, -0.03613783f, -0.04806593f, -0.03800190f, -0.04525088f, 
    -0.09203677f, -0.07038116f, -0.06610698f, 0.03202476f, -0.06728826f, 0.01588145f, 0.03411634f, -0.05592067f, 
    0.04824725f, -0.05222829f, -0.09492243f, -0.06952191f, 0.04175821f, 0.02259104f, 0.03186189f, -0.02284421f, 
    -0.04862344f, -0.06592683f, 0.01807210f, 0.03024192f, 0.00840673f, -0.05838063f, -0.01151554f, -0.07110871f, 
    -0.02509185f, -0.02211266f, -0.05201605f, -0.07945462f, 0.04182383f, 0.03116064f, -0.09541159f, -0.08930562f, 
    -0.08528042f, 0.01116605f, -0.02992678f, -0.07655676f, 0.03588082f, -0.01924338f, -0.04829640f, -0.03646507f, 
    -0.04967267f, -0.03159085f, -0.06101939f, 0.01383566f, -0.04113288f, -0.02114060f, 0.00531020f, -0.01891320f, 
    0.04126900f, -0.02568033f, -0.03474583f, 0.03180042f, -0.03852617f, -0.01867800f, -0.08675423f, -0.01861659f, 
    -0.01796885f, 0.02882455f, -0.06409244f, 0.02050769f, -0.02653050f, 0.02566523f, 0.04756608f, -0.04896285f, 
    0.01241493f, -0.07816423f, -0.06010868f, -0.00852724f, 0.03826607f, -0.03125584f, -0.06514624f, -0.02704184f, 
    -0.03606877f, -0.00016401f, 0.01605041f, -0.04999828f, -0.04295962f, -0.03351524f, -0.07334150f, -0.01113299f, 
    0.01513260f, -0.08584412f, -0.04206646f, -0.04037746f, -0.04058851f, 0.01830863f, 0.03618623f, -0.00586557f, 
    -0.03590518f, -0.08983704f, -0.05636021f, -0.02589952f, 0.01157094f, 0.04232414f, -0.06430314f, -0.03587913f, 
    0.02337643f, -0.05101880f, -0.08716164f, -0.07794385f, -0.06808967f, -0.06477199f, -0.08713418f, -0.06632592f, 
    0.02116079f, 0.03809282f, -0.09322876f, 0.00127551f, -0.06396189f, 0.02091208f, -0.00836742f, -0.01097121f, 
    0.02231474f, -0.05295143f, -0.03913296f, 0.02624824f, -0.06935618f, -0.02290769f, 0.02452437f, -0.02237247f, 
    -0.03827972f, -0.02840922f, 0.00996470f, 0.02848157f, -0.00768763f, 0.02722089f, -0.06271598f, -0.03413166f, 
    -0.07663149f, 0.02933859f, -0.07408471f, -0.09074783f, -0.07167949f, 0.02630198f, -0.09035088f, -0.08799880f, 
    -0.02297871f, 0.00613227f, -0.04660551f, -0.04891722f, -0.09342538f, 0.02294759f, -0.08161924f, -0.04420313f, 
    -0.05167472f, -0.03381096f, -0.04354670f, -0.04043798f, -0.05916591f, 0.03259660f, -0.08033761f, -0.06449362f, 
    -0.05509966f, -0.08861225f, -0.02873853f, -0.00282730f, -0.04194602f, -0.03760853f, -0.08583925f, -0.00573466f, 
    -0.09059887f, 0.00295970f, -0.05713037f, 0.04651983f, 0.02760394f, -0.00835425f, -0.02895510f, 0.01324507f, 
    -0.00770416f, -0.09402025f, -0.00494956f, -0.05634239f, -0.01531714f, -0.07485404f, -0.05188556f, -0.09537222f, 
    -0.06999278f, -0.05732048f, 0.04599148f, 0.03526623f, -0.06334947f, 0.02879362f, -0.06283332f, 0.03075049f, 
    0.43509704f, 0.11321978f, 0.22242218f, 0.01679668f, 0.06103786f, -0.04150187f, 0.00450582f, 0.00400418f, 
    -0.15186544f, 0.04340834f, 0.14068222f, 0.01144375f, -0.11927588f, -0.02735776f, -0.12903619f, -0.13640547f, 
    0.02974767f, -0.15558977f, 0.02010432f, 0.14556763f, -0.04828668f, 0.28210184f, 0.01520571f, -0.03693275f, 
    0.07958261f, 0.09384636f, -0.03286473f, -0.13073577f, -0.05873709f, -0.03109420f, 0.02061983f, 0.13745417f, 
    0.03874997f, 0.05280619f, 0.12687355f, 0.04982447f, -0.39944810f, -0.33312353f, -0.24985716f, -0.06952357f, 
    -0.06475668f, -0.22658306f, -0.21688762f, -0.12831552f, -0.18800354f, -0.00605770f, -0.03415756f, 0.04254759f, 
    0.06368034f, 0.17870772f, -0.34381306f, -0.27933323f, 0.00538473f, 0.07942789f, 0.02149737f, 0.14485210f, 
    0.08484821f, 0.08489126f, 0.10681984f, 0.11260220f, -0.04449907f, 0.17321825f, 0.11133736f, 0.12516874f, 
    -0.07735147f, -0.10587581f, 0.12729201f, 0.27680534f, -0.01630685f, 0.16086115f, 0.07974895f, 0.09725534f, 
    0.08255842f, 0.13628797f, 0.03129089f, -0.12117211f, -0.12030491f, -0.08277338f, -0.02264387f, -0.06291354f, 
    -0.08203091f, 0.16225122f, 0.05754155f, 0.00027443f, -0.27153713f, 0.42297894f, -0.39851454f, 0.46327412f, 
    0.11521517f, 0.02346179f, 0.19689767f, -0.04652558f, 0.20621169f, 0.01915837f, 0.18929482f, -0.08602121f, 
    0.33826730f, 0.04683894f, -0.11437534f, -0.23551486f, -0.11896471f, -0.02752733f, -0.09014071f, 0.11352956f, 
    -0.13376093f, 0.25327572f, -0.12793203f, 0.02505405f, 0.06635994f, 0.15810724f, -0.13218528f, -0.23045105f, 
    -0.00622875f, -0.00962459f, 0.02800685f, 0.00235230f, 0.01283538f, 0.21450408f, 0.06693740f, 0.06553495f, 
    0.02458302f, -0.18400355f, 0.10474725f, -0.01912930f, 0.07717158f, 0.15222119f, 0.04224456f, -0.00746847f, 
    -0.09141644f, 0.12263028f, 0.14504051f, -0.03051152f, 0.04684042f, -0.10824356f, -0.11299511f, 0.03008642f, 
    -0.07734159f, 0.19592291f, 0.19456992f, 0.03634203f, -0.05069323f, -0.03212012f, -0.01703034f, -0.11224712f, 
    0.15320605f, 0.14801319f, -0.12478803f, -0.29392189f, -0.03378141f, 0.02840391f, 0.02591656f, -0.05656850f, 
    0.20270938f, 0.09717453f, -0.05168013f, -0.20850112f, -0.30450067f, 0.03548532f, 0.07499455f, 0.00613733f, 
    0.03317085f, 0.11764505f, 0.10644917f, 0.09122863f, 0.04170043f, 0.15004829f, 0.07343144f, 0.09845237f, 
    -0.03315330f, 0.18073407f, 0.13192557f, 0.11526430f, 0.01896838f, -0.17270084f, 0.36971959f, -0.05109360f, 
    0.01403258f, 0.17428431f, -0.02539067f, 0.12974083f, -0.12389469f, -0.12720427f, -0.08393560f, -0.12546276f, 
    -0.01692309f, 0.02097583f, 0.05348792f, -0.10858692f, 0.01731415f, 0.09659364f, -0.07801438f, 0.11364637f, 
    -0.36855713f, 0.42461345f, 0.19409357f, 0.25830984f, -0.00532368f, -0.05378181f, -0.04350412f, 0.07269493f, 
    0.12041210f, 0.18453260f, 0.13869485f, 0.11394358f, 0.20026165f, 0.09395716f, 0.00228428f, 0.01681622f, 
    0.02824930f, 0.12621462f, 0.16924378f, 0.01541935f, 0.18546332f, -0.07552649f, 0.27062219f, -0.01712931f, 
    0.14816649f, 0.30339304f, -0.06801611f, 0.06369386f, -0.09242011f, -0.03267450f, -0.04484813f, 0.01660842f, 
    0.12483676f, 0.15889093f, 0.05585403f, -0.01233685f, 0.12312996f, 0.25116056f, 0.37078437f, 0.09766165f, 
    0.04274985f, 0.09746986f, 0.22582404f, -0.03141189f, 0.04470401f, -0.14899793f, -0.00127085f, -0.03072600f, 
    -0.34104401f, 0.03210451f, 0.01891237f, 0.04857545f, -0.06130138f, 0.24249421f, 0.00447174f, 0.06326573f, 
    0.10439412f, 0.07086187f, -0.01949764f, -0.08680337f, 0.26709819f, 0.21931902f, 0.03246205f, -0.06268526f, 
    0.13334668f, -0.03963643f, 0.11479539f, -0.00645417f, 0.18771774f, -0.08151852f, 0.00412625f, -0.02892682f, 
    0.23867741f, -0.22313827f, -0.79193789f, -0.01929896f, 0.04017981f, 0.07936398f, 0.04174451f, 0.08837456f, 
    -0.00435990f, -0.08156757f, -0.10994770f, -0.06655638f, -0.02586582f, -0.24764036f, 0.46721643f, -0.26938498f, 
    -0.01230844f, 0.03680728f, 0.20368625f, 0.17254220f, 0.05409966f, -0.02575547f, 0.14780572f, 0.02671421f, 
    -0.27456036f, -0.09913276f, 0.14380841f, 0.08340957f, 0.04120101f, 0.11195219f, -0.04311041f, -0.01435139f, 
    0.01953684f, -0.07544368f, -0.05302573f, -0.04563557f, 0.09033875f, -0.09615944f, 0.30052167f, 0.25069728f, 
    -0.02997208f, -0.06039847f, -0.08598471f, 0.08083594f, -0.11470813f, -0.04246294f, 0.01696134f, -0.06301057f, 
    -0.07611008f, -0.08185238f, -0.17775513f, -0.19121571f, -0.03325661f, 0.06486140f, 0.06193652f, 0.05047582f, 
    -0.07015614f, -0.10627329f, -0.06861338f, -0.04666859f, -0.03319163f, 0.16636193f, -0.04003436f, -0.15190861f, 
    0.21336998f, 0.08686571f, 0.00890913f, 0.02835768f, 0.03389235f, -0.08573525f, 0.01559229f, 0.12677906f, 
    -0.20644221f, -0.52150452f, 0.13983671f, 0.13847700f, 0.15908173f, -0.02694615f, 0.01401429f, 0.04515525f, 
    0.14666502f, -0.00161156f, 0.10237083f, 0.00212895f, 0.24242054f, 0.20344076f, -0.24099676f, -0.11443427f, 
    0.18928754f, 0.04388647f, -0.11185679f, 0.14904521f, 0.18355693f, 0.10917275f, -0.09508488f, 0.02093678f, 
    0.01926978f, 0.02427868f, -0.23566750f, -0.27644038f, 0.08218746f, -0.05428350f, -0.02157205f, -0.08276261f, 
    0.09004528f, -0.01647449f, -0.03528372f, 0.03997397f, 0.00819420f, -0.17606169f, 0.02220639f, 0.02432427f, 
    0.05607955f, -0.16894791f, -0.09376586f, -0.06346512f, -0.03630883f, -0.07990649f, -0.11766359f, 0.08995204f, 
    0.67309296f, 0.03581754f, -0.00797434f, -0.00164376f, -0.17786740f, -0.03823793f, 0.11666051f, 0.00656045f, 
    0.07825568f, -0.18658343f, 0.01060591f, 0.02900554f, 0.04977144f, 0.17908390f, -0.02432655f, 0.21881235f, 
    0.05681575f, -0.06866768f, 0.29624656f, 0.04638627f, 0.00778502f, -0.14353165f, -0.07180969f, -0.28244060f, 
    0.10169431f, 0.04764515f, -0.06590545f, -0.02387078f, -0.05717167f, -0.10052728f, 0.04126373f, -0.05681686f, 
    -0.17392789f, 0.03265359f, -0.18071385f, -0.27953297f, -0.26144487f, -0.36906049f, -0.00910591f, 0.29714838f, 
    0.06678508f, 0.28190184f, 0.04735656f, 0.04005243f, -0.01935496f, 0.00408459f, 0.07507668f, 0.09648535f, 
    0.33923456f, -0.00099929f, -0.38862053f, 0.20960778f, -0.08804142f, 0.12259398f, -0.02812124f, 0.20369518f, 
    -0.16645193f, 0.10884991f, 0.11086851f, 0.00699730f, -0.08284752f, 0.15329300f, 0.12791583f, -0.07565955f, 
    -0.05928349f, -0.08045837f, 0.22734031f, -0.05965598f, 0.03684204f, 0.04293177f, 0.05518686f, 0.20656906f, 
    -0.22075872f, 0.15677723f, -0.23719858f, -0.01573153f, 0.07725896f, 0.02357352f, -0.03364960f, -0.08603299f, 
    0.08029412f, 0.03722939f, 0.10968105f, 0.03785559f, -0.15643103f, 0.50203168f, 0.24629182f, 0.08182176f, 
    -0.02033665f, -0.00246260f, 0.02441456f, 0.06846616f, 0.08905719f, -0.09838231f, 0.03057064f, -0.04652512f, 
    0.42608914f, 0.04778009f, -0.09171385f, 0.03429487f, -0.06265168f, 0.07517146f, 0.04362406f, -0.02556356f, 
    0.02754991f, -0.00161786f, -0.05244146f, 0.15598257f, 0.07065876f, -0.09662247f, 0.11567549f, 0.02036756f, 
    0.10383230f, -0.05754250f, -0.05848091f, 0.03651205f, -0.04220105f, -0.01774187f, 0.00901519f, 0.25247699f, 
    -0.43885651f, -0.19784528f, 0.27784866f, 0.02929053f, -0.00086597f, -0.04796191f, 0.10002785f, -0.07053985f, 
    -0.04537826f, -0.21047217f, 0.01940227f, -0.13118723f, -0.18781090f, -0.31880724f, -0.23027988f, -0.09116201f, 
    0.29111055f, -0.01307020f, 0.18859479f, 0.15923506f, -0.10694640f, -0.00870475f, -0.04574132f, 0.03085705f, 
    0.17116469f, 0.00962233f, 0.03725910f, -0.16106662f, -0.00332874f, -0.06062294f, -0.03735751f, -0.09179067f, 
    0.04523940f, 0.10660448f, 0.05021418f, -0.00914725f, -0.28995705f, 0.14774995f, -0.02964406f, 0.23247841f, 
    0.02923555f, 0.19490063f, -0.02688632f, 0.17279078f, 0.15963638f, 0.17558315f, -0.04950731f, 0.10384633f, 
    0.05344283f, 0.14247918f, -0.10128132f, 0.04110678f, -0.01945853f, 0.16809672f, 0.15407416f, -0.10938006f, 
    0.22288823f, 0.07053200f, 0.12836489f, 0.29635632f, 0.07679292f, 0.06431896f, -0.06783370f, -0.00198935f, 
    0.02188547f, -0.01740991f, -0.03099931f, -0.15028761f, 0.02823770f, 0.04774059f, 0.00264588f, 0.04613442f, 
    0.03435978f, 0.33235511f, 0.10652734f, 0.42296058f, -0.02963275f, -0.26577795f, -0.09525019f, -0.01805366f, 
    0.13006525f, 0.10645969f, -0.13811366f, 0.02352867f, -0.14249040f, 0.18427116f, 0.13804317f, 0.25671968f, 
    0.03826380f, 0.01802360f, 0.11507438f, -0.04849139f, 0.13678458f, 0.09158015f, 0.09009495f, 0.15380301f, 
    0.07589955f, 0.20124075f, -0.10931991f, 0.33810398f, -0.12739055f, 0.07780641f, 0.01893065f, -0.27084422f, 
    0.15624444f, 0.07845926f, 0.17188832f, 0.12828425f, -0.26660985f, 0.02771196f, -0.12402628f, 0.05434856f, 
    0.01334399f, -0.06816105f, 0.00059382f, 0.00276896f, -0.02698099f, -0.03162897f, -0.03139006f, -0.20098551f, 
    0.27474284f, -0.09722537f, -0.59282976f, 0.40535304f, -0.24902621f, 0.14026900f, 0.01689457f, -0.16006736f, 
    0.05949477f, 0.02666871f, 0.11210203f, 0.08462717f, -0.07756728f, -0.00198692f, 0.54446876f, -0.03728616f, 
    0.09216921f, -0.13642171f, -0.04609244f, -0.02721047f, -0.08389404f, -0.09322134f, 0.01321515f, -0.15778688f, 
    -0.11402668f, 0.06610271f, -0.09889063f, -0.09959025f, 0.04111859f, 0.05578805f, -0.01691234f, -0.13813671f, 
    0.24863344f, -0.20006832f, -0.07211925f, -0.02916370f, -0.09701174f, -0.12740970f, 0.04108674f, -0.05857521f, 
    -0.01827573f, -0.00753812f, 0.07554067f, -0.07958060f, 0.03103373f, 0.02717484f, 0.03655646f, 0.17082861f, 
    0.17021437f, 0.01200794f, -0.11293392f, 0.13296089f, 0.05712363f, 0.08121074f, 0.03670160f, -0.24943095f, 
    -0.12535807f, -0.22267020f, -0.09594496f, -0.19374114f, 0.02778006f, -0.02871022f, -0.11477533f, 0.03969755f, 
    0.02497357f, -0.28951666f, -0.12118367f, -0.16593714f, -0.05729512f, -0.14442630f, -0.06217606f, -0.17049073f, 
    -0.44020310f, -0.10735542f, 0.26609743f, 0.02741706f, -0.06200258f, -0.22276199f, -0.01534436f, 0.07790208f, 
    0.05590172f, -0.01145831f, 0.09852161f, 0.09811549f, -0.09405632f, 0.15258065f, 0.19325928f, 0.10349898f, 
    -0.02406611f, 0.02016285f, -0.08783893f, -0.04544598f, 0.19604890f, 0.03141786f, 0.05074564f, 0.16953862f, 
    0.18902768f, -0.12656899f, 0.20120333f, 0.02913572f, -0.14153230f, 0.04091884f, 0.07357815f, -0.01581501f, 
    0.12469025f, 0.12483251f, 0.26639068f, 0.26202974f, -0.13277937f, 0.05867406f, 0.30443352f, 0.05012394f, 
    -0.21738304f, -0.09043689f, 0.14802979f, -0.08233996f, 0.06480808f, -0.07857268f, 0.09298037f, -0.04005255f, 
    0.21043743f, 0.08860943f, 0.31109878f, -0.14817321f, 0.01698770f, -0.01973415f, -0.18880352f, -0.09348538f, 
    -0.01437438f, -0.16800159f, -0.16996115f, -0.11873349f, -0.09931462f, -0.09092105f, -0.22769956f, -0.11537870f, 
    0.20314229f, 0.27051339f, 0.17036927f, 0.18982449f, 0.09858441f, -0.17989080f, -0.13954107f, -0.30311432f, 
    0.93852443f, -0.12199691f, -0.02162475f, 0.10191198f, 0.29702085f, 0.14156397f, 0.10307350f, 0.27278188f, 
    -0.21327205f, -0.09136938f, 0.01913048f, 0.08720790f, -0.11466186f, -0.16436327f, 0.02159709f, -0.02380937f, 
    0.14140068f, 0.13551381f, -0.03251585f, -0.01691170f, -0.07971767f, 0.05752119f, -0.08895262f, 0.00685144f, 
    -0.11052087f, 0.01641471f, 0.12004240f, 0.08837323f, -0.03529369f, 0.09046084f, -0.01804596f, 0.02273271f, 
    0.04817205f, 0.04208665f, 0.01338495f, -0.20008263f, 0.05054168f, 0.07884912f, 0.06786926f, 0.16139174f, 
    0.19357242f, 0.03992940f, 0.00391203f, -0.12574784f, 0.11125165f, 0.17369166f, 0.02307344f, 0.02513457f, 
    0.03820371f, 0.21533599f, -0.11424597f, -0.08399984f, -0.22372858f, 0.02999423f, 0.08357314f, -0.27064669f, 
    -0.01498852f, -0.01626682f, -0.15319371f, 0.03502078f, 0.15971938f, -0.06555764f, 0.00299637f, 0.27486119f, 
    0.08477090f, 0.10692532f, -0.14532414f, -0.08827870f, 0.00774173f, 0.19055413f, 0.24907060f, 0.14271832f, 
    -0.11997371f, -0.25923631f, -0.18980622f, 0.01692140f, -0.24715486f, -0.02672303f, -0.03777359f, -0.09680821f, 
    -0.03732896f, -0.01737387f, -0.15713367f, -0.05456130f, -0.35794526f, 0.38901594f, 0.16015661f, 0.30686074f, 
    -0.19003226f, -0.19376521f, -0.09148419f, 0.00608639f, -0.23004270f, -0.01492491f, 0.07847182f, 0.09621681f, 
    0.53414017f, -0.00911146f, 0.14513716f, 0.02571676f, -0.00264795f, 0.13943036f, -0.18217951f, -0.04422646f, 
    0.02400734f, -0.12702513f, -0.01945706f, -0.09276688f, 0.29473269f, 0.05814419f, 0.14994147f, -0.13501902f, 
    0.09426489f, -0.15142412f, 0.06029377f, -0.04055681f, -0.03445168f, 0.04039938f, -0.24606203f, 0.05566598f, 
    -0.29065675f, -0.21426164f, -0.01502530f, 0.19455487f, 0.22464196f, 0.05547184f, 0.08556142f, -0.13625771f, 
    -0.18557666f, -0.02688186f, 0.24722400f, -0.02016534f, 0.02529907f, 0.04575224f, 0.11582580f, 0.23186293f, 
    -0.03872884f, -0.07246764f, -0.06920403f, -0.11009818f, -0.13269608f, -0.17256568f, -0.09484668f, 0.03142595f, 
    -0.47729328f, -0.19298078f, -0.15074842f, -0.12699841f, -0.01973217f, -0.11778362f, 0.09048083f, 0.00205876f, 
    0.21570189f, 0.04751926f, -0.01354906f, 0.12157321f, 0.07482299f, -0.03583420f, -0.12057081f, 0.15993111f, 
    0.09008572f, 0.10265245f, 0.11453582f, 0.06701577f, -0.04541335f, 0.12070975f, 0.00519343f, -0.06288141f, 
    0.12101234f, 0.25872892f, -0.14901415f, 0.24626559f, -0.08362163f, -0.17657013f, -0.18138909f, -0.33257052f, 
    0.00385905f, 0.07740584f, 0.02480252f, 0.01677136f, -0.00951040f, -0.10388883f, -0.09491880f, 0.01970193f, 
    0.04641544f, -0.01749341f, 0.01001381f, 0.03280075f, -0.02484870f, -0.01769643f, -0.15385520f, -0.06947757f, 
    -0.04256898f, 0.02018327f, 0.03520209f, 0.04698193f, 0.05699959f, 0.02700950f, -0.04756638f, -0.06475640f, 
    -0.00121701f, 0.01526463f, -0.02964029f, -0.02806946f, -0.03984345f, -0.01245146f, 0.05849166f, -0.07231810f, 
    0.04333787f, -0.05979241f, -0.02606732f, -0.06949672f, -0.03931997f, -0.07367356f, 0.05044221f, 0.04036227f, 
    -0.05263854f, -0.04394268f, -0.00472669f, -0.03992334f, 0.05214385f, -0.01353610f, -0.03733116f, 0.00329913f, 
    -0.01266838f, 0.04160654f, -0.05021528f, -0.02820867f, -0.02866319f, 0.02448284f, -0.04725977f, 0.06218146f, 
    -0.06807569f, 0.00232455f, 0.03112532f, -0.04039935f, -0.03319320f, -0.02860992f, -0.02390226f, -0.03089059f, 
    -0.06535254f, -0.07397585f, 0.04885317f, 0.03154337f, -0.06182045f, -0.06713144f, 0.04877060f, -0.00588473f, 
    0.05915563f, -0.01601667f, -0.00995367f, -0.00816378f, 0.02845134f, 0.06212154f, 0.04846655f, -0.03341919f, 
    0.03431459f, -0.06179959f, 0.00366360f, -0.07684976f, -0.07258002f, -0.05066118f, 0.06077690f, 0.04805818f, 
    -0.00079788f, 0.01703934f, -0.01793758f, 0.05744096f, -0.06365982f, -0.06827243f, -0.05130613f, -0.01449144f, 
    -0.03621212f, -0.02176257f, -0.03527943f, -0.06751933f, 0.00398618f, 0.00832665f, -0.03074756f, -0.05322650f, 
    -0.01642513f, -0.02036535f, -0.01485018f, -0.04170062f, -0.05079979f, 0.05107656f, -0.03993691f, 0.06185821f, 
    -0.07327370f, -0.02379215f, -0.07469463f, -0.06381887f, -0.02853602f, -0.03188173f, -0.04902849f, 0.02595935f, 
    -0.04836169f, -0.05391997f, 0.03623907f, -0.01908001f, 0.03239699f, -0.03381336f, -0.01296643f, 0.03134939f, 
    -0.06258662f, 0.06143963f, -0.06941210f, -0.06275090f, -0.04104863f, -0.01879464f, 0.06344683f, 0.00455235f, 
    -0.05740949f, 0.01260462f, -0.00382807f, -0.02988961f, 0.05308420f, -0.06186663f, 0.00313168f, -0.03818581f, 
    0.00212575f, 0.04867340f, 0.06281599f, -0.00918662f, 0.03867124f, -0.04776577f, -0.06474662f, -0.00126016f, 
    0.02109166f, 0.05655889f, -0.02892062f, 0.05862334f, -0.01234474f, 0.04664717f, 0.05929970f, -0.04371467f, 
    -0.02753240f, 0.03016795f, -0.02870787f, 0.05833594f, 0.05366927f, -0.07820842f, -0.03954700f, 0.05999611f, 
    0.05299004f, -0.02734015f, 0.03700140f, -0.07533402f, 0.06289196f, 0.02063922f, 0.02503556f, 0.01557960f, 
    0.00646179f, -0.02092141f, -0.01439099f, -0.06279895f, 0.06171213f, -0.05853808f, -0.04169608f, 0.05678789f, 
    0.01420384f, -0.04516704f, 0.04570542f, 0.01755418f, 0.02322848f, 0.02568038f, 0.00923346f, -0.04848566f, 
    0.03217586f, -0.00853010f, 0.00340541f, 0.04132973f, -0.06698338f, -0.05768862f, -0.02348157f, 0.05645873f, 
    -0.05941604f, -0.04230104f, 0.05389799f, -0.06524292f, -0.00131926f, -0.05961697f, 0.01876416f, -0.05804799f, 
    -0.26075262f, 0.24712150f, 0.26384863f, 0.15035932f, -0.05577976f, -0.01618501f, -0.26477575f, 0.06840159f, 
    0.00340811f, 0.24652514f, 0.05748403f, 0.02107319f, 0.15720719f, -0.07758334f, 0.04393178f, -0.11567321f, 
    0.07966555f, 0.12066817f, 0.11147980f, 0.04029348f, 0.07857402f, -0.02801695f, 0.05449044f, 0.14201815f, 
    -0.17394871f, 0.21848880f, 0.04006694f, 0.06427238f, 0.06206412f, -0.09677671f, -0.08884981f, 0.07841096f, 
    0.01494616f, 0.07943410f, -0.00399810f, -0.03470307f, 0.02334783f, 0.45926508f, 0.44253752f, 0.20879044f, 
    -0.17094994f, -0.19470619f, 0.23620257f, 0.07807884f, 0.01744214f, -0.14558469f, 0.01650126f, -0.04753253f, 
    -0.49460256f, 0.53944725f, -0.38596502f, -0.34615892f, -0.30279249f, -0.04427966f, 0.08261628f, -0.12141907f, 
    0.18444738f, -0.00499587f, -0.07990694f, 0.12805760f, 0.24914229f, -0.05386359f, -0.23602261f, 0.26272041f, 
    0.05991003f, 0.07381526f, -0.02404145f, -0.11138696f, 0.05228202f, 0.17117850f, -0.10027608f, 0.15827902f, 
    0.30314156f, 0.16670889f, -0.32581043f, 0.03112066f, -0.06216536f, -0.11727124f, 0.14130847f, 0.08544791f, 
    0.01540950f, 0.03044679f, -0.04583029f, -0.02095891f, -0.20915024f, -0.10652252f, 0.01325987f, -0.15225512f, 
    -0.00953231f, 0.13599119f, -0.00202087f, 0.23920342f, -0.02451397f, -0.10555143f, 0.11320670f, 0.12503956f, 
    -0.23088716f, 0.04399348f, 0.17091823f, 0.35816532f, 0.07403366f, 0.09951080f, 0.06262969f, 0.00815733f, 
    0.05774124f, -0.06850966f, -0.15739605f, -0.04571402f, -0.05183435f, 0.22739613f, 0.20637466f, 0.03518775f, 
    -0.07766815f, -0.01091676f, -0.01387488f, -0.03565855f, 0.00102923f, -0.10147970f, -0.05066280f, -0.03520234f, 
    0.03212618f, -0.07185912f, 0.03906508f, 0.20622326f, 0.08825895f, 0.01264926f, -0.13759074f, 0.07584177f, 
    0.12069354f, 0.00768886f, -0.13402416f, 0.11770806f, -0.09297317f, 0.13625844f, 0.36959335f, 0.08122083f, 
    0.04048111f, -0.16402839f, -0.15288642f, -0.20401235f, 0.05463479f, 0.15003414f, 0.09280941f, -0.01209477f, 
    -0.27236092f, -0.16787697f, -0.06732403f, 0.24220894f, -0.05901989f, 0.00120729f, 0.05805602f, -0.00956439f, 
    0.10024471f, -0.05965726f, 0.00345930f, 0.16005874f, 0.23743248f, 0.15632202f, -0.07769265f, 0.14313477f, 
    -0.13183004f, -0.07199560f, 0.10754802f, 0.19712575f, 0.01257745f, 0.06240516f, 0.17790943f, -0.15155992f, 
    0.27515918f, -0.08528499f, 0.02404427f, 0.12527488f, 0.07805332f, 0.06458596f, 0.04255534f, -0.11479921f, 
    -0.18148655f, 0.07154851f, 0.11824078f, -0.02088475f, 0.11704603f, -0.01459884f, 0.14897822f, 0.08779815f, 
    -0.00696602f, 0.06250097f, -0.10235193f, -0.06270987f, 0.07728349f, 0.02219962f, -0.09516779f, -0.01169902f, 
    -0.09314536f, -0.03854049f, -0.04648286f, 0.07610060f, 0.02371910f, 0.06573307f, -0.02617457f, -0.03214588f, 
    0.17766322f, 0.12525979f, 0.14956565f, 0.12295344f, 0.22091965f, 0.04544278f, 0.05603323f, 0.06427909f, 
    0.03748700f, 0.04241431f, -0.03977900f, -0.13019535f, -0.05870647f, -0.11550859f, -0.21769015f, -0.19592735f, 
    -0.20984915f, -0.10034163f, -0.00624811f, 0.10982297f, 0.06955519f, -0.03439633f, 0.14319995f, -0.00787076f, 
    -0.08381954f, 0.04567719f, -0.44310203f, -0.17236088f, 0.16915129f, 0.27302191f, 0.47475138f, 0.38985193f, 
    0.00776028f, 0.21927708f, 0.21002182f, 0.16544864f, -0.07741793f, 0.08332847f, 0.04942822f, 0.12836055f, 
    -0.17156419f, 0.43951619f, 0.23605709f, 0.06037197f, 0.11305520f, 0.01892812f, 0.05207703f, 0.16300781f, 
    0.02278399f, -0.12231608f, -0.06695625f, 0.08295796f, 0.21103036f, 0.23871492f, -0.37289605f, 0.21287796f, 
    -0.08196623f, 0.23099214f, 0.06222286f, -0.02457207f, -0.04092127f, -0.02090527f, -0.07135727f, -0.11383282f, 
    -0.22543797f, 0.07499833f, -0.20403573f, -0.05472823f, -0.00198272f, -0.00013554f, 0.00585592f, 0.04082530f, 
    -0.04982537f, 0.13303185f, 0.14551389f, 0.13126320f, -0.09827603f, 0.39406335f, 0.06463713f, 0.13018118f, 
    -0.17173247f, -0.02625463f, -0.13848184f, 0.35182941f, 0.03827845f, -0.13315472f, -0.26197666f, 0.07118817f, 
    -0.05163449f, -0.05234818f, 0.03624069f, 0.18624632f, -0.01985835f, 0.05801513f, 0.03204316f, 0.07023364f, 
    0.10290283f, 0.10586929f, 0.10039046f, 0.32332012f, -0.06021262f, 0.15799199f, 0.09892072f, -0.03034646f, 
    -0.01791083f, -0.02901271f, 0.01478278f, 0.03813870f, 0.08995885f, 0.24211127f, 0.01900112f, 0.20239876f, 
    0.28475505f, 0.19219220f, 0.31105152f, 0.13176455f, -0.19710267f, 0.12149669f, -0.14455029f, -0.20237228f, 
    -0.01684313f, -0.02963112f, -0.18316305f, 0.01956715f, 0.26513663f, -0.00672533f, 0.26267827f, 0.35346714f, 
    0.06632927f, 0.00421084f, -0.03296065f, 0.13906455f, -0.12561068f, 0.06366952f, -0.07130415f, -0.07217711f, 
    -0.35503885f, -0.05115157f, -0.19938603f, -0.00938989f, 0.00778561f, 0.03484393f, 0.06819756f, 0.02440101f, 
    0.02160294f, -0.06580468f, -0.16683976f, -0.16799979f, 0.05654912f, 0.33117226f, 0.10672199f, 0.14405958f, 
    0.04864881f, 0.14146422f, -0.04262658f, 0.27956066f, -0.13453569f, 0.00267715f, -0.10689106f, -0.14150885f, 
    0.16565545f, -0.09442963f, 0.00429881f, 0.17908621f, 0.09792354f, 0.06840463f, -0.25883192f, -0.03932290f, 
    -0.01255909f, 0.06900169f, 0.22536264f, -0.10856151f, -0.12693708f, -0.13175248f, -0.04791790f, 0.02380190f, 
    -0.05085700f, -0.03659765f, -0.07841604f, -0.07216590f, 0.05076078f, 0.03173042f, 0.08148928f, 0.02012492f, 
    0.01168076f, -0.00907491f, -0.07459391f, -0.05165142f, 0.03342406f, -0.06179921f, 0.01424096f, 0.00242931f, 
    0.02134020f, -0.04140114f, 0.01614637f, -0.02123913f, -0.00094555f, 0.00897012f, -0.01102105f, -0.00052959f, 
    -0.02120704f, -0.06593180f, 0.06036123f, -0.03827174f, 0.05660605f, 0.02014597f, -0.05263094f, -0.05578348f, 
    0.05386122f, -0.03101859f, 0.05846759f, -0.03398191f, -0.07305320f, -0.01782721f, -0.06914627f, -0.00666340f, 
    -0.01384189f, 0.05711549f, -0.07710356f, -0.00748345f, -0.06800201f, 0.03405818f, -0.01755600f, 0.02496170f, 
    0.04891163f, 0.05908950f, -0.02011765f, -0.04853591f, -0.06510922f, -0.06622020f, -0.02846190f, -0.02879953f, 
    -0.00983867f, 0.03072720f, 0.05878295f, 0.05337425f, -0.00263805f, -0.04405620f, 0.01015485f, -0.05089022f, 
    0.00062779f, -0.07120950f, 0.01131953f, -0.02149483f, 0.01610678f, 0.05645633f, 0.00462457f, -0.00657854f, 
    -0.02515473f, 0.05608083f, -0.07484476f, 0.05538103f, -0.04239942f, 0.05609375f, -0.07071644f, 0.05159231f, 
    -0.06371067f, -0.06530883f, -0.01976651f, -0.01317285f, -0.06653339f, 0.02548662f, 0.03186367f, 0.06726865f, 
    -0.00432429f, -0.07383154f, 0.03701360f, -0.05359374f, -0.02106938f, 0.01905429f, 0.02930289f, -0.06404072f, 
    -0.00510379f, -0.05642772f, -0.03060463f, 0.00677780f, -0.02539474f, 0.05124764f, 0.04639794f, 0.04490694f, 
    0.05668514f, 0.04126805f, -0.07426541f, 0.05934172f, -0.06899308f, 0.00669190f, -0.00084071f, 0.06266229f, 
    -0.06934570f, -0.04733243f, 0.02737143f, 0.03722518f, -0.04503387f, -0.07346690f, 0.01214996f, 0.05577243f, 
    -0.05301374f, -0.05770915f, -0.03545551f, -0.05298019f, -0.05995862f, -0.07728174f, -0.00551042f, -0.03218540f, 
    0.00485219f, -0.04143441f, -0.05420419f, 0.02501743f, -0.00672593f, 0.05453096f, -0.00045261f, -0.00234705f, 
    -0.03745528f, -0.06176235f, -0.04423546f, 0.02996805f, -0.01778756f, 0.01802451f, -0.01465748f, -0.06791320f, 
    -0.07258853f, -0.00798783f, 0.01145569f, 0.02720076f, 0.04317672f, 0.05756098f, 0.02119137f, -0.04130916f, 
    0.07412929f, -0.00805053f, -0.07093736f, -0.01954329f, 0.04268823f, 0.06372784f, 0.02505636f, -0.00425163f, 
    -0.00237828f, -0.01028502f, 0.06660879f, 0.00028674f, -0.06642137f, 0.00134521f, 0.05138926f, -0.05174551f, 
    -0.02256705f, -0.01205196f, -0.01428424f, 0.05105243f, -0.05123753f, -0.05783805f, -0.01625774f, -0.05003852f, 
    -0.04385146f, -0.04878794f, 0.01659012f, -0.03734495f, 0.04204492f, -0.02131052f, 0.03277827f, 0.05484598f, 
    -0.03529112f, 0.03041078f, -0.00504343f, -0.05943552f, 0.00880770f, -0.07914046f, -0.06281383f, 0.02136383f, 
    -0.01685718f, 0.05589356f, 0.06276049f, -0.05842070f, -0.07483529f, -0.07499095f, 0.01547928f, -0.07444113f, 
    -0.07315471f, -0.04284486f, 0.04292400f, 0.06478945f, -0.02145287f, 0.05220898f, -0.01516141f, 0.03324612f, 
    -0.03883117f, -0.02686275f, 0.03030382f, -0.05341792f, 0.03902165f, -0.04706828f, -0.02266762f, -0.05607405f, 
    -0.05451699f, 0.06995904f, -0.05520716f, -0.07754841f, 0.01417524f, 0.03019764f, 0.04967639f, -0.00027541f, 
    0.01159709f, -0.02451161f, -0.06915842f, -0.01836113f, -0.00174047f, 0.04375885f, -0.00677111f, -0.05570225f, 
    -0.03112227f, -0.01712829f, -0.06934945f, -0.06605420f, -0.06716185f, 0.03283335f, -0.00369000f, 0.03744782f, 
    0.01067863f, -0.06603698f, -0.01221963f, -0.06128763f, -0.06369890f, 0.05575585f, 0.05144978f, 0.01264736f, 
    0.00991590f, -0.05468813f, 0.00970744f, -0.04683715f, 0.05143793f, 0.01596309f, -0.00861510f, -0.03731322f, 
    0.06662190f, -0.03632364f, 0.02464432f, -0.03308766f, 0.01671227f, -0.00409804f, 0.00555226f, 0.03549984f, 
    0.01958547f, 0.04822491f, 0.02689841f, 0.05948521f, 0.05241733f, -0.01973166f, -0.02575436f, -0.03818662f, 
    -0.04346318f, 0.06949768f, -0.03400346f, -0.04800865f, 0.05874797f, 0.01209160f, 0.03415990f, 0.04404587f, 
    -0.04329072f, 0.04964718f, -0.07216209f, -0.02884934f, 0.04240354f, -0.01937234f, 0.01913048f, -0.06708545f, 
    -0.06192556f, -0.00792891f, -0.07479664f, -0.03538221f, 0.02326711f, -0.00673374f, -0.02525234f, 0.03322287f, 
    0.02573641f, 0.02075578f, -0.03705658f, -0.06620467f, -0.02622443f, -0.07580663f, -0.00613963f, -0.02359528f, 
    -0.03807208f, 0.03040098f, 0.05156086f, -0.03849455f, -0.02363941f, -0.07695328f, 0.02360056f, 0.03094537f, 
    -0.03716316f, -0.02458530f, -0.03159489f, -0.05332129f, 0.04461949f, -0.04220537f, -0.00815779f, -0.05416103f, 
    -0.00285764f, 0.03749296f, -0.01951171f, -0.07121899f, -0.01159213f, -0.07616768f, 0.03315480f, -0.03485834f, 
    0.05949915f, -0.02367025f, 0.00141094f, 0.01735863f, -0.06464812f, 0.00321605f, -0.05383190f, 0.01665490f, 
    0.03190595f, -0.06145243f, 0.01678342f, 0.05553608f, -0.04343018f, 0.01370084f, 0.01368491f, -0.05813895f, 
    0.05954546f, 0.05585482f, -0.03959325f, 0.04233598f, -0.07144934f, -0.05453844f, 0.00505209f, -0.07374107f, 
    0.02222794f, -0.03414429f, 0.00298486f, -0.03856364f, 0.05232309f, -0.07188343f, 0.02069580f, -0.00509541f, 
    0.00084636f, -0.00114185f, -0.00375793f, 0.00163895f, 0.03537786f, 0.03819797f, 0.05924741f, -0.00962595f, 
    0.05546129f, 0.04926667f, 0.00070930f, -0.06676552f, -0.02097758f, -0.02374461f, -0.04231910f, -0.04847686f, 
    -0.01291961f, 0.06291482f, 0.06316050f, -0.01632652f, -0.03232560f, -0.03810846f, -0.07740111f, 0.01711991f, 
    -0.05844504f, -0.06271327f, 0.02079757f, -0.05531656f, -0.06646728f, 0.03180676f, 0.02859786f, -0.05093274f, 
    0.38838097f, 0.01008827f, 0.21739525f, -0.29188755f, 0.12213489f, 0.03204740f, -0.06753870f, -0.08592613f, 
    0.07197142f, -0.02661396f, 0.11781406f, 0.04429166f, -0.05097040f, -0.04935443f, -0.17319673f, -0.00981446f, 
    0.01112700f, -0.12109079f, 0.08247935f, 0.10091674f, -0.04751126f, 0.15678881f, 0.20544194f, -0.01040759f, 
    0.16083115f, 0.00636284f, 0.11128112f, -0.26692471f, -0.12600411f, -0.04856186f, 0.05172839f, 0.07722062f, 
    0.22438312f, 0.07296960f, 0.11833991f, 0.15916590f, -0.09771267f, -0.48991346f, -0.25306737f, -0.11909227f, 
    -0.07635038f, -0.02515641f, -0.04232460f, 0.13739535f, -0.12751657f, -0.04567149f, -0.01919220f, 0.00754134f, 
    0.33469453f, 0.15836392f, 0.37695256f, -0.11492348f, 0.38206297f, -0.04630611f, 0.31796792f, 0.08117445f, 
    0.04496730f, 0.09720807f, 0.18990445f, 0.13058600f, 0.08800492f, -0.05977277f, -0.18371074f, 0.06235599f, 
    -0.09218720f, 0.06608447f, 0.00582652f, 0.06198653f, -0.06692512f, -0.08038136f, 0.04766572f, 0.06078709f, 
    -0.07755651f, 0.04500491f, 0.04694235f, 0.21959305f, 0.05908442f, -0.00325790f, 0.02321903f, 0.02220580f, 
    -0.09785436f, 0.00004123f, 0.03925479f, -0.00469230f, -0.03916033f, 0.16970579f, -0.05371929f, 0.08165294f, 
    0.31359392f, 0.00582078f, 0.29404932f, 0.11345838f, 0.17247263f, -0.10892533f, 0.31488410f, -0.00952978f, 
    0.17553495f, 0.31834400f, -0.08072932f, -0.25272137f, -0.05235903f, 0.13173473f, -0.03136582f, 0.07638728f, 
    0.02507327f, 0.12497443f, 0.01765324f, 0.12040620f, 0.11382834f, 0.13492669f, -0.06767437f, -0.23720311f, 
    0.04728307f, 0.04581755f, -0.01965208f, -0.02816573f, 0.11159893f, 0.11450104f, 0.15694904f, 0.26266328f, 
    -0.07706240f, -0.28541747f, -0.18938072f, -0.08886793f, -0.00701514f, 0.01930113f, -0.14237754f, -0.11071338f, 
    0.00426293f, 0.13284719f, 0.20762721f, 0.09003299f, 0.10028607f, -0.03237962f, -0.31302851f, -0.12853885f, 
    -0.18477575f, 0.08535990f, 0.25259000f, 0.29844794f, -0.04187271f, 0.02221683f, -0.03566429f, -0.00989177f, 
    0.13815399f, 0.11616174f, 0.00641255f, -0.27402449f, -0.13535814f, -0.07834601f, -0.07508236f, -0.11319955f, 
    0.08908864f, 0.06460536f, -0.05119384f, -0.25472280f, -0.25967699f, -0.15623353f, -0.39410689f, -0.29196322f, 
    0.08993749f, 0.02938615f, -0.21565558f, 0.13519670f, 0.10214230f, 0.02070176f, -0.10461003f, 0.07917997f, 
    -0.34871003f, -0.00907297f, -0.08265436f, 0.02124615f, 0.05031668f, 0.06513347f, 0.06408715f, 0.21584694f, 
    0.06135032f, 0.08652480f, -0.01279905f, 0.07300232f, -0.16755308f, -0.07226057f, -0.05142887f, -0.18596554f, 
    -0.01172264f, -0.06189425f, 0.04891526f, -0.00712360f, 0.00223912f, 0.14900863f, 0.09386849f, -0.01234509f, 
    -0.32238322f, 0.18301845f, 0.15638705f, 0.16573392f, -0.03995235f, 0.04587613f, -0.11585456f, 0.12272628f, 
    0.12791470f, 0.00646690f, -0.10026887f, 0.00290705f, 0.14019608f, 0.23632637f, 0.07202239f, 0.04591686f, 
    -0.07290372f, 0.04564930f, 0.11523741f, -0.04324055f, 0.01843644f, -0.13989097f, 0.20198983f, 0.09798553f, 
    0.25200745f, 0.23787124f, 0.05465500f, 0.17295650f, -0.13751949f, 0.03913232f, -0.05098987f, -0.04633061f, 
    0.23623215f, 0.10140299f, 0.13419153f, 0.07689252f, -0.02784657f, 0.04370259f, -0.07626366f, -0.10176251f, 
    0.13298993f, 0.15317875f, 0.12664565f, -0.17068747f, 0.17905343f, -0.05881348f, 0.03961065f, -0.08736785f, 
    -0.05925925f, -0.54084498f, -0.17635262f, 0.49972621f, -0.07561183f, 0.15807405f, 0.09268913f, -0.09990846f, 
    -0.07950166f, 0.11654811f, -0.06284122f, -0.06310192f, -0.10543317f, 0.23936991f, 0.39222041f, -0.24332568f, 
    0.26276913f, -0.13408804f, 0.00011164f, -0.03717972f, 0.14391828f, -0.13815178f, -0.09137284f, 0.05381015f, 
    0.23561391f, -0.16833940f, -0.19245745f, 0.04819065f, -0.03656818f, 0.08212855f, 0.01566478f, -0.04300420f, 
    0.15904261f, -0.06576797f, -0.08625092f, -0.01071527f, 0.05412067f, -0.33787242f, 0.51534849f, -0.22154118f, 
    -0.15432152f, 0.04594862f, 0.22354035f, 0.08078039f, -0.00446224f, 0.09104426f, 0.17567573f, -0.04320274f, 
    -0.00379674f, -0.07269919f, -0.03029278f, -0.10209950f, 0.12792027f, 0.16749139f, 0.00689529f, 0.03700143f, 
    0.11759887f, -0.26221314f, 0.10902335f, -0.14210759f, 0.06843394f, -0.33245537f, 0.01464238f, 0.18165140f, 
    -0.01090049f, 0.03921421f, -0.01304288f, 0.11513352f, -0.09377609f, -0.15243356f, -0.07918753f, -0.10976159f, 
    -0.38764548f, 0.03520478f, -0.03841399f, -0.15421000f, -0.12992603f, -0.12992810f, 0.07501062f, 0.08854360f, 
    -0.01851864f, 0.04849516f, 0.08999924f, 0.08834627f, -0.00835200f, 0.23405780f, -0.04240507f, -0.18878256f, 
    0.18688640f, -0.00594876f, 0.22472782f, 0.13399546f, 0.32082096f, 0.03568542f, 0.12199958f, 0.12977998f, 
    0.18028575f, -0.17727761f, 0.00838767f, 0.15105602f, 0.10935859f, -0.05779476f, 0.09564923f, 0.13714170f, 
    -0.03191265f, 0.18148078f, 0.14203413f, 0.04291432f, 0.05097456f, 0.10919990f, -0.01008426f, -0.16696958f, 
    0.07225241f, -0.16343980f, -0.01669506f, -0.18028198f, 0.06558029f, 0.05854711f, -0.03875203f, 0.16152692f, 
    -0.09383855f, 0.08248932f, -0.04925599f, -0.31057921f, -0.01668302f, 0.01843144f, -0.27671856f, -0.01533289f, 
    0.17186867f, -0.06339557f, 0.04016735f, -0.13318726f, 0.11518965f, -0.02875600f, -0.02308578f, 0.09211130f, 
    0.19046395f, -0.05590205f, 0.05823988f, 0.03160196f, 0.00716468f, -0.09071478f, -0.04007784f, -0.11271860f, 
    -0.41647026f, 0.04582398f, 0.08636746f, -0.01616153f, -0.01238554f, -0.03948681f, 0.03121283f, -0.25831047f, 
    0.07567818f, 0.08870978f, 0.07859078f, 0.12476350f, -0.16473937f, -0.05132881f, -0.02072491f, -0.27137688f, 
    0.12571312f, 0.14570972f, 0.06760561f, 0.13030250f, 0.09923805f, 0.23626848f, -0.19498968f, 0.04218605f, 
    -0.16895795f, -0.09344442f, -0.04266863f, -0.04462495f, 0.13842708f, 0.03067086f, 0.00716410f, 0.04376430f, 
    0.08270833f, -0.09701893f, -0.06008540f, 0.10919206f, -0.10901012f, 0.20448697f, -0.12621881f, -0.14296484f, 
    -0.04400719f, -0.06881126f, -0.11263329f, 0.04020917f, -0.08933710f, -0.03812725f, 0.01587782f, 0.03005563f, 
    -0.49443653f, 0.31963360f, 0.06520172f, -0.44898191f, 0.13316566f, -0.18968265f, 0.04756739f, 0.16570878f, 
    0.16553532f, -0.19531903f, 0.17175934f, 0.03356808f, 0.24499658f, -0.13959180f, -0.41530597f, 0.00898037f, 
    -0.04893729f, 0.06284008f, 0.03272827f, 0.04575049f, 0.01845523f, 0.20798224f, 0.02667028f, 0.04335263f, 
    0.11183133f, 0.34305200f, 0.15457407f, 0.01324371f, -0.05254509f, -0.10669328f, -0.08102847f, 0.04003499f, 
    -0.11913801f, 0.09420275f, 0.04351334f, 0.08011263f, 0.28570241f, -0.16950749f, -0.47237793f, -0.08111391f, 
    0.09065780f, -0.05314078f, 0.00517688f, -0.24277499f, 0.26148489f, -0.21091774f, 0.04686936f, 0.08066919f, 
    -0.33778185f, 0.12717855f, 0.13864221f, 0.15271975f, 0.08872271f, -0.15807459f, 0.00789277f, 0.01580964f, 
    -0.06351320f, 0.34104979f, -0.15184802f, 0.19829664f, -0.14065205f, 0.30208224f, -0.01673228f, 0.10186779f, 
    -0.20807451f, 0.08911102f, 0.00826488f, -0.03014453f, 0.11934894f, 0.09695755f, 0.12574908f, 0.06666350f, 
    0.62949389f, 0.20706803f, -0.13288310f, -0.15940702f, -0.03092977f, -0.03305614f, -0.02726443f, 0.04177447f, 
    0.02629025f, -0.01289784f, -0.08624271f, 0.03183903f, -0.00588090f, 0.00933587f, 0.03367558f, 0.08947993f, 
    -0.01596435f, 0.04398151f, -0.17907007f, -0.13497686f, -0.18664470f, 0.04063886f, 0.00546617f, -0.07768187f, 
    0.00676681f, 0.04344416f, 0.08839377f, 0.18577401f, -0.00343716f, 0.08055042f, -0.10513258f, 0.02402449f, 
    0.07080647f, -0.06829165f, -0.03187441f, 0.04450708f, 0.11472084f, -0.11755989f, 0.17168747f, -0.14716184f, 
    0.03957964f, 0.00950116f, 0.03706611f, 0.00259333f, 0.04360002f, 0.01109394f, 0.07280737f, -0.16317725f, 
    0.07599381f, -0.14122720f, 0.03684754f, 0.06322225f, 0.11179136f, -0.00063556f, 0.12738712f, 0.08380938f, 
    -0.02990614f, 0.14521386f, 0.00126910f, 0.12389426f, -0.02504710f, -0.02313089f, 0.05103968f, 0.05838520f, 
    -0.18152151f, -0.03364406f, -0.05147062f, -0.14073376f, -0.16782035f, -0.02369136f, 0.10198966f, 0.18123086f, 
    -0.38465783f, 0.13375114f, 0.38811418f, 0.44624498f, 0.09502491f, 0.18334396f, 0.05094765f, 0.05715672f, 
    0.00463094f, 0.00317682f, 0.06494739f, 0.07323666f, 0.07361433f, -0.00609529f, 0.10162646f, 0.01534570f, 
    -0.18135674f, -0.00364167f, -0.15611039f, -0.08816549f, -0.08123673f, 0.04598176f, -0.10260553f, 0.43397784f, 
    -0.01418654f, -0.08240896f, 0.23573951f, 0.21018492f, 0.06255389f, 0.02806474f, -0.12298334f, -0.12982416f, 
    0.16404699f, 0.18009628f, 0.12496589f, 0.26813167f, 0.22927196f, -0.01591757f, -0.34692991f, -0.46424371f, 
    0.08427847f, 0.04171253f, -0.03593465f, 0.03869184f, -0.05631863f, -0.16369352f, -0.15172334f, -0.21744850f, 
    0.03491072f, 0.06501345f, 0.45279557f, 0.12749848f, 0.28701183f, -0.16831772f, -0.13092303f, -0.10725920f, 
    -0.11711405f, 0.14023894f, 0.10815059f, 0.10704986f, -0.07537405f, 0.24731871f, -0.21332645f, 0.04858828f, 
    -0.02701041f, 0.01412160f, -0.15915115f, -0.03925313f, -0.00350896f, 0.07332277f, 0.00191367f, -0.19003405f, 
    -0.04733150f, 0.05191432f, 0.21029416f, 0.18689229f, -0.01061611f, 0.11004099f, 0.07557313f, 0.16927402f, 
    0.04820651f, -0.07388759f, -0.08953377f, 0.05402739f, 0.11537251f, -0.11138602f, -0.03793381f, 0.26999608f, 
    0.01638300f, 0.04550276f, -0.19142380f, 0.11383315f, -0.06080595f, 0.38387284f, -0.30110961f, 0.07304879f, 
    -0.12553380f, -0.02874682f, 0.17952663f, 0.17096455f, 0.10288503f, 0.07586437f, -0.08180988f, -0.05613605f, 
    -0.06936593f, -0.09823119f, 0.14748745f, 0.13383465f, 0.08683489f, 0.16057481f, 0.03879314f, 0.20097777f, 
    -0.04353804f, 0.11009138f, 0.07868902f, 0.05419117f, 0.05861296f, 0.09693071f, -0.06076528f, -0.02595796f, 
    0.25020406f, 0.50408351f, 0.15338297f, -0.00244796f, 0.09594481f, 0.13130316f, -0.09824637f, -0.17342046f, 
    -0.02950593f, 0.09542862f, 0.03323717f, 0.38909712f, 0.34873915f, 0.16742918f, 0.23653330f, 0.07265543f, 
    -0.14350370f, 0.10464688f, -0.13672389f, 0.06859034f, 0.06145285f, 0.04289432f, 0.04375767f, -0.08588694f, 
    -0.37012368f, -0.11156909f, -0.17085131f, 0.31140536f, 0.06613936f, -0.02703761f, -0.07206790f, 0.08385903f, 
    0.00118776f, 0.13657150f, 0.07550535f, 0.01210748f, 0.27868846f, -0.09589873f, 0.22459944f, -0.16144192f, 
    -0.12360312f, 0.09937432f, 0.14446846f, -0.07041091f, -0.12512331f, -0.12453232f, -0.11210421f, -0.25135997f, 
    -0.20629755f, -0.02501251f, -0.04837401f, 0.03645939f, 0.07344074f, 0.12416898f, -0.39899978f, 0.02265291f, 
    -0.15033221f, -0.03476539f, 0.07530461f, -0.23844133f, -0.06218908f, -0.06540459f, -0.04574201f, 0.02033925f, 
    -0.00389016f, 0.08781986f, 0.02128942f, 0.05050559f, 0.07559968f, 0.09132250f, 0.14923991f, -0.07951617f, 
    0.51877385f, -0.38774106f, -0.40823880f, -0.38498142f, 0.08193698f, 0.10670327f, -0.01226407f, -0.17983246f, 
    -0.07402408f, -0.05676409f, -0.06438051f, -0.10659093f, 0.07425149f, -0.05282575f, 0.17222512f, 0.27473330f, 
    -0.16343285f, -0.14389747f, -0.18397275f, 0.06803933f, -0.10696702f, 0.20478599f, 0.14517850f, 0.24048589f, 
    -0.06107080f, -0.32007256f, 0.01815264f, 0.05928858f, -0.11561646f, 0.14684398f, 0.11488896f, 0.05558341f, 
    0.04222897f, 0.18092589f, 0.19305909f, 0.19046526f, -0.05266168f, -0.23433776f, -0.11605158f, -0.04306041f, 
    0.06790851f, 0.21896666f, -0.03266306f, -0.01880397f, -0.02849617f, 0.00493832f, -0.11663113f, -0.09245089f, 
    0.16543511f, -0.21149328f, 0.42030990f, 0.21831179f, -0.04609687f, 0.19729996f, 0.05658655f, 0.00514089f, 
    -0.01158639f, 0.09422094f, 0.09756699f, -0.06921053f, -0.27682233f, -0.16026281f, -0.06164755f, 0.16889922f, 
    -0.04444648f, 0.01136319f, 0.00170205f, 0.03063431f, -0.03410484f, 0.01707642f, 0.02237307f, -0.11045562f, 
    0.38221145f, 0.08060431f, 0.78508013f, 0.09825472f, -0.08955908f, -0.06769872f, -0.23856226f, 0.09463662f, 
    -0.09549361f, 0.02610403f, 0.09773833f, -0.01006041f, -0.15927666f, 0.39393738f, -0.24771795f, 0.31175971f, 
    0.06782956f, 0.01898346f, 0.01836559f, 0.05245299f, -0.18121204f, 0.16425472f, 0.01310016f, 0.06895732f, 
    0.36445639f, -0.04502688f, 0.09721698f, 0.06436153f, -0.06930427f, 0.05614924f, -0.09852290f, 0.08945336f, 
    -0.18669473f, -0.02059150f, 0.20297107f, -0.04264585f, 0.11966486f, 0.01119646f, 0.05789842f, -0.13604410f, 
    -0.06025870f, -0.05304475f, -0.03752000f, -0.00666584f, 0.05706898f, 0.10765630f, 0.03551212f, -0.21052973f, 
    0.00903392f, -0.06375911f, -0.08765484f, 0.19731115f, 0.20311464f, -0.07448982f, 0.13399076f, 0.23306109f, 
    -0.15456021f, 0.01095573f, 0.13736056f, 0.15364777f, -0.03195127f, -0.39963716f, -0.01450907f, 0.11545573f, 
    -0.04529658f, 0.06865972f, 0.13018271f, -0.07875776f, -0.05220762f, -0.09207215f, -0.11549719f, 0.04980152f, 
    0.14104792f, 0.55719614f, 0.20214696f, -0.01219100f, -0.00674534f, 0.01594815f, -0.00668078f, 0.07449663f, 
    0.23481123f, 0.21132581f, 0.11621682f, 0.13177210f, -0.27804601f, -0.28752774f, 0.03790195f, 0.32410440f, 
    0.04840402f, 0.02700956f, 0.30504587f, 0.03967918f, -0.05209142f, -0.01913847f, -0.02286056f, -0.01799789f, 
    0.02674615f, 0.17280455f, 0.08979556f, 0.27298424f, 0.01377591f, -0.01617779f, -0.00093118f, -0.10937354f, 
    -0.12334948f, -0.26040164f, -0.15588239f, -0.14101726f, 0.14733593f, 0.14932133f, 0.12098611f, 0.00238259f, 
    -0.13059592f, 0.01395127f, -0.01370179f, -0.00185668f, -0.00513509f, -0.18947771f, -0.13265029f, -0.06481123f, 
    0.10471068f, 0.63340634f, 0.24496850f, 0.52611005f, 0.08815317f, -0.28767678f, 0.07745729f, -0.15172704f, 
    0.08207045f, 0.26416296f, 0.13701558f, 0.06625818f, -0.08180429f, 0.06295244f, -0.02877525f, 0.02308381f, 
    -0.06423969f, -0.05918842f, 0.07366371f, 0.02567112f, 0.01723394f, 0.32670602f, -0.01047176f, 0.17898507f, 
    0.08017021f, 0.44915473f, -0.27365395f, 0.14696988f, -0.15043697f, 0.04305642f, 0.05852062f, 0.00218177f, 
    0.08849172f, 0.03934458f, 0.18458140f, 0.12060821f, -0.70756310f, -0.10805257f, -0.73182702f, -0.48733050f, 
    0.03100902f, -0.30712745f, 0.00871272f, -0.19676195f, -0.14380071f, -0.07387376f, -0.14535879f, -0.20157574f, 
    0.25071585f, 0.20302242f, -0.52622384f, -0.11229403f, -0.50918722f, 0.17733148f, -0.18791838f, -0.04348454f, 
    0.02727293f, -0.04687741f, 0.26039532f, -0.05127514f, 0.08044045f, 0.41030401f, 0.18943812f, -0.28501305f, 
    0.18458700f, -0.22648543f, 0.04148620f, -0.03539412f, 0.09301356f, 0.08618291f, -0.07946800f, -0.12375060f, 
    0.06441283f, 0.10941043f, -0.30103537f, -0.14386491f, -0.07448658f, -0.05625736f, 0.13113420f, -0.11046182f, 
    0.16562517f, 0.06977881f, -0.23768392f, -0.06513441f, -0.05174104f, -0.16077572f, -0.26901805f, 0.01814608f, 
    -0.00112262f, -0.19313772f, 0.16671717f, -0.00060741f, 0.10040817f, -0.04944674f, 0.18136452f, 0.01643281f, 
    0.13108566f, 0.21970235f, 0.11048654f, -0.06686829f, -0.03356666f, 0.01330987f, -0.01471519f, -0.02495010f, 
    -0.13030496f, 0.13131769f, 0.01119138f, -0.16927810f, 0.24947092f, 0.12283891f, -0.09496237f, 0.15256463f, 
    -0.20914742f, -0.05990997f, 0.04198850f, -0.04563901f, 0.02127188f, -0.07474532f, -0.06214450f, -0.02574798f, 
    -0.16211338f, -0.10072163f, 0.16440694f, -0.21861273f, -0.07052279f, -0.12768912f, 0.10355785f, 0.05063318f, 
    0.10932703f, 0.08447061f, 0.15978009f, 0.00156811f, 0.03604117f, 0.22094680f, -0.08006223f, 0.13584507f, 
    0.00603843f, 0.07376116f, 0.19703123f, -0.07169124f, 0.00984075f, -0.18885587f, -0.05652187f, 0.31374043f, 
    0.16104446f, -0.11077596f, 0.13543728f, 0.00672297f, -0.16821985f, 0.24002156f, -0.02106328f, -0.06042601f, 
    0.25319809f, 0.13145296f, 0.30247617f, 0.05034218f, -0.18399544f, 0.02784258f, -0.13283059f, -0.01601410f, 
    0.01099222f, -0.04055222f, -0.07221967f, -0.13790172f, 0.01427392f, -0.00422020f, 0.07748505f, -0.05014355f, 
    0.39160177f, -0.06280591f, 0.27061364f, -0.09535826f, 0.16951835f, -0.26053464f, 0.31758901f, -0.09463377f, 
    0.13892603f, -0.04224985f, -0.35719094f, 0.22815263f, -0.24418136f, -0.27215514f, -0.10226001f, 0.02743634f, 
    0.02053348f, 0.14118566f, 0.19143148f, 0.02403972f, 0.05026010f, -0.09699752f, -0.19092359f, 0.12947458f, 
    0.25529757f, -0.03089504f, -0.14602743f, 0.06041225f, 0.06360210f, -0.05131107f, 0.16053241f, 0.15812975f, 
    -0.03171238f, 0.15701148f, -0.02184075f, -0.06142255f, -0.18639977f, -0.08086047f, 0.09137953f, 0.02642250f, 
    0.02154363f, 0.07479157f, -0.15987098f, 0.04015452f, 0.10757022f, 0.25475347f, -0.32656661f, 0.41185465f, 
    0.15381624f, -0.41119891f, -0.21588925f, 0.28338075f, 0.25632352f, 0.11160663f, 0.05026506f, -0.01063859f, 
    -0.00369557f, 0.09056298f, 0.13253534f, 0.25061858f, 0.03452066f, 0.16628847f, -0.14020562f, -0.08197372f, 
    -0.07450386f, -0.12959166f, -0.08996688f, -0.08483843f, 0.09446855f, 0.06906825f, -0.09573841f, 0.00591165f, 
    0.20358460f, -0.12641637f, -0.13264085f, 0.05155050f, 0.02055628f, -0.14538747f, -0.30092421f, -0.04836548f, 
    0.02475313f, -0.07079477f, 0.16088875f, 0.12530394f, -0.01726435f, 0.28441662f, 0.27231327f, -0.04263650f, 
    0.05499092f, 0.12788491f, 0.07029383f, 0.03643191f, 0.05137249f, -0.03137887f, 0.12904562f, -0.12656389f, 
    -0.75225157f, -0.30539989f, 0.59235460f, -0.17849201f, -0.19624770f, 0.09195804f, -0.15252741f, -0.08680702f, 
    0.10193691f, 0.12991273f, -0.01397280f, 0.02035287f, 0.06145383f, 0.01361668f, -0.12553704f, 0.25570241f, 
    -0.07917557f, 0.11726687f, -0.17693147f, -0.38313487f, 0.06167544f, 0.14261945f, -0.21335134f, -0.02011340f, 
    0.08592038f, -0.09742583f, -0.06531818f, 0.10197604f, 0.19315408f, -0.02010506f, -0.12783934f, -0.05102281f, 
    -0.05047714f, -0.14022094f, 0.04516006f, -0.02174762f, -0.38718784f, -0.22485159f, -0.36533239f, -0.01865939f, 
    -0.05036227f, -0.01333114f, 0.05995298f, -0.04771022f, -0.08478414f, 0.07499810f, -0.12585168f, -0.06807487f, 
    0.43048832f, 0.58858091f, 0.44181496f, 0.17481734f, 0.03373084f, -0.05091932f, 0.05422694f, -0.06811651f, 
    0.05561271f, 0.03907014f, 0.07022903f, 0.19470187f, 0.08133566f, -0.08491791f, 0.40808168f, 0.30478546f, 
    -0.02731019f, 0.25684786f, -0.11162203f, -0.12169501f, 0.20812185f, 0.03647747f, -0.00264490f, 0.05371761f, 
    -0.11361743f, 0.03662418f, -0.21158421f, -0.07400604f, 0.02726143f, -0.31738627f, -0.18974172f, -0.18593389f, 
    0.06957196f, 0.01570834f, 0.06303429f, 0.12636189f, 0.16458470f, 0.04475413f, 0.67733526f, 0.12909803f, 
    -0.15667802f, 0.01180704f, 0.20840457f, -0.31022906f, -0.18414113f, -0.19711179f, 0.18883954f, -0.10357004f, 
    0.26901430f, 0.07157939f, 0.10397877f, 0.02797101f, 0.19395480f, -0.09684713f, 0.09553740f, 0.04093074f, 
    -0.12529725f, -0.07416447f, 0.10151976f, -0.23372306f, -0.10822652f, -0.19174808f, -0.28107494f, -0.08734731f, 
    0.00103540f, 0.17175776f, -0.03026026f, -0.06748181f, -0.07340169f, -0.01223625f, -0.08447555f, -0.28526413f, 
    -0.32819077f, -0.14054105f, -0.12982102f, -0.04149609f, 0.00894654f, 0.05486967f, 0.18710744f, -0.13082372f, 
    0.05726149f, -0.01122333f, 0.11925815f, 0.19563964f, 0.08572432f, 0.11784745f, -0.06665172f, -0.08554443f, 
    -0.07731917f, 0.09291591f, 0.07223513f, 0.13841151f, 0.07711051f, -0.02043701f, 0.03976366f, -0.24595220f, 
    -0.29320759f, -0.32473800f, -0.03703152f, -0.06103433f, 0.02225024f, 0.01520877f, 0.07817595f, 0.04834650f, 
    0.01331189f, -0.02651327f, -0.06196547f, -0.16547289f, 0.18996076f, -0.07402483f, -0.15870258f, -0.12322809f, 
    0.25819716f, 0.20358537f, -0.04750730f, 0.04828541f, -0.08539868f, 0.00582945f, 0.01902279f, 0.04935816f, 
    0.34090710f, -0.39207628f, 0.76375109f, 0.05389884f, 0.38539732f, -0.19389822f, -0.14547259f, 0.40720636f, 
    0.12043645f, -0.06432153f, 0.02615357f, -0.12187371f, 0.01110388f, -0.00581838f, -0.07067087f, -0.52030712f, 
    -0.07096694f, 0.14989325f, 0.12110781f, -0.08892127f, -0.08146099f, -0.05659097f, -0.00385772f, 0.06492091f, 
    -0.03482346f, 0.13985522f, 0.27112648f, 0.27357167f, 0.12651183f, -0.05770748f, -0.04072586f, -0.09501592f, 
    0.01239087f, 0.08205052f, 0.01133576f, 0.13517547f, 0.64348572f, -0.10518547f, 0.16767113f, 0.06117855f, 
    0.12627159f, -0.09779499f, 0.04921339f, -0.12900206f, 0.13442118f, 0.03305324f, -0.00110157f, 0.07102556f, 
    -0.06106459f, 0.16774720f, 0.17078757f, -0.11853997f, -0.12671381f, -0.31755617f, -0.00580170f, 0.10873540f, 
    0.10505596f, -0.01457124f, -0.04525366f, 0.38352007f, 0.08391141f, -0.16587321f, 0.00877423f, 0.29820073f, 
    -0.16027085f, 0.05921501f, -0.05646767f, 0.13982821f, 0.18142693f, 0.13202886f, -0.03958932f, 0.21854603f, 
    0.33968511f, 0.26654503f, -0.11445484f, -0.34325302f, 0.01714343f, 0.07930382f, 0.12608021f, -0.11011592f, 
    -0.09743379f, -0.04769723f, 0.07746902f, -0.04428098f, 0.10065798f, 0.04144624f, -0.23313695f, -0.01024103f, 
    0.21736480f, 0.15043028f, 0.18602605f, 0.19680904f, -0.21027625f, -0.04283176f, 0.02093704f, -0.02894540f, 
    0.08946602f, -0.15844446f, 0.03968797f, -0.10757403f, -0.07626591f, -0.12030245f, -0.13061410f, 0.02004864f, 
    -0.04556356f, -0.14620812f, -0.06472694f, -0.00590517f, 0.06474172f, -0.04263035f, -0.06429387f, -0.19412491f, 
    0.35738364f, 0.16940600f, -0.03468720f, 0.02351166f, 0.06556865f, -0.00905324f, -0.11802308f, 0.02922084f, 
    -0.38583004f, -0.11553098f, -0.28622478f, -0.30134034f, 0.00123681f, 0.08040213f, -0.08640298f, -0.10262247f, 
    0.06587815f, 0.19997317f, 0.05381834f, 0.15533398f, -0.12666900f, 0.08949274f, -0.22394867f, -0.02821423f, 
    -0.03634103f, -0.16508265f, -0.28525960f, -0.24605343f, -0.06118934f, 0.07321256f, 0.01581913f, 0.07650484f, 
    -0.03346654f, 0.05631409f, -0.03234747f, -0.01570817f, -0.06653710f, 0.00226808f, -0.03066939f, -0.07809222f, 
    0.01808113f, -0.06761429f, -0.02548957f, -0.04459393f, -0.01811025f, -0.05376147f, -0.00865084f, -0.02664845f, 
    0.01278548f, 0.05035560f, -0.05307494f, -0.01152262f, -0.02616926f, -0.05115063f, -0.00179843f, -0.05975429f, 
    0.01008262f, -0.06941065f, -0.04096118f, -0.03983958f, -0.03709470f, 0.02653231f, -0.07886148f, -0.07775889f, 
    -0.06795134f, -0.03390272f, -0.05141101f, -0.05344140f, 0.05213781f, 0.01919508f, 0.00029648f, -0.06154690f, 
    -0.03335016f, 0.03714738f, -0.03190785f, 0.01205594f, -0.05463361f, -0.01065025f, -0.04262799f, -0.06639378f, 
    -0.03939452f, 0.04935078f, 0.05096338f, -0.07695402f, 0.02652631f, -0.00530748f, 0.00974345f, 0.03421407f, 
    0.04937193f, -0.01665436f, 0.04946917f, -0.01335203f, 0.01919357f, 0.04286556f, 0.03772856f, 0.05909602f, 
    0.03409822f, 0.05678816f, 0.06342987f, 0.02369092f, 0.05201934f, -0.04295731f, -0.00512500f, 0.00483616f, 
    0.04605516f, -0.01298583f, -0.02837614f, 0.05726828f, 0.02826631f, -0.00581020f, -0.07039633f, -0.07555058f, 
    -0.01329863f, -0.07647291f, -0.05944638f, -0.02000830f, 0.00648659f, -0.05442534f, 0.05651290f, -0.01921101f, 
    -0.05662730f, 0.04441332f, 0.06013259f, 0.01350290f, 0.00229026f, -0.02056869f, -0.04703742f, 0.01099078f, 
    0.04908179f, 0.04890880f, -0.02474312f, 0.03194860f, -0.07657851f, 0.01177731f, -0.01222068f, -0.05930204f, 
    0.03522446f, 0.00287208f, 0.01142490f, -0.04883686f, 0.05204486f, -0.04337577f, 0.04681062f, 0.04082475f, 
    -0.01420236f, -0.07283556f, -0.05196558f, -0.06212278f, -0.02407917f, -0.05617550f, 0.05462138f, -0.04977301f, 
    -0.06971327f, -0.02086285f, 0.03368007f, -0.01758599f, 0.05100186f, 0.06280985f, -0.03510077f, 0.03675720f, 
    -0.07627523f, 0.03061465f, 0.01625047f, -0.02205934f, 0.02427922f, -0.00265260f, 0.00646567f, -0.02406567f, 
    -0.03796843f, -0.07774294f, -0.05986787f, 0.00282429f, -0.04902398f, 0.05531949f, -0.04635677f, 0.01920644f, 
    0.01848547f, -0.01497868f, 0.05351279f, -0.02037971f, 0.05830192f, -0.07364227f, -0.05539788f, 0.03677838f, 
    -0.05822613f, -0.05326049f, -0.00008992f, -0.07189080f, 0.00687805f, 0.02455020f, -0.03219667f, 0.01055907f, 
    -0.05903529f, 0.05281542f, 0.00235308f, -0.00466898f, -0.01177909f, 0.01523670f, 0.00571490f, -0.07200588f, 
    0.04479348f, -0.00094156f, -0.02100358f, -0.03767514f, 0.03137228f, -0.02715606f, 0.04477785f, 0.05517869f, 
    0.04298575f, 0.00958942f, 0.01523895f, -0.01874533f, -0.01134249f, -0.06329697f, 0.00682084f, -0.03834473f, 
    0.03715884f, -0.05202930f, 0.01783270f, 0.05017452f, 0.00171628f, 0.01343919f, -0.04529535f, -0.07574982f, 
    -0.06965491f, -0.04845221f, -0.07455725f, -0.02189603f, 0.00029548f, -0.04246639f, 0.05506396f, 0.00805179f, 
    0.00921002f, -0.03256159f, 0.05906669f, 0.01247852f, -0.02062196f, -0.02006364f, -0.06904116f, 0.02030875f, 
    -0.06442145f, -0.02534648f, -0.00654854f, 0.05379899f, 0.02363476f, 0.02329965f, 0.06092507f, -0.05191673f, 
    0.02413383f, 0.01382038f, -0.04732408f, -0.05846098f, 0.05290275f, -0.01380795f, -0.07016456f, 0.05492970f, 
    0.05750208f, -0.04892710f, 0.00440790f, -0.06732335f, -0.06743836f, -0.06395715f, 0.02281337f, -0.06923670f, 
    -0.00867203f, 0.03665517f, -0.06075386f, -0.01925661f, -0.01023262f, -0.07249427f, 0.00446709f, 0.00982604f, 
    0.05098593f, -0.07039984f, 0.05415923f, -0.08541152f, -0.04510840f, -0.01486406f, -0.07979579f, 0.00763359f, 
    0.04233194f, 0.01663543f, 0.06677434f, 0.05300321f, 0.01609952f, 0.06928147f, -0.01467541f, -0.00933134f, 
    0.01766814f, -0.05993936f, -0.05458692f, -0.00001068f, -0.00832248f, -0.00454975f, 0.03963336f, -0.04741848f, 
    -0.06065915f, -0.03462188f, -0.02833900f, -0.00586828f, 0.05124822f, -0.04784440f, -0.07732325f, 0.02987425f, 
    0.04740385f, -0.06536908f, -0.01570991f, 0.00964366f, -0.07083648f, -0.08321311f, 0.01470324f, 0.02141982f, 
    0.04622155f, -0.04422963f, -0.06067809f, 0.01046579f, -0.00350156f, -0.04289984f, 0.04085613f, -0.02686784f, 
    -0.05249761f, 0.01694638f, 0.02434675f, -0.05944338f, -0.03046225f, -0.06966617f, 0.05713893f, -0.05094045f, 
    -0.03305732f, -0.01082884f, -0.05879468f, 0.01148796f, -0.02455776f, -0.00445799f, -0.06792018f, -0.01908137f, 
    -0.03562045f, 0.02345348f, 0.03097933f, -0.01890191f, 0.02476037f, -0.00599398f, 0.01822380f, -0.00516342f, 
    -0.00650896f, 0.02363921f, 0.03338040f, 0.04591494f, -0.06023844f, -0.04545782f, -0.00849986f, -0.07103517f, 
    -0.00126321f, -0.07275558f, 0.03407167f, 0.00568160f, -0.06683978f, 0.01272158f, -0.04854319f, -0.04227955f, 
    0.02041917f, -0.07186799f, 0.05397744f, -0.02391233f, -0.07463101f, 0.04540303f, -0.03676839f, -0.00050359f, 
    -0.07760260f, -0.02401263f, 0.02736950f, -0.00377619f, 0.02186354f, 0.00950518f, -0.05598535f, 0.05813420f, 
    -0.02431161f, 0.04342625f, -0.06219506f, 0.05647637f, -0.02992192f, 0.03062266f, -0.03981096f, 0.03763239f, 
    -0.07242901f, 0.02743156f, -0.04754540f, -0.01863559f, 0.04714623f, -0.02314160f, -0.05726088f, 0.02316402f, 
    -0.00919745f, 0.01994194f, -0.02240011f, 0.04842658f, -0.04006857f, -0.00991208f, 0.02771747f, -0.00027630f, 
    0.05955244f, -0.00871710f, -0.01234516f, -0.00489226f, 0.03777215f, 0.01690247f, 0.03439039f, -0.07431526f, 
    -0.02740534f, -0.04661211f, 0.04569863f, -0.00855418f, 0.00147436f, -0.02034386f, -0.04051718f, 0.06350798f, 
    0.03329876f, 0.11545265f, 0.07454123f, 0.19944352f, 0.06483321f, -0.12119105f, -0.04115089f, -0.12899478f, 
    0.28944173f, -0.04208318f, 0.04080446f, 0.11248911f, -0.25526127f, -0.00160370f, 0.33193484f, 0.24568997f, 
    0.11121861f, -0.10417519f, 0.07894694f, 0.14553887f, 0.17790534f, 0.09427097f, 0.03048580f, -0.41857979f, 
    -0.35512513f, -0.00558232f, -0.21837962f, 0.02525281f, 0.01834300f, -0.07773773f, 0.04692440f, -0.03670491f, 
    -0.34777170f, -0.14231135f, -0.11233958f, -0.30314994f, -0.20001495f, -0.07800561f, 0.15035951f, 0.56858218f, 
    0.20747168f, 0.03373936f, -0.05032345f, 0.15311559f, -0.03247819f, -0.05715396f, 0.04168558f, 0.08064530f, 
    0.44451508f, -0.21461855f, -0.44087338f, 0.78916728f, 0.09815565f, -0.10904054f, 0.05969752f, -0.09662802f, 
    0.10240161f, 0.12321203f, 0.04631695f, 0.11719683f, -0.08513644f, -0.32439438f, 0.63178122f, -0.19084385f, 
    -0.00487697f, -0.15748674f, 0.15774992f, 0.26068676f, 0.06049095f, 0.14321841f, 0.22413962f, -0.02378452f, 
    0.28614274f, 0.16867477f, -0.10709979f, -0.08963657f, -0.03020378f, -0.10012200f, 0.04089837f, -0.10847110f, 
    0.04342718f, 0.14408565f, 0.13791637f, 0.00171940f, 0.14389277f, -0.03554726f, 0.24048975f, -0.01605118f, 
    0.24782681f, 0.06606910f, -0.18368559f, 0.13511060f, -0.00214325f, -0.17527752f, -0.09254364f, 0.11924738f, 
    -0.07392222f, 0.14916685f, -0.03245554f, 0.27816910f, -0.10710506f, -0.13083117f, -0.07220040f, -0.20858371f, 
    0.09934713f, -0.07401758f, 0.07077390f, -0.06638308f, 0.16066171f, -0.09882122f, -0.14404808f, -0.04719658f, 
    -0.02934742f, -0.21498108f, -0.19153008f, -0.28212485f, 0.10155428f, 0.01761637f, 0.08208021f, 0.22831725f, 
    -0.11262238f, 0.10935628f, 0.18643136f, 0.12985343f, 0.01656056f, -0.01393200f, 0.05911798f, 0.20389833f, 
    0.12081510f, -0.08199324f, 0.17057896f, 0.02628099f, -0.31975985f, 0.31991029f, -0.04593362f, -0.00959854f, 
    0.18267992f, -0.10626625f, 0.05267400f, 0.15475462f, -0.06398540f, -0.06378327f, -0.03892689f, -0.17041086f, 
    0.32178396f, -0.28975481f, 0.02809958f, -0.21663404f, -0.22758542f, 0.00604790f, -0.16192761f, -0.18057936f, 
    -0.09995374f, -0.20837779f, -0.09426742f, -0.21234506f, -0.23615816f, 0.09339598f, 0.21516138f, 0.13041492f, 
    -0.06482635f, 0.01065094f, 0.17872542f, 0.16391833f, 0.03817902f, 0.10115116f, 0.04426726f, 0.04828108f, 
    0.15318529f, 0.27972865f, 0.36751875f, -0.29330334f, -0.03156533f, 0.17395739f, 0.36174017f, 0.14081544f, 
    0.08296014f, 0.18307026f, 0.12458185f, 0.03751062f, -0.09059826f, -0.02081875f, -0.08417939f, -0.18653417f, 
    0.24965295f, 0.18260899f, 0.09403156f, -0.04412302f, 0.24177177f, 0.22124854f, 0.12085914f, 0.02396717f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01864150f, -0.13467968f, 0.00094689f, 0.37576541f, 0.01197673f, 0.10925260f, 0.08752184f, -0.01973856f, 
    0.30652392f, 0.11001148f, 0.04145751f, 0.11113465f, 0.07164674f, 0.16349299f, 0.03428113f, -0.08489729f, 
    -0.02105808f, 0.01487096f, 0.09873955f, 0.01348667f, -0.05792871f, 0.12999626f, 0.11505982f, 0.16732620f, 
    0.21557973f, 0.01522299f, 0.09451181f, -0.06746144f, 0.13046202f, -0.03404450f, 0.02110750f, 0.20546773f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.45381257f, 0.08012663f, 0.11971103f, 0.27510399f, -0.18799989f, -0.05741608f, 0.03236076f, 0.09450559f, 
    0.31575793f, 0.34952521f, -0.06931007f, -0.00599086f, -0.05909579f, -0.31920430f, -0.51032358f, -0.18431868f, 
    0.16328703f, 0.25292456f, 0.15947907f, 0.02320197f, -0.13781756f, 0.04745007f, -0.14423947f, 0.09524816f, 
    0.32202870f, 0.16871633f, -0.25536993f, 0.46411315f, 0.26886886f, 0.03003227f, 0.08794026f, 0.14951062f, 
    0.01678556f, -0.21627413f, -0.01788692f, 0.25817490f, 0.00625649f, 0.41097394f, 0.02163726f, -0.04932854f, 
    0.07715971f, 0.26657784f, -0.17880265f, 0.31006795f, 0.26732016f, 0.29944444f, -0.14957674f, -0.26915896f, 
    -0.12786809f, -0.10191541f, -0.19874999f, 0.03072965f, 0.11623847f, 0.30610269f, 0.15442537f, 0.20224264f, 
    -0.18676828f, -0.47388202f, 0.08916041f, -0.62854838f, 0.30499706f, 0.14997920f, 0.06827462f, -0.02955075f, 
    0.05053708f, 0.49277076f, -0.11276203f, -0.08032980f, 0.45901421f, -0.29533634f, 0.05629472f, -0.16792764f, 
    0.04230521f, -0.30425766f, 0.00314681f, 0.04069209f, 0.22515367f, 0.24924099f, -0.09220045f, 0.29068962f, 
    -0.01647344f, 0.28648049f, 0.16981584f, -0.02380745f, 0.11397047f, 0.09530526f, -0.01454992f, 0.07700665f, 
    -0.17746274f, 0.17262009f, -0.26187503f, -0.30936250f, -0.02015279f, 0.08368225f, -0.04709422f, 0.11427713f, 
    0.46722385f, 0.20645349f, -0.07600649f, -0.26108795f, 0.10960028f, -0.10362781f, 0.26211444f, 0.12485712f, 
    0.17932805f, -0.19509624f, 0.00342959f, -0.01395487f, -0.27383572f, 0.12242012f, 0.66019785f, 0.29969165f, 
    -0.14487523f, 0.26287457f, -0.24563719f, 0.02397753f, 0.05782561f, 0.02663276f, 0.01723874f, 0.17927413f, 
    0.23191987f, 0.28886977f, 0.43821460f, 0.45896089f, -0.53037924f, -0.02381405f, -0.01171009f, 0.14172582f, 
    0.13949054f, 0.09349851f, 0.12074330f, 0.33379203f, -0.23933135f, -0.01737041f, -0.29614502f, 0.10640023f, 
    -0.06244996f, 0.25134307f, -0.09978153f, 0.12965539f, 0.31346557f, 0.29714301f, 0.51228356f, 0.15166011f, 
    0.13249516f, 0.41376376f, -0.06414673f, 0.14917384f, -0.10105836f, -0.12505151f, 0.27599263f, -0.17039573f, 
    0.05219433f, -0.53920919f, 0.39851579f, -0.18937197f, -0.54494041f, -0.08507769f, -0.04913078f, -0.01232721f, 
    0.06783855f, -0.15461180f, 0.03563833f, -0.32546988f, 0.30881009f, 0.43479055f, -0.65941799f, -0.07968783f, 
    0.03052656f, 0.32982066f, -0.14623924f, 0.47216120f, -0.30086434f, 0.13442829f, -0.29974735f, 0.60904926f, 
    0.09324364f, 0.15767105f, 0.19606546f, 0.05794216f, -0.17302765f, 0.31390598f, -0.52101463f, 0.17610957f, 
    0.14193471f, 0.43898910f, 0.03711437f, 0.04841946f, -0.20625089f, 0.11080603f, 0.05524474f, -0.16472128f, 
    -0.45260444f, -0.28892887f, -0.03572586f, 0.04525694f, -0.12256219f, -0.14951302f, 0.24736160f, -0.03100164f, 
    -0.16999103f, -0.11894467f, 0.01940780f, -0.08424336f, -0.39655459f, 0.06362250f, -0.38597414f, -0.13437420f, 
    0.15170401f, -0.20209195f, -0.19754018f, -0.09122329f, -0.09386288f, 0.08773350f, 0.02157021f, 0.14937018f, 
    -0.07111631f, 0.14093474f, -0.10550077f, 0.19905539f, 0.08722520f, 0.13918586f, -0.12123172f, 0.31037819f, 
    0.00074747f, 0.09399908f, -0.05574849f, -0.25627705f, 0.40171528f, 0.04513878f, -0.17928320f, 0.01323635f, 
    0.23573495f, 0.01079922f, 0.09187437f, -0.13220832f, -0.07567733f, 0.12729396f, -0.30702585f, -0.00145777f, 
    -0.16113499f, -0.10556827f, 0.37697843f, 0.04724465f, -0.05439058f, 0.24823017f, 0.08241606f, 0.11232594f, 
    0.41660294f, -0.00114862f, -0.22698247f, 0.20159934f, 0.31549680f, 0.13977002f, 0.15093452f, -0.32122427f, 
    0.21869084f, 0.38969427f, 0.04261686f, 0.07716657f, 0.25000450f, -0.39455095f, -0.23944232f, -0.04853067f, 
    0.15542217f, 0.14048083f, 0.11612566f, 0.01199773f, 0.43736273f, 0.15290397f, 0.01744743f, -0.05173365f, 
    -0.13389216f, 0.30907604f, 0.24178921f, 0.13628830f, 0.00598808f, 0.02456182f, -0.05512320f, -0.20175777f, 
    0.27461475f, -0.47655532f, 0.19785695f, -0.00956218f, -0.17618108f, -0.00517456f, -0.13766187f, -0.10957436f, 
    0.13860124f, 0.02229518f, 0.10786846f, 0.12443344f, -0.02628265f, 0.18173100f, 0.25015372f, -0.05345891f, 
    -0.14591971f, 0.19641639f, -0.14756823f, -0.01936674f, 0.18248302f, 0.23539169f, 0.04572980f, -0.36145952f, 
    -0.02932242f, -0.25321031f, -0.12466238f, -0.02411776f, 0.12747040f, 0.13508873f, 0.29747939f, -0.06787926f, 
    0.09098656f, -0.42527857f, -0.48927358f, -0.31229320f, 0.54390371f, -0.07490544f, -0.05616068f, 0.45080543f, 
    0.37786981f, 0.32880655f, -0.08938707f, -0.32230023f, 0.21344967f, -0.19996202f, 0.32805127f, 0.13328139f, 
    -0.01905766f, -0.23030084f, 0.01250833f, -0.22794963f, 0.11123350f, 0.22232285f, 0.46829480f, 0.33205527f, 
    -0.13297850f, 0.26013312f, 0.07937308f, 0.08259380f, -0.09932923f, -0.25596756f, 0.26929986f, -0.08713157f, 
    0.03260132f, 0.20919196f, -0.06781454f, 0.33799818f, 0.13918445f, 0.05706178f, -0.02020397f, 0.22989200f, 
    -0.30799717f, 0.24881081f, -0.04640040f, 0.21958727f, -0.01140691f, -0.09279355f, 0.02863950f, -0.13951607f, 
    0.18787318f, -0.08591477f, -0.10442936f, 0.07183316f, 0.35788339f, -0.24381787f, -0.01652493f, -0.43145981f, 
    0.13998242f, 0.28780437f, 0.15643653f, -0.08069428f, 0.15159422f, -0.03146137f, 0.10597599f, 0.17298786f, 
    0.18114756f, -0.45256752f, 0.55070680f, 0.04015860f, 0.36571229f, 0.11642256f, -0.08488750f, 0.07447557f, 
    -0.40564060f, -0.07019212f, 0.08058519f, 0.26379272f, 0.15281042f, -0.16847910f, 0.18641648f, 0.06001959f, 
    0.09219315f, -0.07784343f, -0.10429058f, 0.10971717f, 0.20953254f, -0.08107879f, -0.20305641f, -0.13772090f, 
    0.11721200f, 0.22417584f, 0.24495599f, 0.13548563f, 0.08795181f, -0.46765918f, -0.08712869f, 0.15956920f, 
    -0.06531833f, 0.38311589f, -0.13235962f, 0.23024587f, -0.31311718f, -0.11117627f, 0.09136187f, -0.01088663f, 
    -0.32578793f, -0.30420852f, 0.09629529f, 0.54096997f, -0.07625431f, 0.32385528f, 0.01916850f, -0.06425732f, 
    0.21569155f, -0.40884286f, -0.14515258f, 0.19419518f, -0.06029676f, 0.24418482f, 0.14950915f, -0.64221066f, 
    0.15396541f, 0.03259927f, 0.11740297f, 0.08601367f, -0.17252776f, 0.05926337f, -0.28534660f, 0.30776918f, 
    -0.00701201f, -0.51966858f, 0.42608741f, 0.02596890f, 0.14037952f, -0.10929569f, 0.03831585f, 0.43589449f, 
    -0.03799922f, -0.18100747f, 0.12915620f, 0.22017331f, -0.17478856f, 0.10936534f, 0.08432522f, -0.11305336f, 
    0.30120611f, 0.19392192f, -0.14902002f, 0.33293498f, -0.25429901f, 0.01509736f, 0.16674544f, 0.21278459f, 
    0.07010380f, -0.11906256f, -0.01324597f, 0.15109287f, -0.04308057f, -0.17884104f, -0.13326445f, -0.07632183f, 
    0.07617071f, 0.46614298f, 0.19229975f, 0.17562592f, -0.27714691f, -0.11659365f, 0.10405555f, 0.29074866f, 
    0.41341239f, -0.14457238f, -0.05522556f, -0.25854796f, 0.08556154f, 0.36320391f, -0.20165175f, 0.09741391f, 
    0.10600348f, 0.37069774f, -0.09006441f, -0.09656218f, 0.24640721f, 0.22850452f, 0.89434332f, 0.64572316f, 
    -0.16281909f, -0.14576255f, -0.05742755f, 0.15504238f, -0.11158359f, -0.13517380f, 0.30409479f, -0.73586750f, 
    -0.06297240f, -0.11442878f, 0.47376463f, -0.04095000f, -0.23428909f, -0.12116542f, -0.07950615f, 0.35622880f, 
    0.48458272f, -0.41690707f, -0.00357056f, -0.11917897f, -0.40520069f, 0.08320209f, 0.05420802f, -0.01644227f, 
    0.12594523f, 0.28826782f, -0.16382764f, 0.33406192f, -0.33827597f, -0.13589229f, 0.28614557f, -0.20637372f, 
    -0.11569315f, 0.13538443f, 0.00789187f, -0.08938268f, -0.07231686f, 0.42238411f, 0.27845049f, -0.06592692f, 
    0.30486313f, -0.27478498f, 0.35373232f, -0.36175197f, 0.17050019f, 0.07821225f, -0.14466907f, 0.02178744f, 
    -0.23839150f, -0.04341603f, 0.05917810f, -0.21959758f, -0.21742833f, -0.07471478f, -0.01881017f, -0.10615518f, 
    -0.04601402f, 0.09553271f, 0.12849627f, 0.00601031f, 0.01788949f, 0.27256244f, -0.08735923f, -0.11500869f, 
    0.14743595f, -0.27435136f, -0.07802828f, 0.12510999f, -0.00302728f, 0.14623673f, -0.07715557f, 0.17499028f, 
    -0.25391790f, -0.23361498f, -0.18458131f, 0.15605648f, -0.23797752f, -0.04537445f, -0.11436113f, -0.04522865f, 
    0.35448140f, 0.26504365f, 0.03751690f, 0.01417549f, -0.46836364f, -0.34873453f, 0.00496333f, -0.12532929f, 
    -0.00895959f, 0.15878159f, -0.08997586f, 0.17188680f, -0.01227366f, -0.34198886f, 0.23493662f, 0.09299383f, 
    0.15459520f, 0.10642086f, -0.12577072f, -0.00987769f, -0.07232697f, 0.28891605f, -0.07677958f, 0.15501367f, 
    -0.07368428f, -0.12627238f, 0.23876765f, -0.41773281f, 0.01948656f, 0.06917205f, -0.11717594f, 0.29286715f, 
    0.47004950f, -0.27328521f, -0.10298376f, -0.10237358f, -0.00636577f, 0.41148534f, -0.06543851f, 0.09867783f, 
    0.12706721f, 0.16711198f, 0.17055121f, 0.15086693f, -0.15492903f, 0.11911145f, 0.35480425f, 0.49069315f, 
    -0.05499539f, -0.43403870f, -0.01955411f, 0.10695879f, 0.06182179f, 0.22961666f, -0.13748319f, -0.41401380f, 
    -0.09611505f, 0.04632692f, 0.01840867f, -0.01861489f, 0.15147369f, 0.07520582f, -0.10247209f, 0.27135718f, 
    -0.50040424f, -0.34611583f, 0.11365817f, 0.34182844f, 0.21936408f, 0.43319145f, -0.24001889f, 0.12405375f, 
    0.02739273f, -0.40274113f, 0.02255688f, 0.33588091f, -0.24575780f, 0.46918043f, 0.28525463f, 0.04177051f, 
    -0.01997591f, 0.10325339f, 0.10701834f, 0.13973632f, 0.05732157f, -0.02226434f, -0.12000740f, 0.07108632f, 
    -0.16449523f, 0.03988592f, 0.52834290f, 0.15359159f, -0.04800076f, 0.04756447f, -0.00638290f, 0.22772259f, 
    0.02381843f, -0.00280730f, 0.00510234f, 0.02884461f, -0.34968069f, -0.10807109f, -0.25154039f, 0.09836360f, 
    0.15369861f, 0.38497192f, 0.13908342f, 0.21772033f, -0.06987981f, -0.04146491f, -0.24804431f, -0.17958006f, 
    0.12948126f, -0.17214818f, -0.17034116f, 0.13548781f, 0.12720114f, 0.25370502f, -0.03557526f, 0.10029747f, 
    0.09258053f, 0.21371610f, -0.17543358f, 0.14310052f, 0.07244530f, -0.14917675f, 0.15983920f, -0.09022077f, 
    0.05292930f, 0.07119080f, 0.16190122f, -0.08459361f, -0.15430851f, 0.06662831f, -0.06841729f, 0.06095543f, 
    -0.10397072f, -0.03628602f, 0.10405497f, -0.17837730f, -0.20723224f, -0.02616723f, -0.20613956f, -0.03651449f, 
    0.00036404f, -0.05905212f, -0.12640367f, 0.13643517f, 0.04568651f, 0.04490045f, -0.08076960f, -0.07695121f, 
    -0.00655400f, -0.18986356f, 0.06345174f, -0.06334443f, -0.11341969f, -0.07260147f, 0.09516474f, 0.08308140f, 
    -0.21195059f, -0.22769737f, 0.14565483f, 0.32417423f, -0.09774856f, 0.09187157f, -0.38118908f, -0.16572516f, 
    0.29040250f, 0.65024287f, -0.01243136f, -0.03904797f, -0.06206216f, 0.29342809f, -0.00209439f, 0.10590839f, 
    -0.10079243f, 0.14321324f, 0.29914457f, 0.10119931f, 0.09862811f, 0.13428006f, -0.03427180f, -0.44977036f, 
    -0.06769908f, -0.03044677f, -0.66299105f, -0.12301414f, -0.11172079f, -0.10253026f, -0.11320697f, 0.36781418f, 
    0.04848465f, 0.45991439f, -0.00393975f, 0.20809072f, 0.07320962f, -0.36048895f, 0.32394698f, -0.15092167f, 
    0.10655299f, 0.15256022f, -0.01063824f, -0.17038918f, 0.46592635f, -0.30468106f, -0.13063633f, -0.01787993f, 
    0.16581513f, 0.05958065f, 0.09620503f, 0.06681189f, -0.08615556f, -0.21927032f, 0.32625785f, 0.16350636f, 
    0.04517769f, 0.19620915f, -0.00011626f, 0.32056421f, 0.12113831f, -0.16624467f, 0.02676002f, -0.03907919f, 
    -0.12049594f, -0.04016280f, 0.00981122f, 0.26706076f, 0.31559819f, 0.48110643f, 0.06995732f, -0.11730234f, 
    0.09678064f, -0.31034419f, -0.06217710f, -0.05487254f, -0.28313565f, 0.34364274f, -0.26373827f, -0.00095481f, 
    0.06689420f, -0.30866763f, 0.03521303f, 0.08308031f, -0.02307031f, 0.30285993f, -0.08749944f, -0.11032782f, 
    0.13488127f, 0.46773627f, -0.54476219f, -0.03358082f, 0.70528567f, 0.13113104f, 0.16536549f, 0.22307101f, 
    -0.02117753f, -0.24820612f, 0.05373855f, 0.23440497f, -0.75619102f, -0.02993597f, -0.09916822f, 0.14641501f, 
    0.12867492f, 0.50837088f, -0.12271132f, 0.25566050f, -0.15866347f, 0.06497160f, -0.07961980f, 0.17431644f, 
    0.14788084f, -0.07728601f, -0.24597967f, -0.06211630f, 0.00744842f, 0.24870296f, 0.26324436f, -0.07547855f, 
    -0.06600969f, 0.66067201f, -0.07579547f, -0.78566992f, -0.11766236f, 0.01080197f, 0.15612710f, -0.15065950f, 
    0.03185912f, -0.20318389f, -0.11449909f, 0.49390540f, -0.20869391f, 0.17424908f, 0.18833058f, -0.12061482f, 
    0.09938832f, 0.22902252f, -0.13379768f, -0.26972851f, -0.07076360f, -0.30543819f, -0.09195877f, -0.59887785f, 
    0.00692511f, -0.07230631f, 0.06644506f, -0.05845901f, 0.16100524f, -0.16321097f, 0.35515687f, 0.31908706f, 
    0.22131997f, -0.00661775f, -0.25669423f, 0.26505044f, 0.31249702f, 0.16082670f, -0.13675596f, -0.03117391f, 
    -0.15633039f, 0.00799426f, 0.13222420f, 0.12408120f, -0.37229109f, 0.05065545f, 0.06994107f, -0.07252798f, 
    0.00527519f, -0.43006942f, -0.08531833f, -0.02388769f, 0.26685449f, 0.12903662f, -0.09664114f, 0.17479996f, 
    0.11021100f, -0.08285557f, -0.21487297f, -0.03609296f, -0.10158622f, 0.22091947f, 0.16665590f, 0.04680110f, 
    -0.08907339f, 0.23230153f, 0.83844417f, -1.03431582f, 0.26529685f, -0.13216060f, -0.11485060f, -0.00594861f, 
    -0.18212114f, 0.49733260f, 0.06439317f, 0.17707227f, 0.14479336f, -0.36764267f, -0.07405621f, 0.11827516f, 
    0.06096761f, -0.04006332f, -0.00204387f, 0.06926265f, 0.40693292f, 0.04154969f, -0.57316792f, 0.08837318f, 
    -0.10772599f, 0.25231162f, 0.13388509f, -0.01802767f, -0.11349731f, 0.38567162f, -0.23823284f, -0.15230744f, 
    -0.01847704f, -0.04889834f, -0.29146558f, -0.29520383f, 0.12364454f, -0.15401974f, 0.05640066f, 0.26423210f, 
    -0.18937005f, -0.13855092f, -0.01465446f, 0.02859338f, -0.02043050f, 0.43861514f, -0.04769377f, -0.04656175f, 
    -0.04620820f, 0.10341287f, -0.10502107f, 0.19467248f, 0.41875303f, 0.14285447f, -0.22814259f, -0.11229781f, 
    0.08862620f, -0.27401325f, -0.06348429f, 0.05249709f, 0.04382733f, -0.00981297f, 0.20610999f, -0.07847503f, 
    0.14325903f, -0.11849884f, 0.14789684f, -0.38124985f, 0.21929619f, 0.05646497f, 0.04670884f, -0.19492961f, 
    -0.18805310f, -0.15666258f, 0.00976325f, -0.06622104f, -0.05743852f, 0.39485508f, 0.02269782f, -0.14569560f, 
    0.15952362f, 0.16630225f, 0.15519843f, 0.36148360f, 0.12759180f, -0.24319813f, -0.17257977f, 0.12300227f, 
    -0.04935791f, -0.20080383f, -0.01603172f, 0.12074810f, -0.12578779f, 0.05119297f, -0.10291024f, -0.03382392f, 
    0.11192718f, 0.21381241f, 0.40379989f, 0.16847235f, 0.27428004f, 0.09393186f, 0.11088236f, 0.00681089f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.24141717f, 0.08752851f, -0.06606689f, 0.04044374f, 0.19541863f, 0.12238466f, 0.01350698f, 0.25131008f, 
    0.19604497f, 0.07470164f, 0.05770255f, 0.03196646f, 0.02554638f, 0.04893804f, 0.26598409f, 0.15016417f, 
    0.11399543f, -0.21702924f, 0.10721467f, 0.02507816f, 0.20590188f, -0.02413874f, -0.12129533f, 0.22722851f, 
    0.23402262f, 0.14700411f, 0.10437243f, 0.21105742f, 0.27065194f, 0.07267752f, -0.06170646f, -0.16428672f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.03739307f, -0.53717202f, 0.12173026f, -0.09379703f, -0.46708772f, 0.07624317f, -0.59504855f, 0.27939904f, 
    0.22349857f, -0.56314516f, 0.09330284f, 0.22918332f, 0.12992211f, -0.48951665f, -0.57829612f, -0.65834057f, 
    0.04966999f, -0.50052565f, -0.31957847f, -0.21224861f, -0.75406814f, -0.32840255f, -0.02900339f, -0.93606359f, 
    0.20305657f, 0.00979036f, -0.35918748f, 0.04709871f, -0.29211789f, 0.09527393f, -0.18732521f, 0.02146075f, 
    0.31236464f, -0.29882422f, -0.17655125f, -0.14109269f, -0.26841718f, -0.32274848f, -0.25213274f, -0.11206272f, 
    -0.20159818f, -0.25599945f, -0.12296157f, 0.21026099f, 0.34225589f, 0.32683712f, 0.26437986f, -1.06027746f, 
    -0.28795239f, 0.11170317f, 0.00229998f, -0.69510221f, 0.37015358f, -0.08967400f, -0.00507606f, -0.14008617f, 
    0.09055911f, 0.12513182f, 0.22217299f, 0.18146582f, 0.35671967f, -0.04806061f, -0.23202094f, 0.14022741f, 
    -0.08817068f, -0.17473964f, -0.48655665f, 0.16725430f, 0.17867011f, -0.26060015f, -0.53927481f, 0.25185597f, 
    -0.01752679f, -0.07719903f, 0.00964560f, 0.01537965f, -0.23848832f, 0.34721974f, 0.17818457f, 0.27371466f, 
    0.26569706f, -0.44928712f, -0.56542486f, 0.14483452f, 0.41474757f, -0.18646529f, 0.16426860f, -0.25161654f, 
    -0.08907416f, 0.04595670f, -0.57834965f, 0.28500995f, -0.38352734f, -1.03047359f, -0.07001477f, -0.03007807f, 
    -0.00604345f, -0.48451912f, -0.00045028f, 0.20166375f, -0.47482178f, 0.55098492f, -0.65500867f, 0.26405886f, 
    -0.05742666f, -0.46360108f, 0.08434131f, -0.21387185f, -0.02401791f, -0.47594613f, 0.20203121f, 0.13023029f, 
    -0.00873530f, -0.31496337f, -0.45364794f, 0.09359744f, 0.18780655f, -0.52512378f, 0.12349388f, -0.04074963f, 
    -0.05385774f, 0.06653352f, -0.58450216f, -0.76702833f, -0.35360238f, -0.13279434f, -0.36312646f, 0.20280665f, 
    -0.05677587f, -0.14654866f, 0.01193295f, 0.17585124f, 0.36121669f, -0.24219939f, 0.23695216f, -0.12857226f, 
    0.18683980f, -0.16554560f, 0.18676952f, 0.02056676f, 0.22952169f, -0.66720623f, -0.10388197f, 0.25937533f, 
    -0.55461997f, 0.04121291f, -0.35750490f, -0.46193743f, -0.29149678f, -0.86133778f, 0.14701936f, 0.18513018f, 
    0.16709644f, -0.30058384f, 0.08107735f, -0.00436390f, 0.02236963f, -0.19267294f, -0.15123965f, -0.29304057f, 
    0.03534695f, 0.28106377f, 0.06425136f, -0.48094466f, -0.15291266f, -0.56448948f, -0.28690970f, 0.10988121f, 
    0.04871986f, 0.29506984f, 0.02564707f, 0.11396820f, -0.08206915f, -0.03075726f, -0.37474063f, 0.07290529f, 
    -0.22195201f, 0.24445935f, -0.37484360f, -0.17828177f, -0.14143233f, -0.53016800f, -0.01840279f, 0.06146804f, 
    0.09678512f, 0.27677500f, -0.08521516f, -0.04636063f, -0.02498825f, 0.24021548f, 0.42918900f, -0.01713779f, 
    -0.25910783f, 0.37546876f, -0.66915077f, -0.19869724f, 0.43592998f, -0.01423868f, -0.07541315f, -0.27033284f, 
    -0.11205228f, -0.02996239f, -0.38330770f, 0.06347986f, -0.15194589f, -0.19434153f, 0.04747034f, 0.15378624f, 
    0.25971454f, -0.15710555f, 0.10872878f, -0.08715644f, -0.11854292f, 0.04199988f, -0.15239750f, 0.05733618f, 
    -0.03650995f, -0.84109002f, 0.25080490f, 0.02818842f, 0.13620298f, -0.35929972f, 0.36528894f, 0.28767958f, 
    -0.84728557f, 0.05705335f, 0.19954313f, 0.13872275f, -0.20405334f, -0.21298502f, -0.12416981f, -0.61086553f, 
    -0.86213559f, 0.15129612f, 0.12361953f, -0.67391628f, -0.06487288f, -0.26788497f, 0.15799323f, 0.22619231f, 
    0.06906233f, -0.22781794f, 0.09634393f, 0.37524605f, 0.15111475f, -0.15858978f, -0.10849392f, -0.24649119f, 
    -0.13749316f, 0.32287464f, 0.12236482f, -0.07723079f, 0.21232995f, -0.29324779f, -0.04329736f, 0.08165589f, 
    -0.14924984f, 0.25187844f, -0.28748083f, -0.26500821f, -0.53114951f, 0.33968225f, 0.25187749f, 0.12466913f, 
    -0.70888615f, 0.22062020f, -0.44326946f, -0.21298769f, -0.27518746f, 0.30913597f, -0.12768184f, -0.10214326f, 
    0.10262299f, -0.37295321f, 0.09882502f, 0.17592703f, 0.28023654f, -0.21039289f, -0.03472358f, 0.15444657f, 
    -0.69507569f, 0.30361030f, -0.45890790f, 0.04713489f, 0.10587825f, -0.19239587f, -0.03882013f, -0.01588632f, 
    -0.16835321f, -0.00496033f, 0.10076205f, 0.37428451f, 0.31639811f, -0.73619872f, -0.66291815f, -0.35756969f, 
    0.10648090f, 0.01818134f, 0.23283802f, 0.23537984f, -0.48150870f, 0.22703372f, -0.02808548f, 0.07381433f, 
    0.15269420f, -0.58508611f, 0.35987556f, -0.15620752f, -0.21332277f, -0.27389935f, 0.14723535f, -0.48808765f, 
    0.06842354f, -0.76050723f, -0.35234058f, -0.40497079f, -0.07195320f, 0.02639799f, -0.36768973f, -0.03968098f, 
    -0.14625080f, 0.12588303f, 0.30531260f, -0.53215665f, 0.49280101f, 0.48048839f, -0.45325202f, 0.04469724f, 
    0.11225089f, -0.46713972f, -0.53339303f, -0.18945123f, 0.19007741f, 0.05182438f, -0.08103794f, -0.32325777f, 
    -0.32741091f, -0.33129323f, -0.27513182f, -0.24889040f, 0.35991734f, -0.50432312f, -0.07314969f, 0.38393775f, 
    -0.49439356f, -0.03016752f, -0.27445436f, -0.70676112f, -0.46963954f, 0.45030597f, 0.03359853f, -0.24235585f, 
    0.34183827f, -0.13931571f, -0.40606561f, -0.08086725f, -0.27641553f, -0.01828421f, -0.54561746f, -0.05376900f, 
    -0.22897765f, 0.02288311f, -0.26325065f, -0.25665593f, -0.40806404f, -0.25075769f, 0.33527735f, -0.28023443f, 
    0.29907182f, -0.26394072f, 0.18212457f, 0.04707900f, -0.63982230f, 0.37888965f, -0.08401237f, 0.41526505f, 
    -0.00639031f, 0.06027685f, 0.30277872f, 0.30729789f, -0.75191867f, -0.00469786f, -0.42704782f, 0.03174520f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.30138037f, 0.04149012f, 0.17974027f, 0.01513086f, -0.12057693f, 0.09551550f, -0.11742412f, -0.15958408f, 
    -0.06655424f, 0.11840965f, 0.06481957f, 0.06153912f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
