#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.14707673f, -1.02238870f, -0.45742130f, 0.32414734f, 0.43412778f, 0.05578301f, 0.30362076f, 0.17914125f, 
    0.21956703f, 0.02684199f, 0.29241040f, 0.15745391f, -0.12959209f, -0.06831654f, -0.07531898f, -0.13970278f, 
    -0.26289058f, -0.20351040f, 0.01818075f, -0.12328368f, -0.29439604f, 0.00018720f, -0.10088468f, -0.31386298f, 
    -0.28480285f, -0.51953155f, -0.14274712f, -0.01986787f, 0.05484053f, 0.03457535f, -0.67121696f, -0.29254687f, 
    0.23851037f, 0.07069750f, 0.00247173f, -0.21420909f, -0.62520015f, -0.20408498f, 0.44774416f, -0.28719282f, 
    -0.13053162f, -0.37834817f, -0.01908985f, -0.11132037f, -0.40714061f, -0.03929527f, -0.31227744f, 0.03020141f, 
    -0.26903811f, 0.05048314f, 0.61404949f, -0.74406463f, -0.91275221f, -0.66750365f, 0.06010423f, 0.23766571f, 
    0.32327828f, 0.37437716f, 0.49840516f, 0.03080822f, 0.15265825f, 0.12769997f, 0.01241063f, -0.07089394f, 
    -0.05518805f, -0.24841109f, 0.12021097f, 0.14897186f, -0.02898588f, -0.30143803f, 0.20733291f, -0.08435061f, 
    -0.06599029f, -0.04446277f, 0.31069964f, 0.60681427f, -0.21592930f, -0.50118327f, 0.14215368f, 0.35034773f, 
    -0.36861163f, -0.21490669f, 0.05496936f, 0.05435891f, 0.28365761f, -0.01493680f, 0.19336779f, -0.05642786f, 
    -0.11666265f, 0.09992197f, 0.05804386f, 0.08350468f, 0.27609795f, -0.22624339f, -0.40475518f, -0.07813058f, 
    0.02351266f, 0.24401826f, 0.44938397f, 0.07025122f, 0.22043291f, 0.84683770f, 0.46475062f, -0.72606659f, 
    -0.26139608f, 0.04035577f, 0.03202714f, -0.01034986f, -0.11873945f, -0.16139522f, -0.02735360f, -0.30282414f, 
    -0.09599346f, 0.35840604f, -0.37079427f, 0.13727452f, 0.04668083f, -0.33490217f, 0.12667079f, 0.09317857f, 
    0.18127757f, 0.08351984f, -0.20276533f, -0.08884629f, 0.27575588f, 0.50519240f, -0.30612582f, -0.57171726f, 
    -0.46736696f, -0.11714222f, 0.60689944f, -0.27292129f, -0.03209319f, 0.42034027f, -0.37114316f, -0.17618667f, 
    -0.24723434f, -0.46964860f, 0.17966498f, -0.25986362f, -0.27469078f, 0.15446077f, 0.14844464f, 0.28659064f, 
    0.01826100f, 0.31525525f, 0.05323345f, -0.07637394f, -0.28937384f, 0.11713462f, -0.41580892f, -0.59057921f, 
    -0.49135330f, -0.48120025f, -0.39635465f, -0.21021676f, -0.47208488f, -0.46161786f, -0.28520572f, -0.59274215f, 
    0.00478941f, 0.26431391f, 0.06294511f, 0.27908456f, -0.11661944f, 0.02635875f, -0.12460035f, 0.00213361f, 
    0.06019963f, -0.14892143f, -0.23528729f, 0.41785496f, 0.29817811f, 0.01863178f, 0.11370798f, 0.95596784f, 
    0.34722728f, -0.06620737f, -0.11151600f, 0.06707612f, -0.12872934f, 0.15742153f, 0.03556968f, -0.49892852f, 
    -0.43813917f, -0.03696811f, 0.03456581f, -0.13319366f, -0.20309801f, 0.02758474f, -0.05159792f, 0.08210834f, 
    0.26532975f, -0.08135507f, 0.01226947f, -0.13079078f, -0.14080042f, -0.24441667f, 0.24100670f, -0.16312242f, 
    -0.17842640f, 0.82916307f, 0.13209586f, -0.56739545f, -0.05992461f, -0.46431330f, -0.31969190f, -0.15298030f, 
    -0.31300348f, -0.59396249f, 0.27427766f, 0.58992964f, -0.41701642f, 0.37168297f, -0.40776506f, -0.09243345f, 
    -0.26844287f, -0.04458531f, -0.26689559f, -0.21176393f, -0.10867706f, -0.02164621f, -0.11751712f, 0.02516251f, 
    -0.33464962f, 0.45114484f, 0.37168840f, 0.32324997f, 0.10625463f, 0.13806179f, -0.31554386f, 0.07729627f, 
    0.14164862f, 0.29653290f, -0.01158047f, 0.10541112f, 0.25361681f, -0.13455591f, -0.23217133f, -0.20879629f, 
    0.18169762f, 0.19238403f, -0.16769849f, -0.15715715f, -0.02194967f, 0.05593805f, 0.28553402f, -0.13337938f, 
    -0.26542363f, -0.32083100f, 0.70273745f, -0.32080477f, 0.03221588f, -0.03393577f, 0.15374216f, -0.36932796f, 
    -0.28054160f, 0.39952347f, 0.42144179f, -0.44728470f, -0.37354141f, -0.42781365f, 0.41272947f, -0.04577101f, 
    0.47743115f, -0.09858810f, 0.19244619f, -0.10412951f, -0.07978006f, 0.01486787f, 0.07355556f, -0.18864794f, 
    0.13783550f, -0.02149232f, -0.03497586f, 0.56816059f, 0.12151239f, -0.06535538f, -0.02958615f, -0.24366051f, 
    0.31640780f, 0.23501191f, -0.14309862f, -0.01808842f, 0.23330109f, 0.24539104f, -0.48558494f, 0.07816243f, 
    -0.05698401f, 0.01731338f, -0.00660097f, -0.33793217f, 0.14615026f, -0.00606452f, 0.01834733f, -0.37632662f, 
    0.22479887f, 0.13397107f, -0.28565571f, 0.13780205f, -0.33954525f, -0.19548133f, -0.39149982f, -1.00745726f, 
    -0.87758893f, 0.21060699f, 0.35686561f, 0.22959296f, 0.22832108f, 0.29783764f, -0.11056244f, -0.14678892f, 
    -0.13066477f, -0.06965874f, 0.32550669f, 0.10578828f, 0.03709075f, -0.19789386f, -0.13571556f, -0.34470868f, 
    -0.08034382f, -0.41919479f, 0.20493557f, -0.18710943f, -0.24018310f, 0.44194648f, 0.85512453f, -0.45158431f, 
    -0.30180258f, 0.34632087f, 0.44055057f, -0.42481446f, -0.39463392f, -0.35157198f, -0.69062209f, 0.17260236f, 
    -0.04754268f, 0.13851644f, 0.04789146f, 0.12967017f, 0.22935770f, -0.02884229f, 0.18741186f, -0.17136678f, 
    -0.11329453f, -0.23703024f, 0.09981399f, 0.03963365f, 0.04822473f, -0.01570879f, -0.87183547f, -0.51341844f, 
    -0.31720316f, 0.26748049f, 1.05106509f, 0.33432099f, -0.26254976f, -0.78306150f, -0.31256765f, 0.49515972f, 
    -0.37755549f, -0.04276535f, -0.38250476f, -0.14859268f, -0.10467768f, 0.28452891f, 0.06718721f, 0.09615748f, 
    0.26505804f, 0.14208497f, 0.15896662f, -0.13347314f, 0.05895710f, -0.12995028f, -0.12123368f, 0.17312206f, 
    0.27577946f, -0.32651606f, -0.09016845f, -0.54036838f, 0.10895994f, 0.02101253f, 0.07626510f, -0.05221788f, 
    -0.06096592f, 0.11717194f, 0.01624428f, -0.21931985f, 0.05093896f, 0.15242861f, -0.11155118f, -0.28563079f, 
    -0.05866580f, -0.09442180f, 0.19994904f, 0.27728641f, 0.18919644f, 0.05524960f, 0.23045087f, 0.46215826f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01659940f, -0.14172773f, 0.17098491f, 0.25075641f, 0.17226756f, 0.22010039f, -0.10700096f, 0.05359811f, 
    -0.13783038f, -0.15423940f, 0.11407796f, 0.19408430f, 0.01637373f, -0.00915748f, 0.26937759f, 0.17926186f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16472244f, 0.18725903f, -0.10237484f, 0.00323627f, -0.02684003f, 0.00944352f, -0.09455957f, -0.11430754f, 
    -0.04576185f, -0.14452043f, 0.03815344f, -0.05837753f, 0.00208917f, -0.12813067f, 0.07925955f, -0.00390195f, 
    0.23207074f, 0.09179225f, 0.12667979f, 0.05034646f, 0.22977369f, 0.33307025f, 0.20033789f, 0.06054543f, 
    0.05747943f, -0.05588987f, -0.10293464f, 0.06025386f, -0.02411257f, 0.05367037f, 0.09757043f, 0.10827302f, 
    0.00422489f, 0.08275233f, 0.12343994f, -0.00079087f, 0.15682130f, 0.01677101f, -0.06140693f, 0.07207229f, 
    0.11956610f, 0.07218000f, -0.12713976f, 0.05602368f, -0.08141083f, 0.08528642f, -0.07723742f, 0.06792080f, 
    -0.02804763f, -0.11068745f, 0.23248430f, -0.04549104f, 0.04724181f, -0.04518536f, 0.02810841f, -0.06583830f, 
    -0.06011105f, -0.07737176f, 0.18417090f, -0.03544660f, 0.20022993f, 0.03283049f, -0.03277568f, 0.12775809f, 
    0.21028411f, 0.08314890f, 0.19511780f, -0.02833061f, -0.03379641f, -0.08023902f, 0.01699749f, -0.06190456f, 
    -0.24061905f, -0.07150732f, -0.14667207f, 0.08206299f, -0.06097738f, 0.08197615f, 0.01642177f, -0.05601815f, 
    -0.06731862f, 0.03777913f, -0.07405650f, 0.03627380f, 0.25854981f, -0.11132789f, 0.15223858f, 0.06167590f, 
    -0.09519736f, -0.02622361f, 0.02875431f, -0.11275689f, -0.06015351f, -0.02889509f, -0.12361485f, 0.01691482f, 
    0.07006335f, -0.48907799f, 0.21057369f, -0.27398258f, -0.05945173f, 0.02048733f, -0.09700598f, 0.14426480f, 
    -0.06965356f, 0.18055359f, -0.06727823f, 0.21120714f, 0.02682520f, 0.06465728f, 0.06365702f, 0.03571180f, 
    -0.06949243f, -0.03539839f, -0.04190231f, -0.14456992f, -0.28293753f, -0.03317810f, -0.08983574f, -0.02871565f, 
    0.26560894f, 0.00815967f, 0.06046089f, 0.03471513f, 0.08324628f, -0.01222879f, -0.00994984f, -0.05801345f, 
    -0.06072066f, -0.02617166f, 0.02604901f, 0.04159782f, 0.10302775f, 0.12115439f, -0.01604064f, -0.02327788f, 
    -0.10059129f, 0.01919899f, -0.00394620f, -0.04860247f, -0.06896459f, 0.07590722f, 0.14861310f, 0.03510571f, 
    -0.06050963f, -0.03259392f, -0.13663658f, -0.28095430f, 0.07958223f, 0.13756566f, 0.00883507f, 0.13505016f, 
    0.06009221f, 0.01851727f, 0.16049598f, -0.13471332f, -0.05662926f, -0.16533427f, -0.04165566f, -0.07978422f, 
    0.02733047f, -0.23392868f, -0.10276940f, -0.13273878f, -0.12367672f, 0.01154525f, -0.16937532f, 0.08317380f, 
    -0.14555711f, 0.29022402f, -0.31327194f, -0.05039310f, 0.18534209f, 0.02429578f, 0.26411512f, -0.00018717f, 
    -0.03134879f, 0.05222553f, 0.11533147f, 0.01071752f, -0.09467288f, -0.09579731f, -0.04131255f, -0.00026284f, 
    0.18158370f, 0.11047274f, 0.07706723f, 0.00855020f, -0.11518995f, -0.01444678f, -0.05511780f, -0.14587408f, 
    0.17171229f, 0.06356282f, 0.35234269f, -0.01122572f, -0.05082310f, -0.12667260f, -0.18822780f, -0.29337433f, 
    -0.17558131f, -0.10111821f, -0.07583788f, -0.07178453f, -0.08006858f, 0.07531831f, -0.01769749f, 0.22894965f, 
    0.16208176f, -0.04423169f, 0.09379673f, -0.07137819f, 0.10643892f, 0.07167881f, -0.04541410f, -0.29935020f, 
    0.40747011f, -0.03353977f, 0.15112838f, -0.13595000f, -0.03203429f, -0.17618701f, -0.10818449f, -0.17146868f, 
    0.09236648f, 0.04236336f, 0.03651894f, 0.15891030f, 0.03882723f, 0.05352547f, 0.14274566f, -0.01493483f, 
    0.14536992f, -0.07318578f, -0.06148032f, -0.12602381f, 0.08680013f, 0.05664247f, 0.16521247f, 0.20430201f, 
    0.04538188f, 0.31866008f, -0.09928716f, 0.16195974f, -0.16792241f, -0.24129783f, 0.29443553f, 0.09357435f, 
    0.11342572f, 0.11058854f, -0.08124932f, 0.12796323f, 0.16970539f, 0.17310961f, -0.04716636f, -0.04420654f, 
    0.13226934f, 0.03847038f, 0.21163377f, 0.11186039f, -0.12804389f, -0.02316073f, 0.14824541f, -0.05726636f, 
    -0.19822949f, 0.10674898f, 0.04225487f, 0.13882138f, 0.20020238f, 0.11174718f, 0.29407248f, 0.26192898f, 
    -0.18332577f, -0.14587377f, -0.13587393f, -0.09283359f, 0.15303500f, -0.30612347f, 0.11791117f, 0.06983808f, 
    -0.07862828f, -0.09528164f, -0.02368772f, 0.02558133f, 0.03591385f, -0.01547542f, -0.13124867f, -0.04037645f, 
    -0.18164800f, -0.00005800f, 0.04951609f, 0.05272064f, 0.07177141f, -0.03453542f, 0.15731475f, 0.08482563f, 
    -0.14061536f, 0.08680685f, -0.13060442f, -0.16062886f, 0.04138224f, 0.14917301f, -0.03968326f, 0.10702091f, 
    -0.10123431f, -0.11332124f, -0.03297713f, -0.18972892f, -0.03210991f, 0.09731331f, -0.12246667f, -0.10517474f, 
    -0.09634078f, 0.17696084f, -0.12527272f, 0.18292277f, 0.12430125f, -0.13918975f, -0.03691743f, -0.27414379f, 
    0.00642589f, 0.01297458f, 0.08833572f, 0.03802393f, 0.33403525f, 0.11735228f, 0.06333121f, -0.05465274f, 
    -0.11507168f, -0.00963542f, -0.06007239f, -0.19594145f, 0.13324122f, 0.22103818f, 0.03199114f, -0.00564331f, 
    0.11274786f, -0.10344664f, -0.02820206f, -0.31180817f, 0.07101382f, -0.08396609f, -0.08297338f, -0.00995034f, 
    -0.04535750f, 0.10889987f, 0.03826826f, -0.14059094f, -0.13634139f, -0.26082915f, -0.15139157f, -0.21222167f, 
    -0.02364179f, -0.02798232f, 0.06990422f, -0.13148607f, 0.12616076f, 0.01303157f, -0.04356637f, -0.24510828f, 
    -0.26762298f, -0.12431554f, 0.10048432f, -0.21771571f, 0.14187834f, 0.11578123f, 0.16092734f, 0.09910665f, 
    0.03908890f, -0.06173420f, -0.05738094f, -0.12584887f, 0.03217458f, -0.06630059f, -0.03737009f, -0.07752533f, 
    0.04328988f, 0.13561159f, 0.01159633f, -0.08948411f, 0.20376781f, 0.01290966f, 0.08416779f, -0.01609890f, 
    -0.10773636f, 0.12060112f, 0.08855256f, 0.04614750f, -0.02894029f, 0.03603562f, -0.03237928f, -0.06722320f, 
    0.09212081f, 0.10278260f, 0.07786229f, 0.01541908f, -0.15107590f, -0.21280247f, -0.27358043f, -0.35979861f, 
    -0.10711035f, -0.04183507f, 0.00376547f, -0.03500616f, -0.09426533f, -0.16294423f, 0.17559347f, -0.01871547f, 
    -0.02653534f, 0.51045835f, 0.03499417f, 0.21162415f, 0.13306800f, 0.07081377f, 0.10358998f, 0.04562793f, 
    -0.04979552f, 0.11807425f, -0.13466141f, 0.01284787f, -0.07017500f, -0.11416568f, -0.05095350f, -0.00141515f, 
    0.13984035f, -0.22087003f, 0.07016585f, 0.02112206f, -0.00091795f, 0.20934072f, -0.02349771f, -0.09922661f, 
    0.01564321f, -0.11508980f, 0.05886134f, -0.32360372f, -0.01112760f, 0.09070178f, -0.05027189f, -0.00649079f, 
    0.04847206f, -0.06992935f, 0.02984053f, -0.18722886f, 0.04686561f, 0.12351403f, 0.26532564f, 0.05415051f, 
    -0.02929431f, 0.15721081f, -0.09813028f, -0.00272024f, 0.05063804f, -0.07302371f, -0.00283590f, 0.06570700f, 
    -0.16851975f, -0.21874940f, -0.08923054f, 0.10709434f, -0.09474889f, -0.08831426f, -0.29361290f, -0.18576232f, 
    -0.10299012f, -0.06931987f, -0.00044631f, -0.04548335f, -0.11710346f, -0.08531366f, 0.15008898f, 0.10022324f, 
    -0.02035770f, -0.11318664f, 0.12401838f, -0.08955101f, 0.02494990f, 0.15517412f, -0.06151019f, 0.04631055f, 
    -0.02370998f, -0.39407337f, -0.02285188f, -0.26486400f, 0.08865912f, 0.03939775f, -0.04417210f, 0.16201892f, 
    0.14131911f, 0.06394170f, 0.18286301f, 0.04063409f, -0.09821653f, -0.03577046f, -0.01543647f, -0.17214374f, 
    -0.13760608f, 0.00454255f, 0.01918758f, -0.06829241f, 0.02148555f, 0.01775254f, -0.08248985f, 0.00608807f, 
    0.07208818f, -0.03023246f, -0.15087149f, -0.18829289f, 0.05743739f, -0.05473129f, 0.12212105f, -0.05164645f, 
    0.19018996f, -0.11064412f, -0.11494149f, 0.01191150f, -0.35078087f, 0.15341136f, 0.07682523f, -0.09604821f, 
    0.04631927f, 0.00015123f, -0.06885751f, 0.02708953f, 0.00359762f, -0.04261979f, 0.10327008f, -0.23273690f, 
    0.18883756f, 0.13705647f, 0.34729797f, 0.36556226f, -0.07561579f, 0.09202242f, 0.10145942f, 0.08641347f, 
    -0.10819771f, 0.11161931f, 0.13194877f, 0.17224219f, -0.08343670f, -0.23625205f, 0.14412980f, 0.08731105f, 
    0.01913143f, -0.15005629f, -0.14191061f, 0.16475666f, -0.04787782f, 0.18544269f, 0.00290015f, -0.10040037f, 
    0.17956205f, -0.16085690f, -0.05793761f, 0.23045848f, 0.01253658f, -0.07687552f, -0.09387668f, -0.07230014f, 
    0.00135251f, -0.06212727f, -0.08284759f, 0.10360210f, -0.00263605f, 0.00241776f, 0.02437633f, 0.04481065f, 
    0.13896199f, -0.00133867f, -0.04961580f, 0.17560340f, -0.02969515f, -0.05130396f, -0.05444150f, -0.05347281f, 
    -0.03407283f, -0.04373630f, 0.03951120f, -0.06943291f, -0.04456746f, -0.05600746f, 0.02507495f, -0.03950771f, 
    -0.01335268f, -0.03402332f, 0.04713345f, -0.01082825f, 0.06019560f, -0.03215323f, -0.01210794f, -0.04104557f, 
    -0.01894494f, -0.05772858f, 0.00604171f, -0.02975055f, -0.05673870f, -0.00444888f, -0.04385020f, -0.07330363f, 
    0.00975228f, 0.01684424f, -0.00784961f, 0.05357024f, 0.04415739f, 0.03073280f, 0.04152057f, -0.05300059f, 
    0.02197096f, 0.01510426f, 0.05641693f, 0.00579381f, 0.02851973f, -0.07684551f, 0.05201573f, -0.06947533f, 
    -0.00658037f, 0.03579865f, -0.03463063f, -0.07001730f, -0.07627705f, 0.01905192f, -0.07142279f, -0.05962260f, 
    -0.08585726f, -0.05682410f, -0.02169424f, -0.00784467f, -0.03522005f, 0.01578830f, -0.03814913f, -0.04506687f, 
    -0.08676707f, -0.04158532f, -0.06890152f, 0.02362495f, 0.00893039f, 0.00402490f, -0.05376568f, -0.02172383f, 
    0.03279120f, 0.03983290f, 0.03324299f, -0.00278073f, -0.07639041f, -0.06762496f, -0.01364482f, -0.05691106f, 
    0.04014964f, 0.02484417f, -0.00476142f, 0.00858008f, 0.06118038f, -0.07921112f, -0.08526745f, 0.03689360f, 
    -0.02344661f, -0.02010147f, 0.03719543f, 0.00106294f, 0.02801266f, 0.04695908f, -0.04072722f, -0.06998181f, 
    -0.05026180f, -0.07954442f, 0.02544135f, -0.07573134f, 0.03520153f, 0.01112022f, -0.06572642f, -0.06388288f, 
    0.02758515f, 0.02404855f, -0.06756923f, 0.00413570f, 0.02194552f, -0.03389961f, -0.04960746f, -0.07484952f, 
    0.01667210f, 0.03934314f, 0.05034483f, 0.02218692f, 0.03386698f, -0.06729510f, 0.01093453f, -0.04520021f, 
    -0.05523514f, -0.04826584f, -0.07244901f, -0.04991139f, -0.07998138f, 0.06059074f, 0.05365430f, 0.00794158f, 
    0.00966221f, 0.01709819f, 0.01983444f, 0.01098936f, -0.00730756f, -0.08366164f, -0.05622823f, -0.01557451f, 
    0.04965680f, 0.05667270f, -0.04792206f, -0.03784966f, 0.04770312f, -0.03694548f, 0.04426502f, 0.05550096f, 
    0.00447529f, -0.05251725f, 0.01384525f, 0.00935931f, -0.07065517f, -0.01187216f, -0.05346503f, -0.05328600f, 
    0.01916481f, -0.01463499f, -0.05519319f, -0.00074819f, -0.01585352f, -0.00816828f, -0.09709376f, -0.04227835f, 
    -0.02273242f, 0.04341055f, -0.00377109f, -0.04773019f, -0.03941489f, 0.04243135f, -0.03468133f, 0.01009165f, 
    0.00534624f, 0.05797111f, -0.04740230f, 0.06561744f, -0.00300220f, -0.00192821f, 0.02118189f, -0.06123429f, 
    -0.05028968f, -0.07776835f, -0.02788146f, 0.04527628f, 0.03848135f, -0.02319126f, -0.07956453f, 0.03679992f, 
    -0.09401491f, 0.02877967f, -0.01045525f, 0.01159889f, -0.00599288f, -0.01415768f, -0.06371187f, -0.03937653f, 
    0.02306483f, 0.06288978f, 0.06360713f, -0.04393042f, -0.04426847f, 0.00367918f, -0.07050864f, -0.07316738f, 
    -0.06335202f, -0.10441448f, -0.14091681f, -0.05367715f, -0.00535320f, -0.03522844f, -0.05432631f, -0.01982441f, 
    0.11547692f, -0.06251040f, -0.03522325f, 0.23409140f, 0.01799034f, 0.23247585f, 0.19226348f, 0.12635691f, 
    -0.07278536f, -0.06429093f, 0.08459056f, 0.04481741f, 0.01032489f, 0.03141394f, -0.06364466f, 0.11541063f, 
    0.08680979f, -0.18992981f, -0.14301191f, -0.15497789f, -0.18997514f, -0.00675485f, -0.06859419f, 0.04566023f, 
    0.18939918f, -0.13400404f, 0.15259188f, -0.17968583f, 0.10574128f, 0.09290395f, -0.09470063f, -0.02842611f, 
    -0.17686729f, 0.21047634f, -0.09606016f, 0.05703278f, -0.08650979f, -0.17793135f, -0.04433631f, -0.05079873f, 
    0.27959824f, -0.10241855f, -0.29834709f, 0.20080765f, 0.04331246f, 0.00759823f, -0.01848751f, -0.09706976f, 
    -0.03777542f, 0.07902934f, -0.10831843f, 0.07303438f, 0.09209964f, 0.16858484f, 0.00886069f, -0.19165179f, 
    -0.07692299f, 0.08482946f, -0.07283332f, 0.00843558f, 0.03580699f, -0.01254799f, 0.02652081f, 0.02786968f, 
    0.35013792f, 0.35535729f, 0.35015604f, 0.13139665f, 0.07613949f, 0.12878628f, 0.08656419f, -0.01001820f, 
    0.11152845f, 0.00802090f, 0.04104071f, 0.02225084f, 0.22493957f, 0.11159296f, -0.38801977f, -0.18622762f, 
    -0.04009513f, -0.04386030f, -0.24847353f, -0.07334132f, 0.00551300f, 0.04931752f, 0.11054774f, 0.02074267f, 
    0.13316491f, 0.21406320f, 0.17983004f, 0.46213683f, -0.08594996f, -0.01391586f, 0.09765630f, -0.27855745f, 
    -0.10569553f, -0.10421481f, 0.15487938f, -0.08626208f, 0.17098691f, -0.20454752f, -0.07685967f, -0.04881105f, 
    -0.07695557f, -0.23186687f, -0.06319105f, -0.08869564f, 0.10229471f, 0.04621460f, 0.15055504f, 0.03512665f, 
    -0.05620459f, -0.10384525f, 0.16451761f, 0.13543347f, -0.15142924f, 0.08062446f, -0.16509573f, 0.03740477f, 
    -0.00063425f, 0.01231242f, 0.04314284f, 0.10275507f, 0.13124117f, -0.17159225f, -0.29191750f, 0.02419355f, 
    0.04196726f, -0.04323692f, -0.04542535f, 0.06188527f, -0.03212745f, 0.03115766f, -0.10840816f, 0.08305255f, 
    -0.06256428f, 0.06747712f, -0.09085921f, -0.05875171f, 0.04733008f, -0.07908643f, -0.03117275f, 0.08114517f, 
    0.20039840f, -0.23743011f, -0.11115504f, 0.02066590f, 0.14458025f, 0.28885970f, -0.44772226f, -0.00687697f, 
    0.07984521f, 0.06600296f, 0.25843528f, 0.01100346f, -0.04619573f, -0.10641322f, 0.19988264f, 0.06944486f, 
    -0.26777196f, -0.01609758f, 0.24816205f, 0.03703612f, 0.02791335f, 0.11285318f, -0.15978952f, 0.07369822f, 
    -0.01581206f, -0.04446848f, -0.03102749f, -0.10309415f, 0.09265771f, 0.03146392f, -0.01614578f, -0.00688466f, 
    -0.01245929f, 0.03665284f, 0.08702828f, -0.09210566f, 0.05665876f, -0.01805458f, 0.04526199f, -0.03699011f, 
    -0.04767646f, 0.04034756f, -0.05444586f, -0.04841252f, -0.01347082f, 0.02936130f, -0.00427896f, 0.00421986f, 
    -0.04844587f, 0.03657403f, 0.00917780f, -0.04343808f, 0.02093469f, 0.02867600f, -0.05100339f, -0.06696770f, 
    -0.04350657f, -0.06238970f, 0.01390955f, 0.01318855f, -0.06301372f, 0.02512556f, -0.05613374f, 0.00602995f, 
    0.04454226f, -0.00051809f, 0.03213649f, -0.06512202f, -0.01815022f, 0.03018441f, -0.06065755f, -0.01314381f, 
    -0.07000453f, -0.06791463f, -0.04785839f, -0.01531658f, 0.03298678f, -0.00961514f, 0.03837687f, -0.00372302f, 
    0.00383786f, -0.04565666f, 0.01465175f, -0.00175565f, -0.00031867f, 0.01784477f, 0.02929595f, 0.04824097f, 
    -0.00711464f, -0.07887478f, -0.07044854f, 0.05638532f, 0.01293443f, -0.04986549f, -0.01439069f, -0.05105832f, 
    0.04391200f, -0.04028226f, 0.01244091f, 0.00117808f, -0.04154725f, 0.06428072f, -0.03028927f, -0.01334414f, 
    -0.01684045f, -0.05219876f, -0.04436205f, -0.07231664f, 0.04228533f, -0.02736538f, -0.05642180f, 0.00602876f, 
    -0.03623613f, -0.03925054f, -0.06934069f, 0.03656531f, 0.02592201f, -0.00645997f, 0.03691794f, 0.05137181f, 
    -0.06028872f, -0.06683321f, 0.04500144f, 0.02433643f, 0.02366637f, -0.04026257f, -0.05442010f, 0.05132459f, 
    0.04226660f, -0.07326825f, 0.00617100f, 0.03493096f, -0.04395248f, -0.00324664f, 0.02632280f, -0.08388349f, 
    -0.00910120f, -0.01475006f, -0.00857506f, -0.03642813f, -0.00855680f, 0.00882485f, -0.02979997f, -0.04863286f, 
    -0.05263186f, -0.04795052f, -0.03558345f, 0.01026496f, -0.00023837f, 0.02555280f, -0.07215648f, -0.05756883f, 
    0.01535181f, 0.00835915f, 0.00842673f, -0.04321027f, -0.01413236f, -0.00979850f, -0.02228089f, 0.04919065f, 
    -0.05474314f, -0.07261907f, -0.05906356f, 0.01911548f, -0.06391811f, 0.03537772f, -0.05119746f, 0.02491933f, 
    0.04564874f, 0.03998855f, -0.07865247f, 0.02000954f, 0.05735797f, -0.01135175f, 0.01551042f, -0.04398476f, 
    0.00152861f, -0.01867974f, 0.05335744f, -0.05703120f, -0.01226150f, -0.01385749f, 0.04158080f, 0.03622477f, 
    -0.02362533f, -0.08085766f, -0.02945778f, -0.03504671f, 0.02639436f, 0.00761824f, -0.00984115f, -0.07922757f, 
    -0.05803366f, -0.04176147f, -0.04957470f, 0.03834849f, 0.00391262f, -0.01287569f, -0.02414266f, 0.00065489f, 
    0.00370446f, 0.01049998f, -0.07192924f, 0.02811155f, 0.04981458f, 0.03783299f, 0.01593141f, 0.01384398f, 
    0.03070991f, -0.05473096f, 0.05376422f, 0.02309978f, 0.04562765f, -0.02669986f, -0.07124895f, 0.05589844f, 
    -0.00917074f, 0.04135783f, -0.06062756f, -0.02144833f, 0.03866452f, 0.05082944f, -0.03496906f, 0.04201214f, 
    -0.07470366f, 0.02132790f, -0.02273024f, -0.05609023f, -0.01418903f, -0.03332370f, 0.04891441f, -0.03783034f, 
    -0.00541897f, -0.02925690f, 0.07207386f, 0.22127227f, 0.09336931f, 0.05319605f, -0.09167985f, 0.07896777f, 
    0.06951396f, 0.18829265f, 0.14596179f, 0.25047916f, -0.00687103f, -0.07146622f, 0.06203479f, -0.03002503f, 
    0.00521961f, -0.04395116f, 0.13057117f, 0.01933738f, -0.01946218f, -0.08494981f, 0.01379704f, 0.07380015f, 
    -0.12139297f, 0.01014251f, 0.20687541f, -0.00983296f, -0.03102601f, 0.01302896f, -0.17505227f, 0.15384831f, 
    -0.13572155f, -0.02625142f, -0.06586500f, -0.05809321f, 0.08361872f, -0.04358305f, -0.14538521f, 0.04148594f, 
    -0.03280764f, 0.06384758f, -0.03134521f, 0.21467324f, -0.13362965f, -0.11880262f, -0.09064621f, -0.25320753f, 
    0.11402113f, -0.16362427f, -0.01387297f, -0.03190021f, 0.02281763f, -0.04565537f, -0.02342135f, -0.00474498f, 
    -0.04094673f, -0.01255982f, -0.17280276f, -0.06188098f, -0.12268531f, -0.05345978f, -0.07593532f, 0.01036668f, 
    -0.05774753f, -0.06742681f, -0.16126452f, -0.09131517f, -0.00483605f, -0.00108911f, -0.09993608f, 0.00995674f, 
    0.29831401f, 0.11495609f, 0.16966577f, -0.14483216f, -0.04495239f, -0.23026779f, -0.12615439f, -0.08204770f, 
    0.13088608f, 0.00005121f, -0.05564577f, -0.09822660f, 0.05375213f, 0.09557334f, -0.08980425f, -0.16116877f, 
    0.06718018f, 0.16267589f, 0.01611098f, 0.13134669f, -0.06288519f, -0.04744288f, 0.04771426f, -0.11782750f, 
    0.15540116f, 0.07031839f, 0.06478895f, 0.04054801f, 0.07411950f, 0.05598069f, 0.01810495f, -0.04845700f, 
    0.06982818f, -0.08724068f, 0.10792279f, -0.04949366f, 0.00780603f, -0.02060711f, -0.09794333f, -0.03806583f, 
    0.02923618f, 0.06978106f, 0.07337314f, 0.06570676f, -0.02426349f, 0.00252797f, 0.03438306f, -0.08942769f, 
    0.25215837f, -0.08512429f, 0.13676715f, -0.09970039f, -0.10433973f, 0.06637913f, 0.03051567f, 0.12399675f, 
    -0.05950951f, -0.07604287f, 0.05775062f, 0.12795745f, -0.01065485f, -0.06437691f, -0.10590702f, 0.01519063f, 
    -0.03975353f, 0.04893412f, 0.08040667f, 0.07669078f, -0.00564811f, -0.06774914f, -0.14609392f, 0.07386088f, 
    -0.12117299f, 0.22855958f, 0.07587188f, -0.08510508f, -0.01070824f, -0.18037966f, -0.01629772f, 0.00887957f, 
    0.02784469f, -0.00849491f, 0.08889723f, 0.13019255f, 0.23893541f, 0.13687560f, 0.04296206f, 0.24816345f, 
    0.10507399f, 0.22495641f, 0.03540540f, 0.14878464f, 0.00272425f, -0.00631297f, 0.05498238f, -0.09869310f, 
    -0.01510787f, -0.18326423f, 0.03752746f, 0.24085595f, -0.12379672f, 0.15154116f, -0.01271094f, -0.13910833f, 
    -0.07379326f, 0.05847822f, 0.07666046f, -0.04163511f, 0.02266051f, -0.08475975f, -0.05556611f, -0.07170530f, 
    0.06460536f, 0.06811467f, -0.05926377f, 0.05229652f, -0.10519715f, -0.18158080f, -0.10959219f, -0.05740063f, 
    -0.13535658f, 0.12197505f, -0.45014688f, -0.03945554f, -0.10755557f, -0.02173319f, 0.00246473f, -0.18863672f, 
    -0.05552081f, -0.02926476f, -0.00491998f, -0.08080777f, 0.19861774f, 0.06362357f, 0.05422015f, -0.14563157f, 
    -0.03873311f, 0.03680500f, -0.04235472f, -0.01595011f, -0.05340646f, 0.08317190f, 0.06581369f, -0.07523645f, 
    0.15395428f, -0.05992515f, -0.32039347f, 0.20567977f, -0.00456491f, 0.11934385f, 0.02329921f, 0.14498401f, 
    0.01505212f, 0.07482231f, -0.03435297f, 0.00924373f, -0.08840142f, 0.20055901f, -0.03842836f, 0.00356980f, 
    0.04425304f, -0.02038375f, -0.06652072f, 0.02128976f, -0.11902960f, 0.16180152f, -0.02139316f, 0.02092545f, 
    -0.11606974f, -0.18712859f, 0.34240675f, -0.03476706f, -0.17449735f, 0.01900837f, -0.07195833f, -0.12450083f, 
    -0.02883755f, -0.02528773f, 0.03616618f, -0.06339342f, 0.32744470f, -0.03696198f, -0.07190845f, 0.37169713f, 
    0.07997438f, 0.03434416f, -0.09497236f, 0.01526620f, -0.13693456f, 0.00203388f, -0.08609781f, -0.03488211f, 
    0.19257639f, -0.09580572f, -0.03668139f, 0.29431802f, 0.01516888f, 0.07120658f, -0.15210760f, 0.06435943f, 
    -0.12162774f, 0.01078936f, 0.01934603f, 0.00243695f, -0.06147945f, 0.19351725f, 0.12294795f, 0.19981866f, 
    -0.14506538f, -0.11983828f, -0.09497811f, 0.05526578f, -0.10694107f, 0.13385741f, -0.00151139f, 0.06620746f, 
    0.25117421f, -0.27673230f, 0.24622034f, -0.15723410f, 0.01610649f, 0.06386767f, -0.03358229f, 0.20440157f, 
    -0.10211197f, 0.04068106f, 0.07495256f, 0.01414364f, -0.07096406f, 0.07081529f, 0.06963415f, -0.10329820f, 
    -0.08726763f, 0.03365255f, -0.08194064f, 0.04066131f, -0.20428047f, 0.06494303f, -0.05054782f, 0.00546633f, 
    0.09546045f, 0.11135223f, -0.00033467f, -0.22318964f, -0.04374164f, 0.02755259f, -0.00308231f, 0.06461932f, 
    -0.02093889f, -0.01279777f, 0.00926854f, -0.08514453f, -0.34591365f, -0.00175345f, -0.04455273f, 0.00342788f, 
    -0.06133543f, -0.04089379f, -0.09327630f, -0.09891132f, -0.03392712f, 0.01104028f, 0.20348534f, -0.11540976f, 
    0.14151978f, -0.18908919f, -0.01996713f, 0.14721932f, 0.03154679f, 0.04897518f, -0.12916201f, 0.00935420f, 
    -0.09051793f, 0.09303851f, 0.05697912f, -0.05202926f, 0.00583548f, -0.14214772f, 0.04805144f, 0.33128628f, 
    -0.12546314f, -0.14654137f, 0.03532619f, 0.15778136f, -0.13589820f, 0.24342893f, -0.13118781f, 0.08824551f, 
    0.19867361f, 0.57039839f, -0.44033650f, 0.03288408f, 0.01623368f, 0.02945573f, 0.18065396f, -0.17705438f, 
    0.02514365f, -0.05201419f, -0.02448363f, 0.03683523f, -0.11136506f, -0.03997751f, 0.05920831f, 0.09495652f, 
    0.09371496f, 0.20177421f, 0.09695851f, 0.01062189f, -0.01537366f, 0.03262250f, 0.14844806f, 0.01440225f, 
    -0.07773022f, -0.25383842f, 0.24812278f, -0.03517368f, 0.02359339f, 0.07621884f, -0.00967150f, 0.09340265f, 
    0.12989141f, -0.02989271f, 0.09509907f, 0.11575165f, -0.04635031f, -0.09169332f, -0.05467187f, 0.07763427f, 
    0.05221529f, -0.01258965f, -0.08554450f, 0.07344053f, 0.12242784f, -0.06277639f, 0.09292935f, 0.23887500f, 
    -0.23513101f, -0.14860180f, 0.40864187f, -0.05236257f, 0.22229797f, -0.10180164f, -0.16886978f, 0.10825325f, 
    0.07309243f, 0.05417821f, 0.21142794f, 0.09769250f, 0.09902275f, -0.20298886f, -0.04683524f, 0.13670006f, 
    0.16364788f, 0.19297501f, -0.09978557f, 0.07848696f, -0.03241834f, -0.13313545f, 0.08720490f, -0.01514776f, 
    -0.11103457f, 0.16343507f, 0.21561287f, -0.01768686f, 0.04769646f, -0.06230940f, -0.09312765f, 0.01377055f, 
    -0.07145848f, -0.00651337f, -0.02665881f, 0.09674142f, -0.09209961f, -0.04128543f, 0.27472889f, 0.01023629f, 
    0.04049312f, 0.01596853f, 0.12055553f, -0.06786788f, 0.03965011f, 0.04472776f, 0.20407102f, 0.14150950f, 
    -0.10014109f, -0.10204940f, 0.08516376f, -0.11912853f, 0.04644942f, -0.12335751f, 0.09621529f, -0.08093335f, 
    -0.03261838f, -0.12198707f, -0.06776274f, -0.00985547f, -0.13768467f, -0.15426089f, -0.06097220f, 0.10659302f, 
    0.02827698f, 0.10409511f, 0.15030432f, 0.15206656f, -0.12346783f, -0.17713016f, -0.04747923f, -0.06559242f, 
    -0.07622250f, 0.17764357f, 0.01799872f, 0.04229799f, 0.12165294f, 0.10013399f, 0.02626454f, -0.08102028f, 
    -0.14027524f, -0.04588212f, 0.04779287f, 0.09084781f, -0.20159702f, -0.09684528f, -0.10694752f, -0.11815283f, 
    0.03761130f, 0.11246056f, -0.05610572f, 0.06443855f, 0.10258540f, -0.14876772f, -0.05443059f, 0.04422649f, 
    0.00478444f, -0.24721377f, -0.12058181f, -0.02516188f, 0.21489029f, 0.03317691f, -0.04261284f, 0.20377551f, 
    -0.05138943f, -0.00218438f, 0.02576805f, 0.14745936f, 0.16821225f, -0.13708574f, -0.10661689f, -0.11453396f, 
    -0.01536508f, 0.08491081f, 0.04302127f, -0.01873176f, 0.04756239f, 0.03773427f, -0.05406783f, 0.14658552f, 
    -0.32110637f, 0.12159674f, -0.04695728f, -0.13703170f, -0.08623038f, -0.05333783f, 0.15331174f, 0.02872231f, 
    0.07540344f, -0.05347795f, 0.06374481f, 0.05289943f, -0.08679766f, 0.11211789f, 0.37924799f, -0.29799101f, 
    -0.08099823f, 0.37783098f, -0.10589273f, 0.08117983f, 0.01818609f, -0.08749472f, 0.03767477f, -0.06360077f, 
    -0.24951065f, 0.07647754f, 0.36085507f, -0.10437305f, 0.06555361f, 0.12556778f, 0.16051447f, 0.14432085f, 
    -0.08525136f, 0.01533482f, -0.02839208f, 0.01959359f, -0.24275646f, -0.02595261f, -0.06231245f, -0.07427933f, 
    -0.03875138f, 0.02935215f, -0.12135380f, -0.00452264f, 0.05386114f, 0.00892763f, -0.05875269f, -0.09349937f, 
    0.13975747f, -0.12491605f, -0.31992203f, 0.01639729f, 0.04184617f, 0.05219849f, 0.07513846f, -0.03948399f, 
    0.03167446f, -0.03914789f, -0.04796452f, -0.03498533f, 0.32736528f, 0.01465170f, 0.35526669f, -0.06500106f, 
    0.10312623f, 0.01742749f, -0.07917257f, 0.14733061f, 0.00869897f, 0.04603916f, 0.12564477f, 0.05487354f, 
    -0.09147228f, -0.32769322f, -0.32206377f, 0.09010601f, 0.01919347f, 0.10214811f, 0.12614395f, 0.02948641f, 
    -0.01294654f, -0.05359867f, 0.02626755f, -0.08103389f, 0.09504571f, 0.08201884f, 0.04601060f, 0.10093848f, 
    0.08046988f, 0.06538481f, -0.03741322f, 0.08986226f, -0.03076073f, 0.05440969f, 0.04500039f, 0.12769069f, 
    -0.02315372f, -0.18634214f, 0.30736378f, 0.14027955f, 0.04237534f, 0.07522696f, -0.13136141f, -0.01645350f, 
    -0.00778820f, -0.02700579f, 0.03496296f, 0.05597548f, 0.26806527f, 0.04583117f, 0.04917188f, -0.02735878f, 
    0.06171080f, 0.06436093f, 0.09842630f, 0.13295595f, -0.07620075f, -0.09787833f, 0.05914178f, -0.07629526f, 
    0.21111670f, 0.07670090f, -0.13526554f, -0.04454023f, 0.07438286f, 0.22123377f, 0.04010763f, 0.02590512f, 
    -0.03755341f, -0.07088858f, -0.06367860f, -0.06459738f, 0.06545068f, 0.00082905f, 0.02371304f, 0.23263843f, 
    -0.04097523f, -0.07583519f, -0.03279785f, 0.09111378f, -0.01587241f, 0.05420925f, 0.01679128f, -0.09395023f, 
    0.09630606f, -0.22776519f, 0.09135662f, -0.04597360f, -0.08602457f, 0.08944373f, -0.17731407f, 0.15626362f, 
    -0.09922908f, -0.04459800f, -0.04256362f, 0.06410908f, 0.00181276f, -0.02184114f, 0.13272209f, 0.11779180f, 
    -0.09619786f, 0.05062700f, -0.08029070f, 0.02058637f, -0.18270056f, -0.03228049f, -0.10156776f, -0.05475034f, 
    0.23638763f, -0.05867634f, 0.26124990f, 0.04855721f, 0.02374995f, 0.11020682f, 0.01063809f, 0.03227868f, 
    -0.02592498f, 0.10686106f, -0.10541374f, -0.05222437f, 0.05508693f, 0.03413848f, -0.13359894f, 0.16182016f, 
    -0.06214803f, 0.06284044f, -0.02764189f, 0.02150372f, -0.01072855f, 0.03162392f, 0.06507262f, 0.06402002f, 
    -0.03779474f, -0.16830879f, -0.06052174f, -0.03747090f, 0.15120308f, 0.19725750f, -0.06108976f, 0.01268272f, 
    0.11460724f, -0.08932934f, 0.09512136f, 0.00901537f, -0.03945100f, 0.12524839f, -0.08440033f, -0.06369606f, 
    -0.08513071f, -0.10869871f, -0.06923261f, 0.08026517f, -0.04813390f, 0.11272391f, 0.06026524f, 0.01538699f, 
    0.19592212f, 0.52291417f, 0.00054309f, -0.15519182f, 0.20920061f, -0.08298028f, 0.12895001f, 0.08609978f, 
    0.05386837f, 0.01375589f, 0.00961585f, -0.01800203f, -0.01907500f, -0.03870548f, -0.06175353f, 0.10156465f, 
    0.08834092f, 0.09089290f, 0.03711141f, -0.07782051f, -0.11730225f, 0.04193633f, -0.01796876f, -0.05446098f, 
    -0.22064382f, -0.00684080f, 0.37556309f, 0.14537232f, -0.00742684f, 0.02341526f, -0.10101867f, 0.09921550f, 
    0.13310952f, 0.07109546f, 0.07695803f, 0.14129050f, -0.22135055f, -0.11197881f, -0.12453538f, 0.08660688f, 
    0.08555414f, 0.08408564f, 0.15212794f, 0.05598480f, 0.11661606f, 0.05984288f, 0.08334282f, 0.18656726f, 
    0.00844475f, 0.12588601f, 0.47064778f, 0.12612209f, 0.08980751f, -0.22757255f, -0.17170966f, 0.04874428f, 
    -0.10935394f, -0.01177350f, 0.10931329f, 0.09305622f, 0.13688031f, -0.16455026f, -0.06548802f, 0.01299185f, 
    0.08957312f, -0.08278168f, -0.04909171f, 0.08245633f, -0.11442354f, -0.00665093f, -0.15737012f, -0.27879813f, 
    0.12172367f, 0.03229902f, -0.01661128f, -0.15625826f, -0.02325367f, 0.04868189f, 0.10004055f, -0.02176369f, 
    -0.07983364f, -0.02338335f, -0.02363746f, 0.04021313f, -0.12196223f, -0.11805584f, 0.08290564f, 0.13343726f, 
    -0.03766498f, -0.01628454f, -0.10448593f, -0.08879742f, 0.08686674f, -0.01832812f, -0.05540069f, 0.24376819f, 
    -0.07372785f, -0.02808995f, 0.21316114f, 0.00730527f, -0.05232975f, -0.21974376f, -0.00650590f, 0.05482578f, 
    -0.00343279f, -0.03270198f, -0.03366732f, 0.00597317f, 0.20195842f, 0.05085558f, 0.05784981f, -0.06620228f, 
    0.02595653f, 0.10116803f, 0.13905656f, -0.04065500f, 0.04223027f, -0.02893164f, -0.07106614f, -0.06491689f, 
    -0.08213530f, 0.14434423f, 0.13122737f, 0.13670823f, 0.21860574f, 0.02271370f, 0.06022929f, -0.15933740f, 
    0.11764444f, -0.00178588f, 0.11134635f, -0.03404045f, -0.00477979f, -0.05456488f, -0.20584790f, -0.13462575f, 
    -0.01809706f, 0.06412189f, 0.11707785f, -0.02404588f, 0.08538020f, 0.04575296f, 0.05053299f, -0.09108438f, 
    0.10959814f, -0.04296808f, -0.22647436f, -0.21248509f, 0.01738302f, -0.07350390f, 0.08427823f, 0.06294755f, 
    -0.10178286f, -0.06957421f, 0.01827078f, 0.07640835f, 0.19446340f, -0.11049206f, 0.02065433f, -0.11655658f, 
    0.04000133f, -0.01230877f, 0.02368771f, 0.00779691f, -0.08784037f, 0.04146086f, -0.05360807f, -0.01916392f, 
    -0.14876647f, 0.17276937f, 0.14045562f, 0.03014719f, -0.08304818f, -0.28416967f, 0.11999895f, -0.00514491f, 
    -0.03354760f, 0.01315789f, 0.14967716f, 0.04324935f, 0.23873602f, 0.00672600f, 0.31652749f, 0.02104370f, 
    0.00801029f, 0.36697543f, 0.01511526f, 0.02917113f, 0.02122421f, -0.11470079f, 0.01874025f, -0.16609505f, 
    -0.33821270f, -0.39055109f, 0.11433773f, 0.14628683f, -0.19444700f, 0.12239465f, -0.13054760f, -0.05344762f, 
    0.02741640f, 0.09136909f, 0.04758072f, 0.18297513f, -0.00641491f, 0.00467001f, -0.04242205f, -0.09396234f, 
    0.07343468f, -0.12355340f, -0.01290990f, 0.09912749f, 0.00943025f, -0.06816839f, -0.03011600f, -0.06133427f, 
    0.24461532f, 0.03395783f, -0.00678497f, 0.05230629f, -0.13221045f, -0.22209734f, 0.04480577f, -0.01738311f, 
    0.28763723f, 0.06836542f, 0.16394687f, 0.21942776f, 0.01347492f, 0.01533737f, -0.15501982f, 0.13812928f, 
    -0.06928285f, 0.11359359f, 0.03480517f, 0.05160050f, -0.01057640f, -0.05451060f, 0.21693109f, 0.09104806f, 
    0.01896515f, 0.34498855f, 0.31090435f, 0.23887703f, -0.08797419f, 0.01829532f, -0.03531075f, -0.08174391f, 
    -0.04112105f, -0.03417351f, 0.03842116f, 0.08212317f, -0.20448618f, -0.30252501f, 0.17437676f, -0.16722761f, 
    -0.01352600f, -0.05461305f, -0.09442887f, -0.18975917f, -0.41668776f, -0.03474725f, -0.12175419f, -0.49822995f, 
    0.07718438f, 0.19779137f, 0.21084264f, -0.06631716f, 0.19970039f, -0.02528098f, -0.13315760f, 0.05102528f, 
    -0.10067176f, -0.07607871f, -0.05887033f, -0.26982471f, -0.26328653f, -0.05978661f, 0.18736106f, 0.17569989f, 
    0.02223768f, 0.12071759f, -0.06701575f, 0.13526750f, 0.03026070f, -0.03207820f, 0.08561158f, 0.06329334f, 
    -0.16642223f, -0.24511966f, 0.03427893f, 0.20398636f, -0.09575769f, -0.12826996f, 0.03333763f, 0.06648501f, 
    -0.12997401f, -0.15362673f, 0.02423114f, -0.01017401f, -0.29751587f, 0.50480419f, 0.49496421f, 0.16486582f, 
    -0.01122700f, -0.13821863f, 0.09747390f, 0.02264042f, -0.05633624f, 0.00947036f, 0.10147066f, 0.04531425f, 
    0.05914916f, 0.27145502f, 0.02017749f, 0.30988130f, 0.10566265f, 0.01728986f, 0.22053966f, 0.01221697f, 
    0.25326487f, -0.20558202f, 0.27473801f, 0.07325542f, -0.05696582f, -0.18492670f, 0.11449597f, -0.26146919f, 
    -0.12164914f, -0.00867041f, 0.22844823f, 0.13266177f, 0.26822510f, -0.16714133f, -0.03464726f, 0.22898200f, 
    -0.21696816f, 0.08123764f, -0.23445843f, 0.04628368f, -0.01652350f, 0.05776118f, 0.11164809f, -0.07113010f, 
    0.00632039f, 0.15560451f, -0.03660275f, -0.02882046f, -0.46553564f, -0.10969841f, 0.07145185f, -0.19781174f, 
    -0.01384696f, -0.13716933f, -0.36712500f, -0.18292883f, 0.11472372f, -0.01059598f, 0.07174315f, -0.12724935f, 
    0.12521333f, 0.03802646f, 0.30378807f, 0.55258560f, -0.11949378f, -0.05984448f, 0.25151137f, -0.13914728f, 
    0.14982860f, 0.07255774f, 0.03146931f, 0.36363438f, -0.30172423f, -0.05802660f, 0.87368655f, 0.01357225f, 
    0.11007301f, 0.15617721f, -0.12367646f, 0.05794461f, -0.08409286f, -0.31354043f, 0.10053893f, -0.03959680f, 
    -0.01038179f, -0.20054515f, 0.11050050f, 0.09157253f, 0.02451986f, 0.03192248f, -0.16471124f, 0.10864568f, 
    0.04047484f, -0.02781896f, -0.00845701f, 0.07192232f, -0.25176996f, 0.10302117f, 0.12116615f, -0.14861761f, 
    -0.04563648f, -0.01053366f, -0.10252306f, 0.00552564f, -0.45629278f, -0.24571462f, -0.22475964f, -0.39925614f, 
    -0.15125149f, -0.35728627f, -0.04892794f, -0.01116307f, -0.14045863f, -0.13897429f, -0.00170008f, -0.07421523f, 
    0.01816854f, -0.03931719f, 0.14710298f, 0.07256137f, -0.21379386f, -0.23079181f, -0.00358736f, -0.04841019f, 
    0.22999603f, -0.16150177f, 0.04586316f, -0.08810877f, -0.04831146f, -0.12663054f, -0.10057061f, -0.19102415f, 
    0.15228356f, -0.11764738f, 0.23891127f, 0.04471515f, -0.05750923f, 0.03136484f, -0.12069886f, -0.25456515f, 
    0.11627930f, 0.06525899f, 0.17403629f, -0.01054173f, 0.11850951f, -0.06474140f, 0.11946480f, 0.14664043f, 
    0.22254911f, -0.08160240f, -0.08131210f, -0.05260170f, -0.12497680f, -0.05355145f, -0.04171285f, 0.04664829f, 
    0.32378823f, -0.00401206f, 0.09515630f, 0.09567350f, 0.11700345f, -0.01640699f, -0.02112553f, 0.08501064f, 
    -0.00122218f, -0.07816514f, -0.19882673f, 0.02727380f, 0.11838565f, -0.03193370f, 0.00164984f, 0.01850242f, 
    0.07012140f, 0.08607703f, -0.02440561f, -0.03645571f, -0.13067943f, -0.07165185f, -0.17400306f, -0.02215914f, 
    -0.01376523f, 0.06798699f, 0.21857971f, 0.15106089f, -0.00789621f, -0.07532996f, -0.06967893f, 0.05193394f, 
    -0.21337762f, -0.32514024f, -0.24769340f, -0.18529658f, 0.21545365f, 0.20562737f, 0.11747825f, 0.34975260f, 
    0.06821848f, -0.04843456f, 0.00707119f, 0.05340897f, 0.16837867f, 0.08121408f, -0.01056255f, 0.08822997f, 
    -0.13972226f, -0.27840552f, 0.22723916f, 0.16183774f, -0.01898003f, -0.11706804f, -0.08015345f, 0.07730107f, 
    -0.15724781f, -0.11536901f, 0.00140715f, -0.01805829f, 0.14115895f, 0.09678604f, 0.16952212f, 0.20211358f, 
    0.13402727f, 0.07547144f, 0.02557484f, 0.02940641f, 0.17152068f, -0.03921930f, -0.05520055f, 0.02197942f, 
    0.19417128f, -0.02104565f, 0.20946471f, 0.15247083f, 0.00580071f, 0.00261926f, 0.24173003f, -0.04492364f, 
    -0.03112993f, -0.04657057f, 0.01589949f, 0.18755971f, 0.16892551f, -0.07581601f, 0.08249666f, 0.16469204f, 
    -0.02465010f, 0.00526690f, -0.00450585f, 0.00615161f, 0.25441903f, 0.29990423f, -0.06096738f, 0.16004740f, 
    -0.42375490f, -0.02334763f, -0.00151002f, -0.19431797f, 0.02366291f, -0.19685018f, -0.10468762f, -0.42369467f, 
    -0.12895308f, -0.06504579f, -0.07860991f, -0.02097976f, 0.28464323f, 0.20997806f, 0.12637579f, 0.07712147f, 
    0.20156966f, 0.12863772f, 0.09376118f, -0.04127137f, 0.14469793f, 0.15596747f, -0.02783334f, 0.02430358f, 
    -0.00435853f, -0.03970465f, 0.11019062f, -0.04286006f, 0.03334067f, 0.15117188f, 0.11985719f, 0.00740858f, 
    -0.18357340f, -0.17356807f, -0.12351004f, -0.12622860f, 0.04807761f, -0.15533447f, -0.02212854f, 0.02005901f, 
    0.04196696f, 0.17478879f, -0.15793899f, -0.09717517f, -0.06882922f, -0.15455996f, -0.19818284f, -0.02330760f, 
    0.41245449f, -0.24006878f, 0.25997299f, 0.03298909f, -0.04330298f, -0.03114845f, -0.02522958f, -0.02679192f, 
    0.04122807f, 0.01056357f, 0.11053613f, 0.00040837f, 0.04077710f, 0.05880472f, 0.01614076f, 0.14138803f, 
    0.08527206f, 0.04457204f, -0.03425298f, 0.18851534f, 0.14015254f, -0.05201381f, -0.09256698f, -0.04762371f, 
    0.11778593f, -0.37097874f, 0.06228424f, -0.09637951f, -0.03212668f, -0.10628010f, -0.03362094f, -0.04736370f, 
    0.04258708f, 0.05399211f, 0.07159264f, 0.25122166f, 0.03203297f, -0.09751585f, -0.05315128f, -0.05829746f, 
    0.25096661f, 0.05288247f, 0.06322228f, -0.19940339f, 0.07016481f, -0.10363548f, -0.07716047f, 0.07825182f, 
    -0.28944090f, 0.41763714f, -0.31538719f, 0.32680914f, 0.03662758f, -0.17132020f, 0.04851336f, 0.04910859f, 
    0.03645263f, 0.04142599f, -0.17106959f, 0.08481007f, 0.01462375f, -0.28328770f, -0.27359000f, -0.21724427f, 
    0.01419133f, -0.06374649f, 0.11210682f, 0.20899354f, -0.09906702f, 0.02240035f, -0.02371492f, -0.03692896f, 
    0.10601880f, 0.20973602f, -0.03204617f, -0.25205955f, 0.14115261f, -0.00459641f, 0.23923451f, 0.17617357f, 
    0.03715720f, -0.07065310f, 0.00764285f, 0.02448818f, -0.17272849f, -0.15273991f, -0.05612933f, 0.13774174f, 
    -0.05926464f, 0.07388271f, 0.04533989f, 0.05093060f, 0.04515057f, -0.08574861f, 0.10592282f, -0.07093738f, 
    -0.09718445f, 0.45362750f, -0.23738444f, 0.14258802f, -0.06729578f, 0.06439795f, 0.25338757f, 0.06533323f, 
    0.00712632f, 0.16808860f, 0.04188998f, 0.00080069f, -0.19588989f, 0.03246603f, -0.05988020f, 0.12228101f, 
    0.06659812f, 0.00849289f, -0.03974913f, -0.08159469f, 0.16956960f, 0.00850979f, -0.02806504f, 0.07994118f, 
    -0.25270119f, 0.06511019f, -0.03632740f, 0.02371077f, 0.03936620f, -0.10240302f, -0.08694555f, -0.11830339f, 
    -0.06678623f, -0.02942958f, -0.04850082f, 0.00489412f, 0.28355896f, -0.12699063f, 0.00004241f, -0.02547145f, 
    -0.12131112f, -0.13554382f, 0.04891890f, -0.11150809f, 0.07034476f, 0.15919465f, -0.08503306f, 0.05049030f, 
    -0.10648526f, -0.23820144f, -0.30682081f, -0.16157261f, -0.04623147f, 0.05113792f, -0.03856298f, 0.09370222f, 
    0.02266136f, 0.07769303f, 0.07041178f, -0.00081720f, -0.05498824f, 0.24794322f, -0.26173154f, 0.02955279f, 
    -0.02208634f, 0.19229862f, 0.21319720f, 0.11807862f, 0.01281788f, -0.06780969f, 0.00168861f, -0.03198328f, 
    0.21971799f, -0.04061704f, 0.27160445f, -0.28046459f, 0.08413484f, 0.08835638f, 0.12686221f, -0.04765459f, 
    0.01334515f, 0.00046911f, 0.00063091f, 0.01495606f, -0.17166702f, -0.05782320f, -0.14960873f, -0.00241304f, 
    -0.01243767f, 0.10293680f, -0.04673338f, -0.13410740f, 0.00601052f, 0.07660727f, 0.01539790f, -0.11377380f, 
    0.01790847f, -0.07751050f, 0.02508476f, 0.02020826f, 0.05187878f, -0.04911591f, -0.02337591f, -0.00500323f, 
    0.05817187f, 0.04614219f, -0.02310951f, -0.03906471f, 0.01851300f, -0.05821966f, -0.05527972f, 0.01974048f, 
    0.02660832f, -0.03590453f, -0.04958118f, -0.07840775f, -0.05328852f, 0.00390653f, -0.01396571f, 0.04340243f, 
    0.02963634f, 0.02657469f, 0.05209248f, 0.03078345f, -0.01781263f, -0.05252929f, -0.01218227f, 0.00503627f, 
    0.02851053f, -0.00615794f, -0.04083876f, 0.00922607f, -0.07935084f, 0.01851433f, -0.00465066f, -0.02678712f, 
    -0.02618409f, -0.06245371f, -0.05108733f, 0.03621661f, -0.06163159f, -0.08017138f, -0.04409146f, -0.06666934f, 
    -0.04374920f, -0.07850163f, 0.05933146f, -0.06918168f, -0.03261553f, -0.04234608f, -0.01031084f, -0.05409713f, 
    -0.05374976f, -0.02752968f, 0.02124862f, -0.06104192f, -0.01935497f, 0.05461366f, 0.03999213f, -0.03493846f, 
    -0.02003997f, -0.03566020f, 0.04128047f, 0.04110937f, 0.03644479f, -0.02481461f, -0.00929029f, -0.02008438f, 
    -0.05624899f, -0.03490401f, -0.07020941f, -0.06017166f, 0.00627630f, -0.01269371f, -0.05602194f, -0.05991918f, 
    0.03555830f, -0.07841044f, -0.00191040f, -0.07650729f, -0.04679802f, 0.04756829f, 0.02516786f, 0.03193641f, 
    0.01390938f, 0.00138694f, -0.01509821f, 0.06235722f, 0.04920148f, 0.04164802f, -0.01408344f, -0.04826074f, 
    0.03786727f, 0.05641097f, 0.03529384f, -0.06967242f, 0.00993649f, -0.05458255f, -0.02860668f, 0.04423758f, 
    0.02038068f, -0.00047941f, -0.00409562f, -0.03335835f, -0.05867798f, -0.02284794f, -0.03165811f, -0.07105844f, 
    0.00965128f, 0.00179800f, -0.05285291f, 0.03536230f, -0.05503223f, 0.03997720f, 0.03322645f, -0.00413318f, 
    -0.03584952f, 0.00456449f, 0.04685640f, 0.04065168f, -0.06636444f, -0.06931777f, 0.02014259f, 0.02964271f, 
    0.04644077f, 0.03714031f, -0.04120505f, -0.00338537f, -0.02962215f, -0.07651639f, -0.00441166f, -0.07634678f, 
    0.02633835f, 0.01597657f, 0.02459294f, -0.05085270f, 0.03669159f, 0.04198598f, 0.04959652f, -0.07683970f, 
    -0.02220958f, -0.07826784f, -0.01853705f, -0.06534178f, -0.08324578f, -0.01026873f, 0.01319589f, -0.02315921f, 
    0.05900112f, -0.06129500f, 0.01734747f, 0.03433451f, 0.05467402f, -0.02705609f, -0.05434002f, 0.03111899f, 
    -0.04038345f, 0.00979974f, -0.02017374f, 0.00589959f, -0.03783553f, -0.03999780f, 0.01903789f, 0.05965587f, 
    -0.07544078f, -0.06902269f, 0.03592592f, 0.04742263f, 0.04144001f, -0.01723926f, 0.04847473f, -0.02704980f, 
    -0.02334397f, 0.03842846f, 0.02015788f, 0.01628518f, -0.04726265f, -0.01736021f, -0.02938600f, 0.00431840f, 
    0.03704849f, -0.03143328f, 0.04680238f, 0.04340159f, 0.02731185f, -0.04320953f, -0.07289620f, 0.05465827f, 
    0.15856816f, 0.17886123f, 0.01138193f, -0.00231924f, -0.18146275f, -0.08908433f, 0.10896304f, -0.05836994f, 
    0.09657852f, 0.02113538f, -0.01708780f, 0.01637527f, -0.06649332f, 0.10568714f, -0.06913159f, -0.14908172f, 
    -0.10643146f, 0.03219038f, 0.09662203f, -0.01742716f, -0.07979924f, 0.01157416f, 0.10593207f, -0.03598664f, 
    0.34131035f, 0.53839171f, -0.09780350f, 0.25356543f, -0.12437512f, 0.02729071f, 0.27433792f, -0.21490131f, 
    0.13537955f, -0.02397050f, -0.22257732f, -0.02017398f, -0.15692687f, -0.00671793f, -0.05424692f, -0.22901866f, 
    -0.20523365f, -0.06152342f, 0.04604532f, -0.10391963f, -0.00829974f, 0.08467247f, 0.00025679f, -0.05596227f, 
    0.12942755f, -0.10051769f, -0.18429942f, -0.11121641f, 0.02205957f, 0.17410289f, -0.09066457f, 0.05089112f, 
    0.02180119f, -0.09982523f, 0.05911104f, -0.14578003f, -0.03134341f, 0.00067333f, -0.11537427f, -0.03358764f, 
    -0.06003951f, 0.05241816f, -0.07317717f, 0.12948309f, -0.03252863f, 0.02783852f, -0.06832393f, -0.10821319f, 
    0.05129431f, 0.04900157f, -0.21264875f, 0.14617039f, -0.02029019f, 0.08603913f, -0.05640344f, -0.01642791f, 
    -0.10607173f, 0.07232284f, -0.05895773f, 0.08788738f, -0.14079805f, 0.06218313f, 0.19490521f, 0.10209074f, 
    0.00077371f, -0.17925163f, -0.06677958f, -0.26368138f, 0.05844737f, 0.03117831f, -0.06329570f, 0.19695701f, 
    0.06960069f, 0.01222554f, -0.27919993f, -0.21140718f, 0.12450571f, -0.01831515f, 0.03575361f, 0.15331501f, 
    0.25696412f, -0.10784209f, 0.09446403f, 0.05697792f, 0.15193208f, -0.12709457f, 0.04125959f, -0.03995104f, 
    -0.03784449f, -0.20585060f, 0.07701370f, -0.23500302f, -0.07276864f, 0.00759804f, -0.30282578f, -0.01568564f, 
    -0.30370781f, 0.23128483f, 0.06633107f, 0.08371332f, -0.11928795f, -0.03372750f, 0.14624624f, -0.25186053f, 
    0.06583592f, -0.03369464f, 0.01386771f, -0.12763387f, -0.14180270f, 0.23826785f, 0.29892191f, 0.04887285f, 
    0.06058713f, -0.09152195f, -0.11680138f, -0.11675277f, 0.07997303f, -0.03112601f, 0.23470026f, -0.08960672f, 
    0.26568314f, -0.00186355f, 0.17106776f, 0.48444787f, 0.04694680f, 0.27422944f, 0.01348770f, -0.07168953f, 
    0.03046549f, 0.14333390f, 0.11317086f, 0.19743770f, -0.33860019f, -0.43908900f, -0.30986416f, 0.28513479f, 
    0.10888977f, -0.25818178f, 0.04172675f, -0.17312330f, 0.05237855f, -0.07626412f, -0.03094211f, 0.12017203f, 
    0.23448287f, -0.12608778f, -0.30995902f, 0.08236206f, 0.03576197f, 0.01540346f, -0.15446529f, 0.07845754f, 
    0.11935165f, 0.05840040f, 0.01445128f, -0.03905997f, 0.01797313f, -0.03433872f, -0.05138858f, -0.07121772f, 
    -0.03342627f, -0.06486375f, 0.15537088f, -0.01204978f, -0.13056263f, -0.10436494f, 0.14538598f, -0.08657457f, 
    -0.28882501f, -0.25322130f, -0.12402325f, 0.13122626f, -0.09568246f, -0.02670995f, 0.00187113f, -0.09505762f, 
    -0.17248492f, -0.06339444f, -0.04406351f, -0.01662782f, -0.14349234f, -0.09483335f, -0.02635033f, 0.22960261f, 
    0.20398560f, 0.01807030f, 0.03976813f, -0.10823149f, 0.10892885f, 0.11134657f, 0.02223496f, -0.08956061f, 
    0.36442527f, -0.17775440f, 0.15245643f, 0.09141602f, 0.06487860f, 0.02584225f, -0.02063463f, -0.05219454f, 
    0.04077266f, 0.07937510f, 0.17010315f, 0.04293606f, 0.12997541f, -0.23048452f, 0.07474570f, -0.04867195f, 
    0.15501630f, 0.01506857f, -0.01703984f, -0.02461894f, 0.01092304f, 0.10317657f, 0.06575090f, -0.08041023f, 
    -0.18225431f, -0.18994257f, -0.05666075f, -0.11968047f, -0.10432783f, -0.01626489f, 0.14792253f, -0.05468263f, 
    0.01375584f, -0.04359223f, 0.02022930f, -0.06772427f, 0.29011354f, 0.10381131f, 0.18708479f, 0.05202722f, 
    0.12683143f, 0.12381464f, 0.10322325f, 0.12966101f, -0.00952547f, -0.00873176f, 0.02141029f, 0.03230702f, 
    -0.10086218f, 0.10826907f, 0.27977702f, 0.43490699f, -0.14283137f, -0.12028138f, 0.05293882f, 0.07051345f, 
    -0.04891939f, -0.04446611f, 0.03798751f, -0.07487603f, 0.34959856f, 0.01309034f, -0.08148207f, -0.04898984f, 
    -0.07715531f, -0.15532495f, 0.04686372f, -0.12937745f, 0.03946798f, -0.01707924f, -0.10467933f, 0.07132765f, 
    0.04094571f, -0.07261028f, 0.16294435f, 0.04492766f, 0.06835136f, -0.01985824f, 0.15715902f, 0.16378681f, 
    -0.06918150f, -0.08075717f, 0.09141710f, 0.05387077f, -0.13919625f, -0.24455099f, -0.27687302f, -0.16796260f, 
    0.06870333f, 0.01143038f, -0.10328771f, -0.08320046f, 0.03428452f, 0.04755762f, 0.07855576f, 0.03451526f, 
    -0.00720638f, -0.15156351f, -0.26303324f, -0.19940154f, 0.04127356f, -0.05708840f, 0.05576629f, -0.17625739f, 
    -0.10050805f, 0.08433064f, -0.03059309f, 0.03661385f, -0.02343751f, -0.17819570f, -0.12980917f, -0.22127861f, 
    0.03556499f, 0.03795478f, -0.04553938f, 0.01658520f, 0.00052295f, -0.05840569f, 0.04208752f, 0.02716473f, 
    0.12426655f, 0.06385466f, 0.08651414f, -0.17369105f, 0.03968231f, -0.14304474f, 0.10544790f, -0.01747877f, 
    -0.07784786f, -0.04641195f, 0.06465496f, -0.00663427f, 0.19383350f, -0.06888786f, 0.01034531f, -0.35718632f, 
    0.02411052f, -0.00295378f, 0.01108997f, -0.05732558f, -0.01555016f, -0.00832482f, 0.09828129f, 0.07032078f, 
    -0.09885416f, -0.09154276f, 0.18219005f, 0.01286011f, -0.15804137f, -0.01312948f, -0.14129804f, 0.03139064f, 
    0.02125802f, -0.01207773f, -0.08077854f, -0.03777440f, 0.03666338f, -0.10220027f, -0.00241747f, -0.05210868f, 
    0.18463381f, 0.04104444f, 0.04098087f, 0.16411109f, 0.03533049f, 0.10252883f, -0.08827262f, -0.05786527f, 
    -0.21877009f, 0.25401422f, -0.13297755f, -0.24357417f, 0.12419385f, 0.09257086f, -0.04316755f, 0.11296874f, 
    -0.14193165f, 0.11397530f, 0.16420335f, -0.06670136f, 0.10262177f, -0.08731997f, -0.12950318f, -0.04631842f, 
    -0.04805475f, 0.00309405f, -0.06218112f, -0.08052976f, 0.05539704f, 0.02449214f, 0.24709341f, 0.05177967f, 
    -0.26942918f, 0.23563124f, 0.00522576f, 0.03425745f, 0.17461000f, -0.07280600f, 0.06392762f, 0.04304381f, 
    -0.09676921f, 0.16832067f, 0.16048267f, 0.22071576f, 0.06953015f, -0.19096015f, -0.05456496f, 0.16932589f, 
    -0.05896701f, -0.08294592f, 0.07200805f, -0.13801448f, -0.05592194f, 0.03062542f, -0.02551811f, -0.05985566f, 
    -0.01524881f, 0.20700210f, 0.32388085f, -0.03590431f, 0.01897054f, -0.04145028f, -0.12006222f, -0.26823017f, 
    0.02404997f, 0.12102357f, 0.15103133f, 0.01002721f, -0.08817136f, 0.02616244f, 0.30630159f, 0.08045878f, 
    -0.09361519f, 0.09788793f, 0.15501665f, -0.09772497f, -0.05376935f, -0.04918370f, 0.14435641f, 0.22276270f, 
    -0.18454795f, -0.19252460f, -0.12759019f, -0.07803106f, 0.15055120f, 0.17261520f, 0.02630856f, -0.06366818f, 
    -0.10672449f, -0.24871637f, -0.12269305f, -0.11132607f, -0.11968872f, -0.14125083f, 0.19752756f, 0.27325329f, 
    -0.05539148f, -0.02962573f, -0.01735636f, 0.06436203f, -0.00096982f, 0.05747395f, -0.03777925f, -0.05026449f, 
    -0.00852505f, 0.05244366f, 0.19836465f, -0.03653756f, 0.04808939f, 0.01094656f, -0.13663912f, 0.01168640f, 
    -0.12746756f, -0.00339466f, 0.03541813f, 0.02894987f, -0.03090306f, -0.32259318f, -0.10629895f, -0.16175041f, 
    -0.18882558f, 0.02091186f, -0.28448308f, -0.11357469f, 0.12703162f, 0.01538459f, -0.01729987f, -0.07312112f, 
    -0.03400875f, -0.24747862f, -0.24476258f, -0.00454719f, 0.13898630f, -0.03266035f, -0.11350734f, 0.16248293f, 
    0.12514627f, 0.15537098f, 0.01129914f, -0.17618878f, -0.03694603f, -0.01488990f, -0.03799227f, -0.21152164f, 
    0.17539841f, -0.11866436f, -0.06040211f, -0.04899267f, 0.07043192f, -0.05265091f, 0.19059102f, 0.15106791f, 
    0.11627840f, -0.12426991f, -0.08017051f, 0.31444210f, -0.14126828f, 0.13946791f, 0.11837916f, 0.16469024f, 
    0.04177061f, -0.04921089f, 0.03437831f, 0.25630909f, -0.26886016f, -0.33310559f, 0.36193258f, -0.18779036f, 
    0.02514185f, 0.31461427f, -0.21112642f, 0.08424305f, 0.07651000f, -0.04520794f, 0.03997319f, 0.02210400f, 
    -0.08298136f, 0.17625262f, 0.14999127f, -0.00694794f, -0.01151904f, 0.02949548f, 0.14411645f, 0.09967597f, 
    -0.11341902f, -0.02720262f, 0.03985235f, 0.08877363f, -0.06510754f, 0.11712956f, -0.00559354f, 0.09474551f, 
    0.00430235f, -0.21247190f, -0.13651478f, -0.17658021f, 0.21825910f, -0.01550011f, -0.02159747f, -0.14480802f, 
    -0.06865886f, 0.06311419f, -0.37247926f, 0.03595163f, -0.11877057f, -0.04255200f, 0.02261992f, -0.08323442f, 
    -0.04240904f, -0.00068724f, -0.06105248f, 0.00513446f, -0.14827698f, -0.13132572f, -0.03665322f, -0.05601455f, 
    -0.03530949f, -0.01954302f, 0.03158167f, -0.07075698f, -0.05914308f, 0.02477927f, 0.13834681f, -0.10280830f, 
    0.17431289f, 0.30168304f, 0.00305504f, 0.17213055f, -0.11538775f, 0.05721148f, 0.04266398f, -0.11999705f, 
    -0.00004360f, 0.07741291f, 0.02357097f, 0.05026447f, 0.03837884f, 0.09821314f, 0.13611856f, 0.06678338f, 
    -0.10645457f, -0.22883560f, -0.09285112f, -0.13484433f, -0.12715071f, -0.01458955f, -0.00416071f, -0.10582781f, 
    0.35765117f, -0.11860415f, 0.46037212f, -0.18087658f, -0.10419162f, -0.01215456f, -0.14334510f, 0.09558638f, 
    -0.00500158f, -0.09942417f, 0.10007447f, -0.20042036f, 0.08172787f, 0.17374557f, 0.16405417f, 0.19418705f, 
    0.10222631f, 0.22294153f, -0.02068479f, 0.24866888f, -0.10821561f, -0.09079857f, -0.03493595f, -0.12916756f, 
    -0.18485858f, 0.05435444f, -0.01900288f, 0.31886086f, -0.14595810f, 0.00034122f, -0.00737915f, 0.03215703f, 
    -0.05459124f, 0.02300531f, 0.08317815f, -0.06465961f, 0.19873747f, 0.34573323f, 0.33644184f, 0.17410842f, 
    -0.18574484f, -0.37822339f, -0.08748631f, -0.10323712f, -0.02771203f, 0.13106245f, -0.02751962f, 0.10670755f, 
    0.10212708f, -0.34877169f, 0.09030386f, -0.08858906f, 0.06127380f, 0.01505151f, -0.04564067f, 0.14750852f, 
    0.10835029f, -0.08196055f, 0.20961960f, 0.12160774f, 0.19824581f, 0.12916906f, 0.12024494f, -0.03021326f, 
    -0.14212091f, -0.06145823f, -0.11795399f, -0.03244393f, -0.16201018f, -0.00391947f, -0.19592535f, 0.10224622f, 
    0.06151405f, 0.13731270f, 0.04254028f, 0.10619704f, -0.16171965f, 0.01830301f, 0.05072755f, -0.14561224f, 
    0.00265824f, 0.01367441f, 0.04966538f, -0.04698890f, 0.01140271f, 0.26756930f, 0.24479656f, 0.07519868f, 
    -0.02379502f, 0.01868960f, -0.12920094f, 0.02010912f, -0.05709588f, -0.00373632f, 0.06655388f, -0.09844629f, 
    0.18482383f, 0.23839274f, 0.37644789f, 0.12051880f, -0.02253533f, 0.08691268f, 0.11726014f, -0.18742186f, 
    0.01709866f, 0.00756605f, -0.05117230f, 0.05617658f, -0.06867614f, -0.15221989f, 0.21619934f, -0.03110095f, 
    0.09753017f, -0.23512772f, -0.04320879f, -0.09362692f, -0.14814012f, 0.17753564f, 0.07404625f, 0.07685211f, 
    -0.05802330f, -0.13692419f, -0.14864971f, 0.09708209f, 0.06213192f, -0.03677880f, -0.15853338f, -0.00749345f, 
    0.02173083f, -0.04611530f, -0.11624434f, 0.12783347f, 0.06312174f, -0.08079141f, 0.01200336f, -0.13622075f, 
    0.09361532f, 0.03304331f, -0.02701672f, 0.15704016f, -0.14389090f, 0.07955031f, -0.13294004f, 0.03046028f, 
    0.20698485f, -0.18383001f, 0.17458448f, 0.09811752f, 0.03086786f, 0.06033331f, -0.03636554f, 0.08757650f, 
    0.20701094f, 0.10993909f, 0.11857239f, 0.16659796f, -0.04622338f, 0.12320623f, 0.07312091f, 0.04532834f, 
    0.13154966f, -0.10162767f, 0.02617135f, -0.01813807f, -0.08581541f, -0.03606529f, 0.03746399f, 0.21042648f, 
    -0.02932944f, -0.16063020f, 0.06073788f, -0.16660683f, 0.00949370f, -0.05974517f, -0.09997563f, 0.15736067f, 
    0.12074565f, -0.05565276f, 0.02354555f, -0.08342425f, 0.18915541f, -0.28322196f, -0.28147486f, -0.16661176f, 
    0.07404948f, 0.23952697f, -0.08741664f, 0.19802035f, 0.09760006f, -0.23339252f, -0.11468730f, -0.28416568f, 
    0.01046067f, 0.13046741f, -0.28805882f, 0.07717234f, 0.06153474f, 0.05002448f, 0.07438265f, -0.07523996f, 
    -0.22471298f, -0.13827829f, -0.12536533f, -0.08476780f, -0.01583911f, 0.01041995f, -0.05475646f, -0.23885392f, 
    0.07587899f, -0.02865219f, 0.08569293f, 0.06671271f, -0.02108197f, 0.01642073f, -0.09173705f, 0.11041379f, 
    0.22944719f, 0.21753404f, 0.21390004f, -0.25826213f, -0.08609571f, 0.05864549f, -0.04997331f, -0.03973522f, 
    0.02323863f, -0.21181716f, -0.17162089f, -0.11339614f, 0.44069326f, -0.03583571f, -0.29101855f, -0.38681948f, 
    0.12635909f, 0.08203819f, -0.02930746f, 0.12361016f, -0.00738353f, -0.00144679f, 0.08813345f, -0.06754238f, 
    -0.08581183f, 0.14321451f, -0.29530400f, 0.24000803f, 0.11712609f, 0.10241078f, -0.03498133f, 0.02932538f, 
    0.14810255f, -0.03249812f, 0.05256409f, -0.00204304f, -0.02457912f, -0.17057088f, 0.02081992f, -0.04143558f, 
    0.11727472f, -0.06217269f, 0.18512303f, 0.11772427f, 0.19751438f, -0.03491057f, 0.13486946f, 0.10058709f, 
    0.24467723f, 0.03861063f, 0.31688869f, -0.11615850f, -0.08411708f, 0.09601905f, 0.05311041f, 0.05166695f, 
    0.03298292f, -0.05353700f, 0.03666110f, 0.16185580f, 0.34052357f, -0.24729845f, 0.02516671f, 0.02445936f, 
    -0.10985392f, -0.16738439f, 0.13343561f, 0.26084262f, 0.02571806f, -0.07741162f, 0.03779437f, 0.12457789f, 
    0.00125151f, 0.12045725f, -0.18428972f, -0.26390839f, -0.01996731f, -0.08413879f, 0.06509863f, 0.14699864f, 
    0.08233211f, 0.00213326f, 0.09526913f, 0.11349186f, 0.38097376f, 0.31121686f, -0.23833731f, -0.02769460f, 
    -0.03502723f, 0.06878246f, 0.10859465f, 0.11065926f, -0.02503688f, -0.13466245f, 0.10682496f, -0.11484637f, 
    0.11530538f, -0.21606344f, 0.30997527f, 0.20548494f, 0.00957940f, 0.14741352f, -0.02080489f, 0.06268331f, 
    0.11438666f, 0.05986241f, 0.05840966f, -0.12933441f, 0.17415622f, 0.06686032f, -0.22588117f, -0.23922077f, 
    0.03936621f, -0.11813205f, 0.06840358f, -0.04788510f, -0.28248608f, -0.29530898f, -0.25592297f, -0.16381846f, 
    0.05771912f, -0.10565265f, -0.09491242f, -0.25861898f, 0.04223869f, 0.03269655f, -0.06471231f, 0.06953800f, 
    0.11270471f, -0.17711085f, -0.00026611f, 0.01357951f, -0.10301523f, -0.03306373f, 0.11413158f, -0.03885508f, 
    0.06213012f, -0.02367586f, 0.00225933f, 0.20604570f, 0.15194650f, 0.01883550f, 0.09296619f, 0.08707409f, 
    -0.34658819f, -0.08487030f, -0.02857511f, -0.16387968f, -0.04315836f, 0.17687456f, -0.11022975f, 0.22083347f, 
    0.16314125f, -0.09158678f, 0.02454790f, -0.19987522f, -0.05312452f, -0.03432919f, -0.04891837f, 0.16541724f, 
    0.11437324f, 0.17627232f, -0.01057800f, 0.13372421f, 0.01647351f, 0.07574496f, 0.17431997f, -0.01015705f, 
    0.17746498f, 0.02743400f, 0.06335209f, 0.14240451f, -0.04354426f, -0.07880983f, 0.00717803f, -0.02644335f, 
    0.01926361f, -0.01953910f, 0.07562092f, 0.09536599f, -0.26884389f, 0.32972920f, 0.16347292f, 0.24356027f, 
    0.23088031f, 0.01715760f, -0.06515252f, -0.00351527f, 0.05626354f, 0.04893232f, 0.03620759f, -0.04719423f, 
    -0.06812599f, -0.06939209f, 0.02193855f, 0.09529074f, 0.00314139f, 0.00049329f, -0.00957618f, -0.16545771f, 
    -0.00771704f, 0.08913080f, -0.04396138f, -0.03454418f, 0.08865416f, 0.18869717f, -0.17425691f, -0.17372975f, 
    0.09430803f, -0.05750749f, 0.02134831f, 0.04672994f, -0.04784060f, -0.03135924f, 0.03244345f, -0.02027568f, 
    -0.04325549f, -0.05743772f, 0.10172813f, 0.16805346f, -0.01566896f, -0.08258807f, -0.05537917f, -0.01998255f, 
    -0.06805701f, 0.06771128f, 0.05550568f, 0.18187329f, 0.14597481f, 0.10596675f, 0.11796241f, 0.09125219f, 
    -0.04343515f, -0.04737725f, -0.01412560f, -0.11509126f, -0.23779278f, -0.12673765f, -0.04897095f, -0.10036217f, 
    0.22598815f, -0.00593987f, 0.27140653f, 0.23879263f, -0.10620511f, 0.08689141f, 0.08108629f, 0.21351728f, 
    -0.16090380f, 0.06216951f, 0.11296200f, 0.21272033f, 0.13792832f, 0.03971607f, -0.00570564f, 0.07587068f, 
    -0.09176756f, -0.02971463f, 0.00899693f, 0.12045428f, 0.12184840f, -0.01801251f, -0.03220303f, 0.22344172f, 
    -0.32829240f, 0.12887560f, -0.12692994f, -0.10246777f, 0.01165983f, 0.01208593f, 0.11395293f, 0.19529317f, 
    0.05851077f, -0.12453986f, -0.14732605f, -0.12017389f, -0.17551479f, 0.17616887f, 0.03162134f, -0.13059586f, 
    0.00620151f, -0.16673978f, -0.02488684f, -0.11412558f, 0.01422133f, -0.08290646f, -0.02206746f, 0.02713616f, 
    -0.14666519f, -0.09490858f, 0.16667295f, 0.08235242f, -0.00522594f, 0.06449234f, 0.16127840f, 0.15806894f, 
    -0.07307287f, -0.03566204f, 0.10251376f, -0.11455464f, -0.07466432f, -0.13167089f, -0.04641944f, -0.01563819f, 
    0.08804964f, 0.13866787f, 0.15089674f, -0.01459449f, 0.05708125f, 0.07883367f, -0.06022533f, -0.01812636f, 
    -0.02107531f, 0.00582617f, -0.05581227f, -0.13473658f, 0.13257423f, 0.06428298f, 0.03081498f, -0.00782483f, 
    0.00941859f, 0.11636797f, 0.08449905f, 0.02788695f, 0.22630626f, -0.05055957f, 0.12868269f, -0.02478193f, 
    -0.08544891f, -0.02565630f, -0.21307448f, -0.11731366f, -0.16406205f, -0.07384075f, 0.12114146f, 0.02774308f, 
    -0.21446738f, 0.03139931f, -0.01139155f, 0.06224874f, 0.08217322f, -0.14576623f, 0.08183104f, -0.00398869f, 
    -0.03233736f, 0.16281423f, 0.00992208f, 0.08465146f, 0.00075685f, -0.04274124f, -0.04181441f, 0.04505070f, 
    0.00374896f, 0.07701132f, -0.01580735f, 0.04285975f, 0.11052398f, 0.04293072f, -0.08315071f, -0.06730992f, 
    -0.27599564f, -0.05315305f, 0.18392912f, 0.03321901f, 0.02855781f, 0.14581408f, 0.01983029f, 0.02507966f, 
    -0.02711544f, -0.07037257f, 0.10090324f, -0.09506172f, 0.01266109f, -0.07253232f, 0.09161483f, -0.08689800f, 
    0.03829649f, 0.00625508f, 0.09974430f, 0.03404341f, 0.02835443f, -0.10499943f, 0.05854114f, 0.05928962f, 
    0.05370627f, -0.03932038f, -0.26575243f, -0.20170894f, 0.09600814f, 0.15558600f, -0.02323704f, -0.09751696f, 
    -0.10394417f, -0.07189320f, -0.08803920f, -0.07860284f, -0.13330112f, 0.01371707f, 0.25895470f, 0.23448575f, 
    -0.06214880f, 0.00445906f, 0.03146902f, 0.09389452f, 0.10878596f, -0.11543133f, 0.00090094f, 0.02125779f, 
    0.02207913f, -0.21017550f, -0.06332314f, -0.14115860f, 0.05719798f, -0.03400230f, -0.28539076f, 0.08285078f, 
    -0.07121284f, -0.09544848f, -0.07771968f, 0.05212113f, 0.01965842f, 0.01400668f, 0.08944422f, 0.03231093f, 
    0.00818519f, 0.10181326f, -0.12964560f, -0.05853717f, -0.06101691f, -0.11897209f, -0.01624700f, -0.02970210f, 
    0.17521228f, -0.20873185f, 0.02009008f, -0.04440933f, 0.00868704f, 0.11625415f, 0.11522021f, -0.12838534f, 
    0.05499573f, -0.00595368f, 0.01581953f, -0.05858061f, -0.03988848f, 0.06513000f, 0.12851402f, -0.04846050f, 
    0.06578407f, -0.02199118f, -0.02064337f, -0.06749919f, 0.10546146f, -0.19000076f, 0.04510335f, 0.06889767f, 
    0.06338684f, -0.07662193f, -0.10291321f, 0.04466613f, -0.09316286f, 0.09214460f, -0.10116664f, -0.11504888f, 
    -0.07902700f, -0.01778945f, 0.05478405f, 0.09563206f, -0.12905316f, -0.17218457f, 0.23107423f, -0.12245013f, 
    0.00539494f, 0.05852107f, -0.15349360f, 0.11727123f, 0.09552035f, 0.06457210f, 0.01870629f, 0.01864740f, 
    0.39023387f, 0.15066314f, 0.02989780f, -0.09594130f, 0.20817666f, -0.07531351f, 0.02309202f, 0.13548204f, 
    0.04831458f, 0.14343749f, -0.01792485f, 0.03228993f, -0.10646960f, -0.00533845f, -0.09986687f, -0.08463299f, 
    0.15031385f, -0.08300299f, 0.05794720f, 0.07008360f, -0.06583606f, -0.02745289f, -0.05861766f, -0.10296349f, 
    0.61449540f, 0.14415659f, -0.03052188f, 0.39517486f, -0.03822108f, -0.06170683f, 0.05118429f, -0.29323322f, 
    0.17877953f, 0.04299112f, 0.02546786f, 0.09177399f, 0.18531391f, 0.11745174f, 0.18399772f, 0.38162294f, 
    0.00280349f, 0.05738876f, 0.11523679f, 0.07878576f, -0.08923721f, 0.10821828f, -0.01142764f, -0.17270678f, 
    0.36841166f, -0.18909517f, -0.11497455f, -0.10762988f, -0.26739585f, -0.25694716f, -0.00714233f, -0.36587894f, 
    -0.01148341f, 0.12987448f, -0.07818891f, 0.06028197f, -0.04959935f, 0.07097668f, 0.34835052f, -0.16870290f, 
    0.10472651f, -0.17919733f, -0.20449330f, -0.25962752f, -0.27805439f, -0.08146072f, -0.24330191f, -0.45225292f, 
    -0.00196117f, 0.10009234f, -0.00961070f, 0.09718776f, 0.02517973f, -0.02310497f, 0.18985815f, -0.02849428f, 
    -0.07601391f, -0.15398604f, -0.15514006f, 0.05495628f, 0.25558615f, -0.32561246f, -0.42391935f, -0.10823161f, 
    -0.01860299f, -0.18958932f, 0.23878397f, 0.18011329f, -0.10851692f, 0.00804296f, -0.13396943f, 0.06764903f, 
    0.19602317f, 0.14846909f, -0.16357543f, -0.17546952f, 0.00970817f, 0.23714571f, 0.11812954f, 0.35605794f, 
    -0.10052797f, -0.02070667f, -0.07205904f, -0.11617081f, 0.37322149f, 0.15459915f, 0.17328617f, 0.08405725f, 
    0.05817694f, 0.00011572f, -0.03861076f, 0.11673863f, 0.07935196f, -0.01041520f, 0.06621668f, 0.06639009f, 
    0.00187565f, 0.32667565f, -0.17119434f, 0.17228012f, 0.06171532f, 0.10497630f, 0.19778284f, 0.18518364f, 
    0.06770951f, 0.06289834f, -0.09086578f, 0.05872997f, 0.01089217f, 0.22281188f, 0.24564964f, 0.21955930f, 
    0.11607984f, 0.09710257f, 0.06640939f, 0.15137613f, -0.10694303f, 0.15253723f, -0.00577255f, -0.03884519f, 
    0.06778292f, 0.17359632f, -0.03140307f, -0.02391372f, 0.03540629f, -0.12073831f, -0.06852945f, -0.26920232f, 
    -0.05998423f, 0.01532179f, -0.12080505f, -0.23198037f, 0.02429411f, 0.02740757f, 0.31728151f, -0.03716650f, 
    -0.13755360f, -0.30904862f, 0.07493011f, -0.51345843f, 0.03597359f, 0.11767550f, 0.00022229f, -0.02099983f, 
    0.17755489f, -0.29651549f, -0.00551247f, -0.18338156f, -0.09995230f, 0.04930824f, -0.07236109f, -0.12639415f, 
    0.20652618f, 0.09324441f, 0.07158259f, 0.11436078f, 0.24851920f, 0.27914840f, 0.06295331f, 0.09670106f, 
    0.00242662f, 0.21396598f, 0.15246876f, 0.19470437f, -0.11369401f, -0.13455233f, -0.16015786f, -0.03152377f, 
    0.37778836f, 0.19321144f, -0.29299170f, -0.31042796f, 0.24756932f, 0.11961197f, -0.04573776f, -0.06431571f, 
    0.00697275f, 0.04100300f, -0.01785254f, -0.13394159f, 0.13559927f, -0.08195645f, -0.11407002f, -0.17701140f, 
    -0.11498353f, -0.03025057f, -0.05572899f, -0.25236723f, -0.39890131f, -0.18225394f, -0.26555598f, -0.32725561f, 
    -0.00059814f, 0.00718195f, -0.03839239f, -0.11071094f, -0.05090829f, -0.02607251f, -0.02192043f, -0.12766373f, 
    0.02739048f, -0.14263257f, -0.14693694f, -0.06151123f, 0.07529150f, 0.25852716f, 0.12905836f, 0.16816723f, 
    0.00085068f, 0.10056466f, 0.07431801f, 0.06791945f, 0.13492116f, 0.19091778f, -0.18937215f, -0.14216563f, 
    0.02090916f, -0.18155596f, -0.10106174f, 0.04521312f, -0.09556971f, 0.13108757f, -0.17925963f, 0.13591836f, 
    0.16362293f, -0.04619555f, 0.12480537f, 0.08883344f, -0.02314599f, -0.07845375f, -0.03543512f, -0.10272214f, 
    0.08789607f, 0.10555364f, 0.09282367f, 0.00401558f, 0.03588152f, 0.07532483f, 0.01244859f, 0.20597664f, 
    -0.06650157f, -0.04796057f, -0.06975817f, 0.10625774f, -0.04323148f, 0.07673831f, -0.01085522f, -0.12712878f, 
    0.05843515f, 0.12310366f, -0.08622540f, -0.01184134f, 0.07524209f, 0.25738615f, 0.04168823f, 0.27951565f, 
    0.01739333f, 0.14292473f, 0.06159871f, 0.08824521f, 0.04763949f, -0.00720778f, 0.12124702f, 0.03654585f, 
    0.22367691f, 0.09927840f, 0.36276856f, 0.41376731f, 0.17243063f, 0.19892322f, -0.04601146f, 0.09491578f, 
    -0.00498817f, 0.05495883f, 0.10573103f, 0.04955687f, -0.07890476f, -0.22011752f, -0.18309872f, -0.07714809f, 
    0.06450071f, 0.07989433f, -0.02423817f, 0.12377042f, -0.10847978f, -0.04014580f, -0.03061114f, -0.05749516f, 
    0.19021557f, 0.15439567f, 0.54804337f, 0.32678679f, 0.15845297f, 0.02195863f, 0.02804728f, 0.04994953f, 
    -0.19164316f, 0.02136041f, 0.01292640f, -0.18738879f, -0.23320432f, -0.26985767f, -0.21773292f, -0.13494615f, 
    -0.12351068f, -0.18631965f, -0.11231671f, -0.14471163f, -0.10551763f, -0.06297820f, 0.11821486f, -0.10862100f, 
    -0.17946446f, -0.02370851f, -0.16850328f, -0.21526456f, 0.12500499f, 0.02149833f, -0.12346710f, 0.15350978f, 
    -0.07817601f, -0.01480806f, -0.00658431f, 0.18941857f, 0.10015181f, -0.11518341f, -0.27350020f, -0.01784941f, 
    0.00738939f, -0.09113853f, -0.06402169f, -0.09319421f, 0.01338168f, 0.08928054f, -0.04660463f, 0.00767193f, 
    0.15297358f, -0.06598266f, -0.18566369f, -0.03034001f, 0.12470438f, -0.19365810f, -0.05602799f, 0.21047908f, 
    0.14583875f, -0.11790489f, -0.06134361f, -0.11988511f, -0.17992121f, 0.03518620f, -0.10819697f, 0.00258553f, 
    -0.01862006f, -0.02900150f, 0.10140507f, 0.11931323f, 0.05526884f, -0.06423040f, 0.11469423f, -0.03595784f, 
    -0.20608544f, 0.25976360f, 0.11262292f, -0.05235298f, -0.12350108f, 0.16028982f, 0.07498750f, -0.06534630f, 
    -0.09420229f, -0.04035189f, 0.08885950f, -0.04091090f, -0.04805144f, -0.05344962f, 0.06685310f, 0.20506863f, 
    0.03581662f, 0.10240100f, 0.13003738f, 0.11214750f, 0.26997516f, 0.13211955f, 0.33097443f, 0.08429441f, 
    -0.00190235f, -0.04233322f, -0.03468328f, -0.01303276f, -0.04263545f, 0.02202510f, -0.04757096f, -0.03395890f, 
    -0.05322409f, 0.04971912f, 0.05962614f, -0.00397449f, 0.05504209f, -0.01271062f, -0.05600750f, 0.06246583f, 
    -0.00573945f, -0.00327475f, -0.02523298f, -0.06313520f, -0.02907107f, 0.03990666f, -0.04567586f, -0.04990596f, 
    -0.01793275f, -0.02780226f, -0.07847673f, -0.08581598f, -0.03940456f, 0.00456501f, -0.02385406f, 0.01456543f, 
    0.01569195f, -0.10135163f, -0.03957007f, -0.04719069f, -0.03838861f, 0.03087627f, -0.10131354f, -0.06384429f, 
    -0.09801055f, -0.06144004f, -0.00155904f, -0.09634524f, -0.00107145f, 0.03498092f, -0.05823949f, 0.01883434f, 
    -0.08220802f, -0.05016136f, -0.09556411f, -0.04081867f, 0.06939396f, -0.03990158f, -0.08092655f, -0.02510806f, 
    -0.00771294f, -0.08080906f, -0.09859546f, -0.04585256f, 0.00168628f, -0.01892104f, -0.08321007f, -0.07956894f, 
    -0.02708500f, 0.00718795f, -0.01661750f, -0.06898891f, -0.03400644f, -0.05551768f, -0.07290542f, -0.02402173f, 
    -0.05960992f, -0.03175001f, -0.07775564f, 0.04008836f, -0.03335333f, 0.00295411f, -0.01401769f, 0.02781754f, 
    -0.07107044f, -0.02276137f, 0.04839958f, -0.04138680f, -0.06512380f, -0.03428360f, -0.03360768f, -0.02503311f, 
    -0.01130475f, 0.06641605f, 0.03905666f, -0.02510031f, 0.01884521f, 0.02879009f, -0.00751383f, -0.04230424f, 
    -0.07061472f, 0.02347710f, 0.01451018f, -0.10163543f, 0.01757431f, -0.05440565f, -0.04198239f, -0.04436798f, 
    -0.03762343f, -0.06179577f, -0.00850069f, -0.03332158f, -0.05629728f, -0.06011899f, -0.06402941f, 0.03628663f, 
    0.00344752f, -0.01501701f, -0.09120113f, 0.00830140f, -0.10118775f, -0.03672167f, -0.06731173f, 0.00887742f, 
    0.02572055f, -0.08587275f, -0.07521363f, 0.00073637f, -0.05356169f, 0.03284237f, -0.00939293f, -0.04232873f, 
    0.03869106f, -0.01173143f, -0.01333564f, -0.00003981f, -0.08269223f, -0.04741247f, -0.02957188f, 0.02231386f, 
    -0.10079281f, -0.09708828f, -0.02608558f, -0.08636705f, -0.08054043f, 0.00513197f, -0.08298430f, -0.01651219f, 
    -0.07009426f, -0.04264241f, -0.10314132f, 0.02058760f, -0.03859485f, -0.07830808f, 0.00831507f, 0.03164871f, 
    0.00621223f, -0.03104993f, -0.02075871f, 0.04201873f, -0.05971926f, -0.06438185f, -0.04514565f, -0.04581356f, 
    0.03181628f, -0.02054751f, -0.00899797f, 0.02478080f, -0.04064519f, -0.01666320f, -0.05065481f, -0.03577813f, 
    -0.07989478f, 0.03905282f, -0.07269780f, 0.01629580f, -0.01211098f, -0.03982169f, -0.05321800f, -0.01686734f, 
    -0.03205289f, 0.01512581f, -0.05562000f, -0.08266060f, -0.01652264f, 0.00687139f, -0.07953758f, -0.02073043f, 
    -0.09596974f, -0.02042475f, -0.02036501f, -0.04224327f, -0.05466866f, -0.03345349f, -0.10074904f, 0.01778179f, 
    0.05877151f, -0.00558740f, -0.06956227f, -0.03582683f, -0.03708835f, -0.06435465f, 0.03054425f, 0.00107423f, 
    0.00071926f, -0.06371707f, 0.04260791f, -0.04737280f, 0.01833125f, 0.02937112f, -0.04320351f, 0.00528655f, 
    -0.02548554f, 0.06049724f, -0.02246165f, -0.05643907f, -0.04147122f, 0.03601422f, 0.03766824f, -0.00099897f, 
    -0.00868936f, -0.02733995f, -0.01558570f, -0.02099345f, -0.03593943f, 0.04326455f, 0.03797771f, -0.04868514f, 
    0.04183308f, 0.05282861f, 0.04521000f, -0.03651970f, -0.05170986f, -0.01145485f, 0.02866498f, -0.02049573f, 
    -0.05915581f, 0.05370769f, 0.00385960f, 0.06321158f, -0.03589503f, -0.06885716f, -0.06938104f, -0.01809352f, 
    0.04551195f, -0.01838256f, -0.06694067f, 0.04440594f, 0.05595658f, 0.01780888f, -0.02971865f, -0.04465929f, 
    0.00373266f, 0.03989637f, -0.07422440f, -0.01323837f, -0.06638486f, -0.05490303f, -0.00559877f, -0.07275531f, 
    -0.02976656f, -0.07346396f, -0.07264940f, -0.04910083f, 0.05085196f, -0.07578281f, 0.03955853f, 0.01429333f, 
    -0.06270864f, -0.01821282f, -0.00670430f, -0.06604812f, -0.02623878f, 0.04903040f, 0.00219115f, -0.06976210f, 
    0.06051087f, -0.05670159f, -0.01339755f, -0.06344730f, -0.06415772f, 0.00169364f, -0.01440032f, -0.03359204f, 
    -0.04761725f, -0.04371890f, -0.06652015f, 0.04729636f, -0.03922277f, -0.02491155f, 0.03045315f, -0.01408586f, 
    0.01357632f, -0.05599919f, 0.00402783f, 0.01529346f, -0.05228994f, 0.04169046f, 0.06234938f, -0.02125921f, 
    -0.06028131f, -0.01041866f, 0.05626995f, 0.03749861f, -0.06693254f, 0.02668213f, 0.06847400f, 0.05655256f, 
    -0.04681383f, 0.05732451f, 0.04163276f, -0.06327645f, -0.06887075f, 0.05175363f, 0.03986347f, 0.01730872f, 
    -0.06451521f, 0.02260196f, -0.06835114f, -0.03566490f, -0.00273922f, -0.06606676f, -0.04435379f, 0.03234268f, 
    -0.05162363f, 0.00802604f, 0.00224558f, -0.03316167f, -0.05548707f, -0.02952596f, -0.00119041f, 0.05502131f, 
    0.05105377f, 0.06430676f, 0.01212357f, -0.05917436f, 0.06228919f, -0.07293627f, -0.05634279f, 0.00565727f, 
    0.04872379f, 0.01356088f, -0.06515500f, 0.05826048f, -0.07425427f, -0.00455838f, 0.01491546f, 0.00944959f, 
    0.00334050f, 0.05069695f, 0.03486712f, -0.03031813f, 0.05446598f, 0.06221931f, -0.01218872f, -0.07197849f, 
    -0.00215052f, 0.03568086f, -0.05668310f, 0.02414232f, 0.00438679f, 0.04418144f, -0.04048058f, 0.00730801f, 
    -0.06721688f, 0.00994786f, -0.02212336f, 0.01791716f, -0.01992685f, -0.02472552f, -0.04518916f, -0.01762025f, 
    -0.05808279f, -0.00112932f, 0.01177875f, -0.02427802f, -0.06312432f, 0.01756390f, -0.05967255f, -0.00553895f, 
    -0.06501441f, -0.02648944f, 0.00720380f, -0.04054324f, 0.05953537f, -0.01617669f, 0.03845436f, -0.02374616f, 
    0.06879617f, 0.05466690f, -0.01764390f, -0.20829816f, 0.09239813f, -0.00334755f, -0.13804802f, 0.02556071f, 
    -0.10146582f, 0.03292338f, -0.05483139f, -0.19788735f, 0.02837500f, 0.04091074f, -0.16510962f, 0.08142789f, 
    -0.08760429f, 0.11057659f, -0.09863356f, -0.04345515f, -0.04479817f, 0.06760322f, 0.04188998f, -0.14634845f, 
    -0.12091055f, 0.28987429f, 0.21925287f, -0.11090347f, 0.02554000f, -0.12345010f, -0.05856317f, 0.17910759f, 
    0.06226145f, 0.01098270f, 0.19166742f, 0.09949287f, -0.02604685f, -0.03127831f, 0.09173270f, -0.06094830f, 
    -0.10361566f, 0.03838441f, 0.02251702f, -0.06341206f, -0.04963075f, -0.06664791f, 0.06732132f, -0.09357513f, 
    0.03544678f, 0.15510769f, -0.05568318f, 0.04297933f, -0.14411515f, -0.11646533f, -0.04293203f, 0.03488497f, 
    0.00391809f, 0.22199839f, -0.16331427f, -0.02785857f, -0.12855485f, 0.09795928f, 0.20455459f, 0.09602182f, 
    -0.10553300f, -0.04556653f, 0.02256933f, 0.02764382f, -0.02312070f, 0.04099688f, 0.09830642f, 0.08608697f, 
    -0.12286702f, -0.04026099f, -0.06308533f, 0.02668239f, 0.12528367f, 0.04199054f, 0.04942998f, -0.10350949f, 
    0.11039895f, -0.00480749f, 0.04161644f, 0.00166951f, -0.22645803f, 0.04555655f, 0.12333810f, 0.25814345f, 
    -0.22151926f, -0.05184232f, -0.16204178f, 0.07645287f, -0.00317890f, 0.04437939f, 0.06034571f, -0.02732719f, 
    -0.11200742f, 0.39142057f, 0.10812639f, 0.16215205f, 0.15085459f, -0.02048071f, 0.02669410f, -0.05056036f, 
    -0.04721411f, -0.01622745f, -0.05591447f, -0.09063370f, -0.01481163f, -0.07349154f, -0.04646945f, -0.05642383f, 
    -0.15937424f, -0.16888982f, -0.05908200f, -0.07903789f, 0.11885314f, 0.07956431f, 0.08463448f, 0.05027303f, 
    -0.15525186f, -0.01632212f, -0.32475692f, 0.13360804f, -0.02322706f, -0.04079240f, -0.08764212f, 0.07446992f, 
    0.06745318f, 0.10994387f, 0.00484677f, -0.05486199f, -0.11978280f, -0.05085378f, -0.04310711f, -0.13334168f, 
    0.07607238f, -0.09651346f, -0.00658585f, -0.05896290f, 0.26200545f, -0.00610054f, 0.01438788f, 0.19994327f, 
    0.14266810f, -0.07665168f, 0.01417256f, 0.33838516f, -0.03025805f, -0.11985728f, 0.22246975f, -0.00207760f, 
    0.05082315f, -0.03558761f, -0.32020205f, 0.12394027f, -0.35297677f, -0.13473709f, 0.35050398f, 0.00262812f, 
    0.09596991f, 0.30535269f, -0.06535706f, 0.13157864f, 0.01777171f, -0.19994536f, 0.13548742f, 0.00656124f, 
    -0.26623851f, 0.06161293f, 0.26629606f, -0.02819685f, -0.09588533f, 0.12314280f, -0.02682368f, 0.20837578f, 
    -0.16468947f, -0.09594942f, 0.01058348f, 0.00512867f, 0.03826575f, 0.14409402f, 0.03931334f, -0.00907897f, 
    -0.01401964f, 0.00180894f, -0.00287525f, -0.06394801f, 0.28267077f, 0.05364690f, -0.04549542f, 0.00945754f, 
    -0.02266372f, -0.29057288f, -0.07733995f, 0.13988653f, -0.04028476f, 0.07254475f, 0.09017240f, 0.07277041f, 
    -0.00401513f, 0.17752673f, 0.28909332f, 0.19035776f, 0.02334335f, -0.08694317f, 0.22993997f, 0.18140547f, 
    0.17955486f, 0.02467238f, 0.10681864f, 0.02842246f, 0.02774712f, -0.08373218f, 0.01891807f, 0.16031472f, 
    0.27671987f, -0.34745765f, 0.11282118f, -0.04620740f, 0.00853209f, -0.07734869f, -0.06999536f, -0.01470999f, 
    -0.18419321f, -0.02379615f, 0.05629884f, 0.08708583f, 0.15433685f, -0.20605190f, -0.13136606f, -0.09467773f, 
    -0.04804734f, -0.21801528f, -0.01710167f, -0.04364328f, -0.05022918f, -0.06244834f, -0.22733517f, -0.15020874f, 
    -0.36875305f, -0.20386676f, -0.13995102f, -0.10097638f, 0.06955720f, -0.10878000f, 0.07529879f, -0.02110358f, 
    0.00165197f, -0.17370839f, 0.13435711f, -0.16458371f, 0.33684725f, -0.01365215f, 0.18925506f, -0.23758602f, 
    -0.07888170f, 0.12019902f, 0.10473064f, 0.02137442f, 0.01956665f, 0.00324800f, 0.07074841f, -0.00588074f, 
    0.40498886f, 0.27806243f, 0.31988418f, 0.06433990f, -0.21155205f, -0.01967314f, -0.05467290f, 0.09532359f, 
    0.13486409f, -0.01828074f, -0.02726780f, -0.00109277f, 0.27013376f, -0.08446157f, -0.27258682f, -0.17634861f, 
    0.03230945f, -0.13035782f, -0.04181861f, -0.12366405f, -0.02100056f, 0.09073550f, -0.04291914f, 0.06089239f, 
    0.19208159f, 0.38137820f, -0.20806117f, 0.23196530f, 0.09358550f, 0.10899993f, 0.10107710f, 0.11945351f, 
    0.06815483f, 0.08352442f, -0.05227539f, -0.03216483f, -0.32742760f, -0.20420164f, -0.21589886f, -0.01899632f, 
    0.13984108f, 0.13424204f, 0.07366440f, 0.03760028f, 0.03726828f, 0.07151412f, 0.01429122f, 0.00401231f, 
    0.14549841f, -0.40905109f, -0.21749140f, -0.37210166f, 0.05626090f, 0.03900636f, -0.00175752f, -0.16575955f, 
    -0.00463023f, -0.07412273f, -0.17767864f, 0.06370999f, -0.03876034f, -0.48199904f, -0.16143918f, -0.19229537f, 
    0.09525512f, -0.04092643f, 0.07356314f, 0.00243565f, 0.01246766f, 0.02930970f, -0.03846828f, 0.02135010f, 
    0.05919530f, 0.04943778f, 0.02130967f, -0.08034679f, 0.03527481f, -0.02616886f, 0.03322910f, 0.10105112f, 
    -0.12693228f, 0.13993222f, 0.17766975f, 0.14292116f, 0.46259621f, 0.27249032f, -0.22083235f, -0.32245159f, 
    -0.05252126f, 0.11861468f, -0.23387697f, -0.01305614f, -0.03886629f, 0.00176165f, 0.02829322f, -0.21117759f, 
    0.37048703f, 0.03854680f, 0.41284159f, 0.24552618f, -0.02096405f, 0.05599200f, 0.12346633f, 0.04072976f, 
    0.10386610f, 0.00140205f, 0.08111101f, 0.00425114f, 0.03666534f, -0.03328711f, -0.07657704f, -0.05247318f, 
    0.17478305f, -0.10070212f, -0.08934755f, -0.03046723f, -0.14084117f, -0.08484353f, -0.07516581f, -0.28405002f, 
    0.07368647f, -0.12019258f, 0.06036485f, 0.17048277f, 0.02720866f, -0.08128526f, -0.05983784f, -0.07969425f, 
    0.05101953f, 0.11547954f, 0.03197865f, 0.15076175f, -0.03370877f, 0.18790266f, 0.12326793f, 0.16142546f, 
    0.02259914f, 0.00194054f, 0.07466611f, -0.08592377f, -0.02570985f, -0.10684128f, -0.18125309f, 0.06969405f, 
    0.42339629f, 0.08971695f, 0.07465641f, 0.08684124f, -0.04547932f, 0.14514223f, -0.06329621f, 0.17946652f, 
    -0.04417796f, -0.07164004f, 0.03263586f, -0.04723545f, -0.17325485f, -0.00426594f, 0.10950553f, -0.10788766f, 
    0.01129651f, 0.05342261f, 0.12865838f, -0.04337159f, -0.00761669f, 0.02190791f, 0.04332827f, -0.08576842f, 
    -0.14199528f, -0.25738892f, -0.40775195f, 0.05060906f, -0.07935694f, -0.01282173f, 0.18954223f, 0.03547192f, 
    0.11001548f, -0.08002223f, 0.01283016f, -0.11924504f, 0.08857229f, 0.13088614f, 0.02219601f, 0.02449448f, 
    -0.05554182f, 0.13228031f, -0.04344114f, 0.16667067f, -0.03766607f, 0.02318387f, -0.13410407f, 0.03358057f, 
    0.23789728f, 0.34172210f, 0.28635490f, 0.28335238f, -0.15116517f, -0.08210532f, 0.08237172f, 0.20942560f, 
    0.09889344f, 0.00161062f, 0.08622252f, -0.11618945f, -0.09443296f, -0.04123167f, -0.24148668f, -0.15865223f, 
    -0.06376446f, -0.07750700f, -0.13995548f, 0.11405177f, 0.01226953f, 0.09129104f, 0.01431522f, -0.00963055f, 
    0.22831632f, 0.39238769f, 0.02091255f, 0.32765615f, 0.15602018f, 0.08403829f, 0.33015597f, -0.08392520f, 
    -0.00763875f, -0.13048474f, 0.09345695f, 0.00138153f, -0.28472200f, -0.36327803f, -0.18002655f, -0.12903963f, 
    -0.03496473f, -0.03660691f, 0.09895416f, 0.03710907f, 0.09329408f, 0.06158232f, 0.12500611f, 0.14531060f, 
    -0.22983176f, -0.11156563f, -0.23577635f, -0.26813793f, -0.04636568f, 0.04505678f, 0.03571932f, -0.05670273f, 
    0.02289295f, 0.06637194f, 0.07099726f, -0.01910329f, -0.19206508f, -0.44110069f, -0.28280979f, -0.14047663f, 
    0.00106030f, -0.00555317f, -0.00615823f, -0.00718899f, -0.04499409f, 0.01813352f, -0.13000201f, 0.03912289f, 
    0.14775138f, 0.16965503f, 0.30449763f, 0.07311695f, 0.03923668f, -0.09034458f, 0.06756441f, 0.02539018f, 
    -0.00482289f, -0.03520554f, -0.07795200f, 0.10776116f, 0.37356707f, 0.17255194f, 0.00120361f, 0.29677522f, 
    0.08808749f, 0.23674472f, 0.22056672f, 0.10856816f, -0.06217283f, 0.00286611f, 0.21857297f, -0.04616106f, 
    0.08203527f, -0.10352597f, 0.22402310f, 0.36952022f, -0.06092695f, 0.08376744f, -0.17176053f, 0.01181105f, 
    0.02352313f, -0.05506426f, -0.01503555f, -0.01591755f, 0.14137174f, 0.03779835f, 0.08411722f, 0.02167883f, 
    0.06086623f, 0.16773735f, 0.08151242f, 0.22325030f, -0.06215224f, -0.02834744f, -0.01975012f, -0.08748135f, 
    0.01843559f, 0.13712987f, -0.34494445f, -0.05017909f, 0.07324642f, -0.04128350f, 0.02671302f, -0.17368568f, 
    -0.08367486f, -0.09915702f, -0.10633877f, -0.08938452f, 0.12656900f, 0.13443470f, 0.07400702f, 0.13017319f, 
    0.00620020f, 0.08487854f, 0.00645449f, 0.00327201f, -0.07259104f, 0.05164777f, -0.01391950f, 0.01270467f, 
    0.19282162f, -0.17137237f, -0.33332157f, 0.10449314f, -0.07230178f, 0.01789284f, -0.05520605f, 0.15100951f, 
    -0.05827980f, 0.11006144f, 0.13082571f, -0.05586680f, -0.03863019f, 0.15065363f, 0.14930619f, 0.00253935f, 
    0.06602786f, -0.01906748f, -0.00888750f, -0.01022179f, -0.12970777f, -0.07697819f, -0.01511257f, 0.01999102f, 
    0.20299102f, -0.20930883f, 0.22893412f, 0.03976829f, -0.21522081f, 0.06066776f, 0.05538780f, -0.12022938f, 
    -0.01894537f, -0.08307050f, 0.04759883f, -0.11633664f, 0.22616202f, 0.05799313f, -0.06863850f, 0.26930717f, 
    0.07580899f, 0.07892834f, 0.02607081f, 0.18290156f, 0.02107154f, 0.02564962f, 0.04402363f, -0.00687009f, 
    0.00092735f, -0.02361887f, 0.06025621f, 0.32972711f, 0.04131398f, 0.11721130f, 0.03945600f, 0.08485049f, 
    -0.02848527f, 0.07733103f, 0.04199428f, 0.03400961f, 0.27707818f, 0.22699453f, 0.31903589f, 0.19164583f, 
    -0.26490402f, -0.07836623f, -0.15425551f, 0.14302267f, -0.02988182f, 0.00071259f, 0.09852785f, -0.02329304f, 
    0.12871854f, -0.17202343f, 0.34095439f, 0.04194634f, 0.00046318f, 0.01118508f, 0.02547012f, 0.15076908f, 
    -0.02071238f, -0.01346901f, 0.06786101f, 0.14906293f, 0.18203850f, 0.12604907f, 0.11918295f, -0.00718126f, 
    -0.17209391f, -0.21049124f, -0.12246845f, -0.00189864f, -0.22365128f, 0.04574905f, -0.00975509f, 0.00078638f, 
    0.18119471f, 0.21409544f, 0.00737457f, -0.12044859f, -0.04784980f, 0.02835714f, -0.11068862f, 0.03096586f, 
    0.02300411f, -0.01061759f, 0.06843471f, -0.12244087f, -0.05302300f, 0.04983273f, 0.03524027f, 0.10151978f, 
    -0.13100958f, -0.03135152f, -0.14409164f, -0.11909486f, -0.05682855f, -0.08834156f, 0.08524623f, -0.16818136f, 
    0.09895154f, -0.24293597f, -0.04797023f, -0.07115862f, 0.02477239f, -0.07775267f, 0.07141224f, -0.00186421f, 
    0.09712855f, -0.00450038f, -0.05397160f, 0.01991722f, -0.03435645f, -0.18594673f, 0.05775101f, 0.15157677f, 
    -0.10159931f, -0.05066917f, -0.02311316f, 0.19743358f, -0.01653849f, 0.14349256f, 0.06493856f, 0.10167937f, 
    -0.03209544f, 0.38192233f, -0.32262424f, 0.01059399f, 0.08168057f, 0.01268536f, 0.04113695f, -0.10651760f, 
    -0.08640771f, -0.04868654f, -0.00563220f, 0.02968779f, 0.10542031f, 0.01412703f, -0.03031588f, 0.05620720f, 
    -0.00914486f, 0.15964943f, 0.10166543f, 0.08238696f, 0.04493271f, 0.04032674f, -0.00586693f, 0.01481638f, 
    -0.25296661f, 0.34173054f, -0.02522968f, 0.01385160f, -0.05454456f, 0.02176048f, -0.12912835f, 0.05933409f, 
    -0.07937706f, -0.06889684f, 0.03946167f, -0.04636761f, 0.07828077f, 0.12380733f, 0.10430613f, -0.02698493f, 
    0.10228992f, -0.02510951f, 0.20124175f, 0.00461401f, -0.08918623f, 0.09526795f, 0.07330523f, 0.00076309f, 
    0.10094813f, 0.29293546f, -0.10885668f, 0.12441969f, -0.12197755f, -0.06621052f, 0.04414380f, 0.05967369f, 
    0.06331029f, 0.11834560f, 0.10089388f, -0.11171195f, 0.05401606f, 0.18469945f, -0.10503339f, -0.08293934f, 
    0.03089147f, 0.08793991f, 0.04316590f, 0.20577474f, -0.16151665f, -0.00500147f, -0.12544180f, -0.04909303f, 
    0.30800909f, -0.18376122f, 0.00286759f, -0.11519617f, -0.01337967f, 0.02542828f, 0.08269095f, -0.15134078f, 
    -0.09154315f, -0.06757694f, 0.09528656f, 0.02298413f, 0.21749631f, 0.20780203f, -0.13199835f, 0.08653154f, 
    0.12736055f, 0.14288621f, 0.09652644f, 0.15637793f, 0.00625561f, 0.11186785f, -0.00258239f, -0.01060021f, 
    -0.14356606f, 0.15564840f, -0.02063310f, -0.06179554f, -0.13719787f, -0.00278000f, -0.01656648f, -0.16780016f, 
    -0.09598400f, 0.01015999f, -0.09867388f, -0.03432985f, 0.51002920f, -0.10165045f, 0.01890224f, -0.06716481f, 
    0.11157698f, 0.03804368f, -0.01763656f, -0.01725021f, -0.07366961f, 0.00273860f, -0.10789228f, 0.01871394f, 
    -0.00384679f, -0.49777949f, 0.25001842f, -0.16213548f, -0.05130220f, 0.00895534f, -0.03656482f, 0.06092449f, 
    0.06403427f, 0.11732444f, -0.05450863f, 0.15311432f, 0.17374460f, 0.04845917f, 0.03927461f, 0.05333718f, 
    -0.14519934f, -0.14159203f, -0.03795762f, -0.08875828f, -0.19158921f, -0.04826482f, -0.08261207f, -0.12845218f, 
    0.19885649f, 0.28322577f, 0.07308076f, 0.07719725f, -0.08746020f, -0.05070381f, 0.01498904f, 0.04040634f, 
    -0.13402444f, -0.11319170f, 0.03978214f, 0.02310822f, 0.16070205f, 0.13098368f, 0.01675248f, 0.10541674f, 
    -0.04786808f, 0.01519686f, -0.10872206f, -0.01346952f, 0.01480798f, 0.07856803f, 0.02744958f, -0.13004264f, 
    0.12387016f, 0.19806126f, -0.03339199f, -0.40469185f, 0.11199682f, -0.00926726f, -0.06045308f, 0.12294337f, 
    0.03692384f, 0.05522422f, 0.04407981f, -0.21380824f, 0.14901184f, -0.20867442f, -0.30540118f, 0.06778637f, 
    0.06419228f, -0.14427145f, 0.07245865f, -0.17965204f, -0.02751531f, 0.09477986f, -0.04851981f, 0.11397022f, 
    -0.14716719f, 0.06949908f, -0.38879696f, 0.19728750f, 0.16142938f, 0.10236919f, 0.11438385f, 0.02248135f, 
    0.03299886f, 0.02854422f, 0.04132655f, -0.05117987f, 0.13310841f, -0.07493011f, -0.00386427f, -0.08268835f, 
    0.03413827f, 0.07795003f, 0.17579176f, 0.03126625f, 0.01755035f, -0.08927189f, -0.00564544f, -0.08392629f, 
    0.20728835f, 0.04329283f, -0.42791101f, -0.08891764f, -0.01626049f, 0.08692235f, 0.07958286f, -0.00657212f, 
    0.10306674f, 0.09139818f, 0.17553358f, 0.15518710f, 0.37557152f, 0.06789494f, 0.08149035f, 0.06097346f, 
    -0.05357060f, 0.16610028f, -0.06019201f, -0.02322549f, -0.15312709f, -0.04273229f, 0.08072937f, 0.03927705f, 
    -0.36744362f, -0.33273476f, -0.42869204f, -0.09827352f, 0.17016041f, 0.05980974f, 0.03146457f, -0.04088753f, 
    -0.13367963f, 0.03852076f, 0.00751564f, -0.00991325f, -0.11032799f, -0.17597395f, -0.08188666f, -0.03271268f, 
    0.02329374f, -0.01908384f, -0.13746922f, -0.16216376f, -0.24805525f, -0.02678746f, -0.12108386f, -0.40263566f, 
    0.18587551f, 0.05783414f, 0.19509023f, -0.03042847f, -0.09677427f, 0.04464307f, -0.08503796f, -0.14506136f, 
    -0.01437359f, -0.10118353f, 0.00299072f, -0.19640671f, -0.10608141f, -0.09510369f, 0.29662299f, 0.20327310f, 
    -0.05979386f, 0.06674893f, -0.02607261f, 0.11454408f, -0.04661832f, -0.16966808f, 0.13561241f, 0.11483650f, 
    0.35815275f, -0.08694398f, 0.08491297f, 0.10618415f, 0.24783508f, 0.26471955f, 0.13256781f, 0.11480862f, 
    0.03900546f, -0.08074524f, -0.11846253f, -0.13933207f, 0.16331212f, 0.46930072f, 0.14737168f, 0.18531477f, 
    -0.12769030f, -0.13395296f, -0.05594295f, 0.20154797f, 0.03831276f, 0.19685803f, 0.10411403f, -0.10465885f, 
    0.04639002f, 0.05728658f, -0.01306258f, 0.52333248f, 0.11839586f, -0.10757016f, -0.09188358f, 0.19864574f, 
    0.03069579f, -0.18278742f, 0.06649122f, 0.09115200f, 0.10685146f, -0.11000182f, 0.14227749f, 0.04408050f, 
    -0.17925499f, -0.05866508f, -0.01496333f, 0.06984611f, 0.18192314f, -0.04177050f, 0.05557178f, -0.14115354f, 
    0.23018432f, -0.04941008f, -0.02348020f, -0.22066160f, -0.13185094f, 0.04141421f, -0.14180200f, 0.05059658f, 
    0.04145283f, 0.09455919f, -0.20773186f, -0.03155912f, -0.15140200f, -0.01111698f, -0.03568320f, -0.03451621f, 
    0.07706216f, -0.00587433f, -0.11965413f, -0.13387288f, -0.10573949f, -0.07538664f, 0.14961804f, -0.04387020f, 
    -0.04349410f, -0.25716850f, -0.20467940f, 0.29015818f, -0.02468207f, 0.08503094f, 0.19232596f, -0.03496465f, 
    0.02716046f, 0.01091955f, 0.02584522f, 0.39884686f, -0.06004215f, 0.27243105f, 0.41196427f, 0.21202810f, 
    -0.00521241f, 0.27322245f, -0.21259098f, 0.30642316f, -0.06377136f, 0.13250169f, 0.14057665f, -0.15092471f, 
    0.34608188f, 0.20944586f, 0.15485406f, 0.05469497f, 0.04665833f, -0.00346249f, -0.12660988f, -0.03309415f, 
    -0.00539849f, -0.05568311f, 0.06691126f, -0.08244307f, 0.04205872f, 0.12056241f, -0.04253571f, -0.00227140f, 
    0.14199392f, 0.06287064f, -0.09959078f, -0.11009344f, -0.24340862f, -0.09698592f, -0.20104864f, -0.44095063f, 
    0.10938288f, 0.00296810f, 0.37269962f, 0.08151480f, -0.00372682f, -0.10688023f, -0.04436482f, -0.02605160f, 
    0.09125220f, -0.05038455f, 0.06986143f, 0.01696390f, -0.38649261f, -0.13266043f, -0.25471166f, 0.13898250f, 
    0.13076214f, 0.06758662f, 0.18340914f, -0.02746495f, 0.01087943f, 0.02334603f, 0.05497551f, 0.04413141f, 
    0.09417158f, 0.30812371f, 0.36818966f, -0.03214080f, -0.04394276f, -0.11291706f, -0.12150192f, -0.01531979f, 
    0.16038303f, 0.09150630f, -0.03132705f, 0.15976483f, 0.00567127f, -0.14760014f, 0.08736739f, -0.04843133f, 
    0.19233511f, -0.10732064f, 0.06953914f, -0.06263892f, 0.05040327f, -0.03533666f, 0.03662800f, 0.00269654f, 
    0.00445862f, 0.28429273f, -0.21268007f, -0.10754198f, -0.06238630f, -0.08676047f, 0.05005467f, -0.08524659f, 
    -0.00481759f, 0.02743641f, -0.15184195f, -0.01754359f, -0.16082057f, 0.11901012f, 0.03843741f, -0.01686480f, 
    0.15566050f, 0.03974257f, 0.04765744f, 0.01967786f, 0.06999211f, 0.04399417f, -0.06671136f, 0.05145027f, 
    -0.42469320f, -0.21557118f, 0.03071001f, 0.16374347f, -0.03699570f, -0.13180080f, 0.08769219f, 0.06184528f, 
    -0.01113066f, -0.04867077f, 0.02503531f, -0.07700086f, 0.04347380f, -0.11019878f, 0.06274487f, -0.14161469f, 
    0.01016567f, -0.00055690f, 0.12070032f, -0.00625123f, 0.06109605f, -0.06087944f, 0.00449637f, -0.05448685f, 
    -0.20889543f, 0.04796620f, -0.27093023f, 0.05666865f, 0.03544328f, -0.11544976f, 0.07374918f, -0.03028783f, 
    0.14984560f, 0.06281757f, -0.00324491f, 0.00006731f, 0.00194100f, -0.09497321f, -0.05275862f, -0.07502532f, 
    -0.02760192f, 0.02728785f, -0.08052853f, -0.14930958f, 0.14050575f, 0.04203558f, -0.09654163f, 0.02638676f, 
    -0.18880165f, 0.16412444f, -0.18797427f, 0.01100292f, 0.06410077f, -0.21129729f, 0.08872733f, -0.01584912f, 
    -0.02000962f, 0.01154906f, 0.07434523f, 0.08036619f, 0.10858402f, -0.04287117f, 0.06312592f, -0.05248356f, 
    -0.03886003f, -0.04668161f, -0.05596545f, -0.12952194f, 0.06892656f, -0.04024487f, -0.01570392f, 0.03135686f, 
    0.11898923f, 0.17709380f, 0.10104740f, 0.10538565f, -0.11394330f, -0.11556673f, 0.14105770f, -0.05023179f, 
    0.06896438f, 0.13426459f, 0.06540286f, -0.10821851f, -0.14433740f, -0.18398541f, 0.10257591f, -0.19036491f, 
    0.06560098f, -0.09705212f, 0.03349913f, -0.04745504f, 0.10204204f, -0.08555464f, -0.07559722f, -0.10777617f, 
    -0.20338929f, -0.49396166f, 0.24355203f, -0.00538858f, -0.08536137f, 0.03566865f, -0.14504369f, 0.05867052f, 
    -0.00638463f, -0.06264467f, -0.03658916f, 0.10228745f, -0.01066899f, -0.00065519f, -0.01031609f, -0.09437060f, 
    -0.03035148f, -0.06627598f, 0.09134850f, 0.05734283f, -0.03150078f, 0.04378938f, -0.04287025f, -0.07632883f, 
    0.05043734f, 0.12098099f, -0.23312622f, 0.09907853f, -0.04192951f, -0.11358235f, 0.01205122f, -0.11212146f, 
    0.04147261f, -0.07392361f, -0.08126323f, 0.05012325f, -0.07830632f, 0.09693307f, 0.00194027f, 0.11926995f, 
    -0.03960205f, 0.16456001f, -0.00838996f, 0.01433826f, -0.06902928f, 0.00484192f, -0.01281367f, -0.03576546f, 
    0.23082088f, 0.39797881f, 0.03660175f, 0.25174975f, -0.16589977f, 0.06925019f, -0.04414250f, -0.05669960f, 
    0.08103581f, 0.00351859f, -0.01977742f, -0.05230679f, -0.18046556f, 0.18024066f, 0.21243811f, 0.11980025f, 
    -0.17483404f, -0.06792763f, -0.04352431f, -0.05218631f, -0.26747474f, -0.02669967f, 0.14324975f, -0.03492659f, 
    0.30458125f, -0.43376124f, 0.29865918f, -0.13866684f, -0.09002193f, -0.07388987f, 0.00962134f, 0.18926752f, 
    0.05429466f, -0.02121207f, -0.02458421f, -0.14652520f, 0.00208110f, 0.21703537f, 0.03900215f, 0.40041724f, 
    0.03888263f, 0.11585457f, -0.16241464f, 0.19770977f, 0.04164977f, 0.08405369f, -0.15686953f, -0.10343862f, 
    -0.15057045f, 0.03928678f, 0.01519096f, 0.34894639f, -0.05900935f, -0.09679024f, 0.07411397f, 0.12054075f, 
    -0.00513647f, 0.21612750f, 0.05600008f, -0.02555361f, -0.01334910f, 0.44020694f, 0.30404210f, 0.09529438f, 
    -0.24801318f, -0.18659183f, -0.19470847f, -0.05759974f, 0.00952344f, 0.09608419f, 0.00467946f, -0.13248694f, 
    0.16915962f, -0.17243990f, 0.45534858f, 0.06449431f, 0.21187177f, 0.06934449f, 0.16453488f, 0.08617789f, 
    0.08156428f, -0.06748302f, 0.16806446f, 0.07672237f, 0.13391054f, 0.05942007f, 0.07306065f, -0.00113716f, 
    -0.29817125f, -0.27166298f, -0.02594424f, 0.02210469f, -0.15047814f, 0.03075295f, -0.09656344f, 0.05317059f, 
    -0.15352224f, 0.18461202f, -0.10900862f, 0.04139794f, -0.17796971f, 0.03493146f, -0.02400447f, -0.06929835f, 
    -0.02428442f, 0.03881513f, -0.04884036f, -0.07353856f, -0.27736402f, 0.10780690f, 0.01362926f, -0.04268020f, 
    -0.13026710f, 0.04191566f, -0.27861413f, -0.14205343f, -0.01092298f, 0.02525961f, -0.00691877f, -0.02499507f, 
    0.16688137f, 0.19110546f, 0.41296515f, 0.17559518f, 0.03432909f, 0.05253466f, 0.05468854f, -0.20545910f, 
    0.09467085f, 0.15208538f, -0.11307018f, 0.07422768f, -0.10325982f, -0.15239216f, 0.09992971f, 0.20556016f, 
    0.08323303f, -0.11824445f, 0.02844016f, -0.00456473f, -0.10341717f, -0.01229371f, 0.16414472f, 0.01481929f, 
    -0.23495965f, 0.06338806f, -0.28472155f, 0.17834076f, -0.02115266f, 0.01061081f, -0.07156049f, -0.03455207f, 
    -0.00170169f, -0.10033776f, -0.07089584f, -0.05672309f, 0.02026133f, -0.04760187f, 0.15214628f, -0.05467415f, 
    -0.05318477f, 0.19881137f, 0.02484112f, 0.23919803f, -0.02993932f, 0.05388084f, 0.01276078f, 0.00777918f, 
    -0.04663343f, 0.08048449f, -0.21145521f, -0.22065751f, -0.02487537f, -0.01273174f, -0.08186082f, -0.11155592f, 
    -0.02599968f, -0.13067475f, -0.15046835f, -0.21031721f, 0.34562090f, 0.14862823f, 0.03136266f, -0.01520186f, 
    0.11298386f, 0.06121252f, -0.07629970f, 0.15849186f, 0.09305652f, 0.05065127f, -0.04866043f, 0.05067125f, 
    -0.16395311f, -0.36413476f, -0.36317417f, 0.08267614f, 0.01584236f, 0.04130421f, 0.04191892f, 0.10631353f, 
    0.20972183f, 0.04258858f, 0.06627255f, 0.10124321f, -0.13605878f, 0.12354194f, -0.13713260f, -0.13577807f, 
    0.05341091f, 0.10492895f, -0.00332125f, -0.01098245f, 0.00955665f, 0.07994904f, -0.00035419f, 0.20372699f, 
    -0.31282923f, 0.09696205f, 0.09168867f, 0.33590847f, 0.07968900f, -0.05964029f, -0.04152537f, -0.06430399f, 
    -0.00297852f, -0.04386976f, -0.01854053f, 0.13731231f, 0.11002550f, -0.08951706f, -0.03255832f, 0.17008951f, 
    0.06326505f, 0.06662489f, 0.05787384f, -0.09092304f, -0.06340767f, -0.04245641f, 0.05039940f, -0.01821180f, 
    0.35813317f, -0.03963975f, 0.02902567f, 0.13435452f, 0.25577268f, 0.22028860f, 0.06296939f, 0.06283198f, 
    0.02572299f, 0.03976828f, -0.01388445f, -0.02244319f, -0.32397524f, 0.06409863f, -0.02756409f, 0.33192810f, 
    -0.01161603f, 0.03226065f, -0.05827006f, 0.12015147f, -0.08909306f, -0.07330363f, -0.12648682f, -0.13860473f, 
    0.18300389f, 0.27106515f, 0.37062082f, 0.02115973f, 0.03886388f, 0.04369085f, 0.07586892f, 0.11779217f, 
    -0.20079474f, 0.25302219f, 0.01465161f, -0.18580185f, -0.22034192f, 0.10027868f, -0.02455054f, -0.02216751f, 
    -0.12547465f, -0.01302379f, -0.06302491f, -0.08753604f, -0.09080920f, -0.08695792f, 0.04530403f, -0.03139147f, 
    -0.12211701f, -0.08784139f, 0.01534488f, -0.05221677f, 0.17684093f, 0.03080595f, -0.12752756f, 0.21992864f, 
    -0.08968113f, 0.04581099f, -0.05895471f, 0.02026994f, -0.09503483f, -0.05296099f, -0.15907848f, -0.00742480f, 
    0.00055070f, -0.00096785f, 0.00749227f, -0.13749208f, -0.00907553f, 0.02844921f, 0.01274346f, 0.10515784f, 
    0.02989165f, -0.41900361f, -0.38991690f, 0.17314751f, 0.03705441f, 0.12729186f, -0.09801897f, 0.25021249f, 
    0.10473379f, -0.00303842f, -0.06751118f, 0.00390277f, -0.28802019f, 0.22493467f, -0.00786639f, 0.25385094f, 
    0.07413451f, 0.02342682f, 0.06940512f, 0.09818119f, 0.02800221f, -0.04253408f, -0.04940666f, -0.04819760f, 
    0.03736904f, 0.62598366f, 0.07796626f, -0.28445318f, -0.04618767f, 0.03082296f, 0.18787898f, -0.03330182f, 
    -0.10534992f, -0.06319873f, -0.02581208f, -0.03651014f, -0.22847547f, -0.04412218f, 0.00435225f, 0.13412139f, 
    0.00590709f, 0.06472456f, 0.10342215f, -0.10924513f, 0.19768594f, 0.01721697f, 0.23077999f, -0.00872017f, 
    0.13469842f, -0.12419221f, 0.20496963f, 0.05013107f, 0.03273857f, -0.08934393f, -0.10381597f, 0.00235677f, 
    0.05297018f, 0.04158858f, 0.12570903f, 0.05428449f, -0.00820983f, 0.15127411f, 0.08401811f, 0.11425875f, 
    0.02166735f, 0.03754489f, 0.00322007f, -0.13385460f, 0.09394123f, -0.12230561f, -0.22034480f, 0.08508578f, 
    0.34042904f, -0.27312222f, 0.05235674f, -0.06928119f, -0.13201152f, -0.17059112f, -0.05768963f, -0.06689999f, 
    -0.01647865f, -0.07747632f, -0.00685489f, 0.05914335f, 0.19846739f, -0.01346087f, -0.02156400f, -0.15739980f, 
    0.02269746f, 0.04968422f, 0.03365345f, 0.10838953f, -0.05975388f, -0.19789857f, -0.10978696f, -0.02010589f, 
    0.06948271f, 0.06596500f, -0.24039823f, 0.14581141f, 0.11955582f, 0.06215574f, 0.03108322f, 0.00176185f, 
    0.01871506f, 0.06427300f, -0.11372174f, 0.01503643f, 0.08431320f, -0.21410720f, -0.19595301f, -0.11727621f, 
    -0.02660000f, -0.06098413f, -0.09502454f, -0.00553922f, 0.04716608f, 0.00806875f, -0.11961906f, -0.01838802f, 
    0.26153815f, 0.31134453f, 0.31346503f, 0.03249248f, -0.05535555f, -0.02541613f, 0.06370689f, 0.18412237f, 
    0.02383803f, 0.04612831f, 0.00364927f, -0.00926045f, 0.29311705f, 0.05104223f, -0.24696600f, -0.11744618f, 
    -0.01538079f, 0.13744067f, -0.13017544f, -0.14096874f, 0.00592563f, 0.05538131f, 0.09754780f, -0.03831240f, 
    0.07742251f, 0.32509214f, -0.15899208f, 0.39950496f, 0.02656686f, 0.00645484f, 0.12666744f, -0.06618473f, 
    0.02126460f, -0.08512045f, 0.05067230f, -0.09648636f, 0.14337702f, 0.07919053f, 0.02429320f, 0.12190639f, 
    0.04195200f, -0.00662442f, 0.08528800f, -0.04577295f, 0.17423142f, 0.24371037f, 0.12146029f, 0.00866147f, 
    0.00444918f, 0.01839971f, 0.05050756f, -0.01884745f, 0.01413248f, 0.01484845f, -0.00392671f, 0.01057655f, 
    0.02168966f, 0.04357497f, -0.00087733f, -0.03160294f, 0.34584659f, -0.06443787f, 0.03213686f, 0.02881611f, 
    0.00972651f, -0.07234622f, 0.08618020f, -0.01333120f, 0.01976482f, 0.09694858f, -0.01157447f, -0.08339541f, 
    0.00015700f, 0.04911789f, -0.16791454f, -0.20499887f, -0.04259320f, -0.35381287f, -0.07354280f, -0.07703018f, 
    0.03781818f, 0.00013043f, 0.07635203f, -0.08715554f, 0.25690490f, 0.10999514f, -0.22120319f, 0.16652295f, 
    0.13012482f, 0.09606931f, 0.16535202f, 0.06716353f, -0.01924910f, -0.17307280f, 0.13511413f, -0.00349616f, 
    0.03919271f, -0.26723352f, 0.03996702f, 0.16346878f, 0.00898671f, 0.05372855f, -0.16111405f, -0.07837733f, 
    -0.01666540f, -0.05380317f, -0.13143422f, 0.02342645f, 0.10804097f, 0.02193969f, -0.01557941f, 0.04370651f, 
    0.00906058f, 0.06424029f, 0.03253028f, -0.05901651f, -0.17655478f, -0.01804665f, -0.03081462f, -0.02159737f, 
    -0.00709878f, -0.07565024f, -0.01577549f, -0.02677356f, -0.02572497f, -0.06119391f, 0.02840833f, -0.02174341f, 
    0.05780676f, 0.04140954f, -0.01669477f, 0.00837997f, 0.03988327f, -0.04537062f, 0.03202712f, -0.00291079f, 
    -0.01483197f, 0.03808809f, -0.05755180f, -0.00684449f, 0.03726742f, 0.00233932f, -0.05671486f, 0.05153697f, 
    -0.01354916f, 0.03749771f, 0.00125237f, 0.02696411f, 0.04711521f, 0.02285746f, -0.06028917f, -0.07660531f, 
    -0.05509236f, 0.03146821f, -0.01596725f, -0.07652707f, 0.03009229f, 0.00488981f, -0.01660516f, -0.00649718f, 
    0.01562496f, 0.01975523f, 0.06358453f, -0.01739877f, -0.07725856f, 0.05755862f, -0.02470364f, 0.00953930f, 
    -0.01471808f, -0.04406628f, -0.06721976f, -0.03809604f, 0.01514171f, -0.07595772f, 0.04170391f, -0.06874306f, 
    -0.02393499f, -0.01598923f, -0.04510710f, -0.07635285f, 0.04083969f, -0.06632254f, -0.00383402f, 0.04341863f, 
    -0.04337813f, -0.01066358f, -0.04366785f, 0.06324732f, -0.07164571f, -0.02646163f, -0.04670502f, 0.01174501f, 
    -0.06837050f, 0.02446353f, -0.02855207f, 0.04475834f, -0.00106645f, -0.03853187f, 0.05645510f, 0.00056740f, 
    -0.00526786f, 0.03421724f, 0.04383654f, -0.05363449f, 0.04380493f, -0.05779200f, -0.06400793f, 0.05463449f, 
    0.03399299f, -0.06512910f, 0.05624470f, 0.01242522f, 0.00399365f, -0.05639389f, 0.02895763f, -0.07416415f, 
    -0.02372343f, -0.04172524f, -0.04622399f, 0.00134376f, -0.04977123f, 0.03201431f, 0.03411460f, 0.02058802f, 
    0.00351174f, -0.05473577f, 0.03673466f, 0.00073657f, 0.00394115f, 0.00146262f, -0.04010154f, 0.05208104f, 
    -0.00122051f, -0.03030145f, -0.01686282f, -0.07004451f, -0.00770729f, -0.00105999f, -0.05716641f, -0.01158410f, 
    0.05687528f, 0.03585676f, 0.02162740f, 0.06443906f, -0.04261579f, -0.02360779f, -0.04164317f, -0.07777165f, 
    -0.07799202f, -0.05002248f, 0.00437067f, 0.03400685f, -0.05119160f, 0.01217547f, 0.02083603f, -0.01984202f, 
    0.02963401f, 0.05899979f, 0.01364705f, -0.02591147f, 0.00548905f, 0.05160806f, 0.03531685f, -0.07628477f, 
    0.01086691f, -0.03608792f, 0.04548893f, 0.00197531f, 0.05463056f, 0.04509289f, 0.00773864f, -0.03463972f, 
    0.02464265f, 0.03877255f, 0.02684406f, -0.06638200f, 0.06018190f, 0.02582714f, -0.05768827f, 0.03690153f, 
    0.04673702f, 0.05237408f, 0.04555326f, 0.00728597f, -0.05303539f, 0.00867856f, 0.01844366f, 0.04115147f, 
    -0.03566689f, -0.03568955f, -0.04485048f, 0.01204900f, -0.01089286f, 0.03793130f, 0.00818251f, -0.05141644f, 
    -0.03866427f, -0.06673472f, 0.03732531f, -0.07125234f, -0.06908285f, -0.01919868f, -0.05497059f, 0.01523356f, 
    -0.06944481f, 0.00885474f, -0.05208048f, -0.05951944f, 0.04011820f, -0.07200063f, -0.00194936f, -0.01613238f, 
    -0.07326466f, -0.04535909f, -0.12636238f, -0.05987230f, -0.04351437f, -0.05330539f, -0.06632432f, -0.07449454f, 
    -0.01892196f, -0.04926665f, -0.09210822f, 0.03765303f, -0.21331006f, -0.11021781f, 0.19130209f, -0.02446330f, 
    0.08039416f, 0.06623194f, 0.02703408f, 0.09607127f, 0.16481726f, 0.05915937f, -0.00252394f, 0.12041210f, 
    0.04635720f, 0.11098783f, -0.05664777f, -0.05219685f, -0.13397671f, 0.12781636f, -0.10916479f, 0.06638871f, 
    0.19209170f, 0.01869043f, 0.01739434f, -0.05057813f, -0.10917675f, 0.08347023f, -0.00111051f, 0.00608123f, 
    -0.20714176f, -0.05069242f, -0.01683299f, -0.12050517f, -0.02253725f, 0.05148411f, 0.08420312f, 0.11826331f, 
    0.14500611f, -0.14605637f, 0.07984608f, -0.01526900f, 0.01101356f, -0.04173117f, -0.20506087f, -0.03484415f, 
    -0.06688051f, -0.07412358f, 0.05915640f, -0.05242503f, 0.03200608f, 0.23632503f, 0.09370615f, 0.12536761f, 
    0.14358450f, 0.28153855f, -0.01615831f, 0.06669153f, 0.01861146f, -0.05701591f, 0.03626245f, -0.14322333f, 
    -0.11492660f, -0.00852365f, 0.10345457f, 0.44201076f, -0.13074663f, 0.03289277f, 0.10683328f, 0.02405205f, 
    -0.07960520f, -0.02694732f, -0.03550373f, 0.14273679f, -0.05307989f, 0.12003626f, 0.08266506f, 0.07092593f, 
    -0.01756498f, -0.09276852f, -0.08618509f, -0.25832310f, -0.04416221f, -0.06265969f, -0.05022031f, 0.09504299f, 
    0.14808139f, -0.30813658f, 0.15064120f, -0.13136519f, 0.05664224f, 0.11680518f, 0.15415944f, 0.05915734f, 
    -0.05970335f, 0.02518336f, 0.04890954f, 0.24876259f, -0.02503928f, 0.04533239f, -0.08046882f, -0.02825237f, 
    -0.14117624f, -0.13017222f, -0.20160319f, -0.06289462f, -0.10515945f, -0.04556897f, -0.10966616f, 0.01828988f, 
    -0.12371252f, -0.15393089f, 0.02269066f, 0.13346909f, -0.07788399f, -0.02728979f, -0.13645169f, -0.12503056f, 
    -0.05793409f, -0.01949475f, 0.02863286f, -0.07799896f, -0.03213104f, 0.12042844f, -0.09187057f, 0.07407732f, 
    -0.12096333f, -0.08530098f, -0.14804523f, -0.01556872f, -0.10089590f, -0.02375754f, -0.06112554f, -0.05486728f, 
    -0.03161851f, 0.20320609f, 0.24611197f, -0.02562548f, 0.08345040f, 0.10542479f, 0.06545562f, 0.08248296f, 
    0.04454697f, 0.02864302f, 0.01177353f, -0.10077406f, -0.15897514f, 0.00811257f, -0.13519295f, -0.13985440f, 
    0.03681190f, -0.15236370f, -0.00042565f, -0.23029926f, -0.13749051f, 0.07347423f, -0.06893754f, -0.00113383f, 
    -0.27238819f, -0.08703791f, -0.06679137f, -0.05817099f, 0.03996612f, -0.09509750f, 0.05916559f, 0.15869461f, 
    0.04200366f, -0.04202608f, -0.11424487f, -0.01912922f, -0.21809335f, -0.20186682f, -0.01654454f, -0.01159659f, 
    0.13604811f, 0.18167549f, -0.06736103f, 0.04216716f, -0.04188341f, 0.05151020f, 0.11230197f, 0.04359002f, 
    -0.29264393f, 0.35759386f, -0.05032325f, -0.29122731f, -0.11514734f, 0.02252891f, -0.09408735f, 0.00053664f, 
    0.03618561f, 0.03293877f, 0.04119384f, -0.17802127f, 0.03570271f, -0.13252074f, -0.16467217f, -0.17238374f, 
    0.05068746f, -0.05441063f, 0.02344733f, 0.03535850f, 0.17546649f, 0.12538712f, 0.19820486f, 0.07960725f, 
    -0.24413884f, 0.31623372f, -0.01568180f, 0.15224607f, 0.03781569f, 0.01818711f, 0.05147301f, 0.04286401f, 
    0.12961631f, 0.21211143f, 0.13026175f, 0.23904710f, -0.03550896f, -0.03721144f, -0.05234171f, -0.02644781f, 
    -0.00430990f, -0.05972645f, -0.01056807f, -0.03398971f, 0.05333939f, 0.06165031f, 0.01251250f, -0.02716397f, 
    -0.39008135f, 0.14025414f, 0.27921483f, -0.05049941f, -0.08180719f, 0.04808539f, -0.05973687f, -0.20294471f, 
    -0.13822523f, 0.13835728f, 0.10402696f, 0.10290686f, -0.03319627f, 0.15395235f, 0.06503338f, 0.22543530f, 
    0.24494006f, 0.09101290f, 0.23157263f, -0.05687702f, -0.07036424f, -0.06841276f, 0.12953050f, 0.05968169f, 
    -0.37312603f, -0.35824209f, -0.23646165f, 0.14647716f, 0.14525019f, 0.00768742f, -0.01275652f, -0.09478059f, 
    -0.15959217f, -0.11635603f, -0.01712336f, -0.04482663f, -0.15774123f, -0.16497667f, 0.16465896f, 0.21393767f, 
    -0.10594712f, 0.01634567f, -0.00261559f, -0.07881033f, -0.08205204f, -0.12973325f, -0.09745988f, 0.06320655f, 
    -0.05959786f, -0.21996686f, 0.16571569f, -0.28106230f, -0.05157527f, -0.04880550f, 0.05550785f, 0.05347401f, 
    -0.15331014f, 0.06191837f, -0.01381794f, 0.15476112f, -0.24711990f, -0.03150178f, -0.11210921f, -0.34093416f, 
    -0.18504901f, -0.18875536f, -0.13478991f, -0.26414531f, -0.19105430f, -0.00603194f, -0.15536387f, -0.10497736f, 
    -0.05721387f, 0.00559158f, -0.13088806f, 0.04705745f, 0.21410866f, -0.12200417f, -0.04869799f, 0.09694361f, 
    0.02497354f, -0.00438123f, 0.11781385f, -0.12024984f, -0.23864461f, 0.16431786f, -0.00399038f, -0.04251261f, 
    -0.06197896f, -0.09401196f, -0.10693588f, -0.11040009f, 0.01768790f, 0.00261091f, 0.25693050f, 0.04085204f, 
    0.10015416f, -0.21956290f, -0.12611598f, 0.17112055f, 0.04151052f, 0.07160456f, 0.06711444f, 0.25047275f, 
    0.05893300f, 0.07775850f, 0.06404031f, 0.07266936f, -0.46919388f, -0.41009164f, 0.16809009f, -0.00476823f, 
    0.11293704f, -0.00356759f, -0.00853477f, -0.09261670f, 0.02236473f, -0.04000384f, -0.04737001f, 0.04955707f, 
    0.04581411f, 0.22220308f, -0.26770070f, 0.02314671f, 0.08091906f, 0.14468929f, 0.20124511f, 0.09001020f, 
    0.05038701f, 0.02037848f, -0.06703945f, -0.00278076f, -0.28448409f, 0.05515017f, 0.12559408f, 0.11949734f, 
    -0.01659540f, -0.03089621f, 0.06462368f, -0.02263555f, 0.02242064f, 0.12105569f, 0.18245819f, 0.08801777f, 
    0.13118045f, -0.10641187f, -0.34674767f, -0.10439708f, -0.13892540f, -0.06932253f, -0.02808603f, -0.04320190f, 
    -0.11063198f, -0.10297908f, -0.19495974f, -0.07746396f, 0.13581076f, 0.06532373f, 0.27206910f, -0.13177912f, 
    -0.08140460f, -0.08194081f, -0.13608569f, 0.06506659f, -0.10109897f, -0.09865638f, -0.00494881f, -0.09055054f, 
    0.03545848f, 0.03340188f, -0.21795067f, 0.09337129f, -0.08609778f, 0.26881677f, -0.06676389f, 0.05247810f, 
    -0.05828965f, -0.02274847f, -0.09419184f, -0.10214070f, -0.10067727f, 0.20569502f, 0.18487123f, 0.05927631f, 
    0.02497968f, 0.09815029f, -0.01405075f, -0.13552222f, -0.01057705f, -0.01025049f, 0.18853848f, 0.21453241f, 
    0.04035509f, -0.18792665f, 0.15947558f, 0.13797058f, -0.14911723f, 0.04061945f, -0.11863560f, 0.02372202f, 
    0.11593954f, -0.10293797f, 0.04781551f, -0.05424901f, 0.05442276f, 0.27778760f, 0.18229315f, 0.15402275f, 
    0.07450679f, 0.20864931f, -0.06318244f, 0.06508149f, -0.04687457f, -0.03424064f, -0.09349252f, -0.17921168f, 
    0.09128696f, -0.00633240f, -0.18763126f, 0.28646946f, 0.05147208f, 0.17994320f, -0.04233553f, 0.05708299f, 
    -0.10635255f, -0.05550340f, 0.03467697f, -0.04605328f, -0.16344747f, 0.14464302f, 0.21891683f, 0.12637720f, 
    -0.15221480f, -0.27189165f, -0.00780970f, 0.02487886f, -0.03152033f, 0.03243273f, 0.00871449f, -0.02803473f, 
    0.26563594f, -0.26698080f, 0.09574024f, 0.03325645f, 0.07167565f, 0.05505806f, 0.11982071f, 0.12672740f, 
    -0.02189282f, -0.15831274f, -0.12043916f, 0.13698918f, -0.08867199f, -0.03816244f, 0.18184714f, 0.05090402f, 
    -0.11641040f, -0.05203428f, -0.08468752f, 0.07721487f, -0.00266066f, -0.07158261f, -0.02948068f, 0.18530256f, 
    -0.03769051f, 0.16538469f, 0.06132659f, 0.07878881f, -0.06220810f, 0.07825311f, 0.05717251f, 0.01758843f, 
    0.06832470f, 0.11876600f, 0.03994727f, -0.08946653f, -0.19666550f, 0.09014089f, -0.10611957f, 0.03928211f, 
    -0.01576455f, 0.07907626f, 0.03404602f, 0.03776991f, -0.05023074f, 0.04942203f, 0.16623031f, -0.14887534f, 
    0.08067258f, -0.03424663f, 0.23563349f, 0.18486437f, -0.07127596f, 0.13787632f, 0.04011890f, 0.00171725f, 
    0.12541094f, -0.07611583f, -0.15945224f, 0.09933844f, -0.11582658f, -0.07886255f, 0.10729679f, 0.20220731f, 
    -0.08147755f, -0.35642523f, -0.06264748f, 0.06111323f, -0.13376610f, 0.15916839f, 0.10271911f, 0.08290476f, 
    0.37971559f, 0.46138355f, -0.16385844f, 0.03910738f, 0.13503656f, -0.09383792f, -0.09954481f, 0.00249262f, 
    -0.14880684f, -0.04920796f, -0.03523786f, -0.00793026f, 0.00143087f, 0.10538272f, 0.07098267f, 0.09330255f, 
    -0.01361343f, 0.12115894f, -0.09854373f, 0.06669646f, -0.09195350f, 0.08370375f, -0.01601389f, 0.01706055f, 
    -0.08442277f, -0.04104707f, 0.00855646f, 0.03464830f, 0.01206247f, 0.03326342f, 0.05363724f, -0.00022687f, 
    -0.00603991f, -0.06160107f, 0.06239060f, -0.03718376f, 0.00238180f, 0.03529320f, 0.03291774f, 0.02764418f, 
    -0.08785880f, -0.06829719f, -0.05050385f, -0.03662528f, -0.04642547f, -0.05643236f, 0.03719173f, 0.06360230f, 
    0.03262769f, 0.00453082f, -0.06086063f, 0.01825164f, -0.02444876f, -0.06745075f, 0.01065400f, -0.06326193f, 
    -0.05413783f, -0.00744844f, -0.06733892f, -0.01285007f, 0.04553114f, 0.01605148f, -0.03664083f, -0.02654581f, 
    0.02628646f, 0.00936351f, 0.02655005f, -0.01559772f, -0.02486603f, 0.04970340f, 0.02002601f, 0.03262663f, 
    -0.01604588f, 0.03113470f, -0.02245021f, -0.05591475f, 0.01976063f, 0.04899863f, -0.01642565f, 0.04553815f, 
    -0.05097834f, -0.04487199f, -0.01335674f, -0.06414187f, -0.03034992f, -0.06326877f, -0.07116091f, 0.03590835f, 
    0.05797840f, 0.00607188f, -0.00406331f, -0.01643419f, 0.00753391f, -0.03678118f, -0.06017331f, 0.01990798f, 
    0.04433333f, -0.04176946f, -0.05316671f, 0.06652820f, 0.03195398f, -0.07511760f, -0.05060723f, -0.00475083f, 
    -0.07492098f, -0.08224282f, 0.02701857f, -0.03230923f, -0.07041017f, 0.00009547f, -0.06799052f, 0.03274360f, 
    -0.06088614f, 0.04323329f, -0.00392923f, -0.06792864f, -0.05841117f, -0.02746106f, -0.02900152f, 0.06382492f, 
    -0.05175166f, -0.04039732f, -0.08127984f, -0.00402113f, -0.00060209f, -0.00679981f, -0.04897178f, -0.06367831f, 
    -0.05561435f, -0.03482969f, 0.03547826f, -0.04445475f, -0.03022070f, 0.00428184f, -0.07518434f, 0.01905705f, 
    0.02363517f, 0.01751808f, -0.07377481f, 0.02455630f, -0.02851016f, -0.04498400f, 0.06101379f, 0.05825975f, 
    0.01859303f, -0.03885306f, -0.03274820f, 0.02529402f, -0.03454306f, 0.00757334f, -0.06403873f, 0.01361124f, 
    -0.05954258f, 0.00740160f, -0.05341465f, 0.05203293f, 0.02288285f, 0.03819195f, 0.04546796f, -0.00802305f, 
    -0.02200752f, 0.00274093f, -0.05510321f, -0.00462315f, 0.06277666f, -0.03586966f, -0.00293185f, 0.05216561f, 
    -0.07872429f, 0.00190667f, -0.06085688f, 0.03475843f, 0.04396988f, -0.05301736f, -0.07204400f, -0.03074047f, 
    -0.03248429f, 0.04362857f, 0.03945835f, -0.01708165f, 0.02620610f, 0.04318167f, -0.00440270f, -0.08062746f, 
    -0.08543858f, -0.09042337f, -0.03857336f, -0.06436286f, -0.04885508f, -0.00186209f, -0.02042016f, -0.03431858f, 
    0.02219240f, 0.01324389f, 0.05250910f, -0.03485120f, -0.03908994f, 0.02920144f, -0.00200175f, 0.04488398f, 
    0.01516331f, 0.06036111f, 0.00384684f, 0.04120491f, 0.03395164f, -0.00852621f, 0.00969769f, -0.06945776f, 
    -0.08182708f, 0.05424161f, 0.04502118f, -0.05484961f, 0.00450094f, -0.02446097f, 0.06107942f, -0.02203648f, 
    -0.00760148f, -0.01385242f, -0.02974474f, 0.05774374f, 0.04571784f, -0.01729625f, -0.05915549f, -0.06822185f, 
    -0.01410424f, -0.03415423f, 0.05702699f, 0.05799547f, 0.01638694f, -0.04833603f, -0.04613220f, 0.04257789f, 
    -0.06728486f, -0.03175153f, -0.06910186f, 0.02381825f, -0.06281101f, -0.07078523f, -0.03704990f, 0.03572333f, 
    -0.04172404f, 0.05646636f, 0.00107286f, -0.06964334f, 0.04614628f, 0.05908294f, -0.06751571f, -0.00368421f, 
    -0.07209943f, -0.00897279f, 0.05417603f, -0.01886913f, 0.03479793f, -0.05763180f, 0.02527305f, 0.02509543f, 
    -0.03145727f, -0.00471334f, -0.03877055f, -0.02535165f, -0.04064894f, -0.04447609f, -0.03633145f, -0.00489980f, 
    -0.07470310f, -0.05170406f, 0.05356907f, -0.01314325f, 0.03057932f, 0.03518222f, -0.02980083f, -0.02002920f, 
    0.01767165f, 0.04963914f, -0.07031712f, 0.04099014f, -0.05206883f, -0.04695632f, 0.00732919f, 0.05198153f, 
    -0.05628366f, 0.03130094f, 0.03757530f, -0.06877194f, -0.00881995f, -0.07265298f, 0.02258418f, -0.05606860f, 
    0.05295506f, 0.03481999f, 0.06369229f, -0.06679642f, -0.03710828f, -0.02176760f, -0.04245731f, -0.02213782f, 
    -0.00608333f, -0.05855194f, -0.07474288f, -0.06847735f, -0.03387621f, -0.03900068f, -0.00186415f, -0.06686849f, 
    -0.05989743f, 0.06014974f, -0.07672115f, 0.02921027f, -0.00479259f, 0.04690046f, 0.00358192f, -0.03294059f, 
    -0.01659186f, -0.04256366f, -0.04228078f, -0.02807536f, -0.05528612f, 0.01849411f, -0.03704587f, 0.06318332f, 
    -0.07376267f, -0.06626845f, -0.06313396f, -0.03968213f, 0.06310385f, 0.04135794f, -0.05040250f, -0.06209940f, 
    -0.00199528f, 0.03717511f, 0.02313821f, 0.03072609f, -0.07035245f, -0.04051208f, -0.03449363f, 0.03779857f, 
    0.04834075f, 0.02350613f, 0.02232289f, -0.05213486f, -0.04768615f, -0.07462078f, -0.06789710f, -0.01506620f, 
    -0.04084066f, 0.05319320f, -0.02205844f, -0.07187497f, 0.05808658f, -0.00028188f, -0.01654835f, -0.05542269f, 
    0.04194689f, -0.03524497f, -0.03763772f, 0.03682796f, 0.01201420f, -0.01115200f, 0.05292647f, 0.02033669f, 
    0.02222340f, -0.01830262f, -0.03915209f, 0.03585371f, -0.01612276f, -0.01989659f, -0.00348658f, 0.00488571f, 
    0.01369909f, -0.02262695f, -0.07639080f, 0.05730266f, -0.02989021f, -0.07606533f, 0.06493734f, -0.05332096f, 
    0.05321234f, 0.02761277f, -0.02781112f, 0.02415998f, 0.05388529f, 0.04020026f, -0.02804986f, -0.03581175f, 
    -0.01177063f, 0.04796075f, -0.02578688f, -0.03629407f, 0.03235798f, -0.01824026f, 0.04379492f, -0.02311813f, 
    0.06072760f, -0.06215842f, -0.04923716f, 0.04479226f, -0.02522358f, -0.04369259f, -0.03135312f, -0.05756326f, 
    0.05231641f, -0.00230744f, 0.05586172f, 0.06037785f, -0.05671277f, 0.01268872f, 0.00261895f, 0.04297594f, 
    0.34246203f, -0.23442470f, 0.20822774f, 0.11101657f, 0.00387625f, -0.03625295f, 0.00922451f, -0.02497664f, 
    -0.04130956f, 0.09679477f, -0.23777421f, -0.04948897f, -0.29284370f, 0.03249059f, -0.28619277f, -0.09474476f, 
    -0.17993695f, -0.00013817f, -0.16275662f, -0.05983651f, -0.03188473f, -0.10650023f, -0.11134849f, -0.21036936f, 
    0.43691114f, 0.15255114f, 0.09123094f, -0.08636230f, 0.10613301f, 0.00125745f, -0.00546322f, -0.24992831f, 
    0.06042219f, 0.08990856f, 0.07307085f, 0.19637196f, 0.02359719f, 0.02495104f, 0.11888656f, -0.03200706f, 
    0.01647841f, -0.07130991f, 0.01196949f, -0.09793577f, 0.08491341f, -0.09179653f, 0.14500859f, 0.18294773f, 
    0.11164983f, 0.19716524f, -0.15182576f, 0.09849600f, 0.04590282f, -0.03048514f, -0.10207119f, 0.04127974f, 
    -0.05584360f, 0.13769542f, -0.10082449f, -0.03521895f, 0.27266538f, -0.19971505f, -0.13190910f, -0.33495870f, 
    -0.11723670f, 0.04628704f, -0.03786704f, 0.11168719f, -0.04317364f, -0.04197159f, 0.01562237f, -0.18027963f, 
    0.05186137f, 0.10912687f, -0.14386545f, -0.06177215f, 0.23645104f, 0.07713775f, 0.22989945f, 0.22031406f, 
    -0.06139380f, -0.06429350f, 0.03817535f, 0.00259586f, 0.06956819f, 0.00160905f, -0.06336368f, 0.11941395f, 
    0.00442375f, 0.00819446f, 0.02258769f, -0.01950285f, 0.18705155f, 0.11326408f, 0.01679374f, 0.02976877f, 
    -0.35833856f, 0.09100798f, -0.40879294f, -0.15369552f, 0.10320283f, -0.00556543f, 0.02546479f, -0.14751844f, 
    0.12407084f, -0.03789275f, -0.11998544f, -0.14516306f, -0.03743456f, -0.00415303f, 0.11231118f, 0.08345750f, 
    0.04430442f, 0.00856236f, 0.07086021f, -0.01953176f, 0.28099361f, 0.15888250f, -0.08608577f, 0.09903760f, 
    -0.04624856f, 0.18264711f, 0.06279370f, -0.01059542f, 0.04208532f, -0.10269656f, 0.08506947f, -0.03860068f, 
    0.14380758f, -0.00188251f, -0.03096457f, -0.05633232f, 0.16578554f, 0.08447832f, 0.17528811f, 0.01174626f, 
    0.04044634f, -0.00557703f, 0.03699901f, 0.07569988f, -0.15115374f, 0.12445360f, 0.00414801f, -0.07230861f, 
    0.19421518f, 0.03437659f, 0.03732622f, -0.30405664f, 0.01727770f, -0.11129247f, -0.07564970f, -0.02418510f, 
    0.01161652f, -0.06855360f, -0.18633841f, -0.04981542f, 0.10165782f, -0.06077857f, -0.20351069f, 0.11217063f, 
    0.06473137f, 0.11494417f, 0.18361403f, 0.07090189f, 0.01492311f, 0.13195273f, 0.05345307f, -0.00321257f, 
    0.10696170f, -0.28117317f, 0.03434103f, -0.09413294f, -0.00780491f, 0.00901790f, -0.14189705f, -0.05390604f, 
    0.05883249f, -0.06004648f, -0.18766968f, -0.03680973f, 0.03035213f, -0.00555344f, 0.11065735f, 0.10033074f, 
    0.07232870f, -0.10014199f, -0.20736288f, 0.05355105f, -0.01585683f, 0.08260201f, 0.04036171f, 0.06862966f, 
    0.02864468f, 0.16424526f, -0.05867049f, -0.04289258f, 0.07266605f, 0.04747067f, -0.03823110f, -0.08165062f, 
    0.04055038f, -0.13495679f, -0.06005075f, -0.15026110f, 0.08040305f, 0.12747957f, 0.15325086f, 0.10733846f, 
    0.09134999f, -0.04367963f, 0.03264493f, -0.00616286f, 0.02936069f, 0.04378868f, -0.06725041f, -0.10894565f, 
    -0.13098872f, -0.00143506f, -0.04841265f, -0.00016884f, -0.07300176f, 0.00855363f, -0.06721697f, 0.15382850f, 
    0.15341504f, -0.03362253f, 0.21999405f, -0.00796442f, 0.13147207f, -0.00092114f, 0.08966553f, 0.18670678f, 
    0.01695232f, 0.23824908f, 0.02069815f, 0.16135693f, 0.00098039f, -0.01567431f, 0.14112218f, 0.16010846f, 
    0.15504596f, 0.03817417f, 0.22156179f, -0.10691033f, -0.12668109f, -0.09122983f, 0.05121553f, 0.09307120f, 
    -0.01698921f, 0.05464067f, 0.03227151f, 0.13933861f, -0.03763509f, 0.27928314f, 0.13845834f, 0.19244690f, 
    0.19803686f, 0.05396756f, 0.12618378f, 0.18265325f, -0.00754090f, 0.04143764f, 0.10343263f, -0.10360117f, 
    -0.29622960f, 0.00299552f, 0.03499376f, 0.01310289f, 0.01701633f, 0.13648638f, 0.08607445f, -0.06639332f, 
    -0.01740134f, -0.06952527f, 0.03153203f, -0.00717196f, 0.17452021f, -0.17360991f, -0.08368984f, -0.21152897f, 
    0.00139784f, -0.03710149f, -0.22338232f, 0.16892008f, -0.19143784f, -0.10229300f, -0.00117385f, -0.00460716f, 
    -0.04466093f, -0.28603047f, 0.35107955f, 0.13177291f, 0.02430504f, -0.14317839f, -0.07944901f, -0.05258128f, 
    -0.09481505f, -0.05286272f, -0.08840672f, 0.12548743f, 0.21409316f, -0.13829681f, 0.12167367f, -0.02912199f, 
    -0.15518422f, -0.15933201f, -0.10323791f, 0.00003618f, -0.26410463f, -0.12265693f, -0.13845159f, -0.08136476f, 
    0.12935609f, 0.17419136f, 0.07113472f, 0.15709051f, -0.02570278f, -0.06983561f, -0.07668370f, 0.01375007f, 
    -0.05522259f, 0.06036296f, 0.06008419f, 0.00065101f, 0.28130713f, 0.07371312f, 0.05591090f, 0.13767153f, 
    -0.19448033f, -0.04963615f, -0.06734442f, 0.04310283f, 0.11691166f, -0.04634934f, 0.03586701f, -0.01292993f, 
    -0.02325978f, 0.06978031f, 0.02069376f, -0.35738686f, -0.03445289f, -0.05784526f, 0.06941485f, 0.11128470f, 
    0.14599034f, -0.14073065f, -0.14995949f, -0.02632517f, -0.13870768f, -0.20509019f, 0.02563881f, -0.24925220f, 
    -0.17368267f, -0.22847351f, -0.14467631f, -0.13868231f, 0.00291011f, -0.13292152f, 0.01923837f, 0.16798870f, 
    -0.31333932f, 0.03716676f, -0.10911351f, 0.07029699f, 0.13089214f, 0.06084272f, 0.12075161f, 0.13200285f, 
    -0.01461787f, 0.04591543f, -0.06493134f, -0.07813593f, -0.10369795f, 0.05215143f, 0.02239595f, -0.24333006f, 
    -0.03011216f, 0.00298877f, 0.21135026f, 0.10714577f, 0.13773426f, 0.15062833f, -0.04362686f, 0.08884572f, 
    -0.04033685f, -0.04898057f, -0.03722441f, 0.06477596f, 0.00279716f, 0.02393677f, -0.00751771f, -0.01166583f, 
    -0.00899181f, -0.05795744f, -0.05074743f, 0.01071407f, -0.00811169f, -0.04801931f, -0.04943747f, 0.02474942f, 
    -0.02640306f, 0.04150862f, -0.03395694f, 0.05437818f, -0.02216472f, 0.03349343f, 0.06452893f, -0.02150883f, 
    0.03993278f, 0.00212218f, -0.02426306f, -0.06995133f, 0.00814583f, 0.02429129f, -0.00280924f, -0.00421591f, 
    -0.05958069f, 0.01793465f, -0.07398477f, 0.03231779f, -0.05300933f, -0.00663312f, -0.01148342f, -0.04136093f, 
    -0.06059349f, 0.04798643f, -0.01945982f, -0.04977365f, 0.06379454f, -0.03880736f, -0.00172736f, -0.07230209f, 
    -0.04520579f, -0.03964790f, 0.02420774f, 0.01080049f, -0.05499186f, -0.00955605f, -0.07006846f, -0.07129357f, 
    0.00056231f, -0.07236266f, -0.05975933f, -0.03088219f, -0.04115795f, -0.07400882f, -0.03587025f, 0.03791835f, 
    -0.05375737f, -0.05819679f, 0.01941155f, 0.05166005f, -0.00589189f, -0.00256743f, 0.00591958f, 0.01453333f, 
    0.04936498f, -0.02814178f, -0.00703040f, 0.01744846f, -0.06265349f, -0.04003637f, -0.02455578f, -0.05407464f, 
    0.03196640f, 0.01267373f, 0.03357026f, -0.06635377f, 0.06222223f, -0.01961054f, 0.02893631f, 0.05188176f, 
    -0.07409669f, -0.03060471f, 0.04524174f, 0.01135601f, 0.02975063f, 0.01715070f, -0.06247818f, 0.04450222f, 
    -0.06076073f, -0.06301633f, 0.01297053f, 0.02177393f, -0.04818448f, -0.02435886f, -0.00836147f, 0.05186254f, 
    -0.01935876f, 0.02423479f, 0.04806273f, -0.07519179f, 0.05661982f, 0.02230864f, -0.06833412f, -0.05229648f, 
    0.01192964f, 0.00859145f, -0.01525938f, 0.06532452f, 0.00804488f, 0.04718299f, -0.06407514f, -0.02801745f, 
    -0.03811297f, 0.01080501f, -0.04997042f, -0.07700489f, 0.04037717f, 0.00309731f, 0.00036075f, -0.00333495f, 
    0.03543330f, 0.03691395f, 0.04877705f, -0.03994510f, 0.01347936f, 0.01211532f, -0.00858763f, 0.03065645f, 
    0.01845298f, 0.03956197f, 0.00956474f, 0.05677270f, 0.05955825f, 0.00533291f, -0.01900451f, 0.05931846f, 
    0.03893438f, -0.06585877f, -0.01778706f, 0.02189493f, -0.02588649f, -0.00899156f, -0.06967121f, 0.04746113f, 
    0.06343757f, -0.07582499f, 0.06659203f, 0.00663122f, -0.06677725f, -0.05943830f, -0.00803492f, 0.03637471f, 
    -0.02725009f, -0.07191083f, 0.06536342f, 0.00734509f, -0.03638761f, 0.05352726f, -0.02111798f, -0.00961245f, 
    -0.01938649f, -0.06345625f, -0.00562366f, -0.00137622f, -0.02089578f, 0.00433545f, -0.06196188f, -0.04412858f, 
    -0.02118902f, -0.01795523f, -0.00943498f, -0.04098443f, -0.05163802f, -0.06237653f, -0.00479692f, 0.01579382f, 
    -0.02685113f, -0.04633639f, -0.06643793f, 0.00901487f, -0.00171040f, -0.01832649f, 0.05135497f, 0.05761756f, 
    0.27031523f, -0.16094394f, -0.06532696f, -0.05382051f, 0.04108214f, -0.11685137f, 0.00031189f, -0.08523580f, 
    0.00701556f, -0.10116890f, -0.18218718f, -0.05105078f, 0.07852486f, 0.12624343f, 0.29988524f, 0.04114413f, 
    0.10521043f, -0.02540649f, -0.05543162f, 0.07931993f, 0.05134811f, -0.07564069f, -0.01570132f, -0.09044209f, 
    -0.06606638f, -0.05157569f, 0.05399266f, -0.10144533f, -0.09482230f, 0.07593739f, 0.03971170f, -0.10078479f, 
    0.19092064f, -0.04352213f, 0.15448296f, -0.01789839f, -0.10576484f, 0.07681467f, 0.08772221f, 0.21254390f, 
    0.09771089f, 0.15462406f, -0.02580552f, -0.00173516f, 0.13767968f, -0.00256657f, 0.07892116f, 0.31906244f, 
    0.09945408f, -0.06494812f, 0.05429396f, 0.21004201f, 0.05820332f, -0.16923422f, -0.13252866f, 0.01282570f, 
    -0.04441578f, -0.08326427f, -0.04738517f, 0.10697974f, 0.08326566f, 0.34034362f, 0.07810386f, -0.08577777f, 
    0.15612538f, 0.03665639f, 0.23329531f, 0.12809789f, -0.15216319f, 0.10186696f, 0.02942813f, -0.17186427f, 
    0.00777901f, 0.27018571f, -0.04867420f, -0.11352030f, 0.00359872f, 0.19770251f, 0.15284681f, -0.06517854f, 
    -0.06591095f, -0.07537584f, -0.01603562f, 0.06913796f, -0.06973024f, -0.36976501f, -0.04676462f, -0.06426580f, 
    0.00195425f, -0.09581598f, -0.10507013f, -0.00169849f, -0.18090029f, -0.07533038f, -0.07017704f, -0.15223424f, 
    -0.02277684f, -0.19360758f, -0.07804488f, -0.06343118f, -0.07467878f, 0.03254117f, -0.08151735f, -0.09186557f, 
    -0.16857821f, 0.02243381f, -0.18665838f, 0.09689938f, 0.00656568f, -0.03666840f, 0.15056650f, 0.06839225f, 
    -0.01303839f, -0.13182494f, -0.24356750f, -0.14597169f, -0.06712654f, -0.22532067f, -0.21520266f, 0.01514771f, 
    -0.12427881f, 0.10014532f, 0.01021377f, 0.29013383f, -0.10079196f, -0.02413668f, -0.01982172f, -0.20812771f, 
    0.02020881f, 0.02617845f, 0.03655187f, 0.06272016f, 0.33977690f, 0.08884803f, -0.10313039f, 0.08830544f, 
    -0.16067226f, 0.03581160f, -0.07070725f, -0.07169158f, 0.08449979f, 0.06703427f, -0.09313081f, 0.06672385f, 
    -0.02008529f, 0.21797258f, 0.22651988f, -0.17375198f, 0.06105001f, 0.01137875f, 0.02012421f, -0.00577490f, 
    -0.01184477f, -0.10063056f, -0.03407067f, -0.14545316f, -0.14586070f, -0.07637941f, -0.34570640f, -0.44087270f, 
    -0.00781521f, -0.13905805f, 0.05564674f, -0.26150876f, 0.01674619f, 0.01138115f, -0.01624148f, 0.18664461f, 
    -0.08436812f, 0.09239503f, 0.17613155f, -0.09035797f, 0.24003302f, -0.02310920f, 0.18979786f, 0.29657146f, 
    -0.02323048f, 0.04950979f, -0.17357299f, -0.02539133f, -0.15441374f, -0.24792153f, -0.13975623f, -0.17359200f, 
    -0.04408696f, 0.08113244f, -0.02850278f, -0.06824584f, 0.04022350f, 0.10561053f, -0.03585000f, 0.04695105f, 
    0.02177923f, -0.00193558f, 0.00493693f, 0.01232450f, -0.07764289f, -0.03919500f, -0.01976094f, -0.07263248f, 
    0.05415635f, -0.01663142f, -0.00306510f, -0.01737451f, -0.04740485f, -0.07086597f, 0.01520880f, -0.02574313f, 
    0.05567628f, -0.00585875f, 0.02874323f, -0.03469151f, -0.05822398f, -0.05624311f, -0.00112702f, 0.03637402f, 
    0.02849621f, -0.05052900f, 0.03948605f, 0.04226489f, 0.03394317f, 0.03085724f, 0.03506507f, 0.06509607f, 
    -0.02289201f, -0.02608047f, -0.05080832f, -0.02526399f, -0.01884646f, 0.00333783f, 0.02804055f, -0.05559087f, 
    -0.07917897f, -0.00344536f, -0.05915279f, -0.04892847f, 0.04515791f, 0.02043083f, -0.01901202f, -0.01433462f, 
    0.02230600f, -0.00553005f, -0.01996977f, 0.01643583f, 0.03794180f, -0.01817618f, 0.04170251f, -0.07019295f, 
    -0.04604612f, 0.06511080f, 0.03179507f, 0.06431487f, 0.00243431f, -0.06546105f, -0.02642042f, -0.01933776f, 
    0.05511842f, -0.03924987f, 0.03374673f, 0.06036454f, 0.02380167f, 0.03533592f, 0.02255531f, -0.02877008f, 
    -0.01242759f, 0.02838825f, 0.00564064f, -0.05313691f, -0.00355450f, -0.07679327f, -0.07182701f, -0.05379988f, 
    -0.05870824f, -0.06278005f, -0.07290217f, 0.00905592f, 0.02269225f, 0.00272595f, -0.03967680f, -0.01784296f, 
    0.03947630f, 0.05609576f, -0.06435669f, -0.04183590f, -0.00885473f, 0.02327347f, -0.00647832f, 0.01495835f, 
    0.02344213f, 0.00946280f, 0.04469050f, 0.05556820f, 0.04025836f, 0.03404025f, -0.02720452f, 0.00028601f, 
    -0.07576025f, 0.00032355f, -0.01685073f, -0.05807972f, -0.02402348f, -0.05139905f, 0.03436020f, -0.03426649f, 
    0.02966143f, -0.05795116f, -0.01574445f, -0.03804848f, 0.03762335f, 0.00884810f, 0.02475232f, 0.01131630f, 
    0.00867237f, -0.05333909f, -0.05349617f, 0.01657800f, -0.03169145f, 0.03215186f, 0.03513347f, -0.00468463f, 
    -0.01546333f, -0.03939478f, -0.05204070f, 0.04945019f, -0.06486169f, 0.05916885f, -0.06137463f, -0.02927353f, 
    -0.03528174f, -0.02451741f, -0.02327334f, -0.06709924f, 0.00038218f, 0.00932250f, -0.05398281f, 0.02968523f, 
    -0.01359941f, -0.05243788f, 0.02018516f, -0.02907938f, 0.00031678f, -0.06662726f, -0.00596891f, 0.00195056f, 
    -0.03945671f, 0.02401851f, 0.01758938f, 0.01288211f, 0.00148488f, -0.02029388f, -0.01739468f, -0.04905278f, 
    -0.05622803f, -0.01699230f, 0.00215996f, 0.01882550f, 0.01217478f, 0.02796023f, -0.04167602f, -0.02575995f, 
    -0.07689662f, -0.04458395f, 0.01792737f, 0.03715072f, -0.00419967f, 0.00135366f, 0.00281874f, 0.00238403f, 
    -0.01912534f, 0.05295574f, 0.00895986f, -0.00877130f, -0.06833825f, 0.03843625f, -0.05249059f, 0.03344573f, 
    -0.07463755f, 0.05067753f, -0.01953013f, -0.03515983f, -0.02108882f, -0.01347599f, -0.03832363f, -0.05864850f, 
    -0.18014909f, 0.13371016f, -0.15859932f, 0.11692055f, 0.02543242f, 0.06127073f, -0.03787908f, -0.01182551f, 
    0.16079411f, 0.14398430f, 0.12582405f, 0.10772637f, 0.21460083f, -0.07638867f, 0.12329649f, -0.08676185f, 
    -0.10464980f, -0.12046898f, -0.11444193f, -0.02185215f, 0.05025384f, -0.03612823f, 0.03575141f, 0.09551828f, 
    -0.17008759f, 0.06949691f, 0.13991824f, 0.26395515f, 0.08859280f, -0.08547589f, 0.11188351f, 0.18237191f, 
    0.10979047f, 0.03121867f, 0.01936041f, -0.07391854f, 0.08814021f, 0.17102243f, -0.09719288f, 0.06122589f, 
    0.10232787f, 0.22342171f, 0.03653553f, 0.18176554f, -0.05608900f, 0.05720820f, -0.01854071f, 0.12149000f, 
    -0.15380061f, -0.13366067f, 0.41457063f, 0.05176418f, -0.00864135f, -0.03266712f, -0.02649450f, 0.09518310f, 
    -0.07509314f, -0.00157449f, 0.01770823f, 0.15057138f, 0.20471022f, -0.15884601f, 0.06561884f, 0.32771444f, 
    0.07979487f, -0.03060970f, 0.06391676f, -0.08403216f, -0.15497389f, -0.04300079f, -0.13602658f, 0.02571732f, 
    0.12771982f, -0.10665979f, -0.18159629f, -0.36369917f, -0.08420447f, -0.08462502f, -0.20345962f, -0.02259666f, 
    -0.11564323f, -0.04822440f, -0.07575194f, -0.05772057f, -0.27523908f, -0.10281914f, 0.00178125f, 0.23708203f, 
    -0.02745642f, 0.04730904f, -0.06220978f, 0.02125307f, -0.16826642f, -0.01623881f, -0.06831589f, -0.09530152f, 
    0.13263324f, -0.08048161f, 0.14498645f, -0.38047862f, -0.04104190f, 0.20381282f, 0.01686409f, 0.16179255f, 
    0.01806305f, 0.17249709f, 0.00805212f, 0.06412999f, -0.18559612f, 0.14091314f, -0.13278648f, -0.07208795f, 
    -0.09797398f, 0.06080365f, 0.01013915f, 0.01931593f, -0.20568019f, 0.12056781f, 0.05021334f, -0.00550981f, 
    0.20207919f, 0.04326552f, 0.08878204f, -0.04225154f, 0.10558530f, 0.13089618f, -0.07682630f, 0.15242419f, 
    -0.01604003f, -0.04385927f, 0.01109436f, 0.03264331f, -0.15346745f, -0.00788485f, 0.00421414f, 0.03425501f, 
    -0.05388228f, -0.01528734f, 0.07526921f, 0.08764922f, -0.00159690f, 0.16138324f, 0.20112237f, 0.24394117f, 
    -0.13934991f, -0.01092721f, 0.04028249f, -0.10451742f, -0.00895172f, 0.07858989f, -0.08673781f, 0.16229351f, 
    -0.02659773f, -0.00115290f, 0.04366759f, -0.00846357f, -0.05422220f, -0.02256838f, -0.02828412f, 0.33291993f, 
    0.06298280f, -0.03560303f, -0.15641029f, 0.13675496f, 0.01160881f, 0.10143866f, -0.15689529f, -0.03973681f, 
    0.19131239f, 0.46597368f, -0.41950881f, 0.16757752f, 0.16048808f, 0.07176385f, 0.39482519f, -0.22046775f, 
    -0.03645022f, 0.11679339f, 0.05911224f, -0.05793228f, -0.08567724f, -0.00913368f, 0.01687091f, 0.13734628f, 
    0.11367989f, 0.16197494f, 0.10401364f, 0.02750892f, -0.11502019f, -0.14085771f, 0.04856192f, -0.02809981f, 
    0.04806196f, 0.06331760f, 0.06369543f, -0.05621940f, -0.01715449f, -0.04005666f, 0.05983111f, -0.02437813f, 
    -0.00254802f, 0.01519861f, -0.01612293f, 0.05833944f, 0.03195489f, -0.00983643f, 0.01976810f, 0.05218687f, 
    -0.01359162f, -0.00688934f, 0.00635893f, -0.02037510f, -0.04242411f, 0.02163317f, -0.06040800f, 0.00448615f, 
    -0.03238262f, -0.04967326f, -0.05093889f, 0.00329310f, -0.03126694f, -0.03420426f, -0.02838317f, 0.01442545f, 
    -0.07993180f, -0.03714100f, -0.01153995f, 0.01941897f, -0.07060971f, 0.02576385f, 0.02124976f, 0.00225017f, 
    -0.07599975f, 0.00304092f, -0.00556146f, 0.02020649f, -0.05203580f, 0.00436756f, -0.06343077f, -0.00825851f, 
    -0.00943832f, 0.00520589f, 0.03270394f, -0.04702657f, 0.04311622f, 0.00793064f, -0.07913627f, 0.05144882f, 
    -0.00696694f, -0.01299905f, -0.07284772f, 0.02911880f, 0.03415900f, -0.08089095f, -0.04314841f, -0.03694620f, 
    -0.06112900f, -0.07603000f, -0.06619344f, 0.00921846f, 0.00844839f, 0.04326210f, -0.03551583f, 0.01283034f, 
    -0.06304052f, 0.02372335f, -0.07157386f, -0.03331153f, -0.03751479f, -0.03248101f, -0.03456338f, -0.05208500f, 
    0.04375910f, -0.01123414f, 0.03282551f, -0.07580619f, -0.07143316f, -0.08193589f, -0.05749064f, 0.05698648f, 
    0.03594483f, -0.04539317f, -0.00025811f, -0.08186723f, -0.08238348f, -0.07492356f, -0.05507817f, -0.03222055f, 
    0.06028247f, -0.03708933f, 0.04791242f, 0.03762454f, -0.00309372f, -0.07238243f, -0.02113903f, -0.06851916f, 
    0.00287946f, 0.02034100f, -0.02707170f, 0.01287840f, 0.05319805f, 0.01896075f, -0.01692514f, 0.02185747f, 
    -0.07036591f, 0.02266322f, 0.00378826f, -0.02558594f, 0.01283268f, -0.04301899f, -0.07112545f, 0.03194107f, 
    0.00621879f, 0.02876994f, 0.02209114f, -0.03376021f, -0.01935221f, 0.03573899f, 0.03331553f, -0.02977856f, 
    -0.01532215f, 0.04273376f, 0.00450193f, -0.05393019f, 0.00432506f, 0.02472484f, -0.04443403f, -0.08416825f, 
    0.05094675f, -0.05829286f, 0.02525759f, 0.00927159f, 0.05691431f, 0.04814833f, 0.05545441f, 0.01718211f, 
    0.01924364f, 0.06115003f, -0.04341470f, -0.03683609f, 0.02659043f, -0.02446637f, -0.02138334f, 0.03628946f, 
    0.00197217f, -0.02497523f, -0.05516455f, 0.01859197f, 0.04363727f, 0.00376247f, -0.04490666f, -0.00441725f, 
    0.00197136f, -0.04319606f, -0.01146970f, 0.03045058f, 0.03451609f, 0.01088358f, 0.01959212f, -0.06127466f, 
    0.05955498f, -0.00622849f, -0.01057554f, -0.04451349f, 0.03411242f, 0.05717290f, -0.00519775f, -0.00446999f, 
    -0.05189142f, -0.00129990f, 0.02657690f, 0.05246695f, 0.04790763f, -0.05866266f, -0.02659909f, -0.00767971f, 
    0.04954275f, -0.07775774f, 0.02679400f, -0.04174592f, 0.02712455f, -0.03774026f, -0.01876156f, 0.05763736f, 
    0.11414193f, -0.08164071f, -0.41383284f, -0.19004296f, -0.03223779f, -0.02290969f, 0.02142022f, -0.04649846f, 
    -0.16134354f, -0.07635590f, -0.14709255f, -0.07656969f, 0.18437155f, 0.04508228f, 0.08053507f, 0.04312347f, 
    0.06371810f, 0.00229212f, -0.14107677f, 0.17200021f, 0.08271073f, 0.12786996f, -0.07302143f, -0.06170721f, 
    0.10090799f, -0.01860566f, -0.19125655f, 0.02915406f, -0.02095848f, 0.13253289f, 0.14089283f, -0.04116335f, 
    0.13233429f, 0.04174767f, 0.09724422f, 0.06399339f, -0.21825486f, 0.10542965f, 0.05841479f, 0.06509914f, 
    0.02807068f, -0.00225300f, -0.12380581f, -0.31580016f, 0.03258077f, 0.13634811f, 0.16741943f, 0.35372946f, 
    -0.15075812f, -0.03290083f, 0.14191629f, 0.18825960f, 0.01338281f, -0.07506844f, -0.20185500f, 0.07573528f, 
    0.02620714f, -0.01097054f, 0.17312093f, 0.08868688f, 0.24766062f, 0.02037743f, 0.13806370f, 0.11209477f, 
    0.07216464f, 0.11815263f, 0.09058252f, 0.13682027f, -0.02029009f, 0.00871815f, 0.12173482f, -0.14897959f, 
    0.04149771f, 0.03893314f, -0.22727248f, 0.25147051f, 0.07700682f, 0.17292492f, 0.10871238f, 0.09981912f, 
    -0.10291786f, 0.05765141f, 0.06432191f, 0.10490226f, -0.30495045f, -0.06422898f, 0.22133052f, 0.29959694f, 
    -0.16260701f, -0.14309376f, -0.03190480f, -0.13908119f, -0.07800417f, 0.02255234f, 0.05160231f, 0.08415665f, 
    0.13692729f, -0.06850215f, 0.13265854f, -0.17973340f, -0.01457416f, 0.02757495f, 0.06946214f, 0.07140206f, 
    -0.05464084f, 0.05707095f, -0.12288222f, 0.06340113f, -0.34963661f, 0.00754517f, 0.06225940f, -0.03001769f, 
    -0.06091130f, -0.00272123f, -0.14075939f, -0.04512906f, -0.16151550f, 0.04572769f, -0.16010639f, 0.19264503f, 
    -0.33223307f, 0.02136298f, -0.01237770f, 0.15534233f, 0.03452768f, 0.06499077f, -0.08061877f, -0.14919637f, 
    0.08603501f, 0.13274457f, -0.08740865f, -0.01136989f, -0.32326010f, 0.00662184f, -0.06085864f, -0.00841276f, 
    -0.12931623f, 0.02330595f, -0.04544293f, -0.15041378f, -0.00776603f, 0.22338568f, 0.01294636f, 0.01126884f, 
    0.12066811f, -0.08720966f, 0.20209533f, 0.21022280f, 0.10923902f, 0.27158159f, -0.04488271f, -0.01927159f, 
    0.03587474f, 0.01189951f, -0.05702140f, -0.09616320f, -0.25293094f, -0.02407934f, -0.18080060f, 0.05343310f, 
    0.00675451f, -0.10346490f, 0.15378235f, -0.03247981f, -0.00029735f, 0.02129455f, -0.08122119f, 0.03695578f, 
    0.23502126f, 0.55117595f, -0.08296417f, -0.18114892f, 0.14942186f, -0.02244334f, 0.18527283f, 0.11721039f, 
    0.03439534f, 0.03539729f, 0.04730167f, 0.00998586f, -0.24295330f, -0.02027019f, 0.05200182f, 0.11938640f, 
    -0.02071032f, 0.14740199f, -0.26276022f, -0.12476791f, -0.00373380f, 0.15906808f, 0.17358530f, 0.13270120f, 
    -0.01842841f, -0.26925376f, 0.00292854f, -0.04886265f, -0.02083828f, -0.03998471f, -0.13516659f, -0.00311525f, 
    -0.05736155f, -0.13873482f, 0.00259863f, 0.05756591f, 0.01337954f, 0.22137392f, 0.15805998f, 0.23212564f, 
    0.16827087f, 0.02740717f, 0.14519671f, 0.17852107f, 0.06733195f, 0.03101420f, -0.00916388f, 0.08675904f, 
    0.21895790f, -0.50248253f, 0.04370729f, -0.16617785f, -0.03250063f, -0.05296339f, -0.10910134f, 0.03719439f, 
    0.15353765f, -0.12189483f, 0.02263503f, -0.03549816f, -0.04078234f, -0.29325789f, -0.10623229f, -0.08539617f, 
    0.21040733f, 0.18606848f, 0.00661870f, 0.02595274f, 0.13058005f, -0.08386553f, 0.08740825f, 0.15890430f, 
    -0.30819762f, -0.01037762f, -0.60190177f, 0.09910559f, -0.02285528f, -0.03720982f, 0.03940224f, -0.09876304f, 
    -0.02859430f, 0.03320576f, -0.08908442f, 0.01125034f, 0.13091783f, 0.11626340f, 0.08892983f, 0.01255138f, 
    0.17001322f, -0.01330960f, 0.05350615f, 0.11587285f, -0.01714466f, 0.08579303f, 0.04626354f, -0.06824682f, 
    0.22208980f, 0.30952987f, 0.29830021f, 0.05909896f, 0.01057162f, -0.03872230f, 0.05519494f, 0.03707055f, 
    -0.03414680f, -0.00174739f, 0.00293347f, -0.05219412f, 0.12785809f, -0.35338306f, -0.58170784f, -0.32638383f, 
    0.11773505f, 0.16784780f, -0.07759653f, -0.08772270f, -0.13053860f, -0.22864123f, -0.11870322f, 0.00661047f, 
    0.13688312f, 0.27395040f, 0.00324228f, 0.34690988f, 0.12264656f, 0.13422628f, 0.07652996f, -0.08624791f, 
    0.06197030f, 0.01412892f, -0.04276544f, -0.04332741f, -0.22235340f, -0.25580966f, -0.36341399f, -0.12920073f, 
    0.07503144f, -0.00015471f, 0.00136630f, -0.10491920f, 0.05369895f, -0.02860061f, 0.08582788f, -0.13479216f, 
    -0.02484785f, -0.22449555f, -0.03378874f, -0.16304016f, -0.00151371f, 0.03417329f, 0.02074472f, 0.14630120f, 
    -0.22249180f, -0.07878587f, 0.13231969f, 0.13452430f, 0.31477970f, -0.34315497f, -0.19112401f, 0.01072768f, 
    -0.05724214f, -0.10882805f, 0.04226042f, -0.01297698f, -0.11429323f, 0.12465385f, -0.12485484f, 0.16461273f, 
    0.07501187f, 0.04806725f, -0.16031593f, -0.17135210f, 0.01609176f, -0.22307028f, 0.03468017f, 0.18669353f, 
    0.06113325f, -0.05554795f, -0.03222029f, -0.09242650f, 0.28043482f, 0.18984473f, -0.32743213f, -0.25688836f, 
    0.00240948f, -0.11036160f, 0.25803724f, 0.00278457f, -0.01478242f, -0.04799552f, 0.06762527f, 0.02159170f, 
    -0.16344661f, -0.17350000f, 0.39541358f, 0.04359623f, 0.02838619f, 0.12257823f, 0.05605372f, 0.07220151f, 
    -0.01239041f, 0.04424930f, -0.03425411f, -0.09634498f, 0.01141595f, -0.07829364f, -0.06976406f, -0.03332034f, 
    0.01038385f, 0.11179265f, 0.17568143f, 0.01926900f, 0.05765160f, 0.02491849f, 0.08982997f, 0.09478209f, 
    -0.06670433f, -0.05265972f, -0.03672778f, 0.02964726f, -0.06359262f, 0.03134618f, -0.05744555f, -0.05471985f, 
    -0.02675763f, -0.08082678f, -0.02201569f, 0.03115940f, 0.02228852f, 0.03876372f, -0.01265663f, -0.03450431f, 
    0.03654226f, -0.01707965f, 0.00924963f, -0.01088676f, 0.01760510f, 0.04489651f, -0.06349556f, 0.04697498f, 
    -0.03403470f, -0.07131062f, 0.05497079f, 0.06009936f, 0.04134810f, 0.01140444f, 0.02605474f, 0.00288956f, 
    0.04051083f, -0.07431913f, -0.03461497f, 0.02584048f, -0.07768793f, -0.06280772f, 0.03515199f, -0.04829067f, 
    -0.03740251f, 0.04210097f, -0.04663058f, -0.00667833f, -0.00297555f, 0.00328919f, 0.05451825f, 0.03864233f, 
    -0.02660533f, -0.03956318f, -0.01484066f, 0.01338890f, 0.03716666f, -0.00328036f, 0.02906019f, -0.04419026f, 
    -0.06241750f, 0.01081191f, -0.01755286f, 0.01548591f, -0.06272382f, -0.00186065f, -0.05434493f, -0.03706003f, 
    -0.05246968f, 0.02128384f, -0.05632211f, -0.04265635f, 0.02475806f, 0.00806607f, 0.02236914f, -0.06519382f, 
    -0.02336380f, 0.02931324f, -0.03859041f, 0.00629463f, -0.04439458f, -0.04539082f, 0.02892029f, -0.08023644f, 
    -0.04195669f, -0.03935628f, -0.05234927f, 0.02907210f, -0.00927886f, 0.05446529f, -0.01570818f, 0.00116596f, 
    0.00727605f, -0.07948513f, -0.03620660f, 0.00366661f, -0.02904293f, -0.04010386f, -0.00946390f, -0.01900503f, 
    0.03838261f, -0.07322245f, -0.05668364f, -0.03769349f, -0.07413579f, -0.03853648f, 0.01416157f, 0.04530072f, 
    0.01453344f, -0.05327841f, 0.02280430f, -0.02046795f, 0.02827622f, -0.02310270f, -0.00630057f, -0.00158729f, 
    -0.05106041f, -0.06941479f, -0.02871934f, -0.06547776f, -0.05739416f, -0.02119281f, -0.00100458f, -0.01556681f, 
    0.02602230f, 0.00834706f, -0.04114887f, -0.04724014f, 0.03153428f, -0.03362474f, 0.00216165f, 0.03646138f, 
    0.00925005f, -0.01155535f, 0.05649138f, -0.07695773f, -0.01031560f, -0.00722185f, 0.04914141f, -0.02947990f, 
    -0.07852275f, -0.00263352f, -0.04817486f, -0.06558000f, 0.02750892f, -0.00249558f, -0.05843902f, 0.02194113f, 
    0.05904142f, -0.03959314f, 0.05182951f, -0.03518206f, -0.01346191f, -0.04844651f, -0.05768062f, -0.01716095f, 
    -0.00628803f, 0.02932541f, -0.03316433f, -0.03039601f, 0.00392871f, -0.04231507f, -0.04870931f, -0.01751287f, 
    -0.02735982f, -0.03384395f, -0.06387296f, -0.02518101f, -0.01146937f, 0.03101127f, 0.05504877f, -0.02638621f, 
    0.01881527f, -0.03636184f, -0.02845968f, -0.01443296f, -0.01253650f, 0.00134553f, -0.05583175f, 0.01745308f, 
    -0.00941992f, 0.02763291f, 0.04691291f, 0.06138685f, 0.02485290f, 0.01719743f, 0.04069917f, 0.02875273f, 
    0.06208059f, 0.00023210f, -0.01078941f, 0.05039173f, 0.06315714f, 0.03368152f, -0.04665424f, -0.00293684f, 
    0.08598522f, -0.05301702f, -0.03282807f, 0.12781690f, 0.08071854f, -0.00186287f, -0.00802861f, 0.11757924f, 
    0.20030954f, 0.01546991f, 0.06820379f, 0.18793753f, -0.08030443f, 0.01585728f, 0.10917240f, 0.03662035f, 
    0.12580481f, -0.00173537f, 0.18456468f, -0.00112514f, -0.03053994f, 0.00135971f, 0.02262373f, 0.06043568f, 
    -0.36376739f, -0.04471380f, 0.13311642f, -0.14127375f, -0.09331987f, 0.02345162f, -0.20475459f, 0.20739102f, 
    0.06108598f, -0.16883492f, 0.04949525f, -0.17566411f, 0.07455388f, -0.11100595f, -0.06394669f, 0.22535489f, 
    -0.02629626f, 0.16627391f, 0.01224038f, 0.27020204f, -0.11983851f, -0.04669928f, 0.01898191f, -0.22227986f, 
    0.40811655f, -0.05061885f, -0.00440969f, -0.14716622f, 0.07834807f, 0.03389672f, -0.02241274f, 0.12706906f, 
    0.06973355f, -0.03203984f, -0.14013717f, 0.03859451f, -0.24412481f, 0.12764871f, 0.13439205f, 0.06030749f, 
    0.05870026f, -0.04504787f, -0.09453667f, 0.00428433f, 0.07045963f, 0.12846231f, -0.02885737f, 0.05217083f, 
    0.06683863f, 0.06753025f, 0.22482799f, 0.01512096f, -0.05281631f, -0.15368754f, -0.03253097f, -0.08716171f, 
    0.10552532f, 0.09466214f, 0.07288150f, -0.08923779f, 0.42693207f, 0.25703061f, -0.16942582f, -0.25023502f, 
    0.11854669f, 0.09631038f, 0.01014137f, 0.19168000f, 0.07201169f, 0.06082760f, 0.04099178f, -0.07268988f, 
    -0.04566123f, -0.16361555f, 0.01730133f, 0.16068317f, 0.03263051f, 0.03879487f, -0.17670162f, -0.13441794f, 
    0.09773696f, 0.01278383f, 0.20286602f, 0.13560607f, 0.25644448f, -0.00611952f, 0.05170418f, 0.07733068f, 
    -0.03063544f, 0.00114843f, 0.06059626f, 0.13123196f, 0.06773562f, -0.11974116f, 0.03732814f, -0.13470514f, 
    0.41599661f, -0.07880715f, 0.14517146f, 0.00577247f, -0.16429421f, -0.02415003f, 0.13218252f, 0.20122923f, 
    -0.07037345f, -0.01328384f, 0.13394867f, 0.14859319f, 0.13827968f, -0.09552769f, 0.01986630f, 0.13647865f, 
    0.01238060f, 0.03748856f, 0.05526857f, 0.08182807f, 0.05437674f, -0.10826796f, -0.13403457f, 0.03095147f, 
    -0.21220000f, 0.36388290f, 0.06005020f, -0.15509732f, -0.02246265f, -0.11532611f, 0.11760507f, -0.04832477f, 
    0.06726727f, -0.03403207f, -0.00181071f, 0.04588022f, 0.15080090f, 0.27176094f, 0.12585965f, -0.04919786f, 
    0.00067256f, 0.07473280f, -0.07363971f, 0.01222592f, -0.06420011f, -0.02685352f, 0.18229358f, 0.06069557f, 
    -0.19446105f, -0.33525360f, 0.23302360f, 0.25232786f, -0.09149201f, 0.08008183f, -0.14866228f, 0.18363166f, 
    -0.04621148f, -0.02591397f, 0.09811267f, -0.05494058f, 0.06771313f, -0.02462930f, -0.03284030f, -0.09885616f, 
    -0.01905782f, 0.00932688f, -0.02449475f, 0.12616161f, -0.01884566f, -0.15962850f, -0.26765192f, -0.08676472f, 
    -0.06947859f, -0.01317073f, -0.02721585f, -0.00724419f, -0.05886982f, -0.00357106f, -0.03398198f, -0.03516966f, 
    0.02312641f, -0.01273051f, -0.04120812f, 0.01936101f, 0.04283567f, -0.07501645f, -0.03010545f, -0.03273215f, 
    0.00726232f, -0.01760296f, 0.01368679f, 0.03464698f, 0.02893093f, -0.07366011f, 0.04065068f, 0.02821623f, 
    0.00919181f, -0.01864278f, 0.05510513f, -0.07653175f, 0.02324020f, -0.03149089f, 0.05539643f, -0.04696164f, 
    0.04746341f, 0.01283022f, 0.06268122f, 0.06288682f, -0.05558081f, 0.04520087f, 0.03943948f, -0.07454701f, 
    -0.07048024f, 0.01532961f, 0.03233936f, 0.06246551f, -0.01713565f, -0.05377827f, 0.00875410f, -0.00304260f, 
    0.02697861f, 0.01266481f, -0.04336541f, -0.03151771f, 0.05895403f, -0.07697091f, 0.02882897f, -0.03987049f, 
    -0.05514708f, -0.02421453f, 0.01517286f, -0.04358567f, -0.04670922f, -0.02816286f, -0.06111300f, -0.02017254f, 
    0.04545494f, -0.05533287f, -0.03771130f, 0.03942310f, -0.07333945f, -0.00615374f, -0.05038254f, 0.02927214f, 
    -0.03707074f, -0.01159074f, 0.06350510f, -0.03725407f, -0.06986349f, 0.02688412f, 0.01124740f, -0.00423714f, 
    0.05921730f, -0.07748973f, 0.06267487f, -0.02146062f, -0.02060490f, 0.00335111f, -0.03984674f, 0.01486026f, 
    -0.07398561f, -0.07648500f, 0.02541414f, -0.01841032f, -0.07699937f, -0.05148199f, 0.00077233f, 0.04926430f, 
    0.04433041f, 0.05514842f, -0.06431981f, 0.04808567f, 0.00464128f, -0.00300108f, -0.05970706f, -0.03045148f, 
    -0.03019754f, -0.05660941f, 0.00007107f, -0.01914548f, -0.05462412f, 0.03499577f, -0.05770968f, -0.01957561f, 
    0.05732005f, 0.04312008f, -0.03576631f, -0.06988563f, 0.00633085f, 0.04148391f, -0.06270777f, 0.04460770f, 
    -0.04968158f, 0.05142858f, 0.01107315f, 0.06366816f, 0.01357854f, 0.01456526f, -0.03663794f, 0.01934241f, 
    0.03086361f, -0.00284577f, -0.01724122f, -0.06588321f, -0.00581329f, -0.05844535f, 0.05718808f, 0.06013124f, 
    -0.00104553f, 0.00249874f, -0.05338528f, -0.00703957f, -0.03248872f, -0.02140223f, -0.02088763f, -0.06447376f, 
    -0.01040796f, 0.00351849f, -0.01933722f, -0.00302047f, 0.02161090f, -0.02056260f, -0.02560630f, -0.06420251f, 
    -0.02826269f, -0.05083105f, -0.07285046f, 0.00789982f, -0.05438605f, 0.03859780f, 0.01076059f, 0.03695014f, 
    -0.04512365f, -0.05893061f, -0.00704653f, -0.00274907f, 0.00041492f, -0.07963484f, -0.05432722f, -0.05260484f, 
    0.00148380f, -0.06144672f, 0.05446810f, 0.02560536f, -0.07128005f, -0.06095897f, -0.02986113f, 0.01177306f, 
    0.03348092f, 0.06048730f, -0.07524466f, -0.06060187f, 0.03554294f, -0.06038938f, -0.06759973f, -0.04744812f, 
    0.05991755f, -0.08041928f, -0.02391615f, -0.06668519f, 0.01751268f, 0.05781132f, -0.00957768f, -0.02487310f, 
    0.19075294f, -0.06395388f, -0.20058869f, -0.03580203f, -0.07702182f, -0.03198895f, 0.10012712f, -0.01667726f, 
    0.03604438f, -0.03531296f, -0.08160305f, -0.10064141f, 0.15980096f, 0.15884259f, 0.17597684f, -0.21281567f, 
    -0.10765710f, -0.02383845f, -0.17990881f, 0.14887020f, -0.10090584f, -0.03360126f, -0.18882047f, 0.10357945f, 
    0.25654480f, -0.02082630f, -0.32218292f, 0.11799598f, -0.12337594f, 0.06411972f, 0.15485024f, -0.11767261f, 
    0.13234910f, 0.12921634f, -0.02850092f, -0.14094533f, -0.14788799f, 0.13039301f, 0.03288431f, -0.10525909f, 
    -0.16395622f, 0.00073085f, -0.04562125f, -0.05030165f, 0.09681206f, -0.01422961f, 0.10068576f, 0.17475313f, 
    -0.25904804f, -0.07284314f, -0.04642692f, 0.24012348f, -0.15023863f, 0.03806482f, -0.05094438f, 0.03700493f, 
    0.02488334f, 0.09688134f, 0.03101952f, -0.08691654f, 0.20363657f, 0.11565945f, -0.14594203f, -0.07109100f, 
    0.04056162f, 0.13867989f, 0.07608189f, 0.17876668f, -0.08718517f, -0.04738552f, -0.09169992f, -0.18572852f, 
    0.20174669f, 0.11012085f, -0.20804106f, 0.00513293f, 0.09780774f, 0.11586193f, -0.09110226f, 0.09656940f, 
    -0.09015977f, -0.02094384f, -0.02743841f, 0.11244304f, -0.42277193f, -0.07062388f, 0.05852895f, -0.01510689f, 
    -0.06442961f, -0.10624930f, -0.04708865f, -0.14715481f, 0.02301579f, 0.05973458f, 0.11998424f, 0.07626253f, 
    0.13786286f, -0.04266636f, -0.18992811f, -0.09554956f, -0.19973427f, 0.04925016f, 0.23647955f, 0.19555196f, 
    -0.03903256f, 0.02002054f, -0.09078973f, 0.08711450f, -0.15935050f, -0.09396409f, 0.01375394f, -0.12316149f, 
    -0.05557337f, -0.17697236f, -0.12204850f, -0.01521180f, -0.02174878f, 0.05137803f, -0.07887337f, 0.08532319f, 
    -0.22268969f, 0.27997857f, 0.21120246f, 0.08069974f, -0.05994982f, -0.01397795f, 0.00729919f, -0.03635516f, 
    0.02905493f, 0.13139434f, -0.07611737f, -0.09142432f, -0.14652240f, 0.03864953f, 0.00510699f, 0.09589248f, 
    -0.03649716f, 0.06418674f, 0.02362677f, 0.04918959f, -0.06444446f, 0.13814479f, 0.14699760f, -0.11161487f, 
    0.13978638f, -0.08938485f, 0.01203950f, 0.09023581f, 0.12059607f, 0.27969399f, -0.14006679f, 0.08243413f, 
    0.11773842f, -0.04234295f, 0.04095100f, 0.04706565f, -0.17987110f, -0.18278819f, -0.30442929f, 0.15155907f, 
    0.05387339f, -0.16113736f, 0.18277255f, -0.10101477f, -0.03522677f, 0.10895693f, 0.06538343f, 0.06286173f, 
    0.40123010f, 0.32350165f, -0.26712936f, -0.07986490f, 0.16049178f, 0.06117775f, 0.06953125f, 0.05369671f, 
    -0.03737013f, 0.00059416f, -0.00804211f, -0.00565784f, -0.02157870f, 0.01867494f, 0.12629853f, 0.11829667f, 
    -0.07515542f, 0.00366868f, 0.06978497f, -0.07065892f, -0.10091306f, 0.03129909f, 0.06514494f, 0.07888396f, 
    -0.34303531f, 0.13586812f, 0.21961232f, -0.05154724f, -0.00277387f, 0.00086013f, -0.20924066f, -0.00680209f, 
    -0.05216667f, 0.01717235f, 0.01176961f, 0.02265410f, -0.07784821f, -0.13260494f, -0.23949493f, -0.07886451f, 
    -0.03274355f, 0.04835714f, 0.09766223f, 0.03550434f, 0.10510208f, 0.09916324f, 0.06683093f, 0.17770936f, 
    0.17238015f, 0.24924509f, 0.14168960f, 0.19486479f, 0.17786761f, -0.02711231f, -0.16194846f, 0.28451478f, 
    0.01491515f, -0.01384396f, -0.00461571f, 0.06716536f, 0.00919081f, -0.06400740f, -0.22329098f, -0.20598869f, 
    0.02389541f, -0.01416028f, 0.07618109f, 0.02591786f, -0.03915223f, 0.07203563f, -0.14498682f, -0.23114547f, 
    0.06706645f, -0.03446648f, -0.04931146f, -0.04643302f, -0.08856072f, 0.21392554f, -0.00133825f, -0.13219255f, 
    0.03168203f, -0.02518499f, -0.01112994f, -0.09369432f, -0.04967072f, -0.08721592f, 0.03247707f, 0.24622072f, 
    -0.05099062f, 0.04841398f, -0.11515358f, -0.13416441f, -0.04658887f, -0.03455482f, -0.10432459f, 0.11348028f, 
    0.03511059f, -0.11344777f, 0.15563294f, 0.17632329f, -0.10144752f, -0.12726352f, -0.18652754f, -0.03822546f, 
    -0.00985025f, 0.05828641f, -0.03246046f, -0.11387773f, -0.02691255f, 0.03595632f, 0.12297669f, 0.23442380f, 
    -0.02693900f, 0.20167744f, 0.17115214f, 0.07087803f, 0.06561809f, -0.02377566f, -0.00483672f, -0.03380593f, 
    0.10370927f, 0.14198777f, 0.16924283f, -0.02000777f, 0.14103805f, 0.15551133f, 0.12177366f, -0.06287968f, 
    -0.03043681f, -0.03472332f, 0.02856472f, -0.08069723f, -0.09482699f, -0.03358905f, -0.35216689f, -0.20614374f, 
    -0.11781153f, 0.04628224f, 0.13095368f, 0.00567690f, 0.00223272f, 0.18204144f, 0.18297657f, -0.16313995f, 
    0.06863554f, -0.03728938f, -0.18625464f, -0.35128558f, 0.10371101f, -0.02845723f, -0.02390163f, 0.21356888f, 
    0.10945246f, -0.03538094f, 0.08002934f, -0.07254501f, -0.29013905f, -0.06307391f, -0.11543051f, 0.06098635f, 
    0.09930196f, 0.05790710f, -0.06759848f, 0.02095860f, 0.00275223f, 0.08295039f, -0.00532056f, 0.08156594f, 
    0.04397433f, -0.09471329f, -0.06722873f, 0.25088581f, 0.02648544f, -0.15162995f, 0.07241750f, 0.05301381f, 
    0.07411505f, 0.08799542f, 0.06406408f, 0.06248138f, 0.01327273f, 0.04611986f, 0.34542632f, 0.50292671f, 
    0.07894725f, 0.37816373f, 0.09938351f, 0.23014317f, -0.00357202f, -0.17428018f, -0.03725768f, -0.17648485f, 
    -0.15016082f, 0.02970766f, -0.09597311f, 0.17728643f, -0.19843473f, 0.10081612f, -0.07467058f, -0.17338438f, 
    -0.13340496f, -0.08753349f, 0.05667746f, -0.04106678f, 0.06505743f, 0.03290513f, 0.11705294f, 0.12059162f, 
    0.14651425f, -0.02956102f, 0.03355976f, 0.08333480f, 0.03873023f, -0.17956743f, 0.18949947f, -0.13175550f, 
    -0.15430649f, -0.08530045f, 0.08221459f, -0.08346187f, -0.03685077f, -0.03412323f, -0.13209558f, -0.03272479f, 
    0.18173170f, 0.08225416f, 0.03218611f, 0.00931066f, -0.00206097f, -0.15225372f, -0.19598141f, 0.06005142f, 
    0.06251347f, -0.10048904f, -0.12207229f, 0.08413012f, 0.04915630f, 0.03031969f, 0.09794303f, 0.18547621f, 
    -0.51302266f, -0.22898509f, 0.18882588f, 0.01495979f, 0.08954457f, 0.00187389f, -0.10404586f, 0.18788704f, 
    0.12995231f, -0.02940573f, 0.01694857f, 0.23367347f, 0.09085885f, -0.15897305f, -0.11709008f, 0.05048525f, 
    0.16658086f, 0.01948799f, 0.02171560f, 0.06122931f, 0.09418143f, 0.07345825f, -0.01049469f, -0.01491770f, 
    -0.23104544f, 0.17546809f, 0.10508112f, -0.01399050f, 0.11490016f, 0.10037838f, -0.05460005f, 0.08777436f, 
    0.02735078f, -0.00972995f, 0.00267398f, -0.00463145f, -0.26645795f, -0.10459472f, 0.20306796f, 0.16969912f, 
    0.03117286f, -0.12821470f, 0.08301493f, -0.20312540f, 0.09833819f, -0.09639069f, -0.00998531f, 0.03468873f, 
    -0.05914277f, -0.22527878f, 0.06083872f, 0.05049240f, 0.06995468f, -0.09976979f, -0.05562650f, -0.13280347f, 
    0.03931605f, -0.10806445f, -0.13980269f, -0.06607426f, -0.02397818f, 0.10626601f, 0.01792374f, 0.09540726f, 
    -0.00788743f, 0.12428799f, 0.02134228f, 0.10208058f, -0.05268034f, -0.15204164f, -0.09413264f, -0.14967349f, 
    -0.13038224f, 0.21697447f, 0.15846871f, 0.23636642f, 0.23001891f, 0.01036651f, -0.05509296f, -0.02271894f, 
    -0.01864832f, -0.00992529f, 0.12359510f, -0.11748383f, -0.08872265f, -0.00801622f, 0.03848830f, -0.05362060f, 
    0.00456211f, 0.01421990f, 0.12191220f, -0.05257356f, 0.04789714f, 0.05611073f, 0.11173248f, -0.04906494f, 
    0.05740673f, -0.13877669f, -0.08548680f, -0.08249258f, 0.20585640f, 0.14181156f, -0.07036008f, 0.12640259f, 
    -0.03822419f, 0.02797541f, 0.13557625f, 0.10616750f, 0.01928343f, -0.02895758f, 0.06498448f, -0.17279404f, 
    0.07238158f, -0.02312618f, 0.02938486f, 0.00927117f, 0.01689266f, -0.19934069f, -0.16427089f, 0.20645717f, 
    -0.18982266f, -0.05292370f, -0.04374522f, 0.11799674f, -0.14555776f, -0.20341411f, 0.24501486f, 0.18048485f, 
    0.07218438f, -0.09139143f, -0.02127413f, 0.16248909f, -0.05274273f, 0.18731281f, 0.41962811f, 0.03591977f, 
    -0.04128155f, 0.33754587f, -0.06743263f, 0.25785658f, 0.17097579f, -0.18962608f, 0.01145734f, -0.03671549f, 
    -0.13126209f, -0.17246105f, 0.36760202f, 0.03758314f, -0.03112724f, 0.08294095f, -0.01790587f, 0.15728849f, 
    0.07712057f, 0.10211997f, 0.01585848f, 0.01510933f, -0.10024478f, -0.00811647f, -0.03702940f, -0.02433807f, 
    -0.01449142f, 0.08414390f, -0.04069143f, 0.01215414f, 0.09730871f, -0.02663443f, 0.02501840f, 0.01987245f, 
    -0.18794037f, 0.10311635f, -0.00897689f, 0.23486859f, -0.02468201f, 0.01417656f, -0.05007192f, 0.08921600f, 
    -0.04860692f, 0.00244156f, 0.07381772f, 0.23497306f, -0.09261915f, -0.08861326f, 0.18541373f, -0.07589099f, 
    0.16296864f, 0.03527673f, 0.18838362f, 0.03508972f, 0.07513294f, 0.16125612f, 0.17851329f, 0.09070740f, 
    -0.26123670f, 0.13298406f, 0.32455057f, 0.01369301f, -0.08434373f, 0.01893337f, -0.09278405f, 0.05056680f, 
    0.04086898f, -0.03502902f, 0.18057564f, -0.06608109f, 0.11062451f, 0.06813814f, -0.15288365f, 0.24134359f, 
    0.13657293f, 0.21203239f, 0.00854387f, 0.10221396f, -0.12766171f, 0.04918144f, 0.04321714f, -0.04578275f, 
    0.24051951f, -0.15737139f, 0.12072162f, -0.03622891f, 0.07254118f, -0.15480500f, 0.04535704f, -0.05464178f, 
    -0.13708831f, -0.14329410f, -0.02417303f, 0.02521964f, -0.04478062f, 0.11778498f, 0.05460144f, 0.07644966f, 
    0.15554862f, 0.05525959f, 0.01223056f, -0.04969944f, -0.07594125f, 0.10793918f, 0.10309525f, 0.07716238f, 
    -0.10289592f, 0.06422595f, 0.02300296f, -0.18848756f, -0.00591019f, -0.05244449f, 0.04368608f, -0.17292848f, 
    0.00136587f, -0.07509903f, -0.11933319f, -0.02612610f, 0.10268980f, -0.08942355f, -0.04107872f, -0.16018528f, 
    0.07500349f, -0.00806865f, 0.03476679f, 0.10464521f, -0.18398926f, -0.15461893f, -0.07879230f, -0.01859163f, 
    -0.09559076f, -0.44014812f, 0.35779932f, -0.21114329f, -0.12044729f, 0.01187730f, -0.10311954f, -0.17663786f, 
    -0.16045576f, -0.03777234f, -0.09607542f, 0.16221850f, -0.00702746f, -0.06841100f, -0.11322831f, 0.14756319f, 
    -0.14917992f, 0.06459907f, -0.10482433f, 0.00914512f, -0.22163559f, -0.08275194f, 0.04006401f, -0.10696437f, 
    0.23809761f, -0.04089234f, 0.04296101f, -0.01849686f, -0.01575935f, -0.08507368f, 0.11061483f, 0.06980430f, 
    -0.10534097f, 0.00424891f, -0.03368647f, 0.07536168f, 0.12491313f, -0.02840589f, -0.12389019f, 0.10793304f, 
    -0.07751574f, 0.03459994f, -0.02972602f, 0.08434704f, 0.09774145f, -0.07657483f, -0.15162694f, 0.14697985f, 
    -0.18823309f, 0.45958373f, 0.03106725f, -0.49092972f, -0.09330744f, -0.07590916f, -0.02280543f, -0.02614896f, 
    0.09159467f, -0.15076299f, -0.05378857f, -0.07740026f, 0.15288472f, -0.10916011f, -0.04328925f, -0.22651751f, 
    -0.04115408f, 0.09375667f, -0.14294006f, -0.08959620f, -0.08191353f, 0.12392791f, -0.04141854f, 0.07675249f, 
    -0.54720545f, -0.01635477f, -0.08931868f, 0.11615058f, 0.04081389f, 0.03766530f, 0.34310192f, 0.04507700f, 
    -0.04002242f, 0.07308906f, -0.00257204f, 0.03833957f, -0.01674248f, -0.18106772f, -0.09350254f, -0.04961553f, 
    0.07350396f, 0.10702834f, -0.00662941f, 0.16319668f, -0.02795193f, 0.00851447f, -0.14658543f, -0.02847015f, 
    -0.05944608f, 0.13492796f, -0.04215401f, -0.08415696f, 0.00183329f, -0.02873990f, -0.15516220f, -0.15126447f, 
    -0.08308960f, -0.13854685f, -0.16961658f, -0.14046298f, -0.00106392f, 0.06507853f, -0.11955000f, 0.17052789f, 
    -0.09470873f, -0.03064508f, 0.11746332f, -0.01711760f, -0.09942029f, 0.02616067f, -0.05486897f, -0.09349106f, 
    0.37249285f, -0.13426885f, -0.13522784f, 0.08558148f, -0.10179985f, -0.14925592f, 0.09059867f, -0.09050114f, 
    0.00602520f, 0.05277272f, 0.09601426f, 0.04511548f, 0.07981576f, 0.10282047f, 0.12771723f, -0.10049397f, 
    0.11331629f, -0.07744797f, -0.02655426f, -0.23752053f, -0.08338068f, 0.05348499f, 0.07479456f, 0.06460684f, 
    0.12205251f, 0.16828133f, 0.07577693f, 0.08325364f, -0.13614994f, -0.11505942f, 0.24077143f, -0.20625490f, 
    0.06947067f, 0.05704102f, -0.06613022f, -0.07206916f, 0.12277368f, -0.01118660f, -0.07553099f, 0.14988993f, 
    -0.01464048f, 0.01172515f, 0.11294032f, 0.19624425f, -0.12080439f, 0.03647314f, 0.06077141f, 0.05599143f, 
    -0.23378940f, -0.07402398f, 0.04782461f, 0.18853915f, 0.03057797f, 0.14735873f, 0.19696851f, 0.11921261f, 
    -0.08863147f, -0.04906210f, -0.04052147f, -0.03399398f, 0.33413053f, -0.09826673f, 0.26557365f, 0.10100494f, 
    -0.10057723f, -0.12659959f, -0.14522198f, 0.01242367f, -0.03703651f, -0.06305476f, -0.05626801f, -0.00678075f, 
    -0.06396750f, 0.04081314f, 0.19298376f, 0.11587588f, -0.12204658f, -0.06158489f, 0.10649927f, 0.10075222f, 
    -0.14711148f, 0.09696075f, -0.14392461f, -0.02524887f, 0.09427189f, 0.09681630f, 0.05122999f, 0.07120096f, 
    -0.10951474f, -0.15103064f, -0.04855209f, -0.10873381f, -0.16259784f, 0.15398750f, 0.00221171f, -0.12913570f, 
    -0.05235390f, 0.27462924f, -0.18965136f, -0.06485596f, 0.08625942f, -0.15162985f, -0.09690472f, -0.19279069f, 
    -0.04862937f, 0.02048544f, -0.03118127f, -0.20691994f, 0.14593016f, 0.02888572f, 0.10394882f, -0.01883907f, 
    -0.02342696f, -0.12863368f, -0.12473484f, -0.18689072f, 0.00160209f, 0.12720646f, 0.08202270f, -0.09728790f, 
    0.18744904f, -0.22775432f, -0.08949587f, -0.13775660f, 0.04903915f, -0.01766683f, 0.05797268f, 0.02730773f, 
    0.05166089f, 0.08897896f, -0.00281913f, -0.15206219f, -0.06329327f, -0.23667444f, -0.04644595f, 0.04494212f, 
    -0.11319313f, -0.03569007f, 0.13143092f, -0.07622305f, -0.07850264f, -0.04909826f, -0.03824390f, -0.02709353f, 
    -0.12674314f, 0.06301437f, -0.21740012f, -0.11808469f, -0.01816171f, 0.01826037f, 0.04466387f, 0.00148078f, 
    0.00907102f, -0.12888962f, 0.02026702f, 0.05293410f, 0.11606269f, 0.04362946f, 0.00407814f, -0.10510513f, 
    -0.06342217f, 0.11941655f, 0.15899068f, 0.07142568f, 0.09269014f, 0.08920331f, 0.07099620f, 0.00812294f, 
    -0.35465351f, 0.03321175f, 0.05638954f, -0.17834412f, -0.13857281f, 0.01164549f, -0.13453594f, 0.01081977f, 
    -0.00911404f, 0.10179028f, 0.03423488f, 0.00291940f, -0.09019578f, -0.13263799f, -0.25933352f, -0.08769725f, 
    -0.06699452f, -0.06087951f, -0.00901202f, -0.12273668f, -0.00595334f, 0.03901381f, 0.12005645f, 0.19167283f, 
    0.20529443f, 0.41582808f, 0.12208099f, 0.04112189f, 0.00097122f, -0.05210808f, -0.05323816f, 0.07534593f, 
    0.05815625f, 0.14883162f, -0.01490097f, 0.05775177f, 0.10059118f, 0.00588969f, 0.12272618f, -0.11978292f, 
    -0.03151006f, -0.11449362f, -0.01680807f, -0.10711246f, -0.00677551f, 0.03022444f, 0.02309102f, -0.12000018f, 
    0.15490000f, 0.02756771f, 0.22574034f, -0.11387595f, -0.08938601f, 0.01344663f, 0.00236070f, -0.02683812f, 
    0.05728963f, -0.09007367f, 0.06082294f, -0.08613567f, -0.04034046f, -0.01739636f, 0.09241996f, 0.19344346f, 
    0.13358614f, 0.04870642f, -0.10544851f, -0.00916438f, -0.09106328f, -0.03613348f, -0.09137415f, 0.05960307f, 
    -0.26199663f, -0.29524025f, -0.06623737f, 0.22004893f, 0.00233789f, -0.04254889f, -0.08334415f, 0.00512310f, 
    -0.09023707f, -0.05035740f, -0.04560207f, -0.14400567f, 0.03671845f, 0.36183652f, 0.41082716f, 0.29039228f, 
    -0.13086617f, -0.08118383f, 0.12539895f, 0.01563169f, 0.15681635f, 0.08757059f, -0.02600537f, 0.06322581f, 
    -0.05479266f, -0.21787648f, 0.10081589f, 0.06061765f, 0.22440332f, -0.03887441f, 0.17475526f, 0.15587607f, 
    0.00561072f, -0.14308356f, 0.12358901f, 0.02074412f, 0.18363544f, 0.19522275f, 0.05080518f, -0.13648652f, 
    -0.04800161f, 0.10026892f, 0.07693140f, -0.01090114f, 0.07769076f, 0.09172918f, 0.01388626f, -0.03113295f, 
    0.12112177f, 0.16101623f, -0.19216818f, -0.09638324f, 0.17561808f, -0.04097618f, 0.14836966f, 0.05095131f, 
    0.05721647f, 0.01085501f, 0.06007436f, 0.01297114f, -0.20215851f, 0.30836266f, 0.27748394f, 0.01949915f, 
    0.02585700f, -0.00639856f, -0.07374769f, -0.00290173f, 0.12108757f, 0.02130258f, 0.22783099f, -0.15425500f, 
    0.12917899f, 0.07029092f, 0.17082535f, 0.28254136f, -0.15840471f, -0.13625751f, 0.03093225f, -0.09605866f, 
    0.07100987f, 0.07635425f, 0.01987969f, 0.06190325f, -0.12372980f, -0.16119227f, 0.54737294f, 0.02604793f, 
    0.10848151f, -0.06862606f, -0.10087848f, 0.13999546f, 0.07006694f, -0.02904545f, 0.05308163f, -0.10219607f, 
    -0.03201764f, -0.30286068f, -0.07442259f, 0.18337230f, -0.17586903f, 0.07673666f, -0.13737233f, 0.07106182f, 
    -0.04410265f, -0.12551413f, 0.03613073f, -0.00942712f, 0.05614531f, 0.10951675f, 0.09807611f, 0.07745198f, 
    0.06884088f, -0.17924370f, 0.13700494f, -0.02220780f, -0.04063630f, -0.02040053f, 0.07446868f, -0.03072812f, 
    -0.06575313f, -0.02835911f, 0.00643045f, -0.00560049f, 0.04596151f, 0.04692192f, -0.02275729f, -0.03329273f, 
    0.03722198f, -0.07574723f, -0.04606310f, -0.01674280f, -0.00264820f, -0.02860455f, -0.04234635f, -0.01786534f, 
    -0.00220942f, -0.03335667f, 0.01731470f, 0.03314395f, -0.04186908f, -0.02418919f, -0.01119083f, -0.01649944f, 
    -0.05027717f, -0.02192660f, -0.01988798f, 0.01633396f, 0.02348712f, -0.05296345f, -0.02059867f, 0.01607040f, 
    -0.03519912f, 0.02254586f, 0.03916511f, -0.04040903f, 0.02791213f, 0.06498383f, -0.00602366f, -0.06362425f, 
    0.04124886f, -0.06404676f, 0.01314529f, -0.05519264f, -0.01274001f, 0.04683524f, 0.04628035f, -0.00631206f, 
    -0.04263256f, -0.02041350f, -0.03089258f, 0.00495659f, 0.02234140f, 0.02666484f, 0.03631919f, -0.05183852f, 
    -0.06492399f, 0.03716652f, 0.06578376f, -0.00127535f, -0.04794635f, -0.02318963f, 0.02338711f, -0.04314201f, 
    0.02929134f, 0.06572004f, -0.07141542f, 0.02531282f, -0.07169524f, 0.05936168f, -0.06564616f, 0.05461961f, 
    0.06198818f, -0.00667907f, -0.07161038f, -0.05373162f, 0.01703702f, 0.05149724f, -0.02661754f, 0.02382273f, 
    -0.06996633f, 0.05147051f, -0.06521823f, -0.00687897f, -0.04758516f, -0.07214727f, -0.00022326f, -0.01801372f, 
    0.01584725f, -0.06681924f, -0.07545185f, 0.04446823f, -0.03087408f, 0.03939601f, -0.00663995f, 0.04042083f, 
    -0.07051334f, 0.06039419f, 0.02368999f, -0.01208563f, -0.06693310f, 0.05426981f, -0.06522043f, -0.05243424f, 
    0.01102843f, 0.05948636f, -0.02014077f, -0.01532162f, 0.05486521f, 0.03558899f, 0.02213577f, 0.05679142f, 
    -0.05460316f, -0.01586090f, 0.04538880f, -0.04756509f, -0.05179793f, -0.00690914f, -0.00621929f, 0.00855209f, 
    -0.03191549f, -0.05303264f, -0.03897362f, -0.00414601f, 0.00430869f, 0.05389377f, -0.03690575f, -0.03441444f, 
    0.06676327f, -0.06817608f, 0.01701275f, -0.03478587f, -0.06803782f, -0.06242134f, 0.03053424f, -0.02881704f, 
    0.05360981f, -0.03532584f, -0.01304612f, 0.04103257f, -0.01964756f, 0.00605357f, -0.05479053f, 0.02816731f, 
    0.05372268f, 0.03054127f, 0.03599285f, -0.03319427f, 0.05464418f, 0.03410792f, 0.00119787f, -0.03772917f, 
    0.03542941f, -0.00203133f, 0.00219233f, -0.06556038f, -0.05826274f, -0.06663845f, -0.05687140f, -0.00755369f, 
    -0.07310591f, -0.00632425f, -0.00658435f, 0.04927223f, 0.01577195f, -0.00809746f, 0.04252620f, 0.01265475f, 
    -0.07340169f, -0.03208635f, -0.03542163f, -0.00571989f, 0.03985297f, -0.00522259f, -0.07657398f, -0.03766116f, 
    -0.02031575f, -0.06350696f, -0.02747029f, 0.02062899f, -0.06119352f, 0.02037616f, -0.02585798f, -0.05989298f, 
    -0.01610283f, 0.02480071f, -0.02429008f, -0.07435738f, 0.01188154f, -0.04189801f, -0.00815940f, -0.07347747f, 
    0.07570378f, 0.03997604f, -0.09750642f, 0.08230830f, -0.04747659f, -0.11769587f, -0.04194224f, -0.08819021f, 
    -0.11825258f, -0.01724059f, -0.01320125f, 0.00044466f, 0.10043342f, 0.01925551f, 0.14174689f, -0.00746175f, 
    0.05943231f, 0.04077061f, 0.01719494f, 0.03752369f, 0.08435543f, -0.11475780f, -0.03172730f, -0.09481106f, 
    0.28386757f, 0.06638297f, -0.00455137f, 0.09832274f, 0.02277183f, 0.03823009f, 0.13436720f, -0.07232939f, 
    0.07440870f, 0.15348610f, 0.09913648f, 0.15352719f, -0.15407743f, -0.07246152f, 0.20874044f, 0.04572764f, 
    -0.05099469f, -0.15736678f, -0.09000289f, -0.31546146f, 0.21298905f, 0.10790084f, 0.06976999f, 0.19661979f, 
    -0.31413156f, -0.09903581f, -0.02804261f, 0.12155249f, 0.08977918f, -0.30821306f, -0.10719558f, -0.00075417f, 
    0.09454830f, 0.07539738f, 0.03125964f, 0.00403375f, 0.27433449f, 0.12963057f, -0.01510530f, -0.04332909f, 
    0.04385717f, 0.06892791f, 0.16234401f, 0.16922686f, 0.02725147f, -0.00070260f, 0.09240832f, 0.04072199f, 
    0.03281853f, 0.11817258f, -0.17260924f, 0.00539189f, 0.09943701f, 0.19349685f, 0.00142564f, 0.13377750f, 
    -0.03336506f, 0.02868132f, 0.07678822f, 0.03884922f, -0.52389938f, -0.23038675f, 0.11180678f, 0.25036824f, 
    -0.06940717f, -0.22375691f, -0.08134749f, 0.03010122f, 0.01493975f, -0.00208306f, -0.07947394f, -0.00528846f, 
    0.05238120f, -0.06851383f, -0.07262637f, -0.20798092f, 0.10941210f, -0.00009831f, 0.05671846f, 0.07011280f, 
    -0.07611674f, 0.06601024f, -0.13669695f, 0.10215271f, -0.28302965f, -0.11825976f, 0.00522656f, 0.05862586f, 
    -0.08165344f, -0.05350555f, -0.16568221f, -0.07717369f, 0.03800572f, -0.15301299f, -0.20768492f, -0.06813566f, 
    -0.29168171f, -0.20441261f, -0.13972509f, 0.21244010f, 0.07232216f, -0.03793440f, -0.06820843f, -0.36535099f, 
    0.11818185f, -0.02599245f, -0.07597699f, -0.04684564f, -0.16001900f, 0.03048642f, -0.00213110f, -0.15073697f, 
    -0.10544946f, -0.08498946f, -0.09036062f, -0.20113561f, 0.10607802f, 0.18235710f, 0.02140608f, 0.01396434f, 
    0.11360318f, -0.00685081f, 0.17906751f, 0.17798410f, 0.14121845f, 0.18109350f, -0.00861036f, -0.02591892f, 
    -0.02851810f, 0.14595152f, -0.01154884f, -0.09152638f, -0.27006310f, -0.30672970f, -0.24282226f, -0.30959105f, 
    0.07339037f, 0.05915362f, -0.05884734f, -0.06232592f, -0.03784743f, 0.07502056f, -0.16141215f, 0.03639821f, 
    0.24459219f, 0.25674558f, 0.11192114f, -0.14232554f, 0.14198194f, -0.08879018f, 0.26667026f, 0.23882985f, 
    0.06692123f, -0.04695609f, 0.07427064f, 0.10173119f, -0.20114644f, -0.15142433f, -0.08851792f, -0.05355597f, 
    0.00274681f, 0.02217057f, -0.03578677f, -0.11554942f, 0.07493365f, 0.17771019f, 0.02427334f, 0.18104596f, 
    -0.08839068f, -0.04343406f, -0.05150832f, 0.01225220f, -0.01215876f, -0.07654548f, 0.02656044f, -0.06287479f, 
    -0.04322940f, -0.02122111f, 0.00437325f, 0.03141358f, -0.01857650f, -0.07756165f, -0.02684780f, -0.01289892f, 
    -0.06613163f, -0.06881674f, 0.04845614f, 0.04601026f, -0.00956884f, -0.05688890f, 0.00095838f, -0.08082949f, 
    0.01816572f, -0.00293461f, 0.03629609f, -0.03026880f, -0.04505630f, -0.01910872f, -0.04289905f, -0.03997284f, 
    -0.01885865f, -0.06175166f, -0.02610166f, 0.02406220f, 0.05417640f, -0.05817209f, -0.09005046f, -0.08062306f, 
    0.01837879f, -0.07809459f, -0.08421650f, -0.06206561f, 0.03052386f, -0.07802337f, -0.10009437f, 0.04104118f, 
    -0.07713271f, 0.01567060f, -0.07633872f, -0.04267747f, -0.05376299f, -0.03817529f, -0.01987805f, 0.03589582f, 
    -0.10041663f, -0.03923595f, -0.05083657f, -0.08629923f, -0.02151999f, 0.04567359f, 0.01066398f, -0.01099499f, 
    -0.05108739f, 0.02359059f, -0.08079738f, -0.01627864f, -0.03083345f, -0.10009015f, -0.00658187f, -0.03938779f, 
    -0.06905606f, -0.05672750f, -0.07150891f, 0.03591553f, -0.03737362f, -0.07658562f, -0.07853515f, -0.06629357f, 
    -0.03680398f, -0.03939120f, -0.00315686f, 0.05688456f, -0.05847723f, -0.09824253f, 0.05807368f, -0.10243028f, 
    -0.05674326f, 0.03445612f, -0.05915735f, -0.03807255f, -0.08974044f, -0.06957234f, -0.01529484f, -0.06527047f, 
    0.02140241f, 0.01405299f, -0.03045244f, -0.02787117f, 0.04503828f, -0.07723425f, -0.08231580f, 0.01975876f, 
    -0.03267630f, -0.00672318f, -0.06637222f, -0.02521506f, -0.02417143f, -0.07957929f, 0.00498694f, 0.05046866f, 
    -0.01022615f, -0.05500486f, -0.00409153f, -0.01952828f, -0.03156774f, 0.04887565f, 0.03582181f, 0.02358447f, 
    0.02924846f, 0.02629032f, -0.03165017f, 0.02388517f, 0.00692132f, -0.03627337f, 0.00645420f, -0.08047847f, 
    -0.07845217f, -0.03817572f, -0.03226816f, -0.01774985f, -0.03045506f, 0.00666579f, -0.02559868f, 0.00143354f, 
    -0.08265935f, -0.07547577f, 0.00385185f, 0.03221656f, 0.01849512f, -0.09151743f, -0.07167403f, 0.00631986f, 
    0.03249739f, 0.00125022f, 0.02253842f, 0.00923087f, -0.04563046f, 0.02534137f, -0.07494188f, -0.02131406f, 
    -0.01705050f, 0.02364767f, 0.03695805f, -0.02264653f, 0.03475378f, -0.01771953f, 0.02582859f, 0.00659224f, 
    -0.07579721f, 0.01665366f, 0.00362074f, -0.02804757f, -0.08133475f, -0.09874220f, -0.05929213f, -0.02295199f, 
    0.05583744f, 0.01080942f, 0.03830999f, -0.00014196f, -0.00627717f, 0.01056435f, -0.09865741f, -0.02933761f, 
    -0.09660301f, -0.01810284f, 0.00759646f, -0.04663410f, -0.06275509f, -0.06814174f, -0.03382120f, 0.05094098f, 
    -0.04826068f, 0.01741090f, -0.06823555f, -0.00101398f, 0.01110865f, 0.00595271f, 0.01831362f, 0.06072334f, 
    -0.01291116f, -0.16660720f, -0.01286023f, 0.07515964f, -0.20311324f, -0.02007276f, -0.06164020f, -0.02226218f, 
    0.00051810f, 0.00968601f, 0.00836716f, 0.13157475f, -0.18080550f, -0.12624359f, -0.03883760f, 0.05910022f, 
    0.10611959f, 0.01021667f, 0.07104653f, -0.03985059f, -0.02025719f, 0.03029291f, 0.00750511f, -0.03915473f, 
    0.21944441f, 0.05885192f, 0.22646880f, 0.00088587f, -0.07202485f, 0.11252603f, -0.11638116f, -0.00848122f, 
    0.00717184f, -0.04573784f, 0.10044087f, -0.12281168f, -0.00124512f, -0.06417760f, 0.04711424f, 0.05026025f, 
    0.19406839f, -0.13321997f, -0.06153966f, 0.00786334f, -0.11059800f, 0.03647031f, 0.01496005f, 0.11183023f, 
    0.23851246f, -0.09829676f, 0.16912323f, -0.05793555f, -0.13597114f, -0.03513619f, -0.04274053f, 0.14560682f, 
    -0.00988134f, -0.19047077f, 0.06077533f, -0.15269336f, -0.00123875f, 0.05308804f, 0.09571695f, 0.23421660f, 
    0.07264891f, 0.14578672f, -0.06347054f, 0.19007517f, -0.07702731f, -0.04376243f, 0.04018086f, -0.06500687f, 
    -0.20317572f, 0.01466153f, 0.08540232f, 0.18845123f, -0.14691868f, -0.16428016f, -0.00312135f, 0.15845715f, 
    -0.10033076f, -0.15929811f, -0.11304244f, -0.01867336f, 0.11489801f, 0.20378119f, 0.20833589f, -0.06592900f, 
    0.02184389f, -0.25681055f, 0.02889273f, -0.02982037f, -0.06419878f, -0.01344488f, -0.12749663f, -0.01435997f, 
    0.06266960f, -0.26095170f, -0.04162597f, -0.09493639f, 0.08308642f, -0.00624239f, 0.09170483f, 0.07635739f, 
    -0.08441887f, -0.07019112f, -0.06551658f, 0.09727807f, -0.00715412f, 0.00338267f, 0.06355429f, 0.01267062f, 
    -0.14269345f, 0.01145768f, 0.02734551f, 0.07148263f, -0.00751265f, -0.04160831f, -0.08534025f, 0.07140967f, 
    0.06957921f, 0.05002218f, -0.04285277f, 0.06749475f, -0.00439351f, -0.02590851f, 0.16089223f, -0.04398939f, 
    -0.03144912f, -0.05396511f, 0.01558120f, 0.01955910f, 0.00411355f, 0.05971252f, 0.07172151f, 0.01971899f, 
    -0.10341606f, 0.03036669f, -0.01987262f, 0.03611217f, -0.06823104f, 0.08727505f, 0.04005580f, -0.09965917f, 
    -0.13784689f, 0.34448197f, 0.48643318f, -0.10512518f, -0.04504766f, -0.05734128f, -0.00646145f, -0.20331451f, 
    -0.09215653f, 0.00784128f, 0.01054573f, -0.08798054f, 0.08607873f, -0.04857593f, 0.13590047f, -0.06413002f, 
    -0.11885072f, -0.21426091f, -0.05812628f, -0.16826621f, -0.19964612f, 0.19723096f, -0.05373542f, 0.03851967f, 
    -0.05861999f, -0.28651178f, 0.01361199f, 0.15867290f, 0.01849890f, -0.05136422f, 0.06104214f, 0.08182541f, 
    -0.04338217f, -0.03378382f, -0.11690740f, -0.00517740f, -0.11125996f, -0.09359679f, -0.07414455f, -0.11417563f, 
    0.13414739f, 0.03470924f, -0.12957093f, 0.07358019f, -0.17495961f, 0.02235114f, -0.05117210f, -0.09293787f, 
    -0.06325302f, -0.06563178f, -0.03216456f, 0.03206480f, -0.01516543f, 0.04647334f, 0.06464612f, 0.02803055f, 
    0.00739244f, -0.00685943f, -0.06813183f, 0.05630128f, -0.04392541f, -0.01746525f, 0.03791593f, -0.06209455f, 
    -0.05017611f, -0.01500068f, -0.06468747f, 0.04627572f, 0.04010933f, -0.02647710f, -0.05671038f, 0.07029127f, 
    -0.04669273f, -0.05608755f, -0.03192121f, -0.03322313f, 0.05861883f, -0.02898617f, -0.04191335f, 0.01911876f, 
    0.01784813f, -0.06848573f, -0.04546273f, 0.04451583f, -0.01350930f, -0.03302387f, -0.04712008f, -0.01010212f, 
    -0.06830381f, 0.04719683f, -0.03792492f, -0.03302512f, -0.04878433f, -0.02234351f, 0.00908148f, -0.05094647f, 
    -0.00462251f, -0.04348706f, -0.00143099f, 0.02891167f, -0.05574387f, 0.02426467f, 0.06017041f, 0.01199236f, 
    -0.05294010f, 0.00688941f, -0.01698004f, -0.00088834f, -0.06672275f, -0.04374664f, 0.04386225f, 0.00865805f, 
    0.02745095f, 0.00070414f, -0.06084692f, -0.06472585f, -0.06693303f, -0.00938672f, -0.06262209f, -0.02063723f, 
    -0.03608889f, 0.01668162f, -0.06797805f, 0.06613239f, -0.06359866f, 0.03961294f, 0.00948602f, -0.06303120f, 
    0.04530583f, -0.02557044f, -0.05592864f, 0.05070861f, 0.03061833f, -0.03667960f, -0.02070644f, -0.07070742f, 
    0.04468613f, -0.00889536f, 0.05235104f, -0.00817479f, -0.06613841f, 0.06673981f, 0.01867172f, -0.06695312f, 
    -0.04217915f, -0.03408684f, 0.02193254f, -0.03116524f, -0.00509112f, -0.01407520f, 0.04189029f, -0.05272128f, 
    0.04243480f, -0.06037103f, 0.02405921f, 0.01079261f, -0.06262229f, -0.07187019f, 0.03377523f, -0.01734482f, 
    0.04961869f, -0.05950986f, 0.00724986f, 0.00203132f, -0.06929560f, 0.02006856f, -0.00483170f, -0.05891975f, 
    -0.03935971f, -0.02466478f, -0.00093641f, -0.00208811f, 0.00782975f, -0.00941365f, 0.04267417f, -0.03714630f, 
    0.06493374f, 0.00957338f, -0.07101800f, -0.04624852f, 0.03873880f, -0.02012775f, -0.01344977f, 0.06456118f, 
    -0.07080355f, -0.03898904f, -0.03604022f, -0.02535723f, 0.04158030f, -0.06095895f, -0.00876780f, 0.06009347f, 
    -0.05011726f, -0.01474764f, 0.04045788f, 0.03214379f, -0.01285973f, 0.00884312f, 0.03685226f, -0.02914316f, 
    -0.02724596f, 0.03717575f, -0.02157442f, 0.04682899f, 0.02766693f, 0.01388585f, -0.04021564f, -0.04296579f, 
    0.06975507f, 0.00854059f, 0.03822648f, 0.04339638f, 0.04294389f, -0.05567477f, 0.04846351f, -0.00949635f, 
    -0.00752986f, -0.06867985f, 0.00127295f, -0.01023128f, 0.01424545f, -0.04025035f, 0.03550000f, -0.02563820f, 
    0.02150798f, -0.01142790f, 0.05045493f, -0.05378485f, -0.01981035f, -0.03422553f, -0.05705317f, 0.02774102f, 
    -0.06460954f, 0.02773634f, -0.02870693f, 0.00066202f, 0.06403054f, -0.06413848f, 0.03144530f, 0.03047884f, 
    -0.05016718f, 0.38220537f, 0.37513298f, 0.17491136f, -0.02259547f, -0.08069217f, -0.02376741f, 0.06440876f, 
    0.03285005f, -0.00202780f, 0.13126047f, -0.04108763f, -0.11611732f, 0.18775335f, -0.06174018f, -0.06181024f, 
    -0.00406845f, 0.05040140f, 0.04806539f, -0.13398634f, -0.02494969f, 0.11538249f, -0.04777592f, 0.02207324f, 
    0.35427296f, 0.46276301f, 0.24085563f, 0.16035312f, 0.00642081f, 0.06962060f, -0.00084471f, -0.05693716f, 
    0.09418745f, 0.02792979f, -0.06250649f, 0.04617978f, -0.07830125f, 0.18188651f, 0.02127042f, -0.15529986f, 
    0.00488518f, 0.03920531f, 0.24084219f, 0.15044370f, 0.02692994f, 0.15596204f, -0.00547778f, 0.14348716f, 
    0.08171947f, -0.11586263f, -0.16155979f, -0.10042927f, -0.02880220f, -0.00113896f, 0.16659053f, -0.01561790f, 
    0.09004593f, 0.07884239f, -0.03904064f, 0.11305458f, 0.04310171f, 0.13176294f, -0.28884670f, 0.03422949f, 
    0.10305167f, 0.04141653f, 0.12500054f, 0.19403665f, -0.06810775f, 0.10341644f, -0.08798090f, 0.06442881f, 
    -0.17093748f, 0.03107999f, -0.06868380f, -0.18523830f, -0.04952827f, 0.06625943f, -0.02064125f, 0.11629492f, 
    -0.03055129f, -0.00444556f, -0.00065569f, 0.17301989f, -0.14519109f, -0.42771831f, -0.06917836f, -0.24365683f, 
    0.19160216f, -0.02414093f, 0.05970069f, -0.15163149f, -0.16294347f, -0.02953161f, -0.04354416f, 0.04307773f, 
    -0.00747967f, -0.05630107f, -0.06606397f, -0.26599434f, -0.08089133f, -0.05817312f, 0.20093408f, 0.05147980f, 
    0.06130618f, 0.00530854f, -0.17523575f, 0.00675969f, -0.15700097f, -0.18780223f, -0.14787638f, -0.01906806f, 
    -0.05977974f, -0.02798920f, -0.07675009f, 0.02559876f, -0.09436236f, -0.06534779f, -0.05169662f, -0.03996241f, 
    -0.17544901f, 0.43983772f, -0.03357159f, 0.00521403f, 0.01454287f, -0.09766960f, 0.05020121f, 0.01925772f, 
    -0.00166869f, 0.06321388f, -0.00400835f, 0.00029857f, 0.01345409f, 0.02194677f, 0.00219574f, 0.21184647f, 
    -0.14007252f, -0.01671058f, 0.01831146f, 0.08851679f, 0.00361129f, 0.19025004f, 0.00027276f, 0.03164777f, 
    0.20273741f, 0.22765690f, 0.15271108f, -0.14977671f, -0.00976104f, 0.11077943f, -0.16937692f, 0.02151564f, 
    -0.02127713f, 0.08101566f, 0.13544351f, -0.07686812f, 0.07069279f, -0.28978238f, -0.56202036f, 0.17477125f, 
    0.19022223f, -0.16213450f, 0.05599231f, -0.27819392f, -0.09767583f, 0.04357138f, -0.13097371f, 0.15155002f, 
    -0.12438448f, -0.13327762f, -0.32005152f, 0.24599804f, 0.10893901f, 0.09576024f, 0.22745930f, -0.04582410f, 
    0.15326403f, 0.07778075f, 0.03496189f, -0.06611169f, 0.10538141f, -0.02110158f, 0.01928670f, -0.01670599f, 
    0.07191209f, 0.09130121f, 0.29063812f, 0.11545449f, 0.08930958f, 0.00082842f, 0.17685042f, 0.13812369f, 
    -0.26793537f, 0.12098137f, -0.18810415f, 0.26101002f, 0.07612219f, -0.03019552f, -0.03147523f, 0.08935039f, 
    -0.03090369f, 0.01812278f, -0.04545239f, 0.17428438f, 0.22253408f, 0.00912364f, 0.24199843f, -0.05303530f, 
    0.00401517f, 0.04513407f, 0.06249252f, 0.09402780f, 0.06483256f, 0.03394084f, 0.21326035f, 0.07678961f, 
    -0.21079111f, 0.29798731f, -0.18725085f, 0.32853821f, -0.06754595f, -0.00944383f, -0.13608301f, 0.12657090f, 
    -0.09497984f, -0.00397225f, 0.08220072f, -0.04537664f, -0.14089264f, 0.22383539f, -0.09959680f, 0.14437939f, 
    -0.15905423f, 0.01438665f, -0.02436854f, 0.01979969f, -0.31518000f, -0.00145099f, -0.09590262f, -0.13012305f, 
    0.29324615f, -0.32401747f, 0.19954711f, -0.10655852f, -0.22563553f, -0.00105283f, 0.02481884f, 0.01375450f, 
    0.07371309f, 0.03365409f, -0.02650933f, -0.00175730f, 0.09266252f, -0.06151541f, 0.03755791f, 0.27675864f, 
    -0.12950797f, 0.02583941f, -0.15213427f, 0.07463966f, 0.02832538f, 0.07451495f, 0.04649315f, -0.01387025f, 
    0.31404182f, 0.07347199f, -0.08935905f, -0.10430017f, 0.05434145f, -0.05727888f, -0.13696511f, -0.06917762f, 
    0.09289653f, 0.04902070f, -0.10996508f, -0.10172593f, 0.11241274f, 0.09058861f, -0.10305012f, -0.08229720f, 
    -0.16755725f, -0.02901133f, 0.01586618f, 0.15172739f, 0.15216084f, 0.11164634f, 0.08214158f, -0.07568540f, 
    0.17420211f, -0.11637706f, 0.38164714f, -0.18529460f, 0.04775085f, 0.13557677f, -0.12109586f, 0.05953775f, 
    0.07456457f, 0.06473072f, 0.06311179f, 0.13854820f, 0.05425850f, -0.15044349f, -0.17084767f, 0.12553884f, 
    -0.26655218f, -0.09095377f, -0.03517504f, 0.08753970f, -0.22256726f, 0.05669487f, 0.21440756f, -0.07148691f, 
    0.19430153f, 0.01822686f, 0.00012557f, -0.17524400f, -0.19562754f, -0.00392855f, -0.16317990f, 0.11101387f, 
    0.03303837f, 0.06348904f, -0.00128959f, -0.12470397f, -0.07956529f, -0.05313089f, -0.18834490f, 0.07193926f, 
    -0.06668654f, 0.03484343f, 0.03918339f, 0.02141573f, -0.06055905f, -0.07498548f, -0.08073917f, -0.09582307f, 
    0.18319634f, 0.16611733f, 0.09301909f, -0.06073768f, -0.04056332f, 0.03221219f, 0.17253242f, 0.00078578f, 
    0.06325001f, 0.01591193f, 0.03845580f, 0.24013337f, 0.21633816f, -0.06711879f, -0.04442924f, 0.23701309f, 
    -0.17072199f, 0.21682084f, -0.09345498f, 0.26173332f, 0.01135933f, 0.11025985f, 0.12945783f, 0.01808111f, 
    -0.14501773f, 0.42719886f, -0.32739788f, 0.22787584f, 0.09261725f, -0.08022008f, 0.06983637f, -0.20512953f, 
    -0.12389816f, -0.05609034f, 0.16806734f, 0.00242518f, 0.17592743f, 0.00779552f, -0.05163387f, -0.13206959f, 
    0.00211755f, 0.15665577f, -0.11259956f, 0.06752931f, -0.06863867f, -0.08297187f, -0.21384986f, -0.04343241f, 
    0.23709325f, -0.19859086f, 0.03562340f, 0.26728785f, 0.01579817f, -0.09712241f, -0.07832550f, -0.06064657f, 
    0.03037693f, 0.05132900f, 0.05579378f, 0.20126474f, -0.08568189f, 0.15281247f, 0.23338239f, 0.23146017f, 
    0.06115193f, -0.08957292f, 0.06897078f, -0.03737317f, 0.01109413f, -0.12107435f, -0.02454932f, 0.00440050f, 
    0.46456733f, 0.02299032f, 0.09553609f, -0.05150438f, -0.01153372f, -0.02243238f, -0.06866889f, -0.08806781f, 
    -0.01398736f, -0.09132034f, 0.05764268f, 0.01096325f, -0.17644972f, -0.32560006f, 0.08367010f, -0.15379749f, 
    -0.06995516f, -0.06033053f, -0.07807784f, -0.18530101f, -0.02839608f, -0.01778113f, -0.10028590f, -0.09351666f, 
    -0.42317513f, -0.27867451f, -0.31798851f, -0.05806635f, 0.19629677f, -0.17446184f, -0.01793404f, 0.09727989f, 
    0.18196151f, -0.10764526f, -0.10314201f, -0.12059537f, 0.37744069f, 0.02600497f, 0.20279512f, -0.26214436f, 
    -0.12534304f, 0.04256494f, 0.09926036f, 0.15719436f, -0.02003761f, -0.06114056f, 0.01236819f, 0.03996142f, 
    0.32906845f, 0.40369266f, 0.34954071f, 0.19717632f, -0.04239615f, 0.11729667f, 0.07034081f, 0.08037630f, 
    0.03775675f, -0.08442171f, -0.01135995f, -0.03342453f, -0.17901027f, -0.25607446f, -0.26022816f, -0.00353913f, 
    0.00711688f, -0.10363413f, -0.01677568f, 0.00512272f, 0.02145558f, 0.06866909f, 0.01578621f, -0.01967094f, 
    0.12355304f, 0.43910640f, -0.28852776f, 0.27995726f, 0.09496411f, 0.04169442f, -0.07962797f, -0.02170924f, 
    0.02272193f, -0.07683668f, -0.12497388f, 0.08126703f, -0.24174029f, -0.36945879f, -0.18346526f, 0.03266617f, 
    0.10680953f, 0.05603946f, -0.03542424f, 0.05150931f, 0.28557870f, 0.06238855f, -0.01469934f, 0.19476764f, 
    -0.19215368f, -0.33939472f, -0.29671398f, -0.04153972f, 0.03661047f, 0.07568825f, 0.15537298f, -0.36804616f, 
    0.03474306f, 0.02246180f, -0.09846551f, 0.11285423f, -0.17276345f, -0.27782637f, -0.24099678f, -0.37295067f, 
    -0.03092636f, 0.04385366f, -0.03213114f, -0.12784973f, 0.05382374f, 0.09838294f, -0.03279637f, 0.05231135f, 
    0.41387951f, 0.28077748f, 0.30244055f, 0.11242484f, 0.10858031f, -0.06944397f, 0.06629596f, -0.01389371f, 
    0.01258274f, 0.08348743f, 0.10169362f, 0.20037569f, 0.26759338f, 0.09814753f, -0.11353810f, -0.25199139f, 
    0.05861138f, 0.16714714f, -0.02434654f, -0.03493050f, -0.07293077f, 0.00953081f, 0.04272331f, -0.04283036f, 
    0.18812412f, -0.04697813f, 0.52597791f, 0.05344393f, 0.05580879f, 0.06240473f, -0.04315300f, 0.23349568f, 
    0.15637751f, -0.05611147f, 0.05510022f, -0.07956592f, 0.09972607f, -0.14221583f, -0.05192508f, -0.07744432f, 
    0.16248262f, 0.02437223f, 0.00902187f, 0.04905687f, -0.02405142f, 0.02228365f, -0.19707203f, -0.10908423f, 
    0.06897072f, 0.11329295f, 0.45704412f, 0.12108408f, 0.00805389f, 0.01400953f, -0.00603193f, 0.00879481f, 
    0.20330772f, 0.05132391f, 0.12608843f, -0.20096649f, -0.14809111f, 0.02062257f, -0.14598119f, 0.07029711f, 
    -0.03790369f, -0.01137003f, -0.03146865f, 0.12489390f, -0.01705234f, 0.11940558f, 0.05983029f, 0.21120659f, 
    -0.01951586f, 0.21987131f, 0.61227655f, 0.10981980f, 0.06546272f, -0.14007808f, 0.09137516f, -0.22981782f, 
    0.33979475f, 0.16235523f, 0.00232357f, 0.14134592f, 0.04423956f, -0.09164345f, 0.03678340f, -0.12345608f, 
    0.08481339f, -0.10177606f, 0.11096466f, -0.02451097f, 0.20076181f, 0.15862650f, -0.00417176f, 0.02533978f, 
    -0.29488081f, 0.13688527f, -0.04307999f, -0.00739464f, 0.02466868f, 0.02478008f, 0.10666384f, 0.02579942f, 
    0.00607632f, 0.02682453f, -0.00388807f, 0.06193864f, -0.26599598f, 0.03426582f, -0.03998385f, -0.02736697f, 
    0.17444099f, -0.00004608f, 0.24798672f, 0.14666912f, 0.06790221f, 0.04728433f, -0.04079683f, 0.18049400f, 
    -0.30856836f, -0.04753920f, -0.23695581f, -0.44269410f, -0.07646511f, -0.18388826f, 0.09210130f, -0.06349463f, 
    -0.10592569f, 0.01880200f, -0.01857804f, -0.03840619f, -0.26435706f, -0.21490626f, 0.07886411f, -0.06340943f, 
    0.10338611f, 0.00458957f, 0.12155803f, 0.08354833f, -0.04813365f, -0.08128215f, 0.01688504f, 0.03397440f, 
    -0.39470428f, 0.04613054f, -0.50776601f, -0.06029294f, 0.08065952f, -0.02937005f, 0.30133352f, 0.15774812f, 
    0.05072892f, 0.08039875f, 0.03650082f, -0.07103181f, -0.17655182f, 0.00360553f, 0.05014485f, -0.08721777f, 
    0.13947144f, 0.05914896f, -0.02713146f, -0.01231244f, 0.03211192f, 0.00518360f, -0.08411839f, -0.05116930f, 
    -0.26741236f, 0.08745098f, -0.10134577f, 0.16533573f, 0.17756657f, 0.13443466f, 0.11451306f, -0.12507686f, 
    -0.09108461f, 0.04127692f, 0.02634421f, 0.12605022f, 0.02475388f, 0.06729504f, 0.23642541f, -0.08874891f, 
    0.05278795f, -0.04699272f, -0.00928355f, 0.00133679f, -0.06048985f, -0.01506911f, 0.05688371f, 0.18748169f, 
    -0.13828550f, 0.08003874f, 0.16278882f, 0.12233430f, 0.06267072f, 0.05630473f, -0.14729610f, 0.20687491f, 
    -0.12192756f, -0.01229982f, 0.02521472f, -0.03073042f, -0.20115682f, -0.22794032f, -0.04108420f, -0.12122276f, 
    0.12134589f, -0.11560746f, 0.14361688f, -0.22204649f, 0.07702123f, -0.10361709f, -0.07990135f, -0.05592256f, 
    0.18658222f, -0.50041085f, 0.06427537f, -0.04269649f, 0.07575483f, 0.11130814f, 0.05786826f, 0.15763442f, 
    0.16709857f, 0.09046730f, -0.02630127f, -0.00052751f, -0.05606056f, 0.01582175f, 0.03176971f, -0.08902619f, 
    0.00294953f, -0.11912454f, 0.04717382f, 0.02082492f, -0.02988526f, -0.01793372f, 0.05924311f, 0.03437548f, 
    -0.01583393f, 0.10528845f, 0.11699527f, 0.09909177f, -0.10046335f, -0.10635673f, -0.06757507f, -0.04677384f, 
    -0.15501706f, 0.32861459f, 0.04705142f, 0.10174277f, -0.05852961f, -0.36888736f, -0.09687474f, -0.22541612f, 
    0.06805168f, 0.00536514f, 0.13362129f, 0.07823037f, 0.02661725f, 0.29667723f, 0.01391924f, 0.21901949f, 
    0.16751264f, -0.34030744f, -0.07769152f, -0.10839235f, -0.05096980f, -0.08205332f, -0.08018455f, -0.01991927f, 
    0.25954711f, 0.04650704f, 0.05940388f, -0.10283525f, 0.11076899f, 0.17116749f, 0.08931711f, 0.12893748f, 
    0.05634737f, -0.03001617f, -0.04841876f, -0.10541359f, -0.16713932f, -0.05945397f, -0.18853521f, -0.05867811f, 
    0.35501623f, 0.28142527f, 0.15804930f, 0.30497155f, 0.14881714f, 0.04155966f, 0.00643148f, -0.05205671f, 
    -0.15787642f, -0.21239808f, 0.02146403f, -0.01826525f, 0.06224915f, -0.54519647f, -0.40497977f, -0.15588465f, 
    0.01962864f, 0.23658030f, -0.14369558f, 0.24277554f, -0.08573245f, -0.00270309f, -0.02772873f, 0.08558978f, 
    -0.24925789f, -0.35111222f, -0.28311691f, -0.42510933f, -0.05758156f, 0.03693643f, 0.18072961f, 0.14436319f, 
    -0.03380085f, -0.00914796f, 0.01057504f, -0.10690778f, 0.42360130f, 0.08205317f, 0.25233635f, 0.52880776f, 
    0.01641768f, 0.04222686f, 0.08721524f, 0.11910737f, -0.00462384f, 0.06099711f, -0.05739632f, 0.02137916f, 
    0.26230061f, -0.16981667f, 0.22417496f, -0.03530847f, -0.09509957f, -0.07378360f, 0.11020475f, 0.09789724f, 
    0.00736342f, 0.06606720f, 0.16237690f, 0.22369610f, 0.20960003f, 0.13980030f, 0.06156640f, 0.27420092f, 
    0.05880282f, 0.09035555f, -0.05251070f, 0.02742846f, -0.10375351f, -0.08881725f, 0.00214480f, 0.04077336f, 
    0.25756577f, -0.00347015f, 0.26329726f, -0.05444859f, -0.03273803f, 0.04855351f, -0.05866463f, -0.02677960f, 
    -0.12905043f, -0.01147857f, -0.05120237f, -0.02187556f, 0.32447892f, 0.22107558f, 0.10251569f, 0.16482550f, 
    -0.00447299f, 0.01309848f, -0.00629108f, 0.01470079f, -0.15548745f, -0.05800671f, -0.13270435f, 0.02315313f, 
    -0.27362522f, -0.33642015f, -0.38744128f, -0.30809909f, 0.04182378f, -0.20002201f, -0.02762154f, 0.20134504f, 
    0.21632597f, 0.06052023f, 0.14838058f, 0.09819043f, 0.29296398f, 0.18860325f, -0.14095773f, 0.21466814f, 
    0.18446559f, 0.40627807f, 0.24251874f, 0.17650872f, -0.17069711f, 0.08124744f, 0.05218792f, -0.05130826f, 
    -0.46533883f, 0.16810519f, -0.23725577f, -0.35940763f, 0.01062692f, 0.26485863f, 0.13346447f, -0.16388091f, 
    0.00579636f, -0.04666984f, -0.02995616f, 0.09216326f, -0.01329507f, -0.14276017f, -0.03227729f, -0.04705948f, 
    0.16606216f, 0.19411239f, -0.24285206f, -0.01531716f, -0.01339244f, -0.14626040f, -0.10364392f, -0.21393840f, 
    0.31493062f, -0.26247767f, -0.06011182f, -0.16692626f, -0.14705710f, -0.06767800f, 0.06574315f, -0.07707189f, 
    0.22832263f, -0.08984539f, -0.07661845f, -0.10729644f, 0.00776655f, 0.11803232f, 0.15358554f, -0.00315056f, 
    0.15759756f, -0.04769181f, 0.05984133f, 0.20433955f, 0.10477150f, 0.03810977f, -0.10661566f, 0.11769328f, 
    -0.00325394f, -0.35712183f, 0.06777219f, -0.32650146f, -0.09731673f, 0.04581805f, 0.04240926f, -0.01570434f, 
    0.24646483f, 0.04029856f, 0.06817951f, 0.03571893f, 0.06531949f, -0.08317243f, -0.09059188f, -0.12066913f, 
    -0.01935541f, 0.06124366f, 0.04058086f, -0.06093451f, 0.17372614f, 0.05990685f, 0.18782188f, 0.19520284f, 
    0.00745351f, 0.27249116f, -0.24205817f, 0.15631260f, -0.03748288f, -0.05459465f, -0.04583005f, 0.00623098f, 
    -0.06235439f, -0.02568219f, 0.00919116f, 0.06403924f, -0.15559821f, 0.26492229f, 0.07283526f, -0.09150565f, 
    0.28755319f, 0.04592090f, 0.04968769f, 0.09278932f, 0.01280037f, 0.05684532f, 0.07994684f, -0.21624060f, 
    0.01580006f, 0.05890490f, 0.17468435f, 0.01952635f, -0.02838804f, 0.05366127f, 0.08061375f, -0.03224363f, 
    0.01992631f, 0.01324572f, -0.09201554f, 0.02069915f, 0.20249689f, 0.05026805f, -0.19081014f, -0.31812602f, 
    0.01219459f, -0.03341277f, -0.05292194f, -0.07028884f, -0.07445653f, -0.12440042f, -0.09121146f, -0.08410457f, 
    -0.03543682f, -0.07530800f, -0.20962562f, 0.26348591f, -0.01780302f, 0.09081635f, 0.05855461f, 0.00016831f, 
    -0.01819597f, -0.03059632f, -0.03040700f, 0.06634240f, 0.04517465f, 0.06364303f, 0.05126155f, -0.08405577f, 
    0.00738254f, -0.16000114f, -0.07583610f, -0.08644126f, -0.03971080f, -0.14225747f, -0.17929015f, 0.07820021f, 
    -0.01889508f, 0.15441860f, 0.08333015f, 0.22996955f, -0.00404747f, -0.08414989f, 0.10048999f, -0.03322480f, 
    -0.04777040f, -0.04597769f, 0.03270069f, 0.17102949f, 0.27340433f, 0.02426002f, 0.06669964f, 0.13706738f, 
    -0.03683577f, -0.00453939f, -0.08879659f, 0.06157108f, -0.05337210f, 0.08742340f, -0.06602190f, 0.04469370f, 
    -0.26320457f, -0.07084443f, -0.00684671f, -0.10108239f, 0.07009517f, 0.10108425f, -0.04138695f, 0.16373818f, 
    0.15184675f, 0.03662335f, 0.01009387f, -0.11794539f, -0.02990743f, 0.30318820f, -0.12534177f, -0.25541741f, 
    0.02481167f, -0.20513745f, 0.14296333f, -0.14737444f, -0.03590650f, 0.01411481f, -0.01541033f, 0.00734327f, 
    0.01116028f, -0.33457211f, 0.35392514f, -0.05386467f, 0.00584370f, 0.00454342f, 0.05254937f, 0.18380763f, 
    -0.07420415f, -0.01810218f, 0.01038003f, -0.01307577f, -0.10056474f, -0.09393492f, -0.05606630f, -0.09579708f, 
    0.07895251f, 0.07146211f, 0.10164756f, -0.14925694f, -0.06760125f, 0.02897486f, 0.05723757f, 0.13100120f, 
    -0.18079545f, -0.16909771f, 0.19880040f, 0.04330659f, 0.06506962f, 0.03847484f, -0.06881071f, -0.01164618f, 
    0.09030070f, 0.07230837f, 0.04443625f, 0.03562173f, 0.11986713f, 0.17314462f, 0.00418785f, 0.13819320f, 
    -0.07566529f, 0.05102226f, 0.01816695f, 0.14596041f, 0.04423742f, -0.03150980f, -0.09427927f, 0.20718180f, 
    -0.07342238f, -0.27519819f, 0.17478751f, 0.04684790f, 0.18146764f, -0.05434423f, -0.22854905f, 0.26538309f, 
    -0.14373913f, 0.01722805f, 0.11385280f, 0.00398663f, -0.08241223f, 0.03808095f, -0.15796436f, -0.09028034f, 
    0.04433525f, 0.12769373f, 0.08322092f, 0.04455916f, -0.10499498f, -0.04458284f, -0.14546724f, -0.09169845f, 
    0.04325256f, 0.18246256f, -0.16620876f, 0.17628734f, 0.01214332f, 0.00917827f, 0.05701512f, -0.12314934f, 
    -0.02955165f, -0.00491044f, -0.02585189f, 0.09924014f, -0.04030912f, -0.12286682f, -0.08765473f, 0.14695227f, 
    -0.04168582f, -0.16201460f, -0.09974030f, -0.03695836f, -0.12564036f, 0.01024868f, -0.05328491f, 0.10513988f, 
    0.28262737f, 0.07659300f, 0.26759738f, -0.08812041f, 0.11193173f, -0.15205525f, 0.05044512f, 0.07305235f, 
    0.13838653f, -0.11991346f, -0.10081858f, -0.20141795f, -0.01885374f, -0.08892234f, -0.34903201f, -0.06867636f, 
    0.00944948f, 0.12425732f, 0.04688920f, 0.16507970f, -0.05135158f, -0.09083132f, 0.00580790f, -0.09136886f, 
    0.09632761f, 0.43025225f, 0.33028990f, 0.26161006f, 0.04887730f, 0.05552208f, 0.14093943f, -0.11579596f, 
    -0.10716787f, -0.02814802f, -0.07649821f, -0.16315190f, -0.38057220f, -0.24732634f, -0.33678082f, -0.04400591f, 
    -0.03659929f, 0.04687626f, -0.01269908f, -0.00971355f, 0.14317097f, 0.00988609f, 0.28817326f, -0.06503047f, 
    0.04303274f, -0.02231521f, -0.03005913f, -0.43572158f, 0.07086680f, 0.00611377f, -0.17866233f, 0.27245989f, 
    -0.06294020f, 0.05984258f, -0.03686089f, 0.04608582f, 0.12407624f, -0.36679476f, -0.36807457f, 0.06273575f, 
    0.04626622f, -0.13375108f, 0.04386448f, -0.02780738f, -0.00133387f, 0.12077255f, -0.16492099f, 0.16578753f, 
    -0.08366186f, -0.14402103f, -0.25276962f, -0.02334665f, 0.03396426f, -0.24825074f, 0.07263796f, 0.21012738f, 
    -0.02762557f, -0.09799379f, 0.00958433f, 0.14320496f, 0.27609995f, 0.27736306f, 0.14044791f, 0.42455614f, 
    0.09384286f, 0.35066903f, 0.10799961f, 0.20942415f, -0.03199109f, -0.11061436f, -0.06247696f, -0.06576381f, 
    -0.11648533f, 0.05769232f, 0.19787982f, 0.18249641f, -0.12080730f, 0.05837981f, -0.05021274f, -0.10176925f, 
    -0.14693145f, 0.01054460f, 0.01643346f, 0.02201673f, 0.10445774f, 0.13065106f, -0.06224286f, 0.07461153f, 
    0.01814868f, 0.16081762f, -0.04408844f, 0.01219981f, 0.03142474f, -0.08442695f, -0.07932176f, -0.13298817f, 
    0.05608854f, 0.02026237f, -0.04805980f, -0.05149281f, 0.04363384f, -0.02789610f, -0.00276399f, -0.03694287f, 
    -0.04456343f, 0.03114463f, -0.00311954f, -0.05961474f, 0.03715493f, -0.04092922f, 0.04026736f, 0.04956515f, 
    -0.03088761f, 0.04346608f, -0.03813270f, 0.00034818f, -0.06889672f, 0.06710625f, -0.01572892f, 0.03994356f, 
    0.03581588f, -0.06121157f, -0.03851339f, -0.04712714f, -0.02848445f, 0.05693249f, 0.05544084f, 0.02603852f, 
    0.01018581f, -0.07143665f, 0.04055383f, 0.05530654f, 0.01047004f, 0.06244564f, -0.01764666f, -0.05439345f, 
    -0.04342465f, -0.02831704f, 0.00917511f, 0.03637905f, 0.00276531f, -0.00817688f, -0.00189992f, -0.07707093f, 
    -0.00876229f, 0.02092193f, -0.05183415f, -0.06731077f, -0.04553983f, -0.00210568f, -0.01213458f, -0.06709976f, 
    0.00627542f, 0.00107013f, 0.03726563f, 0.04866562f, 0.02483969f, -0.07686408f, -0.02735713f, -0.03066386f, 
    0.00775160f, 0.06499360f, -0.05885783f, 0.03162073f, -0.01799082f, 0.01449914f, 0.06463341f, 0.02979478f, 
    -0.07056587f, 0.00980985f, -0.06727403f, 0.01738678f, 0.04136119f, 0.00080395f, 0.01210732f, -0.06091104f, 
    0.00635377f, -0.05030608f, 0.02359735f, -0.03577625f, 0.02168941f, 0.02167361f, -0.03616346f, 0.04964062f, 
    -0.04320097f, -0.05423671f, 0.04485627f, 0.00072148f, 0.02393573f, 0.00189521f, -0.03478970f, 0.01191886f, 
    0.00217297f, -0.00888290f, -0.02809907f, -0.03246823f, -0.01566740f, 0.01655316f, -0.08147117f, -0.06127561f, 
    0.00708029f, -0.01719148f, -0.03299218f, -0.05016332f, -0.00675535f, 0.04011437f, -0.02924947f, -0.06269766f, 
    0.02523244f, 0.06469748f, -0.02371930f, -0.06505635f, -0.04125705f, 0.05810153f, 0.05076758f, -0.02753715f, 
    0.03845973f, 0.05351045f, -0.04209159f, -0.03772246f, -0.05808829f, -0.03193490f, -0.04318377f, -0.03674534f, 
    0.04036379f, 0.00110510f, 0.02037027f, 0.01606578f, 0.05955838f, -0.05581723f, 0.01817233f, -0.04700985f, 
    0.02816180f, 0.02834801f, 0.05453009f, -0.00782213f, 0.00154262f, -0.03357913f, -0.05000037f, 0.03862452f, 
    -0.02718838f, 0.03289054f, -0.05107923f, -0.01432495f, 0.04247302f, 0.02619032f, -0.05702169f, -0.01157772f, 
    -0.06640466f, -0.05292526f, -0.06647650f, -0.03938285f, -0.02383373f, 0.06146612f, 0.03497754f, -0.02068998f, 
    -0.02368459f, -0.04051958f, -0.06520233f, 0.00434246f, 0.00471865f, -0.03690794f, -0.05318603f, 0.04383257f, 
    -0.07799893f, -0.04864343f, -0.05012535f, 0.06635231f, -0.02677277f, -0.04228505f, -0.00643777f, 0.06695124f, 
    -0.02775044f, -0.05569386f, -0.03489742f, -0.06291783f, 0.04238681f, -0.07323191f, -0.06827365f, -0.04541750f, 
    0.05301828f, -0.00397917f, 0.05453949f, 0.01898356f, -0.03688235f, 0.05729668f, -0.08009653f, 0.02145892f, 
    -0.08073960f, 0.04621064f, -0.06051422f, 0.00453218f, -0.01490597f, -0.02690622f, 0.01564767f, 0.00616533f, 
    0.03878097f, -0.06741386f, 0.03336410f, -0.03596883f, -0.00803126f, -0.01710883f, 0.02396030f, 0.04150151f, 
    -0.03406335f, -0.02244240f, -0.02587899f, -0.01971659f, -0.01246749f, -0.02500194f, -0.07203445f, -0.06142851f, 
    0.00835157f, -0.04902519f, -0.03223053f, 0.03547744f, 0.01767761f, -0.00391400f, -0.00381027f, -0.01214337f, 
    0.04170015f, -0.04938165f, -0.02790437f, -0.00658417f, -0.06701504f, 0.00279115f, -0.03320520f, -0.01276617f, 
    -0.01422428f, -0.04538522f, -0.06021178f, 0.01361004f, -0.00947197f, 0.00896115f, 0.03866619f, -0.01918731f, 
    0.01909005f, -0.01081266f, 0.07079225f, -0.06792896f, -0.05329303f, 0.00185023f, 0.02863015f, -0.04890724f, 
    0.05217285f, 0.01274319f, 0.01125879f, -0.02052485f, 0.02602350f, 0.04099258f, -0.05998633f, -0.03726032f, 
    0.00885604f, 0.05789409f, -0.00073252f, 0.03997920f, 0.00124557f, -0.07053816f, 0.03140233f, -0.04265246f, 
    -0.00414520f, 0.05070499f, -0.04172454f, 0.05232540f, -0.04676998f, -0.02147528f, -0.03364605f, 0.03644859f, 
    0.03808904f, 0.01330546f, -0.01699349f, -0.04163412f, -0.06933065f, 0.00548183f, 0.03422839f, 0.04706909f, 
    -0.04213640f, -0.05282010f, -0.03414616f, 0.04709163f, -0.03020146f, -0.00948934f, -0.07190180f, 0.01741426f, 
    -0.07721414f, -0.06925367f, 0.03146544f, 0.00331647f, -0.07376393f, 0.01907970f, -0.03526564f, -0.02163353f, 
    -0.08340197f, 0.03318796f, -0.03855032f, -0.02997667f, 0.00170613f, -0.00786451f, -0.04007397f, -0.02520850f, 
    0.03937350f, -0.02484467f, -0.03438957f, -0.00280854f, -0.07052857f, 0.05997925f, -0.06293608f, -0.04627544f, 
    0.01439979f, 0.03962349f, -0.01772612f, -0.04559987f, -0.03774950f, -0.06828402f, -0.03779890f, 0.01518585f, 
    0.03304193f, -0.08302839f, 0.05016338f, -0.00073990f, -0.02892643f, 0.04113358f, -0.02420752f, 0.05450121f, 
    -0.00366131f, -0.07457826f, 0.00665157f, -0.04147048f, 0.04261622f, -0.01210145f, -0.08843388f, 0.03570889f, 
    -0.07812534f, 0.01098480f, 0.00638437f, -0.03558788f, -0.04932871f, -0.01236188f, 0.03304224f, -0.05691755f, 
    0.00162502f, -0.01990481f, 0.00226576f, -0.03234284f, 0.00594336f, -0.02778341f, -0.00934388f, -0.04304146f, 
    0.04723601f, 0.03926754f, 0.02620534f, -0.08000609f, 0.00192615f, 0.05354055f, -0.08497532f, -0.01991991f, 
    -0.05079466f, 0.02906214f, -0.06581039f, 0.05019952f, 0.04992772f, 0.00293849f, -0.06851157f, 0.03166993f, 
    -0.07879318f, 0.04728950f, 0.05667890f, 0.04517155f, 0.00321254f, 0.03575858f, -0.06011326f, -0.01233126f, 
    -0.05987222f, -0.01349468f, -0.03596516f, 0.01801030f, -0.00317310f, 0.05080676f, 0.02181645f, 0.02437529f, 
    -0.01708453f, -0.11348469f, -0.08789456f, -0.26315805f, -0.09541490f, -0.02285530f, -0.06628764f, -0.15075508f, 
    -0.15317698f, -0.11683013f, -0.20805308f, -0.21346156f, -0.03409043f, 0.04222303f, -0.10453550f, 0.05878542f, 
    -0.01509892f, -0.03703317f, -0.09585454f, -0.04832348f, -0.04659363f, 0.00685512f, -0.02015861f, -0.12467296f, 
    0.25708044f, 0.03725120f, -0.10737846f, -0.19868350f, -0.10254710f, -0.04327176f, 0.03625787f, -0.07760662f, 
    0.02085847f, 0.01423681f, 0.04070022f, 0.08319763f, -0.09704953f, -0.05588486f, 0.01068485f, -0.14690530f, 
    0.01960737f, -0.16830507f, -0.06178343f, -0.24666129f, 0.04425161f, 0.01497218f, 0.01045709f, 0.05903724f, 
    -0.15593979f, 0.09489608f, -0.03018039f, 0.08727650f, -0.08540357f, -0.00118155f, -0.06223518f, -0.13680942f, 
    0.03230100f, -0.01417371f, -0.04959639f, -0.00752786f, 0.00581960f, 0.10888240f, 0.05246968f, -0.13951650f, 
    -0.05669984f, 0.04434586f, 0.09126284f, -0.03397886f, -0.08439115f, -0.08433151f, 0.02208305f, -0.07788658f, 
    -0.13862981f, -0.07247157f, -0.15790078f, 0.07127096f, 0.14018646f, 0.08984330f, 0.03099193f, -0.00817959f, 
    -0.13173266f, 0.04142572f, 0.02535902f, 0.02924776f, -0.20460154f, -0.02737566f, 0.18257542f, 0.07125323f, 
    -0.15069516f, -0.12946998f, -0.11109447f, -0.03212727f, -0.00257129f, -0.13602620f, -0.03470702f, 0.01520242f, 
    -0.12463317f, -0.00069119f, -0.08636402f, -0.00679559f, -0.02764745f, -0.15727806f, -0.00232291f, 0.14036901f, 
    -0.09203519f, 0.03115791f, -0.05532622f, 0.07441606f, -0.04237321f, -0.07069814f, -0.00198993f, 0.01358356f, 
    0.04575352f, -0.07443313f, -0.07960610f, -0.14133719f, 0.01489288f, -0.06600598f, -0.07991301f, 0.00949001f, 
    -0.11982488f, -0.01945645f, -0.24275982f, 0.12408084f, 0.08144451f, -0.05334713f, -0.03650229f, -0.23397480f, 
    -0.03911706f, -0.04885970f, -0.01636215f, -0.15097545f, 0.02661368f, 0.05415557f, 0.04063363f, -0.13538001f, 
    -0.04957933f, -0.01539985f, -0.01595390f, -0.04785453f, 0.12223202f, -0.05384180f, 0.11601447f, 0.03165050f, 
    0.13083050f, -0.26677331f, -0.17455968f, 0.14735924f, 0.03730037f, 0.14845698f, 0.03665252f, -0.04135310f, 
    -0.03354676f, -0.01423762f, -0.06078191f, -0.11385183f, -0.34532368f, -0.18766637f, 0.01499214f, -0.22459370f, 
    0.07541498f, -0.09266078f, 0.08559333f, -0.06517773f, 0.10717583f, -0.18858288f, -0.04598470f, -0.06352595f, 
    0.00835138f, -0.03595716f, 0.13234769f, -0.30452475f, 0.04683026f, -0.18356816f, -0.10289673f, 0.10495275f, 
    -0.09631509f, -0.02114748f, -0.02085266f, 0.00981742f, -0.03484258f, -0.03684195f, 0.01014038f, -0.08297452f, 
    -0.04513599f, -0.17020059f, 0.03096267f, -0.12669969f, 0.01314289f, 0.18489876f, 0.11566413f, 0.01180118f, 
    -0.01824317f, 0.03998528f, -0.18312646f, -0.00011730f, -0.04705789f, -0.12537098f, -0.01196245f, -0.02582359f, 
    -0.11759667f, 0.09757219f, 0.01628702f, 0.03259289f, -0.01494984f, -0.12047320f, 0.02383210f, 0.00157427f, 
    0.08303178f, -0.01599375f, -0.01422747f, -0.02043737f, 0.04273073f, 0.02039290f, 0.10453255f, -0.09351587f, 
    0.21015160f, 0.19414829f, -0.02844296f, 0.18079296f, 0.00075499f, 0.18515447f, 0.07167883f, 0.07293832f, 
    -0.04964205f, -0.03494203f, -0.01256954f, 0.07999370f, -0.18251030f, -0.09754033f, 0.08031116f, -0.07699677f, 
    -0.15220270f, -0.12042039f, -0.04351609f, -0.16663688f, 0.11482204f, 0.24173033f, 0.08965921f, -0.03238386f, 
    -0.32053077f, -0.14816174f, 0.11860802f, -0.09752515f, 0.01644379f, -0.08903278f, -0.17173286f, 0.00591903f, 
    0.02483475f, -0.10684063f, 0.09470221f, -0.11527883f, 0.13641359f, 0.06538192f, 0.22649023f, 0.20355467f, 
    0.02990113f, 0.21658745f, -0.01400057f, 0.12042412f, 0.06438479f, -0.13666642f, 0.06581546f, -0.06274620f, 
    -0.06468130f, -0.10173651f, -0.09932302f, 0.40445396f, -0.03339771f, 0.12209780f, 0.08242482f, 0.15819974f, 
    -0.07805373f, 0.03874220f, 0.06863707f, 0.02436219f, -0.31134760f, 0.08267538f, 0.19853093f, 0.19335312f, 
    -0.06318113f, -0.21033493f, -0.06303183f, -0.30560100f, -0.10942385f, -0.04491090f, -0.03463006f, 0.04681636f, 
    0.06203155f, -0.23665719f, -0.05809061f, -0.09711806f, 0.03140395f, -0.09770411f, 0.09880302f, 0.10850453f, 
    0.06277554f, -0.04267852f, -0.02682876f, 0.14175488f, -0.33239463f, -0.10290778f, -0.02598608f, -0.18989237f, 
    -0.15605256f, -0.13412315f, -0.15213001f, -0.07438875f, -0.05097898f, -0.09969524f, -0.15347710f, 0.01755066f, 
    -0.16347066f, -0.20435673f, -0.15404993f, -0.02140739f, 0.10528737f, -0.01327777f, -0.02797915f, -0.31532639f, 
    0.11717542f, -0.04181228f, 0.03500062f, -0.15675269f, -0.49886847f, 0.03357503f, -0.04495879f, -0.09051602f, 
    -0.10413115f, 0.03318363f, -0.08562507f, -0.05455790f, -0.11746205f, -0.06526996f, 0.17931567f, -0.08056718f, 
    0.15827246f, 0.05178926f, 0.40955710f, 0.44822413f, 0.05788673f, 0.19427462f, 0.07621159f, -0.09376557f, 
    -0.07115930f, 0.07197344f, 0.09984205f, -0.02910711f, -0.38427073f, -0.13726768f, 0.26376599f, -0.22630474f, 
    0.06403960f, -0.06471262f, -0.02217611f, -0.09923202f, -0.07904372f, 0.10517044f, 0.00353750f, 0.05735543f, 
    0.15297021f, -0.04977565f, -0.01734127f, 0.03490877f, -0.01046187f, -0.03058923f, 0.03585071f, 0.05589436f, 
    0.15796523f, -0.04118663f, -0.15187608f, 0.04031356f, -0.30215463f, -0.07276218f, 0.10978324f, 0.09470220f, 
    0.10512563f, 0.03180465f, -0.10370055f, 0.09592588f, -0.05006281f, 0.15136570f, 0.09391952f, 0.09331545f, 
    -0.00783120f, 0.12352992f, 0.22471428f, 0.12268913f, 0.00149166f, 0.00372880f, -0.11017137f, -0.08984610f, 
    0.07043608f, 0.04321041f, 0.01852421f, -0.05738233f, -0.30325335f, 0.05802328f, -0.32380873f, 0.24159510f, 
    0.09547473f, 0.03769071f, 0.02029928f, -0.18247823f, 0.00988656f, 0.03944963f, -0.06046039f, -0.03978912f, 
    0.47751862f, 0.29774061f, 0.41111124f, -0.00356900f, -0.03512821f, -0.10842948f, -0.06683333f, 0.09622636f, 
    -0.03261204f, -0.00348960f, 0.06529372f, 0.14852946f, 0.13086988f, -0.02832008f, 0.12768492f, -0.05987052f, 
    0.17164749f, -0.00532637f, 0.09748264f, 0.01441871f, -0.05340746f, -0.08111873f, -0.04751272f, -0.16651230f, 
    -0.11197816f, 0.09868598f, -0.01435884f, -0.13050780f, -0.07253637f, -0.03555469f, 0.14187992f, -0.04509418f, 
    0.09986980f, -0.00424034f, -0.06891892f, -0.07364802f, -0.04727777f, -0.14759119f, -0.12836275f, 0.15795116f, 
    0.01227780f, -0.06676160f, 0.05665698f, 0.19543412f, 0.10612183f, 0.06184373f, -0.09250220f, 0.09941178f, 
    -0.30359194f, -0.15196964f, 0.04146479f, 0.11197500f, -0.09129550f, -0.08920187f, -0.07878444f, 0.17950897f, 
    -0.06369225f, -0.01271966f, 0.00518559f, 0.02828269f, 0.06843722f, 0.03326680f, 0.28747571f, -0.15346710f, 
    -0.01111876f, -0.03443784f, 0.06657011f, 0.03243617f, 0.06768385f, -0.03781062f, 0.08080055f, 0.03350747f, 
    -0.17878348f, -0.07042890f, -0.25208080f, 0.15739819f, 0.10961667f, -0.11344886f, 0.07108962f, 0.06540775f, 
    0.11687158f, 0.03703556f, -0.05112837f, -0.00784503f, 0.08382317f, 0.08632658f, -0.04980124f, -0.09925825f, 
    0.05765283f, -0.04378429f, 0.08081530f, -0.07834153f, 0.02091559f, 0.09477452f, 0.04435086f, 0.01587887f, 
    0.05645069f, 0.25339437f, -0.20713305f, -0.12246673f, 0.06095440f, -0.12913631f, 0.00143313f, -0.03205736f, 
    -0.01482178f, 0.04113714f, 0.14596778f, -0.00013579f, 0.16447785f, 0.06821043f, 0.23811944f, -0.00944604f, 
    -0.04832121f, -0.06623150f, 0.10184117f, -0.10976437f, 0.05060631f, 0.03499473f, 0.04135174f, -0.04833856f, 
    0.08864913f, 0.02031272f, 0.04025891f, -0.07001443f, -0.10710725f, -0.10248960f, -0.01063470f, -0.14622667f, 
    -0.04363484f, 0.17759317f, 0.12272153f, -0.02474971f, 0.00452493f, -0.16200243f, 0.23877962f, 0.00590296f, 
    -0.03155615f, -0.02448945f, 0.09368470f, 0.08050942f, 0.07240527f, -0.07481805f, -0.03529810f, -0.00940419f, 
    -0.09629157f, -0.43344951f, -0.09627936f, 0.11525252f, -0.04611720f, 0.16682975f, -0.14342393f, -0.06223708f, 
    0.04449789f, -0.01661528f, 0.06194742f, 0.10488200f, 0.11480013f, 0.05698153f, -0.03615918f, -0.14979839f, 
    -0.09496854f, -0.08293164f, 0.32409221f, 0.13689047f, 0.00870950f, -0.01869530f, -0.05738645f, 0.07127980f, 
    -0.01593735f, 0.00820178f, -0.05937613f, -0.00791286f, -0.06235768f, 0.02680305f, 0.03458777f, 0.06646949f, 
    0.01168375f, 0.01954483f, -0.05578779f, 0.01232304f, 0.05574647f, -0.05602784f, 0.04190630f, -0.04153395f, 
    -0.04950035f, -0.00153455f, -0.07415608f, 0.03097509f, -0.06321130f, -0.02035270f, 0.06196298f, 0.06291009f, 
    -0.03809566f, 0.00685487f, 0.04703987f, -0.04592501f, -0.06892471f, -0.04900938f, -0.01473441f, -0.01994812f, 
    -0.06901909f, -0.07625867f, -0.01754542f, -0.05820614f, -0.02401768f, -0.04658782f, -0.04201300f, 0.00585765f, 
    -0.04298114f, -0.00687319f, -0.05750894f, -0.04578337f, -0.00713294f, 0.04469406f, 0.01089037f, 0.03316947f, 
    0.05843922f, -0.04726420f, -0.02907783f, 0.03697615f, -0.02075392f, 0.01393525f, 0.03561543f, 0.00154791f, 
    -0.07491919f, 0.00566382f, 0.03874605f, -0.02768654f, -0.05744657f, -0.06867328f, 0.00480250f, -0.01051656f, 
    0.05818489f, -0.00564970f, -0.03127156f, 0.03154082f, 0.01221502f, 0.05670664f, -0.05040849f, 0.02881720f, 
    0.02878450f, 0.02253221f, 0.00472296f, 0.06359327f, -0.02538871f, 0.03823201f, -0.01101581f, 0.00399478f, 
    -0.06279738f, -0.06533530f, 0.00653760f, -0.01630051f, -0.04716998f, -0.00926260f, 0.06021431f, 0.05005576f, 
    0.02392719f, -0.00986240f, -0.07753692f, 0.02123143f, 0.01904455f, 0.03380413f, -0.01583520f, -0.05371154f, 
    -0.07425294f, -0.04774018f, -0.02510588f, -0.02343002f, -0.05541699f, 0.01671547f, -0.07724763f, 0.03914315f, 
    0.01379035f, -0.00508469f, 0.02289238f, 0.01158208f, 0.00752091f, 0.05390061f, 0.01667909f, 0.05919349f, 
    -0.02233444f, -0.03497694f, -0.06944818f, 0.04115831f, 0.00457007f, -0.02230605f, -0.04718009f, -0.06316018f, 
    -0.06454717f, 0.01676762f, 0.00875709f, 0.00294776f, -0.05273372f, -0.05207592f, -0.00920098f, -0.06302865f, 
    -0.01331668f, -0.07193187f, -0.07052524f, 0.03844793f, -0.02746745f, 0.02176435f, 0.02210065f, -0.01481203f, 
    0.06331319f, -0.00771535f, 0.03573580f, -0.00565172f, 0.05724114f, -0.06936106f, -0.01522302f, -0.07309727f, 
    -0.00741196f, 0.06339023f, -0.02510994f, 0.04480910f, -0.01164062f, 0.00272683f, -0.05069546f, 0.06297539f, 
    0.00045925f, -0.05887996f, 0.03730470f, -0.06806348f, 0.01620443f, 0.02690199f, 0.05644326f, -0.03331633f, 
    -0.07333338f, -0.06241195f, -0.00295490f, -0.04472633f, -0.02794760f, 0.04496729f, -0.04902489f, -0.00721258f, 
    -0.07348307f, 0.04035248f, -0.01628564f, 0.04243905f, 0.03689119f, -0.07237664f, 0.06302643f, -0.04239904f, 
    -0.06876907f, -0.04962740f, -0.06943399f, 0.05337891f, 0.05607693f, -0.03178750f, 0.02656708f, -0.01691727f, 
    -0.02376036f, -0.01325364f, 0.00513918f, -0.04839825f, 0.00351402f, 0.04561516f, 0.05329416f, -0.02844794f, 
    -0.04740719f, 0.44036403f, -0.04234147f, 0.12601130f, 0.14548616f, 0.10004016f, -0.18974669f, 0.02311482f, 
    0.08303098f, 0.11444114f, 0.10648841f, 0.11645687f, 0.10879067f, -0.17023781f, -0.14073581f, -0.00926041f, 
    -0.00823724f, -0.10356236f, -0.00566518f, -0.03637815f, -0.02251874f, 0.08610234f, 0.26583934f, 0.26534519f, 
    0.03702742f, 0.40358123f, 0.09549417f, 0.04111020f, 0.08752504f, -0.19354762f, 0.23088537f, -0.10285589f, 
    -0.03847580f, 0.16784245f, 0.00004773f, 0.14630240f, 0.13199322f, -0.04711843f, -0.01670647f, -0.00374215f, 
    0.04451600f, -0.15028191f, -0.10716588f, -0.13111600f, -0.03590301f, 0.02145768f, -0.09063094f, -0.28879604f, 
    0.21180968f, 0.16944563f, 0.23323663f, -0.13948180f, -0.18447702f, 0.06819219f, 0.13181999f, -0.12404579f, 
    0.05275316f, 0.06730544f, -0.00641467f, -0.04189845f, 0.02342037f, -0.15357171f, -0.01595189f, -0.16045858f, 
    -0.05545795f, 0.07106212f, 0.16464481f, 0.11283281f, -0.07237168f, -0.06526938f, 0.23974954f, 0.22646143f, 
    -0.38515371f, -0.39812601f, -0.33323178f, -0.07477175f, -0.08642738f, -0.07576192f, -0.08624575f, 0.12752660f, 
    -0.08742872f, -0.01964513f, -0.04376272f, -0.15721516f, 0.30967513f, -0.07378498f, 0.36593395f, 0.09246027f, 
    -0.01220576f, -0.14016005f, 0.08904948f, 0.07184653f, -0.01001545f, 0.03037949f, -0.14045087f, 0.15578528f, 
    -0.20327914f, -0.12641649f, 0.16059442f, -0.09376644f, 0.00765516f, 0.01901901f, 0.03894084f, 0.25337601f, 
    0.12052761f, -0.07460934f, -0.04184842f, 0.07078745f, 0.11251582f, -0.19343194f, -0.08805485f, -0.08499019f, 
    -0.04805021f, 0.03230654f, 0.07640569f, 0.08051731f, 0.01685732f, 0.15943153f, 0.04016428f, -0.13972533f, 
    0.23922406f, 0.01853486f, -0.10298934f, 0.04641645f, -0.07972341f, -0.08793132f, 0.06896394f, -0.13171047f, 
    0.13495576f, -0.03861542f, -0.04698974f, -0.04169249f, -0.18551409f, 0.14431122f, 0.24009572f, -0.12448440f, 
    0.00691441f, -0.03018538f, -0.02773121f, 0.07432285f, 0.09745982f, 0.06941354f, 0.27274403f, 0.04834525f, 
    0.33794639f, -0.14274704f, -0.07430516f, 0.14050297f, -0.09026291f, 0.04649026f, 0.16891865f, 0.07546444f, 
    -0.02712052f, 0.04159896f, 0.20057198f, 0.23061329f, -0.08086263f, -0.29564342f, 0.15464741f, 0.00334474f, 
    -0.20487849f, 0.25196505f, -0.09746942f, 0.17821017f, -0.11130472f, -0.14119321f, -0.06929158f, -0.07360280f, 
    0.08490036f, -0.02266156f, -0.34349716f, 0.05845363f, 0.14695467f, 0.15149404f, -0.13402452f, 0.22879991f, 
    -0.00362906f, -0.08451799f, 0.02423304f, 0.11991268f, 0.02227265f, 0.15428215f, -0.09468533f, -0.04878731f, 
    0.00510934f, -0.16450213f, 0.12595645f, -0.05346874f, -0.17997244f, -0.10222737f, -0.22695342f, -0.39087868f, 
    0.04914133f, -0.21916029f, -0.41674867f, -0.17159437f, 0.02013087f, -0.02543804f, 0.05702315f, -0.08245251f, 
    -0.07942002f, -0.12432291f, -0.06401289f, -0.13554375f, 0.42637542f, 0.12777531f, 0.21739250f, 0.10782305f, 
    0.16915379f, 0.07567111f, -0.13721159f, 0.13528168f, 0.11900883f, 0.12565960f, 0.02450307f, -0.03054690f, 
    0.22382279f, -0.50927633f, -0.43287900f, 0.02374499f, -0.00474660f, 0.06156755f, 0.07133640f, 0.03071394f, 
    0.01640703f, -0.13909221f, 0.17185387f, -0.00618570f, 0.10968009f, 0.10493125f, 0.04678586f, 0.01179066f, 
    0.01315102f, 0.18016350f, -0.19157153f, -0.12919478f, 0.12037998f, 0.02789416f, 0.12422466f, 0.20370065f, 
    -0.21453686f, 0.08240284f, 0.26414967f, 0.39942300f, -0.04751519f, -0.04847415f, -0.09131607f, -0.04914694f, 
    -0.02893036f, -0.05763032f, 0.07673737f, -0.01744569f, 0.20317832f, -0.21077028f, 0.09617019f, 0.13188215f, 
    0.08839327f, 0.13519964f, 0.02228519f, 0.01579296f, -0.05386418f, -0.06433307f, -0.00012199f, -0.06827945f, 
    0.18224305f, -0.01357201f, -0.10192201f, 0.22517954f, 0.14745696f, 0.26929873f, 0.09169588f, 0.13757908f, 
    -0.00029479f, -0.04583298f, 0.05616106f, 0.07101150f, -0.11868298f, 0.30776402f, 0.33764493f, 0.34614727f, 
    -0.27107859f, -0.14067777f, -0.15882704f, 0.04278764f, 0.06070831f, -0.01591762f, 0.08030059f, 0.00398268f, 
    0.16381358f, -0.00683590f, 0.09289891f, 0.17624910f, -0.05730213f, -0.03638849f, -0.02125579f, -0.06880762f, 
    -0.08477835f, 0.04003040f, -0.04576007f, -0.03273935f, 0.01271387f, 0.14245687f, 0.12673537f, 0.07263378f, 
    -0.10617201f, 0.02629137f, -0.08907194f, -0.01381650f, -0.05669548f, 0.10703605f, 0.02556910f, 0.08184498f, 
    0.10387857f, -0.23287433f, 0.14953382f, 0.00617075f, 0.07119223f, 0.24754354f, -0.09282126f, -0.04758523f, 
    0.05710957f, 0.05391538f, 0.05052409f, 0.04796840f, -0.07519425f, 0.08329340f, -0.09370399f, -0.09150501f, 
    -0.11382680f, 0.07542314f, 0.00816969f, -0.12454081f, 0.03833803f, 0.04878711f, 0.09357561f, 0.17065051f, 
    -0.17800634f, -0.37960666f, -0.22401465f, 0.05957680f, 0.14390771f, 0.13035077f, -0.05812412f, 0.07332268f, 
    0.00761239f, -0.15545383f, -0.06930642f, 0.07496402f, -0.22259499f, 0.28067082f, 0.21797252f, -0.02069216f, 
    -0.13633826f, -0.08147831f, -0.15411372f, 0.13738148f, -0.06035405f, 0.03711420f, 0.07926125f, -0.04601463f, 
    0.22036576f, 0.71790081f, 0.08568749f, -0.42468768f, 0.05077530f, -0.05079371f, 0.22937663f, -0.02242663f, 
    -0.08615466f, 0.02584672f, 0.04262445f, -0.11754112f, -0.11403482f, -0.02380568f, 0.11067789f, 0.14321759f, 
    0.05606776f, 0.21014665f, -0.06761227f, -0.11409000f, -0.05305130f, 0.16433598f, 0.01300258f, 0.05972699f, 
    0.05780104f, 0.00697522f, -0.02276327f, 0.01413398f, -0.05809202f, 0.00121878f, -0.00091607f, -0.04046572f, 
    -0.07455630f, -0.06550960f, -0.00074784f, -0.05276448f, -0.06344911f, -0.01660573f, -0.02368689f, 0.03042298f, 
    -0.06434906f, -0.00292525f, -0.07743166f, 0.01614963f, 0.03290303f, -0.07974978f, -0.03879550f, 0.06072001f, 
    0.00824354f, 0.00442266f, 0.06128306f, 0.03766320f, 0.06132794f, -0.07186502f, 0.00910030f, 0.03368316f, 
    -0.02951225f, -0.02328674f, -0.07257830f, 0.01781284f, 0.03586105f, -0.01134088f, -0.04605332f, 0.03901610f, 
    -0.01270318f, -0.06486589f, -0.01779943f, -0.03823557f, -0.05119123f, -0.04009617f, -0.02549470f, -0.08014590f, 
    -0.06626809f, 0.00558947f, 0.03984155f, -0.06718486f, -0.02617922f, 0.04384275f, -0.03812594f, 0.02353598f, 
    0.01574861f, 0.01214272f, -0.03470568f, -0.03815767f, -0.01068225f, 0.05933374f, 0.04365393f, 0.04555894f, 
    -0.01431407f, -0.03141845f, -0.05983759f, -0.01992897f, 0.04129915f, 0.06216688f, -0.01442607f, 0.01696324f, 
    0.00720711f, 0.00206990f, 0.01056869f, -0.05716863f, -0.02024436f, 0.04936133f, -0.01110551f, 0.04098962f, 
    0.03788432f, -0.02382242f, -0.04215302f, -0.00389715f, 0.05523514f, -0.07429599f, -0.00740974f, -0.04515705f, 
    0.00561293f, -0.04719435f, 0.00966395f, -0.07830937f, 0.01379745f, -0.07161099f, 0.00965166f, -0.01806910f, 
    -0.04749391f, 0.04339557f, -0.05313307f, -0.06787864f, -0.07663749f, -0.03535539f, 0.01406786f, -0.02842477f, 
    -0.04750221f, 0.04367994f, -0.07871538f, -0.04282754f, -0.06279624f, -0.02117755f, -0.04793138f, -0.01156914f, 
    0.05000041f, -0.07518118f, -0.06441938f, 0.00341371f, 0.04236582f, -0.06032747f, -0.04038592f, -0.00040795f, 
    0.04734610f, 0.03877151f, -0.01435620f, -0.04658587f, -0.06248944f, -0.04949566f, 0.01330072f, 0.03776117f, 
    0.02491909f, -0.02686328f, -0.02799277f, -0.04506378f, -0.00152255f, -0.04215461f, 0.01163859f, 0.06230887f, 
    0.06368201f, 0.06169239f, 0.06187557f, 0.05340539f, -0.06257996f, 0.02649254f, -0.05064207f, -0.03139775f, 
    -0.07568023f, 0.05305603f, 0.00830686f, -0.02638261f, -0.02778325f, -0.04011279f, -0.00433618f, -0.02230046f, 
    -0.05531232f, -0.04719701f, -0.00626864f, -0.06907792f, 0.00813427f, -0.03426331f, -0.02882832f, 0.04979840f, 
    -0.05652010f, -0.05656943f, -0.03947768f, -0.03425322f, -0.04625267f, 0.00046344f, -0.06089577f, 0.03168924f, 
    -0.00007039f, 0.01166631f, 0.05471706f, -0.03023408f, 0.03375738f, -0.06083766f, -0.07032537f, -0.04249710f, 
    0.05952255f, 0.05777198f, 0.03702447f, 0.05592983f, -0.07311478f, 0.06056471f, -0.00043768f, -0.00473218f, 
    -0.00294208f, 0.03153179f, -0.07199117f, 0.06225907f, 0.00482793f, -0.01655748f, 0.00479005f, -0.04861034f, 
    0.23684530f, -0.14755817f, 0.30040839f, 0.08396342f, -0.01359568f, -0.10493799f, -0.12556735f, 0.00865004f, 
    0.07606094f, -0.05719098f, -0.13684013f, -0.08847351f, -0.23257290f, 0.19830032f, 0.05231173f, 0.23786761f, 
    0.21670787f, 0.06844278f, 0.03690305f, 0.13057649f, 0.11068644f, 0.05452771f, -0.05888556f, -0.05330926f, 
    0.26732886f, 0.04535643f, 0.37376311f, -0.04628085f, -0.11772139f, -0.14156972f, -0.12932777f, 0.04118364f, 
    0.09861296f, -0.03837022f, 0.19377978f, 0.05741666f, 0.01843204f, 0.07302087f, 0.11072082f, 0.01692616f, 
    0.11684146f, 0.10644998f, -0.01162438f, -0.01684013f, -0.00657929f, -0.12207153f, 0.08516258f, 0.19543663f, 
    0.11433198f, 0.15317284f, -0.21772330f, 0.12171053f, -0.03541794f, -0.15897846f, 0.13206585f, 0.10002092f, 
    -0.03906709f, 0.06276820f, -0.12048557f, 0.11317317f, 0.09253666f, 0.12657790f, -0.11650351f, -0.08269625f, 
    0.12648422f, 0.04336538f, 0.10772520f, 0.14671414f, 0.00436261f, 0.11071002f, -0.01290852f, -0.11142580f, 
    -0.09101852f, 0.26531845f, 0.20683485f, -0.03473047f, 0.08079904f, 0.08155428f, 0.21581760f, 0.23337395f, 
    -0.03993297f, -0.00504712f, 0.05195480f, 0.04750715f, -0.00250305f, -0.36649868f, -0.11077305f, -0.20324108f, 
    0.05924268f, 0.15727536f, -0.04101658f, 0.08871724f, -0.09291204f, -0.13380796f, -0.03470946f, -0.09902013f, 
    -0.16371568f, 0.26030871f, 0.03973065f, 0.04008334f, 0.04291145f, 0.03803727f, 0.10418837f, -0.11945285f, 
    -0.09491878f, -0.01221814f, -0.06234844f, -0.04224819f, -0.14062442f, -0.06663948f, -0.09819259f, 0.08048401f, 
    0.06864740f, -0.11631930f, 0.01215187f, 0.03722949f, -0.02875459f, -0.11185739f, -0.00531474f, 0.01113198f, 
    -0.08621865f, 0.24299395f, -0.08280171f, 0.09387626f, -0.01380429f, -0.03848917f, -0.03853993f, -0.05242296f, 
    -0.05996742f, 0.07161994f, 0.04659004f, 0.01019965f, 0.43312427f, -0.05984304f, 0.09508486f, -0.04548262f, 
    -0.20498583f, 0.01085642f, -0.01085987f, -0.02474954f, 0.13737828f, 0.15514040f, -0.26482496f, 0.08388922f, 
    0.05311939f, 0.30838239f, 0.17632945f, -0.36171240f, 0.03386093f, -0.15882750f, 0.06466819f, 0.01113642f, 
    0.00347956f, -0.06914522f, -0.11516929f, -0.24064158f, 0.02277168f, -0.07687094f, -0.30883417f, -0.16272141f, 
    0.08982504f, 0.12470645f, 0.20758019f, -0.25133842f, 0.05253447f, -0.12826572f, -0.08423832f, 0.04995730f, 
    -0.33693111f, -0.27562115f, 0.20778459f, -0.02180854f, 0.14840116f, 0.20873004f, 0.10181295f, 0.13258432f, 
    0.00538785f, -0.00611106f, -0.08976585f, -0.08638158f, 0.02085787f, -0.16621062f, -0.05777718f, -0.13146654f, 
    0.06562951f, 0.22267324f, 0.01664857f, -0.04655077f, -0.00323038f, 0.04675670f, 0.01233096f, 0.15694280f, 
    -0.06836310f, 0.05956214f, 0.02006760f, -0.04379590f, 0.03775540f, 0.01439525f, 0.03184458f, 0.05454448f, 
    -0.01079874f, -0.00766634f, -0.04931231f, -0.02344153f, 0.04103404f, 0.03828565f, -0.07720996f, 0.03762132f, 
    -0.00618679f, 0.06282524f, 0.05917661f, 0.00999889f, -0.06102558f, -0.00937629f, -0.00401509f, -0.03805127f, 
    0.00371912f, 0.03346552f, -0.03196079f, -0.07200631f, -0.00333595f, -0.00978385f, 0.02528639f, -0.01702460f, 
    -0.04773439f, -0.04993674f, 0.02256379f, 0.04628205f, -0.07610427f, 0.03917591f, -0.03374365f, 0.01308687f, 
    0.02537824f, 0.00116395f, 0.05643858f, 0.03690093f, -0.04948370f, -0.01961268f, -0.06821774f, -0.00492589f, 
    0.02064593f, -0.06202794f, -0.00437221f, -0.06852580f, 0.01116509f, 0.00119754f, 0.01110679f, 0.03502533f, 
    -0.02803815f, 0.01426203f, -0.05750543f, -0.06494286f, 0.02867931f, -0.01225931f, -0.05819709f, 0.02631612f, 
    -0.06143802f, -0.07194418f, -0.07792215f, -0.02215863f, -0.01106518f, -0.02770627f, 0.02149747f, -0.02803412f, 
    0.03000934f, 0.02845492f, -0.03078849f, 0.05668058f, 0.00343855f, 0.00959659f, -0.03822248f, 0.04596156f, 
    -0.01908411f, 0.03459201f, -0.01193052f, -0.06666855f, 0.04472658f, 0.03718938f, 0.05194357f, -0.07467491f, 
    0.00836037f, 0.00102403f, 0.04390532f, 0.01476664f, -0.06630800f, -0.06942249f, -0.03157447f, -0.05295781f, 
    -0.01075187f, -0.04290007f, 0.01771280f, 0.00179128f, -0.04591313f, -0.00446921f, -0.01702744f, 0.02349169f, 
    -0.03006122f, -0.03755084f, 0.04672706f, -0.06725755f, 0.05591485f, 0.05062038f, -0.02964397f, -0.00928799f, 
    -0.04379632f, -0.01710080f, -0.03271544f, -0.05144737f, -0.03216898f, -0.02995365f, -0.06880036f, 0.01859815f, 
    -0.04344016f, 0.01975832f, 0.06348513f, -0.03975663f, -0.01421555f, -0.00659041f, -0.05061966f, 0.02072900f, 
    -0.06432801f, 0.04404260f, 0.01357089f, 0.03237820f, 0.01771121f, -0.01167829f, -0.01975983f, 0.06373204f, 
    -0.05352197f, -0.00035094f, 0.00783873f, -0.03194541f, 0.03268607f, 0.01451730f, -0.05422704f, -0.06546570f, 
    0.04339407f, -0.05397966f, 0.02764588f, -0.03219398f, -0.08029007f, 0.00274741f, -0.07576996f, -0.01566071f, 
    0.02346620f, 0.04642475f, 0.05615200f, -0.03547472f, -0.02191090f, -0.06477629f, 0.06127094f, -0.06665460f, 
    0.05194912f, -0.01686772f, -0.06773531f, 0.03610434f, 0.03678304f, 0.00117740f, -0.01254094f, 0.06065395f, 
    0.01706436f, -0.02163486f, 0.02118142f, -0.07008456f, 0.03147636f, 0.00448568f, -0.03920510f, -0.06898772f, 
    0.01747332f, -0.07651351f, -0.04225684f, 0.01496057f, -0.01891335f, -0.02747308f, -0.00122560f, -0.01428343f, 
    -0.06628124f, 0.01138845f, 0.03656833f, 0.05251078f, -0.07753548f, 0.01774047f, -0.06189341f, -0.00893806f, 
    -0.08525465f, 0.03756252f, -0.05707730f, -0.06083210f, 0.01037703f, -0.01596766f, 0.01903950f, 0.02993154f, 
    0.06077284f, -0.01917417f, 0.07214024f, -0.07340001f, 0.04075163f, -0.00577045f, 0.03522553f, 0.02452829f, 
    -0.04953403f, 0.01792423f, -0.04816987f, -0.02990386f, -0.06227881f, 0.02612904f, -0.02724622f, -0.03021193f, 
    -0.03555863f, -0.01239106f, -0.06649826f, 0.02926548f, -0.05626219f, -0.06638777f, 0.06500049f, -0.07473361f, 
    0.00052329f, -0.01698963f, -0.05615221f, 0.03142110f, -0.04692893f, 0.04257485f, -0.05505243f, 0.03551463f, 
    -0.05925709f, 0.01259357f, -0.01584539f, 0.05730800f, -0.03995380f, -0.05345201f, 0.00505844f, 0.04210314f, 
    -0.05963357f, -0.00931561f, -0.01667913f, 0.01928801f, 0.03059549f, -0.04708132f, -0.00545255f, -0.00834537f, 
    -0.07597698f, 0.05778941f, -0.05185378f, 0.00601638f, -0.02584429f, 0.03022460f, -0.01974656f, -0.01642242f, 
    -0.06599986f, 0.03284712f, -0.05717621f, -0.00732765f, -0.06169222f, -0.05410125f, 0.00736516f, -0.00813440f, 
    -0.04008982f, -0.00715321f, 0.02832321f, -0.04903022f, 0.06054258f, -0.00799718f, 0.07430770f, 0.04647496f, 
    -0.05360332f, -0.02825855f, -0.04761695f, 0.03164026f, 0.02096583f, 0.02105713f, -0.05140663f, 0.00446529f, 
    0.05617118f, -0.04165713f, -0.06267050f, -0.04146656f, -0.05586270f, 0.06390073f, -0.07164206f, -0.07419755f, 
    -0.04034466f, 0.00883833f, 0.02877989f, -0.05112585f, 0.01092765f, 0.01964281f, 0.04132336f, -0.01051931f, 
    0.02491191f, -0.00508941f, -0.03654231f, -0.06875208f, -0.01365012f, 0.03894089f, 0.02431629f, 0.04513589f, 
    -0.01289263f, 0.04083366f, -0.00344035f, 0.06168737f, -0.07730311f, -0.05905776f, -0.05524760f, -0.00466756f, 
    -0.02550016f, -0.04263932f, 0.05011608f, 0.04075045f, -0.04272468f, -0.04853640f, 0.02603276f, -0.00593474f, 
    -0.01390114f, -0.00397076f, -0.06816312f, -0.06587997f, -0.02531623f, 0.06188773f, -0.07239169f, -0.03129132f, 
    -0.00068573f, 0.02204736f, -0.07177605f, 0.05841903f, 0.06293148f, -0.04858525f, -0.02875968f, -0.02996192f, 
    0.04353233f, -0.02755768f, -0.02371150f, -0.05793100f, 0.06190356f, 0.03408980f, 0.00900798f, 0.05597463f, 
    -0.04000514f, 0.03303566f, 0.06719781f, -0.04198369f, -0.04091791f, 0.00820129f, 0.00452864f, 0.00099644f, 
    -0.05042354f, 0.02534048f, 0.01933789f, -0.00200282f, 0.02860138f, -0.01221628f, -0.05577401f, -0.06182954f, 
    0.00218811f, 0.02885829f, 0.05486887f, -0.01431663f, 0.01117680f, -0.04518664f, -0.04802947f, -0.01115043f, 
    -0.01177172f, 0.02893432f, -0.06784344f, 0.02207437f, 0.06436156f, 0.03128319f, -0.04815664f, -0.02748337f, 
    -0.01121445f, -0.05865217f, -0.01825555f, -0.00816146f, 0.02760899f, 0.00825519f, -0.06640542f, 0.04796632f, 
    -0.00899096f, -0.03979439f, -0.05754145f, -0.06688581f, 0.05944463f, 0.04592170f, 0.05807903f, -0.04073430f, 
    0.01112349f, -0.05688632f, -0.02023889f, 0.01257833f, 0.00705620f, -0.01954263f, -0.01399757f, -0.06210868f, 
    0.05617945f, -0.02547436f, -0.00356020f, 0.05049502f, -0.00662650f, -0.03749065f, -0.08034610f, -0.06299474f, 
    -0.00728467f, 0.05692237f, -0.04854876f, -0.05068319f, 0.03551868f, 0.01298869f, -0.03132788f, 0.04440559f, 
    0.00538660f, -0.03428505f, 0.01818625f, -0.06413557f, -0.06970173f, 0.05820014f, 0.02181929f, -0.00546386f, 
    -0.07622946f, -0.04960391f, 0.05816588f, -0.03252975f, -0.07079432f, 0.00172206f, -0.00787090f, -0.06878719f, 
    0.01165538f, -0.02776553f, 0.05275121f, -0.00829509f, -0.05129434f, -0.05886105f, 0.03923571f, 0.01679149f, 
    -0.03713851f, -0.00973961f, -0.00303923f, -0.05553322f, 0.04033132f, -0.00291572f, -0.01353933f, -0.00286397f, 
    0.01412310f, 0.01676837f, -0.04294498f, 0.00088715f, -0.07137980f, 0.00905282f, -0.07347859f, 0.04084122f, 
    -0.01182271f, 0.02447420f, -0.02754887f, 0.06199287f, -0.02759216f, -0.03521406f, 0.02674385f, -0.02330791f, 
    0.06168275f, 0.00781947f, -0.00505553f, 0.03594376f, -0.05462171f, 0.00635894f, -0.04218119f, 0.00907324f, 
    -0.04780692f, 0.01393352f, -0.00337630f, 0.06439437f, -0.06257971f, 0.03650989f, -0.06623624f, -0.04261783f, 
    0.05740998f, -0.04001886f, 0.01527573f, -0.03851756f, 0.00341903f, 0.06747586f, -0.00961920f, 0.03122054f, 
    0.04846985f, -0.06406806f, 0.01236445f, -0.06059798f, 0.01317154f, 0.04504012f, 0.04887056f, 0.06217534f, 
    -0.00772497f, 0.01604290f, -0.06580153f, -0.05251107f, -0.01777386f, 0.05763496f, 0.03072294f, 0.00133945f, 
    0.02307948f, 0.02792589f, -0.03575787f, 0.02186361f, 0.00949303f, -0.05013255f, 0.05506097f, -0.06717236f, 
    0.03392754f, -0.02780968f, 0.00741376f, 0.04173796f, -0.07984061f, 0.03558031f, -0.01539575f, 0.02297475f, 
    0.02835388f, -0.02691173f, 0.00331462f, -0.03640859f, 0.05270316f, 0.00990945f, -0.01021561f, -0.05725364f, 
    0.00787369f, 0.00688887f, -0.01563561f, -0.04923432f, -0.04591587f, 0.05123299f, -0.06836867f, -0.03368710f, 
    -0.04506528f, -0.03246650f, 0.04911866f, 0.00807248f, -0.03765651f, -0.02768649f, -0.02143381f, 0.01260285f, 
    -0.02915000f, 0.05454999f, -0.01728537f, 0.03156805f, 0.03931143f, -0.02528575f, 0.02407154f, -0.02822830f, 
    0.00505439f, 0.03053564f, -0.03332223f, 0.02168393f, -0.06585839f, -0.03051539f, -0.02753339f, -0.06766383f, 
    -0.00620973f, -0.07249431f, 0.04531053f, -0.05530835f, -0.03246520f, 0.05571504f, -0.05674605f, -0.03577905f, 
    0.05423960f, 0.04356650f, -0.01692193f, -0.00114673f, -0.01117670f, -0.03153722f, -0.03051238f, 0.04067932f, 
    -0.00240558f, -0.00075971f, 0.02276205f, 0.04889292f, 0.01922165f, 0.03095999f, -0.03388304f, -0.02439039f, 
    0.00653545f, -0.04638944f, -0.02167446f, 0.01438986f, 0.05188190f, -0.04336513f, 0.05615735f, 0.05198381f, 
    0.03123860f, 0.01395157f, -0.05266953f, 0.01116601f, -0.03981895f, 0.02432438f, 0.04790962f, 0.05012593f, 
    -0.00478839f, -0.00695953f, -0.01443163f, -0.03212375f, -0.04787095f, 0.05145172f, -0.07144658f, -0.03478847f, 
    0.01541738f, -0.05939878f, -0.02043584f, -0.01693113f, 0.00856144f, 0.02009749f, -0.06837338f, 0.01853231f, 
    0.05201659f, 0.04737844f, -0.04895207f, 0.02203451f, 0.01235800f, -0.05010189f, -0.06969666f, 0.01559707f, 
    -0.06720519f, 0.04371892f, -0.06420317f, -0.06560298f, -0.00362193f, -0.05991279f, -0.02978902f, 0.05985222f, 
    0.00428615f, 0.06246762f, 0.02389617f, -0.05222955f, 0.04555701f, -0.02412814f, 0.05141429f, -0.05823005f, 
    -0.05330971f, -0.03558384f, 0.01611659f, 0.01708664f, -0.06403533f, -0.01390099f, -0.02505285f, 0.04166618f, 
    0.01262041f, -0.06598652f, 0.00157963f, -0.00863209f, -0.00075403f, -0.02122613f, -0.03207050f, -0.05220185f, 
    -0.01096062f, -0.00670331f, -0.02946899f, -0.02542597f, -0.06883708f, 0.02914525f, 0.00365697f, 0.00449769f, 
    -0.07170247f, -0.05754502f, -0.05330662f, 0.04792319f, -0.01313525f, 0.01964254f, -0.03066734f, -0.06460813f, 
    0.06083744f, 0.04195754f, 0.03181106f, -0.03865517f, -0.02483465f, -0.01262453f, -0.05044778f, -0.01307443f, 
    0.01104739f, 0.04377779f, 0.00789188f, -0.00813081f, -0.00366276f, -0.00034457f, -0.03184714f, -0.06798950f, 
    -0.05072389f, -0.06742538f, -0.00535562f, -0.00197475f, -0.04240173f, 0.02358454f, 0.03506026f, -0.05438940f, 
    -0.02211741f, -0.06621355f, 0.00909304f, 0.01598814f, 0.02376810f, 0.06821644f, 0.00317491f, 0.03589677f, 
    -0.01445409f, 0.06546915f, -0.04433817f, -0.03238884f, 0.01134101f, 0.02565831f, 0.05591778f, 0.02327147f, 
    0.02115464f, 0.03670479f, -0.01452635f, -0.04685196f, 0.05465499f, -0.02793196f, -0.03758494f, -0.04577465f, 
    0.05912335f, -0.01287808f, -0.04923687f, 0.01371525f, -0.03283701f, 0.00569989f, 0.01267178f, 0.03484964f, 
    -0.06464544f, -0.00224868f, -0.04383129f, -0.02836761f, -0.00607398f, -0.00146055f, 0.04116078f, -0.02907893f, 
    -0.06770475f, 0.05681876f, 0.00846032f, 0.01920791f, -0.04454817f, -0.04585307f, -0.06816476f, 0.07154786f, 
    -0.07097481f, 0.04272692f, 0.00193029f, 0.01687009f, 0.00731440f, 0.02020941f, -0.01430685f, -0.00940974f, 
    0.00083821f, 0.01660148f, -0.00405192f, -0.04369875f, -0.06517739f, -0.00003343f, -0.07112306f, 0.04556358f, 
    0.03372950f, -0.07078800f, -0.06061194f, -0.05483231f, 0.05641596f, -0.02479248f, 0.04911270f, -0.00381427f, 
    0.25780588f, -0.16306177f, 0.31582707f, -0.08121659f, 0.02932082f, -0.05600065f, -0.19853586f, -0.09711646f, 
    -0.02280789f, -0.10708310f, -0.14392057f, -0.07112274f, 0.02624424f, 0.17600559f, 0.17910269f, 0.04751617f, 
    0.10676511f, 0.00112018f, -0.05143759f, 0.04121574f, 0.04599997f, 0.05782965f, -0.17936116f, -0.17121972f, 
    -0.04040179f, -0.04203650f, 0.13929383f, -0.13233536f, -0.14390050f, 0.00141518f, -0.21826215f, 0.07303896f, 
    0.19778654f, -0.02253781f, 0.07683338f, 0.06417210f, -0.09155684f, 0.07316434f, 0.05470808f, 0.07935251f, 
    0.14806938f, 0.10898265f, 0.04676643f, -0.03692205f, 0.10470419f, -0.03054973f, 0.05923474f, 0.27308604f, 
    0.13608533f, 0.15754195f, -0.25491413f, 0.29228580f, -0.04382398f, -0.14550509f, 0.06078670f, 0.05168748f, 
    -0.05743082f, 0.07624222f, -0.18906720f, 0.12008563f, -0.03818161f, 0.20733981f, -0.07507546f, -0.03590979f, 
    0.09895917f, 0.06474715f, 0.08146144f, 0.13784863f, 0.02876526f, 0.16002215f, 0.06474150f, -0.13910581f, 
    0.00727629f, 0.26594853f, 0.20605446f, 0.02405877f, 0.01983266f, 0.07920768f, 0.24388577f, 0.06207583f, 
    0.02648167f, -0.12116921f, -0.10726734f, 0.06781527f, -0.15110447f, -0.37205711f, -0.12691537f, -0.13686846f, 
    0.07307668f, 0.08484913f, -0.11857542f, 0.06384079f, -0.19851559f, -0.22135785f, -0.06020311f, -0.17787771f, 
    -0.16323555f, 0.11194967f, 0.15355939f, 0.11614794f, 0.01324238f, -0.01504939f, 0.14366324f, -0.12369453f, 
    -0.19534799f, -0.01436144f, -0.10723790f, -0.16236013f, -0.13674171f, -0.06254239f, -0.03294263f, 0.11093751f, 
    -0.13661028f, -0.20087720f, -0.17879429f, -0.02047423f, -0.09646771f, -0.11029436f, -0.00080480f, 0.05318043f, 
    -0.13141096f, 0.11224546f, -0.03311122f, 0.06413077f, -0.05825839f, -0.08832495f, 0.00769286f, -0.00904184f, 
    -0.02374774f, 0.05322550f, 0.13207288f, 0.08436483f, 0.41103274f, -0.08855248f, -0.11954791f, 0.06590191f, 
    -0.19353859f, -0.03066564f, -0.06035982f, -0.02001387f, 0.07940751f, 0.00915667f, -0.13967963f, 0.13925666f, 
    -0.00842450f, 0.16991740f, -0.06958986f, -0.23181391f, 0.00654744f, -0.18604833f, 0.02685535f, 0.09992369f, 
    0.03758925f, -0.12771516f, -0.12731415f, -0.11250906f, -0.14822544f, -0.03142259f, -0.32560739f, -0.17461811f, 
    -0.02665855f, 0.00822799f, 0.12668897f, -0.15307914f, -0.04391699f, -0.06576429f, -0.01771027f, 0.07085495f, 
    -0.32159826f, -0.04415596f, 0.18258482f, 0.01821064f, 0.12628867f, 0.15184267f, 0.18518373f, 0.06416839f, 
    -0.05166440f, 0.04732413f, 0.00457881f, -0.06720736f, 0.01849749f, -0.08788376f, -0.03900447f, -0.11607454f, 
    0.04314065f, 0.16568507f, -0.03686005f, 0.02478283f, 0.10076323f, -0.02400413f, 0.00463033f, 0.05936937f, 
    0.01764501f, -0.00835968f, -0.01489436f, -0.04814161f, 0.03397402f, -0.01071752f, 0.03984348f, 0.01371294f, 
    0.02372179f, 0.01722463f, -0.04088599f, -0.00664686f, 0.04920553f, -0.00599286f, -0.03660551f, -0.03240478f, 
    0.02794798f, -0.00194538f, -0.02359393f, 0.05552186f, 0.02737368f, -0.00521958f, 0.02032953f, 0.02503651f, 
    -0.04062889f, -0.04290831f, -0.08299674f, 0.05296054f, -0.03040333f, 0.05151694f, -0.01042661f, -0.06674211f, 
    0.03966155f, -0.06184063f, 0.04179561f, 0.01732623f, -0.02717233f, 0.02040806f, 0.01035314f, -0.02989759f, 
    -0.01201886f, -0.05747999f, -0.06822184f, 0.04233270f, -0.05499048f, -0.06015106f, 0.00490086f, -0.05317531f, 
    0.06853550f, 0.05266110f, -0.02772029f, -0.01981876f, -0.07359702f, -0.03199617f, -0.02562658f, -0.00421203f, 
    0.05134189f, 0.00180421f, -0.03007504f, -0.00665601f, -0.00590333f, -0.02757689f, -0.07409731f, -0.00645710f, 
    -0.06099368f, -0.08164410f, -0.02906970f, -0.00307974f, -0.04481501f, 0.04686620f, 0.05708726f, -0.02853271f, 
    -0.07125813f, 0.01606844f, 0.06079299f, 0.01859427f, 0.06071286f, 0.05385200f, 0.05521088f, 0.03418173f, 
    0.01251204f, 0.00706701f, -0.07066041f, -0.06082646f, -0.07077541f, 0.06094554f, -0.03006623f, 0.04375034f, 
    -0.00750897f, -0.03843745f, -0.05478224f, -0.04922686f, -0.02873589f, 0.02269813f, 0.03964768f, -0.07697151f, 
    -0.06867908f, 0.02210667f, 0.00048142f, 0.03461557f, -0.05791567f, -0.02233297f, -0.02863545f, 0.01498987f, 
    -0.03774752f, 0.03541982f, -0.05977534f, -0.04284455f, -0.05861194f, -0.02108607f, -0.01105066f, 0.04110304f, 
    -0.00045070f, 0.01666395f, 0.04488351f, -0.02953894f, -0.07638077f, 0.00686279f, 0.02918365f, 0.03707582f, 
    -0.01076532f, -0.01334060f, 0.06329013f, 0.04311404f, -0.05350649f, -0.05998802f, -0.01529066f, 0.04137911f, 
    0.04657478f, -0.05030667f, 0.02861070f, -0.06475522f, -0.03915085f, -0.01660755f, 0.05906910f, 0.04448788f, 
    -0.02362951f, -0.01882894f, -0.07493880f, -0.05831262f, 0.00867106f, -0.05480077f, -0.03512138f, -0.00295997f, 
    -0.07623082f, -0.03974352f, -0.03539848f, 0.01022771f, -0.07334399f, 0.05470311f, -0.03440408f, 0.04622475f, 
    -0.06969823f, -0.03860459f, 0.01174065f, -0.00237940f, -0.01291060f, -0.03336696f, -0.00363172f, -0.01797967f, 
    -0.02620992f, 0.02020736f, -0.03998841f, 0.03972900f, -0.04828272f, -0.02488375f, -0.07429632f, 0.06267523f, 
    0.01536283f, -0.03802541f, -0.04319106f, -0.03689807f, -0.02482494f, 0.03479647f, -0.05607235f, 0.01207528f, 
    -0.06264859f, 0.03558167f, -0.02975214f, -0.06440151f, 0.04822963f, -0.03421930f, -0.00800795f, -0.01536989f, 
    -0.07316212f, -0.02111754f, -0.04314306f, -0.04279704f, -0.02416282f, 0.02425493f, 0.01980607f, -0.07176888f, 
    0.02830640f, 0.03808895f, 0.02580873f, -0.02015467f, -0.04148478f, 0.01047857f, -0.06656563f, 0.02530324f, 
    0.02627375f, 0.05852257f, -0.06047884f, -0.00318131f, 0.02957664f, 0.05181493f, 0.02328692f, -0.06934876f, 
    0.01518402f, -0.05752507f, 0.01325150f, -0.02628022f, -0.00983490f, 0.02988920f, -0.07000286f, -0.07925849f, 
    -0.07357201f, -0.04530554f, -0.02884809f, -0.03793458f, 0.02443404f, 0.00132893f, 0.05737272f, -0.02527269f, 
    0.01736835f, -0.04405591f, 0.00786696f, -0.06387802f, 0.05162103f, -0.00371459f, -0.03812338f, -0.04451705f, 
    -0.02488266f, -0.01444972f, -0.07508797f, -0.04481386f, -0.04519863f, 0.02571478f, 0.04942057f, 0.00725903f, 
    -0.04621771f, 0.04573690f, -0.07325464f, 0.05019881f, 0.03875541f, -0.00848027f, -0.00499260f, -0.06686307f, 
    0.01934265f, 0.03429367f, -0.02175852f, -0.02312260f, 0.04876838f, -0.02046406f, 0.03321051f, -0.00135485f, 
    -0.07901502f, -0.00364668f, -0.04729591f, 0.03106477f, -0.06600254f, -0.04964028f, -0.05853264f, -0.01777769f, 
    -0.00045783f, 0.05567890f, 0.04481061f, -0.02479907f, -0.04926757f, 0.05382771f, -0.02338524f, 0.05213559f, 
    0.03790257f, -0.03058146f, -0.01561889f, 0.00243411f, 0.04318457f, 0.02097853f, 0.01012427f, -0.01514180f, 
    -0.04792287f, 0.00894110f, -0.00805418f, -0.05227229f, -0.01753492f, 0.00092660f, -0.06938776f, 0.03938246f, 
    0.00591247f, -0.04862144f, 0.02116094f, 0.00365092f, -0.02101042f, -0.05557343f, 0.00743374f, -0.05715131f, 
    -0.01447109f, -0.05672453f, 0.04528932f, -0.00153833f, -0.00805503f, 0.03156414f, -0.05624855f, 0.01654168f, 
    0.03171222f, -0.05501235f, 0.02629600f, 0.06187296f, 0.00697342f, -0.03053004f, -0.07754006f, -0.03177525f, 
    -0.05815761f, 0.04779714f, -0.00252747f, 0.03228517f, -0.07255790f, -0.03133824f, -0.06591271f, -0.01368584f, 
    -0.04457110f, 0.01910102f, 0.01079443f, -0.01591793f, 0.02832284f, 0.07185699f, 0.01061083f, 0.04179783f, 
    -0.03492827f, 0.01210356f, -0.05046951f, -0.04217002f, -0.07249203f, -0.00554331f, 0.05338229f, 0.04039425f, 
    -0.08595523f, -0.02496703f, 0.05158385f, 0.01376499f, 0.05408643f, -0.07042538f, -0.04667493f, -0.03199810f, 
    0.05461647f, 0.02211642f, -0.02075534f, -0.00427710f, 0.01754508f, 0.03832420f, -0.03246816f, 0.01922909f, 
    0.03730997f, 0.04624279f, -0.01874917f, 0.03285260f, 0.01284728f, -0.04575525f, 0.05739187f, -0.05380730f, 
    -0.08402739f, -0.02744276f, 0.03436193f, -0.03352832f, -0.06378599f, 0.00678136f, -0.04957811f, -0.03241423f, 
    -0.04910027f, -0.05904312f, -0.00342179f, -0.01713017f, -0.06435349f, -0.04694531f, 0.06888919f, -0.04325672f, 
    -0.08242932f, 0.02739699f, -0.00024465f, -0.02695541f, 0.06103473f, 0.03641809f, 0.00584529f, -0.00970435f, 
    -0.05663401f, -0.04668690f, 0.06311107f, -0.16557695f, -0.02103179f, -0.05390264f, -0.18592240f, -0.09416801f, 
    0.13201162f, 0.01639479f, 0.12415628f, -0.11483461f, -0.07045561f, -0.12912816f, -0.12786442f, 0.17020372f, 
    0.11666191f, -0.08072729f, -0.14999214f, -0.07031402f, -0.03061665f, 0.06305364f, 0.20911084f, 0.04965980f, 
    -0.07614525f, -0.15117741f, 0.13701910f, 0.04711444f, -0.01445079f, -0.21061188f, -0.13229096f, 0.11696937f, 
    -0.07122312f, 0.04424594f, 0.06785974f, 0.24663846f, 0.11440808f, -0.16499479f, 0.00618496f, -0.07506735f, 
    0.09476575f, -0.02389462f, -0.04592901f, -0.00880337f, 0.08143964f, -0.08179846f, -0.04763496f, -0.14731456f, 
    -0.28985184f, 0.01756441f, 0.16451633f, 0.00605382f, -0.00512911f, 0.08436192f, -0.01236692f, -0.02877123f, 
    -0.05040274f, -0.04945187f, 0.00047666f, -0.03304785f, -0.15396254f, -0.27576464f, 0.03404366f, 0.21260053f, 
    0.02968631f, -0.04182483f, 0.09104615f, -0.00031717f, 0.00411934f, -0.00042099f, -0.00808817f, 0.08910808f, 
    -0.15527487f, -0.27029988f, -0.13663316f, 0.11774629f, -0.04838558f, -0.10896143f, -0.03059603f, -0.00432086f, 
    0.03646802f, -0.06967645f, -0.08150848f, -0.10447884f, -0.03243273f, 0.15911473f, 0.31243461f, 0.27679768f, 
    -0.13755858f, 0.07084026f, 0.04974799f, 0.19416478f, 0.06776607f, -0.03723438f, -0.04411587f, -0.06836867f, 
    -0.01494302f, 0.09493325f, 0.18361036f, 0.15401611f, 0.19685774f, -0.01457399f, 0.01811327f, 0.09372201f, 
    -0.06534895f, 0.01993453f, 0.04971363f, -0.00459678f, -0.03067018f, 0.09384236f, -0.03272735f, -0.00953373f, 
    0.01920640f, 0.07021592f, -0.03717324f, -0.03787604f, -0.01530751f, 0.03678556f, 0.03502226f, -0.08725911f, 
    0.13724694f, -0.13000910f, -0.25200936f, -0.10617769f, 0.07465040f, 0.02212174f, -0.00077922f, -0.04395194f, 
    0.04480099f, -0.02572503f, 0.06160266f, -0.16674164f, -0.09128062f, 0.11370524f, 0.09864797f, -0.17588122f, 
    -0.06991412f, -0.07157526f, -0.05201412f, -0.09849974f, 0.11094907f, -0.17436169f, -0.01826384f, 0.02084487f, 
    -0.12321007f, -0.29698738f, -0.09218571f, 0.06016014f, -0.16221406f, -0.22639124f, 0.13921498f, -0.06401746f, 
    -0.05278167f, 0.06021013f, 0.04181050f, 0.04714004f, -0.33298731f, 0.01440748f, 0.57748234f, -0.01368791f, 
    -0.17888430f, 0.14018822f, -0.16382806f, 0.27524385f, 0.08886832f, -0.07943793f, 0.02747566f, -0.12316060f, 
    0.01683511f, -0.12289172f, 0.07486555f, -0.06297578f, 0.03440426f, 0.05626969f, 0.03015607f, -0.10012285f, 
    0.07307933f, -0.04616613f, -0.01363881f, 0.05573104f, -0.21822214f, -0.03247445f, -0.02186165f, -0.00139915f, 
    0.04560144f, 0.08731790f, 0.12384716f, -0.00217620f, 0.06236723f, -0.05746535f, -0.00272407f, -0.03212962f, 
    0.05396078f, -0.05877446f, -0.05474929f, 0.03775319f, -0.02580528f, -0.05119051f, -0.00109675f, -0.05864114f, 
    -0.01488641f, 0.02568266f, -0.00035924f, -0.05518891f, -0.07937038f, -0.00373947f, 0.06379893f, -0.06850866f, 
    -0.01289110f, 0.04201719f, -0.04978584f, 0.03559352f, -0.03857186f, 0.03449347f, 0.05226667f, -0.02839324f, 
    0.04786725f, 0.04039943f, -0.04781026f, 0.01926426f, -0.02346354f, 0.05092795f, -0.01110237f, -0.04003269f, 
    0.01592667f, -0.05936016f, -0.06232950f, 0.04803075f, -0.04515208f, -0.02778386f, 0.04014045f, 0.00937524f, 
    -0.03088061f, -0.06740084f, -0.06908473f, 0.00197482f, -0.01515983f, 0.02944568f, -0.04605219f, 0.00733801f, 
    0.02942243f, 0.00750596f, -0.05965474f, 0.00747707f, -0.05143086f, 0.01755788f, 0.05545307f, -0.05269217f, 
    0.00661070f, 0.03350729f, -0.00076008f, -0.00639154f, -0.01839809f, 0.02054283f, -0.04245452f, -0.01630834f, 
    -0.03839638f, 0.01748717f, -0.01477957f, -0.00899132f, -0.06662229f, 0.03928898f, 0.03632092f, 0.02497865f, 
    -0.02992104f, 0.00149926f, 0.06314176f, 0.04909871f, 0.03769469f, 0.02549353f, 0.06251342f, 0.02292511f, 
    -0.03965388f, -0.05904362f, 0.01108958f, -0.06664023f, -0.01645739f, 0.05762748f, 0.01420421f, -0.03003061f, 
    0.00761187f, 0.01938601f, -0.07944046f, -0.03680125f, 0.04628302f, -0.03530395f, 0.04614013f, -0.02657832f, 
    -0.04132763f, 0.02096970f, -0.03758124f, -0.07106018f, -0.01241600f, 0.05412616f, -0.02762035f, -0.06628536f, 
    0.05209670f, -0.06252903f, 0.05826828f, 0.04156194f, -0.00017239f, -0.01967653f, 0.00652194f, -0.04621140f, 
    -0.05201062f, -0.06304827f, -0.07960580f, -0.04810610f, -0.01012059f, -0.00815095f, -0.06535395f, -0.04752694f, 
    0.04335542f, -0.04866522f, 0.04828256f, -0.01537609f, -0.01860320f, -0.01501640f, 0.05472021f, 0.06053055f, 
    -0.06728868f, -0.03624875f, 0.02071187f, 0.01002469f, -0.04796693f, 0.01830541f, -0.04076447f, 0.06823903f, 
    -0.05428121f, 0.04951360f, -0.05867397f, -0.04225445f, 0.04982601f, 0.00593205f, -0.05626775f, 0.01698367f, 
    0.02592364f, 0.05028581f, -0.04292210f, 0.05082039f, 0.01035107f, -0.05439402f, -0.05357968f, 0.04758114f, 
    -0.01317847f, -0.02632432f, -0.01891756f, -0.02108578f, 0.04315522f, -0.01664768f, -0.01594265f, 0.01883173f, 
    0.01249607f, -0.00200139f, -0.06378376f, 0.00185763f, -0.00798723f, 0.00620259f, -0.05832153f, 0.00451274f, 
    0.05669044f, -0.05900563f, -0.01407786f, 0.04433048f, 0.03479218f, -0.01697239f, -0.05212042f, -0.01792021f, 
    0.01034382f, -0.04054311f, -0.05522541f, 0.00885246f, -0.03996554f, 0.02347373f, -0.02768769f, -0.01930975f, 
    -0.02243528f, -0.07753171f, -0.05443088f, -0.06433959f, 0.04458477f, -0.01876953f, -0.05331905f, -0.04982591f, 
    -0.35583106f, 0.26737666f, 0.08292833f, 0.10901194f, -0.11875343f, -0.13944608f, -0.00991330f, -0.07013535f, 
    -0.03663682f, -0.05652047f, 0.05083714f, 0.06026759f, -0.13492297f, -0.09056617f, -0.14941657f, -0.05113556f, 
    0.06913265f, -0.02392506f, 0.16370037f, -0.00569629f, 0.00861314f, 0.15922308f, 0.05019114f, 0.05217677f, 
    0.32989174f, 0.40062723f, 0.22852507f, 0.08673461f, 0.00400238f, 0.00450301f, 0.13193837f, -0.10129853f, 
    0.09188125f, 0.23259977f, 0.14971471f, 0.13355018f, 0.16290843f, 0.16038112f, 0.06521658f, -0.05530034f, 
    0.00246387f, -0.17134468f, -0.10197071f, -0.09025661f, 0.01795759f, 0.03515407f, -0.09943084f, -0.00843805f, 
    0.16205013f, 0.06580842f, 0.24907307f, -0.06450515f, -0.08914011f, -0.13100177f, 0.00892795f, -0.01565261f, 
    -0.10199068f, 0.00431157f, 0.12359021f, -0.02525894f, 0.20762645f, 0.07515585f, 0.02430477f, -0.04718851f, 
    0.10598578f, 0.14267990f, 0.10929823f, 0.23149347f, -0.19638880f, -0.08479792f, 0.00148031f, -0.00971445f, 
    -0.42257586f, -0.15644623f, -0.13239127f, 0.06151256f, -0.15261771f, 0.06681935f, -0.12088302f, -0.02696167f, 
    -0.25241822f, -0.09378169f, -0.12980640f, -0.00198465f, 0.28930396f, -0.10039137f, 0.25090590f, 0.15645745f, 
    -0.05163001f, -0.10044485f, -0.01720985f, -0.19057712f, -0.00139725f, 0.04470726f, -0.12794547f, 0.18211332f, 
    -0.10299850f, -0.45945999f, 0.09282124f, -0.38572374f, 0.01453777f, 0.07617075f, 0.00489454f, 0.15691525f, 
    0.01370240f, 0.06268700f, -0.00449252f, 0.14120658f, 0.13001913f, 0.05296153f, -0.03707323f, 0.01832421f, 
    -0.05597006f, -0.03677370f, -0.00881172f, -0.10367065f, -0.05432396f, 0.02294939f, -0.06404873f, -0.12206210f, 
    0.00876983f, 0.25041530f, -0.00988798f, 0.13272858f, -0.02570929f, -0.14282723f, 0.08417225f, -0.17349584f, 
    -0.00303635f, -0.05989502f, -0.11701432f, 0.00085542f, 0.17800562f, 0.25343606f, 0.14976935f, 0.02273027f, 
    -0.13629286f, -0.05653845f, -0.09069896f, 0.05930026f, 0.01331197f, 0.17194968f, 0.23044197f, -0.07686395f, 
    0.18505687f, 0.17264193f, 0.31383780f, -0.04263942f, 0.05841290f, 0.13632733f, 0.06237819f, -0.02547191f, 
    -0.11515684f, 0.12665404f, 0.23607503f, -0.06154504f, -0.04728716f, -0.29857609f, -0.22075385f, -0.07546075f, 
    0.09045602f, -0.19091550f, -0.01543013f, -0.25856894f, -0.08004674f, -0.03542613f, -0.08758772f, 0.00630887f, 
    -0.13068879f, -0.14694849f, -0.36074916f, 0.10185540f, 0.13529901f, -0.00420666f, -0.01210932f, 0.07852997f, 
    -0.06923853f, -0.18193133f, -0.02387764f, 0.08186519f, 0.04798932f, -0.10585404f, -0.01705833f, -0.09372422f, 
    0.02953014f, 0.01684547f, 0.13369833f, -0.06195109f, -0.02866487f, -0.01419968f, 0.03074076f, -0.12948374f, 
    -0.19927101f, 0.24364325f, 0.11261366f, 0.09674726f, -0.03559943f, 0.01854528f, -0.08170227f, 0.12601373f, 
    0.01962958f, 0.19482817f, 0.05260744f, 0.10569955f, 0.12307172f, 0.06204806f, -0.00799268f, -0.28073013f, 
    -0.23809217f, 0.07558128f, 0.08852624f, 0.00775085f, -0.18011266f, 0.04306403f, -0.01398626f, 0.08991241f, 
    -0.38670915f, 0.42760110f, -0.03746068f, 0.21142080f, 0.06911698f, -0.06237308f, -0.01308308f, 0.06561251f, 
    0.16831407f, 0.06951977f, 0.07586946f, -0.03171308f, 0.01700842f, 0.07993445f, -0.21490566f, -0.04581784f, 
    -0.15655459f, -0.03464027f, -0.02161574f, 0.06857669f, -0.19574092f, -0.03321467f, -0.18273848f, -0.24112990f, 
    0.21452887f, -0.21457258f, -0.01685048f, -0.12925541f, -0.10125130f, 0.10645949f, 0.04785698f, 0.02261433f, 
    0.04181038f, 0.00819574f, -0.08984472f, 0.05265266f, -0.18343793f, 0.07518008f, -0.04704205f, 0.03068398f, 
    -0.02623118f, 0.00208728f, -0.01016761f, -0.04970495f, 0.05750636f, 0.09973075f, -0.07553555f, 0.07342296f, 
    0.30460384f, 0.02242975f, -0.00384673f, -0.27896637f, 0.05171180f, -0.02282870f, -0.16315605f, -0.28381714f, 
    -0.03371780f, 0.02401994f, -0.06377558f, -0.02502983f, 0.05524283f, -0.23197241f, -0.11205211f, -0.08669959f, 
    0.08759510f, 0.05873492f, 0.07316488f, 0.13637713f, -0.07085794f, -0.06912203f, -0.04143834f, -0.08001730f, 
    0.17689468f, 0.07331921f, 0.43117407f, -0.20571619f, 0.02928155f, 0.20189038f, 0.00954487f, -0.00475331f, 
    -0.03603008f, -0.03175072f, 0.12486900f, -0.08549728f, 0.00660463f, -0.25709316f, -0.13139595f, -0.12710947f, 
    -0.04846139f, -0.11157514f, -0.04043695f, 0.03925214f, -0.08013155f, -0.12504451f, 0.10499443f, -0.25117379f, 
    -0.10988648f, 0.08820806f, -0.01829023f, -0.01952712f, -0.16946316f, -0.07848314f, -0.13976872f, 0.23343560f, 
    0.01936701f, -0.02180689f, -0.12647866f, -0.04133119f, 0.01510765f, -0.06399988f, -0.10205450f, 0.07866200f, 
    -0.01978067f, -0.07798005f, 0.01215124f, 0.06599616f, 0.05370690f, -0.14073098f, -0.13744144f, -0.01614686f, 
    0.13865952f, 0.31442115f, -0.11843365f, 0.12490498f, 0.05835063f, -0.02827820f, 0.06140006f, 0.15654083f, 
    0.11244562f, -0.08529894f, -0.01492309f, 0.10025579f, 0.16263461f, -0.11756700f, -0.15490012f, 0.19790293f, 
    0.09018298f, 0.29158500f, -0.02488817f, -0.09397784f, -0.04429648f, 0.00589279f, -0.02643015f, 0.07402896f, 
    -0.35475931f, 0.07788081f, -0.16890718f, 0.20199203f, -0.03458866f, 0.12959407f, 0.10606141f, 0.03674908f, 
    -0.09098984f, 0.03560063f, -0.01579989f, -0.07422035f, 0.13310412f, -0.04945667f, -0.05609851f, -0.04031846f, 
    0.00549296f, -0.09047507f, 0.11755548f, 0.01521484f, 0.04143268f, -0.08652957f, -0.09509765f, -0.06736810f, 
    0.05164704f, -0.01527070f, 0.23825584f, -0.05077683f, 0.01940959f, 0.07314854f, 0.00103953f, -0.01418641f, 
    0.08273046f, -0.01022741f, -0.10636213f, -0.22901937f, 0.18100142f, 0.07486341f, 0.06683152f, -0.04693281f, 
    0.11583508f, 0.02657954f, 0.05631068f, 0.21261768f, 0.11983813f, 0.07724647f, 0.10464133f, 0.21449879f, 
    -0.16779552f, -0.10115078f, 0.18846811f, -0.02346929f, -0.02775946f, -0.00470702f, -0.06302274f, -0.07788628f, 
    0.21297790f, -0.00004068f, 0.09570260f, -0.01037258f, 0.05075437f, -0.06442610f, -0.14159496f, -0.17650850f, 
    0.10195287f, 0.21478425f, 0.05595774f, -0.02804917f, 0.06106658f, -0.07663906f, -0.14774287f, 0.02908116f, 
    -0.21842632f, 0.25579369f, -0.29811665f, 0.03158156f, 0.03978846f, -0.02145809f, -0.01224949f, -0.07593442f, 
    -0.09015546f, -0.07276054f, 0.00367793f, 0.02809291f, -0.14831309f, 0.03409829f, 0.06001912f, -0.10775535f, 
    0.08311705f, 0.02295841f, 0.03846430f, -0.13137580f, -0.01976452f, 0.10489707f, 0.10086773f, 0.19430840f, 
    -0.07060892f, 0.07181760f, 0.00819165f, -0.30998468f, 0.27330291f, 0.10254522f, 0.07750271f, -0.26848799f, 
    0.03848439f, -0.04536413f, 0.00487896f, 0.00013413f, -0.24131456f, -0.21219903f, -0.34448671f, -0.13864878f, 
    0.11638995f, 0.20131411f, 0.01879998f, 0.02717391f, -0.06920505f, -0.15674825f, 0.03730472f, -0.10056802f, 
    -0.08573791f, 0.13607171f, 0.09725185f, -0.00123904f, -0.02670437f, 0.03349586f, 0.20161338f, -0.14257732f, 
    -0.01101512f, 0.10327055f, -0.02115570f, 0.01575620f, -0.21172015f, -0.04740381f, -0.15982577f, -0.03419005f, 
    -0.03579216f, -0.01723325f, 0.05505301f, -0.13574854f, 0.01306949f, -0.21977720f, -0.05419846f, -0.27500448f, 
    -0.12356536f, -0.15738012f, 0.02172417f, 0.08719576f, 0.14742444f, -0.01350663f, -0.02993457f, 0.05296681f, 
    -0.04000865f, -0.11250013f, 0.11219595f, 0.02467603f, 0.17999293f, 0.02195232f, 0.04166113f, 0.05119178f, 
    -0.05895748f, -0.00166490f, -0.04438331f, -0.05063469f, 0.00083427f, -0.03203366f, -0.21184537f, 0.28722206f, 
    -0.03602431f, 0.02888734f, -0.06821373f, -0.00496933f, -0.07459220f, -0.00997558f, 0.03306399f, 0.25345778f, 
    0.16843149f, -0.15519717f, -0.17734176f, -0.09941928f, -0.20914577f, 0.01679476f, -0.26145190f, -0.20704114f, 
    0.15211743f, 0.09864946f, 0.10012738f, -0.07086744f, -0.09233310f, -0.11968875f, 0.01960270f, 0.16140844f, 
    -0.15114155f, -0.06392542f, 0.26419133f, -0.06811158f, 0.10412275f, 0.16717547f, 0.18733203f, 0.13264705f, 
    0.01762654f, 0.09064063f, 0.06249892f, -0.00390026f, -0.20949724f, -0.11506785f, -0.21699047f, -0.10668875f, 
    0.03181827f, -0.06307932f, -0.13535459f, -0.19448403f, 0.09653059f, 0.03022172f, 0.07242727f, 0.05029887f, 
    -0.01631689f, 0.04384064f, 0.08077209f, -0.07963888f, 0.12773933f, -0.02403494f, -0.14235029f, 0.01416668f, 
    -0.13014229f, 0.10439423f, -0.07202451f, -0.12875637f, 0.07769240f, 0.15073165f, 0.04971202f, 0.09481793f, 
    -0.16925338f, 0.11561480f, -0.05704759f, 0.04101412f, -0.08030339f, 0.19395131f, 0.10086955f, -0.04882552f, 
    -0.10639802f, 0.06948892f, -0.11501218f, 0.10793844f, 0.08792987f, 0.00755169f, 0.05834242f, 0.00833911f, 
    -0.03719726f, 0.09140990f, 0.09487902f, 0.07005878f, -0.23683235f, -0.11809450f, 0.02482286f, -0.16823472f, 
    -0.00687016f, -0.00523073f, 0.16823311f, -0.18352558f, -0.01227985f, 0.00511514f, 0.02886452f, 0.04067961f, 
    0.11426686f, 0.09513796f, -0.22689848f, 0.18175463f, -0.06545347f, -0.02053037f, -0.06322311f, -0.21712677f, 
    0.08573406f, 0.11302025f, -0.09468979f, -0.02563420f, 0.00145786f, 0.04449585f, 0.16726750f, -0.10801455f, 
    -0.12031522f, -0.02259943f, 0.02283756f, -0.06757450f, 0.03360133f, 0.07585860f, 0.03704987f, 0.14177687f, 
    0.18928638f, 0.07514508f, 0.01126099f, 0.05515376f, 0.22537102f, 0.13198163f, 0.16367772f, 0.02927694f, 
    0.11020413f, -0.04173973f, -0.01352988f, -0.04703604f, -0.16457765f, -0.18947566f, -0.07698330f, 0.26179886f, 
    0.03063600f, 0.04342407f, -0.02939916f, 0.17570114f, -0.03495117f, 0.03888951f, 0.06333941f, -0.11373368f, 
    -0.02548999f, 0.35308754f, 0.24188122f, 0.08610871f, -0.01912886f, -0.00035809f, 0.02556959f, -0.11909036f, 
    -0.15550385f, -0.10595113f, -0.08789187f, -0.12691522f, -0.02900478f, -0.53323919f, -0.18063165f, 0.01736135f, 
    0.01005065f, -0.06153889f, -0.04595379f, 0.01512686f, 0.09839804f, -0.07818691f, 0.16620384f, -0.02171273f, 
    -0.18581122f, -0.15961617f, -0.21520804f, 0.11353811f, -0.14268403f, 0.01696109f, -0.23976284f, 0.12392158f, 
    0.06820072f, 0.20781356f, -0.05004396f, -0.15421136f, 0.19747430f, -0.16628365f, -0.38431627f, -0.12046830f, 
    0.12289955f, -0.17131187f, -0.05651863f, -0.02216963f, 0.15171409f, -0.00397660f, -0.11542942f, 0.17348064f, 
    0.16466191f, -0.04226294f, -0.18751575f, 0.22728288f, 0.01931443f, -0.08779681f, 0.14285147f, 0.13394840f, 
    0.11942498f, -0.02123955f, -0.11779482f, 0.18771647f, -0.11346891f, -0.05640220f, 0.07509688f, 0.09441579f, 
    0.17265438f, 0.40591979f, 0.08321416f, 0.03393985f, 0.00136448f, -0.17019580f, 0.15311153f, 0.01479778f, 
    -0.28151709f, 0.21709940f, 0.27297887f, -0.12570064f, 0.02610839f, 0.12428784f, 0.03647599f, 0.05106515f, 
    -0.16070788f, -0.11990193f, 0.04279779f, -0.00724752f, -0.02819456f, -0.01558683f, -0.05821976f, 0.07458335f, 
    -0.05695093f, 0.01889972f, -0.11808610f, -0.14046161f, 0.37202451f, 0.05463359f, 0.02260320f, -0.07590800f, 
    -0.00521083f, -0.08462743f, -0.05151321f, -0.20305999f, 0.05457041f, -0.01174159f, -0.07851950f, 0.04228859f, 
    0.02048876f, -0.12961471f, 0.00637707f, -0.05158591f, 0.02875649f, 0.02710861f, 0.17733890f, 0.01069676f, 
    0.06337854f, 0.00038691f, -0.00100065f, 0.15058215f, 0.17144288f, -0.09405303f, 0.03676265f, -0.05475686f, 
    -0.34817004f, -0.25813067f, 0.13529566f, -0.09920865f, -0.07169687f, 0.02213650f, -0.30272925f, 0.21042286f, 
    0.20802623f, 0.01439028f, 0.14642200f, -0.04769519f, 0.14468777f, 0.01727060f, -0.05530799f, 0.29767138f, 
    0.02131558f, 0.29774067f, -0.04860670f, 0.15886432f, -0.01955297f, -0.05236375f, 0.19389348f, 0.21489932f, 
    0.12795079f, 0.03875390f, 0.25176048f, 0.07466117f, -0.03070765f, -0.10942893f, -0.10268914f, 0.09736004f, 
    -0.04958884f, -0.04947613f, -0.02070405f, 0.16620128f, -0.19457860f, 0.26971328f, 0.28709248f, 0.14705257f, 
    0.19107714f, 0.10456531f, 0.02829221f, -0.00058095f, 0.08242811f, 0.09963775f, 0.10068724f, -0.05273367f, 
    -0.03390074f, 0.02216570f, 0.15092328f, -0.03463339f, -0.00097638f, -0.02759792f, 0.11312952f, -0.09388436f, 
    -0.00339519f, -0.07308335f, -0.01461814f, 0.03404859f, -0.04402749f, -0.13287017f, -0.13674743f, -0.02908899f, 
    -0.10440970f, 0.06068129f, -0.09053881f, 0.12920710f, -0.15576537f, -0.18050021f, 0.04983563f, -0.19591837f, 
    0.06285348f, -0.11890920f, 0.23670189f, 0.08090053f, 0.06178045f, 0.01966137f, 0.00023323f, -0.08676428f, 
    -0.26517239f, 0.00483903f, 0.10158549f, 0.14644545f, -0.22484532f, -0.02721113f, 0.03582589f, -0.06542958f, 
    -0.15888794f, -0.05407979f, -0.16574375f, -0.00351140f, -0.14366899f, -0.20206930f, 0.04103379f, 0.06080050f, 
    0.08040087f, -0.03618637f, 0.10655975f, 0.07202657f, -0.00777874f, 0.10521478f, -0.02162332f, 0.27594435f, 
    -0.02746177f, 0.09138586f, 0.16705194f, 0.17248808f, 0.20530032f, 0.05109654f, -0.20859481f, 0.10261104f, 
    -0.16446023f, -0.04680623f, -0.09775026f, 0.06281143f, 0.02466653f, -0.00159838f, -0.08627828f, 0.15791677f, 
    -0.27551302f, 0.26258770f, -0.06121208f, -0.17456844f, -0.13362528f, -0.19479483f, -0.04441609f, 0.12010229f, 
    0.11417168f, -0.20225823f, -0.03923601f, -0.03074801f, -0.11723708f, 0.14430326f, 0.14811516f, -0.26001221f, 
    -0.14239842f, -0.01339230f, -0.12784179f, -0.07823895f, 0.02609908f, 0.05666167f, 0.12803143f, 0.14521451f, 
    -0.38351518f, 0.08456486f, 0.17473322f, -0.00560891f, 0.14994568f, 0.03158913f, 0.23435940f, 0.10423889f, 
    -0.16181317f, 0.12093551f, 0.00643751f, -0.04150947f, -0.15281744f, -0.12707433f, -0.06414794f, -0.02076252f, 
    0.01556655f, 0.18704692f, -0.00644786f, 0.07094192f, -0.02346426f, 0.09106232f, -0.14112750f, 0.03121183f, 
    0.35495731f, -0.16493675f, -0.22297178f, -0.19972719f, -0.00120271f, 0.05624352f, 0.11160123f, -0.00897228f, 
    0.08676854f, 0.03054550f, 0.06658114f, -0.22540994f, 0.22998801f, 0.01549468f, 0.04823970f, 0.10582000f, 
    0.09188946f, -0.02496533f, -0.06385920f, 0.04960955f, 0.03814081f, 0.02481342f, 0.06574722f, -0.02733728f, 
    -0.20082156f, -0.63056105f, -0.33491543f, -0.04967104f, 0.12640393f, -0.03306609f, 0.20557117f, -0.20947154f, 
    0.01354366f, 0.12622313f, 0.06845105f, 0.15820536f, -0.05624589f, -0.25405368f, 0.05869197f, -0.18969570f, 
    0.10742542f, -0.07084599f, -0.15489399f, -0.17047222f, 0.10406477f, 0.01929890f, -0.04231223f, 0.04217876f, 
    -0.20858008f, 0.30691645f, 0.00787785f, 0.23477541f, -0.04300838f, -0.02668311f, -0.10933413f, -0.05913383f, 
    -0.03246032f, -0.02799719f, 0.07167188f, 0.02350303f, 0.02499056f, -0.09756722f, 0.10429165f, -0.13405730f, 
    -0.05132950f, 0.03305817f, 0.09890127f, 0.00963446f, 0.01659161f, -0.10549508f, 0.05734221f, 0.15556535f, 
    0.39919409f, -0.06114444f, -0.09686050f, 0.10749973f, 0.15207697f, 0.10246100f, 0.07437302f, 0.01588500f, 
    0.04125973f, -0.08403710f, -0.00002423f, -0.02587547f, -0.04397018f, 0.21697211f, 0.08676826f, 0.21335074f, 
    -0.17177120f, -0.11207539f, -0.06808380f, 0.11026323f, 0.06148017f, -0.01890642f, 0.06352026f, -0.07158805f, 
    -0.07044855f, 0.30024567f, -0.31267139f, 0.28554121f, 0.14676458f, -0.01742590f, -0.08349472f, 0.15728790f, 
    -0.06415282f, -0.06907749f, -0.03075364f, -0.08237786f, -0.04213078f, -0.10342463f, 0.07730962f, -0.05336257f, 
    -0.06028912f, -0.05096840f, -0.14369977f, -0.16065429f, 0.13387150f, -0.04558040f, -0.15255217f, -0.07224800f, 
    0.04982239f, -0.13189082f, 0.00517982f, -0.01679266f, 0.03930556f, 0.08782010f, -0.17525695f, -0.14244278f, 
    0.08411595f, -0.03662496f, -0.12045414f, -0.06499849f, -0.16954321f, -0.11136150f, -0.01818623f, -0.23558359f, 
    -0.00916753f, -0.12363982f, -0.18002836f, -0.10655237f, 0.06270839f, -0.05385401f, 0.00260536f, 0.05426796f, 
    -0.01391366f, -0.57151616f, -0.42962238f, 0.27354434f, 0.07654606f, 0.17137755f, -0.00530412f, 0.16216864f, 
    0.07365022f, -0.03290583f, -0.03414543f, 0.22222337f, -0.18693413f, 0.30985963f, 0.07181275f, -0.01642695f, 
    -0.02977652f, 0.11749893f, -0.05228487f, 0.13412096f, 0.14099251f, -0.09482551f, 0.09784804f, -0.07399530f, 
    0.59418565f, 0.34661290f, 0.30000073f, -0.17511599f, 0.07645934f, -0.03677341f, -0.03420412f, 0.07098348f, 
    -0.03958495f, 0.01841879f, 0.02327859f, -0.11738889f, -0.18054256f, -0.05308544f, -0.09634300f, 0.12262846f, 
    0.16206349f, -0.09389900f, -0.08496566f, -0.29466003f, -0.07001717f, -0.06359848f, -0.01938805f, -0.09116668f, 
    0.08103255f, -0.14653085f, 0.13175596f, 0.26846606f, -0.05644932f, -0.13695344f, 0.02377676f, -0.12372214f, 
    0.27367550f, -0.04251695f, 0.08099522f, 0.22131300f, 0.02430009f, 0.13934004f, 0.13144919f, 0.29066429f, 
    0.23296902f, 0.02670684f, 0.04310532f, 0.11305454f, 0.05735163f, 0.00817854f, -0.11792221f, 0.02701667f, 
    0.49657574f, -0.09920319f, 0.07890210f, -0.00298764f, -0.09812505f, -0.11156677f, -0.17296055f, -0.14607100f, 
    -0.02624485f, -0.06043524f, -0.06372774f, 0.09290092f, -0.05740490f, -0.19805741f, 0.13956317f, -0.19490668f, 
    0.11886411f, 0.05713020f, 0.02403632f, -0.04195002f, -0.04004415f, -0.12361275f, -0.19062184f, -0.07995527f, 
    -0.31097794f, -0.22526903f, -0.33076301f, 0.10892818f, -0.04513733f, -0.17740488f, 0.27629447f, 0.20991324f, 
    -0.09452698f, -0.14005804f, -0.12428258f, -0.10024813f, 0.33813161f, -0.08727250f, -0.18574272f, -0.09652751f, 
    -0.01998567f, -0.03669997f, 0.06669184f, 0.08030766f, -0.04917436f, -0.02698977f, -0.05635162f, -0.03466820f, 
    0.24396394f, 0.45060226f, 0.22995113f, 0.09700805f, -0.06805057f, 0.03619509f, 0.05019064f, 0.25922266f, 
    -0.00821184f, 0.00771463f, -0.00591098f, -0.07773098f, 0.23174933f, -0.21151733f, -0.32041141f, -0.06114953f, 
    0.06556448f, -0.05441673f, 0.05246152f, 0.18606329f, -0.07597228f, 0.07628775f, -0.12900175f, 0.07154647f, 
    0.01943866f, 0.31436336f, -0.29357088f, 0.18260905f, 0.04516628f, 0.14175227f, 0.25872326f, 0.25096929f, 
    0.16875370f, 0.06732819f, -0.07768016f, 0.18236521f, -0.16969407f, -0.09007208f, -0.06108473f, 0.23351793f, 
    0.08114219f, 0.14439031f, 0.21063687f, 0.09544926f, -0.06551093f, 0.01439360f, -0.16759929f, 0.03529783f, 
    0.04405764f, -0.03739769f, -0.19958420f, -0.15164126f, -0.01586694f, 0.04245000f, 0.06851153f, -0.18522267f, 
    -0.02725388f, -0.05429875f, -0.13155578f, 0.00443257f, 0.14506884f, -0.27010292f, 0.05591869f, -0.21173279f, 
    -0.15833874f, -0.10803340f, 0.17791271f, -0.12820671f, 0.02147021f, 0.14553909f, 0.00445913f, 0.01957580f, 
    0.17274053f, 0.04042356f, 0.10523004f, -0.18526642f, 0.05711642f, -0.05905489f, -0.01959223f, -0.05415119f, 
    -0.15837304f, 0.07337820f, 0.09472318f, 0.03260519f, 0.43203145f, 0.08683211f, -0.49817905f, -0.01154796f, 
    0.00421199f, -0.01933427f, 0.17415288f, 0.07054005f, -0.25219503f, 0.05176209f, -0.01611399f, -0.06126409f, 
    0.14349568f, -0.12683892f, 0.11143346f, 0.03057582f, 0.20988590f, 0.06537045f, -0.09112549f, -0.01159947f, 
    0.04201417f, -0.09680655f, 0.08797893f, -0.03054516f, 0.08684114f, -0.14332499f, -0.22043428f, -0.26578817f, 
    -0.04711556f, -0.01377255f, 0.06615295f, 0.01739324f, -0.40447751f, -0.04358997f, -0.01545400f, -0.14383546f, 
    0.22825198f, -0.10238577f, 0.09290337f, 0.14600135f, 0.05913724f, -0.00010116f, -0.09169871f, -0.04293257f, 
    0.14745037f, 0.03800690f, 0.03276338f, 0.01161150f, 0.06794685f, -0.05244158f, -0.01666296f, 0.16771252f, 
    0.19390172f, -0.00214387f, 0.06623159f, 0.13902293f, 0.01403623f, 0.07365528f, 0.12930007f, 0.02814353f, 
    -0.06250774f, -0.24439631f, 0.36184779f, -0.17445262f, -0.03343384f, -0.20806065f, -0.05915376f, 0.09957432f, 
    0.06508671f, 0.03340738f, 0.22075404f, 0.12100402f, 0.11829059f, -0.19195874f, 0.05168502f, 0.10512414f, 
    0.25156730f, 0.18058741f, -0.01775139f, 0.02571429f, 0.11981288f, -0.02410255f, 0.03424747f, 0.11666030f, 
    -0.12358962f, 0.11482035f, 0.18019655f, -0.00101082f, 0.03478665f, -0.10612026f, -0.03329938f, 0.13380925f, 
    -0.10459323f, -0.00192849f, -0.02572611f, 0.14316951f, 0.00791687f, -0.12422376f, 0.04714321f, 0.09181073f, 
    0.09582531f, -0.05321591f, 0.17568521f, 0.09412032f, 0.02360144f, -0.00031631f, 0.05546885f, 0.07243714f, 
    -0.19718313f, -0.02082835f, -0.03027025f, -0.20714477f, 0.01492355f, -0.01302886f, 0.15657692f, -0.00960281f, 
    0.00673198f, -0.04161398f, -0.07742110f, -0.13050322f, -0.14618921f, -0.18315294f, 0.13605867f, -0.11126610f, 
    -0.16699685f, -0.07380272f, 0.03894966f, 0.22895539f, 0.02778565f, -0.08516610f, -0.04675171f, -0.12874933f, 
    -0.21227586f, 0.02004723f, -0.10652848f, -0.08683385f, 0.05958305f, -0.03201241f, -0.13282037f, -0.03282786f, 
    -0.02604770f, 0.13765335f, -0.04519795f, -0.00124949f, -0.12919290f, 0.02532130f, -0.00546514f, 0.06810070f, 
    -0.00511525f, 0.07684767f, -0.05416387f, -0.03985367f, -0.08720523f, -0.05658929f, -0.07571124f, 0.06446584f, 
    0.10908658f, 0.04495836f, -0.11971635f, -0.08925844f, 0.11954793f, 0.01204453f, -0.06014733f, -0.14229904f, 
    -0.01716842f, -0.01183866f, 0.12458156f, 0.13460584f, 0.14426126f, 0.05910143f, 0.10652204f, -0.08118323f, 
    -0.07103656f, -0.06258880f, -0.01316282f, -0.00809553f, 0.01820147f, 0.05493129f, -0.01347793f, 0.18741333f, 
    -0.18601920f, 0.15764217f, -0.01650082f, -0.31201082f, -0.07520153f, -0.04769503f, 0.03602197f, 0.00898286f, 
    0.00604405f, 0.03813044f, 0.06843086f, 0.04839417f, -0.13919419f, 0.00224534f, 0.17695418f, -0.29666063f, 
    -0.12351611f, 0.02840662f, -0.21812254f, -0.05137067f, 0.09862467f, -0.08599122f, -0.01923350f, -0.05918623f, 
    -0.00648504f, -0.07227522f, 0.13617396f, -0.05099694f, 0.18080948f, 0.04033715f, 0.23394710f, 0.09662131f, 
    0.07036366f, 0.14939883f, -0.03039241f, 0.03769132f, -0.06869625f, -0.09742442f, -0.16560106f, -0.08682077f, 
    -0.01337632f, 0.04985769f, -0.04893912f, 0.02361230f, 0.00620086f, -0.00352227f, -0.10647033f, -0.00335023f, 
    0.53947747f, -0.29367036f, -0.12863275f, -0.09833106f, -0.00823790f, -0.03478101f, 0.01014444f, 0.02998393f, 
    0.16434722f, 0.03052356f, -0.01430907f, -0.00664580f, 0.04278279f, 0.05186291f, 0.22992857f, 0.10308500f, 
    0.12346444f, 0.02342694f, -0.05116667f, 0.18617718f, 0.19934408f, 0.04010924f, -0.00170924f, -0.04476759f, 
    -0.07745401f, -0.28647533f, 0.00742419f, -0.37080923f, -0.05529578f, -0.00448028f, 0.06548014f, -0.06632250f, 
    0.10619632f, -0.01643835f, 0.20415494f, 0.07316363f, 0.03336455f, -0.10468219f, 0.16241984f, 0.12923807f, 
    0.18500961f, 0.12670770f, -0.16515121f, -0.12118597f, 0.04952603f, 0.00762150f, 0.15154818f, 0.22777951f, 
    -0.16319548f, 0.26237488f, 0.12876280f, 0.18107584f, -0.02046602f, -0.14569093f, -0.15048182f, 0.07414719f, 
    -0.03060039f, 0.02166305f, -0.09282973f, 0.20484771f, -0.03929495f, 0.01495909f, 0.10841913f, -0.01967295f, 
    0.09860457f, 0.05070210f, 0.13371468f, 0.21177249f, 0.03981834f, 0.08051592f, 0.16978601f, -0.06036034f, 
    0.03758708f, 0.15448530f, -0.11703611f, -0.24402566f, 0.13901588f, 0.09682403f, 0.20268840f, 0.11498392f, 
    0.03954920f, -0.06816099f, 0.09674217f, -0.01448467f, -0.21683991f, 0.02908957f, 0.02517549f, 0.07195348f, 
    -0.04041435f, -0.04353945f, -0.17046356f, 0.09805002f, -0.00024784f, -0.03685743f, 0.04020120f, -0.16065492f, 
    -0.06030036f, 0.19394471f, -0.23763895f, 0.09932733f, -0.01315828f, -0.06860311f, -0.06163014f, 0.04896455f, 
    0.00965135f, 0.01386899f, 0.01024651f, 0.10406271f, -0.12308630f, 0.12445155f, 0.09195111f, 0.13438204f, 
    -0.03654313f, -0.07759240f, -0.12296140f, -0.06947515f, 0.00706718f, -0.22510862f, -0.12274128f, 0.15186800f, 
    -0.13816355f, -0.08802791f, 0.05526327f, 0.28633645f, 0.02971661f, -0.02805294f, -0.01837843f, -0.14349879f, 
    -0.08488881f, 0.04768078f, 0.07892717f, 0.05955797f, 0.08160618f, 0.08998536f, 0.00827552f, -0.17025389f, 
    -0.08525388f, -0.02810991f, 0.04266935f, -0.05534369f, 0.18425474f, 0.09030219f, -0.07239852f, 0.20395857f, 
    -0.20105036f, 0.09965754f, 0.06412449f, -0.16338845f, -0.04517531f, 0.05772234f, 0.12120505f, -0.02222215f, 
    0.06304291f, 0.05580252f, -0.09197298f, -0.04670458f, -0.29142243f, 0.13808450f, 0.06825118f, -0.47396797f, 
    -0.19701970f, -0.01729471f, 0.01111987f, 0.03801962f, 0.03013747f, 0.05789048f, -0.04414107f, -0.04874095f, 
    0.17340340f, 0.10279235f, 0.27000007f, -0.15480502f, 0.26174200f, 0.04391777f, 0.20813145f, 0.14057770f, 
    -0.02536158f, 0.05290563f, 0.00199999f, -0.02238093f, -0.23862851f, -0.17643285f, -0.10094011f, -0.12970203f, 
    -0.04784508f, 0.13459720f, -0.23461103f, -0.14393888f, 0.04657652f, 0.11156228f, -0.05508893f, 0.12336931f, 
    0.12967244f, -0.00212606f, 0.19124955f, 0.13003916f, -0.19403081f, -0.26099452f, -0.01355371f, -0.08094347f, 
    0.39236143f, 0.24784455f, 0.14022999f, 0.04108667f, 0.11615781f, 0.22204554f, 0.09906302f, 0.08162669f, 
    -0.13721998f, 0.17110476f, 0.03998868f, 0.14176774f, -0.07641836f, -0.13541816f, 0.17460026f, 0.14485161f, 
    -0.07164224f, 0.17344680f, 0.39987502f, 0.21616469f, 0.04422889f, -0.10274248f, -0.05413786f, -0.14620270f, 
    0.02721401f, 0.15657674f, 0.01204904f, -0.00291563f, -0.29897249f, -0.20837736f, -0.24095193f, -0.23765461f, 
    0.02542714f, -0.16058464f, -0.03069045f, -0.15328112f, -0.26362893f, -0.10762315f, -0.32274985f, -0.29741028f, 
    -0.23967178f, 0.25198603f, -0.18291569f, 0.22042778f, 0.16341934f, -0.02985551f, 0.05264027f, -0.10553882f, 
    -0.22591901f, -0.13439736f, -0.20059738f, -0.14364895f, -0.13613373f, -0.32232550f, -0.05620262f, 0.01328242f, 
    -0.09528465f, 0.05511096f, -0.07381330f, 0.08864839f, -0.07321167f, -0.00691482f, -0.04313630f, 0.07555606f, 
    0.16770752f, 0.03819553f, 0.02967680f, -0.21611679f, -0.00053223f, -0.01783561f, 0.03629604f, 0.15691534f, 
    0.05647131f, 0.01201425f, -0.09296413f, -0.06122338f, -0.41535029f, 0.29516101f, 0.16357064f, 0.15306145f, 
    0.14504926f, 0.00862635f, 0.07848115f, 0.06086608f, -0.08485673f, 0.01427441f, 0.00421585f, 0.01873871f, 
    0.08546571f, 0.57570100f, -0.05448564f, 0.16768688f, 0.00692792f, 0.05748413f, 0.38172659f, 0.02406148f, 
    0.32233101f, -0.06908799f, 0.25604659f, 0.16002913f, -0.05952447f, 0.05328598f, -0.02884273f, 0.04441915f, 
    -0.01238583f, -0.03162184f, 0.23817097f, 0.18037231f, 0.12911461f, -0.16681503f, 0.02484596f, 0.28213298f, 
    -0.26512730f, 0.10332271f, -0.00571628f, -0.10577904f, -0.16628452f, -0.03116555f, 0.01451241f, 0.04761202f, 
    -0.11811773f, -0.05347698f, -0.20264402f, 0.07877823f, -0.30446303f, -0.17992476f, 0.03360404f, -0.02887617f, 
    -0.07091761f, -0.24669595f, -0.08867718f, -0.16267326f, 0.07887061f, -0.04800285f, -0.01924368f, -0.12739596f, 
    0.14275409f, 0.04601248f, 0.07393074f, 0.37814990f, -0.20684867f, 0.07951732f, 0.11796156f, -0.11892874f, 
    0.00191438f, 0.24095732f, 0.03395236f, 0.24869718f, 0.00487781f, 0.19110656f, 0.14829688f, 0.49069592f, 
    -0.06807755f, 0.18835181f, 0.07837167f, 0.20666146f, 0.05213760f, 0.02735478f, -0.08032295f, -0.22917736f, 
    0.31263497f, 0.09513082f, 0.08854409f, -0.05780400f, 0.01985282f, 0.19026709f, 0.04877270f, -0.10993103f, 
    -0.08334338f, 0.08423664f, 0.08124186f, -0.07507549f, -0.24355482f, -0.20499060f, -0.25060827f, -0.10935726f, 
    0.06086373f, 0.12048182f, 0.07532553f, 0.04113091f, -0.26061183f, -0.23576394f, -0.33996722f, -0.44031918f, 
    0.02415401f, 0.01187346f, 0.06958841f, 0.22042853f, -0.07406232f, -0.08800387f, -0.02299003f, 0.07723354f, 
    0.03250812f, -0.09450632f, -0.02524398f, -0.04446138f, -0.14454624f, 0.05171109f, -0.22438210f, 0.26144055f, 
    -0.09729799f, 0.06725357f, 0.18956855f, -0.01879030f, -0.02954445f, 0.02024907f, -0.02116792f, 0.04005448f, 
    0.37615824f, -0.00600395f, 0.19587259f, -0.11340576f, -0.05338313f, -0.16430984f, 0.03277978f, -0.00470747f, 
    -0.08877856f, 0.08866975f, 0.09309827f, -0.13878915f, 0.09160332f, 0.10279629f, 0.10583681f, -0.00062828f, 
    0.19955489f, 0.02666330f, -0.16182782f, 0.00313908f, -0.18252264f, -0.11602517f, 0.00306359f, -0.10455207f, 
    0.24123526f, 0.05105784f, 0.12603278f, 0.00440630f, -0.16604084f, -0.19481641f, 0.24533089f, -0.10257798f, 
    -0.06230555f, -0.04442510f, 0.10940281f, 0.09397474f, 0.24825099f, -0.05829232f, -0.33933029f, 0.15014979f, 
    0.08157024f, -0.14418693f, 0.00436033f, 0.14460957f, -0.24535429f, 0.01924076f, 0.00576910f, 0.10414054f, 
    -0.03762561f, -0.02068755f, 0.11757924f, -0.24868682f, -0.05899034f, -0.20440321f, -0.11664172f, 0.18450223f, 
    -0.23458527f, -0.01781704f, -0.08359929f, -0.02156230f, 0.28562963f, 0.03003899f, 0.36828491f, -0.07569835f, 
    -0.17527044f, -0.06743548f, 0.08120804f, 0.17920460f, 0.10130086f, 0.12340259f, 0.11139666f, 0.08993691f, 
    -0.13736834f, -0.18388103f, 0.08090094f, -0.12143759f, -0.20342599f, -0.05748570f, 0.20753191f, 0.08051921f, 
    0.01459387f, -0.05757940f, 0.04700563f, 0.05454419f, 0.10767765f, 0.21931353f, -0.07760707f, 0.06018643f, 
    0.02156176f, 0.05283335f, 0.02465137f, -0.02224541f, -0.07276838f, 0.01387585f, 0.05701693f, -0.03671992f, 
    0.22230485f, 0.27844974f, -0.01103953f, -0.14709012f, -0.05685316f, -0.11398289f, 0.08904779f, -0.14835820f, 
    -0.00380332f, -0.07115111f, -0.09713715f, -0.07168389f, 0.05946239f, 0.08453164f, 0.16833569f, 0.01932662f, 
    -0.16286844f, -0.03027936f, -0.02333644f, -0.06620810f, 0.09015664f, 0.27305594f, 0.17026117f, -0.07655852f, 
    -0.05273251f, -0.10643352f, -0.03423339f, -0.42718580f, 0.01176164f, -0.15913616f, 0.05283759f, 0.08871464f, 
    0.02806201f, 0.02049660f, 0.11901498f, -0.03932946f, 0.24148236f, -0.06431688f, 0.19413447f, 0.20064461f, 
    0.10462894f, -0.03281476f, -0.07040299f, 0.13345258f, -0.09454836f, 0.00197933f, 0.02379975f, 0.03075091f, 
    0.16874765f, -0.15468745f, -0.25022447f, 0.22272393f, -0.00312555f, 0.30539131f, -0.00400754f, -0.09423346f, 
    -0.12566303f, -0.13411340f, 0.02033730f, -0.07891136f, 0.16379757f, 0.08140090f, -0.07882795f, -0.18235230f, 
    -0.00954394f, 0.03902596f, 0.02054041f, -0.11213113f, -0.07336354f, -0.16665071f, -0.18892677f, 0.00382169f, 
    0.04738921f, 0.06832749f, -0.23211643f, -0.02250700f, 0.03341328f, 0.05201163f, 0.14649640f, 0.05140735f, 
    0.22253472f, 0.13957444f, 0.27761653f, 0.36343095f, 0.11088627f, -0.10945000f, -0.08044103f, -0.16132942f, 
    -0.18598156f, 0.07107246f, -0.02376696f, 0.00464990f, -0.19414476f, 0.05285840f, 0.23677313f, 0.35487714f, 
    -0.17821451f, 0.17101899f, -0.04947482f, 0.10459547f, -0.07137142f, 0.11266941f, 0.12565733f, 0.05974349f, 
    -0.02953805f, 0.05292083f, -0.00281792f, 0.05080525f, -0.03671383f, -0.24059652f, -0.24730040f, -0.08322745f, 
    -0.06309295f, -0.03975639f, -0.05029660f, 0.01973256f, -0.31987649f, -0.05770772f, -0.28054148f, -0.52572834f, 
    0.14653806f, 0.05306802f, 0.11489549f, -0.12551902f, 0.04019933f, 0.24682552f, -0.21510732f, -0.12089277f, 
    -0.22173718f, -0.11451603f, 0.02861181f, -0.24285975f, -0.27365074f, -0.10051789f, 0.21854380f, 0.01406130f, 
    -0.05874480f, 0.08094092f, 0.06848447f, 0.09368744f, 0.01990738f, -0.11648750f, -0.04177042f, 0.07060042f, 
    -0.07067587f, -0.24503995f, -0.07719278f, -0.16202508f, -0.01687739f, -0.02422560f, -0.12859888f, -0.09815841f, 
    -0.12756252f, -0.18963405f, -0.15591991f, -0.15369278f, 0.04664410f, 0.28196400f, 0.06150787f, -0.08122405f, 
    0.10251220f, -0.05937376f, 0.07820821f, -0.00215266f, 0.08224609f, -0.00537753f, 0.15009676f, 0.03224475f, 
    0.09998066f, 0.15689252f, -0.08724534f, 0.02631753f, 0.20185530f, 0.00274376f, 0.01228435f, 0.04037710f, 
    0.05156143f, -0.14749555f, 0.12832162f, 0.07693741f, 0.02755744f, -0.17509623f, 0.08775660f, -0.14699563f, 
    -0.11715396f, -0.05851720f, 0.07749278f, -0.13794637f, 0.21282518f, -0.07048418f, 0.01531005f, 0.04845082f, 
    0.19191965f, -0.00576317f, 0.16900665f, -0.09187862f, -0.06492219f, 0.10792189f, 0.07387567f, 0.11637388f, 
    0.11739866f, -0.03168512f, -0.13527441f, 0.07528105f, -0.18157656f, -0.03050033f, 0.17659453f, -0.01455658f, 
    0.02218423f, -0.14046124f, -0.18569870f, 0.05633631f, 0.04245185f, 0.02873779f, 0.17381069f, 0.02419936f, 
    0.02158740f, 0.14436957f, 0.06800396f, 0.40527090f, -0.08623520f, 0.12735943f, 0.24569251f, 0.06000279f, 
    0.06193192f, 0.01474455f, 0.18306138f, 0.52545589f, 0.05527484f, -0.07919966f, 0.44081008f, 0.04528150f, 
    0.08851610f, 0.18270692f, -0.01621342f, 0.11697377f, -0.04716214f, -0.17634244f, 0.10235026f, -0.07020865f, 
    0.44506070f, -0.02064338f, -0.06257752f, 0.31254435f, 0.06456578f, 0.05911481f, -0.16340849f, 0.11516353f, 
    -0.03484178f, 0.12097252f, 0.04353378f, -0.06066334f, -0.05832706f, 0.07110421f, -0.15050167f, -0.05847514f, 
    -0.02934964f, -0.16394307f, -0.03762377f, -0.03495800f, -0.43158031f, -0.37124863f, -0.40448493f, -0.45414609f, 
    -0.03748715f, -0.02314424f, -0.07711077f, -0.05205522f, -0.01275764f, 0.05804617f, 0.05475893f, -0.05982964f, 
    -0.06593370f, 0.03666949f, -0.04598224f, -0.02345963f, -0.06179081f, 0.05057617f, 0.05508311f, -0.01843476f, 
    0.05838020f, 0.04461870f, -0.07107684f, 0.02944185f, -0.02596450f, -0.04245637f, -0.03586688f, 0.05327918f, 
    -0.00586613f, -0.05903795f, -0.05819617f, -0.04591635f, 0.00249556f, 0.02152140f, 0.04574196f, 0.04501036f, 
    -0.02019478f, 0.02823730f, 0.05626869f, 0.02925956f, -0.00763077f, -0.02755944f, 0.01709111f, -0.04214726f, 
    0.05442655f, 0.05364846f, -0.04954183f, 0.05618434f, 0.01770650f, 0.00322830f, 0.00663310f, -0.08800617f, 
    -0.01248422f, 0.04117687f, -0.04798160f, -0.07860283f, -0.02064129f, 0.03891676f, -0.05994856f, 0.02970777f, 
    0.03685329f, -0.07678733f, 0.03842006f, -0.05446675f, -0.00124910f, -0.03125270f, 0.03987173f, 0.05364175f, 
    -0.02320932f, -0.07174686f, 0.06169907f, -0.02105198f, 0.03979382f, -0.00482854f, -0.02839335f, 0.00800343f, 
    0.04264312f, -0.03521517f, 0.05435097f, 0.01050752f, -0.05946486f, -0.01333039f, -0.02656475f, -0.03379060f, 
    0.02477396f, 0.04222053f, -0.06788430f, -0.04493934f, -0.02882288f, -0.06727464f, 0.00668605f, 0.04448731f, 
    -0.00479498f, 0.01130712f, -0.05031736f, -0.00017016f, -0.02060243f, -0.03664348f, -0.06841452f, 0.01724267f, 
    0.01353533f, -0.03665205f, 0.01397686f, -0.00169970f, 0.03291251f, -0.03394480f, -0.07246806f, 0.04011116f, 
    0.06069732f, 0.01134054f, -0.02789191f, -0.01567852f, -0.02036123f, -0.03318277f, -0.01833970f, -0.02414889f, 
    -0.02577192f, -0.02935542f, -0.02921923f, 0.03502135f, 0.05107595f, -0.05855834f, 0.01450842f, 0.04364004f, 
    0.03733467f, 0.00518598f, -0.03858825f, -0.02535232f, -0.06395447f, -0.05997467f, -0.07313363f, -0.07442418f, 
    -0.04270734f, 0.04006845f, 0.03812442f, 0.02871073f, -0.07500816f, -0.06152670f, -0.04224240f, -0.08094203f, 
    -0.08005425f, 0.03226224f, 0.01644703f, 0.05770505f, 0.01362517f, -0.03813219f, 0.00747830f, -0.01242996f, 
    -0.06708658f, 0.05309962f, 0.03024640f, -0.04862987f, -0.02608458f, -0.07199673f, 0.01526388f, -0.06150543f, 
    -0.02005211f, -0.05581821f, -0.03949994f, -0.03382080f, -0.05049679f, 0.03862051f, -0.03535731f, 0.04010111f, 
    -0.05095353f, 0.04271736f, -0.01180576f, 0.02713596f, -0.06924317f, -0.01210391f, -0.02568887f, 0.01951001f, 
    -0.05323020f, 0.02019900f, -0.00741271f, -0.05263136f, 0.04551110f, 0.03602314f, -0.04334142f, 0.04392819f, 
    -0.03763749f, -0.00466287f, -0.00456503f, 0.00707576f, -0.04357544f, 0.02757556f, -0.02753759f, 0.03882695f, 
    0.03433012f, -0.06680852f, -0.02877153f, 0.04488451f, 0.01387200f, -0.06355264f, -0.03747224f, -0.04880084f, 
    0.12330070f, 0.17931895f, 0.03014261f, -0.07704975f, -0.03672613f, -0.14878637f, -0.05596533f, -0.06470152f, 
    -0.06539710f, 0.13107780f, -0.03393248f, 0.19040053f, -0.17920758f, 0.13088344f, 0.23910952f, -0.29794171f, 
    -0.01409768f, -0.01290264f, -0.06179577f, 0.07564406f, 0.08420465f, 0.16108957f, 0.04234193f, 0.05529618f, 
    0.21398796f, 0.57978588f, 0.06388444f, 0.20399232f, -0.14943986f, 0.11605646f, -0.16911657f, 0.00273520f, 
    0.26804608f, -0.01869562f, -0.11528586f, -0.01019719f, -0.23630863f, 0.07583207f, -0.15422441f, -0.10184053f, 
    -0.28143752f, 0.16652665f, 0.08760961f, 0.02043485f, 0.11242267f, 0.01782385f, 0.03549327f, -0.02106034f, 
    0.31040210f, -0.23874418f, -0.32803857f, 0.06124945f, 0.08521573f, 0.04916707f, -0.20785478f, 0.07103569f, 
    -0.03625229f, 0.08630696f, -0.15097566f, -0.06004344f, -0.20496063f, 0.38756827f, 0.16528995f, 0.05655300f, 
    0.10946914f, 0.24498165f, -0.18439335f, 0.17449692f, 0.06592646f, 0.07848965f, -0.01067494f, -0.12366825f, 
    0.01175445f, 0.11856699f, -0.01803091f, 0.15201332f, 0.08131701f, 0.02804603f, 0.01333178f, -0.13678008f, 
    0.08199405f, -0.06208824f, -0.00260565f, 0.02552852f, -0.22463746f, -0.12998930f, -0.03193366f, 0.01696914f, 
    0.05089583f, 0.00236460f, -0.26000682f, -0.15567076f, -0.11351088f, -0.04358332f, -0.06562172f, -0.07531381f, 
    0.17109106f, -0.02032343f, 0.18637566f, 0.03602877f, 0.23719209f, 0.05661489f, -0.12238462f, -0.03936404f, 
    -0.04958158f, -0.16060939f, 0.06893741f, 0.14121483f, 0.11744548f, -0.31343362f, -0.12512256f, -0.07397193f, 
    -0.17636257f, -0.48275965f, -0.00443238f, -0.03691148f, 0.09669572f, 0.00394790f, 0.00487845f, 0.14086983f, 
    -0.16267581f, -0.02345034f, -0.01058911f, 0.20404133f, -0.23880589f, 0.10534000f, 0.07772115f, 0.05173017f, 
    0.05348849f, 0.26790822f, 0.20537646f, -0.09625593f, 0.10643499f, 0.20539309f, -0.08849850f, 0.17570813f, 
    -0.02713340f, -0.04880752f, -0.07671874f, 0.06822632f, 0.13189560f, 0.04304233f, 0.13296387f, 0.14916883f, 
    0.23843993f, 0.42987314f, 0.24225532f, 0.47994065f, 0.10872789f, -0.01485864f, 0.08404815f, 0.06084814f, 
    0.23412775f, -0.03108582f, -0.00459883f, 0.15937500f, -0.22997665f, -0.52440917f, -0.30636626f, 0.12802714f, 
    0.13651468f, -0.02036944f, -0.07833447f, -0.28739288f, -0.05841757f, -0.06110233f, 0.00466524f, 0.13879064f, 
    -0.40690115f, -0.33824360f, 0.02891982f, 0.17495063f, 0.14224073f, 0.05529369f, -0.00196340f, 0.18852891f, 
    0.00947639f, 0.00025670f, 0.00136509f, -0.07290179f, 0.13584486f, 0.01073664f, -0.06492332f, 0.00744755f, 
    0.10159294f, 0.04145275f, 0.20517294f, 0.13465686f, 0.02163262f, -0.19788231f, -0.18742356f, -0.15590630f, 
    0.02596878f, -0.04062652f, 0.19930725f, 0.07153390f, 0.02552058f, -0.03976429f, -0.06911008f, 0.13290201f, 
    0.12527980f, 0.11334699f, 0.14218538f, 0.15446399f, -0.13927756f, -0.16012932f, -0.05171734f, 0.19511978f, 
    0.10235029f, 0.07781269f, 0.22954975f, 0.09923170f, -0.03953630f, -0.05509922f, 0.23350830f, 0.17164746f, 
    -0.27354378f, 0.05299330f, 0.22961143f, -0.12649186f, 0.08532562f, -0.02774311f, -0.04723456f, 0.10575060f, 
    0.12454443f, 0.00914835f, 0.03579142f, -0.02319555f, 0.12606141f, -0.15093248f, 0.00749500f, 0.02958070f, 
    0.13491444f, 0.07866540f, -0.03368948f, 0.14649533f, -0.04292069f, -0.06488656f, -0.11678217f, -0.19245851f, 
    0.24700792f, 0.17543504f, 0.03230362f, -0.02676923f, 0.08652894f, -0.03936686f, 0.13523106f, -0.00190458f, 
    -0.02261385f, -0.00350038f, -0.10662612f, 0.00953556f, -0.29812759f, 0.03890862f, 0.08638224f, 0.00076932f, 
    0.04257587f, -0.00262503f, -0.04258275f, -0.10921072f, 0.03431268f, 0.14147066f, 0.06759575f, 0.06874990f, 
    -0.16742998f, -0.02612911f, 0.19660118f, 0.01808221f, -0.05318612f, -0.06722648f, 0.11041658f, -0.08671901f, 
    0.17647254f, 0.12398239f, -0.05047998f, -0.03365720f, 0.28599989f, 0.13455227f, -0.03941437f, -0.09326254f, 
    0.11541361f, 0.09917798f, 0.11390132f, 0.12242708f, 0.12603463f, 0.05605922f, 0.06790312f, 0.02878150f, 
    -0.15668821f, 0.06578735f, 0.04084979f, 0.21744721f, 0.21122168f, 0.00247011f, -0.09520869f, -0.10861894f, 
    0.10953162f, 0.06374732f, 0.13750502f, 0.09506961f, 0.16408230f, -0.00398967f, 0.00842833f, 0.09950223f, 
    -0.00320582f, 0.02680429f, 0.00591534f, -0.04274774f, 0.07456017f, -0.01254599f, 0.04101270f, -0.16256142f, 
    0.22192946f, -0.12575343f, -0.10837544f, 0.02003777f, 0.07010461f, -0.08111342f, 0.11867939f, 0.07847938f, 
    -0.11356045f, -0.14721118f, -0.00012165f, 0.19565952f, 0.25121257f, -0.03243045f, 0.13722889f, -0.15657200f, 
    0.12622026f, 0.01498531f, 0.00020749f, 0.06145537f, 0.06014770f, -0.24056448f, -0.14708118f, 0.12994301f, 
    -0.19994009f, 0.13803846f, -0.08068671f, -0.01869226f, -0.14931144f, -0.24122739f, 0.33613098f, 0.02991437f, 
    0.05106487f, 0.02518065f, 0.07462344f, 0.03424579f, 0.12927723f, 0.18220611f, 0.23782983f, -0.20536257f, 
    0.00095707f, 0.17600615f, -0.04014192f, 0.10510068f, 0.10739185f, -0.15522312f, -0.00385644f, -0.00449316f, 
    -0.37766168f, -0.39210093f, 0.37539920f, 0.17586212f, -0.11142488f, 0.06342768f, -0.10743059f, 0.18358365f, 
    0.04845409f, 0.02904308f, 0.15372656f, 0.09449349f, 0.02481048f, -0.07058093f, -0.10619061f, -0.04856692f, 
    0.00799144f, -0.12775461f, 0.00613547f, 0.06388245f, 0.17860842f, -0.01665625f, -0.14125060f, -0.06573142f, 
    0.05042666f, 0.05426951f, 0.03429107f, -0.05297348f, -0.07581072f, -0.07841110f, 0.03229010f, -0.01875219f, 
    -0.06231487f, 0.04380393f, 0.00384014f, -0.02990013f, 0.04382692f, -0.04433377f, -0.05032133f, 0.01149827f, 
    -0.01207625f, 0.02284739f, 0.05983411f, -0.05459496f, 0.06313393f, -0.06996065f, -0.00719016f, 0.00156291f, 
    -0.04759156f, -0.05990537f, 0.00897133f, -0.05499817f, -0.01473082f, -0.04478040f, -0.07705654f, 0.00118821f, 
    0.02904364f, 0.04461343f, 0.02070789f, 0.00575325f, -0.00277823f, -0.01637753f, 0.05414786f, 0.05230286f, 
    0.05692830f, 0.06251220f, -0.04241910f, 0.01917053f, -0.05589112f, -0.07516702f, 0.03920892f, 0.01279052f, 
    0.01901372f, 0.03379856f, -0.04665383f, -0.05408492f, 0.00826857f, -0.04793356f, 0.02358161f, 0.05973395f, 
    -0.05597905f, 0.05346604f, 0.01670991f, 0.00807607f, -0.05100915f, -0.06512772f, 0.02195071f, 0.01238860f, 
    0.01175355f, 0.03721348f, -0.02580929f, -0.06400212f, -0.04756803f, 0.00124466f, 0.03972152f, 0.02274788f, 
    -0.02999444f, -0.05594542f, -0.06886463f, 0.05343109f, -0.02445675f, -0.06088477f, 0.03278536f, -0.04237328f, 
    0.01203279f, -0.05584694f, -0.01969421f, -0.05051317f, -0.00005079f, -0.01649500f, 0.02841179f, -0.04925966f, 
    -0.00333451f, -0.06353211f, -0.02909831f, -0.03246522f, -0.01580896f, -0.07884522f, -0.07221618f, -0.04204966f, 
    0.01517667f, -0.01959649f, -0.05447851f, 0.06050631f, -0.01395403f, -0.03091136f, -0.01463363f, -0.07351797f, 
    0.05730165f, -0.05705136f, -0.06749254f, 0.02530710f, -0.04907649f, 0.04362552f, -0.07398864f, -0.03080433f, 
    0.01491620f, 0.01453962f, -0.03314517f, 0.01640103f, 0.00026280f, 0.00499640f, 0.04888181f, -0.00620101f, 
    -0.05277666f, -0.06061778f, -0.02080138f, -0.05131837f, 0.01100725f, 0.01000087f, 0.00378851f, -0.04123827f, 
    0.04662766f, 0.00486099f, -0.00604584f, -0.05298184f, -0.04368097f, -0.05450099f, -0.07281435f, 0.04243419f, 
    -0.03827074f, -0.04648150f, -0.00239464f, -0.04110078f, 0.02126703f, -0.07398928f, 0.02467954f, 0.06137099f, 
    -0.04642587f, -0.03682321f, -0.05150765f, 0.00225424f, -0.06166314f, 0.02048226f, 0.05063267f, 0.01741230f, 
    -0.03169907f, -0.06739267f, 0.05625363f, -0.02847376f, -0.05480079f, -0.04044222f, 0.05408798f, 0.04420022f, 
    0.04195018f, -0.02276637f, -0.07544412f, -0.02197889f, -0.01581026f, 0.00959786f, 0.05097724f, 0.00501112f, 
    -0.04111268f, -0.01868910f, -0.05245086f, -0.06381276f, 0.02334210f, 0.02025334f, -0.06410518f, -0.03884793f, 
    -0.04865572f, 0.00114542f, -0.04683060f, -0.06083076f, -0.06107118f, -0.01798015f, 0.00561585f, -0.00112627f, 
    -0.05386671f, 0.06079582f, -0.05827796f, 0.04419035f, 0.00855611f, -0.03059939f, 0.03217487f, 0.03318985f, 
    -0.05015597f, 0.03256621f, 0.00550753f, -0.12905808f, -0.09540717f, -0.07635913f, 0.05715071f, -0.06115323f, 
    -0.18051749f, -0.01779570f, 0.05061870f, 0.12296311f, -0.14041631f, -0.18776965f, -0.62416744f, -0.38839495f, 
    -0.07933582f, 0.08496478f, 0.11461599f, -0.11262055f, 0.05132038f, 0.09212220f, -0.03675433f, 0.12570556f, 
    0.11360323f, 0.09489270f, -0.15546690f, -0.29796809f, -0.06785784f, 0.00780767f, -0.05177213f, 0.06195061f, 
    -0.08640241f, 0.26068628f, 0.04666088f, -0.11628255f, 0.11748210f, 0.03776856f, 0.10793529f, -0.12988430f, 
    0.03533999f, -0.09499364f, 0.05591294f, 0.07104579f, -0.07734299f, 0.01619812f, -0.17088856f, -0.02343608f, 
    0.55025208f, 0.42075583f, -0.04256517f, 0.20295371f, -0.04530908f, -0.07258412f, 0.11176538f, -0.19956791f, 
    0.05139075f, 0.03800320f, -0.01695673f, -0.03459800f, -0.24649116f, 0.09796802f, -0.50583869f, -0.60162681f, 
    0.09367052f, 0.09626135f, -0.00731445f, 0.15475495f, 0.01893410f, -0.06157967f, 0.11028934f, 0.17403659f, 
    -0.32593414f, -0.32719168f, -0.45051235f, -0.71707922f, 0.11520582f, 0.01097136f, -0.14069857f, -0.04046921f, 
    -0.09108733f, -0.06095862f, 0.03520598f, -0.03413011f, 0.42559233f, -0.09024944f, 0.03982805f, 0.12479266f, 
    0.17527734f, -0.10297324f, 0.12681985f, -0.03468493f, 0.03015844f, 0.07968147f, -0.00200077f, 0.11040334f, 
    -0.06104004f, -0.29091564f, 0.19999592f, 0.08084725f, -0.04754912f, 0.14803572f, 0.17786202f, 0.05843993f, 
    0.03699704f, -0.14307733f, -0.12791838f, 0.19181855f, 0.15867648f, 0.00285837f, 0.10220485f, 0.13569593f, 
    -0.05247600f, -0.11208788f, -0.05478460f, 0.02353115f, 0.09056614f, -0.00818027f, -0.01843879f, 0.05301338f, 
    0.06296439f, 0.32889071f, 0.15622064f, 0.05966898f, -0.06538006f, -0.18631999f, 0.04954756f, 0.01840134f, 
    0.11222105f, 0.00875708f, 0.00311713f, -0.06179967f, 0.34911841f, 0.09358823f, 0.00491445f, 0.21222253f, 
    0.05884846f, -0.08627529f, 0.04384561f, -0.05888722f, 0.01799087f, 0.23382184f, 0.12720738f, -0.18800457f, 
    -0.11463320f, -0.30860570f, -0.42969680f, -0.17058040f, -0.11500083f, -0.00042525f, -0.22205590f, 0.37934712f, 
    0.19397499f, -0.08386722f, 0.13886663f, 0.05129953f, 0.20326358f, 0.04367649f, 0.05718232f, 0.05807270f, 
    0.31596068f, 0.13376945f, 0.38415217f, 0.24408230f, -0.16655636f, -0.02836095f, 0.03366540f, -0.03639700f, 
    -0.13982527f, -0.55405259f, 0.10271285f, 0.22983876f, 0.04211316f, 0.11497041f, -0.05363951f, 0.31592792f, 
    -0.04220069f, -0.04074025f, 0.00508841f, 0.21190901f, 0.09470767f, 0.00889789f, -0.06249654f, -0.01918961f, 
    0.04880336f, -0.18275322f, 0.25775841f, 0.06206512f, 0.06584749f, 0.01860850f, 0.02780859f, 0.02513609f, 
    0.20278789f, -0.10650645f, -0.07908870f, 0.19842251f, -0.03814967f, 0.03837338f, 0.09042775f, -0.00856611f, 
    -0.03716883f, 0.00109817f, 0.11190291f, 0.03367534f, 0.05898500f, 0.03438422f, 0.24274510f, 0.04615377f, 
    0.16508220f, -0.03666618f, 0.02809246f, -0.03784244f, -0.00975298f, 0.04842377f, 0.05617581f, -0.10684094f, 
    0.14705840f, -0.07711671f, 0.02354803f, -0.09765646f, -0.00167496f, 0.02622726f, 0.02589683f, -0.15125699f, 
    -0.07616527f, -0.00905008f, 0.00289403f, -0.02505117f, 0.07107762f, 0.06248200f, 0.04050660f, 0.04445549f, 
    0.00954166f, 0.01975733f, -0.05939766f, -0.05349832f, 0.00807761f, -0.03384391f, -0.06409554f, 0.02101506f, 
    -0.08170623f, -0.05632020f, -0.00694442f, -0.06161712f, 0.12054775f, -0.05100522f, -0.05444181f, 0.04111316f, 
    -0.09969997f, -0.08144153f, 0.06483245f, 0.02043494f, 0.23985782f, -0.05475585f, 0.06941724f, -0.27910423f, 
    0.12431642f, -0.06370034f, 0.19810826f, 0.14975654f, -0.11612943f, -0.06157300f, 0.13591075f, -0.04704558f, 
    0.12175909f, 0.19028932f, -0.01693802f, -0.18675193f, 0.06658491f, 0.18845107f, 0.16993968f, 0.10118876f, 
    -0.09978821f, -0.06086820f, -0.04462999f, -0.07455046f, 0.25172889f, -0.29018831f, 0.00283676f, -0.07073004f, 
    0.06396660f, -0.13217987f, -0.08001493f, 0.00096240f, 0.02174252f, -0.05483981f, -0.03395426f, -0.02056117f, 
    -0.05749606f, -0.19144987f, -0.24947268f, -0.07090756f, -0.05929618f, -0.07482070f, -0.17650877f, 0.08636724f, 
    0.08497481f, 0.09701993f, -0.13839415f, 0.15494454f, -0.06390339f, 0.04173635f, 0.11064377f, 0.17263442f, 
    0.07204396f, -0.01122659f, -0.14110325f, 0.04646094f, -0.02840659f, -0.12150495f, -0.15440877f, -0.06487773f, 
    0.14251992f, -0.03316154f, 0.16049069f, 0.19535078f, 0.07511798f, 0.01533683f, 0.10865063f, -0.27485445f, 
    -0.08354338f, -0.06056778f, 0.03913625f, 0.00735872f, 0.09117617f, 0.02090595f, 0.10139723f, -0.09488468f, 
    -0.09053604f, 0.05179276f, -0.04383480f, -0.03505173f, -0.09428292f, 0.06237181f, 0.08782890f, -0.04075727f, 
    0.11290863f, 0.07324028f, 0.03971697f, -0.12980394f, 0.00351841f, 0.09814384f, -0.14967760f, -0.06896755f, 
    -0.03691131f, -0.04881522f, 0.13257246f, -0.07253295f, 0.13303746f, -0.00797399f, -0.31750664f, -0.35492927f, 
    -0.09941360f, -0.09132782f, -0.09787676f, -0.02897104f, -0.08093175f, 0.13743174f, -0.02978539f, 0.05374260f, 
    0.31424963f, 0.16567186f, 0.08045676f, -0.14646572f, 0.30388048f, -0.03157097f, 0.11450530f, 0.17126568f, 
    0.12434441f, 0.00343115f, 0.00127279f, 0.04752491f, -0.01366144f, -0.09023451f, -0.10754682f, -0.13442425f, 
    0.02885815f, 0.01438889f, -0.06734783f, -0.00958416f, -0.25401980f, -0.08695459f, -0.13043803f, -0.04012182f, 
    -0.06557537f, -0.02491465f, -0.03467942f, -0.02206530f, -0.06525936f, 0.00356204f, 0.04900470f, 0.02935730f, 
    -0.01105306f, -0.00748584f, 0.00520178f, -0.01059046f, 0.03012830f, 0.00785255f, 0.02529021f, -0.03209232f, 
    -0.01345218f, 0.06430563f, 0.04597458f, 0.04251027f, -0.04222637f, 0.04650248f, -0.04842631f, 0.02901474f, 
    0.06760663f, -0.02685703f, 0.01238616f, -0.03148188f, 0.03611015f, -0.02161827f, -0.03790821f, -0.05416473f, 
    -0.05504109f, -0.04743916f, -0.00240335f, -0.04021279f, -0.02807531f, 0.03010437f, 0.03659361f, -0.06013533f, 
    -0.07799710f, -0.07014042f, 0.02867305f, 0.07403604f, -0.04931132f, -0.07123350f, -0.00542533f, -0.04490342f, 
    0.01409505f, -0.02288789f, -0.07072023f, 0.06077037f, -0.02157947f, -0.06413979f, 0.01015577f, 0.02289069f, 
    0.05121522f, 0.07042715f, 0.05345969f, -0.06425104f, 0.03850545f, 0.02395598f, 0.04407065f, -0.05854433f, 
    0.03404307f, 0.00752265f, 0.03363232f, 0.02688822f, 0.04098503f, -0.04629425f, 0.03575415f, -0.07356543f, 
    -0.06099983f, -0.05519716f, 0.06478411f, -0.03975711f, -0.01285535f, -0.04222208f, 0.06746796f, -0.01483333f, 
    0.07031151f, 0.00286255f, -0.01595849f, -0.06161844f, -0.04483309f, 0.02838048f, -0.06132106f, -0.06772126f, 
    0.03579096f, -0.00274690f, 0.06685283f, -0.00297460f, -0.04088935f, -0.03249551f, 0.01908170f, 0.03862682f, 
    -0.06591758f, -0.07523769f, -0.02712282f, 0.01572272f, 0.04452569f, 0.01309867f, 0.06392064f, -0.05543758f, 
    -0.03948114f, -0.01698822f, 0.01599114f, -0.03493935f, -0.01326039f, -0.02471324f, -0.00566590f, -0.06754340f, 
    0.04753650f, -0.04302444f, 0.05250910f, -0.03926442f, -0.05595348f, 0.04128102f, -0.01887554f, -0.01861353f, 
    -0.02527592f, 0.03786642f, 0.00021489f, 0.05046456f, -0.03548476f, -0.06532665f, -0.04541184f, -0.06191301f, 
    0.00498334f, -0.03986783f, -0.01639373f, -0.07151874f, 0.04049559f, 0.02772004f, -0.02541580f, -0.03458890f, 
    -0.05736914f, 0.01595523f, -0.02778380f, 0.00908972f, -0.00236391f, -0.05765015f, 0.06924727f, 0.05874371f, 
    -0.01515645f, -0.07022706f, 0.01463405f, -0.07410362f, -0.03252941f, -0.06677104f, -0.01585148f, 0.06087103f, 
    -0.00165692f, -0.00483888f, 0.00474483f, 0.03331704f, 0.04038928f, -0.03289516f, -0.02746328f, -0.03457808f, 
    0.02822008f, -0.05878451f, -0.06311664f, -0.07059103f, 0.05764008f, 0.03073598f, -0.03836219f, -0.06122024f, 
    0.05393601f, 0.04202953f, -0.04250422f, -0.03893093f, -0.03872456f, -0.07370422f, 0.03896880f, -0.02371627f, 
    0.00178919f, -0.01337133f, -0.02048852f, -0.04170484f, -0.01459285f, 0.03884799f, 0.01798070f, -0.02458229f, 
    0.00949067f, -0.06055694f, -0.03109579f, -0.00269481f, -0.05752248f, 0.03368766f, -0.04092661f, 0.04889661f, 
    -0.19779119f, -0.02432993f, 0.21702263f, 0.19024172f, 0.02511211f, 0.04272636f, -0.13847591f, 0.04453020f, 
    0.00440484f, 0.19073088f, 0.08811841f, 0.23334913f, -0.07225279f, -0.18685731f, -0.02999766f, 0.02261899f, 
    -0.01576032f, -0.06644147f, -0.06392954f, 0.10358396f, 0.03389157f, 0.00933913f, 0.27204084f, 0.25069749f, 
    -0.31105292f, 0.06594992f, 0.49185532f, 0.15389566f, 0.16691524f, -0.01246694f, -0.15744482f, 0.07878923f, 
    0.02317671f, -0.06218985f, 0.28880146f, 0.13049026f, 0.08313829f, -0.16733667f, -0.16208343f, 0.26829115f, 
    0.09727748f, 0.20379072f, 0.05276666f, 0.10866702f, 0.08061906f, 0.07763986f, -0.02487374f, -0.02192325f, 
    0.04231821f, 0.00524010f, 0.25974020f, -0.18233000f, 0.13665348f, 0.04808395f, -0.00908630f, 0.15683372f, 
    -0.11523292f, 0.02543765f, -0.06381919f, 0.10878121f, -0.05291384f, -0.02290803f, 0.28271592f, 0.09788828f, 
    0.03116409f, -0.00786349f, 0.03096368f, -0.15636766f, -0.02645303f, -0.11470538f, 0.14452113f, 0.11525925f, 
    -0.10924191f, -0.02916477f, 0.02097002f, -0.16540883f, 0.11865512f, -0.14388017f, -0.07087830f, -0.17421333f, 
    0.04524352f, -0.17945321f, -0.07488812f, -0.13180494f, -0.07398467f, -0.15943724f, -0.02586396f, 0.04614415f, 
    0.10969174f, 0.10066295f, 0.14545460f, 0.12559003f, -0.05231002f, -0.12155484f, -0.04751951f, -0.14775471f, 
    0.02603326f, -0.08806374f, 0.37635550f, -0.17209920f, 0.10512320f, 0.08421499f, -0.11726925f, -0.04209098f, 
    -0.13754083f, 0.01359487f, 0.00984827f, 0.11984266f, -0.06187236f, -0.09192729f, -0.21283697f, -0.09012660f, 
    -0.03401351f, 0.22156093f, 0.06914062f, 0.11888268f, 0.09079005f, -0.04034658f, 0.02930035f, 0.05722196f, 
    0.15992184f, -0.20319836f, -0.10263323f, -0.06187623f, 0.21675654f, 0.14058179f, -0.10060979f, 0.30776682f, 
    0.07366132f, -0.01195960f, 0.03908327f, 0.11154566f, 0.01269304f, -0.01962746f, -0.20030685f, -0.09208530f, 
    0.02288621f, -0.01151666f, -0.01939182f, 0.11164360f, 0.06072317f, -0.09188880f, -0.04954992f, 0.19090575f, 
    -0.19737214f, 0.35355249f, 0.08167642f, 0.02009082f, -0.06188281f, -0.13677527f, 0.08809938f, 0.10138608f, 
    0.08773284f, 0.03559660f, 0.02797945f, 0.07277925f, 0.07225571f, 0.06454399f, 0.37883687f, -0.14838888f, 
    0.08440655f, 0.41043055f, -0.19994232f, 0.10651812f, -0.03420689f, -0.01527970f, -0.01375704f, -0.09235472f, 
    -0.37243330f, 0.09592475f, 0.24066791f, 0.05638550f, 0.01382211f, -0.01181957f, 0.24601115f, 0.17916319f, 
    -0.02685391f, 0.03616291f, -0.04729615f, 0.10907915f, -0.06970391f, -0.03228083f, -0.07820760f, -0.08207110f, 
    0.09242233f, 0.03401776f, -0.07476284f, 0.18813379f, 0.08963344f, 0.01525969f, -0.16070962f, -0.01320425f, 
    0.01463499f, -0.22295593f, -0.11973764f, -0.48711213f, -0.13921325f, -0.03741682f, -0.11753538f, -0.09188861f, 
    0.11775365f, -0.11111952f, -0.13335903f, -0.12785012f, -0.20711073f, 0.18112029f, -0.12576373f, 0.06458247f, 
    -0.08893643f, -0.02235816f, -0.04938217f, -0.01905428f, 0.12029105f, -0.04515498f, -0.08763392f, 0.09326445f, 
    0.14407530f, 0.09422253f, -0.14666668f, -0.15998617f, -0.15535481f, 0.06299902f, -0.02637515f, 0.19541299f, 
    0.18996377f, -0.05889327f, -0.11597879f, 0.01993066f, -0.09838045f, 0.01615985f, 0.12813693f, -0.05192909f, 
    0.03267391f, 0.02872913f, 0.07688506f, -0.06187231f, -0.01977301f, -0.05951470f, 0.21239312f, 0.11877574f, 
    0.00131044f, 0.10567373f, 0.02513020f, 0.22625299f, -0.22756723f, 0.03344596f, 0.06711058f, 0.02859935f, 
    0.03944616f, 0.04870014f, -0.03658884f, -0.06358899f, -0.23339607f, 0.24233654f, -0.03863424f, 0.31675091f, 
    0.26098406f, 0.03663819f, -0.00741406f, 0.01861434f, 0.05473773f, 0.08948555f, -0.06860594f, -0.17765380f, 
    -0.11797821f, -0.12734875f, 0.09093824f, 0.34929314f, -0.12821014f, -0.05284503f, 0.03589959f, 0.05059391f, 
    -0.04685666f, 0.04241203f, -0.03748980f, -0.03156634f, -0.08959481f, 0.32429445f, 0.07142294f, 0.00988958f, 
    -0.05913331f, 0.04511382f, -0.01344690f, -0.07206272f, 0.02276510f, -0.01114714f, 0.04688700f, 0.00270328f, 
    -0.08164413f, 0.02243695f, 0.05845940f, 0.34192106f, 0.18008904f, 0.10220163f, 0.26139703f, 0.01044414f, 
    -0.01423199f, -0.15332578f, 0.06933793f, -0.03302792f, 0.11123604f, 0.12862757f, 0.09929561f, -0.07211287f, 
    0.05129753f, -0.16007113f, -0.02890977f, -0.04837338f, 0.03571555f, 0.00363388f, -0.10074580f, 0.09454925f, 
    -0.07397205f, 0.34807178f, 0.05264378f, 0.09272656f, 0.08596727f, 0.10861702f, 0.00142139f, 0.13671781f, 
    -0.02297717f, 0.02900600f, 0.15053736f, 0.01437267f, 0.05148969f, 0.17114593f, 0.16671211f, 0.18549427f, 
    0.03391038f, 0.08251946f, 0.03825201f, -0.13607903f, 0.08390472f, 0.12079371f, 0.03637451f, -0.09999712f, 
    -0.01707524f, -0.05207870f, 0.09154283f, 0.16925992f, -0.04030007f, -0.09954625f, 0.01983935f, 0.12443908f, 
    0.07070352f, -0.02921557f, -0.08033466f, -0.13174658f, -0.30857131f, 0.15493515f, 0.26412416f, 0.14385605f, 
    0.14069678f, -0.12950262f, 0.29621118f, 0.08008240f, 0.02815518f, -0.16292834f, 0.05481205f, 0.02173181f, 
    0.05939609f, -0.29797918f, 0.06879453f, 0.17833015f, -0.06568556f, 0.01821249f, -0.20935912f, 0.13151817f, 
    -0.05084853f, -0.13745086f, -0.07213702f, -0.03590642f, -0.01426718f, 0.02630647f, 0.06114977f, -0.02763617f, 
    -0.01757093f, 0.07373760f, 0.16993672f, 0.01332081f, 0.03243719f, 0.03220022f, 0.22583143f, 0.13054360f, 
    0.07880300f, -0.21835302f, 0.02597316f, 0.11147052f, 0.06257242f, -0.01386589f, -0.08158351f, -0.06537548f, 
    0.10790517f, 0.02950031f, 0.00044367f, 0.23763028f, 0.09682947f, 0.12884678f, 0.24852662f, 0.21225049f, 
    0.00896857f, 0.22422515f, 0.10251527f, 0.14535481f, -0.01902915f, -0.10521124f, 0.09649012f, 0.02524668f, 
    0.15577899f, -0.14420451f, 0.02823729f, -0.08395737f, 0.06549391f, -0.05354676f, -0.14250737f, -0.05041830f, 
    -0.11513650f, 0.00700312f, 0.05465334f, 0.12186477f, -0.27428934f, -0.14551648f, 0.09706025f, 0.09877834f, 
    -0.12826298f, -0.05550629f, -0.06080361f, -0.19099215f, -0.21559899f, -0.00900591f, -0.01788038f, -0.23629554f, 
    -0.14447284f, -0.13894607f, -0.27187148f, 0.03643736f, -0.04119502f, -0.22410628f, 0.15515858f, 0.05751609f, 
    0.09251768f, -0.06837220f, -0.14366855f, -0.06545541f, 0.18004429f, -0.00668968f, 0.03768002f, -0.11061862f, 
    -0.15044834f, -0.00349299f, 0.05506342f, 0.10421600f, -0.03504203f, -0.01192424f, 0.08721406f, 0.08079366f, 
    0.41917586f, 0.38528425f, 0.15854913f, 0.07743315f, -0.00805217f, 0.08187158f, 0.02642804f, 0.11876421f, 
    0.09949551f, 0.02718267f, 0.14714095f, -0.11078969f, -0.11523628f, -0.12191366f, -0.04859350f, 0.04226846f, 
    -0.05198453f, -0.24816151f, -0.06327873f, 0.21588251f, 0.05175624f, 0.18729876f, 0.10483450f, -0.22209100f, 
    0.21210571f, 0.61815411f, 0.08546860f, 0.26859242f, 0.09356253f, 0.16086659f, 0.14273478f, -0.09868963f, 
    0.00926076f, 0.01265732f, -0.00188253f, -0.00453390f, -0.31106016f, -0.40275386f, -0.16595608f, 0.05167803f, 
    0.02830984f, 0.02005079f, -0.14090407f, 0.03911654f, 0.27058777f, -0.02098823f, 0.06640052f, 0.20873739f, 
    -0.21481724f, -0.31054550f, -0.27433354f, -0.11877875f, -0.16291548f, 0.01588647f, -0.03587720f, -0.21254021f, 
    -0.01817987f, 0.02429823f, -0.13445070f, -0.01691706f, -0.39032269f, -0.38791332f, -0.31013516f, -0.33632979f, 
    0.15474273f, -0.09805010f, -0.03445259f, -0.09039899f, 0.09314577f, 0.09748601f, -0.16129835f, 0.07769727f, 
    0.13609739f, 0.01847655f, 0.15579340f, 0.23685421f, 0.04285609f, 0.03379377f, 0.15254043f, -0.01323307f, 
    -0.05264621f, 0.05616848f, -0.02450933f, 0.26193687f, 0.34047535f, 0.23413135f, 0.14723316f, -0.04967019f, 
    -0.06809881f, 0.21551998f, -0.22268203f, 0.13871126f, -0.03537979f, -0.00933072f, 0.15630746f, -0.20152260f, 
    0.02997182f, 0.24316517f, 0.47263330f, 0.09106872f, 0.03223842f, 0.09354327f, -0.10928416f, 0.05585659f, 
    -0.00156543f, -0.02633996f, 0.03127465f, 0.10089942f, -0.09454814f, -0.12671393f, -0.21602455f, -0.18629329f, 
    0.12184193f, 0.07039566f, -0.07605018f, -0.01429814f, 0.09799422f, -0.03671791f, -0.24578249f, -0.29750797f, 
    -0.13788645f, 0.04450523f, 0.05843249f, -0.04791248f, -0.06809411f, 0.01225035f, -0.09783377f, 0.06265114f, 
    0.13607787f, 0.25954708f, 0.19069763f, 0.09961784f, 0.05713565f, -0.18085547f, -0.17084348f, -0.07415945f, 
    0.01404496f, -0.05665843f, -0.10518263f, -0.06263872f, 0.14831297f, -0.04761859f, 0.18676110f, 0.21736418f, 
    -0.30960447f, 0.11280303f, 0.11115710f, -0.07166426f, 0.00089324f, -0.14913978f, -0.01800744f, 0.03323975f, 
    0.07657929f, 0.02226013f, 0.00687124f, 0.11354369f, -0.05418332f, -0.25741929f, -0.15584190f, 0.01260872f, 
    0.08714931f, 0.04659998f, 0.00902090f, 0.01423047f, 0.01896918f, -0.05366342f, -0.07321337f, -0.09928818f, 
    -0.26758054f, 0.14254555f, 0.06858498f, -0.04834750f, 0.04892595f, 0.06374721f, -0.13810216f, -0.04246055f, 
    -0.10707052f, -0.12126100f, -0.11935622f, -0.05402654f, -0.21209608f, -0.08144522f, 0.24386905f, 0.03412970f, 
    0.05756781f, -0.04629640f, -0.00640363f, -0.10519870f, 0.09710585f, -0.08293162f, -0.03002348f, 0.11288023f, 
    -0.14020567f, -0.32474223f, -0.04561413f, -0.02828349f, 0.02969050f, -0.17359510f, 0.00535584f, -0.16732927f, 
    -0.01017701f, -0.00806627f, -0.07889391f, -0.08005974f, -0.11305344f, 0.13508214f, 0.12577839f, 0.14230549f, 
    0.04755689f, 0.00835320f, -0.01737159f, 0.09877888f, -0.04533583f, 0.00248917f, -0.05127186f, -0.01215184f, 
    -0.13976653f, 0.15723750f, 0.03233165f, -0.00134734f, 0.35012090f, 0.06628907f, -0.00507683f, -0.10348630f, 
    0.02505763f, -0.02429624f, 0.05916054f, -0.00614271f, -0.03016804f, -0.08811130f, -0.12289713f, -0.16390961f, 
    0.02770955f, 0.00912196f, 0.09873889f, -0.05253401f, 0.08078232f, -0.04335252f, -0.05581973f, -0.01026490f, 
    0.05074344f, -0.22043741f, -0.16762972f, -0.05470946f, 0.10201745f, 0.01527113f, -0.00270916f, 0.09325588f, 
    -0.04565465f, -0.07658309f, -0.03985195f, 0.10134190f, -0.04216468f, -0.01989486f, 0.06370828f, -0.15056595f, 
    0.02857072f, 0.03502913f, 0.03532170f, 0.04713050f, 0.00025206f, -0.05541879f, 0.02345469f, 0.02278041f, 
    -0.00496599f, 0.03604732f, 0.06138492f, 0.36057085f, -0.21072605f, -0.01336915f, 0.18283141f, 0.04924564f, 
    0.01702904f, 0.06677077f, 0.11668877f, 0.27923319f, -0.16292581f, 0.02595450f, 0.39654610f, -0.15748657f, 
    -0.01102298f, 0.36959919f, -0.04796898f, 0.09349008f, 0.00823353f, -0.02523555f, 0.06015822f, -0.13067940f, 
    -0.02242247f, -0.31403607f, 0.26741675f, 0.06807455f, -0.00301529f, 0.00576152f, -0.01977455f, 0.18582086f, 
    -0.00721115f, 0.01445284f, -0.01569838f, 0.14551066f, -0.12386810f, 0.00811812f, -0.02075680f, -0.04406254f, 
    0.13693555f, -0.08896799f, -0.03786938f, 0.03039720f, -0.00744926f, -0.00132656f, -0.00825133f, -0.05287442f, 
    0.24766198f, -0.13153094f, 0.15576729f, 0.14703456f, -0.09396721f, 0.04991711f, 0.04899329f, -0.09318479f, 
    0.16543020f, 0.12101814f, 0.13422862f, -0.00414588f, -0.15834042f, 0.03970258f, 0.10362571f, 0.14495301f, 
    0.03867850f, -0.17501095f, -0.04088160f, -0.10739736f, -0.07077915f, -0.06755761f, -0.04875316f, -0.11880303f, 
    0.31288522f, 0.26958123f, 0.31885535f, 0.15228248f, 0.02078461f, 0.09119502f, -0.08765547f, -0.04372416f, 
    -0.21755463f, -0.01665427f, -0.06045328f, -0.05271345f, -0.12680642f, -0.09183799f, 0.04060369f, -0.01850117f, 
    0.08450082f, 0.06294279f, 0.05551017f, -0.05487749f, 0.07875062f, 0.04172011f, 0.06004099f, 0.12310182f, 
    -0.25081238f, -0.10563252f, -0.18259825f, -0.28779867f, -0.10011810f, -0.09837867f, 0.01478184f, 0.16899136f, 
    -0.06210752f, 0.01093062f, 0.04409817f, 0.02007964f, 0.02498090f, 0.04948563f, -0.09388698f, -0.07274937f, 
    0.06581157f, -0.11173370f, 0.14207968f, 0.19614285f, -0.12030981f, 0.02873781f, -0.02874166f, -0.22966121f, 
    -0.18734664f, 0.13857228f, -0.10758836f, -0.03457982f, -0.19337699f, -0.08053603f, 0.08455916f, 0.15530737f, 
    -0.10331476f, -0.04828736f, -0.00804967f, 0.02564778f, -0.15460604f, -0.26255813f, -0.08662096f, -0.46593583f, 
    0.08859050f, -0.16525738f, 0.09945557f, 0.04331861f, -0.04353412f, -0.01158281f, 0.00693558f, 0.10796154f, 
    -0.13711609f, -0.03029493f, -0.55875772f, 0.04372035f, -0.12216395f, -0.14058182f, 0.00731051f, 0.15219530f, 
    0.15323918f, -0.12151565f, -0.26531091f, 0.14499383f, -0.17935658f, -0.12102151f, 0.07393360f, 0.05577303f, 
    0.04885741f, 0.09204478f, 0.00516052f, 0.04060544f, 0.08570898f, -0.11870652f, -0.13120250f, 0.17797051f, 
    -0.10345508f, 0.24317352f, 0.07980330f, -0.07974880f, 0.15014993f, -0.06328864f, 0.22702745f, -0.24556142f, 
    0.04158253f, 0.06713483f, 0.06677007f, 0.09790471f, -0.02276880f, 0.01481150f, 0.14200482f, 0.03086471f, 
    -0.10977649f, 0.03337917f, 0.10261477f, -0.01549538f, -0.07240195f, 0.25224689f, 0.11490445f, -0.09360144f, 
    0.07524503f, 0.23018892f, 0.42213538f, -0.05266198f, 0.01913076f, 0.14944465f, -0.05460091f, -0.20827936f, 
    -0.06250836f, 0.14143890f, 0.07613308f, -0.13405763f, 0.11839987f, -0.23009782f, -0.17701855f, -0.14861925f, 
    -0.04107363f, -0.19668394f, 0.13643374f, -0.10954768f, -0.10807654f, 0.05764030f, -0.05831568f, 0.05094782f, 
    0.47870129f, -0.25367230f, 0.03428121f, 0.23175983f, 0.20827155f, -0.00573324f, -0.07129664f, 0.09749010f, 
    0.05881990f, 0.02069213f, -0.04913774f, -0.06968159f, -0.02937250f, 0.02831385f, 0.06126033f, -0.08089769f, 
    -0.16037101f, 0.04769917f, 0.03391628f, 0.09578771f, -0.23978300f, 0.08914083f, -0.11188105f, -0.02239333f, 
    -0.17157348f, 0.29908949f, -0.38150391f, -0.02203894f, -0.07772058f, 0.05571514f, -0.03264557f, -0.15419640f, 
    -0.16108204f, -0.15063787f, -0.01943722f, -0.08768050f, 0.08948058f, -0.07566748f, -0.00640420f, -0.04689173f, 
    0.00907083f, 0.09860776f, 0.07206871f, -0.03247486f, -0.05790471f, 0.07628451f, -0.00539365f, -0.04496197f, 
    0.14321990f, 0.04462728f, -0.31973827f, 0.21331593f, -0.10102069f, 0.07004562f, 0.04950321f, -0.02893668f, 
    -0.02779173f, 0.16741098f, -0.03756997f, 0.04293558f, -0.01745133f, 0.26722285f, 0.08021381f, -0.04180376f, 
    -0.08413199f, -0.09722010f, -0.03570697f, -0.04511198f, -0.01229923f, 0.03851567f, 0.04382368f, 0.05882815f, 
    0.06095676f, -0.07558047f, 0.35587534f, 0.01616922f, -0.00622657f, -0.01233112f, 0.01985609f, -0.11962108f, 
    0.05341524f, -0.05181434f, 0.07567081f, -0.00618106f, 0.18929407f, 0.17311336f, 0.02839353f, 0.29443747f, 
    0.15898289f, 0.20457587f, 0.06970869f, 0.10789996f, -0.10401397f, -0.00340469f, -0.00279445f, 0.01461960f, 
    -0.01819740f, -0.07271122f, -0.15695532f, 0.28464803f, -0.05100365f, 0.14599097f, -0.02424688f, 0.06649939f, 
    -0.05061597f, 0.13024838f, -0.04281503f, -0.00134903f, 0.31277806f, 0.13737307f, 0.22695404f, 0.25038093f, 
    -0.10512473f, -0.07093830f, -0.12745082f, -0.00943625f, -0.04226865f, 0.02976543f, 0.02055750f, 0.07792395f, 
    0.18324667f, -0.41208205f, 0.36801964f, -0.14537372f, -0.00487124f, 0.05107809f, 0.03663723f, 0.21826765f, 
    0.04360187f, 0.05552122f, 0.14211111f, 0.14728755f, 0.10254623f, 0.23838201f, 0.18570578f, 0.02003341f, 
    -0.14809608f, -0.17078745f, -0.24840254f, -0.09991635f, -0.27378470f, -0.03378464f, -0.20141280f, -0.24445508f, 
    0.22391739f, 0.10797127f, 0.03316991f, -0.02913857f, -0.07443104f, -0.07594169f, -0.00233330f, -0.02867512f, 
    -0.04885039f, -0.07993983f, -0.01601488f, -0.12961748f, -0.03287120f, 0.28850695f, 0.14132822f, 0.17655101f, 
    -0.04155132f, -0.04064917f, -0.11031500f, -0.08533125f, -0.02240012f, -0.04089335f, 0.10648322f, -0.22657125f, 
    -0.00257646f, -0.14182854f, 0.01693490f, -0.08565571f, 0.15755726f, 0.04996790f, -0.00059106f, 0.08426405f, 
    0.07687208f, -0.02902089f, -0.04975444f, -0.06252889f, -0.01563811f, -0.28944620f, -0.04312493f, 0.16362192f, 
    -0.04411598f, -0.22156140f, 0.00003126f, 0.06935995f, -0.05530705f, 0.19149977f, -0.06244687f, 0.11697192f, 
    0.01430296f, 0.38744932f, -0.33789229f, 0.03195295f, 0.08073186f, -0.04752820f, 0.15373078f, -0.12585694f, 
    0.06036951f, 0.00501399f, 0.10938761f, 0.01947469f, -0.01555333f, 0.04519820f, 0.05262085f, -0.01672520f, 
    0.03707068f, 0.07222186f, 0.04265417f, 0.11050393f, 0.06915224f, 0.12738679f, 0.14376152f, 0.08912909f, 
    0.10035933f, -0.08434063f, -0.03964056f, -0.06276407f, 0.04839210f, -0.03486850f, 0.02468984f, 0.06542943f, 
    -0.06058973f, -0.03696658f, 0.00107824f, -0.06832564f, -0.01480498f, -0.02189912f, -0.04159205f, 0.25649187f, 
    0.03813830f, 0.03370108f, 0.03418444f, -0.00016485f, 0.09161933f, 0.06911113f, 0.17996551f, -0.07512752f, 
    -0.33249626f, -0.06503212f, 0.09679674f, -0.04684766f, 0.05177852f, -0.10702823f, 0.00889286f, -0.17023286f, 
    -0.18724877f, -0.02183455f, 0.16089509f, -0.00334937f, -0.01691461f, -0.20534518f, 0.22531189f, 0.26126981f, 
    0.10913853f, 0.02701625f, -0.04417207f, -0.20105022f, -0.23706043f, 0.05245816f, 0.02170120f, -0.03571067f, 
    0.23803468f, 0.28115758f, 0.17560518f, -0.10302241f, -0.09080815f, -0.02665500f, -0.06482942f, 0.04217646f, 
    0.06270934f, 0.16113192f, -0.10770360f, -0.11657062f, -0.16723192f, 0.17270797f, 0.20647649f, 0.05383939f, 
    -0.01595629f, 0.08335534f, 0.10125536f, 0.09354341f, -0.04701904f, -0.03962391f, 0.23155536f, 0.03808475f, 
    -0.20599836f, -0.06626617f, 0.03234237f, 0.16162251f, 0.10866227f, 0.01606087f, 0.19951409f, 0.05174251f, 
    0.05734708f, -0.16366880f, -0.05112880f, -0.03942628f, -0.00085818f, 0.16875909f, 0.39201918f, 0.06370605f, 
    -0.15585715f, -0.15809861f, -0.01079782f, 0.15131158f, -0.08673596f, -0.02285051f, 0.03622229f, -0.27552769f, 
    -0.03319360f, 0.14080191f, 0.20797500f, 0.29123276f, 0.16249926f, -0.08975792f, -0.08700775f, -0.07140734f, 
    -0.06251674f, -0.02703008f, 0.00408435f, -0.00241571f, -0.05689035f, -0.19779077f, 0.02375634f, -0.06325548f, 
    0.04590354f, 0.00156107f, -0.07592011f, 0.07771947f, 0.22362053f, -0.21958511f, -0.03326681f, 0.06130173f, 
    0.08882868f, -0.06039507f, -0.36534712f, 0.05874280f, 0.02661833f, -0.00200166f, -0.11646572f, -0.11506546f, 
    -0.07142507f, 0.17669198f, -0.03905067f, -0.03009660f, -0.01276907f, -0.00410944f, -0.21445869f, -0.31713700f, 
    -0.03033447f, -0.03877592f, -0.06101415f, -0.07667725f, 0.15863518f, 0.01545377f, -0.08244634f, 0.07171021f, 
    -0.02100884f, 0.02251462f, 0.09579652f, 0.15772678f, -0.03662541f, -0.02516740f, 0.28463531f, -0.02245825f, 
    0.04838128f, 0.00458354f, -0.07917272f, 0.10552467f, -0.07643318f, 0.12844105f, 0.71467972f, -0.21872425f, 
    -0.10571533f, 0.23744284f, -0.15979502f, 0.03322418f, -0.15909965f, -0.00171440f, 0.04039759f, 0.07569261f, 
    -0.27318153f, -0.02163084f, 0.25360513f, -0.05745564f, 0.12188841f, 0.05167413f, -0.10281910f, 0.11032392f, 
    0.04644335f, 0.01680635f, -0.10964476f, 0.16705617f, -0.17089248f, 0.09509917f, -0.08631689f, -0.14023609f, 
    -0.04374300f, 0.06497654f, -0.24685597f, 0.06321616f, -0.02484228f, 0.19905216f, -0.25211045f, -0.10554143f, 
    0.01512905f, -0.04419553f, -0.13588710f, 0.18149671f, -0.05473652f, 0.00228585f, 0.00600778f, -0.01571403f, 
    0.03907844f, 0.06306530f, 0.14199609f, 0.21843132f, -0.02700077f, 0.09117376f, 0.17610258f, -0.16145764f, 
    -0.03384872f, 0.01450802f, 0.00218043f, 0.03255676f, 0.01403603f, -0.12354399f, 0.01972459f, -0.12025642f, 
    0.08941217f, 0.22900406f, -0.06266993f, 0.27565730f, -0.07199523f, 0.10746696f, -0.06007143f, -0.03181580f, 
    -0.10747359f, -0.12483148f, -0.15182802f, 0.05364385f, -0.11652367f, 0.02876116f, -0.13858673f, 0.03863578f, 
    -0.13852590f, -0.09718203f, 0.08430285f, -0.05787777f, -0.05021263f, 0.05658508f, 0.02829956f, -0.01707330f, 
    -0.13035396f, -0.36063671f, -0.07891881f, -0.24828014f, -0.13309763f, -0.00751416f, -0.21147613f, 0.16825224f, 
    0.00044345f, -0.11086392f, -0.00563167f, -0.04605321f, 0.17961290f, -0.08058899f, 0.07570861f, 0.14665377f, 
    -0.11336088f, 0.05930067f, -0.09790210f, 0.07381839f, 0.03946028f, 0.00109394f, -0.05029926f, -0.10068792f, 
    0.18683657f, 0.13319643f, 0.01953498f, -0.05222254f, -0.09203283f, 0.07541125f, -0.04851122f, 0.15632834f, 
    -0.00492656f, 0.04524527f, -0.06312420f, 0.05650821f, -0.18886149f, -0.05706348f, -0.18645622f, -0.06254634f, 
    -0.07679006f, -0.06264037f, 0.01282253f, -0.05570260f, -0.02663642f, 0.12334071f, -0.00240756f, 0.10137179f, 
    0.23282185f, -0.06563226f, -0.13843808f, -0.03463037f, -0.06047955f, 0.11070704f, 0.06373815f, 0.15854639f, 
    0.00706324f, -0.06762827f, -0.08124822f, 0.09005270f, -0.14425775f, -0.13864823f, -0.02358256f, -0.07447859f, 
    -0.07154433f, 0.08674695f, 0.01996100f, 0.04614852f, -0.02066236f, -0.07112136f, -0.12686397f, 0.06905632f, 
    -0.23835726f, 0.02821868f, 0.01041993f, -0.17221358f, -0.08471256f, 0.04238790f, 0.04257995f, -0.08511519f, 
    -0.02037043f, -0.04812421f, -0.11977771f, -0.09507779f, -0.30320477f, -0.16540647f, -0.09805666f, 0.02507174f, 
    -0.01118861f, 0.06241352f, -0.01120279f, 0.05711261f, -0.18312122f, -0.00659527f, 0.06698868f, -0.19549997f, 
    0.10484258f, 0.28460249f, 0.33066955f, 0.02441318f, 0.08751905f, 0.14004169f, -0.06751237f, -0.12102494f, 
    -0.13043915f, 0.02168992f, 0.13821368f, 0.14292510f, 0.02649361f, -0.04006192f, -0.29536295f, 0.12451674f, 
    -0.03543648f, -0.11292750f, 0.05043567f, -0.10303440f, -0.05046642f, 0.13606064f, -0.05167012f, 0.01092196f, 
    0.19196804f, 0.23710215f, -0.07922477f, 0.22904526f, -0.00810880f, -0.02729359f, -0.01615547f, -0.05757374f, 
    0.08612547f, 0.00342145f, -0.10501286f, -0.06808175f, -0.09924752f, -0.05084279f, 0.07434335f, 0.08670666f, 
    0.06251366f, 0.02195093f, -0.19601639f, 0.10707070f, -0.12772368f, -0.11898356f, -0.02625676f, -0.01003169f, 
    -0.02599039f, 0.05368330f, -0.06872659f, -0.02700704f, 0.01392500f, 0.04834839f, -0.04479748f, -0.02127469f, 
    0.02901044f, -0.05285361f, 0.03859549f, 0.02567809f, -0.06939883f, 0.00413084f, -0.00518600f, 0.03362979f, 
    -0.08894692f, -0.07946490f, -0.07715920f, -0.00820437f, -0.05515250f, 0.01292741f, 0.01832354f, -0.00621021f, 
    0.01516217f, -0.04334223f, 0.01689471f, 0.03021001f, -0.06192941f, -0.00448602f, -0.04016376f, -0.04556522f, 
    -0.01582949f, 0.05283392f, -0.03366116f, -0.10050795f, 0.03969037f, -0.08084429f, 0.01267102f, -0.07001150f, 
    -0.03272364f, -0.00420696f, 0.04987966f, -0.05550569f, -0.04737971f, -0.07527177f, -0.04769696f, 0.01311215f, 
    -0.00909629f, 0.03077843f, -0.07664354f, -0.05117595f, -0.05247725f, -0.03554464f, -0.08170915f, -0.06058699f, 
    -0.03858266f, -0.08165284f, -0.08253992f, 0.03536563f, 0.04096476f, -0.04896245f, 0.03296755f, -0.06540499f, 
    -0.06671000f, -0.07696083f, -0.01644697f, -0.06871515f, 0.01118937f, -0.07562102f, 0.03892759f, -0.06419251f, 
    -0.04099473f, -0.02887183f, 0.02100893f, -0.08933090f, -0.06157510f, 0.05798519f, -0.01015972f, -0.04728424f, 
    -0.01130454f, -0.08560132f, -0.00151154f, -0.05106121f, 0.04666148f, -0.07449172f, -0.07060147f, -0.03752155f, 
    -0.07522112f, 0.02430553f, 0.01005699f, 0.02529455f, -0.08031826f, -0.03823679f, -0.02728574f, 0.04132716f, 
    -0.06480801f, 0.03441320f, -0.05812272f, 0.01315433f, 0.01012679f, -0.10038348f, -0.07409715f, -0.09979212f, 
    0.04445805f, -0.09210405f, 0.01934312f, -0.00563424f, 0.02379334f, -0.00723883f, -0.02571506f, 0.02797844f, 
    0.03407083f, 0.05284011f, 0.02817200f, -0.02738664f, -0.00085224f, -0.02391001f, 0.04129487f, 0.02615874f, 
    -0.06807825f, 0.03698708f, -0.04434610f, -0.02969232f, -0.07462151f, 0.03879812f, 0.03312486f, -0.02964509f, 
    -0.06955413f, -0.07754539f, -0.00435264f, -0.02319433f, 0.02324399f, -0.07022646f, 0.00509848f, -0.04365963f, 
    -0.04427805f, -0.01201147f, 0.02555645f, -0.01356130f, -0.00990433f, -0.00862095f, -0.05551852f, 0.03325234f, 
    -0.07113361f, 0.01203516f, 0.04159252f, -0.03934017f, 0.02642406f, -0.07849005f, -0.04293652f, -0.07090124f, 
    -0.09091869f, 0.00180646f, 0.02610100f, -0.02964835f, -0.08139403f, -0.06387008f, -0.08184952f, -0.02906306f, 
    -0.07657780f, -0.03811087f, -0.04709014f, 0.02373717f, -0.00828402f, -0.00946336f, 0.02164846f, 0.02112891f, 
    0.04367471f, -0.01972554f, -0.02770851f, -0.06551213f, -0.04008972f, -0.05557839f, -0.07948750f, -0.08262865f, 
    -0.07996529f, -0.01825405f, -0.04572165f, 0.04495133f, -0.00259647f, -0.06907545f, 0.03275052f, 0.04993876f, 
    -0.05944199f, -0.00536691f, -0.08258244f, -0.07401576f, -0.08677695f, -0.00405515f, 0.01674926f, 0.01515710f, 
    0.02866210f, 0.10811503f, 0.22041658f, -0.15951303f, 0.03919261f, 0.02635153f, 0.00639309f, -0.06791834f, 
    -0.02381971f, 0.03235873f, 0.00481432f, -0.16921076f, 0.00750945f, -0.10149904f, -0.09758034f, 0.11285648f, 
    0.20761667f, 0.00138437f, 0.04024261f, 0.02608670f, 0.15115346f, 0.14094345f, 0.18604958f, 0.16666095f, 
    0.14969708f, -0.13937375f, 0.17028357f, -0.16294655f, 0.06720766f, -0.15715221f, 0.10578768f, -0.01574606f, 
    0.22795163f, 0.08369952f, 0.14139241f, 0.16614729f, 0.08748342f, -0.01910548f, 0.06179165f, -0.00425547f, 
    0.07004504f, 0.08399215f, 0.03652910f, -0.02708341f, 0.13145410f, 0.04178431f, -0.03484430f, -0.05531214f, 
    -0.26614320f, 0.23421039f, 0.13408373f, 0.12908438f, 0.06676337f, -0.05719797f, 0.14536601f, -0.11547030f, 
    0.00061391f, 0.04767322f, 0.13882227f, 0.09304501f, -0.09012925f, -0.08543023f, -0.11011604f, -0.08640832f, 
    0.20249802f, 0.01424682f, 0.22668855f, -0.07072904f, 0.10983829f, -0.04240240f, -0.00742773f, 0.16064009f, 
    -0.21802926f, -0.22008283f, -0.11709422f, 0.02662825f, 0.07482515f, 0.04846877f, 0.02468235f, 0.06211909f, 
    -0.03670569f, 0.09018406f, 0.03692787f, 0.02148977f, 0.04707181f, 0.11294045f, 0.31108284f, 0.10160737f, 
    0.03972330f, 0.11673725f, 0.04416765f, -0.02972443f, 0.00455880f, -0.17026621f, 0.00031791f, 0.02161914f, 
    -0.27013549f, 0.11068851f, -0.09233860f, 0.03045305f, 0.03902180f, -0.11120550f, -0.01295758f, 0.01757289f, 
    -0.03092624f, 0.09916990f, 0.08004840f, -0.10422245f, -0.03891365f, 0.08019318f, 0.08030146f, 0.05542257f, 
    0.06848443f, 0.00044697f, -0.11517020f, -0.17703743f, -0.07791241f, 0.01337478f, 0.04009831f, -0.17053398f, 
    0.16319831f, -0.20349902f, -0.12677698f, 0.18493065f, 0.15413550f, 0.17443648f, 0.00782743f, 0.00355780f, 
    -0.08283254f, -0.06075552f, -0.02177591f, 0.07741529f, 0.09405269f, 0.05916704f, 0.09825613f, -0.11285265f, 
    0.03653713f, 0.05041053f, -0.04014473f, -0.12212203f, 0.14949012f, -0.16798420f, 0.05196648f, 0.15576793f, 
    -0.05428300f, -0.34169096f, -0.32716402f, 0.00221826f, -0.01582797f, -0.00843286f, 0.10310312f, 0.07249837f, 
    0.03707694f, 0.04885203f, 0.16441584f, -0.07833064f, -0.14238402f, 0.05353286f, 0.23440519f, -0.35084063f, 
    -0.03340931f, 0.07638709f, -0.02882300f, -0.05375707f, 0.10545473f, -0.10994034f, -0.06385419f, -0.12407306f, 
    -0.20488606f, -0.02994921f, 0.16447134f, -0.31973839f, 0.06660748f, 0.08131593f, 0.17997725f, 0.13488613f, 
    0.06216125f, 0.05453613f, 0.14393258f, 0.04067716f, -0.15912792f, -0.07058530f, -0.01851016f, -0.02201909f, 
    0.01994948f, -0.02592025f, 0.23455818f, -0.01948071f, 0.21485300f, 0.06213535f, 0.16914995f, -0.02846617f, 
    -0.04963965f, -0.00700035f, -0.02529728f, 0.01379480f, -0.01466551f, 0.00169902f, -0.06126069f, -0.02581248f, 
    -0.05742469f, -0.03183125f, -0.02352471f, -0.06098629f, 0.06365984f, -0.07027345f, -0.03740434f, -0.06641163f, 
    -0.00585858f, -0.03636268f, 0.03273233f, 0.00318054f, 0.03383944f, 0.00920750f, 0.01033546f, 0.02035755f, 
    0.03506294f, 0.03583265f, -0.00401675f, 0.01148818f, 0.06246436f, -0.00974438f, 0.04269386f, 0.00143008f, 
    0.03965783f, -0.00376451f, -0.01459200f, -0.02484755f, 0.03753329f, -0.03652776f, -0.06612750f, 0.02583381f, 
    -0.00581714f, -0.05921602f, -0.06332609f, 0.05910365f, 0.02427043f, -0.05301782f, -0.02701141f, -0.07090827f, 
    -0.03853398f, -0.00519577f, -0.01808897f, -0.00645470f, 0.00258374f, 0.00258417f, 0.04339090f, 0.03991479f, 
    -0.03479345f, 0.02864701f, -0.02090662f, -0.00503069f, 0.01317730f, 0.02399224f, -0.06255735f, 0.05997153f, 
    -0.06602333f, 0.04233505f, -0.05606430f, 0.01961869f, 0.04518524f, -0.01349486f, -0.02647724f, 0.06015066f, 
    0.05743105f, -0.02400783f, 0.04889126f, -0.05178593f, -0.06079778f, -0.03646656f, -0.05779420f, 0.05482520f, 
    0.05732832f, -0.05613118f, 0.01996013f, -0.05971652f, 0.01218915f, 0.05669204f, 0.03545405f, -0.02717786f, 
    -0.05475473f, 0.01048472f, -0.00924833f, 0.01638380f, -0.07270025f, -0.05293920f, -0.02825591f, 0.05099149f, 
    -0.04596308f, -0.00262138f, -0.03971352f, -0.06018818f, -0.06984746f, -0.03734247f, -0.00415944f, -0.06025546f, 
    -0.07163827f, -0.07250851f, -0.03441471f, -0.05745662f, -0.05028854f, 0.05862746f, -0.06018716f, -0.07786193f, 
    -0.05222132f, 0.04455450f, -0.06254303f, 0.04753249f, 0.03309815f, -0.00523492f, -0.01521001f, 0.01070706f, 
    0.01411857f, -0.06374103f, 0.04722710f, 0.01009026f, -0.01476827f, 0.04151117f, 0.04889273f, -0.03155141f, 
    -0.00246130f, -0.05827421f, -0.04447648f, -0.00028494f, 0.02784287f, -0.02393490f, 0.01795825f, -0.04781783f, 
    -0.01622687f, -0.04906786f, -0.01511810f, 0.03572999f, 0.06237498f, -0.02931520f, 0.04724539f, -0.01895272f, 
    0.04976741f, -0.02687660f, 0.00796505f, 0.05072841f, -0.04559875f, -0.03442037f, 0.03822971f, -0.06467324f, 
    -0.05801052f, 0.00440439f, -0.04159148f, -0.03232432f, 0.00931921f, -0.04106536f, 0.00734323f, 0.03536272f, 
    0.06663235f, -0.03577581f, 0.00429568f, 0.02028137f, -0.03528553f, 0.00418018f, 0.01877785f, -0.06367261f, 
    -0.03378230f, -0.07550574f, -0.02011470f, -0.04145388f, -0.04869449f, -0.07127030f, 0.06462105f, 0.00875199f, 
    0.01152833f, 0.01112111f, -0.06061383f, -0.06054234f, -0.02549802f, -0.07104076f, 0.04026097f, -0.03238481f, 
    0.01838974f, -0.07320578f, -0.02823472f, 0.04256086f, -0.06097317f, -0.04957154f, -0.03873977f, -0.07218006f, 
    0.30278331f, -0.09619824f, -0.30819982f, -0.09386013f, 0.01582225f, -0.08456883f, 0.10653248f, -0.04989779f, 
    -0.03479712f, 0.03587613f, -0.08859005f, 0.07929192f, 0.17069414f, 0.00557275f, 0.29725328f, 0.11493105f, 
    0.01875340f, -0.01938019f, 0.06579860f, 0.10796206f, -0.01905079f, -0.05512461f, -0.03995780f, 0.02158712f, 
    0.01225837f, -0.65660846f, -0.42864984f, -0.13432638f, -0.15373968f, 0.01822871f, -0.08849303f, -0.09239888f, 
    -0.09153212f, -0.08433319f, 0.02666120f, -0.05696752f, -0.03618932f, 0.02781773f, 0.15020993f, 0.02068605f, 
    0.11883579f, 0.03369645f, -0.04585947f, -0.01057625f, -0.10897551f, -0.10573333f, 0.02079044f, -0.05480750f, 
    0.24321136f, 0.18234235f, 0.27276471f, 0.22921625f, 0.01504170f, 0.04726444f, -0.03720335f, -0.07603612f, 
    -0.04753762f, -0.08871175f, 0.00412869f, -0.06101775f, -0.03914960f, -0.31056941f, -0.13928120f, -0.01658512f, 
    0.08295137f, 0.07053907f, -0.15827653f, 0.29754230f, -0.08891800f, 0.01583311f, 0.04106697f, -0.07921442f, 
    0.08899508f, 0.01659396f, -0.07057014f, -0.00907490f, -0.10399970f, 0.20562215f, 0.28765509f, 0.16723594f, 
    0.03624658f, 0.00904423f, 0.04560623f, -0.06182276f, 0.29815170f, 0.24599318f, 0.21973680f, 0.24348059f, 
    -0.05251848f, -0.07069153f, -0.05893236f, 0.09878340f, -0.03472045f, 0.02362082f, 0.11802441f, -0.05077900f, 
    0.00527534f, -0.16034637f, -0.10985634f, 0.29487798f, 0.02444962f, 0.00084438f, -0.09067990f, 0.09690480f, 
    -0.02862607f, 0.06007601f, 0.09645666f, 0.14285952f, 0.18168628f, 0.21729702f, 0.26549402f, 0.22353218f, 
    -0.04717880f, -0.05599444f, -0.17073822f, 0.02378073f, -0.03945185f, -0.09473666f, -0.03166072f, 0.03312773f, 
    0.30049905f, 0.10126062f, 0.29824421f, 0.00791447f, -0.09063101f, 0.02597210f, -0.01466378f, -0.06924052f, 
    -0.08534566f, 0.10474405f, 0.03194442f, -0.14812635f, 0.21846621f, 0.21628074f, 0.06629279f, 0.08223435f, 
    0.01951711f, 0.04496235f, -0.02970790f, -0.00441613f, -0.06052892f, -0.04459695f, -0.04016106f, -0.04282068f, 
    -0.34765199f, -0.48385912f, -0.27248755f, -0.18253057f, 0.01823402f, -0.08246555f, -0.02178233f, -0.04057395f, 
    0.11216695f, -0.05725865f, -0.06504451f, 0.10350034f, 0.07342381f, 0.18756020f, 0.05763797f, 0.00364294f, 
    -0.09130098f, -0.01179223f, -0.10134239f, 0.10815500f, -0.08327081f, 0.19000664f, 0.03075421f, 0.10994508f, 
    -0.03556467f, 0.26020569f, -0.24031973f, -0.30762666f, 0.14467393f, 0.03035332f, 0.05335960f, -0.14781517f, 
    -0.00033527f, -0.03334105f, -0.05161282f, 0.07042378f, -0.01189821f, -0.03507264f, -0.10500366f, 0.01129508f, 
    0.07314269f, 0.33755285f, -0.14998730f, -0.08533578f, -0.01461446f, 0.05430903f, -0.08449937f, -0.12134875f, 
    0.19190951f, -0.00134462f, 0.25675145f, 0.00679734f, -0.12434604f, -0.14452764f, -0.00677961f, 0.03133187f, 
    0.31704608f, 0.18556479f, 0.10871188f, 0.19118908f, -0.06796822f, 0.08243105f, -0.05346189f, 0.02530751f, 
    -0.03362724f, 0.01535720f, -0.03156606f, -0.03068055f, -0.00966604f, 0.06097675f, 0.08929310f, 0.25641191f, 
    -0.07938619f, 0.13594928f, 0.26078087f, -0.15645970f, -0.08126305f, -0.15732166f, -0.15061137f, 0.06930608f, 
    0.06766635f, 0.11881554f, -0.08405004f, -0.09867074f, -0.13016392f, -0.39905486f, -0.36445498f, -0.38788006f, 
    0.11931711f, 0.09726339f, 0.06257012f, 0.18692872f, -0.12873048f, -0.09941401f, -0.27821353f, -0.31858119f, 
    -0.06764218f, 0.18151177f, -0.39900655f, 0.15822028f, 0.11658879f, 0.09402601f, -0.01021178f, -0.11386223f, 
    -0.23088615f, -0.11462415f, -0.29529807f, -0.11705034f, -0.24222188f, -0.07682087f, 0.03051123f, -0.02404740f, 
    0.01515716f, 0.04650819f, -0.01454372f, -0.01012176f, 0.04572483f, -0.10148280f, -0.06842396f, 0.07710321f, 
    0.09069887f, 0.07482427f, 0.11074094f, -0.11437465f, -0.01126342f, -0.08265866f, -0.09996483f, -0.03089446f, 
    0.04630738f, -0.10145087f, -0.05318385f, -0.16479710f, -0.12555072f, 0.20914058f, -0.27690217f, -0.22861722f, 
    0.26720315f, 0.10915224f, 0.07433188f, -0.14113756f, -0.18184157f, -0.10197870f, 0.07409575f, 0.08594362f, 
    0.03639177f, 0.36821941f, -0.07983970f, 0.31438506f, 0.06013452f, 0.04883522f, 0.15805015f, -0.00667377f, 
    0.22957525f, -0.03762579f, 0.25773156f, 0.05250401f, -0.09141817f, -0.30667019f, -0.21097282f, -0.16800901f, 
    -0.08559185f, -0.13027877f, 0.19139853f, 0.17865635f, 0.24887688f, -0.06040029f, 0.08950575f, 0.16893724f, 
    -0.11772604f, -0.02958802f, 0.15783708f, -0.16471890f, -0.00960747f, 0.05731180f, 0.15714556f, 0.33856934f, 
    -0.03871091f, -0.07580367f, -0.04860347f, 0.31866536f, 0.07693653f, -0.22160643f, 0.05128101f, 0.01360665f, 
    0.08346374f, -0.29761735f, 0.10603120f, 0.12870148f, -0.15894622f, -0.03181720f, 0.09888497f, 0.02576925f, 
    0.06423622f, 0.12209085f, -0.02693293f, 0.09171655f, -0.18909691f, -0.15890610f, 0.06404372f, 0.17766511f, 
    0.10434056f, -0.04270282f, 0.11276523f, 0.19655204f, 0.16934834f, 0.18474638f, 0.09799756f, 0.16001433f, 
    0.16620122f, 0.02818363f, 0.09438628f, 0.12003812f, -0.08086023f, -0.17337464f, 0.05602688f, -0.12126137f, 
    0.03483250f, -0.39536852f, 0.31211475f, 0.07156818f, 0.04124338f, 0.08560602f, -0.10441886f, 0.00643046f, 
    0.04968923f, 0.01714255f, 0.07808521f, -0.07465743f, -0.01030239f, 0.08530264f, -0.09172826f, 0.00564619f, 
    0.07157365f, -0.11496675f, 0.06813669f, -0.02890603f, -0.40086952f, -0.42432845f, -0.14297746f, -0.49854523f, 
    0.16342464f, -0.21902801f, -0.31675729f, 0.05715628f, -0.05164238f, -0.18610403f, 0.02956320f, -0.08723492f, 
    -0.12819719f, 0.13988012f, 0.00251301f, -0.05841866f, -0.03955915f, -0.08345924f, 0.36725205f, 0.06060169f, 
    0.08324362f, 0.02045446f, 0.01398262f, -0.03380397f, 0.02337330f, -0.00013124f, 0.14247800f, -0.11050831f, 
    0.24669711f, 0.18892357f, -0.05299979f, 0.02661753f, 0.03121172f, 0.12939531f, 0.11218258f, -0.18865219f, 
    0.04407913f, 0.09082412f, 0.01291746f, -0.09003071f, -0.02595321f, -0.18286993f, 0.23004435f, 0.06718448f, 
    0.02739671f, -0.15764746f, 0.05002318f, -0.12839492f, 0.08424317f, 0.18058683f, -0.03168992f, 0.04123288f, 
    -0.24427547f, -0.32705465f, -0.12603857f, -0.03650576f, 0.15901114f, -0.15558472f, -0.12111272f, 0.02112479f, 
    -0.02798392f, -0.12861145f, 0.09030493f, -0.06146311f, 0.35213044f, 0.26855436f, 0.24785532f, -0.07010008f, 
    0.08649287f, 0.28317612f, 0.11205164f, 0.06455167f, -0.00482075f, -0.10661546f, 0.02946197f, -0.06800114f, 
    0.09734796f, 0.34897625f, 0.17257540f, 0.36717743f, -0.06315416f, 0.15326053f, -0.00378419f, -0.10532760f, 
    -0.09774712f, -0.07192601f, 0.02786191f, 0.03833401f, 0.07865125f, -0.14474583f, -0.11406905f, -0.00100852f, 
    -0.14200014f, -0.33201459f, -0.19046456f, -0.14936775f, -0.10892781f, 0.00141836f, 0.00924387f, 0.07409851f, 
    0.12435328f, -0.08021241f, -0.04105463f, 0.11672459f, -0.03140011f, 0.00891364f, -0.07047484f, -0.03044312f, 
    -0.08067012f, -0.11956638f, 0.01236334f, 0.22089462f, -0.12575564f, -0.40120366f, -0.09661385f, -0.05019123f, 
    0.03842605f, -0.01925210f, -0.15535319f, 0.07853097f, 0.08667193f, 0.03279017f, 0.00157411f, 0.00492768f, 
    0.02351437f, -0.32639486f, -0.17993706f, 0.21614522f, 0.00781971f, -0.03390673f, 0.02624232f, -0.41736105f, 
    -0.01740475f, 0.11211611f, -0.09125177f, 0.07707874f, -0.13789266f, -0.23069902f, -0.33221048f, -0.34440461f, 
    0.10754402f, -0.01875980f, -0.02591670f, -0.08793932f, 0.05695615f, 0.00432816f, 0.13750766f, 0.02727158f, 
    0.30174166f, 0.30075043f, 0.43209946f, 0.12295715f, 0.04953896f, 0.17406383f, 0.06850146f, -0.15090425f, 
    0.03977609f, 0.06936704f, 0.10809992f, -0.02798504f, -0.00825118f, -0.00038858f, 0.13556398f, -0.56975645f, 
    -0.14906111f, -0.06572518f, -0.03740411f, -0.19469523f, -0.12983672f, 0.11312306f, 0.10354558f, -0.03216049f, 
    0.09979983f, 0.12068120f, 0.32194117f, -0.04025638f, 0.11826162f, -0.03629379f, 0.12129043f, 0.24225730f, 
    0.02728756f, -0.03473331f, -0.07110546f, -0.04243661f, 0.06864518f, -0.01388386f, -0.00758883f, 0.00685056f, 
    0.21409820f, 0.01439377f, 0.06354102f, 0.08424115f, 0.09312772f, 0.20078646f, -0.08475593f, 0.03587877f, 
    -0.13077492f, 0.09672026f, 0.03904421f, 0.12020848f, -0.10833238f, 0.00976806f, 0.04651201f, -0.05262861f, 
    -0.01332760f, 0.18655536f, 0.18109204f, 0.13918495f, 0.01158458f, -0.06373125f, 0.05517711f, -0.21669157f, 
    -0.06222542f, -0.08658006f, -0.07061715f, -0.18285045f, -0.00354040f, -0.01013407f, 0.11168711f, 0.05098485f, 
    0.32230997f, 0.37696674f, 0.09055904f, 0.02464481f, 0.01361447f, -0.02756437f, 0.04794518f, -0.14253223f, 
    -0.22984299f, 0.05502667f, -0.04328945f, -0.05246907f, 0.02373107f, -0.02424513f, -0.05616255f, -0.00557461f, 
    0.03640585f, -0.14090703f, 0.09772017f, 0.11167093f, -0.08202787f, 0.17277393f, -0.21794505f, 0.02582552f, 
    0.12734424f, -0.16422696f, 0.05768074f, -0.16819856f, -0.10186399f, 0.00877182f, -0.09888843f, -0.09573723f, 
    -0.01491893f, -0.09428358f, 0.06453352f, -0.06958466f, 0.32170832f, 0.02286180f, 0.05824108f, -0.16436192f, 
    -0.06327872f, 0.11295336f, -0.00026018f, 0.02793458f, -0.10390254f, -0.15536927f, 0.05632016f, -0.01345303f, 
    0.01803643f, 0.06341541f, -0.13809042f, 0.04871327f, 0.03844775f, 0.11691593f, 0.01485627f, -0.00188511f, 
    -0.08498086f, -0.07980851f, -0.02444462f, 0.02149314f, 0.23293029f, -0.18368179f, 0.06106021f, -0.04172283f, 
    0.09103558f, -0.14497884f, -0.00739146f, -0.17856371f, -0.18346779f, 0.04453857f, -0.08755356f, 0.08189434f, 
    0.03170430f, -0.33847147f, -0.19590668f, -0.32469627f, -0.01892925f, 0.02984428f, -0.12360790f, 0.24475782f, 
    0.03459019f, -0.16908546f, -0.20991208f, 0.12909132f, 0.03417783f, -0.16719821f, -0.00263187f, -0.01397005f, 
    0.03604433f, 0.05360252f, -0.15333813f, 0.06918026f, -0.00895669f, -0.03635325f, -0.07985222f, -0.06952509f, 
    0.11895563f, 0.14244160f, 0.07825240f, -0.07159981f, -0.01027608f, -0.08885829f, 0.10769238f, -0.13900539f, 
    0.01276185f, -0.08141341f, -0.16027473f, -0.08674707f, 0.04018229f, 0.06605326f, 0.03037805f, 0.15497521f, 
    0.00906875f, 0.03448165f, 0.01780459f, -0.00979494f, -0.04788136f, 0.06156275f, 0.24044669f, -0.19745652f, 
    0.22160605f, 0.19041102f, 0.30263922f, -0.03432085f, 0.05444974f, 0.18782808f, -0.32195222f, -0.08320663f, 
    0.01875977f, 0.12264522f, 0.26708406f, 0.10544571f, 0.18937597f, -0.21885522f, -0.12433782f, -0.05284040f, 
    0.12775207f, 0.00910417f, 0.07364025f, 0.00131598f, -0.19818231f, 0.14865091f, -0.15533377f, 0.05549781f, 
    0.16037428f, 0.04458168f, -0.23638456f, 0.03875574f, 0.19511044f, 0.02580286f, 0.04873751f, 0.08432677f, 
    0.13081357f, -0.05173417f, 0.07570150f, 0.01088677f, 0.04767408f, -0.05869112f, -0.05535225f, -0.02603351f, 
    0.00838147f, -0.14630313f, 0.12222949f, 0.07274379f, -0.07469705f, -0.08827220f, 0.01466985f, -0.09045903f, 
    -0.35646254f, 0.30210596f, -0.12575588f, 0.05143671f, 0.01710605f, -0.05583862f, -0.00582760f, -0.02865727f, 
    -0.09290145f, 0.04405496f, 0.02222339f, 0.02084661f, -0.24805512f, -0.09712919f, -0.03869706f, 0.00460184f, 
    0.11234684f, 0.06325058f, 0.20319869f, -0.13758300f, -0.00419901f, 0.09632386f, 0.14317942f, -0.02462710f, 
    0.36137864f, 0.30569315f, 0.16803767f, 0.13938692f, -0.00479977f, -0.08100105f, -0.01047163f, 0.03581892f, 
    0.05584295f, 0.18260522f, 0.06377515f, 0.01965068f, 0.13963471f, 0.09313133f, -0.08137496f, -0.10194450f, 
    -0.00157050f, -0.13783115f, -0.07676481f, 0.04930819f, -0.15411212f, 0.05732216f, -0.16409612f, -0.16233088f, 
    0.28538680f, -0.21046115f, 0.22765316f, -0.14722434f, -0.06498509f, 0.05504661f, 0.01227592f, -0.11624440f, 
    0.01143191f, -0.02426418f, 0.06200736f, -0.14063483f, 0.12355031f, 0.05976690f, -0.02483314f, 0.16697875f, 
    0.01768057f, 0.05508947f, 0.04467918f, 0.02679086f, 0.03623813f, 0.02380509f, 0.02527512f, 0.08373547f, 
    -0.26650971f, -0.04632445f, 0.08554433f, 0.23852479f, -0.17670666f, -0.08950451f, -0.17453383f, 0.00483749f, 
    -0.14325733f, 0.04119119f, -0.06200866f, -0.00975263f, 0.37079599f, 0.16205855f, 0.21235338f, 0.02638679f, 
    -0.06274769f, 0.00409936f, -0.03087733f, -0.05657518f, 0.01310093f, 0.05136113f, -0.06611376f, 0.18318988f, 
    0.06112121f, -0.35359240f, 0.27779225f, -0.13975689f, 0.00123124f, -0.02149018f, 0.06753744f, 0.13156782f, 
    0.03212018f, -0.04969153f, 0.08656391f, 0.09256934f, 0.24093288f, 0.03416233f, -0.01232826f, 0.03894358f, 
    -0.11434045f, -0.01626565f, -0.03149959f, 0.04460998f, -0.16272283f, 0.01861687f, -0.12177855f, -0.09953825f, 
    0.24256378f, 0.13443714f, -0.00884449f, 0.03591549f, -0.05838020f, -0.12487279f, 0.07095094f, 0.00960952f, 
    0.01616539f, -0.03421586f, -0.02749808f, -0.01471645f, 0.07962864f, 0.14506243f, 0.19795381f, 0.11047141f, 
    0.02478775f, -0.05240748f, -0.12316073f, -0.04035089f, -0.04809452f, -0.01860996f, 0.20724122f, -0.16815230f, 
    0.06529666f, 0.17557721f, 0.14383654f, -0.03153567f, -0.03670390f, -0.02975773f, 0.02670230f, 0.02402785f, 
    -0.03324072f, 0.09691425f, 0.11220584f, 0.01969765f, 0.07986459f, -0.27839649f, 0.07793077f, 0.07456500f, 
    0.10832532f, -0.10142562f, -0.02847739f, -0.00633237f, -0.09235633f, 0.10133349f, -0.06393509f, 0.03155151f, 
    -0.17562678f, -0.02419385f, -0.39565533f, 0.22969900f, -0.01101718f, 0.02416779f, -0.10253201f, -0.02543196f, 
    0.01766398f, 0.00683447f, -0.00597993f, 0.11106517f, 0.09892622f, 0.06666478f, 0.03547138f, -0.08289685f, 
    0.13386036f, -0.03380854f, 0.10202528f, 0.08481806f, -0.00726550f, 0.03279219f, 0.03774083f, -0.06865001f, 
    -0.14950159f, 0.15517117f, 0.13271083f, -0.15471931f, -0.02794010f, -0.08397382f, -0.20483914f, -0.14262021f, 
    0.01437722f, 0.01748308f, -0.08208010f, -0.32019708f, -0.04021699f, -0.06792295f, -0.19816788f, 0.07944196f, 
    0.10138305f, 0.08513548f, 0.09038110f, -0.02593382f, 0.08592447f, 0.17283666f, 0.00187368f, 0.07655082f, 
    0.21041606f, 0.21126853f, 0.20855233f, 0.08650103f, -0.03335318f, -0.14689122f, -0.04428321f, 0.05659305f, 
    0.06793413f, 0.12788913f, 0.06763245f, 0.29755887f, -0.03409957f, -0.05275886f, 0.01896406f, -0.21400936f, 
    0.15918602f, -0.07140218f, 0.05730632f, -0.03264320f, 0.04716274f, 0.05146458f, 0.15428716f, 0.16326697f, 
    -0.36769375f, 0.20450222f, 0.03430753f, 0.02087747f, -0.17922424f, -0.12767424f, 0.17389953f, -0.15291947f, 
    -0.04224197f, 0.17332307f, 0.04235940f, -0.03780704f, -0.03445943f, -0.05443623f, -0.11700924f, 0.30306017f, 
    0.16796270f, -0.07413124f, 0.05353907f, -0.01034291f, -0.00794529f, 0.05790517f, 0.03006858f, 0.06047072f, 
    -0.30831110f, -0.30925232f, -0.05149891f, 0.22283006f, 0.00414314f, -0.08533772f, 0.07448757f, 0.17555161f, 
    -0.00551712f, 0.10523804f, 0.03552659f, 0.05691943f, -0.16084735f, 0.03138852f, 0.38961035f, 0.23944926f, 
    -0.17549688f, -0.02372614f, -0.01067310f, 0.06477172f, -0.03737481f, -0.01809701f, -0.01622325f, 0.02233569f, 
    -0.10182805f, 0.14824232f, 0.28308645f, -0.07721661f, 0.04216403f, 0.05045624f, 0.25401822f, 0.08794142f, 
    -0.02804996f, 0.13583435f, -0.00867948f, -0.04216594f, -0.07213013f, 0.04692030f, -0.03684526f, -0.22040099f, 
    -0.09382262f, -0.02219025f, 0.04093228f, -0.15768042f, -0.12209245f, 0.11615333f, -0.03454791f, -0.07596090f, 
    -0.20039678f, 0.20941614f, -0.32993579f, -0.12561455f, 0.25675678f, -0.05130449f, -0.01137634f, 0.09140399f, 
    -0.02363589f, 0.03917512f, 0.07434535f, -0.15073276f, -0.12610011f, 0.10787898f, 0.10802966f, -0.11695898f, 
    -0.00988395f, -0.01983621f, -0.12273251f, -0.12969092f, 0.05250142f, 0.05199838f, 0.14509626f, 0.05473309f, 
    0.02285364f, -0.19869116f, -0.06083073f, 0.14954315f, 0.04708345f, -0.00557325f, 0.16055955f, 0.17055121f, 
    0.12119615f, 0.09492601f, 0.06549821f, -0.10677395f, -0.37238282f, -0.20455600f, 0.20116156f, 0.19710422f, 
    0.03964272f, 0.04802768f, 0.14461340f, 0.06786077f, 0.12515086f, -0.09599576f, -0.16101599f, -0.01112792f, 
    -0.07480643f, 0.00433427f, -0.13854684f, -0.10548910f, 0.02224427f, 0.15969925f, 0.13183229f, -0.06613804f, 
    0.00715315f, 0.01170257f, 0.04104179f, 0.15637198f, -0.07121356f, 0.07360044f, 0.03920843f, 0.08667055f, 
    -0.07772964f, -0.01489496f, 0.18584701f, 0.05755012f, 0.24165246f, 0.12143069f, 0.25709474f, 0.08547790f, 
    0.00312405f, 0.05472950f, 0.29662818f, 0.22119039f, 0.04027326f, -0.05150144f, -0.09337534f, 0.15177000f, 
    0.06193602f, 0.14737178f, 0.09614673f, 0.17125112f, 0.02601979f, 0.07439705f, 0.02978767f, -0.07798683f, 
    -0.13451529f, 0.01675363f, 0.05932411f, 0.24363820f, -0.17157367f, -0.13460858f, -0.12024976f, 0.16473810f, 
    -0.18705107f, 0.37317967f, 0.22402568f, 0.05935214f, 0.01889371f, -0.01203345f, -0.03241809f, -0.05984900f, 
    0.17944799f, 0.08661389f, 0.08956382f, 0.00812788f, -0.19178320f, -0.10412046f, -0.09301963f, 0.04593612f, 
    -0.03173343f, -0.00155526f, 0.00796518f, -0.06397030f, -0.17265506f, -0.07465788f, -0.00429211f, -0.12099718f, 
    0.27623594f, -0.05029473f, -0.29433215f, -0.02180417f, 0.04001575f, 0.07834030f, 0.03734761f, 0.11860454f, 
    0.05016520f, 0.01537281f, -0.19809532f, 0.03548807f, -0.08489910f, 0.08987240f, -0.06095617f, -0.19740292f, 
    0.01172839f, 0.08806324f, -0.02840252f, 0.00378330f, 0.00880837f, 0.09662300f, -0.06015877f, 0.06341846f, 
    0.18946300f, 0.26617804f, 0.16632636f, -0.32189178f, 0.07468060f, 0.05366915f, 0.10943842f, 0.02343868f, 
    0.09031337f, 0.07779586f, -0.00165254f, 0.00929230f, -0.09759647f, -0.29947069f, -0.22548983f, -0.25156263f, 
    0.18916920f, 0.17175785f, 0.06024954f, 0.11603266f, -0.00045768f, -0.03405260f, 0.02411397f, -0.16330053f, 
    0.09222308f, 0.28543809f, 0.10794591f, -0.03903569f, 0.01401605f, 0.16716276f, 0.08470479f, -0.15141572f, 
    -0.00541677f, 0.13343717f, 0.14416578f, -0.12302338f, -0.09736168f, -0.12017237f, -0.28463891f, 0.00076161f, 
    -0.00460093f, 0.00369294f, 0.11016960f, 0.03743896f, 0.06478132f, -0.04330134f, 0.10190111f, -0.02441756f, 
    -0.25940129f, -0.13020724f, -0.02226598f, -0.02741578f, -0.09005961f, -0.03935556f, -0.01826609f, 0.16471133f, 
    -0.00598906f, -0.09300098f, -0.03425144f, 0.05271696f, 0.14841513f, -0.20007148f, -0.09643272f, -0.01655467f, 
    -0.00474498f, 0.02070021f, 0.01654815f, 0.05228532f, 0.07770402f, 0.05265367f, -0.19580883f, 0.14921142f, 
    0.10573398f, 0.30402327f, 0.10984603f, 0.02662345f, 0.03511479f, -0.12512049f, 0.15981621f, 0.07136772f, 
    0.01669458f, -0.12290619f, 0.00226398f, 0.11024681f, 0.16242512f, -0.04513123f, -0.38448018f, 0.12242634f, 
    0.04771132f, 0.29254127f, -0.00119114f, -0.21396154f, 0.00304619f, -0.03620391f, 0.01150039f, -0.07980821f, 
    -0.25711742f, -0.05480941f, 0.15518588f, 0.18209864f, 0.05368625f, 0.10521786f, 0.15486601f, 0.02172233f, 
    -0.04620787f, -0.03472748f, -0.02230972f, -0.08287514f, 0.01778675f, -0.08744653f, -0.14065051f, -0.09022364f, 
    -0.04630521f, 0.02796779f, -0.23639677f, -0.05177123f, 0.11090901f, -0.09966192f, -0.08880464f, -0.00939918f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10530049f, 0.26767197f, 0.05135269f, -0.02237298f, 0.02816414f, -0.04682825f, -0.05845337f, -0.09747186f, 
    0.23655245f, 0.02071781f, 0.11380471f, -0.08409487f, 0.23055910f, 0.03819321f, -0.02651630f, 0.05543340f, 
    0.04386781f, 0.04627012f, -0.03234803f, 0.01978282f, 0.08209944f, -0.07375736f, -0.11351757f, 0.05216662f, 
    -0.05933676f, -0.02027962f, 0.06832927f, -0.01913810f, -0.08933932f, -0.12506770f, 0.17245479f, -0.15045577f, 
    0.14820141f, -0.01330081f, -0.05093047f, -0.10441842f, -0.02944098f, 0.13585030f, 0.16177750f, -0.08163226f, 
    -0.04824717f, -0.01269530f, -0.00400889f, 0.19187343f, -0.07154315f, 0.25723621f, -0.08119205f, -0.01397261f, 
    -0.06083722f, 0.03874195f, 0.05112951f, 0.04772522f, 0.03846315f, 0.03807625f, -0.00470009f, -0.09088106f, 
    0.09334074f, 0.25544268f, -0.03491175f, 0.11823247f, -0.06441323f, 0.07912692f, -0.03619205f, 0.08638757f, 
    0.03542328f, 0.23994040f, -0.08589781f, 0.04692993f, 0.30726117f, 0.08040003f, 0.09966367f, -0.08004916f, 
    -0.01451095f, -0.03811640f, -0.05490161f, 0.00767029f, 0.05147108f, -0.06082077f, 0.10590181f, -0.09487005f, 
    -0.05910581f, 0.18348894f, -0.04134976f, -0.07503860f, -0.05970667f, -0.00795069f, 0.17062809f, 0.05355550f, 
    -0.05667445f, -0.07883276f, -0.07656640f, 0.24945794f, 0.06566517f, 0.14524253f, 0.11333178f, 0.19133320f, 
    -0.05945053f, -0.01094838f, 0.08301650f, 0.14772795f, -0.01523541f, -0.01335945f, 0.01027877f, -0.03326020f, 
    0.20470653f, 0.09184546f, -0.03164759f, 0.26988763f, 0.04886881f, 0.00497884f, 0.22069165f, 0.01824669f, 
    0.05906330f, 0.02091234f, 0.10438745f, 0.00710843f, 0.03018505f, -0.08653103f, -0.04851646f, 0.07645922f, 
    -0.00761835f, -0.12902559f, -0.02973332f, 0.14657640f, -0.04021727f, 0.06929100f, 0.08426376f, 0.01970740f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13166936f, -0.27986273f, 0.00737250f, 0.00666988f, 0.04397453f, 0.05190952f, 0.03311555f, 0.15722919f, 
    -0.39021954f, 0.13916674f, -0.44982895f, -0.22884890f, -0.56812531f, 0.18819179f, 0.05431986f, 0.16440809f, 
    -0.17967354f, -0.24639608f, -0.34585264f, 0.15892209f, -0.16505603f, 0.01740994f, 0.40695283f, -0.00906485f, 
    0.03468146f, -0.02991142f, -0.20302036f, 0.18014586f, 0.04288313f, -0.06927944f, -0.07871311f, 0.15754059f, 
    -0.25858366f, -0.14803515f, 0.11665315f, 0.06323037f, -0.05946435f, -0.15302020f, -0.53306174f, 0.14076892f, 
    0.00616040f, 0.00584326f, 0.10034198f, -0.32868996f, 0.00215715f, 0.03336498f, -0.03943898f, 0.15141046f, 
    -0.08361586f, 0.11751994f, 0.03592071f, -0.05800300f, -0.15328448f, -0.04123432f, 0.24980454f, -0.17331792f, 
    -0.36739856f, -0.15307996f, -0.20468716f, -0.55908209f, -0.04226416f, 0.12345981f, -0.06123393f, -0.27191821f, 
    -0.06436779f, 0.10967993f, 0.15526626f, 0.14929497f, 0.07364839f, -0.33920640f, -0.09954377f, 0.07295941f, 
    0.02946523f, -0.05921922f, -0.08171269f, -0.07890400f, -0.25533953f, 0.01676332f, -0.27257663f, 0.12213130f, 
    -0.08071188f, -0.11104035f, -0.02234771f, -0.04329970f, 0.01787786f, 0.00214890f, -0.02930283f, -0.00524553f, 
    -0.06223806f, -0.29853475f, -0.08572330f, -0.30151802f, 0.02464244f, -0.04893081f, -0.00453604f, -0.24907662f, 
    0.15375742f, 0.20447080f, -0.10439343f, 0.07836737f, 0.30296689f, -0.16892125f, 0.10230582f, 0.03575898f, 
    0.03796874f, -0.45338044f, -0.01863693f, -0.22464424f, 0.17205741f, 0.07982044f, -0.34179854f, -0.23689309f, 
    0.16153850f, -0.17025012f, 0.10098983f, -0.05689923f, -0.49172893f, 0.15521197f, -0.00405710f, -0.32974643f, 
    0.03767691f, 0.14816423f, 0.05585888f, 0.04852076f, 0.11461145f, -0.27276981f, -0.38666931f, 0.06430200f, 
    0.05023177f, 0.24295723f, -0.02349550f, -0.03182768f, 0.02388313f, 0.01571024f, -0.04054800f, 0.05870802f, 
    -0.23810181f, 0.03756776f, -0.16390489f, -0.59801668f, 0.19908357f, -0.12880926f, 0.05165182f, 0.11906387f, 
    0.24677339f, -0.50762320f, 0.41565230f, -0.06414365f, 0.03881098f, 0.03057206f, 0.25630471f, 0.09705199f, 
    -0.00253623f, -0.02503375f, -0.15398780f, 0.06523913f, 0.07128705f, 0.05440070f, 0.13435894f, -0.35511181f, 
    -0.00595621f, 0.22538963f, -0.10612027f, 0.01157613f, 0.01051999f, 0.23579998f, -0.24091065f, 0.11500487f, 
    -0.06564594f, -0.08321006f, -0.00299590f, 0.04969298f, -0.07033544f, 0.19590935f, 0.02113269f, -0.23947176f, 
    -0.08322048f, 0.05828575f, 0.15018137f, -0.02720115f, -0.02952382f, 0.04846617f, 0.07958120f, -0.27414820f, 
    -0.26795238f, 0.03010967f, 0.15437943f, 0.00813400f, 0.01773124f, 0.09099061f, -0.03094075f, 0.17919366f, 
    0.08422055f, 0.02310911f, -0.10367189f, 0.14653517f, -0.03703793f, 0.35729843f, 0.12564838f, -0.46455285f, 
    -0.05576083f, -0.00642985f, 0.01067033f, 0.22787870f, -0.06353474f, -0.07721423f, -0.03682996f, 0.04374553f, 
    0.02353200f, 0.12932681f, 0.00047153f, 0.07274824f, -0.02899582f, -0.01713012f, 0.09306184f, 0.01604433f, 
    -0.01483760f, -0.09574739f, -0.02887312f, 0.20774838f, -0.08362111f, -0.29898340f, -0.24069235f, -0.02328632f, 
    -0.10288997f, 0.26015964f, -0.03537833f, 0.02864734f, -0.92913270f, 0.18674946f, -0.41444331f, -0.03324400f, 
    0.08439595f, -0.08728624f, 0.03488125f, 0.26086998f, 0.14933378f, -0.02974182f, -0.32093057f, 0.05029723f, 
    -0.05686400f, -0.12251591f, 0.14763966f, 0.19522598f, -0.19169742f, 0.09170709f, 0.03071627f, -0.04315009f, 
    0.02726182f, 0.16393110f, -0.67126530f, 0.30260944f, 0.13667226f, 0.11142491f, -0.14513712f, 0.00470174f, 
    -0.06026164f, -0.02834629f, 0.14987525f, -0.09541027f, -0.18891841f, -0.03466189f, -0.02106400f, -0.33253849f, 
    0.11602025f, -0.11938064f, -0.09618680f, 0.46547562f, -0.20436797f, -0.15925214f, 0.01651044f, 0.17596714f, 
    -0.15996659f, 0.18611495f, 0.31029612f, -0.22751544f, 0.03322344f, 0.02191689f, -0.38534376f, -0.55974478f, 
    -0.00943847f, -0.00711941f, 0.13062811f, -0.39920932f, -0.01160662f, -0.35249257f, -0.14730422f, -0.19691409f, 
    0.08777624f, 0.40251791f, -0.37477928f, -0.14518631f, -0.01323966f, 0.10614906f, 0.02928697f, 0.09914099f, 
    0.06572269f, 0.01405430f, 0.02947460f, 0.05820381f, 0.04250661f, 0.23363562f, 0.06019137f, -0.02112200f, 
    0.00998893f, -0.00361450f, -0.54510719f, 0.03793989f, 0.04441897f, 0.06190923f, 0.01434905f, -0.28322217f, 
    0.07742418f, 0.03308300f, -0.21142352f, 0.07611853f, -0.02316885f, 0.17044607f, 0.01324516f, 0.16113582f, 
    0.01306336f, 0.08431679f, -0.05835318f, 0.04714631f, 0.12242188f, -0.80896848f, -0.04409184f, -0.46770152f, 
    0.03557694f, 0.05506268f, -0.01351832f, 0.17469464f, -0.04723746f, 0.05206549f, 0.07067306f, -0.27302793f, 
    -0.06860025f, 0.09965237f, -0.05342675f, -0.04533341f, -0.02141721f, -0.08408546f, 0.04987481f, 0.05669537f, 
    -0.09452929f, -0.04232574f, 0.06609164f, 0.08030652f, 0.03976968f, -0.05984243f, -0.06202631f, 0.10424120f, 
    -0.26504692f, -0.49810654f, 0.07502465f, 0.22846569f, 0.03259952f, -0.17224953f, 0.21864265f, -0.07334755f, 
    0.21492107f, 0.00355572f, 0.05434784f, -0.27778625f, 0.03802981f, 0.06882901f, 0.14622737f, 0.02640637f, 
    -0.02546050f, 0.12256275f, 0.21665052f, -0.22866474f, 0.36168033f, 0.04933053f, -0.03852418f, -0.07065563f, 
    -0.01520184f, -0.31766677f, -0.13350911f, 0.10648618f, 0.05108424f, -0.08484980f, -0.03050981f, 0.14710626f, 
    -0.08832892f, -0.13214123f, 0.21270616f, -0.05377167f, -0.13288677f, 0.04299290f, -0.11112228f, 0.26808396f, 
    -0.12866470f, -0.00543391f, -0.07845839f, 0.28170606f, -0.59800082f, -0.20127062f, 0.05619572f, 0.12277251f, 
    0.06451140f, 0.30644435f, 0.14969419f, -0.47655940f, -0.22264375f, -0.00124796f, 0.07552707f, 0.09405655f, 
    -0.00136402f, 0.00572344f, 0.19532137f, -0.02148459f, 0.01948354f, 0.10734427f, -0.22373666f, 0.20489684f, 
    -0.09399233f, 0.17965207f, 0.17771497f, -0.17416504f, -0.02610249f, -0.02211786f, 0.20741984f, 0.13782001f, 
    0.03194406f, -0.06478022f, 0.08618297f, -0.23593098f, -0.05168758f, -0.24651738f, 0.01833247f, -0.11235391f, 
    -0.06309976f, 0.12882508f, -0.19376239f, 0.04818694f, -0.38006002f, -0.04760840f, 0.00898075f, 0.21461824f, 
    -0.00191994f, -0.21025467f, 0.08683845f, 0.18874648f, 0.03492412f, 0.11054073f, -0.04258879f, -0.16065830f, 
    0.05988840f, -0.20080730f, 0.08354367f, 0.03312041f, -0.46662387f, 0.10430196f, -0.42530218f, -0.00110358f, 
    -0.05013353f, 0.06622515f, 0.18260880f, 0.25872967f, -0.15657753f, 0.06715342f, 0.44522893f, 0.12418906f, 
    0.06620891f, -0.30051759f, 0.01852182f, 0.01006586f, -0.06301529f, -0.07000447f, -0.21497272f, -0.03130865f, 
    -0.00612773f, 0.08164850f, -0.03632283f, -0.06907904f, 0.03920472f, -0.25226092f, 0.20056713f, -0.23062325f, 
    0.14610328f, -0.14350593f, -0.27963290f, -0.25313744f, 0.07008978f, -0.35227045f, 0.06658953f, -0.03983806f, 
    0.02854626f, -0.21195082f, 0.00313948f, -0.54063159f, -0.19253226f, 0.00982501f, -0.04202960f, -0.04162028f, 
    0.13464151f, 0.10902859f, -0.47503045f, 0.18192236f, 0.20912375f, 0.03193418f, 0.01680144f, -0.01351967f, 
    -0.07447577f, 0.04122889f, -0.14732334f, 0.09624014f, 0.05964004f, 0.02065015f, 0.20219903f, -0.07498372f, 
    -0.23303993f, -0.22741599f, 0.00813451f, -0.00805358f, 0.12530304f, -0.01967619f, 0.13271207f, -0.10312034f, 
    0.06571724f, -0.10045969f, 0.18332350f, 0.18799338f, 0.17558761f, 0.00010470f, -0.07488190f, -0.06714566f, 
    0.07462136f, -0.17156671f, -0.06564493f, 0.17496194f, 0.02617718f, -0.10656756f, -0.02750809f, 0.05849446f, 
    0.04184672f, 0.05039232f, 0.02689860f, 0.13331595f, 0.18742180f, -0.13272415f, -0.26158965f, 0.17153929f, 
    -0.01550521f, 0.03625947f, -0.03570313f, 0.13857765f, -0.04076191f, -0.01383148f, -0.55167592f, -0.01842382f, 
    -0.06686160f, -0.03479942f, 0.07193307f, -0.22179298f, -0.08336780f, -0.22225782f, -0.00251278f, -0.23575361f, 
    0.06627280f, -0.20055619f, 0.11930748f, -0.06428150f, 0.19015484f, -0.07722322f, -0.13378003f, 0.19141939f, 
    0.11388438f, -0.08935869f, -0.23819743f, -0.00089950f, -0.04046658f, -0.16499542f, -0.02739310f, 0.01597763f, 
    0.05905074f, -0.18394558f, -0.01285772f, 0.13707426f, -0.36137375f, -0.38820279f, 0.02779965f, 0.22116959f, 
    -0.02225413f, 0.03453979f, -0.14706425f, 0.01270806f, -0.09698614f, 0.03170602f, -0.73075360f, -0.07962362f, 
    -0.07448570f, -0.06863777f, 0.05670335f, -0.02966917f, 0.03942563f, -0.06705170f, -0.04383164f, -0.07246783f, 
    -0.04929262f, -0.04391073f, -0.05212969f, -0.35100013f, 0.00736851f, -0.04265184f, 0.03265794f, -0.02235495f, 
    0.03028850f, 0.05953499f, -0.12166397f, -0.12115221f, 0.16490997f, -0.34584424f, 0.09529503f, -0.05992589f, 
    0.06555456f, 0.11836152f, -0.00921008f, 0.18262504f, -0.14570349f, -0.07423184f, 0.03378130f, 0.09428549f, 
    0.15963879f, 0.06653274f, -0.10872079f, -0.29374662f, 0.02221777f, 0.01768976f, -0.06280387f, -0.17865862f, 
    -0.02860357f, 0.06364148f, 0.36294088f, 0.01608925f, -0.10427669f, -0.13892569f, -0.16408862f, 0.10664394f, 
    -0.00623283f, 0.20232122f, -0.36821300f, 0.00665833f, 0.13483992f, -0.09016235f, -0.00460557f, -0.21551704f, 
    0.22258048f, 0.06878427f, -0.06600996f, -0.46982932f, 0.02197324f, 0.19130133f, 0.00471892f, -0.34218946f, 
    0.10161471f, 0.07280497f, -0.43116680f, 0.09308986f, 0.11408149f, 0.01164557f, -0.36498341f, 0.17154871f, 
    -0.08554676f, -0.05825882f, 0.05480509f, 0.04160476f, -0.05188728f, -0.09875745f, -0.06094855f, -0.06968456f, 
    -0.00635880f, -0.26642397f, 0.14233613f, 0.01107101f, 0.07258496f, -0.01488569f, -0.12467066f, -0.06579748f, 
    -0.00854487f, -0.06818999f, -0.09597282f, 0.05494424f, 0.00734407f, 0.18106332f, -0.04162251f, -0.17364761f, 
    0.06998589f, 0.00264103f, 0.23979717f, 0.01495116f, 0.09324985f, -0.02064847f, -0.06239638f, -0.18426466f, 
    0.07818587f, 0.10373152f, -0.00421948f, -0.44396496f, -0.04090315f, 0.00600190f, -0.07079049f, -0.10206643f, 
    -0.08765732f, -0.10825311f, -0.09957079f, 0.08598702f, 0.01613765f, 0.17686684f, 0.15186433f, 0.11756776f, 
    -0.03046689f, -0.07645606f, 0.04347521f, -0.21025231f, -0.19401135f, 0.06053253f, -0.49467778f, 0.13297062f, 
    0.07051663f, 0.18404339f, 0.02234103f, -0.03611023f, 0.00991662f, -0.08250803f, 0.23316571f, 0.02228919f, 
    -0.05101018f, -0.07833020f, 0.07584279f, -0.18759798f, 0.03900068f, 0.37849709f, 0.19916064f, 0.23177214f, 
    0.11086868f, -0.02482300f, 0.06978218f, 0.24558017f, -0.32868713f, -0.43389389f, -0.49099767f, -0.00394366f, 
    0.03944527f, 0.08740301f, -0.04948442f, -0.18236774f, 0.08237866f, -0.02384200f, 0.16567375f, -0.06701640f, 
    0.09344964f, 0.00129049f, -0.27578011f, -0.16916198f, 0.20383310f, -0.16709544f, -0.09372306f, 0.15859771f, 
    -0.01193485f, 0.07811233f, -0.11159378f, 0.15526713f, -0.17655586f, -0.23388723f, -0.09430500f, 0.09783656f, 
    0.12003437f, -0.16594768f, 0.18925019f, -0.03619472f, -0.13700184f, 0.01764240f, 0.08043578f, -0.19922179f, 
    0.04127190f, -0.15139033f, 0.16201167f, -0.10274216f, -0.22311996f, -0.30736327f, -0.07986083f, 0.23375787f, 
    -0.27974099f, 0.29523554f, -0.02400794f, 0.27401543f, 0.07137874f, 0.04943076f, -0.67443407f, -0.55242097f, 
    -0.04434147f, -0.02433557f, -0.06341153f, -0.53652662f, -0.43657005f, -0.34349424f, 0.24944130f, -0.20363237f, 
    0.09841352f, -0.51912892f, -0.18913296f, -0.09056527f, -0.01119458f, -0.10969665f, 0.29294187f, -0.25510472f, 
    0.02818181f, 0.04229729f, -0.14297472f, -0.02278790f, -0.06553783f, -0.16735055f, -0.02827619f, 0.09440678f, 
    -0.02678886f, -0.43085760f, -0.52039278f, -0.07636413f, 0.06594118f, 0.02414291f, -0.10943099f, 0.22083895f, 
    0.03343724f, 0.10103717f, -0.25365576f, 0.21527269f, -0.05643876f, -0.43171871f, 0.04067114f, -0.03638680f, 
    0.01046824f, 0.12237100f, -0.02473354f, -0.54950356f, 0.14269337f, -0.13252133f, -0.06614663f, -0.10478391f, 
    0.03842563f, -0.00202424f, -0.05254330f, -0.21932916f, 0.06833985f, -0.06826701f, 0.37420210f, -0.42572343f, 
    -0.08916439f, -0.26691115f, -0.08837672f, 0.05324845f, 0.02639456f, 0.00731800f, -0.18316120f, 0.07268025f, 
    -0.06576570f, 0.00448617f, 0.01649001f, 0.24867804f, 0.22048032f, 0.03896515f, -0.14228001f, -0.10836761f, 
    -0.24879660f, -0.65842754f, -0.04543480f, -0.47614339f, -0.17415394f, -0.08207762f, 0.42148122f, 0.05189952f, 
    0.18712337f, 0.12975244f, 0.00007611f, 0.25711763f, 0.01897931f, 0.05284753f, 0.16554998f, -0.06452564f, 
    -0.88695133f, 0.18872848f, -0.11744285f, -0.04811412f, -0.37175292f, -0.03089028f, -0.03779287f, 0.13451701f, 
    -0.02295828f, -0.47040796f, 0.32018262f, -0.81402254f, 0.16375691f, 0.17941219f, 0.01801578f, 0.08351535f, 
    -0.12290282f, 0.01113725f, -0.04450316f, 0.05897025f, -0.00458070f, 0.06224702f, -0.11330093f, -0.03789579f, 
    -0.07691348f, 0.01515062f, -0.23361029f, 0.22773187f, -0.34311116f, 0.15502210f, -0.05233429f, -0.00133575f, 
    -0.22150858f, 0.11640189f, -0.04987883f, 0.29777321f, 0.06493200f, 0.10897680f, 0.41642898f, -0.19812059f, 
    -0.03017687f, -0.01439579f, 0.18465933f, -0.19832028f, -0.22642736f, 0.09358771f, -0.12122234f, 0.52285999f, 
    0.05105574f, -0.24645983f, -0.03941435f, 0.10178760f, -0.04534131f, -0.40382710f, -0.07924528f, 0.07436965f, 
    -0.07945790f, -0.01374448f, 0.01520224f, 0.14797786f, 0.02544243f, -0.14696474f, 0.04707280f, -0.25365600f, 
    -0.03920070f, -0.23856838f, -0.14684999f, 0.05879272f, 0.02818665f, 0.05007393f, 0.05289998f, -0.34307155f, 
    0.13208488f, -0.30488062f, 0.18709403f, 0.13202238f, -0.01828553f, -0.28712070f, 0.03147642f, -0.06369423f, 
    0.07238434f, -0.32983869f, -0.50466448f, -0.49774751f, 0.05962118f, -0.27141514f, 0.20503013f, 0.00271670f, 
    -0.10169512f, 0.02647118f, 0.17523412f, -0.17579870f, 0.13940856f, -0.02278949f, 0.04168040f, 0.16412959f, 
    0.05939426f, -0.14039119f, 0.05457456f, -0.02131535f, 0.04573341f, -0.02428438f, -0.15061764f, 0.07599822f, 
    -0.06866471f, 0.23525113f, -0.07730974f, -0.22831658f, -0.28167820f, -0.13534835f, -0.11825849f, -0.09344129f, 
    0.52326888f, 0.18606421f, 0.08530079f, 0.17308989f, 0.06263077f, 0.01665130f, 0.28975186f, 0.02767817f, 
    -0.50289577f, 0.00178568f, 0.05319596f, 0.02862358f, 0.07682448f, -0.07034734f, -0.41921845f, 0.19609228f, 
    -0.12888901f, 0.05288380f, 0.05520559f, 0.01090519f, 0.27516738f, -0.34804884f, 0.00867237f, 0.09577103f, 
    -0.05599242f, 0.09548674f, 0.22457331f, -0.43782818f, -0.21756321f, -0.13028751f, 0.07284970f, -0.43185624f, 
    0.16195956f, 0.12266883f, 0.00841025f, -0.01242493f, -0.55400968f, -0.08420151f, -0.19862911f, 0.28475568f, 
    0.19030561f, 0.05241770f, -0.19335452f, -0.15956433f, 0.03521617f, 0.26518744f, 0.07167327f, -0.06640544f, 
    -0.19357625f, 0.04301978f, -0.15991157f, -0.60872245f, 0.10041774f, 0.04187173f, -0.35245675f, 0.00967720f, 
    0.00179650f, 0.04934137f, -0.17996261f, -0.15212610f, -0.61810142f, -0.05462421f, -0.11522774f, -0.36840940f, 
    -0.03905633f, -0.17996053f, 0.34434909f, -0.36605608f, -0.00267169f, 0.16413103f, 0.36584726f, 0.08336702f, 
    0.08203237f, 0.06565190f, -0.19085947f, 0.00811233f, -0.02103372f, 0.06462912f, -0.04966462f, 0.25529361f, 
    -0.08077258f, 0.24390616f, -0.17692842f, -0.00424579f, -0.33070016f, -0.03111993f, 0.04510732f, -0.03851193f, 
    0.16172290f, -0.07938846f, -0.00325681f, 0.06884822f, -0.04527076f, 0.29621792f, 0.04896193f, 0.06436608f, 
    0.03788313f, -0.06398883f, -0.34737670f, -0.52721918f, 0.17725347f, -0.01511844f, 0.15081693f, -0.27186590f, 
    -0.06857534f, 0.03468336f, 0.09798191f, 0.32181948f, -0.08416551f, 0.04574856f, -0.17505714f, 0.22846994f, 
    -0.07838801f, -0.14844203f, 0.07128904f, -0.04471477f, -0.04204023f, 0.00122453f, -0.04029875f, -0.07585528f, 
    0.07115785f, 0.13673815f, 0.07947151f, 0.01029600f, -0.33778647f, 0.22887407f, -0.38516763f, 0.16028683f, 
    0.18473747f, -0.64129364f, 0.16745383f, 0.28347021f, -0.06465450f, -0.05749072f, -0.28653851f, -0.05017169f, 
    -0.54268777f, -0.20685959f, -0.03421368f, -0.24043442f, 0.01315153f, 0.06640597f, -0.03264831f, 0.14417183f, 
    -0.52540576f, 0.09604582f, -0.07442290f, 0.16062012f, -0.18117999f, -0.03162461f, -0.02959025f, 0.18461472f, 
    0.02198191f, -0.03225810f, -0.39983046f, -0.33530748f, -0.32495275f, -0.12935874f, 0.21791132f, -0.35020277f, 
    -0.09338284f, 0.25373325f, -0.07941355f, -0.02712710f, -0.30453423f, -0.00120378f, 0.08256948f, -0.26709917f, 
    0.11541248f, -0.46068120f, 0.28983253f, 0.01852202f, 0.10816277f, 0.29022810f, -0.02323196f, -0.15876153f, 
    0.24208914f, -0.12599649f, -0.30161953f, 0.17535043f, -0.31131521f, -0.07847627f, 0.38427144f, -0.33688956f, 
    0.01270837f, 0.05310483f, -0.07934507f, 0.32178244f, 0.11399416f, -0.22849950f, -0.14838962f, -0.34397843f, 
    0.16425684f, -0.27790955f, -0.47160482f, 0.16370019f, 0.00478778f, -0.28828621f, -0.26137388f, -0.63018155f, 
    -0.06366689f, -0.08759425f, 0.17488156f, -0.18690325f, 0.02473451f, -0.29453924f, 0.01868989f, -0.00982823f, 
    0.00968441f, -0.37880003f, 0.17613356f, 0.05279298f, -0.13796565f, 0.06047398f, -0.40176681f, 0.08061133f, 
    0.03348271f, -0.05007540f, 0.12428378f, 0.00891770f, 0.06207344f, 0.02605286f, -0.01383901f, 0.07414984f, 
    0.06555116f, 0.09901504f, -0.13465932f, 0.22208337f, 0.20432615f, -0.01331293f, -0.18473080f, 0.24341036f, 
    0.02071379f, 0.01689239f, -0.09477117f, -0.26649109f, 0.24449541f, 0.03552752f, 0.10603444f, -0.47655091f, 
    0.06714597f, 0.15669680f, 0.06467232f, 0.02072603f, 0.05381402f, 0.05276326f, -0.07539044f, 0.05477487f, 
    -0.01340820f, 0.11058224f, 0.02662242f, 0.06742694f, -0.13759845f, -0.00629813f, -0.18346432f, -0.31744811f, 
    -0.40857074f, 0.41365883f, 0.21801272f, -0.10379703f, 0.25944132f, 0.30429322f, -0.13539273f, -0.05610052f, 
    -0.43949789f, 0.04289044f, 0.08413965f, -0.01478540f, 0.08111745f, -0.02112459f, 0.06520345f, -0.25193343f, 
    0.22659010f, 0.04177850f, 0.20330255f, -0.40558475f, -0.00305846f, -0.07813849f, -0.06044935f, 0.07760487f, 
    -0.01104515f, -0.32151970f, 0.09662970f, -0.11485766f, 0.03899302f, 0.00314284f, 0.13269863f, 0.03041493f, 
    0.07120069f, 0.27929026f, -0.25950974f, 0.03175862f, 0.11089405f, -0.05844762f, 0.04389620f, 0.21029985f, 
    -0.15297903f, -0.16820873f, -0.09678537f, -0.32512760f, -0.23256472f, -0.13395669f, -0.07892913f, 0.01226491f, 
    -0.07027908f, -0.23122615f, -0.11773442f, -0.29944402f, 0.11480325f, -0.46165487f, -0.40234971f, 0.38259912f, 
    -0.07857260f, -0.07973875f, 0.15387084f, -0.83324975f, 0.09536889f, 0.21866208f, 0.29860044f, -0.62643391f, 
    -0.00461036f, 0.42756531f, 0.19021091f, 0.03801861f, 0.00379851f, 0.05619316f, 0.04966031f, 0.06630899f, 
    -0.04309950f, -0.08808839f, -0.41337758f, 0.23126417f, 0.06467992f, -0.02394617f, 0.02637602f, 0.11023177f, 
    0.00855144f, 0.00844661f, 0.14571539f, -0.04852071f, -0.05118020f, -0.06591298f, 0.11370400f, 0.31289878f, 
    -0.14759634f, 0.09794350f, 0.33161753f, -0.06310980f, 0.02149888f, -0.20670263f, -0.04500343f, -0.15118963f, 
    -0.00960220f, 0.34011614f, 0.21125650f, -0.43542746f, -0.17944221f, -0.32588711f, 0.02905512f, 0.33754197f, 
    -0.04980198f, -0.07038940f, -0.04265501f, -0.21783404f, 0.08721129f, -0.05208646f, -0.31574857f, -0.11543867f, 
    -0.00215995f, 0.23863819f, 0.01001671f, -0.05822776f, 0.04214354f, 0.03875112f, 0.28359014f, 0.07382305f, 
    -0.05416954f, -0.14886808f, 0.06254128f, 0.03882557f, 0.27018741f, 0.10418359f, 0.10325369f, 0.14736941f, 
    -0.67457408f, -0.30760217f, -0.13707545f, -0.28523952f, -0.01518406f, 0.15894388f, -0.74110526f, 0.02372306f, 
    0.13629138f, -0.20836699f, 0.04262643f, -0.29182234f, -0.54739356f, 0.00459222f, -0.15934929f, 0.25814444f, 
    -0.21314836f, -0.27176705f, -0.25021929f, 0.19654697f, -0.28681311f, -0.02103706f, 0.02086149f, -0.15404949f, 
    0.05900906f, -0.25226805f, -0.10088275f, -0.46003118f, -0.42685103f, 0.12458943f, 0.27997583f, 0.14145981f, 
    0.19236897f, -0.44480386f, -0.00155051f, -0.02206318f, -0.18156092f, -0.08168415f, 0.26692000f, 0.30545998f, 
    0.18065293f, 0.15428977f, 0.16011579f, -0.34013295f, 0.09130190f, -0.47594410f, -0.02478908f, -0.63298577f, 
    0.14411066f, 0.07784244f, 0.10876226f, 0.08761800f, 0.08804959f, 0.12384210f, -0.13660046f, -0.16595188f, 
    0.00403283f, -0.01070311f, -0.32023588f, 0.18414329f, -0.07031500f, 0.21986860f, 0.21520540f, 0.29129824f, 
    -0.15740167f, 0.09381735f, -0.02333769f, -0.12854509f, -0.00927305f, -0.05294978f, -0.04331609f, 0.04161674f, 
    -0.00585005f, -0.08840698f, -0.25632459f, 0.10599598f, -0.06626478f, -0.14207877f, 0.00998809f, 0.31680778f, 
    -0.03674429f, -0.33034983f, -0.44685245f, -0.04137589f, 0.25187030f, 0.02459313f, -0.47283188f, 0.10641626f, 
    0.15259966f, 0.34969491f, -0.10798880f, -0.01222178f, -0.03520747f, -0.47524348f, 0.04367756f, 0.12171416f, 
    -0.00127922f, -0.40006557f, 0.52758104f, -0.23373388f, -0.33534509f, 0.10450238f, -0.27068704f, 0.15508884f, 
    0.04866239f, 0.07856823f, -0.39092040f, -0.29853526f, -0.04883797f, 0.06496422f, 0.09499478f, 0.09698523f, 
    -0.04836584f, -0.38757876f, 0.06232826f, 0.07170548f, -0.05513813f, -0.00611427f, -0.32287401f, -0.04033370f, 
    -0.00984944f, 0.13534063f, -0.08123265f, -0.02123466f, 0.06225793f, -0.22121584f, -0.36196467f, 0.23869348f, 
    -0.21252681f, -0.24373482f, 0.19229454f, -0.12957835f, -0.37659693f, 0.10241108f, 0.16693050f, -0.07903107f, 
    -0.56115627f, 0.10549469f, 0.07463203f, -0.24764222f, 0.12439136f, -0.07793389f, 0.31760558f, -0.24211736f, 
    -0.08452870f, 0.07050381f, -0.15523601f, 0.24187994f, 0.04451375f, 0.06074718f, 0.00001977f, -0.01612351f, 
    -0.08120207f, 0.09916623f, -0.25011119f, -0.08309893f, 0.03628072f, 0.16598584f, -0.17152843f, -0.13897318f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14593561f, 0.10142642f, 0.05908886f, -0.05554466f, -0.05370921f, -0.00084337f, 0.02591708f, -0.09007271f, 
    0.01756385f, 0.06072006f, -0.01864246f, -0.11188398f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
