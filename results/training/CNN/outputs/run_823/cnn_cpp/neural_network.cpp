#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.49657732f, -1.00459719f, -0.59117490f, 0.43571755f, 0.50275290f, 0.55376875f, 0.77579635f, -0.06512868f, 
    0.40805167f, -0.10524163f, 0.11986577f, 0.32691067f, -0.04343538f, 0.33735442f, -0.05609494f, -0.16560483f, 
    0.05402399f, -0.37778926f, -0.22983694f, -0.04886795f, 0.02821003f, 0.01076513f, 0.05679001f, -0.09780689f, 
    -0.13514259f, 0.02525178f, 0.43808454f, 0.59932888f, 0.69649082f, 0.37134156f, 0.03811683f, 0.07488751f, 
    -0.12418098f, 0.03290837f, -0.42266375f, -0.03997038f, -0.09431702f, 0.18002762f, 0.48248035f, 0.07967075f, 
    0.23759899f, 0.01521569f, 0.11584853f, 0.48163033f, 0.19434933f, -0.41402927f, -0.23987749f, -0.15421647f, 
    0.21732643f, -0.13893428f, 0.05838140f, 0.40265435f, 0.67671734f, 0.12144540f, 0.21363981f, 0.18858711f, 
    0.13379960f, 0.24043790f, 0.14478295f, 0.14365286f, -0.13907735f, 0.03217375f, -0.11649234f, -0.14948756f, 
    0.07427671f, 0.14360628f, 0.22341715f, 0.42304265f, 0.20881420f, -0.25474271f, 0.30203065f, -0.02031341f, 
    -0.34139055f, -0.04949829f, 0.47506326f, -0.12929066f, -0.10794675f, -0.35456154f, -0.01623835f, -0.28750965f, 
    -0.01393301f, -0.67340088f, -0.42131573f, -0.40688425f, 0.05195448f, 0.05333864f, 0.19494748f, 0.07601527f, 
    0.20695479f, 0.40223110f, -0.53615040f, -0.49546924f, 0.04498773f, -0.06345375f, 0.47304699f, -0.05777721f, 
    0.31569844f, -0.29671049f, -0.10602973f, -0.07335258f, 0.75216103f, -0.17211656f, -0.64625901f, 0.00704334f, 
    -0.17191194f, 0.59138012f, 0.76483655f, -0.50052935f, 0.00381416f, 0.32334191f, -0.05546853f, 0.08594341f, 
    -0.16500692f, 0.28717604f, 0.05974677f, -0.03010373f, -0.23116583f, -0.32630298f, 0.18881838f, -0.04906431f, 
    0.16716659f, 0.11511266f, 0.07928465f, 0.05969767f, 0.07470727f, 0.76899236f, 0.87024415f, 0.46801770f, 
    -0.36033356f, -0.47133642f, -0.45606977f, -0.42319557f, 0.05117154f, -0.57326877f, 0.16997552f, 0.45273095f, 
    0.13824849f, 0.17172320f, 0.17361394f, -0.38294014f, 0.17542905f, -0.17632039f, 0.19098869f, 0.04268825f, 
    -0.04141329f, -0.01446140f, 0.09056155f, 0.26549694f, -0.31445211f, 0.03582811f, 0.28272468f, 0.32200310f, 
    0.54391301f, 0.76028645f, -0.09254599f, 0.34577471f, 0.13652249f, 0.14977127f, -0.19191162f, 0.42612952f, 
    -0.02059708f, 0.12426618f, -0.15033682f, -0.12571570f, -0.04006789f, -0.20729662f, -0.35815242f, 0.06545565f, 
    -0.28886369f, -0.09439491f, -0.05164604f, 0.43645674f, -0.09185583f, 0.20213009f, -0.02287378f, 0.37412754f, 
    -0.24405614f, -0.42241812f, -0.40873498f, -0.20847081f, -0.54916811f, -0.20560588f, -0.00534557f, -0.29047859f, 
    -0.17148352f, -0.36952701f, 0.49759948f, 0.14197610f, -0.21812105f, 0.15231486f, -0.56955069f, -0.31550020f, 
    -0.10650258f, 0.23835738f, -0.14596176f, -0.00804873f, -0.22701767f, 0.02700012f, -0.30267110f, -0.04419193f, 
    -0.27235764f, 0.33218729f, -0.59551859f, -0.83377779f, -0.48044240f, 0.65758991f, -0.18296513f, 0.24806608f, 
    0.21211192f, -0.05568420f, 0.12613778f, -0.20269075f, -0.46934840f, -0.00480183f, -0.09014320f, 0.31974086f, 
    -0.14495482f, -0.30282629f, 0.13441347f, 0.28405920f, 0.23202801f, -0.11686449f, 0.14525017f, -0.34568438f, 
    0.39908275f, 0.53474796f, 0.43664449f, 0.47938594f, 0.91120535f, 0.40974092f, -0.12088802f, 0.30137780f, 
    -0.58826810f, 0.26478979f, 0.11767236f, 0.35083050f, 0.20742682f, 0.01304962f, 0.11889342f, -0.24052747f, 
    -0.03323350f, -0.06727359f, 0.32179967f, 0.07029488f, -0.27018806f, 0.14127025f, -0.01493061f, -0.23794752f, 
    -0.28214821f, -0.00984225f, 0.23934473f, -0.43575206f, -0.05098582f, 0.87628138f, -0.13699818f, -0.33311671f, 
    -0.60040027f, -0.05029237f, -0.09760486f, 0.20129317f, -0.05131884f, -0.12275265f, -0.14524466f, 0.24360624f, 
    -0.32648185f, 0.24143213f, 0.03986974f, 0.26434946f, -0.34133086f, 0.18527994f, -0.11599881f, -0.30295861f, 
    -0.05276977f, -0.24903950f, -0.37201902f, 0.55827218f, -0.47296757f, -0.58311117f, -0.28106615f, 0.18864881f, 
    -0.52235794f, -0.46989694f, 0.09886666f, -0.27914515f, 0.16352814f, -0.46569842f, -0.00084867f, 0.13743846f, 
    -0.29758322f, -0.30975389f, -0.27033871f, -0.27399153f, -0.27037650f, -0.27578583f, -0.09862022f, 0.03400666f, 
    0.22056964f, 0.16129866f, -0.12215204f, -0.19668964f, -0.79747146f, 0.26846409f, -0.56556171f, -0.59210867f, 
    -0.09377518f, 0.27240056f, 0.41176489f, 0.05377569f, 0.41194347f, 0.62558365f, -0.18252273f, 0.04045564f, 
    0.20208012f, 0.01239727f, -0.13438331f, 0.42536056f, -0.14740080f, 0.18914266f, -0.20919228f, -0.52501142f, 
    0.04667044f, -0.16242653f, 0.07871848f, 0.00114764f, 0.03630839f, -0.91087049f, -0.05501844f, 0.31571403f, 
    -0.30235511f, -0.27666593f, -0.06188125f, 0.28313318f, 0.08610281f, -0.01121747f, -0.00496610f, 0.04548319f, 
    0.19535516f, -0.12518479f, -0.20784916f, -0.39453900f, -0.02683145f, 0.37630668f, 0.07029964f, 0.28623450f, 
    -0.50853276f, 0.16610767f, 0.19082820f, 0.04968902f, -0.12107857f, 0.07768599f, 0.09415576f, -0.43303210f, 
    -0.51545709f, -0.30218935f, -0.19357210f, 0.24084222f, -0.93081492f, -0.42528930f, 0.16489500f, -0.43927538f, 
    -0.66280782f, -0.21490270f, 0.43385807f, 0.01210997f, -0.29825917f, 0.10979172f, 0.16689752f, -0.02097421f, 
    0.18173079f, 0.21416727f, -0.03670943f, -0.13035725f, -0.15049936f, 0.25220498f, 0.02018850f, -0.53312713f, 
    -0.55810493f, -0.58037329f, -0.43338996f, -0.31072518f, -0.04485388f, -0.03823778f, -0.27683547f, 0.37050733f, 
    0.25797415f, 0.15569527f, -0.00573936f, 0.06067415f, -0.10053441f, 0.04716228f, -0.14682743f, 0.38892439f, 
    0.39947608f, 0.20350625f, -0.17066444f, -0.21011779f, -0.20980176f, -0.19876502f, -0.28562331f, -0.06203065f, 
    0.23872676f, 0.08410522f, -0.46072742f, -0.63709813f, -0.61585027f, 0.38922691f, 0.55281824f, -0.24157475f, 
    0.26380131f, 0.58490521f, 0.18644127f, -0.40184727f, -0.36599565f, -0.27422345f, -0.48768365f, -0.02064824f, 
    -0.01842589f, 0.13502491f, -0.18672653f, -0.24178578f, -0.37074193f, -0.15986930f, -0.27110997f, -0.05954194f, 
    -0.06548202f, 0.92996401f, 0.44521618f, 0.44728440f, 0.64867026f, 0.70555657f, 0.29429433f, -0.03274465f, 
    -0.34392145f, -0.06515077f, -0.45021400f, 0.23916826f, 0.25693396f, -0.13962704f, 0.10977682f, 0.13955979f, 
    0.20047127f, -0.17334716f, 0.12226810f, 0.08005706f, 0.11986334f, 0.08612739f, 0.08462798f, 0.07909290f, 
    0.17847933f, 0.09270313f, 0.03651890f, -0.15173341f, 0.54413229f, -0.06012607f, -0.14916746f, 0.37828812f, 
    0.12409475f, 0.25011140f, 0.23471287f, 0.07338420f, 0.29707241f, 0.26311225f, 0.41995183f, 0.38775384f, 
    -0.11537319f, -0.46700919f, -0.04831875f, 0.00054898f, -0.54469907f, -0.28969109f, -0.06407657f, 0.18596621f, 
    0.07490905f, 0.13639687f, 0.12106432f, -0.70847440f, 0.13460892f, -0.32362685f, -0.41406688f, 0.00604219f, 
    0.19522391f, 0.67748058f, 0.00300180f, 0.28938177f, 0.51192230f, 0.36787462f, -0.06262583f, -0.01107414f, 
    0.09670448f, 0.41667771f, 0.34319520f, 0.01131376f, 0.00666791f, 0.06670532f, 0.07016172f, -0.01439647f, 
    0.42713085f, 0.16505781f, -0.09246781f, 0.21376015f, 0.17949304f, 0.30289960f, 0.29214570f, 0.22628754f, 
    0.53070742f, -0.71334803f, 0.42859495f, 0.22226396f, 0.12880851f, 0.52141160f, -0.35336947f, -0.24836750f, 
    0.26420590f, 0.13137221f, 0.03946685f, -0.20101355f, -0.18348913f, 0.17008902f, 0.08998067f, -0.06088956f, 
    0.26670307f, 0.08589911f, 0.05193114f, 0.36171952f, 0.02084213f, 1.05136323f, 0.26699287f, -0.31480387f, 
    -0.51990217f, -0.14208813f, 0.37480995f, -0.07305305f, -0.10543671f, -0.42525268f, 0.11293397f, -0.17618933f, 
    0.07675329f, 0.03987647f, 0.15617801f, 0.07847466f, -0.08178946f, 0.01467774f, -0.05636828f, 0.21262719f, 
    -0.10402597f, 0.01410401f, -0.01105438f, 0.06048468f, -0.02855759f, 0.16719073f, 0.25464585f, -0.50057173f, 
    -0.73683280f, -0.20550200f, 0.26668334f, -0.15135126f, 0.11285156f, 0.49791443f, 0.33432844f, -0.14861007f, 
    -0.35205966f, -0.05579583f, -0.31618184f, -0.14705595f, 0.21438278f, 0.08019574f, -0.14895038f, 0.27517420f, 
    -0.02858108f, 0.17639717f, 0.02785708f, 0.13994768f, -0.08390804f, 0.00325693f, -0.09239174f, 0.71134156f, 
    0.24045916f, 0.16342886f, -0.15823784f, 0.92792207f, -0.15308520f, -0.50582528f, -0.40756392f, 0.19378643f, 
    0.54942125f, -0.17479064f, -0.01644512f, -0.07137211f, 0.12501927f, 0.36068293f, -0.19418404f, -0.01164269f, 
    -0.20584244f, -0.11030640f, -0.38535181f, 0.18748812f, 0.10350934f, -0.02231334f, -0.00089059f, -0.04533534f, 
    -0.33122602f, -0.71808767f, -0.49604037f, -0.07230207f, -0.14121270f, -0.59531635f, 0.44783434f, -0.27384314f, 
    -0.58646506f, 0.32874280f, 0.37621471f, 0.19233072f, 0.19523391f, 0.23013741f, 0.34679252f, 0.17014103f, 
    -0.15140547f, 0.06479522f, 0.37992918f, -0.19744335f, 0.09551229f, -0.02798492f, 0.10688755f, -0.03507388f, 
    0.34574869f, 0.38462856f, 0.07095268f, -0.66693985f, -0.83068442f, -0.19670603f, 0.48461518f, 0.37675166f, 
    -0.26666626f, -0.05725903f, -0.02928000f, -0.27636221f, 0.36207855f, -0.32125989f, 0.18786202f, -0.16863360f, 
    0.23216367f, -0.02400104f, -0.16121057f, 0.09926399f, 0.35602328f, 0.12091302f, -0.13407679f, -0.18712348f, 
    -0.13103113f, 0.24430239f, -0.34522763f, 0.00890683f, 0.05098833f, -0.47629249f, -0.44943264f, -0.59561002f, 
    0.15214939f, -0.35442287f, -0.57435840f, -0.63124895f, -0.20160508f, 0.12896667f, -0.30615869f, -0.16009210f, 
    -0.43991417f, 0.23199160f, -0.22911747f, 0.11632505f, -0.19888836f, -0.00523083f, -0.04186166f, 0.24195953f, 
    -0.01616900f, 0.02399909f, 0.13396530f, 0.14963622f, 0.54922760f, -0.57938969f, -0.32020515f, -0.67750514f, 
    0.14947133f, -0.15222171f, 0.13231301f, 0.13604647f, -0.28390065f, 0.00151475f, 0.16633277f, -0.09662417f, 
    0.39110228f, 0.13573770f, 0.19843124f, -0.16547197f, 0.18699700f, 0.03107783f, -0.30006865f, -0.25832987f, 
    0.00475944f, -0.06953237f, -0.18771537f, 0.01571903f, 0.62392479f, 0.40411961f, -0.75867069f, -0.31188917f, 
    -0.12366499f, -0.00868364f, -0.50180715f, 0.20922948f, -0.41599944f, 0.09546468f, 0.03087398f, 0.10751966f, 
    0.23998742f, 0.10718120f, 0.27879551f, 0.11807587f, -0.04466519f, -0.21549587f, -0.23418292f, 0.24662031f, 
    0.21507981f, -0.15537529f, 0.04785723f, -0.30507705f, 0.06073063f, -0.68936789f, 0.10142197f, 0.35304448f, 
    0.07651860f, 0.36730066f, -0.85980570f, 0.70385283f, -0.39370012f, -0.56359506f, 0.11647504f, -0.06437203f, 
    0.23690315f, -0.00241455f, 0.15771182f, 0.13330185f, 0.27909821f, -0.22312647f, -0.14743266f, 0.06413705f, 
    0.10524079f, -0.10584720f, 0.00426602f, 0.27067706f, 0.09721483f, -0.19581050f, -0.56032097f, -0.44017288f, 
    -0.21094100f, 0.02792474f, 0.14379421f, 0.59110296f, 1.18887365f, 0.51819426f, 0.10914709f, 0.41627023f, 
    0.10435832f, -0.38269362f, 0.02834705f, -0.30755883f, -0.05885200f, -0.04440712f, 0.04037901f, -0.00966080f, 
    0.24971855f, -0.07698888f, -0.01673891f, -0.08435860f, -0.23486455f, -0.01583943f, 0.05565790f, 0.10377922f, 
    0.44756171f, 0.61081558f, 0.59329128f, 0.09126249f, -0.05453393f, 0.48701853f, 0.13462307f, -0.26426348f, 
    0.44404468f, -0.04560775f, -0.03861922f, -0.20641273f, 0.20290147f, -0.23045295f, -0.23069426f, -0.07221311f, 
    0.05480363f, -0.14317454f, -0.44500455f, -0.14350563f, -0.17099127f, -0.11868572f, 0.23137484f, -0.30697292f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.31597796f, 0.12477797f, 0.20507731f, 0.29292110f, 0.17926833f, 0.32402289f, 0.16863559f, 0.27154642f, 
    0.08546691f, 0.10394417f, 0.01054969f, 0.15859051f, 0.14869678f, 0.14726989f, 0.27573955f, 0.21561635f, 
    -0.06838360f, -0.05328939f, -0.10055585f, 0.10947259f, 0.05117079f, 0.00449400f, 0.25895858f, 0.07882973f, 
    0.03996788f, 0.20462388f, 0.13765715f, -0.21555057f, 0.07444798f, 0.08263393f, 0.01817448f, 0.06167181f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04159860f, 0.00436785f, -0.04664548f, -0.02221218f, 0.02690148f, 0.02639041f, -0.04487519f, -0.03532998f, 
    0.03947815f, -0.03781470f, 0.01793597f, -0.00964472f, -0.01589017f, 0.02023911f, 0.00612587f, -0.01176118f, 
    0.02435926f, 0.03075856f, 0.04101915f, -0.02512358f, -0.00697796f, 0.03401903f, 0.04443045f, 0.00739978f, 
    0.04885972f, -0.00884223f, 0.02102583f, -0.02439109f, 0.02275388f, -0.01181742f, -0.04800055f, -0.00604173f, 
    0.03027064f, -0.03110154f, -0.04883375f, -0.04965826f, -0.05153142f, 0.02638043f, -0.04371213f, 0.04443191f, 
    -0.02480466f, -0.02840008f, -0.05177673f, -0.04309319f, 0.03866734f, -0.00543624f, 0.02990434f, -0.04659590f, 
    -0.00217267f, -0.04826567f, -0.04441150f, 0.00750961f, -0.01030244f, 0.01355713f, 0.02930936f, -0.03394537f, 
    0.00242592f, 0.03981196f, -0.00179608f, -0.03967651f, 0.04023154f, -0.02113466f, -0.03264973f, -0.04150284f, 
    -0.00708359f, 0.00596312f, 0.04229070f, -0.00180744f, -0.01024200f, -0.01163699f, 0.00883691f, -0.00809985f, 
    -0.02050106f, 0.01834235f, -0.01759795f, -0.03865837f, -0.00396064f, -0.05401041f, -0.04783255f, 0.02954540f, 
    -0.01107634f, -0.04714237f, 0.03260233f, 0.00569967f, -0.04749148f, -0.04816135f, 0.03810740f, 0.04321712f, 
    0.01300968f, -0.03787840f, -0.01194173f, 0.00398815f, 0.01478863f, -0.03398792f, 0.00370561f, -0.03532775f, 
    -0.02927263f, -0.00969000f, 0.00622962f, 0.01897608f, 0.01193363f, -0.03853679f, -0.04477810f, 0.00025381f, 
    -0.01783300f, 0.03253623f, -0.01799642f, -0.01755087f, 0.01743384f, -0.04938446f, 0.01422005f, 0.02960629f, 
    0.02327648f, -0.04533682f, -0.03277119f, 0.02383295f, -0.00347292f, 0.04354386f, -0.00193980f, -0.05589012f, 
    0.02199624f, 0.02716340f, -0.03975943f, 0.01050701f, -0.05446035f, -0.04840065f, 0.03393123f, -0.05029286f, 
    -0.04651524f, -0.03353432f, -0.03999294f, -0.00379665f, 0.02076286f, 0.03448767f, -0.03826903f, -0.04610305f, 
    0.01791943f, 0.03691242f, 0.01942906f, -0.04977930f, -0.01852523f, 0.03439518f, -0.04814520f, -0.02991918f, 
    0.02979027f, -0.04982147f, 0.02283355f, -0.03753211f, 0.00182859f, 0.02670969f, -0.03878726f, 0.02646469f, 
    -0.02670976f, -0.00314657f, 0.02637489f, -0.00286233f, 0.01409096f, -0.01351987f, 0.04281475f, 0.00903869f, 
    0.01048931f, 0.02526495f, 0.00701240f, -0.01621955f, -0.00624669f, -0.02068555f, -0.00309404f, -0.03592318f, 
    0.03408891f, -0.05379561f, -0.05097544f, -0.04473515f, 0.03294329f, -0.04534707f, -0.00981678f, -0.00228975f, 
    -0.04690548f, -0.03337650f, -0.01172845f, 0.04403387f, -0.02443036f, 0.01103965f, -0.00545250f, 0.03056068f, 
    0.01691128f, -0.01250550f, -0.04971415f, -0.04434357f, 0.00699152f, -0.00845172f, 0.04499374f, 0.03859635f, 
    -0.04718986f, -0.05033882f, 0.01869730f, -0.03453862f, -0.00500680f, -0.02317221f, 0.00758022f, 0.04582218f, 
    0.03725261f, -0.00956027f, 0.00991162f, 0.04324199f, -0.02885300f, -0.00648821f, 0.04170898f, -0.01202383f, 
    -0.02870383f, 0.01946739f, -0.03162095f, -0.02597815f, 0.02149231f, -0.04862676f, 0.02417695f, -0.03103183f, 
    -0.00087443f, 0.01727164f, -0.01376773f, 0.00073556f, 0.03064404f, -0.02372771f, 0.00150706f, 0.02415085f, 
    -0.00578782f, -0.00914872f, -0.02041574f, -0.05600335f, 0.03929568f, -0.01763740f, -0.02909124f, -0.03428578f, 
    -0.04638874f, 0.00646995f, -0.04027496f, 0.00009920f, 0.01488189f, -0.00881111f, -0.02141379f, 0.00789057f, 
    -0.05583381f, -0.04721681f, 0.02798543f, -0.00784112f, 0.03545458f, 0.04359595f, -0.02673803f, -0.01630145f, 
    0.03521825f, 0.01094677f, 0.01681116f, 0.01834292f, 0.00481375f, -0.01206568f, 0.01687399f, 0.02335496f, 
    -0.05472029f, -0.04093305f, 0.03936785f, -0.04331658f, 0.00031974f, -0.01033423f, -0.05405720f, -0.00239748f, 
    0.00808412f, -0.03758356f, 0.01195318f, 0.02775072f, -0.02348187f, -0.02384248f, 0.03946321f, -0.01813084f, 
    0.00459303f, 0.02851377f, 0.03853452f, 0.01184633f, 0.03285120f, -0.00825676f, -0.02512852f, 0.03036550f, 
    0.04271211f, -0.03837442f, 0.04128911f, -0.02330073f, 0.01423695f, -0.04920278f, -0.01515108f, -0.04270780f, 
    -0.04676503f, 0.03921238f, -0.02966127f, -0.05160285f, -0.02625654f, -0.02737165f, -0.03354539f, 0.01533583f, 
    0.02037909f, -0.04088335f, 0.02572186f, -0.04085134f, 0.00248841f, 0.03256676f, -0.04331904f, -0.04289109f, 
    0.01550944f, 0.01174780f, -0.04075953f, 0.00896982f, 0.03104648f, 0.00663499f, -0.03810087f, -0.01783074f, 
    0.02034243f, -0.03890210f, -0.00431496f, -0.03552314f, -0.02168275f, -0.04046971f, -0.02416252f, 0.00229456f, 
    -0.01515486f, 0.01618614f, -0.01104419f, -0.02386167f, -0.02308067f, 0.02383596f, 0.01092547f, -0.02026843f, 
    -0.04083564f, 0.00403628f, -0.03549995f, 0.00548250f, -0.00913150f, 0.00078542f, -0.04975537f, -0.03202404f, 
    -0.04178613f, -0.04424386f, -0.01988974f, 0.04181970f, 0.02875398f, 0.02234716f, 0.01091004f, -0.05225071f, 
    -0.00760169f, 0.02766277f, 0.00794412f, -0.02884228f, 0.02638074f, 0.03220189f, -0.01047627f, -0.03034976f, 
    -0.00559951f, -0.03362995f, 0.02508144f, -0.03879561f, 0.01400455f, -0.00373931f, -0.01208466f, -0.02204110f, 
    0.02795089f, -0.04260138f, -0.01250187f, -0.03171279f, -0.03898147f, -0.04528746f, -0.03768710f, -0.00709939f, 
    -0.00857916f, -0.01962513f, 0.01039222f, -0.01716977f, 0.01385104f, 0.00091807f, 0.00852497f, 0.01150103f, 
    0.02106027f, -0.05601176f, -0.04351733f, -0.02134914f, 0.03037380f, 0.00418647f, -0.02839253f, 0.00801177f, 
    0.13695265f, 0.00840421f, 0.04117139f, 0.14881618f, 0.13907945f, 0.05714415f, -0.03247194f, 0.09639153f, 
    0.12039562f, 0.09429247f, 0.06802557f, -0.00882627f, -0.00737376f, 0.09772240f, -0.19088145f, 0.01538966f, 
    0.00433947f, -0.14948079f, 0.03289524f, 0.16388780f, 0.07853177f, -0.17175999f, -0.10601036f, -0.01940868f, 
    -0.18733992f, -0.10430937f, -0.06652045f, 0.01686076f, 0.07255161f, -0.02125592f, 0.11633608f, -0.07213554f, 
    -0.12675582f, 0.06861605f, 0.01731759f, 0.00452957f, 0.06277139f, -0.00684093f, 0.03455366f, -0.17677452f, 
    -0.06228258f, 0.06862537f, 0.16823623f, -0.12669760f, -0.02565352f, -0.14296204f, -0.08814025f, 0.05008082f, 
    -0.24221517f, 0.24680223f, 0.13407062f, 0.03338899f, 0.05960901f, 0.12842606f, 0.14930817f, -0.07305746f, 
    0.07864738f, 0.01019465f, 0.12530084f, 0.07423748f, -0.08886195f, -0.09009317f, 0.41455793f, -0.11414976f, 
    0.00886078f, -0.00602184f, -0.02599398f, -0.08248343f, -0.05443925f, 0.06051377f, -0.08268671f, -0.07136490f, 
    -0.17478687f, 0.04412377f, -0.18785845f, -0.21545291f, -0.04062101f, 0.03930293f, -0.07863590f, -0.07963645f, 
    -0.06197779f, 0.02338158f, -0.04191079f, 0.02838145f, -0.00554260f, 0.17615886f, -0.13392366f, 0.06129861f, 
    0.11123533f, 0.00461965f, 0.10077173f, -0.06223954f, 0.10997710f, 0.04530744f, 0.07537181f, -0.01193306f, 
    0.13877703f, -0.13693707f, 0.09887126f, -0.16687980f, -0.00907061f, -0.11045676f, 0.00864745f, 0.08193552f, 
    -0.06238300f, -0.13238840f, 0.06666803f, 0.01435081f, -0.13045755f, 0.09209879f, -0.04840613f, -0.01249163f, 
    -0.01597401f, 0.02826774f, 0.09353061f, -0.14751610f, -0.00682935f, 0.12554108f, -0.03668477f, 0.02228740f, 
    0.08174208f, 0.19644034f, 0.11029585f, 0.21970771f, -0.06069364f, 0.07585404f, -0.01820801f, 0.01833569f, 
    0.10801269f, 0.02358728f, -0.15328228f, 0.00586963f, 0.13174804f, 0.14107658f, -0.11556060f, 0.25128394f, 
    -0.05081700f, 0.05263248f, -0.03456409f, 0.00532779f, -0.09156548f, 0.34896994f, 0.11073831f, 0.22561105f, 
    0.46671468f, -0.03144942f, 0.06545377f, 0.01505712f, -0.00154828f, 0.01537304f, 0.01799806f, 0.11276871f, 
    -0.04569613f, 0.02072848f, -0.13708079f, -0.04846527f, 0.38436013f, 0.04554256f, 0.05524492f, -0.04824910f, 
    0.05762893f, -0.02465414f, 0.08613805f, -0.16610472f, -0.07719446f, 0.10710163f, -0.00355174f, 0.08186122f, 
    0.06439914f, 0.12650707f, 0.21952289f, -0.02038334f, 0.12728712f, -0.07355028f, -0.04255855f, -0.11474404f, 
    -0.00340938f, 0.08107740f, -0.10068814f, 0.06558475f, 0.23049341f, -0.18362641f, -0.03600276f, -0.02386463f, 
    -0.03213489f, -0.03485181f, 0.17303045f, 0.10776494f, -0.14282280f, -0.00897965f, -0.21119544f, -0.17784977f, 
    -0.01250876f, -0.09543076f, 0.15810101f, -0.26934600f, 0.05714795f, -0.01956524f, 0.17362942f, 0.10928664f, 
    0.15757637f, 0.30754200f, 0.03245415f, -0.04197856f, 0.09927572f, 0.13230635f, -0.28101417f, -0.29904011f, 
    0.09057854f, -0.14922574f, -0.02136263f, 0.00505778f, 0.04518810f, -0.15850370f, 0.05940587f, -0.15910646f, 
    0.05401495f, 0.01923900f, 0.00173694f, -0.02126812f, 0.13733639f, 0.01617591f, -0.03240917f, -0.01997095f, 
    0.08281237f, 0.31579345f, -0.08106224f, 0.06424576f, 0.37797159f, -0.19550349f, 0.06959165f, -0.05092615f, 
    0.05301330f, 0.00504032f, -0.12918435f, 0.00666820f, -0.09356759f, -0.14310746f, -0.01249646f, 0.04719587f, 
    0.02768948f, -0.26156595f, 0.13964614f, 0.13695344f, 0.19341916f, 0.09992484f, -0.06120583f, -0.06288286f, 
    -0.01000102f, -0.04807933f, 0.03042327f, 0.20156683f, -0.19174509f, 0.07852603f, 0.14614867f, 0.09730086f, 
    0.11062058f, -0.11319473f, -0.03236711f, 0.00102062f, -0.10691357f, 0.06709514f, -0.14922112f, 0.16883233f, 
    0.14399520f, 0.16515714f, -0.14931077f, 0.18634260f, -0.03742558f, -0.01534029f, 0.09158049f, -0.06362006f, 
    0.00868083f, -0.16515398f, 0.09266960f, -0.01467789f, 0.08449729f, 0.00923057f, 0.23850094f, -0.21117568f, 
    0.05529515f, 0.11796907f, -0.00049712f, -0.07165837f, 0.01817136f, -0.08211891f, 0.05747550f, 0.04745617f, 
    0.22509204f, -0.08838316f, -0.13950637f, -0.11858294f, 0.04804080f, -0.10093944f, -0.06051258f, -0.06541193f, 
    0.08608318f, 0.14120875f, -0.19547664f, -0.10246775f, -0.18514390f, 0.19753370f, 0.10870022f, -0.01193004f, 
    0.08207822f, -0.07056883f, 0.03415488f, -0.00210036f, 0.12417273f, 0.01370018f, 0.00544104f, -0.01254591f, 
    -0.10644867f, 0.26627484f, -0.07974522f, -0.05428253f, -0.04822667f, 0.07817179f, -0.02366057f, -0.10555397f, 
    0.05437849f, 0.03425939f, 0.05894424f, 0.15642674f, -0.16599576f, -0.20277339f, 0.29970840f, -0.05214647f, 
    -0.08859821f, -0.06338780f, 0.09366459f, 0.04539246f, 0.04313229f, 0.01282548f, -0.10752014f, -0.10050451f, 
    -0.01719731f, -0.12226919f, 0.08058466f, 0.00874392f, -0.07623772f, -0.04236716f, 0.05285928f, 0.07687692f, 
    0.00212059f, -0.17337386f, 0.05174442f, 0.06961405f, 0.31508097f, -0.01579432f, 0.01288006f, -0.00897135f, 
    0.06139091f, 0.11158372f, -0.09402239f, 0.00883528f, 0.02976515f, -0.10896691f, 0.04103367f, -0.07562324f, 
    0.27134240f, -0.06365448f, -0.03106405f, -0.09382608f, 0.17376411f, 0.05911892f, 0.07199784f, 0.19146350f, 
    -0.07203748f, -0.07072309f, 0.07441777f, 0.08383539f, 0.00962607f, -0.14190038f, -0.07301549f, -0.14851312f, 
    -0.03202398f, 0.01840250f, -0.03830577f, -0.02507766f, 0.00270722f, 0.01926761f, -0.02141634f, 0.03691357f, 
    0.03321507f, -0.00163435f, -0.01327221f, -0.04581645f, 0.03869779f, -0.03613229f, -0.05981363f, 0.01679817f, 
    0.02668621f, -0.04298785f, -0.04361759f, -0.05067379f, 0.03427297f, 0.02614218f, -0.01518812f, 0.04025076f, 
    -0.02075646f, -0.00700704f, 0.00223750f, 0.00989090f, -0.05831658f, -0.00361065f, 0.02377579f, -0.05330502f, 
    -0.01905927f, 0.01308997f, -0.01335035f, 0.02766230f, 0.03894937f, 0.01918004f, -0.02013044f, -0.05129174f, 
    0.02607470f, 0.03790630f, -0.00288729f, -0.02994953f, -0.02549803f, -0.00917910f, -0.02503193f, -0.04720628f, 
    0.03281079f, -0.01860084f, 0.01592992f, -0.01295620f, 0.01333941f, -0.01467758f, -0.05339444f, -0.01791449f, 
    -0.03288858f, -0.00787323f, 0.02667961f, -0.02455712f, -0.00618976f, -0.05284901f, -0.05242164f, -0.06045554f, 
    -0.01880202f, -0.01468952f, 0.03130968f, -0.03344032f, -0.04134239f, -0.03288034f, 0.00117547f, -0.03764142f, 
    -0.01448821f, -0.05347597f, 0.03522285f, -0.05489226f, -0.04299407f, -0.04499047f, 0.03079085f, -0.02682202f, 
    -0.02188815f, 0.00329987f, 0.03330125f, 0.03641869f, -0.03647771f, -0.02251336f, -0.04717466f, 0.03972688f, 
    0.04121058f, 0.02830329f, -0.04292081f, -0.03518302f, -0.03539761f, 0.01324871f, -0.04619291f, 0.00542055f, 
    -0.05642499f, -0.02798468f, 0.02561123f, -0.05590528f, -0.00849543f, 0.03487417f, -0.00744311f, 0.04081896f, 
    0.03197663f, 0.00159349f, 0.00679669f, -0.02519291f, -0.02067242f, 0.01656239f, -0.04889986f, 0.00149418f, 
    -0.00577487f, -0.04718689f, 0.02721063f, 0.02547300f, -0.02276812f, -0.02719363f, 0.01183475f, -0.00110670f, 
    0.04028866f, -0.01113441f, 0.00747575f, 0.02887384f, -0.04143477f, -0.03268457f, -0.02067648f, -0.01799755f, 
    -0.03094355f, 0.03403383f, -0.00472897f, 0.00319681f, -0.02078495f, -0.01421402f, -0.05203851f, -0.03071229f, 
    0.02619021f, 0.02888870f, 0.03669376f, 0.02087639f, 0.00101664f, -0.00607954f, -0.03689312f, -0.01022634f, 
    0.01781387f, 0.02825316f, 0.02422970f, 0.01340098f, -0.00914601f, 0.03363652f, -0.00622867f, -0.05828693f, 
    0.03011526f, 0.03301469f, -0.02421576f, 0.02431753f, 0.03651099f, 0.03642307f, 0.01780610f, 0.02412148f, 
    0.01661863f, 0.03027157f, -0.05106023f, 0.01469204f, -0.05671900f, 0.01608130f, -0.02702701f, 0.02360162f, 
    -0.04439253f, -0.05656027f, 0.03964865f, -0.04120998f, 0.00565580f, -0.04452622f, -0.01943501f, -0.01709721f, 
    0.00884888f, -0.00437251f, -0.01098617f, 0.00161076f, -0.04304032f, 0.03320116f, 0.03818726f, 0.02445321f, 
    -0.01249318f, -0.00864530f, 0.02310150f, -0.02679924f, -0.02359784f, 0.00738428f, -0.03533910f, -0.00649640f, 
    0.01563758f, -0.02243281f, -0.05688716f, -0.05692944f, -0.04724271f, -0.01097950f, -0.03883995f, -0.00170436f, 
    0.03514972f, 0.00126737f, -0.02574017f, -0.01801055f, -0.01045772f, -0.03553537f, -0.04971527f, 0.02385363f, 
    -0.03320453f, -0.03472739f, 0.03979861f, 0.00248817f, 0.02598499f, 0.03549898f, 0.01214614f, -0.03877521f, 
    0.02593901f, 0.03673753f, -0.01965990f, -0.00310122f, -0.04864794f, -0.02673220f, -0.01868002f, -0.02830160f, 
    -0.04304903f, -0.02025950f, -0.03935700f, -0.02726814f, -0.01012431f, -0.00700866f, 0.01351672f, -0.05061846f, 
    -0.00310524f, -0.01332735f, -0.02743183f, -0.03598727f, 0.00253301f, 0.01784900f, -0.01674658f, 0.01068396f, 
    0.00816187f, 0.02168399f, -0.01551932f, -0.04940350f, 0.01138910f, 0.01436428f, 0.00753772f, -0.02211593f, 
    0.02749034f, -0.04876324f, -0.04335064f, 0.01752756f, -0.05535737f, 0.00988565f, -0.01235759f, -0.02017336f, 
    -0.02145349f, 0.02957433f, 0.02659567f, -0.05325914f, -0.00533229f, -0.03805993f, -0.01982009f, -0.03149998f, 
    -0.04257879f, -0.01871759f, 0.01292286f, -0.02312022f, -0.01894445f, -0.03597870f, -0.02693847f, 0.01669149f, 
    -0.03652812f, 0.02478433f, -0.01058923f, 0.01055497f, 0.02018719f, 0.00309088f, -0.01095299f, -0.02470540f, 
    -0.03365565f, 0.01034710f, -0.00761301f, -0.05598189f, -0.04358101f, 0.01861961f, 0.02535574f, 0.04219129f, 
    0.02586294f, -0.00697520f, 0.02741280f, -0.00858891f, -0.03082662f, -0.04558182f, -0.04537446f, 0.02349176f, 
    0.02876631f, -0.01140103f, -0.00759599f, -0.02111338f, -0.02298200f, -0.04717976f, 0.02174709f, -0.00017100f, 
    -0.01044697f, -0.02211328f, 0.03207773f, -0.03573332f, -0.00940111f, -0.04554338f, 0.02204116f, -0.05517471f, 
    -0.05703050f, -0.02896278f, 0.04314121f, -0.01789081f, -0.03261220f, 0.01524312f, -0.03695519f, -0.05821325f, 
    0.03781906f, -0.03214429f, 0.03721280f, 0.01526612f, -0.02698058f, 0.02153985f, 0.02440776f, -0.02103889f, 
    -0.05750563f, -0.05521757f, 0.00340129f, 0.01518153f, -0.03147689f, 0.02392127f, -0.01536705f, -0.03006378f, 
    -0.00309842f, -0.03954192f, 0.03223017f, -0.05972483f, 0.02604616f, -0.01013412f, 0.02959623f, -0.02371599f, 
    0.02655052f, 0.02262869f, 0.01714104f, -0.03021507f, -0.04133542f, -0.03025850f, -0.04084058f, -0.04526838f, 
    -0.02312881f, -0.03453851f, -0.01944652f, 0.03119018f, 0.00868780f, -0.01008672f, -0.05524641f, -0.00369940f, 
    -0.04557044f, -0.02744037f, 0.01868524f, -0.05128631f, 0.00537787f, -0.03389730f, 0.04175951f, -0.01795153f, 
    -0.04542138f, -0.03935956f, -0.03523514f, -0.04530986f, 0.02128859f, -0.00281274f, -0.00172913f, -0.03015207f, 
    0.01214661f, -0.01999193f, -0.04451927f, -0.01935994f, -0.00474501f, 0.02361001f, -0.03449323f, 0.02926703f, 
    0.03257678f, 0.03094525f, 0.01635891f, 0.01836048f, -0.04629859f, -0.02017184f, 0.01610109f, -0.03681377f, 
    -0.64040464f, 0.08997437f, 0.23170042f, -0.26555744f, 0.00916176f, 0.10219019f, 0.02272040f, 0.06548247f, 
    0.01314989f, 0.06445080f, -0.11509436f, -0.05559519f, 0.05586710f, -0.11582652f, 0.06024224f, 0.01886842f, 
    -0.04526958f, 0.00609085f, -0.11892322f, -0.01391179f, -0.02062825f, 0.06687217f, 0.12298994f, 0.05158224f, 
    0.11603420f, 0.00340685f, 0.16234584f, 0.24362940f, 0.03151079f, 0.08365339f, -0.20772153f, -0.04168998f, 
    0.11995400f, -0.02000699f, -0.03892504f, 0.12827601f, -0.19569610f, -0.25084388f, 0.01666260f, 0.22495058f, 
    0.00513384f, -0.10895784f, 0.00699013f, 0.01158812f, -0.17524666f, 0.01399268f, -0.02493359f, 0.05084269f, 
    -0.10400570f, -0.04661464f, -0.18657579f, -0.00756125f, -0.12920246f, -0.10124314f, -0.03100524f, 0.10860416f, 
    0.21848753f, 0.01561380f, 0.04170088f, -0.05876442f, 0.07454275f, 0.32636029f, 0.11519384f, -0.07792556f, 
    -0.10437178f, -0.21771994f, -0.04491937f, 0.00964551f, 0.00175065f, -0.13384145f, 0.03633204f, 0.01536248f, 
    0.04785345f, 0.00159507f, -0.01594934f, 0.10748391f, -0.17657341f, 0.00062519f, -0.19004112f, -0.01206741f, 
    -0.07474262f, 0.01593961f, -0.05509676f, -0.10098491f, -0.02586076f, -0.10763434f, 0.00307156f, 0.09690935f, 
    -0.05861999f, -0.08520237f, -0.02751534f, 0.05647297f, -0.10955723f, -0.03194103f, -0.03405898f, -0.10798697f, 
    0.44217053f, 0.04873887f, -0.07651607f, 0.00101160f, 0.17385820f, 0.12838507f, -0.05232071f, -0.11878882f, 
    0.05025220f, 0.04032858f, -0.03349934f, -0.00698142f, -0.17004263f, 0.00156352f, -0.08070308f, 0.02534187f, 
    -0.06127627f, -0.04199295f, -0.05268659f, 0.05365986f, -0.08343671f, 0.00611377f, 0.01726703f, 0.08501802f, 
    0.09947498f, 0.11806747f, -0.01669299f, 0.19401196f, 0.03021126f, -0.03670953f, -0.20806466f, 0.08711743f, 
    -0.01357727f, -0.04798407f, 0.11376653f, 0.06559989f, 0.04935754f, -0.03731348f, 0.22069576f, -0.10005070f, 
    0.00755733f, 0.09393220f, 0.02103449f, -0.04877556f, 0.01591432f, -0.07119676f, 0.01382713f, -0.06964919f, 
    0.34569180f, -0.16591099f, -0.13481960f, -0.07495142f, 0.09243894f, 0.09161282f, 0.15304737f, -0.03243985f, 
    -0.01272945f, -0.09562811f, 0.04140037f, -0.01537741f, 0.04813978f, -0.08088620f, 0.00089312f, 0.29532751f, 
    0.08794656f, 0.16633829f, 0.02997091f, 0.00327226f, 0.10276807f, -0.18581228f, -0.05301141f, -0.00384976f, 
    0.15023425f, 0.04073017f, 0.04246853f, -0.07151209f, 0.11129573f, 0.01648291f, 0.12920435f, 0.00220953f, 
    0.00554243f, -0.04463015f, 0.10597156f, -0.04227009f, 0.09696361f, 0.11551178f, 0.07658280f, 0.01235494f, 
    0.19784679f, 0.20098746f, -0.10419382f, -0.05526984f, 0.03279189f, -0.03313453f, -0.12518589f, -0.03313790f, 
    0.62659067f, 0.22077850f, -0.19106486f, 0.01628411f, 0.07163585f, 0.08931143f, 0.00767487f, -0.08812966f, 
    -0.14354348f, -0.12897943f, -0.04769063f, -0.11714080f, 0.11583736f, 0.05051845f, -0.12677786f, 0.04998006f, 
    -0.07144469f, 0.00807297f, 0.04706090f, 0.00816084f, 0.02291648f, 0.00048613f, -0.00333015f, 0.23702490f, 
    -0.18457517f, -0.14264610f, -0.07619720f, 0.13793251f, -0.38319781f, -0.00227652f, 0.14116494f, -0.18232293f, 
    -0.11954601f, -0.05410640f, 0.04995291f, -0.02359187f, 0.05568695f, -0.06880702f, 0.16392621f, 0.02179802f, 
    0.00319028f, 0.05742191f, 0.27752656f, -0.08661713f, 0.07160181f, 0.14285947f, -0.03260934f, 0.12237792f, 
    0.14826939f, -0.10258556f, 0.20610283f, -0.09775309f, 0.06492802f, 0.03929039f, -0.03062155f, -0.02805080f, 
    0.02249599f, 0.03283049f, 0.26829758f, -0.20518623f, 0.25392047f, 0.01785911f, -0.13980488f, -0.02971195f, 
    -0.18573724f, 0.09128137f, -0.07978581f, 0.01197228f, -0.03030729f, 0.08530816f, -0.06594531f, 0.03872254f, 
    -0.06929065f, 0.25168383f, 0.06647916f, -0.12651554f, -0.02050938f, 0.02280273f, -0.05281172f, -0.05029060f, 
    0.02945581f, 0.00244241f, -0.12340362f, -0.02549192f, 0.19114366f, 0.09556506f, 0.08136157f, -0.19112474f, 
    0.02295130f, -0.02637052f, 0.07823822f, 0.07184064f, 0.02580925f, -0.00684562f, 0.09106751f, -0.09155092f, 
    -0.19729030f, -0.02819216f, 0.13632892f, 0.13119750f, 0.05653921f, -0.01941973f, 0.07978488f, 0.06012554f, 
    0.04210956f, 0.05138661f, 0.01387515f, 0.16341695f, 0.32575774f, -0.09517401f, -0.05940510f, -0.15434784f, 
    0.05155638f, 0.14007163f, 0.04287367f, -0.15944406f, 0.14500883f, -0.00787355f, 0.02580297f, 0.07652669f, 
    -0.00053288f, -0.08440972f, 0.11519664f, 0.39948758f, 0.03862581f, 0.09686039f, 0.04079328f, 0.07503195f, 
    0.03668433f, 0.08375289f, -0.13021465f, -0.17883185f, -0.03410162f, 0.27408072f, -0.05884865f, -0.10479256f, 
    0.10531676f, 0.11436012f, -0.12431623f, -0.07371780f, -0.08761343f, -0.00276482f, 0.01709264f, 0.05686679f, 
    -0.26924387f, 0.05378244f, 0.15743496f, -0.03173414f, 0.08390821f, -0.07804867f, 0.02306517f, 0.02461616f, 
    -0.15017590f, 0.10857309f, 0.00010144f, 0.10695044f, 0.28062657f, -0.30334380f, -0.01781700f, -0.03314747f, 
    0.08865283f, 0.00741551f, 0.07947934f, 0.12452337f, 0.03330341f, 0.13481133f, -0.01065295f, 0.06421831f, 
    0.04264642f, 0.33202311f, 0.17270263f, -0.09108806f, -0.03148439f, 0.10469624f, -0.09990959f, -0.05522726f, 
    -0.00455980f, -0.01697042f, -0.08789374f, 0.01000175f, 0.14393879f, 0.03248665f, 0.02241370f, 0.06535696f, 
    -0.05310963f, -0.03437085f, -0.09348524f, -0.13228080f, -0.08422300f, -0.09642439f, 0.03556706f, -0.19625846f, 
    0.30900544f, 0.07595028f, 0.00790604f, -0.13807809f, 0.01424863f, 0.03243161f, 0.13299949f, 0.07313395f, 
    -0.06524764f, -0.05167656f, -0.07802685f, -0.07266434f, -0.15887584f, -0.04112183f, 0.08099638f, -0.08935493f, 
    0.03677086f, -0.07764441f, -0.02304317f, 0.00233054f, 0.07560523f, 0.07376134f, 0.03940995f, 0.08137657f, 
    -0.09627715f, 0.07436746f, 0.03412605f, -0.13265848f, 0.00776819f, -0.01468739f, -0.09964100f, -0.00357091f, 
    0.10486562f, -0.03449407f, 0.01169729f, 0.12000287f, 0.24958582f, -0.05547536f, -0.13123159f, 0.17809981f, 
    -0.05907066f, -0.03987300f, -0.11458769f, 0.09861349f, -0.02664525f, 0.12801209f, -0.02268479f, 0.04595679f, 
    0.32681769f, -0.27910060f, -0.15952766f, -0.00124770f, -0.06813425f, -0.10200195f, 0.00662260f, 0.09576595f, 
    0.09764599f, -0.07355194f, -0.12104969f, 0.01763006f, -0.04594799f, 0.25749296f, -0.07528963f, -0.04798797f, 
    0.09725581f, -0.09933107f, -0.10502088f, 0.13492939f, 0.02894055f, -0.02244735f, 0.12972936f, 0.13767260f, 
    0.05801285f, -0.11097874f, 0.04551218f, 0.03530160f, 0.02288277f, -0.03463861f, 0.01023942f, 0.02580584f, 
    0.08548014f, 0.03534064f, -0.02229227f, 0.01688678f, 0.11169802f, -0.07991293f, 0.14153069f, 0.04517108f, 
    -0.00630763f, 0.02352545f, -0.11082395f, 0.12936299f, -0.11234617f, 0.01908600f, -0.03113275f, -0.02678043f, 
    0.10839342f, 0.00641442f, -0.03620424f, -0.03365568f, 0.03649236f, 0.12775043f, 0.01113288f, -0.05425927f, 
    0.12415162f, 0.16030195f, -0.01017512f, -0.01427799f, 0.19908623f, -0.16457011f, -0.01539941f, -0.03129637f, 
    -0.06594912f, -0.04362904f, -0.07823797f, 0.02205653f, -0.11091751f, -0.04791060f, 0.15921786f, -0.04055758f, 
    0.13506792f, 0.01014164f, -0.01484020f, 0.00829428f, 0.04219560f, -0.10523032f, -0.11975358f, 0.00016147f, 
    0.05815300f, -0.17252147f, 0.10482244f, 0.09488058f, 0.12511133f, -0.10188366f, 0.20472895f, -0.01414873f, 
    0.08297142f, 0.03286892f, 0.05643861f, 0.09452649f, -0.01915302f, -0.17321184f, -0.00921526f, -0.03503224f, 
    0.00030976f, 0.13548936f, -0.13339666f, -0.12967750f, 0.15277560f, 0.05384268f, 0.00335958f, -0.09637600f, 
    0.04159389f, -0.01960706f, 0.17389612f, -0.11477786f, -0.14598931f, 0.23354790f, 0.01872646f, 0.17405435f, 
    -0.03276106f, 0.14011788f, 0.01395909f, 0.12547487f, 0.09644116f, -0.09278963f, -0.03159141f, -0.14520130f, 
    0.27372953f, 0.13094956f, -0.07145340f, 0.02293818f, -0.00803625f, 0.01869539f, 0.16364853f, 0.03622153f, 
    -0.00818460f, -0.00640042f, 0.10117824f, -0.00915657f, 0.18113099f, 0.33042037f, 0.05203029f, -0.04502519f, 
    0.10056997f, 0.05714800f, -0.01129402f, -0.07278150f, 0.10984708f, -0.00177137f, 0.03662100f, -0.01488235f, 
    0.26274222f, 0.17211911f, -0.11457947f, -0.03069950f, 0.10112436f, -0.01194021f, 0.06326660f, -0.16053590f, 
    -0.08675051f, -0.12002952f, -0.09110475f, -0.05670201f, -0.03821127f, -0.25285339f, 0.09221742f, 0.08904878f, 
    -0.19427782f, 0.03926620f, -0.05938319f, 0.00447975f, 0.08713692f, 0.15358338f, -0.12019140f, 0.22647899f, 
    -0.29387906f, 0.02681638f, -0.01004463f, -0.02345593f, -0.14359865f, 0.09813331f, 0.08076590f, 0.00981129f, 
    0.05534907f, -0.08885231f, -0.11088888f, -0.22676009f, 0.14123237f, 0.22360906f, -0.07234237f, -0.08683024f, 
    -0.05413850f, 0.08455347f, 0.05547979f, 0.04408014f, 0.12530503f, 0.27392483f, 0.05596997f, 0.06010308f, 
    0.02836838f, 0.14050947f, -0.18331918f, -0.05205010f, 0.02054688f, -0.00594055f, 0.01497653f, 0.06105794f, 
    0.20461357f, 0.09221251f, -0.02669641f, 0.01743772f, 0.01817478f, -0.17312267f, -0.03472805f, -0.07750928f, 
    0.04403990f, 0.00277369f, -0.03917077f, -0.11709794f, 0.00599792f, 0.01668925f, 0.09814028f, 0.03684827f, 
    0.23479033f, -0.23867668f, 0.18290682f, -0.00617847f, 0.05411817f, 0.19214287f, -0.11303765f, -0.00829512f, 
    0.02771536f, 0.10885089f, -0.01496818f, 0.00196086f, 0.08057465f, -0.07431617f, -0.04513538f, 0.02180102f, 
    0.03908851f, -0.14962758f, 0.05376884f, 0.11827459f, -0.02308160f, -0.05705415f, -0.04549505f, 0.09679133f, 
    0.33983174f, 0.14758976f, 0.06699809f, 0.09229547f, 0.04670624f, 0.08014917f, -0.00124316f, 0.05541598f, 
    0.03690181f, 0.00508384f, -0.02189103f, 0.14195020f, 0.24523538f, -0.05074184f, -0.14762275f, -0.12911884f, 
    -0.06626132f, 0.14329755f, -0.00558809f, -0.01709119f, -0.00962194f, 0.00586929f, 0.02995987f, 0.09912813f, 
    0.20552248f, 0.00094802f, 0.11285256f, 0.27299616f, 0.10153440f, 0.09645090f, -0.08136243f, 0.08609562f, 
    -0.03248633f, 0.05845726f, -0.06059192f, -0.27408624f, 0.15140025f, 0.08781077f, -0.26068774f, -0.06162919f, 
    0.05101009f, -0.01841889f, -0.14281829f, -0.09866958f, -0.04898573f, 0.02816937f, 0.10014791f, 0.05191108f, 
    -0.15118153f, -0.03416605f, 0.08158927f, -0.05742572f, 0.06012084f, -0.01773767f, -0.05146312f, -0.04279637f, 
    0.01921026f, 0.12142168f, -0.08652633f, 0.08533566f, 0.19501983f, 0.01757169f, -0.07112340f, 0.02565159f, 
    0.02283959f, -0.06992742f, 0.10313655f, 0.03173128f, 0.16972652f, 0.03355275f, -0.04725761f, 0.09721987f, 
    0.15609162f, 0.36033559f, 0.04786906f, -0.16077755f, -0.11192922f, 0.05646807f, -0.00607968f, -0.01994197f, 
    0.05768030f, 0.07304715f, -0.15784398f, -0.03209516f, -0.06793100f, 0.08983199f, -0.14538360f, -0.00320942f, 
    0.00862646f, -0.02185781f, -0.07682332f, -0.11066556f, -0.05306150f, -0.09349180f, 0.11019048f, -0.15146394f, 
    0.20355859f, 0.07084277f, 0.23052408f, 0.13840537f, -0.02418558f, -0.16462503f, 0.06778840f, 0.10287689f, 
    0.07140899f, 0.01719269f, -0.04785444f, -0.06370913f, -0.17425615f, -0.32387382f, -0.08412760f, -0.00495222f, 
    0.08032610f, -0.00983449f, -0.17257963f, -0.06998903f, -0.08562179f, 0.06539713f, 0.10046938f, 0.13818102f, 
    -0.06116218f, -0.08173010f, -0.02859037f, -0.07502948f, 0.07838663f, 0.08214993f, -0.09085292f, 0.03824409f, 
    -0.06879379f, 0.06811557f, 0.12010688f, 0.05647638f, 0.17368825f, -0.13064775f, 0.04751821f, -0.13177200f, 
    0.16140823f, 0.09842374f, 0.05517958f, 0.00988856f, 0.13382563f, 0.08064149f, -0.03434882f, 0.03818293f, 
    0.13874881f, 0.09270127f, 0.05918402f, 0.10222219f, 0.03001318f, -0.02458621f, 0.15115370f, 0.05240882f, 
    0.02720512f, -0.03751538f, 0.08464942f, -0.08998238f, 0.27782634f, 0.19312987f, 0.05559759f, -0.14282887f, 
    0.20306401f, 0.08907633f, 0.05613300f, -0.00481548f, 0.15615845f, 0.05059240f, 0.14206880f, 0.04546170f, 
    0.21432084f, -0.26220578f, -0.11011178f, -0.14875787f, 0.21743713f, -0.01697948f, -0.02613653f, -0.07034014f, 
    0.20177685f, 0.12103140f, 0.02949341f, -0.05582410f, -0.12596120f, 0.34080759f, -0.23767306f, 0.06566858f, 
    0.16478984f, 0.07730714f, 0.11022392f, 0.04895567f, 0.09818160f, 0.03732798f, 0.10349273f, 0.01612443f, 
    -0.16639850f, -0.03385793f, 0.24143638f, -0.05599444f, -0.08017294f, -0.01417215f, -0.06227791f, -0.14004576f, 
    -0.08505689f, 0.00341330f, -0.08908311f, 0.12556513f, 0.11651650f, -0.19490376f, -0.16702667f, -0.04536508f, 
    0.12478290f, -0.03541927f, -0.03513934f, -0.00578544f, 0.10359158f, -0.01802401f, 0.08310183f, 0.12877636f, 
    -0.18845877f, -0.14252757f, 0.11039637f, -0.16552784f, 0.02423005f, -0.08849817f, -0.15530926f, 0.09460638f, 
    0.09410702f, 0.08712682f, 0.06252416f, 0.11029317f, -0.23577693f, 0.15828644f, -0.30595583f, 0.23989815f, 
    -0.07237719f, -0.14553015f, 0.07356244f, 0.00495683f, 0.27799654f, 0.04919956f, -0.02704450f, 0.14725944f, 
    0.02054721f, 0.02782254f, -0.04144973f, 0.21584119f, -0.08370326f, 0.01248613f, -0.05131604f, 0.14753164f, 
    0.02678890f, -0.04863834f, 0.08919494f, -0.06161008f, -0.12436125f, -0.04437474f, -0.01294678f, 0.05064976f, 
    -0.25455049f, -0.04708220f, 0.03241108f, -0.06300670f, 0.03702160f, -0.09583644f, 0.12198605f, -0.00651560f, 
    -0.22018252f, 0.04434329f, -0.06387585f, -0.13481840f, -0.08884004f, -0.02424001f, 0.10732208f, 0.13845624f, 
    -0.00642211f, 0.00898005f, -0.00682100f, 0.01772881f, 0.01205131f, -0.04275681f, 0.02237281f, -0.09192575f, 
    -0.22825377f, -0.13231058f, -0.09065107f, -0.09916477f, -0.00143444f, -0.02989295f, 0.00052095f, -0.12053391f, 
    0.19714768f, -0.01413349f, 0.02084688f, -0.16060796f, 0.08211149f, -0.08730161f, 0.01104979f, 0.02582717f, 
    0.08377022f, -0.07847784f, -0.05284013f, -0.01833247f, -0.01790427f, -0.21423753f, -0.31784412f, -0.09271626f, 
    0.16047610f, 0.05242443f, 0.06547177f, -0.06265672f, -0.01784903f, 0.08310758f, -0.04675898f, 0.00818203f, 
    -0.02433906f, 0.07820486f, 0.10200303f, 0.14805919f, 0.12207681f, -0.04815294f, -0.02064033f, 0.02066165f, 
    0.09670427f, 0.11079941f, 0.09711143f, -0.08680369f, 0.12353610f, 0.04447988f, 0.06603108f, 0.13063096f, 
    -0.01062049f, -0.04958693f, -0.00883535f, 0.12890257f, -0.05563810f, 0.10372835f, -0.01591605f, -0.00862446f, 
    0.01537529f, 0.01150419f, -0.26370350f, 0.01249039f, 0.12962359f, -0.01077381f, 0.09689885f, 0.06775551f, 
    0.12092952f, -0.01415451f, 0.16100352f, 0.01647588f, -0.19971398f, 0.00789031f, -0.27676463f, 0.11598124f, 
    -0.04313666f, 0.02017923f, 0.05286385f, -0.13965878f, 0.01348404f, 0.07320435f, 0.04880423f, 0.15411474f, 
    -0.24939919f, 0.27540538f, -0.01988250f, 0.19082230f, -0.01368352f, -0.11707590f, -0.11102428f, 0.19146658f, 
    0.00748392f, 0.06821559f, -0.10216270f, 0.03729087f, -0.08534603f, -0.03729072f, -0.18095285f, 0.06133908f, 
    0.06484647f, 0.03884304f, 0.10615776f, 0.03827921f, 0.20329912f, 0.07841098f, 0.08398004f, -0.04952249f, 
    0.28443965f, 0.18786274f, -0.04181805f, -0.08318730f, 0.02324667f, -0.00203911f, -0.02483725f, -0.00285434f, 
    -0.04287818f, 0.06995782f, 0.16253556f, 0.01702705f, 0.07539579f, 0.19653143f, -0.00475010f, -0.03667032f, 
    -0.17983365f, 0.12078686f, -0.04381169f, 0.00487494f, -0.00037848f, -0.02167914f, 0.10352270f, 0.06288227f, 
    -0.14792579f, -0.10188378f, -0.25599274f, -0.08049026f, -0.07112578f, -0.11894863f, -0.01210621f, -0.10943213f, 
    0.05896739f, -0.02832373f, 0.13235380f, 0.04668433f, -0.06765390f, 0.03630478f, 0.02650821f, -0.27348024f, 
    -0.02188980f, 0.00083167f, -0.06653076f, -0.14428434f, -0.04674563f, -0.11103576f, 0.11573805f, -0.11068036f, 
    -0.11731711f, 0.05385528f, -0.06263109f, -0.04233043f, 0.24522419f, 0.11280562f, 0.03001324f, 0.01893515f, 
    0.11312959f, 0.17227049f, -0.06380568f, 0.16585620f, 0.35498592f, 0.06026360f, -0.39189076f, -0.07219838f, 
    0.05759748f, -0.03847186f, 0.01068795f, 0.08287079f, -0.03028904f, -0.01826733f, 0.08417583f, 0.04465082f, 
    0.23260385f, -0.04974968f, -0.02638135f, 0.08558748f, -0.00615442f, -0.10602464f, -0.07486082f, 0.12069692f, 
    -0.06980292f, 0.08739804f, -0.04179698f, -0.15935785f, 0.09783158f, -0.12390798f, -0.25275496f, -0.10861354f, 
    0.18946490f, -0.03846851f, -0.13119437f, -0.13882869f, 0.12440208f, 0.07205263f, 0.06933432f, -0.09009263f, 
    0.04397611f, -0.02477386f, -0.03948639f, 0.00163065f, 0.03820683f, 0.00536643f, -0.01909343f, 0.01040393f, 
    -0.02482736f, 0.00985600f, -0.04780211f, -0.01878502f, -0.01515926f, 0.02505638f, -0.00207961f, -0.03588749f, 
    0.02720188f, 0.01316135f, 0.01323714f, -0.03379706f, -0.00528828f, -0.00296605f, -0.03069852f, 0.02760254f, 
    -0.04674093f, -0.04806508f, -0.04456004f, -0.03103803f, -0.05213993f, 0.02275651f, 0.02592688f, -0.03789266f, 
    0.02615251f, -0.00527676f, 0.00767577f, -0.02351006f, -0.04945230f, -0.01120871f, 0.00614897f, 0.01685679f, 
    -0.04888968f, -0.02329505f, -0.02861812f, 0.01587718f, -0.00112470f, -0.00784135f, -0.03977895f, 0.03033238f, 
    0.00835538f, -0.00390531f, 0.00889387f, -0.02421865f, 0.02129687f, 0.03420669f, 0.04398734f, -0.00109571f, 
    0.03563706f, 0.02678505f, -0.01535292f, -0.03745318f, 0.03064581f, 0.04381591f, -0.04067838f, -0.04581984f, 
    -0.01509122f, 0.01289625f, 0.01487438f, -0.04887568f, -0.04948485f, -0.00895634f, -0.04072069f, -0.02786594f, 
    -0.04259835f, 0.02110187f, -0.03604494f, -0.03919459f, 0.03363675f, -0.00487288f, -0.01835593f, 0.03315197f, 
    -0.03665118f, -0.01930865f, -0.03672179f, -0.03521160f, 0.02290831f, -0.04439837f, 0.04617346f, -0.02995235f, 
    0.02817727f, 0.02054777f, 0.01185954f, 0.02210724f, -0.02970852f, -0.01702958f, -0.01400423f, 0.01455447f, 
    0.05293085f, -0.05680197f, -0.05189537f, 0.04384010f, 0.00897031f, -0.02027208f, -0.00011516f, -0.01322986f, 
    0.00876543f, -0.02478075f, -0.00342304f, -0.01408084f, 0.01827244f, -0.03438038f, 0.00444639f, -0.02243404f, 
    -0.00381570f, 0.03347132f, -0.00636488f, 0.04058145f, -0.00806108f, 0.00487487f, -0.01606712f, 0.00560804f, 
    -0.04619227f, 0.00274528f, 0.04910216f, -0.01814665f, -0.00925052f, -0.03512423f, 0.00717252f, -0.03260536f, 
    -0.03414859f, 0.02307186f, -0.05220551f, -0.01585213f, -0.01548055f, 0.01080340f, -0.01467187f, -0.03679381f, 
    0.01263089f, 0.01079199f, 0.03298732f, 0.03412043f, 0.00327860f, -0.01643900f, 0.00265503f, -0.03987361f, 
    0.04203401f, -0.04124420f, -0.00933484f, 0.04082566f, 0.01427446f, 0.03701475f, 0.02435953f, 0.02994011f, 
    0.04179269f, 0.00549187f, -0.01489898f, -0.00671212f, -0.02627585f, -0.04101105f, 0.03024526f, -0.03030387f, 
    0.04372012f, -0.02931869f, 0.04525271f, -0.03891526f, -0.00308952f, -0.03470651f, -0.02895143f, -0.01782398f, 
    -0.00947886f, -0.04365782f, 0.00215023f, 0.02617508f, 0.01420404f, 0.01021108f, 0.04273863f, 0.03623252f, 
    -0.03453498f, 0.00375014f, 0.00535568f, 0.01339515f, 0.03566860f, 0.03335995f, -0.05085253f, 0.03147286f, 
    -0.01370540f, -0.04176562f, 0.02774950f, -0.01053893f, 0.01508171f, -0.03661640f, -0.01516898f, 0.02657025f, 
    -0.02033659f, -0.03698120f, 0.02283644f, 0.00018785f, 0.01747741f, 0.00525178f, 0.02708950f, 0.03248744f, 
    0.03625183f, 0.03676934f, -0.03208623f, -0.05713379f, 0.00919551f, 0.03770219f, 0.02852377f, 0.01880379f, 
    -0.03819152f, -0.05324451f, -0.00646785f, -0.01537857f, -0.00629923f, -0.04098603f, 0.02612622f, 0.00555642f, 
    -0.04629694f, -0.01844074f, -0.02724267f, 0.01825199f, 0.00384995f, 0.02044640f, 0.04217769f, -0.04286705f, 
    -0.01752767f, -0.03349344f, -0.02127495f, -0.02995612f, -0.03705369f, -0.01401385f, 0.02222711f, -0.03641838f, 
    -0.01360756f, -0.01935607f, 0.02231715f, 0.02306901f, -0.00115115f, -0.01675157f, -0.02611678f, -0.05482884f, 
    -0.04650770f, -0.03541052f, -0.05265122f, 0.03327966f, -0.01654665f, -0.00614132f, -0.01538050f, 0.02637632f, 
    -0.04777139f, -0.01620930f, -0.05590102f, 0.02723596f, 0.00318840f, -0.03006621f, 0.03832638f, 0.00585349f, 
    -0.03142601f, 0.03085843f, 0.00777977f, -0.01028895f, -0.00373725f, -0.01737490f, -0.00449459f, -0.01739152f, 
    0.01361644f, 0.01060384f, -0.01330768f, -0.04329743f, -0.01652576f, -0.01161516f, 0.00525368f, -0.01680780f, 
    0.00052617f, -0.04973581f, -0.03304004f, 0.01757127f, -0.01857272f, 0.03679762f, -0.04687416f, -0.03403492f, 
    0.02906777f, -0.04361233f, -0.01803829f, 0.01480608f, -0.00321630f, -0.00095998f, 0.00079418f, 0.04201390f, 
    -0.03557025f, 0.00842160f, -0.01392804f, 0.03964602f, 0.04151809f, 0.01764558f, -0.04687181f, 0.02996556f, 
    0.03966585f, -0.04801710f, -0.01137399f, 0.01468297f, 0.05096658f, -0.03407398f, 0.02062732f, -0.00994925f, 
    -0.00951099f, 0.01438899f, 0.04164438f, -0.02595793f, 0.01287035f, 0.04039640f, -0.04298928f, -0.03308510f, 
    -0.05275784f, -0.00050224f, -0.01485865f, -0.01030135f, -0.03827018f, 0.04398934f, -0.03187540f, -0.04990008f, 
    0.02284737f, -0.03696810f, 0.03114094f, 0.00129141f, 0.03498287f, 0.01846969f, 0.03059384f, -0.03992064f, 
    0.01331307f, 0.02591842f, -0.04136853f, -0.05136250f, -0.05506952f, 0.03510623f, -0.00402417f, -0.01147243f, 
    -0.03969044f, 0.00895083f, 0.05139225f, -0.00875615f, -0.01937108f, -0.00100125f, 0.01256131f, -0.04902341f, 
    0.01923251f, 0.02201949f, 0.01347208f, -0.05537834f, 0.02684606f, 0.03434363f, 0.00591294f, -0.01583163f, 
    -0.00976444f, 0.04636367f, -0.01970232f, 0.01735904f, 0.00223039f, -0.01655288f, 0.01027473f, -0.03218774f, 
    0.00245627f, -0.03460292f, 0.00106001f, -0.03875256f, -0.01368564f, 0.01677605f, -0.02802011f, -0.03728985f, 
    -0.01693709f, 0.00170236f, 0.01466434f, 0.01023439f, -0.01864585f, 0.01259764f, 0.02920505f, -0.02250802f, 
    -0.02007051f, 0.00588420f, -0.03104858f, -0.01727630f, -0.01648946f, 0.01131123f, -0.02201333f, -0.05218272f, 
    -0.05266265f, 0.02820615f, -0.04969456f, -0.04240701f, -0.02210806f, -0.02988584f, -0.04759746f, -0.02496280f, 
    -0.05930472f, -0.01740144f, 0.03182296f, -0.01096979f, -0.04711404f, 0.04837558f, -0.05515963f, 0.01011218f, 
    0.01740457f, -0.00527434f, 0.01141936f, 0.03022872f, -0.03974112f, -0.04324259f, -0.02073219f, -0.00289806f, 
    -0.02740517f, -0.02222570f, -0.02727626f, 0.03228242f, -0.04500258f, 0.04692035f, -0.02674102f, -0.03464902f, 
    0.02372664f, -0.00869493f, 0.00590735f, 0.03273822f, -0.04108457f, -0.05112177f, 0.00938198f, -0.01573291f, 
    0.00428380f, 0.01911527f, -0.05801417f, -0.04957176f, 0.02635686f, -0.04240252f, -0.00332843f, -0.02806987f, 
    0.01960995f, 0.01381813f, -0.04848198f, -0.05915123f, -0.04267900f, -0.04677545f, -0.00423510f, 0.01957423f, 
    -0.01863873f, 0.00083088f, -0.03545194f, 0.02568547f, -0.05308233f, 0.03867996f, 0.02096547f, -0.03878932f, 
    -0.04375288f, 0.03037008f, -0.05662749f, -0.00957667f, 0.00520631f, -0.04412096f, 0.03068090f, -0.00000289f, 
    -0.04180454f, 0.03131445f, -0.01434545f, -0.01791079f, 0.01579745f, -0.03109810f, 0.02357372f, 0.00442643f, 
    0.02938299f, 0.03298584f, 0.02645563f, 0.02252710f, -0.00103676f, 0.01656144f, -0.00435438f, 0.01284761f, 
    0.00043484f, -0.04599234f, -0.02771630f, 0.02072287f, -0.00309494f, 0.01342736f, 0.02203356f, -0.04433029f, 
    -0.02901651f, 0.03254282f, 0.03176786f, -0.00606437f, -0.04021196f, -0.02377300f, -0.03214681f, -0.02460869f, 
    -0.03715760f, -0.03180281f, 0.03148478f, 0.02267263f, -0.02210677f, -0.03182300f, -0.01592506f, -0.00232299f, 
    0.00899882f, -0.04267908f, -0.03550876f, -0.05591166f, 0.00130900f, 0.03011069f, -0.04153018f, 0.04344245f, 
    0.02857224f, 0.03892357f, 0.03212275f, 0.01703289f, 0.01171273f, -0.04727248f, 0.02273224f, 0.03781208f, 
    -0.02716517f, -0.01234933f, 0.02810805f, 0.03228253f, -0.03487733f, -0.00639007f, -0.00121537f, -0.05396778f, 
    0.02653537f, 0.00496704f, -0.01302843f, 0.03598872f, -0.02912323f, -0.02114875f, 0.00652633f, 0.00055108f, 
    -0.05159256f, 0.00352766f, -0.05118931f, -0.03408601f, -0.00243225f, -0.01423825f, -0.04285632f, -0.03129768f, 
    0.04115372f, 0.00746543f, 0.00880656f, 0.01608311f, -0.02878019f, 0.02248853f, 0.02356670f, -0.01730687f, 
    0.02619554f, 0.00993118f, 0.03313210f, -0.03072934f, -0.04157319f, -0.01290215f, 0.01593707f, 0.03525475f, 
    -0.03754316f, 0.00975428f, 0.03288772f, 0.01600752f, -0.03666603f, 0.00012772f, 0.02430569f, -0.01283211f, 
    -0.04408109f, -0.05774861f, -0.05257469f, -0.03798458f, 0.00562299f, 0.02799584f, 0.03905775f, 0.03400492f, 
    -0.03848314f, 0.00006815f, -0.01732492f, 0.00120204f, 0.00806014f, -0.05730241f, 0.03778386f, -0.00955762f, 
    0.00748149f, -0.03908608f, -0.00815361f, -0.04711377f, 0.04032983f, 0.03091653f, -0.02925809f, -0.05397850f, 
    0.01622242f, -0.05175987f, -0.02064821f, -0.03200850f, -0.03093815f, 0.01818573f, -0.04189769f, -0.03002288f, 
    -0.02082633f, 0.05098274f, -0.01663825f, 0.03613961f, -0.00677676f, -0.00046093f, -0.02607186f, -0.05211372f, 
    -0.01766235f, 0.01831377f, -0.00697389f, -0.02715892f, -0.01766397f, -0.03221817f, -0.03052581f, -0.05173809f, 
    -0.04172422f, -0.03701516f, 0.02024728f, -0.03588325f, -0.03071765f, -0.05875048f, -0.00593419f, 0.02345794f, 
    0.02946610f, -0.03798205f, 0.02023226f, 0.03681181f, -0.03954287f, 0.00297007f, -0.05503862f, 0.00479341f, 
    0.00271007f, -0.00758383f, 0.00630593f, -0.04770692f, -0.00593909f, -0.01798597f, -0.03433772f, 0.04662936f, 
    -0.01256502f, 0.00759452f, 0.00304717f, -0.03300997f, -0.02820813f, -0.04675772f, -0.03759959f, -0.01354544f, 
    0.04157526f, 0.04068258f, 0.04061391f, -0.00713013f, 0.00310370f, -0.04880759f, -0.01188304f, -0.05792926f, 
    -0.02199582f, -0.04952369f, -0.05497936f, -0.02585335f, -0.00410283f, 0.00562383f, -0.04622794f, -0.05644844f, 
    -0.03697957f, -0.01440373f, -0.03457293f, 0.00534834f, 0.03638957f, 0.01394879f, -0.02650382f, 0.02589685f, 
    -0.03829924f, -0.01382739f, 0.03593261f, 0.02424416f, 0.02474744f, -0.04108269f, -0.04349539f, -0.04790207f, 
    -0.00857748f, -0.04898074f, -0.01213515f, -0.00794225f, 0.01127794f, -0.02671200f, 0.00289861f, 0.03729259f, 
    -0.01196207f, -0.01375317f, 0.02386681f, -0.02123078f, 0.00057144f, -0.00493971f, 0.01384182f, -0.04507441f, 
    -0.01125755f, 0.03858150f, -0.02839907f, -0.01817455f, 0.01151822f, -0.03899135f, -0.00220530f, -0.00199932f, 
    -0.00515199f, 0.03173834f, -0.01645047f, -0.02857935f, 0.01879421f, -0.05694827f, 0.03074118f, -0.02756909f, 
    0.02696543f, 0.03258758f, -0.00988468f, -0.00355671f, -0.01469518f, 0.03443234f, -0.02714765f, -0.00083908f, 
    0.00075690f, 0.02589505f, -0.02412145f, 0.02267971f, 0.04025793f, -0.00716829f, 0.01116197f, -0.03142984f, 
    0.03747753f, 0.04091275f, -0.05608300f, -0.00731213f, -0.00095292f, -0.02550652f, 0.01248519f, 0.03387358f, 
    0.01891956f, 0.03435508f, 0.04656712f, -0.00272459f, -0.03621158f, -0.05285195f, -0.01067831f, -0.02823827f, 
    0.04036113f, 0.01486487f, -0.01876120f, -0.00945165f, -0.01840313f, -0.00999840f, -0.05567784f, -0.05081822f, 
    0.02840830f, 0.01475270f, -0.02984668f, 0.00327376f, 0.02824740f, -0.05512522f, 0.01577285f, -0.03454225f, 
    0.01801608f, -0.03464605f, -0.05053059f, -0.04959902f, -0.01130098f, 0.03572621f, -0.03347728f, -0.01074085f, 
    -0.05035290f, 0.00996884f, -0.04135260f, -0.01067290f, -0.03648270f, -0.05647916f, -0.04204140f, -0.02979171f, 
    -0.41503426f, 0.18175450f, -0.18105109f, -0.11594877f, 0.24582672f, -0.03142970f, 0.16319534f, 0.12767358f, 
    0.06269943f, 0.11132230f, 0.14049666f, 0.01417312f, 0.07158243f, 0.11611472f, 0.13230692f, -0.22764134f, 
    -0.02500021f, 0.08635125f, -0.08134858f, 0.13550198f, 0.07540629f, 0.10581835f, 0.10370772f, 0.24988024f, 
    0.23972423f, 0.15212487f, 0.19636659f, 0.04376031f, 0.18472444f, 0.22655278f, -0.12776178f, 0.01060896f, 
    0.16149463f, 0.08609263f, 0.10835561f, 0.12329467f, -0.02308859f, -0.06623098f, 0.12649302f, 0.18177299f, 
    0.10832079f, 0.14385901f, 0.09443941f, 0.11526889f, -0.03284985f, 0.03336736f, 0.07751512f, 0.13032568f, 
    -0.28276634f, -0.07013382f, 0.06518483f, 0.04145660f, 0.21431106f, 0.23767425f, 0.11112510f, 0.20987101f, 
    0.24949478f, 0.04061464f, 0.06763572f, -0.05072242f, 0.35089946f, 0.13243732f, 0.29744267f, 0.17911550f, 
    0.03893331f, -0.01581642f, 0.01067258f, 0.06459562f, 0.18649559f, -0.05736639f, 0.02242798f, 0.06350779f, 
    0.17559078f, 0.10256454f, 0.05597302f, -0.08976506f, 0.07756303f, 0.06038093f, -0.05330935f, 0.01278229f, 
    -0.00141133f, 0.09971374f, 0.07567611f, 0.08687999f, -0.17325640f, -0.06129085f, -0.00089823f, 0.34272686f, 
    0.05685438f, -0.00193971f, 0.12335079f, 0.16934371f, 0.09994658f, 0.06377050f, 0.08123414f, -0.02647160f, 
    0.17007722f, -0.31703421f, 0.15000142f, -0.05248275f, 0.09912967f, 0.11718589f, -0.02434398f, -0.06380761f, 
    0.08292589f, 0.16504157f, 0.05302694f, 0.12095787f, -0.07860342f, 0.19562417f, 0.12169527f, -0.35628083f, 
    0.14641184f, -0.09392973f, 0.02144768f, 0.09079941f, 0.10657558f, 0.08640522f, -0.05742797f, 0.15862463f, 
    0.05957825f, 0.16131406f, 0.08884601f, -0.11308412f, 0.18641755f, -0.28861400f, -0.02090663f, 0.05976737f, 
    0.07122552f, 0.04340469f, 0.19669698f, 0.24236500f, -0.07629376f, 0.05727522f, 0.00266981f, 0.00831135f, 
    -0.03485503f, -0.00915389f, 0.05642605f, 0.06433745f, 0.09371512f, -0.13890666f, 0.13638707f, 0.01049155f, 
    0.06997071f, -0.57142901f, -0.09105562f, -0.24520791f, 0.00444216f, 0.17992803f, 0.22073594f, 0.07072405f, 
    0.01692927f, 0.04876954f, -0.02121139f, 0.07463994f, -0.13399500f, -0.18989880f, -0.26251754f, 0.16133587f, 
    0.04161767f, 0.17445239f, -0.11655923f, 0.06550375f, 0.08277415f, -0.00696846f, 0.04444088f, 0.07886243f, 
    0.13818617f, -0.06223341f, -0.03064493f, 0.09890555f, -0.02891874f, -0.03559263f, -0.01292315f, 0.03210275f, 
    0.09147345f, 0.07163572f, 0.06227715f, 0.01973223f, 0.04908188f, -0.23813908f, -0.16345863f, -0.08062278f, 
    0.14265960f, 0.15432447f, -0.01194922f, -0.00067947f, -0.00007964f, 0.08647473f, -0.04841243f, 0.02815090f, 
    0.22842273f, -0.40770862f, -0.22178349f, 0.02234497f, -0.04309146f, -0.01442418f, 0.09805382f, 0.02002044f, 
    -0.00456104f, -0.06951486f, 0.05132226f, -0.05266655f, 0.15989503f, 0.21221381f, -0.09194246f, -0.21498744f, 
    0.19154210f, 0.04622043f, 0.07322960f, -0.01676532f, -0.00099545f, -0.01381240f, 0.00545881f, 0.16851483f, 
    -0.10970585f, -0.10789882f, -0.09081540f, 0.20016356f, -0.06192682f, 0.03348447f, 0.10269149f, 0.09708645f, 
    0.05267455f, -0.08528282f, 0.03130424f, 0.02110198f, -0.31159312f, -0.37423575f, -0.03065477f, 0.01099230f, 
    0.15202168f, 0.03657694f, 0.25019488f, -0.04343614f, 0.06607150f, 0.07915588f, -0.05645365f, 0.00175418f, 
    0.10075389f, -0.00500160f, 0.10641915f, -0.18537827f, 0.03101790f, 0.15987968f, 0.17872861f, 0.02956500f, 
    0.02953199f, 0.05948896f, 0.25489837f, -0.03911894f, 0.19302338f, 0.06820222f, 0.05626406f, 0.47898927f, 
    0.07586234f, 0.20197506f, 0.05240682f, 0.05178095f, 0.27668309f, 0.09650852f, 0.03422161f, 0.06060224f, 
    -0.20740384f, 0.00202684f, -0.17479882f, -0.03188855f, 0.10479993f, -0.06199331f, 0.12514336f, 0.07497182f, 
    0.00071278f, -0.00879480f, 0.03076387f, 0.04276095f, 0.35324717f, 0.22748123f, 0.21202709f, 0.18840721f, 
    -0.02544633f, 0.02207379f, 0.16049775f, 0.05676419f, 0.17770113f, -0.01548111f, 0.02355287f, 0.03647087f, 
    -0.51211965f, -0.09426477f, -0.25568175f, 0.07592576f, 0.07595633f, 0.00920667f, -0.02242226f, 0.04007334f, 
    0.06593072f, 0.07739045f, 0.27112830f, 0.01691253f, 0.05363131f, -0.18162929f, 0.04905552f, 0.14188541f, 
    0.16544661f, 0.22401844f, 0.08494531f, 0.00329384f, 0.25321767f, 0.05577040f, -0.03852878f, -0.05405967f, 
    0.02484621f, 0.03432647f, 0.00283355f, 0.30975828f, -0.03846383f, 0.10158195f, 0.25086626f, 0.09845957f, 
    0.06164003f, 0.09683432f, 0.12523690f, 0.04508047f, -0.04292589f, -0.18236506f, 0.36304787f, 0.12061150f, 
    0.01749348f, 0.30246249f, 0.05974579f, -0.03636874f, 0.12881954f, 0.04270243f, 0.14361146f, 0.16502240f, 
    0.00925507f, -0.07408219f, 0.33531034f, 0.36560163f, 0.19029190f, -0.02554370f, 0.12840247f, 0.03914000f, 
    -0.01686883f, 0.13837066f, 0.17218405f, 0.10715151f, -0.01229348f, -0.01454833f, 0.00312458f, 0.11875530f, 
    0.05025395f, -0.01184801f, 0.11523467f, 0.15033117f, 0.03293165f, 0.09413706f, 0.04596616f, 0.00639121f, 
    -0.23652092f, -0.23764800f, -0.30883723f, -0.17611389f, 0.15671411f, 0.12836272f, 0.10351662f, 0.07562798f, 
    -0.05680832f, 0.03200856f, 0.05473734f, 0.04539230f, 0.10101952f, 0.10082390f, 0.11130878f, -0.19133851f, 
    0.01166532f, -0.09273471f, -0.02404897f, 0.06216228f, 0.07248206f, -0.03669284f, -0.01045030f, 0.11044720f, 
    -0.03313192f, -0.03846948f, -0.00624699f, -0.00419343f, -0.04689945f, 0.02136249f, -0.03838474f, -0.04527859f, 
    -0.03370067f, 0.04609458f, 0.01847361f, 0.00023399f, -0.00892884f, 0.02788583f, 0.02580118f, -0.01013088f, 
    -0.01709159f, 0.00713543f, 0.01677313f, -0.04638815f, -0.00324386f, 0.01176282f, -0.01432094f, -0.00792110f, 
    -0.02367126f, -0.02371835f, 0.01802736f, -0.04173691f, 0.01269217f, -0.05643716f, -0.01099459f, -0.04143462f, 
    -0.03937594f, -0.01292679f, -0.04259592f, 0.00116738f, 0.00059119f, 0.04563482f, 0.02651725f, -0.03413390f, 
    0.04000102f, 0.03014404f, -0.02732620f, -0.04992737f, 0.02136296f, 0.00420121f, -0.03419303f, -0.01554117f, 
    -0.03090527f, -0.01398266f, 0.02173034f, 0.01385954f, -0.05576488f, 0.04693929f, -0.01251507f, 0.04514500f, 
    0.04106057f, -0.01551108f, -0.04474084f, -0.04730656f, -0.05077913f, -0.00919211f, -0.02341601f, 0.02904049f, 
    -0.03350248f, -0.05197010f, 0.02165397f, 0.03413463f, -0.01027688f, -0.01646983f, 0.02536804f, 0.04453198f, 
    -0.01306579f, 0.01795632f, -0.03261012f, -0.03591662f, -0.05039621f, -0.05437524f, -0.00940749f, 0.00561425f, 
    -0.00680689f, 0.03793731f, -0.02538890f, 0.00417263f, 0.01225848f, 0.02117942f, 0.04621781f, 0.01484871f, 
    -0.02520603f, 0.01629684f, 0.00057190f, -0.01088496f, -0.00385094f, 0.01709034f, -0.00492947f, -0.01046547f, 
    0.04126761f, -0.04771899f, 0.04148479f, 0.04763020f, 0.03272089f, 0.00080878f, 0.00492263f, 0.03472236f, 
    0.02929972f, -0.00927936f, -0.04555322f, -0.03250301f, -0.02105803f, -0.03584559f, -0.03544372f, 0.03061235f, 
    -0.05080387f, 0.01387627f, 0.00530665f, 0.00330438f, 0.04126005f, 0.04065498f, -0.01428076f, -0.02703424f, 
    -0.00021321f, 0.01615687f, 0.01654903f, 0.01923046f, -0.02713158f, -0.01217108f, -0.00008602f, -0.05396259f, 
    -0.03516543f, 0.03465399f, -0.05171933f, -0.01162387f, -0.04539708f, 0.00175408f, -0.02836151f, 0.03371231f, 
    0.03060763f, 0.02851221f, 0.02012822f, -0.03076579f, -0.02272152f, -0.04963575f, -0.03392895f, 0.04527440f, 
    0.04122117f, 0.01986563f, 0.02975213f, -0.01634436f, 0.02442182f, 0.04490164f, -0.04848305f, 0.04076403f, 
    0.03542078f, 0.01096243f, -0.02799732f, -0.04339363f, 0.04429264f, 0.00976382f, 0.00551698f, 0.02361083f, 
    -0.00937309f, -0.03781015f, -0.02277338f, -0.02988669f, 0.02239174f, -0.04838208f, -0.01922002f, -0.01427165f, 
    0.02789875f, -0.00212058f, 0.01756805f, 0.03231830f, 0.03709625f, -0.02564167f, -0.03016433f, 0.04441513f, 
    -0.04119550f, 0.00641450f, 0.04200171f, 0.02543952f, 0.03984045f, -0.04138249f, -0.00270752f, 0.02530437f, 
    0.03708749f, -0.01767022f, -0.02322931f, 0.01199897f, 0.02702319f, -0.03554859f, -0.03364228f, 0.00852275f, 
    -0.02591126f, -0.02935660f, 0.00639216f, -0.00355818f, 0.01598622f, -0.00036909f, 0.01362597f, -0.02151795f, 
    -0.02248432f, -0.00900873f, 0.01446900f, 0.00563501f, -0.01394289f, -0.03692041f, -0.03332091f, 0.01130718f, 
    -0.04677995f, 0.03647366f, 0.01907048f, 0.00089734f, 0.04223520f, 0.03945398f, 0.03460410f, -0.00090924f, 
    -0.04172480f, 0.03709119f, -0.01657526f, -0.02961139f, -0.04657866f, -0.01644796f, -0.02658758f, -0.03980450f, 
    0.02799953f, 0.02617212f, 0.02666283f, -0.05290859f, -0.01945011f, -0.02147068f, -0.02147659f, -0.01841790f, 
    -0.04440273f, -0.05424440f, 0.00278892f, -0.03402142f, -0.00668193f, -0.01994549f, -0.03076141f, 0.03801327f, 
    -0.00038107f, 0.03145592f, -0.03159825f, -0.04938618f, -0.04157346f, -0.03753650f, 0.03442138f, 0.03027159f, 
    -0.03927404f, -0.05094860f, 0.02731872f, 0.00829336f, 0.02112687f, -0.00909401f, -0.03626374f, 0.04049939f, 
    0.02003295f, -0.04314557f, 0.03081024f, 0.02632293f, 0.00525783f, -0.05376722f, -0.03530346f, -0.02894290f, 
    -0.05420531f, -0.03760253f, 0.00687313f, 0.04141876f, -0.03735109f, -0.01064052f, -0.03380497f, -0.03724780f, 
    -0.04710370f, -0.04381704f, -0.03636193f, -0.04876415f, -0.05318628f, -0.03512627f, 0.01364875f, -0.04002015f, 
    -0.03259833f, -0.00642375f, 0.03585701f, 0.03700751f, -0.02486845f, 0.02075907f, 0.02808380f, 0.00588240f, 
    -0.03127146f, -0.02559790f, -0.01685937f, 0.02697278f, -0.01085034f, -0.01109951f, -0.03876104f, 0.03721393f, 
    -0.05042981f, 0.01523014f, 0.04405982f, -0.03005851f, 0.03594896f, 0.00764287f, -0.01315575f, 0.02134983f, 
    0.03199874f, -0.01551389f, -0.03679995f, -0.05410339f, -0.01146001f, 0.04020272f, 0.04549704f, 0.02848671f, 
    -0.05233792f, -0.04447515f, -0.00202490f, -0.00727580f, 0.00591629f, 0.01895736f, 0.00180798f, 0.03282448f, 
    -0.03718591f, -0.05510633f, -0.05048810f, 0.00124327f, 0.04743803f, 0.03794678f, 0.04023798f, 0.01880218f, 
    0.02721599f, -0.01473962f, 0.02342470f, 0.03905382f, 0.01582415f, -0.05366317f, 0.03899414f, -0.00924143f, 
    -0.04532175f, 0.00222828f, 0.00863441f, -0.03968330f, -0.04464294f, -0.00088268f, -0.04645972f, -0.00335403f, 
    -0.02620210f, 0.02529109f, -0.03418501f, 0.00301634f, -0.00392533f, -0.03267176f, -0.04034783f, 0.03718905f, 
    -0.02145110f, 0.00743514f, -0.05355292f, -0.01150265f, 0.03335715f, -0.01714743f, -0.02250132f, -0.04652922f, 
    -0.04500801f, 0.03695073f, 0.01856975f, 0.03381065f, -0.05109481f, -0.01623811f, 0.01789633f, -0.01282692f, 
    0.00370889f, 0.02040427f, 0.00267452f, -0.04468386f, -0.00735957f, 0.03276590f, -0.04212010f, 0.00041406f, 
    -0.04796925f, -0.04767190f, -0.01290025f, -0.00327057f, 0.02334479f, -0.05558280f, -0.03763892f, -0.00399247f, 
    0.62998283f, -0.13409592f, -0.00782478f, 0.14652826f, -0.05782389f, 0.13544145f, 0.04329312f, 0.11816805f, 
    0.01873203f, -0.02721110f, 0.05648728f, -0.04654849f, 0.14897472f, 0.12896381f, -0.19576295f, -0.04386310f, 
    -0.10098136f, 0.05003170f, -0.06665607f, 0.00371047f, -0.02393249f, 0.05856999f, -0.08089224f, -0.02237062f, 
    -0.02742246f, 0.06200957f, -0.05273792f, -0.07511840f, -0.01262034f, -0.07654826f, 0.05159767f, 0.05263219f, 
    0.02907095f, -0.00898254f, -0.10375536f, -0.04361228f, 0.12272262f, 0.03837219f, 0.10662121f, 0.01095233f, 
    0.03147938f, 0.02803088f, 0.05836522f, -0.05054614f, 0.11457918f, 0.08133535f, 0.04209686f, -0.04445538f, 
    0.43934983f, -0.35087079f, -0.01230460f, -0.00586705f, 0.08164123f, -0.02354647f, 0.04535421f, 0.06256545f, 
    -0.13417922f, 0.13424371f, -0.06147217f, 0.13557743f, 0.09427243f, 0.30059659f, -0.02386377f, -0.16688718f, 
    0.17277586f, 0.04612924f, 0.03801228f, 0.04986752f, 0.03809122f, 0.05629879f, 0.05562977f, 0.10205920f, 
    0.05448185f, 0.01867782f, 0.09009361f, 0.18971200f, 0.00740902f, 0.04475100f, 0.03180429f, -0.03196871f, 
    0.06952154f, 0.08546585f, 0.11927138f, 0.05739821f, -0.06490476f, 0.04509829f, 0.07030834f, -0.14684121f, 
    0.15995722f, 0.03947586f, 0.02214071f, 0.02260731f, -0.02711533f, 0.00216181f, -0.07064787f, 0.00461668f, 
    -0.02271371f, -0.13761882f, -0.06057680f, -0.12292153f, -0.12575090f, 0.03345144f, 0.09149800f, -0.03519714f, 
    0.00880923f, 0.03629289f, 0.07346497f, 0.06309605f, 0.44841293f, -0.16418116f, 0.07316738f, 0.12247135f, 
    -0.11122124f, -0.00835574f, 0.00741740f, 0.07322426f, 0.04237130f, 0.11775341f, 0.04885306f, -0.07601041f, 
    0.00965869f, 0.01684912f, -0.04702245f, 0.01272971f, -0.06691245f, 0.03604626f, -0.12715465f, 0.00344633f, 
    0.07656880f, -0.01591127f, -0.05194388f, 0.08344942f, 0.12660274f, 0.01806036f, 0.04108390f, -0.20131470f, 
    0.05919418f, -0.02276448f, 0.12350184f, 0.10365247f, 0.08523221f, 0.01127084f, -0.06849681f, 0.17624949f, 
    0.03524050f, 0.03560608f, -0.13148263f, -0.04688859f, 0.00620463f, 0.00900326f, -0.11834291f, 0.03885773f, 
    0.06336862f, 0.07835127f, 0.02255818f, -0.09510700f, 0.00704251f, 0.05335534f, -0.20867166f, 0.02639887f, 
    -0.15423636f, -0.13998327f, 0.03732462f, 0.15030882f, 0.04737416f, -0.01083141f, -0.10402814f, -0.10688002f, 
    -0.27712077f, -0.16421302f, 0.20404083f, -0.25418079f, -0.01915651f, 0.03326517f, 0.22084272f, 0.00961100f, 
    -0.03580763f, 0.00024887f, -0.00384724f, 0.00135539f, 0.16658057f, -0.06530812f, 0.02671727f, -0.01112436f, 
    0.00618444f, -0.07484226f, 0.01123085f, 0.12615551f, 0.07292408f, 0.01506323f, -0.11030342f, 0.07003901f, 
    0.13785407f, -0.19493385f, 0.10892843f, -0.09968919f, 0.04756543f, -0.05053991f, 0.01009793f, -0.17128015f, 
    0.08421916f, -0.00763571f, 0.05430678f, -0.08386672f, 0.16891150f, -0.14891979f, 0.14861615f, 0.01964288f, 
    -0.07636986f, 0.03150417f, 0.00445499f, 0.05723449f, 0.12738499f, 0.09580757f, -0.03536283f, 0.05553399f, 
    -0.11829861f, 0.05064806f, 0.05169386f, 0.05713134f, -0.00904456f, 0.05662534f, -0.05580252f, 0.05788971f, 
    0.09429611f, -0.03930286f, -0.01403649f, -0.07106820f, 0.29177949f, -0.00934021f, -0.20687345f, 0.00186648f, 
    -0.09063995f, 0.00004637f, 0.05282875f, 0.12610261f, -0.03485884f, 0.12431113f, -0.09635881f, -0.06576597f, 
    -0.02943150f, 0.20459022f, -0.06824927f, 0.09057575f, -0.00758492f, 0.01310274f, -0.02184249f, 0.18191752f, 
    0.06712428f, 0.05458646f, -0.06530552f, 0.13555974f, 0.33258227f, -0.13097401f, 0.03574251f, -0.27777779f, 
    0.02425464f, -0.10195142f, 0.06048324f, -0.02565917f, -0.05250107f, -0.04054179f, -0.00254811f, 0.04457524f, 
    0.14589977f, -0.10575895f, 0.01482035f, 0.12985867f, 0.11427146f, 0.11374204f, 0.05667204f, 0.12162834f, 
    0.12584302f, -0.02775445f, -0.00439735f, 0.09058402f, -0.03897464f, -0.08125050f, 0.29294887f, 0.02698546f, 
    0.02688394f, -0.07387555f, 0.06945243f, 0.11605844f, 0.13316807f, 0.02860524f, -0.09670642f, 0.08927357f, 
    0.36567804f, 0.06865135f, -0.11246109f, 0.09352896f, 0.11523841f, 0.09484987f, 0.09369659f, 0.04420615f, 
    -0.06153529f, -0.07013060f, -0.03755400f, -0.02145925f, 0.19232948f, -0.08517337f, 0.03029604f, -0.19893308f, 
    -0.05665113f, 0.03419432f, 0.03211661f, 0.04253298f, -0.15412168f, 0.02608129f, 0.07496540f, 0.03890266f, 
    -0.10617801f, 0.09910290f, -0.17647378f, -0.22943617f, -0.04507052f, -0.01915460f, -0.11179195f, -0.06422249f, 
    0.00119054f, 0.09446177f, 0.02995651f, -0.12479053f, 0.07133485f, 0.01307868f, -0.19429615f, -0.02689772f, 
    -0.03695074f, -0.09532183f, -0.13037296f, -0.05847196f, -0.04682228f, 0.02430015f, -0.08960801f, -0.02599261f, 
    0.22000574f, -0.08486804f, 0.07125671f, -0.15052356f, 0.00161056f, -0.07417240f, 0.00517486f, 0.03117836f, 
    0.07443144f, 0.02494928f, -0.04217224f, -0.07822952f, 0.05470739f, 0.12372227f, -0.22235602f, -0.01368241f, 
    0.01072014f, 0.15849732f, 0.06513977f, -0.15198776f, 0.04413268f, -0.02044007f, 0.10312054f, -0.06110281f, 
    0.23690900f, -0.09110228f, 0.01848521f, 0.05200044f, 0.08440296f, -0.01796798f, 0.05372964f, 0.10419005f, 
    0.12185877f, 0.11750357f, -0.10937547f, 0.01574153f, 0.08796140f, 0.15583120f, -0.13235506f, 0.15214533f, 
    -0.02287723f, 0.04964013f, -0.00818221f, -0.02680559f, 0.04990021f, 0.09676851f, 0.17295048f, 0.02933939f, 
    -0.00846882f, -0.02125403f, -0.02424069f, 0.01988613f, 0.03482842f, -0.04335464f, 0.03114832f, -0.00893971f, 
    0.04913693f, -0.01275856f, -0.00689780f, -0.04666756f, -0.01004521f, 0.04829632f, 0.00784623f, 0.02947442f, 
    -0.03669709f, 0.03864326f, -0.02899309f, -0.04923538f, -0.01584784f, 0.03354843f, 0.03371067f, -0.00896932f, 
    -0.02074013f, -0.00200341f, 0.00697750f, 0.01214746f, 0.01041575f, -0.01060549f, -0.01001279f, 0.03380821f, 
    -0.02052536f, 0.03592312f, -0.03955312f, 0.04428611f, 0.01421173f, 0.02146900f, 0.04386979f, -0.04330324f, 
    0.02021070f, 0.01638293f, -0.04828993f, -0.04176022f, -0.01001881f, -0.01691919f, -0.00990856f, -0.04206201f, 
    -0.00553515f, 0.02905560f, -0.02470945f, 0.01193636f, -0.04064652f, 0.04686302f, 0.02620476f, -0.01772442f, 
    -0.02346793f, -0.02313928f, 0.01080898f, 0.03870787f, 0.00682098f, -0.00206482f, -0.03124384f, -0.03121711f, 
    0.00841857f, -0.03308083f, -0.02600802f, -0.03988629f, -0.01849655f, -0.03832588f, 0.01502068f, -0.05067306f, 
    -0.00637895f, -0.02330702f, -0.00953136f, -0.00721669f, -0.05073160f, 0.03350214f, 0.00269951f, -0.04305476f, 
    0.04891044f, 0.01094845f, 0.04701698f, -0.03993647f, -0.04285192f, -0.03386305f, -0.02964637f, -0.01426291f, 
    -0.03242889f, 0.00536054f, -0.00832008f, 0.01497403f, 0.01448056f, -0.02472540f, 0.03402141f, 0.03518439f, 
    0.01503316f, -0.03659127f, -0.01845794f, -0.00995087f, -0.02529304f, 0.00817710f, 0.00131544f, -0.02770393f, 
    0.01964310f, 0.01687794f, -0.03207802f, -0.04504989f, -0.01183139f, -0.00812881f, 0.04878334f, -0.02865396f, 
    -0.01555510f, 0.04172862f, 0.04372153f, 0.04476215f, -0.03548009f, -0.03271592f, -0.00946090f, -0.04987967f, 
    -0.00609083f, -0.00413632f, 0.03520082f, -0.01966379f, -0.02935947f, -0.03686504f, -0.04521660f, -0.02224524f, 
    -0.00022064f, -0.03731022f, 0.04680747f, 0.00966179f, -0.03741429f, 0.00040737f, -0.01527803f, 0.00696167f, 
    -0.03456064f, 0.00329572f, 0.05089886f, 0.04164895f, -0.04734406f, 0.00094758f, 0.00351007f, 0.01880830f, 
    0.02477079f, 0.02755422f, 0.00385605f, 0.00218594f, 0.02569065f, -0.04644601f, 0.02042089f, 0.00108717f, 
    0.00475977f, -0.03904517f, 0.00343097f, 0.02370645f, 0.03952172f, 0.04032595f, 0.03280173f, 0.02772846f, 
    -0.00733545f, 0.00244061f, -0.01927054f, -0.01958323f, 0.04514975f, -0.03729673f, -0.02473287f, 0.03673129f, 
    0.03512096f, 0.04285661f, -0.03579333f, -0.00282368f, -0.01300718f, -0.04057012f, 0.02256205f, -0.04030190f, 
    0.02617898f, -0.04066726f, -0.00088741f, -0.03291898f, 0.01364680f, -0.02622414f, -0.02136118f, 0.01031720f, 
    0.04856493f, -0.01010909f, 0.02437785f, 0.00302770f, 0.01836695f, 0.00923925f, -0.01493611f, -0.04184930f, 
    0.00142338f, 0.02518991f, 0.03251307f, -0.02710709f, 0.00920837f, -0.04940090f, -0.00837213f, -0.04669223f, 
    0.01767299f, 0.02004497f, -0.04701338f, 0.01272023f, -0.02269072f, 0.01301971f, 0.03942806f, -0.03885214f, 
    -0.05102652f, -0.00575313f, -0.01174456f, 0.04350772f, 0.02984476f, -0.03313239f, -0.02505211f, 0.01484239f, 
    0.04086550f, -0.01472721f, 0.02959108f, -0.04164039f, 0.00877363f, -0.02805642f, -0.00887765f, 0.01776040f, 
    -0.04216526f, -0.04297985f, 0.04943303f, 0.02135613f, -0.01050793f, 0.02561465f, -0.04441670f, -0.02495806f, 
    0.02128002f, -0.01230936f, -0.03974325f, 0.03775391f, -0.01862046f, 0.04521525f, -0.02655232f, 0.02581028f, 
    -0.03710688f, -0.04840606f, -0.00090104f, 0.00889167f, -0.04800108f, 0.02038530f, -0.02341207f, -0.04038167f, 
    -0.00096285f, -0.00396064f, -0.05061017f, -0.03680909f, -0.04157440f, -0.02645458f, -0.03526122f, -0.04735046f, 
    0.04174728f, 0.02539386f, -0.03168656f, -0.00077108f, 0.04616134f, 0.02638081f, 0.01942418f, 0.00649589f, 
    0.00246505f, 0.03787344f, -0.02688188f, -0.00509298f, -0.04088763f, 0.02866022f, -0.00582172f, -0.04246170f, 
    -0.02043260f, 0.02729924f, 0.04413547f, -0.00537764f, -0.01078948f, -0.01739751f, -0.04613367f, 0.00816071f, 
    -0.04320920f, -0.00868495f, -0.04302486f, 0.00838203f, 0.00093973f, 0.01061808f, -0.04961490f, 0.03007896f, 
    0.03088295f, -0.03259712f, -0.02698770f, -0.03267376f, -0.04150404f, 0.04530724f, 0.04231605f, -0.01633197f, 
    -0.00676104f, -0.02199866f, 0.04961795f, -0.03976821f, 0.03985042f, -0.02115437f, 0.00812610f, -0.00047762f, 
    0.04879266f, -0.04059315f, 0.04330330f, 0.02926181f, 0.02663500f, 0.00093796f, -0.00849626f, -0.02135750f, 
    -0.02155181f, -0.01097565f, -0.02789027f, 0.01667503f, -0.01713968f, 0.01792655f, 0.04958325f, 0.02734794f, 
    -0.04263622f, -0.02324072f, 0.01077942f, -0.02764748f, -0.04067959f, -0.02752766f, -0.04065653f, 0.02576317f, 
    0.02684298f, 0.02232493f, 0.05081560f, 0.02392686f, 0.02761144f, -0.04939799f, 0.00578343f, -0.01220973f, 
    0.03568361f, -0.04525369f, 0.02901423f, -0.04636294f, 0.03140314f, 0.03067250f, -0.00276649f, -0.04605334f, 
    -0.01637955f, 0.01482589f, 0.01362666f, 0.00610982f, -0.03921483f, -0.01727647f, -0.01059636f, -0.00171456f, 
    -0.03831643f, -0.01744701f, 0.03029814f, 0.04314712f, -0.00686407f, -0.01864451f, 0.00088891f, 0.00158215f, 
    0.02474221f, 0.02739146f, -0.04315946f, -0.03825469f, -0.01974342f, 0.05052691f, 0.04731343f, 0.04274470f, 
    -0.02739585f, -0.01262697f, -0.03103527f, -0.03624739f, -0.03587594f, 0.02234149f, -0.01700176f, -0.00454301f, 
    -0.01684821f, -0.05011206f, -0.01500625f, 0.02556582f, -0.00515692f, 0.02712106f, -0.03186590f, 0.02609033f, 
    -0.05285086f, 0.25926349f, -0.28613409f, 0.12006471f, -0.06585874f, 0.03488263f, -0.05154902f, -0.09625839f, 
    0.01980712f, 0.08017772f, 0.20139378f, -0.00036267f, -0.02065855f, -0.02211933f, 0.09218609f, 0.21764126f, 
    0.12269928f, -0.03127322f, 0.16761634f, 0.06642174f, 0.15435649f, -0.08521598f, 0.10229366f, -0.12179586f, 
    -0.24295840f, -0.18674617f, -0.05543064f, -0.00925831f, -0.12134501f, -0.14631449f, 0.07035554f, 0.01405861f, 
    -0.14665700f, 0.06995195f, 0.08917107f, 0.06297574f, 0.18431942f, 0.26167062f, -0.05697216f, -0.03248814f, 
    -0.00449963f, 0.12775441f, 0.04689965f, 0.00163728f, 0.06280357f, -0.09994960f, 0.06426096f, 0.03738848f, 
    -0.03683922f, 0.26847154f, -0.03473891f, 0.07285528f, -0.02861770f, 0.06199086f, -0.02228625f, -0.02504988f, 
    -0.04656677f, 0.00041404f, 0.15600684f, 0.08682545f, -0.10897008f, -0.29336736f, -0.22731650f, 0.29580596f, 
    -0.05485452f, 0.21724875f, -0.01035031f, 0.08724099f, -0.04540028f, 0.11801306f, -0.05402912f, -0.02584220f, 
    -0.17827103f, -0.02231304f, -0.14170575f, 0.12584907f, -0.18458256f, -0.05507756f, -0.01556600f, -0.07662729f, 
    -0.00502400f, -0.04361732f, -0.01069057f, 0.02052769f, 0.04378835f, 0.03461704f, 0.01829410f, 0.02157741f, 
    0.02108536f, 0.04440177f, 0.07788339f, -0.03720336f, 0.17441373f, 0.07142073f, 0.02139202f, 0.21427229f, 
    0.04601464f, 0.03571991f, -0.00615636f, -0.20738812f, -0.04492841f, 0.02489580f, 0.18328664f, 0.19911236f, 
    0.01852226f, -0.15132332f, 0.05930796f, -0.07079484f, -0.11659670f, 0.04585133f, -0.07170743f, 0.25904450f, 
    -0.08718088f, 0.05526134f, 0.03170132f, -0.11138811f, -0.01274014f, 0.05260821f, -0.07908291f, -0.01989301f, 
    0.21196227f, -0.08369163f, 0.20042992f, 0.37119821f, 0.07960042f, 0.12064487f, 0.38431421f, -0.00546471f, 
    0.00206633f, 0.10262169f, -0.02608225f, 0.02004262f, 0.03490794f, 0.21764980f, 0.17762089f, 0.10500255f, 
    0.06721972f, 0.03511867f, -0.09653577f, 0.02819028f, -0.00662624f, 0.19256908f, 0.09250599f, -0.02955950f, 
    0.07657650f, 0.29597113f, 0.18371738f, -0.24944347f, -0.06018446f, -0.21050119f, 0.07843491f, -0.07564972f, 
    -0.10539565f, -0.02665845f, -0.08265743f, 0.05497363f, -0.13374509f, 0.30369404f, 0.35432479f, -0.30514720f, 
    0.05757918f, -0.09974958f, -0.00448426f, 0.10363369f, -0.10997169f, 0.12208386f, 0.02951639f, 0.17174067f, 
    0.12058318f, -0.06287797f, 0.12974438f, 0.15938729f, 0.13968518f, 0.15315682f, -0.09035466f, -0.06979378f, 
    0.01569797f, -0.00258929f, -0.04351038f, 0.04921419f, 0.00257305f, 0.03394702f, -0.02307555f, -0.22601502f, 
    -0.15825894f, 0.03583182f, 0.08870064f, 0.06327277f, -0.00793219f, 0.00413374f, 0.00819272f, 0.14232455f, 
    -0.34458703f, 0.04871811f, -0.08709232f, -0.06837643f, -0.13002516f, 0.21352850f, -0.02796677f, 0.11302910f, 
    0.08878794f, 0.10724813f, 0.10462914f, 0.24204721f, 0.00852190f, -0.05390234f, 0.14023496f, 0.00447779f, 
    -0.01355521f, -0.01417218f, -0.07578382f, 0.14102168f, 0.03514380f, -0.20599672f, 0.17201394f, -0.15745974f, 
    0.34420586f, -0.16738260f, -0.10589238f, -0.14348245f, 0.14614731f, 0.00606548f, 0.03264834f, -0.00903837f, 
    0.06207693f, 0.16167524f, 0.03886648f, 0.22151707f, -0.02143918f, 0.12225158f, 0.00247689f, -0.15606076f, 
    -0.03039140f, -0.04027133f, -0.06620646f, -0.02609453f, -0.02738654f, -0.11867915f, 0.02665373f, 0.10424541f, 
    -0.44933370f, -0.22284622f, 0.14272442f, 0.16314046f, -0.12532125f, 0.00602574f, -0.09956438f, -0.18473284f, 
    -0.10856977f, 0.06805746f, -0.01836026f, 0.12085494f, -0.14498881f, 0.08600553f, 0.18541703f, 0.04172431f, 
    0.04896809f, 0.05087795f, -0.00453297f, 0.19910496f, -0.00125552f, -0.01526496f, 0.05344994f, 0.00142917f, 
    0.00797529f, -0.02173852f, 0.12917565f, -0.06381159f, -0.05322045f, 0.02275322f, 0.09066941f, -0.09422194f, 
    0.02457923f, 0.00600007f, 0.06717735f, 0.00005855f, 0.06282157f, -0.12975760f, 0.07484503f, 0.04604527f, 
    -0.04743011f, 0.21228595f, -0.13880196f, -0.14116572f, -0.02177052f, 0.12204628f, 0.03002256f, 0.00202109f, 
    -0.51719093f, -0.04933730f, 0.02022038f, -0.00038503f, 0.07232162f, -0.15774266f, 0.01170698f, -0.08243580f, 
    -0.01549515f, -0.02679632f, -0.17246185f, 0.02244810f, -0.13829926f, 0.16429925f, -0.05494007f, 0.00486955f, 
    0.02087632f, -0.04125303f, 0.13840196f, 0.06811726f, -0.03956419f, -0.01204289f, 0.00760758f, 0.10082140f, 
    -0.00666606f, 0.26824427f, 0.21676865f, -0.01618452f, 0.02146018f, 0.03538219f, 0.03306536f, 0.16847092f, 
    -0.05292849f, -0.12030917f, -0.03099988f, 0.16467655f, 0.14635715f, -0.08811955f, 0.04582674f, -0.05639458f, 
    0.00802168f, -0.05913097f, 0.12791838f, 0.18655901f, -0.01617739f, 0.07260495f, 0.02823496f, 0.09587228f, 
    0.32736626f, 0.05819018f, 0.03126270f, 0.12812309f, -0.09832903f, 0.15094540f, 0.11486838f, 0.14952894f, 
    0.02102902f, -0.09007642f, 0.05059317f, -0.01035167f, -0.60699522f, 0.28971693f, 0.51213813f, 0.26983169f, 
    0.10790275f, 0.07363944f, -0.10082560f, 0.10667183f, 0.01676562f, -0.01551947f, -0.08451068f, 0.00028082f, 
    -0.18280913f, -0.04475685f, -0.08175220f, -0.11297821f, -0.00499418f, -0.01463813f, 0.07903661f, 0.02246033f, 
    0.03908379f, -0.09806190f, 0.08103925f, 0.10367039f, -0.39584109f, -0.16466105f, 0.12364319f, 0.25245118f, 
    -0.11147349f, -0.07882114f, 0.00049762f, 0.08224306f, 0.08605444f, 0.07465068f, 0.02108671f, 0.10259397f, 
    -0.02938610f, 0.01469525f, 0.01173907f, 0.00116162f, 0.01917275f, 0.03858719f, -0.02188804f, -0.02528140f, 
    -0.04051762f, 0.03655353f, 0.02901096f, -0.01920950f, -0.05564368f, -0.03377465f, 0.01434955f, -0.01360594f, 
    -0.05120361f, 0.00004808f, -0.02420105f, -0.01329102f, 0.01891686f, -0.02905708f, 0.00575497f, 0.04783648f, 
    0.03382798f, -0.00737668f, -0.00128790f, 0.00478512f, 0.01454333f, -0.02859931f, -0.05662600f, -0.02012123f, 
    -0.05165056f, -0.01159540f, -0.00206419f, -0.02535829f, -0.05297121f, -0.02051215f, -0.05098605f, -0.03488391f, 
    -0.04354503f, -0.01763600f, 0.00472216f, -0.00693826f, -0.04774465f, -0.01686905f, -0.03617303f, 0.02780361f, 
    -0.04629392f, 0.03877672f, -0.04447407f, 0.03971783f, -0.00600961f, 0.03666693f, -0.05422386f, 0.01895346f, 
    -0.00824614f, -0.01933868f, -0.04656121f, 0.01811293f, 0.00328560f, -0.05649047f, -0.03757124f, 0.00131521f, 
    -0.03534604f, -0.01028664f, -0.01831489f, 0.03349650f, 0.00665997f, -0.00726024f, 0.01814933f, -0.01064041f, 
    0.01241482f, -0.01737949f, 0.03834821f, -0.03343964f, -0.00930027f, -0.00388941f, 0.05806711f, 0.01376556f, 
    0.00628910f, 0.00050198f, -0.00725963f, -0.02437488f, -0.01399137f, 0.01415388f, -0.04730568f, 0.02865998f, 
    0.03903044f, 0.04228964f, -0.03466146f, 0.03826167f, 0.02778141f, -0.04190083f, 0.02547842f, 0.01831122f, 
    0.03921389f, -0.00756612f, -0.03976223f, -0.04746693f, -0.04635540f, 0.04382949f, -0.03951409f, 0.01028833f, 
    -0.04543909f, 0.04066282f, 0.03898402f, -0.04421663f, -0.00886303f, 0.00825657f, 0.01923998f, -0.02765033f, 
    0.02240316f, -0.01115537f, 0.01760064f, 0.03403204f, -0.04391209f, 0.01539555f, -0.05912264f, 0.03954861f, 
    -0.04249929f, 0.01550767f, 0.00690740f, 0.00401254f, -0.01044872f, -0.04446936f, 0.02761637f, -0.04198898f, 
    -0.00304068f, 0.01742601f, -0.04869193f, 0.03535042f, 0.04553283f, 0.03391611f, 0.02142743f, 0.01245037f, 
    0.03163524f, 0.02836687f, 0.03649942f, -0.01959919f, -0.01864506f, 0.02687735f, -0.03570931f, -0.04101292f, 
    -0.04260190f, 0.03629328f, -0.02146467f, -0.04914085f, 0.04893127f, 0.03686569f, 0.03422063f, -0.01782418f, 
    -0.02983167f, -0.00226226f, 0.01293024f, 0.02864903f, -0.00493809f, -0.01359366f, 0.02705305f, -0.03541826f, 
    -0.05187245f, 0.03062820f, -0.01204422f, -0.02358555f, 0.02167083f, -0.05201714f, 0.02073787f, -0.05010478f, 
    0.02549183f, 0.01308847f, -0.01401420f, -0.05278838f, -0.01975747f, -0.02943624f, 0.03161814f, -0.04932066f, 
    -0.05275226f, -0.04558698f, -0.03977299f, -0.03116580f, -0.03421924f, -0.00335786f, 0.02660574f, 0.03800981f, 
    0.02539303f, 0.02082096f, -0.03317663f, 0.03200971f, 0.03951098f, -0.01231806f, -0.02854736f, -0.02023787f, 
    -0.00687803f, 0.01224618f, 0.00134080f, 0.02032169f, 0.01906215f, -0.01672035f, -0.02080673f, 0.01278705f, 
    -0.03782315f, 0.02815172f, 0.03822013f, -0.03562085f, -0.03530793f, 0.00893442f, -0.04964720f, 0.03484645f, 
    -0.02677372f, 0.01386470f, 0.05035914f, 0.00546637f, 0.02631661f, -0.00740342f, -0.02378072f, -0.02401321f, 
    0.03573618f, 0.00048898f, 0.00066848f, -0.02053596f, 0.01934620f, -0.02156360f, -0.05253111f, -0.04256251f, 
    0.04318468f, -0.03922853f, -0.01475961f, 0.03494558f, 0.00865253f, 0.01367434f, -0.03202209f, 0.00492170f, 
    -0.05098834f, -0.03535562f, 0.00840649f, -0.04173557f, 0.04702774f, -0.02213934f, -0.03888410f, -0.04116530f, 
    -0.01040466f, -0.02827965f, -0.01476385f, -0.01005495f, 0.03355844f, -0.04033838f, 0.03888648f, 0.00837907f, 
    -0.03394393f, -0.02506808f, 0.02818966f, 0.04648120f, 0.02079073f, 0.02559078f, -0.01658016f, 0.00541978f, 
    -0.03468997f, 0.03672610f, -0.01848523f, -0.04186209f, 0.04033090f, -0.05794675f, -0.01933583f, 0.01114000f, 
    -0.01047208f, 0.00930082f, -0.04304942f, 0.03546828f, -0.05058664f, -0.02485411f, 0.01572302f, 0.04283985f, 
    -0.02284813f, 0.03641152f, 0.03214656f, -0.03138657f, 0.02298405f, -0.03697245f, 0.01789726f, 0.01351737f, 
    -0.04145791f, -0.04047367f, 0.04143877f, -0.00889033f, -0.02601678f, -0.04879294f, 0.03689381f, -0.05374926f, 
    0.04405844f, 0.03560308f, -0.04399514f, -0.02801142f, -0.05548770f, -0.00156763f, -0.03466494f, -0.03155512f, 
    0.04205111f, -0.05722047f, 0.04507708f, -0.01311923f, 0.03889231f, -0.02791958f, 0.00232476f, 0.01537419f, 
    0.01909692f, 0.01753596f, -0.04639852f, -0.04033999f, -0.02303070f, 0.01379152f, 0.04241559f, -0.01614908f, 
    0.03304801f, 0.02216306f, 0.00350403f, -0.04147116f, 0.03542127f, -0.02776658f, -0.02749059f, -0.05148015f, 
    -0.00521522f, -0.01160451f, -0.01729120f, -0.00392772f, -0.00970665f, -0.02601941f, -0.01128966f, 0.04603949f, 
    0.02031656f, 0.00410820f, -0.00553446f, -0.03876270f, 0.03491093f, -0.00383913f, -0.03901061f, -0.02079496f, 
    -0.03885118f, -0.02740799f, -0.00009346f, 0.04251813f, 0.03423485f, -0.00400555f, 0.00450647f, -0.02665145f, 
    0.03396807f, -0.04522073f, -0.03135641f, 0.00865795f, -0.03135082f, -0.03080751f, 0.00940812f, -0.03846958f, 
    -0.02476828f, -0.04638251f, -0.01813248f, -0.01040764f, -0.04138544f, -0.04511027f, -0.02196121f, -0.03168810f, 
    -0.02619011f, -0.03160252f, -0.03002070f, -0.00221295f, -0.02051508f, 0.04404895f, -0.00458764f, -0.01938386f, 
    -0.00768586f, 0.00481044f, -0.02980314f, 0.02394022f, 0.02628420f, -0.02661400f, -0.04689113f, -0.04734145f, 
    0.02585371f, -0.03274413f, -0.00321440f, -0.03767765f, 0.02749678f, -0.00178393f, -0.00584240f, 0.01700269f, 
    -0.09785789f, 0.03154510f, 0.03833093f, -0.30750281f, 0.03897126f, -0.05692063f, 0.17355049f, -0.00329995f, 
    -0.07108349f, -0.05459871f, -0.05688457f, 0.03051735f, 0.06565814f, -0.02181969f, 0.40558454f, 0.09201095f, 
    0.10124271f, -0.00350791f, -0.07138854f, -0.03505955f, -0.12718408f, 0.06571244f, 0.13330068f, 0.02372638f, 
    0.14328609f, 0.05171264f, 0.15716255f, 0.07371469f, 0.02503334f, 0.04063009f, -0.13532868f, 0.05790947f, 
    0.11628431f, -0.01683939f, 0.13294502f, 0.12793407f, 0.24946937f, 0.14545341f, -0.05871762f, 0.14914183f, 
    0.02475077f, -0.03071276f, -0.21639447f, 0.17921613f, 0.08845916f, 0.09808196f, 0.09920234f, 0.09088328f, 
    0.14886375f, -0.29039675f, -0.21109611f, -0.04480912f, 0.04426865f, 0.02030288f, -0.07939842f, 0.07852107f, 
    0.13724871f, -0.15493940f, -0.03945395f, -0.00926882f, 0.20340379f, 0.11612348f, -0.25061035f, 0.41153148f, 
    0.05538688f, -0.03812902f, -0.06670543f, 0.13032311f, 0.17817847f, 0.00141357f, 0.09795035f, 0.08209261f, 
    0.19475903f, -0.17318608f, 0.08075835f, 0.00923347f, 0.10326796f, -0.07707734f, 0.04085941f, 0.10179247f, 
    0.12965362f, 0.01491974f, 0.08566947f, -0.04952333f, 0.18667591f, 0.05795855f, -0.00936183f, 0.11440464f, 
    -0.02802495f, 0.01635940f, 0.01606796f, 0.15715845f, -0.03145881f, 0.03256255f, -0.02762317f, 0.08746754f, 
    0.03058661f, 0.01105821f, -0.10248352f, 0.29888579f, 0.17366417f, 0.07777268f, -0.07163228f, -0.07118472f, 
    0.09142168f, 0.16440065f, 0.05716138f, -0.06206860f, 0.23313506f, -0.11046235f, 0.10003815f, -0.01759828f, 
    0.10621757f, 0.03786692f, -0.01865354f, 0.01954063f, -0.00004407f, -0.17619459f, 0.05259645f, 0.09008722f, 
    0.06510149f, -0.05624733f, -0.02790193f, -0.15498261f, 0.12693502f, -0.11284439f, 0.11742818f, -0.05223761f, 
    -0.16417690f, -0.02683065f, 0.19876938f, 0.02753830f, 0.00387018f, 0.07419917f, -0.04314197f, -0.10081264f, 
    0.12348481f, -0.02120579f, 0.04301065f, 0.03100441f, 0.12048980f, -0.18135776f, 0.03446488f, -0.09088299f, 
    -0.29246479f, -0.12203733f, -0.11488198f, -0.04442766f, 0.04106883f, 0.12788543f, 0.14343202f, 0.02833806f, 
    -0.01135243f, 0.00712851f, 0.05074882f, 0.05186584f, -0.17342974f, 0.08407442f, -0.11161034f, 0.00891590f, 
    -0.09427235f, 0.21615021f, -0.16990930f, 0.07886571f, 0.01655364f, -0.05915690f, 0.09127697f, -0.03396958f, 
    0.26399925f, 0.14733271f, -0.33882585f, 0.24878444f, -0.11448914f, 0.04321273f, -0.02963640f, 0.04562047f, 
    0.11265362f, -0.03263409f, 0.13298102f, -0.06803463f, -0.03671417f, 0.18187724f, -0.00029574f, 0.03245603f, 
    -0.07156317f, 0.10532320f, -0.07276370f, -0.07887875f, 0.14763002f, 0.00219005f, 0.09131333f, 0.09197277f, 
    0.01046734f, 0.02110876f, -0.23428154f, 0.30762145f, -0.06822930f, 0.02939863f, -0.00736578f, -0.01393234f, 
    -0.03320640f, -0.10275216f, -0.05528665f, 0.06093325f, -0.00501424f, -0.16520305f, 0.28013581f, 0.36550823f, 
    0.10461709f, 0.13937782f, -0.07990249f, -0.13012454f, -0.01805886f, 0.05698809f, 0.00577531f, 0.16168600f, 
    -0.19494247f, -0.16473907f, 0.00415898f, -0.07183880f, 0.00746692f, 0.01002405f, 0.00081175f, 0.13585247f, 
    -0.03634092f, -0.25295508f, -0.01512495f, -0.16107561f, -0.27940679f, 0.07780311f, -0.00410463f, -0.00281444f, 
    0.05686880f, 0.02267118f, 0.00929798f, -0.01388143f, 0.07876096f, 0.08494471f, 0.08393428f, -0.06064730f, 
    -0.07494911f, 0.23791501f, -0.10832822f, -0.22025502f, -0.09728411f, 0.00291682f, 0.04236505f, -0.00499671f, 
    0.05643734f, 0.04723693f, -0.07471605f, -0.06204037f, 0.00874220f, -0.03406150f, -0.08367147f, 0.16018355f, 
    0.00928323f, 0.13247642f, 0.05396388f, -0.06788521f, 0.12401722f, -0.06779892f, 0.04310503f, -0.02473967f, 
    0.07495706f, -0.06439345f, 0.13815182f, -0.07738045f, 0.13213214f, -0.00956846f, 0.04465928f, 0.04270722f, 
    -0.01021117f, 0.06533857f, 0.04292962f, 0.00957860f, 0.21948501f, -0.07191969f, -0.23286651f, 0.29834506f, 
    -0.03372553f, -0.12457260f, 0.00767720f, -0.10501491f, 0.10207161f, -0.01380384f, 0.04163872f, 0.16221306f, 
    -0.09409975f, 0.15566595f, 0.02113967f, 0.07542825f, 0.10832793f, -0.05517292f, -0.03847377f, -0.04748745f, 
    -0.05930540f, -0.14215204f, 0.20850299f, 0.04872270f, 0.15217538f, -0.27271953f, -0.16395040f, 0.21720439f, 
    -0.01559661f, 0.05590096f, 0.05996760f, -0.02783623f, 0.02022236f, 0.01554258f, -0.07560428f, -0.10824531f, 
    0.21309775f, -0.04065125f, 0.09623715f, 0.28941739f, 0.03300029f, 0.01951639f, -0.01076650f, 0.08623077f, 
    0.03360023f, 0.09519791f, 0.06938658f, 0.02994170f, 0.16330978f, 0.05962342f, -0.20994006f, 0.25736201f, 
    0.11992844f, 0.10318950f, 0.11464742f, 0.01089529f, 0.06093702f, 0.11101283f, 0.19672453f, 0.16305088f, 
    0.12635246f, 0.14573278f, -0.07287410f, 0.20796180f, 0.16200015f, 0.02609875f, -0.01413688f, -0.14285596f, 
    0.10564446f, 0.17417093f, 0.00370714f, -0.07959855f, -0.16175209f, 0.25401410f, 0.05117165f, 0.14700356f, 
    -0.01908500f, -0.09703126f, 0.06843202f, 0.07420520f, -0.04176800f, 0.09123397f, -0.03663071f, 0.11171703f, 
    -0.33889213f, -0.00092523f, -0.10479427f, -0.07138652f, -0.12714513f, -0.01674762f, 0.11086445f, -0.00787692f, 
    -0.03433777f, -0.03381316f, -0.05814102f, -0.07259049f, -0.01545937f, -0.04197428f, -0.02343714f, 0.02629347f, 
    0.09126848f, -0.07497936f, 0.02410327f, 0.10562816f, 0.01763017f, -0.03031892f, -0.06169208f, 0.03925496f, 
    -0.04586019f, -0.02043622f, -0.02199032f, 0.03502942f, -0.03586863f, -0.00336618f, -0.01897620f, 0.01694133f, 
    0.02744384f, -0.01987407f, -0.01755748f, -0.04637700f, -0.04479784f, 0.01617391f, -0.05296180f, 0.03954254f, 
    -0.00039024f, 0.03175989f, -0.03000248f, 0.00073818f, 0.01378789f, 0.04129934f, 0.00702138f, -0.00795555f, 
    0.02601675f, -0.00587111f, -0.02400495f, 0.03982121f, -0.02208403f, 0.01804643f, -0.05414686f, 0.02512808f, 
    -0.02770606f, -0.02390958f, 0.00786424f, 0.00310287f, -0.05665444f, -0.01825896f, -0.01741793f, 0.01797920f, 
    -0.03959738f, -0.04045304f, -0.03397471f, -0.01792543f, 0.03643154f, -0.03323530f, -0.03748716f, -0.00208381f, 
    -0.04726665f, -0.01158476f, 0.04031061f, -0.04270958f, -0.02174308f, 0.04667222f, -0.04043519f, -0.05497994f, 
    -0.02801699f, 0.01184805f, -0.05274937f, -0.04994356f, -0.01046876f, 0.00794153f, 0.04680277f, -0.04401358f, 
    -0.02190717f, 0.03755274f, 0.01264578f, -0.04995420f, 0.01438424f, -0.03182936f, -0.04089548f, 0.00233494f, 
    0.03102809f, -0.00198651f, -0.02752875f, -0.03466459f, -0.00352557f, -0.04943518f, -0.02743231f, -0.00714296f, 
    -0.03876664f, -0.03733396f, -0.01453491f, 0.01484744f, -0.01236024f, -0.04850404f, 0.00534990f, -0.00692975f, 
    -0.00522878f, 0.04026547f, 0.01800289f, -0.03783687f, -0.00454527f, -0.04333345f, -0.04261373f, 0.03213799f, 
    0.01887544f, 0.02308046f, -0.02043872f, -0.04179931f, -0.04966016f, 0.03907170f, -0.04293771f, 0.04309456f, 
    -0.01799932f, 0.03766260f, -0.03433114f, 0.03686916f, 0.03900348f, 0.00901614f, -0.01131158f, 0.01199546f, 
    -0.05106394f, 0.04044191f, -0.01659850f, 0.00107087f, -0.04503186f, -0.05237706f, 0.05096085f, -0.02488564f, 
    -0.03277588f, 0.01994810f, -0.02569143f, -0.02563692f, 0.00518851f, 0.01393042f, 0.02942249f, -0.02295227f, 
    -0.00167387f, -0.04383019f, 0.01167554f, 0.04090624f, -0.02768183f, -0.05151104f, 0.02889570f, -0.03785898f, 
    -0.03363611f, -0.04183082f, 0.03490378f, 0.00931774f, -0.02649689f, 0.04237266f, -0.04326383f, 0.01042864f, 
    0.02070882f, -0.05492610f, -0.00007323f, 0.02443869f, -0.00792585f, -0.02959267f, 0.00477862f, -0.06099273f, 
    -0.01578627f, 0.04218170f, -0.03383350f, -0.00216854f, -0.01083410f, 0.00151334f, 0.00788391f, -0.01552044f, 
    0.02174979f, 0.04626709f, -0.00913228f, -0.01133832f, -0.01510113f, 0.01480418f, 0.02412567f, -0.01007031f, 
    -0.05351042f, -0.03597014f, 0.00792054f, 0.04353776f, -0.02433441f, 0.02793259f, -0.04672823f, -0.04332455f, 
    -0.01426861f, 0.03486867f, 0.02908151f, -0.01376153f, -0.02993500f, -0.04413354f, 0.00646772f, 0.03294306f, 
    -0.04268659f, -0.03097917f, 0.01021049f, -0.03671660f, -0.02285985f, -0.03709525f, 0.03581942f, -0.03610805f, 
    -0.03240636f, -0.02186540f, 0.04588297f, -0.05541676f, 0.03290446f, 0.03599595f, -0.03341956f, 0.04648868f, 
    0.01680136f, -0.04401675f, 0.01719729f, -0.00820538f, 0.02703019f, -0.04770075f, -0.01367580f, -0.03074300f, 
    0.01344350f, -0.03902983f, -0.02528727f, 0.03041712f, 0.04291640f, -0.01178025f, -0.04379517f, 0.03272215f, 
    0.02414922f, -0.03192786f, -0.01111690f, -0.02116768f, 0.01938578f, -0.02788797f, -0.05368572f, 0.04470369f, 
    0.04308883f, -0.00878767f, -0.03312853f, 0.00028051f, 0.04009148f, -0.01582947f, -0.03462147f, 0.01434403f, 
    0.01612728f, -0.05012235f, 0.02266247f, -0.05882931f, -0.01898067f, -0.02928547f, 0.00675391f, -0.00231189f, 
    0.02330956f, 0.03197355f, 0.02952293f, 0.02464345f, -0.05181085f, 0.01508146f, -0.05482228f, -0.02411903f, 
    0.01780314f, 0.01417319f, -0.04138440f, -0.00498765f, -0.00302427f, 0.01115553f, -0.03301887f, -0.04358318f, 
    -0.03725361f, 0.02112499f, -0.04859825f, -0.05824902f, 0.03384537f, -0.02037513f, 0.03422716f, 0.04190930f, 
    0.03336602f, -0.05306533f, 0.03967419f, -0.04604317f, 0.05369016f, -0.03885358f, -0.01571255f, -0.03671967f, 
    0.02099908f, 0.02711558f, -0.01794162f, -0.01389934f, -0.03438038f, 0.04415441f, 0.03231907f, 0.01361644f, 
    -0.00235450f, -0.00576504f, -0.00465128f, -0.03749869f, -0.00362213f, -0.01039435f, -0.03259188f, 0.01846907f, 
    -0.00710502f, -0.02838529f, -0.04128704f, -0.00472595f, 0.02644852f, 0.00533772f, -0.00487955f, -0.04455481f, 
    0.02091253f, 0.01726141f, 0.02530422f, -0.03274960f, -0.02530922f, 0.02129868f, -0.00715439f, 0.04254075f, 
    0.04543043f, 0.01908270f, -0.03748205f, -0.01683262f, -0.03319210f, 0.02084275f, 0.04306901f, 0.00726098f, 
    -0.04096212f, 0.03872490f, -0.03005678f, 0.01542732f, 0.05217493f, -0.00195747f, 0.04253304f, -0.05423211f, 
    0.04192198f, -0.01353931f, 0.02148998f, 0.02698067f, -0.02995227f, -0.05318198f, 0.05145078f, -0.01175562f, 
    0.00211573f, 0.01064643f, 0.02578297f, -0.00793316f, 0.00081956f, -0.00688353f, 0.01162555f, 0.01029567f, 
    -0.02241759f, 0.01961097f, -0.04409418f, -0.02838980f, 0.02145901f, -0.01344433f, -0.04146320f, -0.02937604f, 
    0.01287372f, -0.04091875f, 0.00163298f, -0.01254576f, 0.00331337f, 0.00861655f, -0.05132112f, 0.03296641f, 
    -0.02571495f, -0.00329566f, -0.02637061f, 0.04002453f, 0.04418199f, 0.00702431f, 0.04763605f, 0.04130430f, 
    0.04116239f, 0.00092143f, 0.01333554f, 0.03767274f, -0.00061234f, 0.02622999f, -0.04346435f, 0.01865415f, 
    -0.02158404f, -0.04396157f, -0.00819487f, -0.03924313f, 0.00459858f, -0.00132462f, -0.02241363f, -0.01792540f, 
    0.02637708f, -0.03811330f, -0.00982659f, -0.04990096f, 0.02557526f, -0.02051635f, 0.01224121f, -0.03311475f, 
    0.12865476f, 0.16732253f, 0.00469270f, -0.02532034f, 0.03546472f, 0.02362792f, 0.09098692f, 0.00137758f, 
    0.01578316f, 0.05913064f, -0.03534088f, 0.06239560f, -0.15266651f, -0.10779911f, 0.09908181f, 0.19069293f, 
    0.01855057f, -0.12653613f, 0.02043833f, 0.11770822f, -0.04982325f, -0.19182575f, 0.05470208f, 0.02090382f, 
    -0.11301829f, -0.23023354f, -0.16276833f, -0.29363510f, -0.11117429f, 0.00126240f, 0.08133593f, 0.04604226f, 
    -0.13315037f, 0.06182089f, 0.01474420f, 0.03566722f, 0.24143930f, 0.09214932f, -0.05857398f, 0.05890336f, 
    0.00019075f, 0.13499977f, -0.00923883f, 0.04663257f, 0.23122609f, -0.02100687f, -0.03900506f, -0.12082095f, 
    0.08651833f, -0.04927377f, 0.11337876f, 0.15722325f, 0.18584663f, 0.00347512f, -0.01551328f, -0.08624604f, 
    -0.10800689f, -0.13027929f, 0.05681884f, -0.03408135f, 0.22151667f, -0.19345078f, -0.08924862f, 0.00400344f, 
    0.00407413f, 0.03912219f, 0.10284691f, 0.06188566f, 0.14060326f, 0.03992552f, -0.04499009f, -0.10794738f, 
    0.09120815f, -0.27641326f, -0.12843142f, -0.26421285f, 0.12829047f, -0.10919753f, 0.00776150f, 0.03145516f, 
    0.22701637f, 0.06562915f, 0.02417902f, 0.05104003f, -0.02176718f, 0.41421190f, -0.05684043f, 0.00236861f, 
    0.12593056f, 0.05943604f, -0.06829052f, -0.04603429f, 0.07565925f, 0.16375120f, 0.11472618f, 0.08139305f, 
    -0.07701666f, -0.15112329f, 0.12939952f, 0.23668468f, 0.03038593f, -0.04349338f, 0.05273080f, -0.01702093f, 
    -0.13219598f, -0.00928476f, -0.08551031f, -0.06341976f, 0.20991069f, -0.22276019f, -0.23147961f, 0.00015765f, 
    0.01995899f, 0.14245914f, -0.00936094f, -0.05495625f, 0.00494912f, 0.05582633f, 0.01967729f, 0.09344497f, 
    0.03615664f, -0.11454148f, -0.07905700f, 0.18709573f, -0.01852827f, 0.19751462f, 0.13795981f, -0.03533403f, 
    -0.00228009f, 0.06901561f, -0.14089449f, 0.00991771f, 0.01207887f, 0.32693300f, -0.24920152f, 0.25200409f, 
    0.12350994f, -0.16082637f, 0.03686590f, -0.03736794f, 0.09090076f, 0.22846746f, 0.16090293f, 0.09391841f, 
    0.15508792f, 0.28328329f, 0.00733046f, 0.20070817f, -0.07530031f, 0.00380929f, 0.04538909f, 0.09588818f, 
    0.02619402f, -0.07167761f, -0.00426936f, -0.12841095f, -0.08303081f, 0.36024174f, 0.28616107f, -0.06276686f, 
    -0.16042657f, 0.01894456f, 0.01790197f, -0.01302992f, -0.08838519f, 0.11283977f, -0.00090298f, -0.01584823f, 
    0.22073096f, 0.03354312f, -0.09790185f, 0.30837682f, 0.07842042f, -0.00515007f, -0.04741529f, 0.00625487f, 
    -0.14239171f, 0.07188567f, -0.07458615f, 0.05136752f, 0.20521182f, 0.18716398f, 0.09770022f, 0.07632039f, 
    -0.16682874f, -0.11934378f, 0.05877452f, -0.05002749f, 0.02350070f, -0.12202892f, 0.05693181f, -0.09198771f, 
    -0.09282643f, -0.00056842f, 0.18991745f, -0.00361072f, -0.10215908f, -0.05297475f, 0.09464157f, 0.09513023f, 
    -0.03210926f, 0.12544969f, -0.04886738f, 0.03669285f, 0.26453111f, -0.43683359f, -0.10030211f, 0.22005466f, 
    0.05893711f, 0.00674917f, -0.00770728f, -0.09460849f, -0.00807307f, -0.10793249f, 0.07128374f, -0.12954780f, 
    -0.16193391f, 0.01585350f, 0.08168489f, -0.17128842f, 0.26859802f, -0.09056749f, -0.02264192f, 0.05755223f, 
    0.14630386f, 0.12171060f, -0.03634458f, -0.00299346f, 0.19492434f, 0.23422508f, 0.11692880f, 0.00676084f, 
    0.03226060f, 0.02267638f, -0.23381127f, 0.13800892f, -0.10495969f, 0.01243825f, 0.05803585f, -0.03292219f, 
    -0.13588281f, 0.08525771f, -0.33297998f, -0.04493239f, 0.12662695f, -0.13411953f, 0.08137392f, 0.13470271f, 
    0.00349221f, -0.05296232f, -0.04709397f, 0.04388760f, -0.19339290f, -0.11891699f, -0.00267088f, -0.11078847f, 
    0.20168763f, -0.05029729f, 0.15048659f, 0.00588154f, -0.01423553f, 0.03774061f, 0.04648970f, 0.11798707f, 
    0.12919861f, 0.08659913f, 0.06677651f, 0.21159628f, 0.02182549f, -0.04273300f, -0.06275799f, -0.12653551f, 
    -0.06253519f, 0.07064252f, 0.14232588f, -0.01959595f, 0.42134857f, -0.16400334f, -0.34479350f, 0.04551547f, 
    0.08964855f, 0.10331847f, 0.03457129f, -0.00961643f, 0.10201953f, 0.07312116f, 0.02102299f, 0.04445431f, 
    0.17433646f, 0.11781428f, 0.13200268f, 0.07843797f, 0.09588198f, -0.13609628f, -0.08645517f, 0.00419583f, 
    -0.01485486f, -0.09107397f, -0.13538100f, -0.01623404f, -0.04248038f, -0.02641780f, 0.10076136f, 0.19830342f, 
    -0.05871333f, -0.08946864f, 0.02330883f, -0.05896043f, 0.05412272f, 0.10874876f, -0.13057877f, -0.06098721f, 
    -0.01034047f, 0.11052688f, 0.10357665f, 0.20919538f, -0.05181788f, -0.03725267f, -0.11105917f, 0.01205361f, 
    0.03453914f, -0.11502197f, 0.16473129f, 0.16158165f, 0.01373846f, -0.07666121f, 0.00964898f, -0.19175585f, 
    0.03623751f, -0.06916939f, 0.10588586f, 0.03072494f, 0.04961976f, 0.05922026f, 0.16094971f, -0.10186158f, 
    0.02632963f, 0.07102912f, -0.10339896f, 0.01527258f, 0.07166090f, 0.05041372f, 0.13307872f, 0.08190241f, 
    0.10226656f, 0.00215304f, -0.08030889f, -0.01228623f, 0.02244344f, 0.33107346f, -0.00551157f, 0.23363198f, 
    -0.00373381f, -0.06581952f, -0.13919012f, 0.10872619f, -0.06794772f, -0.23757255f, -0.05590031f, -0.00844914f, 
    -0.20980793f, 0.16140652f, 0.10213234f, -0.01963417f, -0.00912703f, -0.07617560f, 0.09529273f, 0.13461472f, 
    -0.11453741f, 0.08067307f, -0.03097320f, -0.11358709f, -0.16095744f, -0.12559982f, -0.16450538f, -0.21779078f, 
    0.03046769f, -0.07711118f, -0.02375811f, 0.04558067f, 0.05090889f, 0.00680532f, -0.03061354f, 0.03140105f, 
    0.59628570f, 0.00494040f, 0.00951752f, 0.26290777f, -0.11398606f, -0.01954981f, -0.00730159f, 0.07893702f, 
    0.01752797f, 0.01225463f, 0.00773537f, -0.06974386f, -0.12344798f, -0.18990898f, -0.07813982f, 0.07108279f, 
    0.09613580f, -0.03228769f, -0.05973688f, -0.06382730f, 0.05797622f, 0.07477025f, 0.00643652f, 0.00452513f, 
    -0.22835322f, -0.07391799f, 0.07623281f, 0.00060750f, -0.00972045f, 0.00817555f, -0.11152594f, -0.03984975f, 
    -0.04263017f, -0.06097484f, 0.05456272f, 0.01500095f, 0.19436067f, 0.03308256f, 0.05433866f, -0.12809175f, 
    0.08601553f, 0.02179583f, -0.09783432f, 0.03944980f, 0.08890250f, 0.22165604f, 0.03600272f, -0.00977759f, 
    0.41226918f, -0.16118826f, 0.01000229f, -0.00186657f, -0.02485246f, -0.06284726f, 0.10020603f, 0.08071434f, 
    -0.09852445f, 0.09986080f, -0.03725472f, 0.04742765f, 0.06944129f, 0.28088456f, -0.12086131f, -0.04843647f, 
    0.23478679f, 0.04188214f, 0.05835040f, 0.08287770f, 0.02992045f, 0.08694055f, 0.20326832f, 0.11334699f, 
    0.07420441f, -0.19541149f, 0.01333488f, 0.19927146f, 0.06619077f, 0.05023452f, -0.00731629f, -0.11080036f, 
    0.01184090f, 0.13521099f, 0.02205319f, 0.00042959f, 0.00265974f, -0.01409039f, 0.01962430f, 0.03787411f, 
    0.09757314f, 0.07633489f, 0.05507106f, 0.11164284f, -0.04242123f, 0.05956452f, -0.11640763f, 0.11438294f, 
    -0.21387747f, 0.11392811f, 0.08375741f, -0.40488648f, -0.10162789f, 0.13901950f, 0.09361494f, 0.08943708f, 
    0.14143649f, 0.10332967f, 0.00778170f, 0.11862294f, 0.24292560f, -0.14887570f, 0.00890702f, 0.21483684f, 
    -0.00938496f, -0.03613522f, -0.09033451f, 0.08011585f, -0.00156767f, -0.04039182f, 0.11822379f, -0.08762393f, 
    -0.01831069f, 0.00228031f, 0.21900864f, 0.03831699f, 0.06045509f, -0.07857024f, -0.01832056f, 0.10713787f, 
    0.03364368f, 0.07174867f, 0.19411421f, 0.17894921f, 0.02728317f, 0.06769603f, 0.04631625f, -0.00276096f, 
    0.08496236f, 0.12385040f, 0.06149824f, 0.07757409f, 0.14545481f, -0.07641916f, -0.07857845f, 0.07414915f, 
    -0.11331093f, 0.26061672f, -0.06103350f, -0.15801470f, -0.00224857f, -0.05174211f, -0.13878259f, 0.07936030f, 
    0.07156637f, -0.01362242f, 0.13197619f, -0.00099778f, -0.22000968f, -0.05270346f, -0.07446598f, 0.05165783f, 
    -0.11202629f, -0.15073439f, 0.04724489f, 0.18003105f, 0.08713733f, -0.11160030f, -0.01302919f, -0.01230699f, 
    -0.33445874f, -0.11548802f, 0.06417550f, -0.38058573f, -0.01795519f, 0.11598803f, 0.15780880f, 0.07763980f, 
    0.02840817f, 0.05841449f, 0.07028027f, 0.01886928f, -0.11085225f, -0.06402862f, -0.03010440f, -0.21886379f, 
    -0.01261652f, 0.00047152f, -0.02665055f, 0.05169178f, 0.14472555f, -0.00614152f, 0.00060628f, 0.14413750f, 
    0.15172179f, -0.03603043f, -0.10818768f, -0.25210720f, 0.05361830f, 0.10264475f, -0.08118229f, -0.16750507f, 
    0.07668003f, -0.10027588f, -0.12176374f, -0.04358586f, -0.17753001f, -0.12562008f, 0.04801213f, 0.08880114f, 
    -0.07832033f, -0.01821403f, -0.03103130f, 0.00287108f, 0.04543471f, 0.22336225f, -0.12292683f, 0.05770550f, 
    0.02264471f, 0.11289746f, 0.13136914f, 0.08935951f, -0.02283374f, 0.05973349f, 0.04437546f, 0.07474024f, 
    0.02159668f, -0.07153393f, 0.06316333f, -0.12809989f, 0.09877788f, 0.04683564f, -0.14138921f, -0.01172953f, 
    -0.04805800f, -0.03466995f, -0.04107435f, 0.10977604f, 0.09896392f, 0.12762929f, -0.01771184f, 0.02958783f, 
    -0.05410343f, 0.11572327f, -0.08132529f, 0.07317019f, -0.05994225f, -0.00503993f, 0.03560369f, 0.09121222f, 
    0.03219112f, 0.11219137f, -0.01949361f, 0.07708271f, 0.02374365f, -0.01862882f, -0.03613287f, 0.00126354f, 
    -0.05340619f, -0.03044360f, -0.00427721f, -0.08829222f, 0.04899497f, -0.02603370f, 0.05625895f, 0.02455946f, 
    0.00014655f, -0.09479731f, 0.10728753f, -0.05092489f, 0.04047086f, 0.13335544f, -0.05069317f, 0.17324378f, 
    0.04834149f, 0.09163383f, -0.12934342f, 0.02281212f, -0.27546725f, 0.10621695f, 0.21236059f, -0.02212953f, 
    0.00638624f, 0.01123632f, -0.03124062f, 0.03817112f, 0.03277736f, -0.09256828f, -0.00765816f, -0.00917272f, 
    0.43756968f, 0.03502464f, -0.10184432f, -0.03585909f, -0.04618724f, 0.04386896f, 0.08892845f, -0.04194507f, 
    0.01562154f, 0.07988747f, 0.10445614f, 0.02243270f, 0.18106911f, 0.14356330f, -0.04009352f, -0.25698435f, 
    -0.03971154f, 0.11342438f, -0.00506963f, 0.15539493f, -0.21551380f, 0.01963037f, 0.19424102f, 0.14261904f, 
    -0.06462684f, 0.09179943f, -0.30123463f, -0.15464269f, 0.00592771f, -0.00980596f, -0.05544234f, 0.01880838f, 
    0.06454556f, 0.01456113f, -0.02049563f, -0.08388636f, -0.02673178f, -0.07700022f, -0.09489793f, -0.14486411f, 
    -0.02878853f, -0.03978522f, -0.14205137f, 0.01316766f, -0.12967061f, -0.02882183f, -0.07258235f, -0.04582843f, 
    0.03622109f, -0.03585498f, 0.10697310f, -0.18899958f, 0.04824736f, 0.02883927f, -0.16380724f, 0.07026457f, 
    0.09741431f, 0.02125406f, -0.10102261f, 0.05620577f, 0.10390149f, 0.14119242f, -0.14434665f, -0.08757044f, 
    0.03435102f, 0.18531010f, 0.02270586f, -0.08811617f, 0.11504620f, 0.03487304f, 0.09259683f, 0.00426351f, 
    0.47441623f, 0.07344232f, 0.01617444f, -0.03776568f, 0.03943882f, -0.06963076f, -0.07664404f, 0.01013713f, 
    0.16341139f, 0.02359773f, -0.07678241f, -0.02760568f, 0.03958045f, 0.02490335f, -0.11718749f, 0.26324371f, 
    -0.02861938f, 0.01324409f, -0.05908565f, -0.10952909f, -0.03626025f, -0.01690754f, 0.12296760f, -0.06172750f, 
    -0.05562158f, 0.11355150f, -0.03164576f, -0.05897675f, -0.05778281f, 0.11995148f, -0.00916991f, 0.02516214f, 
    -0.04098095f, -0.01274146f, -0.11811330f, 0.06180859f, -0.02746444f, 0.20596181f, -0.07890176f, 0.17795841f, 
    -0.06481351f, 0.10273870f, 0.03058580f, -0.00054294f, -0.10348703f, -0.11183892f, 0.06210910f, 0.00496046f, 
    0.04604970f, 0.06881137f, -0.07327760f, -0.07637418f, -0.11698907f, -0.08895360f, 0.18568447f, -0.01456807f, 
    0.05500963f, 0.04654792f, 0.00149017f, 0.07547879f, -0.20922790f, -0.17411125f, -0.09407420f, 0.08745876f, 
    -0.10707507f, -0.03361470f, 0.01201200f, 0.03439727f, -0.06002436f, 0.02420416f, 0.02198651f, -0.04396552f, 
    0.22521751f, -0.08234768f, -0.01463285f, -0.06816754f, -0.06072770f, -0.23296194f, 0.08489460f, 0.00501715f, 
    -0.13634299f, -0.04869527f, -0.03668791f, 0.01036489f, -0.51750159f, -0.09144841f, 0.13477585f, -0.22637449f, 
    -0.12547697f, -0.11957379f, 0.06805965f, -0.07905541f, -0.01169992f, -0.10826986f, 0.11164386f, 0.04185956f, 
    -0.14842948f, 0.06407379f, 0.15705746f, 0.16676340f, -0.02681117f, 0.04029386f, -0.01187901f, 0.11232290f, 
    0.03000065f, -0.03118013f, -0.13655205f, 0.09749980f, 0.19052669f, -0.04067141f, 0.10915740f, -0.19527425f, 
    0.00115237f, 0.01632331f, -0.08483605f, -0.02155712f, -0.08583683f, 0.02418424f, 0.02846746f, -0.16641077f, 
    0.22312474f, -0.07581819f, -0.15476702f, 0.01263969f, 0.05752101f, -0.11162055f, 0.09215669f, 0.07657926f, 
    0.01238219f, 0.10817567f, -0.00686946f, -0.01592574f, 0.06145837f, -0.23951857f, 0.07925513f, 0.44297501f, 
    -0.05679956f, 0.05016888f, -0.00273714f, -0.09312735f, 0.00745791f, 0.10980464f, 0.01316640f, -0.06724963f, 
    0.01345515f, -0.18428537f, -0.28125751f, 0.45662829f, -0.12403987f, 0.11367714f, -0.21469842f, -0.08038153f, 
    0.13298431f, 0.02032296f, -0.07681841f, 0.00524112f, 0.13532868f, -0.27277374f, 0.20484899f, -0.05385441f, 
    0.07186420f, 0.06620365f, 0.12785257f, -0.06138908f, -0.21628337f, 0.10267961f, -0.00636022f, -0.06495077f, 
    0.29104507f, 0.27617413f, -0.06070186f, 0.13074379f, 0.18268414f, 0.02489389f, -0.06736892f, 0.00137863f, 
    0.10336810f, -0.09167846f, 0.10793950f, -0.10510909f, 0.19631223f, 0.18835801f, 0.08680362f, -0.05428964f, 
    0.14935355f, 0.08866137f, 0.02800267f, 0.17641890f, 0.02342830f, 0.09318553f, -0.05382927f, -0.05420523f, 
    -0.22857651f, -0.07538014f, 0.22470279f, 0.05800528f, 0.13681577f, 0.08632174f, 0.10987046f, -0.08406484f, 
    -0.06028404f, 0.06749197f, 0.04131144f, 0.08354991f, 0.15350555f, 0.19348215f, 0.32296896f, 0.30235252f, 
    0.17887793f, -0.02738288f, 0.20894921f, 0.16954093f, 0.02758949f, 0.02014742f, 0.00921539f, 0.00833560f, 
    0.01725363f, 0.05552283f, 0.30680609f, 0.06877706f, 0.15412784f, -0.01698608f, 0.08936538f, -0.02148928f, 
    -0.09215331f, -0.07141416f, 0.03144787f, -0.07493167f, 0.24241494f, -0.11776172f, 0.22478354f, 0.40443397f, 
    -0.18854342f, -0.16836433f, 0.01258067f, 0.02032225f, 0.08268070f, 0.06115296f, 0.06481659f, 0.08522398f, 
    -0.09993053f, 0.23977982f, 0.02836823f, -0.22858416f, 0.03117197f, 0.04069622f, 0.02089928f, -0.11605799f, 
    0.04127527f, -0.10733641f, -0.08861204f, -0.05577580f, 0.29564789f, 0.19975685f, -0.07736193f, -0.06141797f, 
    0.07307889f, 0.10760178f, 0.05137039f, 0.09126946f, 0.04730448f, 0.01777630f, 0.06435860f, 0.11945334f, 
    0.19380105f, 0.07323879f, -0.05491781f, 0.24364379f, -0.16438225f, -0.09993871f, -0.08045010f, -0.05807278f, 
    0.09092293f, 0.05433030f, -0.02471294f, 0.01294816f, 0.02911618f, -0.16974014f, 0.18278760f, -0.52538699f, 
    0.03857764f, -0.11047692f, 0.11140512f, -0.01110583f, -0.04840745f, -0.03523378f, 0.09612212f, 0.05256727f, 
    0.23647016f, -0.20805858f, -0.02924477f, 0.16143502f, 0.00298868f, 0.19226520f, -0.08915640f, -0.06795610f, 
    0.01129337f, 0.10824959f, 0.11238096f, 0.00294379f, 0.08141674f, -0.40702495f, 0.02031483f, -0.13734175f, 
    0.01884043f, -0.10404700f, -0.02627802f, 0.06597021f, 0.04289735f, 0.07467391f, -0.16819283f, -0.02068724f, 
    0.25565949f, -0.12535755f, 0.18280913f, 0.05060818f, 0.05404785f, 0.03059244f, 0.07468750f, 0.27944380f, 
    0.00593191f, 0.01520249f, -0.18049906f, 0.08942451f, 0.02352002f, 0.04441816f, 0.23481098f, -0.22015995f, 
    0.02739204f, -0.02564495f, -0.01339432f, -0.03920721f, -0.06589995f, 0.06870399f, 0.03611721f, 0.06822198f, 
    -0.08057953f, 0.11247673f, 0.23643740f, 0.04600255f, 0.08919045f, -0.02887093f, -0.04285000f, 0.04853406f, 
    0.04030148f, 0.01271380f, 0.00663502f, 0.01091005f, 0.02834403f, 0.18121859f, -0.34399509f, -0.29815188f, 
    -0.04641727f, -0.20227490f, 0.01825160f, -0.00152882f, -0.04005236f, 0.12145954f, -0.00359073f, -0.06218171f, 
    -0.06409326f, -0.17940255f, -0.15412265f, -0.21836917f, -0.21362811f, -0.20176841f, 0.09347213f, 0.02739405f, 
    -0.11900140f, 0.02124698f, -0.13226084f, -0.04999644f, -0.12609787f, -0.02535482f, -0.00223491f, -0.08308359f, 
    -0.10829268f, 0.00624196f, 0.07243377f, -0.08672100f, 0.02553036f, 0.01014305f, -0.04722511f, 0.13599595f, 
    0.12022445f, 0.50704736f, 0.20142177f, 0.10644537f, 0.10676362f, 0.04490997f, -0.02331123f, -0.02098657f, 
    0.07004943f, 0.05465393f, -0.02499622f, 0.06059882f, -0.16743484f, 0.17961457f, -0.07770172f, 0.22037853f, 
    -0.06737307f, 0.20933796f, 0.03621268f, 0.00893806f, -0.10535423f, -0.07690707f, 0.05819722f, -0.12963234f, 
    -0.22538753f, 0.21479924f, -0.17722429f, 0.07155097f, 0.09850191f, 0.06872523f, -0.12034667f, 0.02687920f, 
    0.08429587f, 0.13586302f, 0.07240188f, -0.06500874f, 0.14561224f, 0.12956469f, -0.07120044f, 0.02942161f, 
    0.15529126f, 0.21225877f, 0.07529517f, 0.02754972f, 0.00508634f, -0.06623051f, 0.02277514f, 0.16293922f, 
    0.19494955f, 0.07278655f, 0.14736333f, 0.24016827f, 0.08578379f, 0.11101376f, 0.05619154f, -0.07374814f, 
    0.01606183f, -0.00485417f, -0.01099075f, 0.13286953f, -0.34605235f, -0.01783256f, 0.16711764f, 0.02970662f, 
    0.11337899f, 0.07674152f, 0.06161921f, 0.10012286f, -0.06960743f, 0.04279841f, 0.14358693f, -0.00048038f, 
    0.19307500f, 0.20564401f, 0.00779617f, -0.08593821f, 0.08729110f, -0.09985014f, 0.17797984f, 0.20264706f, 
    0.10392438f, 0.05323487f, 0.10649415f, -0.00229728f, 0.00037109f, -0.00078089f, 0.34949136f, -0.06403142f, 
    -0.02257026f, -0.01404389f, 0.12483907f, 0.06868692f, 0.03051642f, -0.13495734f, 0.08925783f, 0.12221872f, 
    -0.00266890f, 0.24173351f, 0.07350327f, 0.28276899f, 0.10788102f, 0.23180397f, 0.00857950f, 0.06768553f, 
    -0.07854678f, 0.03123309f, -0.02429402f, 0.05296644f, 0.10568974f, -0.09805564f, 0.15941933f, 0.09112158f, 
    0.02872311f, -0.02212959f, 0.06017123f, 0.21638568f, 0.02149848f, 0.10016907f, 0.02938188f, 0.02766523f, 
    0.04599978f, -0.09094616f, 0.26316118f, -0.28622535f, 0.06756280f, 0.04048814f, 0.11382590f, 0.15292315f, 
    0.11153799f, 0.16834906f, 0.07053707f, 0.05369059f, -0.10647582f, 0.01956492f, 0.16004942f, 0.35450453f, 
    0.11554216f, -0.01241303f, 0.05637968f, -0.00385226f, 0.11660561f, 0.18307559f, 0.10978659f, -0.02603736f, 
    -0.25344306f, -0.07355217f, -0.05055585f, 0.41022679f, 0.28137860f, -0.03762015f, -0.11197500f, 0.13191096f, 
    0.26986524f, 0.20487474f, 0.23425047f, 0.17464234f, -0.04655464f, -0.25425550f, 0.25114241f, 0.02913984f, 
    0.08331020f, 0.31219700f, 0.06895600f, 0.10698196f, 0.00000983f, 0.03447911f, 0.01212600f, 0.01727329f, 
    0.12360820f, -0.07631503f, 0.07679968f, -0.13314317f, 0.02015750f, 0.11540773f, -0.04010830f, 0.14287473f, 
    0.23912966f, -0.07842302f, 0.17414494f, 0.00078012f, 0.01558309f, -0.17862195f, -0.08452246f, 0.16538040f, 
    0.19536813f, 0.02009070f, -0.07886936f, 0.33013141f, 0.08760885f, -0.04397138f, 0.07089356f, 0.11316816f, 
    -0.40265980f, -0.21696913f, 0.29910481f, -0.06968164f, 0.09866566f, 0.15632395f, 0.13125400f, 0.09059779f, 
    0.08747791f, 0.10457127f, 0.16608445f, 0.13881411f, -0.07905576f, -0.23697990f, 0.11437552f, 0.10287730f, 
    0.26244879f, 0.07520092f, 0.09303676f, 0.27079630f, 0.11770616f, 0.05918153f, 0.03657801f, 0.11967956f, 
    0.17454962f, -0.24062635f, 0.16379891f, -0.05560539f, 0.04894829f, -0.00483727f, 0.09982403f, 0.11062749f, 
    0.13712622f, -0.07266465f, 0.13892718f, 0.02300486f, 0.11317699f, 0.25721544f, 0.17484902f, 0.20419775f, 
    0.02380683f, -0.06809448f, 0.02007918f, 0.01108913f, -0.10042243f, 0.14303398f, 0.10097585f, 0.09682492f, 
    0.19685884f, 0.34629267f, 0.03172798f, 0.10807327f, -0.18533599f, 0.03459112f, 0.02042451f, -0.02551782f, 
    0.04030731f, 0.01354457f, 0.01136042f, 0.05547172f, 0.05609563f, -0.24804457f, -0.04379253f, -0.12053166f, 
    -0.01047084f, -0.09468862f, 0.08464558f, -0.06258786f, 0.09059721f, 0.00057260f, -0.02163831f, 0.15240423f, 
    0.34460482f, -0.13000424f, 0.09305272f, 0.12200682f, -0.08180264f, 0.23878551f, 0.01647492f, -0.17632128f, 
    0.10143435f, 0.12892139f, 0.14644083f, 0.04533305f, 0.20593800f, 0.15414131f, 0.36899012f, -0.10810507f, 
    0.05844525f, 0.01401393f, 0.09729335f, 0.16103156f, 0.14844400f, -0.02015311f, 0.06937885f, 0.09724340f, 
    0.01266288f, -0.00307081f, -0.05520754f, 0.19573209f, 0.04830486f, 0.13883029f, -0.04126330f, 0.05334592f, 
    0.06825604f, 0.03277016f, 0.08397719f, 0.07730172f, 0.04216190f, 0.02096673f, 0.31427950f, -0.09726635f, 
    -0.00565586f, 0.04834946f, 0.01715074f, -0.04483757f, 0.06722414f, -0.10204814f, -0.08199416f, -0.02793352f, 
    -0.26920137f, -0.29614806f, -0.10858937f, -0.00848378f, -0.07914123f, -0.04938261f, 0.03969969f, 0.15644966f, 
    0.10721584f, 0.05841090f, 0.03865320f, 0.03056579f, 0.06485948f, 0.18008645f, 0.35272068f, -0.19724709f, 
    0.23405036f, 0.04867487f, 0.13282779f, 0.22619551f, 0.08872161f, 0.02910635f, 0.11811201f, 0.04743012f, 
    -0.12237822f, 0.17900431f, 0.06094154f, 0.10053784f, 0.09654369f, 0.11415891f, 0.06752423f, 0.23751672f, 
    0.09580820f, 0.12340353f, 0.07632548f, 0.17402209f, 0.03956535f, 0.07107244f, 0.22432280f, -0.16059864f, 
    -0.09648035f, 0.14645803f, 0.15000574f, 0.18288164f, 0.10566600f, 0.09462648f, -0.04625270f, 0.20094125f, 
    0.19544195f, -0.11442517f, 0.21482749f, -0.03055519f, -0.16074160f, -0.10308143f, 0.21723941f, 0.12737225f, 
    -0.08766190f, 0.06301317f, -0.10506378f, 0.06383739f, -0.20088769f, -0.05662752f, 0.08320962f, -0.21265846f, 
    -0.03387810f, 0.08585301f, 0.11631548f, -0.01144221f, 0.02627503f, -0.01988537f, -0.02420497f, 0.10842028f, 
    0.18853885f, 0.27557987f, -0.06651963f, -0.03105601f, 0.15366428f, -0.03933544f, -0.08228696f, -0.04289020f, 
    0.04909916f, 0.06197621f, -0.01840925f, 0.01729382f, 0.04164825f, 0.13798179f, 0.13980070f, 0.25173697f, 
    -0.01472840f, 0.19558497f, -0.00940740f, -0.10179572f, -0.05475378f, -0.09652101f, 0.19185628f, 0.05553045f, 
    0.18252113f, -0.31808603f, 0.04297419f, 0.10371368f, 0.00729580f, -0.01461126f, 0.05036778f, 0.09276972f, 
    0.13775481f, -0.00860208f, 0.09551080f, 0.14812744f, 0.29658869f, 0.28090361f, -0.04026023f, 0.00551618f, 
    -0.16676232f, 0.03644228f, -0.06978688f, 0.01461801f, 0.01778498f, 0.02735021f, -0.13794719f, -0.09631740f, 
    0.25498590f, 0.25274470f, -0.07092008f, 0.12370293f, -0.00163142f, -0.09109284f, 0.14344352f, 0.06037801f, 
    0.01204951f, 0.12405153f, -0.05683761f, -0.12643759f, -0.11658724f, 0.06803062f, 0.14630488f, -0.15600556f, 
    0.08691843f, 0.18635449f, 0.17000479f, 0.06152639f, 0.12517492f, -0.04125961f, 0.06876818f, 0.08084095f, 
    0.06745207f, 0.09869782f, 0.08495831f, -0.03263031f, 0.09652311f, 0.17370817f, 0.01030916f, -0.15343240f, 
    -0.00549252f, 0.07698963f, -0.07796390f, 0.09169114f, -0.20583864f, -0.01223378f, 0.02962066f, 0.01790200f, 
    -0.02612732f, 0.19023132f, 0.02333637f, -0.20213903f, 0.01744483f, 0.18833232f, -0.04300114f, -0.08531407f, 
    0.15034904f, 0.32244909f, 0.20809500f, 0.04165401f, -0.00316481f, -0.02770984f, -0.03557561f, 0.10526566f, 
    0.03421434f, -0.02528372f, 0.17810394f, 0.22235000f, -0.08471733f, 0.03937060f, -0.02307486f, -0.21631472f, 
    0.15422060f, 0.10235875f, 0.09800989f, -0.05944121f, 0.08524480f, -0.06874068f, 0.00629202f, 0.02914275f, 
    -0.07216977f, 0.04761439f, -0.12176900f, 0.17904447f, -0.04216310f, -0.10570937f, 0.03045226f, 0.05784159f, 
    -0.09389586f, -0.17542098f, 0.16278115f, 0.11201174f, 0.21261573f, 0.26639971f, 0.16415319f, 0.06938816f, 
    0.02614744f, -0.00143626f, 0.03217989f, 0.04575508f, 0.14216827f, 0.11164006f, -0.05251539f, 0.06397767f, 
    -0.21076362f, -0.01012198f, 0.00185526f, -0.34173328f, -0.03406804f, -0.01230235f, -0.00926119f, 0.05032154f, 
    -0.00978948f, 0.05951932f, -0.11581224f, -0.16117124f, -0.08023304f, -0.08284646f, -0.14558700f, -0.08714398f, 
    0.06023404f, 0.01442078f, 0.03870442f, 0.04049630f, -0.00425418f, 0.07037979f, -0.00654180f, 0.05646208f, 
    -0.10717509f, -0.20032835f, 0.05452018f, 0.29730517f, -0.00858732f, 0.00115066f, 0.06650861f, 0.15460706f, 
    -0.04130057f, 0.17398249f, -0.07473957f, 0.07988152f, 0.25806686f, -0.10470051f, -0.15041144f, -0.23752791f, 
    0.00706538f, -0.08462176f, 0.07835606f, -0.02123545f, -0.10760116f, 0.21616304f, 0.09092693f, 0.06413243f, 
    -0.21497318f, -0.02862895f, 0.00966183f, -0.05568972f, -0.06836846f, 0.04703746f, 0.06251766f, 0.00268761f, 
    0.07248436f, -0.02539432f, 0.04077623f, 0.03243772f, -0.03688934f, -0.01033779f, 0.11052614f, 0.14959624f, 
    -0.09882890f, -0.05560950f, 0.16629268f, 0.21261835f, -0.04971737f, 0.17262948f, 0.04256922f, -0.01942445f, 
    -0.39135161f, -0.10436618f, 0.28510711f, 0.21337053f, 0.04926216f, -0.02225347f, 0.12587632f, 0.17750016f, 
    0.03759102f, 0.21653539f, 0.25083041f, 0.06818634f, 0.01797126f, 0.43662176f, 0.28125009f, -0.09768959f, 
    0.11268225f, -0.04229905f, -0.03936895f, 0.03696622f, 0.10459241f, 0.03102072f, 0.05280554f, -0.10506743f, 
    0.23249388f, 0.11353973f, 0.00015281f, 0.06591615f, 0.26117378f, 0.03933508f, -0.10272992f, 0.08771825f, 
    -0.01019723f, 0.05155151f, 0.04856931f, 0.10427056f, 0.08749633f, -0.06938877f, -0.13083719f, 0.18371193f, 
    0.07947690f, -0.01552443f, 0.02275587f, 0.11213551f, -0.09381321f, -0.12005038f, 0.01475656f, -0.14835690f, 
    0.06417197f, 0.12021835f, 0.10197700f, 0.40710348f, -0.11250558f, -0.02014279f, -0.11178183f, 0.06547514f, 
    -0.05668293f, 0.03852359f, -0.15044835f, 0.16782556f, 0.16896124f, 0.05145949f, -0.15061387f, -0.03936911f, 
    0.09719928f, 0.04415594f, 0.08110666f, -0.18304983f, 0.03529153f, -0.08156069f, 0.00400348f, -0.08837018f, 
    -0.10368211f, 0.04372454f, -0.20923170f, 0.09491590f, 0.08207704f, -0.02807933f, 0.15121073f, 0.25305626f, 
    0.06466621f, -0.17188309f, 0.14891855f, 0.14394581f, -0.19749600f, 0.08115637f, 0.15727447f, 0.28151500f, 
    0.04562616f, 0.04861436f, -0.03747044f, -0.04517607f, 0.01930340f, 0.14984940f, -0.00202965f, 0.16952847f, 
    -0.01160059f, 0.04525791f, -0.04066620f, -0.13966137f, 0.06720093f, 0.15416387f, 0.12315229f, 0.01591683f, 
    0.04413537f, -0.00481588f, -0.02201287f, -0.16884960f, -0.05862423f, 0.03072408f, 0.00866852f, 0.16488139f, 
    0.03472666f, -0.06040017f, 0.00793558f, 0.03299290f, 0.05712864f, 0.00952195f, 0.00462086f, -0.10313903f, 
    0.06598298f, -0.05588312f, -0.02738110f, -0.45526561f, 0.03119018f, -0.08279058f, 0.21727504f, -0.08519398f, 
    0.08551721f, 0.12009705f, 0.14186350f, 0.18257473f, 0.12217316f, 0.07578898f, 0.00818958f, 0.27504468f, 
    0.08372083f, -0.00971014f, 0.15365754f, -0.04212889f, 0.06921062f, -0.07538256f, -0.10032463f, -0.00179640f, 
    0.20359428f, 0.03297482f, -0.23434085f, 0.06984959f, -0.03960008f, 0.04443817f, 0.01683632f, -0.06702421f, 
    0.11208412f, -0.12533692f, 0.10533539f, -0.00820685f, -0.15970850f, -0.03092678f, -0.18147935f, 0.06861829f, 
    -0.00235998f, 0.07345599f, 0.08641911f, -0.09651420f, -0.06444258f, 0.07266221f, 0.06402820f, -0.06569155f, 
    -0.14220957f, -0.51104581f, -0.11500535f, 0.25684419f, -0.01931035f, -0.06100140f, 0.05358863f, 0.16535161f, 
    0.03978405f, -0.04814047f, 0.10479297f, 0.13635473f, 0.27736720f, 0.25790191f, 0.15380587f, 0.12466270f, 
    0.09630634f, 0.03739782f, 0.15275709f, 0.17535436f, 0.06767792f, 0.19243485f, 0.02383799f, 0.17809319f, 
    0.08856001f, -0.37276235f, 0.27045649f, 0.00772660f, -0.13189368f, -0.01824582f, -0.05100719f, -0.01869779f, 
    0.04232595f, 0.00720336f, 0.07187387f, 0.03432401f, 0.35528579f, -0.00654940f, 0.12843251f, -0.04913980f, 
    -0.03206624f, 0.04839257f, 0.00583567f, -0.18458502f, -0.07387981f, 0.06629530f, -0.15281048f, -0.21760099f, 
    0.08659350f, -0.00757688f, 0.12658770f, 0.17772099f, 0.09633739f, -0.03116499f, -0.00121594f, -0.01218357f, 
    -0.12112924f, -0.07071008f, -0.08266941f, -0.09822268f, -0.14630964f, 0.13019951f, 0.05118629f, -0.22105347f, 
    0.12557864f, -0.14732341f, 0.05273363f, -0.03991218f, -0.01000091f, -0.02308215f, -0.06311351f, -0.02820968f, 
    0.08288786f, -0.06403544f, 0.17668623f, -0.06023659f, -0.10618317f, 0.04588113f, -0.01407931f, -0.15620369f, 
    -0.07418531f, 0.00214128f, -0.05222101f, 0.01206859f, 0.22979599f, 0.19887193f, -0.22498342f, -0.01431098f, 
    0.01431854f, 0.17301579f, 0.06366649f, -0.09890103f, -0.04453150f, 0.05536072f, -0.04076695f, -0.11335189f, 
    0.23430900f, -0.03250055f, 0.04843240f, -0.07807182f, 0.00148011f, -0.02704723f, 0.01256111f, -0.01871625f, 
    0.00671549f, 0.08749037f, 0.15375534f, -0.07677234f, 0.03407891f, 0.33365044f, -0.02694578f, -0.09277651f, 
    0.04034251f, -0.02862986f, 0.16694066f, -0.01127418f, 0.06304418f, -0.01593053f, -0.00972051f, 0.10834780f, 
    -0.15324013f, 0.46015343f, 0.04270435f, 0.28297761f, 0.04166904f, -0.10169618f, 0.00927457f, -0.02297512f, 
    -0.06345376f, -0.21543312f, 0.12327705f, 0.04659092f, 0.22648223f, 0.23506659f, 0.04148970f, -0.12295827f, 
    0.11443254f, 0.02904789f, 0.05442489f, -0.00870263f, -0.08595698f, -0.12604567f, 0.03891699f, 0.01649591f, 
    -0.06173551f, 0.16518222f, 0.07238164f, -0.38145003f, -0.10100048f, 0.19931552f, 0.12562707f, 0.07754023f, 
    -0.19588436f, -0.00774607f, -0.08960096f, -0.24556983f, 0.03457995f, 0.20858742f, -0.14808941f, -0.02899143f, 
    0.00963067f, -0.00406090f, -0.09052563f, 0.03537922f, 0.08038267f, 0.05327377f, 0.04430644f, 0.18990739f, 
    -0.14434619f, -0.04597877f, 0.15604012f, 0.27000332f, -0.04403450f, -0.09108327f, -0.03298349f, 0.12460744f, 
    -0.00836168f, 0.08269865f, -0.09638935f, 0.16282831f, 0.18950580f, -0.13211061f, 0.05722578f, 0.06170210f, 
    -0.03522569f, -0.06465992f, 0.06384321f, -0.13331419f, -0.03791139f, -0.01642181f, 0.05040715f, 0.05589011f, 
    -0.08858103f, 0.25683114f, -0.09435624f, -0.20303068f, -0.07320913f, -0.08500890f, -0.05697518f, 0.07166350f, 
    0.04547199f, -0.03895120f, -0.02402674f, -0.00409416f, -0.21330242f, -0.09513022f, -0.03770087f, 0.06146964f, 
    -0.12063355f, 0.06193605f, -0.05540281f, 0.01976898f, -0.04490244f, 0.04357640f, -0.02384651f, -0.05626382f, 
    0.14013775f, 0.12964906f, 0.03772378f, 0.14375319f, -0.01117348f, -0.01955367f, -0.05705737f, 0.13098341f, 
    0.04676032f, 0.26250499f, 0.08967967f, 0.08262684f, -0.04790397f, 0.22819857f, -0.01210158f, -0.00653498f, 
    0.24720055f, -0.01108898f, 0.04051602f, -0.03589036f, -0.09562062f, -0.06157845f, 0.00440256f, -0.10182139f, 
    0.16974764f, -0.08151172f, 0.02801885f, 0.15538476f, -0.01853815f, 0.02596585f, 0.00588245f, 0.04984029f, 
    -0.12626775f, 0.10871901f, 0.06914400f, 0.03508409f, -0.10933533f, 0.05699880f, 0.11203108f, 0.22080722f, 
    -0.02713118f, 0.01837424f, -0.10335349f, 0.01695181f, -0.05339393f, -0.12311555f, -0.00803371f, -0.20078149f, 
    -0.08413389f, 0.16334151f, 0.05631119f, -0.11401266f, 0.13527866f, 0.04911629f, -0.03256136f, -0.05226104f, 
    -0.20524466f, -0.14776450f, -0.12980478f, 0.04350942f, 0.22202367f, 0.16257003f, -0.25359043f, 0.05279288f, 
    -0.09796739f, 0.02107251f, 0.06044686f, -0.05096877f, -0.12402620f, 0.01070739f, -0.14264137f, 0.00306077f, 
    0.04196643f, 0.31631082f, 0.05205309f, -0.04537849f, 0.12802759f, -0.08743676f, 0.13709296f, 0.12000331f, 
    0.00572186f, -0.09887809f, -0.05483374f, 0.12441669f, -0.19040228f, 0.31584471f, -0.14352091f, 0.00885651f, 
    0.11036946f, 0.06487060f, -0.04987920f, -0.07879134f, -0.09584486f, -0.03097005f, 0.24602833f, 0.01740517f, 
    0.25846934f, 0.15284710f, 0.12800385f, -0.09152077f, -0.01282571f, 0.06588528f, -0.03417165f, -0.08923282f, 
    -0.02392244f, -0.07544617f, 0.10726661f, -0.18136957f, 0.16678892f, 0.00599584f, -0.02173424f, 0.13649267f, 
    0.04510598f, -0.06646253f, -0.00112141f, 0.06349168f, -0.04712129f, -0.04382538f, -0.08831405f, -0.01308434f, 
    0.02292454f, -0.18197861f, -0.19168316f, -0.17163308f, 0.00454369f, -0.06856493f, -0.03103853f, -0.08077538f, 
    0.00102726f, 0.05120789f, 0.03377178f, 0.13498405f, -0.05329321f, 0.20681782f, 0.00169242f, 0.45404616f, 
    0.13587295f, 0.01577515f, 0.08588912f, 0.07585697f, 0.06382135f, -0.08762044f, -0.12088675f, -0.11829044f, 
    0.04925164f, 0.32001147f, -0.10913442f, -0.05532834f, 0.25025100f, 0.13127501f, -0.00909297f, -0.00808265f, 
    0.16095492f, -0.05888427f, 0.08062647f, -0.06016478f, 0.34833521f, -0.09646197f, -0.03082401f, -0.03265617f, 
    0.06107776f, 0.19279210f, -0.09045937f, -0.07858365f, -0.07314444f, -0.02413213f, 0.11245884f, -0.25947943f, 
    0.12840369f, -0.29248723f, 0.09025313f, 0.08790456f, -0.12136383f, -0.02784475f, 0.07009597f, 0.16276509f, 
    0.03858643f, -0.10836513f, 0.07008735f, 0.02258765f, 0.43055969f, -0.04025552f, 0.11124793f, 0.01151816f, 
    0.10145220f, 0.01577717f, 0.13515891f, 0.00143114f, 0.08136527f, 0.28156650f, 0.08229765f, 0.10617223f, 
    0.03839882f, -0.03972697f, -0.03232850f, -0.01919999f, 0.01620895f, 0.00292547f, -0.04358423f, 0.04546941f, 
    -0.01550580f, -0.04711672f, 0.00180528f, -0.03114816f, -0.03247414f, 0.03701090f, -0.01107144f, 0.04211398f, 
    0.01445924f, 0.01360659f, 0.01616433f, 0.03561886f, 0.03307591f, 0.02527350f, 0.00220703f, -0.02168694f, 
    -0.03438370f, 0.04242786f, -0.03113914f, -0.00264966f, 0.03549954f, -0.02927981f, -0.00271734f, -0.02482847f, 
    0.02857462f, 0.00252342f, 0.01141180f, -0.00099138f, 0.00619541f, 0.01933296f, 0.00669228f, -0.05590312f, 
    -0.01109252f, -0.04825784f, 0.03471711f, -0.04915269f, 0.01660105f, 0.03149366f, -0.02112846f, -0.03703815f, 
    0.00140949f, -0.00871824f, 0.01175602f, -0.03790671f, 0.03958666f, 0.01081599f, -0.00124716f, -0.02591261f, 
    -0.04688689f, -0.03805022f, 0.01089744f, 0.01742136f, -0.00231942f, -0.04292981f, 0.03120134f, -0.04432300f, 
    0.03739493f, -0.02785149f, -0.03862945f, 0.01992380f, 0.01106925f, -0.01499803f, -0.04098270f, 0.01391078f, 
    -0.02624585f, -0.03333694f, -0.00275391f, -0.02508225f, 0.01342572f, -0.02571376f, -0.05461070f, 0.04157782f, 
    0.00447923f, -0.05913293f, -0.04640407f, -0.02759655f, 0.00636348f, -0.05453987f, -0.01664149f, -0.01037098f, 
    -0.00153235f, -0.00369873f, 0.02568070f, 0.00400452f, 0.00937278f, -0.04687628f, 0.02354269f, -0.05073108f, 
    0.01432204f, 0.01320098f, -0.02638498f, 0.00806992f, 0.02071371f, -0.01847928f, 0.01716636f, -0.01528877f, 
    -0.02152027f, -0.00833269f, -0.04024496f, -0.04315218f, -0.04415018f, 0.02850104f, 0.01754303f, 0.01988390f, 
    -0.02398083f, -0.03562418f, 0.00666502f, -0.01960578f, 0.01209857f, 0.03462140f, 0.00869909f, -0.04620815f, 
    -0.00761225f, 0.03305573f, -0.03906158f, 0.02426540f, 0.01014406f, 0.03450025f, 0.04050637f, 0.03882548f, 
    -0.05045487f, -0.00014737f, -0.03363733f, -0.00420025f, -0.00894959f, 0.02871781f, -0.00366304f, -0.04223381f, 
    -0.01294184f, -0.02398369f, 0.02549257f, 0.03305581f, -0.05623939f, -0.04170118f, -0.03783093f, 0.00982641f, 
    0.03506181f, -0.02516834f, -0.01998558f, 0.03830811f, -0.01027065f, 0.00076395f, -0.00569454f, 0.02915567f, 
    -0.05825301f, -0.04077033f, 0.01992745f, -0.00897039f, 0.04434034f, 0.00613298f, -0.03206757f, 0.02926748f, 
    -0.04809881f, 0.00811501f, -0.01447727f, -0.02399663f, -0.01984643f, -0.04079393f, 0.02347866f, -0.03522607f, 
    -0.04574458f, -0.01405848f, 0.04214387f, -0.03689648f, -0.05375586f, -0.01856633f, 0.01180018f, -0.05310206f, 
    0.02424316f, -0.04923911f, 0.04324272f, -0.03423543f, 0.03776587f, -0.02274509f, 0.03402255f, -0.05686496f, 
    -0.02521294f, 0.03338692f, 0.01937930f, -0.04690877f, 0.02106160f, -0.02685078f, -0.03786027f, 0.03560365f, 
    0.03925970f, 0.02597843f, 0.03420132f, -0.05645120f, -0.04553003f, -0.01016966f, -0.00745268f, 0.03661211f, 
    0.00481460f, -0.00284887f, -0.01505447f, -0.02038900f, 0.01695956f, -0.01634000f, -0.00472978f, 0.01929035f, 
    0.01453487f, 0.01637257f, -0.00447066f, -0.03781724f, -0.04698184f, -0.05622390f, 0.01390743f, -0.01388163f, 
    0.01541352f, -0.01706818f, -0.00540902f, -0.03439052f, -0.00327607f, -0.02311679f, 0.01154523f, 0.03092176f, 
    0.03885465f, -0.01056097f, 0.01175922f, -0.04359249f, -0.01708615f, 0.01404364f, -0.04059983f, -0.02300013f, 
    -0.04813335f, 0.00224701f, -0.00707909f, -0.00519886f, 0.01788615f, -0.02642170f, -0.00525415f, -0.05423567f, 
    -0.03500587f, -0.04696296f, -0.04003359f, -0.04828914f, -0.04837278f, -0.05689263f, 0.00906160f, -0.05479194f, 
    0.03538934f, 0.02132531f, -0.00085451f, 0.03297127f, -0.02412362f, 0.02595249f, -0.05065523f, 0.01066346f, 
    -0.03313893f, -0.01591253f, -0.02733730f, -0.03168205f, -0.04283641f, 0.03561088f, -0.03012197f, 0.00065442f, 
    -0.00923133f, 0.00231298f, 0.02883044f, -0.04303722f, 0.00789352f, -0.01573006f, 0.01414588f, -0.05349325f, 
    0.02031781f, -0.05489986f, 0.02094849f, -0.02712419f, 0.01518239f, -0.01085814f, 0.00526942f, 0.00642546f, 
    -0.03410245f, 0.02124203f, 0.01361589f, 0.01550703f, -0.01972996f, -0.02518867f, -0.02443537f, -0.04719643f, 
    0.00378231f, -0.02003200f, -0.00603603f, 0.00209985f, -0.01142002f, 0.03738716f, 0.00024142f, -0.04870229f, 
    0.00473905f, -0.02195740f, -0.04412375f, 0.00819357f, -0.02403497f, 0.02511225f, 0.00043876f, -0.02176397f, 
    0.00095489f, 0.03372795f, 0.00915177f, 0.03766333f, -0.01916993f, 0.02758252f, 0.02482400f, 0.01860574f, 
    0.02184687f, 0.03006942f, -0.03762295f, 0.02537892f, 0.03850488f, -0.00781138f, -0.06172901f, -0.04620152f, 
    -0.02922652f, -0.00469273f, -0.03475701f, -0.03239275f, -0.01274710f, -0.03981699f, -0.05894222f, 0.00446131f, 
    0.04128847f, -0.03242335f, -0.00838567f, 0.03050852f, -0.03245819f, -0.04295536f, 0.03949657f, 0.02707477f, 
    0.03004044f, 0.00108545f, 0.03707767f, -0.01218253f, 0.03609736f, 0.01703431f, 0.03191403f, -0.01212418f, 
    0.02310229f, -0.03447381f, -0.02604555f, 0.00505308f, 0.01345768f, -0.03673019f, 0.00611416f, -0.01542955f, 
    -0.04619410f, 0.02193254f, 0.04863212f, -0.04623068f, -0.02330534f, -0.04708165f, -0.02315739f, -0.03172965f, 
    0.02353951f, -0.03138916f, 0.00247272f, -0.04615131f, -0.03279117f, -0.03675481f, -0.00551730f, -0.04876456f, 
    -0.02974219f, 0.00505501f, -0.00133454f, -0.04257077f, -0.04035314f, 0.02156524f, -0.04548042f, 0.02946039f, 
    0.05106384f, 0.00494920f, 0.01683934f, 0.02256649f, 0.02898083f, -0.00994679f, -0.02519354f, 0.01436980f, 
    -0.04951778f, -0.02858128f, -0.03679740f, 0.01474793f, 0.00534694f, 0.01130568f, -0.00385545f, -0.02085870f, 
    -0.04539430f, -0.05194966f, -0.02920886f, -0.04825164f, 0.03908754f, 0.04082770f, -0.02036462f, -0.05116691f, 
    -0.04087177f, -0.02125627f, -0.03995437f, 0.03370180f, 0.00249667f, -0.05100261f, -0.00383141f, -0.04139762f, 
    -0.02288885f, 0.02670975f, -0.03478562f, 0.01155178f, 0.00569712f, -0.05194277f, -0.00468840f, -0.01044083f, 
    0.00220677f, -0.05464582f, 0.00816453f, -0.01351885f, -0.03409537f, -0.00086489f, -0.02310220f, -0.04697221f, 
    0.03890103f, 0.00452251f, 0.02828766f, -0.04601222f, -0.04733811f, 0.02940212f, 0.01076690f, -0.00183048f, 
    -0.04054513f, -0.00251977f, -0.05623701f, -0.03589448f, 0.00580265f, -0.03539950f, -0.04129814f, -0.00405350f, 
    -0.01448324f, 0.01795718f, 0.01912377f, -0.01236862f, 0.03673603f, -0.01705526f, -0.02384864f, -0.00289930f, 
    0.03434688f, 0.02165256f, -0.02906525f, 0.02420904f, 0.04161524f, 0.01910333f, 0.02542275f, -0.01800470f, 
    -0.01142422f, -0.05181484f, -0.04334916f, -0.01422819f, -0.00137430f, -0.04137210f, -0.01979036f, -0.00199673f, 
    0.03643478f, 0.01266688f, 0.00675550f, -0.05109649f, -0.04605860f, 0.02672658f, 0.02119581f, -0.03446511f, 
    0.02809710f, -0.05607712f, -0.05749858f, 0.02948057f, 0.03762103f, -0.04588523f, -0.00171943f, -0.00972025f, 
    -0.01122082f, -0.04481332f, -0.00013759f, -0.00134247f, 0.01463385f, 0.02279435f, -0.02096546f, 0.01008768f, 
    -0.01405775f, 0.01562413f, 0.00713031f, -0.04083659f, 0.00389466f, 0.01502530f, 0.02037747f, -0.03189831f, 
    0.01436332f, 0.01070269f, 0.01624265f, 0.03905808f, 0.00290348f, -0.02681869f, 0.02274831f, -0.02432707f, 
    0.02170256f, 0.02888741f, 0.02699158f, 0.00030310f, -0.04420003f, -0.00272579f, 0.02576612f, 0.03558107f, 
    -0.02784008f, -0.01900675f, -0.04601878f, -0.04030657f, 0.03174340f, -0.03865001f, 0.03876324f, 0.00351423f, 
    -0.02133235f, 0.01565855f, -0.02013911f, 0.00981792f, -0.00148195f, -0.00128391f, -0.01473784f, -0.02740995f, 
    0.03437553f, 0.02645121f, -0.01356182f, -0.03551511f, -0.04443609f, -0.02302763f, -0.03182863f, -0.05396358f, 
    -0.04305281f, 0.01126610f, -0.02383480f, -0.03667201f, -0.04537532f, 0.02032069f, -0.04460325f, -0.04895514f, 
    0.01077590f, -0.00163155f, -0.03682455f, -0.02762055f, 0.03449079f, 0.00932688f, 0.00390096f, -0.05055053f, 
    0.03612678f, -0.04282846f, 0.03632549f, -0.01296933f, 0.03085161f, -0.05543526f, 0.01043216f, 0.03167434f, 
    0.00459457f, -0.05441834f, 0.04029690f, -0.04239424f, 0.01953605f, -0.00664710f, 0.00971529f, 0.03229251f, 
    0.01843354f, 0.01219663f, -0.03971083f, 0.02821341f, -0.05307953f, 0.02220335f, 0.03417774f, 0.01294384f, 
    -0.00285702f, 0.01716542f, 0.03702578f, -0.04749557f, -0.03674448f, 0.02090338f, 0.01463970f, 0.01429177f, 
    -0.03324387f, -0.03721453f, 0.01235331f, -0.04425668f, -0.01923209f, 0.03373931f, 0.02771484f, -0.03411935f, 
    -0.01445108f, 0.01330630f, 0.00680702f, -0.04242665f, 0.04071079f, 0.02707678f, -0.03518821f, 0.03352834f, 
    0.01808406f, -0.03176419f, 0.00938082f, -0.03984088f, -0.00204857f, 0.00855340f, -0.05423275f, -0.03448832f, 
    0.03013266f, -0.00673628f, -0.03988986f, -0.02513368f, 0.02736796f, 0.02363835f, -0.03974776f, 0.00308965f, 
    0.01203506f, -0.00125823f, 0.02510285f, -0.04543892f, -0.05389108f, 0.00691225f, -0.05732814f, 0.02381276f, 
    0.02245814f, 0.03387948f, -0.01244738f, -0.00914090f, 0.01987546f, -0.02810927f, 0.01220827f, -0.02554517f, 
    0.02631722f, -0.03371296f, -0.01265009f, -0.02615148f, 0.02238659f, -0.05577669f, 0.03921850f, -0.02924209f, 
    -0.00089986f, -0.01647601f, -0.02922434f, -0.02744532f, -0.01476348f, -0.05137862f, 0.01925030f, -0.01115204f, 
    0.01565250f, -0.02985742f, 0.01512525f, -0.00138728f, 0.03370889f, -0.05447753f, -0.02525360f, -0.02449850f, 
    -0.01659264f, -0.02765168f, -0.04600242f, 0.00254700f, -0.01308019f, -0.00958942f, -0.01221012f, -0.04470511f, 
    -0.03685093f, -0.01014317f, 0.04042495f, -0.00336530f, 0.03755279f, -0.04660403f, 0.02028203f, -0.00681460f, 
    -0.00008354f, 0.01768163f, -0.03559996f, 0.02668512f, 0.04117765f, 0.04124468f, 0.00219943f, -0.03033752f, 
    -0.01851633f, 0.00932817f, -0.03055016f, 0.02905878f, -0.02672920f, -0.01403677f, 0.00189481f, -0.03069939f, 
    -0.04151648f, 0.01456610f, -0.04015682f, 0.00240887f, 0.04422414f, -0.02530753f, 0.02796355f, -0.05594770f, 
    0.03799012f, -0.00682768f, -0.01995041f, -0.03737027f, -0.01782349f, -0.01766259f, -0.05059366f, -0.05653003f, 
    -0.04024409f, -0.04868154f, 0.03921165f, 0.00962536f, -0.02995144f, 0.03517022f, -0.00654116f, 0.02919145f, 
    -0.01481393f, 0.02471056f, -0.03536448f, -0.00043040f, 0.02477997f, -0.00135712f, 0.03772711f, 0.00842159f, 
    -0.04474727f, 0.01926187f, 0.00325926f, 0.02861726f, -0.04584067f, 0.01239991f, 0.04180557f, -0.00569365f, 
    -0.05538979f, 0.01244310f, -0.03307424f, -0.05709086f, 0.00537335f, -0.00629595f, 0.03301510f, -0.03262158f, 
    0.03888559f, 0.00375941f, -0.03483921f, -0.01972757f, 0.00411141f, -0.02507525f, 0.01908624f, -0.05286972f, 
    0.01486243f, -0.02991418f, -0.00404844f, -0.04090315f, 0.01926102f, -0.01889640f, 0.00352907f, -0.03738109f, 
    0.01802586f, -0.00062231f, -0.02273927f, 0.03270290f, -0.00536092f, 0.01955034f, 0.01937895f, 0.03002037f, 
    0.04160497f, -0.01883231f, 0.00098964f, 0.01109240f, -0.05374704f, -0.00388209f, -0.03163006f, 0.01401070f, 
    -0.22925723f, 0.07998324f, 0.04662153f, -0.01613443f, -0.04765438f, -0.04943502f, -0.01741135f, 0.04890532f, 
    0.06600743f, 0.07394966f, 0.08304179f, 0.08831017f, -0.07811943f, 0.01764353f, 0.02258242f, -0.01691106f, 
    -0.03586685f, -0.11675168f, 0.03292811f, 0.14545859f, 0.15891942f, -0.00917773f, -0.03892871f, -0.11444329f, 
    -0.18244725f, 0.01162296f, -0.11095323f, -0.04740987f, -0.03901665f, -0.07868514f, 0.03218697f, 0.04906677f, 
    -0.02801949f, 0.15487477f, 0.00315926f, 0.02024717f, 0.13995090f, 0.05763087f, -0.02509147f, -0.01963826f, 
    0.00625744f, 0.07613077f, 0.20683903f, -0.02703220f, -0.01759317f, -0.07095090f, -0.09459636f, 0.06141784f, 
    -0.34010854f, 0.36134934f, -0.03921641f, 0.04363776f, -0.05542021f, 0.15799919f, 0.04530006f, -0.10202716f, 
    0.05679987f, 0.03419530f, 0.10841205f, 0.07590472f, -0.26865640f, -0.23093893f, 0.08269451f, 0.09132121f, 
    -0.10827369f, 0.04653366f, -0.11024970f, -0.05764529f, -0.00894841f, 0.14542948f, -0.13092709f, -0.09902447f, 
    -0.18839654f, -0.02862887f, -0.08935510f, -0.19346048f, -0.16796830f, -0.11514147f, -0.05095177f, 0.01477538f, 
    -0.03917132f, -0.01114917f, 0.03965352f, 0.10432474f, 0.00692047f, 0.09176243f, -0.09570874f, -0.03652412f, 
    0.04427024f, 0.16475610f, 0.08241494f, -0.11338389f, 0.18248264f, -0.01687529f, 0.07711270f, 0.07467956f, 
    0.31611398f, 0.10642649f, -0.03499934f, 0.14472078f, 0.00253356f, -0.03148696f, 0.04261684f, 0.08552491f, 
    -0.09173485f, -0.14277540f, 0.13008617f, 0.02186786f, -0.22188863f, 0.09979108f, -0.16227725f, -0.10798432f, 
    -0.02890385f, 0.05398253f, 0.03291064f, 0.00143894f, -0.00508720f, 0.12817287f, -0.09548356f, 0.04080934f, 
    0.23144235f, 0.11025362f, 0.14828095f, 0.09360628f, -0.05100287f, 0.19965525f, 0.17971082f, 0.07393668f, 
    -0.01729809f, 0.02611937f, -0.20185480f, -0.15509962f, 0.09317900f, 0.16739659f, 0.04281725f, 0.24867666f, 
    0.01851346f, -0.08028033f, -0.03154707f, -0.06026980f, -0.08061535f, 0.24896970f, 0.11173423f, 0.05601782f, 
    0.22100870f, 0.04951317f, 0.06514979f, 0.16147238f, 0.03640903f, -0.06175847f, 0.13327190f, 0.01981739f, 
    -0.10086387f, 0.08942026f, -0.12853801f, 0.10201658f, 0.19595301f, 0.24518804f, 0.33821777f, -0.12356468f, 
    0.20573817f, 0.10564448f, 0.09650832f, -0.13835491f, -0.05821060f, 0.20903462f, 0.02516324f, 0.11047910f, 
    0.37826663f, 0.24301127f, -0.04179653f, 0.23734014f, 0.23251145f, 0.00731086f, -0.02284070f, -0.07812619f, 
    -0.02187712f, -0.02179795f, -0.08324367f, 0.02616808f, 0.12321198f, 0.18839623f, 0.01802319f, -0.07380070f, 
    -0.00210194f, 0.09579649f, 0.22915544f, 0.03456677f, -0.09873644f, 0.06294220f, -0.09015084f, -0.01547147f, 
    -0.20870684f, 0.18611075f, 0.02465047f, 0.10076739f, -0.07039039f, 0.10042037f, 0.13733368f, 0.14567263f, 
    -0.03978849f, 0.25702232f, 0.13718390f, 0.14835277f, 0.01950165f, 0.15269987f, -0.19183883f, -0.28012338f, 
    -0.02620993f, -0.02371066f, -0.01132342f, -0.01543263f, 0.01303720f, -0.17326489f, 0.09511926f, -0.16293193f, 
    0.09471288f, -0.12026472f, -0.16818075f, -0.05823135f, 0.07639427f, 0.00040242f, -0.02186503f, -0.03597912f, 
    0.07768158f, 0.32853508f, -0.00136910f, 0.09692117f, 0.09924879f, 0.11655004f, 0.12966014f, 0.01035389f, 
    0.06204966f, 0.08729181f, 0.02890126f, -0.06025691f, 0.02424737f, -0.11682405f, 0.08293573f, 0.03603620f, 
    -0.11613335f, -0.15204756f, 0.15000346f, 0.08971531f, 0.13999265f, 0.02579634f, -0.09035304f, -0.06900082f, 
    -0.02989062f, -0.03074827f, 0.02711423f, 0.07710803f, -0.28460142f, -0.00098955f, 0.01284156f, 0.10183121f, 
    0.04621204f, 0.03138548f, -0.04829469f, 0.09986475f, -0.04233415f, 0.14115581f, -0.07034086f, 0.11963993f, 
    0.03672881f, 0.10183637f, 0.02740691f, -0.03482366f, -0.04269847f, 0.04132690f, 0.12052614f, -0.04017796f, 
    -0.04555877f, -0.01622172f, 0.11034139f, 0.00784360f, 0.02512429f, -0.03689217f, 0.02215713f, 0.00544178f, 
    0.08175233f, 0.15415335f, -0.06454134f, -0.02917959f, -0.08488654f, 0.14202793f, 0.16192323f, 0.00731621f, 
    -0.19402252f, 0.03260672f, 0.13501078f, -0.01134113f, 0.02284584f, 0.01798306f, 0.00103814f, -0.08469892f, 
    0.08644980f, 0.13020054f, -0.12947461f, 0.04300062f, -0.11407928f, 0.12004852f, -0.11640894f, 0.22917630f, 
    -0.01990539f, -0.06333290f, 0.05981663f, 0.03942273f, 0.13538766f, -0.03110188f, -0.03002889f, -0.01838637f, 
    0.05807140f, 0.07833348f, 0.22044587f, 0.08352510f, 0.03312942f, 0.05895642f, 0.08556660f, -0.11366108f, 
    -0.07539804f, -0.02383120f, 0.08563664f, 0.06640013f, -0.03896572f, 0.02029563f, 0.05658911f, 0.07908171f, 
    0.04391474f, 0.03586642f, 0.09120663f, -0.02931424f, -0.00692577f, -0.05177879f, 0.01199793f, -0.07926642f, 
    -0.14048842f, 0.04784881f, -0.11466393f, 0.13152516f, 0.04778129f, 0.18804799f, 0.01086766f, 0.00285978f, 
    0.03979900f, -0.13019456f, 0.13307357f, 0.12203403f, 0.00873543f, -0.05308730f, 0.25489181f, 0.22189876f, 
    0.13775617f, -0.02163475f, -0.08291751f, 0.11565492f, -0.00214150f, 0.04478819f, -0.03045559f, -0.02683125f, 
    -0.15241994f, -0.03327488f, 0.07137851f, -0.05319127f, -0.02096352f, 0.03745241f, 0.18008505f, 0.16847758f, 
    -0.07750539f, 0.06765397f, 0.22110455f, 0.15278648f, -0.14853427f, -0.09561262f, -0.02860020f, -0.16678818f, 
    0.00114282f, -0.06273780f, 0.03529265f, 0.12506086f, -0.01188700f, 0.08959876f, -0.05832266f, 0.08959403f, 
    -0.04180811f, 0.00745785f, 0.02370912f, -0.04131451f, -0.04942789f, -0.01992872f, -0.04772509f, 0.01257542f, 
    -0.01995450f, 0.02165474f, 0.00118242f, 0.02188343f, 0.04098119f, -0.00318051f, 0.03257112f, -0.00309761f, 
    -0.01413252f, 0.02852275f, -0.05192347f, -0.06110558f, -0.02928472f, -0.02348119f, -0.03342686f, -0.04524262f, 
    0.03845045f, -0.04730625f, 0.03678667f, -0.02827562f, 0.02771899f, -0.03627575f, 0.01782730f, 0.01923573f, 
    0.04116445f, -0.00878993f, -0.03390361f, -0.05085703f, 0.01592324f, 0.02641753f, 0.02602517f, 0.03323846f, 
    -0.01217421f, -0.05979493f, 0.00305509f, -0.01197551f, -0.04986295f, -0.01490909f, 0.00799759f, -0.03943321f, 
    -0.02947323f, 0.02192931f, 0.02213739f, 0.02254540f, -0.01232501f, 0.02507113f, -0.00122299f, -0.01980237f, 
    0.01356445f, 0.03254663f, -0.00044486f, -0.01140556f, 0.03017016f, -0.02619142f, -0.05516872f, 0.04080060f, 
    -0.00624622f, 0.02547309f, -0.05232753f, -0.03230685f, 0.03157597f, 0.00561265f, -0.01169947f, 0.00967126f, 
    -0.00027391f, -0.02110820f, 0.02847322f, -0.03878328f, -0.03375015f, -0.00192614f, -0.03038532f, -0.02395379f, 
    0.01410115f, -0.03333376f, -0.03723317f, 0.02804455f, 0.03727436f, -0.05829259f, -0.02413363f, -0.04678480f, 
    0.02519271f, 0.00172791f, 0.04245803f, -0.05025502f, -0.04591218f, -0.03606804f, 0.01849162f, 0.02830780f, 
    0.02710598f, -0.00577858f, 0.00789521f, 0.02186500f, 0.00582276f, 0.02771915f, -0.01086557f, -0.04863102f, 
    0.02536309f, -0.01752688f, 0.02752822f, -0.05302205f, 0.02347679f, -0.02253482f, -0.04551034f, 0.03791203f, 
    -0.01000528f, -0.05143913f, 0.01124783f, 0.00309804f, -0.01899997f, -0.04102525f, -0.01948663f, -0.04750716f, 
    -0.04756885f, 0.00484594f, -0.02091808f, -0.01012657f, -0.03496964f, 0.04567489f, 0.02034391f, 0.05192614f, 
    -0.00811927f, -0.02867834f, 0.00093079f, -0.02817354f, -0.00970360f, -0.03202505f, -0.03773782f, -0.04591823f, 
    0.01042577f, 0.02693849f, 0.03021452f, 0.03831781f, -0.05467178f, 0.00835236f, 0.00177566f, 0.00449785f, 
    0.02742489f, -0.01967047f, -0.05221938f, -0.05304806f, 0.04003586f, -0.03279646f, 0.00737824f, -0.00982863f, 
    0.02960644f, -0.05287174f, 0.03426222f, -0.05437579f, -0.01450374f, 0.02696340f, 0.03579362f, -0.01146244f, 
    0.01562762f, 0.00947078f, 0.01265525f, -0.05218711f, 0.00372917f, -0.02667144f, -0.04983885f, 0.03644140f, 
    -0.01580791f, -0.02768049f, 0.01174357f, 0.01234175f, 0.00253163f, 0.00939234f, -0.01247589f, 0.00971799f, 
    0.02810184f, -0.03653191f, -0.04569949f, -0.01111729f, 0.04711653f, 0.02312672f, 0.03603308f, -0.02571835f, 
    0.01771507f, -0.00557045f, 0.01685793f, 0.03791245f, 0.02706586f, -0.01899013f, -0.01433038f, 0.03692674f, 
    0.01743696f, -0.02702500f, -0.03445925f, -0.02180091f, -0.02726645f, 0.03106550f, -0.03396538f, -0.00257404f, 
    -0.02990397f, -0.01223475f, -0.02336422f, -0.02863079f, 0.01048297f, -0.05927112f, -0.05896000f, 0.03634814f, 
    0.03948862f, 0.02994852f, -0.03776114f, 0.01644103f, 0.03510180f, -0.00067668f, -0.06056288f, -0.02686872f, 
    0.04173091f, -0.04780099f, -0.03724860f, -0.03899946f, -0.03507942f, -0.04772510f, -0.01625347f, -0.01258097f, 
    -0.00116919f, -0.03764110f, 0.02108677f, -0.02377044f, 0.01005663f, 0.01888008f, -0.02183840f, -0.00793459f, 
    0.01250486f, 0.00590115f, -0.05995066f, 0.00307441f, -0.02247319f, -0.04637598f, -0.05696103f, 0.00660976f, 
    -0.03878387f, 0.02187847f, -0.04590556f, 0.02601018f, -0.02702093f, -0.00843281f, -0.05982418f, 0.01898313f, 
    -0.02158363f, 0.02554677f, -0.00164174f, 0.00963282f, 0.02222391f, -0.00821903f, 0.00134812f, 0.00240981f, 
    -0.05159460f, 0.01404215f, 0.03741755f, -0.04553104f, 0.03063335f, -0.02778478f, -0.02722100f, -0.03443358f, 
    -0.03569709f, 0.03853815f, 0.02848007f, 0.02305852f, -0.03278388f, -0.03002574f, 0.04033127f, 0.01668026f, 
    -0.03054350f, -0.02719054f, -0.02111010f, 0.00988274f, -0.00889634f, -0.00291061f, -0.05032094f, -0.02600047f, 
    -0.00914106f, -0.01792797f, -0.02293718f, -0.00271934f, -0.05162643f, -0.04918361f, 0.00939609f, -0.02296997f, 
    0.03677770f, -0.04183287f, -0.05046035f, 0.00368164f, -0.02829964f, -0.05481240f, 0.04158808f, -0.04726494f, 
    0.02113094f, -0.02101383f, -0.01275639f, -0.02100121f, 0.02277102f, -0.04521571f, 0.00124030f, -0.05483499f, 
    0.03003999f, -0.04405654f, 0.00062262f, -0.02886651f, 0.01482825f, -0.02043529f, -0.00801399f, 0.02407248f, 
    -0.02488425f, 0.00061104f, 0.00407721f, 0.05200442f, -0.03453743f, -0.04646682f, -0.04505438f, 0.00561116f, 
    -0.02940275f, -0.04299220f, -0.03396623f, -0.02785639f, 0.02693772f, -0.02940455f, -0.00890475f, -0.04976963f, 
    -0.05954842f, -0.01994607f, -0.04537884f, -0.03630431f, 0.03659594f, -0.00757257f, 0.01258685f, 0.00298945f, 
    0.00128468f, -0.02671412f, -0.01159268f, -0.01742322f, -0.03489565f, -0.06104125f, -0.02972265f, -0.01220431f, 
    -0.04477566f, 0.02985571f, 0.02926700f, -0.00301327f, -0.03443227f, 0.02700307f, -0.05352390f, -0.04851565f, 
    -0.02251728f, -0.01169601f, -0.04412045f, -0.00279924f, -0.00614386f, 0.03238074f, -0.03274882f, 0.00072958f, 
    0.01941743f, 0.01071498f, -0.00724858f, 0.03900571f, -0.03351310f, 0.00712517f, 0.00469711f, 0.03306990f, 
    -0.01453419f, -0.00874332f, 0.01932756f, 0.03819395f, -0.00362939f, 0.04438542f, -0.01477311f, -0.03099532f, 
    -0.05824761f, -0.04726563f, -0.04095497f, -0.01241682f, 0.02715120f, 0.03743858f, -0.03924632f, -0.00583313f, 
    0.04807374f, -0.00592034f, -0.18896738f, -0.08407256f, -0.00971456f, 0.06171492f, 0.07169241f, -0.05152496f, 
    -0.04752908f, -0.04279824f, 0.12027167f, -0.00711730f, 0.27240893f, 0.24651098f, 0.09809577f, 0.02568832f, 
    -0.13840534f, -0.04000933f, 0.10355898f, 0.05420560f, 0.11177733f, -0.05729045f, -0.04378214f, -0.11815387f, 
    0.12377195f, 0.09459480f, 0.01079074f, -0.05205779f, -0.07935140f, -0.11689539f, 0.12883507f, 0.03861509f, 
    0.09885485f, -0.03897823f, -0.14604279f, -0.04759213f, 0.08293313f, 0.19373152f, -0.00305905f, 0.18633778f, 
    -0.07212073f, -0.07144055f, -0.04390589f, 0.00604696f, 0.04144378f, -0.10513756f, 0.10667708f, -0.02039414f, 
    0.31996933f, -0.40505046f, -0.04200574f, -0.00767622f, 0.00187302f, -0.00294135f, -0.24925737f, -0.06416508f, 
    -0.06145779f, 0.09340821f, -0.02764726f, 0.10444499f, 0.29755676f, 0.12116788f, -0.22745100f, 0.12142836f, 
    -0.05847773f, 0.02598287f, -0.06260718f, 0.03474305f, -0.02729180f, 0.04222540f, -0.03548151f, -0.02217442f, 
    0.16463469f, 0.05261809f, 0.06569321f, 0.15912360f, -0.18369128f, -0.10832606f, 0.03007974f, 0.08043949f, 
    0.04127479f, 0.04155882f, 0.14844860f, 0.00710656f, -0.03948614f, -0.01572870f, 0.27465755f, -0.17123000f, 
    -0.06415946f, -0.09337089f, -0.04161175f, 0.00036875f, 0.05334133f, 0.10150681f, -0.04782157f, 0.05323628f, 
    0.12650615f, -0.13596772f, -0.29677215f, -0.03400239f, -0.11388947f, 0.08655275f, 0.14276791f, -0.00547324f, 
    -0.00721386f, 0.02253538f, 0.07851128f, 0.02304607f, 0.49744418f, 0.00933696f, 0.08197688f, 0.07493038f, 
    -0.17605308f, 0.03329460f, 0.03461429f, 0.03625594f, -0.09832497f, 0.08768235f, -0.11026470f, -0.02241537f, 
    0.22235522f, 0.01444891f, -0.13674352f, 0.13714613f, -0.09045946f, 0.11069453f, 0.10997047f, 0.06444041f, 
    -0.07654773f, -0.00412102f, -0.09533282f, -0.05641053f, 0.07426608f, -0.01259880f, 0.18131961f, -0.32278481f, 
    0.04788921f, -0.19714737f, -0.01388506f, 0.05806375f, 0.00284148f, -0.00099572f, 0.03726790f, 0.03098614f, 
    -0.02020037f, -0.01395252f, -0.01669322f, -0.33981487f, -0.09166439f, -0.01336349f, 0.04890265f, -0.06202585f, 
    0.07783540f, 0.13152343f, -0.09704193f, 0.02510363f, -0.12568697f, 0.23605940f, 0.09889883f, -0.09488337f, 
    -0.12441071f, -0.17088085f, -0.00593843f, 0.16328439f, 0.01684257f, 0.10926615f, -0.06180233f, -0.01183033f, 
    0.14687717f, -0.25325128f, 0.13017109f, 0.04942488f, -0.09939718f, 0.02940277f, 0.03480728f, -0.02805640f, 
    -0.01362969f, -0.00539850f, 0.01096711f, -0.03555035f, 0.22367723f, 0.09926449f, -0.06931382f, -0.03590390f, 
    -0.00269148f, 0.00963343f, 0.05922179f, 0.05492901f, 0.08692481f, 0.07842777f, -0.02947513f, 0.08390504f, 
    0.05325526f, -0.12830944f, -0.05620109f, -0.05896111f, -0.07591414f, 0.07805349f, -0.02138669f, -0.05888838f, 
    -0.05035565f, 0.16505049f, 0.00711502f, 0.02531268f, 0.35342628f, -0.12808917f, 0.34534362f, 0.17736061f, 
    -0.09930402f, 0.07414856f, -0.03423729f, 0.11535888f, 0.11150710f, -0.10757381f, -0.06818232f, 0.04415516f, 
    -0.05637472f, -0.20476392f, -0.06311408f, -0.07038008f, 0.09265147f, -0.01909794f, -0.03747572f, -0.03529116f, 
    -0.02061510f, -0.05787414f, 0.05231426f, 0.09487654f, -0.04295085f, 0.03031966f, -0.11303201f, -0.16431005f, 
    -0.03587934f, -0.04494352f, 0.04827274f, 0.06927195f, 0.03016064f, -0.01958715f, -0.07459304f, -0.08804760f, 
    -0.25347781f, 0.21147646f, 0.05848471f, 0.04319296f, -0.05774841f, -0.06658865f, -0.07448377f, 0.04578847f, 
    -0.02568129f, -0.00506023f, -0.06575400f, 0.03731240f, 0.51801616f, -0.04465970f, 0.12472762f, -0.17149615f, 
    0.02057618f, -0.03853015f, 0.06218639f, 0.09760723f, 0.05591354f, 0.01118355f, -0.06908558f, -0.10005402f, 
    0.05996126f, -0.17231639f, 0.05887811f, -0.13375783f, 0.10939526f, -0.00657604f, 0.11121888f, -0.13950165f, 
    0.03805272f, 0.01475990f, 0.06053623f, -0.00577538f, 0.36966592f, -0.11692513f, 0.15801422f, 0.06009233f, 
    -0.09086712f, -0.08162422f, -0.04611311f, 0.05380309f, 0.01935176f, 0.02854318f, -0.02507175f, 0.07014762f, 
    -0.37976879f, 0.05871005f, -0.04748021f, 0.19272986f, 0.06052545f, -0.00292030f, 0.02099339f, 0.08878312f, 
    -0.09575615f, -0.12106556f, -0.14469345f, -0.05807983f, 0.08477814f, -0.27628347f, -0.07183747f, -0.13880762f, 
    0.10556938f, -0.04401785f, 0.14065415f, -0.08784313f, -0.11253811f, 0.08290621f, -0.05274842f, 0.04399917f, 
    -0.02447415f, 0.11579097f, 0.11100969f, -0.07240381f, -0.12767555f, -0.06668068f, 0.01653457f, 0.15259902f, 
    0.00303146f, -0.04513630f, -0.01891570f, -0.11808224f, 0.27798706f, -0.04697439f, -0.23009877f, 0.16475143f, 
    0.08378939f, -0.09330191f, 0.02599341f, -0.00178354f, 0.18417095f, 0.11201198f, -0.01153786f, 0.14531381f, 
    0.39852321f, -0.00295629f, 0.04102851f, 0.01770541f, 0.00710330f, 0.00578522f, 0.09494153f, 0.11396758f, 
    0.02828978f, -0.03679011f, 0.01812322f, -0.05333245f, -0.40679130f, 0.09960512f, 0.19465695f, 0.26134017f, 
    0.06102956f, 0.07815768f, -0.12181521f, 0.02649132f, 0.04137972f, -0.00828064f, -0.00205358f, -0.12549224f, 
    -0.37440661f, -0.25307503f, -0.03141110f, -0.20050149f, 0.04469414f, 0.11500872f, 0.14337032f, 0.07177597f, 
    0.07048688f, -0.02077350f, 0.00339673f, 0.01111278f, 0.08852340f, 0.20756431f, 0.05725704f, 0.09576593f, 
    -0.05857177f, -0.01347379f, 0.15047154f, 0.07717331f, 0.00947427f, 0.13779904f, 0.04988991f, 0.12659755f, 
    0.03011592f, 0.03153597f, -0.03892303f, -0.01989598f, -0.04645125f, -0.00027704f, -0.01577148f, -0.01021863f, 
    0.04929826f, -0.01613038f, -0.04580687f, -0.04696230f, -0.03290826f, 0.03457483f, -0.03479398f, -0.02172153f, 
    -0.01464817f, -0.03631981f, -0.05044577f, -0.02304819f, -0.03991955f, 0.03384091f, 0.03813018f, -0.02210146f, 
    0.01283855f, -0.02128446f, 0.01407955f, 0.01088892f, -0.03872380f, -0.02204718f, -0.00748012f, -0.02847863f, 
    0.00579856f, -0.03351711f, 0.01174293f, 0.02194941f, -0.00676287f, -0.00289391f, -0.03326181f, -0.01053087f, 
    -0.01589602f, -0.03707679f, -0.01843200f, -0.02517470f, -0.03316528f, 0.00534952f, -0.02248736f, 0.02287514f, 
    0.00056109f, 0.01197600f, -0.02581601f, 0.03248429f, -0.04872385f, -0.00169301f, 0.01967457f, 0.03149233f, 
    0.00007893f, -0.00130977f, 0.03009550f, 0.04105998f, 0.04989245f, 0.04486548f, 0.02195975f, 0.00858271f, 
    -0.00096813f, -0.04561820f, 0.01528946f, 0.04017867f, -0.04638030f, -0.03976669f, 0.04813794f, -0.04284897f, 
    -0.00163805f, -0.03677132f, -0.03292958f, 0.00726737f, -0.03078127f, 0.00882833f, 0.00090463f, -0.03588905f, 
    0.01051707f, -0.03477271f, 0.02258709f, -0.02110668f, -0.03701448f, 0.04935958f, -0.02127829f, -0.04294182f, 
    -0.02281229f, -0.00215888f, -0.02112302f, 0.02142292f, -0.01686271f, -0.00341022f, 0.05097424f, 0.02673695f, 
    -0.03665170f, -0.00617816f, -0.04362353f, 0.04008357f, 0.03321469f, 0.03065824f, 0.00655260f, 0.02049449f, 
    0.00795654f, 0.02787189f, -0.00639976f, -0.01812532f, -0.04169176f, 0.04783451f, -0.04021644f, -0.04885602f, 
    -0.00591098f, 0.04598248f, 0.01263562f, 0.01536687f, 0.04658351f, -0.02024185f, -0.02001985f, -0.00304115f, 
    -0.01391763f, 0.02529419f, 0.02661667f, -0.04449551f, -0.02966479f, -0.04724902f, -0.00584744f, 0.00349445f, 
    -0.04040407f, -0.02483087f, 0.03904494f, -0.04440270f, 0.01618857f, 0.02500509f, 0.04707977f, -0.04466320f, 
    -0.01704159f, -0.03576059f, -0.02352045f, -0.01233248f, -0.02169185f, -0.02107654f, -0.03062536f, -0.01998717f, 
    -0.01063212f, -0.01060015f, -0.00359981f, -0.01359094f, -0.04316428f, 0.03467619f, -0.01995284f, -0.03069195f, 
    0.01000923f, 0.00992179f, 0.00842951f, -0.03004445f, -0.03063983f, 0.01898832f, 0.00222254f, -0.01229871f, 
    -0.03244760f, -0.03524083f, -0.02195240f, -0.04363106f, 0.01093003f, -0.04686884f, 0.02323136f, -0.00700710f, 
    -0.04258634f, 0.00033817f, -0.03644305f, -0.04820584f, 0.02110626f, -0.03532450f, 0.03889360f, 0.03038199f, 
    -0.00019178f, 0.04770083f, 0.04750230f, -0.03205321f, -0.00932855f, -0.01266883f, -0.01528976f, -0.04467902f, 
    -0.04945396f, -0.03011204f, 0.01698513f, 0.00265086f, 0.00213316f, -0.03320636f, 0.03176104f, 0.02164386f, 
    -0.02903039f, 0.04775275f, 0.01607372f, -0.04376634f, -0.00017395f, -0.03659396f, -0.01789486f, -0.00864177f, 
    0.01603660f, -0.04816989f, -0.04332668f, 0.01000345f, 0.04062784f, -0.01561974f, -0.02890822f, -0.01510338f, 
    0.01372880f, 0.03472612f, 0.03537392f, -0.03935585f, 0.02504101f, 0.02083349f, -0.03474352f, -0.04294105f, 
    0.00206987f, -0.00081530f, 0.01342139f, -0.03316486f, -0.04155307f, -0.04342011f, 0.02041559f, -0.03517798f, 
    -0.03802894f, 0.04918576f, 0.04111609f, -0.03805775f, 0.02930539f, -0.02589137f, -0.04962717f, -0.02289453f, 
    0.03524889f, -0.02773591f, -0.00118844f, 0.00593816f, 0.02718252f, -0.04650658f, 0.03555559f, -0.03144764f, 
    0.04768863f, -0.01699582f, -0.04483085f, 0.02249290f, 0.01805908f, 0.03077638f, -0.00288820f, -0.01037994f, 
    0.00945493f, 0.01112151f, 0.03987932f, 0.03915975f, -0.01592333f, -0.03673380f, -0.00667531f, 0.05061809f, 
    -0.03856355f, 0.00637581f, -0.00187644f, 0.03681939f, 0.04327251f, 0.00353964f, 0.04375706f, -0.00822324f, 
    -0.02074398f, -0.04218085f, -0.04811072f, -0.02535320f, -0.02534185f, -0.01428223f, 0.00486265f, 0.01906121f, 
    -0.04703368f, -0.03868249f, -0.00480155f, -0.03629462f, 0.02284717f, -0.02307642f, -0.00834181f, 0.02868160f, 
    -0.05016764f, 0.01252699f, 0.02255366f, 0.04813723f, 0.00933668f, 0.00227351f, 0.03582097f, -0.01484636f, 
    -0.00178995f, 0.01091341f, 0.03208222f, -0.01056706f, 0.00598521f, -0.01833110f, -0.01066386f, 0.04157145f, 
    -0.01448543f, -0.00038446f, -0.03379781f, -0.02696221f, 0.04253512f, 0.00411417f, 0.00918813f, -0.02896362f, 
    -0.04615602f, -0.05079569f, 0.02498925f, 0.01334155f, -0.01385677f, 0.00144993f, -0.02586502f, 0.03914089f, 
    -0.04646951f, -0.03008897f, -0.05051747f, 0.02955395f, -0.02615135f, -0.04095004f, -0.03464311f, -0.03254556f, 
    -0.01961252f, -0.00270098f, 0.00938543f, -0.02729410f, -0.03773778f, 0.02786567f, 0.04244988f, -0.00983505f, 
    0.00889424f, -0.04736342f, -0.03743015f, -0.02629789f, -0.04774987f, -0.01475655f, 0.00432126f, -0.03481259f, 
    0.05072879f, 0.04647205f, 0.05062203f, -0.04648480f, -0.00062602f, -0.04712247f, 0.00213419f, 0.00251126f, 
    0.00736783f, 0.00686896f, 0.03220856f, -0.04985703f, -0.03723106f, -0.00247114f, -0.05074130f, 0.04909599f, 
    -0.04379520f, -0.03951327f, -0.04675514f, -0.04100965f, 0.04309957f, 0.04764182f, -0.00497984f, 0.01611407f, 
    -0.04247222f, -0.01938340f, -0.04327789f, 0.03878395f, -0.04850676f, 0.04018290f, -0.00117245f, -0.00282563f, 
    0.01875809f, 0.02462590f, -0.03026104f, -0.01876966f, -0.02994893f, 0.03570114f, 0.02628387f, -0.02527784f, 
    0.04777659f, -0.00865253f, 0.04424680f, 0.00442547f, 0.02701907f, -0.01091897f, -0.00391466f, 0.02266955f, 
    0.24572058f, 0.12087420f, -0.08418277f, 0.07609280f, -0.03205511f, -0.05942101f, 0.05527764f, 0.09055416f, 
    -0.02435898f, -0.12125901f, -0.07560445f, -0.06915882f, -0.19344841f, -0.18531778f, -0.04141281f, 0.04837421f, 
    0.08958462f, -0.13884707f, 0.00892745f, 0.10546647f, 0.05138943f, -0.06896525f, -0.06142524f, 0.09791980f, 
    -0.27362248f, -0.16365357f, -0.09323263f, -0.19169110f, -0.14724761f, -0.01189676f, -0.04610891f, 0.11543990f, 
    -0.08168904f, 0.06226353f, 0.16711462f, 0.20046401f, 0.26470962f, 0.20760196f, -0.02864023f, 0.05761652f, 
    0.02705999f, 0.17665747f, -0.07160619f, 0.10733130f, 0.04517533f, 0.09051672f, -0.04602029f, -0.04525978f, 
    0.03695873f, 0.21402532f, -0.18125702f, 0.14629160f, 0.05995800f, 0.02767933f, 0.02199866f, -0.03749074f, 
    0.02630986f, -0.13650160f, -0.02187023f, 0.01973127f, -0.21410881f, -0.23993118f, 0.03007414f, 0.03316157f, 
    0.05351647f, -0.01274481f, -0.07118031f, -0.02488200f, -0.00173453f, 0.01464064f, -0.02056633f, 0.03246410f, 
    -0.24640015f, -0.22693567f, -0.06544434f, -0.20513250f, 0.13192973f, 0.00268046f, -0.01605327f, -0.01877452f, 
    0.12050524f, -0.01470825f, -0.03867342f, 0.12825310f, 0.27892125f, 0.00551431f, 0.02613671f, 0.19326587f, 
    0.01766057f, 0.09823154f, -0.18459328f, 0.04598583f, 0.06275934f, -0.00926924f, 0.00391615f, 0.00693023f, 
    -0.06070393f, 0.20281845f, 0.32141498f, 0.18332665f, 0.12661777f, 0.04469867f, 0.08092190f, 0.04132043f, 
    -0.01280972f, 0.05088142f, -0.12782697f, -0.04622302f, -0.25329590f, -0.28159299f, -0.20597398f, -0.06082762f, 
    0.01715950f, 0.07300445f, -0.06627553f, 0.04455784f, -0.04679376f, -0.12363327f, 0.12253924f, -0.06811450f, 
    0.01716108f, -0.07761618f, 0.16844858f, -0.07757460f, 0.05783256f, -0.05883420f, 0.05181254f, 0.01729554f, 
    0.10897352f, -0.14067057f, 0.09594422f, 0.06825031f, 0.12592113f, 0.14932641f, 0.09426994f, 0.20793228f, 
    0.00633037f, 0.03873031f, -0.02199718f, -0.05541006f, 0.00930097f, 0.01545234f, -0.00723656f, -0.08967093f, 
    -0.08466399f, 0.30888027f, 0.17779936f, 0.21196952f, -0.01813678f, 0.05829956f, -0.02021383f, 0.02083943f, 
    -0.03962530f, -0.00961453f, 0.13654643f, -0.06004248f, 0.04692895f, 0.11943940f, 0.21823509f, 0.02434270f, 
    0.06938395f, 0.12653673f, 0.02019331f, 0.06369001f, -0.02314951f, -0.00429944f, 0.08929933f, -0.02778306f, 
    0.23645401f, 0.21079060f, -0.05217381f, 0.24219142f, 0.01484872f, 0.15615711f, 0.04130903f, -0.01870917f, 
    -0.04342233f, 0.03533363f, 0.01331339f, -0.00428672f, 0.03419357f, 0.27283537f, 0.18109721f, 0.20316161f, 
    -0.00064219f, 0.04579498f, 0.16552287f, 0.05239864f, -0.04792081f, -0.05217732f, 0.18040919f, -0.10287749f, 
    -0.27629161f, 0.12580037f, -0.02649439f, 0.18299435f, -0.04735926f, 0.03677538f, 0.03509744f, -0.02698198f, 
    -0.05148759f, -0.13883018f, -0.13955379f, 0.05580146f, -0.23384641f, -0.19726107f, -0.05559099f, -0.11575620f, 
    0.08453690f, -0.04883654f, -0.04007942f, -0.04241397f, -0.02319099f, -0.01609988f, 0.02972236f, -0.10101096f, 
    -0.05569090f, 0.14411879f, 0.01836975f, -0.10166387f, 0.06554107f, -0.06288774f, -0.13196085f, 0.10619168f, 
    0.06216787f, -0.01365656f, -0.04872057f, -0.12325689f, 0.04544403f, 0.25504062f, 0.01317402f, 0.14663671f, 
    0.05712375f, 0.04346934f, -0.12152864f, -0.02666953f, -0.03954395f, 0.05165594f, 0.01259666f, 0.07096161f, 
    0.06340744f, -0.06397381f, -0.14085998f, 0.04291859f, -0.07776697f, -0.01846348f, 0.05505137f, 0.00265837f, 
    0.17768680f, 0.03549900f, -0.12283724f, 0.02893736f, -0.37548962f, -0.02144125f, 0.08417334f, 0.05814983f, 
    0.09398918f, -0.01069031f, -0.03652551f, -0.17792469f, 0.07776099f, -0.06780220f, 0.15475261f, 0.13461214f, 
    0.16292048f, -0.15405981f, 0.11892195f, 0.20695159f, -0.06179023f, 0.13829246f, -0.05727495f, 0.06031187f, 
    0.05552516f, 0.16497459f, 0.02672395f, -0.06322892f, -0.25122043f, -0.13827001f, -0.21128279f, -0.04559093f, 
    -0.01816125f, -0.05360684f, -0.08144000f, -0.10528471f, 0.00102209f, -0.01229071f, -0.11923949f, 0.08030675f, 
    0.35458621f, 0.08665363f, 0.13877244f, 0.05447285f, -0.03202091f, -0.01036591f, 0.02171537f, -0.01306138f, 
    -0.00148361f, -0.03456480f, -0.04428338f, 0.02489467f, -0.01208724f, 0.20377487f, 0.01332610f, 0.22484355f, 
    -0.03504697f, 0.13092951f, 0.00313021f, 0.11816253f, -0.06544026f, -0.00752721f, 0.07197984f, -0.05136390f, 
    0.25485697f, 0.14172317f, 0.19054690f, 0.10672230f, 0.12243643f, 0.01038396f, -0.06683272f, -0.10664506f, 
    -0.03877949f, -0.01236919f, -0.01552426f, 0.08519882f, 0.11924107f, 0.02046033f, 0.00840483f, 0.12534447f, 
    -0.07349460f, 0.00709954f, 0.10454936f, -0.04339324f, -0.06656446f, 0.05754206f, 0.04702703f, -0.02670039f, 
    0.00802627f, 0.08602564f, -0.10461038f, 0.16629258f, -0.07850642f, 0.11956153f, -0.04169527f, -0.05402029f, 
    0.10610867f, -0.05058727f, -0.13666347f, 0.02368045f, -0.04437419f, 0.21542452f, -0.00564944f, -0.01293313f, 
    -0.04971819f, -0.14953688f, 0.08213597f, 0.00753642f, 0.02673504f, -0.13459128f, -0.08580098f, 0.20605113f, 
    0.13558963f, 0.17625536f, -0.04174215f, 0.04924122f, -0.04849870f, -0.10412144f, 0.13146211f, -0.03492599f, 
    -0.08271025f, -0.00378959f, -0.02580272f, -0.04742247f, -0.37882128f, -0.24733758f, -0.06762484f, -0.09746725f, 
    0.05252750f, -0.01081670f, -0.08495513f, 0.05820594f, 0.03647783f, -0.11879073f, -0.01183242f, -0.04612569f, 
    0.00280840f, -0.00753374f, -0.02570948f, -0.01278867f, -0.03055573f, 0.03302562f, -0.02508689f, -0.00141175f, 
    -0.00083230f, 0.01304852f, -0.05491090f, -0.02011835f, -0.00502700f, -0.03705376f, -0.03961672f, 0.00248403f, 
    0.01546697f, -0.00756541f, -0.02190586f, -0.04306492f, 0.00214335f, -0.02434486f, 0.02536073f, -0.03343067f, 
    0.02400241f, 0.00043470f, -0.04217280f, 0.01883119f, -0.03729882f, -0.04910245f, 0.03464022f, -0.01650081f, 
    -0.04741205f, 0.01343341f, -0.00201256f, -0.05307331f, -0.00113067f, -0.04815343f, -0.03968510f, -0.05337249f, 
    0.01206986f, -0.03200705f, -0.05472283f, 0.01729278f, 0.00877947f, -0.01450169f, -0.03782594f, -0.03267101f, 
    -0.04236633f, 0.02495829f, 0.04042612f, -0.00891982f, -0.02438458f, -0.00732272f, -0.02560467f, 0.00683475f, 
    -0.01929582f, 0.03128032f, -0.04417089f, 0.02112574f, -0.01311780f, -0.01485261f, 0.00398601f, -0.04082712f, 
    0.00564797f, 0.03354793f, -0.01030063f, -0.02665290f, 0.01752401f, -0.01532553f, -0.03732530f, -0.02413078f, 
    0.03990610f, 0.04331000f, -0.01460698f, 0.03060882f, -0.01326878f, -0.03139988f, -0.01071095f, -0.03937696f, 
    -0.00121764f, 0.04465747f, -0.05271908f, -0.04488209f, 0.01692898f, -0.04605931f, 0.02255008f, -0.03913843f, 
    -0.02439404f, -0.01588012f, 0.00763941f, -0.03690090f, 0.01911408f, -0.03158407f, 0.03059340f, 0.04173822f, 
    0.00463808f, -0.00921534f, -0.04518635f, -0.02909174f, 0.03303051f, -0.01251598f, -0.05802548f, -0.05134142f, 
    0.00523434f, 0.04279817f, 0.00918173f, 0.01727643f, -0.01986222f, 0.00787391f, 0.03560398f, 0.00978022f, 
    0.01742319f, -0.02610052f, -0.02465921f, -0.03128567f, -0.04193041f, 0.01741439f, -0.02753767f, 0.01398190f, 
    -0.05202407f, 0.00187884f, -0.02495203f, 0.03786574f, -0.03196551f, -0.00267221f, -0.04247469f, 0.02541722f, 
    -0.05203007f, -0.04109538f, -0.05555810f, -0.01874514f, -0.05069350f, 0.02312810f, 0.03374959f, 0.01753399f, 
    0.04130814f, -0.05639234f, -0.00118874f, -0.04220170f, -0.02805619f, 0.03411208f, -0.03877653f, 0.04034466f, 
    -0.01456886f, -0.03535143f, -0.00650256f, -0.00791975f, 0.03470740f, -0.02962560f, 0.01815462f, 0.04044400f, 
    0.02481388f, 0.03687419f, -0.00208158f, -0.04781761f, 0.00969316f, 0.04024515f, 0.00903927f, 0.02540302f, 
    -0.01935835f, 0.02330500f, 0.02798504f, 0.01322523f, -0.02112371f, 0.02039537f, 0.00515538f, -0.00414217f, 
    0.03866825f, 0.03983175f, -0.01319919f, -0.04192916f, 0.01982202f, 0.00653495f, -0.03056354f, 0.00875223f, 
    0.04222642f, -0.03410885f, -0.01341973f, -0.04408668f, 0.02498883f, -0.01207424f, -0.01287492f, -0.05732507f, 
    -0.04619171f, -0.04569413f, -0.03449163f, -0.03256233f, -0.01036398f, -0.01842822f, -0.05347541f, 0.03928652f, 
    -0.01534435f, 0.03592113f, 0.01141269f, -0.01097758f, -0.00143500f, 0.00560132f, -0.05684692f, -0.04650059f, 
    0.01018296f, -0.01462441f, -0.04091694f, -0.02076412f, 0.02213615f, -0.00141885f, 0.02936552f, 0.02943284f, 
    -0.03112787f, -0.03149265f, -0.02258137f, -0.02186668f, -0.05685480f, -0.04089470f, 0.02707409f, -0.02058224f, 
    -0.03243072f, -0.03690301f, 0.03158549f, -0.01637597f, -0.05456496f, -0.04634163f, 0.02383853f, -0.02060820f, 
    0.01326724f, -0.01447600f, 0.01313163f, -0.04031395f, -0.04256451f, 0.02375301f, -0.04972468f, -0.02622730f, 
    -0.05575741f, -0.04665275f, 0.00003656f, 0.00205396f, -0.00467191f, -0.01579148f, -0.03172887f, 0.03253444f, 
    -0.02615669f, -0.01877117f, -0.02754565f, 0.02435832f, -0.01076983f, -0.05149242f, -0.02394176f, -0.00035244f, 
    -0.03785192f, -0.00599062f, -0.01632896f, -0.05785317f, -0.00758055f, -0.01469716f, 0.01659057f, 0.00227755f, 
    -0.00021957f, -0.05242154f, 0.02436538f, -0.01445672f, 0.01576203f, -0.03249542f, 0.00672521f, 0.03512425f, 
    0.01072845f, -0.03891483f, -0.02150570f, -0.04048357f, -0.04958186f, 0.00487038f, 0.02148379f, 0.01595904f, 
    0.00030181f, 0.02614069f, 0.03854466f, -0.01730635f, 0.03684705f, 0.04265671f, 0.00422254f, 0.02713474f, 
    0.03057195f, 0.00241603f, 0.03496935f, 0.01028286f, 0.03655674f, 0.03560938f, -0.04759143f, 0.04190487f, 
    0.02934130f, -0.02590797f, -0.04380549f, -0.05117732f, 0.01462081f, 0.00918799f, -0.02293743f, -0.00754584f, 
    0.00326784f, -0.03397181f, 0.03552467f, -0.01020117f, -0.04413779f, -0.00347697f, 0.01685904f, 0.03093012f, 
    -0.04599640f, -0.01491952f, -0.04603719f, -0.04556366f, 0.04068655f, -0.03704222f, 0.03612036f, 0.03694978f, 
    0.02164984f, 0.03310871f, -0.04427028f, 0.01793413f, -0.03194257f, 0.03865412f, -0.04453336f, 0.03192214f, 
    0.02358232f, -0.02100951f, -0.04390695f, 0.01056882f, -0.00521127f, 0.02446089f, -0.04192632f, -0.00522377f, 
    0.01770926f, 0.00644297f, -0.02302657f, -0.00667902f, -0.00099317f, 0.01041438f, -0.01391060f, -0.04659261f, 
    -0.03483330f, 0.03162253f, 0.00529674f, -0.01033902f, -0.03139738f, 0.03919911f, -0.04081570f, 0.00666977f, 
    0.03915261f, -0.00287671f, -0.03721511f, -0.00675622f, 0.00936850f, -0.02178135f, -0.02253009f, -0.03729717f, 
    0.03443794f, -0.03188955f, -0.00885375f, 0.01060922f, -0.02715604f, -0.03932898f, -0.04493688f, 0.01565141f, 
    -0.04906393f, -0.02032146f, -0.03098211f, -0.03888111f, 0.03005398f, -0.00164445f, -0.04344141f, -0.05475257f, 
    -0.03455147f, -0.02585614f, 0.02764937f, -0.00867131f, -0.03835822f, -0.05469538f, 0.01036898f, 0.02370122f, 
    0.03141738f, -0.04135533f, -0.01682787f, 0.01435747f, -0.00372230f, -0.01452107f, 0.00031426f, 0.00666345f, 
    -0.01753753f, -0.01806504f, 0.04171826f, -0.01211760f, 0.00619595f, 0.00098936f, -0.04458397f, -0.04752499f, 
    0.01073568f, 0.01478118f, -0.00103522f, -0.05014015f, -0.04742848f, 0.01115748f, 0.01455564f, 0.01591380f, 
    0.03093312f, -0.02657575f, -0.05045633f, -0.00006354f, -0.03040988f, 0.01921181f, -0.04013353f, -0.01617758f, 
    -0.04618191f, -0.04041279f, -0.04374998f, -0.02888921f, -0.02277807f, 0.01619044f, 0.03265135f, -0.05180367f, 
    -0.02262316f, 0.01696133f, -0.02921779f, 0.00254810f, 0.03149878f, -0.02829418f, 0.02254884f, 0.01653132f, 
    -0.05283320f, -0.01035779f, -0.03668895f, -0.04860930f, 0.00046081f, -0.00729699f, -0.05227315f, 0.03542390f, 
    0.01708927f, 0.03291231f, -0.04601996f, -0.00149171f, 0.01569820f, 0.00993998f, -0.04761141f, -0.05680483f, 
    -0.00890690f, 0.04204414f, -0.04047354f, 0.01758214f, -0.03447219f, -0.02346537f, 0.02867731f, -0.03730319f, 
    0.02891352f, -0.00639290f, -0.01442820f, -0.04471546f, 0.00273473f, -0.00071364f, -0.05524167f, -0.02003797f, 
    0.02198093f, 0.01359982f, -0.04449245f, 0.00832221f, 0.02355972f, -0.03712656f, 0.03495862f, 0.02229154f, 
    0.03533472f, 0.03513717f, -0.05563709f, 0.02501412f, -0.01171699f, -0.00738523f, -0.02859597f, -0.03417764f, 
    -0.04730678f, -0.04053249f, 0.01287495f, -0.00006058f, -0.02855319f, -0.04754329f, 0.01640038f, -0.03489600f, 
    -0.01207436f, -0.04725837f, 0.01900361f, -0.03510972f, -0.01464682f, -0.01178367f, -0.00700901f, -0.00123830f, 
    0.01007832f, -0.00757218f, -0.05120594f, -0.04791201f, -0.02078681f, -0.04526601f, 0.02211224f, 0.00546766f, 
    0.00340719f, 0.03736429f, 0.03928052f, -0.03414626f, -0.02105640f, -0.04450787f, -0.00168565f, -0.03329365f, 
    -0.04261946f, -0.04409578f, 0.03495455f, 0.00794654f, -0.04127424f, -0.04543661f, -0.04895165f, -0.05219596f, 
    0.01455113f, 0.03793136f, -0.05380256f, 0.01328954f, -0.02127117f, -0.04689864f, 0.02523817f, -0.04184974f, 
    0.00271631f, -0.00604814f, 0.04019886f, -0.01845989f, -0.01493901f, 0.03602634f, 0.00797155f, -0.02130092f, 
    -0.02727410f, 0.02507029f, 0.01574431f, 0.02355535f, 0.03400024f, -0.04114124f, 0.00724224f, -0.04231648f, 
    -0.02061517f, 0.03782778f, -0.02530803f, -0.01058707f, 0.02218842f, -0.05417258f, 0.00724586f, 0.00526394f, 
    0.01357890f, 0.03430543f, -0.05749629f, -0.04812208f, -0.02726254f, -0.02768942f, -0.03264044f, 0.04107838f, 
    -0.04568667f, -0.03189777f, -0.04537454f, -0.03623045f, -0.03793643f, 0.00442670f, 0.01847835f, -0.00733107f, 
    -0.01771517f, -0.04107872f, 0.02500167f, 0.00474928f, 0.01443043f, -0.05213021f, -0.00868882f, 0.03285545f, 
    -0.00093091f, 0.04453044f, -0.01784364f, -0.00353393f, -0.03610331f, -0.04937435f, -0.02891268f, -0.00678277f, 
    -0.04917791f, -0.00980609f, 0.03307282f, -0.00008264f, 0.03474407f, -0.04947589f, -0.03307721f, 0.00839899f, 
    0.00336208f, -0.00812269f, -0.00196905f, -0.00254128f, 0.03212798f, 0.01601920f, -0.05583425f, -0.01313914f, 
    -0.05590374f, -0.03399809f, 0.00295694f, -0.03397969f, -0.00947553f, 0.01454179f, 0.00848191f, 0.04500760f, 
    0.03007343f, -0.00071650f, 0.03204102f, 0.01620117f, -0.04690268f, -0.00842417f, 0.03528897f, -0.02324450f, 
    0.00890816f, 0.01361749f, -0.02466035f, -0.03096331f, -0.05052502f, -0.01553191f, -0.02378903f, 0.02758237f, 
    0.00576443f, -0.02117265f, -0.04462470f, -0.00576723f, 0.02931842f, -0.01683307f, 0.02403137f, 0.00568964f, 
    -0.04117079f, 0.02015521f, -0.03211801f, -0.02521890f, -0.01889039f, -0.01782557f, 0.01372522f, 0.01552011f, 
    -0.03986654f, -0.05477139f, 0.01218554f, -0.02037004f, -0.00344228f, 0.00210269f, 0.02327459f, -0.03894686f, 
    0.02785400f, -0.05265706f, -0.03114791f, -0.04064213f, -0.03408740f, -0.00455724f, -0.02537116f, 0.01775782f, 
    -0.04991259f, -0.02660578f, -0.04945999f, 0.01896681f, -0.02049149f, 0.00988590f, 0.03017443f, -0.04063173f, 
    0.02631387f, 0.02716953f, -0.04679973f, 0.02233081f, -0.01438118f, -0.03599891f, -0.00066138f, 0.00247240f, 
    -0.04486483f, 0.01817336f, -0.02652450f, 0.00116803f, 0.00834118f, -0.03257693f, 0.03721314f, 0.01235893f, 
    0.01152922f, -0.03361123f, 0.03575931f, -0.02965960f, -0.03327547f, -0.02918424f, 0.00694957f, -0.00783900f, 
    -0.05185813f, -0.01842157f, 0.01930866f, -0.03319472f, 0.00128182f, -0.03788641f, 0.01891334f, -0.03759421f, 
    0.03758841f, -0.03387283f, -0.04531009f, 0.04319271f, -0.02240345f, 0.00265313f, -0.02282304f, 0.00416687f, 
    -0.04598536f, -0.01261104f, -0.00359938f, 0.01480526f, 0.04147618f, -0.02055510f, -0.03579441f, 0.01865961f, 
    0.02495614f, 0.03537060f, 0.01594830f, -0.05513422f, 0.04069310f, 0.01141400f, -0.04508499f, -0.05389136f, 
    0.01138628f, -0.05326627f, 0.03047814f, -0.04613769f, 0.01905074f, -0.04350758f, -0.01906794f, 0.02411122f, 
    -0.05155759f, -0.05124676f, -0.00083361f, -0.00178618f, 0.02454419f, -0.03567499f, 0.00373538f, -0.00407183f, 
    -0.03607620f, 0.03242779f, 0.03468893f, 0.01008131f, -0.00205503f, 0.03847128f, -0.03134958f, 0.03867589f, 
    0.03328475f, -0.05550395f, 0.01155560f, -0.03202495f, -0.04874324f, 0.00249713f, -0.00045363f, 0.01247973f, 
    -0.00006298f, 0.03975514f, 0.01685553f, 0.01457789f, -0.02947848f, 0.03626519f, -0.04143251f, 0.02724459f, 
    0.05097370f, 0.04219330f, 0.02893741f, 0.03121089f, -0.02579804f, 0.02600534f, 0.00758459f, 0.00091536f, 
    -0.05772875f, -0.05019213f, -0.02812361f, -0.01190079f, -0.03271597f, 0.02193102f, -0.02299595f, 0.01306977f, 
    -0.23621662f, 0.01135003f, 0.25189391f, -0.12089873f, 0.01281982f, -0.06469958f, 0.17151254f, -0.01833176f, 
    -0.05725574f, 0.00362344f, 0.03642072f, 0.04575848f, 0.00920003f, -0.07304633f, 0.11698531f, 0.08206208f, 
    -0.00812077f, -0.20217013f, -0.04331038f, -0.06348795f, -0.04122843f, 0.04156595f, 0.05703109f, -0.00527283f, 
    0.17455047f, 0.09895913f, -0.04735590f, 0.04926980f, -0.06101440f, -0.04977272f, -0.11912996f, 0.03029853f, 
    0.01813763f, -0.00039521f, 0.09098440f, 0.02898742f, 0.13439912f, -0.06090308f, -0.07605454f, 0.00211005f, 
    -0.00201050f, 0.04423019f, 0.05665820f, 0.12350376f, 0.08097264f, 0.04086989f, -0.02923258f, 0.04032628f, 
    -0.03365742f, 0.10151769f, -0.03906913f, 0.10420904f, -0.06263873f, 0.09642983f, -0.16038102f, -0.12743330f, 
    0.12451272f, -0.11968996f, 0.06959087f, 0.00483883f, 0.29707024f, -0.01529622f, -0.23964860f, -0.05915094f, 
    -0.00467839f, 0.05470929f, -0.09710122f, -0.04429963f, 0.12266111f, 0.05803014f, 0.00087163f, -0.07550691f, 
    0.32300022f, -0.11484699f, -0.08141950f, -0.12987295f, -0.04248503f, -0.17082439f, -0.05549131f, -0.07843706f, 
    0.17613302f, -0.03964327f, 0.01758442f, 0.02391494f, -0.11747693f, 0.14037417f, -0.14097233f, 0.00301178f, 
    0.03675797f, 0.14302380f, -0.02099893f, -0.01984197f, 0.10804726f, 0.03551376f, 0.07915289f, 0.16117369f, 
    0.11292578f, 0.19240372f, -0.01153373f, 0.26748419f, 0.11287648f, 0.05292163f, -0.03062312f, 0.00729449f, 
    -0.02917340f, -0.15141247f, 0.02145010f, -0.02495312f, 0.13219188f, 0.05524613f, -0.15887934f, -0.06275882f, 
    0.01386198f, -0.05686289f, -0.05280243f, -0.03332158f, 0.01527321f, -0.15535544f, 0.01493626f, 0.12389672f, 
    0.03628551f, -0.16383509f, 0.06052383f, -0.19510730f, 0.03412021f, -0.06327236f, 0.13796628f, -0.03116584f, 
    -0.09304076f, -0.03157175f, 0.04829585f, -0.08331525f, -0.03555936f, 0.16466303f, -0.08050377f, 0.09693347f, 
    0.02093890f, -0.08503758f, 0.01315526f, 0.01687490f, 0.10179306f, 0.02293852f, 0.01883301f, -0.07247320f, 
    -0.13384463f, 0.02254704f, 0.05778811f, 0.15229861f, 0.03859036f, -0.02887991f, 0.17126155f, -0.04420775f, 
    -0.08204821f, 0.06821577f, 0.01310700f, 0.08031347f, -0.08747268f, 0.07792296f, 0.21083918f, -0.02151230f, 
    -0.08284231f, 0.11513767f, 0.01379693f, -0.11163920f, -0.07932222f, 0.02185162f, 0.10050397f, -0.07161252f, 
    0.42305115f, 0.15860535f, -0.29417187f, 0.20294085f, -0.00247324f, 0.06913566f, -0.00581569f, 0.07872454f, 
    0.02787218f, -0.04125604f, 0.06192052f, -0.01749188f, 0.03801425f, 0.28763324f, 0.14447068f, 0.03673205f, 
    -0.12471333f, 0.10334337f, 0.00261398f, -0.10099366f, 0.01619162f, 0.01481406f, 0.11237582f, -0.01109228f, 
    0.05799090f, 0.34585986f, -0.08148526f, 0.18840487f, 0.00251517f, 0.17872865f, 0.03199388f, 0.09435096f, 
    -0.05292996f, 0.15678316f, 0.02503813f, 0.18821408f, 0.12475692f, -0.05176648f, 0.03816646f, 0.09632177f, 
    0.05333379f, 0.03737400f, -0.04701092f, -0.07153663f, 0.00578402f, -0.09528609f, -0.04967574f, 0.04964119f, 
    0.00774393f, -0.10136615f, -0.03129110f, -0.03023344f, 0.12720022f, -0.05763044f, 0.01629404f, -0.07267945f, 
    0.00401612f, 0.02206872f, 0.08953645f, 0.05530577f, -0.08030590f, 0.17916057f, 0.14174896f, 0.14002059f, 
    0.08999848f, 0.11463667f, 0.00819946f, -0.00214660f, -0.05368289f, 0.01311828f, 0.11054152f, -0.01338305f, 
    0.03202895f, 0.12574229f, -0.05775337f, -0.00953872f, 0.05263189f, -0.07396965f, -0.02919282f, 0.05165190f, 
    0.02817541f, -0.06912199f, -0.04138549f, -0.11731441f, -0.07078476f, 0.07865663f, -0.19275188f, -0.04106514f, 
    -0.00637822f, 0.13329159f, -0.07361969f, -0.06005101f, 0.08334874f, 0.10307045f, -0.00483848f, -0.07601660f, 
    -0.08975533f, 0.29534879f, 0.11416972f, -0.00485773f, -0.01524976f, -0.07085015f, 0.04658895f, 0.07037938f, 
    0.05352443f, 0.01909633f, -0.02718664f, -0.04024003f, 0.16739897f, 0.01288026f, -0.35458964f, 0.25927776f, 
    -0.02757281f, -0.02106538f, -0.04581551f, -0.04756674f, 0.05720743f, 0.13573706f, 0.15529144f, 0.01926372f, 
    -0.23009352f, 0.19992211f, 0.15857811f, 0.02197531f, 0.11604655f, 0.00334595f, 0.02912484f, 0.02136798f, 
    -0.08053780f, -0.04389312f, 0.10752689f, 0.05003206f, 0.08676896f, 0.00189300f, -0.19855003f, 0.16814072f, 
    -0.03976936f, 0.10031175f, 0.05930383f, -0.03102290f, 0.12459412f, -0.04206222f, -0.17783335f, -0.00086694f, 
    0.15578705f, -0.14498468f, 0.16824569f, 0.17051584f, 0.04413551f, 0.01726519f, 0.12111953f, -0.00630831f, 
    0.02732432f, -0.03249183f, 0.02652798f, 0.04129173f, 0.13431992f, 0.18236724f, -0.16873118f, 0.05870555f, 
    0.21761312f, 0.18928795f, 0.05956693f, -0.03622279f, 0.02729149f, -0.08709265f, 0.18295878f, -0.06646835f, 
    -0.09109426f, 0.29155818f, -0.21108785f, 0.05240477f, 0.15846960f, 0.20322880f, -0.06690414f, 0.00915696f, 
    0.20990252f, 0.08651043f, 0.05883401f, 0.01698721f, -0.15583378f, -0.01831341f, -0.09408982f, 0.31249630f, 
    0.01070885f, -0.15291382f, 0.08143400f, 0.08973975f, -0.06896728f, 0.02925941f, -0.09061647f, 0.10771737f, 
    -0.29841796f, -0.01452427f, 0.08095591f, 0.05840054f, -0.14045709f, -0.01753253f, 0.07344274f, -0.03140815f, 
    -0.10604294f, -0.11866742f, 0.08971730f, -0.05371311f, 0.14507581f, -0.05188183f, -0.10877986f, -0.01650752f, 
    0.09388794f, -0.21750447f, -0.03567429f, 0.06946229f, 0.17443202f, -0.00483900f, -0.07845295f, -0.05977527f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04308872f, 0.06909074f, 0.03019455f, -0.01688393f, 0.10213607f, 0.09503163f, 0.02026945f, 0.03443978f, 
    0.14942777f, 0.01723724f, 0.06644671f, 0.01895573f, 0.02054657f, -0.01172842f, 0.08215596f, -0.02789222f, 
    0.04695003f, 0.08665444f, -0.04648698f, 0.09358176f, 0.01104009f, -0.03322805f, -0.03041120f, -0.00070230f, 
    -0.03315679f, -0.00645318f, -0.04351353f, -0.03853985f, 0.04021565f, -0.05131764f, 0.01077695f, -0.00901743f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04942385f, -0.04108522f, -0.06682301f, -0.53003174f, -0.18225862f, 0.25568244f, -0.14514408f, 0.08156210f, 
    0.01490099f, -0.11240684f, 0.21004565f, 0.02082817f, -0.12210829f, -0.12872842f, -0.06463514f, -0.12522590f, 
    -0.26358175f, 0.32600680f, -0.03521423f, 0.14954314f, 0.38631636f, 0.35190049f, -0.13149196f, -0.01990188f, 
    -0.18298993f, -0.11745085f, -0.41537726f, -0.15705986f, 0.10931018f, -0.06329075f, -0.15174171f, -0.28412670f, 
    0.05327275f, -0.35905668f, 0.04355127f, 0.34394863f, 0.38703012f, 0.21725199f, 0.10605988f, 0.01881461f, 
    0.25240776f, -0.13062541f, 0.00076973f, -0.17637630f, 0.05893642f, 0.01440589f, 0.15618865f, -0.06228416f, 
    -0.29236919f, 0.32453251f, -0.20440395f, 0.24062622f, -0.25311866f, -0.37527797f, -0.09810185f, 0.02164191f, 
    -0.26425967f, 0.04269872f, -0.12047072f, -0.14467368f, 0.02953400f, -0.05906725f, -0.09726899f, -0.19808769f, 
    0.05931944f, 0.62978280f, -0.17886212f, -0.10186432f, -0.03282124f, 0.46763071f, 0.08268820f, -0.01638578f, 
    0.21332915f, -0.08952419f, 0.04334973f, 0.17504472f, -0.01262927f, 0.14440724f, -0.14278902f, 0.05059878f, 
    0.47142863f, -0.07407320f, -0.38641822f, -0.02964183f, -0.07707880f, -0.05699518f, 0.17296885f, 0.08145941f, 
    0.33573928f, 0.06388509f, -0.25849208f, 0.14693037f, 0.03509381f, -0.17349322f, 0.05014580f, 0.03595191f, 
    -0.15820506f, -0.15397878f, -0.16571645f, 0.02598431f, -0.14432637f, 0.30473608f, 0.10267784f, 0.15095994f, 
    -0.17481007f, 0.07082622f, 0.33340871f, -0.13830237f, 0.30442527f, -0.15518829f, 0.07250346f, -0.01402075f, 
    0.00024945f, 0.58790451f, 0.06456920f, 0.15968592f, -0.08192775f, 0.12457270f, 0.11459830f, -0.16354933f, 
    -0.22302984f, -0.12799433f, 0.26847339f, 0.09465078f, 0.04188019f, -0.09895510f, -0.10957507f, 0.02451197f, 
    -0.04708587f, 0.01652150f, 0.11564709f, -0.04479535f, 0.14790151f, 0.02504559f, -0.03663884f, -0.01529159f, 
    -0.13757750f, 0.08668996f, -0.09286277f, 0.15092473f, -0.07678300f, -0.01518897f, 0.12214104f, 0.06640451f, 
    -0.07357084f, 0.10724412f, -0.14122221f, -0.15866330f, 0.06824981f, -0.06459111f, 0.16460253f, 0.08624608f, 
    -0.04660892f, -0.13784169f, -0.11520794f, 0.15759262f, -0.15388334f, -0.03893595f, 0.00013649f, -0.17558411f, 
    0.02948182f, 0.11669163f, -0.17666757f, -0.20770726f, -0.35449928f, -0.13141185f, -0.04692364f, 0.10459413f, 
    0.28184876f, 0.11275704f, -0.27595511f, 0.09814832f, 0.52967882f, -0.04926806f, 0.34188735f, 0.03436993f, 
    0.29108492f, -0.28960979f, -0.33597988f, 0.09687401f, 0.07478064f, 0.02503926f, -0.03688736f, -0.02725525f, 
    0.24718142f, 0.13596550f, 0.47225976f, -0.01535068f, -0.36198002f, -0.07360441f, 0.05936927f, 0.01251690f, 
    -0.06683096f, 0.07983932f, 0.11685891f, 0.13019231f, 0.16831255f, 0.05610883f, -0.11049496f, -0.02529220f, 
    0.27919608f, -0.15049031f, 0.40346763f, -0.00039945f, -0.16918066f, 0.01766689f, 0.05773741f, -0.08016448f, 
    -0.02053899f, -0.16340777f, 0.35321194f, 0.07139882f, 0.07176965f, -0.53229356f, -0.11507586f, -0.13766311f, 
    -0.22533755f, -0.17493497f, 0.35050693f, -0.08061537f, -0.12065739f, -0.01990017f, 0.04964527f, -0.12678161f, 
    0.01836469f, 0.44069642f, -0.12010010f, -0.15373105f, 0.23001015f, 0.19640386f, 0.07360536f, 0.11561885f, 
    -0.08474910f, -0.17794183f, 0.31430939f, -0.02043009f, 0.04686286f, 0.11178759f, -0.06320000f, 0.18174060f, 
    -0.02215612f, 0.19870505f, -0.19568790f, 0.10388338f, 0.17296556f, 0.09550960f, -0.03683540f, -0.13639793f, 
    0.21550703f, 0.03801054f, -0.25112218f, -0.10920820f, 0.08321133f, -0.10039240f, 0.15763728f, -0.10605195f, 
    0.05408138f, 0.27924174f, 0.12513012f, -0.25779152f, 0.01973193f, -0.46293753f, 0.00385324f, -0.06836220f, 
    0.10483896f, -0.02147288f, 0.08638220f, 0.14417443f, 0.41528380f, -0.13170677f, 0.08467995f, -0.10497651f, 
    -0.11657110f, 0.14692761f, -0.43487781f, 0.09293729f, -0.03081405f, 0.06621753f, -0.10485572f, -0.12556051f, 
    0.16974960f, 0.03789637f, 0.37619632f, -0.06998077f, 0.30593902f, 0.07546701f, -0.12687430f, -0.05754825f, 
    -0.03955395f, 0.38368759f, -0.05885662f, 0.53301871f, -0.09329554f, 0.33844349f, -0.10812330f, 0.15679416f, 
    0.02979716f, 0.07062967f, 0.10543252f, 0.11029518f, -0.27850273f, -0.07666300f, -0.09871796f, 0.00690198f, 
    -0.14643252f, -0.01352430f, 0.00445138f, 0.14101660f, 0.23120931f, 0.47028857f, 0.09132034f, 0.15409857f, 
    0.01032627f, 0.14602241f, -0.34088194f, 0.13858221f, -0.34466928f, 0.00030584f, 0.04569452f, 0.22587129f, 
    -0.01960216f, -0.03742785f, 0.07712898f, 0.43592003f, 0.35414729f, -0.35083735f, 0.13753909f, 0.10003845f, 
    0.05443348f, -0.16203672f, -0.32558441f, 0.13855578f, 0.06880763f, -0.00136632f, 0.22255903f, 0.17026831f, 
    -0.14188713f, -0.17912835f, 0.19754462f, 0.06842216f, -0.23906469f, -0.19554824f, 0.06928440f, -0.07100515f, 
    0.24328074f, -0.11915759f, -0.34349188f, 0.00518172f, 0.46653935f, -0.17450106f, -0.01267644f, 0.04843728f, 
    0.14781231f, 0.14569847f, 0.06153147f, -0.42755696f, -0.18474178f, -0.18255083f, -0.10820092f, 0.05508214f, 
    -0.09244776f, -0.06704406f, 0.04469839f, -0.09107344f, 0.20371476f, -0.09021090f, -0.01377838f, -0.07526020f, 
    0.32193390f, -0.09538320f, 0.61241645f, 0.24420619f, 0.11272381f, -0.26974252f, 0.00798158f, -0.11906725f, 
    -0.17122099f, 0.01791334f, 0.07563854f, -0.02015070f, 0.49825311f, -0.09212799f, 0.02391558f, -0.21659182f, 
    -0.09095813f, 0.06733403f, 0.06369786f, 0.09232232f, 0.36491710f, -0.32711914f, -0.03318955f, -0.09174718f, 
    -0.13460685f, 0.05201226f, 0.09971273f, 0.00487123f, 0.28797221f, -0.04491870f, 0.21537490f, -0.16350941f, 
    0.36122924f, -0.09923120f, 0.48591942f, -0.01309616f, -0.04775533f, -0.03310507f, -0.06975400f, -0.08437055f, 
    0.33033556f, -0.07873855f, 0.40404394f, -0.16154224f, -0.09185191f, -0.08544135f, -0.04599420f, 0.00676853f, 
    -0.10047474f, -0.18657030f, -0.03188858f, 0.14580783f, -0.04699129f, -0.34548429f, -0.06841774f, 0.14288683f, 
    0.36066064f, 0.06036493f, 0.08693659f, -0.08998883f, 0.12892900f, 0.06284185f, 0.06750849f, 0.11861295f, 
    -0.29368299f, -0.13048477f, -0.23546448f, 0.30880877f, 0.22661400f, 0.05511545f, 0.04049151f, 0.08523022f, 
    -0.14817512f, -0.08359292f, 0.35970432f, 0.01001361f, -0.37775040f, -0.17221802f, -0.16852374f, 0.05237882f, 
    -0.17156769f, 0.27185774f, -0.06963478f, 0.33829117f, 0.20526017f, 0.11833887f, -0.12427966f, 0.04153667f, 
    0.05138104f, -0.14499484f, -0.11574493f, 0.14073302f, -0.18682337f, 0.00950709f, 0.16121052f, 0.09092931f, 
    0.34421054f, -0.25387070f, 0.29671440f, 0.14043960f, -0.26925322f, 0.00161564f, -0.06650342f, 0.07181322f, 
    0.07374209f, -0.16670299f, -0.32289821f, 0.03832999f, 0.06037369f, 0.00149911f, -0.06609768f, -0.11190597f, 
    0.15084015f, -0.25408673f, -0.02303399f, -0.30675474f, 0.25343832f, 0.07438935f, 0.05890380f, 0.15168232f, 
    0.06975176f, 0.07353864f, -0.16152674f, -0.08268004f, -0.07871259f, -0.10596086f, 0.31666553f, 0.13671736f, 
    0.26949295f, -0.03613515f, -0.16698462f, -0.15281847f, 0.30369750f, 0.17152932f, -0.04707604f, -0.09532066f, 
    0.29873094f, -0.05911174f, -0.12296971f, 0.08667231f, 0.52357745f, 0.03551599f, 0.12887992f, 0.45106179f, 
    0.17008334f, -0.04796476f, -0.11131158f, 0.03813733f, 0.30996206f, 0.33558303f, -0.11323998f, 0.06212336f, 
    0.20333064f, 0.12498248f, 0.16289847f, 0.05154399f, -0.13903750f, 0.06740556f, 0.11234829f, -0.09626140f, 
    0.24094281f, 0.44888347f, -0.04448200f, 0.11101937f, -0.23531279f, -0.61438072f, -0.09227090f, 0.16462947f, 
    -0.30289978f, -0.16236258f, -0.23398383f, -0.04105354f, 0.20067695f, -0.15550163f, -0.09871729f, -0.08927207f, 
    -0.17146808f, -0.05126359f, 0.07617906f, -0.04945933f, -0.02040944f, -0.12494751f, -0.01651360f, -0.14509188f, 
    -0.08989707f, -0.01395497f, -0.14942639f, -0.01491800f, 0.02287687f, 0.14311641f, -0.01064280f, -0.11331233f, 
    -0.13365419f, -0.13737634f, -0.14080897f, -0.06157604f, -0.12830395f, 0.09764902f, 0.05531441f, -0.10522917f, 
    -0.11902186f, 0.05064502f, 0.15922923f, 0.06259996f, -0.12032436f, -0.15617086f, -0.02331463f, -0.08906303f, 
    -0.11053131f, 0.42722857f, 0.00644453f, 0.01861784f, -0.12476493f, 0.10066629f, 0.02983721f, -0.01774041f, 
    0.00321082f, 0.15360537f, -0.06324846f, -0.00516360f, 0.09817967f, 0.06071864f, -0.40017590f, -0.00857079f, 
    0.09956091f, 0.21311763f, 0.17724746f, 0.22568449f, -0.05914514f, 0.06271826f, -0.04148383f, -0.04657994f, 
    0.05859315f, -0.14111336f, -0.54962999f, 0.03638790f, 0.00705647f, -0.11436747f, 0.08442559f, -0.22806415f, 
    0.03519502f, 0.13687669f, 0.09611097f, 0.06412469f, -0.09379285f, -0.06137356f, 0.13845965f, -0.00617281f, 
    0.01501912f, -0.04493720f, 0.13204929f, 0.17487571f, -0.08465671f, -0.04694369f, -0.09559331f, 0.12013898f, 
    0.10739535f, -0.04994332f, -0.08683688f, -0.15985182f, -0.15470390f, 0.14245059f, -0.16571954f, -0.12515366f, 
    -0.11517581f, -0.03167221f, 0.01959058f, 0.05065476f, 0.00188011f, -0.01356675f, 0.07908945f, -0.11419810f, 
    -0.09492323f, -0.06074649f, -0.12063345f, -0.29169759f, 0.20686296f, 0.10466867f, -0.03735022f, -0.15559627f, 
    -0.26401612f, 0.16326226f, 0.01095261f, -0.15399897f, 0.48717499f, 0.01816648f, 0.00866456f, -0.07364425f, 
    0.12680912f, 0.20887911f, 0.43847847f, 0.09771333f, 0.13197309f, -0.60924083f, 0.07364739f, -0.02367981f, 
    0.26980841f, -0.05761769f, -0.18432467f, 0.05247369f, 0.50207323f, 0.06310547f, -0.15871707f, 0.26751399f, 
    -0.01713402f, -0.54752553f, -0.05909939f, 0.09844629f, 0.18341865f, 0.00383487f, 0.06773114f, -0.09024025f, 
    0.01724715f, 0.06730407f, 0.17784782f, -0.17615701f, -0.34343028f, 0.02628326f, 0.30862185f, -0.02384338f, 
    0.00376504f, 0.06792735f, 0.44823125f, 0.22544342f, 0.06523515f, -0.01844044f, 0.03371763f, 0.14331821f, 
    -0.34279531f, -0.11558566f, 0.18927133f, 0.11750653f, -0.13497707f, 0.02874896f, -0.07747771f, 0.02420980f, 
    -0.16929048f, -0.05781155f, -0.11705954f, -0.04477359f, -0.36190701f, 0.24971133f, -0.07063802f, -0.09898420f, 
    0.35277241f, -0.02204228f, -0.03320654f, -0.13011509f, -0.07046841f, -0.06092364f, 0.30658805f, -0.06013414f, 
    -0.08380757f, -0.19761388f, -0.58739197f, 0.09844703f, 0.35773331f, 0.31458953f, -0.02437441f, 0.08098514f, 
    -0.03806872f, -0.11164773f, -0.37072742f, 0.16838565f, 0.03662236f, -0.16098019f, -0.02036224f, 0.04829933f, 
    0.03445163f, 0.27736640f, -0.08545581f, 0.17195766f, 0.06099112f, -0.52335334f, -0.06849638f, 0.10656841f, 
    0.05796145f, 0.00920619f, 0.34734744f, 0.12367798f, -0.02552104f, -0.06558990f, -0.27371469f, 0.08542586f, 
    -0.23705947f, 0.00522675f, 0.43235961f, 0.13185619f, 0.29210708f, -0.02906400f, 0.11875363f, 0.12929550f, 
    0.23448470f, 0.05889378f, 0.45796284f, 0.08455911f, -0.34097609f, -0.12267141f, 0.16306457f, -0.23718415f, 
    -0.00113381f, -0.14323285f, -0.09318354f, 0.03537486f, -0.06015873f, -0.13608493f, 0.13392648f, 0.13938169f, 
    -0.15865692f, 0.11227942f, 0.13126265f, -0.05656101f, 0.01509728f, -0.03385640f, -0.05858849f, 0.11573891f, 
    -0.09451150f, -0.17760825f, -0.17501250f, -0.13843444f, 0.05989952f, -0.13910110f, 0.05574707f, -0.03615424f, 
    0.16120005f, 0.09605796f, -0.04386740f, -0.03010050f, -0.04887750f, 0.08638028f, -0.13717166f, -0.01464016f, 
    -0.03481542f, -0.12728840f, -0.06789004f, -0.00010697f, -0.22130580f, -0.08769930f, -0.06532840f, -0.14216527f, 
    0.08925114f, -0.12836650f, -0.19600756f, 0.01712458f, -0.13098656f, 0.07581988f, -0.21052520f, -0.17449079f, 
    -0.02233793f, -0.03367180f, -0.10035487f, 0.09346923f, -0.01029640f, -0.01433244f, -0.04233813f, 0.03906374f, 
    -0.10635239f, -0.04500948f, -0.00233628f, 0.08103279f, 0.15456790f, 0.03525613f, -0.13220046f, -0.16701564f, 
    -0.01186692f, 0.11358956f, 0.14447649f, 0.00619270f, 0.06836318f, -0.04815161f, -0.00324713f, -0.03425394f, 
    -0.04613319f, 0.05443774f, 0.10698685f, 0.14120464f, 0.10171998f, 0.03360771f, 0.11141865f, -0.02928129f, 
    -0.15912117f, -0.00126360f, 0.10532920f, -0.16455121f, 0.03295070f, -0.06440504f, -0.11412410f, 0.13881016f, 
    -0.16502878f, 0.03577656f, -0.13977440f, -0.02807016f, -0.02349624f, -0.05599184f, 0.00099007f, -0.13406089f, 
    -0.08467946f, 0.00766736f, 0.06055166f, 0.40429574f, -0.25741699f, -0.10027125f, 0.11208589f, -0.04218086f, 
    0.23515850f, 0.15943100f, -0.36845508f, 0.08926374f, 0.14563787f, 0.00761250f, -0.00684647f, 0.04020727f, 
    -0.19915944f, -0.42319849f, 0.05143567f, 0.15196918f, 0.07089537f, -0.20006278f, 0.11385318f, -0.17654805f, 
    0.36555278f, -0.12047752f, -0.14842357f, -0.14904732f, -0.27992859f, -0.00674284f, -0.04448003f, 0.33204663f, 
    -0.08977184f, 0.06476605f, -0.00690861f, -0.00349395f, -0.17756963f, -0.12378535f, -0.04501627f, 0.05225332f, 
    -0.04789625f, -0.04616235f, -0.02274439f, -0.09456598f, 0.08732166f, 0.02412233f, 0.13095571f, -0.07320406f, 
    -0.07195136f, -0.16225314f, -0.05337733f, -0.08319382f, 0.06073198f, 0.11516038f, -0.16935742f, 0.08270021f, 
    -0.12905432f, 0.07431798f, -0.09611275f, -0.01028805f, -0.00917900f, 0.04895011f, -0.17055871f, 0.01552068f, 
    -0.10698872f, -0.51328409f, 0.07477639f, 0.27002639f, 0.49660039f, 0.36308101f, 0.00286144f, -0.00362418f, 
    0.05759738f, 0.01820849f, 0.27459848f, -0.11792363f, -0.08895026f, -0.08265465f, 0.30867946f, -0.11170176f, 
    0.18383920f, 0.37163541f, -0.12824810f, -0.12205871f, -0.07108346f, 0.33261254f, -0.05780355f, 0.16406476f, 
    -0.28140062f, -0.15826079f, 0.30382612f, 0.08534791f, -0.15459093f, -0.00922675f, 0.15523103f, 0.34082866f, 
    -0.07021026f, -0.02920326f, 0.07144441f, 0.00657429f, -0.12397073f, 0.04889944f, -0.09376390f, -0.09484565f, 
    -0.13384563f, 0.14444400f, -0.12950851f, 0.10628645f, -0.09069387f, -0.15360606f, 0.02116393f, 0.13212390f, 
    0.09026567f, 0.10812289f, -0.02361451f, -0.17516477f, 0.05952216f, -0.16823491f, -0.07658503f, 0.03538653f, 
    -0.07856115f, -0.17027646f, 0.06060420f, -0.05696646f, 0.04524848f, 0.14007410f, -0.02116339f, -0.04875023f, 
    -0.15012752f, -0.37705365f, -0.09569205f, -0.09623986f, 0.09874018f, 0.03672498f, 0.14332174f, 0.07401313f, 
    -0.13529541f, -0.08979620f, -0.01100556f, -0.12255810f, 0.13548082f, -0.16306244f, 0.17362744f, -0.02854075f, 
    0.51398575f, -0.34278911f, -0.10395435f, 0.01067083f, -0.08743639f, 0.11093052f, 0.11555051f, 0.11956814f, 
    0.00008140f, -0.05634943f, 0.37340325f, 0.15563950f, 0.14931712f, -0.09022243f, 0.12044451f, 0.41518936f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.26073238f, 0.26168969f, 0.23373309f, 0.02963509f, -0.04706263f, 0.04732306f, 0.12274238f, 0.14911944f, 
    -0.00165069f, -0.12001698f, -0.09962162f, 0.03161174f, -0.05484885f, -0.05934548f, 0.10513486f, -0.01330249f, 
    0.02362479f, 0.08353910f, -0.13333599f, 0.16810766f, 0.02776029f, -0.11576125f, 0.19602644f, -0.08656451f, 
    0.05945471f, -0.20664299f, -0.08435704f, -0.09145118f, -0.16117457f, 0.14482470f, -0.11264475f, 0.11217205f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.72730201f, 0.05408762f, -0.05412744f, 0.07475544f, 0.02022345f, -0.00897800f, 0.14194694f, 0.04804908f, 
    -0.09266894f, 0.13017762f, -0.42866951f, -0.02443432f, 0.32735255f, 0.08415020f, 0.04821973f, -0.80276799f, 
    -0.05016661f, -0.11712065f, 0.19172713f, -0.06882568f, 0.02937165f, -0.07977900f, -0.61604846f, 0.37800550f, 
    -0.01268692f, 0.01019721f, -0.01433822f, 0.11687429f, -0.00486250f, -0.09019426f, -0.03697465f, -0.48001277f, 
    0.23046134f, 0.27395603f, -0.55053127f, -0.01053991f, -0.06707913f, -0.40057459f, 0.23232383f, -0.10438431f, 
    0.12624368f, -0.17012967f, -0.14400393f, 0.27257633f, -0.02451027f, 0.21094340f, -0.14948212f, -0.16879381f, 
    0.07407910f, -0.16623183f, -0.16611610f, -0.06060697f, -0.16183507f, 0.38916892f, -0.20297819f, 0.12425764f, 
    -0.08946764f, -0.06068102f, -0.09418356f, -0.65038204f, 0.01801396f, 0.05611538f, -0.07594411f, 0.14090374f, 
    0.34618539f, -0.66862905f, -0.00173861f, 0.03995968f, 0.09899300f, -0.55049956f, -0.01042900f, 0.21674629f, 
    -0.43388978f, 0.34888527f, -0.47648835f, 0.25634417f, 0.10951304f, -0.25935414f, 0.23033929f, -0.15701512f, 
    -0.15912032f, 0.08322053f, 0.36598226f, -0.09191100f, -0.22284806f, 0.09740075f, 0.01126173f, 0.14569518f, 
    0.13919011f, 0.13476881f, -0.03012528f, -0.43944836f, -0.04215892f, -0.19738583f, -0.00976208f, -0.65814835f, 
    -0.70075119f, -0.13702740f, 0.04748093f, 0.26339003f, 0.11558276f, 0.29046634f, -0.41053152f, -0.09871916f, 
    0.33426303f, -0.76040280f, -0.25277570f, 0.38756490f, 0.26116481f, -0.21456286f, -0.08860279f, 0.03242904f, 
    -0.06788577f, 0.09006360f, -0.05882240f, 0.02748973f, 0.25550151f, -0.34515870f, -0.22812356f, -0.29651237f, 
    0.09798640f, -0.04067728f, 0.05752626f, -0.36568025f, 0.02988189f, -0.03060958f, 0.06459081f, 0.13700439f, 
    0.08301754f, -0.47272354f, -0.04441460f, -0.28694916f, -0.13147977f, 0.19851287f, 0.16064852f, -0.16385205f, 
    -0.10666677f, -0.12437885f, -0.14229268f, 0.38253435f, 0.13965108f, -0.02662747f, -0.15264034f, 0.17188409f, 
    -0.38118747f, -0.01810911f, -0.28203177f, 0.13677867f, 0.11578707f, 0.00742923f, 0.07299078f, 0.10393694f, 
    0.01320845f, -0.17939365f, 0.00905460f, 0.30143172f, 0.00447065f, -0.42422095f, 0.01047349f, 0.05642347f, 
    -0.11698213f, 0.49612841f, -0.22861061f, -0.14465022f, 0.14283444f, 0.10555962f, 0.04919935f, -0.28404027f, 
    -0.16776326f, 0.00965627f, 0.17444636f, -0.34997004f, -0.02979430f, 0.26558742f, 0.24079548f, -0.24528418f, 
    0.06936551f, 0.00105213f, -0.09235734f, -0.03276429f, -0.43842405f, 0.25062564f, 0.14372036f, -0.16909622f, 
    -0.08899611f, 0.12615220f, -0.00286034f, 0.25103164f, -0.02207252f, 0.07495589f, 0.16750936f, -0.23481432f, 
    0.05788611f, -0.16669270f, -0.07747076f, -0.15268120f, -0.04755691f, 0.21886879f, -0.13815010f, 0.17448908f, 
    0.29115054f, 0.04775595f, -1.03383803f, -0.57171780f, 0.09238987f, 0.26667732f, -0.38707310f, 0.11899729f, 
    -0.62196034f, 0.17620227f, -0.66411722f, 0.15099964f, -0.42826676f, -0.27820262f, 0.24247083f, 0.24659038f, 
    -0.01673687f, 0.01583978f, -0.03667219f, 0.00192775f, 0.00994308f, -0.05506091f, 0.01959560f, -0.40798938f, 
    0.04082971f, -0.35999149f, -0.09993435f, -0.43620998f, 0.09135182f, -0.21551715f, -0.60984761f, -0.14912683f, 
    0.06856787f, 0.13100713f, 0.32419580f, 0.00615099f, 0.22465764f, -0.46333247f, 0.25714624f, 0.35835928f, 
    -0.39813739f, 0.00538089f, -0.11081156f, 0.05211943f, 0.13164155f, 0.09766358f, -0.38213119f, -0.29307640f, 
    -0.07028797f, 0.00343459f, 0.04753128f, 0.13373089f, -0.03487629f, -0.02335322f, 0.04677143f, 0.14547083f, 
    0.33525890f, 0.15058002f, -0.39711425f, 0.29643810f, 0.06438646f, -0.49097288f, -0.30988377f, 0.02512490f, 
    -0.40053502f, 0.28319722f, -0.17983107f, -0.42882416f, -0.29065856f, -0.16796629f, -0.34268269f, 0.24016480f, 
    0.00552670f, 0.17533000f, -0.22848815f, -0.03737610f, 0.06454057f, 0.18145825f, 0.15274142f, -0.44117379f, 
    0.04135597f, -0.22003402f, 0.06126699f, -0.13442506f, 0.02495824f, 0.34531668f, -0.12409230f, 0.08849970f, 
    0.10430006f, -0.08363903f, 0.42769095f, -0.17191033f, -0.11747543f, 0.12530695f, -0.16990969f, 0.04849158f, 
    0.13178232f, 0.27196544f, -0.09389969f, -0.03512096f, -0.38535625f, 0.05778456f, 0.00444794f, -0.16030717f, 
    -0.05336053f, -0.09394482f, 0.58718097f, -0.09057101f, -0.21792173f, -0.74872243f, 0.24048662f, -0.13346703f, 
    0.10339735f, 0.07465553f, -0.01698419f, 0.29347655f, -0.18239842f, -0.58172566f, 0.14820172f, -0.61250281f, 
    0.11161976f, 0.50636697f, 0.26436937f, -0.15863399f, 0.01771798f, -0.47444907f, 0.10717974f, 0.11258122f, 
    -0.00487136f, -0.43111396f, 0.20647742f, 0.06010647f, 0.03725770f, -0.48826814f, 0.02966394f, 0.10218365f, 
    0.43803009f, -0.16174515f, -0.00243507f, -0.12482345f, 0.24985391f, -0.23772554f, -0.14690936f, -0.26643354f, 
    -0.08521754f, 0.06656533f, -0.07604928f, -0.16937844f, 0.06230666f, -0.09240763f, 0.00276948f, -0.34265259f, 
    -0.68922949f, -0.27886999f, 0.41236687f, -0.12926543f, 0.11400980f, 0.19817932f, 0.15684560f, -0.11435012f, 
    -0.12711720f, -0.02069788f, -0.81384796f, -0.26760834f, 0.11548752f, -0.16022731f, 0.07437388f, 0.20794746f, 
    0.11044303f, -0.04992410f, -0.53349137f, 0.09490780f, -0.26482999f, 0.04062403f, 0.06318350f, -0.28436813f, 
    -0.05144389f, 0.10007990f, 0.09092051f, -0.33060774f, -0.10821580f, 0.35781044f, 0.10493697f, 0.29980576f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.17248775f, 0.02536556f, 0.06203686f, -0.07734182f, 0.05937963f, 0.18555550f, -0.09407463f, -0.25876740f, 
    -0.08397859f, -0.05943264f, 0.01358805f, 0.06954557f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
