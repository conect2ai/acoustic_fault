#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.40846354f, -0.87429208f, -0.09231476f, -0.77314484f, 0.24833065f, -0.25057673f, -0.38031712f, -0.60485077f, 
    -0.20882972f, 0.61859280f, 0.66694140f, -0.21659212f, -0.47769040f, 0.41024685f, -0.23562695f, -0.19699691f, 
    0.56650764f, -0.41153529f, 0.22495572f, -0.22194090f, 0.03223113f, -0.23900820f, -0.83456022f, -0.90727609f, 
    -0.23990670f, 0.70364749f, -0.15483998f, 0.34484795f, 0.17419064f, 0.97663307f, -0.62865353f, -0.62259275f, 
    -0.02577083f, 0.39825392f, -0.25861701f, -0.02056136f, -0.80968839f, 1.06230664f, -0.49468789f, -0.84811062f, 
    0.40634385f, 1.00914776f, -0.10432322f, 0.06899431f, -0.24587102f, 0.03321647f, -0.52902961f, 0.54237837f, 
    -0.69169390f, 0.02581940f, 0.63665700f, -0.71044201f, 0.07430983f, 0.72539866f, -0.54885888f, -0.22524515f, 
    0.86089379f, 0.94496775f, -0.62258834f, -0.52167207f, 0.21056353f, -0.10787172f, -0.08702356f, 0.53397161f, 
    -0.42720911f, -0.04466464f, 0.39124498f, -0.18408650f, -0.03771342f, -0.39948699f, -0.30132097f, 0.52903157f, 
    -1.16896725f, -0.76546782f, 0.00189185f, 0.11629161f, 0.70143777f, 0.41727075f, 0.35135749f, 0.38611457f, 
    -0.23837784f, 0.48392567f, 0.25750977f, -0.14331082f, 0.23777875f, -0.16260615f, -0.02406282f, -0.13864537f, 
    0.38505408f, 0.42240408f, -0.56432372f, -0.71774709f, -0.64317024f, 0.74804449f, 0.02613674f, -0.22113052f, 
    -0.63982379f, -0.63802844f, -0.31856149f, 0.36154956f, 0.80560547f, 0.15017964f, -0.78266740f, -0.70189553f, 
    -0.50093174f, 0.49544472f, -0.11494029f, 0.55887032f, 0.95691472f, 0.70999420f, -0.69544595f, 0.18718295f, 
    0.00821559f, 0.15220428f, -0.25692511f, -0.35562021f, 0.03419609f, 1.14971209f, -0.20137061f, -0.61480391f, 
    0.81573701f, -0.37190172f, 0.62495106f, -0.45538041f, 0.26624715f, -0.57762301f, -0.00009319f, 0.07546145f, 
    0.37036291f, 0.69391346f, -0.39570132f, 0.20069782f, 0.11775413f, -0.01789280f, -0.49251458f, -0.81493479f, 
    -0.31699705f, -0.57610923f, 0.12314145f, 0.25393665f, -0.10081321f, 0.29114425f, 0.44670105f, 0.49848890f, 
    0.51794153f, -0.90926921f, -0.81650442f, 0.65272230f, 0.01771661f, -0.86194712f, 0.01204929f, 0.12475581f, 
    0.53971297f, 0.38966960f, 0.65094441f, 0.42428347f, 0.00491943f, -0.19377986f, -0.39554054f, 0.06498627f, 
    -0.16877532f, -0.07373066f, -0.34666413f, 0.73283803f, 0.08262125f, -0.01989824f, 0.36672720f, 0.14868076f, 
    0.28554103f, -0.05084247f, -0.18809298f, -0.60545164f, 0.70373261f, 0.59987360f, -0.56024885f, 0.10821751f, 
    0.03826593f, 0.20359671f, -0.47356719f, 0.11247277f, 0.38607308f, -0.01185681f, -0.45702735f, -0.73979032f, 
    -0.55803293f, -0.55639374f, -0.19752075f, -0.66181064f, -0.05890245f, 0.08263291f, 0.30480251f, -0.00415952f, 
    0.10976322f, 0.50558871f, -0.23890272f, -0.44084638f, 0.31419790f, 0.22626363f, -0.95146948f, -1.07183766f, 
    -0.17106971f, 0.82967085f, 0.80121088f, -0.42504036f, 0.15821546f, -0.24498171f, -0.40137613f, 0.46380350f, 
    -0.07959007f, -0.09825194f, -0.01504835f, 0.16057229f, 0.52286196f, -0.03132134f, 0.13950379f, 0.32137743f, 
    -1.52706993f, 0.55635959f, 0.54385519f, 0.16214187f, 0.26647878f, 0.22490384f, -0.03697613f, -0.37213710f, 
    0.08149583f, 0.02132787f, 0.36984941f, 0.04990386f, 0.65175819f, -0.41278020f, -0.46531796f, 0.09184687f, 
    0.08926241f, -0.14369844f, -1.23164499f, -0.02102953f, 1.02508080f, -0.28609481f, 0.10970966f, -0.47066885f, 
    -0.45611486f, -0.23356481f, -0.10614310f, -0.65279979f, -0.78549719f, 0.15847820f, -0.59725893f, -0.78183669f, 
    -0.51858741f, -0.09521991f, -0.57620460f, -0.67476481f, 0.16728100f, 0.35728660f, -0.41253611f, -0.60601795f, 
    -0.44241354f, -0.14861442f, -0.53676409f, -0.41100234f, -0.27150717f, -0.88850302f, -0.63729024f, 0.13478048f, 
    -0.51998681f, 0.19674718f, -0.26377019f, 0.65882289f, -0.05803457f, 0.67360210f, -0.22131671f, 1.08196735f, 
    -0.15795192f, -0.76401073f, -0.60482925f, -0.33904192f, -0.32549053f, -0.05601859f, -0.26731548f, -0.77161425f, 
    -0.52249169f, -0.32043251f, 0.86376560f, -0.55310184f, -0.50398701f, -0.56700993f, -0.11586446f, -0.08899896f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08980282f, 0.29233545f, 0.31969371f, 0.17749588f, 0.13278714f, 0.22530846f, 0.14247175f, 0.38830093f, 
    0.18374471f, -0.16822435f, 0.05228611f, -0.07057057f, 0.29335651f, -0.04028399f, -0.29686475f, -0.08291136f, 
    0.26655847f, 0.36077699f, -0.21269649f, 0.25719565f, -0.24788730f, -0.04747247f, 0.24915200f, -0.26305729f, 
    -0.02323741f, 0.26612645f, 0.18743640f, -0.19077609f, 0.02836713f, 0.36258355f, 0.02473547f, -0.14906178f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05085313f, 0.02910361f, -0.02027676f, 0.07511880f, -0.03261605f, 0.08210814f, 0.15122293f, -0.05287727f, 
    -0.01436781f, 0.14727172f, -0.02960298f, -0.02645788f, 0.00268929f, -0.02787836f, -0.00541636f, -0.04890439f, 
    -0.10419291f, 0.05165064f, 0.00410408f, -0.07256899f, 0.22560653f, 0.15024035f, 0.39704311f, 0.07474705f, 
    -0.07940020f, -0.14985886f, -0.01245976f, -0.24207850f, 0.11272878f, -0.03671042f, -0.04994026f, 0.07248351f, 
    -0.00362913f, 0.10865787f, -0.00814481f, -0.09055431f, 0.11396661f, -0.08136248f, 0.12390524f, 0.01185122f, 
    -0.15404400f, -0.01070370f, -0.04116302f, 0.15575191f, -0.07861457f, 0.06107576f, 0.00113486f, -0.17973669f, 
    0.06644767f, -0.05886514f, 0.00677183f, -0.04647260f, 0.02813027f, 0.12268614f, 0.11247773f, 0.06428909f, 
    0.13203329f, 0.03615250f, 0.07741160f, 0.06243985f, 0.12737980f, 0.15520026f, 0.28718519f, -0.15065414f, 
    0.04310667f, -0.13162307f, -0.30125386f, -0.16412908f, 0.06585597f, -0.05796267f, -0.04879513f, -0.03037000f, 
    0.01008858f, -0.03967440f, -0.12067477f, -0.01610037f, -0.00087758f, 0.29181993f, -0.01772339f, 0.00785284f, 
    -0.13027683f, -0.18677314f, 0.36385515f, 0.01696695f, -0.13304767f, 0.05835570f, 0.02501124f, -0.13898887f, 
    -0.11316226f, -0.02283213f, 0.00647155f, 0.07932727f, 0.06448745f, 0.12945551f, 0.08759927f, 0.00135008f, 
    -0.04897823f, -0.01502710f, 0.14325058f, -0.06704044f, 0.44496197f, 0.10699285f, -0.05629598f, 0.20003659f, 
    0.06891587f, -0.26083928f, 0.07267900f, 0.03085461f, -0.01659342f, 0.19327492f, 0.05845295f, 0.10913637f, 
    0.10732526f, -0.05156526f, 0.17834036f, 0.13152887f, 0.15492821f, 0.09444747f, 0.08647690f, 0.08886085f, 
    0.19510198f, 0.29523885f, 0.06217153f, 0.05723825f, 0.40559652f, 0.24840891f, -0.07421383f, 0.01681305f, 
    0.31564680f, 0.14970510f, 0.07789369f, 0.10709253f, 0.17403395f, -0.00101068f, 0.11071778f, -0.00569539f, 
    0.02318641f, -0.00340813f, 0.06395971f, 0.01188663f, 0.33387992f, 0.18156792f, -0.05184520f, 0.28461802f, 
    0.04844039f, -0.01827004f, -0.00826718f, -0.04886828f, -0.01617097f, -0.07426389f, 0.02217576f, 0.04613135f, 
    0.14465295f, -0.05142397f, 0.00314191f, 0.29749191f, 0.15133263f, -0.01862614f, 0.07245845f, 0.10537481f, 
    -0.00482074f, -0.26856276f, -0.26600745f, -0.24616082f, -0.12523505f, -0.08547425f, 0.06590852f, 0.03663442f, 
    0.15056118f, 0.14090481f, 0.10031942f, 0.13407740f, 0.05530246f, -0.06210274f, 0.03326852f, -0.01291260f, 
    -0.04318174f, -0.05361320f, 0.04940576f, -0.08474575f, -0.09142593f, -0.08495032f, -0.02086983f, -0.00969834f, 
    -0.03570681f, 0.01121152f, -0.09313724f, -0.14298445f, -0.08564268f, -0.10116366f, 0.03599133f, 0.08650968f, 
    -0.02082958f, -0.03656432f, -0.04356698f, -0.13302070f, 0.07075556f, -0.02445452f, 0.08957813f, 0.02680114f, 
    0.02651954f, 0.15559728f, 0.28072363f, 0.18452282f, 0.06470903f, 0.11545484f, 0.08301855f, 0.12238867f, 
    0.16759968f, 0.05854939f, 0.05011032f, -0.01128828f, 0.01749597f, -0.15982094f, -0.01226685f, 0.04920559f, 
    -0.03955954f, -0.21970637f, 0.13147494f, -0.07050025f, -0.14234921f, -0.32686836f, 0.10068263f, -0.11588301f, 
    -0.12389246f, 0.05109166f, -0.25020882f, -0.29712385f, -0.25362468f, -0.26623967f, -0.18035847f, -0.12614283f, 
    -0.03808224f, 0.23748301f, -0.03298514f, -0.02357203f, -0.04426026f, -0.06760278f, 0.04832445f, 0.28695703f, 
    0.39399478f, 0.12255142f, 0.37458837f, 0.26480210f, 0.08601559f, -0.05366686f, -0.07495329f, -0.04239987f, 
    -0.08490828f, -0.01834061f, -0.02959865f, 0.02655501f, 0.01912830f, -0.01045934f, -0.03275863f, 0.13693336f, 
    -0.14279182f, -0.06157833f, -0.00999893f, -0.02620145f, 0.62350136f, 0.32793102f, 0.22805792f, 0.37825915f, 
    -0.05158345f, -0.13037072f, -0.12705724f, -0.11630547f, -0.11177760f, -0.05157446f, -0.09365159f, 0.01625634f, 
    0.00483068f, 0.12559585f, 0.02408052f, 0.08747970f, -0.03977945f, 0.06873117f, -0.01135961f, -0.08267818f, 
    0.09935324f, 0.14282727f, 0.07004081f, 0.09478273f, 0.12652336f, -0.05378681f, -0.07402870f, -0.07622051f, 
    -0.00126180f, -0.07375360f, 0.01877788f, -0.06394809f, -0.06100142f, -0.03064123f, 0.02532586f, -0.00801270f, 
    -0.06299521f, -0.13001165f, 0.06055215f, -0.24417686f, -0.22847766f, -0.32213360f, -0.18894248f, -0.06403795f, 
    -0.16178612f, -0.01851049f, 0.08605954f, 0.06582788f, 0.08301905f, -0.08962616f, -0.04683540f, 0.08048449f, 
    -0.08469602f, -0.09130532f, -0.08584125f, -0.00402339f, -0.01432780f, -0.08520220f, -0.01175026f, 0.00979087f, 
    -0.05585914f, -0.19761029f, -0.11594798f, 0.27875084f, -0.09247874f, 0.15614866f, 0.11044330f, 0.20928091f, 
    0.07790362f, -0.05223632f, -0.04600197f, -0.00467542f, -0.00530597f, -0.01758130f, -0.06281248f, 0.10219223f, 
    0.06765019f, 0.00011801f, 0.27577999f, 0.19305709f, 0.08893330f, 0.17399056f, 0.38965446f, -0.14660218f, 
    -0.03082749f, -0.07080369f, -0.11880738f, -0.14479108f, 0.02771920f, -0.09336503f, 0.02303446f, -0.01084538f, 
    -0.01284800f, 0.05496328f, 0.01616493f, 0.06230401f, -0.04551435f, 0.00588260f, -0.04911219f, -0.11173545f, 
    0.23651640f, 0.13455014f, 0.18815890f, -0.03018752f, -0.07550661f, -0.07484513f, -0.04681512f, -0.07147522f, 
    -0.04212225f, -0.08741853f, 0.04412954f, 0.03269630f, -0.08769344f, 0.02332712f, 0.01045401f, 0.04065494f, 
    -0.08435053f, -0.11286575f, -0.00009430f, -0.10179424f, 0.25146025f, 0.09582271f, 0.17366874f, -0.12463524f, 
    0.30238619f, -0.03560610f, -0.14411366f, 0.01672513f, 0.08115674f, -0.03193668f, -0.04223083f, 0.05379697f, 
    -0.00875357f, -0.02586815f, -0.01352991f, 0.11638427f, 0.04949742f, 0.12383775f, -0.05158935f, 0.13629697f, 
    -0.25915208f, -0.23474514f, -0.35254818f, -0.05178177f, -0.37657866f, 0.05898303f, -0.11666379f, -0.01391782f, 
    -0.29312700f, -0.11668421f, -0.01767602f, -0.01214127f, 0.02377080f, 0.03008439f, 0.00120089f, 0.00466011f, 
    -0.04945046f, -0.05428394f, -0.20908622f, -0.13119246f, 0.11817792f, 0.06297958f, 0.09705002f, 0.07980912f, 
    0.04449891f, -0.04129485f, -0.03495329f, -0.05714034f, -0.04919647f, -0.06276493f, 0.08236048f, 0.07676511f, 
    -0.04004095f, 0.01403798f, -0.00366456f, 0.01224395f, 0.19412737f, -0.04600287f, 0.10613212f, -0.04000651f, 
    0.19351935f, -0.00824388f, 0.15889223f, -0.04003669f, 0.07420400f, 0.10013285f, -0.02015341f, 0.05804542f, 
    0.32154408f, -0.02633922f, 0.06836925f, -0.00584884f, 0.02398643f, -0.05915781f, -0.02350402f, 0.01822879f, 
    -0.18570992f, -0.06848758f, 0.01313538f, -0.14478672f, -0.00204351f, -0.07329963f, 0.00821968f, -0.03006711f, 
    -0.03599317f, -0.07343736f, -0.00691855f, -0.04210030f, -0.06316470f, -0.10666124f, 0.15032417f, 0.12103137f, 
    0.10215475f, 0.01684732f, 0.07564481f, -0.13085775f, -0.03576704f, -0.01002464f, 0.00165517f, -0.00963800f, 
    0.24478397f, 0.03662095f, 0.02207850f, -0.16061470f, 0.14321093f, 0.01510123f, -0.14161441f, -0.01410915f, 
    -0.02053064f, -0.10899353f, -0.09931195f, 0.04391136f, -0.01086951f, 0.15902859f, 0.22190277f, 0.13703389f, 
    -0.02254371f, -0.01519360f, -0.15967871f, -0.01867970f, 0.01076678f, 0.21023642f, 0.26371315f, -0.02413463f, 
    0.13033171f, -0.03266775f, -0.01880542f, -0.04164489f, 0.12857626f, -0.10764472f, 0.10220433f, 0.03744552f, 
    -0.02177355f, 0.04105606f, 0.07462655f, 0.02799339f, 0.11169097f, 0.04365923f, 0.11760728f, -0.03227298f, 
    0.24593274f, 0.13655053f, 0.17094947f, 0.03753963f, 0.31072184f, 0.33403423f, -0.03427235f, 0.04507088f, 
    0.19831932f, 0.11684114f, 0.00904612f, 0.08778265f, 0.09348788f, 0.02870105f, 0.11077331f, 0.08675956f, 
    0.01946748f, -0.03447430f, -0.19736147f, -0.18030749f, -0.05320530f, 0.03101897f, -0.15523396f, 0.03397994f, 
    -0.05957670f, 0.07578058f, -0.06531397f, -0.05910234f, 0.14079665f, -0.08003005f, 0.00189494f, -0.00465909f, 
    0.03456516f, -0.00986669f, 0.15577687f, -0.04724119f, 0.03095814f, 0.16466619f, -0.18782568f, -0.06632284f, 
    -0.04668667f, -0.11935713f, -0.04196014f, -0.03982417f, -0.25433153f, 0.02090372f, 0.06691261f, 0.02031513f, 
    -0.08406133f, 0.05075692f, -0.00665259f, -0.01453466f, 0.04699000f, 0.02253356f, 0.02743166f, -0.10427727f, 
    -0.06264918f, -0.16707493f, -0.11546358f, -0.17617466f, -0.20215194f, -0.30633780f, -0.24539357f, -0.14962491f, 
    0.03446431f, -0.04324731f, 0.07817560f, 0.16631314f, 0.13828833f, 0.11280132f, -0.06857882f, 0.01842901f, 
    0.17820217f, 0.03092854f, 0.04496839f, -0.05185564f, 0.03803103f, 0.07861124f, -0.03353747f, 0.13977802f, 
    -0.21980412f, -0.41897935f, 0.13035408f, -0.30975986f, -0.28508049f, 0.04807853f, 0.01798837f, -0.18063352f, 
    0.04016369f, 0.03332300f, -0.10942837f, -0.01115374f, 0.01701677f, 0.06287068f, 0.08366189f, -0.10464281f, 
    0.01147452f, -0.13162374f, -0.04331928f, 0.03120851f, -0.04909127f, 0.24943124f, 0.15615556f, 0.24932684f, 
    0.04438857f, 0.14648987f, 0.11944133f, 0.04506978f, 0.23765586f, -0.02312060f, 0.01690885f, 0.04536752f, 
    -0.05017548f, -0.06739224f, 0.04066475f, -0.05941235f, -0.03085784f, -0.18252860f, 0.12835637f, 0.15068512f, 
    0.27757928f, -0.01700728f, -0.02498402f, 0.02527112f, -0.21634738f, 0.02778235f, 0.06127504f, 0.07068238f, 
    -0.01775708f, 0.12551403f, 0.08608745f, -0.09351287f, 0.04830617f, 0.10520077f, 0.11358432f, 0.04612862f, 
    0.07383595f, -0.11183610f, 0.12291411f, 0.16081400f, 0.23523457f, -0.21082121f, -0.33564687f, 0.03903122f, 
    0.15404709f, 0.17982572f, -0.01360720f, 0.11171449f, -0.00526424f, -0.01567322f, 0.04168114f, -0.05188587f, 
    -0.11184797f, -0.01898430f, -0.13785589f, 0.18700065f, -0.14133939f, 0.08962971f, 0.05783844f, -0.10139047f, 
    0.08975693f, 0.05984805f, -0.03220344f, -0.19870731f, -0.09291364f, 0.09891775f, 0.20162036f, -0.02609473f, 
    0.02106866f, -0.08119426f, 0.07653053f, -0.09338210f, 0.03014162f, 0.02037916f, 0.02697297f, -0.08282735f, 
    -0.05570606f, 0.03738764f, 0.09805354f, 0.14504187f, -0.30639136f, -0.43781304f, -0.31942493f, 0.03469403f, 
    0.15503824f, 0.19940211f, 0.07510310f, 0.00803235f, -0.20100221f, 0.18471923f, -0.02418731f, -0.07009151f, 
    -0.05158446f, 0.01596189f, 0.08127474f, -0.00514015f, -0.03109070f, 0.02952673f, -0.01714905f, -0.18554565f, 
    0.26089692f, 0.37490678f, -0.28657231f, 0.15786155f, 0.41860268f, -0.18322307f, -0.28644878f, -0.08368348f, 
    0.15051110f, 0.28348377f, 0.10016140f, 0.03916962f, 0.07310317f, 0.03771508f, 0.12862083f, -0.16477829f, 
    0.11710142f, 0.12940586f, 0.07221418f, -0.05721135f, 0.10038751f, -0.17756814f, -0.03254824f, -0.16188948f, 
    0.17897370f, 0.09708620f, -0.13160668f, -0.07732236f, 0.04270182f, 0.23076035f, 0.14257170f, 0.12059611f, 
    0.00544238f, 0.02415466f, 0.08465680f, 0.03056568f, 0.03687828f, -0.09244405f, -0.12448967f, 0.19143434f, 
    0.04651532f, 0.05098756f, 0.04080907f, -0.15286651f, -0.13324048f, 0.03615814f, 0.21672848f, -0.11165009f, 
    0.10330600f, -0.04754282f, 0.19614907f, 0.00410822f, 0.02189261f, 0.07541696f, 0.00605227f, 0.15218924f, 
    0.11427204f, 0.13028602f, 0.11630182f, 0.12090304f, -0.13206366f, 0.20325051f, -0.05272005f, -0.16225401f, 
    0.16580674f, 0.04167109f, -0.02239520f, -0.07256475f, 0.04055316f, 0.08010742f, 0.08283814f, 0.13570350f, 
    0.00624486f, 0.01319410f, 0.17447776f, -0.12663710f, -0.07770807f, 0.04829904f, 0.09504522f, 0.07933453f, 
    -0.41908476f, 0.17552145f, 0.49789014f, 0.18817036f, 0.30149454f, -0.01252815f, -0.09872951f, -0.02529437f, 
    -0.01248767f, 0.10147902f, -0.08176406f, -0.07319406f, 0.03825418f, 0.11032049f, 0.06848055f, -0.15736535f, 
    -0.06588019f, 0.00428982f, -0.16296886f, 0.01650279f, 0.20042135f, -0.09913279f, -0.17814827f, -0.26849133f, 
    0.41744715f, -0.22843486f, 0.05181948f, 0.01893051f, -0.15218954f, -0.06421508f, 0.02006161f, -0.16826825f, 
    0.10134166f, 0.00124311f, 0.00560435f, 0.10688879f, -0.22486606f, -0.25656426f, -0.46171981f, -0.21326725f, 
    -0.18945417f, 0.00144690f, 0.09332794f, -0.13172792f, -0.07805042f, 0.00513182f, -0.05701476f, -0.08422180f, 
    -0.09068471f, 0.03695327f, -0.12546545f, 0.05143553f, -0.08614199f, 0.17609878f, 0.07738835f, 0.01330447f, 
    0.00701083f, 0.21059078f, 0.08419859f, 0.07198268f, 0.06583387f, -0.22310270f, -0.28595373f, -0.30892563f, 
    0.25945312f, -0.02639719f, 0.07647981f, -0.03596016f, -0.07144757f, 0.01389946f, 0.02238143f, -0.04116251f, 
    -0.09320857f, -0.21558085f, -0.09922191f, -0.10467552f, -0.04538491f, 0.15929107f, -0.19178614f, -0.25509417f, 
    0.24537160f, 0.01037429f, -0.09497792f, -0.24159117f, 0.15967034f, 0.00550766f, 0.06436851f, -0.20105369f, 
    0.10105749f, -0.04912578f, 0.12159558f, -0.05518117f, -0.07739087f, -0.09299814f, 0.09514804f, 0.01029378f, 
    0.20132230f, -0.10473898f, 0.09524543f, 0.08580717f, -0.44996768f, -0.06794467f, 0.00078665f, -0.43003434f, 
    -0.00064265f, -0.02539899f, 0.10067435f, -0.38772389f, 0.00570993f, -0.04917238f, 0.32762778f, 0.03583520f, 
    0.03019137f, -0.00711543f, 0.22657821f, 0.18862109f, -0.05495013f, 0.00712487f, 0.24812251f, -0.04861535f, 
    -0.35794735f, 0.06134526f, -0.08272967f, -0.29609060f, -0.04171326f, 0.03597945f, -0.01462298f, -0.20794918f, 
    -0.12372272f, 0.06602267f, -0.02290345f, 0.03732117f, 0.13401355f, 0.13748078f, 0.00601278f, 0.16619398f, 
    0.07447181f, 0.18627644f, -0.11366116f, 0.17398995f, -0.49472263f, 0.65055948f, 0.52106452f, -0.23406830f, 
    0.00983650f, -0.04179063f, -0.20479603f, -0.08221000f, 0.07559613f, 0.02863267f, 0.00124831f, 0.00803262f, 
    -0.00110042f, 0.02623458f, -0.00123835f, -0.15800445f, -0.12650388f, -0.05216483f, -0.23477827f, -0.14053087f, 
    -0.09510457f, 0.41012365f, 0.12849180f, -0.16154535f, -0.07615661f, 0.12691903f, 0.06947568f, -0.11921101f, 
    -0.03869899f, -0.00964168f, 0.04752567f, 0.13278443f, -0.03680765f, 0.02456523f, -0.04988520f, 0.04110113f, 
    0.02496167f, 0.11071961f, -0.04533585f, 0.10441516f, -0.07700033f, -0.12498304f, -0.13380426f, 0.09531271f, 
    0.44987741f, 0.03977243f, -0.02047227f, 0.06080598f, 0.05502088f, 0.04114831f, -0.02047767f, -0.09772672f, 
    -0.15399635f, -0.02376641f, -0.00371270f, 0.06180833f, -0.01681047f, 0.07548369f, 0.00883421f, 0.02237877f, 
    -0.37435064f, -0.30610892f, -0.40581000f, 0.13183554f, 0.23606490f, 0.27674067f, -0.25736076f, -0.16224076f, 
    -0.05169112f, 0.10292900f, -0.07719717f, 0.14963187f, -0.08587361f, 0.10112934f, -0.06350391f, -0.06043182f, 
    0.01738564f, 0.20135474f, 0.25153092f, -0.23384613f, -0.39971787f, -0.19207008f, 0.00268896f, 0.25708455f, 
    0.25391996f, 0.22541451f, -0.09500372f, 0.07483743f, -0.06534725f, 0.18080445f, -0.05528283f, -0.07962386f, 
    0.01181819f, 0.06033673f, 0.07054913f, 0.04384102f, -0.06245975f, -0.01494565f, 0.05198070f, -0.14224599f, 
    0.17382963f, 0.13845608f, 0.31184575f, 0.06075047f, 0.06833342f, -0.09341702f, 0.29563394f, -0.01746580f, 
    0.14133385f, 0.03040963f, 0.02381333f, 0.01197945f, -0.01539338f, 0.04402165f, 0.10644237f, -0.04722394f, 
    0.01123820f, 0.09274981f, 0.09608023f, 0.10221013f, 0.01819000f, -0.30115885f, -0.17216910f, -0.08520665f, 
    0.11938196f, 0.06498028f, -0.13931586f, -0.03214283f, -0.16038734f, -0.00825673f, 0.01262341f, 0.06182575f, 
    0.17144263f, 0.07273089f, 0.02364076f, 0.01909966f, -0.20523073f, 0.00971350f, -0.06498929f, 0.01297645f, 
    -0.38489264f, 0.11629643f, 0.26921147f, -0.04957513f, 0.05941947f, 0.03417027f, -0.05644599f, 0.06241713f, 
    -0.11521257f, 0.05143235f, -0.15734038f, 0.07843888f, -0.07404605f, 0.09919965f, 0.06289983f, 0.00432014f, 
    0.04863249f, -0.05588715f, 0.12921360f, 0.13454266f, -0.00451300f, 0.05129761f, -0.22078601f, -0.13386795f, 
    0.34025055f, -0.11423641f, -0.19628389f, -0.06250568f, -0.06130612f, 0.15898664f, -0.03338888f, 0.01453127f, 
    0.03776673f, 0.03551627f, 0.06550149f, 0.10861842f, -0.02078220f, -0.12379262f, -0.37916392f, -0.14001195f, 
    -0.32701746f, 0.10510561f, 0.30552042f, 0.20836772f, 0.01145888f, -0.03139952f, -0.14577127f, -0.13708656f, 
    0.12021531f, 0.09950072f, 0.03270181f, 0.00316019f, -0.04626777f, 0.06250291f, -0.08499771f, -0.14228898f, 
    0.08467347f, 0.01143468f, 0.16719936f, 0.15502141f, -0.13004212f, -0.04970515f, -0.23335010f, -0.07330361f, 
    0.18301181f, -0.02696965f, 0.04630406f, -0.05565136f, 0.00715975f, -0.02848699f, 0.14423814f, 0.08761869f, 
    0.15956822f, -0.01141695f, -0.04796445f, 0.16251478f, 0.00817941f, -0.03716713f, -0.02460913f, -0.00222081f, 
    -0.07960645f, 0.03248212f, 0.15156959f, -0.04953243f, -0.10039143f, -0.06999073f, 0.07110183f, 0.00154105f, 
    0.12368916f, 0.08794335f, 0.00776308f, -0.08205757f, -0.06066359f, -0.02111883f, 0.09035289f, 0.10940441f, 
    0.12622532f, 0.08615100f, 0.20973928f, 0.23727342f, 0.12271849f, -0.01760300f, 0.30650052f, -0.14489147f, 
    -0.14947274f, 0.03247806f, 0.28388777f, 0.06818896f, -0.08526226f, -0.00896179f, 0.03632142f, -0.17439646f, 
    -0.05619221f, 0.03623610f, 0.00510470f, -0.03415813f, -0.04024315f, -0.09869525f, -0.01999426f, 0.09273517f, 
    0.20731725f, 0.04653363f, 0.27154538f, 0.06389312f, 0.06898908f, -0.12179176f, 0.12666076f, -0.04126065f, 
    0.17141126f, 0.05481134f, 0.00158435f, -0.00715764f, -0.03050963f, -0.05477505f, 0.03145563f, -0.02393923f, 
    0.05541695f, 0.09540546f, 0.08811664f, -0.00970997f, -0.03088464f, 0.25232193f, 0.47803405f, -0.06714372f, 
    -0.08067675f, 0.09749228f, -0.02651497f, -0.05309192f, 0.05811122f, -0.06808984f, 0.07211629f, -0.09580214f, 
    -0.08751824f, 0.05113788f, 0.08906143f, 0.02396959f, 0.06942514f, -0.14621140f, -0.06129425f, 0.06370345f, 
    -0.00754300f, 0.16022925f, 0.17768182f, -0.02728888f, 0.14802910f, -0.13774191f, 0.10226291f, 0.12245810f, 
    0.13380760f, 0.01239444f, -0.03127329f, -0.04452591f, -0.06123509f, -0.14169644f, 0.02007162f, 0.00615494f, 
    -0.02364574f, 0.25995764f, -0.04439960f, 0.05161659f, -0.25527230f, -0.06092072f, 0.02866094f, -0.06647649f, 
    -0.18783639f, 0.21370491f, -0.06687275f, -0.03368128f, -0.11597865f, 0.04351763f, -0.03698762f, 0.01186522f, 
    -0.10551395f, 0.08755811f, 0.07281089f, 0.09729508f, -0.00428108f, 0.12809706f, 0.03272601f, 0.17509474f, 
    -0.02445958f, 0.01171506f, 0.02052735f, -0.02260733f, -0.00168790f, -0.04263864f, -0.03543204f, 0.00425251f, 
    -0.01925930f, 0.02579566f, 0.03325199f, -0.01347313f, -0.02447116f, -0.02729787f, -0.03901750f, -0.00783592f, 
    0.01893422f, -0.03338672f, -0.04716967f, -0.00513411f, -0.03238456f, -0.00893338f, -0.03335936f, -0.03143538f, 
    -0.03373536f, -0.00478555f, -0.03271399f, -0.03239067f, 0.02874680f, -0.04331636f, -0.00255932f, 0.01016789f, 
    0.02280647f, -0.00873743f, 0.03461957f, -0.00967801f, -0.04350088f, 0.01422155f, -0.02094021f, -0.00057578f, 
    0.02735012f, -0.00228225f, -0.02809751f, -0.00021329f, -0.02812228f, -0.01842531f, 0.02092468f, 0.02849191f, 
    -0.01469808f, 0.00996575f, -0.02024772f, -0.00998513f, 0.00398499f, 0.00669859f, -0.02642413f, -0.02942356f, 
    -0.03667738f, -0.02412633f, 0.03234934f, 0.00440188f, -0.04136400f, 0.00303560f, -0.01199209f, -0.04088913f, 
    -0.03437924f, -0.02181796f, -0.01870565f, -0.03774559f, 0.03007780f, 0.00462869f, -0.04211821f, -0.02724104f, 
    -0.00759807f, -0.04547583f, 0.00818388f, -0.01543646f, 0.02188570f, 0.01086611f, -0.03433439f, -0.03362218f, 
    -0.01443230f, -0.02204937f, -0.02791219f, -0.00473801f, -0.01067634f, 0.02399140f, -0.01832964f, 0.00624045f, 
    -0.02061191f, -0.04401400f, 0.00214027f, -0.03073180f, -0.02129336f, -0.01776714f, 0.01969810f, -0.04339385f, 
    0.02614323f, -0.03701718f, 0.00777686f, -0.04245666f, 0.01557154f, -0.02790814f, -0.03267685f, -0.04951997f, 
    -0.00784685f, 0.03211552f, 0.02727436f, 0.03370911f, -0.00797958f, 0.01224609f, 0.00187879f, 0.02071858f, 
    0.01041461f, -0.03303766f, 0.02928548f, 0.01979801f, -0.03187067f, 0.03977766f, -0.00923040f, -0.00412697f, 
    -0.01058243f, -0.01355311f, -0.01133654f, 0.01738978f, 0.02229501f, -0.04028109f, -0.02559568f, 0.02792713f, 
    -0.02124828f, 0.01977392f, 0.01636555f, -0.02147436f, -0.00379970f, -0.01583751f, 0.02260198f, 0.02052430f, 
    0.00523326f, -0.04144131f, 0.02099004f, -0.00941960f, 0.03114732f, 0.00168526f, -0.01236027f, -0.04153940f, 
    0.00498993f, 0.00235099f, 0.00151420f, -0.01484580f, -0.03134970f, -0.01980029f, 0.02286469f, -0.04278755f, 
    0.03194222f, -0.00508270f, 0.01448007f, -0.00460080f, 0.01932958f, 0.01971057f, 0.01669262f, 0.00348532f, 
    -0.02146246f, -0.01975142f, 0.01183344f, 0.00174138f, 0.03449110f, -0.00989691f, -0.03127484f, -0.04401373f, 
    -0.01616097f, 0.00454408f, -0.01486085f, 0.00623291f, -0.00650447f, 0.02672064f, -0.02730994f, 0.03110774f, 
    -0.01996840f, -0.04315601f, -0.00608434f, -0.04269645f, 0.00783953f, 0.02794417f, 0.00213236f, 0.03165167f, 
    0.03179447f, -0.02763922f, 0.00614299f, 0.01950759f, -0.02312341f, -0.02242799f, 0.02439404f, -0.02572434f, 
    -0.03774480f, 0.01024887f, -0.02672808f, -0.02291412f, 0.02126758f, 0.01480875f, -0.02789981f, -0.03365135f, 
    0.00756049f, -0.03000169f, 0.01081002f, -0.03204831f, 0.01613958f, 0.00713344f, 0.02184851f, 0.02961797f, 
    -0.02247733f, 0.00464570f, -0.01373347f, -0.00228869f, -0.04226445f, 0.00422651f, -0.02951892f, 0.00898624f, 
    -0.00832784f, 0.00650092f, -0.02222832f, -0.00973834f, -0.03634975f, 0.00369572f, 0.01789780f, -0.03383092f, 
    -0.03448350f, 0.01871317f, 0.02597357f, 0.01580641f, 0.02463304f, 0.01667276f, -0.04193226f, -0.00174954f, 
    -0.02944715f, -0.03675945f, -0.01470715f, -0.00854760f, -0.02603081f, -0.00459548f, -0.03051145f, -0.01980724f, 
    -0.04090132f, 0.01864215f, -0.03337562f, -0.04370326f, 0.00209439f, 0.02867642f, -0.00848983f, 0.00814762f, 
    0.01493474f, -0.01287153f, -0.02511599f, -0.02061606f, -0.02729262f, -0.03925076f, -0.00537074f, 0.02549523f, 
    -0.03657360f, 0.01103655f, 0.03415562f, -0.02396282f, 0.00454381f, -0.02143544f, -0.00414256f, -0.01571670f, 
    0.01316144f, -0.01806741f, 0.02747684f, 0.03149890f, -0.02538243f, -0.03392602f, -0.01626786f, 0.00611237f, 
    -0.03552466f, 0.00174489f, 0.00340130f, -0.02352132f, -0.01306711f, 0.02644527f, -0.03187580f, 0.02719294f, 
    0.00422123f, -0.02539712f, -0.03947731f, -0.03459204f, 0.00137324f, -0.02345649f, -0.00708444f, -0.03838287f, 
    0.03633351f, -0.00963157f, 0.00697723f, 0.02031044f, 0.00935766f, -0.00061686f, 0.03304918f, -0.02674870f, 
    0.01925746f, -0.00043218f, 0.03172370f, 0.03177652f, -0.03191986f, -0.01352795f, 0.02732109f, 0.02625675f, 
    0.00133465f, 0.02066600f, 0.01490746f, -0.00967239f, 0.00425170f, -0.03811387f, -0.01764216f, -0.03225034f, 
    0.02113995f, -0.00886295f, -0.04332096f, 0.03972175f, -0.04031543f, -0.00465658f, -0.02020800f, -0.00723446f, 
    -0.02362683f, 0.01061830f, 0.02879822f, -0.03113013f, 0.02182380f, -0.03936200f, -0.00331561f, 0.01229460f, 
    -0.01021376f, -0.00344821f, 0.01979001f, -0.01624669f, -0.03109370f, -0.01898542f, -0.01448517f, -0.04020005f, 
    -0.02682820f, -0.02477865f, -0.02768920f, -0.00399612f, 0.03394474f, -0.00294372f, 0.01074729f, -0.03222970f, 
    0.00890857f, 0.01334116f, 0.03080668f, 0.03558053f, -0.01632380f, -0.02180522f, 0.03344076f, 0.01236694f, 
    -0.04195295f, 0.01541657f, -0.04047641f, -0.00625895f, 0.01247144f, -0.00211237f, -0.02356974f, -0.01439302f, 
    0.01217089f, 0.00045724f, 0.03836131f, -0.02071099f, 0.01404339f, 0.04359761f, -0.03258906f, -0.01180178f, 
    0.01599387f, -0.01582054f, 0.03521784f, -0.02424960f, 0.02910697f, -0.01174249f, -0.01427994f, 0.02875663f, 
    0.00528349f, -0.00190682f, -0.01552457f, 0.03664437f, -0.01172538f, 0.03181157f, -0.02719758f, -0.03573493f, 
    -0.03541180f, 0.01238232f, -0.03695508f, -0.00515273f, 0.01040757f, 0.02330614f, 0.01096699f, -0.03703171f, 
    0.00216060f, -0.02445405f, -0.02880300f, -0.02023067f, -0.01121125f, 0.01265457f, -0.02562238f, 0.00623804f, 
    -0.01505873f, 0.02975349f, 0.00260931f, -0.00601978f, -0.01052222f, -0.04408242f, -0.04790634f, -0.03523286f, 
    -0.00293592f, 0.00593535f, -0.03719253f, -0.03219030f, 0.01304323f, -0.03460300f, -0.02517763f, -0.01390041f, 
    0.00931800f, -0.03501335f, -0.00429818f, -0.04163286f, -0.04030284f, 0.00563433f, -0.03592464f, -0.01908310f, 
    -0.02063428f, -0.00962019f, 0.00919074f, 0.02202016f, -0.01343638f, 0.01335558f, 0.03503499f, -0.00013345f, 
    -0.04335500f, -0.03268173f, 0.02372596f, -0.01682677f, 0.01091105f, 0.02040902f, 0.01501012f, 0.01743417f, 
    0.02395051f, -0.02573882f, 0.02237899f, -0.04275347f, -0.03601458f, -0.00348429f, -0.01489216f, -0.01331866f, 
    -0.02492547f, -0.02425732f, -0.04254122f, -0.01500262f, 0.00147696f, 0.02688427f, -0.01528241f, 0.03235781f, 
    -0.03384255f, -0.04081715f, 0.02640128f, -0.00395690f, -0.00301485f, -0.02532834f, 0.03920496f, 0.03966867f, 
    -0.00367079f, 0.00527502f, -0.00580055f, 0.03434409f, 0.00073796f, 0.01126261f, -0.02888438f, 0.02307010f, 
    0.01610156f, 0.00843689f, -0.04238911f, 0.01810438f, 0.01236185f, -0.00866484f, -0.00389011f, -0.03796463f, 
    0.00403549f, 0.00278615f, 0.01273853f, -0.02454806f, -0.01446340f, -0.02061909f, -0.01707568f, 0.03485639f, 
    -0.03124585f, 0.03266616f, 0.02855396f, 0.00407744f, -0.03234801f, -0.00833157f, 0.02783177f, -0.00094383f, 
    -0.02968845f, -0.03458205f, -0.02769826f, 0.00112431f, -0.00111705f, -0.00076551f, -0.01199103f, -0.00673671f, 
    -0.02090863f, 0.01137852f, -0.04225492f, -0.02882393f, -0.03671964f, -0.01095953f, 0.01276937f, 0.00169586f, 
    0.00707454f, 0.00894647f, 0.03166230f, 0.01021461f, 0.01540087f, -0.02814335f, 0.02425203f, 0.01225577f, 
    -0.00279610f, -0.01594027f, -0.02945060f, -0.00102033f, -0.01554336f, -0.00083723f, 0.01749593f, -0.00517114f, 
    -0.02116474f, 0.03331345f, 0.02580781f, 0.03160240f, -0.00078722f, 0.02648497f, 0.01182187f, -0.01308323f, 
    -0.03844382f, 0.00076660f, 0.01570741f, -0.01013601f, -0.01986534f, -0.01035304f, -0.03933948f, 0.01785028f, 
    -0.04169143f, 0.02688252f, -0.01681885f, 0.00835982f, -0.02485082f, 0.02622046f, 0.02203726f, 0.01945879f, 
    0.03388317f, -0.03794990f, 0.01113208f, -0.02988447f, -0.02322332f, -0.01204153f, 0.00537037f, -0.01001809f, 
    -0.04017563f, -0.02377193f, 0.02989128f, -0.02228379f, -0.01411698f, 0.01310329f, -0.02114850f, 0.00012979f, 
    -0.00369691f, -0.00615722f, -0.01967995f, 0.00138927f, 0.02719117f, 0.02185639f, -0.00726757f, 0.03111484f, 
    0.02944863f, -0.02943910f, 0.00817104f, 0.01568930f, -0.00843299f, -0.02064961f, 0.02155456f, 0.01514698f, 
    -0.00440094f, -0.02801380f, -0.01210292f, 0.00735704f, -0.04125746f, -0.02478916f, -0.01758611f, -0.00269785f, 
    0.02753755f, -0.01917396f, -0.00990655f, 0.01436528f, -0.03864146f, -0.02744775f, 0.00887459f, -0.01457439f, 
    0.00112727f, 0.00839987f, 0.02530301f, 0.01320881f, 0.02852177f, 0.02794010f, -0.01916548f, 0.01824612f, 
    -0.04748753f, 0.01550518f, -0.04402957f, -0.03964858f, 0.02892713f, -0.02079047f, -0.04124447f, 0.01620492f, 
    0.01623786f, 0.02261312f, 0.00478550f, -0.01224829f, 0.01830954f, 0.00229900f, 0.02721930f, -0.02673536f, 
    -0.03933431f, -0.03073045f, -0.04034093f, -0.03879784f, -0.03614504f, 0.00922816f, 0.00733739f, -0.00960013f, 
    0.02721959f, -0.00278624f, -0.03269206f, 0.01395901f, -0.01730827f, 0.02531483f, -0.00648288f, -0.02189768f, 
    0.34611630f, -0.03762906f, 0.14763345f, 0.08108450f, 0.08121298f, 0.02452867f, 0.07025009f, -0.06957052f, 
    -0.10943714f, 0.14728223f, -0.02899316f, -0.03337367f, -0.06459943f, 0.07286709f, -0.06303591f, 0.12664767f, 
    0.14916246f, -0.04889289f, -0.11495549f, -0.16493082f, -0.30720422f, 0.18414389f, -0.02870237f, 0.08888724f, 
    0.05379019f, 0.10077655f, 0.00914235f, 0.01618534f, 0.01920983f, 0.02105921f, 0.08570459f, 0.04602358f, 
    0.03488973f, -0.00067517f, -0.02451785f, 0.04264558f, -0.19437049f, 0.10066089f, -0.13054545f, -0.12720257f, 
    0.26328564f, 0.23764706f, 0.38400781f, 0.02561867f, 0.18003538f, 0.05561413f, 0.22260700f, -0.07016318f, 
    0.09103242f, 0.06599604f, 0.01871606f, 0.01605651f, 0.13569692f, -0.03894960f, -0.06758711f, -0.04892240f, 
    -0.00827825f, -0.04924579f, 0.20601733f, 0.07289029f, -0.28770185f, 0.11859743f, 0.18156701f, 0.22745492f, 
    -0.04762462f, 0.17554528f, -0.15585490f, -0.06018594f, -0.09591299f, 0.02846955f, 0.03201308f, 0.09640753f, 
    0.00381223f, -0.01100092f, 0.07424891f, -0.31023797f, 0.02173238f, -0.01263380f, -0.16192700f, 0.06826572f, 
    0.75461245f, 0.52466047f, -0.30287936f, -0.06179990f, -0.19320384f, 0.00995944f, -0.03423052f, -0.16654029f, 
    0.23826209f, 0.05016281f, 0.03331100f, -0.14615238f, 0.00026030f, 0.04552817f, -0.03021030f, 0.16700102f, 
    -0.19781402f, 0.02027738f, -0.16638368f, -0.04688522f, 0.22076699f, -0.30092797f, -0.13102201f, 0.05669647f, 
    -0.12308709f, 0.16340241f, -0.11138456f, -0.04826218f, 0.18911560f, -0.00949297f, 0.04651234f, 0.02758715f, 
    -0.14101057f, -0.14476097f, 0.10563883f, 0.11116252f, -0.23920436f, -0.05619400f, -0.11840218f, 0.24191184f, 
    0.40020707f, 0.10914645f, 0.13205385f, -0.31729332f, -0.08571821f, 0.02842386f, -0.14186545f, -0.18611214f, 
    -0.01753859f, -0.02133313f, -0.00902664f, -0.05700491f, -0.18335463f, 0.06363566f, -0.08207141f, 0.06826023f, 
    0.09976143f, 0.03258548f, 0.14244348f, 0.12174764f, -0.18021327f, -0.18519309f, -0.08156581f, -0.07428068f, 
    0.03395913f, -0.02404821f, -0.00116287f, -0.03949251f, -0.11124265f, 0.16443807f, 0.10616525f, -0.06795282f, 
    -0.06196642f, 0.05461059f, 0.21852365f, -0.17990571f, -0.19724844f, 0.00862320f, 0.00259058f, 0.10832436f, 
    0.07996708f, -0.10331984f, -0.30815384f, -0.09146915f, 0.11166383f, 0.10775285f, 0.09714875f, 0.13554089f, 
    0.13594307f, -0.02586510f, 0.18234102f, -0.03651760f, -0.06407768f, -0.00563879f, 0.10266002f, -0.02904152f, 
    0.01464179f, 0.08407403f, -0.01992737f, -0.01257374f, -0.08739556f, -0.02929945f, -0.01048703f, 0.11465542f, 
    0.07348625f, 0.00341047f, 0.07296226f, -0.04972982f, -0.08784080f, 0.07543895f, 0.16040717f, 0.02382410f, 
    0.03291532f, -0.07338051f, 0.08193943f, 0.17327157f, 0.01399356f, -0.01288684f, -0.14190187f, 0.00198275f, 
    -0.03633760f, -0.09508563f, -0.03615250f, -0.17745748f, 0.10526863f, -0.11409080f, -0.03911390f, -0.03172622f, 
    0.03212915f, 0.11855941f, -0.12524939f, -0.00000315f, -0.14240576f, 0.16046168f, 0.10210709f, -0.28905603f, 
    -0.19085054f, 0.02813420f, 0.05614592f, -0.09664112f, -0.09635541f, 0.14503349f, 0.07683074f, 0.25944033f, 
    0.13581747f, -0.07009353f, -0.00640653f, -0.07475188f, -0.07133595f, 0.04353782f, 0.10515864f, 0.07024395f, 
    -0.00019108f, -0.07985963f, 0.01966191f, -0.07877694f, 0.06582864f, 0.12677042f, -0.11251258f, -0.04738725f, 
    -0.45421773f, 0.22183438f, 0.14097258f, 0.23704763f, 0.10067721f, 0.08908807f, 0.12742417f, -0.07163409f, 
    0.04430651f, 0.09843400f, 0.16832323f, -0.06322937f, 0.05130067f, 0.02480409f, 0.06594136f, -0.17819034f, 
    -0.09034278f, -0.06105555f, -0.18105978f, -0.18336995f, -0.80292457f, 0.01374465f, 0.15071066f, -0.06193072f, 
    0.05514421f, 0.10187068f, 0.02038028f, -0.01210871f, -0.05225445f, 0.07925820f, 0.21396235f, -0.01392329f, 
    0.08407889f, 0.07620887f, 0.04129408f, -0.06614200f, 0.12099917f, -0.17708574f, -0.17558357f, -0.06532814f, 
    0.08049198f, 0.19130953f, 0.16033059f, -0.28292206f, 0.02014942f, 0.02418643f, 0.00913094f, -0.02975171f, 
    0.08522388f, -0.00761868f, 0.05366505f, 0.11453058f, 0.02646958f, 0.12751445f, -0.06273493f, -0.06497117f, 
    0.08570338f, -0.00079475f, -0.04343601f, 0.03289256f, 0.32551670f, 0.03740897f, -0.10882896f, -0.06221466f, 
    0.05790399f, 0.06734222f, 0.03392016f, 0.08445618f, 0.03755503f, 0.12019677f, 0.24872956f, -0.04739882f, 
    -0.04526895f, -0.05173509f, 0.05336806f, 0.02463330f, 0.12952991f, 0.09166081f, 0.06147377f, 0.00184074f, 
    0.21862200f, -0.10488097f, 0.05852369f, -0.09635019f, 0.34988269f, 0.14637558f, 0.14529236f, -0.15574387f, 
    -0.03274235f, 0.22186382f, 0.00319921f, 0.10001422f, -0.04427017f, 0.03738618f, -0.00139901f, 0.03028161f, 
    0.01131793f, 0.01646730f, 0.07386762f, -0.01569921f, -0.28304109f, 0.27570710f, 0.02391280f, 0.22900072f, 
    0.16462152f, 0.11185595f, 0.00926552f, -0.05690559f, 0.09127256f, 0.03949966f, 0.03195504f, -0.00054044f, 
    0.03392667f, -0.02008955f, -0.00949524f, 0.02529863f, -0.05787006f, -0.07881850f, -0.10409956f, -0.02926522f, 
    0.07315734f, 0.13571000f, -0.00408513f, -0.01264362f, -0.08221179f, 0.13543524f, 0.05918339f, -0.11182877f, 
    0.02702817f, 0.02982865f, 0.00507903f, 0.14055805f, 0.04136188f, 0.11489642f, 0.01990427f, 0.04034811f, 
    0.02380794f, 0.08213532f, -0.01800435f, -0.01315061f, 0.02564285f, 0.20614278f, 0.02418667f, 0.10907024f, 
    -0.21754448f, 0.21718462f, -0.07127207f, -0.09242564f, 0.09107020f, -0.04473430f, 0.07433908f, 0.02742532f, 
    0.01199537f, 0.08440602f, -0.06275520f, -0.07143216f, -0.14332496f, -0.04829139f, -0.22898979f, -0.00247351f, 
    0.23369958f, 0.08148459f, 0.40264434f, 0.37555653f, 0.19205591f, 0.02643898f, 0.32529628f, 0.08799696f, 
    0.19273967f, 0.02677361f, 0.03278754f, -0.03763668f, -0.02683278f, 0.03977012f, -0.01503532f, -0.04848309f, 
    0.08006135f, -0.15596268f, 0.08192386f, 0.14121896f, -0.11001857f, 0.05785871f, -0.03808079f, 0.04502072f, 
    -0.08675856f, 0.02282733f, -0.02269575f, 0.02472149f, 0.04237651f, 0.03021488f, 0.00822757f, 0.00438134f, 
    0.04946272f, 0.01129162f, 0.11924432f, 0.06865949f, -0.01794115f, 0.06791835f, -0.01057323f, 0.03454338f, 
    -0.13315338f, -0.10141502f, -0.21224076f, -0.27606407f, 0.34533802f, -0.06853881f, 0.13493049f, 0.35287145f, 
    -0.02399454f, 0.06255848f, -0.08934241f, 0.04884145f, -0.07813349f, 0.00125778f, 0.13666366f, -0.14885524f, 
    -0.02280392f, 0.04231981f, 0.00216820f, -0.09236638f, -0.07367943f, -0.02079196f, -0.09533275f, 0.10074556f, 
    0.01401421f, 0.04137075f, 0.04692707f, 0.02934988f, -0.03744765f, 0.10803422f, -0.05655205f, -0.07997860f, 
    -0.03468864f, 0.15396583f, 0.09940582f, 0.11727133f, 0.14095868f, 0.03269852f, -0.05745251f, 0.00007451f, 
    0.64751703f, 0.21247073f, -0.22180738f, -0.39376286f, -0.40460804f, 0.02053031f, -0.14702931f, 0.04053957f, 
    0.04278480f, -0.14901361f, -0.01344606f, -0.08553657f, 0.09209861f, 0.11994226f, -0.14816687f, -0.17292871f, 
    0.00999280f, 0.00959330f, -0.07405905f, 0.22412294f, -0.08869941f, 0.02287471f, -0.03617205f, -0.09198089f, 
    0.03876851f, 0.09095316f, -0.10808148f, -0.05091888f, 0.07056237f, -0.05471788f, 0.02263642f, 0.02444956f, 
    0.05085880f, 0.00510129f, -0.09663381f, -0.02358621f, -0.02262203f, 0.00391010f, -0.00443492f, -0.01649840f, 
    0.37438709f, 0.20852472f, 0.11342849f, 0.00851416f, -0.26171061f, -0.07701655f, 0.00750509f, -0.06852995f, 
    0.12523745f, -0.07685550f, -0.08746205f, -0.04266566f, -0.04376965f, 0.05305644f, -0.05619464f, 0.30992797f, 
    0.05986353f, 0.03448538f, 0.10410796f, 0.17860183f, 0.07557227f, -0.08927240f, 0.26891536f, 0.04681874f, 
    -0.07739360f, -0.07141835f, 0.19135462f, -0.00530370f, 0.04667754f, -0.04056626f, -0.07606957f, -0.03738772f, 
    -0.09418797f, 0.11538049f, -0.03456550f, 0.00383161f, 0.06005605f, -0.08177271f, -0.07547590f, -0.07223179f, 
    0.20745596f, 0.09747469f, 0.39009082f, 0.32225546f, 0.23629972f, -0.02974141f, 0.27885288f, 0.02611349f, 
    0.17036273f, 0.13940252f, 0.05242754f, -0.09361152f, -0.03704237f, 0.01331085f, -0.06553003f, 0.15652135f, 
    0.14810298f, -0.01142743f, 0.07494516f, 0.10360247f, 0.45708740f, 0.11043139f, -0.09237999f, -0.13045314f, 
    -0.07214761f, 0.11625372f, 0.11254277f, 0.00935645f, -0.02809002f, -0.02812311f, 0.13135564f, 0.00175619f, 
    -0.17388277f, -0.02418730f, 0.02724994f, -0.03898928f, 0.07135738f, 0.03465373f, -0.00963881f, -0.00988114f, 
    0.36567825f, 0.18405019f, 0.48148048f, 0.40520176f, 0.08751574f, -0.08179884f, 0.26131961f, 0.06173352f, 
    0.12948541f, -0.03470675f, 0.02898994f, -0.02452995f, -0.00800032f, -0.04069255f, 0.00054449f, 0.05381656f, 
    0.08449809f, 0.08914565f, -0.02180895f, 0.00988074f, 0.04303680f, -0.21534145f, 0.14634724f, -0.23960839f, 
    -0.05927934f, 0.11470930f, 0.00850254f, 0.02741657f, 0.05282587f, -0.06289661f, -0.04713627f, -0.04190184f, 
    -0.03226482f, 0.05861731f, 0.07557482f, -0.02410358f, -0.04075137f, -0.09656180f, 0.22104065f, 0.06797575f, 
    0.25481337f, 0.07362519f, 0.07395869f, 0.02508758f, -0.03094710f, 0.12243038f, -0.14603360f, -0.11533746f, 
    0.07451352f, 0.08725761f, -0.02045154f, 0.01463160f, 0.09817742f, 0.03881297f, 0.06779582f, -0.01708895f, 
    -0.11574149f, -0.12259606f, -0.00032052f, 0.07900573f, 0.30305052f, -0.04550802f, -0.33920142f, -0.00062321f, 
    0.16196749f, 0.05265310f, 0.11231489f, 0.07749460f, 0.06686237f, 0.02898615f, 0.05547830f, -0.00868563f, 
    -0.03487004f, -0.01421038f, -0.04035386f, 0.11747102f, -0.00649944f, 0.03373143f, 0.02735206f, -0.10868909f, 
    0.20780222f, 0.28097671f, 0.26528367f, -0.00665800f, 0.03262109f, -0.14456788f, -0.11089590f, 0.04423948f, 
    0.00657746f, 0.14275238f, -0.05825914f, 0.04892943f, -0.05303733f, 0.06205559f, -0.02348751f, -0.01851611f, 
    -0.04237908f, -0.07609191f, 0.11591650f, 0.09603719f, -0.06372517f, 0.14345451f, -0.05640032f, 0.20386596f, 
    -0.10750633f, 0.16831888f, 0.01970806f, 0.03131107f, 0.08171665f, 0.07507433f, -0.07344127f, -0.10767557f, 
    -0.08176082f, 0.01491337f, -0.04067927f, 0.18207192f, -0.01327349f, 0.03658951f, -0.01178637f, -0.00074407f, 
    -0.70702779f, 0.04293672f, -0.18102007f, 0.19750790f, 0.08700947f, 0.12352751f, -0.11844324f, -0.12108923f, 
    -0.12308151f, 0.00803715f, -0.00698014f, 0.13060239f, -0.07359169f, 0.03096543f, -0.13048467f, -0.01479818f, 
    0.04873114f, 0.04815212f, 0.02570404f, 0.08325426f, 0.00884181f, -0.15265363f, 0.24492820f, 0.03411592f, 
    -0.04624744f, 0.17074603f, 0.00245344f, 0.02497165f, 0.05458223f, -0.09372540f, 0.02382501f, 0.07860060f, 
    0.01551465f, 0.00691800f, 0.15955311f, 0.04932362f, 0.05663096f, -0.04012992f, -0.19949131f, 0.23801500f, 
    -0.20329136f, -0.34831396f, -0.15210751f, 0.06110589f, -0.33091450f, 0.03085879f, -0.02194162f, 0.24523115f, 
    -0.08977772f, 0.13949299f, 0.03536300f, -0.09042875f, -0.00624375f, 0.12296369f, -0.00069280f, 0.14391546f, 
    -0.00860363f, 0.08449361f, 0.01265975f, -0.04412419f, 0.19313346f, -0.01680709f, 0.10062871f, 0.00329489f, 
    -0.02318289f, -0.04202776f, 0.05433894f, -0.01368462f, -0.00093425f, 0.11183834f, 0.10669544f, 0.01966967f, 
    -0.02215604f, -0.01801807f, 0.03531440f, 0.09020466f, -0.01150653f, 0.07778552f, 0.14793806f, 0.05267324f, 
    -0.07521381f, -0.15404211f, -0.22065780f, 0.24740599f, -0.41141510f, 0.10957012f, 0.03049180f, -0.04801180f, 
    -0.04786961f, -0.04197164f, 0.14357844f, -0.01305744f, -0.03610760f, 0.00874251f, -0.07192660f, -0.02373839f, 
    -0.05988976f, 0.07898493f, -0.11565203f, -0.00012491f, 0.16324235f, 0.04440036f, 0.09729748f, -0.01871640f, 
    -0.04150286f, -0.06704990f, 0.11072683f, -0.02724191f, -0.04555575f, -0.04996201f, 0.09071373f, 0.06547096f, 
    0.15628633f, 0.11041677f, 0.05444294f, 0.08526578f, -0.00489364f, -0.09925954f, -0.06410056f, -0.07225063f, 
    -0.08116668f, 0.07193995f, 0.16388018f, 0.00873157f, -0.35684809f, -0.04021039f, -0.07158885f, -0.12435375f, 
    -0.09844971f, 0.06778754f, 0.00370874f, -0.05210587f, 0.00754742f, 0.06959375f, 0.05420473f, 0.08476276f, 
    -0.00214403f, -0.07175032f, 0.04276928f, 0.05646742f, -0.07377722f, 0.33694315f, 0.10410425f, 0.07163114f, 
    -0.17217459f, 0.03777147f, -0.02502687f, 0.01106900f, -0.02684160f, 0.21676438f, -0.05604347f, -0.07856499f, 
    0.02526772f, 0.02130469f, 0.04245627f, 0.05311994f, 0.05490775f, -0.05899753f, -0.03989188f, -0.03017823f, 
    0.70725328f, 0.01701230f, -0.25845310f, -0.09076079f, 0.00038905f, -0.05600607f, 0.09863543f, -0.02067853f, 
    0.03446871f, 0.09363383f, -0.03271919f, -0.00735446f, -0.05649126f, -0.06531321f, -0.01802794f, -0.03470475f, 
    0.10147492f, 0.11996481f, 0.16175680f, 0.06468035f, 0.41476756f, -0.05035457f, -0.26498342f, -0.16246045f, 
    0.12112087f, -0.08601528f, -0.07143526f, -0.10064615f, 0.06627892f, -0.05573955f, -0.02542483f, -0.05517271f, 
    -0.10894945f, -0.17516680f, 0.04312672f, 0.06111951f, 0.06368693f, 0.01340236f, 0.15175840f, -0.12215724f, 
    0.11226049f, -0.09274202f, -0.06689200f, -0.01793697f, 0.32107824f, -0.13190660f, -0.02592320f, -0.02099151f, 
    -0.03829360f, -0.13623753f, -0.02250831f, -0.09971950f, -0.07105853f, 0.13948046f, -0.13818897f, 0.05913863f, 
    0.13289911f, 0.07994213f, -0.02053524f, -0.18467379f, 0.05752026f, -0.03749456f, -0.08215948f, 0.06771897f, 
    -0.20939283f, 0.00640631f, -0.03382448f, -0.05691703f, -0.01898978f, -0.02425593f, -0.01558585f, -0.01367809f, 
    0.00503744f, 0.01704474f, -0.08928189f, -0.10099377f, -0.01982648f, 0.03596338f, -0.14182477f, 0.00193250f, 
    0.22945495f, -0.03980801f, 0.54354346f, -0.13075806f, -0.17023098f, 0.00642778f, 0.07424664f, 0.00099626f, 
    0.01423316f, 0.21111722f, 0.05069840f, -0.04823026f, -0.04916054f, -0.04654083f, -0.12737145f, 0.03104752f, 
    0.04408427f, -0.01175429f, 0.09799658f, 0.06297609f, 0.28108084f, 0.13753061f, -0.16420545f, 0.10248884f, 
    0.02598165f, 0.08680013f, 0.01825045f, 0.03852452f, 0.00102049f, 0.07838777f, 0.02346697f, -0.05928915f, 
    -0.02798532f, -0.04657828f, -0.07842174f, -0.03758209f, 0.08115186f, 0.18459067f, 0.11104111f, -0.01700909f, 
    -0.13628761f, 0.07993911f, -0.08495332f, 0.13014033f, 0.22688678f, 0.03309774f, 0.08124163f, -0.07773133f, 
    -0.06311698f, 0.04277971f, 0.04789538f, 0.00461548f, -0.10954627f, 0.07463165f, 0.02154307f, -0.03375837f, 
    0.07194398f, -0.03104762f, -0.05759957f, -0.12158217f, -0.25900960f, -0.00614640f, -0.06032671f, 0.09354138f, 
    0.09131450f, 0.23971255f, 0.04207082f, 0.03184897f, 0.04862304f, 0.11533613f, -0.05028881f, -0.12127180f, 
    -0.00253529f, 0.00132184f, -0.00921154f, 0.13739164f, 0.04416175f, 0.12302626f, -0.01006274f, -0.01169547f, 
    0.28811660f, 0.22286338f, 0.23824185f, 0.12325559f, -0.21233191f, 0.07741630f, -0.14558357f, -0.13943073f, 
    0.11566837f, 0.25569084f, -0.03685769f, 0.04540491f, 0.07512250f, 0.03231577f, 0.03915998f, 0.00015961f, 
    0.04534939f, -0.04859293f, -0.05440077f, -0.03216477f, 0.04327263f, -0.03436880f, -0.17834584f, 0.05879187f, 
    0.16715269f, -0.01144695f, 0.02050869f, -0.05038456f, -0.07806942f, -0.05727377f, 0.11336914f, 0.10116428f, 
    0.05083004f, 0.04624359f, 0.03614970f, 0.07683272f, -0.02769797f, 0.00030460f, -0.11937013f, -0.06183588f, 
    -0.13440765f, -0.05060478f, -0.08409555f, 0.10506027f, -0.43872377f, -0.06604869f, 0.09278240f, -0.03981446f, 
    -0.06155172f, -0.00884399f, 0.11875957f, -0.02102323f, 0.06505790f, 0.09571370f, -0.03199769f, -0.01627578f, 
    -0.08271025f, 0.03096084f, 0.07333472f, 0.00014818f, 0.12989517f, -0.03699541f, 0.07793011f, 0.06393820f, 
    -0.02619583f, -0.06216129f, -0.06802808f, -0.00775941f, -0.08812022f, -0.09595950f, 0.11142749f, 0.14822914f, 
    0.13792576f, 0.00546004f, 0.04108126f, -0.02854373f, 0.04892526f, -0.02209783f, -0.10239115f, -0.03691350f, 
    -0.67968988f, -0.13518079f, -0.09593613f, 0.24665985f, 0.14489496f, 0.03846255f, 0.07355071f, -0.09843448f, 
    0.09440098f, -0.05762374f, 0.07931591f, -0.08561224f, -0.06596398f, -0.06483025f, 0.06587151f, 0.08751784f, 
    0.09534074f, 0.03540148f, -0.00238502f, -0.04279726f, 0.11933748f, 0.05022135f, -0.22029954f, 0.04488425f, 
    0.06980261f, 0.04794990f, 0.03259463f, 0.04099455f, -0.05085967f, 0.02857625f, 0.03573862f, 0.07627908f, 
    -0.03273594f, 0.01738932f, -0.11665582f, 0.16323005f, 0.06328513f, 0.06098004f, -0.04143236f, -0.04102352f, 
    -0.67975742f, -0.43865180f, 0.07205879f, -0.05743492f, -0.47812623f, 0.03687723f, 0.01293097f, 0.20819113f, 
    0.15373583f, -0.00420137f, -0.03954176f, 0.00751166f, 0.01489518f, -0.01765106f, 0.07021605f, -0.10586324f, 
    -0.05933625f, 0.01095166f, -0.11040439f, 0.03466644f, 0.04818859f, -0.01873150f, 0.40168208f, 0.28586182f, 
    -0.09008197f, 0.03803206f, -0.11317923f, 0.09314759f, -0.03210920f, -0.00058561f, 0.03858775f, 0.01759013f, 
    0.08365577f, 0.01587411f, 0.13021667f, -0.03870185f, 0.03375711f, -0.07617564f, 0.00617727f, -0.05371831f, 
    0.25332689f, 0.10520292f, 0.05692025f, 0.08431566f, -0.09337659f, 0.09319497f, -0.12031031f, -0.02529998f, 
    0.07940358f, 0.22543448f, -0.05333101f, 0.10891753f, 0.00904008f, -0.03589996f, -0.03779740f, 0.02954754f, 
    -0.02884285f, 0.01783405f, -0.09839971f, -0.02127401f, 0.03221942f, 0.10181069f, -0.05414239f, 0.29876086f, 
    -0.12067644f, 0.15843573f, 0.06847039f, 0.02729903f, 0.05173690f, 0.10964541f, -0.00804199f, 0.01623693f, 
    -0.02566890f, -0.03173218f, -0.01989865f, -0.08228659f, 0.01605396f, -0.04855007f, -0.10604085f, 0.06648501f, 
    0.14964633f, 0.19793755f, 0.00970283f, 0.23803343f, -0.23559725f, 0.09421444f, -0.17816335f, -0.05203653f, 
    -0.00309917f, 0.27530700f, -0.05021662f, 0.01481534f, -0.04581087f, 0.00977694f, -0.06548236f, 0.01654936f, 
    -0.03717035f, 0.07939392f, -0.05976277f, 0.06425852f, -0.12957998f, -0.07421701f, 0.26489201f, 0.04854782f, 
    -0.16750304f, 0.04318297f, -0.04576572f, -0.01131809f, -0.19426923f, 0.00359301f, 0.04376359f, -0.14257984f, 
    0.01444170f, -0.04786817f, 0.10725415f, 0.16909079f, 0.04857641f, -0.10439943f, 0.03615546f, 0.10067391f, 
    0.41826445f, 0.01670502f, 0.16553333f, -0.01262167f, -0.08434701f, 0.11618174f, -0.05320446f, -0.03551809f, 
    0.03316270f, 0.09518848f, -0.02154762f, 0.04697091f, 0.08663908f, -0.07232986f, 0.00091061f, 0.05364102f, 
    -0.05323813f, -0.13306214f, 0.09972750f, -0.01694934f, -0.40778458f, 0.00024578f, 0.04975114f, 0.03340632f, 
    0.02633752f, -0.05234832f, 0.07154332f, -0.02178758f, 0.01162920f, 0.03665826f, -0.07722997f, -0.03758162f, 
    -0.06103514f, 0.09094174f, -0.05230627f, -0.08813240f, 0.07107466f, 0.01390107f, -0.00692781f, 0.01229032f, 
    0.41817862f, 0.30017540f, 0.03481497f, -0.15027423f, -0.23616309f, 0.02912612f, 0.09065961f, -0.03352924f, 
    0.11585400f, 0.12817766f, 0.03682346f, 0.06491464f, 0.12275331f, -0.03903379f, -0.02110178f, 0.00699993f, 
    0.05233895f, 0.04220612f, 0.10307306f, 0.08650050f, -0.12342240f, 0.34421417f, 0.09325621f, 0.02642049f, 
    -0.13072465f, 0.12562424f, -0.00171119f, 0.15568842f, -0.00855384f, -0.07158127f, -0.02040545f, 0.01141041f, 
    -0.02347935f, 0.01744425f, -0.12204033f, -0.03567166f, 0.21482813f, 0.12516041f, 0.00533604f, -0.05206616f, 
    -0.18937430f, 0.08484560f, 0.07072463f, 0.26756379f, 0.06861616f, -0.21461187f, 0.13972038f, -0.14184627f, 
    -0.11344106f, -0.03502298f, -0.01449174f, 0.13666555f, 0.01479669f, 0.28362387f, 0.05366231f, 0.00645944f, 
    0.07001815f, -0.02643058f, 0.07337994f, 0.03444579f, 0.07896931f, 0.00481562f, 0.22828983f, 0.24993888f, 
    0.01262816f, -0.02329957f, 0.10557844f, 0.10973502f, -0.16778322f, -0.08588121f, 0.15690310f, 0.15048908f, 
    0.02073151f, 0.04815493f, 0.00338347f, 0.03223108f, 0.20167677f, 0.06763686f, 0.09103909f, 0.07212448f, 
    0.41940197f, 0.27250019f, -0.10752010f, -0.30621669f, 0.09278873f, -0.08788436f, 0.03731181f, 0.08452681f, 
    0.17540288f, 0.04105888f, 0.01596816f, 0.10357427f, 0.12738809f, 0.05280798f, 0.16358426f, 0.15745504f, 
    0.13770476f, 0.00097476f, 0.13680510f, 0.07321242f, 0.07751718f, -0.25604308f, -0.01301884f, 0.20824711f, 
    0.03863172f, 0.04844090f, -0.01406213f, -0.06525987f, 0.00090363f, -0.01327582f, 0.06869273f, 0.05473294f, 
    0.04890081f, 0.13273376f, 0.03041948f, 0.03177958f, 0.08441126f, 0.09250868f, 0.04903462f, 0.06675143f, 
    -0.07548136f, -0.11775579f, -0.40514147f, -0.16769993f, -0.21641719f, 0.06452394f, 0.05683894f, 0.06663137f, 
    0.18463176f, -0.10018152f, -0.04023810f, -0.08295696f, 0.02122640f, 0.07894072f, -0.00427335f, 0.03177371f, 
    0.09913462f, 0.01382169f, 0.05533570f, -0.01774707f, -0.21412247f, -0.10828201f, 0.03263825f, 0.01025459f, 
    -0.16904466f, -0.09320269f, -0.05802402f, -0.19739935f, 0.00954601f, -0.11650811f, 0.03226463f, -0.01834232f, 
    0.00281744f, 0.04853905f, -0.01195802f, -0.18847762f, 0.02540031f, 0.01940645f, 0.11012660f, 0.09408663f, 
    0.30258298f, 0.23261854f, -0.11076678f, -0.06820918f, -0.05092105f, 0.00464645f, -0.00581599f, 0.20410433f, 
    0.04235160f, 0.03973489f, 0.02507992f, -0.03846252f, 0.01122326f, 0.01448160f, 0.11046809f, 0.21348582f, 
    -0.02174760f, 0.12496834f, 0.03283997f, -0.12777595f, -0.02529592f, 0.28937101f, -0.04066741f, -0.25462422f, 
    -0.51010340f, 0.06571716f, -0.09972938f, 0.03481407f, -0.08743769f, -0.01000941f, -0.12268306f, 0.06676484f, 
    0.00203725f, -0.00522574f, -0.13509949f, 0.06342029f, 0.09109613f, 0.12601024f, 0.07355640f, 0.20185578f, 
    -0.44866824f, -0.23157363f, 0.01950010f, 0.15554883f, 0.02224435f, -0.01287724f, -0.06045418f, 0.01941503f, 
    -0.07351274f, 0.08133058f, -0.04564129f, -0.11024000f, -0.08662971f, -0.03202366f, 0.09724528f, -0.07348849f, 
    0.02279313f, 0.03315991f, 0.07166006f, -0.13104981f, -0.33373901f, -0.33802068f, -0.05652284f, 0.04081713f, 
    0.07584973f, -0.12601495f, -0.19171283f, -0.01391723f, -0.05180125f, -0.04590341f, 0.07002231f, 0.05129550f, 
    -0.07020818f, -0.01371737f, 0.07919209f, -0.06423669f, -0.13720755f, -0.06324839f, 0.01867121f, -0.03314833f, 
    -0.35567600f, -0.21745445f, -0.17157899f, -0.05638631f, 0.30618727f, -0.17367464f, -0.22392341f, -0.07245602f, 
    -0.10961524f, -0.19832693f, -0.03699255f, 0.02111572f, -0.04778561f, 0.17532457f, 0.03308061f, -0.03823769f, 
    -0.10526461f, -0.03326593f, 0.08092529f, -0.01873338f, -0.06212152f, -0.11941519f, -0.27858353f, -0.26823324f, 
    -0.14338057f, -0.03572448f, -0.05877128f, 0.04176398f, -0.00858880f, -0.05747893f, -0.05580075f, -0.12034290f, 
    -0.01162987f, -0.11209721f, -0.05604202f, -0.01831655f, 0.04762548f, 0.01576790f, 0.07984512f, 0.05878891f, 
    0.37254632f, -0.04990562f, -0.34287843f, -0.03299373f, 0.06743449f, 0.03151837f, 0.11064547f, 0.15874566f, 
    0.05080753f, 0.22368430f, -0.14419629f, -0.10105142f, 0.03723506f, -0.03849711f, 0.01727880f, 0.03710768f, 
    0.04909828f, 0.01680963f, 0.15963449f, 0.19229324f, -0.51087350f, 0.05593628f, -0.00937151f, 0.21969956f, 
    -0.03770733f, 0.09180886f, -0.04003663f, -0.03200573f, 0.01332216f, -0.04245117f, -0.06720844f, -0.03049855f, 
    -0.09479249f, 0.02627838f, -0.10643718f, -0.00140976f, -0.00465135f, 0.01202075f, -0.00512515f, -0.03312316f, 
    -0.22419569f, 0.07740462f, -0.08691554f, -0.04667393f, -0.00482431f, -0.23531795f, -0.04399233f, -0.01875637f, 
    -0.13880683f, -0.20641810f, -0.30915210f, -0.07766515f, -0.03571839f, 0.17365806f, -0.00644814f, -0.10075808f, 
    -0.04092610f, -0.02369381f, -0.05150930f, -0.10156801f, -0.28004301f, -0.02400435f, 0.10988120f, 0.07706751f, 
    0.08618159f, 0.10667384f, 0.00469885f, -0.01556226f, 0.05504220f, 0.01607041f, -0.05987291f, -0.04047346f, 
    -0.02003169f, 0.05289330f, -0.01049271f, -0.05740461f, -0.00279424f, 0.05645905f, 0.01389850f, 0.02704524f, 
    0.18561012f, 0.11090650f, 0.12328228f, -0.13742232f, -0.19362833f, 0.02508915f, -0.17564148f, -0.01588244f, 
    -0.01925594f, 0.01369581f, -0.01765498f, 0.01300032f, 0.06115367f, -0.00354666f, -0.01707162f, 0.04391343f, 
    -0.01000421f, 0.13350827f, 0.03036502f, 0.08967743f, -0.27154255f, -0.07823173f, -0.05969218f, 0.11452744f, 
    -0.06923524f, -0.15950963f, -0.06395141f, 0.00535155f, -0.01543576f, -0.09289940f, -0.07631316f, -0.01782065f, 
    -0.00971592f, 0.02684389f, 0.01107980f, -0.09482501f, 0.10489120f, 0.02643323f, 0.02086083f, 0.10464333f, 
    0.34199741f, 0.17618240f, -0.31227848f, -0.18110980f, -0.23705357f, 0.08752972f, 0.17485404f, 0.19265024f, 
    0.18494555f, -0.01335167f, 0.06897734f, -0.05679925f, -0.00764248f, 0.12194476f, 0.02862115f, 0.12750238f, 
    0.01536218f, 0.07049388f, 0.06282391f, -0.02878084f, -0.18951023f, -0.14662650f, 0.07780977f, -0.02102745f, 
    -0.07802893f, -0.12106739f, -0.09318316f, -0.05691549f, -0.08747071f, -0.18535921f, -0.04940347f, 0.02581019f, 
    0.00119297f, 0.15813610f, 0.03264287f, -0.06768294f, -0.07158107f, 0.15044804f, 0.12045541f, 0.06369587f, 
    -0.28180483f, 0.10941662f, -0.03440168f, -0.11586791f, -0.00320351f, -0.16622351f, -0.00561890f, 0.01528716f, 
    0.24278748f, -0.17838177f, 0.03000351f, 0.07499831f, -0.08433360f, 0.00677009f, 0.04082290f, 0.02228054f, 
    -0.02733326f, 0.08909487f, -0.09247737f, 0.12996127f, -0.23054475f, 0.03169380f, 0.04276088f, 0.24280624f, 
    0.05617555f, -0.00634890f, -0.00514680f, 0.04400511f, 0.14150162f, -0.09087697f, -0.01641621f, -0.01710766f, 
    -0.00541173f, -0.02247306f, 0.00698308f, -0.00728185f, 0.07658561f, -0.02367565f, 0.00275297f, 0.01900228f, 
    0.20503499f, 0.31554544f, 0.09814452f, -0.10088397f, -0.04665234f, 0.06419107f, -0.02290081f, -0.00865498f, 
    0.39361215f, 0.04705747f, 0.06936179f, 0.01926169f, -0.01972775f, 0.04535015f, 0.00638784f, 0.03026223f, 
    -0.03986171f, 0.13413934f, 0.12136082f, -0.01578592f, 0.38483804f, 0.25455436f, 0.16291018f, -0.28104454f, 
    -0.18542598f, 0.17148621f, -0.02283992f, 0.17207915f, 0.19368029f, -0.05321851f, 0.03576934f, -0.03222971f, 
    0.02030431f, -0.04544108f, -0.09900909f, 0.13112642f, -0.04438096f, 0.01670092f, 0.05745075f, -0.04834004f, 
    0.04059453f, 0.12328799f, 0.20721117f, 0.04959230f, -0.19021113f, 0.09922082f, -0.05307538f, 0.02148605f, 
    -0.01712425f, 0.07428989f, 0.05405734f, -0.06751386f, -0.02444030f, 0.01731712f, -0.01464758f, 0.07608258f, 
    -0.04957294f, 0.02183426f, 0.05184462f, -0.09989479f, 0.23686786f, 0.06804338f, -0.08199688f, -0.37577954f, 
    -0.09653900f, 0.00237185f, 0.01729470f, 0.16015497f, 0.17928807f, 0.01350012f, -0.05654446f, -0.16261795f, 
    -0.00197516f, -0.00795542f, -0.02179397f, 0.07401998f, 0.10630605f, -0.00222449f, 0.06549039f, 0.13333493f, 
    -0.00400672f, 0.26841885f, 0.20029131f, 0.05234790f, -0.29872239f, 0.02406959f, -0.08997436f, 0.01103675f, 
    -0.05956078f, -0.02229503f, 0.02128026f, -0.03497034f, 0.01503373f, 0.01865413f, -0.06922153f, 0.07959808f, 
    0.04901061f, 0.08640263f, -0.00093657f, 0.08529589f, 0.29993391f, 0.32454225f, -0.17927946f, -0.19846746f, 
    -0.00094043f, 0.06540975f, 0.13638589f, 0.25554422f, 0.06488402f, 0.02651742f, 0.01854769f, -0.02758151f, 
    0.03063423f, -0.03665796f, 0.11933257f, 0.09118170f, -0.00330358f, -0.01384735f, 0.08546041f, 0.01340280f, 
    0.22896348f, -0.08626279f, 0.08924083f, 0.09390154f, 0.04946888f, 0.13297640f, 0.08853778f, 0.01220641f, 
    0.04940821f, -0.03801872f, 0.06996792f, -0.06909943f, -0.03956768f, 0.17816906f, 0.05701998f, -0.07010950f, 
    0.04056602f, -0.01716366f, -0.11091273f, 0.03322005f, 0.38708287f, -0.05917504f, -0.19868034f, -0.16743125f, 
    0.10290302f, 0.20352240f, 0.05032205f, 0.20890953f, -0.01054722f, -0.01618311f, 0.06101420f, -0.02820887f, 
    0.01178147f, -0.09234346f, 0.01413669f, 0.02264425f, -0.04472428f, 0.22387084f, -0.07597525f, -0.06898510f, 
    -0.02471431f, -0.01402339f, 0.23744863f, 0.03094445f, 0.04731922f, 0.02155038f, 0.11193477f, 0.03632518f, 
    -0.02779767f, -0.02945441f, 0.03220023f, -0.01100860f, 0.07483646f, -0.01509064f, 0.08203789f, 0.08818068f, 
    0.14879765f, -0.11352944f, 0.21771403f, 0.06547541f, -0.03989523f, -0.03265554f, -0.70114297f, 0.13183825f, 
    0.10063988f, 0.08422993f, 0.04651923f, 0.04787476f, 0.13409819f, 0.16848075f, -0.12401903f, 0.01200063f, 
    -0.02897081f, -0.04467828f, 0.02852769f, 0.03431296f, -0.08815675f, -0.01411841f, 0.17240667f, 0.12258209f, 
    -0.57053494f, 0.27375177f, -0.19234496f, -0.00081586f, 0.09346221f, -0.18629700f, -0.13840829f, 0.07372949f, 
    -0.00199750f, 0.13101177f, 0.26969728f, 0.07949587f, 0.18828011f, 0.01939668f, -0.00351372f, 0.02299459f, 
    0.05161187f, 0.06808578f, 0.17451903f, -0.10401383f, -0.00344413f, -0.17621899f, 0.09692035f, 0.15574220f, 
    -0.03152598f, 0.07238650f, -0.04251638f, -0.04193847f, 0.20362160f, 0.27783906f, 0.02511374f, 0.07219435f, 
    -0.04984592f, 0.13665962f, -0.03598536f, -0.01149905f, 0.13806741f, 0.02472121f, 0.15556224f, 0.14133868f, 
    0.21966009f, -0.52460444f, -0.23639463f, 0.15077800f, -0.16752410f, 0.14422260f, 0.23894867f, 0.07900731f, 
    0.12137088f, 0.17670053f, 0.07521146f, -0.01149118f, 0.05245046f, 0.05868325f, 0.12176731f, 0.19530258f, 
    0.13381428f, -0.01949768f, 0.04149568f, 0.20697431f, 0.25640443f, 0.03257615f, 0.06147197f, 0.06544032f, 
    0.29043731f, -0.04895079f, -0.06375062f, 0.05325789f, 0.08153788f, 0.08245770f, 0.16832222f, 0.07532205f, 
    0.01591872f, 0.21590547f, 0.09629627f, 0.02941217f, -0.04739076f, 0.07789823f, 0.09322480f, 0.26586923f, 
    -0.07992717f, -0.11741244f, 0.29969350f, 0.15462393f, -0.30696616f, -0.20812529f, -0.14792709f, -0.18446298f, 
    0.06896691f, 0.17653504f, 0.12882352f, 0.18969785f, 0.14298475f, -0.03594876f, 0.04409894f, -0.03211597f, 
    0.03085495f, 0.01781631f, -0.04139385f, -0.08292992f, 0.09564895f, 0.02509702f, -0.16905756f, -0.05350438f, 
    0.00710146f, -0.08132353f, -0.11531697f, 0.01117828f, -0.02360781f, -0.02000035f, 0.04447519f, -0.13841701f, 
    0.14032464f, -0.02282325f, -0.10960759f, 0.08489041f, 0.00421986f, -0.19556895f, 0.02634482f, 0.06429513f, 
    -0.13077827f, -0.15820673f, 0.00987522f, 0.00628878f, -0.09297920f, -0.10457177f, -0.06168649f, 0.00775749f, 
    0.08509885f, 0.02173151f, 0.02987237f, 0.03849467f, -0.06953428f, 0.03370741f, -0.11527751f, -0.01288122f, 
    -0.04527650f, -0.08786438f, 0.07669526f, 0.01786579f, -0.15517607f, -0.07244743f, -0.59238929f, 0.18210234f, 
    -0.09659437f, 0.04848000f, -0.00642862f, 0.19450758f, -0.13772462f, -0.09113016f, -0.08006717f, 0.05212275f, 
    -0.06915582f, -0.02171876f, 0.03605130f, 0.09014104f, -0.02142025f, 0.09054391f, 0.10982669f, 0.03591867f, 
    0.31328645f, 0.34534639f, -0.22422801f, -0.17469271f, 0.09594195f, -0.02028980f, -0.03248921f, 0.11402569f, 
    -0.14006984f, -0.08130792f, 0.04606976f, -0.01302482f, 0.08306847f, 0.06035407f, -0.00866825f, 0.00802212f, 
    -0.06031785f, 0.04892752f, -0.12630190f, 0.07531036f, 0.07297974f, 0.26629993f, 0.14859660f, -0.18705109f, 
    0.20242649f, -0.06253448f, -0.06257939f, -0.03171109f, -0.17904072f, -0.04328965f, 0.09453823f, -0.02514705f, 
    0.16760956f, 0.03807582f, 0.08433305f, -0.00035578f, 0.00050599f, -0.22231865f, -0.05124369f, 0.11489386f, 
    0.12699583f, 0.19367407f, 0.20721042f, -0.02173364f, 0.22795977f, -0.08498655f, -0.05031284f, -0.24630073f, 
    -0.16601813f, -0.14507748f, 0.03921833f, -0.19776540f, -0.01532807f, 0.03994359f, -0.02449850f, -0.03129824f, 
    0.13317297f, -0.18173330f, -0.00795453f, 0.02994747f, -0.05092493f, 0.03471514f, 0.28896132f, -0.09630841f, 
    -0.40095630f, -0.18891749f, -0.03381021f, -0.22468990f, -0.05986950f, -0.06893238f, -0.03980485f, 0.05589020f, 
    -0.05757330f, -0.02032687f, -0.01889551f, -0.06142617f, 0.09299251f, 0.05347132f, -0.08750430f, 0.02439957f, 
    0.04182050f, 0.05159260f, 0.44532567f, -0.16901334f, -0.18425685f, 0.05555648f, 0.10967617f, -0.05853986f, 
    0.11565228f, 0.00390425f, 0.09571747f, 0.09654654f, -0.00737225f, 0.01066334f, 0.00160428f, 0.01600602f, 
    0.05988447f, 0.04811373f, -0.01237248f, 0.20775096f, 0.21406886f, 0.04335078f, -0.41384676f, 0.12487441f, 
    0.16797692f, 0.11368915f, 0.07065612f, 0.04493130f, -0.03646320f, -0.00670076f, -0.00583433f, 0.00012300f, 
    -0.03313415f, -0.03433831f, -0.06621131f, -0.09907754f, -0.12408414f, 0.05353016f, -0.07248852f, -0.07213984f, 
    0.09756872f, 0.07060169f, 0.03390709f, -0.07184394f, -0.06567674f, -0.08773969f, -0.09433863f, -0.07305001f, 
    -0.17072645f, -0.13935910f, 0.29128766f, 0.07897145f, -0.08021428f, 0.03927735f, 0.06673655f, -0.14954509f, 
    0.05056662f, 0.17376705f, -0.05444896f, -0.15062097f, -0.31065768f, 0.10316537f, -0.33558959f, 0.29943511f, 
    0.01867215f, 0.01445917f, 0.10956972f, 0.08165582f, 0.11191614f, 0.14887515f, -0.11672544f, -0.00639788f, 
    -0.09056159f, 0.08932085f, 0.09491058f, 0.08082674f, 0.04155278f, 0.12656757f, -0.08004421f, -0.00226052f, 
    0.07321659f, 0.02369178f, 0.06752007f, 0.11863743f, -0.22973238f, 0.11316999f, 0.13765867f, -0.03979724f, 
    -0.14360797f, -0.08484510f, 0.04057809f, 0.04580865f, -0.01158539f, 0.07688851f, 0.01620538f, 0.08027519f, 
    -0.02708195f, 0.01747334f, -0.06414622f, 0.00660097f, 0.03372028f, -0.08177564f, 0.09152200f, -0.00996018f, 
    -0.04944311f, -0.04449023f, -0.07490396f, -0.00557834f, -0.06923445f, -0.12208860f, 0.15318619f, -0.01039327f, 
    0.10394388f, 0.04581271f, -0.01039794f, 0.03687329f, -0.07347202f, 0.13490960f, -0.05600955f, 0.08782718f, 
    0.01238896f, -0.21227397f, 0.16285171f, -0.00459334f, -0.14044477f, -0.17163926f, -0.07995448f, -0.02601828f, 
    0.13023172f, 0.01951241f, 0.02943528f, 0.11553560f, -0.00180544f, -0.04110103f, -0.00307313f, -0.04107469f, 
    0.05974274f, -0.04637248f, 0.01512569f, -0.00686157f, -0.02169407f, 0.05224141f, -0.05971014f, -0.06212979f, 
    -0.03262870f, 0.00166369f, -0.09949543f, -0.18942077f, -0.09664493f, -0.04652556f, 0.13800097f, 0.04518022f, 
    0.14341509f, 0.13382076f, -0.05434578f, -0.05803690f, -0.01733793f, -0.11957382f, 0.06612416f, 0.08178037f, 
    -0.44312957f, -0.10846523f, -0.22350919f, 0.36253947f, -0.44185284f, -0.36121869f, -0.33066928f, -0.06384082f, 
    0.03489489f, 0.08341524f, 0.20442438f, 0.05300088f, -0.03391872f, 0.03602118f, 0.05981044f, -0.12566283f, 
    0.03281281f, 0.06020430f, -0.06971380f, 0.10516641f, 0.29956806f, -0.24752618f, -0.18787764f, 0.04127705f, 
    0.11858181f, 0.15345609f, -0.06590633f, 0.04457533f, -0.04146443f, -0.10857182f, 0.15971372f, 0.03141877f, 
    0.03996426f, 0.06780926f, -0.05242572f, 0.16569684f, 0.14143924f, 0.04255037f, -0.03474659f, 0.01646327f, 
    -0.22929971f, -0.25812221f, -0.01978945f, 0.19508204f, -0.19704518f, -0.01863254f, 0.06158903f, 0.12681463f, 
    0.18870005f, -0.06762631f, -0.10718925f, -0.04333972f, 0.03571574f, 0.02773280f, 0.05791811f, 0.10053925f, 
    -0.03349843f, -0.00705608f, -0.01580255f, 0.01691247f, -0.03005762f, -0.06946298f, 0.04758321f, 0.19287682f, 
    -0.15548052f, -0.12040519f, -0.06676178f, -0.04719640f, 0.03010723f, -0.10601362f, -0.03352249f, 0.05171522f, 
    -0.05579564f, 0.07764365f, 0.08086456f, -0.01814806f, 0.01765199f, -0.15224311f, 0.13683483f, -0.12074725f, 
    0.04134456f, 0.13485156f, -0.10447388f, 0.14735268f, -0.15166727f, 0.13372269f, 0.19335827f, 0.07048834f, 
    -0.03154152f, 0.04609175f, 0.00741115f, 0.01297616f, 0.06482250f, 0.02146125f, 0.00623785f, 0.02911196f, 
    -0.02388663f, 0.07217336f, -0.06784961f, -0.02776052f, -0.11703825f, 0.04944649f, 0.17602399f, 0.19284849f, 
    -0.13392554f, -0.11918116f, 0.06904474f, 0.01136660f, 0.02365760f, 0.02999939f, -0.03355460f, 0.01486709f, 
    -0.05999282f, 0.04606729f, 0.04863440f, -0.02304072f, 0.02334997f, 0.02889867f, 0.00502029f, 0.07479434f, 
    -0.12669301f, 0.13142192f, -0.26610103f, 0.20960808f, -0.17427066f, 0.06008068f, 0.09609632f, 0.30949035f, 
    -0.01324747f, -0.04116592f, -0.01824737f, 0.02492823f, 0.00351928f, -0.03091495f, -0.05552400f, 0.05494044f, 
    0.00174656f, 0.07342840f, 0.04458069f, -0.13900195f, -0.10025263f, -0.22140831f, 0.10946311f, -0.03514577f, 
    -0.11726109f, -0.05122950f, -0.00066409f, -0.03073419f, -0.06030646f, 0.04657859f, 0.10562824f, -0.05192552f, 
    0.00913779f, -0.04638685f, -0.04806500f, 0.07589705f, 0.03695306f, -0.18830043f, -0.02538073f, 0.05857610f, 
    0.10153219f, -0.18849114f, -0.11339105f, -0.11601204f, 0.15714830f, 0.18383937f, -0.07653838f, 0.13068025f, 
    0.01697048f, 0.02097852f, 0.06225615f, -0.05629480f, -0.01234001f, 0.10863545f, -0.01951521f, -0.00418365f, 
    0.04003762f, 0.14727221f, 0.07097543f, 0.10007025f, -0.09848154f, 0.16391310f, 0.00050856f, -0.09771200f, 
    0.00128624f, 0.01995090f, 0.07722104f, 0.18252802f, -0.01158765f, -0.03036649f, 0.04630664f, -0.00062376f, 
    -0.05307702f, -0.02959383f, 0.02437382f, -0.06676549f, 0.09077130f, -0.01389052f, -0.01843325f, -0.03178681f, 
    0.21202563f, -0.13863482f, -0.08287888f, 0.10080104f, 0.05664086f, 0.01660167f, 0.02062604f, 0.07849848f, 
    -0.00613300f, -0.00156076f, 0.06892306f, -0.01727952f, 0.00977404f, -0.08084151f, 0.00646525f, -0.05538298f, 
    0.11643063f, 0.08285683f, 0.07299985f, -0.08129071f, 0.33495736f, 0.14710532f, -0.45750105f, 0.02173309f, 
    0.09569071f, 0.07690459f, 0.24640425f, 0.24737799f, -0.01078541f, 0.06478765f, -0.02251085f, 0.00874239f, 
    -0.03946728f, -0.05326181f, -0.04762417f, -0.06027440f, 0.08082826f, -0.00711091f, 0.09022621f, -0.14380963f, 
    -0.30421495f, 0.20876934f, -0.18433692f, 0.05467992f, 0.15406995f, -0.13605841f, -0.00477913f, 0.09115718f, 
    -0.16867261f, -0.14691080f, 0.15282758f, 0.24807605f, 0.22371188f, -0.08416048f, -0.00728274f, 0.01787138f, 
    0.05213512f, -0.31264615f, 0.20231764f, -0.03272320f, -0.06423462f, 0.23707746f, -0.16987830f, 0.04704726f, 
    -0.00885161f, 0.11976477f, -0.07922509f, 0.10419135f, -0.23032248f, 0.00316637f, 0.18197632f, 0.19075646f, 
    -0.05188777f, 0.14925349f, -0.08555207f, -0.00541289f, -0.05885627f, -0.03701671f, 0.12787390f, 0.06109784f, 
    0.11004991f, -0.33493710f, 0.25914454f, 0.01844550f, 0.06255320f, -0.17685655f, 0.37790418f, -0.19081984f, 
    0.23206930f, 0.19178124f, 0.17544988f, 0.05855686f, 0.16967614f, -0.03530182f, 0.00056927f, 0.05171729f, 
    0.14405693f, 0.00066478f, -0.06609759f, 0.05264112f, 0.15935977f, 0.04868602f, 0.02080882f, 0.12138803f, 
    0.19461119f, 0.06526566f, -0.03209000f, 0.04986028f, 0.03570668f, -0.11118054f, 0.16124386f, 0.08811562f, 
    -0.05424697f, 0.19392702f, 0.01410842f, 0.08985101f, 0.08761511f, 0.10781436f, -0.17176832f, 0.10259537f, 
    -0.17732950f, 0.19732700f, 0.18209051f, 0.21647127f, -0.13899526f, 0.04158033f, -0.00486184f, -0.08463088f, 
    -0.03815371f, 0.02711313f, 0.06478932f, 0.09351796f, 0.17037763f, -0.07553743f, 0.00916062f, -0.02761335f, 
    -0.00852849f, -0.09862143f, 0.08897339f, -0.12578817f, -0.06446242f, 0.08133852f, -0.01724081f, -0.02762800f, 
    -0.04997123f, 0.00307918f, -0.15419108f, 0.04354975f, 0.00525925f, -0.13908873f, 0.10041683f, -0.07365898f, 
    -0.12669712f, 0.08369640f, -0.04591241f, -0.06932192f, 0.02626162f, -0.06082102f, 0.02393503f, -0.02594340f, 
    0.25132445f, -0.13111201f, -0.37723127f, -0.13257128f, 0.12963431f, -0.05088035f, -0.06881031f, 0.02341031f, 
    0.21138626f, 0.07638461f, -0.02644370f, -0.04724824f, 0.00471118f, 0.15593345f, 0.07829662f, 0.01617343f, 
    0.00012607f, 0.19734961f, 0.04633103f, 0.05517315f, 0.24054845f, 0.17281826f, -0.64023614f, -0.01590865f, 
    0.15300897f, 0.04982896f, 0.09036623f, 0.27168667f, -0.01986701f, -0.18808761f, -0.00652310f, 0.01700825f, 
    -0.09620616f, -0.12858468f, -0.02436574f, -0.02022203f, -0.00052929f, 0.10136916f, 0.22067738f, -0.06584191f, 
    -0.12956113f, 0.13081872f, 0.07478269f, 0.00300824f, 0.07189670f, -0.02594854f, -0.12815967f, 0.18753144f, 
    -0.04721963f, -0.13297044f, -0.01420787f, -0.01719734f, -0.02140919f, 0.02327417f, 0.05818123f, 0.12435467f, 
    0.04205316f, -0.02053814f, -0.17021075f, 0.04526133f, 0.19366783f, -0.01152979f, 0.23259339f, -0.24961719f, 
    0.16101505f, -0.02027697f, -0.12849626f, 0.10787146f, -0.04494592f, -0.21156727f, 0.07111237f, 0.01841215f, 
    0.19526412f, -0.00008208f, -0.01725759f, 0.00202252f, 0.17292495f, -0.05439486f, -0.25220060f, 0.12772147f, 
    0.03328318f, 0.17505017f, 0.09563429f, -0.06132887f, -0.12136298f, -0.16263723f, -0.03097597f, -0.09868353f, 
    -0.08177319f, -0.03163421f, 0.08889588f, -0.06954144f, 0.10362848f, -0.02042727f, -0.11125908f, -0.01351193f, 
    0.04052738f, -0.17110291f, -0.34927455f, -0.07578053f, -0.28196302f, 0.14743011f, 0.26000625f, -0.15705635f, 
    -0.14710085f, -0.08907138f, -0.02031939f, -0.06112917f, -0.09415747f, -0.05194894f, 0.02650098f, -0.06504941f, 
    -0.08637343f, -0.07048416f, -0.07123216f, -0.08175919f, -0.05080233f, -0.00715572f, 0.00671989f, 0.00466487f, 
    -0.03424075f, -0.08309835f, -0.15733141f, -0.19809619f, 0.05870941f, -0.11310760f, 0.14482348f, 0.01435726f, 
    0.10064692f, -0.00889309f, 0.00291240f, 0.06562315f, -0.06532399f, 0.02892253f, 0.04285213f, -0.09382970f, 
    0.01716551f, 0.17421396f, -0.07647902f, -0.01752291f, 0.03046964f, 0.09963886f, -0.12731221f, 0.12419253f, 
    -0.03912716f, -0.01503108f, 0.16125759f, 0.21462178f, -0.04897326f, 0.02389811f, -0.05515184f, -0.03806905f, 
    0.03899292f, 0.05056804f, -0.07416271f, -0.01181474f, -0.00637845f, -0.09748957f, -0.06603704f, -0.07747889f, 
    -0.11116379f, 0.07540131f, 0.02661424f, -0.06172862f, -0.20269714f, -0.17243205f, -0.01294358f, 0.02111788f, 
    -0.07227004f, -0.14640801f, 0.09948295f, 0.13643937f, 0.20276614f, -0.16337335f, -0.03494645f, -0.02210739f, 
    -0.07881953f, -0.13229837f, 0.04206682f, -0.06925613f, 0.07652248f, 0.12155292f, -0.23984398f, -0.00133875f, 
    -0.04645636f, -0.17269590f, 0.13427833f, 0.13962284f, -0.08197419f, 0.05316239f, -0.10589303f, 0.00181771f, 
    0.08983403f, -0.00233484f, -0.08457077f, 0.04672830f, 0.02593357f, -0.10955869f, 0.07573633f, -0.04722386f, 
    -0.03496871f, -0.21183866f, -0.42782569f, -0.09784827f, 0.02588905f, 0.09211171f, -0.06172770f, 0.09571851f, 
    -0.24661423f, -0.02851338f, 0.00920200f, -0.00662589f, -0.07946277f, -0.04965685f, 0.09467519f, -0.05368681f, 
    -0.09239062f, 0.15636636f, 0.03354274f, -0.00956112f, -0.22272876f, 0.07831655f, 0.12279914f, 0.00857371f, 
    -0.14843450f, -0.03840953f, -0.03322642f, 0.08090679f, -0.05875827f, -0.03988731f, 0.04626823f, -0.00372181f, 
    0.03165273f, 0.02957330f, 0.01977365f, 0.01486574f, 0.02503109f, -0.01831039f, -0.07484566f, 0.06283718f, 
    0.17573746f, -0.05688573f, -0.24153084f, -0.07312766f, -0.14539379f, -0.01558498f, 0.10173982f, -0.13985351f, 
    0.19544952f, 0.06829010f, -0.01258299f, -0.08824021f, 0.07456898f, 0.03731528f, 0.01156280f, -0.06479208f, 
    0.01682491f, -0.08710447f, 0.08248028f, 0.03380719f, -0.06996811f, 0.08218591f, 0.07852277f, -0.09641538f, 
    -0.05121673f, 0.04016646f, -0.13860629f, -0.06874841f, -0.05649135f, -0.09469950f, 0.19284058f, 0.12582599f, 
    -0.08002829f, 0.13871527f, -0.08971464f, -0.03440463f, -0.08425684f, -0.03320130f, 0.07811712f, 0.01567657f, 
    -0.08607368f, 0.37167662f, -0.13985805f, 0.39009801f, -0.43095657f, -0.32687891f, 0.01198419f, -0.02230697f, 
    -0.21825080f, 0.14798702f, 0.24141505f, 0.04827680f, 0.14834450f, -0.03103813f, -0.04313273f, 0.13482046f, 
    -0.01648634f, -0.17547728f, -0.06396399f, 0.03319097f, 0.03367484f, -0.06130267f, 0.11239687f, 0.14563744f, 
    -0.00291613f, 0.01347975f, 0.13037118f, 0.08706121f, 0.01686818f, 0.03346795f, 0.06324887f, -0.08088578f, 
    0.08769421f, -0.03156465f, -0.05784037f, 0.05010306f, 0.16091560f, -0.01221307f, -0.14644705f, -0.02021755f, 
    -0.16923995f, 0.08159231f, -0.18627247f, -0.00474323f, -0.06326294f, 0.01644707f, 0.05743705f, -0.17105317f, 
    0.16850539f, 0.15519406f, 0.05674430f, -0.02770123f, -0.01272885f, -0.00435179f, -0.02911056f, 0.13208474f, 
    -0.03175230f, -0.07011626f, 0.09097827f, -0.05848262f, -0.00199413f, 0.03187177f, -0.09243728f, 0.02849538f, 
    -0.15282860f, -0.02614300f, -0.12695362f, -0.13310693f, 0.04924615f, -0.04425494f, -0.01327815f, 0.01567144f, 
    -0.06300393f, -0.00762977f, -0.00567896f, -0.01561335f, 0.00133461f, 0.12344608f, 0.36388582f, -0.00838542f, 
    -0.20070291f, 0.00780706f, -0.35485944f, -0.03049389f, -0.04748678f, 0.13117591f, 0.02594689f, 0.16966562f, 
    -0.03220532f, 0.10213766f, 0.08065429f, -0.05015386f, 0.02332728f, 0.03878612f, 0.04341302f, 0.07486387f, 
    -0.08540940f, 0.12879862f, 0.06316335f, -0.01993750f, -0.15974523f, -0.06858040f, 0.10898415f, -0.18694858f, 
    -0.05344366f, -0.01910538f, -0.07535455f, 0.03826848f, 0.04930061f, 0.04981502f, 0.05220288f, -0.08456025f, 
    -0.04149050f, -0.14201199f, 0.01806110f, 0.05850070f, 0.01310688f, 0.02007451f, 0.13888815f, -0.11005434f, 
    -0.38672864f, 0.14563976f, -0.57903790f, 0.08980028f, -0.14070773f, 0.00410226f, 0.14003991f, 0.22036695f, 
    -0.09994332f, 0.01189761f, 0.01961681f, -0.05694472f, 0.06691446f, -0.01284138f, 0.04350531f, 0.06774545f, 
    -0.06358013f, 0.02998203f, 0.09860715f, -0.08585608f, 0.16546781f, -0.07282738f, -0.40603527f, -0.42076844f, 
    -0.01622755f, -0.10306083f, 0.00157404f, 0.02017293f, 0.10705456f, 0.14454071f, 0.07247209f, 0.01634528f, 
    -0.00618179f, 0.00832798f, 0.05722466f, -0.05150907f, -0.00477876f, 0.15630139f, 0.07086729f, -0.02166287f, 
    -0.00722652f, -0.02830735f, 0.02799479f, -0.04144290f, 0.01485309f, 0.02421976f, -0.04055124f, -0.01036392f, 
    0.00546443f, -0.02684103f, 0.03311713f, 0.02995829f, -0.02155435f, -0.03890925f, -0.01954235f, 0.00424248f, 
    -0.01033604f, 0.01139343f, 0.00802567f, 0.01720090f, -0.01824862f, -0.04368783f, 0.00630399f, -0.02054187f, 
    0.02295933f, -0.04152630f, -0.02040888f, -0.03663833f, -0.00172715f, -0.02312052f, -0.00963300f, -0.00475232f, 
    0.00890303f, 0.00005419f, -0.00209239f, 0.01992962f, -0.03504926f, -0.04324669f, -0.01387918f, -0.01687066f, 
    -0.02714615f, -0.01693781f, -0.03441445f, 0.00177133f, 0.00719581f, -0.02571611f, 0.02173419f, -0.01310635f, 
    -0.02366177f, -0.03611415f, -0.03370793f, 0.00862480f, 0.00337570f, -0.02838554f, -0.03620646f, -0.03621863f, 
    -0.00630140f, 0.02133196f, -0.02938971f, 0.02800400f, 0.00320541f, -0.02529488f, -0.04085831f, -0.00437914f, 
    0.00530955f, 0.03341404f, 0.02829891f, 0.03162008f, 0.03012134f, 0.01438650f, -0.00611214f, 0.02349133f, 
    -0.01423538f, -0.03202548f, -0.02756020f, -0.01865689f, 0.02456808f, -0.00273784f, -0.03061626f, 0.01148278f, 
    0.02607579f, -0.02649207f, -0.01362915f, 0.00569940f, -0.00990946f, -0.01038327f, -0.01864688f, 0.01053717f, 
    -0.01080927f, -0.02156469f, 0.00381722f, -0.01134781f, 0.02336947f, -0.02521577f, 0.02848657f, -0.01526410f, 
    0.00022239f, 0.02428308f, 0.00080770f, 0.03040707f, -0.00246500f, -0.02269966f, -0.00969808f, 0.01953799f, 
    -0.01179456f, 0.00917066f, -0.01883279f, -0.01538284f, 0.03670505f, 0.03423166f, 0.00290987f, -0.00371206f, 
    0.01363347f, 0.01473826f, 0.01232620f, -0.03291935f, -0.00288065f, -0.03470942f, -0.04035307f, 0.02554252f, 
    -0.03534207f, -0.02159300f, 0.01970333f, 0.02766466f, 0.01549084f, 0.03186968f, -0.01454336f, -0.02048833f, 
    -0.03363953f, -0.02606006f, -0.01276441f, 0.02262219f, 0.01552085f, -0.01000612f, 0.02804357f, -0.02912649f, 
    0.02309749f, -0.02249512f, -0.04240138f, -0.02121221f, -0.04450268f, -0.02623378f, 0.03390289f, -0.04080743f, 
    0.00827683f, 0.00447315f, 0.03220695f, -0.03344903f, 0.02453320f, 0.00680962f, -0.04134068f, -0.03861956f, 
    0.00887689f, -0.03134747f, -0.04051680f, 0.02467719f, -0.03613377f, -0.00056431f, -0.00909466f, -0.01569645f, 
    0.01636680f, 0.02566416f, -0.03278610f, -0.01218651f, -0.02332797f, -0.02550063f, 0.02465297f, -0.01160843f, 
    -0.04311676f, -0.02919866f, 0.01745025f, 0.01178429f, -0.01596237f, 0.02707880f, 0.02038632f, -0.01111387f, 
    -0.00670859f, 0.02074122f, 0.01523902f, -0.02110346f, -0.04444265f, -0.01409770f, 0.02596322f, 0.01297965f, 
    0.01519100f, -0.03178469f, 0.02491091f, -0.03413991f, 0.01445950f, -0.00357494f, 0.01327659f, 0.00130464f, 
    -0.02933718f, -0.00813963f, -0.00493286f, -0.02116501f, 0.00878148f, 0.01973105f, 0.00630699f, -0.00353015f, 
    0.02422288f, 0.02132838f, -0.01092204f, 0.02077758f, -0.02113161f, 0.02756529f, -0.00477987f, -0.00373874f, 
    -0.02731587f, 0.02146634f, 0.01107140f, -0.02276823f, -0.02811964f, -0.01289252f, 0.02545687f, -0.02818465f, 
    0.02052158f, -0.00610112f, 0.03019777f, -0.04203567f, -0.02991961f, -0.01458904f, -0.03537372f, 0.02025572f, 
    0.02011912f, 0.00916099f, 0.02761415f, 0.00389604f, 0.02272866f, 0.01202057f, -0.03895369f, 0.03517197f, 
    0.02095129f, 0.02266323f, -0.01613571f, -0.01192821f, -0.02489326f, -0.02442706f, 0.03417525f, -0.03476113f, 
    0.00643437f, 0.03101892f, -0.02822625f, 0.03000576f, 0.02256587f, -0.03650574f, -0.03569132f, 0.01072633f, 
    0.01983003f, 0.00401479f, -0.03688863f, 0.00816968f, -0.02589008f, -0.02342953f, -0.00397496f, 0.01754321f, 
    -0.01545401f, -0.01448028f, -0.00133749f, 0.03080837f, 0.01305885f, -0.02295082f, 0.01548351f, -0.01460132f, 
    -0.00878225f, -0.04410018f, 0.01443559f, -0.01544907f, 0.02904912f, 0.01764142f, -0.02507219f, -0.02751584f, 
    0.01844520f, -0.02149601f, -0.03228312f, -0.01713653f, 0.00781160f, 0.02333917f, 0.01600006f, -0.02912392f, 
    -0.04352995f, 0.01530427f, 0.03307237f, -0.00281618f, -0.04044161f, -0.03743257f, -0.00548242f, -0.03252344f, 
    0.00282680f, -0.00712155f, 0.01657488f, -0.02645604f, -0.00171701f, 0.00077841f, 0.01333807f, 0.01966545f, 
    -0.00026821f, -0.02601636f, -0.03929379f, 0.02985470f, -0.00979019f, 0.01322152f, -0.01320574f, -0.03564805f, 
    0.02720479f, 0.01731281f, -0.01529205f, -0.00976059f, 0.03094296f, -0.03509526f, -0.02402653f, -0.00820798f, 
    0.01245266f, 0.00152643f, 0.00736366f, -0.00192422f, 0.00311493f, -0.00933594f, 0.00991692f, -0.00503549f, 
    -0.01696326f, 0.00410928f, 0.00871361f, 0.01159880f, 0.01983474f, 0.03328042f, -0.01534426f, 0.02347739f, 
    -0.02933112f, 0.00557926f, -0.01768134f, -0.01570583f, -0.01626805f, 0.03341971f, 0.02744046f, -0.02688945f, 
    0.01601189f, -0.01752285f, 0.02181436f, 0.01254851f, 0.02797447f, -0.02621341f, -0.01403312f, -0.02000130f, 
    0.02116194f, -0.04157184f, -0.02643877f, -0.00212932f, 0.02069191f, 0.00608889f, -0.01843353f, 0.02412754f, 
    -0.03926876f, -0.01657014f, -0.02104822f, -0.03297302f, -0.02137966f, 0.02351815f, -0.00932243f, -0.04319027f, 
    0.02233452f, 0.01644599f, -0.02549551f, -0.00519981f, 0.01632700f, 0.02208079f, -0.01958801f, -0.00694208f, 
    0.01453111f, -0.03914769f, -0.03703015f, -0.04120116f, -0.03275957f, 0.02389418f, -0.01504719f, 0.02086720f, 
    -0.00221719f, -0.03355535f, 0.01494524f, 0.03000204f, 0.03134620f, -0.03665712f, 0.02840336f, 0.03287000f, 
    -0.01232287f, 0.00162128f, -0.03171377f, -0.01335262f, -0.03612253f, -0.01360948f, -0.02203397f, -0.00631772f, 
    -0.03840972f, -0.02905924f, 0.01626064f, -0.02951663f, -0.01537710f, 0.02904730f, -0.02066947f, -0.01113062f, 
    0.03436526f, 0.01701318f, 0.02888695f, -0.01025884f, -0.02025616f, 0.02513851f, 0.01575263f, -0.03917750f, 
    -0.00937341f, -0.01902877f, -0.02784874f, -0.00989613f, -0.02117474f, 0.01102959f, -0.03640568f, -0.01743173f, 
    -0.02999478f, 0.02119469f, 0.03328776f, -0.02200288f, -0.02574649f, -0.00315161f, -0.03430519f, -0.03576618f, 
    -0.01931667f, -0.00961673f, -0.01933188f, -0.02314237f, -0.02291528f, 0.00578783f, -0.01132464f, 0.01082373f, 
    0.02135967f, -0.00654554f, -0.01939500f, -0.02131240f, -0.00188078f, -0.04387025f, -0.02577636f, -0.03027614f, 
    -0.04177230f, -0.00659554f, 0.02562798f, 0.00325799f, -0.04058049f, 0.00083530f, -0.03601881f, -0.04468803f, 
    -0.02703463f, -0.03756463f, -0.01791800f, 0.02306963f, -0.01397701f, 0.01424638f, -0.03047145f, 0.02447260f, 
    0.00874797f, 0.03115888f, -0.00695287f, -0.01616608f, -0.04381844f, -0.00338868f, -0.00252898f, 0.03160306f, 
    -0.04300835f, 0.03181322f, 0.03068948f, -0.03606431f, 0.03464505f, -0.02498344f, -0.01760659f, -0.01607218f, 
    -0.01609023f, -0.03558167f, -0.02233316f, 0.01844162f, 0.02092612f, -0.01465099f, -0.04311265f, -0.02571406f, 
    0.02626702f, 0.01785539f, -0.01512276f, -0.03548673f, 0.02048099f, 0.03292067f, 0.00061998f, -0.03739885f, 
    0.03239008f, 0.01045519f, 0.01273175f, -0.02268113f, 0.01777033f, 0.02963840f, 0.01184046f, -0.04128051f, 
    -0.00226775f, -0.04247424f, 0.03023811f, 0.01750780f, -0.02189199f, -0.01318373f, -0.01319688f, 0.00048098f, 
    -0.01824728f, 0.03175217f, 0.03272067f, -0.02678615f, 0.00105431f, 0.01609097f, 0.03251315f, 0.00871081f, 
    -0.03264513f, 0.02755627f, -0.01684989f, -0.03331158f, -0.02293580f, -0.02583961f, 0.01583325f, -0.03490989f, 
    -0.00133619f, -0.03297761f, -0.04126761f, 0.01490474f, -0.01283550f, -0.01728765f, -0.00995261f, -0.04298489f, 
    -0.03821278f, 0.00107983f, 0.01072384f, -0.04287741f, 0.00489656f, -0.01681183f, -0.03934168f, -0.02247546f, 
    0.01765949f, 0.02517418f, -0.02189712f, -0.02809890f, 0.00126391f, -0.03689466f, 0.02807173f, -0.02857451f, 
    -0.02956984f, 0.01279701f, -0.00909939f, -0.00280590f, -0.00010261f, 0.00867822f, -0.02251454f, -0.02200316f, 
    -0.02598205f, -0.01630046f, -0.00196675f, -0.01312824f, -0.02103815f, -0.01594445f, -0.03341344f, -0.03378211f, 
    -0.00290358f, -0.03771108f, 0.02066026f, 0.02594178f, 0.02313730f, 0.01994941f, -0.02795486f, 0.01058564f, 
    -0.01778529f, -0.01498416f, 0.03205175f, -0.00801322f, -0.04148892f, 0.03252429f, 0.00174923f, 0.01095292f, 
    -0.00170074f, -0.03726594f, -0.02661742f, 0.00764550f, -0.00199885f, -0.01193667f, -0.04004904f, -0.02410022f, 
    0.02681871f, 0.02061561f, -0.02272953f, -0.02768584f, 0.01315618f, -0.00670501f, -0.00531773f, -0.00964193f, 
    0.02318160f, 0.01217900f, 0.02287018f, 0.01211152f, -0.00977418f, 0.01804348f, -0.03479989f, 0.01696242f, 
    0.03047290f, 0.00951356f, 0.02666485f, 0.01356731f, 0.02882712f, -0.01487760f, 0.00105307f, -0.02162623f, 
    -0.01460217f, -0.00334801f, -0.01853957f, -0.03545943f, -0.00392782f, 0.02974943f, -0.01727135f, -0.01019695f, 
    -0.01164546f, 0.00564828f, 0.00950364f, -0.04323456f, -0.02498833f, 0.02758360f, 0.01928258f, 0.00946083f, 
    0.00909762f, -0.00202464f, -0.03138882f, 0.01678192f, -0.02737642f, -0.00470207f, 0.02553879f, 0.01258242f, 
    0.00984986f, -0.02090823f, 0.00891714f, 0.02936731f, -0.02939839f, -0.03155322f, 0.00484304f, 0.00585442f, 
    -0.22082908f, 0.03375276f, -0.25606793f, -0.00206384f, 0.24953042f, -0.00782564f, -0.00854830f, 0.06434193f, 
    0.18607405f, 0.07570362f, -0.09155420f, 0.04836855f, -0.05589836f, 0.01356546f, -0.04457528f, -0.01008567f, 
    0.10518894f, 0.24569008f, 0.14661667f, 0.21015365f, 0.33000338f, 0.16297224f, 0.09521636f, 0.14680722f, 
    0.09889632f, -0.05856097f, 0.02112664f, 0.00420989f, -0.00328348f, -0.01558574f, 0.03151118f, -0.01911155f, 
    -0.00518605f, -0.06755944f, 0.14445700f, -0.03110846f, 0.05040907f, -0.02112320f, 0.06295148f, 0.09334879f, 
    -0.16973174f, -0.16824013f, -0.01836672f, 0.14932923f, 0.19523311f, -0.14527470f, -0.11010300f, 0.05845524f, 
    -0.00723219f, 0.10396851f, -0.08260209f, -0.05715092f, -0.11843768f, 0.03938230f, -0.00614783f, -0.06142635f, 
    -0.06903929f, 0.09897176f, -0.00853658f, -0.11184004f, 0.39570248f, 0.06947111f, 0.16939566f, 0.05857283f, 
    0.05884917f, -0.08399305f, 0.05604058f, 0.02356808f, -0.03964047f, 0.01997158f, -0.06380126f, -0.12888132f, 
    -0.01671300f, -0.02303181f, 0.02098721f, 0.05895026f, 0.09137033f, -0.22569539f, 0.05542213f, -0.02454468f, 
    -0.35228622f, -0.09180335f, -0.07304642f, -0.06447965f, 0.14526771f, -0.02763272f, -0.08389627f, 0.04259707f, 
    -0.08356074f, -0.04469302f, -0.00393742f, 0.16337059f, 0.12253329f, -0.04953713f, -0.20348315f, -0.12706852f, 
    0.00324660f, -0.00453771f, -0.05300797f, 0.12711141f, -0.14920086f, 0.26912767f, -0.00271637f, -0.06772123f, 
    0.16124852f, -0.04013992f, -0.02736988f, 0.04677583f, 0.01407437f, -0.01183796f, -0.02182718f, -0.03891559f, 
    0.06740894f, 0.01549826f, 0.15592308f, -0.12521613f, -0.09029549f, -0.09313606f, -0.06518999f, 0.07994826f, 
    -0.30013263f, -0.14678638f, 0.23684163f, 0.04430801f, -0.10838556f, -0.02710824f, 0.10599252f, 0.12885183f, 
    0.03505693f, 0.12673862f, 0.07001648f, 0.02720137f, 0.10644266f, 0.09257958f, -0.11744329f, -0.01448669f, 
    -0.02419723f, 0.10502244f, 0.04483479f, -0.11141100f, 0.23263593f, 0.15118240f, 0.13907012f, -0.01733051f, 
    0.01444744f, -0.00702915f, 0.02180784f, 0.06607637f, 0.06508029f, -0.04940506f, 0.04000577f, 0.04996492f, 
    0.05008734f, 0.03499791f, -0.02328667f, 0.08824671f, 0.05507073f, -0.02613797f, -0.10049368f, -0.08788431f, 
    0.04313890f, 0.06150215f, -0.26695424f, -0.12136980f, -0.27600536f, -0.02220865f, -0.15658800f, -0.11721437f, 
    -0.15637749f, 0.00834152f, -0.10337601f, -0.07021117f, 0.03427849f, 0.04905459f, -0.03095341f, -0.05965542f, 
    -0.09343492f, -0.12536962f, 0.00699700f, -0.04377599f, 0.16404092f, 0.11722805f, 0.13928600f, 0.05789906f, 
    0.02293885f, -0.03696476f, 0.03154651f, 0.08854679f, 0.04517009f, -0.03419543f, 0.00584426f, 0.06263974f, 
    -0.04361235f, 0.01215711f, 0.04817935f, -0.10598940f, -0.15005569f, -0.08086058f, -0.09784946f, -0.17065068f, 
    -0.16668215f, -0.18789758f, -0.22174941f, -0.16022128f, -0.07182460f, 0.03875194f, 0.04802433f, -0.05966290f, 
    0.05983232f, 0.11601976f, -0.13752866f, 0.01238784f, 0.00989365f, 0.07673258f, 0.08192237f, 0.17204449f, 
    0.15658776f, 0.14910366f, 0.15935379f, 0.23632237f, 0.26340726f, 0.03289976f, 0.20753068f, -0.05906028f, 
    0.05564957f, -0.05874570f, 0.06874887f, 0.07842385f, 0.12422862f, 0.17641483f, -0.13761830f, -0.23149578f, 
    -0.07960404f, -0.04269576f, 0.02804116f, -0.11647914f, -0.04425686f, -0.23797610f, 0.08686354f, -0.02687441f, 
    0.55397230f, 0.16853680f, 0.05057400f, 0.14876190f, 0.06011279f, -0.09261519f, -0.07432879f, 0.03109120f, 
    0.08133341f, -0.05203985f, -0.02150141f, 0.11310648f, 0.10751846f, 0.10667170f, 0.00635185f, 0.04319715f, 
    0.18841884f, 0.05740477f, 0.05821801f, 0.13244614f, 0.56403553f, 0.08610149f, 0.02499546f, 0.08343147f, 
    0.05528468f, -0.00488021f, -0.01415527f, 0.00118581f, 0.04965513f, -0.04830557f, -0.00120259f, -0.00226695f, 
    0.10878086f, 0.00727459f, -0.04200450f, 0.09651767f, 0.21030420f, 0.06096068f, -0.06008225f, -0.05107953f, 
    0.31101975f, 0.08628128f, 0.18875624f, 0.07684451f, -0.02111647f, -0.03959690f, 0.05154081f, 0.02256786f, 
    0.02243295f, 0.08530778f, 0.05967870f, 0.02436113f, 0.18724929f, 0.06800099f, -0.03857722f, 0.06012719f, 
    0.01799327f, -0.07463641f, -0.22715095f, -0.20661128f, -0.00405367f, -0.05170683f, -0.11944783f, -0.09168749f, 
    -0.01800485f, -0.09629585f, -0.04096847f, -0.03435184f, -0.04018665f, 0.04160008f, -0.08934882f, 0.03977224f, 
    -0.02054868f, 0.08833729f, 0.03437408f, -0.05719974f, -0.19725101f, -0.08060008f, -0.23942953f, -0.12429459f, 
    -0.22263631f, -0.25949770f, 0.12998201f, -0.16917554f, -0.06622222f, -0.13097519f, -0.06736451f, -0.05952491f, 
    0.15161622f, 0.00690575f, -0.03222020f, -0.02135930f, -0.04853030f, 0.03477567f, 0.05431685f, 0.05063815f, 
    -0.00643539f, 0.12478589f, -0.12964195f, -0.10959873f, 0.55312449f, 0.17063247f, 0.05560847f, 0.02117417f, 
    -0.03863452f, -0.13013783f, -0.01463569f, 0.06562854f, -0.05503497f, 0.00471274f, -0.01754815f, 0.01375172f, 
    0.02317370f, 0.04780838f, 0.01841684f, -0.02281657f, 0.14818169f, 0.10788638f, 0.11750163f, 0.06479669f, 
    0.02250266f, 0.13073991f, 0.16266356f, 0.15332600f, 0.08604094f, -0.06856888f, -0.01065080f, 0.04289649f, 
    0.02416041f, 0.01530696f, 0.04494514f, 0.00032939f, 0.03237704f, -0.02136526f, 0.01122191f, -0.02696348f, 
    -0.14140239f, -0.14314307f, -0.07844845f, -0.08370398f, 0.18492351f, 0.15720697f, 0.06941982f, 0.08357873f, 
    -0.01811940f, -0.15892829f, 0.06392477f, 0.09204965f, -0.11727507f, 0.13146658f, -0.02338303f, -0.01720502f, 
    0.00894935f, 0.02248538f, -0.00771903f, -0.04628518f, 0.18353076f, 0.04239464f, 0.03498268f, -0.01790629f, 
    0.10604885f, 0.01115328f, -0.17224854f, 0.12156895f, 0.30327320f, -0.06170881f, 0.08023897f, 0.09312005f, 
    0.21907102f, 0.14931834f, -0.04266188f, -0.04943845f, -0.06862269f, -0.04803561f, -0.06997132f, -0.12507589f, 
    0.09709568f, 0.15691730f, 0.22437376f, 0.04013935f, 0.12200878f, 0.16858941f, 0.09056322f, 0.08503237f, 
    0.14499624f, 0.01543093f, 0.02162340f, -0.00205325f, -0.03352394f, -0.05572187f, -0.00548231f, 0.07053494f, 
    0.03721334f, -0.02476029f, 0.01499922f, -0.07492370f, -0.12944561f, -0.10489443f, -0.20956787f, -0.10448635f, 
    -0.00926327f, -0.19464821f, -0.42123663f, -0.19353114f, -0.27904174f, -0.03594654f, -0.10865769f, -0.20671195f, 
    -0.06645740f, 0.01766995f, -0.11297403f, 0.01026229f, 0.07937158f, 0.11001285f, 0.02527406f, 0.03683210f, 
    0.01506586f, 0.01452956f, 0.11401241f, -0.01870046f, 0.20438230f, 0.04840679f, 0.07024376f, 0.01915723f, 
    -0.03464327f, -0.03761821f, -0.02970599f, 0.02785934f, 0.00431168f, 0.00322977f, 0.07640821f, -0.03875538f, 
    0.03321904f, -0.12064428f, 0.05336599f, -0.15001163f, -0.12821725f, -0.19312125f, -0.17873405f, -0.10382343f, 
    -0.12851766f, -0.02728109f, 0.06080208f, -0.09566905f, 0.00412424f, 0.02319495f, 0.24068646f, 0.08737531f, 
    -0.12187131f, 0.03617334f, -0.04042526f, -0.02634168f, 0.09054115f, 0.16320243f, 0.03293020f, 0.02490358f, 
    -0.00680308f, -0.05084799f, 0.08934620f, -0.15947656f, 0.25155693f, 0.19694383f, 0.11231082f, 0.07238819f, 
    -0.10790518f, -0.07621326f, 0.08061199f, 0.03343439f, -0.03276638f, 0.13452467f, -0.07882860f, 0.02676077f, 
    0.02758935f, 0.02352620f, -0.02396221f, 0.14388202f, 0.02442499f, 0.09512676f, -0.01368328f, -0.16185258f, 
    -0.41719323f, -0.28791681f, -0.17014521f, -0.11364487f, 0.03973384f, 0.00917014f, 0.11925447f, 0.12893620f, 
    -0.22885045f, 0.20723911f, -0.00620729f, 0.01862702f, 0.01816308f, 0.06919388f, -0.08669423f, -0.02799704f, 
    0.07239702f, 0.08862652f, 0.07073034f, 0.08796199f, -0.03433594f, -0.03514805f, -0.01275301f, 0.27348158f, 
    0.25501001f, -0.09179217f, 0.12042319f, 0.10393438f, 0.07789543f, 0.09149631f, -0.04529928f, 0.00424982f, 
    -0.00559595f, 0.02477692f, 0.00826423f, -0.06865091f, -0.00630822f, 0.13801424f, 0.47892624f, 0.09265902f, 
    0.10125806f, 0.06058734f, -0.22678809f, -0.03571444f, 0.21941993f, 0.01700619f, -0.07924742f, 0.09372379f, 
    0.17758231f, 0.12894122f, -0.03407396f, -0.05162433f, -0.07258804f, -0.02196404f, -0.02008910f, -0.03118493f, 
    0.11698381f, 0.09549734f, 0.19218571f, 0.13612391f, -0.12032140f, -0.09806142f, -0.17625268f, 0.12226606f, 
    -0.09473141f, 0.01306938f, -0.09905908f, -0.05469808f, -0.02575500f, 0.11523143f, -0.04226410f, 0.12690082f, 
    0.08319078f, -0.05327383f, -0.03988660f, -0.06142019f, -0.12846336f, -0.03568868f, -0.05077789f, -0.14812227f, 
    0.19290434f, 0.07968295f, -0.19678570f, -0.04937175f, 0.10689119f, -0.05771268f, -0.00369087f, 0.06580286f, 
    -0.01385708f, 0.16125043f, -0.07795137f, -0.04716178f, -0.01403947f, -0.00931233f, -0.03153905f, -0.06723961f, 
    0.02173857f, 0.01198871f, 0.18144996f, 0.09972021f, -0.03762737f, -0.12657334f, -0.03249411f, -0.17294919f, 
    -0.00982571f, -0.05033511f, -0.03786809f, -0.00087565f, -0.02178452f, 0.06865015f, -0.10337488f, -0.11455020f, 
    -0.02920821f, 0.01171867f, 0.01422579f, 0.00817736f, 0.17979164f, 0.26038048f, 0.05918192f, 0.02827150f, 
    -0.03910981f, 0.02441551f, 0.00453633f, -0.00890432f, -0.05699145f, -0.04841228f, 0.02753570f, 0.01673214f, 
    -0.05312775f, -0.02109227f, -0.02211694f, 0.01816856f, -0.04920844f, 0.01198783f, -0.02930417f, 0.01163732f, 
    -0.02277075f, -0.01101283f, 0.01479835f, -0.02083733f, -0.00111642f, -0.04756035f, 0.01598893f, -0.00435257f, 
    0.00370481f, -0.00320538f, 0.00564601f, -0.04562645f, -0.01661263f, -0.04562607f, 0.01735812f, -0.03873968f, 
    0.01179634f, 0.03167557f, 0.01356522f, -0.00941523f, 0.02400678f, -0.03857706f, -0.03455121f, 0.01722687f, 
    -0.01886519f, -0.03613320f, 0.00695632f, -0.03519494f, -0.00526067f, 0.02084017f, 0.01793757f, 0.00891700f, 
    -0.03274181f, -0.00418341f, 0.02131848f, -0.04395642f, 0.01936008f, 0.01636410f, -0.02492715f, -0.00617704f, 
    0.02004637f, 0.02198632f, 0.00348832f, -0.01386772f, -0.02234571f, -0.03176177f, -0.04663190f, 0.01165892f, 
    -0.04755956f, -0.00893871f, -0.01519621f, -0.01788996f, -0.02805752f, -0.00681528f, -0.02912901f, 0.02267995f, 
    0.02740505f, 0.00561963f, -0.02920194f, 0.01427352f, 0.01933982f, -0.01377835f, -0.02534470f, -0.01800860f, 
    -0.05868962f, -0.03934417f, -0.04019106f, -0.00581566f, -0.01469198f, -0.05108540f, 0.00431915f, 0.01961535f, 
    -0.04220816f, 0.01620756f, 0.02335437f, -0.05672342f, -0.02145510f, -0.00082181f, -0.01052977f, 0.00850563f, 
    -0.03232388f, -0.00015518f, -0.01545330f, 0.00066467f, 0.00860205f, -0.02652540f, -0.04260791f, -0.00190068f, 
    -0.01274846f, 0.00706595f, -0.04724397f, 0.00548568f, -0.04675589f, -0.04012959f, -0.02043947f, -0.00484638f, 
    0.00393546f, 0.00601710f, -0.04828767f, 0.01198231f, 0.01812005f, 0.02587112f, 0.00237654f, -0.03409144f, 
    0.01585414f, -0.04530512f, 0.01040367f, -0.03681571f, -0.01995451f, -0.04042726f, -0.02134648f, -0.00152964f, 
    -0.02935499f, -0.01473008f, -0.01465177f, -0.00151953f, -0.04457719f, -0.02752828f, -0.02402296f, 0.03341664f, 
    0.01888032f, 0.00316006f, -0.03301522f, -0.02025207f, 0.02350144f, -0.05150396f, -0.03202051f, -0.03072799f, 
    -0.00202603f, 0.01378384f, -0.05428030f, -0.03883991f, -0.03443629f, -0.05138486f, 0.01714019f, -0.04662309f, 
    -0.00579227f, -0.01873730f, -0.03811828f, -0.04096685f, 0.00313860f, -0.01291926f, -0.04362639f, -0.02328515f, 
    0.00669684f, 0.02258988f, -0.00403751f, -0.02377977f, -0.06101039f, -0.00338907f, -0.04905243f, -0.00317068f, 
    -0.00180581f, 0.01192085f, -0.05033443f, 0.01792216f, -0.00821469f, 0.01857234f, -0.02730639f, -0.01204478f, 
    0.01387048f, -0.02472874f, -0.01431344f, -0.02915584f, -0.04394488f, 0.02747317f, 0.00503441f, -0.03684057f, 
    -0.00801032f, -0.02384348f, -0.04202695f, -0.04705737f, -0.02374271f, -0.01903227f, -0.03496753f, -0.02996352f, 
    -0.01997848f, -0.03211662f, 0.00672497f, -0.03213123f, -0.03699180f, -0.03018160f, 0.04341466f, 0.02295876f, 
    -0.04229984f, -0.03161677f, -0.03719880f, 0.02486053f, -0.04146409f, -0.00066154f, -0.02955341f, -0.00715369f, 
    -0.01117236f, -0.04772196f, -0.01980352f, -0.00720088f, 0.01668861f, -0.00011735f, 0.00126897f, -0.01412229f, 
    0.00817014f, -0.03351021f, -0.03831549f, 0.00457209f, -0.00721544f, 0.00613584f, -0.00930054f, -0.00223376f, 
    -0.04437201f, -0.02352255f, 0.00012647f, -0.03592381f, 0.00441869f, -0.03125124f, -0.03486799f, -0.02021970f, 
    -0.04044525f, -0.00877185f, 0.00849562f, -0.05250574f, -0.02919320f, -0.03410060f, 0.03033462f, 0.00678885f, 
    0.00232259f, 0.02321594f, 0.02364799f, -0.01974278f, -0.04803826f, -0.03137001f, 0.00613325f, -0.04784596f, 
    -0.04930484f, -0.01141502f, 0.01715133f, -0.05037867f, 0.02453590f, -0.01536131f, -0.01726516f, 0.01377124f, 
    0.00354643f, 0.01626362f, 0.01694158f, -0.00509054f, -0.04980646f, -0.01771527f, -0.00833431f, -0.03566215f, 
    -0.04663619f, 0.01638064f, 0.00188444f, 0.02470426f, 0.01599354f, -0.01437216f, 0.00718210f, -0.03011337f, 
    -0.03516653f, -0.00136200f, -0.00385318f, -0.00501851f, -0.02300327f, -0.00758349f, 0.00373446f, -0.02290471f, 
    -0.01213266f, -0.04969376f, -0.03741169f, -0.00112951f, -0.04642634f, 0.04112423f, -0.04499785f, -0.00743039f, 
    0.00447615f, -0.02278356f, -0.05231535f, -0.01318080f, 0.02568504f, -0.04153311f, -0.03825425f, -0.02896115f, 
    0.00446212f, 0.02588996f, 0.00948948f, 0.01127306f, 0.00416057f, 0.02810168f, -0.01412951f, -0.01624994f, 
    -0.02878254f, 0.00483416f, -0.03020491f, 0.00258790f, -0.02150284f, 0.00756388f, -0.02102415f, -0.05307591f, 
    -0.01158379f, -0.02990443f, -0.05283352f, -0.01947479f, 0.03718497f, -0.02143494f, 0.02047407f, -0.02822246f, 
    0.03321112f, -0.01972357f, 0.02027730f, -0.02984527f, -0.03448671f, -0.01594288f, -0.02170093f, -0.01092607f, 
    0.00590739f, -0.03641687f, -0.00673021f, -0.01003077f, 0.00512732f, -0.06070406f, 0.00052818f, 0.00936668f, 
    0.00150044f, 0.01953863f, 0.01351510f, -0.00407689f, -0.00840249f, -0.04687171f, -0.04787188f, 0.02192320f, 
    -0.01025901f, -0.02173975f, 0.01299209f, -0.03106363f, -0.02637411f, -0.01802912f, -0.03225007f, -0.02811909f, 
    -0.03901881f, -0.05285358f, -0.04385813f, 0.00863895f, 0.01319550f, -0.00152174f, 0.00693083f, -0.00630384f, 
    0.01844425f, -0.03621696f, -0.00822042f, -0.02700137f, 0.02057100f, -0.06628836f, -0.00122868f, -0.02390979f, 
    0.02076858f, 0.03041885f, 0.01097337f, -0.00091428f, -0.01712542f, -0.01535182f, -0.03903927f, -0.00273476f, 
    0.01462030f, 0.01663634f, -0.04154848f, -0.01252326f, -0.05037949f, -0.03432757f, -0.02318005f, -0.01178089f, 
    0.01774644f, -0.03727543f, 0.00425563f, 0.00231400f, -0.01774302f, -0.00782744f, 0.01336248f, 0.02633971f, 
    0.02273656f, 0.00013058f, 0.01762201f, -0.03421620f, 0.01347910f, -0.00311787f, -0.01185028f, 0.01495770f, 
    0.00471806f, -0.04756228f, -0.03978608f, -0.00155745f, -0.02253670f, -0.01695339f, 0.00560116f, 0.01086162f, 
    0.00585342f, 0.00073819f, -0.00000342f, 0.00922864f, -0.03340947f, -0.01637280f, -0.00007054f, -0.00326096f, 
    -0.04416210f, 0.01310730f, -0.03900423f, 0.02557988f, -0.00097116f, 0.00102251f, -0.03252569f, -0.04344748f, 
    -0.04879788f, -0.00744124f, 0.01384515f, -0.01036610f, -0.03974553f, -0.01237666f, -0.04704379f, -0.00578484f, 
    -0.03917082f, -0.00426313f, -0.01726083f, -0.00165671f, -0.03577465f, -0.03327236f, -0.00120961f, -0.04954203f, 
    0.03295582f, 0.01875771f, -0.02114260f, -0.04612789f, -0.01459757f, -0.01757642f, 0.02387206f, -0.04838507f, 
    -0.02517796f, -0.00468554f, -0.05524423f, -0.01429576f, -0.01160635f, -0.02361145f, 0.00860643f, 0.01678703f, 
    -0.04238106f, -0.03612889f, -0.03275180f, 0.01363488f, 0.00510392f, -0.01751409f, 0.03289941f, -0.01396607f, 
    -0.03330323f, -0.03776103f, -0.00740733f, -0.04052433f, 0.02888855f, 0.02708688f, 0.02286654f, -0.00419448f, 
    0.02656668f, -0.00173232f, -0.02136682f, -0.03687412f, -0.00104242f, 0.00190300f, 0.04388431f, 0.04149005f, 
    0.00044753f, 0.00258995f, -0.02344263f, -0.02327373f, -0.06251227f, -0.03745982f, -0.03294617f, -0.02721422f, 
    -0.02820589f, -0.00739318f, -0.04146140f, -0.03119573f, -0.02941563f, 0.00829798f, -0.00062364f, -0.00456499f, 
    0.00316607f, 0.00215013f, -0.00016832f, -0.00006956f, 0.01662669f, 0.01829443f, 0.01952427f, 0.02414102f, 
    0.00450310f, 0.00349156f, -0.01545623f, -0.00924442f, -0.00243760f, 0.00001092f, 0.01388808f, -0.00259412f, 
    0.02400753f, -0.01227167f, -0.01171114f, -0.00254246f, -0.00171450f, -0.03315447f, -0.02086806f, -0.02977293f, 
    0.02130041f, 0.01721909f, 0.01927532f, -0.02873439f, -0.01167699f, -0.01305240f, -0.04137874f, -0.01741775f, 
    -0.01154839f, -0.02307060f, 0.03106420f, -0.04563026f, 0.01969281f, 0.00268699f, -0.04188335f, 0.00406632f, 
    -0.04682374f, 0.02000315f, -0.04540599f, 0.01625361f, 0.00526023f, 0.01924650f, 0.00022844f, 0.01109315f, 
    -0.02958927f, -0.04227857f, -0.05125114f, -0.02881317f, -0.03765931f, 0.02255770f, -0.00261868f, -0.03306592f, 
    -0.03761049f, 0.00399784f, -0.00020951f, 0.00224355f, 0.00660558f, -0.05278410f, -0.06494436f, 0.02243187f, 
    -0.02675224f, 0.02011002f, -0.03069643f, -0.04698421f, -0.05029663f, 0.00395279f, 0.02529527f, 0.00273555f, 
    -0.02675723f, -0.05250803f, -0.00595529f, -0.04766205f, 0.01825802f, -0.03884491f, -0.00807454f, -0.03959158f, 
    -0.03835250f, -0.02141818f, -0.02798402f, -0.04709395f, -0.03083941f, 0.02380645f, -0.02076376f, -0.02409653f, 
    0.00886244f, 0.00889469f, 0.01776884f, -0.02903336f, -0.01810338f, 0.02237073f, 0.01434629f, 0.01371887f, 
    0.01774874f, -0.00467988f, -0.04092576f, -0.04756396f, -0.04497551f, 0.00339872f, -0.04053234f, 0.00243711f, 
    -0.04675491f, 0.00081697f, -0.03771267f, -0.01290560f, -0.01254346f, -0.01308032f, 0.02506827f, 0.00709049f, 
    -0.03118161f, -0.03987688f, 0.00510414f, 0.01404378f, 0.01057814f, -0.00177262f, -0.04660853f, -0.02696120f, 
    -0.02607245f, -0.03372930f, -0.04187295f, -0.04822549f, -0.03321812f, -0.03108957f, -0.00763396f, 0.00918515f, 
    -0.00207019f, -0.05217382f, -0.02285875f, -0.02596828f, -0.06034876f, -0.00301774f, -0.04221563f, -0.02132553f, 
    -0.01236512f, -0.03073088f, 0.00376107f, -0.03541234f, 0.00699823f, -0.04595290f, -0.05154513f, 0.02227129f, 
    0.28918374f, 0.03021145f, 0.02178941f, -0.08307023f, 0.04578346f, 0.12027907f, -0.10898662f, -0.28568557f, 
    0.05746578f, 0.11426666f, 0.03511175f, 0.03932415f, 0.05824109f, -0.02889854f, 0.05702434f, -0.10821033f, 
    0.00245831f, -0.18336956f, -0.00002184f, 0.05124385f, 0.00916187f, 0.13236383f, -0.10543361f, -0.14801255f, 
    0.08429126f, -0.02001950f, 0.11630597f, -0.13115577f, 0.03543300f, -0.05677815f, 0.04596253f, -0.04455102f, 
    -0.11679190f, 0.03584497f, -0.00419043f, 0.11101885f, 0.07099953f, -0.09000492f, 0.12837681f, -0.04944489f, 
    0.21513537f, 0.19756505f, 0.24324457f, 0.10288126f, -0.04285987f, 0.02348579f, -0.00073571f, -0.03813201f, 
    0.18073292f, 0.15343596f, -0.03696375f, 0.05148673f, -0.03901251f, -0.02308047f, -0.00353576f, 0.08698811f, 
    0.13373730f, 0.02529812f, 0.15388104f, 0.02701284f, -0.08363643f, 0.30395761f, -0.09545287f, 0.04350840f, 
    0.00178580f, 0.10703208f, -0.15333813f, -0.08943075f, -0.02662998f, -0.05772161f, 0.00289142f, -0.01859955f, 
    -0.04401024f, -0.01286905f, -0.13928385f, -0.10316426f, 0.06038326f, 0.15140407f, 0.02737561f, -0.03857582f, 
    -0.51503772f, 0.10501504f, -0.02595270f, 0.07590485f, -0.15921085f, -0.06262118f, -0.07590892f, -0.15062924f, 
    -0.25629503f, 0.07603018f, -0.01623940f, -0.03406371f, 0.04703060f, 0.07696140f, 0.01733598f, 0.17283516f, 
    -0.06218387f, 0.01051236f, 0.12095670f, -0.09063257f, 0.25890672f, -0.08936504f, -0.19758782f, 0.12123107f, 
    -0.05254981f, -0.01564088f, 0.02954850f, 0.10746607f, -0.09805412f, 0.10209815f, 0.00911339f, 0.11892678f, 
    0.05531760f, 0.06739586f, 0.02167608f, -0.03552904f, 0.01051611f, 0.01542349f, 0.00878070f, 0.19489449f, 
    0.34413558f, -0.08682004f, -0.26324037f, -0.11306249f, 0.06202927f, 0.08405022f, -0.08392971f, -0.00103791f, 
    0.32426181f, 0.00830928f, 0.04654804f, -0.03273104f, 0.12870057f, -0.03910171f, 0.05343553f, 0.05755164f, 
    0.00605095f, -0.04731936f, -0.11762929f, -0.07445709f, 0.21593386f, -0.03875548f, -0.03679430f, 0.04549802f, 
    -0.02030693f, 0.06388336f, 0.01280887f, -0.03031060f, -0.12429728f, 0.05599673f, 0.03799271f, 0.04364266f, 
    0.03450860f, 0.02253462f, -0.06668387f, 0.07253566f, 0.01981115f, 0.12672549f, -0.04915884f, 0.16047607f, 
    -0.02047227f, -0.31752875f, -0.21155383f, 0.09820869f, -0.09557225f, -0.02793646f, -0.00820980f, -0.01748234f, 
    0.09706832f, -0.01486808f, 0.27094993f, 0.04278926f, -0.10953517f, 0.02215032f, 0.02398204f, -0.02892097f, 
    0.06051537f, 0.03937310f, -0.06197027f, -0.02020044f, -0.10801864f, -0.00999035f, -0.03295750f, -0.05800723f, 
    -0.04416368f, -0.03338235f, -0.04901583f, -0.12615603f, -0.12610458f, -0.09748428f, 0.12680653f, 0.04830443f, 
    -0.08124831f, 0.08619584f, 0.09791225f, -0.00751116f, -0.02103254f, -0.09182750f, 0.03408789f, 0.06744137f, 
    0.03017758f, 0.09076439f, 0.34839633f, 0.16430417f, -0.12372377f, -0.15289982f, -0.13409662f, -0.07142927f, 
    0.08803143f, -0.07480181f, 0.13321279f, -0.10123599f, -0.00287094f, -0.08797115f, 0.04545918f, 0.14865106f, 
    -0.03142304f, -0.12246949f, 0.00108700f, -0.07311132f, -0.29980254f, 0.10276204f, -0.17426695f, -0.05414795f, 
    -0.16843218f, 0.03693475f, -0.12080842f, -0.15587039f, -0.16872241f, 0.01736855f, -0.05450362f, -0.10575842f, 
    0.02379220f, 0.02855499f, -0.06270298f, 0.06856604f, -0.00318995f, -0.04184690f, -0.00804819f, 0.01242294f, 
    0.11944795f, 0.05497617f, 0.19039103f, -0.03945350f, 0.04344301f, -0.06208117f, -0.05420034f, -0.09938812f, 
    -0.05148795f, 0.07461322f, -0.05905169f, -0.07183748f, -0.03398738f, -0.03894584f, 0.02670717f, 0.03905391f, 
    -0.02919079f, 0.02968406f, 0.16776964f, 0.05154099f, 0.39617115f, 0.04999255f, 0.02588727f, -0.22708705f, 
    -0.06656390f, -0.11329605f, -0.07633326f, -0.06590182f, -0.02386931f, -0.05709955f, -0.00959608f, -0.05396429f, 
    -0.04870581f, -0.07336290f, 0.08435889f, 0.05106202f, 0.13027549f, -0.00117557f, 0.07804478f, -0.10457952f, 
    -0.01558355f, 0.21219762f, -0.10903299f, -0.22573332f, 0.22911249f, -0.12960197f, -0.15211849f, -0.05031965f, 
    0.00131763f, -0.14795850f, 0.06614315f, -0.05650059f, -0.13584389f, 0.07243773f, -0.07667151f, -0.01069803f, 
    -0.04412823f, -0.03879083f, -0.08501376f, -0.16750892f, -0.00499683f, -0.22734655f, -0.15346293f, 0.02734610f, 
    -0.19711791f, -0.04885048f, -0.04188716f, -0.04572071f, 0.10295038f, 0.02536076f, 0.10562424f, 0.06441434f, 
    -0.01917043f, 0.04287161f, -0.03480228f, -0.06439712f, 0.02619138f, -0.03800752f, -0.02162328f, -0.00236234f, 
    0.39331695f, -0.44244456f, 0.26502019f, -0.10965841f, -0.15854609f, 0.07923479f, 0.09228367f, 0.06691844f, 
    0.09680105f, -0.00610957f, 0.08397042f, -0.04271156f, 0.01377646f, 0.01752210f, -0.08729447f, 0.01460143f, 
    0.11912333f, 0.04997917f, 0.14704606f, 0.09687161f, -0.06964249f, 0.20704801f, 0.06056583f, 0.06179936f, 
    0.11459907f, 0.06280666f, -0.02560678f, -0.05247531f, 0.03556464f, -0.03791008f, 0.01001562f, -0.01387586f, 
    -0.05901009f, -0.05449322f, -0.01328718f, 0.06411161f, 0.06836556f, 0.07877111f, 0.07048280f, -0.07224437f, 
    -0.05055097f, 0.13953845f, 0.00509086f, -0.00905454f, 0.02138609f, -0.04796619f, -0.04597320f, -0.20088382f, 
    -0.13353851f, -0.14258909f, -0.09681600f, -0.12644333f, -0.04413163f, 0.01481541f, 0.07889631f, 0.01827822f, 
    -0.04222959f, -0.15981068f, 0.05903432f, -0.03008244f, 0.03838833f, 0.19667734f, -0.20309526f, -0.05317419f, 
    0.05510173f, 0.22554180f, -0.10823321f, -0.06126267f, 0.03142503f, 0.02291488f, -0.05794718f, -0.00047658f, 
    0.00786229f, -0.01251904f, -0.00633831f, 0.11744104f, 0.08366878f, 0.10448765f, 0.05878448f, 0.02608557f, 
    -0.01187350f, -0.10721929f, -0.00097540f, 0.07213964f, -0.35324097f, 0.14119315f, -0.27993104f, 0.00744458f, 
    -0.14401597f, 0.15954813f, 0.01521971f, 0.04716754f, 0.07084557f, -0.02079803f, 0.01492504f, -0.03976711f, 
    0.05413573f, -0.03081556f, -0.12196537f, 0.08921917f, -0.06325272f, -0.02372413f, -0.09365921f, 0.02890002f, 
    0.04969113f, -0.07795522f, -0.07188128f, -0.07869390f, -0.06355088f, -0.12280144f, 0.07865515f, -0.06441689f, 
    -0.00537806f, 0.00696370f, 0.03666544f, 0.08139578f, 0.11968216f, -0.08372982f, 0.01793394f, 0.02588853f, 
    0.07683130f, -0.20220777f, 0.05220998f, 0.18545853f, -0.08572710f, -0.07526902f, 0.07342454f, 0.00253998f, 
    0.25860083f, -0.08893788f, 0.24116266f, -0.03378711f, 0.03328735f, -0.01587629f, -0.02444297f, 0.07142817f, 
    -0.04444453f, -0.00279042f, -0.01917776f, -0.05293845f, -0.01834559f, -0.10976040f, 0.05853157f, -0.03761782f, 
    -0.05323029f, -0.04377751f, -0.06497341f, -0.02320229f, -0.09695383f, -0.11720689f, 0.27199200f, 0.20837510f, 
    0.01325876f, 0.15177543f, 0.10899181f, -0.09050328f, 0.00674326f, 0.02587342f, -0.00285748f, 0.08060031f, 
    -0.15122530f, 0.07229429f, -0.45194632f, 0.33718568f, -0.12390969f, -0.02622976f, -0.19404691f, -0.16451414f, 
    -0.02977446f, -0.16515703f, 0.06451709f, -0.08155401f, -0.04812142f, 0.07797003f, 0.12994753f, 0.18562694f, 
    -0.02053204f, 0.06533469f, -0.10570230f, -0.06755103f, 0.00180777f, 0.09635007f, -0.08142949f, -0.13579193f, 
    0.11772434f, 0.11623420f, -0.01622995f, 0.00281129f, 0.07654113f, -0.12468835f, 0.05385065f, 0.00240820f, 
    -0.04132280f, -0.01212343f, 0.01142018f, 0.19074419f, 0.07737043f, 0.04570702f, 0.06137535f, -0.03067886f, 
    -0.09636519f, 0.06949630f, 0.04749864f, 0.02987303f, -0.23899259f, 0.13951628f, -0.10413484f, -0.05499464f, 
    0.25321120f, -0.06460712f, 0.03926065f, 0.08532248f, 0.07905670f, -0.04882852f, 0.07661211f, -0.10574804f, 
    -0.04495210f, 0.02904288f, -0.09051700f, -0.04316704f, -0.00141320f, -0.05001974f, 0.14270163f, 0.35083389f, 
    -0.17668124f, 0.03829887f, -0.19864181f, -0.01846390f, 0.20665023f, -0.03296788f, 0.07536596f, 0.04113259f, 
    0.07601248f, -0.03987148f, 0.07601117f, -0.07746169f, 0.12129901f, 0.15865339f, -0.07418035f, 0.08436061f, 
    0.08135194f, 0.03058385f, 0.04147311f, 0.12229310f, -0.19954813f, 0.16486180f, -0.16399959f, -0.11349642f, 
    -0.04324665f, 0.13121562f, 0.02720883f, 0.04536767f, 0.04500525f, -0.03313741f, 0.00444584f, -0.06753900f, 
    -0.07911750f, -0.01800816f, -0.01273041f, 0.07225548f, 0.01637565f, -0.15507665f, -0.30902338f, 0.04969463f, 
    -0.02576011f, 0.02639972f, 0.07318464f, 0.17949790f, 0.25678268f, 0.11480416f, 0.04177670f, -0.10270782f, 
    0.07239064f, -0.03497834f, -0.00362500f, -0.01047643f, 0.09390011f, 0.03943216f, -0.05372328f, 0.13367590f, 
    0.03684258f, -0.00425389f, -0.00491723f, 0.12562931f, -0.31477743f, 0.13500246f, -0.09585439f, -0.08285935f, 
    -0.04231856f, 0.12556347f, -0.02760539f, -0.02077639f, -0.00551095f, -0.01939481f, -0.04582207f, 0.01269456f, 
    0.07141172f, -0.12200221f, 0.05652016f, 0.10317722f, -0.07688077f, 0.01235786f, 0.27627209f, 0.08188154f, 
    -0.02376881f, -0.01579645f, 0.04613117f, 0.03974979f, 0.14547125f, -0.11459102f, 0.17857131f, -0.07863601f, 
    -0.05256419f, -0.04496815f, 0.01414455f, 0.02763082f, 0.03973562f, -0.01331143f, -0.08645655f, 0.03998768f, 
    -0.28443500f, 0.04765554f, -0.23477727f, 0.06879912f, 0.06025976f, -0.12448318f, 0.02812127f, -0.00466633f, 
    0.00332105f, -0.07387752f, 0.01999113f, -0.01465234f, -0.06254862f, -0.04415229f, -0.05236442f, 0.15624404f, 
    0.07594785f, 0.08635728f, 0.05100001f, -0.03760535f, -0.04275632f, 0.08425122f, 0.23965845f, 0.09368739f, 
    -0.08380629f, -0.17697752f, -0.07709543f, -0.21231945f, 0.05762981f, -0.04399969f, 0.03078294f, -0.04069722f, 
    -0.01121873f, 0.04503974f, 0.02322890f, 0.04202876f, 0.01231240f, -0.00480142f, 0.09118115f, 0.03672614f, 
    -0.20727277f, -0.18183529f, -0.14683542f, 0.21711078f, 0.08720823f, 0.11160203f, 0.02983319f, -0.02116262f, 
    0.07965776f, -0.09439615f, 0.01398292f, -0.02518647f, -0.08246700f, 0.09476826f, 0.06946135f, 0.03313753f, 
    -0.04080833f, 0.14897582f, -0.00095885f, -0.00097884f, 0.26691008f, -0.03662362f, 0.40703169f, -0.18188632f, 
    0.03020720f, -0.09804156f, 0.00109737f, -0.10526760f, 0.04304130f, 0.01381178f, 0.04710994f, -0.04886200f, 
    0.06408932f, -0.05151491f, -0.06280564f, -0.11996938f, 0.08451840f, 0.00026637f, -0.13525666f, 0.01713901f, 
    0.75054276f, -0.07320826f, 0.01829300f, -0.23397484f, 0.09128221f, 0.05332132f, 0.17178148f, -0.09388818f, 
    0.13802461f, -0.04481012f, 0.00889104f, -0.03797217f, 0.09101110f, -0.05363042f, 0.07985459f, 0.07052784f, 
    -0.06973255f, -0.03121269f, 0.06915948f, 0.07032789f, 0.47027990f, 0.25740203f, -0.35913959f, -0.15312271f, 
    0.11776084f, -0.06069487f, 0.09584241f, 0.01112328f, 0.04069868f, 0.08673234f, 0.02849602f, 0.09639616f, 
    0.02657266f, -0.06591328f, 0.15512714f, 0.00771425f, -0.06409533f, 0.07220653f, -0.05154388f, 0.11849432f, 
    -0.22693479f, 0.22915077f, 0.33229175f, 0.15751569f, 0.17534664f, 0.25526506f, 0.00324553f, 0.03369692f, 
    0.06628704f, -0.05917910f, 0.03481150f, 0.09761079f, 0.08672507f, 0.02379277f, -0.04432306f, -0.06578749f, 
    -0.01167272f, 0.01775572f, -0.00420135f, -0.14745350f, -0.02039764f, 0.21916287f, -0.05710122f, -0.12281954f, 
    -0.02318427f, 0.10718627f, 0.03029693f, 0.10619560f, -0.04293826f, 0.04682682f, -0.05708151f, 0.07441816f, 
    0.03481164f, -0.11130784f, 0.04135169f, 0.14891039f, -0.00180626f, -0.00661738f, -0.00372613f, -0.08044687f, 
    -0.23323369f, -0.05711599f, 0.11797650f, 0.00930825f, 0.29300624f, 0.01833246f, 0.06050052f, 0.03089409f, 
    -0.08933420f, 0.13201870f, -0.03170498f, 0.04861265f, -0.01626302f, -0.00482774f, 0.01231269f, 0.01829573f, 
    -0.02600786f, -0.05381986f, -0.02016697f, 0.03297769f, -0.03945550f, -0.10161415f, 0.05623111f, -0.01855139f, 
    -0.01479522f, 0.03221549f, -0.04813243f, -0.06032091f, -0.07078691f, -0.09485320f, -0.02965853f, 0.03648975f, 
    -0.14675789f, -0.04539806f, 0.00451512f, -0.03156044f, -0.00498133f, 0.22070959f, -0.14400266f, -0.16151731f, 
    -0.16660541f, -0.00584591f, 0.17593865f, 0.14837343f, 0.21632543f, 0.16911234f, 0.09787788f, -0.01017384f, 
    0.04099003f, -0.08970885f, 0.08675396f, 0.06025374f, 0.02112814f, 0.01344503f, 0.03313934f, 0.01460684f, 
    0.07509042f, 0.08408060f, 0.06320676f, 0.06078574f, 0.10527730f, -0.38118538f, 0.34652692f, -0.27861506f, 
    0.33366564f, 0.08964723f, 0.08646604f, -0.16049023f, 0.13616632f, -0.08754412f, 0.01334926f, -0.13908988f, 
    -0.03945433f, 0.05726548f, 0.01921440f, -0.13266775f, 0.05926086f, -0.13816951f, -0.03481849f, 0.09441644f, 
    0.00332053f, 0.00738752f, 0.39277074f, -0.09254702f, 0.06351178f, -0.06040368f, -0.01969843f, -0.15068761f, 
    0.07310127f, -0.09611390f, -0.05102614f, 0.04291905f, 0.03974890f, -0.10276860f, -0.07947557f, 0.10947970f, 
    -0.01244485f, 0.03258074f, 0.07807131f, 0.03637955f, 0.12882814f, 0.03135435f, 0.13705400f, 0.03085782f, 
    -0.15838678f, 0.02156832f, 0.06513450f, -0.06922632f, -0.00413047f, -0.03728619f, -0.08991468f, -0.05328711f, 
    0.02746050f, 0.16969368f, -0.03013961f, 0.13666394f, 0.15753843f, 0.24726108f, 0.06513792f, -0.10825592f, 
    -0.18719229f, 0.04071983f, -0.06724273f, -0.23731674f, -0.60615951f, 0.14762975f, -0.00205309f, 0.01027785f, 
    0.04500857f, 0.17129627f, 0.02388153f, 0.07596764f, -0.08149549f, -0.11128440f, -0.08905271f, 0.05617541f, 
    0.02074611f, 0.16782545f, -0.10749248f, -0.20826526f, -0.31791231f, -0.21058148f, -0.14525080f, 0.20976427f, 
    0.22963369f, -0.00565321f, -0.01822732f, -0.01370362f, 0.01658693f, 0.01009576f, -0.06165632f, 0.02096155f, 
    -0.08782633f, 0.00587499f, 0.02466129f, 0.01343501f, -0.13504370f, -0.05805059f, -0.12250274f, -0.18276273f, 
    -0.24071868f, -0.11139226f, -0.05551409f, 0.24588445f, 0.13969032f, 0.09578564f, -0.11103391f, 0.01908967f, 
    0.01039020f, -0.15830843f, 0.04245770f, 0.05443250f, -0.09065448f, -0.00409017f, -0.02741143f, 0.09991790f, 
    -0.04034401f, 0.15023208f, 0.03999854f, -0.15613130f, -0.00033619f, -0.01606904f, 0.44874117f, -0.36203375f, 
    -0.12742589f, -0.11557497f, -0.05880506f, -0.14195326f, 0.10746852f, -0.01646382f, 0.01799983f, -0.03931375f, 
    0.06083422f, -0.00317832f, 0.00284206f, 0.00224003f, 0.03496351f, 0.01539977f, 0.03284532f, 0.03557570f, 
    0.07886598f, -0.14761353f, -0.02371533f, -0.22981742f, -0.25301805f, 0.06725794f, -0.13370360f, -0.23518734f, 
    0.06348281f, -0.00639471f, -0.00247284f, 0.01159598f, 0.13802789f, -0.15946898f, -0.10829669f, 0.12759610f, 
    -0.18255529f, -0.26925814f, 0.12384145f, 0.04113027f, 0.60912561f, 0.20920174f, 0.08962896f, -0.35293010f, 
    0.14034733f, 0.02418929f, -0.13194156f, -0.01106298f, -0.02495428f, 0.02433760f, 0.14875446f, 0.08939978f, 
    0.08471976f, -0.09628144f, -0.08059485f, 0.05591919f, 0.08319590f, -0.06788550f, 0.15791750f, 0.06417737f, 
    -0.18177961f, -0.24401885f, -0.24236178f, 0.00874072f, 0.22829260f, 0.00119683f, -0.01710959f, 0.05202384f, 
    -0.01836959f, -0.09674751f, 0.01255730f, -0.01303982f, -0.03268320f, -0.05280696f, -0.01396305f, -0.06069246f, 
    0.06766283f, -0.08191273f, 0.07902544f, -0.03169543f, 0.08690572f, 0.00486802f, 0.00699868f, -0.12445779f, 
    -0.04540174f, 0.00357016f, -0.02152107f, -0.02325652f, 0.01478548f, 0.04859487f, -0.05707570f, -0.03790748f, 
    -0.09760468f, 0.06628976f, 0.00871151f, -0.00876632f, -0.09207598f, -0.11726075f, 0.01528975f, -0.13486482f, 
    -0.26536435f, -0.01500703f, 0.23244582f, 0.20964491f, 0.33417976f, 0.06559927f, 0.01419992f, 0.13100022f, 
    0.06006867f, -0.01145753f, -0.00641954f, 0.00185089f, 0.05489812f, 0.03721457f, 0.00883141f, -0.01343640f, 
    -0.07381279f, 0.02261885f, -0.04639603f, -0.03753715f, -0.06581540f, -0.02877811f, -0.17553590f, -0.13799919f, 
    -0.13227969f, 0.00154148f, -0.00932027f, 0.00397118f, 0.00172608f, -0.05214192f, 0.05009778f, 0.02229812f, 
    0.03609888f, -0.17660645f, 0.07485433f, -0.05595944f, -0.09840190f, 0.02270923f, -0.15937588f, -0.14837879f, 
    0.40297180f, 0.10637596f, -0.05640386f, -0.22272064f, 0.17366230f, 0.30855086f, 0.11409596f, 0.04229190f, 
    -0.24297549f, 0.04895752f, -0.05112670f, 0.07010335f, 0.19648150f, 0.18041459f, 0.03449696f, 0.08792856f, 
    0.08401112f, -0.07791075f, 0.10459302f, -0.00996566f, -0.10667274f, 0.15128182f, 0.27971235f, -0.34525365f, 
    -0.03898008f, -0.02021203f, 0.10094190f, -0.13207352f, 0.07633348f, 0.07362078f, 0.01909981f, 0.00326631f, 
    -0.05879285f, 0.05759803f, 0.03907261f, 0.13274905f, -0.10925668f, 0.05599568f, 0.03429331f, -0.00738793f, 
    0.18313687f, 0.06684572f, 0.05569481f, 0.11719500f, 0.33537817f, 0.18555386f, 0.03894779f, -0.06643145f, 
    -0.28451890f, 0.08626293f, 0.07432810f, 0.10543601f, 0.06392832f, 0.07601072f, -0.02086676f, 0.03694607f, 
    0.17823584f, 0.05747635f, 0.00441037f, 0.05791240f, -0.23400451f, -0.17449802f, -0.18013307f, 0.15236990f, 
    0.09856632f, -0.09805133f, 0.03875822f, -0.11622814f, -0.01692900f, 0.00069750f, -0.08603842f, 0.00589814f, 
    -0.06400129f, -0.01939378f, 0.00357677f, -0.06461452f, 0.12362131f, 0.21109773f, -0.09441978f, 0.04056165f, 
    0.02042546f, -0.28504238f, -0.04423208f, -0.08890323f, 0.19113851f, -0.02863648f, 0.02709592f, -0.06325716f, 
    0.13813573f, -0.10427299f, -0.03641327f, 0.00675383f, 0.04149161f, -0.05547189f, 0.01780223f, 0.00912470f, 
    0.07808942f, -0.08127435f, 0.05721375f, 0.05464607f, -0.14212595f, -0.19662912f, -0.18724845f, 0.18573436f, 
    0.20354399f, 0.07250874f, 0.03507338f, -0.07113358f, -0.05478784f, 0.08700365f, 0.04522696f, 0.10534862f, 
    0.06789447f, -0.00631625f, -0.03018926f, 0.06577654f, 0.04205677f, 0.11979668f, 0.03619537f, -0.07522173f, 
    0.13742295f, -0.36827582f, 0.13175385f, -0.27860788f, 0.32820365f, 0.06223802f, 0.15268254f, -0.21986587f, 
    0.18908130f, -0.06030547f, -0.03114982f, -0.04081656f, -0.00889308f, -0.01368502f, 0.07683182f, -0.01750346f, 
    -0.01104224f, -0.12731481f, 0.09138144f, -0.00149480f, -0.20682880f, -0.11251347f, 0.11495772f, 0.26487732f, 
    0.10086495f, 0.09949632f, -0.05605483f, -0.03404996f, 0.14183959f, -0.12143800f, -0.05363354f, 0.05622708f, 
    -0.08115783f, 0.08658934f, -0.04887606f, 0.00626087f, 0.02694880f, 0.18089280f, 0.06916267f, 0.00836881f, 
    -0.12274855f, -0.02434267f, -0.37517953f, -0.51710606f, -0.16717933f, 0.05987952f, 0.06085001f, -0.08895920f, 
    0.21279962f, 0.31079075f, -0.03352894f, -0.01277802f, 0.06292411f, 0.04250694f, -0.03369346f, -0.10498499f, 
    0.16629127f, -0.03423187f, -0.15411954f, 0.09144077f, 0.17581908f, 0.17273556f, 0.19695815f, 0.10321080f, 
    0.18258339f, 0.02247623f, -0.06079351f, -0.00961117f, 0.05928672f, 0.02871057f, 0.11107916f, 0.05577614f, 
    -0.04044665f, 0.04592114f, 0.04369558f, 0.07702126f, 0.15135780f, -0.10329626f, 0.08384624f, -0.02906958f, 
    -0.06825254f, 0.12714486f, -0.05652625f, -0.10802608f, -0.07272634f, -0.00293536f, -0.03641584f, -0.05586117f, 
    0.21923271f, 0.27963194f, -0.03944019f, -0.02438788f, -0.00609738f, 0.03498681f, -0.12003411f, -0.02775085f, 
    0.04920471f, 0.00924640f, -0.29158503f, -0.05724290f, 0.08564398f, 0.18894948f, 0.16720279f, 0.15059297f, 
    0.20357886f, -0.09135545f, -0.12960725f, 0.06708534f, 0.04564676f, 0.05258657f, 0.00706129f, 0.02388496f, 
    -0.02165801f, 0.04595685f, 0.01909547f, 0.15103734f, 0.00040266f, 0.11303307f, -0.01832669f, -0.16802336f, 
    -0.33764651f, 0.04850892f, 0.08384075f, 0.01253541f, -0.13435560f, 0.09650770f, -0.05267086f, 0.07056265f, 
    0.02117316f, 0.16403854f, 0.06830160f, 0.07603541f, 0.05981922f, -0.04484642f, -0.07840615f, -0.23821595f, 
    0.11543557f, -0.00648839f, 0.14045072f, 0.00324312f, -0.15931337f, 0.17294450f, 0.15285388f, 0.03225895f, 
    0.03662764f, -0.09838485f, -0.08836037f, 0.09781101f, -0.07379396f, 0.11750462f, 0.16193360f, -0.17934208f, 
    0.02728455f, 0.05483826f, 0.04864352f, -0.15884329f, 0.14414483f, 0.01575862f, 0.13275224f, 0.10442579f, 
    0.54248035f, 0.12966600f, -0.28601816f, -0.05735807f, 0.18207870f, -0.10610233f, -0.06214331f, 0.03142278f, 
    0.26314425f, -0.08817929f, 0.01268178f, 0.09389743f, 0.16228543f, -0.05764711f, -0.02887136f, 0.16740172f, 
    -0.06669009f, 0.00033065f, -0.13539924f, -0.05669313f, 0.12418018f, 0.10603915f, 0.11269964f, 0.11522863f, 
    0.07652342f, 0.02562245f, -0.00919083f, 0.02841112f, 0.07239970f, 0.01941739f, 0.09097019f, 0.11550800f, 
    0.16393341f, 0.05700067f, -0.06986662f, 0.16654894f, 0.01456266f, 0.05146950f, 0.01691766f, 0.08619418f, 
    0.09207453f, -0.18462609f, -0.02042402f, 0.00376751f, -0.11551791f, -0.07148688f, -0.02458141f, -0.01098472f, 
    0.01189624f, -0.06695890f, 0.02491935f, -0.07783721f, -0.08837956f, -0.01802251f, -0.00955600f, -0.08296860f, 
    -0.02325781f, 0.02091333f, -0.03139076f, -0.04806806f, 0.00491485f, 0.00118507f, 0.09221840f, 0.04439946f, 
    0.11544344f, 0.06928696f, -0.04734430f, 0.02754455f, 0.02367182f, 0.03825475f, 0.14938626f, 0.11083603f, 
    -0.01645742f, 0.04204993f, -0.04746328f, -0.03259856f, -0.00232184f, -0.07130489f, 0.05548376f, -0.03390746f, 
    -0.16903515f, -0.09012549f, -0.34294584f, -0.20003322f, -0.41123101f, -0.05089369f, -0.00274102f, -0.28758726f, 
    -0.00476775f, 0.16294920f, -0.03706383f, -0.08262678f, 0.03495330f, -0.20390008f, -0.14132720f, 0.18561736f, 
    0.03211078f, -0.12535904f, -0.08496308f, -0.02205347f, -0.20899270f, 0.01912290f, -0.04577193f, -0.06202935f, 
    0.10611902f, -0.00684016f, -0.08760992f, -0.02380606f, -0.09924103f, 0.21447277f, -0.01564425f, -0.03504128f, 
    -0.01415292f, 0.00807681f, -0.00863929f, -0.03708571f, -0.01482827f, -0.15079752f, -0.12377549f, -0.18675835f, 
    0.21114323f, 0.26657119f, 0.18450062f, 0.17274240f, 0.22704309f, -0.05656598f, -0.10636102f, 0.08675950f, 
    0.05106467f, 0.07508423f, 0.02325316f, 0.10874800f, 0.01284094f, 0.05524966f, 0.01204927f, 0.00929682f, 
    0.02547813f, -0.04607972f, 0.01576264f, 0.05559171f, 0.40819728f, 0.28470397f, 0.17432311f, 0.02161071f, 
    0.00295598f, -0.03562553f, -0.03807029f, 0.00826595f, 0.06999933f, 0.09522608f, 0.10866342f, 0.24879831f, 
    -0.05002487f, -0.05190014f, -0.07983549f, -0.09000223f, 0.00266078f, -0.04384050f, 0.02610525f, -0.01411959f, 
    0.30388090f, 0.18547119f, 0.08493029f, 0.14415565f, 0.14594153f, -0.04998148f, 0.00896629f, 0.05494333f, 
    -0.00574480f, -0.00624660f, 0.09578813f, 0.14265469f, -0.00025208f, 0.07384891f, 0.02055508f, 0.01400292f, 
    -0.23378083f, -0.21411940f, -0.18650353f, -0.13343820f, -0.12215924f, -0.09406864f, -0.07063255f, -0.06804670f, 
    -0.10392445f, 0.00412529f, -0.00710720f, 0.00627119f, 0.07294694f, 0.06648169f, 0.03322521f, 0.01855088f, 
    -0.06630117f, 0.05139034f, -0.05583142f, -0.02531558f, -0.02223642f, -0.01570394f, 0.01386143f, -0.00335502f, 
    0.21715017f, -0.45994800f, -0.29419085f, -0.47220379f, -0.30704620f, 0.07443004f, -0.06132263f, -0.16604672f, 
    0.03814057f, 0.07623415f, 0.01001662f, 0.01584546f, 0.07337923f, -0.02077703f, -0.11603161f, -0.05459330f, 
    0.02379765f, -0.01155070f, -0.01300240f, 0.01213600f, 0.28594983f, 0.24037765f, 0.07715544f, 0.26235420f, 
    0.36342129f, -0.04962607f, -0.04655998f, 0.06105284f, -0.00595790f, 0.04161447f, 0.01714763f, 0.04718332f, 
    0.00983402f, 0.06235088f, 0.09777009f, 0.12315705f, -0.01608773f, -0.06425349f, 0.01070777f, -0.12570080f, 
    0.11851630f, 0.10814276f, 0.08655336f, 0.15890950f, 0.11561443f, -0.03208330f, 0.03622302f, 0.06437970f, 
    -0.03949022f, -0.04513013f, 0.12212081f, 0.00365392f, -0.00902825f, 0.09987865f, 0.12248711f, -0.14843392f, 
    -0.08348769f, -0.09255096f, 0.06759270f, -0.04618678f, 0.20884541f, 0.13429122f, 0.18536673f, 0.21135160f, 
    0.20657559f, -0.12331779f, -0.03221120f, 0.11418477f, 0.00415220f, 0.08204507f, 0.04777372f, -0.05360750f, 
    0.05928100f, 0.00728991f, 0.11411248f, 0.17625971f, 0.00535915f, 0.02388555f, 0.07421261f, -0.09862567f, 
    -0.22064333f, -0.10560264f, -0.45080262f, -0.20191360f, -0.26984403f, -0.01601255f, 0.04446401f, 0.02551083f, 
    -0.04331106f, 0.32596779f, -0.08620441f, -0.01098639f, 0.05156137f, 0.02048109f, -0.12599169f, -0.06546464f, 
    0.11589412f, -0.02304876f, -0.16001241f, -0.13681203f, 0.06954145f, 0.08080244f, 0.14079888f, 0.13590449f, 
    0.08796324f, 0.03095933f, -0.02281054f, 0.02824566f, -0.00694936f, -0.03306441f, 0.18444195f, 0.08948732f, 
    0.05189477f, 0.04944715f, 0.04389475f, 0.02838842f, -0.06748754f, -0.08435768f, 0.04417728f, -0.04071386f, 
    0.27068618f, -0.25484502f, -0.22994480f, -0.05204882f, -0.44792208f, -0.00863527f, -0.21052308f, -0.38232517f, 
    -0.00091112f, -0.00732963f, -0.00816932f, -0.05283817f, -0.02860223f, -0.00350297f, -0.13223851f, -0.01153190f, 
    -0.13941981f, -0.04862310f, 0.02225309f, -0.07309217f, 0.08140846f, 0.01179052f, 0.09998262f, 0.00208035f, 
    0.07579428f, 0.02381851f, -0.01702365f, 0.00186826f, -0.05111670f, 0.06248503f, 0.16328569f, 0.04458838f, 
    -0.08113170f, -0.02226930f, -0.01558585f, -0.10028003f, -0.03639428f, -0.05939079f, 0.03705195f, -0.00280192f, 
    0.16678910f, 0.05970036f, 0.10333689f, 0.10662430f, -0.06040908f, -0.16887063f, 0.09206650f, -0.03482176f, 
    0.01970485f, -0.05562121f, 0.02237150f, -0.03773176f, -0.05763925f, -0.10007564f, 0.09526090f, 0.08284542f, 
    -0.07674836f, -0.02417754f, 0.09123672f, -0.17817201f, 0.17040375f, 0.15656275f, 0.02354077f, 0.18417828f, 
    0.19754016f, 0.01776606f, 0.01626308f, 0.07988726f, 0.01594701f, -0.02422103f, 0.09208080f, 0.07059260f, 
    0.03349239f, 0.07500974f, 0.06509297f, 0.31319767f, -0.00991317f, -0.06841049f, -0.00292230f, -0.07246422f, 
    -0.06856614f, 0.02389685f, -0.08583333f, -0.50335252f, -0.32178333f, -0.07378890f, 0.08767857f, 0.05955819f, 
    0.10541153f, 0.07372170f, -0.03793758f, -0.11106351f, 0.04507920f, -0.00649954f, 0.01586387f, 0.00655103f, 
    -0.04947449f, 0.05149031f, -0.01771481f, -0.12098651f, -0.16800086f, -0.04994006f, -0.56636131f, -0.28542963f, 
    -0.20399100f, 0.05380022f, 0.08208902f, 0.03872611f, 0.04455710f, 0.19416514f, -0.05601412f, 0.01471808f, 
    0.05366481f, -0.03883237f, -0.00968765f, -0.06836094f, -0.05577667f, 0.11088161f, -0.10014361f, 0.15673967f, 
    -0.00016969f, 0.04263405f, -0.29848325f, -0.17187411f, -0.18729123f, 0.06164008f, -0.00487602f, 0.10948891f, 
    0.11189329f, 0.27411482f, -0.10969490f, 0.00474239f, -0.04392138f, 0.02194021f, -0.07401144f, -0.00785401f, 
    0.12578626f, 0.01631981f, -0.13807613f, 0.06524821f, -0.21386559f, -0.13527733f, -0.14894833f, -0.16038036f, 
    -0.17402646f, 0.12694833f, 0.25346604f, 0.30783477f, 0.21973418f, 0.25863007f, -0.12688364f, -0.02573360f, 
    0.06698047f, -0.04500017f, 0.03190688f, -0.04485110f, -0.02954163f, -0.00373761f, -0.04803765f, 0.03582961f, 
    -0.11328786f, 0.24465099f, -0.14937846f, -0.10484800f, -0.08672624f, -0.07514188f, -0.01741786f, 0.25503078f, 
    -0.12340377f, 0.26246092f, -0.07087660f, -0.06076076f, -0.00530264f, -0.01573524f, -0.04938341f, 0.04140591f, 
    0.03037005f, -0.02857996f, -0.06674278f, -0.13522850f, -0.04151836f, -0.17871787f, -0.45911095f, -0.43708599f, 
    -0.19277921f, -0.05473304f, 0.00599106f, -0.17589508f, -0.03132686f, 0.02666366f, -0.09739334f, -0.04529378f, 
    0.01986237f, -0.06327675f, -0.09249352f, -0.05658682f, 0.09899509f, 0.11631528f, -0.12310067f, -0.01640152f, 
    0.31979972f, 0.11322957f, 0.36032623f, -0.11093777f, 0.10541710f, 0.15103154f, 0.00105498f, 0.10888067f, 
    -0.14153066f, 0.08190018f, -0.03090341f, -0.00226591f, -0.00976509f, -0.12122834f, -0.07742141f, -0.05245601f, 
    0.01027619f, -0.02053930f, 0.12542956f, 0.04278453f, 0.12228397f, 0.03664893f, -0.21438271f, -0.00110451f, 
    -0.07786371f, -0.08166832f, -0.06582905f, -0.12146278f, -0.03501077f, -0.07488596f, 0.04698153f, 0.01581994f, 
    0.01563594f, 0.01071068f, 0.01186577f, 0.05095135f, -0.03905889f, -0.00638183f, 0.00148729f, 0.04863680f, 
    0.11843752f, 0.25994036f, 0.07088284f, 0.02638424f, 0.04495580f, -0.07220013f, -0.01859821f, -0.13685313f, 
    -0.06346926f, 0.04035325f, -0.01614937f, -0.01520467f, 0.00273958f, -0.00979487f, 0.10725009f, 0.00210328f, 
    0.04087239f, -0.21232003f, -0.08078210f, -0.07272626f, -0.12158932f, -0.08750413f, 0.16118385f, 0.02655570f, 
    0.02320615f, 0.04181116f, -0.06191833f, -0.44988498f, -0.08477833f, -0.06283890f, 0.06139491f, -0.00821234f, 
    0.06156382f, 0.00264381f, 0.04529262f, -0.06423116f, 0.03142490f, 0.02674337f, 0.09994543f, -0.00179786f, 
    -0.35894862f, 0.28650168f, 0.00783104f, 0.31585985f, -0.32092673f, -0.09211347f, -0.06573185f, 0.04240907f, 
    -0.18346064f, 0.18974128f, 0.02881321f, -0.00549363f, -0.08032288f, -0.04644291f, -0.02583208f, -0.13672857f, 
    -0.12469203f, 0.01919851f, -0.03827474f, -0.04122712f, 0.02574797f, -0.24916248f, 0.00502240f, 0.19674885f, 
    -0.11428127f, -0.09716900f, -0.06610586f, 0.03433178f, -0.25352341f, 0.23167607f, -0.17500593f, 0.16589892f, 
    0.03934906f, -0.04605013f, -0.28990215f, -0.19456291f, -0.07681108f, 0.09176652f, -0.16555637f, 0.21822189f, 
    -0.00949807f, 0.18600352f, 0.36910653f, -0.44725201f, 0.10305982f, -0.03736016f, -0.09095011f, -0.04221963f, 
    0.13286909f, -0.13541541f, 0.20197275f, -0.00670303f, 0.10364181f, -0.10781729f, 0.16121493f, -0.18459040f, 
    0.11173645f, 0.12039994f, -0.13633245f, -0.21984437f, 0.17620389f, -0.00371664f, 0.04594485f, 0.00292073f, 
    0.26776859f, -0.03616844f, 0.05425572f, -0.01786939f, -0.10554821f, -0.05993361f, -0.06892812f, -0.02481840f, 
    0.01647777f, -0.07263770f, -0.22012046f, -0.10732763f, 0.05998738f, -0.03358156f, -0.11639953f, -0.01347028f, 
    0.33535266f, 0.05831767f, -0.23500027f, -0.13252334f, -0.16748336f, 0.10949494f, -0.06357718f, 0.06689267f, 
    0.05165149f, 0.05176295f, -0.09126355f, 0.04287950f, -0.00755698f, -0.06658570f, -0.03413172f, 0.03783704f, 
    0.10348120f, -0.00124094f, 0.03794500f, -0.00917183f, 0.11973911f, 0.02609377f, -0.00825266f, 0.03601948f, 
    0.10300578f, -0.00661762f, 0.05103842f, 0.10635405f, -0.00639124f, -0.06099309f, -0.04666292f, -0.07232004f, 
    0.07743607f, 0.00396172f, 0.01847369f, 0.00989738f, -0.05889002f, -0.09436928f, -0.09066557f, 0.02332337f, 
    0.21389420f, 0.14183654f, 0.25858799f, -0.36507124f, -0.07583706f, 0.06529848f, 0.06533644f, 0.08876294f, 
    0.07682983f, 0.03469351f, -0.02505709f, 0.02540973f, 0.01287531f, 0.03970515f, 0.03008221f, -0.09903296f, 
    -0.03838618f, -0.17538249f, -0.09319061f, 0.03312889f, -0.05191519f, 0.04021079f, -0.02058534f, 0.02850277f, 
    -0.08314171f, -0.01770243f, 0.05628503f, -0.00199084f, 0.30063036f, 0.01754699f, 0.05751771f, -0.02843949f, 
    0.06345607f, 0.04071152f, -0.03571270f, 0.00359810f, 0.05536035f, -0.04865623f, -0.01117420f, 0.00355200f, 
    0.38846141f, 0.01951646f, -0.11324564f, 0.11201252f, 0.16733871f, 0.05223782f, 0.08757439f, -0.02094444f, 
    -0.05683934f, -0.08562669f, 0.08561952f, -0.01655915f, 0.07589233f, 0.08094627f, 0.03029563f, 0.01195979f, 
    -0.00462568f, -0.12639591f, 0.03992357f, 0.07515302f, 0.53033388f, 0.15556210f, 0.04178668f, -0.12775932f, 
    0.03395415f, -0.05385562f, 0.10534235f, 0.06440407f, -0.06821855f, 0.00001505f, 0.11440042f, -0.12375523f, 
    0.08929412f, -0.04526609f, -0.03530454f, 0.02756424f, -0.15962924f, 0.00154076f, 0.07950696f, 0.05839083f, 
    0.18599989f, 0.20364185f, 0.31029487f, -0.10973123f, 0.07308968f, 0.04646654f, 0.05649186f, -0.04977416f, 
    0.09287775f, 0.06031632f, 0.05969419f, 0.09234131f, 0.16035508f, 0.01007488f, 0.17988783f, -0.14969867f, 
    -0.18252891f, -0.06884337f, -0.06215230f, -0.04698283f, 0.23405413f, -0.01105506f, -0.19536524f, -0.08284146f, 
    0.01946307f, 0.08540680f, 0.07174475f, 0.14538619f, 0.02780121f, 0.01619146f, -0.16767448f, 0.05751634f, 
    0.06839739f, 0.07208787f, 0.04441272f, 0.00614112f, 0.07274456f, -0.00439382f, -0.04385974f, 0.04203387f, 
    0.23268548f, 0.18070820f, 0.34831834f, -0.18636093f, 0.07377551f, 0.06340422f, 0.39312759f, 0.34956306f, 
    -0.18535554f, -0.05400535f, 0.11236731f, -0.01149909f, -0.03445399f, -0.02955672f, 0.11592018f, 0.01227402f, 
    -0.02516081f, -0.02088678f, -0.12616070f, 0.24283157f, 0.06073641f, -0.03594556f, -0.10668445f, 0.04275291f, 
    0.03880385f, -0.00013780f, -0.00861737f, -0.13416708f, -0.00247530f, -0.03747083f, 0.08054034f, 0.02158296f, 
    0.09355574f, 0.04335929f, 0.01088280f, 0.02367371f, -0.02737775f, 0.14931194f, 0.18833028f, 0.01278412f, 
    0.08899230f, 0.28124979f, -0.01245694f, 0.15506767f, 0.02620016f, 0.05820534f, 0.02403258f, -0.00971447f, 
    -0.04464828f, -0.00981780f, -0.05394112f, -0.08576196f, -0.01181762f, -0.12639514f, -0.01362052f, -0.04017727f, 
    -0.06212771f, 0.04593614f, -0.03146711f, -0.00405110f, -0.25804549f, -0.09503612f, 0.11495343f, 0.14377742f, 
    -0.05073943f, -0.01748772f, -0.05498512f, -0.08871371f, -0.04090869f, 0.00979600f, -0.07619891f, 0.02114959f, 
    0.06604563f, -0.07318224f, 0.03568750f, -0.06309704f, 0.05872124f, 0.08889615f, -0.02881810f, -0.02121649f, 
    0.20454840f, 0.31135792f, 0.25755903f, 0.04074164f, 0.04948232f, 0.15383306f, 0.23518078f, 0.11619164f, 
    0.12667622f, 0.34407756f, 0.00424138f, -0.02591323f, 0.03927791f, -0.05525694f, -0.04322496f, -0.03614572f, 
    0.04424253f, 0.16411880f, -0.03960269f, 0.05339673f, 0.13311639f, 0.05163861f, -0.04332919f, 0.13051309f, 
    0.08253755f, 0.00642136f, 0.03028398f, -0.03955157f, -0.02358946f, -0.03238725f, -0.04163549f, -0.02013087f, 
    -0.00361728f, -0.11851886f, -0.10243724f, -0.06711107f, -0.05165904f, -0.08475485f, -0.00318314f, -0.01339330f, 
    0.49273539f, -0.04540024f, -0.16498196f, -0.42076406f, -0.17775862f, 0.18741874f, 0.13833694f, 0.10072239f, 
    0.06153249f, 0.10300326f, 0.08476233f, -0.00314526f, -0.04381263f, -0.12842275f, -0.01081977f, -0.00337298f, 
    0.03316205f, -0.09061643f, 0.07528952f, -0.02856197f, 0.18205196f, 0.03271194f, -0.09056731f, 0.02400133f, 
    0.07706018f, -0.02314883f, -0.00313265f, 0.02593759f, -0.05859729f, 0.04966492f, -0.03201447f, -0.17179085f, 
    -0.20262913f, -0.12747645f, -0.13579084f, -0.04074465f, -0.02623997f, -0.05390346f, -0.10415914f, 0.04472863f, 
    0.00622678f, 0.38377821f, 0.08291203f, -0.03307650f, -0.21009542f, 0.10623462f, -0.07668623f, 0.02045269f, 
    0.09967166f, 0.12865931f, -0.01180016f, -0.03321130f, -0.11116461f, 0.01492638f, 0.02025484f, -0.01662763f, 
    0.05758414f, -0.00709539f, -0.01386257f, -0.17534849f, -0.02108522f, 0.17196959f, -0.00766467f, -0.08645407f, 
    0.05881249f, 0.01856147f, -0.11886799f, -0.18235362f, 0.10569107f, -0.19085723f, -0.03257496f, 0.01323681f, 
    0.11664631f, -0.06907515f, 0.04688473f, 0.00998364f, -0.05143928f, -0.04239693f, -0.00502482f, -0.10411900f, 
    0.01998062f, -0.01356579f, 0.09332821f, -0.12351982f, -0.09371845f, -0.02962532f, -0.06785394f, -0.07792229f, 
    0.05068551f, 0.12446991f, 0.04228389f, 0.08601207f, -0.02132644f, -0.12147074f, -0.14260146f, -0.11499820f, 
    -0.00260256f, 0.02350985f, 0.05208402f, 0.04274344f, 0.45757723f, 0.25161961f, 0.42109182f, 0.04646187f, 
    0.33976364f, 0.26454207f, 0.25406754f, 0.12079144f, 0.12640907f, 0.14267996f, 0.00205229f, -0.05017607f, 
    -0.07113431f, -0.17545700f, -0.00656159f, -0.01198947f, -0.02011678f, 0.01580418f, 0.04378391f, 0.01119800f, 
    0.02845063f, 0.26575017f, 0.15082482f, 0.03326919f, -0.04911946f, -0.00856245f, -0.12696867f, -0.15708899f, 
    -0.14702941f, -0.00882814f, -0.02497179f, 0.02091019f, -0.00785745f, -0.06946418f, -0.00392206f, -0.02052847f, 
    0.03576423f, 0.02488642f, -0.08018120f, -0.08314428f, 0.23001845f, 0.05127474f, -0.03155530f, -0.22354537f, 
    -0.14421609f, 0.16988309f, 0.11484428f, 0.33870012f, 0.19219507f, -0.14056012f, -0.10024136f, 0.08145173f, 
    0.02397254f, -0.00191693f, 0.03538557f, 0.00293697f, -0.00855506f, 0.00414657f, -0.06121900f, -0.02942186f, 
    -0.24110329f, 0.17573850f, 0.03289101f, 0.05978689f, -0.22422001f, -0.02719278f, -0.03846015f, -0.11455677f, 
    -0.03197496f, 0.13036260f, -0.03829124f, 0.00687789f, 0.00674110f, -0.04052195f, -0.04432970f, -0.12300239f, 
    0.07481647f, -0.05105289f, -0.11206846f, 0.14955941f, 0.33628747f, 0.29200849f, 0.50521243f, -0.21416996f, 
    0.01740979f, 0.19247386f, 0.20845939f, 0.01174356f, 0.16346440f, 0.09434446f, 0.01000605f, -0.03441988f, 
    0.02169098f, -0.12033907f, 0.04331696f, -0.07677340f, -0.02327440f, 0.00111470f, -0.23373052f, 0.11142412f, 
    -0.02246867f, 0.02215413f, 0.02836003f, -0.01634135f, -0.02871820f, -0.00049086f, -0.03761163f, 0.02753843f, 
    -0.02507781f, -0.03999607f, 0.02909119f, -0.01881307f, -0.01354948f, 0.01704537f, -0.02914697f, -0.03182968f, 
    0.00164314f, -0.00855262f, 0.01309531f, 0.02219197f, 0.00593697f, -0.04158147f, 0.02140436f, -0.03714870f, 
    -0.01644627f, -0.01918913f, -0.03557400f, 0.00042933f, 0.01342308f, 0.01653102f, 0.01560528f, -0.04153728f, 
    0.01414201f, 0.00135797f, 0.00921728f, -0.02604872f, 0.02216578f, -0.03944784f, 0.00265180f, -0.00929588f, 
    -0.02940848f, -0.01255333f, -0.02139671f, 0.02709362f, 0.01181076f, 0.01089303f, 0.00992569f, 0.01594746f, 
    0.00374053f, -0.03969030f, -0.01089142f, 0.01307637f, -0.03006714f, -0.01057103f, -0.00981998f, 0.00681948f, 
    -0.03238497f, -0.03180187f, 0.00829748f, -0.03925370f, -0.01911239f, -0.01887507f, -0.02198051f, -0.01439727f, 
    -0.04664804f, -0.00052043f, -0.00656456f, 0.02975069f, -0.04322530f, -0.00089350f, 0.02362567f, 0.00033595f, 
    -0.02735632f, -0.01505282f, -0.04288147f, -0.02536357f, 0.02942475f, -0.02142863f, -0.02767644f, -0.00568437f, 
    -0.02228706f, -0.03452156f, -0.01479453f, 0.01178775f, 0.02169391f, -0.03507392f, -0.03186661f, 0.03102188f, 
    -0.03240530f, 0.01518912f, -0.02360468f, -0.03072021f, -0.02177807f, 0.01433988f, 0.02759888f, -0.00047185f, 
    -0.04175154f, -0.01337837f, -0.00160843f, -0.03997115f, 0.02067467f, 0.00685109f, -0.01230981f, -0.03063039f, 
    -0.02627988f, 0.02885031f, 0.00344085f, -0.03039845f, -0.01577193f, -0.02549371f, 0.01057225f, -0.03404261f, 
    -0.02839200f, -0.01300260f, -0.03759525f, -0.02741664f, -0.01656412f, -0.01918218f, 0.01086137f, 0.02987619f, 
    -0.01745434f, -0.01183523f, -0.02527542f, -0.00102961f, -0.00329590f, -0.00589023f, -0.01758815f, -0.03343917f, 
    0.03116236f, 0.00145176f, 0.02444925f, -0.03747720f, -0.03823398f, 0.02212271f, 0.01736369f, 0.01865569f, 
    -0.02861640f, 0.01522794f, -0.04311686f, -0.02006813f, 0.01741928f, -0.00944402f, -0.00952755f, -0.01025078f, 
    -0.04169429f, -0.02587343f, 0.01559516f, 0.00864414f, -0.03106834f, -0.04010225f, -0.03031193f, 0.03040074f, 
    -0.03426139f, -0.02759667f, -0.00378753f, -0.00095640f, 0.01461861f, 0.02080182f, -0.01046255f, -0.02693146f, 
    -0.00832080f, 0.01532281f, 0.01888680f, 0.00325126f, 0.01543071f, 0.02660654f, -0.02177385f, 0.00508229f, 
    -0.03267962f, -0.00815645f, -0.03027349f, -0.00827569f, -0.02915550f, -0.04648838f, 0.01474695f, -0.01980360f, 
    -0.01616311f, -0.01663556f, 0.01316798f, -0.00607943f, -0.02048833f, -0.03250437f, 0.02819034f, -0.02615531f, 
    -0.03717190f, -0.04236056f, 0.00958115f, -0.00058672f, -0.03382745f, -0.00258638f, -0.03852070f, -0.01123334f, 
    0.00214514f, -0.03484187f, -0.02968785f, 0.01439109f, 0.01978074f, -0.04459367f, -0.02537467f, -0.00421201f, 
    -0.02757192f, -0.02404646f, -0.04442814f, -0.02975562f, -0.00676289f, -0.04565869f, -0.02141802f, 0.01401414f, 
    0.00778740f, 0.01154990f, -0.03674499f, -0.03366860f, -0.00739365f, 0.00640285f, -0.04011903f, 0.00746272f, 
    -0.04426420f, 0.00599996f, -0.00693820f, -0.03094959f, -0.03615761f, -0.04078859f, -0.00383174f, 0.00210371f, 
    -0.00737512f, 0.01306102f, -0.00613447f, -0.00089241f, 0.00964370f, 0.00286823f, -0.01050999f, 0.02498768f, 
    -0.03101270f, -0.01411845f, -0.00773761f, 0.02983443f, -0.00037510f, 0.00384228f, -0.02896611f, 0.01456369f, 
    -0.02163762f, -0.04692899f, 0.02208937f, 0.00407042f, 0.01607933f, -0.01653612f, -0.02632086f, -0.01488084f, 
    -0.02334907f, -0.03312661f, -0.00074852f, -0.02386159f, -0.00490984f, 0.01812411f, -0.00822667f, 0.00319438f, 
    0.01959210f, -0.02481535f, 0.01097308f, -0.01636145f, -0.00775008f, 0.00036127f, -0.04402730f, 0.00068758f, 
    -0.00682363f, -0.00773515f, 0.03325365f, 0.01605959f, -0.01254646f, 0.01069258f, -0.00330803f, -0.04167682f, 
    -0.04556051f, 0.02365439f, -0.02055257f, -0.03966544f, -0.01674615f, -0.00719716f, -0.03665243f, -0.01564122f, 
    -0.01739060f, -0.03984989f, 0.01633217f, -0.03753911f, -0.01054332f, -0.01736177f, -0.00664201f, -0.02500367f, 
    -0.02273033f, -0.02848396f, -0.03618733f, -0.00623033f, -0.04762113f, -0.00918650f, 0.02799756f, -0.03845396f, 
    -0.02254404f, 0.02444130f, 0.02816846f, -0.03828401f, -0.01009157f, -0.02300584f, -0.03836356f, -0.02634592f, 
    -0.04428012f, 0.01984307f, 0.02277643f, -0.01699213f, 0.02671569f, 0.01459563f, -0.01714963f, -0.03249436f, 
    -0.02481950f, -0.02066552f, -0.00470291f, -0.01148048f, 0.01064656f, 0.02440627f, -0.00284498f, 0.00305580f, 
    0.00889794f, -0.02923666f, 0.02399669f, 0.00482418f, -0.00403914f, -0.00840627f, -0.00540932f, 0.00563819f, 
    0.01968757f, 0.00894934f, 0.01023594f, 0.02880233f, -0.01496788f, 0.02082585f, 0.02555805f, -0.03429100f, 
    0.03144295f, -0.03836456f, 0.01854411f, 0.01744659f, 0.03035941f, -0.01339298f, -0.04374054f, 0.00610118f, 
    -0.01996827f, -0.00761459f, -0.03580019f, 0.01364051f, 0.02841542f, -0.02277809f, -0.01502949f, -0.04180788f, 
    -0.02306785f, -0.01648094f, -0.03998854f, -0.04597005f, 0.02604401f, -0.02410037f, 0.02593352f, -0.02486588f, 
    -0.01404021f, 0.01608222f, -0.02001085f, -0.04144835f, 0.01292041f, -0.03321674f, 0.02545737f, -0.02504982f, 
    0.02354518f, -0.02492349f, 0.00964101f, 0.01240369f, -0.02140214f, -0.01688780f, -0.04006963f, 0.02253455f, 
    -0.01527857f, -0.03288874f, 0.01004926f, -0.01269055f, -0.03147395f, -0.02733670f, 0.02390953f, 0.02623239f, 
    0.01176378f, -0.04347548f, -0.02409349f, 0.00949751f, 0.02339028f, -0.03833430f, 0.01420954f, 0.00771900f, 
    0.02139057f, -0.04458284f, 0.02378485f, -0.02024639f, 0.01790130f, -0.03534942f, 0.00965884f, -0.03692896f, 
    0.01133930f, 0.02528479f, -0.04136777f, 0.00876906f, 0.01894021f, 0.01789265f, 0.01376545f, 0.00584562f, 
    0.03114095f, 0.02324361f, -0.00783306f, -0.00595687f, -0.02454551f, -0.02998560f, -0.00858829f, -0.01996670f, 
    -0.02032605f, -0.00746849f, 0.02793109f, -0.02755080f, -0.01419884f, -0.01555492f, 0.00298724f, -0.04459702f, 
    0.02384214f, 0.02749433f, 0.00350307f, -0.03532132f, 0.00795972f, 0.00658794f, 0.00724068f, -0.03076114f, 
    -0.03727215f, 0.02394899f, -0.00212014f, -0.04487648f, -0.01804288f, -0.03333774f, 0.02921271f, -0.01940973f, 
    -0.00439679f, -0.03857626f, 0.00713522f, -0.04431146f, 0.03080526f, 0.02767443f, -0.04239287f, -0.00612609f, 
    0.02136548f, -0.01606749f, -0.01308580f, -0.01332619f, 0.01922511f, 0.01618982f, 0.02621490f, 0.02696463f, 
    -0.03716117f, -0.01184322f, 0.01734892f, 0.00839865f, 0.00863351f, -0.02763124f, 0.00384051f, -0.02956796f, 
    -0.00017962f, 0.01567764f, -0.03685519f, -0.01665295f, -0.04167147f, -0.00679179f, -0.00666053f, -0.00003374f, 
    -0.00274572f, -0.01001248f, -0.01273205f, -0.00436204f, 0.01830852f, -0.01793584f, -0.01844587f, -0.02395814f, 
    0.02792728f, 0.00614166f, 0.02705224f, -0.01931069f, 0.01262403f, -0.04253975f, -0.03439928f, -0.00894915f, 
    -0.02588809f, -0.00130250f, 0.01308689f, 0.00353481f, -0.00208568f, -0.04279305f, -0.00571124f, -0.02004833f, 
    0.00638156f, -0.00404044f, -0.03222411f, 0.01546792f, -0.01062546f, 0.01766171f, 0.02078105f, -0.02698902f, 
    -0.00650913f, -0.00972300f, -0.01884371f, -0.02562886f, -0.00761247f, 0.02811450f, 0.01395437f, -0.04453549f, 
    0.01929766f, 0.01273106f, -0.02450214f, 0.00157577f, 0.02555826f, -0.00522364f, -0.02705950f, 0.02402111f, 
    -0.01340200f, -0.04027487f, 0.00011542f, -0.03127521f, -0.00518295f, 0.01995927f, 0.01423951f, -0.02415799f, 
    -0.00981405f, -0.01801469f, 0.01407280f, -0.00444839f, 0.00263427f, 0.01817435f, -0.04381558f, -0.04429956f, 
    0.01917925f, -0.01471879f, -0.02998644f, -0.02426307f, -0.03558837f, -0.03265071f, -0.02866060f, -0.02078248f, 
    0.02440430f, 0.01152921f, 0.02766538f, -0.04701356f, -0.01337739f, 0.00656012f, 0.00543727f, 0.02560847f, 
    -0.01284587f, -0.01237228f, -0.03392063f, -0.01473183f, 0.00134390f, 0.00655451f, -0.04278900f, -0.03582189f, 
    -0.01805118f, 0.01824637f, 0.01294235f, -0.00261934f, 0.02101802f, 0.00816781f, -0.01940134f, -0.01160411f, 
    0.01463729f, 0.00872211f, 0.03053999f, -0.03060510f, -0.01971407f, 0.02085085f, 0.00569787f, 0.01811747f, 
    0.02608928f, 0.00111354f, 0.02365056f, -0.02953640f, 0.02325155f, 0.01241584f, -0.01870095f, 0.02388931f, 
    0.00234907f, 0.01425363f, 0.00185914f, -0.02385183f, -0.03075518f, -0.02115719f, -0.02223066f, 0.00560503f, 
    -0.02369582f, 0.00444567f, -0.00324119f, 0.02860584f, 0.00033628f, 0.01218656f, -0.01751988f, 0.01282405f, 
    0.01445708f, 0.03161443f, -0.03852366f, 0.01880072f, -0.00706401f, -0.02039875f, -0.02811063f, 0.00204723f, 
    -0.03272488f, -0.01508480f, 0.01456766f, 0.02059665f, -0.03680372f, -0.01070044f, -0.02259479f, 0.02465227f, 
    0.00341941f, -0.04089982f, -0.00217098f, -0.00494533f, -0.04529145f, 0.02924638f, -0.04701254f, 0.02683688f, 
    -0.01550588f, -0.01967232f, -0.04659439f, -0.01274537f, 0.00655333f, -0.02420861f, 0.01516973f, -0.04729740f, 
    -0.03071600f, -0.03081863f, -0.04185307f, 0.03023733f, 0.02741187f, -0.03046803f, -0.03880252f, -0.01975220f, 
    -0.12301239f, 0.05493980f, -0.03675868f, 0.33514458f, 0.07079262f, -0.04910535f, 0.16003966f, -0.03660615f, 
    0.05789313f, -0.02649212f, 0.05876488f, 0.04036217f, 0.04713385f, 0.08190893f, 0.06602690f, 0.09377643f, 
    -0.05010743f, 0.09901787f, -0.12240993f, -0.08958140f, 0.47259715f, 0.10385940f, 0.28422201f, 0.36686927f, 
    -0.04562404f, -0.01321390f, -0.06231006f, -0.06804149f, 0.01231393f, -0.02211566f, -0.07998075f, 0.00848399f, 
    0.11371760f, 0.00674513f, 0.00038878f, 0.00849899f, -0.04463550f, 0.25130531f, -0.02786436f, -0.05344969f, 
    -0.30256200f, 0.00390900f, 0.37369302f, 0.30205002f, 0.08133832f, 0.07373651f, -0.06275704f, -0.04024537f, 
    -0.06978165f, -0.18709250f, -0.06437664f, 0.08050331f, 0.04419078f, 0.10889675f, 0.16926849f, 0.06793897f, 
    0.01533268f, 0.02865207f, 0.07869222f, -0.00241920f, 0.19829427f, -0.01518708f, 0.35452792f, 0.15969121f, 
    -0.20975319f, -0.07428549f, -0.10575580f, 0.03084776f, 0.04991974f, 0.09520314f, -0.10621071f, -0.00675322f, 
    -0.01175011f, -0.01879107f, -0.04185416f, 0.07068276f, -0.11162170f, 0.15367027f, 0.04488669f, 0.19383116f, 
    0.35125601f, -0.27920529f, 0.13028072f, -0.04228433f, 0.18687463f, -0.04893919f, 0.11498509f, -0.00523773f, 
    0.09980259f, 0.05002819f, 0.08043223f, -0.04628696f, -0.00861956f, 0.07660013f, -0.03055424f, -0.02323758f, 
    0.00005100f, 0.15852031f, 0.07902509f, -0.19486447f, 0.38043141f, -0.24129799f, 0.22872700f, 0.11611196f, 
    0.03471630f, -0.00859161f, 0.10004614f, 0.03281733f, 0.23440643f, 0.12576486f, -0.01967285f, 0.12009262f, 
    0.02159566f, 0.19120552f, 0.06493943f, 0.15715551f, 0.16636403f, 0.07613020f, 0.18965138f, 0.08738042f, 
    -0.24132080f, 0.00331379f, 0.09485613f, 0.38242939f, -0.01437214f, 0.34017774f, -0.03138474f, 0.21631064f, 
    0.11477146f, 0.26549929f, -0.09880841f, -0.00336165f, -0.02302275f, 0.04480917f, 0.19114165f, -0.04779960f, 
    -0.00611822f, -0.07210593f, 0.16161703f, 0.06506857f, 0.22672625f, 0.16438179f, 0.12191933f, 0.26020402f, 
    0.08796322f, -0.02161056f, -0.03057693f, 0.00795419f, 0.18379807f, 0.09213724f, -0.03556747f, 0.06502040f, 
    -0.01281652f, 0.03702953f, 0.09556639f, 0.10543367f, -0.01463461f, 0.11367953f, 0.22913671f, 0.13108340f, 
    0.01268595f, -0.25515956f, -0.19453998f, -0.14634249f, -0.19453892f, -0.18881932f, -0.01486807f, 0.02587039f, 
    0.05371734f, 0.17908233f, -0.02919747f, 0.23382127f, 0.03524748f, -0.07993854f, -0.15267999f, -0.10424840f, 
    -0.06440483f, 0.04545473f, -0.00348040f, -0.01769924f, 0.10750838f, -0.01143197f, 0.04407662f, 0.04954923f, 
    -0.02949704f, -0.04666488f, 0.04805752f, -0.03740086f, -0.01652068f, -0.02929093f, -0.16738884f, -0.01907158f, 
    0.08714318f, 0.02724243f, -0.01454667f, -0.09818906f, 0.06158162f, 0.09112079f, 0.01830811f, 0.02953392f, 
    -0.35504591f, -0.08008040f, 0.05159311f, 0.07740745f, -0.02363770f, 0.03757879f, 0.00468045f, 0.03259683f, 
    -0.07306260f, -0.00897884f, 0.03718080f, 0.02592986f, -0.04835619f, 0.00725645f, -0.04199773f, 0.03930967f, 
    -0.02342454f, -0.15396862f, 0.00256708f, 0.03307137f, -0.05137427f, -0.27106714f, 0.37818831f, 0.20365433f, 
    -0.12624475f, 0.05079602f, -0.03751270f, -0.11412784f, -0.05593749f, -0.10335159f, -0.21766828f, -0.06119261f, 
    -0.00596737f, 0.11659142f, 0.04533128f, 0.02488509f, 0.01451645f, 0.06409483f, -0.05698194f, 0.32320616f, 
    0.69465315f, 0.13081467f, 0.09375859f, 0.20700927f, 0.05451671f, -0.07947765f, 0.05787287f, -0.03698349f, 
    -0.07892086f, -0.12126884f, -0.00517379f, 0.02099061f, 0.00832595f, 0.04494582f, -0.03879960f, -0.01599700f, 
    -0.07447352f, 0.01273011f, -0.03171830f, 0.06526493f, 0.25588623f, 0.09876638f, 0.08369844f, 0.46702844f, 
    0.05530005f, -0.09836764f, -0.04143371f, -0.16662486f, -0.10663817f, -0.10068674f, -0.11739242f, -0.07170763f, 
    0.04160695f, 0.27284309f, 0.14392628f, -0.04673159f, -0.11766420f, 0.02498325f, 0.07246565f, 0.03444866f, 
    0.05043688f, -0.05800323f, 0.16110896f, 0.35591292f, -0.10062726f, 0.02270921f, -0.06668657f, -0.09190544f, 
    -0.14322956f, -0.08937393f, -0.10516242f, -0.05396466f, -0.04825051f, -0.00982585f, 0.04963748f, -0.03124383f, 
    0.06277660f, -0.12073318f, 0.21574812f, -0.17159639f, -0.12290443f, -0.25102654f, -0.12655912f, 0.03085872f, 
    -0.16185881f, -0.12467060f, -0.00359919f, 0.01269429f, 0.07272443f, -0.04480701f, -0.14702553f, 0.05710214f, 
    -0.08207487f, -0.08766247f, -0.10742772f, -0.01896503f, -0.02342280f, -0.08235519f, -0.04592619f, -0.01164080f, 
    -0.38108575f, 0.10664932f, 0.28553826f, 0.30898625f, -0.03489160f, 0.03753120f, 0.04583542f, 0.02373804f, 
    0.15684427f, 0.02652140f, 0.02133946f, -0.05398437f, -0.11025701f, -0.04969155f, 0.01599380f, 0.09322705f, 
    0.00915447f, 0.00013758f, 0.10062437f, 0.14610516f, 0.35076338f, 0.09569092f, 0.26652753f, -0.11135450f, 
    -0.16392556f, -0.07537653f, -0.05410365f, -0.11106128f, 0.04122810f, -0.05698914f, -0.00580298f, 0.04928562f, 
    0.03478027f, -0.07660110f, -0.06875343f, -0.07888557f, 0.01676069f, 0.13015632f, 0.02741624f, 0.01612306f, 
    0.16737977f, 0.04667108f, 0.10118913f, -0.06918425f, -0.06109749f, 0.00699257f, -0.05886535f, -0.03406619f, 
    0.05507310f, 0.03938193f, 0.04639514f, -0.03097388f, -0.13638751f, 0.07668049f, 0.06684599f, -0.10156502f, 
    -0.02566419f, 0.02934190f, -0.01639750f, -0.11381990f, 0.22989447f, 0.03470539f, 0.17740214f, 0.12086321f, 
    0.05076563f, 0.03491806f, 0.02936373f, -0.01232981f, 0.10511152f, 0.06732384f, -0.00702084f, 0.00308641f, 
    -0.03752794f, -0.00075914f, -0.09034376f, 0.05906936f, 0.10688071f, 0.05034676f, 0.03990268f, 0.05138880f, 
    -0.07681482f, -0.04951379f, -0.08448473f, 0.23602584f, -0.06925050f, 0.00287623f, 0.00690208f, -0.05107289f, 
    -0.03656149f, -0.12926376f, 0.11442631f, 0.06415198f, 0.11489807f, 0.04735062f, -0.03682647f, 0.22613433f, 
    -0.02659924f, -0.07862688f, -0.03194062f, -0.11821714f, 0.15589896f, 0.07468399f, 0.02485194f, 0.02888857f, 
    -0.00837885f, -0.03524729f, 0.02851850f, -0.07052790f, -0.05215522f, -0.09337249f, 0.05616974f, 0.01016583f, 
    -0.00425623f, 0.00486215f, -0.01048466f, -0.13590710f, 0.03286828f, 0.09999795f, -0.02633335f, -0.09912984f, 
    -0.27037078f, -0.12041067f, 0.06630667f, 0.02628539f, 0.03911562f, -0.01114117f, -0.03722716f, 0.09714452f, 
    -0.00447019f, -0.02747617f, -0.02697755f, 0.12707169f, 0.01325939f, -0.13273987f, -0.02207904f, -0.04319519f, 
    -0.02131976f, -0.07813918f, -0.07655533f, -0.03015037f, 0.09125411f, -0.05344543f, -0.09268358f, 0.00249422f, 
    -0.05539364f, -0.01451498f, 0.02203405f, -0.06306744f, 0.00071593f, -0.02173631f, 0.06271730f, 0.10665134f, 
    0.29105529f, 0.03318900f, 0.11882430f, -0.12498354f, -0.05438247f, -0.06058731f, -0.07440995f, -0.01699471f, 
    0.10810187f, -0.26692265f, 0.08639982f, -0.31128129f, 0.07980643f, 0.16745949f, -0.01101741f, 0.08000547f, 
    0.05650361f, -0.02273041f, -0.02587240f, 0.14075656f, -0.03027326f, 0.14308965f, 0.05523173f, -0.15800428f, 
    0.01062418f, -0.02762360f, 0.15672241f, -0.05458416f, 0.18517753f, 0.11674888f, 0.10166054f, 0.05705998f, 
    0.02666497f, 0.07041147f, -0.00679538f, -0.13109253f, 0.05863981f, -0.02764186f, 0.02187499f, 0.08036115f, 
    -0.01572816f, 0.01593584f, 0.02830852f, -0.03738294f, 0.09002878f, 0.07854792f, 0.09264759f, 0.07854086f, 
    -0.04099537f, -0.27926114f, 0.28801042f, 0.21784611f, 0.09467463f, 0.17624970f, -0.02221235f, 0.25807059f, 
    -0.07593658f, -0.02013426f, 0.01810244f, 0.11816247f, 0.04709224f, 0.04296074f, 0.14167821f, -0.03716285f, 
    0.08938548f, -0.00172372f, -0.08219044f, 0.03174049f, -0.19822909f, -0.09219321f, -0.08783206f, 0.24506868f, 
    -0.00099848f, -0.13117419f, -0.06339304f, 0.05289578f, 0.00728065f, -0.05314920f, -0.00138771f, 0.02727354f, 
    0.06810906f, 0.05381582f, 0.14725916f, 0.13346738f, 0.10846782f, 0.01448735f, -0.10132386f, -0.08971565f, 
    0.18512344f, -0.04651227f, -0.03236469f, 0.11833620f, 0.03202061f, -0.05565383f, 0.12053384f, -0.03647352f, 
    0.01412984f, -0.02102303f, 0.01182461f, 0.06771879f, 0.04681292f, 0.04481624f, -0.02206799f, 0.09206875f, 
    -0.07302801f, -0.15457664f, -0.11967750f, -0.05418925f, -0.15225722f, -0.28084671f, -0.02354799f, 0.31458661f, 
    0.03391916f, -0.08054978f, 0.07028303f, -0.01319711f, 0.00443255f, 0.03775355f, -0.10564771f, 0.14170504f, 
    -0.01797681f, 0.00259876f, 0.00097751f, -0.03601098f, 0.03788008f, 0.02650710f, -0.00686977f, 0.07429134f, 
    0.21498889f, -0.24496046f, 0.14028700f, -0.00731236f, 0.03819652f, -0.00867050f, 0.04348812f, -0.02301524f, 
    0.13156912f, 0.00898098f, -0.09278105f, 0.08640572f, -0.00259029f, -0.03666298f, -0.03057759f, 0.10200658f, 
    -0.07677030f, -0.09930581f, -0.07239722f, -0.05906402f, -0.34381607f, -0.10013751f, 0.18021485f, 0.24884439f, 
    -0.07561830f, 0.07812688f, 0.01232469f, 0.01515058f, -0.04748863f, -0.02148042f, -0.03571772f, 0.00373839f, 
    -0.01450726f, -0.04646058f, -0.00496909f, 0.22371930f, 0.05509728f, -0.17328204f, 0.02870525f, 0.10283732f, 
    -0.27475992f, -0.06422964f, -0.04146136f, 0.04471133f, 0.00504519f, 0.14241728f, -0.01235111f, 0.14597407f, 
    0.14649658f, 0.17634127f, 0.00703919f, 0.05572030f, 0.01836294f, -0.02299777f, 0.00998618f, 0.12018020f, 
    0.24474627f, 0.00063869f, 0.14379320f, 0.09696250f, -0.26061231f, 0.08809745f, 0.11510547f, -0.24536757f, 
    0.12952687f, 0.01403319f, -0.15805981f, -0.01746656f, -0.05801829f, -0.00408824f, 0.00015870f, -0.13642000f, 
    0.07147111f, 0.10064454f, -0.03679912f, 0.17658190f, 0.00950656f, 0.13102022f, -0.13041957f, -0.22878125f, 
    -0.10545079f, -0.05684717f, 0.31569055f, -0.03783162f, 0.17485067f, 0.03037592f, -0.00698669f, 0.18726969f, 
    0.04096528f, 0.19550352f, 0.03945404f, 0.00873661f, -0.03065765f, -0.03337842f, -0.17875184f, 0.06686991f, 
    -0.12843993f, -0.00031873f, -0.12551175f, 0.05355740f, -0.31549200f, -0.20917961f, -0.20276885f, 0.28456745f, 
    -0.12816323f, 0.10322242f, 0.06981539f, 0.10498195f, -0.10252436f, 0.03509945f, -0.01050146f, -0.04874320f, 
    -0.08904797f, 0.05733914f, -0.07075108f, 0.08810460f, 0.01953548f, 0.06155536f, -0.16707505f, -0.03577080f, 
    0.66196781f, 0.49473104f, -0.31592682f, 0.09485631f, -0.27247548f, 0.11731339f, -0.29130134f, 0.35345304f, 
    -0.45386294f, -0.34557801f, -0.16964778f, 0.02357287f, -0.07099599f, 0.01865486f, 0.12297247f, -0.04145216f, 
    -0.09067929f, 0.10825368f, -0.04825760f, 0.14194112f, -0.23556708f, 0.01791599f, -0.38387600f, 0.24876079f, 
    -0.11909897f, 0.08525419f, -0.19063596f, 0.00215121f, -0.16285348f, -0.47828591f, 0.04445248f, 0.04583570f, 
    -0.12530459f, -0.09361713f, -0.01056631f, -0.16813867f, -0.14720334f, 0.00365997f, -0.07797800f, 0.07089291f, 
    0.29840854f, 0.02644036f, 0.30978593f, 0.01860998f, 0.17761987f, -0.26922569f, 0.12378655f, -0.15570436f, 
    0.00482937f, -0.07327404f, -0.19685079f, 0.09654552f, -0.02864450f, -0.04375815f, -0.08407699f, 0.04275282f, 
    -0.00980444f, -0.06804379f, 0.05230417f, 0.02425048f, -0.30848604f, 0.08845694f, 0.00488259f, -0.10084756f, 
    -0.03572619f, 0.00857629f, 0.05234761f, 0.10218318f, -0.07689410f, -0.07308822f, -0.09381747f, -0.00209563f, 
    -0.04027786f, -0.08748848f, 0.10532401f, -0.15303989f, -0.03700075f, 0.07259322f, 0.04784698f, -0.08512001f, 
    0.57977474f, 0.48100051f, 0.28310597f, 0.11768864f, 0.23076791f, 0.20215790f, -0.11356813f, -0.22624224f, 
    0.14869554f, -0.38061613f, -0.06694908f, 0.03309915f, -0.01928487f, -0.06683730f, -0.04374448f, 0.00268465f, 
    -0.13560975f, -0.07280236f, -0.01359165f, 0.11712459f, -0.44349673f, -0.08329114f, -0.07353950f, -0.07939224f, 
    -0.11580313f, -0.01049226f, -0.08089245f, 0.02980255f, -0.04996832f, 0.03550663f, -0.03268034f, -0.03686730f, 
    0.07178079f, -0.07986197f, 0.00153790f, 0.23660773f, -0.21094215f, 0.03782970f, -0.15047541f, -0.27874869f, 
    -0.01801018f, -0.06240901f, -0.05222717f, 0.08611704f, 0.07278013f, 0.01431006f, 0.03260878f, -0.01067489f, 
    0.15079109f, 0.08763020f, -0.02285738f, -0.00538508f, 0.01802507f, 0.06369042f, 0.18768848f, -0.05383460f, 
    0.05155358f, 0.12764008f, 0.09463833f, 0.18874456f, -0.54631162f, 0.17993166f, -0.10282829f, 0.29404065f, 
    -0.03978002f, 0.06751931f, 0.13493069f, 0.10364719f, 0.03170337f, 0.26997128f, 0.19202834f, 0.04159616f, 
    -0.01590197f, -0.27188602f, -0.05405628f, 0.01837447f, -0.18092187f, -0.04635546f, -0.16011332f, -0.27636534f, 
    -0.14553522f, 0.10646614f, -0.09035052f, 0.11349584f, 0.02642250f, 0.08547385f, -0.11828197f, 0.16595429f, 
    -0.04627072f, 0.07136084f, -0.03495746f, 0.02816030f, 0.06064143f, -0.01484726f, -0.04916786f, 0.04022908f, 
    0.09526425f, 0.09836689f, 0.04979206f, -0.01165378f, -0.22217236f, 0.10631547f, 0.06498516f, -0.10348867f, 
    0.02840427f, 0.22136264f, -0.12281520f, 0.14587511f, -0.00652944f, -0.06347740f, 0.00273534f, 0.15415101f, 
    0.21861975f, 0.01748145f, -0.00850802f, 0.12041370f, 0.11638744f, 0.06274473f, 0.18401632f, 0.05421014f, 
    0.21097016f, -0.01891811f, 0.04377441f, -0.13806190f, 0.13359392f, -0.31634587f, 0.00354887f, 0.15426625f, 
    0.05375060f, -0.10281780f, -0.11955329f, 0.01242689f, 0.23554394f, -0.01532303f, -0.03047714f, 0.08467097f, 
    0.10084658f, 0.07699589f, -0.00725333f, 0.14512208f, 0.77191734f, -0.18956296f, 0.22270267f, 0.03121409f, 
    0.37089035f, 0.19053832f, -0.08152360f, -0.14918029f, 0.09701261f, -0.02943964f, 0.14605987f, 0.04350415f, 
    0.05133551f, 0.03063690f, -0.04294280f, -0.02233866f, -0.22959305f, 0.00545221f, 0.08103962f, -0.00133922f, 
    -0.27466145f, -0.06005536f, 0.23652355f, -0.23438074f, 0.13946161f, -0.10790163f, 0.07413474f, 0.10877349f, 
    0.13794824f, 0.12015361f, -0.05253744f, 0.05813113f, -0.00036182f, -0.03206722f, 0.06767201f, -0.10739585f, 
    -0.14335848f, -0.06881887f, 0.04187041f, -0.14355825f, -0.17977284f, -0.00276143f, -0.01853868f, 0.05444378f, 
    0.15811092f, 0.00674377f, -0.04313415f, 0.02807358f, -0.10284940f, 0.13302851f, -0.03193596f, -0.04805633f, 
    -0.04277182f, -0.10468248f, -0.01355509f, 0.06078199f, 0.08575169f, 0.05410109f, -0.04988014f, -0.01797457f, 
    0.11595087f, 0.00121572f, -0.02534464f, -0.11049616f, -0.15212205f, -0.16713522f, -0.04264653f, 0.16091166f, 
    -0.13874058f, -0.10228002f, -0.02764899f, 0.03965500f, 0.08629360f, 0.06837341f, -0.03300055f, -0.13668470f, 
    -0.02377950f, -0.08529332f, -0.02334760f, 0.00105530f, 0.00905457f, 0.11022159f, 0.12259703f, 0.01997011f, 
    -0.33828551f, -0.14611593f, 0.06134057f, 0.03180712f, -0.22728202f, -0.06061419f, 0.01929448f, -0.11146358f, 
    0.07841237f, 0.06736200f, -0.17021474f, -0.02519729f, 0.01706163f, -0.09798945f, 0.03456680f, 0.05298600f, 
    -0.10230467f, -0.15874718f, -0.04043922f, 0.30927211f, 0.21359125f, 0.20298938f, 0.16775468f, 0.15457772f, 
    0.22240397f, 0.39276510f, 0.03762590f, 0.03968060f, -0.04905472f, -0.08117128f, -0.01434075f, 0.02024291f, 
    0.15581091f, 0.06332826f, 0.09527151f, 0.10506084f, -0.06995212f, 0.13443813f, -0.01702391f, -0.10922222f, 
    0.00135311f, 0.00062316f, -0.22313087f, -0.01106951f, -0.02656771f, -0.22640881f, 0.03121417f, -0.05695662f, 
    0.09776255f, 0.08628176f, 0.01953290f, 0.00386988f, -0.16146824f, -0.06531665f, -0.09321564f, -0.16579981f, 
    0.00525305f, 0.05061083f, 0.19343302f, 0.14938736f, 0.13417333f, 0.08759566f, -0.00706363f, -0.15116426f, 
    0.17188826f, -0.00379063f, -0.04904382f, 0.07077403f, 0.01551126f, 0.04666322f, 0.11366872f, -0.00898927f, 
    0.03449225f, 0.00218242f, 0.08891640f, 0.20703562f, -0.33139849f, -0.09783586f, -0.17811261f, -0.07402695f, 
    -0.09956402f, 0.04233788f, -0.16468710f, -0.06109446f, -0.16781433f, -0.13536300f, -0.06990242f, -0.00763531f, 
    -0.01667358f, 0.13433756f, -0.01465375f, -0.03402192f, -0.10344921f, 0.07423231f, -0.05590388f, -0.16123399f, 
    0.82672399f, 0.54225361f, 0.07009845f, 0.46887514f, -0.23928444f, -0.16268967f, 0.11026490f, -0.13146158f, 
    -0.24161379f, -0.15065339f, -0.07195591f, -0.03138383f, 0.17023604f, -0.12905964f, -0.27378464f, -0.08010002f, 
    0.04640771f, -0.13765788f, 0.06404498f, 0.07064322f, 0.08331097f, 0.01355568f, 0.13398986f, -0.07276792f, 
    0.11560519f, -0.15474431f, -0.04533288f, 0.07292975f, -0.11734091f, -0.00931550f, -0.10299858f, -0.02580190f, 
    0.15749468f, -0.02888683f, -0.10257705f, 0.05231701f, -0.07814290f, -0.15010399f, -0.01567717f, -0.10075113f, 
    0.22330160f, 0.23941849f, -0.04194277f, 0.20120864f, -0.09344731f, -0.02297492f, 0.12641169f, -0.14104474f, 
    0.06631890f, 0.12197138f, -0.16783747f, 0.05230398f, -0.03767872f, -0.06018023f, -0.03013430f, 0.04056323f, 
    0.02598460f, 0.07251894f, 0.02127617f, 0.18522514f, -0.30791679f, -0.19108242f, -0.10277390f, 0.29720300f, 
    -0.08511960f, 0.08140654f, 0.11450204f, -0.10908282f, 0.21654235f, 0.28842360f, 0.01945859f, 0.02090697f, 
    -0.05982176f, 0.08120573f, -0.02138195f, 0.03378386f, 0.01227052f, 0.07349826f, 0.09651182f, 0.17289004f, 
    -0.03365876f, -0.09284745f, -0.12835824f, 0.21133602f, 0.26725775f, 0.08352397f, 0.01634552f, 0.12568103f, 
    0.10211272f, 0.23026359f, 0.06691393f, 0.02597290f, -0.01389049f, -0.04053582f, -0.01790469f, 0.04879325f, 
    0.11358139f, 0.22718646f, 0.05441461f, 0.25640589f, 0.46492809f, -0.14135472f, 0.09874722f, 0.09904552f, 
    0.04183399f, 0.17016467f, -0.00437851f, -0.05369761f, 0.16574198f, -0.09589985f, 0.03674781f, 0.10502126f, 
    0.04794795f, -0.04079318f, -0.06421981f, 0.05049390f, -0.05395751f, -0.10801373f, 0.02505296f, -0.04415668f, 
    0.00664252f, 0.07265458f, 0.00030688f, 0.30480358f, 0.21911000f, 0.11926838f, 0.10830964f, 0.15212475f, 
    -0.08735055f, 0.28220302f, 0.08151115f, -0.05356292f, -0.08251253f, -0.09969388f, -0.05267775f, 0.14954130f, 
    -0.02232732f, 0.16233552f, 0.02279104f, 0.12762915f, -0.08520658f, -0.22783135f, -0.00003797f, -0.05753655f, 
    0.09209038f, -0.01021713f, 0.11934475f, -0.07613107f, 0.16002521f, 0.07502448f, -0.01378301f, 0.04364652f, 
    0.00979769f, 0.03583788f, 0.06674066f, 0.01517943f, -0.00139869f, 0.12612130f, 0.10241967f, 0.06462236f, 
    -0.01885255f, -0.01191341f, -0.02891829f, 0.00777478f, -0.00345837f, -0.03938731f, -0.00095913f, -0.02624840f, 
    -0.02090709f, 0.02974424f, -0.01287689f, -0.02070935f, 0.00108772f, -0.03881603f, 0.00862668f, -0.03596380f, 
    0.02789806f, -0.02516523f, 0.00701275f, 0.02778208f, -0.00977269f, 0.01672185f, 0.00250143f, 0.02495375f, 
    -0.01785303f, -0.00606930f, 0.03247454f, 0.00675695f, -0.03303545f, -0.01810172f, -0.03231099f, -0.02973925f, 
    -0.03820655f, 0.02927634f, 0.00178365f, -0.00439324f, 0.02068541f, -0.04374626f, 0.02974502f, -0.03033702f, 
    0.03026224f, -0.01816632f, -0.03153122f, 0.02983995f, 0.01505009f, 0.01090366f, -0.03387710f, -0.00495202f, 
    -0.01565991f, -0.02415716f, -0.03092807f, -0.02735328f, 0.02507643f, -0.01671025f, -0.02329260f, -0.01320531f, 
    0.02045932f, -0.02186844f, -0.00627261f, -0.04256861f, 0.01751948f, -0.03234198f, -0.03438684f, -0.02731627f, 
    0.00751205f, -0.01269094f, 0.00714693f, -0.00284916f, 0.03201422f, 0.02380187f, -0.04009786f, 0.01020302f, 
    0.01482856f, -0.03985680f, -0.03209732f, -0.04130308f, -0.01810399f, -0.02113663f, -0.00211395f, 0.00068418f, 
    -0.04288728f, 0.01388774f, -0.01095302f, -0.00010257f, -0.00348316f, -0.02025966f, 0.00972359f, 0.01701219f, 
    -0.03260279f, 0.00947579f, -0.01606550f, -0.02768525f, 0.00658147f, 0.01083654f, 0.00341035f, -0.01704835f, 
    -0.01585040f, -0.02628003f, -0.02029659f, -0.00372608f, 0.03289618f, 0.00024322f, -0.02404741f, 0.02886864f, 
    -0.00905900f, 0.01082171f, 0.00545908f, 0.01118370f, 0.00487060f, -0.01706107f, 0.01553439f, -0.03992071f, 
    0.01428645f, -0.00136998f, -0.03806365f, 0.01376049f, -0.01562228f, 0.01363445f, -0.00704155f, -0.03821113f, 
    -0.02892247f, -0.04056975f, 0.02676677f, 0.02807181f, -0.04068340f, -0.02217004f, 0.00858447f, -0.03747388f, 
    -0.04096903f, 0.01577277f, 0.01719409f, 0.03071635f, 0.01217892f, -0.03664026f, 0.03302420f, -0.04269893f, 
    0.00732640f, 0.01831136f, -0.02436832f, -0.01015470f, -0.00670786f, -0.02730285f, 0.01786019f, -0.00075360f, 
    0.02422702f, 0.02025945f, 0.01656940f, 0.01525705f, 0.00885083f, -0.03604998f, 0.00331459f, -0.01394191f, 
    -0.00009078f, -0.02144408f, -0.03628360f, 0.00013423f, 0.02532646f, 0.01803368f, 0.02301606f, -0.00881787f, 
    0.01478608f, 0.02572943f, 0.03160182f, -0.00713391f, 0.01979287f, -0.02958230f, 0.00396590f, -0.01330957f, 
    0.01297706f, 0.01283414f, -0.03335881f, -0.02366506f, 0.02976330f, 0.01438714f, -0.02439900f, 0.00485692f, 
    -0.02057197f, -0.01856626f, 0.02793716f, 0.00615904f, -0.00037451f, -0.03513703f, 0.02191725f, 0.01610497f, 
    0.00953100f, -0.03394639f, 0.00505638f, -0.04177296f, 0.00178343f, 0.01499962f, -0.03160629f, -0.02472742f, 
    -0.04279434f, -0.02059355f, -0.01725086f, -0.01094618f, -0.02562401f, -0.02513184f, -0.02093739f, -0.00135253f, 
    -0.02097130f, 0.01954932f, -0.01432797f, -0.03202715f, 0.02807154f, -0.02767592f, 0.03012659f, -0.03652674f, 
    -0.03010669f, 0.02883350f, 0.01449587f, 0.00644394f, -0.00475403f, -0.02347172f, 0.01179564f, 0.00563953f, 
    0.00147414f, -0.00525681f, 0.02753313f, -0.02089588f, 0.02362016f, -0.02413767f, -0.02042378f, 0.00820580f, 
    -0.00025598f, 0.02252213f, -0.03556535f, 0.01676003f, -0.04189256f, -0.00031179f, -0.01974606f, 0.01562179f, 
    -0.03218463f, -0.01935673f, 0.02898899f, -0.01234746f, 0.01337280f, -0.01961727f, -0.03407216f, 0.00833245f, 
    -0.03949292f, 0.01993254f, -0.03173536f, -0.03824553f, -0.01618720f, 0.02792723f, 0.00176614f, -0.03239383f, 
    -0.01978460f, -0.03338554f, -0.01727709f, -0.02781022f, -0.00326160f, -0.02721794f, 0.01572925f, 0.02388042f, 
    -0.01378187f, 0.01995186f, 0.00175528f, 0.02424304f, 0.01067512f, -0.02612305f, 0.02527194f, 0.02429187f, 
    0.01243888f, 0.03300605f, -0.00378959f, 0.00399021f, -0.02473934f, 0.02156630f, -0.01939778f, 0.02573675f, 
    -0.01283667f, -0.01422251f, -0.01482179f, 0.02613053f, -0.03250596f, -0.01358404f, -0.03736331f, 0.01770299f, 
    0.01018259f, -0.02571754f, -0.00509503f, 0.02528423f, -0.01395648f, -0.01536892f, -0.01162661f, -0.00012904f, 
    0.01887982f, 0.00761186f, -0.02247562f, -0.03665871f, -0.03105631f, -0.01987264f, -0.02784202f, 0.02534324f, 
    -0.01675200f, -0.01292306f, -0.01046839f, -0.03181330f, -0.01641989f, -0.00158488f, 0.02418221f, 0.00999985f, 
    -0.03525457f, -0.02584850f, -0.00812072f, 0.00379730f, -0.02601163f, -0.00889401f, 0.02737293f, 0.02241037f, 
    0.00271455f, 0.00983438f, 0.01443313f, 0.00882509f, 0.02243354f, 0.01705864f, -0.03274730f, 0.01417420f, 
    0.01584302f, -0.03861683f, 0.01179823f, 0.00711366f, -0.01353709f, -0.04359638f, -0.03105821f, -0.02433023f, 
    0.01261290f, 0.03572459f, -0.00631903f, -0.03580669f, -0.01869612f, 0.01167778f, 0.00864919f, -0.02439610f, 
    0.00064152f, 0.01449115f, 0.00610654f, 0.03010377f, 0.00777982f, -0.02383566f, -0.02295758f, -0.03482380f, 
    0.01961683f, -0.00529490f, 0.01200062f, -0.01777159f, -0.00589834f, 0.01411182f, 0.01663387f, 0.03204949f, 
    0.01560539f, -0.01807705f, 0.02976853f, -0.02165590f, -0.03992794f, 0.00330473f, -0.02740880f, 0.03238792f, 
    -0.03702989f, 0.02124704f, -0.00635868f, 0.00345238f, 0.03058448f, 0.01340502f, -0.01661033f, -0.00682940f, 
    -0.03406972f, 0.02122030f, -0.04258459f, -0.01274894f, -0.02908202f, 0.00963730f, -0.03336155f, 0.02045617f, 
    0.02431517f, -0.00013494f, -0.02087969f, 0.02884885f, -0.02283779f, -0.02164423f, 0.01248222f, -0.01129193f, 
    0.01527988f, 0.01575830f, -0.01583467f, -0.00594883f, 0.01749422f, -0.00864545f, 0.01041696f, 0.00588389f, 
    0.01839401f, 0.03246387f, -0.02175416f, -0.04371680f, 0.03218080f, -0.01147175f, -0.00611423f, 0.02069837f, 
    0.02773118f, -0.03381668f, 0.01382863f, 0.01376496f, -0.01072538f, -0.00660055f, 0.01232181f, -0.01622765f, 
    0.02442885f, -0.02224476f, 0.00413376f, -0.00088511f, -0.01499697f, -0.02149236f, 0.03006447f, -0.01410798f, 
    -0.03173009f, -0.03473258f, -0.00210207f, 0.02365388f, -0.00152423f, -0.02864746f, 0.02015903f, 0.00371278f, 
    0.03193046f, -0.03616372f, -0.04292899f, 0.02228848f, 0.01077178f, -0.00443950f, -0.01607013f, -0.00455549f, 
    -0.04237517f, 0.02891826f, -0.01450722f, -0.01376058f, 0.01833996f, -0.02668481f, 0.01929383f, 0.00634711f, 
    0.00789999f, -0.03676972f, 0.00215485f, 0.01339737f, -0.04530867f, -0.04356607f, -0.03363851f, -0.04233745f, 
    -0.03085343f, -0.02644115f, 0.02701639f, -0.03894942f, -0.03752570f, -0.00189975f, -0.00170575f, 0.03146082f, 
    -0.03849713f, -0.04351887f, 0.00101641f, 0.02933644f, -0.00446682f, 0.02847893f, -0.03506614f, 0.01383306f, 
    -0.00837268f, -0.00934588f, 0.03249217f, 0.02961414f, -0.03923371f, -0.02807670f, -0.01130726f, 0.02252630f, 
    -0.01426667f, 0.01921421f, -0.03350206f, 0.01087756f, 0.03699429f, 0.03157138f, 0.01960708f, -0.02384973f, 
    0.01382524f, -0.00184737f, -0.03030837f, 0.00461351f, -0.02074754f, -0.02891210f, 0.01832396f, -0.00224248f, 
    -0.03606844f, -0.01932938f, -0.02194691f, -0.02140916f, 0.03546031f, 0.02054428f, 0.03469849f, 0.01425688f, 
    -0.01015934f, 0.03138473f, 0.01458694f, -0.01282341f, -0.00084185f, -0.02337180f, -0.03960888f, 0.00924925f, 
    -0.00162332f, -0.00976726f, -0.03091558f, -0.00290556f, -0.01049286f, -0.00108867f, -0.03185607f, 0.00647483f, 
    0.00170555f, 0.00830114f, -0.02632101f, 0.01490674f, 0.02146221f, -0.02652165f, -0.01390420f, 0.02606344f, 
    0.00606238f, -0.00711435f, -0.03836467f, -0.03525275f, 0.02736516f, -0.01976667f, -0.03347572f, -0.00067841f, 
    -0.03669186f, 0.03029360f, 0.02764533f, 0.03011297f, -0.03180999f, 0.01658477f, -0.01807386f, -0.01414400f, 
    -0.04015421f, -0.04355519f, -0.01326503f, 0.02312548f, 0.02330145f, -0.04261342f, -0.00227700f, 0.01799930f, 
    -0.00426812f, 0.03298698f, 0.01468065f, -0.00711430f, -0.00951646f, 0.01000389f, -0.03916433f, 0.01349317f, 
    -0.00494031f, -0.01070069f, -0.00702180f, 0.02120192f, 0.02833349f, 0.00892270f, 0.00126370f, -0.03317707f, 
    0.02559271f, 0.02486648f, -0.03738002f, 0.02914004f, 0.01968867f, 0.00228549f, -0.02277046f, 0.03255246f, 
    0.02473113f, -0.03684203f, -0.00016126f, -0.01559566f, 0.02838866f, -0.00853361f, 0.01976882f, -0.04116426f, 
    0.02313216f, 0.01925865f, 0.02228612f, 0.02825660f, -0.02118552f, 0.01037263f, -0.04450923f, 0.00383152f, 
    0.00115785f, 0.02627626f, -0.00170384f, -0.00608472f, -0.04234489f, -0.00210384f, 0.00596316f, -0.03286727f, 
    0.03018775f, -0.03898246f, -0.04032255f, 0.02734226f, 0.03643757f, 0.00048487f, -0.02335546f, -0.03720821f, 
    0.00779801f, -0.03191422f, -0.01116436f, -0.02939788f, -0.00238207f, -0.01038977f, 0.03021350f, -0.03106440f, 
    0.01309417f, -0.00343104f, 0.03158285f, -0.02182920f, 0.01922472f, 0.02157956f, -0.02249555f, -0.02079762f, 
    -0.00140974f, 0.02448949f, -0.01175149f, -0.00801123f, 0.01845405f, -0.01551982f, 0.01485357f, -0.04084796f, 
    -0.03536321f, 0.00963116f, 0.02535189f, 0.01883968f, -0.02388779f, -0.03351172f, -0.00617836f, -0.01607826f, 
    0.00607926f, -0.02060190f, -0.03594581f, -0.03284099f, -0.04216002f, 0.02417466f, 0.00560223f, -0.00346168f, 
    0.00751504f, 0.00643400f, -0.03691864f, 0.03054719f, -0.04524823f, 0.03191423f, -0.01225725f, 0.02993287f, 
    -0.01210879f, 0.01589227f, -0.02600550f, 0.01722518f, 0.02865362f, -0.02441780f, -0.02013777f, 0.03317415f, 
    -0.02669321f, -0.03943960f, -0.01082104f, -0.02437113f, -0.03245183f, 0.00380104f, -0.01984660f, -0.03564791f, 
    0.00606418f, -0.02975339f, -0.00132015f, 0.00519442f, -0.04139436f, 0.00916548f, -0.03742613f, -0.03376384f, 
    -0.03739237f, 0.01044120f, 0.02180215f, -0.04161454f, 0.01357221f, -0.03373020f, 0.03395280f, -0.01027923f, 
    -0.00133635f, 0.02689068f, -0.04030105f, -0.01216012f, -0.03537904f, -0.03761404f, -0.02859393f, -0.03556825f, 
    0.01144416f, -0.01606506f, 0.00336778f, -0.03382936f, 0.02742915f, -0.04324913f, -0.02943325f, -0.02064568f, 
    -0.00176705f, 0.01094428f, 0.00949291f, 0.00962057f, -0.02943986f, 0.02463783f, 0.00303498f, -0.01459487f, 
    0.01581217f, 0.02231641f, 0.02887125f, 0.01708540f, -0.04378602f, 0.00259804f, 0.03144716f, 0.02875588f, 
    -0.01569570f, 0.00327620f, 0.02879095f, -0.01000510f, -0.03105565f, 0.01193356f, 0.02615787f, -0.01667488f, 
    0.01341377f, -0.04165647f, 0.01675426f, 0.00923002f, -0.01462113f, -0.01831727f, -0.02240021f, -0.01983313f, 
    0.04643473f, -0.02264816f, -0.03718691f, 0.01018522f, 0.02990197f, 0.02995732f, -0.03360662f, 0.02269325f, 
    -0.02376084f, 0.01843946f, 0.03255393f, -0.01290336f, 0.03048254f, 0.01384597f, 0.02845289f, 0.03245552f, 
    -0.04420796f, 0.01205534f, -0.04510317f, 0.00635728f, -0.00294423f, 0.00715286f, -0.02373939f, 0.03042269f, 
    -0.03090610f, -0.03558606f, 0.01763809f, -0.03770833f, 0.00800241f, 0.00357153f, 0.02693861f, -0.01039391f, 
    -0.03302392f, 0.02425162f, -0.04468247f, 0.02078097f, 0.03126943f, 0.01185118f, -0.00985367f, 0.01058557f, 
    0.01906544f, -0.02244289f, -0.01062297f, -0.03446355f, -0.04311249f, -0.02976068f, 0.03034051f, 0.02586420f, 
    -0.03935026f, 0.01707273f, -0.00526427f, -0.02410045f, 0.00508336f, -0.02999187f, -0.02465489f, 0.03266504f, 
    0.02885131f, 0.02334307f, -0.04370864f, -0.01633662f, 0.03266634f, -0.01876871f, 0.00980939f, 0.00120745f, 
    0.00680597f, 0.02218827f, -0.00198469f, 0.02383810f, 0.00488965f, -0.00604487f, 0.00236902f, -0.03584182f, 
    0.02923889f, 0.03309578f, -0.03093648f, -0.03618990f, 0.01069554f, -0.01668357f, -0.04376126f, -0.01245370f, 
    -0.04420747f, -0.03568473f, 0.01929739f, 0.03135911f, -0.04279039f, -0.03584661f, -0.03030842f, -0.00619622f, 
    -0.00820100f, -0.01983843f, -0.01990611f, 0.00615291f, 0.02371860f, -0.02850270f, -0.02600367f, 0.00893879f, 
    -0.03206483f, 0.03148137f, -0.03893253f, -0.03261020f, -0.03122644f, -0.00207276f, -0.02550512f, 0.03242991f, 
    0.00723024f, 0.00526051f, 0.03500607f, 0.02456808f, -0.01732849f, -0.03152826f, 0.02621802f, 0.01944381f, 
    -0.03978327f, -0.00411282f, -0.03214654f, 0.02888862f, 0.02640242f, -0.03702248f, 0.02547183f, 0.02021853f, 
    0.02668222f, 0.01395245f, -0.00185875f, -0.00878530f, 0.01043634f, 0.01149979f, -0.01301993f, -0.01530744f, 
    0.00566721f, 0.02072467f, -0.02813252f, -0.02190450f, 0.00548902f, 0.01835053f, -0.02372573f, -0.02797996f, 
    -0.04275590f, 0.00763549f, -0.04085330f, 0.01400147f, 0.02581117f, -0.01065708f, -0.03894741f, -0.02999380f, 
    0.01346018f, -0.00416847f, -0.02782815f, 0.01796981f, -0.03392856f, 0.02547932f, -0.04017837f, -0.01650400f, 
    -0.00976289f, 0.03158845f, -0.01630377f, -0.03977846f, -0.00996685f, 0.00027140f, -0.03191523f, -0.00692956f, 
    0.02606953f, -0.03709389f, -0.00192385f, -0.04413510f, -0.01516001f, -0.01352139f, 0.02403776f, 0.01600504f, 
    0.00666762f, -0.00428235f, -0.02389645f, -0.02602683f, -0.03305418f, 0.00942174f, 0.01049467f, -0.03138146f, 
    -0.00067900f, 0.03075493f, -0.01194123f, -0.04155655f, -0.04494833f, 0.01890793f, -0.02822631f, -0.00564943f, 
    -0.00003646f, -0.03222492f, 0.02783933f, -0.00238555f, 0.02421660f, -0.00526252f, -0.02473870f, 0.00739137f, 
    0.01406026f, -0.01179321f, 0.02164776f, 0.02034995f, 0.03040817f, -0.02451639f, 0.00148865f, 0.00638876f, 
    -0.02875772f, -0.03871109f, 0.00752171f, 0.02016988f, 0.01917595f, 0.01675564f, 0.00602874f, 0.02328191f, 
    -0.03283842f, 0.03367548f, 0.02073854f, -0.00348022f, 0.00565390f, 0.01465183f, 0.02333624f, 0.01090747f, 
    0.00968025f, -0.02769531f, -0.00829785f, 0.01162527f, -0.01307226f, 0.04267942f, -0.02687466f, -0.01045430f, 
    -0.03803715f, -0.01939909f, 0.02141699f, -0.03631091f, -0.04207686f, 0.02023174f, -0.02435011f, -0.00257431f, 
    -0.04134151f, 0.00971562f, -0.00103721f, 0.02942251f, -0.01375072f, -0.04471188f, 0.01299831f, 0.02105673f, 
    0.01473523f, -0.04254201f, 0.00217559f, 0.00888063f, -0.01687481f, -0.03289165f, -0.03284601f, 0.01134354f, 
    0.03271189f, 0.02453816f, 0.02701070f, -0.02636125f, -0.02960129f, 0.00487524f, 0.00076998f, 0.01961309f, 
    0.02934366f, -0.03029197f, -0.00735863f, 0.00676270f, -0.04036257f, -0.01524534f, 0.01872258f, 0.02203627f, 
    -0.00169888f, 0.01670898f, 0.00327748f, 0.01213810f, 0.02439139f, -0.03296203f, -0.01138487f, -0.03458321f, 
    -0.00621354f, 0.01128120f, -0.04157512f, 0.02061627f, -0.03129124f, -0.02931596f, -0.00680821f, -0.03251113f, 
    -0.00033068f, 0.03067819f, -0.00788476f, -0.01256668f, -0.01874131f, 0.01687317f, 0.04091225f, 0.03110562f, 
    -0.01626467f, -0.04317050f, 0.00547722f, -0.01508727f, -0.02045575f, 0.02151966f, -0.00619657f, 0.00670951f, 
    -0.02929585f, -0.02991821f, -0.00296028f, -0.03045981f, -0.02160789f, -0.01513136f, -0.00829623f, 0.02720635f, 
    -0.04452812f, -0.01029094f, 0.02796798f, -0.01167641f, 0.02134543f, -0.00309238f, 0.02857319f, 0.02382374f, 
    -0.04182285f, 0.04174642f, 0.02115224f, 0.00078839f, -0.00738338f, 0.04497926f, 0.01063558f, -0.02006575f, 
    -0.00326645f, 0.01649304f, -0.00396869f, 0.02940463f, 0.01365240f, 0.03058130f, -0.02656141f, 0.03244218f, 
    0.01721682f, -0.02457896f, -0.01843309f, -0.01522211f, 0.02621733f, -0.04239713f, -0.01211479f, -0.00847765f, 
    -0.04418803f, 0.01361427f, -0.01481073f, 0.03077554f, -0.02737085f, -0.00954793f, -0.02502747f, -0.00033666f, 
    0.02243583f, 0.02702293f, 0.03187231f, -0.00392921f, -0.01934279f, -0.04463037f, 0.03838022f, -0.03739242f, 
    -0.01530328f, 0.02848663f, 0.01701712f, -0.02924254f, -0.01476679f, -0.01554863f, 0.02265116f, -0.03719974f, 
    -0.00461873f, -0.01481164f, -0.02826354f, -0.01914927f, -0.01909999f, 0.00803691f, -0.03243569f, -0.04239468f, 
    0.00792610f, -0.02270392f, 0.00448959f, 0.03243318f, 0.02340315f, -0.02086343f, -0.02402638f, -0.02191898f, 
    -0.02840392f, -0.03206936f, -0.01542975f, 0.04108997f, -0.03336590f, 0.03045088f, 0.02078619f, -0.00676043f, 
    0.00545458f, 0.02733485f, 0.04392661f, 0.03460480f, 0.01079052f, -0.03418368f, -0.00466614f, 0.01297560f, 
    0.02795956f, -0.02498697f, -0.01932175f, -0.02003117f, 0.01958027f, 0.02551479f, -0.00655545f, 0.02995201f, 
    0.00842408f, -0.03710015f, 0.02076074f, 0.01445493f, 0.01196148f, 0.03457382f, 0.01410002f, -0.01939871f, 
    -0.00667663f, -0.03444484f, 0.01941490f, -0.00411387f, 0.00970159f, 0.01255918f, 0.03072931f, 0.00642757f, 
    0.03070949f, -0.04536106f, 0.02140702f, -0.04243267f, 0.01506159f, -0.01457484f, -0.03805192f, -0.04382069f, 
    0.00859341f, -0.01851766f, 0.01439565f, -0.03679994f, -0.03720107f, -0.01668257f, -0.03271665f, -0.02990342f, 
    -0.00722904f, -0.03441613f, -0.02214793f, -0.00674428f, 0.02524977f, 0.00568080f, -0.00667644f, 0.01797003f, 
    0.00886399f, -0.02679612f, -0.03046816f, -0.02784405f, -0.00641750f, -0.02432342f, -0.00110362f, -0.03979663f, 
    -0.00583407f, 0.02393771f, -0.04330992f, -0.04219896f, 0.03898935f, 0.03272007f, -0.01562318f, 0.00396057f, 
    -0.04380682f, 0.03228813f, -0.02476852f, 0.01736013f, 0.01861221f, 0.01746053f, 0.02433629f, 0.02340309f, 
    0.02332258f, -0.03551339f, -0.01795560f, 0.00721914f, 0.03152267f, -0.02968216f, 0.00475367f, 0.02483699f, 
    -0.01380248f, 0.02623486f, -0.01151619f, 0.00971121f, -0.00206000f, 0.00054529f, -0.04341716f, -0.00282660f, 
    0.01859412f, 0.01993000f, 0.01991736f, -0.03442165f, 0.02242570f, -0.03610390f, -0.01082204f, -0.04310446f, 
    -0.00910750f, 0.01275303f, 0.02243645f, -0.03908411f, 0.01640103f, -0.02580524f, -0.03792500f, -0.03928381f, 
    0.02451724f, -0.00472405f, -0.02852261f, -0.04368660f, 0.01074834f, -0.02823657f, 0.01988329f, -0.01022011f, 
    0.01656347f, 0.02975729f, 0.00336801f, -0.01110206f, -0.01334300f, -0.00403003f, -0.00216235f, 0.01008742f, 
    -0.01182038f, -0.00190550f, 0.02242154f, -0.04356471f, -0.01193111f, -0.01855912f, 0.00268780f, 0.00170053f, 
    -0.02513862f, 0.02998135f, 0.00556878f, -0.04225673f, 0.00975669f, -0.02174776f, 0.01949895f, -0.03329713f, 
    0.01927292f, -0.03941845f, -0.00731170f, -0.00450990f, 0.02267046f, 0.00302194f, -0.00147426f, -0.02657438f, 
    -0.03752628f, 0.01168241f, 0.03066966f, -0.03885540f, 0.01908261f, -0.03608996f, 0.00058731f, 0.02290436f, 
    -0.03924152f, -0.01488289f, -0.01887816f, -0.00797801f, -0.04035590f, -0.00588002f, -0.02232023f, -0.02602076f, 
    -0.00953983f, 0.01598890f, 0.10763864f, 0.14874552f, 0.08976449f, -0.09897070f, 0.13438912f, 0.05957445f, 
    0.06501360f, -0.11561347f, 0.02741287f, 0.03546363f, -0.02734929f, 0.16644098f, 0.01284906f, 0.07642306f, 
    0.11753081f, -0.02292965f, -0.08818448f, -0.01995079f, 0.04455756f, -0.04054508f, -0.03410450f, 0.00126520f, 
    0.02447906f, 0.12582865f, -0.02107494f, 0.16241331f, -0.02306218f, 0.03768820f, -0.00855434f, -0.02808141f, 
    0.12823227f, -0.05409516f, -0.01644010f, 0.11798421f, -0.06099705f, 0.32119071f, -0.21356189f, 0.07127224f, 
    -0.02610167f, 0.09237347f, 0.34763297f, 0.14979051f, 0.11878437f, 0.00101230f, -0.07084683f, 0.08714286f, 
    -0.04672959f, 0.06667730f, -0.05429422f, 0.05419815f, 0.11285458f, 0.00604976f, -0.02972534f, 0.00804557f, 
    -0.03644468f, -0.04066643f, 0.07554223f, -0.02944743f, -0.03306779f, 0.01341146f, -0.14313214f, 0.32009140f, 
    -0.05181426f, -0.02341516f, 0.02440975f, 0.10620322f, 0.06222368f, 0.04169724f, -0.08929678f, 0.01489239f, 
    0.00290613f, 0.01083460f, -0.01058538f, 0.04522902f, -0.07929399f, -0.07425155f, 0.13268532f, 0.20887235f, 
    0.30387282f, 0.03051406f, -0.02075046f, -0.31807420f, 0.07431814f, 0.05929176f, 0.00151150f, 0.17826512f, 
    0.34261405f, 0.02603197f, -0.00291984f, -0.12924354f, 0.10584614f, -0.01959022f, -0.01019110f, -0.09989467f, 
    -0.03648054f, 0.06286430f, -0.16440061f, -0.03871340f, -0.19875661f, -0.31713390f, 0.23048483f, -0.12883471f, 
    -0.03395168f, 0.14345957f, -0.07348561f, 0.00233931f, 0.17903814f, 0.00048247f, -0.10131308f, -0.20795517f, 
    0.03478329f, 0.10552839f, -0.00391560f, -0.10605534f, -0.06804119f, 0.01590841f, 0.09223226f, -0.10617337f, 
    0.08489396f, -0.31659439f, -0.28047320f, 0.39119807f, -0.23892625f, 0.11104473f, -0.03923864f, 0.26560074f, 
    -0.25789270f, 0.09127139f, -0.20814539f, -0.03631473f, -0.12607031f, 0.10313905f, 0.05236258f, 0.03110890f, 
    -0.02575335f, 0.00146837f, 0.15066962f, 0.12420371f, -0.11247493f, -0.14067814f, 0.19811295f, -0.08575806f, 
    -0.01819759f, -0.05445110f, -0.01619600f, 0.05906279f, 0.09955655f, 0.06171475f, 0.01250274f, 0.02833545f, 
    0.02848739f, 0.14035285f, 0.14150666f, -0.06718706f, -0.10747505f, 0.06171166f, 0.07871604f, -0.11009815f, 
    0.31782836f, 0.03756651f, 0.13472062f, 0.03565316f, -0.05686118f, -0.10193579f, -0.09253168f, 0.00810828f, 
    -0.06526067f, 0.17243594f, 0.03484361f, 0.02107068f, 0.03622347f, -0.09646896f, -0.00781891f, -0.02727244f, 
    -0.01772289f, -0.01168723f, -0.08071931f, 0.01702783f, -0.01929783f, -0.03016345f, -0.12203195f, -0.04719564f, 
    -0.06557623f, -0.03480715f, 0.03965054f, 0.05050090f, 0.01988601f, 0.04837684f, -0.05277190f, 0.03389498f, 
    0.14093356f, 0.01518974f, 0.02733755f, 0.17587908f, 0.02447363f, 0.00830797f, 0.00969972f, -0.01097198f, 
    -0.19751438f, -0.18888551f, -0.04186563f, 0.06672457f, -0.04146378f, -0.08544958f, 0.04942374f, -0.01370738f, 
    -0.11942884f, 0.00100991f, -0.08398337f, -0.01022299f, -0.04511362f, 0.09991302f, -0.04617231f, -0.01055085f, 
    0.15292458f, 0.06353407f, 0.00942930f, 0.03592390f, -0.09380291f, 0.06063576f, 0.07548787f, 0.36758175f, 
    -0.05185920f, -0.00784760f, 0.08391868f, 0.14331974f, 0.05233237f, 0.14091225f, -0.05654192f, 0.03315052f, 
    0.00610974f, -0.02817701f, 0.01642324f, 0.01529999f, -0.09538257f, 0.03578093f, 0.02298108f, 0.07327782f, 
    -0.23438177f, 0.11829317f, -0.25884765f, -0.02399535f, -0.09239743f, -0.02345142f, -0.00562067f, 0.01176015f, 
    -0.05585609f, 0.04161897f, 0.03299136f, 0.06513655f, -0.02949489f, 0.06873740f, -0.06736571f, -0.05082806f, 
    0.04117070f, 0.13346778f, -0.08247310f, 0.01230562f, -0.74022758f, -0.11258235f, -0.07007753f, 0.26003274f, 
    -0.10564216f, 0.06197953f, 0.02750512f, 0.00144373f, -0.03097386f, 0.02963209f, 0.05377726f, 0.07835025f, 
    -0.01320996f, 0.06753170f, 0.02595802f, -0.10089498f, 0.03390134f, -0.09170892f, -0.04812603f, -0.02429174f, 
    -0.06730857f, -0.22683302f, 0.06883423f, 0.35749707f, -0.22206150f, -0.00667930f, -0.00170294f, -0.02378257f, 
    -0.10119523f, -0.05192410f, -0.03557469f, -0.00987530f, -0.10367291f, -0.07566204f, 0.01963014f, -0.00926169f, 
    0.04947472f, -0.10106796f, 0.11221236f, 0.12442704f, 0.16941173f, 0.02907681f, 0.08848114f, 0.05136513f, 
    -0.06092799f, -0.03771876f, 0.02141589f, -0.03946702f, -0.02145122f, 0.07251786f, 0.09355953f, -0.08353419f, 
    0.03051627f, -0.03016306f, 0.04260790f, 0.05385588f, 0.00052229f, -0.00849784f, -0.05586799f, -0.03495095f, 
    -0.01200188f, 0.06538910f, 0.30147153f, 0.11518202f, -0.00222353f, -0.05667518f, 0.00494809f, -0.07894014f, 
    0.11209556f, 0.05542593f, 0.05628182f, -0.00995077f, 0.03357830f, -0.01805261f, 0.04342550f, 0.04047526f, 
    -0.00550575f, -0.18559666f, -0.04157465f, -0.17766021f, 0.29747450f, 0.04067457f, -0.23130377f, 0.15606478f, 
    0.02066279f, 0.04176934f, -0.00017785f, -0.02515102f, -0.05269708f, -0.03593640f, 0.01986006f, 0.02065563f, 
    -0.00773998f, -0.02280205f, -0.02146958f, -0.03052569f, 0.07191236f, 0.08229952f, 0.01708225f, 0.08943295f, 
    -0.08021172f, -0.21747196f, -0.05736180f, -0.23423396f, -0.16722649f, 0.05022227f, 0.03154499f, 0.06283601f, 
    0.06036672f, 0.03812994f, 0.13264506f, 0.01294559f, 0.01864353f, 0.11047645f, 0.04386817f, -0.03455710f, 
    0.05718867f, 0.14456293f, -0.09988800f, 0.01898432f, 0.08790189f, -0.01822984f, -0.12685989f, 0.30134219f, 
    -0.25312588f, -0.03996749f, 0.05536043f, -0.04338592f, 0.01165598f, 0.02317306f, 0.03949445f, -0.14696334f, 
    -0.06729306f, 0.07237358f, -0.02152298f, 0.03854505f, 0.13952114f, 0.05367063f, -0.10769417f, 0.05586326f, 
    0.08372147f, 0.14636762f, 0.21960281f, 0.17584489f, 0.03505414f, -0.02410606f, 0.19373265f, -0.06489418f, 
    0.21671157f, -0.01345729f, -0.00745422f, 0.04892822f, 0.04014913f, 0.05137010f, -0.04046455f, 0.17950021f, 
    0.05548452f, -0.03657588f, 0.05478422f, 0.09760886f, -0.06106580f, -0.12162936f, -0.01890552f, -0.18131597f, 
    -0.11329286f, 0.03566336f, -0.00638345f, 0.00052355f, -0.02566738f, 0.01071988f, -0.01926441f, -0.01399746f, 
    0.04503910f, 0.02084190f, 0.02301552f, 0.07738125f, -0.05403534f, 0.11833160f, -0.12223619f, 0.00934318f, 
    -0.01003446f, -0.10189868f, 0.04065398f, 0.19289166f, 0.01823019f, -0.11534338f, -0.00479506f, -0.02333044f, 
    -0.13034557f, 0.13110088f, -0.14930877f, 0.07327693f, -0.01918042f, -0.02150583f, 0.02019298f, -0.07162493f, 
    0.05855939f, 0.08727493f, -0.09063860f, -0.00064165f, -0.14596084f, -0.08570264f, -0.04921416f, -0.08998905f, 
    -0.02803438f, 0.03329333f, 0.01784132f, -0.05193899f, 0.03844327f, 0.05081875f, -0.04533893f, -0.02704457f, 
    0.08858751f, 0.11991152f, 0.09796556f, 0.05588285f, 0.00773408f, -0.05121280f, 0.06104333f, -0.01592289f, 
    0.25340998f, -0.59069902f, -0.17142037f, -0.18392621f, -0.19226566f, 0.02813695f, -0.03304711f, 0.09271812f, 
    -0.06590863f, 0.13048458f, 0.00912077f, 0.06024138f, -0.04085600f, 0.08684680f, -0.05295110f, -0.17254508f, 
    -0.11087668f, 0.02499954f, -0.02175119f, 0.07956853f, 0.25796089f, -0.22828111f, -0.22960787f, 0.16467534f, 
    -0.10467443f, 0.03921086f, -0.01072352f, 0.01987226f, -0.11515451f, 0.03171956f, -0.08731613f, 0.02769008f, 
    -0.01010359f, 0.02331670f, -0.03538517f, -0.03722299f, 0.09912191f, -0.05228274f, 0.04229682f, 0.04343116f, 
    -0.00591131f, -0.27857864f, 0.00875376f, 0.29825938f, -0.13297890f, -0.12521286f, 0.00596273f, 0.22695196f, 
    -0.18261878f, 0.00292120f, -0.05248292f, -0.09577620f, 0.04642182f, 0.02413657f, -0.00489092f, -0.02324545f, 
    -0.02643215f, 0.06003788f, 0.05415729f, 0.08342409f, -0.05437984f, -0.05568696f, -0.00614368f, 0.10647680f, 
    0.01670199f, -0.21354038f, 0.01268660f, 0.05262630f, -0.09849698f, 0.06805594f, -0.02006115f, 0.01726716f, 
    0.03995717f, 0.11326586f, 0.05043115f, 0.10762165f, 0.08222329f, -0.12113833f, 0.13600731f, 0.06483176f, 
    0.02540175f, 0.10973515f, 0.01270328f, 0.12001925f, 0.13739882f, -0.02312244f, 0.11743749f, 0.08730068f, 
    0.04022438f, 0.04247626f, -0.00389148f, -0.01980846f, 0.01360079f, 0.05131911f, -0.04566324f, 0.08760588f, 
    0.03421141f, 0.00768810f, 0.02793978f, 0.16836634f, 0.11887801f, 0.10014208f, 0.16293237f, 0.37017572f, 
    -0.03755560f, 0.04797740f, 0.06314005f, -0.05306967f, -0.14934188f, 0.03185550f, 0.00349299f, 0.04583415f, 
    -0.14370723f, -0.02282675f, 0.05562091f, -0.01977015f, -0.06968780f, -0.06204406f, -0.05850229f, -0.05643091f, 
    0.24500452f, 0.13288221f, -0.01001314f, 0.33118853f, 0.10430024f, -0.00058186f, -0.02237537f, 0.11184829f, 
    0.06526188f, 0.08571716f, 0.03888543f, -0.00109682f, 0.05652792f, -0.08432146f, -0.09256356f, 0.08737997f, 
    0.09855362f, 0.08911346f, 0.06865082f, 0.06470314f, -0.05145045f, -0.27317327f, 0.07706045f, 0.15514231f, 
    -0.05930026f, -0.14156681f, -0.08508419f, 0.02656994f, -0.14544033f, -0.00087392f, -0.07150118f, -0.05722214f, 
    0.02704380f, 0.03053522f, -0.04953926f, 0.10687219f, 0.11946651f, -0.00851810f, -0.00139341f, -0.04332709f, 
    -0.19685128f, 0.02741657f, 0.06909143f, -0.06692917f, -0.08893664f, 0.02447680f, 0.31008670f, 0.11630580f, 
    0.00955456f, 0.10616835f, -0.04878555f, -0.01014502f, 0.01241597f, -0.04306160f, 0.05681146f, -0.12395019f, 
    -0.17407800f, 0.12316646f, 0.08613567f, 0.18894102f, 0.04039611f, -0.24514689f, 0.15600024f, -0.20829453f, 
    -0.20151201f, 0.08553486f, -0.06363754f, -0.03807027f, -0.01211318f, 0.01903191f, -0.00851299f, 0.01866745f, 
    -0.00039313f, -0.00906495f, -0.01664838f, -0.05305232f, 0.23026145f, -0.10086575f, 0.15885726f, 0.12052056f, 
    -0.23220840f, -0.03652887f, -0.35880613f, -0.17000394f, -0.17008692f, 0.08193279f, -0.01778804f, -0.00331295f, 
    0.01612532f, -0.06806222f, -0.03940955f, -0.04366643f, -0.08774186f, 0.04571666f, 0.07939499f, -0.03289041f, 
    0.00427810f, 0.14494711f, -0.11978307f, -0.03632893f, -0.01503130f, -0.03013846f, 0.06635771f, -0.35788924f, 
    0.11458759f, -0.08134907f, 0.14931881f, 0.04159649f, 0.01422491f, 0.02249717f, -0.02314736f, -0.06647924f, 
    -0.02844273f, 0.00677434f, -0.01270744f, 0.25279626f, -0.01563958f, 0.09426985f, 0.11667977f, -0.12408059f, 
    -0.62198526f, -0.49207455f, 0.54625225f, 0.08456391f, 0.17584750f, 0.05406130f, -0.05488837f, 0.15277490f, 
    -0.04831867f, 0.14647938f, 0.21214370f, 0.09942468f, 0.01158490f, 0.03544479f, -0.05727337f, -0.15173048f, 
    0.22739077f, 0.00347319f, 0.14964247f, -0.01615121f, -0.19227421f, 0.15335993f, 0.23962598f, 0.01480961f, 
    0.16254632f, -0.33961859f, 0.10295071f, 0.09531231f, -0.13610944f, 0.15516791f, 0.07347379f, -0.07659696f, 
    0.14895152f, 0.10179529f, -0.17388332f, -0.11269449f, 0.27909297f, -0.00903205f, 0.16261376f, -0.31007928f, 
    0.16283497f, 0.05927161f, -0.36750436f, 0.03073196f, 0.22097571f, 0.06294256f, -0.00641230f, -0.03489058f, 
    0.25590730f, 0.00538386f, 0.00019990f, 0.07090025f, 0.17891036f, -0.09971838f, -0.02754197f, -0.17294064f, 
    0.06476590f, 0.01444656f, 0.14609469f, 0.22265702f, 0.12049782f, 0.14225382f, 0.11327121f, 0.07601939f, 
    -0.04083348f, 0.05685966f, -0.01835464f, -0.10073910f, 0.14405206f, -0.16258539f, -0.02710353f, 0.17924738f, 
    0.08870091f, 0.07272617f, -0.17405938f, 0.12819667f, 0.28118429f, 0.06038139f, 0.08835057f, -0.00905163f, 
    0.04048552f, 0.02182181f, 0.36482427f, 0.01735403f, 0.28564841f, -0.10016444f, -0.00283523f, 0.14131959f, 
    0.09532848f, 0.06267826f, -0.18332554f, 0.16952556f, 0.02864867f, -0.00683927f, -0.07053776f, 0.00647399f, 
    -0.03996637f, -0.03887082f, 0.02434683f, 0.05050340f, -0.00191770f, -0.01626658f, -0.00648636f, -0.06032902f, 
    0.01545365f, 0.04848505f, -0.14234383f, -0.04398038f, 0.04545156f, 0.05888960f, -0.05267740f, -0.03142426f, 
    -0.03963020f, 0.03785750f, -0.05988685f, -0.22466563f, -0.04069003f, -0.12089700f, 0.07654884f, 0.01591489f, 
    0.11179375f, 0.11568139f, 0.18508069f, 0.19749005f, 0.02372415f, -0.02818207f, 0.08977201f, 0.15264840f, 
    0.11814450f, -0.01331091f, 0.03040162f, 0.02884874f, 0.05811453f, -0.14401986f, -0.06697493f, 0.03329216f, 
    0.21770039f, 0.01971395f, 0.03411406f, 0.07363146f, -0.04087948f, -0.24656329f, 0.05653397f, -0.15814553f, 
    0.02633556f, -0.02047463f, 0.03863204f, -0.10089377f, -0.05733626f, -0.07233027f, -0.07561752f, -0.02386567f, 
    0.02467747f, 0.10393943f, -0.00012636f, 0.04029424f, -0.11804149f, 0.02629763f, 0.06354086f, -0.02726300f, 
    -0.01724083f, -0.09922169f, 0.03141898f, -0.16712634f, -0.17235833f, -0.03113222f, -0.11801405f, 0.01365053f, 
    -0.04255630f, -0.02729057f, -0.06748267f, 0.06087166f, -0.00629211f, 0.05851437f, 0.02402827f, 0.14514720f, 
    0.04045613f, 0.01586146f, 0.23939896f, 0.03452810f, 0.55918646f, 0.30040219f, -0.06047328f, 0.13362002f, 
    -0.23886968f, -0.10803980f, -0.03298634f, -0.02567992f, -0.04789403f, 0.09991828f, -0.13928209f, 0.17727537f, 
    -0.10215115f, 0.04048240f, -0.00428571f, -0.04818007f, -0.09590555f, 0.10253577f, 0.19914979f, 0.05521934f, 
    0.03846647f, -0.08198047f, -0.18410774f, 0.10397547f, 0.02082198f, -0.02133043f, -0.02065017f, 0.00097953f, 
    0.01209642f, 0.06536225f, -0.05724370f, 0.00167515f, 0.01530192f, -0.13425110f, 0.15441388f, 0.01785778f, 
    -0.12987410f, 0.04723155f, 0.18198739f, 0.03211548f, -0.10507537f, 0.08327907f, 0.11794536f, 0.04179325f, 
    0.00529559f, 0.01748685f, 0.04630266f, 0.10819628f, 0.08958519f, -0.17654872f, -0.10372024f, 0.09055414f, 
    -0.03010859f, 0.06038826f, -0.01559945f, 0.00960397f, -0.05934725f, -0.02109320f, -0.00831965f, -0.01623046f, 
    0.24038728f, 0.37498054f, -0.21019985f, 0.34794876f, -0.11061131f, 0.08240755f, -0.14597978f, 0.10599802f, 
    -0.03197469f, -0.34687713f, -0.01307144f, -0.14458959f, 0.12098370f, 0.01916828f, 0.00592608f, -0.05477501f, 
    0.02222776f, -0.08568814f, 0.08602080f, 0.03741474f, 0.05250985f, -0.23083423f, -0.01947433f, -0.27925661f, 
    -0.05170538f, -0.05663425f, 0.00730711f, -0.01269647f, -0.06486774f, -0.01756523f, -0.04044122f, 0.01300650f, 
    0.05339298f, 0.04116473f, 0.06685633f, 0.11464379f, -0.00097637f, -0.14110854f, 0.09565437f, 0.02346156f, 
    0.09906506f, -0.15167125f, 0.11068067f, 0.05069344f, 0.07581522f, -0.01864706f, -0.08131021f, 0.12553105f, 
    -0.02275954f, 0.08930035f, 0.13103682f, -0.10947660f, -0.01313255f, 0.11363081f, 0.08792172f, -0.09208360f, 
    0.00713352f, -0.13118599f, -0.05359745f, 0.03586211f, 0.00771816f, -0.27435419f, -0.01887832f, -0.13616578f, 
    0.19147447f, -0.11737452f, 0.00788243f, 0.10255143f, -0.06653130f, 0.08580352f, 0.04268509f, 0.00691803f, 
    -0.03978115f, -0.01347456f, 0.12286949f, 0.21960211f, 0.13007581f, -0.05371810f, 0.11112349f, 0.04822551f, 
    -0.31080207f, 0.05617158f, -0.18196274f, -0.41516444f, -0.30797771f, 0.01088715f, 0.10090763f, 0.06756139f, 
    -0.24127495f, -0.07171715f, -0.03285615f, -0.06328856f, 0.01479774f, -0.04808721f, 0.00023257f, -0.02626672f, 
    -0.17398494f, 0.14050849f, -0.07608017f, 0.06833068f, 0.02401463f, -0.08378270f, 0.07358516f, 0.03730708f, 
    0.12459296f, 0.04375753f, -0.06993861f, -0.03286447f, 0.01049363f, 0.05439562f, 0.01308558f, 0.01980585f, 
    0.10890231f, -0.06855296f, -0.07454408f, -0.00287068f, 0.06433469f, -0.08969212f, 0.06350072f, -0.04271391f, 
    0.38409558f, 0.07216732f, 0.38960576f, -0.04365383f, 0.09996186f, 0.12134501f, -0.07202475f, 0.00122940f, 
    0.14086205f, 0.01311787f, 0.03207745f, -0.00827587f, 0.00779126f, -0.11913518f, -0.09606942f, 0.10123711f, 
    -0.03544345f, 0.06764308f, -0.01468564f, -0.01312809f, 0.03726451f, 0.01289491f, 0.06907143f, 0.03621207f, 
    0.10289004f, -0.03806977f, -0.02410598f, 0.05220293f, 0.03767492f, 0.06061126f, 0.08807851f, 0.01539101f, 
    -0.09916091f, -0.04302578f, -0.03183047f, -0.10862827f, -0.07450708f, -0.10674582f, 0.02919808f, -0.03253291f, 
    -0.08645339f, -0.48571330f, 0.22503169f, -0.05695557f, 0.41690800f, -0.08586619f, -0.08809909f, 0.04359185f, 
    0.06818225f, 0.02900001f, -0.14322320f, 0.16188283f, -0.07221342f, -0.03081860f, 0.16571726f, 0.16790140f, 
    -0.00688576f, 0.08916616f, -0.01420279f, -0.17179368f, -0.00157176f, -0.03966365f, -0.09108916f, 0.07218824f, 
    -0.08766702f, 0.00421713f, 0.04048007f, 0.01076368f, -0.04849192f, 0.08981287f, -0.00411024f, -0.08371647f, 
    0.03644332f, 0.01965015f, 0.15582167f, -0.05631144f, 0.05350356f, -0.08051023f, 0.02030219f, 0.01680410f, 
    0.20108873f, -0.05483853f, -0.04577100f, -0.02319189f, 0.40426376f, 0.05296661f, -0.01075006f, -0.08876694f, 
    -0.01862037f, 0.02920679f, 0.14189498f, 0.04271269f, -0.03994314f, -0.09880304f, 0.02093735f, -0.13474701f, 
    0.01603564f, -0.00661007f, -0.06025648f, -0.11375155f, 0.02695859f, 0.18197173f, -0.19443297f, -0.30781507f, 
    0.10130183f, 0.16381176f, 0.12795818f, 0.03177400f, 0.03110483f, 0.07060154f, -0.07478385f, 0.00517310f, 
    0.00527021f, -0.09510321f, 0.02471990f, -0.02326765f, -0.14875300f, 0.05019558f, 0.07484919f, 0.28834462f, 
    -0.29648608f, 0.02241771f, -0.13026780f, -0.30384517f, -0.31579536f, -0.03457142f, 0.18131177f, 0.01781266f, 
    -0.20030193f, -0.00301847f, -0.10075547f, 0.01453263f, -0.02652987f, -0.01633467f, 0.02598188f, -0.17260939f, 
    -0.09590497f, -0.02259034f, -0.11383977f, 0.01597997f, -0.21363117f, 0.24816515f, 0.25066188f, 0.00197146f, 
    0.29647285f, -0.14960746f, 0.13866276f, 0.15748174f, -0.01863952f, 0.01057558f, -0.06648079f, 0.01400859f, 
    0.11940414f, 0.02563716f, -0.01257160f, -0.00298066f, 0.00524687f, -0.06908154f, 0.01126006f, -0.04292422f, 
    -0.43672740f, -0.16529886f, -0.27988988f, -0.36713222f, -0.12943025f, 0.05707853f, 0.18859833f, -0.03514007f, 
    -0.07387838f, -0.03827320f, -0.08385897f, -0.00787695f, 0.01975652f, -0.00197550f, 0.08355480f, -0.03321939f, 
    -0.07949252f, 0.01361640f, 0.05416422f, -0.00737574f, 0.16761117f, 0.25456342f, -0.04637022f, 0.25928795f, 
    0.05698221f, -0.04763310f, 0.06326726f, 0.09652537f, 0.09993950f, 0.02171695f, -0.01637104f, 0.01148004f, 
    -0.03266884f, -0.01493777f, -0.04497397f, -0.14518315f, 0.07465060f, 0.04924196f, -0.09917066f, 0.00478688f, 
    0.21770917f, -0.15752770f, 0.02192257f, -0.12386516f, 0.01140023f, 0.13316269f, -0.11195329f, 0.05555237f, 
    -0.06079828f, -0.15764081f, 0.09928060f, 0.02029026f, 0.02968131f, 0.08470503f, 0.02443953f, -0.09673740f, 
    0.03486810f, -0.00445457f, 0.13776797f, 0.25342658f, 0.39567608f, -0.15168245f, -0.25583851f, -0.13449429f, 
    0.14223894f, 0.10579233f, 0.18770511f, 0.08998148f, 0.02218038f, 0.08268117f, 0.13009678f, 0.06009018f, 
    -0.08223961f, -0.01616115f, 0.01883359f, 0.12566374f, 0.05950619f, -0.09109055f, 0.01842700f, 0.09231339f, 
    0.16780187f, -0.09715550f, -0.01763145f, 0.00164770f, -0.14117406f, 0.01259446f, 0.05021738f, 0.10663359f, 
    0.01704324f, 0.08246166f, 0.06040517f, 0.02892512f, -0.05270887f, -0.07152097f, 0.00377199f, 0.06689621f, 
    -0.00264656f, -0.00540855f, 0.13339192f, 0.00142914f, 0.07683698f, 0.09302490f, -0.46529582f, 0.08008314f, 
    0.10316377f, -0.05385154f, 0.12891711f, 0.12193268f, 0.01673326f, 0.19057533f, 0.03257196f, -0.09716962f, 
    -0.06794996f, -0.02957764f, -0.10813563f, 0.12100131f, 0.07131070f, -0.22831801f, 0.01328919f, 0.05834588f, 
    -0.81986320f, 0.10974137f, -0.34415317f, 0.04573001f, 0.18780914f, 0.06470411f, -0.16232811f, -0.07891206f, 
    -0.05115542f, -0.04414615f, 0.18622884f, 0.15230112f, 0.15526456f, -0.06839251f, 0.07318363f, 0.08144646f, 
    0.05794362f, -0.06472369f, 0.09316856f, 0.27570695f, -0.13494191f, 0.34182838f, -0.22364409f, 0.04954246f, 
    0.17291746f, 0.05598005f, 0.09244553f, -0.03838846f, 0.11684582f, -0.12619208f, 0.05632279f, 0.06488771f, 
    -0.01271595f, 0.11583501f, 0.05063887f, 0.09667753f, 0.10519108f, -0.01469145f, -0.01808528f, 0.00954852f, 
    0.21748747f, -0.51492828f, -0.21742816f, 0.05408061f, -0.24116330f, 0.02462618f, 0.23511530f, 0.03262166f, 
    0.07477722f, 0.15022829f, 0.13178222f, -0.03426664f, 0.11910358f, -0.04453101f, -0.17893557f, 0.25564805f, 
    0.01811377f, -0.04990583f, -0.01846703f, 0.06372356f, 0.17259873f, 0.10956368f, 0.02532364f, -0.09514456f, 
    0.01739985f, 0.01116696f, -0.04689498f, 0.11149848f, -0.02565439f, -0.01707970f, 0.18743780f, 0.12936202f, 
    0.06405108f, 0.13373868f, 0.00451681f, 0.06361023f, -0.01065879f, 0.06727808f, -0.06623025f, -0.03995175f, 
    -0.23685265f, 0.00056744f, 0.28860894f, 0.39185587f, -0.08972158f, -0.12964480f, -0.06367870f, -0.23188852f, 
    -0.06789517f, 0.08432750f, 0.14990559f, 0.01562913f, 0.09130106f, 0.07293805f, 0.09722469f, 0.03929375f, 
    -0.00020655f, -0.01376925f, -0.00390228f, -0.01438179f, 0.09693876f, 0.15682490f, 0.05520087f, -0.13987981f, 
    0.10584369f, 0.05806899f, -0.03357246f, 0.01177181f, -0.01753804f, -0.03412378f, 0.01602270f, -0.08917940f, 
    -0.07975730f, 0.04075266f, 0.09337920f, -0.00351644f, -0.18417336f, -0.20191127f, -0.07283329f, -0.05445602f, 
    0.12530553f, -0.17305428f, 0.34102097f, 0.07214395f, -0.21428560f, -0.09134221f, -0.07511425f, -0.04196154f, 
    -0.00382972f, -0.21924159f, 0.11639430f, 0.04561965f, 0.19277667f, -0.00731833f, -0.10183121f, 0.03416521f, 
    0.10693340f, 0.04291202f, 0.00796232f, 0.02323093f, 0.04080107f, 0.10088581f, -0.46496966f, -0.12212973f, 
    -0.05660177f, 0.10011110f, 0.06049477f, 0.07822445f, -0.04641778f, 0.09189241f, 0.07212546f, 0.01558086f, 
    -0.01001183f, -0.04796201f, -0.04308517f, 0.03996660f, -0.04547846f, -0.18013632f, -0.11376274f, -0.14409709f, 
    0.38946539f, 0.13664818f, -0.02739790f, -0.29215750f, -0.09536829f, 0.09373575f, -0.05917099f, 0.09481373f, 
    0.00996779f, 0.07865670f, -0.11810505f, 0.08539786f, 0.03476605f, -0.02671076f, -0.00377014f, 0.09950789f, 
    0.12838982f, 0.12966460f, 0.02471471f, 0.15449508f, 0.33538637f, 0.04402194f, -0.23498134f, -0.56611055f, 
    -0.03146034f, 0.01538900f, -0.03155925f, 0.08654246f, -0.01229082f, -0.01811237f, 0.02490621f, -0.04242939f, 
    -0.11673454f, -0.12528276f, 0.08992954f, 0.06988212f, 0.02927836f, 0.02163351f, 0.05240680f, 0.06365080f, 
    0.05671875f, 0.03376138f, -0.11311492f, -0.31599358f, 0.20233443f, -0.07654937f, 0.08357519f, -0.06086100f, 
    -0.01036535f, -0.00665200f, -0.02904360f, -0.13900766f, -0.02263878f, 0.00304976f, -0.20976700f, 0.05462613f, 
    0.17894633f, 0.01680379f, -0.07059075f, 0.18232334f, -0.17055191f, 0.13796458f, 0.22744496f, 0.04800722f, 
    -0.14799269f, -0.15676811f, -0.15954147f, -0.22486821f, -0.08995035f, -0.09845473f, 0.04758975f, -0.08586452f, 
    0.06944474f, 0.08576482f, 0.15379050f, -0.00534269f, -0.05813469f, 0.05421874f, -0.09046336f, -0.05421010f, 
    0.13413587f, -0.14257829f, 0.45344386f, -0.22512724f, -0.46424225f, -0.18963878f, -0.05870460f, 0.06348836f, 
    0.08318951f, -0.11381286f, 0.05003092f, 0.09978127f, -0.00350205f, -0.04203303f, 0.03147921f, -0.10841931f, 
    0.01754588f, 0.22339606f, -0.05654608f, -0.16658545f, 0.32352191f, 0.10106740f, -0.27597216f, 0.12910414f, 
    0.14654844f, 0.12146707f, 0.19082771f, 0.13928117f, 0.03944165f, 0.14291881f, -0.01856388f, -0.03171004f, 
    -0.00501709f, 0.03994826f, -0.02180977f, 0.02468256f, 0.09160818f, 0.10809039f, 0.06157123f, 0.11108837f, 
    -0.18415640f, -0.00415978f, -0.06336103f, -0.00738859f, 0.21285498f, -0.05937310f, -0.01817379f, -0.11822370f, 
    -0.06941887f, 0.02685089f, 0.08242642f, -0.06444768f, -0.02677571f, -0.05506508f, -0.18539692f, 0.07495073f, 
    0.00105355f, -0.04197758f, 0.02766122f, 0.06326353f, -0.35841721f, 0.15786049f, -0.30603012f, 0.14581734f, 
    0.15935031f, 0.12440912f, 0.08739342f, 0.04981515f, 0.06995875f, 0.07204237f, 0.04219658f, -0.07855074f, 
    -0.00711464f, 0.03043830f, -0.00782764f, 0.09687473f, 0.09732813f, -0.00577139f, 0.00071437f, 0.10841000f, 
    0.11984414f, 0.06132343f, 0.11905295f, -0.07083080f, -0.24232148f, 0.17206281f, -0.07020404f, -0.00051460f, 
    -0.07544133f, 0.05740047f, 0.01804387f, -0.02086126f, -0.00121951f, 0.02881544f, 0.00681632f, -0.02280489f, 
    0.07232969f, 0.12381583f, 0.10389075f, 0.18148530f, 0.11046509f, 0.00748706f, 0.03937795f, -0.02487813f, 
    0.15720938f, 0.01372739f, -0.00172487f, -0.00219591f, -0.01256705f, -0.04571553f, 0.05604533f, 0.00899716f, 
    -0.06100151f, -0.05161208f, -0.06344801f, 0.09930498f, -0.17275214f, -0.04902320f, -0.00258431f, 0.05830543f, 
    0.14891864f, -0.19191769f, 0.25742975f, 0.31070289f, -0.27757415f, -0.24719286f, -0.09640513f, -0.15189254f, 
    0.12434925f, 0.02752217f, 0.17549023f, 0.09183052f, 0.16081694f, 0.11177414f, -0.08003373f, 0.09042486f, 
    0.05851225f, 0.01483061f, 0.09627426f, 0.07204565f, 0.03432976f, 0.13620944f, 0.03910418f, -0.01210655f, 
    0.10375464f, -0.02735750f, -0.06565464f, -0.06410690f, -0.07701595f, -0.05590283f, 0.04553604f, 0.13526878f, 
    0.07399657f, 0.02680360f, -0.00976408f, 0.03142617f, -0.10701080f, -0.03980676f, -0.08007075f, 0.04665837f, 
    -0.99047691f, -0.19766623f, -0.30120775f, 0.53413004f, 0.10534921f, -0.18623248f, 0.13140924f, -0.13743038f, 
    0.00945789f, 0.01873682f, 0.33505026f, -0.02923219f, 0.05243682f, 0.06867965f, 0.02304778f, 0.07449550f, 
    0.03560783f, 0.01086901f, -0.05078688f, 0.09807553f, 0.24794853f, -0.03158722f, -0.08381467f, -0.03376652f, 
    0.10464430f, 0.06609153f, 0.13936916f, 0.08076107f, -0.01268778f, 0.11543136f, -0.00922090f, 0.06956454f, 
    -0.06845777f, 0.00476050f, -0.10393531f, 0.15314350f, 0.04152853f, -0.01287948f, -0.02109443f, -0.01167681f, 
    -0.36100924f, -0.30705857f, -0.28718597f, 0.11388598f, -0.19216001f, -0.10557196f, 0.04537422f, 0.05818852f, 
    0.10980407f, -0.03567619f, 0.01426192f, 0.00437027f, 0.04686522f, 0.11972932f, -0.07018480f, 0.06931498f, 
    -0.02026739f, -0.04265796f, 0.09437862f, 0.05822022f, 0.13992673f, -0.00746933f, 0.16890660f, 0.09383311f, 
    -0.10612358f, 0.02588338f, -0.12441441f, 0.07626597f, 0.03042101f, 0.00721562f, 0.01042612f, -0.01553564f, 
    0.11658277f, 0.11019249f, 0.02235197f, -0.00496166f, 0.06325657f, 0.01675459f, 0.16592288f, 0.13467942f, 
    0.00107195f, 0.15769576f, -0.10254228f, -0.04464869f, -0.17540577f, 0.16120513f, -0.14400314f, 0.05522439f, 
    -0.01139739f, -0.02103422f, 0.03163208f, 0.03677522f, 0.06677549f, 0.06605218f, -0.04299707f, -0.01008928f, 
    0.05167367f, 0.11074798f, 0.08009477f, 0.21960327f, -0.20970598f, 0.08333053f, 0.04494646f, 0.21689984f, 
    -0.18340442f, -0.07102548f, -0.17394853f, -0.18772306f, 0.12671514f, 0.08433547f, 0.09101172f, -0.04277632f, 
    0.06890488f, 0.03749273f, 0.07183390f, -0.02829380f, -0.05833675f, 0.00386790f, 0.01457509f, -0.02957329f, 
    -0.06833387f, 0.18398795f, -0.34426031f, 0.16032270f, -0.22389436f, 0.15999073f, -0.17985658f, -0.05825229f, 
    -0.03565560f, 0.03418821f, 0.00970746f, 0.00809351f, 0.06125525f, -0.02479887f, -0.04264828f, 0.04863549f, 
    0.10827273f, 0.00411273f, 0.08662007f, 0.16194300f, 0.14221893f, -0.16259348f, 0.26660472f, 0.06393705f, 
    -0.17974338f, -0.11735387f, -0.03434515f, -0.00108172f, -0.03668839f, 0.01719203f, 0.10435756f, -0.01755103f, 
    0.12156679f, 0.06494936f, -0.03154442f, 0.09535251f, 0.04396344f, 0.12577093f, -0.08523892f, -0.02571316f, 
    0.12747063f, 0.32057393f, 0.16498487f, -0.07146571f, 0.01345525f, -0.00919599f, 0.06132175f, -0.06258210f, 
    0.13180065f, 0.11097658f, -0.02634155f, 0.04074143f, -0.01645518f, -0.03610030f, -0.00454056f, 0.03287390f, 
    -0.18196261f, 0.07791553f, 0.06421394f, -0.03469425f, 0.01163781f, 0.02340412f, 0.08090083f, 0.20229024f, 
    0.02270314f, -0.08674973f, 0.00033450f, -0.13313557f, 0.03631082f, -0.03260911f, -0.05947264f, -0.02224949f, 
    -0.08403233f, -0.04431791f, -0.04087922f, -0.04037309f, 0.23830293f, -0.02208275f, 0.11234500f, 0.01463965f, 
    0.28932798f, 0.37596330f, -0.15424636f, 0.02285631f, 0.01869382f, -0.02787086f, -0.02612549f, 0.00315982f, 
    0.09051113f, 0.10968786f, -0.04495542f, -0.01353263f, 0.00445270f, 0.09645908f, 0.01909016f, -0.04840226f, 
    0.02532606f, 0.07363129f, -0.09503206f, 0.11848112f, 0.10745598f, 0.07573476f, 0.38576680f, -0.08956436f, 
    0.05662743f, -0.09119414f, -0.05965728f, -0.03333078f, 0.02045120f, -0.05672275f, -0.00712670f, -0.00490770f, 
    0.04937513f, -0.03617773f, 0.03213944f, 0.24773385f, 0.10179901f, 0.12738866f, 0.06392781f, -0.10696680f, 
    -0.26106045f, -0.57489026f, 0.28919151f, 0.01268184f, -0.00778608f, -0.03473520f, 0.12790737f, -0.18189906f, 
    0.07279805f, -0.05893575f, 0.05005478f, 0.17426731f, -0.09455752f, 0.14241335f, -0.02746851f, 0.04346208f, 
    0.04032033f, 0.00893555f, -0.05081316f, -0.01945283f, -0.05988001f, -0.05667730f, 0.34920430f, -0.15874211f, 
    -0.02021756f, -0.04657214f, 0.05197784f, -0.12613314f, -0.00140806f, -0.00411611f, 0.10688835f, 0.03011209f, 
    0.01073027f, 0.01629801f, 0.14731689f, 0.22252876f, 0.21252950f, 0.01333074f, 0.06782091f, -0.11037441f, 
    -0.29432747f, 0.64729851f, -0.03272058f, -0.11132760f, 0.19912769f, 0.04631956f, -0.08412846f, 0.17655800f, 
    -0.09028892f, 0.05636109f, 0.00804236f, -0.06930113f, -0.05306116f, 0.13600568f, 0.05355996f, -0.08715004f, 
    -0.10351893f, 0.11903203f, -0.00077273f, 0.11969662f, 0.01152907f, -0.13540049f, -0.08284455f, 0.02736000f, 
    -0.10881895f, -0.05422372f, -0.01790815f, -0.19597580f, -0.02745051f, -0.03507083f, -0.01288886f, -0.03665537f, 
    0.04071153f, -0.00374125f, -0.00558476f, 0.19728953f, 0.17306790f, -0.02647636f, 0.04123059f, -0.01198828f, 
    -0.24115235f, -0.10325017f, -0.50108939f, -0.19656341f, -0.07444745f, 0.09924999f, 0.13811502f, 0.12054321f, 
    -0.11744395f, 0.08534992f, -0.01944866f, 0.00271289f, -0.09063493f, 0.02612098f, -0.08600655f, 0.00022012f, 
    0.03230571f, 0.00852118f, -0.00292663f, 0.01476889f, 0.06842303f, -0.08954090f, -0.03805743f, -0.02297482f, 
    -0.04013596f, -0.05124616f, 0.03647809f, -0.08873189f, -0.07114484f, -0.09086054f, 0.06480840f, 0.18437319f, 
    -0.03901813f, 0.02366577f, 0.01331220f, -0.12500314f, 0.19541653f, 0.02987431f, 0.03262844f, 0.00247391f, 
    0.25784332f, 0.49158412f, -0.02871821f, -0.05364767f, 0.08218883f, 0.20399810f, 0.18105036f, 0.21324004f, 
    -0.00007859f, 0.20911475f, 0.01673919f, 0.02853756f, 0.04255685f, 0.00097137f, 0.14274558f, 0.21892858f, 
    -0.06783348f, -0.09858817f, 0.08963626f, 0.03829311f, 0.39637548f, 0.24670093f, 0.39854389f, -0.16777477f, 
    0.01534977f, -0.07148050f, 0.05992449f, 0.04889362f, 0.13395979f, 0.13098031f, -0.05434766f, 0.01424647f, 
    0.01381095f, 0.11987171f, 0.02419754f, 0.02559654f, 0.06863349f, 0.09914294f, 0.09907772f, 0.12842607f, 
    0.11902681f, -0.15117918f, -0.01749944f, 0.20118783f, -0.00810514f, -0.06685578f, -0.02938328f, -0.08944545f, 
    -0.03103296f, -0.00910180f, -0.00739889f, -0.11654691f, -0.11477181f, -0.06092013f, 0.00026839f, 0.08732648f, 
    0.10317222f, 0.03121596f, 0.00422458f, -0.06916097f, 0.43385634f, -0.08952875f, -0.13509232f, 0.18993375f, 
    -0.04513566f, -0.15878731f, 0.04485715f, -0.11189675f, 0.03971470f, -0.06790382f, -0.04944521f, -0.07356527f, 
    -0.12169429f, -0.04997016f, -0.06031636f, -0.02526475f, -0.01478219f, 0.20726489f, -0.06723456f, -0.08862533f, 
    -0.02566237f, -0.04671723f, -0.07582582f, 0.26162234f, -0.01691524f, -0.03408862f, -0.03208477f, -0.04589193f, 
    -0.02350837f, -0.05912858f, -0.12099391f, 0.03247564f, -0.08369972f, -0.00457910f, 0.00271411f, 0.04998811f, 
    -0.04858705f, 0.01439130f, -0.06352308f, -0.10895394f, -0.32637599f, -0.08609607f, -0.35092270f, -0.15479997f, 
    -0.03285566f, 0.02450945f, 0.05489894f, 0.10553484f, -0.02253389f, 0.06028727f, 0.00210764f, 0.12739494f, 
    -0.10019525f, -0.07441324f, -0.13765460f, -0.00921333f, 0.04160865f, 0.02133418f, 0.03187238f, 0.00920828f, 
    0.30348414f, 0.23433441f, -0.52750409f, 0.21612693f, 0.21292104f, 0.21983519f, 0.00817620f, 0.08561159f, 
    -0.16870040f, 0.22221206f, 0.00107889f, -0.10096966f, -0.00827162f, 0.03713445f, -0.05217590f, 0.06933392f, 
    0.00408244f, 0.06714407f, 0.13850629f, 0.15104644f, 0.04613156f, -0.06389064f, 0.05879036f, 0.13354036f, 
    -0.08813497f, -0.07944507f, -0.10774434f, -0.06724051f, -0.04801682f, -0.11563791f, -0.02605966f, -0.04250753f, 
    -0.02017794f, 0.00768080f, 0.01523360f, 0.11259051f, 0.12106583f, 0.01564597f, 0.05379178f, -0.06677983f, 
    -0.09049061f, -0.06006613f, -0.06015064f, 0.07792680f, 0.05809327f, -0.01064448f, -0.00761145f, -0.08627633f, 
    -0.04573235f, -0.03210136f, -0.04225485f, -0.06411768f, -0.09462574f, 0.02400618f, 0.03050423f, 0.03759667f, 
    -0.00736399f, -0.05775893f, -0.06464376f, -0.07424138f, 0.06221626f, -0.21067730f, 0.17222902f, -0.06726071f, 
    0.23628514f, -0.03251331f, -0.11646786f, -0.10875867f, 0.05229414f, -0.11692505f, 0.03475364f, 0.00889574f, 
    0.02550684f, -0.06041592f, 0.00720236f, 0.16309743f, 0.13192886f, 0.03963345f, 0.04181322f, 0.02340166f, 
    0.25499937f, 0.32560670f, 0.00411806f, -0.21094838f, 0.14839847f, -0.17968032f, -0.13568388f, 0.00073526f, 
    -0.02061730f, -0.01622489f, -0.05326134f, -0.04831278f, 0.08669893f, 0.00232738f, 0.06535913f, 0.03586460f, 
    -0.04642796f, -0.08313921f, -0.09900917f, -0.14030027f, 0.02483796f, -0.12832597f, -0.12351649f, 0.05744135f, 
    -0.06691310f, -0.03875056f, -0.01273128f, -0.07971067f, -0.08202163f, -0.00358125f, -0.04060812f, 0.05171427f, 
    -0.11367626f, -0.00959449f, 0.01816031f, -0.04791187f, 0.21428990f, -0.00766439f, 0.01145605f, -0.07167849f, 
    0.15897249f, 0.50534153f, -0.35469171f, -0.18114787f, -0.06641879f, 0.30893269f, 0.12616172f, 0.21976304f, 
    -0.15565796f, 0.16434789f, 0.08103020f, -0.02041369f, 0.01127382f, -0.01430601f, -0.00040889f, 0.07468833f, 
    -0.08859855f, 0.06153757f, -0.02646638f, -0.00381071f, 0.09318040f, -0.13914740f, 0.01903063f, -0.09038934f, 
    -0.04407270f, -0.07899866f, 0.00835339f, -0.07522002f, -0.04931621f, -0.09350817f, 0.10440889f, 0.11616578f, 
    0.03207511f, -0.12175699f, 0.08279436f, -0.03548510f, 0.04409342f, -0.01210924f, 0.01048866f, -0.02584003f, 
    -0.25992477f, -0.17742690f, 0.25554565f, -0.43384188f, 0.27386129f, 0.10367285f, 0.02710863f, 0.04588166f, 
    0.02314609f, -0.05247904f, 0.01272186f, 0.09898662f, -0.07424332f, -0.01531516f, 0.22360687f, 0.14150696f, 
    -0.00913881f, -0.02078484f, -0.10159263f, -0.07300919f, -0.17189656f, 0.16740432f, -0.06657847f, 0.19692804f, 
    -0.06813587f, -0.05386519f, -0.04126369f, -0.06353188f, -0.02162744f, -0.05307624f, -0.01133348f, -0.00820653f, 
    -0.07715894f, 0.01011260f, 0.07349733f, -0.08792773f, 0.14707091f, 0.10601225f, -0.00868896f, -0.00161302f, 
    0.04798052f, 0.28428590f, 0.27098843f, -0.24638028f, 0.20126885f, 0.10736555f, -0.04015547f, 0.18574744f, 
    0.01406304f, -0.00247266f, 0.11693810f, -0.02260277f, 0.00134668f, 0.08577499f, 0.12028837f, -0.02602039f, 
    -0.00765674f, 0.05385764f, -0.01965065f, -0.07923151f, 0.36198181f, 0.36774004f, 0.14593649f, -0.25205970f, 
    0.31030428f, 0.16815436f, 0.09651390f, 0.11497031f, -0.05334817f, -0.00840886f, -0.02733877f, -0.02081030f, 
    0.03086271f, 0.00372415f, 0.09882506f, 0.08771065f, -0.12116483f, 0.03719834f, -0.04273212f, -0.00413798f, 
    0.09129394f, 0.18957412f, 0.18933652f, -0.11697443f, -0.00813312f, -0.04919681f, -0.06521053f, -0.02319095f, 
    0.01821674f, 0.04306873f, -0.03036774f, 0.00354303f, 0.02063369f, 0.02986017f, 0.04319261f, 0.04048780f, 
    -0.02103151f, -0.06244091f, -0.07452036f, -0.25329006f, -0.15915015f, 0.21592757f, -0.06576286f, -0.30061302f, 
    0.05702439f, 0.05292780f, 0.10542412f, 0.22395495f, 0.04871566f, 0.07565126f, -0.02806306f, -0.05143290f, 
    -0.03385469f, -0.00511326f, -0.01502350f, 0.01372670f, 0.02052737f, 0.04117620f, 0.06659898f, 0.11145424f, 
    0.06300177f, 0.08438370f, 0.31158039f, -0.23800041f, 0.04700403f, -0.03276122f, -0.01253897f, -0.11553524f, 
    0.11123180f, 0.04315574f, -0.00608764f, 0.02809585f, -0.01812647f, 0.09773715f, 0.06506935f, 0.04500366f, 
    -0.01174615f, -0.05999064f, -0.08860957f, -0.08572885f, 0.18001737f, 0.65068299f, -0.09012796f, 0.05628804f, 
    0.26331377f, 0.18611132f, 0.06798951f, 0.16332142f, -0.17363870f, 0.02811619f, -0.00051266f, 0.01236924f, 
    0.05935714f, 0.02092852f, 0.12951355f, 0.03891179f, -0.05023353f, 0.00995196f, 0.13265471f, 0.10249895f, 
    -0.09717055f, -0.01880445f, -0.21479715f, 0.07139528f, 0.07443863f, -0.00042522f, -0.08915535f, 0.00722458f, 
    0.11876827f, 0.04997870f, 0.00249272f, 0.01533759f, -0.04233663f, -0.01728471f, 0.01830364f, 0.22174156f, 
    0.12169016f, 0.13760701f, 0.05305593f, -0.12699364f, -0.17174879f, 0.19025387f, 0.18545845f, 0.11872170f, 
    0.04958000f, -0.05597110f, 0.05037531f, -0.00123117f, 0.02510630f, 0.01780553f, 0.02244001f, -0.02592180f, 
    0.00039006f, 0.06876818f, -0.04159451f, 0.02624504f, -0.02091914f, 0.07932258f, 0.08198318f, 0.04027903f, 
    -0.01565759f, -0.16460717f, 0.01629971f, 0.09042510f, 0.08831624f, 0.04329104f, 0.03668912f, 0.08113493f, 
    0.02849609f, -0.08757866f, 0.00857911f, 0.04612418f, 0.07675539f, -0.00991809f, -0.05777779f, 0.03883676f, 
    0.04825736f, 0.08071923f, 0.04939192f, 0.15062256f, 0.19675009f, -0.02899212f, -0.05346187f, 0.09292861f, 
    -0.13957630f, 0.25162289f, 0.14951502f, 0.10255758f, 0.10276558f, -0.03668025f, -0.06095998f, -0.00689229f, 
    0.06701999f, 0.00721311f, -0.04458258f, -0.12305770f, 0.10328659f, 0.05722675f, 0.08328263f, 0.10141883f, 
    0.87242287f, 0.39979652f, -0.16255523f, -0.00528498f, -0.03382413f, -0.14330882f, 0.23438074f, -0.03629895f, 
    -0.10743926f, -0.18462789f, -0.12127987f, -0.00872710f, 0.03346669f, 0.12358575f, 0.20226231f, 0.12514813f, 
    0.06365737f, -0.06807188f, 0.18060622f, -0.05264567f, 0.34162399f, 0.22057988f, -0.23866598f, 0.01269034f, 
    -0.06576617f, 0.16402434f, 0.08596516f, -0.04015849f, -0.06068349f, -0.02449914f, 0.16537955f, 0.21766450f, 
    -0.03839130f, 0.11629429f, 0.10926227f, 0.16463132f, 0.01245001f, 0.03185886f, 0.07021329f, 0.09992123f, 
    -0.20700501f, 0.14063558f, 0.56477344f, 0.21509309f, 0.20137814f, 0.10349465f, 0.30159038f, 0.00384784f, 
    0.20929061f, 0.03728106f, 0.02774622f, 0.16213906f, -0.04347488f, 0.14566381f, 0.19394200f, 0.02796695f, 
    0.05689745f, 0.05121128f, 0.15084933f, -0.01720553f, -0.10576185f, 0.10282899f, -0.01327367f, 0.05335723f, 
    0.05415350f, 0.05890889f, 0.03137277f, 0.08814945f, -0.06187497f, 0.09440986f, -0.02681215f, -0.00098998f, 
    -0.06580192f, 0.03302652f, 0.16680729f, 0.08844008f, 0.01179716f, 0.09330958f, -0.00884691f, 0.06869858f, 
    -0.07528203f, 0.24198854f, 0.04562036f, -0.04008790f, -0.13315304f, 0.11565466f, 0.04493883f, -0.10924063f, 
    -0.07312381f, 0.06861224f, 0.01704513f, 0.06375685f, 0.17082921f, 0.12565978f, 0.07175637f, 0.01901097f, 
    -0.03642740f, -0.09556209f, 0.02742995f, -0.04220147f, -0.11257587f, -0.03480090f, 0.03394268f, 0.00158206f, 
    -0.11327770f, -0.00164015f, 0.01057471f, -0.01414590f, -0.01432146f, -0.03906792f, 0.07864702f, -0.00750773f, 
    0.04611281f, 0.08990017f, 0.06537460f, 0.10525288f, 0.16682489f, 0.22769016f, 0.02729763f, 0.04487604f, 
    -0.03210346f, 0.00179556f, -0.34332067f, -0.01472613f, 0.17363079f, 0.10854072f, 0.05312704f, 0.08356048f, 
    0.18545584f, 0.13678385f, -0.00534312f, 0.03841095f, -0.09019807f, 0.08989283f, 0.16236244f, 0.04996759f, 
    0.01817050f, 0.24519737f, 0.03067117f, 0.08504219f, 0.13423492f, -0.00449172f, -0.06152201f, 0.04064233f, 
    0.01513210f, 0.26492432f, 0.12157328f, 0.17928033f, 0.19121595f, -0.02657304f, -0.03635328f, 0.03714891f, 
    -0.01447987f, -0.02844053f, 0.02046571f, -0.00361801f, 0.05077325f, 0.07337474f, 0.28378892f, 0.31570011f, 
    -0.19437122f, -0.05361227f, 0.06370970f, 0.10453117f, 0.25067765f, -0.04215262f, -0.00975682f, 0.00786007f, 
    0.01188636f, -0.03243117f, -0.01344001f, -0.03283624f, -0.03205828f, -0.07449351f, 0.01039991f, 0.05919790f, 
    0.01119851f, 0.00597929f, -0.04516191f, 0.09881133f, -0.48610532f, -0.19725072f, 0.20948863f, 0.23219648f, 
    0.33895117f, -0.02673684f, -0.02368188f, 0.04942643f, -0.06737346f, -0.11511429f, -0.08416987f, -0.07314061f, 
    0.11753211f, 0.06441368f, 0.01891802f, 0.15111472f, 0.09188814f, 0.04828904f, -0.07061322f, 0.11869952f, 
    -0.26876622f, -0.06354953f, 0.05253056f, 0.08255067f, 0.02613861f, -0.01376851f, 0.00398696f, -0.01324133f, 
    -0.06564894f, -0.08957075f, -0.00744724f, -0.12961888f, 0.00022621f, 0.00659344f, -0.09183013f, 0.13872769f, 
    0.18197885f, 0.03751394f, -0.05536955f, -0.00637368f, -0.08644687f, -0.17022635f, 0.01498512f, -0.14246769f, 
    -0.03506683f, -0.03583864f, -0.04526585f, -0.10496078f, -0.07084779f, 0.14667532f, 0.00438692f, 0.08246870f, 
    0.08676127f, -0.04872629f, -0.02512636f, -0.01577346f, -0.00810616f, -0.05510537f, 0.03612148f, 0.00025427f, 
    -0.36803886f, -0.19719957f, -0.20944637f, -0.04825645f, 0.21076348f, 0.03474550f, 0.08195915f, 0.01496392f, 
    0.11730298f, 0.22373934f, 0.01695837f, 0.12422749f, -0.05681355f, 0.02249590f, -0.03428561f, 0.06433467f, 
    -0.07238192f, 0.20694818f, -0.01919510f, 0.03249907f, -0.20697559f, 0.01440181f, 0.26032674f, -0.03278469f, 
    -0.10659937f, -0.06379449f, 0.04552587f, 0.04598605f, -0.04074362f, -0.06166602f, -0.03298425f, -0.00033900f, 
    -0.00123388f, -0.04082765f, -0.02999600f, -0.01196229f, -0.04657054f, 0.01242398f, 0.00660255f, 0.09370330f, 
    -0.04155086f, 0.05018334f, 0.01680706f, -0.08075707f, -0.14851525f, -0.12007466f, 0.01739062f, -0.08428922f, 
    -0.04072523f, -0.07509032f, -0.10359716f, 0.13257025f, 0.12988308f, -0.10445139f, 0.07854395f, 0.07640894f, 
    0.11654583f, 0.03479001f, 0.07825885f, 0.00596971f, 0.31566602f, 0.15934920f, 0.06863403f, -0.11388951f, 
    -0.13946041f, 0.00030259f, 0.10918267f, -0.02720151f, -0.03179268f, -0.03776646f, -0.09737578f, 0.07667352f, 
    0.04160104f, -0.00533494f, -0.04467405f, -0.07169823f, -0.14461677f, -0.04528134f, 0.18896943f, -0.02020675f, 
    -0.02883598f, -0.27196395f, -0.28018942f, 0.08337847f, 0.18654369f, -0.01439496f, -0.20366335f, 0.05040557f, 
    -0.00737695f, -0.15821776f, 0.02087798f, 0.02293846f, -0.08170614f, -0.05607848f, -0.04830997f, 0.02843588f, 
    0.01970871f, 0.06044547f, 0.04685469f, -0.09080051f, -0.11125156f, 0.05381507f, 0.07149274f, -0.02379685f, 
    -0.12290926f, -0.08861856f, -0.00430310f, 0.02567038f, -0.03859724f, -0.05051550f, 0.04934609f, -0.04291574f, 
    0.03600048f, 0.21135503f, 0.11037886f, 0.01733707f, 0.11556116f, 0.07341689f, 0.05350899f, 0.03664488f, 
    -0.42776734f, 0.13468768f, -0.17818311f, 0.01700966f, 0.05941509f, 0.10797884f, 0.11958151f, -0.01687337f, 
    -0.01356879f, -0.04576389f, -0.09041081f, -0.00264234f, 0.07331648f, 0.18030210f, 0.21658473f, -0.01375628f, 
    0.07355195f, -0.01894757f, 0.06595510f, 0.04451280f, -0.07633641f, 0.06399319f, -0.04650202f, -0.02627515f, 
    -0.10579122f, -0.01294012f, 0.00837787f, -0.01646494f, -0.02931911f, -0.07531780f, 0.04184888f, 0.09510364f, 
    0.15591574f, 0.16592589f, 0.13063005f, 0.03409372f, 0.03741622f, 0.07016343f, 0.02143999f, -0.03986788f, 
    0.26737621f, 0.66854769f, 0.01495894f, 0.26974472f, -0.19671014f, 0.00516428f, 0.15257879f, -0.12980995f, 
    -0.11217464f, 0.04652578f, -0.01628287f, 0.17373528f, 0.19632167f, 0.09224533f, 0.03114840f, -0.05153645f, 
    0.11189232f, -0.16544515f, 0.09483355f, 0.11685070f, -0.15204421f, 0.05262884f, 0.29457471f, -0.05269045f, 
    0.05018686f, -0.09771401f, 0.10738939f, 0.03192211f, 0.05835753f, 0.02641121f, 0.08494685f, 0.03134947f, 
    0.04174401f, 0.05909725f, 0.03901550f, -0.00334616f, 0.05162463f, 0.03795387f, 0.01846074f, 0.10794153f, 
    0.08970834f, 0.23412593f, 0.10226097f, 0.03893551f, 0.14673251f, 0.17470005f, 0.14317136f, 0.01136398f, 
    0.08478571f, 0.14229785f, -0.02951927f, 0.07681040f, -0.04621731f, 0.07368914f, 0.05558356f, 0.13222490f, 
    0.05601573f, 0.07729220f, 0.06830341f, 0.01143926f, -0.17076018f, -0.10367764f, -0.16280530f, 0.11779775f, 
    -0.10899676f, -0.02222370f, -0.11719765f, -0.10814086f, 0.03420817f, -0.04853390f, -0.03549797f, -0.01079953f, 
    -0.05040625f, -0.00652352f, -0.01702574f, 0.05035732f, -0.00311039f, 0.05163214f, -0.02545272f, -0.17524773f, 
    0.07662338f, -0.29349658f, -0.16287869f, 0.09838939f, 0.21602787f, 0.00095510f, 0.06149050f, 0.15057749f, 
    0.22504063f, 0.02660563f, 0.01559475f, 0.03863733f, -0.01200866f, -0.00535153f, -0.04552044f, 0.19690025f, 
    0.02689214f, 0.04656150f, 0.07762458f, -0.00787658f, 0.09113525f, -0.31231979f, -0.10279997f, -0.10388926f, 
    0.05613888f, 0.12193080f, -0.07169811f, -0.17858037f, 0.08132057f, 0.12360135f, 0.10095221f, 0.11854225f, 
    0.09332495f, -0.03356674f, -0.06387177f, 0.06098499f, 0.10393831f, 0.02844309f, 0.07685643f, 0.02784094f, 
    0.11634295f, -0.21226178f, 0.04959656f, -0.07584825f, 0.24123840f, -0.03476760f, 0.10869397f, 0.15226170f, 
    0.06526921f, -0.09009065f, 0.01917529f, 0.03115552f, -0.01769561f, -0.00728182f, -0.02963756f, 0.11898307f, 
    -0.08907629f, 0.09152678f, 0.04420469f, -0.13110258f, -0.17135900f, -0.05427658f, -0.27011669f, -0.05384042f, 
    0.06671907f, 0.04313188f, -0.02823740f, -0.01342529f, 0.05095781f, 0.05580353f, -0.05087705f, 0.02503746f, 
    -0.02608011f, 0.06221850f, -0.00807711f, 0.03746282f, -0.04497416f, 0.04979317f, 0.17076896f, 0.05107837f, 
    -0.24518216f, 0.23937811f, 0.10019954f, 0.10128752f, 0.14067847f, -0.00954074f, 0.06577913f, -0.02290295f, 
    0.07631899f, 0.07125524f, -0.03787741f, 0.08658594f, 0.05372505f, -0.02632221f, 0.05559421f, 0.04257992f, 
    0.18365051f, -0.02650191f, -0.14604875f, -0.16118096f, -0.17917657f, -0.23216045f, -0.22018072f, -0.30019915f, 
    0.01678804f, 0.05495974f, -0.10264765f, 0.03735057f, -0.06128959f, -0.04395315f, 0.05963424f, -0.00844189f, 
    0.03218133f, -0.08818229f, 0.12615861f, 0.03192414f, 0.07492074f, 0.14643286f, -0.03174774f, -0.01257605f, 
    -0.03386704f, 0.30873674f, 0.35804951f, 0.17174259f, 0.32671723f, 0.01445900f, -0.09771299f, 0.23185879f, 
    0.03580172f, 0.30136728f, -0.07150292f, -0.02051922f, -0.00109250f, 0.01184817f, -0.04095900f, -0.02873683f, 
    -0.04308684f, -0.07476564f, -0.05007745f, 0.02422963f, -0.48086917f, -0.52003115f, -0.56896073f, 0.11683229f, 
    0.01138787f, -0.01327161f, 0.09384742f, 0.06386419f, 0.13422093f, 0.04877946f, -0.03669906f, 0.04829489f, 
    -0.10149220f, 0.02057910f, 0.06382912f, 0.14926356f, -0.13206872f, 0.12172940f, 0.02472553f, 0.02582956f, 
    -0.06540775f, -0.20186427f, -0.10987739f, -0.11913943f, -0.25232172f, 0.16590166f, -0.18491386f, 0.16602717f, 
    -0.02754252f, 0.03884849f, -0.03557501f, -0.05958949f, 0.00581410f, 0.06527695f, 0.17297450f, -0.01029854f, 
    -0.16038904f, 0.15208511f, -0.07188390f, 0.15125065f, -0.31970692f, -0.23437253f, -0.05396442f, -0.11619511f, 
    -0.07420020f, 0.14166971f, -0.01039738f, -0.10329501f, 0.11793837f, -0.01271405f, 0.04109083f, 0.00673386f, 
    -0.04427642f, 0.08227983f, 0.05718190f, 0.02965740f, 0.11613862f, -0.07308157f, 0.14584409f, 0.06315666f, 
    -0.18984780f, -0.01356969f, 0.00989813f, 0.15376805f, 0.09826009f, 0.00399096f, 0.05543794f, 0.07038625f, 
    -0.23986427f, 0.03368495f, -0.15330799f, -0.03683464f, -0.18429941f, 0.17939217f, 0.13332435f, -0.00384150f, 
    -0.15571040f, -0.00451512f, -0.01687605f, 0.04149473f, -0.03069564f, -0.16982107f, -0.06785677f, -0.19845285f, 
    -0.00033525f, -0.05475980f, 0.10019532f, 0.01246293f, 0.04150837f, 0.13614693f, -0.03088338f, -0.07712702f, 
    0.00396977f, 0.09171393f, 0.06407288f, -0.02009063f, 0.04958495f, -0.06148514f, 0.19282912f, 0.07614589f, 
    0.19927117f, 0.15926284f, 0.30293956f, 0.22209695f, 0.18382327f, 0.00681167f, -0.10993576f, -0.09375207f, 
    -0.04114161f, 0.03438881f, 0.03335429f, 0.06232847f, -0.00172011f, -0.05133632f, 0.01406160f, 0.04421289f, 
    -0.03247629f, -0.00833362f, -0.06986637f, -0.00835453f, -0.11320099f, -0.19253458f, -0.33921137f, -0.18919212f, 
    -0.12421339f, -0.02288177f, -0.04566427f, 0.05273446f, -0.02279226f, 0.07087440f, 0.05133390f, -0.07051771f, 
    0.12648910f, 0.00104432f, 0.08962816f, 0.26875827f, 0.06851821f, 0.01489127f, 0.01766441f, -0.02451778f, 
    -0.05555186f, 0.18096125f, 0.21111812f, 0.22101304f, 0.12488864f, 0.06040214f, 0.07651797f, -0.08407874f, 
    -0.09713197f, -0.00883543f, -0.01313018f, 0.03462127f, -0.04943131f, 0.05086665f, 0.05014047f, 0.03895456f, 
    0.01350806f, -0.09318282f, -0.00668632f, 0.00608260f, -0.22190812f, 0.07076339f, -0.14621167f, 0.37167853f, 
    0.11908705f, 0.04874873f, 0.11342503f, 0.17142637f, 0.07144025f, 0.32994226f, -0.01190391f, 0.00273807f, 
    -0.03540830f, 0.00500909f, 0.17878726f, 0.01826351f, -0.14097433f, -0.02168757f, -0.07777596f, -0.11767001f, 
    0.00374156f, -0.14516754f, -0.73005259f, -0.15948941f, -0.15354007f, -0.08939430f, -0.02874677f, -0.01700974f, 
    -0.18300056f, 0.07111447f, 0.07530757f, 0.02222220f, 0.07443423f, 0.01258254f, 0.01601270f, -0.09166420f, 
    -0.02095299f, 0.07585450f, -0.01334436f, 0.09918927f, 0.30152985f, -0.00330731f, -0.27455825f, -0.09714651f, 
    -0.11431773f, 0.01030495f, 0.01685510f, -0.04574792f, -0.11317065f, -0.08078862f, 0.10842027f, 0.13642843f, 
    0.16697942f, -0.05485682f, -0.07413265f, -0.05808529f, 0.06210125f, 0.02170494f, 0.01827767f, 0.04770519f, 
    -0.18252327f, -0.41554999f, -0.14576158f, 0.24776685f, 0.11960510f, -0.05744094f, 0.00079823f, -0.05072404f, 
    -0.18150392f, -0.11503065f, -0.14798918f, -0.01261735f, 0.02670196f, -0.18207668f, 0.00404470f, -0.07068164f, 
    -0.03347677f, 0.00450541f, 0.08324052f, 0.06658401f, 0.12160207f, 0.09043726f, 0.19967522f, 0.12699313f, 
    0.10850356f, 0.07767935f, 0.05146976f, -0.05367661f, 0.03589849f, 0.23255144f, -0.03218431f, 0.05957674f, 
    0.08774509f, 0.06549423f, -0.02626720f, 0.09183922f, -0.02647722f, 0.01467993f, -0.06460464f, -0.00536092f, 
    0.18913820f, 0.28423029f, 0.43018234f, 0.01282431f, 0.24096788f, -0.07136708f, 0.04970432f, 0.01238513f, 
    0.11800097f, 0.18667607f, 0.01630375f, -0.00017004f, 0.03764093f, 0.01733897f, 0.02415156f, 0.01618100f, 
    -0.03874869f, -0.20127861f, 0.00005114f, -0.03420082f, -0.17790450f, -0.49373099f, -0.52164388f, 0.02332535f, 
    0.08158433f, -0.09450542f, 0.00558546f, 0.04862855f, -0.08673250f, 0.01202151f, 0.03908587f, 0.04663998f, 
    -0.02043112f, -0.03206969f, 0.05645423f, -0.07450443f, -0.07532829f, 0.02372684f, 0.04539554f, 0.06295098f, 
    -0.23930807f, -0.37346521f, -0.23194119f, -0.10523128f, -0.07545684f, 0.02877380f, -0.07879196f, 0.04852088f, 
    -0.17534414f, -0.00272239f, 0.15814069f, -0.05030479f, -0.05443437f, 0.01179011f, 0.20349391f, 0.08538149f, 
    0.07568974f, 0.01548963f, -0.10929271f, -0.02042112f, -0.19043300f, -0.22505526f, -0.23462315f, 0.15348354f, 
    -0.23270769f, -0.02502097f, 0.04453885f, -0.00629856f, -0.09178074f, -0.00680753f, 0.14537954f, 0.02980808f, 
    -0.05508346f, 0.00956326f, 0.08512501f, 0.08832041f, 0.03645391f, 0.00162035f, 0.03312656f, 0.02078644f, 
    0.03405307f, 0.16118789f, 0.06136138f, 0.33727142f, 0.16942008f, 0.04824848f, 0.06081533f, 0.03713872f, 
    0.19632126f, 0.31545284f, 0.00890604f, 0.06587880f, 0.00238072f, -0.03954198f, -0.02642547f, 0.02910098f, 
    0.01771518f, -0.14696001f, -0.22556627f, -0.08472660f, -0.04557918f, -0.33601892f, -0.26739329f, -0.27097589f, 
    -0.14765520f, -0.02792097f, -0.07846711f, -0.05144994f, -0.09442369f, -0.06293746f, 0.02165268f, -0.11402814f, 
    0.00915044f, -0.02540143f, 0.01155048f, 0.11553677f, 0.04131151f, -0.07020458f, 0.01528575f, -0.07892241f, 
    0.04540680f, 0.28463897f, 0.29841819f, 0.30411255f, 0.28298259f, 0.09428763f, 0.00757473f, 0.05339008f, 
    -0.04457058f, 0.01797322f, -0.04465736f, 0.05602280f, -0.02558059f, -0.06143997f, 0.06699274f, -0.00894749f, 
    -0.01328487f, -0.03308538f, -0.07721416f, -0.00897233f, -0.08122825f, -0.22815792f, -0.19334146f, -0.16300599f, 
    -0.10061466f, 0.00670454f, -0.12643194f, -0.09069323f, -0.07398310f, -0.01051362f, 0.04453046f, 0.05040814f, 
    0.05624884f, 0.02400752f, 0.02541147f, 0.11016534f, 0.01711619f, -0.04284078f, 0.03447224f, -0.03165944f, 
    0.12369359f, 0.03380113f, 0.14017503f, 0.30646750f, -0.11700778f, 0.14457409f, -0.09659651f, -0.04861226f, 
    -0.15719104f, 0.03181373f, -0.09078888f, -0.03619881f, -0.03322610f, -0.15081501f, 0.05449653f, 0.06545303f, 
    -0.01597806f, -0.06689072f, 0.03243410f, -0.05969844f, -0.04378406f, -0.31357676f, -0.26915628f, 0.03691639f, 
    -0.02608871f, 0.00370829f, -0.01094325f, 0.08630098f, -0.20151120f, 0.03152473f, -0.00979690f, -0.01839853f, 
    0.03364034f, 0.06802635f, 0.03316079f, -0.05860677f, -0.00023701f, -0.04772481f, 0.02744743f, 0.02312050f, 
    -0.21946879f, -0.00600724f, 0.27051952f, 0.27812690f, -0.09319758f, 0.00738204f, 0.11201924f, 0.05319538f, 
    -0.10381604f, 0.07707058f, -0.05721685f, 0.01458624f, 0.03198284f, -0.05675241f, 0.05421227f, 0.03749698f, 
    -0.08176922f, -0.04404709f, -0.08058637f, 0.09496337f, -0.28367984f, 0.05609897f, 0.09062498f, 0.41613272f, 
    0.08234966f, 0.07927866f, -0.00352820f, -0.04909638f, -0.00235203f, 0.20539919f, -0.03846256f, 0.10594951f, 
    0.02072780f, 0.05217700f, 0.06508145f, 0.03154638f, 0.11318198f, -0.03233790f, -0.07631183f, 0.03512781f, 
    0.02022098f, 0.02278234f, -0.11524823f, 0.22633965f, 0.20350905f, -0.01033714f, 0.00260517f, 0.06595141f, 
    0.03521037f, 0.17494319f, 0.02618845f, 0.11183963f, 0.02093225f, 0.00242366f, -0.02104308f, 0.00801301f, 
    0.08349194f, 0.07086405f, -0.19883928f, 0.06766915f, -0.03075657f, 0.21989958f, 0.22744101f, 0.34359968f, 
    0.16549990f, 0.10337298f, 0.14182571f, 0.01018582f, 0.11317470f, 0.11802620f, -0.04663168f, 0.15302029f, 
    0.04808075f, 0.02409885f, 0.03055585f, -0.04286783f, -0.04353981f, -0.05181695f, -0.06975912f, 0.02775294f, 
    0.08499724f, 0.05957609f, -0.18147442f, 0.32611811f, 0.23485222f, 0.00105933f, 0.08161803f, 0.22121599f, 
    -0.01965822f, 0.32140496f, 0.00359957f, 0.06148896f, -0.02370665f, -0.04271539f, -0.02994058f, -0.00997689f, 
    -0.00069256f, 0.02788883f, 0.03618379f, -0.10353692f, -0.12520984f, 0.03006075f, 0.18717572f, 0.20006706f, 
    0.24809566f, -0.11594981f, 0.10008514f, -0.11265177f, -0.08316132f, -0.00814232f, -0.01151250f, 0.02493392f, 
    0.00287035f, 0.00657386f, -0.06446431f, 0.05702465f, 0.08673242f, -0.06169870f, -0.08516736f, -0.00170609f, 
    -0.20773612f, -0.13899936f, -0.13184455f, -0.02856405f, -0.10995980f, -0.16124450f, 0.02640995f, 0.02605905f, 
    -0.02700271f, -0.08922149f, 0.03685890f, -0.01954898f, -0.16397545f, 0.07518336f, 0.04190429f, 0.28635401f, 
    0.06812178f, 0.18811381f, 0.15468633f, 0.23340455f, 0.13593052f, -0.05595585f, 0.02186407f, 0.13730735f, 
    0.04493845f, 0.07577187f, 0.12936918f, 0.02542839f, -0.05712196f, 0.08440742f, -0.03131888f, -0.00763478f, 
    0.06688776f, -0.09346877f, 0.03223840f, 0.06806505f, 0.02599143f, 0.10953657f, -0.08281822f, 0.11588508f, 
    0.03768276f, -0.15289465f, -0.14155360f, 0.01281260f, -0.04543184f, 0.06532164f, 0.02489476f, 0.07179976f, 
    -0.02140251f, -0.02698810f, 0.07916430f, 0.13943513f, -0.06284177f, 0.04389190f, 0.03825025f, 0.04681089f, 
    -0.13192849f, 0.17609222f, 0.04206387f, -0.06976140f, 0.27962607f, 0.14725180f, 0.11193103f, -0.03111665f, 
    0.17255630f, 0.06795615f, 0.11120946f, 0.00972388f, -0.05753480f, 0.03300790f, 0.02467023f, -0.09358487f, 
    0.00881423f, -0.06382202f, -0.09230664f, 0.05186232f, 0.05258168f, -0.16272381f, 0.01057594f, 0.01101384f, 
    0.27673689f, -0.28875837f, 0.15170704f, -0.36718398f, 0.31059447f, 0.02670811f, 0.16820632f, 0.02044564f, 
    0.35332403f, 0.06058803f, 0.07501878f, 0.07187603f, 0.07661431f, 0.03357865f, 0.20549364f, -0.04870500f, 
    0.06310166f, -0.03468436f, -0.09008797f, 0.00270499f, 0.08104545f, 0.14163290f, 0.07685981f, -0.34722498f, 
    0.24997316f, -0.04262218f, 0.08582334f, -0.03168552f, 0.06742736f, -0.08145604f, -0.14778464f, -0.12398747f, 
    0.12674949f, 0.03226943f, 0.00969262f, -0.03371357f, -0.09184156f, -0.07086197f, -0.03541623f, -0.35756066f, 
    0.03121798f, 0.01869166f, -0.20610540f, 0.25635374f, -0.20514861f, 0.17722361f, -0.13477983f, 0.16768233f, 
    -0.17695734f, 0.02814837f, -0.03859088f, 0.03802560f, 0.01348892f, 0.03754290f, -0.01115508f, -0.07256277f, 
    0.03412541f, 0.02384911f, 0.05295618f, 0.10798987f, -0.12715030f, 0.03225721f, 0.10955527f, -0.14278223f, 
    -0.00068834f, -0.02328159f, 0.10913022f, 0.12514873f, 0.13344570f, -0.02837269f, 0.00198370f, 0.07221627f, 
    -0.00827188f, 0.07430454f, 0.10454400f, -0.10854103f, -0.01833700f, 0.00192007f, -0.07446866f, -0.24460329f, 
    -0.14593972f, 0.17206773f, 0.49321106f, 0.19838467f, 0.42976776f, -0.12264490f, -0.01042048f, 0.04763227f, 
    -0.09982783f, 0.12086463f, -0.07900219f, -0.03898272f, 0.06687772f, 0.00333106f, -0.07072170f, -0.00301322f, 
    -0.10397319f, -0.13467488f, -0.10688619f, 0.07395159f, 0.05488135f, 0.08386611f, -0.02199142f, -0.11476012f, 
    -0.01853062f, -0.04342503f, 0.16120169f, 0.10351660f, -0.04868354f, 0.07770086f, -0.19238493f, 0.02183280f, 
    -0.05834509f, 0.04084776f, -0.01851766f, -0.16676794f, -0.13714013f, -0.03180022f, -0.25860071f, -0.21197999f, 
    0.01254142f, -0.12899910f, 0.06365085f, 0.13688658f, 0.01195691f, -0.04929702f, 0.03337281f, 0.09017418f, 
    -0.06837483f, -0.03716322f, 0.02988569f, 0.02858810f, 0.09403237f, 0.18087271f, 0.06921134f, 0.07762566f, 
    0.25516385f, 0.30492643f, 0.15146127f, 0.20923127f, 0.34441763f, -0.10391611f, 0.19935074f, -0.06142490f, 
    0.12873720f, 0.15660422f, 0.16000251f, 0.06061428f, 0.12227831f, 0.07499647f, 0.03845387f, 0.03767489f, 
    -0.02329844f, -0.24272786f, -0.06118861f, -0.21242891f, -0.18907203f, -0.18046784f, -0.05033131f, -0.07211474f, 
    -0.21926528f, -0.03143680f, 0.32156509f, -0.08865555f, -0.06970005f, 0.08259057f, -0.05292444f, -0.18422756f, 
    0.02340221f, -0.13189751f, -0.09484898f, 0.07966582f, 0.05028816f, 0.02653190f, -0.04054630f, 0.07591535f, 
    0.14093992f, 0.14972231f, 0.15937951f, 0.05276819f, -0.46916184f, -0.16832861f, -0.08432424f, 0.10041738f, 
    -0.26981065f, -0.00223169f, 0.10111322f, -0.06921211f, -0.02561563f, 0.12555668f, -0.02730929f, -0.02127606f, 
    -0.06878161f, 0.16732875f, 0.08957994f, 0.15066993f, 0.01558899f, 0.12868297f, 0.02454531f, -0.04069242f, 
    -0.23291121f, -0.08845518f, -0.08392280f, 0.08286119f, -0.42078570f, 0.17578618f, -0.06021899f, 0.10967489f, 
    -0.15804160f, 0.10835448f, -0.15410142f, 0.10033993f, 0.07247550f, -0.07851929f, 0.10714531f, 0.17434859f, 
    0.09803022f, 0.05236451f, 0.02881448f, 0.17377067f, -0.21327525f, 0.36153966f, 0.18209496f, 0.12856494f, 
    0.13730811f, -0.17673767f, -0.19673505f, -0.01938109f, -0.03696374f, -0.03098949f, 0.06733386f, -0.04937028f, 
    -0.11746372f, -0.05548261f, -0.01545656f, -0.02415791f, -0.29956073f, -0.14933726f, -0.32183608f, -0.33825085f, 
    0.04643625f, 0.19847254f, -0.01848837f, 0.23236550f, -0.18536855f, -0.09482148f, -0.14299032f, 0.04594119f, 
    -0.02425277f, -0.25803754f, 0.07449275f, -0.14570419f, -0.09548506f, -0.01807005f, 0.14533091f, 0.00446833f, 
    -0.19776244f, 0.03777294f, -0.22070782f, -0.31542957f, 0.30888435f, 0.06833028f, 0.25903448f, 0.03467779f, 
    0.14159557f, 0.07764192f, 0.04443568f, -0.06783933f, 0.02272297f, 0.04747248f, -0.17759705f, -0.00349655f, 
    0.02457824f, -0.08275861f, 0.01119809f, 0.05462256f, 0.22748022f, 0.05245402f, 0.05278778f, 0.16049413f, 
    -0.16264038f, -0.34162450f, -0.12149130f, -0.27632338f, -0.02317670f, 0.10158416f, 0.00904517f, -0.01170718f, 
    0.20403004f, 0.12765743f, -0.05106793f, 0.05445305f, 0.25979355f, 0.07193912f, -0.06067120f, 0.02337428f, 
    -0.03320279f, -0.21891272f, -0.14241724f, 0.08511080f, 0.20475061f, 0.02626264f, 0.03034428f, 0.04050783f, 
    0.14844318f, 0.21756363f, -0.01382522f, -0.08681645f, 0.00129912f, 0.04346804f, 0.03055105f, 0.01823169f, 
    -0.04172031f, -0.05367480f, 0.01363466f, 0.02297809f, 0.14839821f, -0.14251569f, 0.02837560f, -0.00415986f, 
    -0.04853003f, 0.00527216f, 0.21841452f, -0.18844366f, 0.02234692f, -0.09703057f, 0.07028522f, 0.01610877f, 
    0.12664156f, -0.15511005f, -0.03140534f, -0.10724179f, -0.03618516f, -0.08731353f, 0.06620903f, 0.19111444f, 
    -0.05421092f, 0.11213402f, 0.24041989f, 0.22641535f, 0.00965405f, -0.04789199f, 0.04190192f, -0.23790587f, 
    0.02974383f, 0.02205994f, 0.16549230f, -0.00355655f, 0.03984353f, 0.11802248f, -0.16295685f, -0.00811114f, 
    -0.00648088f, 0.01232740f, 0.05966717f, -0.02356709f, -0.05960143f, -0.13689181f, -0.15017924f, -0.16277470f, 
    -0.12062004f, -0.02381290f, 0.29675433f, 0.33943185f, 0.14815055f, -0.06006835f, 0.02313966f, 0.00916020f, 
    -0.07977182f, 0.10921773f, -0.10950662f, -0.01712083f, 0.06483080f, 0.10933637f, 0.05167199f, 0.03825777f, 
    0.21843922f, 0.09925696f, -0.02560554f, 0.17839549f, -0.08696661f, 0.03777624f, -0.08666076f, -0.14317210f, 
    0.05347895f, -0.11620859f, 0.06383912f, 0.08702605f, 0.09337812f, 0.08692356f, -0.13847606f, 0.00626169f, 
    -0.05256518f, 0.00667799f, 0.02966960f, -0.07508656f, -0.15238126f, -0.13361146f, -0.25122982f, -0.31027308f, 
    -0.12704600f, -0.54480231f, -0.08951819f, -0.04591296f, 0.51879966f, 0.22942075f, 0.15259281f, 0.15061182f, 
    0.01729634f, 0.19971457f, 0.01876901f, 0.18770291f, 0.10510586f, 0.10764100f, 0.10843346f, -0.00360361f, 
    -0.09611502f, -0.12616818f, 0.03370815f, 0.05160638f, 0.20821284f, -0.02018364f, 0.03740283f, 0.12206309f, 
    -0.02593048f, -0.01721681f, 0.11197948f, 0.01885463f, -0.03924871f, 0.09025133f, -0.13200586f, -0.04065147f, 
    -0.06900530f, 0.06242213f, 0.03641016f, -0.03379803f, 0.08235035f, -0.01822106f, 0.03912554f, 0.06040027f, 
    0.11365268f, -0.09457479f, -0.30398291f, 0.08766255f, 0.19039941f, -0.05006265f, -0.05528173f, 0.07752433f, 
    -0.29056108f, 0.04058769f, 0.07133663f, 0.06991199f, 0.00270777f, 0.08878035f, -0.01500294f, -0.00994148f, 
    0.16633348f, 0.06553271f, 0.15462294f, 0.15779658f, 0.02526849f, -0.07372642f, -0.16072857f, -0.29901576f, 
    -0.02907965f, -0.17143765f, 0.05455621f, 0.09603115f, -0.08702166f, 0.02997625f, -0.03276226f, -0.02063371f, 
    0.02351415f, 0.07454033f, -0.08587370f, 0.16406944f, -0.02641891f, -0.01121968f, 0.19292061f, 0.29520214f, 
    -0.11798868f, 0.04212219f, 0.11132781f, -0.13008973f, 0.02578339f, -0.05940277f, 0.01631832f, -0.13335480f, 
    0.12385097f, -0.13065334f, -0.00473385f, -0.07864069f, 0.03260589f, -0.06823976f, -0.03311504f, 0.21091828f, 
    0.15782861f, 0.07135728f, 0.16506568f, 0.21468511f, -0.04006410f, 0.19038956f, 0.18803008f, 0.27890489f, 
    0.05945526f, 0.01022574f, -0.06542902f, -0.06666633f, -0.09202512f, -0.00228587f, 0.07785775f, 0.06224082f, 
    -0.07936896f, -0.03715521f, -0.10437676f, 0.02365677f, -0.16459934f, -0.11915892f, -0.07143281f, -0.24953428f, 
    0.14567296f, 0.01336207f, -0.04213547f, -0.00924465f, 0.23366681f, 0.06912716f, -0.06195934f, -0.12699014f, 
    0.11758249f, -0.11639624f, 0.00352801f, -0.08291224f, 0.02215902f, -0.19329257f, -0.03023451f, 0.07884460f, 
    0.09988840f, 0.00220325f, 0.14854509f, 0.13503930f, 0.15728940f, -0.16718858f, -0.10980470f, 0.19326542f, 
    -0.13161662f, -0.13496159f, -0.08943114f, 0.10156143f, -0.01238665f, -0.06981795f, 0.01984774f, -0.08311285f, 
    0.00229202f, 0.08972277f, 0.06337475f, 0.09607607f, 0.14202201f, 0.29483160f, 0.06877409f, 0.04826422f, 
    0.02642327f, -0.01887741f, 0.01038065f, 0.01058948f, -0.01943775f, -0.02841491f, -0.00030501f, -0.02115601f, 
    -0.02700498f, 0.00055348f, -0.04407287f, -0.03911496f, 0.02511019f, 0.01431264f, 0.00611456f, 0.02279865f, 
    -0.01917964f, -0.03484824f, 0.02085462f, -0.03022583f, -0.03373252f, -0.02538346f, 0.00352865f, 0.02497081f, 
    -0.00256872f, 0.00674170f, -0.00104820f, -0.00346063f, 0.02485429f, -0.04562233f, 0.03834300f, -0.03769290f, 
    0.02015607f, 0.02759553f, 0.02391917f, 0.02521957f, -0.04245317f, -0.03742525f, 0.02641259f, 0.01950233f, 
    0.02852961f, 0.00729308f, -0.01974215f, -0.04106188f, -0.02090642f, -0.00672775f, -0.02401605f, -0.03379941f, 
    -0.02642915f, -0.03330267f, -0.04643746f, 0.03042126f, -0.00593265f, -0.00204401f, 0.01299386f, 0.02278956f, 
    -0.02710038f, 0.03116073f, 0.02959250f, 0.00148612f, 0.04108838f, 0.02241682f, 0.00788895f, 0.01600432f, 
    0.02713221f, 0.02271028f, 0.02774284f, 0.02002180f, -0.03127943f, -0.03464707f, -0.03788975f, -0.04275922f, 
    -0.01870074f, 0.01939962f, 0.02462552f, -0.03851344f, 0.01969213f, -0.04009915f, -0.02507369f, -0.00465933f, 
    0.01698384f, -0.02825170f, 0.00083246f, -0.04495098f, 0.01248102f, -0.02860299f, 0.01971191f, -0.02929015f, 
    -0.02280927f, 0.00002330f, -0.00614067f, -0.04247507f, -0.01626633f, -0.03025153f, -0.01162045f, 0.01225948f, 
    0.02109846f, 0.00647186f, 0.02890912f, 0.00945491f, 0.03873475f, -0.03479857f, -0.04384376f, -0.02532118f, 
    0.03797987f, -0.02852311f, 0.00091113f, -0.01133261f, -0.01784567f, -0.00375848f, -0.02093918f, -0.01966741f, 
    0.00901041f, 0.03089411f, -0.00134157f, -0.01662658f, -0.00798923f, -0.01825830f, -0.02192891f, -0.01649661f, 
    -0.03715917f, -0.02824231f, 0.00262617f, 0.01740818f, -0.01194714f, 0.00170943f, 0.03096625f, 0.02823421f, 
    -0.03131312f, 0.02607350f, -0.01190507f, -0.03117207f, -0.00907520f, -0.03483092f, 0.00885981f, -0.00741431f, 
    0.00004953f, -0.01471134f, -0.02342623f, -0.00644834f, 0.01086037f, -0.03715184f, 0.02829001f, -0.04042080f, 
    0.03073953f, -0.03063816f, -0.04528970f, -0.00939190f, 0.01541264f, -0.04022341f, 0.01663996f, -0.02173447f, 
    -0.02388392f, 0.01836653f, -0.00278966f, 0.01364728f, 0.01975060f, -0.00902844f, -0.01422579f, -0.04028967f, 
    -0.01140990f, -0.01593959f, -0.00902515f, -0.01674613f, -0.00842687f, 0.00397396f, -0.03741619f, 0.00560546f, 
    0.00202483f, 0.01087824f, 0.02924220f, -0.01950352f, -0.03131028f, -0.02024437f, 0.02613022f, -0.03284622f, 
    -0.00947489f, 0.02124740f, 0.02180129f, 0.03067438f, 0.02637989f, -0.01483751f, -0.00850340f, -0.01652147f, 
    0.00293732f, 0.00054791f, -0.01103212f, -0.02398587f, -0.01882877f, 0.00615854f, 0.01786374f, 0.01425350f, 
    -0.00528919f, -0.04151509f, -0.02388782f, 0.00584619f, -0.04551007f, -0.01062488f, 0.02154247f, -0.02423320f, 
    -0.01310991f, 0.02168318f, -0.00291249f, -0.00872208f, -0.04058580f, 0.01509668f, -0.04006352f, -0.00848446f, 
    0.03403667f, 0.02110222f, -0.00465383f, -0.02498943f, -0.02509793f, 0.01808458f, 0.01450011f, -0.03622661f, 
    0.02060139f, 0.01110301f, -0.03886150f, -0.01866397f, -0.02737900f, -0.03421042f, 0.01716383f, -0.01473306f, 
    0.04191685f, -0.04281284f, 0.00981629f, -0.03756611f, -0.00420422f, -0.03069592f, -0.02298993f, -0.03997733f, 
    -0.01542880f, -0.03708673f, 0.03223139f, 0.02599469f, -0.02698163f, -0.02812156f, 0.01962093f, -0.01082066f, 
    -0.03927455f, 0.01378349f, 0.00500674f, -0.02018472f, -0.02426044f, -0.02889915f, 0.02226041f, 0.01760492f, 
    -0.02025910f, 0.02576783f, 0.00237186f, 0.00952136f, -0.03000187f, 0.00403579f, -0.00908731f, 0.01756689f, 
    0.02876713f, 0.02201393f, 0.01546290f, -0.02415283f, 0.03047361f, 0.01860892f, 0.02887158f, 0.02230983f, 
    0.04183486f, -0.02759297f, 0.01629280f, 0.00125716f, -0.00673637f, 0.02798072f, -0.04410342f, 0.00967299f, 
    -0.01601820f, 0.03184956f, 0.02427288f, -0.04439822f, -0.01795670f, 0.02335658f, 0.00413193f, 0.02243045f, 
    0.03148937f, -0.03486473f, 0.01869450f, 0.02790883f, 0.03657604f, 0.02074385f, 0.03050214f, -0.00425330f, 
    -0.01115308f, -0.03824346f, 0.02426482f, 0.01546168f, -0.01258026f, -0.03718774f, -0.01046033f, -0.00503831f, 
    0.01715508f, -0.03589376f, 0.02605303f, 0.00290792f, 0.01065031f, 0.02685486f, 0.02973391f, 0.02405345f, 
    -0.00486692f, -0.03112186f, -0.04152853f, 0.02951356f, 0.02242647f, 0.02875015f, -0.01202242f, -0.02700800f, 
    0.01114117f, 0.02375124f, -0.03347084f, -0.01154071f, 0.00483100f, 0.02866611f, -0.00227240f, 0.01012981f, 
    0.02527882f, 0.01783846f, 0.01188113f, -0.03341413f, 0.01127189f, -0.03501078f, -0.02202301f, 0.00351889f, 
    -0.03939850f, -0.02404666f, -0.01435852f, 0.01724591f, -0.02219153f, 0.02597339f, -0.00536746f, -0.01615000f, 
    0.01587177f, -0.00405590f, 0.00375479f, 0.01626546f, -0.01061270f, -0.00117397f, -0.03212195f, -0.03020856f, 
    -0.02669804f, 0.00773254f, -0.03698124f, 0.00684504f, -0.02485362f, -0.01500408f, -0.02614233f, 0.01553571f, 
    -0.04321041f, 0.03095855f, -0.04265098f, -0.03621903f, 0.01545219f, -0.01341126f, -0.00186077f, 0.02775604f, 
    0.00470591f, 0.04381385f, -0.03078417f, -0.01973979f, 0.01679686f, -0.00424893f, -0.01467538f, 0.01932571f, 
    0.01361424f, 0.02401333f, 0.01680755f, -0.03239400f, -0.00595178f, -0.00516875f, 0.00574273f, 0.03071986f, 
    -0.01432341f, 0.02816083f, -0.02251761f, -0.03588380f, -0.01616029f, -0.02513441f, 0.02595659f, 0.02992845f, 
    -0.01637242f, -0.03544197f, -0.01142417f, 0.01422779f, 0.02111637f, 0.02948512f, 0.01589797f, -0.03003659f, 
    -0.02183542f, 0.02307025f, 0.01620388f, 0.00943475f, -0.00054264f, -0.00884520f, -0.04304742f, 0.00334593f, 
    -0.03137435f, -0.02286434f, -0.03201202f, 0.02901172f, 0.03577787f, 0.02130010f, 0.02556301f, -0.00206241f, 
    -0.00524499f, 0.00113391f, 0.02977602f, 0.01703357f, -0.00284123f, -0.02763303f, 0.01852947f, 0.00285364f, 
    -0.02344786f, 0.00024714f, 0.00449172f, 0.01403106f, -0.01177827f, -0.00550802f, 0.02359431f, 0.02641136f, 
    0.01383759f, -0.01257694f, -0.03189753f, 0.00652079f, -0.03029246f, 0.01113771f, 0.01824450f, 0.01102052f, 
    0.02389390f, -0.02806216f, -0.03115963f, -0.01501260f, -0.02731187f, -0.02122015f, -0.00198237f, -0.01705408f, 
    -0.01134247f, 0.01655163f, 0.02054705f, 0.03059657f, -0.00384797f, -0.02252369f, -0.01028703f, 0.02370995f, 
    0.01920713f, 0.02316768f, -0.04480661f, -0.04630333f, 0.01433918f, -0.01318877f, 0.00207619f, 0.00752532f, 
    0.02771921f, -0.00196775f, 0.02442477f, 0.01569580f, -0.03056627f, -0.02260394f, -0.04520670f, -0.00480382f, 
    -0.00977999f, 0.01192940f, -0.02438370f, -0.03467348f, 0.00281841f, 0.01215981f, 0.00161899f, -0.00488015f, 
    -0.01932258f, -0.02471002f, 0.03441374f, -0.00924908f, -0.02054450f, 0.02428726f, -0.01779905f, 0.02916456f, 
    -0.04129982f, 0.00562169f, 0.02327668f, -0.00584144f, -0.03840702f, -0.00044625f, -0.03675875f, 0.02504924f, 
    -0.00285996f, 0.00136613f, 0.01525815f, -0.03730246f, 0.02537909f, -0.03646999f, -0.02829391f, 0.02980994f, 
    0.00870424f, 0.02133309f, -0.04598230f, 0.01382094f, -0.03032134f, -0.02873491f, -0.04748646f, -0.02586474f, 
    -0.00973370f, -0.01088709f, -0.00265995f, -0.01581315f, -0.01967971f, 0.00814002f, -0.01780836f, -0.04294808f, 
    -0.02172163f, -0.03716702f, 0.01597694f, -0.02090319f, -0.02141832f, -0.01702793f, 0.00649359f, 0.00107332f, 
    0.00056176f, -0.03347141f, -0.01942473f, -0.03994787f, 0.01165650f, 0.02554595f, -0.04418664f, -0.04079181f, 
    -0.03794918f, -0.00218575f, -0.00760073f, -0.03429322f, 0.00619616f, -0.02460479f, 0.01616267f, 0.00640414f, 
    -0.03845105f, 0.02512127f, -0.01141367f, -0.02506610f, 0.01784493f, -0.01197843f, -0.02942508f, -0.02937829f, 
    -0.00132238f, -0.00130492f, -0.02894455f, 0.02225663f, 0.03152809f, 0.00349584f, 0.01702461f, 0.01278185f, 
    0.01900606f, -0.00709394f, -0.00673302f, 0.00549469f, 0.02557722f, -0.03130575f, -0.00293493f, -0.02335979f, 
    -0.02295920f, 0.00408121f, 0.01566032f, -0.02209503f, -0.01118279f, -0.04182809f, -0.02311270f, -0.01682291f, 
    0.01565328f, 0.02688885f, -0.02185360f, -0.00262654f, -0.02303361f, 0.02867013f, -0.03107024f, -0.04165354f, 
    -0.03710934f, -0.02543358f, -0.00024989f, -0.02726757f, -0.04323396f, -0.03739455f, -0.00678453f, 0.00120122f, 
    0.00888903f, 0.02802872f, 0.01785411f, -0.04083635f, -0.03515770f, 0.01426913f, -0.01079553f, -0.03139547f, 
    -0.00354689f, -0.04324813f, 0.01891244f, 0.01086613f, -0.00443974f, -0.01943409f, -0.01649361f, -0.02714878f, 
    -0.01475765f, -0.02052856f, 0.01538230f, -0.04114301f, -0.00506845f, 0.01063400f, 0.00425672f, -0.00498718f, 
    -0.03051720f, -0.01873292f, -0.01587211f, 0.01219108f, 0.01226448f, -0.01306938f, -0.02215611f, 0.01001494f, 
    -0.00765080f, 0.00444446f, -0.01706698f, 0.02765218f, -0.03545864f, -0.02592481f, 0.00704705f, -0.03955989f, 
    0.02568419f, -0.04250404f, 0.00417302f, -0.01278364f, -0.04532455f, 0.01392248f, -0.02311097f, 0.01276921f, 
    0.00071797f, -0.04026134f, 0.00118219f, 0.03039130f, -0.03640456f, -0.02981320f, 0.01371426f, 0.01933574f, 
    -0.00438069f, 0.02065826f, -0.03395348f, 0.01061400f, -0.02024481f, 0.01583438f, -0.00452071f, -0.00794758f, 
    -0.02294691f, 0.00876211f, -0.00204560f, -0.02464035f, -0.01185488f, -0.00912058f, -0.02871758f, -0.02507250f, 
    -0.02571428f, 0.00661070f, 0.03592855f, -0.02247517f, 0.02620155f, -0.03628399f, -0.01216064f, 0.02000416f, 
    0.03371062f, -0.01904675f, 0.02560224f, -0.01334313f, 0.02604996f, 0.00280163f, -0.01741473f, -0.01385353f, 
    0.02483239f, 0.00060700f, 0.00995387f, 0.00032679f, -0.01970730f, -0.04447704f, -0.04456930f, 0.00459256f, 
    -0.02162789f, 0.01354538f, -0.00867154f, -0.02693157f, 0.03251214f, -0.00982377f, -0.03637607f, -0.02869616f, 
    -0.03030278f, -0.03779328f, -0.02380656f, 0.01389430f, -0.03145660f, 0.01715743f, -0.02426920f, -0.02622815f, 
    0.02315914f, 0.00881172f, -0.00171351f, -0.01304258f, -0.03345399f, -0.04353173f, -0.02946016f, -0.00711328f, 
    -0.00087202f, -0.00565513f, -0.02876116f, 0.01880103f, 0.00743427f, -0.02240089f, -0.03152453f, 0.00999712f, 
    -0.01709662f, 0.00337876f, -0.00282215f, -0.04130064f, 0.00818050f, -0.02660182f, -0.04448637f, 0.01042863f, 
    -0.00178598f, 0.00518141f, 0.02032175f, -0.01373232f, 0.01891530f, -0.04488975f, 0.03395617f, 0.03194096f, 
    -0.03349480f, 0.02502107f, -0.03187979f, -0.00684226f, 0.02317770f, 0.01334954f, 0.00551330f, -0.01135860f, 
    -0.03643127f, 0.02728180f, 0.03139339f, -0.02576398f, -0.02444416f, -0.02992698f, -0.00805099f, -0.01243771f, 
    0.01818694f, -0.03105602f, -0.00136113f, 0.03269508f, -0.00483128f, 0.01378007f, -0.00209464f, 0.01674647f, 
    0.00342091f, -0.00875355f, 0.00730657f, 0.03131631f, 0.01298602f, 0.02877434f, -0.02004623f, 0.03372887f, 
    -0.02003175f, 0.01893737f, -0.01050279f, 0.01769042f, -0.00960773f, -0.00868139f, 0.01866895f, -0.02756041f, 
    0.02962130f, -0.03547888f, 0.00637295f, 0.02954678f, 0.00885722f, -0.03284376f, 0.03083114f, 0.02817726f, 
    -0.00726186f, -0.00160522f, 0.03344009f, -0.02599712f, 0.00618342f, 0.02123223f, 0.01527052f, -0.02257022f, 
    -0.00621173f, -0.02272296f, 0.02957907f, -0.04004416f, 0.00861635f, -0.03872194f, -0.04180541f, -0.02024928f, 
    -0.02416496f, 0.01414623f, 0.02193252f, -0.02820723f, 0.02430779f, -0.02246286f, -0.02437958f, -0.03704688f, 
    0.02569477f, 0.02257594f, -0.03775420f, 0.01209114f, 0.01118162f, -0.00156051f, -0.01992078f, -0.00036143f, 
    -0.04057282f, 0.00332614f, 0.00068005f, 0.00426141f, -0.01486086f, -0.01286728f, 0.01935402f, -0.03226940f, 
    -0.00028314f, -0.04162548f, 0.00228214f, -0.01115927f, -0.01340353f, -0.01254870f, -0.00999770f, -0.03803238f, 
    -0.04493562f, -0.01772341f, 0.01155485f, 0.01936628f, -0.01048247f, -0.02457901f, -0.00917463f, -0.01163220f, 
    0.00439522f, -0.00594829f, -0.02885355f, 0.01001269f, 0.01621521f, -0.02945738f, 0.00100735f, 0.01053028f, 
    0.02660555f, -0.02331915f, 0.01669086f, -0.01844251f, -0.01567306f, 0.02310491f, 0.00121438f, 0.00644717f, 
    0.00680484f, -0.03279160f, -0.03644339f, -0.00261318f, -0.00755380f, 0.01928941f, -0.00927902f, 0.00901639f, 
    0.01507438f, -0.01509994f, -0.00673133f, 0.03920687f, -0.02762105f, -0.04350857f, 0.02173526f, -0.01004854f, 
    -0.03812027f, -0.03331976f, -0.03431135f, -0.02557175f, -0.00889640f, -0.03889293f, -0.04000490f, 0.02510718f, 
    -0.00691773f, -0.00443540f, -0.04021410f, 0.00712797f, -0.00542421f, -0.04406708f, 0.01421128f, -0.01383522f, 
    -0.02541288f, -0.02250194f, 0.00981980f, 0.00281352f, 0.01178580f, -0.02264555f, -0.00995050f, 0.02178809f, 
    0.01079016f, 0.00979830f, -0.01495501f, 0.00602438f, 0.03012507f, 0.01855208f, 0.01646615f, -0.01058972f, 
    -0.03540752f, -0.03051524f, -0.02934566f, -0.00861956f, -0.01480752f, 0.01135614f, 0.03164388f, -0.02358383f, 
    -0.01084270f, 0.03359444f, -0.01118755f, -0.02335247f, -0.01834461f, 0.02480701f, -0.01908913f, 0.01584735f, 
    0.00846583f, -0.03934544f, 0.00622684f, -0.03326792f, -0.02397604f, -0.02102217f, -0.00904128f, 0.00515450f, 
    -0.03417295f, 0.01150148f, -0.04466071f, -0.00118066f, 0.03218579f, -0.03253400f, 0.00177048f, 0.02393418f, 
    -0.04192660f, 0.03369057f, -0.04138144f, -0.01111608f, -0.03044511f, 0.03176280f, 0.02593481f, -0.01437641f, 
    0.01603434f, 0.03275360f, -0.01533574f, -0.02851990f, -0.02573502f, 0.03029847f, 0.00862907f, -0.04195853f, 
    0.01830435f, 0.00313599f, -0.02612040f, -0.01135359f, 0.02603665f, 0.00975261f, 0.00887446f, -0.03819494f, 
    -0.00996209f, -0.03901087f, -0.04111550f, 0.02347492f, -0.02157209f, -0.00020765f, -0.01928376f, -0.04416833f, 
    -0.03313585f, 0.03116930f, -0.04327045f, -0.01274002f, 0.01845321f, 0.02580315f, 0.03373466f, -0.00099927f, 
    0.00625138f, 0.00603633f, -0.04482204f, -0.02425573f, -0.00012813f, -0.00065125f, -0.04356860f, -0.00251780f, 
    -0.03059598f, 0.00616561f, 0.02733236f, 0.01014215f, -0.03008258f, -0.01517604f, -0.00666061f, -0.03921735f, 
    -0.02653061f, -0.02188288f, -0.04361874f, 0.00874423f, -0.04096962f, -0.03976063f, 0.00249462f, -0.00737423f, 
    0.02792586f, 0.03299332f, 0.00413900f, 0.01622639f, -0.00063071f, -0.01173532f, 0.00083033f, -0.00569768f, 
    -0.01625422f, 0.02138307f, 0.01145737f, -0.01558332f, -0.02749656f, 0.01869862f, -0.02702044f, -0.01394619f, 
    0.02183221f, -0.01147736f, -0.04442368f, 0.00707998f, 0.02564126f, -0.03108869f, 0.02838571f, 0.01327504f, 
    0.00654014f, 0.00617417f, -0.01513742f, -0.00920456f, 0.02888952f, 0.01490339f, -0.00648610f, 0.02884788f, 
    -0.01383968f, -0.04070966f, -0.02068560f, -0.01140715f, -0.03930835f, -0.00869535f, -0.03726085f, -0.01844252f, 
    0.03014962f, -0.02170668f, -0.03405862f, 0.03301051f, -0.01062919f, 0.02930532f, 0.02452681f, 0.00139870f, 
    -0.01542479f, 0.01128835f, 0.00030959f, 0.01424823f, 0.03460957f, 0.00955084f, -0.03665937f, 0.00275069f, 
    0.03228521f, 0.02541838f, 0.02779452f, -0.01685742f, 0.03379123f, 0.01663459f, -0.01732948f, 0.01302425f, 
    0.03317314f, -0.00582426f, 0.02474602f, -0.00097930f, 0.00857137f, -0.01163477f, -0.01276946f, 0.00094499f, 
    -0.02726065f, 0.02774413f, -0.04208448f, 0.01082972f, -0.01938212f, 0.02409106f, 0.02341647f, 0.00268567f, 
    0.01052878f, -0.01396879f, -0.01123037f, -0.01905352f, 0.02380731f, -0.03810961f, -0.03880257f, -0.01840702f, 
    -0.00975654f, -0.03773241f, 0.00918449f, -0.03851469f, -0.03821505f, 0.00744827f, 0.02864152f, -0.03336873f, 
    0.03017217f, -0.00555117f, -0.02785341f, -0.03943653f, -0.01597694f, 0.00296314f, -0.02128928f, -0.03524103f, 
    -0.03987431f, 0.00936719f, -0.03054486f, -0.02079186f, -0.01400733f, 0.01574856f, -0.02284621f, -0.04145873f, 
    -0.02361501f, 0.01289030f, 0.03288662f, 0.01846457f, -0.00504779f, 0.02873719f, -0.00305287f, -0.04287711f, 
    -0.00745809f, 0.01740519f, 0.02016016f, 0.02714807f, -0.00449573f, 0.02971622f, 0.03160916f, -0.02886515f, 
    -0.02809740f, -0.01557251f, 0.01001493f, 0.00740835f, 0.02259905f, -0.03300760f, 0.02220865f, -0.04274120f, 
    -0.00813536f, -0.03741660f, -0.03384119f, 0.00092929f, 0.03015499f, 0.01226202f, -0.01450012f, -0.00187132f, 
    0.02556747f, 0.01233430f, -0.04074244f, -0.02300023f, 0.01332015f, 0.01205108f, -0.03235452f, 0.00719122f, 
    -0.01192890f, 0.03220760f, -0.00210087f, -0.01675920f, -0.03489081f, 0.03345032f, -0.03333865f, -0.00930115f, 
    0.01254722f, -0.02687957f, -0.02039890f, 0.02630183f, -0.00278199f, -0.00932303f, 0.01547697f, -0.00791259f, 
    0.00257121f, 0.02087911f, -0.03314541f, 0.00716988f, -0.00705458f, -0.03217569f, -0.03318157f, -0.02861503f, 
    -0.02736601f, 0.02819683f, -0.01214006f, -0.02972976f, 0.01967804f, -0.03952071f, 0.01420849f, 0.03118726f, 
    0.00380572f, -0.02930433f, -0.00813853f, -0.01294747f, 0.01391723f, 0.02000468f, 0.00025751f, 0.03895937f, 
    0.03676521f, 0.02670387f, -0.02637034f, -0.03689306f, 0.00953407f, 0.03342828f, 0.01429333f, 0.00364847f, 
    0.00507102f, 0.02768435f, -0.03458001f, -0.02946714f, 0.01769825f, -0.03747721f, -0.02651492f, 0.00885328f, 
    -0.01673245f, 0.00863609f, -0.02551423f, -0.00815128f, 0.03807519f, 0.00963951f, 0.02513865f, 0.03111138f, 
    -0.00094202f, 0.03704949f, 0.00960959f, 0.01165179f, -0.00143667f, 0.03053291f, 0.02126375f, -0.00035760f, 
    -0.03290572f, 0.02552471f, -0.01731047f, -0.01041775f, -0.01476376f, -0.00657120f, -0.01934501f, -0.01577359f, 
    0.01984148f, -0.01510631f, 0.02510486f, -0.02315365f, -0.00503497f, -0.01662511f, 0.02224617f, -0.02958822f, 
    0.01636235f, 0.02000354f, -0.02558019f, 0.00839479f, -0.01040018f, -0.02620070f, 0.02129552f, -0.00718672f, 
    0.03164654f, -0.03784481f, 0.03456203f, 0.02992877f, 0.00201755f, -0.00637675f, 0.03179840f, 0.00669511f, 
    0.02034751f, 0.02320732f, -0.00896228f, -0.03442300f, -0.00402881f, -0.02187968f, -0.01637414f, 0.00074162f, 
    -0.03410534f, -0.03406457f, 0.01593648f, 0.00179737f, -0.00824080f, -0.02715783f, -0.00689908f, -0.02124855f, 
    -0.02406458f, 0.01822350f, -0.01316123f, -0.02631564f, -0.03567291f, -0.00297460f, 0.00422286f, 0.01196207f, 
    0.00698918f, -0.03036041f, 0.00522564f, 0.00671940f, 0.00553623f, -0.00280617f, -0.02466984f, 0.01100359f, 
    -0.29008076f, 0.15534224f, 0.08987727f, -0.06774990f, -0.03908295f, -0.05161770f, -0.03571495f, 0.04666744f, 
    0.01313615f, 0.10423591f, -0.03129718f, 0.04797755f, -0.02864907f, -0.11874743f, -0.02955024f, 0.01224918f, 
    0.01572940f, 0.11417217f, 0.14107150f, 0.18117967f, -0.29373544f, -0.29494500f, 0.02606330f, -0.34940434f, 
    -0.02809991f, -0.05442255f, 0.03165197f, -0.17253353f, 0.02668646f, -0.02024032f, 0.03738001f, -0.00688811f, 
    -0.03558259f, 0.03135024f, 0.01997132f, 0.05905305f, 0.21078354f, -0.00158622f, 0.01253471f, 0.14247762f, 
    0.10680975f, 0.16119331f, 0.06672809f, 0.15537357f, 0.03816921f, 0.03568287f, -0.12115907f, 0.17055988f, 
    0.03685313f, 0.25452468f, -0.06859788f, 0.05894294f, -0.07872396f, 0.04724741f, -0.09267755f, -0.03230715f, 
    -0.09431227f, -0.02911265f, -0.07007272f, -0.01714657f, -0.21177326f, 0.02989765f, 0.09907707f, -0.03374689f, 
    0.03950808f, -0.10477384f, 0.05464472f, -0.04937221f, 0.00599728f, -0.12375429f, 0.11825892f, -0.05289405f, 
    -0.05150336f, 0.03688776f, -0.09340204f, 0.07827850f, 0.02854555f, -0.00690773f, -0.03880690f, 0.02846978f, 
    -0.36911666f, -0.58062422f, 0.35441950f, -0.09412859f, -0.38097498f, 0.28426224f, -0.08312184f, 0.06932992f, 
    -0.28449640f, -0.25873205f, 0.00583504f, -0.02475916f, 0.04901907f, 0.11181596f, 0.10089062f, 0.04086706f, 
    -0.16893344f, -0.04978430f, -0.13599420f, 0.12090977f, -0.33500034f, 0.06347588f, -0.09585045f, -0.07398358f, 
    -0.05278268f, -0.20843486f, 0.03424666f, 0.01690648f, -0.18911898f, -0.22473855f, -0.09672786f, -0.11345411f, 
    0.03105621f, -0.03213916f, 0.03751051f, -0.11623570f, -0.15021463f, -0.01457327f, -0.06203533f, -0.45874330f, 
    -0.02149162f, 0.20588613f, -0.13094473f, -0.00885265f, 0.09789953f, 0.09411190f, -0.15036437f, 0.06424703f, 
    -0.09091681f, -0.05755213f, -0.09595141f, -0.06213132f, 0.08245295f, -0.06168238f, -0.06037188f, -0.12040430f, 
    -0.09069252f, -0.10865586f, -0.01739509f, 0.06865777f, -0.04348971f, -0.18930256f, -0.02694727f, -0.21909456f, 
    -0.08421063f, 0.00995115f, 0.19508530f, 0.10078441f, -0.10197847f, -0.18362564f, -0.04846953f, 0.05304159f, 
    0.07299665f, -0.03270714f, -0.13540380f, -0.06652751f, 0.02441370f, -0.12117597f, -0.05978154f, -0.21730562f, 
    0.31553668f, 0.09160338f, 0.19472279f, 0.17409632f, 0.35942292f, 0.05529974f, 0.01312997f, -0.03513182f, 
    0.04867313f, -0.16811407f, -0.05287076f, -0.05980981f, 0.02599943f, 0.02333059f, 0.01606395f, 0.20345590f, 
    0.01894646f, -0.05595978f, -0.02918412f, -0.03593470f, -0.16707474f, -0.07681337f, -0.05231752f, -0.22401914f, 
    -0.24724251f, 0.19995646f, 0.00231173f, -0.04966410f, -0.04392619f, 0.00026551f, 0.01782396f, 0.17722347f, 
    -0.04412277f, -0.09207103f, -0.01593034f, -0.02623332f, -0.16217232f, -0.11294516f, -0.02322892f, -0.26167876f, 
    0.16743597f, 0.22831692f, 0.45261282f, 0.41612527f, -0.02218142f, -0.02457283f, 0.10787010f, 0.05288837f, 
    0.09816413f, -0.08635268f, 0.06730378f, 0.03793501f, 0.08781683f, -0.10848359f, 0.11248193f, 0.10399551f, 
    0.16081499f, 0.11159564f, 0.16688673f, 0.10240653f, -0.11526877f, 0.33450353f, 0.48529533f, 0.17070089f, 
    -0.05740369f, 0.21523294f, 0.12290171f, 0.07089150f, 0.11406723f, 0.14623198f, 0.03009854f, -0.01827436f, 
    0.04683523f, 0.08820424f, -0.00060746f, -0.18743978f, -0.21662781f, -0.38166654f, -0.04795724f, -0.02044880f, 
    -0.46913162f, -0.40062276f, -0.12713099f, -0.16749699f, -0.22508998f, 0.00977839f, -0.04553215f, 0.04791388f, 
    -0.06544255f, 0.02078837f, -0.02214850f, 0.05978033f, 0.08468351f, 0.03866353f, -0.03900985f, 0.07468045f, 
    0.09557436f, 0.14804243f, 0.19067095f, -0.01038373f, 0.29217428f, -0.06590100f, -0.45743793f, -0.11224920f, 
    -0.39159122f, -0.12643231f, -0.00263498f, 0.15516523f, -0.09464267f, 0.03305055f, 0.08433781f, 0.19554758f, 
    -0.11495304f, -0.02188987f, -0.04943227f, 0.18081850f, 0.07315680f, 0.21106716f, 0.01877999f, 0.01211288f, 
    -0.37101379f, -0.27579036f, -0.43743828f, -0.03261854f, -0.00470814f, 0.02885910f, -0.09632315f, 0.12843506f, 
    -0.04742295f, -0.02716758f, -0.03205564f, 0.05496173f, 0.00676018f, -0.22673340f, 0.03615211f, -0.00667615f, 
    0.04045479f, 0.00837897f, 0.23748618f, 0.13337901f, 0.35643589f, 0.01176217f, -0.02986159f, 0.34132272f, 
    0.19033293f, 0.10149750f, -0.00061189f, 0.06688526f, 0.03828105f, -0.11413924f, 0.03351916f, 0.05112898f, 
    0.10246675f, 0.04974426f, 0.06844487f, 0.11136320f, -0.23291060f, -0.10268059f, -0.04670809f, -0.34212315f, 
    0.43024930f, 0.02417004f, 0.16611356f, 0.16349971f, -0.02938339f, -0.14295392f, -0.04938750f, 0.15346150f, 
    0.01810963f, -0.07960042f, 0.06752171f, -0.14325394f, 0.10066031f, 0.00679619f, 0.12409563f, -0.00875982f, 
    -0.04407072f, -0.11270787f, -0.00020488f, -0.23268245f, -0.15691662f, -0.23319682f, -0.05355469f, -0.10289526f, 
    -0.08189657f, 0.05233973f, -0.02091330f, 0.00048499f, 0.00899477f, 0.01878325f, -0.00792479f, 0.00716962f, 
    0.07479652f, 0.04588135f, 0.02381591f, 0.07765318f, 0.14138776f, 0.06408344f, 0.10318547f, 0.07008243f, 
    -0.18196620f, -0.52509135f, -0.30136672f, -0.11546776f, 0.21112651f, 0.03529136f, 0.12138790f, 0.11857539f, 
    -0.15888277f, 0.00508289f, 0.19070537f, -0.03981383f, 0.11716176f, 0.11002588f, 0.00875432f, 0.20765553f, 
    0.01839155f, -0.39130971f, -0.23679121f, 0.08485229f, 0.00447751f, -0.21970603f, -0.16387096f, -0.12845549f, 
    0.01714242f, 0.07187889f, -0.02447953f, -0.04985341f, -0.09980541f, -0.12079115f, 0.08960652f, 0.02233907f, 
    -0.07660449f, -0.06585029f, 0.01661005f, 0.05524008f, 0.15226170f, -0.03414081f, -0.02380309f, 0.07215481f, 
    -0.16415948f, 0.12180299f, 0.08836107f, -0.08539408f, 0.03397588f, -0.07837464f, -0.06549403f, 0.05346737f, 
    0.00027625f, 0.27586126f, -0.03629293f, -0.04878586f, 0.02898414f, -0.07857916f, 0.01833829f, -0.13232972f, 
    0.04328297f, -0.06313711f, 0.05403672f, 0.27248308f, -0.04196508f, -0.19425718f, -0.16598260f, -0.37236038f, 
    0.03555501f, 0.10109511f, -0.04301762f, -0.13710980f, 0.08805740f, 0.03127888f, 0.05149709f, -0.04438913f, 
    0.05536817f, -0.04970295f, 0.00123286f, 0.08516908f, 0.00761117f, -0.25220928f, 0.04065592f, -0.22886597f, 
    0.38431102f, 0.20851031f, 0.46861330f, 0.39155480f, 0.09534241f, 0.06360020f, 0.04536560f, -0.01561392f, 
    0.09495538f, -0.04368738f, 0.05349224f, -0.02639163f, 0.08811100f, -0.00206016f, 0.07525700f, 0.17306067f, 
    0.08333468f, 0.09922209f, -0.05169373f, 0.09168696f, -0.14832190f, -0.23966359f, -0.07573993f, -0.17604598f, 
    -0.04492796f, -0.04245689f, 0.04015753f, 0.05033023f, -0.01560182f, -0.13899226f, 0.04217516f, -0.08557855f, 
    -0.13406073f, -0.02997510f, -0.03602165f, 0.02618722f, -0.24506629f, -0.14453696f, -0.12886187f, -0.23186637f, 
    -0.09093069f, -0.37558231f, -0.11108919f, 0.20086955f, 0.56185061f, 0.15120026f, -0.02746236f, -0.09672021f, 
    -0.14723942f, -0.10446175f, -0.12248542f, -0.00483821f, 0.07509824f, -0.04330954f, 0.05731818f, 0.21095486f, 
    0.07431560f, 0.02164530f, -0.17179632f, -0.16396022f, -0.00282465f, -0.12152674f, -0.00102833f, -0.05276305f, 
    -0.13885729f, 0.11920737f, -0.00902122f, 0.04486180f, -0.05819609f, 0.00870925f, -0.18789698f, -0.06396747f, 
    -0.02929223f, 0.01380681f, 0.08668216f, -0.11431879f, 0.00201066f, -0.07222464f, 0.06287030f, -0.00143795f, 
    0.07503533f, 0.07319422f, -0.03358315f, 0.21418521f, 0.08590787f, 0.02311823f, -0.01594846f, 0.00897776f, 
    -0.06786240f, 0.06931624f, 0.01082168f, 0.01921620f, 0.07720760f, -0.02546102f, -0.12262632f, -0.02344576f, 
    0.11715715f, 0.07078406f, -0.07452536f, 0.11244694f, -0.03923413f, 0.09148721f, 0.04159971f, 0.03971176f, 
    0.13939048f, -0.05288696f, -0.01823991f, 0.07639503f, -0.00163591f, 0.23264413f, 0.05090715f, 0.06172056f, 
    0.07639529f, 0.05061134f, 0.01952417f, 0.05055175f, 0.08968638f, 0.10053575f, -0.15868503f, 0.39076418f, 
    -0.12267666f, 0.08279675f, 0.07425103f, -0.03230292f, -0.01262119f, -0.06109771f, -0.10020717f, 0.02468310f, 
    -0.03723189f, 0.08600227f, -0.03714980f, -0.00932003f, -0.05049873f, 0.04910450f, 0.04014622f, -0.03941368f, 
    0.17984301f, 0.05006161f, 0.05288612f, 0.28127727f, 0.08807693f, 0.22792497f, 0.02973201f, 0.18456554f, 
    0.19990037f, -0.04346727f, 0.03654815f, 0.07958891f, 0.02849301f, -0.04909556f, -0.01748624f, 0.14799181f, 
    0.11827417f, 0.04080529f, 0.02732619f, 0.05155821f, -0.16359782f, -0.05107907f, -0.12305900f, -0.16684547f, 
    0.02673075f, 0.07119606f, -0.08854595f, 0.10434156f, 0.07211635f, 0.13333984f, -0.07185794f, -0.06834618f, 
    -0.03470765f, 0.12158672f, 0.01018220f, -0.02992581f, -0.03240532f, 0.01313515f, -0.00240094f, -0.13946724f, 
    0.18653804f, -0.07731582f, 0.09932346f, 0.24193043f, 0.20917884f, 0.20233034f, 0.25942552f, 0.34401926f, 
    0.19845390f, -0.20460305f, 0.06092874f, 0.03249002f, 0.17360289f, -0.11338723f, 0.01536695f, -0.06309919f, 
    0.07294305f, 0.00178216f, 0.08868600f, -0.04577278f, 0.14172281f, 0.07090042f, 0.01870930f, -0.01412535f, 
    0.04031632f, 0.04242613f, -0.03310831f, 0.00917746f, 0.00597208f, 0.02037668f, -0.00930180f, -0.00468073f, 
    -0.03188980f, 0.04227487f, -0.04403955f, -0.03930368f, 0.01297521f, 0.02153032f, 0.02961452f, 0.04381705f, 
    -0.01894456f, 0.03335311f, -0.02118447f, 0.00622460f, -0.01276291f, 0.02518464f, 0.02453392f, -0.03788720f, 
    0.01668888f, -0.03415529f, -0.02793905f, 0.02552256f, -0.01877276f, -0.04803317f, 0.02580481f, -0.00982693f, 
    0.01565274f, -0.02249164f, 0.00558272f, -0.02966288f, -0.01786486f, 0.00226213f, -0.01315169f, 0.00413549f, 
    -0.01972123f, -0.00625561f, -0.02948270f, 0.00144385f, 0.01438960f, -0.00464442f, 0.01123640f, 0.00077247f, 
    -0.04756714f, 0.00504935f, -0.03471581f, -0.00610052f, 0.00221428f, -0.04629751f, -0.03145191f, -0.00072963f, 
    -0.00783341f, -0.02372244f, -0.03997998f, -0.00737802f, -0.01957408f, -0.00583742f, -0.02071392f, -0.03805097f, 
    0.02252919f, -0.03594126f, 0.02317268f, -0.03146076f, -0.02084191f, -0.00992393f, -0.01237864f, -0.00279725f, 
    0.01309668f, -0.03786083f, 0.00068307f, -0.01676532f, 0.00059169f, 0.01990142f, 0.02109596f, 0.01897158f, 
    -0.03397448f, -0.03876952f, -0.04357946f, -0.04633772f, 0.00588425f, -0.00678109f, 0.01383744f, 0.01207974f, 
    -0.02455640f, -0.01344026f, 0.01919154f, -0.03708092f, -0.01605457f, -0.02262629f, 0.02453662f, -0.04278534f, 
    0.01301854f, -0.01496756f, -0.01803145f, -0.03261878f, 0.02384569f, 0.01491949f, -0.03317073f, -0.04209217f, 
    0.00924841f, -0.02552093f, -0.03705950f, 0.01039920f, 0.02323544f, 0.02506767f, 0.01283203f, -0.04414894f, 
    0.01729757f, -0.04678560f, 0.02135159f, 0.01221256f, -0.04501204f, 0.01595508f, -0.00574710f, 0.00932561f, 
    -0.00933308f, -0.04207279f, -0.02427958f, -0.03173797f, -0.02411826f, -0.00534904f, 0.00593091f, -0.01808569f, 
    -0.01029426f, 0.00165791f, -0.02665706f, -0.02535496f, -0.03886627f, -0.01601255f, -0.03896701f, -0.00012184f, 
    -0.00453548f, -0.01248008f, -0.01779680f, -0.03051056f, 0.00076688f, 0.01578581f, 0.01086555f, -0.04523908f, 
    0.02386186f, -0.03028724f, 0.01426019f, -0.02438614f, -0.00455986f, 0.02666169f, 0.01399315f, -0.02449842f, 
    0.00463784f, -0.00737675f, 0.00602524f, 0.00377730f, 0.00901886f, 0.02183525f, -0.01761496f, -0.03456139f, 
    0.00842292f, 0.00822022f, 0.00824760f, -0.01041139f, -0.01437999f, -0.01482798f, -0.04879284f, 0.01660991f, 
    0.00268138f, -0.04403401f, -0.00605125f, -0.02253465f, -0.02904595f, -0.04316754f, 0.00735657f, 0.00499569f, 
    -0.03582790f, -0.01957020f, 0.01090057f, -0.00336835f, 0.00368141f, 0.01885207f, 0.02306898f, -0.05072479f, 
    0.01272176f, 0.02565658f, -0.03067819f, 0.02641817f, -0.05012366f, 0.01839529f, -0.02188257f, -0.01239051f, 
    0.00424707f, -0.04282930f, -0.01281465f, 0.02516939f, 0.00549628f, -0.03518642f, 0.02508111f, -0.02881390f, 
    0.02652454f, 0.03484328f, -0.00046293f, -0.00433611f, 0.00529447f, -0.01793884f, 0.03411600f, -0.00654716f, 
    0.01135418f, -0.02834496f, -0.03173335f, 0.01384359f, -0.01235574f, -0.03723934f, -0.02604066f, -0.00435229f, 
    0.03863843f, 0.03202506f, -0.00872552f, 0.02024488f, 0.00561644f, 0.00247291f, -0.01354092f, -0.04648543f, 
    -0.04304635f, -0.04110717f, -0.04467978f, 0.01479664f, -0.01480818f, -0.01082445f, -0.02219867f, 0.01741977f, 
    0.01108834f, 0.01029343f, 0.01602725f, 0.02066095f, -0.01593255f, -0.00632557f, -0.00304857f, -0.01834574f, 
    -0.03077472f, -0.03152623f, 0.00810633f, 0.01246232f, -0.03841310f, -0.02651886f, -0.00964497f, 0.01345793f, 
    -0.03978563f, -0.02595162f, 0.00678841f, -0.01960173f, 0.01989287f, -0.00777375f, 0.02913748f, -0.00904592f, 
    -0.01879128f, -0.01659417f, -0.03359286f, -0.00729687f, -0.02263529f, 0.01124531f, -0.01592237f, 0.01921133f, 
    -0.02942747f, 0.01613665f, 0.01752335f, -0.01581444f, 0.00697887f, 0.00527847f, 0.00929871f, -0.04004559f, 
    0.02231712f, -0.00494599f, 0.02225803f, -0.02166832f, 0.00666968f, -0.04742364f, 0.04138140f, -0.02726256f, 
    -0.00997597f, -0.02709534f, -0.00378652f, -0.01114806f, 0.02440651f, -0.01506144f, 0.02018887f, 0.02871799f, 
    0.01735296f, 0.00773868f, -0.01360879f, 0.01364338f, -0.01703654f, -0.01007575f, -0.03054200f, 0.00956615f, 
    0.02269547f, -0.01620886f, 0.00020122f, 0.02696213f, 0.02745222f, -0.02096217f, -0.03203949f, -0.00385046f, 
    -0.00760553f, -0.01615726f, -0.03075981f, -0.02352262f, -0.01975460f, -0.01742595f, 0.02076872f, -0.04774347f, 
    -0.00892785f, 0.02779049f, 0.02276413f, 0.00354937f, -0.03345634f, 0.02185273f, 0.01480415f, 0.02208590f, 
    0.03977285f, 0.01309565f, 0.00203695f, -0.01501345f, 0.00374113f, 0.03986014f, -0.01945543f, 0.01465081f, 
    0.03281054f, -0.01699959f, -0.01557295f, -0.02670697f, -0.01238089f, 0.01731390f, -0.04179210f, -0.00864227f, 
    -0.01794025f, -0.02533554f, 0.00506101f, -0.03673342f, 0.01239020f, -0.01567271f, -0.00786495f, -0.04519199f, 
    0.01389427f, -0.03602250f, 0.02781702f, 0.00146918f, -0.02644817f, -0.00474276f, -0.00772953f, -0.03565267f, 
    -0.00963697f, -0.01523451f, -0.01351314f, -0.04129476f, -0.01852913f, 0.01003601f, 0.00005714f, 0.01110738f, 
    0.01001878f, 0.01440198f, 0.01103432f, -0.02795605f, 0.01450124f, 0.00149598f, -0.01697177f, -0.04988155f, 
    -0.02202123f, -0.01188263f, 0.02077397f, -0.03830582f, 0.00359092f, 0.00428242f, -0.03560115f, -0.01082029f, 
    0.01687304f, 0.00879958f, 0.00634195f, -0.00029563f, -0.02622769f, -0.02932242f, -0.03918226f, 0.01487470f, 
    0.01964437f, -0.01457408f, -0.04027131f, -0.02062017f, -0.03635794f, -0.00276478f, -0.03608829f, -0.00160767f, 
    -0.01591141f, -0.04394381f, -0.02043746f, -0.01385190f, -0.00192351f, -0.02730137f, -0.00037127f, -0.00472712f, 
    0.03438281f, 0.04790311f, 0.04408679f, 0.01383778f, -0.00985527f, -0.01984730f, -0.01186362f, 0.02010520f, 
    0.03762033f, 0.04115267f, -0.01384692f, 0.00624471f, 0.02119699f, -0.03284850f, 0.00367163f, 0.01204788f, 
    -0.00533795f, -0.03443588f, 0.00599287f, -0.03635098f, 0.02885130f, 0.01354101f, -0.00102504f, 0.01562321f, 
    0.01538310f, 0.00919802f, 0.01813296f, 0.00518347f, -0.02835494f, -0.04992726f, -0.01227530f, -0.00920058f, 
    0.00902736f, 0.02756625f, 0.02587046f, 0.02584067f, 0.01166582f, 0.01390336f, 0.00038265f, -0.04286189f, 
    -0.03494272f, 0.02866284f, -0.00108228f, -0.00321366f, -0.00434845f, 0.02593163f, -0.02704383f, 0.00869768f, 
    -0.00436401f, 0.00204924f, 0.01611659f, 0.01618866f, 0.01173518f, 0.00729123f, -0.03345792f, -0.01230502f, 
    -0.00038456f, 0.01184150f, -0.01593613f, 0.00245428f, -0.00356422f, 0.00562192f, -0.04007089f, -0.03438341f, 
    0.02711261f, 0.01071719f, -0.03463806f, -0.00033342f, 0.01774947f, -0.03152655f, -0.00173380f, 0.01059672f, 
    0.01860545f, -0.01466876f, 0.01874730f, -0.01081566f, -0.02569676f, 0.02691546f, 0.01005413f, -0.04610153f, 
    -0.04081884f, 0.01672249f, 0.02398004f, 0.02694581f, -0.02710498f, -0.01654345f, -0.03504423f, -0.01457036f, 
    -0.00363067f, -0.02678013f, -0.00247404f, 0.02347060f, -0.00936307f, 0.01946079f, -0.00933225f, 0.00009570f, 
    -0.00094010f, 0.00584720f, 0.02501615f, 0.01049302f, -0.03121910f, 0.01761513f, -0.03032383f, -0.01091329f, 
    -0.03217501f, -0.01757735f, 0.00304514f, -0.01565368f, -0.00373906f, -0.03507994f, -0.03631151f, 0.02943640f, 
    -0.04137869f, -0.00086384f, 0.00057761f, -0.02689780f, -0.02514851f, -0.02925212f, 0.01049614f, 0.02381171f, 
    0.02767706f, 0.03099938f, 0.00785094f, -0.00563487f, 0.02166563f, 0.01072715f, -0.03619913f, 0.00616773f, 
    0.02703373f, 0.01156839f, -0.05011754f, 0.01197589f, -0.01377516f, -0.04520723f, -0.01063502f, -0.01270936f, 
    -0.02266061f, -0.03595416f, 0.02154694f, 0.02202878f, -0.03037264f, 0.03570617f, -0.02565358f, 0.01360264f, 
    -0.02619057f, 0.04559902f, -0.02295887f, -0.01625075f, 0.01982938f, -0.01889974f, -0.03765767f, -0.00876041f, 
    -0.01972073f, 0.00514686f, 0.00793231f, 0.01927000f, -0.03338152f, -0.00857890f, 0.03672516f, 0.00483290f, 
    -0.00590285f, -0.00549662f, 0.01975232f, 0.00602950f, 0.02645805f, 0.00807195f, -0.00545340f, -0.04027750f, 
    0.00172642f, -0.01423800f, -0.04911789f, -0.03634272f, 0.01157359f, -0.01614563f, 0.01955869f, -0.03866929f, 
    -0.01639521f, -0.00574995f, 0.01199195f, -0.01002476f, 0.01734513f, 0.02280982f, -0.02213066f, 0.03827957f, 
    -0.03361483f, -0.02564616f, 0.01661983f, 0.00174912f, 0.00421605f, -0.03621181f, 0.02705864f, 0.02536766f, 
    -0.00321742f, 0.02018131f, -0.01841679f, -0.00374653f, 0.01986761f, 0.00741852f, -0.01190073f, -0.01155117f, 
    0.00881274f, -0.00895461f, -0.02078616f, -0.04301509f, -0.00803188f, 0.01417686f, 0.00548471f, 0.00495797f, 
    -0.03107764f, -0.01866924f, -0.00051837f, 0.01302804f, -0.01298940f, 0.01867806f, -0.01358755f, -0.02193540f, 
    -0.01753754f, -0.01477654f, -0.02775995f, 0.00839153f, -0.00206480f, -0.00805047f, -0.00199941f, -0.01726848f, 
    0.03774558f, -0.02988997f, 0.01694956f, -0.00639140f, -0.03868840f, 0.00719470f, 0.00696425f, -0.00965647f, 
    0.03331551f, 0.01186912f, -0.01931032f, -0.03796058f, 0.01671403f, 0.02507337f, 0.00053116f, 0.03239474f, 
    0.02673589f, -0.02742522f, -0.01710512f, 0.03390058f, -0.01842692f, -0.00629783f, -0.02938480f, 0.00430570f, 
    -0.03274390f, -0.01915039f, -0.03977228f, 0.02417358f, -0.03071210f, -0.01455167f, -0.00043767f, -0.02675873f, 
    0.00966271f, -0.02332665f, 0.00170572f, -0.03731576f, 0.03037135f, 0.02868710f, 0.00122045f, -0.04458809f, 
    0.00087611f, -0.01142526f, 0.01678863f, -0.01120386f, -0.01708637f, 0.02921918f, 0.00875631f, 0.01941067f, 
    0.03250607f, 0.01599383f, 0.02643324f, -0.02916347f, -0.03998149f, 0.00533045f, 0.00782537f, 0.00034056f, 
    0.00116600f, -0.02301270f, 0.02790489f, -0.04236792f, -0.02991852f, -0.04050139f, -0.01642997f, 0.03242218f, 
    0.02659642f, -0.04303591f, -0.02510857f, 0.03407386f, 0.00269511f, 0.01982099f, -0.00699444f, -0.03110693f, 
    -0.00461071f, -0.00719694f, -0.03659098f, -0.01925953f, -0.04017586f, 0.03139090f, 0.01570987f, 0.02813765f, 
    -0.03926636f, -0.00175423f, -0.00879818f, -0.02024979f, -0.00168850f, 0.01636872f, 0.00099575f, -0.02527558f, 
    0.02029509f, -0.03031193f, -0.02543717f, 0.00271811f, -0.00624566f, 0.03168167f, 0.01316692f, 0.01327031f, 
    -0.02425798f, -0.02863333f, -0.03649064f, 0.01601412f, -0.02073944f, 0.01039392f, -0.03387323f, -0.01801733f, 
    -0.03889804f, -0.03405720f, 0.02699558f, 0.00258640f, -0.03742823f, 0.01869020f, -0.03847740f, 0.00500929f, 
    0.00166407f, -0.02193983f, 0.03355863f, -0.01378946f, 0.00940407f, 0.00450037f, 0.01595066f, -0.00816980f, 
    0.01683897f, -0.03298481f, 0.00908089f, -0.02746099f, -0.04257407f, 0.00434889f, 0.00698434f, -0.00574577f, 
    -0.04053107f, 0.03171026f, -0.00382943f, 0.00654080f, -0.01190031f, 0.01524518f, -0.04010495f, 0.02262182f, 
    0.00471349f, 0.01788548f, -0.02439690f, -0.03023655f, -0.02365818f, -0.01054884f, -0.01213006f, -0.01587589f, 
    -0.01423029f, 0.02182743f, -0.00069167f, 0.01382476f, -0.01092394f, -0.02874846f, -0.00816939f, -0.03866420f, 
    -0.00670142f, 0.02405030f, 0.01160774f, -0.01498939f, -0.03077502f, -0.03816026f, 0.01857422f, -0.03664732f, 
    0.01843737f, 0.03306238f, -0.00994855f, 0.01688543f, 0.00254089f, 0.02952246f, -0.01500751f, -0.02597300f, 
    -0.01839330f, 0.02335174f, -0.01947182f, -0.03537251f, 0.00782664f, -0.01761787f, -0.01254614f, -0.03823001f, 
    -0.01894792f, 0.02477421f, 0.02381134f, 0.00741425f, -0.03629490f, 0.00338688f, -0.03486331f, 0.00600102f, 
    0.03261957f, -0.00136590f, -0.01474133f, 0.01676427f, 0.00311951f, -0.03515028f, -0.01002408f, -0.01157288f, 
    0.02919572f, -0.03320498f, -0.01128983f, -0.00568970f, -0.01738971f, -0.01079092f, -0.00970083f, -0.03121148f, 
    -0.03427024f, -0.02037107f, -0.02283080f, -0.02367705f, 0.03103467f, -0.02391965f, -0.01803282f, 0.02709321f, 
    0.00432622f, -0.02995403f, 0.00920123f, -0.02302066f, -0.03559675f, 0.02318350f, 0.02341540f, 0.00873800f, 
    0.02656904f, -0.02372109f, -0.01123847f, 0.01836813f, 0.00974451f, -0.03034508f, -0.03603087f, -0.01181947f, 
    -0.03092757f, -0.03137350f, -0.04362563f, -0.01966476f, 0.00581364f, -0.03153903f, -0.04382785f, -0.01942522f, 
    -0.03702258f, 0.00199489f, 0.00173784f, -0.03571790f, 0.02269263f, 0.02764631f, 0.01265847f, -0.04437887f, 
    -0.03457801f, -0.03722285f, -0.00355013f, 0.02496450f, -0.03690740f, 0.03901612f, -0.02027989f, 0.00088443f, 
    -0.00990219f, -0.02185902f, 0.00931104f, -0.00811018f, -0.03839383f, -0.01710791f, 0.00538005f, -0.00933369f, 
    -0.02050549f, -0.02262600f, -0.00335725f, -0.02259788f, -0.02962756f, 0.00865829f, 0.01078899f, -0.03987778f, 
    -0.01458740f, 0.01578970f, -0.00659163f, 0.03147084f, -0.03251649f, -0.00982762f, -0.04190838f, -0.00030327f, 
    0.00781568f, -0.03350701f, -0.00830081f, -0.02582414f, -0.03601853f, -0.00770125f, -0.00362780f, 0.01627552f, 
    -0.02592956f, -0.00041796f, 0.02513664f, -0.01102903f, -0.02632855f, 0.00049303f, -0.02986893f, 0.00062604f, 
    -0.02501306f, 0.02260233f, 0.02070523f, 0.02041232f, -0.02486211f, -0.02844938f, -0.03456607f, -0.03167375f, 
    -0.04329732f, -0.03746017f, -0.02249226f, -0.01400296f, -0.01283314f, 0.03604142f, 0.03150003f, 0.01524758f, 
    0.00185057f, -0.02225229f, -0.00478166f, -0.01597248f, -0.01592330f, -0.00986596f, 0.03693204f, -0.02223918f, 
    -0.03586227f, -0.03283550f, 0.01175316f, -0.02613308f, 0.02507125f, 0.03069458f, 0.00017276f, 0.00030940f, 
    -0.03277241f, -0.00006297f, -0.03221387f, -0.03058838f, -0.00687777f, -0.01739927f, -0.03344060f, -0.01638684f, 
    -0.00903508f, -0.02751198f, -0.00470618f, 0.03424646f, 0.00413383f, 0.01145782f, 0.01428221f, -0.02247164f, 
    -0.02909743f, -0.00301207f, -0.00227580f, -0.03327799f, -0.01098656f, 0.00986836f, 0.00620885f, 0.00217382f, 
    -0.03454375f, 0.02555499f, -0.00958541f, -0.02093785f, -0.00860093f, -0.02944477f, 0.01949886f, 0.02877924f, 
    -0.00955275f, 0.00597325f, -0.04061361f, 0.02077505f, 0.03208732f, -0.04207544f, 0.00899765f, -0.02058407f, 
    -0.03565051f, -0.01102848f, -0.01112907f, -0.02272162f, -0.01624564f, 0.02164999f, 0.02874271f, 0.01915758f, 
    -0.00571561f, -0.02090892f, 0.03180954f, -0.03991232f, -0.02609055f, 0.02060079f, 0.02896655f, -0.00414865f, 
    0.01291827f, -0.01055498f, 0.03089949f, -0.02846024f, 0.03180330f, 0.00840768f, -0.01611989f, -0.00971868f, 
    0.03745517f, 0.02139946f, 0.03419597f, -0.01505818f, 0.02050003f, -0.02527442f, -0.01917735f, 0.00530870f, 
    -0.03481558f, -0.03021798f, -0.02982309f, -0.03852835f, -0.00928708f, 0.01234135f, -0.00912436f, -0.02764328f, 
    0.02620983f, 0.00700396f, -0.02187787f, -0.03532892f, -0.02607069f, -0.04261484f, 0.00947800f, 0.01981090f, 
    0.01237670f, 0.01398341f, -0.00639247f, 0.02074586f, -0.02451847f, -0.03084826f, 0.02872783f, -0.02684325f, 
    -0.01460690f, 0.00584320f, -0.00783019f, 0.02795971f, 0.01543131f, -0.01515207f, 0.02060889f, -0.03151696f, 
    -0.03714844f, 0.03203078f, -0.00275448f, 0.01633600f, -0.01918517f, 0.00839876f, 0.01412752f, -0.03391350f, 
    0.02549475f, -0.02634785f, -0.04438120f, 0.02042267f, -0.04432285f, 0.02016549f, -0.02970261f, -0.01275705f, 
    -0.01430006f, -0.00708372f, -0.01639998f, -0.00266202f, 0.00532902f, 0.01558245f, 0.01855170f, 0.02515185f, 
    -0.01126724f, 0.01197267f, -0.02812685f, -0.03952199f, -0.00471842f, -0.04275225f, 0.00762007f, -0.04409518f, 
    -0.03407174f, 0.01961148f, 0.02164541f, -0.00795125f, 0.02004074f, -0.00101303f, -0.02939560f, -0.02340992f, 
    0.02808273f, -0.03963479f, 0.00844080f, 0.01737219f, -0.01884666f, -0.02219243f, -0.01532015f, 0.02083987f, 
    -0.00625571f, 0.03359528f, 0.02138082f, 0.01867755f, 0.02389846f, 0.01238257f, 0.00582078f, 0.02204782f, 
    -0.03792720f, -0.00137269f, 0.03203481f, -0.04455886f, 0.01179261f, -0.02602790f, -0.01350741f, -0.03632823f, 
    -0.04013061f, 0.02217979f, 0.02959095f, 0.03647581f, 0.02111853f, 0.00378925f, -0.02429480f, 0.01765316f, 
    -0.04068376f, 0.00851267f, -0.01122302f, -0.02708840f, 0.02583377f, -0.00201407f, 0.01828829f, -0.02576610f, 
    0.00943131f, 0.00946554f, -0.01101245f, 0.02740940f, -0.04347498f, -0.02291184f, -0.02086747f, -0.01589279f, 
    0.01416423f, -0.03571793f, 0.00001686f, -0.03021589f, -0.02362576f, 0.00769639f, 0.00624302f, -0.00523790f, 
    -0.03110438f, 0.03161333f, 0.00625823f, 0.01261025f, -0.03826252f, 0.02023473f, -0.01110763f, -0.04305571f, 
    -0.03277095f, 0.02005544f, 0.02946660f, 0.00504885f, 0.03047706f, -0.01905983f, 0.01079234f, -0.04105827f, 
    0.00727504f, -0.02905303f, 0.00000404f, -0.00935524f, -0.00684725f, -0.01299201f, -0.00664965f, 0.02573715f, 
    0.01054891f, -0.03568587f, -0.03246878f, 0.00670763f, -0.00456286f, -0.03932293f, 0.03136744f, -0.03274743f, 
    -0.01482321f, 0.00707668f, -0.04057462f, 0.03404026f, -0.01237248f, 0.02860685f, -0.02583654f, 0.00890679f, 
    0.02309962f, -0.01692525f, 0.01145968f, -0.02733438f, -0.03550134f, -0.01267609f, -0.03124146f, 0.00362309f, 
    -0.02063452f, -0.03479935f, 0.02443755f, 0.01129631f, -0.01175000f, 0.02719431f, -0.00190872f, 0.01422575f, 
    -0.02392019f, 0.01616203f, -0.02237979f, 0.02186286f, -0.01874686f, -0.00558257f, -0.02682809f, 0.03136322f, 
    -0.02183343f, 0.01094966f, 0.02312119f, -0.03354732f, -0.03625479f, 0.01276733f, -0.01935162f, -0.00321204f, 
    0.03039290f, -0.01000288f, -0.01002883f, -0.03085699f, -0.02560197f, -0.00910564f, 0.00028341f, 0.01280644f, 
    -0.00340411f, -0.03617115f, 0.01173673f, -0.00467875f, -0.01384777f, -0.02520016f, -0.00181646f, -0.03613152f, 
    -0.03264284f, 0.01550562f, -0.01805614f, -0.03031265f, 0.01449263f, -0.03115824f, 0.00483004f, 0.00507743f, 
    -0.03085262f, -0.02364319f, -0.01141378f, 0.03185122f, 0.03402038f, 0.00397441f, -0.03599090f, -0.01969439f, 
    0.00032677f, 0.00072059f, -0.02431038f, 0.01698189f, -0.00937652f, -0.02507135f, -0.03820978f, -0.03456319f, 
    -0.00701458f, 0.02079344f, 0.00563086f, 0.02717907f, 0.03598404f, -0.03820275f, 0.03116070f, 0.02148820f, 
    -0.00631839f, 0.03197109f, -0.02104716f, 0.01492737f, 0.02803073f, -0.00759127f, 0.01162196f, -0.01840603f, 
    -0.00727771f, -0.03693099f, -0.02003435f, 0.02369915f, -0.02220607f, 0.03065029f, -0.02000359f, 0.00581349f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09498846f, 0.03067186f, -0.03873753f, -0.07828090f, 0.14535594f, 0.10953953f, 0.13177268f, 0.09427037f, 
    0.03045048f, 0.10568125f, 0.01012974f, 0.10751210f, -0.00391768f, 0.17911780f, -0.02928142f, -0.03046650f, 
    0.10332198f, -0.00273356f, 0.01084967f, 0.01987161f, -0.00994494f, 0.03854410f, 0.15001811f, -0.02132546f, 
    0.03179094f, 0.02741807f, 0.02226029f, -0.00054729f, 0.03320194f, -0.02682909f, -0.03069520f, -0.02214906f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.25606793f, 0.20524432f, -0.00609406f, 0.10832548f, -0.19022712f, 0.41550124f, -0.26011345f, 0.01290908f, 
    -0.09229102f, -0.40547046f, 0.07550050f, -0.34034762f, -0.74202961f, -0.40550798f, 0.23470998f, 0.07343335f, 
    -0.45065150f, -0.06670585f, 0.06574756f, 0.17799397f, -0.11827542f, 0.17377907f, -0.09598152f, 0.32428816f, 
    -0.39748925f, -0.10325513f, 0.16075292f, -0.07864944f, -0.15764336f, 0.18490712f, 0.14068574f, -0.02391817f, 
    0.33144781f, -0.43501541f, 0.06454029f, -0.19082572f, 0.14067800f, -0.05270538f, 0.12151839f, 0.02584091f, 
    -0.02643905f, 0.33843461f, -0.00251303f, 0.25943214f, -0.01836005f, 0.27136087f, 0.16746305f, -0.14887211f, 
    0.04130053f, -0.47061169f, -0.10701570f, 0.15935823f, -0.36575574f, 0.25469071f, 0.07799326f, 0.23075876f, 
    -0.25983718f, 0.07380167f, -0.50698417f, -0.16154061f, -0.16608796f, 0.30117676f, -0.13972302f, -0.13956136f, 
    0.22554353f, 0.20175646f, -0.04404096f, -0.02092716f, -0.41572669f, -0.13749795f, 0.01681235f, -0.48711219f, 
    -0.09447171f, -0.34813651f, 0.06225061f, 0.19711967f, 0.33270243f, 0.06238444f, -0.28206408f, 0.13799787f, 
    -0.06919841f, 0.23949936f, 0.02944124f, 0.14467283f, -0.15288158f, 0.29534546f, 0.15410447f, -0.44197741f, 
    -0.09114962f, -0.22727779f, 0.21652937f, 0.11037920f, -0.06233935f, 0.14553246f, -0.04181907f, 0.01583979f, 
    -0.19572704f, 0.09141271f, 0.18278879f, 0.16851662f, -0.44949815f, -0.12456981f, -0.65856200f, -0.13388453f, 
    0.07447938f, -0.02940242f, -0.08953385f, -0.38947940f, 0.39765227f, -0.21791494f, -0.05586925f, -0.10720219f, 
    -0.22672220f, 0.26198858f, -0.11019808f, -0.10477506f, -0.27376530f, -0.24186887f, -0.54998982f, 0.23260371f, 
    0.29503909f, 0.17892580f, -0.07750594f, -0.03644261f, -0.13859084f, 0.14224121f, 0.06804726f, -0.12084404f, 
    -0.61937869f, -0.00286031f, -0.01209532f, 0.24566001f, 0.04976014f, -0.29753461f, 0.17803788f, -0.60770148f, 
    -0.02047539f, 0.05357216f, 0.15400179f, -0.09883790f, -0.14789696f, 0.16490781f, -0.01140120f, -0.02664417f, 
    -0.06956150f, 0.05149005f, -0.10702622f, -0.05479624f, 0.26034918f, -0.22562194f, 0.07869143f, -0.05964924f, 
    -0.33484843f, 0.26216179f, 0.24404110f, 0.08256282f, -0.03683513f, 0.23869419f, 0.04273355f, -0.09020325f, 
    -0.12607545f, 0.37401500f, -0.14362000f, 0.29472765f, 0.48365995f, 0.07784657f, 0.30759507f, -0.19419459f, 
    -0.14848556f, -0.24024707f, -0.14448997f, 0.14739254f, -0.41259539f, -0.34753576f, 0.14791188f, 0.06572923f, 
    0.07837242f, -0.17800140f, 0.00773163f, 0.03754399f, -0.05956517f, -0.40031460f, 0.06307086f, 0.03807959f, 
    -0.06698738f, 0.05684094f, -0.61568409f, 0.08260632f, -0.07406870f, -0.40257487f, 0.14946018f, 0.05926650f, 
    -0.17723475f, 0.39103439f, 0.16708033f, -0.31292951f, -0.58377683f, -0.59093547f, 0.30841273f, 0.34208363f, 
    -0.02303581f, 0.13455820f, -0.08056799f, -0.43971628f, 0.19077344f, -0.19237787f, -0.13845325f, -0.16381398f, 
    -0.06152290f, -0.31322551f, -0.00496441f, 0.11865488f, -0.14066991f, 0.09301528f, 0.26520157f, -0.21163610f, 
    0.07891456f, -0.33021361f, 0.35091844f, 0.07588616f, -0.04151093f, -0.60236061f, -0.16583957f, -0.13856937f, 
    0.05825007f, -0.71175849f, 0.11581533f, 0.11756923f, -0.30177894f, -0.08115476f, 0.20040193f, 0.14665718f, 
    0.03876499f, 0.08477885f, -0.02722020f, -0.01986513f, -0.03412953f, -0.02653001f, 0.31124693f, -0.13711637f, 
    0.05922305f, 0.62584400f, 0.02923961f, -0.09111929f, -0.04504383f, -0.31114116f, -0.15021333f, -0.47723654f, 
    0.06924710f, -0.39623451f, -0.59498268f, 0.01237787f, -0.17005867f, -0.32699874f, -0.00636704f, -0.14196150f, 
    0.19332558f, -0.63404632f, -0.05774216f, 0.29797995f, -0.49015984f, 0.43931878f, 0.10635383f, 0.23558483f, 
    0.04460928f, -0.23669986f, 0.02134722f, 0.27671626f, 0.07259835f, 0.00285145f, -0.42920965f, 0.07292785f, 
    0.00944400f, -0.32410771f, 0.09124917f, 0.02613643f, -0.15761060f, -0.16039720f, -0.20030040f, 0.06653008f, 
    0.28534353f, -0.52442878f, -0.35643828f, -0.14984520f, 0.09865650f, -0.57111949f, -0.07652695f, -0.15202719f, 
    -0.37548125f, -0.06969336f, 0.06676430f, -0.49889022f, 0.29678783f, -0.00301507f, 0.28839469f, 0.31057969f, 
    0.12851018f, 0.09597408f, -0.12917750f, 0.22226736f, -0.39025015f, 0.14334913f, -0.36764592f, -0.08924779f, 
    -0.45455125f, 0.26420024f, -0.14039573f, -0.12115090f, -0.13392770f, -0.20495312f, 0.43230587f, -0.32381386f, 
    0.03310369f, 0.11545224f, 0.01879168f, 0.02669445f, -0.13333812f, 0.14652909f, 0.15098345f, -0.11160710f, 
    0.18650813f, -0.48468190f, 0.11151959f, -0.22003171f, -0.31416017f, -0.00871635f, 0.30659574f, -0.18057881f, 
    0.07540483f, -0.27274981f, 0.14465047f, -0.31650761f, -0.31873715f, -0.35205221f, -0.61684746f, -0.08435770f, 
    0.38362214f, 0.05554644f, -0.16804911f, -0.14734592f, 0.21285625f, 0.32586250f, -0.66269255f, 0.13667178f, 
    0.09045319f, 0.35132951f, -0.27935037f, -0.14397310f, -0.00975985f, -0.08232322f, 0.04628467f, 0.14221641f, 
    0.01220099f, -0.39603058f, -0.15009169f, -0.31485537f, 0.21303837f, -0.16823724f, -0.25448647f, -0.26701897f, 
    0.12517501f, 0.37636542f, -0.12902524f, -0.28774440f, 0.33431709f, -0.34375373f, -0.35023165f, 0.03469764f, 
    0.29737845f, -0.48725697f, 0.14399333f, 0.01568767f, 0.04304060f, -0.17677431f, 0.05356289f, 0.21197817f, 
    0.09587171f, -0.56042206f, 0.40449116f, 0.15369745f, 0.16902956f, 0.00927996f, 0.07326972f, -0.03263829f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.23913491f, -0.06123714f, 0.15987283f, -0.12827264f, -0.15866354f, 0.20541169f, 0.08196811f, -0.17266546f, 
    0.00489290f, 0.01602363f, 0.11337002f, 0.09886250f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
