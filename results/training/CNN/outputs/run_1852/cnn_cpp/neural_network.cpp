#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.30428085f, 0.29792753f, 0.19345152f, 0.05694643f, 0.43437484f, 0.11807339f, 0.05239852f, -0.35916924f, 
    -0.24874619f, -0.33108380f, -0.28313366f, 0.21669030f, 0.21357732f, 0.30434015f, -0.73466295f, 0.04819264f, 
    0.40626231f, 0.10003273f, -0.36755487f, 0.44600621f, 0.09844098f, 0.34732312f, 0.50971138f, 0.44418287f, 
    0.17374940f, -0.26477218f, -0.05461457f, 0.50718457f, 0.87259644f, -0.62272817f, -0.32851073f, 0.14723437f, 
    -0.16287522f, -0.08664134f, 0.05631354f, 0.06707665f, -0.11601704f, -0.09430429f, 0.07536957f, -0.23529179f, 
    -0.59685308f, -0.68884069f, 0.06378011f, 0.18339452f, 0.28285369f, -0.49982819f, -0.38615596f, -0.15124950f, 
    0.35160431f, -0.66600317f, -0.06516993f, -0.17128336f, -0.15150201f, -0.22637437f, -0.24724174f, 0.26389846f, 
    -0.00608655f, 0.25763842f, 0.40375257f, -0.72776860f, -0.21742752f, -0.08424824f, -0.13163099f, 0.07520563f, 
    -0.27254224f, 0.19239080f, 0.26531833f, -0.09589358f, 0.16533107f, 0.20210505f, 0.21201372f, 0.35810593f, 
    -0.53495175f, 0.79865825f, -0.55935365f, 0.39686713f, -0.13282461f, 0.26346067f, 0.04179980f, 0.23359640f, 
    0.10580628f, 0.40510738f, 0.31520858f, 0.00558214f, -0.29349080f, -0.04986607f, -0.08320217f, 0.26700550f, 
    0.34890890f, 0.35068026f, -0.31164122f, -0.33266783f, 0.79443586f, 0.06126874f, -0.04657324f, 0.08924052f, 
    -0.31052920f, -0.01865593f, -0.09304930f, -0.48493484f, -0.59759802f, -0.23453368f, 0.15017784f, 0.34452799f, 
    0.08082469f, 0.09805785f, -0.00906295f, -0.23099558f, 0.43165565f, 0.47549954f, 0.22915134f, 0.08090562f, 
    -0.21166527f, -0.14756061f, -0.03017126f, -0.43522727f, 0.23549289f, 0.59639323f, -0.52538735f, -0.54980528f, 
    -0.22533935f, -0.17037980f, -0.23613694f, -0.16017295f, 0.07598504f, 0.27070287f, 0.12011781f, -0.11834615f, 
    -0.59078872f, -0.27325800f, 0.59105176f, 0.03557963f, -0.31173435f, -0.25338185f, -0.31297219f, -0.10246930f, 
    0.02157465f, -0.12209542f, -0.26123163f, -0.33724093f, 0.47747660f, -0.30633318f, 0.29968342f, 0.41450852f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.14883837f, -0.16946723f, 0.04233212f, 0.09526101f, -0.04358740f, 0.07452905f, -0.17261998f, 0.12969156f, 
    -0.13501799f, 0.24069129f, -0.22934613f, 0.29717100f, 0.06180908f, -0.04917011f, 0.02729397f, -0.00704856f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.03936494f, 0.06888396f, -0.11189091f, -0.10383148f, 0.18871936f, 0.08627417f, 0.05206010f, -0.17183527f, 
    0.06687860f, 0.03452015f, 0.12083691f, 0.04723036f, -0.05494922f, -0.09883551f, 0.08284879f, 0.22670306f, 
    0.04308449f, 0.20927513f, 0.20940062f, 0.17695771f, 0.15903592f, 0.07215259f, -0.05802078f, -0.04033940f, 
    -0.02439118f, -0.17504662f, -0.06032601f, 0.06491057f, 0.05323812f, -0.15063530f, -0.10025498f, -0.05415859f, 
    -0.02732177f, 0.14801268f, -0.03026064f, -0.19126385f, 0.06518614f, 0.30324998f, -0.00733125f, 0.12819700f, 
    0.05225175f, -0.04148810f, -0.01215098f, 0.03955302f, -0.08158968f, -0.01774663f, 0.25244820f, -0.13712534f, 
    -0.09133097f, 0.03155474f, -0.01441322f, 0.27802509f, -0.01314482f, -0.07599358f, -0.19019368f, 0.29178128f, 
    0.01953369f, 0.12136622f, -0.03093377f, -0.07855462f, -0.14164390f, 0.03931195f, 0.02818484f, -0.02986972f, 
    -0.01718304f, -0.18293251f, 0.01734450f, -0.06413350f, -0.02942510f, 0.13255361f, 0.10845548f, 0.14805295f, 
    -0.03639198f, 0.13918908f, -0.13319224f, 0.17770565f, 0.14951985f, 0.01935278f, -0.00059894f, -0.06595309f, 
    -0.01365349f, 0.00130433f, 0.02568813f, 0.05496828f, 0.07166808f, -0.15595447f, 0.10097361f, 0.07769372f, 
    -0.09614317f, 0.14163823f, 0.06776638f, -0.24298009f, 0.03315594f, -0.02663184f, 0.01852547f, -0.01014545f, 
    0.08136721f, -0.07133903f, -0.16400658f, -0.11964703f, -0.26481751f, -0.24261515f, 0.08284977f, -0.10492718f, 
    0.00094577f, 0.01619015f, -0.06524214f, 0.05348282f, 0.02358011f, 0.20144415f, 0.06626817f, -0.20583002f, 
    -0.01226077f, 0.05535221f, 0.15468901f, -0.12250632f, -0.16879147f, 0.03066795f, 0.11339298f, -0.33014894f, 
    -0.05672317f, 0.19085461f, 0.05957063f, -0.01010684f, 0.21377081f, -0.12599319f, -0.21829061f, -0.17351265f, 
    -0.19612242f, -0.07987463f, -0.03000195f, 0.13765319f, -0.10758683f, -0.07079588f, 0.06451010f, 0.01746325f, 
    -0.21381877f, -0.04852922f, -0.18674077f, 0.07338007f, 0.10739585f, 0.18113998f, 0.02004288f, 0.12199145f, 
    -0.02459698f, -0.06593186f, -0.02596043f, 0.03749771f, 0.02625494f, 0.00545876f, -0.04580496f, 0.04467349f, 
    0.01615045f, -0.06249972f, -0.06505187f, -0.03205264f, -0.07761770f, -0.01083987f, -0.00656068f, -0.08235817f, 
    -0.03597284f, -0.07292113f, -0.00189577f, 0.05958015f, -0.06917724f, 0.05308863f, -0.05738205f, 0.02758159f, 
    -0.06923576f, -0.05193428f, -0.02189549f, -0.03505712f, -0.06617308f, 0.03906203f, -0.02709246f, -0.01618470f, 
    -0.04609685f, -0.01263532f, -0.03134530f, -0.01220960f, 0.00472633f, 0.02253299f, -0.04854853f, -0.07717501f, 
    -0.02259275f, -0.03196859f, -0.01945558f, -0.04850914f, 0.00935932f, 0.06887110f, -0.06621280f, -0.03953940f, 
    0.03767587f, 0.01935287f, -0.03562121f, -0.05326008f, 0.00409636f, 0.01127633f, 0.00044772f, -0.03914420f, 
    -0.01878604f, 0.07122014f, -0.08059378f, -0.03658038f, -0.08224684f, -0.08716284f, 0.00205527f, -0.00945077f, 
    0.04971484f, 0.00088734f, -0.06377643f, -0.02240361f, -0.06392462f, -0.03212182f, -0.04391115f, 0.06333180f, 
    -0.05259796f, 0.04040179f, 0.05117237f, -0.05422904f, -0.08291933f, 0.02642400f, 0.03620779f, -0.03764094f, 
    -0.02985138f, -0.00049378f, 0.00412835f, -0.04219140f, -0.00011549f, -0.02516467f, -0.00587571f, -0.04662412f, 
    0.06199988f, -0.01179866f, -0.06385431f, -0.08347049f, -0.05143029f, -0.00893126f, -0.03302219f, -0.00713788f, 
    0.06851484f, 0.01935025f, 0.06277659f, 0.05505684f, -0.05505671f, 0.01485010f, 0.00933678f, 0.02723188f, 
    0.04686618f, -0.05490085f, 0.02320700f, -0.08495964f, 0.00457131f, 0.02598923f, 0.02361100f, -0.08436029f, 
    -0.01282472f, -0.05934327f, -0.07328609f, -0.02512747f, -0.02870608f, -0.01699239f, 0.00881461f, 0.02620842f, 
    -0.01800630f, -0.01688586f, 0.01386992f, -0.01227224f, 0.03767088f, 0.04430700f, 0.02732336f, 0.02509703f, 
    -0.04651112f, 0.02356322f, -0.08476333f, 0.04269951f, 0.07415025f, -0.07878341f, 0.00655477f, -0.07284210f, 
    -0.02375503f, -0.02788134f, 0.05392487f, 0.00796690f, 0.03584103f, -0.06746764f, 0.02809327f, -0.04219600f, 
    -0.08960866f, -0.28396019f, 0.15677135f, 0.01530113f, 0.06155476f, -0.10906057f, 0.04300240f, -0.08841080f, 
    0.08553892f, -0.35173857f, -0.12614240f, 0.10627615f, -0.04141475f, -0.18142390f, -0.01501027f, -0.01446110f, 
    -0.04268852f, 0.32032302f, -0.00367491f, 0.18089047f, 0.17495222f, -0.09110395f, -0.03112132f, -0.19397788f, 
    0.05721506f, -0.06505392f, -0.07679076f, 0.36206573f, -0.41313419f, -0.47157875f, -0.00803400f, -0.04735325f, 
    0.07710713f, 0.04463695f, -0.07558709f, -0.05007556f, -0.01297371f, 0.15376604f, 0.22303054f, -0.11947163f, 
    0.13268930f, 0.02401723f, 0.06690902f, -0.02049486f, 0.13328299f, 0.10334353f, -0.05604256f, 0.05238522f, 
    -0.12107823f, 0.09738233f, 0.05881197f, 0.12656562f, 0.00142844f, -0.07292918f, -0.61354446f, -0.45831367f, 
    0.26660126f, -0.02918573f, -0.03553029f, -0.02282416f, 0.12536067f, 0.11010130f, -0.21292314f, -0.10494696f, 
    -0.10960762f, -0.01664475f, 0.09092044f, 0.07183824f, 0.14742823f, -0.00041542f, 0.11230009f, 0.10700496f, 
    -0.47894388f, -0.04550746f, -0.37903127f, -0.07978005f, 0.02048087f, 0.08279551f, -0.05101449f, -0.03291257f, 
    -0.14333236f, 0.00114660f, -0.07047179f, -0.02256387f, 0.04848194f, 0.02093311f, -0.04005127f, 0.06086878f, 
    0.14881876f, -0.12605852f, -0.82106757f, -0.65058613f, -0.34545499f, -0.03410496f, -0.04832973f, 0.17206731f, 
    -0.02305201f, 0.00364726f, -0.04824605f, 0.15550046f, -0.04273439f, -0.06456666f, -0.05769293f, 0.05400481f, 
    -0.09820045f, 0.00721849f, 0.04820756f, 0.02573839f, 0.31799456f, -0.65249813f, -0.03871704f, -0.17501102f, 
    0.07641192f, -0.16110064f, -0.10736547f, 0.07587971f, 0.11635888f, 0.21470876f, -0.05118137f, -0.02205598f, 
    0.00317146f, -0.07996833f, 0.16602992f, -0.06160294f, -0.01577277f, 0.14836143f, -0.25640807f, -0.04383011f, 
    0.00521340f, 0.10152287f, -0.00330195f, -0.04290404f, 0.07386715f, 0.08589176f, 0.11300334f, -0.04287884f, 
    -0.00125113f, 0.19058360f, 0.01568243f, 0.04680679f, -0.04600827f, 0.03601692f, 0.02332393f, 0.10400217f, 
    -0.30319864f, 0.11961449f, 0.15072003f, 0.00957593f, 0.23030618f, -0.06692703f, 0.05849721f, -0.10150366f, 
    -0.03546096f, -0.00372666f, 0.03841199f, -0.36549005f, 0.17342271f, 0.09927111f, -0.02026701f, 0.03603050f, 
    0.25510600f, -0.22893535f, -0.05400874f, 0.16493399f, -0.03357744f, -0.08954579f, 0.10088599f, 0.08011132f, 
    0.13601169f, -0.19956768f, -0.06251309f, -0.16182218f, 0.24781244f, 0.32197046f, -0.01896925f, 0.04445493f, 
    0.10158782f, -0.00197451f, 0.20973384f, 0.05660613f, 0.39532608f, 0.21879514f, 0.03952835f, 0.04264347f, 
    0.00945371f, -0.02036814f, -0.11573220f, 0.14387369f, 0.05162646f, 0.26078755f, 0.13747306f, -0.00885433f, 
    -0.11321710f, -0.01936921f, -0.03202393f, -0.09021378f, 0.10105530f, -0.03568999f, 0.14057605f, 0.24886282f, 
    0.00281273f, -0.07952894f, -0.06397182f, -0.13707118f, 0.23495103f, 0.01647995f, 0.13006392f, -0.10251060f, 
    -0.02039722f, -0.05935529f, -0.01877341f, 0.05854882f, -0.28223017f, 0.16446222f, -0.01568220f, -0.02016792f, 
    -0.06669918f, -0.07119991f, -0.00048415f, -0.10894809f, 0.07000182f, -0.03136505f, -0.05837617f, 0.12043159f, 
    -0.09620296f, -0.28439793f, 0.05210098f, 0.07325338f, 0.06442317f, -0.03648739f, -0.16593818f, -0.05082117f, 
    0.10897722f, 0.05508679f, 0.22898573f, 0.15667893f, -0.20272899f, 0.08814981f, 0.07676473f, 0.10954301f, 
    0.11228821f, -0.13022165f, 0.04044250f, 0.01107907f, -0.13193358f, -0.23107390f, 0.00205520f, 0.13181013f, 
    0.16892499f, -0.03879930f, -0.06411456f, 0.07846852f, -0.31038970f, 0.02930764f, 0.10214365f, -0.04373585f, 
    0.04610904f, -0.18920590f, 0.07331463f, -0.03609888f, -0.21167982f, 0.07289899f, 0.29800054f, 0.25482783f, 
    0.02118848f, -0.08392305f, 0.05759269f, 0.05700880f, 0.11932280f, 0.04591947f, 0.05294187f, 0.09825839f, 
    0.03885441f, 0.05399475f, 0.06764858f, 0.13281666f, -0.19261940f, 0.22645698f, 0.08439045f, -0.01295219f, 
    0.01350272f, -0.09556948f, -0.01698083f, 0.11865359f, -0.11789346f, 0.07141576f, -0.10491819f, -0.06061576f, 
    0.09207421f, 0.22660717f, 0.04648663f, -0.12193293f, -0.16223016f, -0.16976330f, -0.06087895f, -0.02707007f, 
    -0.01499188f, -0.09326906f, -0.17392083f, 0.07364573f, -0.02455140f, 0.06903373f, -0.00580182f, 0.02823461f, 
    0.00556963f, 0.00033549f, -0.09512959f, -0.11283956f, -0.07136092f, -0.08774532f, 0.14389223f, -0.02492090f, 
    -0.06816509f, -0.13983540f, 0.02179900f, 0.26185241f, -0.08894954f, 0.09072141f, 0.12951984f, -0.00614767f, 
    -0.06904202f, -0.01436189f, 0.06459966f, -0.12173889f, -0.20067190f, -0.37453330f, -0.11585631f, -0.04955040f, 
    0.00319199f, -0.16885071f, 0.14336494f, 0.01156664f, 0.09946094f, 0.00006255f, -0.03375397f, 0.18378624f, 
    -0.15871204f, 0.00714079f, 0.02527906f, -0.02388436f, 0.03844762f, -0.03034164f, -0.50416887f, -0.24336278f, 
    -0.13593094f, -0.03488095f, -0.06839548f, -0.04165238f, 0.13180214f, -0.15177257f, 0.19317181f, 0.09938651f, 
    0.05537704f, -0.04550179f, -0.02418604f, 0.01461255f, 0.21564628f, 0.00131509f, 0.17261793f, 0.04839855f, 
    -0.41105646f, -0.26883149f, -0.31593016f, -0.02456852f, -0.01378028f, -0.01607258f, -0.10370138f, -0.01323612f, 
    -0.12603387f, 0.24802803f, 0.09125949f, 0.02215215f, 0.16044492f, 0.14826743f, 0.03834914f, 0.11090477f, 
    0.06454758f, 0.19701810f, 0.02233521f, -0.31234238f, -0.21812426f, -0.03593124f, 0.13608833f, 0.02483177f, 
    -0.05326402f, 0.04035238f, -0.04573148f, -0.22361076f, 0.02640620f, -0.04828620f, -0.07392628f, 0.11411890f, 
    0.02866876f, -0.02838247f, -0.00255273f, 0.02504764f, 0.27563044f, 0.20861211f, 0.21991062f, 0.03070833f, 
    0.05520459f, 0.02743949f, 0.13847528f, 0.10018250f, 0.03791600f, 0.16831027f, -0.00980990f, -0.49540028f, 
    0.06379095f, -0.05697558f, 0.01630183f, 0.04677824f, -0.00161183f, 0.07661001f, -0.12868743f, -0.01534350f, 
    -0.01278162f, -0.01756143f, 0.18308133f, 0.04045325f, -0.01729747f, -0.08540965f, -0.04347707f, 0.00703993f, 
    -0.18616563f, 0.24663122f, 0.19068056f, 0.22627489f, -0.03047512f, 0.20503891f, 0.10298944f, -0.05395517f, 
    -0.01219919f, 0.00496273f, 0.02296601f, -0.05033466f, -0.07414213f, -0.08040271f, -0.00224080f, 0.10603689f, 
    0.13706261f, -0.38562426f, -0.23684789f, -0.06019789f, -0.02062530f, 0.06576452f, -0.15926304f, -0.07711025f, 
    0.05394917f, -0.08665557f, 0.12585314f, 0.06574798f, 0.05586173f, -0.11723981f, -0.01657766f, -0.21956894f, 
    -0.03389318f, 0.05033423f, 0.13183798f, 0.32990414f, -0.07123975f, -0.31041029f, -0.00079063f, 0.12317641f, 
    -0.06481908f, 0.10273752f, 0.12267160f, 0.06387247f, 0.03817277f, 0.06465870f, 0.01255128f, -0.04500307f, 
    -0.18575996f, -0.24047379f, -0.02411922f, 0.01297099f, -0.15689582f, -0.19873752f, -0.09401816f, -0.01948303f, 
    0.03573442f, -0.11315476f, 0.12207801f, 0.11119109f, -0.01673811f, 0.16930516f, -0.37133548f, 0.00649039f, 
    -0.02265660f, -0.06875693f, -0.25395137f, -0.09062061f, 0.01354663f, -0.14279616f, 0.02139504f, 0.17200723f, 
    0.10579684f, -0.08959016f, -0.02528263f, -0.03556050f, -0.05678201f, 0.09657100f, 0.03510941f, 0.20971316f, 
    0.09655433f, -0.09958508f, -0.30867761f, -0.01274208f, -0.11836099f, -0.07975377f, 0.12330937f, -0.11872755f, 
    -0.00581577f, 0.11124226f, -0.11996012f, -0.28428265f, -0.10751474f, 0.07380051f, 0.05645123f, 0.05671963f, 
    0.05891848f, -0.07603758f, 0.21618576f, -0.18517517f, -0.21348548f, -0.08338541f, -0.01266270f, -0.02522887f, 
    0.04235714f, 0.10914098f, -0.02827055f, -0.22526129f, 0.30184007f, 0.56888324f, 0.13949977f, 0.06136124f, 
    0.10843896f, -0.07100071f, -0.03958082f, 0.11265742f, -0.11500052f, -0.11862227f, 0.08892428f, 0.08315210f, 
    0.22834669f, 0.01669544f, 0.01595567f, -0.03548522f, 0.05214800f, 0.07144238f, 0.07922658f, -0.20532881f, 
    0.03200506f, 0.06803905f, -0.08814911f, -0.05557777f, -0.00642231f, -0.07104792f, -0.11937521f, -0.12387326f, 
    -0.17163728f, -0.11393974f, 0.14819753f, -0.00685342f, -0.00841253f, 0.06837999f, 0.07599491f, 0.11586070f, 
    0.17454730f, -0.05294447f, -0.11527025f, -0.08324596f, 0.11819844f, 0.06342650f, -0.02010506f, 0.01729006f, 
    0.01305039f, -0.24825607f, 0.03213976f, 0.12635909f, -0.07965734f, 0.00046198f, -0.00985442f, 0.00318842f, 
    0.02453699f, 0.30611858f, -0.09207462f, 0.09375988f, -0.04035886f, -0.20433614f, 0.01972628f, -0.13365448f, 
    -0.02493201f, 0.22050606f, -0.24399455f, -0.25283000f, 0.06414406f, 0.07036337f, -0.27034596f, -0.12228885f, 
    0.04404299f, 0.08550829f, 0.05843473f, -0.43014410f, -0.46638581f, -0.08918747f, 0.05289135f, -0.05410174f, 
    0.05819916f, -0.02372588f, 0.07629506f, 0.04521701f, -0.09421425f, 0.17839248f, 0.21152386f, -0.18826580f, 
    -0.30746552f, -0.14844324f, 0.03155652f, 0.06397931f, 0.00285266f, 0.16048530f, 0.18828698f, 0.02302000f, 
    -0.12202511f, 0.14268555f, 0.03757005f, -0.05065891f, 0.03135210f, -0.01409372f, 0.08201829f, 0.02352399f, 
    -0.04148499f, -0.12652715f, -0.14496896f, -0.02498913f, 0.00797276f, 0.12417495f, -0.08829611f, 0.04387504f, 
    -0.13056004f, -0.05104205f, -0.01525914f, 0.29188910f, 0.06057227f, 0.06889899f, 0.03199677f, 0.13798450f, 
    -0.32122618f, -0.10056380f, -0.05971900f, -0.11054169f, -0.14373082f, 0.19653769f, 0.01049928f, -0.12184165f, 
    0.05585657f, 0.03017707f, -0.16613291f, -0.07015966f, -0.01611757f, 0.12488090f, 0.03270802f, 0.04691891f, 
    0.11979806f, 0.18723316f, -0.02244266f, -0.11195774f, 0.06023480f, -0.03592423f, 0.12434986f, 0.01640809f, 
    0.06295491f, 0.14835721f, -0.17250352f, 0.17754507f, 0.04320720f, -0.13299021f, 0.11445893f, 0.18309870f, 
    0.15455940f, 0.09431526f, -0.01731995f, 0.00094946f, -0.03308586f, 0.02910285f, -0.10560369f, 0.10714854f, 
    -0.14412129f, 0.14055336f, -0.04148716f, 0.09096356f, 0.03112074f, 0.24537003f, -0.00796443f, 0.11030012f, 
    -0.00924646f, -0.05021298f, 0.03224421f, 0.06907204f, -0.03115524f, -0.03912691f, 0.26196802f, 0.12134234f, 
    0.22014733f, -0.07077568f, 0.04892746f, 0.06377730f, -0.04153978f, 0.07603663f, -0.14858449f, -0.09830495f, 
    0.02203804f, 0.06230900f, 0.21143515f, 0.00012750f, 0.01118547f, 0.08792274f, -0.02055480f, -0.01274232f, 
    -0.02252697f, -0.05295482f, 0.03304400f, 0.07250363f, 0.03245718f, 0.06776516f, 0.10833427f, 0.05078802f, 
    0.16002712f, -0.00410809f, 0.01270565f, -0.02292922f, 0.10035570f, 0.15327232f, -0.01397399f, -0.10089703f, 
    0.07499824f, -0.05037974f, -0.16767451f, -0.09098238f, -0.07337350f, 0.15263671f, 0.10401296f, -0.01893853f, 
    -0.03615660f, 0.07729207f, 0.03424173f, -0.05910644f, 0.23393813f, 0.08620327f, 0.06793127f, 0.02970435f, 
    -0.06899697f, 0.11614719f, -0.03177749f, 0.07296067f, 0.16674063f, -0.04174992f, -0.04534014f, 0.17256455f, 
    0.06340984f, 0.15024631f, -0.16000658f, -0.00289522f, -0.29787865f, -0.07511150f, 0.05685079f, -0.10686684f, 
    0.08711460f, -0.07840572f, 0.14904802f, 0.16760425f, 0.10719360f, 0.20854758f, 0.26311344f, 0.03046374f, 
    -0.07921661f, 0.00623180f, 0.07009283f, 0.06269214f, 0.17494790f, 0.11903413f, 0.22306189f, -0.00893087f, 
    -0.05575079f, 0.03281146f, 0.13644420f, 0.17758831f, 0.02810368f, -0.10004397f, -0.08788654f, -0.18832970f, 
    0.10735605f, 0.04799554f, 0.05390237f, 0.03041014f, -0.03296804f, 0.02429242f, 0.13497950f, -0.02056199f, 
    0.01737335f, -0.01162371f, 0.14227939f, 0.07712006f, -0.04265587f, -0.05754582f, -0.11722668f, -0.15778841f, 
    -0.15273200f, -0.21908946f, 0.09785409f, 0.24043541f, 0.04748006f, 0.01667333f, -0.00251433f, 0.11001565f, 
    -0.06019064f, 0.09507816f, 0.17964397f, -0.07885774f, -0.12260430f, 0.04966825f, 0.09503746f, 0.04019104f, 
    0.10881404f, 0.18697608f, 0.03001346f, 0.06355087f, 0.00529080f, 0.12460750f, 0.09302229f, 0.07994951f, 
    -0.01961949f, 0.08222931f, 0.15978807f, 0.11076746f, -0.10706317f, -0.13303787f, 0.06947937f, 0.11128303f, 
    0.06453406f, 0.07548411f, -0.14074098f, -0.10319814f, -0.06840876f, -0.11830219f, 0.03967141f, -0.13325159f, 
    0.07948568f, -0.05365396f, -0.05793200f, 0.07475665f, 0.00724579f, 0.18905468f, 0.25672179f, 0.03351723f, 
    0.12967545f, -0.11924811f, 0.07530665f, 0.03566679f, -0.06465083f, 0.13465212f, -0.13188657f, -0.16651785f, 
    -0.17773038f, -0.22618024f, -0.08495968f, -0.03452007f, 0.07730035f, -0.03179422f, 0.03249447f, -0.08036759f, 
    -0.24173860f, 0.11335798f, 0.08259758f, 0.08319172f, 0.05155467f, -0.21020356f, -0.01120721f, -0.02797004f, 
    0.08438618f, 0.15073255f, -0.22184075f, -0.05081096f, 0.06358102f, 0.15439188f, 0.02755903f, 0.07335786f, 
    0.01217570f, -0.14292322f, -0.15051316f, -0.06955340f, -0.12477660f, 0.09027039f, 0.03940405f, 0.05334554f, 
    0.12262698f, 0.04056834f, -0.02592641f, 0.13895723f, -0.31124836f, -0.01169073f, -0.01470216f, -0.06131696f, 
    0.15880166f, 0.16243947f, 0.15614276f, 0.10178804f, -0.04455093f, -0.00599546f, -0.00069994f, 0.00631227f, 
    -0.00148445f, 0.04743607f, 0.06217213f, 0.01960837f, -0.00139482f, 0.00307000f, -0.02835065f, 0.02802258f, 
    0.21609867f, -0.03896565f, 0.02171433f, -0.02979003f, -0.02238631f, -0.08112106f, -0.22594082f, 0.01210019f, 
    -0.05369917f, -0.02307084f, 0.06607889f, -0.10120564f, -0.19929266f, 0.05909964f, 0.11623695f, 0.21288395f, 
    0.08521272f, 0.17719086f, 0.07597372f, -0.09037456f, -0.11941818f, 0.00913892f, 0.00996873f, 0.06540036f, 
    0.00320422f, -0.20292488f, -0.00452658f, -0.01885395f, -0.01872468f, -0.12353896f, 0.11018021f, -0.11383811f, 
    0.14959811f, 0.09764571f, 0.08490770f, 0.01784469f, 0.33060482f, 0.08903655f, 0.05216203f, -0.07856027f, 
    -0.10279777f, 0.02651915f, -0.16798161f, 0.06220004f, 0.16099590f, 0.03992449f, -0.01934118f, -0.03174708f, 
    -0.04335307f, -0.04857253f, 0.02590744f, -0.00924619f, -0.13350673f, -0.17529911f, -0.02412847f, 0.04595285f, 
    0.03040029f, 0.03852022f, -0.07455833f, -0.05813000f, 0.08020558f, 0.09347418f, 0.02732994f, 0.15872553f, 
    -0.06375232f, 0.17694981f, 0.03699440f, -0.03870326f, -0.06642260f, -0.01872845f, 0.14702731f, 0.22612172f, 
    -0.04553870f, -0.03449166f, 0.02209158f, -0.01181747f, -0.04551360f, -0.02431893f, 0.10806079f, 0.15493239f, 
    -0.13382682f, 0.23280837f, 0.00433268f, 0.21389723f, 0.01445052f, 0.22743757f, 0.13167453f, 0.05949267f, 
    -0.08697527f, -0.11735915f, 0.11587183f, -0.13558687f, -0.11130106f, 0.01504618f, -0.01701853f, 0.04807451f, 
    0.09077697f, -0.13585919f, 0.00757017f, -0.29992527f, 0.08935875f, 0.03003176f, -0.04711718f, -0.05826789f, 
    0.05548048f, -0.02607227f, -0.24658428f, 0.10111493f, -0.21124884f, 0.10228419f, 0.14953808f, -0.01232672f, 
    -0.10313938f, -0.09283981f, 0.04628709f, 0.35130927f, 0.18894587f, 0.36922076f, -0.00135795f, 0.12564914f, 
    -0.00215921f, -0.05007773f, 0.06283474f, -0.05535027f, -0.05395681f, -0.09092803f, -0.08600608f, 0.09795710f, 
    0.09115619f, -0.11914425f, 0.00621914f, 0.03925659f, 0.00824568f, 0.26244342f, 0.02935776f, -0.13100067f, 
    0.00854211f, -0.11065296f, 0.19733307f, 0.05906556f, -0.08696903f, 0.13792539f, -0.23056465f, 0.10091644f, 
    -0.09913499f, -0.12239133f, -0.07015800f, 0.03100617f, 0.02192258f, 0.02662802f, 0.14424330f, -0.14941935f, 
    -0.03834743f, 0.07200033f, 0.01997316f, 0.08183856f, 0.04359212f, -0.03793231f, 0.11971717f, -0.20699909f, 
    -0.30286926f, 0.08113894f, -0.00074502f, 0.02401933f, 0.04022309f, -0.03220861f, 0.05345573f, -0.15727931f, 
    -0.15786853f, 0.07286824f, 0.03222424f, 0.17816719f, -0.08718581f, 0.23545218f, 0.07493585f, -0.04658564f, 
    0.06757492f, -0.04344022f, -0.18898176f, 0.09186402f, -0.00162287f, -0.01919232f, 0.22455759f, 0.09727058f, 
    -0.06859205f, -0.06596952f, 0.07082896f, 0.07634915f, -0.07887680f, -0.32704878f, -0.03197808f, 0.05124322f, 
    0.04223106f, -0.03955438f, -0.03525280f, 0.09128901f, 0.51069796f, 0.28616112f, 0.35433367f, 0.10846079f, 
    -0.19513074f, -0.14948063f, 0.02593244f, -0.00566916f, 0.12139571f, -0.13628477f, -0.22953296f, 0.00743850f, 
    -0.05342040f, 0.03464088f, 0.08647343f, -0.07193596f, -0.06217098f, -0.15299603f, -0.03520111f, -0.37644467f, 
    -0.08774273f, -0.13773203f, -0.01297621f, 0.09401866f, 0.03720506f, -0.06358889f, 0.05151591f, 0.14564481f, 
    0.01049555f, 0.14087997f, -0.00717012f, 0.09742429f, -0.23261601f, 0.04958490f, 0.09237155f, -0.11115417f, 
    0.13178751f, -0.03745884f, 0.19811623f, 0.10254553f, -0.11141687f, -0.03877380f, 0.04326068f, 0.11267198f, 
    -0.16339928f, 0.30975950f, -0.17027397f, 0.28775254f, -0.09896624f, -0.00775123f, -0.05418569f, -0.06164929f, 
    -0.09743597f, -0.08436236f, -0.04842949f, -0.03115611f, -0.59175074f, -0.02686920f, -0.05157389f, -0.12897496f, 
    0.00112154f, -0.02330598f, 0.07592480f, 0.19002333f, 0.11005231f, -0.36896133f, 0.11765939f, 0.00837566f, 
    -0.01666319f, 0.00574122f, 0.07022226f, -0.00972767f, 0.18159665f, 0.20442641f, 0.21692885f, 0.02414063f, 
    0.11141876f, -0.09728715f, 0.15738523f, -0.01591344f, 0.05460024f, 0.11180862f, -0.14663915f, 0.29315129f, 
    -0.05666000f, 0.11741459f, 0.03881718f, 0.00777569f, -0.00765605f, -0.07329163f, -0.26967981f, -0.38076738f, 
    0.02710920f, -0.07044479f, -0.23066039f, 0.21354178f, 0.08651212f, -0.07193942f, 0.03653488f, 0.15997367f, 
    -0.01881904f, -0.17447780f, 0.04143760f, 0.08969123f, -0.07634525f, 0.01446778f, 0.02423857f, -0.19588754f, 
    0.09162673f, -0.03826590f, -0.62107295f, -0.10147378f, -0.02558618f, 0.15352546f, 0.16673142f, -0.01862601f, 
    -0.02294896f, -0.10422274f, -0.06365633f, -0.09072486f, -0.11064848f, -0.08551439f, -0.18879065f, -0.09849960f, 
    0.00413548f, 0.10594702f, 0.09941038f, -0.30910811f, 0.22669110f, 0.04159575f, -0.06887949f, 0.08063830f, 
    -0.03804107f, -0.08643239f, -0.11181511f, 0.05191407f, -0.18759844f, 0.06659643f, 0.04635972f, 0.02237201f, 
    0.06639782f, -0.03764242f, 0.05780153f, 0.04878877f, 0.32301334f, 0.38540179f, 0.17912312f, -0.02926499f, 
    0.01927700f, -0.04895866f, -0.11069622f, 0.00079223f, -0.01058724f, -0.03452715f, 0.20828223f, 0.29723987f, 
    0.04364985f, -0.03467845f, 0.09635630f, 0.03731386f, 0.02669425f, -0.09501336f, -0.33247396f, -0.01850754f, 
    -0.05827216f, -0.01653850f, -0.02927309f, -0.01733544f, 0.08409770f, -0.11307670f, 0.06445870f, -0.13065933f, 
    0.20158553f, 0.07396849f, 0.09321018f, -0.04836486f, 0.15409572f, -0.10428404f, -0.14402069f, -0.15450789f, 
    0.14820360f, 0.20719206f, 0.10481158f, -0.02165310f, -0.12891233f, -0.00589337f, -0.06078484f, 0.02367908f, 
    0.04672964f, 0.21544839f, -0.01851029f, 0.13021255f, -0.01066617f, 0.02943694f, -0.00668108f, 0.22729824f, 
    -0.11559369f, -0.03764488f, 0.07017361f, 0.29772186f, 0.11286126f, -0.32849792f, -0.16995390f, -0.10941300f, 
    0.03817495f, -0.07739824f, -0.04659128f, -0.10221444f, 0.08730601f, 0.01363558f, 0.03284467f, 0.00512432f, 
    0.18664068f, 0.14018907f, -0.07602645f, 0.00073992f, -0.14958431f, -0.13808787f, 0.36641479f, 0.01578624f, 
    -0.03090709f, -0.17011560f, -0.15083241f, -0.10154001f, 0.11413093f, 0.44289058f, -0.45554906f, 0.06656284f, 
    -0.03978186f, -0.02098450f, -0.22038536f, -0.12587690f, 0.09474409f, 0.12826490f, -0.19117519f, -0.06777062f, 
    0.02209559f, -0.10680394f, 0.06019020f, 0.01021167f, 0.04089528f, -0.18914139f, 0.04086674f, 0.05748367f, 
    -0.06833839f, 0.04289044f, -0.06453983f, -0.06830743f, -0.01664481f, 0.02379442f, -0.06748912f, -0.01294541f, 
    0.24383636f, 0.03126806f, -0.25446579f, -0.05557732f, -0.12555231f, 0.07445151f, 0.13376962f, -0.00700503f, 
    0.03121831f, -0.08747767f, 0.11171895f, -0.10488319f, 0.04197997f, 0.10777392f, -0.00718174f, -0.08988313f, 
    -0.04447521f, 0.09077030f, -0.07160699f, -0.12010776f, -0.09623676f, -0.01995539f, -0.03069036f, -0.05373786f, 
    0.12247446f, 0.33647928f, -0.04281937f, 0.46560320f, -0.14097244f, -0.72883755f, 0.05316091f, 0.04612210f, 
    0.10281695f, 0.09969656f, -0.00130272f, -0.01483223f, -0.04550228f, -0.03396724f, 0.03691673f, 0.05211664f, 
    0.12078083f, -0.00770667f, 0.11938655f, 0.02581371f, 0.12101500f, 0.03236110f, -0.42928302f, -0.33887047f, 
    0.00765555f, -0.05371319f, 0.10166739f, 0.06596997f, -0.11925624f, -0.01771283f, -0.44300991f, -0.16867058f, 
    -0.07833344f, 0.13779612f, 0.01797516f, 0.06185207f, -0.16955605f, 0.17470390f, -0.07193645f, -0.29331106f, 
    -0.18808645f, -0.19742732f, 0.10659148f, 0.09336109f, 0.10217290f, 0.09278470f, -0.18870735f, 0.06345510f, 
    -0.26060623f, -0.16798007f, -0.27436429f, 0.04960756f, -0.09247494f, 0.07134810f, -0.00166045f, 0.03889186f, 
    -0.09635998f, 0.13406563f, 0.11974195f, -0.04268410f, 0.13014969f, 0.07109812f, -0.09435292f, 0.15706350f, 
    0.07028139f, 0.13006805f, -0.09024281f, -0.04350908f, -0.24325293f, 0.09677824f, 0.05242822f, -0.04541156f, 
    -0.11561039f, 0.10065674f, -0.13602835f, 0.05763143f, 0.20102254f, 0.09593949f, -0.02814156f, 0.00734573f, 
    0.14027104f, -0.03708553f, 0.19301499f, -0.06146467f, -0.18900430f, 0.00487946f, -0.22962587f, 0.08510363f, 
    0.06831577f, -0.00706580f, 0.08696463f, -0.04974139f, 0.13045843f, -0.07065094f, 0.21138403f, 0.09308062f, 
    0.18726018f, -0.06521560f, 0.00425929f, -0.12942277f, -0.08646654f, -0.04768953f, -0.12826183f, 0.12650318f, 
    -0.01792941f, 0.07097062f, -0.02116689f, -0.16770217f, 0.09877904f, 0.12389369f, -0.11424984f, 0.01682649f, 
    0.17705248f, -0.00140485f, -0.00843642f, 0.08000743f, 0.02920433f, 0.09762661f, -0.01533332f, 0.17023687f, 
    -0.04003332f, 0.28562602f, 0.18488044f, 0.16597922f, 0.18796176f, 0.17768447f, 0.02687113f, 0.13325156f, 
    0.14701916f, 0.02121313f, 0.10424767f, 0.04538202f, -0.08852024f, -0.05263389f, -0.01378709f, 0.08045363f, 
    0.01885510f, 0.20657392f, -0.00413313f, 0.25404793f, -0.06056761f, -0.01532741f, 0.09205064f, 0.14270772f, 
    -0.19443634f, -0.03101114f, -0.03773170f, -0.05141081f, -0.17426939f, 0.05098419f, 0.01188551f, 0.02332342f, 
    0.01030975f, -0.14531665f, -0.21900713f, -0.05798225f, -0.11241716f, -0.04097959f, 0.06728087f, -0.07092234f, 
    0.09078018f, -0.00447194f, -0.12844662f, 0.02762743f, 0.09397963f, -0.07956097f, -0.01520190f, 0.35480818f, 
    -0.01026252f, -0.05150381f, 0.01636888f, 0.15648058f, 0.05051907f, 0.04558483f, 0.08195848f, 0.08229855f, 
    -0.01400637f, -0.07490056f, -0.10920655f, -0.07004648f, -0.26175454f, 0.00959986f, -0.05850646f, 0.20174146f, 
    -0.07186031f, 0.12196114f, -0.04135306f, -0.09815617f, -0.04466922f, 0.28802091f, 0.13103625f, 0.10301139f, 
    -0.16288395f, -0.06126958f, 0.04051214f, 0.06293984f, -0.02481885f, 0.04493564f, -0.06985455f, -0.11723551f, 
    0.13041691f, 0.14557235f, 0.33552334f, -0.18365394f, -0.16432777f, -0.02823031f, -0.07837933f, 0.07649455f, 
    0.09507715f, 0.09520303f, 0.12941915f, 0.01161931f, 0.15610413f, -0.05726029f, -0.02065827f, -0.11147465f, 
    0.07975703f, -0.08348648f, -0.01838792f, -0.51274401f, -0.09521711f, -0.15392667f, 0.04290881f, -0.11503492f, 
    0.09314144f, -0.00366463f, 0.10660540f, -0.08477345f, 0.25918826f, 0.06478525f, -0.05883551f, 0.05926858f, 
    0.07457554f, -0.06454914f, 0.07124305f, 0.02108767f, 0.05419131f, 0.23031160f, 0.28487894f, -0.16295540f, 
    -0.03147068f, -0.17460734f, 0.12304447f, 0.08433095f, 0.15785441f, -0.12274291f, -0.09177841f, -0.21784325f, 
    -0.30666837f, -0.15688612f, -0.07712969f, 0.03008593f, 0.04671850f, -0.18080966f, -0.03281502f, 0.15691768f, 
    -0.04801615f, -0.03294642f, -0.03300709f, -0.05304594f, -0.12473702f, 0.13633600f, 0.13019457f, 0.11589678f, 
    0.34553772f, -0.02176316f, -0.20512602f, -0.07734497f, -0.13382179f, -0.13073526f, -0.10672526f, 0.16311967f, 
    -0.18892393f, -0.08786011f, 0.04500211f, -0.02423658f, 0.14477895f, 0.11457464f, 0.03070957f, 0.21992280f, 
    0.22741784f, 0.13240123f, 0.21350625f, 0.01638498f, -0.19330005f, -0.04736370f, -0.05094566f, -0.12499236f, 
    0.04995618f, -0.03295882f, -0.18129247f, 0.28464171f, 0.00504473f, -0.10039025f, -0.07060887f, -0.00219560f, 
    0.09542069f, 0.03585311f, -0.03651507f, -0.00350803f, -0.42417404f, -0.11305483f, 0.16350338f, 0.12132858f, 
    -0.04867847f, 0.03420501f, -0.04680499f, -0.14530714f, 0.12298892f, 0.11379833f, 0.22110340f, -0.26499838f, 
    -0.01306874f, 0.14576006f, 0.14544155f, 0.01786944f, 0.08239133f, -0.10015611f, 0.15475777f, -0.18778862f, 
    -0.00072315f, -0.02135023f, 0.01376970f, 0.08380426f, -0.00404165f, 0.04021690f, -0.20847948f, -0.16494915f, 
    0.04956665f, 0.05466568f, 0.07511012f, 0.05579641f, -0.14158601f, -0.03480244f, -0.00220722f, -0.06994896f, 
    0.24900863f, -0.01886275f, 0.14058094f, 0.03391958f, -0.04037585f, -0.01941625f, -0.00358105f, 0.00187174f, 
    0.03895779f, 0.40179101f, -0.13451020f, -0.01043547f, -0.24003586f, -0.28305689f, 0.01603996f, 0.00147426f, 
    -0.00878006f, -0.11871091f, 0.17252578f, 0.18692173f, 0.32022896f, -0.20497853f, 0.05333221f, -0.04282274f, 
    -0.05034047f, 0.02050452f, -0.10793311f, -0.21068271f, 0.16601156f, -0.16167095f, 0.09650140f, -0.09362786f, 
    0.01286941f, 0.12179692f, -0.05482100f, -0.19208620f, 0.31480226f, 0.47646445f, 0.01773457f, 0.03135979f, 
    0.02050984f, 0.02676710f, -0.09827777f, -0.09391084f, 0.12708047f, -0.25157925f, -0.22599256f, -0.20782681f, 
    -0.01782725f, 0.16176403f, 0.00469770f, 0.04267282f, -0.10574539f, 0.08000040f, -0.14996135f, -0.43036234f, 
    -0.01849815f, -0.13910632f, 0.04386814f, -0.11201454f, 0.12640715f, -0.03414510f, -0.09074694f, 0.22962645f, 
    -0.01284569f, 0.10294671f, 0.07437384f, -0.01146851f, -0.04132002f, 0.06629211f, 0.07321600f, -0.14300890f, 
    -0.00844262f, 0.16524895f, 0.03890719f, -0.03319206f, -0.05248748f, -0.07100561f, -0.01050718f, 0.00026444f, 
    -0.12078818f, -0.18240656f, 0.10577476f, 0.25642258f, 0.16507372f, 0.03205366f, 0.07276779f, 0.03865306f, 
    -0.00325551f, 0.03907831f, -0.66382462f, 0.23579395f, 0.13248879f, -0.08412906f, -0.07653267f, 0.03040423f, 
    -0.09364772f, -0.05116691f, -0.02110270f, 0.07539234f, 0.00428484f, -0.01708923f, 0.08824148f, 0.03639034f, 
    -0.14580891f, -0.03213063f, -0.00514992f, -0.01223751f, 0.10128298f, -0.08872025f, -0.12310007f, 0.05236975f, 
    0.06246513f, 0.12622169f, 0.08546995f, 0.01274858f, 0.08252320f, -0.32669184f, -0.20806010f, 0.19913056f, 
    -0.14570497f, -0.08229551f, 0.07800259f, 0.06153159f, -0.08156053f, 0.04017597f, 0.28244454f, -0.19524063f, 
    -0.04784119f, -0.07959344f, -0.03342780f, -0.25261274f, 0.04535332f, -0.02611185f, -0.01364605f, -0.37149435f, 
    -0.01178377f, 0.05128888f, 0.19845706f, -0.21378802f, -0.04891884f, 0.01004633f, -0.15070209f, -0.06045438f, 
    0.10289256f, -0.22816716f, -0.28057346f, 0.07656562f, -0.10411280f, -0.07093767f, 0.10472336f, -0.04741504f, 
    0.05072458f, 0.23618215f, 0.06289111f, 0.22522320f, -0.05246485f, 0.04612360f, -0.04764839f, 0.11661876f, 
    0.06985563f, -0.07153557f, 0.20780571f, -0.02738956f, -0.09922209f, -0.17404842f, -0.12268687f, -0.19952632f, 
    0.02768189f, -0.01143654f, 0.09649337f, -0.15988724f, -0.27987069f, -0.78837168f, -0.02740021f, 0.03360746f, 
    -0.00840515f, -0.02593419f, 0.00948490f, -0.03326474f, 0.05921777f, 0.19711767f, -0.04859706f, -0.09887836f, 
    0.09651279f, -0.18591560f, -0.09869961f, -0.00838657f, 0.06461606f, 0.21208110f, 0.25469586f, 0.16551076f, 
    -0.05321873f, -0.00447561f, 0.07466456f, 0.02095275f, -0.11251466f, -0.05383288f, -0.09982757f, -0.09643835f, 
    -0.34866753f, -0.17009304f, 0.10818698f, -0.07279031f, 0.07460995f, -0.03624004f, 0.02925897f, 0.02807048f, 
    0.03564707f, -0.19247180f, -0.05158429f, 0.03000375f, 0.06255660f, 0.06528658f, -0.04034994f, -0.01662091f, 
    -0.30058810f, -0.02826460f, -0.35971156f, -0.01366777f, -0.08223134f, 0.13660569f, 0.04581743f, 0.17839472f, 
    0.05093108f, 0.19051823f, 0.04160068f, -0.14281413f, 0.04091685f, 0.07802774f, -0.09410977f, 0.00382185f, 
    -0.06523453f, -0.02474255f, 0.15530063f, -0.03212932f, -0.06224028f, 0.11016215f, -0.15647472f, -0.00283965f, 
    0.13740404f, 0.14173277f, -0.09441828f, 0.22362608f, -0.06730835f, -0.11266621f, -0.04062220f, 0.02920847f, 
    0.15479176f, 0.06945379f, -0.09363484f, 0.02667384f, 0.23444173f, -0.08847982f, 0.06456328f, -0.08080532f, 
    0.14322817f, 0.13748281f, -0.04658249f, -0.07050779f, -0.04770017f, 0.15794657f, 0.34877330f, -0.00533697f, 
    -0.09964441f, -0.00078823f, 0.05104921f, 0.02151365f, -0.10490894f, 0.02162074f, -0.02670623f, -0.04921373f, 
    0.11812793f, 0.03782406f, -0.05782899f, 0.18869624f, 0.06658679f, 0.07905406f, -0.00931000f, 0.07826438f, 
    0.09955634f, 0.13390106f, -0.11697676f, 0.12196281f, -0.04136029f, 0.14390624f, 0.03825561f, -0.13428463f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.02249878f, -0.05429869f, 0.14397548f, 0.03648909f, 0.28511012f, 0.24006891f, 0.12765895f, 0.01611811f, 
    -0.02053472f, 0.13050316f, 0.00376301f, 0.14915220f, 0.03205670f, 0.00828266f, -0.00714168f, -0.00101609f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20618841f, -0.06293823f, -0.14892367f, 0.11924389f, -0.02046004f, -0.10197670f, 0.38606831f, 0.13167804f, 
    0.07966375f, -0.34558463f, -0.28405014f, -0.26472643f, -0.20284611f, -0.15043254f, -0.69992238f, 0.31451151f, 
    0.02116487f, 0.09259531f, -0.05192217f, -0.27723414f, 0.28931957f, 0.00170004f, 0.19998404f, -0.09755343f, 
    -0.51100051f, -0.15981366f, 0.40359539f, 0.39220679f, -0.23455423f, 0.28996614f, -0.17392546f, 0.21185648f, 
    -0.35392880f, 0.04907209f, -0.24628760f, 0.29478127f, 0.16304594f, -0.33395913f, 0.10239351f, 0.05398396f, 
    0.21443644f, 0.26352593f, -0.42414007f, 0.07412077f, 0.20500590f, -0.33588508f, -0.28559273f, -0.17753282f, 
    -0.07563275f, -0.11591226f, 0.18818897f, 0.20911148f, -0.07154021f, 0.03247678f, 0.03032094f, -0.18336302f, 
    -0.17822275f, 0.01725340f, -0.22907975f, -0.19251573f, -0.13653213f, -0.15971702f, -0.17491347f, 0.03626800f, 
    -0.28179416f, 0.20536271f, 0.25770172f, -0.05363863f, 0.34994653f, 0.11927546f, 0.11856993f, 0.06598775f, 
    0.33974969f, -0.07663723f, -0.38131922f, -0.14938435f, 0.13128863f, -0.41793725f, -0.37781140f, 0.07223887f, 
    0.28994280f, 0.06900918f, 0.44507423f, 0.29254737f, -0.30417702f, 0.15893629f, 0.38566393f, -0.22591697f, 
    0.10988396f, 0.21888761f, 0.31312108f, 0.16666542f, 0.01972012f, -0.17575601f, 0.23815024f, 0.22490463f, 
    0.14874448f, 0.19176278f, 0.39150533f, -0.35891256f, 0.09406989f, -0.18351494f, 0.27889359f, 0.13785744f, 
    -0.01131796f, 0.10599634f, -0.20852298f, 0.26354858f, -0.26959127f, 0.00719097f, 0.08881190f, -0.25551036f, 
    -0.06388061f, 0.08743028f, -0.24419700f, 0.03433082f, 0.28584453f, 0.39238054f, -0.23074080f, 0.05308864f, 
    0.23515947f, 0.17388321f, 0.33421886f, 0.10811961f, -0.06871986f, -0.00905177f, -0.43229347f, -0.10051428f, 
    0.15689428f, 0.21951331f, -0.29224995f, 0.23957859f, 0.17352414f, 0.44898269f, -0.45345548f, 0.07130574f, 
    -0.02481004f, 0.15134227f, 0.20275062f, 0.08961568f, -0.06519374f, 0.28988004f, -0.31465527f, 0.37881497f, 
    0.01813597f, 0.02835378f, -0.10138382f, 0.11051635f, 0.22756770f, -0.07468434f, 0.31142446f, -0.36505580f, 
    0.22090253f, -0.06195793f, 0.11142689f, 0.02130298f, 0.13371877f, 0.09693812f, 0.12132336f, 0.12922519f, 
    -0.25511491f, -0.10054949f, -0.06099579f, -0.12386703f, -0.08915103f, -0.01250942f, -0.03940492f, 0.23588690f, 
    -0.09739733f, -0.05744629f, 0.25818563f, 0.13608941f, -0.20483294f, -0.28479403f, -0.10330656f, -0.26484683f, 
    -0.08646514f, 0.03550617f, -0.46677127f, 0.07824547f, 0.31988561f, 0.28222933f, -0.25103655f, 0.18277177f, 
    -0.27393624f, 0.26271227f, 0.35452500f, 0.17044403f, 0.04222341f, 0.08556660f, -0.35100135f, -0.19245768f, 
    -0.08284627f, 0.22103932f, -0.05355038f, 0.15611346f, 0.16089381f, 0.31630793f, -0.03162575f, -0.06500283f, 
    -0.14149238f, 0.30058265f, 0.22167335f, 0.18643807f, -0.08916301f, -0.37243769f, 0.14048967f, -0.00334144f, 
    0.11576455f, 0.02094147f, -0.29959413f, -0.06120249f, -0.11591621f, 0.26001495f, 0.04301104f, -0.05170102f, 
    -0.07225524f, 0.28838956f, -0.08936308f, 0.32116488f, -0.18164991f, -0.12445673f, 0.23578185f, -0.23145346f, 
    0.16171409f, -0.02350771f, -0.30580440f, 0.11175106f, 0.21226528f, -0.05543453f, 0.11505757f, -0.10762574f, 
    -0.02454698f, -0.21172179f, 0.10883511f, 0.29479301f, -0.17575644f, 0.43209943f, -0.31316993f, 0.06594414f, 
    0.14098197f, 0.06503133f, 0.33460885f, 0.18774062f, 0.18221200f, 0.33286369f, -0.11497837f, 0.06022537f, 
    -0.32054076f, 0.19196120f, 0.35921806f, 0.00752137f, -0.05283049f, -0.31140763f, -0.13960737f, 0.16901994f, 
    0.22136490f, -0.06004056f, 0.17789978f, 0.17290998f, -0.41147211f, -0.07256106f, -0.00424709f, 0.33861342f, 
    -0.18943010f, -0.23236448f, 0.18505217f, 0.34419259f, 0.16417411f, -0.24950628f, 0.00561074f, -0.04489026f, 
    0.13805340f, -0.10588083f, -0.53161228f, 0.12396687f, 0.19474317f, -0.15458204f, 0.36283121f, 0.20952517f, 
    0.07214466f, -0.33202004f, -0.40597206f, 0.01354827f, 0.00512708f, -0.10319941f, -0.35792691f, -0.18098122f, 
    -0.18550469f, 0.16898876f, -0.07740847f, 0.01246502f, -0.01921728f, -0.21601370f, 0.13371792f, -0.26070461f, 
    0.14807385f, 0.14530618f, -0.20925155f, -0.06663387f, -0.27773863f, -0.08559846f, -0.04212714f, -0.22603112f, 
    -0.07916065f, 0.23205386f, 0.09544026f, 0.19498213f, -0.32754785f, -0.11962262f, 0.39188099f, -0.12587592f, 
    0.35691798f, 0.02875234f, 0.07361963f, -0.14111336f, 0.21432263f, 0.20807894f, -0.44291010f, 0.10901776f, 
    0.08560133f, 0.05426663f, 0.22625622f, 0.06760511f, 0.27812257f, 0.38567260f, -0.08016420f, 0.03537869f, 
    -0.33519810f, -0.34559563f, -0.10394134f, 0.14943376f, 0.28058302f, -0.21090908f, -0.13220984f, 0.12074342f, 
    0.19910239f, -0.06002331f, 0.05426674f, 0.20527093f, -0.04834802f, 0.16591525f, -0.13037722f, -0.21428932f, 
    0.12756465f, -0.12152409f, 0.12986299f, 0.42896202f, 0.19915339f, 0.31617558f, -0.17221494f, -0.34722114f, 
    0.02067246f, -0.07046911f, 0.20920381f, 0.27602181f, 0.09274136f, -0.19335841f, 0.26638910f, -0.00519630f, 
    -0.19314329f, 0.21183075f, 0.01314639f, -0.10322532f, -0.34204853f, -0.47456625f, 0.31966674f, -0.37107456f, 
    0.05957121f, 0.15500534f, 0.42409945f, -0.05334005f, -0.00112928f, -0.21946597f, 0.10632446f, -0.18200530f, 
    0.29643267f, 0.12728237f, 0.28573450f, -0.31076473f, 0.29612184f, -0.08596107f, 0.19639175f, -0.13275972f, 
    -0.27896759f, -0.11259678f, -0.27196580f, -0.06232569f, -0.17721604f, 0.01655729f, 0.02559255f, 0.10606184f, 
    -0.16048555f, 0.22488460f, 0.33481237f, 0.15456155f, 0.00972683f, 0.01895793f, 0.17525063f, 0.42396972f, 
    0.22931494f, -0.04941082f, 0.02438539f, 0.17272602f, 0.28691137f, -0.18730663f, 0.20406643f, -0.35108688f, 
    0.08213643f, 0.28344753f, 0.17177022f, -0.31776252f, 0.05555358f, 0.23847012f, 0.25371605f, -0.17391934f, 
    0.29201752f, 0.04658033f, -0.17466837f, -0.00774733f, 0.28238055f, -0.32384679f, 0.06317957f, -0.09630372f, 
    0.21333577f, -0.30791020f, -0.13058479f, 0.29251760f, -0.10455460f, 0.17616922f, 0.08842113f, 0.26453033f, 
    -0.04606931f, 0.04615048f, 0.32992339f, 0.08975475f, -0.31033894f, 0.48526901f, 0.12329417f, 0.30355570f, 
    -0.12275696f, 0.19905904f, 0.19666050f, -0.62549412f, -0.14496543f, -0.24372940f, 0.24720950f, 0.04194862f, 
    0.11865169f, -0.16721076f, -0.10990784f, -0.07973313f, -0.21884936f, -0.10475764f, -0.12389466f, -0.18998185f, 
    0.24871448f, 0.09409493f, -0.12535530f, -0.22073346f, -0.20960176f, -0.00210756f, -0.06797600f, 0.13449001f, 
    -0.23443268f, 0.24990399f, 0.00632120f, -0.19887500f, 0.10146473f, 0.30344552f, 0.04095358f, 0.05191033f, 
    -0.08308905f, -0.15057109f, -0.13048473f, -0.39345402f, 0.34315133f, 0.14790793f, 0.20837982f, -0.23728177f, 
    -0.15669414f, 0.04477636f, -0.20003848f, -0.07673401f, -0.14454670f, -0.12820113f, 0.44937316f, 0.20415793f, 
    0.26859644f, -0.28926173f, -0.17145810f, -0.24333374f, 0.24632356f, 0.04889755f, 0.18348506f, -0.11114402f, 
    0.12501933f, 0.12303790f, 0.27620265f, -0.28224027f, 0.31826800f, 0.22137468f, 0.05583418f, 0.28784394f, 
    -0.11402342f, -0.15145119f, -0.09710483f, 0.31099394f, -0.24845359f, -0.35701844f, 0.02010826f, -0.69462818f, 
    0.12661561f, -0.16617462f, 0.42501459f, 0.16771221f, 0.16774464f, -0.21956487f, 0.08928017f, -0.12101024f, 
    -0.04047846f, -0.16007142f, -0.17357275f, 0.34729061f, 0.22467348f, -0.33781156f, 0.15964180f, -0.17518836f, 
    0.22635040f, 0.17942242f, -0.09526853f, 0.26413468f, 0.10760552f, 0.05829143f, 0.12434288f, -0.25709060f, 
    0.06888233f, -0.23677364f, 0.30999580f, 0.31612101f, 0.22643650f, 0.13589793f, -0.67911273f, -0.16160131f, 
    -0.25986475f, -0.09438151f, 0.03350025f, -0.00356598f, -0.30173841f, 0.30960903f, 0.13450556f, 0.16707000f, 
    -0.15850143f, 0.49310040f, 0.01033075f, -0.42189986f, -0.18046527f, -0.30041289f, 0.22273448f, 0.12076965f, 
    0.05038832f, -0.15611720f, -0.00270802f, 0.22474012f, 0.26287106f, -0.14555755f, 0.19632447f, -0.23245740f, 
    -0.18802884f, 0.20537157f, -0.22050188f, -0.01152786f, 0.26454669f, -0.04246699f, -0.12106244f, -0.29136640f, 
    0.01964244f, -0.03739013f, -0.37476003f, 0.29904121f, -0.01299907f, -0.32430837f, -0.27275842f, 0.05659568f, 
    0.09764432f, 0.13353254f, 0.12159209f, -0.44862849f, 0.17003974f, 0.26086313f, -0.24484804f, 0.08304363f, 
    -0.01901457f, -0.00449303f, 0.05656723f, 0.13591856f, -0.14412744f, 0.10008845f, 0.06741721f, -0.22890590f, 
    0.07814776f, -0.14822726f, -0.08069916f, -0.23942494f, -0.25130308f, 0.00173077f, -0.15950173f, -0.20850930f, 
    -0.21130382f, -0.09341178f, -0.44047549f, 0.32351083f, 0.27313432f, 0.23062617f, -0.13845801f, 0.13425165f, 
    -0.17061467f, -0.30403316f, 0.04330382f, -0.22860709f, -0.03559944f, 0.23890302f, -0.36611536f, -0.32485402f, 
    -0.27041721f, 0.14713585f, -0.24039765f, 0.27364230f, -0.14740676f, 0.14836068f, 0.32568333f, 0.22022150f, 
    -0.06374961f, -0.22154957f, 0.26818278f, 0.13874349f, -0.26363251f, 0.26284352f, 0.20406874f, 0.16740631f, 
    0.16210081f, -0.04845788f, 0.03103655f, 0.08696128f, -0.01632278f, -0.27622998f, -0.15960814f, 0.09144515f, 
    0.31592035f, 0.14892562f, 0.09437909f, -0.18225163f, 0.24141465f, 0.05085431f, -0.18421374f, -0.44110155f, 
    0.17536075f, 0.20713444f, 0.02885417f, 0.27172881f, 0.03956604f, 0.51774687f, -0.31360006f, 0.17259930f, 
    -0.22326846f, -0.27220306f, 0.05093082f, 0.14296429f, 0.04597166f, 0.14409699f, 0.02589290f, -0.19536933f, 
    0.26756275f, -0.10216233f, 0.00267715f, -0.08949744f, 0.19009903f, -0.16983077f, 0.01562912f, -0.14878215f, 
    0.30397326f, -0.28090093f, -0.08430184f, 0.37786993f, 0.08171806f, 0.32120201f, 0.08479680f, 0.17511652f, 
    -0.19789894f, 0.00372237f, -0.32056111f, 0.09618354f, 0.38515258f, -0.04225757f, -0.23330607f, -0.31174859f, 
    0.28290850f, 0.30762458f, 0.35246259f, 0.34150842f, 0.09291292f, 0.22025752f, -0.13392085f, 0.34022263f, 
    0.02153366f, -0.16345382f, -0.34337303f, 0.04275452f, -0.25274423f, 0.12412082f, 0.02593707f, 0.31440827f, 
    0.26905602f, -0.35400537f, -0.30644390f, -0.00245838f, -0.05523907f, 0.04042033f, 0.20351948f, -0.29925179f, 
    0.00633950f, -0.20373964f, -0.17843328f, -0.31356901f, -0.24032019f, -0.18019703f, -0.66175658f, -0.19678833f, 
    -0.31297413f, 0.07361363f, -0.28169239f, 0.28957611f, 0.13620269f, -0.23323865f, 0.37623671f, -0.29424423f, 
    0.05483110f, 0.16043162f, -0.05013193f, 0.25170395f, -0.09905601f, 0.23753612f, 0.16540504f, 0.37975466f, 
    -0.24086246f, -0.08788024f, 0.15210964f, -0.50621778f, -0.21006246f, -0.09450767f, -0.01492932f, -0.31127048f, 
    0.10277563f, 0.03745234f, 0.82201946f, -0.20399670f, 0.14528662f, 0.59758687f, -0.14618127f, 0.10340030f, 
    0.08972036f, -0.37045163f, 0.31595817f, 0.03741166f, -0.02914812f, 0.00567607f, -0.40410855f, 0.14203230f, 
    -0.11892647f, 0.22287084f, 0.39263734f, 0.05297814f, 0.13075288f, -0.20727475f, 0.24713978f, -0.00612234f, 
    -0.28275701f, 0.20249330f, 0.55786049f, -0.01051436f, 0.03749024f, -0.04958955f, 0.05198562f, -0.06257045f, 
    -0.24406563f, -0.22332382f, -0.01268831f, 0.15697464f, 0.29214948f, 0.15123568f, -0.31281078f, 0.12646906f, 
    -0.05636561f, 0.27550605f, 0.34713241f, -0.48528033f, 0.26497984f, -0.38572732f, -0.47765604f, 0.05601789f, 
    -0.04635620f, 0.06364968f, 0.17752846f, 0.24851395f, -0.31579354f, 0.27574331f, -0.26289126f, 0.04690875f, 
    -0.05151623f, 0.25297773f, 0.47643918f, -0.02695424f, 0.18434733f, 0.14836487f, -0.13065721f, 0.00179068f, 
    -0.08800467f, -0.06635775f, 0.17810911f, 0.05089187f, 0.11745428f, -0.10975237f, 0.26377454f, -0.18450812f, 
    0.25485045f, 0.00050935f, -0.33999214f, -0.05277245f, 0.22019818f, -0.24637134f, -0.14191385f, -0.27127439f, 
    -0.05632329f, 0.12820111f, -0.09334029f, 0.05518917f, -0.05753067f, 0.05753475f, 0.41339892f, 0.12640169f, 
    -0.09746837f, -0.23975441f, -0.02559326f, -0.01479983f, -0.27467427f, 0.28188393f, 0.12509024f, 0.37693703f, 
    -0.09995487f, 0.14402065f, -0.11425430f, 0.25785699f, 0.13346161f, 0.32969841f, -0.24993922f, 0.16717976f, 
    0.03547328f, 0.24371852f, 0.21061233f, 0.12569478f, 0.08194573f, -0.20904607f, -0.51459587f, -0.28332672f, 
    -0.10962688f, -0.15622622f, 0.35163933f, 0.36839333f, -0.21410483f, 0.38169694f, -0.02552677f, 0.06030371f, 
    -0.16270147f, 0.36827216f, 0.46896735f, -0.32648149f, 0.14978887f, -0.45625207f, -0.43089220f, -0.22994386f, 
    -0.05392489f, 0.15120246f, 0.05245617f, -0.12750074f, 0.21013021f, 0.12409478f, -0.00951053f, 0.23693965f, 
    -0.26483133f, 0.05261840f, 0.09142291f, 0.00461016f, -0.31649581f, -0.08741199f, -0.00661389f, 0.26010844f, 
    0.10727615f, -0.06518966f, -0.38969550f, 0.26023874f, 0.10076852f, 0.24967974f, -0.12114169f, -0.09328075f, 
    0.22338869f, 0.10758676f, -0.09343105f, 0.19272594f, -0.00255061f, 0.06969965f, -0.59649664f, -0.27791765f, 
    -0.20776254f, 0.14912550f, -0.24293227f, -0.16270721f, 0.10840405f, 0.28093931f, 0.01001873f, 0.31576040f, 
    -0.17611338f, 0.22293434f, 0.04518936f, -0.24583346f, -0.06765611f, -0.02083797f, -0.05606430f, -0.13696371f, 
    -0.19534388f, -0.01522237f, 0.27513847f, -0.21320918f, 0.05901464f, 0.16793306f, -0.00232576f, 0.27436349f, 
    -0.06173712f, -0.05114526f, 0.36665660f, -0.38941962f, 0.04441370f, -0.16611691f, 0.32617268f, 0.34835863f, 
    0.26638418f, 0.13992128f, 0.19188622f, 0.00698969f, 0.09276882f, 0.16222377f, -0.12079542f, -0.20201708f, 
    0.29916936f, 0.02835608f, -0.09014341f, 0.48258150f, -0.04969681f, 0.19766471f, -0.02500849f, 0.47457501f, 
    0.08688728f, 0.02402875f, -0.18148194f, 0.03380156f, 0.11847919f, 0.41123307f, -0.06339762f, -0.26711181f, 
    0.27524787f, -0.61404759f, -0.11659307f, -0.19892482f, 0.38617399f, 0.14817794f, -0.64712667f, 0.18283549f, 
    -0.03049514f, -0.22701448f, 0.19999269f, -0.05521739f, -0.38518518f, 0.09588804f, -0.23393176f, 0.31884289f, 
    -0.10252260f, 0.09243360f, 0.13096289f, -0.09091684f, -0.14284913f, 0.38546145f, 0.32874930f, 0.27483180f, 
    -0.28575948f, 0.07619196f, 0.14983222f, 0.10595413f, -0.10034189f, 0.46970454f, -0.32768357f, 0.03616861f, 
    0.11719099f, 0.33847171f, -0.06680603f, -0.56625974f, 0.25665808f, -0.08090603f, 0.06121025f, -0.03078775f, 
    -0.18804169f, -0.01400718f, 0.48609218f, 0.21639669f, -0.17791392f, -0.01795373f, 0.11568314f, -0.16718435f, 
    0.10427298f, -0.12882343f, -0.09640215f, -0.08398729f, 0.31450754f, 0.10208347f, 0.19438528f, -0.34930944f, 
    0.27802014f, -0.06072846f, 0.12931845f, 0.12359550f, 0.04256115f, -0.14124116f, -0.16691023f, 0.13965218f, 
    -0.24477114f, 0.17199092f, -0.13250001f, 0.12383565f, 0.08192208f, -0.25915542f, -0.07369749f, 0.09541904f, 
    -0.13521333f, 0.06372881f, -0.21567433f, -0.15687418f, -0.17953007f, 0.04339214f, -0.29906154f, -0.24438149f, 
    -0.23665822f, -0.17947684f, 0.37385359f, 0.11156580f, -0.00438847f, 0.10833252f, 0.16596411f, -0.15382102f, 
    -0.09901974f, -0.16727600f, -0.52242291f, 0.34130669f, -0.46298620f, -0.27910042f, 0.26746738f, -0.14015226f, 
    -0.02866089f, -0.44068152f, -0.02073204f, -0.30264798f, -0.14833646f, 0.19859523f, 0.06727216f, 0.09859189f, 
    0.01140425f, -0.20840737f, -0.32278740f, 0.35925835f, -0.30513757f, 0.13452448f, -0.12937407f, -0.05035633f, 
    0.23036233f, 0.18614496f, 0.06256016f, 0.23831059f, 0.30111191f, -0.01526954f, -0.30342916f, -0.49120227f, 
    -0.13218629f, -0.23410088f, 0.17364267f, -0.04380680f, 0.02845462f, -0.51712966f, 0.34033152f, -0.15294424f, 
    0.35242930f, -0.19397607f, -0.51004982f, -0.24397467f, 0.13433231f, 0.03256766f, -0.02961966f, -0.13908970f, 
    -0.08424894f, 0.11524476f, -0.07129975f, -0.08129036f, -0.00902822f, 0.48932520f, -0.04351766f, 0.13310777f, 
    -0.04583339f, -0.24343142f, -0.18162335f, 0.00792332f, -0.00242182f, 0.21233380f, -0.38997585f, 0.11772557f, 
    -0.13116841f, 0.19917423f, -0.15231550f, -0.18890232f, -0.22897549f, -0.07675638f, -0.12021486f, -0.22117117f, 
    -0.24361417f, -0.22197679f, -0.01440179f, -0.10179774f, -0.13967280f, -0.11073077f, 0.08368704f, 0.05439015f, 
    -0.21407598f, -0.19030246f, -0.17599827f, 0.20064387f, -0.16703492f, -0.00822377f, -0.24357393f, -0.11325654f, 
    -0.21753952f, -0.11432847f, -0.23058531f, -0.12626255f, -0.19638696f, 0.02805501f, -0.02379036f, -0.19669905f, 
    -0.14913367f, -0.11546880f, -0.16733906f, 0.06083220f, 0.32674327f, -0.12401951f, 0.22000095f, -0.03445893f, 
    0.10959876f, 0.35919026f, 0.05664543f, 0.38125536f, -0.11927710f, -0.48136368f, -0.05508774f, -0.31294709f, 
    0.03470203f, -0.20195207f, -0.02408596f, 0.15705459f, -0.20519291f, 0.24247089f, 0.28366762f, -0.23662245f, 
    0.26582003f, -0.41617918f, 0.02448720f, -0.45122859f, 0.26119214f, -0.21563563f, -0.42178300f, 0.04842538f, 
    0.06052920f, 0.11672273f, 0.03240237f, -0.12909231f, -0.21216932f, -0.03031796f, 0.13590515f, -0.06974092f, 
    -0.20186695f, -0.15829641f, 0.17325470f, -0.07520020f, -0.09413102f, -0.11854959f, -0.19130862f, -0.13021278f, 
    -0.17893007f, -0.21819887f, -0.50169659f, -0.17607763f, 0.15313490f, 0.16691598f, 0.27500463f, 0.08080890f, 
    0.32115111f, -0.12719679f, -0.02062302f, 0.10787447f, -0.03574480f, -0.17729598f, -0.33120269f, -0.20371556f, 
    -0.11950528f, -0.01339963f, -0.08911826f, -0.13378996f, 0.08819484f, 0.10725040f, -0.17995039f, -0.12115067f, 
    0.25918609f, 0.02491470f, 0.09907867f, -0.03210426f, 0.07931539f, 0.24120843f, 0.10312802f, -0.38160485f, 
    -0.22587278f, 0.03133664f, -0.05387726f, 0.14793947f, -0.16807628f, 0.31117752f, -0.01036595f, -0.13101986f, 
    -0.32995969f, 0.43915671f, -0.46457592f, 0.11646357f, 0.19270679f, -0.37308455f, 0.30012432f, 0.07474283f, 
    -0.23045821f, 0.16952392f, -0.07803890f, 0.13718681f, -0.41099551f, 0.41818660f, -0.10454547f, 0.23598719f, 
    0.07862382f, -0.29035261f, -0.20122308f, 0.01086711f, 0.12010758f, 0.30621222f, 0.20056552f, 0.14052136f, 
    0.00072642f, 0.03359900f, -0.04409195f, -0.11966413f, 0.31564060f, -0.16371211f, 0.36674979f, -0.17379992f, 
    0.17890966f, -0.04163181f, 0.22298925f, -0.27979937f, 0.24996887f, -0.02179445f, 0.23083973f, 0.41033837f, 
    -0.22304057f, 0.06674152f, 0.09114460f, 0.37389845f, 0.04645146f, -0.26460600f, -0.19845617f, -0.21208495f, 
    0.20996684f, 0.04836319f, 0.23922421f, -0.12142868f, 0.34969515f, 0.18412253f, -0.00782661f, -0.21856014f, 
    0.17733434f, -0.18129849f, -0.12534288f, -0.22262609f, -0.10392193f, -0.05876148f, 0.17481045f, -0.19735888f, 
    0.06221408f, -0.14610736f, 0.07087684f, -0.06380716f, -0.05217634f, -0.27295065f, -0.11229618f, 0.20250328f, 
    -0.11440898f, 0.01990832f, 0.26661569f, -0.03889830f, 0.10955837f, -0.38715705f, -0.00406779f, 0.08318350f, 
    0.08901916f, 0.36517304f, 0.38978469f, -0.31448719f, 0.31687206f, -0.15815794f, -0.33731145f, -0.26085246f, 
    0.18888129f, 0.10800990f, -0.01232687f, 0.16797532f, 0.37912282f, -0.24505986f, 0.30286521f, -0.14204144f, 
    -0.23131208f, -0.17139244f, -0.06630871f, 0.34311554f, -0.10181607f, -0.02304904f, -0.06435598f, -0.11830303f, 
    -0.31296185f, -0.02619755f, -0.07661889f, -0.11271968f, 0.52314043f, 0.02262683f, 0.28284609f, 0.03774064f, 
    0.00947088f, 0.15870757f, 0.37428582f, -0.24145107f, -0.20068213f, -0.47282469f, 0.09570978f, -0.09011009f, 
    -0.34714052f, 0.00412592f, -0.18135996f, 0.14676601f, -0.28293020f, -0.05724075f, 0.29306716f, -0.16455145f, 
    0.06565130f, 0.31589091f, 0.05140986f, -0.14228918f, -0.20492551f, 0.33213311f, 0.37313020f, 0.27352417f, 
    -0.17486066f, -0.09748708f, -0.35319495f, 0.26348534f, -0.11686173f, 0.20042565f, -0.19776344f, 0.17473696f, 
    0.13208297f, -0.09065098f, -0.16362584f, -0.26562116f, -0.12390133f, -0.14472087f, 0.23395823f, -0.08555399f, 
    0.08856925f, 0.24170008f, 0.17129192f, -0.15668468f, -0.29732540f, -0.13452712f, 0.20929523f, 0.17703730f, 
    -0.11302575f, 0.08452869f, 0.01506413f, -0.31883004f, 0.13078426f, -0.05484453f, 0.33931842f, 0.14905579f, 
    0.28816885f, -0.19388741f, 0.11795653f, 0.38005155f, -0.63930672f, -0.51072872f, 0.16967689f, 0.03058539f, 
    0.00332552f, 0.13164696f, 0.25861499f, -0.04645466f, -0.17591769f, -0.08916539f, -0.16279134f, 0.33877963f, 
    0.13083448f, -0.02388008f, 0.09240615f, 0.02584300f, 0.25942844f, -0.41170943f, -0.12037216f, 0.09417101f, 
    0.19652537f, 0.13686067f, -0.15336075f, -0.20675176f, 0.20185496f, -0.23725896f, -0.15040593f, -0.42804155f, 
    -0.25367838f, 0.20472160f, -0.33880314f, 0.00873910f, -0.21181393f, 0.33876356f, 0.15920614f, 0.28747457f, 
    -0.19289625f, 0.25234330f, -0.09065749f, -0.53996229f, -0.22288767f, 0.11354393f, 0.13038003f, 0.31056762f, 
    0.21238634f, 0.11487660f, -0.27677351f, -0.24518940f, 0.16669145f, -0.11224384f, 0.27816465f, 0.03140464f, 
    0.24573338f, -0.11444812f, 0.32424936f, 0.38656995f, -0.26928416f, 0.03787611f, 0.00465806f, 0.30131742f, 
    -0.03914545f, 0.19121514f, 0.13815328f, 0.12096804f, 0.46322802f, 0.04337007f, 0.07153369f, -0.03531109f, 
    -0.26190847f, -0.06349410f, 0.24335352f, -0.05459664f, -0.02431388f, -0.25111806f, 0.03328273f, -0.21599117f, 
    0.14102860f, 0.10582525f, -0.05088747f, 0.22796759f, -0.21235253f, -0.07483931f, 0.07934030f, -0.22129226f, 
    0.20684308f, -0.06885344f, 0.22757739f, 0.32496411f, 0.22819124f, -0.01144660f, -0.19397320f, 0.30842295f, 
    -0.36123207f, -0.10122661f, 0.02173692f, 0.01603482f, -0.16657327f, 0.02363790f, 0.31857815f, 0.23332791f, 
    -0.00638438f, -0.42576772f, 0.24603710f, -0.14520980f, 0.20210436f, -0.26013908f, -0.37515858f, 0.17492592f, 
    0.36440200f, -0.10425129f, -0.06331283f, 0.22372292f, 0.05524717f, -0.14609753f, 0.34909672f, -0.17763585f, 
    0.10011353f, -0.09416427f, 0.47888386f, -0.18823421f, 0.08840134f, 0.06054710f, -0.08646052f, 0.28072700f, 
    0.16598429f, 0.22619072f, 0.02749541f, -0.06524976f, 0.14160252f, 0.45128399f, -0.14728335f, 0.21981697f, 
    -0.00307631f, -0.05755835f, 0.13593307f, -0.12105285f, -0.06673797f, -0.12671964f, 0.12594561f, -0.05759716f, 
    -0.07136663f, 0.12147328f, 0.15039095f, -0.17923538f, 0.08640590f, 0.12821309f, 0.04404096f, 0.02552333f, 
    0.15171525f, -0.33496940f, -0.05009530f, -0.01659763f, 0.17892006f, 0.06702217f, -0.03663862f, -0.17365310f, 
    -0.05964777f, -0.05060565f, -0.19651729f, -0.01142789f, -0.14973104f, 0.02190787f, -0.16221473f, 0.02037312f, 
    -0.10228176f, -0.11969232f, -0.14611584f, 0.17645194f, -0.04313771f, -0.08313227f, -0.17567207f, -0.02676475f, 
    -0.01733366f, -0.21379834f, 0.05523939f, 0.32927272f, -0.29010376f, 0.42453063f, -0.04325815f, 0.30460292f, 
    -0.26920599f, 0.03106150f, -0.11374224f, -0.17111853f, -0.15113732f, 0.08490634f, 0.15060551f, -0.06819371f, 
    0.40922529f, 0.11611530f, 0.60860682f, -0.33808145f, -0.05259605f, 0.39063898f, 0.03737397f, 0.00791531f, 
    0.24487969f, -0.16238543f, 0.08634782f, -0.19937390f, -0.09129281f, -0.12022127f, 0.20714597f, 0.36103663f, 
    0.24935368f, 0.16766924f, -0.02648717f, 0.09523672f, -0.13454796f, 0.15021549f, 0.15938038f, 0.02328897f, 
    0.11604628f, -0.01461211f, 0.45416498f, 0.06430347f, -0.22214207f, -0.05840948f, 0.02940559f, 0.24581340f, 
    0.21694845f, -0.03064341f, -0.06217267f, 0.16897994f, -0.06124137f, 0.45329419f, -0.10061411f, 0.22137053f, 
    -0.29063430f, -0.12965785f, 0.09203812f, 0.02627617f, -0.03333322f, 0.07374641f, -0.15904745f, -0.11697558f, 
    0.08388509f, -0.14155325f, 0.22157358f, -0.24647920f, 0.05290981f, -0.31943911f, 0.22512212f, -0.07756249f, 
    0.33389112f, -0.11358324f, -0.42088556f, 0.22706056f, 0.21377330f, 0.19670862f, 0.21276627f, 0.03746584f, 
    0.09557284f, -0.16166562f, -0.36986852f, -0.15732093f, 0.33781999f, 0.14375558f, -0.13421357f, 0.24942690f, 
    0.12289087f, -0.21084982f, 0.32371461f, -0.11939565f, -0.12165801f, 0.07365400f, -0.51679373f, 0.17624386f, 
    0.13134392f, 0.24634735f, -0.48159236f, -0.00482519f, -0.28272870f, 0.05258139f, 0.27976263f, 0.20671479f, 
    0.18443203f, -0.02636357f, 0.34727696f, -0.38170516f, -0.05850217f, -0.11793251f, 0.22217940f, 0.14926757f, 
    0.14225073f, -0.12446751f, -0.17970417f, 0.11420221f, -0.36949065f, 0.17907339f, -0.17150645f, 0.29825637f, 
    0.16728720f, -0.22642729f, 0.16569567f, -0.31814831f, 0.09190314f, -0.10538927f, 0.14043675f, -0.26623887f, 
    0.04195118f, -0.10920343f, 0.18268263f, 0.02638570f, -0.02564280f, -0.29102930f, 0.25638396f, -0.03514256f, 
    0.05078077f, 0.24441232f, -0.08672778f, 0.33941400f, -0.00310657f, -0.26297203f, 0.01027636f, 0.14985701f, 
    -0.15852177f, 0.03918991f, 0.20912510f, 0.26010197f, 0.38452962f, 0.01867720f, -0.36746398f, -0.09428537f, 
    0.07022890f, 0.27558786f, 0.17013459f, 0.39942324f, -0.21681289f, -0.20846511f, -0.08209623f, -0.01146368f, 
    0.19746009f, 0.14755949f, 0.59784997f, -0.27717677f, 0.07343639f, 0.08567063f, -0.13924091f, 0.21763700f, 
    -0.26434672f, 0.21076368f, 0.34577861f, -0.25101134f, 0.02709446f, 0.07377075f, 0.28747320f, 0.42353562f, 
    -0.11542935f, 0.00745475f, -0.03493932f, -0.18878835f, -0.17453663f, 0.18168895f, -0.35191083f, 0.05114394f, 
    -0.35533044f, -0.06247712f, -0.35541078f, -0.08361373f, 0.20659851f, -0.22218277f, 0.38696235f, -0.38928270f, 
    0.28839833f, -0.02050094f, 0.50967300f, -0.21416959f, 0.43636605f, 0.04380526f, 0.37483302f, -0.25546125f, 
    0.04934933f, 0.10743520f, 0.42726454f, 0.01155223f, -0.06168312f, -0.23159720f, -0.13509479f, 0.20357384f, 
    -0.34763324f, 0.24890372f, -0.40257359f, -0.03308859f, -0.00459188f, -0.24955775f, -0.08197946f, 0.23101264f, 
    0.30554360f, -0.01447393f, 0.12274913f, -0.07710014f, 0.14432286f, -0.06158695f, -0.13435136f, -0.28024125f, 
    -0.03511836f, -0.12817273f, 0.02292683f, 0.20745422f, -0.17337032f, 0.07654922f, 0.23926246f, -0.17056660f, 
    -0.09048828f, 0.32761106f, 0.20753859f, 0.30789381f, -0.10320996f, 0.40461427f, 0.13281280f, 0.32585952f, 
    -0.17530453f, -0.19733679f, -0.03776751f, -0.24522762f, -0.28341243f, -0.18918806f, -0.27434549f, 0.13721757f, 
    0.05988641f, 0.00661051f, -0.18323433f, -0.22137621f, -0.29051572f, 0.11579939f, -0.02074202f, 0.09738827f, 
    -0.00884608f, 0.10673727f, -0.21596317f, -0.10133182f, 0.24018051f, -0.00219558f, 0.31989053f, -0.07750159f, 
    0.21982907f, -0.26873890f, 0.10765813f, 0.20360741f, -0.20203561f, 0.27957284f, -0.31577280f, -0.15171356f, 
    0.23083159f, -0.15422291f, 0.09393155f, -0.10356767f, 0.05531194f, 0.33881694f, -0.13486677f, -0.15240873f, 
    0.13671617f, -0.05577519f, -0.16208223f, -0.17699359f, 0.07414466f, 0.32820174f, -0.11139152f, -0.02157132f, 
    0.03212516f, 0.10069406f, 0.37439448f, -0.29775393f, 0.08592390f, -0.20474245f, 0.08719175f, 0.11972035f, 
    0.03873244f, 0.07628778f, 0.09798913f, 0.34648481f, -0.17541358f, 0.14194252f, 0.01602436f, -0.10090862f, 
    0.02702459f, -0.19360551f, -0.42903075f, 0.39415541f, -0.24042027f, -0.36857390f, 0.35490632f, 0.06263277f, 
    -0.22852615f, -0.04448655f, 0.33107778f, 0.55820990f, -0.15442418f, -0.00083611f, -0.53028876f, 0.10600352f, 
    0.35477608f, -0.20503122f, -0.22198273f, 0.29922387f, 0.25955945f, -0.18822476f, 0.06050204f, -0.33382282f, 
    0.03034278f, -0.36671335f, -0.20573658f, 0.27320755f, 0.06360035f, 0.30824542f, -0.26265311f, 0.28102651f, 
    -0.08447676f, -0.24385864f, 0.18883084f, 0.15973556f, 0.11721855f, 0.12134678f, 0.00730922f, -0.14928977f, 
    0.02302646f, 0.12454104f, 0.09210192f, -0.45744917f, 0.41903478f, -0.23490565f, 0.22688122f, -0.24535240f, 
    -0.22488528f, 0.19229794f, -0.34908116f, 0.12065913f, -0.19127785f, -0.27976701f, 0.20400287f, 0.21559171f, 
    -0.18305272f, -0.02255461f, -0.19179457f, -0.13838398f, -0.05738758f, 0.38600630f, 0.17548059f, 0.29551339f, 
    -0.21434046f, 0.03695357f, -0.43924877f, -0.00330761f, -0.33558583f, -0.19529195f, 0.35722876f, 0.12856285f, 
    -0.27103320f, 0.00208126f, -0.02989987f, 0.31799796f, -0.08243788f, 0.15655874f, 0.24942875f, 0.19283840f, 
    0.24292947f, -0.13258946f, -0.24195543f, 0.28137898f, -0.21805371f, 0.08886544f, 0.25944728f, -0.03812151f, 
    0.08665589f, 0.04223049f, 0.10798325f, 0.41736671f, -0.18957041f, 0.18816857f, -0.05539491f, 0.10215168f, 
    -0.51185375f, 0.20845555f, -0.56266588f, 0.20017572f, -0.07879970f, 0.42509165f, -0.20703763f, 0.28995049f, 
    0.13080943f, -0.10808787f, -0.15379541f, -0.50124013f, -0.13577081f, -0.05327889f, -0.42777079f, -0.07599058f, 
    -0.24371359f, -0.22735101f, -0.04910270f, 0.20805748f, -0.15927514f, 0.08283179f, 0.37229943f, 0.02964487f, 
    -0.14175053f, -0.59101164f, -0.17979792f, -0.42255718f, 0.12398852f, -0.18380864f, -0.13747786f, 0.27876723f, 
    -0.18725677f, 0.20806143f, 0.13858853f, -0.14241831f, 0.24829927f, 0.06021538f, 0.23183127f, -0.11363724f, 
    0.02626023f, 0.39597750f, 0.35338679f, 0.07168166f, -0.13641961f, -0.19455977f, 0.20574379f, 0.41842490f, 
    0.11796462f, 0.06266873f, 0.17164598f, -0.10291196f, -0.13365787f, -0.23885672f, 0.14015892f, 0.02381480f, 
    0.09914806f, 0.09525615f, 0.08632576f, -0.41340429f, 0.22374196f, 0.22027911f, -0.41774085f, 0.17241824f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12941916f, 0.07595416f, -0.02439725f, -0.22259942f, 0.30042136f, -0.19263028f, 0.04057578f, 0.20699860f, 
    -0.28917769f, 0.13866819f, -0.19174398f, 0.27127928f, 0.20337892f, 0.28490806f, 0.02824280f, 0.45930248f, 
    -0.23282848f, 0.44234532f, -0.19956110f, 0.28342596f, -0.06649243f, -0.11810455f, 0.47994602f, 0.41542858f, 
    -0.24339034f, -0.21131355f, 0.00027476f, 0.34421968f, -0.24509168f, 0.56548166f, -0.06092643f, -0.26632813f, 
    -0.00523318f, 0.32183695f, 0.19393921f, -0.05736681f, 0.46016923f, 0.08933804f, 0.37286156f, -0.19340737f, 
    -0.27536270f, -0.05209858f, -0.35631895f, -0.27250516f, 0.38695717f, 0.24149001f, 0.24823534f, -0.09368025f, 
    0.10161894f, 0.31883731f, -0.40089795f, 0.22131301f, 0.24048123f, 0.23035419f, -0.15193456f, 0.48370132f, 
    0.50690043f, 0.44469753f, 0.05208671f, -0.51296329f, 0.08891962f, 0.08627011f, 0.48259267f, -0.14207542f, 
    -0.23833591f, -0.19596876f, -0.36052030f, -0.12868696f, -0.01275481f, 0.37067354f, 0.21218087f, -0.14815190f, 
    -0.31339371f, 0.10128640f, -0.20360792f, 0.56268013f, 0.39859667f, -0.08226218f, 0.17531471f, 0.00229835f, 
    0.11162822f, -0.19962113f, -0.09671736f, 0.33659911f, 0.29426622f, -0.35254708f, 0.54358250f, 0.21359198f, 
    -0.13543661f, 0.19267912f, -0.05710669f, -0.28279507f, 0.34982058f, -0.40259182f, 0.09713043f, 0.35844842f, 
    0.44048485f, 0.45685005f, -0.13813402f, -0.24264474f, 0.29092690f, -0.20538695f, -0.11143345f, -0.25377899f, 
    0.48476869f, 0.35692868f, 0.34358081f, -0.15291402f, 0.09935474f, -0.42090842f, 0.01045923f, 0.03659218f, 
    0.24541748f, -0.22886696f, -0.13123897f, 0.55639380f, 0.59249538f, -0.20758595f, -0.25999254f, -0.11661327f, 
    0.45154724f, 0.03568871f, 0.23621300f, -0.29988307f, 0.55879146f, -0.05468987f, -0.18421791f, 0.32888982f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.12705585f, -0.00474881f, 0.28306580f, -0.02987669f, -0.02097306f, 0.16605243f, -0.12134250f, -0.17603056f, 
    -0.18082653f, 0.03981618f, -0.00832837f, -0.20022148f, -0.05072025f, -0.20493343f, -0.61164427f, -0.02742234f, 
    0.19087404f, -0.12703648f, -0.06651641f, -0.02827057f, -0.18967357f, 0.01372974f, -0.08758301f, 0.13302594f, 
    0.14546636f, 0.01528032f, -0.27466023f, 0.24517137f, -0.02761915f, -0.05526722f, 0.14959694f, -0.27931762f, 
    0.09633428f, -0.14869621f, 0.38667381f, 0.01894674f, 0.10424571f, -0.04774460f, -0.32504031f, -0.03455092f, 
    0.14508291f, -0.09026222f, -0.20478317f, -0.09661646f, 0.08004089f, -0.19947988f, 0.00522833f, -0.18740138f, 
    0.02630822f, 0.00421519f, 0.17851919f, 0.12523594f, -0.07697646f, 0.03215094f, 0.27489561f, -0.09509828f, 
    -0.07207777f, 0.01127068f, 0.01600000f, -0.19372134f, -0.39620033f, 0.16859230f, 0.16486114f, 0.29444036f, 
    -0.14010392f, 0.06834635f, -0.55121511f, 0.05525752f, 0.33610389f, -0.08907704f, 0.05526892f, 0.06105458f, 
    -0.11216487f, -0.02035035f, 0.06404746f, -0.26429123f, 0.03109816f, -0.15928367f, 0.03478132f, -0.01991943f, 
    0.08958768f, 0.00457262f, 0.24570717f, -0.27604285f, -0.02573879f, 0.17346594f, 0.12194553f, 0.23237845f, 
    0.12581219f, 0.10959867f, 0.16400436f, -0.32176331f, -0.03273634f, -0.01780107f, 0.01990665f, -0.08772535f, 
    -0.08329437f, -0.12652041f, -0.03772381f, 0.22312212f, 0.01507187f, -0.07984600f, -0.10885955f, 0.02751657f, 
    -0.24228238f, 0.04666530f, 0.23664473f, 0.06305928f, -0.09700710f, 0.14545359f, -0.17487834f, -0.12687507f, 
    0.15580350f, 0.07530137f, 0.05072272f, -0.15896536f, 0.04582207f, 0.10088998f, -0.07541919f, -0.36974725f, 
    0.09606336f, 0.05712038f, -0.03698134f, 0.00641773f, -0.23292157f, -0.02856478f, 0.12114774f, 0.11057183f, 
    -0.00359261f, 0.00978877f, -0.03515784f, -0.03438645f, -0.05786726f, -0.09611236f, -0.03766787f, -0.07184146f, 
    0.03701472f, 0.01441426f, 0.04166397f, -0.04515946f, 0.04964956f, 0.00998262f, -0.00194958f, 0.02287429f, 
    -0.00352416f, 0.02052612f, 0.07633435f, 0.01227660f, 0.00549127f, -0.09151359f, 0.01843557f, 0.02620712f, 
    -0.09244832f, -0.03974841f, 0.01004128f, 0.04373144f, -0.05666547f, -0.07201070f, -0.02087791f, -0.00065586f, 
    -0.01032710f, 0.01268214f, -0.00890053f, 0.07018402f, 0.00511411f, -0.03032539f, 0.03071618f, 0.07848003f, 
    -0.01449088f, 0.05858228f, 0.05571526f, 0.04885818f, -0.04129767f, -0.07686839f, -0.02012980f, 0.08177555f, 
    -0.05889814f, -0.01048829f, -0.07658049f, 0.00556823f, -0.07210555f, -0.00644548f, 0.00607493f, -0.03284574f, 
    0.05996113f, -0.12801127f, -0.08576514f, -0.09849765f, 0.03128107f, -0.11999486f, -0.09474538f, 0.06254829f, 
    0.01870607f, -0.06672312f, 0.01917520f, -0.00258231f, 0.02204425f, -0.06882336f, -0.05504181f, 0.02661188f, 
    -0.11094339f, -0.03338077f, -0.05683746f, 0.00382857f, -0.04813185f, 0.06867792f, 0.01454040f, -0.07185705f, 
    -0.00601867f, 0.04876177f, 0.07303660f, -0.05871673f, 0.06135316f, -0.03692113f, 0.07399257f, 0.04605015f, 
    -0.03411638f, -0.03353025f, -0.03130369f, 0.02150499f, -0.05124216f, -0.04695024f, -0.07037733f, -0.07131160f, 
    -0.06870339f, -0.04223375f, -0.04718715f, 0.00225612f, -0.00921403f, -0.09183408f, -0.08233181f, -0.02847979f, 
    0.06435636f, 0.03119206f, 0.01558085f, 0.02484976f, 0.00261475f, 0.01314860f, 0.05814224f, 0.03809753f, 
    -0.07853071f, 0.04917004f, -0.04485636f, 0.02606004f, 0.07660708f, -0.03440988f, -0.01737306f, 0.03271655f, 
    -0.02711711f, -0.01223576f, -0.08111276f, 0.02721392f, -0.01194836f, -0.09680576f, 0.04390224f, 0.00051274f, 
    -0.01735020f, -0.03326453f, 0.05091833f, 0.06237828f, -0.05514835f, -0.10163994f, 0.00927644f, 0.04206433f, 
    -0.07911453f, -0.05561890f, -0.01463780f, 0.03998489f, 0.01875907f, -0.14696699f, -0.02472384f, -0.07086003f, 
    0.00786200f, 0.04039481f, 0.04423570f, -0.02768495f, 0.04503469f, 0.04696323f, -0.09145124f, -0.07264318f, 
    -0.03649897f, -0.05101233f, 0.01707383f, -0.07731363f, 0.03694220f, -0.14148942f, 0.01668278f, -0.04164327f, 
    -0.12715220f, -0.00623253f, -0.10493174f, 0.05602674f, 0.00565388f, -0.01786857f, 0.03942309f, 0.03453765f, 
    -0.01537000f, 0.03478524f, -0.12592682f, -0.06031022f, 0.02687999f, 0.07541942f, 0.00803109f, 0.08570408f, 
    -0.04241991f, -0.05117162f, -0.00487302f, -0.01699893f, -0.07302427f, -0.08337760f, -0.07254400f, -0.03070075f, 
    0.01091243f, -0.10870841f, -0.00684782f, -0.00629456f, 0.00330149f, 0.02995021f, -0.00145322f, 0.03057393f, 
    -0.05790512f, -0.05704916f, 0.00781051f, 0.02215184f, -0.02106757f, -0.06178213f, 0.06747854f, 0.01277351f, 
    -0.10279962f, 0.02308488f, 0.08304644f, -0.09617663f, -0.10826036f, 0.06663793f, -0.09273778f, -0.06001946f, 
    -0.07036689f, 0.07910306f, -0.03045167f, 0.03333719f, -0.02520024f, -0.04603166f, -0.10923404f, -0.13148278f, 
    0.07237334f, -0.03950438f, -0.07941039f, -0.00247160f, -0.00487188f, -0.04111030f, -0.05137794f, 0.01646674f, 
    -0.01226906f, 0.04274521f, -0.08530990f, -0.06282002f, -0.08193445f, 0.05165496f, -0.05075562f, -0.12091224f, 
    -0.03194157f, -0.03266265f, -0.01535677f, -0.06239447f, -0.00804085f, -0.10788269f, 0.03409948f, 0.03178604f, 
    0.07708218f, -0.03846244f, -0.02633368f, -0.11453696f, -0.10730007f, 0.04112393f, -0.02638135f, 0.01474527f, 
    -0.01173561f, -0.08887602f, 0.08620038f, 0.03809447f, -0.08103190f, -0.06639110f, -0.03053370f, 0.02561604f, 
    0.09141937f, 0.27096277f, 0.42957163f, 0.07351465f, -0.45882300f, 0.14953330f, -0.33981150f, -0.12099475f, 
    0.12808053f, -0.10532698f, 0.07315408f, -0.02927477f, -0.30642390f, -0.45880485f, 0.08740184f, 0.10017665f, 
    0.32890546f, -0.01822387f, -0.05498331f, 0.06452832f, -0.37581462f, -0.20707431f, -0.22223249f, -0.18699177f, 
    0.25769365f, 0.00590416f, -0.15257035f, 0.08182510f, -0.03047244f, -0.33306161f, 0.06062939f, -0.19758090f, 
    -0.06986231f, -0.06444279f, 0.19712561f, -0.16393989f, 0.06856581f, -0.04364135f, 0.03525393f, 0.18721321f, 
    -0.01514730f, -0.18772884f, -0.25119224f, 0.07655768f, 0.02544346f, -0.08427809f, 0.17328219f, -0.31209561f, 
    0.09786338f, 0.05605647f, 0.29164281f, -0.28084165f, -0.00518358f, -0.02863791f, 0.31153664f, -0.07433644f, 
    -0.09538966f, -0.16411096f, -0.00538271f, -0.30820060f, -0.21754687f, 0.13587661f, -0.10424555f, 0.00058956f, 
    0.01519818f, 0.08587446f, 0.75390440f, 0.03454110f, -0.07610366f, -0.09846411f, 0.01814936f, 0.02302305f, 
    0.00217514f, 0.06444537f, -0.08373548f, -0.16026093f, -0.55654240f, -0.40699422f, 0.13844685f, -0.02877058f, 
    0.11484820f, -0.00081472f, 0.16620940f, -0.20867532f, -0.33139658f, 0.18930176f, -0.01148712f, -0.05030469f, 
    0.38124943f, -0.04274871f, 0.11656683f, -0.01569943f, -0.31574157f, 0.07307482f, 0.16868182f, 0.12712571f, 
    -0.39440227f, -0.23144095f, 0.03149668f, 0.24577034f, -0.29693428f, 0.15388757f, 0.01685495f, -0.33063897f, 
    -0.00455009f, 0.13116995f, 0.03612771f, 0.24206385f, -0.05330215f, -0.07418720f, 0.07191520f, -0.41621917f, 
    0.18391716f, 0.26903912f, -0.01221490f, -0.19334327f, -0.45453987f, -0.27799836f, 0.60216248f, 0.04877713f, 
    -0.31038412f, 0.19850801f, 0.14043374f, 0.14939423f, 0.18147762f, 0.20036259f, -0.02393481f, 0.00593788f, 
    0.28412482f, 0.00237649f, -0.07652488f, -0.00705326f, -0.01077124f, 0.17923284f, 0.10851441f, -0.35148808f, 
    -0.12677848f, 0.01114909f, 0.03657575f, -0.43579274f, -0.17981678f, -0.16277201f, -0.03715022f, -0.00676569f, 
    0.21365729f, 0.20995043f, 0.00366640f, 0.20382369f, -0.17780656f, -0.26610470f, 0.20718475f, -0.00385293f, 
    0.02527799f, -0.07151809f, 0.06434849f, 0.13803513f, -0.05715954f, -0.20554452f, 0.14537884f, -0.06652243f, 
    -0.14482588f, -0.01122214f, 0.21640210f, -0.20903601f, -0.04864983f, 0.06318849f, -0.37360588f, 0.05229044f, 
    -0.02696745f, -0.26638249f, 0.05001457f, -0.20610465f, 0.01735057f, -0.08372010f, 0.04143073f, -0.03884993f, 
    0.00358691f, -0.29681900f, 0.03919811f, 0.01820843f, 0.20944382f, -0.47728193f, -0.09563631f, 0.05749159f, 
    -0.45782998f, -0.30750611f, 0.03498353f, 0.11807248f, -0.05052746f, 0.13189705f, -0.27128279f, -0.02060940f, 
    -0.01905367f, -0.05140249f, -0.13277739f, -0.26966277f, 0.29756811f, 0.09756512f, -0.08062348f, 0.07037865f, 
    -0.39292485f, 0.11998113f, 0.05487373f, 0.09250360f, -0.47352728f, -0.16167489f, 0.05883355f, 0.08779024f, 
    -0.08883419f, 0.00797559f, 0.01962876f, -0.07400358f, -0.01625690f, 0.18661383f, -0.27243254f, 0.08763951f, 
    0.29815111f, -0.13913786f, 0.12256109f, 0.21784522f, -0.25377777f, 0.06212040f, 0.09440266f, 0.11879602f, 
    -0.30367401f, -0.02520823f, 0.05046601f, 0.10744289f, 0.04449968f, 0.18338475f, -0.06803163f, 0.16694739f, 
    -0.07435564f, 0.12393727f, 0.08097331f, 0.20869011f, -0.25998631f, 0.03565952f, -0.12264060f, 0.18358587f, 
    -0.07707394f, 0.17868143f, 0.00807653f, 0.07243814f, -0.15926790f, 0.03862403f, 0.14725187f, 0.06734157f, 
    -0.10571976f, 0.14063157f, 0.26137644f, 0.10002445f, -0.23120691f, 0.09803922f, 0.20401464f, 0.13432859f, 
    0.23038548f, 0.59042197f, -0.10031107f, -0.06013203f, 0.03805536f, 0.20411108f, -0.03762691f, -0.12307404f, 
    -0.13738254f, 0.00629937f, -0.08318509f, -0.22300395f, -0.03898934f, -0.15918104f, -0.41850641f, -0.04166061f, 
    0.25898027f, -0.01165372f, -0.04112488f, 0.14896108f, 0.19797209f, -0.06276926f, -0.03503210f, 0.16917236f, 
    -0.03269265f, -0.17281948f, -0.12772392f, 0.22323675f, 0.00877750f, 0.03465221f, 0.10110340f, -0.13809699f, 
    0.01482719f, -0.00532224f, 0.09600414f, -0.11547206f, 0.05247719f, 0.03297379f, -0.14951493f, 0.03554402f, 
    0.09388569f, 0.04104811f, -0.18762016f, -0.13255593f, -0.02256315f, -0.07441807f, 0.08615837f, 0.49202868f, 
    0.13626125f, 0.12365288f, 0.28159899f, 0.04266511f, -0.04072721f, -0.09792286f, 0.24660192f, -0.04567439f, 
    -0.20468496f, -0.12644976f, 0.15109576f, -0.15310974f, 0.30711493f, 0.03208531f, 0.14082927f, 0.26197231f, 
    0.03825743f, -0.03334521f, 0.21198188f, -0.09252147f, 0.21097831f, 0.04381508f, 0.06127200f, -0.03565177f, 
    -0.25369769f, 0.38952067f, 0.00370432f, -0.19869472f, -0.15587336f, 0.24272823f, 0.18937881f, 0.04340787f, 
    0.13635220f, -0.00914481f, 0.15759884f, -0.23314901f, -0.14230828f, -0.00830852f, -0.01993560f, 0.06090253f, 
    0.15161522f, -0.06864923f, 0.08817445f, -0.38377142f, -0.04193833f, 0.11072498f, 0.22255735f, 0.17591503f, 
    -0.13108486f, 0.13456471f, -0.01551295f, 0.09928360f, 0.30658615f, 0.08379122f, 0.07370485f, 0.02697677f, 
    0.00388576f, 0.07374642f, 0.12228874f, -0.10313808f, -0.23499094f, 0.11332569f, -0.35543633f, 0.01815233f, 
    -0.15397328f, 0.01756626f, 0.01665479f, -0.05409810f, 0.09349758f, -0.19006790f, -0.15566349f, -0.00096096f, 
    0.11541727f, 0.00390045f, -0.12634534f, -0.16237229f, -0.17702627f, 0.06157161f, -0.00397917f, 0.22145236f, 
    0.33025348f, 0.19607921f, 0.20590052f, 0.04239522f, 0.23320200f, 0.32686490f, -0.31445697f, -0.23325804f, 
    -0.09456671f, 0.08537134f, 0.07855756f, -0.23675865f, -0.05716797f, -0.24086541f, -0.38209781f, 0.02865592f, 
    0.25137344f, -0.07877578f, 0.04769202f, 0.18540819f, 0.00619682f, -0.09132214f, 0.15753561f, 0.25481170f, 
    0.08399704f, -0.13772786f, -0.31059042f, 0.11788535f, 0.00288807f, -0.05970275f, 0.09481236f, -0.14859259f, 
    -0.04394537f, -0.03900458f, 0.14822400f, -0.12209547f, -0.00455254f, -0.05827121f, -0.22094785f, 0.10979231f, 
    0.03816068f, -0.09035414f, -0.11276130f, -0.16790725f, -0.09189212f, -0.00172769f, 0.13772808f, 0.34430280f, 
    0.10631937f, 0.02912418f, 0.16602664f, 0.16484849f, 0.07281922f, -0.05264575f, 0.26097700f, -0.13092619f, 
    -0.21422921f, -0.36023328f, 0.19556206f, 0.01441345f, 0.24283743f, 0.14317311f, 0.24098258f, 0.30630291f, 
    -0.05145053f, -0.00237441f, 0.06140288f, 0.01707280f, 0.19845100f, 0.03556420f, 0.02692635f, -0.04853760f, 
    -0.07679726f, 0.40197760f, 0.04433880f, -0.17906834f, -0.40024045f, 0.26886413f, 0.13200389f, 0.14135027f, 
    0.14149721f, -0.02533929f, 0.11503369f, -0.38783208f, -0.19775145f, 0.13038434f, -0.11391257f, 0.02802791f, 
    0.40728411f, 0.05850913f, -0.01796444f, -0.31156865f, -0.12902012f, 0.15141633f, 0.12278144f, 0.09760076f, 
    -0.18951240f, 0.05230456f, -0.02111992f, 0.16247377f, 0.14091507f, 0.07543515f, -0.11007278f, -0.13721880f, 
    -0.13370098f, 0.01385774f, 0.00983816f, 0.00809433f, -0.06397985f, -0.05105142f, -0.19006296f, -0.03972224f, 
    0.06651866f, 0.02259347f, 0.05000109f, -0.24222986f, -0.14125662f, -0.25694960f, -0.06518776f, 0.05092391f, 
    0.16833605f, -0.03243172f, -0.05094127f, -0.08657154f, -0.28572145f, 0.26438496f, -0.02374346f, 0.15141658f, 
    -0.35120580f, 0.47655013f, 0.36143863f, 0.02799888f, 0.02402285f, 0.12261674f, -0.09731910f, 0.09504683f, 
    0.07618140f, 0.09856299f, 0.23192060f, 0.10165977f, 0.08303415f, 0.08218495f, 0.28047314f, 0.17904274f, 
    0.03806381f, -0.03338601f, 0.07948342f, -0.14173126f, 0.14451119f, 0.23051485f, -0.16011313f, -0.08759338f, 
    -0.14386068f, -0.06293403f, 0.02673455f, -0.12514600f, 0.05145558f, -0.10239214f, -0.15382844f, -0.15283991f, 
    0.02702436f, 0.28701556f, -0.10605045f, 0.26136726f, -0.04679184f, -0.05277553f, 0.17927775f, -0.09735861f, 
    -0.01321805f, -0.00571063f, 0.06996912f, 0.03938052f, -0.17907552f, -0.08342659f, -0.06274900f, 0.01150350f, 
    0.14767690f, 0.12856816f, 0.20517552f, 0.20781538f, -0.18891226f, 0.11983880f, 0.32977417f, 0.09678917f, 
    0.29760978f, -0.00519767f, -0.46279210f, -0.12410475f, -0.03967280f, -0.24650043f, -0.04217000f, 0.17481808f, 
    0.05380626f, -0.06380405f, -0.20491837f, 0.18787968f, -0.01692052f, -0.01393664f, -0.03060654f, 0.03218936f, 
    0.14332761f, -0.34202233f, -0.00821222f, 0.09976134f, -0.00865399f, 0.05619974f, -0.23474555f, -0.18512563f, 
    0.10207749f, -0.05414034f, 0.04797168f, 0.30454406f, -0.07621300f, -0.15519811f, -0.09431980f, -0.14836936f, 
    0.10818627f, 0.06360206f, -0.08044545f, -0.11257324f, 0.06090111f, 0.09526736f, -0.02470391f, 0.03326946f, 
    -0.02317178f, -0.00681651f, 0.02700045f, 0.04052157f, -0.26162431f, 0.03848036f, 0.15418246f, -0.10413485f, 
    -0.03886818f, -0.11828468f, -0.14456378f, -0.04373890f, 0.19235079f, -0.13807070f, -0.13459659f, 0.05988341f, 
    0.04461927f, 0.06955314f, -0.06219049f, -0.13344048f, -0.04825737f, -0.09583765f, 0.75450677f, 0.04225240f, 
    0.12212282f, -0.34738982f, 0.06065401f, 0.17560659f, -0.05242837f, -0.24766937f, -0.10003679f, -0.27926016f, 
    -0.30925471f, 0.32976863f, 0.24608634f, -0.08032258f, -0.08464801f, 0.13061430f, 0.02430231f, 0.17061903f, 
    0.06291972f, -0.14581163f, 0.04978852f, 0.11768788f, 0.05087984f, 0.02484660f, 0.04607178f, 0.09271858f, 
    0.23719044f, -0.38160238f, -0.08529337f, 0.04152758f, 0.06596289f, 0.14100118f, -0.40397647f, -0.25135866f, 
    0.19268844f, -0.17841372f, -0.05406845f, -0.15500945f, 0.01737823f, -0.33232468f, -0.15004498f, -0.09010786f, 
    -0.07574005f, 0.16767001f, -0.10778623f, -0.04561473f, -0.01319659f, -0.08144596f, -0.20867242f, 0.14351848f, 
    0.11257231f, 0.06515159f, -0.03362066f, 0.20152847f, -0.18203689f, -0.07065247f, -0.15645596f, -0.08585273f, 
    0.00375372f, 0.04485326f, 0.38502911f, 0.09101763f, -0.09201678f, 0.13526084f, 0.31191590f, -0.03455409f, 
    0.03987988f, -0.08097418f, -0.21181694f, 0.12003013f, 0.08338352f, -0.03251242f, -0.18819314f, 0.18436407f, 
    0.05208551f, -0.07738567f, 0.00531518f, 0.11509290f, -0.21536379f, -0.02790809f, 0.07905910f, 0.02528559f, 
    0.16711263f, -0.02833194f, 0.06632695f, -0.31154892f, -0.07940065f, -0.04711320f, 0.01121224f, -0.31620172f, 
    0.14213388f, -0.02847940f, 0.12528072f, -0.01749814f, -0.40869942f, -0.07623198f, -0.52376103f, -0.20841207f, 
    0.20388566f, -0.11149383f, -0.10900760f, 0.05172129f, 0.00035471f, 0.31798318f, -0.07556725f, -0.06621524f, 
    -0.14120322f, -0.12994064f, 0.07443137f, 0.07388768f, -0.32502958f, -0.04187543f, 0.08550467f, -0.05346710f, 
    -0.21256728f, -0.11041875f, -0.18759063f, 0.12104689f, 0.08173846f, -0.01882389f, -0.03402306f, -0.04022364f, 
    0.19155169f, 0.32417664f, 0.08122011f, -0.18816806f, -0.29976037f, 0.00276479f, 0.37196684f, -0.06636480f, 
    -0.27887487f, 0.10605606f, 0.05223504f, 0.16006875f, -0.43356597f, -0.09836262f, 0.01800533f, 0.01531003f, 
    0.03480066f, 0.03383079f, 0.04271239f, -0.04749881f, -0.05166124f, -0.02038269f, 0.02411813f, -0.05047472f, 
    -0.00692723f, -0.10449826f, -0.07185258f, 0.06194447f, 0.02653808f, 0.01352098f, -0.04236454f, -0.01463678f, 
    -0.00234676f, -0.08182956f, 0.00822286f, 0.00152856f, 0.00775288f, -0.05667025f, 0.00577688f, 0.03329835f, 
    -0.03768582f, -0.01154175f, -0.04590663f, -0.01441184f, -0.04557976f, -0.08856881f, 0.01332040f, 0.08799820f, 
    -0.00116250f, -0.03341684f, 0.08011214f, 0.00846549f, -0.06633355f, -0.03600369f, -0.01350739f, -0.07810792f, 
    0.03616720f, -0.08947389f, -0.01813726f, -0.01933848f, -0.02039820f, -0.07350098f, 0.04393476f, 0.00738035f, 
    -0.08110823f, -0.00267260f, 0.05936327f, 0.00597607f, -0.08388978f, 0.03493565f, 0.07444021f, -0.01033272f, 
    -0.04749910f, 0.02499706f, -0.06280952f, -0.06736682f, 0.05536519f, -0.02241658f, 0.04931870f, -0.00727943f, 
    0.01879761f, 0.08204161f, -0.03120135f, -0.11068013f, 0.01211377f, 0.02815091f, 0.05849833f, 0.07608397f, 
    -0.08568946f, 0.04006637f, 0.00055247f, -0.01665729f, -0.05045309f, -0.06473750f, 0.02215762f, -0.02885913f, 
    -0.08416387f, -0.06429211f, -0.09311090f, -0.02904385f, 0.01314217f, -0.06524485f, 0.06630010f, -0.08589990f, 
    -0.09326281f, -0.00115890f, -0.04666992f, -0.06978727f, 0.06615808f, 0.01962537f, -0.02152015f, -0.08865550f, 
    -0.01893974f, 0.01938657f, -0.00982382f, 0.03851220f, 0.01919812f, 0.03163496f, -0.05578158f, -0.04473381f, 
    -0.03154721f, -0.10430458f, 0.01345904f, 0.01715245f, -0.09937312f, 0.01327412f, 0.01457403f, 0.05291404f, 
    -0.04896224f, -0.01994176f, 0.05581569f, 0.00106328f, -0.00507564f, -0.07843020f, -0.05045274f, -0.04172852f, 
    0.03115655f, -0.05335193f, 0.02763468f, -0.05039508f, -0.01703322f, 0.02738013f, 0.08396617f, -0.06316068f, 
    0.03179931f, -0.33689868f, -0.06664862f, -0.06425563f, 0.00177238f, -0.13070419f, -0.10200620f, 0.15711451f, 
    0.04789872f, 0.03171634f, 0.08695967f, 0.10274069f, 0.05426308f, -0.04875805f, 0.02033147f, 0.02364456f, 
    0.03094225f, 0.06743610f, 0.06672335f, -0.04637064f, -0.05864291f, 0.11846328f, -0.16861193f, -0.10444409f, 
    0.15006457f, -0.09467661f, -0.04710054f, 0.08122013f, -0.00150062f, 0.10013854f, 0.03056915f, -0.05945035f, 
    0.03007343f, -0.01106885f, 0.24831091f, 0.07488403f, 0.04820157f, -0.01159400f, 0.33737674f, 0.04201323f, 
    -0.08931829f, 0.12562692f, -0.02471864f, 0.00731743f, 0.10968580f, 0.21955656f, 0.04891417f, 0.20487948f, 
    -0.10759787f, 0.12974481f, -0.02467063f, 0.00613813f, -0.03307240f, 0.19147712f, 0.10138647f, 0.08381239f, 
    0.02426534f, 0.12054010f, 0.00941689f, -0.09917180f, -0.19311766f, 0.07692188f, 0.25473368f, 0.16953148f, 
    -0.13695982f, -0.00499903f, -0.11886921f, 0.01614163f, -0.02097193f, 0.07802381f, -0.00646239f, 0.08038133f, 
    -0.02341833f, -0.14215802f, 0.02445636f, 0.20953436f, 0.22038679f, 0.35710490f, 0.13038090f, -0.05941168f, 
    0.13825482f, -0.00464553f, -0.00823480f, -0.12206288f, -0.12578978f, 0.03510463f, 0.47796735f, -0.04030119f, 
    -0.01001643f, -0.05715777f, 0.11231031f, -0.05853563f, 0.02933465f, -0.06292395f, -0.05139454f, -0.00562586f, 
    -0.02372837f, 0.16272539f, 0.06961226f, 0.10751582f, -0.14516817f, -0.05174058f, 0.06807496f, 0.06224559f, 
    0.05784031f, -0.07992157f, -0.03354172f, -0.18771151f, 0.11080056f, -0.05106858f, 0.11411504f, -0.20888659f, 
    0.15645860f, 0.07366388f, 0.02670383f, 0.27312577f, 0.12693025f, -0.03743970f, 0.05972857f, -0.11562091f, 
    0.05210167f, 0.07918266f, 0.03126457f, 0.00011830f, 0.46249232f, -0.07171550f, -0.10622312f, 0.08022203f, 
    -0.30849290f, 0.56463820f, 0.34315300f, -0.02796433f, 0.19765724f, -0.07504750f, -0.07625953f, 0.13446629f, 
    0.04741228f, 0.05692033f, 0.15068170f, 0.17280519f, 0.15861611f, 0.17840838f, 0.35751119f, 0.25626412f, 
    -0.14086214f, 0.01280856f, 0.06609892f, -0.15833604f, 0.09220963f, 0.22429213f, 0.11363920f, 0.10501704f, 
    -0.07524686f, 0.11790964f, 0.12906693f, -0.25818166f, -0.06657395f, -0.04032366f, -0.30269620f, -0.17611022f, 
    0.10443157f, 0.14022686f, -0.11404943f, 0.12179949f, 0.08669662f, -0.05152980f, 0.25940031f, -0.13925062f, 
    -0.00386433f, 0.05204473f, -0.00819397f, 0.41614848f, -0.31419387f, -0.22296494f, -0.16756858f, -0.20586669f, 
    0.13351357f, 0.12877895f, 0.16280523f, 0.16224450f, -0.28714922f, 0.29367962f, 0.24294215f, 0.04784342f, 
    0.26357445f, -0.01347477f, -0.45851839f, -0.01766883f, -0.15859333f, -0.17270601f, -0.02323113f, -0.05538230f, 
    0.03527145f, 0.01992573f, -0.02300298f, 0.06765415f, -0.24126594f, -0.06213594f, -0.00463260f, 0.03830927f, 
    0.05158754f, -0.49466053f, -0.07877186f, -0.10271294f, 0.06578157f, -0.26954180f, -0.26162472f, -0.09516229f, 
    0.33396029f, 0.05767575f, 0.19392475f, 0.28457782f, 0.01879855f, -0.24778183f, -0.02889336f, -0.26669255f, 
    0.05442078f, 0.08730472f, -0.30435699f, 0.03922417f, 0.14442252f, 0.07659929f, -0.04748302f, 0.00913501f, 
    0.04237263f, 0.08825811f, 0.09524742f, -0.09021598f, -0.36092848f, -0.08778873f, -0.00169872f, 0.02068864f, 
    -0.00834350f, -0.22205900f, -0.28415471f, -0.08073039f, 0.18981686f, -0.13616280f, -0.08954573f, 0.15026779f, 
    0.14533022f, 0.10806055f, -0.05696177f, -0.00669699f, 0.08889127f, -0.03639540f, 0.70508635f, 0.22597575f, 
    0.06012246f, -0.30648842f, -0.09836491f, 0.01745104f, -0.04541422f, -0.13357164f, -0.00463191f, -0.15354520f, 
    0.14368795f, -0.14185110f, 0.18099405f, 0.03022021f, 0.39461279f, 0.14161518f, -0.01857625f, -0.10138275f, 
    -0.16344221f, 0.10910553f, 0.05468333f, -0.09472650f, -0.18667676f, -0.16552649f, 0.00294372f, 0.00174816f, 
    -0.06449229f, 0.29414448f, 0.07960493f, 0.14859676f, 0.38671672f, 0.04723176f, 0.04517249f, 0.19051704f, 
    -0.33082068f, -0.04271281f, 0.02383596f, -0.03443696f, 0.08259245f, 0.15536243f, 0.06047812f, -0.05228549f, 
    -0.05571522f, 0.20119117f, -0.26951718f, 0.17354652f, 0.06679484f, -0.05414675f, 0.05927495f, -0.13076700f, 
    0.05508163f, -0.01989356f, 0.04117611f, -0.21158694f, -0.01132853f, -0.05412138f, -0.08964881f, 0.29450867f, 
    0.06983118f, 0.01240992f, -0.06254574f, 0.20368801f, 0.02988878f, -0.15305704f, -0.22654083f, -0.05964165f, 
    0.05439814f, -0.19613419f, -0.16629457f, 0.00194577f, 0.52610046f, -0.31079659f, 0.09859669f, 0.34285697f, 
    -0.03529672f, 0.07828367f, 0.04783341f, -0.01012596f, 0.62261218f, 0.03052929f, -0.00625319f, 0.07107683f, 
    -0.19676143f, 0.38160199f, -0.07828659f, 0.09511452f, -0.08736234f, -0.10538748f, -0.00905604f, 0.11540421f, 
    0.14325935f, -0.04453344f, -0.00838743f, 0.31174898f, -0.17709081f, -0.10788643f, -0.08669507f, -0.05266923f, 
    -0.02544947f, 0.12757766f, -0.13044430f, -0.29166344f, 0.15341696f, 0.11720669f, 0.06637107f, 0.12541106f, 
    -0.02623641f, 0.10546479f, 0.01198750f, -0.10743771f, 0.12338577f, -0.00672186f, 0.00459898f, -0.06894068f, 
    -0.08019870f, 0.00495444f, -0.15820147f, -0.09817224f, -0.10885854f, -0.21985535f, -0.27396551f, 0.20232865f, 
    0.01664476f, -0.02361416f, -0.01114692f, 0.17164530f, 0.29041836f, -0.04648569f, -0.24834073f, 0.30639046f, 
    0.24053815f, -0.05156140f, -0.18662432f, -0.11476551f, -0.31649876f, 0.22665626f, -0.31277415f, 0.14363612f, 
    0.09564003f, 0.03034982f, -0.16126300f, 0.07387045f, -0.36711392f, 0.04308370f, -0.15655048f, 0.16987097f, 
    0.23441204f, 0.01888853f, -0.10883164f, 0.17278560f, -0.01021455f, 0.10515248f, 0.10535397f, 0.07871107f, 
    -0.04658019f, -0.05570222f, 0.05250338f, 0.05914810f, -0.00479248f, 0.03172719f, -0.26434553f, -0.07482984f, 
    0.16787511f, -0.01195233f, 0.04999864f, 0.05140830f, 0.00437048f, -0.09435742f, -0.00411213f, -0.00508494f, 
    -0.06530228f, 0.07729089f, -0.26481870f, 0.01123249f, 0.03878701f, -0.03873476f, -0.04311390f, 0.28002664f, 
    -0.11479669f, 0.07239514f, 0.02452659f, 0.19963326f, -0.03611587f, -0.19445609f, -0.02543317f, -0.05054245f, 
    0.07292502f, -0.17910090f, 0.23160581f, -0.19412142f, 0.13607536f, 0.08259043f, -0.11471905f, 0.14348403f, 
    0.23434247f, 0.05666338f, 0.07909277f, 0.11379800f, 0.03713725f, 0.09141453f, -0.11372893f, -0.15481640f, 
    -0.00160565f, -0.09631083f, 0.52622175f, 0.11272564f, -0.44440788f, 0.17220142f, -0.03235212f, -0.06052579f, 
    0.08785275f, -0.15308428f, 0.05714300f, -0.12478617f, -0.01324250f, -0.11016081f, 0.01165963f, -0.02152042f, 
    0.04489411f, -0.01161252f, -0.02145435f, 0.07481556f, -0.31478626f, 0.08423286f, -0.01846561f, -0.18006669f, 
    0.10679200f, -0.13095383f, 0.01779277f, 0.12220716f, 0.03337627f, 0.22791600f, 0.04268716f, 0.10175259f, 
    -0.00977745f, -0.11182402f, 0.07252629f, 0.14268282f, 0.00112276f, 0.19142818f, 0.12377896f, -0.01182236f, 
    0.11098821f, 0.08972649f, 0.12027226f, -0.00502418f, -0.00862558f, -0.07966226f, 0.00737224f, 0.12583998f, 
    -0.13146962f, 0.20432155f, 0.05680393f, 0.13129428f, 0.00443379f, -0.12425904f, 0.36992264f, 0.09100111f, 
    -0.12131064f, 0.17471069f, 0.05300869f, 0.24430908f, -0.27525541f, -0.05104051f, 0.15296358f, 0.03502082f, 
    -0.08684652f, -0.47780070f, -0.40374988f, -0.05144182f, 0.06717368f, -0.09225421f, -0.11965434f, 0.11554123f, 
    0.11829025f, -0.14402577f, -0.12366574f, 0.07524812f, 0.08076674f, -0.18061538f, -0.15352346f, 0.25050953f, 
    0.11599458f, 0.00542999f, -0.01442437f, 0.00450817f, 0.01687621f, -0.14022531f, -0.04714646f, -0.03167798f, 
    -0.08381493f, -0.19974640f, -0.13559169f, 0.37833560f, 0.02394948f, 0.11517663f, -0.09026279f, 0.02639030f, 
    -0.08944396f, 0.03721657f, 0.27935374f, -0.20103176f, 0.03664834f, 0.00973691f, 0.18092254f, 0.06809823f, 
    -0.07838827f, 0.05135473f, -0.05577809f, -0.29087523f, 0.11431934f, 0.06313332f, 0.29110563f, 0.64039010f, 
    -0.02836738f, 0.25586462f, 0.19174613f, -0.08794265f, 0.04987779f, 0.09942541f, 0.40422538f, 0.04561269f, 
    -0.04946696f, 0.18856099f, 0.21396522f, -0.04650706f, -0.02318932f, 0.11719523f, 0.31833774f, -0.19461358f, 
    0.00891975f, -0.10335203f, -0.25814810f, -0.10329628f, -0.32823229f, 0.21475406f, 0.01754350f, -0.05615136f, 
    -0.26454937f, -0.10829919f, 0.06938102f, 0.08984619f, -0.02220141f, 0.11525781f, 0.09381255f, -0.16807382f, 
    -0.04561666f, -0.07353345f, 0.05282462f, -0.26758182f, 0.08745357f, -0.10671297f, 0.40033519f, 0.08658279f, 
    -0.06518769f, -0.03707950f, 0.23956704f, -0.06815881f, 0.10454703f, -0.04647211f, 0.08521825f, 0.06164234f, 
    0.22908582f, 0.08413517f, -0.01353050f, 0.18668190f, 0.14234455f, 0.02407284f, 0.17307335f, -0.10382548f, 
    0.09729296f, 0.04155977f, 0.24818760f, -0.17784041f, 0.02819801f, 0.04476713f, -0.04370621f, 0.01972931f, 
    0.01818803f, -0.17930171f, -0.07788333f, 0.02077193f, 0.22353747f, -0.12745567f, -0.26168540f, -0.23926833f, 
    0.13523644f, -0.06750517f, -0.11440856f, -0.06627643f, 0.59603053f, -0.07666246f, -0.17839184f, 0.02124659f, 
    0.25945807f, 0.34324017f, -0.07872119f, -0.04445977f, -0.21192482f, 0.19409359f, -0.08065171f, -0.41196677f, 
    -0.03802814f, 0.07507238f, -0.00400323f, -0.20965563f, -0.30898243f, -0.08730797f, 0.19723335f, -0.18148626f, 
    0.18883483f, 0.17743494f, -0.02581730f, 0.06709486f, -0.13814028f, -0.04444797f, -0.09076021f, 0.01731345f, 
    0.01367859f, 0.04306940f, 0.08337721f, 0.06666683f, -0.07971843f, 0.00061236f, 0.17101075f, -0.02909946f, 
    -0.08424131f, -0.04392100f, 0.01757219f, -0.01502595f, 0.00003027f, -0.04542536f, -0.06871984f, 0.12899874f, 
    -0.04728049f, 0.00280464f, 0.01785333f, -0.00229066f, 0.04108086f, -0.18944615f, 0.05881031f, -0.12523688f, 
    0.03285113f, -0.26060998f, 0.00871372f, -0.10369792f, 0.17975786f, -0.39042625f, -0.21033052f, -0.05045967f, 
    -0.33107448f, -0.18565869f, 0.05627777f, 0.23838046f, 0.12460253f, 0.21199650f, -0.13225982f, -0.08277448f, 
    -0.04054169f, -0.00601530f, 0.40607622f, -0.14346071f, -0.04603853f, 0.05682346f, 0.05016559f, 0.08334196f, 
    -0.40966010f, 0.04196775f, -0.05290910f, -0.13071983f, -0.10220096f, -0.25336614f, 0.08714305f, 0.22872156f, 
    0.02586799f, -0.02017245f, -0.37835154f, -0.01838930f, -0.42535260f, 0.35566682f, -0.07252769f, 0.10720565f, 
    0.37789309f, -0.24830917f, 0.23773317f, 0.00338786f, -0.20943694f, 0.08294236f, 0.10172327f, 0.10037059f, 
    -0.10923149f, 0.05261877f, 0.07268313f, 0.19211718f, 0.08442008f, 0.00541408f, -0.02217941f, -0.05357201f, 
    -0.15207829f, 0.06829677f, 0.10431648f, 0.03875067f, -0.39478001f, 0.03992928f, -0.24823427f, -0.06827852f, 
    -0.23034531f, 0.28207186f, -0.06700567f, -0.04316100f, -0.00080578f, -0.02758295f, 0.46985531f, 0.28302383f, 
    -0.07978306f, 0.23870039f, 0.27395192f, 0.23038287f, -0.16233186f, 0.10959561f, -0.09728629f, 0.01970013f, 
    0.03606325f, -0.04172077f, -0.26906729f, 0.03484591f, -0.14677402f, 0.23289521f, -0.07489786f, 0.19427298f, 
    -0.03075328f, 0.07145737f, -0.05635819f, 0.07921518f, 0.23497376f, 0.20548318f, -0.00135474f, 0.08419250f, 
    -0.20157219f, -0.00466671f, -0.01483798f, 0.06377028f, 0.12198021f, 0.09828373f, -0.07232491f, 0.02313401f, 
    0.13811694f, -0.04271639f, 0.02373834f, -0.00418561f, -0.05030712f, 0.04589451f, -0.03770255f, -0.14681864f, 
    -0.02890158f, 0.16377424f, 0.01144164f, -0.05264052f, -0.00599079f, 0.06818845f, -0.05454674f, 0.16479124f, 
    -0.14623632f, 0.00995326f, 0.01342235f, 0.14300317f, -0.08372165f, 0.73437786f, 0.04947881f, 0.19179773f, 
    -0.01249500f, -0.12441727f, 0.07734705f, -0.16654426f, 0.01954156f, 0.12036266f, -0.11708909f, -0.01907507f, 
    0.25343227f, -0.04918997f, 0.11431809f, 0.08679636f, 0.07953542f, -0.01343537f, 0.01401055f, -0.19994034f, 
    -0.06857274f, 0.00891911f, -0.55608356f, 0.14905471f, -0.41288340f, 0.08446153f, -0.04958837f, 0.04618185f, 
    0.04072943f, 0.01538692f, 0.06493669f, 0.43157303f, 0.02266977f, 0.15880609f, 0.10789468f, 0.07477047f, 
    -0.12845074f, 0.07568635f, -0.08992594f, -0.08976256f, 0.09961876f, -0.39164728f, -0.02254308f, -0.10227097f, 
    -0.12705350f, -0.16926588f, 0.11749413f, 0.12380222f, 0.00984388f, 0.03178155f, -0.01596232f, 0.01140672f, 
    0.12403039f, 0.04855319f, 0.03614217f, 0.12443341f, 0.09163205f, 0.19179125f, 0.02920618f, -0.06858028f, 
    0.12483103f, 0.09125137f, 0.04837538f, 0.10920703f, -0.03425692f, -0.12349098f, 0.42992368f, 0.19952050f, 
    -0.04413036f, -0.04206918f, 0.02380329f, 0.24573335f, 0.01631165f, 0.01707241f, -0.17233339f, -0.03862317f, 
    -0.10246120f, -0.09362324f, -0.13271718f, 0.11494450f, 0.00675682f, -0.13065438f, 0.28572533f, 0.14035828f, 
    0.17062797f, -0.23544729f, -0.27235264f, 0.01853565f, 0.42167154f, 0.08468156f, 0.02030568f, -0.02901981f, 
    -0.21975099f, 0.05100577f, 0.09415615f, 0.04549862f, 0.16706190f, 0.15985650f, -0.09235755f, 0.27300677f, 
    -0.05758354f, 0.20075163f, -0.06456052f, 0.00781089f, 0.07666191f, -0.10180154f, 0.48157993f, 0.10301708f, 
    -0.12491205f, -0.09067693f, -0.03565623f, 0.06139733f, 0.08603662f, 0.09719337f, 0.02981804f, -0.01140327f, 
    -0.06774558f, 0.01339685f, -0.03414701f, -0.07421808f, -0.17077938f, -0.01767128f, 0.03335613f, 0.10412986f, 
    -0.23215741f, -0.01612530f, -0.10904256f, -0.19850652f, -0.07191201f, 0.45408663f, 0.08857702f, 0.26343715f, 
    0.15296721f, 0.01090654f, -0.36540300f, 0.07478432f, 0.06399219f, -0.00457115f, -0.24831539f, 0.07966322f, 
    0.00337084f, 0.03209084f, -0.00033288f, -0.13381450f, 0.40325472f, -0.28202957f, 0.03467847f, -0.06431428f, 
    -0.14641352f, 0.03579011f, -0.71432894f, -0.11862129f, 0.17565675f, 0.19177169f, 0.00503511f, -0.04102143f, 
    0.07976054f, 0.24443334f, 0.08260803f, 0.36970094f, -0.10434145f, 0.00935502f, -0.01578787f, 0.07466481f, 
    -0.18197285f, -0.08319936f, -0.09569960f, 0.27878526f, 0.52126187f, -0.13816239f, -0.30771828f, -0.04425027f, 
    -0.12834880f, -0.11853675f, -0.11493076f, -0.09787995f, 0.21244547f, -0.13192773f, 0.19931330f, 0.11033215f, 
    0.04212219f, 0.13349442f, 0.01726070f, -0.14412689f, 0.17568116f, 0.03628007f, -0.10853298f, -0.04040487f, 
    0.15215474f, -0.03209110f, -0.24842545f, 0.11686059f, 0.11495721f, -0.13401383f, 0.36041364f, 0.33872253f, 
    -0.14928183f, -0.20190738f, -0.04335514f, 0.17174061f, 0.09546307f, -0.07711606f, -0.35397050f, 0.00192295f, 
    0.14532955f, -0.16775082f, -0.08084781f, -0.04664487f, -0.07637261f, 0.27871192f, 0.08843248f, -0.00720457f, 
    -0.06517663f, -0.33666590f, -0.18197894f, -0.05363906f, -0.37562823f, 0.18620358f, -0.16156198f, 0.01354869f, 
    0.14821246f, -0.30456933f, 0.02791652f, 0.07276946f, 0.15545192f, 0.35291591f, -0.02406909f, 0.14304784f, 
    0.00141695f, -0.15270002f, -0.08661851f, -0.19211945f, 0.04592013f, 0.06521484f, 0.17490183f, -0.22438423f, 
    0.04859169f, -0.05894509f, -0.16896856f, 0.11400279f, 0.07585360f, -0.00678812f, -0.28776857f, -0.23738733f, 
    -0.12351654f, 0.04317838f, 0.17137307f, 0.11776811f, -0.03031915f, 0.03668369f, 0.16959931f, -0.08847089f, 
    -0.03444199f, 0.19919318f, -0.15062112f, 0.00522174f, 0.06404275f, -0.31997487f, 0.05120765f, -0.01984013f, 
    -0.12410103f, -0.04205827f, 0.17388611f, -0.18452807f, -0.20722307f, 0.09874754f, 0.14319801f, 0.04293685f, 
    0.23659751f, 0.15159345f, -0.25440297f, -0.12403036f, -0.23098770f, 0.10660192f, 0.09750003f, -0.17700584f, 
    0.12172347f, -0.13351469f, 0.06763913f, 0.15337305f, 0.03999142f, 0.07141221f, -0.06239255f, -0.05248905f, 
    0.00479631f, -0.39060637f, 0.05750461f, -0.29090226f, 0.07399337f, 0.27639365f, 0.07586017f, -0.39157844f, 
    0.00306518f, 0.02192673f, -0.18214138f, 0.06364305f, -0.31119668f, -0.01452800f, 0.23777126f, -0.14804655f, 
    0.02130825f, -0.06161137f, 0.03969226f, -0.20859891f, -0.00054262f, -0.00927936f, -0.08536306f, -0.10462826f, 
    0.17455132f, -0.09197221f, 0.05267485f, 0.28686276f, -0.15287372f, -0.09016004f, 0.15438800f, -0.13850059f, 
    -0.07098122f, -0.01852248f, 0.16568024f, -0.09468123f, 0.22851546f, 0.01933374f, -0.33683586f, -0.35703418f, 
    -0.27888861f, 0.18639877f, 0.02113525f, -0.28574839f, 0.19644971f, -0.20889206f, 0.07644714f, 0.10485151f, 
    0.06140152f, -0.32483104f, -0.00380664f, 0.17601617f, 0.07124580f, -0.33075756f, -0.09090654f, -0.33496362f, 
    -0.08922794f, -0.26743418f, -0.11815509f, 0.05718400f, 0.06280357f, 0.10233295f, -0.05844596f, 0.08747489f, 
    0.11521104f, -0.03454771f, -0.05074453f, 0.11984241f, 0.05970916f, 0.06060920f, -0.14962934f, 0.11508941f, 
    -0.08882805f, -0.06754754f, -0.06249974f, 0.00855154f, 0.00861041f, -0.05390032f, -0.34760311f, -0.08137064f, 
    0.04200494f, -0.01576332f, 0.03627066f, 0.16729490f, 0.02757837f, 0.11865757f, 0.02734190f, 0.10125662f, 
    -0.08656836f, -0.06250449f, 0.19214556f, 0.00295090f, 0.09909658f, 0.03615468f, 0.02516530f, -0.04077464f, 
    0.03415211f, 0.13579331f, -0.00188067f, 0.16861242f, 0.04811632f, -0.20714229f, 0.10337163f, 0.29328585f, 
    -0.04351537f, 0.28736374f, 0.22447926f, -0.11512511f, -0.07888822f, 0.02760567f, 0.41847721f, 0.00911836f, 
    -0.08221819f, 0.20055677f, 0.17615320f, -0.04499444f, -0.09539507f, 0.08975093f, 0.33913806f, 0.17727588f, 
    0.11693414f, 0.01600734f, -0.38664022f, -0.01522856f, -0.45240539f, 0.04778711f, 0.02261550f, -0.01983708f, 
    0.20373212f, 0.00009565f, -0.06735611f, -0.19898759f, 0.00395688f, 0.12473799f, -0.08883089f, 0.00891407f, 
    0.10983597f, 0.02744144f, 0.17182113f, -0.08544312f, -0.10582909f, 0.07693827f, 0.00899109f, -0.01708917f, 
    -0.02429624f, 0.07878835f, 0.09485039f, 0.05805531f, 0.05386345f, 0.01150901f, -0.04240340f, -0.04121353f, 
    0.12574843f, 0.01663737f, -0.04518212f, 0.14002031f, -0.04516223f, 0.05453025f, 0.11336975f, 0.01238110f, 
    0.13646963f, 0.08167273f, 0.01150986f, -0.08580524f, 0.05207834f, 0.13133691f, -0.16300185f, 0.07515260f, 
    0.09527923f, 0.08959801f, -0.09827760f, -0.12792365f, 0.00862977f, -0.08811864f, -0.26968524f, -0.29061428f, 
    0.13410202f, -0.13047914f, -0.17249492f, 0.00589385f, 0.17157365f, -0.01319219f, 0.08282943f, -0.07265968f, 
    0.21033080f, 0.45739248f, -0.26526427f, 0.04293082f, 0.08331748f, 0.17817160f, -0.24332376f, -0.11152849f, 
    0.01502431f, 0.11778396f, -0.12703441f, -0.09764645f, -0.08648036f, -0.07197121f, 0.00781311f, 0.10415172f, 
    0.04049874f, 0.08983333f, -0.01158360f, 0.02706591f, 0.15704966f, -0.18504238f, 0.35543725f, -0.01144747f, 
    0.07454583f, -0.08643193f, -0.08074728f, 0.19097084f, -0.03705473f, -0.06941432f, 0.09980083f, -0.23306733f, 
    -0.06007021f, 0.05299231f, 0.07026310f, 0.07105880f, 0.06934188f, 0.05262423f, -0.00855782f, 0.16841933f, 
    -0.21314846f, -0.06026860f, -0.10741923f, 0.04556376f, -0.05444181f, -0.18132277f, 0.22182912f, 0.26996368f, 
    0.13112959f, -0.07380626f, 0.09300243f, -0.18775532f, 0.21880656f, -0.15638377f, -0.06371154f, 0.09888033f, 
    -0.32000712f, -0.02798261f, 0.21587215f, 0.16818631f, 0.05275546f, 0.15033416f, -0.09292084f, -0.13677531f, 
    -0.03001814f, 0.07349049f, 0.17107244f, -0.27641436f, -0.24391004f, 0.15379967f, 0.04832142f, 0.04448707f, 
    -0.33255073f, 0.10888713f, -0.01763955f, -0.25918147f, -0.29626334f, -0.05039160f, 0.18954305f, 0.18807541f, 
    0.00760887f, 0.05585431f, -0.13753159f, -0.03869736f, -0.08006786f, 0.09181295f, -0.13393717f, 0.12357797f, 
    0.34717456f, -0.17521255f, 0.17441694f, -0.11497256f, 0.08434866f, 0.09429152f, 0.09503081f, 0.18538594f, 
    -0.06560573f, -0.04684518f, 0.01971832f, 0.14943089f, 0.16244775f, 0.03035332f, 0.02388414f, -0.09285649f, 
    0.06587540f, 0.01345558f, -0.00776873f, -0.08267475f, -0.15729071f, 0.07035207f, -0.18423606f, 0.07682056f, 
    -0.16134900f, 0.16783923f, -0.00648497f, -0.00575829f, 0.02610681f, -0.09215529f, 0.12028121f, 0.19358164f, 
    -0.06134854f, 0.18398438f, 0.19816683f, -0.05538001f, -0.18055521f, 0.04681137f, 0.23399487f, 0.06548481f, 
    0.16453975f, 0.44483393f, -0.13521262f, 0.03211358f, -0.15991659f, 0.26214457f, -0.03284262f, -0.04299856f, 
    -0.00337872f, 0.12955464f, 0.03418672f, -0.05122184f, 0.15729360f, 0.05502079f, 0.18230303f, 0.01249304f, 
    0.15741050f, -0.05577648f, 0.02804031f, -0.11234390f, 0.01625396f, -0.02077689f, 0.09779308f, -0.11522400f, 
    0.27882132f, 0.01011419f, 0.07491130f, -0.08032051f, -0.05268544f, -0.11162087f, -0.01801023f, -0.08148555f, 
    0.11425851f, -0.02612482f, -0.07843865f, -0.04963809f, 0.04517651f, -0.02673529f, -0.19798677f, 0.31251454f, 
    -0.15836847f, -0.02297434f, 0.06757488f, 0.05772955f, 0.00343470f, 0.53657448f, 0.12797800f, -0.34037679f, 
    0.08125705f, -0.32672435f, -0.12059821f, -0.15372671f, 0.25020924f, -0.08474324f, -0.04595003f, 0.07295409f, 
    -0.16358693f, -0.14941612f, -0.00034139f, 0.04993111f, -0.18383086f, 0.02197772f, -0.43460795f, -0.26495028f, 
    -0.02834794f, 0.06109902f, 0.26509929f, -0.01831465f, 0.00671522f, -0.04885302f, -0.08994468f, 0.03795579f, 
    0.13290372f, 0.09637741f, 0.03030470f, 0.07378527f, -0.07517839f, -0.16976146f, 0.15120836f, 0.04596315f, 
    -0.19073436f, 0.06354989f, -0.22303949f, 0.11263712f, -0.01255239f, 0.11518620f, -0.02980233f, 0.02769189f, 
    0.06916593f, -0.19564454f, 0.14359044f, 0.16772307f, -0.04336907f, 0.11682895f, 0.12402425f, -0.04075979f, 
    -0.00094903f, 0.02587574f, 0.01320676f, 0.12024886f, -0.05604035f, 0.21150786f, -0.02040470f, 0.04571614f, 
    -0.11764669f, 0.11828604f, -0.02395942f, 0.19417226f, -0.00663251f, -0.08576070f, 0.17036228f, 0.08901466f, 
    -0.06302764f, 0.28689528f, 0.03233430f, 0.12097958f, -0.19620873f, 0.10708465f, 0.59746504f, 0.12981129f, 
    -0.22713448f, 0.23032673f, 0.44302267f, 0.31939304f, -0.20076358f, 0.19342975f, 0.19956420f, -0.17464682f, 
    0.00711322f, -0.34678891f, 0.29565123f, 0.07629238f, 0.08523399f, 0.03450870f, -0.15486658f, -0.00374776f, 
    -0.07021104f, 0.25089884f, -0.00369427f, 0.01671092f, -0.08284716f, -0.07926122f, -0.14866252f, -0.14618090f, 
    -0.33313015f, 0.01996385f, 0.07109372f, 0.21174571f, -0.11901440f, -0.04553297f, -0.00180810f, 0.20940296f, 
    0.02028440f, 0.21024095f, -0.03833865f, -0.16907854f, -0.06568024f, 0.13622743f, 0.16869999f, -0.13198446f, 
    -0.16087306f, 0.01918250f, -0.14267881f, 0.19518387f, 0.18676132f, 0.07971820f, 0.11280980f, -0.03970275f, 
    0.05974643f, -0.04731244f, -0.01254728f, 0.07718400f, -0.06190442f, 0.22376946f, -0.05735635f, -0.26547855f, 
    0.10889614f, 0.01660688f, 0.01023732f, 0.14140411f, -0.05091994f, 0.05204691f, -0.04974557f, -0.15161750f, 
    0.12046085f, 0.09186783f, 0.02634049f, -0.12172452f, 0.40970412f, -0.04767529f, 0.15783581f, 0.24652182f, 
    -0.01708261f, -0.04479863f, 0.08887519f, -0.03205035f, -0.02487735f, 0.02152495f, -0.05892203f, 0.00670077f, 
    0.03839020f, 0.21688259f, 0.00649630f, 0.32284984f, 0.14040521f, 0.05171980f, 0.02920831f, 0.18589213f, 
    0.30200508f, -0.02942940f, 0.19308195f, 0.04969177f, 0.16541906f, -0.09848464f, -0.07906051f, 0.08569262f, 
    -0.03561654f, 0.10394424f, 0.00929187f, -0.17716701f, -0.01943105f, 0.07014900f, 0.06140158f, 0.13587473f, 
    0.00345523f, -0.00720993f, -0.07128381f, -0.11372671f, -0.19789757f, -0.00806615f, -0.12771869f, 0.01349596f, 
    0.02315896f, 0.10783599f, -0.00906710f, 0.02035835f, -0.13090391f, -0.12377015f, 0.22025540f, -0.04992686f, 
    0.30660653f, -0.03668035f, -0.03892302f, 0.16222689f, 0.07047453f, -0.10938094f, -0.11616900f, 0.02682592f, 
    0.33751816f, 0.13860811f, -0.05356580f, -0.08182561f, 0.01234249f, 0.05545512f, 0.08006023f, 0.25001729f, 
    0.00610349f, -0.12452864f, -0.46176952f, 0.00685316f, 0.09507733f, 0.15346223f, 0.00268727f, 0.12487180f, 
    -0.03550849f, -0.00395959f, -0.03510872f, 0.06560146f, 0.03756587f, 0.13778602f, -0.23533097f, 0.00886550f, 
    -0.07556546f, -0.28017500f, 0.04301788f, -0.20551178f, -0.29395539f, 0.01568178f, 0.28379446f, 0.22647955f, 
    0.02115929f, 0.15214850f, -0.06735917f, 0.00331630f, -0.01253614f, -0.04674661f, -0.11776767f, -0.06164210f, 
    0.06254657f, -0.10263809f, 0.05538695f, -0.00746857f, -0.60313874f, 0.04881621f, 0.11888846f, -0.33200702f, 
    -0.03261853f, -0.14242876f, 0.05924968f, 0.05081275f, -0.10756161f, 0.25144291f, -0.27999765f, 0.20393920f, 
    0.04001795f, -0.24962841f, -0.03067692f, -0.20828921f, -0.20697933f, 0.03588232f, 0.04316053f, -0.01994156f, 
    -0.05672946f, 0.04850216f, 0.01814840f, -0.04219857f, -0.27292669f, 0.06125345f, 0.11036403f, -0.12378150f, 
    -0.05058410f, 0.12192662f, -0.03509142f, -0.07100993f, -0.02959582f, -0.12996869f, 0.03613793f, -0.02881974f, 
    0.03209531f, 0.01419225f, 0.03668538f, 0.33570391f, 0.07422467f, 0.23070833f, -0.20568161f, 0.04236748f, 
    -0.30667129f, 0.05774092f, -0.03432006f, -0.03933567f, 0.30300501f, 0.38849762f, 0.10569423f, 0.08852040f, 
    -0.18737964f, -0.09457295f, -0.03947970f, -0.03920603f, -0.00562628f, -0.46024963f, -0.12517165f, -0.35381046f, 
    0.03050774f, -0.00930484f, 0.06155430f, -0.08844154f, 0.13401987f, 0.11241740f, -0.25238180f, -0.02404001f, 
    0.01455196f, -0.18435805f, -0.00751421f, -0.00799331f, 0.19365130f, 0.11734493f, 0.15261385f, 0.11451109f, 
    -0.17833939f, 0.09422059f, -0.08447754f, 0.33792737f, 0.16325036f, -0.00778380f, -0.19782773f, -0.18408325f, 
    0.07747632f, 0.02388925f, 0.14916791f, -0.17854963f, -0.14273635f, -0.08062179f, 0.21650051f, -0.16113950f, 
    0.04484564f, -0.52955186f, 0.07011411f, 0.06575787f, 0.23614645f, -0.00069703f, 0.06425153f, 0.04680741f, 
    -0.11347149f, -0.03233618f, 0.06810217f, -0.00385044f, 0.03690830f, -0.11144873f, -0.11845705f, 0.00133790f, 
    -0.07495728f, 0.24855849f, -0.00784846f, 0.11868709f, 0.01458598f, -0.00959735f, 0.20866773f, 0.23291394f, 
    -0.23070888f, 0.03051975f, -0.11190352f, 0.20538190f, 0.05904854f, 0.16290845f, 0.11261766f, 0.09136765f, 
    -0.11185232f, 0.14160949f, 0.06359218f, 0.05389471f, 0.09243908f, 0.06296133f, 0.19088395f, -0.04679672f, 
    0.13184784f, -0.02249910f, -0.08746797f, -0.22446078f, 0.07668548f, 0.10446497f, 0.10945477f, 0.19544411f, 
    0.07706819f, 0.23933250f, -0.02101095f, 0.19908369f, -0.01042056f, 0.18761954f, 0.04689493f, -0.02678468f, 
    0.09092849f, 0.07734515f, 0.09112196f, -0.11850550f, 0.40167925f, -0.02790305f, 0.26617870f, 0.27807692f, 
    -0.00965795f, -0.04221147f, -0.47012949f, 0.08068599f, -0.04123107f, 0.08636666f, 0.06240726f, -0.05048785f, 
    0.03822665f, 0.27481672f, -0.07537606f, 0.39864135f, -0.13103865f, 0.18498270f, 0.06960942f, 0.01706050f, 
    0.01111404f, -0.05215466f, 0.20848772f, -0.04118513f, 0.24788500f, -0.21440266f, 0.12123621f, 0.14039353f, 
    -0.21641804f, 0.15747541f, -0.08383512f, 0.04236023f, 0.13109908f, 0.01547276f, 0.05102023f, 0.02535062f, 
    0.00518267f, 0.09849688f, -0.01925696f, 0.04856633f, 0.20359021f, 0.12484370f, 0.04850103f, -0.00100112f, 
    0.09870368f, 0.06122765f, 0.24133952f, 0.00196819f, -0.06611615f, -0.00101082f, -0.06202204f, 0.07094603f, 
    0.22442333f, -0.12130050f, -0.02069429f, 0.09390195f, 0.03039603f, 0.07676374f, -0.27426142f, -0.15187943f, 
    0.36729419f, -0.21723038f, -0.26361030f, -0.08809098f, 0.22730607f, 0.08983818f, -0.15652038f, 0.04401401f, 
    -0.05704870f, -0.36524490f, 0.34084734f, 0.00500438f, -0.06167974f, -0.28077528f, -0.04426630f, 0.07402485f, 
    0.02095128f, 0.08044232f, 0.18210080f, 0.02697383f, -0.10103007f, -0.06782999f, -0.04684935f, -0.29684693f, 
    0.01755924f, 0.21374977f, 0.05788912f, 0.15110125f, 0.12937243f, 0.10574954f, -0.31568983f, -0.04413158f, 
    0.16000178f, -0.15549567f, 0.00445704f, -0.03101321f, 0.07931796f, 0.08398325f, 0.07230475f, 0.08139105f, 
    0.02413967f, -0.00414694f, 0.09749780f, -0.03191918f, 0.08909565f, 0.01974839f, 0.23782475f, -0.01021981f, 
    0.08023427f, 0.09370394f, 0.12281103f, -0.03432774f, 0.21678838f, 0.43567243f, -0.08608318f, -0.21168846f, 
    -0.16961291f, 0.09567541f, -0.06181658f, 0.13941999f, -0.08466534f, 0.13436136f, -0.13652690f, -0.14903679f, 
    0.12624593f, 0.02562080f, -0.10847378f, -0.00098935f, 0.06122849f, 0.08106430f, 0.15200205f, 0.05239437f, 
    -0.03340529f, -0.03968415f, 0.83101743f, 0.15086940f, 0.17211674f, 0.08252772f, -0.05318113f, 0.03614118f, 
    -0.19681601f, -0.05375939f, 0.02625484f, 0.47844237f, 0.12515023f, 0.15212400f, 0.26615226f, -0.00658103f, 
    0.06206467f, 0.04336228f, 0.00358527f, -0.05580847f, -0.12146058f, 0.13791144f, 0.44497824f, 0.00653854f, 
    -0.10089698f, 0.01597804f, 0.11680081f, -0.06470998f, -0.16947389f, -0.03160951f, -0.11149831f, -0.03867054f, 
    0.01306500f, 0.07013659f, -0.05507426f, 0.11197330f, -0.21096657f, -0.13530800f, -0.02671736f, -0.01782905f, 
    0.06004883f, 0.08094506f, 0.16735935f, -0.14164636f, -0.13985868f, -0.09054001f, 0.28544527f, -0.48015532f, 
    0.33727399f, 0.03541752f, -0.04652985f, 0.14728449f, 0.15477826f, 0.05996706f, 0.30784535f, 0.09360351f, 
    -0.00443848f, 0.10055897f, 0.16031747f, -0.03477823f, 0.53872973f, -0.06071724f, -0.34062669f, 0.11722302f, 
    0.04188930f, 0.04743565f, 0.05580943f, -0.02207543f, -0.08743567f, -0.03424311f, -0.06406430f, 0.03764792f, 
    0.06291807f, -0.02696976f, 0.06608998f, -0.04339295f, -0.04789294f, 0.03588546f, 0.01732946f, 0.02631517f, 
    0.00767262f, -0.01331468f, 0.05766705f, -0.01321011f, 0.07027955f, -0.02729286f, 0.00378681f, -0.09294981f, 
    -0.07315866f, 0.02414247f, -0.05322906f, -0.01911755f, 0.01146048f, -0.03788550f, 0.00644862f, -0.08664109f, 
    0.01412042f, 0.02881938f, -0.05768487f, 0.04098107f, 0.04356204f, -0.00587545f, 0.03051884f, -0.05025627f, 
    -0.05363848f, -0.02147226f, -0.08711335f, -0.07369341f, -0.00029359f, 0.04208353f, -0.00090107f, -0.03897537f, 
    -0.02182660f, -0.03870593f, 0.04787437f, 0.00128759f, -0.08712241f, -0.07148524f, 0.01392965f, 0.01762036f, 
    0.07515193f, 0.02089649f, 0.00506764f, -0.07683693f, 0.00847026f, -0.05509699f, -0.07344304f, 0.00861415f, 
    -0.03523182f, -0.00276127f, 0.03571528f, 0.03629724f, -0.01719946f, -0.06447335f, -0.06531377f, -0.08049911f, 
    0.01080308f, 0.02827268f, -0.01133682f, 0.08298686f, -0.08770101f, 0.00033944f, 0.01087148f, 0.06038335f, 
    0.00483900f, -0.02695791f, 0.07032567f, -0.07580972f, -0.09197097f, -0.00703989f, -0.08685057f, -0.06397952f, 
    -0.04409156f, 0.02510813f, 0.03455972f, -0.05679476f, 0.03571504f, -0.03916921f, 0.06453139f, -0.07824967f, 
    -0.01281379f, -0.01949768f, 0.04292347f, 0.03339626f, -0.02106259f, 0.02052841f, -0.07837476f, -0.05466554f, 
    -0.08381046f, -0.08738796f, 0.06386709f, -0.04032553f, 0.03775479f, -0.06167480f, 0.05564867f, -0.08682704f, 
    -0.06482862f, -0.03398151f, 0.04146465f, 0.07832140f, 0.05972262f, -0.01452275f, 0.01783356f, -0.08667387f, 
    0.05369341f, 0.06517240f, -0.00577783f, 0.03664479f, 0.03348936f, 0.03341980f, 0.00531312f, 0.06999664f, 
    0.32118142f, -0.25466144f, -0.32796904f, -0.08593401f, -0.13519210f, 0.14261381f, -0.10822475f, 0.02502191f, 
    0.09190535f, -0.04603392f, 0.01586904f, 0.06754285f, -0.02118452f, -0.02557482f, 0.07364939f, 0.09717406f, 
    0.21257962f, 0.07554694f, -0.00853415f, -0.07622793f, 0.22980951f, 0.08717707f, 0.05562738f, -0.02277463f, 
    -0.01433393f, -0.07660163f, 0.04148857f, 0.23212148f, 0.00868147f, 0.16205789f, 0.16458227f, -0.07520528f, 
    0.04858272f, 0.19114301f, 0.00724417f, -0.10055547f, -0.01417683f, 0.07001337f, 0.14460556f, 0.05442096f, 
    0.04353285f, 0.12890041f, 0.01879239f, -0.13634415f, 0.37635544f, 0.06124171f, 0.22816692f, 0.69826299f, 
    -0.09027150f, -0.00881403f, 0.07567323f, -0.03909232f, 0.18118921f, -0.00048001f, -0.17142990f, 0.04173349f, 
    0.11221047f, 0.08748688f, 0.05814899f, 0.00628242f, 0.17679901f, 0.25061297f, 0.11585785f, -0.13271026f, 
    -0.02668568f, -0.00986669f, -0.14047170f, 0.06739685f, -0.57456577f, 0.13543600f, 0.04176431f, 0.05479810f, 
    -0.17375147f, 0.04033711f, 0.05366440f, 0.20680492f, -0.03162890f, 0.14528462f, 0.41357374f, -0.09773480f, 
    -0.27029634f, 0.08060331f, -0.08121848f, 0.05805681f, -0.07013556f, -0.35552257f, 0.32136375f, 0.17104937f, 
    -0.07728679f, -0.05429846f, 0.12744765f, -0.04352479f, 0.03490542f, 0.02497560f, -0.05552662f, 0.12364234f, 
    0.15885022f, 0.18646716f, -0.09244775f, 0.21367724f, 0.39758649f, 0.13437396f, 0.25043014f, -0.03899271f, 
    0.15924565f, 0.13823558f, 0.23978741f, -0.00668741f, -0.17630655f, 0.04347681f, 0.07381106f, 0.02582433f, 
    -0.23447396f, -0.01115324f, -0.09017362f, 0.14085549f, 0.26608387f, -0.14327744f, -0.47121745f, -0.13342033f, 
    0.16542692f, -0.29409111f, 0.02169736f, 0.20084202f, 0.08180432f, -0.16636615f, -0.28516668f, 0.09328345f, 
    -0.06992128f, -0.61056083f, -0.29681203f, -0.01462914f, -0.05337711f, -0.01371995f, -0.14915958f, 0.17467627f, 
    0.06862234f, -0.02726610f, 0.00017424f, 0.03918785f, 0.06571032f, -0.09330164f, 0.00108828f, 0.10310885f, 
    -0.26247230f, 0.02526334f, -0.01276772f, 0.02997498f, -0.09782822f, 0.03673401f, 0.11876654f, 0.13332804f, 
    -0.07855664f, 0.17707029f, 0.02005923f, 0.13618927f, 0.01105187f, 0.22391647f, -0.03047400f, -0.09759591f, 
    -0.16877557f, 0.08097909f, -0.11802967f, 0.15021895f, 0.11193895f, 0.08335758f, 0.33444139f, -0.00332885f, 
    0.07285254f, 0.03435081f, -0.09742515f, -0.04245927f, -0.09295180f, -0.02373080f, -0.05050227f, 0.07751155f, 
    -0.05058751f, 0.11906885f, 0.08818168f, -0.11059751f, 0.04938279f, 0.13112727f, 0.07930672f, 0.01507413f, 
    0.22148575f, 0.08476106f, 0.02192170f, -0.13084874f, 0.23099169f, 0.01507920f, 0.37788031f, 0.02818682f, 
    -0.00344774f, -0.03974834f, -0.07283407f, 0.09276546f, -0.47393036f, 0.05914188f, -0.02278440f, -0.05088380f, 
    -0.04265789f, -0.02634336f, 0.02691632f, 0.05755002f, -0.00485585f, 0.29414341f, 0.11923108f, -0.00828138f, 
    0.20329657f, -0.03535600f, -0.07036207f, -0.10766581f, 0.10196940f, -0.07259181f, 0.30207059f, -0.04796818f, 
    -0.18483990f, -0.03207293f, -0.03769823f, -0.09870487f, 0.11448731f, 0.03387909f, 0.02264554f, 0.12217367f, 
    0.11149326f, -0.03703298f, 0.01707832f, 0.04285433f, 0.04606985f, -0.09495658f, -0.01750934f, -0.06612650f, 
    0.03644228f, 0.12958966f, 0.20205964f, -0.18419334f, -0.02857047f, -0.03525439f, 0.03695447f, -0.03130836f, 
    0.03250806f, -0.00507730f, -0.03429401f, 0.09675760f, 0.33106500f, -0.30247766f, -0.19133493f, 0.02153280f, 
    0.38363963f, -0.09867426f, -0.16120699f, -0.02428095f, 0.19867264f, -0.05271630f, -0.08788290f, 0.04015520f, 
    -0.03236527f, -0.06464443f, -0.01764510f, 0.05404473f, -0.02691036f, -0.03135403f, -0.03778663f, -0.12441728f, 
    -0.12228526f, 0.04697594f, -0.06277882f, -0.05317377f, -0.07633253f, -0.02288173f, 0.00707192f, -0.02798724f, 
    -0.02104375f, -0.06612001f, 0.06629766f, -0.07472775f, 0.01169395f, 0.01018146f, 0.07204444f, 0.04371526f, 
    0.05077774f, -0.10923577f, -0.06434304f, -0.08437102f, -0.02805478f, -0.01603940f, -0.06751540f, 0.04432574f, 
    -0.01715202f, -0.03766385f, 0.01181638f, -0.12313753f, -0.06283461f, 0.03785124f, -0.00397702f, -0.06313901f, 
    -0.00802363f, -0.08888154f, -0.06404125f, -0.07274988f, -0.02941160f, -0.07141431f, 0.03546851f, 0.03891918f, 
    -0.08013851f, 0.05317829f, -0.00379547f, 0.04010576f, -0.06334493f, -0.05248762f, 0.02070499f, 0.04344474f, 
    -0.06868234f, -0.12227145f, 0.03359441f, -0.05401134f, -0.01275249f, 0.02749704f, 0.01660613f, 0.04470664f, 
    0.01966144f, 0.07617547f, 0.04590045f, -0.11717251f, 0.05619701f, -0.04801084f, 0.01679746f, -0.00380298f, 
    0.05368771f, -0.02372825f, -0.08588780f, -0.01582264f, -0.02569118f, -0.00877417f, -0.04915063f, 0.01431102f, 
    -0.04148172f, -0.02689688f, -0.09863537f, -0.09893662f, 0.07833489f, -0.06666150f, 0.02686181f, 0.02408648f, 
    -0.06105464f, 0.02897083f, 0.06055974f, -0.05120249f, -0.10485885f, 0.04200182f, -0.05596188f, -0.09192377f, 
    0.01806361f, -0.04038633f, 0.04220188f, -0.02445913f, -0.06083504f, 0.04405399f, 0.01376475f, -0.01939468f, 
    0.01944317f, 0.01642694f, -0.06462540f, -0.05361648f, -0.04814928f, -0.08158641f, -0.02032485f, 0.02850067f, 
    -0.00438094f, 0.01468632f, -0.04670952f, -0.00412191f, -0.07559834f, -0.08884802f, -0.03874821f, 0.03227961f, 
    -0.11246865f, -0.00888570f, 0.04973410f, -0.04759260f, -0.04738831f, 0.02966767f, 0.02632611f, -0.07262063f, 
    0.06806678f, 0.56868023f, -0.10248008f, -0.00127812f, -0.40974057f, -0.04047322f, -0.54082870f, -0.15678413f, 
    0.18655083f, -0.00892214f, -0.07245014f, 0.09640193f, -0.19013084f, -0.15641224f, 0.13427180f, 0.06877657f, 
    0.09686229f, -0.12706985f, 0.04970262f, 0.00544316f, -0.13298361f, -0.16657266f, -0.11181588f, -0.17654859f, 
    0.32416183f, -0.03080241f, -0.04226416f, 0.05623451f, -0.04773331f, -0.31640288f, -0.03246418f, -0.34087554f, 
    -0.36140180f, -0.00240771f, -0.03081582f, -0.12530889f, 0.09500444f, 0.05634004f, 0.02480038f, 0.14090109f, 
    0.07298284f, -0.00777749f, -0.07355139f, 0.11684901f, -0.11718389f, -0.06516870f, 0.10746887f, -0.05749530f, 
    -0.00815287f, -0.09444964f, 0.13293386f, -0.39920202f, 0.14874548f, -0.26375240f, -0.07819483f, -0.03148280f, 
    -0.35295433f, -0.15849213f, 0.03510605f, 0.13889354f, 0.01764033f, 0.22639838f, -0.13408323f, -0.09432425f, 
    0.00027550f, 0.07532609f, 0.76443785f, -0.11391994f, -0.16548595f, 0.02095774f, 0.04423455f, 0.04995538f, 
    0.05937252f, -0.12189399f, 0.03838395f, -0.40861225f, 0.02340619f, 0.12754270f, 0.00966324f, -0.00735560f, 
    0.08492368f, -0.06885073f, -0.16914691f, -0.17293338f, -0.50550479f, 0.27497113f, -0.06347848f, -0.02934969f, 
    0.24674024f, -0.15921867f, 0.17915589f, 0.01726077f, -0.30314437f, 0.11698043f, 0.10541373f, 0.09227958f, 
    -0.35737908f, -0.25350302f, -0.08005564f, 0.02135609f, -0.06453115f, 0.08230663f, 0.01816388f, -0.17367338f, 
    0.10235976f, 0.03839804f, -0.14134359f, -0.19417328f, 0.06276362f, 0.17845240f, 0.05039912f, -0.20307779f, 
    -0.17119558f, 0.21742415f, 0.00254863f, 0.01080684f, -0.23785600f, -0.07919163f, 0.37885517f, 0.19076927f, 
    -0.33004868f, 0.15410818f, 0.21892297f, 0.14497170f, 0.04501862f, 0.18487224f, 0.07802005f, -0.05401149f, 
    -0.05710382f, -0.02745749f, 0.00283669f, 0.02194022f, -0.10985941f, -0.02315797f, -0.00424094f, -0.05890574f, 
    -0.08523247f, -0.07017246f, 0.06381478f, 0.00483652f, 0.04989721f, -0.09216997f, -0.04644717f, 0.00323033f, 
    -0.00972690f, -0.10075050f, -0.08223858f, -0.05315155f, -0.12659462f, 0.04276911f, 0.00279626f, 0.07747401f, 
    0.07711757f, -0.05022525f, -0.07961555f, 0.01436852f, 0.07008450f, -0.03281290f, -0.00895431f, -0.01333008f, 
    -0.10311929f, -0.05541949f, -0.00055592f, 0.01197536f, 0.01399869f, -0.06066582f, -0.09497073f, -0.00783248f, 
    0.06038166f, 0.04080462f, -0.08667202f, -0.09334120f, -0.06487916f, 0.03905329f, -0.04753025f, -0.05789456f, 
    -0.01161754f, -0.02208173f, 0.08957361f, 0.06322070f, 0.03644511f, -0.06689175f, -0.05716730f, -0.01881440f, 
    -0.02751005f, -0.03421438f, -0.05412592f, 0.01829952f, -0.08805324f, 0.03100444f, -0.03304197f, 0.06009334f, 
    -0.07412039f, 0.08098432f, -0.09253049f, -0.08876621f, 0.07622883f, -0.02652042f, -0.03783320f, 0.03052185f, 
    -0.15792954f, -0.09585740f, -0.06694993f, -0.05627791f, 0.03392427f, 0.07477876f, 0.06112674f, -0.00111730f, 
    0.05334087f, 0.00077945f, 0.08836507f, 0.02102431f, -0.11735117f, 0.02090115f, -0.04181971f, 0.03842133f, 
    -0.05878782f, 0.03252872f, 0.02349039f, 0.03912038f, -0.13406281f, -0.01968746f, -0.09849825f, -0.07374489f, 
    -0.08820089f, 0.01005370f, -0.00205702f, -0.00627668f, -0.05093560f, -0.01968557f, 0.00840626f, 0.06110055f, 
    -0.10574748f, 0.03927539f, 0.02700352f, -0.07954930f, 0.03909777f, 0.03488018f, -0.00103405f, -0.08516733f, 
    -0.01370519f, -0.01208722f, 0.08071931f, -0.11130237f, -0.08437356f, -0.07490281f, 0.06201355f, -0.02604234f, 
    0.02825998f, -0.03957431f, -0.07229271f, 0.10185878f, -0.11466305f, -0.00193009f, -0.08272257f, -0.06232634f, 
    -0.16308667f, 0.30878672f, -0.11807273f, 0.08416838f, -0.31422263f, 0.24850830f, -0.06253798f, 0.06094344f, 
    0.06487592f, -0.07337845f, -0.12853235f, -0.00004770f, 0.14879473f, 0.02736096f, -0.07444067f, 0.07091979f, 
    0.10088400f, -0.28635374f, 0.03271659f, 0.00876798f, 0.07164021f, -0.02174006f, -0.37480161f, -0.04939390f, 
    0.10501238f, 0.09539542f, -0.08460236f, 0.19128120f, 0.06224673f, -0.14067270f, -0.03213018f, -0.11933175f, 
    -0.04453852f, -0.05321496f, 0.18585567f, 0.02452296f, 0.13204572f, -0.08994755f, -0.21796151f, 0.14843781f, 
    0.09901058f, 0.11243670f, 0.01205764f, 0.16301943f, -0.12233283f, -0.36630416f, -0.06668823f, 0.09083929f, 
    0.14743346f, -0.03372629f, 0.23076735f, -0.01652508f, 0.04408844f, 0.14392684f, 0.25845462f, -0.01858982f, 
    0.06645130f, 0.00420718f, 0.01574076f, 0.12998779f, -0.48516655f, 0.17832717f, 0.19232716f, 0.22952409f, 
    -0.08358794f, -0.08454712f, -0.33201459f, 0.10566959f, -0.24259405f, -0.07818708f, 0.01247581f, 0.00070020f, 
    0.03095281f, -0.15507768f, 0.03241466f, -0.58320123f, -0.03664090f, -0.09750849f, -0.07070058f, -0.06429128f, 
    0.17585172f, 0.04070583f, 0.11035153f, -0.12432265f, -0.22917931f, 0.24128635f, -0.15465198f, -0.00163266f, 
    0.06418454f, -0.06931553f, 0.03851838f, 0.05447099f, -0.01072992f, 0.02111565f, 0.00767150f, 0.00951898f, 
    0.00152085f, 0.02941422f, 0.11653924f, 0.21016948f, 0.03819637f, 0.08358464f, -0.02336502f, 0.01705721f, 
    -0.10938118f, -0.03443701f, -0.00683089f, 0.01422571f, 0.11881384f, 0.05760458f, -0.22927858f, 0.06196980f, 
    -0.13663185f, 0.23181826f, 0.01639329f, -0.17695403f, -0.03345969f, 0.04416706f, 0.04985031f, -0.32078916f, 
    -0.02450086f, 0.13673267f, 0.00288721f, 0.10404570f, -0.28827551f, -0.14561203f, 0.23621315f, 0.13575871f, 
    -0.23399197f, 0.42088759f, 0.47871998f, 0.03398542f, 0.31667075f, 0.02621694f, -0.11955944f, 0.18283750f, 
    0.07160629f, -0.04227529f, 0.13119066f, 0.19596951f, 0.20627260f, -0.01882829f, -0.10663068f, 0.33056819f, 
    -0.00945363f, 0.01384612f, -0.01838551f, -0.13312703f, -0.03820980f, -0.11888596f, 0.55909687f, 0.20551412f, 
    -0.09850778f, 0.06307837f, -0.10543067f, 0.01461677f, -0.05857350f, 0.04442271f, -0.15641035f, -0.07158208f, 
    -0.02488017f, -0.04324014f, -0.02999151f, 0.14303812f, 0.07481147f, -0.05219918f, 0.11770696f, -0.22536230f, 
    0.11301392f, 0.06348347f, -0.15486087f, -0.03873124f, -0.17149268f, -0.06680948f, 0.03910374f, 0.17796953f, 
    0.14135960f, 0.29931605f, 0.07542948f, 0.17724460f, -0.21978307f, 0.25879961f, 0.40560147f, 0.13028030f, 
    0.12440535f, 0.33651763f, 0.08632472f, -0.19533911f, -0.44516665f, -0.05468178f, 0.15752880f, -0.06269991f, 
    0.19875661f, 0.15555184f, -0.30723053f, -0.01175850f, -0.09426825f, -0.07958338f, -0.00723219f, -0.02630081f, 
    0.13026175f, -0.73872554f, 0.01876646f, -0.37499622f, -0.07860388f, 0.06741486f, -0.34919134f, -0.15821299f, 
    0.09577323f, 0.00988312f, 0.24273427f, 0.12372852f, 0.33857769f, -0.08275101f, -0.11501877f, 0.02075436f, 
    0.04368686f, 0.19513406f, -0.01892627f, -0.21055765f, 0.22023410f, -0.17414416f, -0.28756535f, -0.09337083f, 
    0.13126421f, 0.01746847f, -0.06012147f, 0.04415395f, -0.03933766f, 0.00917747f, 0.00982345f, -0.10530830f, 
    0.03201418f, -0.05152034f, -0.10096445f, 0.05883709f, 0.24736489f, 0.02600349f, -0.07948577f, 0.25155076f, 
    -0.03992799f, -0.02778906f, 0.04794106f, -0.35041720f, -0.02774360f, -0.08005286f, 0.07679566f, -0.27489063f, 
    0.28497002f, -0.16515574f, -0.14567441f, -0.12426233f, -0.12071491f, -0.40604967f, 0.06815273f, -0.03341695f, 
    0.00170091f, 0.02774153f, -0.08200201f, -0.08637796f, -0.09912495f, -0.08934917f, -0.00143391f, -0.10216529f, 
    -0.04477355f, -0.00600538f, -0.03944243f, -0.11456881f, -0.05146578f, -0.01985165f, -0.04355492f, -0.02393383f, 
    -0.07490604f, -0.01607564f, -0.03975387f, 0.03610563f, -0.07838185f, 0.02066243f, 0.02396298f, 0.02711615f, 
    -0.06403305f, -0.00805253f, 0.07497618f, -0.02430158f, -0.04896425f, -0.07269623f, -0.06705028f, 0.02051245f, 
    -0.03270400f, -0.02244210f, 0.02831400f, -0.00726595f, -0.09775640f, 0.01627363f, -0.03949825f, -0.02064872f, 
    -0.06794053f, -0.03164340f, -0.03143533f, -0.01257642f, 0.01634406f, -0.00642478f, 0.05321114f, 0.01977252f, 
    -0.09300765f, 0.02471307f, -0.00367468f, 0.03281379f, 0.03114902f, -0.00953118f, 0.05588040f, -0.10888857f, 
    0.00888400f, 0.04005478f, -0.01700778f, -0.03786166f, 0.03552529f, -0.04534195f, -0.08346859f, 0.00154372f, 
    -0.05442791f, 0.01525437f, 0.06247113f, -0.09651892f, 0.09809511f, -0.08589767f, -0.04060063f, 0.00323402f, 
    0.00439840f, 0.06936435f, -0.03202734f, -0.05594870f, 0.02475393f, 0.00497538f, -0.08723104f, -0.01911139f, 
    0.06059997f, -0.08249734f, 0.01267837f, -0.03988997f, -0.02049418f, -0.01889477f, 0.00946150f, 0.02117817f, 
    -0.06631751f, 0.00108947f, 0.06997871f, -0.08934224f, -0.08447157f, 0.02047737f, -0.00820161f, 0.05355490f, 
    0.04757200f, -0.05556468f, -0.06224468f, -0.07912510f, -0.04731434f, 0.05857048f, -0.01462214f, 0.05123936f, 
    0.04162361f, -0.09174290f, -0.02020878f, -0.06992419f, -0.06989060f, -0.09242542f, 0.03676367f, -0.10766592f, 
    -0.08364642f, -0.02394257f, -0.05078565f, -0.10339562f, -0.08378665f, -0.02726226f, 0.03339291f, 0.09420414f, 
    -0.07585414f, -0.06248068f, 0.06394188f, -0.00561672f, -0.05349897f, -0.03725970f, -0.09840472f, -0.01915312f, 
    0.15079728f, -0.09187437f, 0.24523841f, -0.05741141f, -0.41119057f, 0.15649061f, 0.13715105f, -0.17537014f, 
    0.12190416f, -0.08351275f, 0.14996991f, -0.05224643f, 0.04666069f, 0.05366120f, -0.09022675f, -0.00208111f, 
    0.25159666f, 0.00513014f, -0.00098947f, 0.17697214f, -0.25649288f, -0.00554339f, -0.13438433f, -0.04763678f, 
    0.26679665f, -0.15788922f, -0.37023798f, 0.05292531f, 0.01258782f, -0.33216661f, 0.02734125f, -0.01370734f, 
    0.10193872f, 0.07885093f, 0.22836775f, -0.00560277f, 0.02640582f, 0.08390080f, -0.16716553f, 0.10757694f, 
    0.18248193f, 0.02303542f, -0.25165319f, 0.06978019f, 0.12838729f, -0.10387948f, 0.20196244f, -0.17691147f, 
    0.11357614f, -0.00502818f, 0.46333390f, -0.23270854f, -0.00630225f, 0.03320198f, 0.39308220f, -0.19504534f, 
    -0.02153525f, -0.04442935f, -0.05972502f, -0.17969927f, -0.00945036f, 0.17814422f, 0.14901549f, 0.20800360f, 
    0.14320563f, -0.06183374f, 0.85856056f, 0.33293158f, 0.07385150f, -0.11756909f, -0.01930135f, 0.04541785f, 
    -0.02399913f, 0.08482948f, -0.08428623f, -0.17014547f, 0.09314647f, 0.26705122f, 0.21266337f, -0.21801972f, 
    0.16413653f, -0.04852610f, 0.13630523f, -0.39271015f, -0.54637086f, 0.23169340f, 0.08578452f, 0.09737355f, 
    0.39768898f, -0.04264857f, 0.15931699f, -0.19362648f, -0.32750165f, 0.16108826f, 0.05967335f, -0.01387238f, 
    -0.28380451f, -0.06648635f, 0.03777786f, 0.30038542f, -0.32607883f, 0.04671706f, 0.07287094f, -0.27656716f, 
    -0.21622513f, 0.12021739f, 0.26884761f, 0.24250522f, -0.04706857f, -0.07466228f, -0.22637120f, -0.60619849f, 
    0.25911227f, 0.23151603f, -0.10121324f, -0.11955386f, -0.42976630f, 0.00190666f, 0.56210154f, -0.06723572f, 
    -0.03631676f, 0.23394725f, 0.13855357f, 0.14666057f, 0.06725255f, 0.01064122f, -0.07748368f, -0.06913906f, 
    0.06960205f, 0.01232933f, 0.04232548f, -0.05987867f, -0.07151284f, 0.05877776f, -0.03850066f, 0.00219696f, 
    -0.08124929f, 0.01435222f, -0.08522934f, 0.07145939f, 0.07393575f, -0.06979640f, 0.06026810f, 0.05025891f, 
    -0.06481589f, 0.05030698f, 0.02372158f, -0.07200871f, -0.05524240f, -0.08974902f, 0.01747253f, -0.05358988f, 
    -0.00382634f, 0.06690990f, -0.08138924f, -0.05000922f, -0.06291948f, -0.07984515f, -0.01191469f, 0.06188050f, 
    -0.08145040f, 0.00613688f, -0.06270355f, -0.08247799f, -0.04429468f, 0.03614360f, -0.00491309f, -0.06994752f, 
    0.00668227f, 0.02986294f, 0.05430871f, -0.07463609f, -0.05811954f, 0.03169765f, 0.08364499f, -0.05977735f, 
    -0.02924410f, -0.05417862f, 0.08309777f, -0.04348639f, -0.00152269f, -0.09892453f, 0.07669460f, -0.00301735f, 
    0.06780151f, -0.04816793f, 0.00703179f, -0.06901896f, 0.03401170f, -0.00546414f, 0.06949039f, 0.05175654f, 
    -0.05967250f, -0.05658333f, -0.08011147f, -0.05074163f, -0.07710108f, 0.02856088f, -0.07300616f, -0.07513153f, 
    0.05286940f, 0.00560302f, -0.08115232f, -0.06773121f, 0.06502490f, -0.04091122f, 0.02105041f, -0.06066825f, 
    0.00439133f, 0.07808306f, -0.09223592f, 0.04069401f, -0.06359416f, -0.00001984f, -0.04906511f, 0.00088525f, 
    -0.00517086f, 0.05933357f, 0.02905262f, 0.04822167f, -0.09539517f, -0.01168020f, -0.03899991f, -0.04784091f, 
    0.05505844f, 0.06526039f, 0.08681893f, -0.06018143f, -0.05157838f, 0.02292623f, 0.00428611f, 0.01286927f, 
    -0.00854462f, -0.08311190f, -0.07958827f, -0.09504753f, 0.03954772f, 0.05423039f, -0.07171710f, -0.00496986f, 
    -0.01167364f, 0.07054216f, 0.03099908f, -0.08356609f, -0.04191653f, -0.01910331f, 0.06931618f, -0.02452161f, 
    0.05790893f, 0.03673990f, -0.06910148f, -0.07558910f, 0.00353724f, 0.07802483f, -0.08770556f, 0.08125889f, 
    -0.10473506f, -0.00099659f, 0.00234237f, -0.06257728f, -0.02033083f, 0.02171241f, 0.05404801f, 0.01525621f, 
    -0.02016750f, -0.12037003f, 0.04926482f, -0.07752299f, -0.00454065f, 0.02266473f, -0.06928331f, -0.03002928f, 
    -0.08012730f, 0.04680116f, 0.07498903f, -0.02371724f, 0.07911260f, 0.03303319f, -0.00945222f, 0.01173152f, 
    -0.01166407f, -0.07662240f, 0.02384493f, 0.05137644f, -0.03883398f, -0.00814367f, 0.02323982f, -0.00376546f, 
    -0.01052408f, -0.06197614f, -0.00941907f, -0.03505072f, -0.00472785f, -0.04819122f, -0.03040057f, -0.05435818f, 
    0.04483343f, -0.06570525f, 0.03968909f, -0.00448186f, 0.00405232f, 0.05622287f, -0.08840165f, -0.07126840f, 
    0.02666211f, -0.06796042f, 0.03882449f, -0.02547116f, -0.06350016f, -0.03911272f, 0.03901970f, 0.07154743f, 
    -0.02283924f, -0.01553646f, 0.03210841f, 0.01721485f, -0.02238496f, -0.00191239f, -0.10038668f, -0.05724387f, 
    0.04552090f, 0.07100351f, -0.04758729f, -0.07045526f, -0.07322297f, -0.03053856f, -0.01566552f, 0.00072638f, 
    -0.09040529f, -0.02549928f, -0.04818679f, 0.02655631f, -0.05999729f, 0.04303299f, -0.07814674f, -0.02808755f, 
    -0.10323437f, 0.06365547f, 0.07452274f, -0.00242380f, 0.04732505f, -0.00875366f, -0.00935228f, -0.00883199f, 
    -0.08162943f, 0.02594065f, -0.01469186f, -0.05410389f, -0.07260393f, -0.10138297f, -0.07236370f, -0.11597379f, 
    0.00034745f, 0.06224777f, 0.00303322f, 0.00290938f, -0.09655488f, -0.01350255f, 0.04090768f, -0.08544726f, 
    0.05909904f, 0.00102303f, -0.08026195f, -0.08216412f, 0.01657296f, -0.01685675f, -0.03487739f, -0.08222012f, 
    -0.06204184f, -0.07379724f, -0.08298030f, 0.05118222f, -0.00425734f, -0.00217648f, -0.01622608f, 0.05614570f, 
    0.00951465f, -0.07810967f, -0.07633591f, 0.05128010f, -0.06855465f, -0.01874762f, 0.00614400f, -0.09161717f, 
    -0.37136549f, -0.26687267f, 0.07600944f, -0.05928690f, -0.06675325f, 0.10153009f, -0.22974905f, 0.16036575f, 
    -0.00805441f, 0.09272902f, -0.05486901f, 0.12249099f, -0.00015900f, -0.19477013f, -0.15632641f, -0.05800932f, 
    -0.25894907f, -0.11354201f, -0.06892120f, 0.04140728f, 0.03969864f, 0.13171422f, -0.28871191f, 0.26347658f, 
    0.18931036f, 0.19412480f, -0.16009970f, -0.13259356f, 0.06632990f, 0.07927536f, 0.08191939f, -0.23398532f, 
    0.11400507f, 0.02858812f, -0.05124994f, 0.16162394f, 0.02979555f, -0.08083221f, -0.01360792f, -0.05802386f, 
    0.11372311f, 0.00645162f, 0.03650614f, 0.28555804f, -0.07449810f, -0.42220068f, -0.20994082f, -0.32162282f, 
    0.07266323f, 0.25233465f, 0.16977642f, 0.02576382f, -0.00607220f, 0.11957881f, 0.19104432f, -0.23672113f, 
    0.11376345f, -0.03205736f, 0.10167507f, -0.04348151f, -0.00355500f, -0.21356447f, 0.22967951f, 0.23117472f, 
    -0.14477603f, 0.02863971f, -0.45672607f, 0.19605522f, -0.19350524f, -0.11648402f, 0.02057554f, 0.06422579f, 
    0.05059778f, 0.02806090f, 0.06337997f, -0.14570603f, 0.00773794f, -0.03676026f, 0.07458144f, 0.22506921f, 
    0.26706499f, 0.08051524f, 0.27666968f, -0.13679715f, 0.12561509f, 0.05502184f, -0.25562790f, 0.14191712f, 
    -0.01195697f, 0.00787546f, -0.09027675f, -0.11686789f, 0.01215064f, 0.09041573f, -0.11799894f, 0.10886548f, 
    -0.02540442f, 0.05650105f, -0.01819659f, -0.18737276f, -0.30003503f, -0.01268697f, -0.07042029f, 0.01898361f, 
    -0.08182682f, 0.15411380f, -0.06990255f, 0.01185180f, -0.07635435f, 0.03825962f, 0.02123117f, 0.07183582f, 
    0.15980630f, 0.17781329f, 0.00398943f, -0.08641104f, -0.07067420f, -0.14230184f, -0.19129126f, -0.15868662f, 
    0.23144375f, -0.02983654f, 0.05896401f, 0.05897297f, -0.16258405f, -0.08560697f, 0.28725377f, 0.02503682f, 
    -0.23543470f, 0.14849730f, -0.21422300f, 0.02185033f, -0.11697559f, 0.16891579f, 0.05914690f, -0.00422988f, 
    -0.04781927f, -0.13504647f, 0.08471034f, 0.08881743f, -0.09447126f, 0.12892799f, 0.07936615f, 0.18127801f, 
    0.23700203f, 0.13059771f, 0.02878630f, -0.19168754f, 0.09706032f, 0.00704450f, 0.25342777f, -0.00248411f, 
    -0.29264235f, 0.10344472f, 0.10714920f, 0.19741479f, 0.06604578f, -0.01581095f, -0.09501821f, 0.14675780f, 
    -0.07072899f, 0.00051054f, -0.02473720f, 0.11554180f, -0.07516810f, 0.02759866f, 0.10429233f, 0.06861648f, 
    0.07782602f, 0.12043758f, -0.02388086f, -0.17249468f, 0.16091791f, -0.44339186f, 0.16585559f, 0.07276721f, 
    0.03631271f, -0.20049573f, 0.00107954f, 0.03160879f, 0.00249736f, 0.06415658f, 0.22314844f, 0.16221984f, 
    -0.01575593f, 0.08640482f, -0.03972652f, 0.01086264f, -0.19837324f, 0.09096372f, -0.05731623f, -0.14484446f, 
    0.14286202f, 0.04183574f, 0.00746757f, 0.15432355f, -0.15776573f, 0.06364407f, 0.06586828f, 0.04979902f, 
    -0.04511492f, -0.02727961f, -0.03756123f, -0.23173364f, -0.03631396f, -0.13542460f, -0.06266389f, -0.04764314f, 
    -0.06054700f, -0.07511091f, -0.02025188f, 0.16156037f, -0.06017024f, -0.25460425f, 0.02181839f, 0.00918325f, 
    -0.09514298f, 0.17096996f, 0.08458501f, 0.11514354f, 0.05944828f, -0.06137593f, 0.00760670f, -0.04257254f, 
    0.20777394f, 0.02216337f, 0.07476551f, 0.22548509f, 0.14184520f, 0.07609684f, 0.19340764f, -0.05417289f, 
    -0.07089258f, 0.16724706f, 0.11007304f, 0.07644936f, 0.00726360f, 0.19833291f, -0.33672163f, 0.08191321f, 
    -0.21070933f, -0.20893881f, 0.11426851f, -0.03851300f, 0.09229538f, 0.05426945f, 0.01929631f, -0.11455366f, 
    0.05275353f, -0.02836541f, 0.01295424f, 0.12680763f, -0.11298381f, -0.02371692f, -0.17534840f, -0.05843749f, 
    0.19607235f, -0.16092457f, 0.21439829f, 0.05016518f, 0.05121461f, 0.04481929f, -0.31232473f, 0.08421662f, 
    0.03521927f, 0.25884759f, -0.01330600f, -0.05175479f, -0.08001927f, -0.13405399f, 0.40200439f, -0.03262113f, 
    -0.18906967f, 0.23373748f, 0.05229476f, 0.25666970f, -0.09175704f, 0.14310052f, -0.02475083f, 0.12814958f, 
    0.05303930f, 0.03573293f, 0.01969096f, -0.25036770f, 0.02056114f, 0.06663973f, 0.15051271f, -0.50708526f, 
    -0.08664750f, 0.26623929f, -0.27541655f, 0.12395882f, 0.17917009f, 0.04008573f, 0.19065915f, 0.18392143f, 
    0.10477764f, -0.11523176f, 0.03165029f, 0.06474313f, 0.02013810f, -0.01123637f, -0.06460660f, -0.13868865f, 
    -0.01414678f, -0.04022946f, 0.04618360f, 0.23038538f, 0.08981197f, 0.01423856f, -0.40085450f, -0.05835615f, 
    0.19607438f, -0.04783779f, -0.11283586f, -0.10951833f, 0.54944539f, -0.12102597f, -0.07825620f, 0.00038117f, 
    -0.17149785f, -0.08760865f, 0.74006039f, 0.11858048f, 0.27290338f, 0.15864654f, 0.00520742f, 0.04866646f, 
    0.02506304f, 0.09228153f, -0.02891956f, 0.30333912f, -0.02712023f, -0.10398870f, 0.00139902f, 0.07737898f, 
    0.22661160f, 0.09073876f, 0.00613766f, 0.19521551f, -0.21880829f, 0.09193188f, -0.04554667f, -0.13789652f, 
    0.09759216f, 0.04830158f, -0.04349155f, -0.07247126f, 0.04147855f, 0.21423699f, 0.09142526f, 0.10406761f, 
    -0.16198444f, 0.15733673f, 0.01909710f, -0.14480697f, -0.24983667f, 0.05127374f, -0.04704366f, -0.10232175f, 
    0.04236262f, 0.11300870f, -0.08324905f, -0.01911350f, -0.11972789f, -0.40530369f, 0.04586978f, -0.00796882f, 
    0.10837460f, 0.09214935f, -0.05105007f, 0.35184714f, 0.10568208f, -0.32890767f, 0.25984910f, 0.58442879f, 
    0.08243845f, 0.11272135f, -0.00173876f, 0.22933683f, -0.09473856f, 0.02524024f, -0.13435693f, 0.18883602f, 
    0.12179415f, -0.28478065f, 0.30598205f, -0.06355249f, 0.33575600f, -0.14323603f, -0.40779102f, 0.16514967f, 
    -0.11990031f, -0.14982356f, 0.05802073f, 0.09631259f, 0.10835255f, -0.07481129f, -0.14650764f, 0.14582849f, 
    0.00278744f, 0.16529089f, 0.02597963f, 0.07118620f, 0.08093868f, -0.34234822f, 0.06757861f, 0.04729041f, 
    0.11729380f, -0.22135532f, -0.48849747f, 0.18299291f, 0.08301138f, -0.00536083f, -0.00402410f, -0.12943554f, 
    -0.07649946f, 0.10839212f, 0.27282524f, 0.06082060f, 0.08420840f, 0.05690602f, 0.30560762f, 0.11438438f, 
    -0.18824466f, -0.10646680f, -0.53044707f, -0.07901835f, -0.05144918f, -0.02431123f, 0.18668376f, -0.26008889f, 
    0.09981395f, 0.30469993f, -0.01334829f, 0.12173618f, -0.03404073f, 0.15045376f, 0.30409113f, 0.18804404f, 
    0.01926660f, 0.21356964f, 0.09135611f, -0.62419170f, -0.18537325f, -0.20046195f, 0.12474203f, -0.09471592f, 
    -0.07257761f, -0.04862595f, -0.15959357f, 0.04082517f, -0.14966892f, 0.07152534f, 0.01182003f, -0.02065649f, 
    0.11744840f, -0.02647212f, 0.05006666f, 0.34166554f, 0.06980049f, 0.24836098f, -0.03061308f, -0.04082482f, 
    0.01090125f, 0.04414142f, 0.17266640f, -0.12929326f, 0.28270248f, 0.04877486f, 0.27778172f, -0.03632224f, 
    0.11581279f, 0.06903438f, 0.16663472f, -0.18705639f, 0.14995319f, -0.17334902f, 0.14969163f, 0.06738038f, 
    0.04297935f, 0.05064043f, 0.05005421f, -0.03039835f, -0.22906928f, -0.04533835f, -0.02219961f, -0.45319963f, 
    0.20926006f, 0.05741374f, 0.16475104f, -0.14377832f, -0.03256735f, -0.30384779f, 0.27499667f, 0.02988824f, 
    0.31447995f, -0.14353475f, 0.06328693f, -0.02143933f, -0.12532306f, -0.47492078f, 0.06745901f, -0.40868738f, 
    0.11673140f, -0.05991160f, 0.03525360f, -0.22281401f, 0.52141833f, 0.08789428f, -0.07183872f, 0.05840179f, 
    -0.01795523f, 0.00275310f, 0.06748365f, -0.05226204f, 0.01551334f, -0.00329722f, -0.00090720f, -0.10595392f, 
    0.05285655f, -0.04122882f, 0.01880245f, -0.07443111f, -0.10454626f, -0.03983738f, 0.00986682f, -0.09961268f, 
    0.06583097f, -0.07405842f, -0.07529587f, -0.05848494f, 0.01598158f, -0.05439227f, -0.06363651f, -0.09569239f, 
    0.03592753f, 0.04787463f, -0.07243311f, -0.04009579f, 0.07358747f, -0.07074076f, -0.05329521f, -0.05456556f, 
    0.03936230f, 0.04967667f, 0.03998210f, 0.03128201f, -0.08022716f, 0.02478974f, -0.06786033f, -0.09027500f, 
    0.00080813f, -0.02477608f, 0.00690149f, 0.03659790f, -0.03954575f, -0.13417043f, 0.03086521f, -0.07339700f, 
    0.02819663f, 0.04863864f, -0.00455715f, -0.04133227f, -0.08343104f, 0.01731823f, -0.06349581f, 0.01741326f, 
    0.01275717f, -0.02544781f, 0.06769512f, 0.00036148f, -0.04946365f, -0.03628659f, 0.04401417f, -0.09541078f, 
    0.02237510f, 0.08391970f, 0.03052507f, -0.07909277f, 0.00494870f, 0.06140842f, 0.06496499f, 0.03657052f, 
    0.01427065f, -0.04821545f, -0.02322495f, -0.08488829f, 0.03331426f, 0.02666836f, -0.05137026f, 0.02940536f, 
    0.00568280f, 0.09014918f, -0.09449841f, -0.05594439f, 0.04739787f, -0.01175974f, -0.00791813f, 0.03557257f, 
    0.03030174f, -0.08724722f, -0.00098508f, 0.06225088f, 0.02179903f, 0.06483640f, -0.08949862f, 0.03279004f, 
    0.00221333f, -0.08347881f, 0.07134039f, -0.16628826f, 0.04563308f, 0.04531051f, -0.06255603f, 0.02446960f, 
    -0.01304397f, -0.00783900f, -0.05602840f, -0.06255097f, 0.00607927f, -0.02667020f, 0.02551559f, -0.05088928f, 
    0.08074022f, 0.05348340f, 0.04884091f, 0.03792559f, 0.05663921f, 0.00626359f, -0.04325988f, -0.07140716f, 
    -0.05776487f, -0.01854681f, 0.03415199f, -0.10366280f, 0.05410786f, 0.04597652f, -0.06987738f, 0.06685031f, 
    -0.02846605f, -0.56284267f, -0.52085924f, -0.03928163f, 0.10445230f, 0.11841478f, -0.15679660f, 0.14599316f, 
    0.04819566f, -0.08657874f, 0.02330867f, 0.08728994f, 0.05194279f, -0.03018031f, -0.24508023f, 0.20987962f, 
    0.05092378f, -0.14959580f, 0.05779279f, 0.04052443f, 0.12409461f, -0.04112499f, -0.06397665f, 0.08800943f, 
    0.01902220f, 0.03476328f, -0.25818491f, 0.13991714f, 0.05623523f, 0.18632923f, -0.04967868f, -0.19009233f, 
    -0.17213227f, 0.05014051f, 0.10321698f, -0.07818430f, -0.02287288f, -0.00425680f, -0.07828373f, 0.00835846f, 
    -0.01786656f, 0.09474833f, -0.14810160f, -0.10057429f, -0.02835796f, -0.31418008f, 0.01381391f, 0.55220878f, 
    0.02882750f, 0.24915276f, 0.21494603f, -0.12761159f, -0.06188194f, 0.12401860f, 0.41075298f, 0.04403339f, 
    0.02180010f, 0.14695482f, 0.15409970f, 0.01036678f, 0.04320605f, 0.08782256f, 0.32527149f, -0.04007584f, 
    0.07084141f, -0.02328688f, -0.73757803f, 0.02884156f, -0.36978164f, 0.10212585f, -0.05301228f, 0.05737332f, 
    -0.26876998f, 0.00313145f, -0.07656877f, -0.19880649f, -0.23972569f, 0.04339087f, -0.06729174f, 0.01331645f, 
    -0.04536030f, 0.06218198f, 0.07075988f, -0.33720902f, 0.22068760f, -0.14739029f, -0.01091298f, -0.00682269f, 
    -0.07343035f, -0.06084715f, 0.06567821f, -0.10673604f, 0.14061372f, -0.02534560f, 0.09378812f, 0.11722037f, 
    0.17077999f, 0.11919552f, -0.07823838f, 0.05017522f, 0.33737636f, 0.08255303f, 0.15936854f, -0.16723673f, 
    0.13345961f, -0.00877897f, 0.06940613f, -0.27404073f, -0.18440765f, 0.26035428f, -0.21139267f, 0.17058754f, 
    -0.17545091f, -0.04007840f, -0.12205768f, -0.06511773f, 0.12877035f, -0.35443968f, -0.22843584f, -0.31848484f, 
    0.29079488f, -0.03285832f, -0.21332495f, -0.18916976f, 0.03676896f, 0.01556500f, 0.13963309f, -0.04605128f, 
    -0.13417707f, 0.03190497f, -0.07243802f, 0.04320516f, -0.11192837f, -0.03922125f, 0.05057854f, -0.14430627f, 
    0.02160382f, -0.05365083f, 0.02665504f, 0.05785354f, 0.05110770f, 0.08581155f, -0.00930365f, 0.02077857f, 
    -0.08876531f, 0.03313851f, 0.05577559f, 0.02420853f, -0.01282651f, -0.03352187f, -0.08923484f, 0.02655688f, 
    -0.07061226f, -0.02378013f, -0.12497433f, -0.05496540f, 0.04299276f, -0.01943745f, -0.04399007f, 0.02823703f, 
    -0.00362783f, -0.08389179f, -0.10753869f, -0.05551193f, -0.05372881f, -0.02013369f, -0.08894434f, 0.00251554f, 
    0.00871303f, -0.09589723f, -0.09973218f, 0.02919516f, 0.08271196f, 0.04152230f, -0.01373084f, 0.05919801f, 
    -0.07580844f, -0.02780815f, 0.02824044f, -0.06266274f, 0.02666732f, -0.03914911f, -0.03885887f, -0.06904946f, 
    -0.09382007f, 0.04882933f, -0.07086574f, 0.02963670f, 0.05022920f, -0.00799836f, -0.03945582f, 0.13668220f, 
    -0.06476132f, -0.02708153f, 0.06832099f, 0.01483557f, 0.06940866f, 0.03378963f, 0.01914848f, 0.04838003f, 
    -0.05359752f, 0.07056056f, 0.01577626f, 0.05493621f, 0.09629815f, 0.05891871f, 0.00620994f, -0.04325437f, 
    0.03358360f, -0.02557831f, -0.04188247f, -0.00247034f, 0.03948725f, -0.09816356f, -0.00134583f, -0.06372724f, 
    0.02449815f, -0.00521078f, -0.13841230f, -0.02863934f, -0.00567699f, 0.06029715f, -0.10360071f, -0.06766669f, 
    -0.06937998f, -0.08020920f, 0.05805833f, -0.00280908f, -0.01113915f, -0.02068200f, 0.04026670f, -0.01024035f, 
    0.00510369f, -0.09665103f, -0.06570338f, -0.08508297f, -0.01764087f, 0.05980988f, -0.06037054f, -0.07922962f, 
    0.00570088f, -0.07199749f, -0.07274886f, -0.01060444f, 0.07020882f, 0.01423783f, 0.06127101f, -0.00249240f, 
    -0.04878181f, -0.05153646f, -0.04346140f, -0.03213595f, -0.01172344f, -0.05161622f, -0.02981958f, -0.06653239f, 
    0.05756263f, 0.01942454f, 0.05740414f, 0.03035916f, 0.02878712f, -0.02121153f, -0.00281000f, -0.10405886f, 
    0.00770014f, -0.09936163f, -0.07095090f, -0.08407069f, -0.04719330f, 0.06138004f, 0.04268883f, -0.07068375f, 
    -0.10690907f, 0.01264423f, -0.05869991f, -0.01059153f, 0.05419291f, -0.06609023f, -0.08630513f, 0.01091829f, 
    0.08288776f, -0.06583229f, -0.01824206f, 0.06026030f, 0.03026236f, -0.03723936f, -0.03947496f, -0.06690376f, 
    -0.09264894f, -0.03061956f, 0.03693530f, -0.06004373f, 0.00782586f, -0.03748765f, -0.03024223f, -0.08910552f, 
    0.05027838f, -0.00818080f, -0.10419905f, -0.02615694f, 0.02647704f, -0.00099334f, -0.07736050f, -0.02208760f, 
    -0.07331456f, -0.01747029f, 0.03271452f, 0.02645024f, 0.06205249f, -0.02604336f, 0.05068434f, -0.05240400f, 
    -0.01977369f, -0.07757517f, -0.07622139f, -0.04639442f, -0.04377602f, 0.04014005f, 0.05421555f, -0.04136385f, 
    -0.03916666f, 0.05358783f, 0.05194350f, 0.06836840f, -0.00374394f, -0.01159021f, -0.05646437f, -0.01756717f, 
    -0.02162357f, -0.03880072f, 0.02924828f, 0.06577069f, 0.04778138f, -0.05672562f, 0.03438922f, -0.08267438f, 
    -0.02911525f, -0.00216121f, -0.02407310f, -0.05839608f, 0.04119169f, 0.03314657f, 0.00400475f, -0.09018022f, 
    -0.06478716f, 0.03321762f, 0.02415169f, -0.00898302f, 0.00649054f, -0.03672919f, -0.03284039f, -0.00194314f, 
    -0.06170975f, -0.01061955f, 0.08603895f, -0.05272563f, -0.02855495f, -0.00115015f, -0.03844675f, -0.09923294f, 
    -0.03785257f, -0.08126007f, 0.03536607f, -0.10431968f, -0.04685492f, -0.06219853f, -0.01912928f, 0.00408968f, 
    -0.08674528f, -0.00203315f, -0.05756005f, -0.01496672f, 0.03140955f, -0.01126852f, 0.06512377f, -0.08876897f, 
    -0.08739015f, -0.04055846f, 0.08402280f, -0.07904443f, -0.02183841f, 0.03603196f, 0.05349993f, 0.00246654f, 
    -0.05222636f, 0.25944585f, 0.30150941f, 0.03733817f, 0.14453457f, -0.08434913f, 0.29387525f, 0.00283947f, 
    -0.22531153f, -0.06842920f, -0.05123819f, 0.01615648f, -0.15021336f, -0.33574963f, -0.23924281f, -0.05782137f, 
    0.01015137f, 0.17456631f, -0.05184673f, 0.13079271f, -0.12705915f, -0.04232382f, -0.46625596f, 0.06890029f, 
    0.07573646f, -0.15525280f, -0.32303184f, -0.00173199f, 0.00518888f, 0.07243664f, 0.12683409f, -0.69658607f, 
    -0.22259264f, -0.02751125f, 0.17173363f, -0.03286739f, 0.06872582f, 0.03202270f, 0.12127098f, 0.06913362f, 
    0.01339842f, -0.09789237f, -0.19098091f, -0.23816852f, 0.22917373f, -0.06896765f, 0.18019898f, -0.33491841f, 
    0.02398860f, 0.12023214f, -0.05347187f, -0.00339425f, 0.07796361f, 0.12616394f, -0.02655394f, -0.07688653f, 
    0.06581447f, 0.11423153f, 0.03725244f, -0.65343308f, 0.17122307f, 0.05990538f, 0.19713044f, 0.09411299f, 
    -0.27887034f, -0.05269852f, 0.62840170f, 0.16317272f, 0.05245170f, 0.16253993f, 0.02394572f, 0.02638059f, 
    -0.04161130f, 0.22828402f, -0.05052574f, 0.47322491f, 0.16559568f, -0.22893748f, 0.06579827f, -0.06235884f, 
    0.01156632f, 0.05385966f, 0.13983284f, -0.30513117f, 0.02498228f, -0.01416515f, 0.20717095f, 0.01048024f, 
    -0.11408550f, 0.01299691f, 0.13022099f, -0.08598373f, -0.17690526f, 0.01524657f, 0.11928979f, -0.01049304f, 
    -0.14553450f, 0.10615215f, -0.00487279f, 0.02126659f, -0.32604063f, 0.00369988f, -0.02109591f, -0.07995261f, 
    0.14257650f, 0.16864969f, 0.22623220f, -0.31183815f, -0.47092429f, -0.40801567f, 0.15327002f, -0.42620042f, 
    0.43562534f, -0.07604503f, 0.02229565f, 0.06154614f, -0.09977107f, 0.17332396f, 0.24121405f, -0.30220842f, 
    0.02301850f, 0.05239491f, 0.09566672f, -0.13966702f, 0.40358344f, 0.07350066f, -0.10406329f, 0.13469765f, 
    -0.05316052f, 0.26221263f, 0.11085144f, 0.05207022f, -0.03220108f, 0.09416265f, -0.07253743f, 0.07896719f, 
    0.14916658f, 0.11591967f, 0.00776526f, 0.11549105f, 0.16391559f, 0.08275666f, -0.08413564f, 0.09461232f, 
    -0.16861065f, -0.25338086f, 0.06850067f, -0.03678451f, -0.09229391f, -0.11204910f, 0.15729254f, 0.08448577f, 
    0.05757404f, 0.22785659f, -0.00985970f, -0.02848976f, 0.04873286f, 0.02467727f, -0.12031244f, -0.11153131f, 
    -0.06073336f, -0.20105664f, -0.01895677f, 0.00294882f, 0.04099822f, 0.06683563f, -0.15833521f, 0.10958978f, 
    0.00903220f, -0.07302454f, 0.00420840f, 0.26635897f, -0.34952360f, -0.27150834f, -0.11021593f, -0.36652425f, 
    0.10248853f, 0.28108206f, -0.04950071f, 0.01051237f, -0.00208228f, 0.05029120f, 0.08209716f, 0.10593785f, 
    -0.13000782f, 0.11947032f, 0.10007435f, 0.11774595f, -0.13935436f, 0.03700306f, 0.07934556f, -0.11512540f, 
    -0.04127874f, 0.07973828f, -0.42613173f, -0.01708799f, -0.78170860f, -0.22126716f, 0.07933977f, 0.05804951f, 
    0.16614373f, -0.17171881f, -0.04026028f, -0.35524467f, 0.15144420f, -0.07285169f, -0.36740220f, 0.26011771f, 
    0.20007932f, -0.00725485f, 0.14200747f, 0.00373094f, 0.43371889f, -0.05113704f, -0.05543998f, 0.10444915f, 
    0.32138720f, 0.09195223f, -0.01530003f, 0.10016750f, 0.11026300f, -0.06049357f, -0.11740288f, 0.12431268f, 
    0.06446596f, -0.15010890f, 0.07114961f, -0.13277951f, -0.08940306f, 0.05737752f, -0.06677434f, -0.07116910f, 
    0.11710364f, 0.13018610f, -0.12322632f, 0.18021946f, 0.00238551f, 0.21437572f, -0.05165944f, 0.12160355f, 
    -0.09457137f, 0.19146334f, -0.03421248f, -0.41837275f, 0.00066348f, 0.09428178f, -0.07715537f, -0.20982017f, 
    0.04041104f, 0.42732298f, -0.04169625f, -0.02421561f, -0.31029174f, 0.07079924f, 0.49597704f, 0.08899730f, 
    0.17215279f, 0.20409256f, -0.21125770f, 0.03388058f, -0.06730163f, 0.07696570f, 0.03223395f, 0.11625606f, 
    0.09321418f, 0.03287599f, -0.01891109f, 0.04286551f, 0.06501138f, 0.21032640f, 0.08257436f, 0.08996893f, 
    -0.09938283f, 0.06278819f, -0.03852539f, -0.05177103f, 0.02452678f, -0.06229105f, 0.26673308f, 0.06479593f, 
    0.12623191f, 0.00043099f, 0.04736138f, 0.04505701f, -0.07865155f, -0.14848875f, -0.05883915f, -0.20168431f, 
    -0.04761496f, 0.12393728f, -0.15235576f, -0.03879085f, -0.01055544f, -0.00983558f, 0.03885167f, 0.21545270f, 
    -0.14412092f, 0.04828646f, -0.05399451f, 0.03409898f, 0.10538137f, 0.42387581f, -0.02877868f, -0.11836184f, 
    0.11057414f, -0.16063777f, -0.04018278f, -0.16128519f, 0.25053838f, -0.07242081f, -0.36671031f, 0.00625045f, 
    0.18179810f, 0.04319725f, 0.03680079f, 0.12155911f, 0.02696899f, 0.05334578f, -0.16398227f, -0.31124774f, 
    -0.10699072f, -0.00263573f, 0.53959703f, -0.00626046f, -0.23258956f, 0.02104456f, -0.09525409f, 0.00794859f, 
    -0.08340881f, -0.03728593f, 0.02522882f, 0.18908168f, 0.03195408f, -0.15530704f, 0.00229351f, 0.05561538f, 
    -0.07216304f, -0.03620975f, -0.10525912f, 0.05838109f, 0.00164773f, -0.01046262f, 0.07798082f, -0.03249668f, 
    0.14946514f, -0.08284364f, -0.02809921f, 0.15320541f, 0.06564444f, -0.00947308f, 0.11442573f, 0.20248877f, 
    -0.06097437f, -0.08200590f, 0.08869467f, 0.12161042f, 0.02090338f, 0.25251168f, -0.07514325f, -0.12437623f, 
    0.01159254f, 0.07196025f, 0.09320307f, 0.04004914f, -0.07391720f, -0.14220171f, 0.33443779f, 0.28859478f, 
    -0.01171144f, 0.08632457f, -0.04474397f, 0.17559257f, 0.06440981f, 0.05055327f, 0.29618672f, 0.23500606f, 
    -0.08949851f, 0.23030333f, 0.12040708f, 0.12571967f, -0.01892995f, 0.10327877f, 0.05361722f, 0.07409532f, 
    -0.00328253f, 0.05572742f, 0.02732833f, -0.00254779f, -0.10344820f, 0.07283661f, -0.07839397f, -0.01347367f, 
    -0.02252398f, 0.06109571f, -0.07119685f, -0.09498087f, -0.04078528f, -0.07899293f, -0.02826085f, -0.05172083f, 
    -0.14738457f, -0.13050182f, -0.01737758f, -0.08568010f, 0.06395595f, 0.13116392f, -0.14790244f, 0.04222424f, 
    -0.02401866f, 0.07916356f, 0.03305589f, 0.02465472f, -0.04030962f, 0.08047021f, 0.01053977f, -0.09454069f, 
    0.01551873f, -0.05119264f, 0.01121674f, -0.00062310f, 0.04090178f, 0.03199760f, 0.02843885f, 0.01922447f, 
    0.02822203f, 0.03022116f, 0.06553379f, -0.01353612f, 0.09760299f, 0.14773816f, -0.14454339f, -0.16308627f, 
    -0.09810285f, -0.00355209f, -0.00954517f, 0.00565497f, -0.02820658f, -0.00229283f, -0.18530928f, -0.10248503f, 
    -0.08590578f, -0.00681531f, 0.01015508f, 0.10789507f, -0.10285731f, -0.02357655f, 0.18467361f, -0.01883454f, 
    -0.07524907f, 0.06333674f, -0.03073025f, -0.10240677f, 0.19649507f, -0.13592547f, -0.00267234f, 0.06573428f, 
    -0.11830199f, -0.13174319f, 0.03985909f, -0.11870177f, 0.07565777f, -0.02923505f, -0.00571145f, 0.02216707f, 
    0.08666594f, 0.07713918f, -0.08726328f, 0.01080965f, -0.19085726f, 0.26648739f, 0.26238632f, 0.03499905f, 
    -0.01728898f, 0.00623915f, 0.11657251f, 0.02722309f, -0.02628834f, -0.14278600f, -0.15090024f, -0.00620215f, 
    -0.05951832f, 0.05175897f, 0.07750200f, 0.01825950f, 0.08991268f, -0.06116685f, -0.01855612f, 0.08202496f, 
    -0.14425915f, 0.03806563f, 0.07776441f, -0.21915163f, -0.05314140f, 0.00054212f, 0.05932985f, -0.11922974f, 
    0.04173945f, 0.15104660f, 0.07308709f, 0.03414537f, 0.09876561f, 0.03117487f, -0.02565522f, 0.02950393f, 
    0.08158793f, 0.15333922f, 0.04242463f, 0.08376049f, -0.16739474f, -0.14546746f, -0.09396819f, -0.08368768f, 
    -0.18686008f, -0.06935535f, 0.21455021f, -0.04200673f, 0.02933224f, 0.15093364f, -0.21435566f, 0.05696024f, 
    0.09248263f, 0.10168994f, 0.08849425f, 0.03290693f, 0.03519607f, -0.20378441f, -0.21408841f, 0.11852457f, 
    -0.06005864f, -0.19946979f, -0.06392305f, 0.08071838f, 0.18347336f, 0.00637492f, -0.29677004f, 0.10455596f, 
    0.00700954f, 0.17238401f, -0.21580841f, 0.10539872f, -0.00766861f, -0.01570657f, -0.01668853f, -0.16099606f, 
    0.02968297f, 0.14856838f, -0.23399383f, 0.17286579f, 0.10904420f, -0.07156954f, -0.09061497f, -0.12522194f, 
    0.21790035f, 0.10145538f, 0.00305320f, 0.04540390f, -0.35316259f, -0.37682700f, -0.00746508f, 0.31633377f, 
    0.11169630f, 0.35152501f, 0.35259941f, 0.11396655f, -0.05320446f, 0.22288460f, 0.34391692f, -0.14355484f, 
    -0.02644295f, -0.11131374f, 0.18298532f, -0.03841935f, 0.11254694f, -0.07176658f, 0.11407834f, 0.27104825f, 
    0.15941083f, 0.04804334f, -0.50968844f, 0.18427695f, -0.02826183f, -0.07844740f, -0.03243903f, 0.06463499f, 
    0.07652881f, 0.12577036f, 0.03041388f, -0.35351318f, -0.20209536f, -0.10423101f, -0.04460932f, 0.02652646f, 
    0.23789130f, -0.00340243f, 0.32088065f, -0.15000434f, -0.06109503f, 0.00810123f, -0.29322293f, -0.01121030f, 
    -0.03001009f, 0.17258969f, -0.17104524f, -0.14723472f, 0.04980077f, 0.20866641f, 0.13291834f, 0.15259318f, 
    -0.05544423f, 0.06500746f, 0.02400522f, -0.00405164f, -0.10507549f, -0.05941461f, 0.16687752f, -0.11058635f, 
    -0.09710697f, -0.05561652f, -0.03193134f, -0.13589802f, 0.01052176f, 0.23678099f, 0.00875886f, 0.16341822f, 
    -0.06892136f, 0.03496123f, -0.03827514f, -0.21124807f, -0.00875625f, -0.16845943f, -0.24854809f, 0.05917970f, 
    0.28950003f, -0.15158063f, -0.41440499f, -0.03667257f, -0.25874150f, -0.05927315f, 0.05923360f, 0.07704773f, 
    0.20477286f, 0.08487852f, 0.28653327f, -0.04370321f, -0.11901087f, 0.06439856f, -0.17202741f, 0.18586332f, 
    0.07469884f, 0.12451924f, 0.11886279f, 0.17675993f, 0.15521044f, 0.01156435f, 0.33526972f, 0.04327241f, 
    -0.26318398f, 0.16011904f, -0.01591126f, -0.00193942f, -0.03234283f, 0.05553722f, 0.17516969f, -0.04091664f, 
    -0.05403731f, 0.02031224f, 0.23479357f, -0.29036844f, 0.04981327f, -0.19281989f, -0.07032078f, -0.07194228f, 
    -0.00260083f, 0.15029776f, -0.24136980f, 0.03488869f, 0.12074745f, -0.07031931f, 0.24387828f, 0.16615441f, 
    -0.04611070f, -0.12521139f, 0.05673616f, 0.27605346f, -0.09997661f, -0.00538114f, -0.07495489f, -0.50462431f, 
    0.05536066f, -0.18857647f, -0.21936537f, 0.04715637f, 0.13105315f, 0.13983589f, -0.33083707f, -0.02992382f, 
    0.31398642f, -0.09175813f, -0.20424441f, 0.08581606f, 0.09278293f, -0.17171401f, -0.17803621f, -0.25809705f, 
    -0.07697760f, -0.00806957f, 0.70302701f, 0.06470342f, 0.31828943f, 0.04495079f, -0.03481949f, 0.02512017f, 
    -0.03361241f, -0.10181692f, -0.05707988f, 0.22643259f, 0.16788949f, -0.20942184f, -0.06812713f, 0.01626328f, 
    0.06328059f, -0.02655566f, -0.17214869f, 0.37684536f, -0.03590012f, 0.22713524f, -0.00510284f, -0.14106876f, 
    0.09660560f, 0.07759622f, -0.04188147f, 0.10058849f, 0.15298691f, 0.08567450f, -0.04042436f, 0.16037643f, 
    -0.11537516f, 0.00580936f, 0.01081847f, -0.13011163f, -0.25249633f, 0.15996981f, 0.01182766f, -0.12296087f, 
    0.10985268f, -0.01528344f, -0.17956118f, 0.00609169f, 0.30396846f, -0.20345509f, -0.09243113f, 0.04758356f, 
    -0.03439546f, 0.14367178f, -0.01760359f, 0.27719539f, 0.20329602f, -0.05785777f, 0.31762195f, 0.49834728f, 
    -0.16395414f, 0.12446315f, 0.07864340f, 0.12295131f, -0.15095674f, 0.17201757f, 0.08260340f, -0.06291818f, 
    0.00191459f, -0.42263189f, -0.18810755f, -0.08626349f, 0.22659023f, 0.00281966f, 0.02862742f, -0.06142352f, 
    0.02891878f, 0.03548098f, -0.10741590f, -0.05382523f, 0.04261974f, -0.04520483f, -0.05966844f, 0.06115131f, 
    -0.20069851f, 0.14044636f, 0.06473500f, 0.06873158f, -0.09864739f, 0.08097580f, 0.23796742f, 0.32443574f, 
    -0.21265562f, 0.10310046f, -0.06009864f, 0.09557743f, 0.02944623f, 0.23760614f, 0.12990560f, -0.01900851f, 
    -0.00136272f, 0.06894536f, 0.12237146f, 0.06700443f, 0.04688327f, 0.05958431f, 0.20182963f, -0.14331469f, 
    0.04172629f, -0.02254522f, -0.01114770f, 0.08182389f, 0.17199667f, 0.17495377f, -0.04476148f, -0.12713245f, 
    0.06146604f, 0.04256742f, -0.01936220f, 0.10030594f, 0.05414108f, 0.02410183f, -0.01929421f, -0.08949062f, 
    0.20780690f, -0.04453435f, -0.07796470f, -0.00099200f, 0.23063353f, -0.12445483f, 0.27419993f, 0.01736846f, 
    -0.01165077f, 0.03141206f, -0.45955408f, 0.06863378f, 0.30963278f, 0.07872969f, -0.02952722f, -0.02286645f, 
    -0.05959277f, 0.11553977f, 0.04816253f, 0.36528620f, 0.26379192f, 0.24314943f, 0.00618028f, 0.15255025f, 
    0.07103799f, -0.04822879f, 0.07470203f, 0.10159722f, 0.28000113f, -0.21128167f, 0.06608701f, 0.04101541f, 
    -0.13055858f, 0.10225581f, -0.01160540f, 0.00025575f, 0.04511604f, -0.01966634f, 0.05185295f, 0.14114924f, 
    0.07830711f, 0.11950862f, 0.03136078f, -0.14819886f, 0.16544242f, 0.09447948f, -0.05748765f, 0.10465701f, 
    0.06458211f, 0.15978581f, 0.08144271f, -0.05814705f, -0.11566461f, -0.13395278f, -0.00557826f, 0.01219036f, 
    0.21326490f, -0.01717302f, 0.09640593f, 0.23960318f, 0.27771577f, 0.02308094f, -0.38099289f, 0.05207617f, 
    0.40883663f, -0.14443585f, -0.14219159f, -0.11524422f, 0.02205245f, 0.03041598f, 0.01129444f, 0.12871495f, 
    0.06083462f, -0.05262740f, -0.11309844f, 0.04642545f, -0.05114720f, 0.00418341f, 0.05745346f, 0.05132907f, 
    0.13974327f, -0.13712744f, 0.10727967f, 0.12575673f, 0.16297118f, 0.30001554f, 0.00083844f, 0.17511508f, 
    0.20931123f, -0.05755170f, 0.04624040f, 0.06225317f, 0.09584017f, 0.09790055f, 0.17750786f, -0.26211962f, 
    0.08294956f, -0.15163194f, -0.09217398f, 0.21435140f, 0.00158345f, -0.05815332f, -0.08082964f, 0.13186458f, 
    -0.11003494f, 0.02640399f, 0.32439238f, -0.04796423f, 0.02220382f, 0.03191090f, 0.14447434f, -0.03763873f, 
    -0.30726197f, 0.10206445f, -0.30245006f, -0.26760584f, 0.10425165f, 0.07000401f, 0.12806277f, 0.16315071f, 
    -0.09093541f, 0.03631252f, 0.01593255f, -0.01898576f, -0.01719819f, 0.12097298f, 0.16261804f, 0.20689014f, 
    0.05049696f, 0.06295718f, -0.01621442f, -0.19011129f, -0.01485404f, 0.22037701f, 0.11996444f, -0.23626919f, 
    0.02768694f, -0.00575583f, 0.87448901f, -0.03130355f, -0.08183312f, 0.24937481f, -0.02251472f, -0.05933514f, 
    -0.12748526f, -0.04316070f, 0.03265641f, -0.08680125f, -0.01942797f, 0.45915526f, 0.04725304f, -0.29365024f, 
    -0.16427553f, -0.00345831f, -0.32383609f, -0.10704693f, -0.16389252f, -0.02406725f, 0.44277790f, -0.03684773f, 
    0.06774082f, -0.12559079f, 0.18940999f, -0.11476547f, 0.00226747f, -0.08869305f, 0.08990903f, -0.09854169f, 
    0.08352675f, -0.06803549f, 0.08017313f, 0.31280878f, -0.05732763f, 0.03399217f, 0.24549423f, -0.34511128f, 
    -0.04251970f, 0.07451646f, 0.10998145f, -0.12155492f, 0.15004827f, 0.02905950f, 0.19701307f, -0.29609153f, 
    -0.32644176f, 0.12030844f, 0.02635234f, -0.06822150f, 0.16934559f, -0.04129022f, 0.26519901f, -0.02738654f, 
    -0.10734208f, 0.05825065f, 0.21392371f, 0.08248833f, 0.28616196f, 0.07270745f, -0.10282426f, -0.16614495f, 
    -0.07789426f, -0.04106544f, 0.03163150f, 0.06264334f, -0.02965301f, -0.08799864f, 0.08240668f, 0.05265132f, 
    -0.10281105f, -0.05271820f, -0.01100671f, 0.02976847f, -0.03306267f, 0.01189240f, 0.04464822f, 0.04121408f, 
    -0.08787335f, -0.01307981f, 0.00611571f, 0.03231270f, -0.06049742f, -0.04515459f, 0.00103583f, -0.07000501f, 
    0.03703640f, -0.09533978f, -0.08368790f, 0.00079697f, -0.00971736f, -0.03893502f, -0.00879192f, 0.07090613f, 
    -0.06884371f, 0.03804861f, 0.05255757f, -0.00861404f, 0.03989691f, -0.06180555f, -0.00391638f, 0.08138914f, 
    -0.09361854f, -0.05606185f, 0.01535668f, -0.04085943f, 0.06747352f, 0.03715907f, -0.06308328f, 0.04228577f, 
    -0.08481085f, 0.00864462f, -0.07596717f, 0.00590095f, -0.04766206f, 0.00601724f, -0.09903122f, -0.06379044f, 
    -0.08131634f, -0.03859162f, -0.03699752f, 0.04739384f, 0.00423917f, -0.03238770f, 0.05794000f, -0.02954248f, 
    0.03557765f, -0.01055296f, -0.01391407f, 0.05221199f, -0.04897650f, -0.10337760f, -0.06145367f, 0.02410842f, 
    -0.07624215f, 0.03330243f, 0.05798751f, -0.06432538f, 0.05447219f, -0.05729778f, 0.00016880f, -0.06750438f, 
    -0.01200073f, 0.00974804f, -0.05189103f, -0.07191890f, -0.01132219f, -0.07358798f, -0.01224632f, 0.00472477f, 
    -0.02509019f, 0.03471587f, -0.06934667f, 0.02738718f, -0.00509862f, 0.03050529f, 0.04739701f, -0.07949974f, 
    0.04572683f, 0.00768573f, 0.06727420f, 0.06659628f, -0.06838406f, 0.03437558f, -0.01068095f, 0.02793686f, 
    -0.06978458f, -0.07490528f, 0.01216900f, 0.03714403f, -0.00880567f, -0.02529925f, -0.07933158f, -0.03386160f, 
    0.02029309f, -0.07719724f, 0.05937960f, 0.01879150f, -0.01729830f, -0.08290145f, -0.05468451f, 0.00739476f, 
    0.00091700f, -0.07718863f, -0.08187260f, -0.05499772f, -0.09407683f, -0.07659730f, -0.06641807f, 0.01808196f, 
    0.01156019f, -0.42377594f, 0.33095053f, 0.00969451f, 0.23877226f, -0.21758132f, 0.01653424f, 0.15596825f, 
    -0.06219916f, 0.11905553f, 0.11456053f, 0.16273913f, -0.04050942f, -0.05637696f, 0.06837531f, 0.00236548f, 
    -0.21731196f, 0.26725641f, 0.04119145f, 0.06573958f, 0.04223689f, 0.01131726f, 0.27951637f, 0.03117614f, 
    -0.13218153f, 0.21631688f, 0.07040190f, -0.13324022f, -0.07504259f, 0.24222149f, 0.06591035f, -0.08275495f, 
    0.03032531f, 0.09344803f, -0.09625823f, 0.14675649f, 0.05378320f, -0.02431986f, 0.46803367f, -0.11965822f, 
    0.17394006f, 0.08103645f, 0.06440438f, 0.06787053f, 0.10547113f, 0.24545816f, -0.04841631f, -0.09533227f, 
    0.05401125f, 0.28908631f, -0.11645063f, 0.11249255f, -0.10007101f, 0.16265434f, 0.04673811f, -0.02732584f, 
    0.22398974f, 0.11887472f, -0.05588876f, -0.07741582f, 0.27322671f, -0.12746248f, 0.30930951f, 0.16515887f, 
    -0.04208560f, 0.02945397f, 0.24224801f, 0.04316242f, 0.47868112f, 0.02445099f, -0.05086032f, -0.03878988f, 
    -0.10589109f, 0.05817683f, 0.05333182f, 0.29314610f, 0.27120537f, 0.21472113f, 0.04825334f, 0.09307391f, 
    0.19567209f, 0.01665322f, 0.09867307f, 0.03987966f, 0.28634650f, -0.17282929f, 0.23922253f, 0.05600042f, 
    -0.23343377f, 0.26519474f, -0.10745812f, -0.07178907f, 0.19796295f, -0.09733990f, 0.02063147f, 0.13033406f, 
    0.07135678f, 0.16411969f, 0.00075054f, -0.12556268f, -0.08942473f, -0.02034465f, -0.05951064f, 0.06105679f, 
    0.19207904f, 0.10817765f, 0.15203144f, -0.08979036f, 0.07258060f, -0.13277128f, 0.19794318f, -0.09021892f, 
    0.25816882f, -0.15551719f, 0.11911298f, 0.15503797f, 0.14217463f, -0.00151769f, -0.19450295f, 0.16587809f, 
    0.21628259f, 0.00073355f, -0.16744666f, -0.08173130f, 0.46085897f, 0.09720819f, -0.21196431f, 0.13846999f, 
    -0.12422190f, 0.08691349f, 0.22181590f, -0.01916827f, 0.03159719f, 0.10799251f, -0.01670085f, -0.01436023f, 
    -0.05991934f, -0.09078795f, -0.09417068f, -0.09984836f, 0.19435072f, 0.08177278f, -0.39279372f, 0.22551803f, 
    -0.01084113f, -0.23371236f, 0.05342076f, 0.02057858f, -0.03739728f, -0.14883587f, 0.27322403f, 0.13542359f, 
    -0.01856858f, 0.07379632f, -0.32719713f, 0.23448151f, 0.01657684f, 0.08052821f, -0.02613864f, -0.11512437f, 
    -0.04646036f, -0.24099632f, 0.44796482f, 0.06804880f, 0.07205903f, -0.02729607f, -0.04123937f, -0.06072402f, 
    -0.18891524f, -0.20162140f, -0.22554389f, 0.12900473f, -0.14911108f, -0.07700881f, 0.08238323f, -0.05948395f, 
    0.09112480f, 0.20869684f, 0.06681546f, 0.03756190f, -0.06309325f, -0.04555330f, 0.26763675f, 0.07095577f, 
    -0.00144976f, 0.00014985f, 0.06719323f, -0.12486947f, -0.46105757f, 0.03257093f, 0.31983379f, 0.08570407f, 
    -0.03835542f, -0.03761141f, -0.54616803f, -0.13434497f, 0.10688137f, -0.03453334f, 0.03960658f, 0.01584906f, 
    -0.05354742f, -0.01037262f, -0.07025394f, -0.28049263f, 0.24522384f, 0.08273067f, 0.00253761f, 0.04345843f, 
    0.15484792f, -0.05646834f, 0.12728047f, -0.12454243f, 0.30939060f, 0.24273407f, 0.17269102f, 0.12310411f, 
    0.25051987f, 0.00463847f, 0.16598885f, -0.23211606f, 0.09921871f, -0.19536817f, -0.01928153f, -0.11078362f, 
    0.04672151f, -0.10358300f, 0.01928143f, -0.04177746f, -0.02862296f, -0.09801423f, -0.14666758f, -0.04921673f, 
    -0.10489725f, -0.00539927f, 0.00776948f, 0.04896159f, 0.21051928f, 0.03319707f, -0.14785983f, -0.02223232f, 
    -0.14857642f, -0.04811275f, 0.07119185f, -0.19939791f, 0.11421943f, -0.08737603f, 0.01898707f, -0.31922182f, 
    0.27638948f, 0.01065092f, 0.09532577f, -0.23025820f, -0.00456629f, 0.03974383f, 0.15561819f, 0.01568109f, 
    0.16043514f, -0.32490325f, 0.37500936f, -0.03941686f, 0.29420763f, -0.18266170f, 0.32741097f, 0.00662340f, 
    -0.19462767f, -0.09434935f, 0.04091718f, 0.07695133f, 0.04916272f, 0.05840407f, -0.23916867f, 0.02287685f, 
    0.09551581f, 0.28986329f, 0.08606504f, 0.09590638f, -0.11202029f, -0.31328174f, 0.24491522f, -0.09047130f, 
    0.11151142f, -0.32674885f, -0.18333352f, 0.02180087f, -0.07872440f, 0.09508944f, 0.08491735f, -0.26361576f, 
    0.02910775f, 0.00445577f, 0.12795857f, -0.07109547f, -0.00425485f, 0.05341233f, 0.12165009f, -0.01618561f, 
    -0.11611805f, -0.13702358f, -0.37721470f, -0.33823270f, 0.25878692f, -0.06221667f, 0.08712682f, -0.23541671f, 
    0.04031485f, 0.12775835f, -0.29254234f, 0.21868972f, 0.07279693f, 0.18006589f, -0.05290064f, 0.18328868f, 
    0.09916828f, 0.26589015f, 0.07349976f, -0.58616537f, 0.03138168f, -0.09364741f, -0.05126034f, -0.04453791f, 
    -0.11039547f, -0.06242616f, -0.29437777f, -0.07254871f, 0.43295449f, -0.02489506f, -0.05318967f, 0.01358042f, 
    0.22142762f, 0.37410793f, -0.08165838f, 0.52766240f, 0.12541658f, -0.07654265f, 0.11250360f, -0.04836263f, 
    -0.16279854f, 0.03653191f, -0.03998611f, 0.03160635f, 0.26363650f, 0.01068916f, 0.39808649f, 0.00870394f, 
    -0.13642371f, -0.02787871f, 0.18183519f, -0.02126229f, 0.04228336f, -0.06222096f, 0.08099908f, 0.06995407f, 
    0.06765923f, 0.04118221f, -0.01011922f, 0.09479886f, -0.13090701f, -0.06108606f, -0.05153852f, -0.18604623f, 
    0.15279773f, 0.12544520f, 0.03446812f, -0.02561501f, -0.05952540f, -0.51826388f, 0.43162531f, -0.11060039f, 
    0.38589528f, -0.31118274f, -0.05906330f, 0.20592269f, -0.03417283f, 0.08520389f, -0.07434305f, -0.24855414f, 
    0.11671073f, 0.01673130f, 0.23561683f, -0.12527068f, 0.35402778f, 0.24842583f, -0.17920919f, 0.05928042f, 
    0.19280212f, 0.28050059f, 0.22742556f, 0.00216414f, -0.09640266f, 0.10990923f, -0.08391582f, -0.45283926f, 
    -0.21877410f, 0.04211235f, 0.04550867f, -0.41900060f, -0.29320109f, -0.30344278f, 0.07212102f, -0.21778554f, 
    0.16682971f, 0.17112239f, 0.00056108f, 0.21762617f, -0.35840869f, -0.04582309f, 0.21989575f, -0.03755891f, 
    0.01127127f, 0.11548945f, -0.10975844f, 0.16657461f, -0.01116754f, -0.09014586f, 0.14197163f, -0.19641252f, 
    0.02369631f, 0.06570152f, 0.24413972f, -0.13229339f, 0.06912155f, -0.07243511f, -0.24309838f, 0.18218012f, 
    -0.06744605f, -0.18051049f, -0.02782503f, -0.25966662f, 0.15689343f, -0.20834614f, 0.16321154f, -0.23658168f, 
    0.07241610f, -0.20935455f, -0.00087443f, 0.01821668f, 0.20127666f, -0.28036278f, 0.00594019f, -0.19765076f, 
    -0.40352491f, -0.19211261f, -0.08372188f, -0.17039669f, -0.15304579f, 0.02339171f, -0.13287386f, 0.29661831f, 
    -0.12031963f, -0.05463012f, 0.36169258f, -0.10290706f, 0.47802860f, 0.03930983f, -0.02309191f, 0.02252482f, 
    -0.29686889f, 0.24188904f, -0.04060616f, 0.06660490f, -0.03356605f, -0.24898335f, 0.14519660f, 0.05505478f, 
    0.05221218f, 0.03216929f, -0.12031396f, 0.07935964f, -0.38204774f, 0.31662834f, 0.18405651f, 0.15871033f, 
    0.24735010f, -0.23422721f, 0.17465593f, -0.10104632f, -0.16205171f, 0.13471740f, 0.20255904f, 0.15743136f, 
    -0.34761482f, -0.05924037f, -0.05078414f, 0.02593800f, -0.15948473f, 0.10790738f, -0.12131240f, -0.03766624f, 
    -0.15041779f, 0.09736995f, 0.13347846f, 0.26127788f, -0.45823798f, -0.19890408f, -0.16462876f, -0.15003665f, 
    0.04433243f, 0.29657093f, -0.00199207f, 0.08204874f, -0.15346505f, 0.02363477f, 0.50903589f, 0.06331406f, 
    -0.03659122f, 0.24539499f, 0.22448155f, 0.26036933f, -0.17144348f, 0.15349700f, -0.08560020f, 0.09845442f, 
    -0.08607265f, -0.05485601f, -0.01776536f, 0.01288433f, 0.02739720f, -0.01610806f, 0.05721164f, -0.04200165f, 
    -0.00336161f, 0.04969127f, 0.08802562f, -0.03561003f, 0.02517802f, 0.01733222f, -0.07187629f, 0.02834221f, 
    0.01349109f, -0.10463145f, 0.00676761f, 0.02996173f, 0.01912043f, 0.02827152f, -0.07382850f, 0.04699644f, 
    -0.00958274f, -0.10578643f, -0.01823279f, -0.02107285f, -0.08366868f, -0.05883360f, -0.06322837f, -0.08632647f, 
    -0.03978274f, 0.01281899f, -0.07445119f, -0.09646899f, -0.09293935f, 0.02400682f, -0.05432943f, -0.01207055f, 
    0.04696857f, -0.04267412f, -0.02317037f, -0.02121750f, -0.00921807f, -0.06006354f, -0.09474066f, 0.00681257f, 
    0.00201757f, -0.01717040f, 0.05419792f, -0.03380603f, -0.02408031f, -0.04892928f, 0.06338421f, -0.09449381f, 
    -0.04309829f, -0.03617166f, 0.05494601f, -0.00569780f, -0.12679105f, -0.05458354f, 0.03469616f, -0.10769305f, 
    0.01633100f, 0.05075509f, -0.05788884f, -0.00013894f, -0.10858884f, -0.08112054f, -0.06183796f, -0.01835862f, 
    0.01831442f, -0.09717340f, -0.04166346f, -0.08213458f, -0.02939638f, -0.06798930f, -0.03502063f, -0.06362625f, 
    -0.00794835f, -0.03970859f, 0.06282572f, -0.00371788f, 0.01446320f, 0.01018397f, -0.10272712f, -0.09645469f, 
    0.03694564f, 0.06676142f, -0.11163116f, 0.00702304f, -0.04167832f, -0.00940162f, 0.04909047f, -0.08172103f, 
    -0.07308441f, -0.08609092f, -0.08385663f, -0.04169657f, -0.05623578f, -0.02232473f, -0.00236025f, -0.07067723f, 
    -0.05081177f, -0.02503915f, -0.02413240f, -0.03704533f, -0.04205566f, 0.00063272f, 0.07481546f, 0.03809929f, 
    0.02130395f, -0.09837656f, -0.05057625f, -0.01261749f, 0.04854233f, 0.07222948f, -0.10216077f, 0.02201677f, 
    -0.02520423f, -0.07688262f, -0.00532433f, 0.04411865f, -0.07210986f, -0.00918814f, -0.08723747f, -0.07587327f, 
    -0.00449050f, -0.07729497f, -0.06892666f, -0.02781474f, -0.06919148f, -0.01306518f, -0.07029314f, 0.01187722f, 
    -0.09250045f, -0.08289945f, 0.07224067f, -0.11197651f, 0.04024495f, -0.05521014f, -0.07282999f, -0.00619040f, 
    -0.01466385f, -0.00810808f, 0.01700651f, -0.05664903f, 0.00354358f, 0.04196458f, 0.05925912f, -0.10058226f, 
    0.02204974f, 0.01607190f, 0.02803380f, -0.00053952f, 0.04139656f, -0.06739729f, -0.05553305f, -0.08313330f, 
    -0.08199079f, -0.11467870f, -0.01397085f, -0.01316251f, -0.05768454f, -0.07263525f, -0.04648346f, -0.03052037f, 
    -0.09070515f, -0.02547180f, -0.08137933f, -0.06018697f, 0.01408864f, -0.00582755f, 0.02242502f, -0.05066599f, 
    -0.01612724f, -0.06508718f, -0.03916894f, -0.08059002f, -0.09332889f, 0.02145681f, -0.03626105f, 0.03088053f, 
    -0.03821313f, -0.06655804f, -0.05458011f, 0.03217280f, -0.03158315f, -0.01889791f, -0.07372125f, -0.05175757f, 
    -0.02766619f, -0.03968716f, -0.06791691f, -0.03883087f, -0.08691662f, -0.01821890f, 0.06424989f, -0.08080567f, 
    -0.01552172f, 0.02222592f, 0.06586916f, 0.06049708f, -0.03661132f, 0.04029345f, 0.06496086f, -0.08922362f, 
    -0.01543902f, 0.02542345f, 0.01204357f, 0.03706468f, -0.02692452f, 0.07196786f, 0.02658506f, 0.01044786f, 
    -0.07835956f, -0.02076738f, -0.01774278f, 0.01723125f, -0.10771812f, -0.06069334f, -0.01476502f, -0.03037115f, 
    -0.08379149f, 0.05470012f, 0.07818019f, -0.03647202f, 0.04773487f, -0.02605582f, 0.00188513f, -0.01188527f, 
    0.05071858f, -0.10522424f, -0.05069336f, 0.00327919f, -0.12296505f, -0.02475621f, -0.02370216f, -0.07735857f, 
    0.05729446f, -0.07038356f, -0.06519559f, -0.07916117f, -0.06960543f, -0.09205677f, -0.01423635f, -0.05200621f, 
    -0.01711115f, 0.02724608f, -0.11447500f, 0.01631752f, 0.07425722f, -0.05839365f, -0.04066625f, 0.01582232f, 
    0.02161198f, 0.02475451f, 0.05832215f, -0.02581939f, -0.08264489f, 0.03339063f, -0.05200089f, -0.05960291f, 
    -0.08759713f, -0.04865735f, 0.00942965f, 0.02371698f, -0.07635766f, -0.00427613f, 0.01957930f, 0.03912542f, 
    0.05541641f, 0.07136616f, -0.08767121f, 0.01130489f, 0.05236125f, -0.04611639f, -0.00887679f, -0.00165101f, 
    0.01193604f, 0.02728397f, -0.02310283f, 0.03797086f, 0.05062892f, 0.05413513f, -0.02270427f, -0.03590975f, 
    0.01004410f, -0.07594413f, 0.05613386f, -0.08359977f, -0.07674633f, -0.06174297f, 0.01791768f, -0.00925896f, 
    0.00893713f, -0.07208779f, -0.06931433f, -0.04489423f, 0.04106787f, -0.04181175f, -0.09138617f, 0.03741026f, 
    -0.05927655f, -0.04785209f, -0.01013478f, -0.05317620f, -0.06098152f, 0.06553961f, -0.07576264f, 0.04530641f, 
    0.06363899f, 0.06706493f, -0.00388414f, -0.02181627f, 0.02744407f, -0.02314033f, 0.03207828f, 0.06646983f, 
    -0.06496090f, -0.04047177f, -0.11630160f, -0.09427934f, -0.02306800f, -0.02390827f, 0.03387798f, -0.06031373f, 
    -0.00988024f, -0.08808413f, -0.06482183f, 0.06203454f, -0.06923354f, -0.02931127f, -0.08531243f, 0.06144636f, 
    -0.04076557f, 0.05797167f, -0.03558291f, -0.09620529f, -0.04978637f, 0.06879447f, -0.07675413f, 0.06772124f, 
    0.02987516f, 0.00656748f, -0.08659806f, 0.09232320f, 0.02670672f, 0.03853462f, -0.04262951f, -0.07503989f, 
    -0.08027977f, 0.05159764f, -0.04139237f, -0.00229081f, -0.03786138f, -0.01172305f, -0.06936739f, 0.09645198f, 
    0.05945098f, 0.07023037f, -0.05040583f, -0.09540670f, -0.08884341f, -0.07771670f, -0.00555889f, -0.10325933f, 
    0.04852361f, 0.07290357f, 0.00353057f, -0.05674675f, -0.05313950f, 0.02330113f, -0.06177028f, 0.00541996f, 
    0.02718240f, 0.00981166f, -0.02081435f, 0.05327995f, -0.05773383f, -0.02665484f, -0.03674334f, 0.00878124f, 
    0.09704755f, 0.45766711f, -0.37853783f, 0.02040401f, 0.00106118f, 0.00676673f, -0.21056138f, -0.04595626f, 
    0.02330359f, 0.02923339f, -0.17533253f, -0.04696469f, -0.19308817f, -0.41211829f, -0.02039652f, 0.05932010f, 
    -0.10222854f, 0.10499182f, 0.06041108f, 0.08428409f, -0.11465845f, -0.19936216f, -0.52712607f, 0.21662900f, 
    0.13110584f, -0.05100308f, -0.21057197f, 0.23021516f, 0.00319151f, 0.16165778f, 0.03385456f, -0.85881710f, 
    -0.56266856f, -0.00581567f, 0.10848565f, -0.14804520f, 0.21362101f, -0.05834026f, 0.12789801f, 0.14474560f, 
    0.06027495f, -0.03900256f, -0.19558366f, -0.00748919f, -0.06681201f, -0.03190824f, 0.13052507f, 0.29890975f, 
    0.04926248f, 0.10304128f, 0.12572666f, -0.34953550f, 0.23161490f, -0.04598448f, -0.01065006f, 0.15476683f, 
    -0.03634958f, 0.03721634f, 0.37809661f, -0.00471568f, -0.05336288f, 0.32413921f, 0.17153078f, -0.37565303f, 
    -0.20571518f, -0.11516616f, -0.37062785f, -0.18137430f, -0.57370704f, 0.19802447f, 0.06169825f, -0.00829044f, 
    -0.49393120f, 0.06631578f, -0.01864928f, -0.00250348f, -0.13536341f, -0.38500151f, 0.19451444f, 0.25621188f, 
    0.01735435f, -0.05287187f, 0.16865245f, -0.41341376f, 0.13344200f, -0.03288078f, -0.11500276f, 0.15045442f, 
    0.00544921f, -0.16926683f, 0.24950321f, -0.17598180f, -0.02615793f, -0.09132548f, 0.25127581f, 0.10356361f, 
    -0.09608952f, 0.07866834f, 0.05683747f, 0.10347910f, 0.28340980f, 0.12300514f, -0.04725758f, -0.19435269f, 
    0.22289707f, 0.13089575f, 0.06363449f, -0.47601768f, -0.23899725f, 0.30943078f, -0.16601036f, 0.22981183f, 
    -0.01366595f, 0.01588460f, 0.02098812f, 0.11197438f, 0.14517628f, -0.18175000f, -0.17648856f, -0.11673899f, 
    0.03277203f, 0.18598752f, -0.05555363f, -0.14467162f, 0.11220043f, 0.01980899f, 0.14257526f, 0.28600794f, 
    -0.18691938f, 0.27780044f, 0.10128558f, -0.02805138f, -0.25850648f, 0.06781983f, 0.09485699f, -0.19680887f, 
    0.00750768f, -0.04928932f, 0.00709637f, 0.00957875f, -0.05403625f, 0.14432205f, 0.09554187f, 0.04143216f, 
    0.08797766f, 0.01789170f, -0.08035307f, -0.27030736f, -0.03116515f, 0.02431489f, -0.03542693f, 0.02628846f, 
    0.05796454f, 0.04863530f, 0.06130914f, 0.13157369f, -0.06888834f, 0.00824788f, 0.15595424f, -0.02887368f, 
    0.09614642f, -0.02007954f, -0.42530146f, 0.20006554f, -0.03983103f, -0.08022314f, -0.07414297f, 0.34101969f, 
    -0.01791080f, 0.08937152f, -0.06736021f, -0.03246579f, 0.08435044f, -0.02731078f, 0.22698237f, -0.58215314f, 
    0.13298857f, -0.16583207f, -0.05296025f, -0.00908951f, 0.18262208f, 0.01017436f, -0.08788601f, 0.00234350f, 
    -0.07254857f, 0.03536784f, -0.11268410f, 0.00985212f, -0.44996595f, 0.07203821f, -0.46171069f, 0.17195372f, 
    0.14676647f, 0.07184424f, -0.09279068f, 0.09027281f, -0.24730004f, -0.13500607f, 0.06720943f, 0.00813268f, 
    0.04442254f, -0.16750109f, -0.04500709f, -0.10593129f, -0.15782830f, -0.23337269f, -0.03358814f, 0.08190257f, 
    -0.11668113f, -0.07580353f, 0.12527958f, 0.11263194f, 0.05673119f, -0.44241920f, -0.41510236f, 0.20575526f, 
    -0.41854993f, 0.05417207f, -0.16359231f, 0.06137048f, 0.04949789f, -0.06007937f, -0.20067951f, 0.08235255f, 
    0.01591246f, 0.00877930f, -0.05245551f, 0.27185246f, -0.09842457f, 0.10931989f, 0.06827325f, 0.12967996f, 
    -0.11606957f, 0.19493252f, 0.09845741f, 0.17262071f, -0.15074900f, 0.08966296f, -0.09079272f, 0.02906381f, 
    0.09755410f, -0.00892042f, -0.04916925f, -0.10850789f, -0.22285861f, 0.02335836f, 0.38244793f, -0.21537741f, 
    -0.11916341f, 0.23975542f, 0.09139586f, 0.23400809f, -0.45123178f, -0.12329831f, -0.05899603f, -0.24597761f, 
    0.03893654f, -0.00401402f, -0.01563252f, -0.05375679f, -0.05167264f, -0.06155288f, -0.05228905f, -0.00357677f, 
    0.01372838f, 0.00227773f, -0.02554283f, -0.06475987f, -0.00394122f, -0.07471505f, -0.04508273f, 0.03282792f, 
    0.01910226f, 0.08783471f, -0.01497235f, 0.01098309f, 0.07026811f, -0.06440169f, -0.06403048f, -0.07785801f, 
    -0.00854811f, 0.07951418f, -0.07258314f, -0.05753800f, 0.01311932f, 0.04790764f, -0.03564630f, 0.05857937f, 
    -0.06010158f, 0.01652683f, -0.05291480f, -0.02028921f, -0.07585024f, -0.02291185f, -0.06734792f, 0.06809432f, 
    -0.00310985f, -0.08624971f, -0.02180050f, 0.05713890f, -0.00388630f, 0.08121481f, 0.04580911f, 0.06458989f, 
    -0.03287882f, 0.07005562f, -0.00968587f, 0.02101526f, -0.07432931f, -0.08720481f, 0.01626723f, -0.04926050f, 
    0.08108015f, 0.03714130f, 0.01402553f, -0.06547730f, -0.05144824f, -0.08227636f, -0.01145559f, -0.01350792f, 
    -0.00603852f, -0.02070035f, 0.02590647f, -0.05568321f, 0.08216847f, -0.02461189f, 0.07117011f, 0.04457068f, 
    -0.06694125f, 0.08549932f, 0.00638685f, -0.00440726f, -0.07065782f, -0.00786790f, -0.04862007f, -0.05061112f, 
    -0.01735100f, 0.06678309f, 0.02894882f, -0.08059887f, 0.00195235f, -0.06815387f, 0.03926907f, 0.02420133f, 
    0.08480624f, -0.08780226f, -0.04447317f, 0.08043867f, -0.08326259f, -0.03625373f, 0.00995250f, -0.08714116f, 
    0.05080200f, -0.05338519f, 0.03836885f, -0.04548636f, -0.01871480f, -0.04058256f, -0.03296944f, -0.01155816f, 
    -0.06494883f, -0.06938824f, -0.06474302f, 0.00377130f, 0.01042632f, -0.01254608f, 0.01801557f, -0.05969559f, 
    0.05728114f, 0.05899395f, 0.03683724f, -0.00814122f, 0.07185967f, 0.05564305f, 0.06039322f, -0.08297105f, 
    -0.01538838f, -0.08601589f, 0.06776470f, -0.05358464f, -0.06640681f, 0.05220787f, 0.01618315f, 0.05876997f, 
    -0.03476468f, -0.02262494f, 0.05533406f, 0.06849813f, 0.01911960f, 0.01747066f, -0.10765896f, 0.06917750f, 
    0.01585247f, -0.06690641f, 0.03291183f, 0.01409650f, -0.03063385f, 0.04347877f, -0.09696764f, 0.00912557f, 
    0.04617007f, 0.05778820f, -0.04493121f, 0.01213417f, -0.10151110f, -0.04979640f, -0.00301884f, 0.05261397f, 
    -0.10252073f, -0.10861322f, 0.05498005f, -0.00344385f, -0.03238402f, 0.00893506f, -0.02630528f, 0.01067381f, 
    0.05926304f, -0.05200291f, 0.07722167f, -0.01577594f, -0.03160892f, -0.07416900f, -0.03348560f, -0.05160732f, 
    0.06708261f, -0.05037611f, -0.09988668f, -0.04752636f, 0.00074232f, 0.08494494f, -0.00421378f, 0.02085052f, 
    0.01899899f, -0.00098628f, -0.06759616f, -0.07043421f, -0.08664989f, -0.04996039f, 0.01306071f, -0.07534636f, 
    -0.00109679f, -0.10821816f, -0.07027987f, 0.00669089f, -0.11813286f, -0.03042744f, 0.06529500f, -0.08617439f, 
    0.00165004f, 0.06628311f, 0.01930799f, -0.07033159f, 0.03926929f, -0.03719511f, -0.01198603f, 0.05382448f, 
    -0.04408007f, -0.10129233f, -0.00696560f, -0.07395495f, -0.05073304f, -0.02965114f, -0.03026204f, 0.04899958f, 
    0.05395473f, 0.03802423f, 0.06587342f, -0.02761909f, -0.01110170f, 0.03418503f, -0.01450142f, -0.08847974f, 
    -0.04752553f, -0.00810298f, 0.07522961f, 0.04215227f, 0.04774796f, -0.04988586f, 0.01024152f, -0.05695110f, 
    -0.02866606f, -0.02634657f, 0.06531102f, 0.02830221f, 0.00373988f, 0.00619200f, -0.10061597f, 0.02573116f, 
    -0.01143410f, -0.11428122f, -0.10718670f, -0.06117915f, 0.02141764f, -0.03267876f, -0.03530733f, -0.06052770f, 
    0.05262419f, -0.11262483f, 0.00708599f, -0.03820328f, -0.01836363f, -0.10795744f, -0.03693533f, -0.10174694f, 
    0.04069072f, -0.02229688f, 0.08346032f, 0.02673389f, -0.11631441f, -0.05081458f, -0.08737491f, -0.10169803f, 
    -0.03484835f, -0.05015118f, -0.01926029f, 0.04016588f, -0.07834595f, 0.07274999f, -0.02833820f, -0.02647153f, 
    0.04441709f, -0.07209314f, 0.06482820f, 0.00264205f, 0.05586641f, 0.07527377f, -0.06799988f, -0.06932937f, 
    -0.01942139f, -0.03874299f, -0.05623717f, 0.05688681f, 0.04869020f, -0.09190076f, 0.05169241f, -0.00267476f, 
    0.00258289f, -0.08811004f, 0.06003203f, -0.04327879f, 0.02744062f, -0.02604758f, -0.00607156f, -0.02181410f, 
    -0.03378453f, 0.03866631f, -0.07523782f, -0.08674891f, -0.07817553f, -0.02220768f, -0.03690955f, -0.07824609f, 
    -0.00457783f, 0.01142305f, 0.00887951f, 0.05662021f, 0.04565489f, 0.05643548f, 0.02151980f, 0.04468373f, 
    -0.00257038f, 0.03177144f, -0.01958733f, -0.07293592f, -0.07736073f, 0.05785511f, 0.04921599f, -0.08214328f, 
    0.04542116f, -0.04544079f, 0.00780383f, -0.02935669f, 0.05240771f, -0.01838189f, -0.04547760f, -0.06540682f, 
    -0.06653505f, 0.05041872f, 0.06540432f, -0.05709618f, 0.07888381f, -0.03892498f, -0.05261457f, 0.02088286f, 
    -0.01367124f, -0.02956393f, -0.05433485f, -0.08580213f, -0.05752856f, 0.00739252f, -0.05225478f, -0.08410725f, 
    -0.00372298f, -0.08206487f, 0.06654400f, 0.01526606f, -0.02333964f, -0.07082935f, -0.04347122f, 0.02144836f, 
    -0.03654594f, 0.04717878f, -0.02822877f, -0.06205900f, -0.08339604f, -0.01438166f, -0.02383887f, -0.07381071f, 
    -0.08966640f, -0.03456543f, 0.01564350f, -0.02973440f, -0.09160899f, 0.02435498f, 0.02077428f, -0.04090963f, 
    -0.08037958f, 0.02462576f, 0.03473457f, 0.03580347f, 0.00877166f, 0.04903394f, -0.02868149f, 0.01657816f, 
    -0.07141187f, -0.01271213f, 0.05941793f, -0.03335030f, 0.03080775f, 0.05370174f, -0.01345701f, -0.00484666f, 
    -0.05491497f, 0.00452645f, -0.04701869f, -0.05087514f, 0.03639048f, -0.02239234f, -0.00238488f, -0.04921874f, 
    -0.16275954f, -0.31150201f, 0.31957197f, -0.02726779f, 0.38088626f, -0.24096158f, -0.18256250f, 0.13084403f, 
    -0.10390500f, -0.08752339f, 0.07987179f, 0.04016624f, 0.05598150f, -0.03928676f, -0.07396860f, 0.20605813f, 
    -0.03832250f, 0.07914439f, 0.02123480f, -0.01891868f, 0.12624300f, -0.17778210f, 0.26812637f, -0.00696766f, 
    -0.11748265f, -0.03029277f, -0.25622931f, 0.04310206f, -0.05892747f, 0.16489251f, -0.02021873f, -0.13459076f, 
    -0.01845803f, 0.05221894f, 0.03758160f, 0.14751714f, 0.07031586f, -0.02439087f, 0.29455334f, -0.11227471f, 
    0.04123773f, 0.05466411f, -0.21198055f, -0.20386569f, -0.02952672f, 0.00138105f, 0.17775337f, 0.08229756f, 
    0.08920497f, 0.38225362f, -0.04901655f, 0.25399616f, -0.12648731f, 0.20634656f, 0.29417759f, 0.03368904f, 
    0.01877102f, 0.21693286f, 0.03046178f, -0.53587055f, -0.03001278f, -0.23901312f, 0.20410372f, 0.10727541f, 
    -0.11763845f, -0.08507091f, -0.13845816f, -0.02874744f, 0.18868333f, 0.15857719f, -0.00241296f, 0.03636155f, 
    0.01162515f, -0.04389728f, 0.07467562f, 0.26277342f, -0.01210370f, 0.30762517f, -0.12562601f, -0.13087343f, 
    0.04135693f, 0.00877581f, 0.15576026f, -0.02735402f, 0.21336152f, 0.09301876f, 0.20869312f, -0.15902708f, 
    -0.22038724f, 0.22733335f, 0.11907770f, -0.45289254f, 0.22801051f, -0.26491532f, 0.08850130f, -0.07581682f, 
    0.02359784f, 0.13616917f, 0.06910384f, 0.07865430f, -0.07427907f, -0.21466380f, 0.10222486f, -0.08774427f, 
    0.10265493f, -0.14819761f, -0.06686255f, -0.21232001f, -0.04467359f, -0.26550445f, 0.49024498f, -0.07928158f, 
    0.06548855f, -0.28069019f, 0.00501648f, 0.00776691f, 0.03709950f, -0.32358375f, -0.11128574f, -0.36111510f, 
    0.32895166f, -0.15838519f, -0.24414308f, -0.42935273f, 0.34588087f, 0.00296461f, -0.22971852f, -0.11096668f, 
    -0.09028892f, 0.08567917f, -0.03331783f, 0.08806492f, -0.00570465f, -0.05358864f, 0.04868220f, -0.03784235f, 
    -0.09518015f, -0.08681481f, 0.02946190f, 0.06774567f, -0.08836643f, -0.06968711f, 0.05662933f, 0.01483412f, 
    0.01763661f, 0.02867646f, -0.05735487f, -0.05267568f, 0.05609938f, -0.07628782f, -0.00947940f, -0.01984579f, 
    0.04384774f, 0.07042179f, 0.03139513f, 0.06240866f, -0.07129902f, -0.00107083f, -0.03122014f, 0.01180643f, 
    -0.05407082f, -0.06696253f, 0.00911059f, 0.07343564f, -0.05052609f, 0.01973751f, 0.03285081f, -0.06762219f, 
    -0.04345331f, -0.10760769f, -0.03596552f, 0.06624382f, -0.08032484f, -0.05782930f, -0.02875820f, -0.02604088f, 
    -0.01982129f, 0.04961713f, -0.02031579f, -0.02405014f, -0.04863375f, -0.09328122f, 0.04564932f, -0.05245395f, 
    -0.03802520f, -0.00400496f, -0.09716655f, 0.03176058f, 0.00618574f, -0.06338591f, 0.00980925f, 0.02349479f, 
    -0.06791741f, -0.02657912f, -0.03073429f, -0.06122300f, 0.03852100f, -0.06721103f, 0.06497465f, 0.06550667f, 
    -0.00769516f, -0.06046970f, -0.03984765f, -0.00716252f, -0.10798821f, 0.04754214f, 0.03923979f, 0.04674367f, 
    -0.02798697f, 0.01622712f, -0.08652658f, -0.02642172f, 0.10045574f, -0.05445159f, -0.04247988f, 0.02381559f, 
    0.07256097f, 0.06589422f, -0.01347879f, -0.06009671f, -0.04445477f, 0.02314865f, 0.00614251f, -0.02627619f, 
    -0.02899797f, -0.03805618f, -0.03517172f, -0.08818319f, -0.05734822f, -0.09762688f, -0.11368335f, -0.04281505f, 
    -0.06114204f, -0.09136575f, 0.03472432f, -0.00062360f, 0.01159498f, 0.04382515f, 0.02607390f, -0.02926666f, 
    0.02606795f, 0.00203321f, 0.04860792f, -0.05235694f, -0.02570091f, -0.04586706f, 0.07461572f, 0.05141831f, 
    0.02897041f, -0.00876332f, -0.08004644f, -0.04733418f, -0.05964006f, 0.04904576f, -0.02735662f, 0.02226874f, 
    0.19196308f, -0.13183568f, 0.15407462f, 0.07361437f, 0.00986396f, -0.11603541f, -0.34414619f, 0.04211011f, 
    0.12271017f, -0.18276285f, 0.02651905f, 0.06789669f, 0.05092761f, 0.22715454f, -0.00416024f, 0.02077039f, 
    0.03777034f, 0.15190561f, 0.00949846f, -0.01252704f, 0.03535638f, -0.11203036f, -0.12706976f, -0.24216567f, 
    0.01983246f, -0.25542668f, -0.22926471f, 0.18266422f, 0.02721632f, 0.10884686f, -0.07364280f, -0.37275848f, 
    -0.30696571f, -0.05673195f, 0.19706631f, -0.02309474f, 0.00745622f, 0.08550042f, 0.23074901f, 0.15072986f, 
    -0.20353812f, 0.14457418f, -0.33821404f, -0.22138798f, 0.26539570f, -0.06881791f, 0.25894710f, -0.07154465f, 
    -0.05856676f, 0.08618889f, -0.00627534f, -0.02713374f, 0.13867082f, 0.16828284f, 0.00399169f, 0.14776136f, 
    0.23137212f, 0.36348054f, -0.07123530f, -0.35083437f, -0.02953868f, 0.03781343f, 0.23286909f, -0.43075806f, 
    -0.15864705f, 0.01499023f, 0.57078141f, 0.16746315f, 0.06373604f, 0.20458257f, -0.03407724f, 0.04017284f, 
    -0.15650971f, 0.05046057f, -0.00770126f, 0.39525890f, 0.14801626f, 0.40710741f, 0.20927289f, -0.28575471f, 
    -0.17351229f, -0.00770916f, -0.24679616f, -0.12102278f, -0.21702139f, -0.03183838f, 0.56734478f, -0.07061101f, 
    -0.08740247f, -0.04717823f, 0.27883333f, -0.01692857f, -0.07530918f, -0.12774970f, 0.10417544f, -0.10413984f, 
    0.14419794f, 0.05675071f, -0.01083865f, 0.12744805f, -0.21134126f, -0.07720201f, 0.07158363f, -0.33408666f, 
    0.08839107f, 0.12524903f, 0.18148552f, -0.38804725f, -0.09691252f, -0.36557198f, 0.12017547f, -0.54037601f, 
    0.10733923f, -0.13579252f, 0.07256398f, 0.03741673f, 0.16558751f, -0.41761783f, 0.34639937f, -0.13854858f, 
    -0.03506070f, 0.18423191f, 0.17516726f, 0.00709295f, 0.66162789f, 0.18294337f, -0.28891674f, -0.01002655f, 
    -0.03448623f, -0.00410200f, -0.16348995f, -0.02704717f, 0.13084416f, 0.12447356f, 0.00949976f, 0.07728624f, 
    0.04646778f, 0.06415061f, -0.05342073f, -0.03705363f, 0.11031786f, -0.10911367f, -0.25432274f, 0.22098696f, 
    0.12604167f, -0.09482556f, 0.06401660f, -0.04405509f, 0.00606406f, -0.06335349f, 0.27700242f, 0.18987986f, 
    0.05818193f, -0.07401690f, -0.30500111f, 0.40193534f, 0.06708121f, 0.16789311f, 0.08178596f, -0.20955268f, 
    0.02203008f, -0.01364772f, 0.18461959f, 0.08534316f, -0.03555044f, 0.03354676f, -0.01939098f, 0.00101054f, 
    -0.19103983f, 0.07850714f, -0.26024911f, -0.21280791f, 0.06159526f, -0.17778037f, 0.24602754f, 0.18421374f, 
    0.13311735f, 0.26732919f, 0.11473272f, -0.00285615f, 0.08139482f, 0.11828075f, 0.21275109f, 0.21322478f, 
    -0.06150592f, 0.18094066f, 0.13108255f, -0.28362688f, 0.08326188f, 0.07184107f, 0.35625821f, -0.00178565f, 
    -0.05889247f, -0.08398902f, -0.34605882f, 0.04018669f, -0.32561493f, 0.14672416f, -0.07420829f, 0.01728317f, 
    -0.13606249f, 0.09533624f, 0.01373057f, -0.03943641f, -0.08244173f, 0.07437097f, 0.12852335f, -0.04444249f, 
    0.00423413f, 0.00817650f, 0.01121183f, -0.11417740f, 0.41785845f, 0.00004997f, 0.39979583f, 0.08583378f, 
    -0.09262990f, -0.04913972f, 0.16386326f, -0.19225658f, 0.17313543f, -0.07660172f, 0.07581359f, 0.13016334f, 
    0.14799081f, 0.14091565f, 0.03296074f, 0.16966735f, 0.22881000f, 0.10725957f, 0.17618813f, -0.18869069f, 
    0.09119449f, 0.16352582f, 0.21435302f, -0.26114529f, -0.12336987f, 0.03627653f, -0.35593960f, 0.02909299f, 
    -0.07252167f, -0.08014137f, -0.03243000f, -0.12769663f, 0.21188183f, -0.23809139f, -0.25307146f, -0.31272218f, 
    0.37372082f, 0.03132105f, 0.02360056f, -0.09135143f, 0.10823485f, -0.03772647f, 0.09171247f, 0.13668302f, 
    0.05639424f, 0.07025722f, 0.06382040f, 0.02022394f, -0.02339586f, 0.06056109f, -0.07528056f, -0.06222010f, 
    -0.05025200f, -0.01386464f, 0.05481312f, -0.01903622f, -0.02715073f, -0.05288882f, 0.04672591f, 0.00326165f, 
    0.01261986f, 0.03659939f, -0.05371327f, -0.04358720f, 0.03647404f, -0.01312758f, -0.01781447f, -0.05060583f, 
    -0.00591350f, 0.02073630f, 0.05535181f, 0.05117832f, -0.06422043f, -0.07383236f, -0.07774540f, -0.03780927f, 
    0.05500445f, 0.05028420f, -0.09342977f, 0.01831077f, -0.08939166f, 0.07534894f, -0.04278452f, 0.06902590f, 
    -0.08735677f, 0.04591480f, -0.01099699f, 0.03314617f, -0.05823032f, -0.04332641f, -0.06463269f, -0.03640343f, 
    0.01836662f, 0.07387701f, -0.05252897f, 0.02218397f, -0.02044767f, -0.00267481f, -0.01188810f, -0.07438425f, 
    -0.04578011f, 0.00379879f, -0.03835520f, 0.00369159f, 0.02577537f, 0.00750075f, -0.03579555f, -0.05070099f, 
    0.03724623f, -0.00048277f, -0.04504177f, -0.05795031f, -0.02529715f, 0.03800034f, 0.05100362f, 0.02154447f, 
    -0.09132978f, -0.05235028f, -0.08703853f, -0.07931671f, 0.00775771f, -0.07852476f, -0.09000760f, -0.07882381f, 
    -0.02549354f, -0.03905522f, 0.05475871f, -0.07483070f, 0.03936221f, 0.01044824f, 0.01038472f, -0.08898477f, 
    0.01951739f, 0.03399435f, 0.07674555f, -0.02465702f, 0.01246379f, 0.02247890f, 0.01708402f, -0.03691835f, 
    -0.08172592f, -0.07447517f, -0.03957557f, 0.00073011f, -0.06311773f, 0.00759516f, -0.03616222f, -0.08410425f, 
    -0.02248333f, -0.08180769f, -0.00390456f, -0.08462145f, 0.00710969f, -0.05496713f, -0.03395106f, 0.06958872f, 
    -0.06307267f, 0.05557787f, 0.01251558f, -0.00695154f, -0.01505558f, -0.02752060f, 0.07738275f, -0.00705724f, 
    -0.07778230f, -0.05769217f, 0.07092553f, -0.02663040f, -0.06000535f, 0.03556066f, -0.05162514f, 0.05555654f, 
    -0.06662617f, -0.07576914f, -0.04332993f, 0.05855546f, 0.07552567f, -0.07795198f, 0.02566328f, -0.07875728f, 
    0.04298576f, -0.07823098f, -0.01758158f, -0.00433695f, -0.07714225f, -0.06975756f, -0.07498750f, -0.07758496f, 
    -0.02480130f, -0.04228241f, 0.02916900f, -0.09385627f, 0.03666584f, -0.03726977f, -0.10447755f, -0.09033420f, 
    -0.11503698f, 0.02201139f, -0.02378017f, 0.05745714f, 0.01752274f, 0.02876000f, -0.01669240f, 0.04437716f, 
    0.03333181f, 0.07301362f, -0.01011535f, 0.06372230f, 0.00088450f, -0.00691453f, -0.07423231f, -0.06619585f, 
    0.01004786f, -0.09902944f, 0.00845041f, -0.03001064f, -0.02992835f, 0.04551243f, 0.05462589f, 0.06808502f, 
    -0.00992481f, 0.01166589f, 0.01477574f, 0.06812539f, -0.00824615f, 0.06267610f, -0.03870592f, 0.01388249f, 
    -0.01405219f, -0.03023545f, -0.10609617f, 0.02522081f, 0.06882852f, 0.01639932f, -0.07013879f, -0.08887643f, 
    -0.09407149f, -0.04726114f, 0.07355920f, 0.02889293f, 0.01438291f, -0.01635476f, 0.03010923f, 0.00348354f, 
    -0.08251873f, 0.05351814f, 0.05079627f, 0.04010726f, -0.01183526f, 0.00100266f, 0.01770424f, -0.04469097f, 
    -0.07224263f, -0.02028453f, -0.03286144f, -0.03388150f, -0.01337304f, -0.10224881f, -0.02678740f, 0.01450781f, 
    -0.04411763f, -0.05471523f, -0.03460377f, -0.06625627f, -0.09473065f, -0.05833619f, -0.00082412f, 0.01429043f, 
    -0.00125374f, -0.05911738f, 0.00444535f, -0.08137729f, 0.04233602f, -0.02167261f, 0.07750076f, -0.06683248f, 
    -0.11488118f, -0.02176959f, -0.05675808f, -0.00663314f, 0.04838107f, -0.00825267f, -0.08472263f, -0.06691797f, 
    0.03455870f, -0.04597879f, 0.03472947f, -0.03241161f, -0.04246330f, 0.03897706f, 0.07420043f, -0.03877351f, 
    0.04993661f, 0.00285362f, -0.02851810f, -0.09181292f, 0.06641460f, -0.09665014f, 0.04003058f, -0.07519517f, 
    -0.06720717f, 0.00419965f, -0.02558727f, -0.00291232f, -0.07996637f, 0.02231486f, 0.01390332f, -0.00217570f, 
    0.01051620f, 0.02243925f, 0.01953549f, 0.04218268f, -0.07587406f, 0.03230229f, -0.02928538f, -0.07496735f, 
    0.01173528f, -0.03360978f, -0.01336924f, -0.02259528f, 0.01932243f, 0.01307920f, -0.02977187f, -0.01634181f, 
    0.06683173f, -0.09944559f, -0.02660422f, -0.09992556f, -0.00187558f, -0.08330195f, 0.06427515f, -0.00798790f, 
    -0.10495347f, -0.08683484f, -0.01706422f, -0.04495228f, -0.00956698f, 0.03369142f, -0.03840780f, 0.02830688f, 
    0.05818608f, -0.00768637f, 0.00782745f, 0.01272363f, -0.02197068f, -0.08746444f, 0.03832140f, -0.00492065f, 
    0.01181340f, 0.02561987f, -0.07007963f, 0.00724720f, 0.01081774f, -0.09568604f, 0.00265584f, 0.03876784f, 
    -0.05939075f, -0.06677911f, -0.09320494f, 0.06925928f, -0.03784760f, -0.02181505f, -0.02504642f, 0.07096094f, 
    -0.00590790f, -0.04756599f, -0.04919741f, 0.01133692f, 0.04745984f, -0.09987952f, 0.05391158f, -0.08310700f, 
    -0.03616532f, 0.04262563f, -0.07988694f, 0.00158569f, -0.05428752f, -0.08056439f, 0.03816060f, -0.07182053f, 
    0.05724788f, 0.05307577f, 0.05503571f, 0.08511934f, -0.09599966f, -0.08117187f, -0.10827651f, -0.04590975f, 
    0.05115793f, 0.06960064f, -0.01202097f, 0.00754205f, -0.01681227f, 0.02919736f, 0.03670759f, -0.09726907f, 
    -0.10129748f, -0.07132244f, 0.02048440f, 0.03212050f, -0.03875975f, 0.01168178f, -0.03188749f, 0.04901963f, 
    0.01892572f, 0.01561996f, -0.07614856f, -0.07550450f, -0.04686253f, -0.03711288f, 0.04461640f, -0.08919847f, 
    0.06021876f, -0.06304149f, 0.01773424f, -0.03918484f, -0.10333610f, 0.04861217f, -0.07848887f, 0.03812411f, 
    0.01739048f, -0.06768292f, -0.09883288f, -0.07985689f, -0.01401228f, 0.03140530f, -0.01347995f, 0.02708049f, 
    -0.04162999f, 0.13087131f, -0.10221377f, -0.04453497f, 0.02780747f, 0.06802378f, 0.06913412f, -0.00707045f, 
    0.18148781f, 0.02032877f, -0.05861681f, 0.12920775f, 0.22289118f, 0.25569841f, -0.16976510f, 0.17779833f, 
    -0.36544222f, -0.42611164f, 0.00018384f, 0.00206953f, 0.01038047f, 0.06211128f, 0.23342448f, -0.06095714f, 
    0.15927452f, 0.00915750f, -0.22465648f, 0.16873631f, -0.08066386f, 0.11466870f, -0.24330792f, 0.00684763f, 
    -0.07991916f, -0.15956348f, 0.18054222f, -0.05360584f, -0.09154423f, -0.07806227f, 0.14196298f, 0.01506687f, 
    -0.49306971f, 0.10468259f, -0.17760576f, 0.21655075f, -0.16736832f, 0.17647432f, -0.05559915f, 0.15540522f, 
    -0.01380328f, 0.10064612f, 0.12953167f, -0.10270895f, -0.01357023f, 0.11089130f, -0.05663164f, 0.06736426f, 
    -0.05955755f, 0.14182492f, 0.10284318f, 0.05489361f, -0.35583168f, 0.17303252f, 0.31640351f, -0.01309516f, 
    0.02236713f, 0.09804257f, -0.12517717f, 0.00119092f, -0.22501928f, 0.04183789f, 0.00672414f, 0.00620629f, 
    0.00915459f, -0.48620588f, 0.06240715f, -0.29550076f, 0.24283610f, 0.38645315f, 0.16968770f, -0.08213416f, 
    0.10911047f, 0.01154661f, -0.27682349f, -0.16241021f, 0.18180725f, 0.00595113f, 0.19756924f, -0.14085110f, 
    -0.13182595f, -0.35447228f, 0.06030006f, -0.28212222f, 0.18982401f, -0.36727327f, -0.16567381f, -0.13867636f, 
    0.00010006f, -0.08528347f, 0.04325062f, 0.12814091f, 0.06377062f, -0.10741673f, -0.03086234f, -0.07595590f, 
    -0.11824358f, -0.18614371f, -0.12877434f, -0.12714590f, 0.29843315f, 0.09523243f, 0.00555796f, -0.09577989f, 
    -0.39992040f, 0.24072002f, 0.02767710f, -0.20743206f, 0.34224504f, -0.03712537f, -0.63782865f, -0.44258818f, 
    0.11869304f, -0.11878680f, 0.01479590f, -0.16833782f, -0.03446377f, -0.26401922f, 0.34803119f, -0.00859292f, 
    -0.07956629f, 0.28430504f, 0.30926958f, -0.04755818f, 0.02824342f, 0.14212978f, -0.40495202f, 0.09260885f, 
    0.13644814f, -0.09428839f, 0.09836634f, 0.03803397f, 0.12093634f, -0.10599810f, -0.23931149f, 0.19377393f, 
    0.14070146f, -0.17068712f, -0.03885715f, -0.03029406f, 0.12213372f, -0.10039317f, -0.29162660f, 0.04966713f, 
    0.24113649f, 0.02648912f, -0.42607743f, 0.13450955f, 0.05714639f, -0.20132221f, -0.10510284f, 0.00782121f, 
    -0.13687852f, 0.04783684f, 0.26012859f, 0.00696139f, 0.04928655f, -0.01154664f, -0.14787215f, 0.04607631f, 
    -0.09460881f, -0.03606347f, -0.31479922f, 0.22775796f, -0.43428186f, -0.19630240f, -0.09134684f, -0.23536089f, 
    0.06035723f, 0.32972687f, 0.22070599f, -0.13374768f, -0.06155796f, 0.19678245f, 0.50091046f, 0.06537135f, 
    -0.03738104f, 0.00440737f, 0.10184185f, 0.00106907f, -0.57073575f, -0.12079411f, 0.02484648f, 0.07227901f, 
    -0.00856613f, 0.00217431f, -0.89596927f, 0.06809689f, -0.26711115f, -0.04061028f, -0.05692969f, -0.05737017f, 
    0.17418694f, -0.08955713f, 0.02551781f, -0.13292779f, -0.40383798f, -0.01707890f, -0.20643139f, -0.03313435f, 
    0.03933492f, -0.02324888f, 0.21138099f, -0.06482637f, 0.20500137f, 0.29277751f, -0.39574957f, -0.08401397f, 
    0.23334022f, -0.22145602f, 0.11291497f, -0.15064663f, 0.10429735f, 0.11824801f, 0.00471525f, 0.04141976f, 
    -0.03360789f, -0.18399349f, -0.03259691f, -0.08187117f, -0.16122325f, 0.02887882f, 0.05036213f, -0.37622833f, 
    0.04013489f, 0.04253513f, -0.03168022f, -0.03834370f, 0.13440269f, 0.02708297f, -0.07215543f, 0.07955600f, 
    -0.03422278f, 0.20355016f, 0.08130945f, -0.34209239f, -0.50353026f, -0.28702933f, 0.05333152f, -0.28861567f, 
    0.04271831f, 0.07242820f, -0.01712724f, -0.00076119f, -0.09253823f, 0.02857274f, 0.22356141f, 0.08124329f, 
    0.10508373f, -0.65435183f, 0.01208734f, 0.04635189f, -0.14565296f, 0.14163487f, -0.17796849f, -0.04115978f, 
    -0.08021385f, 0.06062070f, -0.03422887f, -0.04552956f, -0.13172010f, -0.25926498f, 0.00688714f, -0.04970436f, 
    0.03262613f, 0.14421648f, 0.02409830f, 0.31839806f, -0.18208349f, 0.24105060f, -0.22565061f, 0.26761392f, 
    -0.05515225f, -0.00034703f, -0.04935996f, 0.05114359f, 0.05502268f, 0.17633928f, 0.22392246f, -0.38763133f, 
    -0.23232144f, 0.24680386f, 0.08906104f, -0.12725084f, 0.25577626f, 0.05434772f, 0.08292877f, 0.08624699f, 
    0.20435612f, -0.04896752f, -0.04806808f, -0.17185496f, 0.37103701f, -0.11292643f, 0.06913974f, -0.08900645f, 
    0.05516909f, -0.06753764f, 0.18954504f, 0.12164012f, 0.16522205f, 0.05085034f, -0.19230191f, -0.20430961f, 
    0.09106357f, -0.03901230f, -0.08942831f, -0.12321363f, 0.27109078f, 0.09138204f, 0.11252778f, 0.13700970f, 
    -0.06339601f, -0.02471653f, -0.17531851f, 0.15282565f, -0.03076321f, 0.02495920f, -0.00476699f, 0.01647729f, 
    -0.37784430f, 0.10634685f, -0.07471348f, 0.23316100f, -0.08755337f, -0.37098265f, 0.30376810f, 0.10890019f, 
    0.30013758f, 0.00220047f, 0.20373225f, -0.10644938f, -0.37093240f, -0.25356570f, 0.16570763f, 0.15685840f, 
    0.01718552f, 0.01395999f, 0.17469785f, -0.16012987f, -0.20708083f, 0.08064846f, -0.03519225f, 0.25980923f, 
    -0.12957767f, 0.20619701f, -0.03211513f, 0.11763775f, 0.19023964f, -0.00270079f, 0.09590460f, 0.05229253f, 
    0.10470384f, 0.21292298f, 0.19820821f, -0.18941270f, -0.40381142f, -0.20717628f, -0.39673230f, -0.10542209f, 
    0.27454183f, 0.07269841f, -0.04427501f, 0.34345597f, 0.42434031f, -0.21650258f, -0.26318204f, 0.15092395f, 
    0.18870091f, 0.13115810f, -0.03789466f, 0.12051465f, 0.09487272f, 0.06960128f, -0.17109784f, 0.42293480f, 
    0.18449846f, 0.39318052f, -0.09691411f, -0.05059412f, -0.07647971f, -0.18891662f, -0.35369539f, -0.00507217f, 
    -0.01086506f, 0.16666244f, -0.04993065f, 0.06929453f, -0.20797624f, -0.20736313f, 0.19606888f, -0.08988254f, 
    -0.31280991f, 0.19301909f, -0.02115112f, 0.13461544f, -0.22381712f, -0.18536766f, -0.28544453f, -0.06871419f, 
    -0.04846033f, -0.10992315f, -0.10723278f, 0.06078773f, 0.05190383f, 0.26221642f, 0.14946893f, -0.85816419f, 
    -0.63150364f, 0.02913876f, -0.01658341f, -0.07110346f, 0.19325593f, -0.01649909f, 0.22674005f, 0.09441029f, 
    -0.08038527f, -0.03495626f, -0.06858560f, -0.15529409f, 0.31106004f, 0.00567264f, 0.08749373f, -0.19304672f, 
    0.00809327f, 0.01590688f, -0.13035513f, -0.22040331f, 0.16482089f, -0.09588293f, -0.15144640f, 0.02126146f, 
    0.03472894f, 0.14632270f, 0.07285944f, -0.46574965f, 0.39914155f, 0.18157938f, 0.09684476f, -0.21962659f, 
    -0.38747898f, -0.05301122f, 0.93997473f, -0.04127499f, -0.24630441f, 0.22538894f, -0.01613991f, -0.07886339f, 
    -0.43172100f, 0.12071855f, 0.04224164f, 0.34494850f, 0.29250768f, -0.25368109f, 0.29601526f, 0.07315347f, 
    0.11062860f, -0.03673498f, -0.17444132f, -0.04484233f, -0.13932234f, -0.05398308f, 0.42402992f, 0.05220685f, 
    -0.04042257f, -0.01592030f, 0.27787691f, -0.27828366f, -0.19442312f, -0.11008836f, 0.12515748f, 0.13817528f, 
    -0.12976807f, 0.03018466f, -0.01116157f, 0.06265470f, -0.02100115f, -0.11077824f, 0.05979139f, -0.07632374f, 
    0.11628637f, 0.19324487f, 0.04404650f, -0.57424945f, -0.44608033f, -0.36737087f, -0.22608867f, -0.40878806f, 
    0.10236955f, -0.06915464f, -0.05555081f, 0.37038934f, 0.37945494f, -0.25074828f, 0.02377935f, 0.27127063f, 
    -0.04864218f, 0.16894029f, 0.23449636f, -0.01254564f, 0.35403523f, 0.00296569f, -0.24128705f, 0.12418693f, 
    -0.05626661f, 0.05726006f, 0.05161000f, 0.03817536f, 0.07710253f, -0.05837722f, 0.01087462f, 0.01395768f, 
    -0.05414160f, -0.07666679f, 0.02584510f, 0.00000535f, -0.02046959f, 0.03327382f, -0.06349099f, -0.04324009f, 
    0.05913370f, -0.01434889f, -0.08836762f, -0.07953723f, -0.10314972f, -0.10120049f, -0.08664899f, -0.00134595f, 
    -0.04433379f, -0.10804760f, 0.02255402f, -0.05020084f, 0.07865637f, -0.03481986f, -0.00749960f, -0.04786317f, 
    0.01149803f, 0.00402232f, 0.05295195f, 0.03796090f, 0.03759862f, -0.07593475f, -0.04993781f, -0.03225300f, 
    -0.06529460f, -0.11260871f, -0.03413381f, -0.07562735f, -0.00954094f, 0.03412580f, 0.06349965f, 0.02020572f, 
    -0.04731125f, -0.02163144f, 0.01949639f, 0.04653740f, 0.00511368f, -0.07144749f, -0.03467084f, -0.09444772f, 
    0.05512072f, -0.10046358f, -0.08907664f, -0.11672307f, 0.06667254f, -0.05723650f, 0.03318181f, -0.05930308f, 
    -0.08270565f, -0.05553458f, -0.01837448f, -0.00123230f, 0.08662523f, 0.00659263f, -0.06006027f, -0.00223298f, 
    -0.07088427f, -0.04681559f, -0.04705858f, -0.06536623f, 0.05340080f, -0.02360557f, -0.08029488f, -0.04080848f, 
    0.06071483f, 0.03474632f, -0.03594800f, -0.05838029f, 0.02546645f, -0.00426700f, -0.02692190f, 0.00122030f, 
    0.01283656f, -0.09104186f, -0.06461144f, 0.05574657f, -0.10926817f, 0.08572966f, 0.02798908f, -0.06897303f, 
    0.04054056f, -0.11471081f, -0.05271215f, -0.09664325f, -0.08356981f, 0.00623630f, -0.06281465f, -0.00056132f, 
    -0.01362197f, 0.02237644f, -0.01610867f, 0.03591854f, -0.06665386f, -0.04922671f, -0.11450531f, -0.07137223f, 
    -0.02217619f, -0.09002099f, -0.04181565f, -0.02185687f, -0.06982749f, 0.01520169f, 0.06055676f, -0.07271899f, 
    -0.11261638f, 0.01046138f, -0.00449448f, -0.02474086f, -0.01656018f, 0.06637432f, -0.01566721f, -0.03658617f, 
    0.18437351f, 0.00789795f, 0.17714320f, 0.00734746f, 0.19957453f, -0.10509103f, -0.03071966f, 0.10457447f, 
    0.03389811f, 0.12239059f, 0.01940766f, 0.09479675f, 0.11555431f, 0.12004536f, 0.37240207f, 0.18637379f, 
    -0.28644934f, 0.20338807f, 0.00394121f, 0.07318205f, -0.15361829f, 0.00596535f, 0.09986937f, -0.00087832f, 
    -0.11892214f, -0.05208587f, 0.18666716f, -0.19054188f, 0.05359682f, -0.11269940f, -0.03219977f, -0.06269982f, 
    -0.11459857f, 0.08822352f, -0.23891534f, 0.04491463f, 0.12725525f, -0.08799855f, 0.12778747f, 0.08274169f, 
    -0.02253146f, -0.11542345f, 0.01993615f, 0.26310903f, -0.10429236f, 0.11263429f, -0.02759382f, -0.17299905f, 
    0.04853046f, 0.14322181f, -0.20558329f, 0.19656658f, 0.15477835f, 0.09933638f, -0.22586976f, 0.05259882f, 
    0.22326232f, 0.01198844f, -0.08643212f, -0.01185131f, 0.32640624f, -0.30133134f, -0.18518922f, -0.15160112f, 
    -0.04798752f, 0.06640905f, -0.16742948f, 0.07816048f, 0.15626214f, 0.03820651f, 0.00631500f, -0.00327539f, 
    0.28971121f, 0.05217125f, -0.02845613f, 0.52481228f, -0.03653794f, -0.31545597f, -0.15182212f, 0.01865261f, 
    -0.00470452f, 0.06768959f, 0.22486806f, 0.29081428f, 0.27539641f, -0.30109283f, -0.32439247f, -0.23231825f, 
    -0.05192856f, 0.08349717f, -0.09828323f, 0.14490849f, 0.08112626f, 0.10112923f, 0.06961413f, 0.13738485f, 
    0.02868424f, 0.00263610f, -0.04580747f, -0.33132479f, -0.01210691f, 0.09496515f, -0.07598261f, -0.08490509f, 
    0.20157085f, 0.01016888f, -0.06539159f, 0.08193538f, 0.13568576f, -0.27439973f, 0.13961491f, 0.27424547f, 
    0.26003250f, -0.10538676f, -0.02009220f, 0.21756098f, 0.07639103f, 0.02214568f, -0.03158421f, 0.28174114f, 
    0.03602334f, 0.01081561f, -0.11594126f, -0.02570675f, 0.06897788f, 0.08826508f, 0.14919549f, 0.13445278f, 
    0.02870432f, -0.04589405f, -0.05736509f, 0.03246998f, -0.00734563f, 0.05089728f, 0.03870573f, 0.01255739f, 
    -0.07571171f, -0.09142996f, 0.03139216f, 0.07197843f, 0.05492654f, -0.01525392f, -0.06177223f, -0.05776533f, 
    -0.05964783f, 0.07404864f, -0.00398037f, -0.05867686f, -0.08018975f, 0.06383784f, 0.01426607f, -0.00036077f, 
    0.07801077f, 0.01674693f, 0.00316729f, 0.01892376f, 0.08537417f, -0.00008779f, 0.00376724f, -0.00951584f, 
    0.01856494f, -0.01232958f, -0.06098914f, -0.01581927f, -0.04215463f, -0.04971927f, 0.02775137f, 0.01442868f, 
    -0.07501704f, -0.06646010f, -0.01557213f, -0.01965857f, -0.02922152f, -0.07376477f, 0.05477272f, -0.00984153f, 
    -0.00785978f, -0.07478133f, -0.01630690f, 0.00979489f, 0.07175997f, -0.07339759f, 0.04912310f, -0.07956596f, 
    -0.08136404f, -0.09234431f, -0.03803395f, -0.04011710f, 0.01765196f, -0.00199365f, 0.00279751f, -0.02920938f, 
    0.00316244f, 0.08654013f, 0.03782713f, 0.02356721f, -0.05330690f, 0.03847459f, -0.06381568f, 0.04104768f, 
    -0.00655268f, 0.01918315f, -0.02616343f, -0.02178295f, -0.05679054f, 0.03193032f, -0.06959086f, -0.02122193f, 
    -0.03917111f, 0.00126551f, -0.00548765f, 0.05736312f, -0.07855111f, 0.00879033f, -0.03877883f, -0.05324086f, 
    0.07077152f, 0.01217927f, -0.08161033f, 0.03964854f, 0.02939609f, -0.06364442f, 0.07356493f, -0.01385034f, 
    0.06748251f, -0.06840510f, -0.07736349f, 0.09261946f, -0.08324429f, -0.02747867f, 0.05395248f, -0.02322258f, 
    0.08017680f, -0.05062350f, 0.02728432f, -0.05901212f, -0.06097952f, -0.06563132f, -0.01055325f, -0.07244015f, 
    0.04162855f, -0.01499247f, 0.00600798f, -0.06429604f, 0.03045969f, -0.03712956f, -0.04954901f, 0.08032254f, 
    0.07433687f, -0.06378673f, 0.06155601f, -0.07631528f, 0.07026188f, -0.05788199f, 0.04518428f, -0.04925014f, 
    -0.02694999f, -0.03491440f, -0.12507340f, 0.00135343f, 0.03753511f, 0.01413366f, -0.02286736f, -0.04116096f, 
    0.01836077f, 0.03390933f, -0.03079479f, -0.01698840f, -0.09195472f, -0.03494339f, -0.09939291f, -0.09781819f, 
    0.01682157f, 0.03229708f, 0.05672906f, -0.07519355f, 0.00614946f, -0.09626188f, -0.06591611f, -0.10008669f, 
    -0.02448472f, -0.01856779f, -0.07569776f, -0.00582435f, -0.05240657f, -0.02589336f, -0.02076060f, -0.00284937f, 
    -0.01417434f, -0.02603931f, -0.01899070f, -0.12029310f, -0.07975196f, 0.03332973f, 0.02064624f, -0.06930055f, 
    0.03179739f, -0.04495697f, -0.04304421f, 0.05135894f, 0.00225733f, 0.00231736f, -0.01505764f, 0.06783569f, 
    0.04886665f, -0.05381690f, -0.00827502f, -0.04673277f, -0.04079371f, -0.11477726f, -0.07142953f, -0.09054196f, 
    0.04684880f, 0.03983803f, 0.03427130f, -0.08344836f, -0.06054340f, -0.04046065f, 0.01447643f, 0.00406142f, 
    0.05977571f, 0.05271997f, -0.02721503f, -0.09013047f, 0.00883454f, -0.09167036f, 0.07373423f, -0.02385581f, 
    -0.10542450f, -0.03752373f, -0.08221129f, -0.01554468f, -0.05375911f, -0.04538288f, -0.12275176f, -0.00200503f, 
    -0.08186853f, 0.08376718f, -0.04198998f, 0.01189248f, 0.05090345f, -0.04933686f, -0.04654872f, -0.02529353f, 
    0.04547296f, -0.09855601f, 0.05285579f, -0.00327401f, -0.06166112f, 0.00110528f, 0.05213561f, -0.07786521f, 
    -0.06209491f, -0.05002234f, -0.00016103f, -0.06913505f, -0.11847837f, -0.11077335f, 0.01393656f, -0.02476479f, 
    -0.04738361f, 0.01939246f, -0.11623729f, -0.07561783f, 0.03327651f, -0.07019743f, 0.03090793f, 0.01458930f, 
    -0.08923642f, -0.06769105f, 0.03547698f, -0.06928106f, -0.07734439f, -0.04345012f, -0.04984565f, 0.02125199f, 
    -0.05375462f, -0.13022292f, 0.01501443f, -0.05925348f, -0.10411362f, 0.04486093f, -0.12467317f, -0.06006164f, 
    0.10388025f, 0.02088734f, 0.56940264f, 0.05742237f, 0.32859582f, -0.09005727f, 0.14123887f, 0.09393109f, 
    -0.21582526f, 0.05066340f, 0.12020849f, -0.05959431f, 0.14091484f, 0.07133269f, 0.09028120f, 0.01084581f, 
    -0.17929083f, 0.20989041f, 0.02707807f, 0.08403184f, -0.18415810f, -0.23184781f, 0.24812476f, 0.05810094f, 
    -0.13716750f, 0.05538782f, 0.04836990f, -0.14450380f, 0.01342897f, 0.07257207f, 0.13874708f, -0.02841422f, 
    0.02526085f, -0.01958042f, 0.01452075f, 0.01654640f, 0.07415204f, 0.00242268f, 0.14657265f, 0.06097947f, 
    -0.17434222f, -0.18264320f, -0.01533885f, -0.11999827f, 0.12999374f, 0.29536983f, 0.04884432f, -0.31950626f, 
    -0.00916939f, 0.16544257f, -0.39259678f, 0.14409789f, -0.06653412f, -0.02845295f, 0.00579090f, 0.12139937f, 
    0.09228581f, 0.11475796f, 0.01486653f, -0.22220035f, 0.07783329f, -0.10667504f, 0.02792340f, 0.14177753f, 
    -0.06440883f, 0.03943397f, -0.39376351f, -0.17348063f, 0.50023448f, 0.00034655f, -0.03035425f, 0.02025150f, 
    0.16036326f, 0.20531186f, -0.06631047f, 0.55430895f, 0.07719288f, -0.05036253f, -0.08455240f, 0.08435339f, 
    0.13066407f, -0.04582299f, 0.15955064f, 0.16471250f, 0.48191032f, 0.10198470f, 0.01748665f, -0.08379639f, 
    -0.03301872f, 0.15094188f, -0.14294229f, -0.01570302f, 0.19715548f, -0.09545162f, 0.13649556f, -0.01082507f, 
    -0.13544160f, 0.07765514f, 0.08671835f, -0.12863261f, -0.11507294f, -0.10446625f, -0.13377465f, 0.06629904f, 
    0.09734552f, 0.07295749f, -0.01459147f, 0.01809411f, 0.13654052f, -0.16495708f, 0.31042039f, 0.07760791f, 
    0.30975655f, -0.19857043f, 0.02963595f, 0.13608547f, 0.01216749f, 0.01754008f, -0.01637352f, -0.04765154f, 
    0.13228047f, 0.06731102f, 0.11471687f, -0.15663080f, 0.20899884f, 0.10009010f, 0.10366462f, 0.02201174f, 
    -0.04196310f, 0.35950339f, -0.03348639f, -0.08041686f, -0.01749122f, 0.27330855f, -0.05535259f, -0.14426959f, 
    -0.14029257f, 0.23742920f, -0.07563168f, 0.04159228f, -0.06707795f, 0.01121899f, -0.24827994f, 0.02036396f, 
    -0.06128594f, -0.03012286f, 0.04105471f, 0.25198042f, -0.11975764f, -0.10308685f, 0.06307633f, 0.28612638f, 
    0.20486625f, 0.29336083f, -0.10424954f, 0.16675206f, 0.02457230f, 0.25894654f, 0.17829295f, -0.31097153f, 
    -0.03289507f, -0.03728365f, 0.03399172f, 0.04504155f, 0.12917475f, -0.07548904f, -0.19221362f, 0.19239338f, 
    -0.03351048f, -0.04758214f, 0.00200356f, 0.15066151f, -0.10147014f, -0.07377783f, 0.13394412f, -0.11284254f, 
    0.24825150f, 0.05633082f, 0.15660651f, -0.02509511f, 0.26563570f, -0.08660663f, -0.09217986f, 0.04520438f, 
    -0.25273463f, -0.03250476f, 0.26129642f, -0.08849348f, -0.14886586f, 0.11634392f, 0.19735788f, 0.17870963f, 
    -0.10053154f, 0.05392422f, -0.82480991f, -0.09275629f, -0.12683640f, -0.00521041f, -0.00728914f, -0.01741009f, 
    -0.14464124f, 0.19705544f, -0.06135527f, -0.10539283f, -0.02008029f, -0.16618344f, 0.04695090f, 0.40586290f, 
    0.23291615f, -0.04523258f, 0.11255644f, 0.01168344f, 0.12647262f, 0.07145599f, -0.13700433f, 0.31749868f, 
    0.20463593f, -0.15474346f, 0.08903883f, -0.16178557f, -0.02368286f, -0.06036748f, 0.16944189f, 0.27343252f, 
    0.01360686f, -0.08788799f, 0.07766636f, 0.02830835f, 0.01675361f, 0.05724316f, -0.08974674f, 0.08391430f, 
    -0.13460156f, 0.12030362f, -0.08717917f, 0.02776043f, -0.10629482f, 0.03847108f, 0.00303781f, 0.09232589f, 
    -0.05452758f, 0.41565323f, -0.05521319f, 0.06071510f, 0.12379768f, -0.02600247f, -0.38920960f, -0.24526589f, 
    0.29187098f, 0.18159498f, 0.19585060f, 0.13982199f, -0.23805104f, -0.09978131f, 0.26921782f, 0.30923858f, 
    -0.00590613f, -0.03141409f, -0.05627909f, -0.02636129f, -0.04252176f, -0.00272188f, 0.00951583f, -0.02827667f, 
    0.02511136f, -0.07157014f, -0.01411769f, 0.06401967f, -0.04069401f, -0.00034169f, -0.03313585f, 0.05436048f, 
    -0.00155266f, 0.04132451f, -0.03380261f, 0.03485617f, -0.10633741f, 0.06033689f, 0.06743480f, 0.01257432f, 
    0.04941802f, -0.02383335f, 0.02698524f, -0.03599264f, 0.02949866f, 0.04835901f, -0.09414655f, -0.05237625f, 
    -0.08349802f, 0.01271982f, 0.00097999f, -0.04894613f, -0.02430160f, 0.03376631f, 0.03442735f, -0.04451117f, 
    0.07205120f, 0.00266979f, -0.01482230f, -0.05639584f, -0.03623065f, -0.04318367f, -0.01576735f, -0.04775371f, 
    -0.06845368f, 0.07819388f, 0.01406952f, 0.04547530f, 0.05886655f, -0.01394834f, -0.01915982f, -0.10053865f, 
    -0.08510405f, -0.04321630f, 0.03977545f, 0.05610346f, -0.00979554f, 0.04786532f, -0.00045092f, -0.04863079f, 
    0.00351795f, -0.02863728f, -0.01654976f, 0.01179483f, 0.04215222f, 0.02942216f, 0.00894610f, 0.00244643f, 
    -0.04506005f, 0.05433420f, 0.07182529f, -0.00493094f, -0.04016133f, -0.07673293f, -0.09697141f, -0.04938514f, 
    0.01476509f, -0.02175463f, 0.05131783f, 0.01459025f, 0.07664876f, 0.04336200f, -0.02239960f, -0.04112892f, 
    -0.05417469f, -0.06456133f, 0.00681965f, 0.01597274f, 0.06479928f, -0.07780026f, -0.04125034f, -0.06910663f, 
    -0.11036920f, -0.08651797f, -0.08680865f, -0.03395976f, -0.05117110f, 0.00255825f, -0.09681442f, -0.02584233f, 
    -0.05907694f, -0.05203121f, 0.00580754f, 0.00882091f, -0.08145484f, 0.04371427f, -0.05749096f, -0.09250406f, 
    -0.03082243f, 0.00725921f, 0.01558476f, -0.00630751f, 0.04639417f, 0.01074342f, -0.07157607f, -0.05736354f, 
    -0.03600173f, 0.03804946f, 0.04522501f, 0.05027587f, -0.05929400f, -0.07382247f, 0.01745707f, -0.10077634f, 
    -0.07947187f, -0.02270200f, 0.01417210f, 0.04371423f, -0.09171122f, 0.06111810f, -0.00880981f, -0.05820699f, 
    -0.08865162f, 0.04804940f, 0.06948803f, -0.02254043f, -0.03763453f, -0.00655458f, -0.06526896f, -0.02541669f, 
    0.04634964f, -0.07807705f, 0.06452437f, -0.08416428f, -0.09900421f, -0.08139809f, 0.02707743f, -0.06579395f, 
    -0.01560452f, -0.02998013f, -0.00122938f, -0.04464188f, -0.02370524f, 0.01718344f, -0.08966096f, -0.02562216f, 
    0.01667511f, 0.04423834f, -0.06364001f, 0.00808622f, -0.06557602f, -0.01500747f, -0.02786384f, -0.05862677f, 
    -0.04782970f, 0.05185124f, 0.02798945f, 0.04755993f, -0.07773816f, 0.03668232f, 0.05928526f, -0.06534550f, 
    -0.09926739f, -0.05329980f, 0.06937794f, -0.09665520f, -0.06843969f, -0.08356100f, -0.01946515f, -0.03256194f, 
    -0.07643240f, -0.07027949f, -0.03731187f, 0.05075528f, -0.07850683f, -0.04538765f, -0.05023386f, 0.06908667f, 
    0.05304978f, -0.00213441f, 0.04944096f, -0.06437642f, -0.07955306f, 0.05801598f, -0.01792592f, 0.05863270f, 
    0.05174877f, -0.02170930f, 0.07092061f, 0.00702017f, -0.05034609f, -0.08988424f, -0.06742221f, -0.00085290f, 
    0.03955406f, -0.01307716f, -0.08267409f, -0.00933840f, 0.02940154f, 0.03956185f, 0.00284273f, 0.02395152f, 
    0.04343811f, 0.05594503f, 0.03848051f, -0.03164607f, 0.05475014f, 0.03585689f, -0.02450500f, -0.05349610f, 
    -0.10077104f, 0.04736636f, 0.05765256f, -0.06651496f, -0.00678575f, -0.10046252f, -0.07231152f, -0.01553400f, 
    0.00140542f, -0.01593240f, 0.01964043f, -0.06215800f, -0.10455383f, 0.06117380f, -0.01739780f, -0.10208595f, 
    0.05442528f, -0.00120226f, 0.03607790f, 0.04745047f, -0.03364908f, -0.03507519f, -0.04506323f, 0.07013017f, 
    -0.05730580f, 0.08721597f, 0.03393624f, -0.01619485f, 0.00083241f, 0.03917476f, -0.04039275f, -0.06018233f, 
    0.12712793f, -0.45466471f, 0.02070168f, -0.05902789f, 0.22274216f, 0.04429144f, -0.36910984f, 0.06063488f, 
    -0.02125758f, 0.18545780f, 0.05845410f, 0.06658472f, -0.20300969f, -0.19639374f, 0.19356176f, 0.00816784f, 
    -0.19375786f, 0.16609624f, -0.02021556f, 0.24544719f, 0.03754473f, 0.16995668f, -0.39434746f, 0.12515321f, 
    -0.19084743f, 0.02515434f, -0.07397160f, -0.21774767f, 0.03099506f, 0.08140961f, 0.19503462f, -0.15562074f, 
    -0.13731706f, 0.31732368f, -0.30787319f, 0.10416480f, 0.06058437f, 0.03803550f, 0.25307733f, -0.00220333f, 
    0.18404381f, -0.05621616f, 0.00375178f, 0.07029723f, 0.05808534f, -0.06512100f, -0.20643340f, 0.14575398f, 
    0.00645706f, -0.02090766f, -0.00981477f, 0.22995242f, -0.00409776f, 0.00519828f, -0.31687552f, -0.26791489f, 
    0.36384422f, -0.17509891f, -0.16787426f, -0.09528840f, 0.59066147f, -0.28432125f, 0.04564404f, 0.20470427f, 
    -0.25283197f, 0.03013987f, 0.05418065f, 0.08556016f, 0.25464305f, 0.23700772f, -0.01026660f, 0.04979943f, 
    -0.09267617f, 0.21234244f, 0.06916443f, 0.31800824f, 0.10962345f, -0.05250260f, 0.10079564f, 0.12766667f, 
    0.26406047f, 0.01011758f, -0.01197972f, 0.08238686f, -0.13480182f, -0.13195355f, -0.11530714f, -0.07100637f, 
    -0.17597647f, 0.01761283f, -0.14744557f, -0.03418038f, 0.10881824f, 0.17711675f, 0.08862567f, 0.09880883f, 
    0.03636871f, 0.14116782f, 0.01098191f, -0.24779414f, -0.09328209f, -0.07173660f, -0.06572855f, -0.03290506f, 
    0.10268557f, 0.03201101f, 0.13613278f, -0.27562448f, -0.15251265f, -0.42345971f, 0.02842940f, 0.02989161f, 
    0.20425439f, -0.11499272f, 0.06581654f, 0.33536240f, 0.22120714f, -0.34722888f, -0.30458292f, 0.29153830f, 
    0.13814534f, -0.10128275f, -0.33361337f, 0.00518117f, -0.09498439f, 0.02105893f, -0.16970427f, 0.08619235f, 
    0.07014281f, -0.33636433f, 0.14813317f, -0.04319913f, -0.42598677f, 0.11280934f, 0.09141000f, -0.02885105f, 
    0.01708037f, 0.01877319f, -0.08004925f, -0.01876200f, -0.01125168f, -0.01676546f, -0.18897514f, -0.07472795f, 
    0.20359123f, -0.05788901f, -0.05716087f, 0.12152769f, -0.29613745f, 0.06079630f, 0.08786418f, 0.14534187f, 
    0.01706765f, 0.07223477f, -0.26029465f, 0.12815712f, -0.00327224f, -0.17043243f, -0.02187534f, -0.17073239f, 
    -0.05571986f, -0.06755653f, 0.09710582f, -0.07209279f, 0.06098833f, 0.05207470f, -0.12573612f, 0.11127514f, 
    0.21960428f, -0.00925669f, -0.26974800f, -0.01262823f, 0.05499727f, -0.31340823f, 0.10016128f, -0.06079363f, 
    -0.00128409f, 0.01624420f, 0.34396955f, -0.22787014f, 0.01679503f, 0.11361876f, 0.30672550f, -0.10521688f, 
    -0.06004086f, -0.00313434f, 0.05658880f, -0.15635578f, -0.10463430f, 0.29091078f, 0.09270898f, 0.25511152f, 
    0.07300607f, 0.06165876f, 0.24669407f, 0.30254641f, -0.10280476f, -0.14146036f, -0.06669986f, 0.07716664f, 
    -0.02460978f, 0.06320158f, 0.04242150f, -0.41020525f, -0.11080090f, -0.02149797f, 0.20941837f, -0.08016101f, 
    0.18130608f, 0.01042959f, 0.11297920f, -0.44187346f, -0.42059910f, 0.15303889f, 0.18110527f, 0.08035898f, 
    0.23534013f, -0.12322713f, 0.00389356f, -0.28719521f, -0.21955040f, 0.06139190f, 0.00303421f, 0.07014954f, 
    -0.14561787f, -0.05837107f, 0.04637389f, 0.23743841f, -0.10441765f, 0.15103853f, -0.00783999f, -0.08475722f, 
    -0.10245936f, 0.08558125f, 0.21102555f, 0.18837588f, 0.02795166f, 0.04848373f, -0.14788932f, -0.42674598f, 
    0.10003997f, 0.10410490f, 0.03990431f, -0.17305426f, -0.06611324f, -0.08008599f, 0.30687892f, -0.03711748f, 
    -0.05157647f, 0.12477983f, 0.03566047f, 0.17284960f, -0.05475781f, 0.01477791f, -0.15397710f, 0.01629107f, 
    0.16388011f, 0.54958701f, 0.00383622f, -0.08293291f, -0.20638818f, 0.02757450f, -0.03100117f, -0.11597591f, 
    -0.03284247f, 0.16752259f, 0.11485048f, 0.00047707f, 0.05987731f, 0.07919283f, 0.16888663f, 0.10020030f, 
    0.18443879f, 0.01843348f, 0.06119373f, 0.01906697f, 0.14191335f, 0.10606804f, 0.03761587f, -0.17496724f, 
    0.22666046f, -0.11139463f, 0.12440983f, -0.10648689f, 0.07783273f, -0.04303441f, -0.02849879f, 0.05709843f, 
    0.07509603f, 0.00699547f, -0.15289602f, 0.06786966f, -0.06345905f, 0.00228414f, -0.11301219f, 0.12644674f, 
    -0.17997582f, 0.02128632f, -0.01143154f, 0.08028586f, 0.04196230f, 0.52116066f, 0.03954619f, -0.18171507f, 
    0.09292390f, -0.32613879f, -0.05588760f, -0.02908522f, 0.18249290f, -0.07296961f, -0.12219646f, 0.10072253f, 
    -0.17126115f, -0.07205665f, -0.05514375f, 0.07076265f, 0.00446034f, 0.00096241f, -0.52139783f, -0.10726654f, 
    -0.04066196f, -0.08628602f, 0.56378764f, -0.01518843f, 0.18355922f, 0.08153962f, 0.06250193f, 0.02249624f, 
    -0.00797798f, 0.00850509f, -0.03589087f, 0.08454195f, -0.02295301f, -0.14798212f, 0.09079047f, -0.02789226f, 
    -0.08215479f, -0.02247902f, -0.20536055f, 0.28273377f, -0.10770146f, 0.13431354f, 0.07773830f, -0.05491717f, 
    0.09065560f, -0.26290366f, 0.05864512f, 0.10817831f, 0.02605585f, 0.18701503f, 0.01688736f, 0.14207757f, 
    -0.05468025f, 0.01362603f, -0.02503774f, 0.04089516f, -0.08544079f, 0.00525068f, -0.00546010f, -0.02177068f, 
    0.02312470f, 0.08050894f, 0.00194390f, 0.16088171f, -0.04599545f, -0.01402528f, 0.40466756f, 0.03856391f, 
    -0.07489160f, 0.22788455f, 0.02450163f, 0.18793605f, -0.11938164f, 0.03792269f, 0.44009662f, 0.24820192f, 
    -0.30338466f, 0.16964597f, 0.34588453f, 0.20422211f, -0.13024928f, 0.09880769f, 0.13816538f, -0.02509895f, 
    0.00182565f, -0.01522925f, 0.20767137f, -0.04920271f, 0.18746023f, 0.08786090f, -0.02093763f, -0.20443165f, 
    -0.13948105f, 0.14473432f, 0.02918432f, -0.19447134f, -0.03314187f, -0.09167400f, -0.16110995f, -0.00427726f, 
    0.00754915f, 0.11178405f, -0.02290188f, 0.16407351f, 0.11743371f, -0.14763902f, 0.31021762f, 0.13497625f, 
    -0.17546211f, -0.00205240f, -0.20566311f, 0.03100839f, -0.07727236f, 0.11815390f, 0.14989883f, 0.01023916f, 
    0.02425559f, 0.11239108f, -0.10882456f, 0.09112667f, 0.03707495f, 0.07938755f, 0.09279905f, 0.01056677f, 
    0.06894952f, -0.02948305f, -0.14293791f, -0.11265802f, -0.00031362f, -0.10057274f, 0.03539694f, 0.08668429f, 
    -0.03194902f, 0.13180372f, 0.06229131f, 0.19672628f, -0.02959477f, -0.03460966f, 0.04521219f, -0.04039346f, 
    -0.10245559f, -0.05402332f, 0.01494250f, -0.15646254f, 0.36852741f, -0.15245274f, 0.07087891f, 0.36506662f, 
    0.09316121f, 0.01598713f, -0.17549439f, -0.01359705f, 0.28707010f, 0.05018432f, 0.00926963f, -0.02853072f, 
    0.24365871f, 0.26728806f, 0.07950150f, -0.10454352f, -0.37992793f, 0.20984201f, 0.05694678f, 0.13307811f, 
    0.16809866f, 0.00778367f, 0.11567086f, 0.13844472f, 0.06836761f, -0.10219318f, -0.11828060f, 0.06456006f, 
    -0.03953374f, 0.13008019f, -0.18252109f, -0.15818985f, 0.10555900f, 0.06071093f, 0.12835781f, -0.00476205f, 
    -0.03999257f, -0.05271323f, 0.01063842f, 0.03451180f, -0.10084902f, -0.06209014f, -0.09344042f, 0.02262833f, 
    -0.15157774f, -0.07389992f, -0.12496151f, -0.01231563f, -0.06833716f, 0.01199011f, -0.30347353f, 0.04531356f, 
    -0.05579955f, -0.01278367f, -0.02214784f, -0.07718899f, 0.01959119f, -0.15078498f, -0.24276832f, 0.16003080f, 
    0.32359290f, -0.09158457f, -0.15282714f, -0.08709110f, -0.13592459f, 0.09278126f, -0.00436602f, 0.15583338f, 
    -0.01608670f, 0.37229744f, -0.13969703f, -0.06603654f, -0.33185568f, 0.25648633f, -0.21772145f, -0.00711662f, 
    0.08224483f, -0.09710997f, -0.14349733f, -0.05969869f, 0.08029713f, -0.11781820f, -0.10594267f, 0.06238040f, 
    0.03114933f, -0.14185330f, -0.05402938f, -0.00111176f, -0.11999867f, -0.05288815f, -0.15084231f, 0.17824979f, 
    0.10865068f, 0.00162450f, -0.26097453f, 0.26188207f, 0.00964875f, -0.05573841f, -0.04994773f, -0.17582425f, 
    -0.06084251f, -0.09917869f, 0.22011541f, -0.25248185f, 0.09742994f, 0.01013565f, -0.26303858f, 0.19462427f, 
    -0.02839040f, -0.00458880f, -0.15753527f, 0.15448594f, 0.07429061f, -0.33703047f, 0.06685427f, 0.01222562f, 
    0.17671126f, 0.05527699f, 0.17895928f, -0.34637421f, 0.17384456f, -0.05670954f, 0.22006451f, 0.11956228f, 
    -0.11551327f, 0.00952087f, 0.12547931f, 0.16835326f, -0.62693316f, 0.26734260f, 0.12741077f, -0.08576334f, 
    -0.15248588f, -0.18629031f, -0.42467996f, -0.03912465f, -0.52353644f, -0.03187000f, 0.02406010f, 0.02583136f, 
    -0.17695461f, -0.28018430f, 0.07152754f, -0.41361043f, 0.02853654f, -0.21743324f, 0.16907728f, -0.05787681f, 
    -0.05429311f, 0.00194875f, -0.01781110f, -0.30726644f, 0.04770946f, 0.17021845f, 0.04787872f, 0.04815650f, 
    0.27418822f, -0.22071311f, 0.17796366f, -0.10045063f, 0.01402577f, 0.03998995f, -0.07572015f, 0.05500803f, 
    -0.08912747f, -0.09092338f, 0.07877845f, 0.12397994f, 0.18924095f, 0.19929428f, -0.06362098f, -0.22846337f, 
    0.05351326f, 0.16681720f, 0.14897791f, 0.09846899f, 0.02556026f, 0.20955932f, -0.28701082f, -0.04221756f, 
    0.06863693f, 0.23147391f, 0.08073252f, -0.03391344f, 0.07028516f, -0.04618166f, -0.17113720f, -0.24838999f, 
    -0.02006273f, 0.18019316f, -0.05739866f, 0.13487262f, -0.20581053f, -0.15995918f, 0.16576622f, 0.14931114f, 
    -0.04671161f, -0.02257866f, 0.01945521f, -0.04732198f, 0.02606129f, -0.10815240f, -0.01690230f, 0.05303084f, 
    -0.11028132f, -0.04671107f, 0.02927133f, 0.02386690f, 0.01710686f, -0.00566594f, -0.02889849f, -0.02551156f, 
    -0.04349313f, 0.00112299f, -0.08328579f, 0.07712752f, 0.03721759f, -0.00750553f, -0.08196948f, -0.01387908f, 
    -0.01462682f, -0.01165162f, -0.05210353f, -0.04493681f, -0.03144376f, 0.01981990f, 0.01507519f, -0.04057543f, 
    0.03226939f, -0.03171727f, -0.08738945f, -0.01319496f, -0.06822129f, -0.08151149f, -0.06823950f, 0.06068350f, 
    0.04550679f, -0.09293935f, -0.02716537f, -0.00722239f, 0.03843851f, -0.08660898f, -0.04767832f, -0.07211863f, 
    -0.09281068f, 0.01290429f, -0.01467616f, 0.01316037f, -0.05090523f, 0.01496996f, -0.06611250f, 0.01190211f, 
    -0.10784875f, 0.02129037f, 0.03405600f, 0.02697937f, 0.05888034f, -0.01742611f, -0.08657099f, 0.04972667f, 
    -0.07940326f, -0.05039711f, 0.05868053f, -0.09437236f, -0.08244481f, -0.01872596f, -0.07945486f, -0.07483769f, 
    -0.04489811f, -0.05448204f, -0.07468934f, 0.06740196f, 0.00741598f, 0.05145949f, -0.05915371f, -0.10624116f, 
    -0.08350640f, 0.08713034f, 0.05550297f, 0.01278949f, -0.10125172f, 0.07450497f, -0.03815044f, 0.01333346f, 
    -0.06742964f, -0.00757285f, 0.01545032f, -0.07420998f, -0.05419162f, 0.06065476f, -0.02685747f, 0.01465736f, 
    -0.04458884f, -0.10311180f, 0.03778984f, -0.10911301f, 0.01463126f, -0.06305280f, -0.07410103f, -0.09254140f, 
    -0.04310866f, 0.00880059f, 0.05687334f, 0.05687354f, -0.06223087f, 0.01771254f, -0.06655215f, -0.09530510f, 
    0.08450500f, 0.03238955f, 0.08570440f, 0.03538683f, 0.06067804f, 0.06005284f, 0.07259560f, -0.04386716f, 
    -0.03528680f, 0.06933509f, 0.06254552f, 0.06262873f, -0.07547679f, -0.07296083f, -0.04296539f, -0.05950519f, 
    -0.04913898f, 0.02616710f, 0.02112920f, 0.05777878f, -0.02384587f, -0.02553637f, -0.09856668f, 0.00303523f, 
    0.01821874f, -0.09304275f, -0.02906393f, -0.07012579f, -0.02598698f, -0.02696743f, 0.03302481f, -0.01068930f, 
    -0.09096909f, -0.02076945f, -0.05324881f, 0.06029908f, -0.05769355f, -0.10181960f, -0.08852726f, -0.07540665f, 
    0.00696141f, -0.10687000f, -0.11278450f, 0.00153110f, -0.00083798f, -0.08263302f, -0.02579225f, -0.02648984f, 
    -0.11711200f, 0.06162724f, -0.08570840f, -0.06285546f, -0.13147870f, -0.00516298f, -0.00423381f, 0.06890933f, 
    -0.00371272f, -0.04892486f, 0.02013454f, -0.13623221f, -0.06017324f, -0.01126583f, 0.01752045f, 0.04973425f, 
    -0.01816196f, -0.11474807f, -0.09757438f, -0.01091829f, 0.06602658f, 0.00813230f, -0.08933848f, -0.02569531f, 
    0.00378832f, -0.09045754f, -0.03973954f, -0.00382737f, 0.06672048f, 0.04464776f, -0.00185374f, -0.04564153f, 
    0.02143078f, -0.02567379f, 0.05674133f, -0.10213489f, -0.07173713f, -0.10806116f, 0.05937876f, -0.04852023f, 
    -0.01767150f, -0.08095537f, 0.07402220f, -0.12482792f, 0.00023156f, 0.02002715f, -0.07350334f, -0.06450973f, 
    0.05421116f, -0.04807815f, 0.03066106f, 0.00855701f, 0.03330852f, 0.02848774f, 0.01208072f, 0.02536245f, 
    -0.01174294f, 0.03059503f, -0.06547564f, 0.01872167f, -0.12367620f, 0.00261487f, -0.07285967f, 0.04200649f, 
    0.03802575f, 0.01153744f, 0.02008088f, -0.04613052f, -0.03141634f, -0.12617661f, -0.05192592f, 0.03830675f, 
    -0.11646950f, -0.12331540f, -0.05893611f, -0.11010524f, -0.04673111f, -0.06217036f, -0.02513239f, 0.01810728f, 
    0.01799929f, -0.04182637f, 0.04226281f, -0.11346087f, 0.01178970f, -0.13110822f, 0.03493515f, -0.02665867f, 
    -0.06211723f, -0.06349351f, -0.04578476f, 0.00935462f, -0.02351235f, -0.01495964f, -0.07881378f, 0.05229972f, 
    -0.32520077f, -0.13650671f, 0.42505366f, 0.02937440f, -0.15419181f, 0.21665436f, -0.28500295f, 0.20629428f, 
    0.11519287f, 0.16426504f, 0.02356723f, 0.07881790f, 0.10928334f, -0.01298371f, -0.01832455f, 0.10094567f, 
    -0.27058530f, -0.06107232f, -0.08421687f, 0.21833657f, 0.02277698f, 0.26066500f, -0.52667266f, 0.16746554f, 
    0.08240256f, 0.08839517f, -0.07978447f, -0.23739323f, 0.02656286f, -0.06601614f, -0.04582197f, -0.11342488f, 
    0.07999941f, 0.22812356f, -0.04290459f, 0.21985351f, 0.06447370f, 0.06524330f, -0.03931320f, -0.09035992f, 
    0.12595549f, 0.01563663f, 0.00258509f, 0.42153820f, -0.43117267f, -0.31053698f, -0.23311625f, -0.37483266f, 
    0.20057021f, 0.21779945f, 0.38044491f, 0.11522723f, -0.29741365f, 0.25929475f, 0.36866218f, -0.22421542f, 
    0.16607589f, -0.07802926f, -0.10345491f, 0.10451647f, -0.00135796f, -0.35310671f, 0.09382117f, 0.27572903f, 
    -0.09708647f, -0.00112734f, -0.59837782f, 0.15249860f, 0.10196277f, -0.04556124f, -0.09156482f, -0.01020631f, 
    0.02791550f, -0.07394666f, 0.07340337f, -0.12890908f, 0.03607165f, -0.05735756f, -0.08494963f, 0.06894659f, 
    0.47715941f, -0.07828257f, 0.37960261f, -0.03257164f, -0.02955377f, -0.04399538f, -0.40107492f, -0.20698370f, 
    0.07753036f, 0.01509963f, -0.17909120f, -0.11053913f, 0.05929908f, 0.24913661f, 0.04188382f, 0.08914874f, 
    -0.07214613f, -0.06898802f, 0.06500131f, -0.03350729f, -0.45952225f, -0.03296044f, 0.03544563f, -0.09834660f, 
    0.00671756f, -0.05707205f, -0.18872888f, 0.04734447f, 0.07034462f, -0.07744642f, 0.23601167f, 0.12637749f, 
    0.19083241f, 0.05645880f, 0.01378638f, -0.17608176f, -0.11824307f, -0.10350806f, 0.14258173f, 0.09432706f, 
    0.15418749f, -0.17825381f, -0.36324045f, 0.01290343f, -0.23042904f, -0.17972547f, 0.15101822f, 0.03648949f, 
    0.31491360f, 0.35757619f, -0.44079140f, -0.03027993f, -0.10876518f, 0.25131789f, -0.07629862f, -0.08828317f, 
    0.02318339f, 0.03004916f, 0.00948106f, 0.04153153f, 0.08807202f, 0.22600567f, 0.19421507f, 0.23251089f, 
    0.08487421f, -0.02938620f, -0.02871385f, 0.11405995f, 0.17301264f, 0.10304203f, 0.09300245f, -0.02710531f, 
    0.08970609f, -0.01949213f, 0.10339107f, 0.18800488f, -0.08140615f, -0.07497668f, -0.06594449f, -0.15106992f, 
    0.10998468f, 0.05010431f, -0.09389142f, -0.07054064f, -0.13441306f, 0.06723636f, -0.01342245f, 0.06970450f, 
    -0.20346354f, 0.02349733f, 0.08292986f, -0.08361875f, -0.10432612f, -0.00423483f, 0.05308161f, 0.56908751f, 
    0.17929541f, -0.11408155f, -0.02919741f, -0.10491629f, 0.05966108f, -0.14677051f, 0.03811298f, 0.15315282f, 
    -0.12589970f, -0.04272600f, 0.13621986f, 0.16129947f, 0.01637695f, 0.01858793f, -0.16541685f, -0.23638779f, 
    -0.02019178f, -0.04147812f, -0.19277447f, -0.13880749f, 0.03264604f, 0.16222383f, 0.01662273f, 0.02469893f, 
    -0.17661527f, 0.02800896f, -0.04865789f, -0.06254029f, -0.05424323f, 0.02358106f, -0.00181105f, 0.02188536f, 
    -0.12712581f, 0.07259881f, -0.16763608f, 0.12193741f, 0.06356712f, 0.00907942f, -0.06937083f, 0.03076114f, 
    0.11204489f, -0.06627881f, -0.05813427f, 0.12634103f, 0.16479629f, 0.06616528f, 0.05528558f, 0.03945366f, 
    0.07004765f, 0.06771278f, 0.04450291f, 0.07511392f, 0.31428853f, 0.25413957f, 0.11307078f, -0.07893451f, 
    0.13439737f, 0.06663768f, -0.06307550f, 0.02357275f, 0.02352505f, 0.14551128f, -0.15163362f, 0.39581370f, 
    -0.24372388f, 0.04266177f, 0.07245605f, 0.19759712f, 0.18630768f, -0.05897845f, 0.06140000f, 0.10213308f, 
    -0.20392172f, -0.06508224f, 0.08007345f, 0.14293852f, -0.18336020f, -0.07724231f, 0.16542785f, 0.08394270f, 
    0.06952949f, 0.38563561f, 0.46055105f, -0.00103856f, -0.12946579f, 0.19422671f, 0.05838494f, 0.10183135f, 
    -0.04313774f, 0.15758727f, -0.03624680f, -0.05990025f, -0.09853563f, -0.00578893f, 0.20090500f, 0.02377691f, 
    -0.11553054f, 0.06473804f, 0.02639618f, 0.10557987f, -0.10312708f, -0.01940641f, -0.00025536f, 0.01037803f, 
    -0.04245308f, 0.17629214f, 0.07768732f, -0.15422134f, -0.08232833f, -0.04367798f, 0.10358118f, -0.13161477f, 
    0.00484859f, 0.14783171f, -0.34255835f, 0.08889015f, 0.12145833f, 0.02840761f, -0.05386085f, 0.09232031f, 
    0.05633422f, -0.03733788f, -0.08304157f, 0.20365785f, 0.01808666f, 0.01930136f, -0.07972906f, -0.51839083f, 
    0.17742760f, -0.14873201f, 0.06932629f, 0.09299793f, 0.13841915f, 0.02385784f, -0.09044126f, -0.09662542f, 
    0.11057248f, -0.00629594f, -0.00347796f, -0.07374772f, -0.06325931f, -0.06348128f, -0.27276054f, -0.13838597f, 
    0.06135837f, 0.03654435f, 0.15020989f, 0.02793001f, 0.41177523f, -0.04211892f, 0.00227739f, 0.00628192f, 
    0.15679982f, -0.02286858f, 0.08717149f, 0.22047520f, 0.02883120f, -0.22734015f, -0.13573651f, 0.14714159f, 
    0.12146460f, -0.06161625f, 0.09232867f, 0.10240356f, 0.09077860f, 0.13308233f, -0.35610607f, 0.05083101f, 
    0.17008395f, 0.07652034f, -0.14450870f, 0.00011325f, 0.00225773f, 0.12387372f, 0.08342802f, 0.19787979f, 
    -0.06327540f, -0.11002132f, 0.05558887f, -0.10094354f, -0.02594884f, 0.22254626f, 0.02266243f, 0.04536897f, 
    0.05521601f, 0.09206540f, -0.03999848f, 0.12604970f, -0.01117109f, 0.06274667f, -0.00907483f, 0.03085402f, 
    0.14176250f, 0.20531915f, 0.00401370f, 0.13418151f, -0.18771175f, -0.03649814f, 0.35300472f, 0.12036230f, 
    -0.06919868f, 0.12252130f, 0.05558373f, 0.20118329f, -0.46811730f, 0.09145556f, 0.16897301f, -0.00307422f, 
    -0.00783929f, 0.56803071f, -0.43766436f, 0.05024864f, -0.20807818f, 0.11385475f, -0.23285350f, 0.13461643f, 
    0.04802300f, 0.09489734f, -0.05631022f, 0.02205768f, -0.01833119f, 0.07181156f, 0.01100531f, 0.14620636f, 
    0.02182623f, -0.18312792f, 0.03274443f, -0.02502270f, -0.16749808f, -0.21426408f, -0.10091393f, 0.15522794f, 
    0.18339123f, -0.03184804f, -0.30899212f, 0.29923671f, -0.00229071f, 0.08341574f, 0.06272674f, -0.23531975f, 
    -0.33431184f, -0.09132310f, 0.23209897f, -0.17705885f, 0.07539518f, -0.02632684f, -0.02556980f, 0.11571898f, 
    -0.25775766f, -0.00299053f, -0.17337963f, 0.08449995f, -0.06426691f, -0.25930867f, 0.14667101f, 0.35332370f, 
    0.18747115f, 0.10542755f, 0.10425635f, -0.30200821f, 0.23899885f, -0.01112259f, 0.08099522f, 0.18827644f, 
    -0.05391164f, 0.25542745f, 0.33504549f, -0.05023928f, -0.32926941f, 0.37894285f, 0.12220911f, -0.47897077f, 
    -0.32593626f, 0.05808426f, -0.45074657f, -0.19304608f, -0.54038370f, 0.13202322f, 0.01296627f, -0.05630749f, 
    -0.44347259f, -0.13439611f, 0.06219437f, -0.16240016f, 0.17489403f, -0.11166350f, 0.15343842f, 0.10427748f, 
    -0.12751608f, 0.04312435f, -0.08588161f, -0.21290758f, 0.15064770f, -0.02214244f, 0.20555022f, 0.13235012f, 
    0.05520749f, -0.26158544f, 0.20795749f, -0.00507091f, -0.05571129f, -0.15554602f, 0.01769960f, 0.08139943f, 
    0.14026745f, -0.08393047f, 0.00572294f, 0.13486706f, 0.27751619f, 0.22273903f, 0.03724837f, -0.31262067f, 
    0.18864912f, 0.16208681f, 0.18049817f, -0.26074633f, -0.20149663f, 0.24087624f, -0.29811749f, 0.13455115f, 
    -0.14241564f, 0.19353464f, -0.03726879f, 0.13547510f, 0.20905147f, -0.08977611f, -0.15213299f, -0.36985159f, 
    0.03442622f, 0.16950405f, 0.00682225f, -0.04993929f, 0.04863835f, -0.07224902f, 0.33463898f, 0.07784537f, 
    -0.02089797f, -0.04545823f, -0.27158186f, 0.05846006f, 0.01364675f, -0.04802954f, 0.03409154f, 0.15985587f, 
    0.16732217f, -0.08156610f, 0.05059670f, 0.20881210f, 0.13840827f, 0.00398867f, 0.03104392f, 0.19921130f, 
    -0.02664445f, -0.10466712f, 0.01210156f, 0.01530074f, 0.15634012f, 0.07877662f, -0.27963352f, -0.16740446f, 
    0.07728510f, 0.00072794f, 0.05067104f, 0.03999966f, 0.06220569f, 0.00755697f, -0.09006085f, 0.07831819f, 
    0.08187567f, 0.13954394f, 0.03692332f, 0.10574374f, -0.02003858f, 0.01799843f, 0.14363723f, -0.02265751f, 
    -0.08590068f, 0.18476647f, 0.13122393f, 0.17354323f, -0.11329287f, -0.12912096f, 0.12845527f, 0.49985686f, 
    0.03690058f, 0.20338829f, 0.24251318f, -0.05645724f, -0.05464541f, 0.16774240f, 0.21494162f, 0.20545442f, 
    -0.00180736f, 0.16626045f, 0.13800763f, 0.02239607f, -0.04679642f, -0.02164641f, 0.09228832f, 0.03748880f, 
    0.09116499f, -0.00797300f, -0.66457963f, -0.04150642f, -0.26735333f, 0.20655902f, 0.06271759f, 0.00384062f, 
    0.04172857f, -0.12735100f, 0.02727243f, 0.00898450f, 0.02611000f, 0.32287908f, -0.13785791f, 0.03711516f, 
    -0.05989244f, 0.00655602f, -0.03402904f, 0.05590650f, -0.14469153f, -0.04677427f, -0.00934035f, -0.15502386f, 
    -0.12015206f, -0.03310901f, 0.07795274f, 0.00801739f, 0.06173858f, 0.14934134f, 0.06889341f, 0.07907344f, 
    0.11654598f, -0.04489557f, -0.02446565f, 0.01223942f, 0.09454235f, 0.05077304f, 0.07317899f, 0.04822018f, 
    0.17276299f, -0.03168105f, -0.11137205f, -0.00096886f, 0.20947920f, 0.01982763f, 0.04758214f, 0.20163238f, 
    -0.12663575f, -0.03328737f, 0.00781690f, -0.01516350f, 0.03771814f, -0.00310659f, -0.23224662f, -0.05618783f, 
    -0.08799584f, -0.15958181f, -0.09859244f, 0.03773990f, 0.08165038f, -0.15428413f, 0.01384367f, -0.07847334f, 
    0.09561026f, -0.17228387f, -0.01491570f, -0.01000172f, 0.28648582f, 0.02229813f, 0.05793713f, 0.15027961f, 
    -0.14367563f, 0.06082812f, -0.05380306f, 0.04513234f, 0.18200177f, 0.18042900f, -0.02695496f, 0.07353985f, 
    -0.22243245f, 0.14179690f, 0.00266983f, 0.09869307f, -0.00670390f, -0.03923186f, 0.40673238f, 0.09848644f, 
    -0.02604390f, 0.10106948f, -0.10815115f, -0.08302842f, 0.04126445f, 0.06596468f, 0.04484130f, -0.15824305f, 
    -0.02697137f, 0.06820785f, -0.10269732f, 0.11876589f, 0.06877768f, -0.06428785f, 0.18803854f, -0.09496862f, 
    -0.13690634f, -0.01576149f, -0.15888771f, -0.05534693f, -0.01557771f, 0.40329230f, 0.03307336f, -0.15551685f, 
    0.10490066f, 0.07472558f, -0.32218304f, 0.03514721f, -0.01202387f, -0.02819327f, -0.19078597f, 0.09606926f, 
    0.08160402f, 0.20007643f, -0.04372617f, -0.20301576f, 0.28926808f, -0.08834764f, 0.07463051f, -0.18773735f, 
    -0.06273202f, -0.06704700f, -0.41820565f, -0.16328418f, 0.14975095f, 0.11371350f, -0.04451770f, 0.05842694f, 
    -0.02706783f, 0.13891859f, -0.00037466f, 0.48283508f, 0.12404004f, 0.24764124f, -0.09056790f, 0.14843369f, 
    -0.04902448f, -0.07692804f, -0.01867761f, 0.17415200f, 0.61788082f, -0.27164236f, -0.01264418f, 0.06097255f, 
    -0.00039062f, 0.06223603f, -0.15980415f, -0.02600014f, 0.24137330f, -0.16627409f, 0.09246890f, 0.16586502f, 
    0.11130119f, 0.01644948f, 0.08713242f, -0.26824141f, -0.01781536f, 0.04248449f, -0.16375281f, -0.05178183f, 
    0.09693123f, 0.11805873f, -0.09654289f, 0.00607742f, 0.08181619f, -0.19045800f, 0.60658354f, 0.07612936f, 
    0.11871124f, -0.14967915f, 0.04818373f, 0.22033609f, 0.13646126f, -0.05635514f, -0.35700497f, 0.09437854f, 
    0.31535131f, -0.01144166f, -0.04425171f, -0.11864492f, 0.05846144f, 0.12678140f, 0.22474989f, 0.10774449f, 
    0.31759152f, -0.22782555f, -0.09569553f, -0.00824265f, 0.03592945f, 0.23364545f, -0.18524432f, -0.27478537f, 
    -0.07511511f, 0.05272134f, 0.02014999f, -0.42992112f, -0.29734725f, -0.37045401f, -0.16725732f, -0.15325290f, 
    0.18411638f, 0.08715971f, -0.01891842f, 0.20129518f, -0.01862046f, -0.21508695f, 0.37694278f, 0.18780570f, 
    0.00433544f, -0.05015229f, -0.00872090f, 0.09550760f, 0.00827700f, -0.07622912f, 0.06161551f, 0.06704116f, 
    -0.22816902f, 0.11780357f, 0.00432122f, -0.15733959f, 0.12185851f, -0.09108637f, -0.14618476f, 0.15204790f, 
    -0.06179683f, -0.21117595f, -0.07163636f, -0.22677901f, 0.08062364f, 0.08745518f, 0.04317128f, 0.17008613f, 
    0.10241815f, -0.08234480f, 0.10000003f, 0.02960573f, 0.14785770f, -0.36205497f, -0.04605452f, -0.13300626f, 
    -0.14792970f, -0.31479338f, 0.17366390f, -0.00153548f, 0.15137060f, 0.01666289f, 0.01130285f, -0.02996440f, 
    -0.15355299f, 0.00082177f, -0.37897664f, -0.13369301f, 0.15144710f, -0.02506524f, -0.04684883f, 0.02819320f, 
    -0.58022529f, 0.35169312f, 0.05485313f, -0.01022928f, -0.55843782f, -0.20950037f, 0.16997775f, 0.09809899f, 
    0.08834969f, 0.06483143f, 0.04458911f, -0.10700274f, -0.24163295f, 0.22879829f, -0.05492613f, 0.14579263f, 
    0.37415323f, -0.16047090f, 0.06840693f, -0.02811829f, -0.22599521f, 0.24332078f, 0.22631499f, 0.04828221f, 
    -0.27478999f, -0.04837766f, -0.07283355f, 0.00004262f, 0.24789795f, 0.11264732f, -0.13160862f, -0.13617490f, 
    -0.06924082f, 0.17363246f, -0.00213758f, -0.03814437f, -0.38975182f, -0.06578796f, -0.07663386f, 0.15108590f, 
    -0.12150786f, 0.16660017f, 0.00584371f, 0.03001862f, -0.13066095f, -0.17232415f, 0.05823348f, 0.11789020f, 
    -0.01626603f, 0.07760672f, 0.10869888f, 0.13814330f, -0.29787922f, 0.17793433f, 0.06960464f, 0.14013577f, 
    -0.02172876f, 0.41089389f, 0.41819310f, -0.05151824f, 0.13005078f, 0.12836291f, -0.07798216f, 0.09668697f, 
    0.09814841f, 0.05697433f, 0.02612063f, 0.12696622f, 0.18596542f, 0.10310201f, 0.03449713f, 0.03951890f, 
    -0.17362042f, -0.07788928f, 0.08252984f, 0.06783908f, -0.04317416f, -0.03230442f, -0.05150735f, 0.08274154f, 
    0.15486857f, 0.13868785f, 0.01409666f, -0.10648473f, 0.07325850f, -0.08616841f, -0.05444023f, -0.11072715f, 
    0.03618423f, -0.03588811f, -0.13001753f, -0.03562286f, -0.00010097f, -0.02704762f, -0.24544582f, 0.09309765f, 
    0.05232803f, -0.15885809f, -0.09373624f, 0.30757183f, -0.33142829f, -0.18406744f, -0.18420267f, -0.33720252f, 
    0.10089221f, 0.23325671f, 0.10799117f, 0.15448377f, 0.03700564f, 0.12627333f, 0.14909604f, -0.00366785f, 
    -0.02008071f, -0.11927491f, 0.11015991f, 0.08045710f, -0.02872481f, -0.03234314f, -0.17028244f, 0.02356477f, 
    0.08923873f, 0.09919472f, -0.73227262f, -0.05316822f, -0.00968466f, -0.05909633f, 0.02283205f, 0.01361582f, 
    0.37436971f, 0.06108953f, -0.04232918f, -0.14620434f, -0.12773396f, -0.34602991f, -0.22535884f, 0.20085381f, 
    0.12092096f, 0.01695284f, 0.27920887f, 0.01348340f, 0.19434063f, -0.10994247f, -0.39441597f, -0.02491312f, 
    0.13663164f, 0.04838031f, -0.17866552f, 0.12429108f, 0.14449248f, 0.19717343f, 0.11829592f, 0.11125264f, 
    -0.09850541f, -0.14967439f, 0.01484200f, -0.16658047f, -0.04416185f, 0.11922283f, -0.11614785f, -0.02055853f, 
    -0.02857078f, -0.00298672f, -0.26456347f, 0.23594359f, 0.22044003f, 0.07367793f, 0.00213537f, 0.28506678f, 
    0.16737078f, 0.10175537f, -0.01152745f, -0.19742465f, -0.30985859f, -0.01861518f, -0.10454842f, -0.00975033f, 
    -0.01670572f, -0.05217578f, 0.07239015f, 0.01209280f, -0.53600973f, 0.03909400f, 0.50017041f, 0.09468705f, 
    -0.00978964f, -0.00311231f, -0.28436434f, -0.01130423f, 0.04152967f, -0.10674353f, -0.09964207f, -0.00104984f, 
    0.15733910f, -0.01378487f, -0.07340214f, 0.08136884f, -0.05582985f, 0.03246457f, -0.01084462f, 0.17325759f, 
    -0.10227946f, 0.05653087f, 0.03359567f, -0.06041906f, -0.19430614f, -0.28999424f, 0.05512435f, -0.06530824f, 
    0.10634799f, 0.03679421f, -0.11386725f, 0.29554808f, -0.00799765f, 0.07473844f, -0.13548131f, -0.10804822f, 
    -0.14185920f, -0.00636554f, 0.23654994f, -0.16410127f, 0.15520759f, 0.05076962f, 0.22473076f, 0.08052555f, 
    -0.15733089f, 0.04706866f, -0.11914567f, 0.06505159f, 0.04342218f, -0.10980064f, 0.23468757f, 0.14342302f, 
    0.04983985f, 0.20072210f, 0.00864641f, -0.27343267f, 0.10373914f, 0.10595147f, 0.19404867f, 0.18558915f, 
    -0.10289583f, 0.18767522f, 0.25252253f, -0.06636156f, -0.17228985f, 0.28567141f, 0.24954744f, -0.19765316f, 
    -0.08352977f, -0.02187430f, 0.32109612f, -0.20839773f, -0.24939761f, 0.18306085f, -0.02646351f, -0.07592953f, 
    -0.17237940f, -0.18597700f, -0.08111899f, -0.17359942f, 0.04735904f, -0.15730204f, 0.00286051f, -0.13241550f, 
    -0.09982714f, -0.01956096f, -0.12873533f, -0.16583656f, 0.16348787f, 0.18445887f, 0.37324572f, 0.07197864f, 
    -0.00816590f, -0.03335402f, 0.35670945f, -0.15450633f, 0.02063427f, -0.16592781f, 0.11332688f, 0.06204358f, 
    0.14151224f, -0.10843633f, -0.01707570f, 0.16072160f, -0.07764980f, 0.02165603f, 0.05063683f, -0.20155555f, 
    0.09131929f, 0.10247160f, 0.00465093f, -0.31122732f, -0.01065377f, 0.07339651f, 0.01504218f, -0.07958068f, 
    -0.07863099f, 0.04139105f, -0.01834367f, 0.03999541f, 0.19667262f, -0.14177315f, -0.02228511f, -0.17224264f, 
    0.00619420f, 0.08583646f, 0.04019492f, -0.10589381f, 0.55224198f, -0.01144564f, -0.01006284f, -0.06080030f, 
    0.05633177f, -0.20609909f, 0.50130832f, 0.05354363f, 0.14176042f, 0.21539484f, 0.02605066f, -0.28577322f, 
    -0.35833105f, -0.00311462f, 0.05258978f, -0.14121269f, 0.04281626f, -0.15489860f, -0.48480180f, 0.04596302f, 
    0.22164068f, 0.17473586f, -0.02372973f, 0.15440251f, 0.01101742f, -0.03742870f, 0.15868092f, 0.13118380f, 
    -0.02534896f, 0.00386025f, -0.19760227f, 0.03622596f, 0.07416860f, 0.06240434f, 0.14901142f, 0.15480368f, 
    0.24549797f, -0.00993297f, 0.04337664f, 0.09384894f, 0.03815002f, -0.04346760f, -0.26490659f, 0.06450552f, 
    0.20736983f, -0.13396618f, -0.14463292f, -0.18058473f, 0.08342795f, -0.05556256f, -0.01716922f, -0.28474665f, 
    0.09147069f, 0.02754833f, 0.01626643f, 0.28666025f, -0.05150685f, 0.03995859f, 0.29309312f, -0.21443619f, 
    -0.10734827f, -0.22006243f, -0.02738735f, -0.26909840f, -0.00512974f, -0.13386355f, 0.13180144f, 0.38293901f, 
    0.09800809f, 0.16164368f, -0.15298340f, 0.16719945f, 0.35507634f, -0.13480301f, -0.02161376f, 0.05526835f, 
    0.35328689f, 0.30652437f, 0.00556880f, 0.00752892f, -0.04034374f, -0.00635063f, 0.04556703f, -0.04271515f, 
    0.09167442f, -0.02424773f, 0.25833291f, -0.02820319f, 0.01993459f, 0.14784890f, -0.02225334f, 0.04902112f, 
    0.09682991f, 0.12806389f, 0.02781468f, -0.37186256f, 0.12844901f, 0.03944895f, 0.05535149f, -0.03254711f, 
    -0.06034938f, -0.04342507f, -0.03259612f, 0.02929016f, -0.11306564f, 0.02022007f, -0.14058408f, 0.14624663f, 
    -0.14696163f, 0.11261027f, 0.08874795f, 0.34457266f, 0.11915195f, -0.06054702f, -0.05537631f, -0.02765747f, 
    0.16888179f, -0.09015168f, 0.02981645f, -0.18415329f, -0.16246270f, 0.04077423f, 0.16713808f, -0.21710770f, 
    0.26545691f, 0.02552499f, 0.14541943f, 0.04762445f, -0.15971960f, 0.11833933f, 0.08865111f, 0.08009428f, 
    0.37602353f, 0.00703810f, -0.34015435f, 0.03120907f, 0.04356911f, 0.15871508f, 0.13717666f, -0.00942594f, 
    -0.05384951f, 0.04398033f, 0.09395830f, -0.01516687f, 0.06239016f, 0.07509968f, 0.16000614f, 0.06677348f, 
    0.10996044f, 0.11228966f, 0.01874681f, -0.10054640f, 0.16110985f, 0.03710149f, 0.21024577f, 0.04809737f, 
    -0.02806381f, -0.09733436f, 0.02266433f, 0.12351967f, 0.02663441f, 0.06975500f, -0.04955263f, -0.01300065f, 
    0.05539889f, 0.08730291f, 0.00929662f, -0.12559013f, -0.02244438f, -0.07413827f, 0.05289133f, 0.07782622f, 
    -0.23171425f, 0.11828276f, 0.04227150f, -0.07199927f, 0.12914312f, 0.47711319f, 0.10960498f, 0.51660144f, 
    0.06701893f, -0.25518674f, -0.32460263f, 0.06627279f, 0.23941360f, -0.12497284f, -0.20818470f, 0.17853914f, 
    -0.05423718f, -0.08351366f, 0.06590263f, -0.04921559f, 0.01048569f, -0.01797962f, -0.10768470f, -0.21622026f, 
    0.03525573f, 0.15378119f, -0.38125595f, -0.03897181f, 0.04909849f, 0.08469075f, -0.08384478f, -0.04684126f, 
    -0.01403504f, 0.14416333f, 0.06197495f, 0.30171087f, -0.03304587f, -0.03979890f, 0.05644707f, 0.09779714f, 
    -0.34109443f, -0.07665269f, -0.21334916f, 0.25832060f, 0.05515425f, -0.23133792f, 0.18107183f, -0.09055376f, 
    0.05058008f, -0.08486361f, 0.08409920f, 0.04524774f, 0.06590809f, 0.01592458f, 0.10286628f, 0.01466540f, 
    0.07407206f, 0.19059251f, -0.00539851f, -0.03089032f, 0.29577973f, 0.03454880f, 0.04138456f, -0.04700971f, 
    -0.00807700f, -0.06419293f, -0.01667759f, 0.06107008f, 0.08635224f, -0.00854480f, 0.08277629f, 0.18313691f, 
    -0.11556333f, 0.00625757f, -0.05203253f, 0.38604331f, 0.05867290f, -0.01895579f, -0.11642145f, 0.13397303f, 
    -0.14631063f, 0.09105214f, 0.09910236f, 0.13454051f, 0.05744397f, 0.15076099f, 0.03575522f, -0.06537296f, 
    -0.06560752f, -0.06832196f, 0.00375130f, -0.06323604f, 0.02555363f, -0.13590613f, 0.07571907f, -0.01125814f, 
    0.02139286f, -0.04986495f, 0.01861599f, 0.01143032f, -0.06646702f, -0.04446507f, 0.11862893f, -0.01245851f, 
    0.02359779f, -0.05371081f, -0.05567447f, -0.12365201f, 0.07604255f, 0.07982479f, -0.06435730f, -0.02591928f, 
    -0.04820487f, -0.02935540f, -0.03796193f, -0.10466345f, -0.04788551f, -0.07971205f, -0.11065061f, 0.02528272f, 
    -0.00263689f, -0.06911188f, -0.04293400f, -0.05134251f, 0.04443344f, -0.00589831f, -0.03895199f, -0.12422042f, 
    0.04721662f, 0.00458517f, 0.00710353f, -0.07103156f, 0.02616165f, -0.00254567f, -0.02191700f, -0.02343773f, 
    -0.10383039f, -0.06403165f, -0.05592247f, -0.09028325f, -0.08894242f, -0.03486790f, -0.03489079f, -0.06392937f, 
    -0.04268198f, -0.01283357f, -0.04617600f, 0.08569640f, 0.00355617f, -0.06564210f, -0.08084539f, -0.16487399f, 
    -0.07695390f, 0.08275579f, 0.03123965f, 0.05445450f, 0.01558520f, 0.01031048f, -0.04262297f, 0.00998890f, 
    -0.02428283f, -0.08811302f, 0.00974995f, -0.08733562f, 0.01486711f, 0.05674915f, 0.02076851f, -0.08600731f, 
    -0.09106773f, -0.03101989f, -0.08153863f, -0.04383736f, -0.00886608f, -0.03382906f, 0.00429906f, -0.06900486f, 
    0.03068441f, -0.04696450f, -0.07228791f, 0.04326073f, -0.12484892f, -0.06003492f, -0.05896275f, -0.01978853f, 
    -0.00830148f, -0.03873839f, -0.01744070f, -0.07830624f, -0.03449818f, -0.12724802f, 0.07259412f, -0.08823111f, 
    -0.09023789f, 0.01574851f, -0.01767853f, 0.02106370f, -0.05400154f, -0.05917561f, -0.02610230f, -0.06840454f, 
    0.00044646f, -0.01571887f, -0.08038185f, 0.06608130f, 0.00780048f, -0.01216341f, -0.10512120f, 0.03306384f, 
    -0.17638303f, 0.03132255f, 0.00352383f, -0.09048641f, 0.09900575f, -0.04020960f, 0.05511880f, 0.01305361f, 
    -0.13386151f, -0.22969122f, -0.21195883f, 0.06982210f, 0.03724980f, -0.13777786f, -0.20565802f, 0.28361166f, 
    0.20714456f, 0.02675508f, -0.08579635f, 0.15317969f, 0.11143250f, 0.01908320f, 0.06987543f, 0.17796230f, 
    -0.21033286f, -0.04956037f, 0.04091716f, 0.15430705f, 0.14929004f, 0.10043013f, -0.21220063f, 0.01644349f, 
    -0.11766434f, -0.00558341f, -0.14916438f, 0.05023168f, -0.03132852f, 0.12703897f, -0.22042561f, -0.09636020f, 
    -0.16056105f, 0.27515629f, -0.23969269f, 0.01027989f, 0.16225545f, -0.08771145f, 0.27473563f, -0.16025993f, 
    0.11951668f, 0.14740659f, -0.10500840f, 0.04737725f, -0.16674042f, -0.07830319f, 0.23861305f, 0.34113404f, 
    0.14074570f, 0.44415465f, 0.21370974f, -0.04081347f, -0.13172685f, 0.28865188f, 0.27069497f, 0.04734457f, 
    0.14979662f, 0.19558311f, 0.04564317f, 0.00608975f, 0.19012490f, -0.04803770f, 0.16650137f, -0.03180807f, 
    0.05861225f, 0.02205764f, -0.46560183f, 0.09740095f, -0.29892516f, 0.19250470f, -0.02573989f, -0.07554886f, 
    0.00017089f, -0.25004932f, 0.04753226f, 0.11907695f, -0.00892624f, 0.04521171f, -0.11977480f, -0.06324922f, 
    0.07095098f, -0.03632443f, 0.17365156f, -0.03528997f, 0.07851617f, -0.32584897f, -0.03014129f, -0.16185577f, 
    -0.32376826f, 0.05039614f, -0.02749456f, -0.06871415f, 0.14187261f, 0.02446564f, -0.05240288f, 0.13421454f, 
    0.08688242f, -0.03369839f, -0.01845749f, 0.07867637f, -0.06560885f, 0.05003933f, 0.16322914f, -0.19584996f, 
    0.21301171f, -0.05492925f, 0.10304216f, -0.14896698f, 0.15019630f, -0.01649687f, 0.00654508f, 0.19646108f, 
    -0.15500596f, -0.05959227f, -0.06440951f, 0.12092695f, 0.25531366f, -0.15446496f, -0.58434933f, 0.06700286f, 
    0.11393848f, -0.25568730f, -0.61774600f, -0.10134378f, 0.17566009f, -0.25769919f, -0.03966980f, 0.02815935f, 
    0.10688763f, 0.02394788f, 0.41270262f, 0.08438426f, 0.21654254f, 0.05104231f, -0.22784188f, 0.11596542f, 
    -0.14373699f, -0.10575587f, 0.03180411f, 0.11390463f, 0.12972812f, 0.12201978f, -0.26119238f, 0.24408606f, 
    0.16753641f, 0.10070962f, 0.09591355f, -0.03796088f, 0.11187264f, -0.28742763f, 0.08595034f, -0.04929474f, 
    0.11065722f, -0.30910367f, -0.63333094f, 0.29730049f, 0.07027075f, -0.01346021f, -0.04886810f, -0.03778139f, 
    -0.01196691f, 0.11163177f, 0.44193551f, -0.09485753f, -0.03099101f, 0.00213466f, 0.20997173f, 0.00043786f, 
    -0.30082312f, -0.10463390f, -0.70913398f, -0.22997567f, -0.04521577f, -0.13601455f, 0.25124350f, -0.25386748f, 
    0.06055012f, 0.39140475f, 0.08311452f, 0.12165899f, 0.00025437f, 0.16420595f, 0.48973852f, 0.12077878f, 
    0.13288744f, 0.25736398f, 0.11154504f, -0.39931902f, -0.17213157f, -0.13457948f, 0.33285272f, -0.11742476f, 
    -0.09140156f, 0.05933808f, -0.31902832f, 0.07705917f, 0.14025997f, 0.06992915f, -0.03910883f, -0.08616184f, 
    0.06750946f, 0.08670650f, 0.01131789f, 0.31991804f, -0.10533524f, 0.43862179f, -0.10421342f, -0.22256981f, 
    -0.03827292f, -0.01367118f, 0.20697847f, 0.01499788f, 0.29715672f, 0.02525093f, 0.32143873f, -0.05011235f, 
    0.01428750f, -0.05206360f, 0.08442667f, -0.17428249f, 0.16260129f, -0.02898942f, 0.15002739f, 0.00685157f, 
    -0.02059231f, -0.03077179f, 0.08779103f, 0.16072555f, -0.16211918f, -0.05557744f, 0.05584985f, -0.50358617f, 
    -0.04313176f, 0.08294281f, 0.16060598f, -0.10214659f, 0.02826988f, -0.19436079f, 0.41764420f, -0.11452182f, 
    0.30640602f, -0.06222142f, -0.07218714f, -0.03073089f, -0.30861565f, -0.31164345f, 0.11971153f, -0.31422523f, 
    0.14921682f, -0.03492252f, 0.13566728f, -0.07768251f, 0.42425561f, 0.09357157f, 0.03338454f, 0.03336339f, 
    -0.00302274f, -0.30112526f, -0.06508072f, -0.06902094f, 0.29946136f, -0.14174722f, 0.00191159f, 0.17255396f, 
    0.00771792f, -0.03235936f, -0.17703541f, -0.00659571f, 0.09388202f, -0.16332527f, -0.43142340f, 0.29737103f, 
    0.07947520f, -0.02533802f, -0.07481368f, 0.09440446f, 0.07254826f, -0.24663576f, 0.39562681f, 0.12764101f, 
    0.04538783f, -0.10667060f, -0.33177084f, 0.31019777f, 0.04262911f, 0.26585403f, 0.12774581f, 0.06663678f, 
    -0.18528900f, -0.09167616f, 0.27614963f, -0.11555309f, 0.06922247f, -0.02696373f, 0.09264565f, -0.02301676f, 
    -0.01113371f, -0.03444483f, -0.38372234f, -0.18380177f, 0.10659140f, 0.04335656f, 0.22820148f, 0.18647778f, 
    0.11004876f, 0.40421498f, 0.07170384f, -0.05357222f, 0.03099636f, 0.20738505f, 0.38430873f, 0.23447441f, 
    0.00042699f, 0.24205616f, 0.30312830f, -0.45311660f, 0.00345701f, -0.04130458f, 0.36066622f, -0.02337607f, 
    -0.12407611f, -0.06317600f, -0.39571244f, -0.20346496f, -0.25347313f, 0.05426896f, -0.08571736f, -0.07769109f, 
    -0.14833902f, 0.13193819f, 0.06984469f, 0.29709008f, -0.18588635f, -0.27521569f, -0.05522901f, 0.03459810f, 
    -0.01444827f, 0.00096978f, 0.24526100f, -0.27852300f, 0.65507871f, -0.12001973f, 0.38517275f, 0.03620673f, 
    -0.09797747f, 0.14460966f, 0.19738713f, -0.15726189f, 0.31314036f, -0.08793280f, 0.15421036f, -0.02917665f, 
    0.22501017f, 0.05744091f, 0.02012388f, 0.05898983f, 0.30749750f, 0.03989900f, -0.02290814f, -0.28641883f, 
    0.25018761f, 0.11371256f, 0.18332770f, -0.17416877f, -0.11555994f, 0.12633044f, 0.16880253f, 0.06242877f, 
    0.24920218f, -0.16274112f, 0.00054376f, 0.01535404f, -0.00303809f, -0.17846954f, -0.24806713f, -0.42692029f, 
    0.28308466f, -0.03233487f, -0.13438655f, -0.21961157f, 0.56911987f, -0.00734669f, 0.00140678f, -0.00370593f, 
    0.21195947f, -0.16054042f, 0.27331972f, 0.05314882f, 0.26715043f, 0.08801691f, 0.14325076f, -0.37786654f, 
    -0.14645799f, 0.07764518f, 0.00724927f, -0.35813028f, -0.19368488f, 0.00691549f, -0.05397404f, -0.17105553f, 
    0.04784259f, 0.21118312f, -0.07638732f, 0.12909599f, 0.03854958f, -0.26559770f, -0.11785783f, -0.03325830f, 
    -0.11148931f, -0.01361150f, 0.15532361f, -0.02005149f, -0.02996077f, -0.10341336f, 0.06839309f, 0.00496691f, 
    -0.19261748f, 0.06714123f, -0.04765460f, 0.01742365f, -0.10167451f, 0.08834558f, -0.30585501f, 0.01607471f, 
    -0.10323482f, -0.29728603f, 0.01102461f, -0.11983370f, 0.04709980f, 0.13361435f, 0.02012284f, 0.24485691f, 
    -0.08867978f, -0.27765384f, -0.32689923f, 0.04532048f, 0.10403749f, -0.54226321f, -0.35537168f, -0.08620190f, 
    -0.17976074f, -0.38797644f, -0.00967245f, -0.00711641f, 0.17872283f, -0.22634563f, -0.11964764f, -0.05152493f, 
    -0.07323134f, -0.01977836f, 0.12211024f, -0.46617565f, 0.70304614f, -0.00950386f, 0.02934773f, 0.01536974f, 
    -0.11199876f, 0.22645859f, -0.05669878f, 0.15841475f, -0.56144065f, 0.25792697f, -0.04709127f, 0.12561892f, 
    -0.06898312f, -0.03812144f, -0.18130861f, 0.01276387f, -0.06842186f, 0.12453653f, -0.21595147f, 0.03074278f, 
    0.05313640f, -0.00091905f, 0.00410512f, -0.02376937f, -0.13249363f, 0.07948799f, 0.16243307f, 0.12988718f, 
    -0.13650693f, 0.00010411f, -0.02328579f, -0.18230030f, 0.12632737f, 0.01073918f, -0.13392520f, 0.09194500f, 
    -0.03121917f, -0.05310530f, -0.23472813f, 0.20828268f, 0.15370837f, -0.07564495f, -0.01118789f, 0.17597091f, 
    -0.18614338f, 0.06652296f, -0.06025322f, 0.01299499f, -0.11937597f, 0.11082715f, -0.10389112f, 0.14822316f, 
    0.01755376f, 0.07272527f, -0.02135350f, -0.03323198f, -0.18193644f, 0.21898097f, -0.00562633f, 0.03673558f, 
    0.16201891f, 0.07414524f, 0.29125884f, -0.05969882f, 0.28866723f, 0.08170004f, 0.03656402f, 0.08646746f, 
    -0.18822925f, 0.06915349f, 0.01592888f, -0.00351994f, 0.04139110f, 0.02773407f, -0.18379572f, 0.19864362f, 
    -0.05477154f, -0.01060883f, -0.07940054f, 0.02080641f, 0.08331838f, -0.14950590f, 0.22735931f, 0.11256278f, 
    -0.01980975f, -0.03378519f, -0.11570706f, 0.02897065f, -0.04790343f, -0.10013972f, -0.09634445f, 0.00602665f, 
    0.05317700f, -0.04131026f, -0.19830401f, 0.02193600f, -0.03365843f, 0.01068597f, -0.17504744f, 0.03242383f, 
    -0.03391178f, -0.21824870f, -0.02987006f, 0.04033903f, -0.21693280f, -0.02412245f, -0.08663787f, -0.17795280f, 
    0.07259441f, 0.07435800f, -0.12707806f, 0.13054983f, 0.05762473f, 0.10762960f, 0.01466807f, 0.03670673f, 
    -0.09354442f, -0.10806094f, 0.02499650f, -0.12304508f, 0.20380050f, -0.30900061f, -0.18373168f, -0.07358757f, 
    0.05147256f, -0.00250043f, -0.61572284f, -0.06367918f, 0.16402607f, -0.18285964f, -0.01550304f, -0.03348774f, 
    0.30856943f, 0.26133147f, 0.05802286f, 0.21071725f, -0.17323142f, -0.10166030f, -0.15870084f, 0.16154249f, 
    -0.12747122f, 0.01779619f, 0.18695007f, 0.01209769f, 0.44166094f, 0.00122256f, -0.23481154f, 0.05830954f, 
    0.08826149f, 0.05378615f, -0.16870852f, 0.01990560f, 0.13998939f, -0.08867884f, 0.22546896f, 0.07337762f, 
    -0.07047542f, -0.02359357f, -0.07679403f, -0.12732653f, 0.08595245f, 0.07823586f, -0.17631966f, -0.07548894f, 
    0.12190153f, 0.10659194f, -0.10506100f, 0.21797197f, 0.13096389f, 0.04699252f, -0.00179022f, 0.31255135f, 
    0.09789772f, -0.10473006f, 0.01005722f, -0.08288626f, -0.23955071f, -0.00414843f, -0.09252253f, -0.12425850f, 
    0.07423905f, -0.03772718f, -0.17074598f, -0.13146572f, -0.34313431f, 0.13579266f, 0.13193043f, -0.02783873f, 
    0.00184149f, 0.11210971f, 0.09444702f, -0.03592451f, -0.02371504f, -0.06436513f, -0.33006129f, 0.12880681f, 
    0.01566828f, 0.02285150f, 0.07061321f, 0.15652256f, 0.03482645f, -0.18325588f, -0.15977994f, 0.14762472f, 
    -0.01237204f, 0.01913471f, 0.02685466f, 0.05809771f, -0.25838706f, -0.24259239f, -0.35389704f, -0.12731746f, 
    0.19842415f, -0.21120510f, -0.42438433f, 0.19692539f, -0.04486211f, 0.02575175f, 0.06662609f, -0.47638434f, 
    -0.43014753f, -0.09877010f, 0.39147511f, -0.17213373f, 0.09436130f, 0.05349863f, 0.12346617f, 0.16289897f, 
    -0.09808506f, -0.10859333f, -0.28571606f, -0.06597137f, 0.20480074f, 0.18198502f, 0.15749463f, -0.07369079f, 
    0.06011118f, 0.16626646f, 0.01363083f, -0.06685334f, 0.11181714f, 0.20854516f, 0.17792965f, 0.14713709f, 
    0.09308603f, 0.33035472f, 0.09126499f, -0.31769675f, -0.15757766f, 0.20804518f, 0.19069326f, -0.28227055f, 
    -0.34158957f, -0.05484816f, -0.09482186f, 0.10374632f, -0.14960371f, 0.11857706f, -0.08967444f, 0.03716467f, 
    -0.40053254f, -0.01702536f, 0.04187204f, 0.41705075f, 0.55305618f, 0.11026314f, 0.18103857f, -0.18272582f, 
    -0.02060236f, 0.00227207f, -0.01715507f, -0.48093382f, 0.21305713f, 0.01725897f, 0.40319347f, 0.06998328f, 
    0.11892464f, -0.20493576f, 0.21742511f, -0.01738886f, -0.18370292f, -0.12188604f, 0.10055307f, 0.03556609f, 
    0.13721918f, -0.04022051f, 0.04454788f, 0.23255599f, -0.11542831f, 0.11136824f, -0.00090632f, -0.27897173f, 
    0.17704307f, 0.18889187f, 0.18675673f, -0.24022219f, -0.42025122f, -0.08014772f, 0.21780802f, -0.24497846f, 
    0.31219634f, 0.07244415f, 0.02887520f, -0.04700914f, -0.02511151f, -0.16765736f, 0.29420039f, -0.35364226f, 
    0.04542347f, 0.07891271f, 0.03581663f, -0.02943985f, 0.54897845f, 0.02260392f, 0.08993532f, -0.06394389f, 
    -0.17738703f, 0.21903946f, 0.31564975f, -0.01479398f, 0.19092377f, 0.02221169f, -0.16838540f, -0.02815669f, 
    -0.07409481f, 0.09808328f, 0.01632356f, -0.11805757f, -0.01909787f, -0.15879115f, 0.01657663f, -0.23141953f, 
    -0.02600867f, -0.11294586f, -0.06142269f, -0.03781205f, -0.34615269f, 0.09042356f, 0.14366122f, 0.16590387f, 
    0.02388237f, 0.17059229f, 0.07995764f, -0.04825085f, 0.01861668f, 0.10923015f, 0.07321777f, -0.23830128f, 
    -0.03218376f, -0.21880633f, 0.05250382f, 0.06767766f, 0.09239177f, 0.05576698f, -0.04892681f, -0.04824257f, 
    0.11804046f, -0.12032155f, 0.09713849f, 0.00303818f, 0.12883203f, -0.31307033f, -0.03541803f, -0.22506481f, 
    0.03611295f, -0.07695593f, -0.06150075f, 0.06640530f, 0.08463384f, -0.05616131f, 0.04040826f, -0.13388431f, 
    -0.16258954f, 0.01301839f, -0.03135680f, 0.04915815f, -0.39912665f, -0.00290697f, 0.22747797f, 0.48605806f, 
    -0.18926194f, -0.02298163f, 0.06521036f, 0.01662997f, 0.46836171f, -0.21741341f, -0.04814748f, 0.07739433f, 
    0.01621978f, -0.02458796f, 0.05459208f, -0.11477989f, 0.24642156f, -0.16033433f, 0.11473282f, 0.15102880f, 
    0.29512456f, -0.00153503f, 0.06981751f, -0.02648535f, 0.16341080f, 0.52541876f, 0.32238388f, 0.02308198f, 
    -0.09123653f, 0.10273664f, -0.09314870f, -0.01783149f, -0.00629425f, -0.18152629f, -0.13299692f, -0.04933747f, 
    -0.06919239f, 0.12302577f, 0.00804052f, 0.00015627f, -0.04828767f, -0.11309151f, -0.26615563f, 0.10931878f, 
    -0.16951042f, -0.04183986f, 0.04442329f, -0.09416740f, 0.23951095f, 0.01349954f, -0.24979363f, -0.27595115f, 
    0.22376367f, 0.07525036f, 0.01989895f, -0.01859115f, 0.03433350f, -0.00339091f, -0.13458942f, -0.17048782f, 
    0.15880772f, 0.03159298f, 0.11126106f, -0.13213751f, -0.06385602f, -0.08485982f, 0.04997948f, 0.05692268f, 
    -0.12286007f, -0.02333480f, 0.16375118f, -0.08386404f, -0.05027507f, 0.01681330f, -0.19103006f, 0.14314112f, 
    0.13527714f, -0.24725020f, 0.04978923f, 0.19485144f, 0.13549690f, 0.14881517f, -0.05632397f, 0.26069853f, 
    0.07821408f, -0.03596354f, -0.02124843f, -0.07539213f, 0.08296575f, 0.00673563f, 0.09624046f, -0.18042646f, 
    -0.11981298f, 0.12019047f, -0.22793472f, 0.16541593f, -0.03888034f, -0.16527309f, -0.14885083f, -0.11673629f, 
    0.00424693f, 0.07089034f, 0.12902085f, 0.22178072f, 0.04066347f, 0.08532706f, -0.03551850f, -0.13417341f, 
    0.22899026f, 0.12225506f, -0.09709223f, -0.08432388f, -0.21395643f, -0.26553535f, 0.09589772f, 0.09783250f, 
    0.03743924f, 0.19792585f, 0.35508206f, 0.09384960f, -0.23460163f, 0.20246768f, 0.32165074f, 0.04665751f, 
    0.13948190f, 0.07015055f, -0.04628324f, -0.00266533f, -0.45888931f, -0.04581106f, 0.06209492f, 0.36477053f, 
    0.19497943f, -0.09240108f, -0.10532946f, 0.22471292f, 0.27624691f, 0.10089385f, -0.03565514f, -0.02743163f, 
    0.05066155f, -0.60855746f, -0.07630271f, -0.41143474f, -0.07408939f, 0.20588170f, -0.12778303f, -0.26285866f, 
    0.15773743f, -0.04417542f, 0.03900359f, -0.07175232f, -0.19794242f, -0.05122115f, 0.03500370f, -0.04179617f, 
    0.12948775f, 0.04387807f, -0.06791434f, -0.22623108f, 0.10617800f, 0.01196235f, -0.20400727f, -0.06026401f, 
    0.05663455f, -0.04328683f, -0.02174908f, 0.26631492f, -0.18765967f, -0.11539385f, 0.10291283f, -0.22491388f, 
    -0.18150848f, -0.04781768f, 0.01852636f, 0.00113134f, 0.15257125f, -0.00673494f, -0.09669571f, -0.29017496f, 
    -0.19236970f, 0.10983094f, 0.03094130f, -0.49064976f, -0.19958088f, -0.26864150f, 0.20452350f, -0.10780732f, 
    0.02595391f, -0.05090459f, -0.04288262f, 0.12051085f, -0.05856086f, -0.40220010f, -0.08122545f, -0.12950444f, 
    0.11704289f, -0.20750350f, 0.18304974f, 0.00921923f, -0.01072874f, 0.12671863f, 0.08010688f, 0.02938716f, 
    -0.06967169f, 0.13915147f, 0.15934071f, -0.04961806f, 0.05220611f, 0.08846544f, 0.00259138f, -0.08725867f, 
    -0.12139525f, 0.28198823f, -0.06362581f, 0.10169709f, -0.09615850f, 0.06466529f, 0.27259636f, 0.05156644f, 
    -0.07150518f, 0.11676107f, -0.07871139f, -0.04053573f, -0.05587986f, -0.03716514f, 0.11531943f, -0.09204303f, 
    -0.09413134f, 0.19729966f, -0.29936543f, -0.02748003f, 0.00693177f, -0.05596963f, -0.05786943f, 0.13879795f, 
    -0.06493621f, -0.02061943f, 0.01737926f, -0.01754745f, 0.12351537f, 0.49967289f, -0.08065711f, -0.42118633f, 
    0.05101131f, -0.16685565f, -0.08475633f, 0.06760214f, 0.09819623f, 0.03753654f, -0.30764338f, 0.00940954f, 
    0.07063363f, -0.06564105f, -0.13091457f, -0.05551318f, 0.52731413f, -0.01101591f, -0.01532658f, -0.07796132f, 
    -0.10091184f, 0.06390873f, -0.02861535f, -0.02935164f, 0.19402781f, -0.03396302f, -0.04168090f, -0.02366561f, 
    0.16099977f, 0.46790710f, -0.08214454f, 0.50162029f, -0.05260910f, 0.02321993f, 0.07003504f, 0.14724398f, 
    0.01173503f, -0.01819989f, -0.06009763f, -0.03336317f, 0.05542069f, -0.37097719f, -0.00143831f, 0.06295236f, 
    -0.16433296f, -0.09203321f, -0.05556428f, 0.14408568f, 0.05507267f, 0.07307201f, 0.14881338f, 0.12246209f, 
    -0.03600085f, -0.01568921f, -0.05326694f, -0.09338314f, 0.10994349f, 0.16592406f, -0.05079442f, -0.09834835f, 
    -0.03507268f, 0.21809056f, 0.10890085f, 0.06904956f, -0.03143355f, -0.02757454f, 0.31273046f, 0.10598563f, 
    0.21236396f, -0.07028668f, 0.06950852f, 0.31750709f, 0.02479151f, -0.05993600f, -0.01037980f, 0.10464195f, 
    0.08463828f, 0.08171560f, -0.07613481f, 0.15319169f, -0.14344700f, 0.05936629f, 0.00163932f, -0.04337468f, 
    0.06151541f, 0.06757832f, 0.02004700f, -0.08048623f, -0.07922137f, 0.02621567f, -0.12641253f, -0.01124417f, 
    -0.07501201f, -0.08511057f, -0.02715854f, 0.06309046f, -0.06980246f, -0.09551503f, 0.01854212f, -0.05539477f, 
    -0.02088627f, -0.05305332f, -0.01479416f, 0.01736350f, -0.07405677f, -0.02615073f, 0.01246698f, -0.00112082f, 
    -0.03637383f, 0.00777752f, -0.06981786f, 0.04431964f, 0.05610666f, -0.11442432f, -0.12619014f, -0.03927712f, 
    -0.03119562f, -0.03375053f, -0.05982088f, 0.04662896f, -0.06673210f, -0.03396691f, 0.03512466f, 0.02634335f, 
    0.02496441f, 0.03689038f, -0.02401490f, -0.08832552f, -0.13459964f, -0.12158509f, -0.06202280f, -0.04983511f, 
    0.07849487f, -0.02627887f, 0.02893906f, -0.09849138f, -0.11872284f, -0.04530566f, -0.05898640f, -0.08195090f, 
    0.03616890f, 0.00985541f, 0.01672244f, 0.05377467f, -0.02568855f, -0.01370536f, -0.07365786f, -0.04587697f, 
    -0.05997059f, -0.07395888f, 0.06511127f, 0.01874845f, 0.03985695f, -0.08688310f, -0.05015158f, 0.07597650f, 
    0.06614182f, 0.06064178f, -0.02421582f, -0.08510943f, 0.02753215f, 0.06902794f, 0.04207104f, -0.04089976f, 
    -0.05849453f, -0.06581967f, -0.02260404f, 0.01094093f, -0.05196936f, -0.11800350f, 0.05157628f, 0.03134745f, 
    -0.02648190f, 0.00026249f, -0.02265686f, 0.05354701f, -0.03093877f, 0.02713398f, 0.01132675f, -0.08369982f, 
    0.01494773f, -0.08656521f, -0.05934328f, -0.03667256f, -0.10520129f, 0.03168583f, -0.09276562f, 0.00660312f, 
    -0.02245330f, -0.07710979f, -0.08924037f, 0.01779616f, 0.01684358f, 0.00459977f, -0.11743944f, -0.03026791f, 
    0.05380164f, 0.06764389f, -0.05221037f, -0.01160104f, -0.10860536f, -0.04315278f, 0.00753087f, -0.07186602f, 
    0.01184667f, -0.13929372f, -0.01535313f, 0.04828622f, 0.01761990f, 0.03363499f, 0.06530035f, -0.02225110f, 
    0.09371485f, 0.06364836f, 0.22281832f, -0.04290381f, -0.02951310f, 0.05921019f, -0.23911619f, 0.15840153f, 
    0.21966438f, 0.22353959f, -0.04113103f, 0.15956588f, -0.03378657f, 0.03847613f, 0.15055510f, 0.09961636f, 
    -0.15273573f, 0.00019457f, -0.08988949f, 0.07673852f, 0.24749051f, 0.08900362f, -0.18553433f, 0.00818962f, 
    -0.06253910f, 0.20433103f, -0.05057247f, -0.18644807f, -0.05404672f, -0.12789184f, -0.06442067f, -0.26908156f, 
    -0.03263051f, 0.13718638f, -0.31694719f, 0.19522344f, 0.14192905f, -0.07534977f, 0.13297184f, 0.01154027f, 
    0.02079191f, 0.11941638f, 0.02486748f, 0.33194712f, -0.27754384f, -0.14311078f, -0.09661942f, 0.05096961f, 
    0.05920881f, 0.10085594f, 0.12410948f, 0.04010960f, 0.10393355f, 0.08906499f, 0.00349785f, -0.11189542f, 
    0.20295610f, -0.16235191f, -0.03724973f, 0.10092763f, 0.45996615f, -0.21815960f, -0.00214432f, 0.21959166f, 
    0.08328749f, -0.01438571f, 0.62224227f, 0.11237063f, 0.05843496f, 0.14574058f, -0.01422778f, 0.06397288f, 
    0.19119985f, 0.14057744f, -0.03286235f, -0.21199445f, -0.07382444f, 0.01636198f, -0.01451885f, 0.10661314f, 
    0.35912871f, -0.02517032f, 0.11217500f, 0.12189444f, -0.11033164f, -0.05934399f, -0.39616305f, -0.16407470f, 
    0.11236098f, 0.03843777f, -0.03148194f, -0.10358872f, 0.13557085f, 0.15497486f, -0.03001258f, 0.14412750f, 
    -0.04509681f, -0.03386325f, 0.01775646f, 0.00557642f, -0.20887950f, 0.02937143f, -0.01361049f, -0.08350420f, 
    0.11159802f, 0.00187714f, -0.14217228f, -0.15376572f, 0.07912078f, -0.00654090f, 0.08994975f, 0.23008919f, 
    -0.05389422f, 0.03373599f, 0.09317167f, 0.03267993f, 0.07704190f, -0.23751917f, 0.12532644f, 0.36698645f, 
    0.05269145f, 0.03503396f, -0.26546296f, 0.13384797f, -0.31686148f, 0.02137557f, -0.01325633f, 0.18148905f, 
    0.12293670f, -0.47130793f, -0.01535897f, -0.05820685f, 0.33056951f, -0.15166649f, -0.02711767f, 0.07344600f, 
    0.02455751f, 0.09121178f, 0.10994101f, 0.14672215f, 0.07873004f, 0.01610545f, 0.12925871f, 0.23518860f, 
    -0.07652980f, 0.17852356f, -0.03347830f, -0.03927159f, 0.09435164f, 0.07925016f, 0.45475507f, 0.20250505f, 
    -0.22022472f, 0.07985248f, 0.10185625f, 0.04409092f, 0.03859539f, 0.11501051f, -0.14458267f, -0.12900162f, 
    0.01838718f, 0.13938600f, -0.00464527f, 0.18386786f, 0.01489082f, 0.00099407f, 0.43053836f, -0.16980518f, 
    -0.03705046f, 0.04603895f, 0.04751660f, 0.06165819f, 0.01088144f, 0.20445302f, 0.08409875f, 0.18249495f, 
    0.07834318f, 0.08007146f, -0.17538895f, 0.23219053f, -0.02267283f, 0.21029098f, -0.02267637f, 0.06263424f, 
    0.19155392f, 0.14057304f, -0.11328426f, -0.12179614f, 0.16763681f, -0.10296163f, 0.20968352f, -0.03136898f, 
    -0.01910628f, -0.00305953f, 0.01866625f, -0.09435284f, 0.32087418f, 0.08503937f, 0.05813995f, -0.01602566f, 
    -0.10682186f, 0.19831458f, 0.01888196f, 0.19998994f, 0.13496029f, 0.34619656f, 0.01170970f, -0.09872003f, 
    0.00633969f, 0.00732524f, -0.13296719f, 0.18033999f, 0.22222947f, -0.17449369f, 0.19755143f, -0.06015613f, 
    0.00088503f, 0.03672291f, -0.09573364f, -0.09057716f, 0.09885702f, -0.10561492f, -0.01151063f, 0.01704862f, 
    0.03971768f, 0.14878570f, -0.09397005f, -0.01238177f, 0.05273941f, -0.04892578f, -0.10887084f, 0.05194934f, 
    0.09269341f, -0.13315555f, -0.01436494f, -0.15139629f, 0.21798354f, -0.09725916f, 0.05347002f, 0.02867289f, 
    0.02140655f, -0.01477873f, 0.05333236f, 0.22400455f, 0.39324909f, 0.00113590f, -0.08723914f, 0.19785702f, 
    0.27903947f, -0.05785635f, -0.12287889f, -0.05939358f, 0.28778276f, 0.05378385f, -0.20731732f, 0.05724708f, 
    0.04503111f, -0.43853828f, 0.22598106f, -0.02906575f, 0.02157166f, -0.28292555f, -0.23533325f, 0.27681741f, 
    0.12919776f, -0.00934353f, 0.03303474f, 0.30406138f, 0.01867288f, -0.10968816f, 0.29921097f, 0.20658223f, 
    -0.09693447f, 0.10464033f, -0.00834118f, 0.02855489f, -0.01276266f, 0.12475649f, 0.18761992f, -0.04754248f, 
    -0.11611801f, 0.02583187f, -0.02161574f, 0.02928217f, 0.02570716f, -0.04070645f, -0.00308727f, -0.18805003f, 
    -0.21910247f, 0.18712239f, -0.11685693f, 0.14273304f, 0.21817924f, -0.04688170f, 0.44823706f, -0.02178358f, 
    0.09715693f, 0.16765842f, -0.09306563f, 0.16193388f, 0.00900600f, -0.38418928f, 0.17674938f, -0.05364776f, 
    0.08306315f, 0.34513646f, 0.07955426f, -0.06699623f, 0.09079936f, 0.27307174f, 0.08776630f, 0.06836329f, 
    0.33393830f, 0.20099737f, -0.19014637f, -0.16726477f, 0.15486638f, -0.13736501f, 0.05985513f, -0.02528032f, 
    0.03539789f, -0.08897937f, 0.26332906f, 0.08471033f, -0.03809174f, 0.16465952f, 0.04762797f, -0.01387396f, 
    -0.05873825f, -0.21453699f, -0.05570410f, 0.19243991f, 0.03889215f, 0.00299487f, -0.03750851f, -0.06972238f, 
    0.12387451f, 0.00337080f, 0.11500774f, 0.07209948f, 0.03922155f, -0.15105820f, 0.20420134f, -0.17144668f, 
    -0.07412525f, 0.10879833f, 0.06549729f, -0.15503280f, 0.09773748f, -0.00433423f, -0.06977843f, 0.01985586f, 
    -0.00046595f, 0.00047762f, -0.00523471f, 0.10136550f, -0.35275301f, -0.08550692f, 0.11467643f, -0.21272184f, 
    0.24355109f, 0.07419369f, -0.03379728f, -0.29199925f, 0.21474892f, -0.17846017f, 0.27279767f, -0.11285651f, 
    0.15902153f, -0.08313273f, -0.08075710f, 0.19348939f, 0.07151658f, -0.29296389f, -0.15625989f, 0.29352033f, 
    0.07443459f, 0.03160022f, -0.12867838f, -0.06631136f, 0.38148114f, -0.00485211f, -0.18326207f, 0.08459929f, 
    0.02834447f, -0.03243418f, -0.02291488f, 0.02683929f, 0.06606739f, 0.00962462f, 0.01446156f, -0.08550242f, 
    -0.06993058f, 0.02238935f, 0.03410377f, 0.02639498f, -0.08136396f, 0.00291472f, 0.02521944f, -0.03940470f, 
    0.03296747f, -0.02637976f, -0.00213359f, 0.06776574f, -0.10640278f, 0.01101278f, -0.07400173f, -0.08829875f, 
    -0.08131402f, 0.03304836f, -0.07422191f, -0.05366982f, 0.07043299f, 0.01490455f, 0.07120713f, 0.04812967f, 
    -0.02637174f, -0.06419971f, -0.05498155f, -0.04289355f, -0.05187854f, 0.07593147f, 0.05624006f, 0.03428420f, 
    0.04855474f, 0.03198714f, -0.09815525f, -0.08641408f, -0.04523378f, -0.00486295f, -0.08569519f, 0.05354315f, 
    -0.05053141f, -0.02952012f, 0.05723324f, -0.05507689f, -0.07466691f, 0.01150729f, 0.02519158f, 0.00327998f, 
    -0.01715669f, -0.04804891f, 0.01054034f, -0.07838412f, -0.05420265f, -0.06343984f, 0.04221518f, 0.03561377f, 
    -0.09928098f, 0.07793047f, -0.06827732f, -0.11429573f, 0.03831881f, -0.05782317f, 0.02704178f, -0.00773730f, 
    -0.07462502f, 0.10039368f, 0.02591108f, -0.00147614f, 0.00573536f, -0.08895763f, -0.04974689f, 0.06506608f, 
    -0.07543354f, -0.00985196f, -0.09883992f, -0.00591967f, -0.06795612f, 0.03793183f, -0.04897640f, 0.02956282f, 
    -0.07495002f, 0.04666000f, -0.03362150f, -0.10806143f, -0.02395482f, 0.06791125f, 0.06150625f, -0.08299964f, 
    0.00130441f, -0.11181213f, -0.04756030f, 0.03769140f, -0.05142055f, -0.07808627f, -0.05293749f, -0.00746044f, 
    -0.05581729f, -0.05108847f, -0.06994806f, 0.03068245f, -0.02613819f, 0.00694079f, -0.00500611f, -0.08086892f, 
    -0.06200248f, -0.11561324f, -0.07329702f, -0.00127100f, -0.06343643f, -0.05193903f, -0.00731869f, -0.08382192f, 
    -0.02759039f, 0.04965012f, -0.06447119f, -0.12506118f, -0.05216742f, -0.00040838f, -0.06647223f, -0.08820698f, 
    -0.02218105f, -0.33612534f, -0.02168795f, 0.00606555f, 0.43882436f, -0.04903321f, 0.01039019f, -0.04901827f, 
    -0.13145836f, 0.00483445f, 0.08869983f, -0.03327728f, -0.04382275f, -0.06037701f, -0.05140353f, 0.22294281f, 
    0.05253734f, 0.16707960f, -0.01565289f, 0.05360154f, 0.13068737f, -0.16088793f, 0.35939541f, 0.16623984f, 
    -0.28604549f, -0.05198447f, 0.04840027f, 0.28676784f, 0.04120656f, 0.24368700f, 0.07130078f, 0.05165814f, 
    0.10503525f, 0.06540350f, 0.11166596f, 0.13929038f, 0.03221278f, -0.01589472f, 0.41548130f, 0.01760409f, 
    0.09623983f, 0.02149724f, -0.12682623f, -0.20748332f, 0.08175933f, 0.03460420f, 0.28885639f, 0.38011625f, 
    -0.01146191f, 0.25246811f, -0.12889019f, 0.17775498f, -0.06490969f, 0.14110295f, 0.05371893f, 0.01947501f, 
    0.07193060f, 0.25064906f, 0.08550016f, -0.13311262f, 0.20527698f, 0.00016094f, 0.40867761f, 0.19865389f, 
    0.05120303f, -0.04202191f, -0.35831925f, -0.07102066f, 0.02758842f, 0.17265674f, -0.03296538f, 0.08018824f, 
    -0.00857824f, 0.27110788f, -0.03307462f, 0.43790287f, -0.01788580f, 0.14756200f, -0.05427394f, 0.08753155f, 
    0.08697613f, -0.08640923f, 0.13608547f, 0.11749758f, 0.34779567f, -0.21598881f, 0.39459246f, 0.06038844f, 
    -0.09014715f, 0.21921706f, 0.03516215f, -0.01353072f, 0.24212956f, -0.16864893f, 0.17781709f, 0.00877481f, 
    0.03119591f, 0.09189175f, 0.07442550f, -0.03487169f, 0.14627777f, 0.01466161f, -0.00394644f, 0.01230204f, 
    0.18366104f, 0.02681414f, 0.16246311f, 0.04994975f, -0.07414933f, 0.05908073f, 0.04502351f, 0.02879265f, 
    0.20569707f, -0.20855124f, 0.10999164f, 0.01201658f, 0.06427518f, -0.04867861f, -0.29707080f, -0.19586103f, 
    0.36586314f, -0.14867193f, -0.11776927f, -0.15713075f, 0.47311068f, 0.09167753f, -0.14082371f, -0.06001657f, 
    0.12077897f, 0.02678102f, 0.34191313f, -0.06595969f, 0.49765456f, 0.10537745f, 0.04605522f, -0.01990426f, 
    -0.21052039f, 0.00410221f, -0.02196568f, -0.02351153f, 0.08093389f, -0.08618402f, -0.26665258f, 0.17760926f, 
    -0.07972833f, 0.18949969f, 0.09345876f, 0.01320789f, -0.11404666f, -0.28127369f, 0.48971316f, 0.12415609f, 
    -0.05018456f, -0.11335817f, -0.20829108f, 0.20477715f, -0.05712586f, 0.04371962f, 0.10329524f, 0.08267491f, 
    0.08340630f, -0.09354077f, 0.12988019f, 0.03047694f, -0.05391417f, -0.08099605f, 0.08876468f, -0.07516942f, 
    -0.02313885f, -0.15218747f, -0.15476690f, -0.05228295f, -0.03828423f, 0.03715099f, 0.22685684f, -0.10168497f, 
    0.20516004f, 0.37399769f, -0.18621974f, 0.08721912f, 0.07752549f, 0.01760545f, 0.16166055f, 0.13931482f, 
    -0.03334726f, 0.16114435f, 0.12854320f, -0.31633049f, 0.19508751f, -0.33608109f, 0.11641099f, 0.02476615f, 
    0.05744881f, 0.02063260f, -0.57114559f, -0.10893199f, 0.22973460f, -0.11832235f, 0.03374601f, 0.07180226f, 
    0.30668059f, 0.49583793f, -0.06069435f, 0.29192913f, -0.23232670f, -0.04819128f, -0.19771233f, 0.14405903f, 
    -0.00792667f, 0.04132467f, 0.22127028f, -0.02574773f, 0.66193199f, 0.03722053f, -0.00109357f, 0.09543978f, 
    -0.02405945f, 0.18419990f, -0.02138114f, 0.00240658f, 0.24406523f, -0.04002322f, 0.21086133f, 0.04155722f, 
    -0.03582771f, -0.02187837f, -0.04997084f, -0.09648731f, -0.00982720f, 0.02730314f, -0.03904206f, -0.13400409f, 
    0.20026155f, 0.04693295f, -0.10331197f, 0.14586772f, 0.03070883f, 0.01699480f, -0.10177970f, 0.33101609f, 
    0.17708994f, -0.25131389f, -0.07288788f, -0.05220666f, -0.20039788f, -0.05593792f, -0.23097676f, -0.34793305f, 
    0.23459338f, 0.00491750f, -0.05674699f, -0.21526916f, 0.27598947f, 0.30978417f, 0.22489500f, 0.05724669f, 
    0.09615493f, 0.25080428f, -0.29974285f, 0.07309229f, 0.15966035f, 0.05848562f, 0.01453369f, 0.10335315f, 
    0.00915359f, 0.05287359f, -0.00506477f, -0.00808492f, 0.10113537f, 0.03912627f, 0.07053789f, 0.26972187f, 
    -0.20424402f, -0.12342662f, 0.06119522f, 0.03484246f, 0.05805085f, -0.10391360f, 0.10338581f, 0.00059139f, 
    0.11571942f, 0.10251623f, 0.05694273f, 0.08678758f, -0.08401244f, 0.00092351f, -0.04238883f, -0.13591464f, 
    -0.01328754f, -0.07391478f, -0.11751308f, 0.05587043f, -0.06110959f, -0.04866005f, -0.11786389f, 0.11265484f, 
    -0.06618016f, -0.04024390f, 0.09232016f, 0.13959172f, -0.30995446f, -0.19931486f, 0.03016265f, 0.12875748f, 
    0.19880676f, 0.20379208f, -0.02067390f, -0.09304421f, 0.06470101f, -0.07599068f, 0.13414881f, 0.10674497f, 
    -0.17967944f, 0.02267267f, 0.21312429f, 0.08603179f, -0.02551474f, -0.03470563f, -0.04698329f, -0.10986679f, 
    0.04219316f, 0.06242719f, -0.58948898f, -0.12686555f, -0.32872546f, -0.08091210f, -0.07204962f, -0.05925104f, 
    0.09921210f, 0.03246904f, -0.00015766f, -0.15195255f, 0.07445302f, -0.00342142f, -0.07431347f, 0.16180180f, 
    -0.03803548f, -0.02624647f, 0.14854869f, 0.13192099f, 0.50417858f, 0.01642671f, -0.44876209f, -0.00416366f, 
    0.18858892f, 0.02103602f, -0.07859298f, -0.03530947f, 0.11818263f, -0.03957109f, 0.07135544f, -0.02119325f, 
    -0.03240278f, -0.15235893f, -0.02643265f, -0.01396324f, 0.20405243f, 0.04518705f, -0.03122221f, 0.04998439f, 
    0.10176050f, 0.06859381f, -0.09254777f, 0.11525981f, 0.08170850f, 0.21980932f, -0.02088130f, 0.48017299f, 
    -0.28373620f, 0.11297969f, 0.06516094f, -0.09548052f, 0.10592773f, -0.06963184f, -0.24339260f, 0.03089557f, 
    0.04184225f, -0.11862500f, -0.12542561f, 0.03013746f, -0.39964241f, -0.00136890f, 0.26658425f, 0.04469593f, 
    -0.33369941f, -0.09581549f, -0.14786547f, -0.01638961f, -0.19546229f, -0.00324263f, -0.19654961f, 0.24377005f, 
    -0.03695967f, 0.19010469f, -0.07521489f, -0.15889978f, -0.03518986f, -0.10221399f, 0.12764704f, -0.35623875f, 
    -0.25428298f, -0.16656983f, -0.02694036f, -0.12853923f, -0.29044658f, 0.19389322f, -0.21194926f, 0.24922235f, 
    -0.18777694f, 0.19946703f, 0.13871722f, -0.07997328f, -0.04063649f, 0.20787524f, 0.10212488f, -0.11289077f, 
    -0.00298422f, -0.04148778f, -0.20964621f, -0.09489104f, 0.10079058f, 0.04362482f, 0.11414075f, 0.21275505f, 
    0.03750698f, -0.05722413f, 0.05744857f, 0.14194266f, 0.15757842f, -0.38712481f, -0.20506319f, -0.28645957f, 
    -0.03296487f, -0.24807523f, -0.09797894f, 0.08912970f, 0.11151104f, 0.05326343f, -0.52910233f, -0.22886240f, 
    0.12334637f, -0.04685467f, -0.01906919f, 0.12032195f, -0.09848085f, 0.08780719f, 0.16503969f, 0.35423961f, 
    -0.26836470f, -0.02894890f, -0.11038364f, 0.03207010f, 0.27312157f, -0.09758156f, 0.07870729f, 0.00421304f, 
    -0.06281848f, -0.23185201f, 0.06911460f, -0.12454245f, 0.28245389f, -0.06423575f, 0.24721353f, 0.13855946f, 
    0.21393295f, -0.07818969f, -0.10000881f, -0.02134291f, -0.06777623f, 0.42337772f, 0.24773192f, -0.11314278f, 
    -0.43856895f, -0.07001355f, -0.04203326f, -0.11324532f, -0.17774014f, -0.13864954f, -0.35429808f, 0.06950736f, 
    -0.03449511f, 0.20549473f, 0.04576204f, -0.05558594f, 0.15919372f, -0.13862194f, -0.11585980f, 0.07714114f, 
    -0.03338100f, 0.03789336f, 0.13685571f, -0.25124601f, 0.23830886f, -0.17608312f, -0.00833364f, -0.06371528f, 
    0.00878838f, 0.06785271f, -0.01340909f, 0.20961720f, 0.33358541f, -0.11666851f, -0.20594077f, 0.13299350f, 
    0.09881587f, 0.17634413f, 0.14331220f, 0.03824367f, -0.17885469f, -0.16972981f, -0.12504202f, 0.00904456f, 
    -0.09441675f, 0.34218714f, 0.13832836f, 0.00572813f, -0.20503907f, 0.16912118f, -0.10252850f, 0.02307672f, 
    0.07069692f, -0.00556441f, -0.13029389f, 0.09523124f, 0.11342848f, 0.01643410f, -0.02075285f, 0.12390825f, 
    0.04128996f, -0.16518357f, 0.00660987f, -0.00085446f, -0.01735258f, 0.10520247f, -0.24898136f, 0.01819189f, 
    0.13469219f, 0.10886848f, -0.08511682f, 0.07073806f, 0.01189376f, -0.16036116f, -0.10145853f, -0.11076041f, 
    0.01713610f, 0.03240037f, 0.22378792f, 0.04273555f, 0.01536117f, 0.02366253f, -0.09453653f, 0.05528217f, 
    -0.03827399f, -0.02182519f, -0.00277398f, 0.14985405f, -0.08943993f, -0.42697862f, -0.08895922f, -0.05154620f, 
    0.02490346f, -0.07596401f, 0.15584256f, 0.01102975f, 0.01760858f, 0.10886729f, 0.17920123f, 0.15159184f, 
    -0.03284989f, -0.00170133f, -0.06039300f, 0.08557074f, -0.53498983f, 0.02603440f, -0.03985254f, 0.16743815f, 
    0.06764335f, 0.00343562f, 0.12590770f, 0.09022976f, 0.09946016f, 0.03001860f, -0.00307605f, 0.06392489f, 
    0.01573718f, -0.29476309f, 0.04966805f, -0.40941018f, 0.06768841f, -0.09154840f, 0.03109848f, -0.09587305f, 
    0.16383579f, 0.04296337f, 0.06231900f, 0.04280534f, -0.35538426f, 0.18599816f, 0.01625401f, 0.05692621f, 
    0.16827747f, 0.07604100f, 0.10965511f, -0.02684855f, -0.04345337f, 0.04393096f, -0.13498850f, -0.05096288f, 
    -0.07102368f, -0.08623327f, 0.08177046f, 0.14165825f, 0.04659010f, 0.03642053f, -0.01556840f, -0.04267476f, 
    -0.11273415f, 0.06398492f, 0.01072907f, 0.02158651f, 0.19018959f, 0.02161023f, -0.32687905f, -0.07728527f, 
    -0.04030953f, 0.32246393f, 0.06871351f, -0.08159865f, -0.03300675f, -0.13492037f, 0.24547917f, -0.08127376f, 
    -0.19559146f, 0.21300226f, 0.14685136f, 0.13122557f, -0.14692686f, -0.17018923f, 0.09346087f, -0.02363568f, 
    -0.01790677f, 0.15613422f, 0.25842622f, -0.04012424f, -0.02851851f, 0.03361014f, -0.10649818f, 0.04317033f, 
    -0.06178065f, -0.12353870f, 0.07610480f, 0.04072924f, -0.07911423f, 0.03198348f, -0.02036233f, -0.04095818f, 
    0.14549807f, -0.10116450f, -0.01769083f, -0.02518759f, 0.04993977f, -0.03921211f, 0.02486569f, -0.13485892f, 
    -0.04069163f, -0.03311763f, -0.12917116f, -0.07999960f, 0.01376304f, -0.02969173f, -0.10738754f, -0.05346474f, 
    0.00570483f, 0.05960427f, -0.06968603f, 0.04194568f, -0.05722082f, -0.05446184f, -0.13346791f, -0.10589562f, 
    -0.11468074f, -0.07814428f, -0.01672845f, 0.04558861f, -0.03233640f, -0.01830659f, -0.06691418f, 0.00930640f, 
    -0.01686295f, -0.01551644f, -0.01889891f, -0.05414515f, -0.02527592f, -0.04340822f, -0.00070952f, -0.10968283f, 
    -0.01868290f, -0.09008529f, -0.03084179f, 0.00159736f, 0.04707500f, 0.00306828f, -0.12245206f, 0.02528586f, 
    0.03220609f, 0.04679375f, -0.09527325f, -0.00254565f, 0.13925390f, -0.09339128f, -0.00155822f, 0.03743768f, 
    0.01653736f, 0.06787205f, 0.02827296f, 0.08037080f, -0.09869786f, 0.03404376f, -0.14474146f, -0.06411564f, 
    0.04903657f, 0.04407905f, -0.01358945f, 0.01031044f, -0.09846278f, -0.03537043f, -0.06835698f, -0.07548686f, 
    -0.06368170f, -0.07219175f, 0.00265134f, 0.05178360f, -0.01601097f, 0.03457652f, -0.00937229f, -0.10769135f, 
    -0.11660291f, -0.18886320f, -0.02449657f, 0.00873805f, 0.02054412f, -0.10749345f, -0.04983881f, -0.06928103f, 
    -0.00394622f, -0.08989234f, -0.06737791f, 0.06535481f, 0.08052173f, 0.00949587f, 0.01052379f, 0.06053421f, 
    0.03238726f, 0.08918237f, 0.02152775f, 0.01580351f, -0.04950184f, 0.02621878f, 0.15833895f, -0.06350517f, 
    -0.13400126f, -0.07915097f, 0.13140789f, 0.02040194f, -0.06851877f, -0.04207894f, -0.02871433f, -0.08851620f, 
    -0.31939065f, 0.13450389f, 0.00074363f, 0.03915555f, 0.13079055f, -0.21259707f, 0.04204690f, 0.02960469f, 
    0.05374346f, -0.15376557f, 0.02434666f, 0.11006067f, 0.15395808f, 0.00392884f, 0.12686722f, 0.11797439f, 
    -0.09450857f, 0.04311064f, -0.05869657f, -0.11088084f, 0.07035602f, 0.16279922f, 0.41642356f, 0.20790121f, 
    -0.08167642f, -0.05022781f, 0.00581997f, -0.15664807f, 0.05490865f, 0.26063606f, -0.01010888f, -0.03941488f, 
    0.09323130f, 0.01848566f, 0.05800132f, 0.15498212f, 0.11470982f, -0.08288421f, 0.40059379f, -0.14713898f, 
    0.01389464f, 0.12608793f, -0.01809387f, -0.03451455f, 0.08752465f, 0.21189754f, 0.02798338f, 0.11819220f, 
    0.05963189f, 0.04953433f, -0.03328035f, 0.10843880f, -0.28733262f, 0.22662437f, 0.10939087f, 0.09207463f, 
    0.29808331f, 0.20055072f, -0.07823027f, -0.02589791f, -0.22626780f, -0.09791740f, 0.14458179f, 0.00734860f, 
    0.03304564f, 0.13054593f, 0.18434805f, 0.17711715f, -0.08482119f, 0.03798997f, 0.02116536f, -0.05101521f, 
    -0.13969691f, -0.41292056f, 0.06528134f, 0.14545673f, 0.26270449f, 0.37978142f, 0.03148415f, -0.20914367f, 
    0.11257436f, -0.07564609f, 0.11240169f, 0.18162322f, 0.07687796f, -0.48743072f, 0.22762644f, -0.08950227f, 
    -0.32833138f, 0.15219918f, -0.24827410f, -0.18402418f, 0.19571014f, -0.16693826f, -0.28434983f, -0.05783774f, 
    0.15782714f, 0.13478807f, -0.07298952f, -0.10368289f, -0.09750450f, -0.11439428f, 0.07032235f, 0.01487751f, 
    0.04662311f, -0.24905197f, 0.05995396f, 0.04899374f, 0.08900576f, -0.01047803f, 0.08916776f, -0.16772294f, 
    0.22736984f, -0.16808158f, 0.00521394f, 0.01952621f, 0.33804375f, -0.00091719f, 0.02490500f, 0.11262804f, 
    0.09604157f, -0.13312338f, 0.05141331f, -0.10798390f, 0.20638114f, -0.24827662f, -0.25806460f, 0.02405116f, 
    -0.02199309f, 0.01145074f, -0.36159036f, 0.07039342f, -0.36005008f, 0.21758436f, -0.08831262f, 0.03765038f, 
    0.17437869f, -0.04785999f, -0.00708416f, 0.03737254f, 0.01059090f, 0.09303961f, -0.07551051f, 0.18106930f, 
    0.01348522f, -0.18859081f, 0.07480318f, 0.13078326f, -0.10104068f, 0.08299144f, 0.01561705f, -0.09663952f, 
    0.14059977f, 0.06282920f, -0.04020127f, 0.23206221f, 0.07116289f, -0.15174431f, -0.18350632f, -0.14242744f, 
    -0.11381964f, -0.02553884f, 0.06710634f, -0.14463229f, 0.11582457f, -0.06573171f, -0.14073685f, 0.14810954f, 
    0.04854431f, 0.15336289f, -0.01577192f, 0.06184277f, -0.06824509f, -0.22280788f, 0.08031777f, 0.12138470f, 
    -0.04161287f, -0.03299377f, 0.29875663f, -0.17959411f, 0.00995995f, 0.04337996f, 0.15162608f, -0.01405073f, 
    0.01423036f, 0.01345459f, 0.06243636f, 0.00848781f, 0.01359935f, 0.19724271f, 0.11070538f, -0.03953469f, 
    -0.02254985f, 0.02593130f, 0.69748938f, 0.11705568f, -0.26091772f, 0.09259044f, -0.07091133f, -0.03625018f, 
    -0.00834842f, -0.06168619f, 0.00759694f, -0.64243871f, -0.05921056f, 0.03480106f, 0.10811274f, -0.10734003f, 
    0.12930350f, 0.01229099f, -0.10657172f, -0.27718681f, -0.36165658f, 0.10666364f, 0.16206415f, -0.01070270f, 
    0.36640769f, 0.00503194f, 0.17969236f, -0.15137620f, -0.11899139f, 0.20568915f, -0.03201569f, 0.01043380f, 
    0.07145247f, -0.10997969f, -0.04046768f, 0.21708666f, 0.02568520f, 0.15340643f, 0.13531199f, -0.08134612f, 
    -0.03486498f, 0.01829613f, 0.13178772f, -0.11047082f, 0.16925254f, 0.03892680f, -0.31353694f, -0.12747769f, 
    -0.09953161f, 0.08787012f, -0.10113692f, -0.17132713f, 0.10449568f, -0.16686782f, 0.30342367f, 0.14443186f, 
    -0.01629379f, 0.02119792f, -0.22570844f, 0.12112424f, -0.12505546f, 0.00547550f, -0.08993252f, 0.07216419f, 
    0.03927827f, -0.07338302f, -0.00489592f, 0.00507346f, -0.09044389f, -0.00134520f, -0.04294418f, -0.00559299f, 
    0.00262187f, -0.02920180f, 0.07396480f, 0.01166201f, -0.08950378f, 0.03676687f, 0.00167517f, 0.02134409f, 
    -0.01785881f, -0.00474791f, 0.08049044f, 0.03600600f, -0.01576409f, -0.01183998f, 0.05144447f, -0.08374456f, 
    -0.04638290f, -0.01707052f, -0.04430583f, -0.04724209f, -0.04894166f, 0.05479846f, 0.04051805f, 0.04204042f, 
    -0.11307482f, -0.04842031f, -0.00914949f, -0.03444711f, -0.05105630f, -0.04320762f, 0.02385974f, -0.02739472f, 
    -0.08391524f, -0.10487346f, -0.09266918f, 0.02876511f, -0.00779924f, 0.06991848f, -0.09202596f, 0.04316544f, 
    -0.04411702f, -0.02517541f, -0.07297195f, -0.02014906f, -0.10672513f, -0.05494347f, -0.02844419f, -0.10977050f, 
    0.00715268f, -0.12977128f, -0.00123386f, -0.04631601f, -0.05107296f, -0.10312168f, -0.02285696f, 0.00163441f, 
    -0.04003456f, -0.06574706f, -0.02482871f, -0.07122350f, 0.08727123f, -0.08150500f, 0.00044152f, 0.04602200f, 
    0.02303601f, -0.00666088f, 0.02097010f, 0.01437125f, -0.00471569f, -0.07598389f, -0.08807909f, -0.07905298f, 
    0.04713415f, 0.02890297f, 0.05792752f, -0.06344377f, -0.04785922f, -0.06759433f, 0.03444336f, -0.03647546f, 
    -0.01111950f, -0.10785110f, 0.00728182f, -0.03100100f, -0.05901693f, 0.02572904f, 0.02129038f, -0.06128333f, 
    -0.13835832f, -0.07697034f, 0.00270677f, -0.09859043f, -0.05766200f, -0.02675859f, 0.04211575f, -0.05107123f, 
    -0.00980564f, -0.04099047f, -0.03309232f, -0.00440958f, 0.02773149f, -0.04461292f, 0.07522897f, -0.11009930f, 
    0.04584699f, -0.08041964f, 0.02572912f, -0.00464428f, 0.00836443f, -0.07454531f, -0.09029907f, 0.03493413f, 
    -0.11323515f, -0.07211338f, 0.00675836f, -0.09665709f, 0.01399699f, -0.00144326f, -0.03633478f, -0.06883085f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01470155f, 0.00445114f, -0.02556488f, -0.27340463f, -0.10225350f, 0.02953048f, 0.00170193f, 0.12966236f, 
    -0.19938211f, -0.02460643f, 0.12601930f, 0.17264041f, 0.07396037f, -0.03192966f, 0.16509743f, -0.18172008f, 
    0.07208651f, 0.38233086f, 0.08895096f, -0.12272146f, 0.08992653f, 0.07398957f, 0.06111603f, 0.22450431f, 
    0.17900509f, 0.02108862f, -0.07448372f, 0.17929833f, 0.20790373f, -0.02655950f, -0.20510471f, 0.03370300f, 
    -0.16696034f, 0.17876671f, -0.09187829f, -0.13904794f, -0.04730631f, -0.02116984f, -0.02098792f, 0.11956920f, 
    0.18767159f, 0.08410205f, 0.03262805f, 0.06008786f, -0.05997146f, -0.00458373f, 0.07556110f, -0.08758776f, 
    0.21128713f, -0.07925454f, -0.08808791f, 0.14813578f, 0.35200089f, 0.06909315f, 0.00455490f, 0.24750143f, 
    0.03423503f, 0.26477361f, -0.02982567f, -0.07034559f, -0.05212639f, -0.09576271f, 0.06831724f, -0.18309613f, 
    0.06932753f, -0.09710978f, -0.00594530f, 0.18633004f, 0.02463315f, 0.12863375f, 0.20734289f, 0.02330130f, 
    -0.09274302f, 0.06264748f, 0.16903692f, -0.15506369f, 0.17961828f, 0.09786452f, 0.07051919f, 0.16342926f, 
    0.00585109f, -0.10499816f, 0.17532304f, 0.07098699f, -0.04874213f, -0.07078061f, 0.25483426f, -0.04558177f, 
    -0.03047887f, -0.04813054f, 0.05040345f, -0.05816977f, -0.04714003f, -0.02317544f, 0.07335616f, -0.02481940f, 
    0.14296968f, 0.03630929f, 0.42276105f, -0.02163955f, -0.05314921f, 0.11316044f, -0.01790042f, 0.20545755f, 
    -0.12429108f, 0.14830206f, 0.21567491f, 0.27437630f, -0.16105016f, 0.02725462f, 0.07928556f, -0.05683507f, 
    -0.04119953f, 0.04086880f, -0.11169779f, 0.00311379f, 0.36950600f, 0.22414763f, -0.02812464f, 0.29262367f, 
    0.15195748f, 0.02017578f, 0.09012529f, -0.05615862f, -0.08604880f, 0.28813958f, -0.12667143f, -0.06340182f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.04385568f, 0.03724142f, 0.01422756f, 0.24200174f, 0.20850146f, 0.07878996f, 0.09788159f, -0.12080250f, 
    0.00995239f, 0.01451999f, -0.19593948f, -0.16118795f, -0.12321717f, 0.14272131f, -0.37607673f, 0.22822623f, 
    -0.09492752f, -0.34105468f, -0.14394909f, -0.27987880f, 0.18618770f, 0.17264701f, -0.05464302f, -0.27149433f, 
    -0.34624952f, 0.08872271f, -0.07426812f, 0.04496369f, -0.26891908f, 0.03492214f, 0.25019914f, -0.06163757f, 
    0.11703876f, -0.39122221f, 0.08640882f, 0.22308569f, -0.01601377f, -0.11797968f, -0.13296670f, 0.06871989f, 
    0.12778027f, -0.40913913f, -0.00875756f, -0.31431690f, -0.03871609f, 0.05763483f, 0.03526514f, 0.01113903f, 
    0.10385955f, -0.02111114f, -0.04962694f, 0.16211791f, -0.44377983f, -0.04062777f, -0.04547851f, -0.43373865f, 
    -0.09210785f, -0.10184147f, 0.18965192f, 0.01042705f, 0.04969446f, -0.04421077f, 0.03173591f, 0.08757196f, 
    0.00170208f, -0.00648919f, -0.07809739f, -0.16893370f, -0.00866503f, 0.02197899f, -0.13716801f, -0.01565955f, 
    -0.07285062f, 0.01949767f, -0.57578492f, -0.05160918f, -0.07911776f, 0.06857908f, -0.02004607f, -0.08606838f, 
    0.04817026f, -0.01724136f, -0.22317761f, -0.00330125f, 0.05187407f, 0.02299807f, -0.23154640f, 0.06622571f, 
    0.16285747f, -0.16000740f, 0.10088757f, 0.02757035f, -0.00475729f, 0.01595554f, 0.09038337f, 0.13584277f, 
    0.03708162f, -0.12455934f, -0.31713355f, 0.11868624f, -0.02407738f, -0.06046022f, 0.05334394f, -0.02870957f, 
    -0.07618447f, -0.07866078f, -0.52810538f, -0.60816991f, 0.08462157f, 0.01988580f, -0.05456575f, 0.03900466f, 
    -0.35430396f, -0.00036447f, -0.03434664f, 0.06721891f, -0.44992936f, -0.34417340f, -0.04328540f, -0.46375391f, 
    -0.45768598f, -0.01558492f, -0.28280705f, 0.13432923f, -0.04359040f, -0.12892339f, 0.13221192f, 0.02048861f, 
    -0.10615173f, 0.03398175f, -0.03354764f, -0.72861272f, 0.30307406f, 0.10179166f, 0.18563379f, 0.21698201f, 
    -0.30223680f, -0.03428052f, -0.13097654f, 0.25949115f, 0.22237098f, -0.08127633f, -0.37516439f, 0.17336959f, 
    -0.02738706f, 0.31625357f, -0.16000786f, -0.21766035f, 0.09594690f, 0.11892463f, -0.01606471f, 0.18731397f, 
    0.03881693f, -0.01039269f, 0.07931351f, 0.01778452f, -0.11224168f, -0.00315525f, -0.54922849f, -0.02279405f, 
    -0.23259118f, 0.18317747f, 0.02303528f, -0.70484173f, -0.00919447f, -0.05986406f, -0.24311747f, 0.02417232f, 
    0.07581981f, -0.09757240f, -0.06335104f, -0.17417143f, -0.04676441f, -0.03152571f, -0.19206305f, 0.05401817f, 
    0.04102221f, -0.03832413f, -0.14226507f, 0.25485858f, 0.08624694f, -0.31220561f, 0.03734741f, -0.00072313f, 
    0.10304812f, 0.16269733f, 0.16680530f, -0.00941563f, -0.01605985f, -0.06760363f, -0.05534374f, 0.01268894f, 
    0.01293440f, -0.05767545f, -0.05438128f, 0.18998682f, -0.03195377f, -0.31332010f, -0.08821857f, 0.03129271f, 
    -0.04706207f, 0.03502750f, 0.04610317f, -0.43727741f, -0.03052449f, -0.04529125f, -0.02233382f, 0.20606194f, 
    0.02760221f, 0.00040857f, 0.20950224f, 0.03056537f, -0.03420410f, 0.01370085f, 0.00945343f, -0.52969050f, 
    0.03664079f, 0.10773732f, -0.30587238f, 0.00426900f, -0.02680328f, -0.24978246f, 0.05706811f, 0.11234324f, 
    -0.26497120f, -0.12095890f, 0.27074069f, 0.24554895f, 0.10365899f, -0.40076184f, 0.03546148f, 0.07855918f, 
    -0.08217584f, -0.16542013f, -0.08165392f, -0.25453392f, 0.43174756f, 0.21532451f, -0.73983961f, -0.07134432f, 
    -0.31649217f, 0.13511607f, -0.04593225f, 0.02455220f, 0.11160124f, -0.13328651f, -0.09171096f, 0.05731045f, 
    0.17697479f, 0.10631440f, -0.18529464f, -0.12569958f, -0.04021079f, 0.11764598f, -0.37201452f, 0.04274634f, 
    -0.26156074f, -0.08392189f, -0.00731854f, -0.36916122f, -0.55401075f, -0.11426578f, -0.44123530f, -0.35270342f, 
    -0.05489150f, -0.12733795f, 0.11012657f, -0.31487039f, -0.31143653f, -0.03962681f, 0.20615761f, -0.21819595f, 
    0.19474442f, 0.16299057f, -0.39780274f, -0.11908978f, -0.23735832f, 0.12468635f, -0.02862322f, -0.01910687f, 
    0.12762356f, 0.19873090f, 0.05288089f, 0.10795385f, 0.01622720f, 0.03880945f, -0.13337421f, -0.09179188f, 
    -0.27107397f, -0.20670883f, -0.04981650f, -0.27696925f, -0.05092227f, -0.09164350f, -0.30894235f, -0.11033534f, 
    -0.03658955f, 0.16000506f, -0.05513953f, 0.00734695f, 0.03524709f, -0.01989101f, 0.39955652f, -0.39358199f, 
    0.10046117f, -0.08388367f, -0.46264121f, -0.11037601f, 0.04332351f, 0.14092200f, -0.05058370f, 0.02385738f, 
    -0.27088657f, 0.39643469f, -0.75773484f, -0.00714313f, 0.00996926f, 0.01760556f, 0.27359238f, -0.05796891f, 
    0.06835131f, 0.02047273f, -0.01807145f, 0.08047326f, 0.01794226f, 0.38885766f, 0.10464992f, -0.05716027f, 
    -0.06801821f, 0.00500920f, -0.53064615f, -0.55530268f, 0.09949194f, 0.37635952f, -0.04902602f, 0.19838914f, 
    0.04593176f, 0.02706912f, 0.10170945f, -0.25342456f, 0.03608248f, -0.02816211f, 0.03389471f, -0.29277840f, 
    0.16437538f, -0.16384108f, -0.25950441f, 0.00365725f, -0.00625502f, -0.43109325f, 0.10153645f, -0.12233496f, 
    0.14102308f, -0.01150528f, 0.15863402f, -0.56246406f, -0.29283947f, 0.05643428f, -0.44422957f, 0.14879258f, 
    -0.04410065f, 0.08543240f, 0.07498650f, 0.31418520f, -0.09566382f, 0.07955343f, 0.25966036f, -0.08197528f, 
    -0.39978507f, 0.09986414f, -0.08301706f, -0.33700651f, 0.05306792f, 0.01104989f, -0.05450203f, 0.05722037f, 
    0.14294486f, -0.16791716f, -0.15796819f, -0.30282468f, 0.00530755f, 0.02235767f, -0.09939789f, -0.03126258f, 
    0.02733956f, -0.12754568f, -0.03812654f, 0.14295647f, -0.08955681f, -0.04221209f, 0.00731763f, -0.37190410f, 
    0.22884843f, -0.08058578f, 0.17376809f, -0.36929125f, -0.10573000f, 0.06271932f, -0.01975395f, 0.10384593f, 
    -0.09762766f, -0.37835574f, -0.32260060f, -0.07765711f, 0.05396991f, 0.11870950f, 0.09623374f, -0.32750762f, 
    -0.15159543f, 0.22500585f, 0.03878552f, 0.03083199f, 0.09403395f, -0.04226126f, 0.04431378f, -0.07700828f, 
    -0.05109977f, -0.04497879f, -0.04155069f, 0.17580494f, -0.11266588f, -0.07437766f, -0.07352474f, -0.57632452f, 
    0.05787455f, 0.22542803f, -0.00825992f, -0.29805472f, -0.01059274f, -0.06087836f, 0.17178337f, -0.02960630f, 
    0.03226750f, 0.17418249f, -0.53129739f, 0.18514068f, -0.11819644f, 0.04243108f, -0.07805641f, 0.00266339f, 
    -0.02143138f, 0.15704402f, 0.16988377f, 0.02136197f, -0.04661877f, -0.04930494f, -0.05804172f, -0.59160066f, 
    -0.02171297f, -0.12212887f, 0.01648339f, 0.01800497f, 0.05519516f, 0.22932065f, 0.07847284f, 0.01382454f, 
    -0.05918096f, 0.08573610f, 0.29210046f, -0.07269041f, 0.11692265f, 0.14597069f, 0.01509600f, -0.04652222f, 
    0.06191465f, 0.04405180f, 0.07716265f, 0.00179516f, -0.05430605f, -0.04210602f, -0.05180558f, 0.10224105f, 
    0.08400342f, -0.08175040f, -0.02029343f, -0.01756360f, -0.05474700f, -0.23496720f, -0.11514530f, 0.00483218f, 
    -0.02466056f, -0.18493164f, -0.12948076f, -0.05756925f, -0.19949915f, 0.06787872f, -0.04056939f, -0.04182330f, 
    -0.04976273f, -0.25035739f, 0.18285654f, 0.05668055f, -0.28234702f, -0.19539438f, 0.16370662f, 0.34992903f, 
    -0.00306583f, 0.08070315f, -0.12759320f, -0.05753684f, 0.01447229f, 0.08828122f, -0.00981801f, -0.10342649f, 
    -0.08672735f, -0.18490553f, 0.49940971f, 0.02889192f, -0.05399559f, -0.50215465f, 0.01974529f, -0.00762749f, 
    0.20797788f, 0.04426298f, -0.02370751f, 0.05624900f, 0.08846608f, 0.04208921f, 0.06418461f, -0.50663888f, 
    -0.28037208f, -0.11300050f, 0.00407561f, -0.32760596f, -0.30176124f, 0.06429579f, 0.07202969f, 0.06375862f, 
    0.03579287f, -0.19640179f, -0.43975684f, 0.14368361f, 0.08656411f, 0.10317665f, -0.08178214f, -0.22764154f, 
    -0.04133539f, -0.17065169f, -0.01960867f, 0.04033253f, -0.02650144f, 0.05326699f, -0.05241970f, 0.03162074f, 
    0.23158397f, -0.89627773f, 0.02943021f, 0.07533732f, -0.02630796f, 0.08349144f, 0.12620285f, -0.05885420f, 
    -0.25343454f, 0.04849979f, -0.01633977f, 0.14869764f, 0.01794581f, 0.00124512f, 0.04745204f, 0.17275938f, 
    -0.02901834f, -0.11772738f, -0.02738678f, -0.36033595f, -0.09682526f, -0.14063820f, 0.02486132f, -0.36316428f, 
    0.20187700f, 0.03901471f, 0.07697641f, 0.05524030f, -0.04108182f, 0.04851351f, 0.12303588f, 0.04527199f, 
    0.04831855f, -0.04929145f, 0.01508727f, -0.45052654f, -0.05123215f, -0.18257320f, 0.16291700f, 0.07033069f, 
    0.02299894f, 0.00613810f, 0.08219360f, 0.29664266f, -0.00131086f, -0.11953456f, 0.06664356f, -0.29406512f, 
    -0.01702017f, -0.05594428f, -0.10872501f, 0.09899801f, -0.06577034f, 0.05138450f, -0.49794346f, 0.10190187f, 
    -0.02014536f, -0.08478028f, 0.21513332f, -0.05467859f, -0.06950227f, -0.01954689f, 0.08067804f, 0.03300643f, 
    0.19657291f, 0.05524588f, -0.22376668f, 0.08666906f, 0.12640795f, -0.03046246f, 0.08635677f, -0.02527347f, 
    0.05632971f, -0.47245106f, 0.11607897f, 0.13897905f, -0.26205316f, 0.04280331f, 0.12514780f, 0.06914183f, 
    -0.73166013f, -0.02306565f, -0.13681479f, -0.26655170f, -0.26624623f, -0.53324926f, -0.02202975f, -0.10292145f, 
    -0.00816902f, 0.15996188f, 0.13406447f, 0.10312832f, -0.03882729f, -0.03088342f, 0.05361220f, -0.02045896f, 
    -0.11415628f, -0.03636359f, 0.04943319f, 0.00893933f, -0.18951149f, 0.13105758f, 0.11958170f, -0.16908385f, 
    -0.03176758f, -0.04731141f, -0.10136658f, -0.30420542f, 0.07867219f, 0.10108583f, 0.06221339f, -0.02889971f, 
    -0.00244750f, 0.10884150f, -0.08489171f, 0.13797374f, 0.10050203f, -0.10605682f, 0.09775600f, -0.55282122f, 
    0.12435985f, -0.15109217f, -0.10147108f, 0.10028129f, 0.18194211f, 0.03589350f, 0.17133993f, -0.13034463f, 
    -0.02942495f, -0.05281531f, -0.02517520f, 0.07314120f, 0.01136379f, 0.05314903f, 0.09862388f, 0.13599260f, 
    0.08148671f, -0.51054519f, 0.01784015f, 0.22116828f, -0.06423196f, -0.02528862f, -0.06590559f, 0.09050861f, 
    0.00593886f, -0.18942767f, 0.25922763f, -0.23844913f, -0.01322227f, -0.49624473f, -0.00759810f, -0.04834624f, 
    -0.33597851f, -0.21703073f, -0.19368380f, -0.04900037f, -0.00530533f, -0.06748106f, 0.12231325f, 0.05323721f, 
    0.02089824f, 0.03653470f, 0.08230700f, -0.43279603f, 0.07021761f, -0.39580673f, 0.16086772f, 0.01983657f, 
    -0.02434000f, -0.04115515f, -0.51227415f, -0.18827516f, 0.08028495f, 0.04072369f, 0.01655517f, 0.00894845f, 
    -0.03179317f, 0.01115030f, -0.14488390f, 0.09346640f, -0.06071129f, 0.05507325f, 0.08187221f, 0.05251257f, 
    -0.21295199f, 0.11167452f, -0.03259009f, 0.04295577f, 0.01797879f, 0.07286815f, 0.05780132f, 0.02546468f, 
    0.01995502f, 0.06341624f, 0.00093830f, 0.02058404f, 0.05109151f, -0.11602429f, -0.04529078f, -0.02398597f, 
    0.00475749f, 0.27771217f, -0.59554666f, 0.05337456f, -0.10574394f, 0.07827295f, -0.28651825f, -0.36382258f, 
    0.02027805f, 0.11654686f, -0.05943314f, 0.19106762f, -0.02566171f, 0.10556503f, -0.05314407f, 0.07144707f, 
    0.03733161f, 0.13923490f, -0.42356104f, -0.11894181f, -0.10344355f, -0.22487295f, 0.18161613f, -0.03311503f, 
    -0.48637745f, 0.08563522f, 0.03865620f, -0.29138237f, -0.32161197f, -0.56640321f, -0.40968496f, 0.09954624f, 
    -0.11771376f, 0.07059281f, 0.22530468f, 0.02696273f, -0.13567699f, -0.16247594f, 0.26224115f, -0.20318049f, 
    -0.17390139f, -0.01429267f, 0.20183794f, 0.14063235f, -0.44330665f, -0.23152032f, -0.48747021f, -0.06475261f, 
    0.12875865f, 0.15817446f, 0.01259773f, 0.10913189f, 0.04627489f, -0.00240589f, -0.18326496f, -0.02165243f, 
    -0.17747900f, 0.13500607f, -0.02546944f, -0.07091900f, 0.01478502f, 0.04148383f, -0.19635718f, 0.12519361f, 
    -0.46744156f, 0.31912369f, 0.06831856f, 0.12849396f, 0.05579288f, -0.07547192f, -0.40968174f, -0.39341429f, 
    -0.29119161f, -0.09666750f, 0.00209948f, -0.31380975f, -0.01844734f, 0.25161341f, -0.00324097f, 0.11333309f, 
    0.01026275f, 0.00358493f, -0.13003403f, -0.03887312f, -0.04737865f, -0.04957680f, -0.68576896f, -0.04606372f, 
    -0.01137189f, 0.05334414f, 0.07600715f, 0.36738729f, -0.00048259f, 0.32025436f, -0.04862783f, -0.02291843f, 
    0.00431489f, 0.07222507f, 0.00521513f, -0.01133843f, -0.84277970f, -0.85166866f, 0.05669231f, -0.19549461f, 
    0.05749681f, -0.00115276f, -0.08450322f, -0.93206954f, -0.06726896f, -0.06483539f, -0.10674135f, -0.24185185f, 
    -0.14104022f, -0.06576790f, -0.42597902f, -0.06855686f, -0.00146303f, -0.13466439f, 0.01377672f, -0.19147983f, 
    -0.25006279f, 0.16634262f, -0.06831058f, -0.22592521f, -0.51194155f, 0.10795258f, -0.35759270f, 0.15685152f, 
    0.01973432f, 0.16658664f, 0.23959649f, 0.13365479f, 0.02703496f, -0.45040640f, 0.06178536f, -0.04127339f, 
    0.14726277f, -0.26366234f, -0.05719274f, -0.06878035f, 0.20981392f, 0.16395137f, -0.00460150f, 0.20926192f, 
    0.00182517f, -0.17210731f, -0.07822030f, -0.05363631f, -0.03864259f, 0.21982658f, -0.07213584f, -0.01566084f, 
    0.00711220f, -0.02158643f, 0.01875713f, 0.13946936f, -0.10654153f, -0.17620146f, -0.04688959f, 0.28023380f, 
    0.42310920f, -0.04490555f, -0.08989915f, 0.28625304f, 0.00164526f, 0.10814266f, -0.12325329f, -0.10532562f, 
    0.00202834f, -0.38210699f, 0.19621803f, -0.09705584f, -0.11927810f, 0.12021638f, -0.07388660f, -0.11786609f, 
    -0.32100186f, -0.15909514f, -0.03738051f, -0.44540280f, -0.42483643f, 0.06777528f, -0.03102875f, -0.00412993f, 
    0.09026424f, 0.01412939f, -0.00682475f, 0.12173305f, 0.02998343f, -0.07909580f, -0.07206639f, 0.03374878f, 
    0.11924162f, -0.19419655f, -0.05141542f, -0.03940127f, -0.00348611f, -0.06452545f, -0.09326007f, 0.02118980f, 
    0.03304143f, -0.13908684f, 0.09453747f, 0.25451040f, -0.15568605f, 0.19690233f, 0.02990875f, -0.12524267f, 
    -0.25258672f, -0.38729855f, 0.02755546f, 0.05450508f, -0.02948497f, 0.04392107f, -0.43000019f, -0.04104328f, 
    -0.01467965f, -0.07483905f, -0.02280879f, -0.17424686f, -0.04676587f, -0.03612088f, -0.65764624f, -0.01022679f, 
    0.06368227f, -0.05031743f, -0.07662907f, 0.20005548f, -0.30431381f, -0.34499320f, -0.06992377f, 0.16745822f, 
    -0.03019323f, -0.12015332f, -0.40201607f, -0.62750536f, 0.02699905f, 0.05646340f, -0.00498944f, 0.12061607f, 
    0.14617641f, -0.02884634f, -0.10205188f, 0.04483334f, 0.03110860f, 0.38119495f, 0.08827506f, 0.14763705f, 
    -0.29686332f, 0.06740353f, -0.49665004f, -0.12809350f, 0.24288696f, -0.14531432f, -0.04357860f, 0.01959214f, 
    0.10769925f, 0.02228304f, 0.04980497f, -0.57769006f, -0.05944962f, -0.17318167f, -0.04775155f, -0.01996517f, 
    0.23215969f, 0.00105728f, -0.01669391f, 0.22652011f, -0.01951995f, -0.11918203f, 0.04242777f, -0.38761741f, 
    -0.64586008f, 0.04100426f, 0.22709779f, 0.13983977f, 0.10997761f, 0.04950760f, 0.09132354f, 0.04410806f, 
    -0.32227311f, 0.09039731f, 0.01867626f, -0.06296132f, -0.33482012f, -0.61656559f, -0.50207961f, 0.11707532f, 
    -0.13446085f, 0.04818940f, 0.09505881f, 0.10134027f, 0.09580833f, 0.05203735f, -0.16610572f, -0.55421084f, 
    0.07958460f, -0.12165610f, 0.20267515f, -0.03429115f, -0.35249168f, -0.36932424f, 0.16356032f, -0.05798212f, 
    0.10330100f, 0.16174310f, 0.06462508f, -0.00199780f, 0.17442964f, -0.05947790f, -0.31528729f, -0.05749797f, 
    -0.20608070f, -0.13911103f, 0.03079659f, -0.19618785f, 0.03176444f, -0.00950932f, 0.17575026f, -0.23263602f, 
    0.31753847f, -0.39239380f, 0.06456199f, -0.20501079f, -0.02640879f, -0.06924657f, -0.26939216f, -0.09823094f, 
    -0.02923824f, -0.04490061f, 0.04898297f, 0.24847932f, 0.18501468f, -0.18266790f, -0.02744701f, 0.18813787f, 
    -0.47511762f, -0.45883334f, -0.59553671f, -0.12324180f, -0.04267504f, 0.01611655f, -0.59442890f, -0.30932486f, 
    -0.04004486f, -0.06216257f, -0.00852222f, -0.45026517f, 0.06450529f, -0.11666187f, -0.43982285f, -0.00091598f, 
    -0.00185129f, -0.00954307f, 0.19583857f, -0.16179368f, 0.27391693f, -0.02069413f, 0.01301039f, 0.21700825f, 
    -0.04451967f, -0.04829650f, 0.06317056f, -0.04507339f, -0.05788320f, -0.04172583f, 0.35659519f, -0.19609214f, 
    -0.44387573f, -0.06534205f, -0.24649636f, -0.08721273f, -0.08947062f, 0.35319179f, -0.10042463f, 0.08811343f, 
    -0.58494866f, -0.02940445f, 0.19171427f, -0.71304458f, 0.05466900f, -0.24870105f, -0.44370180f, -0.18472056f, 
    0.02313805f, 0.15578523f, -0.42448166f, -0.59762633f, -0.17820737f, -0.18543135f, -0.05051735f, -0.08110005f, 
    0.07830885f, 0.11217698f, -0.13677120f, 0.20069014f, 0.10485370f, 0.28406152f, -0.04385598f, -0.04378455f, 
    -0.30277470f, -0.09619806f, 0.02370722f, -0.07028335f, -0.03232642f, 0.09452315f, -0.25702980f, 0.03410121f, 
    0.08149499f, -0.04248007f, -0.03306922f, -0.30988339f, -0.68349034f, 0.19071622f, 0.08703026f, -0.16178522f, 
    -0.48150805f, -0.09612012f, 0.05450556f, -0.20120381f, 0.25389153f, -0.06490896f, 0.24184035f, -0.31711683f, 
    -0.04429987f, -0.05018498f, 0.22292981f, 0.05968564f, 0.01948399f, -0.32069430f, -0.20736119f, 0.15913610f, 
    0.00789185f, -0.11574730f, 0.05098173f, 0.17643636f, 0.07474168f, 0.03388514f, -0.24898386f, -0.02100966f, 
    0.16666257f, 0.03600241f, -0.07223134f, -0.08479013f, -0.04812823f, -0.09244497f, -0.17687567f, 0.12142756f, 
    -0.60373420f, -0.14878993f, -0.06002330f, 0.18832591f, 0.04617932f, 0.06660908f, -0.21073498f, -0.02093786f, 
    -0.10965636f, -0.16285460f, -0.02191919f, -0.52502626f, 0.04101644f, 0.17688130f, 0.05852716f, -0.08866657f, 
    0.21501103f, -0.31948227f, -0.35055745f, -0.07470340f, 0.05356009f, 0.06381166f, 0.13076051f, -0.54386723f, 
    -0.01351818f, -0.10749612f, -0.00872706f, -0.11180079f, -0.01099975f, 0.05267203f, 0.18093443f, -0.00358126f, 
    -0.09128108f, 0.00365634f, 0.33114457f, -0.08711586f, 0.03407929f, -0.04610939f, 0.07349291f, -0.49052972f, 
    -0.04287573f, 0.00603616f, -0.43549901f, -0.01356201f, -0.04463437f, -0.07123087f, -0.53495938f, 0.02778480f, 
    -0.26505196f, -0.06327835f, 0.21901898f, 0.02469251f, 0.00000820f, -0.50943410f, 0.22433458f, -0.55123234f, 
    0.32216856f, 0.03973017f, -0.10805350f, -0.32090181f, -0.26826251f, 0.13916285f, -0.17048375f, 0.11601429f, 
    -0.04275133f, 0.09077287f, -0.01584435f, 0.16183946f, -0.09365739f, -0.34913459f, 0.03122266f, -0.16931145f, 
    0.04757909f, -0.22269671f, -0.04332338f, -0.22585891f, 0.11160720f, -0.07801806f, 0.01758730f, 0.05212770f, 
    -0.16211505f, 0.02081657f, -0.29447845f, 0.05462892f, -0.15414053f, 0.00588745f, 0.25526103f, 0.02496639f, 
    0.39693204f, 0.00512159f, 0.05777756f, -0.31723115f, -0.09171749f, 0.14260595f, 0.13789459f, 0.03718497f, 
    0.22703597f, -0.01986677f, -0.08229642f, -0.15381786f, 0.23207103f, -0.32943296f, -0.33072302f, -0.10898592f, 
    -0.38540876f, -0.08308187f, -0.12622038f, -0.10072324f, -0.20818411f, -0.25281408f, 0.18408497f, -0.15149686f, 
    0.24920231f, 0.18078305f, 0.05295334f, -0.08764221f, 0.01349263f, -0.02443228f, -0.19139495f, 0.02232887f, 
    0.18438251f, -0.09609412f, -0.05339444f, 0.01409853f, -0.07265804f, -0.04182460f, 0.12169122f, 0.00123365f, 
    0.02427581f, -0.17860430f, -0.03823772f, -0.25405085f, 0.09543741f, -0.04291438f, 0.23796490f, -0.37542465f, 
    -0.44937462f, 0.00361695f, 0.17801140f, -0.21623763f, 0.06278800f, -0.31729987f, -0.02161189f, 0.09574533f, 
    0.11597344f, 0.12250049f, 0.17402579f, -0.11882257f, 0.05503156f, 0.00345832f, -0.27802613f, -0.20657006f, 
    -0.07740061f, -0.08922201f, -0.06250970f, 0.02267873f, 0.04137551f, -0.31060445f, 0.04735464f, -0.02566447f, 
    0.03128557f, 0.04231798f, -0.19979072f, -0.01959342f, 0.14636798f, -0.04161653f, 0.02938651f, -0.24981526f, 
    -0.02569361f, 0.04023363f, 0.14629717f, 0.10045312f, -0.07697009f, 0.05720291f, 0.10292047f, 0.01561516f, 
    -0.40089041f, 0.21478289f, -0.23291767f, 0.07549790f, -0.05007388f, 0.14436035f, -0.78993720f, 0.01767690f, 
    -0.60481179f, -0.46671027f, -0.06658900f, -0.04524409f, -0.10211258f, -0.61142504f, 0.46047682f, -0.57628423f, 
    -0.08617258f, -0.22593449f, 0.01568374f, -0.00007490f, 0.15394296f, 0.04277323f, -0.44473502f, 0.20757766f, 
    0.07664761f, 0.12111221f, 0.03750489f, -0.01803879f, -0.04074912f, -0.20455398f, 0.07423496f, 0.09062669f, 
    0.18173264f, -0.47634077f, 0.00006703f, 0.02994501f, 0.01667508f, -0.04662296f, -0.25799441f, 0.04444545f, 
    -0.08731581f, -0.02660317f, 0.01069679f, -0.37620699f, -0.39651245f, -0.46710449f, -0.73859394f, -0.06303865f, 
    -0.01700625f, 0.02692708f, 0.00357332f, 0.02807214f, -0.52175874f, -0.30138439f, 0.02486311f, -0.13073623f, 
    -0.39368615f, -0.07536042f, -0.39268771f, 0.07121216f, -0.40714440f, -0.19910589f, 0.05498378f, -0.15319423f, 
    -0.00562037f, -0.11752170f, -0.00150786f, -0.44490328f, -0.08737285f, 0.05814399f, -0.00068854f, -0.03850462f, 
    -0.12739395f, 0.16467001f, -0.01146046f, -0.78521156f, -0.04282675f, -0.00531988f, 0.27673566f, -0.12899068f, 
    -0.39372095f, 0.28401598f, 0.04740812f, 0.01162136f, -0.10395717f, -0.05164688f, -0.21429136f, 0.25880757f, 
    -0.37582684f, -0.05218917f, 0.18165964f, -0.11303380f, -0.00394955f, -0.34513718f, -0.05968860f, 0.11618000f, 
    0.21582998f, -0.06066472f, -0.06185640f, 0.02015929f, 0.06663371f, 0.01801217f, 0.18314686f, -0.04068114f, 
    0.02713737f, 0.05386415f, -0.05821231f, 0.16988021f, 0.07800240f, -0.33981726f, -0.11950153f, -0.03969685f, 
    -0.06782334f, -0.03236577f, -0.03952922f, 0.34243777f, -0.34851441f, -0.25406513f, -0.06084460f, 0.06244362f, 
    -0.09840236f, -0.08657832f, 0.24857166f, 0.03073971f, -0.01573743f, 0.02310569f, -0.23197405f, -0.61285985f, 
    -0.30542210f, 0.09425179f, -0.02896372f, 0.01582045f, -0.01969558f, 0.17166096f, -0.23164447f, -0.07745805f, 
    0.13669392f, -0.08856180f, 0.07297575f, -0.51678425f, 0.18565492f, 0.08530248f, 0.00615273f, -0.51427376f, 
    -0.02925772f, 0.11863318f, 0.21110284f, 0.19075829f, -0.09858721f, 0.15831320f, -0.11014087f, 0.20384586f, 
    -0.01689173f, -0.32899314f, 0.07247735f, 0.11357019f, 0.02935706f, 0.13133118f, -0.03558912f, 0.03920995f, 
    0.31182581f, 0.10501641f, 0.27928454f, -0.13612303f, -0.05674644f, 0.02436548f, -0.23446468f, 0.02081165f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.33832687f, 0.24531251f, 0.14897816f, 0.02356769f, -0.06426783f, -0.14632344f, -0.00209549f, -0.07724171f, 
    0.18338437f, 0.02431376f, 0.05848534f, -0.05931487f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
