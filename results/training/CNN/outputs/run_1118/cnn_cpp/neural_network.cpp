#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.76497108f, -0.49546304f, 0.16342637f, -0.88986301f, -0.55741757f, 1.14329886f, 0.01835731f, -0.09947073f, 
    0.21630032f, -1.29201353f, -0.63464034f, -0.48141328f, 0.80843782f, -0.44080782f, -0.07531115f, -0.44548830f, 
    -0.58687282f, -0.51388854f, -1.19016159f, 0.52582771f, -0.41877520f, 0.03027365f, 0.36973032f, 0.42716673f, 
    0.19236034f, -0.35900140f, 0.52880770f, 0.94991904f, 0.27515405f, 0.84410381f, -0.59354424f, -0.45943338f, 
    -0.28117165f, 0.41820639f, 0.04610261f, 0.23618427f, 0.57803184f, 0.46470177f, -0.01446032f, 0.83972621f, 
    -0.92978126f, -0.66634858f, -0.19859248f, 0.30972308f, 0.47395703f, -0.71262079f, 0.71583992f, -0.62194127f, 
    -0.46217921f, -0.73841757f, 0.47664493f, -0.47023585f, 0.90040541f, -0.46033472f, -0.26338646f, -0.40697530f, 
    0.38460603f, -0.45815071f, 0.26046687f, 0.16988307f, -1.00083709f, -0.94201821f, 0.32756308f, -1.02994645f, 
    0.26717940f, 0.72701579f, 0.16280434f, 0.60438961f, 0.17518108f, 0.16788548f, -0.38566956f, -0.05246405f, 
    -0.05383315f, 0.20349309f, 0.71917361f, 0.25456116f, 0.69508433f, -1.10925543f, 0.32387799f, -0.74662638f, 
    -0.16462854f, 1.09767890f, 0.06511637f, 0.20536177f, 0.33277714f, 0.14385855f, 0.01052609f, -0.13297150f, 
    0.60826772f, 0.28192765f, 0.99105281f, -0.93702775f, -1.00350809f, -0.19381960f, 0.36609501f, 0.57467586f, 
    -0.54500771f, -0.19431424f, -0.56146991f, 0.01181608f, 0.36865917f, -0.02551256f, 0.26749408f, 0.41808614f, 
    -0.52015340f, 0.49770480f, 0.65777695f, 0.60154337f, -0.95423025f, 0.37130287f, 0.57641321f, 0.61532605f, 
    -0.39085343f, -0.39521283f, 0.52740061f, 0.42814109f, 0.13929185f, 0.42845038f, -1.38470960f, 1.43707848f, 
    -0.46375543f, -0.25589168f, -0.31231618f, 0.08273333f, -0.21381932f, 0.16549735f, -0.96626878f, -0.85654712f, 
    -0.72497475f, 0.41932091f, 0.12304974f, 1.05328059f, -0.27275476f, -0.11872038f, -0.35810781f, -0.11045333f, 
    0.11960345f, 0.34062216f, 0.76617855f, 0.92274058f, 0.83953524f, -0.32117379f, 0.12624447f, 0.06996541f, 
    0.09853795f, 0.58440822f, -0.15339451f, 0.64523256f, 0.60082793f, 0.06725585f, -0.30289930f, 0.70280021f, 
    -0.61059886f, -0.64172876f, -0.52727205f, -0.33817098f, -0.72960240f, -0.85166186f, -1.13332582f, -0.30307952f, 
    0.29526660f, -0.25833440f, -1.05870640f, -0.33472672f, 0.10476881f, -0.79926872f, -0.50021791f, -0.37761855f, 
    0.21931210f, -0.63117933f, -0.74469399f, -1.46754360f, -0.81590033f, -0.71277773f, 0.29344952f, 0.66534001f, 
    0.05123272f, 0.43273297f, 0.91721791f, 0.00067357f, -0.62320262f, 0.05562932f, 0.90991068f, -0.65633875f, 
    0.23174287f, 0.20994736f, -0.42492828f, 0.67482203f, -0.15887825f, -0.68002993f, 0.83583862f, -0.37158921f, 
    0.13106810f, 0.28223109f, -0.62230259f, -0.36048993f, 0.25808945f, 0.53908551f, -0.39785495f, -0.50650501f, 
    -0.57012951f, -0.56937951f, -0.83510023f, -0.21484785f, 0.52927160f, 0.63582021f, 0.72459710f, 0.17816833f, 
    0.22546995f, -0.28904524f, -0.68910265f, 0.64924204f, -0.36895663f, 0.43752927f, 0.07656913f, 0.67711508f, 
    0.82245374f, -0.76000929f, 0.41238344f, -0.27862072f, -0.50110203f, 0.37046731f, 0.27822345f, 0.60771221f, 
    0.12881438f, -0.16484995f, -0.74745017f, -0.90764886f, 0.41310510f, 0.89198697f, 0.65909380f, -0.03138863f, 
    -0.14756587f, -0.38060829f, 1.01851773f, -0.79217046f, -0.87222922f, -0.69220644f, -0.53981048f, -0.35357860f, 
    -0.32511964f, 0.05778948f, 0.31732959f, -0.11193891f, -0.04648320f, 0.16083540f, -0.95500201f, -1.00236678f, 
    -0.69775629f, 0.64088088f, -0.16937217f, -0.14164184f, 0.70262474f, 0.21475895f, 0.73225456f, 0.04511251f, 
    -0.56599659f, 0.58985198f, -0.61002266f, -0.53291714f, 0.81609529f, 0.56784785f, -0.15861773f, 1.01033509f, 
    0.56058043f, -0.53515708f, -0.10846777f, -0.52595127f, -0.15310191f, -0.41306126f, -0.23959170f, -0.00569760f, 
    0.05638382f, 0.36608461f, 0.53920150f, 0.14875729f, 0.29885009f, -0.73893327f, -0.58281958f, 1.26347005f, 
    -0.71925861f, -0.83389401f, 0.86326963f, -0.21626545f, -0.31168437f, 0.07499343f, 0.73420674f, -0.82676762f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.36087903f, -0.27457330f, 0.59333235f, 0.37773871f, 0.22451615f, -0.15292148f, -0.16408731f, 0.51846874f, 
    0.14148760f, 0.43066046f, 0.12193174f, 0.06793819f, 0.14732052f, 0.15010005f, -0.37520081f, 0.15623143f, 
    -0.02320493f, -0.34497291f, -0.20223552f, 0.42937928f, 0.16777347f, 0.41810259f, 0.20645657f, 0.30947652f, 
    -0.19090815f, -0.01607415f, 0.68127632f, 0.60717082f, 0.16475531f, -0.01446787f, 0.38742352f, 0.35134000f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.08340225f, 0.26206121f, -0.05190561f, -0.04546504f, -0.11685300f, -0.10843759f, 0.14539251f, 0.06586393f, 
    0.09182931f, 0.20552237f, 0.06331337f, 0.19778942f, -0.11507104f, 0.08338712f, -0.20020130f, -0.04651866f, 
    -0.06660531f, -0.17790043f, 0.01756665f, -0.01565617f, -0.20011598f, -0.02062871f, -0.07549363f, -0.13001965f, 
    -0.03850275f, -0.03683162f, 0.10943070f, -0.23988520f, -0.17345889f, 0.12932236f, 0.01139178f, -0.13879934f, 
    0.09128213f, 0.02185776f, 0.03644269f, 0.16291328f, -0.56346381f, -0.27834803f, -0.10426304f, 0.08357099f, 
    -0.21722564f, 0.12546608f, -0.06327718f, 0.13267538f, 0.13925052f, 0.19221249f, -0.09648175f, 0.04752218f, 
    -0.21182062f, 0.15132482f, 0.17505953f, -0.05878329f, 0.00155122f, -0.14227495f, -0.24524657f, 0.13136442f, 
    -0.12125278f, 0.04071647f, 0.07718235f, 0.14263000f, 0.13374278f, -0.05147010f, 0.02529570f, -0.31918302f, 
    -0.35652676f, -0.19394237f, -0.10455450f, 0.01385739f, -0.09569679f, -0.13049208f, 0.13994727f, 0.12479237f, 
    -0.23839295f, -0.47513965f, 0.15984629f, -0.24919857f, 0.01777614f, 0.04420184f, 0.16509531f, 0.04836349f, 
    -0.19018501f, -0.36858290f, -0.38094380f, -0.16129880f, 0.00301612f, -0.07003836f, 0.04326745f, 0.23702383f, 
    0.12153966f, 0.10883777f, -0.06115545f, -0.18268861f, -0.12473927f, -0.04507867f, -0.05778307f, 0.02857030f, 
    -0.14123154f, 0.09573059f, 0.11187772f, 0.00990619f, -0.08182278f, 0.12292290f, 0.05377749f, -0.05115276f, 
    -0.04920208f, 0.09962837f, 0.12403069f, 0.26434177f, 0.05678737f, -0.15187223f, 0.02392967f, -0.19802588f, 
    -0.06087607f, -0.04876649f, 0.06095023f, 0.11896975f, 0.24088067f, -0.23506798f, 0.00845491f, -0.11487678f, 
    0.31877446f, 0.31986159f, -0.06701808f, -0.05119643f, 0.10008087f, -0.13053223f, 0.01887732f, 0.22768645f, 
    0.27535573f, 0.03083230f, 0.01941130f, -0.03417562f, 0.06861594f, -0.08363409f, 0.01753186f, 0.10091693f, 
    -0.05384580f, 0.13712451f, -0.06913809f, 0.02489204f, 0.01001601f, 0.06014190f, 0.02530325f, 0.08838867f, 
    0.01255256f, -0.17023608f, -0.03472359f, -0.00248169f, 0.10448050f, 0.00233027f, 0.01142055f, -0.14390680f, 
    -0.07939224f, 0.13802527f, 0.40004009f, 0.37915328f, -0.03889799f, 0.00822014f, -0.14450395f, 0.02246055f, 
    0.05201800f, -0.12351757f, 0.04404065f, 0.09875827f, 0.16631366f, 0.10800248f, -0.04136278f, -0.05559070f, 
    0.11296096f, 0.09756543f, 0.04092984f, 0.24042787f, -0.12974133f, 0.21655253f, 0.10658438f, 0.16217440f, 
    0.19367862f, 0.03112973f, 0.08443724f, 0.16252643f, -0.33364257f, -0.18172085f, -0.05009497f, -0.03228094f, 
    0.04717820f, -0.21901515f, 0.04526878f, 0.20588310f, 0.16484523f, -0.20350435f, -0.11172237f, 0.13406204f, 
    -0.11691289f, 0.08799385f, -0.00228318f, 0.04701730f, 0.05946821f, -0.09674184f, 0.27487922f, 0.23633081f, 
    0.56861192f, 0.11072664f, 0.03653994f, 0.02546173f, 0.20823428f, 0.20922203f, 0.07846148f, -0.06803323f, 
    -0.03205959f, 0.11083909f, 0.13693467f, 0.02996809f, 0.20344256f, 0.04483341f, 0.20730998f, 0.21323811f, 
    -0.08596636f, -0.10929468f, -0.09829202f, -0.01676231f, -0.23850955f, -0.12801772f, 0.23613131f, 0.10552081f, 
    0.00915672f, -0.08650399f, 0.22094977f, 0.22469696f, -0.13051927f, -0.27670324f, 0.03968166f, 0.01162039f, 
    -0.11843928f, -0.02969416f, -0.06894754f, 0.17541815f, 0.06619200f, -0.02731695f, 0.06142991f, -0.02364979f, 
    0.03378857f, 0.10455082f, -0.00993255f, 0.33264488f, 0.37064302f, 0.42456830f, 0.02677579f, 0.04022134f, 
    0.14333284f, 0.01122627f, 0.06003250f, 0.05981433f, -0.72456861f, -0.47769418f, -0.49936667f, 0.03276606f, 
    -0.08036631f, 0.00775180f, 0.14745912f, 0.00035527f, 0.05537350f, -0.92929709f, -0.52698690f, -0.14336532f, 
    -0.02772931f, 0.07108045f, 0.13174260f, 0.13802725f, 0.03957194f, -0.11032045f, 0.03497336f, -0.01808564f, 
    0.13353875f, -0.19805105f, -0.03368254f, -0.10029490f, 0.16776857f, 0.13631356f, -0.03535497f, -0.27118301f, 
    -0.63660991f, 0.20637272f, -0.23650765f, 0.06528635f, -0.05469108f, 0.17929158f, -0.04963465f, 0.10129291f, 
    0.24564572f, 0.15407220f, 0.22954459f, -0.17929792f, 0.21039265f, -0.29817337f, -0.13173598f, -0.13592148f, 
    0.03925990f, 0.15959480f, 0.20681249f, -0.29870799f, -0.10201640f, 0.11118347f, 0.06110853f, 0.12467501f, 
    -0.04619572f, 0.16049966f, 0.14771879f, -0.21570359f, 0.19890274f, -0.05425996f, -0.04801017f, 0.29872683f, 
    -0.17094944f, 0.04386256f, -0.15964445f, -0.07031848f, 0.46987730f, 0.54510546f, -0.19765905f, 0.22171852f, 
    -0.14954703f, 0.00996635f, 0.06651387f, -0.09748127f, 0.06017657f, 0.32869703f, 0.00995905f, 0.04620075f, 
    -0.09326305f, 0.12584858f, -0.01106579f, 0.13521144f, 0.04821083f, 0.42268789f, -0.11408859f, 0.38169438f, 
    0.01716552f, 0.25492585f, 0.08136685f, 0.03300625f, 0.32266724f, 0.23215593f, -0.06242128f, 0.09285169f, 
    0.25118881f, -0.11939609f, -0.16922653f, 0.06446666f, 0.00148817f, -0.05004922f, -0.09158773f, 0.25007752f, 
    0.09587556f, 0.08051226f, -0.12740387f, -0.04605482f, 0.14557528f, -0.08318049f, 0.10174312f, -0.37358183f, 
    0.03542051f, 0.30977863f, 0.23099913f, -0.09160747f, 0.04512895f, -0.20793545f, 0.02921297f, 0.07014247f, 
    -0.04715694f, -0.11075447f, 0.17554538f, 0.32245612f, -0.13505161f, -0.28336257f, -0.14208512f, -0.15921040f, 
    0.18858092f, -0.06966799f, -0.17061000f, -0.09231474f, -0.04080269f, 0.11260120f, 0.11399867f, -0.11485200f, 
    -0.15617058f, 0.20105182f, 0.09348518f, -0.26612988f, -0.10202509f, 0.01310295f, -0.05602568f, 0.01799600f, 
    0.11963279f, -0.09752627f, 0.24497853f, -0.20678386f, -0.17970391f, 0.21874709f, -0.21500871f, 0.08864401f, 
    -0.06336532f, -0.07788892f, -0.05425250f, 0.16937909f, -0.27306262f, -0.02291753f, 0.20356621f, 0.10563184f, 
    0.00033899f, -0.04370497f, 0.07589166f, 0.23550889f, -0.11549782f, -0.19059281f, 0.14117099f, -0.47693145f, 
    0.17407311f, -0.04263348f, 0.32492852f, -0.12443198f, -0.03035447f, 0.08573034f, 0.12236616f, -0.05902767f, 
    -0.26652515f, 0.06792422f, -0.23074423f, -0.09418868f, 0.02943015f, 0.02459439f, -0.01221644f, -0.15023179f, 
    0.02300841f, -0.10079446f, 0.04231565f, -0.14643151f, -0.03868620f, 0.19438671f, 0.12043670f, 0.19890516f, 
    0.11745700f, 0.30743200f, 0.28028768f, -0.29204881f, 0.03200408f, 0.11911637f, -0.10635833f, -0.03583415f, 
    0.09990284f, -0.13766517f, 0.32037815f, 0.30314901f, -0.18119843f, 0.13413630f, 0.17297097f, -0.01254714f, 
    0.03261238f, -0.06829150f, 0.10026243f, 0.24492206f, -0.05000318f, -0.13205476f, -0.10989526f, 0.13607886f, 
    -0.01807775f, -0.04303354f, -0.01340296f, 0.02537883f, -0.08218353f, 0.08311238f, 0.19915456f, -0.16273040f, 
    -0.04596173f, 0.01460901f, -0.19998083f, 0.02572097f, -0.12496051f, 0.09335650f, -0.03945644f, -0.11467644f, 
    -0.14445455f, -0.04741368f, 0.16829327f, -0.11989237f, 0.10121361f, -0.08939624f, 0.22014904f, 0.08520422f, 
    -0.19341181f, -0.05700048f, -0.00267462f, -0.24796359f, 0.05169129f, -0.01001554f, -0.09020067f, -0.24806662f, 
    0.03512123f, 0.32413453f, -0.05772502f, -0.03635880f, -0.31564578f, -0.01496338f, 0.12149613f, -0.07241487f, 
    -0.58727282f, -0.22737011f, 0.55426794f, -0.06439590f, 0.06132932f, -0.04790796f, -0.18690592f, 0.22603434f, 
    -0.06335165f, 0.17033158f, -0.64484441f, -0.01108300f, 0.02129181f, 0.12190310f, -0.12627807f, -0.15890579f, 
    0.15310493f, 0.00944454f, 0.02679037f, 0.06502848f, 0.02299744f, -0.23842058f, -0.13395306f, 0.00473229f, 
    -0.02961333f, 0.00535927f, -0.12113149f, 0.19325596f, 0.11652276f, -0.17456000f, -0.05179631f, 0.07830252f, 
    -0.28852063f, -0.05433019f, 0.00425629f, 0.01740445f, -0.07517491f, 0.07060530f, 0.40905070f, -0.15467307f, 
    -0.43012995f, -0.04140428f, 0.22527306f, 0.08344400f, -0.02787542f, -0.08350800f, 0.17501174f, -0.06161319f, 
    0.22579347f, -0.23441672f, 0.07888325f, -0.06951724f, 0.00829942f, -0.16324948f, -0.06956261f, -0.44181743f, 
    0.21948275f, -0.07629025f, -0.05082449f, 0.00639628f, -0.12293471f, -0.13450243f, -0.02252911f, -0.13989133f, 
    0.05095199f, 0.17473145f, -0.05335753f, 0.10161878f, 0.00565759f, -0.03351106f, 0.30408651f, -0.01410628f, 
    0.18827859f, -0.05584380f, 0.03621172f, -0.01802513f, 0.08789881f, -0.01841705f, 0.15322150f, 0.11305790f, 
    0.05458023f, -0.23681045f, -0.29259145f, 0.08437249f, -0.07742611f, -0.10688958f, -0.06241156f, -0.21277548f, 
    -0.18682995f, -0.15788767f, -0.23236644f, 0.06740138f, 0.31061769f, 0.01594379f, 0.23903289f, 0.10101895f, 
    0.10201270f, 0.09401679f, 0.04858987f, 0.44419897f, -0.06466734f, 0.13242337f, -0.00788784f, 0.11587222f, 
    0.08971731f, -0.07022194f, 0.24076727f, 0.04218287f, 0.15267408f, -0.11684371f, 0.10392745f, -0.07732608f, 
    0.17459707f, -0.07369620f, 0.27912128f, 0.26000667f, 0.07842772f, 0.11681860f, -0.21453565f, 0.04440618f, 
    0.07093332f, -0.03787696f, -0.25791058f, 0.07784025f, 0.00363871f, 0.11565011f, 0.13162374f, -0.06777493f, 
    0.07302546f, -0.01226309f, -0.04175141f, -0.02678002f, 0.02574232f, 0.01850254f, 0.00025334f, -0.00392611f, 
    0.04511529f, 0.07211423f, 0.13611326f, 0.00274292f, 0.05188931f, -0.13183610f, 0.16064595f, 0.00615985f, 
    -0.11810837f, -0.20203379f, -0.21046366f, -0.01841850f, -0.11431368f, -0.15738417f, -0.09441912f, -0.01327161f, 
    0.12141720f, 0.25295368f, 0.02084823f, 0.05643760f, 0.02041135f, 0.10364239f, 0.06940814f, -0.11024240f, 
    0.09821215f, 0.04268035f, -0.22301514f, 0.29020971f, 0.12595278f, 0.09047717f, 0.11029209f, -0.42571163f, 
    -0.11572522f, -0.32093367f, -0.05285755f, -0.08272907f, -0.02919455f, -0.06752884f, -0.09426268f, 0.08758330f, 
    -0.02993633f, 0.13402854f, 0.32390872f, 0.06705462f, -0.09323572f, -0.12952982f, 0.14590220f, -0.03939252f, 
    0.01472451f, 0.02575610f, 0.15253322f, 0.16359329f, 0.01180688f, -0.07018911f, 0.28440520f, 0.36237994f, 
    0.05692091f, -0.03523599f, 0.14433883f, 0.04108297f, 0.05694178f, 0.15039743f, -0.43353203f, -0.19015317f, 
    0.12731163f, -0.01192738f, 0.07903903f, -0.29172334f, -0.20942765f, -0.02051681f, -0.18422744f, -0.25385904f, 
    -0.14039537f, -0.19455774f, 0.14421435f, -0.00875866f, -0.03205401f, 0.01032310f, 0.06195969f, -0.03965657f, 
    -0.19153304f, -0.14274479f, 0.02665748f, 0.10516582f, 0.00422472f, -0.07946065f, -0.04416531f, 0.15356329f, 
    -0.11019175f, -0.00938086f, -0.13176824f, -0.50936991f, 0.07662203f, -0.07991511f, -0.05866861f, 0.08617626f, 
    -0.00135864f, -0.02196469f, -0.31850836f, -0.20712712f, 0.03906897f, -0.09607837f, -0.19895795f, 0.04490555f, 
    0.00539479f, -0.17536035f, -0.09244341f, -0.27704436f, 0.15455534f, 0.45911115f, -0.00678214f, 0.15525661f, 
    -0.00519338f, 0.10515856f, 0.03188331f, -0.08405880f, 0.34325889f, 0.09810150f, 0.36578625f, -0.00272672f, 
    0.24435553f, 0.21734893f, 0.04333194f, 0.12872837f, -0.07150496f, -0.13971981f, 0.06152870f, 0.34688535f, 
    0.11610983f, -0.08851875f, 0.17760415f, 0.36100382f, 0.19897123f, -0.01009767f, -0.17747019f, 0.03070113f, 
    -0.24618860f, -0.21229337f, -0.04278461f, -0.12023629f, 0.19426641f, 0.15557158f, 0.08008905f, -0.04084639f, 
    -0.00924987f, -0.01694080f, -0.01745008f, 0.03582177f, 0.01879558f, 0.21845061f, 0.43234575f, 0.03734754f, 
    0.24406910f, 0.01064920f, -0.11964777f, -0.16020532f, -0.00326310f, 0.03873169f, 0.10061162f, 0.03100362f, 
    0.11553846f, -0.47110739f, -0.04631567f, 0.04646981f, 0.09107208f, 0.20350446f, -0.26400819f, -0.18524577f, 
    -0.07916567f, -0.21207328f, 0.08134861f, -0.02791502f, -0.32528228f, 0.29497579f, 0.00642395f, -0.10862929f, 
    0.08525329f, 0.06161410f, 0.16728559f, -0.30259290f, -0.42257437f, -0.42524704f, 0.21939892f, 0.11360230f, 
    0.06709449f, 0.17834431f, 0.16388658f, 0.21778430f, 0.26641831f, 0.04419060f, 0.39581490f, -0.03615871f, 
    0.11447852f, -0.07536457f, -0.00069701f, -0.06384271f, -0.13720429f, 0.01875470f, -0.08799049f, -0.05264156f, 
    0.02316950f, -0.14550994f, 0.02842507f, 0.02114894f, -0.11222787f, -0.01865823f, -0.09129295f, 0.05093351f, 
    0.02947519f, 0.02102822f, -0.02024836f, -0.04047158f, -0.11040936f, 0.30426916f, 0.04768433f, 0.19920498f, 
    0.24259150f, -0.02665326f, 0.12280136f, 0.15462305f, -0.05955048f, 0.11187450f, -0.18367104f, 0.16967525f, 
    -0.05873448f, 0.04810165f, -0.02319105f, 0.04561517f, -0.03678278f, -0.01176299f, 0.03450878f, -0.01138017f, 
    -0.02030214f, -0.00880866f, -0.04830232f, -0.03674373f, -0.04428854f, -0.03696175f, 0.00562777f, -0.03433517f, 
    0.03496584f, -0.05694382f, -0.02245593f, 0.04283904f, -0.04856930f, -0.01354392f, -0.03417820f, 0.03596934f, 
    -0.04507826f, -0.05556292f, -0.05068900f, 0.00676642f, -0.04141284f, 0.03725142f, -0.00470448f, -0.06512509f, 
    0.00306519f, 0.01539392f, -0.03813551f, 0.01421449f, -0.01287878f, -0.04892971f, -0.02407156f, 0.00180249f, 
    0.03007163f, -0.04648738f, 0.04233840f, 0.01508725f, -0.05072087f, -0.04244545f, 0.01524313f, -0.05138101f, 
    -0.04833837f, 0.00952076f, -0.02239775f, 0.03595854f, 0.02139705f, -0.02222606f, 0.05450194f, 0.00231311f, 
    0.03585908f, 0.02413986f, -0.02877637f, -0.01464179f, -0.04967645f, 0.00084181f, 0.02564006f, -0.00669070f, 
    0.00150493f, 0.01514999f, -0.02401177f, -0.02498783f, -0.01272359f, 0.02184324f, 0.03725163f, 0.02212302f, 
    -0.00915904f, -0.02038772f, 0.03021968f, -0.01246466f, 0.04675246f, -0.05398123f, 0.03095146f, 0.00979472f, 
    -0.03397325f, 0.02986105f, -0.02008748f, -0.04967460f, -0.02316847f, 0.05215103f, -0.05750562f, -0.00369078f, 
    -0.04486963f, -0.05118233f, 0.04311169f, -0.03950743f, -0.04656119f, 0.05021618f, -0.03258125f, -0.03766235f, 
    0.04958560f, 0.02443294f, 0.02094279f, 0.01987454f, -0.00143060f, -0.03516706f, -0.02092039f, 0.04948842f, 
    -0.01448100f, 0.02583942f, -0.00558999f, -0.03548482f, -0.00467641f, 0.05178559f, -0.06100269f, -0.04736070f, 
    0.02201546f, -0.02471545f, -0.05722141f, -0.02226312f, -0.06123932f, -0.05558377f, 0.02805287f, -0.05816075f, 
    -0.05535127f, -0.04413776f, -0.03022193f, 0.01037137f, -0.02610702f, -0.01970269f, -0.05054535f, -0.04483249f, 
    0.03663627f, 0.01012997f, 0.05292146f, 0.04291341f, -0.05997530f, 0.02863233f, 0.04796071f, -0.04507194f, 
    -0.03122112f, 0.04914205f, -0.05265778f, 0.02952684f, -0.00350133f, -0.03916350f, 0.02451987f, -0.04995111f, 
    -0.06418335f, -0.02315910f, -0.01062628f, 0.01451317f, -0.03361855f, 0.05728062f, -0.05206102f, -0.04093112f, 
    0.03956646f, -0.05274954f, 0.00733753f, -0.02946560f, -0.01941635f, -0.02547774f, 0.02467027f, 0.04321022f, 
    -0.01202059f, 0.01893286f, -0.04903726f, -0.00030131f, 0.02132862f, 0.03902493f, -0.03149393f, -0.04736246f, 
    0.00300180f, -0.02670903f, 0.03060461f, -0.05064332f, -0.04522499f, -0.03767880f, 0.04904664f, -0.05964965f, 
    -0.05038317f, 0.00280106f, -0.02454623f, -0.00839563f, -0.04708236f, 0.02917096f, -0.03304462f, -0.04740195f, 
    0.03023288f, -0.01211645f, 0.01544247f, -0.03103997f, 0.03761999f, 0.05108679f, 0.04376070f, 0.01222418f, 
    -0.05624127f, -0.01595356f, -0.01574351f, -0.06447117f, -0.03723782f, -0.01692275f, 0.00065301f, -0.05839235f, 
    0.03379859f, 0.05119393f, 0.00149094f, 0.04409935f, -0.04500426f, 0.03034113f, 0.01600392f, -0.04723979f, 
    -0.05656015f, -0.03259251f, -0.05660429f, -0.00954401f, 0.05337175f, 0.02837129f, 0.03252416f, -0.05658938f, 
    0.00884761f, -0.01491238f, -0.04268670f, -0.05996534f, 0.00523834f, -0.03752814f, 0.05058662f, 0.00430189f, 
    -0.00141820f, -0.04044542f, -0.03308721f, -0.01561401f, -0.00420254f, -0.06402284f, -0.02932891f, -0.05327917f, 
    -0.02724331f, 0.01430223f, -0.04139412f, 0.00062894f, -0.01511730f, -0.04464440f, 0.03952181f, -0.04325477f, 
    0.02636709f, -0.02351887f, 0.03740900f, 0.00590972f, -0.06251656f, 0.03406597f, 0.04754093f, -0.00739036f, 
    -0.00337521f, -0.05181942f, -0.01979179f, 0.02158445f, -0.03243994f, 0.02363078f, 0.04279462f, 0.00288975f, 
    0.05278515f, 0.00504701f, 0.00583222f, 0.03925977f, -0.04281688f, -0.04883716f, -0.05439156f, -0.02371309f, 
    -0.00394744f, -0.01451184f, -0.02624963f, 0.03539632f, 0.02850586f, 0.01999959f, 0.01116895f, -0.03971192f, 
    0.04626445f, 0.05320863f, -0.06464997f, 0.03382410f, 0.01716810f, 0.01411576f, -0.04533327f, -0.02936710f, 
    -0.04146648f, -0.05979576f, 0.00448688f, 0.01234422f, 0.04275765f, -0.04711169f, 0.03181834f, 0.04263265f, 
    -0.54285437f, -0.28384900f, -0.35522550f, -0.21842927f, 0.04805607f, -0.20631620f, 0.07037477f, 0.05904044f, 
    -0.10195728f, 0.08540934f, 0.13736221f, 0.56267166f, -0.09408803f, -0.11440118f, -0.27647859f, -0.02805637f, 
    -0.11796116f, -0.02996249f, -0.20656285f, 0.15277326f, 0.12845127f, 0.16848220f, -0.08233389f, 0.12718089f, 
    0.18671948f, 0.05622405f, 0.05729107f, 0.18427193f, -0.11073433f, -0.16285931f, 0.11923033f, 0.03445819f, 
    0.06188975f, 0.04707152f, -0.06015140f, 0.15508273f, -0.16216674f, -0.17022784f, -0.27430671f, -0.05637321f, 
    0.12960818f, -0.12416983f, 0.14868489f, -0.04825706f, 0.00760631f, -0.15297210f, -0.30533618f, -0.49267691f, 
    -0.01351571f, -0.26449597f, -0.38775137f, 0.18087696f, -0.19202234f, -0.11432008f, -0.12718956f, 0.06018730f, 
    -0.24140245f, 0.01677649f, 0.06098362f, -0.06875286f, 0.00191165f, -0.06205138f, 0.16089489f, -0.03794805f, 
    0.07471193f, 0.08878618f, -0.03998461f, -0.02537102f, 0.07463929f, 0.05956377f, 0.03976028f, 0.17890739f, 
    -0.25890440f, -0.06965621f, -0.14114168f, 0.16362135f, -0.01206472f, -0.15281209f, 0.02341774f, 0.09885361f, 
    0.22128832f, 0.10865346f, -0.03400730f, -0.01105395f, -0.02353444f, 0.01817265f, 0.04678759f, -0.15332897f, 
    0.05111591f, 0.06977939f, 0.29123899f, 0.17155439f, -0.09769352f, -0.14009401f, -0.00517867f, -0.06302962f, 
    0.14147228f, -0.07993203f, 0.04197677f, -0.01922328f, -0.09320706f, 0.00769789f, -0.01049144f, -0.08873890f, 
    -0.00284818f, 0.05051807f, 0.07066884f, 0.07576752f, -0.07939534f, -0.14742218f, 0.02845398f, 0.00639299f, 
    -0.06632134f, 0.07965342f, 0.10128139f, 0.12654155f, 0.19857015f, 0.34554830f, 0.03872129f, -1.31797719f, 
    -0.11557736f, 0.13422801f, -0.08744128f, 0.14477418f, 0.11270761f, -0.08972766f, -0.34089100f, -0.16262470f, 
    0.21253468f, -0.13380706f, -0.14984588f, -0.24044906f, 0.03321419f, 0.04879133f, -0.08757868f, -0.05290828f, 
    0.03023688f, 0.16328219f, -0.03549358f, -0.02138809f, -0.01285816f, 0.01078854f, -0.07045713f, 0.06329932f, 
    -0.08744167f, -0.00524416f, 0.05343498f, -0.02755256f, -0.01318516f, -0.02757671f, -0.01166465f, -0.15964647f, 
    0.03087660f, -0.18504986f, 0.03103996f, -0.11456832f, -0.03476724f, -0.09421625f, -0.19823010f, 0.13118221f, 
    0.09428298f, -0.14053519f, -0.27180278f, 0.03468542f, 0.03063728f, -0.02776419f, 0.03271257f, -0.17918552f, 
    0.04675673f, 0.15865158f, -0.00932478f, -0.22799903f, 0.20011356f, 0.60267675f, 0.04274625f, 0.06475697f, 
    0.07646608f, 0.07782641f, 0.09486555f, 0.08296368f, 0.06458876f, -0.26787671f, -0.04245550f, 0.07508932f, 
    -0.16443603f, 0.10482067f, 0.15112227f, 0.11725309f, 0.08900078f, -0.18692364f, -0.22998625f, 0.06576338f, 
    0.14479099f, 0.10936695f, 0.20443498f, 0.28191662f, -0.05517806f, 0.13274904f, -0.08092529f, 0.15848060f, 
    -0.01851859f, -0.15628932f, 0.04837200f, 0.07902451f, -0.00395677f, 0.11027595f, 0.01937947f, 0.11160512f, 
    -0.11183549f, -0.12434678f, 0.05224168f, -0.11238078f, 0.12982927f, 0.02151693f, 0.05400717f, -0.01032556f, 
    0.17337391f, 0.03611931f, -0.30102009f, -0.04801270f, 0.00922978f, -0.11847036f, -0.01348431f, -0.08131857f, 
    -0.08270112f, 0.09684942f, 0.10425486f, 0.38802290f, -0.00218838f, 0.10329074f, -0.09809405f, -0.00195188f, 
    -0.24513464f, -0.00679056f, 0.19956137f, 0.18716402f, -0.47402200f, 0.07240837f, 0.14084120f, -0.04627418f, 
    0.11514684f, 0.12274747f, -0.12251014f, -0.19110762f, -0.19007187f, -0.43943542f, 0.16432287f, 0.03392339f, 
    0.10566745f, 0.04981756f, 0.16596743f, 0.14531124f, -0.02762165f, 0.04280680f, -0.09268610f, 0.05124725f, 
    0.00701358f, -0.00389597f, 0.05473867f, -0.03659660f, 0.03789992f, -0.10657050f, -0.10548420f, -0.12147690f, 
    -0.00016436f, -0.07741367f, -0.00097222f, -0.03596339f, 0.08222049f, 0.04836810f, 0.10717446f, 0.24897635f, 
    0.24514157f, -0.04035320f, 0.03981488f, -0.03019786f, -0.04889396f, -0.15123464f, 0.27259898f, 0.41472811f, 
    -0.10531003f, -0.57274663f, 0.05207470f, 0.04231878f, -0.22467887f, 0.03708636f, 0.28258845f, 0.20138955f, 
    -0.59907341f, -0.65948170f, 0.09395911f, -0.36775112f, -0.09049745f, -0.25931725f, -0.10897955f, -0.02513748f, 
    0.06334879f, 0.01288294f, -0.02073853f, 0.19253074f, -0.09685542f, -0.02980282f, -0.01413607f, -0.05121529f, 
    0.13232835f, -0.04935599f, 0.25371486f, 0.27677280f, 0.28749645f, -0.05533319f, 0.12865859f, 0.19192153f, 
    0.04548188f, 0.02455612f, 0.28390548f, -0.13103832f, -0.35992691f, 0.09479528f, 0.17636256f, 0.04865740f, 
    -0.11512109f, -0.03015691f, -0.16786298f, -0.19459137f, -0.24266031f, -0.11010279f, -0.11517026f, -0.00498853f, 
    -0.05630840f, 0.03713737f, 0.09105808f, -0.19823571f, -0.03276993f, 0.22167648f, -0.36279601f, -0.30121186f, 
    -0.39446384f, 0.08149472f, -0.07016049f, 0.17927581f, 0.03920545f, 0.27573752f, 0.01477393f, -0.18713714f, 
    0.00094113f, -0.11071084f, -0.21322942f, 0.04268590f, 0.28051493f, 0.08143587f, 0.37812480f, 0.19542506f, 
    0.11831100f, 0.23487774f, -0.14983985f, -0.13829491f, 0.05301956f, -0.03123358f, 0.04806666f, 0.05714527f, 
    -0.15152976f, 0.11576935f, 0.15767406f, 0.07236580f, -0.18621360f, -0.15391320f, 0.13439545f, -0.01362164f, 
    -0.04665559f, -0.15289733f, 0.02646942f, -0.09891707f, -0.08944891f, -0.03835165f, -0.12609267f, -0.16785991f, 
    0.04653336f, 0.05662499f, -0.11898610f, 0.13573049f, -0.00900534f, -0.10330091f, 0.33585340f, 0.06020771f, 
    0.04265451f, 0.13525443f, 0.13048828f, 0.05659502f, -0.01450143f, -0.04114596f, -0.14284511f, -0.33776087f, 
    -0.09316974f, 0.06855273f, -0.00686414f, 0.06669477f, 0.08836475f, -0.11298018f, 0.09182476f, -0.12688541f, 
    -0.14719866f, -0.11477365f, -0.03016817f, 0.02710345f, 0.07596280f, -0.26834455f, -0.96869487f, -0.67354530f, 
    0.04306365f, -0.04413615f, 0.08337215f, -0.07738528f, -0.10419476f, -0.02005012f, -0.11570335f, 0.04612664f, 
    0.45702767f, -0.05806709f, -0.02396787f, -0.11699697f, 0.08006279f, 0.01701990f, 0.10570440f, 0.07966362f, 
    -0.03272104f, 0.01452269f, -0.24886101f, -0.02284948f, -0.34049156f, 0.12485745f, 0.20155938f, 0.13551004f, 
    0.06854124f, 0.11731265f, 0.07214665f, -0.32288501f, -0.06117902f, -0.09258223f, 0.08503827f, 0.20880339f, 
    0.07105006f, -0.87304980f, -0.35393411f, -0.17213123f, -0.10341733f, -0.24898119f, -0.22043307f, -0.10012721f, 
    -0.00149768f, -0.04729532f, -0.52972066f, 0.02256523f, 0.09769085f, -0.07133996f, -0.16878867f, -0.22683829f, 
    -0.08054108f, -0.04287947f, 0.20381248f, -0.11763518f, 0.63648355f, 0.63927329f, 0.17761661f, -0.10947941f, 
    0.18639529f, 0.00018678f, 0.13172632f, 0.09473310f, 0.09456076f, -0.07955275f, 0.04208389f, -0.01236798f, 
    -0.25975338f, -0.17398840f, -0.29136211f, 0.20778765f, 0.08136291f, 0.29923522f, -0.10402190f, -0.09870672f, 
    -0.00144095f, 0.05766130f, 0.14263162f, 0.01701952f, 0.07564206f, -0.05541435f, -0.21767873f, 0.15483296f, 
    -0.17566364f, -0.05840723f, 0.02953813f, -0.13492526f, -0.07591752f, 0.02343150f, -0.06716995f, 0.03921308f, 
    -0.04769609f, -0.13712221f, -0.02121912f, 0.00127576f, 0.22415245f, 0.01316150f, -0.03885837f, -0.10502477f, 
    -0.27762154f, -0.10136361f, -0.23616543f, 0.02328673f, 0.33674651f, -0.10907847f, -0.23703897f, -0.02971356f, 
    -0.20043012f, -0.10743783f, 0.29322484f, 0.39248863f, 0.09790362f, 0.26309299f, 0.08166554f, 0.22865617f, 
    0.27013364f, 0.14183232f, -0.07149633f, 0.57052201f, -0.34723806f, -0.16983859f, 0.04692135f, -0.10579520f, 
    0.04096148f, -0.06588240f, -0.15465665f, -0.20222992f, -0.24807799f, -0.17838143f, 0.00275132f, 0.05708111f, 
    -0.19729620f, 0.02924868f, -0.03631420f, -0.03962899f, 0.08668179f, -0.14665595f, 0.09976359f, -0.11841481f, 
    -0.08225238f, -0.11881080f, -0.13202001f, -0.16520494f, 0.20207272f, 0.02961540f, 0.05695820f, -0.00429189f, 
    -0.02813566f, -0.03105699f, -0.05756675f, 0.20837802f, -0.05964636f, -0.04838019f, 0.13528757f, 0.17836055f, 
    0.27573124f, 0.01017240f, -0.06658599f, 0.12281041f, 0.30645776f, 0.23914568f, 0.17302038f, -0.49663034f, 
    0.65699059f, -0.24111120f, 0.00285615f, 0.18104006f, -0.16566354f, 0.10988107f, 0.19734044f, 0.20914699f, 
    -0.25556704f, 0.33995971f, -0.07908865f, -0.08107051f, -0.32611352f, -0.01741082f, -0.06525241f, -0.04917556f, 
    0.07300805f, -0.27633962f, -0.48163667f, 0.18218574f, 0.03525930f, 0.23303084f, -0.02080422f, 0.12051120f, 
    -0.07012203f, -0.00103167f, -0.12494706f, 0.24005315f, 0.14668256f, 0.06889935f, 0.12413364f, -0.05167478f, 
    -0.00785970f, 0.02156684f, -0.02696334f, -0.01035770f, -0.17382199f, -0.06820344f, 0.02440795f, 0.27568570f, 
    0.10779281f, 0.00159373f, 0.02336967f, -0.14388879f, -0.02946858f, -0.10421011f, 0.03359485f, -0.05274186f, 
    -0.04929730f, 0.00126579f, -0.00552963f, -0.01617859f, -0.01378633f, 0.07325791f, 0.39828718f, 0.03497772f, 
    -0.22874841f, 0.00527415f, 0.09986004f, 0.15943331f, 0.38538009f, -0.04968110f, -0.26802960f, 0.21015725f, 
    -0.40821135f, 0.04591534f, 0.04093226f, 0.15143636f, 0.05381989f, 0.00664605f, 0.15682080f, -0.36446106f, 
    0.23824796f, 0.00927445f, -0.19480495f, -0.02272939f, -0.29843926f, 0.02886031f, 0.02539796f, 0.02069797f, 
    -0.26234430f, 0.28700742f, 0.22232415f, -0.10896978f, 0.06340071f, -0.20634097f, 0.13646871f, 0.16613412f, 
    0.08381555f, 0.03790840f, -0.01170989f, 0.04808602f, 0.02938740f, 0.10319959f, 0.19866139f, 0.12944558f, 
    -0.03255330f, -0.12651077f, 0.08488766f, -0.48418525f, -0.42830867f, 0.07012566f, -0.24460095f, 0.13803796f, 
    -0.13593584f, -0.10249047f, 0.19595204f, 0.06965498f, 0.11542408f, -0.05414078f, 0.05711779f, 0.03342879f, 
    -0.02826644f, 0.19371091f, 0.03300920f, -0.03132420f, -0.11445746f, -0.26395482f, -0.08120970f, -0.01982121f, 
    0.17768231f, -0.12999038f, 0.21065553f, -0.04166264f, -0.05877111f, -0.47195786f, -0.35314146f, -0.01940137f, 
    -0.12632871f, 0.19822939f, 0.20264204f, 0.03789248f, -0.12334820f, -0.26458862f, -0.17879234f, 0.38977635f, 
    0.22023031f, 0.05514135f, -0.22343674f, -0.40450752f, 0.03044026f, -0.12281135f, -0.08833316f, 0.09618471f, 
    0.31073117f, 0.19177479f, -0.22147948f, -0.11588984f, -0.06818306f, 0.10729149f, 0.04471707f, 0.02685248f, 
    -0.02500729f, 0.28396299f, -0.01065312f, -0.14875542f, -0.08012980f, -0.12372480f, 0.07425187f, 0.17762817f, 
    0.06730291f, 0.08850533f, 0.22966588f, 0.52002960f, 0.04317362f, -0.15542142f, -0.08158098f, 0.10930538f, 
    0.06041380f, 0.03119445f, -0.03750100f, -0.35242796f, 0.41517261f, 0.07297057f, -0.11504785f, -0.05595157f, 
    0.08481411f, -0.00515667f, 0.19709389f, -0.12205672f, 0.23698948f, 0.27740133f, 0.10546351f, -0.18340719f, 
    -0.10078775f, 0.18799947f, 0.10675406f, 0.09027845f, -0.70986766f, -0.12027010f, -0.32148346f, -0.25362819f, 
    0.18498546f, -0.16539782f, -0.16514687f, 0.14226185f, 0.05319658f, -0.24720734f, 0.11275703f, -0.38097674f, 
    -0.02981473f, 0.10617594f, -0.09836774f, -0.00414956f, 0.00992722f, -0.10351286f, 0.08585650f, 0.43128744f, 
    0.46490738f, 0.04145190f, -0.21540436f, -0.06170432f, 0.11892104f, -0.05663938f, 0.00233541f, -0.07717931f, 
    0.20652829f, 0.13596079f, 0.17953171f, 0.18411915f, -0.10474111f, -0.01524844f, -0.03103646f, 0.02888750f, 
    -0.12950687f, 0.04649491f, -0.05972084f, 0.04325436f, 0.11652137f, 0.18319635f, 0.08173534f, -0.04116329f, 
    -0.27801579f, -0.04985677f, 0.33631596f, 0.02801757f, 0.02071847f, -0.50233984f, -0.29202744f, -0.01260461f, 
    -0.03199855f, 0.04902707f, 0.03536265f, 0.28507468f, 0.10701172f, -0.01260546f, -0.18638539f, 0.14289024f, 
    -0.04119866f, 0.00005419f, -0.00236667f, 0.30296546f, -0.00143498f, 0.41464829f, -0.12267590f, -0.02513753f, 
    -0.04720077f, 0.04163084f, -0.02665324f, -0.01814764f, -0.39822677f, -0.00726750f, -0.22935522f, -0.09216478f, 
    0.02678816f, -0.06810894f, -0.10814507f, 0.05534351f, 0.09617026f, -0.37150428f, -0.21421716f, 0.15118898f, 
    -0.06705958f, 0.19056316f, 0.03830869f, 0.11044313f, -0.01332172f, 0.14769125f, -0.00545882f, 0.17367288f, 
    0.08728137f, -0.17611329f, -0.19320798f, -0.11126719f, -0.04260366f, 0.07082117f, 0.09420327f, -0.01931837f, 
    -0.00337631f, 0.31289870f, -0.12891518f, -0.10173911f, -0.05510799f, -0.01962300f, 0.07162623f, -0.12265441f, 
    0.38894123f, -0.01093499f, -0.21830860f, -0.00919568f, -0.01198451f, 0.21164942f, -0.02265355f, 0.00239600f, 
    -0.03443182f, 0.38017169f, 0.09423996f, -0.21997905f, -0.01939729f, -0.00907598f, -0.08607686f, -0.11600736f, 
    0.20945285f, -0.09740039f, 0.60398161f, -0.08654756f, -0.45258707f, -0.08692511f, 0.10813539f, 0.04417791f, 
    0.16769248f, -0.08175029f, 0.02460764f, -0.13028228f, 0.15462637f, 0.06702068f, 0.05427229f, -0.09192050f, 
    -0.04884112f, 0.07189257f, 0.11860810f, 0.01519815f, -0.49969280f, -0.08888505f, 0.29655963f, -0.28013080f, 
    -0.02653907f, -0.20825174f, 0.20741095f, 0.13068734f, 0.06440350f, 0.29201579f, -0.00080708f, -0.00309479f, 
    0.03205384f, -0.09020993f, 0.07939234f, 0.02007113f, -0.24134821f, 0.20201260f, -0.20421618f, 0.05308241f, 
    -0.32158265f, 0.02850376f, 0.02004693f, -0.02476750f, -0.01679412f, 0.12839395f, 0.16455528f, 0.27409601f, 
    0.15364116f, -0.12643546f, -0.18094414f, 0.17010184f, 0.07697090f, 0.06506237f, 0.04371886f, 0.07193618f, 
    -0.18939836f, -0.19540527f, 0.46062329f, -0.23782142f, 0.13145772f, -0.19643958f, 0.06728525f, 0.11065319f, 
    0.12929450f, -0.08972540f, 0.08286999f, 0.07207274f, -0.15270722f, -0.00303734f, -0.10445189f, 0.14352025f, 
    -0.00824066f, -0.04778489f, -0.07090912f, -0.32747138f, -0.10065419f, 0.14572237f, 0.00015948f, 0.24741437f, 
    0.08898211f, 0.00427038f, 0.12677628f, -0.14513864f, 0.05390416f, 0.02638882f, -0.11378066f, -0.03223682f, 
    0.05015178f, -0.00815986f, 0.03444121f, -0.01033261f, 0.19994015f, -0.01410086f, 0.05146061f, -0.00933574f, 
    -0.02931635f, -0.01447000f, 0.16627911f, 0.00093605f, -0.01472766f, 0.62292838f, -0.07051883f, -0.13882896f, 
    -0.07540731f, -0.23659292f, 0.10851875f, 0.24021511f, 0.12733512f, -0.22496054f, 0.40351111f, -0.27629906f, 
    -0.38283312f, 0.09334336f, 0.22501619f, 0.32031170f, -0.06328238f, 0.07445082f, -0.07964402f, -0.14233187f, 
    -0.01115027f, -0.01390502f, -0.26845232f, 0.10592051f, 0.07813081f, -0.13728167f, -0.06317312f, -0.00585349f, 
    -0.07319845f, 0.01077651f, 0.13183182f, -0.18764015f, -0.06605247f, 0.07387330f, -0.09283656f, 0.00879700f, 
    0.12397572f, 0.17395446f, 0.01319613f, -0.17703155f, -0.10502307f, -0.27884597f, -0.22046877f, -0.06818189f, 
    -0.01752518f, -0.01042067f, 0.36736587f, 0.20124766f, -0.26825514f, -0.07251553f, -0.09759569f, -0.17502774f, 
    -0.07103090f, 0.19924890f, -0.09616897f, 0.61022639f, -0.40018129f, -0.53291434f, -0.19740899f, 0.16059577f, 
    -0.04092835f, 0.32264200f, -0.20026645f, -0.04076485f, 0.43182349f, 0.15731658f, -0.19119933f, 0.02291883f, 
    0.05277247f, 0.06887221f, -0.00831609f, 0.22997922f, 0.15191406f, 0.35254470f, -0.21084286f, -0.16433966f, 
    -0.11440900f, 0.15971576f, 0.17696401f, 0.06495606f, -0.15265314f, -0.07102612f, -0.05669209f, -0.46953985f, 
    -0.27355322f, 0.00059810f, -0.00792784f, -0.00115287f, -0.12549342f, -0.08016362f, 0.11039618f, -0.24446867f, 
    -0.06249513f, 0.00244713f, 0.03242740f, 0.05513235f, -0.10264988f, -0.09004333f, -0.20144726f, 0.08203793f, 
    -0.00443068f, -0.26026151f, -0.30609488f, 0.00269868f, 0.07234279f, -0.10457138f, 0.41278061f, -0.04542863f, 
    0.03746533f, 0.15942989f, -0.30821422f, -0.26038274f, -0.05068320f, 0.14627124f, 0.32906935f, 0.06431189f, 
    -0.00282629f, 0.25134423f, -0.18292236f, -0.42052874f, -0.39849821f, -0.00762710f, 0.02675370f, 0.15817545f, 
    -0.04915175f, -0.01947768f, 0.11191308f, -0.27569753f, -0.21569283f, 0.07466495f, -0.04594111f, -0.08852448f, 
    -0.03954102f, 0.00466540f, 0.14732137f, 0.08476629f, -0.13341036f, -0.02530132f, -0.04428564f, 0.13190815f, 
    -0.04071048f, 0.05262912f, 0.08091318f, 0.11915624f, -0.08811037f, -0.07519574f, 0.00328234f, 0.06441087f, 
    -0.07487205f, -0.06883916f, -0.06352340f, -0.01280452f, 0.09258158f, -0.10345629f, 0.13565829f, -0.05418013f, 
    0.04243731f, -0.06874921f, 0.13204733f, 0.06307760f, -0.01268642f, 0.03197755f, 0.24679735f, -0.37769759f, 
    -0.55626565f, 0.29538590f, -0.05113541f, 0.14693379f, 0.05714704f, 0.19050691f, 0.11401512f, 0.24326314f, 
    0.02008987f, -0.04964591f, -0.06937741f, 0.04406023f, -0.02784313f, -0.07433725f, -0.01631290f, -0.03236557f, 
    -0.03589465f, -0.03836688f, -0.01640221f, 0.01449664f, -0.03518554f, 0.04664632f, 0.01771208f, 0.00551406f, 
    0.03739040f, -0.00168962f, 0.00184377f, 0.00314277f, -0.08093695f, -0.01823826f, -0.06641530f, -0.05226293f, 
    -0.01862302f, 0.00299488f, 0.02472581f, 0.01971746f, -0.04983645f, 0.01511759f, -0.09141102f, -0.07702728f, 
    -0.07573970f, 0.00190347f, -0.01096774f, -0.05034056f, -0.08860189f, 0.02950477f, -0.07320395f, 0.00131918f, 
    -0.00769957f, -0.04555842f, -0.04141136f, 0.04162022f, -0.06068267f, 0.02717957f, -0.07511161f, 0.00266819f, 
    -0.06556542f, 0.01656078f, -0.00282204f, 0.04427335f, -0.05012919f, -0.02290128f, -0.07122055f, -0.00960959f, 
    -0.04952746f, -0.01616646f, 0.05176267f, -0.03720725f, 0.02131503f, -0.04498737f, -0.08417191f, -0.07895230f, 
    -0.07749117f, -0.01644848f, -0.02915032f, -0.04132119f, -0.09076881f, -0.04931178f, -0.05525811f, -0.00061409f, 
    -0.04485007f, 0.00793264f, -0.07838381f, -0.03709877f, -0.06268434f, -0.04955721f, -0.01270913f, -0.04401257f, 
    -0.01075863f, -0.09254268f, -0.05361797f, -0.04799671f, -0.05727288f, -0.03389917f, 0.03961663f, -0.08651498f, 
    -0.04014868f, -0.05932225f, -0.01584436f, -0.05396364f, -0.00724985f, 0.03600441f, 0.02178380f, -0.02335121f, 
    -0.02002998f, -0.00163144f, -0.09730593f, -0.02438227f, -0.04374801f, -0.04052760f, -0.00963327f, -0.07290722f, 
    -0.08302489f, 0.00458298f, -0.07993733f, -0.05571065f, -0.03805270f, -0.01258278f, -0.06760265f, -0.06251454f, 
    -0.03944461f, -0.07672492f, -0.07071739f, -0.04264562f, -0.04118131f, -0.03165614f, -0.08820216f, 0.00706945f, 
    -0.05018514f, -0.01931389f, -0.05265135f, 0.00741688f, -0.01665069f, -0.00293346f, -0.05294661f, -0.05905926f, 
    -0.01097452f, 0.00524683f, -0.01443227f, -0.07983103f, -0.00457748f, -0.03301248f, 0.03441640f, -0.05190742f, 
    0.04041461f, 0.01609427f, 0.00764525f, -0.09908809f, -0.04202778f, -0.07302023f, -0.02669002f, -0.04174437f, 
    0.00653859f, -0.01270073f, 0.01057381f, 0.01239695f, -0.03378726f, 0.05152639f, -0.05539617f, 0.00761904f, 
    0.00518887f, 0.00575176f, -0.08557624f, -0.05566042f, 0.04987824f, -0.05924426f, -0.01720033f, 0.05222367f, 
    0.02139382f, 0.00985487f, -0.01729462f, -0.00917336f, -0.05976358f, -0.04817455f, -0.03811872f, -0.04362066f, 
    -0.02483268f, 0.01342947f, -0.01290140f, -0.04610612f, 0.03074088f, 0.02525603f, -0.02061474f, -0.09460682f, 
    0.00537862f, 0.03196307f, -0.05164998f, 0.04732945f, -0.07464977f, -0.05212741f, -0.03829099f, -0.10085868f, 
    -0.03420382f, -0.07220957f, -0.09116767f, -0.06152621f, -0.06702356f, -0.07177461f, 0.00583620f, -0.07003406f, 
    -0.05117165f, -0.03129313f, 0.01512957f, -0.05768614f, 0.02314172f, 0.02138485f, -0.01760830f, -0.07658076f, 
    0.02897937f, -0.00013567f, -0.07309862f, -0.07838371f, -0.01067171f, 0.01612397f, -0.06354379f, 0.00637257f, 
    -0.05410001f, 0.02081025f, -0.04920058f, -0.03851703f, -0.10061761f, -0.00531934f, 0.00988207f, 0.04563934f, 
    0.01813451f, -0.02790363f, 0.02132827f, -0.07754187f, -0.05210959f, 0.00259718f, 0.00422363f, -0.02537987f, 
    0.04924845f, -0.07553130f, -0.01828217f, 0.03155829f, -0.01738525f, -0.04518013f, -0.02118418f, -0.06101123f, 
    0.04147798f, -0.00188391f, -0.01029129f, -0.03006104f, -0.01968263f, 0.00717456f, 0.01403367f, 0.02150623f, 
    0.02232661f, 0.04341028f, -0.03975488f, -0.06042155f, -0.06692063f, -0.03966058f, -0.04512841f, -0.00674815f, 
    0.01652481f, 0.03908489f, -0.00643832f, -0.01549068f, 0.01516314f, -0.00262161f, -0.03096309f, 0.01282474f, 
    -0.02975403f, 0.01974015f, -0.10016563f, -0.04484176f, -0.02483039f, -0.04318492f, -0.06802516f, -0.01904538f, 
    -0.06986690f, -0.04672380f, 0.00420225f, -0.08133117f, -0.00331136f, -0.07862306f, 0.00858648f, -0.03057370f, 
    -0.05562560f, -0.05137670f, -0.06629878f, -0.01609394f, -0.04054964f, -0.05672727f, 0.03992827f, -0.03686991f, 
    0.00256462f, -0.01992624f, -0.05728044f, 0.00732176f, -0.02494977f, -0.06477144f, 0.02605726f, -0.04120916f, 
    0.10978746f, 0.19085512f, -0.10144962f, -0.01797534f, -0.02219375f, -0.10658248f, 0.16501305f, 0.09089088f, 
    -0.06990691f, 0.34230351f, 0.15990677f, 0.25688139f, 0.22444944f, 0.05527090f, -0.01977576f, 0.13707364f, 
    0.03161984f, -0.05966164f, -0.14174882f, -0.18587017f, 0.07111757f, 0.18756980f, -0.07645819f, 0.11070195f, 
    -0.01510103f, 0.28854701f, 0.24206877f, -0.74864048f, -0.14783080f, 0.35345393f, -0.16494577f, -0.17789017f, 
    -0.13104457f, -0.07419465f, -0.10833740f, 0.15452416f, -0.63051671f, -0.24565187f, -0.07403038f, 0.04283619f, 
    -0.15903191f, -0.01010986f, -0.15130438f, -0.09310199f, -0.08639926f, 0.00900864f, 0.00358702f, 0.14002220f, 
    -0.08812868f, -0.03165517f, 0.10947859f, 0.16518815f, -0.16537207f, 0.04322312f, -0.02726563f, -0.05100949f, 
    -0.19312805f, 0.21911380f, 0.03200745f, 0.01325175f, 0.10950762f, -0.01327308f, -0.27250841f, 0.10877071f, 
    -0.14175734f, 0.01523001f, -0.01747588f, -0.15692057f, -0.10372189f, -0.00512419f, 0.02994835f, 0.31765136f, 
    0.09838035f, 0.32795757f, 0.15299308f, 0.08294230f, -0.29047516f, -0.14693727f, 0.27740043f, 0.18801986f, 
    -0.06696174f, -0.34829557f, -0.38163334f, -0.35592729f, 0.20429598f, -0.08552616f, 0.00714300f, 0.12273823f, 
    -0.05956038f, -0.06170008f, 0.36012220f, 0.24589680f, 0.24006565f, 0.08166970f, 0.04566038f, -0.17799196f, 
    0.31716409f, 0.09668414f, 0.16807084f, -0.33854169f, -0.57252532f, -0.00384080f, -0.04418047f, -0.12076804f, 
    0.09272800f, -0.35824585f, -0.28706822f, -0.24801691f, 0.00306126f, -0.00159883f, 0.08319192f, -0.06020692f, 
    -0.03863279f, 0.05944338f, 0.00598379f, 0.01040003f, 0.23530534f, -0.02889819f, 0.14058697f, -0.15832135f, 
    -0.24877629f, 0.32911170f, 0.01991727f, -0.03888540f, -0.03428008f, -0.14977731f, -0.15779547f, 0.39180902f, 
    0.23702510f, 0.11960066f, 0.08774710f, 0.02249670f, 0.26441193f, 0.28601390f, -0.16983606f, -0.22364506f, 
    -0.22614756f, -0.05843482f, 0.08239549f, 0.00051913f, -0.08276530f, -0.01371894f, 0.15074536f, 0.11555684f, 
    -0.19668315f, -0.12822811f, -0.04252792f, -0.21273918f, 0.20666645f, 0.04098010f, 0.05637518f, -0.17616512f, 
    0.09343886f, 0.00820144f, 0.05949220f, 0.12590143f, -0.08540957f, 0.05354827f, -0.08834879f, -0.16161127f, 
    -0.06611197f, -0.46749151f, 0.26380977f, -0.01753862f, 0.05115253f, 0.10851257f, -0.09557479f, -0.11874191f, 
    0.02436464f, -0.07341000f, -0.22860241f, 0.07269406f, 0.10715296f, 0.38662833f, -0.00319760f, 0.00968148f, 
    0.08544778f, 0.13765775f, 0.01859614f, 0.24620435f, 0.40889382f, -0.15279961f, 0.27522442f, -0.14192417f, 
    0.09245413f, -0.06562574f, 0.18963046f, 0.20988555f, 0.18587451f, -0.22959040f, -0.12011137f, 0.17890336f, 
    0.23863305f, -0.03973150f, 0.16334085f, -0.00471771f, 0.15596159f, -0.14319971f, 0.14265600f, -0.05903121f, 
    0.12622203f, 0.00092877f, 0.13651864f, 0.04735018f, -0.08691495f, -0.13309659f, -0.12388145f, -0.02744048f, 
    -0.46366215f, 0.01447643f, 0.02749416f, -0.01335853f, 0.36434522f, -0.37678799f, -0.15369645f, -0.00606281f, 
    -0.06698313f, -0.59117287f, -0.24151827f, -0.13529120f, 0.07762871f, -0.20183985f, -0.12997684f, -0.10797954f, 
    -0.11212792f, -0.06357685f, 0.37557980f, 0.39446604f, 0.20089771f, 0.05963834f, -0.00129425f, 0.14866415f, 
    0.14883588f, 0.03267898f, 0.22761057f, 0.09172808f, 0.16545781f, -0.09224510f, 0.12057730f, 0.04535472f, 
    0.10361884f, -0.03389057f, -0.13540871f, -0.05963764f, 0.17800876f, 0.29841080f, 0.20016210f, -0.02518067f, 
    0.12367684f, -0.09659323f, -0.11371108f, 0.00715357f, -0.37653953f, -0.13022803f, -0.34621298f, -0.09580608f, 
    -0.15248145f, -0.32128397f, 0.00363470f, 0.24528001f, 0.03617798f, -0.48417363f, -0.04854844f, -0.21234678f, 
    -0.03567421f, -0.35682774f, 0.12595057f, 0.02526296f, 0.09471176f, -0.05614193f, -0.21894081f, 0.01646773f, 
    0.06927678f, 0.18839791f, 0.04254746f, -0.01361003f, 0.03138980f, 0.09691258f, 0.17133979f, 0.36625886f, 
    -0.31393135f, 0.13615051f, -0.15643334f, 0.00830807f, -0.01852882f, 0.20107380f, 0.06516302f, 0.18606415f, 
    -0.06259876f, -0.13645315f, 0.24109983f, 0.11688483f, -0.18583894f, -0.09157365f, 0.02027205f, 0.07820638f, 
    0.02627747f, -0.51286858f, 0.08346941f, 0.10935444f, 0.01805236f, -0.02925215f, 0.06793568f, 0.02540275f, 
    -0.07319394f, -0.17186840f, 0.07961255f, 0.11246501f, 0.09316224f, -0.00425438f, -0.05749784f, 0.02732587f, 
    0.05316156f, 0.12579319f, 0.03165650f, -0.13382420f, -0.21561831f, -0.13673641f, 0.08474970f, -0.00232270f, 
    0.06875900f, -0.05476718f, 0.03183195f, -0.05746727f, 0.34458849f, -0.32032421f, -0.21527869f, -0.10674145f, 
    0.00155402f, -0.08651015f, 0.08889783f, 0.01556464f, 0.20742653f, 0.10741889f, 0.35893762f, 0.45016626f, 
    0.03114068f, 0.18838421f, 0.05824177f, -0.30436715f, 0.14120819f, 0.10543384f, -0.23955010f, -0.23906218f, 
    -0.02380103f, -0.02565011f, 0.02180691f, 0.03813336f, 0.02631661f, 0.14222896f, -0.19808936f, -0.22515088f, 
    -0.29158026f, 0.14668083f, 0.17243057f, -0.03083440f, 0.15474072f, 0.13585632f, -0.02242717f, -0.10621492f, 
    -0.06207148f, -0.30351722f, 0.07731410f, 0.00278285f, -0.18939061f, 0.07963439f, 0.03992940f, -0.04352946f, 
    -0.63138562f, -0.01395456f, -0.18655324f, -0.05446786f, -0.02263553f, 0.06884180f, -0.08604330f, 0.19454834f, 
    0.06724073f, 0.14797236f, -0.02805405f, -0.17612891f, -0.11217058f, 0.05750300f, -0.16001925f, -0.15534809f, 
    -0.16600984f, 0.07813068f, -0.23326106f, 0.01680335f, 0.04436435f, -0.01786992f, 0.10782953f, 0.01671252f, 
    -0.15091969f, 0.19701983f, -0.02877020f, 0.19649000f, -0.08282278f, 0.00631686f, -0.07154275f, 0.14503610f, 
    -0.17644644f, -0.21120439f, 0.15135993f, 0.10481295f, 0.01361051f, -0.02368343f, -0.25269786f, 0.30053702f, 
    0.09147368f, 0.08083490f, 0.10496856f, -0.19140059f, 0.18129528f, -0.06764638f, -0.49078229f, 0.07647061f, 
    0.08473638f, -0.00743991f, -0.15900065f, 0.04506343f, -0.03801731f, 0.05692138f, -0.10711458f, 0.06970229f, 
    -0.06814662f, 0.01740738f, 0.07123167f, 0.14662892f, 0.21362132f, 0.03992024f, 0.05339563f, -0.03453512f, 
    -0.02234752f, -0.06886847f, 0.02622431f, 0.13006654f, 0.02300041f, 0.28567228f, 0.14582482f, -0.09134015f, 
    0.03557462f, -0.13741872f, 0.16921373f, 0.49727648f, 0.04218877f, 0.05494168f, 0.10481783f, 0.00838805f, 
    -0.06099273f, -0.13080420f, -0.26415759f, 0.11386392f, 0.26647002f, 0.02140411f, -0.09720467f, 0.21006101f, 
    0.12297073f, 0.07757553f, -0.14833920f, 0.14246956f, 0.04057221f, 0.15198918f, 0.09743308f, -0.08966680f, 
    -0.04867354f, 0.08441831f, 0.00145258f, 0.14647099f, -0.25487369f, -0.39256367f, 0.35614079f, 0.24151415f, 
    0.06147225f, -0.01706927f, -0.23967879f, -0.00333630f, -0.17619081f, 0.08529601f, -0.04231089f, 0.11104722f, 
    -0.13172373f, 0.08282993f, -0.07393374f, 0.19542442f, 0.03419333f, 0.19944723f, 0.16507570f, -0.03139131f, 
    0.33360943f, 0.14898650f, 0.09361747f, 0.07935534f, -0.05441907f, 0.01774418f, -0.02658733f, -0.12154657f, 
    -0.10682128f, 0.08567033f, 0.13670051f, -0.04866918f, 0.03606360f, 0.13350688f, 0.03489887f, 0.17549321f, 
    0.06635948f, -0.05865260f, 0.04364181f, 0.01654849f, 0.07464688f, 0.04095199f, -0.00139891f, -0.03943188f, 
    0.08523870f, -0.29359797f, -0.21222313f, -0.17773138f, 0.10582136f, 0.00929840f, -0.02960117f, -0.06329828f, 
    -0.01543072f, -0.13851273f, 0.37286940f, 0.05286603f, 0.21769957f, 0.10474862f, 0.07732836f, 0.11852989f, 
    -0.05715115f, -0.02175616f, 0.03073700f, 0.03173953f, 0.27945459f, 0.03217151f, 0.01240208f, 0.03481758f, 
    0.27037778f, 0.00319784f, 0.07083842f, -0.20258541f, 0.14728364f, -0.33052716f, -0.11671014f, -0.03736952f, 
    -0.01697253f, 0.02052931f, -0.12278515f, -0.12684561f, 0.11694621f, 0.06067282f, -0.27497932f, -0.07921728f, 
    -0.07410530f, -0.05126832f, -0.01367241f, -0.08074108f, -0.12971479f, -0.34360087f, -0.22209325f, -0.18769448f, 
    0.01186834f, -0.04329538f, 0.06606229f, -0.06005182f, -0.08665188f, -0.13856097f, -0.16774234f, 0.14165163f, 
    -0.02356797f, -0.05059921f, -0.02389535f, 0.02530617f, -0.12844959f, 0.00775198f, -0.32675156f, -0.02543439f, 
    -0.55818468f, -0.87523156f, -0.05145452f, 0.01350536f, 0.17652176f, -0.04688224f, 0.16600446f, -0.08332212f, 
    -0.12186037f, 0.15571947f, -0.20609991f, -0.58564025f, -0.21365230f, -0.14042452f, -0.04668696f, 0.03505559f, 
    0.00396380f, -0.02042660f, -0.03991589f, 0.10804800f, -0.07802584f, 0.23750076f, 0.05346677f, 0.03934289f, 
    0.04369092f, 0.06499612f, -0.05716868f, 0.40344900f, 0.01795382f, -0.24325000f, 0.11150146f, 0.21729428f, 
    -0.20861563f, 0.05617859f, -0.01850156f, 0.06159155f, 0.21227239f, 0.07492432f, 0.23097780f, 0.10851320f, 
    -0.18394387f, -0.09856430f, 0.20289172f, 0.05598197f, -0.23750690f, -0.28480703f, -0.65515649f, -0.39328292f, 
    0.11178456f, -0.10758208f, -0.04041314f, 0.30481026f, -0.22950853f, -0.04441192f, -0.03312495f, 0.00779767f, 
    0.14383163f, 0.07972798f, 0.00490439f, 0.10800140f, 0.25764200f, 0.02990296f, -0.01472551f, -0.13214913f, 
    0.28962600f, 0.12521172f, 0.00299048f, 0.08466971f, 0.00333376f, -0.01520741f, -0.08233023f, -0.12275589f, 
    -0.36403039f, -0.24959084f, 0.28184888f, -0.00630765f, 0.16070700f, -0.22440733f, 0.02532546f, -0.04018279f, 
    0.17118382f, 0.07008377f, 0.01382133f, 0.00235708f, -0.01074427f, 0.00360970f, 0.02429078f, 0.02056834f, 
    0.02888687f, -0.10537862f, 0.09614816f, -0.38848624f, -0.26491964f, -0.17388861f, 0.22905372f, 0.25747949f, 
    0.16448075f, 0.06664856f, -0.07346045f, 0.04470517f, 0.04546945f, 0.03044813f, -0.04259922f, 0.00840877f, 
    -0.03182547f, 0.07755821f, 0.06280855f, -0.04229471f, -0.13633054f, -0.06560518f, -0.02065695f, -0.11224671f, 
    -0.04175153f, -0.17477807f, 0.16641739f, 0.10169728f, -0.12701054f, 0.85500294f, -0.74504590f, -0.20135912f, 
    0.32435411f, 0.05676256f, 0.03868659f, 0.10799545f, -0.17129631f, -0.10522936f, 0.07940385f, -0.41989169f, 
    -0.28345948f, -0.20384079f, 0.01683163f, 0.03519752f, -0.04196404f, -0.04347679f, -0.00063391f, -0.00227567f, 
    0.15846513f, -0.01037374f, -0.14333281f, 0.00599606f, 0.01143488f, 0.01381376f, -0.02854509f, 0.07398002f, 
    -0.00894862f, 0.14895412f, 0.05567358f, -0.17144202f, 0.10483564f, 0.04328753f, -0.12262180f, 0.02658735f, 
    -0.08876688f, -0.00774706f, -0.09004921f, -0.17271964f, -0.20445128f, -0.11544604f, -0.08901005f, 0.04069921f, 
    -0.05377514f, 0.02910732f, -0.38043278f, 0.05882808f, -0.04443731f, -0.16069831f, 0.02383982f, 0.08075438f, 
    0.07608104f, 0.02904680f, 0.10929631f, -0.38855705f, -0.09472676f, -0.01265812f, 0.01132952f, 0.20122546f, 
    0.05713238f, -0.09420152f, 0.17823051f, 0.10138671f, -0.20049319f, -0.11199002f, -0.13060425f, 0.28967696f, 
    -0.07115098f, -0.19063781f, 0.14899951f, 0.01616966f, 0.03995237f, -0.12295346f, -0.06789376f, -0.08086488f, 
    -0.04728224f, 0.22058754f, 0.08640722f, 0.14233840f, 0.04137830f, -0.03740486f, -0.13884465f, 0.08661678f, 
    -0.02473822f, -0.09457921f, 0.04320779f, -0.18748119f, -0.00933712f, -0.05777100f, 0.03083480f, 0.05262699f, 
    0.07406700f, -0.02600046f, 0.04990433f, 0.05744010f, 0.05434715f, 0.05295621f, 0.02593046f, -0.12930317f, 
    0.34330779f, -0.08144614f, -0.17047574f, -0.06618264f, 0.03362820f, -0.07160217f, -0.04849476f, -0.07631996f, 
    -0.11386515f, 0.18572555f, -0.05854444f, -0.17252210f, -0.06467201f, 0.03106349f, 0.24186438f, -0.00092527f, 
    0.14291812f, 0.09078319f, 0.12134475f, 0.02500696f, -0.21728544f, -0.01924580f, 0.19068061f, 0.05874965f, 
    0.14167263f, 0.05962634f, 0.06351644f, 0.09269728f, 0.07971060f, -0.05028851f, 0.24838224f, 0.19864739f, 
    -0.03028823f, 0.03752237f, 0.04442524f, 0.08373824f, -0.12405206f, -0.04872558f, 0.03547680f, 0.00867682f, 
    -0.08249630f, 0.02799550f, 0.02793699f, -0.06493413f, -0.10840176f, -0.21701607f, -0.18696845f, 0.03843751f, 
    0.04158996f, -0.02710584f, -0.12334917f, -0.00465828f, -0.13634680f, -0.12245442f, 0.17793241f, 0.29250750f, 
    0.16521113f, 0.02029633f, 0.01971554f, -0.02806771f, 0.06950647f, -0.02624298f, 0.27204263f, 0.08202542f, 
    -0.23643939f, 0.20844318f, -0.10462712f, 0.24412917f, -0.04524013f, 0.09410080f, -0.00271604f, -0.06112092f, 
    -0.00426082f, -0.08176108f, -0.34673747f, -0.00235121f, 0.13323773f, -0.19489345f, -0.27470836f, 0.03101831f, 
    -0.12389308f, -0.03303886f, -0.16078080f, -0.71689028f, -0.10816424f, -0.31316617f, 0.05690286f, 0.00091463f, 
    -0.04237325f, -0.15880229f, 0.20208460f, 0.02428664f, -0.31782830f, -0.11421956f, 0.29383010f, 0.08762530f, 
    0.15204510f, 0.11945325f, 0.19479115f, -0.05813415f, -0.01038436f, 0.01909974f, 0.16720159f, -0.05969181f, 
    -0.07537759f, -0.00843380f, 0.05114225f, 0.03495399f, -0.24863678f, 0.35898051f, -0.18553816f, 0.02686369f, 
    -0.09170958f, 0.12865953f, 0.03925395f, 0.07972905f, -0.17962977f, 0.33249521f, -0.53408301f, -0.23166260f, 
    0.02171278f, 0.05087738f, 0.14852269f, -0.01639347f, -0.08196434f, -0.18724492f, -0.10989375f, -0.17792554f, 
    0.07146284f, 0.00707563f, -0.13875389f, -0.13083838f, 0.07526406f, 0.20762314f, 0.28851810f, 0.39660218f, 
    0.19571599f, -0.15576719f, -0.06125196f, -0.08638263f, 0.12483609f, 0.04568787f, -0.11093272f, 0.03291481f, 
    -0.07845639f, 0.27980641f, 0.11435959f, -0.14289072f, -0.11050970f, 0.03317228f, -0.09670492f, 0.12349966f, 
    -0.01698533f, 0.01766687f, 0.09317830f, 0.04199260f, 0.01348233f, -0.02917838f, -0.08204351f, 0.26368767f, 
    0.05184352f, -0.00675557f, 0.27650574f, -0.76919609f, -0.03314741f, -0.04116963f, 0.32345915f, -0.35325450f, 
    0.10887083f, -0.02993317f, 0.03541508f, -0.02567039f, -0.10683114f, -0.06682586f, 0.11943694f, 0.04032095f, 
    0.01774448f, 0.15219779f, -0.03109342f, 0.05736559f, -0.05218647f, -0.02251695f, -0.07183947f, 0.09697985f, 
    -0.04252282f, 0.00439434f, -0.00407736f, -0.13516703f, 0.09277242f, 0.69808292f, 0.12227493f, -0.23563954f, 
    0.02171524f, 0.13152075f, -0.10699055f, -0.15382001f, 0.25490567f, -0.10988702f, -0.20874953f, -0.44044381f, 
    -0.78819376f, -0.19544123f, -0.10207473f, 0.06060896f, -0.08839122f, -0.01638572f, -0.15590915f, 0.01742563f, 
    0.13686056f, 0.09685087f, -0.07838766f, -0.01686066f, -0.02826795f, -0.03202270f, -0.18108344f, -0.03222623f, 
    -0.01365757f, 0.27517012f, 0.30010369f, -0.07306594f, 0.00169659f, -0.03800635f, -0.00123410f, -0.21237972f, 
    -0.09164207f, -0.01311478f, -0.25947717f, -0.50056350f, -0.03716201f, -0.10153266f, -0.04417432f, -0.03227891f, 
    -0.11152790f, -0.09233295f, -0.09975244f, 0.04717634f, -0.43765283f, -0.12054887f, -0.05564960f, 0.02793397f, 
    0.08169851f, 0.11373435f, -0.10560616f, 0.05249355f, 0.09782843f, 0.06418414f, -0.04410886f, -0.10790525f, 
    0.09151856f, 0.09917343f, 0.07923629f, -0.05899894f, 0.33221325f, 0.17466390f, 0.12714177f, 0.18645516f, 
    -0.00079749f, -0.03599456f, -0.02187311f, -0.10158043f, 0.07375710f, 0.19174260f, -0.00237038f, -0.05310348f, 
    0.07724712f, 0.14719118f, 0.15796968f, 0.10474060f, -0.17893060f, 0.21877375f, 0.02011673f, -0.03438708f, 
    -0.26487783f, -0.02283339f, -0.04750911f, -0.11046979f, -0.23020697f, -0.14346869f, -0.08714987f, -0.06467420f, 
    0.03132759f, 0.00928575f, 0.06776521f, 0.11438004f, 0.03094264f, 0.14201677f, -0.03602370f, -0.03921545f, 
    0.05049280f, -0.08755692f, -0.23267630f, 0.21330319f, 0.24165282f, -0.12793861f, -0.12904359f, -0.01705033f, 
    0.14830260f, -0.28991339f, -0.45299962f, -0.22545581f, -0.18845396f, 0.22817273f, -0.21871702f, -0.01911495f, 
    -0.00544964f, -0.15727139f, 0.22250447f, -0.36042294f, -0.50157809f, -0.07078495f, 0.11043145f, 0.13278024f, 
    -0.06878296f, 0.07934473f, 0.03914621f, -0.21445550f, -0.08523867f, 0.01406566f, 0.20817067f, 0.34970975f, 
    0.27595037f, -0.07057029f, 0.01584257f, -0.07507195f, 0.01318301f, 0.10269853f, 0.24144772f, -0.04631505f, 
    -0.17232965f, 0.06061136f, 0.01957145f, -0.05168704f, 0.09440139f, 0.14725880f, 0.10533962f, -0.04608539f, 
    0.01201233f, -0.13896424f, -0.12717670f, 0.03142065f, 0.16119580f, 0.04680910f, -0.11393255f, 0.16807425f, 
    0.08793958f, 0.08723170f, 0.12617834f, 0.03294541f, -0.11039940f, -0.02386796f, 0.13248624f, 0.38495401f, 
    0.24753407f, -0.16666575f, 0.04832339f, 0.33537149f, -0.05331205f, 0.15486839f, 0.38515311f, -0.07634576f, 
    -0.19823870f, -0.39036945f, -0.47355330f, -0.12392918f, -0.09318534f, -0.04242476f, -0.00672719f, -0.00676543f, 
    -0.04998776f, 0.25709257f, -0.74418175f, -0.57580882f, 0.01630216f, 0.04773157f, -0.34921488f, 0.25904876f, 
    0.09927773f, -0.17760129f, 0.07878651f, 0.21043998f, -0.26973376f, 0.07507534f, 0.12042280f, 0.17564040f, 
    0.09983778f, -0.00284015f, -0.07337463f, 0.04583333f, -0.36119267f, -0.10787533f, 0.02658590f, 0.07535766f, 
    -0.02139535f, 0.07354662f, -0.04126791f, -0.03131131f, 0.12350959f, 0.15453956f, 0.42225471f, -0.04569549f, 
    -0.01870511f, -0.01659253f, -0.03518380f, -0.17075092f, 0.15834461f, 0.23113827f, 0.11711235f, 0.12666965f, 
    0.13964488f, 0.12637901f, 0.06762833f, 0.25166100f, 0.05530858f, -0.03117854f, -0.07652454f, 0.16005699f, 
    -0.08789842f, 0.26228350f, 0.06036434f, -0.16465814f, -0.02550979f, 0.08356448f, 0.17387219f, -0.00092642f, 
    0.06875767f, -0.12116123f, -0.19849326f, -0.16766116f, -0.07925828f, -0.01955544f, -0.02683602f, 0.05066975f, 
    -0.19057733f, -0.01071383f, 0.11088184f, -0.02139868f, -0.14042100f, -0.13208938f, -0.13814336f, 0.14596862f, 
    0.25357202f, 0.01748202f, -0.04269644f, -0.02244639f, -0.01129402f, -0.01734160f, -0.03946574f, 0.08618242f, 
    0.01335589f, -0.05264906f, 0.09626672f, 0.01714680f, -0.12651509f, 0.01081044f, 0.13318798f, 0.30616683f, 
    -0.14694276f, -0.04369643f, 0.15192868f, -0.07201361f, 0.08046725f, -0.13147298f, 0.09069112f, 0.13068378f, 
    -0.01439777f, 0.06551473f, 0.01528852f, 0.01397226f, -0.14496671f, -0.04249906f, -0.00699745f, 0.15400483f, 
    0.06256494f, -0.10064983f, -0.02327581f, 0.00919829f, -0.00315703f, -1.02489686f, -0.14007749f, -0.10884917f, 
    -0.02831084f, 0.09742653f, 0.08994802f, -0.00028534f, -0.12293267f, -0.24204388f, 0.18991207f, -0.44615272f, 
    -0.65529954f, -0.06077051f, 0.01139249f, 0.20762908f, 0.08730071f, -0.02029543f, -0.00026435f, 0.00319108f, 
    0.06134931f, -0.17493205f, -0.11755445f, -0.27390453f, -0.08184224f, -0.01423311f, -0.03342857f, 0.06318492f, 
    -0.05880768f, 0.12244181f, 0.04632898f, -0.10857352f, -0.17244780f, -0.05702663f, 0.00225926f, 0.03533424f, 
    0.03855537f, -0.22650534f, -0.31515592f, 0.04192638f, -0.09002902f, -0.06755182f, -0.04560117f, 0.08678751f, 
    0.01821796f, 0.07992197f, -0.33849874f, -0.36985242f, -0.08175876f, -0.05145233f, 0.02706526f, -0.29570428f, 
    0.12128995f, 0.07467602f, 0.14910467f, 0.06798302f, 0.18025050f, -0.11212758f, 0.05383596f, 0.12555708f, 
    0.05462817f, 0.08209572f, 0.10843360f, -0.06317951f, -0.16958801f, 0.09454872f, -0.03889745f, 0.18862157f, 
    -0.06094561f, -0.07928764f, -0.01386873f, 0.19759989f, -0.08788736f, -0.03166726f, 0.32241607f, 0.02414653f, 
    -0.10076018f, 0.07377878f, 0.13068971f, 0.01934785f, 0.03874722f, -0.22051944f, 0.11735275f, 0.21603762f, 
    0.07898068f, -0.01416782f, -0.02674816f, 0.00374867f, -0.02354538f, -0.02284518f, -0.07932819f, 0.05764455f, 
    0.08500312f, 0.01537437f, -0.02199349f, 0.03578028f, 0.02792164f, 0.00307360f, 0.02936844f, -0.08243500f, 
    0.17463946f, -0.22876203f, -0.11986410f, -0.01745006f, 0.15387970f, 0.19871449f, -0.04053272f, -0.03439065f, 
    0.04437489f, 0.02210048f, -0.16132838f, -0.17339532f, 0.11072118f, -0.06201462f, 0.21459752f, -0.04149853f, 
    0.06744415f, 0.20451351f, -0.02446299f, -0.52499551f, 0.04558517f, -0.02933078f, 0.06558970f, 0.16330160f, 
    -0.02769051f, -0.04481544f, 0.00088773f, -0.62068748f, -0.52410918f, 0.01393282f, 0.08127252f, 0.12071998f, 
    -0.01253954f, 0.04113319f, 0.06259894f, -0.06003688f, -0.06400584f, -0.04931644f, -0.12696400f, -0.07249665f, 
    0.03354209f, -0.05907928f, 0.03697966f, -0.01712008f, 0.09653368f, -0.09500980f, -0.00934873f, -0.05881636f, 
    -0.05185622f, 0.00874012f, -0.06906950f, 0.05101806f, 0.01485129f, 0.36469936f, -0.02911279f, 0.14822210f, 
    0.04315499f, -0.00167385f, -0.23698612f, -0.04873578f, 0.01911329f, 0.00649343f, 0.24744160f, 0.19966185f, 
    0.03584963f, 0.51602840f, 0.08609735f, 0.08524613f, -0.00091752f, 0.06308702f, 0.24577433f, -0.11710673f, 
    -0.64052153f, 0.04463692f, -0.58132762f, -0.21586432f, -0.23062550f, -0.20196596f, -0.06113028f, -0.18725389f, 
    -0.05325811f, -0.03837541f, -0.50680196f, -0.58632481f, -0.29502052f, -0.28380913f, -0.36773553f, 0.01283355f, 
    0.11672176f, 0.08680129f, -0.23305456f, 0.09936714f, 0.12888290f, 0.08423547f, 0.03292697f, -0.05237300f, 
    0.03483415f, 0.13560762f, 0.04502559f, 0.20552891f, 0.09367453f, 0.03952923f, 0.05615089f, 0.05778686f, 
    -0.05232331f, -0.15345153f, -0.03010395f, -0.09666513f, 0.18280682f, 0.08590737f, -0.02625901f, -0.03936539f, 
    0.08538879f, 0.01343474f, 0.09878498f, -0.02662557f, 0.00138785f, -0.92622763f, 0.28483424f, -0.95998788f, 
    -0.15927541f, 0.17713794f, -0.25688377f, 0.02072414f, -0.04810036f, -0.11838999f, -0.19542086f, 0.23808670f, 
    0.03076928f, -0.05572826f, -0.03219009f, 0.00189958f, 0.18829946f, 0.08077812f, 0.13647299f, 0.22090721f, 
    0.08571756f, 0.15197209f, -0.09980283f, 0.11492620f, -0.02392346f, 0.10499915f, -0.08676886f, 0.04109283f, 
    0.12059887f, 0.14849053f, 0.23300007f, 0.02659286f, 0.07592821f, -0.08888409f, 0.06913728f, -0.05416657f, 
    0.19261090f, 0.10461878f, 0.12726170f, 0.07695174f, 0.02851417f, 0.03641316f, -0.06643733f, -0.07307710f, 
    -0.01642240f, -0.08014479f, 0.31097957f, -0.27994394f, -0.46230063f, -0.15247172f, 0.04295301f, 0.03961783f, 
    0.16079609f, 0.04348547f, 0.10837814f, -0.04154038f, 0.00998498f, -0.04330631f, -0.02174215f, -0.00594391f, 
    -0.09960469f, 0.01633423f, -0.04214228f, -0.13009526f, -0.01067641f, 0.00664176f, 0.03733026f, -0.09747396f, 
    0.01001959f, -0.16058764f, 0.00129498f, -0.13911287f, -0.05730744f, 0.20349519f, 0.41904244f, -0.67379558f, 
    0.02824185f, 0.13273796f, 0.16213776f, 0.04430963f, 0.05963071f, -0.13389249f, -0.58310258f, -0.06861197f, 
    -0.29517221f, -0.34539041f, -0.12388071f, -0.50277185f, -0.21138677f, 0.08759250f, -0.04631618f, 0.07177848f, 
    0.11001600f, 0.19992024f, -0.02465444f, -0.13110670f, -0.12606922f, -0.11035834f, 0.01185428f, -0.07629292f, 
    0.06299130f, 0.07787376f, 0.15697850f, -0.11890367f, -0.02240743f, -0.03319606f, -0.09499574f, -0.11751129f, 
    -0.09976006f, 0.02733862f, -0.73450631f, -1.74633956f, -0.21813549f, -0.02335642f, -0.16519567f, -0.03366831f, 
    0.05646816f, 0.04485535f, -0.44048771f, -0.57769585f, -0.70856774f, -0.15118393f, -0.07570873f, -0.02455847f, 
    0.03945161f, 0.08391220f, 0.18892705f, -0.41730541f, -0.06525146f, 0.10102355f, -0.12080533f, 0.02688997f, 
    -0.09194426f, -0.00083574f, 0.00341364f, -0.10212924f, 0.04832305f, 0.21420695f, 0.25624144f, 0.03132411f, 
    0.06292404f, 0.06879843f, 0.24628387f, 0.02913207f, -0.18533042f, -0.26409826f, 0.03008117f, 0.09972695f, 
    0.28533217f, 0.09883097f, 0.12304555f, 0.06773150f, 0.18626906f, 0.03363907f, 0.18321113f, 0.26385906f, 
    -0.29014885f, 0.02486507f, 0.21700135f, -0.03632735f, -0.10721340f, -0.19148360f, -0.02811267f, 0.01098712f, 
    0.03513362f, -0.05244522f, -0.00068133f, 0.10490032f, -0.03862716f, 0.01663125f, 0.00136268f, -0.19377893f, 
    0.07909009f, 0.06502453f, -0.04543903f, 0.02121769f, -0.04772643f, 0.00905879f, -0.22236136f, -0.09445546f, 
    -0.25723946f, -0.07600114f, -0.19161405f, -0.23069951f, -0.06674885f, -0.05949667f, -0.25066167f, -0.12110964f, 
    0.04819080f, -0.07008767f, 0.32848561f, -0.15055624f, -1.22301078f, 0.07871549f, 0.13010497f, -0.00637295f, 
    -0.02966641f, -0.03146406f, -0.00666961f, 0.34200528f, -0.11403592f, -0.50681347f, 0.19276078f, 0.16094197f, 
    0.23369123f, -0.11747808f, 0.04876072f, 0.01887492f, 0.07810981f, 0.06420141f, 0.13866447f, 0.02293183f, 
    -0.05080762f, -0.07741011f, -0.06297851f, 0.04425395f, -0.19000229f, 0.14180069f, 0.15897158f, 0.19590451f, 
    -0.10792682f, 0.09075914f, -0.06717230f, 0.00855657f, -0.03136824f, -0.08429076f, 0.09859695f, 0.14159761f, 
    0.19296390f, -0.01032023f, 0.03610291f, 0.03557587f, -0.00495908f, 0.25059506f, 0.43148279f, 0.59405833f, 
    0.11325213f, -0.08583479f, 0.02087336f, 0.15053622f, 0.00163115f, 0.34207955f, 0.22250442f, 0.48382872f, 
    0.10234740f, -0.34864524f, -0.18281181f, -0.27189857f, -0.11939646f, -0.10966133f, 0.12914801f, 0.21041182f, 
    0.10845906f, -0.18263923f, -0.18597144f, -0.05999628f, -0.20831597f, 0.12762773f, -0.02671830f, -0.03335744f, 
    0.19557455f, 0.19447733f, 0.19299531f, 0.17914046f, 0.20763233f, 0.16959892f, 0.20866643f, 0.12614393f, 
    0.01754182f, -0.11552932f, 0.26306671f, -0.10062038f, 0.10933172f, 0.10319021f, 0.08303254f, 0.19566433f, 
    0.09020787f, 0.10043047f, 0.04113900f, -0.12204819f, 0.04158487f, 0.09486960f, 0.15427674f, 0.08957653f, 
    -0.04168211f, -0.14878356f, 0.05125977f, 0.22046356f, 0.19536684f, -0.02424491f, -0.13087770f, 0.07044597f, 
    0.09631748f, -0.21595830f, 0.12016810f, 0.19685936f, -0.04294950f, 0.24193911f, 0.04516939f, 0.09544204f, 
    -0.00435624f, -0.31127313f, 0.19575618f, 0.08508771f, 0.17323567f, 0.00095311f, 0.05848220f, 0.06931100f, 
    0.14240554f, 0.04750015f, 0.12210850f, 0.18367797f, 0.03680504f, 0.07491916f, 0.01072541f, 0.20495290f, 
    -0.08801968f, 0.08718280f, 0.27512425f, 0.06615351f, 0.35778335f, 0.00000511f, 0.01694411f, 0.13987659f, 
    0.27254203f, 0.12516801f, 0.12650052f, 0.05396132f, -0.01881949f, -0.03700874f, 0.07288915f, 0.14891030f, 
    0.06046650f, 0.04845546f, -0.07048183f, -0.17761026f, 0.24942143f, -0.02316024f, -0.30988455f, 0.14297360f, 
    -0.07063345f, 0.35802025f, 0.51681411f, -0.10199068f, -0.00691091f, -0.02069141f, 0.02392339f, -0.04076213f, 
    -0.03623299f, -0.09971350f, 0.16281720f, -0.20072594f, -0.16118674f, 0.05279379f, 0.08344012f, 0.14182942f, 
    0.06455865f, -0.06130663f, -0.08469437f, -0.04815166f, -0.07946926f, 0.10983265f, -0.10082654f, 0.08952852f, 
    -0.11482753f, -0.10386632f, 0.15969719f, 0.06747802f, 0.29819882f, 0.14748470f, -0.24848674f, -0.23313269f, 
    -0.14858377f, -0.18501511f, -0.17864838f, 0.10285742f, -0.06332196f, 0.10317681f, 0.03375984f, 0.03224694f, 
    0.01685286f, -0.06268293f, 0.05693243f, 0.03646092f, 0.00541172f, 0.15119049f, 0.13568963f, -0.08312965f, 
    -0.03265575f, -0.18251453f, -0.10660361f, -0.01864492f, 0.00928174f, 0.05472967f, 0.22780666f, 0.17263463f, 
    0.29257825f, 0.01154205f, -0.20365831f, 0.03342738f, 0.10620125f, -0.11416999f, -0.19529532f, 0.03656519f, 
    0.09745006f, 0.03846633f, 0.04990048f, -0.00712668f, 0.07190565f, 0.02935392f, 0.07674515f, -0.11501230f, 
    -0.04060791f, 0.14676218f, 0.16955787f, -0.08259392f, 0.18845768f, 0.30343410f, -0.02977824f, 0.04321103f, 
    -0.03454985f, 0.00462192f, -0.25017655f, -0.14138763f, -0.02954765f, 0.36362797f, -0.25537011f, -0.05924688f, 
    0.09003113f, 0.10942529f, 0.30082878f, -0.03172568f, 0.08470625f, 0.09496649f, 0.14228399f, 0.08701278f, 
    0.05132724f, -0.11838178f, 0.04681800f, 0.11562547f, 0.02944990f, 0.13109243f, -0.20348009f, -0.07109277f, 
    -0.03557237f, 0.19779107f, 0.11716467f, -0.10654049f, 0.07355157f, -0.00304491f, -0.28144902f, -0.00320250f, 
    0.04168555f, 0.12266580f, 0.09159058f, 0.17455745f, -0.18234336f, 0.13729179f, -0.21180990f, 0.13767146f, 
    -0.17012542f, 0.02665274f, 0.03412852f, -0.07443112f, -0.08957877f, -0.20152086f, 0.15284808f, 0.02148035f, 
    -0.41145909f, -0.19228826f, 0.06985135f, -0.00941993f, -0.10632733f, 0.07063445f, 0.13014968f, -0.17910802f, 
    -0.00716976f, 0.17409763f, 0.02674132f, 0.10323287f, 0.26672807f, 0.22179219f, 0.32322019f, -0.10328918f, 
    -0.00538427f, 0.09280060f, 0.23541979f, 0.07478549f, 0.02120601f, 0.02072747f, 0.16943072f, 0.12749380f, 
    -0.01736905f, 0.02731835f, 0.09751584f, 0.03898318f, -0.01451387f, -0.16566321f, 0.07232699f, -0.03986825f, 
    0.14798135f, -0.01375865f, 0.08228556f, 0.05083435f, 0.03169055f, -0.27654317f, 0.13920899f, 0.06207930f, 
    -0.05143815f, -0.06289952f, 0.05633575f, 0.12021913f, 0.25283161f, 0.00647106f, 0.12750880f, 0.04771549f, 
    -0.05293385f, 0.03461322f, 0.13949195f, 0.05855568f, 0.21639493f, 0.13042584f, 0.07674447f, -0.00421626f, 
    0.10011698f, 0.13321868f, 0.01256130f, 0.06377348f, 0.34272575f, -0.16568162f, 0.39195746f, 0.52556717f, 
    0.36959594f, 0.04648221f, -0.37044227f, 0.19739716f, -0.03739442f, -0.01636694f, 0.13415121f, 0.14731553f, 
    0.09640069f, -0.30718124f, -0.04145394f, -0.17760356f, -0.02511537f, -0.02155368f, -0.13053668f, -0.21562102f, 
    -0.14512534f, -0.24846172f, 0.02716538f, -0.00411427f, 0.21323828f, 0.09723820f, 0.09948102f, 0.04899235f, 
    0.06051034f, 0.10606065f, 0.13191475f, -0.12443681f, 0.12215025f, 0.15806536f, 0.00964371f, 0.06384946f, 
    -0.00502606f, 0.06017544f, 0.12865703f, 0.12470347f, 0.01073649f, 0.01536905f, 0.25190422f, 0.13991953f, 
    0.10799821f, 0.04460445f, 0.17448483f, 0.19217223f, 0.21789515f, 0.45329693f, 0.20631485f, 0.28073394f, 
    0.12322373f, 0.12577772f, 0.20013297f, 0.13295403f, -0.09685542f, 0.32102254f, -0.02985358f, -0.17711979f, 
    -0.08015238f, 0.14122374f, 0.04615345f, 0.15558295f, -0.13160087f, -0.20039429f, -0.55035418f, 0.00525151f, 
    0.02213794f, 0.13302113f, 0.20632139f, -0.03928687f, -0.03191675f, -0.04421066f, -0.02083031f, -0.02799798f, 
    -0.01479016f, -0.00348936f, 0.05002076f, 0.00353251f, 0.02212422f, 0.11264808f, -0.03765952f, -0.37765902f, 
    -0.13854311f, -0.12035216f, -0.04516293f, 0.12254991f, -0.01750871f, 0.03014889f, -0.05431286f, -0.16322424f, 
    0.08811060f, 0.14948817f, 0.05718816f, -0.14576709f, -0.03471955f, 0.16209070f, -0.09913372f, -0.12119298f, 
    -0.37049305f, -0.10865232f, 0.14051117f, -0.09164260f, 0.04085488f, 0.05665866f, 0.01913503f, -0.11365701f, 
    -0.05459941f, 0.11874948f, 0.35100821f, 0.09016999f, 0.04249586f, -0.00402434f, 0.15802108f, 0.11644046f, 
    -0.10607160f, -0.03802701f, -0.05721638f, 0.20483837f, 0.09479418f, 0.26102811f, 0.63244689f, 0.63003445f, 
    0.07502509f, 0.12677164f, 0.16548584f, -0.07107781f, 0.12708198f, 0.13256407f, -0.04733973f, 0.04433611f, 
    -0.11920767f, -0.00655409f, -0.04031402f, -0.21395431f, -0.09180254f, -0.18569759f, 0.05938686f, -0.07020596f, 
    -0.11150470f, -0.17099476f, 0.23057464f, -0.02798291f, 0.03702642f, -0.11897478f, -0.08575968f, -0.11573648f, 
    -0.06972837f, -0.04986695f, -0.04235044f, 0.20599066f, 0.08759273f, 0.14975452f, -0.06878377f, -0.03318897f, 
    -0.25715548f, 0.15005474f, -0.21981893f, -0.48819831f, 0.04550281f, 0.00907833f, 0.13560191f, 0.04181161f, 
    0.03918657f, -0.11156096f, -0.08650369f, 0.07065775f, -0.17395726f, -0.02101148f, -0.10382921f, -0.01148221f, 
    -0.11295682f, -0.07128491f, -0.20608620f, 0.11695977f, -0.08041649f, -0.04570125f, -0.10561891f, -0.00875125f, 
    -0.09866630f, 0.07219307f, 0.10422812f, 0.11674514f, 0.19911362f, -0.03077259f, 0.41794750f, 0.21085051f, 
    0.07440192f, 0.20016873f, 0.19015907f, 0.21176258f, 0.10952242f, 0.10852432f, 0.20494786f, 0.28717434f, 
    0.16412079f, -0.11255214f, 0.10055976f, 0.21550231f, 0.07151064f, 0.15534785f, 0.10675015f, 0.01521394f, 
    -0.10814315f, -0.11698408f, -0.12753972f, -0.09691365f, 0.25186595f, 0.24611780f, 0.07906909f, -0.07892836f, 
    0.05241680f, 0.06139683f, -0.12043053f, 0.02826455f, 0.04716193f, 0.15205741f, 0.36314380f, 0.23260139f, 
    -0.04530153f, 0.02091610f, 0.19797534f, 0.21135955f, -0.07890765f, -0.04726370f, -0.01127520f, 0.11887629f, 
    0.21657671f, 0.09591760f, -0.10259806f, -0.14275837f, 0.23007101f, 0.14952601f, -0.03347342f, -0.27441999f, 
    -0.42582744f, -0.10365114f, 0.00980540f, -0.16426899f, 0.10083089f, 0.00863777f, -0.01801996f, -0.01533308f, 
    0.08063463f, -0.02864518f, 0.05761250f, 0.03706897f, 0.01571709f, -0.10134577f, -0.06023920f, -0.04168877f, 
    0.06334991f, 0.07245203f, 0.10537361f, 0.01900415f, 0.08926535f, -0.03656540f, 0.10778990f, 0.06923994f, 
    0.09924918f, 0.09500416f, -0.00374642f, -0.23001327f, -0.09236865f, -0.12734759f, -0.09355479f, 0.07436126f, 
    -0.08629887f, 0.00871093f, 0.00166239f, -0.06190932f, -0.19008368f, -0.25996727f, 0.02480428f, -0.02508153f, 
    -0.07856110f, 0.16160558f, 0.17520992f, 0.18732601f, -0.14763641f, -0.36608043f, -0.41156274f, 0.16068767f, 
    -0.08784458f, 0.32542118f, 0.12647393f, 0.16349927f, 0.29057717f, -0.07113652f, -0.14652973f, -0.12154459f, 
    -0.17722039f, -0.25353792f, -0.43508637f, 0.04262554f, -0.19926654f, 0.00537540f, 0.00336818f, 0.12084656f, 
    -0.07159648f, -0.05654727f, -0.15278928f, 0.18613143f, 0.03010933f, -0.09517813f, 0.03925324f, 0.12230729f, 
    0.19465075f, -0.05965519f, 0.12869900f, 0.01515570f, -0.15591037f, 0.22757678f, 0.15756133f, 0.11596940f, 
    -0.01623412f, 0.06216629f, 0.07714185f, -0.14420365f, -0.08382911f, 0.00996732f, -0.01717548f, 0.01666318f, 
    -0.00664647f, -0.06938171f, 0.10438464f, 0.25612175f, -0.58480048f, -0.03744630f, 0.24349998f, 0.04025962f, 
    0.20638047f, -0.25794724f, 0.34481502f, -0.15226272f, 0.15898313f, 0.09145756f, 0.19428663f, 0.04175670f, 
    -0.05111613f, -0.02102605f, 0.07896504f, 0.22692642f, -0.02177737f, 0.04038551f, 0.24938436f, 0.05448914f, 
    -0.09837902f, 0.01736172f, -0.09410733f, -0.12082218f, 0.19053659f, 0.14944312f, -0.25601977f, 0.17260543f, 
    0.11248824f, -0.14274587f, 0.13066798f, -0.05499773f, 0.02110462f, 0.04462659f, -0.03445818f, -0.04974706f, 
    -0.23475623f, 0.15390305f, 0.21796519f, -0.11912023f, -0.11669420f, -0.17692828f, 0.04102696f, 0.13241707f, 
    -0.22846161f, -0.16300586f, -0.07082328f, 0.05472163f, -0.09881295f, 0.01426019f, -0.06007514f, 0.06448159f, 
    0.15591511f, 0.25656718f, 0.20324832f, -0.00998554f, 0.17489067f, 0.09653075f, -0.02563391f, 0.02664579f, 
    -0.07870669f, 0.14479181f, -0.33633658f, -0.10950062f, -0.01188094f, -0.12447722f, 0.01432909f, 0.06679828f, 
    -0.13965836f, 0.12381068f, 0.13098198f, 0.20609756f, -0.14869148f, -0.01297240f, -0.21140796f, 0.25474408f, 
    0.17689976f, -0.20528387f, 0.04802364f, 0.10467242f, 0.22195663f, -0.01580715f, 0.05097846f, 0.15233082f, 
    0.27139848f, -0.01073880f, 0.02414255f, -0.04779505f, 0.07553218f, -0.06092528f, -0.13489380f, -0.23602249f, 
    0.08373903f, 0.06274863f, -0.06020041f, 0.02955364f, -0.09789060f, -0.13569137f, -0.02457164f, -0.19944450f, 
    0.04250196f, -0.04201337f, -0.02052563f, -0.08678614f, -0.17676590f, -0.01682872f, -0.10669083f, 0.05054453f, 
    -0.20193955f, 0.11979968f, -0.01357396f, -0.19772300f, 0.10078976f, -0.02772791f, 0.08470692f, 0.12888648f, 
    0.13033803f, -0.19739617f, -0.28170070f, 0.10932142f, 0.05858484f, -0.05321254f, -0.04911916f, 0.15010211f, 
    0.13836667f, 0.08574239f, 0.01328127f, -0.17115007f, 0.08848949f, -0.00923138f, -0.03392641f, -0.02424278f, 
    -0.01388722f, 0.22900791f, 0.06974159f, -0.26057395f, -0.31337261f, -0.00571830f, 0.31584936f, 0.03337677f, 
    -0.10679605f, -0.04464290f, -0.03560812f, 0.13009365f, 0.30677336f, 0.09829280f, -0.46459398f, 0.06766559f, 
    -0.06985416f, 0.19953829f, 0.27148575f, -0.09578229f, 0.01692142f, -0.02474498f, 0.25220409f, -0.17652088f, 
    -0.07602553f, 0.10373463f, 0.18985175f, 0.10278302f, 0.13107365f, 0.29272532f, -0.08805268f, -0.21892405f, 
    0.12189569f, -0.01634205f, 0.08298501f, 0.02471475f, 0.00926622f, 0.03287574f, 0.16399710f, -0.02502356f, 
    0.11854027f, -0.01431183f, -0.15931553f, 0.08335048f, 0.12621027f, 0.09705090f, 0.24272881f, 0.34124070f, 
    -0.17205176f, -0.37554750f, -0.13686420f, -0.19344819f, -0.10486396f, -0.01227249f, 0.03725365f, -0.08431072f, 
    0.27439651f, 0.04988355f, 0.12493274f, 0.24552618f, 0.04770272f, -0.05396120f, -0.08991871f, -0.17979045f, 
    -0.02584972f, 0.01205442f, -0.03606180f, -0.18486053f, 0.31814283f, 0.21349931f, 0.07991010f, 0.11378500f, 
    0.18833882f, 0.12020412f, -0.04921335f, 0.00193276f, -0.08821613f, 0.10349321f, 0.17425242f, 0.17989463f, 
    0.11497721f, 0.07708481f, 0.05716303f, 0.19634517f, -0.15464705f, -0.07073089f, -0.03194073f, -0.04286759f, 
    -0.13675542f, -0.11185640f, -0.11968292f, 0.15688062f, -0.03556151f, -0.23177363f, 0.04795588f, -0.14897469f, 
    -0.25709340f, -0.20998277f, -0.28199288f, -0.20888446f, -0.12769285f, -0.01302549f, 0.10839138f, 0.05427497f, 
    0.01222941f, -0.16519451f, 0.13038261f, -0.08014581f, 0.08888187f, -0.23643775f, -0.25924337f, -0.39498782f, 
    -0.03739271f, 0.56630456f, 0.09358327f, 0.28913650f, -0.20422465f, 0.11320091f, 0.15928732f, 0.07152372f, 
    -0.04206550f, 0.02034762f, -0.06442288f, -0.05153229f, -0.00579643f, 0.02756973f, 0.01218017f, -0.04497572f, 
    -0.00616682f, 0.01292946f, -0.04544728f, -0.02105497f, -0.03281461f, -0.03568940f, 0.02031903f, 0.03401840f, 
    -0.01013190f, 0.00851875f, -0.00677184f, -0.02244353f, 0.02785951f, 0.01389325f, 0.00835781f, 0.03337756f, 
    -0.04704252f, -0.02417610f, -0.01561465f, 0.03210322f, -0.05342352f, 0.04818702f, 0.02287301f, 0.05001640f, 
    0.04641887f, 0.00289393f, -0.01178726f, -0.03651683f, -0.01978171f, -0.03440243f, -0.00173350f, 0.04589243f, 
    -0.04946864f, 0.00489480f, 0.03533961f, -0.03661053f, 0.02781238f, -0.06116359f, -0.05821755f, -0.03533630f, 
    -0.02752446f, 0.04006304f, 0.04781998f, -0.00250035f, -0.05712851f, -0.05164590f, -0.06182977f, 0.04651143f, 
    -0.02871644f, -0.01176476f, -0.00196052f, 0.04077143f, -0.02827940f, -0.01631865f, 0.04193958f, -0.03877269f, 
    -0.05374436f, -0.02496405f, -0.04506136f, 0.01544423f, -0.06059690f, -0.01012488f, -0.01793947f, 0.03465485f, 
    0.03481809f, -0.06481367f, -0.05980235f, -0.00009217f, 0.04826171f, 0.02603708f, 0.04885893f, -0.05151853f, 
    0.04950140f, -0.03820153f, 0.03008308f, -0.05724426f, -0.03891768f, -0.00627523f, 0.01182788f, -0.05354751f, 
    0.03972689f, -0.01020434f, -0.05222073f, 0.03262348f, -0.02368926f, -0.00958012f, -0.02168883f, 0.01759577f, 
    -0.00562718f, -0.01434625f, 0.00127656f, -0.06868222f, 0.03995721f, 0.02338045f, -0.01695126f, -0.06384936f, 
    -0.04758171f, -0.05022208f, 0.02733877f, 0.00241202f, -0.04154354f, 0.02388838f, -0.06186600f, -0.05449244f, 
    -0.06932636f, 0.00881842f, 0.03272737f, 0.03221698f, 0.03654959f, 0.02790806f, -0.05736011f, -0.00340103f, 
    0.03268492f, -0.01873856f, 0.01169106f, 0.01454100f, -0.01622044f, -0.06541636f, -0.02392416f, -0.03270114f, 
    0.03697374f, 0.04569190f, -0.03647227f, -0.05079887f, 0.00030258f, -0.05771451f, -0.01277857f, -0.02076812f, 
    -0.04005000f, -0.04440641f, -0.02447207f, 0.02228978f, -0.05555966f, -0.02684109f, 0.01797606f, -0.00533157f, 
    -0.04349717f, -0.03669713f, 0.00319142f, -0.05994730f, -0.05949180f, 0.04126461f, 0.01630481f, 0.03596636f, 
    0.03800298f, 0.00832603f, -0.01243367f, -0.00784582f, 0.05122441f, -0.02610819f, 0.00523076f, -0.03052144f, 
    0.01289063f, -0.00470736f, 0.00933076f, -0.02894870f, -0.04375595f, -0.04783110f, 0.04671086f, 0.01949980f, 
    -0.01028014f, -0.06317626f, 0.02122081f, 0.01943389f, 0.03907757f, 0.00755918f, 0.05236544f, -0.06196387f, 
    -0.05916760f, 0.02057640f, 0.02684692f, 0.03009645f, -0.06224021f, 0.01598990f, -0.01847821f, 0.00475744f, 
    -0.01541496f, -0.00116750f, 0.02121084f, -0.03029314f, 0.05050396f, 0.03979839f, -0.06035855f, -0.00827075f, 
    0.03385732f, 0.00555169f, -0.00226626f, -0.00680909f, 0.05085904f, -0.05637655f, 0.05043439f, 0.03535941f, 
    0.02513071f, 0.03054415f, 0.01258981f, 0.03252933f, 0.03820556f, -0.06384000f, -0.00207962f, -0.00222202f, 
    0.02502842f, -0.05002717f, -0.04343944f, -0.02932802f, -0.02117897f, -0.05742869f, -0.05929329f, 0.03520652f, 
    -0.00301932f, 0.01402463f, -0.00295883f, 0.02619607f, -0.01233778f, 0.01431487f, 0.03583731f, -0.05243666f, 
    0.01325968f, -0.01164354f, 0.03271522f, 0.00681056f, -0.05574329f, -0.00101936f, -0.04124737f, -0.04810076f, 
    0.02709593f, 0.01794741f, 0.02749960f, -0.06571311f, -0.00839754f, -0.04035243f, 0.01299005f, -0.06427475f, 
    0.03438993f, -0.02977200f, 0.03771593f, -0.04361507f, 0.01894551f, 0.02614926f, 0.04776864f, 0.01859236f, 
    -0.02873005f, -0.05066907f, -0.01911873f, -0.06541646f, 0.03191686f, -0.03976324f, -0.01625427f, -0.04220285f, 
    -0.04278895f, -0.01197394f, -0.01418000f, -0.02028526f, -0.02812783f, -0.02570261f, -0.01668907f, -0.00387920f, 
    0.00219950f, -0.00956324f, -0.01229224f, -0.05682881f, -0.05914700f, -0.06165678f, -0.00591576f, 0.00748171f, 
    0.02479550f, -0.03516780f, -0.04130007f, -0.00311399f, 0.00580390f, -0.01665822f, 0.00587116f, 0.00010809f, 
    0.03357603f, -0.02916192f, 0.01357355f, 0.03893821f, -0.01589688f, -0.04099370f, -0.04356134f, 0.02607580f, 
    0.33277902f, -0.16405642f, 0.26622808f, 0.18126333f, 0.05652903f, 0.09883284f, 0.19949801f, -0.07315813f, 
    0.18023393f, -0.35981908f, 0.04573329f, 0.07971995f, -0.01391538f, 0.01262267f, 0.00446572f, -0.16218595f, 
    -0.20597251f, -0.29263610f, -0.04569012f, 0.02971018f, -0.07682039f, -0.05450628f, 0.01711281f, -0.01708513f, 
    0.12342060f, -0.02415925f, -0.00679342f, 0.16382137f, -0.15815057f, -0.56786609f, 0.13860817f, -0.03885079f, 
    -0.03412479f, -0.20792298f, -0.02859315f, 0.12339357f, 0.00526058f, -0.07110272f, 0.04422366f, -0.05222307f, 
    -0.20476091f, -0.02029617f, 0.01202487f, 0.14029978f, -0.11368483f, 0.21540670f, -0.01301550f, 0.11935506f, 
    -0.07630964f, 0.19364785f, -0.11961900f, -0.13612950f, -0.10959300f, -0.08354250f, -0.01108683f, -0.36274502f, 
    0.02832567f, 0.09473856f, 0.06191972f, 0.03727607f, -0.06352954f, 0.18327133f, -0.15603559f, -0.13806358f, 
    -0.04796249f, 0.09320045f, 0.04056358f, 0.06543069f, 0.06833375f, 0.01041508f, -0.12106325f, -0.11225148f, 
    0.07345051f, -0.43439963f, -0.08750187f, 0.14829546f, 0.13474105f, -0.14173821f, -0.16915320f, -0.21782580f, 
    -0.33445609f, 0.02320662f, 0.24976896f, -0.02351358f, 0.00794771f, -0.10631938f, -0.07908932f, -0.04918988f, 
    0.14103456f, -0.01218599f, 0.01265146f, -0.04898620f, -0.13213155f, 0.18174590f, -0.03985126f, -0.15068193f, 
    -0.04718778f, -0.36714813f, 0.00507429f, 0.02326922f, 0.01975689f, 0.02716218f, 0.02719909f, -0.38028610f, 
    0.04919749f, 0.04935275f, 0.32643291f, 0.08213842f, 0.03373858f, 0.01636579f, 0.05205288f, 0.06951322f, 
    -0.14183593f, -0.05898473f, -0.07943013f, 0.22297037f, 0.03274209f, 0.52196741f, 0.05946507f, -0.29045469f, 
    0.01972560f, 0.02479942f, 0.14649205f, 0.14197537f, 0.04168147f, 0.15617597f, -0.10768834f, 0.05597068f, 
    -0.15510556f, 0.06760543f, 0.04046296f, -0.02103139f, -0.07064407f, -0.08100801f, -0.07018647f, 0.21714400f, 
    0.14450255f, 0.07754293f, 0.12299999f, 0.01739371f, 0.00127363f, -0.03269213f, -0.08752611f, -0.10909528f, 
    0.11858574f, 0.10910001f, 0.07465203f, 0.21802664f, 0.04665599f, 0.08782699f, -0.16887437f, -0.10263454f, 
    -0.20940274f, 0.43975496f, 0.22770517f, 0.31125632f, 0.06850968f, -0.00580128f, 0.12167896f, 0.13300565f, 
    0.00772505f, -0.15316065f, 0.08544793f, 0.25564584f, 0.20269680f, -0.07464444f, -0.01254117f, -0.09064557f, 
    0.12109961f, 0.04186413f, -0.07851349f, 0.12840688f, 0.21769592f, 0.06345687f, -0.12390976f, -0.27179983f, 
    0.21435195f, 0.09197988f, 0.10295512f, 0.11454388f, -0.08972587f, -0.23730907f, -0.13025481f, 0.24418564f, 
    0.00351295f, 0.09783740f, -0.13537765f, -0.15871304f, -0.11938394f, 0.13599350f, 0.01925512f, 0.14980951f, 
    0.09598101f, 0.07034255f, -0.01052330f, 0.12899572f, 0.19423003f, 0.05350693f, 0.09536421f, -0.17273945f, 
    -0.07324935f, -0.08405559f, -0.00414726f, 0.05510769f, 0.16355163f, 0.24485043f, 0.01337913f, -0.18664327f, 
    -0.13072057f, -0.03722755f, 0.08747893f, -0.19278717f, 0.03089767f, 0.07909904f, 0.18947427f, 0.10368466f, 
    0.18226258f, 0.34354100f, -0.21576013f, 0.20648329f, -0.10681666f, 0.03457630f, -0.03517296f, 0.16341963f, 
    0.07726559f, -0.20727411f, -0.15744425f, -0.15516959f, 0.02512146f, 0.05556129f, -0.05947288f, 0.01445071f, 
    -0.24979348f, -0.11466417f, 0.15339243f, 0.05915608f, -0.16121814f, 0.29080251f, 0.03889882f, 0.18470204f, 
    0.14120905f, 0.09762683f, -0.08878233f, -0.03077203f, 0.06802365f, 0.01069726f, 0.10695445f, 0.01306360f, 
    -0.01968705f, -0.01416368f, 0.15210697f, 0.03762489f, 0.33497107f, -0.01602747f, -0.06511644f, -0.01487149f, 
    -0.09368125f, 0.13797779f, -0.26698425f, -0.09144796f, -0.38645148f, 0.41022477f, -0.16880827f, -0.21383294f, 
    0.15710242f, -0.03403904f, 0.14117526f, -0.07977428f, 0.05660414f, -0.37586895f, -0.09071808f, -0.10161178f, 
    0.14122233f, -0.02863063f, 0.06491879f, -0.13086592f, -0.04804128f, -0.37850794f, -0.25691190f, 0.23027703f, 
    0.05288311f, -0.09234982f, 0.34906369f, -0.16823263f, 0.08753549f, 0.08240138f, -0.08540352f, -0.28337923f, 
    0.34568027f, 0.14442307f, -0.14501184f, 0.03093586f, 0.06946281f, -0.23201767f, -0.05796461f, 0.04733329f, 
    -0.12424013f, 0.11339428f, -0.01294066f, -0.10862146f, 0.04724715f, 0.04722294f, 0.07767168f, -0.02174165f, 
    0.05751562f, -0.17858225f, 0.03298974f, -0.19949408f, 0.12542078f, 0.11070076f, 0.03441430f, -0.10682370f, 
    -0.06211302f, 0.07695740f, 0.10868241f, -0.23888677f, -0.13507633f, 0.01621209f, 0.09937292f, -0.01758349f, 
    0.05671344f, 0.13452820f, 0.14178854f, -0.09495120f, -0.18199253f, 0.07844584f, -0.06582937f, 0.04207884f, 
    -0.06552150f, -0.20443039f, 0.16783820f, -0.04493809f, -0.16096382f, -0.00656856f, -0.00865012f, -0.20146120f, 
    0.03271927f, -0.40613869f, 0.35543433f, 0.14351362f, -0.25157639f, -0.13705467f, 0.13024151f, 0.17842564f, 
    -0.04994003f, -0.08080617f, -0.07458226f, -0.14614506f, -0.05411879f, 0.24700512f, 0.03707701f, 0.27709538f, 
    0.07886484f, 0.06149339f, -0.01845430f, 0.11025500f, -0.13429238f, 0.03407208f, -0.05238711f, -0.03284250f, 
    0.09796312f, 0.19579691f, 0.02881780f, 0.05970045f, 0.09540598f, 0.14025870f, 0.08398322f, -0.16938147f, 
    0.05054866f, -0.03234317f, -0.02227996f, -0.03453219f, 0.14424631f, -0.04313153f, 0.05329433f, 0.08595800f, 
    -0.01710891f, 0.00098758f, 0.11809420f, 0.02042976f, -0.10220490f, -0.12462209f, -0.05435489f, -0.20533223f, 
    0.09486365f, -0.10341490f, -0.15460932f, 0.00652347f, -0.04007447f, 0.08435203f, 0.00559389f, 0.09051597f, 
    0.00097370f, 0.21045634f, -0.22712880f, 0.05815141f, 0.17879398f, 0.04683466f, 0.06374409f, -0.09380938f, 
    0.10791416f, -0.00429214f, 0.32809508f, -0.21048349f, -0.10127902f, 0.38260359f, -0.14101069f, -0.19103070f, 
    0.20304906f, 0.01969445f, -0.03399700f, 0.12121574f, 0.06030055f, -0.18515614f, -0.04167396f, -0.19248007f, 
    0.15394621f, 0.17423938f, 0.06018013f, 0.00986810f, -0.06120157f, 0.04063021f, 0.06716716f, 0.11619453f, 
    0.08811378f, 0.12859549f, 0.03354354f, 0.01142653f, 0.07350470f, -0.07748948f, -0.19099957f, -0.12053198f, 
    0.06182753f, -0.15558413f, 0.07198703f, 0.03286232f, 0.09489011f, 0.03127495f, 0.10408776f, -0.13164234f, 
    -0.32842433f, 0.18676850f, 0.03437865f, -0.00739341f, 0.05859339f, -0.14576136f, 0.11697298f, 0.02016063f, 
    -0.12769692f, -0.13647269f, 0.33845228f, 0.17236930f, 0.06659588f, 0.22813055f, 0.01143020f, 0.04797472f, 
    0.02913569f, 0.13198888f, 0.01117582f, 0.22816813f, -0.17889468f, 0.06658369f, 0.15304762f, 0.16649295f, 
    -0.18635723f, 0.11092219f, -0.13886231f, 0.17036827f, 0.39959964f, 0.16927268f, -0.35583675f, 0.01290845f, 
    -0.13599642f, -0.26119703f, 0.00890284f, -0.15189455f, 0.19897915f, 0.09189322f, -0.09259877f, -0.07529797f, 
    -0.11466651f, -0.05266659f, -0.22608839f, 0.05979868f, -0.12117665f, -0.10646522f, 0.36575934f, 0.12604097f, 
    0.03589762f, 0.03651536f, -0.03015114f, 0.09573624f, 0.20249476f, -0.12501106f, 0.00567950f, 0.04101126f, 
    0.06883973f, 0.04756682f, -0.04470706f, 0.11350878f, 0.10723169f, -0.01462360f, -0.00710758f, 0.07492673f, 
    -0.03667314f, -0.06931852f, -0.23372801f, -0.02406012f, -0.03719441f, 0.02201330f, 0.24972391f, -0.01474434f, 
    -0.10749923f, 0.20565242f, 0.04436675f, 0.17136779f, 0.04138268f, -0.05187279f, -0.24478135f, 0.09471542f, 
    -0.11720774f, -0.04304085f, -0.03777854f, 0.32041305f, 0.04475847f, -0.08441104f, 0.16615516f, -0.02217796f, 
    -0.04291296f, 0.02721007f, 0.00956576f, 0.14238907f, 0.35768270f, -0.01510283f, 0.09892838f, 0.04087335f, 
    0.14688750f, 0.15542087f, 0.09758788f, -0.16584136f, -0.24837314f, -0.13256061f, -0.30625999f, 0.09514800f, 
    0.03359087f, 0.11885498f, 0.05428916f, 0.10849610f, -0.02357672f, -0.44689929f, -0.28354171f, -0.07785800f, 
    0.11621886f, 0.11627722f, 0.06570770f, -0.04399829f, 0.15201867f, -0.02822265f, 0.02582761f, -0.02982429f, 
    -0.09340908f, -0.13686951f, -0.03872273f, 0.01803240f, -0.02718049f, 0.06146128f, -0.08215719f, -0.36069375f, 
    0.08929104f, -0.19489916f, -0.17883646f, -0.05845235f, -0.09915636f, 0.10749683f, 0.20973642f, -0.09470966f, 
    0.61402553f, -0.42845070f, 0.11086108f, 0.18523060f, 0.11709715f, -0.11086257f, -0.01342136f, 0.04716631f, 
    0.08184782f, -0.51341283f, 0.01587219f, 0.23447789f, -0.02159225f, -0.02240418f, 0.09173907f, -0.07313473f, 
    0.03331167f, 0.06847691f, -0.04802198f, 0.18288149f, -0.23725806f, 0.01746300f, -0.10348050f, 0.05763994f, 
    -0.02641608f, 0.01747796f, 0.04272365f, -0.09132256f, -0.17221217f, -0.26513466f, 0.19527429f, -0.13203797f, 
    -0.10028809f, -0.01864197f, -0.01344020f, 0.07257468f, -0.02440073f, -0.18616848f, -0.08135816f, -0.27115643f, 
    -0.04615485f, 0.29539582f, 0.08807283f, 0.22295626f, -0.27956474f, -0.03033540f, 0.23004583f, -0.21205561f, 
    0.09881429f, 0.13982315f, 0.02289935f, 0.07166516f, 0.01846080f, -0.00308329f, 0.62739122f, -0.17532282f, 
    0.14938767f, 0.03052288f, -0.13477242f, -0.24694793f, -0.18325883f, 0.07965194f, 0.00062586f, -0.06361170f, 
    0.21854131f, 0.08717810f, 0.04051817f, -0.17330098f, -0.04873650f, 0.11517729f, -0.08455906f, -0.10016415f, 
    0.02135205f, -0.17618108f, 0.05009314f, -0.01624314f, -0.01540963f, -0.06419422f, 0.17073920f, -0.04794870f, 
    0.06380110f, -0.06634259f, -0.11037134f, -0.10983609f, 0.14911528f, 0.09164207f, 0.03895253f, 0.06445637f, 
    -0.03953483f, -0.23299958f, 0.06277728f, 0.46947324f, -0.14483495f, -0.23472811f, 0.05575357f, 0.00554606f, 
    -0.02571442f, 0.14614949f, -0.14015773f, 0.07471199f, 0.01079190f, 0.02424454f, 0.04647353f, 0.03036109f, 
    0.05873996f, -0.02730251f, -0.17813769f, -0.53998804f, 0.16435020f, -0.01030456f, 0.03139722f, 0.06522521f, 
    -0.03835784f, 0.00266676f, 0.29219550f, 0.01106089f, -0.15465651f, 0.56359798f, 0.18945566f, -0.40667540f, 
    0.11699168f, -0.07259424f, -0.32828951f, 0.19408058f, 0.06841283f, 0.13303687f, -0.49333817f, -0.12085111f, 
    -0.29271248f, 0.32629505f, 0.03004068f, 0.13339533f, 0.08806766f, -0.03092722f, 0.22954299f, 0.07917367f, 
    -0.05836285f, -0.10582287f, 0.11630145f, 0.01346074f, 0.07812376f, -0.18768647f, -0.02037978f, 0.11561638f, 
    0.04109233f, 0.20110117f, -0.17203778f, 0.18065065f, 0.01400829f, 0.06796364f, -0.02258217f, -0.25874087f, 
    0.26781097f, 0.07632725f, 0.10259161f, 0.59206682f, 0.07581739f, 0.07028180f, 0.12529178f, -0.01229033f, 
    -0.00374908f, -0.06874971f, -0.22223009f, 0.09239795f, 0.42991596f, -0.07498508f, 0.03922376f, 0.18823992f, 
    -0.06800321f, 0.05299891f, 0.05360971f, -0.46460813f, -0.13870417f, 0.21889530f, 0.17865181f, -0.03169622f, 
    0.12449780f, -0.03134679f, 0.01265683f, 0.09440989f, -0.18390131f, -0.17701611f, -0.34853917f, 0.04038535f, 
    -0.15109603f, -0.20902458f, -0.00757308f, 0.28969336f, -0.04958039f, -0.03683234f, 0.08296481f, -0.03712827f, 
    -0.38507357f, -0.12348647f, 0.12757692f, -0.27987745f, 0.03730714f, -0.16640902f, 0.38966998f, -0.14803082f, 
    -0.01164333f, 0.16972946f, 0.04748957f, -0.03479389f, 0.05945265f, -0.04865606f, -0.27195838f, -0.06263214f, 
    0.01087879f, -0.01790038f, -0.05058957f, -0.03716866f, 0.00256163f, -0.23063476f, -0.09570231f, -0.35062724f, 
    0.17815799f, 0.24298456f, -0.16035876f, 0.30374211f, 0.07913532f, -0.20744722f, -0.25988585f, 0.03089464f, 
    -0.08081967f, -0.23067202f, 0.16819212f, -0.40173599f, 0.05117819f, 0.11614193f, 0.12842865f, 0.08772654f, 
    0.17370827f, 0.35779798f, 0.05038892f, 0.34331793f, 0.15922521f, 0.27420253f, 0.11712246f, -0.17893781f, 
    -0.05768298f, -0.08516822f, -0.26918137f, 0.36652634f, 0.14793760f, -0.10736752f, -0.15037765f, -0.11416326f, 
    -0.09088284f, 0.01570805f, -0.08782500f, -0.13215038f, 0.21927342f, -0.25678319f, -0.36834729f, 0.09636986f, 
    0.05816532f, -0.06361052f, 0.11918751f, 0.03871610f, -0.00507164f, 0.15903108f, -0.28157815f, -0.03128413f, 
    0.06980990f, 0.17487362f, 0.01755355f, 0.12143400f, 0.06024234f, 0.04427006f, -0.22831282f, -0.05370939f, 
    -0.17766936f, 0.11329964f, 0.05481320f, -0.12989333f, -0.12123590f, -0.25228783f, 0.15458922f, -0.23799773f, 
    0.48474315f, -0.08154120f, 0.20227167f, 0.04465917f, -0.13470335f, 0.11009627f, -0.16687122f, 0.08548375f, 
    -0.37777746f, 0.18969107f, 0.26814085f, -0.05030069f, -0.18303654f, -0.30971122f, 0.09806564f, -0.06599271f, 
    0.17069739f, -0.03020695f, 0.03575473f, 0.10171128f, 0.02574461f, 0.04331240f, 0.00841633f, 0.10469760f, 
    -0.01920673f, -0.12464461f, -0.17424887f, -0.07956648f, -0.01022694f, -0.01977731f, 0.09347764f, 0.27863637f, 
    -0.15379508f, 0.08141465f, 0.11596078f, 0.02952112f, 0.00493809f, 0.12204355f, -0.12036340f, -0.21269922f, 
    0.00943560f, 0.15715912f, 0.18080261f, 0.05207435f, 0.16275105f, 0.12598562f, 0.02160603f, -0.14779477f, 
    -0.17225972f, -0.01394799f, 0.04319834f, 0.20522209f, 0.13144445f, -0.54511976f, 0.32406971f, 0.48091397f, 
    -0.03476956f, -0.11747351f, 0.16647734f, -0.01879756f, 0.06879077f, 0.35383621f, -0.34995216f, -0.13332157f, 
    0.07181098f, -0.01581887f, -0.02318782f, 0.07432911f, -0.01383560f, 0.01596290f, -0.03796905f, 0.06868865f, 
    -0.18700966f, 0.06246453f, -0.02077123f, 0.06936788f, 0.04116498f, -0.17091438f, -0.00294441f, 0.05179136f, 
    -0.00524088f, -0.17314602f, 0.17078291f, 0.00076176f, -0.28119966f, -0.25609422f, 0.10970767f, -0.05723672f, 
    -0.04457679f, 0.11002433f, 0.05225072f, 0.11782267f, -0.22506998f, -0.02416600f, 0.07923184f, 0.17474002f, 
    0.11211445f, 0.15780358f, 0.11495367f, 0.05591845f, -0.16392614f, 0.13445249f, 0.13368301f, -0.10174320f, 
    -0.19145170f, -0.06590608f, -0.08349942f, -0.08320155f, -0.04527294f, -0.20858575f, -0.04268798f, 0.08292902f, 
    0.08856262f, 0.04374106f, 0.03798955f, 0.10840687f, -0.09085564f, 0.05016268f, -0.06228399f, -0.06668392f, 
    0.00904122f, 0.03605150f, 0.02968196f, 0.04041751f, 0.02399917f, -0.76454198f, 0.08896790f, -0.02242967f, 
    -0.21499956f, -0.03499206f, 0.43618074f, -0.03346016f, 0.05663034f, -0.05639956f, -0.24516326f, 0.13538268f, 
    0.26955497f, 0.12778573f, -0.10108353f, -0.29259789f, 0.08582573f, -0.01033125f, -0.08205329f, 0.06652061f, 
    -0.03352987f, -0.05875885f, -0.01886427f, -0.08816700f, -0.19002430f, -0.10077872f, -0.13737482f, 0.00013999f, 
    0.14387403f, -0.03024792f, 0.18254714f, -0.08218378f, -0.03332066f, -0.20858380f, -0.26308003f, -0.17485058f, 
    0.08754125f, 0.10569553f, 0.37960005f, 0.18101099f, -0.06939117f, -0.00773242f, -0.07380787f, -0.01492591f, 
    0.01201961f, 0.09212077f, -0.17431977f, -0.04212005f, -0.12663500f, 0.03542113f, -0.10205843f, -0.04592079f, 
    0.02366542f, 0.02919396f, 0.01712456f, 0.20021267f, -0.05043044f, -0.12929156f, -0.18056524f, 0.16397530f, 
    0.15836042f, 0.04780856f, 0.00849931f, 0.00010187f, -0.22720726f, -0.11397220f, 0.47455525f, 0.02034882f, 
    0.18919346f, 0.15701450f, -0.01642726f, 0.01017761f, 0.19172256f, 0.00519147f, 0.01216797f, 0.15214148f, 
    -0.04778713f, 0.13893624f, 0.27107710f, -0.03187963f, 0.09695677f, 0.24737975f, -0.15700418f, 0.01659731f, 
    -0.02768640f, 0.17218275f, -0.04029465f, -0.14901868f, 0.10396761f, -0.14764018f, 0.14981206f, -0.34608975f, 
    -0.17440245f, 0.19859824f, 0.00617303f, 0.19705455f, -0.07141253f, 0.06021445f, 0.07287298f, 0.24487178f, 
    -0.26743340f, -0.04853318f, -0.04593241f, 0.04564172f, 0.03073129f, 0.26968855f, -0.02311418f, 0.07735578f, 
    0.03103745f, -0.27443349f, -0.27217743f, -0.18466237f, 0.08909266f, 0.17698845f, -0.22731100f, 0.03258602f, 
    -0.00114474f, -0.04869060f, 0.01732579f, -0.10353070f, -0.11564485f, 0.12300944f, -0.03994380f, -0.02548260f, 
    -0.02943213f, -0.01896008f, 0.03399308f, -0.49422681f, -0.10354935f, -0.04982936f, 0.09109785f, -0.00344927f, 
    -0.00275939f, 0.08045854f, 0.07621686f, 0.06934473f, 0.21539772f, -0.08437079f, 0.22917968f, -0.16881834f, 
    -0.05847099f, -0.03730557f, 0.11435150f, 0.09542990f, -0.08658905f, 0.25223461f, -0.16138013f, 0.04891555f, 
    -0.01881703f, -0.08484760f, -0.07386445f, 0.11762773f, -0.16639969f, 0.01823566f, -0.11720569f, -0.07505585f, 
    0.15696229f, -0.01267507f, 0.03626163f, 0.04507701f, 0.01222324f, -0.10813538f, -0.01073004f, 0.36015138f, 
    -0.06055048f, 0.12401234f, -0.19187281f, 0.19899906f, 0.01547370f, -0.15897511f, -0.18073712f, 0.04096408f, 
    -0.08924264f, 0.08751738f, -0.09016467f, -0.05325826f, 0.07607175f, 0.08777998f, -0.01859533f, -0.19558698f, 
    -0.07634798f, -0.01820183f, 0.08479540f, -0.10840245f, -0.02825740f, -0.00743490f, 0.03750627f, 0.19336431f, 
    -0.07255315f, 0.24993734f, 0.01861529f, 0.00900770f, -0.25076696f, 0.19372977f, -0.15735754f, 0.17957273f, 
    0.01980501f, 0.00080083f, -0.03449062f, 0.33660948f, 0.16602860f, -0.14823261f, -0.05573693f, 0.07446783f, 
    0.03749021f, 0.03100387f, 0.00817085f, -0.11021400f, 0.09643626f, 0.38297266f, 0.02428012f, 0.03428161f, 
    0.04227813f, 0.10371931f, -0.03623152f, -0.10312924f, -0.29383653f, -0.27990478f, -0.36712024f, -0.22588421f, 
    0.01073420f, -0.24258026f, 0.27567402f, 0.18132339f, -0.11663003f, -0.09289180f, 0.11216599f, -0.04767885f, 
    0.05161442f, 0.21153729f, 0.08728255f, 0.06491936f, 0.22343080f, 0.21493222f, 0.17216425f, -0.23063777f, 
    0.16070598f, -0.11171333f, 0.11260844f, 0.05383813f, 0.05880334f, 0.04220094f, 0.10207263f, 0.07547382f, 
    0.02290916f, 0.03433036f, 0.00285257f, -0.07306629f, -0.07094353f, 0.16532046f, 0.32160172f, -0.09020896f, 
    0.07175343f, 0.13091716f, 0.21216556f, 0.08712030f, 0.06160735f, 0.03625470f, 0.01068205f, 0.03581572f, 
    0.04814608f, -0.33211732f, -0.01353132f, 0.13565370f, 0.23602125f, -0.06476891f, 0.09149618f, 0.26305857f, 
    0.25805169f, 0.06896562f, 0.39141801f, 0.11877983f, 0.09641165f, 0.07868813f, -0.16812748f, 0.09515353f, 
    -0.05407646f, 0.05470430f, -0.00351672f, -0.09547594f, -0.01658873f, 0.09934848f, -0.07719408f, -0.06694947f, 
    -0.00418430f, -0.20464356f, 0.03866326f, 0.06695728f, 0.04505800f, 0.21342139f, -0.07098275f, 0.21356384f, 
    0.07690452f, -0.05191835f, -0.06831581f, 0.20873368f, -0.26869866f, 0.15461719f, -0.12918670f, -0.26371640f, 
    -0.39565226f, 0.07327312f, 0.12532867f, 0.15489654f, 0.04312945f, -0.08969481f, -0.01792246f, 0.02609552f, 
    0.15533406f, -0.11804287f, 0.02361277f, 0.06932966f, -0.06704184f, 0.12246837f, 0.10890600f, 0.01728760f, 
    -0.04557898f, 0.17852408f, 0.05882111f, -0.11056963f, -0.04599613f, -0.13586232f, 0.17318153f, 0.03630204f, 
    -0.07676457f, -0.08533231f, -0.14465502f, -0.17333853f, -0.06407503f, -0.01438666f, 0.01702082f, -0.05612347f, 
    -0.17992632f, 0.11147392f, -0.13033515f, -0.19591728f, -0.02677413f, -0.01146142f, 0.04821414f, 0.21073380f, 
    0.19792889f, -0.07949320f, 0.16724776f, -0.13001949f, -0.41620103f, -0.30433726f, 0.30643222f, -0.02669539f, 
    0.02575746f, -0.00229524f, 0.05060883f, -0.03129318f, 0.21049093f, 0.07466662f, -0.34893206f, 0.10268943f, 
    0.20564733f, 0.22362956f, 0.13798475f, -0.38862723f, -0.17773859f, 0.01399979f, 0.21086511f, -0.19444302f, 
    -0.04656558f, 0.04389965f, 0.06654194f, 0.02136737f, -0.08769267f, 0.03667841f, -0.31139567f, -0.29987720f, 
    -0.07053828f, -0.00592928f, -0.07577105f, -0.09474313f, -0.01639027f, -0.12617981f, -0.08547037f, 0.11533831f, 
    0.14217278f, -0.01228669f, 0.00717587f, -0.03991634f, -0.03294659f, -0.04184309f, 0.02877617f, -0.26758066f, 
    0.32407853f, -0.09076563f, 0.13187407f, -0.03136074f, 0.17214306f, 0.08143798f, -0.08387033f, -0.09407970f, 
    -0.09242996f, -0.05468709f, -0.09889903f, 0.12625316f, 0.12642838f, 0.03126526f, 0.23994207f, 0.08219285f, 
    0.11173408f, 0.22570790f, -0.21604696f, -0.07321133f, 0.04440820f, -0.12161182f, -0.07112043f, 0.06139845f, 
    -0.02575114f, 0.07900381f, -0.02175465f, -0.05167878f, 0.00581636f, 0.07872600f, 0.13143310f, 0.00403299f, 
    -0.10863118f, 0.03682562f, -0.00170901f, 0.15746669f, 0.12096331f, 0.09766466f, -0.02382897f, 0.08748249f, 
    -0.11241706f, 0.16145308f, -0.10104818f, 0.06045467f, -0.23365119f, 0.14980014f, -0.02585848f, 0.05635890f, 
    -0.10608261f, 0.10164759f, -0.00049533f, -0.05691307f, -0.28618881f, 0.12423869f, -0.06859220f, 0.10600441f, 
    0.01453360f, 0.02694804f, -0.03095766f, -0.12313700f, 0.20193771f, 0.17825440f, 0.22984682f, -0.20396003f, 
    -0.16907410f, 0.66489762f, -0.11987435f, 0.05092226f, 0.22827607f, -0.03788735f, 0.00323949f, 0.15167311f, 
    0.39330626f, 0.24598902f, 0.17259248f, -0.00839525f, -0.06018734f, -0.00810473f, 0.00013783f, -0.01237173f, 
    -0.01919666f, 0.38943535f, 0.13880767f, 0.07681109f, -0.03030234f, 0.02592540f, -0.13106982f, 0.01147016f, 
    0.03279857f, 0.02906896f, 0.24284838f, -0.10595252f, -0.28694642f, -0.05513653f, -0.14574203f, -0.09844364f, 
    0.03443130f, -0.08367403f, -0.00449773f, 0.03651822f, 0.06649499f, 0.06783038f, 0.08591031f, 0.08164912f, 
    -0.00839484f, 0.02675981f, -0.08828953f, -0.23824282f, 0.23814024f, 0.38171515f, 0.22369088f, 0.14451541f, 
    -0.08104320f, 0.06638560f, 0.00286685f, 0.09567338f, -0.04851441f, -0.27232832f, 0.01123797f, -0.48194754f, 
    -0.05570122f, -0.27959806f, -0.02256612f, 0.03059260f, -0.09330393f, 0.11287465f, -0.21020070f, -0.12177173f, 
    0.13617665f, 0.14478971f, 0.06976514f, -0.06801285f, -0.03598075f, 0.01205137f, -0.06150014f, 0.11148744f, 
    0.20820379f, 0.07602403f, 0.07619517f, 0.19660042f, 0.01066850f, 0.08082308f, -0.17131414f, -0.00169182f, 
    -0.04109551f, -0.01659529f, 0.08178461f, 0.18307689f, 0.21657073f, -0.05888909f, 0.07191152f, -0.00703129f, 
    0.19028714f, 0.18954134f, 0.10474391f, 0.15768045f, 0.10647235f, -0.02091067f, 0.06415050f, 0.11712296f, 
    0.01095106f, -0.05219359f, 0.05076856f, -0.20199221f, -0.09650120f, -0.05380550f, -0.10054678f, 0.23561282f, 
    -0.24937050f, 0.02260960f, 0.06948546f, 0.25050405f, 0.20136267f, -0.02663278f, 0.17994115f, -0.04139122f, 
    -0.03537505f, 0.14512821f, -0.04971220f, -0.00749931f, 0.30884895f, 0.21663956f, 0.07204838f, 0.11289788f, 
    -0.03725012f, -0.00110680f, 0.09853970f, -0.12353048f, 0.07451461f, -0.32518160f, -0.20991521f, -0.00913634f, 
    0.10323057f, -0.02834384f, -0.00120635f, 0.21559687f, 0.07644892f, -0.22503823f, 0.71036482f, 0.23650314f, 
    -0.60909343f, -0.09463492f, -0.16637208f, -0.15693590f, -0.07311705f, -0.03421672f, -0.03444443f, 0.27153528f, 
    0.25776389f, 0.14148723f, -0.10570780f, -0.07498199f, -0.20511943f, -0.11317264f, -0.21056654f, -0.11572184f, 
    0.20982793f, 0.01735788f, 0.13974620f, -0.00292149f, -0.11636035f, -0.01218259f, -0.04832993f, -0.23279178f, 
    0.07873402f, -0.08833788f, 0.09465806f, 0.32000795f, 0.04010285f, -0.00341382f, 0.04207049f, -0.03156998f, 
    -0.01625413f, -0.08424642f, -0.05899036f, 0.09842463f, 0.15601051f, 0.02806336f, -0.06429914f, -0.00959009f, 
    0.11896092f, -0.01893035f, -0.06133493f, 0.27386770f, -0.50524098f, -0.44038960f, 0.06671697f, -0.17109655f, 
    -0.02244785f, 0.14680660f, -0.01585733f, -0.09194976f, -0.40946147f, 0.00431868f, -0.06764320f, 0.09980783f, 
    0.24836183f, 0.25105834f, -0.00759872f, 0.10103928f, -0.23414724f, 0.12482164f, 0.26751328f, -0.23152019f, 
    -0.11232555f, -0.05873030f, -0.11912401f, -0.09199619f, -0.10574511f, 0.03836074f, 0.10934454f, 0.12550986f, 
    0.14383073f, 0.03189364f, 0.06797676f, 0.04153855f, -0.07944959f, -0.13504326f, -0.01660664f, 0.03315441f, 
    0.13529424f, 0.07667421f, 0.16081548f, 0.07242518f, -0.02093756f, -0.01039647f, -0.06022272f, 0.11038556f, 
    0.00809646f, 0.01068703f, 0.22122005f, 0.10672455f, 0.05616901f, -0.02306951f, -0.04405564f, -0.02996313f, 
    -0.13768978f, 0.38867104f, -0.17717808f, -0.16555056f, -0.14884660f, -0.18439865f, -0.04749858f, -0.20721042f, 
    -0.05686694f, 0.06472757f, -0.92176831f, 0.05215837f, 0.11189533f, -0.00491390f, 0.01085330f, 0.08392601f, 
    -0.06878037f, 0.05780357f, -0.17407948f, -0.36197871f, -0.02513165f, 0.14672498f, -0.05784980f, 0.01627749f, 
    -0.00868396f, -0.01999532f, -0.10992599f, -0.01860243f, 0.04635642f, 0.08193009f, -0.09196826f, 0.06247507f, 
    0.06280424f, -0.10859515f, 0.17627870f, 0.02764113f, -0.06220365f, 0.02353633f, 0.11938003f, 0.15476705f, 
    -0.00623755f, 0.07127467f, 0.08985487f, 0.04701675f, 0.08825086f, -0.01898211f, 0.12443233f, -0.00576948f, 
    0.16223845f, 0.01549495f, 0.13424110f, -0.22869107f, 0.06165085f, -0.24334471f, 0.22091593f, 0.20784819f, 
    -0.39348903f, 0.40542835f, -0.05709746f, 0.18504389f, 0.32532990f, 0.08011322f, 0.20747101f, 0.09031348f, 
    -0.10274220f, 0.03356202f, 0.46659866f, 0.11837074f, -0.02061827f, -0.10408486f, 0.06160980f, -0.02744276f, 
    0.11716413f, 0.50785607f, 0.11696192f, 0.28133774f, -0.06359532f, 0.08510243f, 0.10704995f, 0.01206144f, 
    -0.13209660f, -0.05207950f, -0.49618006f, -0.04545027f, -0.06829857f, -0.06893409f, -0.30662498f, 0.10642754f, 
    0.18962449f, 0.16954066f, 0.20328294f, -0.26913339f, -0.72190601f, -0.45232254f, -0.20569126f, 0.09096544f, 
    0.14716743f, -0.22746854f, -0.05032408f, 0.14754328f, 0.05264676f, -0.52570277f, -0.61519492f, -0.35538754f, 
    0.15871567f, -0.02738359f, 0.28112549f, -0.06602663f, 0.06141079f, -0.40885195f, 0.10388553f, -0.00602290f, 
    -0.46563688f, 0.27531138f, -0.33850178f, -0.04982731f, -0.04185864f, 0.19900286f, 0.30441430f, -0.15120520f, 
    0.15418056f, 0.15784694f, 0.03453215f, 0.03057957f, 0.32832825f, 0.07754752f, 0.29264745f, -0.70402032f, 
    -0.19830669f, 0.26935729f, 0.11690943f, -0.01834774f, 0.01186488f, 0.03037408f, 0.02909709f, -0.11803495f, 
    -0.20465273f, -0.54861915f, -0.53958732f, 0.09334606f, -0.27822724f, -0.24459112f, 0.04116364f, 0.19321644f, 
    -0.21412349f, -0.31920329f, -0.36246946f, 0.04828117f, -0.11435191f, 0.10558575f, 0.07716376f, 0.21644001f, 
    0.09133472f, 0.10086454f, 0.25873151f, -0.33826262f, -0.09043395f, 0.02105707f, -0.08191217f, -0.00871432f, 
    0.21645784f, 0.10246049f, -0.03245720f, 0.07286005f, 0.15249613f, -0.14337175f, 0.14477842f, -0.04099234f, 
    0.08760132f, 0.25186357f, 0.04870353f, 0.21087207f, -0.45654640f, -0.20866911f, 0.26228809f, 0.01375913f, 
    -0.14005807f, -0.11973044f, 0.12304959f, 0.06947796f, 0.16072445f, 0.34616533f, -0.10209545f, -0.24636187f, 
    -0.18751042f, 0.22167946f, 0.43601710f, -0.05380673f, -0.42415649f, 0.30962804f, 0.49409977f, -0.37774193f, 
    0.00871590f, 0.02059674f, 0.11912104f, -0.04744381f, -0.18646528f, -0.14052595f, 0.13404424f, 0.50070143f, 
    -0.34610423f, -0.54956162f, -0.27465194f, -0.11794596f, -0.33327937f, 0.13680606f, 0.02477488f, 0.30606136f, 
    0.15220416f, -0.06091007f, -0.95939153f, -0.15841967f, -0.19085723f, -0.05616889f, 0.05555191f, -0.22916082f, 
    -0.02170846f, 0.26586732f, 0.39021719f, 0.32435253f, -0.11212536f, 0.10056505f, 0.05456367f, 0.19999525f, 
    -0.08675398f, 0.02355207f, 0.07371181f, 0.13335136f, 0.34461325f, -0.06635673f, 0.02010250f, 0.25566837f, 
    0.17925771f, -0.02299288f, -0.08264290f, 0.22828758f, 0.09793969f, -0.24311428f, 0.10330348f, -0.05684500f, 
    0.20794126f, 0.03273292f, 0.08186051f, 0.13126464f, -0.84976864f, -0.59109432f, 0.41752070f, 0.14955507f, 
    0.13941470f, 0.08915298f, -0.03424128f, -0.07804549f, 0.22177552f, -0.20792624f, 0.01876101f, -0.11915998f, 
    0.02508261f, 0.13090537f, 0.11254790f, 0.15005137f, 0.01122472f, 0.30412886f, 0.25315759f, 0.33061317f, 
    0.35767928f, -0.08181524f, -0.03546573f, -0.01081121f, 0.04370197f, -0.08385574f, 0.13809451f, -0.12799527f, 
    -0.06091200f, 0.07181220f, -0.11844280f, -0.15316761f, -0.07909575f, 0.08749160f, 0.20098032f, 0.19324572f, 
    0.03417499f, 0.34850067f, 0.01706007f, -0.12443542f, 0.24241795f, -0.17932270f, -0.10778905f, -0.06453963f, 
    0.28778177f, 0.39077017f, -0.87806451f, -0.49413872f, -0.01634108f, 0.06030904f, 0.04704226f, 0.19097042f, 
    0.17970119f, 0.02315673f, 0.09996124f, 0.24147238f, 0.11733124f, 0.00241184f, -0.02719158f, -0.14497887f, 
    0.14014971f, -0.09552580f, -0.15202348f, 0.00019099f, 0.22696015f, 0.22206038f, -0.30165637f, -0.01875984f, 
    0.00599659f, 0.00196588f, -0.14704868f, 0.06020895f, 0.12075105f, -0.12226493f, -0.15468568f, -0.11253974f, 
    0.12467365f, 0.17987210f, 0.05568925f, -0.08325412f, 0.02981193f, -0.13138272f, -0.35088605f, -0.48089504f, 
    -0.20467663f, 0.34186140f, -0.02414558f, 0.09671404f, -0.13287161f, -0.01055058f, 0.30268410f, -0.30398902f, 
    0.09299631f, -0.04904834f, -0.02142207f, -0.19863527f, -0.04668622f, -0.04152719f, 0.02857105f, 0.02103198f, 
    -0.13583456f, -0.61915529f, 0.25055784f, 0.17056969f, 0.01572734f, 0.09930119f, -0.00954527f, -0.38076058f, 
    -0.39889595f, -0.38289183f, 0.01220497f, 0.46410617f, -0.47142121f, -0.23443408f, 0.05527566f, -0.13773376f, 
    -0.05637342f, 0.00387189f, 0.05804267f, -0.13927935f, -0.02140183f, -0.18887189f, -0.25924844f, -0.01239808f, 
    -0.03047470f, 0.17190588f, -0.19837800f, 0.02327475f, -0.01934586f, 0.04989062f, -0.04492505f, -0.10754040f, 
    0.10709741f, 0.03515176f, -0.05319934f, 0.20811516f, 0.11733403f, -0.03233144f, 0.17435174f, -0.12001570f, 
    -0.03074355f, 0.04373285f, 0.01383020f, -0.05569045f, 0.16957222f, -0.01665785f, -0.07682725f, 0.01599022f, 
    0.04143754f, -0.12891534f, -0.03507801f, -0.09364006f, -0.09591222f, -0.42468041f, -0.62512827f, -0.18834966f, 
    0.23904289f, -0.33403775f, -0.25588650f, 0.22954808f, -0.07820505f, 0.01173506f, -0.16071326f, 0.03555992f, 
    -0.23592076f, 0.11618268f, 0.05696655f, 0.04406052f, 0.01639931f, 0.03562175f, -0.00082709f, -0.08083311f, 
    0.06613705f, 0.27354702f, 0.07317469f, 0.04465327f, -0.04497560f, 0.17030174f, 0.04374440f, -0.21869601f, 
    0.07081810f, -0.30935073f, 0.17847884f, 0.03854381f, 0.06590980f, 0.23198609f, -0.01793708f, 0.09910051f, 
    0.03889012f, 0.22046547f, -0.01548610f, -0.04426534f, 0.07312646f, 0.12594873f, 0.00755692f, 0.00555655f, 
    -0.06373863f, 0.05564912f, 0.18659405f, -0.32205459f, -0.03865714f, -0.03899319f, -0.01807646f, 0.13905901f, 
    0.00245045f, 0.05403114f, -0.07534424f, 0.19789790f, -0.02158646f, 0.07380614f, 0.10298988f, 0.08127497f, 
    0.00123198f, 0.12252912f, -0.00079206f, -0.10365497f, 0.08295035f, -0.03319749f, -0.01002741f, 0.02316868f, 
    0.07972205f, -0.04780081f, 0.33394080f, -0.01450127f, -0.11379676f, 0.43317598f, -0.20962133f, -0.35028166f, 
    0.11237208f, -0.10926398f, -0.19028766f, 0.18235724f, 0.02686020f, -0.07064374f, 0.17251731f, 0.27962819f, 
    0.17594118f, -0.37844896f, -0.36955860f, -0.42160699f, -0.05972738f, -0.04247258f, 0.15319780f, 0.22904216f, 
    0.08693265f, 0.21548527f, 0.02686865f, 0.02886790f, 0.00148697f, 0.07647470f, 0.15474345f, -0.08088119f, 
    0.21713609f, 0.01127013f, 0.08781549f, -0.02015416f, -0.00547428f, 0.04554797f, 0.09455527f, 0.10687931f, 
    -0.07517058f, -0.15858552f, 0.07121955f, 0.01145892f, -0.40268373f, -0.31725234f, 0.02686187f, 0.04659318f, 
    0.01459263f, 0.09873269f, -0.17708951f, 0.14369079f, 0.04859113f, 0.15437263f, -0.44458959f, -0.17618054f, 
    0.02033818f, 0.02593476f, 0.03062340f, -0.09584907f, -0.20081747f, 0.03024043f, -0.16450043f, -0.03323898f, 
    0.11138751f, 0.14330636f, 0.22098552f, -0.14401533f, -0.20541292f, -0.34970620f, -0.11278863f, -0.06445286f, 
    -0.22007750f, -0.11228224f, 0.26483664f, -0.01716648f, -0.18209244f, -0.18226677f, -0.06847773f, -0.09726921f, 
    0.17234556f, -0.06888637f, -0.13454236f, 0.08367363f, -0.36789864f, -0.04678117f, 0.06038021f, 0.14245880f, 
    0.22392152f, -0.08728788f, 0.03422308f, -0.14832826f, 0.07126322f, -0.11573575f, 0.05201934f, 0.06589484f, 
    0.01782588f, 0.03638497f, 0.26312119f, 0.11630168f, 0.05259253f, 0.08022457f, -0.12297145f, -0.11279191f, 
    0.14298205f, -0.05097831f, 0.13057710f, 0.11694613f, 0.09824470f, -0.04768143f, -0.03720878f, -0.00806870f, 
    -0.13171066f, 0.41083816f, 0.08361247f, 0.35359994f, -0.18364331f, -0.40540883f, -0.13381368f, -0.11260929f, 
    0.24918661f, 0.04750597f, -0.17657334f, 0.11748079f, 0.03952891f, -0.03359950f, -0.08790427f, -0.39475235f, 
    0.00857923f, -0.12620459f, 0.08628106f, 0.42446136f, 0.36334372f, -0.05381759f, -0.12452586f, -0.27560458f, 
    -0.03308535f, 0.04418578f, -0.07813387f, -0.00246448f, 0.09475665f, -0.03882409f, 0.02237775f, 0.06917630f, 
    -0.02747290f, 0.01424195f, 0.12368303f, 0.09665296f, 0.02730597f, 0.27653506f, 0.01631682f, 0.10978187f, 
    0.09863538f, 0.01047113f, 0.09918500f, 0.05898114f, 0.14426047f, 0.06612929f, 0.13367324f, 0.13918169f, 
    0.17731500f, -0.00161828f, 0.06043587f, 0.01137485f, -0.18559264f, 0.21974806f, 0.20898254f, 0.50495571f, 
    -0.14575338f, -0.30762860f, 0.10581252f, 0.10705073f, -0.00391009f, 0.20265085f, 0.12805364f, -0.01868849f, 
    0.30328980f, 0.33619431f, 0.24019566f, -0.13008703f, 0.21549532f, 0.04012595f, -0.13345252f, 0.08237755f, 
    -0.13515811f, 0.76246536f, 0.40778384f, 0.04122579f, 0.04861143f, 0.19066253f, 0.10583889f, -0.03672434f, 
    -0.07394997f, -0.44402146f, -0.30711263f, -0.23456165f, -0.07485573f, 0.10484625f, 0.01058487f, 0.01454270f, 
    0.18357895f, 0.00164754f, 0.00209273f, -0.43926385f, -0.13905820f, -0.34510764f, -0.14662242f, -0.39375749f, 
    0.16932116f, 0.26458964f, 0.12476139f, 0.32536191f, -0.71556950f, -0.26748088f, 0.02066644f, -0.65420365f, 
    0.13598000f, -0.19807719f, -0.00282409f, -0.00302639f, 0.30920523f, 0.08141232f, 0.27898988f, 0.01519370f, 
    0.36918375f, -0.16846742f, 0.26915929f, 0.07344133f, 0.03007009f, 0.30794725f, 0.01804475f, 0.45382276f, 
    0.37469265f, -0.05930010f, 0.01756134f, 0.01057086f, 0.00398775f, 0.00249084f, -0.34495470f, -0.15637256f, 
    -0.16746272f, -0.02434983f, 0.07888644f, -0.03323634f, -0.06624208f, -0.04346181f, -0.04300582f, -0.20380758f, 
    -0.26591340f, 0.26927441f, -0.24224825f, -0.16115133f, -0.22331625f, -0.19974615f, 0.13034528f, 0.10323431f, 
    -0.19960549f, -0.21191765f, -0.18040331f, -0.08250927f, 0.02911158f, 0.06603070f, -0.00259329f, 0.22507136f, 
    -0.00690752f, 0.13826884f, 0.43984568f, 0.28576297f, 0.13267604f, -0.09640735f, 0.10787131f, -0.23391394f, 
    -0.02395215f, -0.18897648f, -0.15465993f, 0.05475418f, -0.12265239f, 0.03330590f, 0.04194817f, 0.08254849f, 
    -0.01779888f, -0.03178536f, -0.10465054f, 0.02718488f, -0.00710267f, 0.19716497f, 0.01668279f, -0.21957336f, 
    0.19157486f, 0.17664577f, -0.08076532f, 0.06071123f, 0.23742920f, -0.04692644f, -0.05232332f, -0.78284001f, 
    -0.14693606f, 0.31029958f, 0.14937137f, 0.04602862f, 0.08776531f, 0.01902008f, 0.33951634f, 0.31471357f, 
    0.11596796f, 0.04586095f, 0.14131562f, -0.06786627f, -0.00337610f, -0.04689407f, -0.25336823f, -0.32304299f, 
    -0.33667180f, 0.22196144f, 0.10871162f, -0.01509896f, -0.16419980f, 0.16501126f, -0.18004531f, -0.13305765f, 
    -0.17473057f, -0.20280884f, 0.14304830f, 0.04967320f, 0.13409601f, -0.22560877f, -0.03285793f, -0.19656274f, 
    -0.14319713f, 0.34570044f, 0.05765698f, -0.17087281f, -0.11994837f, 0.00264607f, -0.04419864f, 0.10380948f, 
    0.05705984f, 0.05287806f, 0.34798232f, 0.23421329f, -0.15324533f, -0.03698920f, 0.02240389f, 0.04669132f, 
    -0.06006703f, -0.04197884f, -0.16379483f, 0.03914344f, -0.16013737f, -0.39033791f, 0.12683289f, 0.09270830f, 
    0.18701242f, -0.10134482f, 0.03105403f, 0.10755368f, 0.10569264f, -0.03005411f, 0.06425308f, 0.02619896f, 
    0.06314258f, 0.15402323f, 0.13035381f, -0.04981302f, 0.07329412f, -0.06446575f, -0.00887480f, 0.08660903f, 
    -0.08957864f, 0.06719624f, 0.04931755f, -0.03483753f, -0.04160861f, -0.04118945f, 0.14411463f, -0.07356673f, 
    -0.00482574f, -0.05673531f, 0.02878394f, -0.01190080f, -0.21448942f, 0.16444218f, 0.31323904f, -0.03016181f, 
    -0.04403023f, 0.17144620f, 0.09586094f, -0.10214925f, 0.12507412f, -0.11753820f, 0.10756003f, -0.00335848f, 
    -0.06031457f, -0.01167045f, -0.10213835f, 0.18805037f, -0.15827787f, 0.14889552f, 0.18314254f, -0.05690258f, 
    0.20285158f, 0.35553849f, 0.29330280f, 0.07282402f, 0.04744833f, -0.03628456f, -0.00128250f, -0.14557162f, 
    0.12338496f, -0.15214756f, 0.05313143f, 0.00284451f, -0.12135090f, -0.16169734f, -0.07141501f, -0.41295797f, 
    -0.12209432f, 0.00534888f, -0.06041254f, 0.00192615f, 0.02396868f, -0.05345253f, -0.32888007f, -0.34737954f, 
    -0.04735075f, 0.03985098f, -0.02469898f, 0.28686133f, -0.38763031f, 0.17496371f, -0.09916948f, -0.02673860f, 
    -0.09268282f, -0.05779262f, 0.13452932f, 0.13751249f, -0.00693929f, -0.28518286f, -0.45566785f, 0.01084993f, 
    -0.09099644f, 0.05058936f, 0.04797970f, -0.09872372f, 0.05418396f, -0.06871893f, -0.06553037f, 0.19745280f, 
    0.16416571f, 0.05753735f, -0.01255787f, -0.08811501f, -0.22142528f, 0.14835098f, -0.22596876f, -0.11641014f, 
    -0.26650077f, 0.04829055f, -0.10372256f, 0.00144555f, 0.21001101f, 0.02694056f, 0.13503690f, 0.08506517f, 
    0.13519619f, 0.41239795f, 0.04022126f, 0.02026585f, -0.09134445f, 0.10538817f, 0.01018699f, -0.05819479f, 
    -0.08046637f, -0.25115153f, -0.06444321f, 0.36147684f, 0.00491974f, 0.12770438f, 0.11020571f, -0.03966295f, 
    0.06619591f, 0.11617032f, -0.01060439f, -0.01989366f, 0.07430457f, -0.31968790f, 0.02736191f, -0.01037737f, 
    0.15440354f, 0.10164326f, 0.00339959f, -0.15759072f, -0.05404320f, -0.00995324f, -0.03341932f, 0.15266559f, 
    0.03637436f, 0.06985916f, -0.09442801f, -0.16776274f, 0.39631939f, 0.06253909f, 0.34286246f, 0.02390827f, 
    0.04731665f, -0.04222401f, -0.15816876f, -0.04532412f, -0.08685346f, 0.16238850f, -0.17349152f, -0.06584833f, 
    -0.13689804f, -0.25622657f, 0.11158147f, -0.04551141f, -0.07926740f, -0.10088151f, 0.19800033f, 0.04224684f, 
    -0.04203055f, 0.04759819f, -0.09465484f, -0.12550958f, 0.01507343f, 0.01814953f, 0.11503661f, 0.17310593f, 
    0.15337411f, -0.13799188f, -0.16237617f, 0.06334362f, 0.00246951f, 0.10951696f, 0.04336121f, 0.19375117f, 
    0.14819309f, 0.10329316f, 0.06069685f, 0.12410927f, 0.08972317f, -0.10319594f, 0.23219785f, 0.47413766f, 
    0.46517149f, 0.24907483f, 0.15116970f, 0.23246215f, -0.00017954f, 0.03832659f, 0.01662783f, 0.13137192f, 
    -0.05027692f, -0.13083693f, 0.20547967f, -0.08411318f, 0.17288768f, 0.00480291f, 0.05721568f, 0.24891697f, 
    0.06142623f, 0.07653903f, 0.07555969f, 0.10903354f, 0.05454720f, 0.03830238f, 0.01420675f, -0.06473030f, 
    0.01109304f, 0.03365024f, -0.13145368f, 0.01075306f, 0.31251428f, -0.05573593f, 0.11316387f, -0.01902010f, 
    -0.08882669f, 0.03348242f, -0.08852816f, 0.01949865f, 0.00033553f, -0.34679919f, -0.28030860f, -0.08727716f, 
    -0.12431379f, 0.09739414f, 0.10207056f, -0.17159788f, 0.20894052f, 0.15633395f, -0.37335041f, 0.01376697f, 
    0.25063375f, -0.02268277f, -0.08607594f, 0.05512423f, 0.05521317f, 0.08147452f, -0.12249732f, 0.04744245f, 
    0.06882279f, 0.01752510f, -0.11096222f, -0.16804977f, -0.19505502f, 0.07865790f, -0.02732500f, 0.01303651f, 
    0.03980157f, 0.02039870f, 0.11033738f, -0.10554937f, -0.27802846f, -0.14657745f, 0.08678397f, -0.13902119f, 
    0.08055010f, -0.07677928f, -0.30891648f, 0.05473144f, 0.02399117f, 0.05146008f, -0.08641443f, -0.07012266f, 
    -0.03509449f, -0.01506806f, -0.01023055f, -0.29411238f, -0.12867698f, 0.09042533f, 0.03610481f, -0.00450399f, 
    0.12173468f, -0.03119021f, 0.16134995f, -0.08817976f, 0.01399619f, 0.18403132f, -0.08814918f, -0.11292974f, 
    0.02371501f, 0.05472406f, -0.06234867f, -0.11403091f, 0.12096392f, 0.00558291f, -0.14564189f, -0.03199861f, 
    0.12466144f, 0.23664302f, 0.06383560f, 0.01837566f, -0.01930146f, 0.46285594f, -0.14058812f, -0.02498972f, 
    0.14625239f, -0.06357145f, 0.02596164f, 0.13763596f, -0.01817561f, -0.20420901f, -0.12862979f, -0.08671680f, 
    -0.01146331f, -0.05208617f, 0.09839511f, -0.01680744f, 0.02748253f, -0.02239400f, -0.12854166f, -0.02215990f, 
    0.08321029f, 0.05719772f, -0.04777994f, -0.09705187f, -0.06990455f, -0.11091688f, -0.10107520f, -0.09484318f, 
    0.00465605f, 0.14167856f, 0.00045563f, -0.08846433f, 0.34544379f, 0.23783503f, -0.06163142f, -0.11001506f, 
    -0.06620265f, -0.18858062f, -0.22337203f, 0.42683932f, -0.14505534f, -0.16081944f, 0.01392837f, 0.11150829f, 
    0.00701392f, -0.08822366f, -0.25871715f, 0.26944703f, 0.10454839f, -0.05247546f, 0.21516983f, 0.13950326f, 
    -0.05547390f, 0.04136682f, -0.02010368f, -0.42305163f, -0.23584974f, 0.29191327f, 0.07061942f, 0.09537973f, 
    0.00822856f, 0.05429686f, -0.03080278f, -0.00280843f, 0.01697609f, 0.23373251f, 0.03681718f, 0.11320198f, 
    0.10519418f, -0.04926332f, 0.15181138f, 0.16890325f, -0.16922797f, 0.04902315f, 0.23567450f, 0.01267132f, 
    0.07476867f, 0.09556989f, -0.03884294f, 0.29742733f, 0.25397354f, -0.01028741f, 0.04805411f, -0.00577917f, 
    0.03242750f, 0.08438695f, -0.02727241f, -0.21016578f, 0.07095251f, 0.02793308f, 0.22679722f, -0.01102190f, 
    0.18806037f, 0.37829614f, -0.02035632f, 0.05956666f, 0.15967983f, 0.18931136f, 0.01697378f, 0.20845777f, 
    -0.48397005f, -0.60179973f, -0.04766167f, -0.13323592f, -0.24340390f, 0.01016566f, 0.21503389f, 0.02738572f, 
    0.07052467f, -0.06796136f, 0.06503442f, 0.17079371f, -0.09574462f, 0.11136322f, -0.07414740f, 0.02904039f, 
    0.04488109f, -0.20390970f, -0.19130576f, 0.33372548f, 0.43916282f, 0.15108374f, 0.03800302f, -0.02320247f, 
    0.12895474f, 0.06267003f, 0.21308424f, 0.32360670f, -0.22425485f, -0.52373892f, -0.02421678f, 0.15576509f, 
    0.19240005f, 0.07894182f, 0.21817891f, 0.12227535f, 0.19093008f, -0.52292383f, -0.18928698f, 0.00425376f, 
    0.28684983f, 0.11816920f, 0.30822635f, -0.03347503f, 0.06270099f, -0.62722027f, -0.25930592f, -0.21429095f, 
    -0.01888530f, -0.15614364f, -0.36853498f, 0.01669154f, -0.05495049f, 0.08280444f, 0.02718572f, -0.03841587f, 
    0.26688385f, 0.10299087f, -0.09581784f, 0.14259188f, 0.06906226f, 0.04667830f, 0.02065153f, -0.24920584f, 
    0.12622896f, 0.29084069f, 0.03843992f, 0.03516835f, -0.06317928f, 0.09054985f, 0.00235881f, 0.27626774f, 
    -0.72376686f, -0.60951012f, 0.22850120f, 0.07378812f, 0.01054546f, -0.24727100f, -0.08572394f, 0.04179851f, 
    0.22223580f, 0.09807881f, -0.00611171f, -0.06572913f, -0.01778555f, 0.13903964f, 0.08998016f, 0.00682777f, 
    0.03555993f, 0.09956620f, 0.31455496f, -0.33263019f, 0.04378734f, -0.15697876f, -0.08578984f, 0.00605418f, 
    0.14751138f, -0.05021698f, 0.12514728f, -0.19572662f, -0.06113969f, 0.06664199f, -0.05607675f, 0.11048328f, 
    -0.02339247f, -0.00918164f, 0.14718561f, 0.02570897f, -0.22403808f, -0.23838456f, -0.03685075f, -0.09830723f, 
    0.09809578f, -0.01595314f, 0.09286696f, -0.07312468f, 0.06780354f, 0.22034845f, -0.59244710f, -0.68975425f, 
    0.08303865f, -0.13644482f, 0.35485050f, 0.24042407f, -0.06508069f, 0.11040536f, -0.14410987f, 0.06549624f, 
    -0.11526904f, -0.29853064f, -0.38547245f, -0.02856286f, -0.07538582f, 0.06312621f, -0.03242728f, -0.15170324f, 
    0.01541079f, 0.00206283f, -0.05550684f, -0.03734959f, 0.00298183f, 0.11307871f, 0.04979077f, -0.01372559f, 
    -0.24650498f, -0.12270992f, -0.11620288f, -0.10809371f, -0.04015294f, -0.06432812f, 0.14948380f, 0.10122826f, 
    0.02693963f, -0.18006442f, -0.17853661f, -0.21466748f, -0.17328407f, -0.12658828f, -0.09777927f, 0.07522324f, 
    -0.02835831f, 0.04454568f, -0.25099748f, -0.04550992f, 0.28750139f, 0.04716824f, 0.05934052f, 0.02851973f, 
    -0.04047434f, 0.00265561f, 0.02229990f, -0.47846174f, 0.23556563f, 0.51258910f, -0.01142751f, -0.07892440f, 
    -0.20711921f, -0.06400715f, 0.02813708f, 0.07576369f, -0.10138963f, -0.31861565f, 0.07375287f, 0.05805939f, 
    -0.03830841f, 0.10266151f, 0.22314577f, 0.07928729f, 0.07713901f, -0.38981020f, -0.21625021f, 0.08535396f, 
    0.16671523f, 0.23891938f, 0.26587382f, 0.16480993f, 0.11645620f, 0.16472964f, -0.17626654f, 0.15549234f, 
    -0.03335746f, -0.09010023f, -0.08023823f, 0.03738674f, -0.01340409f, -0.05946733f, -0.03195325f, 0.02926188f, 
    -0.02486881f, -0.06034914f, 0.15084650f, 0.15930757f, 0.00761822f, 0.13430624f, 0.21206598f, 0.04167677f, 
    -0.01040123f, -0.05602409f, -0.28431144f, -0.09177301f, -0.00363013f, -0.00551147f, -0.11851201f, -0.12883037f, 
    -0.11073893f, 0.13303207f, 0.07587533f, 0.16700836f, -0.16340034f, -0.17363951f, -0.06265258f, 0.07538150f, 
    -0.08692186f, -0.10424660f, 0.21478572f, 0.17673495f, -0.24881716f, 0.03745585f, -0.06051434f, 0.00666471f, 
    0.16596249f, 0.03443472f, 0.16245368f, 0.06783266f, -0.13691579f, -0.58108568f, 0.17454386f, 0.05112089f, 
    0.07073779f, 0.20816545f, 0.17425197f, 0.11887199f, -0.01969671f, -0.28036579f, 0.10312949f, 0.04776800f, 
    -0.08827478f, 0.09485821f, 0.11393195f, -0.06893331f, -0.01666495f, -0.51429999f, -0.46087158f, -0.04100320f, 
    -0.07479782f, -0.05188641f, -0.07126163f, -0.03540503f, -0.15104267f, 0.05817333f, 0.07744440f, 0.15123031f, 
    0.30150345f, 0.01649333f, -0.04857518f, -0.05661254f, 0.23032197f, 0.04538137f, 0.15026546f, 0.30400732f, 
    -0.31232139f, -0.12882048f, 0.12457426f, 0.09997445f, -0.03750337f, 0.09610538f, 0.17100856f, 0.23434529f, 
    0.10692149f, 0.25799617f, 0.10806545f, -0.02160222f, -0.15152550f, -0.19061652f, 0.12882671f, 0.10814226f, 
    -0.09339444f, 0.30323213f, 0.27127317f, -0.26197040f, 0.03535442f, 0.09569242f, -0.30730003f, 0.10942010f, 
    -0.07838959f, 0.00117025f, 0.08562654f, 0.07038821f, -0.09203894f, 0.02186528f, -0.19442649f, -0.02861516f, 
    0.02589431f, 0.01378333f, -0.06558092f, -0.17003569f, 0.02798989f, -0.20246451f, 0.04610461f, 0.03299590f, 
    0.18688539f, -0.03516236f, 0.00113529f, 0.16405311f, -0.03863047f, -0.51482058f, -0.12547882f, 0.11207628f, 
    0.26964492f, 0.09040238f, 0.03869922f, -0.05591280f, 0.09115133f, -0.29770538f, 0.23444167f, 0.22446670f, 
    0.02442627f, 0.04346583f, 0.03893565f, 0.06151876f, 0.21130939f, -0.04761205f, -0.23958436f, 0.02493181f, 
    0.04468776f, 0.11630173f, 0.06782121f, -0.00235354f, 0.17660043f, -0.12095620f, -0.03908071f, 0.04000436f, 
    0.10519351f, 0.23203531f, -0.17747341f, 0.14012033f, -0.01040296f, -0.06046483f, 0.08940583f, -0.29898930f, 
    -0.09904171f, -0.41317713f, 0.46980906f, -0.13574252f, 0.04728600f, -0.03329533f, 0.07625426f, -0.08694208f, 
    -0.28524300f, 0.02308794f, -0.01277529f, 0.19156060f, 0.03398968f, -0.00779684f, -0.19161348f, 0.24235897f, 
    -0.00725176f, 0.13960010f, -0.03889197f, -0.30282658f, -0.23032986f, 0.16048656f, -0.16377845f, -0.07059707f, 
    -0.03049205f, 0.11071312f, -0.14287581f, 0.20354816f, 0.10039485f, 0.15971585f, -0.09747248f, 0.03958990f, 
    0.05169265f, 0.28825349f, 0.02083821f, 0.01869056f, 0.36695090f, 0.18063611f, -0.03798835f, -0.19598384f, 
    0.19099882f, 0.07517948f, 0.05247217f, 0.08629908f, -0.14927775f, 0.31296346f, -0.21454522f, -0.72060436f, 
    -0.01102267f, -0.10845879f, 0.12363271f, -0.01338598f, -0.04395120f, -0.11649434f, 0.06932840f, -0.06462859f, 
    0.36296520f, 0.10637866f, 0.01343909f, -0.59270334f, 0.05428773f, 0.04813317f, 0.00303477f, 0.26193881f, 
    0.11806616f, 0.35289812f, -0.26691791f, -0.27985793f, -0.23922279f, 0.00389292f, -0.05756958f, -0.01714953f, 
    0.22874388f, 0.07977508f, 0.33586344f, -0.24373707f, -0.06839060f, 0.12512907f, 0.06602686f, -0.12718102f, 
    -0.05169795f, 0.23389824f, 0.16000706f, -0.17060977f, 0.02314113f, -0.01844668f, -0.04074926f, 0.10481168f, 
    -0.09517740f, 0.00981216f, 0.31880054f, 0.20177467f, -0.32215735f, 0.11862139f, -0.20733640f, 0.00350222f, 
    0.00885756f, 0.11556680f, 0.02475153f, 0.64962912f, -0.24772342f, 0.00183230f, -0.00468602f, 0.01345219f, 
    -0.18970342f, 0.06579626f, -0.05343467f, 0.17707884f, -0.66106635f, 0.41838044f, 0.11780798f, 0.27614984f, 
    0.03715217f, 0.03123740f, 0.17921154f, -0.06145452f, -0.04347925f, 0.42943987f, -0.07305184f, -0.14198086f, 
    -0.23102373f, 0.25006175f, -0.10363194f, 0.14239486f, -0.12455720f, 0.09489524f, 0.16064976f, 0.09425041f, 
    0.06097434f, -0.01690232f, 0.04396808f, 0.11204066f, 0.00108854f, -0.03996323f, 0.06360988f, 0.01537341f, 
    0.18060145f, 0.35210583f, -0.09798145f, 0.20299232f, 0.09657546f, 0.07994024f, -0.04111354f, -0.05877402f, 
    -0.19307443f, -0.20638029f, 0.28135228f, -0.01767058f, 0.20823310f, 0.07046650f, 0.02348109f, -0.06605576f, 
    0.19796613f, 0.19947803f, -0.45462978f, 0.13746272f, 0.08966845f, 0.05249161f, -0.66815960f, 0.02608105f, 
    -0.06125294f, -0.08659892f, -0.11327248f, 0.13137439f, -0.11668687f, -0.07522210f, 0.01489254f, 0.09022433f, 
    -0.12450708f, -0.11109889f, -0.04033961f, 0.14338915f, 0.38497585f, -0.46220016f, 0.00979215f, -0.11689375f, 
    0.12883092f, -0.07344314f, 0.08974802f, -0.23080631f, -0.11449011f, -0.07925561f, -0.00885846f, 0.18183188f, 
    -0.07260048f, 0.01492436f, 0.09745073f, -0.12843554f, 0.32652032f, -0.00598835f, -0.19403765f, 0.02202017f, 
    0.00363612f, -0.01209849f, 0.10639815f, -0.17629676f, -0.10488430f, -0.18882689f, 0.00040148f, -0.12974700f, 
    0.33160609f, -0.02418639f, 0.04287582f, -0.25853932f, -0.17662421f, 0.15030839f, -0.20381412f, 0.16249241f, 
    -0.84995174f, 0.65265054f, -0.41228953f, -0.08721562f, -0.09463269f, 0.00969442f, 0.14832246f, -0.03476100f, 
    0.03413539f, 0.00865205f, -0.00800959f, -0.00608755f, 0.03455495f, -0.02252525f, 0.02831236f, 0.04273129f, 
    -0.02255717f, 0.03987543f, -0.04198001f, -0.02850401f, -0.00047103f, 0.00254113f, 0.01578426f, 0.01776199f, 
    0.04036077f, -0.01352052f, 0.01443555f, -0.03504811f, -0.02391293f, -0.01095716f, -0.02902252f, -0.04260246f, 
    0.01131855f, -0.02560453f, -0.02078836f, -0.02042372f, -0.06378993f, -0.01857693f, -0.02320910f, 0.02483022f, 
    -0.02323924f, 0.03192742f, -0.01248133f, 0.05779951f, -0.05565465f, -0.00110826f, -0.04314728f, -0.05009533f, 
    0.00719311f, -0.03463694f, -0.04640835f, 0.02678552f, 0.05967363f, -0.04712818f, -0.04737597f, 0.03197967f, 
    0.02548988f, -0.05739370f, 0.05233789f, 0.00988291f, -0.01499946f, -0.06150734f, -0.00142971f, -0.05166572f, 
    -0.02455594f, 0.00679591f, 0.02549310f, 0.03777029f, -0.05008828f, 0.02653856f, 0.00819337f, 0.03438974f, 
    0.04494353f, -0.04742400f, 0.04726082f, 0.04206095f, 0.04980834f, 0.00715042f, 0.02189161f, 0.01576537f, 
    -0.00696522f, -0.01987279f, -0.03424385f, 0.02977266f, -0.05206997f, -0.01883313f, -0.06547937f, 0.00914245f, 
    -0.06762116f, -0.05759057f, -0.04448905f, -0.01632701f, -0.01548487f, -0.03461770f, 0.01067701f, -0.00378557f, 
    -0.03226434f, -0.04722229f, -0.05213031f, -0.02654873f, 0.02172176f, -0.03918029f, 0.02133295f, -0.00876509f, 
    -0.05309198f, -0.03258051f, -0.06545275f, 0.02026940f, 0.03880346f, 0.03784509f, 0.01850750f, -0.01979383f, 
    0.03387288f, -0.05501541f, 0.04910666f, -0.01387117f, -0.05142237f, -0.00506073f, 0.01242595f, -0.03822833f, 
    -0.04280924f, 0.00355807f, 0.02318457f, 0.04799143f, 0.01921914f, -0.02709143f, -0.03112740f, -0.01684087f, 
    -0.04904690f, 0.02272796f, -0.04333214f, -0.01226282f, 0.04223168f, -0.06093385f, -0.00039591f, 0.03853253f, 
    -0.00674119f, 0.03854172f, 0.00227029f, -0.02579354f, 0.00037539f, -0.06891990f, 0.01697177f, 0.04221530f, 
    -0.02018406f, 0.01219254f, 0.00173920f, 0.00773155f, -0.02463404f, -0.04045081f, -0.02978555f, -0.01672232f, 
    0.04578490f, -0.02247849f, -0.03351653f, -0.05828511f, -0.05463750f, 0.00084274f, -0.05233765f, -0.00020951f, 
    -0.05425802f, -0.02531776f, 0.03212655f, 0.04769663f, 0.01380839f, 0.00193180f, 0.03697828f, -0.06511907f, 
    -0.06729208f, 0.01843383f, 0.02651695f, -0.03427047f, 0.01680935f, 0.04593503f, 0.01350254f, 0.04492182f, 
    0.02830996f, 0.00367860f, 0.00326395f, 0.01332464f, -0.00806822f, 0.04515368f, 0.00342139f, -0.02531899f, 
    0.03332479f, -0.00417226f, -0.00470167f, -0.04673974f, -0.01682937f, 0.00322651f, 0.02372857f, 0.01108435f, 
    -0.00758259f, -0.02608251f, 0.00129691f, 0.04320137f, -0.02411259f, -0.01918470f, -0.00828806f, 0.02732491f, 
    0.00609170f, -0.03627046f, 0.04631616f, -0.01839588f, -0.05492885f, -0.01545544f, 0.01903339f, -0.01642791f, 
    -0.01577643f, -0.01720100f, -0.04610111f, -0.06936766f, -0.03136030f, -0.05679678f, 0.02873514f, 0.01922441f, 
    0.04503157f, -0.00736987f, 0.04498203f, -0.05317810f, 0.03984977f, 0.00789670f, -0.04818361f, -0.00416634f, 
    0.03761012f, 0.01539925f, 0.01245866f, -0.01230278f, 0.04989708f, 0.03453195f, 0.05212474f, 0.04480813f, 
    -0.02417934f, -0.06396810f, 0.00707386f, -0.03249607f, -0.01426223f, 0.01686111f, -0.03041326f, -0.01797906f, 
    -0.02229909f, 0.00054440f, -0.05668205f, -0.00054880f, 0.00659298f, -0.02327348f, 0.02101628f, 0.02159626f, 
    0.03170480f, 0.03326859f, -0.05987606f, -0.01658744f, 0.00662433f, 0.01873635f, 0.00564172f, 0.03318140f, 
    0.04873902f, 0.02528313f, -0.00861926f, 0.00105645f, 0.02074626f, -0.03604502f, -0.02133873f, 0.02291848f, 
    -0.04679522f, -0.00107514f, -0.03097753f, 0.00759674f, 0.03684486f, -0.05954712f, -0.03557064f, -0.01442557f, 
    0.03695684f, -0.01877679f, -0.01190779f, 0.04422157f, -0.02346584f, -0.05690265f, 0.01911516f, 0.00798315f, 
    -0.01915974f, 0.04134158f, -0.03756777f, -0.03113941f, 0.00970214f, -0.05536168f, 0.00064494f, -0.03863569f, 
    -0.02497771f, 0.03803215f, -0.04701481f, 0.03698655f, 0.02905691f, 0.03984497f, -0.00658919f, -0.03673273f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02889043f, -0.11218289f, 0.23145898f, -0.02631784f, 0.34812376f, 0.23714823f, 0.08327952f, 0.01227415f, 
    0.00773574f, 0.11812822f, 0.02663810f, 0.24425702f, 0.22672603f, -0.00471202f, 0.49679795f, 0.23197450f, 
    0.06318917f, 0.19057278f, -0.04169048f, 0.04719889f, 0.03440598f, -0.05642049f, 0.11217242f, 0.04001364f, 
    -0.00326637f, -0.04047564f, 0.12997170f, -0.17277665f, 0.07050059f, 0.42740649f, -0.03083913f, -0.03179459f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01694061f, 0.69351774f, -0.11898377f, -0.10011467f, -0.21687257f, 0.12112164f, -0.33644566f, 0.07114808f, 
    -0.05307636f, 0.06051188f, -0.22551645f, -0.01178358f, -0.23600802f, 0.02089808f, -0.30343020f, -0.27137497f, 
    -0.11675613f, -0.80738360f, 0.13948900f, 0.15589860f, 0.14189330f, -0.04391456f, 0.04873637f, 0.03836597f, 
    0.08821445f, 0.55069864f, -0.04794950f, 0.46579322f, -0.17378390f, -0.12338770f, 0.55872321f, -0.13221286f, 
    0.18008214f, -1.23558819f, 0.12133449f, 0.06898285f, 0.27939251f, -0.31310755f, -0.43556747f, -0.46589226f, 
    -0.19631702f, 0.41725227f, -0.32419366f, -0.10467272f, 0.58801192f, 0.03112703f, 0.72285205f, -0.25611782f, 
    0.20458695f, -0.08566645f, 0.15045476f, 0.12969927f, -0.21244797f, -0.28412032f, 0.24951763f, -0.21220431f, 
    0.10583904f, 0.16054134f, 0.06411718f, 0.75946212f, 0.10575681f, 0.09044821f, -0.07957558f, 0.16226479f, 
    -0.35625827f, -0.74580967f, 0.06271552f, -0.03992253f, 0.20900770f, 0.49299717f, -0.35182971f, -0.26309320f, 
    -0.05656176f, 0.52883387f, 0.04813123f, -0.46793580f, 0.05420214f, -0.45719758f, -0.48992378f, 0.23809378f, 
    -0.09841040f, 0.08255614f, 0.15353124f, -0.10382532f, 0.21870552f, -0.03764182f, -0.18614765f, -0.09563145f, 
    -0.36682042f, -0.85729915f, -0.15726995f, -0.18923791f, 0.25468284f, 0.09267731f, -0.13427584f, 0.14983788f, 
    -0.01755695f, 0.19322625f, -0.59422958f, -0.15210649f, -0.27308452f, -0.39416814f, 0.08301199f, 0.69356686f, 
    -0.03462823f, 0.24451086f, -0.43807843f, -0.53182977f, -0.90559798f, -0.08211146f, -0.73907554f, 0.33651909f, 
    0.04388209f, 0.24093868f, 0.08139066f, -0.29054397f, 0.36986861f, 0.41271693f, -0.92851686f, -0.67241693f, 
    0.35036615f, -0.40204141f, 0.32204777f, 0.01509708f, 0.22485843f, -0.46583188f, -0.00975778f, -0.07339073f, 
    0.42942420f, -0.11355822f, -0.29776421f, 0.06244621f, -0.13276526f, -0.05314816f, 0.54356843f, -0.43633792f, 
    -0.02083716f, 0.21582222f, 0.29232761f, -0.31269535f, -0.10240617f, -0.17378883f, -0.11695702f, -0.23404284f, 
    -0.19827463f, -0.42715618f, -0.12071188f, 0.22655217f, -0.09969456f, -0.03309306f, 0.08819170f, 0.30406061f, 
    0.10829352f, 0.18705851f, 0.29012597f, -0.49616149f, 0.23232278f, -0.58267349f, -0.08464602f, 0.07240225f, 
    -0.22788733f, -0.07635696f, 0.20977381f, -0.10723871f, -0.07495484f, -0.31561753f, -0.20189932f, -0.43494117f, 
    0.03463334f, -0.15043448f, 0.42595926f, 0.19124801f, -0.32959020f, -0.25994742f, -0.08456336f, -0.01555366f, 
    0.37727144f, 0.06830833f, 0.15937479f, 0.31251568f, -0.14517096f, 0.52541709f, 0.15675917f, -0.11246465f, 
    0.03971623f, 0.47634903f, 0.08416905f, -0.18446730f, -0.36505479f, -0.01195017f, -0.26161584f, 0.08663614f, 
    -1.22432256f, 0.42122766f, 0.26466236f, -0.15233600f, 0.37369299f, 0.40995732f, 0.11357180f, -0.44939741f, 
    0.06081682f, -0.67644691f, -0.65249771f, 0.24942462f, 0.18045495f, 0.42812532f, 0.25843468f, 0.15276997f, 
    -0.15628786f, -0.16373087f, 0.13380201f, 0.07591018f, -0.39217108f, -0.02204834f, -0.22391401f, -0.02265184f, 
    -0.62218654f, -0.33025038f, -0.08787123f, -0.15677585f, 0.12520395f, 0.54814190f, -0.59720635f, -0.13472275f, 
    -0.39749229f, -0.16777919f, -0.02803388f, -0.04035976f, -0.34732327f, 0.16880186f, -0.23195972f, 0.73417193f, 
    -0.13916872f, -0.33084342f, -0.13512546f, -0.08465227f, 0.34905288f, 0.51070535f, -0.66059130f, -0.25461346f, 
    -0.11034254f, 0.08048979f, 0.14047429f, 0.07391762f, -0.00329946f, 0.18727373f, 0.17386566f, 0.18189098f, 
    0.44524372f, 0.06865446f, -0.32435021f, -0.05527176f, 0.24569966f, -0.54307562f, 0.06187166f, -0.02201741f, 
    0.03917537f, -0.28189835f, 0.15705647f, 0.01672397f, -0.06906069f, -0.59537411f, -0.36394027f, 0.90639299f, 
    -0.15816249f, -0.63295126f, 0.36598241f, 0.39611873f, 0.61269456f, -0.02319800f, -0.17515430f, -0.12666628f, 
    0.30970633f, 0.23549642f, 0.04406438f, 0.28651512f, 0.14384262f, -0.61915928f, -0.15223433f, 0.14254797f, 
    -0.43732634f, -0.36254913f, -0.17749326f, 0.05391053f, -0.26927161f, -0.02263744f, -0.10230067f, 0.08138751f, 
    0.05599879f, 0.25505963f, -0.54802603f, 0.10064398f, -0.02487079f, 0.38539699f, 0.53088886f, -0.40474743f, 
    -0.09019975f, -0.12895240f, -0.14700374f, 0.36298692f, -0.14383754f, -0.04597823f, -0.00379708f, 0.03121355f, 
    -0.44495460f, 0.24907264f, -0.02397580f, -0.34094873f, -0.08590683f, -0.04884052f, -0.87153405f, 0.34119907f, 
    0.16507097f, -0.00065884f, 0.26397181f, -0.82284373f, -0.11522690f, 0.40359607f, 0.22913161f, -0.03152233f, 
    -0.15178324f, -0.08017625f, 0.27847806f, -0.00772993f, -0.46104914f, 0.02907177f, 0.55062777f, -0.45864931f, 
    0.11854780f, -0.12001468f, 0.37977713f, -0.15859377f, -0.45084822f, 0.29857108f, -0.25799009f, -0.01971754f, 
    0.44203827f, 0.34745675f, 0.07368115f, -0.31831852f, -0.44007421f, -0.70010340f, 0.72980881f, -0.14197344f, 
    -0.27896166f, -0.52251238f, -0.58573502f, 0.07447172f, -0.35340497f, 0.00339162f, 0.35318807f, -0.01448207f, 
    -0.25379390f, 0.00989112f, 0.34647867f, 0.10829272f, -0.41334093f, -1.21068239f, 0.00611237f, -0.18518700f, 
    -0.14020774f, -0.48460692f, -0.19216882f, -0.03015118f, -0.65802628f, -0.09169231f, -0.13390906f, 0.46386966f, 
    0.11962108f, 0.01877202f, -0.02290778f, -0.64336896f, -0.06155813f, -0.58646804f, 0.20551999f, 0.24556245f, 
    0.30366245f, -0.67870504f, -0.15502223f, -0.56437421f, 0.40817884f, 0.08247265f, -0.77566022f, 0.03144701f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20243634f, 0.01881071f, 0.32164949f, 0.08065337f, -0.06870983f, 0.14773080f, -0.12537239f, -0.34459430f, 
    -0.18995181f, 0.27152610f, -0.10590842f, 0.30438465f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
