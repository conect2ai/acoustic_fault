#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.19715703f, -0.72812545f, -1.56379259f, -1.04081798f, -0.84547031f, 0.37957972f, 0.42960376f, 0.51161742f, 
    0.10770409f, -0.30461726f, 0.42447641f, -0.30087250f, -0.14874795f, -0.36807737f, 0.35541224f, -0.16802704f, 
    -0.61089832f, -0.36777344f, -0.36626473f, -0.47616112f, -0.06549513f, -0.25698268f, 0.46606663f, 0.19086921f, 
    0.60159892f, -0.48198798f, 0.54083478f, 0.09520157f, -0.45998552f, 0.83089066f, -0.32502183f, -0.09837084f, 
    0.44691038f, 0.45114258f, 0.04420610f, 0.09978262f, -0.30818555f, -0.46561986f, 0.67342722f, 0.28937316f, 
    0.18577172f, -0.08874814f, -0.40176204f, 0.20904769f, -0.30247602f, -0.18538643f, 0.30134845f, -0.09836389f, 
    0.23223440f, -0.31784606f, 0.02538537f, -0.14777300f, 0.07505967f, 0.74098182f, 0.16030638f, -0.92504293f, 
    -0.67604840f, 0.18177441f, 1.11190856f, 0.50179309f, 0.06502677f, -0.26311317f, -0.17778939f, 0.33603334f, 
    0.23348659f, -0.26365751f, 0.14588138f, -0.09880298f, -0.23839487f, -0.36411116f, 0.00633423f, -0.31830016f, 
    -0.18087386f, 0.06943488f, 0.13426095f, 1.14402676f, 0.45556998f, 0.82478869f, -0.01775487f, 0.11202936f, 
    -0.64413738f, -0.11669705f, 0.00234928f, 0.10608502f, 0.26565605f, 0.13531916f, 0.03408695f, -0.11239209f, 
    0.03974837f, -0.12140317f, 0.08846560f, 0.02242114f, 0.06506002f, -0.11836412f, -0.04629947f, 0.18982072f, 
    0.64544481f, 0.21379349f, -0.51317179f, -0.59325886f, -1.88085091f, -1.60264766f, 0.38297075f, 0.89487064f, 
    -0.27345088f, 1.79079354f, 0.50780845f, -0.84702498f, -0.51293308f, 0.65599537f, -0.07088178f, -0.49166948f, 
    -0.50675553f, 0.19596526f, -0.42033198f, -0.00846570f, 0.08429185f, -0.28251719f, -0.09493867f, -0.46474621f, 
    0.05484368f, -0.31528381f, -0.05144373f, 0.22612892f, -0.13835338f, -0.74476540f, -0.89436305f, -1.12003839f, 
    -0.06286512f, -1.26593316f, -0.13032663f, 0.15580550f, -0.60403043f, -0.60432243f, 0.08975960f, -0.28666702f, 
    -0.38467753f, -0.40611497f, -0.29491732f, 0.37217900f, 0.40950620f, 0.83393586f, 0.34455684f, -0.25021407f, 
    0.07224202f, -0.12347335f, -0.26573023f, 0.83884066f, -0.07727516f, -0.25303143f, 0.91056406f, -0.10360348f, 
    0.01017061f, -0.14637291f, 0.46687073f, -0.36293626f, -0.33907595f, -0.00865688f, -0.40558723f, -0.46849489f, 
    -0.59120196f, 0.66615075f, -0.15838656f, -0.23485088f, -0.52041614f, 0.14783399f, 0.24942777f, 0.05177202f, 
    -0.22385101f, -0.33186981f, -0.03863925f, 0.33066902f, 0.20103157f, 0.21487236f, 0.58411962f, -0.46467420f, 
    -0.30417097f, -0.93295717f, 0.54529780f, 0.45773420f, 0.44889045f, 0.03029744f, -0.97001815f, -0.18048283f, 
    -0.86006087f, 0.21036315f, 0.30699322f, -0.45391294f, 0.74785829f, -0.26914960f, -0.32117712f, -0.58839095f, 
    0.43693948f, 0.79625058f, -0.06617397f, -0.06114201f, -0.24710673f, 0.27459860f, 0.02362705f, -0.33227351f, 
    -0.21101113f, 0.68381327f, 0.64928627f, 0.60192668f, -0.85970289f, -1.04894054f, -0.80716085f, 0.00836961f, 
    -0.12847786f, -0.15580031f, -0.32128155f, -0.99077785f, 0.36963588f, -0.48434788f, -0.33240306f, 0.40155897f, 
    0.19770743f, 0.30901834f, 0.11378866f, -0.12072462f, 0.16817898f, -0.50632483f, -0.16746022f, 0.27722615f, 
    0.31483403f, -0.58625197f, -0.91772544f, -1.27814782f, -0.82107383f, -0.59503877f, 0.71915179f, 0.11952145f, 
    0.25048679f, 0.41075000f, 0.14536686f, 0.77002442f, 0.11375364f, 0.15470916f, 0.24337986f, -0.13536707f, 
    -0.19937705f, -0.20826446f, -0.31578413f, 0.00963497f, -0.12671830f, -0.36867338f, -0.05624908f, 0.19537175f, 
    -0.48147553f, -0.54089034f, 0.86228365f, -0.53488445f, -0.77126992f, -0.81066859f, 0.00444974f, 0.38454300f, 
    0.41812354f, -0.11737324f, -0.23252439f, 0.50278443f, -0.54544812f, -0.37869939f, -0.53449452f, -0.40350249f, 
    0.16839956f, 0.18021764f, 0.05308557f, -0.20338814f, -0.34686980f, -0.85245645f, -0.34182781f, -0.72196567f, 
    -0.67486852f, -0.85602838f, -1.01926255f, -0.38802791f, -0.13531190f, 0.14294052f, 0.98696268f, -1.03207481f, 
    -0.98285347f, -1.32699871f, -0.85051090f, -0.43132287f, -0.35026282f, 0.51761031f, 0.15826686f, -0.04028056f, 
    0.40525702f, 0.09737334f, -0.19633192f, 0.10963061f, 0.01682979f, -0.43973392f, -0.54720694f, 0.00229655f, 
    0.02472872f, -0.16198049f, -0.22014025f, -0.46376017f, 1.27647889f, 0.98156422f, 0.49506223f, -0.56626630f, 
    -1.33683741f, -0.33795843f, 0.62674278f, -0.41696125f, -0.57357675f, -0.91823822f, 0.08566999f, -0.50537592f, 
    -0.43927193f, -0.15964258f, 0.05918363f, 0.02545302f, 0.24156260f, 0.37997416f, -0.49653414f, -0.17467608f, 
    -0.08555102f, -0.07313611f, 0.01604825f, 0.06592723f, -0.12868944f, -0.25831440f, 0.39428160f, 0.41458899f, 
    0.07487462f, 0.35837427f, -0.45828000f, -0.07112370f, 0.58970708f, 0.28267327f, 0.16874179f, 0.12717117f, 
    -0.37568501f, 0.81818146f, -0.73307556f, 0.00109024f, -0.30630270f, -0.33181274f, -0.21708183f, -0.33014327f, 
    0.00191076f, -0.21640527f, -0.12246808f, -0.32925412f, 0.34095645f, 0.42277405f, 0.66504699f, 1.11443925f, 
    0.58643484f, -0.24608898f, 0.22381766f, 0.00288161f, 0.02106874f, -0.33918953f, -0.24443619f, -0.53859162f, 
    -0.07450714f, 0.22522083f, -0.07850070f, 0.04303196f, 0.01526030f, -0.18912622f, -0.16491601f, 0.04856665f, 
    0.36488059f, 0.02339916f, 0.13136467f, -0.33762828f, -0.65077418f, -0.47619963f, -0.29133463f, -1.07368875f, 
    -0.42639744f, -0.41739061f, -0.41496170f, -0.44448593f, -0.46989965f, -0.52486902f, -1.27760983f, -1.30305326f, 
    -1.04125261f, -0.07643633f, -0.01408574f, -0.37056351f, -0.73608011f, -0.59969306f, -0.35576966f, -0.56526071f, 
    -0.06309634f, -0.15007642f, -0.34758109f, -0.10635560f, -0.04236660f, 0.19772102f, 0.13072018f, 0.30419117f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.47276962f, 0.75017899f, 0.69119889f, 0.46180680f, 0.57395416f, 0.23831141f, 0.57966858f, 0.85199708f, 
    0.33858138f, -0.10232691f, 0.17020240f, 0.23977409f, 0.70412511f, 0.67109454f, 0.32229301f, -0.16850497f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17567614f, -0.11916184f, -0.55092001f, 0.06573512f, 0.15942572f, 0.02698939f, -0.33959353f, -0.15424888f, 
    -0.23147739f, -0.21543816f, -0.27395850f, -0.18956777f, -0.22829846f, -0.00111885f, 0.20753449f, -0.03078916f, 
    0.02819409f, 0.03504891f, 0.08717441f, 0.03085866f, -0.12443388f, -0.22029725f, -0.52473062f, -0.34556824f, 
    -1.00121653f, 0.06762104f, 0.28889734f, -0.18748938f, 0.02072487f, 0.15467149f, 0.08979318f, 0.05277693f, 
    -0.08519750f, -0.11234584f, -0.19834606f, -0.21866761f, -0.39018777f, -0.39565992f, 0.04213389f, 0.21753964f, 
    0.10141264f, 0.07139838f, 0.12601165f, -0.03019119f, -0.06956986f, -0.02582644f, -0.06175453f, 0.07770915f, 
    0.87629628f, -0.04212604f, -0.16284437f, -0.30952117f, -0.11323228f, -0.23519978f, 0.15886182f, -0.05453396f, 
    -0.11914913f, -0.08968318f, -0.01466944f, -0.02603032f, 0.50422412f, 0.14987257f, -0.15009840f, -0.26551265f, 
    0.42095140f, 0.06744798f, 0.00129289f, 0.00265911f, -0.01526563f, 0.10866562f, 0.10446883f, 0.14270310f, 
    -0.05503174f, 0.00647311f, -0.43706593f, -0.05080710f, -0.01573395f, -0.27789503f, -0.10688236f, -0.10641566f, 
    -0.04310178f, -0.00449109f, -0.01387411f, -0.07825799f, 0.34404665f, 0.11907239f, -0.49295768f, -0.27626294f, 
    -0.18215197f, -0.40414587f, 0.02975101f, -0.10756303f, 0.21863791f, -0.29813448f, -0.26418999f, -0.12504873f, 
    0.02370062f, 0.38781098f, 0.22294758f, -0.13572575f, -0.14914237f, -0.12308140f, -0.17609432f, 0.14567553f, 
    -0.09603338f, -0.04480892f, -0.05379164f, 0.11037657f, 0.60524225f, 0.01431929f, -0.31004930f, -0.02432686f, 
    0.23166607f, 0.26053813f, 0.05414633f, -0.01571681f, -0.09015302f, 0.14474621f, -0.00906094f, 0.07172862f, 
    0.17454174f, 0.00627227f, -0.15751299f, 0.20773873f, 0.12719715f, 0.06760237f, -0.11219653f, -0.16543618f, 
    -0.04182437f, 0.19599156f, 0.11777505f, 0.17360000f, 0.35582146f, 0.20344780f, 0.12666778f, -0.49812847f, 
    -0.01930597f, 0.11714313f, -0.31574640f, 0.16696489f, 0.04614769f, 0.04915065f, -0.15430683f, 0.05387463f, 
    0.04199626f, -0.46539336f, -0.01537001f, 0.05291670f, -0.18219936f, 0.15245399f, -0.40920871f, -0.00594817f, 
    -0.15062131f, 0.03739537f, 0.07218753f, 0.16252242f, -1.09646654f, -0.36077973f, 0.22388454f, -0.08112071f, 
    0.11554214f, -0.04509524f, 0.15404055f, 0.11601356f, -0.08876964f, -0.10023166f, -0.01692810f, -0.00321937f, 
    -0.45163378f, -0.30117381f, -0.62666982f, 0.35802636f, 0.20882139f, 0.03909224f, 0.00074552f, -0.01153480f, 
    -0.10049738f, 0.11086190f, 0.05469262f, -0.03725371f, 0.60525918f, 0.54114199f, -0.31901672f, -0.24511936f, 
    0.21355420f, -0.05753892f, 0.00755386f, 0.12645997f, -0.12893796f, -0.15956330f, -0.05709354f, -0.05501086f, 
    0.38580206f, 0.04058271f, -0.12983550f, -0.45465207f, 0.01730864f, 0.33143571f, 0.27616358f, 0.09767026f, 
    0.13030097f, -0.01814962f, -0.23509286f, -0.04922638f, -0.04447461f, 0.05954625f, 0.02368051f, 0.17304681f, 
    -0.00248313f, 0.11214118f, -0.19182760f, 0.01335734f, -0.05636931f, -0.10803057f, 0.14477496f, -0.06826828f, 
    -0.52159953f, 0.28417686f, 0.22808343f, 0.07406323f, -0.05733857f, 0.10810995f, -0.05173619f, -0.17035376f, 
    0.10006549f, -0.11013906f, -0.14383447f, 0.17537905f, 0.39580408f, 0.15194204f, 0.19243523f, 0.10425050f, 
    -0.06276567f, -0.02703330f, -0.18550089f, 0.10087213f, -0.13807480f, 0.01190822f, -0.03312185f, -0.00423773f, 
    0.76717073f, -0.47035310f, 0.03821078f, -0.14942007f, 0.00226049f, -0.13450156f, 0.15700264f, 0.08896182f, 
    0.13589349f, -0.10972562f, -0.02342286f, 0.02707989f, 0.23394288f, 0.23555467f, 0.60201621f, -0.11212327f, 
    0.23399386f, -0.19930275f, 0.03697500f, -0.16849799f, 0.06318345f, -0.12781493f, -0.09083863f, -0.15587825f, 
    0.43635854f, 0.11113341f, -0.41699111f, 0.05995838f, -0.38783503f, -0.02965793f, 0.02102768f, -0.07059156f, 
    -0.13968462f, 0.00090580f, -0.04634054f, 0.18585679f, 0.03049935f, -0.17032519f, -0.21019590f, -0.14025372f, 
    -0.08772059f, -0.17073417f, 0.08130573f, 0.17462452f, 0.03371580f, -0.02001186f, 0.18994637f, 0.14012501f, 
    -0.31443688f, -0.01658350f, -0.33528548f, -0.85685217f, 0.21235229f, 0.08433840f, -0.04868471f, -0.43807980f, 
    -0.00178308f, 0.07424026f, -0.04120884f, -0.07042067f, -0.18818092f, 0.07323372f, -0.23005407f, -0.18862431f, 
    0.04932912f, 0.03671260f, 0.07296678f, 0.08035005f, -0.22558984f, -0.03464992f, -0.05358915f, -0.04296507f, 
    0.29514629f, -0.15830061f, 0.29966152f, -0.01015428f, 0.10209198f, 0.05804315f, -0.26053920f, -0.09094235f, 
    -0.34264895f, -0.08774573f, -0.59107143f, -0.53170145f, -0.70526940f, -0.07787568f, -0.17075504f, -0.36176950f, 
    -0.08321694f, -0.48253161f, 0.10287710f, 0.32325050f, -0.13268305f, -0.01582101f, 0.06505370f, 0.07094885f, 
    0.98935813f, -0.44074208f, 0.30935213f, -0.27077597f, -0.08694021f, -0.32220724f, -0.27003753f, 0.05931197f, 
    -0.11717696f, 0.00427488f, -0.15888591f, 0.11817621f, 0.20126532f, 0.50919628f, 0.13438772f, 0.43344343f, 
    -0.06488959f, 0.06872171f, 0.05316921f, -0.08041155f, 0.12809776f, 0.10379191f, -0.08081833f, 0.20617220f, 
    0.21119276f, 0.10360961f, 0.16841738f, -0.02242470f, -0.02857806f, -0.06679469f, -0.19398877f, -0.07993016f, 
    -0.00561863f, -0.13178131f, 0.08560780f, -0.04441741f, 0.13272381f, 0.11068249f, 0.21153772f, 0.17347266f, 
    -0.14470772f, 0.20622925f, -0.12091608f, 0.19944467f, -0.07199991f, 0.08936615f, 0.00088939f, 0.13060068f, 
    -0.55312592f, 0.81233704f, 0.70315075f, -0.17341618f, -0.09364212f, 0.10492878f, 0.02404674f, -0.26433042f, 
    -0.03726815f, 0.06623307f, -0.29614258f, 0.08303156f, 0.25156292f, -0.29972884f, -0.12050456f, 0.14696877f, 
    0.03404927f, 0.00564964f, 0.10328476f, 0.10042845f, -0.13815460f, -0.22562233f, 0.12044644f, 0.32088953f, 
    -0.65509742f, 0.12340321f, 0.08525866f, 0.17211337f, -0.06801914f, 0.06327418f, 0.04722572f, -0.04456013f, 
    0.00378554f, 0.05865781f, -0.10292902f, 0.14317514f, -0.37037334f, -0.09994299f, 0.22641471f, -0.01353261f, 
    0.04135344f, 0.00397277f, -0.02462933f, 0.00583479f, 0.06463314f, -0.10893980f, -0.09037280f, 0.15689854f, 
    -0.00633534f, 0.22226794f, 1.07603168f, 0.58741987f, 0.09017274f, -0.11219043f, -0.17974713f, 0.21066633f, 
    0.02381491f, -0.20582820f, 0.00759000f, -0.07564883f, -0.34280357f, -0.37019756f, 0.81442899f, 0.25971985f, 
    0.07440668f, 0.37876961f, 0.18860407f, -0.18320560f, 0.03827033f, -0.00612844f, 0.01777003f, 0.02029449f, 
    0.04973553f, -0.27205482f, -0.03472377f, -0.25404498f, -0.27751809f, 0.14202942f, 0.09149549f, 0.06828120f, 
    0.07840964f, -0.02608673f, 0.00211524f, 0.06974781f, -0.19175552f, 0.15589219f, -0.19443686f, -0.28646153f, 
    0.38228571f, 0.04043613f, 0.14179988f, 0.18862452f, 0.01041037f, 0.05440476f, 0.08874003f, -0.10559417f, 
    -0.16037086f, -0.02398378f, -0.02399327f, -0.42034468f, -0.09471728f, 0.12839407f, 0.10551199f, -0.10567527f, 
    -0.09200462f, -0.03083029f, 0.01327820f, -0.01646085f, -0.28153151f, 0.30107972f, 0.36585495f, 0.37534818f, 
    -0.06456052f, -0.13142924f, 0.15083863f, -0.00505439f, 0.04364628f, -0.08644396f, -0.11169106f, 0.02041584f, 
    -0.10486264f, -0.00490114f, 0.40816221f, 0.13045874f, 0.02301560f, -0.06562553f, 0.06721409f, -0.12031948f, 
    0.14775707f, 0.13909724f, -0.09436308f, 0.17395476f, -0.58436698f, -0.35312507f, -0.23263702f, -0.22767539f, 
    0.01494381f, -0.16140611f, -0.17471752f, -0.15317324f, 0.09146192f, 0.00723611f, 0.02548345f, 0.07614164f, 
    -0.59968036f, -0.26501596f, 0.39528987f, -0.72936279f, 0.28242743f, -0.32263410f, -0.08958840f, 0.00144025f, 
    0.12407183f, 0.03292512f, -0.09714860f, -0.06367800f, -0.00675082f, -0.36007652f, -0.51269376f, -0.35389802f, 
    0.03002690f, 0.11670969f, 0.00322023f, -0.04413363f, -0.02577797f, -0.07960035f, 0.03421086f, -0.15499830f, 
    -0.09082024f, 0.01754305f, 0.25130317f, -0.58064646f, -0.03121545f, -0.10580937f, -0.22396785f, 0.18935812f, 
    -0.01271396f, -0.19367759f, 0.11270077f, -0.09513417f, -0.94880295f, -0.46589082f, -0.26688686f, -0.42627153f, 
    0.01378042f, 0.02910777f, -0.00167628f, 0.02978813f, -0.07470322f, -0.13158469f, 0.04140332f, -0.04960364f, 
    -0.26803344f, 0.20482813f, -0.09299551f, 0.47600409f, 0.09470694f, 0.04223436f, 0.05560651f, -0.14619507f, 
    0.08217653f, 0.19291538f, 0.26676497f, 0.03355336f, 1.04011798f, -0.35050026f, -0.26589760f, -0.26510701f, 
    -0.47994101f, -0.18657538f, 0.15092464f, 0.06103373f, -0.03573992f, -0.26538992f, 0.25971487f, -0.01200755f, 
    0.04022142f, -0.40171134f, 0.03248709f, -0.41957060f, -0.22081360f, -0.17155178f, -0.09988812f, 0.10296112f, 
    -0.04900143f, 0.14213884f, -0.10686071f, -0.14586364f, -0.83666337f, -0.13721946f, -0.11816506f, -0.44503289f, 
    -0.26889443f, -0.06273229f, -0.12915410f, 0.07543065f, -0.07216900f, 0.01824542f, 0.02441269f, 0.00953500f, 
    -0.60080785f, 1.09648454f, 0.00143905f, -0.39112556f, 0.41125953f, 0.15704042f, 0.04066177f, -0.10847852f, 
    -0.55431890f, -0.02700962f, -0.09881987f, -0.08163367f, -0.08524574f, -0.17087087f, -0.06559893f, 0.27046251f, 
    -0.05776664f, -0.02655185f, -0.08383185f, -0.39256403f, -0.00236485f, 0.15267003f, -0.30260015f, 0.15992860f, 
    -0.05275670f, 0.26076940f, 0.48059955f, 0.07737331f, 0.17407854f, -0.30677181f, 0.05397422f, -0.25279418f, 
    0.07982650f, -0.09865517f, -0.15178676f, 0.11775032f, -0.04281276f, -0.07058104f, -0.71825379f, 0.33433807f, 
    -0.07743148f, 0.10836820f, -0.27281848f, -0.20612743f, 0.05403769f, -0.36670363f, 0.27132773f, 0.22870532f, 
    0.14519049f, -0.12295579f, 0.31328022f, 0.23524030f, -0.25648874f, -0.13435823f, -0.13512222f, -0.23405455f, 
    -0.21687382f, 0.15042306f, -0.01908261f, -0.04376163f, 0.02103682f, -0.29229400f, -0.00489599f, 0.17489329f, 
    0.28833374f, 0.21090348f, -0.05766762f, -0.06567199f, 0.04522578f, 0.10872966f, -0.07805187f, 0.11754382f, 
    -0.03730246f, 0.15116709f, -0.27493009f, 0.27767342f, -0.00605283f, 0.04382022f, 0.00407966f, -0.09347042f, 
    -0.00653503f, 0.15067397f, 0.01163766f, 0.17969133f, 0.20455226f, -0.01358712f, 0.04472654f, 0.30553779f, 
    0.19394226f, 0.01337826f, 0.05201583f, 0.09713188f, -0.09171598f, -0.03418270f, 0.05116888f, 0.04975340f, 
    -0.40448967f, -0.39469150f, 0.35128245f, 0.27383748f, -0.20413598f, -0.16212820f, 0.09192509f, 0.14646277f, 
    -0.05919209f, 0.01715357f, -0.11433133f, -0.04801377f, 0.10149308f, 0.35126126f, -0.06248323f, -0.30772036f, 
    -0.07337693f, -0.13970633f, -0.13748848f, 0.02922540f, 0.15087493f, 0.14477757f, -0.00388161f, -0.36952552f, 
    -0.26539215f, -0.04658680f, 0.87795329f, 0.00320116f, -0.27693871f, 0.04561028f, -0.16336873f, 0.10330527f, 
    0.31968376f, 0.03161555f, 0.15729365f, 0.09127624f, -0.19087704f, -0.31707782f, -0.10967575f, 0.18808436f, 
    0.03084488f, 0.11430195f, -0.01682821f, 0.13658324f, -0.08934969f, 0.00707838f, -0.08986332f, -0.12336423f, 
    0.02852816f, -0.04684991f, 0.14027968f, 0.20012066f, -0.17857821f, -0.26121771f, -0.18595040f, -0.12982868f, 
    -0.18998557f, -0.21951824f, -0.18834756f, 0.03980150f, -0.33198863f, 0.11501732f, -0.14240693f, -0.07575305f, 
    0.01417455f, -0.07514831f, -0.04125731f, 0.10432871f, 0.09374763f, -0.14893635f, -0.18144640f, -0.00881164f, 
    -0.81178081f, -0.26453048f, -0.34358683f, 0.12620789f, -0.00783488f, 0.08211481f, -0.07225125f, 0.14719673f, 
    -0.05453190f, -0.06369349f, -0.07776017f, 0.20146328f, -0.06350999f, -0.11621325f, -0.09646360f, 0.03215762f, 
    0.05468462f, -0.00364080f, 0.15820074f, -0.15520538f, 0.19231302f, -0.00470719f, 0.04640729f, 0.00648636f, 
    0.19351894f, -0.65539163f, -0.27348837f, 0.10569350f, -0.25810069f, 0.08893178f, 0.11356981f, -0.27835763f, 
    -0.13304035f, 0.07930392f, -0.05478133f, -0.03615902f, -0.18319695f, 0.06058497f, 0.07988989f, 0.08589971f, 
    -0.28269771f, -0.32890767f, 0.03624757f, -0.12791140f, 0.04605529f, 0.01014326f, 0.03506895f, 0.11420040f, 
    -0.05757228f, -0.28708664f, 0.15525080f, 0.01385204f, -0.02468133f, 0.12745848f, 0.08145121f, 0.13978322f, 
    -0.04176940f, -0.06595489f, 0.04547499f, -0.23585993f, -0.11410882f, -0.21868767f, 0.51905119f, 0.17589612f, 
    -0.18871620f, -0.17495246f, -0.17434485f, -0.17002437f, -0.26330635f, 0.04666436f, -0.38716051f, 0.06072477f, 
    0.12323551f, -0.05061480f, -0.05331804f, 0.25581133f, -0.06983990f, -0.00052928f, -0.05914364f, 0.08608272f, 
    0.21687219f, -0.11218170f, -0.01219071f, -0.05281283f, 0.24669503f, 0.20294091f, 0.25268939f, 0.09724969f, 
    -0.07115840f, -0.10489704f, 0.01629058f, 0.01596612f, 0.26487392f, -0.07921609f, -0.01277094f, 0.10891152f, 
    -0.08421491f, -0.02640541f, -0.15815996f, -0.18662597f, -0.07196745f, -0.03186806f, 0.04152332f, 0.05994089f, 
    0.14130846f, 0.05541812f, 0.12605162f, 0.37836486f, 0.18052696f, 0.33829677f, 0.34295914f, 0.18798816f, 
    0.00781886f, -0.04661179f, -0.04003337f, -0.05314893f, 0.04010563f, 0.14208570f, 0.00533813f, -0.06360099f, 
    -0.07699696f, 0.73277426f, -0.55008221f, 0.11490868f, 0.32960865f, -0.18219545f, -0.16914020f, -0.04892632f, 
    0.06576213f, 0.06742127f, 0.00250831f, -0.15518986f, -0.80326670f, -0.16527829f, 0.00274553f, -0.57576478f, 
    0.01718739f, 0.02979807f, 0.00693883f, 0.14281142f, -0.08759992f, -0.13450557f, -0.02499801f, -0.19668111f, 
    0.37061462f, 0.03102377f, -0.25993842f, 0.40885276f, 0.32246801f, -0.03453114f, 0.21553142f, -0.06589039f, 
    0.06440172f, 0.08286969f, 0.12986593f, 0.14537501f, 0.00513020f, 0.08776107f, 0.21385799f, 0.15610588f, 
    0.02992704f, 0.05823571f, 0.08676652f, 0.00590192f, 0.00719627f, -0.07921018f, -0.05175931f, 0.12686662f, 
    0.07955291f, -0.29908356f, -0.17523348f, -0.59154427f, 0.01536453f, 0.09332337f, -0.01407216f, 0.07686333f, 
    0.26103511f, 0.04819003f, -0.08191143f, 0.02186521f, -0.77622396f, -0.06654103f, 0.18088688f, -0.00140593f, 
    0.04912371f, -0.16738690f, 0.19780812f, -0.06597665f, 0.06862530f, 0.44248074f, -0.23288083f, -0.13999996f, 
    0.38910675f, -0.57562780f, 0.12347390f, 0.27530283f, 0.06365871f, -0.00715727f, 0.00673679f, 0.03270283f, 
    -0.06165008f, 0.20442805f, 0.09504978f, -0.13399594f, -0.24331544f, -0.33254889f, -0.26558822f, 0.22769444f, 
    0.01538123f, -0.08754163f, 0.03576771f, 0.05435878f, 0.04211491f, 0.07649811f, 0.04557806f, -0.16760965f, 
    -0.92869765f, -0.10946332f, 0.14425083f, -0.14704567f, -0.15487672f, -0.03133288f, -0.11980212f, 0.04842045f, 
    0.14101957f, -0.06116261f, -0.18066788f, -0.04040909f, 0.07064475f, 0.09756710f, -0.29562622f, -0.14680845f, 
    0.13470706f, 0.25504649f, 0.09502006f, 0.30637801f, -0.09088115f, -0.05561059f, 0.10262231f, 0.08606254f, 
    -0.03807193f, 0.02435326f, -0.05659200f, -0.03968780f, 0.45025662f, 0.04588349f, -0.05882098f, 0.00782427f, 
    0.17549734f, 0.01763267f, 0.12241817f, 0.12173607f, 0.01713921f, 0.44386145f, -0.01270624f, -0.55255097f, 
    0.05015806f, 0.15982021f, 0.17233390f, -0.00353231f, -0.00186987f, 0.16676517f, 0.13712774f, -0.11334649f, 
    0.20313223f, 0.12055214f, -0.08660292f, 0.27690282f, 0.21003492f, -0.06974915f, -0.31996047f, 0.30203000f, 
    0.01087828f, -0.00184097f, 0.03473471f, 0.06798920f, -0.22809546f, -0.17071047f, -0.25075445f, -0.36811820f, 
    -0.04800389f, -0.02866506f, -0.04645371f, -0.03133553f, -0.09555811f, -0.11945401f, 0.08887963f, -0.10555419f, 
    -0.19380863f, -0.05313058f, 0.03261760f, -0.32329652f, -0.04869187f, -0.03115937f, 0.12015478f, 0.02536484f, 
    -0.00266818f, -0.65991771f, -0.17594703f, -0.70718783f, 0.33516213f, 0.05401804f, 0.25201741f, 0.17030808f, 
    0.05227379f, 0.18686578f, -0.09034882f, -0.20139459f, 0.04225138f, -0.24108569f, 0.08977128f, -0.20852599f, 
    0.06118173f, 0.14298451f, -0.55527854f, 0.00094844f, 0.09564225f, 0.34232411f, 0.13306326f, 0.13585785f, 
    -0.03603075f, 0.05214826f, 0.15708019f, -0.05493847f, -0.01312424f, -0.38740912f, -0.03155713f, 0.53534418f, 
    -0.03973410f, 0.01085869f, -0.08714733f, 0.03094678f, -0.08951204f, -0.09823504f, 0.21883370f, 0.30033496f, 
    -0.32047725f, -0.22892566f, -0.38014299f, 0.16202155f, -0.05023952f, 0.05481209f, 0.09818800f, -0.01947462f, 
    -0.03632461f, -0.02338293f, -0.21130466f, -0.21609972f, 0.06474555f, 0.42703474f, 0.26670530f, -0.14368673f, 
    0.14229870f, 0.08167115f, 0.31224716f, -0.17612472f, 0.20350474f, -0.09243252f, 0.09561200f, 0.18392855f, 
    -0.13518722f, 1.04404080f, -0.02332324f, 0.30676234f, -0.12298766f, 0.06893913f, 0.01898059f, 0.21152683f, 
    0.07421998f, 0.11782744f, 0.38637552f, -0.27389354f, 0.06350380f, 0.11399113f, -0.12477238f, -0.09220023f, 
    0.17981215f, -0.01280485f, 0.01464925f, 0.08607071f, -0.03486078f, 0.04815523f, 0.46015388f, 0.10340050f, 
    0.20862713f, 0.05805149f, -0.55769771f, -0.00059874f, 0.01015482f, -0.14704995f, 0.15279908f, 0.26611200f, 
    -0.11461103f, -0.05221715f, 0.08113784f, -0.00495384f, 0.22918512f, -0.14594907f, -0.36694714f, -0.14353170f, 
    -0.07962910f, 0.00713926f, 0.02448734f, -0.05522864f, -0.02510948f, 0.02623593f, -0.08521391f, -0.15098022f, 
    -0.18796088f, -0.58444101f, 0.41544181f, -0.10157254f, 0.03108530f, -0.06177278f, 0.07353769f, -0.02938640f, 
    -0.06767505f, 0.22020946f, 0.18964942f, 0.02496084f, -1.31450093f, -0.55050039f, -0.74032712f, -0.08339750f, 
    -0.46668038f, 0.06445245f, -0.29940280f, 0.11212344f, 0.07442537f, -0.03370822f, 0.03100778f, -0.02684991f, 
    -0.21929224f, -0.39899299f, -0.17748810f, -0.53712267f, 0.02344430f, 0.21999200f, 0.13132916f, -0.03683355f, 
    0.01560602f, 0.04615366f, -0.15795451f, -0.03763290f, -0.92958689f, -0.18340114f, 0.73663110f, 0.62625647f, 
    0.12264162f, 0.02186484f, -0.03252890f, 0.05863082f, 0.00250641f, 0.04352368f, 0.01841589f, 0.06846951f, 
    -0.28385505f, -0.48054951f, -0.97085655f, -0.42623025f, -0.22414096f, 0.12479108f, 0.29795319f, -0.15753673f, 
    -0.03726921f, 0.10862705f, -0.16808133f, 0.19853157f, -0.63458049f, 0.52763736f, 0.64186066f, -0.17575975f, 
    -0.15074334f, 0.19941638f, -0.07811815f, -0.04551408f, 0.08613835f, 0.04800050f, 0.11844658f, 0.14441462f, 
    0.08463213f, 0.08969387f, -0.29253083f, 0.17769001f, -0.12431965f, 0.03580153f, 0.25773588f, 0.23353696f, 
    0.06414772f, 0.13113354f, 0.21828073f, 0.31552759f, -0.58404279f, -1.50191033f, -1.20036936f, -0.07955340f, 
    -0.33871016f, 0.15867813f, 0.09987257f, -0.30157793f, 0.11958830f, -0.10168412f, 0.01620278f, -0.13158563f, 
    0.73506778f, -0.74578488f, 0.20907938f, -0.62972158f, 0.08554968f, 0.10003269f, 0.29961288f, -0.43131673f, 
    0.04995551f, 0.16035053f, 0.07729364f, 0.21039779f, 0.03757683f, 0.04628689f, -0.08851609f, 0.13036844f, 
    0.04378792f, -0.06862240f, 0.04443038f, 0.06359766f, -0.13231644f, 0.09596016f, -0.04144879f, 0.20499964f, 
    0.06633805f, -0.17212535f, -0.05621192f, -0.07617573f, 0.08013579f, 0.12734680f, 0.18797702f, -0.04421527f, 
    -0.20181671f, -0.25534618f, -0.00443272f, 0.13240647f, -0.99215466f, -1.49030793f, -0.66181493f, -0.11568583f, 
    -0.11635784f, -0.43775547f, -0.14404000f, -0.44550127f, -0.09109816f, -0.08980186f, -0.05288487f, -0.19408552f, 
    -0.83959156f, -0.17729463f, -0.79208905f, -0.11406341f, 0.28653193f, -0.18598662f, 0.31894311f, -0.16573267f, 
    -0.15719439f, 0.16201660f, 0.15470666f, 0.18366691f, 0.30703402f, 0.16505338f, 0.08482394f, -0.08689070f, 
    0.01099882f, -0.04437520f, -0.04119224f, -0.15826075f, 0.05813260f, 0.05094006f, -0.33251685f, -0.32938406f, 
    0.25152615f, -0.32916540f, 0.13550967f, -0.29412180f, -0.04744656f, 0.05669471f, -0.07838736f, -0.04511821f, 
    -0.09305124f, -0.16918643f, -0.08503707f, 0.01492312f, 0.05498576f, -0.06191529f, 0.08092586f, -0.00025134f, 
    -0.12873019f, 0.01178122f, -0.13542338f, -0.00178299f, 0.18742743f, -0.01655209f, 0.00082250f, 0.02548673f, 
    1.11255348f, -0.47487792f, 0.17433164f, -1.10809982f, 0.14773819f, 0.11225317f, -0.20413491f, 0.24442214f, 
    -0.05002981f, 0.21275197f, -0.18747620f, -0.09508336f, -0.39570013f, -0.97590005f, -0.48941439f, -0.96118766f, 
    -0.16835870f, 0.10517700f, 0.13835141f, 0.06267957f, 0.16377369f, 0.15344654f, -0.03173805f, -0.10115640f, 
    -0.23264144f, 0.08633259f, 0.21932445f, -0.04609433f, -0.02769582f, -0.22005863f, 0.03983713f, -0.05878865f, 
    0.12279133f, -0.04082589f, 0.02636068f, 0.00285728f, 0.13595365f, -0.64304590f, -0.06932950f, -0.57093877f, 
    -0.09153926f, 0.21957920f, -0.04281533f, 0.08722015f, -0.22065143f, -0.01448234f, -0.01238021f, -0.01601480f, 
    -0.18779755f, 0.25073338f, -0.35574466f, 0.20703222f, 0.12701774f, -0.02541068f, -0.21426292f, 0.05707602f, 
    -0.07251491f, 0.06042584f, -0.09973855f, 0.14076561f, 0.83843541f, -1.23264921f, -0.38016486f, -0.08364999f, 
    -0.13875479f, -0.22609270f, 0.05674540f, 0.12112615f, 0.24508612f, 0.07163926f, 0.02982107f, 0.07508589f, 
    0.01199837f, -0.36211783f, 0.05925118f, 0.21767482f, -0.05042721f, -0.17516033f, -0.05825599f, -0.14187028f, 
    0.05678904f, 0.05661234f, 0.22293431f, -0.24743882f, -0.79419017f, -0.88594794f, -0.08902191f, 0.60016102f, 
    0.13789470f, 0.11259343f, -0.00221985f, -0.01427549f, 0.07487940f, -0.07169084f, 0.04429887f, 0.02644573f, 
    -0.85089320f, 1.02868998f, -0.24262416f, 0.00360375f, -0.32168245f, 0.10630517f, 0.07358920f, 0.13154028f, 
    0.09458652f, -0.06893726f, 0.06749813f, 0.02935495f, 0.15388711f, 0.02058983f, -0.38946214f, -0.27368397f, 
    0.10527205f, 0.03839125f, -0.07333115f, -0.09398888f, 0.03223882f, -0.05439157f, -0.08384704f, -0.34833473f, 
    0.05351606f, 0.20631693f, -0.06965613f, -0.03481120f, -0.03342771f, -0.09102976f, 0.08399897f, 0.01898629f, 
    0.07475030f, 0.19915956f, 0.11783716f, -0.04196012f, -0.48963878f, 0.07496875f, 0.70870197f, 0.47690442f, 
    -0.03581916f, -0.16653134f, -0.05058949f, 0.24353291f, -0.01445277f, -0.03905790f, -0.08115110f, -0.00770039f, 
    -0.71967423f, -0.99765700f, 0.02779574f, 0.17275944f, 0.14132378f, 0.44477028f, -0.00671668f, 0.26774743f, 
    0.07744392f, 0.20261152f, 0.24776952f, 0.24449328f, -0.00701843f, 0.07464061f, -0.04697356f, -0.41719136f, 
    0.16222106f, 0.01800988f, 0.11603180f, 0.13585255f, -0.01034157f, 0.20990752f, 0.16743162f, 0.28897989f, 
    0.54796052f, 0.36556536f, -0.04249571f, -0.48220059f, 0.16518423f, -0.08744118f, -0.01936576f, -0.07729135f, 
    0.16559303f, -0.02126049f, 0.31311080f, -0.01690762f, -0.46822694f, 0.46672460f, 0.23443159f, -0.08433410f, 
    -0.00500373f, -0.16122647f, -0.07392681f, -0.10832401f, -0.25141594f, -0.01085824f, 0.04223409f, 0.05554611f, 
    -0.06339737f, -0.09569892f, -0.61263382f, -0.46043772f, -0.11979474f, -0.18760000f, 0.28248993f, 0.18722610f, 
    0.18738644f, 0.04993818f, -0.15065117f, -0.03481925f, -0.13500665f, -0.78615725f, -0.57503217f, 0.22746524f, 
    0.16412964f, 0.42887434f, 0.17592433f, -0.04655359f, -0.02126338f, -0.08722902f, -0.22078092f, 0.12125494f, 
    -0.04093901f, 0.09111263f, 0.09105100f, 0.24187423f, 0.05964279f, -0.02686747f, -0.18645918f, -0.16736843f, 
    0.17517233f, 0.30049235f, 0.00099042f, 0.19085917f, 0.44841218f, 0.04356109f, -0.19092983f, -0.15775433f, 
    0.07327481f, -0.00916265f, 0.19603899f, -0.21086508f, 0.07855275f, -0.10404322f, -0.05205637f, 0.13097060f, 
    0.11912034f, 0.51114553f, 0.23684727f, 0.66088355f, 0.08919939f, 0.10177539f, 0.06259941f, 0.08039575f, 
    -0.01912929f, -0.00695127f, 0.02921392f, -0.17354175f, -0.20513803f, -0.35791487f, -0.21626556f, -0.16352981f, 
    -0.00744799f, 0.15040784f, 0.01314643f, 0.05460885f, -0.48237723f, 0.24378216f, -0.37642720f, -0.54800713f, 
    0.11639917f, -0.30286548f, 0.29966763f, 0.24968471f, 0.05282622f, 0.03706704f, 0.10612707f, 0.11947232f, 
    -0.14614359f, -0.18071660f, -0.12334913f, -1.01479959f, 0.26724818f, 0.07871310f, -0.11431599f, -0.15191370f, 
    0.23982503f, -0.01590376f, -0.11852879f, 0.22872812f, -0.06156917f, 0.13858832f, -0.02806234f, -0.06278437f, 
    -1.76950955f, 0.08586910f, 0.13712487f, 0.57267046f, -0.07501683f, -0.15525925f, -0.24170643f, 0.11532012f, 
    -0.17114519f, -0.13300848f, -0.04199171f, -0.01975794f, 0.39538985f, -0.01356573f, -0.25021616f, -0.23667568f, 
    -0.07023618f, -0.07290429f, 0.14809343f, 0.13191901f, 0.22957958f, 0.05937213f, 0.13832831f, 0.08288088f, 
    -0.66953713f, -0.09010985f, 0.11520617f, -0.15802000f, -0.19529058f, -0.18896526f, -0.12717700f, -0.02354830f, 
    -0.36010560f, -0.19176540f, -0.29029682f, -0.29193693f, -0.27564254f, -0.32393184f, -0.69353700f, -0.50308484f, 
    -0.02737725f, -0.17839724f, -0.05278466f, -0.16446397f, -0.02179035f, 0.09504435f, 0.10191219f, 0.10338342f, 
    0.25593257f, -0.36250788f, 0.62664986f, -1.17871439f, 0.07813898f, -0.55917096f, -0.08060922f, 0.03438075f, 
    -0.48510757f, 0.01591482f, 0.17619444f, -0.16519243f, -0.35175437f, -0.04144400f, -0.12636460f, 0.63636643f, 
    0.01127082f, -0.21086113f, -0.11440130f, -0.39689988f, 0.18861820f, -0.28663948f, 0.18877791f, -0.03119154f, 
    -0.05099904f, 0.01544483f, -0.11486262f, 0.35192427f, 0.07050785f, -0.04454929f, 0.04462707f, -0.29681984f, 
    0.11100596f, 0.05363581f, 0.13815653f, -0.10063127f, 0.21856464f, 0.10338483f, -0.91629994f, -0.04412530f, 
    0.33676690f, 0.31203169f, 0.27636051f, -0.03717973f, 0.17056027f, -0.07826974f, -0.03879704f, 0.18681559f, 
    -0.49101308f, -0.45197523f, -0.04797916f, 0.50849068f, -0.32394722f, 0.36916658f, -0.41194156f, -0.11248103f, 
    0.01180539f, -0.12508959f, -0.01418439f, -0.12754890f, 0.00367243f, 0.17542581f, -0.24635376f, 0.09094712f, 
    0.05119546f, -0.18446873f, -0.27937055f, 0.35989168f, 0.13707952f, -0.09307020f, 0.06182233f, 0.06653062f, 
    -0.11977796f, -0.39470747f, -0.31989259f, 0.03145461f, 0.22051589f, 0.00900404f, 0.03408703f, 0.27932358f, 
    0.01070308f, -0.22789992f, -0.10013802f, -0.36809552f, 0.26010260f, -0.67585778f, 0.04881521f, -0.31320441f, 
    -0.10157988f, -0.02643246f, -0.24243246f, 0.15796138f, 0.01923386f, -0.05425199f, -0.10132693f, 0.13595185f, 
    -0.78042638f, 0.00871880f, -1.32892072f, 0.39193615f, 0.11451184f, -0.05020307f, 0.25622118f, 0.07287896f, 
    0.10207183f, -0.00939397f, -0.09409741f, 0.07548991f, 0.06966425f, 0.27710876f, 0.67562330f, -0.03650963f, 
    -0.02266604f, -0.19668508f, -0.07967572f, -0.28697202f, 0.02211268f, -0.13755634f, 0.14873774f, 0.19507451f, 
    0.26851803f, -0.08087812f, 0.29996574f, -0.26784247f, 0.00387624f, 0.00553618f, -0.01207459f, -0.13622361f, 
    0.06393006f, 0.09693272f, 0.25836539f, 0.34208855f, 0.44170830f, 0.45376027f, -0.63589215f, 0.12698273f, 
    -0.08917180f, 0.03754508f, 0.14220951f, 0.27403846f, -0.07064011f, 0.12171808f, -0.00552129f, -0.03375895f, 
    -0.15401380f, 0.49501491f, -0.44882885f, -0.25259688f, -0.10070341f, 0.05242692f, 0.13685697f, 0.06073983f, 
    0.06688514f, 0.16634397f, 0.06239827f, 0.09601808f, -0.52921546f, 0.00979171f, -0.24543788f, 0.35916325f, 
    0.01527743f, -0.07627638f, -0.11104371f, -0.13665228f, 0.03326945f, 0.16338511f, -0.05756018f, -0.00763371f, 
    -0.14951444f, -0.13278054f, -0.14265180f, 0.01839533f, 0.04546805f, 0.23791483f, 0.26303416f, -0.06099200f, 
    0.02661802f, 0.09996541f, -0.10461067f, 0.24434184f, -0.61933827f, -0.12396590f, 0.43699694f, -0.50344789f, 
    -0.19672838f, -0.03306910f, -0.12964281f, 0.35729402f, 0.15299256f, 0.04314259f, 0.09980118f, -0.06952523f, 
    0.28702930f, 0.35444197f, -0.25287437f, 0.58877778f, -0.05049270f, -0.06701084f, 0.05998885f, 0.14691631f, 
    0.10664804f, 0.09164128f, -0.11440857f, 0.16688670f, -0.02446946f, 0.05078374f, 0.19219771f, -0.28334722f, 
    -0.32203168f, 0.17626315f, 0.34100088f, 0.00839037f, 0.08177966f, 0.30511215f, -0.28715801f, 0.07056617f, 
    -0.85748899f, 0.51422542f, -0.80983746f, -0.26831299f, -0.17155980f, -0.14210418f, 0.19640921f, 0.15716097f, 
    -0.05680564f, -0.12011404f, -0.00126604f, -0.12394578f, -0.11980754f, -0.25439799f, -0.39104304f, -0.28320107f, 
    -0.18244895f, -0.82852942f, 0.26328862f, 0.24079339f, -0.44311509f, 0.32471296f, -0.00905640f, 0.10273727f, 
    -0.30542362f, 0.56564724f, -0.28245866f, 0.05073943f, 0.24181922f, 0.13195854f, -0.09127981f, -0.19521753f, 
    -0.07565422f, 0.11788037f, -0.17917870f, -0.10876779f, -0.47093889f, 0.13977039f, 0.07335281f, 0.33460566f, 
    -0.08800563f, 0.30604300f, 0.06564532f, 0.20186061f, -0.20977077f, 0.22753417f, -0.11719507f, -0.09130771f, 
    -0.39661756f, -0.13054277f, 0.36620203f, 0.09886718f, -0.24251229f, 0.17157914f, 0.29576972f, 0.21459772f, 
    -0.17503305f, 0.12126963f, 0.38274994f, 0.29835320f, -0.37541232f, 0.50376004f, 0.23203650f, 0.20864703f, 
    0.02296193f, 0.25089455f, 0.29852903f, -0.02635924f, 0.10374555f, -0.04837676f, -0.17902000f, -0.02528288f, 
    0.05837682f, -0.80085790f, 0.21091475f, 0.03388028f, -0.22562143f, 0.48161280f, -0.11075218f, -0.00181368f, 
    0.02152786f, -0.03499727f, 0.10632259f, 0.10946555f, -0.17466861f, 0.13195075f, -0.44313854f, 0.35664460f, 
    0.04472610f, -0.26986113f, -0.14497599f, -0.08193205f, -0.29877406f, -0.09685760f, -0.40736121f, -0.51810807f, 
    -0.43053177f, 0.66618443f, -0.06492290f, 0.01726547f, 0.10548037f, -0.20360059f, -0.05832772f, 0.13643400f, 
    -0.18606743f, -0.30952063f, -0.60210645f, -0.64947766f, -0.39607406f, -0.16697454f, -0.35193476f, -0.29937980f, 
    -0.18055840f, 0.46454966f, 0.32830292f, -0.16293663f, -0.23059151f, 0.18393303f, -0.11810162f, 0.06690179f, 
    0.35999262f, -0.20921806f, 0.56230801f, 0.08609360f, -0.00301668f, 0.22632509f, -0.20393442f, 0.08458406f, 
    -0.09068158f, -0.23555465f, 0.04716439f, -0.05441209f, -0.22196944f, -0.34483752f, 0.60499585f, 0.20802650f, 
    -0.19219901f, 0.15477714f, 0.03966523f, 0.03131378f, 0.14557067f, -0.30789027f, 0.20975283f, 0.32126364f, 
    -0.05028600f, -0.39223659f, 0.21382707f, -0.11125521f, -0.14318366f, -0.52383441f, 0.17074206f, -0.15442312f, 
    -0.02989968f, 0.13816041f, -0.20489243f, -0.31580418f, -0.18126063f, -0.75189650f, -0.43072206f, 0.01264156f, 
    -0.21014342f, -0.04573783f, -0.01795457f, 0.26726684f, 0.18029825f, 0.11201816f, 0.19105320f, -0.06749775f, 
    -0.70934385f, -0.61689878f, 0.22363156f, -0.34698966f, -0.07206997f, 0.01349227f, 0.03819813f, 0.27216533f, 
    -0.36474007f, -0.15674683f, -0.09485956f, -0.08782998f, 0.39688069f, -0.19359820f, -0.19101025f, -0.04657335f, 
    0.02683314f, 0.23021702f, -0.00844192f, 0.22266254f, -0.02762356f, -0.04005264f, 0.12476472f, 0.24046633f, 
    0.62904984f, -0.11349707f, 0.07613662f, 0.17143776f, -0.00295374f, -0.10501008f, 0.00927810f, 0.05557369f, 
    0.16465122f, -0.11511403f, 0.05766476f, -0.04072304f, 0.21017423f, 0.04860341f, 0.51287442f, -0.05911373f, 
    -0.08467791f, 0.22823577f, -0.03403582f, 0.31679317f, -0.43527755f, -0.29827148f, 0.09437980f, -0.25822037f, 
    -1.22961855f, 0.58794785f, -0.95162058f, 0.90357906f, 0.36594951f, -0.23561701f, 0.22026631f, -0.30144551f, 
    0.03497561f, 0.06705330f, 0.25971231f, 0.05303786f, 0.16110575f, 0.19015925f, 0.19488876f, -0.03056225f, 
    -0.22182329f, -0.05937595f, -0.06571144f, -0.02145610f, 0.04011896f, -0.00450203f, -0.01368932f, -0.16033645f, 
    0.33587462f, 0.35455361f, 0.02106194f, 0.04227900f, -0.39314523f, 0.04040857f, -0.26654643f, 0.04417519f, 
    -0.27842614f, -0.09536885f, -0.15456194f, -0.28239161f, -0.22772522f, -0.10114761f, 0.16011742f, 0.70728141f, 
    0.08857378f, 0.22363269f, -0.06372306f, 0.00678658f, -0.18963741f, 0.16782697f, 0.02918191f, 0.03352702f, 
    0.57031214f, -0.27093422f, 0.69045532f, -0.38889495f, 0.03731669f, -0.42512625f, 0.01970781f, 0.02770361f, 
    0.01143095f, -0.06305887f, 0.02680890f, -0.02973827f, -0.23709136f, -0.41781437f, -0.58993018f, 0.17297304f, 
    -0.04278661f, -0.03111334f, -0.04363823f, 0.03394283f, 0.10073673f, 0.02972167f, 0.16971850f, 0.27679262f, 
    -0.35966700f, 0.30058104f, -0.39291787f, -0.08097677f, 0.07340270f, -0.00115178f, 0.06683458f, 0.22364952f, 
    -0.20533310f, 0.13765861f, 0.37451741f, 0.01398834f, -0.21957876f, -0.21755141f, 0.06955696f, 0.32431149f, 
    0.03674050f, -0.25290862f, 0.05523185f, -0.07882495f, 0.18915986f, -0.02553201f, 0.12085820f, 0.12720798f, 
    0.16104233f, -0.18301815f, 0.20055620f, -0.15764253f, -0.08557251f, -0.02069989f, -0.08100391f, -0.27202898f, 
    0.02852163f, 0.07513620f, 0.08851203f, -0.09902651f, 0.28968725f, -0.17929098f, 0.35490775f, -0.83854675f, 
    0.06816752f, -0.07957895f, -0.26623127f, 0.22291860f, -0.10587315f, 0.05339843f, 0.00533094f, -0.42477083f, 
    0.40552175f, -0.06211533f, 0.16234124f, -0.20032875f, -0.17226242f, 0.16610652f, -0.14078872f, -0.07279808f, 
    0.05261361f, 0.13780279f, 0.07571183f, 0.03353936f, -0.46505302f, -0.50905657f, -0.40338081f, 0.10365123f, 
    -0.20564280f, -0.23858188f, -0.20496541f, -0.28159288f, 0.08432303f, 0.21431749f, -0.02041007f, -0.08546340f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.38013479f, 0.05070879f, 0.18141349f, -0.17817681f, -0.24652810f, 0.14402683f, 0.16510062f, -0.18592624f, 
    0.24168126f, 0.00417535f, 0.05093576f, -0.05190354f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
