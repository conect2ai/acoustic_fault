#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.01919367f, 0.12208851f, -1.28549051f, -0.67401415f, -0.02402980f, -0.38839191f, -0.42352980f, -0.23230706f, 
    -0.03126905f, -0.00139633f, 0.32809484f, -0.43776721f, -0.75132036f, -0.51952469f, 0.26596439f, 0.42992750f, 
    0.22785050f, -0.52058780f, -0.44842267f, 0.00512762f, -0.31605944f, -0.08373092f, 0.25542539f, 0.48300934f, 
    -0.48325840f, -1.35830796f, 1.24454486f, 0.44950292f, -0.62009352f, 0.55944771f, -0.63295913f, 0.27911204f, 
    0.22364399f, -1.00118709f, -0.49587199f, 0.45333442f, 0.39182082f, -0.10977474f, -0.05876907f, -0.62328690f, 
    0.20383769f, 0.05726988f, 0.09678134f, -0.16594355f, -0.15616375f, 0.09465781f, -0.05018020f, 0.14219385f, 
    0.04210776f, 0.18001994f, 1.79034626f, 0.01695125f, 0.10342641f, 1.46001124f, 0.69279104f, 0.85137498f, 
    0.19674022f, -1.00285625f, 0.59382993f, 0.12567544f, -0.30976176f, 0.04971941f, -0.21263950f, 0.37602481f, 
    -0.13241151f, 0.45701349f, 0.14944181f, -0.10453518f, 0.07710327f, 0.11394190f, 0.16720712f, 0.13177164f, 
    0.17613406f, -0.15662861f, 0.15817431f, -0.39294955f, -1.29149544f, -1.33313060f, -0.48371586f, -0.52674133f, 
    -0.88382989f, 0.13314812f, 0.19682488f, 0.35443953f, 0.68229729f, 0.26286730f, 0.07597496f, 0.02251708f, 
    -0.21304308f, 0.54464471f, 0.01779287f, -0.12785079f, 0.06286579f, 0.11423273f, -0.19441471f, 0.15846674f, 
    0.09164856f, -0.03205083f, 0.12961073f, 0.21802969f, -0.66441500f, -0.87759268f, -0.86236769f, -0.29733190f, 
    -0.84538269f, 0.85636175f, 1.47537971f, 0.05662616f, 0.23383863f, 0.79709947f, -0.19941470f, -0.32422996f, 
    -0.15023801f, -0.49822479f, -0.15196960f, -0.02996670f, 0.15836203f, 0.12129645f, -0.03652956f, -0.12639745f, 
    -0.00790675f, -0.11117821f, 0.48880795f, -0.03218881f, 0.37777114f, -1.12269711f, -2.28632212f, -0.71847063f, 
    0.43376544f, 0.34882477f, 0.01089500f, 1.24219239f, 0.74650836f, -0.41228932f, -0.06089573f, -0.03405882f, 
    -0.31831855f, -0.30335557f, 0.02417092f, 0.20663045f, -0.00182819f, 0.00197947f, -0.15180101f, -0.26125097f, 
    -0.05753075f, -0.12370387f, -0.08528888f, -0.22826186f, -0.02839486f, 0.02886364f, 1.32114434f, 0.48793972f, 
    0.55619830f, 1.09013391f, 2.14351726f, 0.47714037f, 0.41917896f, 0.13806583f, -0.08006589f, -0.73737866f, 
    0.25097096f, 0.33281434f, -0.33512408f, -0.22234650f, -0.16003703f, -0.35998350f, -0.22089653f, 0.35914254f, 
    0.44127139f, -0.03725444f, -0.07950609f, 0.25249782f, 0.11829346f, -0.10100182f, -0.10029189f, -0.06919824f, 
    -0.45952845f, -0.58363813f, -1.06159604f, 0.02581965f, 0.18915424f, -0.81169176f, -0.93375409f, -0.99645406f, 
    -0.69105977f, 0.25331441f, 0.20262143f, 0.71083665f, 0.24556758f, 0.24252434f, -0.03468185f, 0.24458070f, 
    -0.30796751f, 0.41903031f, 0.80469787f, 0.04939079f, 0.28817248f, 0.61420012f, -0.01270396f, -0.23506401f, 
    1.08462048f, -0.23954582f, 1.18537068f, 0.15294386f, 0.18244694f, 0.84485924f, 0.55089241f, 1.11724317f, 
    1.08975995f, 0.30937839f, -0.45515242f, 0.08783616f, -0.74507874f, 0.45055920f, -0.43947744f, 0.06946669f, 
    -0.26657891f, -0.12378956f, 0.00283413f, 0.05619462f, -0.17842613f, -0.29051712f, 0.06513277f, -0.24813125f, 
    -0.22548501f, -2.17307091f, 0.98505217f, 0.41468632f, -0.83616877f, -0.21959788f, 0.79188645f, 0.55301237f, 
    -0.54286814f, 0.62722957f, 0.14317450f, -0.05515650f, 0.12687624f, 0.27408019f, 0.44323453f, 0.29543743f, 
    -0.13917479f, 0.04186942f, -0.07119091f, -0.07268196f, -0.22854592f, 0.36015722f, 0.19537853f, 0.22718418f, 
    0.09584373f, 0.21676137f, 0.07634328f, -0.54222482f, -0.40237427f, 0.28127781f, -0.88035935f, 0.40006265f, 
    0.05910930f, -0.63788188f, -0.52046055f, -0.85920370f, -0.23034602f, 0.45827299f, 0.61033863f, -0.42408058f, 
    0.38144138f, -0.63751203f, -0.30944958f, -0.41068232f, -0.36827978f, -0.65565419f, -0.05079533f, 0.09549986f, 
    0.47015879f, 0.25150430f, 0.14601444f, 0.01891409f, 1.19361103f, -0.81232238f, -0.80555111f, -1.37174177f, 
    1.35660589f, -0.18114564f, -0.17877018f, -0.00466165f, -0.11229661f, 0.58770305f, -0.08109377f, -0.00027057f, 
    0.21487224f, 0.01979288f, 0.32388896f, -0.03723935f, 0.11625580f, -0.15276279f, 0.09096108f, -0.17741048f, 
    -0.26227221f, -0.05780900f, -0.33896446f, -0.17273375f, 0.53168160f, -1.09574080f, 0.19922374f, 0.85217476f, 
    0.51616681f, -1.64215922f, 0.16280279f, -0.09998122f, -0.93286079f, -0.10937752f, 0.56543392f, 0.45320487f, 
    0.00936114f, -0.08064260f, -0.17301358f, -0.38166708f, 0.45066744f, -0.11165290f, -0.09259164f, -0.58039409f, 
    -0.49259132f, 0.38135552f, 0.32445619f, 0.23582026f, 0.06364068f, 0.13706565f, 1.41218388f, 0.47288090f, 
    0.15563409f, 0.06452636f, 0.56040567f, 0.13128182f, -0.48666587f, -0.88823593f, -0.50744200f, -0.21717297f, 
    -0.23140186f, 0.05562237f, 0.26889130f, -0.23010606f, -0.59477967f, -0.42992496f, -0.48545945f, -0.40788585f, 
    -0.00698250f, -0.71209610f, 0.36056557f, -0.34418476f, -0.45910668f, -0.20630755f, 1.54026115f, 1.22228360f, 
    0.84319746f, 0.53931040f, -0.24920194f, -0.27127123f, -0.54503757f, 0.23781596f, -0.04923123f, 0.41173831f, 
    0.59303623f, 0.24155156f, -0.04229809f, 0.15523370f, -0.24340136f, -0.05495304f, 0.38678175f, 0.19985259f, 
    -0.62024695f, 0.04676522f, 0.07950638f, 0.51382107f, 0.16445753f, 0.36408445f, -0.01606308f, 1.37008035f, 
    1.13704753f, -0.31186649f, -0.78844464f, 0.36635375f, 0.42811966f, -0.61516106f, 0.11288394f, 0.09821754f, 
    0.54006910f, 0.19250986f, 0.67363501f, 0.17355688f, 0.16678043f, 0.09184429f, 0.45040238f, -0.04701670f, 
    0.32187808f, 0.39006895f, 0.45062608f, 0.18876572f, 0.08109078f, -0.17560701f, -0.10862795f, 0.87485468f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.58677238f, 0.41546252f, 0.33542433f, 0.24431369f, 0.23101008f, 0.25543007f, 0.14817321f, 0.35621703f, 
    0.15868221f, 0.05794724f, 0.21605240f, 0.37183177f, 0.29030299f, 0.18970916f, 0.61011922f, 0.27508667f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12644912f, -0.11735044f, 0.45520011f, -0.11687870f, -0.08640999f, 0.24104087f, 0.07376800f, -0.04105821f, 
    -0.14494187f, -0.02399125f, 0.02720341f, -0.20817596f, -0.81491870f, 0.03016845f, 0.08581983f, -0.04599533f, 
    0.10235616f, -0.15283357f, 0.03341440f, -0.02992526f, 0.01741941f, -0.04534752f, 0.00256832f, -0.13797078f, 
    0.24609488f, -0.19971508f, -0.00617460f, 0.72433740f, -0.03668631f, -0.14022103f, -0.10033314f, 0.16060722f, 
    -0.08504365f, 0.13173142f, -0.13326165f, 0.12367321f, -0.40716967f, -0.20516449f, -0.38330758f, -0.27801475f, 
    0.12381809f, -0.17751713f, 0.10010575f, -0.13877383f, -0.00915504f, -0.12931123f, 0.05809242f, 0.25947607f, 
    0.45597956f, 0.38797289f, 0.27009606f, -0.48458421f, 0.13658331f, 0.05780280f, 0.04523628f, 0.09412415f, 
    -0.01642370f, 0.02480431f, -0.06627958f, 0.13709159f, -0.67113405f, 0.22566237f, 0.04323129f, -0.17165682f, 
    0.13127024f, 0.24507819f, -0.06921175f, -0.08464855f, -0.00178696f, -0.12179073f, 0.01204386f, -0.07038270f, 
    0.36465031f, -0.09692664f, 0.12348442f, 0.19403650f, -0.40359366f, 0.15257566f, -0.06331901f, 0.22529328f, 
    0.02785586f, -0.05922490f, 0.02169861f, -0.08481031f, -0.45076963f, -0.40139216f, 0.20316866f, -0.24139905f, 
    0.03266978f, 0.18511270f, 0.23563932f, 0.08421293f, 0.01733980f, -0.22275898f, -0.07226861f, 0.02502511f, 
    0.31516984f, 0.10724030f, -0.19342762f, 0.24012972f, 0.03133996f, 0.00315836f, 0.11462145f, -0.02867154f, 
    0.04458527f, 0.05353150f, 0.09786808f, -0.33537945f, 0.49404815f, -0.10327613f, 0.13069779f, -0.06336419f, 
    -0.00303582f, 0.06399014f, 0.06388381f, -0.03369332f, -0.00180870f, -0.07765370f, 0.06418415f, 0.06624012f, 
    -0.26887974f, 0.12587927f, 0.05406859f, 0.01943820f, -0.03082345f, -0.04209917f, 0.08579828f, -0.10598400f, 
    -0.03358177f, 0.10510710f, 0.07547768f, -0.04772300f, 0.32228619f, -0.15811056f, -0.20888348f, -0.56285769f, 
    -0.18570273f, -0.02771570f, 0.23669162f, -0.26350865f, -0.09111895f, -0.08710536f, -0.14081392f, 0.06383321f, 
    0.48805910f, -0.31087655f, -0.37688756f, 0.47458461f, -0.24030414f, -0.27305102f, -0.13263574f, -0.12991260f, 
    -0.12379597f, 0.09960979f, -0.08873947f, 0.03887461f, 0.06828838f, 0.18812063f, -0.08567718f, -0.08823338f, 
    -0.66417003f, 0.01636137f, 0.14794596f, 0.21266206f, -0.09764658f, 0.05565745f, -0.03352777f, -0.05660212f, 
    0.05807518f, 0.04865220f, -0.07053477f, -0.11664200f, -0.49100584f, -0.28484908f, 0.07268438f, -0.02995798f, 
    -0.22976685f, -0.02895234f, -0.14191240f, -0.17371245f, 0.00704324f, -0.07787564f, 0.36513415f, -0.52664703f, 
    -0.00895607f, -0.10064183f, 0.04249968f, 0.13394116f, 0.17698897f, 0.08361650f, 0.04457404f, 0.04873005f, 
    0.06188317f, -0.07157687f, -0.28504175f, -0.22197329f, -0.03767197f, -0.17854391f, 0.02752911f, -0.02404113f, 
    -0.02107387f, 0.00037717f, -0.26350340f, 0.16672413f, -0.00305989f, 0.14990860f, -0.61419219f, -0.42165476f, 
    -0.01979837f, 0.25581011f, 0.02910128f, -0.12454417f, 0.02724801f, -0.00537370f, -0.03046706f, -0.12169541f, 
    0.63415003f, -0.32978478f, 0.25286064f, 0.02195873f, -0.32006133f, 0.09577562f, -0.13211761f, 0.05316256f, 
    0.16310090f, 0.03359998f, 0.01173535f, -0.01934230f, 0.51063246f, 0.02722484f, -0.28278157f, -0.00651954f, 
    0.01289648f, -0.00576286f, 0.05326851f, 0.15601958f, -0.05270131f, -0.11584835f, -0.01515658f, 0.08504237f, 
    -0.05435788f, -0.22713570f, -0.30502263f, -0.16472156f, 0.03748972f, -0.06193142f, 0.00759300f, -0.09871914f, 
    0.17314500f, 0.02390139f, -0.09785526f, 0.01654710f, 0.47871944f, -0.14811148f, -0.13137718f, 0.22695585f, 
    -0.13429819f, 0.17056242f, -0.16582109f, -0.15504475f, -0.12796995f, 0.12099051f, -0.15763989f, 0.09776165f, 
    0.27197304f, -0.27664062f, 0.28332528f, 0.46593630f, 0.03042519f, 0.00623080f, -0.07004777f, 0.03164576f, 
    -0.26182231f, -0.03059228f, 0.05404171f, 0.03790302f, -0.05744026f, 0.12094951f, 0.22455359f, -0.29618245f, 
    0.00028032f, 0.01943071f, 0.15114772f, -0.09315339f, -0.13257708f, 0.23067315f, 0.19269827f, -0.15589850f, 
    0.54143488f, 0.00519430f, 0.19687431f, 0.21830590f, 0.14541247f, -0.06526443f, -0.11311506f, -0.10157364f, 
    0.07673373f, -0.05494467f, -0.05533314f, -0.15183464f, -1.18914354f, -0.05594581f, -0.06927359f, -0.15309118f, 
    -0.21803944f, 0.00917108f, 0.05292546f, 0.04570634f, 0.15273406f, 0.17281885f, -0.10434072f, -0.13993718f, 
    -0.14664717f, -0.25421184f, -0.11075970f, -0.12568939f, -0.00482415f, 0.08146799f, -0.12515846f, 0.21087375f, 
    0.05698812f, -0.35003236f, -0.08495393f, -0.05189079f, -0.16496652f, -0.28941479f, 0.15601514f, -0.41977608f, 
    0.07790282f, -0.11309777f, 0.09988271f, 0.04085159f, 0.06626004f, 0.23461260f, 0.01382802f, 0.01255543f, 
    -0.44771028f, -0.59254831f, -0.14411420f, 0.42294505f, 0.07857605f, 0.05960272f, -0.08857442f, 0.23830785f, 
    -0.01362869f, -0.27031764f, 0.08344761f, -0.12914477f, 0.26125011f, -0.10171806f, -0.04819821f, -0.44210497f, 
    0.00570236f, 0.21553272f, 0.18952474f, -0.22615497f, -0.11877485f, -0.00247871f, -0.05092632f, -0.25289455f, 
    0.25498226f, -0.02137791f, 0.17672043f, 0.38804501f, -0.06963336f, 0.01116352f, 0.10659837f, 0.02769709f, 
    0.10593501f, 0.03172257f, 0.18166521f, 0.08026623f, 0.35596085f, -0.19709033f, 0.16064286f, -0.13323355f, 
    -0.07913820f, -0.07124186f, -0.01488954f, -0.02183342f, -0.05350626f, -0.02296334f, 0.05731318f, 0.08070049f, 
    -0.38949880f, -0.59581465f, 0.00004455f, 0.09630962f, -0.38251358f, -0.06039396f, -0.05365264f, 0.03801356f, 
    0.11073365f, -0.07099372f, 0.22174028f, -0.00533660f, 0.54149383f, -0.27228135f, -0.81969446f, -0.02500849f, 
    0.25378215f, 0.10184917f, -0.01503387f, -0.09574538f, 0.00144914f, -0.10730457f, 0.11516219f, -0.09099896f, 
    0.02488939f, -0.55054516f, -0.14173739f, -0.03432075f, 0.25985157f, -0.00841351f, -0.03808442f, 0.00744134f, 
    -0.16774650f, 0.08089508f, -0.04403287f, -0.12543842f, 0.72809875f, -0.52282774f, 0.22763732f, 0.41892001f, 
    -0.19892971f, 0.02317720f, -0.14429972f, -0.10274613f, -0.08475918f, -0.01956629f, -0.01815293f, -0.00505498f, 
    0.49355209f, 0.13306171f, 0.50352257f, 0.33922255f, -0.11743049f, -0.46807310f, 0.04543973f, 0.16213566f, 
    -0.01203647f, -0.00860548f, 0.07783951f, 0.01917492f, 0.41319177f, -0.33620080f, 0.15697101f, 0.09623790f, 
    -0.37709320f, 0.13797204f, -0.21127470f, 0.19144447f, 0.20392230f, 0.03865076f, 0.06112397f, -0.08577316f, 
    0.02246271f, -0.00739133f, 0.24465041f, -0.15343109f, 0.27383927f, 0.02201351f, -0.00952635f, -0.09116958f, 
    -0.13869026f, 0.10471505f, -0.11759104f, -0.01693519f, -0.73936111f, -0.36945128f, 0.11229444f, -0.66028434f, 
    0.15490320f, -0.17464985f, -0.01704385f, -0.04643224f, -0.11414785f, -0.04400571f, -0.03893749f, -0.14364249f, 
    -0.27426928f, 0.25398475f, -0.25250846f, 0.10496263f, 0.00419240f, -0.00285786f, 0.03061235f, 0.14528982f, 
    -0.15863128f, 0.07494112f, -0.00700923f, -0.13412717f, 0.72197884f, 0.19961771f, -0.29703051f, -0.18271421f, 
    -0.09130669f, 0.11112946f, -0.15110384f, 0.13471955f, -0.04031197f, -0.08914416f, -0.14289823f, -0.02192845f, 
    -0.01455065f, 0.00159919f, -0.01231019f, -0.56721598f, -0.23699267f, -0.21853158f, -0.16525517f, -0.17654204f, 
    0.16792560f, 0.12913528f, -0.06435558f, -0.14509843f, -0.04401677f, 0.13672924f, 0.04737567f, -0.29602078f, 
    -0.07503302f, -0.16094021f, 0.01001102f, 0.18440653f, -0.11990803f, -0.22229345f, 0.07106622f, -0.13511512f, 
    0.83301854f, 0.03789116f, -0.20211865f, -0.31404451f, 0.14201872f, 0.12738323f, 0.13730614f, -0.00640952f, 
    -0.15398753f, 0.22046192f, -0.09959485f, -0.08510140f, -0.12504968f, -0.03050952f, -0.14613628f, -0.15642576f, 
    -0.05204563f, -0.14453697f, 0.13417245f, -0.31256267f, 0.09223823f, 0.18686639f, -0.15984875f, -0.02398683f, 
    -0.26767018f, 0.19458336f, 0.05209484f, -0.26352966f, -0.00399710f, 0.08840289f, 0.14288758f, 0.07132825f, 
    -0.14874272f, -0.01389104f, -0.03913289f, -0.09580316f, -0.10068282f, 0.07153618f, 0.07558908f, -0.30854627f, 
    0.07078239f, -0.10865728f, 0.30272576f, -0.16104402f, -0.16170198f, 0.05504012f, 0.01418203f, 0.10029275f, 
    0.34038624f, 0.12545761f, 0.14985482f, 0.00422193f, -0.20379061f, 0.17586504f, 0.00319329f, -0.06791708f, 
    0.10280246f, 0.08025886f, 0.08181146f, -0.14926223f, -0.07321783f, 0.40368098f, 0.53809416f, -0.08973447f, 
    0.12024903f, -0.01649528f, 0.04475269f, 0.08296651f, -0.06002127f, 0.27747798f, -0.01345115f, -0.10916747f, 
    0.14702019f, -0.39872947f, -0.47015119f, 0.03820301f, 0.06896553f, -0.05421527f, -0.03320945f, -0.16613121f, 
    0.02068439f, -0.10374781f, 0.03388970f, 0.00251263f, 0.18984315f, -0.20551804f, -0.06560408f, -0.32214570f, 
    -0.20419222f, -0.22544907f, -0.12315793f, -0.02058854f, 0.01650319f, -0.11477111f, -0.01073470f, -0.00619163f, 
    -0.33019823f, -0.18558371f, -0.11968788f, -0.20776883f, -0.08814185f, -0.16862111f, 0.10313240f, -0.18316101f, 
    -0.11937498f, -0.20164576f, 0.08890309f, -0.05860762f, 0.17427422f, -0.20940283f, 0.04073354f, 0.33160990f, 
    -0.08998058f, -0.29150206f, 0.26832628f, -0.03637025f, -0.12478890f, 0.02459154f, -0.15399484f, 0.02297736f, 
    -0.57970017f, -0.59371394f, 0.42938301f, 0.06596868f, -0.08387099f, 0.17663476f, 0.00360190f, -0.02192247f, 
    0.07207672f, -0.08232693f, 0.14135951f, 0.01633663f, 0.30412290f, 0.09600558f, 0.03814024f, 0.06917930f, 
    -0.12647580f, 0.07476856f, -0.21182661f, 0.15900621f, 0.04938190f, -0.22763640f, -0.16171955f, -0.14451037f, 
    -0.74732327f, -0.48878196f, -0.09189961f, -0.28343761f, -0.20312536f, 0.03409134f, -0.01545183f, 0.19994386f, 
    -0.13425253f, 0.08656333f, 0.11978785f, -0.03822671f, 0.57639331f, 0.62592638f, 0.07279927f, -0.25938889f, 
    -0.04358875f, -0.10804040f, -0.07841514f, -0.05614625f, 0.00008963f, -0.24493891f, -0.00502844f, 0.01775900f, 
    0.40063605f, -0.04127417f, 0.25521156f, 0.22245377f, -0.02864189f, 0.17944919f, 0.00712566f, 0.03829679f, 
    0.06160079f, 0.24657516f, 0.14215197f, 0.27600586f, 0.01516522f, 0.32692578f, -0.14259109f, 0.24288732f, 
    -0.23568776f, -0.02561009f, -0.03183539f, 0.31573895f, 0.06271282f, -0.11677839f, -0.06770206f, 0.16600309f, 
    -0.44301677f, 0.23261906f, 0.33125526f, 0.30648497f, 0.05909883f, 0.12172674f, 0.01672542f, -0.02171851f, 
    0.08215848f, 0.15070486f, -0.17965257f, -0.19982366f, 0.36147812f, -0.12655631f, 0.21515565f, 0.14187098f, 
    0.01002676f, 0.05969944f, -0.18313058f, 0.32743627f, 0.09834000f, 0.02631617f, 0.02162723f, -0.01282821f, 
    -0.32151911f, -1.18904805f, -0.87826055f, 0.09750841f, -0.14519145f, -0.05031153f, -0.18867189f, 0.19636041f, 
    0.00921207f, -0.03131853f, -0.13503647f, -0.19128627f, -0.56185418f, -0.11282511f, -0.26635504f, 0.13484049f, 
    -0.07734814f, -0.00171827f, 0.05869367f, 0.16554664f, -0.00135970f, 0.19468209f, -0.12689565f, 0.03314439f, 
    0.29619631f, -0.18771048f, -0.30159798f, 0.11490244f, 0.04201702f, -0.01140836f, 0.05616918f, -0.07203707f, 
    -0.07684445f, 0.03228768f, 0.17994869f, -0.10510661f, 0.07408739f, 0.42420587f, 0.25339550f, 0.01898201f, 
    -0.13319536f, -0.29603651f, 0.12413067f, 0.10864615f, -0.00295128f, 0.20068730f, -0.08678083f, -0.18331158f, 
    0.07256559f, 0.53429276f, 0.09781586f, 0.19566737f, 0.01583969f, 0.11971381f, 0.18497410f, 0.03539678f, 
    -0.06386770f, -0.16967162f, -0.04942071f, 0.15329623f, 0.20947975f, 0.18399918f, -0.20466490f, 0.42700461f, 
    -0.00213247f, -0.01090075f, 0.07514396f, 0.20487741f, 0.01680348f, 0.06343939f, -0.08403281f, -0.02850085f, 
    -1.09399509f, -0.10224040f, 0.10137349f, 0.45545280f, 0.01680242f, -0.00288966f, 0.00622722f, 0.10029513f, 
    -0.20888488f, 0.08397980f, 0.07313082f, 0.04003071f, -1.37681627f, 0.28816202f, -0.33650675f, -0.07050939f, 
    0.06788313f, -0.15554811f, 0.04560338f, 0.24930602f, 0.00179377f, -0.08948521f, 0.03463037f, 0.08322991f, 
    0.48814431f, -0.08448552f, -0.32537690f, -0.04452771f, -0.16659923f, -0.15192470f, 0.11537534f, 0.09602422f, 
    0.12752455f, 0.06106672f, -0.02579033f, -0.12686209f, -0.00838497f, -0.01816043f, 0.20816942f, 0.21773960f, 
    0.04518325f, -0.10560694f, 0.14723684f, 0.08010596f, 0.02949389f, -0.19678593f, -0.03411153f, 0.17612261f, 
    -0.35934898f, 0.04589387f, 0.12267830f, -0.06136436f, -0.13975123f, 0.04363709f, 0.00831420f, 0.06746207f, 
    0.07161836f, -0.05485284f, 0.05215955f, 0.22493842f, 0.49369314f, 0.24729156f, -0.14304565f, -0.45939913f, 
    0.16280061f, -0.13518234f, 0.05013802f, -0.11421023f, 0.17555386f, -0.02594897f, -0.08352652f, -0.07692241f, 
    -0.25109065f, 0.29850426f, -0.20804495f, -0.37449041f, 0.08734082f, -0.01866972f, -0.07836264f, -0.21289314f, 
    -0.11092415f, 0.09320705f, 0.02917101f, 0.12212719f, -0.11149000f, 0.16826046f, 0.02433765f, 0.17531283f, 
    0.01920958f, -0.01699355f, 0.00943547f, 0.10601425f, -0.14250696f, 0.01568678f, -0.01355809f, -0.01967499f, 
    -0.43814901f, -0.23657808f, 0.28357324f, 0.14776272f, 0.02206582f, -0.05008826f, -0.03639180f, -0.05367386f, 
    0.05456056f, 0.04555860f, -0.06354654f, -0.00045156f, -0.31509671f, 0.26958138f, 0.26973918f, -0.05908936f, 
    0.21987288f, -0.11746545f, 0.05292872f, 0.09112266f, 0.06655183f, -0.05365457f, 0.15554488f, 0.22820507f, 
    -0.21497557f, -0.49735641f, 0.09514348f, 0.11908843f, -0.31636432f, 0.17368461f, -0.10930275f, -0.09371532f, 
    0.12001541f, 0.11617974f, -0.16822398f, -0.12011588f, -0.21104158f, -0.65370566f, -0.47322473f, -0.04710509f, 
    -0.27592143f, -0.11997698f, 0.19281049f, -0.13981362f, -0.07343026f, -0.10672543f, 0.00856729f, -0.19326657f, 
    -0.23007916f, -0.28933018f, 0.24985707f, -0.04542864f, 0.34403631f, -0.10877715f, 0.14066558f, -0.16089571f, 
    -0.02330900f, 0.13808988f, -0.49949774f, -0.06137311f, -0.08448133f, -0.35877475f, 0.15843521f, 0.48762035f, 
    -0.15085009f, -0.10021719f, 0.00956880f, -0.00776289f, 0.11526181f, -0.00637031f, -0.03950846f, 0.23789214f, 
    0.00322074f, -0.05146065f, 0.10905139f, 0.05846684f, 0.03730446f, -0.08227988f, 0.10657357f, -0.02923417f, 
    0.08247022f, 0.13960250f, -0.12664907f, 0.23368917f, -0.77083629f, -0.28072113f, -0.05184656f, -0.04021116f, 
    0.22162655f, 0.15352774f, 0.00613781f, -0.05140861f, 0.11268286f, 0.03664795f, -0.18415803f, -0.06685290f, 
    -0.21015273f, 0.27800006f, -0.50064462f, -0.06214992f, 0.11620086f, 0.26204979f, 0.00759576f, -0.13800184f, 
    -0.02304514f, -0.21726105f, 0.05703268f, 0.02316230f, -0.99567759f, 0.68181086f, -0.37979716f, -0.60641462f, 
    0.26358044f, 0.05819466f, 0.02772025f, -0.20524228f, 0.06369448f, 0.05150995f, -0.05612621f, -0.04145789f, 
    -0.11638828f, 0.10462664f, 0.31198049f, -0.28378400f, -0.07961181f, 0.00263658f, 0.08751488f, -0.08114444f, 
    0.15630297f, -0.08084776f, 0.08153959f, 0.11743893f, -0.13719772f, -0.21374807f, 0.02658916f, 0.28397542f, 
    0.07409994f, -0.21226716f, -0.27215141f, 0.13301706f, 0.16648978f, 0.39765099f, 0.28574657f, 0.24313413f, 
    -0.20551915f, 0.39188462f, 0.17051651f, 0.10116518f, -0.02903872f, -0.05654056f, -0.02830081f, -0.21523124f, 
    -0.08995891f, 0.09794971f, -0.21480760f, 0.11308326f, -0.77405238f, -0.56344467f, 0.24180026f, 0.29692423f, 
    -0.15250242f, 0.06926517f, -0.12679067f, -0.10380137f, -0.02366659f, 0.02489809f, 0.04162396f, -0.05976992f, 
    -0.03765481f, -0.04550093f, 0.18253860f, 0.33946478f, -0.09824254f, 0.13666101f, -0.01446658f, 0.38033959f, 
    -0.15171333f, -0.09705868f, 0.09932998f, -0.13471219f, -0.13642099f, 0.05082884f, -0.14845411f, -0.02295100f, 
    0.23526447f, -0.05220705f, -0.19872576f, -0.23046753f, -0.00121247f, 0.17927951f, 0.00010365f, -0.21251903f, 
    -0.08204403f, 0.01704426f, 0.18534628f, -0.25095978f, -0.09736653f, -0.02773590f, 0.01762065f, 0.00143869f, 
    0.05322534f, -0.46535745f, -0.06360523f, 0.20096679f, -0.14010535f, -0.21427925f, 0.42540708f, 0.42555869f, 
    -0.29183972f, -0.08837138f, 0.17041807f, 0.04475779f, -0.20021173f, -0.09500479f, -0.07879905f, -0.12943396f, 
    0.23167032f, 0.16970626f, -0.10911468f, 0.08503588f, -0.14399981f, -0.03779653f, -0.04560779f, 0.01384353f, 
    0.02188701f, -0.18350181f, 0.20059653f, 0.03334678f, 0.06793602f, 0.14950985f, 0.21320535f, -0.10785606f, 
    -0.05464955f, 0.20280148f, -0.15005282f, -0.13448268f, -0.18384309f, -0.04960043f, 0.14943732f, 0.16820930f, 
    -0.36690816f, -0.06453494f, -0.30655366f, 0.10795721f, -0.06483106f, -0.03140973f, -0.21812001f, 0.14153416f, 
    0.17053694f, -0.05606129f, 0.38649815f, 0.01530266f, 0.03413892f, -0.12266437f, -0.19049719f, -0.08764562f, 
    0.04319644f, 0.05055369f, 0.12949514f, -0.04401639f, -0.08320111f, -0.04431328f, 0.02305792f, 0.01526958f, 
    -0.32519248f, 0.28775921f, 0.04504947f, -0.58124673f, -0.30779582f, 0.09640807f, -0.00290427f, -0.08694713f, 
    -0.03281777f, -0.05406011f, 0.09942417f, -0.23653628f, -0.58630067f, -0.19359128f, -0.11234434f, -0.54891378f, 
    -0.06559992f, -0.01946526f, 0.08829924f, -0.25215226f, -0.13792440f, -0.07785697f, 0.17693806f, -0.18513334f, 
    0.02013351f, -0.20817138f, -0.29947403f, -0.14163430f, 0.02357101f, -0.01519476f, -0.08211845f, -0.06049375f, 
    0.10705916f, 0.10643174f, -0.00953871f, 0.25900653f, 0.50279939f, -0.92827833f, 0.02138241f, -0.15028834f, 
    0.02990816f, 0.08881075f, 0.14773914f, 0.03662677f, 0.01219979f, -0.06888074f, 0.18606991f, 0.08459485f, 
    0.25354332f, 0.11106363f, 0.14038838f, -0.51895684f, 0.09685142f, 0.10436635f, 0.07307345f, 0.21138163f, 
    0.12693475f, 0.03697801f, -0.04318522f, 0.15486169f, 0.11683503f, -0.26438817f, -0.31185022f, -0.38767168f, 
    -0.02984869f, -0.02374502f, -0.09282770f, 0.09172814f, -0.14796686f, -0.41264912f, -0.15736201f, -0.14186855f, 
    -0.51161408f, -0.02430521f, 0.07525861f, 0.17662930f, 0.04978876f, -0.07732461f, 0.23051237f, 0.21414934f, 
    -0.09281208f, -0.03041018f, 0.10741094f, 0.16088359f, 0.15540668f, -0.39498267f, -0.02510215f, 0.13867630f, 
    -0.05441770f, 0.02077089f, -0.12790576f, 0.19639921f, -0.39584821f, 0.21543695f, -0.15020399f, -0.10032535f, 
    0.19128823f, 0.04092270f, 0.28385004f, -0.00672861f, 0.24373150f, -0.19393484f, -0.05742008f, -0.35331553f, 
    -0.15244128f, -0.08754199f, 0.09442477f, -0.06863870f, 0.48892742f, -0.17752300f, -0.19596018f, 0.79328102f, 
    -0.10074048f, 0.16776298f, 0.10377807f, 0.02422029f, -0.10115959f, -0.05748521f, 0.09966166f, 0.12068862f, 
    0.56063569f, 0.02392687f, -0.15568787f, -0.45873621f, 0.17107320f, 0.06592596f, 0.11415745f, 0.04591616f, 
    0.03904380f, 0.15271139f, 0.06198130f, 0.11191109f, 0.28867313f, 0.21730758f, -0.05522254f, 0.18254469f, 
    -0.03770995f, -0.09599272f, -0.01902890f, 0.24036331f, 0.05408445f, -0.05535712f, 0.01871820f, 0.11517850f, 
    -0.50347930f, 0.19443147f, -0.01072082f, 0.03495330f, -0.00208676f, -0.02102195f, -0.17069291f, 0.04368380f, 
    -0.07990138f, 0.17916553f, -0.00496007f, 0.13068850f, -0.24499997f, 0.32311782f, -0.20607620f, 0.42082646f, 
    0.12353352f, 0.05775206f, 0.01801529f, 0.02633021f, 0.25906578f, -0.15153703f, -0.21345663f, -0.44202971f, 
    -0.39093304f, 0.18844154f, -0.09087846f, 0.03780378f, 0.05902208f, 0.00182456f, -0.20564893f, 0.00378660f, 
    -0.10296226f, -0.21312006f, 0.02777754f, -0.26371884f, 0.21626563f, -0.63670975f, 0.39433622f, 0.41983494f, 
    0.09778311f, -0.22982754f, -0.17711046f, -0.09657218f, 0.10687503f, -0.04104045f, -0.22696446f, -0.10138211f, 
    -0.56472820f, 0.60954523f, -0.49507815f, -0.19953446f, -0.27656379f, -0.01423421f, 0.14548475f, -0.24565998f, 
    -0.20948000f, 0.01177571f, -0.23665735f, 0.00495150f, 0.27582866f, 0.27419561f, 0.39298335f, 0.09949960f, 
    0.11489643f, -0.03752600f, 0.18156606f, -0.11813156f, -0.02223946f, 0.11896229f, 0.02280537f, -0.16099542f, 
    -0.13685666f, 0.44711560f, 0.32128930f, 0.25847080f, 0.15930820f, 0.08953709f, 0.05535828f, -0.07681189f, 
    -0.18612906f, 0.14756189f, 0.00462291f, -0.02607531f, 0.19655067f, 0.01553515f, 0.42207512f, -0.09327704f, 
    0.05949506f, 0.24635436f, -0.03691224f, 0.19650112f, 0.00039321f, 0.09833857f, -0.06506188f, -0.09290865f, 
    -0.69568384f, 0.24788354f, -0.22952656f, 0.05336741f, -0.13702980f, 0.01143201f, 0.01228532f, -0.24082030f, 
    -0.09618168f, -0.09706822f, -0.01048880f, -0.11789568f, -0.02416443f, 0.26353911f, 0.00562859f, 0.44474897f, 
    -0.05315754f, 0.00033087f, -0.13667317f, -0.07050081f, 0.01377644f, -0.02986244f, -0.08672365f, -0.08280823f, 
    0.20030841f, -0.12578012f, -0.21467814f, -0.27192548f, -0.34805635f, 0.10772551f, -0.05431854f, -0.14384528f, 
    0.09912588f, -0.16277798f, 0.04306692f, -0.10690193f, 0.30669978f, 0.13637783f, -0.04879151f, 0.25541899f, 
    0.27506787f, -0.02084040f, 0.04164514f, -0.11452467f, -0.17031111f, 0.18195626f, -0.01596385f, -0.02708387f, 
    0.04888372f, 0.05790493f, 0.01238829f, 0.23550679f, -0.31573251f, 0.00412273f, 0.07967063f, -0.16706747f, 
    -0.08615918f, 0.22314472f, -0.29383886f, -0.00169221f, -0.09923946f, 0.30785269f, -0.12899944f, 0.43752736f, 
    0.01646760f, -0.17014639f, 0.05888293f, 0.06047626f, 0.06127663f, -0.00143161f, -0.12946528f, -0.10799933f, 
    0.61188990f, -0.17836207f, 0.11189634f, -0.20648617f, -0.19455892f, -0.21620736f, -0.06622158f, -0.16539878f, 
    -0.06094388f, -0.04351421f, -0.17482981f, 0.03476178f, -0.31002456f, -0.23332271f, 0.29751593f, 0.21567942f, 
    -0.20841458f, -0.15330148f, -0.03539451f, -0.06790005f, -0.24920332f, 0.09152418f, -0.10696606f, 0.07590165f, 
    -0.59874672f, -0.03400740f, -0.11428834f, -0.59283298f, -0.02830613f, -0.05166553f, 0.03548211f, -0.14124566f, 
    -0.15062618f, 0.03622670f, -0.01035982f, -0.15732320f, -0.42422074f, 0.24445888f, -0.38916194f, -0.17758900f, 
    0.04621375f, -0.34125179f, -0.28247112f, -0.01637893f, 0.15952124f, 0.12235238f, 0.05590295f, 0.02875236f, 
    -0.45809305f, 0.32665849f, -0.32624540f, -0.14764366f, 0.10858769f, -0.10209257f, -0.06319074f, -0.07872757f, 
    -0.18421164f, 0.05125449f, -0.35494238f, 0.35088784f, -0.18349887f, -0.03564430f, -0.22031662f, -0.24980046f, 
    -0.10986166f, 0.01129759f, -0.17929205f, -0.29670981f, -0.17121843f, 0.00627428f, 0.12706842f, 0.21455114f, 
    0.06078818f, -0.32406622f, 0.38165876f, 0.36517882f, -0.01624321f, -0.02635170f, -0.13412714f, -0.12715131f, 
    0.05908307f, 0.06316132f, 0.08326247f, -0.07672358f, -0.43979236f, 0.34165069f, 0.26401237f, 0.02209301f, 
    -0.17849965f, 0.14841306f, -0.37932080f, 0.14975087f, 0.06721334f, 0.12704398f, -0.03053562f, -0.12911955f, 
    0.06595569f, -0.15234575f, 0.21385558f, 0.12190104f, -0.43056166f, -0.01471772f, 0.09936702f, -0.05043485f, 
    -0.12238473f, -0.08633539f, -0.23643430f, -0.12775570f, -0.40967849f, -0.11924048f, 0.26980147f, -0.07181927f, 
    -0.01101888f, -0.07094220f, 0.25328404f, -0.19910112f, 0.11746068f, 0.03720081f, -0.09595200f, -0.00800767f, 
    -0.17269766f, -0.24916036f, -0.14747046f, 0.44224575f, 0.15799028f, 0.04582326f, 0.00052905f, -0.18240140f, 
    0.15210231f, 0.11371650f, -0.01182470f, 0.14825405f, -0.28167817f, 0.29089299f, -0.24141151f, -0.36781505f, 
    -0.16450754f, -0.23626146f, -0.00955072f, 0.11877999f, 0.25259072f, 0.09900776f, -0.02513502f, 0.12674399f, 
    0.57879049f, 0.31458205f, 0.09382977f, 0.12412265f, -0.05038169f, 0.05701007f, -0.18442656f, -0.13760681f, 
    -0.03396811f, 0.11056784f, -0.06396881f, -0.01450171f, -0.04315666f, 0.01385982f, 0.07723849f, -0.12133337f, 
    0.13689329f, -0.04514262f, -0.12491592f, -0.03802548f, 0.18916155f, 0.15074538f, 0.00733793f, 0.07573334f, 
    0.18467310f, -0.09789651f, -0.26658291f, -0.28777882f, -0.03140920f, 0.00417003f, 0.07728010f, 0.03343275f, 
    0.15437569f, 0.11409344f, -0.03212330f, -0.04817910f, 0.10599165f, 0.61869550f, -0.41066492f, -0.32447198f, 
    0.08765934f, -0.22090638f, -0.35649526f, -0.13743387f, -0.00441179f, -0.15376833f, -0.12967411f, 0.27834305f, 
    -0.62488687f, -0.26013437f, -0.42830262f, -0.44894719f, 0.02833823f, 0.13322341f, 0.08346464f, 0.00455322f, 
    0.17421977f, -0.35357451f, -0.07003526f, 0.19080320f, -0.04352548f, -0.20525554f, -0.29268062f, 0.22308716f, 
    0.27305809f, 0.00401770f, -0.10358067f, -0.04875865f, 0.09003779f, -0.06474853f, 0.03463141f, -0.41989520f, 
    0.28975561f, -0.02090630f, -0.10539664f, 0.05076861f, 0.37377387f, -0.01231849f, -0.13965712f, 0.04646851f, 
    -0.01377517f, -0.18693340f, 0.17642032f, 0.03569520f, 0.00010411f, 0.33095664f, -0.27744055f, -0.03542423f, 
    0.01328773f, 0.06978528f, -0.59499991f, 0.01167241f, -0.16069974f, 0.01688623f, 0.27508017f, 0.12588228f, 
    0.24845743f, 0.27080441f, 0.00169474f, 0.08820564f, -0.17214164f, 0.16673861f, 0.07855258f, 0.10137551f, 
    -0.14404018f, -0.21620062f, 0.44451359f, 0.04999931f, 0.42315051f, -0.43733716f, -0.04718486f, -0.24790324f, 
    0.02146002f, 0.05544465f, -0.08873338f, 0.16934063f, -0.12733439f, -0.08626900f, -0.01589864f, 0.06895779f, 
    -0.62834769f, 0.76813489f, -0.26224121f, -0.63705111f, 0.19876307f, 0.07682256f, -0.01466351f, 0.12971964f, 
    -0.03636667f, -0.14563057f, 0.08987218f, -0.14267130f, -0.55865502f, -0.36607853f, 0.02958475f, -0.14222334f, 
    -0.09599233f, 0.15998872f, 0.10802674f, 0.01733499f, 0.05449758f, 0.05213676f, -0.08932606f, -0.08575440f, 
    -0.44843388f, -0.15043354f, 0.05138880f, -0.03101668f, 0.24797484f, 0.08820800f, -0.15584245f, 0.05723886f, 
    0.12961362f, 0.18317166f, -0.09490058f, 0.00163354f, 0.66192454f, 0.04478214f, 0.11144413f, 0.27093887f, 
    0.06524441f, -0.08580542f, -0.11512946f, -0.05017958f, -0.06399740f, -0.04383026f, 0.01123534f, -0.06730758f, 
    -0.80830353f, 0.64531535f, -0.80727923f, -0.18558629f, 0.26010695f, -0.30506456f, 0.08467676f, -0.11973731f, 
    -0.01224384f, 0.03578390f, -0.26036581f, -0.19692191f, -0.34347910f, 0.03695104f, -0.01830646f, -0.06396240f, 
    -0.00381413f, 0.31008261f, -0.14187793f, 0.00470503f, -0.05181056f, -0.13901554f, -0.14786498f, -0.01374146f, 
    0.66861868f, -0.14552090f, 0.16987289f, 0.00365440f, 0.10501586f, 0.04315292f, 0.04584463f, -0.00880188f, 
    0.14704533f, 0.14228453f, 0.15009730f, 0.13447428f, -0.22534682f, -0.39077193f, 0.14674944f, -0.08156934f, 
    0.07236271f, -0.22387129f, 0.09512660f, -0.19804110f, 0.05240997f, -0.33669427f, 0.07922239f, 0.25941834f, 
    -0.41555801f, 0.02229277f, -0.32663116f, 0.23806816f, 0.02444923f, -0.06459000f, 0.13503480f, -0.06703895f, 
    0.03246824f, -0.06119366f, 0.03174737f, 0.20661314f, -0.88419008f, -0.15273839f, 0.73695660f, -0.20378208f, 
    0.01849991f, 0.22807963f, 0.10349184f, 0.27533469f, 0.08408310f, -0.13986291f, 0.02175223f, -0.09871056f, 
    -0.28128651f, 0.07548279f, 0.06586272f, -0.06290173f, -0.21004520f, 0.09438428f, -0.09274044f, -0.07558000f, 
    0.00352348f, 0.20003419f, 0.24669354f, 0.03562811f, -0.16084589f, -0.24231838f, -0.35410178f, -0.41208652f, 
    0.08681013f, 0.10475865f, -0.31002110f, -0.01930644f, 0.08124301f, 0.07806897f, 0.05845761f, 0.32583669f, 
    0.00701562f, 0.13872428f, 0.36432526f, -0.25840682f, 0.14016794f, 0.19934385f, 0.03052084f, -0.31735390f, 
    -0.03441489f, -0.19290498f, -0.18879181f, -0.16189878f, 0.15631740f, 0.28126976f, 0.32572925f, 0.09523886f, 
    -0.08881462f, 0.05953199f, 0.01730406f, 0.03694201f, -0.20475972f, 0.05713789f, -0.00886828f, -0.22545919f, 
    0.06056609f, -0.22023916f, 0.10965308f, 0.09367997f, 0.18238543f, 0.06590948f, 0.07278464f, -0.09546015f, 
    0.05051412f, -0.14597759f, -0.24258626f, 0.15164603f, 0.06361698f, 0.35123116f, -0.24103777f, -0.38825759f, 
    0.21890801f, 0.19526179f, 0.02425543f, -0.04600603f, 0.07747314f, 0.02216402f, 0.12675244f, 0.27752832f, 
    -1.39157033f, -0.95433044f, 0.08277480f, -0.04532687f, 0.17604898f, -0.05290482f, 0.05916040f, 0.08140469f, 
    0.24289994f, 0.07825493f, 0.24754328f, 0.13860555f, -0.00450349f, -0.00936353f, -0.00020613f, -0.21658714f, 
    0.02517843f, 0.16854455f, -0.03428176f, -0.03717251f, 0.02760534f, -0.00594682f, -0.03393203f, 0.19870302f, 
    0.46158803f, 0.25282219f, -0.03827842f, 0.01464581f, -0.54312289f, -0.16658290f, 0.14659573f, 0.11423638f, 
    0.14382657f, -0.00961936f, 0.12458425f, 0.01426353f, 0.55471981f, -0.07021657f, -0.26884878f, 0.10851877f, 
    -0.17100736f, -0.17808822f, -0.22605020f, 0.04217264f, -0.14626262f, -0.16872321f, -0.08624891f, -0.19910158f, 
    -0.32751343f, -0.03932815f, -0.53855181f, -0.46377352f, -0.18146698f, -0.01014031f, -0.01441714f, -0.03876590f, 
    -0.07860365f, -0.06494732f, 0.08650562f, 0.05325444f, 0.49074337f, 0.26363900f, -0.16945955f, 0.00435284f, 
    -0.03093421f, 0.13484044f, 0.24106783f, -0.11638656f, 0.17848752f, 0.44503510f, 0.02086747f, 0.15517086f, 
    -0.24328318f, -0.35670432f, 0.05992140f, -0.40177467f, 0.12721786f, 0.24073999f, 0.08589441f, -0.13615082f, 
    -0.00913403f, -0.04140881f, -0.19767974f, -0.07918465f, -0.30224431f, 0.08147976f, -0.76210374f, 0.12166343f, 
    0.03723205f, -0.09869207f, -0.05782993f, 0.12143133f, 0.01143981f, 0.27988604f, 0.21726799f, -0.10232366f, 
    0.24701174f, -0.03670937f, 0.01220032f, 0.29445407f, 0.22132844f, -0.04557575f, 0.10098646f, 0.08449449f, 
    0.13162495f, 0.06852437f, 0.01485140f, -0.12702166f, -0.21240072f, -0.32540640f, -0.00276835f, -0.19917914f, 
    -0.03730086f, 0.01541351f, 0.00159341f, -0.04931229f, 0.02972428f, 0.00210330f, -0.20438325f, -0.03784093f, 
    0.15743211f, 0.25878495f, 0.04189762f, -0.03194738f, 0.16201064f, 0.05322925f, 0.03741346f, 0.09105113f, 
    -0.14297684f, -0.06330951f, -0.04118767f, -0.07837485f, -1.05105686f, 0.29675928f, -0.16916230f, -0.23718049f, 
    0.21732964f, -0.04964686f, -0.27663761f, -0.20005316f, 0.18929358f, -0.26168287f, -0.18451452f, -0.35593465f, 
    -1.04332376f, 0.05810949f, 0.02650514f, -0.06218715f, 0.35748652f, 0.02528212f, 0.14501509f, -0.20567651f, 
    0.08682679f, 0.00988319f, 0.30208617f, 0.25631550f, -0.44404763f, -0.76055956f, 0.03329172f, 0.24112247f, 
    0.21551783f, 0.23533459f, -0.01716575f, 0.11911217f, 0.11259834f, 0.04026888f, 0.06793069f, 0.25409967f, 
    0.26905364f, 0.09827399f, -0.02548514f, 0.00392241f, 0.09731245f, -0.04607436f, -0.22554502f, 0.01169147f, 
    0.02430352f, 0.12486541f, 0.04075257f, 0.04746430f, -0.17977242f, 0.12470660f, 0.09520105f, 0.29342833f, 
    -0.21762656f, 0.12933761f, -0.11948017f, 0.12638287f, -0.11288122f, 0.00003601f, 0.37289453f, -0.17104749f, 
    0.16940458f, -0.33711910f, 0.00418731f, -0.28368950f, 0.01234690f, 0.05687815f, 0.07861673f, -0.01269369f, 
    -0.11266230f, 0.06171549f, -0.11603878f, -0.07534695f, -0.03614083f, 0.36897323f, -0.02406148f, -0.12834521f, 
    -0.02227950f, -0.18427257f, -0.15730077f, -0.04336558f, 0.06030489f, 0.09598134f, 0.04287311f, -0.15868956f, 
    0.13835756f, -0.40361485f, -0.02006061f, 0.26592407f, -0.01330498f, 0.05212338f, 0.16201861f, 0.00536875f, 
    -0.19611663f, -0.09669778f, -0.03937877f, -0.34612671f, -0.31544513f, 0.06091416f, 0.08616993f, 0.13411728f, 
    0.07293258f, -0.30389339f, -0.01090214f, -0.06410073f, 0.04135854f, -0.16145161f, 0.18122676f, 0.06144416f, 
    0.12505278f, -0.23862293f, -0.15116261f, 0.02407599f, 0.18811834f, 0.10039008f, 0.07214972f, -0.08167367f, 
    -0.08634642f, 0.13211988f, -0.01168358f, -0.10510650f, 0.12780420f, -0.08349217f, -0.25421149f, 0.44323280f, 
    -0.04180671f, -0.16070046f, -0.01823032f, 0.02731438f, -0.13958910f, -0.09208344f, -0.13873187f, 0.01177595f, 
    -0.90877086f, -0.51895779f, -0.32987377f, -0.48216197f, 0.02088767f, 0.10323092f, -0.12214373f, 0.28766596f, 
    -0.04334692f, 0.00453904f, 0.07836426f, -0.09462121f, -0.29292837f, -0.21562533f, -0.03511552f, 0.29227343f, 
    -0.08508316f, 0.40884459f, -0.14811583f, 0.18572401f, -0.09591905f, 0.01596416f, 0.00919681f, 0.33354768f, 
    -0.26241794f, -0.17979391f, 0.00501662f, 0.00055776f, 0.20204267f, 0.07546969f, -0.19400026f, 0.17696534f, 
    0.17225757f, -0.07754436f, -0.08411035f, 0.21175545f, 0.09478723f, -0.93080491f, -0.20317706f, 0.02251397f, 
    0.09279507f, -0.04098745f, -0.05360424f, -0.27883935f, 0.13457818f, 0.08565062f, 0.11935253f, 0.06589432f, 
    -0.40270954f, 0.46716234f, -0.62989390f, -0.28034601f, 0.31353661f, -0.17719747f, -0.00658830f, -0.20016307f, 
    -0.16891083f, 0.16542110f, -0.00174578f, -0.17135672f, 0.43776155f, -0.03214467f, -0.23183388f, 0.10539713f, 
    0.07162740f, 0.20994473f, -0.00318153f, -0.17132545f, 0.10269407f, 0.04833160f, 0.31410119f, 0.06385385f, 
    0.88541698f, 0.15967089f, -0.00727813f, -0.30143577f, 0.10550964f, -0.22716102f, -0.09051616f, 0.14277098f, 
    0.04221315f, 0.06729077f, -0.00656065f, -0.16449435f, 0.35667977f, 0.05948879f, -0.19997984f, 0.42826813f, 
    0.38208088f, -0.10357647f, 0.05430694f, 0.00027578f, -0.00248494f, 0.01380562f, -0.26780564f, -0.07202625f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14580652f, 0.11020609f, -0.17102593f, -0.00448478f, -0.01135950f, 0.00754004f, 0.01639949f, -0.19548573f, 
    -0.04679071f, -0.06503622f, 0.22240092f, 0.00014432f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
