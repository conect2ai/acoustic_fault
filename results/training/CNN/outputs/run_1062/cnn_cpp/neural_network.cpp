#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.76985848f, -0.62923789f, -0.70793682f, -0.46757698f, -0.62058204f, 0.10176717f, 0.04185856f, -0.07057089f, 
    0.45036295f, 0.20252354f, 0.22388904f, -0.14851899f, -0.34995767f, -0.12152693f, -0.16294663f, -0.41074976f, 
    -0.21209033f, -0.33205110f, -0.35558546f, -0.32056943f, -0.34400779f, -0.01313483f, 0.23494115f, 0.04488843f, 
    -0.17367131f, 0.45125219f, 0.53574866f, -0.00789711f, -0.31573451f, -0.01052942f, -0.04897684f, -0.13653089f, 
    -0.21487680f, -0.16049604f, -0.47380814f, 0.21914674f, 0.07579090f, 0.07139438f, 0.12264341f, 0.18902521f, 
    -0.22168727f, 0.20216751f, -0.07737622f, 0.08433408f, 0.12512559f, -0.15668015f, -0.11576102f, -0.07487662f, 
    -0.17966321f, -0.11258365f, 0.04007375f, 0.30389762f, 0.11496050f, 0.16454662f, -0.46211427f, -0.29840672f, 
    -0.25045183f, -0.04277644f, 0.07297693f, 0.32713845f, 0.06510403f, 0.32244921f, -0.29635337f, 0.12664638f, 
    -0.36526218f, -0.22178943f, -0.06706543f, -0.02173332f, -0.33877367f, -0.39146042f, -0.35579377f, -0.55927616f, 
    -0.61175489f, -0.55075949f, -0.78746742f, 0.32948884f, -0.46209648f, -0.44725937f, 0.28618529f, 0.79818058f, 
    -0.00010277f, -0.12346587f, -0.38521966f, -0.72540402f, -0.60674965f, 0.27766773f, 0.37717938f, -0.33509296f, 
    0.09378508f, -0.19327705f, -0.07482945f, 0.19184805f, 0.23867449f, 0.03909012f, 0.27179947f, -0.30528799f, 
    0.10252903f, 0.11298946f, 0.04601449f, -0.40531355f, 0.26260948f, -0.34073803f, -0.26799503f, 0.19972517f, 
    0.01948244f, 0.36358804f, 0.36754802f, -0.35024557f, -0.31122911f, 0.19824831f, -0.12712798f, 0.64563870f, 
    -0.38135120f, -0.56113428f, -0.25935021f, 0.20606953f, 0.26390421f, -0.04987917f, -0.21160953f, 0.31334370f, 
    -0.11764482f, -0.39563218f, -0.18699768f, 0.29528123f, 0.02783467f, 0.79742992f, 0.26548785f, -0.02912580f, 
    -0.23399930f, -0.65439749f, 0.20365438f, -0.02697353f, -0.13517326f, 0.08899523f, 0.40648866f, 0.24660444f, 
    -0.08721221f, -0.11855315f, -0.11025339f, -0.00252551f, -0.24552669f, -0.05570783f, 0.00147082f, 0.31855562f, 
    -0.27031603f, -0.16991521f, 0.01740729f, 0.22218342f, 0.05904017f, -0.02311699f, 0.27350020f, -0.03065175f, 
    -0.04924684f, 0.17235036f, 0.04957004f, 0.36850032f, 0.10061467f, 0.12055244f, 0.01731362f, 0.13558504f, 
    0.04794450f, 0.25757036f, -0.22101803f, 0.01121669f, 0.16397560f, 0.13100989f, -0.08656318f, 0.12559709f, 
    0.08450946f, -0.21855177f, -0.01533168f, 0.34996834f, 0.31668335f, -0.11934718f, -0.27993700f, -0.88396364f, 
    -0.64172995f, -0.23740706f, 0.00496032f, 0.33024424f, -0.00759672f, -0.58840477f, -0.13118966f, 0.25067845f, 
    0.02204131f, 0.22905959f, 0.33096898f, 0.44351274f, 0.39205691f, -0.01146703f, 0.12563804f, -0.14339332f, 
    0.17702052f, -0.17877485f, 0.17399114f, 0.22725827f, -0.03910990f, 0.19098198f, -0.05707251f, 0.12847283f, 
    0.14998002f, -0.08989771f, -0.48578414f, -0.00213656f, 0.18837111f, -0.06966549f, -0.04383401f, 0.07210970f, 
    0.04731899f, 0.10527194f, 0.17661816f, -0.21615629f, 0.10411964f, -0.20635647f, -0.10053393f, -0.17690696f, 
    -0.20268409f, 0.55267626f, 0.07930087f, -0.55186641f, -0.21550415f, 0.01637015f, 0.15775858f, 0.19256921f, 
    0.55219430f, 0.27638927f, 0.45532259f, -0.14002532f, -0.17693993f, -0.25744137f, -0.31459573f, -0.18655084f, 
    0.04451510f, 0.18934907f, 0.07949340f, -0.20455402f, 0.04323821f, 0.07509781f, -0.00255744f, 0.09927555f, 
    0.04507427f, -0.32322881f, 0.07903030f, 0.30410600f, 0.00031415f, -0.22571227f, 0.30914679f, -0.30751207f, 
    0.10726898f, 0.12424199f, 0.25786600f, -0.28057945f, -0.06456625f, -0.04765920f, 0.17348270f, -0.09285767f, 
    0.15236959f, 0.19975172f, 0.30738774f, 0.27231145f, -0.11788774f, 0.02737643f, 0.08816829f, -0.18749954f, 
    -0.21037047f, -0.26220459f, -0.12205738f, 0.04543293f, -0.07263523f, 0.20600058f, -0.19754501f, -0.17453976f, 
    0.02873131f, 0.25112936f, 0.21783134f, -0.12708171f, -0.55800062f, 0.07973712f, 0.20833680f, 0.29963017f, 
    0.48154101f, 0.33018401f, -0.11163031f, -0.30547968f, 0.32532722f, 0.12120285f, -0.13383548f, -0.08782442f, 
    0.06530513f, -0.02886800f, 0.15942986f, -0.29409260f, -0.28654531f, 0.19803943f, -0.30548862f, -0.17705980f, 
    -0.09794987f, -0.32186574f, 0.11219782f, -0.06724338f, -0.51929057f, 0.02374387f, -0.26769507f, -0.09035444f, 
    -0.17629825f, 0.24368186f, 0.30081335f, -0.13413306f, 0.17669469f, 0.00290841f, -0.08379199f, -0.03980384f, 
    0.18039531f, 0.26388213f, -0.10277392f, 0.19346710f, 0.21478589f, -0.29706436f, 0.09424519f, 0.14028327f, 
    -0.22282302f, 0.06150696f, -0.17205490f, -0.03877315f, 0.14266567f, -0.92491633f, 0.01236622f, 0.21294378f, 
    0.37154093f, 0.09659848f, 0.13238497f, 0.38965461f, 0.18640296f, 0.29261065f, 0.39404958f, -0.39234930f, 
    0.19346988f, 0.24633010f, -0.15687446f, 0.18417536f, -0.05609117f, -0.10621375f, -0.17269357f, -0.11878272f, 
    -0.34724686f, 0.12580249f, 0.26729047f, -0.05281719f, -0.14029805f, 0.33640951f, 0.19846323f, -0.25085351f, 
    -0.07137805f, -0.66539466f, -0.70337415f, 0.62708771f, -0.08864175f, 0.01603615f, -0.06920981f, 0.24504291f, 
    -0.08171193f, 0.31648421f, -0.20042928f, 0.13752717f, 0.16342729f, -0.04485157f, 0.03969442f, 0.14399362f, 
    -0.07044086f, -0.43603456f, -0.09284209f, -0.12358689f, -0.14501946f, -0.19719236f, -0.08465632f, -0.27845600f, 
    -0.69404972f, -0.37684011f, -0.09241486f, -0.33589777f, -0.44811121f, -0.49036345f, -0.10535081f, -0.62257373f, 
    -0.85217375f, -0.16933529f, -0.21640134f, -0.18415542f, 0.58548182f, -0.40532646f, -0.01803838f, -0.42927364f, 
    -0.17650050f, -0.29895726f, -0.26956621f, -0.36757284f, 0.08363189f, -0.08673514f, -0.13885467f, 0.12179426f, 
    -0.71842051f, -0.17344299f, -0.39514953f, -0.46655080f, -0.69722420f, -0.09878296f, -0.16490413f, -0.71132261f, 
    -0.54980731f, -0.05155811f, 0.00847783f, 0.12011208f, 0.35979679f, 0.24950565f, 0.16034535f, 0.20816018f, 
    0.09655240f, -0.01931470f, -0.28829661f, -0.02605942f, -0.01966418f, 0.39834920f, 0.05260691f, 0.16572829f, 
    0.22370020f, 1.11297691f, -0.56187969f, -0.54157031f, 0.06042939f, -0.37617579f, 0.51686901f, 0.33798796f, 
    -0.07443042f, 0.00960931f, -0.05731582f, -0.05105045f, -0.12115738f, 0.14916800f, -0.07283890f, 0.02164478f, 
    -0.17285480f, 0.08687143f, 0.17705880f, 0.03216391f, -0.23659588f, -0.07456551f, 0.04968150f, 0.00579710f, 
    0.06326663f, -0.00328605f, -0.57998770f, -0.34298459f, 0.26725543f, 0.39100626f, 0.59029877f, 0.33591589f, 
    -0.04709102f, -0.26459321f, -0.15687683f, -0.12164620f, 0.21664976f, -0.31191626f, -0.27918726f, -0.20923555f, 
    0.52789706f, -0.22343764f, 0.11479159f, -0.15422574f, -0.00044751f, 0.06886762f, 0.17605360f, 0.24465556f, 
    -0.10536423f, -0.03429249f, -0.38289663f, -0.88239378f, -0.61729455f, 0.40223172f, 0.21806112f, 0.17158081f, 
    -0.37075704f, -0.17004931f, 0.11756220f, -0.13653262f, -0.47481620f, 0.39787558f, 0.47080162f, -0.10412724f, 
    0.60780185f, -0.46301720f, -0.27560744f, -0.41482306f, -0.05580267f, 0.15491971f, 0.05376350f, 0.02362008f, 
    -0.18929748f, -0.11647354f, 0.22188340f, 0.16066934f, -0.32780963f, -0.71388894f, 0.32522768f, -0.04738614f, 
    0.30993009f, 0.21806562f, 0.42968881f, 0.34327707f, -0.19515772f, -0.40311989f, -0.33031192f, -0.45474190f, 
    -0.21467230f, 0.21545291f, 0.29334879f, -0.11142719f, -0.20563015f, 0.26441246f, 0.02960304f, -0.00549064f, 
    0.07184470f, 0.02025478f, 0.02113027f, -0.24054022f, -0.46724543f, 0.55708724f, 0.00554036f, -0.28246072f, 
    0.26554623f, 0.40740404f, 0.09852123f, 0.47817674f, 0.43661386f, -0.25607350f, -0.48638508f, -0.20740932f, 
    -0.08566239f, -0.13327979f, -0.22520813f, -0.22732438f, 0.08841008f, -0.14968194f, 0.17722172f, -0.08325541f, 
    -0.22305992f, 0.01963089f, -0.04117614f, -0.15483788f, -0.24524638f, -0.33835402f, -0.43361422f, -0.18000445f, 
    -0.57956398f, -0.33970079f, -0.38526112f, -0.59046346f, -0.39222783f, 0.25673452f, 0.21253197f, 0.20103492f, 
    0.11007025f, -0.21156327f, -0.13617326f, -0.39262661f, -0.26129574f, 0.32116941f, -0.30968982f, -0.21193035f, 
    0.11249966f, -0.35829452f, -0.36964881f, -0.21530846f, -0.49216604f, 0.07471078f, -0.31789234f, -0.79620677f, 
    -0.73658770f, 0.19328320f, 0.40763900f, 0.08085585f, 0.23224281f, -0.79913914f, 0.55199778f, -0.08234204f, 
    -0.10807089f, -0.10726053f, 0.07157248f, -0.12902278f, -0.09190886f, 0.00439542f, 0.01325536f, -0.00497343f, 
    0.13252904f, 0.15442866f, 0.26891497f, -0.01990450f, -0.10530993f, 0.02772352f, 0.14898166f, 0.07442427f, 
    -0.13603817f, 0.37576231f, 0.35335028f, -0.96784663f, -0.64338523f, -0.03293157f, -0.36903304f, 0.46018940f, 
    -0.06954389f, 0.14657600f, 0.32396311f, -0.03384617f, 0.44124115f, -0.05736597f, -0.10074569f, -0.05568851f, 
    -0.10774490f, 0.01998078f, -0.06782140f, 0.04167600f, 0.10349995f, 0.05509603f, -0.40531817f, 0.13076733f, 
    -0.29869077f, -0.30199006f, -0.48239619f, -0.61867648f, -0.23496830f, -0.13787840f, -0.60577947f, -0.31646779f, 
    -0.89418572f, -0.53088200f, 0.12158979f, 0.09511618f, 0.44848144f, 0.02228260f, 0.16331914f, 0.19721270f, 
    -0.11915881f, 0.03864342f, 0.11354449f, -0.02096054f, -0.08432277f, 0.12666744f, -0.38050604f, -0.31776506f, 
    -0.00799126f, 0.15882891f, -0.20115532f, -0.74996996f, 0.14191097f, 0.46842781f, -0.52465236f, 0.98835403f, 
    0.42371872f, 0.09184699f, -0.07366890f, 0.18975577f, -0.22764435f, -0.30723137f, 0.00144705f, -0.00521353f, 
    -0.19521232f, 0.06764998f, -0.18583141f, -0.14828548f, 0.03709729f, 0.04425407f, -0.29582477f, 0.05486357f, 
    0.20348795f, 0.16236606f, -0.17533389f, 0.26401165f, 0.27750188f, 0.00674959f, -0.20369549f, -0.51251483f, 
    -0.45239890f, 0.06897213f, 0.25732845f, 0.29109919f, -0.08223651f, -0.10434518f, 0.24831644f, 0.22483902f, 
    -0.32194626f, -0.14971946f, 0.28420526f, -0.19593887f, -0.31806332f, 0.11787067f, -0.15411751f, 0.12743844f, 
    0.18597814f, -0.17772743f, -0.42698485f, 0.34751409f, 0.04616804f, -0.01336301f, 0.10339459f, 0.30845982f, 
    0.19081208f, 0.40515202f, 0.14808822f, -0.31096143f, 0.21700062f, 0.23578128f, 0.19923207f, 0.19666670f, 
    0.10190148f, -0.18413876f, -0.16780704f, 0.05809845f, 0.07306268f, 0.23273231f, -0.06572292f, -0.37141460f, 
    -0.08206429f, 0.04491644f, 0.22756676f, 0.05377814f, -0.02746141f, -0.49739641f, -0.15967530f, -0.55076814f, 
    -0.06925928f, -0.63807708f, 0.42359999f, -0.04197482f, -0.05107338f, 0.30918571f, 0.53955334f, 0.29671881f, 
    0.02701007f, 0.13658085f, -0.17949817f, 0.07994666f, -0.35645610f, -0.23172353f, -0.13807584f, 0.04291346f, 
    0.23348901f, 0.06704722f, -0.02667767f, 0.10540795f, -0.00714267f, 0.08334934f, -0.72037947f, 0.20697977f, 
    -0.02521321f, -1.00069273f, -0.67310899f, 0.59377623f, 0.67618281f, -0.14106886f, -0.37725517f, 0.50430167f, 
    -0.04397850f, -0.15702544f, -0.18595061f, -0.13643363f, 0.23139571f, 0.16561972f, -0.07740882f, 0.17145731f, 
    0.05909844f, -0.27473253f, -0.13357490f, -0.17199080f, 0.12347182f, -0.32855871f, -0.09689402f, 0.27351978f, 
    0.23424625f, -0.28037569f, 0.24735616f, 0.40882218f, -0.18776965f, 0.27047798f, -0.24574603f, 0.05006895f, 
    -0.26708046f, -0.22426850f, -0.30352065f, 0.14880571f, 0.05444485f, 0.14732999f, 0.30818766f, -0.12072621f, 
    0.31539232f, -0.49586946f, 0.03943804f, -0.33024228f, 0.09403322f, -0.26647010f, 0.16424721f, -0.04512703f, 
    -0.09666009f, -0.52146620f, -0.86301512f, -0.23707494f, 0.06446328f, 0.36629331f, 0.42248836f, 0.25397444f, 
    0.22582440f, 0.19650032f, 0.05023817f, 0.13992538f, -0.01292257f, 0.23278899f, -0.28320077f, -0.11784340f, 
    -0.21368594f, -0.19505794f, 0.37374142f, -0.24071670f, 0.26738226f, 0.05116366f, -0.03269824f, 0.07914977f, 
    -0.14645320f, -0.38940161f, -0.14904220f, 0.23464279f, 0.53505677f, 0.02906447f, 0.45355815f, -0.18354440f, 
    0.04630814f, -0.21781163f, -0.26886871f, 0.10346668f, -0.12827174f, -0.35708711f, 0.41876534f, -0.32801366f, 
    -0.06054211f, -0.08996806f, 0.30735710f, -0.32586354f, -0.11112452f, -0.10695787f, -0.15874526f, 0.26971251f, 
    0.13125177f, 0.19708276f, 0.52626359f, 0.68873662f, 0.49041358f, -0.18182471f, 0.44281593f, -0.45653766f, 
    -0.26650470f, -0.22199760f, -0.09754311f, -0.15247443f, 0.06342926f, 0.27033195f, 0.06535009f, -0.28890082f, 
    0.01854933f, 0.11957897f, -0.22838858f, 0.05184833f, 0.09097846f, 0.06892624f, -0.11866680f, 0.23895149f, 
    -0.12101419f, 0.00316887f, 0.11355605f, 0.75894493f, 0.23361410f, -0.44813383f, -0.09174445f, -0.21719261f, 
    0.37322885f, -0.20227599f, 0.10944752f, 0.02524515f, 0.07989099f, -0.14758117f, 0.29578322f, -0.04820870f, 
    -0.22493777f, 0.02897618f, 0.19960818f, -0.18470933f, -0.10093452f, -0.17929894f, -0.14451990f, -0.31250340f, 
    -0.10564727f, -0.02705585f, -0.29215896f, 0.19690669f, -0.37911057f, 0.67654318f, 0.25968820f, -0.46694919f, 
    -0.23652776f, 0.09305566f, 0.15264668f, 0.15870528f, 0.34493911f, 0.07320136f, -0.45511034f, -0.35955045f, 
    0.01481367f, -0.45604563f, -0.19552755f, 0.34897572f, 0.52841878f, -0.21616581f, 0.05105970f, -0.18288374f, 
    -0.12400159f, 0.11293430f, 0.35863757f, 0.01170499f, -0.16688025f, -0.65459973f, -0.44502765f, -0.43574139f, 
    0.04650719f, -0.13295023f, 0.21328339f, 0.13616388f, -0.19594027f, 0.31192988f, 0.49406368f, 0.31243640f, 
    -0.18223310f, -0.19086628f, -0.02914548f, 0.22896463f, -0.28021577f, -0.11641551f, -0.24135236f, 0.24516636f, 
    0.09469498f, -0.03671195f, -0.31709066f, -0.12708037f, 0.13463387f, -0.42710170f, -0.73183107f, -0.43542472f, 
    -0.39842892f, -0.82678419f, -0.51809883f, 0.24859142f, 0.38198328f, 0.16470237f, -0.04634658f, -0.10993152f, 
    -0.33213046f, -0.10415570f, -0.21281724f, -0.40760025f, -0.02344636f, 0.16611587f, 0.29927570f, 0.19979469f, 
    0.04909636f, -0.04931145f, -0.05238832f, 0.22866438f, -0.14101876f, -0.41194052f, -0.17985187f, 0.23525535f, 
    -0.12005132f, 0.08663178f, 0.52162373f, 0.59214741f, 0.03591985f, -0.61072439f, -0.56057888f, -0.07104429f, 
    -0.31342259f, 0.19440104f, 0.14022011f, 0.56942183f, -0.30552521f, -0.33298591f, -0.30468288f, -0.09092541f, 
    0.36725929f, -0.23865384f, -0.19823171f, 0.19522138f, -0.04188761f, 0.05664294f, 0.23865536f, -0.04639525f, 
    -0.33242768f, 0.10844286f, 0.13257778f, -0.23163402f, -0.00480632f, -0.24076639f, -0.21385197f, 0.00749566f, 
    0.09262953f, 0.45887133f, -0.22096100f, 0.18483248f, -0.05597315f, 0.27074003f, -0.02077188f, -0.53607345f, 
    -0.13403918f, 0.28544766f, 0.07665534f, 0.14867105f, 0.06535409f, 0.16468370f, 0.27392888f, 0.20343077f, 
    -0.10356759f, 0.70259899f, 0.77199858f, 0.10707934f, -0.70917368f, -0.88813043f, 0.29780516f, 0.14973031f, 
    -0.12101150f, -0.31843880f, -0.37044755f, 0.18841353f, 0.19748719f, -0.06697745f, 0.21558830f, -0.13968655f, 
    -0.17147051f, -0.18011305f, 0.00503013f, -0.00789862f, -0.27774429f, 0.28437930f, 0.01230053f, -0.10429970f, 
    0.17132922f, 0.21961020f, 0.14264093f, -0.18067583f, 0.57791758f, 0.20711453f, -0.12519133f, -0.81795222f, 
    -0.85165775f, -0.49969044f, -0.32055435f, -0.33467695f, 0.14808440f, -0.25292450f, -0.35320792f, -0.20151392f, 
    0.63704634f, -0.22044604f, -0.22077055f, -0.41847378f, -0.25187573f, -0.24165744f, -0.13506192f, -0.15049888f, 
    -0.18101156f, -0.36015186f, -0.02487825f, -0.39176250f, -0.44520435f, -0.54696393f, -0.63365161f, -0.70131606f, 
    -0.43539757f, -0.02642442f, 0.02729633f, -0.15967418f, -0.21708886f, -0.05283622f, -0.36523232f, -0.41531891f, 
    -0.41859397f, -0.25024992f, -0.24469814f, 0.10577456f, -0.16673246f, -0.35297784f, -0.42786258f, -0.08024784f, 
    0.15909818f, 0.13652183f, 0.29987976f, 0.06168314f, 0.10799384f, 0.12774725f, -0.33090520f, 0.12349886f, 
    0.07466542f, -0.17732933f, -0.09513629f, 0.34562570f, -0.08740775f, -0.36834827f, -0.05398919f, 0.29916683f, 
    0.23466386f, -0.41064891f, -0.01718715f, -0.06359266f, 0.03266638f, 0.11559037f, -0.39020631f, -0.10038857f, 
    0.12680896f, 0.25446200f, -0.01622554f, -0.07135236f, 0.20356800f, -0.93752152f, -0.53957510f, 0.23585656f, 
    -0.13982929f, 0.23828319f, 0.08041956f, -0.89368427f, -0.68841767f, 0.36756375f, 0.57802516f, -0.22620118f, 
    0.08301773f, 0.05438427f, 0.09960340f, -0.23126553f, -0.33242568f, -0.11016665f, -0.15694301f, -0.60948890f, 
    -0.35909277f, 0.06444670f, 0.28731441f, 0.16317058f, 0.04887225f, 0.07105123f, 0.54050547f, 0.57859981f, 
    0.03020926f, -0.33926228f, -0.39093572f, 0.17639074f, 0.21365374f, -0.08919618f, -0.23465608f, -0.27152413f, 
    0.04310136f, -0.07474872f, 0.33043489f, 0.02896148f, -0.11626339f, 0.16568069f, 0.01679069f, -0.41651356f, 
    0.10220359f, -0.15588057f, -0.19064218f, 0.39795157f, 0.07051072f, 0.07007105f, -0.14883788f, -0.22762284f, 
    -0.57081747f, -0.00633565f, -0.64885062f, -0.46940252f, 0.29430810f, -0.03487448f, -0.23330896f, 0.15654737f, 
    0.04515177f, 0.38590869f, -0.21885224f, -0.23564237f, -0.59954745f, -0.37432376f, -0.33691081f, -0.02557316f, 
    0.29171509f, 0.07117919f, 0.00724764f, -0.15639178f, -0.05398565f, 0.08848283f, -0.17311326f, 0.51869947f, 
    0.03531415f, -0.84512430f, -0.48101622f, 0.34243059f, 0.35236079f, -0.35434178f, -0.20363794f, -0.49417719f, 
    -0.58125335f, -0.60534811f, -0.12367777f, -0.02367487f, 0.10501034f, -0.40001386f, -0.18457367f, 0.20022915f, 
    -0.02783999f, -0.20352450f, 0.28573155f, 0.29483643f, 0.08266375f, 0.06461751f, -0.06081902f, -0.01031257f, 
    0.02689891f, 0.22036166f, 0.12374749f, 0.14161035f, -0.20856166f, -0.08973896f, -0.33991089f, -0.25418967f, 
    -0.04134322f, 0.05550448f, 0.41497725f, 0.07226521f, 0.40780592f, 0.42097500f, -0.40624839f, -0.37818727f, 
    -0.36216840f, 0.07165825f, -0.24210441f, 0.25793183f, 0.16818401f, -0.06418487f, 0.03056932f, -0.12999849f, 
    -0.03703224f, 0.40134391f, 0.31206006f, -0.66794896f, -0.48462537f, 0.11108599f, 0.73707938f, 0.56512469f, 
    0.92993748f, 0.20578443f, -0.60394901f, -0.60425758f, -0.35372037f, -0.29448211f, 0.28930584f, -0.46575943f, 
    0.01286734f, 0.04630194f, 0.04118543f, -0.17430730f, -0.00324257f, 0.11721426f, -0.00532886f, -0.03584915f, 
    -0.03604962f, 0.10959768f, -0.04721002f, -0.86174679f, -0.09469129f, -0.51280975f, -0.82708091f, -0.48331365f, 
    0.40500653f, -0.19273795f, -0.45478186f, -0.31399724f, -0.19002326f, 0.27651462f, -0.33076483f, -0.21694252f, 
    -0.35034382f, -0.26453903f, 0.29695386f, 0.07659568f, -0.09363489f, 0.22047985f, 0.01318482f, 0.02253132f, 
    0.19942175f, 0.33371127f, 0.04812720f, 0.09287683f, -0.44631293f, 0.48503041f, 0.16591772f, -0.23226227f, 
    0.28175756f, -0.24234006f, 0.25529033f, -0.03251004f, -0.11525577f, -0.00801380f, -0.10760382f, 0.24585617f, 
    0.10128739f, -0.00448290f, -0.38673696f, 0.25978166f, 0.33920291f, -0.01725391f, -0.25362611f, -0.25145510f, 
    0.02571905f, -0.16381019f, -0.17129056f, 0.23492201f, -0.07493561f, -1.09763396f, -0.93149245f, -0.71093649f, 
    0.10920220f, 0.73067689f, 0.53550494f, 0.55306447f, -0.55182850f, -0.27849627f, 0.39378905f, -0.38242015f, 
    0.00511914f, -0.33656341f, 0.43335229f, -0.60258269f, -0.03669367f, 0.11158800f, 0.03128047f, 0.44291624f, 
    -0.13933674f, 0.03026744f, -0.19733895f, -0.03073642f, -0.17114468f, -0.15840800f, 0.37316698f, 0.82949704f, 
    0.57136267f, -0.21938083f, -0.64134675f, -0.41201970f, -0.09495560f, 0.07465918f, -0.02803967f, -0.65992045f, 
    -0.24719691f, -0.34676507f, -0.23473124f, -0.20836766f, 0.04874204f, 0.30338144f, 0.19377677f, 0.17235343f, 
    -0.07668299f, -0.37126189f, -0.06998366f, -0.22945346f, 0.00087632f, -0.11378634f, -0.22081849f, -0.90628004f, 
    -0.09974961f, -0.14868224f, 0.02602542f, 0.61669779f, 0.26472014f, -0.07376437f, 0.27011418f, -0.04686290f, 
    0.02357762f, 0.14004257f, -0.32555860f, -0.44011673f, -0.04437926f, -0.24062937f, 0.36325839f, -0.02266024f, 
    0.05327496f, -0.10383259f, -0.01163521f, -0.22234820f, -0.17485002f, -0.27140656f, -0.28785124f, -0.56463248f, 
    0.82477939f, -0.34395808f, 0.06138625f, -0.67109233f, -0.89228004f, 0.63417840f, 0.01260328f, 0.13218702f, 
    0.08447626f, -0.04916709f, 0.08189003f, 0.22275433f, 0.32463357f, -0.01965337f, -0.21323031f, -0.21036533f, 
    0.06129072f, 0.39896005f, -0.15039115f, -0.26466841f, -0.18710348f, 0.02040684f, -0.23784395f, 0.29488093f, 
    -0.02267016f, 0.41621336f, 0.21648115f, 0.21963443f, 0.38359708f, -0.14813782f, -0.29798818f, -0.45525929f, 
    -0.08640012f, 0.04718509f, 0.12355603f, 0.27172816f, -0.34353417f, -0.05399042f, -0.21406196f, -0.00093343f, 
    -0.28546807f, 0.08005180f, 0.12367521f, 0.22670867f, 0.17977220f, 0.01844260f, -0.09466171f, -0.03419086f, 
    0.06739327f, -0.27699533f, -0.05574559f, 0.50948989f, 0.40159017f, -0.13827512f, 0.09441172f, 0.00879628f, 
    0.02588823f, 0.29811686f, -0.07777789f, -0.24811114f, -0.05945264f, -0.20080812f, 0.03521442f, -0.17288361f, 
    -0.03306834f, 0.35329726f, -0.07514153f, -0.00891885f, -0.14332044f, -0.10569579f, -0.16571783f, -0.16583310f, 
    -0.35600299f, -0.21839643f, -0.22431903f, -0.53852087f, -0.28285554f, -0.42711669f, -0.10991389f, 0.00959951f, 
    0.40606150f, 0.23559570f, -0.07171027f, 0.33068511f, 0.43447804f, -0.11768679f, 0.21030287f, 0.05447670f, 
    0.12309458f, -0.10780768f, -0.24190135f, 0.15976560f, -0.11827298f, -0.08596169f, 0.08638592f, 0.00888347f, 
    0.17088744f, 0.03415645f, -0.21360652f, 0.10324790f, 0.27032545f, 0.97150308f, 0.04921813f, -0.19687635f, 
    -0.31621748f, -0.42968708f, -0.25584713f, -0.28144160f, -0.42482921f, -0.19718120f, -0.00181789f, -0.12614161f, 
    0.09095710f, 0.43086174f, -0.05700926f, 0.10838939f, 0.13701159f, 0.05048418f, 0.26796523f, -0.37847063f, 
    -0.19587199f, 0.04544766f, 0.02912258f, 0.01042625f, 0.21583776f, -0.56017548f, -0.46866727f, -0.57255542f, 
    -0.05064490f, 0.38351375f, -0.04611815f, 0.19227013f, 0.23359260f, 0.07269081f, -0.13547359f, 0.18303394f, 
    0.11402347f, 0.03775883f, -0.18513121f, 0.17082922f, -0.36813048f, 0.04000206f, 0.07943322f, -0.40451536f, 
    -0.27815419f, 0.41957009f, 0.34824690f, -0.06705346f, 0.20372806f, 0.37076706f, 0.29943648f, 0.19150551f, 
    -0.28384891f, 0.32362774f, 0.21612972f, 0.20425226f, -0.05296977f, -0.31149563f, -0.32317168f, -0.52717906f, 
    0.04315042f, 0.18041284f, 0.19326474f, 0.14607741f, 0.28505430f, -0.20704928f, -0.28850779f, 0.30431113f, 
    -0.08382548f, 0.20931059f, 0.20220803f, 0.15257812f, -0.05815183f, -0.02954567f, -0.24606073f, -0.50109619f, 
    -0.39000270f, 0.76645666f, -0.14512047f, -0.16765586f, 0.29890865f, -0.28584591f, -0.33717230f, -0.06162575f, 
    0.05860490f, 0.54022253f, -0.06434096f, 0.15152159f, 0.25321162f, -0.22313024f, -0.06171253f, -0.08999178f, 
    0.04977646f, -0.21787453f, -0.26033127f, -0.14224601f, -0.08693066f, -0.21502891f, -0.08121017f, -0.54745221f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.25929007f, -0.01586702f, -0.16006458f, 0.21680719f, 0.10366423f, 0.35688883f, 0.12981275f, 0.37144506f, 
    0.18096435f, 0.26559067f, 0.27558738f, 0.29914686f, -0.09412432f, 0.28958300f, 0.14541984f, -0.04303086f, 
    -0.27501377f, 0.35541147f, 0.10437492f, 0.16484033f, 0.10167841f, 0.13385744f, -0.02325654f, 0.13577539f, 
    0.11362147f, 0.11869553f, 0.21478935f, 0.35366789f, -0.11646105f, 0.28203401f, 0.11001525f, -0.06077372f, 
    0.07576253f, 0.04181429f, 0.08616206f, 0.26193106f, -0.00570108f, 0.16017735f, 0.14468126f, 0.12736604f, 
    0.40212169f, 0.47924253f, -0.17494433f, -0.31913754f, 0.35195440f, 0.25090212f, 0.44800165f, -0.09960277f, 
    0.31144422f, 0.36346692f, 0.25454512f, -0.35222670f, 0.31685263f, 0.26295727f, 0.26336622f, -0.12055089f, 
    0.41730696f, 0.31276858f, 0.14463687f, 0.01118057f, 0.22843863f, 0.22386751f, 0.05043163f, -0.01374434f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15961136f, 0.06126703f, 0.07333580f, -0.05683846f, 0.11695637f, 0.01973524f, -0.14862855f, 0.03030518f, 
    -0.15449724f, -0.06665563f, 0.00290082f, 0.07712446f, 0.07369442f, -0.05816188f, -0.12216137f, 0.11269612f, 
    -0.00053450f, -0.09858629f, -0.09538557f, 0.05719389f, 0.00527131f, 0.15797432f, 0.04260700f, -0.08309337f, 
    -0.25687623f, -0.07518614f, -0.00972877f, -0.08327601f, -0.01410106f, -0.07137304f, 0.02159810f, 0.03528841f, 
    -0.09036478f, 0.02480422f, -0.00556330f, 0.22295326f, 0.34558824f, -0.01754432f, -0.41139284f, -0.01056652f, 
    0.01783582f, -0.23259814f, 0.05099418f, 0.09403579f, -0.04937061f, 0.02804518f, 0.05454084f, -0.02047040f, 
    0.10817208f, 0.14868702f, -0.31634074f, -0.06891590f, -0.07045794f, -0.02149511f, 0.09808970f, -0.16041835f, 
    -0.10725150f, 0.00213611f, -0.01440093f, -0.22592866f, -0.30265564f, -0.60681456f, -0.57068938f, 0.12354673f, 
    0.01280782f, 0.00528284f, 0.00905924f, 0.00724025f, -0.21081458f, -0.15407710f, -0.05113885f, 0.00439591f, 
    -0.05872060f, -0.02149727f, -0.04767171f, 0.05917282f, -0.02134891f, -0.00285730f, 0.04292601f, 0.02646025f, 
    -0.12402505f, -0.16935728f, -0.10342357f, -0.11385716f, 0.23146696f, 0.20764050f, 0.09217388f, -0.05623947f, 
    -0.07288920f, 0.05193300f, 0.02963696f, -0.13334784f, -0.03633782f, -0.09643172f, 0.00466307f, -0.01230479f, 
    -0.04348332f, 0.04272041f, -0.17147832f, 0.08836567f, 0.07968803f, -0.02771660f, -0.00992574f, -0.04970010f, 
    0.04630075f, -0.17746942f, -0.10707074f, -0.04351229f, -0.15631351f, -0.17522816f, -0.00818655f, 0.06059657f, 
    -0.10081127f, 0.01604163f, -0.15977415f, -0.19501388f, -0.04415830f, -0.07384411f, -0.07312479f, -0.06467143f, 
    -0.15774822f, 0.00670003f, -0.14743534f, 0.03573840f, -0.03150925f, 0.04058486f, 0.02699442f, 0.02604334f, 
    0.02107194f, -0.09520146f, -0.01848561f, -0.07454807f, 0.09217744f, -0.21184152f, -0.24790014f, 0.07078775f, 
    0.01655854f, -0.02131544f, 0.01178227f, 0.02927272f, -0.02668828f, -0.13236313f, 0.02224702f, 0.06804122f, 
    0.06958274f, -0.00015716f, 0.01299573f, 0.03241446f, -0.00405539f, 0.13191479f, -0.03934239f, 0.01963087f, 
    -0.01328870f, 0.05269696f, 0.01063639f, 0.02156160f, -0.18680640f, 0.03935074f, 0.13533327f, -0.04784405f, 
    0.03519318f, -0.02592775f, 0.09259237f, -0.00507285f, -0.15420419f, 0.03385967f, -0.12259206f, -0.24020374f, 
    0.05480692f, -0.14812081f, -0.01605428f, 0.05442036f, 0.05793941f, 0.05954424f, -0.00867436f, -0.04418477f, 
    -0.02569623f, 0.05011819f, 0.02587259f, 0.15163688f, 0.23255199f, 0.10101154f, -0.04763256f, -0.19838957f, 
    0.05580267f, -0.00909935f, 0.12247053f, -0.02863592f, -0.12622640f, -0.12842615f, -0.10027832f, -0.13384262f, 
    0.27631703f, 0.10968235f, -0.05560819f, -0.14633250f, -0.00023917f, 0.02696105f, -0.11664341f, -0.16617575f, 
    -0.00120489f, 0.01312852f, 0.00635021f, -0.00423363f, -0.24409245f, -0.38995010f, -0.52944911f, 0.13170706f, 
    0.00138299f, 0.00660885f, -0.03050502f, -0.02658859f, -0.08218801f, -0.13170983f, -0.26033777f, 0.05630724f, 
    0.15434733f, 0.02233636f, 0.06136489f, -0.21590939f, -0.03713059f, 0.05948404f, 0.03539574f, 0.00976736f, 
    -0.04069973f, -0.02705789f, -0.04594278f, 0.00080804f, 0.31035525f, 0.36643010f, 0.10146332f, -0.23604497f, 
    -0.04232818f, -0.17972384f, 0.03136608f, 0.04304481f, 0.07240481f, -0.05383547f, -0.14709644f, -0.01985750f, 
    0.23131892f, -0.22128153f, -0.01196280f, -0.09354573f, -0.01903505f, -0.02913532f, 0.05217655f, -0.03478873f, 
    -0.05353573f, -0.05117598f, -0.03025237f, 0.12739027f, 0.15715270f, -0.51060730f, -0.30634382f, 0.25340575f, 
    0.04024258f, 0.00789811f, 0.05377689f, 0.01903116f, -0.00654218f, -0.00041989f, 0.01666234f, 0.07324180f, 
    0.10978835f, 0.18844672f, 0.14546326f, -0.02604048f, 0.15626931f, 0.04395286f, 0.00434489f, 0.04468865f, 
    -0.08994930f, -0.22938606f, -0.03408409f, 0.15689579f, 0.24942191f, 0.10920149f, 0.24106543f, -0.11763886f, 
    -0.01738226f, -0.01611421f, 0.06938995f, -0.19559732f, 0.04650142f, -0.03695605f, -0.02307647f, 0.00516346f, 
    0.10799882f, -0.15524542f, -0.02047236f, 0.03223643f, 0.00830803f, -0.01630930f, -0.09320699f, -0.08116362f, 
    0.16814159f, -0.10660514f, -0.02362448f, -0.05271810f, 0.30064175f, 0.21092227f, -0.20294473f, -0.21506375f, 
    0.06224438f, -0.01496712f, 0.02642237f, 0.04933504f, 0.03236132f, -0.04289795f, 0.00368056f, -0.04154979f, 
    0.35893992f, -0.41837430f, -0.31896603f, -0.05539082f, 0.05260686f, -0.02219309f, 0.04094446f, -0.07813346f, 
    0.15360163f, 0.00477680f, -0.03310062f, 0.09152339f, -0.10215245f, -0.37175718f, -0.01044543f, -0.00807268f, 
    -0.03990604f, -0.00698777f, -0.11641962f, -0.10061943f, -0.09436008f, -0.12058136f, -0.07658859f, -0.02614718f, 
    -0.00667785f, -0.02280879f, 0.01659537f, 0.06237298f, 0.00846000f, -0.03903861f, 0.02128828f, 0.02326272f, 
    -0.04217831f, -0.10403977f, 0.05789970f, 0.04788128f, 0.06430267f, 0.04376351f, -0.06082014f, -0.07040008f, 
    0.05495034f, -0.02013872f, 0.03428004f, -0.07740897f, 0.03335360f, -0.03595005f, -0.03366375f, -0.10528999f, 
    0.01390120f, 0.05031433f, -0.20775592f, 0.05403706f, 0.08699591f, 0.14653911f, -0.12520970f, 0.01653810f, 
    -0.03187114f, -0.00898065f, 0.04638161f, 0.06424026f, -0.27447477f, -0.36312759f, 0.24391556f, 0.27488053f, 
    0.00501385f, -0.00436357f, -0.02082390f, -0.08869893f, 0.03998354f, -0.03814347f, -0.03644171f, -0.02590858f, 
    0.04437816f, 0.00109786f, -0.45015830f, 0.08762739f, 0.08805913f, 0.04530485f, 0.03817847f, -0.03017609f, 
    -0.10750361f, 0.04014705f, -0.10309166f, -0.02064666f, 0.06958789f, -0.23427981f, 0.10200437f, -0.17293911f, 
    0.00494769f, 0.00230778f, 0.03676455f, 0.06850058f, 0.00446031f, -0.02677976f, -0.05047740f, 0.02031270f, 
    -0.05845818f, 0.01888896f, -0.21870789f, 0.13329759f, 0.03526789f, 0.04179139f, -0.04347501f, 0.00052568f, 
    0.01107558f, 0.05543750f, 0.03661858f, 0.04194191f, -0.49036500f, -0.33204499f, -0.30152819f, 0.07339431f, 
    -0.02428322f, -0.01883656f, 0.02256600f, 0.01790503f, -0.16329078f, -0.10570712f, -0.22341059f, -0.07675916f, 
    -0.18062896f, 0.16241343f, -0.11242992f, -0.00966492f, 0.01772127f, 0.07574388f, 0.01329494f, 0.01914463f, 
    -0.00622258f, 0.16302727f, 0.07900161f, 0.00581212f, 0.10583176f, 0.21879977f, -0.01243534f, -0.02797593f, 
    0.08118103f, 0.06144395f, 0.00903790f, -0.04085087f, 0.08659337f, -0.05382439f, 0.02910113f, -0.03874462f, 
    0.24989726f, 0.13939457f, -0.04530235f, -0.09807864f, 0.07104199f, 0.22727460f, 0.13169231f, 0.11278287f, 
    0.01499654f, 0.02766240f, 0.03746605f, 0.05778988f, -0.45841402f, 0.29310507f, -0.18807784f, -0.00466606f, 
    0.12591071f, 0.07495867f, -0.19525665f, -0.05913753f, 0.02007059f, 0.01789497f, -0.01443157f, 0.04615756f, 
    -0.03743170f, -0.05154920f, 0.08830772f, 0.03176276f, -0.19506614f, -0.01369236f, -0.16695802f, -0.09964670f, 
    -0.08055745f, -0.08767188f, 0.01949141f, -0.06437447f, 0.10851725f, -0.51006639f, -0.49739289f, 0.11181659f, 
    0.06481650f, 0.04321813f, -0.10909625f, -0.24048841f, -0.06633765f, 0.01521319f, -0.08344718f, -0.11995935f, 
    0.16776021f, 0.11660275f, 0.07258528f, -0.24959308f, -0.24133131f, -0.07021829f, -0.05837591f, -0.05154907f, 
    0.03057396f, 0.02204322f, 0.01036596f, -0.12068684f, 0.21555783f, 0.14384563f, 0.00952373f, -0.01538714f, 
    0.17465244f, 0.17227265f, 0.01250887f, 0.02847124f, -0.05114387f, -0.04651380f, -0.07284380f, -0.03069558f, 
    -0.00072837f, 0.00502582f, -0.07483719f, -0.00366151f, -0.08783320f, -0.13275872f, -0.01732299f, -0.08403185f, 
    0.01711343f, -0.01942232f, -0.01888029f, -0.04052619f, 0.23936653f, 0.24382384f, 0.18303502f, -0.25450087f, 
    0.07260698f, 0.20620826f, -0.04672772f, -0.18229495f, -0.03622316f, -0.09535433f, -0.08072691f, -0.16749255f, 
    -0.12680185f, -0.55208707f, -0.43644458f, 0.25089735f, 0.05112318f, 0.04562957f, -0.02716993f, -0.08431286f, 
    -0.10241907f, -0.01699942f, -0.12734757f, 0.08426432f, 0.26124713f, 0.14362080f, 0.00799921f, -0.14402173f, 
    0.10647168f, 0.07628539f, 0.04366577f, 0.05915806f, 0.06977798f, -0.00515945f, -0.04790227f, -0.10910821f, 
    0.25965932f, 0.04644081f, -0.16161802f, -0.16479202f, 0.13853565f, 0.02525401f, 0.06889638f, 0.00300908f, 
    -0.06416427f, 0.00459278f, -0.01178163f, -0.04777631f, -0.07855076f, 0.01988851f, -0.12592734f, -0.18293060f, 
    -0.15632355f, -0.08291659f, -0.04134244f, -0.13084261f, -0.02525438f, -0.03948933f, 0.05477919f, -0.00356622f, 
    0.33874646f, -0.24200210f, -0.38313252f, 0.05637813f, -0.03336039f, -0.05995318f, 0.10546038f, -0.01421574f, 
    -0.07350656f, 0.02887931f, 0.04785982f, -0.05743083f, 0.24748868f, 0.23158887f, -0.27937225f, -0.24740238f, 
    0.04475522f, 0.20909393f, -0.05729532f, 0.19248235f, -0.01066437f, -0.00851127f, 0.00265148f, 0.00300965f, 
    -0.20350799f, 0.17128237f, -0.17700516f, -0.01074213f, -0.10326435f, -0.05936202f, 0.04780177f, 0.05097200f, 
    -0.06099438f, 0.01076183f, -0.19299532f, -0.03952511f, 0.48447031f, 0.12767549f, -0.19804223f, -0.07301049f, 
    0.06152263f, 0.04726423f, 0.12440584f, 0.00113406f, 0.03088436f, 0.02898980f, 0.00114080f, -0.02322065f, 
    -0.11961789f, -0.06092262f, 0.02778659f, 0.09281465f, -0.05076421f, -0.01158617f, -0.12091271f, -0.02470481f, 
    0.01116200f, -0.01519118f, -0.00017546f, 0.04557041f, 0.17494306f, 0.11192170f, -0.00283872f, -0.04514092f, 
    -0.04656252f, 0.12745535f, -0.02529518f, 0.05569106f, -0.05029380f, 0.08995551f, 0.05162014f, 0.15230532f, 
    0.18632717f, -0.45543328f, -0.39442447f, 0.02594072f, 0.02342071f, 0.05796515f, -0.19808476f, 0.01354930f, 
    -0.09448732f, -0.16331393f, -0.17417872f, 0.08965674f, -0.26559725f, 0.02035388f, 0.13844095f, -0.07747942f, 
    -0.05517086f, -0.03860105f, -0.08049812f, 0.02061784f, -0.02278738f, -0.02766511f, -0.03140189f, 0.02855765f, 
    -0.40849942f, -0.13288990f, -0.02614287f, 0.11559295f, 0.02016765f, 0.04089798f, -0.00540587f, 0.00011891f, 
    -0.06514955f, -0.01429700f, 0.04218766f, 0.01926905f, 0.01112612f, 0.09117109f, 0.04327887f, 0.07393564f, 
    0.04961406f, 0.07821435f, 0.01181613f, 0.00201180f, -0.09986353f, 0.17267098f, -0.01105170f, -0.05606128f, 
    0.06111211f, -0.00516043f, -0.07588869f, 0.00172830f, -0.04380770f, -0.07785914f, -0.01899000f, -0.13661024f, 
    -0.04794070f, 0.04857527f, 0.04706277f, 0.04747452f, 0.11533739f, 0.11472616f, -0.10584624f, -0.04938740f, 
    0.13303553f, 0.06006540f, 0.02097651f, -0.31330860f, -0.09377552f, -0.16037574f, -0.04404487f, -0.12115368f, 
    0.00705912f, 0.02817691f, -0.09127428f, 0.03187469f, -0.14015524f, -0.06209609f, 0.01883625f, 0.02478650f, 
    -0.03535717f, 0.00239972f, 0.00960383f, -0.13429341f, 0.10195637f, 0.07238423f, -0.07319709f, -0.21452421f, 
    -0.00829064f, 0.01315324f, -0.01262495f, 0.07401673f, 0.10379937f, 0.01006411f, -0.05601145f, 0.08876880f, 
    0.13009617f, 0.20075822f, -0.08992890f, -0.16378713f, 0.04386569f, 0.07866222f, 0.05136253f, 0.17251754f, 
    0.01056097f, -0.00826396f, -0.03056040f, -0.10632131f, -0.03437746f, 0.00393909f, 0.02940624f, -0.01583763f, 
    0.00628245f, 0.01578945f, -0.06046811f, 0.10193349f, -0.06318333f, 0.01843560f, -0.06399268f, 0.13145544f, 
    -0.03482519f, 0.03973126f, 0.04396932f, -0.12954761f, -0.03817485f, 0.01757992f, -0.03184161f, 0.02653709f, 
    -0.23454280f, -0.55975819f, -0.37405849f, -0.37222564f, -0.06774510f, 0.14999592f, -0.42215851f, -0.11782999f, 
    -0.20193833f, 0.11924506f, 0.03849711f, 0.03202329f, -0.00271877f, 0.05202641f, -0.05903033f, 0.04864580f, 
    0.41372970f, -0.09230617f, -0.12839384f, -0.05175143f, -0.08980089f, -0.03508630f, 0.02571767f, -0.17964049f, 
    0.33996978f, -0.14906316f, -0.20195657f, 0.32520005f, 0.22552434f, 0.06297028f, 0.23599467f, -0.17866960f, 
    0.02600979f, 0.00082279f, 0.02131584f, 0.04869730f, -0.00132940f, 0.00284875f, 0.16411527f, -0.18889667f, 
    0.16331044f, 0.01348932f, 0.07742404f, 0.10399443f, -0.04474885f, -0.01278945f, -0.00568707f, 0.02141886f, 
    -0.11145565f, 0.00950745f, -0.03801406f, 0.06284234f, -0.30956239f, -0.08311881f, -0.07468862f, -0.03594000f, 
    0.08219357f, -0.00949816f, 0.12702546f, 0.14408009f, -0.14911151f, -0.04145337f, 0.09358364f, 0.01521524f, 
    -0.09214156f, 0.13097328f, 0.06322058f, -0.18526532f, 0.01808878f, 0.05080658f, 0.00764117f, -0.11383337f, 
    0.04139015f, 0.07661160f, -0.01439046f, -0.05392858f, 0.03290949f, -0.05169505f, 0.21316420f, -0.02977797f, 
    0.00052705f, 0.05604564f, 0.04478353f, -0.00726609f, -0.01170963f, 0.02045883f, -0.01389609f, -0.07310224f, 
    0.11391570f, 0.13193372f, 0.07342854f, 0.10995444f, -0.01820505f, 0.04393939f, 0.05695611f, -0.03871358f, 
    0.08244633f, 0.04263129f, -0.00219185f, -0.01248340f, 0.24799527f, -0.02711990f, -0.10493382f, 0.19260757f, 
    0.02292190f, -0.02818188f, -0.01403577f, 0.00943739f, -0.14955813f, -0.28097162f, -0.05315324f, -0.10959643f, 
    -0.05822515f, -0.03264102f, -0.05120298f, 0.02123672f, 0.05529726f, 0.00980589f, 0.04614948f, -0.04804324f, 
    0.00655088f, -0.08481698f, 0.00680298f, -0.07450836f, -0.20388396f, 0.05534528f, 0.04430695f, 0.21440852f, 
    -0.08791502f, 0.01910883f, -0.01927711f, 0.01689107f, -0.02557403f, 0.06889880f, -0.29600477f, 0.06921878f, 
    0.10010312f, -0.08425353f, -0.01737717f, -0.13826802f, -0.00017778f, 0.04669194f, -0.05027439f, -0.03782885f, 
    -0.13131225f, 0.14094481f, 0.07844162f, -0.17656988f, -0.02755667f, -0.02399648f, 0.13707730f, 0.19069649f, 
    0.05282696f, 0.02434037f, 0.18593358f, 0.02005492f, -0.01193605f, 0.01262756f, -0.03783341f, 0.01357207f, 
    -0.01771049f, 0.13440457f, 0.18685894f, 0.25551534f, 0.09058923f, -0.07110903f, -0.10604507f, -0.00622457f, 
    -0.04262434f, 0.03980560f, 0.03501032f, -0.04044766f, 0.75351763f, 0.04820623f, 0.01140236f, 0.00065922f, 
    -0.05446513f, -0.02543045f, 0.04569725f, 0.02374583f, 0.05564883f, 0.11621360f, 0.23051712f, -0.05599012f, 
    0.07297482f, -0.21598466f, -0.16997077f, -0.08295681f, 0.06780136f, 0.11818381f, -0.02453097f, 0.07510673f, 
    0.02714184f, -0.06860248f, 0.06080083f, -0.10279292f, -0.45491469f, -0.48285025f, -0.17812181f, -0.18272468f, 
    0.06438198f, 0.08503433f, 0.16250950f, -0.03611071f, -0.02547510f, -0.00359573f, -0.04605982f, 0.10788460f, 
    -0.17051570f, -0.07071330f, 0.11441381f, 0.03890499f, 0.00180409f, 0.01457397f, -0.07956373f, 0.05891807f, 
    0.04830188f, -0.08776398f, 0.21589896f, -0.26075086f, 0.48015848f, 0.05941628f, 0.31771493f, 0.19305344f, 
    -0.02489808f, 0.00482712f, -0.05037566f, -0.03972726f, 0.00538243f, 0.04228445f, -0.01684036f, 0.13086094f, 
    -0.02405029f, 0.08879756f, 0.04292095f, 0.12208246f, -0.00997725f, -0.03725335f, -0.12417990f, -0.15808544f, 
    0.14304963f, 0.10967861f, -0.20746440f, 0.05573343f, -0.25545341f, 0.05987955f, -0.19349536f, -0.03342624f, 
    -0.08964188f, 0.04968264f, 0.05786879f, 0.14084271f, -0.04100055f, -0.05195765f, -0.04172888f, -0.03654212f, 
    0.00203464f, -0.42557213f, 0.00386206f, -0.18656453f, 0.03373525f, 0.09450717f, -0.15634778f, -0.00198602f, 
    0.16123761f, -0.03071179f, 0.10735448f, 0.12844414f, -0.06345940f, 0.08326973f, 0.08237882f, 0.07392700f, 
    -0.12709115f, 0.00217414f, -0.06634169f, 0.00205386f, 0.07895131f, -0.02387944f, -0.01502324f, 0.04995206f, 
    0.40323654f, 0.05055410f, 0.15981998f, 0.05792677f, -0.04901972f, -0.00801684f, 0.08525410f, 0.02870495f, 
    0.00507507f, 0.01283904f, 0.15665783f, -0.16336815f, 0.09623034f, 0.00591733f, 0.12493072f, -0.23090677f, 
    -0.06327426f, 0.09828196f, 0.04764505f, -0.08161988f, 0.04051908f, 0.10435344f, -0.14618525f, -0.03881588f, 
    0.04664353f, 0.06334532f, 0.09923553f, 0.06757464f, -0.05073012f, 0.04932565f, 0.02682194f, -0.00279334f, 
    -0.07631006f, 0.08341432f, -0.03917579f, 0.08663430f, -0.25965568f, 0.10035774f, -0.36813071f, -0.25835755f, 
    -0.02210802f, 0.00658372f, -0.02681767f, 0.03961143f, 0.02546551f, 0.16723661f, -0.01933612f, -0.05315433f, 
    0.20160002f, -0.01631037f, 0.14692302f, -0.12858771f, 0.10212119f, -0.00350774f, -0.23338507f, -0.21461901f, 
    -0.10618973f, 0.09694492f, -0.04199260f, -0.15526444f, 0.00632975f, 0.05367844f, 0.05427915f, 0.05701760f, 
    -0.03070248f, -0.06968080f, 0.01034073f, 0.03334744f, -0.07920440f, 0.20132014f, -0.17089352f, 0.00384040f, 
    0.12449387f, -0.11388428f, -0.27908853f, -0.05802326f, -0.05284058f, -0.02231828f, 0.03003786f, 0.05615133f, 
    -0.04778874f, -0.01495421f, 0.02452466f, 0.05741740f, -0.07049088f, -0.21494046f, -0.08037572f, 0.09373300f, 
    -0.06386573f, 0.04360450f, 0.04661702f, -0.01611630f, -0.00752927f, 0.03785313f, -0.04183662f, -0.02000440f, 
    0.22856288f, 0.08474869f, 0.07424834f, -0.00361448f, -0.04759660f, -0.10209710f, -0.04356347f, -0.04134550f, 
    -0.04763989f, 0.01251972f, 0.01790992f, 0.04067627f, 0.39246050f, -0.02760113f, 0.06363079f, -0.11873929f, 
    0.01815768f, -0.01814893f, 0.01794958f, -0.03130667f, 0.03894681f, -0.07260799f, -0.17971297f, -0.08841112f, 
    -0.06218408f, 0.06924425f, 0.42329258f, -0.14609122f, -0.04025700f, -0.06047739f, 0.05493787f, -0.01350946f, 
    -0.01485885f, 0.00894803f, -0.31369236f, -0.03639523f, 0.23251078f, 0.07654367f, -0.20876941f, -0.18576083f, 
    -0.02794046f, 0.04479701f, -0.04989767f, -0.05255193f, -0.01167012f, -0.06031857f, -0.07668775f, -0.03001523f, 
    0.02286894f, 0.08986124f, 0.05684077f, -0.04269896f, 0.05545326f, -0.05586843f, -0.31507257f, -0.21507487f, 
    0.01462416f, -0.02232886f, -0.09209365f, -0.08173578f, -0.26844588f, 0.35720801f, -0.31838012f, 0.28452647f, 
    0.09027717f, -0.27981049f, -0.01778772f, -0.06731229f, -0.02445011f, -0.02813102f, 0.00304569f, 0.09902377f, 
    -0.12626238f, 0.04867490f, -0.00141967f, -0.04254829f, 0.08992672f, 0.03261982f, -0.01786402f, 0.07433344f, 
    -0.04040207f, -0.04143661f, -0.01475355f, 0.04235022f, 0.43419325f, -0.39717606f, 0.07859530f, -0.19365162f, 
    -0.04608894f, 0.01816662f, 0.02535172f, 0.16745897f, 0.03070956f, -0.12616067f, 0.02873744f, 0.12267171f, 
    -0.10273390f, -0.00383785f, -0.30678502f, -0.62728924f, 0.02141012f, -0.07802808f, -0.10109352f, 0.19162990f, 
    -0.02283701f, -0.01673954f, 0.00767065f, -0.12640613f, 0.24795140f, 0.24538435f, 0.19200683f, -0.03052046f, 
    -0.01981541f, 0.06719977f, 0.11321279f, 0.10319311f, -0.05398675f, 0.05615772f, -0.07180581f, -0.02594279f, 
    0.01117589f, 0.00617139f, -0.03839803f, 0.04132041f, -0.01673077f, 0.10675323f, -0.06433053f, 0.03926782f, 
    -0.03672913f, 0.01033084f, -0.06294532f, 0.04971070f, -0.34701055f, 0.12335360f, -0.33133861f, 0.11982778f, 
    0.05312233f, -0.01124120f, -0.00267868f, 0.21461010f, -0.04166987f, 0.05243121f, 0.11464618f, 0.00245837f, 
    0.29297382f, -0.14462207f, 0.16687824f, -0.06820659f, -0.08938740f, -0.22224250f, 0.01972206f, 0.01327864f, 
    -0.11333086f, -0.01206992f, -0.01026746f, 0.09116522f, 0.13333906f, 0.27073571f, -0.14298202f, -0.35444963f, 
    0.05690825f, 0.05421422f, -0.14709207f, 0.12584932f, -0.00346400f, 0.05383050f, -0.18881245f, -0.12790558f, 
    -0.08240668f, 0.00769871f, -0.22573270f, 0.02334367f, -0.21568182f, -0.03134590f, 0.02244028f, -0.15287291f, 
    -0.02682534f, -0.04739711f, 0.04802166f, -0.02667127f, 0.07536804f, 0.03539858f, -0.00720715f, -0.00909971f, 
    0.11563507f, 0.27980152f, -0.15231162f, -0.04048693f, 0.05281997f, 0.02174198f, -0.04048925f, 0.07253475f, 
    0.32947582f, -0.52333128f, 0.29796058f, 0.25672242f, -0.04721626f, -0.04352968f, 0.12061608f, -0.07211623f, 
    0.23933062f, 0.01682609f, 0.08900588f, -0.03221507f, 0.27845433f, 0.33942208f, 0.21813098f, 0.06412203f, 
    0.02639647f, 0.05844999f, -0.01065696f, -0.14920729f, -0.07454982f, 0.03689386f, -0.10262960f, -0.00559778f, 
    -0.08420304f, -0.18511488f, 0.12200035f, 0.10289916f, 0.05503616f, -0.04266771f, 0.00274899f, -0.12727186f, 
    0.16844967f, -0.01816881f, 0.03922763f, 0.11692448f, 0.17456952f, -0.20017062f, -0.19485055f, -0.03733231f, 
    -0.05759320f, 0.00286571f, 0.10949790f, -0.11558723f, 0.13925147f, -0.14394531f, -0.05744458f, 0.02977025f, 
    0.23083851f, -0.28304958f, 0.23890902f, -0.31947583f, 0.05407876f, -0.03217592f, 0.04958824f, -0.10884628f, 
    -0.04525046f, 0.04634907f, -0.06051262f, 0.00503618f, -0.09060092f, -0.05485657f, -0.02683660f, 0.02698842f, 
    0.05440821f, -0.03591373f, -0.07534739f, 0.02719167f, -0.11958570f, -0.09572843f, -0.26817688f, -0.15440626f, 
    0.44258130f, -0.36614823f, -0.13193548f, -0.35095602f, 0.05399115f, -0.01390822f, 0.12333364f, -0.00583264f, 
    0.11600940f, 0.23919785f, 0.17294104f, 0.07033814f, 0.02152781f, 0.16791664f, 0.06042796f, -0.04605126f, 
    0.01422656f, -0.07040273f, -0.05298999f, -0.12566018f, 0.00117409f, -0.05153668f, 0.06918200f, -0.01139499f, 
    0.07794658f, -0.00463082f, 0.10994212f, 0.05389328f, -0.01779183f, -0.05694469f, 0.00554078f, 0.03593991f, 
    -0.02572742f, 0.05632070f, -0.13079329f, 0.05350275f, 0.02212770f, 0.08662202f, -0.10255868f, -0.06493119f, 
    -0.04540702f, 0.03615842f, -0.03308098f, -0.05862673f, -0.02946818f, 0.01930960f, -0.06096691f, -0.14117068f, 
    0.04849355f, -0.18751711f, -0.02729996f, -0.08400343f, -0.04621839f, -0.18217470f, -0.02329394f, 0.01567609f, 
    -0.02502380f, 0.03704013f, 0.02724068f, 0.02115436f, -0.34711176f, 0.04354546f, 0.06493568f, 0.02320980f, 
    -0.00878622f, 0.07463004f, 0.08508680f, 0.11512748f, -0.06483966f, 0.06641664f, -0.00224102f, -0.02895865f, 
    0.08726416f, 0.04595390f, -0.04410170f, -0.02004673f, 0.10729443f, -0.15308751f, 0.01523180f, 0.01900225f, 
    -0.08453985f, -0.01829843f, 0.00800740f, 0.08901835f, -0.05019868f, -0.06290338f, -0.15139383f, -0.10990613f, 
    -0.00816129f, -0.02887657f, 0.00481471f, 0.12138770f, -0.21217605f, -0.25879091f, -0.05139308f, -0.16806671f, 
    -0.18110795f, 0.46129090f, 0.20832969f, 0.19638245f, -0.00158797f, -0.02157206f, 0.10377082f, -0.03200027f, 
    -0.02291777f, -0.06871366f, -0.01623636f, -0.06379747f, -0.06409344f, -0.03636742f, 0.08415686f, -0.08920061f, 
    -0.05583224f, -0.13497820f, -0.19206387f, -0.05482839f, 0.01847057f, 0.05466181f, -0.06991357f, 0.00404176f, 
    0.00648742f, 0.00407382f, -0.06832747f, 0.00427618f, -0.00383444f, -0.03596867f, -0.05408080f, -0.07993814f, 
    0.09593229f, 0.09538519f, 0.14583445f, 0.27884310f, -0.16744114f, -0.01941873f, -0.20900948f, -0.11245938f, 
    -0.24797495f, -0.20484827f, 0.00960921f, 0.02774255f, 0.04440210f, 0.01988791f, -0.08718504f, -0.00018409f, 
    -0.03670169f, -0.09745227f, -0.05979938f, -0.03821295f, 0.01949502f, -0.09003236f, -0.02046814f, -0.04063670f, 
    -0.02543139f, 0.19188516f, -0.22699574f, -0.00979151f, -0.38327762f, 0.33447999f, 0.28275013f, -0.34299734f, 
    0.00432932f, -0.00276123f, -0.07090714f, 0.04396757f, 0.08952357f, -0.12093341f, -0.00422056f, 0.08675799f, 
    -0.06650344f, 0.01054267f, 0.01097664f, 0.00113754f, 0.03904815f, -0.01457690f, 0.04659244f, -0.00988660f, 
    -0.03901532f, -0.10680854f, -0.03774010f, 0.15257385f, 0.06237408f, -0.00334978f, -0.05006976f, 0.17637208f, 
    -0.01635038f, -0.06262667f, -0.07985578f, 0.07038075f, -0.02205389f, 0.02844342f, 0.01488717f, 0.00414348f, 
    -0.16603877f, 0.05561930f, 0.13756622f, -0.11689759f, -0.06075495f, 0.06385069f, -0.00400739f, -0.09541570f, 
    -0.08649897f, -0.07611801f, 0.16423315f, -0.12731802f, -0.06763181f, 0.03234005f, 0.16402861f, 0.07773089f, 
    0.01033717f, 0.09792072f, -0.05404224f, 0.10194435f, -0.01458886f, 0.03260683f, 0.05115585f, -0.02127236f, 
    -0.12488682f, 0.17226686f, -0.06635261f, 0.07158951f, -0.01784572f, -0.03054505f, 0.01260867f, -0.00172303f, 
    0.03963593f, -0.03900554f, -0.09669079f, -0.14372240f, 0.04643676f, -0.10524361f, 0.16782787f, -0.01998476f, 
    -0.00373419f, 0.00122021f, -0.00476593f, 0.06013877f, 0.04837833f, 0.04131016f, 0.21813981f, -0.03698177f, 
    0.14450903f, -0.05791678f, 0.01894177f, 0.11009750f, -0.03268927f, -0.02203628f, 0.05669740f, -0.01666661f, 
    0.08412664f, -0.02158024f, 0.05832609f, 0.05315110f, 0.05210842f, -0.24318199f, -0.10204320f, 0.11187165f, 
    0.03738813f, 0.02915933f, 0.00077842f, 0.03169743f, -0.16718434f, -0.07275344f, 0.00716459f, 0.03913409f, 
    0.03989587f, 0.16928944f, 0.12285961f, 0.03075080f, 0.03682858f, 0.07192782f, -0.00613286f, -0.08062781f, 
    0.00735921f, -0.01183287f, -0.05363432f, 0.13407953f, -0.53480613f, -0.28508997f, -0.15843368f, -0.17749527f, 
    0.06378576f, -0.07725853f, -0.01082194f, -0.04878160f, 0.01179958f, -0.01575252f, 0.04508137f, -0.06307463f, 
    -0.06976726f, -0.71654922f, -0.00707074f, 0.12165791f, -0.08935823f, -0.07489422f, -0.09019137f, -0.07323587f, 
    0.00789563f, -0.03212663f, 0.00672286f, 0.03508651f, -0.37482828f, 0.43890667f, 0.23484421f, -0.11214797f, 
    -0.02770424f, 0.01692500f, -0.07532611f, -0.04869289f, 0.02805948f, -0.00940248f, 0.03482840f, -0.01930013f, 
    0.12777728f, 0.23155645f, -0.31438068f, 0.00557492f, 0.03565706f, -0.13664824f, 0.01318260f, 0.10015579f, 
    -0.05409053f, 0.04681052f, -0.23241624f, 0.15388237f, 0.10192382f, -0.05771736f, -0.56204623f, -0.15113203f, 
    0.08265913f, -0.02187922f, -0.20743521f, 0.10845011f, -0.12919751f, -0.05804205f, 0.05316933f, -0.09092676f, 
    0.12772326f, 0.01557446f, 0.15167561f, 0.02656419f, 0.05192574f, -0.00960331f, -0.00746552f, 0.07927839f, 
    0.08568776f, 0.09673593f, -0.00016058f, -0.20313515f, 0.12173006f, -0.07763113f, -0.12637343f, -0.10358733f, 
    0.01540663f, -0.05531970f, 0.03474409f, 0.01821814f, -0.00446006f, 0.03435060f, 0.00488495f, -0.03177937f, 
    -0.00581085f, 0.22107381f, -0.07172687f, 0.11774947f, 0.00693835f, -0.00480576f, 0.11622141f, -0.18321085f, 
    -0.10965044f, -0.01930182f, 0.05571491f, 0.10883667f, 0.00575370f, 0.09833935f, -0.10121261f, 0.04971281f, 
    0.04663604f, -0.13455717f, 0.00206930f, 0.08532554f, -0.00912955f, -0.02280114f, -0.04261461f, 0.02993041f, 
    0.04011719f, 0.21012369f, -0.10348526f, 0.13667604f, -0.00642162f, -0.07209499f, 0.10396670f, -0.19018964f, 
    0.05281571f, -0.03919589f, 0.21356213f, 0.13459013f, -0.03607643f, -0.51671338f, 0.01591717f, -0.32722396f, 
    0.06275511f, 0.09805132f, -0.16179909f, 0.04189826f, -0.00830192f, 0.06625861f, -0.03892904f, -0.02671890f, 
    -0.24909319f, 0.12895718f, 0.54165947f, 0.08461440f, -0.00627044f, -0.06373379f, -0.01579784f, 0.03610710f, 
    0.00108591f, 0.11049260f, 0.09874710f, -0.03930996f, 0.03699756f, 0.20107268f, -0.23098479f, 0.00236253f, 
    0.02019894f, 0.07941335f, -0.03880608f, 0.05963134f, 0.05935450f, -0.06405221f, -0.15245162f, 0.11754331f, 
    -0.26523805f, -0.13118672f, -0.07196540f, 0.00880935f, -0.03394627f, -0.04682969f, -0.01908518f, 0.05626447f, 
    -0.08006464f, -0.17228395f, 0.09857243f, -0.09742143f, 0.23966140f, 0.16447434f, 0.10592437f, 0.27453071f, 
    0.02906700f, 0.03196286f, -0.01114217f, 0.02207016f, -0.11582258f, 0.09571592f, -0.05968707f, 0.03197143f, 
    0.38347280f, -0.05618260f, 0.48710155f, 0.06454432f, 0.01934374f, -0.00854535f, 0.10266359f, -0.01381582f, 
    0.09704908f, 0.04088419f, -0.04126320f, -0.05197174f, -0.00993409f, -0.06975476f, 0.01336004f, 0.00341071f, 
    -0.00613713f, -0.02963737f, 0.03582832f, 0.03774887f, -0.04257840f, 0.01033453f, 0.04778214f, -0.06910073f, 
    -0.18501931f, 0.09836140f, 0.33850664f, 0.16509171f, -0.00915274f, -0.02395786f, 0.05591603f, 0.05061854f, 
    0.07768742f, -0.23001033f, 0.09026491f, -0.09233134f, -0.27377734f, 0.22565977f, -0.15809727f, -0.23697108f, 
    0.06209598f, -0.03658981f, 0.04342090f, -0.01225860f, -0.04597652f, -0.00000318f, 0.03416268f, 0.00509625f, 
    -0.24625337f, -0.22454566f, 0.28396189f, -0.20117688f, -0.09402926f, -0.00603873f, -0.08140457f, 0.07102622f, 
    0.01721791f, 0.01603264f, 0.00550958f, 0.00976918f, -0.20814011f, 0.18896838f, 0.06558427f, -0.04539012f, 
    -0.03871866f, 0.02868300f, 0.02911656f, -0.09530751f, 0.04908693f, 0.21876022f, 0.00102434f, 0.16368119f, 
    0.00863552f, -0.25005937f, 0.26252818f, -0.15521951f, 0.01262276f, -0.04421530f, 0.01179142f, 0.00803546f, 
    -0.02018856f, -0.01468702f, -0.07265728f, 0.02480493f, 0.07345529f, 0.01121618f, 0.19832468f, 0.14322282f, 
    -0.01772408f, -0.04817704f, 0.04241259f, 0.03483265f, -0.08177830f, 0.01713187f, 0.12872645f, -0.00975087f, 
    -0.13010730f, 0.25030476f, 0.40246883f, 0.21001206f, 0.00476599f, -0.06990238f, -0.09284461f, 0.01238179f, 
    0.05475078f, 0.00749477f, -0.00359893f, 0.03351019f, -0.39083642f, 0.19875562f, -0.06881902f, -0.35598594f, 
    -0.03266612f, -0.04862715f, 0.03189873f, 0.06614713f, -0.03200392f, -0.08243741f, 0.08611210f, -0.02948436f, 
    0.08909415f, 0.01730611f, -0.01310096f, 0.07503674f, 0.07833312f, 0.03759468f, -0.03461916f, 0.04477082f, 
    0.00908915f, -0.07893081f, 0.02674824f, -0.02792781f, -0.26665005f, 0.01279406f, 0.13550891f, -0.38760176f, 
    0.10825951f, -0.10762914f, -0.34886983f, 0.07415812f, 0.00141849f, 0.00146527f, 0.01363054f, 0.00190443f, 
    -0.81065667f, -0.13028325f, -0.08280309f, -0.13095069f, 0.09473664f, 0.01771900f, -0.16126096f, -0.26379919f, 
    0.03778862f, 0.01681098f, -0.06499225f, -0.01233926f, -0.62506747f, 0.15692790f, 0.13330513f, -0.23887807f, 
    -0.21713673f, 0.02744645f, 0.02502595f, -0.16032580f, -0.04392779f, -0.05882683f, -0.00805313f, -0.04146353f, 
    0.01104177f, -0.02873755f, -0.03700952f, 0.00410045f, -0.06079116f, 0.11336862f, 0.02880516f, -0.04265022f, 
    0.02979886f, -0.02165116f, -0.02392043f, -0.01233531f, 0.17109033f, -0.10493923f, -0.09458125f, 0.33433479f, 
    -0.01694858f, -0.05251881f, -0.15344714f, 0.14339562f, -0.04960788f, -0.08061638f, -0.10135506f, 0.02222366f, 
    -0.02895184f, -0.40816003f, 0.10979447f, -0.38256079f, 0.03780977f, -0.22971189f, -0.05020519f, -0.01629489f, 
    0.01546811f, -0.07528092f, 0.00991618f, 0.13810624f, -0.27790624f, 0.35059112f, 0.13062420f, 0.12471813f, 
    0.05368455f, 0.09631093f, -0.05385285f, 0.06761715f, -0.00793506f, 0.01680354f, 0.02049307f, -0.01796283f, 
    -0.24435383f, -0.19811296f, -0.21049353f, 0.01515334f, 0.03320975f, -0.04310763f, 0.07048036f, 0.11880463f, 
    0.04974286f, -0.02050452f, -0.01861831f, -0.00829412f, 0.04859529f, 0.00390903f, 0.08130322f, -0.07461125f, 
    0.07185234f, 0.11170737f, -0.05986517f, 0.19386236f, 0.08938196f, -0.01498450f, 0.01200964f, -0.05713997f, 
    0.16843875f, -0.10089501f, -0.07369904f, -0.04374324f, 0.06285330f, -0.13223405f, 0.05719244f, -0.02197024f, 
    0.10912063f, 0.08992389f, 0.00633846f, -0.09058014f, -0.40149784f, -0.12589741f, 0.11534310f, 0.06210721f, 
    -0.01028434f, -0.16778105f, 0.04844558f, 0.02429434f, -0.03581941f, 0.00350532f, -0.02492042f, 0.06261427f, 
    0.14127786f, -0.24344043f, 0.05645945f, -0.05185246f, 0.06083547f, -0.05655650f, 0.01337856f, -0.01886766f, 
    0.05839291f, -0.04628422f, -0.13760869f, -0.01186163f, -0.10101923f, -0.24644701f, 0.45804444f, 0.06661390f, 
    0.01030988f, -0.04479058f, 0.07377370f, 0.10653345f, 0.06773847f, -0.07382082f, 0.13500859f, -0.03544483f, 
    -0.11195606f, -0.18945411f, 0.20585001f, -0.25447401f, 0.01336779f, -0.03285642f, 0.03879118f, -0.12138195f, 
    0.03077414f, -0.03971031f, -0.00320186f, -0.00619767f, -0.03322048f, -0.07721203f, -0.06310725f, 0.05425118f, 
    -0.00079630f, -0.07037439f, -0.01757193f, 0.03915985f, 0.05556220f, 0.00967324f, -0.00637059f, 0.16273025f, 
    -0.22091317f, 0.43527576f, 0.03333066f, -0.06299718f, 0.03494196f, -0.05733672f, -0.10462593f, -0.09303626f, 
    0.02052098f, -0.01519013f, 0.01320190f, 0.07731160f, -0.17284785f, 0.05036723f, 0.02442603f, -0.04687925f, 
    0.01796190f, 0.03986306f, 0.03909161f, 0.07687822f, 0.05632037f, -0.01839386f, -0.00039442f, 0.05964693f, 
    0.02640695f, -0.07435703f, -0.10644489f, -0.07394978f, 0.02631071f, -0.04361285f, -0.03564142f, 0.01763103f, 
    -0.02117732f, 0.05600675f, 0.03994777f, -0.02781724f, -0.01967645f, -0.02619767f, 0.11014361f, 0.14466380f, 
    -0.01441797f, 0.00200352f, 0.00665976f, 0.08555520f, -0.00296174f, -0.18837440f, 0.02938147f, 0.08262764f, 
    -0.07567161f, -0.30268401f, 0.16962834f, -0.06981287f, 0.08289608f, -0.00388829f, -0.11894409f, -0.23905134f, 
    0.07812756f, -0.08631669f, 0.05191575f, -0.01684103f, -0.04634748f, -0.07798907f, -0.00028981f, 0.14536926f, 
    -0.01719055f, 0.07646522f, 0.01546588f, -0.04756225f, -0.04245007f, -0.02478755f, -0.09757610f, -0.05541233f, 
    -0.11586483f, 0.07574639f, -0.02899914f, -0.04597837f, -0.01760224f, -0.24273205f, -0.07251826f, 0.09200706f, 
    0.01946040f, 0.02149631f, -0.02893910f, -0.00611683f, 0.18549606f, 0.00477559f, 0.05247951f, 0.04566656f, 
    0.02968300f, -0.09463782f, -0.08950586f, 0.00682102f, 0.09918644f, 0.02386357f, 0.28665587f, 0.07183263f, 
    0.06055596f, -0.06967360f, 0.09278335f, 0.19317058f, 0.02700897f, -0.05220020f, -0.02274855f, -0.07511754f, 
    -0.02348756f, 0.06555613f, 0.00279912f, 0.08857595f, -0.31613219f, -0.25486609f, 0.44442868f, 0.19841214f, 
    -0.13827954f, 0.18412106f, 0.04128323f, 0.02938406f, 0.10113374f, -0.00582326f, -0.10635956f, 0.01042910f, 
    -0.09465434f, 0.00742822f, -0.06200052f, 0.07900824f, -0.15089230f, -0.00156359f, -0.14491460f, -0.09628879f, 
    0.13115016f, 0.11902624f, -0.00784235f, 0.01756800f, -0.08424407f, 0.08378009f, 0.00826557f, 0.35844502f, 
    -0.00309336f, -0.03102572f, 0.03289944f, -0.02010382f, 0.10563996f, -0.06814314f, 0.04836758f, 0.19114640f, 
    -0.19047767f, 0.20944910f, -0.08785232f, 0.00125183f, -0.03028995f, -0.08738103f, 0.14023349f, -0.05188797f, 
    -0.01019275f, 0.10738632f, -0.13520427f, 0.11202440f, -0.85423434f, -0.08359820f, -0.06934397f, 0.07300286f, 
    -0.23699413f, -0.02283292f, -0.12929855f, -0.08640417f, -0.08985337f, 0.00501293f, -0.04668758f, -0.07296286f, 
    -0.52704746f, -0.17820376f, -0.31519830f, -0.31336811f, 0.04704829f, 0.09280173f, -0.27933672f, -0.11400473f, 
    -0.04505816f, -0.08245545f, 0.09721714f, -0.18050346f, -0.11780122f, -0.07628692f, -0.20060186f, -0.14963149f, 
    0.10056344f, 0.04897547f, -0.05798625f, 0.04288467f, -0.03592825f, 0.08942589f, -0.12860292f, -0.04743757f, 
    0.09330653f, 0.12730141f, 0.01630846f, 0.21793136f, 0.10313344f, -0.28489032f, -0.21264456f, -0.16832075f, 
    0.01510629f, 0.14808317f, 0.28824475f, -0.17433850f, -0.21752550f, 0.15282810f, 0.18864754f, -0.04905251f, 
    -0.15599690f, 0.00492669f, -0.06553683f, 0.08404241f, -0.02892964f, -0.16966496f, 0.23254482f, -0.12839840f, 
    -0.30160782f, 0.13828838f, -0.04941752f, -0.25745672f, 0.15681912f, -0.05891905f, 0.18198515f, -0.01901369f, 
    -0.00818703f, 0.03286410f, 0.03098098f, -0.13251092f, -0.54537886f, 0.21120772f, -0.32695910f, -0.24039994f, 
    0.07283066f, 0.01573020f, 0.04452621f, -0.07442763f, -0.19543798f, -0.01382189f, -0.01327882f, -0.17181870f, 
    0.14460853f, 0.17477264f, 0.06165598f, 0.13292988f, 0.01856362f, 0.08241220f, -0.07058656f, -0.09343068f, 
    -0.01730120f, -0.16091818f, -0.02300907f, 0.01507280f, 0.26041362f, 0.34839723f, -0.01171416f, -0.27298582f, 
    0.15361263f, 0.04632065f, 0.02936057f, 0.03177406f, -0.24156992f, -0.07274207f, -0.05230017f, 0.09881414f, 
    -0.21413107f, -0.17944737f, -0.09794946f, 0.31597275f, 0.11584879f, 0.01849283f, -0.04543943f, 0.04025098f, 
    -0.05394925f, -0.02612670f, 0.01750657f, -0.01975643f, -0.07453816f, -0.16273549f, -0.09790258f, 0.19948934f, 
    -0.04421179f, 0.03040748f, -0.07156068f, 0.08917925f, -0.09478863f, -0.03194768f, 0.06853663f, -0.14190927f, 
    0.08365174f, -0.21200509f, -0.03850817f, 0.26893193f, 0.07116444f, 0.00140535f, -0.03267577f, -0.02649397f, 
    -0.04090494f, 0.20738952f, -0.18735363f, 0.03838319f, -0.75319910f, 0.33711186f, 0.03029737f, 0.14015269f, 
    -0.05089427f, -0.13607581f, 0.03872572f, -0.18956777f, 0.01435288f, 0.00044617f, -0.05029911f, 0.04628284f, 
    -0.10792823f, 0.09571664f, -0.17004278f, -0.11881762f, -0.00459625f, -0.01634813f, -0.07207184f, 0.02154630f, 
    -0.02815613f, 0.03303451f, 0.06904510f, 0.17819819f, -0.19215465f, 0.04803756f, -0.29847440f, -0.12731987f, 
    0.01330730f, 0.07477492f, -0.10073604f, -0.01843645f, -0.09325353f, -0.05228068f, 0.00790358f, -0.15313996f, 
    -0.06258085f, 0.40866008f, -0.19005114f, 0.09577870f, 0.12079908f, 0.07755681f, -0.00936454f, -0.05257967f, 
    -0.13123991f, -0.13903865f, 0.11416840f, 0.03574467f, 0.23601580f, 0.51752150f, 0.08429745f, 0.18182494f, 
    0.11561577f, 0.14728186f, -0.15404868f, 0.08532374f, -0.02582627f, 0.13408835f, 0.03526641f, 0.01218105f, 
    0.02270674f, -0.13113394f, -0.04151259f, 0.06718671f, -0.05143040f, -0.03949668f, 0.08162526f, -0.10527834f, 
    -0.01803682f, 0.04410443f, 0.07228514f, 0.04847221f, -0.32666475f, 0.35199967f, -0.21914737f, -0.38523233f, 
    0.18395156f, -0.05848759f, -0.17503959f, 0.10988524f, 0.00171903f, -0.14522007f, -0.08833941f, 0.01291092f, 
    0.17965598f, 0.04340994f, -0.10086465f, 0.34442323f, -0.00914516f, 0.02764462f, 0.07513855f, 0.07435036f, 
    -0.04608713f, 0.10359973f, 0.09744334f, -0.00358835f, -0.05362842f, -0.12505445f, -0.22555588f, 0.09855643f, 
    0.06178365f, 0.03861953f, 0.05428680f, 0.08494028f, -0.08284351f, 0.02765339f, -0.00522585f, -0.03009548f, 
    -1.05220056f, 0.54372162f, 0.11946032f, -0.24952376f, 0.19562951f, 0.15251137f, 0.06937575f, 0.19499983f, 
    -0.21438845f, -0.14220195f, 0.03983094f, -0.12539083f, -0.09047628f, 0.01189458f, 0.03305851f, 0.08942058f, 
    0.03123352f, -0.01906159f, -0.23877619f, 0.01390367f, -0.14421584f, -0.05699697f, 0.09900898f, -0.05058861f, 
    -0.32047415f, -0.10430995f, -0.11452690f, -0.36726314f, 0.15627389f, 0.17728482f, 0.04489866f, -0.16824710f, 
    -0.19104864f, 0.20998612f, 0.08157191f, -0.15954082f, 0.03177190f, -0.22432554f, -0.01860686f, 0.04790439f, 
    0.11521191f, 0.03209182f, -0.17125534f, -0.10378274f, -0.02668516f, 0.00307554f, 0.01762854f, -0.01586968f, 
    0.54133344f, -0.22802854f, 0.07517204f, 0.27025056f, 0.04974870f, -0.08191612f, 0.07914177f, -0.17153759f, 
    -0.02661473f, -0.05549884f, 0.11421395f, -0.03995927f, 0.19638899f, 0.09654272f, -0.34322616f, 0.19632113f, 
    -0.20461468f, -0.22492158f, -0.11365020f, 0.10549892f, -0.17273688f, 0.28650057f, 0.04305203f, -0.01706734f, 
    0.24093410f, 0.03864224f, -0.12086566f, 0.12758274f, 0.12435817f, 0.06332204f, 0.04399943f, -0.03817321f, 
    -0.06890206f, -0.03159554f, 0.12435330f, 0.03534974f, -0.02533937f, 0.33700174f, -0.14129901f, -0.11342905f, 
    0.00810444f, -0.05927522f, 0.06251172f, -0.02552396f, -0.29680958f, 0.06953862f, 0.05838390f, 0.17974925f, 
    -0.49362311f, -0.13206442f, 0.42286327f, -0.29563689f, -0.19208775f, -0.08052926f, -0.29585913f, -0.02278735f, 
    0.00695715f, 0.12476949f, 0.07782111f, 0.02373897f, -0.41356421f, -0.05005647f, -0.12020617f, 0.02559210f, 
    -0.02093983f, 0.11833659f, -0.23632473f, -0.02603533f, -0.01876885f, 0.15276422f, 0.10769958f, -0.03789689f, 
    0.93282306f, -0.03031539f, 0.17415082f, 0.21414769f, 0.00400572f, 0.19309913f, -0.14445758f, 0.09531844f, 
    -0.09292687f, -0.02971041f, 0.08195204f, 0.22442918f, 0.07361483f, -0.14963163f, -0.04245247f, -0.01350545f, 
    0.14267147f, -0.01252298f, 0.13797332f, -0.18962504f, -0.08605573f, -0.00227168f, 0.05293618f, 0.01142280f, 
    0.23211615f, -0.05419102f, -0.01089878f, 0.17991401f, 0.01627124f, -0.08361460f, -0.00011196f, 0.05876810f, 
    0.01236435f, 0.01723194f, -0.01843810f, 0.15299419f, 0.05114333f, 0.15096065f, -0.04004474f, 0.14887115f, 
    -0.02384199f, 0.10923259f, 0.17924941f, 0.03193321f, -0.07222535f, 0.09046901f, -0.01883842f, 0.08640227f, 
    0.17786425f, -0.01543405f, -0.14214161f, -0.11304341f, 0.13560027f, -0.03619485f, 0.05860822f, -0.12975995f, 
    0.06890696f, -0.16849631f, -0.11692610f, 0.04309425f, -0.21356587f, 0.07631779f, 0.18150733f, 0.36172551f, 
    -0.01026293f, -0.00800471f, -0.01746969f, 0.05676911f, 0.02170265f, 0.02574474f, 0.03481574f, -0.06229414f, 
    0.11544019f, -0.16346675f, 0.06609613f, 0.10884441f, 0.02670037f, -0.00201835f, 0.02125198f, 0.08370097f, 
    -0.00884305f, -0.03243659f, -0.00543153f, 0.06185538f, 0.11187536f, -0.07782920f, 0.07300628f, 0.23033658f, 
    -0.03480746f, -0.06260946f, 0.01561855f, -0.03088548f, -0.01940079f, 0.04870410f, -0.13344286f, 0.07290054f, 
    -0.02078393f, -0.16393210f, 0.01021783f, 0.12047311f, 0.06338761f, -0.05161996f, -0.17571409f, 0.02831690f, 
    -0.02566135f, 0.04292372f, -0.06004418f, -0.15511411f, 0.11424152f, 0.01061218f, -0.01131607f, -0.06837761f, 
    0.02444399f, -0.09696840f, -0.02852203f, 0.10325268f, -0.04987586f, 0.14060570f, -0.12311514f, 0.04618130f, 
    -0.49500650f, 0.05127783f, 0.17075513f, 0.22606041f, -0.20629062f, 0.07211784f, -0.27692968f, -0.02128423f, 
    -0.02446186f, -0.02551599f, 0.06830083f, -0.14968584f, -0.06081786f, -0.07951557f, 0.01639317f, 0.12904713f, 
    -0.00991275f, -0.05215513f, 0.02997789f, -0.02439386f, 0.07352150f, -0.01627851f, -0.02440123f, 0.07299241f, 
    -0.13907903f, 0.15718013f, -0.12317591f, 0.25362986f, 0.05681884f, -0.06445848f, -0.03739217f, -0.05796863f, 
    -0.01821853f, -0.07343031f, -0.06392603f, -0.00805224f, -0.26795208f, -0.00742444f, -0.22139737f, 0.10252735f, 
    -0.12564038f, -0.18437999f, -0.17971314f, -0.17774642f, -0.01427777f, -0.13029805f, -0.07865311f, -0.04122057f, 
    -0.13750620f, 0.87353820f, -0.55957073f, 0.06645389f, 0.21220852f, 0.02815352f, -0.15187459f, -0.12239936f, 
    -0.13273998f, -0.11846106f, -0.05526046f, -0.04844322f, 0.17817096f, -0.26654917f, 0.05763583f, 0.26244956f, 
    0.00311417f, -0.03417196f, -0.04347030f, -0.12411532f, 0.12640651f, -0.03386160f, 0.07409353f, 0.04319317f, 
    0.29471922f, 0.07907834f, 0.10029444f, -0.53141159f, -0.08621923f, -0.08547279f, -0.08917394f, -0.23179887f, 
    -0.13308161f, 0.01842972f, -0.04131760f, 0.01796439f, 0.02251283f, 0.10929701f, -0.39272407f, -0.14677925f, 
    0.10310704f, 0.01053459f, -0.00432610f, -0.04575919f, -0.20178150f, -0.05102536f, -0.03246503f, 0.06475084f, 
    0.09342239f, -0.16803579f, 0.25486690f, 0.00504764f, -0.20038261f, -0.09363043f, -0.05354117f, 0.16281836f, 
    -0.00513017f, 0.04420885f, -0.00059550f, 0.01647136f, 0.17265150f, 0.08414579f, -0.22735345f, -0.16020392f, 
    0.14559042f, 0.01639516f, 0.09524360f, -0.01797166f, -0.02702637f, 0.02243686f, -0.01006588f, 0.03634038f, 
    -0.62166512f, -0.23988134f, 0.11922265f, 0.27746707f, 0.02257380f, -0.12987415f, -0.00304147f, -0.02617900f, 
    0.04546589f, 0.01418348f, 0.05421118f, 0.04269138f, -0.21907860f, -0.16731182f, 0.07479161f, -0.03213144f, 
    -0.32990009f, -0.07018062f, -0.05376899f, -0.23061219f, 0.03172328f, 0.06217495f, -0.08683052f, 0.07576232f, 
    0.22345521f, -0.01029468f, 0.30370811f, -0.19030246f, -0.17715836f, 0.03833683f, -0.00746378f, 0.03154525f, 
    0.03888370f, 0.12095294f, 0.13247670f, 0.05399215f, 0.11217907f, -0.12114966f, -0.18382648f, -0.09444365f, 
    0.21897268f, 0.21094273f, 0.05132718f, 0.20248526f, -0.12635092f, 0.11170039f, -0.08948956f, -0.04903724f, 
    -0.06632152f, -0.15595573f, 0.13923220f, 0.07348346f, -0.16460358f, 0.18557385f, -0.09659360f, -0.07094963f, 
    0.01962714f, -0.08639479f, 0.02666655f, -0.11408545f, 0.14099048f, 0.17214742f, -0.07256077f, 0.00761481f, 
    0.07867260f, -0.11249462f, 0.05751308f, 0.00870054f, -0.13784216f, 0.16989791f, 0.03045308f, 0.13627815f, 
    0.01712720f, -0.29620305f, 0.21045208f, 0.34815109f, 0.07600030f, 0.17570432f, -0.12636448f, 0.03965480f, 
    0.03861085f, -0.07040840f, -0.00321144f, 0.01572741f, -0.04095155f, 0.02971816f, 0.12355693f, 0.14354748f, 
    0.08189658f, 0.11532956f, -0.07524501f, -0.05762739f, 0.04167665f, 0.01836508f, 0.08522961f, 0.10255171f, 
    0.01542210f, 0.11644444f, 0.12563887f, 0.21162672f, -0.01463392f, -0.04648989f, 0.08507056f, -0.08087192f, 
    0.03496162f, -0.05673990f, -0.03571660f, 0.09735208f, 0.10631436f, 0.10685287f, -0.04296596f, 0.17515790f, 
    0.18777522f, 0.07384831f, 0.05851971f, -0.01670318f, 0.04792377f, 0.06194677f, 0.22552466f, 0.01485248f, 
    0.18384162f, -0.03302464f, -0.03196773f, 0.06404815f, 0.03750532f, -0.05945271f, 0.02013682f, -0.03893323f, 
    0.09640662f, 0.14576705f, 0.29615903f, 0.35089681f, 0.00894832f, -0.05450575f, 0.40541798f, 0.12561235f, 
    -0.04391290f, -0.05913330f, -0.09637789f, 0.00882695f, -0.07881239f, -0.01888629f, 0.05913018f, -0.07165849f, 
    -0.05748262f, -0.18086945f, -0.05544429f, 0.05091201f, -0.02586499f, 0.14212091f, 0.04627230f, 0.10603663f, 
    -0.25614950f, -0.02145091f, -0.02893462f, -0.12159576f, -0.14263068f, 0.02334352f, -0.26790616f, -0.05259137f, 
    0.09793445f, 0.03129699f, -0.02493893f, -0.02115148f, 0.03472070f, 0.00378392f, -0.09796376f, 0.06829665f, 
    0.02646166f, 0.01081269f, -0.00217779f, -0.08377932f, 0.06605080f, 0.05360816f, 0.03652224f, -0.00463241f, 
    0.16947126f, -0.01637899f, -0.16362534f, 0.15194178f, 0.08361243f, 0.02435984f, 0.03767632f, 0.06472439f, 
    -0.07628796f, -0.10200256f, -0.14446977f, 0.04169062f, 0.03412958f, 0.09953679f, -0.00963426f, -0.00156556f, 
    -0.11231538f, -0.04766050f, 0.08412959f, -0.01395673f, -0.11612636f, 0.02816976f, -0.06125558f, 0.10530605f, 
    -0.15493231f, -0.01599921f, -0.12543459f, -0.25693861f, -0.08853587f, -0.06558460f, -0.18344326f, -0.09968606f, 
    -0.01806645f, -0.13277093f, -0.10566948f, -0.19287276f, 0.09974729f, 0.01751115f, -0.03643626f, -0.10208896f, 
    0.09220886f, -0.07507490f, -0.05187086f, -0.15889822f, 0.01220165f, 0.03450110f, 0.02496384f, 0.06123484f, 
    -0.14541520f, -0.01833635f, -0.11947566f, -0.18453678f, -0.10819463f, -0.13832261f, -0.17251067f, -0.05544093f, 
    -0.03830750f, -0.02600750f, -0.00333058f, 0.05582730f, -0.05549239f, 0.11863606f, -0.09093659f, 0.09248224f, 
    0.06817422f, 0.02372916f, 0.07128093f, 0.04403255f, -0.03406643f, -0.08152521f, -0.02485580f, 0.07762068f, 
    -0.17888267f, 0.03762399f, 0.01949225f, -0.02568118f, 0.21010885f, -0.09034657f, -0.07463906f, 0.02247675f, 
    0.03872546f, -0.02607846f, 0.03500744f, 0.01243581f, 0.01062370f, -0.19865477f, -0.06607257f, -0.16574292f, 
    -0.03006522f, 0.16295196f, 0.01291657f, 0.05747763f, -0.01657921f, -0.09473949f, -0.00816106f, -0.02308076f, 
    0.15518920f, -0.04118301f, -0.14549239f, 0.13079703f, 0.04813901f, 0.13638414f, 0.18357211f, 0.06503548f, 
    -0.10529426f, -0.02026524f, -0.05006046f, 0.05108610f, 0.04280296f, -0.00175909f, 0.01609694f, 0.09800703f, 
    0.14595181f, 0.26229832f, 0.16082878f, 0.12189807f, -0.12750512f, -0.07666182f, 0.12090255f, 0.06477256f, 
    0.09294239f, 0.00710088f, 0.03767551f, 0.00624315f, -0.07472780f, -0.38574708f, 0.06251113f, -0.17737028f, 
    0.06539988f, 0.04261062f, -0.04518768f, 0.02055762f, -0.01073973f, -0.16556583f, 0.00403138f, 0.15998849f, 
    0.07134238f, -0.42600349f, -0.06718585f, 0.08033140f, 0.09732097f, -0.20718887f, -0.01380873f, -0.12186787f, 
    0.04739461f, -0.08408063f, 0.05100050f, 0.01042136f, 0.12514345f, -0.05346934f, 0.18539919f, 0.26124877f, 
    -0.06114905f, -0.05284100f, -0.06527342f, -0.09383447f, -0.16035424f, 0.11133483f, -0.10601016f, 0.04454996f, 
    -0.46997198f, -0.13790105f, -0.07213681f, -0.10408305f, -0.01435871f, -0.03700862f, 0.03953446f, -0.06731782f, 
    0.06840943f, 0.00494550f, -0.09579772f, 0.12145220f, -0.43985379f, -0.42859113f, -0.11716001f, -0.28844088f, 
    0.06201175f, 0.02875441f, 0.03548609f, -0.01124965f, 0.09925956f, -0.05045214f, 0.01189458f, 0.07770705f, 
    -0.02134589f, -0.00450765f, 0.01935151f, 0.11341450f, -0.00681798f, 0.06452864f, -0.04421033f, 0.01260342f, 
    0.09196306f, 0.06935559f, 0.12851484f, 0.00270331f, -0.01676403f, -0.25455633f, 0.03930877f, 0.11594706f, 
    -0.34357184f, -0.06806006f, 0.05464122f, -0.09350791f, -0.07131071f, 0.02103398f, -0.02960281f, 0.00953786f, 
    -0.11618789f, 0.15186787f, 0.04415529f, -0.02591124f, 0.04790717f, -0.03679108f, -0.22589728f, -0.17537323f, 
    0.07298070f, -0.09229369f, -0.09511688f, 0.07511626f, 0.06950690f, 0.14726871f, 0.27420676f, 0.26431558f, 
    -0.09158636f, 0.03506901f, -0.00049683f, -0.08886111f, -0.01912095f, 0.04742894f, -0.05566682f, 0.00802142f, 
    0.08579120f, -0.26971558f, -0.13835362f, -0.16145647f, -0.04840810f, 0.04196926f, 0.11575939f, -0.00407935f, 
    -0.12669061f, 0.04420498f, -0.05298649f, 0.01813270f, 0.00962068f, -0.11035246f, 0.03813005f, -0.20410500f, 
    -0.13558541f, -0.15795173f, -0.03702525f, 0.02048028f, -0.00427580f, -0.02636326f, -0.11512906f, -0.30015662f, 
    0.08022167f, 0.08624652f, -0.05929637f, -0.04443774f, 0.06126296f, 0.02420806f, 0.02538904f, 0.01621488f, 
    0.08261280f, -0.10375968f, -0.17158893f, -0.00425915f, 0.25697482f, 0.36495703f, -0.02590748f, 0.04550265f, 
    -0.06471078f, 0.03344324f, 0.05888942f, 0.06570595f, 0.03688769f, -0.10345031f, -0.20580992f, 0.12296234f, 
    -0.15023074f, 0.11072632f, -0.09440155f, 0.06576534f, -0.08632810f, -0.14769094f, -0.03442146f, 0.01151238f, 
    -0.08430909f, -0.08433243f, 0.00280758f, 0.10466091f, -0.06270533f, 0.19527778f, 0.11469814f, -0.11856312f, 
    0.08092253f, 0.08615496f, -0.06031422f, 0.04339894f, 0.07443058f, -0.00607700f, 0.04024080f, 0.01449573f, 
    -0.03559336f, 0.14186424f, 0.11859407f, -0.04278288f, -0.03747540f, 0.00622833f, -0.02705360f, 0.01403320f, 
    0.11207932f, -0.09690127f, -0.25431153f, 0.05116569f, 0.09430581f, -0.51219374f, 0.21329880f, 0.05113414f, 
    0.00957609f, -0.02209475f, 0.06472787f, 0.08234335f, -0.07245880f, -0.02132379f, -0.06132537f, -0.13790494f, 
    0.11359017f, 0.10385922f, 0.03135169f, 0.15276958f, -0.00353404f, 0.02138488f, 0.14927065f, -0.02549998f, 
    0.08297989f, 0.01792783f, 0.05248430f, 0.00516285f, -0.21478662f, -0.14320531f, -0.01297489f, -0.04120053f, 
    0.02158977f, -0.02429502f, -0.05269595f, -0.06826162f, -0.01615380f, -0.05893113f, 0.10052696f, 0.10320599f, 
    0.09067597f, -0.28604192f, -0.18501081f, -0.19416536f, 0.09490830f, -0.00902845f, 0.06423965f, 0.05020260f, 
    0.05214660f, -0.03239175f, 0.21147212f, -0.15794517f, -0.01319326f, 0.03665842f, -0.15998389f, 0.03566089f, 
    -0.13104038f, 0.00625566f, -0.04337825f, 0.05872945f, -0.10099676f, 0.02043402f, -0.25260496f, 0.17442325f, 
    -0.21177851f, -0.11359442f, 0.01437269f, 0.07856149f, -0.13904536f, -0.08493537f, -0.09064350f, -0.18494390f, 
    -0.00998730f, 0.02328450f, 0.01670947f, 0.01258965f, 0.04650672f, 0.04460755f, 0.34576076f, -0.11543098f, 
    0.09318760f, -0.33258995f, 0.02996814f, 0.05653762f, -0.00270177f, -0.01618404f, 0.02048288f, -0.02812374f, 
    -0.10686877f, 0.13241830f, -0.14466934f, -0.03307652f, 0.06316170f, -0.04912224f, -0.06387024f, -0.07305516f, 
    0.01055622f, -0.12150735f, -0.06020879f, -0.02103422f, -0.01595048f, 0.20118703f, -0.27914983f, 0.13376983f, 
    0.17588277f, -0.04009197f, -0.08917169f, -0.08242755f, -0.07586297f, 0.04162414f, 0.01273592f, -0.15527038f, 
    0.01143452f, 0.29577821f, 0.17049211f, 0.26034108f, -0.06597889f, 0.13572320f, 0.01801578f, 0.02869460f, 
    -0.05140998f, -0.03084330f, -0.08982474f, 0.06261644f, -0.17724214f, -0.07879598f, 0.03113096f, 0.15850230f, 
    0.07583419f, -0.05296392f, 0.01577262f, -0.03048437f, -0.00114442f, 0.01445047f, 0.05631318f, -0.01937579f, 
    0.07553723f, -0.00027321f, 0.04303221f, -0.09233093f, -0.02986590f, -0.11247467f, 0.02091241f, -0.00736628f, 
    -0.05412428f, -0.13058221f, -0.05611772f, -0.15916696f, -0.06391124f, 0.13077527f, -0.09184816f, 0.12523097f, 
    0.00315481f, 0.09338631f, -0.01259153f, -0.25344077f, -0.04077164f, -0.28581125f, 0.03292172f, -0.09269781f, 
    0.10482912f, 0.14581981f, -0.38541210f, 0.04275918f, 0.13517123f, 0.19021454f, -0.07962982f, -0.05311626f, 
    0.01607719f, -0.05981858f, 0.00631157f, -0.13761832f, -0.09986562f, 0.00829440f, 0.11702605f, 0.17474774f, 
    -0.04599361f, -0.07670975f, -0.09939651f, -0.09822131f, -0.08043246f, -0.03712346f, -0.00547744f, -0.04516476f, 
    0.05053654f, 0.01127458f, 0.25768229f, 0.01267536f, -0.07435498f, -0.01174187f, -0.19772397f, -0.03583673f, 
    0.02308169f, -0.05857379f, -0.02712082f, -0.06058513f, -0.06465966f, 0.09668367f, -0.25338155f, -0.11735561f, 
    0.09599277f, -0.08397182f, 0.05119189f, -0.00112082f, -0.06481647f, 0.06898894f, -0.11531681f, -0.24454097f, 
    -0.22942699f, -0.39872399f, 0.17659828f, -0.33787361f, 0.04510991f, 0.18703356f, -0.12122073f, 0.02624554f, 
    -0.01934123f, -0.08698402f, -0.08905604f, -0.02600000f, 0.02309753f, -0.02670547f, 0.14113817f, 0.10250267f, 
    0.06606243f, -0.10733514f, -0.01497143f, 0.00969872f, 0.03373597f, -0.02319486f, 0.04653171f, 0.00327434f, 
    0.06199664f, -0.00395220f, -0.23441014f, 0.04789206f, -0.06570744f, 0.02079488f, -0.00673714f, -0.03092440f, 
    0.04939308f, -0.12294629f, -0.03632860f, -0.08338949f, -0.21176825f, -0.14677978f, 0.24708326f, 0.08722362f, 
    -0.25992903f, 0.09544465f, -0.23711745f, -0.09048046f, -0.15815496f, 0.10530296f, -0.04700320f, -0.01809535f, 
    0.14700335f, 0.31221217f, -0.22094613f, 0.15899213f, -0.01049150f, -0.08173125f, 0.01601523f, -0.02438707f, 
    0.02027143f, -0.07353075f, 0.03415792f, -0.03918428f, -0.03561027f, -0.16909951f, 0.15859030f, -0.01467674f, 
    -0.13192385f, -0.04994367f, -0.10187279f, 0.02083391f, 0.12308529f, 0.18634808f, 0.17996465f, 0.06902836f, 
    -0.10487700f, 0.05701316f, 0.11617801f, -0.00991328f, 0.02315514f, -0.04288947f, -0.00394090f, -0.17409851f, 
    -0.19180156f, 0.05185507f, -0.16700712f, -0.13918982f, 0.05243072f, -0.03230709f, -0.02251402f, 0.13144547f, 
    0.00304222f, -0.02091118f, 0.03403832f, 0.10040987f, 0.03080156f, 0.00767753f, 0.03765021f, 0.00815397f, 
    0.16216686f, 0.05659062f, -0.13927828f, 0.08599824f, 0.00726650f, -0.02637703f, -0.02204664f, -0.04025955f, 
    0.11099775f, -0.02814469f, -0.06148056f, 0.07038058f, 0.25580508f, 0.08587482f, 0.06498156f, -0.03968826f, 
    -0.06158545f, 0.04494160f, 0.01850653f, 0.11473839f, 0.23919614f, -0.06351814f, 0.03259411f, -0.00969106f, 
    0.02480186f, 0.22382718f, 0.02555225f, 0.26877671f, 0.08857087f, 0.10984648f, -0.01202119f, 0.24407892f, 
    0.04584548f, -0.05138531f, -0.08440990f, -0.07441738f, 0.17619358f, -0.13252112f, 0.14671460f, 0.01589199f, 
    -0.02586399f, -0.06962883f, -0.08902058f, -0.06551702f, 0.05128389f, -0.03012076f, -0.12863338f, -0.09093131f, 
    0.04367705f, -0.07396721f, 0.02370274f, 0.01574798f, 0.16953103f, 0.05043742f, 0.09016580f, 0.04967294f, 
    0.09668842f, -0.02776175f, 0.03567218f, 0.01409943f, -0.04931885f, 0.09674986f, -0.09660875f, 0.16586924f, 
    -0.00039007f, -0.02216052f, 0.00318254f, -0.14311530f, 0.08449639f, 0.22110784f, 0.00658476f, 0.11288860f, 
    -0.12915656f, -0.14578025f, -0.11164530f, -0.09375656f, -0.08073872f, 0.01872935f, -0.04700100f, -0.09642703f, 
    0.08914953f, -0.01763449f, -0.00637496f, -0.15746959f, 0.01159908f, 0.00489312f, -0.14640476f, -0.12146989f, 
    -0.00562436f, 0.02358242f, 0.02358539f, -0.11243318f, 0.02430691f, -0.08575840f, -0.02984344f, -0.10991392f, 
    0.01738990f, -0.16013975f, -0.12359039f, 0.09233321f, 0.04080863f, 0.05225545f, 0.01063153f, -0.01054556f, 
    -0.07849492f, -0.28357324f, -0.23833832f, -0.68217671f, 0.10245868f, 0.10129131f, 0.09406839f, -0.44614878f, 
    0.27253407f, -0.11615133f, 0.21159264f, -0.03133394f, -0.04397980f, 0.00774622f, 0.01039940f, 0.01522499f, 
    -0.03211156f, -0.06871365f, 0.05955603f, -0.16571225f, 0.08678921f, -0.03697526f, -0.13003632f, 0.14174347f, 
    0.03000122f, -0.08198186f, 0.16575521f, -0.23148125f, 0.29929203f, -0.22097632f, -0.40253004f, 0.02050040f, 
    0.05447555f, 0.01632517f, -0.02354642f, -0.00195933f, 0.10601496f, 0.05828597f, -0.12112426f, -0.01026063f, 
    -0.03695885f, -0.06918555f, -0.08796354f, -0.03113710f, 0.02104603f, -0.01536282f, -0.01593767f, 0.00230319f, 
    0.04560054f, 0.19268882f, 0.09858436f, -0.19469954f, 0.23082170f, -0.12545788f, 0.12312581f, 0.00593507f, 
    -0.01071734f, 0.05545392f, 0.08877511f, -0.07871479f, 0.15850531f, -0.01938102f, -0.05230425f, -0.02157007f, 
    0.18276925f, -0.28762081f, -0.08660760f, 0.09210109f, -0.03805675f, 0.03797100f, -0.03565729f, 0.10088578f, 
    0.05809328f, -0.06648161f, 0.02681679f, 0.26470375f, 0.05587848f, -0.01335025f, -0.19320878f, 0.05479537f, 
    0.08334348f, 0.02176038f, 0.02199869f, 0.09112412f, 0.04663644f, 0.04351742f, -0.12021215f, 0.13643019f, 
    0.03150889f, -0.29125744f, 0.05727895f, 0.15677471f, -0.04653870f, -0.00152050f, -0.03931654f, -0.04548213f, 
    0.05329593f, -0.03545299f, 0.00035508f, 0.26828867f, -0.16343416f, 0.07644925f, 0.20563956f, -0.18452421f, 
    0.01094242f, 0.01087273f, 0.01371264f, 0.03069594f, 0.16453138f, 0.14362203f, -0.14746358f, 0.06638264f, 
    -0.15774380f, -0.07434223f, -0.08580686f, -0.07541145f, 0.05395244f, -0.00346928f, -0.03516559f, 0.02520337f, 
    -0.01770235f, 0.07262935f, -0.08158333f, 0.12094869f, -0.40105814f, -0.21001595f, 0.11552764f, 0.07789305f, 
    0.03127329f, -0.04067657f, -0.08792934f, 0.03284880f, 0.29256681f, -0.05048940f, 0.25616956f, 0.13752115f, 
    -0.03415946f, -0.00753594f, -0.18044072f, -0.19539215f, -0.00699365f, 0.02963637f, 0.09994350f, 0.04679892f, 
    0.09086365f, -0.14186850f, 0.10971905f, -0.05444728f, 0.25290009f, 0.18011877f, 0.01691577f, -0.03756464f, 
    0.09603580f, 0.09916753f, -0.03976132f, -0.09828217f, 0.05900206f, 0.02243660f, -0.02375889f, -0.00599164f, 
    -0.14936550f, 0.01457071f, -0.08852999f, -0.26234978f, 0.21939148f, 0.15130156f, 0.12933408f, 0.08450386f, 
    -0.00514337f, -0.06062007f, -0.00843083f, 0.00941959f, -0.11865715f, -0.11208449f, -0.24806504f, -0.24029888f, 
    -0.02272569f, 0.05178795f, -0.08964311f, 0.07498630f, 0.12886676f, 0.00371931f, -0.11253966f, -0.28638965f, 
    0.04271798f, 0.10245346f, 0.35904661f, 0.30085993f, -0.01410934f, -0.21241617f, 0.00702517f, 0.09733277f, 
    0.02584214f, 0.11751032f, -0.17580755f, 0.08056616f, 0.31617883f, 0.11075452f, 0.07575900f, 0.19088921f, 
    -0.00229654f, 0.14123420f, 0.05930038f, -0.04261062f, 0.18612427f, 0.03278243f, 0.01415423f, 0.00663804f, 
    0.30737680f, 0.08024077f, -0.03247067f, -0.10217882f, 0.00225232f, -0.06830818f, 0.04638591f, -0.06255342f, 
    -0.06462748f, 0.10317200f, -0.31021535f, -0.22564408f, -0.15475646f, -0.00899863f, -0.27717739f, -0.08842839f, 
    0.00769274f, -0.04130474f, 0.03161240f, 0.09821829f, -0.05197894f, -0.07158929f, 0.01025946f, -0.18304132f, 
    0.07072104f, 0.03689732f, 0.10175867f, -0.11063482f, -0.00867586f, 0.00428956f, 0.11050151f, 0.12161328f, 
    -0.08953491f, -0.25230965f, -0.13207802f, -0.18568927f, 0.10232335f, -0.09845276f, 0.09299060f, 0.12867653f, 
    0.20286106f, 0.13643135f, 0.05260497f, -0.15360941f, 0.10223617f, 0.04328446f, -0.00396597f, 0.03084600f, 
    -0.15937471f, 0.14338893f, -0.12132800f, -0.01295249f, -0.00441367f, -0.00251420f, -0.02519120f, 0.11775012f, 
    -0.35258991f, -0.06995370f, -0.06553242f, -0.17625120f, 0.06286746f, 0.12631245f, 0.06778465f, -0.09167217f, 
    0.17489988f, 0.11062802f, -0.13199966f, 0.04257825f, -0.03446382f, -0.07463706f, 0.03113062f, 0.00809441f, 
    -0.00282101f, -0.42769578f, -0.39831257f, -0.21450397f, 0.00701668f, -0.04441565f, -0.04221448f, -0.03745125f, 
    0.03761762f, -0.03807451f, -0.23212007f, 0.01788498f, 0.10346372f, -0.14148964f, -0.22699417f, 0.30150166f, 
    0.12495729f, 0.05991296f, 0.05833337f, 0.03328983f, 0.08792343f, 0.03466863f, 0.08895326f, 0.26881051f, 
    0.03513356f, -0.00504951f, 0.02872040f, 0.06761648f, -0.03751247f, -0.07220034f, -0.05929993f, -0.06066451f, 
    0.12572746f, -0.05515229f, 0.09285437f, -0.01217849f, -0.31644219f, -0.48102570f, 0.01978003f, -0.08975129f, 
    -0.08423963f, 0.01904002f, 0.00402902f, -0.03778231f, -0.01788268f, 0.07384288f, 0.14464535f, 0.00282974f, 
    -0.57371366f, 0.21356657f, -0.30351150f, -0.53205806f, 0.01662955f, 0.02193281f, 0.10775231f, 0.15359642f, 
    0.13518977f, -0.17265029f, -0.13737212f, -0.02783279f, -0.01657007f, -0.16711920f, -0.04597919f, -0.01411587f, 
    -0.09902747f, 0.11796408f, 0.02613696f, -0.06375132f, 0.10064436f, -0.30302805f, 0.17603804f, 0.09887968f, 
    -0.28552550f, -0.21186882f, 0.04150327f, -0.28984743f, 0.01828602f, -0.02901659f, -0.00836141f, -0.11692380f, 
    0.00480456f, 0.13940881f, 0.18245380f, -0.13443670f, 0.02709658f, 0.15230499f, 0.04794323f, 0.07366376f, 
    -0.03915205f, 0.01299498f, -0.09753422f, -0.01944989f, 0.10938659f, -0.14329860f, 0.12093755f, 0.08675376f, 
    -0.32653645f, -0.07982192f, -0.21474656f, 0.08661291f, 0.12700531f, 0.02734247f, -0.08836996f, 0.00982426f, 
    -0.00373373f, -0.13023238f, -0.05781446f, 0.03608200f, 0.35174915f, 0.07232346f, -0.20711890f, -0.14908199f, 
    -0.03353403f, 0.03169363f, 0.08534138f, 0.09968778f, 0.18498510f, -0.20696126f, -0.06771385f, -0.00753147f, 
    -0.20231833f, 0.02239533f, -0.46620062f, 0.11123912f, 0.10321081f, 0.00998522f, -0.05813850f, -0.04413633f, 
    -0.02406782f, -0.15369183f, 0.11421171f, 0.07646162f, -0.42681515f, -0.22526926f, 0.18295684f, -0.04121488f, 
    0.04493240f, 0.00768198f, 0.07033157f, 0.10446780f, 0.07540268f, 0.03955401f, 0.10626999f, -0.09292603f, 
    -0.09565615f, 0.19018334f, -0.06610900f, -0.10970809f, 0.11472590f, -0.04560935f, 0.17859842f, 0.07369852f, 
    -0.01634824f, -0.08319883f, 0.11951546f, -0.03118194f, 0.44014078f, -0.47447705f, 0.11980771f, -0.25609207f, 
    -0.16573761f, 0.18717352f, -0.04279692f, 0.05936625f, 0.01282080f, 0.02340752f, 0.07069379f, 0.01838108f, 
    -0.05127433f, -0.19259559f, 0.10413410f, 0.10594290f, -0.03461672f, 0.08149301f, 0.06054129f, 0.01423092f, 
    0.13558893f, 0.21085329f, 0.03139182f, -0.06072279f, -0.03846539f, 0.17083600f, -0.30959982f, -0.16902578f, 
    -0.02619002f, 0.12799343f, -0.04435946f, -0.06389264f, -0.00417844f, -0.00265561f, -0.00220768f, -0.02333979f, 
    0.17341325f, -0.12675892f, 0.18452455f, 0.25702533f, 0.16079293f, -0.05619009f, -0.04006455f, -0.00506386f, 
    0.01134629f, 0.02988507f, -0.05421869f, 0.03118250f, 0.09343240f, 0.07360409f, -0.06236148f, -0.01650956f, 
    0.01308820f, 0.05001323f, -0.02528425f, 0.02911664f, 0.05072675f, -0.02025534f, 0.08349335f, 0.02194258f, 
    0.05176609f, -0.04186970f, -0.05907764f, 0.02122199f, 0.09122168f, 0.04980847f, 0.08508322f, -0.01230602f, 
    0.01847526f, 0.01931504f, 0.16061608f, 0.08358241f, 0.03214011f, -0.15224393f, 0.41154504f, -0.14157179f, 
    -0.08912968f, -0.06036781f, 0.11409305f, -0.05175903f, 0.07200218f, 0.04065223f, 0.04034687f, 0.04843160f, 
    0.08659431f, -0.00276784f, -0.64036465f, -0.03631461f, 0.08645280f, 0.14411822f, 0.13394791f, 0.03228632f, 
    0.13037038f, 0.01950935f, 0.07143017f, -0.00434924f, 0.01990544f, -0.16326396f, 0.06176774f, 0.08668631f, 
    -0.08758258f, -0.01373230f, 0.14012830f, -0.12880769f, -0.00901595f, -0.01314969f, 0.17594080f, 0.20893964f, 
    0.17857768f, 0.20862280f, 0.22474974f, -0.08348823f, 0.13219270f, 0.13902216f, 0.11805449f, 0.20236154f, 
    0.00667104f, 0.07631804f, 0.02211063f, 0.08916175f, -0.01627200f, -0.11154609f, 0.15466081f, 0.21751495f, 
    -0.04465570f, -0.17269281f, -0.04056912f, 0.08354407f, 0.00947829f, 0.03205645f, 0.04613478f, 0.14147371f, 
    -0.04307566f, 0.41108629f, -0.26180980f, -0.23252559f, -0.12406366f, -0.06149961f, -0.09839860f, 0.00462199f, 
    -0.11921970f, 0.03658459f, -0.17697971f, 0.02794932f, -0.33510596f, 0.06289598f, -0.02577611f, -0.20900024f, 
    0.04232354f, 0.06294817f, 0.19160056f, -0.01631136f, 0.04333163f, -0.00673217f, 0.02137622f, 0.06256785f, 
    -0.19188961f, 0.12017393f, -0.07192787f, 0.14535703f, 0.11590760f, 0.04384716f, -0.09282090f, 0.13811396f, 
    -0.10440752f, -0.04098504f, 0.18851970f, 0.08259844f, -0.45519742f, 0.16291000f, 0.16664892f, -0.16416888f, 
    0.02775380f, -0.05697231f, 0.11342178f, -0.01340680f, -0.04876643f, 0.03833640f, 0.10204829f, -0.05045762f, 
    -0.06493516f, 0.07290131f, -0.32787910f, 0.10362131f, 0.12050650f, 0.12401357f, -0.12207773f, 0.20137244f, 
    -0.01368936f, 0.00106849f, 0.13323796f, -0.07455749f, -0.31650913f, 0.08840407f, 0.09020631f, -0.00755839f, 
    -0.05954569f, -0.08772488f, 0.03532916f, -0.08118267f, -0.09747083f, -0.35088995f, -0.17621072f, -0.16997193f, 
    -0.03039835f, 0.04660301f, -0.37550426f, -0.09384576f, -0.11102296f, 0.09824540f, -0.14589605f, 0.08693583f, 
    0.04168690f, -0.31598511f, 0.06774115f, -0.13840750f, 0.07663146f, -0.17299193f, -0.15094732f, 0.08751491f, 
    0.11415569f, 0.05980217f, -0.14891918f, 0.16546319f, 0.02366862f, 0.00748992f, -0.01694876f, -0.01145587f, 
    -0.17708760f, 0.01135842f, -0.17652243f, 0.06643902f, 0.02259617f, 0.03248974f, -0.03071141f, -0.03269445f, 
    0.08640844f, -0.26694298f, -0.08178154f, -0.15691385f, -0.25268704f, -0.37415826f, 0.03426502f, -0.07461677f, 
    0.05696787f, -0.03372362f, -0.02492303f, -0.05016173f, 0.01987218f, -0.05582572f, 0.11085805f, 0.12079925f, 
    0.00622030f, 0.14269519f, -0.22271614f, -0.02597139f, 0.05157207f, 0.13324520f, -0.00546809f, -0.07788350f, 
    -0.00381061f, 0.03623940f, 0.07525185f, 0.05922432f, 0.00713988f, -0.09451141f, -0.08904745f, -0.08550566f, 
    -0.11465753f, 0.10308070f, 0.06096102f, -0.00741360f, 0.15555182f, 0.02591144f, 0.10192308f, 0.08579015f, 
    0.02913709f, -0.10469316f, -0.10164471f, -0.09063619f, -0.17507544f, 0.10313717f, 0.16316515f, -0.08805227f, 
    -0.00576529f, 0.03302061f, -0.05552978f, -0.06453601f, -0.03275542f, -0.01478716f, 0.19440375f, -0.06562900f, 
    0.02932113f, 0.02771248f, -0.02025339f, -0.06207910f, -0.04992231f, -0.24485748f, -0.08542130f, -0.06179713f, 
    -0.27524072f, -0.24720854f, 0.06484857f, 0.08168837f, -0.01666629f, 0.05999018f, -0.14453048f, 0.02527712f, 
    -0.04159125f, 0.05538830f, 0.09827897f, 0.05756379f, 0.09583494f, 0.00758767f, -0.01035338f, -0.05924620f, 
    0.06771235f, 0.02976228f, 0.07147221f, -0.00771047f, 0.06164759f, -0.16181286f, -0.04732981f, 0.10486084f, 
    0.16488390f, -0.00658809f, 0.02127584f, 0.00896798f, 0.00925733f, 0.02033533f, 0.01100863f, 0.07304668f, 
    0.07706418f, 0.22655444f, 0.07944144f, 0.00093758f, -0.55485874f, -0.46784645f, 0.18091781f, 0.30489570f, 
    0.14503504f, -0.01552615f, -0.12710293f, -0.28211391f, -0.06077183f, -0.02966796f, 0.04500807f, -0.02038635f, 
    -0.05171125f, -0.00892142f, 0.11377168f, 0.29785126f, 0.06644502f, 0.02360710f, 0.06816489f, -0.03629432f, 
    -0.04860409f, 0.05326965f, 0.26350403f, 0.09623168f, 0.41615236f, 0.03823599f, -0.09822766f, 0.14988373f, 
    0.00159103f, -0.03900560f, 0.05917590f, 0.05252591f, -0.02137855f, -0.02582646f, -0.03641242f, -0.11526983f, 
    -0.02308826f, 0.03148926f, -0.00441470f, 0.01154635f, 0.03717323f, -0.00035117f, -0.01602525f, 0.02962093f, 
    -0.01943297f, 0.02625423f, -0.06257210f, -0.08599070f, -0.27059743f, 0.12898685f, 0.08631206f, 0.01652298f, 
    -0.29362613f, -0.20925301f, -0.22242354f, -0.08419450f, -0.08049670f, -0.06612090f, -0.04969440f, 0.01233635f, 
    -0.10300916f, 0.04166359f, -0.00712246f, 0.01794917f, -0.10953362f, -0.16737911f, 0.06404240f, 0.09096289f, 
    0.04646805f, 0.06338043f, -0.17809983f, -0.06124958f, 0.32924524f, -0.05827275f, -0.17535834f, 0.02639953f, 
    0.02425991f, -0.00234987f, 0.18003848f, 0.04476823f, -0.01953245f, -0.04232274f, -0.06959639f, -0.00519616f, 
    -0.05970006f, 0.01842926f, -0.03391869f, 0.14795439f, -0.02458898f, -0.04846622f, -0.04782641f, 0.07044137f, 
    -0.07601569f, -0.02675789f, -0.05065853f, 0.00406068f, 0.07234599f, 0.11889410f, 0.13869637f, -0.04556314f, 
    0.05357005f, -0.00133384f, 0.03058380f, 0.08115491f, 0.10925908f, 0.07699756f, 0.18921743f, -0.01645714f, 
    -0.08960767f, 0.10800666f, 0.08498870f, 0.02137337f, -0.05085246f, -0.18500143f, 0.02032303f, -0.00180680f, 
    -0.02693199f, -0.01857737f, 0.00239993f, 0.02895389f, -0.06937654f, -0.10081057f, 0.18082769f, -0.13682920f, 
    -0.05724828f, -0.04128768f, 0.04383824f, -0.00004611f, 0.08186682f, 0.30565542f, 0.12437556f, 0.15305234f, 
    0.25098857f, 0.08794772f, 0.13795841f, 0.14814749f, 0.02349945f, -0.01243806f, 0.07888874f, -0.04628085f, 
    0.01699278f, 0.03021495f, 0.00804400f, 0.05965122f, -0.38724169f, -0.66256350f, -0.43992308f, -0.51167625f, 
    -0.12690735f, -0.23398311f, -0.08639324f, -0.42704606f, -0.04020550f, -0.03006456f, -0.01914117f, 0.05730542f, 
    -0.65033376f, -0.37628785f, -0.36273548f, -0.33696753f, -0.05742236f, -0.28275254f, -0.04698818f, -0.16094944f, 
    -0.00771436f, 0.00865924f, -0.05154308f, -0.00534795f, 0.01083688f, 0.29521397f, -0.08917753f, -0.03337526f, 
    0.05833751f, 0.01550032f, 0.04468334f, 0.03658001f, 0.10400490f, 0.04610786f, 0.10150997f, 0.05569883f, 
    -0.06478842f, -0.19538510f, -0.06674147f, 0.23137188f, 0.04448830f, 0.17481506f, -0.00406408f, -0.02485229f, 
    0.03558448f, -0.08455557f, 0.09713608f, -0.22445893f, -0.52867556f, -0.31209287f, 0.64643043f, -0.07815991f, 
    -0.11157849f, 0.03516654f, -0.21650715f, -0.24031162f, -0.07218142f, -0.03993824f, -0.07982871f, 0.05250199f, 
    -0.07743064f, -0.04380867f, 0.01816702f, 0.02701466f, 0.05655305f, 0.07471322f, -0.00593926f, -0.12156848f, 
    -0.06458548f, 0.04036555f, 0.03056950f, 0.10084625f, -0.32154918f, -0.07159832f, 0.00498968f, -0.06409020f, 
    0.07316808f, -0.00142324f, -0.07622933f, -0.06408900f, -0.03341504f, 0.05142604f, -0.01901016f, -0.07697830f, 
    -0.14394669f, -0.29262227f, -0.28517187f, -0.16180031f, -0.14128532f, 0.08193892f, 0.06869582f, 0.19543061f, 
    -0.05084432f, 0.06679629f, 0.08961427f, -0.10809863f, -0.08968515f, -0.10992450f, -0.11735088f, 0.29794222f, 
    -0.15475552f, 0.00852906f, -0.09503798f, -0.14271891f, -0.05000647f, 0.00675175f, -0.04058646f, -0.06876413f, 
    0.36051014f, 0.02692006f, 0.09773612f, 0.06182181f, -0.00868545f, 0.04738077f, -0.04225481f, -0.02897170f, 
    0.09553687f, 0.19058272f, -0.08360299f, 0.06798699f, -0.44140133f, -0.57191652f, -0.44714293f, 0.00187620f, 
    -0.32022631f, -0.01484721f, 0.13883595f, -0.18428653f, 0.05776843f, 0.01231129f, 0.01157690f, -0.00978367f, 
    -0.08673447f, 0.14590798f, 0.14130341f, 0.03209551f, -0.04959102f, 0.02912346f, -0.05405628f, -0.05863997f, 
    0.03416496f, 0.04373949f, 0.07254980f, 0.21737573f, 0.32074624f, 0.08093674f, -0.21010140f, -0.16536787f, 
    0.03781695f, -0.14606902f, 0.17291412f, -0.03813107f, -0.01075814f, 0.09979288f, 0.09880728f, -0.03361756f, 
    0.01561732f, -0.10801164f, 0.03978899f, -0.10090442f, 0.02919248f, 0.05332219f, -0.09585697f, 0.04518812f, 
    -0.10367230f, -0.00540322f, -0.16597322f, -0.20794933f, -0.10005724f, 0.23608421f, 0.39253628f, 0.45444223f, 
    -0.07370318f, 0.00699793f, -0.12391764f, -0.02173449f, -0.04345237f, -0.05956884f, -0.00624176f, 0.17123443f, 
    0.00184708f, -0.18450557f, 0.24440846f, 0.22138463f, -0.01845440f, -0.02976546f, 0.00877209f, 0.08747059f, 
    -0.08131597f, 0.09440514f, 0.06682076f, 0.08877575f, -0.17451404f, -0.05955077f, -0.10428583f, 0.10137238f, 
    -0.04172761f, 0.05328276f, 0.03674648f, 0.05296748f, -0.01745552f, 0.05104708f, -0.02856481f, 0.01826898f, 
    -0.16817074f, 0.24077372f, 0.30720511f, 0.07188480f, -0.02829686f, -0.03373026f, -0.04788077f, -0.03317364f, 
    -0.03879867f, 0.14611062f, -0.12887077f, 0.02382710f, -0.14860402f, -0.07984293f, -0.04082870f, 0.02496209f, 
    0.09240917f, 0.04514138f, -0.11724428f, -0.02283175f, -0.02025978f, 0.00206767f, -0.03322443f, 0.07775142f, 
    0.01642025f, -0.26521283f, -0.26811430f, -0.15895991f, 0.04076683f, 0.05038672f, 0.09556530f, 0.01451258f, 
    -0.05249815f, -0.05384126f, -0.04987222f, -0.03886709f, 0.25951567f, 0.14385679f, 0.02487322f, -0.12257262f, 
    0.01778185f, -0.02944699f, 0.00656619f, 0.05936350f, 0.08410604f, 0.09392614f, 0.14506441f, 0.21361829f, 
    0.07424407f, -0.03737807f, 0.08653438f, -0.34571809f, -0.08214463f, 0.07718121f, -0.06845584f, 0.04468756f, 
    -0.00125060f, 0.03687067f, 0.04600998f, -0.07618935f, -0.33102125f, 0.12787259f, 0.08394912f, 0.15034422f, 
    0.00881399f, 0.07838266f, -0.01307250f, 0.03106397f, 0.05055757f, 0.02797365f, 0.10178052f, 0.06479447f, 
    -0.40999472f, -0.23603098f, -0.00764773f, 0.02696159f, -0.13006942f, 0.08709275f, 0.03808517f, -0.06862816f, 
    0.04131514f, 0.04611718f, 0.04045829f, -0.01673168f, -0.25153795f, -0.46800444f, -0.24553291f, 0.00677065f, 
    0.07959246f, 0.10321396f, -0.16525900f, -0.04985085f, 0.01816057f, 0.07250109f, -0.11579414f, 0.03254287f, 
    -0.01745321f, -0.07172382f, -0.02858848f, 0.15236394f, -0.11387130f, -0.06059212f, -0.08943898f, 0.09448031f, 
    -0.03403715f, -0.00314315f, -0.08370303f, 0.04546760f, 0.45200366f, 0.01841892f, 0.17293982f, -0.43498504f, 
    0.18574429f, -0.25166425f, 0.18319499f, -0.16477245f, 0.03411175f, 0.05189418f, -0.11553027f, -0.08200780f, 
    -0.46344465f, -1.05216265f, -0.65928233f, -0.21944445f, 0.02272035f, 0.04367346f, 0.16305782f, -0.12418666f, 
    -0.03124258f, -0.04797770f, 0.07296470f, 0.01691319f, -0.41270351f, -0.68089563f, -0.41813159f, -0.13270718f, 
    -0.15613627f, -0.19841070f, -0.07844843f, -0.04897973f, -0.01955968f, -0.06973729f, 0.06178443f, -0.13031417f, 
    -0.08924336f, 0.00130116f, -0.03151568f, -0.11711618f, -0.08918606f, -0.07598514f, 0.02123815f, 0.03093877f, 
    -0.00027509f, -0.01056425f, -0.02597880f, 0.00289117f, -0.01117767f, -0.72271603f, -0.41124007f, -0.01370612f, 
    -0.08508261f, -0.09900729f, -0.07186543f, 0.09252539f, 0.03063350f, 0.08135929f, -0.00220429f, -0.03591146f, 
    0.27031511f, 0.12181893f, 0.04340585f, -0.24526978f, 0.11161933f, -0.05761420f, 0.03306469f, -0.09252045f, 
    -0.01586238f, -0.04229813f, -0.05458926f, -0.13874356f, -0.42223990f, -0.34740365f, 0.38211715f, 0.44550189f, 
    0.01307539f, -0.13607706f, 0.09321978f, -0.09577444f, -0.08915988f, -0.02877222f, 0.07330633f, -0.09088464f, 
    -0.45409867f, -0.51384598f, -0.16412674f, 0.38696933f, -0.09260768f, -0.00196892f, -0.06783796f, -0.23305766f, 
    0.01391256f, -0.01718328f, -0.02097842f, 0.00062691f, 0.15889935f, -0.18128751f, -0.02456429f, 0.13855520f, 
    0.01784805f, 0.03251887f, 0.16560097f, -0.00678909f, -0.02436600f, 0.04668968f, -0.01092999f, 0.00750130f, 
    -0.27607429f, -0.03369875f, 0.07031434f, 0.26396236f, 0.16040246f, -0.02816475f, -0.05865357f, 0.04490994f, 
    0.07685687f, 0.00775867f, 0.11039183f, -0.03785594f, -0.35210115f, -0.76073050f, -0.18465061f, -0.17936467f, 
    -0.08311344f, -0.29875022f, -0.31425482f, -0.13543825f, -0.05023574f, 0.01228861f, 0.00170056f, -0.15859561f, 
    0.07832472f, -0.04517125f, 0.10183764f, -0.15179260f, -0.14132033f, 0.00500351f, -0.03147956f, 0.14563695f, 
    -0.11184860f, 0.19902535f, -0.02938912f, 0.06965692f, 0.01473556f, -0.22084190f, 0.46927038f, 0.04207616f, 
    -0.04674761f, -0.02661216f, 0.09441403f, 0.25664914f, 0.02382257f, 0.18974718f, 0.03135799f, -0.04618712f, 
    -0.12118848f, -0.35351059f, 0.30009112f, -0.38920781f, -0.08078106f, 0.08118818f, 0.11927513f, -0.15480977f, 
    0.00015537f, 0.06139226f, 0.04143880f, 0.04231148f, 0.02859880f, -0.09568536f, 0.05821111f, -0.07410807f, 
    0.02036659f, -0.04336887f, 0.13090573f, 0.08001813f, 0.03079356f, 0.09418041f, 0.10781684f, -0.11063476f, 
    0.36761153f, 0.25199717f, 0.01385179f, 0.02066737f, 0.07956244f, -0.18432999f, 0.09845939f, 0.00868381f, 
    -0.03528035f, 0.09407103f, -0.19879201f, 0.01962638f, 0.12673616f, -0.17967118f, -0.12335370f, 0.04931867f, 
    0.02945643f, 0.10790985f, 0.12910716f, -0.07607143f, -0.00729280f, 0.03885400f, 0.00887153f, 0.01938923f, 
    0.01632889f, 0.05584905f, 0.00427133f, -0.11639847f, 0.00356508f, -0.00955523f, 0.02925241f, 0.02680331f, 
    -0.10878261f, 0.16164361f, 0.10746736f, -0.06664216f, -0.16541806f, 0.15400581f, 0.22998926f, 0.06735653f, 
    0.02252748f, -0.06663924f, -0.01864895f, -0.01050652f, -0.08169197f, 0.08551383f, -0.02718654f, 0.12096463f, 
    0.20712326f, -0.12717888f, -0.39490566f, -0.22015865f, -0.08870964f, 0.04254148f, 0.16475129f, -0.02519945f, 
    0.04827643f, -0.03537318f, -0.11724629f, -0.01944253f, -0.26948142f, 0.14929105f, 0.13948472f, -0.13395788f, 
    -0.15226898f, -0.28730601f, -0.05253385f, 0.07570557f, -0.09493828f, 0.04270082f, -0.06051407f, -0.00167975f, 
    -0.10829101f, -0.11529443f, -0.01598770f, 0.19374245f, 0.07034390f, 0.03129454f, 0.09821931f, -0.14518118f, 
    -0.03398633f, -0.07332509f, -0.03833247f, 0.04751268f, -0.00302154f, -0.12260722f, 0.23682955f, -0.24753287f, 
    0.04435280f, 0.07103511f, -0.05502862f, 0.03547764f, 0.22877650f, 0.16872980f, 0.02198186f, 0.00351374f, 
    0.23387398f, -0.44141087f, -0.36605975f, -0.06908475f, -0.06550180f, -0.10160130f, -0.03385348f, 0.11361673f, 
    0.13827996f, 0.15478416f, 0.04728714f, -0.03393341f, 0.03185070f, 0.06546602f, -0.06165027f, -0.01501841f, 
    0.02793905f, -0.03620427f, 0.03664173f, 0.08234712f, -0.01705226f, 0.03119221f, 0.14751278f, -0.04925294f, 
    0.11585495f, -0.03936824f, 0.07445565f, 0.02794343f, -0.00130815f, -0.04473187f, 0.01445081f, 0.02671798f, 
    0.21167415f, 0.02758787f, 0.04585385f, 0.06900585f, -0.36851871f, 0.10147731f, 0.23622064f, -0.07029594f, 
    0.03666117f, 0.08436801f, 0.12732965f, -0.02621934f, -0.01096875f, 0.01107483f, 0.10752819f, -0.06650729f, 
    -0.09168100f, 0.23074038f, 0.24502605f, -0.01399857f, -0.01296930f, 0.03672158f, 0.01008384f, 0.05419462f, 
    -0.24782135f, 0.03701983f, 0.00211504f, -0.13968325f, -0.16378987f, -0.02958610f, 0.09898160f, -0.05677216f, 
    -0.01875007f, 0.05561391f, -0.06533177f, -0.00588716f, 0.02242278f, -0.01348542f, 0.09399781f, -0.00133169f, 
    0.04675291f, -0.01047943f, 0.06367052f, -0.10218950f, -0.02716270f, -0.02623138f, 0.00428693f, -0.06239777f, 
    0.10632677f, -0.19188718f, -0.00697402f, -0.11661157f, 0.27681559f, -0.10307350f, -0.00595527f, -0.01311561f, 
    -0.03564200f, 0.04115517f, -0.09423597f, -0.06549317f, -0.01868254f, 0.05520205f, 0.01364125f, -0.00471748f, 
    0.06252879f, -0.07006661f, -0.05244413f, -0.08580942f, -0.01885678f, 0.06090276f, 0.07997672f, -0.03706213f, 
    0.01143794f, 0.03129014f, -0.00027056f, -0.06010408f, -0.12143034f, 0.12940374f, -0.17964800f, -0.06897222f, 
    -0.10991470f, -0.03061044f, -0.04208039f, -0.08998187f, -0.09972414f, 0.09474178f, 0.01794820f, 0.05737447f, 
    0.02895037f, 0.00316913f, -0.08987592f, -0.09525116f, 0.01392281f, 0.00429200f, 0.01448039f, -0.07743269f, 
    -0.04963116f, -0.01504939f, 0.01588701f, -0.14934561f, 0.01531764f, -0.06361808f, 0.01835122f, -0.01089411f, 
    -0.00128871f, -0.02337273f, 0.03452278f, -0.04480464f, 0.03827254f, 0.14142814f, 0.01883329f, -0.07710636f, 
    0.16090553f, -0.01574901f, 0.02083052f, -0.03369858f, -0.07502392f, -0.00390801f, 0.00259883f, -0.06241420f, 
    0.04143329f, 0.08651336f, -0.06416205f, 0.03664123f, 0.31631872f, -0.03054349f, -0.14649697f, -0.21372971f, 
    -0.01000194f, 0.00211813f, 0.01882216f, -0.07617636f, 0.01069351f, -0.01329994f, 0.02406698f, -0.14578857f, 
    -0.11896861f, -0.20511642f, 0.08677538f, -0.08233286f, -0.08185503f, 0.03269396f, 0.01598610f, 0.01617858f, 
    0.16376635f, -0.07056171f, -0.09308240f, -0.02922161f, -0.41620934f, 0.24019593f, -0.03922217f, 0.28245559f, 
    0.06776236f, -0.10750656f, -0.03826921f, 0.03859912f, -0.04196618f, -0.02283364f, -0.14695519f, -0.03929454f, 
    -0.19858150f, -0.27751070f, -0.12278823f, -0.02977419f, 0.01368642f, 0.03219207f, 0.08176330f, 0.04915842f, 
    0.00117870f, 0.09619986f, 0.02508353f, 0.04940223f, -0.02618268f, -0.08228859f, 0.27577397f, -0.03399007f, 
    0.04892461f, -0.00278483f, 0.05684366f, -0.03323135f, -0.09735649f, -0.12601474f, -0.04850129f, 0.00918407f, 
    0.11186069f, -0.20344655f, 0.07550921f, -0.41993904f, -0.03098172f, 0.02814969f, 0.02355042f, -0.00826565f, 
    0.06633237f, 0.07336371f, 0.09001622f, -0.16446446f, -0.09602641f, 0.39257628f, -0.28250158f, 0.28762272f, 
    0.14495918f, -0.02708895f, 0.04810262f, 0.11613272f, -0.24847689f, 0.00000232f, -0.03601075f, 0.03519364f, 
    -0.01996149f, 0.00096382f, -0.14743893f, 0.07501236f, -0.02685653f, -0.08866134f, -0.12983777f, -0.02540911f, 
    -0.06471018f, -0.04436795f, -0.02770179f, 0.15610658f, 0.07990109f, 0.02974989f, -0.07402427f, 0.04921987f, 
    0.02743192f, -0.10858768f, 0.06021093f, -0.05912029f, 0.07439898f, 0.00713528f, 0.08633453f, -0.04668865f, 
    -0.16797781f, -0.46254551f, -0.26990297f, 0.16647078f, -0.09356014f, -0.08416268f, 0.02177105f, 0.03959469f, 
    -0.01433109f, -0.07197909f, -0.02474654f, 0.01261038f, 0.17727147f, -0.15243264f, 0.02734461f, -0.03515631f, 
    -0.17826028f, -0.05494819f, -0.32956865f, 0.04633555f, 0.03390770f, 0.00400131f, -0.03227483f, 0.01456214f, 
    -0.20840235f, -0.05920712f, -0.29338068f, 0.04441434f, 0.03321619f, 0.05341714f, 0.06702963f, 0.02706577f, 
    0.05633041f, 0.13067463f, 0.10642549f, 0.11943533f, -0.46804878f, -0.33406529f, 0.15786685f, 0.03969616f, 
    0.18387486f, 0.06549499f, -0.02937212f, 0.02449916f, -0.00140414f, -0.01491467f, -0.02054718f, -0.06008945f, 
    0.08996852f, -0.03896638f, -0.14759465f, -0.00253982f, 0.01941958f, 0.06826407f, 0.03441790f, 0.02680943f, 
    -0.02059422f, 0.17850982f, 0.00702025f, -0.02666994f, -0.12904318f, -0.00657121f, -0.34197390f, 0.28044015f, 
    -0.06683044f, -0.03560383f, -0.03831645f, -0.08997656f, -0.03919396f, -0.00809535f, -0.06035284f, -0.09651349f, 
    0.08237413f, 0.07076444f, 0.10075183f, -0.14201672f, 0.01399561f, 0.00364773f, 0.00754799f, 0.03165049f, 
    0.01552584f, -0.13064858f, -0.01790068f, 0.02588757f, 0.48823428f, -0.45781088f, -0.45274264f, -0.33927742f, 
    0.01674225f, 0.00085082f, -0.06132033f, -0.00192070f, -0.06214659f, -0.11568758f, -0.05655827f, -0.01970669f, 
    0.04683369f, -0.49264017f, -0.34936190f, 0.20717134f, -0.01002971f, 0.01925968f, 0.03527002f, 0.05081486f, 
    0.09668987f, -0.01785719f, 0.03087063f, -0.00186889f, 0.05158436f, -0.04724137f, -0.00261326f, -0.01249226f, 
    -0.01853571f, -0.06054556f, 0.02855401f, -0.04319398f, 0.00998595f, -0.05774884f, 0.00444942f, -0.04999318f, 
    0.12824351f, -0.00241485f, -0.13489929f, -0.05885031f, 0.04248415f, -0.06997126f, 0.04835721f, 0.01530146f, 
    -0.05427071f, -0.16953924f, -0.05901678f, -0.04264299f, 0.25642413f, 0.09128815f, 0.05266474f, -0.23755483f, 
    -0.03092134f, 0.03031518f, -0.01243350f, -0.00632304f, 0.02449097f, 0.00368362f, -0.01426917f, -0.07468825f, 
    -0.03658997f, 0.01688123f, -0.01670653f, -0.00776905f, -0.01351394f, -0.10753552f, -0.07595849f, 0.03965265f, 
    0.04974024f, 0.03549487f, 0.04960012f, 0.00516769f, -0.06176543f, 0.05661792f, 0.14329329f, 0.02936126f, 
    0.01540839f, -0.05043698f, 0.00693493f, -0.03088141f, 0.01150739f, -0.04004240f, 0.00125136f, -0.08953442f, 
    -0.18852723f, 0.23303151f, -0.16016269f, 0.11269245f, 0.03329543f, 0.15743677f, 0.06254955f, 0.04160212f, 
    0.05820715f, -0.05999725f, 0.00601567f, 0.03044201f, 0.44819427f, -0.52033603f, -0.07526061f, -0.34182334f, 
    -0.05511661f, -0.00453115f, -0.11335206f, -0.00690355f, 0.06597226f, 0.03530074f, -0.06777475f, 0.01409857f, 
    -0.21922003f, -0.35009286f, -0.33833748f, -0.26212719f, -0.04508205f, -0.08387811f, 0.01005336f, 0.11448173f, 
    0.08557998f, -0.01967000f, -0.08214907f, -0.00299698f, -0.21087793f, -0.01441817f, 0.17108928f, 0.00253852f, 
    -0.01052779f, -0.00933481f, 0.07032967f, 0.03066611f, 0.01041183f, -0.01735006f, 0.02071973f, -0.06098292f, 
    0.05758289f, -0.10658783f, -0.04418084f, -0.03369248f, -0.17650338f, -0.08698738f, -0.04401375f, -0.12476078f, 
    -0.07019854f, -0.02640303f, 0.03117389f, -0.05695538f, -0.36920190f, 0.39406198f, 0.00036422f, 0.31958774f, 
    0.02474808f, -0.06007202f, 0.03338101f, 0.03563026f, 0.01291933f, -0.02678339f, 0.00747569f, 0.02739711f, 
    -0.36382192f, -0.15582046f, 0.15277110f, 0.39832485f, -0.04987292f, -0.00580917f, 0.10673013f, 0.05298802f, 
    0.05228726f, -0.03012853f, -0.02645757f, 0.01985738f, -0.33028910f, -0.42317867f, -0.32415655f, 0.18283218f, 
    0.00113458f, -0.05115155f, 0.01050158f, 0.07951242f, -0.01348890f, -0.01973756f, -0.01939234f, -0.01315593f, 
    -0.02271735f, 0.04102192f, 0.05794071f, 0.03332227f, -0.06568693f, -0.22084530f, 0.03287305f, -0.00298236f, 
    -0.03905973f, 0.01082088f, -0.02502947f, -0.06196223f, 0.59227359f, -0.58211190f, 0.42273667f, 0.13163483f, 
    -0.10536862f, 0.20698412f, -0.37035871f, 0.01760049f, -0.05264694f, -0.06261626f, -0.03671094f, -0.05581631f, 
    -0.23075601f, 0.22715057f, 0.19185299f, 0.14024566f, -0.05052535f, -0.01792606f, 0.04686721f, 0.05544378f, 
    0.06832625f, -0.01141218f, -0.02546486f, -0.09186569f, -0.26458013f, -0.39741355f, -0.19705331f, -0.30892712f, 
    -0.27295738f, 0.11929504f, 0.00057050f, 0.09411104f, 0.02512614f, -0.02037686f, -0.11233882f, -0.03019486f, 
    -0.49721652f, -0.17421506f, 0.42722705f, -0.14988756f, 0.11512843f, -0.08591168f, 0.01439928f, 0.11120974f, 
    -0.00082849f, -0.04199506f, -0.04807477f, 0.02251467f, -0.17435031f, 0.01785764f, -0.00691168f, -0.01536079f, 
    -0.08809638f, -0.00825438f, -0.13743936f, -0.11052242f, 0.04490606f, 0.05931436f, -0.01333837f, 0.01999951f, 
    -0.08249263f, 0.09798603f, 0.11750007f, 0.08036757f, 0.08621588f, -0.09235797f, 0.13856106f, -0.02011821f, 
    -0.12808459f, 0.02902568f, 0.02864924f, -0.07224483f, -0.44143522f, -0.45716965f, -0.31687972f, -0.11179532f, 
    -0.11380688f, -0.03298133f, -0.14199436f, 0.07474010f, 0.06245944f, -0.03226852f, -0.02410366f, 0.00317929f, 
    0.00404444f, 0.05323930f, -0.05747145f, 0.00141509f, -0.08347314f, -0.02480387f, 0.01991485f, -0.09332220f, 
    -0.17445736f, -0.31200549f, -0.11026648f, -0.05596029f, 0.41610414f, -0.22244957f, -0.01084444f, -0.51900542f, 
    -0.00616236f, 0.13298213f, -0.12578574f, 0.16496576f, 0.03346624f, -0.00669013f, -0.05641546f, -0.06160467f, 
    -0.20954013f, 0.48567137f, -0.20553508f, 0.07909909f, 0.05935503f, 0.02957938f, 0.02550998f, -0.01510228f, 
    -0.03320119f, -0.02800647f, 0.01915321f, 0.02376961f, 0.24734351f, -0.13645768f, -0.10605414f, -0.16627701f, 
    -0.08720163f, -0.05181206f, -0.07683362f, -0.03945607f, 0.07767811f, -0.03446126f, 0.04640605f, -0.05994671f, 
    -0.14530224f, 0.01944548f, 0.14056216f, -0.11994895f, -0.11977100f, 0.02899286f, -0.02946220f, -0.06531732f, 
    -0.06278694f, -0.02467770f, -0.09183531f, -0.02810298f, 0.03091057f, 0.03167409f, 0.07774661f, -0.08730428f, 
    -0.05814669f, 0.03264952f, -0.11448850f, -0.06413069f, 0.02377279f, 0.07793309f, 0.00969496f, 0.06406563f, 
    0.06726377f, 0.00795204f, -0.01572450f, 0.06597641f, 0.00659452f, -0.03159284f, 0.04011602f, -0.01371042f, 
    -0.03297881f, -0.02530451f, -0.04354103f, -0.05620974f, 0.25505629f, -0.03117793f, -0.05388338f, -0.12438714f, 
    -0.02901591f, 0.04441032f, -0.04418833f, -0.00989982f, 0.06150354f, -0.11413812f, 0.08160276f, -0.03877359f, 
    -0.46031156f, 0.11416554f, 0.03157081f, 0.08972982f, -0.12729546f, -0.09202549f, -0.09850882f, 0.02202870f, 
    -0.01527255f, -0.01808167f, 0.00345854f, -0.00545719f, 0.32985032f, -0.05501670f, -0.08060607f, -0.03459360f, 
    0.05333411f, -0.08988398f, 0.05001632f, 0.06601445f, 0.02779565f, 0.07733744f, 0.02207974f, 0.02820215f, 
    -0.03819094f, 0.09702992f, 0.10864681f, -0.08740602f, -0.03588191f, 0.03526079f, -0.01672012f, 0.07909224f, 
    -0.00455334f, 0.02566135f, 0.04141090f, -0.03828358f, -0.01683583f, -0.13085936f, 0.09855185f, -0.05548016f, 
    -0.01628957f, -0.00987892f, 0.01495721f, 0.05996933f, 0.13143237f, 0.16325541f, 0.01330915f, -0.02828960f, 
    -0.45310983f, -0.40028071f, -0.24100226f, -0.16726549f, 0.07750884f, 0.13677931f, 0.19215468f, 0.06724653f, 
    0.00781877f, 0.01549759f, -0.00906447f, -0.07381756f, -0.16917904f, -0.02147157f, 0.02970489f, -0.06096277f, 
    -0.00526593f, -0.00883887f, -0.03681354f, 0.00376034f, -0.15180150f, -0.05309498f, -0.09458805f, -0.16976917f, 
    -0.06980309f, -0.02394048f, -0.04442204f, 0.00499795f, -0.00028321f, -0.00924819f, -0.03443608f, -0.02216218f, 
    -0.19571257f, 0.13162930f, -0.25954729f, -0.46060988f, 0.09348720f, 0.13382956f, -0.15865578f, 0.01173969f, 
    -0.22048490f, -0.08627854f, -0.02799645f, -0.14231122f, 0.04810890f, -0.00385164f, -0.07849364f, -0.01468797f, 
    -0.09540140f, 0.01985141f, 0.01957316f, 0.05119980f, -0.11237621f, 0.03630036f, 0.03124123f, -0.01565342f, 
    0.08498468f, -0.04671421f, 0.02246197f, 0.06039981f, -0.29164961f, 0.14032978f, 0.05226501f, 0.24887407f, 
    0.00674116f, 0.05302201f, -0.04780683f, 0.04086641f, 0.06387633f, 0.01371700f, 0.01026408f, 0.15033346f, 
    -0.16698816f, 0.00711571f, 0.05235455f, -0.06176865f, -0.07843138f, -0.00095066f, -0.03283573f, 0.00523521f, 
    0.06959618f, 0.08776561f, 0.03107651f, 0.11290611f, 0.04665968f, -0.17844142f, -0.13222189f, -0.07485536f, 
    -0.04358281f, 0.01566321f, 0.06127154f, -0.00121903f, 0.00753573f, -0.03678211f, -0.01441496f, -0.00813141f, 
    -0.03996314f, -0.09856945f, -0.03755981f, 0.05807026f, -0.00182584f, -0.01707839f, -0.00877495f, 0.00698677f, 
    0.13268360f, 0.06719273f, 0.08481970f, 0.21868947f, -0.10794096f, -0.00712095f, 0.11993977f, 0.04856686f, 
    0.06442707f, 0.03603303f, -0.04942525f, 0.08201320f, 0.00036739f, -0.09560972f, 0.13685790f, 0.06349319f, 
    0.07983228f, 0.02886646f, 0.09237619f, -0.02585690f, -0.02138524f, -0.07206704f, -0.06133739f, -0.02213864f, 
    0.11317220f, 0.00292289f, 0.11288294f, 0.11228356f, 0.11046929f, -0.22287926f, -0.07522102f, -0.18492143f, 
    -0.04029410f, -0.01276203f, -0.01112213f, -0.04602026f, 0.04656102f, 0.00684289f, 0.00848065f, -0.11233691f, 
    -0.11283267f, -0.03305976f, -0.15111126f, -0.06425320f, -0.04570872f, 0.07384808f, 0.06304772f, 0.12560545f, 
    -0.02389739f, -0.07877986f, -0.02551270f, -0.06463137f, -0.04358405f, -0.10567215f, -0.23473433f, -0.19579990f, 
    0.03139972f, -0.02949784f, 0.00893907f, 0.04566335f, 0.15052107f, 0.08082897f, 0.04374909f, 0.00781036f, 
    -0.16593960f, -0.20783809f, -0.03889033f, 0.15977103f, 0.08261817f, 0.02234831f, -0.04948682f, 0.06969168f, 
    -0.16117917f, -0.03090904f, -0.17429292f, -0.19235744f, -0.04119276f, -0.40205032f, -0.46498910f, -0.30731726f, 
    -0.07038549f, -0.00034896f, 0.02864177f, 0.00404736f, 0.04880723f, -0.00746618f, -0.01885255f, 0.01954154f, 
    -0.48797467f, -0.64183694f, -0.29032096f, -0.01494798f, 0.01297260f, -0.06250685f, 0.07868239f, 0.14318170f, 
    -0.07024807f, -0.00032591f, -0.02997482f, 0.04595088f, -0.27143684f, -0.14740571f, 0.09343104f, 0.28783455f, 
    -0.01102188f, 0.02882000f, 0.03981323f, -0.01246466f, 0.05640353f, 0.09529029f, -0.05730102f, 0.22003998f, 
    0.04110998f, 0.13919109f, 0.10024426f, -0.57681549f, -0.08284290f, -0.10518406f, -0.05432480f, -0.14675494f, 
    -0.05405648f, 0.04440242f, -0.13528562f, 0.19145060f, 0.41671655f, 0.00304370f, -0.42221266f, -0.16680923f, 
    -0.14535829f, -0.07312611f, 0.01355465f, -0.05320254f, 0.19831483f, -0.03255339f, 0.21134125f, 0.01514893f, 
    0.14659522f, -0.03608194f, -0.04706476f, -0.10069557f, -0.02724466f, -0.04325051f, 0.04278539f, 0.12538952f, 
    -0.11421010f, -0.04292509f, -0.08217160f, 0.03790717f, -0.30074018f, 0.05939844f, 0.08417706f, -0.16086511f, 
    -0.11705821f, -0.07032628f, -0.03017224f, -0.13655414f, -0.07879311f, -0.01889358f, -0.11058167f, -0.05825911f, 
    0.00353296f, -0.13730492f, -0.25720033f, -0.18907531f, 0.08675300f, 0.09263662f, 0.02206630f, -0.00848243f, 
    0.07350648f, -0.06861173f, -0.22485413f, -0.30271387f, 0.13393933f, 0.14543284f, -0.19381748f, -0.12719102f, 
    0.01959828f, -0.10833679f, 0.05291171f, 0.08390896f, 0.08936127f, -0.04795470f, 0.03222108f, 0.05498701f, 
    -0.12160068f, -0.12789717f, -0.11367147f, 0.09791164f, 0.07992873f, 0.02024906f, -0.07246054f, 0.28520417f, 
    -0.31643665f, -0.19065545f, -0.22688831f, -0.20537463f, 0.08696249f, -0.13796636f, -0.30117908f, -0.08438706f, 
    0.02429880f, -0.03190397f, 0.21023871f, 0.09631255f, -0.03982787f, 0.00243849f, -0.04162898f, -0.06824768f, 
    -0.12215572f, 0.04985010f, 0.13602035f, 0.19047081f, -0.12577841f, -0.04307316f, 0.03040464f, -0.10125098f, 
    0.17461163f, 0.07920979f, 0.01494849f, 0.04643331f, -0.08399807f, 0.28367785f, 0.08949979f, 0.22211438f, 
    0.04647247f, 0.02446757f, -0.00787603f, 0.06883658f, -0.06986973f, 0.15115458f, -0.06525248f, 0.11135404f, 
    -0.08138685f, 0.00379183f, -0.02125966f, -0.09242988f, -0.02421094f, -0.12685637f, -0.01350640f, -0.03991780f, 
    0.00874536f, 0.10106307f, 0.00043678f, 0.06692012f, -0.33505592f, -0.36400667f, -0.27467787f, 0.11549752f, 
    0.03954594f, 0.05361949f, 0.25075194f, 0.09508233f, 0.02449921f, -0.13857763f, 0.12850569f, 0.06211144f, 
    -0.29120976f, -0.76635569f, 0.21522243f, 0.37116855f, -0.03887489f, 0.09035475f, -0.02573990f, 0.12912641f, 
    -0.04760143f, 0.13545623f, -0.04968427f, -0.20348197f, -0.15332259f, -0.08858700f, 0.07148346f, -0.01369067f, 
    -0.00401670f, -0.04662627f, 0.02052953f, -0.08905170f, 0.02497119f, -0.13768557f, -0.07989450f, -0.01089838f, 
    -0.11843919f, -0.25088450f, 0.03699116f, -0.16991286f, -0.06067019f, 0.06051896f, 0.09986001f, 0.00390572f, 
    0.05318857f, 0.05262196f, 0.04834000f, 0.03422360f, 0.16463698f, 0.22384581f, -0.11167902f, -0.17987223f, 
    -0.08800104f, -0.14316434f, -0.10635591f, -0.03830674f, 0.06611086f, 0.06677709f, 0.00857762f, 0.15319341f, 
    -0.13575958f, 0.09964421f, 0.12645604f, -0.01142420f, -0.04063931f, -0.06946991f, -0.02038060f, -0.11134917f, 
    -0.04367684f, -0.01929398f, 0.01354191f, 0.01203368f, -0.51482427f, -0.15240146f, 0.14003964f, 0.03954110f, 
    0.05053919f, -0.03626078f, -0.03902842f, -0.00012217f, -0.09066210f, 0.06756498f, -0.00904617f, 0.14828292f, 
    -0.38496527f, 0.12749019f, 0.09060293f, 0.27880064f, -0.09466944f, -0.09166738f, -0.06105965f, -0.02862659f, 
    -0.01609209f, 0.13352440f, 0.15106051f, 0.03485589f, -0.00709978f, -0.13418511f, -0.17343250f, -0.11779683f, 
    0.08367197f, 0.04029790f, 0.09904055f, 0.07083118f, -0.00675429f, -0.11441407f, 0.02879081f, -0.11798590f, 
    0.04376973f, -0.29830623f, -0.29464316f, 0.13293403f, 0.03765690f, 0.10569175f, 0.09646922f, 0.09093091f, 
    -0.07483504f, -0.02928296f, -0.12413388f, -0.04148217f, 0.36975500f, -0.04056293f, -0.09037227f, -0.15602727f, 
    -0.06454163f, -0.06576539f, -0.03682865f, -0.29481184f, 0.03176404f, 0.10213965f, -0.02339424f, 0.05375184f, 
    0.14751239f, -0.00265791f, -0.07039606f, 0.04841575f, 0.15954830f, -0.03030617f, 0.05552355f, 0.13209029f, 
    0.06135857f, -0.01265205f, 0.10514085f, 0.16635756f, -0.70884728f, 0.05799184f, 0.09431501f, 0.22449221f, 
    0.09321688f, 0.08557905f, 0.05514278f, 0.10947752f, -0.00023067f, -0.01506015f, 0.16966790f, 0.01858942f, 
    0.27407050f, -0.01016139f, -0.04288869f, -0.41905412f, 0.15472378f, -0.04081494f, -0.09071125f, -0.01068020f, 
    -0.01909786f, -0.02783414f, 0.02594990f, 0.01112381f, -0.34177426f, -0.42903566f, -0.36641502f, -0.18167096f, 
    0.06099462f, 0.08488120f, 0.05936857f, 0.09118886f, 0.04341367f, 0.04712011f, -0.01469321f, 0.15033886f, 
    -0.08928216f, -0.01815335f, 0.01019524f, 0.05458268f, -0.04187091f, 0.03732065f, -0.08061535f, -0.04074242f, 
    0.10555448f, 0.12134875f, 0.04368425f, 0.15904427f, 0.13094752f, -0.33663177f, -0.31321019f, -0.15587242f, 
    0.19154792f, 0.07949034f, 0.05098396f, 0.13010599f, 0.06480613f, 0.12784095f, 0.18188468f, 0.18725856f, 
    -0.63579118f, 0.12056971f, 0.00359080f, 0.12246698f, 0.00535825f, 0.03652619f, -0.12578760f, 0.05854653f, 
    0.00986756f, 0.19866811f, -0.08640803f, 0.13509852f, -0.13074361f, -0.15625378f, -0.28114498f, 0.28185013f, 
    0.21787484f, -0.01250935f, 0.05681010f, 0.03415779f, 0.00103655f, -0.07360270f, 0.11285470f, 0.14400515f, 
    0.49301466f, -0.03378022f, -0.20847397f, -0.02242275f, -0.04201921f, 0.13562250f, 0.01132219f, -0.23203713f, 
    0.02523699f, -0.00857296f, 0.02143718f, 0.00806257f, 0.26401448f, 0.01884524f, -0.10114972f, 0.14451772f, 
    0.10238483f, -0.06454833f, 0.14239438f, 0.02443797f, -0.02866104f, -0.02651374f, 0.11634971f, -0.03383706f, 
    0.08049311f, -0.03457115f, 0.05781751f, -0.09234641f, -0.15160605f, -0.03596020f, -0.00245451f, -0.00252437f, 
    0.05566083f, 0.11365223f, 0.05978450f, 0.08549785f, -0.09406701f, -0.44436261f, -0.43284130f, 0.02137732f, 
    0.05344182f, 0.09384488f, 0.09146579f, -0.07195241f, -0.04721908f, 0.02920325f, 0.01771633f, 0.02489480f, 
    0.14226533f, -0.04060589f, 0.00747014f, -0.04338823f, -0.13947605f, 0.04710809f, 0.02963019f, 0.11279733f, 
    0.14232932f, 0.03209576f, -0.04169660f, 0.00262115f, 0.27869749f, 0.19141936f, -0.51006126f, -0.04444619f, 
    0.02386594f, -0.03604499f, 0.02176646f, 0.12167940f, -0.03063147f, -0.12736343f, -0.00394205f, 0.11053935f, 
    -0.58290261f, 0.05174491f, 0.24735734f, 0.32170504f, 0.12925006f, -0.03648826f, -0.07054569f, -0.10804528f, 
    0.00603398f, 0.00891881f, -0.01694640f, 0.01581052f, 0.11514982f, 0.08741025f, -0.16263163f, -0.05003854f, 
    0.00922475f, -0.02240588f, 0.04816685f, -0.00142445f, -0.01459429f, 0.03106060f, -0.22288205f, -0.33808973f, 
    -0.27939531f, 0.04435153f, 0.01415472f, 0.40851474f, 0.07230186f, 0.04960749f, 0.04198555f, 0.08205300f, 
    0.13388833f, 0.11351260f, 0.04717429f, 0.12423304f, -0.03892701f, 0.09555873f, 0.00750689f, 0.03578351f, 
    0.09488362f, 0.04088425f, -0.01780277f, -0.07428011f, -0.12439053f, -0.03829997f, -0.07277378f, -0.05888940f, 
    -0.12294598f, -0.03333604f, 0.05482329f, -0.02035485f, 0.00308209f, -0.02738514f, -0.09678176f, -0.02365573f, 
    -0.20321308f, -0.13842651f, -0.05772090f, -0.17960449f, -0.29213801f, -0.11149967f, -0.11804922f, -0.06807058f, 
    -0.06084723f, 0.00805215f, 0.02703382f, -0.03463590f, 0.00131705f, 0.09243887f, 0.01936563f, 0.07179118f, 
    -0.42222971f, 0.06418223f, 0.17296864f, 0.16422707f, 0.04884107f, -0.05519598f, 0.08163891f, 0.00968275f, 
    0.07145825f, 0.05620203f, 0.08281453f, 0.00891271f, -0.06838781f, -0.16075587f, -0.28182590f, -0.16719204f, 
    0.10515304f, 0.04951500f, 0.08702358f, 0.08730701f, 0.09354242f, 0.03864071f, 0.01393870f, 0.07629520f, 
    -0.12093083f, -0.05822528f, 0.02387996f, -0.12980238f, -0.09188975f, -0.09042908f, -0.05347056f, -0.15962797f, 
    0.02935302f, 0.04769951f, -0.03032530f, 0.06252253f, -0.00258937f, -0.02266245f, -0.16040324f, -0.19773529f, 
    0.01557005f, -0.00605704f, 0.03562801f, 0.12934655f, -0.19931541f, 0.00059834f, -0.18419896f, -0.65083212f, 
    -0.07984472f, 0.01035426f, 0.25886285f, -0.05608200f, -0.06083833f, -0.09353773f, -0.01360273f, -0.02994707f, 
    0.01197427f, 0.04780554f, 0.01246815f, 0.00866835f, 0.09494884f, 0.17599887f, -0.08158059f, -0.10484462f, 
    -0.01321958f, 0.06491718f, 0.18674637f, 0.15343609f, -0.00582863f, 0.09592801f, -0.07958074f, -0.09976648f, 
    -0.01432840f, -0.06111609f, 0.08004524f, 0.02329999f, -0.01664275f, 0.08770154f, 0.05086726f, -0.03898460f, 
    0.15197347f, 0.25487855f, 0.20633820f, 0.19573100f, 0.20423734f, -0.42360660f, -0.15436757f, -0.33305237f, 
    0.12050555f, 0.12281986f, -0.18321081f, 0.27012527f, 0.01500627f, -0.05890612f, -0.02226914f, -0.08018724f, 
    -0.06358432f, -0.31216672f, 0.17392613f, -0.34872571f, -0.03746688f, 0.07418594f, -0.09917698f, 0.09252020f, 
    0.06362322f, 0.07402000f, -0.00379169f, 0.02866959f, 0.02467361f, -0.12485141f, -0.11324043f, -0.35951591f, 
    -0.08881266f, 0.00973015f, 0.08184715f, -0.10635437f, -0.02808847f, 0.02304649f, -0.09078491f, 0.06690022f, 
    0.06529365f, -0.17911547f, 0.02294277f, -0.06635991f, 0.01575323f, 0.08527277f, -0.00780140f, -0.00483679f, 
    0.05608045f, 0.03470684f, 0.07439510f, -0.08108031f, -0.02054318f, 0.09382181f, 0.20615374f, 0.00205742f, 
    0.06397592f, -0.05495278f, 0.03495916f, 0.01681341f, 0.07147664f, -0.02161913f, -0.00900036f, 0.05135480f, 
    0.21936019f, -0.16920504f, 0.04397383f, -0.11925292f, 0.14262171f, -0.02893623f, -0.02498286f, 0.00212061f, 
    -0.25684357f, -0.04406741f, -0.26638490f, -0.00412147f, -0.21317233f, 0.16738273f, -0.19772828f, -0.25765958f, 
    0.08480932f, -0.14786413f, 0.01417046f, -0.05669498f, 0.06669158f, 0.02924236f, -0.05210517f, 0.05035618f, 
    0.06912115f, -0.10842990f, 0.09563375f, -0.02092198f, 0.18768741f, -0.00275217f, 0.01234516f, -0.05362618f, 
    -0.20507494f, 0.05879939f, 0.05552335f, -0.03468299f, -0.01728875f, -0.21728587f, 0.15585910f, 0.25150284f, 
    -0.02840091f, 0.04235618f, -0.12292805f, -0.09273551f, -0.05434721f, 0.14193320f, 0.04771058f, -0.05365707f, 
    0.03318431f, 0.09666013f, -0.08472139f, 0.12269138f, -0.18721199f, 0.12586159f, -0.16378094f, -0.09910542f, 
    0.15920100f, 0.04313033f, 0.09334609f, -0.03661986f, -0.01023559f, 0.25917277f, 0.03629004f, 0.39913604f, 
    -0.02742350f, 0.01780236f, -0.11358282f, -0.07867653f, -0.08085389f, -0.13718249f, -0.14294137f, -0.01819758f, 
    0.24414916f, 0.13233967f, 0.13208441f, -0.27620363f, -0.12106697f, -0.15003213f, -0.12897585f, 0.06625172f, 
    0.01860482f, 0.09746825f, 0.05251098f, 0.03769387f, -0.48024309f, 0.03613460f, -0.18262745f, 0.26694834f, 
    -0.05671023f, 0.06228730f, 0.04575688f, 0.22499777f, 0.02105179f, 0.07133191f, 0.08894322f, -0.03998742f, 
    -0.22007313f, 0.33300424f, 0.00408469f, -0.12327334f, -0.24839309f, 0.11889515f, 0.02842191f, 0.08921782f, 
    0.07069703f, -0.02932817f, -0.00998839f, -0.04355622f, 0.15225784f, -0.36235127f, 0.10003466f, -0.28683111f, 
    -0.00709804f, -0.07145930f, -0.09158340f, -0.02204339f, -0.12206989f, 0.00707890f, -0.11250440f, 0.02884375f, 
    -0.07023275f, -0.45386708f, 0.17904849f, 0.10313080f, 0.10217827f, 0.12388841f, -0.08856540f, -0.02203285f, 
    -0.07678653f, -0.11171166f, 0.01159685f, -0.03000969f, -0.53234142f, -0.05053144f, -0.33051503f, 0.19779070f, 
    0.07604092f, -0.22056960f, -0.09429184f, 0.06422684f, -0.16412495f, -0.03213298f, -0.01503559f, -0.02409398f, 
    -0.15204854f, -0.02852365f, 0.09273142f, 0.34266463f, 0.05392634f, 0.09378775f, -0.07019839f, 0.08329122f, 
    0.08204561f, -0.00808238f, 0.15107645f, 0.20698966f, -0.26529184f, -0.23031507f, 0.13297004f, -0.06354258f, 
    0.11814786f, 0.14921492f, 0.10811032f, 0.12013235f, 0.00636015f, 0.04053777f, 0.03445923f, 0.07596764f, 
    -0.31743714f, 0.06344518f, 0.31970638f, 0.08369473f, 0.09170174f, -0.11284832f, -0.01026399f, -0.08646841f, 
    0.00090856f, 0.04375858f, 0.09745520f, 0.05458825f, -0.27931395f, 0.05176247f, -0.04281224f, -0.20175980f, 
    0.07908845f, -0.11977278f, -0.14960000f, 0.04803168f, 0.12180759f, -0.08410811f, 0.00197231f, -0.06094920f, 
    -0.28897470f, 0.54975349f, -0.11243901f, -0.70809513f, -0.15129593f, -0.15431963f, 0.09899938f, -0.01604151f, 
    -0.03582516f, 0.07788227f, -0.11453076f, -0.00239431f, -0.20274742f, 0.17938022f, 0.18771911f, -0.14367796f, 
    -0.09654975f, -0.25164077f, 0.12152759f, 0.05977929f, -0.06383676f, 0.06296860f, 0.00265468f, 0.00799406f, 
    0.01391215f, 0.11853350f, -0.07612366f, 0.13630876f, -0.01290324f, 0.01438431f, -0.20773984f, 0.03765140f, 
    -0.01582779f, -0.17312378f, 0.13966504f, -0.03438310f, -0.43070835f, 0.21537678f, 0.07848926f, -0.19526337f, 
    0.03556290f, -0.05626289f, 0.00569965f, 0.02733633f, 0.05213857f, 0.03665840f, -0.08419718f, -0.14294291f, 
    0.02870473f, -0.35436508f, -0.07918058f, 0.16500697f, 0.08471370f, 0.05283649f, 0.00848682f, 0.02442284f, 
    0.10521661f, 0.09937270f, 0.02884185f, -0.00087012f, 0.19575316f, 0.10989527f, 0.32753271f, -0.57108909f, 
    0.00699426f, -0.10972600f, -0.10068627f, -0.25427863f, -0.01088513f, -0.12163110f, -0.01892945f, 0.09314898f, 
    -0.02859836f, 0.05229426f, -0.18899409f, -0.39683387f, -0.32499650f, -0.03538925f, -0.08110226f, -0.07756978f, 
    0.15991357f, -0.00747649f, 0.02361294f, -0.01341735f, 0.01291245f, 0.00276965f, -0.04423770f, -0.27338052f, 
    0.24063407f, -0.02437070f, 0.08514012f, -0.12034341f, -0.00210132f, -0.18114012f, -0.22964598f, -0.05986850f, 
    0.30549490f, 0.00597845f, 0.30504784f, 0.14923511f, 0.11948283f, -0.08359929f, -0.15127558f, -0.01680592f, 
    -0.00793945f, -0.04279679f, -0.03683118f, 0.23516689f, -0.20101321f, -0.23586288f, 0.08854008f, 0.04958311f, 
    -0.00496519f, 0.18135099f, -0.01591808f, 0.07323099f, -0.11837006f, -0.12457529f, 0.00158006f, -0.24234220f, 
    -0.06997817f, -0.13306151f, -0.50340849f, 0.02466558f, 0.13943826f, 0.14387131f, 0.27784353f, 0.09040654f, 
    0.06166602f, -0.08863981f, -0.02365940f, -0.07508931f, 0.01198040f, -0.04780939f, 0.15763421f, -0.14806907f, 
    0.09894215f, -0.11534844f, 0.01887808f, 0.11496877f, -0.13243516f, 0.02510498f, 0.09906189f, -0.13387479f, 
    -0.31616750f, 0.24592334f, -0.55751610f, 0.22208877f, -0.01430869f, -0.17540561f, 0.08702816f, -0.05003378f, 
    0.07320195f, 0.08306019f, -0.07887078f, -0.05111295f, 0.20927493f, -0.10040011f, 0.39940062f, 0.16572575f, 
    -0.00468050f, -0.00802692f, -0.18585886f, -0.16684544f, 0.00764457f, -0.15805182f, 0.11253478f, -0.02400210f, 
    0.09344308f, -0.07017728f, -0.04033156f, -0.04095213f, -0.08064430f, -0.00571057f, 0.01038934f, 0.08069244f, 
    0.10062969f, 0.01656341f, 0.07155205f, 0.15795057f, -0.01576218f, -0.68849272f, -0.01202949f, 0.20949452f, 
    0.07067722f, 0.19071782f, 0.15839291f, 0.03599905f, -0.05789784f, -0.05222203f, -0.09580898f, -0.13414748f, 
    0.04899242f, 0.20297736f, 0.07470211f, -0.20074107f, 0.07026961f, -0.12519263f, 0.10760370f, -0.14034733f, 
    0.10978182f, -0.16526790f, -0.10195352f, 0.05824434f, -0.15988638f, 0.35905850f, -0.14276975f, -0.24249387f, 
    -0.15573071f, 0.03019293f, 0.20511784f, 0.06698215f, 0.11153389f, 0.11629615f, -0.16134545f, -0.03962119f, 
    0.42997819f, -0.24813117f, -0.28574082f, -0.09756508f, -0.04466361f, 0.02283210f, -0.05634313f, 0.13915411f, 
    0.11852850f, 0.04988543f, 0.03253194f, 0.02291526f, -0.21570250f, 0.19169976f, 0.08341367f, -0.21779065f, 
    0.07444677f, -0.14733872f, -0.05166718f, 0.03414613f, 0.05810188f, 0.08831858f, 0.00879403f, -0.04878198f, 
    -0.14483178f, 0.01549563f, -0.05206828f, 0.05055726f, 0.13543133f, -0.08367668f, -0.06070978f, 0.05349723f, 
    0.09105379f, -0.09019462f, -0.15446329f, -0.12477046f, -0.10504479f, -0.10455596f, 0.18582745f, -0.06088445f, 
    -0.12065045f, -0.15035558f, 0.03326217f, -0.12948340f, 0.03867842f, 0.03970316f, -0.12029401f, 0.03992776f, 
    -0.12027542f, 0.15980919f, -0.08861666f, -0.23442803f, 0.05931039f, 0.04277852f, 0.09019803f, 0.07699843f, 
    0.14844069f, 0.08640572f, -0.16359334f, -0.04508714f, 0.19004014f, 0.01291892f, 0.12427524f, -0.46385249f, 
    -0.07411171f, -0.08160282f, -0.08227032f, 0.07368716f, 0.05039797f, 0.01426400f, -0.04691537f, 0.04969034f, 
    -0.21205781f, -0.16784413f, 0.02231968f, -0.47667187f, 0.04655686f, -0.08173622f, -0.06789297f, 0.14556418f, 
    0.02066380f, 0.00557433f, 0.03630793f, -0.02665450f, -0.30411306f, 0.17012176f, -0.06635306f, -0.13593967f, 
    0.07254982f, 0.07457264f, 0.17997882f, -0.01834513f, 0.03542688f, 0.00007682f, -0.07342813f, -0.03684692f, 
    -0.25006011f, -0.03656133f, 0.22589675f, -0.29664162f, 0.11827325f, 0.06261177f, -0.07755698f, 0.13220230f, 
    -0.03366246f, -0.03110773f, 0.02000066f, 0.04608935f, -0.34447220f, -0.01933817f, 0.09766342f, -0.54526633f, 
    -0.25456557f, 0.11646987f, 0.02084052f, 0.08449604f, 0.10371510f, 0.00369195f, 0.02222295f, -0.02966382f, 
    -0.29522684f, 0.00869126f, -0.15981020f, 0.09395271f, 0.13861275f, -0.07433047f, 0.04523762f, -0.13843609f, 
    0.04812863f, 0.00286146f, -0.09335670f, -0.21704838f, -0.03443751f, -0.34465954f, -0.11124750f, 0.27929577f, 
    -0.03046648f, -0.07332544f, -0.41428357f, 0.01346278f, 0.07427636f, -0.17220697f, -0.04547103f, 0.05402913f, 
    -0.37201655f, 0.02486170f, -0.62322873f, 0.26136288f, 0.05038548f, -0.04609169f, 0.09195063f, 0.06455394f, 
    0.04907801f, 0.00840599f, -0.02495456f, 0.05128149f, -0.12763588f, 0.08112591f, 0.18464532f, 0.45714691f, 
    0.01062020f, 0.05713843f, -0.12327477f, -0.12421490f, 0.26712835f, 0.05062042f, 0.11021603f, 0.09171656f, 
    0.08983488f, 0.19949900f, 0.39390016f, -0.59039873f, 0.03508200f, -0.01490482f, -0.03091998f, 0.02386365f, 
    -0.04970694f, 0.04271450f, -0.04534591f, 0.07358953f, 0.11476026f, -0.19529243f, -0.44012639f, -0.00529097f, 
    0.01636865f, 0.16145873f, 0.12369908f, 0.00893360f, -0.02343444f, -0.05428795f, -0.06330579f, 0.05399409f, 
    -0.28063616f, -0.03645312f, -0.13086139f, 0.13678525f, 0.08585850f, 0.07535239f, 0.09407987f, 0.07857701f, 
    0.05897529f, 0.02687068f, 0.07420414f, 0.05349553f, 0.20512676f, 0.18884930f, 0.13165008f, 0.00148125f, 
    0.07018607f, -0.03229479f, -0.10705969f, -0.05264005f, 0.05711405f, -0.00597396f, 0.01806766f, 0.04253529f, 
    -0.07749796f, 0.39811110f, -0.11755458f, -0.09213331f, 0.07536228f, -0.21258333f, 0.07486206f, 0.15622514f, 
    -0.06984238f, -0.00711657f, -0.01712225f, 0.00566256f, 0.16495498f, 0.07107052f, 0.21072359f, 0.14320199f, 
    0.18598755f, -0.21473593f, -0.16203558f, 0.00004991f, -0.14658722f, -0.14894253f, 0.03763076f, -0.02879656f, 
    0.26633787f, -0.01515584f, 0.12531868f, -0.19722466f, 0.09938852f, 0.05653010f, -0.09348263f, 0.01823778f, 
    0.04692397f, -0.10096600f, -0.08720676f, -0.01925724f, -0.04695586f, 0.03792319f, -0.00931378f, 0.14959311f, 
    -0.17071043f, 0.02918946f, 0.00178389f, -0.01912230f, -0.16595216f, 0.11734236f, -0.05494451f, 0.02780655f, 
    -0.17404339f, -0.00506401f, -0.23813595f, -0.18617934f, 0.00780105f, -0.04429409f, 0.04122294f, 0.04484147f, 
    -0.09640421f, 0.00323344f, -0.22962703f, -0.28043261f, -0.08758936f, -0.06764342f, -0.10655265f, 0.09765749f, 
    -0.12730108f, -0.12656474f, -0.03479610f, -0.07938254f, -0.06341398f, -0.08680341f, 0.01778965f, -0.15988509f, 
    0.02627836f, 0.31571203f, 0.22344787f, -0.21873419f, 0.03094460f, 0.07374831f, 0.02631761f, 0.01083332f, 
    -0.06548159f, -0.13072775f, -0.40827978f, -0.48579457f, -0.34930879f, -0.10747743f, 0.21875891f, 0.16015503f, 
    0.10365743f, 0.24909666f, -0.24067906f, -0.03609189f, -0.00520940f, 0.02248559f, 0.06781768f, -0.13108496f, 
    -0.09346907f, 0.03217137f, 0.18763688f, 0.19382289f, 0.07293332f, 0.08727878f, -0.28982860f, -0.19566099f, 
    -0.10035536f, -0.14864351f, 0.14795890f, 0.01774013f, -0.08667190f, 0.12662075f, -0.38076720f, 0.18936940f, 
    -0.14103785f, 0.00237752f, -0.00895843f, -0.03517351f, -0.03115443f, 0.02999224f, -0.01785610f, 0.03715181f, 
    -0.14033297f, -0.01264763f, -0.19972560f, 0.09816462f, -0.14868195f, -0.14569819f, -0.00338463f, -0.19324213f, 
    -0.11875056f, 0.16260827f, 0.09554116f, 0.09768461f, -0.26234302f, 0.20745483f, -0.14479399f, -0.03431767f, 
    0.07008157f, 0.13119684f, 0.07721794f, 0.02304284f, -0.14900707f, 0.07004133f, 0.01183417f, 0.05633528f, 
    0.09523518f, 0.03757273f, -0.18816756f, 0.23354231f, 0.00811980f, 0.03902320f, 0.08350585f, -0.05115318f, 
    0.24189374f, 0.01872052f, 0.14404073f, 0.29520148f, -0.02666305f, 0.01148385f, -0.10350423f, -0.02358452f, 
    -0.02732428f, -0.06683586f, 0.16077822f, -0.02592859f, 0.13980788f, 0.03757202f, 0.07103135f, -0.03916901f, 
    -0.17641973f, 0.11112168f, -0.02180914f, -0.13884836f, -0.13945085f, -0.06024249f, -0.18192536f, 0.05316013f, 
    0.18353948f, -0.05481264f, 0.15672188f, 0.08674397f, -0.10903488f, 0.13838857f, -0.07879987f, -0.12080320f, 
    -0.02538787f, 0.03571553f, -0.10966324f, -0.11823237f, 0.03589198f, 0.00585513f, -0.28778788f, -0.09860945f, 
    0.09074356f, 0.11957961f, 0.15727803f, -0.10581720f, 0.02894961f, 0.09811541f, 0.04829981f, 0.08605553f, 
    -0.10274555f, 0.10249211f, 0.06646671f, -0.15665996f, 0.18261178f, -0.05706287f, 0.32573432f, -0.30222589f, 
    -0.08025811f, 0.11406433f, -0.01219330f, 0.01318099f, 0.02789845f, -0.00364460f, 0.18307610f, 0.00672397f, 
    -0.02466822f, -0.01934665f, -0.00739255f, 0.28881887f, 0.01918289f, -0.13815270f, 0.02334388f, 0.08602042f, 
    -0.27136832f, -0.05129282f, -0.19474372f, -0.30702847f, -0.18222338f, 0.23132809f, -0.17818736f, 0.12840971f, 
    0.04294286f, 0.20659378f, 0.06357383f, 0.12977038f, 0.06772348f, 0.19785623f, -0.09369532f, -0.02128414f, 
    -0.06075402f, -0.05820377f, 0.00306700f, -0.05671110f, -0.06366477f, 0.19364855f, 0.10850983f, 0.07888040f, 
    -0.13473657f, 0.09867195f, 0.11259226f, 0.10179767f, -0.18632963f, 0.29302865f, -0.02171938f, 0.15988743f, 
    0.07230619f, 0.11304795f, 0.04412819f, 0.19695114f, -0.08743194f, 0.07484098f, 0.06982764f, 0.08484542f, 
    -0.10725988f, 0.30631849f, -0.00672963f, 0.08832589f, -0.26545987f, -0.06337205f, 0.01087660f, -0.13705453f, 
    -0.07001429f, 0.02589186f, 0.04499971f, -0.06338479f, -0.25235125f, 0.40478772f, 0.35965708f, -0.09895609f, 
    -0.19905421f, 0.07517561f, -0.00384289f, 0.18207765f, 0.15813585f, 0.09853160f, 0.08265116f, -0.16193524f, 
    0.02252021f, -0.04563366f, 0.00730107f, -0.15930632f, -0.07897689f, 0.04330822f, 0.02891959f, 0.13655630f, 
    -0.07112196f, 0.04629922f, -0.09613557f, -0.08059496f, -0.28441253f, -0.01990958f, 0.10389477f, -0.12364429f, 
    -0.13868095f, -0.02987912f, -0.10305125f, -0.15973304f, -0.04251228f, -0.11435591f, -0.08704714f, 0.08245109f, 
    -0.05697025f, -0.23422360f, -0.05740474f, -0.13033760f, -0.01134847f, 0.04614456f, -0.03394479f, 0.06546280f, 
    -0.00324555f, 0.05358181f, -0.26936877f, -0.25129151f, -0.25035903f, -0.17242233f, 0.31183520f, 0.17858969f, 
    -0.10522723f, 0.12224589f, -0.06349187f, 0.11536343f, -0.24645519f, 0.09444144f, 0.02313393f, 0.03743365f, 
    0.30899310f, -0.54579735f, 0.25261512f, 0.36890209f, -0.07206634f, 0.12930292f, 0.15585348f, -0.09997159f, 
    -0.01571964f, -0.22620684f, -0.20907469f, 0.00558995f, -0.39331114f, 0.03016423f, 0.03169049f, 0.16653022f, 
    -0.01384970f, 0.07856796f, 0.11334252f, 0.00843915f, -0.00951200f, -0.02723321f, 0.07522330f, -0.11156829f, 
    -0.09938711f, 0.09536452f, 0.02976095f, 0.09693027f, 0.01216493f, 0.11162751f, -0.09289926f, -0.01892778f, 
    -0.00593694f, 0.15256976f, -0.26042300f, -0.08081908f, -0.03136864f, 0.00425466f, 0.30409610f, -0.09517292f, 
    0.06997094f, -0.00804353f, 0.02420474f, 0.09111802f, -0.06001976f, -0.27130094f, 0.18734768f, 0.05695565f, 
    -0.25615296f, -0.13841066f, -0.33833590f, -0.08012409f, 0.04889210f, 0.01962462f, -0.00175292f, -0.27044863f, 
    0.01662579f, -0.04187475f, 0.10853329f, 0.09518076f, -0.14586720f, 0.22845803f, 0.14667429f, 0.08633585f, 
    -0.00026430f, 0.15669142f, 0.06110488f, -0.06347664f, -0.06527496f, -0.02203803f, 0.05284685f, -0.10116880f, 
    0.35911131f, 0.00136541f, 0.20447391f, 0.07100170f, 0.09340381f, -0.26662868f, 0.02388644f, 0.10678470f, 
    -0.11698330f, 0.08008215f, -0.18270864f, -0.00076344f, -0.14996587f, 0.10230330f, -0.04524344f, -0.04837677f, 
    -0.16158269f, 0.03364697f, 0.01545895f, -0.13273226f, -0.26558313f, -0.18742578f, 0.05549148f, 0.10888294f, 
    -0.03684596f, 0.15857667f, 0.11612813f, -0.15387532f, -0.08652318f, -0.05653607f, -0.01631488f, -0.04057663f, 
    -0.00363757f, 0.13692251f, -0.03774008f, -0.08560964f, 0.02587053f, 0.48084295f, -0.12218478f, 0.28117362f, 
    -0.00471831f, 0.06897094f, -0.00173581f, 0.01078072f, 0.05722760f, 0.13851787f, 0.02160182f, 0.12138823f, 
    -0.28536201f, -0.29903707f, -0.07134473f, -0.25310397f, -0.26123017f, -0.11157084f, 0.20962779f, -0.01324598f, 
    -0.00566700f, 0.06128722f, 0.14904292f, -0.06907655f, -0.21804957f, 0.16728224f, -0.02446931f, 0.32174456f, 
    0.00709558f, -0.04679999f, 0.01683226f, -0.04124155f, -0.05785249f, -0.08958368f, 0.01399128f, -0.04257919f, 
    0.42317384f, -0.28913862f, 0.00724025f, -0.00857130f, -0.22207998f, 0.06530812f, 0.01662642f, -0.17668906f, 
    -0.05340704f, 0.09019168f, -0.18697517f, -0.00867699f, -0.48574790f, 0.24305472f, -0.02754966f, -0.01730877f, 
    0.06148958f, 0.08581096f, -0.20526800f, -0.05819490f, 0.02782647f, 0.08323387f, -0.26577041f, -0.35548005f, 
    0.19290905f, -0.14410985f, 0.05928499f, -0.00215514f, -0.03689015f, -0.05363847f, -0.13047829f, 0.00426583f, 
    -0.10974669f, 0.10382036f, -0.04635610f, -0.23435012f, -0.77563196f, -0.05422193f, -0.21422340f, 0.16553503f, 
    -0.08321334f, 0.04425365f, -0.11746363f, -0.00551825f, 0.16077602f, -0.04614670f, 0.14328142f, 0.14052761f, 
    -0.08838937f, 0.21454906f, 0.15895288f, -0.07435215f, -0.11896165f, 0.01367017f, 0.08701345f, -0.05669942f, 
    -0.00208892f, 0.07348294f, 0.11377330f, 0.09475093f, 0.19928168f, -0.42647690f, 0.23256961f, 0.10384080f, 
    -0.09211182f, 0.04066171f, 0.06873418f, 0.00383493f, 0.03872669f, 0.09759039f, 0.11411243f, 0.06704961f, 
    -0.29994413f, 0.00707025f, -0.15704788f, -0.05113925f, -0.12049579f, -0.08959541f, 0.18367685f, 0.03612367f, 
    0.02299367f, 0.08168772f, 0.02772899f, -0.00752306f, -0.12564881f, -0.34997165f, -0.11815179f, -0.03884595f, 
    -0.09138880f, 0.04409740f, -0.04125822f, 0.02914486f, 0.07692869f, -0.01490444f, -0.03586370f, 0.11058750f, 
    -0.17576917f, 0.03378903f, 0.13607201f, -0.01050040f, -0.06819075f, 0.08370262f, 0.00486592f, 0.04424615f, 
    -0.04118308f, -0.04564574f, 0.17223305f, 0.23166811f, -0.23186770f, 0.28974071f, -0.20768324f, -0.03388569f, 
    -0.05031272f, -0.05141704f, 0.18108954f, -0.09447395f, -0.20729223f, 0.09380595f, 0.03823855f, 0.13061267f, 
    0.15621422f, -0.41454515f, 0.02568641f, 0.11687900f, -0.09684297f, 0.13460837f, -0.04371611f, 0.02571833f, 
    -0.12019601f, 0.03637191f, -0.10929817f, -0.05145714f, -0.07090610f, -0.09326161f, -0.13103484f, 0.08799875f, 
    -0.01286810f, 0.06689709f, 0.04835648f, 0.03131186f, 0.01073914f, -0.08008737f, -0.10650538f, 0.01778387f, 
    -0.31177989f, -0.22535372f, -0.14812329f, 0.12770061f, 0.04261453f, 0.06890193f, -0.05938356f, -0.00440932f, 
    -0.06669635f, -0.08235767f, 0.05386143f, 0.02085669f, -0.18055579f, 0.02894037f, 0.11448894f, -0.09494562f, 
    -0.03025667f, -0.14733568f, 0.18455109f, 0.02357992f, 0.07340736f, -0.10594433f, 0.21055362f, 0.10502065f, 
    -0.07462168f, 0.15081616f, 0.02738905f, 0.11179124f, -0.18520600f, 0.03957354f, -0.09493353f, 0.06975544f, 
    0.03616569f, -0.12091944f, 0.02146448f, 0.22203183f, 0.16732726f, -0.61528891f, -0.16315229f, 0.22159894f, 
    -0.00602577f, -0.18642506f, -0.01040768f, 0.13421889f, -0.06118154f, -0.04825452f, 0.04535320f, 0.14506617f, 
    0.17344086f, 0.12160274f, 0.19348809f, 0.05552899f, -0.11354147f, 0.05841371f, 0.12362948f, -0.07105669f, 
    -0.05900547f, 0.07216717f, -0.02463062f, 0.00995908f, -0.39679694f, 0.39544991f, -0.09046851f, 0.11240701f, 
    0.10378814f, 0.02569927f, -0.05022008f, -0.12195794f, -0.03618756f, 0.09730000f, 0.01691633f, -0.08520854f, 
    0.13008399f, -0.22480367f, 0.11410570f, -0.03934087f, -0.05642932f, -0.02072447f, -0.00592254f, -0.05105011f, 
    -0.09502426f, -0.07937304f, -0.11937603f, -0.03105825f, 0.16325633f, 0.06965490f, 0.10297740f, -0.05504714f, 
    0.02432282f, 0.13185802f, -0.07470594f, 0.05398815f, -0.17468120f, -0.18978019f, -0.20869324f, -0.32634121f, 
    -0.13089976f, 0.05501274f, 0.02174222f, 0.47973800f, -0.01961792f, 0.03862705f, 0.07051067f, 0.15224561f, 
    0.04544931f, -0.19299136f, 0.05878609f, -0.17181075f, -0.05773613f, 0.03677293f, -0.03152054f, 0.00776458f, 
    -0.08982708f, -0.03591794f, -0.07192405f, -0.00941973f, -0.04489242f, 0.02988525f, -0.05953497f, -0.04345755f, 
    0.23823971f, -0.19300790f, 0.06558556f, -0.09977296f, -0.16817553f, -0.11783478f, -0.00782167f, -0.07448244f, 
    -0.04041470f, -0.19110441f, -0.22670147f, -0.04432195f, -0.09153645f, 0.17060156f, -0.02695476f, -0.09955730f, 
    -0.01593367f, -0.20071709f, -0.02629001f, -0.14047603f, -0.19974254f, 0.11340961f, 0.10872021f, -0.06861434f, 
    0.05058438f, -0.08439974f, -0.06000450f, -0.02856793f, -0.07997050f, -0.02842984f, 0.22582217f, -0.29950929f, 
    -0.02469432f, 0.16148156f, -0.06220555f, 0.00758332f, -0.04063630f, 0.11280244f, 0.02368764f, 0.14289276f, 
    -0.13721319f, 0.06284030f, 0.08149787f, 0.07154219f, 0.17999338f, -0.05921938f, 0.25022623f, 0.19045016f, 
    -0.15632083f, -0.11293669f, -0.04218252f, 0.02032213f, -0.07115255f, 0.09189592f, -0.06849313f, -0.05671575f, 
    -0.01265948f, 0.04093099f, 0.15951483f, 0.03972705f, 0.01369102f, 0.22278462f, -0.24329621f, 0.04671321f, 
    -0.02636222f, -0.04434039f, 0.18800591f, -0.03437205f, -0.23935093f, -0.08335552f, -0.43618321f, -0.03973206f, 
    -0.14124312f, -0.23063034f, -0.21147783f, -0.29773584f, 0.06003960f, -0.07864696f, -0.04398573f, -0.06956457f, 
    -0.01888781f, 0.05865326f, 0.05611454f, 0.10213961f, 0.19960387f, -0.04003201f, 0.16663623f, -0.03139848f, 
    -0.20166203f, 0.11375841f, -0.18279991f, -0.05246153f, 0.02750633f, -0.01283123f, 0.10710737f, 0.09346251f, 
    -0.05343790f, -0.04044235f, -0.01783864f, -0.13672306f, 0.01696493f, 0.01194858f, -0.04727861f, -0.05662994f, 
    -0.00147247f, -0.02944794f, 0.06723271f, 0.01724253f, -0.15749231f, 0.16352257f, -0.01205056f, 0.02396048f, 
    -0.34874433f, 0.27573243f, -0.05820060f, -0.08382012f, 0.01823403f, -0.02191383f, 0.03008899f, -0.02093921f, 
    -0.22344223f, 0.26762754f, -0.21894968f, 0.34251180f, 0.02617117f, 0.01069327f, 0.07189842f, 0.11729196f, 
    -0.07183596f, 0.16757588f, 0.00255326f, 0.05584129f, 0.03737121f, 0.05620232f, 0.26989427f, 0.18653463f, 
    -0.05616326f, 0.05968668f, 0.16811635f, -0.00740421f, -0.23136984f, -0.03998592f, 0.19353238f, 0.05737917f, 
    -0.11959551f, 0.14687386f, -0.20524018f, 0.14705093f, -0.05450802f, 0.08832181f, 0.01365438f, 0.01209978f, 
    -0.05340483f, -0.05568271f, 0.09737458f, -0.00259081f, -0.08972534f, -0.24834247f, 0.03997420f, 0.06401027f, 
    0.13721134f, -0.08105892f, -0.03102958f, -0.18894771f, -0.02101638f, 0.03954530f, -0.01721508f, -0.20094770f, 
    0.00846810f, 0.04355932f, -0.11750264f, 0.04637111f, 0.05429952f, -0.06901781f, -0.02324204f, 0.21237074f, 
    -0.27935505f, -0.04666686f, -0.05289107f, -0.24629870f, 0.30467314f, -0.13847971f, 0.22637324f, 0.08479349f, 
    0.05578632f, 0.08414304f, -0.16435239f, 0.14171927f, -0.11351835f, 0.17154902f, 0.03481435f, 0.02629811f, 
    -0.15407002f, -0.06908428f, -0.01452805f, -0.06106314f, -0.01504320f, 0.01247985f, -0.06391392f, 0.03764014f, 
    -0.19492622f, 0.06996451f, -0.09793213f, -0.07505353f, -0.32164854f, 0.11364808f, -0.24685216f, 0.06591988f, 
    -0.03036083f, -0.10752538f, 0.05256239f, -0.00739453f, 0.06273804f, -0.07882888f, 0.14608623f, 0.24511141f, 
    -0.07788747f, -0.02118262f, 0.04371761f, 0.03119437f, 0.07086707f, -0.05263610f, -0.06149852f, -0.01267393f, 
    0.02918719f, -0.09607859f, -0.06893437f, -0.02549377f, -0.28901112f, 0.01053587f, -0.48267910f, -0.05140114f, 
    0.05629141f, 0.02544656f, -0.01341834f, -0.08968756f, -0.11306914f, 0.06918341f, 0.05229235f, -0.09810714f, 
    -0.36192608f, 0.15167464f, -0.05293364f, -0.02465739f, -0.13999894f, -0.02661468f, 0.10932745f, 0.03634025f, 
    -0.08246804f, -0.04067529f, -0.04442929f, 0.06178694f, -0.14313832f, -0.57935834f, 0.29311374f, 0.00143112f, 
    -0.16446745f, -0.14986141f, -0.24843031f, 0.02635134f, 0.04582326f, -0.08801911f, 0.08687267f, 0.05820371f, 
    -0.14211282f, 0.00289545f, -0.03445902f, -0.07006138f, -0.05617407f, -0.15978557f, -0.15373914f, -0.16982234f, 
    0.14065038f, -0.02973816f, -0.06152198f, -0.13443673f, -0.43501675f, 0.02080853f, -0.06594563f, 0.25070265f, 
    -0.05366774f, 0.05168735f, 0.00705739f, 0.21910217f, -0.19785951f, -0.03695118f, 0.02867794f, -0.04627502f, 
    -0.43289191f, 0.48787004f, -0.31427073f, -0.04641964f, -0.04343921f, 0.13611239f, 0.11912652f, -0.13709824f, 
    0.04826375f, -0.05593189f, 0.19563782f, -0.08047348f, 0.06647099f, -0.56568646f, 0.08513805f, 0.14937428f, 
    0.14072627f, -0.15967259f, 0.05515917f, 0.00274307f, 0.01486784f, 0.04018109f, 0.00233096f, -0.01701353f, 
    -0.08510111f, 0.05860483f, 0.03295303f, 0.03360144f, 0.10246409f, 0.06349941f, 0.16401750f, -0.08992954f, 
    0.07109366f, -0.01941536f, 0.06248368f, 0.14034051f, 0.13541625f, 0.21463490f, -0.18882939f, 0.08372244f, 
    -0.04926019f, 0.09874239f, -0.07131060f, 0.02392745f, 0.02230713f, -0.01458287f, 0.00442770f, -0.00654674f, 
    -0.03577773f, -0.28254297f, -0.02607162f, -0.42040727f, 0.07865644f, -0.13653305f, -0.08252805f, -0.00152914f, 
    0.01275676f, 0.13713981f, 0.15068778f, 0.16184460f, -0.02506080f, -0.03842552f, 0.33594787f, 0.07186146f, 
    0.21418124f, 0.04074318f, 0.00813186f, 0.04500725f, -0.07056790f, -0.05111422f, 0.02534353f, 0.00564240f, 
    0.00075804f, -0.43910807f, 0.41697630f, -0.31828085f, 0.04522389f, -0.13025622f, 0.27038422f, -0.02787230f, 
    0.14718121f, 0.16705111f, 0.01309932f, -0.05784078f, -0.21125475f, -0.06029702f, -0.41820818f, 0.08192888f, 
    0.02533336f, -0.24880923f, -0.02069203f, -0.20393819f, 0.00114498f, 0.02210787f, -0.01349847f, -0.02527492f, 
    -0.40877834f, -0.05402836f, -0.30456400f, 0.25413287f, 0.14720075f, -0.09424911f, 0.02898748f, -0.00220256f, 
    -0.00073913f, -0.16421077f, 0.02158063f, 0.07481292f, 0.02731223f, -0.25116634f, 0.19287252f, -0.14261660f, 
    -0.06858554f, 0.04015052f, -0.00627830f, 0.00447268f, -0.10245533f, 0.00491260f, 0.33710811f, -0.08433721f, 
    -0.16173071f, 0.08971398f, -0.14142811f, 0.10888816f, -0.03656172f, -0.01307733f, 0.03598920f, -0.07650817f, 
    -0.07581814f, 0.12221878f, -0.03503964f, -0.17556198f, -0.18487711f, 0.02748222f, -0.08187914f, 0.14887056f, 
    0.04376442f, -0.09216532f, 0.18760589f, 0.03083762f, 0.05140297f, -0.00450475f, -0.18363178f, -0.19922431f, 
    -0.37557346f, 0.60843515f, -0.51038188f, -0.01900633f, -0.17385559f, 0.06307592f, 0.12818396f, 0.02031654f, 
    -0.06640249f, -0.01456608f, 0.03976182f, 0.03363890f, 0.37970310f, 0.12519181f, -0.02610988f, -0.01747421f, 
    0.05120137f, -0.07690141f, -0.09060131f, 0.06568349f, -0.01922011f, 0.16663706f, 0.02275128f, -0.00882135f, 
    -0.30958536f, -0.11439777f, -0.21028922f, 0.04551383f, 0.08165058f, 0.07397939f, -0.09665290f, 0.15129951f, 
    -0.06254596f, 0.00623667f, 0.01367667f, -0.03321750f, -0.26456529f, 0.01566703f, 0.07488123f, 0.13129282f, 
    0.15918767f, -0.14159249f, -0.00869994f, -0.19366348f, 0.01354980f, 0.07292160f, -0.00426023f, -0.15798190f, 
    0.51486838f, 0.28389418f, 0.26098403f, 0.04202723f, -0.10080418f, 0.17862993f, -0.15748143f, 0.07764468f, 
    -0.14956842f, -0.00874573f, -0.07817712f, 0.00315040f, -0.04542121f, -0.07266933f, 0.02460383f, 0.31958726f, 
    -0.07951954f, 0.09137190f, -0.02206509f, 0.15475574f, -0.18305737f, 0.15043817f, 0.02638722f, 0.01870714f, 
    -0.02669455f, -0.25484821f, 0.27974972f, -0.27488402f, -0.00609257f, -0.07183603f, -0.18993154f, -0.09017539f, 
    0.03567030f, -0.20823336f, 0.06836212f, 0.02221277f, -0.03371018f, -0.11119235f, -0.32053453f, 0.05741649f, 
    0.05918535f, -0.11276881f, 0.10880737f, 0.00607897f, 0.00733032f, 0.09675458f, 0.06243652f, 0.13676204f, 
    0.06937671f, 0.09512357f, 0.05210804f, -0.06585550f, -0.11580415f, 0.11110850f, 0.20676412f, -0.00583235f, 
    -0.05055559f, 0.02574301f, 0.02323204f, -0.03116672f, 0.35638022f, 0.32422653f, 0.19266869f, -0.02226667f, 
    -0.12637331f, 0.01406467f, -0.01623763f, 0.11551758f, -0.07137129f, 0.08191269f, -0.05777594f, -0.07872281f, 
    0.12758160f, -0.05153806f, -0.00790616f, -0.03764597f, 0.00173904f, 0.11261656f, 0.14614168f, 0.07171807f, 
    -0.01032072f, 0.06572745f, -0.06713720f, -0.18608867f, -0.11424792f, -0.14911996f, 0.30636209f, -0.01733863f, 
    -0.09177133f, 0.18090029f, 0.01033937f, -0.10080095f, -0.01646440f, 0.04103692f, 0.04291339f, 0.01542275f, 
    -0.04949404f, 0.07306454f, 0.13751249f, -0.01171283f, -0.13152553f, -0.03888419f, 0.08114620f, -0.22782516f, 
    0.06728209f, 0.07288080f, 0.05528337f, 0.07542824f, 0.01313056f, -0.16074640f, -0.09999342f, -0.28541812f, 
    -0.14962791f, -0.14893265f, -0.17174751f, -0.11551344f, 0.00490402f, 0.03462738f, -0.04125172f, -0.10515111f, 
    0.07128982f, 0.04682194f, 0.04832773f, -0.04530537f, 0.02448542f, 0.05218999f, -0.01602096f, 0.19054653f, 
    -0.00251957f, 0.05293602f, 0.02016259f, -0.15694687f, -0.32978737f, -0.15899749f, -0.17153518f, 0.24753961f, 
    0.09308843f, -0.30412373f, 0.14668010f, -0.10267597f, 0.07682662f, 0.01357642f, 0.01419936f, -0.09627925f, 
    0.13423474f, 0.02655928f, 0.40101990f, -0.13845742f, -0.12766136f, 0.10135733f, -0.08301529f, -0.03605469f, 
    -0.11151076f, 0.05596438f, 0.24744692f, 0.13960102f, -0.09161665f, 0.01050240f, -0.17213625f, -0.04326663f, 
    0.05059877f, -0.01250505f, 0.10251199f, -0.04238058f, -0.00447454f, 0.01432843f, 0.05074672f, 0.00837320f, 
    -0.06057449f, -0.15341550f, -0.04448337f, 0.13785389f, -0.19157290f, -0.18465601f, 0.01409308f, 0.06839382f, 
    -0.02629399f, -0.00829994f, -0.09215645f, -0.04572166f, 0.23015000f, 0.02688904f, 0.41898760f, -0.02727196f, 
    -0.00552583f, 0.02874978f, 0.01702442f, 0.06892545f, -0.18676813f, 0.06089022f, -0.05339113f, -0.05868588f, 
    -0.54029465f, 0.14856249f, -0.13388169f, 0.01124293f, -0.03130665f, 0.12588716f, -0.07387160f, 0.03582678f, 
    -0.19898576f, -0.08388069f, -0.08432991f, 0.02726104f, -0.13036884f, 0.02443064f, 0.10083536f, -0.18761727f, 
    -0.09343913f, 0.02362629f, -0.05716992f, -0.04637279f, 0.02743445f, 0.02731949f, -0.01879494f, -0.13898806f, 
    0.08583142f, 0.10445835f, 0.07466993f, -0.08651326f, 0.03293027f, 0.14077441f, 0.00140258f, 0.08846289f, 
    0.05625154f, 0.16692196f, 0.17342654f, -0.02207987f, -0.35672280f, 0.18695246f, -0.63574642f, 0.43180165f, 
    0.22786248f, -0.04985682f, 0.13478322f, -0.14934015f, -0.04846951f, 0.04443843f, 0.04342695f, 0.09272815f, 
    0.27038243f, -0.00259004f, 0.15291928f, -0.18203074f, -0.05952881f, 0.00862292f, -0.06420917f, -0.01515367f, 
    0.05593299f, 0.06284066f, 0.04515278f, -0.00500344f, -0.02417503f, -0.04912468f, -0.00897817f, 0.04785118f, 
    0.05424035f, 0.06584106f, 0.04855122f, -0.02509872f, -0.05302679f, 0.09988364f, 0.27444297f, 0.18750472f, 
    -0.46042719f, -0.11911634f, 0.36613968f, 0.21826823f, -0.10340931f, -0.07663873f, 0.19640566f, 0.02566664f, 
    -0.04602954f, 0.10827980f, -0.07847691f, -0.10057091f, 0.18728212f, 0.13720237f, 0.09550296f, 0.01577948f, 
    -0.10050512f, -0.08923840f, 0.08353507f, 0.01398518f, -0.08518716f, -0.02075792f, -0.00813753f, -0.06244176f, 
    0.19982421f, 0.03622087f, 0.04899283f, -0.26964763f, 0.00350928f, 0.03119830f, -0.06436893f, 0.06222814f, 
    0.02840036f, 0.19972262f, 0.11838137f, 0.04080351f, -0.21420906f, -0.00641078f, -0.16515635f, 0.04161337f, 
    -0.01248076f, -0.03863437f, -0.01832604f, -0.00583673f, 0.03970204f, -0.08880780f, -0.09981176f, -0.11409495f, 
    0.45789632f, -0.09842136f, 0.45800939f, -0.05845613f, -0.01416592f, -0.03118830f, -0.29136455f, 0.09651440f, 
    -0.03534540f, -0.04758789f, 0.03862931f, -0.04144627f, -0.19464341f, -0.14712842f, -0.08904393f, 0.00673918f, 
    0.04463336f, -0.07604855f, -0.12774944f, 0.03325915f, -0.16285445f, -0.04973505f, 0.05206627f, -0.20115913f, 
    0.09844916f, 0.15396260f, -0.03109199f, 0.02762740f, -0.08199347f, 0.00987823f, -0.02067827f, 0.00478803f, 
    0.01895038f, 0.00264952f, 0.04863617f, -0.00872061f, -0.29114386f, -0.23556392f, -0.08285627f, 0.29820067f, 
    0.03897550f, -0.04658170f, 0.15775011f, -0.05683782f, -0.07995532f, 0.04104579f, 0.05146375f, 0.07236828f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13288233f, 0.03598341f, 0.09128303f, -0.07063213f, -0.11766110f, 0.04514840f, -0.00334180f, -0.14609405f, 
    0.08685797f, 0.02980729f, -0.00243039f, -0.00400161f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
