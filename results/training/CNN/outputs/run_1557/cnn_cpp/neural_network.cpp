#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.09705913f, -0.71856850f, -0.68183064f, -0.29468226f, -0.38567895f, -0.03340431f, -0.00177524f, 0.04727745f, 
    0.14978968f, -0.26078618f, -0.51463312f, -0.20307536f, 0.53781092f, -0.39292890f, 0.23623918f, 0.00746682f, 
    -0.18213318f, 0.73658276f, 0.42431584f, -0.28914413f, -0.65711170f, -0.25125980f, -0.08796726f, -0.44768655f, 
    0.16720027f, 0.45590335f, 0.55922061f, -0.32542217f, 0.42572001f, -0.06218537f, 0.40870622f, 0.40652731f, 
    0.24703500f, 0.19768324f, 0.39913315f, -0.06586405f, -0.00417725f, 0.08546448f, 0.19777270f, -0.66246825f, 
    -0.82788002f, -0.83223170f, 0.18578222f, -0.34613836f, -0.34849048f, 0.79959881f, 0.09827838f, 0.58619100f, 
    0.15658134f, -0.38893998f, -0.05662100f, 0.36548302f, 0.25397456f, 0.42973492f, 0.79427308f, -0.76755130f, 
    -0.51924819f, 0.44643962f, -0.33853218f, 0.39709356f, -0.23125587f, 0.09845433f, -0.55625230f, -1.21102273f, 
    0.69702351f, 0.43736646f, -0.56402081f, 0.29076114f, -0.47513384f, -0.11663970f, 0.13708372f, 0.23880616f, 
    0.55098045f, 0.38462573f, 0.20100896f, -0.24983315f, 0.22886708f, 0.27609247f, 0.44065493f, -0.51715636f, 
    -0.46803826f, -0.35040301f, 0.19248398f, 0.62904042f, -0.81549788f, -0.50718057f, 0.65177143f, 0.30828550f, 
    0.02994086f, 0.08229084f, -0.73729932f, -0.45669967f, -0.50681746f, 0.30927765f, -0.05684735f, -0.02876495f, 
    0.44434994f, 0.46349943f, 0.13301085f, 0.15713385f, 0.24195805f, 0.36791876f, 0.00043070f, 0.64352709f, 
    -0.68681973f, -0.25436705f, 0.00246082f, -0.52037823f, -0.44894472f, 0.39607537f, 0.25352815f, 0.52154642f, 
    0.33759841f, 0.28925100f, -0.00767128f, 0.08719059f, -0.32405171f, -0.13192275f, -0.51210117f, -0.16125321f, 
    -0.23025011f, 0.42461857f, 0.72000241f, 0.02457596f, 0.16068465f, 0.54645389f, -0.22983983f, -0.13827087f, 
    0.11155754f, 0.61810994f, -0.56198287f, 0.77024627f, -0.08386314f, -0.00063923f, -0.29679084f, -1.13263714f, 
    -0.94688284f, 0.58681411f, 0.61346072f, -0.40506750f, -0.62867576f, 0.13579760f, -0.25742334f, 0.01121841f, 
    -0.65241355f, -0.28657573f, -0.41732407f, -0.15021959f, -0.13885921f, -0.56377000f, -0.15498263f, 0.41974461f, 
    -0.62015373f, 0.43921873f, -0.02046270f, -0.70751864f, 0.13962446f, 0.69249600f, 0.60231328f, -0.34775051f, 
    0.11779605f, -0.20306648f, -0.08667534f, 0.10700304f, 0.00389826f, -0.53500664f, -0.76539361f, -0.54219532f, 
    -0.20788880f, 0.41968289f, 0.40622088f, 0.66731173f, -0.04680818f, 0.37556019f, -0.65070736f, 0.47135812f, 
    -0.42131674f, -0.08122233f, -0.00419963f, 0.40791482f, -0.62493223f, -0.42932841f, -0.54235417f, 0.32397011f, 
    0.60970867f, 0.55509216f, -0.01647977f, -0.37427437f, -0.35803556f, -0.33305040f, 0.39703247f, 0.65159506f, 
    0.50285566f, -0.33810082f, -0.32786098f, 0.15296181f, -0.43539235f, -0.13682523f, -0.62571055f, -0.34232292f, 
    -0.57862079f, 0.07793679f, 0.51075852f, -0.75011653f, -0.36561045f, -0.29769582f, -0.04542892f, -0.29241696f, 
    0.89121866f, -0.58277756f, -0.39942792f, 0.34491235f, -0.10131083f, 0.40716898f, -0.56450373f, 0.33655474f, 
    -0.36875960f, 0.16040273f, -0.09189225f, 0.37480256f, 0.52673364f, -0.04817274f, 0.29095238f, -0.13393810f, 
    0.52079499f, 0.29809490f, 0.64348590f, 0.19430250f, -0.47396126f, -0.07935325f, -0.00195808f, -0.12348454f, 
    0.50749916f, -0.29021692f, -0.46462840f, -0.37640285f, -0.45985228f, -0.32751015f, -0.39767480f, -0.15660010f, 
    0.47929907f, 0.34765249f, 0.56565541f, -0.41452190f, -0.43976879f, -0.54090130f, 0.98713505f, 0.01157798f, 
    -0.34204417f, -0.56882834f, -0.46221632f, -0.14869857f, 0.19770801f, -0.02549591f, -0.75964665f, -0.58130008f, 
    -0.58940524f, -0.36815447f, -0.40965685f, -0.48354933f, -0.40260968f, 0.58258808f, -0.51251835f, 0.00863656f, 
    0.14473601f, -0.13439453f, 0.22480488f, 0.54967684f, -0.37991437f, -0.25966099f, -0.21006517f, -0.02795048f, 
    0.48676896f, -0.33045694f, -0.40342882f, -0.41202563f, 0.55857825f, 0.34702986f, 0.42072958f, -0.44650120f, 
    -0.20792213f, 0.19890703f, -0.50568330f, -0.38853464f, 1.09490573f, 0.11607476f, 0.00985424f, 0.01342066f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22285527f, -0.09747099f, -0.14482549f, -0.23832197f, 0.04963057f, -0.05848990f, -0.10263653f, -0.05239604f, 
    -0.13377261f, 0.02909012f, 0.52983105f, 0.06246992f, -0.06623501f, 0.46625513f, -0.04518377f, 0.02755263f, 
    -0.18688002f, 0.15656598f, 0.23268989f, 0.31803179f, -0.03727625f, 0.44350466f, -0.34938121f, -0.06062770f, 
    0.13888459f, 0.08701118f, 0.33431825f, 0.15726085f, -0.11392882f, 0.53932548f, -0.18981060f, -0.04750789f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.24449451f, -0.15288907f, 0.10024957f, 0.02357670f, 0.14412628f, -0.08163218f, -0.12069405f, -0.14394459f, 
    0.09004555f, 0.24780677f, 0.04754075f, -0.01458019f, 0.04588209f, 0.07778688f, -0.17637923f, 0.11074260f, 
    -0.04518287f, 0.04446704f, -0.11238362f, 0.11851826f, 0.18904379f, 0.05914434f, 0.07151762f, -0.21956553f, 
    -0.04684062f, -0.04734109f, -0.13999520f, 0.04822331f, 0.10681510f, -0.01918275f, 0.07954361f, 0.13429068f, 
    0.10278611f, -0.04545920f, -0.11448843f, -0.24407056f, -0.00207359f, 0.11446895f, 0.14477862f, 0.04691197f, 
    -0.03961772f, -0.05154351f, 0.07023852f, 0.11905113f, 0.06382218f, 0.07893654f, 0.07859891f, -0.14062439f, 
    -0.02668855f, 0.00373453f, 0.05275781f, -0.00625997f, 0.12195207f, -0.20834439f, 0.03693005f, -0.02121517f, 
    0.23599000f, 0.07701591f, -0.05084649f, 0.25737417f, -0.08455612f, 0.07772171f, 0.43205595f, 0.15391712f, 
    0.14741731f, -0.21041420f, 0.01365265f, 0.03678382f, -0.11266112f, -0.05029938f, -0.22469884f, 0.05610285f, 
    -0.08847578f, -0.16185285f, -0.13581575f, -0.02959081f, 0.14433518f, 0.03328373f, 0.13877596f, -0.03904733f, 
    0.10871296f, 0.10233252f, -0.07574723f, -0.20470250f, -0.07186223f, 0.10189625f, -0.00478746f, 0.05536376f, 
    0.18248509f, -0.09930675f, 0.05979631f, -0.02902787f, -0.08272456f, 0.08121537f, -0.03577030f, -0.10119104f, 
    0.08531334f, -0.11396398f, -0.07824904f, -0.20018928f, -0.00735421f, -0.14102168f, 0.06653497f, 0.11743464f, 
    0.07703796f, 0.08026278f, 0.10644282f, 0.05645218f, 0.13841110f, 0.25369963f, -0.00250605f, 0.10692360f, 
    -0.00207642f, 0.09472114f, -0.01281597f, -0.10750698f, -0.11652880f, -0.03563868f, -0.00187664f, 0.03035419f, 
    0.08894076f, 0.05693120f, -0.00942519f, -0.13106804f, -0.09367162f, -0.15165636f, 0.19043933f, 0.00626377f, 
    0.07266168f, 0.04301339f, 0.05867597f, 0.09091145f, -0.06000617f, 0.29603940f, 0.06341182f, 0.05586612f, 
    0.01184759f, -0.28164697f, -0.01728827f, 0.06008413f, -0.08534577f, 0.03956228f, -0.11788365f, -0.01061985f, 
    0.16582775f, -0.08924274f, -0.20385635f, 0.16234139f, 0.16831981f, -0.13850248f, 0.02883617f, -0.01169386f, 
    0.15233585f, 0.01664516f, 0.02213337f, 0.03145024f, -0.08405823f, 0.08571826f, 0.12004082f, -0.19407791f, 
    0.11248094f, -0.07653842f, -0.03206884f, 0.06620570f, -0.05532188f, 0.22376876f, -0.04138074f, 0.09630995f, 
    0.01494341f, -0.04090178f, -0.12691481f, -0.25890213f, -0.07655212f, 0.03833146f, 0.00313993f, 0.06100759f, 
    0.04987583f, 0.01223341f, 0.02747733f, 0.00279830f, 0.15247600f, -0.00749227f, -0.10261615f, 0.10017338f, 
    -0.01286309f, 0.15493193f, 0.01458314f, 0.16733089f, 0.19451149f, -0.03733404f, 0.02315877f, -0.01470625f, 
    -0.00590648f, 0.01058528f, -0.04126228f, -0.04501468f, 0.02371461f, -0.04549737f, 0.09258211f, 0.06009487f, 
    -0.33769172f, 0.11696639f, -0.13997237f, -0.00922657f, -0.05589124f, 0.01831076f, 0.12203862f, -0.00878041f, 
    0.05123645f, 0.16539615f, 0.02228593f, -0.09347098f, -0.07924674f, -0.07670580f, -0.17405482f, 0.14106387f, 
    0.06825148f, -0.07734858f, -0.05502939f, 0.10860693f, -0.02265149f, 0.03126264f, -0.19984129f, -0.19354542f, 
    -0.09761146f, -0.04068428f, -0.13190235f, -0.16924749f, -0.25210202f, 0.13206087f, 0.13456491f, 0.03220095f, 
    0.16423185f, -0.04070518f, 0.00964273f, 0.01909791f, -0.05126536f, 0.14855462f, 0.08287733f, -0.09777835f, 
    0.15944646f, -0.01987473f, -0.14987092f, 0.03102340f, -0.07882015f, -0.15381552f, 0.03376195f, -0.05473391f, 
    -0.13835731f, -0.07269609f, 0.17576647f, 0.30883443f, 0.08588432f, -0.11030446f, 0.15502037f, -0.01313699f, 
    -0.06666277f, -0.28273624f, -0.06201809f, -0.03727860f, 0.10613985f, -0.23843314f, -0.22640224f, -0.04583206f, 
    -0.14681035f, -0.05626129f, 0.00243624f, 0.04370599f, 0.00348785f, 0.03839527f, -0.01263621f, 0.03923927f, 
    0.00936278f, 0.25382671f, 0.06372304f, -0.05663645f, 0.06770590f, -0.16967292f, -0.18863182f, 0.30397245f, 
    0.15413822f, -0.00032955f, -0.06924699f, -0.01324049f, 0.03795457f, 0.27240989f, 0.29634532f, 0.06184460f, 
    0.12403778f, -0.17845197f, -0.60057002f, 0.17053567f, 0.11223606f, -0.09336314f, 0.05578645f, -0.02903223f, 
    0.25556195f, 0.31370428f, 0.16415076f, -0.23410359f, -0.08860995f, 0.14116000f, 0.11565907f, 0.15959027f, 
    0.07658075f, -0.10148425f, -0.04833943f, -0.13693590f, -0.37965298f, 0.19967949f, 0.07923856f, 0.03053696f, 
    0.04852063f, -0.04123246f, 0.16871516f, 0.01545443f, 0.13280308f, 0.05031733f, -0.08772098f, 0.05590137f, 
    -0.04029677f, -0.05793631f, -0.07101144f, -0.11843814f, -0.18021987f, -0.16092983f, -0.07798840f, 0.10288707f, 
    0.07541524f, 0.14926833f, 0.22221953f, -0.07383709f, 0.07096984f, -0.11914134f, -0.07227877f, 0.07109044f, 
    -0.00793390f, -0.12457670f, 0.00311161f, -0.15060143f, -0.03445114f, 0.09429047f, 0.21081038f, 0.06752991f, 
    -0.34861487f, 0.03212067f, 0.05821245f, 0.02809900f, -0.13547321f, 0.04716477f, -0.07642128f, -0.04212527f, 
    -0.20098896f, 0.42058229f, -0.06159017f, 0.09269124f, 0.02127707f, 0.12500383f, -0.00372085f, 0.19019033f, 
    0.11258636f, 0.14768192f, -0.06069535f, -0.06448875f, -0.04105248f, 0.02202028f, 0.20087402f, 0.05799706f, 
    -0.12372753f, -0.08818550f, -0.12193686f, 0.13504389f, -0.03230706f, -0.01786933f, 0.02793015f, -0.01639552f, 
    -0.03377702f, 0.03206602f, 0.17684437f, 0.22162117f, -0.04498619f, 0.02784722f, 0.02603089f, 0.02943649f, 
    0.10594516f, 0.09155893f, 0.05729312f, 0.05154178f, 0.12661175f, 0.07830598f, 0.13152124f, 0.08162892f, 
    -0.03282724f, -0.06995916f, 0.12105044f, 0.00954972f, 0.11853526f, 0.04313139f, 0.15765738f, -0.11368096f, 
    0.00104210f, -0.27856323f, -0.02940772f, -0.22550508f, -0.10040193f, 0.20324822f, 0.08864678f, -0.11691196f, 
    -0.13674533f, 0.03764491f, 0.09837306f, 0.08584639f, -0.01923452f, -0.09156414f, 0.07828060f, 0.13712771f, 
    -0.01083654f, 0.12999609f, 0.10587417f, -0.03561653f, 0.14143683f, -0.04304348f, -0.15662542f, -0.04755936f, 
    0.19157638f, -0.03668088f, -0.00281913f, -0.00235281f, -0.03183652f, 0.22683801f, -0.05106075f, -0.23453937f, 
    -0.15012449f, -0.07260031f, 0.27117342f, 0.01183932f, -0.00549558f, -0.03029385f, 0.11560041f, -0.12505193f, 
    -0.21008232f, 0.04310945f, -0.00319890f, 0.02276543f, -0.02291041f, -0.12564661f, -0.09934290f, -0.03653296f, 
    -0.28444368f, -0.07086310f, -0.51728386f, -0.34639484f, 0.09096675f, 0.12036736f, 0.10942970f, 0.09186597f, 
    0.19670047f, 0.07449804f, 0.25925523f, -0.05660597f, -0.26531708f, 0.04409981f, -0.01334320f, -0.02338713f, 
    -0.03778320f, 0.27249759f, -0.03453933f, -0.00335625f, -0.24204978f, -0.08433586f, -0.30387947f, -0.24193437f, 
    -0.10939959f, -0.10185344f, 0.12265386f, -0.01937695f, -0.06686806f, 0.13274248f, 0.03410687f, -0.01328019f, 
    -0.01108122f, 0.07613245f, -0.03888648f, 0.00375639f, -0.07531023f, 0.04876918f, 0.01389563f, -0.02348008f, 
    0.14920446f, 0.05988210f, -0.02790722f, -0.16706032f, -0.15540040f, -0.27428859f, 0.05931921f, -0.13006872f, 
    -0.12350830f, 0.00396859f, -0.11751635f, 0.33592638f, 0.17289336f, -0.10923283f, 0.19310948f, -0.18816349f, 
    0.10218341f, 0.05827073f, 0.05996342f, -0.17464297f, 0.06693189f, -0.02896950f, 0.11016182f, -0.04909970f, 
    -0.04420174f, 0.02982749f, -0.06546379f, 0.04801307f, -0.04768214f, 0.03474741f, 0.11369970f, 0.15116620f, 
    -0.03370966f, 0.05119988f, -0.02173338f, 0.01605960f, -0.22814195f, 0.04220843f, 0.02324030f, 0.08655085f, 
    0.01897540f, -0.04912391f, 0.01834082f, -0.21834832f, 0.01583112f, -0.08407354f, -0.11603441f, -0.06245833f, 
    -0.15122637f, 0.11258368f, -0.16270560f, 0.04779769f, -0.14804524f, -0.01952614f, -0.27462015f, 0.08883236f, 
    0.15547085f, 0.02155106f, 0.05198558f, -0.03884687f, -0.09141117f, 0.29293439f, 0.26531565f, -0.14738490f, 
    0.02803152f, -0.03421735f, 0.08714975f, -0.19488701f, 0.10881120f, -0.03139496f, -0.18901162f, 0.16809060f, 
    0.22550575f, 0.13484876f, 0.07003449f, 0.05141150f, -0.03660399f, -0.00460973f, 0.29499045f, -0.21522890f, 
    -0.20352714f, -0.46317309f, 0.09127547f, -0.19890596f, 0.16294712f, -0.10173585f, 0.04897551f, 0.09013491f, 
    -0.09479067f, 0.03064449f, 0.11486461f, -0.07805817f, 0.05967134f, 0.16922680f, 0.04968102f, -0.09107685f, 
    0.00673864f, 0.07990195f, -0.01735986f, -0.16125774f, 0.06372981f, 0.07436983f, -0.00654877f, -0.09671311f, 
    -0.05506980f, -0.04864753f, -0.09922608f, -0.07178847f, 0.02206299f, 0.16967820f, 0.01602645f, 0.13573927f, 
    -0.17648552f, -0.09977877f, -0.21398248f, 0.07379984f, 0.13653684f, 0.05708164f, 0.07633638f, -0.02282077f, 
    -0.04707245f, -0.12211445f, -0.20937738f, -0.10947996f, -0.10362142f, -0.05380933f, 0.04731002f, 0.24453653f, 
    0.06513395f, 0.06638563f, 0.10634598f, -0.03462541f, 0.03199032f, 0.02864526f, 0.06100669f, 0.09655032f, 
    -0.03039005f, 0.08609319f, 0.02696545f, -0.10556509f, -0.14718722f, -0.26253662f, -0.03470340f, 0.14166485f, 
    0.08116280f, -0.07036681f, 0.13064881f, 0.19696628f, 0.16042639f, 0.16566662f, 0.17033346f, 0.04531492f, 
    0.08955371f, 0.02208470f, -0.12977916f, 0.04326361f, 0.05315644f, 0.15530354f, -0.10815641f, -0.04640414f, 
    0.16035749f, -0.09924483f, 0.27716133f, 0.19092590f, -0.04244636f, -0.03783751f, 0.07128478f, 0.07337270f, 
    0.15345946f, -0.06074165f, 0.13070929f, -0.11143702f, 0.11427379f, 0.16621289f, 0.06540377f, -0.05992315f, 
    -0.09678017f, -0.13207647f, 0.22813210f, -0.13048989f, -0.12070478f, 0.04964529f, 0.05962916f, -0.04049299f, 
    0.02826554f, -0.06962389f, -0.00718254f, 0.11819911f, 0.01036146f, 0.03549820f, 0.17372559f, 0.09479658f, 
    -0.05483785f, 0.04734990f, 0.13425313f, 0.14463639f, 0.11942244f, 0.28062743f, 0.08338677f, 0.00228142f, 
    0.05818859f, 0.09001749f, 0.05061297f, -0.14674129f, 0.09928207f, 0.08276851f, 0.08957946f, -0.12520692f, 
    0.04811614f, -0.11786956f, 0.01553355f, -0.20141889f, 0.02318077f, -0.17241296f, 0.07537887f, 0.22091125f, 
    -0.05778808f, 0.08524726f, -0.00175523f, -0.07280036f, 0.12498924f, 0.01233802f, 0.10460275f, 0.12192436f, 
    0.12400123f, -0.00808135f, 0.03396405f, 0.09132250f, 0.01565416f, 0.13629912f, 0.01722994f, 0.06811392f, 
    0.12600133f, -0.17852439f, -0.23696962f, 0.07461498f, 0.05552948f, 0.01528960f, 0.06597297f, -0.13046601f, 
    0.05233702f, 0.22035764f, -0.00185770f, 0.13827324f, -0.01794505f, -0.23699768f, 0.13472264f, -0.14488864f, 
    0.14102107f, -0.01474300f, -0.12771195f, -0.09803340f, 0.00984573f, 0.03125558f, -0.03321293f, 0.02065084f, 
    -0.11484016f, -0.33861819f, -0.11669232f, -0.18481410f, 0.01540027f, 0.15435536f, 0.11503677f, 0.05287929f, 
    -0.03683684f, -0.11104878f, -0.23353636f, -0.03327986f, 0.22942151f, 0.05371902f, -0.13638878f, 0.00505125f, 
    0.03965095f, 0.02713927f, -0.00007490f, 0.05672514f, -0.06065475f, 0.02495389f, 0.02301042f, 0.06006701f, 
    0.04533538f, 0.00717206f, -0.04219208f, 0.08852143f, 0.01630677f, 0.13090873f, 0.19293515f, -0.20928155f, 
    -0.05046326f, 0.01219101f, 0.16812819f, -0.03125320f, -0.05911077f, 0.06593409f, -0.07571391f, -0.20003836f, 
    0.16096534f, 0.04887636f, 0.20494182f, 0.02422471f, -0.04866769f, -0.07740353f, -0.01018383f, -0.11039387f, 
    0.19578280f, 0.03047527f, 0.08140045f, -0.09288701f, -0.00022292f, -0.06654564f, -0.12758435f, -0.03336629f, 
    -0.10859012f, -0.00576029f, -0.07428434f, 0.04526496f, 0.08543117f, -0.05226329f, 0.00572621f, 0.01962992f, 
    -0.06433778f, -0.08020616f, 0.16531530f, -0.04694572f, -0.08761615f, 0.18444423f, 0.03630303f, 0.06546956f, 
    0.03405458f, -0.12129695f, -0.04614455f, 0.07526635f, -0.03300933f, 0.00559814f, 0.04870304f, -0.00608607f, 
    0.09846071f, 0.01231912f, 0.04313900f, 0.11530654f, 0.07859619f, -0.09052823f, 0.07464346f, 0.01518308f, 
    0.06720852f, -0.09913138f, -0.03361323f, 0.01335758f, 0.10232365f, -0.12986162f, -0.04960906f, 0.28250632f, 
    -0.00426901f, 0.06939836f, 0.10144512f, -0.04186733f, -0.05305725f, 0.12458251f, 0.00695785f, 0.15204233f, 
    0.01111911f, 0.04438799f, 0.02436296f, 0.04053683f, -0.09155082f, -0.29031223f, -0.23817550f, 0.05302217f, 
    0.36910757f, -0.15586004f, 0.09990148f, 0.24544588f, 0.05152959f, -0.09347177f, 0.23456991f, 0.05145671f, 
    -0.49356738f, -0.03986146f, 0.30637854f, 0.07751987f, -0.07093471f, -0.06150162f, -0.12434232f, -0.04217841f, 
    0.11018812f, 0.19862586f, -0.00825427f, 0.26554805f, -0.02064076f, -0.08215340f, 0.06510160f, -0.00519716f, 
    -0.26330155f, 0.01742653f, -0.02810916f, -0.04526018f, 0.07686909f, 0.07527081f, 0.04958947f, -0.04893234f, 
    -0.22796991f, -0.04212743f, -0.02267410f, -0.04965485f, -0.05828098f, 0.15946984f, 0.02281310f, -0.06838942f, 
    -0.04640575f, -0.00837401f, 0.16218802f, -0.00523053f, -0.20385297f, -0.19753160f, -0.37410435f, 0.09972801f, 
    -0.21182069f, 0.01944404f, 0.08636609f, 0.08533182f, 0.06074589f, 0.13740097f, 0.13586666f, 0.10717122f, 
    0.03387979f, -0.00055492f, -0.03248134f, -0.11024863f, 0.05566814f, -0.05632858f, 0.35114303f, -0.41496035f, 
    0.00634608f, 0.11373223f, -0.29762912f, -0.45394406f, 0.03424514f, 0.07997381f, -0.24261183f, -0.45439872f, 
    -0.29494461f, -0.22188038f, -0.07237126f, -0.08798129f, 0.27550933f, -0.03440376f, -0.07148892f, 0.00705703f, 
    0.29764614f, 0.07582884f, 0.23088798f, 0.07783570f, 0.10517090f, 0.09700689f, -0.17936882f, 0.09397893f, 
    -0.00524149f, -0.08390205f, 0.14630321f, 0.09370732f, 0.21101530f, -0.03083126f, -0.02856437f, -0.08489895f, 
    -0.08949035f, 0.06727998f, -0.00844734f, -0.17138892f, 0.09659576f, 0.04429318f, -0.01263246f, 0.04503338f, 
    0.02480670f, 0.06361175f, -0.05543660f, 0.25841743f, -0.01050447f, 0.14267047f, 0.07887194f, 0.01234649f, 
    0.17618790f, -0.06983539f, 0.07367072f, -0.01180877f, -0.02658170f, -0.05469650f, 0.17234120f, -0.02257822f, 
    -0.05056573f, -0.04834509f, -0.02128070f, 0.13509306f, 0.02075599f, 0.06648973f, -0.00650837f, 0.30013785f, 
    0.08284386f, -0.00370179f, 0.10174245f, 0.01710838f, -0.00849449f, -0.04755852f, -0.11147943f, -0.08784064f, 
    0.24969018f, -0.02155900f, -0.03972253f, -0.01700673f, 0.20040150f, -0.06970901f, -0.01525100f, -0.59411120f, 
    -0.36013606f, -0.31056893f, -0.12353154f, 0.25749496f, -0.17920728f, -0.08542001f, 0.04884714f, 0.00687114f, 
    -0.24783342f, -0.06089368f, -0.22014211f, -0.10042017f, -0.01819292f, -0.22512904f, 0.06230276f, 0.10142683f, 
    0.14292111f, 0.28134125f, -0.14680392f, 0.13693513f, 0.01467556f, -0.08058552f, -0.10092454f, -0.03995245f, 
    -0.00809583f, -0.12608103f, -0.01161463f, -0.07394703f, -0.07026701f, 0.08646598f, -0.25121987f, 0.02530515f, 
    -0.03224515f, 0.06195035f, 0.06314947f, 0.05734189f, 0.19587408f, 0.15588564f, 0.08706677f, -0.02819635f, 
    -0.06041690f, -0.10430424f, -0.05777056f, 0.05085164f, -0.13788609f, -0.09054315f, 0.19985229f, 0.04365693f, 
    -0.23175997f, -0.32207713f, -0.11947707f, -0.04616788f, -0.00495961f, 0.21625385f, 0.10019583f, 0.16041800f, 
    0.00723162f, -0.03167166f, 0.28941751f, 0.02386135f, 0.08766104f, -0.03004964f, -0.14059369f, -0.04786888f, 
    -0.26095495f, -0.02321590f, 0.08092047f, -0.34243882f, 0.02052409f, 0.08463679f, 0.09332735f, -0.38237903f, 
    0.08128995f, 0.02094129f, 0.18998106f, -0.12192708f, -0.13033026f, -0.13150376f, 0.11094211f, -0.22548291f, 
    0.02562493f, 0.01108397f, 0.19706561f, -0.00921079f, -0.03897682f, 0.05756555f, -0.05872505f, 0.03142554f, 
    -0.09883635f, 0.18509570f, 0.21165028f, 0.17487533f, 0.24849612f, -0.06172001f, 0.00672075f, 0.00653376f, 
    -0.04108618f, -0.01827715f, -0.04162085f, -0.07979880f, 0.08746994f, -0.00190685f, -0.03547769f, 0.06244035f, 
    0.09501219f, -0.09918159f, 0.07939111f, -0.30692378f, 0.30963284f, -0.47811639f, 0.08641326f, -0.03182056f, 
    -0.13190868f, -0.18026999f, 0.12748364f, 0.16959998f, -0.08757872f, -0.08230612f, -0.30465969f, -0.07518359f, 
    -0.08269377f, -0.35584363f, 0.01359461f, 0.17887390f, 0.14609951f, 0.23069799f, 0.10056399f, 0.05612488f, 
    0.03086777f, -0.00490465f, 0.08301448f, -0.10620303f, 0.03428267f, -0.00451948f, 0.13131858f, -0.06027380f, 
    -0.10373127f, -0.03779313f, -0.08246528f, -0.03044797f, -0.08117282f, -0.12375244f, -0.05776610f, -0.48582736f, 
    -0.06183783f, 0.51636857f, 0.07872892f, 0.12056243f, -0.02042311f, 0.06056668f, -0.33381158f, -0.12571293f, 
    0.03579974f, 0.36983988f, -0.35536349f, -0.06755277f, 0.10498762f, -0.13403812f, -0.08938313f, 0.08774246f, 
    0.02093454f, -0.24625160f, 0.22856814f, 0.29775336f, -0.29453266f, -0.08655562f, -0.05858651f, 0.04576239f, 
    -0.14334190f, -0.12426779f, -0.25616828f, -0.13344766f, -0.60588843f, -0.04962021f, -0.11006308f, -0.11095697f, 
    -0.00647500f, 0.00957561f, -0.09013076f, -0.14717866f, -0.24969564f, -0.00448285f, -0.05302684f, -0.16909508f, 
    -0.10112496f, -0.02535912f, -0.17206284f, 0.09080799f, -0.49120933f, -0.12328292f, -0.38289014f, 0.02858673f, 
    0.05786981f, -0.00667339f, 0.03562992f, 0.01766383f, -0.00953420f, 0.28649852f, 0.03646585f, 0.04938462f, 
    0.00783366f, 0.09209555f, -0.02512730f, -0.06576870f, 0.01950185f, -0.09516828f, 0.14697519f, 0.10402905f, 
    0.08924928f, 0.08337926f, 0.07112762f, 0.08337215f, -0.03420937f, 0.07072169f, 0.11766841f, -0.39144486f, 
    -0.51080388f, 0.04976281f, 0.02382019f, 0.07015397f, -0.10627143f, 0.06115848f, 0.03793944f, -0.11495044f, 
    0.00812187f, -0.04475838f, 0.08706452f, -0.13522261f, -0.13507059f, -0.10922107f, 0.07922719f, 0.01294836f, 
    0.13815838f, 0.06457777f, -0.01764301f, -0.28862259f, -0.06068653f, 0.01944262f, 0.10775685f, -0.02978360f, 
    0.13234760f, -0.06360436f, -0.38462749f, 0.33942726f, 0.34337834f, -0.03765884f, 0.14594692f, 0.01893197f, 
    0.03885388f, 0.08331650f, 0.04439337f, -0.07745529f, -0.02141121f, 0.14264311f, -0.06612772f, -0.00124236f, 
    -0.10306584f, 0.09514528f, -0.04565739f, 0.09020551f, -0.17846359f, -0.04502611f, -0.07122123f, 0.09849926f, 
    -0.00376245f, -0.14451855f, -0.01706624f, -0.01573243f, 0.13876668f, -0.04564100f, 0.26728231f, 0.23185003f, 
    0.01039897f, 0.20255950f, 0.00078243f, 0.01416526f, 0.12280533f, -0.04521273f, -0.13915820f, -0.10204871f, 
    -0.00761989f, 0.16525196f, -0.19044815f, -0.09173852f, -0.05937959f, 0.06163971f, 0.01829107f, -0.10759725f, 
    0.03784955f, 0.29781744f, 0.00502120f, 0.17695066f, 0.02415509f, -0.03252258f, -0.01455532f, -0.16160253f, 
    -0.26856050f, -0.18815498f, 0.27881387f, -0.01328854f, -0.01987387f, -0.07712290f, -0.04545532f, -0.05851994f, 
    0.14544953f, -0.09056401f, -0.18741848f, 0.05169910f, -0.22710349f, 0.01627338f, -0.23514260f, 0.10609809f, 
    -0.00156095f, 0.04297111f, -0.04744074f, -0.26138645f, -0.30145699f, -0.03527042f, 0.03229985f, -0.13543077f, 
    -0.00337610f, 0.01658994f, 0.13537680f, 0.28964460f, -0.19445251f, 0.20396116f, 0.06043211f, 0.07782812f, 
    0.04242979f, 0.12012588f, 0.18039766f, -0.08284742f, -0.43618566f, -0.01044234f, 0.19097887f, -0.05449145f, 
    0.23159489f, -0.13999486f, -0.08204778f, 0.14506255f, 0.12653944f, 0.02474414f, 0.17403638f, 0.11138417f, 
    0.05487339f, 0.10048982f, 0.01964657f, 0.12381493f, 0.18183321f, 0.12282819f, -0.41968030f, -0.09932412f, 
    0.21063651f, -0.08146557f, -0.01948022f, -0.04824962f, -0.15450162f, -0.05772098f, 0.09659670f, -0.08400065f, 
    -0.73115963f, -0.09468593f, 0.11545449f, -0.34029949f, 0.02064447f, -0.00382993f, 0.02823085f, 0.12179602f, 
    -0.09803942f, -0.06444583f, 0.02365822f, 0.04108291f, -0.03692943f, 0.13966601f, 0.01160935f, -0.03784579f, 
    0.05635829f, 0.22196425f, -0.07331149f, 0.12878585f, -0.04868570f, 0.04179123f, 0.06401327f, -0.04109706f, 
    0.00677365f, 0.07740673f, -0.34761906f, 0.23322546f, 0.09114777f, -0.11039972f, -0.01566063f, -0.04794059f, 
    0.07100578f, -0.01545126f, -0.00312634f, -0.14298669f, 0.28952187f, 0.38302311f, 0.04970888f, 0.08452266f, 
    -0.03031564f, 0.03579513f, 0.18598782f, 0.11564215f, -0.16569056f, -0.25668633f, -0.32792273f, -0.04172213f, 
    0.01034105f, -0.06697781f, -0.04485445f, -0.12692276f, -0.12220478f, 0.18255515f, 0.36425325f, 0.15411420f, 
    0.21588244f, 0.15843117f, 0.03131096f, 0.28385919f, 0.13691069f, 0.24961871f, -0.02259587f, -0.21567632f, 
    -0.23718035f, -0.20737919f, -0.05832856f, -0.17969009f, -0.12701857f, -0.09718224f, -0.11910039f, -0.32330802f, 
    0.12679318f, -0.13098891f, -0.00260352f, -0.04233635f, -0.09765465f, 0.09808847f, 0.12278954f, -0.04933628f, 
    0.20378542f, 0.40471011f, -0.60041410f, -0.07886901f, -0.06873166f, -0.08084731f, 0.04698005f, -0.02667332f, 
    -0.18967393f, -0.32223672f, 0.26372734f, 0.02851489f, -0.03958717f, -0.01712607f, -0.05422715f, 0.00321130f, 
    -0.10130093f, 0.02268568f, -0.19118723f, 0.22459836f, -0.36433569f, -0.06389251f, 0.01951203f, -0.12041260f, 
    -0.15663512f, 0.00571564f, -0.22763419f, -0.01052572f, -0.00264589f, -0.06221756f, -0.10723391f, -0.02003509f, 
    -0.06348833f, -0.08223905f, -0.02970199f, -0.00281237f, -0.59088463f, -0.51220691f, -0.40810633f, 0.03983162f, 
    0.08392549f, -0.02982728f, -0.06616627f, 0.04976397f, 0.10574642f, 0.26080593f, -0.00938328f, 0.02002649f, 
    -0.00635997f, 0.02222455f, 0.12823090f, -0.14190158f, -0.01379317f, -0.11278743f, 0.21660301f, -0.05729013f, 
    -0.18171865f, -0.09827464f, 0.02363800f, 0.14441456f, 0.06022706f, 0.07829012f, 0.10586458f, -0.50993288f, 
    -0.35386074f, 0.27902678f, 0.04136877f, 0.11933835f, -0.09640304f, 0.05324746f, -0.11686459f, -0.03921554f, 
    0.13836733f, 0.12083175f, 0.06128691f, -0.00616473f, -0.05215009f, -0.09719399f, 0.00442822f, 0.09916649f, 
    0.24734110f, 0.11869538f, -0.02222090f, -0.18556246f, -0.13510048f, 0.07546599f, 0.03270053f, -0.19485910f, 
    0.05539325f, 0.05986093f, -0.36492288f, 0.02974465f, 0.09333128f, 0.08933300f, 0.13565741f, -0.05711672f, 
    -0.00631274f, 0.00066744f, 0.03322630f, 0.05666331f, 0.04096735f, 0.19635881f, 0.04275046f, 0.10346799f, 
    -0.06409901f, 0.03623100f, -0.05326418f, 0.15194385f, 0.14868616f, 0.21860492f, 0.05238181f, -0.06972314f, 
    -0.07319282f, -0.22062325f, 0.06041459f, 0.06762164f, 0.06799870f, 0.07466792f, 0.06774767f, -0.11107054f, 
    -0.05602999f, -0.06153288f, 0.11073475f, -0.05417815f, 0.01780913f, -0.07875510f, 0.09354677f, 0.08012632f, 
    0.15504806f, -0.03874794f, 0.04103369f, -0.20671545f, -0.00952328f, 0.07292324f, 0.00355672f, 0.05847507f, 
    -0.13706766f, 0.20884609f, 0.02127510f, -0.07615652f, 0.02635321f, 0.04830328f, 0.02148337f, 0.05211166f, 
    -0.19295645f, -0.43422553f, 0.09458735f, -0.08424840f, 0.03038872f, -0.06952288f, -0.08245257f, 0.07639766f, 
    0.05804633f, 0.02586137f, 0.11187507f, -0.05657390f, -0.01304964f, -0.09674690f, -0.01188413f, 0.02525696f, 
    0.01826075f, 0.06183292f, -0.43542051f, -0.29802829f, -0.34627700f, -0.05249726f, -0.02959259f, -0.05329299f, 
    -0.02610302f, -0.04625247f, -0.00233890f, 0.25979981f, -0.06979362f, 0.10295676f, -0.03342927f, 0.05704939f, 
    0.01950013f, 0.07837385f, 0.05228642f, -0.18140374f, -0.13667789f, -0.40777996f, -0.38240293f, 0.01293173f, 
    -0.00851588f, -0.01998912f, 0.05887633f, 0.04323862f, 0.14305004f, 0.14089549f, -0.06872614f, 0.03552102f, 
    0.00927952f, 0.07025380f, -0.05405513f, 0.07917016f, 0.05160317f, 0.09730364f, -0.21047400f, -0.61315191f, 
    0.11937269f, -0.05122781f, -0.04881543f, -0.09835458f, -0.07126641f, 0.06749900f, 0.04396533f, 0.15223829f, 
    -0.09382335f, 0.38090229f, -0.16011876f, 0.11527684f, -0.01711896f, -0.00574529f, 0.17784867f, 0.18976295f, 
    0.09131316f, 0.07941277f, -0.03080565f, -0.02282358f, -0.04135028f, -0.05213918f, -0.03972204f, 0.00884192f, 
    0.01273566f, 0.19024004f, -0.09685820f, -0.21484275f, -0.03442138f, 0.10609788f, -0.06391517f, 0.01040494f, 
    0.02940280f, -0.04584691f, -0.43542624f, 0.18069839f, 0.02107950f, -0.03444430f, 0.10793351f, -0.01019759f, 
    0.01270264f, -0.04231032f, 0.03265239f, -0.03357084f, -0.49537998f, -0.13916850f, 0.00490975f, -0.09295154f, 
    -0.08374047f, 0.07900374f, 0.17609948f, 0.08667509f, -0.55979681f, -0.26414534f, -0.29861456f, 0.04278442f, 
    0.07014746f, -0.05282943f, 0.05520877f, -0.04342438f, 0.04092848f, 0.18596546f, 0.15460727f, 0.17857249f, 
    0.16088590f, 0.13935085f, 0.06560553f, 0.19682121f, 0.01592997f, 0.10170480f, -0.17207310f, -0.02592229f, 
    -0.00219922f, -0.09956690f, 0.06028414f, 0.01664442f, -0.05240550f, -0.15210830f, -0.13300748f, 0.01626854f, 
    -0.36250082f, -0.25326654f, -0.11495157f, 0.03569845f, -0.07396630f, 0.08259924f, -0.00611246f, 0.00055205f, 
    0.08991797f, -0.36857656f, 0.03632784f, -0.13315548f, 0.04746054f, 0.29283926f, 0.08569947f, 0.04784717f, 
    0.05522271f, -0.12547624f, 0.07048435f, 0.00204734f, -0.04633071f, 0.04908613f, -0.07195214f, 0.06628384f, 
    0.01701355f, -0.07388402f, -0.07463868f, -0.23730162f, 0.05293319f, 0.00626701f, 0.13252263f, 0.13410246f, 
    0.05982986f, 0.07177004f, 0.14142895f, -0.07899174f, -0.11474251f, -0.15388425f, 0.07896598f, -0.06521384f, 
    0.02098589f, -0.08130614f, -0.00038176f, 0.06354972f, -0.24817014f, -0.07144164f, 0.06172478f, -0.15875207f, 
    -0.04717251f, -0.12965493f, 0.01893399f, 0.01414281f, -0.11973115f, 0.07001883f, 0.09164231f, 0.01619510f, 
    0.01457509f, -0.03299027f, -0.07060740f, 0.02632330f, 0.12546416f, 0.14921822f, 0.11830424f, -0.02947094f, 
    0.01705369f, -0.00755608f, -0.11296146f, 0.09031326f, -0.01734345f, -0.10604363f, -0.12859891f, -0.33837673f, 
    0.01351965f, 0.39070997f, 0.03656555f, 0.03684597f, -0.04969717f, 0.07087595f, 0.07227884f, 0.12483685f, 
    -0.01767167f, 0.15398109f, 0.32487518f, -0.12238136f, -0.06502776f, -0.19253130f, -0.07036822f, 0.20330362f, 
    -0.00238961f, -0.21786538f, 0.15873982f, 0.03956082f, 0.02595505f, -0.06815947f, -0.10916208f, 0.00387593f, 
    0.10987131f, 0.13103986f, -0.08072919f, -0.22779407f, 0.00346015f, -0.02792235f, 0.15270595f, -0.01778475f, 
    -0.00442881f, 0.12692489f, 0.00262092f, -0.04844737f, 0.04490270f, 0.15354314f, 0.04949789f, -0.05195476f, 
    -0.16044211f, 0.06537472f, -0.02761689f, -0.02599585f, 0.01153731f, 0.03170919f, -0.10784648f, -0.02893742f, 
    0.01540915f, -0.07360627f, -0.02963226f, -0.15966171f, 0.05675424f, -0.11231620f, -0.03625367f, -0.18677443f, 
    0.09743129f, 0.02556822f, 0.03726303f, 0.05917419f, 0.07553586f, 0.05044406f, -0.21816953f, 0.22664088f, 
    0.06578932f, 0.00257789f, -0.01591117f, -0.05865889f, 0.03188128f, -0.12581062f, -0.05410029f, -0.17620932f, 
    -0.12871511f, 0.29251671f, -0.23825537f, 0.07199670f, -0.16876476f, -0.11441904f, 0.14382125f, -0.06090001f, 
    0.03444151f, -0.09624530f, 0.21595606f, -0.09526900f, -0.08126646f, -0.09901262f, 0.03998623f, -0.06623853f, 
    -0.00423124f, -0.05044572f, -0.17083697f, -0.21449637f, -0.09594181f, -0.04066674f, -0.08952457f, -0.18967426f, 
    -0.02210679f, 0.00029736f, -0.11735864f, -0.12044498f, 0.12704062f, 0.02816212f, 0.04026508f, -0.05414626f, 
    0.21402018f, 0.15583889f, 0.17851239f, 0.24091424f, 0.09224590f, 0.23259515f, 0.06969794f, -0.09955541f, 
    -0.03891075f, 0.12412427f, 0.26320475f, 0.05512978f, -0.03535818f, -0.14223783f, -0.27629647f, 0.00459103f, 
    -0.08964713f, -0.14523908f, -0.04149332f, -0.06880327f, -0.04977953f, -0.08988425f, 0.14795493f, 0.27058321f, 
    -0.06335026f, -0.03536728f, -0.09236402f, 0.06025381f, 0.02030229f, -0.07939828f, 0.08114848f, 0.17952202f, 
    0.17728341f, 0.02502724f, -0.06344488f, -0.12833607f, 0.00629496f, 0.02098993f, -0.13681799f, -0.17869332f, 
    0.23846520f, 0.18678172f, 0.11932938f, 0.04737424f, 0.25980857f, -0.08863563f, 0.12368368f, 0.06087231f, 
    -0.08768710f, 0.01093957f, -0.06353544f, 0.04735276f, 0.09290764f, 0.01949768f, -0.00975774f, 0.15757039f, 
    0.12239511f, 0.10311331f, 0.12717247f, 0.25212964f, -0.00268521f, -0.12340846f, -0.08973467f, 0.16725324f, 
    0.15322533f, 0.08372532f, -0.08143163f, -0.05534713f, -0.06108617f, 0.04732234f, 0.01944541f, 0.02419166f, 
    -0.00148707f, 0.04132524f, 0.14531900f, 0.16169414f, 0.01556085f, 0.18523695f, -0.12072027f, -0.07083022f, 
    -0.13834652f, -0.00032443f, -0.03815696f, -0.07209814f, -0.12305094f, -0.06581970f, -0.19604285f, -0.13307174f, 
    -0.02746005f, 0.12706336f, 0.03140774f, 0.04598489f, -0.22334693f, -0.08012660f, 0.10294206f, 0.34942019f, 
    0.01403094f, 0.17188755f, 0.10334163f, -0.21337315f, 0.06186098f, 0.03394048f, -0.13372590f, 0.02330708f, 
    -0.00701904f, 0.11799155f, 0.14538369f, -0.12018304f, -0.00377634f, 0.08840431f, 0.17074320f, -0.23235901f, 
    0.41985509f, -0.11075266f, -0.05462798f, -0.30159986f, 0.00760214f, 0.10134224f, 0.11425368f, 0.06269077f, 
    0.18789290f, -0.33995658f, -0.08190273f, 0.03563527f, 0.13000196f, 0.09184991f, -0.01839168f, -0.01739943f, 
    0.06814092f, 0.00432697f, -0.12066291f, -0.31347156f, 0.06413175f, -0.12580320f, 0.06468930f, -0.01745387f, 
    0.01975164f, -0.12173396f, -0.35881656f, -0.08905299f, -0.03139517f, -0.11595200f, 0.13547747f, -0.02537694f, 
    0.03776997f, -0.07031420f, -0.04310435f, 0.09325811f, 0.13153134f, -0.15262102f, -0.12501390f, 0.00412396f, 
    -0.01486355f, -0.02663615f, -0.08910140f, -0.09788925f, 0.07455558f, 0.13588753f, 0.33673984f, 0.01195126f, 
    0.11584951f, -0.03832788f, 0.04922665f, -0.00531226f, 0.08784462f, 0.16519669f, 0.11527906f, -0.01025197f, 
    -0.00832067f, 0.02031081f, -0.10470469f, 0.03250244f, -0.05244398f, -0.03915125f, -0.00383616f, -0.46493685f, 
    -0.30074623f, -0.05865191f, 0.20759955f, -0.03551162f, 0.08270396f, 0.05255078f, 0.00612517f, 0.32293099f, 
    0.01177688f, -0.12402765f, -0.15832588f, 0.05835066f, 0.01827876f, 0.07731313f, 0.09778318f, 0.04401580f, 
    -0.08859412f, 0.37383041f, 0.14416812f, -0.09323677f, 0.01303837f, -0.08954507f, -0.02781670f, 0.09482407f, 
    -0.00559323f, 0.37950060f, 0.00576687f, 0.05933264f, 0.04684171f, -0.03741828f, 0.00144913f, 0.11296641f, 
    -0.12666109f, -0.05975837f, -0.16974023f, -0.29751727f, -0.27296081f, -0.00759381f, 0.08921371f, 0.07187709f, 
    -0.04631379f, -0.01877402f, -0.03838741f, -0.09113618f, 0.20987201f, 0.05067705f, -0.07813213f, 0.03494227f, 
    -0.13073102f, -0.07562054f, 0.15598525f, 0.19891985f, 0.05404951f, 0.20206511f, -0.06923614f, -0.03126583f, 
    0.02767611f, 0.05890411f, 0.04063537f, -0.01502468f, -0.07796188f, 0.23936830f, -0.34226370f, -0.06536245f, 
    0.05559964f, 0.15376128f, -0.00792131f, 0.08210476f, -0.09225824f, -0.11584175f, 0.00043210f, 0.03572029f, 
    -0.18675250f, 0.08383764f, -0.05982747f, 0.01680691f, 0.13571461f, 0.06260346f, -0.02308109f, -0.19308680f, 
    0.19410038f, -0.54916590f, 0.00463940f, -0.09469610f, 0.25436822f, 0.22744662f, 0.05955383f, -0.05822359f, 
    0.31493622f, -0.08535060f, -0.61344504f, -0.02849082f, -0.10206140f, 0.08191121f, 0.02549190f, 0.00256422f, 
    0.00112241f, -0.24346907f, -0.25139621f, 0.09794278f, -0.11682716f, 0.28237388f, -0.16734427f, 0.04103575f, 
    0.09016447f, 0.06091363f, -0.12928675f, 0.20962688f, 0.14571616f, -0.02539161f, -0.07948278f, -0.07045002f, 
    -0.04186145f, -0.04095310f, 0.00141690f, 0.33593169f, 0.41433513f, 0.07347755f, 0.08207893f, 0.05157760f, 
    -0.10982271f, 0.05891406f, 0.08560716f, -0.05181530f, -0.01993332f, -0.57412159f, -0.57011700f, -0.22423051f, 
    0.05596611f, -0.06777670f, -0.02289311f, -0.01615625f, 0.04134255f, 0.11976149f, 0.27800068f, 0.11013430f, 
    0.05934348f, -0.00475548f, 0.03643481f, 0.06375927f, 0.10587052f, 0.13315807f, 0.15272948f, -0.10361889f, 
    -0.66787040f, -0.03035008f, 0.07684717f, 0.01571952f, -0.04796229f, -0.02879305f, 0.03314216f, 0.11752919f, 
    0.14253999f, -0.19805372f, -0.11824544f, 0.48848423f, -0.20346497f, -0.08089395f, 0.14901452f, -0.01948424f, 
    0.15668900f, 0.07486419f, -0.06841448f, -0.09191071f, 0.04938293f, -0.01942975f, 0.02804690f, -0.04862292f, 
    -0.04180048f, 0.08128259f, 0.35260969f, 0.23034783f, 0.00588066f, 0.03662232f, -0.08670277f, -0.00636333f, 
    0.09284478f, -0.01119872f, -0.13041584f, -0.35628664f, -0.19292770f, -0.00882767f, -0.02493349f, -0.06889482f, 
    0.00593178f, -0.10481829f, 0.00791839f, -0.13417584f, -0.39170283f, -0.38794351f, -0.03279408f, -0.08091554f, 
    0.10718393f, 0.01569912f, 0.03326385f, -0.07392584f, -0.07573237f, -0.18144256f, 0.01138261f, 0.07926662f, 
    -0.03543799f, 0.07908791f, -0.05231046f, 0.00889030f, 0.07515314f, 0.01187085f, 0.24450664f, -0.02827518f, 
    0.01680978f, 0.15163520f, -0.11176732f, 0.18893959f, 0.06447318f, -0.03488094f, -0.14201021f, -0.04690713f, 
    0.05049022f, 0.02892023f, -0.06160791f, -0.16196725f, -0.08717003f, 0.02655496f, -0.06402142f, 0.58165026f, 
    -0.52970648f, -0.15840994f, 0.28157297f, -0.02125198f, 0.02360707f, 0.04445768f, -0.28556097f, -0.14199986f, 
    -0.07651931f, 0.33642876f, 0.15904467f, -0.01295742f, -0.08901346f, -0.09109794f, 0.01559037f, 0.12866405f, 
    -0.04699762f, 0.01212683f, -0.04294088f, 0.02187044f, 0.17600928f, 0.04220252f, 0.02951330f, 0.06296664f, 
    0.05038372f, -0.12894677f, 0.04926847f, 0.18425085f, 0.12377962f, 0.10602862f, 0.03092315f, 0.01760542f, 
    0.03985265f, 0.04384961f, -0.03456526f, 0.01898300f, 0.02954135f, -0.07666051f, 0.00183264f, 0.04534740f, 
    0.03422235f, -0.17373247f, -0.30137661f, -0.14003399f, -0.07385555f, 0.05701932f, 0.20903362f, -0.05000938f, 
    -0.00504846f, -0.13420150f, 0.03316949f, -0.04240074f, 0.07871111f, 0.02873164f, 0.03346330f, -0.22585459f, 
    0.01796180f, -0.10017861f, -0.07523414f, -0.04728690f, 0.08496725f, -0.12236305f, 0.01412473f, 0.32527000f, 
    0.23556086f, 0.01127654f, 0.15079388f, 0.01055279f, 0.05417900f, 0.02697833f, 0.06756314f, 0.22874184f, 
    0.38073140f, -0.04710778f, -0.15620875f, -0.08941074f, 0.00957605f, 0.07873814f, -0.08698966f, 0.05536749f, 
    -0.01865799f, -0.09410577f, -0.26857293f, 0.13226767f, 0.06513567f, 0.01456916f, -0.03002605f, -0.04643046f, 
    0.09875301f, -0.09231781f, -0.07760555f, -0.07504365f, 0.13309339f, 0.09230178f, -0.18286970f, -0.03780822f, 
    -0.04966154f, -0.03020876f, 0.07810663f, 0.03580542f, 0.05998927f, 0.10502052f, -0.02639136f, -0.01965794f, 
    -0.03500691f, -0.03785824f, 0.04456647f, 0.02600937f, 0.03790092f, -0.06014041f, 0.16516474f, -0.00258710f, 
    -0.08887049f, -0.03894648f, -0.04863558f, 0.13962427f, 0.06886149f, 0.08166328f, -0.21879825f, 0.02273239f, 
    0.02622678f, 0.10086772f, 0.00266293f, -0.12299916f, 0.14356457f, -0.08141769f, -0.16360597f, 0.06720652f, 
    0.00425862f, 0.01376605f, 0.08232949f, -0.05995282f, -0.00035407f, -0.17171939f, 0.18445982f, -0.09962141f, 
    -0.00632991f, 0.02845792f, -0.05892880f, 0.09239193f, 0.20961910f, 0.13536923f, -0.00807874f, 0.23370853f, 
    0.09910344f, 0.18118218f, 0.02493966f, -0.09631381f, 0.06603900f, -0.03153108f, -0.06055040f, -0.07155982f, 
    0.16362992f, -0.03765541f, 0.06963334f, 0.01446841f, -0.04837491f, -0.03080616f, 0.08235291f, -0.07526481f, 
    0.00515036f, 0.02824550f, 0.00771554f, -0.32177263f, -0.09499983f, -0.00754107f, 0.16343556f, 0.03008265f, 
    -0.10072720f, 0.00569654f, -0.01548223f, 0.11490849f, -0.02389123f, 0.03167962f, -0.11425522f, -0.02334421f, 
    0.05384313f, -0.06177908f, -0.09067053f, -0.24734654f, -0.24604821f, -0.03774655f, 0.09527680f, -0.00859707f, 
    0.04868232f, -0.20126724f, -0.00685887f, -0.10000472f, 0.03648657f, -0.11589436f, 0.02400403f, 0.03855018f, 
    0.00458559f, 0.16954522f, -0.00725345f, 0.12512924f, 0.18517300f, -0.04221047f, 0.07632782f, 0.03352377f, 
    -0.05204502f, -0.04580045f, -0.05775921f, 0.09249841f, -0.09073712f, -0.07113762f, 0.25861651f, 0.02387743f, 
    0.06804239f, 0.10100327f, 0.02582188f, 0.20850153f, -0.12032139f, 0.08621096f, -0.03561807f, -0.01615123f, 
    -0.05291400f, -0.21378501f, 0.12221683f, -0.04309617f, -0.07959371f, -0.08270453f, 0.08779997f, 0.01139771f, 
    0.14120449f, -0.09196180f, -0.08474857f, 0.06420401f, -0.08192813f, -0.00002819f, -0.18074720f, -0.12524927f, 
    -0.17805658f, -0.23581199f, -0.14003122f, -0.27397844f, 0.02324286f, -0.04343593f, -0.17775248f, 0.04944608f, 
    -0.02635191f, 0.12054733f, 0.02826657f, 0.16986282f, 0.04539768f, 0.08630648f, -0.00412710f, -0.08554965f, 
    0.12520851f, 0.00344228f, -0.05085070f, 0.07241246f, 0.08006033f, 0.09089527f, 0.00207901f, 0.01346753f, 
    -0.02311046f, -0.16111752f, 0.06579947f, 0.05395648f, 0.13433509f, 0.08808844f, 0.18532245f, 0.05239521f, 
    -0.04196436f, -0.17015427f, -0.07933712f, -0.04416157f, -0.06489614f, -0.31509349f, 0.08447757f, -0.24772173f, 
    -0.14962856f, -0.01857689f, -0.01186366f, -0.09668116f, 0.07889556f, 0.02641555f, 0.10786105f, 0.03958517f, 
    -0.03924785f, 0.14998870f, 0.02800825f, -0.08042134f, -0.00731290f, -0.08665082f, -0.12531151f, 0.08548965f, 
    -0.00109279f, 0.06434102f, 0.08113652f, 0.15068842f, -0.00770455f, 0.04742748f, 0.13219768f, -0.08375979f, 
    0.00146201f, 0.19145709f, -0.03952490f, 0.13816777f, -0.00185867f, 0.06237393f, -0.01455295f, -0.14351526f, 
    0.15002975f, 0.04085168f, -0.00421040f, 0.14038405f, -0.07466432f, -0.02942776f, 0.02914855f, 0.13938504f, 
    -0.11952714f, 0.12326147f, 0.05543382f, 0.01036915f, -0.05294534f, -0.15140875f, 0.04791258f, -0.08080009f, 
    0.08133925f, -0.09376489f, 0.09920602f, 0.13306886f, -0.01624015f, 0.18970428f, -0.07970293f, 0.04038031f, 
    0.15141909f, -0.10905331f, 0.00860519f, 0.09737305f, -0.01029104f, 0.18974520f, -0.52413559f, 0.09263060f, 
    0.04749719f, 0.05845661f, -0.09062577f, -0.08337487f, -0.12410328f, -0.01924916f, 0.03400270f, -0.08262320f, 
    -0.02823355f, -0.08267477f, 0.01060895f, -0.09954420f, 0.03754982f, 0.15003766f, -0.07845397f, 0.05137373f, 
    -0.06633384f, 0.03290956f, 0.01351225f, -0.04308470f, 0.01850262f, -0.02212638f, -0.09228268f, 0.30059788f, 
    -0.00677247f, 0.26448211f, 0.02762873f, 0.01477921f, 0.23935954f, 0.03273690f, 0.14971468f, 0.01274971f, 
    -0.07795418f, -0.18164878f, -0.06977924f, -0.04839720f, 0.07907417f, 0.07784409f, -0.16598079f, -0.00142671f, 
    -0.12574051f, -0.00822436f, 0.15393573f, 0.37163788f, -0.01385264f, -0.00646648f, 0.01141537f, -0.13594347f, 
    0.01429792f, -0.02229501f, 0.15347542f, 0.09679755f, -0.03191404f, 0.02426129f, 0.06268914f, -0.07513621f, 
    -0.05376489f, 0.03400643f, -0.08056802f, -0.11416961f, -0.09331173f, 0.32094723f, 0.05603950f, 0.06547847f, 
    0.00303465f, -0.14739686f, -0.09983330f, -0.10531089f, -0.00642665f, -0.20342709f, -0.02874081f, 0.06443008f, 
    0.12162299f, 0.10185799f, -0.16738045f, -0.01011323f, -0.08156510f, 0.02153289f, -0.08474998f, 0.16223815f, 
    -0.07004086f, -0.02369772f, -0.15856315f, -0.02137277f, -0.07072233f, -0.04582623f, -0.23971030f, -0.18729100f, 
    0.34707287f, 0.22280288f, 0.07589853f, -0.15765038f, -0.10418237f, -0.17346385f, 0.06441985f, 0.21392860f, 
    0.28990650f, -0.26715216f, 0.23632340f, -0.19270149f, 0.14167999f, -0.04843053f, -0.07956041f, -0.03865746f, 
    0.06695536f, 0.25819808f, -0.06582343f, 0.04805616f, 0.10071991f, 0.03576100f, -0.07536089f, -0.19399445f, 
    -0.06527069f, -0.01231371f, 0.01517169f, 0.09300958f, 0.15175864f, 0.16952893f, -0.17847259f, 0.00647525f, 
    -0.07338239f, -0.36861759f, 0.07437405f, 0.11855054f, -0.16085449f, 0.11182448f, 0.08718873f, 0.08104591f, 
    0.00291493f, -0.00842625f, -0.03838979f, -0.11297700f, 0.00470384f, 0.23331606f, -0.06503025f, 0.07434120f, 
    0.03349752f, -0.03216087f, 0.01288356f, 0.08084450f, 0.05657269f, -0.19253241f, -0.09743650f, 0.18920210f, 
    0.06419058f, -0.13941610f, -0.18576373f, -0.12713316f, -0.18089677f, -0.07483903f, -0.24286138f, -0.21280745f, 
    0.08141519f, -0.03090709f, 0.01643722f, -0.12675263f, -0.02399950f, -0.26708806f, 0.09075851f, 0.01373055f, 
    -0.09731283f, 0.09672694f, 0.08722130f, 0.06527229f, 0.00869971f, 0.04409409f, 0.08289867f, -0.03193149f, 
    0.12600006f, 0.32971546f, -0.01095231f, 0.11417414f, 0.42816943f, -0.03787846f, 0.44926932f, -0.01193528f, 
    0.02245811f, -0.14116898f, 0.16568489f, -0.03243744f, -0.01349545f, 0.07535913f, -0.04695862f, 0.01226033f, 
    0.10183643f, 0.02500619f, -0.17431001f, 0.26823494f, 0.07841758f, 0.12781456f, 0.11141068f, -0.09551477f, 
    0.12812234f, 0.14518455f, 0.08190618f, 0.00378114f, -0.01107608f, -0.01003587f, -0.09298953f, -0.05176691f, 
    0.02699087f, 0.02766635f, 0.07731296f, 0.01702509f, 0.02650844f, -0.34539351f, 0.09305954f, 0.00155761f, 
    0.01047422f, -0.08194787f, -0.15457805f, 0.00688067f, 0.12804645f, 0.22376792f, -0.40014458f, 0.09999157f, 
    0.01802267f, -0.00674198f, 0.02766592f, -0.10627864f, -0.15955912f, -0.05191949f, -0.05564980f, 0.14946942f, 
    -0.02815940f, -0.04628627f, -0.00072345f, -0.02152358f, -0.04271857f, -0.00564901f, 0.09663293f, 0.28939578f, 
    0.00788445f, 0.00362368f, -0.10317720f, 0.06006059f, 0.03305091f, 0.23318119f, 0.07597829f, -0.30549246f, 
    0.08748943f, 0.38201666f, 0.00758247f, -0.13090110f, -0.13452841f, -0.06493276f, 0.12867263f, 0.06772549f, 
    -0.02126116f, -0.00543118f, 0.03090373f, 0.01171708f, -0.05394645f, 0.03026600f, -0.05272586f, -0.00710798f, 
    0.01069145f, 0.02859942f, 0.00403979f, 0.03150321f, 0.01467758f, 0.03159759f, -0.03362824f, -0.01417277f, 
    -0.02998482f, -0.04399867f, 0.02815493f, 0.04878810f, -0.02086757f, 0.03942701f, -0.00888666f, -0.04993817f, 
    -0.03114079f, -0.02893011f, 0.04540187f, -0.04920720f, -0.00489935f, -0.03490868f, -0.00307169f, -0.02880978f, 
    0.03333919f, 0.03181036f, 0.05228336f, -0.02000206f, -0.05003322f, 0.04495243f, 0.04885114f, -0.04656034f, 
    0.01718171f, -0.04212478f, 0.00264106f, -0.01589201f, -0.04418683f, -0.05838416f, -0.02795149f, 0.04594519f, 
    -0.04222699f, 0.04575372f, -0.04169783f, -0.00500971f, 0.02053241f, -0.01055500f, -0.04694815f, -0.01222059f, 
    -0.04279859f, -0.01467927f, 0.02281263f, 0.04270964f, -0.03599589f, 0.02595990f, 0.02377446f, -0.01095559f, 
    0.03615686f, 0.01640226f, -0.04186962f, -0.01394441f, -0.04325382f, -0.00784543f, -0.06189163f, 0.04546508f, 
    -0.06431770f, -0.00495916f, -0.02690367f, 0.01695716f, 0.03311192f, -0.04439827f, 0.02272474f, 0.04439583f, 
    0.04331326f, -0.06621114f, -0.05714516f, -0.05182114f, -0.04506037f, -0.04758738f, 0.04900406f, -0.01890459f, 
    0.01170042f, 0.05325032f, 0.04301228f, -0.01164614f, 0.02407851f, 0.01123328f, -0.02830794f, -0.00048232f, 
    0.03394448f, -0.03178321f, 0.03439794f, -0.05356722f, 0.01344942f, 0.04600018f, -0.00622398f, -0.06310122f, 
    0.01310850f, 0.03168048f, 0.04214701f, 0.04590480f, -0.02607091f, -0.04747244f, -0.03793990f, 0.04612840f, 
    -0.02773315f, -0.05675001f, -0.00122783f, -0.02351066f, -0.05971908f, 0.04004802f, -0.04956627f, 0.03996932f, 
    -0.04543488f, -0.01811595f, -0.02273222f, 0.01612341f, 0.02957198f, -0.04303373f, -0.00609912f, -0.03507746f, 
    -0.05333886f, -0.05961597f, -0.02926378f, -0.05365080f, -0.03179656f, 0.00920256f, -0.03505122f, 0.01637187f, 
    -0.04306052f, -0.05971053f, 0.00260929f, -0.03608963f, -0.00531623f, -0.01964240f, -0.00333384f, -0.01794543f, 
    0.03390235f, -0.03390905f, -0.03806616f, 0.01523592f, -0.05147107f, -0.00240951f, 0.03145229f, -0.02431558f, 
    -0.02410797f, -0.05648493f, -0.06150937f, -0.03015219f, -0.04987036f, 0.02871348f, -0.05200750f, -0.02402745f, 
    -0.00321255f, 0.02102820f, 0.01937711f, -0.03516250f, -0.02162457f, 0.04010383f, 0.02548314f, -0.05984933f, 
    -0.00800338f, -0.02252079f, -0.03719114f, -0.01508507f, -0.04108215f, -0.02231058f, -0.00046802f, 0.01388426f, 
    -0.00909261f, -0.04734396f, 0.04871402f, -0.04118095f, 0.03310425f, 0.01090045f, -0.03489217f, -0.00658393f, 
    -0.03285332f, -0.03090028f, -0.03027281f, 0.02578967f, -0.01525023f, 0.02276696f, -0.01680828f, -0.00070867f, 
    -0.02553209f, 0.02565761f, 0.02676899f, 0.03568960f, -0.01505156f, 0.01990719f, -0.01848618f, 0.00634547f, 
    -0.05984931f, -0.04452419f, 0.00358184f, -0.01336952f, 0.01970265f, 0.03624776f, -0.03215348f, 0.00926835f, 
    0.02740248f, -0.02594801f, -0.03796313f, -0.05560699f, 0.03744141f, -0.05086219f, -0.02008269f, -0.04735921f, 
    0.01902200f, 0.00504333f, -0.01834114f, -0.04507571f, -0.00684091f, -0.05653377f, 0.03002904f, -0.02736174f, 
    -0.02961236f, 0.03257279f, -0.02903973f, -0.04340678f, -0.05462449f, 0.02207027f, 0.04274804f, -0.04706686f, 
    0.00995971f, -0.01410880f, -0.02461586f, -0.01439351f, -0.01023563f, 0.01333424f, 0.03637135f, -0.05723313f, 
    0.00624903f, 0.03518968f, -0.05328672f, -0.02023041f, -0.04987411f, -0.04862897f, 0.02162138f, 0.03189163f, 
    0.00943075f, -0.05625005f, 0.00645781f, -0.01366299f, -0.01080854f, 0.03520355f, -0.02705383f, 0.04605550f, 
    -0.01590388f, -0.05239286f, 0.04494780f, -0.04842784f, -0.05189380f, -0.02501328f, -0.05394119f, -0.05988324f, 
    -0.00683829f, -0.03918599f, 0.02960451f, 0.03157334f, -0.00646733f, 0.03760869f, -0.05722050f, 0.03724913f, 
    0.00704804f, 0.03359444f, -0.05005736f, 0.05313873f, 0.01615673f, -0.01522237f, -0.00568418f, 0.01287752f, 
    -0.03909328f, -0.00581609f, 0.00101778f, -0.00736760f, -0.06263422f, -0.03958606f, -0.00623324f, -0.06091570f, 
    -0.08132988f, 0.04279484f, 0.01547166f, 0.19879836f, 0.03909252f, 0.13925886f, -0.02402300f, 0.13049455f, 
    0.02778132f, 0.10117096f, 0.23765829f, -0.02069368f, -0.00081232f, 0.05336909f, 0.04055898f, 0.01127342f, 
    0.10259723f, 0.05024692f, 0.06057274f, 0.03203185f, 0.16608994f, 0.18648301f, 0.08304218f, 0.07919866f, 
    0.02101173f, 0.06531380f, 0.03137396f, -0.06145597f, -0.03306104f, -0.16246773f, 0.18624729f, 0.01891018f, 
    0.00431114f, -0.06798960f, -0.01626940f, -0.08741932f, -0.14963228f, -0.22023408f, -0.12254743f, 0.00952476f, 
    0.07399733f, 0.22967659f, -0.01577791f, 0.13793860f, -0.15149444f, -0.10840783f, -0.02939281f, -0.06540878f, 
    0.01764092f, -0.02794725f, 0.00318706f, 0.08232340f, 0.16027050f, 0.12879385f, -0.19500370f, 0.02506559f, 
    -0.14553329f, -0.19714744f, 0.07598263f, -0.00413758f, -0.11080717f, 0.19165689f, -0.19935712f, -0.16892448f, 
    -0.25350907f, 0.34054956f, 0.15290889f, -0.02799433f, 0.31543395f, 0.02476317f, -0.04887484f, 0.20286831f, 
    -0.11217867f, -0.07153461f, -0.01438158f, -0.12605812f, 0.10688503f, -0.03007789f, -0.23569217f, -0.15413265f, 
    -0.09475206f, 0.10832069f, -0.06814741f, -0.00634358f, -0.00274579f, 0.12986180f, 0.03984497f, 0.07957876f, 
    0.13000864f, 0.25886154f, -0.01451293f, 0.06994714f, 0.12301527f, -0.01810458f, -0.07723221f, 0.16881412f, 
    -0.05187676f, 0.06536245f, 0.04966808f, -0.14036144f, -0.19897620f, -0.02488862f, 0.04688574f, 0.14837462f, 
    0.06273115f, -0.26966304f, -0.20784633f, -0.39217761f, -0.10347442f, -0.05844098f, -0.13970785f, 0.09746864f, 
    -0.00384431f, 0.08688314f, 0.06448572f, -0.06639273f, -0.20545746f, 0.07432740f, 0.07292555f, -0.06156617f, 
    0.17667092f, 0.04329788f, 0.03886499f, 0.01802243f, -0.01916521f, 0.17164692f, -0.08616567f, 0.10907762f, 
    -0.05640440f, 0.13505526f, 0.21535069f, 0.12911917f, 0.21895500f, 0.16231826f, -0.11384542f, -0.29951003f, 
    0.19915646f, 0.22064283f, 0.06970174f, -0.03212081f, 0.04307675f, -0.02832259f, 0.08824215f, -0.05501980f, 
    -0.11778080f, -0.06082067f, 0.00125127f, -0.05820150f, -0.08028185f, -0.02566845f, 0.01828997f, 0.13446395f, 
    -0.16984239f, -0.06041561f, -0.01684288f, -0.12956020f, 0.01872785f, 0.04509453f, 0.19099918f, -0.12041376f, 
    -0.33112007f, 0.04715795f, 0.03287541f, -0.02505952f, 0.02855639f, 0.03516194f, 0.25327742f, 0.19703041f, 
    0.16356350f, 0.04722293f, 0.05362337f, 0.26671836f, -0.12116668f, -0.02459228f, 0.08973099f, 0.03346385f, 
    0.21916844f, 0.29193595f, -0.03856031f, 0.13778269f, 0.02176797f, 0.01980510f, -0.10724557f, -0.08456821f, 
    -0.07898609f, -0.00706054f, 0.01338027f, -0.23757492f, -0.13204291f, -0.26797742f, 0.02903876f, 0.07149751f, 
    0.13361189f, 0.04841734f, 0.07621805f, -0.18967056f, -0.14272983f, -0.19766715f, 0.02872143f, 0.00509369f, 
    0.04037351f, 0.03339638f, -0.22960427f, -0.19292311f, -0.09997121f, -0.22845772f, -0.03452833f, 0.14590631f, 
    -0.01337847f, 0.05810347f, 0.35844192f, 0.19028005f, -0.17849642f, 0.09763985f, 0.12197228f, -0.03846775f, 
    -0.06204630f, 0.05848072f, -0.02236529f, 0.08594764f, 0.14705247f, 0.04138922f, 0.06710136f, 0.04526262f, 
    0.04578409f, 0.16018422f, 0.00517964f, 0.14394245f, 0.01420536f, 0.05204386f, 0.10171635f, 0.11199718f, 
    0.03709470f, 0.11117494f, -0.06139485f, 0.06757940f, 0.20576672f, -0.08112708f, -0.06750821f, 0.13025053f, 
    0.03591336f, 0.05029972f, 0.03771968f, 0.00678847f, 0.06982978f, 0.08016739f, -0.15685731f, -0.05187990f, 
    -0.06787873f, 0.06607985f, -0.16909789f, 0.09756774f, -0.17317905f, -0.04838970f, -0.21405506f, -0.04391251f, 
    0.02687726f, 0.11365006f, -0.20423310f, 0.18301141f, -0.00802913f, 0.13109249f, -0.04645093f, 0.13584714f, 
    0.00955909f, 0.11909613f, 0.04125650f, 0.00885430f, 0.21447168f, -0.02063322f, -0.19571911f, 0.02968151f, 
    0.05458490f, -0.05368533f, 0.12586485f, 0.04661974f, 0.08183559f, -0.03227890f, 0.14774381f, 0.18833485f, 
    -0.02552065f, -0.04521209f, 0.10871264f, 0.01656174f, -0.05281973f, 0.11134032f, 0.13255379f, 0.05738648f, 
    0.00027595f, 0.25686821f, 0.04722628f, -0.15245053f, -0.17976893f, -0.00935595f, -0.01211360f, 0.01964369f, 
    0.02362585f, -0.25249285f, -0.10237817f, -0.43912983f, 0.22539489f, 0.13927996f, -0.13005634f, 0.00573283f, 
    0.11242019f, 0.22573054f, 0.12696430f, 0.33258119f, -0.22580753f, 0.05761988f, -0.09699438f, -0.02148820f, 
    0.05871086f, 0.10427525f, -0.02724410f, 0.11009282f, -0.40151983f, -0.26050419f, 0.05872857f, -0.15803570f, 
    -0.11392925f, -0.05502399f, -0.12769157f, 0.12336744f, -0.11727116f, 0.16454430f, 0.13723569f, -0.31311402f, 
    -0.07189573f, -0.09573063f, 0.14122428f, -0.08766648f, 0.12947780f, -0.18540834f, -0.23070155f, -0.28661951f, 
    -0.17785223f, 0.04509472f, -0.27743378f, 0.02265320f, 0.08131831f, 0.02193318f, 0.15134567f, 0.20245083f, 
    0.09436814f, 0.06525633f, 0.04033962f, 0.04767136f, 0.02735689f, 0.02081234f, 0.08206604f, 0.19318721f, 
    0.38357237f, 0.02572074f, -0.09715853f, -0.24720606f, 0.00007460f, 0.15811561f, 0.03262707f, -0.01256724f, 
    -0.12045258f, -0.27704319f, -0.26226971f, -0.02024093f, -0.05938868f, 0.04217191f, 0.02560067f, 0.03980995f, 
    0.16784969f, -0.13306999f, 0.07456402f, 0.25683942f, -0.06759020f, -0.05980753f, -0.25149921f, 0.05326372f, 
    -0.06512285f, -0.20883176f, -0.09415458f, 0.04207862f, -0.12754028f, 0.09847742f, 0.04929471f, -0.00399371f, 
    0.01658341f, 0.03100751f, 0.08420285f, -0.17517576f, 0.02454448f, -0.05419249f, -0.14104293f, 0.08893850f, 
    -0.03441318f, 0.03138441f, -0.09220092f, 0.06285353f, 0.06135830f, -0.13729928f, -0.46773332f, -0.04694743f, 
    0.06785840f, -0.09921917f, -0.09121211f, -0.14581126f, -0.07804275f, -0.26783505f, -0.17881514f, -0.08572551f, 
    0.01077039f, -0.03733490f, -0.07200621f, -0.04618281f, 0.13191941f, 0.10317818f, 0.04870997f, -0.31773615f, 
    -0.00886713f, -0.26881883f, 0.06950054f, 0.11358471f, 0.09796171f, 0.10435820f, -0.03560063f, 0.27566087f, 
    0.27003893f, -0.10959841f, 0.05659981f, -0.03949380f, 0.08929214f, -0.08449893f, 0.02686581f, -0.07685413f, 
    0.38402879f, 0.10085856f, -0.12238964f, 0.11828645f, 0.01141264f, 0.12079217f, 0.02767906f, 0.07879370f, 
    0.01415759f, 0.40770835f, -0.39017195f, -0.14714162f, -0.00985067f, -0.17767265f, 0.06506938f, 0.07001306f, 
    -0.02171163f, 0.01409642f, 0.07808339f, 0.11396167f, -0.02578125f, -0.07933143f, -0.07274857f, -0.06527866f, 
    0.01042976f, -0.08843835f, 0.05264142f, -0.18458913f, -0.13278435f, 0.09347180f, -0.09210764f, -0.19668521f, 
    0.06163090f, -0.02760964f, 0.20993954f, 0.00480770f, 0.40107092f, 0.00401610f, -0.07147492f, -0.02978351f, 
    0.00150674f, 0.00361368f, -0.00953978f, 0.00397704f, -0.00612309f, -0.19128852f, 0.39448634f, 0.17941895f, 
    -0.00109374f, -0.05248817f, -0.06200976f, 0.11024104f, -0.17118038f, -0.09254013f, 0.41953969f, 0.06605063f, 
    -0.23750077f, 0.11837487f, -0.01053625f, 0.28915301f, 0.01311830f, 0.08810841f, -0.13413224f, -0.20849952f, 
    -0.59011984f, 0.00209247f, 0.13849060f, -0.04847815f, -0.02957696f, 0.19831823f, 0.22493032f, 0.16865946f, 
    0.22771889f, -0.03487231f, -0.10834160f, 0.03176117f, -0.12770611f, -0.12804584f, 0.02764829f, 0.14627206f, 
    0.09648888f, -0.22526667f, -0.18106844f, 0.07518905f, -0.08341502f, -0.09573601f, -0.14589888f, 0.08922322f, 
    0.00727276f, 0.04047463f, 0.15287332f, 0.23340902f, -0.12724870f, 0.00022602f, 0.02839825f, -0.07327985f, 
    0.05221985f, 0.00217250f, 0.04094818f, 0.28285998f, 0.20084468f, -0.33244285f, -0.03536375f, 0.00325247f, 
    -0.04075171f, -0.12164195f, 0.11180176f, 0.02153901f, 0.13091716f, 0.13278285f, 0.21071239f, 0.05269107f, 
    0.03697238f, 0.09642862f, -0.05624714f, -0.05348961f, -0.03082476f, -0.42509240f, -0.06704988f, -0.09971704f, 
    -0.06470518f, -0.09779334f, -0.03803121f, 0.06134044f, 0.05590252f, 0.01989074f, 0.07956323f, 0.07436453f, 
    -0.02751186f, -0.10678831f, 0.01386520f, -0.09422700f, 0.00651752f, -0.00900504f, -0.00345669f, 0.08184653f, 
    -0.46780095f, 0.17660047f, 0.08519019f, -0.00440937f, -0.06163345f, -0.09268209f, 0.16071759f, -0.08268587f, 
    0.12651162f, -0.18782470f, 0.20592228f, -0.04749333f, -0.01335320f, 0.27683637f, -0.08811972f, 0.07962956f, 
    0.05637586f, -0.11431205f, 0.25251326f, 0.26369998f, -0.11984901f, -0.03410031f, -0.12485921f, 0.08565097f, 
    0.01753122f, -0.12434261f, -0.00333058f, 0.03459290f, 0.11787160f, -0.03385282f, 0.00690932f, 0.11995988f, 
    -0.16627261f, 0.17822933f, 0.09025040f, -0.16466904f, 0.01217560f, -0.05898074f, -0.05492271f, -0.02384448f, 
    -0.06460380f, -0.05868968f, 0.04499033f, -0.19409949f, -0.03455894f, -0.06779045f, 0.26475617f, -0.04898027f, 
    0.00695351f, -0.04908342f, 0.04388545f, 0.07418329f, -0.00546390f, -0.27285379f, -0.21939588f, -0.19529822f, 
    -0.07654931f, 0.03098648f, -0.01392035f, 0.07998958f, 0.05149416f, 0.10086332f, 0.11913059f, 0.06152347f, 
    0.16618921f, -0.07226280f, -0.15056309f, 0.09948741f, -0.07130278f, 0.11909765f, -0.08886562f, -0.01895033f, 
    0.08169657f, 0.28441536f, 0.15980376f, 0.04074993f, -0.23452824f, -0.05365259f, 0.08555851f, -0.01552170f, 
    -0.11376954f, -0.05037866f, 0.03338652f, -0.16531920f, -0.18708269f, -0.19921714f, 0.05783932f, -0.07388799f, 
    0.00307065f, -0.20298168f, -0.08112274f, -0.19133535f, -0.04041058f, 0.08421712f, -0.14947471f, -0.00197460f, 
    0.05015811f, 0.16520858f, 0.18711975f, 0.07671789f, 0.16322547f, -0.02594384f, 0.00871500f, 0.04249290f, 
    0.11124966f, 0.02979084f, 0.03726052f, -0.15032500f, 0.26024157f, -0.15170091f, -0.05365684f, -0.11507732f, 
    -0.08943951f, -0.19106603f, 0.09663035f, 0.08890742f, -0.16770573f, -0.11330998f, 0.00437035f, 0.04994101f, 
    0.09254663f, -0.12133240f, -0.11369491f, 0.19619770f, -0.15990444f, -0.07590653f, 0.27385876f, -0.19622438f, 
    0.07868045f, -0.09881645f, 0.09662896f, -0.04340765f, -0.02661021f, 0.08991221f, -0.24037695f, 0.15242837f, 
    0.26668340f, -0.01645962f, -0.05105342f, -0.13055253f, 0.03691121f, -0.07085570f, -0.04488765f, -0.09754535f, 
    -0.31748050f, 0.19155510f, 0.00076361f, 0.10956328f, -0.07732474f, 0.03467922f, -0.07758882f, 0.07639975f, 
    -0.01213609f, 0.29145816f, 0.43672726f, -0.12266593f, -0.05589887f, 0.03907793f, 0.01941466f, 0.10025759f, 
    -0.07771144f, -0.16418543f, 0.14882956f, -0.26019147f, 0.10204859f, -0.00268063f, -0.10115035f, -0.08127830f, 
    -0.05933196f, -0.00804936f, -0.01598739f, 0.14211990f, 0.20835201f, 0.01239615f, 0.10580779f, 0.02049492f, 
    0.07361646f, 0.16069311f, 0.10610073f, -0.20859365f, 0.13917527f, 0.06021051f, -0.03954055f, 0.03410917f, 
    0.13931644f, 0.09761977f, 0.07182691f, 0.06147139f, -0.33072427f, 0.22018357f, -0.04600428f, 0.04299696f, 
    -0.01388125f, 0.09314963f, 0.01842136f, -0.10341684f, -0.10429646f, -0.20236197f, -0.33036354f, 0.09576088f, 
    -0.14531478f, -0.02420362f, -0.16398032f, -0.01682080f, -0.02667903f, 0.01115075f, -0.22607052f, 0.36734611f, 
    0.31826320f, 0.01361613f, -0.08629861f, 0.08813727f, 0.00092370f, 0.02382682f, -0.13812058f, -0.07944085f, 
    -0.13203067f, 0.54447967f, 0.29971555f, 0.49143907f, -0.25759831f, -0.18010649f, -0.15789713f, 0.18420035f, 
    -0.28367278f, 0.10925301f, 0.05429495f, -0.05422003f, 0.01305454f, -0.11686530f, 0.02131316f, 0.06244699f, 
    0.12251295f, -0.07206459f, 0.24668701f, -0.10584904f, 0.06890547f, 0.09414710f, -0.03423302f, 0.01834448f, 
    0.18417840f, -0.11370455f, 0.09859156f, 0.20258811f, 0.32611403f, 0.14311966f, 0.02846485f, -0.05696818f, 
    0.06305192f, 0.17986187f, 0.08308166f, -0.22785752f, -0.15952362f, 0.36825925f, 0.02606817f, 0.02360403f, 
    -0.13760933f, 0.01882990f, -0.03729202f, -0.04280888f, 0.14568420f, -0.17241386f, 0.20828339f, -0.01429177f, 
    0.00626125f, -0.05577502f, 0.05330500f, 0.01446629f, 0.09939308f, 0.05635425f, 0.04800929f, 0.20598145f, 
    -0.08282464f, 0.01828908f, 0.26216567f, 0.02997550f, 0.04548447f, -0.02191596f, -0.06954344f, 0.03028849f, 
    -0.14101195f, 0.07640140f, 0.18647362f, -0.17167412f, 0.08149297f, 0.22124398f, 0.03509489f, -0.19186887f, 
    0.41600826f, -0.46265870f, -0.06871918f, -0.34501755f, 0.11686504f, -0.06149918f, 0.01465536f, 0.07934266f, 
    -0.13736327f, 0.10777392f, 0.07171847f, -0.02531670f, -0.01532699f, 0.15481523f, -0.07294190f, 0.03232415f, 
    -0.02341269f, 0.11067733f, 0.10022194f, 0.06365346f, -0.23847526f, -0.03028071f, -0.16548413f, -0.14956564f, 
    0.08628533f, -0.13530199f, -0.04934631f, 0.03080820f, 0.11240776f, 0.08415829f, 0.02139835f, 0.23959756f, 
    -0.07115753f, -0.02467144f, 0.01811731f, -0.00322273f, 0.04867328f, 0.03933742f, -0.08072802f, -0.05816693f, 
    0.08979882f, -0.00343874f, -0.21416646f, -0.12684759f, 0.03525537f, 0.03711867f, 0.10580686f, -0.01703657f, 
    -0.00479373f, -0.02836538f, -0.04843023f, 0.01568819f, -0.03188636f, 0.16235511f, 0.12893443f, 0.05391748f, 
    0.05086889f, 0.07238347f, 0.02968387f, -0.07117436f, -0.08111300f, 0.01279098f, -0.25062570f, 0.02733975f, 
    0.07717376f, -0.00662951f, 0.23712188f, -0.04751915f, 0.05144044f, 0.07907246f, 0.23870972f, -0.05503212f, 
    -0.14680223f, -0.01081937f, -0.08231574f, 0.20236960f, 0.08497911f, -0.08883567f, 0.07911365f, -0.05655291f, 
    0.01040406f, 0.10025080f, 0.17159884f, -0.07852361f, -0.14043351f, -0.04414915f, 0.09331616f, 0.00110208f, 
    -0.02140205f, -0.17163664f, 0.30879247f, 0.11826230f, 0.02167288f, -0.01655774f, 0.01843772f, -0.16355109f, 
    0.08940611f, -0.22519641f, 0.11238864f, 0.02128683f, 0.08629009f, -0.14087813f, -0.00492471f, 0.03415864f, 
    0.07054572f, -0.03827915f, 0.07680636f, 0.06156595f, 0.05959907f, -0.03314001f, 0.09198406f, 0.07191326f, 
    -0.00183892f, 0.26718614f, 0.20920026f, 0.08517568f, -0.03927696f, 0.10126655f, -0.01320829f, -0.04403391f, 
    -0.10725287f, 0.11714309f, 0.08138665f, -0.03169933f, 0.05204624f, -0.01660856f, 0.16511218f, 0.01453804f, 
    -0.03467950f, -0.04751558f, -0.13296583f, 0.00174333f, 0.04047754f, -0.00595919f, -0.09822284f, 0.16133033f, 
    0.32027650f, 0.02370262f, -0.05555556f, -0.23348144f, -0.05121339f, 0.07266507f, -0.19853073f, -0.08602042f, 
    -0.22661416f, 0.35578001f, -0.17280045f, 0.12215354f, -0.14097738f, -0.16164528f, 0.16581775f, -0.22464696f, 
    0.02891305f, 0.00039303f, 0.16602059f, -0.05823745f, 0.00261500f, -0.09525380f, 0.02876974f, -0.18615344f, 
    0.00752837f, -0.03248227f, 0.01514095f, 0.10644587f, 0.05458650f, -0.28399158f, -0.11645856f, 0.05403182f, 
    -0.10166634f, -0.09250551f, -0.15150481f, 0.08232095f, 0.24853051f, -0.13098674f, -0.04092417f, 0.01992650f, 
    0.04133863f, -0.19483401f, 0.03437345f, -0.03158920f, 0.16421035f, 0.02110122f, -0.12466545f, 0.04519051f, 
    0.07068975f, 0.04087831f, -0.19654635f, -0.06243681f, -0.40187323f, 0.20427492f, 0.15194558f, -0.23536670f, 
    -0.20510516f, -0.10620250f, 0.18453468f, 0.08215282f, -0.06431799f, 0.09058899f, 0.11405606f, 0.02220923f, 
    0.04999192f, 0.03489901f, 0.06778649f, 0.07038608f, 0.07826064f, 0.21389124f, 0.01957390f, -0.02135996f, 
    0.40288189f, -0.14029500f, -0.07793114f, -0.18453752f, 0.07017355f, -0.01688194f, -0.01387932f, -0.06217352f, 
    0.26867977f, 0.11007355f, -0.19561200f, -0.04304502f, 0.07440520f, 0.11831339f, 0.04934810f, -0.21007523f, 
    0.03193907f, 0.04766094f, 0.05669426f, -0.15147510f, -0.05452077f, -0.00224012f, 0.07795423f, -0.04611250f, 
    0.01677440f, -0.01393585f, 0.14210504f, 0.23290983f, -0.13105585f, -0.06078838f, 0.08785870f, 0.17129545f, 
    -0.13914169f, -0.07727223f, 0.15178160f, 0.01055902f, 0.15156046f, -0.02722829f, 0.00468596f, 0.09023650f, 
    0.07387696f, 0.04457983f, 0.07981516f, -0.29659581f, -0.10933910f, 0.16987847f, -0.12709194f, -0.01095855f, 
    -0.07508200f, 0.01507392f, 0.00102960f, -0.08017638f, 0.02378460f, -0.07482242f, -0.13326538f, 0.01866470f, 
    0.10113793f, -0.09209874f, -0.16839109f, -0.04294369f, 0.08766500f, 0.09700876f, 0.03667292f, 0.30365786f, 
    -0.05823793f, -0.06564331f, 0.20289536f, 0.09209670f, -0.01646505f, 0.00930687f, -0.18844274f, -0.14380951f, 
    0.17106429f, 0.20634072f, 0.13516694f, -0.05679504f, -0.13267921f, -0.13866441f, -0.08171485f, 0.03350530f, 
    0.83021915f, 0.03857337f, -0.06849504f, -0.08296703f, -0.08936568f, -0.12333310f, 0.09074707f, -0.08717780f, 
    -0.04237131f, -0.04457695f, -0.00667451f, 0.04136126f, 0.03713481f, -0.04137355f, -0.03670178f, -0.05322852f, 
    -0.05254497f, 0.02128742f, 0.05145574f, 0.03669447f, -0.03071745f, 0.01710857f, -0.00654602f, 0.03447895f, 
    0.00455947f, 0.02395859f, -0.01536012f, -0.00712771f, 0.02544277f, 0.05025416f, -0.05302528f, 0.03830915f, 
    -0.01574282f, -0.02875153f, 0.04231888f, -0.05375264f, 0.02333874f, 0.01199788f, -0.00570572f, 0.05363512f, 
    -0.02532461f, -0.00416188f, -0.05779334f, 0.02471322f, 0.02246376f, -0.00282521f, -0.00247751f, -0.04483696f, 
    0.01890639f, -0.01252419f, -0.00502174f, -0.02376412f, 0.02586736f, 0.05339241f, 0.05749351f, 0.04631760f, 
    -0.00832704f, -0.04779375f, -0.00147092f, -0.02641908f, 0.05283653f, -0.01536131f, -0.05666970f, -0.05326695f, 
    -0.02056950f, 0.01960373f, 0.02259367f, -0.01623339f, 0.00900481f, 0.03276472f, -0.02922965f, -0.02481559f, 
    -0.01106311f, -0.01356696f, -0.00465054f, -0.04801038f, -0.03784033f, 0.01412684f, 0.03781796f, -0.00716925f, 
    0.03845485f, -0.04917644f, 0.01948849f, 0.04131857f, 0.00241579f, -0.04933582f, 0.01956528f, -0.03916030f, 
    -0.00974406f, -0.03332341f, -0.01045990f, 0.00960048f, 0.03274557f, -0.02351185f, 0.01412912f, -0.00177812f, 
    0.04051302f, -0.03466455f, 0.04878004f, -0.01222378f, -0.01330829f, 0.03218155f, -0.00192101f, -0.00153014f, 
    -0.02583630f, -0.02909905f, -0.05487729f, -0.05009178f, 0.05255601f, 0.03045119f, -0.05443843f, -0.00212793f, 
    0.05596304f, -0.04983214f, 0.04285788f, 0.02164109f, -0.02621314f, -0.01024047f, -0.05507933f, 0.03566860f, 
    -0.05314169f, 0.03152484f, -0.05577635f, 0.00942707f, -0.03860625f, -0.01168450f, -0.05594710f, -0.00731404f, 
    0.01526025f, 0.00557828f, 0.03667925f, -0.05295089f, 0.05702854f, -0.00404133f, -0.05694674f, -0.01925790f, 
    0.04247725f, 0.03118712f, -0.05755806f, 0.01608003f, 0.03245244f, 0.02765059f, -0.04162022f, 0.03038124f, 
    -0.05188287f, 0.01530104f, 0.00733130f, -0.02651715f, 0.02109327f, -0.04498237f, 0.01753138f, 0.02428615f, 
    0.05341821f, 0.01040193f, 0.02773480f, 0.01076194f, -0.00802400f, 0.05685526f, 0.01076180f, 0.00028699f, 
    -0.05197334f, 0.04403355f, -0.02828884f, 0.01759987f, 0.00871560f, -0.00352997f, -0.05166065f, -0.00944221f, 
    -0.05331059f, -0.05651109f, -0.01778912f, -0.00287191f, 0.04192778f, -0.03672887f, -0.04459452f, -0.01228634f, 
    -0.03469395f, -0.02664045f, -0.00178980f, -0.01757278f, -0.00313664f, 0.01121049f, -0.04102318f, 0.01887205f, 
    -0.04415009f, -0.01146370f, -0.04260892f, -0.00933418f, -0.02962951f, -0.03310173f, 0.03988481f, 0.05600137f, 
    -0.04279848f, 0.00887764f, 0.02200392f, 0.01491049f, 0.03398936f, -0.04832696f, 0.01064309f, -0.01130912f, 
    -0.02707816f, -0.05536333f, 0.04410999f, -0.01836132f, 0.00526294f, -0.05471748f, -0.02388347f, -0.05090548f, 
    0.03349608f, -0.01518924f, -0.03173623f, 0.01802110f, -0.00492887f, -0.03045755f, -0.00285514f, -0.01312444f, 
    -0.03306651f, 0.02384417f, 0.05099620f, -0.04971667f, 0.02621641f, -0.01784596f, -0.02528316f, 0.04159193f, 
    -0.02675077f, 0.01820532f, -0.05624997f, -0.03412144f, -0.00459892f, 0.01707183f, -0.01349012f, 0.03002223f, 
    -0.02576626f, -0.03503904f, -0.01630423f, -0.04847854f, -0.01745275f, 0.02020374f, -0.03335632f, -0.01169324f, 
    0.05730490f, 0.02035148f, 0.02610934f, -0.00454663f, -0.04239352f, -0.05793627f, 0.01179346f, 0.03603867f, 
    0.01303623f, -0.02387047f, -0.05074776f, -0.03583537f, -0.05213865f, -0.04058206f, 0.01536097f, -0.03174660f, 
    -0.01001027f, -0.03570116f, -0.05041482f, -0.02276387f, -0.01874238f, 0.00329413f, 0.00436231f, -0.02376851f, 
    -0.04500889f, -0.00709211f, 0.02398841f, 0.03536393f, -0.05174458f, 0.02432167f, 0.04661389f, 0.04920421f, 
    0.01510493f, -0.01998831f, -0.05202466f, -0.04513399f, 0.02118564f, 0.03032312f, 0.01669454f, -0.03348324f, 
    -0.00310069f, -0.05427615f, -0.00432887f, -0.05176508f, -0.04425596f, 0.01514629f, -0.03291439f, -0.01417237f, 
    -0.04644562f, -0.05122222f, 0.03921890f, 0.05842613f, -0.00249459f, 0.02855227f, -0.00182195f, 0.04664652f, 
    0.04256765f, -0.10719609f, -0.00938181f, 0.14877601f, -0.02987662f, -0.03504503f, -0.06268154f, 0.11423084f, 
    0.22962713f, -0.21401307f, -0.15899244f, 0.06971720f, -0.16219752f, -0.06115257f, -0.06022796f, -0.07053373f, 
    -0.07187977f, 0.01526035f, -0.01889136f, -0.06700272f, -0.09065807f, -0.01480277f, -0.19020563f, -0.27990368f, 
    0.08599055f, -0.01750455f, 0.08913010f, -0.10431983f, -0.10059649f, -0.08066947f, 0.06990633f, -0.02259064f, 
    -0.06944133f, -0.00098214f, 0.01711941f, 0.01941271f, -0.06824467f, -0.21740586f, -0.05911741f, 0.07409900f, 
    0.00003478f, -0.04394534f, 0.08035372f, 0.03496991f, -0.06769621f, 0.02072864f, 0.09035370f, 0.07171451f, 
    -0.04403881f, 0.01608269f, -0.14664534f, -0.06917129f, 0.08996354f, -0.01026930f, 0.12735480f, -0.15848532f, 
    0.15644656f, -0.08294732f, -0.11869659f, 0.07783072f, -0.20760556f, 0.07640761f, -0.08939203f, -0.12053132f, 
    -0.04202430f, 0.35308945f, -0.12179928f, 0.03416793f, 0.05500438f, 0.14786364f, 0.04499191f, 0.32138908f, 
    -0.03004907f, -0.06886261f, 0.11838352f, -0.11888783f, -0.03121801f, -0.08842982f, -0.03874605f, 0.02644019f, 
    -0.20847736f, 0.02721803f, 0.19505653f, 0.01999406f, 0.01388418f, 0.01686378f, -0.06435516f, -0.03948710f, 
    0.06296447f, 0.16204247f, -0.06905027f, 0.11656187f, 0.05531968f, 0.01636869f, 0.07714494f, -0.00058405f, 
    0.10130960f, 0.09846704f, 0.01978129f, -0.00564631f, -0.03766436f, 0.21516432f, 0.04169893f, -0.09548628f, 
    -0.00090364f, -0.07285918f, 0.18062404f, -0.15581842f, -0.24720673f, -0.11447328f, -0.05231104f, 0.12563638f, 
    0.01140300f, -0.00215242f, 0.11010891f, -0.00430597f, -0.26664388f, 0.10334226f, -0.00804396f, 0.00602053f, 
    0.10774350f, 0.14108625f, 0.09372114f, 0.00099313f, 0.00591132f, 0.11378984f, 0.01293494f, -0.05197798f, 
    -0.04298971f, 0.03111500f, -0.14595951f, 0.08616277f, -0.15668534f, -0.02911348f, -0.02181304f, -0.19165434f, 
    -0.02736832f, 0.03450898f, -0.07620055f, 0.00984909f, 0.14064711f, -0.11344568f, -0.00060409f, 0.05808057f, 
    -0.08247865f, -0.07831732f, 0.00147493f, -0.17724772f, -0.02341067f, -0.01271585f, -0.05900624f, -0.03654199f, 
    -0.04604790f, -0.03998923f, 0.03112019f, -0.12933376f, 0.04699387f, 0.01923320f, 0.01502549f, 0.09365948f, 
    -0.20725065f, -0.08946281f, -0.02650086f, -0.08030763f, -0.08297195f, 0.20439702f, 0.03663812f, 0.01925828f, 
    0.07481204f, 0.04578215f, 0.18441145f, 0.18114136f, 0.06063297f, 0.28519338f, 0.09753518f, 0.06446348f, 
    0.03922872f, 0.13569207f, 0.15272176f, 0.15407725f, -0.11717090f, 0.04993906f, -0.04117707f, 0.14890578f, 
    -0.04654684f, 0.02975681f, -0.34132767f, -0.22196239f, -0.41063192f, -0.10002097f, 0.01215275f, 0.28391564f, 
    -0.02846251f, 0.06240798f, 0.10815225f, -0.04220039f, 0.07246016f, -0.05182958f, -0.25757378f, -0.10675514f, 
    -0.01851921f, -0.03409739f, 0.00166780f, 0.01020241f, -0.16863009f, -0.08460383f, -0.06383569f, 0.06355605f, 
    0.15779892f, 0.03815077f, 0.04284600f, -0.33418110f, 0.41669241f, -0.04906326f, 0.20066756f, 0.11051639f, 
    -0.08832160f, -0.02373717f, 0.01592432f, 0.09381410f, 0.02819322f, 0.13631295f, 0.08160160f, 0.03212227f, 
    0.08988084f, -0.00883550f, 0.02932955f, 0.20464668f, 0.04679902f, 0.15210235f, 0.00060994f, 0.01545219f, 
    0.01239687f, 0.00458706f, -0.06915085f, 0.10016332f, -0.02268125f, -0.00098064f, -0.01099485f, -0.18583082f, 
    0.08037925f, 0.12655039f, 0.07028976f, -0.11736965f, 0.08325589f, 0.06848375f, -0.00465603f, 0.11171844f, 
    -0.01760099f, -0.16753206f, -0.17674786f, -0.06423517f, -0.13366415f, -0.03553461f, -0.15168108f, 0.08247966f, 
    -0.02000391f, 0.12521808f, -0.04875477f, 0.13965394f, -0.06616092f, 0.23140572f, 0.05090660f, 0.25069594f, 
    -0.01189731f, 0.06627166f, 0.25163692f, 0.08086603f, 0.18134058f, 0.10582279f, -0.11145386f, 0.09883809f, 
    -0.21185148f, -0.08343013f, -0.14030719f, -0.33295333f, 0.08551046f, 0.08260630f, -0.05400955f, -0.12539035f, 
    -0.09719200f, 0.05053591f, -0.10837557f, -0.07361966f, -0.08509332f, 0.00609029f, 0.21599524f, 0.08623751f, 
    -0.01427356f, 0.00821450f, -0.01797642f, 0.01548962f, 0.03717081f, 0.00144508f, 0.01180471f, 0.02575169f, 
    0.00096108f, 0.01747663f, 0.01138566f, -0.01022200f, 0.01378549f, 0.04180116f, 0.00169472f, -0.03660492f, 
    -0.00873061f, -0.00608897f, -0.04629035f, 0.05354948f, 0.05108183f, 0.03121873f, -0.02600543f, -0.06628592f, 
    0.02851522f, -0.02115891f, -0.02482832f, -0.05882563f, -0.00093979f, -0.03479821f, 0.05281711f, -0.01033799f, 
    0.00504617f, -0.05867046f, -0.04441648f, 0.04710208f, -0.04252658f, -0.04487701f, 0.04071101f, 0.03000083f, 
    -0.04437617f, 0.04559203f, -0.06459402f, 0.02871079f, 0.00213692f, -0.03597069f, 0.04077521f, 0.02712732f, 
    0.04871059f, 0.04041755f, -0.02668717f, 0.05142271f, -0.02719218f, -0.00793670f, -0.00162988f, -0.01064650f, 
    -0.02653583f, -0.04445733f, -0.06105181f, 0.05244578f, 0.02902424f, 0.03027322f, -0.03906174f, -0.05710387f, 
    0.00726637f, 0.04800289f, -0.06086317f, 0.01045617f, 0.05290369f, 0.00264223f, -0.01376945f, -0.05838572f, 
    -0.00539901f, -0.04572961f, -0.05162011f, 0.00115190f, 0.02345167f, 0.02954519f, -0.05239687f, 0.00678490f, 
    -0.05131019f, 0.04270588f, -0.00782783f, -0.03853451f, -0.02663258f, -0.05412871f, 0.05746581f, 0.02951554f, 
    0.02485000f, -0.00340359f, -0.03934791f, 0.02329356f, -0.03617708f, -0.03554226f, -0.01095468f, 0.03067713f, 
    0.01437883f, -0.02143765f, -0.01619301f, -0.06428857f, 0.01790314f, -0.06556715f, -0.02233601f, -0.04311736f, 
    0.00249179f, 0.02361584f, -0.05052618f, -0.04012659f, 0.02027915f, -0.02186866f, -0.03672314f, 0.04320596f, 
    -0.02746758f, -0.00519422f, -0.02600173f, 0.00158518f, -0.01411526f, 0.00111327f, -0.06001686f, -0.03440563f, 
    -0.05551147f, 0.00993208f, -0.04793083f, 0.04254387f, 0.02540376f, -0.04147408f, -0.02181220f, 0.01928453f, 
    0.04335267f, 0.00495664f, -0.03235339f, 0.02995384f, -0.01929053f, 0.03081802f, 0.03945585f, -0.02657167f, 
    -0.03585040f, -0.04127064f, 0.01522839f, -0.06295871f, 0.04089129f, 0.05020443f, -0.04146502f, 0.01044854f, 
    0.03979140f, -0.05255597f, 0.01834901f, 0.00230035f, 0.03014910f, -0.01774264f, -0.02005459f, -0.01344182f, 
    -0.05859066f, 0.03020475f, 0.01990477f, -0.04253289f, -0.01203672f, 0.03326461f, 0.04564208f, -0.04486380f, 
    -0.03809781f, -0.02045322f, 0.00650818f, -0.05076365f, -0.03740231f, -0.03322130f, 0.04933602f, 0.00097456f, 
    0.00909654f, -0.02548000f, 0.04786285f, -0.02211007f, -0.04722165f, -0.06250525f, -0.05131557f, 0.03363174f, 
    0.02741915f, -0.04309332f, -0.02974356f, -0.03889905f, 0.05527213f, 0.02190191f, -0.03484886f, -0.02175517f, 
    -0.02679529f, -0.05613124f, -0.03939475f, 0.00102268f, -0.02313395f, 0.01434733f, 0.02673627f, -0.06563582f, 
    -0.06102097f, -0.02209150f, 0.04537567f, -0.03365672f, 0.02775722f, -0.00126226f, 0.04018430f, -0.04401267f, 
    0.01215928f, 0.04392523f, -0.03245357f, -0.04484324f, -0.05065028f, 0.03467598f, -0.06204825f, -0.03199879f, 
    0.05173019f, -0.00908531f, -0.03758686f, -0.02971796f, -0.00307024f, 0.02740355f, -0.04858643f, -0.05491772f, 
    -0.00046727f, 0.04771578f, 0.01687483f, -0.01170653f, 0.03959275f, -0.04396069f, 0.01572300f, 0.02595790f, 
    0.03392009f, 0.02345362f, -0.04792277f, -0.03797798f, 0.02356424f, 0.04388223f, -0.05784631f, 0.01703174f, 
    0.05893646f, -0.04304078f, -0.04240575f, 0.01666292f, -0.01027874f, 0.03442768f, -0.02065019f, 0.00928545f, 
    -0.01863021f, -0.02641696f, -0.03613042f, 0.02903940f, 0.02611169f, 0.03110902f, 0.01893561f, -0.05921928f, 
    0.05163185f, -0.05733309f, -0.01781154f, -0.02154391f, -0.03702311f, 0.00673284f, -0.05779301f, -0.01337682f, 
    -0.05494033f, -0.00378580f, 0.04845948f, -0.00908358f, 0.04994932f, -0.03017816f, -0.05359494f, 0.02223860f, 
    0.01398673f, -0.00988153f, 0.01367057f, 0.00031630f, 0.05225701f, 0.04319899f, 0.02432227f, 0.01431266f, 
    -0.04811339f, -0.06192912f, -0.01016073f, -0.05628664f, -0.01492785f, 0.03019664f, -0.04306814f, 0.01975168f, 
    0.05208941f, 0.03360680f, 0.00476663f, -0.01876703f, -0.00849171f, 0.04511905f, -0.03365195f, -0.00402384f, 
    0.19784918f, 0.26194426f, -0.11177259f, -0.10008372f, -0.03832565f, -0.00989654f, 0.01568392f, 0.03307024f, 
    0.05130423f, -0.13729692f, -0.10677452f, 0.00516188f, -0.01855775f, 0.28544345f, 0.14654841f, 0.01909722f, 
    0.16071124f, 0.21239617f, 0.08988998f, 0.07646966f, -0.07631194f, 0.19065236f, 0.12449657f, 0.16368423f, 
    0.11460537f, -0.08475970f, 0.15594214f, -0.08620153f, 0.01894488f, -0.09147864f, -0.23012877f, -0.05733887f, 
    -0.05505542f, 0.05599019f, 0.03000320f, -0.00273009f, -0.09722297f, 0.12655817f, -0.09115431f, -0.08148596f, 
    -0.14194167f, -0.16546589f, -0.04718375f, 0.09555787f, 0.19748048f, -0.11366112f, -0.23748264f, -0.29561812f, 
    0.10298692f, 0.04238657f, -0.00067772f, 0.15539907f, 0.01848891f, 0.15792002f, 0.51310867f, 0.23743993f, 
    -0.06542328f, -0.16159242f, 0.12024187f, -0.08200225f, 0.08878198f, 0.00099708f, -0.11022484f, -0.39814496f, 
    -0.27711976f, -0.15504903f, -0.09787116f, -0.14948368f, 0.03010068f, -0.08680711f, 0.29901284f, 0.01528853f, 
    -0.55237794f, -0.44771108f, 0.08586393f, 0.02298505f, 0.02074811f, 0.00613770f, -0.04737780f, 0.19434094f, 
    0.11413217f, -0.22012290f, -0.16134939f, -0.01173448f, -0.01003649f, 0.09620991f, -0.14955248f, 0.13939746f, 
    -0.03431788f, 0.15006220f, 0.28295797f, -0.02701551f, 0.19885994f, 0.07551438f, 0.02979984f, 0.10981721f, 
    -0.07517704f, -0.00936396f, 0.04382309f, -0.39435247f, -0.56496340f, -0.15315515f, -0.02750675f, -0.14528389f, 
    0.01602227f, -0.00801119f, 0.05950919f, -0.18364470f, -0.24477169f, -0.23287989f, 0.02120559f, -0.17745842f, 
    -0.16101851f, -0.03220301f, -0.01233870f, 0.05528923f, 0.04146351f, -0.10672987f, -0.13758987f, -0.18992683f, 
    0.07524166f, 0.08674228f, 0.15980361f, 0.02931630f, 0.10708670f, 0.13034232f, -0.10360143f, 0.08209553f, 
    -0.33867899f, -0.21255232f, -0.09554354f, -0.10331522f, 0.20962028f, -0.02789002f, -0.16973600f, 0.39681733f, 
    -0.00481432f, 0.10193150f, -0.06931719f, 0.08427332f, 0.14525543f, 0.01646364f, 0.07010044f, 0.02283340f, 
    0.12549368f, 0.08386743f, 0.24784745f, -0.12916228f, -0.10134455f, -0.18649490f, 0.10993205f, 0.08222924f, 
    -0.12255022f, 0.45351103f, 0.02471491f, 0.17515293f, 0.00943434f, -0.19310565f, 0.05687791f, 0.02899820f, 
    -0.04887699f, 0.02543361f, 0.04660998f, 0.01674233f, 0.03475916f, -0.05965692f, -0.10358754f, -0.04216974f, 
    -0.13349339f, -0.00222309f, -0.03565856f, 0.08242980f, -0.17821108f, -0.26987857f, -0.04025057f, -0.01300559f, 
    -0.10218847f, 0.01807132f, -0.08551323f, 0.15099446f, 0.12100896f, 0.14357044f, 0.53514022f, 0.25748104f, 
    0.01509322f, 0.00821546f, 0.25038689f, 0.02216602f, -0.07500186f, -0.54467225f, -0.33606473f, -0.34096804f, 
    0.06219829f, -0.13258007f, 0.00778523f, 0.00984400f, 0.08694432f, 0.11067289f, 0.22898036f, 0.06263064f, 
    0.41474938f, 0.14001215f, 0.06622601f, -0.06038978f, 0.13574778f, 0.00612605f, -0.15759012f, -0.28089827f, 
    -0.51777565f, -0.35473767f, 0.25133672f, -0.45954615f, -0.05328833f, -0.04282796f, 0.02556027f, 0.12504154f, 
    -0.31817389f, -0.09260275f, 0.03407548f, -0.09603813f, 0.07074422f, 0.02032875f, -0.06215134f, 0.09676994f, 
    0.29334247f, -0.16370469f, -0.65494001f, -0.06433214f, 0.01367802f, -0.10550749f, -0.24826832f, 0.04324605f, 
    0.05315948f, -0.11073765f, 0.01024998f, 0.02321428f, 0.17452326f, -0.07345693f, 0.15838255f, 0.11535878f, 
    -0.07383254f, 0.02557733f, 0.07641882f, 0.34035534f, 0.27540740f, 0.49858239f, 0.07045402f, 0.18720575f, 
    -0.14418413f, 0.24270511f, -0.02490778f, -0.00176331f, 0.03640317f, 0.30855498f, 0.01352422f, 0.08569662f, 
    0.07420895f, -0.10296271f, 0.06669436f, 0.06806178f, 0.01155834f, -0.13923539f, -0.03415167f, -0.25525442f, 
    -0.05286398f, 0.16240673f, 0.09835971f, -0.10324194f, 0.07875913f, 0.02201598f, 0.16341279f, 0.15945408f, 
    0.06463553f, -0.04369571f, 0.10212894f, 0.04669148f, -0.15923069f, 0.05765561f, 0.04728783f, -1.16934526f, 
    0.28334743f, -0.15223506f, -0.05537446f, 0.01162914f, -0.16878566f, 0.47215933f, 0.16963512f, -0.25435227f, 
    -0.03135743f, 0.55043441f, -0.31154516f, 0.01057643f, 0.06894408f, -0.00299706f, 0.01610543f, 0.02161088f, 
    -0.05477953f, 0.00825444f, -0.11454520f, -0.00217941f, 0.07064181f, -0.15670212f, 0.10922442f, -0.07996584f, 
    0.16584809f, 0.24567209f, -0.30235767f, 0.26777440f, -0.49913588f, 0.09261636f, 0.02521806f, 0.10129905f, 
    0.01280998f, -0.05247384f, -0.04725191f, 0.16721965f, 0.13457227f, -0.07632073f, -0.33803758f, -0.49186024f, 
    -0.55820596f, 0.06883847f, -0.00063581f, 0.05890166f, -0.64934695f, -0.15495135f, 0.32437611f, -0.02814126f, 
    0.00790996f, -0.18830551f, 0.15681314f, -0.14081019f, 0.08069915f, -0.25839278f, -0.15887503f, -0.08883844f, 
    0.04645231f, -0.13872136f, -0.04229375f, 0.00370355f, -0.05899987f, -0.02282642f, -0.29085341f, -0.06681788f, 
    -0.34341910f, -0.18848717f, 0.23170097f, -0.13826838f, 0.02804112f, -0.02749475f, -0.07276716f, 0.27617320f, 
    0.15449099f, -0.06446612f, -0.13181490f, -0.11015712f, -0.02078663f, -0.01072848f, -0.13646936f, 0.09986360f, 
    -0.04181777f, 0.07341042f, 0.00711641f, 0.03643611f, 0.06804283f, 0.01780880f, 0.03973100f, -0.00057802f, 
    0.11606369f, -0.05297505f, -0.28012216f, 0.07124662f, 0.16943759f, 0.04743010f, -0.18107699f, 0.08797239f, 
    -0.02437066f, 0.05181716f, 0.09264158f, 0.26020449f, 0.30928588f, 0.12887302f, 0.11267451f, 0.12721093f, 
    0.10771818f, 0.06211202f, 0.01934063f, -0.15417324f, 0.20866096f, 0.09375486f, -0.01436009f, -0.09074595f, 
    0.01631318f, -0.06096900f, 0.04907971f, -0.07974377f, 0.09657352f, 0.07001410f, 0.05864028f, -0.13318919f, 
    -0.28072688f, -0.18423896f, 0.00775762f, 0.05493793f, -0.03084690f, 0.20036465f, 0.10962093f, 0.20877877f, 
    -0.13234481f, -0.05961473f, 0.13449195f, 0.04223094f, 0.05482512f, 0.17248057f, 0.03154019f, -0.05846455f, 
    -0.12202840f, 0.13325667f, 0.24513434f, -0.17721964f, 0.00679969f, -0.05973229f, -0.06363803f, 0.35900825f, 
    0.18741386f, 0.08645983f, -0.06346069f, -0.04114534f, 0.01595514f, 0.06247485f, -0.05626143f, -0.02881607f, 
    -0.15091094f, 0.05416903f, -0.17938834f, -0.21889769f, -0.12889606f, -0.16235062f, -0.14563547f, 0.00332321f, 
    -0.22944213f, 0.02419136f, 0.16805099f, 0.27958506f, -0.22850198f, 0.23926750f, -0.22301471f, 0.01672437f, 
    0.13175964f, 0.03920040f, -0.18535875f, -0.08172441f, 0.04578300f, 0.05612730f, -0.01684371f, -0.06480999f, 
    0.05693931f, -0.02769874f, -0.03104815f, -0.22503267f, 0.07516868f, -0.20509537f, 0.08647572f, 0.00016019f, 
    0.00454588f, 0.09447122f, -0.10349317f, 0.01711170f, -0.16272350f, 0.26403937f, 0.57907414f, -0.07493772f, 
    -0.18787549f, 0.07100222f, 0.08126368f, 0.02759551f, -0.04263847f, 0.00783394f, 0.15263993f, 0.11809780f, 
    0.12533821f, -0.06929394f, -0.07020849f, 0.19771351f, 0.03821767f, 0.10475245f, -0.45844200f, -0.30426183f, 
    -0.01081572f, -0.17406558f, -0.26933461f, 0.00819402f, -0.03437780f, 0.01755341f, -0.09803472f, 0.03122051f, 
    -0.08520138f, -0.51978153f, -0.01172138f, 0.19477630f, 0.01548103f, 0.10002937f, -0.18254514f, 0.09630407f, 
    0.11928204f, 0.05847859f, 0.11318859f, -0.20179488f, -0.21569705f, -0.07163043f, -0.03941632f, 0.10395448f, 
    0.19923186f, -0.09246810f, 0.04228463f, 0.08031601f, 0.05451452f, 0.01173586f, -0.13060127f, 0.07867990f, 
    0.14159793f, -0.03444390f, -0.18251938f, 0.03580800f, -0.08775426f, 0.04897290f, 0.05545031f, 0.08764044f, 
    -0.02318211f, 0.03283497f, 0.14222549f, -0.25855696f, -0.03917639f, 0.08051496f, 0.04267675f, -0.12915313f, 
    0.05844475f, 0.03051408f, 0.08755999f, -0.10347167f, -0.60926378f, -0.25609905f, 0.00251164f, -0.02832993f, 
    -0.02834219f, -0.07460309f, 0.15925977f, 0.06675778f, -0.02140093f, -0.00255531f, 0.22300677f, -0.24315220f, 
    0.12964456f, 0.20285432f, 0.02371148f, 0.29250011f, 0.09040225f, 0.09757013f, -0.18353689f, -0.57392532f, 
    -0.04515361f, 0.06588696f, 0.07462608f, -0.10320987f, -0.00661288f, -0.01216331f, 0.16972581f, -0.27169055f, 
    -0.29060119f, -0.13921210f, -0.35781845f, -0.08803891f, -0.16608274f, -0.06802295f, -0.19795394f, 0.04976712f, 
    -0.18708892f, 0.16375569f, 0.11404513f, 0.10687749f, 0.16590175f, -0.05107779f, 0.11221123f, 0.06396101f, 
    -0.09511045f, 0.05823012f, -0.21066099f, -0.10178515f, 0.04735716f, 0.02307393f, -0.06172690f, -0.13811180f, 
    0.09873018f, -0.27969813f, -0.12591052f, -0.02158601f, 0.11467706f, -0.02072741f, 0.16169497f, 0.03662516f, 
    -0.00192606f, -0.01632127f, -0.30003911f, -0.07843597f, -0.08739940f, -0.24242188f, 0.05262484f, 0.06976839f, 
    -0.02012012f, -0.09014668f, -0.33228832f, -0.18087853f, 0.19214369f, 0.06478383f, 0.19550087f, 0.10998924f, 
    0.11391573f, 0.02849562f, -0.06423366f, 0.02854691f, -0.02167805f, 0.13757360f, -0.02354763f, -0.12155686f, 
    -0.03909470f, -0.12065434f, 0.03676866f, -0.04934270f, 0.01415657f, -0.12750107f, -0.09158977f, 0.13394172f, 
    0.16072579f, -0.00679093f, -0.02322218f, 0.13153885f, 0.10151954f, 0.07344300f, 0.23981911f, 0.24688858f, 
    0.04816792f, -0.05640342f, -0.00755935f, -0.03824262f, 0.22419961f, -0.02238634f, 0.12005428f, -0.04132465f, 
    0.09297766f, 0.07455843f, 0.00270222f, 0.13252603f, 0.02332701f, -0.05315733f, 0.00644369f, -0.03597109f, 
    0.00860045f, 0.39735055f, -0.16546015f, -0.24434225f, 0.08519031f, 0.10888126f, 0.02346267f, -0.10457737f, 
    0.06260247f, -0.08613092f, -0.00984447f, -0.18930097f, 0.06847661f, 0.12298032f, -0.01054419f, 0.10541299f, 
    0.01690124f, -0.03924159f, -0.05205951f, 0.05521855f, -0.08806430f, 0.03642758f, 0.03509041f, -0.08859394f, 
    0.03127013f, 0.12399740f, -0.09879731f, 0.09402949f, -0.20020981f, 0.08802549f, -0.00469018f, 0.07003642f, 
    0.22276358f, 0.01711197f, -0.03305528f, -0.00702640f, 0.06493864f, -0.10388696f, -0.17980579f, 0.03253767f, 
    0.05246454f, 0.06416139f, 0.04657341f, -0.19924803f, -0.07885025f, 0.01713513f, 0.17100549f, -0.00564504f, 
    -0.16269945f, 0.08987849f, 0.07952691f, 0.08035247f, 0.16691980f, 0.18888192f, 0.05900822f, -0.06153662f, 
    0.07211351f, 0.18795125f, 0.28340209f, -0.03521345f, -0.00344099f, 0.05743982f, 0.10096553f, -0.12089673f, 
    0.09415283f, -0.09461681f, 0.05390780f, 0.19434161f, -0.03746068f, 0.00797424f, 0.00694290f, 0.05432343f, 
    -0.06518918f, -0.31017834f, 0.00725261f, 0.00459139f, 0.12644194f, 0.03039955f, 0.21879379f, 0.08893949f, 
    0.05775472f, 0.17956866f, 0.09156662f, 0.00246383f, 0.12293030f, 0.09715644f, 0.17785724f, 0.11977352f, 
    -0.05744411f, 0.09044977f, -0.16375904f, -0.07966178f, 0.11679300f, -0.02349542f, 0.11734393f, 0.11374258f, 
    0.06862672f, 0.09421045f, -0.09120379f, 0.08326886f, -0.20377786f, -0.26424280f, 0.03159108f, 0.18273126f, 
    0.11353349f, 0.06424447f, 0.14966394f, 0.14271875f, 0.13562718f, 0.05092835f, 0.11993226f, 0.09312561f, 
    -0.00707769f, -0.03791741f, 0.10104477f, 0.05743602f, 0.04609763f, 0.01618416f, -0.05936068f, -0.20098834f, 
    0.05130538f, 0.11274281f, 0.02372061f, -0.05836915f, 0.01782460f, 0.08913159f, -0.10270011f, 0.10155308f, 
    0.03861439f, -0.27273953f, 0.25059128f, -0.03521305f, -0.15429255f, 0.08110318f, 0.15292780f, 0.05689476f, 
    -0.04170496f, -0.05784132f, -0.23220620f, 0.06548245f, 0.03869364f, -0.02369559f, -0.08569228f, -0.24493422f, 
    -0.25210845f, 0.05587915f, 0.08622691f, -0.18261205f, 0.06958543f, -0.08525900f, 0.05399431f, 0.03094552f, 
    -0.05172352f, 0.11364656f, 0.10410514f, -0.11964471f, 0.12036649f, 0.14449494f, 0.01432743f, 0.04603653f, 
    -0.13725054f, 0.01729706f, -0.23357625f, -0.05656663f, -0.03259920f, 0.04251227f, 0.01531036f, 0.13260405f, 
    0.06041710f, 0.08078546f, 0.15379329f, 0.05966448f, 0.23992670f, 0.08338811f, 0.32635719f, 0.07844842f, 
    0.15226169f, 0.03584211f, 0.02103548f, 0.04832394f, -0.09780841f, -0.05350951f, 0.03879327f, 0.02077871f, 
    0.11499959f, 0.09874205f, 0.13383298f, 0.14584915f, 0.04373134f, 0.00695906f, 0.14182016f, -0.18191892f, 
    -0.15199094f, 0.08169731f, -0.00093104f, 0.11961512f, -0.20104526f, -0.02524737f, -0.24473432f, 0.54206043f, 
    -0.20875792f, -0.21943164f, 0.26576328f, -0.04445374f, -0.16052683f, -0.14905088f, -0.03912752f, 0.06745238f, 
    0.23717047f, 0.40550902f, 0.05380267f, -0.17734137f, -0.11079840f, 0.14435805f, -0.05327457f, -0.00781841f, 
    -0.10029068f, -0.09073257f, 0.12499500f, 0.08514681f, -0.09787600f, -0.08832402f, -0.12576883f, -0.03541572f, 
    -0.16172035f, 0.00420348f, 0.14093049f, 0.23464625f, -0.07193685f, -0.04598591f, -0.13603905f, -0.18100086f, 
    -0.15790561f, -0.13277419f, -0.07325137f, -0.17742896f, -0.06575557f, 0.09861631f, -0.07919267f, -0.19519195f, 
    -0.16813663f, 0.06463755f, -0.01129282f, 0.02204389f, 0.40620565f, -0.05427227f, -0.58968937f, 0.04966348f, 
    -0.01369375f, -0.03784350f, 0.07467221f, 0.04530599f, 0.05750552f, 0.34919491f, -0.18859026f, -0.14896291f, 
    0.00482305f, 0.04622181f, 0.17019363f, -0.03691416f, 0.03526254f, -0.27756819f, 0.36485043f, -0.46864098f, 
    -0.07057983f, -0.06870236f, -0.06829279f, 0.19330782f, 0.09285901f, 0.05377342f, 0.05616009f, -1.27740717f, 
    -0.19464555f, -0.68890667f, -0.05092869f, 0.15527001f, -0.11381325f, 0.01572974f, -0.20242861f, -0.00204783f, 
    -0.00108666f, -0.13677277f, -0.24647093f, -0.07413569f, -0.04571601f, -0.03688718f, 0.07480679f, 0.09425175f, 
    0.16154306f, -0.28738663f, -0.04726060f, -0.37046742f, -0.02842141f, 0.02066785f, 0.04303931f, 0.04667844f, 
    0.13657062f, 0.04459148f, -0.15456189f, 0.15410815f, 0.29894465f, -0.01436719f, 0.10042935f, -0.15766354f, 
    0.05320966f, 0.06442459f, 0.05173037f, -0.16768123f, -0.24054441f, 0.29532808f, 0.05924081f, 0.12908289f, 
    -0.07500496f, -0.07697212f, 0.06563160f, 0.11585104f, -0.11938186f, 0.19093521f, 0.11091895f, -0.12965573f, 
    -0.06786455f, -0.20410688f, 0.19048844f, 0.15518393f, 0.09449285f, -0.07623041f, 0.11452755f, 0.18228064f, 
    0.04707080f, -0.04329656f, -0.03988460f, 0.08034892f, 0.10073641f, 0.10026383f, -0.01155254f, 0.21796770f, 
    0.26408702f, -0.00473434f, -0.05141401f, -0.02614176f, 0.12194713f, 0.03842188f, 0.08497804f, -0.25191832f, 
    -0.63535136f, -0.11338694f, -0.07628966f, -0.00442433f, 0.00205357f, 0.02748781f, -0.03083125f, -0.04544358f, 
    -0.01396389f, -0.05674024f, 0.16392739f, -0.13870333f, -0.05474752f, -0.01150857f, -0.02334509f, 0.13907732f, 
    0.12403214f, 0.12511891f, 0.00514454f, -0.03573782f, 0.03056620f, -0.20653051f, -0.03416631f, 0.03506282f, 
    0.18245655f, 0.19604322f, 0.17600028f, 0.13053930f, -0.56965804f, -0.01426106f, 0.01784318f, 0.05856537f, 
    0.00334274f, -0.04692620f, 0.00749723f, 0.29671976f, -0.19651322f, -0.28290063f, 0.29035896f, 0.18725663f, 
    0.18334518f, 0.06585856f, 0.01517552f, -0.03686598f, 0.03596208f, 0.03856648f, 0.21842054f, 0.01046411f, 
    -0.00054287f, -0.10936241f, -0.06379890f, -0.01997345f, 0.14063542f, -0.06364213f, -0.10797461f, 0.15889457f, 
    0.04616919f, 0.04382169f, 0.04625132f, 0.10917858f, 0.07805181f, 0.14037657f, 0.05243147f, -0.25721097f, 
    -0.19353203f, -0.24099183f, 0.02470365f, -0.09439353f, 0.02058663f, 0.06192033f, 0.04005078f, -0.42773613f, 
    -0.11319065f, 0.04817887f, 0.04537642f, -0.04170554f, 0.22778316f, 0.05302760f, 0.00258346f, -0.00051759f, 
    0.08089651f, 0.07857507f, 0.23434475f, -0.08491299f, 0.02334817f, -0.05244917f, 0.06541546f, -0.02145975f, 
    -0.04897245f, -0.01645327f, -0.03133211f, -0.28052363f, 0.00930398f, 0.12754363f, -0.03276747f, 0.06361967f, 
    0.04982895f, 0.01861710f, -0.19650654f, 0.25276613f, 0.19514862f, -0.18751258f, -0.04828387f, -0.03249137f, 
    -0.04724297f, -0.10535888f, 0.01403478f, 0.02873154f, -0.21265580f, -0.14450362f, -0.13339460f, -0.01422193f, 
    0.02965172f, 0.08310075f, 0.15446167f, 0.12967889f, 0.03800529f, -0.30886140f, -0.25833660f, -0.18375602f, 
    -0.16427922f, 0.04158017f, 0.10892585f, 0.02097399f, 0.00770339f, 0.28169325f, 0.00919825f, 0.19935507f, 
    0.11034580f, 0.18014130f, -0.00897356f, 0.15002257f, 0.11437909f, 0.23414665f, -0.01210560f, -0.04932733f, 
    -0.33790329f, -0.15329760f, -0.09391171f, -0.12326717f, -0.01927609f, -0.13446531f, -0.16230960f, -1.05817127f, 
    -0.33994085f, 0.00599153f, -0.21272714f, -0.16763595f, -0.27945024f, 0.03004714f, -0.00135795f, -0.01559763f, 
    -0.13116719f, -0.03837321f, -0.16423401f, -0.13213609f, 0.00280353f, 0.14433073f, -0.07665782f, -0.10100032f, 
    -0.23958665f, 0.16563600f, -0.01503295f, -0.19975305f, -0.13239591f, -0.02408635f, 0.03004751f, 0.07118681f, 
    0.07796848f, -0.12700555f, 0.27231181f, 0.28108251f, -0.12888481f, -0.00065723f, 0.09529659f, 0.17350283f, 
    0.02809261f, 0.05540138f, -0.07021907f, 0.19305633f, 0.10921296f, -0.00049945f, -0.15356259f, -0.22544092f, 
    -0.16675131f, 0.09553132f, 0.04608054f, -0.10068817f, -0.08255680f, -0.04561761f, 0.18223377f, -0.02658292f, 
    -0.02955326f, -0.02071900f, -0.10840652f, -0.00347142f, 0.20603304f, 0.06928279f, -0.00479611f, 0.06869451f, 
    0.12374725f, 0.02038104f, -0.00901975f, 0.01297406f, -0.06929488f, 0.05738521f, -0.09459592f, -0.12681463f, 
    -0.15549199f, -0.04081798f, -0.07429870f, 0.20737831f, 0.03959656f, -0.12085493f, 0.00517274f, -0.28844365f, 
    0.16843805f, -0.15454245f, -0.16671278f, 0.16747984f, -0.17736842f, -0.05738571f, 0.09993574f, -0.01192800f, 
    0.10049985f, 0.01082066f, 0.14061709f, 0.16280450f, 0.00434252f, -0.09767023f, 0.04353271f, 0.14667885f, 
    0.12303416f, -0.05982748f, 0.09355297f, 0.23128884f, -0.05560206f, -0.04777336f, 0.04675284f, 0.04664581f, 
    -0.04451412f, -0.13288738f, 0.22934289f, 0.07478100f, -0.15073939f, -0.12558296f, -0.08098400f, 0.08030148f, 
    0.16727304f, 0.04781948f, -0.03804435f, 0.06079789f, 0.03646430f, 0.11429941f, 0.11037430f, 0.04537706f, 
    -0.09443329f, 0.13500592f, 0.07064223f, 0.04579514f, 0.13326882f, 0.15303048f, 0.25199911f, -0.05462822f, 
    -0.04060417f, -0.09498374f, 0.01495105f, -0.07723252f, -0.11043093f, 0.07702820f, -0.01924003f, -0.05116779f, 
    -0.13003826f, 0.01355354f, -0.00125714f, 0.07412276f, 0.09275863f, -0.15296939f, 0.28503314f, 0.19215116f, 
    0.08436635f, -0.09501813f, 0.04115611f, -0.19622333f, -0.10365716f, 0.07314433f, -0.06347848f, 0.20879608f, 
    0.21433105f, -0.05299459f, -0.25716153f, 0.02692404f, -0.02859281f, -0.04812074f, 0.11549708f, 0.00235501f, 
    0.27403796f, -0.07379829f, -0.06785146f, -0.14526996f, -0.10274538f, -0.05339917f, -0.00935989f, -0.06732094f, 
    -0.06345645f, 0.24179199f, 0.22214451f, 0.03415502f, -0.01626931f, -0.15751342f, -0.05416869f, -0.06879985f, 
    0.07321271f, 0.05044041f, -0.12536331f, 0.01787988f, 0.06959891f, 0.03668027f, 0.03262281f, 0.04657625f, 
    -0.05246097f, -0.11654350f, 0.23393776f, -0.10576005f, -0.06152007f, -0.10647976f, 0.08286589f, -0.00966587f, 
    0.10045436f, -0.02115539f, 0.14284407f, -0.09282683f, 0.46421477f, 0.28010398f, 0.10009444f, -0.18227686f, 
    -0.27840403f, 0.07570426f, -0.05918159f, 0.02991194f, 0.11015369f, 0.04854589f, -0.02809288f, 0.23287109f, 
    0.04000543f, 0.04106108f, 0.00791941f, 0.08780652f, -0.00772733f, 0.02217984f, 0.28734723f, -0.03972631f, 
    -0.32839307f, -0.07594344f, -0.14849436f, -0.04237509f, 0.01170650f, 0.02893415f, -0.04787266f, 0.03447537f, 
    0.23816669f, -0.11218911f, -0.04813443f, 0.21260159f, -0.16458330f, -0.02618423f, -0.13687119f, -0.42809555f, 
    0.18027994f, 0.12905008f, -0.06754109f, -0.09002350f, -0.08134682f, -0.07211404f, 0.08941545f, -0.03615410f, 
    -0.07911415f, -0.01366252f, -0.07160304f, 0.13402675f, 0.10008498f, -0.00238909f, 0.03982669f, 0.01645240f, 
    0.13619311f, -0.18092239f, 0.28487089f, 0.10947306f, -0.04840216f, -0.12396090f, 0.03627908f, 0.03014600f, 
    0.05875051f, -0.07473458f, -0.04029122f, 0.06079681f, 0.03689973f, -0.26115778f, -0.01072500f, -0.23133168f, 
    0.01663970f, -0.18677637f, -0.12454865f, -0.02785296f, -0.00632919f, -0.10090747f, -0.13853981f, 0.00907122f, 
    -0.12359941f, 0.08404110f, -0.03747893f, 0.11870251f, 0.12941965f, -0.01867802f, -0.03219260f, 0.03786940f, 
    0.02364723f, 0.08233286f, -0.09327558f, -0.15890287f, 0.09111335f, 0.05527290f, 0.16506724f, 0.19514075f, 
    0.16342975f, 0.13250151f, 0.07629481f, 0.01433377f, -0.07716134f, -0.01164238f, 0.23696052f, 0.00859710f, 
    -0.07962775f, 0.07931425f, -0.20868443f, -0.07681115f, -0.27990344f, -0.14738546f, 0.05393763f, -0.19885901f, 
    0.09900066f, 0.35804111f, -0.06220964f, 0.05947948f, -0.06866368f, 0.00283760f, 0.06696547f, 0.03226716f, 
    -0.06913924f, -0.08913176f, 0.04246785f, 0.11852500f, 0.14068708f, -0.15053628f, -0.08407614f, 0.01911447f, 
    0.13221470f, 0.01370290f, 0.17019923f, 0.53189319f, -0.01564799f, -0.18653700f, 0.12083172f, 0.01286233f, 
    -0.03405759f, -0.12282009f, -0.20330155f, 0.22828773f, 0.10170414f, -0.01189490f, -0.16379647f, -0.07819757f, 
    -0.09581853f, 0.20674983f, 0.12506606f, 0.13488743f, -0.04055115f, 0.13982995f, 0.19543408f, -0.03074441f, 
    0.13334094f, 0.02479129f, -0.10359424f, -0.23321226f, 0.05056156f, -0.08667363f, -0.13713796f, -0.04286324f, 
    -0.05266763f, 0.03497216f, 0.08736509f, 0.09755304f, -0.05879458f, 0.05387048f, -0.09245656f, 0.10286222f, 
    -0.15662415f, -0.02625156f, 0.14667481f, -0.15524141f, 0.22861320f, -0.18058489f, 0.01104134f, -0.26986367f, 
    0.09089941f, 0.22209147f, -0.24074990f, -0.03043696f, 0.14653428f, 0.07714950f, 0.18210576f, -0.13359313f, 
    -0.09332541f, -0.00514910f, 0.12507249f, 0.22749218f, -0.08907055f, -0.13870971f, 0.02018415f, -0.09338254f, 
    0.05389874f, -0.28618789f, -0.25619814f, -0.01793346f, -0.03445736f, -0.11848229f, -0.29977307f, -0.00227117f, 
    0.08103645f, -0.08403157f, 0.05888936f, 0.22564965f, 0.09624945f, 0.14065684f, 0.15736191f, 0.10419138f, 
    0.02900052f, -0.12047182f, 0.11083124f, -0.22403663f, 0.05032152f, 0.21764271f, -0.00243326f, -0.06496327f, 
    -0.12327209f, 0.19343214f, -0.18378791f, -0.07901418f, 0.05512536f, 0.16491689f, 0.11499208f, -0.15774591f, 
    -0.17831235f, -0.11519758f, 0.14794883f, 0.03241032f, -0.01445705f, -0.14983799f, -0.16113472f, -0.09149785f, 
    -0.02430387f, -0.11440725f, -0.10537262f, 0.04070545f, 0.07557665f, -0.01659797f, -0.07457606f, 0.27453354f, 
    -0.07774903f, -0.21218233f, -0.10284923f, -0.22381184f, -0.05929458f, 0.05278940f, 0.07167841f, -0.04188190f, 
    0.02152245f, 0.12859629f, 0.10590100f, 0.06314392f, -0.01716490f, -0.00036625f, -0.10163272f, -0.04394283f, 
    -0.08160286f, 0.19185972f, 0.15730783f, -0.05021607f, 0.04056281f, 0.09846730f, -0.01033019f, -0.14334930f, 
    0.32287496f, -0.10893142f, -0.02845618f, -0.43601057f, 0.05198089f, 0.04154689f, -0.20101494f, 0.03090667f, 
    0.25416020f, 0.11199132f, 0.16915873f, 0.16816756f, 0.17426105f, -0.11713137f, -0.01968543f, -0.07350436f, 
    0.05450493f, -0.16960177f, 0.01611023f, -0.39636293f, -0.21929818f, 0.03434173f, -0.07503972f, -0.08132772f, 
    0.05530739f, 0.04371310f, 0.01737801f, 0.00358630f, -0.03752097f, -0.08203284f, -0.39166814f, 0.08447912f, 
    -0.04594520f, 0.11641514f, -0.02400569f, -0.02464397f, 0.17710148f, -0.21942364f, -0.09629430f, -0.04147787f, 
    0.03032105f, -0.04834914f, 0.01991060f, 0.00137576f, 0.07668187f, -0.03808396f, -0.19843379f, 0.01284155f, 
    0.00940768f, -0.11366779f, 0.01209210f, 0.19332488f, -0.05106777f, 0.06975792f, 0.22538526f, 0.31638327f, 
    0.46626508f, -0.08832422f, 0.02388941f, 0.35842383f, 0.04012619f, -0.04922691f, 0.16594157f, -0.10127873f, 
    -0.05455917f, -0.15475324f, -0.04659985f, -0.05103325f, -0.02121605f, -0.04098544f, 0.16085510f, -0.00970776f, 
    0.03566699f, -0.10883388f, -0.27277541f, -0.03031218f, -0.04868031f, 0.01934544f, -0.04482919f, 0.12049552f, 
    0.17296481f, 0.04901885f, 0.25916231f, 0.33333719f, 0.25518265f, -0.02601579f, 0.03431255f, 0.01068713f, 
    -0.02272760f, -0.04466350f, -0.02923662f, -0.22973239f, -0.07184217f, -0.18326817f, -0.08448089f, 0.00072512f, 
    -0.10163655f, 0.00188057f, -0.02470297f, 0.06604379f, 0.17872973f, 0.34472373f, 0.30055448f, 0.00423421f, 
    0.02643809f, 0.09055656f, 0.14841221f, 0.00383426f, 0.01972377f, -0.00774137f, -0.11661480f, -0.28221089f, 
    0.01452369f, 0.14843069f, 0.10335238f, -0.07401794f, 0.00320693f, 0.09722022f, 0.26474467f, 0.22631900f, 
    0.10796422f, -0.11146547f, 0.04967039f, -0.09885605f, -0.12741499f, -0.04604587f, -0.21030027f, -0.38614300f, 
    0.02603665f, -0.13779064f, 0.08649821f, -0.15217869f, -0.32969955f, -0.11099235f, 0.22040705f, 0.06057490f, 
    -0.02334575f, -0.30918804f, -0.36618221f, -0.08638810f, 0.04148572f, 0.13584705f, 0.01594151f, 0.08371358f, 
    0.01483406f, -0.39045885f, 0.03642887f, 0.01735113f, 0.03253077f, -0.00066237f, 0.06372038f, 0.02484385f, 
    -0.08968534f, -0.16371660f, -0.24737327f, -0.03596329f, -0.12088469f, -0.00003642f, -0.06018908f, 0.07614111f, 
    0.01101115f, -0.09493304f, -0.15980656f, -0.13917011f, -0.02273686f, -0.08109274f, -0.31117037f, -0.15360776f, 
    0.06386942f, 0.04310985f, -0.10198689f, -0.05240717f, -0.29713601f, 0.07253631f, -0.11421142f, -0.06706121f, 
    0.14753224f, -0.05662743f, -0.05547687f, 0.04113169f, 0.04904917f, 0.11610254f, 0.11095932f, -0.07051296f, 
    -0.05785703f, -0.10516831f, -0.13727677f, 0.05337911f, -0.07569043f, -0.00653064f, -0.38744572f, -0.06959767f, 
    -0.05553575f, 0.05877901f, -0.02814453f, 0.14673382f, 0.00392258f, 0.01025126f, 0.13408926f, -0.04671341f, 
    -0.28622571f, -0.28295103f, 0.08800011f, 0.14396948f, -0.00501988f, 0.15766300f, 0.06957030f, -0.09611163f, 
    0.09892150f, 0.10370752f, 0.16250339f, -0.03647709f, -0.19705768f, -0.07760292f, -0.08910641f, 0.15685374f, 
    0.12859602f, 0.41970390f, -0.07518593f, -0.35001674f, -0.00220773f, 0.02984789f, -0.02050765f, 0.00965860f, 
    0.06542598f, 0.06212817f, -0.22037473f, -0.10595445f, 0.23225300f, 0.05358553f, 0.03678735f, 0.14794026f, 
    -0.00065714f, -0.01138370f, 0.03837204f, -0.00209664f, 0.11238346f, 0.00993916f, -0.09347125f, 0.10269383f, 
    -0.01931588f, 0.05547452f, -0.08257681f, 0.17753726f, -0.00106258f, 0.00559450f, -0.04487331f, -0.16978467f, 
    0.02102420f, -0.00977377f, 0.00412539f, -0.07648849f, 0.09121494f, -0.07712705f, 0.17237145f, -0.10717578f, 
    -0.12795280f, 0.14635460f, 0.15866016f, 0.13303825f, -0.09344690f, -0.03704317f, -0.21515250f, 0.03433790f, 
    0.15762186f, -0.09045839f, 0.15684846f, 0.05969288f, -0.11216639f, -0.01167713f, -0.13253106f, 0.03503947f, 
    -0.36452293f, -0.13129355f, 0.03669127f, -0.05367934f, -0.18681733f, -0.05579118f, 0.07172068f, -0.05648182f, 
    0.53825802f, -0.22110917f, -0.28429049f, -0.12343877f, 0.05170546f, -0.12788339f, -0.08068904f, 0.00923200f, 
    0.14524540f, -0.28118041f, 0.10150995f, -0.05362704f, 0.02822143f, -0.13421692f, 0.03156006f, -0.06669316f, 
    0.00787948f, 0.02605223f, -0.18460724f, -0.13215397f, 0.07838962f, 0.03185762f, -0.00905887f, -0.00333184f, 
    0.09753440f, 0.08492502f, 0.08938130f, 0.38817504f, 0.14081010f, 0.21899264f, 0.07192650f, -0.02045784f, 
    -0.09723374f, 0.08322560f, 0.14578344f, 0.01427531f, -0.23671104f, -0.34667802f, -0.41666487f, 0.14679891f, 
    0.09172294f, -0.01876858f, -0.06738361f, 0.00112646f, 0.07773531f, 0.18543701f, 0.14487387f, 0.03515549f, 
    -0.08868970f, 0.04162911f, 0.03138462f, 0.07575266f, 0.17016800f, 0.19350313f, -0.03342374f, -0.31578466f, 
    -0.39152402f, -0.05734156f, -0.04693215f, -0.17627858f, -0.23069017f, -0.05624796f, 0.11073123f, 0.00333073f, 
    -0.05832045f, 0.04607854f, 0.07428562f, 0.24710849f, 0.07556633f, 0.08072998f, -0.00829088f, -0.07104512f, 
    -0.04120064f, 0.02446016f, 0.04122461f, -0.09742156f, 0.02875413f, 0.12257137f, 0.11773591f, -0.00579688f, 
    -0.02149787f, 0.29824355f, 0.07064466f, 0.08008325f, -0.04825651f, -0.00677458f, -0.09045456f, 0.05401064f, 
    0.01370609f, 0.16085812f, -0.25837520f, -0.08530822f, 0.15823762f, 0.15029569f, 0.08436992f, -0.00616440f, 
    0.06775881f, -0.01790637f, 0.06357756f, -0.00462049f, -0.45378888f, 0.20502894f, 0.07179121f, 0.07458231f, 
    -0.05186104f, -0.05513601f, 0.03808874f, 0.04029478f, -0.49676424f, -0.30190912f, -0.31837046f, -0.06289122f, 
    -0.14223424f, -0.05642448f, 0.03409480f, -0.00017819f, -0.02285883f, 0.04931900f, 0.12475846f, 0.20124459f, 
    0.07009070f, 0.11261287f, 0.07602282f, 0.06555233f, 0.11588865f, 0.10925815f, -0.32459837f, -0.36307499f, 
    0.02997928f, 0.07751641f, -0.14154865f, -0.13845955f, 0.09240775f, 0.07028608f, -0.20017217f, -0.04848451f, 
    0.14453068f, -0.29909408f, -0.08053876f, 0.06880719f, -0.09023698f, 0.01654010f, -0.00699811f, -0.03104408f, 
    -0.03267925f, -0.04083885f, 0.00652415f, -0.02546856f, 0.03254977f, -0.02408479f, 0.00735106f, 0.03538025f, 
    0.04635999f, -0.05026689f, 0.00073872f, 0.00240563f, -0.03693682f, -0.04722048f, -0.01501206f, -0.03199239f, 
    -0.03926758f, 0.04973755f, -0.02083136f, 0.01827104f, -0.02275502f, -0.00159599f, -0.06446443f, 0.04777574f, 
    -0.05760156f, -0.03508574f, -0.00178074f, -0.02288402f, -0.02918718f, -0.05464523f, -0.04904985f, -0.06396090f, 
    0.01960170f, 0.01792859f, -0.05148539f, 0.04173275f, 0.01993419f, 0.03364787f, 0.00782584f, 0.02215991f, 
    0.00186043f, -0.04895854f, 0.02560491f, -0.03011418f, 0.04609279f, -0.05201546f, 0.00036729f, -0.00985094f, 
    0.04276108f, -0.06338234f, 0.03047158f, 0.01122060f, -0.05661548f, 0.01407028f, -0.05831812f, 0.02137695f, 
    -0.06325367f, -0.02812237f, -0.05003041f, -0.03944511f, 0.01702240f, -0.04422164f, 0.01392899f, -0.03388336f, 
    -0.04551575f, -0.04136021f, -0.01611281f, 0.03259620f, -0.04060280f, -0.02214527f, -0.02703064f, -0.00352979f, 
    -0.00690920f, 0.01532515f, -0.03366987f, 0.01653465f, -0.00600568f, 0.03340616f, 0.03686393f, 0.02427754f, 
    0.00933528f, -0.06087465f, -0.05637727f, -0.05720229f, -0.01987117f, 0.03370081f, -0.03780480f, -0.03016881f, 
    -0.00664152f, 0.03306263f, 0.02325535f, 0.00957796f, -0.03642352f, -0.03050721f, -0.03233224f, 0.00781071f, 
    0.03884235f, 0.02205518f, 0.01326769f, 0.02879799f, -0.02679630f, 0.01215698f, 0.01217077f, -0.01370727f, 
    -0.03560301f, -0.03246723f, 0.00154750f, -0.02244749f, -0.01217612f, -0.00377145f, -0.05787736f, 0.00051470f, 
    -0.00367698f, -0.05618946f, -0.06991430f, 0.03913233f, -0.02673727f, 0.03121949f, 0.00523027f, -0.03311080f, 
    0.04650971f, -0.02413620f, 0.04329374f, -0.00913480f, 0.04261825f, 0.01258493f, -0.02720337f, -0.05580454f, 
    -0.06299968f, 0.00778741f, 0.03959242f, 0.01195064f, -0.01322253f, 0.03055274f, 0.02702006f, 0.00767179f, 
    -0.04511819f, -0.02250067f, -0.06322294f, -0.03197182f, -0.04260403f, -0.03161859f, 0.04828735f, 0.02360860f, 
    0.03603796f, -0.00220389f, 0.01929682f, -0.03141956f, -0.01977455f, -0.05071677f, -0.01808244f, 0.04561237f, 
    0.02069679f, 0.02364401f, 0.00851230f, 0.00083244f, 0.01871441f, -0.03398304f, 0.03701879f, 0.03150747f, 
    0.02344054f, -0.05140619f, -0.06747306f, -0.05319278f, -0.01678836f, 0.04361020f, -0.05689068f, -0.04086514f, 
    -0.01213164f, 0.03012234f, -0.04132871f, -0.02558730f, -0.06635229f, -0.05799669f, -0.03716963f, -0.03102059f, 
    -0.00486905f, -0.00766426f, -0.03884806f, -0.00476399f, 0.04481903f, -0.01549680f, -0.05693677f, -0.04302909f, 
    -0.00474683f, 0.03438272f, -0.03287406f, -0.00534552f, -0.06044796f, -0.05761578f, 0.00256127f, 0.02823771f, 
    -0.04760987f, -0.05293164f, -0.00193429f, -0.04459053f, 0.04192959f, 0.01992700f, -0.03476698f, 0.03669994f, 
    -0.05626200f, -0.05840129f, 0.01130221f, 0.02306851f, 0.02728796f, 0.04920415f, -0.01664335f, -0.05682123f, 
    -0.03560393f, 0.00921139f, 0.01102656f, -0.04538696f, 0.00067066f, -0.04026444f, -0.02281483f, 0.03737278f, 
    -0.00183369f, 0.04145499f, -0.03754885f, 0.00312941f, 0.01447479f, 0.04065526f, 0.01166794f, -0.01582899f, 
    0.02332782f, 0.00920401f, -0.06432138f, -0.01757937f, 0.03793968f, -0.05569448f, -0.00563522f, -0.07003265f, 
    -0.04685015f, 0.01258140f, -0.02451329f, -0.06299398f, 0.02753253f, -0.06381377f, 0.03461882f, -0.05991111f, 
    -0.06465657f, -0.01728103f, -0.04388605f, -0.01782711f, 0.02913903f, -0.03896720f, 0.03057882f, 0.03801575f, 
    0.00972343f, 0.01185133f, -0.00990022f, 0.01464763f, -0.00413494f, 0.04261706f, 0.02807797f, 0.04079844f, 
    0.02031962f, -0.01034816f, 0.02047113f, 0.02700467f, -0.03355043f, -0.00662962f, -0.03809278f, -0.02045680f, 
    -0.05775714f, -0.04493295f, -0.03058652f, -0.03549774f, -0.06606732f, -0.00789723f, -0.02332198f, -0.04581659f, 
    0.00305847f, -0.03737706f, -0.05360181f, -0.01427565f, -0.05761678f, 0.00937383f, 0.01123207f, 0.00561178f, 
    -0.06321181f, -0.01392431f, -0.04048026f, 0.02585682f, 0.03078691f, -0.03669551f, 0.03172246f, 0.00649625f, 
    -0.02442475f, -0.00483205f, -0.03501821f, 0.04385494f, 0.01996137f, 0.00184801f, -0.02703192f, -0.05988747f, 
    0.03009023f, 0.03948843f, 0.02079379f, -0.03857253f, -0.03191224f, 0.01177126f, 0.02655849f, -0.05094720f, 
    0.02889311f, 0.00388058f, -0.01821821f, -0.04786688f, -0.04864312f, -0.01752470f, 0.00237800f, 0.04122018f, 
    0.01764209f, 0.04122724f, 0.04675020f, -0.03292718f, 0.01638273f, 0.00648080f, -0.04666198f, -0.05575723f, 
    0.00179014f, 0.01959172f, 0.00874999f, 0.01766762f, -0.03062863f, -0.00673531f, 0.00024079f, -0.04045332f, 
    0.02763150f, -0.03186908f, -0.05021044f, 0.03975203f, -0.05908916f, 0.05850631f, -0.02538574f, 0.01274147f, 
    -0.01744423f, -0.01037770f, -0.02004244f, -0.05377688f, -0.04985234f, -0.01969559f, 0.02562210f, -0.04678531f, 
    -0.00985563f, 0.00338652f, -0.02190542f, 0.04178036f, 0.03197651f, 0.02169004f, -0.05056233f, 0.02850177f, 
    -0.05728585f, -0.01455378f, -0.04623019f, -0.03090526f, -0.02694513f, -0.01001685f, 0.02114156f, 0.05092374f, 
    -0.06503008f, -0.05530287f, 0.02990186f, 0.03755502f, -0.02291481f, -0.04412827f, 0.01604847f, -0.01755936f, 
    0.04108589f, 0.04685719f, 0.02799518f, 0.01257427f, 0.02956470f, -0.04575595f, 0.01431851f, 0.05272869f, 
    0.02052519f, -0.06470142f, -0.01350134f, 0.05179109f, -0.02221799f, 0.04318286f, -0.06358784f, 0.05390219f, 
    0.02062938f, -0.06082407f, -0.00175725f, -0.03625182f, 0.05084455f, -0.02362869f, 0.02311796f, -0.05336023f, 
    0.00726968f, -0.05480924f, -0.05040106f, -0.01172563f, -0.00742208f, 0.05185579f, -0.00368633f, 0.01838685f, 
    0.01732522f, -0.03499135f, -0.06456959f, -0.05022349f, -0.03856977f, -0.03604257f, 0.03864030f, -0.05377743f, 
    -0.02018155f, 0.00109050f, -0.01210326f, -0.03783933f, -0.05594914f, -0.03115330f, -0.01651944f, -0.03740390f, 
    0.02589756f, 0.03793072f, 0.02539187f, -0.05026982f, 0.03302154f, -0.06430157f, 0.01056777f, -0.06063677f, 
    -0.04257937f, -0.05650929f, 0.01226722f, 0.04038132f, 0.04781332f, -0.04248855f, -0.06101127f, 0.05000778f, 
    -0.00724613f, 0.01544192f, 0.04878399f, -0.03904000f, -0.03196882f, 0.02113313f, -0.03906754f, 0.00078026f, 
    0.02886477f, -0.02383814f, -0.01767733f, -0.05824333f, -0.02400322f, -0.05909263f, 0.00032286f, -0.06351945f, 
    0.03718815f, -0.06095532f, 0.02836180f, -0.04739781f, -0.05393335f, -0.01744824f, -0.00817844f, 0.02378379f, 
    -0.00502862f, 0.02688299f, 0.01481395f, -0.04686714f, 0.03502078f, -0.04759837f, -0.06669451f, 0.03445445f, 
    -0.00993598f, 0.01447755f, -0.06005546f, -0.05291021f, -0.01016085f, 0.04924049f, -0.01156064f, -0.04261535f, 
    -0.05087733f, -0.00108728f, 0.03707698f, -0.00860660f, -0.01822571f, -0.05460854f, -0.04647357f, -0.05867011f, 
    -0.00004297f, 0.00481640f, 0.01255240f, -0.03743144f, -0.03970278f, 0.05256157f, 0.04303097f, 0.02493584f, 
    0.04590809f, -0.04878191f, 0.04679245f, 0.05114883f, -0.03118146f, 0.01929666f, 0.02467473f, 0.00785648f, 
    -0.05231595f, 0.03829405f, -0.04281453f, 0.04582632f, 0.01851360f, 0.02021068f, -0.01473432f, -0.04073729f, 
    -0.04798323f, -0.03402252f, -0.01764511f, -0.01766895f, -0.04487795f, 0.04595049f, -0.02055137f, -0.02556268f, 
    0.02934495f, -0.00447801f, -0.05831535f, -0.03758367f, -0.03012725f, 0.03682310f, 0.01129384f, -0.02119458f, 
    0.00051602f, 0.04350615f, -0.02934383f, 0.04588405f, -0.00419688f, 0.00521132f, 0.03321670f, 0.02109637f, 
    -0.05200269f, -0.04258194f, -0.03471677f, 0.05041626f, -0.02804175f, -0.06095872f, -0.06005771f, -0.01342501f, 
    0.05015443f, -0.03333353f, 0.04758729f, -0.00162898f, 0.05266473f, -0.05030283f, 0.02231507f, -0.06445310f, 
    -0.05395129f, -0.01785316f, -0.04791322f, -0.03080180f, -0.04942048f, 0.03499594f, 0.02263419f, -0.02642757f, 
    -0.00358121f, 0.00163431f, -0.01647745f, 0.05608574f, -0.02926356f, -0.01594269f, -0.01816958f, 0.04506034f, 
    -0.04278690f, 0.01433742f, -0.00791674f, 0.02484070f, -0.00685639f, -0.02213237f, -0.05443812f, 0.03543999f, 
    0.02568356f, 0.06501048f, -0.04486310f, -0.05523867f, 0.00490848f, -0.00986011f, -0.06462291f, 0.05746141f, 
    -0.01300881f, 0.04619861f, -0.05223881f, -0.06280876f, -0.01405786f, -0.03666984f, 0.01673914f, 0.00747610f, 
    -0.02215124f, 0.03991574f, 0.01715726f, -0.04315746f, 0.00772939f, 0.00237006f, -0.00200964f, -0.05853250f, 
    0.04575653f, -0.03777554f, 0.04980110f, -0.01114258f, 0.02029104f, 0.03211581f, -0.00850248f, 0.01043044f, 
    -0.05704919f, -0.03484500f, -0.05666778f, -0.04295809f, 0.01869682f, 0.01439038f, -0.00197960f, -0.05186704f, 
    -0.02660354f, 0.01554934f, 0.01940470f, -0.04467697f, 0.01276695f, -0.06584644f, -0.01605426f, -0.00009027f, 
    0.01747666f, 0.01304435f, -0.00879950f, 0.02059128f, 0.01802211f, 0.04202747f, -0.05025630f, -0.05135540f, 
    -0.03260269f, 0.02831225f, -0.02361463f, -0.05174387f, 0.01867913f, -0.04446290f, -0.01782149f, -0.05096440f, 
    0.03652461f, 0.01778757f, -0.05287490f, -0.05055720f, 0.02173449f, -0.00535600f, 0.01872146f, 0.03327918f, 
    0.03007657f, -0.03378702f, 0.02177265f, 0.01958467f, -0.05988680f, -0.03112110f, 0.00800100f, -0.03210590f, 
    -0.00829444f, -0.03396170f, -0.04119040f, 0.02621621f, 0.02900768f, -0.00112658f, -0.05997101f, 0.01162378f, 
    0.01412131f, 0.02816445f, 0.03911869f, 0.03864783f, 0.00706513f, -0.06393853f, -0.06208216f, -0.04235991f, 
    -0.03995651f, 0.03695007f, 0.01925923f, -0.03530951f, 0.01237269f, -0.05342384f, 0.01016767f, 0.02741122f, 
    -0.03717916f, -0.01131418f, -0.01488421f, 0.00754369f, -0.01813058f, 0.00062478f, 0.03164009f, 0.02576030f, 
    0.02468565f, -0.03223296f, -0.03049575f, -0.06326444f, -0.06652516f, -0.01449170f, 0.04523272f, 0.01190415f, 
    0.01653440f, -0.04154311f, -0.05315072f, -0.06197505f, -0.01385175f, 0.01929355f, 0.04812397f, 0.00397586f, 
    -0.01958355f, 0.01894164f, 0.03733057f, 0.01456165f, 0.04517748f, -0.01263293f, -0.02942012f, 0.03543828f, 
    0.04798671f, 0.02825459f, 0.03117143f, 0.02552355f, 0.00427402f, -0.02600635f, -0.00685255f, -0.01341191f, 
    0.01875099f, -0.01022865f, -0.03802962f, -0.00472231f, -0.02943333f, 0.01709445f, -0.05947895f, -0.00259076f, 
    -0.00655334f, -0.05696916f, -0.02202853f, -0.02427759f, -0.04395347f, -0.01138405f, 0.00328811f, -0.00735660f, 
    -0.06326766f, 0.00665134f, -0.00246082f, 0.01272244f, -0.05300252f, -0.04096359f, -0.00223069f, -0.01303057f, 
    0.00729561f, 0.01556537f, -0.02715310f, -0.01411803f, -0.06453481f, 0.04158882f, -0.03723310f, -0.03905702f, 
    0.03854775f, -0.01109355f, -0.03720292f, 0.00722294f, 0.01659859f, 0.03364625f, -0.03303733f, -0.04633632f, 
    -0.03766272f, -0.05584992f, 0.03149583f, -0.04855313f, -0.04760022f, -0.02830642f, -0.04109696f, -0.03281222f, 
    0.04286022f, 0.03909752f, -0.03248003f, 0.00779707f, -0.06197305f, -0.00344566f, 0.03538606f, 0.00780792f, 
    0.03928291f, -0.00195001f, -0.06602333f, -0.01809330f, -0.05412340f, -0.04833368f, -0.01752832f, -0.02781807f, 
    0.03007497f, -0.01043080f, 0.02611512f, -0.06339843f, 0.01449519f, -0.05130297f, -0.06674854f, 0.03387321f, 
    -0.03498922f, -0.02778299f, 0.01979734f, -0.00432044f, 0.04348418f, -0.04572583f, -0.06530885f, -0.00400549f, 
    -0.04926651f, 0.02710720f, -0.02491656f, 0.00788964f, 0.01113117f, -0.01497589f, -0.02535057f, 0.01494766f, 
    -0.04629512f, 0.01588088f, 0.04219690f, -0.00058377f, 0.00191381f, -0.00241957f, 0.03734089f, 0.01630668f, 
    -0.03275604f, -0.02065891f, -0.01987403f, 0.00359793f, -0.02014015f, -0.03227812f, -0.02779559f, -0.04709208f, 
    -0.05781600f, 0.04703986f, -0.03447769f, -0.05509048f, -0.04553651f, 0.00197981f, -0.06722055f, -0.03978600f, 
    -0.03021175f, 0.00900203f, -0.01799533f, -0.04375104f, 0.01023042f, 0.00860839f, -0.03992904f, -0.00276934f, 
    -0.04334276f, -0.05202712f, -0.01877523f, 0.03288749f, 0.01930034f, -0.03446759f, -0.04734876f, 0.02154117f, 
    0.02659078f, 0.03854757f, -0.04778452f, -0.05128799f, -0.05750658f, 0.04077469f, -0.03631895f, -0.06697338f, 
    0.02194992f, -0.00535483f, 0.02381136f, 0.01294574f, -0.02049365f, -0.03834048f, 0.00034650f, -0.01017053f, 
    0.02465122f, -0.02428209f, -0.02309052f, 0.03797730f, -0.02302139f, 0.02732773f, -0.01820864f, -0.05599764f, 
    -0.09383954f, -0.07862468f, 0.20703459f, 0.00478877f, 0.04822879f, -0.09446339f, -0.11587957f, 0.23600121f, 
    -0.01199159f, -0.04551268f, 0.09981278f, 0.04211214f, 0.04639843f, -0.13190290f, -0.02649555f, -0.01756006f, 
    -0.14850329f, -0.23769611f, 0.01460966f, -0.16357933f, 0.03621508f, -0.01232652f, 0.03798055f, -0.25574672f, 
    -0.31408310f, 0.09581795f, -0.32831556f, -0.03800840f, -0.11682820f, 0.03407631f, 0.04789482f, 0.11263995f, 
    0.04528264f, -0.01889393f, -0.07969631f, 0.05975790f, 0.18798783f, 0.17085558f, 0.10349787f, 0.09176546f, 
    -0.07680295f, 0.02414651f, -0.02038660f, 0.02374571f, 0.04626405f, 0.15448077f, -0.02559282f, 0.02727820f, 
    0.01182356f, -0.16546603f, -0.15447906f, -0.05354528f, 0.10682432f, -0.06477320f, -0.10085475f, -0.17985480f, 
    0.18070994f, -0.06919108f, 0.10596743f, 0.47950086f, 0.09569686f, 0.19311941f, 0.38739693f, -0.16899423f, 
    0.22796957f, -0.28458846f, -0.15168771f, -0.24058741f, -0.14703488f, 0.09714343f, -0.03442159f, 0.01837450f, 
    0.17710744f, -0.08711337f, -0.07891268f, 0.03283947f, 0.13523036f, -0.08838886f, 0.09950896f, -0.18111347f, 
    -0.17480466f, 0.14460129f, 0.12008948f, -0.08392403f, -0.06585858f, 0.08685402f, 0.01314975f, -0.14819415f, 
    -0.19406511f, 0.06353203f, -0.08579088f, 0.04467534f, 0.08264352f, -0.06046056f, 0.01068136f, -0.03027392f, 
    0.03702740f, 0.05005578f, 0.00830170f, 0.13978088f, 0.24261774f, -0.13516366f, 0.07842649f, 0.05849862f, 
    0.13769543f, 0.21989398f, 0.05530951f, 0.01638924f, 0.01795346f, 0.03081690f, 0.00327806f, 0.06548244f, 
    0.16302043f, 0.07744901f, 0.06599973f, 0.04294582f, -0.10054131f, 0.06913757f, 0.05773615f, 0.12671138f, 
    0.02097202f, 0.01469133f, -0.02328984f, -0.06485423f, -0.16651651f, -0.09217507f, -0.03371330f, -0.06197598f, 
    0.15956104f, 0.01778202f, -0.02320942f, 0.14654979f, 0.18102421f, 0.01180011f, 0.12168957f, -0.16111287f, 
    0.06861138f, -0.23153745f, -0.10862399f, -0.12210751f, 0.09987278f, 0.04813876f, 0.03843160f, 0.07578661f, 
    0.09499836f, 0.02479402f, -0.14475903f, -0.06552021f, 0.04899521f, 0.15895455f, -0.01106274f, -0.00356635f, 
    0.23194705f, 0.03028513f, -0.12252827f, 0.08194955f, 0.09346560f, 0.05804587f, 0.02425348f, 0.04415619f, 
    0.08742293f, 0.14746912f, 0.00616032f, -0.10302196f, 0.05173180f, 0.00081051f, -0.02138289f, -0.01996083f, 
    -0.19682719f, -0.03687520f, -0.07206807f, 0.05283507f, 0.02567074f, 0.15332581f, -0.03947368f, -0.13960804f, 
    -0.02704119f, -0.09903292f, -0.03179236f, 0.09711725f, 0.04219680f, -0.03312136f, 0.16572255f, -0.25502694f, 
    0.11418392f, 0.14747697f, 0.08541087f, -0.00419016f, 0.32503313f, 0.13446888f, 0.10822822f, 0.11051361f, 
    0.00842228f, 0.13442540f, 0.11994539f, 0.03004181f, 0.06057872f, -0.08578414f, -0.03193304f, -0.06097933f, 
    -0.10548338f, -0.11286628f, -0.00551529f, 0.13519508f, 0.09495679f, 0.10581847f, 0.23018803f, 0.01172853f, 
    -0.05992373f, 0.19103841f, 0.14810704f, -0.04577295f, -0.05277009f, 0.09354666f, -0.02875674f, 0.02103882f, 
    -0.10138179f, -0.05269525f, -0.08666182f, 0.03625512f, 0.08535396f, 0.01017922f, 0.05380838f, -0.00183551f, 
    -0.29461902f, 0.14850888f, 0.11259579f, -0.04579375f, -0.11512106f, 0.08425808f, -0.00419290f, 0.02402911f, 
    -0.15400173f, 0.06075329f, 0.05783180f, 0.10836634f, -0.10574141f, 0.03907687f, 0.10470167f, -0.09952551f, 
    -0.06980476f, -0.03021317f, -0.15155770f, -0.10248055f, -0.08383957f, -0.11203217f, -0.02853827f, 0.09428056f, 
    0.12252756f, 0.10570318f, 0.20140384f, 0.22652064f, 0.00238380f, 0.00917368f, 0.25749239f, 0.06232031f, 
    0.03350457f, -0.08485416f, -0.00231415f, 0.02010558f, -0.00017069f, -0.02356678f, -0.10965890f, 0.10235077f, 
    0.00153191f, 0.12140013f, 0.02900700f, 0.00665301f, 0.10055491f, -0.01439927f, 0.11822543f, -0.06475460f, 
    -0.10626729f, -0.03768728f, -0.19721256f, -0.16446228f, -0.15744074f, -0.04252114f, -0.26069987f, 0.03006390f, 
    0.20731880f, 0.26517060f, 0.05146005f, 0.06387444f, 0.08333915f, 0.19319682f, -0.07330707f, 0.19245607f, 
    0.23504397f, 0.00924968f, -0.07558917f, 0.00276541f, -0.08748926f, 0.05250297f, -0.04067491f, 0.06125646f, 
    0.03427423f, 0.21769848f, -0.14738180f, 0.00407916f, -0.10052577f, -0.09662990f, -0.07643018f, -0.08541321f, 
    -0.04105944f, -0.03356712f, 0.10571297f, -0.05234817f, -0.18654892f, 0.08966054f, 0.06919657f, -0.07614452f, 
    0.06672801f, 0.09593587f, 0.10824608f, 0.59676647f, 0.02628490f, 0.10705125f, -0.33759752f, -0.09197080f, 
    0.24963202f, 0.09869634f, 0.22369778f, 0.03180039f, 0.10171149f, 0.12735474f, -0.19748732f, -0.07181633f, 
    0.08267292f, -0.07781431f, -0.03330703f, -0.02852412f, 0.07895215f, -0.29553920f, -0.24838096f, -0.08602168f, 
    -0.05274518f, 0.02076787f, 0.10043492f, 0.04081082f, 0.05895589f, 0.17493637f, 0.19997275f, -0.26376766f, 
    -0.13016793f, -0.10809173f, -0.04176070f, 0.10419939f, 0.15979341f, -0.06365163f, -0.08772374f, -0.34509617f, 
    -0.24790475f, -0.02277299f, 0.10848401f, 0.15621820f, 0.01163180f, 0.18555225f, 0.24847837f, -0.02961103f, 
    -0.00040175f, -0.32220468f, 0.15368246f, 0.02988529f, -0.03222609f, -0.03607470f, -0.18565345f, -0.03605627f, 
    0.00527758f, -0.89147449f, -0.36310995f, 0.55987167f, -0.17469369f, 0.04659569f, -0.00933945f, -0.02140096f, 
    -0.01360258f, 0.01701540f, 0.33762121f, 0.23024783f, -0.09639458f, 0.00024394f, 0.04289162f, -0.06815026f, 
    0.00333492f, 0.07565757f, -0.01273092f, 0.00262580f, -0.25490034f, 0.15188517f, -0.01510297f, -0.26486844f, 
    -0.25945622f, 0.02942748f, 0.10122190f, -0.08691857f, 0.31675932f, -0.09903850f, -0.21951368f, -0.19050273f, 
    -0.35720882f, -0.05108872f, 0.14158706f, 0.10792392f, -0.08585722f, 0.07463356f, -0.27017888f, -0.22942628f, 
    -0.03359309f, -0.05473685f, 0.11780070f, -0.04888240f, 0.03760127f, 0.11121821f, -0.45593154f, -0.59047765f, 
    0.24448180f, -0.34452066f, -0.07202195f, 0.01016152f, -0.03309495f, 0.04504492f, -0.05103640f, 0.42973909f, 
    0.06234638f, -0.13643634f, -0.08923566f, -0.04814894f, 0.08121172f, -0.00254592f, -0.05223358f, -0.05663497f, 
    0.16935739f, 0.24332480f, 0.26400828f, -0.07705938f, 0.04160923f, 0.04496177f, -0.01254702f, 0.07153675f, 
    0.03461669f, -0.05351052f, -0.23321562f, -0.08812802f, 0.23307341f, -0.03365555f, -0.06979905f, 0.19878928f, 
    0.02865825f, -0.08442832f, -0.12155250f, -0.03430624f, -0.05117056f, -0.01665921f, 0.07010989f, -0.09282878f, 
    0.03871627f, 0.04795495f, 0.06996590f, -0.09419861f, -0.19408329f, -0.09693496f, 0.04826360f, -0.11404664f, 
    -0.13708341f, -0.21780317f, 0.02042987f, 0.12512690f, 0.00859944f, -0.32050884f, -0.15319516f, 0.00502580f, 
    0.01307134f, 0.08855087f, 0.11735330f, 0.03925389f, 0.00400749f, -0.17907861f, -0.52167994f, -0.64952248f, 
    -0.01177643f, -0.05721279f, -0.10378095f, 0.02825855f, -0.04724310f, -0.08386149f, 0.13397950f, 0.08087086f, 
    0.15829496f, -0.09713725f, -0.00259804f, -0.08000309f, -0.04992320f, -0.06739321f, 0.02023448f, -0.28314465f, 
    -0.25028592f, 0.15260302f, 0.04596825f, -0.11281454f, 0.19761527f, 0.18062291f, -0.14302856f, 0.06648363f, 
    -0.06228375f, -0.29128876f, 0.03908561f, -0.09085397f, -0.28606108f, 0.03041900f, 0.11006273f, -0.07677942f, 
    -0.15803735f, 0.26006433f, -0.55478680f, -0.04069679f, 0.03764065f, 0.01852499f, -0.00394583f, -0.04290963f, 
    0.05562898f, 0.08532854f, 0.16224378f, 0.15447068f, 0.16513056f, -0.01464724f, -0.05490538f, -0.08053979f, 
    -0.00038077f, 0.04727425f, 0.09120473f, 0.01960721f, -0.03294900f, 0.13717918f, -0.12378775f, 0.08005284f, 
    0.09298141f, 0.02413023f, 0.17455189f, 0.04687484f, 0.07330867f, 0.22827950f, 0.08811930f, -0.05116777f, 
    0.11989243f, 0.21007906f, -0.00324859f, 0.02315845f, -0.04793814f, 0.39064243f, -0.44694173f, -0.27793041f, 
    -0.06734280f, -0.03505638f, 0.03773803f, -0.10467690f, 0.00800142f, -0.05605614f, -0.25084946f, 0.09180325f, 
    0.31009859f, -0.17872766f, 0.03039976f, 0.00002820f, -0.11398325f, 0.19982220f, 0.17015897f, -0.77394354f, 
    -0.32246977f, 0.31250703f, -0.12473283f, -0.18414837f, -0.11528594f, 0.12684827f, 0.07903250f, 0.15532212f, 
    -0.05985501f, 0.02247394f, -0.05937262f, -0.01536179f, 0.03981704f, -0.05161045f, -0.03630227f, -0.00745935f, 
    0.04544403f, 0.01836415f, -0.02252143f, -0.02468477f, -0.02801464f, -0.05755476f, -0.09439152f, -0.05754928f, 
    0.04494203f, -0.02552615f, -0.05969120f, 0.00499966f, -0.04823750f, -0.06707262f, -0.00857801f, -0.05052058f, 
    -0.03398760f, -0.07937289f, -0.02914108f, -0.06603231f, 0.00476474f, -0.02514667f, 0.01282420f, -0.00542999f, 
    0.03621211f, -0.01775195f, 0.02562371f, -0.02882938f, 0.00991606f, -0.04124240f, -0.05816071f, 0.03787319f, 
    -0.05656036f, 0.03462057f, -0.04632759f, -0.01903465f, -0.03342159f, -0.02658313f, 0.02318844f, -0.04075762f, 
    -0.03141725f, -0.03121229f, 0.01653256f, -0.04459904f, 0.03780814f, -0.06797756f, -0.00953160f, -0.00690598f, 
    0.02420492f, 0.01656099f, -0.02634208f, 0.00401593f, 0.01724133f, -0.04661967f, -0.00945915f, -0.05147018f, 
    0.06437897f, -0.04172820f, 0.03714284f, 0.02552712f, 0.03055785f, -0.05514405f, -0.01216838f, -0.04473010f, 
    -0.04326019f, 0.00327340f, 0.03533160f, -0.01468832f, -0.08721466f, 0.01855381f, -0.04275779f, -0.02683084f, 
    -0.00712946f, 0.00765758f, 0.01839144f, -0.06020850f, -0.03453265f, -0.00337058f, 0.00664881f, -0.06179912f, 
    0.00481214f, -0.06722362f, 0.00548317f, 0.02954703f, -0.02796927f, -0.02141672f, 0.00808159f, -0.03217040f, 
    -0.05246960f, 0.01553484f, -0.04977709f, -0.09056150f, -0.05124762f, -0.06709957f, -0.03782402f, -0.05935900f, 
    0.00531969f, -0.04353457f, -0.00486635f, 0.00550125f, 0.02203053f, 0.03521623f, -0.06068894f, -0.00377460f, 
    -0.00111486f, -0.00074975f, 0.01287064f, -0.03109087f, 0.03805350f, 0.01770846f, -0.07049423f, 0.03451287f, 
    -0.02604033f, 0.03654182f, -0.02053360f, -0.05768326f, 0.01228336f, 0.00123017f, -0.00709310f, -0.02811257f, 
    0.00910401f, -0.07320916f, -0.06364088f, -0.00977407f, -0.05935514f, -0.01908981f, 0.00458332f, 0.00851045f, 
    -0.05611982f, -0.04365567f, 0.04345041f, -0.02484230f, -0.02896446f, 0.00501098f, -0.06541790f, -0.02900619f, 
    -0.02363441f, 0.03741260f, 0.02478727f, -0.04552677f, -0.06301612f, 0.01329009f, 0.03117816f, 0.00037920f, 
    0.01799381f, -0.04935511f, -0.01894624f, 0.02175903f, -0.06303141f, -0.01241439f, 0.00049656f, 0.00142178f, 
    -0.00407695f, 0.03129464f, -0.04626767f, -0.06420697f, -0.07716303f, -0.00319936f, -0.06677923f, -0.01240375f, 
    -0.04418670f, 0.01515996f, -0.05567063f, -0.01877748f, -0.05137694f, -0.06828603f, 0.02655214f, -0.06790005f, 
    -0.05647471f, -0.07382876f, 0.01263985f, -0.04836296f, 0.00580865f, -0.03064177f, -0.00528501f, 0.03297364f, 
    0.02519355f, -0.02848604f, -0.01482323f, -0.01051559f, -0.07968239f, -0.03623370f, -0.00262787f, 0.01967965f, 
    -0.05536662f, -0.02985635f, -0.06768579f, 0.03214025f, -0.03410073f, -0.04557964f, 0.03419187f, -0.00836507f, 
    -0.02668465f, -0.01790814f, 0.02110771f, -0.01173909f, -0.02949261f, 0.04468631f, 0.02227500f, -0.06867646f, 
    -0.06341972f, -0.04780771f, -0.07230630f, -0.08126247f, -0.03156372f, -0.02114002f, 0.02482382f, -0.05125620f, 
    -0.07162056f, -0.03254447f, 0.01577659f, -0.02910588f, -0.01124394f, -0.04225978f, -0.05343734f, -0.03777226f, 
    -0.05415525f, -0.07888395f, -0.07238972f, 0.00092933f, -0.03492062f, -0.01095515f, 0.00919501f, 0.01811844f, 
    0.01374948f, -0.07219576f, -0.03001840f, -0.01623080f, -0.03192270f, -0.06934897f, 0.00815157f, 0.00006785f, 
    0.02872986f, -0.00632805f, -0.02990613f, -0.05893221f, -0.00591500f, 0.00957441f, 0.04809282f, 0.02585473f, 
    -0.02567482f, -0.01564287f, 0.00092727f, 0.04158568f, -0.05483747f, -0.06877643f, -0.01755753f, -0.00452246f, 
    -0.04832743f, -0.02678659f, -0.02136199f, 0.01022434f, 0.01484390f, -0.05809254f, 0.01710264f, -0.00384520f, 
    0.00182693f, -0.05851728f, 0.01256809f, -0.03626243f, -0.06040708f, -0.03258252f, -0.05458322f, -0.01332435f, 
    0.00996244f, 0.05220040f, 0.00034908f, -0.07276180f, -0.04763982f, 0.01044324f, -0.06929623f, 0.00398230f, 
    0.01398987f, 0.01643414f, 0.02309920f, -0.04397235f, -0.11019309f, -0.03132640f, -0.05122981f, -0.08289301f, 
    0.21102275f, -0.06100147f, 0.19693917f, 0.16163136f, 0.14496905f, 0.06746070f, 0.06526061f, -0.02111121f, 
    -0.19062160f, -0.04866982f, -0.10598971f, 0.00177380f, -0.06739773f, -0.11670730f, -0.17216295f, 0.05251064f, 
    0.05398510f, 0.11398847f, -0.02867734f, 0.02821491f, 0.15212223f, -0.22665828f, 0.01773293f, 0.03789041f, 
    0.00542919f, 0.07479897f, -0.08674038f, -0.04241050f, -0.08961908f, -0.25063387f, 0.13216347f, -0.01520845f, 
    0.06476733f, 0.25428039f, 0.07289220f, 0.05855937f, -0.10378927f, -0.18335994f, 0.19497198f, 0.10625042f, 
    0.06047852f, 0.12637433f, 0.01985399f, 0.08403534f, -0.08344900f, -0.12503408f, -0.12614399f, -0.15780023f, 
    -0.15766048f, -0.05955348f, -0.12909551f, 0.23976557f, 0.18197794f, 0.16660692f, 0.02734250f, 0.07100748f, 
    -0.01256494f, -0.11467803f, 0.02719883f, 0.07082649f, -0.07663982f, -0.19513124f, 0.10719784f, 0.04220178f, 
    -0.14434870f, 0.30385849f, 0.09956591f, 0.01107087f, -0.09102868f, -0.09705751f, -0.05304403f, 0.02596081f, 
    -0.19729654f, -0.11287299f, -0.13947856f, -0.09653094f, -0.07080697f, -0.15543118f, -0.04722095f, -0.09500118f, 
    0.04821838f, 0.21384159f, -0.23971204f, -0.37591544f, 0.07889746f, -0.08199538f, -0.08676341f, 0.06548481f, 
    0.25559282f, 0.02470879f, -0.07235265f, 0.06300904f, 0.10326409f, 0.06407095f, -0.03898568f, 0.08333760f, 
    0.17741935f, 0.00855305f, 0.18149842f, -0.20079935f, -0.15732928f, 0.05312948f, 0.04413643f, 0.04248059f, 
    0.07140381f, 0.14122179f, -0.23476906f, -0.04313694f, -0.00032045f, -0.10708919f, -0.22086345f, 0.23218407f, 
    0.03595587f, 0.07345420f, 0.22071818f, 0.07181918f, -0.19354968f, 0.08874424f, 0.01347468f, -0.01318766f, 
    0.05083560f, 0.09369679f, 0.11108290f, 0.11588004f, 0.09978555f, 0.08646359f, -0.26767811f, -0.17947063f, 
    -0.32819897f, 0.13913809f, 0.15973367f, 0.03790781f, -0.01494407f, -0.10416413f, -0.11122129f, -0.16091853f, 
    0.07610483f, 0.23194236f, 0.15317249f, -0.08035696f, -0.07635964f, 0.15623687f, -0.03368871f, 0.05860078f, 
    -0.12946086f, 0.02927013f, 0.16491573f, 0.08847275f, 0.04521415f, 0.20559019f, 0.13851467f, 0.01323252f, 
    0.18742730f, 0.03050846f, -0.17175698f, -0.27968261f, -0.00674516f, 0.04991585f, 0.19180848f, -0.09564086f, 
    0.02322921f, 0.06324665f, -0.02929289f, 0.13250858f, 0.21077916f, 0.21067214f, 0.18635276f, 0.03756209f, 
    0.02822927f, 0.06450263f, 0.06329594f, 0.06511408f, 0.01435101f, -0.16471478f, 0.04530083f, 0.01497593f, 
    0.13890100f, 0.15878418f, 0.13826029f, 0.07754751f, -0.29553318f, 0.24599992f, 0.08589622f, -0.08755108f, 
    -0.00028280f, 0.19545810f, -0.10544521f, -0.09821711f, -0.16693179f, 0.01555532f, -0.06276673f, 0.31203315f, 
    -0.06807785f, 0.08513366f, 0.03470340f, 0.21031563f, -0.18647814f, -0.07295747f, -0.49915516f, 0.02490658f, 
    0.17579539f, -0.07446694f, -0.11854987f, 0.07627486f, 0.13779378f, 0.07342038f, 0.14684288f, 0.06127422f, 
    -0.24918745f, -0.29918176f, 0.38163450f, 0.21012074f, 0.02575243f, 0.06943195f, 0.21999153f, -0.03366661f, 
    -0.02137971f, -0.09353928f, -0.11130432f, 0.09548185f, 0.02242748f, 0.05750433f, 0.18787752f, 0.17672940f, 
    0.10658720f, -0.10117684f, -0.18829675f, 0.01373840f, -0.08921669f, 0.08429330f, 0.03743729f, -0.05360270f, 
    0.18576957f, 0.11970875f, 0.12543100f, 0.00347343f, 0.21987726f, 0.06214033f, -0.05185852f, -0.01488229f, 
    0.11671383f, -0.01193514f, 0.04686929f, -0.12533084f, 0.15800555f, 0.16691387f, 0.12194719f, -0.07735410f, 
    0.08215435f, 0.03185605f, 0.00946210f, 0.03750290f, 0.06061016f, 0.00564625f, 0.15184101f, 0.04796136f, 
    -0.01816084f, 0.13404559f, 0.10670137f, 0.14028072f, 0.02536872f, 0.14378124f, 0.21241985f, 0.02998208f, 
    0.08877195f, 0.08005767f, 0.04534139f, 0.19488455f, 0.06299918f, 0.23163371f, -0.04689625f, -0.12743229f, 
    -0.11084705f, 0.02430870f, -0.05381892f, -0.11960275f, 0.03254368f, 0.05451993f, -0.03995086f, 0.24415249f, 
    -0.26966721f, -0.35344461f, -0.11423888f, -0.02267809f, -0.14026707f, 0.09347178f, -0.05350237f, -0.06773634f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.25302914f, 0.02603623f, -0.07977838f, 0.11031070f, 0.28942215f, 0.13778569f, 0.08648117f, 0.19117841f, 
    -0.19006030f, -0.10175075f, -0.01917271f, 0.18782233f, -0.04918573f, 0.07842182f, 0.01125133f, 0.05722803f, 
    0.31896237f, 0.04882781f, 0.06741673f, 0.15361889f, 0.07030942f, 0.29539311f, -0.02169080f, 0.06174507f, 
    0.17610221f, -0.06194634f, 0.04054475f, 0.00361810f, 0.03468084f, 0.04659865f, 0.01438953f, 0.18351890f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.27238935f, 0.08663277f, -0.05739434f, 0.03883210f, -0.10514713f, -0.00690500f, -0.10254356f, 0.32093212f, 
    -0.30825686f, 0.03644154f, -0.14171031f, 0.05450980f, -0.35088354f, 0.20547810f, 0.12191014f, -0.01949593f, 
    -0.09092519f, 0.11176099f, -0.08112083f, -0.00589877f, 0.16780868f, -0.09089556f, 0.03062416f, -0.12333727f, 
    0.07669408f, 0.02709899f, 0.07045355f, -0.00846014f, -0.18095912f, -0.24051750f, 0.00239611f, -0.12951300f, 
    -0.02454440f, -0.03056239f, 0.00242571f, 0.06230358f, -0.26138970f, -0.28093848f, 0.30830234f, 0.38266748f, 
    0.18112931f, -0.04448945f, 0.02767991f, 0.01039294f, 0.26027545f, 0.20530318f, 0.02113871f, 0.02090313f, 
    0.22031026f, -0.01706311f, -0.16657472f, -0.32014948f, 0.10021418f, -0.62198019f, -0.25069502f, -0.16993091f, 
    0.44490096f, 0.15951212f, 0.05609417f, -0.13738354f, -0.03414641f, -0.54036599f, -0.07971513f, 0.19958167f, 
    -0.04335370f, -0.04410764f, -0.20808516f, -0.20828605f, -0.16866006f, -0.22852534f, 0.25475010f, -0.54950500f, 
    -0.09207036f, 0.15953073f, 0.11272453f, 0.01900510f, 0.01971528f, 0.06152027f, -0.34624738f, 0.00434047f, 
    0.16044584f, 0.07447228f, 0.18057901f, -0.14717047f, -0.14774501f, -0.04240948f, 0.08342519f, 0.52695566f, 
    -0.40293530f, -0.12300143f, 0.01633320f, 0.17638496f, -0.17999201f, 0.36381963f, -0.03014075f, 0.25887680f, 
    0.04774138f, -0.11342183f, -0.18726635f, 0.00782500f, -0.17642497f, -0.04629167f, -0.00236504f, 0.06635649f, 
    0.15519479f, 0.05517947f, -0.12227768f, -0.13490041f, -0.09414539f, -0.07920165f, -0.04617735f, 0.13505781f, 
    0.06287646f, 0.14857458f, -0.12073965f, 0.06532706f, -0.18264513f, -0.12255744f, 0.07579373f, -0.00106210f, 
    0.03420867f, 0.17447187f, 0.09181640f, -0.09670154f, -0.16236596f, -0.15448964f, 0.07594509f, -0.03733493f, 
    -0.28448275f, 0.05605535f, -0.01406759f, -0.01652969f, -0.02134456f, 0.18466602f, 0.24206543f, 0.35963938f, 
    -0.08086324f, -0.34676385f, 0.09246909f, 0.28552365f, 0.12964594f, -0.17429741f, 0.26453513f, 0.07338797f, 
    -0.11152270f, -0.02458059f, 0.40233791f, -0.12850283f, 0.04605598f, 0.50564414f, 0.01121191f, -0.34335363f, 
    0.18283281f, -0.04977589f, -0.14591321f, 0.08126522f, -0.05727692f, -0.04389372f, -0.07925111f, -0.09444360f, 
    0.13285868f, -0.20511077f, 0.22567305f, -0.01536884f, 0.01073359f, -0.30419612f, -0.18389174f, 0.39185041f, 
    0.31701860f, -0.20098542f, 0.02016804f, 0.17292404f, 0.41536638f, -0.32118136f, 0.04317744f, 0.15335467f, 
    -0.02485418f, -0.07561170f, 0.43735319f, 0.01452849f, 0.10375383f, -0.26098645f, 0.13272218f, -0.04952183f, 
    0.33076027f, 0.08548291f, -0.04127807f, 0.09988982f, -0.02964231f, -0.19436775f, 0.10779976f, 0.02122657f, 
    0.03703124f, -0.18901949f, 0.04380744f, 0.22347821f, -0.29747301f, -0.34895638f, -0.29940048f, 0.05091919f, 
    0.38336334f, -0.14676875f, 0.16379388f, -0.00459828f, 0.22206603f, -0.27623272f, -0.00882266f, -0.06687963f, 
    -0.13168564f, -0.18894911f, 0.47000811f, 0.38759586f, 0.38538671f, -0.09829386f, 0.05382915f, 0.16582510f, 
    -0.20229179f, 0.01325400f, -0.11656432f, -0.07264254f, -0.05951710f, -0.04586422f, 0.07240512f, 0.20192674f, 
    -0.19799952f, 0.14073767f, -0.04236002f, -0.02947450f, 0.20958884f, 0.33985797f, -0.12209052f, 0.09837769f, 
    0.04396463f, -0.06361042f, -0.05812687f, -0.20956193f, 0.26578471f, -0.10193343f, 0.11025710f, 0.17539172f, 
    0.15255967f, -0.07008541f, -0.24511391f, -0.02426808f, 0.19466847f, 0.63354403f, -0.02463008f, 0.05913913f, 
    0.10769173f, 0.05653310f, 0.08000647f, 0.11875381f, 0.19370764f, 0.00387762f, -0.11966611f, -0.08145152f, 
    -0.07315492f, 0.13207908f, 0.15232916f, -0.02996110f, -0.14586824f, -0.12305402f, -0.13050750f, -0.06971563f, 
    -0.02783447f, -0.06807207f, 0.06465127f, 0.02985740f, -0.04405745f, -0.11798753f, -0.12054947f, -0.17467271f, 
    -0.04047138f, 0.15369308f, 0.01470286f, -0.00802668f, -0.12680271f, -0.13733095f, -0.12801667f, 0.16968025f, 
    -0.15321882f, 0.15850613f, -0.07960705f, -0.00908383f, -0.07846352f, -0.16704354f, -0.06938884f, -0.12601514f, 
    -0.17737709f, 0.01926128f, -0.49406269f, -0.34459221f, -0.03631392f, -0.09539586f, 0.05395834f, 0.00042040f, 
    -0.32424206f, 0.27808070f, 0.17545390f, 0.22112972f, -0.06824630f, 0.25426888f, -0.37496769f, 0.02282300f, 
    0.45198867f, -0.04973265f, 0.02702171f, 0.05754200f, -0.06013301f, -0.28468937f, -0.53061444f, 0.17468894f, 
    0.37120369f, 0.03518896f, -0.10847338f, 0.06681664f, -0.13683020f, 0.45433235f, 0.04927571f, 0.23354462f, 
    -0.27370369f, 0.20691077f, -0.17275932f, -0.43765795f, 0.36034673f, 0.20586698f, -0.01190117f, 0.38706705f, 
    0.12861577f, 0.21422426f, -0.05634478f, 0.34449971f, 0.18823266f, 0.22896974f, -0.34944806f, -0.09510141f, 
    0.15859988f, -0.10564097f, 0.01751252f, -0.16264243f, 0.05469607f, 0.17438866f, -0.14895348f, -0.28117186f, 
    0.43058509f, -0.06291333f, -0.16511762f, -0.07925080f, 0.00158291f, 0.13068111f, -0.11499715f, -0.09829130f, 
    0.00118102f, -0.12752546f, -0.13145700f, -0.31110233f, -0.06716634f, -0.13757633f, 0.22679889f, -0.53993416f, 
    0.07663046f, 0.00887222f, -0.09847924f, 0.27740154f, 0.26449555f, -0.27924761f, 0.02425766f, 0.10403652f, 
    0.14928745f, -0.15415049f, 0.26023775f, -0.25858989f, 0.18951903f, -0.13598537f, 0.26372990f, -0.27278775f, 
    -0.20035142f, -0.01614920f, -0.03160683f, 0.03566002f, -0.22352107f, -0.08167336f, 0.01439145f, 0.05548406f, 
    -0.08555546f, 0.20718940f, -0.03969839f, -0.22816896f, -0.20276098f, -0.08059531f, 0.15486825f, 0.16643277f, 
    0.42141068f, -0.07065722f, -0.03037034f, 0.23299684f, 0.59320688f, 0.00857901f, 0.05418231f, 0.00992803f, 
    -0.14721242f, -0.18478940f, 0.24566050f, -0.11805116f, 0.02730899f, -0.63349515f, 0.21155104f, 0.30262810f, 
    0.50494766f, -0.03645794f, 0.09578884f, -0.01209962f, -0.15153614f, 0.24158373f, -0.12108273f, 0.00830196f, 
    -0.41355690f, 0.02297113f, 0.22080681f, -0.03339282f, 0.26835161f, 0.09396914f, 0.07271814f, -0.18999523f, 
    -0.05131126f, 0.06051364f, -0.16919991f, -0.09414326f, -0.29301861f, 0.12195590f, 0.13670999f, 0.04692598f, 
    -0.02380419f, 0.13880961f, 0.32782415f, 0.17382553f, -0.07645860f, 0.59841955f, -0.02091257f, -0.02330610f, 
    -0.00606377f, 0.02181143f, -0.14555310f, 0.07425550f, 0.07073756f, 0.58323383f, -0.08393718f, -0.09826715f, 
    0.09865260f, -0.16831355f, -0.10786251f, -0.13951102f, -0.10834962f, -0.17199525f, 0.10036068f, -0.17296463f, 
    -0.01486448f, 0.06386866f, 0.11514154f, -0.14309551f, 0.10847178f, -0.02678858f, -0.12327845f, -0.13696219f, 
    -0.11503674f, 0.08536559f, -0.09188084f, 0.04253989f, -0.11969538f, -0.07621484f, 0.13055743f, -0.04424519f, 
    0.15402628f, 0.07802111f, -0.03106098f, 0.08743435f, 0.06986253f, -0.17629141f, 0.09725231f, -0.10836427f, 
    0.06303056f, 0.14607598f, 0.15034139f, -0.07602050f, -0.10745906f, 0.02740830f, 0.32128325f, 0.35727379f, 
    0.20270492f, -0.09036072f, 0.10639795f, -0.19403771f, -0.17911811f, -0.23548925f, 0.20620580f, 0.12620036f, 
    0.06168921f, -0.04559730f, -0.18581745f, -0.07047042f, 0.10422971f, 0.17259766f, 0.06337256f, 0.26863956f, 
    0.01249177f, -0.12390803f, 0.07135439f, -0.03961357f, -0.04725173f, -0.47719696f, 0.15798661f, -0.05045423f, 
    -0.12986787f, -0.06665368f, -0.08133747f, -0.05774460f, -0.02670890f, -0.12363893f, -0.09868181f, 0.11838254f, 
    -0.14906447f, -0.12049684f, -0.00627149f, -0.12627915f, 0.10869468f, -0.11200822f, 0.08483987f, -0.17330687f, 
    0.06639671f, -0.12509890f, -0.05586222f, 0.04190702f, 0.05081408f, 0.08581462f, 0.08930165f, 0.05936857f, 
    -0.16945650f, -0.15324214f, 0.13000752f, 0.12764820f, -0.12122241f, 0.06264866f, 0.04970894f, -0.16019008f, 
    0.07140788f, -0.06728173f, -0.05772416f, -0.04630944f, -0.03021404f, -0.15890801f, 0.02612683f, -0.05100220f, 
    -0.09326918f, 0.05671682f, 0.15938155f, -0.11308406f, 0.05690958f, 0.00686016f, -0.12870401f, 0.13557284f, 
    -0.03562589f, 0.14103700f, -0.09184778f, 0.08139871f, -0.00009363f, 0.01263634f, -0.10906262f, -0.14389993f, 
    -0.07430641f, 0.15417133f, 0.02358919f, -0.09315021f, -0.04524336f, 0.13853407f, -0.04049714f, 0.06160171f, 
    0.20347960f, -0.10866494f, 0.14214748f, -0.11369565f, -0.44529998f, 0.00456058f, -0.15476348f, 0.27473676f, 
    0.00017272f, 0.01573757f, -0.10575057f, -0.08379648f, 0.14196022f, 0.25951600f, 0.15514258f, -0.13567108f, 
    -0.08906220f, 0.00515102f, -0.12810817f, 0.30706054f, -0.03252185f, 0.09702747f, 0.10020988f, -0.08249225f, 
    0.25977695f, 0.05573994f, -0.08518679f, 0.12651053f, -0.19563709f, -0.39643037f, -0.11134959f, 0.14741972f, 
    0.06714715f, -0.22587299f, -0.19003509f, -0.10042962f, -0.12414437f, -0.00228159f, -0.04812735f, 0.18159112f, 
    -0.19310419f, 0.22853068f, -0.07394049f, 0.08843827f, -0.00757871f, 0.18160725f, 0.00444666f, 0.06585614f, 
    0.19528675f, -0.15115781f, -0.24559645f, 0.30050841f, 0.19060527f, 0.59259760f, -0.04853289f, 0.30027884f, 
    -0.32846925f, 0.14062478f, 0.03250561f, 0.02561139f, -0.12580201f, 0.43829715f, 0.19302112f, -0.03707884f, 
    -0.14778200f, 0.01699295f, -0.17764544f, -0.06410349f, 0.03228263f, 0.00609262f, -0.18456560f, -0.11240992f, 
    -0.13719459f, -0.19985396f, -0.14879932f, 0.06886314f, 0.01612602f, 0.02561364f, -0.15912406f, 0.08471186f, 
    -0.05481081f, 0.11008525f, -0.08376423f, -0.14632088f, -0.19878574f, -0.21327755f, -0.04430017f, -0.03332496f, 
    0.05772180f, -0.08019287f, 0.08685482f, -0.02718229f, 0.06483460f, -0.08174674f, 0.15200089f, 0.10932331f, 
    0.00575585f, -0.06045220f, -0.15996438f, -0.11206541f, -0.11764817f, 0.04882371f, -0.00066595f, 0.14228924f, 
    -0.15867531f, 0.08933049f, -0.08373432f, -0.14017740f, 0.07592122f, -0.10718112f, 0.03820480f, 0.04685676f, 
    -0.15214288f, -0.05173398f, 0.11926951f, 0.06002485f, 0.00956644f, 0.16096130f, -0.13649587f, -0.00187843f, 
    0.00737071f, 0.03772135f, 0.11446970f, 0.06109896f, -0.00393192f, -0.02150903f, 0.13915254f, -0.08846751f, 
    0.41794240f, -0.48034441f, 0.37111229f, -0.22100477f, 0.51078355f, -0.07043882f, -0.17487738f, -0.51955277f, 
    0.12465900f, -0.38554910f, 0.05482284f, -0.28468731f, -0.02636191f, 0.29498067f, 0.24523991f, 0.12233481f, 
    0.05642007f, 0.05397692f, -0.28350183f, 0.26804745f, 0.31116450f, 0.27690428f, -0.44241378f, 0.18035972f, 
    -0.34882939f, -0.04612497f, 0.12743528f, -0.03528493f, 0.34189302f, -0.24963355f, -0.08358236f, 0.14991076f, 
    -0.17898934f, 0.01926701f, 0.16958734f, 0.09279768f, -0.34848344f, 0.02528958f, -0.05448386f, -0.14737666f, 
    -0.03605440f, 0.04412612f, 0.00125044f, 0.04538213f, 0.26219267f, 0.33775005f, 0.11900620f, -0.08955731f, 
    -0.25815642f, 0.06240527f, 0.31492430f, -0.36495423f, 0.11415976f, 0.53026646f, 0.14651981f, 0.08154763f, 
    -0.04918325f, 0.00354622f, -0.01205810f, 0.10192155f, -0.02914305f, 0.66538823f, -0.04035665f, -0.09022994f, 
    -0.28879187f, 0.02174795f, -0.23756650f, -0.35420126f, 0.16372710f, -0.20708969f, 0.44483536f, -0.24958976f, 
    -0.01917955f, 0.39030316f, -0.05158507f, 0.26478463f, 0.27943400f, 0.06435972f, -0.23208915f, 0.05289682f, 
    0.40436327f, -0.14755680f, 0.09812756f, -0.10913987f, 0.06853033f, -0.22003360f, -0.25061771f, 0.17424117f, 
    -0.06986786f, 0.01285680f, 0.12477015f, 0.15707600f, -0.11318254f, 0.02678179f, -0.15215448f, 0.14371984f, 
    -0.22357985f, -0.05173147f, -0.20304789f, -0.07199320f, -0.29029128f, 0.06252117f, 0.13702615f, 0.62150437f, 
    0.03153573f, -0.25982782f, -0.07247014f, 0.22535649f, -0.03945577f, -0.13274546f, -0.34562081f, 0.12772967f, 
    0.30830833f, -0.03390875f, 0.12261891f, 0.10667707f, 0.23396531f, -0.30432954f, 0.01246580f, 0.25085518f, 
    0.35297161f, 0.09164283f, 0.11316195f, 0.05089539f, -0.34417972f, -0.17690787f, -0.13359475f, 0.27445537f, 
    -0.20366843f, -0.28248382f, 0.17874971f, 0.03784601f, 0.39458665f, -0.06684524f, 0.01230652f, 0.03038617f, 
    -0.14982408f, -0.51957721f, 0.03514657f, -0.02191105f, -0.37184146f, 0.14532135f, 0.34116849f, 0.16321194f, 
    0.09794790f, -0.11814877f, 0.51016486f, -0.02067824f, 0.19415919f, -0.67817509f, -0.47100317f, -0.17063634f, 
    0.00701411f, -0.09003136f, 0.03757083f, -0.14501078f, -0.00586148f, -0.27946618f, -0.08995682f, 0.13970682f, 
    0.05924669f, -0.06663130f, 0.12958442f, -0.11203990f, -0.56678897f, -0.34046277f, 0.08495077f, -0.35503027f, 
    0.37190431f, -0.04116803f, -0.03665865f, 0.21020788f, 0.42141885f, -0.15444122f, 0.21773225f, 0.08806986f, 
    -0.17444640f, 0.01116624f, 0.38736677f, -0.28058174f, 0.05534008f, 0.03414068f, 0.33769900f, 0.23949768f, 
    -0.32466844f, 0.10084367f, -0.04329184f, -0.17441985f, 0.10786806f, 0.00507176f, -0.03917454f, -0.01210587f, 
    -0.09601623f, 0.12085278f, 0.10980396f, 0.08371086f, -0.00741012f, 0.13412388f, -0.22560757f, -0.04658290f, 
    0.21948355f, -0.29230970f, 0.02512653f, -0.10038357f, -0.19178791f, -0.08125580f, 0.27538940f, -0.10593568f, 
    0.01441548f, -0.10815290f, 0.48541096f, 0.47082520f, 0.17585762f, 0.18844530f, 0.22383295f, 0.30734268f, 
    -0.11831540f, 0.11824115f, 0.00790893f, -0.04623000f, -0.02285326f, 0.45978624f, -0.19222599f, -0.18977341f, 
    -0.26107883f, 0.22470208f, 0.20893498f, -0.20074120f, 0.54207772f, 0.31097037f, 0.05014608f, -0.23218158f, 
    -0.23125032f, 0.08037224f, -0.08011323f, -0.00851777f, -0.25952569f, 0.12241945f, -0.03847149f, 0.12433901f, 
    0.31595352f, -0.08687341f, 0.28336254f, 0.10460826f, -0.09968462f, 0.52264017f, -0.18534486f, 0.04392697f, 
    -0.18133946f, -0.15654090f, -0.11693770f, -0.04235202f, -0.06002070f, 0.42755717f, -0.08425365f, -0.00944354f, 
    -0.02525525f, 0.10434735f, -0.22686246f, -0.11039775f, 0.22564350f, -0.16401580f, 0.12945323f, 0.08526560f, 
    -0.14118613f, -0.21967715f, -0.05151607f, 0.13486646f, 0.08904985f, -0.16712418f, -0.09862270f, 0.00436388f, 
    0.04973596f, 0.16090985f, -0.15695094f, 0.08720442f, 0.24913418f, -0.13721748f, -0.00842088f, 0.10275206f, 
    -0.11984666f, 0.09579494f, 0.05091420f, 0.06493305f, 0.04598014f, -0.25263003f, -0.10149012f, 0.31950989f, 
    -0.34574217f, -0.05923092f, -0.18866093f, -0.01255927f, -0.07127670f, -0.10384342f, 0.01951908f, -0.02227766f, 
    -0.21540087f, -0.07935111f, -0.00140767f, 0.28302330f, -0.04879786f, 0.06180699f, -0.47430697f, 0.04980742f, 
    0.35856551f, 0.12786694f, 0.26212421f, 0.22644936f, 0.28139499f, 0.15783709f, -0.18702768f, -0.07283657f, 
    -0.12571757f, 0.14352979f, 0.14829358f, 0.00811109f, -0.19010359f, -0.50749516f, 0.05236017f, 0.31883788f, 
    -0.09403645f, 0.02471533f, -0.20021716f, -0.11142750f, -0.41048229f, -0.32893276f, -0.02525382f, -0.01717351f, 
    -0.14773142f, -0.05691593f, 0.14329845f, 0.31642175f, -0.25484428f, 0.45764518f, -0.30669484f, -0.13567045f, 
    0.17278095f, 0.13778089f, 0.12719519f, 0.02312701f, -0.08354711f, 0.50854486f, -0.34116438f, -0.11436906f, 
    -0.13245906f, 0.06378143f, -0.16591769f, -0.02772043f, 0.16016811f, -0.32431388f, -0.04282627f, 0.37405887f, 
    -0.22094907f, -0.26297188f, -0.10560472f, 0.03279427f, -0.18752216f, -0.07321360f, 0.14759101f, 0.09774254f, 
    -0.26926318f, -0.05286660f, -0.10360661f, 0.12776761f, -0.29810494f, 0.35056457f, -0.09492262f, 0.02747920f, 
    0.36963961f, -0.03730249f, -0.20685552f, -0.12240928f, 0.18406135f, 0.20607542f, 0.06589557f, 0.37716419f, 
    -0.37053540f, -0.06520815f, 0.16918182f, 0.02054374f, 0.07446767f, -0.17550465f, 0.05032901f, 0.26401934f, 
    -0.00463505f, -0.04735010f, -0.02207475f, 0.13780047f, 0.02484982f, -0.25666466f, 0.19657148f, -0.09718177f, 
    -0.10070225f, -0.01245841f, -0.02350178f, 0.12171325f, 0.05328309f, 0.12069015f, 0.27339867f, -0.01053484f, 
    0.10960015f, 0.02345461f, 0.24315226f, -0.42620915f, -0.15848346f, -0.01815009f, -0.02904819f, -0.54959238f, 
    0.48835015f, 0.13603610f, -0.00433860f, -0.16508029f, 0.12224922f, -0.02157747f, 0.12993655f, -0.00803978f, 
    -0.11411358f, -0.16398081f, 0.00010108f, 0.15817890f, -0.09184799f, 0.07292366f, 0.22870541f, 0.10169289f, 
    -0.29886708f, 0.28795639f, 0.04482828f, 0.21276569f, -0.43414617f, 0.31285334f, 0.18252200f, 0.01626742f, 
    0.27691528f, 0.04273434f, -0.05530062f, -0.24582551f, -0.05767492f, -0.38732600f, -0.20203745f, 0.15520899f, 
    -0.04627851f, -0.02546398f, -0.04860631f, 0.01793379f, -0.03230166f, 0.15565017f, -0.09464362f, 0.16475415f, 
    0.16393822f, -0.47550160f, 0.02364664f, 0.32490340f, -0.05419442f, -0.61030662f, -0.26702002f, -0.06698927f, 
    0.12275966f, -0.19079281f, 0.03287267f, -0.01403323f, 0.03319205f, -0.22266342f, -0.10754409f, -0.14211859f, 
    0.04931875f, -0.07482588f, 0.06154402f, 0.19861113f, 0.32588980f, -0.04402986f, -0.00623117f, 0.66226816f, 
    -0.58543217f, 0.11924493f, -0.02839109f, 0.12088622f, 0.26240420f, 0.36339673f, 0.03179920f, 0.28241780f, 
    -0.26914391f, -0.09926371f, 0.01557136f, 0.16193606f, 0.37725094f, 0.26519367f, 0.12164624f, 0.12579329f, 
    -0.03256138f, -0.02439164f, 0.00748589f, -0.11315593f, 0.42185906f, 0.12256002f, 0.19342828f, 0.06286483f, 
    0.19872719f, -0.02866189f, -0.60239959f, -0.30614403f, 0.00928645f, 0.33678460f, -0.04900849f, 0.04276359f, 
    0.51241624f, -0.01836404f, -0.07790069f, -0.11448276f, -0.13837089f, -0.62353623f, -0.12691188f, 0.07963100f, 
    0.14249966f, -0.13861911f, 0.12928911f, 0.06208849f, 0.34550765f, 0.00242047f, -0.08329038f, -0.34496355f, 
    -0.24143830f, 0.07793497f, 0.02181755f, 0.10592252f, -0.13024254f, 0.22291155f, -0.00488685f, -0.04026916f, 
    0.16197032f, 0.05466697f, -0.34669328f, -0.03131059f, 0.20185047f, 0.07331609f, -0.20930763f, -0.37124828f, 
    0.09258636f, -0.10724267f, 0.13913658f, 0.10564449f, 0.27139446f, -0.33671278f, 0.08896866f, 0.21076506f, 
    0.10607967f, -0.20335014f, 0.13256031f, -0.15427232f, -0.30330071f, 0.14994630f, -0.03406617f, 0.32732224f, 
    0.47034144f, -0.19887654f, 0.06815708f, 0.04846228f, 0.43137595f, -0.04798322f, 0.04294163f, -0.11252324f, 
    -0.34515151f, 0.09348778f, 0.24276431f, 0.00848481f, 0.12162773f, 0.44071776f, 0.33560982f, 0.32509077f, 
    0.02924532f, -0.02652484f, 0.12425497f, 0.00977496f, 0.09733607f, 0.37833369f, 0.07021181f, -0.28436741f, 
    -0.01638809f, -0.04240972f, 0.09816214f, 0.01007439f, -0.23507345f, 0.21065590f, 0.21227378f, 0.44458628f, 
    -0.00336203f, -0.12039652f, -0.00373640f, 0.23784955f, -0.19735254f, 0.29995787f, -0.05861654f, 0.10853279f, 
    0.03686219f, 0.02430602f, 0.15875188f, 0.02988139f, -0.09654219f, -0.36540216f, -0.19304565f, -0.14947577f, 
    0.46597141f, -0.11488488f, -0.16421156f, 0.01424966f, -0.01949119f, -0.41967446f, 0.17146520f, 0.21666223f, 
    -0.02172403f, -0.11000648f, -0.17892930f, 0.09037568f, 0.12433469f, 0.01820794f, 0.06965908f, -0.01663459f, 
    0.31229791f, 0.04453372f, -0.08850319f, -0.05683069f, -0.06316846f, -0.05146407f, 0.16775775f, 0.00146138f, 
    0.10035765f, 0.14910550f, -0.38998362f, 0.10439821f, -0.29272702f, 0.22383857f, 0.18996295f, 0.22751068f, 
    0.46649557f, -0.07414563f, 0.08217854f, 0.14804395f, -0.14905748f, -0.06108491f, 0.11890095f, -0.14587897f, 
    -0.16754788f, 0.09319019f, 0.15338823f, 0.00513228f, 0.08782841f, 0.25474858f, -0.17390420f, 0.10560600f, 
    -0.01752866f, -0.00894569f, 0.10605375f, 0.08131065f, -0.27312714f, -0.12731175f, 0.05819376f, -0.00500243f, 
    -0.07384800f, -0.02503798f, -0.22890177f, 0.04033046f, -0.11991905f, 0.10094967f, 0.10051072f, -0.12841617f, 
    0.36655879f, -0.17209642f, 0.01222005f, 0.03524524f, -0.10435057f, -0.03991272f, -0.01903867f, -0.25628272f, 
    0.13824908f, 0.04334864f, -0.13019928f, 0.14760403f, 0.65828657f, -0.00861195f, -0.02716987f, -0.11420705f, 
    0.07100319f, -0.22906394f, -0.06639552f, 0.05585745f, -0.12006813f, -0.02081706f, -0.06730855f, 0.06261083f, 
    0.13439021f, -0.11116014f, 0.06953213f, 0.04283118f, -0.11620448f, 0.24221377f, -0.14933796f, -0.35182226f, 
    0.12653624f, -0.02071277f, -0.09398580f, -0.00665119f, 0.28029215f, -0.41550738f, 0.04316917f, 0.01392582f, 
    0.19929895f, -0.07008199f, 0.09282065f, -0.12678637f, -0.00993278f, -0.08194884f, -0.48997533f, 0.31058863f, 
    0.08420704f, -0.14480184f, -0.10163459f, 0.05598670f, 0.03058155f, 0.09530687f, 0.09797333f, 0.05538652f, 
    -0.12953195f, 0.02923982f, 0.18824653f, 0.39321715f, 0.26842099f, 0.24860124f, -0.03091961f, -0.27062261f, 
    0.05951535f, 0.14820008f, 0.14551507f, 0.04630428f, 0.02447831f, -0.14190848f, -0.18499480f, -0.10314909f, 
    0.06863899f, 0.10930850f, -0.16772485f, 0.12140515f, 0.28146660f, -0.03442882f, -0.18902904f, -0.43786281f, 
    0.20879906f, -0.05097448f, -0.12086318f, 0.11472902f, 0.16509448f, -0.05504519f, -0.17869250f, -0.09292714f, 
    -0.09065381f, -0.07842120f, 0.27289897f, -0.12467024f, 0.23272577f, 0.43068984f, 0.03668689f, 0.30671668f, 
    -0.07239833f, 0.17727849f, 0.05071246f, -0.01705911f, 0.17121029f, 0.13809982f, 0.17375840f, 0.16141294f, 
    0.22022186f, -0.26078850f, -0.08098323f, 0.03907996f, 0.26382399f, 0.06470241f, 0.04770045f, -0.23416103f, 
    -0.05826620f, 0.13643409f, 0.07975396f, 0.15013669f, 0.42536095f, 0.20807086f, -0.01495640f, -0.15858749f, 
    0.12159158f, -0.11148463f, -0.21379131f, -0.46486205f, 0.04253200f, 0.14554670f, -0.14957336f, -0.52992338f, 
    0.43356451f, 0.10650546f, -0.15698785f, -0.09267662f, 0.09962475f, -0.31556246f, 0.11158665f, 0.18766607f, 
    0.54205143f, -0.30914780f, 0.04503383f, -0.49349204f, -0.12266481f, -0.00369382f, -0.12224198f, 0.19074719f, 
    0.40487862f, -0.22001874f, -0.13275088f, -0.09261380f, 0.15283415f, 0.15407419f, -0.10276688f, 0.16760996f, 
    -0.22076279f, -0.02835969f, -0.33890110f, 0.36642104f, 0.33323854f, 0.13567051f, 0.17064644f, 0.29138467f, 
    -0.33245119f, 0.10174183f, 0.00819200f, 0.11616965f, 0.21415240f, -0.13756344f, 0.02587294f, 0.08080398f, 
    0.01992176f, -0.07703661f, -0.13092817f, -0.04475858f, -0.13647175f, -0.08165302f, -0.15575524f, 0.04029908f, 
    -0.15070009f, 0.00696102f, 0.12834686f, 0.00689316f, -0.13586323f, 0.00553337f, -0.19881254f, -0.04674311f, 
    0.08247028f, -0.00585744f, -0.14648274f, -0.06152230f, 0.00042800f, -0.10386768f, 0.02967440f, -0.01539597f, 
    -0.07558063f, -0.00329695f, 0.03095829f, 0.12422632f, 0.11636077f, 0.15910834f, -0.04579208f, -0.20129585f, 
    -0.22627144f, 0.32595474f, -0.02130022f, 0.06509987f, -0.01732540f, 0.16610435f, 0.01538613f, -0.16036201f, 
    0.06761459f, 0.37217557f, 0.10680198f, 0.10078941f, 0.36586726f, 0.07400958f, -0.13502094f, 0.09813543f, 
    0.10777444f, 0.08150742f, 0.23668151f, 0.15965775f, 0.03068537f, 0.05541170f, 0.16943759f, 0.25734806f, 
    -0.24365315f, -0.13733938f, -0.02490285f, 0.00867425f, -0.02584203f, 0.38019490f, 0.21027373f, -0.13971588f, 
    0.18129241f, 0.09862071f, -0.01772593f, -0.17902684f, 0.50941074f, 0.13273856f, -0.14115110f, 0.20431045f, 
    0.19638704f, 0.22770017f, -0.13079937f, 0.20604269f, 0.27609253f, -0.16732204f, -0.26327324f, -0.16101736f, 
    0.04443698f, 0.00501680f, -0.25901186f, 0.12540099f, 0.30332544f, -0.27301595f, -0.09404416f, 0.06264231f, 
    0.04254800f, 0.00221455f, -0.15257129f, 0.04121108f, -0.14228524f, -0.29307747f, 0.12863456f, 0.09849156f, 
    -0.13851368f, 0.17625323f, 0.21005526f, -0.25685820f, 0.66128254f, 0.29243559f, 0.07975531f, -0.40626925f, 
    -0.10555564f, 0.16467799f, 0.02361263f, -0.17707886f, -0.31855333f, -0.24503155f, 0.22162764f, 0.13950247f, 
    0.10946061f, 0.15851632f, 0.17973709f, 0.28627855f, 0.12382418f, -0.17682216f, -0.13765639f, 0.18289588f, 
    -0.17806804f, 0.06685072f, -0.02823450f, -0.01449167f, 0.04313285f, 0.68728453f, -0.05136549f, 0.02271935f, 
    -0.09136651f, -0.29837361f, 0.22961199f, 0.36194357f, -0.16910765f, -0.09139881f, 0.18574598f, 0.02550498f, 
    -0.02040985f, -0.18524724f, 0.10578316f, -0.03800467f, -0.25379342f, 0.08359808f, 0.13106750f, 0.13420223f, 
    -0.05559158f, 0.08273739f, 0.11658572f, -0.34527707f, 0.01741278f, 0.14637057f, 0.16841546f, 0.03912790f, 
    -0.06004905f, -0.07027882f, 0.14114375f, 0.05865438f, 0.30180475f, -0.40559995f, 0.06712897f, 0.12557584f, 
    -0.03069534f, -0.09850015f, -0.06149155f, 0.13295434f, -0.02663386f, -0.08367260f, -0.14781047f, -0.16754980f, 
    -0.08171348f, -0.19894317f, -0.15275630f, -0.07521740f, 0.10021359f, -0.04520132f, -0.02426748f, 0.13613831f, 
    0.03826794f, -0.05058688f, 0.02369788f, -0.01105932f, -0.08915213f, 0.05224770f, -0.11265288f, 0.04844536f, 
    -0.06964874f, -0.04474910f, 0.16946729f, 0.12586100f, 0.07554106f, 0.00197702f, 0.13838391f, -0.01843422f, 
    -0.14993158f, 0.06659476f, 0.02867091f, 0.07205258f, -0.38109323f, -0.12061755f, 0.06456304f, 0.33014569f, 
    -0.00349100f, 0.36101434f, 0.01074532f, 0.14738277f, -0.24338266f, 0.30129021f, 0.12135805f, 0.10871891f, 
    -0.09769087f, 0.03352819f, 0.46234566f, 0.35662481f, 0.13307899f, -0.38122064f, 0.13382590f, 0.09732894f, 
    0.07304647f, -0.07141878f, 0.07779025f, -0.00728393f, -0.29829654f, 0.36400792f, -0.04434717f, -0.00687825f, 
    0.23086454f, -0.19783160f, 0.23103660f, 0.21991941f, 0.02434372f, 0.01119541f, -0.12917471f, -0.00590366f, 
    0.21837516f, 0.10132472f, -0.09016670f, -0.17604356f, 0.13909033f, -0.04594670f, 0.16909431f, -0.11792561f, 
    -0.08154000f, 0.02626920f, -0.31955025f, -0.19163594f, 0.26682302f, 0.45724222f, 0.00292895f, 0.41778529f, 
    -0.16120896f, 0.03630610f, 0.10235955f, 0.01839061f, 0.32391900f, 0.00524598f, -0.12461969f, 0.05645084f, 
    -0.25085360f, -0.00097951f, 0.20944737f, -0.02162709f, 0.32184750f, 0.29005378f, 0.25901464f, 0.20153198f, 
    0.21104625f, -0.36623061f, -0.02428908f, -0.00358106f, 0.06709386f, -0.19369461f, 0.18905137f, -0.12244671f, 
    0.02749832f, 0.00079628f, -0.16704170f, -0.43595529f, 0.11157298f, 0.59290302f, -0.20126453f, 0.12052507f, 
    0.53439504f, 0.16290137f, -0.08376600f, -0.17230746f, 0.10952722f, -0.61954218f, -0.01351862f, -0.14661458f, 
    0.06278934f, -0.04453795f, -0.02329227f, 0.24871053f, 0.21076274f, 0.02091277f, -0.08097762f, 0.13969064f, 
    -0.09197386f, 0.07173469f, -0.16480400f, 0.16288021f, -0.10617950f, -0.22990721f, 0.21062952f, 0.02545948f, 
    -0.00557175f, -0.02629672f, 0.09343942f, -0.15005317f, -0.04762891f, -0.00925675f, 0.01073954f, 0.17004678f, 
    0.08806316f, -0.07044607f, -0.12601364f, 0.04399006f, -0.19210948f, -0.04854864f, -0.04788059f, -0.18212937f, 
    -0.33348149f, 0.23547609f, -0.17169395f, -0.04552442f, 0.46284544f, 0.11567844f, 0.17156824f, 0.53231752f, 
    -0.04283024f, -0.39957234f, -0.05923713f, 0.14379290f, -0.32772210f, 0.30999607f, -0.02047160f, -0.08691441f, 
    0.26963413f, -0.00514024f, 0.28243116f, -0.45146567f, -0.10857319f, -0.56201130f, -0.28664213f, 0.06039359f, 
    0.28293699f, -0.14077391f, 0.03342008f, 0.02317100f, 0.03249058f, 0.09832938f, -0.08950056f, 0.13541113f, 
    0.22669382f, -0.28349447f, 0.27878067f, -0.12558429f, -0.11407150f, -0.11740146f, 0.32918260f, -0.01119395f, 
    0.31296673f, 0.28558791f, -0.08588136f, -0.19721746f, 0.07015347f, 0.17043066f, 0.44450757f, 0.00471979f, 
    0.04220699f, 0.06424002f, -0.09912514f, -0.00440508f, 0.08059528f, -0.55136371f, 0.26436162f, 0.12176888f, 
    0.17024869f, 0.01422470f, 0.03607223f, -0.07175943f, 0.01789060f, 0.14425467f, -0.15731354f, 0.13377498f, 
    0.28108433f, -0.19560936f, 0.13284373f, -0.49226812f, 0.13669012f, 0.40686974f, -0.12647822f, 0.02711451f, 
    0.27290460f, -0.52107292f, 0.07018761f, -0.11057452f, 0.31320146f, -0.03398163f, 0.32023132f, -0.02531262f, 
    -0.31130332f, -0.01964704f, -0.04900847f, -0.13348423f, 0.22571976f, 0.47207451f, 0.10966322f, -0.12884074f, 
    0.05256855f, 0.10634898f, -0.11634992f, -0.02472979f, 0.31995603f, -0.37017426f, 0.08870225f, -0.10454587f, 
    0.30081323f, 0.05164018f, 0.13503577f, -0.06005229f, -0.03121487f, 0.06836949f, 0.25191259f, 0.37680367f, 
    0.03483742f, 0.11668596f, -0.15804532f, -0.17924069f, -0.38033411f, 0.42543745f, 0.02613155f, 0.01279701f, 
    -0.01760447f, 0.13491429f, -0.00908074f, -0.07181558f, -0.03401980f, -0.64735103f, 0.00815164f, 0.33152199f, 
    0.24440223f, 0.03998032f, 0.07158779f, -0.02147776f, -0.06217176f, 0.37933961f, 0.10816322f, 0.02665249f, 
    -0.17604031f, -0.12455328f, 0.24246192f, 0.11578718f, 0.10502486f, 0.18866169f, -0.01578325f, 0.10618225f, 
    -0.28279650f, 0.04082858f, -0.10714702f, -0.19208950f, -0.39149985f, -0.34436515f, -0.00675978f, -0.15492006f, 
    -0.01326372f, 0.10330290f, -0.18311162f, -0.23089555f, -0.17966311f, 0.17271113f, 0.16697693f, -0.41611448f, 
    0.15313685f, -0.02463461f, 0.03857385f, 0.03313219f, -0.19080181f, 0.03386974f, -0.07469884f, -0.07688506f, 
    0.00538278f, -0.06410276f, -0.06285989f, 0.10490078f, -0.12708463f, -0.01302551f, -0.10989998f, 0.06364953f, 
    -0.09768694f, -0.17738326f, 0.16535527f, -0.19761281f, 0.09098820f, -0.08642600f, -0.05577251f, -0.16573258f, 
    0.11278097f, -0.17866622f, 0.13964553f, -0.17603315f, -0.07931516f, 0.00482242f, 0.08299401f, 0.16268270f, 
    0.07468092f, -0.14971043f, 0.16641186f, 0.13594140f, -0.17733692f, -0.06032206f, -0.15236937f, -0.12299798f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09234127f, 0.14641860f, 0.14568658f, -0.13941173f, 0.03770375f, -0.04828496f, 0.16726536f, -0.03136889f, 
    -0.04415154f, 0.14724791f, 0.06849904f, 0.00619430f, -0.00169020f, 0.27399334f, 0.01264591f, 0.01862216f, 
    0.09592991f, -0.05730028f, 0.17101733f, 0.26491636f, -0.04933222f, 0.13210392f, 0.26434627f, -0.13064145f, 
    0.40412050f, 0.17271753f, 0.44024521f, 0.18389276f, 0.12697244f, 0.15443709f, 0.02296576f, 0.36558867f, 
    0.14235209f, 0.18828668f, 0.14879927f, 0.28994974f, 0.24259479f, 0.08584905f, 0.10707547f, -0.00614166f, 
    0.21538958f, 0.35318926f, 0.31055111f, 0.18136688f, 0.08923063f, 0.03069625f, 0.00872795f, -0.20442335f, 
    0.05237667f, 0.10186414f, 0.13391405f, 0.18617457f, 0.25619385f, -0.08546729f, 0.04113943f, 0.11968115f, 
    0.01929578f, 0.02020318f, 0.30360666f, 0.08346219f, 0.29630134f, -0.21907103f, -0.04224851f, -0.01546895f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.01635394f, -0.53731436f, 0.08302055f, 0.01454631f, -0.09432168f, 0.18283424f, 0.18990134f, -0.03713782f, 
    -0.05810708f, -0.16059174f, 0.00491044f, 0.07148315f, 0.17379016f, 0.09914871f, 0.04013044f, -0.02218258f, 
    0.10822929f, 0.09584318f, -0.03089163f, -0.01724296f, 0.07207504f, 0.03156080f, -0.27572581f, 0.30364954f, 
    0.04834162f, -0.47861302f, -1.02019322f, 0.09978514f, 0.13859557f, -0.09562838f, -0.22530515f, -0.70850855f, 
    -0.76483029f, -0.67896175f, -0.07060365f, -0.38415045f, 0.15879646f, -0.56180805f, -0.13280992f, 0.30630106f, 
    -0.58195382f, -0.25444973f, -0.05892476f, -0.06422756f, 0.03317012f, 0.07532731f, -0.08813249f, 0.01100449f, 
    0.03112751f, 0.21496226f, -0.07855400f, 0.20545900f, -0.52408558f, -0.01687231f, 0.11775686f, 0.02486112f, 
    -0.11739361f, -0.27965480f, -0.71683574f, 0.14810824f, -0.03977951f, -0.05221175f, -0.17845742f, -0.01870235f, 
    -0.16130331f, -0.05015763f, 0.10322677f, -0.05402612f, 0.31108037f, 0.08423688f, 0.10689440f, 0.19403125f, 
    -0.10908321f, -0.02316415f, 0.15442398f, 0.35438615f, 0.06927641f, 0.22296023f, 0.11382917f, 0.18994772f, 
    0.05582807f, -0.00226219f, -0.01146935f, -0.24063452f, -0.05946140f, -0.09988772f, -0.85810393f, 0.16169640f, 
    0.11203379f, 0.13179366f, 0.22468865f, 0.06191937f, 0.06571164f, 0.18690887f, 0.03796753f, 0.19486420f, 
    -0.05329314f, -0.14819054f, 0.19733828f, 0.00739356f, -0.32078496f, 0.42631388f, -0.33314472f, -0.02385428f, 
    0.09618581f, 0.06686891f, -0.04048002f, -0.15622349f, -0.15766959f, 0.08653357f, -0.28089884f, -0.68937016f, 
    -0.07118720f, 0.21108624f, -0.20309068f, 0.10401584f, -0.02617409f, 0.10537023f, 0.19485976f, -0.33268589f, 
    0.29619488f, -0.00194734f, 0.30285954f, -0.28252873f, -0.23845860f, -0.17388722f, 0.33865348f, -0.00471945f, 
    -0.00591896f, -0.31371474f, -0.46298972f, 0.00022624f, -0.32420334f, 0.05209234f, 0.13001202f, -0.28163007f, 
    0.11836767f, -0.05667123f, -0.23362675f, -0.49967903f, -0.50693524f, 0.04342344f, 0.05623150f, -0.33715671f, 
    -0.03066089f, -0.01804930f, -0.10748789f, -0.03468075f, -0.01240430f, 0.09388289f, 0.60050321f, -0.93481708f, 
    -0.02108448f, -0.19755271f, 0.69558829f, -0.89504290f, 0.13799740f, 0.10436405f, 0.06816967f, 0.27027828f, 
    -0.03024122f, -0.13984288f, -0.09192815f, -0.10708433f, 0.26989925f, -0.53549784f, 0.09590825f, -0.67714292f, 
    -0.03479684f, 0.28460500f, 0.27942535f, 0.14498670f, 0.24349149f, 0.07842873f, -0.12158880f, 0.02504717f, 
    0.11397466f, -0.04254770f, 0.16865849f, 0.43658695f, -0.11731827f, 0.10510108f, 0.03404640f, -0.05614958f, 
    -0.66339016f, -0.04829988f, 0.05262718f, 0.00948438f, -0.23062585f, -0.11902919f, -0.05289511f, 0.00696288f, 
    -0.10794816f, 0.31899890f, -0.05653062f, 0.04233847f, -0.26818791f, 0.19758248f, 0.21214956f, -0.85024124f, 
    -0.08622572f, -0.55031782f, -0.28627920f, 0.28030652f, 0.13251606f, -0.82593441f, 0.00462790f, -0.17097443f, 
    -0.08340340f, -0.10727865f, 0.39640296f, -0.22738919f, -0.05346018f, 0.01723164f, 0.24071315f, -0.09827697f, 
    0.06007479f, -0.07461372f, -0.26391977f, 0.20327275f, -0.15990074f, -0.98368734f, 0.15626709f, 0.10197327f, 
    -0.02845201f, -0.16309845f, -0.03761104f, -0.34571487f, 0.04865336f, -0.26965350f, 0.15883045f, 0.12151401f, 
    0.01481533f, -0.34289300f, -0.21036515f, -0.54448807f, 0.15006311f, 0.05935644f, 0.29884729f, 0.24961664f, 
    -0.00529261f, -0.02205448f, 0.13211845f, -0.72496921f, 0.15249589f, -0.09163263f, -0.02926122f, 0.07312457f, 
    -0.73257911f, -0.38152409f, -0.62559819f, 0.19245425f, 0.33832735f, -0.20476978f, -0.10176870f, 0.09016243f, 
    -0.04854940f, -0.32014433f, 0.09908028f, -0.06547549f, -0.07991785f, 0.00198807f, 0.03880747f, -0.07922725f, 
    -0.09150763f, -0.17568769f, -0.64166713f, -0.73804593f, -0.11099553f, 0.10704828f, 0.08469453f, 0.04261011f, 
    -0.11320955f, -0.01481596f, 0.01407487f, -0.02579794f, 0.06174029f, 0.04378117f, 0.10308436f, 0.27998662f, 
    -0.24080352f, -0.37299174f, 0.05272507f, 0.05851026f, 0.18384750f, -0.14268520f, -0.21287204f, -0.39438400f, 
    -0.06401297f, 0.04599120f, -0.05354401f, 0.05939977f, 0.22966403f, -0.56026304f, -0.43349048f, 0.13927618f, 
    -0.01363467f, 0.09939110f, 0.00548603f, 0.08507712f, 0.07315173f, 0.05821050f, -0.53486925f, 0.07251804f, 
    0.02960704f, -0.02229343f, -0.52433151f, -0.08850908f, 0.26593703f, -0.04583034f, 0.14820531f, 0.16245277f, 
    -0.11408208f, -0.01591345f, 0.14548714f, 0.05923470f, -0.12738040f, 0.32245469f, -0.19197051f, -0.00534464f, 
    0.05601527f, 0.07746074f, 0.34295750f, 0.06982180f, -0.39661673f, -0.07295781f, 0.06328749f, -0.02187607f, 
    0.00216401f, 0.30671754f, -0.08929037f, -0.12991713f, -0.02821458f, -0.34142935f, 0.08678050f, 0.22724681f, 
    0.09078148f, -0.12219559f, -0.14509633f, 0.15255968f, -0.11077157f, -0.03355620f, -0.17160539f, -0.16696256f, 
    0.27163228f, 0.33438638f, -0.31733048f, -0.16158891f, -0.09396085f, -0.02352308f, 0.27656314f, 0.17031153f, 
    -0.01037689f, 0.23792593f, -0.46687177f, 0.06557166f, 0.24665500f, -0.70526701f, -0.02982428f, -0.19795088f, 
    -0.07552841f, -0.25170562f, 0.02701128f, -0.11654198f, -0.25288820f, 0.07238717f, -0.21714263f, 0.09224514f, 
    -0.02586340f, 0.16082089f, 0.22714671f, 0.09326576f, -0.11480785f, -0.06147899f, 0.00423019f, 0.16178232f, 
    -0.22316305f, -0.09576896f, 0.10392863f, -0.11319742f, -1.01685429f, 0.02664728f, -0.12223288f, -0.03325547f, 
    -0.14600815f, -0.41075817f, -0.16282021f, -0.06364899f, 0.08538025f, -0.20967515f, -0.81330460f, 0.32302099f, 
    0.00259344f, -0.25693235f, 0.34441045f, -0.33837548f, -0.37498319f, 0.09725136f, -0.07315186f, -0.04628708f, 
    -0.07536096f, -0.08605704f, -0.37995166f, -0.09232617f, 0.03533095f, -0.01971511f, 0.23935230f, -0.09748941f, 
    -0.44290599f, -0.33980468f, -0.25724664f, -0.52243459f, -0.05746898f, 0.30372384f, 0.04274489f, -0.09846019f, 
    -0.03882782f, -0.09203053f, 0.00473344f, -0.47755349f, -0.74995124f, 0.04865381f, 0.17244171f, 0.04706042f, 
    -0.07892147f, -0.26474881f, -0.17061147f, 0.31445146f, 0.09421507f, 0.18879732f, 0.21253163f, 0.21998586f, 
    -0.02726417f, -0.00713158f, 0.20503199f, 0.28082046f, -0.18046601f, 0.07962289f, -0.56437695f, 0.15031245f, 
    0.21701591f, -0.04750098f, -0.04811300f, -0.70775551f, 0.50289547f, -0.35548612f, 0.30880621f, -0.08610273f, 
    0.14778340f, 0.18633260f, -0.25409198f, -0.06611775f, 0.11803610f, 0.23002446f, -0.11354908f, -0.19459608f, 
    -0.00686929f, -0.39671499f, 0.06624299f, -0.28851125f, 0.25569090f, -0.15200825f, 0.02272744f, 0.10210207f, 
    -0.02579447f, 0.10201561f, 0.23316205f, -0.14738791f, -0.05426198f, 0.01054169f, -0.21796007f, -0.24380340f, 
    -0.78786904f, 0.30773878f, 0.11323871f, -0.20881885f, 0.07954340f, -0.18090625f, -0.00346710f, -0.51708966f, 
    -0.41730213f, -0.08227763f, -0.13688074f, -0.11132164f, -0.37988633f, -0.31250280f, -0.32761547f, 0.23797767f, 
    0.21780540f, -0.06059625f, -0.12383468f, -0.24932487f, 0.15294400f, -0.57411003f, -0.36040795f, 0.32211304f, 
    -0.06349962f, -0.14627154f, 0.18653321f, 0.06047041f, -0.14470504f, 0.10584732f, 0.20402060f, -0.17990518f, 
    -0.13566317f, -0.10178539f, 0.13498485f, 0.24553736f, 0.25422201f, 0.33482587f, -0.20616980f, -0.10249525f, 
    0.15683837f, 0.30628383f, -0.80381894f, 0.01639814f, 0.05549655f, 0.20177168f, -0.12254908f, -0.24863778f, 
    0.04680127f, 0.48088899f, 0.38560838f, -0.41785893f, -0.06001629f, -0.50284499f, 0.07972129f, -0.26748130f, 
    0.10500318f, -0.08865295f, 0.19250081f, 0.01056342f, -0.09070640f, 0.09234647f, -0.95238930f, -0.19254057f, 
    0.08701340f, 0.23759754f, -0.04051920f, -0.46141860f, -0.42698643f, -0.25005448f, 0.10865232f, 0.23957674f, 
    0.36150506f, -0.02125176f, 0.29233482f, 0.16797784f, -0.25675771f, 0.09238024f, 0.13101004f, -0.20696311f, 
    0.25057501f, 0.00998913f, 0.14348012f, 0.08825922f, 0.24333236f, -0.07982178f, 0.34471199f, -0.23464240f, 
    -0.06030596f, -0.06716371f, 0.23347062f, -0.73530221f, -0.13470051f, -0.09837007f, 0.12064798f, -0.21271941f, 
    -0.17285156f, 0.14117350f, 0.26733062f, -0.38967019f, -0.34333056f, -0.02932765f, 0.08480188f, -0.02640932f, 
    -0.00707643f, -0.27945948f, -0.37593922f, -0.07665859f, 0.34154788f, 0.18407382f, 0.26334307f, 0.04019466f, 
    0.09753777f, -0.26647931f, -0.29430676f, -0.28571185f, -0.83168399f, 0.16808914f, -0.02495052f, 0.05452471f, 
    -0.09543701f, -0.08387564f, 0.16668536f, 0.28954414f, 0.07362012f, -0.11495454f, 0.09202184f, 0.11477135f, 
    -0.37400401f, 0.06856914f, -0.15757520f, -0.18812928f, 0.16677444f, -0.04022847f, -0.04169815f, 0.26850587f, 
    0.20367044f, 0.15590800f, -0.07455129f, -0.31694841f, 0.31608510f, -0.21771745f, -0.04938338f, 0.24466799f, 
    -0.03317226f, -0.14290091f, -0.00334049f, -0.01380530f, 0.30306077f, 0.05846367f, -0.15438747f, 0.25702852f, 
    -0.05398285f, -0.19610716f, -0.21861662f, -0.35245228f, 0.28487775f, -0.07989937f, -0.14091058f, 0.20461340f, 
    0.05979507f, -0.23293407f, -0.66832811f, -0.30133322f, 0.16059479f, -0.73634177f, -0.33432636f, -0.02701973f, 
    -0.10037097f, -0.00704023f, 0.11208568f, 0.07101971f, -0.55428565f, -0.89806932f, -0.65260863f, -0.23803605f, 
    0.06443669f, 0.33658564f, 0.20855135f, -0.12575309f, -0.29232144f, 0.33661297f, -0.10391834f, -0.34707257f, 
    -0.02845006f, 0.09966311f, 0.22293723f, 0.31487569f, 0.07410675f, 0.10692212f, -0.00569955f, 0.30089250f, 
    0.29355755f, -0.37548074f, -0.42541340f, -0.45422125f, -0.36851409f, 0.27799323f, -0.15779895f, 0.02368563f, 
    0.17679411f, 0.31513608f, 0.14850034f, 0.39675933f, -0.56523275f, -0.29387718f, 0.16341954f, -0.31587893f, 
    0.04257727f, -0.43499482f, -0.59432101f, -0.45352641f, -0.44236144f, -0.14020082f, 0.17947838f, -0.08147070f, 
    -0.01231542f, 0.16190654f, -0.14613481f, -0.01050212f, -0.05160610f, 0.08459660f, 0.20220517f, -0.08386900f, 
    -0.61405993f, -0.40481102f, -0.06100497f, 0.26474646f, -0.33318821f, 0.22265258f, -0.08589333f, -0.06980249f, 
    -0.32391098f, 0.38940036f, -0.45432281f, 0.00086483f, 0.06260975f, 0.12114608f, -0.45487493f, -0.15634419f, 
    -0.04708263f, -0.44656050f, -0.08929808f, 0.13521461f, -0.20978887f, -0.25558123f, 0.10154672f, 0.03344986f, 
    -0.00783070f, -0.04537725f, -0.41064700f, -0.50480044f, -0.05157696f, 0.11695721f, 0.22823364f, -0.19976282f, 
    0.00917767f, -0.16523945f, 0.33021834f, 0.01748738f, -0.43053713f, -0.18880181f, 0.03016669f, -0.28474402f, 
    -0.14195223f, 0.07360289f, 0.53822905f, 0.26521921f, 0.00928432f, 0.24705485f, 0.13118616f, -0.39791334f, 
    0.11393751f, -0.19377923f, -0.35101372f, 0.16799179f, -0.39279774f, -0.09875346f, 0.38564193f, -0.08615109f, 
    -0.03232555f, -0.56903172f, -0.17912026f, -0.08687723f, 0.40703234f, -0.06268795f, -0.39652181f, 0.12268288f, 
    0.31738305f, 0.08676306f, 0.33672547f, 0.27350396f, 0.04939517f, 0.05626234f, -0.36953932f, 0.06113110f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21353857f, -0.05604767f, 0.26232374f, 0.00206157f, -0.06326654f, -0.07657874f, -0.14604731f, -0.15930334f, 
    -0.02496284f, -0.01595141f, 0.09211549f, -0.03747172f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
