#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.20936480f, -0.01504655f, -0.32869628f, 0.47599313f, 0.40028888f, 0.59803301f, 0.03716324f, -0.25270501f, 
    0.04250675f, 0.85532469f, 0.66136962f, -0.31492788f, -0.35834995f, -0.15031336f, -0.24200541f, 0.09737903f, 
    -0.00335695f, 0.34350491f, 0.23682770f, -0.15331167f, 0.06557816f, 0.07688533f, -0.50407720f, -0.14015375f, 
    0.12165852f, 0.35367033f, 0.37850192f, -0.11173718f, 0.59756440f, -0.61640394f, -0.26488680f, -0.71413577f, 
    -0.65246528f, -0.71600348f, -0.65497702f, 0.07074963f, -0.04977055f, 0.55385464f, -0.51468337f, -0.15099505f, 
    0.14031108f, 0.47639915f, 0.20053209f, -0.09046383f, -0.16680889f, 0.17202684f, -0.20110175f, 0.05122288f, 
    0.04104146f, 0.19836624f, -0.31870902f, -0.75239187f, -1.11650670f, -0.89237326f, -0.42616209f, 0.35957983f, 
    0.05468619f, 0.17293696f, 0.71248275f, 0.23407701f, 0.40881518f, -0.10201309f, -0.29756132f, -0.18780243f, 
    0.19934407f, -0.68574452f, 0.37655842f, -0.05990116f, -0.09804907f, -0.49374026f, -0.19077353f, -0.05469010f, 
    -0.06212228f, 0.23047017f, 0.15122996f, -0.31524423f, -0.43949425f, 0.20398432f, 0.14414749f, 0.16507585f, 
    -0.31863761f, 0.09081364f, 0.24484260f, 0.45286745f, 0.30153322f, -0.40704665f, 0.37872225f, 0.01481245f, 
    -0.23972146f, 0.15394573f, -0.25535184f, -0.13451731f, -0.05089849f, 0.20116387f, -0.51268309f, 0.15486342f, 
    0.44496086f, 0.26173526f, -0.07882771f, 0.47477677f, -0.70908368f, -0.76997864f, -0.59541899f, -0.17878334f, 
    0.44503054f, -0.64012015f, -0.76587838f, -0.10265452f, -0.51235002f, -0.14689344f, -0.31173095f, -0.26526615f, 
    0.53442460f, -0.39768884f, -0.26267329f, 0.19459042f, 0.04748569f, -0.09364124f, 0.22583756f, 0.16679291f, 
    0.25714675f, 0.31252369f, 0.09954976f, -0.05075907f, 0.24597715f, -1.01751530f, -0.69725055f, -0.13885069f, 
    0.64964813f, 0.64292312f, 0.58155006f, 0.60339469f, 0.29409719f, 0.09556206f, 0.14272441f, 0.16628629f, 
    0.34915036f, -0.33292809f, -0.09040302f, -0.20360608f, 0.14576463f, 0.13361914f, -0.16828428f, -0.38033807f, 
    -0.20987444f, 0.20198606f, -0.15631588f, -0.00611206f, 0.18703850f, -0.08344713f, -0.23784259f, -0.78175688f, 
    0.36964750f, 0.28863218f, 0.71266544f, 0.81694901f, -0.67299902f, -0.32189140f, -0.40312481f, -0.05557853f, 
    0.24937156f, -0.33481327f, 0.14904864f, -0.17248528f, -0.04794164f, -0.43225095f, -0.16727863f, 0.47746271f, 
    0.26371890f, 0.02169177f, -0.06650660f, 0.04924764f, -0.21033083f, 0.08915605f, 0.18683475f, 0.73445463f, 
    0.31216413f, 0.34481245f, 0.22888461f, 0.19426173f, 0.21504010f, 0.01490431f, -0.16063635f, -0.32747144f, 
    -0.50045556f, -0.15548679f, -0.17293844f, -0.17028323f, -0.16573988f, -0.11253833f, 0.20973992f, 0.29412928f, 
    0.08067676f, -0.27473941f, 0.24333811f, 0.26134020f, -0.08566774f, -0.26380205f, -0.40452120f, -0.47477767f, 
    0.30868325f, 0.01134904f, 0.14656045f, 0.25926200f, -0.60303247f, 0.01664308f, -0.11443146f, -0.28738540f, 
    -0.13270341f, 0.16604976f, 0.14503726f, -0.04386205f, 0.22029309f, 0.15858763f, -0.00895759f, -0.29778734f, 
    -0.18315105f, 0.04752124f, -0.15478674f, -0.13266604f, 0.36347219f, 0.29196617f, 0.34412867f, 0.44204879f, 
    0.27057451f, 0.49145004f, 1.16531146f, 0.53412914f, 0.11574954f, 0.46696839f, -0.47950542f, -0.34953731f, 
    -0.22150275f, 0.13526531f, -0.20028237f, 0.11512186f, -0.16523793f, 0.18134482f, 0.05465345f, -0.23946209f, 
    -0.15853862f, 0.14356810f, -0.08152727f, -0.10379833f, -0.00369484f, -0.18262729f, 0.18307909f, 0.00493787f, 
    0.15575562f, -0.21898681f, -1.04024434f, 0.36681688f, -0.26455772f, -1.28072321f, -0.69344944f, 0.40369117f, 
    -0.05617068f, 0.19568110f, 0.35653949f, -0.06010320f, -0.34753057f, -0.63106912f, -0.50434095f, -0.50705415f, 
    -0.29158378f, 0.05733573f, -0.32952312f, -0.24528317f, -0.14715718f, -0.18716064f, -0.31826848f, 0.15116537f, 
    -0.00547789f, -0.14550900f, -0.09141380f, 0.04098122f, -0.36343646f, -0.70812488f, -0.57041597f, -0.36136654f, 
    -0.34499517f, -0.38979560f, -0.33999833f, -0.47287562f, -0.04293282f, 0.02855793f, 0.11439197f, 0.06455736f, 
    -0.19136703f, -0.07881247f, 0.06160177f, 0.28100231f, 0.09975713f, -0.08711819f, -0.07038752f, -0.14642538f, 
    -0.13067207f, -0.21727113f, -0.45055360f, -0.62680703f, -0.32275099f, -0.48270124f, 0.21675539f, -0.27513769f, 
    0.13958097f, -0.21594445f, 0.19264612f, -0.33658507f, -0.40679055f, -0.37112707f, 0.70381135f, 0.82475132f, 
    -0.35064602f, -0.07170859f, -0.21897389f, -0.12586328f, 0.00741349f, 0.12599830f, 0.06955060f, -0.14710808f, 
    -0.05970594f, 0.15296346f, -0.11768865f, -0.18407962f, -0.09839695f, 0.31035829f, -0.28590775f, -0.31557333f, 
    0.57852691f, 0.57769090f, -0.00819796f, -0.52895021f, -0.51248020f, -0.05697343f, 0.44817975f, 0.42828420f, 
    0.37436393f, -0.19582836f, -0.41194829f, 0.67807150f, -0.32671994f, 0.42640445f, 0.21528722f, -0.23830383f, 
    0.23683430f, -0.01875959f, -0.02355296f, 0.14065513f, -0.25997972f, -0.32415909f, -0.85696554f, 0.57214665f, 
    0.12148664f, 0.24810922f, 0.62466866f, -0.62098414f, -0.85325229f, -0.17719358f, 0.62471235f, 0.70606357f, 
    -0.10433640f, -0.02335668f, -0.14229375f, -0.21236348f, 0.30180079f, 0.27115688f, -0.23805994f, 0.25515246f, 
    -0.18451749f, -0.24119109f, -0.19764522f, -0.03024626f, 0.05002309f, -0.22385477f, -0.20997103f, 0.56137371f, 
    0.58075809f, -0.25465316f, -0.44847390f, 0.13495508f, 0.09176569f, -0.03348270f, 0.34429243f, 0.11524262f, 
    -0.32543200f, -0.52635396f, -0.18347757f, -0.01635031f, -0.29112020f, -0.28449640f, -0.21211526f, 0.29368165f, 
    0.08657223f, 0.05999171f, -0.31396708f, 0.11399309f, 0.13063039f, 0.00851079f, 0.10335586f, 0.45376611f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09167003f, 0.23642403f, 0.03831920f, 0.20322672f, -0.06674694f, 0.52566034f, 0.33484200f, 0.05995398f, 
    0.32079056f, 0.05246318f, 0.00081763f, -0.27498919f, 0.40849158f, 0.00688577f, 0.62157029f, 0.40267527f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00398184f, -0.25262094f, 0.07919002f, 0.01855197f, 0.03547804f, 0.05558936f, -0.05715622f, 0.00628407f, 
    0.14492068f, 0.16023906f, 0.09008996f, 0.10386431f, -0.48660338f, 0.18083696f, -0.16054212f, -0.14394300f, 
    0.00047215f, -0.13621360f, 0.05373229f, -0.04895307f, 0.07528275f, 0.02466518f, -0.00016915f, -0.05082007f, 
    0.00585311f, 0.13975775f, 0.48586848f, 0.24558936f, 0.24150915f, -0.07196600f, -0.00070656f, -0.04122267f, 
    -0.26075396f, 0.15125975f, 0.15411630f, 0.31522512f, 0.05761871f, -0.08250448f, -0.22874114f, -0.03212853f, 
    0.30887792f, 0.07629485f, -0.04320555f, -0.03088328f, 0.11192242f, 0.10177944f, 0.09157097f, 0.13329341f, 
    -0.25537252f, -0.43522915f, -0.51182801f, 0.16377026f, -0.03634163f, -0.32203308f, 0.27971271f, -0.01394289f, 
    -0.02013525f, -0.02843593f, -0.04156484f, -0.09317612f, 0.03121922f, 0.06950543f, 0.18003105f, 0.32366708f, 
    0.04091014f, 0.05757761f, -0.04317449f, 0.05510036f, 0.14707798f, 0.07302524f, 0.11301111f, 0.12927984f, 
    0.06775588f, -0.13300294f, -0.10764971f, -0.38304213f, 0.02506798f, 0.22193877f, 0.25832501f, 0.09964624f, 
    -0.10168598f, 0.02006333f, 0.07426287f, -0.11679509f, -0.14977634f, 0.11494049f, -0.21303716f, -0.39810318f, 
    0.10364194f, 0.05974749f, 0.22903661f, 0.18665974f, -0.08764222f, -0.07953910f, -0.18347940f, 0.06111013f, 
    -0.08908021f, -0.12386046f, 0.03309421f, -0.03943012f, 0.06658597f, -0.03603876f, 0.14148729f, 0.08802086f, 
    0.05569913f, 0.01809104f, 0.07469742f, 0.02795742f, -0.05475578f, 0.01481495f, -0.05037965f, -0.27064475f, 
    0.09172470f, 0.00647553f, 0.03446968f, 0.11873142f, -0.06988556f, -0.10273682f, 0.06096733f, -0.09176504f, 
    -0.13601789f, 0.28183699f, 0.20381726f, 0.35142374f, 0.19396849f, 0.10461044f, 0.12816042f, -0.01340934f, 
    0.03498891f, 0.14429851f, -0.00866890f, 0.02978826f, -0.33692071f, -0.12771542f, 0.15975603f, -0.04204718f, 
    -0.27107519f, 0.00174782f, 0.03748219f, -0.10928389f, 0.00894377f, 0.18952648f, 0.01160717f, 0.00033878f, 
    -0.07262714f, -0.05475681f, -0.05244898f, -0.02833826f, 0.04651449f, 0.16636819f, -0.18195166f, 0.19394611f, 
    0.25771296f, 0.05832475f, -0.22281918f, 0.07981964f, 0.16062813f, -0.24095666f, -0.01191993f, -0.00949360f, 
    0.09052939f, 0.06521073f, 0.03462345f, -0.00985412f, 0.42400214f, 0.19215098f, -0.14462171f, 0.20808031f, 
    0.69695777f, -0.19986200f, 0.04130978f, -0.01552782f, 0.20861442f, 0.13759623f, 0.01731826f, -0.05813243f, 
    -0.00237812f, -0.03427064f, -0.12174566f, 0.02111515f, -0.06806919f, -0.08543915f, -0.03823091f, -0.18799047f, 
    0.08967498f, 0.08301562f, 0.19818603f, 0.02817751f, -0.04430369f, -0.00877081f, 0.04418940f, -0.15504737f, 
    -0.26619080f, -0.04390515f, -0.23851047f, 0.03591333f, -0.17032130f, -0.06051993f, -0.05193394f, -0.13417181f, 
    0.16005890f, 0.02942272f, 0.02952879f, 0.07376354f, 0.11483049f, 0.21501023f, 0.14868332f, 0.09987853f, 
    -0.09847325f, -0.09883042f, 0.04692674f, -0.01057265f, 0.02091874f, -0.02786713f, 0.01938390f, -0.01288879f, 
    -0.04556521f, -0.23640418f, 0.07012684f, -0.11778367f, -0.06902754f, -0.03704178f, 0.06041760f, 0.03958372f, 
    0.05379377f, -0.07149640f, 0.04142044f, -0.02387374f, 0.17884548f, -0.03056606f, -0.25895804f, -0.03311405f, 
    -0.00637524f, -0.04083600f, -0.08260602f, -0.02075700f, -0.00307940f, 0.03859550f, -0.00927962f, 0.01995492f, 
    -0.05178015f, -0.15280202f, 0.24321161f, -0.01009279f, -0.14293744f, -0.03587667f, 0.02705826f, 0.06555791f, 
    -0.05546762f, -0.04109066f, 0.08834590f, 0.01560065f, -0.23525643f, -0.07004252f, -0.04492722f, 0.30865195f, 
    -0.13822424f, 0.03481321f, -0.13215308f, -0.05641195f, 0.39698681f, 0.13641809f, 0.26803046f, 0.10236931f, 
    0.27377629f, -0.21934819f, 0.04847946f, 0.13514288f, -0.02481813f, 0.14043275f, 0.09060099f, -0.06823407f, 
    -0.11492420f, 0.00541128f, 0.10409620f, 0.08990566f, 0.08635403f, 0.25837216f, 0.04167508f, -0.16195840f, 
    -0.03654366f, 0.08926246f, -0.07203620f, 0.09925257f, -0.12935665f, -0.05035858f, -0.14228150f, -0.08899313f, 
    0.06068375f, 0.16080278f, 0.04204381f, -0.07682375f, 0.15388916f, 0.03233554f, 0.05487803f, 0.02506603f, 
    -0.01132334f, 0.03102770f, 0.06621972f, 0.08554679f, 0.55891222f, 0.34996387f, 0.09663671f, -0.04710882f, 
    -0.10253940f, 0.05408499f, 0.04847741f, 0.02114997f, -0.07887869f, -0.05627821f, -0.02678476f, -0.08224292f, 
    -0.29915124f, -0.01777240f, 0.02150309f, -0.07235137f, 0.13184780f, -0.03432339f, 0.16089715f, -0.05536463f, 
    0.08259154f, 0.10312278f, 0.17017841f, -0.01895524f, -0.10514197f, 0.00248822f, 0.04696302f, -0.12161904f, 
    -0.16549981f, -0.10809831f, -0.06933045f, 0.09125990f, 0.09069064f, 0.12505509f, -0.06158622f, -0.11627504f, 
    -0.05319916f, 0.06667406f, 0.03870149f, 0.25891688f, -0.04205678f, 0.10331921f, 0.13603698f, 0.12243381f, 
    0.02622497f, 0.08401258f, -0.03349945f, 0.00298564f, 0.07494275f, 0.13384251f, -0.02145515f, -0.04248721f, 
    0.02555411f, -0.04533144f, 0.04084373f, -0.14130555f, -0.08511506f, -0.04422849f, -0.12123813f, -0.07795320f, 
    0.33834094f, 0.08009044f, -0.03446499f, 0.09704915f, 0.28327742f, 0.14669310f, 0.02597420f, 0.00233401f, 
    0.12610266f, 0.14650761f, 0.09717059f, 0.08821382f, 0.05663673f, 0.02373752f, 0.18995799f, 0.18765840f, 
    0.00775177f, -0.01379954f, -0.13708371f, -0.01843823f, -0.10137072f, 0.00187857f, -0.04916965f, -0.07648648f, 
    0.03989362f, 0.00623200f, -0.03252001f, -0.07210775f, -0.03734514f, -0.02271623f, 0.00048294f, 0.03846473f, 
    -0.04181762f, -0.00824156f, 0.03858313f, 0.00937965f, 0.02748322f, 0.01250146f, -0.04807920f, -0.06103545f, 
    -0.02069009f, -0.03397820f, -0.03680539f, -0.02652461f, 0.03198658f, 0.06686580f, -0.04805693f, 0.02431631f, 
    -0.02693089f, -0.01426693f, -0.00150291f, 0.02097202f, 0.01781164f, 0.05625159f, -0.01521034f, -0.05130483f, 
    -0.07460243f, -0.01799651f, 0.06004820f, -0.03299860f, 0.00142336f, 0.00820437f, -0.03846962f, 0.00549296f, 
    -0.02747501f, -0.04097392f, -0.02762074f, 0.02936578f, -0.03846560f, 0.04367905f, 0.04581220f, 0.00736753f, 
    0.04689960f, -0.00128273f, -0.02490589f, -0.06560562f, 0.03280522f, -0.02887551f, -0.01785604f, -0.01360433f, 
    -0.02590007f, -0.04784286f, 0.03026398f, 0.04589355f, -0.04486524f, 0.01654021f, -0.06010584f, -0.02756174f, 
    0.04204011f, -0.07787887f, -0.00926544f, 0.02928403f, 0.02119936f, 0.05145045f, 0.01529359f, 0.02285496f, 
    -0.01618699f, -0.05666191f, -0.01687907f, -0.02963137f, -0.02636324f, -0.03169495f, -0.02776400f, -0.02510029f, 
    0.06134804f, -0.01021697f, -0.02698979f, -0.00982757f, -0.06265189f, -0.02276459f, -0.03994135f, -0.07253274f, 
    0.02735942f, 0.02853512f, 0.05743877f, -0.05250461f, 0.02740142f, -0.05822536f, -0.04174453f, -0.07339311f, 
    0.07456093f, 0.00290890f, -0.05752504f, -0.07406825f, -0.05881091f, -0.01038555f, -0.00728210f, 0.05331005f, 
    -0.02979355f, -0.01970451f, -0.07965488f, -0.07777976f, -0.04033404f, -0.04852765f, 0.04599771f, 0.06257140f, 
    0.02661021f, -0.03716349f, 0.01783560f, 0.07053498f, 0.00309674f, 0.04274013f, -0.01214258f, -0.02269793f, 
    -0.07010619f, -0.05027615f, 0.04327300f, -0.00723591f, 0.00296897f, -0.06398181f, -0.01025506f, -0.01665122f, 
    -0.03655282f, 0.00964746f, -0.05677123f, -0.03969578f, -0.07121918f, 0.00022665f, -0.05287994f, -0.04007782f, 
    0.05058092f, 0.01236775f, -0.05788830f, 0.02237578f, -0.04519594f, -0.02755558f, -0.03869015f, 0.03942119f, 
    -0.01384834f, -0.04341486f, 0.03880475f, 0.00308881f, 0.06991838f, -0.02933601f, 0.01319084f, -0.07533596f, 
    -0.01157008f, 0.02180126f, 0.00424281f, 0.05198373f, -0.02282775f, -0.01419051f, -0.06434628f, 0.02972508f, 
    -0.06507204f, -0.03246156f, 0.03029448f, 0.04651497f, 0.00383951f, -0.03799975f, -0.03886205f, -0.05213933f, 
    -0.00969375f, -0.00998645f, -0.01547064f, -0.03570769f, 0.00316520f, -0.07613003f, 0.04216208f, -0.02500794f, 
    0.00913132f, -0.05867545f, -0.00148943f, -0.03224388f, -0.00663693f, 0.03383540f, 0.01626861f, -0.03056695f, 
    -0.02272209f, 0.01807084f, 0.05945721f, -0.01669807f, -0.00881602f, -0.02864733f, 0.01809391f, -0.01139961f, 
    -0.10744169f, 0.12461860f, -0.02552960f, -0.24383335f, -0.07687227f, 0.10678833f, -0.00565182f, -0.27169266f, 
    0.00266933f, -0.02459427f, 0.07447415f, -0.13010742f, -0.18693149f, -0.25321773f, 0.29530594f, 0.37685612f, 
    0.00955437f, 0.16375552f, 0.01257603f, -0.14699258f, 0.05332088f, 0.06414963f, 0.02047056f, 0.07582074f, 
    0.04879897f, 0.08330130f, -0.04190831f, 0.32154083f, 0.00514008f, -0.07606304f, 0.17188196f, 0.16875538f, 
    -0.06397203f, 0.13116768f, 0.04414168f, 0.16691177f, 0.18798812f, 0.01646851f, -0.16473423f, -0.15798678f, 
    -0.11228579f, -0.05255338f, -0.03243313f, -0.00598805f, -0.11617337f, -0.02047962f, 0.10067157f, -0.09295909f, 
    -0.27312538f, -0.31054682f, -0.18254125f, 0.23213932f, 0.09264377f, -0.10125887f, 0.00203942f, 0.06800833f, 
    -0.12891445f, -0.02790697f, 0.04770211f, -0.11197866f, 0.00472244f, 0.52796876f, 0.15477872f, -0.05452384f, 
    0.31853661f, 0.16688819f, -0.07870688f, 0.03833560f, 0.14285585f, 0.03815220f, 0.17207664f, 0.01338404f, 
    -0.43236002f, 0.23322161f, -0.00190093f, 0.36148039f, -0.09445912f, 0.04783260f, 0.28698295f, 0.17986016f, 
    -0.16815346f, -0.08684643f, 0.14601825f, -0.00646543f, -0.03437829f, 0.07263593f, 0.18651837f, -0.14957601f, 
    -0.07965285f, -0.15686847f, -0.04003203f, 0.16013798f, -0.05186934f, 0.04976899f, 0.07087253f, 0.11009216f, 
    0.06479685f, 0.04971074f, 0.01613621f, -0.03977229f, 0.06132860f, 0.03788470f, 0.02616054f, -0.10703120f, 
    -0.04156522f, 0.09383104f, 0.04047305f, 0.05781212f, 0.00510472f, 0.00946482f, 0.11081493f, -0.39640534f, 
    -0.28510070f, -0.19499624f, -0.17869912f, 0.04923594f, -0.04505352f, 0.04563532f, 0.04439299f, -0.06544334f, 
    0.33151776f, -0.25783411f, 0.11751310f, 0.24566552f, 0.05020654f, -0.00389445f, 0.14031319f, 0.04625997f, 
    0.11096488f, 0.12061995f, -0.00527052f, 0.03091785f, -0.24725692f, -0.24317613f, -0.22337824f, 0.04740977f, 
    -0.05059846f, -0.18169382f, 0.07653417f, 0.08325858f, 0.02248856f, 0.01505591f, -0.20465450f, 0.03298986f, 
    -0.08848468f, -0.10787809f, 0.08811198f, 0.09763248f, 0.00221516f, 0.29012153f, 0.20077984f, 0.26415449f, 
    0.03525404f, 0.03452941f, 0.15760095f, -0.02207210f, -0.05961191f, 0.07125335f, -0.15050490f, 0.05570776f, 
    -0.06924303f, 0.17939730f, 0.09041943f, -0.03810205f, 0.08435419f, 0.02710061f, -0.02023075f, -0.07389999f, 
    0.47162342f, 0.10372938f, -0.11162518f, -0.16689196f, 0.11402148f, 0.08159228f, -0.01390632f, -0.10417474f, 
    0.07323195f, 0.09480603f, -0.04868660f, -0.04204631f, 0.24487919f, -0.00464211f, 0.27118823f, 0.08071365f, 
    -0.20422833f, 0.03980364f, 0.04942308f, -0.00829011f, -0.06059600f, 0.04691395f, 0.08405475f, 0.09300345f, 
    -0.15871054f, 0.07949852f, 0.00769302f, -0.01310679f, -0.12222886f, -0.03028100f, 0.03056050f, -0.14692219f, 
    0.28735447f, -0.04701598f, 0.12782156f, -0.06351571f, -0.02634198f, -0.36998227f, 0.47460455f, 0.28761581f, 
    -0.09501345f, 0.03664827f, 0.24154277f, -0.06328147f, -0.05303774f, -0.04114396f, 0.02066580f, -0.07077000f, 
    -0.06257816f, 0.08668833f, 0.04850738f, 0.25829029f, -0.14638110f, -0.15483181f, 0.07114662f, 0.17363131f, 
    0.07547309f, 0.13751407f, 0.05556176f, 0.12394387f, 0.06044706f, 0.02432731f, -0.04618001f, -0.03323704f, 
    -0.10702377f, -0.05774658f, 0.08737533f, 0.02020061f, -0.09423313f, -0.12797177f, -0.12193924f, -0.10495637f, 
    -0.39402089f, -0.27377716f, 0.09155550f, 0.21803923f, -0.20410292f, -0.10281735f, -0.28752279f, -0.01231662f, 
    0.01427280f, 0.04813999f, 0.00363448f, -0.09792575f, -0.21694200f, 0.30479795f, 0.12888034f, 0.18400417f, 
    0.09113893f, 0.07010351f, -0.06592137f, -0.08956791f, 0.15186527f, 0.15809752f, 0.26453647f, -0.03200044f, 
    -0.51106268f, -0.23605382f, 0.33011156f, 0.46519476f, 0.09909550f, 0.26923341f, 0.22050489f, 0.20773302f, 
    -0.15102655f, -0.00920590f, -0.02217734f, -0.07283871f, 0.15127490f, 0.08036447f, 0.08801763f, -0.15497804f, 
    0.06922545f, 0.03474473f, 0.13748129f, 0.11038197f, 0.04963675f, 0.00017952f, 0.02027978f, -0.04051815f, 
    0.03325751f, 0.08289819f, 0.03585833f, -0.02930997f, 0.08564323f, -0.00620415f, 0.23132393f, 0.00624308f, 
    0.02021656f, 0.12277349f, -0.07652862f, -0.06085132f, 0.31850255f, -0.11762220f, -0.15836549f, -0.21866858f, 
    -0.11197770f, 0.14273357f, 0.02365696f, 0.11996344f, -0.11408105f, -0.03886755f, -0.07534124f, -0.10087736f, 
    0.11620444f, -0.49036655f, 0.02141020f, 0.09463138f, 0.15678406f, -0.05166074f, 0.16731900f, 0.04634785f, 
    0.17432199f, 0.18144929f, 0.26654434f, 0.04218478f, -0.28563938f, 0.01383824f, -0.09411960f, 0.01466686f, 
    -0.10180245f, -0.07069050f, 0.13624412f, 0.10442530f, 0.20951062f, 0.14780152f, -0.02229784f, 0.08805468f, 
    -0.20777585f, -0.19008598f, 0.24264839f, 0.27938816f, -0.03415358f, 0.21918598f, 0.23000351f, -0.02178810f, 
    -0.04852701f, 0.04768284f, 0.15785432f, -0.02636006f, 0.04448260f, -0.00828358f, -0.17631175f, -0.01601103f, 
    0.09673437f, 0.02163946f, 0.10495133f, -0.01833137f, 0.09008014f, -0.07599951f, 0.01411457f, 0.09187391f, 
    0.46908316f, -0.08985797f, -0.30429685f, 0.02378872f, -0.03981601f, 0.10223988f, 0.00408996f, -0.08384044f, 
    0.10737510f, -0.09064186f, 0.08647767f, -0.07071429f, 0.08329705f, -0.04378132f, 0.02213202f, -0.15654676f, 
    -0.05166278f, 0.07555044f, 0.04125278f, 0.01524657f, -0.03580419f, 0.10906935f, -0.04080150f, -0.04903781f, 
    0.02049678f, 0.05095758f, -0.00632251f, 0.03670245f, 0.00842634f, -0.06039421f, 0.02347980f, 0.05051628f, 
    0.04993903f, 0.05907766f, -0.00944802f, -0.04730060f, 0.02264583f, 0.03353512f, 0.00709158f, 0.02189027f, 
    -0.02346973f, -0.04612422f, 0.05036283f, -0.00480264f, -0.01614526f, -0.06661207f, 0.03270166f, 0.02835431f, 
    0.06302764f, -0.02541322f, -0.05229920f, -0.07601608f, -0.03876439f, -0.05077470f, 0.01594662f, 0.03456131f, 
    0.05052437f, 0.03850872f, 0.01008160f, -0.05049083f, -0.02666943f, 0.04527288f, -0.07219866f, -0.07250157f, 
    0.00020721f, -0.05194771f, -0.05717249f, -0.03127426f, -0.03930284f, -0.08261770f, -0.04558130f, -0.06962378f, 
    0.00241925f, -0.06094023f, -0.02496060f, -0.06744794f, 0.01247094f, -0.07568298f, 0.02695187f, -0.00159758f, 
    -0.06419221f, 0.02123435f, -0.02998055f, -0.01061288f, -0.06611087f, 0.03121896f, 0.05745758f, 0.01674551f, 
    0.05858944f, -0.05415390f, 0.02181543f, 0.04375611f, -0.04673200f, 0.00485994f, -0.06883630f, -0.04618219f, 
    -0.03095451f, 0.03383243f, 0.04197940f, -0.04733809f, -0.05641356f, 0.04581349f, -0.04110748f, -0.07876015f, 
    -0.05418463f, 0.04237928f, -0.01537076f, 0.04655539f, -0.05570617f, -0.07610311f, 0.02885672f, 0.00666300f, 
    -0.04513675f, 0.03023204f, 0.01970518f, -0.00562768f, -0.01845887f, -0.03518794f, -0.04988471f, 0.04234614f, 
    -0.04857815f, 0.01927422f, 0.05096732f, -0.01731223f, -0.01218470f, 0.03291938f, -0.06494170f, -0.06442462f, 
    -0.07280404f, -0.02807523f, -0.04922206f, -0.03170554f, -0.00007225f, 0.00132191f, -0.07589600f, -0.07621557f, 
    -0.03702954f, -0.00212267f, 0.06235515f, -0.03594179f, 0.05386012f, -0.03003185f, -0.06585380f, -0.02888956f, 
    -0.04807432f, -0.00460671f, -0.00661495f, -0.06049256f, 0.00374112f, 0.02246259f, 0.00170887f, 0.00569817f, 
    -0.03286782f, 0.05697123f, 0.02041438f, 0.01358570f, -0.06920685f, 0.03890576f, 0.04325214f, 0.01585429f, 
    0.01063142f, -0.05508578f, -0.06982382f, -0.01404996f, 0.04294776f, 0.04878161f, -0.03139669f, 0.03048149f, 
    -0.06255393f, 0.04810454f, -0.05289031f, -0.02308171f, -0.04549734f, 0.01125512f, 0.06371871f, -0.03754115f, 
    -0.04195416f, -0.02506164f, 0.01700302f, -0.03538049f, -0.02155159f, -0.01900355f, -0.07744082f, 0.02459303f, 
    0.04470994f, 0.01533559f, -0.03676563f, 0.04553647f, 0.02351424f, 0.05273267f, -0.05955459f, -0.02938223f, 
    0.01848290f, 0.00592883f, 0.02750643f, 0.01754403f, -0.01382072f, -0.05477008f, -0.05072505f, 0.02318968f, 
    -0.05304638f, 0.03583077f, -0.04784144f, 0.05373015f, 0.01537619f, -0.08099282f, 0.03574077f, -0.02030706f, 
    0.05190178f, -0.02758423f, -0.06885115f, -0.06909113f, 0.01294312f, -0.05575604f, 0.04909956f, -0.05944545f, 
    -0.25776020f, 0.01296636f, -0.14264292f, 0.01770908f, 0.04860928f, 0.02280708f, 0.02895354f, 0.07911034f, 
    0.00773508f, 0.20251079f, 0.16530208f, 0.22373506f, -0.13494962f, 0.14533636f, 0.13328846f, -0.13396271f, 
    -0.10219074f, -0.11576089f, 0.12575494f, 0.01052970f, 0.10702169f, 0.17123301f, 0.04630174f, -0.02268446f, 
    -0.29377380f, 0.22894467f, -0.11143372f, -0.02172154f, 0.11698213f, 0.27177337f, 0.03041038f, 0.15880963f, 
    -0.21738523f, 0.03739468f, -0.05721608f, -0.00375480f, -0.07276937f, -0.00493874f, -0.07465970f, 0.02497758f, 
    0.11490770f, 0.09103864f, -0.06932917f, 0.09646534f, -0.13814239f, -0.00183356f, -0.01655799f, -0.08451090f, 
    0.35151163f, -0.00405567f, -0.10090314f, -0.20827252f, -0.08099209f, 0.03996571f, 0.06986384f, -0.14097916f, 
    0.00003252f, -0.01965342f, -0.05316704f, -0.01684712f, -0.27394322f, -0.41195619f, -0.28720555f, 0.06249613f, 
    -0.18972467f, 0.03480561f, 0.25018883f, 0.06739368f, 0.32274061f, 0.15213901f, 0.16791238f, 0.12457511f, 
    0.19216682f, 0.45548820f, -0.14504787f, 0.19310874f, 0.16324751f, 0.06254948f, -0.04326126f, -0.01446789f, 
    0.08252221f, -0.04607068f, 0.11663313f, 0.03028053f, -0.27046207f, 0.02147079f, -0.00091113f, -0.04440787f, 
    -0.07185752f, 0.12266474f, 0.01935314f, 0.09657812f, -0.07756319f, -0.03243925f, -0.15391225f, -0.02452794f, 
    -0.02425246f, 0.09030898f, -0.08940727f, 0.03133446f, 0.37422684f, 0.02845025f, 0.02859303f, 0.00140395f, 
    -0.15765426f, 0.04752807f, 0.10558437f, 0.00591807f, 0.34856713f, 0.21365258f, 0.24657892f, -0.13285431f, 
    -0.03503311f, 0.05934701f, 0.02238857f, 0.15054233f, -0.07430658f, -0.00235814f, -0.06183650f, 0.05343179f, 
    -0.42993981f, 0.24621934f, 0.10956188f, -0.01188582f, -0.06806457f, -0.02479258f, -0.06379306f, -0.05873735f, 
    0.05839233f, 0.06042616f, 0.03820457f, -0.05366976f, 0.04141098f, -0.09474055f, -0.19135921f, -0.11839345f, 
    -0.04408393f, 0.09633891f, 0.07731558f, 0.06305595f, -0.01784078f, 0.06889586f, 0.01033551f, -0.05274032f, 
    0.32241917f, 0.04283462f, 0.13536619f, 0.10542921f, -0.21169485f, -0.08474033f, -0.03781786f, -0.00051607f, 
    -0.11017853f, 0.11500991f, -0.12918656f, 0.02748548f, -0.06494720f, 0.39431518f, -0.09758673f, 0.24459212f, 
    -0.04312328f, 0.04167252f, 0.00797731f, -0.09859579f, -0.05819387f, -0.06339042f, -0.03675373f, -0.12767078f, 
    0.13311282f, 0.18123443f, -0.01327673f, 0.11389714f, 0.14748974f, 0.04076517f, -0.04419660f, 0.16725007f, 
    -0.01382473f, -0.00559831f, 0.08300424f, 0.01362924f, -0.16936243f, 0.08368374f, 0.24751088f, -0.00122933f, 
    0.04343882f, -0.05940982f, -0.12569195f, 0.05916188f, -0.05510315f, 0.06792141f, -0.03701060f, 0.00144670f, 
    0.30454159f, -0.21240826f, 0.38422981f, 0.10091287f, -0.09299473f, -0.05900087f, 0.19144085f, 0.31091124f, 
    0.35128558f, 0.17037188f, -0.01164661f, 0.08414716f, 0.03034446f, 0.27758005f, -0.09918614f, 0.06527298f, 
    0.09761561f, 0.15324427f, 0.16335058f, 0.20655684f, -0.01163332f, 0.06177164f, -0.31470907f, -0.17168193f, 
    0.38416028f, 0.24479605f, 0.38115811f, 0.18947276f, 0.07814641f, 0.03423217f, -0.12324083f, 0.00386219f, 
    0.12927429f, 0.13301957f, 0.13809299f, 0.15643649f, -0.10581757f, 0.04726336f, 0.01573222f, -0.12193178f, 
    0.08470773f, 0.05079434f, 0.04564961f, -0.24339388f, -0.16859686f, -0.22803210f, -0.40877637f, -0.37586641f, 
    0.08136476f, 0.13361849f, -0.07428457f, -0.10581486f, -0.08803166f, -0.05159560f, -0.11780590f, -0.02908550f, 
    -0.11105443f, -0.15552276f, -0.10780714f, -0.03821143f, 0.56390160f, 0.11984649f, 0.23933007f, 0.04242305f, 
    -0.18608198f, 0.00102496f, -0.06030463f, -0.05150646f, -0.02631889f, 0.13944452f, -0.06656646f, 0.06320277f, 
    -0.02485293f, -0.15122071f, 0.34274787f, -0.10436549f, 0.10368583f, 0.20134299f, -0.02592925f, 0.16978751f, 
    -0.01184346f, -0.03927869f, 0.02677925f, -0.14709662f, 0.22245854f, -0.21606487f, 0.11997260f, 0.32852942f, 
    0.16604352f, -0.15844317f, 0.32136074f, -0.01081119f, 0.07984260f, 0.04273920f, 0.00570448f, 0.41988185f, 
    -0.22696626f, -0.17210148f, -0.10906602f, 0.21218446f, 0.08424986f, 0.06806161f, -0.02465605f, -0.20362632f, 
    -0.54461050f, -0.51683694f, -0.38887873f, -0.47358990f, -0.02040956f, -0.15960078f, -0.12980817f, 0.19686005f, 
    0.13687919f, 0.09368184f, 0.12076578f, -0.24882880f, -0.17867179f, -0.23619467f, -0.04419297f, 0.15243945f, 
    -0.16876039f, -0.20731229f, -0.04268504f, 0.10242014f, -0.07223524f, -0.01153767f, -0.05381523f, 0.02914125f, 
    0.13012385f, -0.01090038f, 0.14137396f, 0.19529416f, -0.01754025f, 0.01819339f, 0.06579582f, 0.11342032f, 
    0.12362151f, 0.31049320f, 0.16923389f, 0.03751511f, 0.17876734f, 0.26041010f, 0.22961757f, 0.22898197f, 
    -0.05492051f, -0.00435438f, 0.30695736f, 0.11696459f, 0.20127928f, 0.08497500f, -0.06110248f, 0.03904301f, 
    0.11954842f, 0.16614676f, 0.14330013f, 0.08884892f, 0.01512998f, -0.66682762f, 0.14078133f, -0.00773008f, 
    0.03192803f, 0.19173324f, -0.07767287f, 0.00072642f, 0.20888135f, -0.03978879f, 0.31348655f, 0.06707796f, 
    0.02546471f, -0.15422611f, -0.28002980f, 0.08443944f, -0.05224788f, 0.16327190f, -0.12677586f, -0.22363888f, 
    0.14484322f, -0.09619533f, 0.23586313f, 0.13438271f, -0.41572765f, -0.14988899f, -0.19657013f, -0.08023047f, 
    0.10591933f, -0.13577552f, 0.12001225f, 0.02560503f, -0.22470172f, -0.07853493f, -0.06741038f, -0.36959666f, 
    0.20483844f, -0.19351047f, 0.04723716f, 0.06262334f, 0.03239980f, -0.05246150f, -0.06667703f, 0.03971181f, 
    0.07838138f, 0.12663953f, -0.12566267f, 0.03556755f, 0.30601805f, -0.14507185f, -0.29973274f, 0.18256344f, 
    0.17055675f, 0.15122712f, -0.02850946f, 0.22807854f, 0.05606352f, 0.02175406f, 0.00884965f, 0.03721004f, 
    0.19022049f, -0.04775742f, 0.34193411f, -0.05666690f, 0.01351889f, -0.14251992f, -0.05814541f, -0.00633680f, 
    -0.00859572f, -0.06788880f, 0.13353828f, 0.12092248f, -0.09365760f, -0.14246447f, 0.13495594f, 0.08694389f, 
    0.04187714f, -0.20903376f, -0.05978678f, -0.00184509f, 0.23034894f, -0.06017938f, 0.01696835f, 0.27919230f, 
    -0.05657682f, 0.05832455f, 0.29993805f, -0.14050332f, -0.04690096f, 0.01870344f, -0.00772142f, 0.13427991f, 
    -0.08210301f, -0.02290080f, 0.02296916f, 0.04313774f, 0.04428744f, 0.21774626f, 0.26053667f, 0.33682406f, 
    0.13721907f, -0.07424565f, -0.11582570f, 0.00161178f, -0.05689890f, 0.09645200f, 0.10922946f, -0.04629797f, 
    -0.01370437f, -0.45397362f, 0.32369223f, -0.00530381f, 0.17025310f, 0.15803124f, 0.11546973f, -0.01603392f, 
    -0.01681428f, 0.07846365f, -0.17160635f, 0.02900089f, -0.12730105f, -0.19685471f, 0.01849132f, 0.15802515f, 
    0.01442543f, 0.04856246f, 0.09278885f, 0.07665695f, 0.05355641f, -0.12195554f, 0.02611415f, -0.00764281f, 
    0.10609400f, -0.17066410f, -0.17267676f, 0.08221992f, -0.04982409f, 0.17386007f, 0.10943975f, -0.07023550f, 
    0.04908931f, -0.04677518f, -0.22143845f, -0.08140226f, -0.29096514f, -0.34663901f, -0.38133484f, 0.24339166f, 
    0.03091201f, 0.16061944f, 0.16844614f, -0.11489207f, 0.07734080f, -0.08036863f, -0.07219630f, -0.01087337f, 
    -0.06534263f, -0.18903957f, -0.19617714f, -0.33437073f, 0.00879302f, -0.03272633f, 0.06593340f, 0.08388640f, 
    0.04963616f, 0.00275616f, 0.03050045f, 0.08203670f, 0.02098889f, 0.25684449f, 0.16599670f, -0.04063587f, 
    0.12059109f, 0.02707709f, -0.05286773f, -0.01778253f, -0.02502574f, 0.00354081f, -0.02141271f, 0.05577077f, 
    -0.02734333f, -0.03996789f, 0.14189486f, 0.07781046f, 0.20007336f, 0.01978840f, 0.14803205f, -0.08472656f, 
    -0.04125544f, -0.05122793f, -0.01333052f, -0.03308070f, 0.00025044f, -0.37899619f, 0.03978373f, -0.20492278f, 
    0.05705224f, 0.06318752f, -0.05577284f, 0.02650271f, 0.09460531f, 0.05334419f, 0.13943057f, 0.10693548f, 
    -0.17382190f, 0.00066525f, -0.18058710f, 0.13243428f, -0.08600344f, 0.07784302f, 0.15668544f, -0.03449671f, 
    0.16337836f, -0.05219305f, 0.06986157f, 0.02609710f, -0.19559115f, -0.19484510f, -0.25609639f, 0.07276765f, 
    0.03605780f, -0.17370263f, -0.02082519f, 0.00868608f, 0.00704071f, -0.06210781f, -0.04106356f, 0.00104815f, 
    0.04385511f, 0.04474409f, 0.00866542f, -0.04382791f, 0.02219841f, -0.03535002f, 0.04009700f, -0.06282335f, 
    -0.06822133f, -0.03318919f, -0.07756046f, -0.03906954f, 0.03312808f, 0.05095725f, 0.02495815f, 0.04144985f, 
    -0.03507302f, 0.02834435f, -0.08510155f, 0.01289541f, -0.06234052f, -0.03855202f, -0.05181488f, -0.02993968f, 
    -0.06429547f, -0.06506172f, 0.00716218f, 0.04830442f, -0.06697490f, 0.01836632f, -0.03096606f, 0.03491945f, 
    -0.00923872f, -0.06924927f, -0.04235617f, -0.01533999f, 0.00231821f, -0.06260434f, -0.01416151f, 0.05324736f, 
    0.05518560f, 0.00658529f, -0.03842986f, -0.00664238f, -0.01992052f, 0.01366403f, 0.01915843f, 0.02677656f, 
    0.01576282f, 0.01262647f, 0.01458997f, 0.00354360f, 0.04718565f, -0.04066089f, 0.03350642f, -0.05114161f, 
    0.01561533f, 0.00231317f, -0.01391243f, -0.02173812f, 0.05773188f, -0.03222037f, -0.05310117f, -0.03831148f, 
    0.01158646f, -0.03159860f, 0.04656937f, -0.03198425f, -0.02805081f, -0.05164909f, -0.06598891f, -0.00948590f, 
    0.05919323f, -0.07610545f, -0.05393847f, -0.04095911f, -0.04808557f, -0.07674142f, 0.05825046f, -0.02924315f, 
    0.03251771f, 0.04949947f, -0.00953550f, -0.03254661f, 0.05951251f, -0.06630571f, -0.05151240f, -0.07897119f, 
    -0.03276067f, -0.00127609f, -0.03019480f, 0.04382810f, -0.00939002f, 0.01023365f, -0.05410787f, -0.01804868f, 
    0.01367218f, -0.01335612f, -0.07260833f, -0.02820259f, 0.06140232f, 0.02959154f, -0.03123552f, 0.01829733f, 
    0.01369472f, -0.00182727f, -0.00436931f, -0.03882651f, -0.06320290f, 0.03230516f, 0.00520721f, 0.04643662f, 
    0.06255149f, -0.05641207f, 0.01152832f, 0.00424517f, -0.03966894f, -0.04122975f, -0.04571297f, -0.02002718f, 
    -0.06340659f, 0.05467470f, 0.05055994f, 0.03099696f, 0.05865105f, 0.02386368f, 0.00460146f, 0.00942612f, 
    -0.08094923f, -0.05542621f, -0.06073434f, -0.06006865f, -0.04811927f, 0.03863658f, 0.01122098f, 0.04318687f, 
    -0.00240910f, -0.02002178f, 0.00522154f, -0.03147462f, -0.05915454f, -0.04724138f, 0.03258067f, 0.03192776f, 
    0.04261213f, 0.02455910f, 0.04647994f, -0.00127212f, -0.05472234f, -0.05397191f, -0.08041751f, -0.08458637f, 
    -0.00744190f, -0.02275704f, -0.00327263f, 0.03995099f, -0.04313230f, -0.07825140f, -0.05492454f, -0.07230511f, 
    -0.07141723f, -0.07423766f, -0.01067805f, -0.02306302f, 0.00907980f, -0.01970668f, -0.04796410f, 0.00681599f, 
    -0.02874719f, -0.01697791f, -0.05287234f, 0.01096723f, 0.00252780f, -0.07451131f, -0.02587169f, -0.02359428f, 
    -0.04035886f, -0.03033188f, 0.04817721f, -0.07418022f, -0.05744788f, 0.06222630f, -0.08047891f, -0.02267825f, 
    -0.06665973f, -0.00295930f, 0.01685572f, 0.03137194f, -0.05959613f, -0.01299228f, 0.05189100f, -0.03191002f, 
    -0.14098208f, 0.07931832f, 0.08953893f, -0.27671146f, -0.10273985f, -0.07073976f, -0.09907172f, -0.17512086f, 
    -0.11869168f, 0.03609750f, 0.25170442f, 0.05285852f, 0.00617979f, -0.02407355f, -0.20593151f, -0.00022584f, 
    0.05555538f, 0.03343706f, -0.01807146f, -0.04349860f, 0.02470018f, 0.13916013f, 0.07351132f, 0.15235715f, 
    -0.13649122f, -0.20895670f, -0.19883312f, -0.12860844f, 0.13843854f, 0.20432800f, 0.07468317f, 0.13897006f, 
    0.11414043f, 0.08090352f, 0.16876099f, 0.13410655f, 0.04191685f, -0.01502647f, -0.08554309f, -0.04697176f, 
    0.00353555f, -0.09998692f, -0.09861554f, -0.10645366f, 0.14590654f, 0.18961374f, 0.08634645f, 0.01549119f, 
    0.16601276f, 0.12115128f, -0.27375934f, -0.04068233f, 0.27809566f, -0.01074558f, 0.07923580f, -0.06430533f, 
    -0.01514046f, 0.01938165f, -0.10326535f, -0.08029617f, 0.00275242f, 0.10644567f, -0.10681980f, -0.11282208f, 
    -0.12514526f, -0.02920541f, -0.00187646f, -0.17953528f, 0.13948588f, -0.05743519f, 0.20826259f, 0.20636812f, 
    0.28740808f, 0.56122464f, -0.04049505f, -0.14964905f, 0.09226555f, 0.03885461f, 0.05767934f, -0.04808554f, 
    0.16573031f, 0.05376809f, 0.16052048f, 0.22483537f, -0.44776002f, 0.00857419f, 0.16188177f, 0.14039160f, 
    -0.03834172f, 0.10736963f, 0.02715951f, -0.27609929f, -0.34850621f, 0.01306061f, -0.04648159f, -0.08466071f, 
    0.05550753f, -0.05765475f, -0.08842032f, -0.02650215f, -0.08895431f, -0.09877019f, 0.01470213f, -0.01575445f, 
    -0.01665130f, 0.07329689f, -0.08045579f, 0.08208171f, 0.23093632f, 0.41961488f, 0.43296275f, 0.00145102f, 
    0.00951429f, -0.03107211f, -0.13316135f, -0.01367741f, -0.20252180f, -0.06059359f, -0.13901499f, 0.06762606f, 
    0.03499518f, 0.16712499f, 0.07323391f, -0.15556598f, -0.01847233f, 0.20393518f, 0.10534682f, 0.14692265f, 
    -0.07548811f, 0.12201611f, -0.01731877f, 0.01863146f, 0.04512902f, 0.00197415f, 0.01211529f, -0.06380675f, 
    0.00165682f, 0.08998284f, 0.11118145f, 0.00561977f, -0.13708553f, -0.11226153f, 0.11487986f, -0.06867233f, 
    -0.02027851f, 0.19958854f, -0.09830716f, -0.17116764f, -0.07707332f, 0.14915946f, 0.07686377f, 0.13524739f, 
    0.04218936f, 0.03830081f, -0.03778567f, 0.09012090f, 0.09884689f, 0.07425330f, -0.07930102f, 0.06555859f, 
    -0.24512729f, 0.11285160f, -0.10337006f, -0.02335877f, -0.05966391f, 0.01903286f, -0.15151627f, -0.14373714f, 
    0.40909389f, 0.21983661f, 0.33460158f, -0.04089241f, 0.20596549f, 0.01390800f, -0.04703777f, 0.17432375f, 
    0.04327720f, 0.19279012f, -0.19601257f, -0.09875868f, 0.10836782f, 0.23997931f, 0.25789031f, 0.17583488f, 
    -0.20296969f, -0.04628941f, -0.06240370f, -0.11822807f, -0.02570252f, -0.06586926f, 0.02434002f, 0.20815760f, 
    -0.22693786f, -0.01929179f, -0.14587308f, 0.04431335f, 0.02588961f, -0.14617597f, -0.09767218f, 0.01881287f, 
    0.16956677f, 0.05064781f, -0.02039222f, 0.12011889f, -0.01682887f, 0.03597994f, 0.06967872f, -0.14014855f, 
    0.03803157f, -0.01964517f, -0.01122157f, 0.05829844f, 0.05887141f, -0.11152766f, 0.13468625f, -0.00714189f, 
    -0.28257301f, 0.19876155f, -0.00829905f, -0.04577526f, -0.19422090f, 0.09089316f, 0.26208746f, -0.01039338f, 
    0.15144669f, -0.05419003f, 0.10931456f, -0.15469459f, -0.13403560f, -0.22902340f, -0.13623516f, 0.11853341f, 
    -0.15559998f, -0.07622429f, -0.06200184f, 0.17254195f, -0.07419556f, 0.00328136f, 0.13299848f, 0.09582386f, 
    0.00376506f, -0.15227030f, 0.21099398f, -0.01559949f, -0.06262404f, 0.19014578f, 0.13749605f, 0.01993434f, 
    0.01090067f, 0.15851751f, 0.19088064f, 0.19289102f, -0.09455229f, -0.47409442f, 0.20378463f, 0.30403617f, 
    -0.22700684f, -0.15573160f, -0.03289783f, 0.08701916f, 0.49332377f, 0.05594075f, 0.25035697f, 0.04015063f, 
    0.32806647f, -0.26611084f, 0.02633609f, 0.05152884f, 0.16211848f, 0.10505408f, 0.18405865f, 0.08392566f, 
    0.29507041f, 0.09559964f, -0.05965677f, 0.00749459f, 0.03501683f, 0.08590708f, -0.06105195f, -0.16955890f, 
    -0.00846512f, 0.15564640f, -0.14319605f, -0.11565641f, -0.04326853f, -0.07496893f, -0.04869866f, -0.12669012f, 
    -0.05729644f, 0.00590978f, -0.07470347f, -0.11297694f, 0.10451452f, -0.00788770f, 0.00155048f, 0.09149235f, 
    -0.00667121f, -0.03435876f, 0.08923870f, 0.00331631f, 0.43077186f, 0.12238801f, -0.16878781f, -0.01919913f, 
    0.03466217f, -0.04565932f, 0.02492929f, -0.18263862f, -0.00194590f, -0.08402668f, -0.17556149f, -0.02655248f, 
    -0.40384173f, 0.25476083f, -0.02998888f, -0.03286607f, 0.06544482f, -0.05648027f, 0.21452157f, 0.00653479f, 
    0.11596918f, 0.14157492f, 0.01576994f, -0.14044872f, -0.03586042f, 0.08464279f, 0.18342775f, -0.17307128f, 
    -0.14906755f, -0.14519393f, 0.04046664f, -0.08266065f, 0.17899683f, 0.09956177f, 0.10358927f, 0.07478855f, 
    0.17294279f, 0.14681110f, 0.42339870f, 0.15866499f, 0.10771469f, 0.09487213f, 0.19097333f, 0.05749923f, 
    0.04402264f, 0.04795384f, 0.06180977f, -0.03106323f, -0.05649098f, -0.01199481f, -0.15377788f, -0.02735492f, 
    0.04985549f, 0.02603804f, 0.03134079f, -0.10173894f, -0.21831353f, -0.10709175f, 0.02044194f, -0.14142558f, 
    0.05261098f, -0.13745096f, -0.06502431f, 0.53178722f, 0.17245078f, -0.05406421f, 0.14961012f, 0.23588684f, 
    0.00135362f, 0.14693896f, 0.10310976f, 0.10176668f, 0.04845514f, 0.18230782f, 0.07352822f, -0.11797789f, 
    0.09330985f, 0.05609110f, 0.00111085f, -0.04423296f, -0.07440821f, 0.10253673f, 0.02793678f, 0.04720580f, 
    -0.10497640f, -0.06910142f, -0.06627586f, 0.05964100f, 0.02090157f, 0.02417256f, 0.05375685f, 0.19568665f, 
    -0.03144410f, 0.04340295f, -0.00357693f, -0.13386762f, -0.09213617f, -0.34389848f, -0.19087653f, -0.05582271f, 
    0.24943194f, 0.14417116f, -0.01520872f, 0.03511264f, 0.03124495f, 0.12700127f, 0.03662478f, 0.07415458f, 
    0.02687197f, 0.34630224f, 0.09818857f, 0.20629334f, 0.16446526f, 0.12301646f, 0.00691143f, -0.02871915f, 
    0.00546544f, 0.12202092f, 0.07525020f, 0.06414622f, -0.20666482f, -0.05224168f, 0.14629640f, 0.04689864f, 
    0.07784461f, -0.05516241f, -0.05747347f, -0.02476093f, 0.13342795f, 0.10741905f, 0.09133802f, 0.11061727f, 
    0.03662872f, 0.06412566f, -0.18319738f, -0.02907770f, 0.12166589f, 0.02227083f, 0.04612677f, -0.02331994f, 
    -0.01249261f, 0.01545882f, 0.06725354f, 0.03772451f, -0.28515568f, 0.01820944f, -0.03354745f, -0.02195521f, 
    0.15321097f, 0.01195256f, 0.13260394f, 0.10127063f, -0.09106164f, -0.11663626f, -0.00439432f, 0.08527368f, 
    -0.24209151f, 0.27332261f, -0.12520739f, 0.06677449f, 0.11513998f, -0.00091282f, -0.01707615f, 0.16274862f, 
    0.11517850f, -0.01381330f, 0.00688368f, 0.03633062f, -0.30252609f, -0.27879050f, -0.04010347f, -0.02690303f, 
    0.09787486f, 0.09452099f, 0.07063489f, 0.06740667f, 0.04859706f, 0.00223160f, 0.03351165f, -0.06609765f, 
    0.01478739f, -0.09567451f, -0.03130117f, 0.03354971f, -0.01302236f, 0.14301053f, -0.13191019f, -0.01760173f, 
    0.01374009f, -0.00995369f, 0.09299653f, -0.00154190f, -0.51251072f, -0.33254606f, 0.00298975f, -0.18522002f, 
    0.11744107f, -0.01663287f, 0.06826945f, 0.05617917f, -0.00102937f, -0.03294726f, 0.00267979f, 0.08882837f, 
    0.31085151f, 0.11032575f, 0.02673689f, 0.05850293f, -0.07682148f, 0.04577329f, -0.08354209f, 0.14636034f, 
    -0.10104822f, -0.12637657f, -0.12406401f, 0.11261944f, 0.04856822f, -0.03849396f, -0.07554027f, 0.11313359f, 
    0.21137455f, 0.14975399f, 0.02007987f, -0.02572745f, -0.09535423f, 0.02948475f, 0.10115140f, -0.00835660f, 
    0.25213164f, 0.01417185f, 0.01277116f, -0.21358471f, 0.10061915f, 0.08192394f, 0.08166609f, -0.00090887f, 
    0.00583311f, -0.13149887f, 0.08119506f, -0.15392749f, -0.12468758f, -0.05361784f, -0.02914370f, 0.10576321f, 
    -0.18346821f, -0.03892741f, -0.09362531f, 0.02489815f, 0.10292618f, 0.21579073f, 0.17549467f, 0.04032555f, 
    -0.46729589f, 0.11545280f, -0.02915118f, 0.11076428f, -0.12242722f, -0.13707045f, 0.04671443f, 0.16134590f, 
    0.07486703f, 0.03866626f, -0.05521816f, -0.02454489f, 0.07940186f, -0.15284887f, -0.01734996f, -0.03543732f, 
    0.13189133f, -0.05874992f, -0.00797214f, 0.09484647f, -0.03831403f, 0.01121179f, -0.06621858f, -0.00452930f, 
    -0.02844660f, -0.11895239f, -0.03232394f, 0.02604485f, -0.10587182f, -0.10431457f, 0.00299230f, 0.03235450f, 
    0.01489452f, 0.03190073f, -0.01668141f, -0.01141250f, 0.07572483f, -0.00174115f, -0.03746500f, 0.01504767f, 
    0.02060962f, 0.01228320f, -0.04511534f, -0.00883676f, -0.05889021f, -0.04853944f, -0.06198814f, 0.01786418f, 
    0.00801451f, -0.00142071f, 0.07387125f, 0.09902137f, -0.06817807f, 0.02810477f, 0.06854701f, 0.01641770f, 
    -0.00282660f, -0.07015047f, 0.05197933f, 0.03185158f, -0.05890844f, -0.05905351f, -0.00920383f, 0.02255381f, 
    0.04890703f, -0.05175645f, 0.03269748f, 0.03459527f, 0.04747088f, -0.02790375f, 0.06264319f, -0.01314035f, 
    0.02343476f, -0.04905034f, 0.08836804f, 0.00742727f, 0.08847857f, -0.01267429f, -0.05312821f, -0.01556625f, 
    0.08731543f, 0.00214072f, -0.04017748f, -0.07043079f, 0.03351177f, 0.01054642f, 0.02981223f, -0.01356835f, 
    -0.05606220f, 0.01711328f, 0.04345335f, -0.04477289f, 0.01617634f, -0.03207378f, 0.01778136f, -0.00623108f, 
    0.03568818f, 0.03613753f, 0.04460238f, -0.08300396f, 0.08288025f, -0.03779138f, 0.03085347f, 0.01005086f, 
    -0.02641848f, -0.05040349f, 0.02877078f, -0.04819353f, -0.06788681f, -0.10339027f, -0.05389884f, 0.01261932f, 
    -0.07966600f, -0.04025392f, -0.01353838f, -0.08173858f, -0.10866887f, -0.04269819f, -0.03790209f, -0.10128391f, 
    0.00693014f, -0.00997159f, -0.10868151f, -0.03740115f, -0.00412922f, 0.07006228f, -0.04370485f, -0.06720757f, 
    -0.03453533f, 0.03463209f, -0.02570330f, -0.06534324f, -0.05630249f, 0.01336595f, -0.01278009f, -0.04892771f, 
    -0.01211311f, 0.00178307f, 0.03947072f, -0.07413009f, -0.06357732f, -0.04269376f, -0.02332440f, -0.04356545f, 
    -0.03565684f, -0.02175811f, -0.01186323f, -0.05986268f, -0.01287238f, -0.07234544f, 0.01374890f, -0.04487093f, 
    0.03907153f, 0.02513565f, 0.05550679f, -0.02059586f, 0.02133705f, 0.07669668f, 0.02363029f, 0.04539237f, 
    -0.02308687f, -0.01707876f, -0.05070787f, 0.07375591f, 0.02321290f, -0.07319685f, -0.06006395f, -0.09455784f, 
    -0.00952853f, 0.02313341f, -0.05470368f, -0.00535876f, -0.00082575f, 0.07550025f, 0.05520913f, -0.04694695f, 
    -0.02092187f, 0.01242300f, 0.05458974f, -0.00077248f, -0.09726947f, -0.11342029f, 0.00397359f, -0.09852846f, 
    0.02271001f, 0.04126486f, -0.02440294f, -0.08175261f, -0.01679094f, 0.03857991f, -0.01520492f, -0.02903399f, 
    -0.06274235f, -0.08052648f, -0.02722440f, 0.01345678f, 0.02569534f, -0.09537083f, -0.00662794f, 0.00480998f, 
    0.02915351f, 0.06158413f, -0.01312156f, 0.04971069f, 0.00245167f, 0.04624908f, 0.03535346f, -0.06858371f, 
    -0.08761714f, -0.09772471f, -0.00746002f, 0.00891398f, -0.09546285f, -0.08520501f, 0.02521761f, -0.08441846f, 
    -0.00840248f, 0.13738263f, -0.11169527f, -0.09523983f, 0.00197507f, -0.03134481f, 0.07535902f, 0.01338107f, 
    0.07014147f, -0.10326310f, -0.03490490f, 0.15298113f, 0.27632385f, 0.22871326f, 0.48053175f, 0.08282895f, 
    0.06948017f, -0.08782079f, -0.00537404f, 0.25655228f, 0.03502014f, -0.18119510f, 0.11562191f, -0.05998411f, 
    -0.10283246f, -0.34194899f, -0.04600304f, -0.05268902f, -0.19779712f, -0.17085044f, 0.03061070f, -0.13518149f, 
    0.11912788f, -0.19032569f, -0.02998445f, -0.01300275f, 0.15469342f, -0.04827813f, -0.14643557f, 0.02794542f, 
    0.04981202f, -0.01783119f, 0.07312658f, -0.10387966f, -0.05499040f, -0.17139123f, -0.11798590f, -0.20933001f, 
    0.07563267f, 0.15499842f, 0.57519102f, 0.05162800f, 0.20623124f, 0.20557047f, -0.11948019f, 0.20527045f, 
    0.14419541f, -0.05373173f, 0.03982685f, -0.06803969f, -0.09820778f, 0.12430517f, -0.32784927f, -0.19850808f, 
    0.10770863f, -0.06731260f, -0.07920895f, -0.05302064f, -0.07667240f, -0.12942646f, -0.07117925f, 0.01435904f, 
    0.12133528f, -0.29011741f, 0.21924548f, -0.14393313f, -0.10641501f, 0.00449677f, 0.04370136f, 0.08081971f, 
    -0.15114401f, -0.08339822f, -0.00592943f, -0.08496456f, 0.46874800f, 0.10937507f, 0.11263064f, 0.07528292f, 
    -0.03479426f, 0.14897852f, 0.05855965f, 0.13638474f, 0.20640229f, 0.08393726f, 0.14568529f, -0.04093155f, 
    0.02882743f, 0.07366688f, 0.10819962f, 0.06467955f, -0.09581885f, 0.13440211f, -0.01080397f, -0.10305099f, 
    0.09773869f, -0.03864218f, -0.19156843f, -0.09827378f, 0.35655019f, 0.08171247f, 0.29480377f, 0.07423937f, 
    0.07309272f, 0.15097068f, -0.03557196f, 0.19068971f, 0.09366709f, -0.08903734f, -0.01376478f, -0.09629739f, 
    -0.08042549f, -0.04389009f, 0.07899899f, -0.09392101f, 0.12280681f, -0.15605249f, -0.10645663f, 0.08066707f, 
    0.00887442f, -0.06331786f, 0.12760141f, 0.03035612f, -0.10935911f, 0.12714411f, 0.12881470f, 0.02881660f, 
    0.04163386f, -0.06852233f, 0.07331600f, 0.10826311f, 0.01133290f, 0.03461368f, 0.21622165f, -0.03317121f, 
    0.06513818f, 0.07918348f, -0.09810016f, 0.29698637f, 0.13627428f, -0.05330174f, 0.13197537f, -0.06219249f, 
    0.10971948f, -0.04739115f, 0.28317681f, -0.14584650f, 0.17434949f, 0.16784802f, 0.01123311f, -0.03000268f, 
    -0.01577661f, -0.02577602f, 0.05296516f, 0.03823566f, 0.05918941f, 0.08709650f, 0.00502718f, -0.09541216f, 
    -0.10334320f, -0.18012765f, 0.04089457f, 0.00943610f, -0.01473300f, -0.06421803f, -0.12927601f, -0.13264702f, 
    0.15051042f, 0.03034319f, 0.00748940f, -0.05910690f, 0.36852309f, -0.07826003f, 0.00033862f, 0.10937634f, 
    0.14917396f, -0.02141114f, -0.20853928f, 0.13436443f, 0.01661619f, -0.06872900f, -0.00900770f, -0.13810579f, 
    0.03074181f, 0.06045860f, -0.06370953f, -0.03908679f, -0.01346260f, -0.06168519f, -0.04594726f, -0.04816443f, 
    -0.06919207f, -0.00227535f, -0.00611587f, -0.06729342f, 0.00906224f, -0.00282118f, -0.04706627f, 0.04574348f, 
    0.04636173f, 0.05366452f, -0.05094894f, -0.03442197f, -0.00573072f, -0.01590329f, 0.03061366f, -0.02356471f, 
    -0.05955989f, 0.06369697f, 0.03532062f, -0.06741992f, -0.03352417f, -0.03999526f, 0.01304101f, -0.07705180f, 
    0.00768812f, 0.06070441f, -0.02461204f, -0.07357871f, 0.05137595f, -0.03973725f, -0.01295993f, -0.07603834f, 
    -0.02221527f, -0.07739781f, -0.00658326f, 0.04907245f, 0.06433178f, -0.06366368f, -0.00487954f, 0.02623974f, 
    -0.04578946f, 0.00479632f, -0.07482405f, -0.02050870f, 0.06176251f, -0.05792923f, 0.02100412f, 0.00392370f, 
    -0.08037119f, 0.05391319f, -0.02613537f, -0.04296660f, -0.08182286f, 0.04966494f, 0.03207632f, 0.05266747f, 
    0.00054857f, 0.05020284f, 0.02023526f, -0.00334821f, 0.06247080f, 0.04586990f, -0.02520521f, -0.00991697f, 
    0.04886005f, 0.01693392f, -0.04583449f, 0.04757394f, -0.02046956f, 0.02928700f, -0.01865753f, -0.06012665f, 
    -0.04769085f, 0.04905015f, -0.00126001f, -0.06102757f, 0.03949168f, -0.08213920f, -0.03438247f, 0.03880819f, 
    0.04563283f, 0.04958627f, -0.03268308f, -0.06535451f, -0.07247745f, 0.05038514f, 0.01271104f, 0.02019832f, 
    -0.05631776f, 0.02204482f, -0.05960433f, -0.06241438f, 0.03987323f, -0.00534447f, -0.00122921f, 0.01852771f, 
    -0.00431622f, -0.02731818f, 0.00326566f, -0.03131368f, -0.00026034f, 0.05087530f, -0.05058652f, 0.02228510f, 
    -0.04505914f, 0.05173027f, -0.06493577f, -0.03388825f, -0.04031041f, -0.04273345f, -0.01811190f, 0.01449088f, 
    -0.02690317f, -0.00096466f, -0.06864749f, 0.02409726f, 0.01461168f, 0.05306558f, -0.05550703f, 0.04168084f, 
    0.05716623f, -0.07540767f, 0.04179601f, -0.00455522f, 0.03015309f, 0.00322608f, -0.04574924f, -0.00579711f, 
    0.04001763f, 0.04737797f, 0.02148654f, -0.03534697f, -0.05690229f, -0.07980260f, 0.04823441f, -0.05569308f, 
    0.02598283f, -0.02137299f, 0.02251274f, -0.01907503f, 0.05770139f, -0.00125127f, 0.05548737f, 0.05013046f, 
    0.01877874f, -0.02356062f, -0.02773790f, -0.04219615f, -0.06243928f, 0.01949162f, 0.04030564f, -0.03789807f, 
    -0.07663827f, 0.05736190f, 0.03331961f, -0.03081523f, -0.02521923f, -0.01695754f, -0.05008732f, -0.00813091f, 
    0.05704778f, -0.07255781f, -0.05293750f, 0.04536288f, -0.02763395f, 0.00770506f, -0.04736621f, -0.06165235f, 
    -0.00821373f, -0.02074787f, -0.03595610f, -0.04692508f, 0.02671513f, 0.02948735f, 0.01146953f, -0.05762974f, 
    0.01092113f, -0.00210691f, -0.06023699f, 0.01837257f, -0.02496711f, 0.04680072f, -0.00728226f, -0.03904501f, 
    -0.37378860f, -0.29058918f, -0.08758763f, -0.13102603f, -0.13803953f, 0.06616915f, 0.04560717f, -0.14360961f, 
    0.04382623f, 0.21261807f, 0.01217320f, -0.05105462f, 0.08516091f, 0.26301843f, -0.25850886f, -0.12329977f, 
    -0.23478636f, -0.16021663f, 0.08092092f, 0.02597602f, 0.05489134f, 0.20751098f, -0.06714751f, 0.11325353f, 
    0.45014110f, 0.18921678f, 0.08507033f, 0.11304644f, 0.23367637f, 0.33462316f, 0.03219371f, 0.03315433f, 
    -0.09560490f, 0.26039526f, -0.02646894f, -0.08428091f, -0.14398201f, 0.19185138f, -0.16333263f, -0.32912058f, 
    0.09622338f, 0.20991875f, 0.17669159f, -0.09158024f, -0.10858379f, 0.27628604f, -0.05832745f, -0.10703590f, 
    0.32186818f, 0.28050590f, -0.06628328f, 0.30488452f, -0.10864426f, -0.11430006f, 0.17865860f, 0.01003461f, 
    -0.10314500f, -0.13826163f, -0.12897100f, -0.12608376f, 0.00803215f, -0.44486356f, -0.14849059f, -0.01829283f, 
    -0.08748531f, -0.05132549f, 0.17344595f, -0.03927974f, -0.06139293f, 0.11983470f, -0.07539210f, 0.07969558f, 
    0.03853378f, 0.31514612f, -0.42785576f, -0.11001835f, 0.09636364f, -0.01542409f, 0.06569961f, -0.02067116f, 
    0.21869311f, -0.09938423f, -0.04413975f, 0.05891171f, -0.25927049f, -0.27273318f, -0.27018538f, -0.28201190f, 
    -0.01052847f, -0.30175540f, -0.02514630f, -0.18842199f, -0.25346240f, 0.23515812f, -0.13970833f, 0.10271751f, 
    -0.28629348f, -0.06807178f, -0.02895409f, -0.15137967f, -0.14229240f, -0.02161204f, 0.07303903f, 0.08293466f, 
    -0.32986027f, -0.02627846f, 0.18450862f, 0.11612230f, -1.03303123f, -0.80059487f, -0.37553915f, -0.28736991f, 
    0.34333760f, -0.01780339f, -0.26323438f, -0.10841820f, -0.06179345f, 0.22756891f, 0.02462075f, -0.03259126f, 
    0.27294081f, 0.38834554f, 0.14522919f, 0.12781212f, 0.15282138f, 0.33497080f, -0.00274996f, 0.04809023f, 
    -0.11166581f, 0.07371125f, 0.00233706f, 0.04154684f, 0.35370368f, 0.08874923f, 0.07567523f, 0.19202545f, 
    0.12033747f, 0.17977078f, -0.09121395f, 0.14462328f, -0.08877259f, 0.11454920f, -0.03281643f, 0.10244104f, 
    0.03696091f, 0.22228161f, -0.24277271f, -0.06339144f, -0.24185127f, 0.08180821f, -0.06965990f, 0.00159357f, 
    -0.10185885f, 0.06262855f, -0.00929498f, 0.16298798f, 0.02982727f, 0.18549743f, -0.13915007f, 0.16044252f, 
    -0.11148246f, -0.06258366f, 0.17592664f, 0.06041611f, 0.15931068f, -0.04732630f, -0.03571984f, 0.01004727f, 
    -0.64345771f, -0.01179100f, 0.24309011f, -0.49157971f, 0.32401350f, 0.07427563f, -0.15591647f, -0.01650649f, 
    -0.02626473f, -0.03414338f, 0.03539465f, -0.02025712f, -0.10738519f, -0.16903375f, -0.28027052f, -0.07195628f, 
    -0.10285059f, -0.01320963f, 0.32836404f, -0.08865729f, -0.18013000f, 0.10622823f, -0.01002277f, -0.04759975f, 
    -0.22277582f, -0.08171604f, -0.22785695f, 0.17819752f, -0.05550386f, -0.03921091f, -0.05891917f, 0.07809186f, 
    0.13293625f, -0.08350019f, -0.02822192f, 0.27770489f, 0.09761458f, 0.08545605f, 0.27660558f, -0.14076997f, 
    0.06315684f, 0.01253153f, -0.02073241f, 0.11832604f, 0.10520031f, -0.07553650f, 0.10634052f, -0.10336317f, 
    0.09379247f, 0.42954171f, 0.17937633f, 0.01853107f, -0.11997430f, 0.01251852f, 0.11256622f, -0.05905190f, 
    -0.04526090f, -0.11898705f, -0.06155440f, -0.07460334f, -0.08362024f, -0.02898758f, -0.14324029f, 0.12377544f, 
    -0.08144723f, 0.12399203f, -0.02624223f, 0.02178992f, -0.21222700f, -0.09528026f, 0.06589621f, -0.05127173f, 
    -0.04945137f, -0.03044879f, 0.31865281f, 0.08087559f, -0.14044833f, 0.07318939f, 0.03549510f, 0.13526809f, 
    -0.02665075f, -0.01377932f, 0.06754338f, -0.01936774f, -0.22826511f, -0.19970652f, 0.05009123f, 0.38732329f, 
    -0.09547605f, -0.02848362f, -0.04176993f, 0.12686813f, 0.25267076f, -0.08131674f, 0.15680596f, 0.11460173f, 
    0.17011869f, -0.23698686f, -0.12625271f, 0.30527487f, 0.18435353f, 0.13833544f, 0.32071853f, 0.10385176f, 
    -0.04268248f, -0.10811710f, -0.05227405f, -0.12220365f, 0.01638731f, 0.05916131f, -0.15665027f, -0.07308083f, 
    -0.09047672f, 0.04787523f, -0.16356462f, 0.13359243f, 0.02166734f, 0.05419754f, -0.07207672f, -0.00960096f, 
    -0.09583315f, -0.05007494f, 0.01237212f, -0.17589216f, 0.10407647f, 0.21104325f, 0.10212395f, 0.11833157f, 
    -0.04433117f, -0.04746047f, -0.02149341f, -0.06316265f, 0.09186509f, -0.18328780f, 0.10098148f, 0.09472302f, 
    -0.02274825f, 0.15591750f, -0.03745825f, -0.04729694f, 0.01478088f, -0.03667212f, -0.09411405f, -0.11019567f, 
    -0.16297856f, 0.33738667f, 0.13401140f, 0.02104958f, 0.02228836f, 0.01892791f, 0.03426797f, 0.02381557f, 
    0.09494097f, 0.04202360f, 0.10507478f, -0.01445693f, 0.03672358f, 0.17534004f, 0.15142240f, -0.14075948f, 
    0.04298238f, -0.04963445f, 0.06627583f, 0.06899323f, 0.05891798f, 0.08715833f, 0.01631457f, -0.07368226f, 
    0.30291674f, 0.08176345f, 0.13098121f, 0.01123192f, 0.11254621f, 0.08594154f, 0.00718863f, 0.09940008f, 
    0.12364905f, -0.11051398f, 0.04422995f, -0.10656820f, -0.21141298f, 0.22044963f, -0.09961641f, 0.04806813f, 
    -0.03966584f, -0.06391242f, -0.04370225f, -0.03920933f, -0.05127753f, -0.00087633f, 0.03899911f, 0.06394035f, 
    -0.31353599f, 0.04951701f, 0.05096984f, 0.33819741f, 0.07021185f, -0.00496390f, 0.05772404f, 0.07829373f, 
    -0.04238971f, 0.04311086f, 0.18560523f, 0.08359728f, -0.02283956f, -0.24393317f, 0.03140727f, -0.01900732f, 
    0.01080762f, 0.03150533f, -0.07698866f, 0.00196931f, 0.02007750f, 0.01158698f, -0.07937550f, -0.04440103f, 
    -0.07734788f, 0.31866083f, -0.07711505f, 0.00375531f, 0.01746623f, 0.01720355f, -0.03852700f, -0.02477524f, 
    0.03801233f, 0.00454778f, -0.04780206f, 0.13965686f, 0.17106518f, 0.50688046f, 0.46046206f, 0.20155574f, 
    0.11335066f, 0.07064354f, 0.00057866f, 0.10129347f, -0.00738220f, -0.17003645f, 0.12008992f, -0.04740395f, 
    0.05072959f, -0.22266628f, -0.37283030f, -0.02604894f, -0.07826884f, 0.08060347f, 0.09762589f, 0.07715929f, 
    0.08743744f, -0.22111812f, -0.23489304f, -0.16194281f, 0.18841207f, 0.17071897f, -0.00475431f, -0.06457485f, 
    -0.11866968f, 0.08428761f, 0.10151500f, -0.08909771f, -0.11483353f, -0.05212472f, 0.15470921f, -0.14974502f, 
    0.46988317f, 0.34701747f, 0.42090759f, 0.01380857f, 0.07055055f, 0.20903103f, -0.05827149f, 0.11468541f, 
    -0.04168759f, -0.02549547f, 0.00598987f, 0.06604395f, 0.24587853f, -0.06445162f, -0.34768000f, -0.36492142f, 
    -0.13186923f, 0.08091148f, -0.00809375f, 0.07929122f, 0.09959909f, -0.09734661f, -0.07085677f, -0.09316428f, 
    0.43351176f, 0.16998924f, -0.17455268f, 0.07210822f, -0.03354936f, -0.09864200f, 0.03424225f, 0.04781738f, 
    -0.01415848f, -0.01921583f, -0.07647526f, -0.13779628f, 0.09994753f, 0.10325441f, -0.00807657f, 0.08820548f, 
    -0.03270743f, -0.12259754f, -0.05181562f, 0.11953442f, 0.09168728f, 0.05531126f, 0.04967260f, -0.08814829f, 
    -0.04052709f, 0.24971338f, 0.11720105f, 0.00803049f, 0.11937898f, 0.24682824f, -0.10277892f, -0.01820789f, 
    -0.06727103f, 0.00701689f, 0.17488240f, 0.13354057f, 0.17600414f, 0.24453403f, 0.32347259f, 0.19015685f, 
    -0.00995215f, -0.05225365f, 0.01491832f, -0.03599425f, 0.04089657f, 0.04638477f, 0.02522026f, 0.00068006f, 
    0.03277373f, 0.07046841f, 0.01403118f, 0.00375530f, -0.04261108f, -0.01224728f, -0.10281967f, 0.03146341f, 
    -0.01926852f, -0.05005249f, -0.05417260f, 0.01556919f, 0.23539130f, 0.03407287f, -0.04178897f, 0.03292343f, 
    0.30501440f, -0.02456097f, 0.03418791f, 0.10934847f, -0.15380177f, -0.07904172f, -0.02623703f, -0.10416000f, 
    0.28200620f, 0.21995054f, -0.09603036f, 0.18601054f, 0.02589017f, -0.17353328f, 0.22725175f, -0.00772489f, 
    0.04815267f, -0.01436606f, 0.12150231f, -0.07741037f, -0.07806909f, 0.40404800f, 0.00692882f, 0.09403685f, 
    -0.06397228f, 0.03686758f, 0.11448992f, 0.04985993f, -0.15982682f, 0.10524147f, 0.11406001f, 0.03638585f, 
    -0.18519317f, 0.20361863f, 0.08792632f, -0.20184007f, 0.05129597f, -0.09435764f, 0.11375151f, -0.06481257f, 
    -0.01151945f, 0.04246925f, 0.01059733f, 0.12558362f, 0.11103211f, 0.05195996f, 0.19643605f, 0.49120080f, 
    -0.08712963f, -0.08794395f, -0.12256154f, -0.00696223f, 0.01858917f, -0.04664008f, 0.06140264f, 0.00735525f, 
    -0.02347574f, 0.03380373f, 0.06542534f, -0.06175307f, -0.02035144f, -0.00417928f, -0.03967254f, 0.04056404f, 
    -0.01917773f, -0.01330117f, 0.05782907f, 0.03718609f, -0.05333420f, -0.02117300f, -0.01530154f, 0.05292768f, 
    0.01910876f, -0.06823559f, -0.02450771f, -0.04470716f, 0.04316562f, -0.03188661f, -0.05081626f, -0.01379915f, 
    -0.05597822f, 0.04251445f, 0.00175216f, -0.06583414f, -0.06807898f, 0.05813263f, 0.01592456f, -0.03355499f, 
    -0.01566156f, 0.06645589f, 0.01833367f, -0.00599036f, 0.03121622f, -0.03973902f, -0.02523990f, -0.02507289f, 
    0.05983267f, -0.06150420f, -0.00851816f, -0.04971325f, -0.05012593f, -0.02771991f, 0.04525129f, -0.04537761f, 
    0.01256629f, -0.02387904f, 0.06989909f, -0.04783248f, 0.04735355f, -0.06106838f, -0.00881706f, -0.04873841f, 
    -0.01110793f, 0.04094001f, 0.00287123f, -0.06986922f, -0.03118764f, 0.06973320f, -0.05101555f, 0.01367015f, 
    -0.05942309f, 0.04719884f, -0.00413301f, 0.01786014f, 0.06037485f, 0.02198686f, -0.05881269f, -0.06548446f, 
    0.06138339f, 0.01791658f, -0.01474661f, -0.00948014f, -0.03488084f, -0.06798361f, -0.01797777f, 0.05431118f, 
    0.03318881f, -0.01452981f, -0.00287895f, 0.05189090f, -0.01853905f, -0.02219742f, -0.06588624f, 0.01716710f, 
    -0.02127316f, 0.00142999f, -0.02808172f, -0.02125012f, 0.06244048f, -0.06568955f, 0.05902504f, -0.05510424f, 
    -0.03319393f, 0.01408804f, 0.04089079f, -0.00587446f, -0.04568676f, -0.02749370f, 0.04294201f, -0.01238737f, 
    0.00774822f, -0.06816909f, 0.00124128f, 0.02423062f, -0.06826171f, -0.00116354f, 0.00842509f, -0.05143233f, 
    0.02612696f, 0.04084543f, -0.04501849f, 0.06112902f, -0.00670434f, 0.00500790f, -0.05459236f, -0.00138343f, 
    0.05206774f, -0.07077937f, 0.00253991f, 0.03244492f, -0.03888400f, 0.04027230f, -0.04013060f, -0.02756837f, 
    -0.03485970f, 0.00750144f, -0.00955365f, -0.04792549f, -0.01327740f, 0.03459850f, 0.02179303f, 0.05511506f, 
    -0.03036772f, 0.01469102f, 0.00437692f, -0.01751272f, 0.06814128f, 0.04735932f, -0.03044568f, -0.03379190f, 
    0.00525137f, -0.02869055f, 0.01215331f, -0.04799509f, 0.05120154f, 0.00736925f, -0.01457254f, 0.05033635f, 
    -0.05658610f, -0.00632352f, -0.06185389f, -0.06281710f, -0.01372401f, -0.01583447f, -0.06350267f, -0.06149957f, 
    -0.04010703f, -0.02598649f, -0.06995844f, 0.03093759f, 0.00531982f, 0.04383437f, -0.05657075f, 0.04357153f, 
    0.06541377f, 0.01301319f, 0.01216730f, 0.03482069f, 0.05678914f, -0.05585821f, 0.06799112f, -0.00576560f, 
    -0.01674715f, -0.04800529f, 0.00977349f, 0.01134886f, -0.00730190f, 0.02945656f, -0.02418610f, -0.02042999f, 
    -0.05591407f, -0.04893848f, 0.04685378f, -0.00131636f, -0.02001173f, 0.03947258f, -0.04069077f, -0.01407521f, 
    -0.00875690f, -0.03936275f, 0.00203592f, -0.07161376f, -0.03471269f, 0.04533046f, -0.01470060f, -0.06821494f, 
    0.05496145f, -0.06120510f, 0.02365349f, -0.03854325f, -0.03262202f, -0.05533659f, 0.01255473f, -0.07794190f, 
    0.05508300f, 0.05508264f, 0.00375741f, -0.06754023f, -0.08111271f, 0.04528416f, -0.05297440f, 0.03007106f, 
    0.01062834f, 0.04072761f, -0.07574303f, -0.07708324f, 0.04467381f, 0.03965694f, -0.06033196f, -0.00055998f, 
    0.00297420f, 0.04532713f, 0.05195160f, 0.01553701f, 0.03281441f, -0.05722402f, 0.03161323f, -0.05939457f, 
    0.00561054f, -0.05935502f, -0.03645590f, -0.03654537f, -0.02463659f, -0.01341290f, -0.05408510f, -0.07462650f, 
    0.03343053f, -0.04033229f, 0.05642992f, -0.02185369f, -0.00489415f, -0.03196531f, -0.01551353f, -0.08217452f, 
    0.00160039f, 0.00283483f, -0.04422465f, -0.02588548f, -0.00735565f, 0.05586173f, -0.02335898f, 0.04159004f, 
    0.05281692f, -0.07066137f, 0.05928518f, -0.06181235f, -0.01589065f, 0.00495713f, -0.01825384f, 0.04647342f, 
    -0.05784575f, -0.02952036f, 0.00760714f, 0.05815057f, 0.00342438f, 0.00036302f, -0.05876435f, 0.04763554f, 
    0.02812685f, -0.07063061f, -0.05174899f, -0.04314023f, -0.00205092f, 0.02129219f, 0.04824106f, -0.01239258f, 
    -0.06945621f, -0.00270796f, -0.05940954f, -0.03735527f, -0.05947690f, -0.08238819f, 0.00694132f, -0.05507571f, 
    0.02741777f, 0.02909553f, 0.04202416f, -0.03120212f, 0.06118535f, -0.08036242f, 0.06376179f, -0.00761819f, 
    0.04033655f, -0.05720804f, 0.05213448f, 0.05359525f, -0.04530152f, -0.05439939f, 0.05349912f, -0.02316202f, 
    0.05179307f, -0.00284525f, -0.01833947f, 0.05040993f, -0.06067166f, -0.04030469f, 0.05349687f, -0.04505265f, 
    0.06930461f, 0.04028723f, 0.02162849f, 0.05116060f, 0.00477728f, -0.07138862f, -0.02980182f, -0.04010010f, 
    -0.00820445f, 0.04648070f, 0.00544944f, -0.00174860f, -0.02883287f, 0.02742445f, -0.03769819f, -0.01928300f, 
    -0.05452881f, 0.00710980f, 0.02686162f, -0.03701735f, -0.03417496f, -0.05754327f, 0.02424153f, -0.00163798f, 
    0.03178290f, -0.02053008f, -0.05612436f, 0.01597494f, -0.06534298f, -0.03972708f, -0.08436675f, -0.06215845f, 
    0.06439393f, -0.01598711f, -0.07074489f, 0.04088360f, -0.00709035f, 0.05246121f, 0.06080197f, 0.03356749f, 
    -0.04587737f, -0.05199414f, 0.01756931f, -0.03265877f, 0.03662870f, -0.06560901f, 0.00172339f, -0.06691325f, 
    -0.03898726f, -0.05015401f, 0.02143441f, 0.03353155f, 0.06089575f, -0.07000679f, 0.06059215f, -0.06113929f, 
    0.02284425f, 0.02678812f, -0.01442216f, -0.02204210f, -0.06643641f, 0.02856342f, -0.03536559f, -0.00478147f, 
    -0.01042376f, 0.04878273f, -0.07341290f, -0.04594678f, 0.05021797f, -0.02064095f, 0.01033133f, 0.03230636f, 
    0.02839977f, -0.08210900f, 0.05438810f, -0.21828979f, 0.04318136f, 0.03013546f, -0.00222639f, 0.08679261f, 
    0.07022077f, -0.11015649f, -0.07514431f, 0.01410534f, -0.16986786f, -0.07511428f, 0.32363397f, 0.31817979f, 
    0.10921888f, 0.08731502f, 0.05817910f, -0.02895123f, 0.09606801f, -0.12900193f, 0.01425889f, 0.00488676f, 
    -0.40035760f, 0.26243484f, 0.06342366f, 0.25501078f, -0.18665305f, -0.06863765f, 0.12046184f, 0.15074794f, 
    0.06818043f, 0.06445353f, 0.01663553f, 0.08689474f, 0.07701148f, -0.17512758f, -0.06615558f, -0.03209278f, 
    -0.06761044f, -0.12526113f, 0.01234404f, 0.02923537f, -0.00748033f, 0.00449520f, 0.19465750f, 0.10036220f, 
    -0.36164573f, -0.39890707f, 0.08973765f, 0.14163965f, 0.09100959f, 0.14362088f, -0.07484577f, 0.16104354f, 
    -0.04440195f, 0.01302557f, 0.05920542f, 0.07458574f, 0.10884269f, 0.09227687f, 0.25651431f, -0.07766016f, 
    0.03120860f, -0.09209846f, -0.04789130f, 0.03726671f, 0.35825962f, -0.01395836f, 0.06341860f, -0.03581768f, 
    -0.03768735f, -0.10305670f, 0.34646681f, 0.14292738f, 0.09002628f, 0.04426736f, 0.25308123f, 0.09349986f, 
    0.01460530f, 0.15749089f, -0.04395577f, 0.07409040f, -0.07694185f, 0.05524408f, 0.03818690f, -0.15529731f, 
    -0.08984369f, -0.02445346f, -0.01772768f, -0.06676597f, -0.01979212f, -0.11143406f, 0.02413145f, 0.01676104f, 
    -0.05652887f, -0.01435778f, 0.05502059f, -0.05317812f, 0.11821716f, -0.02891864f, 0.00043384f, 0.10181611f, 
    0.04828457f, 0.00256872f, 0.00878429f, 0.10698991f, 0.04384873f, -0.02099863f, -0.01853631f, -0.22665158f, 
    -0.14923319f, 0.03208933f, 0.09131823f, 0.01024302f, -0.08609726f, -0.07545574f, -0.05933332f, -0.12661843f, 
    -0.08445980f, -0.07715770f, -0.05590452f, 0.24472667f, 0.03650777f, -0.16615464f, 0.12108596f, 0.15686764f, 
    0.02957724f, -0.06838362f, 0.07709207f, 0.04974319f, -0.36273235f, -0.11667511f, 0.04936247f, 0.02570515f, 
    -0.16594438f, -0.00052873f, 0.01538154f, -0.22908798f, -0.02474605f, -0.02022013f, -0.06456643f, -0.14367023f, 
    -0.01221238f, -0.11072651f, 0.36597675f, 0.27197775f, 0.08720504f, 0.07105455f, 0.19806223f, -0.04621674f, 
    0.02265707f, -0.14889081f, 0.23182712f, 0.07096837f, -0.15223762f, -0.11312954f, -0.16716622f, -0.16387907f, 
    0.09165674f, 0.15312140f, -0.00668097f, -0.04584191f, -0.01091785f, 0.03269827f, 0.18069912f, 0.08230156f, 
    0.76842982f, -0.25855684f, -0.15146935f, -0.01104112f, -0.05258460f, -0.04531831f, 0.05299244f, -0.07125406f, 
    0.01824947f, 0.00186434f, 0.07225642f, 0.01343645f, -0.18814646f, 0.12284935f, 0.06252930f, -0.27845395f, 
    0.06615329f, 0.15603948f, -0.03292281f, -0.00764125f, -0.03395571f, 0.01077038f, 0.12935384f, 0.07068711f, 
    0.04745083f, 0.21059163f, -0.03078162f, 0.02713327f, 0.21917798f, -0.18069415f, 0.11418939f, 0.10384582f, 
    0.10282569f, 0.11455000f, 0.05217193f, 0.13266665f, -0.05670924f, -0.06813537f, -0.09052220f, -0.04820880f, 
    -0.06611359f, 0.03078226f, 0.08739457f, -0.09522448f, 0.09274991f, 0.06520855f, -0.19441102f, 0.03079453f, 
    -0.03951956f, 0.70158005f, 0.13486253f, 0.37862065f, 0.20437919f, 0.20014139f, 0.01675725f, 0.01988126f, 
    -0.03112473f, 0.15698563f, -0.08683030f, 0.02221935f, -0.04259795f, 0.06961509f, -0.01474057f, 0.05961468f, 
    0.07505640f, 0.06811024f, 0.10496993f, 0.07924815f, -0.17453845f, -0.06364104f, -0.09137262f, -0.11412493f, 
    0.26616886f, 0.07928564f, -0.31216878f, -0.04649449f, -0.31749856f, -0.07475518f, -0.04534992f, -0.14110197f, 
    -0.20286806f, -0.11211265f, -0.18831423f, -0.22200380f, 0.11140416f, -0.10691150f, 0.05214386f, 0.03617877f, 
    -0.05119270f, -0.01703381f, 0.35721210f, -0.09350321f, 0.05464506f, 0.14870459f, -0.08602984f, 0.27981371f, 
    -0.29435050f, 0.47746944f, -0.24660443f, 0.46478277f, 0.20921293f, -0.02325609f, 0.09025462f, -0.01092456f, 
    -0.01786146f, 0.03604897f, -0.00591430f, -0.06672928f, -0.01682095f, -0.05227949f, 0.27067047f, 0.17979723f, 
    -0.12126061f, -0.06854967f, -0.06038622f, -0.15362369f, 0.12707004f, 0.03971059f, 0.05719774f, 0.12372416f, 
    0.07735939f, -0.00589987f, -0.05953678f, 0.06262068f, 0.14622369f, -0.02107136f, 0.03268949f, 0.01240824f, 
    -0.36952811f, -0.03816798f, -0.00062056f, -0.14605170f, 0.29826283f, 0.12263366f, 0.27228636f, 0.13434766f, 
    -0.08136384f, -0.06398656f, -0.15986882f, -0.06268721f, -0.18483785f, 0.02077936f, -0.12127335f, 0.07124691f, 
    0.30958351f, -0.03076702f, -0.01800603f, 0.23160642f, 0.17126578f, 0.06154737f, -0.08904795f, -0.04714729f, 
    -0.07326466f, 0.01812637f, 0.08192803f, 0.10363826f, 0.04623521f, -0.19944416f, -0.24512079f, 0.15743876f, 
    0.10736146f, 0.33788142f, 0.02477222f, -0.01234877f, 0.11693496f, 0.03878924f, -0.07441606f, 0.13733226f, 
    -0.08450776f, -0.08531445f, 0.00159622f, -0.14604454f, -0.00282753f, 0.03083675f, -0.06179196f, 0.06618641f, 
    0.05234222f, 0.19805184f, 0.01370437f, 0.08358869f, -0.28022170f, 0.24356560f, -0.30190831f, 0.44938818f, 
    -0.03274261f, 0.01871199f, 0.04537123f, 0.00110643f, 0.03936714f, -0.08091313f, 0.00031715f, 0.03021407f, 
    0.08836405f, 0.22947593f, -0.16441904f, -0.16974902f, 0.07085971f, 0.06646711f, 0.11379233f, 0.24524683f, 
    -0.04875837f, 0.01881111f, 0.07525015f, 0.14621229f, -0.23438348f, 0.07483899f, 0.28478137f, -0.11324044f, 
    -0.14657642f, -0.06595028f, -0.04851824f, -0.07884276f, -0.01839739f, 0.07599348f, -0.20918271f, -0.11214122f, 
    0.08688591f, -0.10763486f, 0.21512683f, -0.07061951f, -0.44402212f, -0.13015617f, -0.00567802f, -0.52680856f, 
    0.18018964f, 0.05577313f, 0.00004973f, 0.04027634f, 0.12243469f, 0.20782718f, 0.17451961f, 0.40091449f, 
    -0.06823798f, 0.10475712f, 0.18004467f, 0.39611337f, -0.08530897f, 0.06545176f, -0.25775239f, -0.26614496f, 
    0.44095778f, -0.13656031f, 0.28334764f, 0.42771477f, 0.25679725f, -0.00550692f, -0.07814819f, -0.09861272f, 
    -0.00031271f, 0.15456668f, 0.04190167f, 0.07189230f, 0.05932744f, 0.21119507f, 0.11829364f, -0.31097215f, 
    0.30624717f, -0.18450570f, -0.08585251f, -0.50669700f, -0.17472298f, -0.49639696f, -0.31480268f, -0.45148239f, 
    0.29352444f, 0.20094554f, 0.13216190f, -0.14815435f, 0.08644014f, 0.00322224f, -0.13647474f, 0.13714053f, 
    -0.22603089f, 0.01191804f, 0.08933594f, -0.19214194f, 0.17389965f, 0.36066452f, 0.09795905f, 0.04250391f, 
    0.14405996f, 0.06424985f, -0.50632226f, -0.17904690f, 0.01594821f, -0.05591694f, -0.02908713f, -0.20773675f, 
    -0.04136987f, -0.34342992f, -0.00392838f, -0.23883365f, -0.02834636f, 0.06873791f, -0.00869987f, 0.11979190f, 
    -0.06593411f, -0.02298278f, -0.03057336f, -0.17687932f, -0.00649603f, 0.17730299f, 0.09249013f, 0.27520704f, 
    0.09589952f, -0.02219806f, 0.39575747f, 0.25938523f, -0.01493141f, 0.01863702f, -0.07014812f, 0.15396227f, 
    -0.21254328f, -0.22329989f, -0.13318828f, 0.21681198f, -0.07228066f, 0.22503930f, 0.03487361f, -0.11156715f, 
    -0.34063071f, -0.30202857f, -0.44214597f, -0.22006743f, -0.00282660f, 0.06370077f, 0.02280620f, 0.25568759f, 
    0.04820173f, 0.24645182f, 0.12195597f, -0.05126335f, 0.12404153f, -0.14603031f, 0.20165734f, -0.19987488f, 
    0.28008240f, -0.26038435f, -0.02107093f, 0.27529088f, 0.10838106f, 0.06834189f, -0.02254162f, 0.21640967f, 
    -0.02997772f, 0.01123217f, 0.14744590f, 0.08024923f, 0.24528450f, 0.14352894f, 0.03646098f, 0.28313866f, 
    0.22393401f, 0.20186101f, 0.28731498f, 0.25127938f, 0.23819506f, 0.29098251f, 0.06909336f, 0.12468172f, 
    -0.04909521f, 0.09005388f, 0.09580418f, 0.18372633f, 0.08685805f, 0.03728826f, 0.13052300f, 0.05697901f, 
    0.01626763f, 0.06836196f, 0.07228225f, -0.16596232f, 0.36556208f, -0.43453372f, 0.37238604f, -0.44544199f, 
    -0.10444712f, -0.07454178f, -0.23085456f, 0.13268884f, 0.10138915f, 0.08971750f, 0.12728654f, -0.10389112f, 
    0.25048721f, 0.08617745f, -0.03172157f, -0.15503713f, 0.08997729f, 0.01867994f, -0.27639538f, -0.42859751f, 
    0.03683536f, -0.21386065f, 0.18248811f, -0.16597545f, -0.18494351f, 0.11656538f, -0.22303061f, 0.26046494f, 
    0.09194028f, -0.22564375f, 0.07794836f, 0.16531841f, -0.22281419f, -0.12815046f, -0.14876139f, -0.37384093f, 
    -0.09963822f, 0.14378940f, -0.14313978f, -0.10805962f, 0.09059092f, -0.12396863f, 0.03025768f, -0.11522420f, 
    0.05447347f, 0.05018771f, 0.21218975f, 0.00835263f, -0.09354727f, -0.34410056f, 0.34401235f, 0.30349788f, 
    -0.00443048f, 0.15009081f, 0.16183245f, -0.21153842f, 0.05234848f, 0.01052297f, -0.04328153f, 0.04845162f, 
    -0.31324711f, 0.09917553f, -0.07258645f, 0.30343378f, 0.03163170f, -0.08972660f, 0.20180993f, 0.16706577f, 
    0.13405229f, 0.11541675f, 0.11656001f, 0.08851337f, 0.04009320f, -0.10765619f, -0.15109695f, -0.16416170f, 
    -0.05617244f, -0.08940057f, -0.04929499f, 0.08191786f, -0.00595924f, 0.11019452f, 0.04929668f, 0.08001990f, 
    -0.29793876f, -0.25966746f, -0.10284929f, 0.11354060f, -0.12460896f, 0.10720866f, -0.15476258f, -0.05505340f, 
    -0.02758482f, 0.08335579f, -0.04482336f, -0.00523442f, -0.31061012f, 0.24459368f, 0.12663427f, 0.00268502f, 
    0.14716288f, -0.03015707f, 0.01660635f, -0.08308637f, 0.15422407f, 0.18065974f, 0.16700500f, 0.09016793f, 
    -0.45667487f, 0.13648520f, 0.16486427f, 0.43193886f, 0.08175089f, 0.07515278f, 0.11047088f, 0.06531879f, 
    -0.03037755f, -0.03436098f, -0.04009676f, -0.01083610f, 0.12427963f, 0.07205717f, 0.24578117f, -0.07880695f, 
    -0.02048595f, 0.04737777f, -0.05015318f, -0.02051790f, -0.06417720f, -0.05255567f, -0.02853902f, -0.01681599f, 
    0.08848860f, 0.02106233f, -0.05921282f, -0.10308440f, 0.13526841f, -0.05448442f, 0.13509470f, -0.05986233f, 
    -0.00079057f, 0.13191804f, 0.07180933f, 0.06081257f, 0.30859953f, -0.00228683f, 0.19572091f, -0.22493677f, 
    -0.15390027f, 0.05170678f, -0.07920149f, 0.01060945f, -0.13022649f, -0.02389597f, -0.09966771f, -0.14747782f, 
    0.26448387f, -0.49433288f, -0.00014036f, 0.33256319f, 0.13942011f, -0.06577769f, 0.13960350f, 0.06831446f, 
    0.06155957f, 0.17154093f, 0.28075403f, 0.02007628f, -0.32097009f, -0.18554218f, -0.12296267f, 0.10100514f, 
    -0.14992799f, 0.01168810f, 0.04467581f, 0.05483885f, 0.09537386f, 0.03430382f, -0.00106877f, -0.10693680f, 
    -0.14919549f, -0.09041303f, 0.21320288f, 0.27036521f, -0.00000112f, 0.29971632f, 0.25823224f, 0.06206300f, 
    -0.04539290f, 0.09250590f, 0.23620525f, 0.01484297f, -0.15677735f, 0.07718190f, -0.16492341f, 0.11163595f, 
    0.05582643f, -0.00354821f, 0.09132380f, 0.03959353f, 0.14456072f, 0.01169488f, 0.06569041f, 0.01251385f, 
    0.60942584f, -0.00797968f, -0.33917323f, -0.01183222f, 0.02593411f, 0.01601958f, -0.09224124f, -0.04682297f, 
    -0.00607530f, 0.08979213f, 0.03251083f, -0.06381213f, -0.01885399f, 0.13166140f, 0.17402644f, -0.13413456f, 
    0.02705456f, 0.07624254f, -0.02598266f, -0.08250523f, -0.08016872f, 0.06596100f, -0.00873093f, 0.05678114f, 
    0.04570899f, -0.04013422f, -0.01337646f, -0.07288010f, -0.01249073f, -0.06938569f, -0.01753015f, 0.02767007f, 
    -0.06740711f, 0.00807049f, -0.02813080f, -0.06766333f, 0.02741130f, -0.01159996f, 0.04349748f, 0.01848696f, 
    0.02969771f, -0.00672444f, -0.06322549f, -0.08126774f, -0.01160742f, -0.04149182f, -0.03624443f, 0.02508033f, 
    -0.02647752f, -0.02357152f, -0.06120930f, 0.00077681f, -0.03685698f, -0.08409880f, -0.05976952f, -0.00013196f, 
    0.04681943f, 0.06158403f, 0.03065708f, -0.05299032f, -0.02934296f, -0.02506392f, 0.00000176f, -0.00250576f, 
    -0.04172474f, -0.00065721f, -0.04970158f, 0.04376452f, 0.03535668f, -0.02553435f, -0.07005277f, 0.00181349f, 
    -0.03185668f, 0.04363040f, -0.03919968f, 0.03394180f, -0.04937769f, 0.05949729f, 0.01396707f, -0.00545618f, 
    0.05225025f, 0.01302157f, 0.04166877f, 0.01209417f, 0.03065690f, -0.02107294f, 0.05210144f, -0.02375126f, 
    -0.05911318f, 0.00979598f, -0.02316865f, -0.03082687f, 0.00497831f, 0.01200358f, 0.01349849f, 0.01992928f, 
    -0.06346420f, -0.02674005f, 0.03992307f, -0.05652595f, 0.02360756f, -0.07284639f, 0.02891785f, -0.00792598f, 
    -0.08316507f, -0.07607020f, 0.02280299f, 0.05383572f, -0.04315427f, 0.00410593f, 0.02765943f, 0.04236763f, 
    -0.05412510f, 0.02339078f, 0.03493532f, 0.04664551f, 0.04372239f, 0.01428880f, 0.03938610f, 0.02781988f, 
    0.00315174f, -0.00217910f, -0.02346824f, 0.01893643f, -0.05761775f, 0.04704986f, -0.01209950f, -0.05041357f, 
    -0.06625684f, 0.05068244f, 0.01255687f, -0.02202070f, 0.00320220f, -0.04151159f, 0.02856568f, 0.05528650f, 
    -0.01073136f, -0.03293462f, -0.02858173f, -0.02684219f, 0.04891255f, 0.04670671f, -0.08198230f, -0.00640344f, 
    -0.06454858f, -0.06728633f, -0.06997356f, -0.07663669f, -0.04990961f, -0.02873663f, -0.02155864f, 0.05383783f, 
    -0.07475954f, -0.01361004f, -0.07560991f, -0.04726817f, 0.04829481f, 0.05873394f, -0.00365415f, -0.06181911f, 
    -0.02293201f, -0.04051611f, 0.00189583f, -0.06694037f, -0.04237872f, 0.05636919f, -0.05320187f, 0.03772665f, 
    0.00439891f, -0.05282857f, -0.04018655f, -0.03511468f, -0.01023760f, -0.07204103f, 0.00753805f, 0.00742078f, 
    -0.06411478f, -0.05644305f, -0.04771410f, -0.05376663f, 0.00859617f, -0.04170051f, -0.03298404f, -0.07077867f, 
    0.02522939f, 0.02839855f, 0.03312532f, -0.00762572f, -0.04509340f, -0.01319592f, 0.03212510f, -0.07835523f, 
    -0.02895167f, -0.00511353f, -0.04471007f, 0.04121756f, 0.02623854f, -0.03698185f, 0.01736301f, -0.00425475f, 
    0.00794408f, 0.01224324f, -0.00772124f, 0.01048222f, -0.00797272f, 0.04421025f, -0.01346469f, 0.01311971f, 
    -0.00603070f, 0.00846733f, -0.00127613f, -0.07534686f, 0.03572233f, -0.06856685f, -0.05382550f, -0.01489309f, 
    -0.17960244f, -0.01739375f, -0.15848860f, -0.03708485f, -0.01447575f, -0.21502244f, -0.13198864f, 0.10263219f, 
    -0.00303694f, -0.01333838f, -0.01639589f, 0.08031037f, 0.33161840f, 0.22447704f, 0.02732712f, -0.03683468f, 
    0.19750525f, 0.11771864f, 0.14170602f, 0.22422306f, 0.06907630f, -0.13318731f, 0.11762399f, -0.01269567f, 
    0.05830292f, -0.15575604f, -0.17578775f, -0.24916969f, -0.02035100f, 0.09228801f, -0.00505568f, 0.03990118f, 
    0.06665584f, -0.20036638f, 0.05179784f, -0.09146813f, -0.26276261f, -0.36743075f, 0.04919714f, 0.03523483f, 
    0.06652542f, 0.02653660f, -0.05987311f, -0.04635591f, 0.12358543f, -0.01556052f, -0.00100164f, 0.12195718f, 
    0.16699271f, 0.19387272f, 0.48268682f, -0.09099144f, 0.15966557f, 0.13688125f, 0.04643634f, 0.08676001f, 
    0.06795180f, -0.04717480f, -0.04180050f, 0.09560218f, -0.05950315f, -0.22725621f, -0.07413920f, 0.15351734f, 
    -0.31571874f, -0.13433656f, -0.08207057f, 0.00942629f, 0.27205718f, 0.07943337f, 0.03185777f, 0.01467129f, 
    0.51922715f, -0.30174056f, 0.28991187f, -0.06728145f, 0.14190364f, 0.13454431f, 0.12835258f, -0.00495283f, 
    0.28371128f, 0.08895852f, -0.14447208f, 0.27102751f, 0.06044542f, -0.46809632f, -0.40390983f, 0.03026961f, 
    -0.02529507f, 0.13340975f, -0.20210572f, -0.15930168f, -0.07109910f, -0.17514117f, -0.04190292f, -0.27167985f, 
    0.12088069f, -0.08454034f, -0.05970909f, 0.01381498f, -0.07084575f, 0.12576690f, 0.17226020f, 0.08982445f, 
    0.05447476f, 0.00662373f, -0.06124317f, -0.03819027f, 0.07057798f, -0.43741319f, -0.64342129f, 0.11745302f, 
    0.05986168f, 0.24379443f, 0.13800590f, -0.12250818f, 0.09571393f, -0.14394002f, -0.17335635f, -0.08230959f, 
    -0.22316736f, 0.21864733f, 0.01484124f, -0.21329407f, -0.03340453f, 0.11399475f, 0.15855776f, 0.14655170f, 
    -0.05053629f, 0.02049985f, 0.03479032f, 0.01726412f, 0.26637599f, 0.30657077f, 0.16979648f, -0.02462837f, 
    0.21297030f, 0.15425161f, 0.10790269f, 0.22780690f, -0.07151183f, -0.15443304f, 0.14375705f, -0.02959723f, 
    0.09516386f, 0.15675931f, 0.29717830f, 0.10115536f, 0.15281594f, -0.01069197f, 0.17429626f, -0.06419548f, 
    0.13061227f, -0.02556559f, -0.07406370f, 0.03356871f, -0.11045294f, -0.12330014f, -0.09017148f, -0.42641532f, 
    0.19712782f, 0.09643403f, -0.12736224f, -0.00027535f, -0.08421292f, 0.01309628f, 0.29721659f, 0.07948366f, 
    -0.57138413f, -0.08160537f, 0.18284427f, 0.22147794f, -0.25662658f, 0.13067555f, 0.00413633f, 0.16678469f, 
    -0.03155035f, 0.03415970f, 0.04583701f, -0.14093922f, -0.13900779f, -0.04721219f, -0.38829336f, -0.01911186f, 
    0.07320046f, -0.14448375f, -0.21157803f, -0.01664441f, 0.01253054f, -0.05815812f, -0.03495770f, 0.11382550f, 
    -0.14169908f, -0.15776204f, -0.10589572f, -0.07231404f, -0.05062287f, 0.03763496f, 0.01011660f, 0.07923604f, 
    -0.06052568f, 0.13869837f, 0.08443715f, -0.02871687f, 0.27723584f, 0.06178822f, -0.31308979f, 0.11128550f, 
    0.11976013f, 0.13902107f, 0.05703327f, 0.09501015f, 0.06354371f, 0.06535449f, 0.00040653f, 0.13267587f, 
    0.12927198f, -0.17200775f, 0.10848230f, -0.01975252f, 0.07963534f, 0.16110168f, -0.01292076f, -0.11707908f, 
    0.19749106f, -0.02114811f, 0.10337325f, -0.03308051f, -0.18117130f, -0.12884316f, 0.09616189f, 0.08005808f, 
    0.00460383f, -0.09862466f, -0.12903678f, -0.00443837f, 0.22528812f, 0.14633371f, -0.08346382f, 0.12945461f, 
    0.12475841f, 0.22711013f, -0.11249173f, -0.13273278f, 0.32769990f, 0.04547508f, 0.11934470f, 0.12913352f, 
    0.05319704f, 0.04709511f, 0.07037903f, 0.09162553f, -0.23350967f, 0.18223058f, -0.35890117f, -0.14563382f, 
    0.15515964f, -0.04604730f, 0.03842151f, -0.03629865f, -0.11010038f, 0.03215178f, 0.09327971f, 0.06351739f, 
    0.12340187f, 0.07977232f, 0.01702984f, -0.28969014f, -0.10501201f, -0.14330944f, -0.03590431f, 0.07203604f, 
    0.11749624f, 0.08875836f, -0.11763559f, 0.16217056f, -0.27968854f, -0.28187463f, 0.05446808f, 0.04096282f, 
    -0.03498903f, -0.05059860f, -0.07473598f, -0.10815882f, 0.04976714f, 0.01724132f, 0.02558443f, -0.09129730f, 
    -0.00641609f, -0.14682822f, -0.07955621f, -0.04512308f, -0.07349277f, -0.04718074f, -0.09088019f, -0.01015200f, 
    0.03472345f, 0.06972067f, 0.01674705f, 0.14761852f, -0.47683024f, -0.36294669f, -0.14475024f, -0.03003100f, 
    0.14313766f, -0.01973332f, -0.04302062f, -0.05792946f, 0.00383655f, 0.01098116f, 0.04096774f, 0.06867581f, 
    0.16950418f, 0.04886735f, 0.07335792f, -0.09204150f, -0.07400370f, -0.03969351f, 0.01881449f, 0.01358624f, 
    -0.01109686f, 0.05238501f, 0.00663634f, 0.09832694f, 0.20361245f, 0.07038850f, -0.02249187f, 0.08961991f, 
    0.23447861f, 0.14505346f, -0.03108863f, 0.07472797f, -0.09326585f, -0.05868932f, 0.00955856f, 0.04607214f, 
    0.10192880f, 0.25558978f, -0.29366353f, -0.18427549f, 0.04659502f, -0.05970936f, 0.14630075f, 0.05181769f, 
    0.05465741f, -0.09622412f, -0.00451999f, -0.05292332f, 0.05889481f, -0.04990120f, 0.06764933f, -0.04498615f, 
    -0.14736554f, 0.01635041f, -0.07923049f, 0.12852021f, -0.00938331f, -0.00271100f, -0.08949296f, -0.08209633f, 
    -0.37313893f, 0.05025328f, 0.17872363f, 0.00344097f, -0.16190919f, -0.14547710f, -0.01282160f, 0.23086028f, 
    0.27379265f, 0.23228042f, -0.08174324f, -0.13091275f, 0.16932756f, -0.05326543f, 0.05070900f, 0.02721427f, 
    0.09826081f, -0.03934896f, -0.03889383f, 0.02138571f, 0.06832422f, 0.02140289f, 0.03746260f, 0.09461647f, 
    -0.07552883f, 0.06197483f, -0.06764960f, -0.02835827f, 0.04518797f, -0.05755496f, -0.00353492f, -0.06479363f, 
    -0.00291457f, -0.05095334f, 0.04025312f, -0.04452098f, -0.05948425f, 0.00447200f, -0.01588821f, -0.00356080f, 
    -0.06455427f, 0.00900217f, 0.04252122f, -0.05619772f, -0.04111191f, -0.04663864f, 0.00390427f, -0.02045950f, 
    0.00189723f, -0.07549886f, 0.00000537f, -0.07398196f, -0.07502984f, 0.03390724f, 0.05453638f, -0.00787657f, 
    -0.04002520f, -0.07030103f, 0.02420740f, -0.03095825f, -0.02715353f, -0.01808384f, -0.05157482f, 0.04083746f, 
    -0.06147377f, -0.03370379f, -0.01434889f, -0.01253057f, -0.00827627f, -0.04574719f, -0.06159455f, 0.00677927f, 
    0.03102913f, 0.05346378f, 0.02688689f, 0.01237169f, 0.01869800f, 0.04320683f, -0.00279902f, 0.02729405f, 
    -0.04583000f, -0.06137503f, 0.05893315f, -0.00551696f, -0.02976974f, 0.06349196f, 0.06169097f, 0.04311772f, 
    -0.01900143f, 0.02167086f, 0.03941055f, -0.01496627f, -0.00060682f, 0.02177545f, 0.00249854f, -0.02197623f, 
    -0.05909483f, 0.04132922f, -0.01955400f, -0.03048566f, -0.05834410f, -0.01533999f, 0.03356074f, 0.01139952f, 
    0.03172114f, 0.05716022f, -0.05194946f, -0.01848077f, -0.03509212f, 0.04460613f, 0.02699274f, 0.05200270f, 
    -0.05313536f, -0.01390007f, 0.01317819f, -0.07097594f, -0.07830413f, -0.07205534f, 0.04637370f, -0.07761992f, 
    0.01342708f, 0.05675855f, -0.04499974f, 0.05416598f, -0.05596485f, -0.05640501f, 0.06408166f, -0.03333942f, 
    -0.01742591f, -0.06036307f, 0.06304495f, -0.01931229f, -0.03575549f, 0.04154209f, 0.03134963f, -0.01093929f, 
    -0.06287190f, 0.03516023f, -0.02312016f, -0.04693161f, 0.00406689f, -0.00852179f, -0.05555236f, -0.05030449f, 
    0.03985735f, -0.00291516f, -0.01020386f, -0.01133963f, 0.02520314f, 0.04789571f, 0.04744873f, -0.00557345f, 
    0.03161112f, -0.01729602f, 0.02617870f, -0.05315739f, 0.04099869f, -0.07850635f, 0.04941213f, 0.03949630f, 
    -0.01617282f, 0.06176182f, -0.01438335f, -0.07086693f, -0.07098301f, -0.04115576f, -0.01950884f, 0.04936243f, 
    -0.05518685f, 0.03470994f, -0.06629568f, -0.02897989f, -0.03507555f, 0.01950497f, 0.00587016f, -0.01644993f, 
    0.02175030f, -0.05637101f, -0.03906448f, -0.07122604f, -0.06421141f, 0.01324715f, -0.01325733f, -0.05475338f, 
    0.01693671f, -0.07453787f, 0.03389244f, 0.01215718f, 0.05559618f, -0.06115284f, -0.05816012f, -0.05150446f, 
    0.04668472f, 0.05843997f, 0.00754210f, -0.02264101f, 0.00719189f, 0.00614377f, 0.02373937f, 0.00035482f, 
    -0.07835789f, -0.03537766f, 0.00014978f, -0.03351824f, -0.06727850f, 0.01453708f, -0.04668330f, -0.06129079f, 
    -0.05939198f, 0.03064199f, 0.01396655f, 0.05760310f, -0.07772420f, 0.03927677f, -0.06498069f, 0.01397213f, 
    -0.12306659f, -0.04260388f, -0.08975256f, 0.23111157f, -0.06626520f, -0.27767769f, -0.01488555f, -0.02383567f, 
    0.06148324f, 0.05168920f, -0.08774225f, 0.11429838f, 0.44848555f, 0.27296123f, 0.02291958f, 0.14742714f, 
    -0.02923772f, 0.00328807f, 0.09629481f, 0.03162193f, -0.04663968f, -0.06484368f, 0.05224873f, -0.06245499f, 
    0.19076395f, -0.36415869f, -0.02691009f, -0.20891020f, -0.01649159f, 0.03193523f, 0.01286661f, 0.02328297f, 
    -0.02303489f, -0.07781716f, 0.07663392f, -0.06625301f, 0.00903320f, -0.04637739f, 0.01875825f, 0.08530479f, 
    0.22538203f, -0.05643800f, -0.15389480f, 0.01333121f, 0.01611471f, -0.04853196f, -0.04063877f, 0.07795319f, 
    0.17299719f, 0.18741295f, 0.55365175f, -0.17656635f, -0.06884757f, 0.04052332f, 0.00093008f, 0.04105419f, 
    -0.00249713f, -0.08995603f, 0.02698260f, -0.11958202f, -0.39405611f, 0.03680258f, -0.12006348f, 0.39443997f, 
    -0.10972320f, -0.03864994f, -0.12751068f, -0.06457002f, 0.10895755f, 0.08632412f, 0.26602823f, 0.07032000f, 
    0.24086381f, -0.49413323f, 0.09871423f, 0.09658784f, 0.02662432f, 0.04192621f, 0.03079826f, -0.18113148f, 
    0.08258612f, 0.07712243f, -0.16017053f, 0.01061411f, 0.10374340f, 0.05556379f, 0.03971444f, -0.00927779f, 
    -0.02440502f, 0.05247461f, 0.02836456f, 0.19354729f, -0.07383114f, -0.19351886f, 0.00959969f, -0.08272246f, 
    0.14735331f, 0.12348153f, -0.04528493f, -0.00839049f, 0.12391300f, 0.16105388f, 0.01282154f, 0.03562981f, 
    0.05859423f, 0.11779280f, -0.07302296f, 0.07289546f, 0.36610079f, 0.16055785f, -0.04530770f, 0.22176990f, 
    0.16063771f, 0.20070371f, 0.06927139f, 0.09449830f, -0.06479058f, -0.05473420f, -0.00379536f, -0.13989651f, 
    -0.18831542f, -0.04892969f, -0.05256614f, -0.34454742f, -0.02047305f, 0.04116808f, 0.03677796f, -0.00773315f, 
    0.01557166f, 0.08975735f, 0.04636856f, 0.03242835f, 0.13003656f, 0.25531036f, 0.21948230f, -0.04617257f, 
    0.04079701f, -0.04062064f, 0.02748892f, 0.14971559f, -0.03759002f, 0.06787477f, 0.03030093f, -0.06087139f, 
    0.17060602f, 0.11793652f, -0.08675719f, 0.14774631f, -0.00851881f, -0.01631468f, 0.02817162f, -0.03932163f, 
    -0.03343767f, 0.07233779f, -0.01862804f, -0.05469195f, 0.09430184f, 0.03388030f, -0.00006993f, -0.11705142f, 
    -0.04942115f, -0.25510064f, -0.07706539f, 0.03887480f, -0.00293912f, 0.00840634f, -0.07778012f, 0.09232871f, 
    -0.15069166f, 0.26220515f, -0.03494166f, 0.20779626f, 0.02338568f, 0.00837933f, -0.04323931f, 0.04096529f, 
    0.01454579f, -0.00455360f, 0.05429499f, -0.01323629f, 0.15574391f, -0.07776356f, -0.15619773f, 0.19752830f, 
    -0.01806337f, -0.16164938f, -0.12715530f, -0.02151019f, -0.07318137f, -0.10962566f, -0.04852999f, 0.01152304f, 
    0.00337630f, 0.00005676f, 0.05248350f, 0.04952482f, -0.22789682f, 0.05149448f, -0.29817656f, -0.22695476f, 
    0.14085676f, -0.16923578f, -0.02154300f, 0.04539271f, 0.04452610f, 0.27559611f, -0.13537320f, -0.20867909f, 
    -0.00909814f, -0.03255631f, -0.03734306f, 0.08560716f, -0.08560454f, -0.03201738f, 0.14332266f, 0.08165427f, 
    0.34261042f, -0.45432195f, -0.02069252f, -0.35742602f, -0.07221405f, 0.11038552f, 0.03243323f, 0.07756375f, 
    0.17961936f, -0.02856577f, 0.11932325f, -0.02003513f, -0.09775110f, 0.10095875f, -0.02824540f, -0.04671022f, 
    -0.00618943f, 0.10836963f, -0.13676381f, -0.10128663f, 0.14285873f, 0.04428713f, -0.15747198f, 0.08284163f, 
    0.05290541f, 0.25473031f, 0.14995836f, 0.10098870f, 0.16745844f, -0.04239577f, 0.25576845f, 0.11055490f, 
    0.05466709f, -0.07635407f, -0.04735130f, 0.02724983f, 0.17023569f, -0.10968494f, 0.15171392f, 0.38792497f, 
    -0.22863780f, -0.05010469f, -0.16537152f, -0.07832223f, 0.18979566f, 0.05009674f, 0.05078012f, -0.01445757f, 
    0.36628011f, -0.35868695f, -0.21835855f, -0.22486641f, -0.08369558f, 0.06332134f, -0.05192125f, 0.02440096f, 
    0.10827768f, -0.04874065f, 0.08260617f, -0.01910850f, 0.28770372f, 0.12854819f, -0.14016774f, 0.10331941f, 
    -0.01074715f, -0.10946769f, 0.01911131f, 0.10190491f, -0.17510064f, -0.09610303f, -0.09305198f, -0.00072087f, 
    0.07930841f, -0.04503476f, 0.03566148f, -0.00163261f, -0.07674257f, 0.02359946f, -0.18487184f, 0.02142555f, 
    0.04998824f, -0.09960288f, 0.01557821f, -0.06856498f, 0.25139844f, 0.19204347f, -0.01030716f, 0.42984101f, 
    -0.01648122f, -0.16572461f, -0.05766591f, -0.13464317f, 0.10132700f, -0.14213717f, -0.02517130f, -0.08763194f, 
    -0.36286715f, 0.52008802f, 0.04685395f, -0.24111250f, -0.02400845f, 0.09143329f, 0.23121618f, 0.00490572f, 
    -0.00782639f, 0.00327059f, -0.12750524f, -0.05662153f, 0.17556985f, 0.21020499f, 0.29493248f, -0.07889260f, 
    0.06828665f, -0.20094347f, -0.13266554f, 0.05091173f, -0.07214388f, -0.05106793f, 0.11697832f, 0.09996349f, 
    -0.04028766f, 0.07900789f, -0.08936278f, -0.10731216f, 0.02269752f, 0.05670123f, -0.03209624f, 0.27797216f, 
    0.07540091f, 0.07835838f, -0.05606331f, 0.06857000f, 0.09559431f, -0.05961388f, 0.18652858f, -0.11352894f, 
    -0.00724363f, -0.15845765f, -0.06000811f, 0.02439618f, -0.03113085f, -0.00371645f, -0.03359795f, -0.13071094f, 
    -0.50543201f, 0.10034332f, 0.26246652f, 0.18898004f, 0.14937346f, 0.12798236f, -0.00622268f, 0.01446986f, 
    0.14552312f, 0.01344779f, -0.11811320f, 0.00183290f, 0.40183157f, 0.01490162f, -0.02518536f, 0.22597980f, 
    -0.06357484f, -0.02343058f, 0.14410923f, -0.03632995f, -0.03477696f, -0.09709278f, 0.01495541f, 0.04740967f, 
    0.05213240f, 0.02739595f, -0.02079216f, -0.01401951f, 0.03408612f, -0.06620450f, -0.01189913f, 0.03910459f, 
    -0.05991789f, -0.08178676f, -0.02619491f, -0.09387056f, 0.03736837f, 0.04636152f, -0.05882756f, -0.09001414f, 
    -0.03371990f, -0.06227081f, 0.00013180f, -0.03950509f, 0.03922509f, 0.01657225f, 0.00544622f, 0.05113781f, 
    -0.05997505f, 0.05417016f, -0.06144106f, 0.03777945f, 0.05737153f, 0.04312614f, -0.03714081f, -0.06826204f, 
    0.01201532f, 0.02021832f, 0.02720080f, -0.02715086f, 0.04131613f, 0.00984914f, 0.01208767f, 0.00072349f, 
    -0.02599207f, 0.02236486f, 0.00543471f, 0.06012635f, -0.07176811f, 0.01336399f, -0.04842710f, -0.00159412f, 
    -0.00652858f, -0.07082592f, -0.04122653f, 0.04815175f, 0.03495000f, -0.05135642f, -0.02688181f, -0.01900291f, 
    -0.05394224f, 0.00474569f, -0.03048979f, -0.00562136f, -0.08689141f, 0.02086281f, -0.05030832f, 0.04370444f, 
    0.04099537f, -0.06569146f, -0.00544674f, 0.04137805f, -0.00491705f, -0.02680122f, -0.08536737f, -0.08829252f, 
    -0.06893948f, -0.02288073f, -0.06648821f, 0.02928579f, -0.01130435f, -0.09945223f, 0.01190878f, -0.04332262f, 
    -0.04731345f, -0.00581805f, -0.05939478f, -0.04120645f, -0.08819669f, -0.02150021f, -0.09880119f, -0.00994582f, 
    0.01102458f, -0.01240552f, -0.09526130f, -0.08865210f, 0.03069023f, 0.04200281f, -0.03806656f, 0.00849170f, 
    -0.07556149f, -0.01742967f, -0.08427979f, -0.08426098f, 0.03812930f, -0.09739285f, 0.00720256f, -0.01002976f, 
    -0.07941531f, -0.00263461f, -0.03753115f, -0.05732875f, -0.03624543f, 0.03456482f, -0.00134154f, 0.05463118f, 
    0.03403630f, -0.06560402f, -0.07525446f, -0.00152362f, -0.05103718f, -0.09394549f, 0.03217684f, -0.05846940f, 
    -0.06713452f, 0.05559534f, -0.07146734f, -0.03078387f, 0.00943740f, 0.00772510f, -0.01036862f, -0.00916071f, 
    -0.02653606f, 0.03962125f, 0.03388362f, 0.02381156f, -0.06586646f, -0.01923485f, -0.07615152f, -0.05311974f, 
    0.06839506f, 0.01743487f, -0.04994196f, -0.00106827f, -0.07509210f, -0.05899814f, -0.07206388f, 0.05054200f, 
    -0.02403038f, -0.00168199f, 0.01128078f, -0.03446179f, 0.05671019f, 0.04688783f, 0.00742677f, -0.04156810f, 
    -0.01810960f, -0.04928494f, -0.03785360f, 0.02081109f, -0.05934495f, -0.09281647f, -0.06166889f, 0.01151003f, 
    -0.03781038f, -0.07087385f, -0.01595127f, -0.04126886f, -0.05888486f, 0.02519176f, 0.01873986f, -0.07789548f, 
    0.03295241f, 0.01035735f, 0.00511293f, -0.03579886f, -0.01247594f, -0.07931162f, -0.06096866f, -0.05025878f, 
    0.00424874f, -0.04491094f, 0.04708276f, -0.02885547f, -0.00439105f, -0.01521697f, -0.03091717f, -0.02741450f, 
    -0.03341502f, 0.02451714f, 0.00525660f, -0.04613838f, 0.02631109f, -0.03618152f, -0.06860376f, -0.05084268f, 
    -0.03290861f, -0.21908098f, -0.08150545f, 0.02717743f, -0.05956872f, -0.18204679f, 0.13332361f, 0.00044136f, 
    -0.00932958f, 0.06242637f, 0.09478386f, 0.07086356f, 0.41537389f, 0.14413075f, 0.01166862f, 0.49232092f, 
    0.04945859f, 0.03091441f, 0.17016733f, 0.11500230f, 0.02713006f, -0.02451198f, -0.10620923f, -0.08292735f, 
    -0.01968317f, -0.50590092f, 0.09758961f, -0.02357442f, 0.03491135f, -0.03979440f, 0.09415995f, 0.04851329f, 
    0.00417879f, -0.06958915f, 0.26927090f, 0.07201193f, 0.07258967f, -0.11992839f, -0.05853942f, -0.01104932f, 
    0.19581774f, -0.25233912f, -0.07089098f, -0.02639403f, 0.24714461f, 0.08147779f, 0.02508614f, 0.18005252f, 
    -0.09020081f, 0.06736343f, 0.23729905f, -0.08079220f, 0.17300718f, 0.02369479f, -0.16010910f, 0.07555381f, 
    -0.01833117f, -0.00556107f, 0.05718550f, 0.03120202f, -0.32953310f, 0.27083981f, -0.16789143f, 0.05290092f, 
    0.11460049f, 0.07812553f, -0.05706407f, 0.01431311f, -0.00266570f, -0.02462612f, 0.20169027f, 0.00455206f, 
    -0.05564060f, -0.38454351f, 0.45162341f, -0.01627940f, 0.00042831f, -0.04698738f, 0.05431608f, -0.11436819f, 
    0.07702855f, 0.11389706f, -0.10057094f, 0.16117057f, -0.11062757f, -0.07970546f, 0.07187618f, 0.02834237f, 
    -0.05328176f, 0.25626025f, 0.14656593f, 0.01227721f, -0.07766771f, -0.07663960f, 0.02157301f, -0.08042900f, 
    0.12306642f, -0.04036456f, -0.04919250f, 0.09135771f, -0.05021802f, 0.05660017f, 0.01890153f, -0.08415443f, 
    0.12110473f, 0.19571568f, -0.14040524f, 0.00587075f, 0.19795044f, -0.03886731f, -0.21270320f, 0.08775055f, 
    0.11542314f, 0.29025939f, 0.02715852f, 0.14291753f, -0.03326244f, -0.07208897f, 0.05404413f, -0.01890711f, 
    0.08243603f, -0.34292248f, -0.06485880f, -0.15642188f, -0.06873303f, -0.12947293f, 0.04776514f, -0.01882553f, 
    -0.04642469f, 0.09219477f, 0.21248394f, 0.06194884f, -0.12805448f, 0.19082913f, 0.21911535f, 0.01049978f, 
    -0.10359579f, -0.03571244f, -0.00890318f, 0.12373132f, -0.06333581f, 0.04890162f, 0.05383871f, -0.16114089f, 
    0.15300936f, 0.12702726f, -0.07662912f, 0.09221108f, 0.07246740f, 0.04392957f, 0.20360054f, -0.11615641f, 
    0.05776291f, -0.05685653f, 0.03391933f, 0.04007482f, 0.23207663f, -0.23519354f, -0.07210006f, -0.18685821f, 
    -0.04681420f, 0.06341468f, 0.03922286f, 0.00674202f, 0.17140053f, 0.06060740f, 0.01142464f, 0.04145646f, 
    0.33881608f, -0.19727303f, -0.14732185f, 0.13938682f, -0.01241304f, -0.00611641f, -0.05210406f, -0.14719510f, 
    0.14291617f, 0.11709049f, 0.01526582f, -0.15273355f, 0.00622497f, 0.09586293f, -0.03406044f, 0.16321449f, 
    0.00029768f, -0.08346272f, -0.25538570f, -0.02353393f, -0.10301764f, -0.03390416f, -0.05152686f, 0.09092982f, 
    0.04766175f, -0.03160094f, -0.05074511f, 0.03060953f, -0.03270294f, 0.06715613f, -0.04432819f, -0.05628474f, 
    0.04688918f, 0.02381488f, -0.07814960f, -0.06570442f, -0.02953030f, -0.07168967f, -0.01198930f, -0.07070681f, 
    -0.04467162f, 0.04001833f, -0.06480347f, -0.00046748f, -0.00675142f, -0.07331671f, -0.07324062f, -0.05220101f, 
    0.03136091f, 0.00393353f, -0.02342867f, 0.04399606f, 0.04654502f, -0.04431120f, 0.02903787f, 0.02359275f, 
    -0.02228960f, -0.02586665f, 0.06566800f, -0.03281828f, -0.01246100f, 0.01224299f, 0.02469287f, 0.02679715f, 
    -0.05967558f, -0.02756986f, -0.01538680f, 0.03736444f, -0.00167612f, -0.02225572f, 0.02495112f, -0.01394760f, 
    -0.02482033f, 0.01976738f, -0.06140011f, -0.00307859f, -0.00394963f, -0.01144858f, -0.04534768f, -0.06617373f, 
    -0.05325513f, 0.02400951f, -0.01719969f, 0.01262096f, 0.06183439f, -0.06672698f, -0.01875602f, -0.07610008f, 
    -0.07073744f, -0.02561511f, 0.04954074f, -0.02868568f, -0.03614811f, -0.03892298f, -0.01394168f, 0.04473570f, 
    -0.01741712f, 0.05679630f, -0.04631241f, -0.01223747f, 0.01273218f, -0.00158658f, -0.01064888f, -0.03627786f, 
    0.00953228f, -0.05042931f, -0.05839458f, -0.03359642f, -0.03942576f, -0.00344386f, -0.07556113f, -0.00297570f, 
    -0.07745645f, -0.06201725f, -0.06517407f, -0.06343615f, -0.05629665f, 0.01398649f, 0.02435179f, -0.03883670f, 
    -0.03057869f, -0.04584710f, -0.00960600f, -0.04046522f, -0.01177977f, 0.03488196f, -0.01076750f, 0.00437164f, 
    0.05915739f, -0.00352866f, 0.05251246f, 0.00750024f, -0.02358786f, -0.00326865f, -0.02913254f, 0.01520954f, 
    0.02673912f, 0.03205283f, -0.02848516f, 0.04738765f, 0.04100790f, -0.04679994f, 0.00987152f, -0.05539133f, 
    -0.05229382f, 0.06112610f, -0.07088198f, -0.06798355f, 0.03399828f, -0.07897773f, 0.04723283f, -0.07396392f, 
    0.00881134f, 0.06461715f, 0.02124384f, 0.01434209f, -0.01119796f, 0.03969233f, -0.03597341f, -0.06786170f, 
    -0.00542792f, 0.07002062f, 0.06439393f, 0.05455005f, 0.06289307f, -0.04302591f, 0.00175770f, -0.06208366f, 
    0.00215410f, -0.06210054f, -0.01815992f, 0.05399041f, -0.04719796f, -0.04846941f, 0.01918400f, 0.05138501f, 
    0.00643591f, 0.02206382f, 0.05300981f, -0.00682568f, -0.06139816f, 0.06173412f, -0.02560435f, -0.05362903f, 
    -0.02692366f, -0.04389850f, -0.05208797f, 0.03985686f, 0.00150312f, 0.05042590f, 0.05621520f, 0.03511052f, 
    -0.06305415f, -0.02019106f, 0.01401901f, -0.04483324f, 0.02486959f, -0.06533208f, -0.07538533f, 0.03929301f, 
    -0.05925568f, -0.06812109f, 0.00511439f, -0.03200258f, 0.04915087f, 0.03318556f, -0.07332587f, 0.06059016f, 
    -0.01083438f, 0.01128079f, 0.01228768f, 0.00106368f, 0.02370881f, 0.03256461f, 0.05171885f, 0.00321397f, 
    -0.06490873f, -0.28646752f, -0.16005048f, 0.07566935f, -0.00329110f, 0.19941713f, -0.25962356f, -0.02932294f, 
    0.13820966f, -0.15211412f, 0.12761551f, 0.12598726f, -0.19303027f, 0.18761976f, 0.10279676f, -0.06727082f, 
    0.12896632f, 0.12587228f, 0.10578644f, 0.10630561f, -0.09566866f, -0.01351245f, 0.17890787f, -0.03552314f, 
    0.52658081f, 0.58132911f, 0.26526654f, 0.09205139f, 0.01314380f, 0.00082929f, 0.07660620f, 0.05965413f, 
    0.03745027f, -0.00984776f, -0.12960778f, -0.01467909f, -0.08809711f, 0.02260755f, -0.17921646f, -0.17820682f, 
    -0.11125945f, 0.47316229f, 0.03057755f, -0.27794993f, -0.19057776f, -0.02872310f, -0.13075005f, -0.15493713f, 
    -0.03380466f, 0.07841429f, -0.01159699f, 0.30907482f, -0.27451992f, 0.13969214f, 0.23110047f, 0.05612407f, 
    0.03703576f, 0.02875167f, 0.05194217f, 0.06299207f, 0.00514782f, -0.14348136f, 0.15908426f, 0.09551556f, 
    -0.14871959f, -0.18061052f, -0.10989539f, 0.04177105f, 0.08463868f, 0.10219449f, -0.01641767f, 0.20807625f, 
    -0.19302234f, 0.01537406f, -0.09251039f, -0.23814838f, 0.18538231f, 0.22341920f, -0.09582167f, 0.17157657f, 
    0.09897415f, -0.17530285f, 0.04065640f, -0.00362644f, -0.17111543f, -0.09260705f, -0.26531774f, -0.14235374f, 
    0.02673552f, -0.20136929f, -0.11752701f, 0.10233039f, 0.13002239f, 0.12790562f, -0.16671515f, 0.07941290f, 
    -0.11543693f, -0.10475679f, -0.00496046f, -0.15673175f, 0.09159586f, 0.21708472f, 0.05816615f, 0.09701826f, 
    -0.18740253f, -0.08108070f, 0.21561885f, 0.05608795f, -0.90703559f, -0.38650423f, -0.03024990f, 0.08973479f, 
    -0.00063492f, -0.07427462f, -0.06843119f, -0.27748257f, 0.01152624f, 0.01270595f, 0.06223025f, -0.05655443f, 
    0.07532871f, 0.75087512f, 0.20804808f, 0.22163039f, 0.10761287f, 0.04752864f, 0.00552472f, -0.03476559f, 
    -0.06298694f, -0.08173537f, -0.02414800f, 0.08080944f, 0.15880215f, 0.17657071f, 0.23997429f, 0.24131362f, 
    0.06709228f, -0.03667755f, 0.03210768f, 0.15727623f, -0.07469767f, -0.04863967f, 0.05647802f, 0.10869062f, 
    0.27313495f, 0.16502739f, 0.03423337f, 0.02632350f, 0.03956781f, -0.00139175f, -0.04297429f, 0.23316798f, 
    0.15076771f, 0.02080914f, 0.13384978f, -0.03285202f, -0.14310800f, -0.06733079f, 0.03768222f, -0.00453546f, 
    -0.00405520f, -0.02816863f, -0.16216642f, -0.12550172f, 0.04392068f, 0.11953505f, 0.00958591f, 0.05009796f, 
    -0.46815118f, -0.12654747f, 0.05868408f, 0.06664068f, 0.07208876f, 0.02199914f, -0.00508574f, -0.18248922f, 
    0.04284625f, -0.03380760f, 0.07254869f, 0.12223640f, -0.02423367f, -0.23365118f, -0.06372211f, 0.04419427f, 
    0.09562182f, 0.06759997f, 0.20947218f, 0.04047322f, -0.04221752f, 0.16120231f, 0.10086667f, -0.04301648f, 
    0.26211333f, -0.06217726f, 0.02271076f, 0.00881571f, 0.00878428f, -0.05738808f, -0.03220051f, -0.02222184f, 
    0.18149434f, -0.14289448f, -0.13306777f, 0.06349134f, 0.26691061f, -0.00202673f, 0.07030897f, -0.00385237f, 
    0.16899030f, 0.11904200f, -0.02444090f, 0.04300852f, 0.04784529f, -0.12520719f, -0.00471343f, -0.01837466f, 
    -0.27855706f, 0.01639703f, -0.06161467f, -0.02718976f, -0.23253807f, -0.04019998f, 0.01981019f, 0.02482078f, 
    0.35492647f, -0.06032195f, 0.04904296f, -0.19890058f, -0.08084688f, -0.18340199f, 0.19987042f, 0.07929612f, 
    -0.13613871f, -0.10032852f, 0.02693912f, -0.02250929f, 0.00843136f, 0.08002377f, -0.04967061f, 0.17266226f, 
    -0.28386027f, -0.03599992f, 0.46230501f, 0.14411461f, -0.03243291f, 0.21389981f, -0.01862427f, 0.15008298f, 
    0.07015882f, 0.05980753f, 0.10252882f, 0.17718042f, 0.06929577f, -0.10609910f, 0.33273664f, 0.13328318f, 
    0.00027949f, -0.12569554f, -0.15581429f, 0.03364826f, 0.24321112f, -0.07548133f, 0.09873726f, -0.08388714f, 
    0.09176651f, -0.41941071f, 0.44564176f, 0.05786909f, 0.05780560f, -0.02950263f, 0.09421816f, 0.16440970f, 
    0.14516534f, 0.07430644f, -0.23436889f, 0.11225536f, 0.45707673f, -0.05217681f, -0.13294122f, 0.21566273f, 
    0.00736070f, 0.00700263f, 0.00165995f, -0.15763906f, 0.12293024f, -0.12213743f, 0.11448979f, -0.03166498f, 
    0.09297494f, -0.06559961f, -0.00442436f, -0.05119671f, -0.12492573f, 0.08342973f, 0.02227708f, 0.07663880f, 
    0.07247937f, 0.01380756f, -0.01318547f, -0.01638031f, 0.09805346f, -0.10040046f, -0.25505525f, 0.33883229f, 
    0.09933446f, 0.09421132f, -0.00144172f, -0.02478733f, 0.03442804f, -0.08606613f, -0.10116780f, -0.07847325f, 
    -0.29217595f, 0.06834805f, -0.21021888f, -0.01113355f, -0.16696338f, 0.00941596f, 0.05753437f, 0.09238140f, 
    0.07470790f, -0.01980144f, 0.02482203f, -0.03484409f, -0.11133352f, 0.13044257f, 0.14582695f, -0.05895876f, 
    -0.01647157f, -0.02103369f, -0.08457995f, -0.08911978f, -0.04182377f, -0.00756576f, 0.05973465f, 0.04079898f, 
    -0.06064728f, 0.01003130f, 0.40499255f, 0.09976608f, 0.18050554f, -0.03533245f, 0.11872236f, -0.12619239f, 
    -0.03286276f, -0.04353309f, 0.23036882f, -0.05556224f, 0.01354288f, -0.08850665f, 0.03065297f, -0.12109609f, 
    0.16271320f, -0.06695391f, 0.04690492f, 0.05019494f, -0.04115914f, -0.00846158f, 0.11471600f, -0.07534437f, 
    -0.36219239f, -0.30602875f, 0.03062284f, 0.42369273f, -0.24407963f, -0.07033192f, 0.08764621f, 0.14667186f, 
    0.03929584f, 0.01675599f, 0.05044270f, -0.01816941f, 0.19105889f, 0.06220556f, -0.11834137f, -0.00119606f, 
    0.28914982f, -0.03435987f, -0.07827459f, -0.01836734f, -0.01870399f, -0.03110330f, -0.00291606f, 0.15740310f, 
    0.11673304f, 0.18203293f, 0.09946429f, -0.01548697f, 0.00366939f, 0.02156544f, -0.06534625f, 0.06936128f, 
    -0.01686258f, 0.00001458f, 0.07879288f, 0.12307344f, -0.29860836f, -0.55917251f, 0.12405126f, -0.16087872f, 
    0.17378673f, -0.03550144f, 0.08748686f, 0.00398260f, -0.07029226f, -0.02684190f, -0.12410378f, 0.05958768f, 
    -0.79435426f, 0.38008478f, -0.00403047f, 0.14541531f, -0.14279327f, -0.00025233f, -0.04708037f, 0.21323103f, 
    0.06116948f, 0.12977710f, 0.12284013f, 0.07207493f, -0.06895803f, -0.00797641f, -0.06719997f, 0.02262721f, 
    -0.01573452f, -0.05656583f, -0.02222906f, -0.04908933f, -0.08922199f, -0.07007933f, -0.04702247f, -0.14908384f, 
    -0.03133880f, -0.33635420f, -0.42577118f, -0.33691239f, 0.10569765f, -0.03833862f, -0.21508799f, -0.18842736f, 
    -0.01663229f, 0.00956850f, -0.17434938f, -0.12317680f, 0.19032073f, -0.00914040f, 0.26072010f, 0.16619143f, 
    0.03170823f, -0.00005373f, 0.09033448f, 0.02699745f, 0.14775003f, 0.05350158f, 0.08134978f, 0.01679207f, 
    -0.01647611f, 0.40138170f, 0.21547003f, 0.34882966f, 0.09052285f, 0.14477701f, -0.01833912f, 0.24727619f, 
    0.02173493f, 0.03903283f, 0.08429977f, -0.04115873f, 0.16050914f, 0.07264981f, 0.00377774f, 0.18754417f, 
    0.01321283f, 0.07946666f, 0.07339869f, 0.07571107f, 0.01825034f, -0.00599195f, -0.03523977f, 0.06253831f, 
    0.08015810f, -0.06543408f, -0.01437732f, -0.02945755f, 0.04320854f, -0.23472904f, 0.03618420f, -0.02412439f, 
    -0.07674018f, -0.21900676f, -0.19863260f, -0.26638359f, 0.42168862f, 0.14641733f, 0.22120254f, 0.01986919f, 
    -0.07751620f, 0.02629150f, 0.04163649f, 0.05356662f, -0.12397905f, -0.02691151f, -0.02168352f, -0.02824384f, 
    -0.67084277f, -0.09666234f, -0.07303590f, 0.08962888f, 0.05293480f, -0.09087251f, 0.07875207f, 0.14087801f, 
    -0.09711982f, -0.03553130f, 0.20990579f, 0.12429384f, -0.33098066f, -0.26620421f, -0.11257525f, -0.15520042f, 
    -0.06076916f, 0.08841427f, 0.27916360f, -0.12492043f, 0.10496871f, -0.09182349f, 0.02313480f, 0.08386780f, 
    -0.15804172f, -0.06917530f, 0.38811815f, 0.08094359f, 0.04081476f, 0.16096462f, -0.13134694f, 0.12220043f, 
    0.18762250f, 0.07928146f, 0.07447968f, 0.00658414f, -0.07148939f, 0.01038362f, -0.00990106f, 0.19811372f, 
    0.03874740f, 0.05960949f, 0.04077114f, -0.00656638f, 0.14110227f, -0.02261574f, -0.06590946f, -0.06114833f, 
    0.13154680f, -0.11046463f, -0.09307752f, 0.16063316f, 0.01408532f, 0.23757128f, 0.00665253f, 0.16750191f, 
    -0.04518811f, 0.13116479f, 0.11511852f, -0.17844434f, 0.09993850f, 0.09321455f, 0.17841072f, -0.21201205f, 
    0.05744333f, 0.05108693f, 0.00992954f, -0.04169115f, 0.02103769f, -0.09916987f, 0.00104758f, -0.07848922f, 
    0.09325051f, -0.13980258f, 0.10970651f, 0.04061433f, -0.10196915f, -0.05270842f, -0.06008404f, -0.07827051f, 
    0.06872129f, 0.10006507f, -0.06798405f, -0.03739243f, 0.06518604f, -0.24351472f, -0.04234423f, 0.07945234f, 
    0.22209966f, 0.28272995f, -0.03229660f, 0.06860249f, -0.05635047f, -0.01836244f, 0.00780181f, 0.09340184f, 
    0.04472643f, -0.02909219f, 0.02991717f, -0.17921105f, 0.00785352f, -0.01306722f, -0.16915423f, 0.06965343f, 
    0.03992312f, -0.07303361f, 0.11887676f, -0.01790310f, -0.00478131f, -0.04039245f, 0.21969490f, 0.10126856f, 
    0.01955645f, -0.24814360f, 0.00924577f, 0.11394643f, 0.16625153f, 0.00224566f, 0.19962344f, 0.19851162f, 
    -0.07158339f, -0.11064483f, 0.18577890f, -0.04946126f, 0.08613657f, 0.05325781f, -0.07621706f, 0.05241309f, 
    0.00290039f, -0.04929835f, 0.01307058f, 0.16444877f, 0.13366890f, 0.01700703f, 0.32411292f, 0.28161004f, 
    -0.09394762f, -0.01432485f, -0.20165259f, 0.05099586f, 0.18193047f, 0.05159278f, 0.27143148f, -0.20689757f, 
    0.27864426f, -0.45352620f, 0.38931832f, 0.23632188f, 0.08991695f, 0.14694904f, 0.10917168f, 0.04716095f, 
    0.15150593f, 0.05305111f, -0.05926093f, 0.12271291f, -0.25824532f, -0.33186677f, -0.19228598f, 0.01071914f, 
    0.11515044f, -0.00349267f, 0.02895173f, -0.16422595f, -0.18596049f, -0.21393156f, -0.00459223f, 0.05951915f, 
    0.02113952f, -0.03848355f, 0.05279530f, 0.05025266f, 0.02464630f, 0.15535414f, 0.06886341f, -0.08542546f, 
    0.06635125f, 0.01470965f, 0.02279521f, 0.09398720f, -0.05862989f, -0.21581694f, -0.77217913f, 0.12745127f, 
    0.10003830f, 0.14758722f, 0.28246424f, -0.19333081f, -0.10870799f, -0.05747656f, -0.00617804f, -0.06025788f, 
    -0.25173753f, -0.01072728f, -0.20303649f, -0.16673063f, -0.05167285f, 0.09497775f, 0.07242046f, 0.15739402f, 
    0.15362799f, 0.15457188f, 0.07980767f, 0.04323382f, 0.08010285f, 0.24813624f, -0.04662034f, -0.01859294f, 
    0.08676964f, 0.11957608f, 0.04623195f, 0.04917608f, -0.04640327f, 0.04173984f, -0.14379910f, -0.13674361f, 
    -0.10541952f, -0.21901290f, 0.45186222f, 0.15388711f, 0.15109815f, 0.08070638f, 0.26012287f, -0.00242012f, 
    0.02196929f, -0.13916370f, -0.04476304f, -0.08581464f, -0.11019083f, -0.28092098f, -0.01364597f, -0.33964470f, 
    0.09595145f, 0.14511621f, -0.07860695f, -0.00366185f, -0.06082895f, -0.03157455f, 0.13155973f, -0.01437165f, 
    0.00230269f, -0.09883995f, -0.21112382f, 0.14392442f, -0.10195103f, 0.12136024f, 0.27785152f, -0.01211269f, 
    0.07153948f, 0.06306245f, 0.14699474f, 0.01200397f, -0.34420255f, -0.02877726f, -0.27813637f, -0.12032365f, 
    -0.05014653f, -0.17362739f, -0.00393812f, -0.05587192f, 0.05197010f, -0.06446488f, 0.14737977f, 0.13501716f, 
    0.13453294f, -0.03079253f, 0.19173717f, -0.36074618f, -0.02046483f, 0.10405269f, -0.12872759f, -0.10157777f, 
    -0.18641444f, -0.03442039f, 0.12117140f, 0.01330708f, 0.07047662f, 0.06543698f, -0.07898898f, 0.16638887f, 
    0.04421438f, 0.05154584f, -0.01088506f, -0.01461522f, -0.06723178f, -0.08617646f, 0.02177747f, 0.07923152f, 
    0.10252842f, -0.37978148f, -0.07430065f, -0.01186434f, 0.15788683f, 0.07539906f, 0.12624319f, 0.06146670f, 
    0.23662953f, 0.04595600f, 0.13900054f, 0.19738013f, 0.13401030f, -0.10234643f, 0.02766444f, -0.12021409f, 
    -0.04442132f, 0.02543948f, -0.02508829f, 0.01338622f, 0.12833786f, 0.20020959f, 0.24626739f, 0.30097318f, 
    -0.05379653f, -0.04817109f, -0.27146038f, 0.11001832f, 0.32905355f, 0.00104196f, 0.19158958f, 0.10988524f, 
    0.03519716f, 0.02823130f, -0.02008789f, 0.12122515f, 0.35152304f, 0.31325138f, 0.17765604f, -0.22245866f, 
    -0.03377180f, 0.04347711f, -0.04570076f, -0.12636568f, -0.02225641f, -0.16446346f, -0.05827448f, -0.03846894f, 
    0.08995064f, 0.08010966f, 0.12598616f, -0.44193119f, -0.07080407f, 0.02150515f, -0.08819480f, 0.02506346f, 
    0.06160217f, 0.15238386f, 0.03941769f, 0.05395960f, -0.16557628f, 0.06630216f, 0.13398406f, 0.03875392f, 
    -0.00694029f, -0.12064415f, -0.08310404f, -0.03496551f, -0.07837732f, 0.01208578f, -0.05474273f, 0.00665039f, 
    -0.04417019f, -0.06726617f, -0.00005993f, -0.07656733f, -0.19840275f, 0.04523521f, -0.08437685f, 0.00144798f, 
    0.08876440f, 0.05509023f, 0.09102685f, 0.19116881f, -0.36279166f, 0.20852233f, -0.01716623f, 0.13200253f, 
    -0.04013074f, -0.16983278f, -0.03647536f, -0.07790588f, 0.09469186f, -0.11628368f, -0.00738904f, -0.06044889f, 
    0.18074760f, 0.01732352f, -0.08393492f, 0.10231049f, -0.01252585f, 0.07405326f, 0.12799750f, 0.14542197f, 
    0.06210986f, 0.00402107f, -0.15331671f, 0.06126860f, 0.05429342f, -0.08035088f, 0.07178820f, 0.17808133f, 
    0.02376928f, 0.04047011f, -0.15676002f, -0.06451548f, -0.20373531f, -0.15718171f, 0.00128754f, -0.04435114f, 
    -0.12310559f, 0.16572788f, -0.13528305f, -0.06922730f, 0.16603436f, 0.04502355f, 0.04700829f, 0.21935502f, 
    0.05453341f, -0.03353209f, 0.05102249f, 0.19474742f, 0.05200143f, -0.37771475f, 0.16779783f, -0.23327889f, 
    0.01854356f, 0.11998281f, -0.11185228f, 0.04185177f, 0.09634272f, 0.20351921f, -0.01288971f, 0.04357067f, 
    0.25549850f, -0.10296084f, 0.21055791f, -0.26472721f, -0.00506751f, -0.04826060f, -0.05020755f, -0.15892291f, 
    -0.11046508f, 0.24977730f, -0.19273563f, -0.08853654f, 0.11978972f, 0.20823526f, 0.08761354f, 0.16670507f, 
    -0.02458746f, 0.06639674f, 0.07448982f, -0.08665781f, 0.11708722f, -0.07167494f, 0.10562969f, 0.09976505f, 
    0.00804767f, -0.32358259f, -0.04482404f, 0.04578656f, 0.10515422f, 0.00281146f, 0.04034387f, 0.29047990f, 
    0.00732673f, -0.02552686f, 0.12924875f, 0.18493865f, 0.34160581f, 0.11263711f, 0.00561092f, 0.09621996f, 
    0.23740932f, 0.05586961f, 0.00432251f, 0.23327860f, -0.03979950f, 0.01345093f, -0.06829439f, -0.07986956f, 
    -0.01349225f, 0.21032165f, 0.38720825f, 0.13643879f, 0.00749551f, -0.06307558f, 0.00526044f, -0.04649902f, 
    0.02836201f, -0.03813878f, 0.06803367f, 0.09413616f, -0.20156723f, -0.37210399f, 0.05766158f, 0.18739142f, 
    0.04713601f, -0.07338183f, -0.13212487f, -0.01538214f, -0.02716040f, -0.05705440f, -0.00542077f, 0.04736008f, 
    0.07106400f, 0.05258749f, 0.28570569f, -0.11770967f, 0.12814914f, 0.05708222f, -0.07077371f, 0.01063519f, 
    -0.01040068f, -0.04058098f, -0.02903240f, -0.03517950f, -0.21180901f, 0.16260621f, 0.00586873f, 0.06795353f, 
    0.28130260f, -0.13661852f, 0.07166635f, 0.12537314f, -0.03619773f, 0.00127253f, 0.08166874f, 0.08356586f, 
    -0.12631743f, -0.12562858f, 0.56050014f, 0.04837149f, 0.16772042f, 0.11112110f, 0.09342246f, -0.04506496f, 
    0.16222541f, 0.11557214f, -0.17589293f, -0.01604422f, 0.01094191f, -0.17129454f, 0.00983960f, 0.27971458f, 
    -0.01999359f, 0.08322886f, 0.07831174f, 0.18972722f, 0.15217933f, 0.10741916f, 0.04348324f, -0.05427231f, 
    0.00911754f, -0.09548717f, -0.16620682f, -0.09332249f, -0.00927555f, 0.14578220f, 0.00771531f, -0.12733679f, 
    -0.02914986f, -0.14054441f, -0.31595904f, -0.16852938f, -0.34471807f, -0.36393300f, 0.05914630f, 0.16062893f, 
    0.01614243f, 0.19020493f, -0.02186680f, 0.13909595f, -0.10680173f, -0.18578754f, 0.06607319f, 0.00888314f, 
    0.00698847f, -0.00239513f, 0.11590682f, -0.21384896f, -0.04811235f, -0.04042697f, -0.09808478f, 0.18341465f, 
    0.10301559f, 0.02143044f, 0.12123582f, 0.13953544f, 0.09818831f, 0.20962092f, 0.24686271f, 0.03788227f, 
    0.12016176f, 0.05625730f, 0.12253630f, -0.07638490f, -0.01566513f, -0.01871629f, 0.25489330f, 0.10776626f, 
    0.15472353f, 0.22290723f, 0.20021226f, 0.11359748f, 0.28022736f, 0.02168794f, 0.08990543f, -0.07174899f, 
    0.23577382f, -0.02053744f, 0.19063906f, 0.01652930f, -0.01421615f, -0.29672107f, -0.24550655f, -0.12598129f, 
    -0.07004149f, 0.04344037f, -0.11137195f, 0.07984666f, 0.14497019f, 0.10752051f, 0.12570973f, 0.09231544f, 
    -0.38332346f, -0.19143622f, -0.05208980f, 0.28963196f, -0.15446430f, 0.00436341f, 0.01923108f, 0.04120843f, 
    0.06131837f, 0.17192549f, -0.04264301f, 0.00887253f, 0.02218778f, -0.17536634f, -0.07495011f, 0.04126101f, 
    -0.04591707f, -0.10549698f, -0.28323206f, 0.07463700f, -0.00715348f, -0.05434226f, -0.15347239f, 0.06555764f, 
    -0.09531083f, 0.15399367f, 0.00820209f, -0.28915793f, -0.02703893f, 0.00735642f, 0.02179105f, -0.09901609f, 
    -0.02807013f, -0.05044822f, 0.28044045f, 0.02822480f, 0.03188400f, -0.16445707f, 0.20093217f, 0.26267946f, 
    0.00215234f, -0.01843171f, 0.12189081f, -0.12745805f, -0.06647978f, 0.10199313f, -0.08481939f, 0.02509011f, 
    -0.23485671f, 0.01935171f, 0.00471128f, 0.21942095f, 0.05553263f, -0.00147570f, 0.01569713f, 0.17200515f, 
    0.00156333f, 0.19897676f, 0.07766984f, 0.19410589f, 0.07731923f, -0.12056299f, -0.16029827f, -0.01785973f, 
    -0.00981263f, -0.08865965f, -0.04030114f, 0.03120528f, -0.00300429f, 0.19794939f, 0.08944449f, 0.04797847f, 
    -0.18019684f, -0.06143947f, -0.13151070f, 0.07559633f, 0.00600133f, -0.02842981f, -0.00707628f, -0.00233290f, 
    -0.04540446f, -0.06675807f, -0.06960671f, -0.07630903f, -0.24704933f, 0.28339112f, -0.07014199f, -0.27907118f, 
    0.22293727f, 0.04219358f, 0.10657908f, -0.09437849f, -0.01325080f, 0.06223960f, 0.00866133f, 0.14955147f, 
    -0.49333248f, 0.48781070f, 0.17302105f, 0.12471544f, 0.08697938f, 0.00106299f, 0.02315443f, 0.05313938f, 
    -0.07232375f, -0.02533231f, 0.21123804f, 0.03955399f, -0.04984732f, 0.15162435f, 0.16871434f, -0.04123595f, 
    0.03359312f, 0.07962874f, 0.05147457f, -0.01913566f, -0.07563832f, -0.02301748f, 0.01365721f, -0.08226964f, 
    0.04998139f, 0.09044041f, -0.10900220f, -0.07301376f, 0.03005760f, -0.10807939f, -0.04025607f, -0.06011372f, 
    -0.05502944f, 0.12918477f, -0.08541030f, -0.03580984f, 0.20379829f, 0.13164192f, 0.43110001f, -0.40106389f, 
    -0.15826805f, -0.05104601f, -0.20913191f, 0.17865989f, -0.11521606f, -0.10358264f, -0.06168593f, 0.02057929f, 
    0.31013450f, -0.25411493f, 0.10540124f, 0.15102272f, 0.13362184f, -0.03093242f, -0.04466588f, -0.04057614f, 
    0.05520947f, 0.12915014f, 0.05824591f, 0.10750987f, -0.31066820f, -0.24883008f, -0.14302057f, 0.07403281f, 
    -0.02722958f, 0.02043773f, 0.09685844f, 0.01600959f, 0.03287756f, 0.02773326f, 0.05238197f, -0.03441224f, 
    -0.16004416f, 0.06404451f, -0.10292973f, 0.08629798f, 0.05978604f, 0.15281561f, 0.08450080f, 0.07438728f, 
    0.02086502f, 0.03995654f, 0.20790216f, 0.05115442f, -0.05729645f, 0.09812970f, -0.28298044f, 0.23220369f, 
    -0.05324192f, 0.21404690f, 0.06196136f, 0.04615828f, 0.24388628f, 0.07257858f, -0.00813424f, 0.05782422f, 
    0.50843424f, -0.03321533f, -0.08815150f, -0.15861322f, 0.02961667f, 0.04104393f, -0.13058835f, 0.01801417f, 
    0.04139110f, 0.23130031f, -0.06367139f, -0.03348663f, 0.34191802f, 0.15085509f, 0.36356872f, 0.05885092f, 
    -0.00407199f, 0.04476405f, -0.09801171f, -0.12604447f, 0.03244979f, -0.07950002f, -0.07884943f, 0.11980373f, 
    0.15132767f, 0.09346499f, 0.00425400f, -0.32350188f, 0.16080154f, -0.06147606f, -0.01687323f, 0.03121509f, 
    -0.11831288f, 0.09262805f, 0.06331697f, 0.06739423f, 0.04887183f, 0.20539820f, 0.18896948f, 0.30994859f, 
    0.13345139f, 0.14707728f, -0.08488350f, 0.15998453f, 0.01647859f, -0.17334189f, 0.04185375f, -0.10690999f, 
    -0.17859188f, -0.01393778f, -0.46697187f, 0.24542253f, 0.00654304f, 0.04712014f, 0.29729372f, 0.01844257f, 
    0.20928273f, -0.05680816f, -0.13712206f, 0.03089072f, 0.21178822f, -0.05446123f, 0.06573068f, -0.13644415f, 
    -0.04628832f, 0.05015672f, -0.05844956f, -0.07694501f, -0.03239802f, 0.11770949f, 0.18558790f, 0.23130001f, 
    0.14207241f, -0.05932584f, 0.10802411f, 0.28325769f, 0.21095911f, 0.37427342f, 0.12016436f, 0.15091629f, 
    -0.01896723f, 0.12657900f, 0.05320948f, 0.17909674f, 0.37153760f, 0.03599905f, -0.03439705f, -0.59445643f, 
    -0.10691458f, -0.04124393f, 0.02174902f, 0.05192365f, 0.10510539f, -0.12325903f, -0.22098675f, -0.03235923f, 
    0.24882257f, 0.25292751f, -0.14538363f, -0.18246694f, 0.11230205f, -0.06137899f, -0.02807580f, 0.17467770f, 
    0.07999185f, -0.10726494f, -0.13323984f, -0.00836638f, -0.19214220f, 0.07862832f, 0.18081191f, 0.14886661f, 
    -0.05732588f, -0.00785991f, -0.04718607f, -0.10664871f, 0.06403255f, -0.06455923f, 0.05656826f, -0.10709157f, 
    -0.10037358f, 0.06170081f, -0.02630013f, -0.05181845f, 0.01149442f, 0.09488194f, -0.12836149f, 0.00326596f, 
    -0.05115007f, 0.02848782f, 0.21273123f, 0.16810724f, -0.25326902f, 0.16810401f, 0.17122243f, 0.17397904f, 
    -0.09944197f, -0.16556783f, -0.01209511f, 0.02769222f, 0.17132366f, 0.01505160f, 0.01909618f, -0.03703792f, 
    0.38135621f, -0.18186432f, -0.17487597f, 0.47830066f, 0.13062155f, 0.11381914f, 0.09823695f, 0.23891446f, 
    -0.08527985f, -0.10300966f, -0.11909448f, -0.14689808f, 0.08298882f, -0.02961391f, 0.19491942f, 0.32004780f, 
    0.13536452f, -0.07357672f, -0.15890904f, -0.16959615f, -0.10824737f, -0.27323198f, 0.02930878f, -0.06563737f, 
    0.26980132f, 0.17671554f, 0.10987654f, 0.18145996f, 0.22624639f, -0.12314145f, 0.18382478f, 0.03349877f, 
    -0.01662888f, -0.10838659f, 0.23104227f, -0.03896828f, -0.22436826f, 0.00035781f, 0.05858645f, -0.26129445f, 
    0.07349458f, -0.07491817f, -0.07432316f, -0.04175711f, -0.07639895f, 0.15941872f, 0.19657820f, 0.12350146f, 
    0.05242689f, -0.03232565f, 0.13154674f, -0.20063497f, -0.12518229f, -0.21441071f, 0.12134747f, -0.17229983f, 
    -0.18002731f, 0.24877687f, 0.00245361f, 0.18125318f, -0.01963281f, 0.33709049f, 0.07512251f, 0.24961473f, 
    0.04714482f, 0.04870885f, -0.06422108f, -0.12319373f, 0.18743050f, -0.08411984f, 0.09131616f, 0.00038960f, 
    -0.10862698f, -0.02668982f, -0.00491319f, 0.26603872f, -0.12392484f, 0.04431421f, -0.11790591f, -0.15791239f, 
    0.25449908f, 0.07309661f, 0.13630006f, -0.03232748f, -0.25574917f, -0.24882863f, -0.12234623f, -0.28134355f, 
    -0.20794530f, -0.00302816f, 0.05430714f, -0.15226857f, -0.13419639f, 0.00205292f, -0.01358676f, 0.02083482f, 
    0.22421901f, 0.36640584f, 0.08242771f, -0.06613585f, -0.12197807f, 0.00696875f, 0.03867535f, 0.05087114f, 
    -0.09429072f, -0.12849998f, -0.16453470f, -0.06265466f, -0.09479584f, 0.15105161f, 0.10501175f, 0.05709437f, 
    -0.12807612f, 0.18421379f, -0.07044090f, 0.00751102f, -0.01174576f, 0.02959948f, 0.08318494f, 0.11054979f, 
    -0.28846139f, -0.14747840f, -0.09475920f, 0.28491634f, -0.26800105f, -0.08289995f, 0.15198396f, 0.04083196f, 
    -0.16060595f, -0.09537813f, 0.01885927f, 0.03194724f, -0.11826940f, -0.21082848f, 0.28538889f, 0.45134413f, 
    -0.07248995f, 0.07524960f, -0.01606277f, 0.06527515f, 0.21018292f, -0.00491426f, 0.10547574f, 0.12888905f, 
    -0.17052941f, 0.09739454f, -0.38696781f, 0.41825816f, 0.07636596f, 0.22653425f, 0.14026168f, 0.12225175f, 
    0.04093843f, 0.03834431f, 0.05345781f, -0.04620119f, 0.28065908f, 0.15511858f, -0.20355648f, -0.09696864f, 
    -0.09515601f, -0.16184029f, -0.08102048f, 0.20055147f, -0.02517276f, -0.06196965f, -0.14542854f, 0.16331309f, 
    0.04599275f, 0.06632539f, 0.12787689f, 0.00654427f, 0.12074438f, 0.00921729f, -0.02097656f, -0.02440142f, 
    -0.05215963f, -0.06668603f, 0.09969418f, 0.01739471f, 0.24446964f, 0.02585863f, -0.05674902f, 0.09718879f, 
    -0.10770440f, -0.03138069f, -0.01584658f, -0.14646216f, -0.04780192f, 0.10095055f, -0.02175507f, 0.07254936f, 
    -0.01420203f, 0.31583151f, 0.06005787f, 0.03084094f, 0.04261663f, 0.06688282f, 0.26654544f, -0.01663025f, 
    0.07881181f, 0.03649350f, -0.09803073f, -0.01566072f, -0.00031335f, 0.09426256f, 0.07273164f, -0.01136859f, 
    -0.04118329f, -0.15305950f, -0.11944290f, 0.18826626f, 0.00608883f, 0.02125453f, -0.32860458f, -0.02461909f, 
    -0.08931033f, -0.32948655f, 0.17460454f, -0.04282933f, -0.03892934f, 0.14636949f, -0.02544272f, 0.26573214f, 
    -0.11119409f, 0.15310949f, -0.31113887f, 0.14461312f, -0.06632392f, 0.17353716f, -0.00429060f, 0.22427870f, 
    0.03037315f, -0.05771866f, -0.01393391f, -0.02108170f, -0.06496570f, 0.07185482f, -0.06478383f, 0.07194650f, 
    -0.49611977f, 0.20444077f, 0.06356240f, 0.12068380f, 0.12674154f, 0.38696346f, 0.01173252f, 0.05398686f, 
    0.04973172f, 0.03690228f, 0.22776578f, 0.01308583f, 0.15887500f, -0.05101618f, 0.19394922f, 0.02819954f, 
    -0.09928104f, 0.01704777f, 0.17871219f, -0.09006726f, -0.12525880f, 0.07410056f, -0.01855701f, 0.07576276f, 
    0.04981895f, -0.01449356f, -0.00195877f, 0.22449876f, -0.13581024f, -0.06143865f, -0.03240731f, -0.13469030f, 
    0.27953309f, 0.26990709f, -0.01302444f, -0.07951956f, -0.08967674f, 0.17499295f, -0.09570045f, 0.03463002f, 
    -0.02266579f, 0.03930333f, 0.22972584f, -0.02860400f, 0.00305515f, 0.05107877f, -0.17770073f, -0.01590504f, 
    0.30969217f, -0.02683659f, 0.13976547f, 0.06631672f, 0.22102231f, -0.00681426f, 0.04087578f, -0.01618795f, 
    -0.13844348f, 0.03760726f, -0.00361650f, 0.31416953f, 0.02663853f, 0.37721264f, -0.00541786f, -0.17334101f, 
    -0.05841496f, 0.05277296f, 0.02096394f, -0.04771025f, -0.07466245f, -0.05476812f, -0.14553538f, -0.10809974f, 
    0.04091011f, 0.11866343f, -0.31643009f, -0.07753368f, -0.18118383f, -0.02858642f, 0.08421239f, -0.06887465f, 
    -0.05891190f, 0.01267615f, 0.00295686f, -0.01289658f, 0.21686056f, 0.14241739f, 0.12490461f, 0.12932838f, 
    -0.11643073f, 0.09225908f, -0.08063309f, -0.12384164f, -0.16163574f, 0.10085247f, 0.03040998f, 0.08423524f, 
    -0.18533720f, 0.08496444f, -0.36000183f, 0.06927012f, 0.00299745f, -0.01947803f, 0.07089044f, 0.24165274f, 
    -0.10233958f, -0.03913391f, 0.09196571f, -0.14305200f, 0.10326647f, 0.19982788f, 0.27071539f, 0.12523580f, 
    0.05921764f, -0.17447972f, 0.09578447f, -0.01776513f, 0.12422016f, -0.06861489f, -0.04779457f, 0.21708915f, 
    -0.04225961f, -0.07828122f, 0.04215963f, 0.12002518f, 0.17715983f, -0.00664489f, -0.03043035f, -0.15281372f, 
    -0.08410484f, 0.04296880f, 0.05468479f, -0.00773973f, 0.42929417f, 0.27056283f, -0.06702948f, 0.35812214f, 
    -0.07020331f, -0.24569243f, -0.24302912f, -0.12134071f, -0.03852902f, 0.06802136f, -0.07800246f, -0.00731366f, 
    0.20411457f, -0.25474459f, -0.03146895f, 0.12493864f, -0.00321515f, 0.09818738f, 0.04406466f, 0.01144036f, 
    -0.02854394f, 0.07125527f, 0.01183511f, -0.02860495f, -0.02062971f, -0.10731415f, -0.09799259f, 0.24672259f, 
    0.08057765f, 0.01860058f, 0.03093392f, 0.06378005f, 0.07734483f, 0.22585595f, -0.07073640f, 0.06808494f, 
    -0.03596870f, -0.19993100f, -0.19018835f, -0.00880181f, -0.07533704f, 0.16294748f, -0.04192704f, 0.19845517f, 
    -0.06707297f, 0.30337298f, -0.04039732f, -0.04705169f, 0.05421785f, -0.06482005f, 0.10466503f, 0.15725592f, 
    -0.05232830f, -0.13300863f, -0.12594116f, -0.03894687f, 0.04941934f, 0.00584816f, -0.26043099f, -0.00775715f, 
    0.34232947f, 0.39131686f, -0.24886976f, -0.04782888f, 0.17479782f, 0.09154480f, -0.10918886f, -0.16087912f, 
    -0.19726261f, -0.08675721f, 0.09637859f, 0.10848793f, 0.02005571f, 0.07461151f, 0.18304765f, 0.18950047f, 
    -0.19467315f, 0.00839293f, 0.14140619f, -0.02578608f, -0.01409251f, 0.09838586f, -0.09551141f, -0.04467652f, 
    -0.01882585f, 0.25235370f, -0.10569277f, -0.09787328f, 0.09287452f, -0.05526720f, -0.02739208f, 0.00818295f, 
    -0.15071297f, 0.07067879f, 0.30040127f, 0.00664203f, 0.09125084f, -0.13693434f, 0.07635591f, 0.00398282f, 
    -0.07448804f, -0.03535756f, 0.02413370f, -0.10506104f, -0.08103570f, 0.11893508f, -0.04327035f, 0.04564342f, 
    -0.40850636f, 0.01450836f, -0.33357477f, 0.19881353f, 0.06454755f, 0.13503173f, 0.05669362f, 0.09674960f, 
    0.17923646f, 0.15297174f, 0.04658217f, -0.00289929f, -0.10139258f, -0.05255989f, -0.02254797f, 0.02898770f, 
    -0.07939361f, 0.09256905f, 0.01758829f, 0.02617938f, -0.02192037f, 0.20897424f, -0.01324407f, 0.04960696f, 
    0.07468759f, 0.10497680f, -0.20358032f, 0.01107392f, -0.00961720f, 0.11642777f, 0.05220493f, -0.05974245f, 
    0.03984685f, 0.01642061f, -0.02067263f, 0.03610527f, -0.02589292f, 0.02503621f, -0.21417461f, -0.30863380f, 
    0.03478619f, 0.00762027f, 0.18866125f, -0.14921452f, 0.15867127f, 0.05170342f, -0.00908016f, 0.23639534f, 
    -0.16551979f, 0.80787873f, 0.00330756f, 0.05902652f, 0.13198534f, 0.00386961f, -0.13587701f, -0.04026935f, 
    0.16639189f, -0.01299584f, 0.03138843f, 0.05187245f, 0.02208306f, 0.12135072f, 0.23463745f, 0.13396376f, 
    -0.15192525f, -0.09849183f, -0.06382348f, -0.00674724f, -0.00757689f, 0.03679633f, 0.01816974f, -0.12286369f, 
    0.00747069f, 0.01133714f, -0.02491760f, 0.03597224f, 0.15094042f, -0.17447470f, 0.01867246f, -0.02023399f, 
    -0.08826073f, -0.04906814f, 0.05333301f, -0.06003004f, 0.28009164f, 0.29634714f, 0.44554970f, -0.02395612f, 
    -0.16408104f, -0.16677637f, -0.20344616f, 0.07964705f, -0.09846108f, -0.00482634f, -0.00225387f, 0.00224354f, 
    0.28004137f, -0.16133153f, -0.02839538f, 0.24539690f, 0.11289313f, 0.04024942f, 0.04912826f, 0.04708118f, 
    -0.04283353f, 0.03284606f, 0.07832926f, -0.01102152f, -0.05285257f, -0.22203037f, -0.13064620f, 0.17325707f, 
    -0.09149715f, 0.09950402f, -0.05206849f, 0.00219145f, 0.05175985f, -0.10190445f, 0.02600867f, -0.00987390f, 
    0.07984034f, 0.16003777f, -0.09908655f, 0.01433393f, -0.13656177f, -0.05346504f, 0.01755793f, 0.01767926f, 
    -0.10318744f, 0.17702027f, 0.03941230f, 0.20614059f, -0.12184636f, 0.22989656f, -0.16064547f, 0.16320793f, 
    -0.02525773f, -0.07736743f, -0.00605157f, -0.01052947f, 0.05001629f, -0.02685818f, -0.15681902f, 0.13213150f, 
    0.26223481f, 0.04601191f, 0.10667764f, -0.08124375f, 0.01011878f, 0.00754007f, -0.08590800f, 0.16421568f, 
    -0.11495608f, 0.29601985f, 0.14575884f, -0.00011767f, 0.17639980f, 0.34642383f, 0.35550508f, 0.02994832f, 
    -0.16993479f, -0.02707921f, -0.12090113f, -0.13837741f, 0.02029797f, -0.08637138f, -0.07052663f, 0.04625210f, 
    -0.24570294f, 0.03175851f, -0.28186572f, 0.23441254f, -0.00886945f, 0.04187207f, 0.09737923f, -0.06009053f, 
    0.25301230f, 0.03169712f, -0.03310980f, 0.04241369f, 0.25166634f, 0.13807864f, 0.39076710f, 0.37293902f, 
    -0.14355974f, 0.04829924f, 0.12152191f, 0.05599256f, -0.06509881f, -0.03365953f, -0.10019325f, -0.05243896f, 
    0.28283173f, 0.19646110f, 0.12897126f, 0.19990616f, 0.20951849f, 0.03244267f, 0.09780510f, 0.05575193f, 
    0.00078808f, -0.03059792f, -0.08121718f, 0.19492319f, -0.08876226f, 0.13176098f, 0.15072757f, -0.15739632f, 
    0.10260960f, 0.08562577f, -0.08902621f, -0.11547714f, 0.01359013f, -0.05831129f, -0.16775472f, -0.11770250f, 
    0.03941983f, 0.22821493f, 0.20255230f, 0.14994854f, -0.20256123f, -0.03969833f, -0.18286593f, 0.03973063f, 
    -0.03647099f, 0.02497132f, 0.03542940f, -0.08152976f, -0.47196949f, 0.21319380f, -0.09813980f, 0.09218551f, 
    0.20303480f, 0.09385294f, -0.06547139f, -0.00498516f, -0.13005905f, 0.08860839f, -0.00501170f, 0.14963506f, 
    -0.49423274f, -0.14582720f, -0.05276261f, 0.42652804f, 0.08692123f, 0.00195700f, 0.09101262f, -0.06801688f, 
    -0.08356280f, -0.11052043f, -0.14163844f, -0.17309974f, 0.31784543f, 0.09353555f, 0.01172269f, 0.06526331f, 
    -0.13702257f, 0.12213694f, 0.12078093f, 0.08761431f, 0.07149858f, 0.10737025f, 0.09458465f, 0.07548311f, 
    0.09488782f, 0.12175796f, -0.01811378f, 0.18152353f, 0.05069039f, 0.23383500f, 0.11665606f, -0.04739930f, 
    -0.04958576f, 0.04804074f, -0.02132408f, -0.13848679f, 0.24389754f, -0.18219198f, -0.05752600f, 0.03059884f, 
    -0.25148919f, 0.06623726f, -0.10145073f, -0.05982117f, 0.00350301f, 0.14250046f, 0.01716780f, -0.03961328f, 
    0.49563414f, -0.47472769f, 0.03938055f, 0.09853720f, 0.15762652f, -0.07439652f, 0.05707704f, 0.09394747f, 
    0.02550535f, 0.03465397f, 0.16544640f, 0.14588356f, 0.01098801f, -0.05542499f, 0.08113249f, 0.28753102f, 
    0.09028697f, -0.03048885f, 0.12059218f, 0.16320892f, 0.20976064f, 0.22106938f, 0.07445068f, 0.19547600f, 
    -0.10941811f, 0.00378472f, 0.07116819f, 0.15990008f, 0.17570758f, 0.12965426f, 0.06733388f, -0.01159700f, 
    0.00672050f, 0.06339831f, 0.02941393f, -0.12577808f, -0.05981502f, 0.09606432f, -0.12215199f, 0.05617882f, 
    -0.14161795f, -0.15166496f, 0.12850671f, 0.01676979f, 0.15397763f, -0.01056355f, -0.01931904f, 0.14353383f, 
    -0.20626572f, 0.15783569f, -0.28174025f, -0.07874586f, -0.08961188f, -0.03033063f, -0.15564959f, -0.16996349f, 
    0.11172650f, 0.02106724f, 0.12556961f, 0.01569116f, 0.16731218f, -0.16543759f, -0.07935660f, 0.00895359f, 
    -0.13195686f, 0.04478228f, -0.16775484f, 0.05939728f, -0.08907993f, 0.03487246f, -0.15000865f, -0.10374928f, 
    -0.18820754f, -0.08769280f, -0.21346864f, 0.05994560f, -0.10435907f, 0.13073893f, 0.03844596f, -0.08475521f, 
    0.12612720f, 0.11701632f, 0.12698770f, 0.02294083f, 0.06532104f, 0.34382823f, 0.07121687f, 0.06501089f, 
    -0.06793793f, -0.01806369f, 0.13990626f, 0.13023113f, -0.10169099f, -0.05172472f, 0.06837696f, 0.02767251f, 
    0.38072559f, 0.27860367f, 0.30371815f, 0.23396842f, 0.04577511f, 0.08382084f, 0.16022100f, 0.13513125f, 
    -0.18387498f, 0.06975591f, -0.08129643f, 0.07057471f, -0.06087022f, 0.08939347f, -0.14555156f, -0.08285335f, 
    0.01955106f, 0.17676790f, 0.03242142f, -0.07215468f, 0.07474219f, -0.02466509f, -0.19725756f, -0.15297949f, 
    0.05254460f, 0.17371103f, 0.10855943f, 0.30392644f, -0.36281213f, -0.08296068f, 0.09741411f, 0.01226420f, 
    0.05637699f, -0.01519348f, -0.03653608f, -0.01498317f, -0.17353110f, -0.16725287f, -0.21725091f, -0.03316636f, 
    -0.02603376f, 0.06453842f, -0.06508771f, -0.00902185f, -0.13222522f, 0.10066108f, -0.10515187f, 0.07987040f, 
    -0.32713228f, -0.07732714f, -0.17643908f, 0.06584520f, -0.05973729f, 0.12459460f, 0.03451427f, -0.08657617f, 
    -0.13709491f, 0.01544232f, 0.06522563f, -0.02078729f, -0.12866019f, 0.04445782f, -0.24220061f, -0.24824148f, 
    -0.07475194f, -0.00310026f, 0.01448610f, 0.09068947f, 0.06942834f, 0.16650122f, 0.02250996f, 0.11112294f, 
    -0.01758196f, -0.03924477f, -0.05806339f, -0.00237081f, 0.11863091f, 0.07864075f, 0.01043721f, 0.11694783f, 
    -0.00101313f, 0.04225688f, 0.07395733f, -0.07958677f, -0.24100578f, -0.40808648f, -0.35400760f, -0.09821734f, 
    -0.06199598f, -0.11538648f, 0.01213170f, -0.06314928f, 0.10162581f, 0.12531351f, 0.01130745f, 0.09779379f, 
    0.25414810f, 0.12609877f, 0.13309951f, 0.27895063f, 0.17865114f, -0.03703906f, -0.00776390f, -0.07128342f, 
    -0.03158690f, 0.16527380f, 0.10303686f, 0.03279898f, 0.11593415f, 0.05707765f, 0.15841173f, 0.24045219f, 
    -0.05946991f, -0.11651814f, -0.12580228f, 0.16412398f, 0.09471498f, 0.18530670f, -0.02400661f, 0.22622666f, 
    0.09058874f, 0.03775978f, -0.06604019f, 0.12368148f, -0.12752180f, 0.00848722f, -0.12577513f, 0.05712667f, 
    0.05226891f, 0.07610913f, -0.13175920f, 0.03138119f, -0.07871279f, -0.14085108f, -0.05441887f, 0.09365398f, 
    0.02812460f, -0.11367855f, 0.08812678f, 0.04510875f, 0.11460003f, 0.09997343f, -0.11321433f, 0.21716265f, 
    -0.15955283f, -0.03088481f, -0.25177732f, -0.24845897f, 0.01637652f, -0.01392675f, 0.05601498f, -0.15541287f, 
    0.09542558f, -0.06633691f, 0.19151089f, 0.09698516f, -0.04927558f, -0.20866065f, -0.10511604f, -0.08475578f, 
    -0.01324797f, 0.03260324f, 0.05785254f, -0.04698683f, 0.03649370f, -0.00600263f, 0.04479924f, -0.12319224f, 
    0.18489374f, 0.04740740f, 0.13652717f, 0.09811340f, -0.14255501f, 0.02570707f, -0.07525279f, -0.00462596f, 
    0.11668020f, 0.07623133f, 0.00219761f, 0.02570452f, -0.00213878f, 0.31366673f, -0.22112529f, -0.31127846f, 
    -0.14990079f, -0.22783671f, 0.10012747f, 0.09583917f, -0.01864520f, -0.04696820f, -0.16517344f, -0.07177350f, 
    0.13989820f, 0.08597261f, 0.27003503f, -0.14232481f, -0.04384252f, 0.07807953f, 0.22927508f, 0.13696960f, 
    -0.00707886f, 0.13971379f, -0.02548545f, -0.00575351f, -0.02403291f, 0.12306304f, 0.05124148f, -0.01562170f, 
    -0.02032985f, 0.02750014f, 0.02183679f, -0.01054191f, -0.06707198f, 0.06625220f, -0.16536717f, 0.04498473f, 
    -0.15432817f, 0.07456640f, -0.23788254f, 0.14422923f, -0.19218260f, -0.10516738f, 0.37305596f, -0.07909300f, 
    -0.14536569f, -0.11188442f, -0.08421686f, -0.13343121f, 0.30943015f, -0.17845087f, 0.31638756f, 0.25405306f, 
    -0.17989324f, 0.01783670f, -0.11991676f, 0.01257610f, 0.09236480f, 0.25486484f, 0.07491526f, 0.12475307f, 
    -0.05920172f, -0.05868298f, -0.21792583f, -0.10045797f, -0.02413990f, -0.08141971f, -0.13624942f, 0.22988941f, 
    -0.08145276f, 0.10348268f, -0.01621724f, -0.02835149f, 0.30559447f, 0.18791465f, 0.10772380f, 0.16751613f, 
    0.00798359f, 0.00487401f, -0.05378908f, -0.06733071f, 0.14577267f, -0.04794201f, 0.05975913f, 0.09254017f, 
    0.09689973f, 0.13416836f, 0.07809447f, 0.11153304f, 0.03939127f, -0.07375711f, -0.20166491f, 0.03373649f, 
    -0.04457046f, -0.09252372f, -0.02650904f, -0.15049313f, 0.25816730f, 0.27227038f, 0.04568774f, 0.22412027f, 
    -0.00341521f, -0.25255659f, -0.08099969f, -0.06552369f, -0.07413711f, -0.07350764f, -0.05030903f, -0.02090615f, 
    -0.20962164f, 0.28039896f, 0.07530988f, 0.09762980f, -0.04045029f, -0.04725967f, 0.10466009f, -0.11334278f, 
    -0.01414394f, 0.06212396f, -0.03979971f, -0.09138477f, -0.18788025f, -0.05871649f, 0.24200016f, 0.05177272f, 
    -0.07862049f, 0.06310285f, -0.06051958f, -0.07537015f, 0.05253901f, -0.04166683f, 0.02662878f, 0.07297856f, 
    -0.16325818f, -0.10400267f, -0.05262037f, -0.10406618f, 0.01276150f, 0.05333252f, -0.16598453f, 0.34563160f, 
    0.13296302f, 0.11122220f, -0.12807728f, 0.11651258f, 0.14341569f, -0.11447856f, 0.10189417f, 0.03795446f, 
    0.20457363f, -0.04235432f, -0.05108620f, -0.00914619f, -0.01048045f, 0.02473998f, -0.05843920f, -0.10281449f, 
    -0.16454282f, -0.17104281f, 0.05582015f, 0.11955761f, 0.26316622f, 0.08549955f, -0.09925826f, 0.01444979f, 
    -0.06531073f, -0.00521838f, 0.07568676f, 0.15214492f, 0.43678594f, 0.19727130f, 0.21126623f, 0.02722793f, 
    -0.00672875f, -0.05192653f, 0.17389883f, -0.07035421f, 0.01206938f, -0.00512930f, -0.05576486f, -0.08829726f, 
    0.02160673f, 0.04084132f, -0.02547712f, 0.13145056f, -0.14147870f, 0.03311781f, -0.12027649f, 0.02317948f, 
    -0.01019222f, -0.00944443f, 0.21696177f, 0.02257708f, 0.03280628f, 0.28666604f, -0.28461394f, -0.33802381f, 
    -0.05601855f, -0.08372466f, -0.04249328f, 0.00640872f, -0.10756552f, 0.03111793f, -0.00764892f, -0.10828998f, 
    0.29904416f, -0.23433925f, 0.07337386f, -0.30325156f, -0.04598043f, 0.05935456f, -0.10282428f, -0.07197784f, 
    0.02456941f, -0.09824116f, 0.06924994f, 0.04906638f, -0.14192629f, 0.03839115f, 0.07956421f, 0.12049790f, 
    0.04292848f, 0.14420871f, -0.00387233f, -0.08129855f, -0.02614303f, -0.00981859f, -0.13843632f, -0.00436230f, 
    0.16116555f, 0.29922301f, -0.06038868f, 0.00300412f, 0.14872280f, -0.07783016f, 0.23001811f, 0.01962089f, 
    -0.04927486f, -0.09022692f, -0.02886097f, -0.09086168f, -0.03197945f, 0.01036022f, -0.12355295f, 0.27288848f, 
    -0.00235557f, 0.06732335f, 0.07506606f, 0.04380579f, -0.02161761f, -0.02112506f, -0.06353709f, 0.16253290f, 
    0.12288854f, 0.32092205f, -0.11431952f, -0.19555216f, 0.04947423f, 0.08272217f, -0.08470511f, 0.01020259f, 
    0.02148546f, -0.08234170f, 0.06222525f, -0.06584394f, 0.07173333f, 0.07197820f, 0.00643501f, 0.14482896f, 
    -0.07662658f, -0.01041122f, 0.05005388f, 0.18147719f, -0.00091698f, 0.06127838f, 0.02708476f, 0.01179723f, 
    -0.05581386f, -0.00641012f, -0.00313207f, -0.04670237f, 0.11110079f, 0.06769738f, -0.04544251f, 0.03263882f, 
    -0.06584697f, -0.18450138f, -0.11279558f, -0.07409426f, 0.16810901f, 0.17240573f, 0.33435866f, 0.26669747f, 
    0.04587489f, -0.05471388f, -0.15210357f, -0.04481718f, -0.07300875f, -0.04214418f, -0.02216609f, 0.08864672f, 
    0.03721905f, 0.43707094f, 0.16014415f, -0.23669860f, 0.01181419f, 0.17251022f, 0.11861162f, -0.02010027f, 
    0.02490719f, -0.01115491f, -0.10082178f, 0.12754674f, 0.21632701f, 0.10670489f, 0.13475141f, -0.04640849f, 
    0.16544127f, -0.08173424f, -0.14474253f, 0.13318750f, 0.06020815f, 0.08944897f, 0.05704403f, -0.03680633f, 
    0.01645496f, 0.20017409f, -0.37617582f, -0.15836401f, -0.13901244f, -0.09290159f, -0.22310218f, 0.26829609f, 
    0.07859164f, 0.12258393f, -0.18845817f, 0.17097618f, 0.05156054f, 0.01771699f, 0.06405010f, 0.14990342f, 
    -0.06401049f, -0.11890469f, -0.10997048f, 0.05951440f, 0.14745705f, 0.04650490f, -0.23190792f, 0.01015814f, 
    -0.49377418f, 0.17042528f, 0.34549928f, 0.16682282f, 0.12594615f, 0.19506828f, 0.04014881f, 0.18057856f, 
    0.01775816f, 0.13856557f, 0.08742581f, -0.00076912f, 0.32557988f, -0.09479141f, 0.15707955f, 0.24432142f, 
    -0.12445366f, -0.07284751f, -0.08907048f, 0.00455025f, -0.11345836f, -0.02083059f, -0.05086159f, 0.02058284f, 
    -0.13950229f, 0.15368307f, -0.31665716f, -0.04295417f, -0.01219169f, 0.00982439f, -0.21038374f, -0.37706310f, 
    -0.08488867f, 0.06909831f, 0.13822745f, 0.00039311f, -0.00809471f, 0.01365594f, 0.03698841f, 0.17887571f, 
    0.06265134f, 0.22632225f, -0.01382535f, 0.05574974f, 0.10133815f, 0.03293618f, 0.19962512f, 0.00214598f, 
    0.15868880f, -0.12297243f, -0.41399366f, 0.01214713f, 0.07147574f, 0.11244719f, 0.03851726f, 0.02667374f, 
    0.18230556f, -0.06778088f, -0.03535486f, 0.03009192f, -0.16526251f, 0.11261825f, 0.08432875f, -0.23733193f, 
    -0.19580996f, 0.06569773f, -0.00926764f, -0.08260004f, 0.15865853f, 0.03659917f, 0.18833323f, 0.17071147f, 
    0.16287389f, 0.12956333f, -0.04257957f, 0.18751439f, 0.18121338f, 0.22925295f, 0.18527806f, 0.27282563f, 
    -0.05245214f, 0.07972489f, 0.02323701f, 0.12495904f, 0.08545291f, 0.01080950f, -0.00023397f, -0.14173293f, 
    -0.07551765f, -0.04710955f, -0.23476996f, -0.20597261f, 0.17516057f, -0.01764287f, 0.11425588f, 0.09469055f, 
    0.10326222f, 0.34894088f, -0.54026824f, -0.11061200f, 0.13113697f, 0.15329397f, 0.15920639f, 0.06178530f, 
    0.18799597f, -0.06533319f, 0.02016108f, 0.02167530f, -0.00674683f, -0.02067224f, -0.01439546f, 0.07970578f, 
    -0.07716724f, -0.14257646f, -0.21926583f, 0.00515040f, -0.14832002f, -0.00725744f, -0.11141048f, -0.17912462f, 
    -0.12935130f, -0.05056774f, 0.06982254f, -0.08301285f, -0.05838902f, 0.25630006f, -0.07135925f, 0.02203678f, 
    0.04628275f, 0.08830854f, 0.32384801f, 0.29321125f, -0.25078613f, 0.25520912f, 0.27668166f, 0.24032970f, 
    -0.23219140f, -0.18529099f, -0.05128834f, -0.18230245f, -0.06338254f, -0.04222856f, -0.06998754f, -0.08376241f, 
    0.60976714f, 0.27698964f, 0.00494983f, 0.21761489f, 0.17578700f, 0.33955136f, 0.08546440f, 0.07587546f, 
    0.01896849f, 0.02018456f, -0.25529370f, -0.03557110f, 0.35161820f, 0.00023027f, -0.12201295f, 0.32238632f, 
    0.29434517f, -0.07675220f, -0.22999330f, 0.15673609f, -0.12265636f, -0.06501617f, -0.11380505f, -0.06161262f, 
    0.35447919f, 0.05553502f, -0.10554845f, -0.01787411f, 0.14491758f, -0.01997279f, 0.25627697f, 0.31878334f, 
    -0.00198058f, -0.01564646f, -0.07772705f, 0.08178261f, -0.14043960f, 0.20945102f, -0.02880541f, -0.10682014f, 
    0.06876010f, -0.27328527f, -0.09511521f, -0.11530791f, -0.10912860f, 0.20668857f, 0.01768598f, 0.04911633f, 
    -0.24701686f, 0.48667157f, 0.36380762f, -0.25791451f, 0.05145813f, 0.01219222f, 0.10154507f, -0.11554242f, 
    -0.09900146f, 0.06599907f, -0.06400503f, 0.07360905f, 0.07434850f, 0.09190828f, 0.03121101f, 0.31335613f, 
    -0.13873991f, 0.04979753f, 0.02337957f, -0.09969135f, 0.08759497f, -0.04858323f, 0.01244847f, 0.04373270f, 
    -0.05826290f, 0.01017491f, -0.02227844f, -0.00279432f, -0.06787742f, 0.05283007f, 0.02091536f, -0.06051793f, 
    0.01621013f, 0.03216756f, -0.04423180f, -0.06029407f, -0.03705459f, -0.01949172f, -0.07681854f, 0.05266272f, 
    -0.00226283f, -0.08166150f, -0.08717686f, -0.04172194f, -0.08001711f, -0.03375528f, -0.01975632f, -0.00192629f, 
    -0.03471218f, -0.04635110f, -0.06336033f, -0.04934396f, 0.03548864f, 0.03397273f, 0.00826462f, 0.05481536f, 
    -0.03282951f, 0.04633959f, -0.07043870f, -0.04553769f, 0.01596288f, 0.03602692f, -0.06396446f, -0.01643826f, 
    0.04186082f, -0.06692649f, -0.05247202f, -0.04642252f, 0.04877386f, 0.01121024f, 0.00397557f, -0.03999837f, 
    0.03573309f, 0.01758381f, 0.00412904f, -0.00156258f, -0.04224760f, 0.00762723f, 0.01497939f, 0.01749402f, 
    -0.05840004f, -0.07481669f, -0.01548686f, -0.03836140f, 0.02616459f, 0.01454287f, -0.05489789f, -0.02783214f, 
    0.04325174f, -0.07453436f, -0.03594751f, -0.00739914f, 0.04907193f, -0.04971462f, 0.05240026f, 0.01574400f, 
    -0.06041672f, 0.05374836f, 0.05032938f, -0.05932303f, -0.04948924f, -0.04098897f, -0.06307612f, -0.00834322f, 
    0.03420098f, 0.02382942f, -0.01262758f, 0.00052227f, 0.01487230f, -0.03107719f, 0.03352298f, -0.06429665f, 
    -0.07081044f, -0.01383523f, -0.08716554f, -0.00955977f, -0.00279629f, 0.01394218f, 0.04360639f, -0.07043085f, 
    -0.05416875f, 0.01843277f, 0.03152017f, 0.04482437f, 0.04454020f, 0.00922840f, -0.03062807f, -0.00938843f, 
    -0.03378446f, 0.00189046f, 0.06524128f, 0.04231419f, -0.08462267f, 0.03829458f, -0.02524695f, 0.02124764f, 
    0.00877725f, 0.02600230f, -0.01471081f, -0.08117165f, -0.08209810f, 0.00111613f, 0.00943804f, -0.03117587f, 
    0.04087184f, -0.04578696f, 0.03667048f, -0.06979174f, 0.06484835f, 0.03532008f, 0.00052088f, -0.07357382f, 
    -0.03843497f, -0.05151200f, 0.03463807f, 0.02200403f, 0.04565565f, 0.02545030f, -0.05085896f, -0.04296442f, 
    0.04834871f, -0.02399475f, -0.07445496f, -0.02929963f, 0.01347950f, 0.01697089f, 0.00298835f, 0.01488824f, 
    -0.02566372f, -0.06953163f, -0.06262140f, 0.05951382f, -0.04114880f, -0.04290813f, -0.05900969f, -0.04682721f, 
    0.04584685f, 0.01140545f, 0.02416268f, 0.02883607f, -0.00014506f, -0.00088843f, 0.04414669f, -0.02888457f, 
    -0.04465085f, 0.04987567f, -0.04654356f, -0.01267894f, -0.06605082f, 0.05363713f, 0.05165470f, 0.06246779f, 
    -0.09085917f, -0.06957350f, 0.01284595f, -0.07415842f, 0.06087559f, 0.05185811f, -0.01310955f, 0.00579737f, 
    0.02456598f, 0.04046338f, -0.01410449f, -0.01255161f, -0.00911785f, 0.01802404f, 0.01783595f, 0.02738748f, 
    0.02939306f, -0.00680451f, 0.05030349f, 0.04285656f, 0.01850325f, -0.00975457f, 0.05180306f, -0.05999218f, 
    0.14253484f, -0.06813134f, 0.06929511f, -0.12056084f, -0.10789376f, -0.03617024f, 0.07529134f, -0.01219761f, 
    -0.02896627f, 0.17538746f, 0.06111635f, 0.05941609f, 0.21246471f, 0.52062827f, -0.45470479f, 0.21059658f, 
    0.10338584f, -0.04376544f, 0.07532180f, 0.20050584f, -0.06611838f, 0.07775316f, -0.01288568f, 0.06561356f, 
    0.37230524f, -0.57880241f, -0.04165692f, -0.21567577f, 0.30883804f, 0.17372926f, -0.01826729f, 0.08463496f, 
    0.00831617f, -0.06400979f, 0.12494511f, 0.14971194f, 0.07822797f, 0.05659191f, 0.10480700f, -0.02633712f, 
    0.14020889f, 0.01801100f, 0.03563563f, -0.08040743f, 0.10299765f, -0.09253727f, -0.13966978f, 0.14271328f, 
    0.41760170f, 0.28291455f, -0.18290582f, -0.41145518f, 0.14224519f, -0.05898013f, 0.24254902f, 0.01792382f, 
    0.01833259f, 0.02690331f, -0.03088035f, 0.07439339f, 0.35519418f, 0.01532179f, -0.03507307f, -0.05673348f, 
    -0.15735491f, 0.00419430f, -0.05134984f, -0.15103294f, -0.03099168f, 0.10211433f, 0.01988694f, -0.08322977f, 
    0.48451471f, -0.28173050f, -0.12456106f, -0.35219383f, -0.00345122f, -0.08900421f, -0.13826112f, -0.05784293f, 
    0.01793694f, -0.00994430f, -0.02569478f, 0.05214945f, -0.44138926f, -0.09082617f, 0.07260228f, 0.16067572f, 
    0.00517286f, -0.00685622f, 0.03500540f, -0.09442154f, 0.03539733f, -0.07293128f, -0.02873848f, 0.00122799f, 
    -0.04124916f, 0.06190529f, -0.00839670f, 0.06987773f, 0.12714420f, 0.11753368f, 0.01818017f, -0.09309106f, 
    -0.05848533f, 0.08988559f, -0.02319360f, 0.14120629f, -0.21997522f, 0.16423076f, -0.22472291f, 0.24630253f, 
    0.15122212f, -0.05119890f, 0.00498446f, -0.06868303f, 0.05929273f, 0.07074314f, 0.01600320f, 0.04616937f, 
    -0.01907791f, -0.12087527f, -0.19512928f, -0.17369959f, -0.04224475f, 0.13962644f, 0.04310006f, 0.12483735f, 
    0.03894493f, -0.03073154f, 0.00746757f, 0.04364829f, 0.29866660f, 0.02479690f, -0.03582687f, 0.11027885f, 
    0.20863929f, 0.25353330f, -0.03467657f, 0.14448412f, -0.08079093f, -0.08004142f, 0.05350162f, 0.01497706f, 
    0.09562480f, 0.22076638f, -0.43938905f, -0.01701275f, 0.00054633f, -0.12931308f, -0.05233628f, -0.00265650f, 
    0.06043480f, 0.10013463f, -0.15868106f, 0.01280593f, 0.11938961f, -0.07333532f, 0.07604011f, -0.13311145f, 
    -0.07130600f, 0.13056895f, -0.02466577f, -0.12302576f, 0.08957266f, 0.05266327f, 0.11101390f, 0.05108665f, 
    0.10825265f, 0.24841386f, 0.14101304f, -0.23150611f, 0.10036352f, -0.10717493f, 0.12067584f, -0.20911635f, 
    0.16166969f, -0.03685213f, -0.08075102f, 0.13701458f, -0.28483775f, 0.21347673f, -0.05545106f, 0.28649628f, 
    0.04971833f, -0.17215942f, -0.01804631f, 0.07916232f, 0.00357687f, -0.10872202f, 0.02383170f, 0.00054859f, 
    0.10787704f, -0.32179320f, 0.20675571f, -0.14749439f, -0.21574329f, 0.15007679f, 0.07517943f, 0.28549263f, 
    0.22215310f, -0.04446929f, -0.02612618f, 0.17459631f, -0.10537870f, 0.35967416f, 0.32045734f, 0.16143309f, 
    0.01915639f, 0.05029312f, 0.14393701f, 0.18147078f, -0.11634181f, 0.03468461f, -0.20157944f, -0.14721803f, 
    0.19151451f, 0.31594512f, 0.52281755f, 0.28932717f, -0.09774547f, -0.29531839f, 0.02191532f, 0.04991231f, 
    0.14124285f, 0.04656034f, 0.06775133f, 0.16077399f, 0.12107203f, 0.01426855f, -0.24577038f, -0.03518511f, 
    0.00981627f, 0.12079406f, -0.10050802f, -0.02361351f, -0.22467665f, -0.34133172f, -0.25238964f, -0.34281662f, 
    -0.19149864f, -0.09816120f, 0.09849382f, 0.06106017f, -0.05067746f, -0.11002891f, -0.00837529f, 0.09876515f, 
    0.04823899f, -0.13979715f, 0.00567723f, -0.02143007f, 0.27429080f, 0.04922758f, 0.14354253f, -0.06174335f, 
    -0.07078265f, -0.07129015f, 0.05571388f, 0.16388974f, 0.12503555f, 0.11865899f, -0.16209145f, -0.02564337f, 
    0.07857218f, -0.20028687f, 0.38981521f, -0.24568261f, -0.04178182f, 0.09997420f, 0.04138754f, 0.19825800f, 
    -0.31925607f, 0.00319168f, -0.06429344f, -0.21510370f, 0.06954391f, 0.10316288f, 0.10228274f, -0.02871618f, 
    0.09649032f, -0.19194117f, 0.14251587f, 0.29372445f, 0.16014604f, 0.08972524f, -0.09002408f, 0.33168757f, 
    -0.26892260f, -0.03836552f, 0.06611907f, 0.03878961f, 0.12495959f, 0.06923796f, -0.02623276f, -0.12230104f, 
    -0.32289633f, -0.39246252f, -0.50614250f, -0.33634904f, -0.17672151f, -0.07375305f, 0.07584684f, 0.05572306f, 
    0.02220418f, -0.05753607f, -0.11242893f, -0.02488608f, -0.05708606f, -0.16956259f, 0.14429778f, -0.10545263f, 
    -0.15676147f, -0.00948970f, 0.11088632f, 0.20033593f, -0.07698615f, -0.20180573f, -0.00424835f, 0.08621561f, 
    0.16278118f, 0.06573525f, 0.15448593f, 0.12939154f, -0.21575882f, -0.01234797f, 0.22406602f, -0.02130939f, 
    0.00593680f, -0.00351327f, 0.09330992f, 0.02649232f, 0.22782911f, 0.11600658f, 0.19723177f, 0.16730750f, 
    0.19142818f, 0.16920374f, 0.12524648f, 0.30427164f, 0.24879800f, 0.07146311f, 0.04360148f, 0.17146617f, 
    0.15628161f, -0.04555552f, 0.07412034f, -0.02947281f, 0.15736964f, -0.68054831f, 0.10131396f, -0.32805094f, 
    0.10801554f, 0.18781929f, 0.00513504f, -0.06750659f, 0.21436949f, 0.13930729f, -0.02247221f, 0.11297881f, 
    0.24346122f, -0.30895188f, -0.20038965f, 0.06968791f, -0.03992110f, 0.08705769f, -0.13444096f, -0.32645094f, 
    0.17808634f, -0.00477515f, 0.16194887f, 0.12453500f, -0.17893729f, -0.04512262f, 0.01340484f, -0.01045846f, 
    0.17716582f, -0.08419948f, 0.01918360f, 0.11231782f, -0.16562806f, -0.02477885f, 0.00999861f, -0.40392333f, 
    0.01036522f, -0.03945243f, -0.04645130f, 0.00065293f, -0.17068787f, 0.21290533f, -0.23369956f, -0.06256764f, 
    0.00447130f, -0.20275252f, 0.15807845f, 0.02497403f, -0.04670613f, 0.15501979f, -0.28922686f, -0.14061587f, 
    -0.00003999f, -0.06244732f, -0.12628338f, -0.05248798f, -0.04898052f, -0.08218435f, 0.22043540f, -0.05015517f, 
    -0.01054527f, -0.00389402f, 0.08217908f, -0.12400707f, -0.06507345f, -0.12689972f, 0.09499807f, 0.07449760f, 
    0.12781243f, -0.04165389f, -0.00663688f, -0.03868110f, -0.11784676f, -0.03186464f, -0.09036866f, 0.01994095f, 
    -0.04708998f, 0.11993585f, -0.07394174f, 0.04263556f, 0.16680035f, 0.24585453f, -0.04722547f, 0.31388286f, 
    -0.27231333f, 0.02632063f, 0.07741836f, 0.40141186f, 0.04283872f, -0.07722206f, 0.44115704f, 0.11607626f, 
    0.09545981f, 0.01334945f, -0.12607174f, -0.05234728f, 0.03615219f, -0.00350116f, 0.37625018f, 0.40580076f, 
    0.04192379f, -0.09626365f, -0.18410145f, -0.00405145f, 0.32901579f, -0.01077601f, 0.01638520f, 0.12059992f, 
    0.08648520f, -0.07254026f, -0.13534518f, -0.12522770f, 0.04307150f, 0.24862996f, 0.03719357f, 0.04260106f, 
    0.02438661f, -0.01111260f, 0.06415036f, 0.03785152f, 0.07977962f, 0.19903378f, -0.20334476f, -0.22497900f, 
    -0.07905822f, -0.02221626f, -0.03490647f, -0.00579636f, -0.03144923f, -0.02191765f, -0.11706356f, -0.27054423f, 
    0.14030263f, -0.00881531f, -0.07589361f, -0.15406851f, 0.06292151f, -0.02005619f, -0.04788262f, 0.17117670f, 
    0.24768358f, 0.08410244f, -0.04660544f, 0.03372138f, -0.19990782f, 0.10335985f, 0.08829310f, 0.02046936f, 
    -0.16301464f, -0.33306217f, -0.03505650f, -0.27289176f, 0.03879344f, -0.07227737f, -0.17121668f, -0.01627729f, 
    -0.15313752f, 0.50707066f, 0.07200802f, 0.08621807f, 0.03987594f, 0.08655884f, 0.29968360f, -0.10091420f, 
    0.05596333f, 0.02517953f, -0.20257755f, -0.04632878f, -0.18266192f, -0.02868853f, 0.29090151f, 0.08671275f, 
    -0.01582391f, -0.14002302f, -0.07742209f, -0.05234972f, -0.12933829f, -0.01097434f, 0.06561698f, -0.04398146f, 
    -0.06985903f, -0.01699967f, -0.05514092f, -0.11838297f, 0.06943028f, 0.16889845f, -0.01876007f, 0.28895757f, 
    0.13303460f, -0.02104042f, -0.16002542f, 0.03894325f, -0.00251158f, -0.38188216f, 0.00592150f, -0.02695392f, 
    0.15822536f, -0.02179464f, -0.21717504f, -0.03330330f, 0.14332226f, 0.20165269f, -0.08554543f, -0.13234018f, 
    -0.30745655f, -0.09775875f, 0.21798711f, 0.09565671f, 0.26543385f, -0.11585405f, 0.00992781f, 0.04705400f, 
    0.11048450f, 0.06729715f, -0.10681068f, -0.04124075f, 0.69691122f, 0.11737484f, 0.15620336f, 0.04864972f, 
    -0.05948615f, -0.06395531f, 0.13780010f, -0.05263672f, 0.09991206f, 0.13183287f, -0.04171953f, 0.14291619f, 
    0.04757078f, 0.03500064f, -0.05591202f, -0.00629834f, -0.01273887f, -0.07177131f, 0.04395379f, -0.01747506f, 
    0.01203544f, 0.03241887f, -0.03419384f, 0.02256103f, -0.04514322f, 0.04598456f, -0.00638048f, -0.06328450f, 
    -0.00315652f, -0.06149297f, -0.06439179f, 0.04020995f, 0.01699868f, -0.06413864f, -0.05945915f, -0.02572869f, 
    0.01941849f, -0.03027079f, 0.02047275f, -0.02498149f, 0.01251825f, -0.01462861f, -0.00523336f, -0.06024537f, 
    0.02419525f, 0.02046977f, -0.07710400f, -0.00745859f, -0.02978990f, -0.02895765f, -0.05091897f, 0.03456547f, 
    0.05306561f, 0.03154087f, -0.06878706f, 0.06448534f, 0.03730664f, -0.06419853f, -0.03124822f, -0.06239692f, 
    -0.04566905f, -0.01015215f, 0.06440073f, -0.04961503f, 0.02303207f, -0.01743374f, 0.06363803f, -0.05592828f, 
    0.05816796f, 0.00956361f, 0.02578534f, 0.01944143f, -0.06482505f, 0.06239772f, -0.05836853f, 0.00943830f, 
    0.04429332f, 0.04427007f, -0.07658097f, 0.02224610f, 0.05320180f, -0.00108261f, -0.06527333f, 0.00549805f, 
    -0.02768251f, -0.00815722f, -0.01120720f, 0.00895533f, 0.05179800f, -0.07682151f, 0.00535519f, 0.07033493f, 
    -0.04997520f, -0.04827623f, 0.04090889f, -0.04383284f, -0.01714184f, 0.02078867f, 0.04147252f, 0.01857608f, 
    -0.06481475f, 0.04769655f, 0.02488334f, -0.07704632f, -0.06335788f, 0.04469332f, 0.02653046f, -0.01522265f, 
    -0.02851821f, 0.02890339f, 0.06146257f, -0.05506957f, -0.01757057f, 0.03493860f, -0.07516768f, 0.00042453f, 
    -0.03199235f, -0.02601224f, 0.01846000f, -0.04217989f, 0.06932544f, 0.04076416f, -0.03135598f, -0.03753020f, 
    -0.06109590f, -0.04276347f, -0.03973370f, 0.02591811f, -0.03000609f, 0.05074907f, 0.03953488f, -0.07795990f, 
    0.01952887f, 0.03336240f, -0.04603649f, -0.02702320f, 0.03735982f, 0.01237572f, -0.04467493f, -0.06096893f, 
    0.05255830f, -0.01079994f, 0.04569973f, -0.06892423f, -0.04028428f, 0.05690960f, -0.06427271f, 0.00231448f, 
    0.01453368f, 0.03550008f, 0.05181874f, -0.06279007f, -0.01956062f, -0.06346749f, -0.06734729f, -0.03664830f, 
    -0.05414931f, -0.05954148f, 0.03216743f, 0.01106339f, 0.02216507f, -0.04799506f, -0.06347954f, 0.04643735f, 
    -0.00031339f, -0.04465305f, -0.04483126f, -0.06120842f, -0.03162786f, 0.02789904f, -0.06684481f, -0.06161561f, 
    -0.02457678f, -0.05628486f, -0.02414790f, 0.00047192f, -0.04569959f, 0.06142840f, 0.02559737f, -0.02885796f, 
    0.00691812f, -0.02713444f, -0.07455620f, 0.04998511f, 0.02947804f, -0.03550039f, -0.04767885f, 0.05119866f, 
    -0.02626243f, -0.06716618f, -0.03925494f, 0.00550079f, -0.06154022f, -0.07254919f, -0.05532961f, -0.07217287f, 
    0.00352894f, 0.02209997f, -0.04636838f, 0.01687449f, 0.04526088f, 0.00878954f, -0.06713191f, -0.06758342f, 
    0.20297526f, -0.04202981f, 0.05598010f, 0.21359931f, 0.01938095f, 0.04137383f, -0.07001451f, 0.07087288f, 
    0.14033085f, -0.07784986f, -0.05674649f, 0.08850026f, -0.06578773f, 0.26944762f, -0.15343571f, -0.36367014f, 
    -0.09593014f, -0.17360874f, 0.11217849f, 0.11071452f, -0.08249332f, -0.05258523f, -0.09877715f, -0.00991678f, 
    0.12872544f, 0.33370385f, 0.28979790f, 0.09535159f, -0.08349665f, 0.01059920f, 0.02094581f, 0.02077402f, 
    -0.19439721f, 0.08166534f, -0.02426730f, 0.04823491f, -0.02603358f, 0.03361423f, -0.04077969f, 0.08699365f, 
    -0.00381027f, 0.12404976f, 0.06824401f, 0.08818693f, 0.04964663f, 0.01681031f, -0.07168207f, -0.01571582f, 
    -0.24646996f, 0.08923933f, -0.02203321f, 0.19258246f, -0.31484926f, -0.14966659f, 0.17184295f, -0.05890141f, 
    0.00775841f, -0.10697994f, -0.07045263f, -0.02423834f, 0.27353099f, -0.17260008f, 0.20267852f, 0.19331110f, 
    -0.08342078f, 0.02046961f, 0.00893289f, 0.00057163f, -0.06749871f, 0.03382005f, -0.12920634f, 0.11337009f, 
    -0.29050866f, 0.02072773f, 0.01764805f, 0.06509252f, 0.06514380f, 0.22698770f, -0.02624541f, 0.02218756f, 
    -0.08805478f, 0.04779647f, 0.06611046f, -0.00983269f, 0.26121333f, 0.18637478f, -0.15616296f, -0.07246095f, 
    0.08043912f, -0.05061525f, -0.16403265f, 0.26556525f, 0.06873449f, 0.05957949f, 0.02957045f, 0.16787487f, 
    0.06159622f, 0.06560225f, -0.05168000f, 0.08238126f, 0.01574234f, 0.02056463f, 0.00074620f, 0.10106550f, 
    0.08021205f, -0.10585762f, 0.04543886f, -0.05697005f, 0.05304534f, -0.01198374f, -0.00803050f, 0.03749058f, 
    -0.01771991f, -0.13427408f, -0.07378588f, -0.06134027f, 0.10517589f, -0.03694014f, -0.05652938f, 0.07366583f, 
    -0.06077627f, 0.24533455f, 0.03171010f, 0.23798631f, 0.00871890f, -0.11566935f, 0.05980529f, -0.19551080f, 
    -0.02619522f, 0.09502991f, -0.12328593f, -0.06879399f, -0.02411086f, 0.03655696f, 0.24305728f, 0.15253286f, 
    -0.07461510f, 0.06358439f, -0.13032342f, -0.12021131f, 0.05067408f, 0.06675366f, 0.03223781f, 0.12215353f, 
    -0.20107678f, -0.22072677f, -0.04868365f, -0.01303570f, 0.20863895f, 0.09444559f, -0.18517810f, 0.15585288f, 
    0.10686986f, 0.17576241f, -0.22574496f, 0.17936347f, 0.08834835f, -0.16749160f, 0.05295639f, 0.00122043f, 
    0.20596436f, -0.02889526f, -0.00378410f, 0.00407448f, 0.10585090f, 0.03423105f, 0.01874402f, 0.21449979f, 
    -0.19112888f, -0.15819944f, -0.01902954f, 0.04180775f, 0.02744160f, 0.10603992f, -0.07774704f, -0.04521098f, 
    0.08162981f, -0.26351994f, -0.00864433f, 0.11291000f, 0.16812751f, -0.03403376f, 0.10875382f, -0.10666815f, 
    0.02659913f, -0.02753169f, 0.18644132f, 0.06853587f, 0.07303118f, 0.11064053f, -0.07453554f, -0.09520658f, 
    -0.03760868f, 0.06193567f, -0.01115824f, -0.07655698f, 0.04569332f, -0.04574623f, -0.00256586f, 0.05193080f, 
    -0.03216929f, -0.01246447f, -0.05175873f, -0.01634928f, -0.01886026f, -0.06405307f, -0.03835713f, -0.02303743f, 
    0.00553680f, -0.02168330f, 0.02353504f, -0.01242964f, -0.04204706f, -0.02953839f, -0.05533709f, -0.07361310f, 
    0.06003682f, 0.01764191f, -0.04400055f, 0.02399968f, -0.04109607f, -0.07019366f, -0.03989158f, -0.06934218f, 
    0.02396508f, -0.00871192f, -0.05428485f, -0.06413642f, -0.07484204f, -0.00041338f, 0.05321886f, 0.02769933f, 
    0.00672348f, -0.01768707f, -0.05422761f, 0.01175269f, 0.00791868f, -0.04976087f, -0.02356084f, -0.01868664f, 
    -0.06069266f, 0.06772150f, 0.01017211f, -0.02960981f, 0.07113297f, -0.01169323f, -0.07556212f, -0.06081241f, 
    -0.02644055f, -0.01057002f, 0.00497273f, 0.01656708f, -0.04595934f, 0.03264546f, -0.00037975f, -0.04738135f, 
    -0.07899652f, 0.00718300f, -0.06360945f, 0.05903722f, -0.05753417f, 0.04334030f, 0.06398130f, 0.05242012f, 
    -0.04694925f, 0.04668549f, 0.01394465f, -0.07529894f, 0.04320696f, 0.05254726f, -0.02383625f, 0.04775206f, 
    0.05094318f, 0.04268432f, -0.00397964f, -0.00058943f, 0.00847731f, -0.04282057f, 0.03477042f, 0.06046976f, 
    0.04957598f, 0.03594402f, 0.06112111f, 0.00922028f, 0.03548220f, 0.04164100f, -0.06205405f, -0.06761772f, 
    0.01093479f, -0.07921967f, -0.00186494f, 0.05465850f, -0.00272163f, 0.04366541f, -0.07020184f, -0.03551323f, 
    0.01367027f, -0.07561455f, -0.02309055f, 0.00802130f, -0.02744904f, -0.05684262f, 0.00145937f, 0.03115630f, 
    -0.01966557f, -0.02337923f, -0.00313520f, -0.07059414f, 0.02504391f, -0.01770995f, 0.00474934f, -0.05475310f, 
    -0.02142741f, 0.05140245f, -0.05554041f, 0.05089813f, -0.02180134f, 0.04882864f, -0.03597313f, 0.05458386f, 
    0.03126015f, 0.01218195f, 0.01277533f, -0.03699733f, -0.02067317f, -0.06775225f, 0.04734565f, -0.06656190f, 
    -0.03198319f, 0.04644300f, -0.07191920f, -0.02011371f, 0.01337865f, 0.02701827f, -0.05078844f, -0.06737680f, 
    0.03126517f, 0.02797751f, -0.07880506f, 0.03195599f, -0.06258946f, -0.03220259f, 0.03752183f, -0.01182958f, 
    -0.07455733f, -0.04272533f, -0.06974164f, -0.00524925f, 0.04894657f, 0.03259516f, -0.04828877f, 0.03999063f, 
    -0.06444684f, 0.00989448f, 0.02313768f, -0.05529979f, 0.04593126f, -0.04996580f, 0.00356150f, 0.02366778f, 
    0.03069390f, 0.01955944f, -0.06825343f, 0.01296054f, -0.02698412f, 0.06267291f, 0.00270693f, -0.03315032f, 
    -0.00042732f, 0.04362869f, -0.06931806f, 0.01740655f, -0.08042334f, -0.02969954f, 0.03766896f, -0.01200866f, 
    -0.06435670f, -0.05093040f, 0.04607432f, 0.02535617f, 0.06262753f, -0.08024977f, 0.03023868f, -0.06428996f, 
    -0.06295281f, -0.05694462f, -0.03372639f, -0.01845213f, -0.08034737f, 0.03047040f, -0.04228657f, 0.00340786f, 
    0.01160838f, -0.08268593f, 0.00518218f, -0.01862244f, 0.05177050f, -0.07156256f, -0.08205582f, -0.00084250f, 
    -0.00449064f, 0.00981926f, 0.05393701f, -0.03450985f, 0.01418802f, -0.01332320f, 0.03543967f, -0.05232402f, 
    -0.03616247f, -0.05522610f, -0.06123576f, 0.03578237f, -0.01265610f, 0.03252743f, 0.02162077f, -0.00310828f, 
    -0.02010049f, -0.05212402f, 0.03972867f, -0.04638710f, -0.00469222f, -0.06299387f, -0.01204240f, -0.07822411f, 
    0.05279863f, 0.05110111f, 0.00403379f, -0.03430017f, -0.00210172f, -0.06524576f, 0.04868290f, 0.03009976f, 
    -0.00925616f, -0.03652028f, -0.06801647f, 0.03275369f, -0.05249330f, 0.05226650f, -0.05194529f, -0.03891695f, 
    -0.06389359f, 0.05216625f, 0.03060647f, 0.01316808f, -0.04885898f, -0.06656878f, 0.01206003f, 0.03548161f, 
    -0.01390706f, 0.04692924f, -0.02947939f, 0.02929296f, -0.00660677f, 0.02724926f, -0.00732172f, -0.04177676f, 
    -0.02849210f, -0.00486652f, -0.05638195f, -0.06542885f, -0.01207569f, -0.04130672f, -0.00554415f, 0.04948731f, 
    -0.02387833f, 0.01538263f, -0.02127134f, -0.06277323f, -0.05909560f, 0.01109992f, -0.03832541f, -0.01315361f, 
    -0.06589298f, 0.03786777f, -0.01268881f, 0.04421059f, -0.04091264f, 0.02390119f, 0.04905355f, 0.01697961f, 
    -0.04832404f, -0.02629216f, -0.05029809f, -0.00300949f, -0.04020854f, 0.02470818f, -0.01183307f, 0.05359963f, 
    -0.01915145f, 0.03770418f, -0.02619506f, 0.03366286f, -0.01286795f, 0.06514124f, 0.01697059f, -0.00168486f, 
    0.06663149f, 0.05137509f, -0.06006419f, 0.04416166f, 0.01526307f, 0.02323885f, -0.04975670f, 0.03253204f, 
    -0.01614379f, -0.07118253f, 0.01800097f, 0.04647328f, -0.06644723f, -0.01216302f, 0.01112381f, 0.00997357f, 
    0.03771964f, -0.01626419f, 0.02539460f, -0.03386265f, 0.00546465f, -0.00632184f, -0.06893605f, 0.02250495f, 
    0.02947119f, 0.04776436f, 0.00195597f, 0.03258232f, -0.03970597f, -0.05870814f, 0.01923491f, 0.03980774f, 
    -0.00247252f, -0.07182711f, -0.04253408f, -0.07241219f, 0.00584479f, 0.04105569f, -0.01830135f, 0.04557193f, 
    -0.05143763f, 0.02938742f, 0.03467969f, 0.02245813f, 0.04240280f, -0.00348846f, 0.02457621f, 0.01926170f, 
    0.00081169f, -0.03308582f, 0.04343189f, -0.00834511f, -0.05312468f, 0.00016895f, 0.01077276f, -0.05060182f, 
    -0.07483708f, -0.02302212f, -0.03186790f, -0.00777923f, -0.05404501f, 0.04459902f, -0.00778988f, -0.00054071f, 
    -0.05152575f, -0.06194964f, -0.04783732f, -0.03577230f, 0.04911068f, 0.04252662f, 0.02104808f, -0.02954536f, 
    0.01968990f, -0.06439145f, -0.01234306f, -0.03368487f, -0.02635837f, -0.00510806f, 0.00619220f, 0.03055288f, 
    -0.17334871f, 0.19328657f, -0.03580672f, -0.02183274f, -0.00379970f, -0.14367756f, 0.02004816f, -0.20225754f, 
    -0.15911809f, 0.05237463f, 0.09443895f, -0.00048441f, 0.15372582f, -0.20478533f, -0.05899001f, 0.08290712f, 
    0.22337028f, 0.22943683f, -0.00785247f, -0.03715276f, -0.03126194f, 0.05896506f, 0.09777299f, 0.09856131f, 
    0.04206094f, -0.16452560f, -0.24834366f, -0.11295903f, 0.09417583f, 0.15803723f, -0.15394019f, -0.02621993f, 
    0.01440003f, -0.10123751f, 0.06853874f, -0.03758654f, -0.09918677f, -0.07403103f, 0.24009278f, -0.00155491f, 
    -0.06991318f, -0.11507556f, 0.01101735f, -0.08309180f, 0.14367415f, -0.01051389f, 0.29777199f, 0.08398015f, 
    0.18700768f, 0.24893035f, 0.04759749f, -0.14073232f, 0.26504967f, 0.20916998f, -0.00593125f, 0.07570327f, 
    -0.13295095f, 0.02689283f, -0.03427679f, 0.03236828f, -0.21079583f, 0.32884416f, -0.06694896f, -0.16724624f, 
    -0.00122283f, -0.01239257f, -0.10299660f, -0.04738662f, 0.12326176f, 0.01165191f, 0.07287169f, 0.08593961f, 
    0.08545063f, 0.40882710f, -0.07680465f, 0.16833657f, 0.06173933f, 0.07842770f, 0.09684617f, -0.04827558f, 
    0.17850427f, -0.01329484f, 0.05827953f, 0.13773067f, -0.43400416f, -0.27791959f, 0.03370704f, 0.28178895f, 
    -0.01139172f, 0.01538572f, -0.10038286f, -0.14226095f, -0.31483561f, 0.02680265f, 0.02077882f, -0.19181277f, 
    -0.05329661f, -0.14135706f, 0.05627405f, -0.08601490f, 0.04055362f, 0.24741639f, 0.08739210f, -0.15101820f, 
    0.09408031f, 0.02402721f, 0.09648007f, 0.17952436f, 0.00665760f, 0.09557131f, 0.24583240f, 0.16271001f, 
    -0.06213377f, 0.05821282f, -0.05464125f, -0.04152285f, -0.14398213f, -0.02588403f, -0.02775692f, 0.03789991f, 
    0.15821925f, 0.01019153f, -0.06151965f, -0.17550966f, -0.02892427f, 0.25349817f, 0.00842238f, 0.13708887f, 
    -0.05413174f, -0.09917082f, -0.22955300f, 0.03257405f, 0.22839318f, 0.03352446f, -0.18665677f, -0.00129966f, 
    0.25881654f, 0.10153007f, 0.04893541f, 0.15539035f, -0.28265947f, -0.09582324f, -0.10100598f, -0.16463748f, 
    0.17930238f, 0.11895701f, -0.01413852f, -0.06099791f, 0.05987462f, 0.04079520f, 0.12561145f, 0.04948568f, 
    -0.09397607f, -0.15265687f, 0.10973286f, -0.02567446f, -0.13209713f, 0.33672440f, 0.02456618f, -0.03809575f, 
    -0.15999277f, 0.02885335f, -0.09778389f, 0.00762106f, -0.03992171f, 0.05049160f, 0.04819275f, -0.08269604f, 
    -0.31617466f, 0.44519663f, 0.37486473f, -0.21552111f, -0.23376656f, 0.05498062f, 0.16559123f, 0.17587107f, 
    -0.13262305f, 0.10954382f, -0.09217457f, -0.07015584f, -0.01657353f, -0.01702948f, -0.11408325f, 0.35915646f, 
    -0.16986831f, -0.20738889f, -0.18253098f, 0.00709954f, 0.11673924f, -0.02122631f, 0.00512179f, 0.14087074f, 
    -0.06854534f, -0.15899043f, 0.19487144f, -0.21729293f, -0.15141982f, -0.12846710f, 0.03426757f, 0.13721207f, 
    0.05574035f, -0.19005890f, 0.05610669f, 0.11335265f, 0.33323762f, 0.36869413f, 0.40010968f, -0.01278064f, 
    0.01785943f, -0.01724324f, -0.09248091f, 0.18700852f, -0.05095931f, 0.11146019f, 0.01208424f, -0.12943621f, 
    0.08938622f, -0.46382856f, -0.00468918f, -0.17057684f, -0.08437575f, 0.02788498f, 0.01501113f, -0.12016936f, 
    0.11364555f, -0.02972829f, 0.13948776f, -0.00698351f, 0.10835978f, -0.13129018f, -0.25948113f, 0.04861692f, 
    -0.03951770f, -0.06671306f, -0.19188319f, -0.12832879f, 0.05815578f, -0.19698535f, 0.01990869f, -0.22731021f, 
    0.35533249f, 0.29497060f, 0.53465641f, -0.06805235f, 0.26569721f, 0.15978095f, -0.02271135f, 0.14071362f, 
    0.13199444f, -0.10248607f, 0.04985667f, 0.05533984f, -0.06562599f, -0.01526463f, -0.35828060f, -0.13837808f, 
    -0.08198962f, -0.14164367f, 0.10764024f, 0.05551784f, 0.05427876f, -0.02723545f, 0.06895424f, 0.06690536f, 
    0.49271601f, -0.11807048f, 0.42421207f, -0.37230116f, -0.11943489f, 0.16179705f, 0.08946379f, 0.02498417f, 
    -0.16079000f, -0.03377988f, -0.14696394f, -0.02614139f, 0.08571112f, 0.13592072f, -0.03244167f, 0.07156035f, 
    -0.16413765f, 0.05474713f, 0.06589862f, 0.10492823f, 0.05460261f, 0.07334293f, 0.05947938f, -0.20308590f, 
    -0.10424837f, -0.01409963f, 0.17333175f, 0.05477363f, 0.06624379f, -0.01838539f, -0.07798114f, -0.14433230f, 
    -0.09090117f, -0.15872447f, -0.35231015f, -0.32787764f, 0.05246719f, 0.10360854f, 0.27070713f, 0.11974468f, 
    0.01753406f, 0.07826681f, -0.36142454f, 0.16676551f, 0.05795552f, -0.27375871f, 0.09390116f, 0.02123447f, 
    -0.23862572f, 0.11858976f, 0.11838216f, -0.21732299f, 0.06626415f, 0.04562003f, 0.10294159f, 0.10550393f, 
    0.05918212f, 0.01014199f, 0.08438269f, 0.07584151f, 0.12271810f, 0.28110346f, 0.19427699f, -0.07780544f, 
    0.07716023f, 0.02498920f, 0.24259607f, 0.14156882f, 0.02058659f, 0.14976655f, 0.34524667f, 0.02906402f, 
    0.31192106f, 0.37762520f, -0.12075430f, 0.19991681f, 0.17480698f, 0.03260037f, 0.17394622f, 0.05012134f, 
    0.08999432f, -0.08535096f, 0.10105211f, -0.15421098f, 0.20745319f, -0.20028248f, 0.13123904f, -0.42971584f, 
    -0.03768848f, -0.05370251f, -0.09420168f, 0.11475597f, 0.15422393f, -0.04737096f, 0.10862886f, -0.05344892f, 
    0.17141186f, -0.16920549f, 0.27258652f, 0.25045630f, -0.13947436f, -0.06527744f, -0.26417798f, -0.04477303f, 
    0.30724925f, -0.05764904f, 0.09199941f, -0.02464488f, -0.01631246f, -0.08621380f, -0.16312063f, 0.12870945f, 
    0.04572779f, -0.24172673f, -0.27204463f, 0.18393131f, -0.03268704f, -0.11252873f, 0.05666907f, -0.20750082f, 
    0.31635630f, 0.06099451f, 0.12521337f, -0.05827097f, 0.04742777f, -0.04204415f, -0.13588822f, -0.14414132f, 
    0.08709631f, -0.11102846f, -0.09060242f, 0.01351780f, 0.04597232f, -0.02010511f, -0.29581118f, 0.06477872f, 
    0.00022278f, 0.19090554f, -0.02469005f, 0.15404575f, -0.07376653f, -0.07920496f, 0.06574647f, 0.07353444f, 
    -0.25395018f, -0.30000207f, -0.32565379f, -0.20090598f, -0.24726528f, -0.10801638f, -0.11000774f, 0.12456759f, 
    0.21821350f, 0.07799472f, 0.20116398f, -0.12691364f, 0.14169024f, 0.10336510f, 0.09602896f, -0.00002006f, 
    -0.12538666f, -0.00060183f, 0.09911709f, 0.00159206f, -0.06091974f, 0.00595031f, -0.01908433f, -0.11348856f, 
    -0.36655617f, 0.13483575f, 0.04085087f, 0.03809708f, 0.13059868f, 0.09014660f, -0.05521952f, 0.04864923f, 
    0.02231099f, 0.00834395f, -0.02910324f, -0.06696545f, 0.52470821f, 0.19073874f, 0.40070540f, -0.02515047f, 
    0.05205256f, -0.06552058f, -0.12173198f, -0.03748551f, -0.09448455f, -0.05842815f, -0.07620548f, -0.06699379f, 
    0.11546219f, -0.20402907f, 0.31218898f, 0.25345847f, 0.07894293f, 0.01443333f, 0.12261865f, 0.12860021f, 
    0.01443888f, 0.08217695f, -0.06347332f, 0.05983004f, 0.37678254f, -0.04503926f, 0.03711426f, 0.34381917f, 
    0.08280285f, -0.04559360f, 0.02769900f, -0.02439209f, 0.19917019f, 0.13441402f, 0.20190686f, 0.14156947f, 
    0.03939544f, -0.07895876f, 0.15346479f, -0.01234414f, -0.27889425f, -0.05657516f, 0.11185312f, 0.03765828f, 
    0.02489364f, -0.15786047f, -0.05976987f, -0.12699014f, 0.03985683f, -0.06108457f, -0.06461377f, 0.21360284f, 
    0.03258041f, -0.00077402f, -0.01685147f, -0.02264335f, 0.03124148f, 0.00659187f, 0.10372821f, -0.05951827f, 
    -0.50033110f, -0.31832230f, -0.45684972f, -0.19737792f, -0.11567186f, -0.00670604f, -0.14245257f, 0.00090460f, 
    0.04358004f, -0.16679674f, 0.04717011f, -0.04435111f, -0.15172024f, -0.00841291f, -0.23142515f, -0.52346444f, 
    -0.02913421f, -0.02009814f, 0.02548119f, -0.11741043f, -0.02325939f, -0.17563154f, 0.06685521f, 0.07068945f, 
    -0.16432971f, 0.17214499f, 0.23551397f, 0.02712184f, 0.04880007f, 0.17755815f, 0.00652818f, -0.21853007f, 
    -0.08124366f, -0.09022342f, 0.21765292f, 0.09654825f, 0.04901545f, -0.08336373f, 0.10713061f, -0.10536198f, 
    0.12306762f, 0.04552749f, 0.04627666f, 0.11122933f, -0.03477348f, -0.00777115f, 0.03843393f, 0.01225793f, 
    -0.12237915f, -0.18169177f, 0.06675559f, 0.09479520f, -0.07071538f, -0.05104345f, -0.00810874f, 0.06425967f, 
    -0.05489681f, 0.13015416f, 0.02983624f, -0.07996355f, 0.26187241f, 0.16536537f, -0.05899141f, 0.02823488f, 
    0.05407612f, 0.11814513f, 0.07807110f, 0.00977185f, -0.02764603f, -0.02579966f, 0.02901129f, 0.02574188f, 
    -0.00217269f, -0.20076011f, 0.00792674f, 0.33824065f, -0.09788131f, -0.02277574f, -0.11068355f, -0.06145849f, 
    0.09179284f, 0.06869725f, 0.05137558f, 0.07240050f, 0.19556385f, -0.27427873f, -0.26833257f, -0.03568571f, 
    0.21716562f, 0.11024257f, -0.10027782f, 0.07132272f, 0.08167743f, 0.00333655f, 0.06149482f, 0.01790232f, 
    0.13993235f, -0.00914176f, 0.02622742f, -0.22035460f, 0.00797788f, -0.01830261f, -0.04347042f, -0.06784555f, 
    0.16008942f, -0.05709939f, 0.09660350f, -0.09127945f, -0.34810722f, -0.12046184f, 0.37210131f, 0.32298529f, 
    0.02827793f, -0.11813039f, -0.07129595f, -0.09446611f, 0.11039630f, -0.07039344f, 0.12622261f, 0.20791702f, 
    -0.07495467f, 0.03150214f, 0.07298876f, -0.17048314f, 0.10453361f, 0.07169452f, 0.06616896f, 0.11654880f, 
    -0.05175843f, -0.01038356f, 0.10198434f, -0.00855211f, -0.07169046f, 0.23205084f, 0.43160042f, 0.43187571f, 
    0.10095111f, -0.11826953f, -0.18839692f, -0.01820150f, 0.10126984f, -0.00051237f, 0.18904254f, -0.04545050f, 
    0.06364326f, -0.33845752f, 0.17475547f, 0.16955207f, 0.08899111f, 0.21373528f, 0.14829861f, -0.01971046f, 
    0.12988845f, 0.06200649f, -0.14571819f, 0.03544313f, -0.10017167f, -0.35134640f, -0.24504800f, 0.15896235f, 
    -0.14142865f, -0.00791879f, 0.10408493f, 0.10664766f, -0.10204817f, -0.04176366f, -0.02203471f, -0.09085328f, 
    0.26449662f, -0.04520638f, -0.08066155f, -0.06755192f, -0.08660196f, 0.23086116f, 0.09579398f, -0.09359963f, 
    0.11109091f, -0.13822956f, -0.21233323f, 0.04977741f, -0.03826236f, -0.31183556f, -0.39363921f, 0.32218435f, 
    0.02381473f, 0.14769655f, 0.15595010f, -0.07216477f, -0.06139326f, -0.12553521f, -0.11639779f, -0.02299708f, 
    -0.03158317f, 0.06181618f, -0.12114686f, -0.38370612f, -0.05270581f, 0.18130243f, 0.13338986f, 0.08525460f, 
    0.17311759f, 0.02890709f, 0.02404534f, 0.03198434f, 0.21738911f, 0.17562124f, 0.01292536f, -0.20702195f, 
    0.06969577f, -0.00984798f, 0.08488498f, 0.17117931f, 0.00480944f, 0.01483277f, 0.07574289f, -0.00893630f, 
    -0.00886867f, -0.04194528f, 0.23506249f, -0.09954344f, 0.14418645f, 0.19381610f, 0.06744862f, -0.00559559f, 
    0.02555013f, -0.10830661f, 0.04430798f, -0.03151549f, -0.00693980f, -0.10763135f, -0.08065955f, -0.00353164f, 
    0.01019497f, 0.12105821f, -0.11188405f, 0.07583956f, 0.11721431f, 0.09471567f, 0.10405252f, 0.13236499f, 
    -0.51934892f, 0.25654253f, 0.09674708f, 0.32186896f, -0.17680097f, 0.04925755f, 0.17797717f, 0.06137003f, 
    0.05314565f, 0.04478132f, -0.07761473f, -0.08325212f, -0.09006076f, -0.32618684f, -0.26132441f, 0.05181276f, 
    0.06520785f, -0.06351096f, -0.12813127f, -0.02597135f, -0.05148771f, -0.08552311f, -0.07411895f, 0.17543153f, 
    0.05986824f, -0.01765239f, -0.06515338f, 0.03411560f, -0.07478067f, -0.04428583f, -0.05051500f, -0.02616319f, 
    0.02185172f, -0.05428253f, 0.03113819f, 0.03430088f, -0.02870229f, 0.02922489f, 0.05827495f, 0.03328640f, 
    0.00518501f, 0.03887705f, -0.07230450f, 0.06467813f, -0.00659664f, 0.01962290f, -0.00390983f, 0.00403222f, 
    -0.02726860f, 0.00307824f, -0.00985366f, -0.06427603f, 0.03239921f, 0.05277620f, 0.05109810f, 0.04011524f, 
    -0.05114022f, 0.01194065f, 0.00588557f, -0.07245185f, 0.05867914f, 0.06207547f, 0.02463984f, 0.02157238f, 
    0.00467352f, -0.04329202f, -0.00385115f, -0.00533731f, -0.01624404f, -0.04609088f, -0.02502212f, -0.06758844f, 
    0.00632295f, 0.00752104f, -0.00091281f, -0.03652276f, -0.04469241f, -0.06791106f, 0.06226407f, 0.03768278f, 
    0.00865440f, 0.01072094f, 0.05651937f, -0.00422068f, 0.00247547f, 0.02415856f, -0.07372932f, 0.04034836f, 
    -0.02287998f, 0.00133483f, -0.06615409f, -0.07295667f, 0.05268459f, -0.00008574f, -0.05390450f, -0.01037959f, 
    0.01077562f, 0.05808069f, 0.01156448f, 0.04049009f, -0.05643196f, -0.06607156f, -0.03385967f, 0.03855225f, 
    0.06304201f, -0.05320797f, 0.03160482f, -0.01582889f, -0.04143775f, -0.06652745f, -0.06367762f, 0.06013168f, 
    0.00944567f, -0.00591090f, -0.06990399f, 0.00228899f, -0.02234383f, 0.00248120f, 0.01384875f, 0.00542279f, 
    -0.00247669f, 0.04933038f, -0.07405574f, 0.04343840f, -0.03282059f, -0.07041012f, 0.00477108f, 0.01180871f, 
    -0.03684242f, -0.07369252f, -0.03664142f, 0.00693779f, 0.00568685f, -0.04452611f, 0.00179881f, 0.03348832f, 
    0.04770350f, 0.00288667f, 0.05219918f, -0.00768678f, 0.02054518f, -0.05593245f, -0.00908208f, -0.06050136f, 
    -0.06779363f, -0.07208285f, 0.00940668f, -0.02698274f, -0.01588568f, -0.02484612f, -0.07010582f, -0.04740262f, 
    -0.06502475f, 0.01696872f, 0.05310072f, 0.04406372f, 0.01172488f, -0.03518987f, -0.04735561f, -0.04598342f, 
    -0.01148433f, -0.03215890f, -0.06803831f, 0.01716212f, 0.06602203f, -0.02182808f, -0.06204779f, -0.03503115f, 
    -0.04043309f, -0.02207492f, -0.04275296f, -0.01500778f, 0.00292494f, -0.01299492f, -0.04817997f, -0.05739239f, 
    -0.06502939f, -0.02440216f, 0.00047016f, -0.01608328f, -0.02178711f, 0.06437717f, -0.03924742f, -0.07261632f, 
    0.05869118f, -0.01412717f, -0.03157412f, -0.07479692f, 0.03967862f, -0.00220782f, -0.01639290f, 0.04474203f, 
    0.00909421f, -0.00459770f, 0.00472388f, 0.01849938f, -0.00461324f, -0.07432923f, -0.03161043f, -0.07428970f, 
    -0.00258417f, -0.04722081f, -0.06917088f, 0.01327359f, 0.05019416f, 0.01682197f, 0.01815006f, -0.01957382f, 
    -0.07608619f, -0.02992322f, 0.05582587f, -0.04004689f, 0.02774844f, -0.04827573f, -0.07201040f, -0.02638795f, 
    0.06896052f, -0.15438104f, 0.08651813f, -0.36917925f, 0.14850107f, 0.01669740f, 0.03559087f, 0.13418357f, 
    -0.20453280f, -0.02423156f, 0.21366863f, -0.10104053f, 0.00408036f, -0.10294197f, 0.01003462f, 0.22403124f, 
    0.21655294f, 0.15174976f, 0.04385751f, -0.06617901f, 0.13031827f, 0.16377352f, -0.03759335f, -0.01097908f, 
    -0.30377921f, 0.01787692f, 0.02118940f, 0.18352142f, -0.00481518f, -0.09786491f, 0.06533176f, 0.15490559f, 
    0.12129739f, 0.06642396f, 0.15083592f, 0.09988588f, 0.08317085f, -0.23438214f, -0.07875033f, -0.02854520f, 
    0.00544913f, -0.25019759f, -0.22292344f, 0.11404994f, 0.05641872f, 0.03759962f, 0.10204811f, 0.17885487f, 
    -0.05308928f, -0.20604043f, -0.16229583f, 0.06193917f, 0.32758433f, 0.02605779f, 0.06951313f, 0.04123056f, 
    0.00933678f, 0.04071800f, -0.01591492f, -0.00962160f, -0.12493237f, 0.27008924f, -0.03652084f, -0.25399286f, 
    0.22771665f, -0.09157486f, -0.02192292f, 0.06831782f, -0.02765177f, 0.03079906f, 0.03813108f, 0.02042924f, 
    0.02969125f, 0.25849366f, 0.29458249f, -0.11140341f, 0.11120410f, -0.02751029f, 0.08548593f, 0.07477774f, 
    0.07707662f, 0.03215422f, 0.07104585f, 0.11151297f, -0.50972927f, -0.05335831f, 0.07381765f, 0.03798589f, 
    -0.05342119f, -0.02182942f, -0.06675051f, -0.16096675f, -0.02890338f, 0.10956404f, 0.02780250f, -0.16400220f, 
    0.05660696f, -0.20932886f, -0.14540096f, -0.02120477f, 0.05280868f, -0.09555928f, -0.06531516f, -0.13975321f, 
    0.16096631f, 0.09420604f, -0.05948120f, 0.02963231f, -0.50836903f, -0.09921531f, 0.16866022f, -0.37052935f, 
    -0.13561966f, -0.17765021f, -0.17052431f, -0.00881591f, -0.05445509f, -0.13996172f, 0.05311194f, 0.11817174f, 
    0.11269272f, -0.08076975f, 0.07273477f, 0.08368708f, -0.03040920f, -0.00004798f, 0.06559138f, 0.03752637f, 
    -0.02676402f, 0.04957700f, 0.10572564f, 0.09167167f, -0.13117106f, -0.15682603f, 0.02622052f, 0.05614178f, 
    -0.00870739f, 0.14192092f, 0.11884466f, -0.10366733f, -0.07307199f, -0.13061063f, -0.03211930f, -0.10418899f, 
    -0.04766287f, 0.11134902f, 0.07329992f, -0.00869033f, 0.28627360f, 0.17231712f, 0.21464472f, 0.14798579f, 
    0.04477974f, -0.02405181f, 0.02379046f, 0.08247449f, -0.06130668f, -0.39356405f, -0.11478755f, -0.22772971f, 
    -0.06978089f, 0.23115893f, -0.05968855f, 0.05418396f, 0.18232612f, 0.04104512f, -0.02682047f, -0.05674837f, 
    0.67745680f, -0.26468268f, -0.01387280f, -0.05271575f, -0.01026892f, -0.12126419f, 0.08712805f, 0.16059303f, 
    0.20361112f, 0.25253820f, -0.00753118f, -0.21268953f, -0.06826195f, 0.27892256f, 0.24351652f, -0.10264595f, 
    -0.03149254f, -0.02288178f, -0.20088318f, -0.08447085f, 0.08364890f, -0.03451876f, -0.01940616f, 0.19576094f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.15882008f, 0.13119261f, 0.04525562f, 0.10926754f, 0.16153219f, 0.01424250f, 0.07211918f, -0.07390435f, 
    0.08537825f, 0.04085207f, 0.04756366f, 0.30547112f, 0.03450120f, 0.01957076f, -0.15851705f, -0.02006256f, 
    -0.15508263f, 0.24750590f, -0.14239922f, -0.02104881f, -0.03672298f, 0.19108880f, 0.09108630f, -0.21966992f, 
    0.12839538f, -0.01128108f, -0.00275584f, -0.02517084f, 0.01779350f, 0.05298223f, 0.00768350f, -0.02620883f, 
    -0.00109782f, -0.03251515f, 0.09105495f, 0.12565970f, 0.22320510f, 0.21259283f, 0.01173102f, 0.10860763f, 
    0.02195061f, 0.03148367f, 0.24264359f, -0.04465330f, 0.08021698f, 0.00255420f, -0.00460951f, 0.10396490f, 
    0.04627255f, 0.17541209f, -0.05443243f, -0.13904965f, 0.00438173f, 0.20516123f, -0.02341523f, 0.13891621f, 
    -0.00227307f, -0.00617025f, -0.00336063f, -0.10226113f, -0.03753757f, 0.12462722f, 0.01378311f, 0.08898017f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.28649485f, -0.31064504f, -0.11072949f, -0.49352139f, -0.59815049f, -0.00370761f, 0.10318661f, 0.19222343f, 
    0.07791463f, -0.11400177f, 0.13240792f, -0.27195725f, 0.14679958f, 0.05512474f, -0.08873229f, -0.09121697f, 
    0.36264083f, 0.02791213f, 0.14901793f, 0.05715036f, 0.00492477f, -0.61159366f, 0.14372180f, 0.25612611f, 
    -0.48580837f, 0.06966074f, 0.18811476f, 0.21238820f, 0.00554709f, 0.07653875f, 0.06358402f, -0.05137331f, 
    -0.30981204f, 0.08789279f, 0.15315610f, -0.18976851f, -0.12039424f, 0.05958005f, -0.10735296f, 0.11333284f, 
    -0.52441752f, -0.06699096f, -0.19267347f, 0.07463303f, -0.08293064f, -0.06912152f, 0.02850194f, -0.25293353f, 
    0.24828541f, 0.06924037f, 0.11145177f, 0.25849476f, -0.10908776f, -0.39916700f, 0.08866662f, -0.07537068f, 
    0.09128356f, -0.00553909f, 0.30519548f, 0.20284724f, 0.07154207f, 0.23573412f, 0.11974429f, -0.40335709f, 
    -0.08086278f, 0.00439938f, -0.04986161f, -0.09160095f, -0.25497398f, -0.10519512f, 0.01838241f, -0.29967445f, 
    -0.26326680f, 0.06984311f, 0.13716975f, 0.13178249f, -0.02857919f, -0.08418082f, -0.17272274f, 0.06944757f, 
    0.68491161f, 0.00848969f, 0.03748488f, 0.04517201f, -0.09013732f, -0.22148636f, 0.10006970f, -0.95290852f, 
    -0.04526624f, 0.04215344f, -0.00418455f, 0.02583860f, 0.03884797f, 0.02200329f, 0.37737402f, -0.01032580f, 
    -0.34504348f, -0.12567751f, 0.22005947f, 0.03563426f, 0.19460131f, -0.26746523f, 0.08076942f, -0.29876035f, 
    -0.07633705f, 0.00905814f, 0.25244406f, 0.19741638f, 0.09518629f, -0.14390600f, 0.22366211f, 0.36369890f, 
    0.31465152f, 0.19510596f, -0.00787042f, -0.06264281f, -0.61816448f, 0.36399138f, 0.07685349f, 0.17915776f, 
    -0.03732575f, -0.06616775f, -0.04941230f, -0.51594967f, 0.08250494f, -0.01298181f, 0.04206275f, -0.48622927f, 
    0.33542690f, -0.08530989f, -0.12218318f, 0.11296115f, -0.19023198f, 0.06277414f, 0.11091174f, -0.08327452f, 
    -0.21554117f, -0.11546610f, -0.01492401f, 0.14964128f, 0.14981081f, -0.07496030f, -0.27557880f, 0.07436711f, 
    -1.04598486f, 0.26192161f, -0.15288229f, 0.04657125f, 0.11265563f, 0.08694580f, 0.15961419f, -0.44841859f, 
    -0.04998858f, -0.05245617f, -0.89993024f, -0.07590085f, -0.00248766f, -0.53583169f, -0.17800927f, 0.09556735f, 
    -0.70236140f, -0.11244302f, 0.53959113f, -0.19993454f, 0.12123926f, -0.38208935f, -0.02875067f, 0.16050863f, 
    0.04765474f, -0.09683753f, 0.18774554f, -0.05934314f, -0.07864062f, -0.29237455f, 0.06910807f, 0.11602366f, 
    0.09304563f, -0.05309139f, 0.05100602f, -0.16408493f, 0.46290600f, 0.47351253f, -0.06339744f, 0.16281010f, 
    -0.00462270f, 0.11271615f, -0.41584891f, -0.09717315f, -0.20262343f, -0.13294357f, -0.04902753f, 0.24248968f, 
    -0.10377396f, -0.37780765f, 0.09662207f, 0.22605367f, 0.03936719f, -0.10799935f, -0.39975223f, -0.02439030f, 
    -0.06253928f, -0.07668653f, 0.02288393f, -0.63367063f, 0.17909481f, -0.07231396f, -0.01472829f, 0.04402759f, 
    0.07087770f, -0.26399821f, -0.06062179f, 0.01040737f, -0.04232669f, -0.10312831f, 0.17190731f, 0.15311229f, 
    0.23352307f, 0.11403760f, -0.47807631f, 0.20671014f, 0.03935754f, -0.18793702f, -0.61520219f, -0.05893232f, 
    0.10394409f, 0.00354173f, -0.02340744f, -0.33645883f, -0.30921251f, -0.59894204f, 0.36412987f, 0.09299680f, 
    0.39825022f, 0.21329194f, -0.33388358f, 0.14013402f, 0.30937326f, 0.24272235f, 0.17889272f, -0.24291350f, 
    -0.02037590f, 0.09458553f, -0.11814060f, 0.04762080f, -0.00353874f, -0.23298767f, 0.01555868f, 0.01011440f, 
    -0.00858930f, -0.10059713f, 0.00506664f, -0.15352444f, -0.47577468f, -0.21174459f, 0.00770558f, 0.32048771f, 
    -0.23335896f, 0.00591794f, -0.05391012f, -0.33905324f, -0.07520355f, 0.10805555f, -0.00415551f, 0.19487192f, 
    0.04405133f, 0.05255737f, -0.44037503f, 0.09517746f, -0.12684689f, -0.05801486f, 0.23337719f, -0.00823671f, 
    -0.24913418f, 0.13373552f, 0.14800176f, 0.09524506f, 0.06344155f, 0.04684528f, -0.01228971f, 0.22748561f, 
    -0.03409273f, 0.00946344f, 0.13579105f, -0.20644805f, -0.08105182f, 0.20675102f, -0.16647272f, 0.00163586f, 
    0.06743979f, -0.01282048f, 0.15368742f, 0.14889552f, -0.34130201f, -0.06384546f, -0.29978877f, 0.10239927f, 
    -0.30135289f, 0.10154739f, -0.16104521f, -0.01097068f, -0.08282781f, 0.15642864f, 0.17749220f, -0.02804988f, 
    -0.15663962f, -0.07337058f, 0.09763150f, -0.00102206f, 0.33243322f, -0.32155734f, -0.05487331f, 0.17855071f, 
    0.01279828f, 0.01408861f, -0.37759426f, 0.24585728f, 0.10422674f, -0.14798900f, 0.11012611f, -0.38318709f, 
    -0.29153278f, -0.03014880f, 0.09286002f, -0.27801114f, -0.25662312f, 0.02801863f, -0.09116089f, -0.40893078f, 
    0.15123190f, 0.04232843f, 0.14084914f, 0.18189177f, -0.01330073f, 0.07995638f, 0.15397604f, 0.01508041f, 
    -0.36174780f, 0.07476212f, 0.01722390f, 0.08839156f, -0.01459690f, 0.03002972f, -0.50739837f, -0.24703169f, 
    -0.10676133f, 0.09900580f, 0.45334676f, 0.13103409f, -0.10852274f, 0.21715076f, 0.17026947f, -0.01258444f, 
    0.17860161f, 0.06090277f, 0.05190685f, 0.31873825f, -0.17763367f, 0.20894343f, 0.14461310f, 0.21636422f, 
    -0.16056386f, 0.12557048f, -0.21904407f, -0.66717654f, 0.05999354f, -0.28054020f, -0.24328348f, -0.30711731f, 
    0.15674584f, 0.08222497f, -0.09673949f, -0.07149593f, -0.27287188f, 0.22627479f, -0.01990938f, -0.18302335f, 
    0.03290831f, 0.07761455f, 0.17477520f, 0.29304573f, 0.10951106f, 0.31871751f, -0.01291407f, 0.23044243f, 
    0.06605496f, -0.04270582f, 0.06327993f, 0.03184966f, 0.12863714f, 0.05972074f, 0.02953013f, 0.18540807f, 
    0.10737957f, 0.02211555f, 0.06889752f, 0.19043864f, 0.05368198f, -0.12586375f, -0.49390101f, 0.10887287f, 
    -0.10214009f, -0.07958340f, -0.55438381f, -0.01742911f, 0.11280622f, 0.26755077f, 0.46755925f, -0.23490357f, 
    0.27559102f, -0.00654826f, -0.25948811f, -0.01747326f, -0.06529058f, -0.23753898f, -0.54940879f, 0.07560292f, 
    0.00403172f, 0.11780782f, -0.97142977f, 0.29619050f, 0.28426161f, 0.27739906f, -0.28276056f, 0.14721143f, 
    0.16073380f, -0.39148515f, -0.07459015f, -0.05353716f, 0.03933582f, -0.15534499f, -0.42336157f, 0.00298725f, 
    -0.53563941f, -0.85908097f, -0.08247268f, -0.26832846f, 0.01431475f, -0.18866707f, 0.08358124f, 0.11966611f, 
    0.06027272f, 0.07606080f, -0.24876407f, -0.95488113f, 0.16459672f, 0.18581973f, -0.04233293f, 0.28570852f, 
    0.19644506f, -0.06308514f, -0.00988991f, 0.15394832f, -0.04910831f, -0.04520093f, -0.22380503f, 0.19425938f, 
    -0.29316232f, -0.02907590f, 0.05020328f, -0.21912555f, -0.30134743f, 0.01920976f, 0.13763046f, -0.02666213f, 
    -0.12876083f, -0.51924402f, 0.06465426f, 0.05328515f, -0.08072221f, 0.20866320f, -0.65978849f, 0.37707084f, 
    0.01355828f, -0.04093641f, -0.03008266f, -0.43208760f, 0.07452209f, -0.41404387f, 0.07519480f, -0.05827352f, 
    -0.11589088f, -0.02568342f, -0.42395309f, 0.07112538f, 0.03070804f, 0.06363015f, 0.38464093f, -0.24750201f, 
    0.03795091f, 0.18868652f, -0.21411480f, -0.14894009f, -0.03884512f, -0.55565691f, -0.38494530f, 0.00920816f, 
    -0.19438298f, -0.15274706f, -0.11216173f, 0.00498556f, 0.51796842f, 0.03629806f, 0.03761429f, 0.08407497f, 
    -0.01395738f, 0.01149777f, -0.26560891f, 0.47450352f, 0.25916401f, -0.38245928f, -0.08248871f, 0.21441431f, 
    0.14063485f, 0.18163589f, 0.01792197f, 0.11829942f, -0.19921428f, 0.09645500f, 0.24137522f, -0.57181746f, 
    -0.31896979f, 0.09867001f, 0.36653891f, 0.17980716f, -0.18526810f, 0.02114693f, -0.49580118f, 0.11022710f, 
    -0.35287592f, -0.24754454f, 0.14302488f, -0.09637098f, 0.12248261f, 0.17037955f, 0.05729936f, -0.30843851f, 
    0.17349382f, -0.00471440f, -0.77388763f, -0.01934621f, 0.08856827f, 0.09908522f, -0.17743495f, 0.04395177f, 
    0.09304810f, 0.01552843f, -0.66645086f, -0.33039525f, -0.20415010f, 0.09026269f, 0.31939945f, -0.70569032f, 
    0.06583005f, 0.29636779f, -0.17114094f, 0.13246018f, 0.20590790f, -0.65057760f, -0.14808169f, -0.01149255f, 
    -0.23070587f, 0.16603175f, 0.10764000f, 0.34068847f, -0.38754651f, -0.20916156f, -0.04107479f, -0.33673531f, 
    0.02358325f, -0.04120722f, 0.14038394f, -0.13286416f, -0.30072823f, -0.50883329f, -0.08564702f, 0.32575312f, 
    0.29932711f, 0.11507870f, 0.10175237f, -0.02302400f, 0.07310548f, -0.06770872f, -0.35964438f, 0.12437809f, 
    0.35217726f, -0.03748358f, -0.14758435f, -0.00940548f, -0.14038521f, -0.15821216f, -0.19731444f, -0.05887350f, 
    -0.34015501f, -0.08379971f, -0.52203113f, 0.08094451f, -0.08051600f, -0.11957818f, -0.46538657f, 0.36819068f, 
    -0.08219506f, 0.06295744f, -0.00983336f, 0.08699398f, 0.10428704f, 0.37522790f, 0.35563469f, 0.07744998f, 
    0.35783476f, -0.06432415f, -0.08119389f, 0.08451132f, -0.22518364f, 0.30235803f, 0.06619655f, 0.06934277f, 
    -0.26196328f, -0.70681149f, 0.15727721f, 0.19052701f, -0.66996807f, 0.04772761f, 0.11291235f, 0.15569438f, 
    0.02970698f, -0.55932796f, -0.04400008f, 0.16288710f, 0.23981307f, 0.19885428f, -0.07986350f, 0.18792212f, 
    0.00943211f, -0.05276383f, -0.60348666f, -0.01725204f, 0.02369523f, 0.29938617f, -0.02018132f, -0.11132468f, 
    -0.40100005f, -0.03235679f, -0.02565692f, 0.38770482f, 0.26620910f, 0.08027609f, -0.17712398f, -0.67406565f, 
    -0.06360289f, -0.11009470f, -0.19901365f, 0.10305493f, 0.12708682f, 0.05831394f, -0.33676454f, 0.09416543f, 
    -0.53991562f, 0.18613492f, 0.20038614f, -0.10116248f, -0.04520320f, 0.21160604f, -0.09231719f, 0.03221149f, 
    0.27908161f, -0.00115302f, -0.14817342f, -0.18760680f, -0.07384301f, -0.03651752f, -0.40016520f, 0.04881834f, 
    -0.24684013f, 0.00280979f, 0.08997543f, 0.18205069f, -0.42509532f, 0.35203251f, -0.14137208f, -0.18600586f, 
    -0.10255376f, 0.22340995f, 0.35661158f, 0.00390844f, -0.10478532f, 0.19629374f, 0.00539073f, -0.57355022f, 
    -0.45536873f, 0.37103418f, -0.08503884f, -0.40679905f, -0.73990548f, -0.16039260f, -0.05498318f, -0.31326482f, 
    -0.01984817f, -0.05648037f, 0.39784425f, -0.96236497f, -0.15332918f, 0.31085896f, 0.03576239f, -0.14715622f, 
    0.00929554f, 0.26715788f, 0.02429974f, 0.26454565f, 0.30302083f, 0.10342567f, 0.27898118f, -0.51236784f, 
    -0.53084767f, 0.05719807f, 0.18393260f, 0.06285113f, -0.31936848f, 0.03056333f, 0.34505871f, -0.07314126f, 
    -0.41699806f, 0.14584206f, 0.06589721f, 0.09379323f, 0.00729143f, -0.04160482f, 0.14589697f, -0.24070409f, 
    0.30083483f, -0.01278010f, -0.24768594f, -0.55518204f, 0.02938951f, 0.30433387f, -0.21294770f, -0.00617641f, 
    0.10928749f, -0.11256072f, -0.32700351f, -0.35775968f, 0.16981623f, -0.48183918f, -0.60444880f, -0.05750651f, 
    0.35014102f, -0.54812342f, 0.09219663f, -0.01174968f, 0.21079233f, 0.25459662f, 0.06725612f, -0.12339541f, 
    0.18602538f, -0.26205716f, -0.08088348f, -0.48747382f, -0.25785422f, -0.23416586f, -0.13026050f, -0.24513105f, 
    -0.00830938f, 0.11247997f, 0.13842905f, 0.24368094f, -0.17133893f, -0.27211648f, -0.09358092f, -0.22732346f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13443634f, 0.18041365f, 0.14466682f, -0.10275675f, -0.16235505f, 0.05679252f, 0.05714082f, -0.12103815f, 
    -0.04108205f, -0.06768411f, 0.16342278f, -0.00913784f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
