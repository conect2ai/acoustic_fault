#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.12765861f, 0.65887308f, 0.34422618f, 0.40690893f, 0.61150217f, -0.89807278f, -0.39324209f, -0.08035761f, 
    0.21307114f, 0.24675798f, 0.02751951f, 0.26263747f, -0.13594016f, 0.01053997f, -0.10156921f, -0.30631790f, 
    -0.12173490f, 0.03920739f, -0.15898196f, -0.27746770f, -0.26518771f, 0.09122279f, 0.14428517f, 0.12863791f, 
    -0.01016365f, -0.69523990f, -0.35347235f, 0.20048961f, -0.08733975f, -0.33192554f, 0.03088867f, -0.69123185f, 
    -1.16088462f, -0.91389555f, -0.41835725f, -0.11090574f, -0.16972981f, -0.32070038f, -0.71068048f, -0.39676332f, 
    0.00167197f, 0.05687061f, 0.16626196f, 0.06693258f, -0.11056181f, 0.09239051f, -0.14191526f, -0.08574413f, 
    0.00996796f, -0.18800293f, 1.17883682f, 0.12959202f, -0.59016496f, -0.12620430f, -0.50658214f, 0.51699585f, 
    -0.04010530f, 0.12019740f, -0.06572674f, 0.31862250f, 0.15331645f, 0.30584058f, -0.54521477f, -0.58272189f, 
    0.23029992f, 0.02783934f, -0.00313548f, 0.07606958f, -0.13405395f, -0.68224794f, -0.50008082f, -0.15029036f, 
    -0.23755699f, -0.34066832f, -0.61911976f, 0.72515702f, 0.59710336f, 0.70322281f, -0.05698165f, 0.14815101f, 
    -0.22218996f, 0.10119969f, 0.22350004f, 0.04127132f, -0.27815193f, 0.24884312f, 0.03450043f, -0.11659777f, 
    -0.13853952f, 0.07733274f, -0.18197194f, 0.20738794f, 0.07212723f, 0.14705558f, 0.15495883f, -0.17420509f, 
    0.23750694f, -0.29085165f, -0.35118166f, -0.59509319f, -0.65963340f, 0.04774375f, 0.55126983f, 0.31217229f, 
    -0.17593379f, -0.33220437f, -0.34635052f, -0.56635833f, 0.18468684f, 0.45515493f, 0.45100492f, 0.04587939f, 
    0.42607737f, -0.37178370f, -0.26088169f, -0.10068613f, 0.09462726f, 0.30033633f, -0.07073790f, -0.34112680f, 
    0.13421974f, 0.39149827f, 0.25512090f, 0.13494830f, 0.46001640f, -0.68254817f, -0.21743608f, 0.41163206f, 
    -0.67468101f, -0.37274852f, -0.65901405f, -0.81048185f, -0.71732539f, -0.11476099f, -0.33038589f, -0.31946537f, 
    -0.17031354f, 0.92939270f, 0.03992217f, -0.24549496f, -0.49320617f, -0.60819000f, -0.43230549f, -0.24264084f, 
    -0.38228947f, 0.45078057f, -0.03646931f, -0.12514338f, -0.16409542f, 0.23286466f, -1.67169309f, -0.45342883f, 
    0.04666492f, -0.51226205f, 0.73852992f, -0.40834036f, -0.72691149f, -0.02214490f, 0.46089077f, 0.58904344f, 
    -0.53643030f, -0.61005980f, 0.11505355f, 0.19741289f, 0.20693703f, 0.56326813f, 0.04345161f, -0.17671195f, 
    0.06960250f, -0.21220346f, 0.04507222f, -0.37391800f, -0.01705106f, -0.24799010f, -0.52847785f, -0.13340671f, 
    -0.50463003f, -1.15660083f, -0.58801001f, -0.41224667f, 1.01603174f, 0.53118014f, 0.48986769f, -0.00760926f, 
    -0.21025613f, 0.28490850f, 0.18808159f, 0.13554922f, -0.43355361f, 0.21924020f, -0.30631310f, 0.01555701f, 
    0.00067976f, -0.52565312f, -0.03690932f, 0.32871020f, 0.02551138f, -0.04990547f, 0.37271419f, 0.36593205f, 
    -0.97297639f, -0.40550664f, 0.45993340f, 1.03868902f, 0.23880579f, 0.48625359f, -0.54057181f, -0.30721581f, 
    0.16206916f, -0.25873435f, 0.60264206f, -0.55057871f, -0.01927069f, 0.76788712f, -0.46536958f, -0.45032912f, 
    0.10190395f, -0.01130172f, 0.03962763f, -0.15028667f, -0.07837848f, -0.13828823f, -0.03880142f, -0.00817573f, 
    -0.34265774f, 0.93392229f, -0.79860729f, -0.34924883f, 0.28288856f, -0.46746293f, 0.26261422f, -0.67064834f, 
    -0.48861220f, 0.50226533f, -0.71189559f, 0.30701625f, 0.26712230f, -0.12695217f, -0.30595747f, 0.14361195f, 
    0.22377539f, 0.60261077f, 0.08171286f, -0.32292938f, -0.24215047f, 0.02382760f, 0.38780564f, 0.29608357f, 
    0.06666049f, 0.22980915f, 0.03729729f, -0.12055945f, -0.07962064f, 0.76351494f, -0.04997029f, 0.08984773f, 
    -0.13253930f, -0.20812553f, 0.29106560f, -0.52103966f, -0.18584846f, 0.10427348f, -0.75915873f, 0.59092957f, 
    -0.25855142f, -0.43512428f, -0.07216279f, 0.25895450f, -0.27433422f, 0.35759044f, 0.32976770f, 0.28497809f, 
    0.20946898f, -0.29206270f, 0.46244344f, -0.19554144f, -0.97427756f, -0.71934962f, 0.07230504f, 0.00185911f, 
    -0.61320210f, -0.14364587f, -0.85840839f, -1.19297040f, -0.29757363f, 0.51498210f, -0.48931399f, 0.16502288f, 
    0.64961612f, 0.55931008f, 0.08179922f, -0.32057735f, -0.26293740f, 0.23875797f, -0.39934978f, -0.46114433f, 
    0.08254995f, 0.34047222f, 0.12690948f, 0.23034681f, 1.08300352f, -0.21979076f, -0.60086417f, 0.00629083f, 
    0.47052735f, -0.04021279f, 0.50788641f, 0.79071569f, -0.31404328f, -0.81652504f, -0.46757028f, -0.02396850f, 
    -0.31182870f, -0.08730609f, -0.17323166f, 0.29183224f, -0.07148968f, 0.32743806f, 0.18783762f, -0.21123718f, 
    0.20040776f, -0.17015675f, -0.42570832f, -0.05849899f, -0.26860151f, -0.70280421f, -0.18601143f, 0.13093241f, 
    0.35289404f, 0.57820696f, -0.67645800f, 0.54648232f, 0.91717499f, -0.23516656f, 0.19465524f, -0.23009124f, 
    -0.16565029f, 0.33464956f, 0.39814791f, -0.39780897f, -0.25388613f, 0.15184772f, -0.08416489f, -0.10962959f, 
    0.07024652f, -0.31144729f, 0.05700901f, -0.12706098f, -0.06967581f, 0.51594496f, -0.47552693f, -0.35631013f, 
    0.31209216f, 0.69128156f, 0.71474773f, 0.36834362f, 0.38223082f, 0.31188595f, 0.30527508f, 0.49246287f, 
    0.23730360f, 0.43954840f, 0.07037386f, -0.39178160f, 0.18946745f, -0.46823478f, 0.02097406f, 0.18170682f, 
    -0.37555131f, -0.55374920f, -0.51604444f, 0.26988983f, 0.06924503f, 0.17643639f, 0.12870826f, -1.00065243f, 
    -1.09093225f, -0.78630930f, -0.31369457f, -0.25770378f, 0.63313735f, 0.89681894f, 0.31558865f, 0.18413723f, 
    0.68524158f, 0.22647734f, 0.31727603f, 0.18880914f, 0.22187603f, -0.31838852f, -0.15653846f, 0.08826610f, 
    0.06229509f, -0.04179503f, -0.03476070f, -0.30920756f, -0.27906597f, -0.06015100f, 0.14397590f, 0.00703253f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27942041f, -0.10536771f, 0.21338254f, -0.04490904f, 0.09964330f, 0.30743545f, 0.25613618f, 0.47192299f, 
    0.25027767f, 0.16106951f, 0.26595953f, 0.20212629f, 0.18864416f, 0.65927517f, 0.50326252f, -0.06322135f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01725388f, 0.01726376f, -0.00857514f, -0.05937158f, -0.04279579f, -0.06325116f, -0.00369505f, 0.02159714f, 
    -0.05131814f, -0.00855480f, -0.01048779f, 0.05754788f, 0.00791800f, -0.00125532f, -0.05627649f, 0.00678074f, 
    -0.05073201f, 0.02589154f, -0.01017674f, -0.02955477f, 0.01093731f, 0.04136060f, -0.01458272f, -0.00468726f, 
    0.03158311f, -0.07245149f, 0.00260611f, 0.04698709f, -0.02887518f, 0.01237977f, -0.07679320f, -0.08265187f, 
    0.03275820f, -0.07559354f, 0.01754327f, -0.07928611f, -0.08109295f, 0.02382773f, -0.06204346f, 0.00566721f, 
    -0.05925826f, 0.03685181f, 0.03188222f, -0.04462191f, -0.03488122f, 0.05528214f, 0.01733507f, 0.03003263f, 
    0.05645947f, -0.04475999f, -0.00974015f, 0.06050361f, 0.00161114f, 0.03951841f, 0.01534186f, -0.01718270f, 
    -0.07256480f, 0.02850738f, -0.07719301f, -0.03899273f, 0.01170426f, 0.02479084f, -0.02534695f, -0.07056272f, 
    0.04281813f, -0.06714019f, -0.05452023f, -0.02282991f, 0.02477703f, 0.05427243f, -0.05542260f, -0.02885026f, 
    -0.01310465f, 0.05084347f, 0.05642012f, -0.01327061f, -0.00740890f, 0.01095206f, 0.04264851f, 0.06168384f, 
    0.05944766f, -0.07534938f, -0.04216700f, -0.04265267f, 0.03551424f, 0.06106729f, 0.02781789f, 0.05634401f, 
    -0.00831244f, 0.06122255f, -0.03535558f, -0.05458069f, 0.00322386f, -0.02304083f, 0.00780278f, 0.01079183f, 
    -0.03853051f, -0.07633328f, 0.04320347f, -0.02342898f, -0.07301979f, -0.03733008f, 0.06161737f, 0.01193282f, 
    -0.00665259f, -0.00576162f, -0.00868508f, 0.03146926f, 0.03366762f, -0.02178273f, 0.03186073f, -0.07973338f, 
    0.05184206f, -0.05617881f, 0.03606162f, -0.06240197f, 0.03462215f, 0.03167389f, 0.04379661f, 0.00611733f, 
    -0.05775595f, -0.02853983f, 0.02724542f, -0.00925260f, -0.04288728f, -0.02819832f, 0.00699991f, 0.05072107f, 
    0.00314530f, -0.07314932f, -0.00857538f, -0.07833001f, -0.05839137f, -0.07185238f, -0.01846562f, 0.04231835f, 
    0.00241291f, 0.00200047f, -0.00766704f, 0.03362958f, -0.04504216f, -0.04714170f, -0.03441635f, -0.06185932f, 
    -0.01083550f, 0.06322017f, -0.04967450f, -0.04034936f, 0.05950126f, 0.01082938f, -0.03883168f, 0.01832188f, 
    0.00026426f, -0.01571556f, -0.05057106f, 0.02741456f, -0.08041675f, 0.06058858f, -0.01681534f, -0.01463094f, 
    -0.07813288f, -0.04274481f, -0.06596578f, -0.00656131f, -0.04637544f, -0.03717977f, 0.03231119f, -0.02679988f, 
    0.04336855f, -0.07740703f, -0.06588125f, -0.02636830f, -0.07687408f, 0.05813481f, -0.08190682f, 0.04457942f, 
    0.01825163f, -0.02461946f, -0.02879848f, 0.01521198f, -0.06084672f, -0.00174043f, -0.02525691f, -0.06443495f, 
    0.03210012f, 0.04238467f, 0.02968615f, -0.07160000f, -0.03944137f, 0.01220607f, 0.06048364f, 0.01070574f, 
    -0.04238134f, -0.00232762f, 0.08568877f, -0.16446255f, -0.17739408f, -0.09192078f, -0.02292392f, -0.11257531f, 
    0.03457082f, -0.05045977f, -0.06615102f, 0.01880608f, -0.38390529f, -0.19756036f, -0.04636817f, -0.03756086f, 
    -0.03493359f, -0.03839697f, 0.16143616f, 0.20209056f, 0.02945571f, 0.03654751f, -0.03805740f, -0.00423600f, 
    -0.11177197f, -0.14702871f, 0.36545283f, -0.05478759f, -0.20641227f, 0.33221394f, 0.01506431f, 0.08491968f, 
    0.08983114f, 0.46392098f, 0.25627896f, 0.15581100f, -0.15383711f, 0.07483386f, 0.15241192f, -0.24013175f, 
    -0.30255967f, 0.05946038f, -0.07870594f, 0.07956805f, 0.13370523f, 0.17344235f, 0.09739818f, 0.17099850f, 
    0.30642831f, -0.32101148f, -0.05135228f, -0.04087141f, 0.24680088f, -0.07969323f, -0.28694266f, 0.10288841f, 
    -0.08385637f, 0.22609140f, -0.10629365f, -0.16184108f, 0.00400688f, -0.13485102f, -0.30625519f, -0.01911221f, 
    0.08457915f, 0.20150860f, 0.10612337f, 0.01727014f, 0.06215049f, 0.19618000f, -0.00151128f, 0.08068600f, 
    0.59571546f, 0.02394086f, -0.29751620f, 0.32475966f, 0.37224454f, -0.04848396f, -0.02121953f, -0.03151850f, 
    0.02831463f, 0.13823289f, -0.24536715f, 0.10135550f, -0.17138414f, 0.28814712f, 0.25280887f, 0.04089129f, 
    0.08413113f, -0.21858704f, -0.11272427f, 0.24979042f, -0.19287322f, 0.07474142f, 0.00096554f, 0.07154673f, 
    0.09402646f, -0.00329112f, 0.11452799f, -0.09558018f, -0.09114230f, 0.19517717f, -0.05337586f, 0.07340432f, 
    -0.00487738f, -0.20770992f, 0.29541466f, -0.13354023f, -0.44975033f, -0.17383002f, -0.18398255f, -0.03530752f, 
    0.03472809f, -0.21406074f, -0.19879855f, -0.09450117f, -0.12963328f, 0.01139261f, -0.09661631f, -0.16174507f, 
    0.07697532f, -0.11265915f, -0.37119976f, -0.28886175f, 0.30039650f, -0.29529041f, -0.07682168f, 0.13247406f, 
    -0.14637509f, -0.15969351f, -0.14157774f, 0.04097545f, -0.19134125f, -0.51971579f, -0.18792066f, -0.22527716f, 
    -0.09405701f, 0.04083685f, -0.10791935f, 0.08859499f, -0.00669329f, -0.07441623f, 0.09995408f, -0.23382656f, 
    0.33375174f, 0.13867240f, 0.30042374f, 0.60937655f, 0.03759754f, -0.23773554f, 0.42496103f, 0.04526513f, 
    -0.00284247f, 0.41982591f, 0.17732652f, 0.25194824f, 0.14910981f, 0.28362399f, -0.54982787f, 0.19191925f, 
    0.33981794f, -0.03376346f, -0.06359981f, 0.04832942f, 0.02138217f, 0.09874525f, -0.08116493f, 0.04798886f, 
    0.14332864f, 0.33626395f, 0.14628558f, -0.06260830f, 0.05652606f, -0.00386626f, -0.19014950f, 0.13953322f, 
    0.03029857f, 0.26464719f, 0.01989316f, -0.14674151f, 0.23299314f, 0.11257666f, 0.51916367f, 0.30416739f, 
    0.00175731f, 0.01138202f, -0.15934898f, 0.07512862f, -0.10223384f, 0.04805276f, 0.13096470f, 0.21241915f, 
    0.30375996f, 0.11560480f, 0.04072342f, 0.32092670f, -0.02071004f, -0.03927544f, -0.06738904f, 0.06133674f, 
    -0.04346208f, 0.09788725f, 0.05554047f, 0.08536050f, 0.20713821f, 0.43363619f, 0.40249723f, 0.22517395f, 
    0.06332463f, 0.02725843f, 0.12522733f, 0.04359918f, 0.01939654f, -0.00478141f, 0.09588869f, -0.02832856f, 
    -0.30940035f, 0.10322727f, -0.58041310f, 0.22510529f, -0.02770923f, 0.12742469f, 0.10904747f, 0.13143167f, 
    0.05826320f, -0.09844437f, -0.06096331f, -0.10929157f, -0.07035012f, -0.02225471f, -0.10233704f, 0.10886437f, 
    -0.10326398f, 0.01155506f, -0.02250690f, -0.00371247f, 0.22441563f, 0.14270620f, 0.07958826f, 0.04172360f, 
    0.12214407f, 0.15117051f, 0.13028868f, -0.03039675f, 0.09883998f, 0.25795841f, 0.19855012f, -0.10911518f, 
    0.16951430f, 0.00631381f, -0.06574080f, -0.22869822f, 0.29657948f, 0.28708345f, 0.40684143f, -0.03540362f, 
    0.19259651f, -0.17443594f, -0.03621779f, -0.00892963f, -0.02783811f, 0.10079662f, -0.06380667f, 0.04952456f, 
    0.08926374f, 0.11651260f, 0.45248631f, -0.56455868f, -0.08266299f, -0.26494884f, 0.09280597f, -0.07267756f, 
    -0.22858039f, -0.04807108f, -0.10986899f, 0.19150475f, -0.09057438f, -0.15153724f, -0.46724403f, 0.29064462f, 
    0.22262383f, -0.00972602f, -0.11323275f, -0.03792325f, -0.00527975f, -0.00264908f, -0.02797671f, 0.01015695f, 
    -0.37901670f, -0.06221221f, 0.36120817f, 0.49273410f, 0.00848563f, -0.06655648f, -0.07170680f, -0.07808710f, 
    0.10692964f, -0.25626671f, 0.07240062f, 0.07402261f, 0.14646116f, -0.13694306f, 0.14572600f, 0.18217872f, 
    0.06901871f, 0.29395893f, 0.28370422f, 0.00623379f, 0.03867356f, 0.13588451f, 0.05346247f, -0.06713346f, 
    0.24782173f, -0.17763431f, 0.30322126f, 0.17920665f, -0.08316115f, -0.00400827f, 0.03017069f, 0.08760968f, 
    0.05840829f, 0.04930889f, 0.01269263f, -0.16631788f, 0.46994120f, 0.60828149f, 0.08437469f, 0.49847761f, 
    0.22595932f, 0.12963921f, 0.04032124f, 0.16105466f, 0.16217554f, -0.04696743f, -0.07031117f, 0.08970746f, 
    0.47850898f, 0.46918738f, -0.24342558f, 0.37735128f, -0.16110080f, 0.09610786f, -0.07819692f, 0.22584891f, 
    -0.23644829f, 0.19737576f, 0.11896957f, -0.06394326f, -0.02097531f, -0.29011020f, -0.05102687f, -0.01978360f, 
    0.14817557f, -0.03084213f, -0.09803634f, 0.06583682f, -0.16556540f, -0.16243866f, -0.07183139f, -0.09764016f, 
    -0.18206257f, 0.11621810f, -0.30987629f, -0.16382799f, 0.05620619f, -0.15003607f, 0.01293560f, -0.01147682f, 
    0.10758672f, 0.03186066f, -0.06783844f, 0.05330694f, -0.59713578f, -0.10875649f, -0.70640850f, -0.08424550f, 
    0.27891362f, 0.07802093f, 0.01535506f, 0.19603693f, 0.04646147f, 0.13021906f, 0.02124847f, -0.09114792f, 
    -0.07213397f, -0.04766626f, -0.06687158f, -0.00707891f, 0.05796752f, -0.04538428f, -0.02215040f, 0.00191493f, 
    -0.03102075f, -0.04139429f, -0.04075055f, -0.00249389f, 0.05036052f, -0.03947349f, -0.05496453f, 0.01409708f, 
    -0.06771771f, 0.00289607f, 0.03740324f, 0.05652714f, -0.00488052f, -0.06702003f, 0.03640258f, -0.01653114f, 
    0.01755622f, 0.00499143f, -0.02580490f, 0.06104189f, 0.02884402f, -0.03479232f, -0.04475771f, -0.02323100f, 
    -0.07856916f, 0.03001533f, 0.03990774f, -0.00101108f, 0.04830990f, -0.03792066f, 0.00390927f, -0.01620955f, 
    -0.06524006f, 0.00813058f, -0.04533077f, -0.04627334f, -0.05069048f, 0.02412522f, 0.01575967f, 0.05318128f, 
    -0.04617993f, -0.03262370f, 0.01551883f, -0.04565492f, 0.02866672f, -0.05743526f, -0.00044373f, 0.02917526f, 
    -0.05815111f, -0.01425740f, -0.02986073f, 0.02851995f, 0.03301831f, -0.03385518f, -0.04962381f, -0.01295277f, 
    -0.04864644f, 0.05429707f, 0.01932398f, 0.02430638f, 0.05019721f, -0.02842539f, -0.06728601f, -0.07090309f, 
    0.03974932f, 0.06849995f, 0.04464417f, 0.01182357f, -0.01218248f, 0.00312907f, -0.06018901f, -0.00638621f, 
    -0.04055032f, -0.01646816f, 0.05288487f, 0.01209514f, 0.03293855f, 0.02235905f, -0.01759042f, -0.06460181f, 
    -0.06017236f, -0.06506411f, 0.04451709f, -0.03069748f, -0.03762814f, 0.04691613f, -0.05528541f, 0.02660414f, 
    0.04215161f, -0.02073933f, -0.05381949f, 0.03443788f, -0.03795632f, -0.00812230f, -0.06738485f, -0.01567426f, 
    0.05085195f, -0.01592706f, -0.06984667f, -0.08452871f, 0.04504817f, 0.06243396f, -0.00038173f, -0.04690466f, 
    -0.03695292f, -0.01006781f, -0.04098104f, -0.07278243f, 0.05020379f, 0.01489379f, -0.03085952f, 0.00347870f, 
    -0.01818513f, 0.04228587f, -0.06642506f, -0.04222585f, -0.07582864f, -0.02167680f, -0.07264118f, -0.00245994f, 
    0.05461568f, -0.04032078f, -0.03508874f, 0.04258759f, -0.02309790f, -0.00065573f, 0.04624275f, -0.02935637f, 
    0.03437633f, 0.00712160f, -0.01533143f, -0.04159339f, -0.00267285f, -0.01067759f, -0.00750794f, -0.07793648f, 
    0.05256070f, -0.01965069f, 0.06190225f, 0.04284228f, -0.01011213f, -0.02433813f, -0.00732317f, -0.05400356f, 
    0.04050053f, 0.01852849f, -0.04115557f, 0.01281178f, 0.01542716f, 0.00822338f, -0.05761486f, 0.02417983f, 
    -0.01247236f, -0.04453183f, -0.05693266f, 0.01252838f, 0.00148970f, -0.01832827f, -0.06106239f, -0.00260310f, 
    0.06200004f, -0.05958884f, 0.01646543f, -0.00333201f, 0.02121786f, 0.07396875f, 0.07848448f, 0.06221607f, 
    0.03563187f, -0.01345857f, -0.04012292f, 0.01779219f, -0.03067049f, 0.00905858f, -0.06189740f, -0.02721287f, 
    -0.03398112f, -0.00983925f, 0.05708883f, 0.04611260f, 0.05883152f, -0.02294314f, -0.06365229f, -0.07180960f, 
    -0.06019741f, 0.16447651f, 0.16145813f, 0.35050654f, 0.20072185f, 0.15250248f, -0.02372055f, -0.10955883f, 
    -0.17088732f, -0.04802188f, -0.00386337f, -0.02257798f, -0.02959896f, 0.13352285f, 0.20685476f, -0.34312215f, 
    -0.02353904f, -0.02287012f, 0.09912641f, 0.01293445f, -0.00050197f, 0.00155653f, 0.01851125f, 0.00490511f, 
    -0.17646271f, -0.00430524f, 0.04025938f, -0.19684884f, 0.03834969f, 0.14803301f, -0.04413145f, -0.01596915f, 
    0.08563607f, -0.06999707f, -0.19753955f, -0.20116073f, -0.48849380f, -0.28017056f, -0.20383854f, -0.13053212f, 
    0.09969309f, 0.09639518f, -0.00673288f, 0.02606895f, -0.02868306f, -0.04991464f, -0.16700678f, -0.23271137f, 
    0.07250002f, -0.19265369f, -0.02194906f, 0.06571553f, -0.04701986f, -0.14689122f, -0.00050726f, 0.16381274f, 
    0.08097796f, -0.01123198f, 0.25039715f, 0.05187820f, 0.24179901f, -0.02415487f, 0.14996541f, -0.12736098f, 
    0.10159663f, -0.05412189f, -0.10577956f, -0.05049529f, 0.08289549f, 0.10458757f, -0.01507750f, -0.02704813f, 
    0.03366510f, 0.03461415f, 0.40858981f, 0.22104910f, -0.01869659f, -0.13207698f, 0.11240853f, 0.34927717f, 
    0.03524162f, -0.07678293f, -0.10963328f, 0.00976089f, -0.36700290f, -0.01441018f, -0.09598748f, 0.04456285f, 
    -0.06848148f, 0.08354323f, 0.03187006f, 0.11275450f, 0.08524100f, 0.01246381f, 0.14435545f, -0.04097306f, 
    0.20472603f, 0.38966385f, 0.29418141f, 0.46193144f, 0.14114171f, 0.13956334f, -0.07235935f, 0.00875073f, 
    0.09198899f, -0.08497384f, 0.00153676f, 0.05950120f, -0.04739989f, -0.06577635f, -0.21522626f, -0.03719662f, 
    0.15417512f, 0.31581613f, -0.05361199f, 0.17545323f, -0.16148968f, 0.02942598f, 0.05924771f, 0.04366945f, 
    -0.02620525f, 0.22408868f, -0.01563395f, 0.01644287f, -0.35124934f, 0.08561698f, -0.12360465f, -0.24456228f, 
    0.02507567f, 0.36105520f, 0.18093464f, -0.01282326f, -0.08144414f, 0.03509917f, -0.04137979f, -0.18412347f, 
    0.19451025f, 0.08811777f, -0.00842704f, -0.07527491f, 0.03814928f, -0.10406624f, -0.20430768f, 0.18974449f, 
    -0.43066901f, -0.06175110f, -0.02754591f, -0.15735057f, -0.04033724f, -0.04278284f, -0.01574915f, 0.23596346f, 
    0.01196420f, -0.13794354f, 0.17213862f, -0.19003044f, 0.45425206f, 0.00825805f, 0.35232079f, 0.60364574f, 
    0.04132463f, -0.21094893f, -0.15117216f, 0.07442184f, 0.02025813f, 0.15180218f, 0.16289192f, 0.17743847f, 
    0.10769890f, 0.12130665f, 0.16170247f, 0.22279270f, -0.11888610f, -0.09366491f, -0.16983213f, -0.11280701f, 
    0.14580567f, -0.08585948f, 0.29065195f, 0.18340799f, -0.58220667f, 0.06780661f, 0.04796339f, -0.04737286f, 
    -0.00715442f, 0.08519674f, -0.11487064f, 0.01361774f, 0.09598346f, 0.05298299f, 0.11285326f, 0.01285634f, 
    0.17759115f, -0.53028429f, -0.26391891f, -0.11699810f, -0.04377468f, -0.13015859f, 0.15567543f, -0.29255974f, 
    -0.06438127f, -0.28245792f, 0.08667874f, -0.01309791f, -0.35268825f, -0.17097537f, 0.31909758f, 0.08520063f, 
    0.07905445f, 0.03577193f, 0.01969126f, 0.15200254f, 0.23083131f, 0.10971387f, 0.05783127f, 0.18137816f, 
    0.39897099f, -0.14697036f, 0.01823075f, -0.32188419f, -0.08199062f, 0.10898547f, -0.03288326f, 0.10688146f, 
    0.39619690f, -0.03114791f, 0.37193710f, 0.00227808f, -0.10943618f, -0.40834191f, -0.39274886f, 0.04313640f, 
    0.10219967f, 0.40604630f, 0.19652928f, -0.03642223f, 0.50280809f, -0.09198968f, 0.18432535f, -0.02781522f, 
    -0.24413931f, -0.42314249f, -0.04362642f, 0.54709399f, -0.01952624f, 0.14653750f, 0.06332050f, -0.09505033f, 
    0.17032816f, 0.03952142f, -0.17496595f, -0.27119297f, -0.03804062f, 0.11710843f, -0.04342883f, 0.06011033f, 
    0.21307635f, -0.01932199f, -0.07717772f, -0.09173666f, 0.07700542f, 0.04652989f, -0.01672319f, 0.22857712f, 
    -0.25607139f, -0.38350737f, 0.04551587f, 0.31654078f, -0.06553020f, -0.08198480f, 0.00392236f, 0.09421738f, 
    0.24193999f, -0.17191167f, -0.01187153f, 0.14441435f, -0.01832123f, 0.15196575f, 0.09674714f, -0.10506365f, 
    -0.16252044f, -0.17356248f, -0.12624228f, 0.04355816f, 0.20323722f, -0.00655828f, 0.13880652f, 0.13808146f, 
    0.12113505f, -0.46525747f, 0.55535710f, 0.21441714f, 0.22871935f, 0.18748081f, -0.16571386f, 0.04807825f, 
    0.22480521f, 0.29820913f, 0.00974882f, 0.17301302f, 0.07495617f, -0.04953301f, 0.26590401f, -0.34456399f, 
    0.14498962f, 0.19766587f, -0.10597409f, 0.00464229f, 0.15060848f, -0.26040080f, 0.00020088f, -0.19951552f, 
    -0.09159295f, 0.07597300f, 0.20721588f, 0.20155321f, -0.21086656f, 0.44852665f, -0.11461712f, -0.23347676f, 
    -0.06971942f, 0.13862661f, -0.15479283f, -0.19781469f, -0.11146255f, -0.00711610f, 0.23443045f, -0.06300340f, 
    0.12344715f, -0.08728991f, -0.02885514f, 0.14851938f, 0.01185278f, -0.12653844f, -0.08098135f, 0.13101023f, 
    -0.85910565f, -0.03518759f, -0.13535310f, -0.39122418f, 0.16715540f, -0.22327158f, 0.12036807f, 0.15067837f, 
    0.08631297f, 0.02639742f, 0.22332329f, -0.04283347f, 0.35260713f, 0.08983953f, 0.18474393f, 0.03410043f, 
    0.07349267f, -0.30175868f, -0.21168020f, 0.19862215f, -0.05394662f, 0.11673836f, 0.03111004f, 0.15349483f, 
    0.29009861f, -0.02220701f, 0.38872433f, -0.21005800f, -0.00493050f, -0.06771201f, -0.31484222f, -0.17102490f, 
    0.16384098f, -0.04191477f, 0.15995264f, -0.08957960f, -0.32629266f, 0.16212080f, 0.50750154f, -0.04861130f, 
    -0.16018291f, -0.22237976f, -0.20738430f, 0.29768801f, 0.05760910f, 0.19799522f, -0.10057171f, 0.13795720f, 
    -0.11824866f, -0.06631715f, -0.27996969f, -0.38427177f, -0.06540687f, -0.03412886f, -0.03902553f, 0.00492806f, 
    -0.09098392f, 0.14562622f, 0.03859923f, -0.10572888f, 0.12874693f, -0.23802315f, -0.42449334f, 0.30065918f, 
    0.13367133f, 0.05182348f, -0.09151973f, -0.14054687f, -0.03399897f, -0.08277736f, -0.14530998f, -0.01918400f, 
    -0.16041322f, 0.01614385f, 0.15403523f, 0.10317418f, -0.10292493f, -0.01601209f, -0.08720969f, 0.11343648f, 
    -0.15539069f, 0.20152430f, -0.02976907f, -0.14943729f, 0.11747583f, 0.09500364f, 0.14649968f, -0.05873608f, 
    -0.11367973f, -0.20892617f, 0.17746864f, -0.03098017f, -0.12781484f, 0.21353830f, 0.02922147f, 0.00984683f, 
    -0.12419382f, 0.09324576f, 0.01832111f, -0.09306278f, 0.07272367f, -0.07457089f, -0.09873874f, 0.03504599f, 
    -0.17922980f, -0.00063252f, -0.00121812f, 0.27604687f, -0.12463349f, -0.05424839f, -0.10245940f, 0.11475302f, 
    -0.10973626f, 0.10054687f, 0.23481411f, 0.22578989f, 0.05654214f, 0.01597498f, 0.04165630f, 0.06828023f, 
    0.27607691f, 0.50341439f, -0.34606883f, -0.23960309f, 0.25196522f, 0.39045733f, 0.15902816f, -0.07201380f, 
    -0.13611132f, -0.00444281f, -0.10007023f, -0.19853595f, 0.51681030f, 0.37489218f, 0.02367881f, 0.00457306f, 
    0.02409402f, -0.11306375f, -0.02652247f, 0.13858347f, -0.25283405f, 0.11265063f, 0.12917583f, 0.04051549f, 
    -0.31797734f, 0.57079130f, -0.19208579f, -0.34354833f, -0.20237136f, 0.19248506f, 0.03437718f, 0.01268639f, 
    -0.14179732f, 0.04595064f, -0.16169083f, 0.01651932f, -0.23190969f, 0.23417120f, -0.15758651f, -0.00419978f, 
    0.01492173f, -0.23455928f, 0.07707326f, 0.18097189f, -0.16412264f, 0.09442978f, -0.07164248f, 0.09668408f, 
    -0.22985414f, 0.26443151f, -0.02460790f, -0.02356488f, 0.21003310f, -0.10953192f, -0.10904713f, -0.00017039f, 
    -0.11391372f, -0.03621365f, 0.03384046f, 0.17968246f, 0.13571699f, -0.00460989f, -0.28117090f, 0.12241366f, 
    -0.08891600f, 0.05523892f, -0.08573660f, 0.04719818f, -0.08883335f, 0.06911717f, 0.03936842f, -0.11045820f, 
    0.14154167f, 0.19946633f, 0.46683863f, 0.18449458f, 0.03866755f, -0.09277748f, -0.20884082f, -0.29490983f, 
    0.01060522f, 0.35791624f, -0.10917156f, 0.17308886f, -0.24231064f, 0.62242770f, 0.19273779f, -0.25949988f, 
    -0.13009439f, 0.07568104f, 0.16865781f, -0.17847985f, 0.24770795f, -0.00202032f, 0.04140297f, 0.14219382f, 
    0.10553801f, 0.16567424f, 0.31016171f, -0.10130543f, -0.09383883f, 0.00535436f, -0.00132134f, 0.02187536f, 
    0.05720437f, 0.21682814f, 0.05841139f, 0.17055598f, 0.42156926f, -0.04469507f, 0.01945512f, -0.09553569f, 
    0.04771762f, 0.00678795f, -0.13126950f, -0.05857279f, 0.04286277f, 0.10261577f, -0.03496460f, -0.03623247f, 
    0.51815289f, -0.07398247f, -0.18944024f, -0.01833170f, -0.20035721f, 0.12040268f, 0.08939841f, 0.06595516f, 
    -0.12984991f, 0.02663850f, 0.09307773f, -0.19444670f, -0.06723881f, -0.41735888f, -0.15266241f, 0.06894515f, 
    0.02105562f, -0.06037467f, -0.01827857f, -0.01964401f, 0.04546038f, 0.00754477f, 0.15079804f, 0.05112179f, 
    0.41546631f, 0.29101840f, -0.23247610f, 0.05160563f, -0.00670963f, -0.10164984f, 0.16778250f, -0.05878737f, 
    0.11026980f, -0.17729898f, 0.05033309f, 0.30710316f, 0.36377475f, -0.11361469f, -0.25286511f, -0.20087162f, 
    -0.10141236f, -0.01602088f, 0.41958243f, -0.22665580f, 0.13913533f, -0.06603018f, 0.10116515f, -0.04055692f, 
    -0.42594370f, -0.00220105f, -0.13975284f, 0.05836428f, -0.05623791f, 0.19323821f, 0.22837824f, -0.11633599f, 
    -0.10634502f, -0.09170549f, 0.00711417f, -0.05552034f, -0.27140304f, -0.12643230f, 0.15763484f, -0.12873350f, 
    -0.00889000f, -0.24151847f, 0.24908257f, 0.08595672f, -0.05815373f, 0.06260276f, 0.01759274f, 0.30967402f, 
    -0.59060997f, -0.05159142f, -0.02070244f, 0.20691505f, -0.15706205f, 0.02654569f, 0.01470650f, 0.16028225f, 
    0.10918027f, -0.06921281f, 0.21550301f, 0.08981013f, 0.29423648f, 0.22858737f, 0.41855001f, 0.17834863f, 
    -0.10258846f, -0.07601333f, -0.06695800f, 0.09739504f, -0.02284318f, 0.03651186f, 0.03663438f, -0.06459173f, 
    -0.11090810f, -0.23426449f, -0.02462734f, 0.49168533f, 0.17752895f, -0.07280119f, 0.06082829f, -0.09600918f, 
    0.01211538f, 0.12597367f, -0.13861625f, 0.03921288f, 0.02773947f, 0.25139347f, 0.22805274f, 0.09055353f, 
    0.14617723f, 0.15344283f, 0.11412686f, 0.26827279f, -0.01260893f, -0.14605363f, 0.13393360f, -0.04834313f, 
    -0.19816436f, 0.14118406f, 0.27142903f, 0.29910669f, 0.17523658f, 0.26670977f, -0.03192626f, 0.10350829f, 
    0.01369225f, -0.17142847f, -0.10752351f, -0.00419552f, -0.06633286f, 0.25103438f, 0.10812651f, 0.26031277f, 
    -0.09158394f, -0.13318704f, -0.00604852f, 0.22800447f, 0.13185515f, -0.00278956f, -0.12001579f, 0.12975246f, 
    -0.39229694f, -0.23257083f, 0.16596782f, -0.64968777f, -0.06260383f, 0.20497000f, -0.33105493f, 0.14145178f, 
    0.06650876f, -0.03369399f, 0.02168387f, 0.05023943f, -0.31023300f, -0.09566377f, 0.78722799f, -0.17387989f, 
    0.04417717f, 0.07921903f, 0.03046697f, 0.04639752f, 0.17176373f, 0.10750718f, 0.08792295f, 0.10341847f, 
    -0.22375327f, -0.15063751f, 0.01578888f, 0.31505883f, 0.06859216f, 0.00048076f, -0.05621235f, -0.07159103f, 
    0.11389592f, -0.06440133f, 0.10922635f, 0.08087704f, 0.05723694f, 0.37369469f, 0.30321532f, -0.06648110f, 
    -0.17816471f, -0.25398001f, -0.18378961f, 0.04937109f, 0.03661002f, 0.08829106f, -0.00143223f, -0.09671023f, 
    -0.10734108f, -0.13353571f, 0.18042941f, 0.51909280f, -0.16300797f, 0.15438235f, 0.03909397f, -0.41804957f, 
    -0.03371883f, -0.16537945f, 0.01365277f, 0.09674823f, 0.04227377f, 0.20678160f, 0.01339587f, 0.05718002f, 
    0.20123591f, 0.27288580f, 0.08353817f, 0.13030413f, 0.21533060f, 0.20352137f, 0.14317444f, 0.27694440f, 
    -0.21462405f, -0.05783056f, -0.40739450f, 0.12474876f, 0.03192356f, 0.06825346f, -0.04536288f, -0.12074541f, 
    0.45349491f, 0.29504961f, 0.20946015f, 0.34163776f, -0.26555720f, -0.16553169f, -0.34386718f, 0.26135048f, 
    -0.01434049f, 0.03536670f, 0.13203593f, -0.14189613f, 0.52973384f, -0.00324286f, 0.14306439f, 0.50737381f, 
    -0.28858861f, -0.06811094f, -0.06633505f, -0.25127253f, 0.19746561f, 0.00201442f, 0.09425316f, -0.03964744f, 
    -0.22536603f, -0.25837389f, -0.43906608f, -0.52974576f, 0.54817373f, 0.41721183f, -0.12885973f, -0.28813750f, 
    0.21900384f, -0.01793261f, 0.13035190f, 0.04017798f, 0.08435693f, 0.07203057f, 0.02829255f, 0.12682346f, 
    0.16003849f, 0.31485218f, 0.20484208f, 0.12805517f, 0.01799902f, 0.09335422f, 0.10877949f, -0.02473894f, 
    -0.08810435f, 0.17729579f, 0.17748277f, 0.53422153f, 0.32378533f, 0.12478938f, -0.12126935f, 0.19530442f, 
    0.02897722f, -0.02860487f, -0.15325481f, -0.22327264f, 0.02701018f, -0.24742776f, -0.10021379f, -0.02176682f, 
    0.18836461f, -0.07340887f, 0.40160120f, 0.38278824f, 0.11477897f, 0.04682373f, -0.16837302f, 0.00034092f, 
    0.09959388f, 0.13745053f, 0.24864258f, 0.23565255f, -0.06898404f, -0.28178972f, -0.18871564f, -0.33994630f, 
    -0.00167071f, 0.27746582f, -0.00769365f, -0.05748331f, -0.20322929f, -0.22475651f, -0.22085537f, -0.23307171f, 
    -0.15235175f, -0.37098366f, 0.03282664f, -0.16907437f, -0.06084958f, 0.24290088f, -0.05332259f, -0.04618675f, 
    -0.31299880f, -0.13395283f, -0.58343166f, -0.58423209f, 0.22824669f, 0.16319938f, -0.11981245f, -0.06066967f, 
    0.12953529f, 0.26100808f, 0.02104658f, 0.08453645f, 0.07677417f, -0.01819263f, -0.06754626f, 0.07276596f, 
    0.18147808f, -0.16379097f, 0.17209637f, 0.04104570f, -0.00302557f, 0.01492923f, 0.05187555f, 0.20397159f, 
    0.10583858f, 0.05734618f, -0.11245558f, 0.15114874f, 0.05208619f, -0.19436613f, 0.14730908f, -0.11732396f, 
    -0.05093919f, -0.05642964f, -0.18961799f, 0.17886430f, -0.36859429f, -0.14735577f, -0.08672673f, -0.38116923f, 
    -0.05817176f, 0.07714844f, 0.18147163f, 0.28386039f, 0.11263467f, -0.46147430f, -0.24031627f, -0.37670776f, 
    -0.07075004f, -0.10535677f, -0.11376773f, -0.15285227f, -0.03116667f, 0.39412570f, 0.53231823f, 0.26092970f, 
    0.14783034f, 0.02221597f, -0.03413781f, -0.12072920f, 0.07822628f, 0.20992863f, 0.13823543f, 0.23643397f, 
    0.05370647f, -0.01307708f, 0.06586937f, 0.00526391f, -0.03270206f, 0.00104976f, -0.04043832f, 0.01003196f, 
    0.05728575f, -0.06347711f, -0.06829472f, 0.03868709f, -0.05175861f, -0.06054056f, -0.01075728f, -0.05747719f, 
    -0.05439994f, -0.05472534f, 0.03919611f, -0.02375933f, 0.01262011f, -0.02582806f, 0.02326716f, -0.04430259f, 
    0.02570824f, 0.04873874f, -0.01381848f, -0.01736193f, -0.02028476f, 0.05640464f, -0.00127066f, 0.04262969f, 
    0.03911563f, 0.06343772f, 0.03975400f, -0.01896594f, 0.03838314f, -0.00550291f, 0.01870583f, 0.05684466f, 
    -0.00863451f, 0.03557037f, 0.00961165f, 0.06426007f, -0.05813427f, 0.03827545f, -0.02006577f, 0.04031741f, 
    0.04031277f, -0.03534303f, 0.06004643f, 0.01458847f, 0.02759211f, -0.06920017f, 0.02101167f, -0.05804335f, 
    0.02067626f, 0.01829187f, -0.05879850f, 0.03455706f, -0.01033250f, -0.01335196f, -0.04564361f, 0.03418795f, 
    -0.00211186f, 0.00928336f, -0.07163990f, -0.03195729f, 0.00320963f, 0.00504921f, -0.05593031f, -0.03961408f, 
    -0.07050136f, 0.00268820f, -0.05978019f, 0.02178674f, -0.01713210f, 0.03109436f, -0.05376508f, -0.01860682f, 
    0.05491050f, 0.01554816f, 0.01410862f, -0.01104074f, -0.06661155f, 0.02410743f, -0.04336347f, -0.03398116f, 
    0.00823755f, 0.02851623f, 0.00282577f, -0.06923170f, 0.04285829f, -0.05199977f, -0.02846022f, 0.00312916f, 
    -0.08690881f, 0.04360943f, 0.01687521f, -0.05711021f, -0.03345246f, 0.03913318f, 0.01257869f, 0.05166538f, 
    -0.07433618f, -0.08204021f, -0.05936557f, -0.02405848f, 0.02217646f, -0.07256661f, -0.03173182f, 0.01561986f, 
    -0.03976998f, 0.02181972f, -0.04603025f, 0.02871018f, -0.03329841f, -0.06190817f, 0.02437938f, -0.02759003f, 
    -0.02104136f, -0.01058456f, -0.02438883f, 0.01178418f, -0.06598807f, -0.02034681f, 0.03157051f, 0.03004777f, 
    0.03388021f, -0.00020065f, -0.02379159f, 0.03433023f, 0.02843445f, 0.07027476f, -0.03116101f, 0.02051113f, 
    -0.02675362f, 0.03680066f, 0.02379468f, 0.00762656f, 0.00800426f, -0.00736623f, -0.06143653f, -0.05957452f, 
    0.03654776f, -0.04159014f, -0.04793191f, -0.04118535f, -0.03209978f, -0.07411099f, 0.03302812f, 0.05244112f, 
    -0.01738414f, -0.02716348f, -0.05133368f, -0.04888360f, -0.07617167f, 0.05836699f, -0.03074585f, -0.02081087f, 
    -0.04012867f, -0.07302391f, -0.01064496f, 0.00782658f, -0.07718189f, 0.06212651f, -0.02979848f, -0.02498556f, 
    0.02412836f, -0.02663067f, -0.05868955f, 0.01395124f, -0.02737627f, -0.07636715f, -0.05717736f, 0.04696229f, 
    -0.03133186f, -0.03567273f, -0.02499926f, 0.02931252f, 0.03420680f, -0.07381357f, -0.00910921f, -0.00235751f, 
    -0.01433159f, 0.01833026f, -0.00822394f, -0.06094765f, -0.02176158f, -0.04823164f, 0.06885678f, 0.02667969f, 
    0.28634951f, 0.58861750f, 0.39545017f, 0.07277006f, 0.03324239f, 0.04830141f, 0.08677979f, 0.03414148f, 
    0.01129842f, -0.05122091f, -0.13308088f, 0.06229693f, -0.30909100f, -0.16323391f, 0.11158669f, -0.01702658f, 
    -0.03972643f, -0.01674674f, -0.09918690f, -0.24987848f, -0.09765603f, 0.03335094f, 0.07891192f, 0.13247049f, 
    0.32555854f, 0.02311489f, 0.27320322f, -0.00838104f, -0.05839810f, 0.00594115f, 0.08592258f, -0.03408919f, 
    0.23697069f, 0.25463578f, 0.21532281f, 0.08907069f, 0.09913837f, 0.05829292f, 0.00698631f, -0.00939519f, 
    -0.05677612f, 0.08055714f, -0.13376221f, -0.02978250f, -0.04595174f, -0.05460993f, -0.11638936f, -0.11887801f, 
    0.10927803f, -0.21174587f, -0.22023165f, -0.00291460f, 0.21644132f, -0.10687125f, -0.17597759f, 0.10337725f, 
    -0.11161379f, 0.17786145f, -0.10540231f, -0.11378086f, -0.10061010f, -0.34849596f, -0.22705151f, 0.02888635f, 
    0.10874037f, -0.00885149f, 0.06987560f, -0.08579496f, 0.04691548f, 0.13605396f, 0.00616398f, 0.17444012f, 
    0.22096853f, -0.50106776f, -0.40991521f, 0.33371416f, 0.15719754f, -0.16668527f, 0.25115705f, 0.04078036f, 
    0.21251129f, 0.08478346f, -0.00256092f, 0.52240497f, -0.34586811f, 0.10399885f, 0.45777968f, 0.05681285f, 
    0.01493933f, 0.05206735f, 0.34949878f, 0.20204400f, 0.35629308f, 0.11339525f, -0.06765547f, 0.14879957f, 
    0.28728539f, -0.06589878f, 0.11858793f, -0.27701133f, 0.15880717f, -0.08675487f, -0.03906896f, 0.13271107f, 
    0.26791200f, 0.07402430f, 0.32110649f, -0.01729278f, -0.13789153f, -0.21547113f, 0.14718440f, -0.09204234f, 
    -0.04939607f, 0.00630707f, -0.05615061f, -0.22835413f, 0.13080055f, -0.13228031f, -0.12764019f, -0.02967805f, 
    0.02591181f, -0.06409559f, -0.10101248f, -0.09548868f, 0.24237046f, 0.07997479f, 0.01955114f, 0.00926134f, 
    0.09810423f, -0.11242583f, -0.06171338f, 0.04401252f, -0.11893909f, -0.36838868f, 0.20858686f, -0.02075297f, 
    -0.00520161f, 0.07384852f, 0.11116081f, -0.03895856f, 0.13057889f, -0.11390036f, 0.14191456f, -0.03597324f, 
    0.14183678f, 0.32934713f, 0.01427287f, 0.14245981f, 0.10391686f, -0.15215205f, 0.21127072f, -0.12581050f, 
    0.06131846f, -0.10564128f, 0.13484821f, 0.02212094f, 0.35853612f, 0.30318508f, -0.36282572f, 0.07176907f, 
    0.02376199f, -0.02860781f, 0.02591007f, 0.11834799f, 0.27183938f, 0.17850621f, 0.26238826f, 0.32213163f, 
    0.17868325f, 0.10587275f, 0.00072332f, 0.11532164f, -0.04077136f, -0.05591748f, -0.05160445f, 0.11738212f, 
    -0.07270551f, 0.30737945f, 0.17953622f, 0.34372458f, -0.35437378f, -0.01636036f, 0.33560911f, 0.11117934f, 
    -0.12995709f, -0.05405214f, 0.10165079f, -0.04090510f, 0.10754040f, -0.14683205f, -0.14087282f, 0.09163996f, 
    -0.44003296f, 0.07466234f, 0.47500843f, -0.02297715f, -0.14659062f, -0.23110716f, -0.05274773f, -0.00672769f, 
    0.04895940f, 0.04088382f, 0.09199198f, 0.10426644f, -0.07028268f, -0.08996624f, -0.03064774f, 0.01855947f, 
    0.26079193f, -0.14819957f, -0.10061761f, 0.06128420f, -0.02967105f, -0.10211840f, 0.05066465f, 0.03027701f, 
    -0.25287005f, 0.24063998f, 0.14607309f, 0.12722497f, 0.14450110f, -0.07780291f, -0.03338427f, -0.17889594f, 
    -0.09587618f, -0.23092227f, -0.22656855f, -0.09335786f, -0.08518918f, -0.03151072f, 0.19464292f, -0.02520957f, 
    -0.04963090f, -0.28657183f, -0.17072630f, -0.04281202f, -0.05172846f, -0.01956815f, -0.13068140f, -0.16188739f, 
    0.23799436f, -0.09748943f, 0.21190310f, 0.04833429f, 0.16812861f, 0.06674132f, -0.05239209f, 0.10895626f, 
    -0.09837084f, -0.03017127f, 0.24183981f, 0.29849443f, 0.29776442f, -0.22588348f, 0.42843482f, 0.32048464f, 
    0.14972422f, 0.27558231f, -0.13871141f, 0.09916960f, 0.01563757f, 0.00749716f, 0.01790602f, 0.11971852f, 
    0.43308395f, -0.04931817f, 0.02088882f, -0.06074372f, 0.04222625f, 0.16196559f, 0.17445379f, 0.11876129f, 
    -0.18015377f, 0.00022577f, -0.27486104f, -0.23664127f, 0.07693499f, -0.01312171f, -0.23860791f, 0.36719728f, 
    -0.21921884f, -0.00105080f, 0.19040549f, 0.21989003f, 0.15134816f, 0.06799963f, 0.03838623f, 0.16868766f, 
    0.18262637f, 0.93515402f, -0.03294709f, -0.42414746f, 0.02940470f, 0.07198645f, 0.08884850f, -0.02473255f, 
    -0.01142898f, 0.15754700f, -0.11713838f, -0.05891307f, -0.38953760f, 0.11837251f, -0.14960371f, 0.10658590f, 
    0.01041951f, 0.17882633f, 0.11385494f, 0.00635877f, -0.10092866f, 0.13593061f, 0.06428138f, 0.30723706f, 
    0.16674371f, 0.43162763f, -0.06693591f, -0.18428129f, -0.38881943f, 0.00806625f, 0.14099516f, -0.18485259f, 
    0.02968762f, 0.26490203f, 0.22903535f, 0.16849694f, -0.24776712f, 0.12577690f, 0.03760812f, 0.21025208f, 
    0.18372545f, 0.26327208f, 0.09169099f, -0.14747630f, 0.00773324f, 0.14065012f, -0.02237489f, 0.16292222f, 
    0.03736656f, 0.42619705f, 0.17997061f, 0.29165870f, -0.28328297f, -0.15101138f, -0.15981406f, -0.06291676f, 
    0.14582857f, -0.06495705f, 0.10124616f, 0.02360543f, 0.43165007f, 0.34603706f, -0.04650306f, -0.33298117f, 
    -0.21002065f, 0.13529867f, 0.16563731f, -0.13164136f, 0.14868170f, 0.19409151f, 0.08923788f, 0.03839644f, 
    0.20564969f, 0.07799856f, 0.04965926f, -0.38301140f, -0.20908839f, -0.13581447f, -0.03269998f, -0.15258117f, 
    0.25206158f, -0.08888553f, 0.10382482f, 0.17718150f, -0.01156855f, -0.12939298f, -0.09403099f, -0.39884964f, 
    -0.21031190f, 0.07956772f, 0.03594343f, 0.17855474f, 0.13462101f, -0.07033355f, -0.09947918f, -0.26215854f, 
    0.86950982f, 0.11027386f, -0.32240656f, -0.00440851f, -0.12214874f, 0.00174834f, -0.00102698f, 0.02710190f, 
    -0.06630664f, -0.04593256f, -0.10034594f, -0.18811522f, -0.45818654f, -0.50720030f, 0.02415779f, 0.41155472f, 
    0.17083552f, 0.02229738f, -0.11090273f, -0.10208468f, 0.03018724f, -0.01841604f, -0.14730807f, 0.07553423f, 
    0.46281353f, -0.00663879f, 0.14757967f, -0.09587225f, 0.08517584f, -0.00225672f, 0.05822039f, 0.18505345f, 
    0.33857694f, 0.24285685f, 0.34732231f, -0.12276067f, 0.25764102f, 0.02700271f, -0.02941274f, -0.05585143f, 
    0.00837938f, 0.14104122f, 0.21590553f, 0.10992488f, 0.18522437f, 0.10424870f, 0.24183597f, 0.02978303f, 
    -0.24290502f, -0.05314818f, 0.13725673f, -0.04334693f, -0.26199049f, 0.16708329f, 0.16544577f, 0.29679349f, 
    0.01428077f, -0.01894514f, -0.27215797f, -0.06484392f, -0.88574576f, -0.17928469f, -0.34702981f, -0.10209686f, 
    -0.00031446f, -0.12515414f, 0.15241663f, -0.15517654f, 0.05636025f, -0.03726277f, -0.00126195f, 0.16677792f, 
    -0.16016914f, -0.16373293f, 0.03219004f, -0.14996672f, -0.02255627f, 0.13052697f, 0.07914533f, 0.31550348f, 
    -0.05913010f, 0.00171034f, 0.20606127f, 0.03031342f, 0.09807816f, 0.22270226f, 0.01041927f, -0.44567230f, 
    -0.02497059f, -0.16877609f, -0.18273081f, 0.18086356f, -0.13265991f, 0.00200169f, 0.24410820f, 0.19563846f, 
    -0.29450864f, -0.27599019f, 0.21280763f, 0.23161702f, 0.02992378f, 0.12452120f, -0.04387986f, 0.06958596f, 
    0.13534319f, -0.02550302f, -0.03336241f, -0.16226205f, 0.04930118f, 0.11638448f, -0.00748753f, -0.13108550f, 
    0.00468246f, -0.13180462f, 0.11222811f, -0.16409172f, 0.08575054f, -0.09447942f, -0.02700154f, -0.13576472f, 
    -0.14790884f, 0.06378060f, 0.09944309f, 0.01995824f, 0.14644623f, 0.09192900f, 0.09363742f, 0.08260545f, 
    0.03584157f, -0.09962418f, -0.04406002f, -0.07259434f, -0.09086042f, -0.24438260f, 0.12538145f, 0.38342094f, 
    -0.09415963f, -0.25738648f, -0.09967338f, -0.24830805f, -0.12496756f, 0.09802022f, -0.00777696f, -0.06352545f, 
    0.14973134f, 0.21652964f, 0.16025545f, 0.18773693f, 0.19128928f, 0.01285411f, 0.04672016f, -0.02510552f, 
    0.10892313f, 0.26398650f, 0.17839190f, 0.07948789f, -0.04054143f, 0.37055454f, 0.03901485f, 0.14980860f, 
    0.13282491f, 0.03853237f, -0.06470919f, -0.07504706f, -0.17665254f, 0.03244190f, -0.08935336f, 0.19368593f, 
    0.27827701f, 0.03886543f, 0.19871631f, 0.00339251f, 0.14135821f, 0.08409631f, -0.07132059f, -0.06893851f, 
    -0.10916100f, -0.05928817f, -0.10667636f, -0.22141586f, -0.02784289f, -0.00088977f, 0.13479476f, -0.23187119f, 
    0.04072727f, -0.18829831f, -0.21525832f, -0.12316065f, -0.30043232f, 0.06537383f, -0.17577884f, 0.22606574f, 
    -0.24815291f, 0.02419625f, 0.00635194f, -0.06893296f, 0.11866616f, -0.07388165f, 0.13005130f, 0.08436235f, 
    0.04754188f, 0.04693843f, 0.13439313f, 0.07262481f, 0.28424770f, 0.32653782f, 0.05760649f, -0.15527616f, 
    0.03862289f, 0.00063861f, 0.01492994f, 0.14040335f, -0.01710243f, 0.04076437f, 0.24017371f, 0.01297181f, 
    0.05490949f, -0.09632831f, -0.10708063f, -0.13895901f, 0.14929293f, 0.02112351f, -0.01510814f, 0.08794682f, 
    -0.01592920f, -0.04553424f, 0.12674673f, 0.06322324f, -0.10498555f, -0.05772138f, 0.01341999f, 0.20798902f, 
    0.21732719f, 0.00233524f, -0.04134513f, -0.09789325f, -0.11331915f, -0.19253568f, -0.02945412f, 0.09418260f, 
    -0.03464837f, 0.04612917f, -0.08351789f, 0.01826503f, 0.09684162f, -0.07090974f, -0.01388144f, -0.11563201f, 
    -0.07214449f, -0.06044656f, 0.00047081f, 0.06451293f, 0.15495266f, 0.16027874f, 0.00288998f, -0.01778900f, 
    -0.09112231f, 0.06938306f, -0.01195530f, -0.00965348f, 0.02097704f, 0.14609817f, -0.01295539f, 0.09943550f, 
    -0.22950695f, -0.11944239f, 0.24804394f, 0.18071418f, -0.12903374f, 0.08692723f, 0.03269795f, 0.25807279f, 
    0.16117430f, -0.01274089f, 0.02745574f, -0.11746313f, 0.21519370f, -0.11953527f, -0.04036177f, 0.00310527f, 
    -0.03222158f, 0.10134966f, -0.02331371f, -0.27835253f, 0.09174253f, -0.08385331f, -0.17272016f, -0.22195269f, 
    0.53606707f, -0.36254051f, 0.00212803f, -0.18094054f, -0.06134046f, -0.06792405f, 0.09216166f, 0.08882464f, 
    0.17534059f, 0.32099202f, -0.26766089f, 0.24715587f, 0.33665779f, 0.06608459f, -0.26142624f, -0.07367137f, 
    0.04423968f, 0.26006329f, -0.20181349f, 0.24352768f, 0.04264623f, 0.02895008f, 0.02463310f, 0.11376891f, 
    -0.03830344f, 0.09980375f, 0.03821164f, 0.14414091f, -0.16613723f, -0.24524586f, -0.09591825f, -0.04063689f, 
    -0.09066530f, -0.04734645f, -0.02566394f, 0.20510705f, 0.14834329f, 0.26356539f, 0.11865017f, -0.33098590f, 
    0.20641182f, 0.02408603f, -0.00996604f, 0.08711658f, 0.00674048f, -0.00473972f, -0.05107090f, 0.08086994f, 
    -0.56858206f, -0.55224061f, -0.15723872f, -0.62082034f, -0.00469831f, 0.00773426f, 0.02923113f, -0.12477919f, 
    0.01100721f, -0.01386271f, -0.09542622f, 0.06866377f, -0.11644131f, -0.25680891f, 0.44405612f, -0.02599641f, 
    -0.11339647f, -0.04592137f, 0.04035486f, 0.11018898f, 0.12813194f, 0.26316178f, -0.02113755f, 0.17702265f, 
    -0.02257731f, -0.25538877f, -0.09399807f, 0.19309622f, -0.11952021f, -0.01319928f, 0.00836834f, 0.04683101f, 
    0.18339278f, -0.02286950f, 0.27497968f, 0.18464667f, 0.59556770f, 0.10242639f, 0.00234181f, 0.04615583f, 
    -0.18477465f, 0.14423868f, 0.11918230f, 0.18458557f, 0.24384803f, 0.05733696f, 0.01394715f, -0.11592330f, 
    -0.80244607f, -0.57153499f, -0.07876030f, 0.13364276f, -0.03921895f, 0.10555243f, -0.02919133f, -0.06360326f, 
    0.20183407f, 0.01709311f, -0.06462031f, -0.04841053f, 0.23600313f, 0.19159217f, 0.04927470f, 0.13170372f, 
    -0.03414490f, 0.09936891f, 0.16532193f, 0.32538703f, 0.03731043f, 0.12994972f, 0.14945349f, 0.09282336f, 
    0.12053470f, -0.14084481f, 0.08020613f, -0.14534384f, -0.17939785f, -0.08371639f, -0.03253369f, -0.10481747f, 
    -0.03780834f, -0.05525910f, 0.06867919f, 0.30225286f, -0.27171820f, -0.18095478f, -0.20831606f, -0.04573106f, 
    -0.00111016f, -0.00159402f, 0.11714929f, -0.07831575f, 0.10567220f, 0.02120428f, 0.21623270f, 0.28344396f, 
    -0.20602506f, 0.23202974f, 0.21681392f, -0.07956491f, 0.19139835f, 0.20094596f, 0.22036384f, 0.13845396f, 
    0.13552801f, -0.13087496f, -0.28268257f, -0.15844747f, 0.24501507f, 0.46504867f, 0.07710623f, 0.37170771f, 
    0.03209577f, -0.07536978f, 0.11697239f, 0.29140118f, 0.08102012f, -0.08887839f, 0.06088503f, 0.00104645f, 
    -0.24277771f, 0.31420583f, 0.28923240f, 0.58744609f, 0.08989743f, 0.16781583f, -0.30043995f, -0.16372696f, 
    0.25528228f, 0.20103095f, 0.14254245f, -0.03952572f, 0.67933846f, 0.37273502f, 0.14755093f, -0.01468057f, 
    0.04576322f, 0.25192717f, 0.08548380f, 0.16782142f, -0.21522078f, -0.12433573f, -0.00857491f, -0.09515436f, 
    -0.16061465f, -0.39725742f, 0.01149254f, -0.01961591f, -0.11621934f, -0.17754138f, 0.03961798f, -0.12871382f, 
    -0.03587484f, -0.02378739f, 0.17115474f, -0.04255060f, 0.22664303f, 0.12033677f, 0.16457765f, 0.02392682f, 
    -0.08791883f, 0.04617366f, 0.15667818f, -0.03194163f, 0.14062344f, 0.03493185f, -0.03656079f, -0.08140428f, 
    -0.16632076f, -0.47706661f, -0.42217177f, -0.18627255f, 0.37550050f, 0.10212276f, 0.19716272f, 0.12736137f, 
    0.17651410f, -0.21834144f, -0.26898590f, -0.13238603f, 0.43872258f, 0.37019968f, 0.65091914f, 0.25483173f, 
    -0.01446949f, -0.06052956f, 0.14380443f, 0.21096930f, -0.12867962f, 0.04375989f, 0.10655178f, -0.10355169f, 
    0.42868140f, -0.33455998f, -0.00722028f, -0.23781012f, 0.11588638f, -0.09727271f, 0.09938176f, -0.03391405f, 
    -0.16055593f, 0.01613697f, -0.03048846f, 0.14987506f, -0.48928317f, -0.50158983f, -0.23165241f, -0.03767378f, 
    0.19454257f, -0.03104371f, -0.02664751f, -0.15652898f, 0.01798225f, -0.14719702f, 0.06228548f, -0.24879433f, 
    -0.24398899f, -0.35352182f, -0.04176736f, 0.05917175f, -0.03870996f, -0.04646411f, -0.00033326f, -0.11726448f, 
    -0.20801273f, 0.11942444f, -0.17501968f, -0.05441140f, 0.69798326f, 0.05381303f, 0.02445280f, 0.18440735f, 
    0.12565674f, -0.08020017f, 0.10369763f, -0.05561347f, 0.01927970f, 0.20119919f, 0.28327504f, 0.21393506f, 
    0.33239570f, 0.27971974f, 0.00976421f, 0.28849256f, 0.07410429f, 0.10319807f, -0.08635790f, -0.04228748f, 
    -0.07277694f, -0.08793281f, 0.11517199f, -0.00165369f, 0.40503919f, 0.46861401f, 0.30883944f, -0.15547192f, 
    -0.15405320f, -0.10779522f, 0.08619786f, 0.03742115f, -0.00835725f, 0.03095114f, 0.06784852f, -0.08896762f, 
    0.03567691f, -0.10950625f, 0.16302899f, -0.18855399f, -0.11408422f, 0.02777121f, 0.12270702f, 0.08749682f, 
    -0.13474777f, -0.31000817f, -0.17074446f, -0.27312776f, -0.16289602f, 0.01288008f, -0.02261321f, 0.02995054f, 
    -0.06190253f, 0.10259896f, -0.02803324f, 0.05948947f, -0.30514243f, -0.08935957f, 0.01318291f, -0.27269533f, 
    -0.13689163f, 0.12539713f, -0.10299534f, 0.05282306f, 0.06505300f, -0.08201015f, 0.14663652f, 0.03900709f, 
    -0.00048757f, 0.13012046f, 0.00928107f, -0.08988860f, -0.02140989f, 0.22998187f, 0.28270471f, 0.11755741f, 
    -0.06501170f, -0.17818597f, 0.06901046f, 0.17484364f, 0.07414169f, 0.09532049f, 0.11240315f, 0.10625669f, 
    -0.53950429f, 0.47361240f, 0.48895565f, 0.24913041f, 0.40834635f, -0.20943059f, -0.03682270f, 0.05267167f, 
    0.14593728f, -0.01358546f, 0.14844494f, -0.24441682f, -0.10055702f, -0.24328034f, -0.08151436f, -0.11710008f, 
    -0.05901066f, 0.03476795f, -0.11721391f, 0.26488337f, -0.09779122f, 0.07536190f, 0.15468831f, -0.11127872f, 
    0.10590122f, -0.29814759f, -0.07270332f, 0.62241840f, 0.06521525f, -0.07558484f, -0.06514645f, -0.13384905f, 
    0.16424163f, -0.12143597f, -0.03962545f, -0.13601820f, 0.17838080f, -0.17056525f, -0.15043205f, 0.10537141f, 
    0.29907855f, 0.26098183f, 0.05387533f, 0.49451974f, -0.23504329f, 0.02274149f, 0.14423592f, -0.12347191f, 
    0.17413543f, -0.14919010f, -0.03577976f, 0.04626349f, -0.02439349f, -0.04981338f, -0.18494937f, -0.03908203f, 
    0.00471474f, 0.19534563f, 0.16173428f, 0.00642750f, 0.26273745f, 0.39775378f, 0.16591862f, -0.23097047f, 
    0.22490086f, 0.01106585f, 0.11937133f, 0.08661108f, 0.03118310f, -0.00129961f, -0.00506151f, 0.02091995f, 
    0.19913565f, -0.18354030f, -0.02665484f, -0.22016472f, -0.05520847f, 0.01555005f, -0.13827889f, 0.27044415f, 
    -0.08196469f, -0.12006892f, -0.06833912f, -0.07307214f, -0.01387653f, -0.21350507f, 0.31555977f, 0.60711014f, 
    0.03489233f, -0.04774827f, -0.11230313f, -0.10678324f, 0.12475432f, 0.11072274f, 0.10919933f, 0.17038874f, 
    0.04859780f, 0.01981336f, -0.00395396f, 0.34988135f, -0.09412694f, -0.06034626f, -0.12444860f, -0.16050833f, 
    0.10534135f, -0.05215025f, 0.15367801f, 0.19520101f, -0.06248310f, -0.26569873f, -0.55253500f, -0.21081413f, 
    -0.08358482f, -0.10025588f, -0.21163784f, -0.14913829f, 0.04899590f, -0.04946286f, 0.10022216f, 0.01848662f, 
    0.43905830f, 0.47550789f, -0.01336057f, 0.00247457f, -0.00740956f, 0.02852232f, -0.10047000f, 0.06079029f, 
    -0.17408276f, 0.05822612f, 0.01035318f, 0.22745712f, 0.36114961f, 0.43387470f, -0.12805140f, -0.06839980f, 
    -0.04255220f, -0.01707719f, 0.10325529f, -0.06611633f, -0.11095260f, -0.10317221f, -0.03211019f, 0.01812728f, 
    -0.07037462f, 0.04713329f, -0.20349948f, 0.33090389f, 0.04883844f, -0.18377048f, 0.00908416f, 0.23268946f, 
    -0.16888338f, -0.04642637f, 0.05015382f, -0.10003845f, 0.06981039f, 0.02005591f, -0.01025214f, -0.11665047f, 
    -0.15667146f, -0.11803462f, -0.18004614f, 0.02713213f, -0.29203978f, -0.05126336f, -0.16629446f, -0.17737958f, 
    0.09902909f, 0.04632137f, 0.10266433f, -0.17120597f, 0.03348167f, -0.04608482f, -0.02433089f, 0.16977473f, 
    -0.11563508f, -0.10347875f, -0.05989746f, -0.04141705f, 0.09232023f, -0.12180009f, 0.02276808f, -0.18325938f, 
    0.29224879f, 0.08771820f, 0.17171654f, -0.10561254f, 0.06141936f, -0.07466695f, -0.02368828f, 0.11913408f, 
    0.34541541f, 0.13570757f, 0.08101357f, -0.43601203f, 0.30347946f, 0.25073969f, 0.25015977f, 0.14814627f, 
    0.14783137f, 0.04374122f, 0.05897593f, -0.09152668f, -0.36512104f, -0.11529091f, -0.16981839f, -0.05073801f, 
    -0.18384460f, 0.08722647f, 0.32549688f, 0.16485900f, -0.02510964f, -0.06287301f, -0.01154384f, -0.05405935f, 
    0.07215950f, 0.03515344f, 0.17305946f, -0.13623291f, 0.21053323f, -0.17820716f, -0.16554694f, 0.08449484f, 
    0.26351154f, 0.10037994f, 0.11353540f, 0.12568823f, -0.06032194f, -0.25773060f, 0.02214201f, 0.13220656f, 
    -0.16871184f, -0.07605568f, 0.12376314f, -0.07141275f, 0.07312915f, -0.02318707f, -0.01716000f, 0.00724805f, 
    -0.15518859f, 0.17184702f, 0.09674548f, 0.15779117f, 0.11656694f, -0.07011116f, 0.01163070f, -0.01222298f, 
    0.06113876f, -0.11652642f, 0.11969299f, 0.06499919f, 0.12109839f, 0.04450193f, -0.23165211f, -0.14822546f, 
    0.20662576f, 0.12232200f, 0.08149880f, -0.26026577f, -0.02856926f, 0.01988093f, 0.12818816f, -0.03525575f, 
    0.46553728f, -0.18113500f, -0.07345105f, 0.09368648f, -0.13426003f, -0.10393820f, -0.00758134f, -0.09637460f, 
    0.02434169f, 0.01999801f, -0.06476836f, 0.00066300f, 0.17003125f, 0.11906159f, 0.09309047f, -0.05320989f, 
    -0.07376590f, 0.05222620f, 0.05879340f, -0.05414840f, 0.38573319f, 0.33518341f, 0.15265033f, 0.23495838f, 
    -0.06667659f, 0.10553972f, -0.35136315f, -0.01531829f, -0.13577311f, 0.15163656f, 0.06693508f, 0.13286243f, 
    0.25544250f, 0.23342392f, 0.09891920f, 0.18422590f, -0.36283389f, 0.17023139f, -0.41145378f, -0.15553738f, 
    -0.11968741f, -0.03047568f, 0.14903003f, -0.05220340f, 0.16729401f, 0.08788930f, 0.02057473f, -0.02184501f, 
    -0.08955365f, 0.11158632f, -0.02835038f, -0.10193873f, 0.13693058f, -0.09966016f, -0.03197018f, -0.16749302f, 
    0.09034154f, -0.12603109f, -0.10122314f, 0.05622509f, 0.17834449f, 0.32069626f, 0.10649247f, -0.13982420f, 
    0.10523418f, 0.05456968f, -0.08569118f, 0.00985888f, 0.04958740f, -0.06831194f, 0.10030732f, 0.03885951f, 
    0.38047424f, 0.04954571f, 0.30640283f, -0.13081621f, 0.00871802f, 0.03308825f, -0.10681075f, 0.01491148f, 
    0.11149020f, -0.13576214f, -0.16392599f, -0.30482367f, 0.00891760f, -0.06135539f, 0.13396743f, 0.11941613f, 
    0.06350725f, -0.23242046f, -0.16686043f, -0.04391244f, -0.29547453f, -0.06765375f, -0.06378955f, -0.31945971f, 
    0.04545971f, -0.17275304f, 0.12809229f, -0.01200953f, 0.03640622f, -0.02929593f, -0.07689103f, 0.21039279f, 
    -0.01544649f, -0.01454830f, 0.11036381f, 0.22819391f, 0.20152530f, 0.12985504f, -0.00264618f, 0.12919657f, 
    0.09680070f, 0.25900695f, -0.26154166f, 0.07694910f, -0.01078357f, -0.10776816f, 0.16977739f, 0.16489643f, 
    -0.00880254f, 0.03028644f, 0.31063566f, -0.04823096f, 0.14565647f, 0.00631170f, 0.08773293f, 0.28635013f, 
    -0.06603163f, -0.07029289f, -0.16264810f, -0.20290025f, -0.26656261f, 0.00478240f, -0.26045674f, -0.17709278f, 
    -0.00095479f, 0.25527844f, 0.24669617f, 0.16664934f, 0.23273660f, 0.13187666f, 0.18225303f, 0.09083649f, 
    0.08748853f, 0.41377446f, 0.31608340f, -0.33321124f, 0.05525668f, 0.13007019f, 0.00711077f, 0.12742862f, 
    0.16421564f, -0.01329067f, 0.04918988f, -0.14867917f, 0.10295258f, 0.01400432f, -0.45304775f, -0.22932227f, 
    0.02790135f, 0.20036195f, -0.00013909f, 0.01198689f, -0.01110586f, 0.04495674f, 0.09849669f, 0.12728390f, 
    0.01820222f, 0.22131589f, -0.37010899f, 0.00145853f, -0.14098352f, 0.03407903f, -0.01170960f, -0.25004777f, 
    -0.12344089f, 0.34005731f, 0.11486273f, -0.01419265f, -0.06828864f, 0.08069799f, 0.02712128f, -0.31973824f, 
    0.20106031f, 0.15920594f, 0.08955026f, -0.30543467f, 0.02322480f, 0.02347478f, -0.07351980f, 0.16259991f, 
    0.07417361f, 0.12372641f, 0.01040183f, 0.22401060f, -0.12542164f, -0.20702896f, 0.24631403f, -0.10213696f, 
    -0.08745968f, -0.14960428f, 0.06028607f, -0.18536659f, 0.19656193f, 0.19748122f, 0.04149921f, 0.18886976f, 
    -0.17936823f, -0.31052318f, -0.01811842f, -0.12075212f, 0.13148867f, 0.24941428f, 0.03226253f, 0.28548202f, 
    0.29918069f, -0.09890813f, 0.34204453f, 0.11395618f, -0.15730250f, -0.15311190f, -0.17257449f, -0.01827633f, 
    0.12170147f, 0.04783219f, 0.29898190f, 0.29775536f, -0.24926768f, -0.16739203f, -0.39106572f, -0.43678898f, 
    -0.00480938f, 0.14605455f, -0.05164520f, 0.04799853f, 0.17483220f, -0.07480350f, -0.00716360f, 0.00424913f, 
    0.03965961f, -0.19115900f, 0.21604386f, 0.11644626f, 0.00043345f, -0.05606812f, -0.10755352f, 0.00394547f, 
    0.18589331f, -0.07139467f, 0.05744867f, 0.08563854f, -0.03466987f, -0.04947209f, 0.07189155f, -0.04289212f, 
    0.00482520f, -0.01661053f, -0.11247169f, 0.23377740f, -0.06103336f, -0.01379866f, -0.14343083f, -0.05141515f, 
    0.21462810f, -0.12559150f, 0.30754614f, -0.34369984f, -0.00398644f, 0.08101264f, -0.01422576f, -0.04510203f, 
    0.05465510f, -0.07126603f, 0.06478366f, -0.00231226f, 0.15543799f, 0.14422925f, 0.14926000f, 0.01678542f, 
    0.00031528f, -0.04796531f, 0.07476630f, 0.00374119f, 0.18826470f, 0.07151399f, 0.04378277f, 0.24988419f, 
    -0.09787308f, 0.13750330f, 0.10870055f, 0.14547396f, -0.01271040f, 0.02781487f, 0.10227603f, 0.17564350f, 
    0.02856261f, -0.04806459f, -0.01406289f, 0.10477655f, -0.10817872f, 0.41613114f, -0.00186599f, 0.24908555f, 
    -0.15937999f, 0.07731539f, -0.14581580f, 0.08148957f, -0.01380793f, -0.15902099f, 0.08795814f, -0.24612278f, 
    -0.38698509f, 0.17958635f, 0.24035810f, 0.49097639f, 0.20841138f, 0.18012387f, -0.34239799f, -0.27826303f, 
    0.08261216f, -0.08418421f, 0.16078033f, -0.35530347f, 0.27711111f, -0.18477082f, -0.05756368f, -0.39782667f, 
    -0.02222266f, 0.00040002f, -0.08431303f, -0.03693129f, -0.01997199f, 0.03025153f, 0.05463479f, -0.01594119f, 
    0.14006399f, -0.55580491f, -0.02699799f, -0.12293189f, 0.01247409f, -0.04064337f, 0.01353644f, -0.00080675f, 
    0.11940226f, -0.05813054f, 0.03799916f, -0.02613191f, 0.05122709f, 0.00806111f, 0.00626806f, -0.00978700f, 
    -0.00958217f, -0.02290447f, -0.07305142f, -0.05861977f, -0.01787182f, 0.07708352f, -0.05228522f, 0.00794736f, 
    0.20056154f, -0.08552805f, -0.11062823f, 0.00045657f, 0.11973411f, 0.21368840f, 0.13057171f, -0.02846541f, 
    -0.00520798f, -0.00327737f, -0.02905107f, -0.03740545f, -0.13521592f, -0.08421305f, 0.44922981f, -0.24236412f, 
    -0.01760380f, -0.11224032f, 0.16940671f, -0.03638509f, -0.16530681f, 0.06496246f, 0.02087543f, -0.06054857f, 
    0.54997611f, -0.07410691f, 0.18940704f, 0.05586745f, 0.03217152f, -0.07151525f, 0.11840837f, 0.00491234f, 
    0.37377647f, 0.11860248f, 0.02164133f, 0.18392973f, 0.07771563f, 0.03599093f, -0.03181104f, 0.20271285f, 
    0.12046591f, 0.22644773f, 0.03499950f, -0.16347806f, -0.10680293f, 0.12455594f, -0.01772796f, -0.08192880f, 
    0.19918171f, -0.18941282f, 0.10086367f, 0.10621068f, 0.04550981f, 0.08021116f, 0.03076428f, 0.04113093f, 
    -0.04911366f, -0.03874394f, -0.27435160f, -0.29170781f, 0.71231663f, -0.18433438f, 0.07399379f, -0.00073373f, 
    -0.19754346f, -0.11389095f, -0.11298688f, -0.12207770f, -0.09935345f, -0.14801651f, 0.18367963f, 0.00917039f, 
    -0.02390795f, 0.05365961f, -0.01112944f, -0.02926429f, 0.01854514f, 0.05596538f, -0.04258935f, -0.05780898f, 
    -0.02926164f, -0.01174424f, 0.02856084f, -0.06018512f, -0.04238243f, -0.07636663f, -0.04917860f, -0.07663125f, 
    0.04622125f, -0.04716717f, -0.00458058f, -0.02793906f, 0.02719220f, -0.01074595f, -0.05116675f, -0.05965513f, 
    -0.02337820f, -0.04537114f, -0.07076763f, -0.05963337f, 0.00617420f, -0.06600858f, -0.05055220f, -0.04306789f, 
    0.01958507f, -0.03718502f, -0.02494759f, 0.02629516f, 0.01577315f, 0.00690694f, -0.00948936f, 0.06180936f, 
    0.02990229f, -0.04319910f, -0.05868388f, 0.04805575f, 0.03231329f, -0.03834852f, 0.02024447f, -0.03355296f, 
    -0.02352580f, 0.04756491f, 0.02778340f, -0.00048663f, 0.01170350f, 0.00327816f, 0.02025552f, 0.03873665f, 
    -0.01772610f, 0.00247810f, -0.06144723f, -0.00607778f, 0.05523533f, 0.00378903f, 0.01115367f, -0.00937863f, 
    0.06010985f, -0.02655774f, 0.03548032f, 0.05586214f, -0.07795613f, 0.05354878f, -0.07048865f, -0.07871372f, 
    -0.01972811f, 0.05423379f, -0.04276938f, -0.00441112f, -0.06894775f, -0.06923187f, 0.03685972f, 0.03774330f, 
    -0.03795993f, -0.07360061f, 0.01668767f, -0.03127290f, 0.02917178f, -0.00219029f, -0.06506518f, -0.02242410f, 
    -0.07146253f, 0.05691558f, -0.07790371f, -0.06042967f, -0.04627421f, 0.00415242f, -0.01932589f, -0.04448038f, 
    0.02940578f, 0.02099296f, -0.06745724f, 0.04160187f, 0.02969126f, -0.00360632f, 0.04386672f, 0.06385643f, 
    -0.07392810f, 0.02587735f, 0.02034426f, -0.07044761f, -0.00969173f, -0.00738309f, -0.04913576f, 0.00612729f, 
    0.02057217f, -0.07275073f, -0.04301238f, -0.01019077f, 0.03471849f, 0.03572359f, 0.04246642f, -0.05957142f, 
    -0.05270987f, 0.05139441f, 0.01357117f, -0.00349059f, 0.05229811f, -0.05453355f, 0.02436811f, -0.02123116f, 
    -0.04387817f, -0.05720136f, -0.00565720f, 0.03604486f, 0.06212416f, 0.06529155f, -0.06091103f, 0.02010971f, 
    0.05870602f, -0.03822657f, -0.07111572f, 0.04380174f, 0.06196854f, 0.05769688f, -0.02470367f, -0.03467346f, 
    0.01880745f, -0.03386616f, -0.03757993f, -0.05295672f, -0.03413872f, -0.06429785f, -0.07703058f, 0.05414852f, 
    -0.00273461f, -0.02893372f, -0.00568687f, 0.06972866f, 0.06124189f, 0.04649558f, 0.05779305f, -0.07080753f, 
    0.04586333f, -0.03775033f, -0.07160058f, -0.06835335f, 0.00247827f, 0.05018956f, 0.01040111f, -0.00219289f, 
    0.01850341f, 0.06530698f, -0.04435776f, -0.06675539f, 0.01592086f, -0.06655409f, -0.01613834f, -0.02554288f, 
    -0.02012824f, 0.00578292f, -0.07487021f, -0.06612559f, -0.02970423f, -0.02537923f, 0.02269310f, 0.02785268f, 
    -0.04608485f, 0.02065494f, -0.03859029f, -0.05847687f, 0.00072011f, -0.03614412f, 0.01863446f, -0.06004483f, 
    0.03460226f, 0.00595491f, -0.03561212f, -0.03826637f, 0.05518952f, -0.01815211f, 0.03860486f, -0.00742536f, 
    0.03267860f, 0.04513234f, -0.05454813f, -0.03095795f, -0.03745929f, 0.04782918f, -0.03972943f, 0.05750424f, 
    0.04683254f, -0.05214454f, -0.02736204f, -0.07205028f, -0.05265008f, 0.04559440f, -0.04415631f, 0.06098093f, 
    -0.07236270f, -0.02724618f, 0.02499998f, -0.05081111f, 0.05941338f, 0.01133005f, -0.00345202f, -0.04719467f, 
    0.03953749f, -0.03362835f, 0.01434095f, 0.00124384f, -0.02083742f, 0.01966042f, -0.06697993f, 0.04490138f, 
    -0.05547679f, 0.00553114f, -0.00763596f, -0.00268692f, -0.05001093f, -0.01863769f, -0.03498966f, 0.05880032f, 
    -0.02060195f, 0.03659673f, 0.02512386f, 0.02411762f, -0.01975349f, -0.03767553f, 0.02707757f, -0.06006125f, 
    -0.04256912f, -0.00992844f, -0.00635882f, 0.01436517f, -0.04196841f, -0.01083477f, -0.04018253f, 0.01106210f, 
    -0.00911417f, 0.02203659f, -0.07056561f, -0.04388769f, 0.03234381f, 0.05313091f, -0.04232456f, 0.02008917f, 
    -0.04166672f, -0.02455370f, -0.01080864f, -0.04958707f, 0.04809596f, -0.02697586f, 0.05081503f, 0.05828272f, 
    0.04015834f, 0.05810164f, 0.01040870f, 0.04558435f, -0.03449481f, 0.03331344f, -0.00023082f, -0.07376531f, 
    -0.04206940f, -0.04732885f, -0.06428874f, -0.00794059f, -0.07617575f, -0.01842784f, -0.07737885f, 0.04175014f, 
    0.02767097f, 0.05273424f, 0.01804450f, -0.05062079f, -0.01603774f, 0.01643305f, 0.02704092f, -0.05214253f, 
    -0.04508352f, -0.00009295f, -0.01273207f, -0.06525593f, -0.06156400f, 0.03016048f, -0.01424068f, 0.05876249f, 
    0.03015191f, 0.01769149f, -0.01716141f, -0.04598633f, -0.03794149f, -0.00165019f, -0.02961033f, 0.02565140f, 
    -0.06677680f, 0.02879676f, -0.05543643f, -0.04554075f, 0.01657935f, 0.03502589f, 0.01702572f, -0.01176816f, 
    -0.01699303f, -0.06562202f, 0.05377087f, -0.03597389f, -0.01931017f, -0.02754215f, -0.06252800f, 0.05611959f, 
    -0.01271045f, -0.03832139f, 0.01996321f, -0.06621484f, 0.03248505f, 0.00251769f, -0.06202717f, -0.00612542f, 
    -0.02887955f, -0.01796951f, -0.02460487f, 0.04429944f, 0.05037254f, -0.03605946f, -0.03728017f, 0.02903241f, 
    0.05739396f, -0.01992238f, 0.05228810f, 0.03389610f, 0.01122265f, -0.00405484f, 0.04238365f, -0.02804615f, 
    -0.03358192f, 0.02111381f, -0.07414631f, -0.03321414f, 0.04131785f, -0.00396726f, -0.02086782f, -0.05887299f, 
    0.00615422f, -0.03493223f, -0.00987293f, -0.01022119f, -0.01617580f, -0.04057734f, -0.01644259f, -0.01723498f, 
    -0.06132157f, -0.01980157f, -0.05610397f, -0.06030871f, 0.01022881f, -0.04233770f, 0.05596707f, 0.02764759f, 
    0.02862315f, -0.07172954f, -0.02231049f, -0.00655073f, -0.05617897f, -0.06841420f, -0.06334628f, 0.06153241f, 
    0.68819141f, 0.55712342f, 0.12835322f, 0.25338322f, 0.01430253f, 0.05454021f, -0.09364299f, 0.00533795f, 
    -0.20062973f, -0.01555440f, -0.00985654f, 0.10295156f, 0.19259495f, -0.09398226f, -0.19588041f, 0.06221287f, 
    0.01284567f, -0.08052352f, 0.07686230f, -0.03301351f, 0.07283868f, 0.15427721f, 0.02483925f, 0.09320255f, 
    0.12499056f, 0.22679108f, 0.01714170f, 0.24145377f, 0.01155000f, 0.04473092f, 0.08444209f, 0.23375423f, 
    -0.02006323f, 0.04269819f, -0.02146037f, 0.09265069f, 0.06115165f, 0.15839598f, 0.07920051f, 0.04788177f, 
    -0.11550695f, 0.12044126f, -0.07714470f, 0.00292951f, -0.22335146f, -0.10207669f, -0.00624399f, -0.10224567f, 
    -0.10130262f, 0.08704307f, -0.03315189f, -0.07229795f, -0.07345111f, 0.08338469f, 0.06549037f, -0.10866413f, 
    -0.10061854f, 0.13042974f, -0.07605321f, -0.19937582f, -0.36905327f, -0.34402078f, 0.08062738f, -0.13893893f, 
    -0.03277830f, -0.21640675f, 0.16947697f, 0.20624025f, 0.05855510f, 0.07515326f, 0.10587268f, 0.06626967f, 
    -0.17997748f, 0.05533214f, -0.16315793f, -0.65905041f, 0.15487066f, -0.22273163f, 0.19641517f, -0.12777972f, 
    0.15438086f, 0.17687047f, 0.06823637f, 0.01621454f, -0.35813963f, -0.35494590f, -0.40871248f, -0.02255798f, 
    -0.02217586f, 0.01076203f, 0.00021829f, 0.19855189f, -0.19999294f, -0.08775651f, -0.00714975f, -0.16495790f, 
    0.35194629f, -0.13330272f, 0.21777780f, 0.31847417f, 0.06318376f, 0.07467832f, 0.02957965f, -0.02747873f, 
    0.10919377f, 0.11472037f, 0.02795624f, -0.01422326f, -0.03025790f, -0.25982481f, 0.03154921f, 0.15138771f, 
    0.18717252f, -0.03769959f, 0.28269055f, 0.21850385f, -0.17677835f, -0.01057253f, -0.00809030f, -0.16026519f, 
    0.15899219f, -0.06628850f, 0.21534842f, -0.01905508f, 0.12675376f, -0.02434367f, -0.18829739f, -0.05228394f, 
    0.04901151f, -0.00405140f, 0.02431417f, -0.09205215f, 0.31260279f, 0.14538208f, -0.36207059f, -0.06927907f, 
    -0.00169485f, 0.08526750f, 0.07431910f, 0.05591127f, 0.08869754f, -0.02964892f, 0.05432677f, 0.06730302f, 
    0.45967072f, 0.18713094f, 0.00023199f, 0.28335530f, 0.01477406f, 0.06540439f, 0.08673681f, 0.10989151f, 
    -0.06077303f, -0.02578475f, -0.07514024f, 0.06338295f, 0.20629430f, 0.09617159f, 0.16320680f, 0.13124068f, 
    -0.01241976f, -0.10328273f, -0.15104823f, -0.28197554f, -0.00105407f, 0.20345256f, 0.13990884f, -0.04672679f, 
    -0.02658320f, 0.23674512f, -0.03559574f, 0.06375279f, -0.06180797f, -0.07367773f, -0.07224410f, -0.08878271f, 
    0.06395876f, 0.04913414f, 0.14054118f, 0.04111220f, -0.14792633f, -0.18375845f, -0.59724057f, -0.12247290f, 
    -0.09966543f, 0.03265326f, -0.03161803f, -0.08225362f, 0.08986963f, 0.12653823f, 0.07203470f, -0.09422630f, 
    -0.14730042f, -0.34827620f, -0.27361849f, -0.13045956f, 0.32764259f, 0.00921024f, 0.05274735f, -0.16277613f, 
    0.15068392f, -0.19827621f, 0.07431699f, -0.10189554f, 0.13999818f, 0.28134525f, 0.60009730f, 0.23200685f, 
    0.13053699f, 0.09110522f, 0.11857092f, 0.30954975f, 0.11617144f, 0.05772033f, 0.07706584f, 0.05893088f, 
    0.18497562f, -0.29826888f, 0.47005790f, -0.35402307f, -0.21886154f, -0.02151082f, 0.04935792f, 0.07946429f, 
    0.04148719f, -0.09692684f, 0.15179227f, -0.15674220f, -0.34155434f, 0.01047549f, 0.01681683f, 0.28549001f, 
    0.17816196f, 0.29633710f, 0.26366237f, 0.02144805f, 0.08744919f, -0.04347158f, 0.24119647f, 0.07865083f, 
    -0.10221392f, 0.00869211f, -0.19487427f, 0.40499327f, -0.01216355f, 0.12396740f, 0.08243892f, -0.05202047f, 
    0.15241453f, 0.31118777f, -0.01300887f, 0.04076784f, 0.02209008f, 0.33742514f, 0.02263436f, 0.37926796f, 
    -0.06585844f, 0.09746656f, -0.06932181f, 0.18370062f, 0.13691185f, 0.14366655f, 0.10492381f, 0.03329558f, 
    0.07245207f, 0.00779760f, 0.14745349f, -0.01153960f, 0.25265995f, -0.07291321f, -0.15443249f, -0.20403412f, 
    0.22221439f, -0.07984884f, 0.06437162f, 0.02032851f, 0.23955208f, -0.27484679f, -0.30864346f, -0.16654468f, 
    0.05966442f, 0.00895596f, -0.21761622f, 0.10696518f, 0.02201255f, -0.01030295f, 0.11627046f, -0.15517353f, 
    0.46879143f, -0.50375521f, 0.27005661f, 0.05052428f, -0.19665486f, 0.05600252f, -0.13445143f, -0.12867147f, 
    0.03446160f, 0.11060960f, -0.04312140f, 0.10658602f, 0.33867082f, -0.53773248f, 0.17782500f, -0.20404342f, 
    0.25888011f, 0.04663045f, 0.05881209f, 0.25482565f, -0.07099640f, -0.00766999f, -0.05943310f, -0.22354938f, 
    0.25677076f, -0.44484854f, -0.26087427f, -0.29152763f, -0.12840270f, 0.11380019f, -0.07175739f, -0.15171063f, 
    -0.20753215f, 0.00932492f, -0.07463503f, -0.03136763f, 0.35828006f, 0.11447192f, 0.27868325f, -0.22453615f, 
    -0.00682677f, -0.02242651f, 0.12808952f, 0.27188426f, -0.00194744f, -0.13583878f, -0.09634891f, 0.03415648f, 
    -0.33066374f, 0.00566302f, 0.02031229f, -0.12455794f, 0.24698026f, -0.17748556f, 0.19541663f, -0.09988584f, 
    -0.13840944f, -0.09237739f, -0.00976204f, 0.03156793f, 0.10361946f, 0.08516630f, -0.29904479f, 0.26683885f, 
    0.12537791f, -0.41687718f, -0.31040886f, -0.18213299f, -0.17933045f, -0.06601335f, -0.05538878f, -0.13971554f, 
    0.28083447f, -0.05817666f, 0.46630099f, -0.05264937f, 0.04499972f, -0.00170725f, -0.10466609f, -0.18746823f, 
    0.12603100f, -0.04345563f, 0.16814490f, -0.01356007f, 0.60895950f, -0.29857063f, -0.18811122f, 0.02499301f, 
    -0.14804897f, -0.07185880f, -0.13059264f, 0.05114346f, 0.21956888f, 0.01040151f, 0.13651893f, 0.16108608f, 
    -0.08647233f, -0.06555849f, 0.00669199f, -0.04360537f, -0.10329537f, -0.01103196f, -0.06149101f, -0.05812156f, 
    -0.06165154f, -0.03671313f, -0.00776029f, 0.00758309f, -0.03868280f, -0.06474247f, -0.06961586f, -0.02885447f, 
    -0.04077791f, -0.01753583f, -0.02842931f, -0.02878870f, -0.02122178f, -0.07384302f, -0.04473711f, -0.07251908f, 
    0.00396987f, 0.03299177f, -0.03641643f, 0.03694947f, -0.07305829f, -0.01029298f, -0.06426421f, -0.01360756f, 
    0.05358678f, 0.05072909f, -0.03583969f, -0.06407773f, -0.06543570f, 0.04967536f, 0.05647280f, -0.02117467f, 
    -0.05608883f, -0.00846098f, -0.10657787f, -0.04133552f, -0.03109054f, -0.07679003f, -0.08188318f, 0.02864596f, 
    -0.06598280f, 0.02948550f, -0.01430156f, 0.00805130f, -0.05559946f, 0.00462360f, -0.05824137f, -0.06626465f, 
    -0.08786405f, -0.08220752f, -0.02577850f, -0.06279536f, -0.02833905f, -0.02043619f, -0.04881521f, 0.01295843f, 
    -0.06322353f, -0.04382923f, 0.06570850f, 0.00201657f, -0.06087163f, -0.04194830f, 0.05467064f, 0.03795528f, 
    0.00682720f, 0.05764383f, -0.05137939f, 0.02920899f, 0.02960549f, 0.04274750f, -0.00190822f, -0.02999458f, 
    -0.01033419f, -0.04689560f, 0.00871595f, 0.02584700f, -0.00172856f, -0.03996096f, -0.03700316f, -0.06912307f, 
    0.02935357f, 0.02553731f, 0.01369860f, -0.01435542f, 0.02501065f, -0.01714097f, 0.01162540f, -0.01494017f, 
    0.02147307f, -0.05330276f, -0.06306376f, -0.00682444f, 0.04456031f, -0.04631408f, -0.07717720f, 0.01989045f, 
    -0.10480775f, 0.01013054f, -0.08314429f, 0.04907882f, -0.10389820f, -0.01649735f, 0.01806540f, -0.03006455f, 
    -0.10813473f, -0.09639320f, -0.06440978f, -0.06856672f, 0.00169410f, 0.01206604f, -0.03855530f, -0.01199560f, 
    -0.04351916f, -0.03663585f, -0.05329512f, 0.02147492f, -0.10272555f, 0.02032367f, 0.00535210f, 0.02121655f, 
    0.02952079f, -0.07568312f, 0.01476100f, 0.00800030f, -0.03068338f, -0.03904127f, -0.02021956f, -0.03069912f, 
    -0.00251984f, -0.04304916f, -0.05827513f, -0.01144742f, -0.03979612f, -0.05152123f, -0.07035176f, -0.06925934f, 
    -0.04784904f, -0.03974969f, -0.00850581f, 0.01305732f, -0.04217352f, -0.07193939f, -0.07664443f, -0.05209868f, 
    -0.06625257f, -0.01606715f, -0.01368820f, -0.06336841f, -0.00785267f, -0.09087231f, -0.08369296f, 0.02455659f, 
    0.02457066f, -0.00806864f, -0.04473438f, 0.03354287f, -0.07394838f, -0.03639505f, -0.03572199f, -0.04623888f, 
    -0.08831772f, -0.04493134f, -0.05478765f, 0.02701882f, -0.07171232f, -0.05707015f, -0.02729589f, -0.00940559f, 
    -0.04569557f, -0.01866819f, -0.08876453f, -0.02062351f, -0.01030058f, 0.00853386f, -0.04683524f, 0.01946434f, 
    -0.02720061f, -0.04843184f, 0.03079614f, -0.02152773f, 0.03106855f, -0.00243915f, 0.01530282f, -0.02188106f, 
    0.04944363f, 0.02712432f, -0.04921596f, 0.01153016f, 0.04943779f, 0.00332970f, -0.02873985f, 0.02980168f, 
    -0.07409720f, -0.04069690f, -0.01392245f, 0.01647896f, 0.04707740f, -0.04086118f, 0.04513000f, -0.00116230f, 
    0.03728429f, -0.02172174f, -0.06664529f, -0.05875250f, -0.04701988f, -0.02272450f, -0.03567937f, 0.02735549f, 
    -0.05597707f, -0.03427628f, -0.07908401f, -0.05903678f, 0.01469294f, 0.02831060f, 0.02742919f, -0.04983380f, 
    -0.05158135f, -0.04210351f, 0.07334695f, -0.01590563f, -0.06649677f, 0.06052084f, -0.00193615f, 0.01743131f, 
    -0.09138437f, -0.00062360f, 0.03771292f, -0.04174884f, 0.01903472f, -0.04309223f, 0.03217496f, 0.00329760f, 
    -0.06434214f, -0.05361015f, 0.02140111f, -0.05956680f, 0.00053710f, -0.02388263f, -0.08327134f, 0.01121407f, 
    -0.06320437f, 0.04143772f, 0.03999966f, -0.02127333f, 0.06567685f, 0.01942342f, 0.01111748f, 0.03535687f, 
    0.04326326f, -0.04426042f, -0.04266265f, -0.00624616f, -0.08197920f, -0.06789641f, 0.06368192f, -0.02499095f, 
    0.07147442f, -0.08634678f, 0.00963406f, -0.06153511f, -0.03847766f, -0.02948388f, 0.04633377f, -0.08796115f, 
    -0.01191069f, -0.05703433f, -0.06301112f, 0.06338686f, -0.01462676f, -0.00308229f, 0.04209585f, -0.05031839f, 
    0.04311837f, 0.02676442f, 0.04522534f, -0.01669524f, 0.04308718f, -0.08264460f, 0.03033543f, -0.05046939f, 
    -0.06520957f, 0.01292893f, -0.06570606f, 0.05182650f, 0.01758615f, -0.06459758f, -0.01775457f, -0.05992785f, 
    0.01363596f, 0.00591657f, 0.06985222f, -0.01488613f, -0.01025168f, -0.06025115f, -0.05463569f, 0.01881665f, 
    -0.07989786f, -0.07014915f, 0.03026381f, -0.05664016f, 0.03339421f, -0.08175019f, 0.00548658f, 0.01371756f, 
    -0.04032008f, -0.06175653f, -0.03166682f, -0.00710874f, 0.04306659f, 0.01089967f, -0.07921249f, -0.02885977f, 
    -0.08538227f, -0.07815282f, -0.03730557f, -0.09192181f, -0.04726636f, -0.07987422f, -0.08311918f, 0.02482174f, 
    0.04845627f, -0.00737739f, 0.02075952f, -0.01684956f, -0.01366624f, 0.01759990f, -0.04665608f, -0.07236017f, 
    0.06255882f, 0.02304773f, 0.03395185f, -0.05737884f, -0.04388439f, 0.02619754f, 0.05181548f, -0.04241952f, 
    0.06565986f, -0.05991144f, 0.02619186f, -0.07971472f, 0.04964974f, -0.04328267f, 0.02679444f, 0.01866786f, 
    0.04262862f, 0.02002707f, 0.02166625f, 0.02919582f, -0.06356415f, -0.07168626f, -0.04639990f, 0.04004167f, 
    -0.01716417f, -0.07210100f, 0.02679608f, -0.02581768f, 0.04707419f, -0.07938867f, -0.07931238f, -0.09329093f, 
    0.04231509f, 0.02876029f, 0.03536198f, -0.06479185f, 0.00803591f, 0.03191383f, -0.04756491f, -0.05558550f, 
    0.02418439f, 0.00417435f, -0.00586938f, -0.02903431f, -0.05618620f, -0.02567296f, -0.02731069f, -0.04152538f, 
    -0.18198259f, 0.49075529f, 0.55601078f, -0.08236735f, -0.20598252f, -0.16422838f, -0.27270481f, -0.19768147f, 
    0.17238103f, 0.03484588f, -0.02884381f, 0.09770092f, -0.36641541f, -0.30590948f, 0.07254832f, 0.24735259f, 
    -0.10622353f, -0.21267416f, -0.15097980f, -0.07118818f, -0.01191149f, -0.06230286f, 0.00443035f, -0.02967677f, 
    0.00564194f, 0.19948587f, 0.28646654f, -0.08583386f, 0.02639078f, 0.23613523f, -0.03597284f, -0.05248114f, 
    0.04998216f, -0.06768921f, -0.19133368f, -0.11013183f, -0.09183417f, 0.08690908f, 0.18677661f, -0.27878547f, 
    -0.26974449f, -0.35952887f, -0.33375296f, -0.04154490f, -0.08873245f, 0.13393322f, -0.16982526f, -0.08767594f, 
    0.17509626f, -0.04779067f, -0.19159015f, -0.13386914f, 0.18116546f, 0.13395089f, -0.15325211f, 0.07331374f, 
    -0.06208935f, -0.04921188f, 0.11825382f, 0.24612173f, -0.01395062f, -0.20546034f, 0.11394834f, 0.39294928f, 
    0.02271047f, 0.26864919f, 0.01307661f, 0.21722968f, -0.04223346f, 0.04143417f, 0.09577382f, -0.05684995f, 
    -0.09840833f, -0.04563579f, -0.17154706f, 0.34164354f, 0.37982693f, -0.10774878f, -0.03477691f, -0.15496321f, 
    0.00858037f, 0.17882986f, -0.10389729f, -0.11957935f, -0.04886046f, 0.08321895f, 0.41358370f, 0.36235490f, 
    0.11544072f, 0.10490667f, 0.25495565f, 0.28132686f, 0.23946358f, 0.22037673f, 0.11916706f, 0.08971524f, 
    -0.48195836f, 0.51491535f, -0.46777618f, -0.22275104f, -0.07097299f, -0.14251669f, 0.19792527f, 0.00628200f, 
    -0.02713435f, -0.15916130f, 0.19828694f, -0.11941503f, -0.24734904f, -0.01877232f, 0.01832861f, 0.36173728f, 
    0.06806937f, -0.02381208f, 0.23947953f, -0.01967746f, -0.09607138f, 0.13736840f, -0.08007474f, 0.15168917f, 
    0.30108157f, -0.03759107f, -0.37287959f, -0.07349492f, 0.14368524f, -0.24258351f, -0.25001976f, 0.04400598f, 
    0.14632006f, 0.17172368f, 0.24226068f, 0.18300608f, -0.10709194f, -0.23360111f, 0.20742223f, 0.36180916f, 
    0.00898848f, 0.28986472f, 0.25796548f, 0.06548025f, -0.04088487f, -0.00646098f, 0.02706849f, 0.05211016f, 
    0.81008011f, 0.76687282f, 0.36007738f, 0.34232968f, -0.13968934f, -0.03247920f, -0.06351645f, -0.13685349f, 
    0.03347439f, 0.03355384f, 0.08015981f, 0.14993434f, -0.32046837f, -0.05458455f, -0.51603121f, -0.09736753f, 
    -0.24471827f, 0.26851380f, 0.07436328f, -0.20174895f, 0.26244557f, 0.15233463f, 0.16155836f, 0.17206377f, 
    -0.11341952f, -0.11105148f, -0.44007400f, -0.14973819f, -0.23790728f, -0.14267179f, 0.03449690f, -0.00330257f, 
    0.00913515f, 0.17407854f, -0.12467903f, 0.13866368f, 0.10497376f, -0.30191201f, -0.11737633f, 0.07516289f, 
    0.00238726f, -0.06677605f, -0.06801032f, -0.24610817f, -0.08483820f, -0.10994563f, 0.07951625f, -0.10702679f, 
    0.49616307f, 0.13172199f, 0.05164038f, -0.02107929f, -0.11958284f, -0.01600368f, -0.04860530f, -0.06022071f, 
    -0.18445782f, -0.03615487f, 0.00822693f, -0.14626472f, -0.34166718f, -0.47136888f, 0.08810139f, 0.36111870f, 
    0.08116222f, -0.03899553f, 0.04670429f, -0.10581814f, 0.04003243f, 0.07556681f, -0.08483794f, 0.18256494f, 
    0.10622463f, 0.31431651f, -0.31175137f, 0.14776622f, 0.08485118f, 0.03267331f, 0.13724965f, 0.03320835f, 
    0.12835370f, -0.01712721f, 0.13810161f, 0.09858789f, 0.06601132f, -0.09886856f, -0.04082732f, -0.33847982f, 
    -0.07063701f, 0.04502986f, 0.18570365f, -0.06207840f, 0.05004007f, 0.04063143f, -0.06867900f, -0.12569927f, 
    -0.11608636f, -0.20599863f, -0.19347343f, -0.00657922f, -0.09867357f, -0.00010239f, -0.00450094f, -0.23479696f, 
    -0.09153686f, -0.00901907f, -0.04431650f, 0.00008129f, -0.24076217f, -0.25234279f, 0.14092758f, 0.19504365f, 
    0.14283107f, -0.10051616f, 0.23602416f, 0.00635666f, -0.01766910f, 0.06495659f, -0.02167234f, -0.00925774f, 
    0.02362709f, -0.05682316f, -0.29692188f, -0.12487833f, 0.00853576f, -0.05714492f, 0.13720666f, -0.09573117f, 
    0.02603155f, 0.00808774f, 0.06863269f, 0.13518706f, -0.03377260f, 0.29660517f, 0.46312365f, 0.34102225f, 
    -0.05372996f, -0.20845830f, -0.01902069f, 0.10917336f, 0.02875624f, 0.18385682f, 0.12884140f, 0.11156332f, 
    -0.45945156f, 0.39629406f, 0.04728793f, 0.32485127f, 0.00272480f, 0.07257798f, 0.08655783f, -0.12606151f, 
    -0.00472456f, 0.14472082f, 0.01025513f, 0.10558986f, -0.33060914f, 0.01788805f, 0.32995048f, 0.30736908f, 
    0.04129682f, -0.10184963f, 0.12628466f, -0.07860009f, -0.11904294f, -0.07641577f, -0.05348225f, -0.04689027f, 
    -0.12893449f, 0.02298651f, 0.24139954f, 0.12245792f, 0.13829561f, 0.00687260f, -0.17216268f, 0.04410707f, 
    0.07732630f, -0.01759770f, 0.10925670f, 0.14727536f, -0.13904396f, -0.20995905f, 0.01211392f, 0.56898361f, 
    -0.18156238f, 0.01338368f, -0.03219767f, 0.26843414f, 0.10002857f, 0.04869955f, -0.05782682f, 0.10625624f, 
    0.12752685f, 0.74100536f, 0.32244459f, 0.05440558f, 0.10296655f, 0.19428135f, -0.24798730f, 0.14879794f, 
    0.03207743f, 0.10482974f, 0.20033248f, 0.15359968f, -0.16267386f, 0.30118755f, 0.01483959f, -0.38549936f, 
    -0.10781950f, 0.14975712f, 0.05912928f, -0.17834979f, 0.06064716f, -0.05901996f, 0.07851406f, 0.03480579f, 
    -0.15463604f, 0.27170950f, -0.26050612f, -0.32743761f, 0.00864076f, -0.08604090f, 0.02329593f, -0.10202190f, 
    -0.05299794f, 0.02805591f, -0.07765745f, -0.02844689f, -0.16705622f, 0.08754319f, 0.27847460f, 0.02008575f, 
    0.01451958f, -0.13570933f, -0.13560000f, -0.12572360f, -0.00063510f, 0.18683085f, -0.08762685f, -0.04266278f, 
    0.19047873f, 0.24518369f, 0.29144418f, 0.20217913f, -0.08203939f, -0.14264970f, -0.02470402f, -0.05499864f, 
    0.02030654f, -0.11085202f, 0.04365947f, 0.13110965f, -0.50052071f, -1.06159472f, -0.19742811f, 0.07909796f, 
    0.20088300f, 0.07906576f, -0.13295236f, 0.18692566f, -0.12582222f, 0.03434530f, 0.08406543f, -0.04856784f, 
    0.15256315f, 0.09267531f, 0.29825076f, -0.15914328f, -0.15177704f, -0.01485798f, -0.07204196f, 0.00258218f, 
    0.24020252f, -0.04666638f, -0.19099154f, 0.12579212f, 0.01821691f, 0.00235222f, 0.20322546f, 0.26900542f, 
    -0.02370645f, -0.08640691f, -0.01136714f, 0.10226691f, 0.22584319f, 0.03941094f, -0.01410930f, 0.25707987f, 
    -0.07028351f, 0.04060485f, -0.05597620f, -0.01815302f, -0.22334358f, 0.09898518f, 0.03568723f, -0.04470929f, 
    -0.11820538f, 0.00225909f, -0.11960556f, -0.00285848f, -0.50696766f, -0.27656424f, -0.19748537f, 0.03688532f, 
    -0.18957342f, 0.25994834f, -0.11338067f, 0.15363564f, 0.10126285f, 0.17006415f, -0.11024891f, 0.04000911f, 
    -0.41083822f, -0.18049236f, -0.31273580f, -0.22522818f, -0.03673828f, 0.01028706f, -0.25760874f, -0.21064951f, 
    0.03721086f, 0.09106763f, -0.20852022f, 0.16067624f, 0.13114180f, -0.45970348f, -0.44158694f, -0.20824963f, 
    0.10354298f, -0.23470795f, -0.10748801f, -0.13822366f, -0.02631078f, 0.11166742f, -0.15482053f, -0.04614901f, 
    0.37968883f, 0.20422387f, 0.00267123f, 0.09846148f, -0.12560496f, 0.18443471f, 0.03035200f, 0.10053686f, 
    0.04600985f, 0.19279706f, 0.20578828f, 0.15363973f, 0.21016833f, -0.04029883f, -0.27643359f, 0.08182281f, 
    0.23628446f, 0.04231272f, 0.00684396f, 0.07165712f, -0.23389205f, -0.22895887f, -0.23120189f, -0.20335507f, 
    0.17861593f, 0.13303801f, -0.01917336f, 0.02504979f, 0.11765456f, 0.05565681f, -0.13423677f, 0.05140394f, 
    -0.19738513f, 0.04420761f, -0.06918269f, -0.05725036f, -0.63434380f, -0.28181174f, -0.75735319f, -0.32910669f, 
    0.04732192f, 0.06688893f, 0.01926129f, 0.14193504f, -0.18969223f, -0.25237826f, -0.02444954f, -0.17319418f, 
    0.38457769f, 0.17826523f, 0.09769197f, 0.29597989f, -0.13669214f, -0.21358076f, 0.14359365f, 0.11404742f, 
    0.27749342f, 0.46097350f, 0.10202556f, 0.03014872f, 0.00628330f, 0.23787139f, 0.18443859f, 0.25066489f, 
    -0.11385290f, -0.02123308f, 0.10012621f, -0.05163078f, -0.00350679f, 0.03008761f, 0.06276690f, 0.16956888f, 
    0.15246649f, 0.11278790f, 0.36875671f, 0.26625103f, -0.03504306f, -0.06813224f, 0.04258164f, -0.02106447f, 
    0.05170565f, 0.01279789f, -0.11379526f, 0.01437074f, 0.29910019f, -0.13468291f, -0.22864059f, -0.16700672f, 
    -0.15073588f, -0.12236310f, -0.09773280f, -0.12204132f, 0.02127245f, -0.04029055f, -0.06458607f, 0.12890723f, 
    -0.07374395f, 0.05769499f, -0.00651000f, 0.01167524f, 0.03737193f, -0.07111068f, -0.04280996f, -0.04822966f, 
    -0.07124503f, 0.00082899f, -0.07678355f, -0.03394838f, -0.03805169f, 0.06493156f, 0.02107465f, 0.02468631f, 
    -0.02262303f, -0.01973016f, 0.04799864f, 0.02480660f, 0.03232056f, -0.02841838f, -0.06130422f, -0.03111475f, 
    0.05308685f, 0.02963841f, -0.05873902f, 0.03606182f, 0.06504558f, -0.02075104f, -0.05096807f, 0.00527638f, 
    -0.02283370f, -0.02469183f, 0.02375881f, 0.05697599f, 0.02508523f, 0.05578854f, -0.07099285f, -0.02255731f, 
    -0.04941967f, -0.03771142f, -0.03701883f, -0.04217074f, -0.01180953f, -0.01891683f, 0.01289646f, 0.00643162f, 
    0.02111267f, -0.04432916f, -0.01117559f, -0.03306745f, 0.02612296f, 0.01290730f, -0.01514248f, -0.02727746f, 
    0.00505938f, 0.04392703f, 0.02096209f, 0.03542990f, 0.02063271f, -0.05910360f, -0.02607312f, -0.00517452f, 
    0.03883874f, -0.06733193f, -0.03428484f, 0.02480089f, 0.01419357f, -0.02105285f, -0.07299568f, 0.01400303f, 
    -0.03816624f, 0.06530493f, -0.07501993f, -0.04142913f, 0.03546968f, 0.01479801f, -0.02991116f, 0.06486782f, 
    -0.03387699f, -0.04861743f, 0.02071047f, 0.06530976f, -0.04984546f, -0.04465014f, -0.04097392f, -0.02386666f, 
    -0.05089417f, -0.07444640f, -0.01710840f, -0.02521060f, -0.06512756f, -0.06928077f, 0.03074189f, -0.05717378f, 
    0.05055081f, -0.06133460f, -0.01955951f, 0.01263992f, -0.07526628f, -0.06767973f, 0.02934114f, -0.05357153f, 
    0.00319033f, -0.03737426f, 0.06082636f, -0.03564920f, 0.01638926f, -0.01461528f, 0.04922175f, 0.03601177f, 
    -0.03582152f, -0.03621142f, -0.06795155f, -0.05775496f, -0.05868125f, -0.03792300f, 0.03670206f, 0.05132330f, 
    0.05880902f, 0.01765169f, 0.02894184f, -0.00588266f, -0.00423908f, -0.05561982f, -0.00819631f, -0.06021154f, 
    0.04776425f, 0.00698594f, -0.05836109f, 0.05711628f, -0.04225813f, -0.01911247f, -0.03549690f, -0.05364070f, 
    0.00499790f, 0.03748447f, -0.03385452f, -0.00763924f, 0.03308350f, 0.05453613f, -0.04614940f, 0.00297402f, 
    -0.01005549f, 0.04102925f, 0.05399384f, -0.04323442f, -0.07664375f, -0.00396724f, -0.05219701f, 0.03374632f, 
    -0.00118645f, -0.06671391f, -0.04875329f, 0.01461344f, -0.00715632f, 0.05539706f, -0.04122577f, -0.03022239f, 
    -0.03183290f, -0.02215848f, 0.02230151f, -0.05681750f, -0.03716976f, -0.01656612f, 0.05144644f, 0.00549309f, 
    -0.00494191f, 0.02653987f, -0.06541320f, 0.03256668f, -0.00013837f, 0.00496777f, -0.07580356f, 0.02106370f, 
    -0.00454090f, 0.03178313f, -0.00649080f, 0.04873744f, 0.06169618f, 0.04757397f, -0.03830705f, -0.04200003f, 
    0.00719441f, -0.06063133f, -0.03637078f, -0.05592839f, -0.05577556f, 0.00426143f, -0.01411019f, 0.01163622f, 
    0.31362194f, 0.06247783f, -0.02225495f, -0.11918611f, -0.09831946f, 0.04647201f, 0.06180551f, -0.03525410f, 
    -0.05768422f, -0.16720669f, -0.02989403f, -0.07755698f, -0.40921733f, -0.31723201f, -0.08889651f, -0.07742687f, 
    -0.00755966f, 0.04088659f, 0.14536387f, -0.04125452f, -0.03720641f, 0.09809990f, -0.18021190f, -0.12588191f, 
    -0.08306175f, 0.02959118f, 0.10494550f, 0.05184430f, -0.07542593f, 0.10632625f, -0.02457794f, 0.09205866f, 
    0.26667985f, 0.52463967f, 0.36829016f, 0.25690579f, -0.04269969f, -0.10296976f, -0.12194384f, -0.41221774f, 
    -0.26746917f, 0.05035486f, 0.08736184f, 0.17379022f, 0.29020876f, 0.25275549f, 0.08898597f, 0.12076434f, 
    0.06486472f, -0.17803638f, -0.08795950f, -0.00891478f, 0.12070096f, 0.18795225f, 0.00713302f, 0.10680147f, 
    0.08072634f, -0.21593337f, -0.15262392f, -0.33189198f, -0.19730259f, -0.32546043f, -0.18279485f, -0.08292665f, 
    0.07834352f, -0.04407088f, 0.12874259f, -0.12158626f, 0.03681398f, 0.15321764f, -0.08574394f, 0.00606353f, 
    0.34173733f, 0.04206794f, -0.24914351f, 0.38310269f, 0.15556967f, -0.02044546f, 0.08836709f, 0.04033465f, 
    0.28302351f, -0.02930393f, -0.03645604f, 0.17608175f, -0.32341349f, 0.22744668f, 0.52065015f, 0.15146174f, 
    0.12816012f, -0.09934858f, -0.07627598f, 0.22983976f, -0.16434802f, -0.00776918f, 0.00737232f, -0.08168150f, 
    -0.35050425f, 0.16963887f, -0.07481045f, 0.40181458f, 0.07674742f, 0.15754676f, 0.02558609f, 0.02880952f, 
    0.26626831f, -0.03106626f, 0.44909930f, 0.13288802f, -0.18327287f, -0.03863060f, -0.00030745f, 0.12030737f, 
    -0.02052482f, -0.13151887f, -0.08378316f, -0.04490466f, -0.11261405f, -0.13399237f, -0.08143578f, -0.21678838f, 
    -0.09100347f, -0.03561932f, -0.01691201f, -0.09793986f, 0.20334154f, -0.09759618f, -0.19662157f, 0.15137888f, 
    0.05525584f, -0.27086928f, -0.21130627f, -0.15177146f, -0.37670588f, -0.45116925f, -0.20983773f, 0.06605729f, 
    -0.23931137f, -0.10933177f, -0.09229580f, 0.08475345f, 0.06041813f, -0.07853551f, 0.06434784f, -0.18867205f, 
    0.05061935f, 0.06905087f, 0.25487664f, 0.15109232f, -0.01319674f, 0.00430669f, 0.12922604f, 0.14573610f, 
    0.01279810f, 0.24523877f, 0.03090811f, 0.16133367f, 0.04704637f, 0.03366654f, -0.04626232f, 0.12970634f, 
    0.12280867f, 0.17487216f, -0.04898139f, 0.07321619f, 0.15462263f, 0.12349681f, 0.03072123f, 0.07665351f, 
    -0.09734488f, 0.12582621f, -0.11141533f, 0.08307607f, 0.07228762f, 0.02132220f, -0.08156018f, 0.02773879f, 
    0.04979507f, 0.19924763f, 0.05276077f, -0.00026326f, -0.35258198f, 0.15003559f, 0.58619875f, 0.27783424f, 
    0.00576584f, -0.09143487f, -0.16249137f, -0.03978246f, 0.04359286f, 0.18158223f, 0.17645462f, 0.14193191f, 
    0.28474200f, 0.23165335f, 0.48272347f, 0.27998120f, 0.09327217f, -0.02821092f, -0.22883812f, -0.03618622f, 
    -0.42581463f, -0.12780046f, -0.08540668f, 0.12593114f, 0.15695579f, 0.08916545f, 0.02246240f, 0.11212005f, 
    -0.01243465f, 0.05583521f, 0.23281661f, 0.05647293f, 0.01571474f, -0.09418025f, -0.24352531f, 0.01907775f, 
    -0.62314904f, 0.12486833f, -0.13625202f, 0.53030503f, 0.06328099f, -0.04823772f, 0.14134304f, -0.13976949f, 
    -0.08737144f, 0.46183699f, 0.17264543f, 0.34013870f, -0.12889510f, 0.06706225f, 0.01493325f, -0.14348851f, 
    0.03989411f, 0.07744399f, -0.22292440f, 0.02638705f, 0.25330043f, 0.06591140f, -0.12189487f, 0.27799839f, 
    0.08910203f, 0.09224589f, -0.18402609f, -0.13506609f, 0.20433530f, 0.02064909f, -0.04761044f, -0.16286083f, 
    -0.03104942f, -0.04307168f, -0.01216973f, -0.50615031f, 0.20934652f, -0.14750493f, 0.23171170f, 0.04587530f, 
    0.17947498f, 0.06180906f, 0.08217414f, -0.15439311f, 0.01438153f, -0.01608401f, -0.13641891f, 0.00286835f, 
    0.86493289f, 0.07249074f, -0.06974159f, -0.29710561f, -0.08863830f, 0.08388470f, 0.10566428f, -0.14505431f, 
    0.10225610f, 0.09793834f, 0.08190832f, 0.39007127f, -0.07978367f, -0.18621473f, -0.29644012f, 0.26772881f, 
    0.06056484f, -0.08592103f, 0.16383870f, -0.10862426f, -0.13110173f, 0.04061507f, -0.01829637f, -0.05259490f, 
    0.19655462f, 0.29791480f, 0.16895287f, -0.03768877f, -0.00853866f, 0.05195398f, -0.10369904f, 0.06430954f, 
    -0.08368181f, 0.22734052f, 0.19418061f, 0.37873471f, -0.40097913f, -0.36328185f, 0.44837549f, 0.31058991f, 
    -0.05433998f, -0.04354052f, 0.11971682f, -0.07137219f, -0.15833619f, -0.12056299f, -0.25841445f, -0.18576865f, 
    -0.02966140f, -0.14739390f, 0.33277568f, -0.30364263f, 0.05056737f, 0.10173070f, -0.09357386f, 0.12428492f, 
    -0.10266604f, -0.37972006f, -0.28372961f, -0.40935346f, 0.04661240f, -0.07276342f, -0.03335389f, 0.41711718f, 
    -0.05421349f, 0.11478871f, -0.05178813f, -0.03059435f, 0.04236450f, 0.09170400f, 0.03940506f, -0.12282737f, 
    0.13670865f, 0.40110770f, -0.13659792f, 0.51918817f, 0.07805115f, 0.01909490f, 0.21555215f, 0.08044171f, 
    -0.04590318f, 0.09095814f, 0.01565163f, 0.11884233f, 0.28094378f, 0.21835728f, -0.40804321f, -0.27402911f, 
    -0.03618763f, 0.11791832f, -0.03165903f, 0.14734340f, -0.20514672f, -0.18407793f, -0.04935770f, -0.27933618f, 
    0.00480829f, 0.28921166f, -0.33023992f, -0.51001865f, 0.13601507f, -0.12804005f, 0.31172395f, -0.14313295f, 
    -0.03787245f, 0.03393999f, -0.06874272f, -0.35846967f, -0.26060459f, 0.31417215f, -0.06360321f, 0.38001618f, 
    0.05033575f, -0.00894780f, 0.18383104f, -0.07704644f, 0.07438426f, 0.23769027f, 0.00533564f, 0.03993485f, 
    -0.40465820f, -0.16997688f, 0.31230807f, 0.21439937f, -0.30164471f, -0.04896131f, -0.31044105f, 0.17296174f, 
    0.15529794f, 0.11309306f, -0.01872341f, -0.12820263f, 0.24194327f, 0.19344985f, -0.29786471f, -0.09196709f, 
    0.00023083f, 0.14910676f, -0.04717181f, 0.25192294f, -0.01244785f, -0.09060409f, 0.10307621f, -0.01932935f, 
    0.11112296f, 0.28752381f, 0.57818300f, 0.04026734f, -0.08236855f, 0.03484202f, -0.10989466f, -0.20736982f, 
    -0.07175814f, 0.01950564f, -0.07515638f, 0.31685075f, 0.30928510f, 0.20166630f, 0.24386905f, -0.02792773f, 
    -0.09876631f, -0.49830970f, 0.25104105f, -0.13789633f, -0.21910661f, -0.00152411f, -0.17197931f, 0.14588898f, 
    -0.55884850f, 0.17054398f, 0.28817567f, -0.25760484f, 0.08507424f, 0.25954229f, -0.05634061f, 0.14237104f, 
    -0.04489934f, -0.30788836f, -0.00972678f, 0.08522402f, 0.02100869f, 0.17161533f, 0.16552867f, 0.27556646f, 
    -0.01158850f, 0.25061864f, -0.01285689f, 0.29213420f, 0.06453285f, 0.00819393f, 0.01451104f, -0.01560021f, 
    0.05146614f, 0.37277627f, 0.09365173f, 0.40707007f, 0.27752325f, 0.26877278f, -0.20015748f, 0.01963220f, 
    0.07957830f, 0.14762291f, -0.08150708f, -0.12887356f, 0.48205748f, 0.06018352f, 0.06575949f, 0.06106927f, 
    -0.08230383f, -0.00798155f, 0.00570833f, 0.07500608f, -0.06438546f, -0.06071931f, -0.20947143f, -0.24156548f, 
    0.07802923f, 0.40901408f, -0.40237007f, -0.12379272f, -0.15874493f, -0.14897965f, 0.11604501f, 0.02996061f, 
    0.00061712f, -0.11377445f, 0.00931562f, 0.03346641f, -0.20378175f, 0.37412417f, -0.17033359f, 0.26101762f, 
    -0.12554348f, -0.11707407f, 0.13823785f, 0.12885402f, -0.22388460f, 0.07856147f, -0.06826697f, -0.05147664f, 
    0.04164201f, 0.02719520f, -0.50055486f, -0.38296384f, 0.22902550f, -0.04049208f, 0.17849013f, 0.24785917f, 
    0.11149248f, -0.22861516f, -0.17164129f, -0.04861191f, -0.04668400f, 0.26475173f, 0.12861231f, 0.10872629f, 
    -0.00720659f, 0.05183787f, 0.18860462f, -0.05685473f, 0.00317594f, 0.07003205f, 0.13286220f, -0.21256584f, 
    0.72691351f, 0.04577349f, 0.21655416f, 0.33411697f, -0.19610418f, -0.17255428f, -0.02322537f, -0.22084168f, 
    -0.02724994f, 0.10586996f, -0.05326065f, 0.12409016f, -0.21474202f, -0.02021090f, -0.12066387f, 0.12283906f, 
    0.00388436f, 0.19680940f, 0.15152882f, -0.28084883f, 0.13892506f, -0.01884839f, 0.04601379f, -0.06516150f, 
    0.05000180f, -0.13747136f, 0.09433728f, 0.13164936f, -0.22289769f, 0.14450100f, -0.12500520f, -0.12479185f, 
    -0.04260159f, 0.02186068f, -0.11457196f, -0.06687929f, 0.91109461f, 0.16664964f, -0.08788799f, -0.10973028f, 
    -0.19945957f, -0.16488980f, 0.08235104f, -0.16248044f, 0.14535961f, 0.03030137f, 0.16383241f, -0.12008061f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04297435f, 0.09191353f, -0.15410700f, 0.04030492f, 0.14604832f, 0.07095409f, 0.04892768f, 0.15681373f, 
    -0.10483528f, -0.03577956f, 0.31956685f, 0.01247317f, 0.01334868f, 0.10308512f, -0.05790970f, 0.06126433f, 
    0.04956336f, 0.08581121f, -0.00575915f, -0.02819712f, -0.06359611f, -0.06010766f, -0.13045517f, -0.07163737f, 
    -0.02851851f, 0.19842389f, 0.11038964f, 0.09685903f, 0.03880797f, 0.18414707f, -0.12556402f, -0.04371476f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.12585348f, -0.18794926f, 0.02943131f, -0.05952759f, -0.05360148f, -0.57955694f, 0.05574027f, -0.30903885f, 
    0.34198841f, 0.02398520f, -0.57122809f, -0.16691516f, -0.56886470f, 0.23350781f, 0.19674622f, 0.08346789f, 
    0.38226920f, 0.11013061f, 0.02730542f, 0.01718094f, 0.07344519f, -0.18752030f, 0.06418475f, 0.15474695f, 
    -0.09775131f, -0.95429713f, -1.08118045f, -0.41750124f, -0.12681542f, -0.68997425f, 0.20502040f, 0.40054566f, 
    -0.11269230f, -0.24640067f, -0.24844636f, 0.01293804f, -0.32901210f, -0.72032934f, 0.15982392f, -0.02013694f, 
    -0.41783014f, -0.03867448f, -0.01827840f, 0.01299018f, -0.05816432f, 0.10572504f, 0.31795681f, 0.17321426f, 
    0.18746150f, 0.22121653f, 0.18547405f, -0.13611366f, -0.12534195f, 0.27809256f, -0.08779823f, -0.07419299f, 
    -0.11042627f, 0.51399499f, -0.07968027f, 0.70769620f, -0.03468848f, -0.36137456f, -1.10044062f, 0.52640867f, 
    0.16437338f, 0.29211253f, -0.61710513f, -0.14897063f, 0.31022078f, 0.06385048f, -0.30158636f, -0.02598287f, 
    0.13209291f, 0.06208160f, 0.27567723f, 0.11876058f, -0.42890811f, 0.12351532f, -0.01017526f, -0.39876312f, 
    -0.36425522f, -0.18136981f, 0.13117854f, -0.07828839f, 0.09853451f, -0.89094621f, -0.93570232f, -0.08234950f, 
    0.06464313f, 0.47878608f, 0.01676956f, -0.84762329f, 0.06835759f, 0.42749712f, 0.13768698f, 0.36459675f, 
    -0.04288000f, 0.20938441f, 0.28332028f, 0.09402008f, -0.21933028f, -0.48052496f, 0.31369877f, -0.61256045f, 
    0.24286376f, 0.01490494f, -0.02610236f, 0.06752208f, -0.65662420f, -0.38775915f, 0.10413231f, -0.31633475f, 
    -0.05498529f, -0.18751910f, -0.25911781f, 0.11303185f, -0.15516870f, -0.03794137f, -0.06989881f, 0.07469582f, 
    0.14134133f, 0.30723572f, 0.24367081f, -0.25222030f, 0.06298997f, 0.00038237f, 0.42599124f, -0.05918897f, 
    0.03144453f, -1.13623297f, 0.10569669f, 0.16504356f, -0.29575202f, 0.39556763f, -0.21991868f, 0.43546751f, 
    0.28949115f, 0.02879167f, 0.03500028f, -0.23749937f, 0.05784964f, -0.06426770f, 0.30826727f, -0.13325764f, 
    -0.26524225f, -0.53766727f, 0.03558707f, -0.14084467f, -0.00117572f, -0.33695233f, 0.24362373f, -0.00663313f, 
    0.16679431f, -0.37685177f, 0.12124053f, 0.17009608f, 0.10222835f, -0.42501000f, 0.15368801f, -0.11635495f, 
    0.01253605f, -0.65485674f, 0.13367005f, -0.06114260f, 0.51466179f, 0.36483482f, -0.48312944f, -0.09556680f, 
    -0.06613541f, 0.13776091f, 0.06838128f, 0.04598472f, -0.27814761f, 0.11510283f, -0.00671796f, 0.39826751f, 
    -0.01077756f, 0.42733258f, -0.11750872f, -0.16878362f, 0.01280015f, 0.29760495f, 0.26792502f, 0.09440482f, 
    -0.00666540f, -0.17748947f, -0.31193694f, -0.23120688f, 0.09542159f, -0.42141902f, -0.70145226f, -0.32697651f, 
    -0.03153405f, 0.10211264f, -0.51098043f, -0.17498536f, -0.16546360f, 0.48912683f, 0.26621985f, 0.32511747f, 
    0.01414337f, 0.01430886f, 0.39949465f, -0.52845627f, 0.42829087f, -0.08789620f, -0.60513431f, -0.68332362f, 
    0.06133765f, 0.01198128f, -0.28190270f, 0.16640554f, -0.15247720f, -0.22929749f, -0.68101865f, 0.09427997f, 
    -0.15885714f, -0.49819902f, 0.34252077f, -0.35925716f, 0.02872943f, 0.34017220f, -0.26741382f, -0.80301279f, 
    0.12413526f, -0.02343559f, -0.31215188f, -0.04592013f, -0.38323963f, 0.27349910f, 0.09951498f, -0.56906348f, 
    -0.52549762f, 0.15454270f, 0.03216495f, 0.25541803f, 0.23860624f, -0.29037207f, -1.13368595f, -0.46345332f, 
    -0.17539154f, 0.11314094f, 0.28387341f, -0.13562307f, 0.00564192f, -0.01028229f, 0.70691997f, -0.03161586f, 
    -0.04708314f, 0.03625992f, 0.07527930f, 0.07855931f, 0.16977414f, -0.11171538f, 0.48208827f, 0.31479156f, 
    -0.16003427f, 0.08860520f, -0.40447921f, -0.01808984f, 0.31744391f, -0.64712948f, 0.19325355f, -0.60710430f, 
    -0.79878509f, -0.09181260f, 0.38569674f, 0.37280902f, -0.74602181f, 0.17718454f, -0.81619489f, 0.09766678f, 
    0.41245762f, 0.27175376f, -0.45830318f, -0.02383722f, 0.12129883f, 0.25950715f, 0.13844179f, -0.05291196f, 
    -0.04727392f, 0.25152555f, -0.10278542f, -0.32381630f, -0.12691927f, -0.12206337f, 0.09695850f, -0.70749766f, 
    -0.04284749f, 0.28029069f, -0.67284673f, -0.14456120f, -0.02290474f, 0.24266645f, 0.18782905f, 0.12350314f, 
    0.12036505f, 0.14190103f, 0.04857555f, -0.95830482f, 0.26219088f, -0.03717367f, 0.30505687f, 0.27031681f, 
    -0.74658477f, -0.27971366f, 0.16917886f, 0.09040668f, -0.12950344f, -0.12322608f, 0.68679750f, 0.10114332f, 
    0.15512583f, -0.21836829f, -0.09301826f, 0.03015342f, -0.05411687f, 0.26909903f, -0.40692613f, -0.13398807f, 
    -0.04627113f, -0.43474773f, -0.15039340f, 0.02693684f, 0.32325575f, -0.31369650f, 0.79063034f, 0.60968548f, 
    -0.49647680f, -0.08308631f, -0.47910085f, 0.56164205f, 0.14621964f, -0.07498565f, -0.25690618f, 0.05512740f, 
    -0.30552793f, 0.08859613f, -0.72326994f, -0.03040872f, -0.08074492f, -0.37286320f, -0.73590505f, -0.12077307f, 
    -0.17608781f, 0.21864641f, 0.53262693f, -0.38779604f, 0.02975480f, -0.11129633f, -0.41655356f, 0.37340561f, 
    0.10070617f, -0.16419075f, 0.32771069f, -0.05107097f, 0.04570789f, -0.55329394f, -0.21926139f, 0.29320639f, 
    -0.32383189f, 0.03778495f, 0.04963139f, -0.54738837f, 0.15053493f, -0.40586486f, -0.13734747f, 0.36266699f, 
    0.46189436f, -0.56479406f, -0.36858508f, -0.14564958f, 0.09036115f, 0.43147212f, -0.79495585f, -0.09045143f, 
    0.05361392f, 0.01023063f, 0.41017908f, -0.39529818f, 0.13002199f, 0.31660652f, 0.50442606f, -0.39187688f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.31642085f, -0.10727353f, 0.33332381f, -0.07999763f, 0.00970810f, -0.03632816f, 0.19630696f, -0.26635909f, 
    0.30777645f, -0.17067319f, 0.11324839f, 0.00987070f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
