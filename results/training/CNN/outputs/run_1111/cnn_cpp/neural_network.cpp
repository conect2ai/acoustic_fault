#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.58750606f, -0.37675884f, -0.59587294f, -0.31899774f, -0.49140441f, -0.00776867f, 0.41605419f, -0.32528827f, 
    -0.26553595f, -0.30706042f, -0.37882990f, -0.00309737f, -0.44066566f, -0.61261052f, -0.27049401f, -0.04828333f, 
    -0.51862484f, -0.36579746f, -0.25983596f, -0.36123312f, -0.22347550f, 0.17007862f, -0.08223381f, 0.01944663f, 
    0.39649034f, -0.72638428f, 0.05380496f, 0.47656196f, 0.01664398f, 0.32730255f, -0.39693269f, -0.73321062f, 
    0.00934572f, -0.27182424f, -0.17325175f, 0.14502086f, 0.41499037f, -0.22396788f, 0.19280675f, 0.27824309f, 
    -0.00926664f, 0.32157949f, -0.05561092f, -0.10206737f, 0.08161953f, -0.19546697f, -0.07926407f, -0.32248983f, 
    -0.51817375f, -0.36256486f, -0.82673115f, 0.78281397f, 0.56181151f, 0.00531482f, -0.48414561f, -0.24652924f, 
    0.46700412f, -0.30403814f, 0.14037740f, 0.18840322f, -0.45697725f, 0.14710613f, 0.03990657f, 0.09483333f, 
    -0.08684567f, 0.10673786f, 0.09434605f, -0.13270842f, -0.07957521f, 0.51642418f, -0.18422501f, -0.16760325f, 
    -0.01758358f, 0.00692074f, -0.22982915f, 0.83055067f, 0.27782229f, -0.77249467f, 0.40743294f, 0.22002308f, 
    -0.28154069f, -0.28223932f, -0.05717595f, 0.12704846f, 0.18357286f, 0.37756655f, -0.22630943f, 0.06679229f, 
    0.12710626f, 0.25038177f, -0.13858120f, 0.33529031f, 0.32882014f, -0.03257389f, 0.20223245f, 0.17221445f, 
    0.03608106f, 0.10511792f, 0.12270656f, 0.13273846f, -0.05797089f, -0.60366154f, 0.47674093f, 0.78171891f, 
    0.72853160f, 0.13535002f, -0.09146065f, -0.41178197f, -0.65948379f, -0.45433441f, -0.06597668f, -0.28335124f, 
    0.05931893f, -0.06872015f, 0.14358471f, -0.15615007f, -0.23460244f, 0.28957817f, 0.08754006f, -0.10035886f, 
    0.11802998f, -0.14375092f, 0.04384624f, 0.11031361f, 0.13443734f, -0.57162744f, 0.33648083f, -0.28021595f, 
    -0.06742834f, 0.65918648f, 0.42149076f, 0.07437990f, 0.16688992f, -0.23091933f, -0.08015715f, 0.87436712f, 
    -0.54658234f, 0.44957170f, -0.23210822f, -0.12808068f, 0.03089200f, 0.34528744f, -0.14206666f, 0.04037478f, 
    -0.25739294f, 0.10606410f, -0.00333054f, 0.16089119f, -0.02917236f, -0.00728741f, -0.86363977f, 0.73904735f, 
    0.31233633f, -0.15757437f, 0.33013844f, -0.98091602f, -0.20165601f, 0.76010883f, 0.31578064f, 0.14579539f, 
    -0.21422015f, 0.08092370f, -0.19152424f, -0.05145836f, -0.00945652f, 0.33747739f, -0.20873328f, -0.19164397f, 
    -0.07342315f, -0.25297603f, -0.17775647f, 0.06583081f, 0.27675560f, 0.02054416f, -0.00011093f, 0.12570660f, 
    0.10851850f, 0.41647726f, 0.18356502f, -0.03206562f, 0.19206357f, -0.20046791f, -0.23319702f, 0.24432340f, 
    0.24445631f, 0.22029279f, -0.13037904f, 0.13932905f, -0.45982298f, 0.06829639f, -0.16233703f, -0.03687705f, 
    -0.20959082f, 0.05502386f, -0.05983976f, 0.51114023f, 0.31811315f, -0.16085760f, 0.23979884f, 0.35830593f, 
    -0.50888073f, 0.46808392f, 0.27265126f, -0.34930608f, -0.06527457f, 0.18015349f, 0.16351832f, 0.07869413f, 
    0.19580923f, 0.24406186f, 0.36614820f, 0.14576191f, -0.41645020f, -0.55162203f, -0.22547956f, 0.03587938f, 
    0.19911996f, 0.25361028f, 0.00572185f, -0.08290704f, -0.00460174f, -0.13970959f, -0.27912462f, -0.33831149f, 
    -0.41857767f, -0.41883507f, -0.70305759f, 0.27140453f, 0.66937160f, 0.52555221f, -0.07505738f, 0.44240677f, 
    0.11263774f, 0.15464725f, 0.17096959f, -0.18352795f, -0.09359711f, 0.10639990f, 0.41776660f, -0.27458802f, 
    -0.22179298f, 0.24134004f, -0.11584979f, -0.13181335f, -0.05587801f, -0.26139715f, -0.19305155f, -0.03234329f, 
    -0.22196572f, 0.00683102f, 1.28817439f, 0.64211655f, -0.09106130f, -0.07178833f, -0.43316504f, -0.23538907f, 
    -0.27501929f, -0.09559308f, 0.35390130f, 0.00290911f, -0.04893665f, -0.04136673f, 0.21731204f, 0.01579154f, 
    -0.22015068f, 0.12184144f, -0.25810638f, -0.08894014f, 0.32436079f, -0.49302086f, -0.10862292f, -0.03302731f, 
    0.05618890f, 0.01851553f, -0.21771997f, 0.35252908f, 0.23177756f, -0.67830861f, -0.52250004f, -0.18787585f, 
    -0.20120515f, -0.15122685f, 0.18047002f, -0.45267770f, -0.20712076f, 0.55276704f, -0.04268819f, 0.39189377f, 
    0.45669982f, 0.13062181f, -0.01572003f, -0.16335744f, -0.24603572f, 0.00172912f, -0.30573606f, 0.31573349f, 
    0.25038382f, 0.38940847f, 0.02795295f, 0.27965528f, -0.11481029f, -0.54241556f, -0.61468774f, -0.52040565f, 
    -0.78380793f, 1.02492452f, 0.51023048f, -0.04592267f, -0.24121833f, 0.85100108f, 0.00538590f, -0.00703220f, 
    0.18346232f, 0.16321789f, 0.14261049f, -0.30891320f, 0.02656974f, 0.14765179f, -0.19721368f, -0.15064016f, 
    -0.04009239f, 0.06724314f, 0.17128490f, 0.00246138f, -0.00751356f, 0.50619954f, -0.11632591f, -0.74958330f, 
    -0.52020788f, 0.04186212f, 0.04609871f, 0.28301302f, 1.23854268f, -0.73252207f, -0.53029746f, -0.47203699f, 
    -0.08627230f, 0.44739828f, -0.11905916f, -0.27051598f, 0.17820548f, 0.22790213f, -0.10662568f, 0.00115712f, 
    0.12976757f, 0.14999102f, -0.18275021f, -0.25796157f, -0.14384373f, -0.05774096f, 0.15605192f, -0.58513641f, 
    -0.63770920f, -0.37527585f, -0.56797802f, -0.38005981f, -0.21983953f, -0.13593976f, -0.12626673f, -0.19176255f, 
    0.20978093f, 0.39181778f, 0.05374175f, -0.32375994f, -0.04419527f, -0.10517042f, 0.26985782f, 0.06595288f, 
    -0.28127819f, 0.01473740f, -0.42566401f, -0.38615912f, 0.10787134f, -0.24895097f, -0.28861839f, 0.53970814f, 
    0.15569924f, 0.16626380f, 0.48589215f, 0.46618858f, 0.20048343f, -0.10732722f, 0.25353184f, 0.30994293f, 
    0.05218757f, -0.08143605f, 0.38144490f, -0.16353489f, -0.32837641f, -0.02145426f, 0.09338632f, 0.01883991f, 
    -0.02195901f, -0.01407133f, 0.17633650f, -0.27379906f, -0.16747619f, -0.19929861f, -0.30086523f, -0.16126788f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27572289f, -0.18590969f, 0.10925334f, 0.19803771f, 0.19626835f, 0.21933006f, 0.32067034f, 0.02161176f, 
    0.20293811f, 0.37604228f, 0.28725272f, 0.10848624f, 0.36340535f, 0.38838366f, -0.04196979f, -0.09562789f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12236729f, 0.19357531f, 0.14994323f, -0.07520024f, 0.15933873f, 0.09222144f, 0.18761930f, 0.08321847f, 
    0.11275943f, -0.02655147f, 0.07958759f, 0.08540808f, 0.05960942f, -0.15135461f, 0.27819026f, -0.00724164f, 
    -0.00163820f, -0.17553414f, -0.07470755f, -0.01815164f, 0.02078806f, -0.04082235f, 0.08861285f, 0.09019083f, 
    -0.65302098f, -0.45757023f, 0.02053308f, 0.19784334f, -0.02833732f, -0.02046408f, 0.15272303f, 0.13762666f, 
    0.02302982f, 0.05917122f, -0.01527483f, 0.02552133f, 0.37784344f, -0.20431237f, -0.26074418f, -0.16689098f, 
    0.10037056f, 0.06543320f, 0.11859346f, 0.12540323f, 0.12366945f, 0.09948876f, 0.01352050f, 0.07220311f, 
    0.23884127f, -0.09095318f, -0.03643408f, -0.04937716f, 0.05053598f, 0.01964318f, 0.07266472f, 0.03090996f, 
    0.02751145f, 0.08033226f, -0.00590527f, 0.01714698f, -0.44892830f, -0.04094395f, 0.03376254f, 0.28401589f, 
    0.01268779f, -0.01830374f, -0.08714009f, 0.13352220f, 0.10780128f, -0.06226960f, 0.10088064f, 0.19937402f, 
    -0.17108268f, -0.10198912f, 0.18480407f, 0.10775869f, 0.09362079f, -0.08641314f, -0.11525664f, 0.08581281f, 
    -0.04423353f, 0.13157202f, -0.01976012f, 0.03179145f, -0.18245882f, -0.21617602f, -0.07451488f, -0.04643151f, 
    0.01330393f, -0.12342388f, -0.03762766f, -0.11242411f, 0.24269521f, -0.03228302f, 0.00511834f, 0.00778827f, 
    -0.35886645f, 0.11142348f, -0.28619480f, -0.00045262f, 0.06848811f, 0.03281099f, -0.05237516f, 0.08196610f, 
    0.09053731f, -0.00088538f, 0.07602847f, 0.20606293f, -0.16052404f, -0.38224739f, 0.06817918f, 0.06351794f, 
    0.18262285f, -0.05687329f, -0.23806575f, 0.14025418f, 0.21224612f, 0.21064425f, -0.00998658f, 0.09360327f, 
    0.55709863f, -0.19805056f, 0.03118566f, -0.10233270f, 0.02529517f, 0.11854565f, 0.12304079f, 0.08020753f, 
    -0.03039269f, -0.11529111f, -0.09189457f, -0.10280667f, 0.19272521f, 0.12695013f, 0.22794928f, -0.18472251f, 
    0.02600515f, 0.05169166f, -0.00114386f, 0.10517907f, 0.11738933f, 0.04679254f, 0.01114307f, 0.05366308f, 
    -0.28514051f, 0.41852501f, -0.06810495f, 0.06305595f, 0.04648822f, -0.07298657f, -0.06556672f, 0.11386545f, 
    0.21420126f, 0.05426475f, 0.05346590f, 0.06563488f, 0.00322892f, 0.16935888f, 0.29419637f, -0.29696661f, 
    0.13433884f, 0.21934046f, -0.16800505f, 0.16008227f, -0.05190868f, 0.02489311f, 0.05368244f, 0.08815558f, 
    0.34094977f, 0.17653951f, 0.12542497f, -0.01672037f, 0.18946342f, 0.15233524f, 0.12584999f, 0.24376102f, 
    -0.07366771f, -0.02801241f, 0.02212733f, -0.15482701f, -0.16309762f, -0.13738616f, -0.22930431f, 0.13381989f, 
    -0.02739644f, 0.06238187f, -0.07182419f, 0.03645257f, -0.08907373f, -0.21343987f, 0.08279805f, -0.07416290f, 
    -0.00182930f, -0.11131466f, -0.01125908f, 0.20383403f, 0.06753790f, 0.07192250f, 0.03628511f, 0.11227203f, 
    0.06136269f, 0.02260394f, 0.00774499f, 0.08970930f, -0.19337682f, 0.09272369f, -0.13429153f, -0.16182804f, 
    0.15865023f, 0.10507113f, 0.00685928f, 0.17343025f, -0.00923523f, 0.07826913f, -0.10011357f, -0.09996812f, 
    0.36224169f, 0.41920522f, 0.08665524f, -0.39574736f, -0.00402541f, 0.17835982f, -0.06563371f, -0.09008356f, 
    0.01675610f, 0.09503742f, 0.09697253f, -0.15776548f, -0.25979742f, 0.16669731f, -0.01213006f, 0.16305748f, 
    0.01160876f, 0.03407829f, 0.06067500f, 0.00863341f, -0.02175122f, -0.05330011f, 0.10884162f, 0.09032908f, 
    -0.35879585f, 0.30913824f, -0.36395410f, 0.05817217f, -0.03788564f, -0.05123774f, 0.03757931f, -0.14061768f, 
    0.06653510f, -0.03307359f, 0.03318399f, 0.06484191f, -0.07453550f, -0.02838713f, -0.05717722f, -0.01468034f, 
    -0.13664788f, 0.08840337f, 0.12546806f, 0.00807900f, 0.00291326f, 0.21603420f, 0.25903243f, 0.11202382f, 
    0.77045566f, -0.00590826f, 0.00963265f, -0.37989324f, 0.01693906f, 0.13661191f, -0.08495937f, 0.00109536f, 
    0.05543905f, 0.12544626f, 0.11881966f, 0.08067545f, -0.01119111f, 0.18938421f, 0.11624201f, -0.20663366f, 
    0.00931554f, -0.06708741f, -0.07462817f, -0.00925324f, -0.10522392f, 0.09681528f, 0.17628022f, 0.08971108f, 
    0.18777864f, 0.08125005f, 0.01214467f, -0.06280394f, -0.11340839f, -0.00279090f, 0.04484142f, -0.09425479f, 
    -0.15288813f, -0.07922243f, -0.16167229f, -0.25410819f, -0.10544796f, 0.49748251f, -0.28602228f, -0.32625663f, 
    -0.06346114f, 0.08476660f, 0.02631447f, -0.18037134f, -0.09807879f, -0.12148977f, 0.00984733f, -0.03854798f, 
    -0.38978711f, 0.04845900f, 0.27300221f, 0.09223478f, -0.06984112f, 0.02921148f, -0.01937674f, 0.11589974f, 
    0.03877096f, 0.04801910f, 0.07945047f, -0.02419505f, -0.16758558f, -0.32806531f, -0.02989070f, 0.06394218f, 
    -0.06028599f, 0.08495330f, 0.01281673f, 0.17969798f, -0.19785134f, 0.14776561f, 0.04774964f, 0.13420588f, 
    -0.22561958f, -0.05075673f, 0.07975923f, 0.28688619f, -0.07172144f, 0.06914809f, 0.05941253f, 0.02406041f, 
    0.02782499f, 0.08163525f, 0.09477565f, 0.10803072f, 0.45432824f, -0.35795951f, 0.26536772f, 0.16372660f, 
    0.01945649f, 0.13757931f, 0.12642685f, -0.01000179f, 0.01216714f, -0.02774468f, -0.08263713f, -0.00583165f, 
    -0.25925860f, -0.18043330f, -0.11878194f, 0.17527445f, 0.04795220f, 0.00001122f, -0.00858837f, -0.08876381f, 
    0.07729708f, 0.06067504f, -0.17574245f, 0.10556962f, -0.15074073f, 0.13596988f, 0.06230887f, -0.20985140f, 
    -0.16136003f, -0.12180354f, -0.06827223f, -0.08281090f, -0.03802113f, 0.10421913f, -0.09041420f, -0.04095728f, 
    -0.11232463f, 0.04409040f, 0.23289372f, -0.17902067f, 0.15368280f, -0.02484720f, 0.17161267f, -0.04430472f, 
    0.16143373f, 0.10523777f, 0.08227076f, 0.05044993f, -0.25276607f, -0.35908988f, -0.07587913f, 0.17236385f, 
    0.08423944f, -0.08008397f, 0.03070723f, -0.04320493f, 0.05405958f, -0.10127479f, 0.00331206f, -0.14348823f, 
    0.06468055f, -0.13436505f, -0.17097910f, 0.16330907f, -0.13633107f, 0.03990450f, -0.04825641f, 0.16513534f, 
    -0.04043613f, 0.05463907f, 0.19037822f, 0.03857414f, 0.00485230f, -0.33892709f, -0.19663431f, -0.20427336f, 
    0.00721353f, 0.27369806f, 0.16374913f, 0.04829443f, 0.08266842f, 0.00415072f, 0.00366925f, 0.24089332f, 
    -0.28273794f, -0.15018079f, 0.03876519f, 0.08118744f, 0.03385061f, 0.19766212f, -0.01384388f, -0.01259873f, 
    0.01023826f, 0.08474809f, 0.12271405f, 0.08618347f, 0.05195295f, 0.07279431f, 0.09966153f, -0.41726112f, 
    0.09958975f, -0.25505036f, -0.02018408f, 0.00635540f, 0.13526827f, 0.14591081f, 0.01582905f, 0.13035354f, 
    0.34910136f, 0.16122782f, -0.43209076f, 0.32398349f, 0.15739313f, -0.19273160f, 0.09549318f, 0.13470829f, 
    0.14633214f, 0.15209506f, 0.00740972f, 0.05368923f, -0.16291417f, -0.21692838f, -0.34570140f, -0.01688796f, 
    -0.00644101f, -0.02898581f, -0.05801144f, 0.09832878f, 0.11949437f, 0.06243922f, 0.17791481f, 0.18590982f, 
    -0.15384814f, 0.04196326f, -0.03788267f, -0.20439555f, 0.06996701f, -0.01656686f, 0.05076211f, -0.05459151f, 
    0.06035801f, 0.18349235f, 0.01141477f, -0.01957350f, 0.15824327f, 0.10545038f, -0.08768761f, 0.14504178f, 
    -0.11315677f, -0.08942064f, -0.14998947f, 0.24860455f, 0.20073341f, 0.25751913f, 0.21399856f, -0.09085975f, 
    0.49758139f, 0.13291439f, -0.48816177f, -0.41491118f, 0.06505027f, 0.07876439f, 0.13522863f, -0.04288303f, 
    0.05525829f, -0.08048213f, -0.16685252f, -0.25290114f, -0.21955594f, 0.07893716f, -0.16724011f, -0.21269087f, 
    0.02431151f, -0.02907942f, -0.08034815f, -0.24904922f, 0.05670080f, 0.02186589f, -0.00429122f, 0.09519627f, 
    -0.22889799f, -0.00159077f, 0.51175898f, -0.19403377f, 0.05779497f, 0.03834601f, 0.07982497f, 0.04063322f, 
    0.16999681f, 0.15119244f, 0.13878509f, 0.08802354f, -0.27683592f, 0.34167662f, -0.13929833f, -0.05667865f, 
    0.07210296f, 0.06497206f, 0.20291467f, -0.01107816f, -0.00091158f, 0.17181879f, 0.10807130f, -0.19049844f, 
    -0.16086970f, 0.04090382f, 0.01856258f, -0.24680014f, -0.26235986f, 0.12790452f, 0.08785352f, -0.06365820f, 
    0.00157928f, -0.12299387f, 0.07720582f, -0.18258274f, -0.09164359f, 0.12542345f, -0.12498209f, -0.04096995f, 
    -0.00872423f, -0.00866031f, 0.00263610f, 0.02225027f, -0.18113557f, -0.23174870f, -0.09368807f, -0.14729054f, 
    -0.04567095f, -0.02345693f, 0.04714805f, 0.20698079f, -0.12323166f, -0.00620392f, -0.01401384f, 0.02866222f, 
    -0.04634139f, 0.15027919f, -0.09801737f, 0.14808288f, -0.09415392f, 0.13451360f, -0.26968640f, 0.05165514f, 
    0.19885609f, 0.16587567f, 0.23568919f, 0.03525280f, 0.02616940f, 0.17934538f, -0.05970537f, 0.17803016f, 
    0.49764436f, 0.44405434f, -0.09524439f, -0.23557951f, 0.15600860f, 0.10591364f, -0.08927896f, -0.06542563f, 
    -0.02746615f, 0.13252594f, 0.07598194f, -0.08528574f, -0.56351477f, 0.04221162f, 0.01689768f, 0.04496546f, 
    0.00502520f, -0.02419840f, -0.03213093f, -0.15117158f, -0.15877609f, -0.06020023f, 0.00681292f, -0.04406001f, 
    -0.36129767f, 0.29363856f, 0.02846733f, 0.00233466f, -0.04962949f, -0.13705945f, -0.08851765f, 0.00228324f, 
    -0.12807623f, -0.02993380f, 0.07721432f, 0.06602501f, 0.12640515f, -0.04737534f, -0.27454329f, -0.49236301f, 
    -0.11780974f, 0.10248358f, 0.10386702f, 0.04812882f, 0.01019508f, 0.10791957f, 0.03858721f, -0.09098545f, 
    0.52366847f, -0.00217564f, -0.13236086f, -0.17365943f, 0.14167815f, 0.05246352f, 0.03499829f, -0.07058425f, 
    0.16304986f, 0.13467221f, 0.08013338f, 0.03656496f, -0.13657224f, -0.04292803f, -0.05282408f, -0.18383001f, 
    -0.04180780f, -0.08135480f, -0.14892285f, 0.08027465f, -0.12469882f, 0.09940374f, 0.02468370f, -0.03170554f, 
    0.22941118f, -0.06281834f, 0.17074616f, 0.00211309f, -0.05288883f, 0.09635495f, 0.07182388f, -0.08220948f, 
    -0.09226436f, 0.06653108f, -0.07644907f, -0.08804623f, -0.02138702f, 0.39134419f, -0.15283597f, -0.09677320f, 
    -0.11778289f, 0.03362594f, 0.03937182f, -0.08754849f, -0.04728761f, -0.08545434f, 0.07659256f, -0.04716188f, 
    -0.74885494f, -0.11703005f, 0.12749012f, 0.02022513f, -0.03842493f, 0.10315001f, -0.08770046f, -0.04318625f, 
    -0.01457616f, 0.11802401f, 0.08538003f, -0.03005649f, -0.18134195f, -0.07032114f, -0.05691271f, 0.15714757f, 
    -0.02533129f, 0.10594227f, 0.06663581f, 0.13318513f, -0.23010577f, -0.01408349f, 0.05903325f, 0.03191767f, 
    0.42038631f, -0.19834898f, 0.30947322f, 0.23718524f, -0.04368493f, 0.16644162f, 0.19427842f, -0.01851369f, 
    -0.00955626f, 0.05113982f, 0.12514979f, 0.13454653f, 0.31156436f, -0.05528980f, -0.11532719f, 0.40627158f, 
    -0.05188919f, 0.07644936f, 0.17419221f, 0.00797858f, 0.07186361f, 0.02621566f, 0.05865625f, 0.13330542f, 
    -0.31719854f, -0.14113501f, 0.00765369f, 0.14406070f, -0.10281950f, -0.06334843f, 0.04614839f, -0.07992528f, 
    0.18546747f, 0.07893993f, 0.06183241f, 0.15449080f, -0.25984004f, 0.02168643f, 0.15051347f, -0.17058507f, 
    -0.05817653f, -0.08253600f, 0.10223712f, -0.12965408f, -0.09574282f, 0.17381394f, -0.02912127f, 0.08177697f, 
    -0.00222244f, -0.62556589f, -0.18057209f, 0.11042731f, 0.03604681f, 0.04208877f, 0.10071449f, 0.22541498f, 
    -0.03498125f, 0.02774848f, 0.12886062f, 0.06560034f, -0.12255091f, -0.02007774f, 0.32320863f, -0.40589187f, 
    -0.00886638f, -0.05471681f, 0.18090920f, 0.16498327f, -0.22942060f, 0.04647488f, 0.03309713f, -0.19296256f, 
    0.06956874f, -0.40589729f, 0.41999310f, -0.14483818f, -0.21539956f, 0.19820212f, 0.16374750f, -0.12243890f, 
    0.30327094f, 0.02690946f, 0.28218073f, 0.24384572f, 0.14231366f, 0.08696193f, -0.11802708f, 0.13053778f, 
    0.02660761f, -0.03244164f, 0.20556067f, 0.15224147f, -0.10966255f, -0.13869920f, -0.12329423f, -0.02407597f, 
    -0.05431377f, -0.05971862f, -0.15564293f, 0.33270881f, 0.15014474f, 0.27950349f, -0.23701642f, 0.00381412f, 
    0.00361430f, -0.13530393f, 0.02945791f, 0.08794300f, -0.03066711f, -0.07306468f, 0.35145774f, 0.48987713f, 
    -0.09214182f, 0.03879150f, 0.04135544f, -0.03687115f, 0.16481653f, 0.18391494f, 0.07972599f, 0.11471852f, 
    0.22406006f, 0.10988536f, 0.35124919f, -0.11063965f, -0.29510605f, 0.11710900f, 0.09230284f, 0.30355582f, 
    -0.07383913f, 0.02398789f, 0.30465838f, -0.02850905f, 0.17115180f, 0.29981515f, 0.07255023f, 0.12806743f, 
    -0.08206442f, 0.04180190f, -0.03099044f, -0.22144113f, -0.08663140f, -0.14386357f, -0.03145156f, -0.09877675f, 
    0.16566417f, -0.12402680f, 0.05785520f, -0.06506763f, -0.11976993f, 0.02064609f, 0.08228634f, 0.03259916f, 
    0.23510034f, 0.07737136f, 0.10938434f, -0.15276195f, -0.21809138f, 0.27448505f, 0.08815144f, -0.19788773f, 
    -0.09540861f, 0.00129584f, 0.04120596f, 0.16521259f, 0.19196969f, -0.04094787f, 0.07347119f, 0.36131790f, 
    0.46401048f, 0.05554025f, 0.03506926f, 0.04099444f, -0.05374631f, -0.00108697f, 0.00392606f, 0.15637796f, 
    -0.12187852f, 0.02927251f, -0.09422814f, 0.05014077f, 0.16562316f, -0.29117766f, -0.09048066f, 0.00147630f, 
    0.02473877f, 0.14472026f, 0.02666327f, -0.01063575f, -0.05700394f, -0.24204125f, -0.16643353f, -0.08371833f, 
    -0.10316321f, 0.28472883f, -0.37068227f, 0.13377200f, 0.03909433f, -0.25394741f, -0.06968012f, -0.04933714f, 
    -0.09976400f, 0.11555953f, 0.00676323f, -0.00559646f, 0.10711969f, -0.42591155f, 0.29090470f, -0.00321880f, 
    0.14920667f, -0.19052951f, -0.10428946f, 0.17764245f, 0.09450731f, -0.13920580f, -0.07052548f, 0.07820660f, 
    -0.15599416f, -0.03471533f, -0.06037140f, 0.17212684f, -0.00805875f, -0.15182653f, -0.06527930f, 0.17275052f, 
    0.12069188f, 0.19036047f, -0.10120985f, -0.10865685f, 0.13555783f, 0.06272930f, 0.04712971f, 0.10468787f, 
    -0.14677043f, -0.08124310f, -0.05415951f, 0.01477409f, 0.26597449f, 0.10084227f, 0.07948937f, -0.08111234f, 
    0.05961691f, -0.07917161f, 0.04307607f, 0.03145763f, 0.09701704f, 0.11733004f, 0.04704691f, -0.09192599f, 
    -0.06892930f, -0.06775937f, -0.17985722f, 0.08988170f, -0.16830057f, -0.14164519f, -0.21187855f, -0.14953731f, 
    0.14323857f, -0.01393482f, -0.16084224f, -0.00786992f, -0.01601585f, -0.09954054f, 0.14741541f, -0.04492469f, 
    0.25575101f, 0.12660706f, -0.02426559f, -0.00774718f, -0.08866992f, 0.14646612f, 0.06280436f, -0.00681523f, 
    -0.00913544f, 0.11612604f, 0.03281278f, -0.00106119f, -0.04079372f, -0.02626874f, 0.16488713f, -0.02443232f, 
    0.12362379f, 0.26080889f, 0.15934694f, -0.00611314f, 0.02797344f, 0.01286913f, 0.02735671f, -0.01993602f, 
    0.04129671f, 0.36616829f, -0.13914242f, -0.01812929f, 0.05692029f, -0.06388369f, -0.03270620f, -0.25859711f, 
    -0.03142750f, 0.07624460f, -0.01451709f, -0.05738426f, 0.27065998f, 0.11223148f, 0.00165671f, -0.20786925f, 
    0.11817855f, -0.09935236f, 0.16732936f, 0.18514901f, -0.05024413f, -0.00006699f, 0.07298455f, 0.22552294f, 
    0.64848900f, 0.02492651f, 0.26898494f, 0.04287971f, -0.12486244f, 0.11582872f, -0.01125286f, 0.02533705f, 
    -0.07346413f, 0.03538285f, -0.18449141f, 0.19699083f, 0.17075779f, 0.21972635f, 0.18411915f, -0.09390098f, 
    0.03711880f, 0.02681412f, 0.01943362f, 0.10651684f, -0.03538366f, 0.07832620f, 0.03253401f, -0.04070307f, 
    0.04386076f, 0.08061206f, 0.14119156f, -0.15874620f, -0.08365259f, 0.00260100f, -0.16966753f, 0.15091425f, 
    -0.19549525f, 0.01531376f, 0.01379229f, 0.00845899f, 0.13810985f, 0.18877482f, -0.06051957f, -0.06746393f, 
    -0.02027797f, 0.04421784f, 0.01020872f, -0.16892228f, -0.03899550f, 0.07200482f, 0.13583548f, -0.15166965f, 
    0.20344433f, 0.25627276f, 0.22324049f, 0.11420840f, -0.11852468f, 0.02851603f, 0.00364662f, 0.10602625f, 
    0.10356528f, -0.07258366f, 0.17656495f, 0.02800671f, -0.18321952f, -0.21408686f, -0.16750424f, -0.04932774f, 
    -0.05802460f, -0.05049329f, 0.05505715f, 0.12203412f, -0.11582720f, 0.04280580f, 0.04551426f, 0.07200500f, 
    -0.08855259f, -0.33045855f, 0.09853659f, 0.09216261f, -0.02159925f, 0.16001277f, 0.05091699f, 0.19772069f, 
    0.02654532f, 0.10594437f, 0.05676469f, -0.11884584f, 0.14667927f, 0.00959624f, -0.07408570f, 0.28497839f, 
    0.06694489f, 0.13353236f, 0.23169751f, 0.00351140f, 0.01538432f, 0.18288244f, 0.00090554f, 0.03331764f, 
    -0.29317513f, -0.07385696f, -0.13389149f, -0.02470882f, 0.03133791f, 0.23853050f, 0.18230532f, -0.09518298f, 
    -0.05861269f, -0.18853819f, -0.03362443f, -0.00362663f, 0.16129990f, 0.23678410f, 0.21051003f, 0.11185730f, 
    -0.04937072f, -0.06098130f, -0.08593513f, -0.08756549f, 0.02451726f, -0.07073678f, -0.15307644f, -0.00496122f, 
    0.11782293f, 0.09308185f, 0.06897350f, -0.07372015f, 0.02197253f, 0.22434619f, 0.14113745f, 0.02562390f, 
    0.18227337f, -0.03292335f, -0.21472566f, 0.02375443f, -0.31642160f, -0.08526586f, 0.03930737f, -0.28452235f, 
    0.02774272f, -0.21700022f, 0.00619011f, 0.28600496f, -0.31454420f, -0.09817228f, -0.16608347f, -0.35536617f, 
    -0.31180802f, 0.04980295f, -0.01594681f, 0.01506688f, -0.05438308f, 0.10929922f, 0.05328707f, 0.18591250f, 
    0.18314974f, 0.01541831f, 0.01437237f, -0.09958281f, -0.15829475f, 0.04051087f, -0.07720129f, -0.00821283f, 
    0.09059326f, -0.06046845f, 0.21163319f, 0.03956068f, -0.23242934f, -0.11785781f, 0.16382861f, 0.15974392f, 
    0.21891004f, -0.20561302f, -0.16791542f, -0.09844772f, 0.00955793f, 0.09062735f, -0.03963160f, 0.06416881f, 
    0.14031108f, 0.01445858f, 0.04617824f, 0.25382930f, -0.14976764f, -0.13252212f, 0.01788235f, 0.33074069f, 
    -0.10565013f, -0.02837639f, 0.22915901f, 0.06812418f, 0.09528665f, 0.12844172f, 0.10696638f, 0.22052532f, 
    -0.22744760f, 0.15467711f, 0.23331460f, 0.02449933f, 0.03995080f, 0.06875198f, 0.16699950f, 0.11380111f, 
    0.08792809f, 0.10348746f, 0.00804659f, 0.26636633f, -0.11574542f, -0.04350702f, -0.11668983f, 0.12067486f, 
    -0.35575375f, -0.13850465f, -0.04393962f, 0.07521770f, 0.11091346f, 0.20139156f, 0.25890866f, 0.21388009f, 
    -0.26681885f, 0.04956136f, 0.04900123f, -0.06973043f, -0.05655341f, -0.01685707f, -0.09952115f, 0.06425409f, 
    -0.10321332f, -0.14953604f, -0.12770268f, -0.17897007f, 0.10492984f, 0.03484832f, 0.02080833f, 0.05922156f, 
    -0.13951539f, 0.16472937f, -0.00010848f, -0.04107717f, 0.35370502f, -0.04998485f, 0.13162519f, -0.07653370f, 
    0.33730713f, -0.04934200f, -0.16861205f, -0.22963449f, -0.08528196f, 0.02500730f, -0.01765388f, 0.13285510f, 
    0.00492047f, -0.13837960f, -0.05352855f, 0.00259141f, -0.06853984f, -0.11364381f, -0.10737500f, -0.11723854f, 
    -0.05435422f, -0.05962496f, 0.01882761f, 0.04648138f, -0.22620296f, 0.12744164f, -0.09672220f, 0.23790373f, 
    -0.02351221f, -0.07501049f, -0.21293859f, -0.23498172f, -0.00430025f, -0.07692676f, -0.08529103f, 0.08307928f, 
    0.04276428f, 0.13293159f, 0.12784623f, -0.17912874f, 0.32736644f, -0.37583348f, 0.09633712f, 0.07071871f, 
    0.09158224f, 0.19234134f, 0.04101940f, 0.22851723f, 0.10389002f, 0.02759234f, 0.06573084f, 0.15179163f, 
    0.05661255f, 0.09503128f, 0.00869570f, -0.22204651f, -0.08367619f, 0.19074720f, -0.02513568f, 0.07267965f, 
    -0.14424838f, -0.07898366f, -0.20432471f, -0.19176571f, 0.09776071f, 0.10650515f, 0.02845651f, 0.05681477f, 
    -0.05679846f, -0.15399568f, -0.08006039f, -0.04444097f, -0.14040376f, -0.30761629f, -0.07410209f, -0.19159009f, 
    -0.26555178f, -0.34684840f, 0.11818492f, 0.24821098f, -0.07852399f, -0.08607089f, -0.07448312f, 0.11308496f, 
    -0.10637807f, 0.03749752f, 0.21453549f, 0.01113978f, 0.15520276f, 0.01105679f, 0.03131479f, 0.13160004f, 
    -0.13542740f, -0.03930470f, -0.00942551f, -0.14863633f, 0.08440415f, -0.11023639f, 0.18695848f, 0.20331915f, 
    0.32745644f, -0.32230133f, 0.21443370f, -0.06626222f, 0.04497622f, -0.05768532f, 0.10345073f, -0.18699864f, 
    0.08686078f, 0.08523317f, 0.06683321f, 0.16506349f, 0.23555301f, 0.12642755f, 0.02221298f, 0.22229828f, 
    -0.10826864f, 0.01446169f, 0.04501974f, 0.08841597f, 0.03830118f, 0.00183050f, -0.12431532f, -0.12090686f, 
    -0.30502442f, 0.05175233f, 0.02103625f, 0.35185787f, 0.13685435f, 0.20954190f, 0.07123249f, 0.06661804f, 
    0.05006151f, -0.11639217f, -0.01595235f, -0.09822207f, 0.09972370f, -0.06910124f, 0.30274001f, 0.18219909f, 
    0.11992084f, 0.10401124f, -0.05017205f, 0.05633008f, -0.02020720f, -0.08545340f, -0.08822941f, -0.09735438f, 
    0.30844790f, -0.11254103f, -0.20577298f, -0.29959983f, -0.03542775f, -0.00448825f, 0.04700886f, 0.09867290f, 
    -0.08410466f, -0.20281921f, 0.16459879f, -0.18951455f, 0.13558172f, 0.15663214f, 0.03797140f, -0.03688529f, 
    0.08878137f, -0.01631965f, 0.16953573f, -0.13126659f, -0.01864986f, -0.18926430f, -0.05377941f, -0.16209479f, 
    0.50555855f, -0.12247663f, -0.04270401f, 0.11440101f, 0.14062749f, -0.12353935f, -0.06703756f, -0.00499285f, 
    0.16805346f, 0.09031352f, 0.22033139f, 0.23359002f, -0.33243048f, 0.02457488f, 0.12373758f, -0.03508629f, 
    0.06896520f, -0.04645844f, 0.05172245f, 0.24631648f, -0.10127453f, 0.08495608f, 0.05493693f, 0.20210157f, 
    0.25525960f, 0.04892731f, 0.18412496f, 0.03486635f, -0.04660536f, -0.08293896f, 0.02626395f, 0.07470009f, 
    -0.01668437f, 0.15877831f, -0.00862394f, 0.01072029f, 0.16704996f, -0.19874784f, 0.08205796f, 0.05372071f, 
    -0.14444096f, 0.09354869f, -0.02448416f, -0.00571479f, 0.17813565f, -0.27279726f, -0.01050404f, -0.06677862f, 
    -0.15041396f, 0.71067798f, 0.41013241f, 0.12678026f, 0.01546625f, -0.09645247f, -0.01326357f, -0.05384389f, 
    -0.09709821f, -0.09802074f, -0.12260962f, 0.10982018f, -0.38845450f, -0.08530186f, 0.37498701f, -0.29097933f, 
    0.00900631f, -0.15119030f, -0.28501186f, 0.06207931f, 0.09362915f, 0.07204338f, -0.10566985f, -0.09034562f, 
    -0.24464498f, 0.04043183f, 0.22448616f, 0.14568065f, -0.03432672f, -0.14900953f, -0.06829161f, -0.04926014f, 
    0.15803862f, 0.23921575f, 0.14928837f, 0.12799817f, 0.09934919f, 0.05213832f, -0.14826111f, 0.04253705f, 
    -0.00677309f, -0.00113292f, -0.02275055f, 0.02585857f, 0.22433151f, 0.14492887f, -0.11900800f, -0.12941982f, 
    -0.20826699f, -0.03216436f, 0.13460709f, 0.00220236f, -0.10052928f, 0.33572355f, 0.03946668f, 0.14377016f, 
    0.13845392f, 0.05337693f, -0.08281324f, 0.09153731f, -0.40821323f, -0.11985369f, -0.11485955f, -0.09726713f, 
    0.07455797f, -0.15307802f, 0.08311870f, 0.05658725f, -0.16322032f, -0.08934889f, -0.10333044f, -0.20779933f, 
    0.18090875f, -0.05469725f, -0.10933828f, -0.19735520f, 0.04952350f, -0.13244000f, -0.00027592f, -0.00056002f, 
    0.00720522f, 0.05868880f, 0.16820383f, -0.08544854f, -0.03665196f, 0.17932700f, 0.04133210f, 0.09403447f, 
    0.19896725f, 0.11201850f, 0.09768000f, 0.09821530f, 0.04967987f, 0.10755502f, 0.14859945f, 0.21004035f, 
    -0.15738305f, 0.52119792f, -0.18818994f, -0.02668455f, -0.20548438f, -0.03264134f, -0.15098786f, 0.05927522f, 
    -0.08997363f, 0.07507379f, 0.03472481f, -0.00872086f, -0.19372855f, -0.15892051f, -0.25516278f, -0.18299289f, 
    -0.00170068f, 0.09349080f, 0.15037437f, 0.17779921f, 0.10134431f, 0.24770424f, 0.31063324f, 0.21851276f, 
    0.62433755f, -0.20755890f, 0.08885557f, -0.03242325f, 0.09731013f, 0.12399058f, -0.22073436f, -0.04247914f, 
    0.03488941f, -0.03840764f, 0.01829535f, 0.37192446f, -0.07674522f, 0.18536584f, 0.03331907f, -0.14277014f, 
    0.05649186f, -0.18372358f, -0.14963986f, -0.08564324f, -0.17811584f, 0.18683764f, 0.05075883f, 0.17368445f, 
    0.05149541f, 0.21552445f, -0.05422221f, -0.19096997f, -0.08358140f, -0.01774287f, -0.16215926f, -0.23999935f, 
    -0.23996893f, -0.16878410f, -0.15186931f, -0.10684977f, -0.16254684f, 0.07576782f, -0.18483715f, 0.10308308f, 
    -0.02391572f, 0.04304176f, -0.02433094f, -0.12047287f, 0.03823220f, -0.06535822f, 0.09587200f, -0.03040113f, 
    0.38493961f, 0.02002284f, 0.38506770f, -0.12193099f, -0.01697283f, 0.00684338f, -0.15652478f, 0.06542744f, 
    0.16635531f, -0.02403562f, 0.20906746f, -0.03162301f, -0.34036222f, -0.43101037f, 0.14519912f, -0.25114769f, 
    -0.09987238f, 0.10697582f, 0.00812075f, 0.33242518f, -0.00597440f, 0.05271357f, 0.02429699f, 0.15486228f, 
    -0.16941386f, 0.17929399f, 0.42102301f, 0.01483580f, -0.06936984f, 0.10532244f, 0.05274590f, 0.13093467f, 
    -0.06838317f, 0.04987025f, 0.08773287f, 0.06950564f, 0.47779906f, -0.01933116f, 0.38264400f, 0.04209669f, 
    0.14423400f, 0.19094089f, 0.18885627f, 0.06034533f, -0.04600449f, 0.00607971f, 0.07050336f, 0.07716320f, 
    -0.22217695f, -0.00784482f, 0.08995025f, 0.07239367f, -0.09526512f, 0.13832985f, 0.04559143f, -0.04599932f, 
    0.08124305f, -0.11395309f, -0.13882521f, 0.02573370f, -0.05965179f, 0.16053988f, -0.02850186f, 0.00115387f, 
    -0.21051696f, -0.27889672f, -0.18120843f, -0.19105324f, -0.13556615f, -0.13453546f, -0.22099380f, -0.13716541f, 
    -0.05876745f, -0.04690041f, 0.01091425f, 0.09848785f, 0.06364217f, -0.05718625f, 0.08086624f, 0.06403997f, 
    0.05068050f, 0.06115704f, 0.28824601f, -0.00532513f, 0.04045890f, -0.09948172f, 0.24822439f, 0.10822254f, 
    -0.10469436f, -0.04386191f, 0.08862899f, -0.17060827f, 0.00858601f, -0.02302041f, 0.19044194f, 0.15083785f, 
    -0.21310350f, -0.56723553f, 0.15793882f, 0.07186429f, 0.01279280f, 0.04344972f, 0.23416129f, -0.05321420f, 
    0.05681033f, 0.10403285f, 0.07958254f, 0.15728119f, 0.41869348f, -0.09568004f, -0.19966884f, 0.01128662f, 
    -0.02532523f, 0.00153900f, 0.06146777f, 0.02048844f, 0.02937230f, -0.08716374f, 0.00336519f, -0.08812185f, 
    -0.08757969f, -0.14845464f, -0.10669317f, 0.04419149f, 0.16367446f, 0.25165507f, -0.01653366f, -0.00674548f, 
    0.13516182f, -0.01237329f, -0.09234098f, -0.02028270f, -0.15999456f, 0.01003953f, 0.27193502f, 0.32968038f, 
    -0.01845517f, -0.06875172f, -0.17983803f, 0.03797781f, 0.01858178f, -0.12344605f, 0.01000431f, 0.04274365f, 
    -0.06315786f, -0.06395026f, -0.03621551f, -0.14909364f, -0.03180078f, 0.01100558f, 0.04733540f, 0.22207397f, 
    -0.03333390f, 0.06429733f, -0.00402402f, -0.16552825f, -0.07802339f, -0.04762623f, 0.02600003f, 0.04717524f, 
    -0.03951246f, 0.02638510f, 0.08043050f, -0.11401520f, 0.00804214f, -0.13630769f, -0.02815118f, -0.17157921f, 
    0.01614403f, 0.09679647f, -0.20579901f, -0.02540833f, 0.01727013f, -0.14570220f, -0.00386704f, 0.10732070f, 
    0.18179810f, 0.13359222f, 0.19069594f, 0.27042422f, -0.22836064f, -0.32978794f, 0.16570590f, -0.00615011f, 
    0.01276358f, 0.01903638f, -0.15206148f, 0.19513375f, 0.09217737f, 0.22939788f, -0.01878396f, 0.19047360f, 
    0.56817520f, -0.11542872f, -0.10977762f, -0.03404365f, 0.00507928f, 0.06146658f, 0.07534999f, 0.14827126f, 
    -0.18614760f, -0.10051189f, -0.08312317f, 0.03275445f, 0.22842528f, 0.07431977f, 0.07847328f, -0.10131732f, 
    -0.16396295f, -0.02806839f, -0.02806000f, 0.11073299f, -0.03740017f, -0.07350779f, -0.14302570f, -0.04995840f, 
    -0.19745144f, 0.63872778f, -0.09957306f, 0.00878682f, -0.03067966f, -0.19505078f, -0.05240712f, 0.10567391f, 
    0.13609901f, -0.06550688f, -0.11909514f, 0.01389461f, -0.33182955f, -0.04922761f, 0.35182637f, -0.32596689f, 
    0.05417537f, 0.03132264f, -0.18535894f, 0.21303427f, 0.01562296f, 0.04498562f, 0.00773660f, 0.02930081f, 
    0.22092293f, 0.21959348f, 0.18287712f, 0.04618145f, 0.03742712f, -0.01324439f, -0.07286331f, 0.15222995f, 
    0.08063042f, 0.14605951f, 0.08355220f, 0.06921056f, -0.02381509f, 0.01870223f, -0.29301998f, 0.14835379f, 
    -0.04808969f, 0.07060605f, -0.04807483f, 0.13020369f, 0.12009696f, -0.03548714f, 0.07237628f, -0.02267636f, 
    -0.24817048f, -0.00025384f, -0.01361529f, -0.11981529f, -0.03270350f, -0.06220208f, 0.06291388f, 0.24277721f, 
    0.02147044f, 0.01753624f, 0.25606582f, -0.00849342f, -0.14286530f, -0.16754474f, -0.10018335f, 0.02887110f, 
    -0.23830983f, 0.03586397f, 0.23337178f, -0.05104081f, 0.11267117f, -0.15306054f, 0.15640251f, 0.14496744f, 
    -0.48743665f, -0.38122150f, -0.07395484f, 0.05847792f, 0.06030490f, 0.13288192f, 0.03816615f, 0.03711114f, 
    0.11363893f, 0.11901892f, 0.03065815f, 0.19206478f, 0.40443662f, 0.02305801f, -0.08779631f, -0.10354196f, 
    0.18224168f, 0.00919508f, 0.18349634f, 0.13895336f, 0.09461325f, -0.11915038f, -0.11276607f, -0.00337486f, 
    0.18326195f, -0.52946693f, 0.16627342f, -0.09794864f, 0.29832953f, 0.15076259f, -0.01283750f, 0.16674455f, 
    -0.01194616f, 0.06038269f, -0.17893963f, -0.02808327f, -0.10314282f, 0.05519092f, 0.23778355f, 0.15802000f, 
    0.03134943f, -0.08349241f, -0.10488223f, 0.07881149f, 0.03555690f, 0.03224986f, -0.09742737f, -0.09382059f, 
    -0.50519526f, 0.20946561f, -0.13913436f, 0.16543563f, 0.04616747f, 0.01349623f, 0.01857154f, 0.07093024f, 
    0.02760699f, 0.21746372f, 0.23043339f, -0.20851810f, -0.01293229f, -0.09872505f, -0.15589607f, 0.21198107f, 
    0.13455813f, 0.00953182f, 0.06883446f, 0.02687392f, 0.02079387f, -0.23104107f, -0.18137556f, -0.14932086f, 
    -0.18611775f, -0.14473277f, 0.11325058f, 0.01768105f, -0.03144039f, 0.07077617f, -0.02566065f, -0.10176967f, 
    0.13085347f, 0.11270312f, 0.27199060f, 0.13351090f, 0.10074920f, -0.19174650f, 0.27071726f, 0.31213099f, 
    -0.04716747f, 0.15153439f, -0.06984774f, 0.04815209f, 0.10214472f, 0.13231304f, 0.03074607f, 0.13154513f, 
    0.70172912f, 0.09423587f, -0.03869554f, -0.27457657f, 0.06362128f, -0.00082177f, 0.12597913f, 0.03049739f, 
    -0.01106242f, -0.08280698f, 0.04784054f, 0.13766004f, 0.22118223f, 0.20200415f, -0.00448502f, -0.21001877f, 
    0.13275978f, -0.16014975f, -0.06679662f, -0.00269991f, 0.04052678f, -0.29390311f, -0.13552074f, -0.10924142f, 
    0.08176112f, 0.34836927f, 0.12855147f, -0.13175072f, 0.03450119f, -0.29161221f, -0.17178585f, 0.07250945f, 
    0.07493817f, -0.03966254f, 0.11103830f, 0.13525896f, -0.25647694f, 0.17506689f, 0.02522602f, -0.20113885f, 
    -0.03945106f, -0.02821754f, 0.04732308f, 0.09753858f, 0.16062714f, 0.08879968f, -0.02166069f, 0.09265404f, 
    0.22747567f, 0.18256038f, 0.21407488f, -0.15628095f, -0.09574552f, 0.01102066f, -0.03625201f, 0.08361063f, 
    0.20625268f, 0.05424758f, 0.15611632f, 0.06842467f, 0.12507056f, -0.15447901f, -0.04490286f, -0.01397091f, 
    0.04025968f, 0.08723883f, 0.07375771f, 0.02454115f, 0.15246411f, 0.04700115f, 0.29663330f, -0.03437610f, 
    0.16436222f, 0.27881277f, 0.06702949f, -0.07165939f, 0.01025969f, 0.10471344f, 0.04089934f, 0.06849128f, 
    0.07949260f, -0.11525305f, -0.02670906f, 0.01650925f, 0.10108656f, 0.01204342f, 0.14592911f, 0.00475714f, 
    -0.03413802f, -0.13487037f, -0.12955472f, 0.09111020f, 0.03855585f, 0.05796906f, 0.00423373f, -0.00552302f, 
    -0.63543844f, -0.04278691f, -0.18883123f, 0.11019059f, 0.05555730f, 0.02355107f, 0.05571196f, 0.02293812f, 
    0.13680336f, -0.08212209f, -0.16906546f, -0.02639769f, 0.09463412f, -0.23068392f, -0.13433236f, -0.22692204f, 
    0.14769168f, 0.09302752f, 0.06750010f, 0.06054504f, -0.07506305f, 0.17266946f, 0.00708524f, -0.05040635f, 
    0.30256703f, -0.60147858f, 0.33313721f, -0.19011940f, 0.08105786f, -0.01272127f, 0.14255357f, 0.06960473f, 
    0.16184278f, -0.03167129f, -0.04045849f, -0.04019170f, -0.20176956f, 0.06754417f, -0.03101959f, 0.55832458f, 
    -0.07247191f, 0.06131773f, -0.16941720f, 0.01470838f, 0.07181700f, -0.06262700f, -0.05121724f, 0.08120204f, 
    -0.86633605f, 0.17560101f, -0.03576786f, 0.35649127f, 0.12885784f, -0.03499988f, 0.04542962f, -0.12417353f, 
    0.13358420f, 0.00923995f, -0.02108324f, -0.00506649f, -0.07812526f, -0.20863166f, -0.06609145f, 0.14417343f, 
    -0.11639931f, -0.05425629f, -0.01854543f, -0.08671716f, 0.15134390f, 0.12047275f, 0.15881254f, 0.04274023f, 
    -0.36104760f, 0.09645280f, -0.11837406f, 0.12159447f, -0.09363908f, -0.12695849f, 0.06943661f, 0.02295394f, 
    0.17487939f, -0.02940606f, -0.08134384f, 0.14255497f, 0.21947588f, -0.44340056f, 0.18597710f, 0.26090971f, 
    -0.00924959f, -0.02541139f, -0.17488253f, 0.01066768f, 0.27321547f, 0.10917465f, 0.07155477f, 0.08256207f, 
    0.13279133f, -0.15400465f, -0.34806246f, 0.04718486f, -0.02166801f, -0.02834249f, -0.00055376f, -0.08230229f, 
    -0.10074458f, -0.06106732f, -0.05282596f, 0.05919380f, 0.02797406f, 0.15949148f, 0.18965717f, -0.00843674f, 
    0.06536422f, 0.15862505f, 0.17309985f, 0.13737993f, -0.01862336f, 0.08114488f, -0.08404335f, 0.01399955f, 
    0.17863883f, 0.09699105f, -0.09780701f, -0.25309542f, 0.01143281f, -0.12824735f, -0.13147175f, 0.01068565f, 
    0.09782815f, 0.00843520f, 0.02328144f, -0.02923383f, -0.18597522f, 0.00580473f, 0.13590160f, -0.08137584f, 
    0.04141378f, 0.00133766f, -0.08183419f, 0.24790660f, 0.00221022f, 0.03660863f, 0.08970965f, 0.13211052f, 
    0.34429315f, 0.12274351f, 0.01820983f, 0.03095314f, 0.09991442f, -0.06806589f, 0.08301405f, 0.26066914f, 
    -0.05575737f, -0.07942256f, -0.01189975f, -0.10696834f, -0.01372169f, -0.25287327f, -0.04516254f, 0.07410444f, 
    0.07418253f, 0.09672160f, -0.06878162f, -0.02601133f, -0.06525860f, -0.11485518f, 0.24492481f, 0.00397422f, 
    0.35838419f, 0.32024622f, -0.07092870f, -0.03783781f, 0.07624085f, 0.17181399f, 0.12642074f, 0.09472573f, 
    0.04027677f, -0.03350383f, -0.07337791f, 0.06553409f, 0.21781656f, 0.20748563f, 0.12149663f, -0.11631583f, 
    0.06663995f, 0.00988103f, -0.25855893f, 0.18524686f, 0.19288789f, 0.18296455f, -0.05936206f, 0.19103873f, 
    -0.47186568f, 0.28680018f, -0.08911308f, 0.04695382f, 0.00363335f, -0.12755901f, -0.05266821f, 0.11165179f, 
    0.10593503f, 0.03780411f, 0.05754670f, 0.04480190f, -0.39115945f, -0.24007986f, 0.06175043f, -0.28165674f, 
    -0.00965200f, -0.00448953f, 0.00330575f, 0.03268763f, -0.04729176f, 0.09100915f, -0.26441357f, -0.06223013f, 
    0.26667303f, 0.04152002f, 0.11461478f, -0.22350775f, -0.01161424f, -0.12572238f, 0.08501510f, 0.23606856f, 
    -0.10564956f, 0.00372319f, -0.08895312f, -0.12336984f, -0.05083379f, 0.04696027f, -0.09703310f, 0.36233801f, 
    0.01734006f, 0.07251558f, -0.08959185f, -0.21160620f, 0.00464252f, -0.19755198f, -0.07318946f, 0.11514837f, 
    -0.57680279f, 0.15802377f, 0.40994230f, 0.63659042f, -0.06144711f, 0.08430910f, 0.02380585f, -0.50428426f, 
    0.01429909f, -0.00269557f, -0.08302713f, 0.16638090f, -0.17238554f, -0.23691405f, -0.00445372f, 0.06317534f, 
    -0.17360422f, 0.12338627f, -0.06144410f, -0.11441952f, 0.02523839f, -0.11749175f, -0.19519904f, 0.10007680f, 
    -0.21131745f, -0.13820809f, 0.11322331f, 0.06705850f, -0.06415220f, 0.10008016f, -0.07142871f, -0.07682428f, 
    0.13552061f, -0.07581908f, -0.02258428f, 0.06909018f, 0.36438441f, 0.03963308f, 0.12318015f, 0.40229842f, 
    -0.07205352f, 0.01714403f, 0.03872770f, -0.15489540f, 0.13169646f, -0.04503169f, -0.01290335f, -0.05322483f, 
    -0.60754412f, -0.12472495f, 0.07605673f, 0.32270673f, 0.03860018f, 0.13210364f, 0.00146710f, -0.10745764f, 
    -0.03012466f, -0.11486658f, -0.03963962f, 0.00238236f, -0.08865436f, 0.12953112f, -0.08644524f, -0.02557138f, 
    0.07885613f, 0.00452084f, 0.22167744f, 0.01058901f, -0.01246670f, 0.06876846f, -0.09221792f, -0.16015047f, 
    0.38969308f, -0.17274089f, -0.16631143f, 0.00293456f, -0.01493305f, -0.00833341f, -0.09116530f, -0.25290340f, 
    0.05013273f, 0.06027113f, -0.02021723f, -0.06659082f, 0.17379269f, -0.06228150f, -0.08804267f, 0.17640176f, 
    0.12588188f, 0.10354424f, 0.20371421f, 0.10506752f, 0.18750729f, 0.10989965f, 0.11071274f, 0.13646664f, 
    0.37374428f, -0.01999660f, 0.12294281f, 0.01293306f, 0.21703990f, -0.02052187f, 0.11367817f, 0.03627980f, 
    -0.06335967f, 0.10551666f, 0.06896309f, 0.03254325f, 0.00024866f, -0.24869105f, 0.10943370f, 0.09601321f, 
    0.00110611f, 0.18403828f, 0.00257122f, 0.02636044f, 0.02548307f, -0.13014840f, 0.01372526f, 0.10493281f, 
    0.13374691f, -0.13030210f, -0.12907696f, 0.26541856f, 0.00891775f, -0.01722955f, 0.00441537f, 0.03028628f, 
    -0.08395713f, 0.11299987f, 0.14869311f, 0.07747814f, 0.01217637f, 0.22194541f, 0.13468501f, -0.05929551f, 
    0.20881124f, 0.11230578f, 0.19919601f, 0.27714467f, 0.06191076f, 0.19063821f, -0.07761212f, -0.08374144f, 
    0.20393431f, 0.06676121f, 0.31003010f, -0.10235888f, 0.01907977f, 0.04586708f, 0.00322609f, -0.01578204f, 
    0.09772490f, 0.13426229f, 0.01648509f, -0.06910018f, -0.14520386f, -0.02065039f, -0.13359706f, 0.12316367f, 
    -0.10607648f, 0.04208435f, -0.01953073f, -0.12997469f, -0.24453421f, -0.12075406f, 0.02223321f, -0.09185554f, 
    -0.37143674f, 0.26279047f, -0.12531008f, 0.43576393f, 0.03801516f, 0.00341032f, -0.15823819f, -0.17802250f, 
    0.02430007f, -0.09191932f, 0.04420634f, 0.20910749f, -0.13294713f, 0.03796064f, 0.12218947f, 0.01901469f, 
    -0.15495488f, -0.00532501f, 0.00629322f, -0.18789272f, 0.06613815f, 0.26883924f, 0.06986749f, -0.00361052f, 
    0.57446963f, -0.00099281f, 0.13252231f, -0.23772629f, -0.05267796f, 0.07320651f, -0.09071500f, 0.12249073f, 
    -0.07694182f, -0.00197403f, 0.26494509f, 0.10656195f, -0.08827983f, 0.07919978f, 0.23143090f, -0.01128389f, 
    -0.01777257f, -0.14185996f, -0.14210276f, -0.22942565f, -0.11704829f, 0.01753569f, 0.17001367f, 0.05138293f, 
    0.11302473f, 0.09757832f, -0.11107960f, 0.06046643f, 0.08555983f, 0.08812211f, 0.12949428f, 0.15872534f, 
    0.00950718f, 0.07701601f, -0.07668661f, -0.14299129f, -0.13533536f, 0.38526049f, -0.13355562f, -0.26557326f, 
    0.11905641f, 0.02224246f, -0.02036984f, 0.13799639f, -0.08303152f, 0.01059382f, -0.00081869f, 0.16861339f, 
    -0.30565703f, -0.15704495f, 0.05809233f, 0.27911717f, 0.06554835f, 0.30413127f, -0.07156381f, -0.03142008f, 
    -0.05325731f, 0.10412062f, -0.19437787f, 0.00785313f, 0.21557657f, -0.03377860f, -0.03795537f, 0.25399444f, 
    0.04558677f, 0.17359854f, -0.02523949f, 0.16853930f, -0.08611865f, 0.03877541f, -0.04311945f, 0.01243396f, 
    0.05910116f, 0.13591652f, -0.40910399f, 0.17915508f, 0.08871487f, 0.12344837f, 0.07057907f, -0.14260423f, 
    0.07138921f, 0.07596065f, 0.02325023f, 0.06133901f, 0.42984658f, -0.18266904f, 0.08512676f, 0.09675021f, 
    0.03774606f, 0.07939527f, -0.03377088f, 0.07248591f, -0.06248106f, 0.11502026f, -0.08380578f, 0.01869557f, 
    -0.20365492f, -0.25612783f, -0.27698144f, 0.22103429f, 0.11896215f, -0.10507493f, -0.08281542f, 0.04525887f, 
    -0.08213004f, 0.10196562f, -0.13252169f, 0.03881480f, -0.11133632f, 0.03493354f, 0.03944641f, 0.03831804f, 
    -0.08432174f, -0.09349335f, -0.04526592f, -0.05433321f, 0.03701551f, 0.14726065f, 0.02377894f, -0.10102340f, 
    -0.16824880f, -0.01964003f, 0.22507705f, -0.06253143f, -0.13047434f, 0.12909061f, 0.18654479f, 0.15808733f, 
    0.17829514f, 0.25435710f, 0.09968825f, 0.09248514f, -0.03049460f, -0.05412075f, -0.11095129f, 0.13935401f, 
    0.30996290f, 0.00676194f, 0.03409543f, 0.19996583f, -0.19947092f, 0.05076344f, 0.28079367f, -0.23110139f, 
    0.24229768f, 0.35916835f, -0.18740596f, -0.00075673f, -0.15168156f, 0.08410025f, -0.10285410f, -0.04684935f, 
    -0.04033351f, -0.20077771f, 0.09374357f, 0.15475944f, -0.18807253f, -0.07403002f, -0.17863163f, -0.13207020f, 
    0.29857832f, 0.32103118f, 0.28158548f, 0.03445574f, 0.09657499f, 0.05369852f, -0.01479321f, 0.08085193f, 
    -0.33439457f, -0.27180323f, -0.01256821f, 0.08199056f, 0.20175335f, 0.36270830f, -0.08482680f, 0.03104789f, 
    0.05823465f, -0.02323427f, 0.02383833f, 0.03311827f, 0.28447175f, 0.10941730f, 0.22635843f, 0.02916117f, 
    0.03981381f, -0.15339093f, 0.11928955f, -0.16938648f, 0.07101241f, 0.17949088f, 0.02052799f, 0.24104433f, 
    0.42117813f, 0.38184100f, -0.44167736f, 0.19753958f, 0.11439040f, 0.15102445f, 0.04242531f, -0.09631359f, 
    -0.10320915f, -0.00196694f, 0.00395124f, 0.01650639f, 0.01839414f, -0.05369151f, -0.11544392f, -0.13023467f, 
    0.03950172f, 0.02260563f, 0.00646943f, -0.08821894f, 0.06731994f, 0.13682336f, 0.10690537f, 0.10971488f, 
    0.01904785f, 0.05352496f, 0.23685876f, 0.00118964f, 0.07159884f, -0.21658216f, -0.05076874f, -0.07819717f, 
    0.17604204f, 0.02704898f, 0.00053189f, -0.12492438f, 0.24291410f, 0.45856741f, -0.10303537f, -0.00249759f, 
    -0.00068545f, -0.01697011f, -0.12857814f, 0.00810940f, 0.08542323f, -0.03733521f, -0.03466675f, -0.18512809f, 
    0.08486757f, 0.52700931f, -0.25824919f, -0.15534438f, 0.08037207f, 0.09438065f, 0.16562250f, 0.14168419f, 
    0.11947750f, -0.09187413f, -0.18142097f, -0.13422659f, -0.36538994f, -0.13021228f, -0.17016159f, -0.05744543f, 
    -0.06860001f, -0.19763494f, 0.05423339f, -0.09539959f, 0.11602307f, 0.13982521f, 0.11705009f, 0.12586974f, 
    -0.02402282f, -0.17901383f, 0.59758341f, -0.06854862f, -0.06892476f, 0.04733082f, 0.07241494f, -0.19008951f, 
    0.06554623f, 0.20898667f, 0.07115999f, 0.04335269f, -0.15374856f, 0.03761655f, -0.00593830f, 0.25722507f, 
    0.17173168f, 0.00048097f, 0.02453978f, 0.12912939f, 0.13402291f, 0.12494991f, 0.06130621f, 0.07856241f, 
    -0.30804315f, 0.08182800f, 0.01782246f, -0.05123434f, -0.06326278f, -0.05620968f, 0.04739260f, 0.22873667f, 
    0.06224529f, -0.08866581f, 0.00578620f, -0.04468771f, 0.07215967f, 0.11910354f, 0.16301095f, -0.19667217f, 
    -0.00352430f, -0.02920928f, -0.02481618f, -0.11447708f, -0.08992771f, -0.25396958f, -0.05995051f, -0.21741168f, 
    0.04066698f, -0.00766094f, -0.14369363f, -0.24414998f, 0.19048493f, -0.05602200f, 0.10349556f, 0.07122087f, 
    -0.01201257f, 0.06086519f, 0.10334383f, 0.03846410f, -0.05201114f, -0.02435509f, 0.08389026f, 0.21046509f, 
    0.08746955f, 0.14019832f, -0.00275402f, -0.12586689f, 0.25434187f, 0.02474269f, 0.15043145f, -0.09830024f, 
    -0.10722549f, 0.12040088f, -0.15404445f, 0.15536560f, -0.19456162f, 0.07693633f, 0.04769970f, 0.01905708f, 
    0.05965231f, -0.00616320f, 0.22457458f, 0.21069027f, -0.02193466f, -0.24059461f, 0.06685554f, -0.36975199f, 
    0.05068038f, 0.17277420f, -0.05622761f, 0.10556506f, 0.27159861f, 0.15551481f, 0.01211385f, -0.01769436f, 
    0.58377153f, 0.33028245f, 0.07743108f, -0.13931186f, -0.00999968f, -0.13900504f, 0.00507541f, -0.05096167f, 
    -0.20170082f, 0.18078332f, -0.08096455f, 0.02338138f, 0.02686136f, 0.09182265f, 0.03773594f, -0.48482767f, 
    0.15446194f, -0.00161209f, -0.03506740f, 0.07280558f, 0.06430399f, 0.09959489f, 0.11048141f, 0.06230654f, 
    0.30916053f, 0.28114048f, 0.11364264f, 0.27453589f, -0.02388654f, -0.02158806f, -0.05606324f, -0.17811890f, 
    0.05304494f, 0.09910323f, 0.04140508f, -0.09560953f, 0.00095657f, 0.02103220f, -0.07712914f, 0.05951250f, 
    -0.02809174f, -0.00947176f, -0.07224417f, 0.04868491f, 0.03233579f, -0.11276182f, -0.13481985f, 0.06703065f, 
    -0.42238808f, 0.00699630f, -0.00783434f, -0.08359649f, -0.14343448f, 0.12797731f, 0.07603902f, 0.10007986f, 
    0.00716643f, 0.20241056f, 0.05126596f, 0.16584800f, 0.36118686f, 0.19957803f, -0.18939152f, 0.02125247f, 
    -0.02422711f, -0.07277452f, -0.03169662f, -0.18786487f, -0.02250208f, 0.14515494f, 0.11515024f, 0.07411496f, 
    0.26796433f, 0.40850130f, 0.09409367f, 0.20918445f, -0.02786851f, -0.19926839f, 0.08086212f, 0.17438926f, 
    0.20607030f, -0.15631826f, 0.08206037f, -0.20208246f, -0.22333029f, 0.20537277f, -0.01830414f, -0.12441231f, 
    0.25132310f, -0.10296078f, -0.03845931f, -0.07249468f, 0.06574132f, -0.00791374f, 0.01420994f, -0.21651861f, 
    -0.36985549f, -0.60215306f, -0.20371443f, -0.09082899f, 0.01252678f, 0.02799001f, 0.15694429f, 0.06640540f, 
    0.15303925f, 0.09799678f, 0.09058037f, 0.07106838f, -0.08521353f, 0.42025077f, -0.29077232f, 0.13803707f, 
    -0.05094448f, 0.07192722f, 0.27718276f, 0.10231485f, -0.14326446f, 0.24909957f, 0.07310756f, 0.08679191f, 
    -0.07008434f, -0.00434874f, -0.08935250f, -0.10804243f, 0.02496332f, 0.09066425f, 0.08510209f, 0.03787369f, 
    -0.11197314f, -0.14490125f, 0.04976297f, -0.13440186f, 0.01172566f, 0.05711532f, 0.03778870f, 0.09075139f, 
    -0.04465111f, 0.06512473f, 0.06006495f, 0.20447396f, 0.05888494f, 0.00925658f, -0.04035511f, 0.13201176f, 
    0.44751483f, 0.39950579f, 0.17488490f, 0.18768191f, 0.16709666f, 0.06784400f, 0.10287803f, 0.06852637f, 
    0.04937335f, -0.11297819f, -0.05765151f, 0.00837242f, 0.23241177f, 0.15621576f, 0.40781108f, 0.12131967f, 
    0.13746545f, -0.09471813f, -0.20521264f, 0.10977252f, 0.02764702f, 0.20695652f, 0.04494561f, -0.14270499f, 
    -0.31212270f, 0.07394742f, 0.10920078f, 0.17684579f, 0.00763549f, 0.02024282f, 0.12791035f, -0.02608086f, 
    -0.09527738f, 0.02999687f, -0.00611348f, -0.07116934f, -0.15622818f, -0.21992812f, -0.18888836f, -0.22587898f, 
    0.01685574f, 0.19861408f, 0.13191998f, 0.06799551f, -0.04333895f, 0.12760527f, 0.12474661f, 0.08817691f, 
    0.20604223f, 0.08597784f, 0.05551195f, -0.03414497f, -0.00179816f, 0.01335279f, -0.08087634f, 0.04224097f, 
    0.02677206f, -0.09518315f, -0.03750950f, 0.03792868f, -0.10445216f, 0.10514430f, 0.09654183f, 0.14097795f, 
    0.07440054f, -0.11879718f, 0.02101597f, -0.14771108f, 0.17298199f, -0.02921722f, 0.07745859f, 0.18035966f, 
    0.10657993f, 0.09007156f, 0.29459211f, 0.21239106f, -0.05640825f, -0.20542003f, -0.02754008f, -0.09847758f, 
    0.02607295f, 0.10185277f, -0.06945588f, 0.01205931f, -0.11961118f, -0.29324716f, -0.14836255f, -0.02519640f, 
    -0.06717835f, -0.08689707f, 0.01628722f, -0.04423786f, 0.07953417f, 0.06374227f, 0.18744510f, 0.27491319f, 
    -0.25746068f, 0.04665787f, -0.23982412f, -0.09387852f, 0.05057445f, -0.11314129f, 0.05423429f, 0.10833694f, 
    -0.06587230f, -0.04204304f, -0.20596130f, -0.13134815f, 0.15028855f, 0.03764959f, 0.00252151f, -0.35074469f, 
    -0.05248057f, -0.04214964f, -0.22822021f, -0.10416837f, -0.02323868f, -0.01367412f, -0.08922488f, -0.07620713f, 
    -0.22691441f, -0.13578972f, -0.33788568f, 0.11770388f, 0.00249824f, 0.10447492f, 0.05135903f, -0.06012617f, 
    -0.01973004f, -0.14026584f, -0.27143973f, -0.29127073f, 0.18629605f, 0.12222625f, 0.06936821f, 0.17016467f, 
    0.04732590f, 0.11915912f, 0.10684377f, 0.03450847f, 0.07780293f, 0.16698271f, 0.06869145f, 0.06546286f, 
    -0.05502727f, -0.28522623f, -0.36824593f, 0.01377798f, 0.08083618f, 0.17307985f, 0.06451543f, 0.05595694f, 
    0.24284855f, 0.00899896f, 0.11079860f, 0.03835088f, 0.31803048f, 0.14907806f, -0.00330897f, 0.19960919f, 
    0.04133288f, 0.15280287f, 0.01167525f, 0.11908850f, -0.16164161f, -0.03714290f, 0.16792686f, 0.10118736f, 
    0.37659904f, -0.00756590f, -0.06503898f, 0.27626511f, 0.30462268f, 0.06208159f, 0.08376228f, 0.21613558f, 
    -0.17842045f, -0.16794831f, -0.11744241f, -0.25032258f, -0.22873896f, -0.15282221f, 0.06943951f, -0.03935124f, 
    -0.00507544f, -0.02031377f, -0.06744280f, -0.13425933f, -0.10383154f, -0.17633344f, 0.03505521f, 0.02890936f, 
    -0.22496331f, -0.30908206f, 0.22419460f, 0.14852582f, -0.05972429f, -0.09101123f, 0.04689154f, 0.10808449f, 
    0.14992025f, 0.14048739f, 0.32113978f, 0.12308004f, -0.00464449f, -0.10256725f, 0.06946301f, 0.31209728f, 
    0.07631020f, -0.04552286f, 0.09092253f, -0.18309632f, 0.18820450f, -0.05743896f, 0.04229008f, -0.06143060f, 
    0.46192908f, -0.35651982f, -0.20691602f, -0.08354361f, -0.01748439f, 0.02643894f, 0.21568444f, -0.13917078f, 
    -0.06148083f, 0.09981044f, 0.20535114f, 0.19476141f, 0.32954511f, -0.24753655f, -0.03776712f, -0.10897395f, 
    0.03246359f, 0.10556575f, -0.02017319f, 0.15628858f, 0.13746457f, -0.04678580f, -0.12335607f, 0.03191784f, 
    0.08382219f, 0.22114590f, 0.13706446f, 0.28692168f, -0.01343728f, 0.17861962f, -0.19533642f, -0.01252526f, 
    -0.10181306f, 0.11414472f, -0.05477609f, -0.07516573f, 0.22004297f, 0.22109842f, 0.38324392f, -0.20262566f, 
    -0.02297306f, -0.04896268f, -0.13047093f, -0.06099448f, 0.18029025f, 0.13851908f, 0.02883701f, 0.05004454f, 
    0.83888459f, 0.14930969f, -0.29008037f, -0.10998624f, 0.13123201f, -0.04257902f, -0.04247828f, -0.18783195f, 
    0.16329186f, 0.12486124f, 0.16798012f, 0.01380130f, 0.05717691f, 0.15420535f, -0.13408113f, 0.07013997f, 
    0.02564232f, -0.01498804f, -0.12453356f, -0.20092770f, -0.04072477f, -0.11552302f, -0.11464919f, -0.02748613f, 
    0.09472338f, -0.04591409f, -0.05068542f, -0.20525831f, -0.01394172f, -0.14610630f, 0.10311180f, -0.15452628f, 
    0.22736196f, 0.14150046f, 0.22675124f, 0.11996399f, -0.24354360f, 0.18132696f, -0.18436728f, -0.24470219f, 
    0.17612109f, 0.01842892f, -0.27906418f, 0.09410424f, 0.01650467f, 0.02896508f, 0.17511682f, 0.31640637f, 
    0.41152170f, 0.47661895f, 0.12181693f, -0.09835992f, 0.02890175f, -0.16811715f, -0.07958331f, 0.11226207f, 
    -0.07268425f, 0.03547292f, -0.05285595f, -0.21924163f, -0.21628866f, -0.15400416f, 0.00183190f, -0.05061170f, 
    -0.09166548f, -0.10523010f, -0.16312082f, -0.07222954f, 0.11965451f, -0.10150361f, 0.06066256f, -0.28558338f, 
    -0.52986109f, 0.29867521f, 0.32322586f, 0.09528305f, -0.17641288f, -0.15343812f, 0.11317094f, 0.01527336f, 
    0.00972456f, 0.06064966f, -0.09215066f, 0.03681349f, -0.35287210f, 0.16397485f, 0.29028538f, -0.15647978f, 
    0.10008708f, -0.03564997f, 0.18854280f, 0.15475784f, -0.10663743f, -0.02148955f, -0.02698281f, -0.11349735f, 
    -0.11255111f, -0.00869978f, 0.16133395f, 0.12244920f, -0.09735283f, -0.02630672f, 0.17189620f, 0.17291071f, 
    0.00481179f, 0.09839716f, 0.02919127f, -0.15032299f, -0.18486361f, 0.01738305f, -0.27738941f, -0.22183947f, 
    -0.19626504f, 0.04191200f, 0.00007862f, 0.12928177f, 0.23174401f, 0.10870959f, 0.06301312f, 0.13728040f, 
    -0.11446454f, -0.38922819f, -0.31908518f, -0.26437420f, 0.13095906f, 0.03635962f, -0.01325935f, -0.06238961f, 
    0.26241514f, 0.05710456f, 0.10607158f, 0.11609548f, -0.07268357f, 0.11506232f, 0.20419377f, 0.20400876f, 
    0.17709525f, 0.13357405f, 0.23325796f, 0.05807371f, 0.21786477f, -0.21238570f, -0.00261000f, -0.19266097f, 
    -0.24604531f, 0.06847151f, -0.06591713f, 0.15142828f, -0.03689773f, -0.12885317f, -0.03037058f, 0.28776255f, 
    0.19925086f, -0.14546120f, -0.11175489f, 0.00547064f, 0.22974457f, 0.02196954f, 0.07041351f, -0.08429962f, 
    0.18627904f, 0.00782795f, -0.17534859f, 0.03661648f, -0.07988004f, 0.02720309f, -0.01399358f, -0.02024185f, 
    1.13942981f, 0.00156128f, 0.40644398f, -0.13046412f, -0.12969843f, -0.17504726f, 0.04247626f, -0.07232004f, 
    0.04652173f, -0.00906765f, 0.02860663f, -0.02539168f, 0.23485866f, 0.20006754f, 0.00454807f, 0.11124522f, 
    -0.06390829f, 0.01232424f, -0.12075761f, -0.12118247f, 0.01649795f, 0.07789281f, -0.04632192f, 0.07388208f, 
    -0.04936031f, 0.52443278f, 0.34651056f, 0.27497938f, 0.11294515f, 0.02614151f, -0.08098794f, -0.05073710f, 
    0.08148744f, 0.04350658f, -0.01301704f, -0.05175401f, 0.22479394f, 0.29235536f, 0.08267000f, 0.24165107f, 
    -0.11144653f, -0.02521388f, 0.04978583f, -0.10056141f, -0.00027834f, 0.03650451f, -0.08286835f, 0.10265333f, 
    -0.28946179f, 0.10583048f, 0.15235962f, 0.09257237f, -0.05234122f, 0.02072801f, 0.06007439f, 0.28129861f, 
    0.05378479f, 0.10063416f, -0.12070578f, -0.00303719f, 0.37262842f, 0.00040470f, 0.24351603f, 0.09977412f, 
    0.09543479f, -0.07582893f, 0.02784506f, -0.14838965f, 0.24105695f, 0.03129461f, 0.00666103f, 0.03668013f, 
    0.67388082f, 0.33450457f, 0.21589990f, 0.17782234f, 0.04706850f, -0.14235269f, 0.02010421f, 0.18836929f, 
    0.03412981f, -0.01772148f, 0.11910075f, 0.08020227f, -0.10616233f, 0.11231108f, -0.00563739f, -0.20896772f, 
    0.08866157f, 0.02590219f, -0.05020913f, 0.06413560f, 0.01831888f, 0.13418965f, 0.02429382f, 0.00455413f, 
    -0.30624437f, -0.48952127f, -0.50021249f, -0.35549879f, -0.08358307f, -0.03245893f, -0.11971084f, 0.12583520f, 
    -0.10366288f, 0.00988741f, 0.10837370f, -0.06409360f, -0.33080825f, -0.05169946f, -0.35667017f, 0.08871449f, 
    0.05001466f, 0.15811269f, 0.06008835f, 0.13992830f, -0.05909271f, -0.01776033f, -0.13168457f, 0.07683935f, 
    0.09998304f, -0.12423776f, -0.09718782f, -0.21928947f, 0.04196201f, -0.12142733f, 0.00712134f, 0.22253409f, 
    0.01909853f, -0.01119377f, -0.03509847f, -0.06511120f, 0.21101101f, 0.17862369f, 0.22226042f, 0.19226211f, 
    0.10272667f, -0.04259391f, -0.02881552f, -0.03492523f, 0.06815068f, 0.18995428f, 0.10114345f, 0.06233017f, 
    0.47078204f, 0.27301663f, -0.07690744f, 0.21715389f, 0.11514074f, -0.05548262f, -0.03170625f, 0.02500737f, 
    -0.12008017f, -0.09578234f, -0.06340323f, 0.06703629f, 0.26968107f, 0.18975492f, 0.14284140f, 0.06354933f, 
    -0.07116583f, 0.00427369f, 0.04512477f, 0.04836713f, 0.00426018f, 0.13218330f, -0.17066221f, -0.00615685f, 
    -0.31664529f, 0.10452773f, 0.15370457f, 0.01425150f, 0.11377253f, -0.06715681f, 0.03336858f, -0.07501905f, 
    0.05277923f, -0.02494200f, -0.03554774f, -0.07836688f, -0.15868607f, -0.04033609f, -0.13680282f, -0.05734324f, 
    -0.03882532f, -0.00382967f, -0.00295020f, 0.10767756f, 0.13557948f, 0.06880045f, 0.11121966f, 0.07051154f, 
    0.07045002f, 0.09821858f, 0.01509571f, -0.05288910f, -0.09761149f, -0.08561591f, 0.03537682f, 0.06375288f, 
    0.08576550f, 0.00031731f, 0.03701722f, 0.14768937f, -0.29214382f, -0.05383443f, -0.06339908f, 0.07232033f, 
    0.00347089f, 0.03423646f, 0.02137843f, -0.12967925f, 0.18928275f, 0.10584188f, 0.24714389f, -0.05013100f, 
    -0.17972830f, -0.10154478f, 0.11065014f, -0.06966302f, -0.01029943f, -0.10759610f, -0.04879665f, -0.03602057f, 
    0.01544495f, 0.06205695f, 0.03636146f, -0.03226241f, -0.11906017f, -0.23496872f, 0.04182892f, -0.03215250f, 
    0.00151641f, 0.01487107f, 0.03328152f, -0.06872517f, 0.15862346f, 0.15025777f, 0.05343372f, 0.16158220f, 
    -0.24743953f, -0.10508807f, -0.21597786f, -0.10131348f, 0.10276198f, 0.14491819f, 0.17824505f, 0.06378353f, 
    -0.00372332f, 0.00559504f, 0.03521736f, -0.08991381f, -0.19017300f, -0.09304499f, -0.10731402f, -0.23018403f, 
    0.10661728f, -0.04698450f, -0.05620797f, 0.00572646f, -0.13964754f, 0.06463331f, -0.11622597f, -0.00186515f, 
    -0.51758164f, -0.48026702f, -0.31821173f, -0.01455446f, -0.07884756f, 0.09009036f, -0.09856115f, -0.16419563f, 
    -0.02329944f, 0.02280840f, -0.06207387f, -0.10029694f, 0.36526722f, 0.25373611f, 0.22875743f, 0.20756336f, 
    0.34080136f, 0.19820143f, 0.13367175f, 0.07571112f, 0.03751680f, 0.13662852f, 0.02758742f, 0.05024642f, 
    0.20915578f, -0.04391683f, -0.44086164f, 0.10700563f, 0.06491193f, 0.12402876f, 0.02898201f, 0.05034273f, 
    0.21124083f, -0.00703472f, 0.02161975f, 0.08054331f, 0.37470800f, 0.22693323f, 0.02264970f, -0.00428824f, 
    -0.01792261f, 0.22792329f, 0.15182815f, 0.04604576f, -0.14274900f, -0.08145478f, 0.09875540f, 0.24200277f, 
    0.35190266f, -0.00007566f, 0.03816406f, 0.22648139f, 0.23416743f, 0.00007307f, 0.08738846f, 0.20125061f, 
    -0.21282306f, -0.18248600f, -0.09211925f, -0.07575271f, -0.24366401f, -0.26299587f, -0.05278312f, -0.09470425f, 
    -0.02169357f, -0.00467162f, -0.04832898f, -0.06593856f, 0.15583687f, 0.13332616f, 0.18958606f, 0.07281780f, 
    -0.14312615f, -0.11598784f, 0.21413320f, 0.19512735f, -0.05858167f, -0.02697416f, -0.07459094f, -0.11707430f, 
    0.11058065f, 0.01937080f, 0.10193410f, 0.05338527f, 0.05496836f, -0.18001939f, -0.06847667f, 0.22723022f, 
    0.02015183f, -0.04708820f, -0.09804663f, -0.19218855f, 0.22343095f, 0.01562580f, 0.00985714f, 0.10559450f, 
    0.42175561f, -0.33519906f, -0.01581184f, 0.01640875f, 0.12637869f, -0.08157953f, 0.15764751f, -0.06666696f, 
    -0.07468664f, 0.16744618f, 0.19989637f, 0.29230517f, 0.14039266f, -0.15193203f, 0.08333961f, 0.08262532f, 
    -0.12924506f, 0.16789429f, -0.11231206f, -0.11237185f, 0.13654257f, 0.07015405f, -0.11169706f, -0.09802936f, 
    -0.07398205f, 0.46386197f, -0.00264277f, 0.33391276f, 0.03644235f, -0.03956046f, 0.08326541f, 0.02592980f, 
    -0.15391563f, 0.01914067f, -0.13094774f, -0.17048767f, -0.05681741f, 0.08612022f, 0.20236254f, -0.30107251f, 
    0.07005599f, 0.00861057f, -0.22238699f, 0.11905504f, 0.11601367f, 0.00782557f, 0.05273033f, -0.00074658f, 
    0.73592550f, -0.10948516f, -0.27307549f, -0.00741900f, 0.16352551f, -0.03177781f, -0.21908389f, -0.04474147f, 
    0.01930791f, 0.01713848f, -0.00440598f, -0.08138087f, -0.10705318f, 0.02675815f, -0.06868266f, -0.02596557f, 
    0.16329029f, -0.03256869f, -0.11823550f, -0.06292816f, -0.07081228f, -0.25030288f, -0.32402769f, -0.23867737f, 
    0.17530096f, 0.00557385f, -0.32101032f, -0.09546663f, -0.00469029f, -0.04309890f, 0.00559424f, -0.00222268f, 
    0.18415233f, 0.23498775f, 0.18346068f, 0.40907383f, -0.33059123f, 0.10571446f, -0.23940891f, -0.00339954f, 
    0.26504910f, -0.15849234f, -0.15409131f, 0.08409730f, -0.09121630f, 0.17830351f, 0.17336941f, 0.22616236f, 
    0.03719187f, 0.21976328f, 0.39634809f, 0.15134583f, 0.02879047f, 0.08783922f, -0.03799703f, -0.05401323f, 
    0.03373839f, 0.00047204f, 0.19267479f, -0.18880612f, -0.15399896f, -0.14984205f, 0.16284792f, -0.01647348f, 
    0.00816031f, 0.16547832f, -0.18173301f, 0.01050073f, 0.19134612f, -0.19197290f, 0.04394090f, -0.29522869f, 
    -0.35593647f, 0.38846001f, 0.49204442f, 0.23277073f, -0.05702984f, 0.13140219f, 0.08830385f, 0.10950717f, 
    0.02873338f, -0.02328415f, -0.02096268f, 0.13021293f, -0.15127349f, 0.36971042f, 0.33747435f, -0.20921355f, 
    -0.10116754f, 0.04651187f, -0.04805572f, -0.00188602f, -0.07809981f, 0.07529338f, 0.10562724f, -0.05798683f, 
    -0.23478822f, -0.04328259f, 0.11856370f, 0.14293382f, -0.08077271f, -0.10714112f, 0.08196148f, -0.16089641f, 
    -0.02141434f, 0.08730007f, 0.07428481f, 0.00771645f, -0.24104735f, -0.11243191f, -0.22780606f, 0.00309760f, 
    -0.13410978f, 0.09293202f, -0.02322301f, -0.01384494f, 0.25905731f, 0.22715899f, 0.00991965f, 0.33044380f, 
    0.00168857f, 0.00919915f, -0.07699833f, 0.01844634f, 0.02563599f, -0.00542560f, -0.03744299f, -0.06389117f, 
    -0.06572587f, -0.07305833f, -0.01477456f, -0.07669821f, 0.02844969f, -0.04458280f, -0.04801289f, 0.04981258f, 
    0.05011874f, -0.00972930f, 0.05668880f, -0.02543912f, 0.02983552f, -0.06463610f, 0.01088623f, 0.02278937f, 
    -0.06901439f, -0.00763331f, -0.06068367f, 0.02787561f, 0.04271390f, 0.00925834f, 0.04409745f, -0.02647990f, 
    -0.04967301f, 0.01477036f, 0.02793605f, 0.02944908f, -0.06800471f, -0.05206746f, 0.04421223f, 0.02456524f, 
    0.00220655f, 0.03765195f, 0.05780166f, 0.01454090f, -0.04570948f, 0.04405275f, -0.00624604f, 0.05357303f, 
    0.04455099f, 0.02951756f, -0.00569513f, 0.02213995f, 0.03977970f, -0.00490911f, -0.00816012f, 0.00880625f, 
    -0.06999400f, -0.00780506f, -0.08551095f, -0.02408217f, 0.05348805f, 0.00845521f, -0.07621569f, 0.03299140f, 
    -0.05198393f, 0.02456597f, -0.00596822f, -0.06934749f, -0.06250057f, -0.01790833f, -0.05159514f, -0.04074192f, 
    -0.05920621f, 0.05241687f, 0.05819140f, -0.03370960f, 0.01675294f, -0.07033437f, 0.05208017f, 0.01287670f, 
    -0.00851391f, 0.06180289f, -0.04744497f, 0.03119111f, 0.03879294f, -0.04831462f, 0.04442040f, -0.07209045f, 
    0.02506256f, -0.04788109f, -0.05919103f, -0.06326814f, 0.03388147f, 0.04358721f, 0.04470840f, -0.00769763f, 
    -0.03557271f, -0.05722695f, -0.03822871f, -0.06443332f, 0.03890023f, 0.04914382f, -0.06666381f, -0.06804141f, 
    -0.00948544f, -0.02904556f, -0.00284682f, -0.01771936f, -0.01311425f, 0.04893945f, 0.04905157f, 0.02004741f, 
    -0.02206347f, -0.04305759f, -0.02105187f, -0.08146909f, 0.04537903f, -0.02774297f, -0.00517015f, -0.07269517f, 
    -0.03894065f, 0.04060613f, 0.03721115f, -0.02516025f, 0.06270173f, 0.03362674f, 0.06350102f, 0.01638607f, 
    -0.06540690f, -0.05551207f, 0.00366914f, 0.03446221f, -0.05620759f, -0.05057961f, -0.02598240f, -0.02368150f, 
    0.04554189f, -0.07024362f, 0.03421524f, -0.04643124f, -0.05430933f, -0.06545428f, 0.02766501f, -0.07976775f, 
    0.03335965f, 0.00293173f, -0.02235552f, 0.03863090f, -0.00939174f, -0.03704169f, 0.02104083f, 0.04375105f, 
    -0.07266435f, -0.04896246f, 0.01832722f, -0.02754935f, -0.06983202f, 0.03320015f, -0.04595633f, 0.04736875f, 
    0.00098714f, 0.05403013f, -0.05131052f, -0.00589543f, -0.03896575f, 0.02601040f, -0.03717012f, -0.02034614f, 
    -0.07731985f, 0.05454366f, 0.06130660f, -0.01379294f, 0.05236503f, -0.00966650f, 0.06105310f, -0.05357653f, 
    -0.06779647f, 0.02828758f, 0.02902515f, -0.07793664f, 0.05587385f, 0.03076136f, -0.04864211f, -0.01003543f, 
    -0.01812404f, -0.04610793f, -0.07013381f, 0.01041037f, 0.06236603f, 0.01206093f, -0.07902085f, 0.05399586f, 
    -0.36612725f, -0.13527329f, 0.12139681f, -0.28088233f, -0.13248740f, -0.19065970f, -0.00925243f, 0.01300324f, 
    0.11058768f, 0.02583430f, 0.08702954f, -0.07147798f, -0.09683225f, -0.20782438f, -0.45701095f, -0.01751027f, 
    0.12034605f, 0.23805442f, 0.23617333f, -0.04805476f, 0.22909039f, 0.15918967f, 0.20217344f, 0.08443402f, 
    0.37316930f, 0.32132798f, -0.11414721f, -0.04529259f, -0.05987822f, -0.04978378f, 0.06718559f, -0.02991376f, 
    0.08877357f, 0.06961182f, 0.18027683f, 0.11642276f, -0.30899608f, -0.15233168f, 0.01825543f, -0.29243907f, 
    -0.11996569f, -0.06197454f, -0.09362979f, 0.09187425f, 0.02851658f, 0.04964339f, -0.20954387f, -0.08161233f, 
    -0.04300241f, -0.09670346f, 0.13207962f, -0.11227033f, 0.05413999f, 0.06594515f, -0.13204396f, 0.02824373f, 
    -0.08748003f, -0.07679562f, 0.09712809f, -0.13468829f, 0.38352680f, -0.00399911f, 0.15745981f, 0.03781321f, 
    0.01911848f, -0.07836372f, -0.05437305f, -0.09361903f, -0.02059462f, 0.00985371f, -0.19431581f, -0.01926554f, 
    -0.12189006f, 0.30333897f, -0.12022392f, 0.20928603f, -0.01085588f, -0.02348123f, 0.08140967f, -0.30940631f, 
    0.06542046f, 0.01371422f, 0.05850272f, 0.05706886f, 0.03589036f, -0.02825340f, -0.09279535f, -0.04392669f, 
    -0.03306001f, 0.02856167f, 0.07618642f, -0.05680102f, -0.13341838f, -0.05928226f, -0.10082614f, 0.00662782f, 
    0.14479764f, -0.06644373f, 0.27454031f, 0.20781283f, -0.05700283f, -0.02609484f, -0.03236136f, -0.11378614f, 
    0.15510257f, 0.08505880f, 0.07021520f, 0.15791011f, 0.22714654f, 0.29506269f, 0.14727961f, 0.00041841f, 
    -0.24914293f, 0.03846095f, 0.01337566f, -0.09420437f, 0.07281148f, 0.00481312f, 0.11847412f, -0.03426709f, 
    -0.25454366f, 0.22209457f, -0.11754969f, -0.02799966f, 0.03556923f, -0.20042300f, -0.01594181f, -0.01373219f, 
    0.09549011f, -0.00129255f, 0.08227431f, 0.06862437f, -0.44975430f, 0.01668628f, -0.46097514f, -0.15335916f, 
    0.23733632f, 0.00629768f, 0.13176027f, -0.13791296f, -0.16839591f, -0.18367396f, -0.14659257f, -0.37115610f, 
    0.43471861f, -0.05965241f, 0.47252941f, -0.03800623f, -0.06445799f, 0.00077848f, -0.04331970f, -0.21022084f, 
    0.07810259f, -0.06477472f, 0.07961486f, 0.13566737f, -0.49688396f, 0.14609960f, -0.04494957f, 0.20714960f, 
    -0.01526647f, -0.03173152f, 0.20786160f, 0.14353624f, 0.11686232f, 0.05911871f, 0.16217530f, 0.18562929f, 
    -0.35674444f, 0.11581042f, 0.14649580f, -0.28337684f, -0.11530950f, -0.02672004f, 0.08695022f, -0.02373455f, 
    0.01804734f, 0.00799665f, 0.23885030f, 0.18886738f, 0.05532099f, 0.00573055f, 0.03846883f, -0.27250579f, 
    -0.11002190f, -0.00584455f, 0.11773489f, 0.20525686f, 0.11830018f, -0.08012526f, 0.12521988f, 0.12948023f, 
    -0.04098386f, 0.01260203f, -0.06094120f, 0.02333169f, 0.04825525f, -0.05873710f, -0.04526018f, -0.01586787f, 
    -0.03799719f, -0.06029025f, 0.02462956f, 0.05027595f, -0.04283794f, -0.01405806f, -0.02856459f, 0.04900327f, 
    0.02713325f, -0.08099413f, -0.02664966f, -0.06277708f, -0.02608800f, -0.03620969f, -0.04812425f, -0.00869862f, 
    0.06145808f, -0.03746482f, 0.04282085f, 0.03231471f, -0.04571735f, 0.03831840f, 0.00396032f, -0.03030523f, 
    -0.03119160f, -0.03789157f, 0.04754649f, 0.00093685f, 0.02019059f, 0.03069336f, 0.05172738f, 0.04933550f, 
    0.04110027f, 0.01673583f, -0.01212575f, 0.01910199f, -0.00733386f, 0.04279835f, -0.07875702f, 0.00248200f, 
    -0.00329965f, 0.01661960f, -0.04478827f, 0.01050245f, -0.06434173f, 0.00524347f, 0.02021289f, -0.06032797f, 
    -0.08157139f, -0.07692009f, 0.03185258f, 0.04702687f, 0.02727072f, -0.01701788f, -0.06059283f, 0.04925495f, 
    -0.03255787f, 0.04104069f, -0.07269228f, -0.04471231f, -0.02380135f, -0.06941193f, 0.01673380f, -0.05700037f, 
    0.06025676f, 0.04498696f, -0.05509859f, -0.02232455f, -0.06314561f, 0.02226296f, -0.02778054f, -0.05326564f, 
    -0.03835901f, 0.03091072f, 0.00533279f, 0.03899449f, -0.04283719f, 0.05413434f, -0.06394771f, -0.01934442f, 
    0.01049752f, -0.04674073f, -0.04195343f, -0.05049513f, -0.07430211f, -0.02568788f, -0.04227123f, 0.02799880f, 
    0.06617816f, -0.07420658f, 0.02434891f, -0.02140300f, -0.05278806f, -0.00380026f, 0.00048910f, 0.02235575f, 
    -0.06517148f, -0.03648378f, -0.00833947f, -0.03826414f, -0.07186260f, 0.06171460f, -0.05038685f, 0.06118403f, 
    -0.04300817f, -0.04202215f, 0.05085897f, 0.04789399f, -0.07355314f, 0.04227739f, -0.02170037f, 0.06105764f, 
    -0.05527218f, 0.02498445f, -0.00582081f, -0.03191464f, -0.00036022f, 0.05676103f, -0.05974304f, 0.01403611f, 
    0.02973114f, -0.03470558f, 0.04561405f, 0.03467604f, -0.02833872f, -0.05704414f, -0.05606757f, -0.05819286f, 
    -0.03545443f, 0.02025012f, 0.04143118f, 0.00711074f, 0.02053731f, -0.02283659f, -0.03607954f, 0.05190253f, 
    0.05437973f, 0.01305970f, -0.00116366f, -0.00627033f, 0.02825574f, -0.05065504f, -0.02268814f, -0.01208510f, 
    -0.02809739f, -0.00061852f, 0.03404652f, -0.05693058f, 0.01873892f, 0.03404628f, 0.04463913f, 0.06282537f, 
    -0.06827598f, -0.03916198f, -0.00929819f, 0.04089925f, 0.04058477f, -0.05985345f, -0.02030492f, -0.06057741f, 
    -0.02654479f, 0.00666142f, 0.02337819f, -0.05772621f, -0.01076700f, 0.04109959f, 0.07008576f, -0.05008285f, 
    0.02777909f, -0.03897267f, -0.01116975f, 0.01553392f, -0.04931653f, -0.06894857f, 0.01325142f, 0.00846686f, 
    0.05711412f, 0.02156211f, -0.03444064f, -0.05337635f, -0.05872476f, 0.06459811f, 0.02352001f, 0.03706309f, 
    0.23819143f, 0.38565573f, -0.15378331f, 0.00629007f, 0.06593156f, 0.06607694f, -0.07915417f, -0.11902483f, 
    -0.17580694f, -0.12586088f, -0.07839920f, -0.09251562f, 0.13130482f, 0.13284306f, -0.11619545f, -0.16179708f, 
    -0.07686876f, -0.03373650f, -0.15208948f, -0.12611112f, 0.01410323f, 0.22904554f, -0.20812424f, 0.33707297f, 
    -0.02342750f, 0.06505193f, 0.01046291f, 0.13118668f, 0.33128512f, 0.07287233f, -0.00937811f, 0.01218522f, 
    0.04388545f, 0.21805856f, 0.07591431f, -0.12921371f, 0.00530775f, 0.07655283f, 0.05143348f, 0.15343370f, 
    -0.13475911f, -0.10014388f, 0.01103232f, -0.07219833f, -0.06559277f, 0.15091178f, 0.06633072f, 0.03502603f, 
    -0.38918194f, 0.14843841f, -0.11870508f, -0.05987712f, 0.01713624f, -0.07317211f, 0.24454817f, -0.00851681f, 
    0.08706170f, 0.03683104f, 0.06035150f, 0.00746168f, -0.28372100f, -0.06113960f, -0.18053751f, 0.01907783f, 
    0.02415070f, 0.15940535f, -0.05881239f, 0.30162457f, -0.13805076f, 0.01460648f, 0.06246264f, -0.14923362f, 
    -0.23075657f, -0.39820164f, 0.10627287f, 0.02502758f, 0.03796571f, 0.04108278f, 0.08080208f, 0.24181242f, 
    0.14026825f, 0.01644850f, 0.04794602f, 0.09536125f, -0.20803422f, -0.13241082f, 0.05323160f, -0.04897571f, 
    0.05855650f, 0.07696406f, -0.02522922f, 0.14216064f, 0.05727905f, 0.07680284f, 0.04987108f, -0.00439767f, 
    0.15831837f, 0.00847430f, -0.10465109f, 0.10819964f, 0.07849015f, 0.09852986f, -0.12535328f, 0.02893173f, 
    -0.10437997f, 0.02953356f, -0.03786726f, 0.16510029f, -0.11584580f, -0.17735766f, 0.01755244f, 0.27835834f, 
    0.09328163f, 0.01797226f, 0.16285381f, 0.11257075f, -0.03023413f, 0.00361318f, 0.00872077f, 0.04603935f, 
    -0.45782170f, -0.61170501f, 0.13893846f, 0.05664146f, 0.07321569f, 0.17852408f, -0.07895176f, -0.11919817f, 
    -0.04522577f, 0.08892987f, 0.04423011f, 0.14057836f, 0.25318483f, 0.08883744f, 0.08056775f, 0.13590199f, 
    -0.05492729f, 0.03206090f, 0.11669854f, 0.07559170f, -0.10104118f, -0.05394415f, -0.12214135f, 0.10236105f, 
    0.16954009f, 0.46447656f, 0.13191000f, 0.42541155f, 0.11445306f, 0.21300793f, 0.07326624f, -0.12064897f, 
    0.03073957f, -0.00354761f, -0.10298085f, 0.03722272f, 0.34055474f, 0.03030744f, 0.05114884f, -0.19666457f, 
    -0.07308835f, 0.19511870f, 0.03231409f, -0.10831866f, 0.15809599f, 0.04587974f, 0.05786218f, 0.05420569f, 
    0.25286677f, -0.02138698f, -0.06150640f, 0.01483072f, 0.15623808f, 0.18209609f, -0.04879761f, -0.12083708f, 
    0.09062400f, 0.17387405f, -0.15497138f, 0.11523475f, -0.21893045f, -0.14596766f, -0.10633528f, 0.13391803f, 
    0.04780301f, 0.04668456f, 0.06087648f, 0.05416663f, -0.20502104f, -0.02159314f, -0.02129837f, 0.04003242f, 
    0.02651051f, 0.01810801f, 0.05103127f, 0.05714102f, 0.05614093f, -0.08031996f, 0.03623560f, -0.05816287f, 
    -0.01399263f, 0.02284107f, 0.03423033f, -0.04741312f, -0.07235077f, 0.00219015f, -0.01102482f, -0.05745299f, 
    -0.07165834f, 0.00327354f, -0.04550078f, 0.02727820f, -0.00728581f, -0.04465312f, 0.05625898f, -0.01555197f, 
    0.01198214f, -0.02455643f, -0.08438540f, 0.06102927f, 0.02427603f, 0.01331274f, 0.00735879f, 0.04015785f, 
    -0.03852232f, 0.04983967f, -0.08022911f, 0.06003163f, -0.00395670f, -0.00109828f, -0.02522508f, 0.00431972f, 
    0.01626079f, -0.01330865f, -0.06783915f, -0.02214494f, 0.00743390f, -0.06965614f, -0.07622380f, -0.03096275f, 
    -0.07327405f, -0.01548384f, 0.00987550f, -0.05225515f, -0.04797070f, 0.01464167f, -0.01488819f, 0.05171495f, 
    -0.00593645f, 0.02448860f, 0.00579429f, 0.01918881f, 0.04154755f, -0.06079650f, -0.00388155f, 0.01382957f, 
    -0.06513854f, -0.01818125f, -0.02449112f, -0.02693551f, 0.02668860f, -0.03535623f, -0.07399585f, -0.06525742f, 
    -0.01205648f, 0.03767492f, -0.08163004f, -0.08199478f, 0.01194655f, -0.03578570f, 0.03707903f, 0.06573120f, 
    -0.04176306f, 0.05246123f, 0.03395118f, -0.05817003f, 0.04835146f, -0.03738182f, -0.03773618f, 0.04577035f, 
    -0.07843687f, -0.01822660f, 0.05290755f, 0.07033751f, 0.07568789f, -0.04026726f, -0.06300290f, -0.00190619f, 
    0.03187687f, 0.02501280f, 0.05169894f, -0.02404894f, -0.02831477f, -0.01898159f, 0.00814734f, 0.01987162f, 
    0.00949140f, 0.00779336f, 0.02858299f, 0.00092903f, -0.05937462f, -0.07772513f, -0.05344003f, 0.00331972f, 
    -0.01735183f, -0.06157316f, -0.00633508f, 0.01808648f, -0.06569304f, 0.01477192f, 0.01650811f, 0.00543489f, 
    -0.06564417f, 0.05600180f, -0.04448440f, -0.00818962f, 0.00693486f, -0.00665823f, -0.03432795f, -0.07094717f, 
    -0.02515322f, 0.04004512f, 0.04393237f, -0.03967097f, -0.07087047f, 0.04700251f, 0.04864632f, -0.03777357f, 
    0.00128738f, 0.05916137f, -0.01693072f, -0.07381411f, 0.00521556f, -0.04824918f, 0.04550446f, -0.02382573f, 
    -0.07084289f, -0.06432232f, 0.03969841f, -0.02968487f, -0.04271945f, 0.04641731f, 0.02300130f, -0.04871595f, 
    0.06400804f, 0.03830916f, 0.03566416f, -0.00313778f, 0.05576982f, 0.01026234f, 0.00566632f, 0.01002519f, 
    -0.04848177f, -0.05128529f, -0.05826025f, 0.00985975f, 0.01131497f, -0.02373926f, -0.07762706f, 0.05045331f, 
    0.05644924f, -0.00786963f, -0.02110491f, -0.01101097f, -0.05172450f, 0.02650935f, 0.00520480f, -0.08328114f, 
    -0.04862412f, -0.06958821f, -0.01919255f, -0.06090485f, -0.03509887f, -0.02600607f, -0.00126765f, -0.05593826f, 
    0.04807056f, -0.02983407f, 0.03886270f, -0.03183018f, 0.04814731f, -0.05659987f, -0.04178626f, 0.05021067f, 
    -0.14437412f, 0.35323706f, 0.38496739f, 0.04679446f, -0.15786363f, -0.06140993f, -0.12005257f, 0.06000848f, 
    0.06271863f, 0.12294579f, -0.20501070f, -0.20919250f, -0.01461929f, -0.12690732f, -0.35152659f, 0.22889823f, 
    -0.13067648f, 0.19180073f, 0.05351979f, 0.02331442f, -0.13733923f, -0.04431780f, -0.05962534f, 0.06883136f, 
    0.31385100f, 0.39676920f, -0.16458751f, -0.03864972f, 0.16221073f, -0.09575923f, -0.12905522f, -0.04416291f, 
    0.09706385f, -0.00108652f, 0.00084032f, 0.04845668f, -0.12875983f, -0.06610348f, -0.05151105f, -0.09548958f, 
    0.11946920f, 0.04912421f, 0.03922419f, -0.09365486f, 0.01349840f, 0.06464384f, 0.13557832f, -0.09747873f, 
    -0.40476936f, -0.65774703f, 0.20374708f, 0.08248225f, 0.02880907f, 0.10369597f, 0.07903808f, 0.21320747f, 
    0.02181253f, 0.03448060f, 0.02781632f, -0.20369522f, 0.21549818f, 0.05199494f, 0.07577388f, 0.28383672f, 
    0.10506592f, 0.01439973f, -0.07096206f, -0.13240969f, 0.06722827f, -0.00721264f, -0.06905133f, 0.22220740f, 
    -0.62128639f, 0.13972025f, -0.54896194f, 0.01193930f, -0.04027624f, 0.00495869f, 0.12603439f, -0.09082106f, 
    -0.00884017f, -0.07781436f, -0.01722486f, -0.02653345f, 0.08800501f, -0.21603839f, 0.01938699f, 0.01045336f, 
    -0.01701542f, 0.16048786f, 0.06915691f, 0.05841412f, 0.03112114f, 0.05754868f, -0.08363025f, -0.03264906f, 
    0.34784672f, -0.04873395f, 0.30090386f, 0.09642412f, 0.08247235f, -0.02367793f, -0.12986976f, -0.22234531f, 
    0.31002969f, 0.01754656f, 0.14731671f, 0.20841494f, 0.07511931f, 0.06238654f, 0.21223791f, 0.22089763f, 
    -0.09201147f, 0.07687416f, -0.15469907f, -0.08660237f, 0.16947973f, 0.10940976f, -0.01312500f, -0.10807637f, 
    -0.32680967f, 0.09532862f, -0.33520988f, -0.28963378f, -0.12876587f, -0.03315729f, 0.04809692f, -0.10771276f, 
    0.15075804f, 0.00336562f, 0.06000813f, 0.08858772f, 0.10336987f, 0.33723059f, 0.02940965f, 0.01598863f, 
    0.01907017f, 0.02124817f, 0.36014721f, 0.10078387f, 0.09428255f, 0.07259743f, 0.02153562f, -0.00507838f, 
    1.07239139f, 0.43820253f, 0.81582052f, -0.07676550f, -0.28055874f, -0.29636735f, -0.10392787f, 0.09466118f, 
    -0.12173967f, -0.00963722f, 0.19639693f, -0.01477793f, -0.21187767f, 0.16486460f, 0.13097484f, 0.09781904f, 
    0.00694364f, -0.24430308f, 0.03088734f, 0.06846212f, 0.18312819f, -0.16035236f, 0.07443114f, 0.18387212f, 
    0.00232444f, 0.24575564f, 0.39455330f, 0.08065169f, -0.06410038f, -0.15634240f, -0.04274838f, 0.08270913f, 
    0.12891951f, -0.00935758f, 0.07296617f, 0.13831033f, 0.04716955f, -0.11012190f, 0.03010725f, -0.14500427f, 
    0.07690886f, 0.03188753f, -0.00311489f, -0.02834948f, 0.25403848f, 0.11049777f, 0.24214409f, 0.19084890f, 
    0.37809941f, 0.36330262f, 0.08170394f, 0.10332548f, 0.07514704f, 0.16573977f, -0.01013334f, -0.03689392f, 
    -0.06395809f, 0.01079301f, -0.20704041f, -0.04130363f, 0.00305036f, 0.04794480f, -0.26223555f, 0.07847223f, 
    0.14778340f, 0.10731162f, -0.09305517f, 0.13927764f, -0.09100387f, 0.04208490f, 0.00700295f, -0.01748978f, 
    0.39052469f, 0.50867510f, 0.08892433f, 0.08692861f, 0.03760941f, 0.03943371f, -0.15066381f, 0.04877763f, 
    0.02210918f, 0.18748416f, 0.11147142f, -0.03959388f, -0.67392862f, -0.00340560f, 0.02238922f, -0.08689911f, 
    0.07919597f, 0.04239710f, 0.07131121f, 0.01325914f, 0.06934465f, -0.00463852f, 0.06515250f, 0.01035885f, 
    -0.34622937f, 0.22256267f, -0.04462877f, 0.13877052f, 0.05095102f, -0.14840075f, -0.06637708f, 0.14752567f, 
    -0.16621256f, -0.14101017f, 0.03568263f, 0.07508633f, 0.13669905f, -0.04033285f, -0.13702919f, -0.18344289f, 
    0.11337688f, -0.16794395f, 0.18676238f, -0.08180222f, 0.07424494f, 0.05365470f, 0.06139022f, 0.24925862f, 
    0.08214906f, 0.04107403f, 0.05791225f, 0.05272478f, -0.24676737f, -0.17276764f, 0.03123134f, 0.01840850f, 
    -0.00381186f, 0.08405256f, -0.04281287f, 0.03591892f, -0.04307910f, -0.17698257f, 0.01767255f, -0.04519115f, 
    -0.13668610f, -0.06329702f, -0.13997386f, 0.03799680f, -0.06593056f, 0.16286187f, 0.01279113f, 0.19472791f, 
    0.19753152f, -0.16394702f, 0.16514018f, -0.00448529f, 0.07415316f, -0.05194426f, 0.00283385f, -0.11539663f, 
    0.00150279f, 0.03652167f, -0.02437197f, -0.10134160f, 0.13552384f, 0.42163435f, -0.02645519f, -0.25398096f, 
    -0.23773970f, 0.03083964f, 0.01328260f, -0.16513044f, -0.07666864f, -0.08373626f, 0.14243047f, -0.10318493f, 
    -0.84880453f, -0.21296872f, -0.12465006f, 0.00367428f, -0.11603244f, 0.04368153f, -0.06630883f, -0.23973852f, 
    0.21919443f, 0.11992868f, -0.08311533f, -0.10338520f, 0.00113308f, -0.02448398f, -0.23985511f, 0.10888443f, 
    0.18707959f, 0.05391814f, 0.34902328f, 0.05889402f, -0.04360234f, 0.10241437f, 0.07574149f, -0.04391553f, 
    0.56524682f, -0.27805090f, 0.28706607f, 0.14089720f, 0.00296877f, 0.12478197f, -0.00914225f, -0.02962881f, 
    0.01228522f, 0.19155726f, 0.11478636f, 0.00239173f, 0.56159210f, 0.11056399f, -0.14419591f, 0.36167738f, 
    0.02769355f, 0.14863598f, 0.28445232f, -0.03213572f, 0.17036191f, 0.08591127f, 0.00108446f, 0.18680084f, 
    -0.03910018f, 0.07969198f, 0.09525717f, 0.07273196f, 0.19242592f, 0.20876019f, 0.08522151f, -0.08680944f, 
    0.02948443f, -0.05224529f, -0.03046756f, -0.02226472f, -0.13150088f, -0.23929280f, 0.10159702f, -0.32334584f, 
    -0.16045515f, -0.17998719f, -0.02283134f, -0.13244218f, -0.04625990f, 0.02815156f, 0.05267113f, 0.04976669f, 
    -0.01993703f, -0.07140471f, -0.02556890f, 0.04905515f, 0.01659216f, -0.01078135f, 0.02422079f, -0.03161003f, 
    0.05085830f, -0.00936993f, -0.04854875f, -0.04425175f, -0.03253713f, 0.05153087f, -0.07466471f, 0.04594903f, 
    0.06039836f, 0.01042388f, -0.05743120f, -0.04702535f, -0.03565369f, -0.04144610f, -0.03545124f, 0.04101739f, 
    -0.02861649f, -0.00605415f, 0.03949131f, -0.02078704f, -0.03023689f, -0.04133344f, -0.02928902f, 0.02154961f, 
    0.00622794f, 0.02132392f, -0.04922421f, 0.03649842f, 0.00779517f, 0.02163409f, -0.06020944f, -0.02510947f, 
    0.03919917f, 0.02914662f, -0.05353839f, -0.01289088f, 0.05641439f, -0.02114510f, -0.07558782f, 0.05382751f, 
    0.03146607f, -0.01563216f, -0.04386428f, -0.00899908f, -0.01847154f, 0.05027987f, -0.05415142f, -0.00115270f, 
    0.03655681f, -0.07840899f, -0.06324903f, 0.03394470f, -0.02962982f, 0.04638191f, -0.03062842f, 0.04743596f, 
    -0.01255307f, -0.01334951f, -0.05076068f, 0.01645741f, -0.06789827f, 0.01179508f, -0.02029635f, -0.07902344f, 
    0.02018107f, -0.01311128f, -0.01569815f, 0.02861122f, -0.07332909f, 0.06018537f, -0.06021304f, -0.02644880f, 
    -0.00979626f, -0.03669874f, -0.04482931f, 0.02084908f, 0.02830845f, -0.05830411f, -0.03958058f, 0.06084770f, 
    -0.02193972f, 0.03822130f, 0.03803786f, 0.02622961f, 0.01663275f, 0.03361325f, -0.04963486f, -0.01278930f, 
    0.02172226f, 0.03307935f, 0.02483217f, -0.08206944f, -0.04315858f, -0.00215975f, 0.04273275f, -0.07356232f, 
    -0.02165947f, -0.02039253f, -0.04722090f, -0.05662176f, 0.01370302f, -0.07609203f, -0.04329784f, 0.02797345f, 
    -0.00754872f, -0.00103762f, 0.05936214f, -0.04038178f, 0.00232744f, 0.05441880f, -0.04493959f, -0.04105931f, 
    0.03825461f, -0.04147713f, -0.04205144f, -0.01417667f, -0.00306403f, -0.02204713f, -0.06503499f, -0.02677381f, 
    0.04717861f, -0.03653028f, -0.07781240f, -0.06157769f, -0.04591825f, 0.05949588f, -0.07424623f, -0.06513891f, 
    -0.06418794f, 0.02342184f, -0.02102696f, 0.04240474f, 0.05130756f, 0.01637537f, 0.04454483f, 0.02078611f, 
    -0.03873395f, 0.00575511f, -0.02081693f, -0.06369455f, 0.04391108f, -0.01088729f, 0.01104291f, 0.03977783f, 
    -0.01651872f, 0.06106026f, -0.05380433f, -0.01280952f, 0.02395605f, 0.01727076f, 0.04145478f, -0.06315896f, 
    0.05636258f, 0.00176378f, 0.00634948f, -0.06589993f, 0.00237129f, 0.05027729f, 0.00062015f, 0.05897790f, 
    -0.08240566f, 0.00635063f, 0.01065524f, -0.02872661f, -0.08112029f, -0.07763751f, -0.04748892f, -0.00870881f, 
    0.03939521f, -0.02141081f, -0.01440097f, -0.04980193f, -0.03537999f, 0.03559766f, 0.01271278f, -0.00828930f, 
    0.05474851f, -0.03696361f, -0.06627235f, -0.00629039f, -0.06593072f, -0.02976782f, 0.03810334f, 0.03983178f, 
    -0.01209087f, -0.02276176f, -0.10289647f, -0.13308266f, 0.05254112f, 0.35013294f, 0.15777662f, 0.09628809f, 
    0.07584527f, -0.09580041f, -0.19714624f, 0.07615214f, -0.46879080f, -0.09563055f, -0.13057280f, -0.47719839f, 
    0.01107014f, -0.14891979f, 0.01365395f, 0.05017300f, -0.30094719f, -0.06816576f, -0.04526720f, -0.11535285f, 
    -0.08829115f, 0.01074395f, -0.10584372f, -0.21046345f, -0.06155772f, 0.10122441f, -0.07236788f, 0.15516686f, 
    0.06931399f, 0.20045939f, 0.02493847f, -0.18407691f, 0.03465503f, 0.26135278f, 0.03448757f, 0.09179826f, 
    0.10317826f, -0.03354833f, 0.17208442f, 0.14736067f, -0.10133243f, 0.00990919f, 0.01993365f, 0.04741482f, 
    0.12687808f, 0.12685928f, -0.33199573f, -0.34578317f, -0.16501236f, -0.14654310f, 0.01143061f, -0.02066995f, 
    0.09736315f, 0.11645133f, -0.02461474f, 0.07023143f, -0.21522352f, -0.06733298f, -0.18519965f, 0.27437225f, 
    -0.11325838f, 0.04004558f, 0.20461030f, 0.25428915f, 0.05946540f, 0.04533667f, 0.25783968f, 0.32562172f, 
    -0.08405122f, -0.24455447f, 0.40799519f, 0.07426678f, -0.14414871f, 0.34446809f, 0.05822263f, 0.17433013f, 
    -0.03261422f, 0.15220632f, 0.11523435f, 0.38669676f, -0.05211629f, 0.16473700f, 0.09440216f, -0.03260618f, 
    -0.01831399f, -0.04937183f, -0.11433771f, 0.07989973f, -0.12159673f, 0.11030123f, 0.04179553f, 0.03676831f, 
    -0.07090984f, 0.16067030f, 0.00884085f, -0.16677755f, -0.21631622f, 0.02959815f, -0.04194310f, -0.02192133f, 
    -0.25819620f, -0.29633299f, -0.15290292f, -0.13650022f, 0.01351201f, -0.14493759f, -0.06924172f, 0.13906491f, 
    -0.04600367f, 0.18208227f, 0.02144597f, -0.15059344f, 0.17582753f, -0.16803449f, 0.17613932f, -0.09113845f, 
    0.28520921f, -0.05019297f, 0.20245008f, -0.16418649f, -0.08262640f, -0.04849057f, -0.02099254f, 0.12789783f, 
    0.11264463f, 0.02884669f, 0.22072366f, 0.08015242f, -0.09912379f, -0.38242126f, 0.00859618f, -0.11583862f, 
    -0.08618094f, 0.01669103f, 0.08338062f, 0.30380154f, -0.16709433f, -0.02158110f, -0.04074691f, 0.14207521f, 
    0.02232522f, 0.01102372f, 0.02870078f, -0.07014933f, -0.03128006f, 0.00417992f, 0.02576188f, 0.09423493f, 
    -0.09472251f, 0.11826094f, 0.07051588f, -0.10404496f, 0.46991292f, -0.34152886f, 0.20750786f, 0.04287939f, 
    0.05130080f, 0.17882763f, 0.07748733f, 0.08113594f, 0.06241347f, -0.01458593f, 0.12507896f, 0.07659256f, 
    -0.02169220f, 0.05947441f, -0.01008080f, -0.08291081f, -0.02277483f, 0.21331896f, 0.05173852f, -0.14186203f, 
    0.15845981f, 0.03551386f, -0.04861457f, -0.07984545f, 0.13357869f, 0.19747409f, -0.03041367f, 0.13765453f, 
    -0.17737611f, -0.26860633f, -0.14855741f, -0.09252413f, -0.04905760f, -0.01119673f, -0.06132201f, -0.01256465f, 
    0.01610188f, 0.06267921f, 0.03488498f, 0.01516788f, -0.04735829f, 0.04488345f, -0.01189271f, -0.01584211f, 
    -0.03558374f, -0.05284876f, -0.00497169f, 0.02864446f, -0.03874059f, 0.06202547f, 0.01453685f, -0.02955499f, 
    -0.02916006f, -0.01661942f, 0.03312542f, 0.06025379f, -0.01347228f, -0.05674087f, 0.03440861f, -0.01102923f, 
    0.03976706f, 0.00329554f, -0.03094742f, -0.05521379f, -0.05538966f, -0.00313074f, 0.03489359f, 0.03108652f, 
    -0.07788911f, -0.07906717f, 0.03782184f, -0.01908017f, 0.02578223f, -0.01977451f, 0.04779813f, -0.01608593f, 
    -0.03781767f, -0.01995539f, -0.06785326f, -0.01486443f, 0.03403768f, 0.02355274f, -0.02050424f, 0.00137403f, 
    0.06116027f, -0.02065464f, -0.04416975f, -0.05021043f, -0.05091558f, 0.04926069f, -0.06338000f, -0.05794868f, 
    0.03089978f, -0.04990227f, 0.03826721f, -0.04011308f, -0.02851839f, -0.05035516f, -0.06710905f, 0.05304024f, 
    0.03250334f, -0.01437848f, -0.03100714f, 0.03740800f, -0.06767897f, 0.01334277f, 0.04899349f, 0.06036134f, 
    0.00728689f, 0.01925539f, -0.05086768f, -0.04879765f, -0.03232037f, -0.01963283f, -0.04055103f, -0.04540183f, 
    0.02618128f, 0.00828834f, 0.01625754f, -0.01815808f, -0.01314849f, -0.06074533f, -0.04674132f, -0.00468587f, 
    0.06036782f, -0.00343350f, 0.02909041f, -0.02614284f, -0.06055726f, 0.05234120f, -0.00209582f, -0.06859984f, 
    0.04059793f, -0.07654071f, -0.07534216f, -0.01203173f, -0.00259803f, -0.01319722f, -0.04933621f, -0.07553982f, 
    0.03909938f, 0.03261431f, 0.01332744f, -0.06565166f, -0.05837368f, 0.00237652f, -0.02110544f, -0.03937231f, 
    0.04572336f, -0.02518675f, -0.06174500f, -0.04283605f, 0.03405428f, -0.04741633f, -0.02304184f, -0.06051406f, 
    -0.05086891f, 0.03279882f, -0.04702288f, -0.02992040f, 0.05883266f, 0.01036991f, -0.04825766f, 0.05821083f, 
    0.02532848f, -0.06980409f, -0.02128846f, -0.01051055f, -0.04301963f, -0.00124801f, 0.02069245f, -0.04099707f, 
    0.00993237f, -0.03168114f, -0.04343382f, -0.00035735f, -0.03667603f, -0.01612617f, -0.03647533f, -0.00065812f, 
    -0.06141490f, -0.07606171f, 0.01207019f, 0.06319827f, -0.07969705f, -0.01610417f, 0.05093728f, -0.00827593f, 
    -0.03462325f, -0.07558490f, -0.06735402f, -0.01714782f, 0.05772986f, -0.05357183f, 0.05713244f, -0.02838496f, 
    -0.05343542f, -0.05879236f, -0.02162975f, -0.01764043f, -0.01562883f, -0.04355863f, -0.02387109f, -0.05179322f, 
    -0.03114591f, -0.03215145f, 0.02245255f, -0.04573913f, 0.01705612f, 0.04953291f, -0.07252332f, 0.05273004f, 
    0.02851935f, 0.03519299f, -0.03545865f, 0.01167943f, -0.04776198f, -0.01792317f, 0.02545560f, 0.00107348f, 
    0.01700293f, -0.03645865f, 0.04592441f, 0.02468447f, 0.01964547f, -0.06185494f, -0.07374939f, -0.04805272f, 
    0.08599844f, 0.15331781f, -0.02806114f, 0.21572074f, 0.00596183f, -0.10419700f, 0.02102875f, 0.03341493f, 
    -0.13808349f, 0.10868572f, 0.09407252f, 0.02803331f, 0.28233799f, 0.37005696f, -0.06738259f, 0.27848852f, 
    0.07815150f, 0.29995397f, -0.07293858f, 0.07719564f, 0.35064766f, 0.16790977f, 0.07631831f, 0.36109069f, 
    0.12873727f, 0.04193652f, -0.11846652f, -0.17887475f, 0.02735089f, -0.12822442f, -0.17057014f, -0.10824478f, 
    0.04610808f, 0.14409688f, 0.03301507f, 0.14526668f, -0.13895014f, -0.06697381f, 0.00417899f, 0.02937588f, 
    0.00025741f, 0.03729879f, -0.06725845f, -0.28665811f, -0.04526323f, -0.19160908f, -0.31518233f, -0.60483497f, 
    0.11040075f, 0.21811518f, 0.16366315f, -0.02343422f, 0.15252948f, -0.14074348f, 0.14069666f, -0.26380202f, 
    -0.41500366f, -0.14110434f, -0.20256668f, -0.18016531f, 0.05410856f, 0.08868753f, -0.07313089f, -0.34981436f, 
    0.06687211f, -0.09102373f, -0.28495619f, 0.08803625f, 0.00882572f, -0.16922967f, -0.08616709f, -0.12323696f, 
    -0.10942589f, 0.04263023f, -0.10113154f, 0.05337367f, -0.15074955f, 0.08073482f, -0.09125355f, -0.15321235f, 
    -0.03827386f, 0.03324720f, 0.16688888f, -0.01400534f, -0.17425621f, -0.26821783f, 0.03222718f, 0.04754226f, 
    0.27556255f, 0.06599254f, -0.07781877f, -0.15000401f, -0.25459844f, -0.40161142f, -0.46091616f, -0.56982070f, 
    0.29138395f, -0.09185635f, -0.06348974f, 0.21493191f, 0.04871787f, 0.00228382f, 0.01037816f, 0.15331155f, 
    0.17971259f, 0.36988726f, 0.24922110f, 0.37848926f, 0.06401499f, -0.02488058f, -0.07745378f, -0.02048532f, 
    0.09218876f, -0.21078050f, 0.11196439f, -0.14151445f, -0.00756256f, 0.20206931f, 0.13181187f, 0.29793966f, 
    -0.43198460f, -0.09801797f, 0.15700127f, 0.14453334f, 0.19193040f, 0.02140474f, 0.00610180f, -0.35722160f, 
    -0.00599656f, -0.15940775f, 0.01484722f, 0.15485571f, 0.18586726f, 0.34861702f, -0.11852101f, -0.02122983f, 
    0.07980613f, 0.09850401f, 0.04911232f, 0.01015983f, -0.05309795f, -0.32078180f, -0.20479997f, -0.64907557f, 
    0.31185308f, 0.04288728f, 0.07668947f, 0.30600950f, -0.09618956f, 0.04756850f, -0.08836395f, -0.19912809f, 
    -0.02275678f, -0.12530604f, -0.00314307f, 0.27406436f, -0.01618259f, 0.30825114f, -0.01877171f, 0.10105029f, 
    0.05827168f, -0.04533255f, 0.10305678f, 0.01052996f, 0.14443256f, 0.20200679f, -0.00163499f, 0.08897031f, 
    0.28554103f, 0.14325505f, 0.16202681f, 0.21906722f, 0.16378990f, -0.06300232f, 0.08788328f, -0.08623078f, 
    0.12288431f, 0.22478586f, 0.19240588f, 0.44754034f, -0.55396831f, -0.53378636f, -0.20729886f, -0.02398185f, 
    -0.11510455f, 0.16257639f, 0.05209973f, -0.15173261f, 0.18971984f, 0.29516339f, 0.13854825f, 0.38929993f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.20003827f, 0.02450373f, 0.23944978f, -0.03175485f, 0.07973831f, 0.00599931f, 0.16420610f, 0.04223362f, 
    0.22256283f, 0.10213990f, 0.17566051f, 0.01790435f, 0.04637885f, -0.11746829f, 0.25979108f, 0.16780140f, 
    -0.04552860f, 0.14331993f, 0.06598922f, -0.05326963f, 0.06532069f, -0.07591431f, 0.14496957f, -0.00983452f, 
    -0.15795144f, -0.03490237f, 0.08528654f, 0.08755916f, -0.02806760f, 0.15413740f, -0.06750192f, -0.01638517f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07397731f, 0.67017603f, 0.13652509f, 0.44823617f, 0.21860704f, 0.21327244f, -0.13357782f, 0.06704383f, 
    0.57251900f, -0.04221215f, -0.33817604f, -0.49861029f, -0.01463266f, 0.32287937f, 0.03296325f, 0.13654077f, 
    -0.08614027f, 0.16918938f, -0.22952612f, -0.07621738f, 0.45341727f, -0.10693415f, -0.12587450f, 0.11014453f, 
    0.12120954f, 0.15370029f, -0.29624403f, 0.28810349f, -0.09412339f, 0.35045516f, 0.11551733f, -0.17013936f, 
    0.02526736f, -0.06524502f, 0.38457948f, 0.22168557f, -0.00714140f, -0.17927356f, -0.21658041f, 0.06282109f, 
    -0.26406169f, 0.21931340f, 0.48138982f, -0.06056269f, -0.37532628f, -0.04198926f, 0.19067094f, 0.15826313f, 
    -0.44351867f, 0.24617615f, -0.25829521f, -0.23306808f, 0.16274795f, -0.02361002f, 0.49510500f, 0.15150614f, 
    -0.30144611f, 0.04226290f, 0.48635799f, 0.27741101f, -0.05398221f, -0.41403866f, 0.10169283f, 0.22040147f, 
    0.34824732f, -0.24972314f, -0.09732392f, -0.00213714f, -0.56907845f, -0.15378881f, -0.32623404f, -0.06016824f, 
    0.10480523f, -0.08216462f, -0.00982751f, 0.17098387f, 0.63850528f, -0.16624686f, -0.23500435f, 0.10220905f, 
    0.35408843f, 0.11340013f, -0.07763464f, 0.31388408f, 0.43549773f, 0.06633998f, -0.09020828f, 0.12180340f, 
    0.29718721f, 0.09505323f, 0.13780349f, 0.25608760f, 0.01232819f, -0.05543963f, 0.08063554f, 0.62682855f, 
    0.01699655f, -0.20979601f, 0.01751468f, -0.12903520f, -0.00007314f, -0.00978874f, -0.09299135f, 0.04150266f, 
    -0.19036387f, 0.04480164f, -0.02877099f, -0.01998479f, 0.00893015f, -0.11800016f, -0.00965445f, -0.16534029f, 
    0.09069697f, -0.10859100f, -0.11197631f, -0.10661582f, -0.09934851f, -0.13981976f, 0.01349129f, 0.14555614f, 
    -0.19166671f, -0.12645452f, -0.09291765f, 0.09263376f, -0.03122764f, -0.10175772f, -0.17419389f, 0.06560360f, 
    0.32127407f, -0.21476755f, 0.37549868f, -0.36244041f, -0.19190069f, -0.12915897f, 0.29092479f, -0.66747355f, 
    -0.19434254f, 0.16455552f, 0.21310471f, 0.39952290f, 0.35526067f, -0.15695731f, 0.08662740f, 0.39799058f, 
    0.30615214f, 0.02058571f, 0.10410868f, 0.18360196f, -0.24964941f, -0.07553466f, -0.05279836f, -0.11067916f, 
    -0.12736976f, 0.00770164f, -0.18259029f, 0.07077125f, 0.08829920f, 0.05276252f, -0.08496403f, -0.07074729f, 
    -0.18241370f, 0.19706221f, 0.29265672f, 0.44346413f, -0.16294493f, 0.03180864f, 0.12530860f, -0.06578358f, 
    0.17563829f, -0.47154185f, 0.21909320f, -0.00079122f, 0.03529568f, -0.23841283f, 0.42534366f, 0.02020729f, 
    -0.21908902f, 0.13336807f, 0.07785939f, -0.13798377f, -0.13331366f, -0.04408573f, 0.62821972f, -0.00202236f, 
    0.13351692f, -0.14023137f, 0.59029055f, 0.18961321f, 0.15199144f, 0.06393533f, -0.12797810f, -0.16889986f, 
    -0.07992062f, 0.08338779f, -0.17350733f, 0.08287324f, -0.10842726f, 0.04677893f, 0.13537148f, -0.07008763f, 
    -0.15307975f, -0.10281742f, -0.15356341f, -0.12496968f, 0.10020615f, 0.06913139f, -0.10167999f, 0.09800771f, 
    -0.05967994f, -0.08060104f, -0.16112554f, -0.09273723f, -0.12994754f, -0.15626653f, -0.12912998f, 0.11516204f, 
    -0.02370267f, -0.08096460f, -0.04715107f, 0.08564372f, -0.16853242f, 0.03917084f, -0.09851010f, 0.03434018f, 
    0.18919203f, 0.38995329f, -0.28475669f, 0.34170699f, 0.13356994f, -0.01015227f, -0.05122443f, -0.03228821f, 
    0.00040883f, -0.04733145f, -0.16151236f, -0.00194338f, 0.12021390f, 0.36362630f, -0.16499309f, 0.19565488f, 
    0.20994453f, 0.10988314f, 0.30917582f, 0.28688064f, -0.09236408f, 0.07915410f, -0.46010464f, 0.17081146f, 
    -0.04570404f, 0.04393758f, -0.48963240f, 0.02405147f, -0.15770219f, 0.06557485f, 0.06413054f, 0.13427058f, 
    -0.14482820f, -0.21725954f, 0.03897857f, 0.17648079f, 0.05349925f, -0.15309808f, -0.66060966f, 0.14562523f, 
    -0.46414647f, 0.09571795f, 0.13948792f, -0.03368824f, 0.17041929f, 0.05384631f, 0.06980824f, 0.18938982f, 
    0.19741242f, 0.44397390f, -0.12521046f, 0.02671153f, 0.44438738f, -0.05697986f, 0.40304506f, -0.16311713f, 
    -0.20016573f, 0.04322458f, 0.23272662f, 0.20242316f, -0.16477345f, -0.66819543f, -0.11206172f, 0.46569309f, 
    -0.00224247f, -0.22405359f, -0.19605148f, -0.00216801f, 0.17043068f, -0.16540302f, -0.16339812f, 0.05620047f, 
    0.14690787f, -0.10117469f, -0.10766785f, -0.15951315f, 0.02643759f, -0.08080077f, -0.13153106f, -0.16578525f, 
    0.03470028f, -0.12460180f, -0.17063297f, -0.06415358f, 0.02480106f, -0.09794321f, 0.14513604f, 0.11384301f, 
    0.05065142f, 0.10777643f, -0.18619472f, -0.14236711f, -0.08027948f, -0.16588771f, 0.02765253f, 0.15773438f, 
    -0.26771683f, 0.20095125f, -0.06591707f, 0.11173239f, 0.03927604f, 0.29361594f, 0.06442022f, 0.10985995f, 
    0.22240996f, -0.19702809f, 0.14129747f, -0.53804815f, -0.22550881f, -0.32346463f, -0.17586656f, 0.27302462f, 
    -0.01214585f, 0.22315282f, 0.24383953f, -0.06079198f, -0.14086390f, -0.16863641f, 0.45719784f, -0.08626058f, 
    -0.17379522f, -0.10860678f, -0.05491127f, 0.17665774f, 0.15598196f, 0.36712834f, 0.05282486f, 0.16786219f, 
    -0.14374724f, 0.37399325f, -0.32064271f, 0.33233693f, 0.41068321f, 0.01427008f, 0.31379330f, -0.15160178f, 
    -0.03339231f, -0.21981399f, 0.02529819f, -0.16563001f, 0.14897434f, 0.30956343f, -0.00817532f, -0.16698697f, 
    -0.09780329f, -0.31974447f, -0.31134579f, 0.14542842f, -0.26635584f, 0.14177743f, 0.08180686f, -0.03799485f, 
    -0.04924130f, 0.03852525f, 0.11696349f, 0.30292627f, 0.16020884f, 0.34729409f, -0.14850347f, -0.02448040f, 
    -0.02417612f, 0.42467684f, 0.01192756f, 0.36730549f, -0.09683343f, 0.18924338f, -0.18010521f, 0.12737215f, 
    0.58210707f, -0.14071786f, -0.41278034f, -0.14361255f, -0.07325343f, 0.17041986f, 0.10807692f, -0.34765801f, 
    0.12676725f, 0.19777679f, -0.66226220f, 0.18023111f, 0.40707132f, 0.05869473f, 0.01716072f, -0.11855262f, 
    0.04289678f, -0.16760740f, 0.09518454f, 0.28758931f, -0.08340850f, 0.06246814f, 0.16060866f, -0.06141257f, 
    0.26045501f, 0.25162831f, -0.38202319f, -0.22593728f, 0.41553801f, -0.20677148f, -0.20121028f, 0.15569343f, 
    -0.32066053f, 0.18384609f, -0.25640985f, 0.02743036f, 0.02850727f, 0.34468663f, -0.03613237f, 0.06237036f, 
    0.40661934f, 0.19144054f, -0.11176042f, 0.41307095f, 0.00123229f, -0.17143051f, -0.47126269f, -0.04170832f, 
    -0.06779295f, -0.14818071f, -0.06998792f, -0.06617058f, -0.11481536f, -0.35366598f, -0.10875652f, 0.10121776f, 
    -0.39173391f, -0.06144694f, -0.28650263f, -0.29750359f, 0.15794384f, 0.06450129f, 0.30375549f, -0.02496177f, 
    0.03143948f, -0.02599312f, 0.26302260f, -0.08279743f, 0.00267702f, 0.05017185f, -0.17758718f, 0.14666449f, 
    -0.23123598f, -0.12043036f, -0.10142092f, -0.00622590f, -0.24274032f, -0.00958864f, -0.00875361f, 0.10190972f, 
    0.26301044f, 0.13718505f, -0.12755181f, 0.10631350f, 0.12999706f, -0.20576733f, -0.10228323f, 0.00537411f, 
    -0.04209620f, -0.10223492f, -0.03872564f, 0.27940953f, -0.38662884f, 0.16706747f, -0.13756384f, 0.11082101f, 
    0.06493829f, -0.11289518f, -0.16544580f, 0.04824175f, 0.29983732f, -0.35018468f, 0.10164028f, 0.17878075f, 
    -0.34741196f, 0.02146620f, -0.02435132f, -0.27190661f, 0.03580924f, 0.03632225f, 0.47298247f, -0.03541309f, 
    -0.09626528f, -0.06962435f, 0.38203606f, -0.02806392f, -0.05441649f, 0.14908151f, 0.06642141f, 0.02458695f, 
    0.08262245f, -0.23902509f, -0.04786529f, -0.14528592f, 0.06888402f, 0.33546856f, -0.12282788f, 0.02997837f, 
    -0.12478474f, 0.17688784f, 0.16058162f, 0.06071614f, -0.04560640f, -0.27644074f, 0.08473066f, 0.16828765f, 
    -0.10784167f, -0.11664756f, 0.39863211f, -0.48773834f, -0.16484228f, 0.14778902f, 0.16998671f, 0.09171826f, 
    -0.24973576f, 0.02500043f, -0.02904275f, -0.01339695f, 0.00891449f, -0.02606681f, -0.03331700f, -0.08595108f, 
    0.08662540f, 0.08526266f, -0.06367291f, 0.00240052f, 0.26921749f, -0.28919193f, 0.11462351f, -0.14150849f, 
    -0.00737672f, -0.09715126f, -0.00014473f, 0.44612911f, 0.47898537f, 0.14672121f, 0.11295634f, -0.26266390f, 
    0.26339450f, -0.00646613f, 0.00743126f, 0.34475681f, -0.11212969f, -0.16850914f, 0.19175485f, -0.14249359f, 
    -0.25315115f, -0.16530402f, 0.28106010f, 0.12787986f, 0.08932727f, -0.05812884f, -0.15577981f, -0.45963135f, 
    -0.43276280f, -0.37911898f, -0.25285059f, 0.29532441f, 0.00870737f, -0.04269069f, -0.22624828f, -0.00273491f, 
    -0.06056042f, -0.48157531f, 0.12420694f, 0.50923949f, 0.46544966f, -0.00696159f, 0.13145544f, 0.21635647f, 
    -0.01444975f, -0.01338910f, 0.28524947f, -0.12649037f, -0.13359806f, 0.08085954f, 0.42048922f, -0.04662330f, 
    -0.49396834f, 0.08548981f, 0.36024189f, -0.03069132f, -0.15206780f, 0.00800235f, -0.13118948f, 0.14784060f, 
    0.11524406f, -0.17485638f, -0.18833773f, 0.28483546f, -0.39226860f, -0.28243023f, -0.04682589f, -0.16372968f, 
    0.07976780f, -0.04755833f, 0.12680580f, 0.19292717f, 0.62952703f, -0.23042245f, -0.03703804f, 0.19962022f, 
    0.23850460f, -0.23014596f, -0.16006111f, 0.30653942f, 0.16645873f, -0.12834063f, 0.03052234f, -0.09224238f, 
    0.21424817f, 0.11469384f, 0.20555954f, 0.16576678f, -0.02417115f, 0.05990308f, 0.10842392f, 0.37680465f, 
    0.20618214f, 0.08987759f, 0.19120747f, 0.07559096f, -0.02453246f, -0.08193146f, -0.40708536f, 0.39754263f, 
    0.38293472f, 0.21652667f, 0.38752350f, -0.05753929f, -0.41525951f, -0.12246432f, -0.04142513f, -0.07701171f, 
    -0.38449425f, 0.35795110f, -0.19118176f, -0.09946255f, 0.55277342f, 0.00895076f, -0.45598465f, 0.06896076f, 
    -0.03411377f, 0.02885992f, 0.22765981f, -0.28034264f, 0.12828530f, 0.12590960f, 0.00446318f, 0.25648776f, 
    0.47614357f, -0.54023838f, 0.19508374f, -0.53487724f, 0.33898669f, -0.10922474f, 0.03168420f, 0.29723567f, 
    -0.34025237f, 0.62033147f, 0.47880778f, 0.42953259f, 0.04607499f, 0.19021657f, 0.09934112f, -0.00553216f, 
    -0.00805289f, -0.03260439f, 0.03149734f, 0.17616123f, -0.00042040f, 0.06674511f, -0.19842556f, -0.11686271f, 
    0.16476248f, -0.16082694f, 0.08190425f, 0.03541399f, 0.09578999f, -0.14742190f, -0.04405192f, -0.07694723f, 
    0.21913618f, 0.16260009f, -0.28780749f, 0.11781911f, -0.47914189f, -0.13297941f, -0.15743829f, -0.23666854f, 
    0.04118806f, 0.00180606f, 0.33155301f, 0.22970262f, 0.13351756f, 0.05999645f, -0.30183110f, -0.15234189f, 
    0.00152560f, -0.64543945f, -0.07485265f, 0.29420716f, -0.31800902f, -0.07936108f, -0.32444343f, -0.08385649f, 
    0.25969681f, 0.08049260f, 0.16886175f, 0.16776548f, 0.11929248f, 0.06835470f, 0.17295848f, 0.34355152f, 
    -0.00204208f, -0.05128859f, -0.06029184f, 0.01755792f, 0.01399170f, -0.11896868f, -0.10065162f, 0.08600252f, 
    -0.22080457f, -0.12891744f, 0.03100603f, 0.07142724f, 0.04318693f, -0.00769216f, -0.00740049f, -0.19191830f, 
    0.00415916f, -0.04562816f, 0.04131834f, 0.09064177f, -0.03717504f, -0.02353898f, -0.03226719f, -0.05511824f, 
    -0.10692166f, 0.08040521f, -0.18432899f, 0.09326746f, 0.13223678f, 0.10053378f, -0.08484287f, -0.14032678f, 
    0.23476538f, -0.05644253f, 0.47463757f, -0.10785923f, 0.04324006f, -0.00120570f, 0.23210506f, -0.22557972f, 
    0.55930722f, 0.00135557f, 0.02619189f, 0.16254729f, 0.05847391f, -0.21092725f, 0.11122082f, 0.05710866f, 
    0.25907129f, 0.03391210f, -0.23352423f, -0.07822330f, 0.01898578f, 0.04181802f, -0.34154335f, -0.09367407f, 
    -0.17448407f, 0.15027869f, 0.12225110f, 0.05514614f, 0.07685983f, 0.32125178f, -0.08110898f, -0.64749813f, 
    -0.05981766f, 0.15401220f, 0.02752871f, -0.08615213f, -0.00601431f, -0.08151624f, -0.00618142f, -0.11386376f, 
    -0.12689602f, 0.00618818f, 0.11359613f, 0.03364838f, -0.06518684f, -0.10980926f, 0.03313115f, -0.06040842f, 
    -0.02258211f, 0.00393707f, 0.01396064f, 0.01811549f, -0.14173089f, 0.07536564f, -0.17550440f, -0.15766785f, 
    -0.16637608f, 0.05533089f, -0.10929301f, 0.01509130f, 0.11423209f, -0.10905599f, -0.17161183f, 0.02319540f, 
    0.11366447f, 0.20826232f, -0.28080902f, -0.21536885f, 0.64115286f, -0.13304445f, -0.17271276f, 0.07826596f, 
    0.32236749f, 0.23158954f, 0.38833496f, -0.34226865f, -0.20838359f, -0.01886413f, -0.17228322f, 0.33490363f, 
    -0.33364812f, 0.33982110f, 0.11617056f, -0.03208097f, -0.10593001f, -0.04476968f, -0.15887623f, 0.07277162f, 
    -0.20727327f, 0.16089045f, -0.20188068f, -0.28772643f, -0.11252648f, 0.21481930f, 0.10328995f, 0.15213512f, 
    -0.00849714f, 0.13347404f, -0.10812043f, -0.15399955f, 0.30395564f, -0.14810693f, 0.43442079f, 0.11380277f, 
    0.06553425f, 0.24165364f, -0.08784156f, 0.11747857f, 0.21460153f, -0.21515127f, -0.03296212f, -0.53424162f, 
    0.14184888f, 0.10117441f, 0.05483501f, -0.08490553f, -0.35690427f, -0.16919997f, 0.15585358f, -0.02490431f, 
    -0.07421883f, -0.03495482f, 0.30944681f, 0.12644319f, 0.13824131f, 0.41251519f, 0.13228971f, -0.18498257f, 
    -0.12288702f, 0.52519852f, -0.27916670f, 0.52153236f, 0.05318143f, -0.33489168f, -0.12638910f, 0.20433551f, 
    0.03219197f, 0.20020923f, -0.20956574f, 0.09813562f, 0.01693515f, 0.33425575f, 0.14816231f, -0.47638062f, 
    0.18628079f, -0.17015667f, -0.50890648f, 0.08725499f, -0.20834948f, -0.07427026f, -0.25736743f, -0.13233574f, 
    0.11617252f, 0.03841693f, 0.27695310f, 0.14628462f, 0.13217191f, 0.09130591f, -0.09067531f, 0.12549959f, 
    -0.01422265f, 0.46721196f, 0.23189166f, 0.45921224f, -0.19665483f, 0.22753778f, 0.17273618f, -0.40216887f, 
    0.28268012f, -0.45166814f, -0.28158888f, -0.17084441f, -0.05724538f, 0.24273327f, 0.27931783f, 0.27853334f, 
    0.27713558f, -0.08642600f, 0.07215558f, 0.20472503f, -0.22808607f, -0.13471004f, 0.30568829f, -0.13020399f, 
    -0.24574305f, -0.04697585f, -0.07721344f, 0.33679578f, -0.02897553f, -0.05547274f, -0.05252586f, -0.05786753f, 
    0.32533199f, -0.09843476f, 0.17129661f, -0.27545771f, 0.16879478f, -0.05993035f, 0.26370728f, 0.06779893f, 
    0.41441458f, 0.37351310f, 0.48671648f, 0.40726554f, -0.17962804f, -0.06650211f, 0.22790058f, -0.12445095f, 
    0.16951518f, 0.26783890f, 0.12417716f, 0.04608656f, -0.04136289f, -0.00823983f, -0.62775511f, 0.00739642f, 
    -0.27467600f, 0.06918248f, -0.12742180f, -0.15067931f, -0.14811815f, 0.22432828f, 0.05146536f, -0.38884670f, 
    0.06595248f, 0.21243234f, 0.29419670f, 0.07169300f, -0.16979976f, -0.05470318f, -0.15405945f, 0.14317182f, 
    0.30009508f, 0.08539284f, -0.07548701f, -0.09383994f, -0.32197821f, 0.15570964f, 0.37892473f, 0.12010449f, 
    0.02056882f, 0.57863569f, 0.20246483f, 0.02280446f, 0.53547502f, -0.03628068f, -0.10990910f, -0.10530053f, 
    -0.15488689f, 0.12152377f, -0.00887045f, -0.13286580f, 0.01386015f, -0.23701164f, 0.14046341f, 0.00524115f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.23163109f, 0.25942373f, 0.06885861f, 0.04152555f, 0.09843361f, 0.25559860f, -0.14122030f, -0.08353176f, 
    0.06682088f, -0.04475490f, 0.12890078f, 0.03103948f, 0.22082275f, 0.09390926f, -0.05937845f, 0.17928155f, 
    -0.16061239f, -0.01184994f, 0.02038862f, 0.30676931f, 0.29176274f, 0.01624173f, -0.03742952f, -0.22782604f, 
    0.32286438f, -0.03688014f, 0.18963729f, -0.01439055f, 0.04901716f, 0.09836019f, 0.32916510f, 0.26724193f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.31366470f, -0.48094350f, 0.18605557f, 0.10123441f, 0.26168370f, -0.35689622f, 0.14772949f, 0.22330002f, 
    -0.13523817f, -0.12470824f, -0.06369651f, 0.15730886f, -0.29614565f, 0.22042000f, 0.13654795f, 0.03314810f, 
    -0.16731477f, 0.11066252f, 0.37059090f, 0.26827109f, -0.68706685f, 0.15585749f, 0.32451737f, 0.00949832f, 
    -0.62195075f, 0.05194673f, -0.06459882f, -0.02651089f, 0.04388862f, -0.28342855f, -0.32215026f, -0.52124143f, 
    -0.17931433f, -0.22808146f, -0.00814344f, -0.09724067f, -0.01434673f, 0.13474949f, -0.04821211f, -0.03788444f, 
    -1.19780934f, -0.10582899f, 0.18755342f, 0.30144456f, 0.17411302f, -0.34178135f, 0.03034162f, -0.11364762f, 
    0.08225472f, 0.12386020f, 0.33414525f, 0.19168800f, -0.11383107f, -0.06125609f, 0.36755124f, -0.03637197f, 
    0.20948000f, -0.02337392f, 0.44672838f, 0.12927105f, 0.25266719f, 0.24038373f, 0.10290129f, -0.22611661f, 
    0.38225588f, 0.16977093f, 0.19244047f, -0.09717832f, -0.54089791f, 0.20247002f, -0.13886687f, -0.69438243f, 
    0.00953096f, -0.00030381f, 0.04152418f, -0.00106013f, 0.38258421f, -0.89196140f, -0.02161715f, 0.34857890f, 
    -0.46871540f, -0.19415444f, -0.31033033f, 0.13942187f, 0.18164447f, -0.07692713f, -0.44180617f, -0.02223820f, 
    -0.00232518f, 0.07783966f, -0.49262953f, 0.08910304f, -0.32123837f, -0.06121990f, -0.32406473f, 0.09702392f, 
    0.29906431f, -0.11922913f, 0.10722710f, -0.03779218f, -0.55417120f, -0.32402661f, 0.04593195f, 0.12934044f, 
    0.29387593f, -0.06646836f, -0.02412433f, 0.04267303f, 0.37110615f, 0.25771239f, -0.81359762f, -0.23628367f, 
    -0.17665170f, 0.04263201f, 0.10998585f, 0.04980497f, -0.17747658f, -0.29168177f, -0.16506840f, 0.05783500f, 
    -0.44338474f, -0.15989998f, 0.18624727f, -0.51330715f, 0.20501557f, 0.35378221f, -0.56297678f, 0.13107200f, 
    -0.27190548f, -0.06001863f, 0.14907472f, 0.11683769f, -0.32535207f, -0.18742591f, 0.07826237f, 0.03453970f, 
    0.15302216f, -0.04890769f, 0.16344608f, -0.59042907f, 0.08798688f, 0.17335632f, -0.47500411f, -0.15118003f, 
    0.37136883f, 0.04870785f, -0.53412628f, 0.21064439f, 0.18805425f, 0.20199703f, 0.03342980f, -0.05304378f, 
    -0.44896382f, -0.12956826f, -0.41593754f, 0.08017498f, 0.22940283f, -0.62868494f, 0.07464512f, -0.03288468f, 
    -0.26120022f, -0.33134189f, 0.10851926f, 0.01107802f, 0.52642500f, -0.10593162f, 0.08679734f, 0.05826581f, 
    -0.32272995f, -0.20507155f, -0.30220732f, -0.47692129f, -0.12155629f, 0.09886214f, -0.24253151f, 0.13927031f, 
    0.15236691f, 0.15489560f, 0.19336893f, 0.05979142f, -0.45773154f, 0.26508668f, -0.08273131f, -0.13246959f, 
    0.33686128f, -0.04993711f, -0.58065128f, -0.09590111f, -0.43752328f, 0.04411654f, 0.28123835f, 0.08845692f, 
    -0.27160257f, 0.52875853f, -0.66166997f, -0.12677220f, -0.42551059f, 0.12407374f, -0.08028667f, -0.70000470f, 
    0.16171859f, -0.09626000f, -0.13497600f, -0.41261396f, -0.47081509f, -0.66893917f, -0.15234871f, -0.09576927f, 
    0.01958832f, -0.54358035f, -0.69386721f, -0.79535490f, 0.36744633f, 0.27587286f, -0.22997421f, -0.04340240f, 
    -0.11836531f, 0.13065799f, -0.10154741f, -0.32123092f, -0.07311644f, -0.45227161f, 0.18470661f, 0.20528528f, 
    -0.10429329f, 0.25552404f, -0.60844541f, -0.18199971f, 0.18738055f, 0.29908523f, -0.05203016f, -0.21638256f, 
    0.45719489f, 0.00953478f, 0.30128244f, 0.09557254f, -0.24527888f, 0.01889349f, -0.24035382f, 0.40620348f, 
    0.23974775f, -0.09621820f, 0.30106932f, -0.65061992f, -0.32405189f, -0.56002724f, -0.09714663f, 0.14561847f, 
    -0.30138135f, -0.07144829f, -0.33494455f, 0.13445893f, -0.31514859f, 0.28024995f, -0.33613718f, -0.04571381f, 
    0.43611833f, -0.31616715f, -0.45356435f, -0.07147335f, -0.06272433f, 0.18243311f, -0.04124925f, 0.24599224f, 
    -0.27416104f, -0.12772128f, 0.16829990f, -0.03237964f, 0.11080308f, -0.30947906f, -0.37235913f, -0.21303502f, 
    -0.42491543f, -0.19493340f, -0.12407878f, -0.48140612f, -0.32828754f, -0.73891163f, -0.46033257f, 0.03524749f, 
    0.06756208f, -0.03111253f, 0.05764941f, -0.40086362f, -0.27415106f, 0.49627510f, 0.03731526f, 0.15558520f, 
    -0.88270706f, 0.20418170f, -0.01433410f, 0.01820077f, -0.03486886f, 0.24477778f, 0.07220362f, -0.60203624f, 
    0.20768315f, -0.08339299f, -0.29588410f, -0.46592858f, -0.57470018f, -0.25650942f, -0.73449147f, 0.21976699f, 
    -0.07838103f, 0.27235454f, 0.29789162f, 0.22988807f, 0.00207530f, 0.10080484f, -0.31532425f, 0.08441938f, 
    -0.29714379f, -0.12938900f, -0.18812530f, 0.18489999f, -0.29159242f, -0.59903097f, 0.04662696f, 0.14358380f, 
    0.10264631f, -0.10098383f, -0.50828373f, 0.02769316f, -0.55305082f, -0.23480387f, 0.01115924f, -0.02252583f, 
    -0.54977655f, -0.19139081f, -0.57302356f, 0.44078079f, 0.39235163f, 0.27227423f, -0.36687514f, -0.08810740f, 
    -0.73235774f, 0.39294675f, -0.31537151f, -0.34696642f, -0.03158670f, 0.04846114f, -0.29922956f, -0.03974679f, 
    0.21889465f, -0.00193503f, -0.27842060f, 0.65433246f, 0.57923615f, 0.02269831f, 0.24527746f, -0.02176555f, 
    0.25865763f, -0.39180708f, -0.00600876f, -0.07593013f, -0.19214560f, -0.34632641f, -0.12985568f, 0.12875113f, 
    -0.36032414f, -0.04737842f, -0.11671627f, -0.47314504f, 0.01393504f, -0.08586184f, -0.81028944f, -0.01604885f, 
    0.02468582f, -0.57260591f, -0.51839018f, -0.10800779f, 0.53700179f, 0.00142967f, -0.31602100f, 0.02976212f, 
    0.01445750f, -0.15523495f, 0.45900318f, -0.34111056f, -0.24601360f, -0.44987598f, 0.31540716f, 0.20595910f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.12754023f, 0.14054832f, 0.14017387f, -0.25341162f, 0.06559744f, 0.22344002f, 0.08176819f, -0.30376217f, 
    -0.00113405f, 0.12823263f, -0.04622054f, 0.10781378f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
