#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.60733974f, 0.09747829f, -0.88069314f, 0.89144266f, 0.21619542f, 0.23811287f, -0.49184215f, 0.70489776f, 
    -0.57164001f, -0.76331383f, -1.46229017f, 0.39497739f, 1.27551520f, -0.14664057f, -0.34202310f, 0.36137879f, 
    -0.77020466f, -0.55902249f, 0.30248106f, 0.54005307f, -0.33623177f, 0.05825263f, 0.51016557f, -0.38471717f, 
    0.18392462f, -0.20985100f, -0.13554974f, 0.57486945f, -0.63251096f, -0.12931088f, -0.83172560f, -0.30774888f, 
    0.71114802f, -0.25669560f, 0.04225602f, 0.61633414f, -1.46499896f, -0.34849936f, 0.29656434f, -0.39990956f, 
    -0.46379748f, -0.93760085f, -0.19022290f, -0.07926137f, -0.49807522f, 0.61488849f, -0.24532010f, 0.23008698f, 
    0.22005163f, 0.31800276f, -0.01765606f, -0.06007846f, 0.36121947f, -0.06731714f, 0.91712159f, -0.64131159f, 
    -0.55615306f, -0.47939473f, 0.99407125f, -0.69724518f, -0.68759704f, 0.58436990f, 0.16831359f, -0.86085898f, 
    0.89938110f, 0.86264545f, -1.17462230f, -1.04546010f, -0.48825699f, -0.03468322f, 0.41321337f, -0.18383564f, 
    0.42628646f, -0.19929415f, -0.56568086f, -0.52081811f, -0.88384557f, -1.08345330f, -0.70897406f, -0.42687088f, 
    -0.49533921f, -0.86638540f, -0.21794862f, 0.45264027f, -0.63978404f, -0.66074580f, 0.36481005f, 0.36542094f, 
    0.41511714f, 0.15991966f, -0.16052063f, -0.68186092f, -0.72005230f, 0.38009703f, 0.44819024f, 0.33559620f, 
    0.37079385f, -0.02606405f, 0.24713361f, 0.62420994f, 0.59467465f, 0.15134422f, 0.09869639f, 0.06743327f, 
    -0.32133257f, -0.47734064f, -0.52779084f, -0.29616138f, -0.75341791f, 0.74169290f, -0.19334565f, 0.00485630f, 
    0.03889403f, 0.29456085f, -0.04778972f, -0.00492511f, 0.19347003f, -0.05099285f, 0.46922544f, 0.64085019f, 
    -0.09732064f, -0.69556820f, 0.48264351f, -0.41960454f, -0.53906000f, -0.17531736f, -0.48869747f, 0.77365553f, 
    -0.31324250f, -0.79948312f, -0.70675391f, 0.05099843f, 0.22004236f, 0.29059318f, 0.41646078f, 0.72001243f, 
    -0.60163081f, -0.42451870f, 0.56494606f, 0.69240254f, 0.45790401f, -0.54571396f, -0.34935430f, 0.08227337f, 
    1.20127249f, -0.91726017f, -0.83757305f, 0.01298863f, 0.12889403f, 0.25147203f, -0.10241124f, 0.21517888f, 
    0.16372620f, 0.32693207f, 0.89984739f, 0.75074768f, -0.88975441f, -0.33779714f, -0.27363244f, 0.16419122f, 
    -0.29340649f, 0.25090852f, -1.35989237f, -0.03093885f, 1.02186811f, 0.01068006f, 0.83379537f, -0.44418374f, 
    -0.43421894f, -0.20276451f, -0.45767093f, -1.21171200f, -0.65172553f, 0.54298186f, -0.33876869f, 0.26819012f, 
    0.77029526f, 0.34849128f, -0.24324621f, 0.20897828f, -1.05419052f, 0.13683748f, -0.30716038f, -0.56647843f, 
    -0.31572914f, 0.40696350f, -0.73348826f, -0.66117346f, -0.80182081f, -0.83688998f, -0.33639634f, 0.58306319f, 
    -0.39977425f, 0.11558117f, -0.47742468f, 0.54987484f, 0.39108878f, 0.11783835f, -0.40520087f, -0.55850750f, 
    0.76498520f, -0.84567416f, -0.72680908f, -0.41501483f, -0.16720906f, -0.68508852f, 0.12579858f, -0.05565120f, 
    0.12809761f, 0.20147635f, -0.27396765f, -0.38139713f, -0.35064930f, -0.41519517f, -0.46074924f, -0.64284897f, 
    0.55758238f, 0.61437136f, -0.89219415f, -0.60705817f, 0.14549373f, 0.29867539f, 0.22638559f, 0.23430692f, 
    -0.13807380f, 0.58791906f, 0.22387716f, 0.23822424f, 0.05542665f, -0.07462023f, -0.08673070f, 0.46978879f, 
    -0.17532659f, 0.22856404f, -1.02239716f, 0.10419200f, 0.86524147f, -0.18738039f, 0.10010409f, 0.10638923f, 
    0.18138541f, 0.23969983f, -0.37027010f, -1.07770371f, -1.34896779f, -0.78785032f, -0.16764012f, 0.06261554f, 
    0.21785192f, 0.12441206f, -0.32034385f, -0.07640973f, 0.25811398f, 0.32556388f, 0.46049204f, -0.60938531f, 
    0.23966329f, 0.06995159f, -0.35598835f, 0.38606626f, 0.41504878f, -0.77689910f, 0.58112681f, -0.58362740f, 
    0.41634613f, 0.01743792f, -0.66553372f, -0.12327255f, 0.23019540f, 0.58423787f, 0.99675900f, 0.84347755f, 
    -0.67324668f, -0.27866778f, -0.73341703f, -0.30831915f, 0.28655866f, 0.22524934f, 0.26706278f, -1.12239134f, 
    -0.87120312f, -0.36275315f, 0.48648873f, -1.25481081f, -0.73968196f, -0.12294830f, 0.01493337f, 0.55683500f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17320351f, 0.43222374f, 0.24166988f, 0.41110319f, -0.50902617f, -0.03531877f, 0.09757087f, 0.08820027f, 
    -0.32936481f, 0.24408941f, 0.01204339f, 0.16674200f, 0.13656658f, -0.13578498f, 0.14381842f, 0.46566620f, 
    0.24181098f, 0.39513579f, 0.05243724f, -0.07065548f, -0.19397160f, 0.04363250f, 0.38055870f, -0.06743681f, 
    0.06385583f, -0.04246439f, 0.20425257f, 0.31004959f, 0.10968889f, 0.14808857f, 0.08078816f, -0.09356157f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.51824760f, -0.47082585f, -0.67935216f, 0.08918999f, 0.06249374f, -0.00588868f, 0.03316321f, -0.03344746f, 
    -0.01521864f, 0.06766343f, -0.14293931f, 0.12318122f, -0.23878567f, -0.24582033f, 0.03819279f, -0.04340901f, 
    0.06469814f, -0.14703862f, -0.00357559f, 0.03321132f, 0.55182046f, -0.01650044f, -0.00063928f, -0.53484654f, 
    -0.15087423f, -0.17564680f, -0.01537008f, -0.00633210f, -0.03256311f, -0.03244519f, 0.07127485f, 0.06302823f, 
    -0.21638437f, -0.11238370f, 0.00759019f, -0.12183666f, 0.08870950f, 0.09056085f, -0.11483299f, -0.02578829f, 
    -0.29284084f, -0.28009278f, -0.18874697f, 0.04160769f, -0.10111845f, 0.00503916f, 0.03250939f, -0.04535890f, 
    0.05975268f, -0.00488170f, -0.03247995f, 0.02808666f, 0.00342106f, 0.05077096f, -0.07155260f, -0.16531914f, 
    -0.12711821f, -0.03054080f, -0.07292683f, -0.01383064f, 0.04355678f, 0.13070323f, 0.10424865f, -0.14946066f, 
    -0.08752773f, -0.22818337f, -0.20706186f, -0.03419899f, -0.30221897f, -0.35969353f, -0.23556785f, -0.05819895f, 
    -0.05853367f, -0.00539134f, -0.03811598f, -0.07480349f, -0.07529715f, -0.00646944f, -0.07865936f, -0.15841314f, 
    0.52466691f, 0.38470545f, 0.04170010f, -0.44380364f, -0.03142611f, 0.11519851f, 0.32838887f, 0.15759033f, 
    0.20568553f, 0.17094204f, 0.01271726f, 0.01934319f, -0.05423459f, -0.08107133f, -0.08478054f, -0.03484918f, 
    -0.08226170f, -0.13087931f, -0.04146833f, 0.18616016f, -0.06440782f, -0.06256159f, -0.04489794f, 0.02354055f, 
    0.08453797f, -0.00676719f, 0.00440676f, -0.00377501f, 0.00652975f, 0.07341822f, -0.06242741f, -0.10359392f, 
    0.08267356f, -0.06659470f, -0.12590678f, -0.06225314f, -0.04292927f, -0.10304589f, -0.04564182f, 0.01840349f, 
    -0.19437031f, 0.20610185f, -0.00524861f, 0.05121209f, -0.37994593f, 0.05921468f, -0.09109356f, 0.10898150f, 
    -0.26647928f, 0.03679534f, -0.17960092f, -0.00576824f, -0.02610203f, -0.14903688f, -0.06970172f, -0.16612598f, 
    -0.05686073f, 0.02988998f, -0.29495791f, 0.04007773f, -0.15360600f, 0.32328349f, 0.10342697f, -0.30360374f, 
    -0.13679571f, -0.14868310f, 0.11672144f, -0.11341577f, -0.00682036f, -0.07859712f, 0.03836190f, -0.00495700f, 
    -0.00695824f, 0.08115412f, 0.01789401f, -0.03450356f, 0.11915221f, 0.13803907f, -0.00754556f, -0.04846939f, 
    0.12607673f, 0.26231462f, 0.14566091f, -0.31261089f, -0.13178444f, 0.05643667f, 0.01546580f, 0.08413822f, 
    -0.03238174f, 0.11904963f, 0.01439713f, -0.04406945f, -0.04304617f, -0.01248175f, -0.00645758f, 0.02622138f, 
    -0.04890900f, 0.07657081f, 0.12536348f, 0.25038061f, 0.21557125f, 0.26600003f, 0.31794387f, -0.23386294f, 
    -0.05226443f, -0.24298541f, -0.03894208f, -0.06897285f, 0.04980286f, -0.15157382f, 0.12417176f, -0.04490082f, 
    -0.02824370f, -0.00519028f, 0.03063801f, 0.01206691f, -0.01659867f, 0.00157065f, -0.06840797f, -0.03533029f, 
    0.19517873f, 0.15951045f, -0.18328843f, 0.07054693f, 0.10502556f, 0.11929392f, 0.06460641f, 0.09924074f, 
    0.06784789f, 0.07856063f, -0.06859658f, -0.04030576f, -0.15658078f, 0.01958989f, 0.07237799f, 0.05513179f, 
    0.05764701f, -0.02924363f, 0.01395166f, 0.05386039f, -0.34153306f, 0.14027153f, -0.22429337f, 0.11744891f, 
    -0.03177063f, 0.03787155f, -0.07460087f, -0.03979491f, 0.07026714f, 0.00636185f, -0.00782062f, -0.05813400f, 
    0.03901069f, 0.06032698f, 0.03994393f, 0.16756721f, 0.09974659f, 0.02315416f, -0.01876028f, -0.01913667f, 
    -0.07953964f, -0.05187576f, 0.07119307f, 0.01256954f, 0.06331025f, -0.01833041f, -0.03292020f, 0.04276752f, 
    0.00063206f, 0.05105300f, -0.14199936f, 0.02599077f, -0.07991037f, -0.08843943f, -0.01948440f, -0.03606948f, 
    -0.04540071f, 0.00330760f, -0.10585940f, -0.05705487f, -0.80950171f, 0.42850682f, 0.51294655f, 0.05592520f, 
    0.39520311f, 0.09845043f, -0.09756978f, -0.06272906f, 0.04767102f, 0.07643437f, 0.09824616f, 0.03606038f, 
    -0.01814552f, 0.07078896f, 0.06320368f, 0.03295736f, 0.04218077f, -0.16761847f, -0.03902842f, -0.12248077f, 
    0.24357532f, 0.24179778f, 0.09741432f, -0.14193365f, -0.12768358f, -0.19082357f, -0.09095242f, -0.10338813f, 
    -0.06750379f, -0.02446078f, 0.07098576f, 0.07690936f, -0.02015346f, 0.05099592f, 0.00975346f, -0.00177140f, 
    -0.04158331f, 0.00342544f, -0.16090454f, 0.03103452f, -0.03093222f, -0.25014472f, -0.38984716f, 0.05253157f, 
    -0.08762664f, 0.04554624f, -0.00165901f, 0.04909179f, 0.02566868f, 0.05864707f, 0.11882138f, -0.03506347f, 
    -0.04902936f, 0.02385281f, -0.13349262f, -0.04743299f, 0.11732008f, 0.02273231f, 0.02064925f, 0.02831383f, 
    0.06748049f, 0.03331543f, -0.23562923f, 0.09021758f, 0.01803168f, 0.01799732f, -0.02167606f, -0.00342382f, 
    0.05553200f, -0.12535338f, -0.12863380f, -0.01994763f, -0.10019112f, 0.00954766f, -0.09946359f, -0.01500527f, 
    0.05105532f, 0.00133916f, 0.00290294f, 0.02696005f, -0.39998841f, -0.28857109f, 0.07762262f, -0.21891208f, 
    -0.18432206f, -0.00383523f, -0.11610686f, -0.11344685f, -0.03757928f, -0.03208375f, 0.06463404f, 0.03026287f, 
    0.02017751f, 0.06533533f, 0.06316368f, 0.01091299f, 0.12192641f, -0.06740624f, -0.10294177f, -0.11525350f, 
    0.28850219f, 0.12411618f, -0.11544731f, -0.41110328f, -0.02602239f, -0.09252833f, -0.18039478f, 0.11171976f, 
    0.18197656f, 0.07112369f, -0.08067721f, 0.02925505f, -0.03733508f, -0.00383752f, -0.17566730f, 0.03184041f, 
    -0.08247642f, -0.06509767f, 0.05917065f, 0.10597997f, 0.05155482f, 0.11347797f, 0.20484972f, -0.05997437f, 
    0.15275256f, 0.03579886f, 0.06159091f, 0.23137808f, 0.16183063f, -0.10643318f, -0.11710599f, -0.06155578f, 
    -0.06406963f, 0.07396992f, 0.07885219f, 0.00667828f, 0.02139236f, 0.06050869f, 0.01372343f, 0.00442672f, 
    0.13898487f, 0.24558099f, 0.33525166f, -0.14199646f, -0.07130325f, -0.10452469f, 0.15667479f, 0.08534016f, 
    -0.11237169f, -0.02082517f, -0.01849686f, 0.00310727f, 0.05956871f, -0.17784111f, -0.26633984f, 0.08875318f, 
    -0.08985455f, -0.01321614f, -0.21158490f, 0.05969432f, 0.23271470f, 0.27080315f, 0.16631743f, -0.21719426f, 
    -0.02861328f, -0.12180842f, 0.09760603f, 0.10000668f, -0.02846226f, -0.04988934f, 0.00704615f, -0.09913531f, 
    -0.15370198f, -0.02627234f, -0.01397214f, 0.02111910f, -0.04044745f, -0.07963017f, -0.01127127f, 0.04223389f, 
    0.21305287f, 0.24067235f, 0.11341891f, -0.44488826f, -0.01943490f, -0.03229326f, 0.04057530f, -0.06507377f, 
    -0.08141042f, -0.09843553f, -0.00070875f, -0.08297350f, 0.02536110f, -0.06633922f, -0.09427807f, -0.10062418f, 
    -0.12059166f, 0.04018711f, 0.05200356f, -0.16293021f, 0.01991951f, 0.18537381f, 0.18834326f, -0.27722409f, 
    -0.00562795f, -0.15706407f, -0.16762333f, -0.19913441f, -0.05117063f, -0.02531660f, 0.01112300f, -0.10798758f, 
    -0.01772773f, 0.04605385f, 0.03003314f, 0.05014776f, -0.09130386f, 0.04118243f, -0.02211414f, 0.04027532f, 
    -0.09285277f, -0.04224088f, -0.12550563f, 0.05073401f, -0.10983604f, -0.05647806f, -0.07255103f, -0.05890200f, 
    0.09762203f, 0.03625017f, -0.14512655f, -0.02533453f, -0.13562220f, -0.02343863f, -0.02091238f, -0.15934789f, 
    -0.17704912f, -0.00685713f, -0.06195621f, -0.06421319f, -0.04043791f, -0.02524542f, -0.01242835f, 0.04321253f, 
    0.02936630f, 0.03681555f, -0.02869571f, 0.05262131f, 0.04309158f, 0.03238811f, 0.01190461f, 0.04547894f, 
    0.00188019f, 0.00830914f, 0.02734766f, -0.14242853f, -0.09740724f, -0.20112713f, -0.06868191f, -0.03943432f, 
    -0.29720393f, -0.16454843f, 0.24496984f, -0.09207812f, 0.04091360f, -0.12030834f, 0.06589869f, 0.02075344f, 
    0.02865772f, -0.05103102f, -0.09239376f, -0.03144696f, -0.24594584f, -0.07230885f, -0.05081514f, 0.03570180f, 
    -0.09602965f, -0.06186265f, -0.09290341f, 0.04665646f, 0.41200566f, 0.21134681f, -0.02314939f, -0.32754180f, 
    -0.16227570f, 0.20816469f, 0.14046550f, 0.23995818f, -0.02018810f, -0.07167643f, -0.06185441f, -0.02140603f, 
    -0.04733111f, 0.05460860f, 0.02818776f, 0.02251828f, -0.00832052f, -0.08389872f, 0.00911093f, 0.00211124f, 
    -0.06059379f, -0.06204136f, 0.07273417f, 0.04661616f, -0.02775611f, 0.00005721f, -0.03921461f, 0.03374154f, 
    0.01774828f, 0.02051394f, 0.05362920f, 0.04179894f, 0.02389768f, -0.02255799f, 0.04676071f, -0.07892361f, 
    -0.00494982f, -0.08934782f, -0.08797834f, -0.01769382f, 0.24655086f, 0.11960296f, -0.29800448f, -0.02550782f, 
    -0.04915435f, 0.01896767f, 0.08258837f, 0.00533423f, -0.06280761f, -0.09694597f, -0.05411441f, -0.20785096f, 
    -0.01664506f, 0.04569831f, 0.02148337f, -0.05679378f, -0.05433415f, -0.10627779f, -0.03956491f, -0.02473414f, 
    0.08963303f, 0.01007256f, -0.34889790f, 0.03413219f, -0.14822139f, -0.03500202f, -0.17027435f, -0.20675792f, 
    -0.02807531f, -0.05285057f, 0.02649823f, 0.08961666f, 0.01548011f, 0.06148387f, -0.00573991f, -0.06698461f, 
    0.03371993f, 0.05868041f, -0.06822893f, -0.26327455f, 0.45025784f, 0.41069260f, -0.05320443f, -0.40614969f, 
    -0.02399563f, 0.03961068f, 0.14234968f, 0.04404115f, -0.12918979f, 0.09291217f, 0.01890724f, -0.05455077f, 
    0.03350255f, -0.00181069f, 0.05980146f, 0.01349454f, -0.06605615f, -0.00791598f, -0.00641617f, 0.01199839f, 
    0.80564326f, 0.07444379f, -0.16499563f, 0.01421785f, -0.11773922f, -0.09067994f, -0.04583893f, 0.03722946f, 
    0.03386929f, -0.06936871f, 0.00595076f, 0.11243752f, -0.17330445f, -0.10800245f, -0.05835940f, -0.09770501f, 
    -0.12183775f, -0.05312718f, 0.13333382f, -0.00018300f, 0.35812199f, 0.00761307f, -0.28908649f, -0.30386561f, 
    -0.07713638f, -0.02130830f, -0.10560534f, 0.04982696f, 0.23923153f, -0.01304167f, 0.13278957f, -0.07509080f, 
    0.06862417f, -0.10327742f, -0.20993103f, 0.17675708f, -0.10459537f, -0.09086510f, 0.02107734f, -0.13013448f, 
    0.11760337f, -0.02423025f, 0.03895935f, 0.11340626f, -0.00545635f, -0.11135367f, 0.00564982f, -0.00348347f, 
    0.03033154f, -0.02706783f, 0.02407907f, 0.02757757f, 0.05142444f, -0.08062138f, 0.05303278f, 0.17733371f, 
    0.01389917f, 0.03782075f, 0.09924686f, -0.01653888f, -0.14627163f, -0.01728799f, 0.04028821f, -0.00068794f, 
    0.01718172f, -0.01030297f, 0.28103110f, 0.10025847f, -0.29290426f, 0.13506664f, 0.03927514f, -0.00009655f, 
    -0.00013449f, 0.12656175f, 0.01340561f, 0.00514275f, 0.02757591f, -0.00701746f, 0.07457016f, 0.04856950f, 
    -0.11103264f, 0.21336094f, 0.08726380f, 0.53507179f, 0.36929387f, 0.02483884f, -0.14566320f, -0.41474137f, 
    0.04775497f, -0.01999078f, 0.06669854f, 0.00053193f, 0.01367917f, -0.00135289f, 0.05388344f, -0.08517739f, 
    0.00954891f, 0.05009198f, -0.30762023f, -0.08414438f, 0.22015846f, 0.02725816f, 0.08205569f, 0.13501121f, 
    0.13263071f, -0.01897800f, -0.02803710f, -0.05613955f, -0.01240093f, 0.00973404f, -0.11410452f, 0.13062347f, 
    0.04111118f, -0.00544383f, 0.04268886f, -0.12140642f, -0.12490645f, -0.05627241f, -0.06019641f, -0.07824071f, 
    0.77728385f, -0.00015539f, -0.61908120f, -0.14052050f, -0.31910598f, -0.16845997f, 0.10559899f, -0.20885538f, 
    -0.00094094f, 0.14499143f, 0.04653061f, 0.02243070f, 0.03257926f, 0.07865416f, 0.08182510f, -0.09616568f, 
    0.00522280f, -0.18073463f, 0.11808841f, 0.21981272f, -0.28588751f, -0.31047288f, -0.25299847f, -0.26244676f, 
    -0.35662049f, 0.03869388f, -0.39371830f, -0.26326686f, 0.26028779f, -0.03223994f, -0.09026594f, -0.08137655f, 
    0.05140449f, 0.02143706f, -0.00054925f, -0.04419667f, 0.09053253f, -0.02991920f, -0.06256722f, -0.06042093f, 
    0.00839033f, 0.16889673f, -0.30731639f, 0.00065701f, -0.52696735f, 0.15520370f, 0.07238099f, -0.19253500f, 
    -0.12298380f, 0.06150009f, -0.00591386f, 0.06068286f, 0.10978740f, 0.06517507f, 0.02635734f, -0.15752438f, 
    -0.06842729f, -0.16405463f, -0.34044486f, -0.06069110f, -0.58663976f, 0.01534875f, -0.04536000f, -0.04675751f, 
    0.09557217f, 0.00909850f, 0.16513489f, 0.06748133f, 0.26790044f, 0.10617281f, -0.03084041f, 0.06982659f, 
    -0.00855313f, 0.05239828f, -0.03843438f, 0.00487182f, -0.03536274f, -0.04260731f, 0.00299889f, 0.09922898f, 
    0.10950624f, -0.18566439f, -0.19004761f, -0.02699434f, -0.18630244f, -0.05531589f, 0.06709333f, 0.07853386f, 
    -0.04624253f, -0.17084049f, 0.04198848f, 0.01508992f, 0.07481184f, 0.00854778f, -0.05296569f, -0.01429500f, 
    -0.03542183f, -0.08197730f, -0.01878581f, 0.01793132f, 0.56919277f, 0.09860226f, 0.12423527f, 0.11298725f, 
    0.07686901f, -0.00248562f, -0.07409950f, -0.04295697f, -0.05082527f, 0.00610502f, -0.01768794f, 0.02926017f, 
    -0.00959158f, 0.01669263f, 0.04282990f, 0.02712006f, -0.24160385f, -0.12314299f, -0.02107419f, 0.12742683f, 
    -0.08839343f, -0.11242767f, 0.06828687f, -0.03075976f, 0.03440891f, -0.00957076f, 0.01903437f, 0.01236156f, 
    -0.02053747f, 0.00240084f, -0.03011085f, 0.06361368f, -0.01880850f, 0.07919711f, -0.00114036f, -0.04097347f, 
    -0.05801669f, -0.12397163f, 0.02894725f, -0.01105278f, 0.20631963f, 0.03714994f, -0.07295965f, -0.00758651f, 
    0.14518927f, -0.07863820f, -0.03320726f, -0.03432437f, -0.05470723f, -0.04226082f, 0.02424111f, 0.00164876f, 
    -0.01296690f, -0.05931661f, 0.02247507f, -0.00316267f, 0.05905338f, 0.08671782f, 0.04605430f, -0.14116205f, 
    -0.20264100f, -0.24146008f, 0.18095355f, -0.00045197f, -0.05598214f, 0.13900696f, 0.04544496f, -0.43033504f, 
    -0.18501140f, 0.13610086f, -0.18349336f, 0.07676177f, 0.03223565f, 0.16779052f, 0.07951496f, -0.02273533f, 
    -0.04212515f, -0.05888294f, 0.04207560f, 0.20154610f, 0.79336691f, -0.08382179f, 0.31825715f, 0.27280629f, 
    0.01951160f, 0.01524395f, -0.01399430f, 0.03593478f, -0.00409640f, -0.02913376f, 0.11423624f, -0.18793878f, 
    -0.04257445f, -0.10131457f, -0.06198599f, 0.13319550f, 0.03314356f, -0.11911329f, -0.05380828f, 0.01428554f, 
    0.58299947f, 0.00141946f, -0.15618309f, -0.05686378f, -0.15893842f, -0.02099911f, 0.10318607f, 0.05133919f, 
    -0.18437575f, 0.09772396f, 0.20095848f, -0.01405296f, 0.04998914f, -0.10136443f, 0.00267385f, -0.04981494f, 
    0.02254371f, 0.03059146f, -0.01180728f, 0.06902464f, 0.43881273f, 0.02176832f, -0.00628016f, -0.18266855f, 
    -0.00819284f, -0.07307991f, -0.06075044f, -0.09859028f, -0.05015929f, -0.00882304f, -0.04003739f, -0.00901266f, 
    0.01075298f, 0.05105107f, 0.00848088f, 0.11276780f, 0.17571367f, -0.12699953f, 0.11574209f, 0.04001503f, 
    0.11954337f, -0.56136566f, 0.14410450f, -0.34804246f, 0.36814764f, -0.02588984f, 0.03006270f, -0.00302836f, 
    -0.07677558f, -0.04034043f, 0.20812789f, 0.03217372f, 0.10472906f, -0.05450141f, 0.13747302f, 0.03007780f, 
    -0.10344724f, -0.09608690f, -0.13022704f, -0.34393153f, -0.45295814f, -0.32248652f, -0.15479262f, -0.03608075f, 
    -0.00585541f, -0.05365443f, 0.00290925f, 0.17112026f, -0.04203241f, -0.07121590f, -0.14551421f, -0.08914485f, 
    -0.14374511f, -0.14202207f, -0.19456787f, -0.02336714f, -0.02060716f, -0.02194977f, -0.04313411f, -0.02054180f, 
    -0.26624146f, 0.18919055f, 0.23071827f, -0.05330015f, -0.04238068f, 0.23086226f, -0.04346694f, 0.03823203f, 
    -0.06772348f, -0.00049438f, 0.02990336f, 0.04092417f, -0.02256393f, -0.12616912f, 0.15864114f, -0.12238184f, 
    -0.30853480f, 0.16944894f, -0.01441045f, -0.00237041f, -0.28989407f, -0.00322432f, -0.11237925f, -0.07088120f, 
    0.13106079f, -0.12913825f, 0.18756108f, 0.10935534f, 0.21580671f, 0.06524826f, -0.11614953f, 0.10601900f, 
    0.01723143f, 0.06047597f, 0.02532646f, -0.04900077f, -0.01145563f, 0.01409252f, 0.02796451f, -0.08398332f, 
    -0.30454201f, 0.17006989f, -0.30512342f, -0.05189522f, 0.10310689f, 0.01513509f, -0.18979000f, 0.05371408f, 
    -0.00097869f, 0.00117171f, 0.05641882f, 0.09862377f, 0.05282623f, -0.02654758f, 0.01849565f, -0.04431843f, 
    0.04656826f, 0.05916916f, -0.40862483f, -0.13609488f, -0.13423130f, -0.03063406f, -0.30377090f, -0.32435557f, 
    -0.12564135f, 0.12361642f, -0.07567621f, 0.00558598f, 0.05387800f, -0.04172620f, -0.00571614f, -0.00342288f, 
    -0.01062260f, -0.00232694f, 0.02991148f, -0.16767238f, -0.35321975f, -0.20656626f, -0.05599239f, -0.16622837f, 
    -0.16709426f, -0.08454253f, 0.24096917f, -0.00777882f, -0.17036901f, 0.01760774f, 0.09333271f, -0.06127561f, 
    0.07710213f, -0.02646099f, 0.04664568f, -0.00924213f, -0.06013336f, 0.26595342f, -0.03817181f, -0.05657373f, 
    -0.07456110f, 0.08939144f, 0.03379039f, -0.04550584f, 0.08301687f, 0.07144742f, 0.03669150f, 0.07115342f, 
    0.10130360f, -0.02651116f, -0.08325602f, -0.09169701f, 0.01167260f, -0.01041537f, -0.01091279f, -0.01382472f, 
    0.08003739f, 0.00162046f, -0.03660551f, 0.00050808f, 0.02548795f, -0.09308761f, 0.10570996f, -0.06672664f, 
    -0.12229545f, -0.24393067f, 0.03952581f, 0.03871845f, 0.12997751f, -0.06572987f, -0.04623768f, 0.05553946f, 
    0.11790922f, 0.01284043f, 0.09028593f, 0.08713771f, 0.11287745f, 0.05769419f, -0.10453764f, -0.03023057f, 
    0.07447297f, 0.09597915f, 0.17625342f, -0.13008310f, -0.02221472f, 0.21974708f, 0.21131642f, 0.04951757f, 
    -0.09588975f, 0.03535666f, 0.02028981f, 0.19654886f, -0.11584030f, -0.12012516f, 0.01772736f, -0.01885618f, 
    0.04538681f, -0.05453962f, -0.02871959f, 0.06449113f, 0.06138410f, -0.01041330f, -0.02151640f, 0.06577084f, 
    0.18751401f, 0.00459555f, 0.06739223f, -0.06175926f, 0.05276927f, 0.05032640f, -0.09225843f, -0.04727848f, 
    -0.06999803f, 0.03156249f, 0.00448684f, 0.01085066f, 0.04160821f, 0.00984029f, 0.02593056f, 0.04621097f, 
    0.19497420f, -0.07795362f, 0.05597334f, 0.05465792f, -0.21560267f, -0.07327462f, 0.02195964f, 0.15792058f, 
    -0.01301583f, 0.26878843f, 0.10907789f, 0.02946424f, 0.02137267f, -0.01428318f, -0.19625235f, 0.01071239f, 
    0.01105701f, 0.03793870f, -0.06976344f, -0.03623265f, 0.08868343f, -0.07529943f, 0.07690425f, 0.04359826f, 
    -0.19813465f, -0.01472193f, 0.07740991f, -0.00021123f, -0.12842773f, 0.13720852f, -0.16161528f, -0.01910597f, 
    0.01466318f, -0.10300515f, 0.01280826f, -0.07643089f, -0.01238646f, 0.17590515f, -0.01897346f, -0.02475585f, 
    -0.01475217f, -0.09817925f, 0.02598538f, 0.01539103f, -0.10906403f, 0.26894885f, 0.00180409f, 0.43600050f, 
    0.03435619f, -0.13417295f, 0.14385721f, 0.04468244f, 0.02803321f, -0.19391465f, -0.08909918f, -0.04242544f, 
    0.05960470f, -0.04617102f, -0.01136517f, -0.03836139f, 0.11545986f, 0.04389003f, -0.26175991f, 0.08933043f, 
    -0.13609143f, -0.10232599f, 0.19466104f, -0.16020843f, -0.06648225f, -0.01101153f, -0.22104429f, -0.00543930f, 
    -0.02528433f, 0.05605914f, 0.01013572f, -0.01552091f, -0.19211596f, 0.16782624f, 0.24979001f, 0.12200887f, 
    -0.03143618f, 0.00559699f, 0.27155355f, -0.12987311f, -0.24380837f, 0.17260808f, 0.75956577f, 0.34247369f, 
    0.15658894f, -0.02982559f, -0.18944244f, -0.25304329f, 0.27702218f, -0.25345606f, -0.00166238f, 0.13112216f, 
    0.04442519f, -0.16157968f, -0.07815658f, -0.00427670f, -0.01465641f, 0.00324740f, -0.03887587f, -0.04090451f, 
    0.01286448f, -0.13496007f, 0.08273267f, -0.29858556f, 0.15240154f, 0.02674719f, -0.05708672f, -0.06953351f, 
    0.00183823f, 0.08933035f, 0.00515643f, 0.01876429f, -0.00565681f, -0.01857411f, 0.00769157f, 0.09560607f, 
    -0.05944610f, -0.24801412f, 0.15976156f, 0.03033707f, -0.18036149f, 0.24256837f, -0.12902297f, 0.13376564f, 
    0.19152993f, -0.27722195f, 0.19736427f, 0.06252778f, -0.20958465f, 0.02479936f, 0.15121016f, 0.16945034f, 
    0.02339569f, 0.03002996f, -0.02427485f, 0.05582028f, 0.07991678f, 0.01170646f, -0.05765024f, -0.03633208f, 
    -0.08223338f, -1.12003767f, -0.64015871f, 0.04595429f, -0.79092449f, -0.09379289f, 0.22125915f, -0.29953170f, 
    0.28301764f, -0.04422987f, -0.05989854f, -0.06934603f, -0.05084316f, -0.00463399f, -0.06964068f, 0.02188041f, 
    0.00891073f, -0.00222208f, -0.13835850f, 0.11455844f, -0.17924446f, -0.04851821f, -0.08073496f, -0.10074046f, 
    0.04773054f, -0.00567707f, -0.07509721f, 0.01999343f, 0.05741585f, 0.03027161f, -0.00364292f, -0.03715883f, 
    -0.03982611f, 0.03134793f, 0.04962903f, 0.06426460f, -0.03420569f, 0.09066147f, 0.09310354f, 0.01071858f, 
    -0.30080464f, 0.01117050f, -0.33208910f, -0.34083775f, -0.28791654f, -0.14609352f, 0.05843396f, -0.03001741f, 
    -0.17383318f, 0.00694908f, 0.00484630f, -0.12877966f, 0.02553230f, 0.03543210f, 0.09757232f, 0.06455693f, 
    0.03134379f, -0.18976440f, 0.33632767f, -0.03587352f, -0.18621269f, -0.69699878f, -0.12589625f, -0.36919954f, 
    -0.12588440f, 0.10123410f, -0.11238310f, -0.32574886f, -0.09570255f, 0.00117708f, 0.04992555f, -0.04895508f, 
    0.01330817f, -0.03178877f, -0.03871364f, 0.06875657f, -0.03126737f, 0.04608444f, 0.12444656f, -0.04716422f, 
    -0.94377601f, -0.71121764f, -0.17197782f, -0.19304346f, -0.69709766f, 0.04510175f, -0.05391782f, -0.14726961f, 
    0.00511061f, -0.18490906f, -0.02914063f, -0.01169589f, -0.05897902f, -0.05406965f, -0.00530175f, -0.12416228f, 
    -0.02762738f, -0.03042355f, 0.06065003f, 0.08550651f, 0.17038138f, 0.16603737f, -0.36541116f, 0.14565800f, 
    0.09144477f, -0.00012243f, 0.05050026f, -0.03752322f, -0.01883768f, 0.03702913f, -0.03654253f, 0.03060075f, 
    -0.06043966f, 0.05229665f, -0.08379675f, 0.01814657f, -0.05739530f, 0.05602328f, -0.19670962f, 0.06564738f, 
    -0.01563913f, 0.05932888f, 0.41501787f, 0.12139605f, 0.23466438f, -0.03118568f, -0.04731830f, 0.05811399f, 
    0.09660456f, -0.60015023f, -0.08287394f, -0.11448233f, 0.04219616f, -0.05219724f, 0.07365678f, 0.00491804f, 
    -0.08142290f, 0.01321018f, -0.01172114f, -0.10051730f, -0.29421777f, -0.14314601f, 0.21919946f, -0.46524745f, 
    0.01897447f, 0.05385781f, -0.02590607f, 0.00665320f, 0.05598754f, -0.00322451f, 0.00519796f, 0.01461077f, 
    0.02203869f, -0.03741375f, 0.05348012f, 0.13682672f, 0.07042915f, 0.08609185f, -0.06945973f, -0.08546394f, 
    0.12460162f, -0.03413447f, -0.04537609f, 0.10324745f, 0.07262460f, 0.02032818f, -0.02578086f, 0.06675602f, 
    -0.01188458f, 0.00221611f, -0.27914950f, -0.06371669f, 0.03189040f, 0.01798785f, 0.02762460f, 0.01282308f, 
    -0.05104206f, -0.05448124f, 0.03154712f, -0.05788403f, -0.05200368f, -0.00194078f, -0.10598639f, -0.23806095f, 
    -0.07533973f, 0.00960168f, 0.01001979f, -0.02849822f, 0.04262758f, 0.04133998f, -0.00594083f, -0.02230361f, 
    -0.03619916f, 0.00148148f, -0.04199620f, -0.17726487f, -0.01103665f, 0.26150015f, -0.01643885f, -0.04928411f, 
    -0.02008231f, -0.14795876f, -0.19867031f, 0.08243360f, 0.03405390f, 0.24068560f, 0.11874435f, 0.09442782f, 
    -0.12825663f, -0.19936456f, -0.06226083f, -0.05656912f, -0.06017293f, 0.03266430f, -0.03767917f, 0.02850484f, 
    -0.05377188f, -0.02645414f, -0.16519530f, -0.02154596f, -0.27353904f, 0.05774685f, 0.17256004f, 0.02060209f, 
    0.07895833f, 0.03632076f, -0.03777937f, -0.00375006f, -0.05308976f, 0.05812279f, 0.05320189f, 0.09384261f, 
    0.00857635f, -0.14093830f, 0.08694376f, -0.02393658f, 0.10677048f, 0.21788099f, 0.15647589f, -0.13846971f, 
    -0.16599382f, 0.33805633f, 0.20670909f, 0.09879734f, 0.13405846f, -0.04967220f, 0.06111288f, -0.05932224f, 
    -0.15956780f, -0.18167306f, 0.05905681f, 0.05748992f, 0.05758645f, 0.01969691f, 0.06130363f, -0.02739510f, 
    -0.12306348f, -0.00613968f, 0.07718365f, -0.07987816f, -0.41004384f, -0.23041141f, 0.35060027f, -0.27356243f, 
    -0.05984139f, -0.00586299f, 0.05066262f, 0.08814201f, -0.02016361f, 0.10971070f, 0.05761209f, -0.00623309f, 
    0.03376200f, 0.03741119f, 0.00438909f, 0.03032973f, -0.12910342f, -0.07895837f, -0.06902838f, -0.01335238f, 
    0.40950298f, 0.15882510f, -0.01141211f, 0.23016277f, 0.33917183f, 0.08420750f, 0.04682508f, -0.12251475f, 
    0.04100805f, -0.06270944f, -0.04919852f, -0.01764723f, -0.07644667f, -0.09569068f, 0.10167205f, 0.06976385f, 
    0.10756395f, 0.11415195f, -0.04410732f, 0.04957237f, 0.35814807f, 0.09895214f, 0.02752362f, 0.06166690f, 
    0.28504747f, -0.08691530f, 0.12872730f, -0.01022228f, -0.01881627f, 0.00073522f, 0.05474381f, -0.02523614f, 
    0.13897525f, 0.02404418f, -0.00799998f, -0.00051218f, -0.03799704f, 0.05700068f, -0.02878869f, 0.00298049f, 
    -0.19385023f, -0.35137498f, -0.20066403f, 0.37209117f, 0.05904734f, -0.03700209f, 0.12813142f, 0.09543578f, 
    -0.04653707f, 0.10133942f, -0.03056722f, -0.05083344f, 0.02854112f, 0.09380259f, -0.00357126f, 0.06310381f, 
    0.16190319f, -0.05607037f, 0.02459074f, 0.14377606f, 0.29843214f, 0.00161786f, -0.08249989f, 0.09146196f, 
    0.07773562f, -0.06220203f, -0.08839259f, -0.22075969f, -0.04873106f, 0.16050819f, 0.05313998f, -0.03365731f, 
    0.04689666f, 0.01731092f, -0.08266345f, 0.06509724f, 0.02970961f, -0.03783682f, -0.03078417f, -0.06123763f, 
    0.02814147f, 0.05270288f, -0.36992803f, 0.07221288f, -0.06451871f, 0.04510212f, -0.05333936f, -0.00805805f, 
    0.03303450f, 0.10468484f, -0.02037561f, -0.02002504f, -0.00911309f, -0.04825925f, -0.03741036f, -0.01164715f, 
    0.06044021f, 0.11730325f, -0.13465674f, 0.04035850f, 0.02343890f, 0.09540793f, 0.11293771f, 0.04404614f, 
    -0.14652802f, 0.04308343f, 0.04440146f, 0.07065471f, 0.00129585f, 0.05265000f, -0.03764855f, 0.00106006f, 
    0.01426686f, -0.02713875f, -0.05417682f, -0.02381845f, 0.06804899f, 0.17798568f, 0.02252595f, 0.01917586f, 
    -0.08440810f, 0.00494128f, 0.07318432f, -0.02495389f, 0.10127115f, -0.04325388f, 0.00836544f, -0.17143096f, 
    -0.06349514f, -0.01875411f, 0.12335344f, -0.04804980f, -0.12444935f, 0.13817157f, 0.08690295f, 0.04100899f, 
    -0.02933151f, 0.06902699f, 0.11051779f, -0.04093482f, -0.19485180f, -0.03945678f, 0.12867892f, -0.13937178f, 
    -0.01186344f, -0.04625909f, -0.06486153f, -0.05802528f, -0.00610107f, 0.02916337f, 0.00622870f, -0.01417302f, 
    0.02766617f, 0.04101545f, -0.07336429f, -0.09081694f, -0.18077284f, -0.09150600f, 0.01786670f, 0.02520063f, 
    0.47824973f, 0.02057272f, -0.17587988f, -0.00917048f, 0.24991821f, -0.06331142f, 0.03880479f, -0.03500696f, 
    0.00007390f, 0.07685047f, -0.14979176f, -0.01703577f, -0.01114388f, 0.10694892f, -0.19043435f, 0.01606344f, 
    0.08779064f, 0.03059351f, -0.01180139f, 0.04194866f, -0.19204170f, 0.33761349f, 0.63775188f, 0.43887168f, 
    0.61129028f, -0.08380392f, -0.09698060f, 0.02992881f, 0.28269005f, 0.03918605f, 0.03111420f, 0.02880960f, 
    0.05971681f, -0.01287688f, 0.05217409f, 0.01792878f, -0.02743155f, -0.00583864f, -0.12362793f, 0.01333166f, 
    -0.13698125f, -0.04067245f, 0.01512244f, -0.16630208f, 0.13114823f, -0.06802082f, -0.00788119f, -0.04709766f, 
    0.02164953f, 0.11726136f, -0.00752502f, -0.03091208f, -0.02114853f, 0.01067205f, -0.05488227f, 0.02206329f, 
    -0.14784327f, -0.02468830f, 0.01063682f, -0.03225137f, 0.35504970f, -0.24804473f, 0.06467042f, 0.23738305f, 
    0.12797703f, 0.20186672f, -0.31615433f, -0.18896982f, 0.05718612f, -0.23600692f, 0.14038400f, 0.17540900f, 
    0.04504027f, 0.01510597f, 0.01801603f, 0.00176738f, 0.00100480f, -0.09561188f, 0.15198743f, -0.08273898f, 
    -0.40179601f, 0.02555062f, 0.33813787f, -0.11313248f, -0.00083637f, -0.24573450f, -0.07428896f, -0.62505811f, 
    -0.41382957f, 0.06692977f, 0.02443540f, -0.01533148f, 0.00658708f, 0.11180004f, -0.08400974f, 0.10308687f, 
    -0.01458416f, -0.19848460f, -0.15887325f, 0.04963733f, -0.22928509f, -0.86339563f, -0.21876809f, 0.54664761f, 
    -0.58598566f, 0.10899772f, -0.06766246f, -0.05216031f, 0.07087363f, -0.08615398f, -0.01066771f, 0.03997665f, 
    0.03397353f, 0.01734611f, -0.04502888f, -0.06427727f, -0.02442636f, 0.04430209f, 0.08124353f, -0.04485702f, 
    0.57905167f, 0.01664729f, -0.05032872f, 0.12904182f, -0.33565125f, 0.24709548f, 0.12222747f, -0.03309620f, 
    0.01166527f, -0.26394069f, -0.02737500f, -0.13593742f, 0.18739656f, 0.03289239f, -0.25987726f, -0.10701960f, 
    -0.03912334f, 0.12027849f, -0.03097686f, -0.04843983f, -0.83975071f, 0.53066361f, 0.01447862f, -0.21141227f, 
    0.32958984f, 0.07669348f, 0.05997151f, -0.02357025f, -0.06705493f, -0.00094489f, -0.35026824f, 0.02555559f, 
    -0.02611663f, 0.00566674f, 0.11358160f, -0.07087634f, 0.04090994f, 0.04452698f, 0.01689491f, -0.08089995f, 
    -0.92738390f, 0.01278981f, -0.38475421f, 0.13084713f, -0.17058922f, -0.03044060f, -0.13066170f, -0.16206257f, 
    0.08807040f, -0.03091132f, -0.06877742f, -0.18478297f, 0.12322584f, -0.12469514f, 0.05176299f, -0.08127897f, 
    0.04385510f, -0.02485247f, 0.16063696f, -0.06217141f, -0.20952964f, -0.04484484f, -0.22221062f, 0.15739128f, 
    0.04903002f, 0.08508789f, -0.16721900f, -0.07531582f, 0.05829342f, -0.14024460f, -0.01436424f, -0.01187806f, 
    0.00667923f, -0.14826471f, 0.02004841f, 0.01826265f, -0.10587586f, -0.06845242f, 0.00771152f, -0.19537403f, 
    0.07955645f, 0.24281543f, -0.06879212f, -0.11695597f, 0.42831764f, 0.11968789f, 0.16289932f, -0.09330910f, 
    -0.06577963f, 0.07988706f, -0.23668109f, 0.09500656f, -0.14350498f, 0.02655762f, -0.09591705f, -0.06917141f, 
    -0.03119597f, 0.11792216f, -0.01964696f, 0.02806509f, -0.41515881f, -0.73607922f, -0.27859220f, -0.19192865f, 
    -0.09812129f, 0.02807873f, -0.07414249f, 0.05668105f, -0.17006601f, -0.21342887f, -0.08019058f, 0.01124490f, 
    -0.06148502f, -0.01931970f, -0.12904166f, 0.13236530f, -0.01389401f, -0.04680991f, -0.04908169f, -0.28732949f, 
    -0.30360758f, 0.18068776f, -0.25441751f, 0.08523165f, 0.15959524f, -0.10943057f, -0.41520926f, 0.29721251f, 
    -0.00476308f, -0.13287355f, -0.01973752f, 0.09043182f, -0.11158817f, 0.10528237f, -0.05960350f, 0.11527739f, 
    0.00696996f, -0.09391106f, -0.10576971f, -0.29886547f, 0.33218148f, 0.27259868f, 0.19497773f, -0.42161784f, 
    0.40983981f, -0.21968132f, 0.15321280f, 0.08587367f, -0.04843725f, -0.03803717f, 0.03670197f, -0.02767324f, 
    -0.01454568f, -0.00737763f, 0.11493015f, -0.07664136f, -0.02538092f, -0.10171849f, -0.07667415f, 0.06059046f, 
    -0.15207565f, -0.24861595f, -0.20420997f, 0.15320577f, 0.40389141f, -0.19086844f, 0.07494763f, 0.14434895f, 
    0.12470327f, 0.07539868f, 0.01343979f, 0.01373183f, -0.07603560f, -0.17327899f, 0.03339682f, -0.04730565f, 
    0.03654655f, -0.06803647f, 0.01667255f, -0.03818886f, 0.23886752f, -0.02539427f, -0.32387832f, -0.31439185f, 
    0.15832402f, 0.05904589f, -0.00328826f, -0.00352230f, 0.03548410f, 0.00647612f, 0.09696877f, -0.07985681f, 
    -0.22841088f, -0.00391323f, -0.09670036f, 0.14136752f, -0.01755382f, 0.03148012f, 0.00736425f, 0.05496892f, 
    -0.19621901f, 0.36827716f, -0.13625994f, 0.09129544f, 0.32567394f, 0.22285064f, 0.09802596f, 0.01228687f, 
    -0.13691083f, 0.04750590f, -0.11446904f, 0.00907911f, 0.02285451f, -0.01299589f, 0.06069765f, 0.01899730f, 
    -0.05957089f, 0.08593047f, 0.06759734f, 0.00704971f, -0.24473175f, -0.30524924f, 0.24839984f, 0.10438146f, 
    0.04468183f, -0.16079450f, -0.06012150f, -0.04886304f, 0.15883490f, 0.04323846f, 0.03709877f, 0.08750724f, 
    0.03466244f, -0.07124308f, 0.10708506f, -0.00096326f, -0.02195343f, -0.15501367f, 0.04878750f, 0.04551215f, 
    0.29282042f, 0.06493726f, -0.09718921f, -0.02051462f, -0.26639810f, 0.07471903f, -0.02623233f, 0.02366873f, 
    -0.23295662f, -0.17749596f, -0.20970683f, -0.01913938f, 0.02621362f, 0.04344860f, -0.17295267f, 0.08488949f, 
    -0.05870966f, 0.05620108f, -0.04236751f, -0.22892404f, 0.42674711f, -0.33839855f, 0.45762402f, -0.41669884f, 
    -0.07980230f, -0.20662123f, 0.01283842f, 0.01356220f, 0.16036618f, 0.00985466f, 0.18456255f, 0.12484591f, 
    0.19349135f, -0.01587919f, 0.09894580f, 0.11659071f, 0.01001040f, 0.17250712f, -0.12907402f, -0.16644384f, 
    0.13894972f, -0.03404957f, -0.05922003f, -0.17159659f, 0.37959725f, 0.10319784f, 0.09591115f, 0.01010287f, 
    -0.00500294f, -0.00298066f, 0.03624788f, -0.10034065f, -0.05312502f, -0.09152897f, 0.07950608f, 0.03511449f, 
    -0.13457569f, 0.08747083f, -0.04176636f, -0.05904688f, -0.16372576f, 0.91597784f, -0.17059557f, 0.04556932f, 
    -0.26647848f, 0.45505103f, 0.11499214f, 0.18336801f, 0.02341592f, 0.02603623f, -0.17567869f, -0.22106819f, 
    -0.03692322f, -0.14687431f, 0.06744782f, -0.11664522f, -0.16639285f, -0.19306083f, -0.05932667f, -0.05156797f, 
    -0.47206345f, 0.19960526f, 0.03062383f, 0.38766366f, 0.40312597f, 0.01032470f, -0.20626029f, 0.05687870f, 
    -0.08969880f, 0.00753782f, 0.00108951f, -0.01992535f, 0.03057145f, -0.06844784f, -0.06816480f, 0.14360525f, 
    -0.08407975f, 0.12037639f, -0.06685406f, -0.16819793f, -0.11274207f, -0.31975970f, 0.30568251f, -0.03889804f, 
    0.10990734f, -0.27360186f, -0.07516307f, -0.01873523f, 0.10568222f, -0.17111409f, 0.14700483f, 0.01385024f, 
    0.10713985f, 0.01063549f, 0.06594840f, -0.13088459f, 0.02810524f, -0.04218612f, 0.10829099f, -0.04259042f, 
    0.34330556f, 0.70332801f, 0.01235211f, -0.24667223f, -0.09295446f, 0.13073950f, 0.13439244f, -0.02653333f, 
    -0.14283575f, 0.11303836f, -0.18114832f, -0.09672832f, 0.04787862f, -0.09955311f, 0.02680090f, -0.07741096f, 
    0.02737661f, 0.10346329f, 0.13811785f, -0.01120427f, 0.22142728f, 0.48886168f, -0.03899262f, -0.50579196f, 
    0.19933273f, 0.22736126f, 0.07663085f, -0.23832148f, -0.06294101f, -0.41840544f, -0.06697525f, 0.07362057f, 
    0.04793008f, 0.03540502f, -0.01371157f, 0.01847232f, 0.20771536f, -0.15755656f, 0.16171511f, -0.02863706f, 
    0.39734155f, -0.01705729f, -0.21271089f, -0.16753903f, 0.05473353f, 0.06600302f, 0.05044426f, 0.10259897f, 
    0.07190800f, -0.00723265f, 0.08886822f, -0.04001763f, 0.09366031f, 0.06657802f, 0.00064856f, -0.09896689f, 
    0.10154647f, 0.07853530f, 0.04137154f, -0.06623884f, 0.09121946f, 0.05332331f, -0.26231584f, -0.15046145f, 
    0.19467351f, 0.10902452f, 0.01563978f, -0.03600721f, 0.05763677f, 0.01256097f, 0.03316165f, -0.01358546f, 
    -0.08238305f, -0.07183159f, -0.07490209f, 0.14480285f, 0.02061870f, 0.12180465f, 0.07767576f, 0.20603006f, 
    0.01105025f, -0.02860345f, -0.04382194f, -0.05005385f, 0.17071000f, -0.03644118f, 0.05000317f, -0.11933581f, 
    -0.04480574f, -0.01073320f, -0.06267438f, 0.06384375f, -0.07487611f, -0.14829297f, -0.04970188f, 0.02382216f, 
    -0.03983278f, 0.02040881f, -0.21514836f, -0.10843676f, 0.04675832f, -0.08330867f, 0.09716712f, -0.13017459f, 
    0.19630378f, -0.13327639f, 0.10892384f, 0.07846247f, 0.06920015f, 0.10912400f, 0.02757945f, -0.04453508f, 
    0.07460851f, -0.03021229f, 0.04011380f, 0.05557030f, -0.01267636f, -0.06636462f, 0.02145248f, 0.00383819f, 
    -0.15315445f, 0.23519245f, 0.08820614f, 0.37614992f, 0.19007602f, -0.08621820f, -0.06585418f, -0.15132302f, 
    -0.05318952f, -0.16004530f, -0.22954676f, 0.01792430f, -0.02597979f, -0.17125857f, 0.00407750f, -0.04594728f, 
    -0.02507935f, 0.03929812f, -0.01424544f, 0.00873736f, -0.34874734f, -0.32056978f, -0.35657224f, -0.25300953f, 
    -0.36205161f, -0.10336073f, -0.02900313f, -0.17358072f, -0.04571819f, -0.03931731f, 0.04104870f, 0.10797193f, 
    0.10016736f, -0.09637075f, -0.06703906f, -0.01072035f, 0.20026976f, 0.23522173f, -0.09664077f, -0.21648179f, 
    0.49197873f, 0.74074006f, -0.15895753f, -0.37598389f, 0.06570534f, 0.04011277f, -0.12634932f, -0.15117295f, 
    -0.19405428f, -0.11532947f, -0.05966972f, -0.11602849f, -0.01966130f, -0.10209516f, -0.09730831f, -0.06550626f, 
    0.05843765f, -0.16134039f, 0.06467797f, 0.11365665f, -0.18702784f, -0.01480513f, -0.22127987f, -0.07175554f, 
    0.40744936f, -0.01548648f, -0.03260211f, -0.15282963f, -0.06244976f, -0.17307650f, 0.00298485f, 0.13858600f, 
    0.11823375f, 0.10648868f, 0.10913754f, -0.05085219f, -0.06459188f, 0.11522397f, -0.13314314f, 0.04739955f, 
    -0.15380426f, -0.35132325f, 0.11776651f, -0.21514532f, -0.40175962f, -0.19064267f, -0.36500028f, -0.04253060f, 
    -0.02391880f, -0.24720138f, 0.03574165f, 0.03108357f, 0.00307731f, 0.13754801f, 0.10353754f, 0.03061141f, 
    0.10907327f, -0.14799361f, 0.00045154f, -0.11711688f, -0.26069093f, -0.12773956f, -0.17309490f, -0.14741504f, 
    0.16110636f, 0.16914606f, 0.13048470f, -0.01543925f, -0.10328907f, 0.11499799f, -0.21640915f, -0.03278706f, 
    -0.08732048f, -0.02879249f, -0.11126009f, -0.16382338f, -0.20765500f, 0.07527944f, 0.01742569f, -0.07682029f, 
    -0.68019527f, 0.07366859f, 0.60219789f, 0.37036875f, 0.82276899f, -0.09263863f, 0.10602303f, 0.03542423f, 
    0.13071078f, 0.04234827f, 0.08340681f, 0.01293348f, -0.06294524f, 0.04449410f, 0.07204267f, -0.02218045f, 
    0.09866162f, 0.19868849f, 0.02974351f, -0.04977631f, -0.28848693f, -0.08699682f, -0.36913350f, -0.15453163f, 
    0.31114513f, 0.12356507f, 0.07026675f, -0.13463204f, 0.12563437f, -0.09019052f, -0.06451396f, 0.10867172f, 
    -0.16982453f, 0.09569181f, -0.07679695f, -0.12393437f, 0.02446549f, 0.23865665f, -0.01974492f, -0.02782593f, 
    -0.43931830f, 0.17065075f, 0.01001949f, -0.17470762f, -0.23004185f, 0.05725234f, 0.07388811f, -0.03256315f, 
    0.08069195f, 0.16283393f, 0.06135195f, -0.19455217f, -0.08969703f, 0.01717918f, 0.10521255f, -0.01815203f, 
    0.13114227f, -0.17377633f, -0.32437631f, 0.06925710f, 0.03654126f, -0.27315122f, -0.19568808f, 0.19840665f, 
    -0.00573440f, -0.13481124f, -0.13396817f, 0.05188187f, -0.26776919f, -0.06261764f, -0.13601419f, 0.10205840f, 
    -0.13161287f, -0.16928510f, -0.29595566f, -0.11744031f, -0.04700243f, -0.00527128f, 0.00200910f, 0.14194943f, 
    0.02636828f, 0.00037767f, -0.08610807f, -0.03427024f, -0.22269626f, 0.12656367f, -0.00054762f, 0.02566353f, 
    0.02503739f, 0.09710451f, 0.04667564f, -0.01065497f, 0.00998542f, 0.03083597f, 0.00477294f, -0.07555979f, 
    -0.01835109f, -0.01970143f, -0.17243749f, 0.05156304f, 0.02720346f, -0.18879177f, 0.09034204f, -0.13635272f, 
    0.05305762f, 0.04160472f, -0.09621211f, 0.06609543f, -0.01191874f, -0.09781753f, -0.09705918f, -0.14727092f, 
    -0.01136782f, 0.03500211f, -0.06822486f, -0.12355877f, -0.07334154f, -0.04219696f, -0.13069014f, -0.03698885f, 
    -0.12209120f, -0.31884456f, 0.11490308f, 0.34032243f, 0.09013133f, -0.17108063f, -0.09618788f, 0.18203184f, 
    -0.35236344f, -0.09107926f, -0.01348910f, -0.05414843f, -0.01155684f, 0.02805709f, 0.04290552f, 0.02154963f, 
    0.06105728f, 0.00817856f, -0.12489052f, 0.02326871f, 0.08631471f, 0.01136847f, -0.03595613f, -0.04954295f, 
    -0.02603280f, 0.06795906f, 0.05532105f, 0.08717817f, 0.00778699f, 0.00859538f, 0.11449624f, 0.05033857f, 
    -0.11020818f, -0.04303450f, 0.08052597f, 0.11560461f, 0.03181618f, -0.02151005f, -0.04373872f, 0.01341432f, 
    0.21091396f, -0.28168514f, 0.18266897f, -0.19927788f, 0.01301368f, 0.24615395f, -0.10482649f, 0.02772123f, 
    -0.05667232f, -0.11524428f, -0.05481214f, -0.10611495f, 0.03062576f, -0.12153083f, 0.00668151f, 0.03800139f, 
    -0.15262280f, 0.06018424f, -0.32034257f, -0.45822343f, 0.12496559f, 0.00629014f, 0.03063055f, 0.59988838f, 
    0.23799184f, 0.10311345f, 0.15789482f, 0.12777846f, 0.09836210f, 0.21213408f, 0.07284509f, -0.13360475f, 
    0.01648344f, -0.00722788f, 0.03234176f, -0.03660195f, 0.03805188f, -0.09941033f, 0.03115773f, -0.17341222f, 
    0.11881339f, 0.16746894f, 0.29094189f, 0.07216569f, 0.22091657f, 0.00147221f, 0.28204444f, -0.02263632f, 
    0.14470978f, 0.14108920f, -0.00407482f, 0.01391849f, -0.01892827f, 0.02173324f, -0.01197258f, 0.13656951f, 
    0.12270798f, -0.19797698f, 0.05384651f, 0.28020045f, -0.08755202f, 0.09350063f, 0.15878318f, 0.23109652f, 
    -0.02522918f, -0.01715477f, -0.24488287f, -0.03586247f, -0.09979954f, -0.00836663f, 0.05136406f, -0.01681771f, 
    0.11195727f, -0.00559200f, 0.01204324f, 0.00668433f, -0.06136820f, -0.01250590f, -0.12055106f, -0.14575206f, 
    0.17753649f, 0.01161130f, 0.17136467f, 0.02727203f, 0.06476373f, -0.08238344f, -0.00126400f, -0.04451151f, 
    0.00776177f, 0.13998459f, 0.19086646f, -0.07697603f, -0.14177598f, 0.03664559f, 0.01853750f, 0.08156301f, 
    0.07105883f, 0.11257987f, 0.04460645f, -0.07147000f, 0.06934144f, 0.23818970f, -0.30147517f, -0.08607898f, 
    0.00230533f, 0.06039323f, 0.00024923f, 0.02518398f, 0.04416785f, 0.09274884f, 0.05882013f, 0.06854556f, 
    -0.01526091f, 0.00028614f, 0.00662805f, 0.02321974f, 0.08374611f, 0.16465949f, -0.02184656f, 0.21824451f, 
    0.07727896f, -0.02293754f, -0.06194942f, -0.05434912f, -0.03057136f, 0.01869255f, 0.01000598f, -0.02175881f, 
    -0.01335456f, -0.02505297f, 0.11986199f, -0.18832047f, 0.00915285f, -0.07816984f, 0.09020676f, 0.11525382f, 
    -0.03244286f, -0.02705029f, -0.07446264f, 0.04021955f, 0.48513761f, -0.05702528f, -0.61653334f, -0.05102758f, 
    -0.04641562f, 0.07665730f, 0.04845030f, 0.02466385f, 0.12359853f, 0.03426726f, 0.07358716f, -0.02647987f, 
    0.04117154f, 0.04695258f, 0.01462129f, -0.00911004f, 0.17689191f, -0.00695278f, 0.04636144f, 0.25843140f, 
    -0.08976024f, 0.15174045f, 0.13532127f, 0.11708450f, 0.02929915f, -0.13923492f, -0.03419653f, 0.07231861f, 
    0.10202230f, 0.09306561f, 0.21628699f, -0.09651235f, 0.02944411f, -0.08988858f, -0.00193764f, -0.03601545f, 
    -0.06300896f, -0.08701710f, -0.12501474f, -0.45443824f, -0.34690240f, -0.13255014f, 0.09535074f, -0.29856399f, 
    -0.17053051f, 0.05978747f, 0.04323977f, -0.04430883f, 0.11671357f, 0.07259645f, -0.06583173f, 0.00672932f, 
    -0.02089596f, 0.05689031f, -0.16956411f, -0.11240406f, 0.03456073f, -0.05462331f, -0.07532034f, 0.02964953f, 
    0.04831683f, -0.25350145f, 0.10106543f, -0.16694948f, 0.01901169f, 0.03188990f, -0.05347697f, 0.01321602f, 
    -0.16552684f, -0.19957200f, -0.07477816f, -0.30867040f, 0.02939343f, 0.09958457f, -0.01262513f, 0.01479597f, 
    0.03475235f, -0.11590701f, -0.03528908f, -0.14168997f, -0.00155642f, 0.06798808f, -0.06868222f, 0.28426528f, 
    0.18781650f, -0.06182888f, 0.09161404f, -0.03293996f, 0.04854483f, 0.02625181f, 0.08865717f, 0.00187166f, 
    0.01444924f, 0.00423940f, 0.05789709f, -0.12649594f, -0.03774663f, 0.03692965f, -0.08307362f, -0.09553535f, 
    -0.31218898f, -0.71628219f, 0.02676704f, 0.21449262f, -0.13743143f, 0.12153579f, -0.01009110f, 0.08128253f, 
    -0.22589736f, 0.05833299f, -0.05851746f, 0.04299732f, 0.07337705f, -0.04561487f, -0.10452482f, -0.21443520f, 
    0.01117132f, -0.07387055f, -0.15026654f, 0.21760581f, 0.07957828f, -0.08190853f, 0.06864443f, 0.00186007f, 
    -0.01886204f, -0.14839435f, -0.18526633f, -0.00640452f, -0.00167501f, 0.13993025f, -0.05183338f, -0.03373225f, 
    -0.00630901f, -0.01662944f, 0.02489354f, 0.00855391f, -0.03508220f, 0.02315718f, -0.02089050f, -0.00676901f, 
    -0.21101320f, -0.26756164f, -0.03200792f, 0.05407799f, -0.04255487f, -0.19367425f, -0.06622039f, -0.07052900f, 
    -0.06399080f, -0.00148956f, 0.00091273f, 0.03943791f, -0.03390216f, 0.17938407f, 0.11288889f, 0.04851168f, 
    0.22327305f, 0.00143499f, 0.03195293f, 0.21674126f, -0.05818927f, 0.17109662f, 0.05542184f, 0.24351206f, 
    -0.03673105f, 0.03817910f, -0.05355263f, -0.09824506f, -0.23527713f, -0.01720580f, -0.04430836f, -0.03697559f, 
    0.01143259f, 0.03679073f, 0.08819142f, -0.01957494f, -0.05712920f, -0.03765287f, -0.28418392f, -0.03770242f, 
    -0.15508208f, 0.02236695f, 0.14918265f, 0.22761963f, 0.05422513f, -0.20191170f, 0.10471841f, 0.03838074f, 
    -0.02096177f, -0.06997056f, -0.02618029f, -0.07023349f, -0.01643016f, 0.02068754f, 0.01768324f, 0.01083565f, 
    0.05978453f, -0.05389601f, 0.09570972f, 0.10410966f, 0.13609397f, 0.07428516f, -0.19873987f, 0.04699054f, 
    -0.00874350f, -0.04515812f, 0.04278895f, 0.04455667f, 0.10761795f, 0.00022293f, 0.04223387f, 0.02175438f, 
    0.01364346f, -0.02639934f, -0.00052340f, 0.09496827f, 0.26841334f, 0.11957907f, 0.12620555f, 0.32340547f, 
    -0.12858580f, -0.13753353f, -0.14865974f, -0.12827630f, -0.05795835f, 0.09025982f, 0.01211073f, 0.27138916f, 
    -0.03973025f, 0.00462092f, -0.06415391f, -0.06119463f, 0.16415781f, -0.23128989f, 0.00333563f, 0.12487458f, 
    0.01026020f, -0.05351996f, -0.14856663f, -0.00910672f, 0.00058493f, -0.00380642f, -0.02664953f, -0.03079273f, 
    0.05152651f, 0.12934241f, 0.16007042f, 0.08718712f, 0.03999743f, 0.03391270f, 0.05472709f, 0.06242315f, 
    0.01233520f, -0.02581584f, 0.06680651f, 0.00571645f, -0.03297159f, -0.02331797f, 0.02458379f, 0.02281629f, 
    -0.01091218f, -0.39972946f, -0.27406043f, 0.10969220f, -0.11865237f, -0.04922190f, -0.20334241f, -0.01341730f, 
    -0.16825372f, -0.10817784f, -0.08219876f, -0.12207469f, 0.05869569f, 0.02727053f, -0.06315391f, -0.04405437f, 
    -0.14702494f, -0.02713012f, -0.21904121f, -0.00251924f, 0.04947437f, -0.06938899f, 0.19314405f, 0.31495413f, 
    0.24788536f, -0.26190281f, -0.02149060f, -0.08684103f, -0.22932707f, -0.15092021f, 0.01883413f, 0.06019648f, 
    -0.04961007f, 0.07775239f, 0.03224117f, -0.04267019f, 0.01871965f, -0.03631701f, 0.04872732f, -0.08571099f, 
    -0.02354556f, 0.01717759f, -0.08310185f, -0.04494099f, 0.07237429f, 0.03836890f, 0.05720207f, 0.01671611f, 
    -0.04680374f, 0.05274830f, 0.07199270f, 0.00462344f, -0.04531208f, -0.09634896f, 0.10365707f, -0.04351681f, 
    -0.19405732f, -0.02430652f, -0.02307197f, 0.01126306f, 0.08600930f, 0.21465786f, 0.08870900f, -0.13225570f, 
    -0.11567149f, -0.05352519f, -0.21727897f, -0.21417594f, -0.05381948f, 0.01773850f, 0.15483081f, -0.05400911f, 
    0.07992356f, -0.01329355f, 0.06539072f, 0.09125939f, -0.06832093f, -0.11105066f, -0.16941458f, -0.03801237f, 
    -0.07046040f, -0.04854719f, 0.04691042f, -0.10878011f, 0.11671427f, 0.04407560f, 0.12469267f, 0.22230920f, 
    -0.03603123f, 0.14697282f, 0.01372274f, -0.00680743f, 0.06956342f, -0.10380675f, 0.02224167f, -0.03217831f, 
    -0.03154344f, -0.10637747f, -0.00217438f, -0.10565763f, 0.22651029f, 0.17174199f, 0.29572695f, 0.24908300f, 
    0.09052252f, -0.25418600f, -0.11784725f, 0.14094536f, 0.00992007f, -0.05293940f, 0.06135583f, -0.02142682f, 
    0.00880369f, 0.08742186f, 0.05740375f, -0.04152960f, -0.06230794f, -0.09856636f, 0.01026688f, -0.17000800f, 
    -0.24587616f, -0.07330618f, -0.24407443f, -0.49723408f, 0.23570906f, 0.00385809f, -0.01413073f, -0.05419850f, 
    -0.13668980f, -0.03216085f, 0.20379809f, -0.08461417f, 0.10927685f, -0.14191434f, 0.05559833f, 0.02846697f, 
    -0.09695668f, 0.16532815f, 0.00965796f, -0.12012085f, -0.24843581f, -0.05832848f, 0.03229232f, -0.10796747f, 
    -0.14802997f, -0.04653683f, 0.16295414f, 0.11951792f, -0.21989726f, -0.00615549f, 0.02136175f, -0.12258884f, 
    -0.03636806f, 0.20368701f, 0.15755548f, -0.08167046f, -0.18705010f, -0.04001964f, 0.04033533f, -0.07892877f, 
    0.31776950f, 0.12887830f, -0.42210996f, -0.14847726f, 0.25596306f, 0.12338701f, 0.03024318f, -0.07472298f, 
    -0.06674287f, -0.01516313f, 0.07367439f, -0.05841289f, -0.17748657f, 0.06121041f, -0.00235031f, -0.08799740f, 
    0.03339977f, 0.07255194f, 0.01664591f, -0.07119459f, 0.35380381f, -0.23265781f, 0.12666622f, 0.10033666f, 
    -0.23454824f, 0.11236655f, -0.07613079f, -0.16208176f, 0.18178104f, 0.26372063f, 0.11106958f, 0.05326030f, 
    0.00366934f, -0.07920948f, 0.06659386f, 0.04711043f, 0.10551552f, -0.03718524f, -0.05859324f, 0.33533400f, 
    -0.21531004f, -0.22555968f, 0.44641894f, -0.16573383f, -0.49669102f, 0.16172290f, 0.03197656f, 0.08151140f, 
    0.12226226f, -0.24753423f, -0.02075215f, 0.04545505f, 0.02072590f, -0.00565775f, 0.09064730f, 0.03187157f, 
    -0.01718940f, -0.02979413f, 0.04220099f, -0.10818411f, -0.05946289f, -0.02646914f, -0.17526031f, 0.03040287f, 
    0.12445297f, 0.04527246f, 0.08404374f, -0.03514318f, -0.05078950f, 0.01467846f, 0.32643500f, -0.15568413f, 
    0.06834845f, -0.07103781f, 0.03412127f, 0.02624647f, 0.12735778f, 0.19577411f, 0.11021946f, -0.02375447f, 
    -0.03397971f, -0.00247969f, 0.09604000f, 0.09359497f, -0.02020679f, 0.01122802f, 0.01148824f, -0.03382879f, 
    -0.06723098f, 0.15952176f, 0.19741303f, -0.12787546f, 0.01318950f, 0.07318915f, -0.14000496f, 0.18195072f, 
    -0.04285300f, 0.13821247f, 0.06994808f, 0.20474109f, -0.41567525f, -0.15162483f, 0.36583406f, 0.10286307f, 
    -0.56382573f, -0.09703814f, 0.00510357f, 0.08069938f, -0.06008133f, 0.01372805f, -0.03342343f, 0.08630094f, 
    -0.11095878f, -0.05641242f, 0.01293372f, 0.02773745f, -0.06121947f, 0.11151535f, -0.10758585f, 0.14274079f, 
    0.21137622f, 0.12009633f, 0.39508617f, 0.11246713f, 0.02063472f, 0.02816028f, -0.11187158f, 0.08581079f, 
    0.02389429f, -0.01778384f, 0.04570714f, 0.04867949f, 0.13214427f, -0.01408060f, -0.05256705f, -0.00249525f, 
    0.05735471f, -0.13375004f, -0.17307875f, -0.37508973f, 0.13345195f, -0.15302357f, 0.12193307f, 0.21664344f, 
    -0.27562556f, 0.04376385f, 0.08011171f, -0.14424121f, -0.15304582f, -0.03008655f, -0.06470445f, -0.06857833f, 
    0.02659428f, -0.00260323f, 0.10177542f, -0.05235201f, 0.08478705f, 0.04442830f, 0.06540333f, 0.11173777f, 
    -0.24440645f, -0.07462709f, -0.24167004f, -0.19265215f, -0.06772652f, 0.01600707f, -0.06886124f, -0.12186612f, 
    0.00171093f, 0.27557090f, 0.00729073f, 0.05477833f, -0.04428403f, -0.03315885f, -0.14950699f, -0.05555891f, 
    0.00509212f, 0.05610547f, -0.00518803f, 0.05900711f, 0.06029290f, 0.06198553f, -0.20069504f, -0.03629731f, 
    0.10601409f, 0.06997926f, 0.02443408f, -0.02971251f, -0.05245651f, -0.03830257f, 0.03312868f, -0.01637819f, 
    -0.02240284f, -0.02215981f, -0.01644163f, -0.35608369f, -0.07377980f, 0.05501791f, 0.16172233f, -0.16647987f, 
    -0.27117220f, 0.21346365f, -0.16576959f, 0.04818138f, -0.03458256f, 0.02669333f, -0.00551469f, -0.04761052f, 
    0.10740785f, 0.05313379f, 0.14791730f, 0.01724812f, -0.02625638f, -0.05691937f, -0.17208126f, -0.03633859f, 
    0.07324947f, 0.15225884f, 0.09565768f, 0.04218694f, -0.35115585f, -0.20310341f, -0.05761959f, 0.01111003f, 
    -0.09664498f, 0.13889791f, 0.02400431f, -0.00626063f, -0.08314968f, 0.15684752f, -0.11241310f, 0.07570141f, 
    0.04511853f, 0.02980278f, 0.01031456f, -0.15153922f, -0.31388173f, 0.07193936f, 0.03086464f, -0.05294584f, 
    0.05117273f, 0.14547881f, -0.00347473f, 0.06337401f, -0.19109657f, -0.01092971f, -0.11890302f, 0.21495028f, 
    -0.01310978f, -0.00828292f, -0.02681099f, -0.05737802f, -0.08554547f, -0.07668695f, -0.00978283f, 0.08735266f, 
    0.07208431f, 0.08674739f, 0.02472747f, 0.07442215f, -0.32639158f, -0.10774894f, -0.36080274f, -0.34614012f, 
    0.16173097f, -0.11984248f, -0.05456650f, -0.04935922f, -0.06710740f, 0.03218025f, -0.05431956f, 0.25907183f, 
    -0.03346161f, -0.05322454f, 0.13238114f, -0.13901117f, -0.19078065f, 0.16565721f, 0.10708491f, 0.06893660f, 
    -0.12193142f, -0.24489942f, -0.06614241f, -0.16112626f, -0.02602350f, 0.03508858f, -0.03298823f, -0.04119279f, 
    0.09969110f, 0.11835593f, -0.01114168f, 0.16617787f, 0.05617790f, -0.03822106f, -0.09619629f, 0.05517472f, 
    0.03906446f, 0.03840534f, -0.00069880f, 0.08684839f, -0.35060826f, 0.02974500f, -0.36915839f, 0.30008516f, 
    0.12949941f, 0.18434477f, -0.06953562f, -0.02530804f, 0.03031956f, 0.09856824f, -0.02005303f, 0.03855167f, 
    0.01092922f, 0.02140882f, -0.04057588f, -0.01354443f, -0.11614918f, 0.31469300f, -0.16759264f, -0.03047656f, 
    -0.53091824f, 0.29326299f, 0.02156338f, 0.12840889f, -0.36052585f, -0.01907596f, -0.16615915f, 0.00823524f, 
    0.17018518f, -0.10900562f, -0.13505726f, -0.11211798f, -0.20711292f, 0.01371048f, -0.00678979f, 0.07020652f, 
    -0.11379179f, 0.00178479f, 0.04743831f, -0.02949071f, -0.16229819f, -0.14243655f, -0.31706655f, 0.07537109f, 
    -0.21312633f, 0.09947969f, -0.05255190f, -0.19573264f, 0.11140473f, 0.07696193f, 0.18763492f, 0.04529697f, 
    0.07083625f, 0.03058303f, 0.05639238f, -0.05488174f, 0.05401582f, 0.06218594f, -0.05456119f, 0.07456060f, 
    -0.11445023f, 0.22214153f, 0.04480880f, 0.10658262f, -0.05293110f, -0.11768057f, -0.19652964f, -0.07435665f, 
    -0.05515809f, -0.04655441f, 0.00386271f, 0.01458739f, -0.00972027f, -0.02525058f, -0.10406294f, -0.00329690f, 
    -0.07934958f, -0.30866873f, -0.27115956f, -0.41236505f, 0.07954603f, -0.22021909f, 0.19669767f, -0.15320966f, 
    -0.32823879f, 0.17685954f, -0.11995208f, 0.07359967f, 0.11812608f, -0.17693771f, 0.05895258f, -0.07796764f, 
    0.00808159f, -0.07942396f, 0.07801887f, -0.04818058f, 0.06576677f, 0.08224063f, 0.12738205f, 0.07553729f, 
    0.24986404f, -0.01763842f, 0.39484933f, 0.13873808f, -0.37432122f, 0.17771403f, 0.17161109f, 0.09088939f, 
    0.07216319f, 0.24480291f, 0.05112310f, 0.03368003f, 0.02297901f, -0.03225210f, 0.04478991f, -0.00723985f, 
    0.01755282f, -0.10794044f, -0.01447521f, 0.10320110f, 0.04204050f, 0.02408723f, 0.33386499f, 0.19646399f, 
    0.01510808f, 0.02350768f, 0.05363693f, -0.09007311f, -0.06967141f, -0.04455096f, 0.04096719f, 0.04771532f, 
    0.09059393f, 0.03615406f, -0.03223364f, -0.06073166f, 0.04760118f, -0.06453851f, -0.29261535f, -0.44228837f, 
    0.53218317f, 0.03449263f, -0.43771723f, 0.05368645f, 0.23833263f, 0.11352660f, -0.23567493f, 0.03602637f, 
    -0.16580310f, 0.12459233f, -0.00249612f, 0.01245293f, -0.08799054f, -0.13473843f, -0.10772955f, 0.07827503f, 
    0.11236105f, -0.10090747f, 0.01009784f, -0.04200329f, -0.05056304f, -0.07092060f, -0.15161988f, 0.09673753f, 
    0.16270673f, 0.17604743f, -0.06613507f, 0.03762277f, -0.07268549f, 0.00737585f, 0.03828761f, -0.09251067f, 
    -0.10490167f, 0.05357645f, 0.07852100f, 0.05795205f, -0.04442428f, 0.05168620f, -0.10124832f, 0.03495014f, 
    -0.15705173f, 0.10872718f, 0.05465699f, 0.09128394f, -0.33258641f, 0.09151181f, 0.02206094f, -0.10969877f, 
    0.07137733f, 0.02055015f, 0.12451208f, -0.11047615f, -0.13015833f, -0.03064224f, 0.16463009f, 0.05070516f, 
    0.10833006f, 0.04466074f, -0.10743603f, 0.03659770f, -0.19060867f, -0.13076524f, -0.23059808f, -0.04293064f, 
    -0.34066054f, 0.08971034f, 0.12662168f, -0.02293290f, -0.05811789f, 0.15118985f, 0.09398077f, -0.03116195f, 
    -0.08354197f, -0.03049458f, -0.02851994f, -0.13444138f, 0.01358396f, 0.10163908f, 0.02159422f, 0.03571729f, 
    -0.14023866f, -0.21690951f, -0.18797745f, 0.28673834f, 0.06787910f, -0.05684000f, -0.03476505f, 0.01433729f, 
    0.07196484f, -0.02213632f, -0.01726289f, -0.08217423f, 0.07135692f, 0.01432012f, -0.02194451f, 0.04981733f, 
    -0.04602864f, 0.15626711f, -0.07315648f, 0.01204234f, -0.17479025f, 0.09124471f, 0.13792308f, -0.11968280f, 
    0.02562975f, -0.29223752f, -0.00700182f, 0.18529812f, 0.10745843f, -0.07901783f, 0.05081722f, 0.01501429f, 
    -0.01878884f, -0.04085538f, 0.02062136f, 0.06239741f, 0.01154036f, -0.02190795f, 0.01312033f, 0.18243672f, 
    0.59013301f, 0.14198527f, -0.29184815f, -0.31120309f, 0.19309719f, -0.12465978f, 0.12230085f, -0.10435344f, 
    -0.25386885f, 0.04655404f, -0.00145357f, 0.03842853f, -0.06552739f, -0.18521427f, -0.03449072f, 0.04159975f, 
    0.08819516f, 0.02737882f, -0.12227549f, 0.05361276f, -0.09802245f, -0.14767186f, 0.26576990f, -0.18264224f, 
    -0.21876830f, 0.39279595f, 0.03252388f, -0.08429416f, -0.13707362f, 0.17769648f, 0.11928786f, 0.03970674f, 
    -0.02605164f, 0.00655648f, 0.03292084f, 0.05488423f, -0.04845522f, -0.06330155f, 0.20615160f, 0.17575003f, 
    -0.09319607f, 0.10534908f, 0.17274199f, 0.05371577f, 0.16771953f, 0.04643583f, -0.04493310f, -0.12002278f, 
    0.09893441f, -0.03646564f, -0.04189507f, 0.10251515f, 0.14005208f, 0.24669054f, 0.02435674f, 0.09390817f, 
    -0.00551900f, 0.10905327f, -0.21631195f, 0.03269684f, -0.15655410f, 0.09238227f, 0.42043063f, 0.04662129f, 
    0.20093733f, 0.19584824f, 0.03502104f, -0.12291987f, 0.00427036f, 0.18244621f, -0.03974130f, 0.08282222f, 
    0.12330616f, -0.00947513f, -0.11176077f, 0.10606585f, 0.16942425f, -0.04498705f, 0.03144873f, 0.11665325f, 
    0.02875918f, -0.02916030f, 0.03867109f, -0.01909152f, -0.07545558f, 0.06026334f, -0.00926076f, 0.11982065f, 
    -0.03501029f, -0.08651650f, -0.05253661f, -0.04483087f, -0.06761637f, -0.03863902f, -0.01676108f, 0.01107363f, 
    0.00010649f, 0.10579804f, -0.02735040f, 0.06272997f, 0.21618983f, 0.38487360f, -0.46947318f, -0.17317079f, 
    0.20683444f, -0.17443056f, -0.08152319f, -0.02024351f, 0.29558200f, 0.16014126f, 0.01366167f, 0.01020948f, 
    -0.03264230f, 0.00376919f, 0.04302337f, 0.00550808f, 0.02284407f, 0.00190357f, 0.15130997f, -0.05924865f, 
    -0.85628289f, -0.70420390f, -1.12757182f, -0.50568002f, 0.26139906f, -0.21325965f, -0.29494298f, -0.17354174f, 
    -0.32534462f, -0.28647980f, -0.03724273f, -0.02566023f, -0.02559319f, -0.04542167f, -0.01421417f, -0.00153006f, 
    -0.02833100f, -0.06406774f, 0.15938850f, 0.07315148f, -0.02191020f, 0.00605514f, -0.08360058f, -0.15154231f, 
    -0.01965952f, 0.01992437f, 0.01519249f, 0.02591527f, -0.05748643f, -0.00820251f, -0.12624532f, -0.19533826f, 
    -0.14820369f, -0.11162069f, -0.02187148f, -0.01279671f, -0.15643089f, -0.02902757f, -0.11906986f, -0.00801514f, 
    -0.36068082f, 0.30986807f, 0.12100326f, 0.37642911f, 0.10329903f, 0.06190743f, 0.18231152f, -0.07253499f, 
    -0.04513309f, -0.26554450f, 0.08927230f, 0.15365891f, -0.05846437f, 0.03719109f, 0.03574313f, -0.01310269f, 
    -0.08325076f, 0.04773638f, -0.10256694f, -0.12138559f, -0.88106042f, -1.34284639f, -1.46324134f, -0.35874459f, 
    0.47141746f, -0.12867194f, 0.18518797f, 0.21361798f, -0.16978429f, -0.18082929f, -0.00507468f, 0.02182050f, 
    0.03539052f, -0.02171210f, 0.07489134f, 0.00106912f, 0.05187436f, -0.02914097f, 0.27083582f, -0.06739130f, 
    -0.56602144f, -0.61241168f, -0.84751904f, -0.20058089f, -0.32802990f, -0.08604413f, 0.05122265f, -0.04330897f, 
    -0.15638021f, -0.57860869f, -0.01168193f, -0.03638525f, -0.03563738f, 0.09100308f, 0.11869816f, -0.13527375f, 
    0.00455096f, 0.17653494f, 0.17547230f, 0.09092629f, -0.48856235f, -0.11525305f, -0.03249520f, -0.09430418f, 
    0.20032927f, -0.23964040f, -0.00503077f, 0.01609018f, -0.14661941f, -0.06284308f, 0.02666236f, 0.04441011f, 
    -0.01245186f, -0.00757553f, -0.00157984f, -0.00839344f, -0.01651611f, -0.03676756f, 0.16428792f, -0.26405737f, 
    -0.49221313f, 0.55495811f, 0.30037940f, -0.02245753f, 0.23642009f, -0.10961656f, -0.00840175f, -0.09208230f, 
    -0.09323508f, 0.05720310f, -0.10068347f, -0.06011224f, 0.10012802f, 0.04050170f, 0.02230973f, -0.01940452f, 
    -0.02993751f, -0.07296813f, -0.06969299f, -0.03812958f, -0.36279222f, -0.17096445f, -0.07361891f, -0.10569970f, 
    -0.17008778f, -0.03097541f, 0.09156194f, 0.02488377f, -0.00193326f, -0.07042323f, -0.00170724f, 0.01000698f, 
    -0.00683684f, -0.01221088f, -0.01369251f, 0.05885610f, 0.02817311f, 0.04692588f, -0.03399659f, 0.03603790f, 
    -0.12415086f, 0.02087604f, 0.09223479f, -0.02396423f, 0.04307696f, 0.00932463f, -0.02598204f, 0.04648192f, 
    0.00055878f, 0.04689639f, 0.12856099f, 0.03554231f, 0.09249057f, 0.04664924f, 0.07220384f, 0.00369289f, 
    -0.04445453f, -0.06397030f, -0.07348299f, 0.00612360f, -0.42473897f, 0.20138583f, -0.31679586f, -0.02304982f, 
    -0.02145402f, -0.06794518f, 0.09197979f, 0.03440114f, 0.02970448f, 0.02894593f, -0.07077573f, -0.03121893f, 
    0.00078577f, 0.04361981f, -0.03999865f, 0.06575461f, -0.10206676f, -0.17818187f, -0.01264206f, 0.02657412f, 
    -0.30231830f, -0.28048640f, -0.47601423f, -0.31364664f, 0.23083036f, -0.21551883f, 0.13677593f, -0.02067245f, 
    0.00174188f, -0.19843245f, 0.03846987f, -0.01241928f, -0.01137853f, -0.06255295f, -0.00047191f, 0.02313808f, 
    -0.00969535f, 0.04957592f, 0.20256826f, -0.11613511f, -0.12484040f, 0.16599557f, 0.08034622f, -0.12052688f, 
    0.22378255f, -0.00979294f, -0.02736848f, 0.00828375f, 0.04361337f, 0.03922744f, 0.10494263f, 0.11969958f, 
    0.23814607f, 0.15794411f, -0.06365643f, 0.06423230f, -0.01140190f, 0.01623265f, -0.01916790f, 0.15045458f, 
    -0.01554031f, 0.44381109f, -0.02516464f, -0.11313093f, 0.25372615f, -0.09624975f, 0.02424071f, -0.04121876f, 
    0.03669194f, 0.00927079f, 0.05853592f, -0.02175141f, -0.00854116f, 0.03519949f, 0.04311982f, 0.13385433f, 
    -0.12643589f, 0.03989862f, -0.07507638f, -0.02806048f, 0.17152317f, -0.33541903f, -0.37041503f, -0.22624722f, 
    0.20700648f, -0.09965264f, 0.15108436f, 0.20693548f, 0.08893012f, 0.10493194f, -0.05749435f, 0.02168255f, 
    -0.05735521f, -0.02816512f, 0.03846712f, -0.05410043f, -0.03056924f, -0.00695356f, 0.16154407f, 0.09069519f, 
    0.06922922f, -0.23044544f, 0.04693890f, -0.05846651f, -0.10141499f, 0.01323685f, -0.00124200f, -0.06831877f, 
    -0.07747328f, 0.13257152f, -0.13354962f, 0.04183422f, 0.07924041f, 0.14901906f, -0.14680764f, -0.01797098f, 
    0.09029851f, 0.01334102f, 0.14907515f, 0.06751341f, -0.51278377f, 0.13481846f, 0.31463572f, 0.13584501f, 
    0.02068625f, -0.10081199f, -0.00878297f, -0.13667801f, -0.06774346f, 0.36209902f, -0.14623159f, 0.11558005f, 
    0.18652897f, 0.02806932f, 0.11122078f, -0.04986980f, 0.04634706f, -0.09864462f, 0.09171461f, -0.01470795f, 
    -0.01275699f, -0.41835448f, -0.73293376f, -0.34402251f, 0.47272885f, -0.13212624f, -0.04538867f, -0.04900519f, 
    -0.04166963f, 0.00932325f, -0.02259968f, -0.02396819f, 0.04975567f, -0.01212280f, 0.01659821f, 0.04732981f, 
    0.10066351f, -0.03357879f, 0.09875579f, -0.10897850f, -0.35840467f, -0.26494417f, 0.28924602f, 0.01534202f, 
    0.24461935f, -0.22756121f, -0.02608966f, -0.13595438f, -0.11146848f, -0.08963799f, 0.09731353f, -0.04902668f, 
    -0.00479543f, 0.02613156f, 0.07589970f, 0.03507342f, 0.03788552f, 0.01458632f, 0.05629089f, -0.21585883f, 
    -0.47967219f, -0.85668439f, -0.88891912f, -0.14849402f, 0.30515298f, 0.01661408f, 0.08944862f, -0.06539895f, 
    -0.18744773f, -0.21329843f, -0.06185575f, -0.10188954f, -0.03704780f, 0.08038507f, 0.14936741f, 0.01764314f, 
    0.03380838f, -0.02307719f, 0.28693002f, 0.15648907f, -0.20146789f, 0.03570180f, -0.27194196f, -0.04446073f, 
    -0.06290605f, 0.00179038f, 0.12411349f, 0.08252594f, 0.07336482f, -0.01701031f, -0.06340983f, -0.00387278f, 
    0.00853784f, 0.02126474f, 0.04991883f, 0.01968971f, 0.04823058f, 0.06192651f, 0.14173652f, 0.00387146f, 
    0.34740135f, 0.09260181f, -0.11373565f, -0.12457312f, -0.03822805f, 0.00893515f, -0.02180576f, 0.07834414f, 
    0.14308982f, -0.04511907f, 0.07460096f, 0.02433418f, 0.05474676f, -0.27923948f, 0.01356805f, -0.03190270f, 
    -0.05375367f, -0.09250510f, -0.05796012f, 0.08698229f, 0.16664220f, -0.09530288f, -0.14119869f, -0.12874763f, 
    0.06922320f, -0.01794631f, -0.00317770f, 0.07008202f, -0.00280438f, 0.07954462f, -0.10986946f, -0.02767258f, 
    -0.15081501f, -0.15111430f, -0.00875568f, -0.22508614f, -0.18802287f, -0.09538711f, -0.05688657f, 0.03520804f, 
    -0.16984095f, -0.06646628f, 0.15658835f, 0.12129546f, -0.00939176f, -0.08968645f, 0.00739871f, -0.03052696f, 
    -0.06762075f, 0.13866302f, 0.07712252f, 0.09031203f, 0.09506097f, -0.14245403f, 0.06348161f, -0.02457506f, 
    0.06323401f, -0.11176066f, 0.14210299f, -0.03229196f, -0.67980623f, 0.12690854f, 0.28742605f, -0.26352960f, 
    0.24737537f, -0.30262366f, -0.15725803f, 0.00506929f, -0.12864271f, -0.03355941f, 0.01551194f, 0.02965477f, 
    0.02244665f, 0.02257584f, -0.03067065f, 0.00542052f, -0.03258976f, -0.03267307f, 0.09049002f, -0.03381296f, 
    0.10080793f, -0.12488896f, -0.16369005f, -0.12207467f, 0.11458682f, -0.06004390f, 0.02837754f, 0.13436747f, 
    0.07147386f, 0.08109762f, -0.07838377f, -0.09456883f, -0.13246344f, -0.11484636f, 0.02880026f, -0.18540746f, 
    -0.06900837f, -0.14849460f, -0.01172107f, 0.01039999f, -0.43743536f, 0.17816411f, 0.22295986f, 0.08630224f, 
    0.01687893f, 0.02018283f, -0.10695195f, -0.00913883f, 0.02443669f, -0.13351116f, 0.06126975f, 0.10579669f, 
    -0.07777739f, 0.05211232f, 0.02907474f, -0.00920620f, 0.02296264f, 0.18164000f, -0.07346339f, 0.00609154f, 
    0.46314415f, 0.01938265f, -0.35451341f, -0.25103939f, 0.13901147f, -0.03646787f, 0.08076542f, 0.25566247f, 
    0.19780028f, -0.20973887f, 0.10191374f, 0.03383194f, -0.13366136f, -0.10193579f, 0.10796174f, -0.04969381f, 
    -0.02396583f, 0.14186512f, -0.00757365f, 0.05060778f, -0.77700084f, -0.88906896f, 0.00259020f, -0.05102640f, 
    -0.52759874f, 0.02240830f, -0.23749366f, -0.17319956f, -0.20775953f, -0.31845197f, 0.01905155f, 0.01417654f, 
    -0.05855715f, 0.09275728f, -0.00339146f, -0.01907405f, -0.00061646f, 0.07389900f, -0.00309547f, -0.07552027f, 
    -0.07577302f, 0.03302243f, 0.10546359f, -0.03978416f, -0.06483494f, 0.00038552f, 0.00893364f, 0.14729072f, 
    0.05437602f, -0.05118183f, -0.12347971f, -0.18527213f, -0.02686481f, -0.12139175f, -0.09882178f, -0.02531141f, 
    -0.01673028f, -0.12194781f, 0.06292000f, 0.10404810f, 0.26561069f, -1.16457975f, 0.01611320f, -0.71820682f, 
    0.14763521f, -0.04830346f, 0.05677698f, -0.15965158f, 0.18509105f, 0.02805749f, -0.01545198f, 0.04913161f, 
    -0.11291243f, -0.01612610f, 0.24256304f, -0.11918741f, 0.05228096f, -0.11542723f, 0.10436725f, 0.04155351f, 
    -0.00125393f, 0.08158699f, 0.07183512f, 0.06109279f, -0.06247628f, 0.02075397f, 0.06048623f, -0.03416142f, 
    -0.03471993f, -0.06402601f, 0.07723488f, 0.01815139f, 0.00356813f, 0.01001502f, -0.04906692f, -0.15290847f, 
    -0.04629605f, 0.09591652f, 0.00246626f, 0.01309171f, -0.15280025f, -0.21452625f, -0.30824339f, 0.02479446f, 
    0.03172358f, 0.07511839f, 0.03270335f, 0.06455427f, -0.01809074f, 0.03621303f, -0.13781369f, -0.00151132f, 
    -0.05388439f, -0.04122577f, -0.10587945f, 0.05033351f, 0.02470399f, 0.11377904f, -0.16020961f, -0.05110044f, 
    0.53531140f, -0.67448121f, 0.05157979f, 0.30156967f, 0.05150310f, 0.03762223f, 0.00390851f, -0.05579694f, 
    0.23910739f, 0.22264795f, -0.00482995f, 0.04430636f, -0.06573959f, -0.13334191f, 0.05304688f, -0.01519289f, 
    0.06236883f, -0.22994182f, 0.19594319f, -0.00369906f, -0.03545558f, 0.05956180f, 0.07637625f, -0.00867012f, 
    -0.02106098f, 0.00907920f, -0.02528121f, -0.02403895f, -0.00759462f, -0.07362387f, 0.04889729f, -0.05683266f, 
    -0.05741628f, -0.04470311f, -0.11630283f, 0.03674727f, 0.03384922f, -0.05373487f, 0.11245168f, -0.00733872f, 
    -0.94196618f, -0.55374330f, 0.94501179f, -0.21626714f, 0.45351610f, 0.16463298f, -0.17884074f, 0.11581577f, 
    -0.03627041f, -0.22099683f, -0.15928634f, 0.13091518f, 0.06364598f, -0.10752850f, -0.16237123f, 0.06804042f, 
    -0.02976360f, 0.16242561f, -0.23287773f, 0.03812490f, -0.43841800f, -0.27528968f, -0.15570547f, 0.52454990f, 
    -0.34316045f, 0.04749985f, 0.11047111f, 0.02404821f, -0.08958328f, 0.07089785f, 0.00189770f, 0.08060082f, 
    0.05080839f, 0.03282873f, 0.02599448f, 0.05274699f, 0.01730316f, -0.08325640f, -0.03052050f, 0.00837201f, 
    -0.41123295f, -0.45901525f, 0.33963957f, 0.06214780f, 0.30123740f, 0.10432571f, -0.01152738f, 0.09323578f, 
    0.02659486f, 0.17642789f, -0.02141566f, -0.02663814f, -0.06879352f, 0.01177226f, -0.03023677f, 0.13222010f, 
    0.09956672f, 0.09963541f, 0.06754030f, -0.09560329f, 0.40116465f, -0.58500695f, -0.42157412f, 0.31122458f, 
    -0.12908392f, 0.18649164f, 0.00188304f, 0.07808734f, -0.14138871f, -0.00984177f, 0.05706425f, 0.09637102f, 
    0.15973347f, -0.01859018f, -0.02443421f, -0.01843063f, 0.01567012f, 0.04743141f, -0.12750538f, -0.15753798f, 
    0.13658273f, -0.02745044f, -0.13174464f, -0.16055845f, -0.03981508f, 0.02722877f, -0.01607511f, 0.05636792f, 
    -0.02647379f, 0.04287152f, -0.05456021f, 0.08239105f, -0.01085767f, 0.13565059f, 0.09739153f, 0.03199887f, 
    0.01186899f, 0.01865495f, 0.03356608f, 0.00078659f, -0.08463193f, 0.13631070f, -0.02819890f, 0.01314033f, 
    -0.18280861f, 0.02827439f, 0.06913874f, 0.01986793f, -0.02932569f, -0.03879359f, 0.03414804f, -0.02006663f, 
    0.07971326f, -0.00112643f, 0.00815340f, 0.07742120f, -0.00034220f, -0.05551277f, -0.15284811f, -0.15716222f, 
    0.23447888f, 0.10846508f, -0.14355481f, -0.07931405f, -0.14793183f, 0.05032310f, 0.01552012f, 0.02857810f, 
    -0.07262026f, -0.09530713f, -0.18415979f, -0.26693451f, 0.05464939f, 0.04603974f, -0.08583214f, -0.01698847f, 
    -0.01733080f, 0.01016687f, -0.00588995f, -0.04666908f, -0.04951138f, 0.20649041f, -0.13917290f, 0.14295308f, 
    -0.10740262f, 0.08740145f, 0.11332604f, -0.02124473f, -0.05867096f, -0.04054575f, 0.03001845f, 0.08034898f, 
    0.04461601f, 0.01949100f, 0.01348578f, 0.02454352f, 0.12854962f, -0.21061659f, -0.15285420f, 0.05455985f, 
    -0.03850468f, -0.37989965f, -0.69074827f, 0.37000331f, -0.29417327f, 0.00628544f, 0.08176529f, -0.03758727f, 
    -0.10107631f, -0.05468798f, 0.04557735f, -0.09421533f, 0.07508899f, 0.00083103f, 0.03597680f, 0.04482267f, 
    0.02363846f, 0.01479016f, -0.20697376f, -0.01094383f, -0.04715892f, -0.01567250f, -0.09516803f, 0.09365559f, 
    -0.13400324f, 0.03216619f, 0.03625009f, 0.13584106f, -0.01142074f, -0.04673261f, -0.11543352f, -0.09232355f, 
    -0.17060156f, -0.06202781f, 0.03179999f, -0.08626872f, -0.02698067f, -0.15052265f, 0.03144849f, 0.10536478f, 
    -0.24296594f, -0.20036945f, -0.02640552f, -0.05979814f, 0.03093141f, 0.01655659f, -0.03812977f, 0.12593994f, 
    0.06605149f, 0.03004585f, -0.21829525f, 0.08891530f, 0.01718995f, 0.09262354f, -0.00891943f, -0.00041800f, 
    -0.00509360f, 0.02896939f, -0.08722541f, -0.03156604f, -0.10233828f, 0.16626991f, -0.02528714f, 0.06389609f, 
    -0.23570278f, -0.01750915f, 0.05823410f, -0.18638282f, -0.03570756f, -0.03392087f, 0.04290161f, 0.00506594f, 
    0.01393207f, 0.00357629f, -0.03098518f, -0.10638382f, -0.14468633f, 0.03613971f, -0.02155214f, -0.01934414f, 
    0.26680189f, -0.21622303f, -0.58029073f, -0.02469617f, -0.35180697f, 0.03097701f, 0.06311507f, -0.11526851f, 
    0.08504531f, 0.07692156f, -0.13850474f, -0.01751766f, -0.09465761f, -0.18114947f, -0.29840368f, -0.02969576f, 
    -0.04578047f, -0.10926619f, 0.01284683f, 0.15431002f, 0.50833571f, 0.30310699f, -0.29121116f, -0.08062768f, 
    -0.20173001f, 0.16062932f, -0.07608973f, -0.11620218f, -0.03860596f, -0.04672540f, 0.07370485f, 0.03481045f, 
    0.04431871f, 0.04486450f, -0.03965865f, -0.00510013f, 0.00175167f, 0.04439359f, 0.03057816f, -0.04635366f, 
    -0.01157766f, -0.34596425f, -0.48521155f, 0.04618009f, -0.26317355f, 0.11066195f, 0.05473947f, -0.13048193f, 
    0.05416488f, 0.02180841f, 0.02781171f, -0.06522711f, -0.14930862f, -0.01540650f, -0.02508639f, -0.16901973f, 
    0.09289143f, -0.07706441f, 0.05577461f, 0.05366379f, 0.30148849f, -0.30284843f, -0.24136268f, 0.16508371f, 
    0.01217395f, 0.30553025f, -0.04592945f, 0.08930148f, -0.08645099f, 0.11098327f, 0.09268115f, 0.11081666f, 
    0.15776458f, 0.01856159f, -0.00559671f, 0.02792438f, -0.00796374f, 0.03539548f, -0.11777694f, -0.01696063f, 
    -0.39495251f, -0.39695358f, -0.03468047f, 0.47798893f, 0.02776304f, 0.08059467f, 0.09740245f, -0.14156199f, 
    -0.03505872f, 0.08248927f, 0.06628579f, -0.01114531f, -0.07824633f, 0.02008695f, -0.03557237f, 0.04380479f, 
    -0.00484920f, -0.07695849f, 0.02386437f, 0.00289923f, -0.00557236f, 0.00609501f, 0.10716175f, 0.21174383f, 
    -0.03141204f, -0.02969584f, -0.02395945f, -0.12186802f, -0.07933848f, -0.08391212f, 0.00706983f, -0.01127063f, 
    -0.00154750f, 0.06480448f, 0.01031043f, -0.02857295f, 0.01801956f, -0.01655593f, 0.00768170f, -0.06164929f, 
    -0.07676655f, 0.12709510f, -0.07940792f, 0.00997106f, 0.05249637f, 0.07953130f, -0.06123329f, 0.00200957f, 
    -0.00421788f, -0.02331334f, 0.13740797f, -0.01148390f, 0.08516006f, 0.02669307f, 0.07909309f, 0.00222721f, 
    -0.04778962f, -0.00457213f, -0.04816954f, 0.03775870f, 0.02466708f, 0.06593388f, 0.10831539f, -0.02767413f, 
    -0.02517111f, -0.02093850f, 0.02556461f, -0.03765994f, 0.03227520f, -0.04817910f, 0.07373394f, -0.01020695f, 
    0.03254060f, -0.06317853f, -0.06214965f, -0.01130976f, -0.15200205f, 0.05818795f, 0.05513436f, 0.02839383f, 
    0.22318527f, 0.18078716f, -0.05746283f, 0.00124217f, -0.13919513f, 0.16230215f, 0.00210194f, -0.03950690f, 
    -0.02525457f, -0.03786359f, -0.14239444f, 0.07812487f, -0.17591268f, -0.13151412f, 0.05099368f, -0.03008676f, 
    -0.03831642f, -0.02796082f, -0.09890442f, -0.07014921f, 0.69769078f, -0.90373218f, -0.87699050f, -0.78235275f, 
    -0.25252756f, -0.06201099f, -0.20155120f, 0.03364487f, 0.33565462f, 0.00656709f, 0.00890471f, 0.07191546f, 
    0.04196966f, -0.02106944f, -0.00061785f, -0.06603501f, -0.05690841f, 0.04585573f, -0.02536569f, -0.03983747f, 
    0.01528634f, 0.08720383f, -0.08393805f, 0.06328878f, -0.15005660f, -0.00227674f, 0.04490740f, 0.00051610f, 
    -0.03413903f, -0.10409002f, 0.03531713f, 0.02821778f, 0.01704018f, 0.02946597f, -0.04600051f, -0.12206462f, 
    -0.24074176f, 0.17457205f, 0.01059838f, -0.00568656f, 0.59177190f, -0.20254424f, -0.02863849f, -0.25158125f, 
    -0.11800517f, -0.23075904f, 0.17162663f, -0.02457804f, -0.03810330f, -0.15579252f, 0.12018058f, -0.06317242f, 
    0.05572693f, 0.02474171f, -0.02276541f, 0.01846058f, -0.01908905f, 0.07360638f, -0.09110364f, 0.06367699f, 
    -0.18496245f, 0.00183912f, -0.01278629f, 0.09990989f, 0.03909037f, 0.06222043f, -0.09710073f, -0.07710716f, 
    0.11914101f, 0.15344273f, 0.08269508f, 0.00994470f, 0.04895445f, 0.00822738f, -0.00607641f, 0.09433176f, 
    -0.01639480f, -0.17119053f, 0.07916273f, 0.03919746f, 0.51401520f, -0.52884024f, 0.75687903f, -0.29668760f, 
    0.01336427f, -0.18845306f, 0.26279759f, -0.03964698f, 0.27261090f, -0.03529548f, 0.02012309f, 0.02587017f, 
    0.05409884f, -0.07065804f, -0.02811823f, 0.04023158f, 0.00082587f, -0.03257328f, -0.00934060f, 0.00573208f, 
    -0.55021495f, -0.27855086f, 0.18936497f, 0.20425081f, 0.00239099f, -0.16884826f, -0.01510368f, 0.07501885f, 
    0.02620712f, -0.02127673f, 0.03817636f, 0.10078263f, 0.07089344f, 0.02121448f, 0.03065616f, -0.11769550f, 
    0.05646215f, -0.07873173f, -0.01293044f, 0.05715999f, 0.34143040f, 0.01751002f, -0.68769747f, -0.05777577f, 
    0.15376015f, 0.16024278f, -0.10537397f, 0.11793743f, 0.24825650f, 0.00705188f, 0.11498101f, -0.04294663f, 
    -0.01856799f, -0.04280060f, 0.22686605f, 0.01565505f, 0.07469556f, -0.00586692f, -0.13612898f, 0.03802146f, 
    -0.38365585f, 0.08688005f, 0.20477849f, 0.13099495f, -0.01742079f, -0.11166682f, 0.01186876f, 0.01550754f, 
    0.00276460f, -0.04755025f, -0.07336529f, -0.00283372f, 0.09102124f, -0.03127459f, 0.05649773f, -0.00365106f, 
    0.01903318f, -0.06706074f, 0.03529407f, 0.04486536f, 0.38825113f, -0.06432398f, -0.22352348f, 0.14651857f, 
    0.10919813f, 0.12741165f, 0.04983541f, 0.06697015f, -0.11541984f, 0.09550773f, 0.07099533f, -0.02955925f, 
    0.03316483f, 0.13386531f, -0.08287759f, -0.03679565f, -0.01496017f, 0.07277071f, 0.12595391f, -0.05000510f, 
    -0.16402832f, 0.08723629f, -0.70406729f, -0.70290053f, -0.47449148f, -0.08347031f, -0.37786713f, -0.06238282f, 
    -0.13772328f, -0.35118052f, -0.00632777f, -0.00938752f, -0.02963496f, 0.11023255f, 0.03922318f, 0.09174548f, 
    0.03346632f, 0.10082811f, -0.15736867f, -0.39823610f, -0.16949554f, -0.00466523f, 0.09744385f, 0.00469588f, 
    -0.17587116f, -0.05847461f, -0.02568956f, -0.06083807f, -0.04235095f, 0.04862264f, 0.01820615f, -0.00093850f, 
    0.03736524f, 0.15777694f, 0.15193328f, -0.04891403f, 0.08805475f, 0.04033247f, -0.02773635f, 0.03968932f, 
    0.11102089f, -0.83561879f, -0.13135065f, 0.30336383f, 0.13761243f, 0.06164673f, 0.29547232f, -0.14535661f, 
    -0.09419236f, 0.00761924f, 0.10717562f, 0.04293819f, 0.00429925f, 0.03817327f, 0.01875960f, 0.02095755f, 
    0.13027102f, -0.24876297f, 0.14480478f, -0.04384904f, 0.93095201f, 0.18048832f, 0.08236486f, -0.30421680f, 
    -0.22936630f, 0.11617744f, -0.17210491f, -0.23321038f, -0.01832657f, -0.31541806f, 0.01037561f, 0.00011328f, 
    0.00590905f, -0.01931551f, -0.00632527f, 0.01648242f, 0.04793093f, -0.01933219f, -0.05395795f, -0.15645397f, 
    0.16747648f, -0.46434534f, 0.04823284f, -0.14808796f, -0.28479618f, -0.11049189f, -0.26982111f, 0.01405087f, 
    -0.26472685f, -0.39052773f, 0.03520923f, 0.00969338f, 0.04393883f, -0.00728876f, 0.00456678f, 0.16971841f, 
    0.02809381f, 0.15922563f, -0.08218125f, -0.46404222f, 0.47385636f, -0.19238035f, -0.35404256f, -0.13726234f, 
    0.00227637f, -0.00933378f, 0.00277888f, -0.03101327f, -0.03546450f, 0.07397862f, 0.02032311f, -0.05366915f, 
    0.02975855f, 0.00681273f, 0.00968820f, -0.00932718f, 0.01767253f, 0.01427521f, 0.21159700f, 0.06686123f, 
    -0.15560086f, -0.32445717f, -0.29150352f, -0.14894129f, 0.08141965f, -0.01455722f, 0.07267468f, 0.08544368f, 
    0.14968376f, 0.12669015f, 0.09793074f, 0.01081511f, -0.09039379f, -0.12882997f, -0.06831867f, -0.01676943f, 
    0.03819137f, 0.03607387f, 0.06548872f, -0.02008805f, -0.84589636f, 0.05929106f, 0.38709417f, 0.20392413f, 
    -0.20120823f, -0.04835602f, -0.10026192f, -0.06481293f, -0.06052328f, -0.08835199f, -0.08094767f, -0.09008655f, 
    -0.01191858f, -0.09770905f, -0.09442347f, -0.02870030f, -0.23011068f, -0.16396850f, -0.22652099f, -0.11832868f, 
    0.16843006f, -0.11756769f, -0.03685531f, -0.12108798f, -0.08772531f, -0.09265687f, 0.07146127f, 0.01735721f, 
    0.00168042f, -0.02837935f, 0.09482182f, 0.07428805f, -0.01056388f, 0.02274393f, -0.02137302f, 0.07246161f, 
    0.12468093f, 0.05346860f, 0.06141684f, 0.13156925f, -0.25478137f, 0.32839125f, 0.24773951f, 0.23255166f, 
    -0.12817444f, -0.03632723f, -0.21128105f, -0.04988301f, -0.06506241f, -0.14150801f, -0.07362698f, -0.10347953f, 
    0.00166365f, -0.07281553f, -0.02876166f, -0.19627497f, -0.26319233f, -0.31816784f, -0.04322908f, -0.11470380f, 
    0.58927095f, -0.22991650f, -0.20574272f, -0.12124941f, -0.07197254f, -0.06434096f, -0.07040946f, -0.01337021f, 
    0.02608604f, -0.15984231f, -0.00463901f, 0.08962918f, 0.05104097f, -0.01776725f, -0.06988990f, 0.01457802f, 
    0.01814782f, 0.08453166f, 0.15274058f, 0.22674130f, -0.32299852f, -0.14098220f, 0.20049182f, 0.00611746f, 
    0.01690187f, -0.12788528f, 0.01848309f, -0.02527031f, -0.08903474f, -0.00813759f, 0.04370657f, 0.11717465f, 
    -0.01795356f, 0.15281911f, 0.09453916f, 0.02115831f, -0.01819926f, 0.04837567f, -0.01262864f, -0.07636445f, 
    -0.09729344f, -0.37062910f, -0.13639681f, 0.05179507f, 0.22319983f, 0.11842524f, 0.12821093f, 0.05467812f, 
    -0.09704611f, 0.14090769f, 0.07416856f, 0.05150310f, -0.00113276f, 0.13410258f, -0.03198620f, -0.02697445f, 
    0.05858698f, 0.01600797f, 0.08431479f, 0.05448280f, -0.15086126f, 0.28155005f, 0.15087812f, 0.15636688f, 
    -0.14081813f, 0.09413570f, -0.02324751f, 0.05320266f, 0.04130554f, -0.20405008f, -0.05434695f, 0.01449338f, 
    0.01666755f, 0.00631917f, -0.00454332f, -0.01762844f, 0.01986613f, 0.03982231f, 0.01278181f, 0.02625117f, 
    0.19135310f, 0.36902091f, 0.06046959f, 0.06971997f, -0.24953382f, -0.08930488f, 0.01095041f, -0.15791357f, 
    0.07686266f, -0.04523633f, 0.09547780f, 0.03481984f, -0.00578384f, 0.16197358f, 0.08652434f, -0.11090320f, 
    0.02352666f, -0.01501854f, -0.19499496f, -0.38770348f, 0.03948149f, -0.32060763f, -0.42800969f, -0.38392889f, 
    -0.14607093f, -0.10615558f, 0.13762723f, 0.07629988f, 0.08011291f, 0.17990123f, 0.09601589f, -0.07547987f, 
    -0.03647082f, -0.07878832f, -0.01121918f, 0.03141935f, 0.01608266f, -0.05516639f, 0.14206168f, -0.03539038f, 
    0.29446855f, 0.02949317f, -0.41942412f, -0.08624218f, 0.16482121f, 0.17147070f, 0.14223264f, 0.05863060f, 
    0.22097637f, 0.07255944f, 0.01337499f, -0.03654954f, -0.04435261f, 0.08465029f, 0.06454819f, 0.06732102f, 
    -0.14116870f, -0.25389835f, -0.17379555f, -0.36025280f, 0.27252886f, -0.05539415f, -0.20205994f, 0.06976476f, 
    -0.08759409f, -0.15143339f, -0.15812294f, -0.05253236f, -0.07899530f, -0.02725415f, -0.02286393f, -0.03685638f, 
    0.02915620f, -0.02999455f, 0.06727589f, -0.11433251f, 0.04123161f, 0.07036699f, 0.13921723f, 0.03844643f, 
    0.36926913f, 0.02596042f, -0.03242961f, -0.05309962f, 0.09572464f, 0.04689161f, -0.20813949f, -0.04918192f, 
    -0.05985666f, -0.02349585f, 0.02789295f, 0.02652081f, 0.07194161f, 0.10879596f, -0.00289708f, 0.15400916f, 
    0.04783087f, -0.01570771f, 0.04337422f, -0.08602887f, -0.05925993f, 0.16114582f, 0.24962513f, 0.11481711f, 
    -0.02121039f, 0.03677367f, -0.07972354f, -0.00705684f, 0.04976909f, -0.04454244f, -0.01927966f, -0.04941836f, 
    -0.00352610f, -0.04973861f, -0.04627109f, -0.02334051f, 0.10592044f, -0.05766676f, -0.08544979f, -0.24026896f, 
    -0.32821023f, -0.01775278f, 0.11328667f, 0.02680960f, 0.10394672f, -0.07666279f, 0.00866443f, -0.06057401f, 
    0.00893644f, -0.05551491f, -0.03461152f, -0.09201135f, 0.08564954f, 0.11840870f, -0.02880400f, -0.03240395f, 
    -0.00995280f, 0.07709455f, 0.18244539f, 0.04665824f, -0.18337873f, 0.04770590f, 0.04191221f, 0.07347091f, 
    -0.08889336f, -0.00880184f, -0.04399005f, -0.04008781f, -0.05750272f, -0.08298720f, -0.07058264f, -0.04602343f, 
    0.01464114f, 0.00601177f, 0.04789263f, -0.01426144f, 0.11913334f, 0.07621119f, 0.02283631f, 0.09048048f, 
    0.12240200f, 0.04338015f, -0.12246160f, -0.23254110f, -0.10787002f, -0.00664801f, 0.08813914f, -0.00433761f, 
    -0.00703961f, -0.16487730f, -0.05045934f, -0.02004377f, 0.17258526f, 0.03261328f, 0.16567358f, -0.08248112f, 
    0.01728124f, -0.04114832f, 0.13447794f, 0.08006202f, -0.23091146f, -0.77515900f, -1.17831886f, -0.78383112f, 
    0.08282890f, 0.00364202f, 0.13147649f, 0.13898341f, 0.20300545f, 0.14782996f, -0.02160978f, -0.06413885f, 
    -0.06455922f, -0.02530048f, -0.03620016f, 0.04348819f, -0.05547095f, -0.02150064f, 0.01719758f, 0.03413580f, 
    -0.10237767f, 0.19069161f, 0.05206916f, 0.05131074f, -0.23927408f, -0.05850693f, 0.02991595f, 0.03165170f, 
    0.00312906f, -0.02064284f, -0.07818463f, -0.03222631f, -0.06057980f, 0.10271987f, 0.02260908f, 0.05168154f, 
    0.20193405f, 0.10106972f, 0.05708421f, 0.02601438f, 0.14583386f, -0.24601747f, -0.27148086f, -0.04703445f, 
    -0.11648976f, -0.10931411f, -0.12861830f, 0.12675162f, 0.10003997f, 0.19680075f, -0.04660083f, 0.05147102f, 
    -0.07066683f, -0.07152483f, 0.05267605f, -0.05838278f, 0.18792379f, 0.08811967f, 0.03937434f, 0.04477481f, 
    -0.36803126f, -0.05846105f, 0.07883356f, 0.12216066f, -0.08064552f, 0.04440711f, -0.16017179f, -0.16965608f, 
    -0.02932185f, -0.21573181f, 0.02244652f, 0.01101616f, 0.09855103f, -0.05524301f, -0.05840284f, -0.11888690f, 
    0.04078737f, 0.14900029f, 0.06304784f, 0.19295439f, -0.13264360f, -0.51836330f, -0.84125537f, -0.43662432f, 
    -0.19510917f, 0.05620187f, -0.23604929f, 0.23337317f, -0.03447769f, 0.14850107f, -0.02946209f, 0.02541071f, 
    -0.00750939f, 0.01422242f, 0.02896635f, 0.08536155f, 0.06067789f, 0.02199999f, 0.06674704f, 0.10057759f, 
    0.19884583f, -0.02011512f, 0.07536974f, -0.52544916f, 0.13602087f, -0.02674467f, -0.18215948f, -0.02055366f, 
    0.04167951f, -0.08336615f, 0.01595001f, 0.13954234f, 0.06229997f, -0.05266542f, -0.01418413f, 0.16429940f, 
    0.19822431f, -0.08663364f, -0.07991228f, 0.21242020f, -0.10651570f, -0.18698777f, 0.01068842f, 0.35494238f, 
    -0.27989012f, -0.19300675f, 0.14506873f, -0.32866088f, 0.07408430f, -0.00372040f, 0.12680422f, -0.15071753f, 
    0.13083479f, 0.03713375f, 0.07985416f, 0.06655981f, 0.08473472f, -0.02978579f, 0.01787536f, 0.06695075f, 
    -0.05855550f, -0.18501633f, -0.10331264f, -0.18053167f, 0.10186128f, -0.01672308f, 0.12305194f, 0.13496891f, 
    -0.03016740f, 0.09831505f, -0.01497806f, 0.07032441f, -0.03835078f, 0.03822012f, 0.07677370f, 0.00483459f, 
    0.06231372f, 0.06305370f, -0.02323895f, 0.05296240f, -0.27701572f, 0.13901612f, 0.23231804f, -0.00591668f, 
    -0.28016618f, 0.04050070f, -0.24909697f, 0.10764877f, -0.22110063f, -0.08137766f, -0.07553262f, 0.06836754f, 
    0.00763225f, -0.05873445f, -0.00830744f, -0.03379309f, -0.04198027f, -0.01490881f, -0.04393355f, -0.16508801f, 
    -0.78705633f, -0.28103247f, -0.28118488f, 0.22855550f, -0.61574090f, 0.00803897f, -0.17849953f, 0.02569787f, 
    -0.15396853f, 0.21809740f, 0.07700021f, 0.05570987f, 0.07354029f, 0.04993624f, -0.02129876f, 0.01740506f, 
    0.02245041f, 0.09781495f, 0.16623934f, -0.06751256f, -0.04563165f, -0.13104637f, 0.04846383f, -0.07979027f, 
    0.13809437f, 0.05805426f, 0.02458487f, -0.06402271f, 0.00180483f, -0.07878327f, 0.08200460f, 0.07143252f, 
    0.08577756f, 0.05005034f, -0.04182272f, 0.06496267f, -0.08297485f, -0.05010392f, -0.01951609f, 0.12674890f, 
    -0.14590298f, -0.13116436f, 0.06250890f, -0.98738587f, -0.08835715f, -0.08411272f, -0.19499139f, -0.04331574f, 
    -0.10723273f, -0.08038888f, -0.06867994f, -0.05331605f, -0.01295070f, 0.10556799f, -0.14945917f, -0.19516575f, 
    -0.06738697f, -0.03393583f, -0.20481046f, -0.07323938f, -0.04236482f, 0.41571620f, -1.37835240f, 0.29357716f, 
    -0.28848311f, 0.07780398f, 0.01902504f, 0.07307801f, -0.22136967f, 0.12576644f, 0.02613980f, -0.05385085f, 
    -0.06312882f, 0.03062132f, -0.11317649f, 0.05413398f, -0.01189689f, -0.06437560f, 0.11910390f, -0.05196467f, 
    0.33526385f, -0.81324667f, -0.05178285f, 0.01868291f, 0.05348965f, -0.11098814f, -0.18625657f, 0.00874939f, 
    -0.01077752f, 0.23120508f, -0.05051859f, 0.09677469f, 0.02293848f, 0.01924366f, -0.02581961f, -0.03874549f, 
    0.01793632f, 0.18908972f, -0.03578182f, 0.07891093f, -0.12143279f, 0.17811669f, 0.13087143f, 0.19903351f, 
    -0.24804406f, 0.09906740f, -0.17899632f, 0.04432374f, 0.01667986f, -0.03041410f, -0.02863539f, -0.07896942f, 
    0.02911314f, -0.03714555f, -0.02447692f, 0.05423255f, -0.03873561f, -0.08939519f, 0.06001237f, -0.08330658f, 
    0.39624861f, 0.08001495f, 0.48877925f, 0.24702142f, -0.31336793f, 0.10672858f, -0.17784634f, -0.31297287f, 
    -0.23854780f, -0.14748241f, 0.06658366f, 0.09310242f, 0.08452621f, 0.12153620f, 0.03817445f, 0.03795932f, 
    -0.04937921f, -0.04844693f, -0.05304652f, 0.04579758f, -0.02931519f, -0.34921280f, -0.28145978f, -0.02906646f, 
    0.10453241f, 0.08681201f, -0.00283625f, 0.13536626f, 0.05571043f, 0.16001895f, -0.01828784f, -0.00131434f, 
    -0.05450685f, 0.05157354f, 0.00599028f, -0.01642929f, 0.08011950f, 0.02932039f, -0.11854232f, 0.02536661f, 
    -0.22039536f, 0.16317384f, 0.04838510f, 0.20063300f, 0.09780481f, -0.01297575f, 0.01227942f, -0.13509053f, 
    -0.07610896f, -0.07848428f, 0.13491608f, 0.06615538f, 0.05586198f, -0.06090812f, 0.02521768f, 0.03748894f, 
    0.00403845f, -0.11310155f, 0.01232870f, -0.04740615f, -0.24539155f, -0.23719695f, -0.69519705f, 0.05258221f, 
    -0.01941610f, 0.05056251f, 0.05056453f, 0.23347877f, -0.02047583f, 0.07820142f, -0.00002848f, 0.02010575f, 
    -0.01569029f, 0.05871953f, -0.04463027f, 0.00868150f, 0.28135273f, -0.07397623f, -0.05848113f, 0.25843114f, 
    -0.21258901f, 0.43140027f, -0.16881676f, 0.05625923f, -0.20184577f, 0.03053299f, -0.22087766f, 0.05543002f, 
    0.01557525f, 0.08308923f, 0.05292414f, 0.03099120f, 0.04977199f, -0.10173222f, -0.01902688f, 0.03242170f, 
    -0.04069468f, -0.11096819f, 0.07101612f, -0.25809532f, 0.06400434f, -0.08512776f, -0.00997838f, 0.07291716f, 
    0.06497969f, 0.02686174f, -0.11276872f, -0.00937537f, -0.01017281f, -0.15658680f, -0.04527262f, 0.07792332f, 
    0.05333514f, 0.08787056f, -0.07946047f, 0.10073622f, 0.12962918f, 0.03391230f, -0.08010019f, 0.04773149f, 
    -0.11261663f, -0.02075448f, 0.56081986f, -0.16737315f, -0.33133587f, 0.04136183f, -0.32836059f, 0.05616339f, 
    -0.00171114f, 0.00909366f, -0.03093491f, 0.05805628f, 0.01784880f, 0.00223276f, 0.03801667f, -0.02245241f, 
    -0.02404999f, -0.03426667f, -0.09855542f, 0.01997007f, -0.12850741f, 0.25355583f, -0.70448261f, 0.14905529f, 
    0.01377600f, 0.10435119f, 0.07156444f, 0.17065085f, 0.05241686f, 0.06364425f, 0.00522129f, 0.02313011f, 
    -0.06775645f, 0.03541008f, -0.07320428f, 0.02449993f, 0.07614203f, -0.04265569f, 0.01746694f, 0.04909326f, 
    -0.84407049f, -0.05128293f, -0.23536545f, 0.29810274f, 0.10098165f, -0.08982994f, 0.17810550f, -0.19513711f, 
    0.15893041f, 0.03089188f, 0.12519883f, -0.10201012f, 0.05860984f, -0.05779865f, 0.03713857f, 0.19022642f, 
    0.07651117f, -0.00241258f, 0.06498916f, 0.04706482f, -0.28780952f, 0.35812873f, 0.16505358f, 0.52582824f, 
    -0.31288806f, 0.15311871f, -0.13590573f, -0.23185541f, -0.12129311f, -0.44092691f, 0.17089245f, 0.00124405f, 
    0.02596029f, 0.04503005f, 0.08428162f, 0.02947699f, -0.03944250f, -0.10335944f, 0.04790942f, 0.02460530f, 
    -0.06631996f, 0.19836755f, -0.02101365f, 0.47613394f, -0.42655316f, 0.17205553f, -0.15423700f, -0.02654264f, 
    -0.05842004f, 0.08534674f, 0.06172364f, 0.00875588f, -0.00261064f, 0.03271599f, 0.10987230f, -0.07617982f, 
    -0.04355466f, 0.22058652f, 0.19573055f, 0.19648132f, -0.20142458f, 0.02151719f, -0.00027029f, 0.17121576f, 
    -0.06622683f, 0.09913556f, 0.07175095f, -0.14128323f, -0.01154075f, -0.08965680f, -0.05350466f, -0.06850138f, 
    -0.09778949f, 0.01040266f, -0.01495869f, 0.10820041f, -0.01396383f, -0.08019559f, -0.06762098f, -0.10693911f, 
    0.06468913f, 0.04706878f, -0.32581881f, 0.06818041f, -0.27821264f, 0.04736892f, -0.01313401f, 0.05639019f, 
    0.06901838f, 0.06623248f, -0.01418919f, 0.05009999f, 0.02803314f, -0.00720874f, 0.02357817f, -0.05843786f, 
    0.06455200f, 0.06847858f, 0.07003253f, -0.02004325f, -0.19345348f, -0.44639936f, -0.42029905f, 0.06315798f, 
    0.04070748f, 0.09738927f, 0.02427742f, 0.11764164f, 0.02864421f, 0.04863260f, 0.01722616f, -0.03218083f, 
    -0.01882823f, 0.08198549f, 0.00460761f, -0.00992894f, 0.06095766f, 0.13405135f, 0.10278052f, 0.21968602f, 
    -0.30724734f, 0.22778079f, 0.14433181f, -0.27479729f, -0.04163672f, -0.01611357f, 0.06412303f, -0.01834936f, 
    -0.00879936f, 0.04244043f, 0.06666281f, 0.06094956f, -0.13027672f, -0.16475816f, 0.00818296f, 0.10657969f, 
    0.13245058f, -0.18643486f, 0.02969402f, -0.00136208f, -0.01601490f, -0.12245417f, -0.18284033f, -0.05527518f, 
    -0.03500591f, 0.04341423f, 0.13423668f, 0.25490472f, 0.07862285f, 0.01365439f, 0.03161778f, -0.01738770f, 
    -0.05768978f, -0.09368300f, -0.07304946f, 0.11991043f, 0.04151152f, 0.07705403f, 0.05290341f, 0.02819224f, 
    -0.51000118f, -0.01741379f, -0.11849378f, 0.23349854f, 0.10322388f, -0.05181507f, 0.11391103f, -0.21701732f, 
    -0.00550729f, -0.04760964f, -0.00879741f, 0.09345101f, -0.00197152f, -0.01756073f, 0.05220921f, -0.05622439f, 
    -0.14371751f, -0.14985947f, -0.08573318f, 0.00185260f, -0.04901679f, -0.08394387f, 0.35815543f, 0.63180238f, 
    -0.96958101f, 0.26059988f, -0.18386252f, -0.32390210f, 0.03113346f, 0.07980112f, 0.07545259f, -0.07397434f, 
    0.08764099f, 0.09876781f, 0.05512390f, -0.03686329f, 0.04249323f, -0.00189722f, 0.04650423f, 0.05234409f, 
    -0.23498936f, 0.03454277f, -0.26525724f, -0.03881310f, 0.00869054f, 0.16482526f, 0.11265780f, 0.09924979f, 
    0.04251511f, -0.11179665f, 0.06609862f, -0.04101602f, -0.03018419f, 0.07974422f, -0.05181631f, 0.07717542f, 
    -0.10921575f, 0.03349022f, -0.02266500f, 0.01734828f, -0.17065190f, 0.12477345f, -0.01276078f, -0.04571555f, 
    -0.15700020f, -0.26247907f, 0.14616324f, -0.14786202f, -0.08029780f, 0.12083923f, -0.01980302f, 0.00602328f, 
    0.03670385f, -0.03116696f, -0.00728652f, 0.04501744f, -0.11669379f, -0.08992364f, -0.03182277f, -0.16675092f, 
    0.00967113f, 0.27991462f, -0.37986442f, 0.01819341f, -0.22037610f, -0.01478366f, 0.06219405f, 0.23307869f, 
    0.07367070f, 0.17514287f, -0.02571605f, -0.01990776f, -0.11169420f, -0.15692392f, -0.10183095f, 0.08074077f, 
    -0.00599130f, -0.07138208f, 0.01281847f, -0.21591963f, -0.16448264f, -0.23341987f, -0.17738810f, -0.10225306f, 
    -0.07812604f, -0.48789582f, 0.11947621f, 0.09617288f, 0.11712659f, 0.17544599f, 0.07402930f, 0.00120588f, 
    0.00218371f, -0.02129758f, 0.00000407f, -0.05319761f, 0.05529139f, -0.00765522f, -0.06988187f, -0.20166750f, 
    0.14530584f, 0.21641789f, 0.38630271f, 0.31032410f, -0.01368122f, 0.07874355f, 0.05101290f, 0.07213433f, 
    -0.13241465f, 0.12680918f, -0.12990737f, 0.13052693f, 0.05444800f, 0.06031830f, -0.29088953f, -0.24042390f, 
    -0.03379205f, 0.04455982f, -0.06225858f, -0.05850489f, -0.09106082f, 0.19829129f, -0.40590101f, 0.28964207f, 
    0.26074874f, 0.13896008f, -0.01056063f, 0.08172061f, -0.11635716f, 0.02255175f, -0.24526715f, 0.06451266f, 
    -0.19194946f, -0.15984766f, 0.03726176f, -0.01495725f, -0.13637969f, -0.22354224f, 0.01394506f, 0.13026142f, 
    0.10988107f, -0.19359124f, 0.35012320f, 0.23962158f, -0.21967395f, -0.11261327f, -0.19465877f, 0.12706955f, 
    -0.13449767f, -0.14509641f, 0.02664173f, 0.03036656f, -0.15963821f, 0.11098994f, 0.03253688f, 0.11060079f, 
    0.03121592f, 0.00953095f, -0.08624266f, 0.05052646f, -0.55257541f, -0.05914040f, 0.13715339f, 0.07777058f, 
    0.03669093f, 0.04795199f, 0.00165058f, -0.18057804f, 0.32942951f, -0.10087412f, -0.00954728f, -0.11602863f, 
    0.00033112f, 0.00742313f, 0.13687189f, 0.09572483f, 0.03592717f, -0.14794290f, 0.19300438f, -0.05429595f, 
    -0.27675664f, 0.13649952f, -0.75065708f, -0.14617902f, 0.08112852f, -0.01156505f, -0.20511471f, -0.04132912f, 
    0.04861346f, -0.00876516f, -0.12859036f, 0.09833186f, 0.13060886f, 0.07212721f, 0.10911252f, 0.11013123f, 
    -0.03837515f, -0.18645911f, -0.07133276f, -0.19792388f, -0.25123382f, -0.27708709f, -0.18851607f, -0.17006606f, 
    -0.28543314f, -0.12727852f, -0.20837989f, -0.10002533f, 0.24734189f, 0.08541818f, -0.22340369f, -0.02434498f, 
    -0.03509124f, -0.02927125f, -0.07243709f, -0.02565655f, 0.08851594f, -0.03901836f, 0.15933022f, 0.17243603f, 
    -0.59297073f, 0.37373987f, 0.42157912f, 0.43922508f, 0.09653272f, 0.19110978f, 0.15647121f, -0.26246795f, 
    0.06290254f, 0.09904291f, -0.19271438f, -0.13643077f, -0.06741723f, -0.00415064f, 0.07949182f, -0.08149312f, 
    0.11208611f, 0.11303472f, 0.14870355f, 0.15260053f, -0.32652643f, -0.36186212f, 0.07906943f, -0.18707398f, 
    0.22286436f, -0.03695456f, -0.18246511f, 0.12838471f, -0.04592561f, 0.09036211f, -0.03385427f, 0.17207533f, 
    0.01052189f, 0.01879146f, 0.04935535f, 0.04828349f, -0.06821984f, -0.06879742f, -0.12255813f, -0.19830635f, 
    -0.34830895f, -0.17684452f, -0.71812260f, 0.11333825f, -0.10247359f, -0.00809947f, -0.12722807f, 0.03869548f, 
    -0.19144575f, -0.13839678f, 0.03226508f, 0.12481014f, -0.03206596f, 0.07450035f, -0.08826417f, 0.05333167f, 
    -0.16692735f, -0.30704185f, -0.43488199f, -0.41622752f, -0.23653640f, 0.03241961f, 0.15071316f, -0.27159882f, 
    0.07955233f, -0.11531838f, 0.04978453f, 0.01870065f, 0.18699871f, 0.00272254f, -0.10882369f, 0.13951123f, 
    -0.07077961f, 0.07641945f, 0.03818370f, 0.06156005f, 0.05262247f, 0.06420257f, 0.13087140f, 0.09616759f, 
    -0.06590725f, 0.18608031f, -0.05783692f, 0.24199364f, 0.11573358f, 0.02240563f, -0.03505123f, -0.19576320f, 
    -0.08179608f, 0.01470312f, -0.03261384f, 0.05034550f, 0.00708095f, 0.03408077f, -0.00455990f, -0.04109426f, 
    -0.10790974f, -0.09197705f, -0.01347396f, 0.05202698f, 0.05285853f, -0.21567425f, -0.05034377f, 0.09084109f, 
    -0.05828660f, -0.17178312f, 0.02388621f, 0.06543344f, -0.24722822f, -0.14714186f, 0.01827667f, -0.07748900f, 
    -0.13485971f, -0.03392080f, -0.00406951f, -0.00636970f, -0.23992079f, -0.27867493f, -0.24475507f, -0.12327593f, 
    0.40527999f, -0.31588194f, 0.20166588f, 0.00503527f, -0.18234155f, -0.02519898f, 0.03791160f, 0.18313015f, 
    0.07959168f, 0.03878563f, -0.10747667f, 0.02256645f, -0.02114465f, -0.10337803f, 0.01965077f, -0.02117519f, 
    0.05157681f, 0.13785017f, 0.10897191f, 0.15918882f, 0.08461267f, -0.46432275f, 0.01885840f, 0.31574208f, 
    0.14111343f, -0.23743342f, 0.05766628f, 0.06514834f, -0.07960968f, -0.13505533f, -0.08065131f, -0.04259960f, 
    -0.17541485f, 0.03802302f, -0.02331294f, 0.14632554f, -0.37459886f, -0.18940303f, -0.00444852f, 0.02126920f, 
    -0.52647978f, -0.20762837f, 0.22809452f, -0.12519431f, 0.05998410f, 0.01887292f, 0.12442259f, 0.29221213f, 
    0.14362904f, -0.05391581f, -0.02901831f, 0.15595213f, -0.05004446f, 0.01176267f, -0.03750251f, 0.05407705f, 
    0.14016503f, 0.14554420f, 0.20969722f, 0.13031372f, -0.27418888f, 0.13214664f, -0.01457299f, -0.07448234f, 
    -0.13067859f, 0.05020523f, -0.07303789f, -0.10362580f, 0.13500157f, -0.05060434f, 0.04762737f, 0.07165735f, 
    0.00380784f, 0.00429073f, -0.08754859f, -0.11418042f, -0.00278162f, -0.10263939f, 0.10795740f, -0.15884143f, 
    -0.37744892f, 0.16519895f, -0.08376136f, 0.13764215f, 0.00181952f, -0.02837430f, 0.03223526f, -0.15787964f, 
    0.20450257f, 0.10213280f, 0.02602127f, -0.11915919f, -0.09356409f, 0.03470923f, 0.14892530f, -0.00930418f, 
    0.01451441f, -0.11651224f, 0.09903619f, 0.08819014f, -0.08387613f, -0.38267785f, 0.09962326f, 0.07450029f, 
    -0.01007991f, -0.16419113f, -0.16876547f, 0.13027203f, -0.11982659f, -0.07301390f, -0.14093360f, 0.15007159f, 
    -0.08920775f, -0.04077976f, -0.03066025f, 0.06862943f, -0.11162360f, -0.04797680f, 0.02806247f, -0.05355147f, 
    0.48627019f, -0.00628927f, 0.53515512f, 0.15289804f, -0.02207950f, 0.12459872f, -0.08151688f, 0.14602053f, 
    0.00695075f, -0.12801965f, 0.01531971f, -0.02755653f, -0.01994899f, 0.01567589f, -0.03780036f, -0.08972377f, 
    -0.19050604f, -0.02359950f, -0.18713120f, -0.28758252f, 0.38632196f, -0.16756633f, 0.43899462f, -0.19073881f, 
    0.01260021f, -0.09867268f, -0.20061000f, 0.06908296f, 0.05205931f, 0.03551131f, -0.04825289f, 0.03810130f, 
    -0.17694658f, 0.16615769f, 0.00250892f, -0.05123838f, -0.08076755f, 0.08727302f, -0.01563556f, -0.02022931f, 
    -0.01749377f, -0.16692644f, -0.04681243f, -0.01007838f, 0.09030826f, -0.17400381f, 0.18323654f, 0.05822007f, 
    0.09172297f, -0.10605265f, -0.08306877f, 0.07727891f, -0.04856708f, 0.01335083f, -0.03675973f, 0.07172926f, 
    -0.13840301f, 0.00994023f, -0.16760790f, -0.13200180f, -0.17546375f, 0.13463934f, 0.10282119f, -0.15759316f, 
    0.11628378f, -0.00607328f, -0.03628569f, 0.14055242f, -0.00561407f, 0.14437515f, 0.00687109f, 0.05288713f, 
    -0.10322455f, 0.11736618f, -0.01179089f, 0.04831678f, 0.11764371f, 0.05732390f, 0.08991998f, 0.24895793f, 
    -0.21769090f, -0.09535939f, 0.15394141f, 0.08647146f, 0.12545241f, -0.04728789f, 0.04940865f, 0.11411168f, 
    0.07500970f, 0.11545791f, -0.00780886f, 0.06506710f, 0.03258175f, 0.07960396f, -0.04507207f, 0.09939957f, 
    -0.10928220f, -0.11656131f, 0.00111065f, -0.18677987f, -0.00351942f, -0.20281142f, -0.15115872f, 0.10669421f, 
    0.10532502f, -0.08562591f, 0.10329495f, 0.00100706f, -0.19845097f, -0.19260915f, 0.02341713f, 0.04150799f, 
    -0.00944201f, -0.02724035f, -0.06303668f, 0.21634080f, -0.25902948f, -0.24637744f, -0.24424724f, -0.15722342f, 
    0.06017461f, -0.24568373f, 0.16851638f, 0.19426204f, -0.18857506f, -0.05054573f, 0.06439271f, 0.21574238f, 
    0.02678530f, -0.13397747f, -0.02476409f, -0.06820201f, 0.06933866f, 0.14884685f, 0.05904295f, -0.11688876f, 
    -0.14855617f, 0.19551179f, -0.08418012f, 0.05923912f, -0.11075343f, -0.43302935f, -0.36382684f, 0.24658519f, 
    -0.20081614f, -0.26151124f, -0.11332139f, -0.03406332f, 0.07528220f, -0.00286646f, -0.15768139f, 0.04333273f, 
    -0.06461953f, -0.02819866f, -0.03705628f, 0.10347653f, 0.01762445f, 0.01349067f, 0.11209103f, 0.14235404f, 
    0.32761234f, 0.04263188f, 0.22028382f, -0.12586027f, -0.06332245f, -0.07155073f, -0.09371172f, 0.19473824f, 
    0.02515044f, -0.00288200f, 0.03688058f, -0.05393009f, -0.01431339f, 0.07127774f, 0.06026084f, -0.01360056f, 
    -0.13987526f, 0.12853785f, -0.03587189f, 0.03402608f, -0.30390283f, 0.08278423f, -0.14568999f, -0.10162026f, 
    0.13530309f, -0.16047639f, -0.11182248f, -0.27049115f, 0.14645696f, 0.08075125f, -0.04906975f, 0.02535988f, 
    -0.02145129f, -0.11984038f, -0.08051369f, 0.10375039f, 0.09797245f, 0.05263008f, -0.04830842f, -0.09307189f, 
    -0.21964264f, -0.52396256f, 0.14838442f, -0.14728373f, -0.14249031f, -0.07830387f, -0.16311207f, 0.07588220f, 
    0.11760146f, -0.09662420f, -0.16524245f, 0.04321983f, 0.00386962f, -0.03460359f, -0.13604467f, -0.03358684f, 
    0.13986684f, 0.17606592f, 0.18429305f, -0.03601665f, 0.10729241f, -0.06691749f, 0.14762515f, -0.07005978f, 
    0.09932178f, 0.11197060f, 0.12910753f, 0.28114429f, 0.14530063f, 0.06241775f, -0.08068652f, 0.04130160f, 
    0.11317820f, -0.07466005f, -0.14538708f, 0.03963831f, 0.12809509f, 0.13617061f, 0.20504735f, 0.14737451f, 
    -0.29514974f, -0.45856908f, -0.53589916f, 0.17393333f, -0.20789589f, -0.07573348f, -0.06613816f, 0.28038582f, 
    0.06464866f, -0.03359189f, -0.09070696f, 0.01315500f, 0.03776060f, -0.01634028f, -0.07192104f, 0.06400157f, 
    -0.05294960f, 0.23224159f, 0.06980722f, 0.11489020f, -0.42294538f, -0.03170146f, -0.13202065f, 0.00532887f, 
    0.35034415f, 0.02289789f, -0.11066932f, 0.02189196f, -0.11405630f, 0.07186750f, -0.06219960f, 0.10494918f, 
    0.11271179f, -0.00244249f, 0.05337881f, 0.03610156f, 0.03788546f, -0.32804596f, 0.13268062f, 0.11107285f, 
    -0.52706414f, 0.03684062f, -0.60433877f, 0.38174391f, 0.26221675f, -0.02017638f, 0.19024271f, -0.09016547f, 
    0.09295171f, 0.11514902f, -0.17589688f, -0.14761473f, -0.01496941f, 0.33324707f, 0.00964513f, 0.04579289f, 
    -0.05923270f, 0.09102308f, 0.01779591f, -0.05098275f, -0.50978786f, -0.08839040f, -0.08359063f, 0.41202393f, 
    -0.50013429f, 0.08967173f, 0.12169982f, 0.18142644f, -0.27406046f, 0.05668447f, -0.04183883f, -0.10123105f, 
    0.21352655f, 0.25531510f, -0.04320990f, 0.09451035f, -0.05480820f, 0.17210801f, 0.04976874f, 0.00661482f, 
    0.11340351f, -0.00648786f, 0.00440084f, 0.04088147f, 0.00929170f, -0.08321565f, 0.11145606f, -0.06107359f, 
    0.03716383f, 0.07482692f, -0.11762308f, -0.01713386f, 0.00834264f, -0.02791179f, -0.07497068f, 0.12569454f, 
    0.06161902f, 0.03721042f, -0.06964557f, -0.05740054f, 0.22860858f, -0.13645734f, 0.38146394f, -0.05226246f, 
    0.07097789f, 0.03088609f, 0.16394125f, -0.04743592f, 0.12610799f, -0.18567491f, 0.00674919f, 0.03023834f, 
    0.04435115f, -0.01896855f, 0.15539399f, -0.01546205f, 0.03302829f, -0.00321412f, 0.05861589f, -0.17001095f, 
    -0.17705670f, -0.48650646f, -0.50900567f, -0.30459562f, 0.07373396f, -0.09328765f, -0.04239083f, 0.24560317f, 
    -0.26673466f, 0.09553465f, 0.02449972f, 0.00398509f, 0.10643931f, 0.04117046f, -0.04037776f, 0.03345672f, 
    -0.05218444f, 0.06598100f, 0.02002255f, 0.08059923f, -0.05958220f, 0.13205248f, -0.07009651f, 0.06160812f, 
    -0.07395094f, -0.03002825f, 0.11943705f, 0.14647058f, 0.11993555f, 0.03294516f, -0.20547093f, -0.01227391f, 
    0.05563043f, -0.03612358f, -0.07184339f, 0.08528139f, 0.00583497f, 0.04248303f, -0.19187833f, -0.11738086f, 
    -0.02680204f, 0.14736052f, -0.40038496f, 0.46645194f, 0.46172464f, -0.20010372f, 0.03919742f, 0.09705903f, 
    0.36891070f, -0.04981316f, -0.21868180f, 0.08855549f, -0.01232256f, -0.05777879f, 0.18651278f, 0.01795853f, 
    -0.07437036f, 0.26820013f, 0.06276188f, 0.18178226f, 0.43441755f, -0.04754445f, 0.38826537f, -0.21371922f, 
    0.10411825f, -0.02961246f, -0.26001751f, -0.03717145f, 0.13781947f, -0.14359513f, -0.09281656f, 0.00987375f, 
    -0.04986312f, 0.07183304f, -0.02827382f, -0.01741876f, -0.09802653f, 0.06066660f, -0.11029335f, 0.21515104f, 
    -0.05396971f, -0.20827538f, -0.37586606f, 0.08413447f, 0.03383609f, -0.14754713f, -0.37281892f, -0.07580893f, 
    -0.05584667f, -0.20079975f, -0.01726259f, 0.07715445f, 0.03812263f, -0.02821128f, 0.02336919f, 0.13120364f, 
    -0.05090348f, 0.12610348f, 0.13025242f, -0.09049156f, 0.00302619f, -0.43305513f, -0.00181811f, -0.13173035f, 
    0.29439145f, 0.06480779f, -0.08852294f, -0.19186172f, -0.04379780f, -0.20284562f, -0.03691011f, 0.00939774f, 
    -0.08788577f, 0.02065939f, -0.02777538f, 0.03911429f, 0.03109641f, 0.07614814f, -0.11085726f, -0.09839114f, 
    -0.58305031f, -0.24703331f, -0.18616411f, 0.20325874f, -0.26933706f, -0.12339421f, -0.01194511f, 0.04166240f, 
    0.05793735f, -0.05324525f, -0.10611431f, -0.00871208f, 0.00559660f, -0.15571070f, -0.06198102f, -0.01267764f, 
    -0.10950753f, -0.12103951f, -0.08583286f, -0.03930845f, 0.37221345f, -0.06535678f, 0.05396979f, -0.01454290f, 
    -0.04389310f, -0.04542626f, -0.01022598f, -0.06406191f, -0.03649488f, -0.06180232f, -0.07745744f, 0.01866852f, 
    0.02961250f, -0.06530046f, -0.02704796f, 0.06005074f, 0.16864738f, 0.01998958f, 0.14331064f, -0.06083678f, 
    -0.19767153f, -0.11528341f, 0.06507749f, -0.15598370f, 0.13637030f, 0.05997410f, 0.06345893f, -0.14070994f, 
    0.09188772f, 0.09735952f, 0.00370072f, 0.17626718f, 0.00500969f, 0.01137236f, 0.06439774f, -0.07818356f, 
    -0.12771533f, -0.08055478f, -0.11686547f, -0.11809255f, 0.57410479f, -0.49104118f, 0.38225439f, -0.16790822f, 
    -0.01953552f, -0.02719743f, -0.07183207f, 0.00152993f, 0.00779959f, -0.14348274f, -0.05876953f, 0.03799113f, 
    -0.01884889f, -0.14011642f, -0.03169632f, 0.10326593f, 0.14740106f, -0.01402210f, -0.00090600f, -0.09000178f, 
    0.12108641f, -0.45287201f, 0.26117843f, -0.11550848f, 0.22525790f, 0.03194062f, -0.15216061f, -0.27782926f, 
    0.23465647f, -0.21110928f, 0.06575709f, 0.09242073f, 0.01001222f, 0.12028469f, 0.05589934f, -0.01692530f, 
    -0.02615617f, -0.09915373f, -0.03377765f, 0.01754317f, -0.40272722f, -0.02841076f, -0.31149396f, -0.00105847f, 
    -0.12983893f, 0.00848149f, 0.08151963f, 0.03397936f, 0.08573359f, -0.07747497f, -0.28237024f, -0.09153876f, 
    0.09143813f, 0.06170354f, 0.05484654f, 0.10835169f, -0.04164215f, 0.03552153f, -0.12806171f, -0.04021610f, 
    -0.30236560f, -0.18529475f, -0.12407116f, 0.37860677f, -0.07723141f, -0.05498124f, 0.10209129f, 0.01939947f, 
    0.30171067f, -0.13334028f, -0.22488697f, 0.02549371f, -0.04946566f, -0.09481934f, 0.12576386f, -0.11328579f, 
    -0.02570099f, 0.10784943f, -0.05308070f, -0.03876783f, 0.37637424f, 0.13011946f, 0.45567256f, -0.08061749f, 
    -0.21952704f, 0.03134339f, -0.01837232f, -0.13195337f, -0.00462124f, -0.12439490f, -0.11339661f, -0.06007276f, 
    -0.00852704f, -0.05021196f, -0.07126164f, -0.09872943f, 0.12297704f, -0.14318660f, 0.15383598f, 0.12053713f, 
    -0.63537848f, -0.45600340f, -0.43111512f, -0.02505032f, 0.46986407f, 0.09659943f, 0.16234475f, 0.26995566f, 
    -0.27936515f, 0.05178225f, 0.05705019f, 0.04178782f, 0.02657771f, 0.20867527f, 0.26058134f, -0.10912342f, 
    0.09940211f, 0.08614235f, 0.13426532f, 0.13635878f, -0.23685473f, -0.40134865f, 0.08781990f, 0.15129094f, 
    0.08211304f, 0.16392927f, 0.26610240f, -0.00291912f, -0.08907834f, 0.09099437f, 0.01034756f, -0.03006564f, 
    -0.01271570f, -0.02711713f, -0.04730195f, -0.12034476f, 0.00074208f, -0.02154330f, -0.07476224f, 0.01248455f, 
    0.06976447f, -0.42614764f, 0.34693477f, -0.55758035f, 0.08913878f, 0.02762238f, 0.07789856f, 0.07408725f, 
    0.04041501f, -0.04241742f, -0.07160391f, -0.00475044f, 0.12526719f, 0.02043675f, 0.05584391f, 0.07772244f, 
    0.22430333f, -0.00573425f, 0.18844929f, 0.09000871f, -0.28709090f, -0.04101142f, -0.33222827f, 0.17103811f, 
    0.01783520f, -0.06827217f, -0.06453502f, -0.04965778f, -0.17056757f, -0.01792340f, 0.04293896f, 0.13096018f, 
    -0.14237526f, -0.14641875f, -0.17409699f, 0.08893532f, -0.15075557f, -0.08509517f, -0.10807341f, -0.08443865f, 
    0.06579738f, -0.41930079f, 0.00770688f, -0.06250475f, -0.01688453f, -0.04634057f, -0.38831434f, 0.05369129f, 
    -0.04445143f, -0.22187009f, 0.06224783f, 0.05145281f, 0.13684846f, -0.00933201f, 0.02785497f, 0.06264118f, 
    0.00000674f, 0.04920913f, 0.07749915f, -0.05406979f, 0.12104081f, -0.28427303f, 0.09103227f, -0.06525745f, 
    0.05296250f, 0.08878963f, -0.06417229f, 0.10078797f, 0.02110651f, 0.06272731f, -0.00854383f, 0.05121653f, 
    -0.03983149f, -0.06304375f, 0.01374119f, -0.01045255f, -0.04251433f, 0.00138895f, -0.08884554f, -0.07600580f, 
    0.24203509f, -0.12919585f, -0.02274832f, 0.32579893f, 0.16912079f, -0.02096856f, 0.23836316f, -0.01057769f, 
    0.14956810f, 0.03404860f, -0.16457173f, 0.03771649f, -0.02388191f, 0.03725990f, 0.13804825f, -0.12095173f, 
    -0.05952729f, -0.10075944f, -0.07421453f, -0.00022655f, 0.14650938f, 0.11001617f, 0.23034784f, 0.02652232f, 
    -0.32216853f, -0.10107568f, 0.11751337f, -0.02403857f, -0.03039257f, -0.02421302f, -0.13053416f, -0.05832592f, 
    0.03365769f, 0.00534288f, -0.01369018f, 0.03184019f, 0.11072598f, 0.05104234f, -0.11731634f, -0.00597217f, 
    -0.22667521f, -0.02093461f, -0.08713461f, -0.17072624f, 0.12860072f, 0.03914009f, 0.14497390f, 0.09350023f, 
    -0.04070279f, 0.10043199f, 0.04596558f, 0.08671328f, -0.06086829f, -0.04202580f, -0.02558215f, 0.14487059f, 
    0.00690373f, -0.00326614f, -0.18615389f, 0.06120759f, -0.15069693f, -0.33869466f, -0.16264930f, -0.12019242f, 
    -0.76610821f, -0.14477681f, -0.17478599f, -0.31089029f, -0.01880196f, -0.00406351f, -0.05731284f, 0.04599039f, 
    0.11528110f, -0.05904489f, -0.07307601f, 0.01083461f, -0.00527958f, 0.01293365f, 0.05239799f, 0.00831805f, 
    0.28125277f, 0.19717775f, 0.26523963f, -0.05795531f, -0.08218644f, 0.02253306f, 0.14902845f, -0.00891555f, 
    0.06117850f, -0.05554271f, -0.19228187f, 0.09952772f, 0.13012590f, -0.02871255f, -0.03112501f, 0.04923969f, 
    0.00777721f, -0.00981261f, -0.04407407f, 0.01144956f, -0.33660793f, -0.10036536f, 0.06334041f, 0.23352160f, 
    0.18102774f, -0.03186427f, -0.09484181f, -0.07884725f, -0.09656957f, 0.14631681f, 0.04709173f, -0.05969215f, 
    -0.19723718f, -0.04871110f, -0.07267867f, -0.09106442f, -0.07592822f, 0.04363918f, -0.08518691f, -0.15351084f, 
    0.46289989f, -0.01281006f, 0.48794448f, 0.27765074f, -0.23014034f, -0.07121962f, 0.18498610f, -0.07856499f, 
    0.08600733f, 0.02046556f, -0.22141892f, 0.01037011f, 0.00831358f, 0.13886376f, 0.06507206f, -0.13524076f, 
    0.07053407f, 0.07671708f, 0.05190444f, 0.03151730f, -0.04064688f, -0.20094961f, -0.08264466f, 0.05245619f, 
    -0.09622428f, 0.01196113f, -0.35471964f, -0.17891082f, -0.13751814f, 0.10196622f, 0.01528779f, -0.02594478f, 
    -0.03014169f, -0.04166489f, -0.03948079f, 0.08170240f, -0.06338590f, 0.04255690f, -0.02658765f, -0.10359607f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.23099008f, 0.12996745f, 0.06046586f, -0.14499468f, -0.06322032f, 0.07229649f, 0.08084867f, -0.10768960f, 
    0.02974782f, -0.00766108f, 0.03500400f, 0.00450406f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
