#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.37560901f, -0.11631774f, 0.00471721f, -0.02032885f, 0.31725463f, 0.21586837f, 0.28452733f, 0.13475493f, 
    0.35553384f, 0.06140757f, 0.01809684f, 0.11509010f, 0.10408312f, 0.17757830f, -0.14168966f, -0.33101237f, 
    0.03816790f, -0.37756100f, 0.05027947f, -0.27624357f, 0.35215223f, -0.00816008f, -0.10244750f, 0.24771661f, 
    0.14927401f, -0.43970492f, -0.21867999f, -0.15090929f, 0.26740012f, 0.36612299f, 0.13460788f, -0.22807932f, 
    -0.31134430f, 0.10801672f, 0.16095333f, 0.24843912f, 0.13618854f, 0.17310877f, 0.13086414f, -0.08678881f, 
    -0.33641195f, 0.06061330f, 0.25962684f, 0.11350960f, -0.03662131f, -0.05297452f, 0.10789977f, 0.12455641f, 
    0.18030187f, -0.04328323f, 0.00140262f, -0.54697031f, -0.41336972f, -0.22642094f, -0.61134917f, 0.61374521f, 
    0.01063170f, 0.08983096f, 0.04497317f, 0.20102809f, 0.14831156f, 0.14786626f, 0.20745875f, 0.19222203f, 
    0.11998148f, -0.21375896f, 0.14391100f, -0.24063547f, -0.18078940f, -0.27731687f, -0.01012919f, -0.14658184f, 
    0.11747415f, 0.24079213f, 0.14187938f, 0.12212607f, -0.89944804f, -0.69812423f, 0.06886761f, 0.24738452f, 
    0.49614623f, 0.31877595f, 0.25737137f, 0.01289673f, -0.21916945f, 0.36401585f, -0.15010175f, 0.02027946f, 
    0.22649582f, 0.03614280f, -0.10940511f, 0.05365043f, -0.21208102f, -0.00800373f, -0.24657089f, -0.02394126f, 
    -0.09299949f, 0.33888581f, -0.13141876f, -0.17485322f, -0.72322035f, 0.24567971f, 0.38398734f, -0.18234801f, 
    -0.13962629f, 0.04783783f, 0.31497845f, 0.41866833f, 0.20251136f, -0.28212181f, -0.45409247f, -0.19237544f, 
    -0.03004620f, 0.59106982f, -0.30619070f, 0.21341141f, 0.19202329f, -0.18518992f, -0.32249117f, -0.32188693f, 
    0.06215370f, 0.36829546f, 0.32644770f, -0.19967987f, -0.12838127f, 0.71425325f, -0.41861969f, -0.14263724f, 
    -0.36716497f, 0.11180432f, 0.21146883f, 0.05668176f, 0.03090545f, -0.32009277f, 0.16961825f, -0.42601031f, 
    -0.00015591f, -0.11118346f, -0.03251095f, 0.31162754f, 0.32125404f, -0.29620278f, -0.35174793f, 0.10546074f, 
    -0.40072089f, 0.19528706f, -0.17811267f, 0.09319819f, 0.20331907f, 0.34229460f, 0.86159569f, -0.48501632f, 
    -0.24969362f, -0.38499516f, -0.67474473f, 0.50622070f, 0.44585752f, 0.59819496f, -0.41178778f, 0.17471442f, 
    -0.08023896f, 0.16225277f, 0.13493577f, -0.20256166f, -0.05860151f, -0.24422519f, 0.14299749f, -0.13105308f, 
    -0.14515434f, 0.28542098f, 0.28721443f, -0.33230463f, -0.25925988f, 0.17544930f, 0.26779118f, -0.86373276f, 
    0.06775524f, -0.81243533f, -1.08969665f, -0.70057487f, 0.42582902f, -0.44597054f, -0.38302577f, -0.11421864f, 
    0.75978798f, -0.34373459f, -0.29571173f, 0.14021806f, -0.04161014f, -0.14304814f, 0.22132380f, -0.29464838f, 
    -0.26740882f, 0.08189987f, 0.09523886f, 0.09224277f, 0.02163743f, 0.06275186f, -0.26346910f, -0.11099515f, 
    -0.53725785f, -0.31613094f, 0.03492040f, 0.00992144f, -0.45339373f, -0.38897005f, -0.24814032f, -0.29601690f, 
    -0.39213973f, -0.19835864f, 0.80702192f, 0.06957655f, 0.03402593f, 0.03662869f, 0.00242599f, -0.29158893f, 
    0.04051644f, -0.45952842f, -0.30426890f, -0.56273711f, -0.14327331f, -0.09451737f, 0.04943703f, 0.06040464f, 
    -0.35470894f, -1.21530104f, 0.27434742f, 0.07372439f, -0.34378633f, -0.22158915f, 0.04546365f, -0.11219046f, 
    0.16924448f, 0.65302300f, 0.21534687f, -0.04534534f, -0.28025982f, 0.09193730f, 0.02038727f, 0.07780040f, 
    -0.05114959f, 0.16260965f, -0.17547347f, 0.17346969f, 0.12150507f, -0.02753508f, 0.15950392f, -0.02988399f, 
    0.07758797f, -0.18498577f, -0.27809957f, -0.58720154f, -0.26314306f, 0.19233470f, -0.06343267f, 0.62721121f, 
    -0.19796489f, -0.38045177f, 0.20396210f, 0.56044656f, -0.03032458f, -0.10736057f, 0.00623922f, -0.01555592f, 
    0.22858109f, -0.20223242f, 0.24231814f, -0.11431699f, -0.22891574f, -0.38571882f, 0.19249773f, 0.25524762f, 
    0.05288951f, 0.23027411f, 0.08826679f, -0.50759584f, -0.04556023f, 0.45629352f, 0.42824182f, -0.11441845f, 
    -0.26449350f, -0.70385247f, -0.27241373f, 0.13648689f, 0.17322357f, -0.06683289f, 0.12645219f, -0.24335642f, 
    0.54454744f, 0.00700932f, -0.16146272f, -0.16923964f, 0.19669665f, -0.01029061f, -0.37946236f, 0.21881874f, 
    0.29466298f, 0.07694885f, -0.00284233f, 0.14376120f, 0.87333077f, 0.07111248f, -0.33395532f, -0.24293405f, 
    -0.60081768f, 0.43101287f, 0.20634343f, -0.00686525f, -0.42756543f, 0.28516614f, -0.13408515f, -0.19464436f, 
    0.07296785f, 0.06114203f, -0.18503411f, 0.12896653f, -0.20579015f, 0.26405793f, -0.02171970f, -0.16850327f, 
    -0.09560019f, 0.11852653f, -0.29085606f, 0.18267062f, 0.30509382f, 0.05142112f, 0.07353535f, 0.19279994f, 
    0.07505032f, 0.16626272f, 0.06302117f, 0.17981122f, -0.12260929f, 0.12539777f, 0.13367206f, 0.25929171f, 
    -0.31506696f, -0.14853199f, 0.24849263f, -0.08237842f, -0.01537811f, 0.09208633f, -0.23031475f, -0.41405401f, 
    0.00292157f, -0.07149155f, -0.08665764f, 0.17302252f, 0.22197163f, -0.25694171f, -0.03626906f, -0.32677177f, 
    -0.33724567f, -0.21316066f, -0.14241123f, 0.36465147f, -0.02438114f, 0.46829522f, -0.25838947f, 0.38705593f, 
    -0.20693952f, -0.03380080f, 0.18130758f, -0.11514431f, -0.14018123f, -0.01827885f, -0.13294654f, 0.10118914f, 
    -0.16277178f, 0.11475901f, 0.07282887f, 0.18387359f, -0.21785542f, -0.06007435f, 0.31408271f, -0.29298609f, 
    -0.21508421f, -0.36082387f, -0.16536994f, 0.00512544f, 0.23219813f, -0.08582748f, 0.31202292f, 0.00951062f, 
    0.29682726f, 0.02161107f, 0.06729940f, 0.10191323f, -0.02802368f, -0.18775634f, 0.11287685f, 0.16105604f, 
    0.07402007f, 0.16392675f, 0.09999794f, 0.15154061f, 0.14451396f, 0.05072172f, -0.04376901f, -0.34611329f, 
    -0.04709627f, 0.12528858f, -0.03603245f, -0.42119816f, 0.00990873f, 0.22277077f, -0.14412588f, 0.18848708f, 
    0.09101281f, 0.34500045f, 0.23830575f, 0.40209764f, -0.39326277f, -0.05054610f, -0.29908916f, 0.25401953f, 
    -0.42563534f, -0.04127832f, -0.12597093f, 0.16802989f, 0.17750223f, -0.20696215f, 0.10991209f, -0.02390234f, 
    0.30326635f, -0.08025973f, 0.54194367f, -0.42191324f, -0.43224317f, -0.16717264f, -0.21968189f, -0.31410915f, 
    0.76986194f, -0.47382191f, 0.01764855f, 0.01698375f, 0.31714574f, 0.22269401f, 0.16293332f, -0.14612345f, 
    0.07845066f, 0.17112519f, -0.26863551f, -0.08188449f, -0.00081374f, 0.02554003f, 0.07185506f, -0.06464627f, 
    0.11457644f, -0.13320281f, -0.77965027f, -0.35377902f, -0.04512676f, 0.96736902f, 0.43768451f, 0.08449906f, 
    -0.57045984f, -0.72113776f, -0.22115673f, 0.38196024f, -0.16759339f, 0.29427364f, -0.27561811f, 0.07105899f, 
    -0.13034162f, 0.25496253f, -0.02093416f, 0.16003434f, -0.19634177f, 0.07208712f, 0.10590997f, -0.16332874f, 
    -0.27672926f, -0.02729521f, -0.22280614f, 0.15035561f, 0.60947090f, 0.17527112f, 0.09736682f, -0.36202988f, 
    -0.11071799f, -0.51234031f, 0.06577107f, 0.56413668f, -0.45058098f, -0.01751362f, -0.34247577f, -0.18722826f, 
    -0.12207787f, -0.15781392f, 0.25925630f, 0.37666702f, 0.00351314f, -0.02410836f, 0.04423484f, -0.14460008f, 
    0.02800040f, -0.18030840f, -0.08122006f, -0.15074067f, 0.44254383f, -0.15358153f, 0.17787874f, 0.13473852f, 
    0.10553817f, -0.10409676f, 0.45187798f, 0.28286910f, -0.35800919f, -0.39225841f, -0.05254478f, 0.11747952f, 
    -0.03958328f, -0.13268685f, -0.09241141f, -0.25450420f, -0.12063695f, 0.11076297f, -0.04988930f, 0.02832325f, 
    0.39086211f, -0.42510888f, -0.16470005f, 0.20085450f, -0.17423633f, -1.29514694f, -0.92121208f, 0.15437302f, 
    0.35105234f, -0.20215891f, 0.92010182f, 0.52187306f, -0.42427590f, -0.35323176f, 0.38908583f, 0.01524823f, 
    -0.24194051f, -0.28014845f, 0.19198146f, -0.31381261f, 0.06898642f, -0.01312235f, -0.25067043f, 0.02449109f, 
    -0.33775699f, -0.02512314f, -0.19571635f, -0.05124301f, 0.01492969f, 0.10506809f, -0.48167434f, 0.02412881f, 
    0.10050294f, -0.15170617f, 0.21434316f, -0.33035529f, 0.15192483f, -0.42299941f, 0.03000098f, 0.45585844f, 
    0.01931774f, 0.16676810f, 0.06858646f, -0.28160197f, 0.28319860f, -0.04621239f, -0.04775214f, 0.05454818f, 
    -0.11276339f, 0.18561773f, 0.02443315f, -0.43491584f, 0.29017749f, 0.14806603f, -0.16813725f, -0.86005849f, 
    0.28116009f, -0.27870369f, -0.83797854f, 0.06186503f, 0.16149125f, -0.09403403f, -0.94786191f, -0.69793129f, 
    -0.38416213f, 0.15595776f, 0.12597686f, -0.04927722f, -0.61132771f, -0.35594335f, 0.09172342f, 0.13836949f, 
    -0.17671691f, -0.13529137f, -0.17617545f, 0.14503686f, -0.23628639f, -0.37259898f, 0.24501427f, -0.44453448f, 
    -0.93923908f, -0.35894686f, -0.06827653f, -0.42450804f, -0.54177636f, 0.28534889f, -0.17734794f, -0.95331281f, 
    -0.56223625f, -0.02960679f, -0.25227287f, 0.03312595f, -0.26643756f, -0.41462061f, -0.51286858f, -0.12801717f, 
    0.18533054f, 0.05548244f, -0.10099591f, 0.03911914f, 0.04063354f, 0.06988342f, -0.10515252f, 0.01549210f, 
    0.20797494f, -0.60293192f, -0.53386730f, -0.52648813f, -0.53971201f, -0.07388063f, -0.20552827f, -0.32283229f, 
    0.01226733f, -0.52330434f, -0.40860444f, -0.30325526f, -0.34613782f, -0.01936859f, -0.20435502f, 0.14286046f, 
    0.36419490f, 0.29580116f, 0.08740516f, 0.09774372f, 0.18516099f, 0.17376636f, 0.13618352f, -0.20291771f, 
    -0.30181283f, -0.19212259f, 0.75797969f, 0.78401238f, 0.00946354f, -0.45809248f, -0.40651625f, -0.33414727f, 
    0.02369737f, 0.10171044f, -0.48734275f, -0.42652756f, -0.06226118f, -0.03664797f, 0.23270723f, 0.05240843f, 
    0.04212383f, -0.18946232f, 0.51758158f, 0.48034737f, -0.18756856f, -0.39189360f, -0.16334987f, 0.04867767f, 
    -0.29010093f, 0.11300793f, 0.23613705f, 0.44991881f, 0.18182848f, -0.26275530f, 0.06131227f, -0.18210803f, 
    0.23035744f, 0.28351983f, -0.01423842f, -0.26384407f, -0.16221844f, -0.14700256f, -0.08556519f, 0.13029550f, 
    0.09437656f, 0.10531326f, -0.03903598f, -0.24020515f, -0.25188857f, -0.17597112f, -0.22178239f, -0.17828178f, 
    0.29642403f, 0.27167580f, -0.08191980f, 0.22814010f, 0.47887105f, -0.12468182f, 0.01934392f, -0.21470533f, 
    -0.11339062f, 0.03889871f, -0.49017432f, 0.03646809f, 0.10293911f, -0.63819438f, 0.20272152f, 0.14418288f, 
    0.01421908f, 0.05943014f, 0.30287820f, 0.11463183f, 0.09232563f, -0.11508532f, -0.16174458f, 0.09062886f, 
    -0.22772317f, 0.06453356f, 0.27749509f, 0.04177311f, -0.31022272f, 0.21328786f, -0.33810854f, -0.15871793f, 
    0.39017436f, 0.03104985f, -0.11326320f, -0.30756122f, -0.55293930f, -0.60779786f, -0.41868719f, 0.00316954f, 
    0.33430737f, -0.15457299f, -0.06263220f, 0.05918245f, -0.09511284f, 0.36980122f, 0.06629746f, 0.37855306f, 
    0.12296244f, 0.10758710f, -0.22339468f, -0.07777903f, -0.13125315f, -0.42645046f, 0.45469180f, 0.34060666f, 
    0.23658870f, -0.00297026f, -0.19644755f, -0.32168677f, 0.28781959f, 0.03715819f, -0.15658468f, 0.04605005f, 
    0.41091794f, 0.03337740f, -0.17694975f, -0.46267092f, -0.10506867f, -0.22068121f, 0.02193690f, -0.07228283f, 
    0.16695212f, -0.17844421f, 0.05463442f, 0.41192713f, 0.14590771f, -0.39949584f, -0.32170302f, 0.24114715f, 
    -0.50266987f, -0.02565725f, 0.23552893f, -0.39786956f, -0.35909060f, -0.14531797f, 0.43951312f, -0.39740539f, 
    0.13964549f, -0.27489030f, -0.27436811f, 0.33400837f, 0.02363078f, -0.35689318f, 0.00841150f, -0.16724715f, 
    0.06646799f, 0.26247200f, -0.05430027f, 0.09570832f, -0.03429249f, -0.20701072f, -0.20024148f, 0.11128629f, 
    0.29964504f, 0.32026148f, -0.20758086f, -0.04808783f, -0.09688022f, -0.11296827f, -0.25406575f, -0.15786199f, 
    0.31470135f, 0.19183917f, -0.24605601f, -0.01595677f, 0.25398761f, -0.43644071f, -0.15066770f, -0.09853307f, 
    0.09680890f, 0.02163678f, 0.29587260f, -0.11191458f, 0.15679461f, -0.14790672f, 0.01158823f, -0.02424374f, 
    0.08629750f, -0.59128290f, -0.50134033f, -0.67897296f, -0.64554763f, -0.64538354f, 0.38939419f, -0.15976128f, 
    0.00122995f, 0.31632817f, 0.40617919f, -0.16651165f, -0.34050059f, -0.37225467f, 0.04809508f, -0.20443426f, 
    0.24157758f, -0.05073968f, 0.12378345f, -0.13522260f, -0.40644628f, -0.37656152f, -0.25957420f, -0.23460534f, 
    -0.14803700f, -0.34136549f, -0.10087162f, 0.34069183f, -0.25763565f, -0.63017786f, -0.29212230f, -0.16278853f, 
    0.29682469f, 0.33224368f, -0.55212450f, -0.37946141f, -0.20507036f, -0.02452246f, 0.06275923f, 0.68291831f, 
    -0.14820859f, -0.42633963f, -0.66204643f, -0.37729093f, -0.06775957f, -0.33552894f, 0.26946795f, 0.12367133f, 
    -0.03000911f, 0.31397393f, -0.01523434f, 0.41461012f, 0.16619065f, 0.17587501f, 0.11258207f, -0.08530284f, 
    -0.65031534f, -0.28742850f, 0.21168694f, 0.10332470f, 0.19365548f, -0.04363884f, 0.03057294f, 0.09064897f, 
    0.26941785f, 0.12600893f, -0.11739136f, 0.19741352f, -0.25419578f, -0.18449952f, -0.04267617f, -0.26170850f, 
    0.14687897f, 0.22011752f, 0.15289246f, -0.24995917f, -0.57999903f, -0.17957583f, 0.45024270f, 0.46395743f, 
    0.32413223f, 0.57563555f, 0.23759082f, -0.37347883f, -0.41309217f, -0.38297760f, -0.18044651f, -0.24040487f, 
    -0.03632122f, -0.24560097f, 0.08444404f, -0.28279689f, -0.19996534f, 0.13273358f, 0.21686615f, 0.19759354f, 
    0.17947417f, 0.13067569f, -0.20360100f, -0.15772347f, -0.19457893f, -0.54823065f, -0.07144225f, 0.47703356f, 
    -0.50739264f, -0.81953746f, 0.01419839f, 0.35735738f, -0.37036216f, 0.13332646f, -0.10429278f, 0.53868866f, 
    -0.38687685f, 0.18523009f, -0.38355187f, -0.12513587f, 0.22196925f, 0.01987516f, -0.15502413f, 0.17885242f, 
    -0.27431270f, -0.16742937f, 0.09953860f, 0.37361035f, -0.03649211f, 0.48674551f, 0.56999826f, 0.44376555f, 
    -0.68429488f, -0.15891844f, 0.14294314f, 0.31052744f, -0.00517066f, 0.03517720f, 0.28642714f, 0.30310753f, 
    -0.05412373f, -0.13855658f, -0.19156143f, -0.26215327f, -0.14144084f, 0.05571966f, 0.05785458f, -0.15493119f, 
    0.12184311f, -0.06495731f, -0.37039393f, -0.22663386f, -0.12088139f, -0.41089994f, -0.20679162f, -0.14303830f, 
    -0.02499890f, 0.00556948f, 0.24191232f, -0.03066203f, -0.32829714f, -0.36879122f, 0.23672399f, 0.09471926f, 
    0.01213627f, 0.02902292f, 0.08994390f, -0.23870482f, -0.05583154f, -0.05726714f, 0.04969440f, 0.18687044f, 
    -0.25871286f, -0.04499210f, 0.05862020f, 0.07822347f, 0.11501633f, -0.21065639f, 0.21253031f, 0.25056034f, 
    -0.74559569f, -0.34234029f, -0.26316646f, -0.78197765f, -0.62643772f, 0.41382423f, 0.04932060f, 0.06144064f, 
    0.36799994f, 0.51069719f, 0.22153431f, -0.11498708f, 0.21702485f, -0.00774647f, 0.22698057f, -0.17907026f, 
    0.00253761f, -0.17257434f, -0.18764661f, 0.19780868f, 0.13759106f, -0.03736233f, 0.28358412f, -0.07555180f, 
    0.02739736f, -0.09678411f, -1.09643555f, -0.63296688f, 0.17954005f, 0.70319986f, -0.57090116f, -0.37783614f, 
    -0.46030363f, -0.43120492f, -0.70443898f, -0.06049410f, -0.39504847f, 0.12678784f, -0.12628040f, -0.16043782f, 
    0.03028147f, -0.14425550f, 0.14335614f, -0.10647006f, 0.17135933f, 0.15576208f, -0.31034112f, -0.01838812f, 
    0.30567506f, -0.02055155f, 0.97939128f, 0.35163799f, -0.40396696f, -0.24726208f, -0.95808101f, 0.01807053f, 
    0.43062335f, 0.29951897f, 0.07868718f, -0.23062225f, -0.21927059f, 0.09299028f, -0.05941943f, 0.18596241f, 
    -0.16596492f, 0.06591338f, -0.02074689f, -0.12943661f, 0.05312016f, -0.09736080f, 0.11607442f, 0.02152948f, 
    0.02188932f, -0.16008192f, 0.18516628f, -0.05019034f, -0.05821281f, -0.03099299f, -0.07194161f, -0.57951021f, 
    -0.01473106f, -0.07568567f, -0.34839323f, -0.24436125f, -0.01862582f, 0.35783315f, 0.09800699f, 0.29379636f, 
    0.32688603f, 0.21691184f, -0.16122699f, 0.09159204f, -0.20631255f, -0.07224641f, -0.24897335f, -0.03677253f, 
    0.18835905f, -0.10823116f, -0.11121260f, 0.09587848f, -0.34330884f, 0.06905459f, 0.30349717f, 0.48918736f, 
    0.19357599f, -0.61396194f, -0.65854484f, -0.27274060f, 0.07163294f, -0.39229897f, -0.09475899f, -0.43897417f, 
    -0.19460219f, -0.08728753f, -0.63072479f, -0.29829723f, -0.06425352f, 0.04955269f, -0.26788279f, -0.39959532f, 
    -0.10506310f, -0.13340099f, -0.00013726f, -0.09506263f, 0.18753979f, -0.80386555f, -0.78837395f, -0.27041188f, 
    -0.07928284f, 0.15548377f, 0.27652484f, -0.03980657f, 0.09757806f, 0.37119445f, 0.49596354f, 0.27150106f, 
    -0.14813623f, 0.08417659f, -0.05939751f, 0.08596212f, -0.21363577f, -0.23800068f, -0.00406446f, 0.21520153f, 
    -0.28854966f, -0.24676144f, -0.22347257f, -0.11311065f, -0.25595903f, 0.11855463f, 0.34519872f, 0.55263728f, 
    -0.05802453f, -0.26532072f, 0.19558790f, 0.08007840f, -0.45618922f, 0.06802733f, -0.21632524f, -0.47043988f, 
    -0.07480300f, 0.09992377f, -0.15486112f, -0.10791165f, 0.36977008f, -0.03467154f, 0.15598154f, -0.00536694f, 
    0.17340074f, 0.20605068f, 0.10831731f, 0.03139700f, -0.12919472f, -0.02665129f, 0.02665958f, -0.52742600f, 
    0.21357162f, -0.03457013f, 0.11130012f, -0.31452668f, -0.84865749f, -0.61774516f, 0.32349268f, 0.10040685f, 
    -0.08817940f, -0.09436796f, -0.27439421f, 0.22155008f, 0.07903371f, 0.43107679f, -0.30694869f, -0.16456042f, 
    -0.22818606f, -0.36807832f, -0.54017621f, -0.30929136f, -0.07168055f, 0.25847882f, -0.25367916f, 0.06767185f, 
    -0.82297230f, -0.70666927f, -0.31380045f, 0.10496082f, 0.28939649f, -0.58896154f, -0.37327337f, 0.20035090f, 
    0.28699893f, 0.05940875f, 0.27895647f, 0.44460529f, 0.35851580f, -0.29333767f, 0.06663129f, -0.27222690f, 
    0.16508995f, 0.11042232f, -0.42513999f, -0.36328667f, -0.18560039f, 0.52366245f, -0.26566488f, -0.33599922f, 
    0.58939761f, 0.98857087f, -0.60801691f, -0.05461162f, 0.56674457f, 0.08979201f, 0.09456985f, 0.33494520f, 
    -0.02740749f, -0.51736897f, -0.50864035f, -0.09471919f, -0.15062875f, 0.16487160f, -0.15752979f, -0.01619925f, 
    0.05689302f, -0.06219250f, 0.12987626f, 0.09061885f, -0.15605026f, 0.08564001f, -0.11292464f, 0.11353010f, 
    0.12601921f, -0.17570233f, 0.43130770f, 0.22132389f, -0.16904058f, -0.08139143f, -0.24314772f, -0.11661603f, 
    -0.10416970f, -0.11882897f, 0.35019082f, 0.08657959f, 0.02848559f, 0.17892598f, -0.31327713f, 0.25064984f, 
    -0.03830024f, 0.09314005f, 0.01065430f, -0.21808901f, 0.23208646f, -0.09050176f, 0.03675794f, 0.19867043f, 
    0.17016163f, -0.00591131f, -0.32872805f, 0.23819277f, -0.18255347f, 0.27907035f, 0.39816105f, -0.28226826f, 
    0.37710252f, -0.26045778f, -0.80464715f, -0.66634375f, -0.39675939f, 0.10619326f, -0.20266096f, -0.04854567f, 
    0.47164863f, -0.09487036f, 0.18773243f, -0.29011947f, -0.27391988f, 0.18664292f, -0.24561083f, -0.40502557f, 
    -0.26389268f, 0.11664466f, 0.10494315f, 0.20183927f, -0.09080981f, -0.10392166f, -0.36474681f, 0.14156769f, 
    0.26228371f, -0.17270021f, -0.10807957f, 0.11142533f, 0.24316491f, 0.22398897f, 0.06218925f, -0.02230682f, 
    -0.05507495f, 0.10288108f, -0.31580931f, 0.05001685f, -0.21650144f, 0.25027260f, 0.31784403f, -0.42008859f, 
    0.02309578f, -0.10231220f, -0.18518868f, -0.22330271f, 0.58620381f, 0.35695755f, 0.55645382f, 0.50601047f, 
    -0.20442043f, -0.15442075f, -0.42305410f, -0.13363072f, 0.20672572f, 0.05138284f, -0.34806651f, -0.28244185f, 
    -0.05239203f, 0.03889271f, 0.26211542f, -0.32071924f, 0.27581543f, 0.09285617f, 0.09158104f, 0.11785365f, 
    -0.22772141f, 0.12892836f, 0.03805105f, -0.07385625f, -0.19851416f, -0.23881790f, -0.50977302f, -0.88813305f, 
    0.76338583f, 0.42200625f, -0.34611782f, -0.44106150f, -0.57737470f, 0.59455800f, -0.18118933f, -0.29292339f, 
    -0.40889263f, -0.19353183f, 0.15159860f, 0.06529618f, -0.05290640f, 0.09470969f, 0.06415934f, -0.15034401f, 
    -0.21376562f, 0.34906241f, 0.31236717f, -0.19978936f, 0.05626027f, 0.01253461f, -0.11865147f, 0.14760116f, 
    -0.03016083f, -0.36138698f, -0.08165802f, 0.42304322f, -0.02238144f, 0.80117470f, -0.12446710f, -0.70979327f, 
    -0.57962996f, -0.21683379f, -0.23443882f, -0.24603920f, -0.33346075f, -0.06125773f, -0.22214793f, -0.00458797f, 
    0.04615112f, -0.22223671f, 0.16484027f, 0.19471920f, -0.23942021f, -0.22671035f, 0.36681598f, -0.39915258f, 
    -0.99915123f, -0.39659294f, -0.48822325f, -0.94197357f, -0.58037823f, 0.36221179f, 0.01723880f, -0.25140637f, 
    -0.33100575f, -0.11785049f, -0.30324852f, -0.36669070f, -0.35524291f, -0.34418893f, -0.12550473f, -0.06349844f, 
    -0.04842953f, -0.20258588f, -0.27867827f, -0.34938464f, -0.10311916f, 0.12173624f, 0.11514875f, -0.20266813f, 
    0.06182536f, 0.33597237f, 0.15935121f, 0.38417670f, 0.49388891f, 0.27917650f, -0.02657542f, -0.14623439f, 
    0.37130126f, 0.25610071f, 0.17853449f, 0.23136677f, 0.09311280f, 0.16027182f, -0.09025586f, -0.05197706f, 
    -0.00037114f, 0.09516421f, -0.08180915f, -0.10225835f, -0.05898526f, 0.12381243f, -0.15741028f, -0.00757731f, 
    0.09976227f, 0.05909199f, 0.42246875f, 0.26015157f, 0.19901311f, -0.35856944f, -0.31743214f, -0.15615644f, 
    0.21956506f, -0.23170263f, -0.10219517f, -0.14622252f, -0.11659095f, -0.46797654f, 0.17649068f, 0.18789297f, 
    0.14152406f, -0.24494353f, 0.01849169f, -0.22923306f, -0.27834207f, -0.47055471f, -0.54664010f, -0.57020563f, 
    -0.29457062f, -0.55309933f, -0.67434698f, -0.45304421f, 0.19011588f, -0.17095853f, 0.22439402f, 0.15592188f, 
    0.33445722f, -0.45685005f, 0.14438403f, -0.01248797f, 0.16073240f, -0.44172230f, 0.21309780f, -0.44827089f, 
    0.35432523f, -0.29664519f, 0.25431180f, 0.25572860f, -0.18278657f, 0.20556483f, 0.27712294f, -0.28037536f, 
    -0.10431194f, 0.10746984f, -0.14667416f, -0.04070898f, 1.13819349f, -0.52861816f, -0.43454036f, -0.34992847f, 
    -0.62538093f, 0.62687969f, 0.43699136f, 0.30639079f, -0.27013659f, 0.00214249f, -0.19442405f, -0.01294793f, 
    0.02892826f, -0.03367785f, -0.22354759f, -0.04621426f, 0.09930880f, 0.02868982f, -0.27464941f, -0.01023433f, 
    -0.03582199f, -0.25276664f, -0.25328252f, -0.21154405f, -0.32746431f, 0.35678270f, -0.30648175f, -0.03176336f, 
    -0.42367110f, 0.24085419f, 0.17055699f, -0.19773604f, 0.74487329f, -0.40313464f, -0.27930501f, -0.08568192f, 
    0.14974524f, -0.04160324f, -0.24811576f, -0.10320711f, 0.29082173f, -0.13570330f, -0.42842272f, -0.00685377f, 
    -0.47341740f, -0.20425089f, 0.03769726f, 0.11923895f, -0.36867926f, -0.26750255f, -0.37208191f, 0.16483925f, 
    -0.02055202f, -0.12775351f, -0.22733214f, 0.05405857f, -0.12321071f, 0.14278397f, 0.35024244f, 0.21514887f, 
    -0.03318674f, 0.10334025f, -0.24560812f, -0.34985843f, -0.00044228f, -0.22102715f, 0.00481516f, -0.09253515f, 
    -0.04215525f, -0.29041258f, 0.21105827f, 0.35572323f, -0.06642406f, 0.30124837f, 0.26470169f, 0.14524081f, 
    0.36185738f, -0.50091070f, -0.42351019f, -0.34107101f, 0.11296900f, 0.09330182f, 0.34852150f, 0.33901826f, 
    -0.54060185f, 0.04434684f, -0.40800634f, -0.06909237f, -0.04543640f, -0.19602518f, 0.07698156f, 0.09315415f, 
    0.27833119f, 0.01881280f, -0.30093113f, -0.08992889f, -0.05052403f, -0.23817244f, 0.36490735f, 0.34583142f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.40848792f, 0.08076175f, 0.35276490f, 0.22115281f, 0.15346566f, 0.06155954f, 0.34223536f, 0.12510176f, 
    0.10829109f, 0.22070818f, 0.25872630f, 0.22435600f, 0.24905555f, 0.10631794f, -0.08954053f, -0.16830075f, 
    0.09485413f, 0.39169812f, 0.25726944f, 0.07623928f, 0.16748507f, 0.47460759f, 0.17724240f, -0.12869287f, 
    -0.49920705f, -0.29150778f, 0.42536768f, 0.29927135f, 0.07010148f, -0.06281030f, 0.39922678f, 0.23693657f, 
    0.32189959f, -0.25124684f, 0.13817315f, 0.16764535f, 0.11078711f, -0.07496070f, 0.15594463f, 0.21418114f, 
    0.34058496f, -0.12472029f, 0.38195807f, 0.01317116f, -0.22800316f, 0.21236633f, 0.19931960f, 0.37764263f, 
    0.40326780f, 0.11728471f, 0.28892678f, -0.07283056f, 0.34973407f, 0.10260887f, 0.27912050f, -0.05542890f, 
    0.10533182f, -0.04886101f, -0.07143771f, -0.09639693f, 0.27374157f, 0.24239169f, -0.06304948f, 0.14944586f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.25444525f, 0.01368720f, -0.08629119f, -0.11018656f, 0.01498366f, 0.02383916f, 0.06136565f, -0.01785935f, 
    -0.09396143f, -0.01044634f, -0.22190693f, -0.26268056f, 0.00463492f, 0.07980952f, 0.08020375f, 0.04093534f, 
    -0.07534775f, 0.10744776f, -0.05039958f, -0.07263952f, -0.02611037f, -0.23476189f, -0.02282385f, -0.03136213f, 
    0.13068949f, -0.18236592f, -0.17427668f, -0.01513730f, 0.02333472f, 0.03785693f, -0.01588481f, -0.06030479f, 
    -0.07690006f, -0.08834653f, 0.00414703f, -0.03822114f, 0.28020260f, -0.10520899f, -0.51597100f, 0.05697603f, 
    0.04164975f, 0.04174443f, 0.03067464f, -0.00910949f, -0.17362638f, -0.11038363f, -0.16252495f, -0.05543248f, 
    -0.28102785f, -0.47079265f, 0.01304366f, -0.01624591f, 0.02559383f, -0.07013385f, 0.02315409f, -0.02345875f, 
    -0.02854168f, 0.10691124f, -0.13292733f, 0.11614897f, -0.17176747f, 0.15375701f, -0.22555745f, 0.14893085f, 
    0.00700412f, -0.01281280f, -0.01432495f, -0.08267385f, -0.00403996f, -0.02629490f, 0.00287583f, -0.15254438f, 
    -0.08673651f, -0.22352810f, -0.57358563f, 0.01462386f, 0.05724445f, 0.06274578f, -0.03734863f, -0.07639778f, 
    0.03570297f, -0.25315326f, -0.14951783f, -0.38198805f, 0.11278312f, 0.09881036f, -0.02906174f, -0.21521541f, 
    0.06735289f, 0.17950827f, 0.00889336f, -0.05252295f, -0.04787127f, 0.03359608f, 0.05377597f, 0.00114765f, 
    0.25083417f, 0.15395072f, 0.06212756f, -0.26437560f, -0.06265365f, -0.04837661f, -0.22245973f, 0.04035117f, 
    -0.24463017f, -0.02816514f, -0.05101099f, -0.16726206f, -0.02927083f, 0.03614153f, 0.19468190f, -0.06884283f, 
    -0.02444222f, 0.10799139f, 0.01562513f, -0.02178232f, 0.01830340f, 0.01320231f, -0.01173682f, -0.10654350f, 
    0.17570883f, 0.12296482f, -0.03278256f, -0.11050567f, -0.08429599f, 0.02651294f, 0.04632970f, -0.06147578f, 
    -0.04817908f, 0.03194879f, 0.01587954f, -0.04194586f, 0.02234101f, 0.21676725f, 0.14915015f, -0.27881247f, 
    0.07596832f, 0.12361455f, -0.00888701f, -0.05918195f, 0.01388526f, -0.05353665f, -0.05097823f, -0.04654745f, 
    -0.00370225f, -0.20159566f, -0.17511958f, 0.06507750f, -0.04178777f, 0.07299161f, -0.04024345f, -0.05796862f, 
    -0.11384241f, -0.10272884f, -0.04243243f, -0.08657108f, -0.31901100f, -0.55607098f, 0.11182585f, -0.04076166f, 
    0.05419776f, 0.04755723f, -0.02293813f, -0.00162072f, 0.01167544f, 0.07157972f, -0.07421880f, 0.02313617f, 
    0.00403614f, 0.00811420f, -0.07703164f, 0.00215081f, 0.09860629f, 0.03180714f, -0.03972502f, -0.03457298f, 
    0.02984057f, -0.01991518f, 0.08605386f, -0.08842389f, 0.01708812f, 0.02762009f, -0.01968886f, 0.02786559f, 
    0.01398762f, 0.03594327f, 0.00268710f, -0.00915384f, -0.03892646f, 0.00299212f, -0.01766828f, 0.03608116f, 
    -0.05685987f, -0.08138627f, 0.03944784f, -0.15004238f, -0.13082944f, 0.05482941f, -0.03519559f, 0.00170022f, 
    -0.13668266f, -0.09831758f, -0.05571870f, -0.21442868f, 0.13491684f, 0.03995279f, -0.10226389f, 0.03780819f, 
    -0.04469258f, -0.08063191f, -0.01338309f, -0.05932382f, -0.17221788f, 0.13229807f, -0.01531621f, 0.04990210f, 
    0.25224182f, 0.25241470f, 0.01466210f, -0.24878599f, -0.06109696f, -0.03144657f, -0.02547351f, 0.03893290f, 
    -0.04977993f, -0.05205864f, -0.12570536f, 0.00855145f, -0.36115491f, -0.00376072f, 0.21462922f, 0.00917167f, 
    0.05990318f, 0.04724024f, -0.12643862f, 0.06412270f, 0.10069036f, 0.01019912f, -0.04043045f, 0.00097288f, 
    -0.16935554f, -0.39955983f, -0.19295093f, 0.15458620f, -0.00115363f, -0.01080664f, 0.02467012f, -0.03093210f, 
    -0.02407848f, 0.00360106f, 0.04445073f, 0.00871972f, 0.44835284f, 0.02542560f, -0.13185993f, -0.14503063f, 
    -0.06676679f, -0.00144111f, 0.07062293f, -0.04731001f, -0.04752072f, -0.11417260f, 0.07620633f, -0.04609355f, 
    0.00157768f, 0.12265097f, 0.09590580f, -0.06662737f, -0.18289982f, -0.01545087f, 0.08101440f, 0.08763592f, 
    -0.26006979f, -0.05171903f, -0.14603351f, 0.04457729f, 0.19842358f, 0.32811406f, -0.29870108f, -0.01584024f, 
    -0.02930908f, 0.11047803f, -0.00149795f, 0.14706899f, -0.05605412f, -0.00808789f, -0.02258012f, -0.05589648f, 
    0.43476385f, 0.37375426f, -0.13565888f, -0.20722087f, 0.09764564f, 0.16559251f, 0.16724533f, 0.14926094f, 
    0.01635254f, -0.00445270f, 0.04772537f, -0.02999779f, 0.30992588f, 0.17752701f, 0.02456283f, -0.04609603f, 
    0.14654405f, 0.18494396f, 0.11643497f, 0.14894956f, -0.04691468f, 0.06464291f, 0.07725891f, 0.04875008f, 
    0.04885623f, -0.24562736f, -0.10020073f, -0.06088023f, 0.02147394f, 0.02730458f, -0.01590141f, 0.00562028f, 
    -0.04549270f, 0.09314487f, 0.03246946f, 0.02975702f, -0.22745343f, -0.24207735f, -0.30299556f, 0.13933325f, 
    0.04912360f, 0.01592287f, -0.02095790f, -0.04758807f, -0.06447107f, 0.04745384f, -0.02870705f, 0.06222369f, 
    0.18005389f, -0.03736103f, -0.17100927f, -0.05445253f, -0.12685274f, 0.04033061f, 0.06556831f, 0.13630819f, 
    0.12301601f, 0.10741119f, -0.07393412f, 0.01783846f, 0.23372994f, 0.07218393f, -0.04147328f, -0.08996217f, 
    0.12465259f, -0.13046683f, 0.07247195f, 0.04394188f, 0.02852199f, 0.04536253f, -0.00936344f, 0.04413891f, 
    -0.36092579f, -0.63536799f, -0.16014682f, 0.08895243f, 0.00841522f, -0.01942327f, 0.04456002f, 0.07373744f, 
    -0.07569073f, 0.01450959f, -0.00159478f, 0.00252924f, 0.10204634f, 0.07678632f, 0.18643951f, -0.20876856f, 
    0.10442191f, -0.04593476f, 0.07092283f, 0.05367571f, -0.00267206f, -0.02665398f, 0.03373704f, -0.05863087f, 
    -0.37284431f, 0.06576174f, -0.22299543f, 0.14223301f, 0.03295801f, -0.00844291f, 0.00462255f, 0.00013176f, 
    0.01848677f, -0.07538085f, -0.01751488f, -0.00165096f, 0.19719438f, 0.18928279f, 0.05193771f, -0.10190940f, 
    0.08889828f, 0.09429310f, 0.07948688f, 0.06058059f, -0.00868038f, 0.08142722f, 0.04431820f, 0.09395155f, 
    0.12871918f, 0.01454081f, -0.26897690f, 0.09930870f, 0.08790784f, 0.04990516f, -0.12527052f, -0.27128214f, 
    -0.00250901f, -0.04873925f, -0.20371160f, -0.07172132f, -0.19895810f, -0.04134371f, 0.02947767f, -0.05383148f, 
    0.01189966f, -0.03863724f, -0.05065468f, 0.00011018f, -0.03924965f, 0.05419711f, -0.10605701f, -0.03213495f, 
    0.44705063f, 0.23247458f, -0.18385640f, -0.17812815f, -0.09426255f, -0.08697495f, 0.04571697f, -0.06665521f, 
    -0.06752162f, -0.01678203f, 0.02611553f, 0.03388881f, 0.15218405f, 0.05500518f, -0.00015469f, -0.24089068f, 
    0.01878874f, 0.04592863f, 0.05657434f, 0.18722573f, -0.03223065f, 0.01840845f, 0.00910402f, 0.02041985f, 
    -0.62554479f, -0.07746631f, -0.11721976f, 0.04697529f, 0.05179395f, 0.00907395f, 0.07533679f, 0.04151957f, 
    -0.07077078f, -0.07869995f, -0.06257609f, -0.01660870f, -0.08403362f, 0.04704175f, 0.13139446f, -0.07655152f, 
    -0.04122322f, -0.05558414f, 0.01315172f, 0.02147064f, -0.02353101f, -0.00638033f, -0.04376504f, 0.00799326f, 
    0.12695871f, -0.04874117f, 0.05012720f, -0.04188729f, 0.05343642f, 0.16156393f, -0.06736819f, -0.10029589f, 
    -0.05773450f, -0.08798280f, 0.00324480f, -0.00979961f, 0.34890729f, -0.00359223f, 0.03020036f, -0.16863298f, 
    0.16432758f, -0.07304134f, 0.18771210f, -0.16594955f, -0.01887044f, 0.00451293f, -0.02637583f, 0.00000721f, 
    -0.31080714f, -0.59683663f, -0.16559991f, 0.17318590f, 0.03683516f, 0.06377529f, -0.13715051f, -0.07295067f, 
    -0.06158444f, -0.02658035f, -0.18755630f, -0.10622526f, 0.19287345f, 0.05561714f, -0.13719916f, -0.14713533f, 
    0.01185002f, 0.09189468f, 0.07963600f, -0.03354807f, 0.09448468f, -0.01179486f, 0.00498155f, 0.01378259f, 
    0.23007375f, 0.26564085f, 0.21242940f, -0.16744821f, -0.27888897f, -0.10111650f, -0.05545290f, 0.04068508f, 
    0.02208022f, -0.04149185f, -0.04629663f, 0.01762202f, 0.25859371f, 0.14285763f, 0.11041408f, -0.06929097f, 
    0.01814722f, 0.09501323f, 0.07777067f, 0.01357312f, 0.18996370f, -0.04771998f, 0.01419479f, -0.05307456f, 
    -0.00714657f, -0.04659749f, -0.12064435f, 0.04735237f, -0.15944113f, -0.14980994f, -0.01342174f, 0.04730421f, 
    -0.02634436f, 0.04194986f, 0.01607039f, -0.01511752f, 0.05678487f, -0.01193911f, 0.17978913f, -0.16087979f, 
    -0.10870115f, -0.11224607f, -0.09734657f, -0.16619000f, -0.00217494f, -0.14408307f, -0.13327061f, -0.08808549f, 
    0.11026386f, 0.29177344f, 0.17653376f, -0.27570555f, -0.00555007f, 0.09796386f, 0.12850736f, -0.29443610f, 
    0.00412266f, -0.12014689f, 0.04764104f, -0.09769582f, 0.02484971f, -0.54503596f, 0.10557692f, -0.01792576f, 
    -0.04722793f, -0.01178844f, 0.05601774f, -0.02918691f, -0.01211063f, 0.04192415f, 0.01422341f, 0.06569157f, 
    -0.11976074f, -0.15318884f, -0.05024062f, 0.01407164f, -0.10994805f, -0.26881340f, -0.06003404f, -0.03220787f, 
    -0.06476045f, -0.05578545f, -0.13784988f, -0.03871900f, 0.20075604f, -0.28887209f, -0.54918504f, -0.48137617f, 
    0.06304556f, -0.16077103f, -0.04862295f, -0.00067729f, -0.02604720f, 0.02874967f, 0.08373821f, 0.09861759f, 
    -0.31952503f, 0.06228311f, -0.05901483f, -0.02357337f, -0.00149383f, 0.01196833f, 0.06388304f, 0.00059152f, 
    -0.05593413f, -0.12415943f, -0.28258780f, -0.14680529f, -0.12448053f, -0.09422636f, 0.05262616f, 0.07984179f, 
    -0.02860902f, 0.00492046f, -0.09812117f, 0.01216968f, 0.05338795f, 0.02689962f, -0.06528071f, -0.00565690f, 
    0.21016799f, -0.08662361f, 0.16183735f, -0.31805316f, 0.04803921f, 0.04585470f, 0.00750050f, 0.05864782f, 
    -0.03458250f, 0.00304442f, 0.00402585f, -0.02099850f, 0.32041386f, -0.13469268f, -0.19294278f, 0.19961683f, 
    -0.06626111f, -0.10369965f, 0.00507771f, -0.20031121f, 0.00961900f, -0.03163677f, 0.03797049f, 0.05649915f, 
    0.22354741f, 0.19065703f, -0.13365574f, -0.11621960f, 0.11431491f, 0.21413906f, 0.04215852f, 0.01324964f, 
    -0.03437819f, 0.00349933f, 0.01214632f, 0.03273910f, -0.09387132f, -0.05727637f, -0.01912370f, 0.01210401f, 
    0.03630738f, 0.06401880f, 0.04697725f, 0.02010870f, -0.02975949f, 0.03743120f, -0.02459703f, 0.02213633f, 
    -0.00811099f, -0.18766363f, -0.10531419f, -0.00916930f, -0.03938975f, -0.08852327f, -0.10305260f, 0.03978969f, 
    -0.10309196f, -0.08604157f, 0.12364529f, 0.17274866f, -0.04057223f, 0.06793374f, 0.04063827f, -0.01490854f, 
    -0.01924087f, -0.03842841f, 0.13594818f, 0.02689158f, -0.05843969f, 0.09167974f, 0.00943821f, -0.05367466f, 
    0.01142310f, -0.36596692f, -0.39569062f, 0.03543577f, 0.01572327f, 0.01227769f, -0.10819934f, -0.01904448f, 
    0.09359882f, -0.01615850f, -0.07693073f, -0.03032732f, 0.00870884f, -0.18226263f, -0.24256051f, 0.06088538f, 
    -0.04763436f, 0.02589473f, 0.03567832f, -0.05845506f, -0.11415110f, 0.03326376f, 0.01320083f, 0.05842867f, 
    -0.02170731f, 0.01530923f, 0.14121479f, -0.00372561f, 0.03272456f, 0.01758427f, -0.03303984f, 0.04326399f, 
    0.02675786f, -0.07736489f, 0.00310257f, -0.13028111f, 0.11400020f, -0.14015643f, -0.02743739f, -0.11172934f, 
    0.03610739f, 0.02116721f, -0.15919447f, -0.10239558f, 0.02275501f, 0.02839645f, 0.04718573f, -0.07468247f, 
    -0.04530424f, -0.04309157f, 0.04392892f, 0.18070236f, -0.02536812f, 0.00144897f, 0.03382663f, 0.05764516f, 
    0.12841646f, -0.10220610f, 0.01000892f, 0.04949711f, -0.03199095f, 0.01199767f, -0.05994114f, 0.00801142f, 
    0.03529603f, -0.00531582f, 0.03893311f, 0.06293810f, -0.11139011f, -0.10596339f, 0.02932156f, 0.00277355f, 
    0.00435985f, -0.33774018f, -0.07315394f, -0.15388240f, -0.02324306f, 0.00592462f, 0.07868137f, 0.00252330f, 
    0.06886862f, 0.05675147f, 0.09839965f, -0.07025564f, 0.14850350f, -0.14640440f, -0.05398842f, -0.03732381f, 
    -0.08534089f, -0.02117591f, 0.04199753f, -0.00537751f, 0.00455037f, 0.02033402f, 0.11870981f, -0.02676170f, 
    -0.22081088f, -0.25584850f, 0.21802495f, 0.08268140f, 0.01889473f, -0.11496652f, 0.00408752f, 0.05058113f, 
    -0.00674724f, -0.12219547f, 0.04835678f, 0.01055133f, 0.51143670f, -0.04401844f, 0.07366960f, 0.16684282f, 
    0.03416323f, -0.02123788f, 0.02146629f, -0.00197581f, -0.03113834f, -0.05029467f, 0.00965396f, -0.28263965f, 
    0.77649063f, -0.28113803f, -0.21954529f, -0.10019716f, -0.04155484f, -0.00715021f, 0.11628926f, -0.01785755f, 
    0.23455845f, 0.02286135f, 0.17362557f, -0.05143206f, 0.06538797f, 0.24379474f, 0.01098287f, 0.15110184f, 
    -0.04678215f, 0.11363719f, -0.13170524f, -0.17426400f, -0.06091468f, 0.01858258f, 0.04864463f, -0.03372237f, 
    -0.23789443f, -0.17981952f, -0.07813423f, -0.26336369f, 0.04995622f, -0.03422158f, 0.07614298f, 0.21595488f, 
    -0.06514145f, -0.07244467f, -0.12807223f, 0.05041555f, -0.44196093f, 0.03647125f, 0.06055655f, -0.15219107f, 
    0.03096987f, 0.04396477f, -0.09840363f, -0.05495790f, -0.03352773f, -0.01931299f, -0.02752207f, -0.01611467f, 
    -0.08001409f, 0.07838167f, -0.04062392f, -0.06823604f, -0.02175436f, 0.00848185f, -0.03454307f, 0.12054054f, 
    -0.12969621f, -0.05315485f, 0.09772927f, -0.11088120f, -0.30409539f, -0.11655784f, -0.09270597f, -0.02229884f, 
    -0.09406353f, -0.06747635f, 0.11789350f, 0.23946930f, -0.05641023f, -0.07162058f, 0.07996305f, 0.05114852f, 
    0.44344142f, -0.02352929f, 0.13070378f, -0.02769856f, 0.02441425f, -0.05484311f, -0.01684837f, -0.02170900f, 
    0.04031090f, 0.01644960f, 0.02844546f, -0.00457845f, 0.32575360f, 0.24244192f, 0.12389182f, 0.11044841f, 
    -0.05858169f, -0.01178377f, 0.00890927f, 0.03272808f, 0.05488730f, 0.06740324f, -0.01520742f, -0.21545233f, 
    0.17944883f, -0.07567608f, -0.03233955f, -0.01603945f, -0.17384683f, -0.01526311f, -0.08157741f, -0.05970859f, 
    -0.03734268f, -0.08859862f, 0.01841140f, -0.02218153f, -0.00424886f, -0.04948169f, -0.02772813f, 0.02852980f, 
    -0.07642840f, -0.02479324f, -0.02567791f, -0.03834413f, -0.09166549f, -0.19922110f, -0.04724322f, -0.00926106f, 
    -0.02889628f, 0.05679459f, 0.01451165f, -0.08425227f, -0.07690199f, 0.05052345f, -0.02746066f, 0.03382349f, 
    0.12945130f, -0.05957234f, -0.02914258f, 0.21846621f, -0.22685499f, -0.20706733f, -0.02254512f, 0.00057774f, 
    0.10437159f, 0.08827209f, 0.13848248f, -0.07784311f, 0.10916900f, 0.08750473f, 0.00697497f, 0.06644911f, 
    -0.29952231f, 0.03893248f, -0.28497100f, -0.03943307f, -0.00324315f, -0.01395403f, 0.12576436f, 0.12554274f, 
    0.10901251f, -0.04745343f, -0.20382723f, -0.05255518f, -0.23698835f, -0.09261958f, 0.28333461f, -0.12569469f, 
    0.02237545f, -0.05565608f, -0.07280193f, -0.03872368f, -0.01904449f, 0.02161402f, -0.13227257f, 0.00331432f, 
    0.44719896f, 0.18200257f, 0.39557594f, 0.07466225f, -0.00083251f, -0.07764020f, 0.03569753f, -0.07626904f, 
    0.00906779f, -0.05189126f, 0.03080062f, 0.06532628f, 0.39655036f, -0.21861024f, -0.11962211f, -0.00780513f, 
    0.06327172f, 0.05599894f, 0.00298882f, -0.04534249f, 0.12121098f, -0.06190995f, -0.01371022f, -0.06388134f, 
    -0.04096464f, 0.00010573f, 0.03582421f, 0.03520302f, 0.06644575f, 0.03139972f, -0.07397838f, 0.05969842f, 
    0.16579503f, 0.04177019f, -0.06380946f, -0.00477388f, 0.24435030f, -0.10031811f, -0.00881441f, 0.23125683f, 
    0.03162766f, 0.04517888f, 0.03371131f, -0.02897837f, 0.02130138f, -0.01813759f, -0.17548829f, 0.12785596f, 
    0.41576052f, 0.20394626f, 0.16460243f, 0.18225384f, -0.07801602f, 0.11917182f, -0.25348336f, -0.01027880f, 
    0.04304072f, -0.01010609f, -0.07708944f, 0.07126097f, -0.06367752f, 0.10222220f, 0.15097395f, 0.09241915f, 
    0.04739660f, -0.10877474f, -0.22944961f, -0.22997338f, -0.04548546f, -0.04320035f, -0.03068090f, 0.00748021f, 
    0.22386272f, -0.16165872f, -0.07316385f, -0.19443493f, 0.04057724f, -0.08414149f, 0.09370507f, -0.12943332f, 
    0.02812001f, 0.18050134f, -0.03137913f, 0.11708426f, 0.28207853f, -0.03146520f, 0.19718347f, 0.09580129f, 
    -0.10137089f, -0.01979184f, 0.02404863f, 0.06387489f, -0.02688440f, 0.01790733f, -0.02841053f, -0.01085497f, 
    -0.00802320f, -0.03307110f, 0.01245789f, -0.04996490f, -0.10281899f, 0.13345134f, 0.09358456f, 0.08689980f, 
    -0.13297345f, 0.30716220f, 0.02654045f, -0.06225438f, -0.00836676f, 0.06505690f, -0.22589824f, -0.36104143f, 
    -0.06219011f, -0.20794529f, -0.09611287f, 0.03939997f, -0.00765223f, -0.08837343f, 0.00809194f, 0.09855738f, 
    0.35339347f, 0.14383748f, 0.32166836f, 0.00915504f, -0.02322282f, 0.00208433f, -0.07228865f, 0.06814019f, 
    0.02948139f, -0.01089375f, -0.03903576f, 0.00210597f, 0.08783706f, -0.00536161f, -0.11785363f, -0.09804946f, 
    -0.08566485f, 0.13040684f, -0.11546860f, -0.14698474f, -0.04667446f, -0.04711147f, 0.01105257f, -0.02912270f, 
    0.01963195f, 0.13362329f, 0.11260618f, 0.09940763f, -0.00223095f, 0.01199478f, -0.06105179f, -0.02068676f, 
    -0.00283757f, -0.06385717f, 0.08011909f, -0.01940744f, 0.16538471f, 0.26043519f, 0.03538016f, 0.03333434f, 
    0.13633355f, 0.00597956f, -0.17362204f, -0.17007966f, 0.07976714f, 0.04836448f, -0.01119159f, -0.22670349f, 
    -0.10024501f, -0.47542462f, 0.32242438f, -0.02623405f, -0.03928787f, 0.05047644f, 0.01741891f, 0.15531325f, 
    0.02863417f, -0.14019765f, 0.07647152f, 0.09937206f, 0.03562724f, 0.02788925f, 0.06201924f, -0.03310880f, 
    -0.02860854f, -0.04622344f, -0.02986393f, -0.01057686f, 0.06049635f, 0.00254956f, -0.02703807f, 0.01477859f, 
    0.12937914f, -0.17031753f, -0.13967420f, -0.04384580f, -0.05628098f, -0.00316314f, -0.02961981f, 0.08559811f, 
    0.05715755f, 0.00083896f, 0.04884533f, -0.06784490f, 0.17305045f, 0.16856900f, 0.07337139f, -0.35083660f, 
    -0.05744774f, 0.13243046f, 0.06327760f, 0.11527633f, -0.01144962f, 0.02633878f, -0.07645509f, -0.04245942f, 
    0.01640399f, 0.05211814f, 0.11545703f, 0.05112519f, -0.02288475f, 0.00711720f, -0.07335502f, -0.04532310f, 
    -0.19885293f, -0.10156153f, -0.08345335f, -0.12702127f, -0.09707239f, 0.07346790f, -0.01914371f, 0.04464034f, 
    0.18713117f, 0.03100052f, -0.00687893f, 0.02398721f, -0.04987932f, -0.00522545f, 0.01421983f, 0.04067017f, 
    -0.17294222f, 0.01450840f, -0.09937542f, -0.19151019f, 0.02948092f, 0.10387974f, 0.02655948f, -0.02801759f, 
    -0.13062029f, 0.04765486f, 0.03723343f, -0.08276986f, -0.23303221f, -0.01769323f, 0.18966450f, 0.05805476f, 
    -0.06990539f, -0.03457918f, 0.11693417f, -0.34715483f, 0.04382446f, 0.01662122f, 0.01558881f, 0.01932539f, 
    0.66633713f, -0.04762667f, -0.07018021f, -0.03139715f, 0.00038763f, -0.01659868f, -0.03563420f, -0.01963572f, 
    -0.09535750f, 0.05326345f, -0.12458865f, 0.06497223f, -0.15274285f, -0.08322582f, 0.00576421f, -0.11933462f, 
    -0.03044082f, 0.00365125f, -0.05631553f, 0.01375222f, 0.01511164f, 0.05021616f, 0.06139409f, -0.02382400f, 
    -0.68306196f, -0.13535163f, -0.61347127f, -0.48477185f, 0.04708678f, 0.03872890f, -0.02960226f, -0.06846550f, 
    0.00854121f, -0.01745724f, -0.03194880f, 0.02974641f, -0.10499635f, 0.07719564f, -0.24034059f, -0.14016433f, 
    -0.01081308f, 0.03287876f, 0.01621616f, 0.02190310f, -0.15610334f, -0.05043388f, -0.17939302f, -0.00495910f, 
    0.09569288f, -0.01666111f, -0.07462678f, -0.04601787f, 0.09192905f, -0.07349766f, 0.11840127f, 0.06132808f, 
    -0.08161460f, 0.00804902f, 0.02685011f, -0.01638936f, -0.37115663f, -0.07980083f, -0.00337036f, -0.31645334f, 
    0.07581161f, 0.13493793f, 0.14200491f, 0.04237564f, 0.06577523f, 0.00504994f, 0.00289097f, 0.04607569f, 
    -0.67927933f, 0.02246473f, -0.28603014f, -0.03180648f, 0.01871063f, 0.13395286f, -0.01736553f, -0.06498183f, 
    -0.04455424f, 0.06829774f, -0.08324949f, 0.05051018f, 0.45814180f, 0.09822313f, -0.06547017f, 0.00170049f, 
    -0.07359161f, -0.02247882f, -0.06603930f, -0.07478225f, -0.05359688f, -0.00561465f, 0.10248032f, 0.04370787f, 
    0.03920418f, -0.05041354f, 0.07147207f, 0.01540570f, 0.05622389f, -0.01765486f, -0.02551623f, 0.03846679f, 
    0.07700212f, -0.11422653f, -0.03856938f, -0.02828033f, -0.03951671f, -0.29818732f, 0.01908115f, 0.01537503f, 
    -0.00631217f, -0.07532217f, -0.11025526f, 0.03825159f, -0.03799042f, 0.00624758f, 0.07030254f, -0.14434698f, 
    -0.04151377f, 0.28622559f, 0.09410668f, -0.09172981f, -0.02934280f, 0.10670077f, -0.01035857f, -0.10085569f, 
    0.26061800f, -0.13241734f, -0.02473656f, -0.02902799f, 0.17136520f, -0.01812735f, 0.04711251f, 0.00389079f, 
    0.00021937f, -0.06867238f, -0.04337882f, -0.01196115f, -0.01662114f, -0.05141539f, 0.03480534f, 0.01244316f, 
    -0.40305486f, 0.13392960f, 0.03389554f, -0.19021846f, -0.05036526f, 0.00158729f, 0.04389188f, 0.07653395f, 
    -0.00869058f, -0.02438288f, 0.03963070f, 0.03270633f, 0.14382103f, -0.60186398f, 0.31748495f, -0.27606237f, 
    0.00329771f, -0.15354605f, 0.15851195f, -0.19178484f, 0.01635614f, 0.00587851f, -0.08596467f, 0.06531909f, 
    0.18395422f, 0.19247286f, 0.22505474f, 0.12779053f, 0.24845603f, 0.11377934f, -0.00106387f, 0.13114583f, 
    -0.00965085f, 0.01267890f, -0.02027700f, -0.02060401f, 0.10163549f, 0.11429403f, 0.15756412f, 0.06609160f, 
    -0.04315306f, -0.00724985f, -0.02518947f, -0.06254026f, 0.04258378f, 0.05093351f, 0.01333207f, 0.04937771f, 
    0.12430302f, -0.14010072f, 0.18733737f, -0.16306122f, 0.05451494f, -0.01439342f, -0.06023359f, -0.01992852f, 
    -0.26089624f, -0.30736661f, -0.30543453f, -0.34041673f, -0.13083510f, 0.03654684f, -0.04583377f, 0.02195843f, 
    0.02396254f, 0.06618053f, -0.25747442f, 0.04827497f, 0.03990486f, -0.11729815f, -0.10912875f, 0.08933628f, 
    0.69848728f, -0.21175852f, -0.04769631f, -0.10107508f, -0.00439759f, -0.04314617f, -0.09888022f, -0.02778473f, 
    -0.07116587f, -0.28854990f, -0.03709010f, -0.04337628f, 0.32079622f, -0.18369642f, -0.14409027f, 0.21623272f, 
    -0.04774007f, -0.01439173f, -0.06283960f, -0.00190293f, -0.06933719f, -0.00794344f, -0.29783866f, -0.04450316f, 
    -0.17462824f, 0.13788106f, 0.10985026f, -0.21480128f, 0.10676515f, 0.04694159f, -0.02663964f, 0.00931790f, 
    -0.02840508f, 0.02806673f, 0.00545884f, -0.04095380f, 0.00282228f, 0.02958446f, 0.09724411f, -0.04839330f, 
    -0.01588530f, 0.06389035f, 0.13927196f, -0.21759075f, -0.04026154f, 0.02319506f, -0.07048345f, -0.06094771f, 
    -0.01989923f, -0.20283064f, -0.23996198f, 0.01654772f, 0.01523086f, 0.00451866f, 0.08537837f, 0.04335158f, 
    -0.03586239f, -0.06360093f, -0.08918563f, 0.01528222f, -0.07739449f, 0.02057546f, -0.01565643f, 0.05922598f, 
    0.00468563f, -0.02344925f, -0.00788099f, 0.02902842f, -0.10028549f, -0.04835062f, 0.04346829f, -0.02417837f, 
    -0.03233407f, 0.16211244f, 0.14365248f, 0.05652095f, -0.03223490f, 0.04563941f, 0.01012347f, -0.08841481f, 
    -0.10283509f, -0.22786079f, -0.04513222f, 0.08512364f, 0.11226315f, 0.11481638f, 0.32893890f, -0.05178682f, 
    -0.04826466f, -0.06371757f, 0.10368862f, 0.04928795f, 0.07283949f, 0.03042456f, 0.02083153f, -0.11725099f, 
    0.05597141f, -0.19759542f, -0.13891014f, 0.03787055f, -0.04457394f, 0.06347804f, 0.00344529f, -0.07578496f, 
    0.03621565f, -0.25437209f, 0.03128602f, 0.12405001f, -0.08671311f, -0.17626700f, -0.04648095f, 0.11378217f, 
    -0.04105781f, 0.03585741f, -0.04649688f, 0.00464968f, -0.04187499f, 0.03484632f, -0.11306765f, -0.03808981f, 
    -0.03843553f, 0.30395618f, 0.20970197f, -0.12770244f, -0.05876469f, 0.02599418f, -0.08454107f, 0.03122869f, 
    0.01310816f, -0.03576409f, -0.22274478f, -0.06022979f, 0.35452119f, 0.07701387f, 0.26236638f, 0.58440679f, 
    0.03003514f, 0.12157951f, 0.03190960f, 0.11779404f, 0.03878969f, -0.02132396f, -0.04738646f, 0.03295106f, 
    -0.12864241f, -0.03097085f, -0.01600828f, -0.29509646f, 0.00133974f, 0.01032207f, 0.07169266f, -0.03430206f, 
    0.06550064f, -0.13931574f, -0.05564222f, 0.12739843f, 0.24802575f, 0.23694099f, -0.08924453f, 0.27459899f, 
    0.01640872f, 0.05439849f, 0.10765491f, -0.06747231f, 0.01857093f, 0.03642560f, -0.01889231f, 0.07775106f, 
    -0.27490553f, -0.08790712f, 0.19124271f, 0.25838056f, 0.08912831f, 0.05360781f, -0.09947558f, -0.01809682f, 
    -0.02751330f, -0.01432103f, -0.15614453f, 0.09940791f, -0.07934102f, -0.11769252f, -0.25071311f, 0.09131752f, 
    0.15941668f, -0.00972758f, -0.10429227f, 0.16987097f, -0.01072571f, -0.09340644f, 0.11042988f, -0.03167356f, 
    -0.18791574f, 0.09176210f, 0.21162954f, -0.23683196f, -0.05989463f, 0.07613919f, -0.05540156f, 0.09851789f, 
    0.00381349f, -0.04456769f, 0.15310420f, -0.04584385f, -0.13239194f, -0.02633668f, -0.14584066f, -0.11599252f, 
    0.02578103f, -0.04680219f, 0.06761839f, -0.00650092f, -0.06674695f, -0.01839042f, 0.06250867f, 0.08276470f, 
    -0.03715188f, 0.00601089f, 0.03251337f, 0.08866251f, -0.02763181f, 0.11901408f, -0.04956352f, 0.00905894f, 
    0.05780662f, -0.00426157f, 0.05735571f, -0.00183198f, -0.01087359f, -0.00660595f, 0.00376390f, 0.08917408f, 
    -0.00867702f, -0.10166287f, 0.06415328f, 0.01169232f, 0.10175120f, 0.02777606f, 0.01258419f, -0.00602468f, 
    0.09739695f, 0.10054716f, -0.15537199f, -0.04134757f, 0.05147965f, -0.01667465f, -0.05856843f, 0.08161249f, 
    -0.08450668f, -0.11242813f, -0.28836960f, 0.08741845f, 0.08453672f, -0.10473868f, -0.05498452f, 0.02894367f, 
    -0.01408392f, -0.03192480f, 0.17572899f, -0.03506704f, 0.08302417f, -0.01142424f, 0.00422693f, 0.04902874f, 
    -0.04857252f, -0.05451158f, -0.10326216f, 0.14750952f, -0.06771783f, -0.11228531f, -0.02359394f, 0.19240345f, 
    -0.01709833f, 0.00310115f, 0.00902320f, 0.04687249f, -0.31560776f, -0.12470506f, -0.12595233f, -0.16241780f, 
    0.04543565f, -0.01334545f, 0.02356720f, -0.00016786f, -0.00267732f, 0.05051767f, -0.11093690f, 0.05521410f, 
    0.06869514f, 0.09111713f, -0.10411976f, -0.08165460f, 0.05184851f, -0.05964604f, 0.06393468f, 0.04813854f, 
    -0.04559049f, 0.02824316f, -0.03874426f, -0.00683364f, 0.09937762f, -0.03464212f, 0.70184356f, 0.33573657f, 
    0.00125130f, -0.11757362f, -0.02977234f, 0.17655589f, 0.03024551f, -0.06611650f, 0.05309420f, -0.00194941f, 
    0.12746015f, -0.14347221f, 0.01858327f, 0.01136635f, 0.08166919f, -0.01048053f, -0.05142487f, 0.02094340f, 
    -0.02707988f, 0.21798077f, 0.02014416f, 0.01830101f, -0.08351794f, -0.48831049f, -0.23698105f, -0.29491210f, 
    0.07927410f, -0.18643904f, 0.03260097f, -0.06136592f, 0.02153961f, -0.03948303f, 0.02932129f, 0.01395015f, 
    -0.56454968f, -0.57217973f, -0.07033527f, 0.10352118f, -0.03164041f, -0.13170929f, -0.10335875f, 0.03497679f, 
    -0.05451579f, 0.01452717f, -0.02572368f, -0.00048236f, -0.67541540f, -0.57799590f, -0.24998070f, -0.14947094f, 
    -0.01994957f, -0.12007584f, 0.06976134f, -0.11275499f, 0.05666438f, 0.00124467f, -0.03346979f, -0.00426436f, 
    -0.20191135f, -0.13784105f, 0.08383925f, -0.06557721f, -0.02055207f, -0.06160367f, -0.23348036f, -0.27741051f, 
    0.02592494f, -0.09908092f, 0.01124602f, 0.00237154f, -0.08554181f, 0.04269182f, -0.07300998f, -0.22410609f, 
    0.03152512f, -0.04878015f, 0.00103783f, -0.00209366f, 0.01584482f, -0.01592349f, 0.00199114f, -0.07197016f, 
    -0.13116014f, -0.00289501f, -0.04496748f, 0.03768025f, -0.12394197f, 0.04122936f, 0.04827423f, -0.54839122f, 
    -0.01391728f, 0.04163608f, -0.01897232f, 0.07901888f, -0.19271649f, -0.11069195f, -0.16927183f, -0.26128948f, 
    0.05723336f, -0.10668094f, 0.00400805f, 0.05402492f, 0.07452406f, 0.03471253f, -0.05023090f, 0.01013038f, 
    -0.11536741f, 0.01760161f, 0.16885316f, -0.11320820f, 0.10499715f, -0.02068360f, -0.01208170f, 0.03357580f, 
    0.08615617f, -0.03630538f, -0.05168560f, 0.06581751f, 0.10315247f, 0.05349297f, -0.00193459f, 0.09587758f, 
    -0.04582735f, 0.15706244f, -0.03979789f, -0.10204867f, -0.02273517f, -0.03513524f, 0.12388416f, -0.06019877f, 
    -0.08677796f, 0.00021786f, 0.23511639f, -0.07778532f, 0.02962578f, 0.07972311f, -0.03730912f, 0.12144782f, 
    0.03828232f, -0.04037113f, 0.06012171f, -0.08824649f, -0.15660802f, 0.39812192f, 0.32297811f, 0.16466229f, 
    -0.07070553f, -0.04013130f, 0.16526981f, -0.11338189f, -0.01152498f, -0.04173130f, -0.05714456f, 0.10919585f, 
    0.13598295f, -0.28763071f, 0.13345464f, -0.25241989f, -0.04561264f, -0.08447824f, 0.08574752f, -0.10469940f, 
    -0.04255163f, -0.07884416f, -0.08495422f, -0.24780037f, -0.23896541f, -0.05677253f, 0.02803767f, 0.10436520f, 
    -0.12886961f, 0.01530686f, 0.06823942f, -0.08818735f, 0.00480534f, -0.06221697f, -0.12938666f, 0.11453866f, 
    0.24280462f, 0.40691781f, -0.23688728f, -0.10270882f, 0.06781519f, -0.02178835f, -0.04352448f, 0.11581869f, 
    -0.00015212f, 0.03547517f, -0.00422884f, -0.06212829f, -0.00285096f, 0.01739253f, 0.05583824f, -0.29010275f, 
    -0.15006748f, -0.00950154f, -0.07460703f, 0.10635030f, -0.03792987f, -0.03171318f, 0.04440917f, 0.08065482f, 
    -0.07005902f, -0.02511095f, 0.06768304f, 0.03666261f, 0.02516173f, -0.04225390f, 0.02189119f, -0.04586450f, 
    0.08203664f, 0.09532920f, 0.11431619f, 0.18385048f, -0.03494857f, -0.00360943f, -0.13172151f, 0.04910143f, 
    -0.02685639f, 0.07748676f, 0.03237747f, 0.03824524f, -0.03332428f, 0.00950911f, -0.02578666f, 0.02561476f, 
    0.14715470f, 0.29438955f, 0.22020371f, 0.28874224f, -0.00995038f, 0.03709387f, 0.08324021f, 0.01679505f, 
    0.13247232f, 0.04413694f, -0.01733776f, 0.05655370f, -0.44544536f, -0.30307651f, -0.55130392f, -0.07511254f, 
    -0.17172296f, -0.11550820f, 0.18474524f, 0.04028095f, -0.02856842f, -0.02929266f, 0.00246067f, -0.08710075f, 
    -0.35656482f, 0.39550745f, -0.09198724f, -0.30282250f, -0.09005433f, -0.03658810f, -0.09829693f, -0.01427794f, 
    0.06880566f, -0.17321257f, -0.00143926f, -0.02110156f, -0.00828676f, -0.08820237f, 0.06634701f, 0.07313821f, 
    0.01675269f, -0.07225380f, -0.18743758f, -0.20023116f, 0.10200337f, -0.14743733f, -0.02486951f, 0.06919785f, 
    -0.36716536f, 0.18206766f, -0.02815283f, -0.09520737f, 0.00488097f, 0.04807832f, 0.04202962f, -0.01555534f, 
    0.01013889f, -0.01127878f, 0.04694640f, -0.05134339f, 0.03995010f, 0.06461497f, 0.12280811f, 0.16345695f, 
    0.01111110f, 0.02408240f, -0.04587931f, 0.06509843f, -0.03874258f, -0.15334862f, 0.08484120f, -0.05251506f, 
    -0.07810941f, -0.06966007f, 0.09066807f, -0.00970071f, -0.06242842f, -0.12796895f, -0.29306975f, 0.08129713f, 
    0.01384062f, 0.04462672f, -0.07167410f, 0.05217674f, -0.25372633f, -0.00481624f, -0.25644997f, 0.10661813f, 
    0.00733813f, 0.01709055f, 0.09884045f, -0.14488299f, 0.01486366f, 0.00147840f, -0.06346419f, -0.11826181f, 
    0.02786728f, 0.09311786f, -0.52289683f, 0.09998243f, 0.07305909f, 0.19587108f, -0.12437308f, 0.09909996f, 
    -0.03197055f, -0.01389508f, 0.01037371f, 0.10751100f, -0.37854677f, 0.22122972f, -0.31041676f, 0.05970512f, 
    0.02371360f, -0.12975146f, 0.08971344f, -0.03514849f, -0.01078616f, -0.04592373f, 0.10186210f, 0.01295885f, 
    -0.11724016f, 0.07684535f, 0.02422059f, 0.06256860f, 0.05010037f, 0.05963880f, -0.00186572f, -0.02770279f, 
    0.04415007f, -0.06460238f, -0.06832242f, 0.20506696f, -0.75296098f, 0.10420733f, -0.09012924f, -0.31014907f, 
    -0.00203813f, -0.05476686f, -0.05784129f, -0.20956339f, -0.05246034f, -0.02769506f, 0.05998496f, -0.07405222f, 
    -0.08195812f, 0.07754102f, -0.03888463f, 0.03463165f, 0.00519490f, 0.08058825f, -0.05037349f, -0.00005385f, 
    0.05097032f, -0.14547110f, 0.23143806f, -0.02340715f, -0.02955891f, -0.22698517f, -0.01570637f, -0.06742040f, 
    -0.00250930f, -0.00712707f, -0.01805057f, -0.00248177f, 0.01125875f, -0.09826566f, -0.02115858f, 0.01676512f, 
    0.40671816f, 0.03714513f, -0.36262783f, 0.10397461f, -0.01007085f, -0.06012494f, 0.16155757f, -0.11619080f, 
    -0.01143596f, 0.01394346f, -0.02730064f, -0.03715891f, 0.27469864f, -0.08299473f, -0.24190222f, -0.26010260f, 
    0.04096704f, -0.26261750f, 0.12722930f, -0.04664258f, 0.00549599f, 0.02810280f, -0.13753650f, -0.03013472f, 
    -0.29816738f, 0.26476362f, 0.45497096f, 0.42356610f, -0.02616368f, -0.00824217f, -0.06206943f, -0.03590108f, 
    0.02547578f, -0.01819938f, -0.06531494f, -0.00222157f, -0.17543583f, -0.04489616f, -0.03131215f, 0.04943396f, 
    -0.05858972f, -0.04980187f, 0.02864899f, 0.08018932f, -0.06017555f, -0.00806779f, -0.01362845f, 0.00459169f, 
    -0.04668460f, -0.07053552f, 0.10405938f, -0.04703904f, -0.04456184f, -0.03294155f, -0.01852755f, -0.11911458f, 
    -0.00007555f, 0.16958819f, 0.17215888f, 0.07446653f, -0.01928060f, -0.09067937f, -0.08025683f, 0.08736427f, 
    0.06528004f, 0.10123868f, 0.06815241f, -0.06781152f, -0.00812848f, 0.07430148f, 0.06819399f, 0.13307704f, 
    -0.08818305f, 0.27139351f, 0.17496042f, -0.01060513f, 0.01202879f, 0.02611757f, -0.00142448f, -0.13892765f, 
    0.05195329f, 0.04870750f, 0.11292487f, 0.12424898f, 0.16363110f, -0.03468015f, -0.02374201f, -0.00771591f, 
    -0.01988555f, 0.03258989f, 0.09120837f, -0.08747558f, 0.01435631f, 0.06431790f, 0.09790277f, 0.12291977f, 
    -0.09897289f, -0.10862323f, -0.10086156f, -0.12297215f, 0.01361242f, 0.04705440f, -0.06686340f, 0.07311904f, 
    -0.02537324f, -0.07211526f, -0.00568325f, 0.00520285f, -0.09453185f, 0.11926937f, 0.20512377f, -0.30902913f, 
    0.08538683f, -0.01018290f, 0.02451867f, -0.05539432f, -0.00346487f, -0.02645780f, 0.09914383f, -0.07277527f, 
    0.06749561f, 0.13098466f, -0.03574423f, -0.19016781f, 0.12933485f, -0.13234931f, 0.04985093f, -0.00144838f, 
    -0.09680171f, 0.00698668f, -0.05338589f, 0.09437814f, -0.06133168f, -0.07115947f, 0.03928024f, -0.42267984f, 
    0.06080543f, 0.11728705f, 0.01074828f, -0.00629721f, 0.01584586f, 0.05698375f, -0.11453287f, 0.03725898f, 
    -0.35650715f, -0.12290654f, 0.03596105f, 0.03653416f, 0.03752413f, 0.04229970f, -0.02325311f, 0.09135215f, 
    -0.07801082f, 0.09256370f, -0.12028705f, -0.01490771f, -0.09863420f, 0.17167294f, -0.14335158f, -0.02579399f, 
    0.09182581f, 0.04574456f, 0.04311866f, -0.19688125f, -0.10934120f, -0.01677080f, 0.04999223f, -0.00147311f, 
    0.65351278f, 0.27877414f, -0.05388107f, 0.05810874f, -0.05760748f, 0.04331367f, 0.02428507f, 0.09539267f, 
    -0.09308054f, 0.03406306f, -0.00367514f, -0.01682802f, -0.50893587f, 0.29832110f, 0.04052605f, 0.27925694f, 
    0.04100004f, -0.03277105f, 0.03420739f, -0.12985550f, -0.11811024f, -0.15363415f, 0.02836378f, -0.00578194f, 
    -0.52733880f, 0.13856210f, -0.07993095f, 0.26457149f, 0.01953962f, -0.21574461f, 0.17049272f, -0.04811827f, 
    -0.11366954f, -0.08306368f, -0.05057032f, 0.05521364f, 0.23866948f, -0.13277932f, -0.11834204f, 0.21788026f, 
    -0.04382263f, -0.04384517f, 0.03643218f, -0.22025907f, -0.02199581f, -0.00600742f, 0.07301373f, 0.05859671f, 
    0.04681851f, -0.05014039f, 0.06170753f, 0.13233472f, 0.05939380f, 0.01809329f, 0.05179624f, -0.02918563f, 
    -0.06227173f, 0.07377674f, -0.02236677f, 0.03811193f, 0.83089614f, -0.11793653f, -0.04716401f, 0.00036405f, 
    0.09070454f, 0.05799299f, 0.00887211f, -0.02860974f, -0.10328603f, -0.06634992f, -0.00568574f, 0.11673439f, 
    -0.07518087f, 0.00867408f, 0.05120873f, -0.19417077f, 0.17653239f, 0.07087243f, -0.00633017f, -0.10565384f, 
    -0.02617586f, 0.13361000f, -0.20236249f, 0.10109223f, 0.24742445f, 0.11296105f, -0.13814434f, -0.06435130f, 
    0.02571594f, -0.14398959f, -0.08476926f, -0.12075928f, -0.06217494f, 0.03223611f, -0.02032393f, -0.01750118f, 
    -0.41483846f, -0.03357744f, -0.27380642f, 0.17851245f, 0.03102253f, -0.01749926f, 0.02269237f, -0.02438596f, 
    0.01909404f, 0.05910805f, 0.11291789f, -0.18675752f, 0.02102598f, -0.19393231f, -0.17806633f, -0.27950960f, 
    -0.00458614f, -0.08373889f, 0.00190935f, 0.10771277f, -0.11421448f, 0.01446182f, 0.04549475f, 0.00459721f, 
    0.10151265f, 0.03270931f, -0.28244057f, -0.00504630f, 0.21224315f, 0.08119591f, 0.00198895f, 0.09022541f, 
    0.01323771f, 0.09564445f, -0.06227717f, -0.07582493f, 0.24749452f, 0.03920546f, -0.05681039f, -0.02403161f, 
    0.09827164f, 0.02865056f, -0.00876599f, -0.18392102f, -0.04916593f, -0.04709786f, 0.02234073f, 0.06329315f, 
    0.02969512f, 0.07330157f, -0.37673119f, 0.04165891f, 0.08331648f, 0.00302484f, 0.01660548f, -0.10021395f, 
    0.02515964f, 0.25848299f, 0.00760400f, -0.04118585f, -0.01707795f, 0.07317559f, -0.22496791f, 0.14576305f, 
    -0.00954173f, -0.04184475f, 0.10051985f, -0.02500620f, 0.01458165f, -0.11621878f, -0.06468963f, 0.04666671f, 
    -0.09700614f, 0.30103573f, -0.33383614f, 0.00280814f, 0.00955268f, -0.00124816f, -0.05902612f, -0.00894808f, 
    -0.09351823f, 0.12721561f, -0.13317139f, 0.09736179f, 0.24703762f, -0.40212056f, 0.29233095f, -0.14638612f, 
    -0.35527945f, -0.14026570f, -0.02348304f, 0.13186280f, -0.05592090f, 0.25776225f, -0.08997708f, 0.03737504f, 
    -0.21076803f, 0.45762843f, 0.04642868f, 0.20344427f, 0.00632021f, -0.03039482f, 0.11092812f, -0.02626422f, 
    0.02049659f, -0.06544059f, 0.02740558f, -0.02652775f, -0.38685843f, 0.32042348f, -0.11694450f, -0.04620746f, 
    0.15762988f, 0.07238754f, -0.08895265f, -0.05897719f, -0.28017548f, -0.07212131f, 0.03557799f, -0.09942400f, 
    0.06100700f, -0.09013679f, -0.18374522f, -0.64669633f, 0.19728765f, -0.01654168f, 0.07500984f, -0.29891968f, 
    0.08478446f, 0.11784316f, -0.19223151f, 0.03974573f, 0.02617098f, -0.15060984f, -0.04832661f, 0.08533452f, 
    0.06353816f, 0.07342671f, -0.00758250f, -0.06113912f, -0.03601215f, 0.10538228f, -0.07925253f, 0.04711581f, 
    -0.07803749f, -0.13266833f, -0.08746936f, 0.07856710f, 0.04813653f, 0.02492280f, 0.03715031f, -0.01222894f, 
    -0.22710580f, 0.14934142f, -0.13687092f, 0.00429652f, 0.09229013f, -0.02763887f, -0.18061431f, 0.13525838f, 
    0.00208555f, -0.00902047f, -0.07085115f, -0.01401066f, 0.09427016f, 0.12582539f, -0.07570323f, 0.05364332f, 
    -0.32694003f, -0.30639961f, 0.27873066f, 0.33339980f, -0.22199406f, -0.05543063f, -0.04806997f, -0.05571116f, 
    -0.03487184f, 0.03741652f, -0.23987930f, -0.02762858f, -0.15339854f, 0.03658615f, 0.07648221f, 0.20287269f, 
    0.06121010f, -0.18882968f, -0.24384303f, -0.01037535f, -0.02847659f, -0.21054904f, 0.02127709f, -0.14451596f, 
    -0.13822816f, -0.33550134f, -0.01771662f, 0.06836957f, 0.00904609f, 0.02955225f, 0.00869444f, 0.08883442f, 
    -0.03853904f, -0.04182930f, -0.08265133f, -0.09771863f, -0.00583236f, 0.09403154f, -0.14463130f, 0.32865831f, 
    0.03100950f, 0.13617301f, 0.07729106f, -0.10983448f, 0.12598145f, -0.06792957f, -0.01739079f, 0.24265084f, 
    -0.31906196f, -0.03655721f, 0.04052632f, 0.07453905f, -0.17466134f, -0.10071267f, -0.29125291f, -0.05759995f, 
    -0.10208704f, 0.08312871f, -0.06073973f, -0.08135888f, -0.27731994f, -0.08474402f, -0.15488891f, 0.05643786f, 
    -0.10932247f, -0.11287632f, -0.12742266f, -0.05656450f, 0.02030010f, 0.00062336f, 0.11172365f, -0.13204768f, 
    -0.01718598f, -0.03229541f, -0.19287334f, -0.11102539f, -0.27225596f, 0.02972776f, -0.15571988f, -0.05175196f, 
    -0.02410424f, 0.00935073f, -0.09283352f, 0.02232233f, 0.07833741f, -0.19356363f, -0.03328869f, 0.14976923f, 
    0.04812463f, 0.06549960f, 0.05764594f, -0.07718478f, -0.00251695f, 0.00574458f, 0.16054182f, 0.04060175f, 
    0.16355984f, -0.06804986f, -0.04561473f, 0.29607633f, 0.00131079f, -0.04926521f, 0.19267210f, 0.06796834f, 
    0.05237324f, -0.05362936f, 0.11761925f, -0.11265322f, 0.00273644f, -0.12334035f, 0.02912921f, -0.27124083f, 
    -0.14470024f, -0.17867354f, 0.00446224f, 0.09127520f, -0.05380547f, -0.03013998f, -0.03012584f, -0.12780330f, 
    -0.21471715f, 0.39863163f, 0.02423707f, 0.11255889f, -0.01014508f, 0.11389519f, -0.14686075f, -0.00888742f, 
    -0.09849036f, -0.04041786f, 0.10789033f, 0.08185603f, 0.25200954f, -0.23943709f, 0.26371092f, 0.10912143f, 
    0.04556008f, 0.05669275f, -0.20116067f, -0.20967078f, 0.14888383f, 0.08734300f, 0.11655214f, 0.01886186f, 
    0.21928830f, -0.03292763f, -0.22921926f, 0.02482117f, 0.08625832f, 0.07024748f, -0.11466625f, 0.06673148f, 
    -0.05389876f, 0.11221999f, 0.04232638f, -0.06824093f, 0.08717740f, -0.07709098f, 0.00265055f, -0.24878933f, 
    -0.14408569f, -0.23135448f, -0.03369991f, -0.10798102f, 0.02051515f, 0.01973493f, -0.12635216f, -0.04664325f, 
    0.19925384f, -0.20289893f, 0.02078927f, 0.12601553f, 0.15551959f, -0.00243532f, -0.00604309f, -0.02616987f, 
    -0.00553424f, 0.11915901f, -0.05540998f, 0.08076940f, -0.08038665f, 0.27369201f, -0.28009170f, 0.27175421f, 
    0.04361464f, 0.05281932f, -0.00896798f, 0.01894679f, -0.12253802f, 0.04355093f, 0.01319193f, -0.15236124f, 
    -0.17034465f, -0.04736361f, 0.16303651f, 0.29049850f, 0.04659988f, 0.04291148f, -0.20588903f, -0.02546576f, 
    0.00892764f, -0.07338890f, 0.13443738f, 0.00839739f, -0.17683800f, -0.22627792f, 0.07194118f, 0.33666539f, 
    0.19968830f, 0.12773813f, -0.01482460f, 0.14334656f, 0.09157498f, 0.05750846f, -0.03573830f, 0.07136703f, 
    -0.06686999f, -0.01946733f, 0.03064146f, 0.04190065f, -0.21690382f, -0.08638002f, 0.01845186f, 0.02346423f, 
    -0.04099240f, 0.09109327f, -0.02589893f, -0.00727403f, -0.11151555f, -0.11942706f, -0.21643887f, -0.11572122f, 
    0.17026249f, 0.03158618f, -0.02898126f, -0.02052207f, -0.14630139f, -0.03081333f, 0.04372013f, -0.12209541f, 
    -0.02809915f, -0.40564319f, 0.44717821f, 0.19334130f, -0.13231130f, 0.14449613f, -0.05804514f, -0.09096585f, 
    0.16984880f, -0.06184286f, -0.16596851f, 0.05095531f, 0.23981795f, 0.05486377f, -0.07420164f, -0.05431079f, 
    -0.00447310f, 0.04025037f, -0.06794970f, -0.01202709f, -0.08494332f, -0.04074423f, 0.09318833f, -0.05441834f, 
    0.08212741f, -0.08799240f, -0.11759079f, -0.07839625f, 0.09369749f, -0.15660469f, -0.01269573f, 0.19106248f, 
    0.09873053f, 0.12238150f, -0.09582398f, 0.00275478f, -0.79573196f, 0.91720837f, -0.36714694f, 0.83318394f, 
    0.21369562f, -0.07743499f, 0.16455217f, -0.19276766f, 0.13047349f, 0.04809693f, 0.04868491f, -0.05011879f, 
    -0.19360194f, 0.07613000f, -0.12716359f, -0.04775263f, -0.19413655f, 0.04364281f, -0.30478489f, -0.08753809f, 
    -0.03446538f, -0.20355338f, -0.02379112f, -0.04252966f, -0.12083866f, 0.11179473f, 0.11740209f, 0.39326560f, 
    0.05049115f, 0.00824491f, 0.12715030f, 0.03234514f, -0.11964526f, -0.13924856f, 0.09967672f, 0.00983207f, 
    0.15462188f, -0.21995680f, -0.36152628f, 0.05510160f, 0.04493676f, -0.16069253f, -0.17096291f, 0.03174965f, 
    -0.16435790f, 0.01646247f, -0.00146553f, -0.21804184f, 0.08231350f, -0.15319255f, 0.42765579f, -0.28465661f, 
    -0.25765419f, 0.03504038f, 0.02778495f, -0.01929015f, 0.03192628f, 0.14479765f, 0.25066009f, 0.01580052f, 
    -0.17103036f, 0.19720873f, -0.05474565f, 0.00562789f, 0.00424850f, -0.16214798f, -0.22131123f, -0.08912431f, 
    -0.10453317f, 0.10231052f, -0.25814921f, -0.00992494f, -0.00159102f, 0.31518090f, -0.04669821f, 0.29401404f, 
    -0.00103088f, 0.06157400f, -0.04708803f, 0.04112600f, -0.07504659f, 0.05214457f, -0.09783489f, -0.04063962f, 
    0.14758301f, -0.18265957f, 0.02110298f, 0.24063276f, 0.03174283f, -0.08325353f, -0.08420398f, -0.01125586f, 
    -0.02080458f, 0.07302866f, 0.01569134f, 0.07488400f, -0.46710414f, -0.58287126f, -0.03870497f, -0.14527102f, 
    -0.29463619f, -0.12413652f, -0.08143470f, -0.04567503f, -0.03154720f, 0.07332719f, -0.15128838f, -0.08562477f, 
    0.02409737f, 0.02225707f, 0.14202707f, 0.13728285f, -0.19643876f, 0.04485976f, 0.00447942f, 0.03260931f, 
    0.07155363f, 0.08432876f, 0.06508785f, -0.07178632f, 0.39678359f, 0.55982322f, -0.10602561f, -0.12994818f, 
    -0.21749644f, 0.00690174f, -0.07081755f, 0.02030347f, -0.00767878f, -0.10666677f, 0.21858323f, 0.13388167f, 
    -0.37426540f, 0.03837310f, 0.05507649f, 0.22612502f, -0.02409732f, 0.13325876f, 0.18757720f, -0.04731520f, 
    -0.02321209f, -0.07852266f, -0.06672370f, 0.04227461f, -0.11835174f, 0.15913160f, -0.14437398f, 0.04012669f, 
    0.12432671f, 0.09268056f, -0.08778366f, -0.04719184f, -0.05289850f, -0.00387591f, -0.05879411f, 0.07136859f, 
    0.46494418f, 0.02443927f, 0.09380814f, 0.15772818f, 0.08814802f, -0.03977072f, 0.16416653f, -0.01918122f, 
    -0.01467643f, 0.10462608f, -0.08723918f, 0.17101263f, 0.20005669f, -0.27769431f, 0.07722487f, 0.29762796f, 
    0.00149430f, -0.05078397f, -0.05289908f, 0.06162877f, -0.02470923f, -0.08979001f, 0.02077343f, -0.09467889f, 
    0.16727945f, 0.01180794f, -0.01198792f, 0.05810817f, 0.01223077f, -0.01811677f, -0.06254367f, -0.02674559f, 
    -0.07868480f, -0.12489765f, -0.14479794f, -0.13666236f, 0.13412255f, 0.04892879f, -0.02355736f, 0.03729937f, 
    0.01665554f, -0.04306059f, -0.08378605f, 0.04416729f, -0.01177527f, -0.02621090f, -0.13218382f, -0.00706884f, 
    0.21615128f, 0.15054570f, -0.04450010f, 0.13639411f, 0.02530191f, -0.04017387f, -0.01481213f, 0.01401372f, 
    -0.00846673f, -0.13605553f, -0.00235854f, 0.05262024f, -0.01342011f, -0.30555186f, 0.23853774f, -0.11270761f, 
    -0.00359187f, -0.05979462f, -0.02941364f, -0.04802523f, 0.26803306f, -0.13114724f, -0.06126364f, 0.11440651f, 
    0.12811975f, -0.23457155f, -0.09388911f, -0.12106708f, -0.00022260f, 0.09851859f, -0.00503100f, 0.01286503f, 
    -0.00258624f, -0.12651210f, 0.03997934f, -0.30133346f, 0.21814042f, -0.33328956f, -0.20716804f, 0.05668426f, 
    -0.08140609f, 0.10049485f, -0.08306438f, 0.07093071f, -0.05704816f, -0.02160352f, -0.07968910f, 0.00200222f, 
    -0.10392782f, 0.04113736f, 0.15378012f, -0.05403721f, 0.06324253f, 0.02858527f, -0.18886848f, -0.03874045f, 
    -0.31688282f, -0.10339812f, -0.20461544f, 0.08458968f, -0.08796405f, 0.09465712f, 0.13028321f, 0.04668304f, 
    -0.12530513f, -0.05432038f, 0.02465347f, -0.00712257f, 0.02250939f, -0.04847540f, 0.02279895f, 0.01318393f, 
    0.08450787f, 0.22972372f, 0.13058782f, 0.25217968f, 0.00686465f, 0.02127511f, 0.02563825f, -0.09501483f, 
    0.04208727f, 0.13186152f, -0.03895644f, 0.06391099f, -0.22170891f, -0.03846918f, -0.03613910f, 0.04080933f, 
    -0.22320753f, -0.11658904f, -0.00622058f, -0.02876276f, 0.04595794f, -0.05560967f, -0.02312348f, 0.08640481f, 
    0.15308863f, -0.04991429f, -0.17590894f, 0.05855411f, -0.09261511f, 0.01182560f, 0.07212210f, 0.05080979f, 
    0.03336878f, -0.05181699f, 0.02207121f, -0.05401717f, -0.10484760f, -0.11565562f, 0.01395142f, 0.08676565f, 
    -0.12476494f, 0.01911418f, -0.08545435f, -0.18297869f, -0.04948773f, -0.02491459f, -0.11026272f, -0.01083483f, 
    -0.22303447f, -0.06071412f, -0.08669990f, -0.07060093f, 0.13969393f, 0.01224748f, -0.02214837f, 0.03402745f, 
    -0.13946603f, -0.01171010f, 0.06042168f, 0.14581218f, -0.24663739f, -0.03107385f, 0.00068634f, -0.09159308f, 
    0.00305109f, 0.03260085f, -0.01798925f, 0.03311067f, 0.05270999f, -0.04334223f, -0.15712452f, -0.10407449f, 
    0.04213699f, 0.12809542f, 0.23651265f, -0.04948413f, -0.20888825f, 0.01741942f, -0.00635605f, -0.05363702f, 
    -0.01699305f, -0.20958984f, -0.03679840f, -0.05028769f, 0.02694918f, 0.01905140f, 0.08897826f, 0.06645521f, 
    -0.06415918f, -0.08140300f, 0.00679812f, 0.10868988f, 0.15559947f, 0.00126483f, -0.04365202f, 0.00893727f, 
    0.14053264f, 0.01741672f, -0.13113101f, 0.04960048f, -0.01185380f, -0.01176810f, 0.01200200f, 0.12665929f, 
    -0.04133555f, -0.27180332f, -0.15268618f, -0.19413742f, 0.08294152f, -0.06466218f, 0.13658696f, -0.05300305f, 
    -0.04474173f, -0.02420208f, -0.16826853f, -0.14694764f, 0.08288571f, -0.07965020f, 0.03048864f, -0.10570582f, 
    0.07954105f, -0.22400813f, 0.25877890f, 0.13861991f, -0.04389984f, -0.04719064f, -0.18229058f, -0.16085471f, 
    -0.10317929f, -0.01320474f, 0.04578598f, 0.10338010f, 0.32122624f, 0.14270531f, -0.28132209f, 0.14306158f, 
    -0.01638291f, 0.08858647f, -0.03839368f, 0.03907757f, 0.14454998f, -0.09721031f, 0.11845998f, -0.03819269f, 
    -0.13791308f, -0.14611523f, -0.26745197f, -0.22372434f, 0.05602069f, 0.02644847f, -0.01492651f, 0.01113458f, 
    0.00720985f, 0.06450156f, -0.08057891f, -0.08380994f, 0.05616672f, -0.14304282f, -0.07600783f, 0.17082593f, 
    -0.14412709f, -0.07182673f, 0.07065306f, -0.23494548f, -0.08179412f, 0.00468960f, -0.06962267f, -0.05223675f, 
    -0.19433725f, 0.10597862f, -0.14782649f, 0.08664312f, 0.07312869f, -0.06242992f, -0.07580777f, -0.08112016f, 
    -0.03396260f, -0.22925539f, -0.00309864f, -0.02671069f, 0.10738590f, 0.00497003f, -0.03408623f, 0.17181572f, 
    0.03501419f, -0.13860159f, -0.07530329f, -0.15209915f, 0.00279148f, 0.03973927f, 0.11327319f, -0.00339070f, 
    -0.11136372f, -0.09303856f, 0.09058239f, 0.16994649f, 0.01996935f, -0.00699806f, 0.06572903f, -0.15983389f, 
    0.02278781f, -0.05179404f, 0.06080763f, -0.03959253f, -0.07113200f, 0.02864063f, 0.23267472f, 0.01923262f, 
    -0.07872184f, 0.04967804f, -0.00527625f, 0.01599300f, 0.04236375f, -0.03498016f, 0.03022534f, 0.06153733f, 
    0.08714586f, 0.33851629f, -0.16319636f, -0.00559551f, -0.00620421f, -0.14090049f, -0.03400159f, 0.01970986f, 
    -0.02948354f, 0.01986315f, 0.00114260f, -0.25444680f, 0.04693158f, -0.37563515f, -0.11217129f, 0.18086077f, 
    0.04235899f, 0.04499300f, -0.08463908f, 0.02929279f, -0.00302139f, -0.02639027f, 0.09284363f, -0.16397612f, 
    0.07311115f, 0.16514911f, 0.18714312f, 0.03149426f, -0.02059968f, 0.05792607f, -0.05831370f, -0.07269631f, 
    0.14522043f, -0.14947563f, 0.09005977f, 0.09965158f, 0.13229209f, 0.11340357f, 0.32125255f, 0.26633334f, 
    0.09145146f, -0.00706348f, -0.11014792f, 0.05883718f, 0.09602422f, -0.00792147f, 0.03589362f, -0.02529591f, 
    0.08428936f, -0.19246140f, -0.32955468f, -0.22896498f, 0.09288345f, -0.03685812f, 0.08224175f, -0.08359501f, 
    0.10496224f, -0.01482235f, -0.01214960f, -0.01058689f, -0.11399450f, -0.02048745f, -0.01208837f, -0.18918775f, 
    -0.05561194f, 0.08746982f, 0.08802371f, -0.11486333f, 0.00450014f, -0.13791284f, -0.11648609f, -0.04280125f, 
    -0.00745272f, -0.05898897f, -0.05818210f, -0.36742836f, 0.06621376f, -0.05149299f, 0.07927039f, 0.02893481f, 
    0.05441698f, -0.04400529f, -0.02160345f, -0.04540385f, -0.13380678f, 0.03312960f, 0.07086337f, 0.23908073f, 
    -0.06434432f, 0.01851777f, 0.03680360f, -0.01309422f, -0.03057942f, 0.08398070f, -0.02105897f, 0.18410246f, 
    -0.04285734f, 0.14370787f, 0.04382219f, 0.10692535f, -0.11019184f, -0.08494594f, -0.12638660f, 0.05439798f, 
    -0.10253638f, -0.21091703f, -0.06922044f, -0.05225237f, -0.05985408f, -0.14807504f, -0.10102331f, 0.03605390f, 
    0.02188338f, 0.11145380f, -0.00971162f, -0.01362394f, 0.01193410f, 0.00497999f, -0.00519412f, -0.04431012f, 
    0.06349710f, -0.59222382f, 0.02695256f, 0.25162819f, 0.14141329f, -0.02519871f, 0.04551639f, -0.15650693f, 
    0.02496197f, -0.04307488f, -0.04106058f, 0.08388794f, -0.10383106f, 0.11122397f, 0.05906913f, 0.32550782f, 
    0.01798098f, -0.05934876f, -0.05730960f, -0.22453924f, -0.04036200f, -0.04099830f, 0.05047947f, -0.14973208f, 
    -0.02989632f, -0.09326789f, -0.12801142f, -0.08358207f, 0.03008487f, 0.08438376f, 0.04174500f, 0.03410874f, 
    0.12757145f, 0.01229660f, 0.20368128f, 0.24963620f, -0.03093028f, -0.08045121f, 0.11929151f, 0.01414920f, 
    -0.03917137f, -0.07084889f, -0.01912415f, 0.05501844f, 0.02708133f, -0.05479788f, -0.06725742f, -0.04644018f, 
    0.12812474f, 0.27773690f, 0.01913715f, 0.09629453f, -0.09433205f, -0.10254086f, 0.00683420f, -0.01798470f, 
    0.05646965f, -0.07831563f, 0.01862815f, 0.09918312f, 0.00863278f, -0.01172936f, 0.32193244f, -0.02314196f, 
    -0.08760304f, 0.20557727f, -0.25454983f, 0.03271249f, -0.02244695f, 0.03635433f, 0.00466164f, 0.06347982f, 
    -0.34277016f, 0.05494262f, -0.20133863f, -0.15274322f, 0.08588142f, -0.07231975f, -0.06453471f, -0.05590129f, 
    -0.05171022f, 0.02103033f, 0.02618863f, -0.06747976f, 0.08019368f, 0.13078286f, 0.13272066f, 0.16318789f, 
    0.08231519f, 0.01851987f, -0.02194446f, 0.04172771f, 0.14593989f, 0.14408465f, -0.02233542f, -0.05981715f, 
    0.12929857f, -0.08161349f, 0.19170846f, 0.24127087f, 0.02202497f, 0.04979286f, 0.02851019f, 0.15714924f, 
    0.01767192f, -0.08881681f, 0.04854725f, -0.01175572f, -0.05956096f, 0.08623850f, -0.05973238f, 0.06864631f, 
    -0.09460057f, -0.00947380f, 0.02974275f, 0.02928861f, -0.03515720f, 0.09946266f, -0.00682321f, -0.02351214f, 
    0.11733025f, 0.11510243f, -0.03554054f, 0.05890849f, 0.08246162f, 0.12520342f, 0.04158978f, 0.03837977f, 
    0.03179222f, -0.07218905f, 0.05093336f, -0.04456915f, -0.02337934f, 0.06713205f, 0.09234761f, 0.20330946f, 
    -0.10176480f, -0.08556344f, -0.05358947f, -0.00690110f, -0.08412370f, -0.16436420f, 0.10582892f, 0.02741831f, 
    0.15578923f, 0.08415729f, 0.20146967f, 0.04527625f, -0.10674239f, -0.05173804f, -0.02773634f, -0.25696689f, 
    -0.02448290f, -0.17315114f, -0.02647083f, -0.16583005f, 0.12153530f, -0.28419608f, 0.33565256f, -0.11447887f, 
    0.04748235f, 0.15859979f, -0.01903179f, 0.04180161f, 0.05832363f, -0.03250775f, -0.02434848f, -0.00448779f, 
    -0.05910613f, 0.05529805f, -0.06859485f, -0.03699140f, 0.03206056f, 0.10668801f, -0.01298373f, -0.06615241f, 
    0.14282337f, -0.00588502f, -0.16262969f, -0.04433121f, 0.08486579f, 0.19475754f, 0.22328700f, 0.11443839f, 
    0.05730762f, 0.08955281f, -0.11483501f, 0.31919262f, -0.05039344f, 0.07118326f, -0.19715965f, -0.08608437f, 
    -0.26596907f, -0.19176689f, -0.00998844f, -0.13601996f, -0.09742308f, 0.04228806f, -0.01876181f, 0.10750761f, 
    -0.08590567f, -0.02146103f, -0.07941498f, -0.25651389f, 0.14360078f, 0.10749059f, -0.13517749f, 0.14440447f, 
    0.05812510f, 0.02629957f, -0.01386937f, -0.06753480f, 0.11357197f, -0.01548064f, -0.00163512f, 0.00500237f, 
    -0.07002489f, -0.00587248f, 0.11048642f, 0.04010671f, -0.29227099f, 0.00151948f, -0.06170408f, -0.17208329f, 
    -0.00444136f, -0.03998161f, 0.02833443f, -0.06314189f, -0.16261235f, 0.00563111f, -0.01755024f, -0.11784910f, 
    0.07867362f, 0.04415344f, 0.00306432f, -0.00263016f, -0.01311840f, 0.00643690f, 0.04122833f, -0.05436620f, 
    -0.07973616f, -0.05549752f, 0.01109293f, 0.11543135f, -0.04592016f, -0.07033650f, -0.05996952f, -0.11187377f, 
    0.03816055f, 0.02767929f, 0.01804735f, 0.03842147f, -0.00877383f, 0.03464733f, -0.04117781f, -0.02124324f, 
    0.09055038f, 0.04359048f, 0.05123901f, 0.08009934f, 0.01196322f, 0.06445086f, 0.01641462f, 0.05168872f, 
    -0.01070445f, 0.22798318f, -0.06566489f, 0.16210103f, 0.00995177f, -0.07954255f, -0.00721289f, -0.04550457f, 
    0.07277028f, 0.08340693f, 0.09747364f, 0.42486063f, 0.00815328f, -0.14848353f, 0.17356659f, 0.05438855f, 
    -0.13604954f, -0.08609416f, 0.16886744f, 0.05587523f, -0.03555047f, 0.13886942f, -0.12764536f, -0.09772386f, 
    -0.12550002f, -0.02029971f, -0.04624835f, -0.16997045f, 0.07198780f, -0.10372771f, 0.00064876f, -0.04582444f, 
    0.02917710f, 0.01517778f, -0.05948184f, 0.25904500f, -0.04558522f, -0.06610687f, -0.02353670f, -0.16783367f, 
    -0.00005942f, -0.05858068f, -0.07621692f, -0.13452490f, 0.15729700f, -0.10417207f, -0.00654117f, 0.03409689f, 
    0.04201734f, 0.10112964f, -0.05328940f, 0.01233541f, 0.11070801f, -0.08574400f, 0.06803931f, 0.01876916f, 
    -0.05566606f, -0.03776648f, -0.03819929f, -0.10874758f, -0.20806222f, 0.03524597f, 0.03317090f, 0.03042669f, 
    -0.04326864f, -0.01340665f, -0.17926911f, 0.08487085f, -0.06501979f, 0.09779497f, -0.02525420f, -0.12467622f, 
    -0.07381681f, -0.03902285f, 0.08801288f, 0.05560173f, -0.09648823f, -0.03146317f, -0.06692866f, -0.05562267f, 
    0.06555842f, 0.12550777f, 0.24067418f, 0.09716032f, 0.06620985f, -0.13792238f, 0.07274117f, -0.09189721f, 
    -0.11949025f, 0.06150624f, 0.09876769f, 0.00668728f, 0.17150715f, 0.09808779f, 0.07364568f, -0.03302191f, 
    -0.03122356f, -0.00424745f, -0.08858328f, -0.06758088f, -0.03860843f, 0.05586075f, -0.09139325f, 0.03340994f, 
    0.14445914f, 0.08410890f, -0.05263061f, -0.03602387f, -0.05181927f, 0.20265083f, -0.20055899f, -0.15357451f, 
    0.06000664f, -0.02040699f, -0.05849916f, -0.01252665f, -0.12823403f, 0.06971750f, -0.06107292f, -0.10151192f, 
    -0.18929881f, 0.11233886f, -0.12397864f, 0.08041029f, 0.11605393f, -0.09339775f, -0.00395397f, -0.03175994f, 
    0.07531637f, 0.11364979f, -0.06743403f, 0.00939493f, -0.11517322f, -0.03152426f, 0.19242692f, -0.38118169f, 
    0.12677856f, -0.09931246f, -0.10663026f, 0.07712796f, 0.17599769f, 0.02427116f, -0.09190527f, 0.31206533f, 
    -0.24938338f, -0.15205576f, -0.24785025f, -0.05401265f, 0.01385433f, -0.01193789f, -0.08701805f, 0.06254799f, 
    0.12002280f, 0.24755721f, 0.03062615f, 0.12167384f, -0.18422143f, -0.06697778f, 0.13605615f, -0.12126565f, 
    0.21546443f, -0.13211644f, -0.02432796f, 0.18294947f, -0.03297503f, -0.02209098f, -0.00891530f, 0.04364768f, 
    0.03172444f, 0.12662686f, 0.14295661f, -0.03274834f, 0.02427413f, 0.10107936f, -0.00294837f, -0.13232605f, 
    0.07296077f, -0.21233751f, 0.05716105f, -0.18989013f, -0.45086667f, -0.08722717f, -0.10159060f, 0.05032719f, 
    0.06286480f, -0.04603564f, 0.05414326f, 0.19009823f, -0.05411005f, 0.00514354f, 0.00196070f, -0.06403181f, 
    -0.04724003f, -0.18071710f, 0.11990210f, -0.05938812f, -0.02356923f, -0.06506356f, -0.05213510f, -0.02084581f, 
    0.23369944f, 0.04090073f, 0.01838909f, 0.02408352f, 0.14949368f, -0.04946711f, 0.24648285f, -0.07455926f, 
    -0.02560145f, 0.12989257f, 0.03470538f, 0.06576224f, 0.05099108f, 0.10989039f, -0.03597785f, 0.05050286f, 
    -0.00168535f, 0.11248881f, -0.34258375f, -0.24682249f, -0.00906249f, -0.00854194f, -0.02877545f, -0.01127553f, 
    0.16312562f, -0.12889180f, -0.23555821f, 0.13977915f, -0.44805452f, -0.26623273f, -0.15257737f, 0.18627585f, 
    0.00777336f, 0.01036926f, -0.02806946f, 0.01224421f, -0.04894241f, 0.02077189f, 0.22466849f, 0.29798090f, 
    -0.29305333f, -0.15551007f, -0.11124536f, -0.03369235f, 0.18777253f, -0.06468100f, -0.08045103f, 0.00566399f, 
    -0.07561425f, 0.12714353f, -0.07549648f, 0.12315509f, -0.03969130f, -0.10402140f, -0.06223384f, -0.07655325f, 
    0.11122959f, 0.08377741f, 0.05513458f, 0.04607992f, 0.00649551f, 0.21610659f, 0.06801448f, -0.03855838f, 
    -0.23682205f, -0.06260150f, -0.04139627f, 0.10372658f, -0.03853874f, -0.01698408f, -0.07888380f, -0.09336928f, 
    0.09166607f, -0.00440762f, -0.00031121f, 0.17732777f, 0.07264724f, 0.14882173f, -0.04170600f, 0.03867868f, 
    0.04805803f, -0.04057378f, -0.09498552f, -0.02765385f, -0.01170736f, -0.00761129f, -0.00648541f, 0.00822275f, 
    0.03533912f, -0.09051040f, 0.33726108f, -0.11001758f, 0.03138636f, -0.02752844f, -0.04918841f, -0.04722909f, 
    0.03520675f, -0.22013494f, 0.11145327f, -0.19269869f, 0.25623235f, -0.04359041f, -0.37440422f, 0.03384107f, 
    0.09506122f, 0.03047322f, -0.04041648f, -0.03992106f, -0.00123217f, -0.09159297f, 0.10910750f, -0.03397239f, 
    0.00165979f, -0.29370758f, -0.40644419f, -0.10573000f, -0.01332915f, 0.01998657f, -0.02312951f, 0.11658397f, 
    -0.01188630f, 0.00864011f, 0.00456908f, -0.05795284f, -0.47275028f, 0.08094884f, 0.16690789f, -0.22009914f, 
    -0.03030863f, 0.06950718f, -0.04421481f, 0.11225529f, 0.12327851f, 0.04339439f, -0.15595879f, 0.13356005f, 
    0.03580680f, -0.06155683f, 0.06919651f, 0.05647641f, -0.18453559f, -0.15943472f, 0.10178542f, 0.29396230f, 
    -0.08521385f, -0.06658376f, 0.15270407f, -0.14269806f, -0.30587137f, 0.28319243f, 0.27677932f, -0.36224440f, 
    -0.05752467f, 0.06513824f, -0.12292414f, 0.16203246f, 0.00798685f, -0.05278262f, 0.11032331f, -0.04133519f, 
    -0.27400008f, 0.08216627f, 0.16331276f, -0.20417023f, 0.11168461f, -0.03881319f, 0.05068132f, 0.14091636f, 
    0.01829063f, -0.02780989f, 0.10187601f, -0.03170275f, 0.08008281f, 0.23446073f, 0.07679581f, -0.00728514f, 
    0.17122690f, -0.00584598f, 0.05225566f, 0.28012127f, -0.00126652f, -0.01997152f, 0.05712982f, 0.03548709f, 
    -0.05504204f, -0.06327148f, -0.33914325f, 0.11427180f, 0.13232473f, 0.24907826f, -0.20697272f, 0.06745104f, 
    -0.00821962f, -0.13216700f, 0.16248930f, 0.01176716f, -0.00332909f, 0.08074836f, -0.31541669f, -0.11366997f, 
    -0.04272684f, -0.02156924f, 0.01329992f, -0.01099375f, 0.06899398f, 0.02339708f, -0.09765215f, 0.00261132f, 
    -0.06048275f, 0.08113492f, -0.13700025f, -0.13737209f, 0.04018539f, -0.09453519f, 0.04443687f, -0.09538446f, 
    -0.17999956f, -0.13875636f, 0.03009473f, -0.07355655f, 0.05631917f, -0.07400031f, 0.22716686f, -0.18429539f, 
    -0.11067217f, -0.03940646f, 0.00715907f, 0.12544297f, -0.21785961f, 0.08789327f, 0.07956062f, -0.04835381f, 
    -0.02492126f, 0.06601827f, -0.43400046f, 0.13773267f, 0.12463290f, -0.08985135f, -0.00128280f, 0.04796428f, 
    0.00927912f, -0.00719458f, 0.03557947f, 0.00230401f, 0.14045942f, 0.02774347f, 0.06369052f, 0.21090288f, 
    0.06719463f, -0.15203407f, -0.11465009f, 0.12422171f, 0.01375818f, 0.14600527f, 0.01575215f, 0.03039324f, 
    0.27397946f, -0.07473500f, 0.06002070f, 0.12442581f, 0.03106294f, -0.05913998f, -0.11771642f, -0.02209259f, 
    0.00507322f, 0.09975865f, 0.02664471f, 0.02025409f, -0.07493919f, -0.12625481f, -0.03289499f, -0.43816495f, 
    -0.08649982f, -0.10331623f, -0.05175664f, 0.05700017f, -0.13493922f, -0.35913664f, -0.17173989f, -0.04523509f, 
    0.04466551f, 0.21592088f, -0.31829280f, -0.20841669f, 0.22176714f, -0.00750817f, -0.07554135f, -0.13034698f, 
    -0.12188706f, 0.22921976f, 0.02893111f, -0.03375538f, -0.16477995f, -0.13356915f, -0.03747520f, 0.08201063f, 
    0.18156393f, -0.05717407f, 0.02306101f, 0.02932813f, 0.01197844f, 0.07429029f, 0.09573434f, -0.06162903f, 
    -0.08427262f, 0.05855130f, 0.18693742f, 0.16451502f, -0.02595484f, -0.18181400f, -0.08191683f, 0.06265806f, 
    0.02495180f, 0.02220759f, -0.11336069f, -0.12948257f, -0.15807427f, -0.01947708f, -0.35050586f, -0.01041435f, 
    0.16785926f, -0.12215604f, 0.27346089f, 0.03587838f, -0.00211602f, 0.02987621f, -0.03152062f, 0.11122403f, 
    0.39499840f, -0.13134371f, -0.08250986f, -0.10350879f, -0.02163821f, -0.01045711f, 0.02441462f, 0.01874562f, 
    -0.01007712f, -0.39492238f, -0.34590650f, -0.18427631f, 0.13349076f, -0.15161014f, 0.03420554f, 0.04488185f, 
    -0.08528193f, 0.10039223f, 0.04153008f, -0.02699443f, 0.04197849f, -0.03157087f, 0.04032981f, 0.01966583f, 
    -0.31372035f, -0.30166474f, -0.14401959f, -0.14856064f, -0.03162951f, -0.00367204f, -0.00360986f, 0.03796352f, 
    0.05011417f, -0.01275569f, -0.03292105f, -0.04750526f, 0.25122049f, 0.12016131f, 0.16023716f, -0.13964035f, 
    0.14613013f, 0.03977276f, 0.11473896f, 0.14983946f, 0.01801461f, 0.00078948f, 0.02454598f, 0.14046104f, 
    0.28471535f, -0.09547436f, -0.35209468f, -0.02004317f, 0.00402211f, 0.02882537f, 0.06088229f, 0.05043785f, 
    0.24940279f, -0.04273021f, -0.02397243f, 0.01260515f, 0.15137407f, 0.10477932f, -0.06198413f, -0.16283777f, 
    -0.00266007f, 0.03600790f, 0.01447573f, 0.08175872f, -0.12846257f, -0.14049587f, -0.03465233f, -0.02663048f, 
    0.27023059f, -0.00886312f, 0.18869042f, 0.19047987f, 0.14050843f, 0.00116038f, 0.02428179f, 0.03643068f, 
    0.02822908f, 0.03203131f, 0.04585471f, 0.04275992f, -0.23591936f, -0.35690689f, 0.09117778f, -0.10448597f, 
    -0.02860667f, 0.02181726f, 0.01084392f, 0.07332817f, 0.08825700f, -0.04098734f, 0.01142299f, 0.06411617f, 
    -0.10987664f, -0.04250422f, -0.09064461f, -0.06838036f, -0.01209932f, 0.07433856f, -0.02373465f, 0.02630203f, 
    0.00740716f, 0.06816090f, 0.02796349f, 0.01711290f, 0.06763955f, 0.08291589f, 0.12311230f, 0.16084395f, 
    -0.03473540f, -0.04710129f, -0.01191695f, 0.02239903f, 0.01324349f, 0.15622851f, -0.12148015f, -0.22887976f, 
    0.20616600f, -0.21977460f, 0.14523345f, 0.18049787f, 0.01173381f, 0.02145576f, 0.16923499f, 0.16989250f, 
    0.14470479f, -0.01252356f, 0.02766346f, 0.05592488f, -0.04092438f, -0.17500405f, -0.20283191f, -0.23572762f, 
    0.02561109f, -0.02449427f, -0.01146060f, -0.01396312f, 0.00939401f, 0.05125858f, -0.11005505f, -0.18717703f, 
    0.16119628f, -0.03701542f, -0.02427692f, -0.05978600f, -0.03738697f, -0.10832224f, 0.01156995f, -0.02852391f, 
    -0.04157415f, 0.16988608f, 0.13562486f, -0.15383109f, 0.13760594f, 0.18528003f, -0.31533048f, -0.27618310f, 
    -0.16252254f, -0.01861200f, 0.03539542f, -0.25649267f, 0.06051302f, -0.03169835f, -0.06402489f, 0.21261688f, 
    -0.03552113f, -0.30817506f, 0.16212055f, 0.20074998f, -0.04210015f, -0.06321699f, 0.08475350f, 0.12581700f, 
    -0.12177154f, -0.08257261f, 0.10693152f, 0.39068836f, -0.09619778f, -0.08193843f, -0.04029029f, 0.12372325f, 
    0.02031642f, 0.05890024f, 0.00502050f, 0.05593487f, -0.00450036f, 0.07659052f, -0.01982291f, -0.07602087f, 
    0.37498245f, -0.13407211f, -0.06152538f, 0.21203397f, 0.28460726f, 0.17112650f, 0.03873842f, 0.04389221f, 
    0.04944356f, 0.02513495f, -0.03261230f, 0.02752909f, -0.07777011f, 0.28964451f, -0.31551287f, -0.21922947f, 
    -0.07980899f, 0.10168301f, -0.07753672f, 0.37765005f, 0.00223534f, -0.11898448f, 0.03495382f, -0.03640371f, 
    -0.09068844f, 0.15936129f, -0.00279387f, -0.26929238f, -0.03239775f, -0.03703024f, 0.15484877f, 0.02086877f, 
    0.01225272f, -0.04064833f, 0.00915830f, 0.01985123f, -0.13232473f, -0.07288398f, 0.01011577f, 0.04519185f, 
    0.06826454f, -0.03570703f, -0.11913103f, -0.01685344f, -0.03369555f, -0.09003932f, 0.11630473f, -0.00722175f, 
    0.00233044f, -0.09257731f, -0.16038790f, -0.09755477f, 0.06021314f, 0.09986855f, 0.04708921f, 0.00857063f, 
    0.09650717f, -0.07504409f, -0.27079222f, -0.67993402f, 0.00712045f, -0.12525637f, 0.01805930f, -0.02566984f, 
    0.07566936f, -0.03954679f, 0.01646025f, -0.12404376f, -0.03300950f, 0.00127565f, 0.07637384f, -0.07805904f, 
    -0.09132706f, -0.00484434f, -0.24401338f, -0.14162843f, -0.05922572f, 0.09181520f, -0.01276842f, 0.07144707f, 
    -0.01910210f, 0.00314143f, 0.06813490f, -0.38613376f, 0.08178223f, 0.17314154f, 0.23939094f, -0.13953866f, 
    -0.05153056f, 0.01670483f, 0.09524442f, 0.11372860f, -0.05862814f, -0.15301862f, 0.08430229f, -0.18069679f, 
    -0.10940324f, -0.22405382f, -0.06558087f, 0.05544103f, -0.25786427f, 0.02274826f, -0.04449194f, -0.03672347f, 
    0.00916821f, 0.00884347f, 0.06160349f, 0.21075572f, 0.16081378f, 0.12279431f, -0.35753638f, -0.23455773f, 
    -0.00818591f, 0.06252781f, -0.13254693f, 0.05627069f, 0.04907648f, -0.12967630f, 0.02736274f, 0.21870551f, 
    -0.07148948f, -0.00097503f, 0.05963748f, -0.10286856f, 0.04179649f, -0.03020685f, -0.01816471f, 0.02618630f, 
    -0.07932351f, 0.16753496f, 0.07891279f, 0.07539328f, -0.22758281f, -0.07380235f, 0.10579836f, 0.03021819f, 
    -0.12344300f, -0.06677316f, -0.12693076f, 0.02478706f, -0.10307693f, 0.00724858f, -0.12282620f, 0.02833498f, 
    -0.06548400f, 0.37278715f, 0.20534985f, 0.03033975f, -0.00981680f, -0.13724324f, -0.04633158f, -0.02358057f, 
    -0.00840399f, -0.00872301f, 0.07841255f, 0.01030285f, -0.32963654f, 0.25242147f, 0.13997212f, -0.19126232f, 
    0.02455389f, 0.02466343f, -0.04832241f, 0.07765915f, 0.08628134f, 0.05922855f, 0.02300225f, 0.02240466f, 
    -0.09089223f, 0.02673146f, 0.18508950f, -0.56111741f, 0.02100675f, 0.06122239f, -0.14376411f, -0.00529208f, 
    -0.00705613f, 0.17270771f, 0.05482507f, 0.19489606f, 0.07615934f, -0.12374914f, -0.13110290f, -0.13444786f, 
    -0.05274991f, -0.09388883f, 0.07791980f, 0.11971166f, 0.00017637f, 0.05151958f, 0.04861099f, 0.11899646f, 
    0.00221752f, 0.17981762f, 0.20388718f, 0.10638738f, 0.03460715f, -0.12742718f, 0.11779758f, 0.01436067f, 
    -0.06814959f, -0.04041924f, -0.00854182f, -0.02710994f, -0.56854880f, -0.46533662f, 0.01706694f, 0.11672101f, 
    0.08322187f, 0.08573765f, -0.03545550f, 0.03535935f, -0.00831102f, 0.03017531f, 0.00349178f, 0.05365686f, 
    -0.56546921f, -0.29841357f, 0.13074981f, -0.60373145f, -0.13793118f, -0.06717767f, -0.22319525f, -0.15485089f, 
    0.08258670f, 0.07910037f, 0.11348014f, -0.12284464f, -0.36308625f, -0.03607467f, 0.11645440f, 0.14442900f, 
    -0.07650749f, 0.02925846f, 0.14187729f, 0.03766832f, -0.00838544f, -0.02405781f, 0.05055242f, 0.02758349f, 
    -0.30508819f, -0.10670274f, -0.00860082f, 0.06350676f, 0.00348316f, -0.09417938f, 0.08092681f, 0.08114072f, 
    0.00502961f, 0.09095719f, 0.05514509f, -0.09547222f, -0.28268823f, -0.34786722f, -0.26285666f, 0.09613498f, 
    0.01993898f, -0.06491400f, -0.01848776f, -0.17227831f, 0.04257200f, 0.02017222f, -0.13338450f, -0.02207422f, 
    0.21156354f, 0.11075512f, 0.06239022f, -0.11165664f, 0.06162816f, -0.11240593f, 0.11002506f, -0.00651167f, 
    0.02946782f, 0.08167181f, -0.14804883f, -0.11534411f, 0.06084985f, -0.06175764f, -0.03188747f, -0.06854450f, 
    0.00294529f, 0.04428222f, -0.10401896f, 0.06217415f, -0.02004991f, -0.07374751f, 0.02843006f, 0.08935413f, 
    -0.15854631f, 0.07806371f, 0.21017806f, 0.12967837f, 0.07178473f, -0.23335746f, 0.16010530f, 0.06576782f, 
    -0.06267298f, 0.02545172f, -0.09142551f, 0.04701296f, -0.07362075f, 0.11922842f, 0.05241225f, -0.02607013f, 
    -0.12273485f, 0.04367952f, -0.13115311f, 0.10194345f, -0.02378312f, -0.01598757f, -0.00584627f, -0.05645690f, 
    0.01634727f, -0.12860483f, -0.03349425f, 0.39221537f, 0.08049905f, -0.06687941f, 0.03851218f, 0.05701175f, 
    -0.04787338f, -0.03834357f, -0.03761946f, -0.25372106f, 0.13438515f, 0.13182488f, -0.00110875f, -0.14694037f, 
    -0.06788804f, -0.02447439f, -0.06983291f, 0.10353348f, 0.04702950f, -0.00970289f, 0.01319478f, -0.03448596f, 
    -0.11547842f, -0.41698077f, -0.43569249f, 0.41652691f, -0.02814999f, 0.20859119f, 0.03316771f, 0.14553504f, 
    0.04339955f, 0.07645152f, 0.03477231f, -0.02420434f, -0.17735301f, 0.06606570f, 0.07450706f, -0.28870293f, 
    -0.03506196f, 0.05288057f, 0.11845023f, 0.02046272f, 0.03216513f, 0.11578781f, 0.09513386f, 0.04661592f, 
    -0.19416815f, 0.08313037f, 0.08065408f, -0.13502772f, 0.12642349f, 0.03609790f, -0.00582177f, -0.09721167f, 
    -0.03540058f, 0.02323850f, -0.06663930f, 0.06968233f, -0.04216738f, -0.13252611f, 0.39976069f, -0.04013097f, 
    -0.09118202f, -0.14380263f, 0.09791677f, -0.01405598f, -0.08922432f, 0.24250282f, 0.08288053f, 0.05963404f, 
    0.13290797f, -0.08882047f, -0.02783421f, 0.12989211f, -0.12794036f, 0.04428083f, 0.08352264f, 0.14408800f, 
    0.25981125f, 0.03444465f, 0.06844046f, 0.09072897f, -0.41528767f, -0.38923800f, -0.05737344f, 0.02137758f, 
    -0.08977894f, 0.06020135f, -0.10489790f, -0.13774696f, -0.03982872f, 0.03882053f, -0.00096381f, -0.06622359f, 
    -0.48765898f, -0.49426070f, -0.54604131f, 0.10454186f, -0.04599807f, -0.18905008f, -0.01331401f, -0.34758058f, 
    -0.02147477f, -0.01164756f, -0.02629698f, -0.09146302f, -0.44833848f, -0.40258649f, -0.47855848f, -0.49297485f, 
    -0.10051874f, -0.05724486f, 0.15150873f, -0.20797169f, -0.02977723f, 0.02653271f, -0.00587038f, -0.01290118f, 
    0.40735820f, -0.10037312f, -0.11808785f, -0.45127606f, -0.03163116f, -0.02033036f, 0.19996053f, -0.04612283f, 
    0.13172154f, 0.01070709f, -0.14330241f, 0.05063134f, -0.02381956f, 0.07733533f, 0.01535737f, -0.08285137f, 
    0.08525809f, -0.08175103f, 0.01988567f, 0.04108815f, 0.01597431f, 0.04569321f, 0.02556091f, 0.00349790f, 
    0.10274151f, 0.14300086f, 0.09959716f, -0.13094474f, -0.04960765f, 0.00488168f, -0.00473959f, -0.14154212f, 
    0.16856757f, -0.27760360f, 0.07374911f, -0.02026529f, -0.25119418f, -0.30085215f, -0.21566562f, 0.26383686f, 
    0.04808194f, 0.18985344f, 0.06855604f, -0.51398736f, 0.02599642f, 0.00402790f, -0.00398729f, 0.01130213f, 
    0.11761326f, -0.06434035f, -0.25554302f, -0.20648436f, 0.03115954f, -0.00463948f, -0.02399093f, -0.01789946f, 
    -0.01803169f, -0.01422626f, 0.01155087f, -0.00321330f, 0.10557152f, 0.09885920f, -0.02654226f, -0.19029410f, 
    0.03832902f, -0.03018182f, 0.15583810f, -0.04706267f, -0.04193063f, 0.07353286f, -0.05932969f, 0.12714092f, 
    0.01397114f, -0.19487412f, -0.31212017f, -0.09708040f, -0.03214346f, 0.00626328f, 0.05352231f, 0.02291674f, 
    -0.04781967f, 0.05996479f, -0.04754800f, 0.02351013f, -0.33639565f, -0.17136943f, -0.14685088f, -0.01048736f, 
    -0.21682639f, -0.01735984f, 0.06145532f, 0.10644815f, -0.03580821f, 0.12652276f, -0.03193257f, -0.06053055f, 
    -0.16856399f, 0.03192570f, 0.05395305f, -0.44195428f, -0.00406251f, -0.02413926f, -0.01646007f, 0.00588514f, 
    0.08792640f, 0.13682862f, 0.01425882f, 0.09851501f, 0.21219474f, 0.04804143f, -0.23286547f, -0.01190127f, 
    -0.03888741f, 0.03468682f, 0.02217431f, 0.06006469f, -0.07623386f, -0.07656226f, -0.03745215f, -0.10869846f, 
    -0.22673553f, -0.23196997f, -0.02750456f, 0.27349487f, 0.14130583f, 0.11367090f, 0.08893650f, -0.12697507f, 
    0.01083214f, -0.03979355f, 0.05475224f, 0.06093014f, -0.30526465f, -0.51271367f, 0.33649579f, 0.49625847f, 
    0.05581389f, -0.49000093f, -0.13874699f, -0.31931114f, -0.08742476f, 0.01441754f, -0.03861111f, -0.18700910f, 
    0.10241541f, 0.02565031f, -0.03723813f, -0.03117432f, 0.02764250f, 0.02666787f, 0.00413710f, 0.09326453f, 
    0.06241475f, 0.16966581f, 0.14234163f, 0.09683062f, -0.02501353f, -0.01220043f, -0.20610389f, -0.03946133f, 
    -0.10441140f, -0.00561205f, 0.04474671f, -0.00992403f, -0.04517036f, -0.06058625f, 0.02347134f, -0.03668425f, 
    -0.10360892f, 0.21461760f, 0.30155441f, 0.36129194f, -0.03403386f, -0.06334062f, -0.14072154f, 0.11018576f, 
    0.04271438f, -0.08350346f, 0.03539272f, 0.03854913f, -0.50311571f, -0.46428829f, -0.69392300f, 0.34371150f, 
    -0.19088969f, -0.23417686f, -0.00915807f, -0.10607197f, -0.03608244f, -0.01421675f, 0.02687653f, 0.05046674f, 
    0.52683580f, 0.27209371f, 0.14216043f, -0.18861499f, 0.07716020f, -0.07661244f, 0.11280116f, -0.05859122f, 
    0.11191862f, 0.08375801f, 0.15742539f, -0.09581161f, 0.08646332f, 0.01559270f, 0.06078602f, -0.13893600f, 
    -0.03426370f, -0.16817953f, -0.02767423f, -0.10912383f, -0.11228576f, -0.12176102f, -0.02461736f, -0.00066789f, 
    -0.18096286f, -0.09993968f, -0.52745056f, -0.45882264f, 0.05671712f, 0.05012110f, 0.02530369f, -0.07464311f, 
    -0.02099168f, 0.03350121f, -0.00637671f, 0.06118995f, -0.42597476f, 0.34668466f, 0.32065094f, 0.09014568f, 
    -0.08641620f, -0.02982009f, -0.01354989f, 0.08241604f, -0.01204829f, 0.11056080f, 0.11864482f, 0.16584758f, 
    0.07006619f, -0.15366875f, 0.09647847f, -0.02300109f, 0.04614016f, 0.05449536f, 0.09007066f, -0.16045928f, 
    0.04065602f, -0.10824980f, 0.03613487f, 0.02726216f, 0.13959351f, -0.09836840f, -0.61346006f, -0.31209084f, 
    -0.06555997f, -0.00919475f, 0.03309425f, 0.06461764f, -0.06149531f, 0.07467503f, 0.05263025f, 0.07289419f, 
    -0.30572018f, 0.23267303f, 0.30966678f, -0.15665589f, -0.18669946f, -0.21930678f, 0.01365391f, -0.03414273f, 
    -0.07476011f, -0.00047443f, -0.01211678f, -0.01834959f, -0.39263803f, -0.11193579f, -0.01256237f, 0.15087861f, 
    0.11092886f, 0.10144775f, -0.04404591f, -0.04695943f, 0.08747508f, 0.03150688f, -0.05454958f, -0.00105559f, 
    0.25627902f, 0.15537389f, -0.11708602f, 0.06565724f, 0.00320844f, 0.03823062f, 0.03966152f, -0.00940044f, 
    0.02793043f, -0.04862958f, 0.01967292f, -0.16205375f, -0.39879054f, -0.59111696f, -0.06633493f, 0.00949826f, 
    0.13564441f, 0.08558720f, -0.00907448f, -0.11159740f, -0.03164992f, 0.09281060f, -0.07033637f, 0.08617807f, 
    -0.02134884f, 0.15998232f, 0.06464893f, -0.02303963f, 0.03302451f, -0.05846211f, 0.13657379f, 0.02221384f, 
    -0.03957348f, 0.07435381f, -0.01771967f, 0.10771611f, 0.08261482f, -0.00624860f, -0.07354579f, -0.32717329f, 
    -0.04178385f, 0.03140698f, 0.09364571f, -0.03818380f, -0.02890524f, -0.01876652f, -0.07085782f, -0.02044997f, 
    -0.38210914f, -0.29523265f, -0.58359456f, 0.02185257f, 0.02779023f, 0.26085690f, -0.13626608f, -0.26787621f, 
    0.02524991f, -0.06073895f, -0.00087573f, 0.06119748f, -0.36999592f, -0.53800446f, 0.15945974f, 0.36422724f, 
    0.14668135f, 0.14686140f, -0.14512029f, -0.24125947f, 0.02911571f, -0.01268588f, 0.08193624f, 0.07300340f, 
    -0.58186412f, -0.58244157f, -0.15667416f, -0.37785119f, -0.02812456f, -0.13146016f, -0.01789654f, -0.19458424f, 
    -0.04267072f, -0.03537221f, -0.00863195f, -0.00117888f, -0.00467996f, -0.08737718f, -0.16303562f, -0.02792692f, 
    -0.02953592f, -0.03064453f, 0.00898103f, 0.00609265f, -0.08721066f, -0.07665862f, -0.18903321f, -0.18234979f, 
    0.13565847f, -0.02388247f, -0.10028715f, -0.04497416f, -0.02536957f, -0.01976932f, 0.02256525f, 0.03616078f, 
    0.09089987f, 0.12120205f, 0.09940013f, 0.26922750f, 0.06300956f, 0.04851142f, 0.01716164f, 0.09316438f, 
    0.12722127f, 0.06438266f, -0.04054876f, 0.36950433f, 0.07088198f, -0.00447337f, 0.05617192f, -0.07846087f, 
    0.04977532f, 0.20896547f, 0.02573488f, 0.05260081f, 0.02362709f, 0.04947126f, 0.09022082f, -0.05061826f, 
    0.10953386f, 0.23399952f, 0.15273431f, 0.17933285f, 0.04062912f, 0.28531554f, 0.01151842f, -0.38722941f, 
    0.08983796f, 0.07025675f, 0.04020787f, 0.27398342f, -0.04893261f, 0.20631920f, 0.24022484f, 0.08872220f, 
    -0.18347786f, -0.04489990f, -0.29790196f, 0.15014473f, -0.09562781f, -0.14605217f, 0.02890297f, -0.03338616f, 
    0.01732879f, 0.05348066f, -0.00130285f, -0.17419672f, -0.15807202f, -0.04256455f, 0.08594133f, -0.09449711f, 
    -0.09705632f, -0.16676539f, 0.11302391f, 0.06342434f, 0.03946976f, 0.04675736f, -0.00489460f, -0.11453813f, 
    0.12832989f, 0.09790165f, -0.08355415f, -0.13225591f, -0.01948813f, 0.02532747f, -0.00232550f, -0.02294580f, 
    -0.09339792f, -0.04159828f, -0.26731238f, 0.00185679f, 0.11081758f, -0.01457190f, -0.00561016f, -0.05430633f, 
    -0.03651236f, 0.15682605f, 0.03080474f, -0.00276253f, -0.11135499f, -0.00030556f, 0.07418834f, -0.03560633f, 
    0.02107371f, -0.20137949f, -0.08637230f, -0.17723969f, -0.00262697f, -0.01500277f, -0.03674761f, 0.02144318f, 
    0.02390413f, 0.08587105f, 0.02202614f, 0.03928519f, 0.17957786f, -0.19905214f, -0.19757935f, -0.19944917f, 
    0.02023998f, -0.01122578f, 0.00647939f, -0.04916370f, 0.10309496f, 0.06393959f, -0.06064765f, 0.06451330f, 
    0.11082353f, 0.15710171f, -0.17055638f, 0.11065849f, -0.05965265f, 0.08786865f, 0.09060919f, 0.01389622f, 
    -0.08535712f, 0.09470322f, -0.04348902f, 0.00323665f, -0.14476362f, 0.20470029f, 0.14362372f, -0.05797130f, 
    0.07088633f, 0.08523589f, 0.08919363f, -0.07352410f, 0.00858918f, -0.00184982f, 0.01527275f, -0.04348507f, 
    -0.16297121f, 0.06956186f, -0.04011492f, 0.17969517f, -0.08151021f, 0.07096511f, 0.11277117f, 0.01978582f, 
    -0.27058738f, -0.05178823f, -0.13811226f, -0.12946466f, -0.07647971f, -0.24871631f, -0.26468810f, -0.26337114f, 
    0.01376906f, 0.15321054f, 0.01231100f, 0.01377013f, 0.00856209f, -0.01127095f, -0.03454453f, 0.02231049f, 
    0.23174611f, -0.60475659f, -0.28140143f, 0.58183134f, 0.10012794f, -0.02629143f, 0.03060716f, 0.02003868f, 
    0.05604363f, 0.00855313f, 0.06079519f, 0.03026338f, 0.57616627f, -0.17244865f, -0.18564458f, -0.26287833f, 
    -0.09778473f, -0.10056876f, -0.17870814f, -0.18437612f, -0.07396061f, -0.02401456f, -0.03573357f, 0.02990581f, 
    0.29104367f, -0.21013623f, 0.20643404f, -0.23607205f, -0.15625124f, 0.10325446f, 0.01545643f, 0.06244500f, 
    0.03394252f, 0.05981300f, 0.03902480f, -0.04956030f, 0.04823240f, -0.25930879f, 0.15820234f, 0.06716095f, 
    -0.17626344f, 0.06038430f, -0.03725987f, -0.04054244f, -0.00939989f, 0.02372386f, -0.01045513f, -0.01814734f, 
    -0.01998873f, 0.05165052f, 0.05712403f, 0.12354887f, -0.05953063f, 0.10788798f, 0.08451396f, -0.00981542f, 
    -0.04159542f, 0.05696481f, 0.01916014f, -0.02848277f, 0.07002456f, 0.02823293f, 0.06732959f, -0.11494899f, 
    -0.04504709f, 0.03686133f, -0.00367863f, 0.01112328f, 0.07457143f, -0.02706982f, -0.11873987f, -0.12989655f, 
    0.08699062f, -0.04666243f, -0.12675513f, -0.04898858f, 0.04537228f, 0.03731452f, 0.11302020f, -0.04185211f, 
    -0.01586565f, 0.01661099f, 0.02580797f, 0.03372045f, 0.15358765f, -0.00764277f, 0.00535847f, -0.06122566f, 
    0.01835983f, -0.13958801f, -0.08345035f, -0.01661565f, 0.01802002f, -0.02670848f, 0.00750646f, 0.00031996f, 
    0.02779908f, -0.07422323f, 0.02998283f, -0.03486019f, 0.00293523f, -0.02256760f, 0.02847301f, -0.00831282f, 
    0.04360501f, 0.05707725f, -0.06304196f, -0.11883413f, -0.17222250f, 0.11001265f, -0.18931402f, -0.00908854f, 
    0.06143436f, -0.11416756f, 0.16215144f, -0.00295076f, -0.00193780f, -0.05345703f, -0.00104010f, 0.03423227f, 
    0.23350064f, -0.61221337f, 0.18030035f, -0.05097556f, -0.01286321f, 0.03432681f, -0.05155889f, -0.05665291f, 
    -0.12889998f, 0.04925319f, -0.09900939f, 0.03209380f, -0.02767499f, 0.19848163f, 0.17738798f, 0.12278464f, 
    0.02285480f, 0.08041936f, -0.01956106f, -0.05962575f, -0.04044762f, -0.04065494f, 0.04773367f, 0.04343343f, 
    0.01993445f, 0.14477026f, -0.04074289f, 0.06489356f, 0.00755118f, -0.00957804f, 0.00268907f, -0.03072589f, 
    -0.00033826f, 0.07058001f, 0.02161692f, -0.02758492f, 0.51242477f, -0.37955326f, -0.10075250f, -0.48928711f, 
    -0.03379907f, -0.05335097f, -0.12845215f, 0.09974891f, 0.01471535f, 0.03223306f, 0.00960039f, -0.04089882f, 
    0.16958848f, -0.09100184f, -0.09120681f, -0.06042758f, 0.03632289f, -0.06113058f, -0.06551018f, -0.05496218f, 
    -0.08630194f, 0.00299589f, 0.02865749f, -0.14890154f, -0.24315463f, -0.27172622f, 0.19476578f, -0.05545439f, 
    -0.03445059f, -0.01641972f, -0.00634892f, 0.11816460f, -0.01569224f, -0.10563917f, -0.00768977f, -0.01300552f, 
    -0.07030817f, -0.41825777f, 0.18909848f, -0.25160971f, -0.04862010f, -0.06300013f, -0.22925736f, 0.30022356f, 
    0.01788276f, -0.03403219f, -0.07144526f, -0.04669910f, -0.19174212f, -0.19457647f, -0.14813916f, -0.13859074f, 
    0.14364173f, 0.01462025f, 0.14323308f, 0.07793658f, -0.00198154f, 0.03693454f, -0.00069733f, 0.04334389f, 
    -0.23019540f, 0.25026914f, 0.14771849f, 0.02328429f, 0.01396883f, -0.10206210f, -0.06895903f, 0.00994437f, 
    0.02996666f, -0.04096860f, 0.06851611f, -0.00662188f, -0.06730423f, 0.15847513f, 0.11985757f, -0.04327635f, 
    -0.02203772f, -0.01779335f, 0.00277079f, -0.04859343f, 0.01443949f, -0.09162648f, -0.08582125f, -0.07961088f, 
    -0.06185868f, 0.06712852f, -0.06728424f, 0.21435161f, 0.10802203f, -0.06298043f, 0.09374972f, -0.04890939f, 
    0.00342823f, 0.00945873f, -0.04556292f, -0.01013330f, -0.25287318f, -0.03082438f, 0.14912897f, -0.08340857f, 
    0.12873933f, 0.01598922f, 0.06892793f, 0.03918003f, -0.00114604f, -0.08684660f, 0.08357368f, 0.06102215f, 
    -0.13264515f, 0.02539179f, 0.01064942f, -0.07486296f, -0.02549484f, 0.01673605f, 0.01646337f, -0.03920380f, 
    0.01711815f, 0.00504178f, 0.03217493f, 0.01175782f, -0.47039622f, 0.02939046f, -0.22728667f, -0.08420736f, 
    0.05511275f, -0.02878679f, 0.08683830f, -0.02024129f, -0.04715151f, -0.07358590f, -0.11379787f, -0.02845219f, 
    -0.07763110f, -0.09006409f, 0.01489488f, -0.16857351f, 0.04113889f, 0.01227575f, 0.02340887f, 0.02385020f, 
    0.04851693f, 0.01712841f, 0.02712369f, 0.02343097f, 0.04983078f, -0.49981168f, -0.24457997f, -0.41550538f, 
    -0.00609692f, 0.10332698f, 0.04137559f, 0.18326612f, 0.14614893f, -0.03031619f, -0.09215537f, 0.06071658f, 
    -0.70385742f, 0.68837082f, -0.15666161f, 0.39853904f, 0.10558113f, -0.05397590f, 0.10673914f, -0.09459049f, 
    -0.12506574f, 0.04806958f, -0.09542707f, 0.07102597f, 0.00512794f, -0.08675484f, -0.02979481f, -0.03916977f, 
    0.02177372f, -0.01502239f, -0.03035542f, -0.05660732f, -0.00400255f, -0.04491094f, -0.02225811f, -0.08625951f, 
    0.07438152f, -0.01996249f, -0.05501818f, -0.17520714f, -0.01876337f, -0.08526304f, -0.02625481f, 0.07850090f, 
    -0.02799055f, 0.08209313f, 0.02503629f, -0.02434390f, -0.40569887f, -0.00908964f, -0.28777021f, -0.03994417f, 
    -0.11500078f, 0.15008394f, -0.07696580f, 0.05025285f, 0.02913387f, -0.02985562f, -0.00184456f, 0.01932133f, 
    -0.06607012f, 0.11685681f, 0.10283443f, -0.01006208f, 0.06251876f, -0.04514967f, 0.05471067f, -0.07167054f, 
    0.09996855f, 0.04645805f, 0.02052374f, -0.08098994f, 0.06623453f, 0.01123196f, -0.00673947f, 0.01349514f, 
    -0.00372758f, -0.02355652f, -0.03663947f, -0.05071723f, -0.03866056f, 0.04589495f, -0.03440030f, -0.03121832f, 
    0.51512337f, -0.72487861f, -0.46979579f, -0.31197166f, -0.12799649f, -0.01001657f, -0.13151973f, 0.02268129f, 
    0.03639081f, 0.02792329f, 0.03834318f, 0.03154791f, -0.45884907f, -0.33633274f, 0.26268950f, -0.03551819f, 
    0.07446581f, -0.04750206f, 0.00610018f, 0.11339504f, -0.03304103f, 0.04741129f, -0.07746757f, -0.03980553f, 
    -0.27030081f, 0.11843208f, -0.07241985f, 0.21721818f, -0.03024807f, 0.02957047f, 0.12747085f, -0.04885043f, 
    -0.10832522f, -0.03008201f, 0.00995688f, -0.12870474f, -0.13959223f, -0.14048479f, -0.01967889f, 0.03961482f, 
    0.01340168f, 0.04211767f, 0.04461833f, 0.03231354f, 0.03230195f, 0.04804610f, 0.08727220f, 0.05189086f, 
    0.14976922f, -0.13463888f, 0.11430392f, 0.17387453f, -0.05720668f, -0.14485149f, -0.20141456f, -0.13899872f, 
    -0.00920825f, -0.01396344f, -0.03395019f, -0.01121495f, 0.44501162f, -0.35801628f, -0.23647940f, -0.42134130f, 
    -0.01508866f, -0.01824566f, -0.02988728f, -0.06984602f, 0.13821089f, 0.01792276f, -0.09871343f, -0.03484919f, 
    -0.06930834f, 0.13183552f, -0.07805461f, -0.07514166f, -0.03734559f, -0.16207229f, -0.03815468f, -0.13387002f, 
    -0.02218929f, 0.04834989f, 0.01727016f, -0.00797165f, -0.36409912f, -0.00319241f, -0.27859676f, 0.40998891f, 
    0.01524685f, 0.00582817f, -0.03308019f, -0.27494788f, -0.00429722f, -0.09579019f, 0.00212537f, -0.06360079f, 
    0.50406045f, -0.62495387f, -0.24404196f, -0.01302186f, -0.04299080f, -0.02481601f, -0.03585035f, -0.03808533f, 
    -0.03659444f, -0.00754692f, 0.06859944f, -0.02670065f, 0.05147748f, 0.05303440f, 0.10595480f, -0.05206390f, 
    0.02396182f, -0.03396156f, 0.10247912f, -0.07137762f, 0.02165902f, 0.05721482f, -0.01201739f, 0.05344619f, 
    -0.08828653f, -0.00038387f, 0.00763453f, -0.04807356f, -0.05452557f, -0.09075845f, 0.02784668f, -0.07890306f, 
    -0.06088344f, -0.03070626f, 0.02516736f, 0.01783592f, 0.00156743f, -0.03706859f, 0.16095370f, -0.16200663f, 
    -0.10678665f, -0.00638091f, -0.07073987f, 0.13414988f, 0.00348059f, 0.04875921f, -0.04209504f, 0.00988727f, 
    0.18320033f, -0.00422829f, -0.12558724f, -0.14157371f, 0.02145377f, 0.01304686f, -0.08934626f, -0.08068135f, 
    -0.05695811f, -0.04070675f, -0.21143988f, -0.14799622f, -0.06131660f, 0.08578487f, -0.07746934f, 0.08492056f, 
    0.03723110f, 0.00322779f, 0.00458944f, -0.03341612f, -0.00027079f, -0.01864513f, 0.02047769f, 0.06047181f, 
    0.05817230f, -0.15747170f, -0.15926284f, 0.25217915f, 0.06773596f, -0.16292404f, 0.02221403f, -0.07574829f, 
    0.03079451f, 0.08893207f, -0.03188820f, -0.00921364f, 0.11841207f, 0.11143312f, 0.36942300f, 0.15226173f, 
    -0.04145833f, -0.20400998f, -0.03180118f, 0.06424977f, 0.00547563f, 0.06468432f, 0.04711482f, -0.07254739f, 
    -0.18492983f, -0.31787369f, -0.23303443f, -0.24506649f, 0.05767123f, -0.04447653f, -0.03714491f, 0.03940833f, 
    0.02944175f, -0.00554077f, -0.03364493f, -0.01583329f, 0.06468674f, -0.01523389f, -0.04172769f, -0.09171751f, 
    -0.00129954f, -0.02171881f, -0.01596559f, -0.05181071f, -0.01153763f, 0.00886607f, 0.00389578f, -0.01647820f, 
    -0.02504163f, 0.05052003f, -0.04260923f, 0.09407385f, -0.03005821f, -0.02935549f, 0.00773046f, 0.00522099f, 
    0.07212054f, 0.03251812f, 0.09842162f, 0.02158466f, 0.08467246f, -0.00161791f, 0.01248665f, -0.02098924f, 
    -0.03406213f, -0.06055243f, -0.06325232f, -0.19583976f, -0.10570790f, -0.02426532f, -0.00991868f, 0.05242013f, 
    -0.23537521f, -0.02126755f, 0.07629668f, 0.23793131f, -0.08981294f, -0.00948153f, 0.11627439f, 0.04293020f, 
    -0.08874496f, 0.04631247f, 0.01163508f, -0.05211802f, -0.20241745f, 0.10867277f, -0.06062467f, 0.24234103f, 
    -0.01103180f, -0.14693664f, -0.00889271f, -0.08152573f, 0.05987222f, -0.02147445f, 0.04377782f, -0.07569098f, 
    0.12492713f, 0.00704691f, 0.02105961f, -0.03126408f, 0.00946273f, 0.09825673f, 0.08053213f, 0.01502975f, 
    -0.00263068f, 0.02415244f, -0.05093836f, -0.00737603f, -0.22129869f, 0.12793517f, -0.13431762f, 0.12873256f, 
    0.01466090f, 0.09940176f, 0.17415249f, 0.04829477f, -0.00245544f, 0.03666462f, -0.00800947f, 0.04859440f, 
    0.03985132f, -0.07729357f, -0.05124521f, -0.14762028f, -0.02060559f, 0.03819563f, 0.07236192f, -0.00192967f, 
    0.07187544f, 0.07244714f, 0.16640581f, 0.01550779f, 0.00784271f, -0.01289209f, -0.07008622f, -0.07493088f, 
    0.01009559f, -0.13631561f, -0.00161250f, -0.01489875f, 0.04764181f, 0.09390571f, 0.10982862f, 0.09966873f, 
    -0.18138707f, -0.18718523f, -0.04520421f, 0.08355962f, 0.04857018f, 0.05108932f, 0.03104449f, 0.02950824f, 
    0.07483886f, 0.04128290f, -0.05922629f, 0.05180104f, -0.05807189f, -0.09521893f, 0.00445130f, -0.30594510f, 
    -0.06581227f, 0.03974735f, -0.02230547f, 0.07022742f, -0.00063464f, -0.07884119f, -0.19506685f, -0.02066197f, 
    -0.23298757f, 0.09194311f, -0.00982830f, -0.00460524f, -0.00096628f, 0.04818661f, -0.16215758f, 0.04917977f, 
    -0.10522837f, 0.12890190f, -0.03941434f, 0.15924001f, 0.03221215f, -0.32749248f, 0.08077810f, -0.10496749f, 
    0.02335106f, 0.03338115f, -0.14388108f, -0.02372033f, 0.12345093f, 0.06499070f, 0.21372136f, 0.11999931f, 
    -0.28054291f, -0.18157527f, 0.13580121f, 0.16714934f, -0.00835693f, 0.11274153f, 0.03511977f, -0.04121460f, 
    0.13360819f, 0.05246117f, 0.23713528f, 0.11669017f, 0.05289149f, -0.49997571f, -0.31665388f, 0.06625863f, 
    0.09564055f, 0.05055574f, 0.05985589f, 0.03221297f, -0.06769830f, 0.00814910f, 0.05150589f, -0.04580028f, 
    0.08575170f, -0.31381094f, -0.65276635f, -0.47902402f, -0.04872693f, 0.09947331f, 0.13046914f, 0.16230834f, 
    0.14887072f, 0.04938126f, -0.11864100f, -0.06791349f, 0.00773853f, 0.00652879f, -0.16166978f, -0.12994534f, 
    0.12506723f, 0.14757884f, 0.12674268f, 0.20853043f, 0.02295564f, 0.01033780f, -0.04343745f, -0.10793427f, 
    -0.08379877f, -0.17712684f, -0.07604116f, 0.00195043f, 0.07415041f, -0.06580117f, 0.04546918f, -0.02484974f, 
    0.03956673f, 0.02172040f, 0.02621655f, 0.15378655f, 0.31544200f, -0.09925792f, -0.11027847f, -0.10631596f, 
    0.23979492f, -0.04855534f, -0.11604483f, 0.02965671f, -0.00136052f, 0.16430534f, 0.13271013f, 0.10752077f, 
    -0.35750812f, -0.18966503f, 0.17032662f, 0.15497245f, -0.02322114f, -0.02063410f, 0.02143648f, -0.05189522f, 
    0.07540745f, 0.12426460f, 0.11394177f, 0.10832107f, -0.07157896f, 0.16781442f, -0.05922908f, -0.31895950f, 
    -0.01962585f, -0.01795297f, -0.00919656f, -0.00000027f, 0.00670499f, -0.02514700f, -0.00097778f, 0.01515686f, 
    -0.03133459f, -0.14768630f, -0.08699797f, 0.07290050f, 0.02388755f, 0.03494060f, 0.10211163f, -0.00482411f, 
    0.08952907f, 0.07162612f, 0.05254274f, 0.09000023f, -0.05029187f, -0.07029490f, -0.16943412f, -0.05942826f, 
    -0.02075012f, -0.01553551f, 0.00498978f, 0.04999163f, -0.04133402f, 0.01620183f, 0.00664989f, 0.01969687f, 
    0.02116530f, -0.06830683f, -0.08140032f, 0.11911038f, -0.04521604f, -0.04427630f, 0.07884118f, -0.06729922f, 
    0.01035689f, 0.08565465f, 0.07723111f, -0.06646489f, -0.09431043f, -0.07840699f, -0.14944737f, 0.18488674f, 
    -0.03708512f, 0.08735608f, -0.07590155f, 0.15794089f, -0.04939163f, -0.01654640f, 0.02350016f, -0.03545309f, 
    0.49873790f, 0.22013050f, 0.02296219f, -0.26292250f, 0.15633355f, -0.02698771f, 0.08742124f, -0.16314140f, 
    0.02385866f, 0.11444591f, -0.05955373f, -0.01485225f, -0.61755329f, 0.11789630f, 0.09198129f, -0.04966125f, 
    0.03522606f, 0.00527646f, -0.07972912f, 0.04905674f, -0.15762232f, -0.10186193f, -0.16121289f, -0.10293932f, 
    -0.00802279f, 0.03249222f, 0.09580691f, 0.01440463f, -0.11134307f, -0.02408117f, 0.00178324f, -0.08166667f, 
    -0.06169584f, 0.05590799f, 0.02922635f, -0.00122414f, -0.09077882f, -0.27558658f, -0.19121070f, -0.07114080f, 
    -0.00749580f, 0.03584222f, 0.19672954f, 0.17524233f, 0.11878009f, 0.02426358f, -0.04693279f, -0.08449249f, 
    0.21377270f, -0.03070863f, -0.07788762f, -0.02087801f, 0.02286294f, 0.06414612f, 0.01811825f, -0.06617726f, 
    0.13135538f, -0.09054463f, 0.04988679f, 0.00763557f, -0.09239371f, -0.02437541f, -0.24868959f, -0.39425391f, 
    -0.14799279f, 0.08304449f, 0.08561069f, -0.12779535f, 0.04277275f, -0.08532988f, -0.05805454f, -0.07264816f, 
    -0.23075564f, -0.15253742f, -0.52764565f, 0.02888203f, 0.02813804f, -0.01352093f, 0.16233759f, -0.29565406f, 
    0.00325120f, -0.08015260f, 0.01914799f, 0.08454367f, 0.00762367f, -0.28778368f, -0.41351646f, -0.12663220f, 
    -0.11054271f, -0.02239378f, 0.04758470f, -0.13473628f, -0.04655277f, -0.03947991f, -0.05743160f, -0.03653001f, 
    -0.49554920f, 0.02828392f, 0.15211707f, 0.25428343f, 0.01112897f, 0.01652046f, 0.09299377f, 0.16460684f, 
    0.09122142f, -0.00231161f, 0.09385210f, 0.02592839f, -0.34977379f, -0.03030450f, -0.04529001f, -0.04393043f, 
    -0.03151825f, 0.06425381f, -0.04817909f, 0.01401595f, 0.00221053f, 0.16755809f, 0.11715318f, 0.17865480f, 
    -0.20982823f, -0.18417989f, 0.05054715f, -0.00817072f, 0.12957974f, -0.05513140f, -0.25318187f, 0.18141192f, 
    0.09064855f, -0.06813440f, 0.02084143f, 0.05445514f, -0.00481062f, -0.00153163f, -0.16058165f, 0.04319301f, 
    -0.04868589f, 0.11645710f, 0.02733456f, -0.32254598f, 0.00495293f, -0.09333928f, -0.14865814f, -0.07331453f, 
    -0.17514972f, 0.15822954f, 0.16124029f, -0.01587002f, -0.09328774f, -0.06256064f, -0.04969505f, 0.01133811f, 
    -0.10953242f, 0.08616859f, -0.02906066f, 0.02021921f, 0.24545418f, -0.13943210f, 0.17121279f, 0.27290142f, 
    0.09050704f, 0.16637041f, 0.01899897f, 0.00475518f, -0.01834558f, -0.03496424f, 0.04734549f, 0.01960717f, 
    -0.15918423f, 0.08183648f, -0.08009243f, 0.15915206f, 0.03258003f, -0.10628261f, 0.00507641f, -0.07180101f, 
    -0.00419958f, 0.00582746f, 0.01698753f, 0.05291383f, -0.22905409f, -0.37067536f, -0.37697288f, -0.07740928f, 
    0.06882542f, 0.07114124f, 0.16276535f, -0.01961869f, -0.10491952f, -0.08578572f, -0.18410210f, -0.47044557f, 
    -0.37471467f, -0.16231067f, -0.12324262f, 0.04179064f, -0.03843282f, 0.18871517f, 0.11974423f, 0.18546779f, 
    0.09499524f, 0.16581587f, 0.10397501f, 0.15033886f, -0.07427494f, 0.25931352f, -0.04249568f, -0.05603203f, 
    0.04742873f, 0.03289916f, -0.01980440f, -0.08894551f, 0.07777556f, 0.01439802f, 0.11750901f, 0.06679803f, 
    0.20226680f, 0.20281403f, 0.08492907f, -0.17653421f, -0.02977473f, -0.12012833f, -0.09360766f, -0.03931444f, 
    -0.13281238f, -0.02903349f, -0.12039196f, -0.01599170f, -0.18242453f, -0.17802706f, -0.25757274f, 0.20318148f, 
    0.07921008f, 0.05992465f, -0.21556310f, 0.22643757f, 0.07261292f, 0.02131902f, 0.00951438f, -0.01267490f, 
    -0.24374545f, -0.10060930f, -0.03983312f, -0.09916770f, -0.09552373f, -0.09815149f, -0.03926557f, -0.12101216f, 
    -0.09022237f, -0.03487151f, -0.16524798f, -0.11708136f, 0.00446927f, 0.11629512f, 0.06094654f, 0.03959717f, 
    0.05894323f, -0.08567170f, -0.07831323f, -0.02535382f, 0.08227685f, 0.06862077f, 0.09114227f, 0.07283311f, 
    -0.32668552f, -0.42709607f, -0.39345524f, 0.02451223f, 0.03058924f, 0.18570942f, 0.14168097f, 0.11096222f, 
    0.01069283f, -0.09571026f, -0.01011385f, -0.05619476f, 0.39598596f, -0.01081228f, -0.32450470f, -0.03288725f, 
    -0.19437893f, -0.09765474f, 0.04928553f, -0.21551774f, 0.07795081f, -0.07015609f, 0.03717671f, 0.07033151f, 
    -0.89220160f, 0.14523001f, 0.23472397f, 0.20375569f, -0.06510846f, 0.07164721f, -0.19863927f, 0.06169934f, 
    -0.05482456f, 0.13784246f, 0.09616192f, 0.22812940f, -0.05634103f, -0.05342307f, -0.09894786f, -0.13916115f, 
    -0.10263352f, -0.05088561f, -0.08659310f, 0.05103389f, -0.10641097f, 0.06586163f, -0.09988753f, -0.06693115f, 
    0.38641289f, 0.32566619f, -0.09187085f, -0.28955460f, 0.04045657f, -0.07513852f, -0.05086143f, 0.04603316f, 
    0.06088911f, 0.02286385f, 0.00688435f, 0.00553909f, 0.07982435f, -0.08111817f, -0.18359293f, -0.10230926f, 
    0.04638957f, 0.05329617f, 0.07080346f, 0.04507861f, -0.08133541f, -0.03635481f, -0.00024468f, -0.24966344f, 
    -0.22326782f, -0.00450753f, 0.09941565f, -0.01794821f, 0.10165893f, 0.10903734f, 0.02963468f, -0.02738929f, 
    0.01906258f, -0.05417718f, 0.06614198f, 0.00431407f, 0.34950167f, 0.02523264f, -0.35432601f, -0.16998769f, 
    0.24963073f, 0.08967466f, -0.00245686f, 0.20742497f, 0.17090650f, 0.09260824f, 0.08159689f, 0.17131372f, 
    0.07112520f, -0.11680042f, -0.65637976f, -0.14093176f, 0.15888824f, -0.02357667f, -0.01327187f, -0.04670395f, 
    -0.01053589f, 0.03745979f, -0.04318189f, 0.08169474f, -0.29757944f, -0.00834402f, 0.14038804f, 0.05365254f, 
    -0.02508340f, 0.11661962f, -0.08488980f, -0.25367147f, -0.00586451f, -0.07638814f, -0.04756000f, 0.05311282f, 
    -0.18216228f, 0.04771618f, 0.08663863f, -0.00841794f, 0.09827868f, 0.04492432f, 0.02410996f, 0.06628273f, 
    -0.09545063f, 0.05574387f, 0.07072475f, 0.08283342f, 0.11014074f, 0.10172345f, 0.06378387f, 0.04864933f, 
    0.06211358f, -0.05181558f, 0.05118481f, -0.03075713f, 0.03480433f, -0.03062979f, 0.04271314f, -0.09666929f, 
    0.13190748f, -0.09548474f, -0.10685075f, -0.10416977f, 0.01096305f, -0.04115260f, 0.01217621f, -0.04882085f, 
    0.02966215f, 0.03237092f, 0.02633184f, 0.11439413f, -0.41870961f, 0.04816855f, 0.10340275f, 0.08587262f, 
    0.09401983f, -0.02660103f, -0.09319124f, 0.01966566f, -0.14360920f, -0.08605700f, -0.00841627f, -0.01910026f, 
    0.27361906f, 0.22503734f, -0.14624846f, 0.19861788f, 0.00559852f, 0.07745991f, 0.19204101f, 0.07123846f, 
    0.02349802f, -0.02103718f, 0.04212985f, 0.00896004f, -0.00749195f, 0.03520173f, 0.02684364f, 0.03603950f, 
    -0.10650942f, -0.05873287f, 0.03125599f, -0.06416360f, -0.03162199f, -0.07371463f, -0.02073756f, 0.00430116f, 
    -0.16059591f, -0.46863019f, -0.46298206f, -0.17922980f, -0.05799998f, -0.08587790f, 0.07694511f, -0.05429965f, 
    -0.03206654f, -0.02318575f, 0.00860427f, 0.02203087f, -0.00429413f, -0.00949945f, -0.03083468f, -0.10220905f, 
    -0.07075647f, -0.07818069f, -0.01184386f, -0.10255673f, 0.00338377f, 0.00256806f, 0.02378047f, -0.02162117f, 
    -0.10685618f, 0.03887747f, -0.02458782f, -0.03817290f, 0.04023759f, 0.01257183f, -0.00116664f, 0.03170295f, 
    -0.17414865f, -0.19101436f, -0.19820775f, -0.48241213f, -0.02741703f, -0.01425461f, -0.10851441f, -0.02052286f, 
    0.12116182f, 0.07116693f, -0.09017701f, -0.03437092f, 0.01687066f, -0.08319893f, -0.00835625f, -0.08168139f, 
    -0.25603113f, -0.13405252f, 0.20122743f, 0.21855678f, -0.03813195f, 0.08548397f, -0.03759364f, 0.01904680f, 
    -0.06700572f, 0.02300978f, -0.10429820f, -0.09538303f, -0.05502352f, -0.08449388f, -0.19091269f, -0.04956395f, 
    0.06666453f, 0.06691280f, 0.03760922f, 0.03568231f, 0.02926903f, 0.05055702f, -0.07823505f, -0.02710970f, 
    -0.05771723f, 0.05379922f, 0.01847544f, 0.10258904f, 0.02261764f, -0.07933997f, -0.11460568f, -0.02242232f, 
    0.02380257f, 0.03068733f, 0.19499162f, 0.04729816f, -0.28308520f, 0.02799818f, 0.06093091f, 0.26171353f, 
    -0.00631602f, 0.00227709f, 0.02232752f, -0.11514751f, 0.07213859f, 0.00270191f, 0.05007534f, 0.06713655f, 
    0.05539902f, 0.06075250f, 0.32290727f, 0.30055818f, 0.09820135f, -0.02926035f, -0.13075051f, -0.06583624f, 
    -0.10628185f, -0.04680896f, -0.06859273f, -0.05698642f, 0.12058284f, -0.21667315f, 0.17663774f, 0.05768974f, 
    0.16970597f, 0.00730795f, 0.05378205f, -0.04664906f, 0.07761878f, -0.13854648f, -0.11207814f, 0.07063353f, 
    0.34577224f, 0.22598319f, 0.27924258f, -0.21711358f, -0.06682762f, -0.06119117f, -0.15294179f, -0.00124125f, 
    -0.14444362f, -0.00596043f, 0.03415767f, 0.01075351f, 0.21016425f, -0.00373095f, 0.31418484f, 0.43190429f, 
    0.10481103f, -0.09818569f, -0.12391531f, -0.09575616f, -0.05075430f, -0.01082264f, 0.06624152f, 0.05498732f, 
    -0.28350979f, 0.13940527f, -0.27642164f, 0.50739491f, -0.03728105f, -0.04452482f, -0.06672227f, 0.04770688f, 
    0.11921355f, -0.18767230f, 0.05734146f, -0.22349170f, 0.06550829f, -0.17839141f, 0.23981988f, -0.34696785f, 
    -0.02572393f, -0.09135751f, -0.00325844f, -0.11225136f, -0.07627433f, -0.04640701f, -0.01964583f, -0.15920644f, 
    0.06934243f, 0.02177638f, 0.08131826f, -0.55132002f, 0.06254581f, 0.00595935f, -0.03543738f, -0.08430513f, 
    0.00686282f, -0.03241509f, -0.01986211f, 0.05119455f, -0.15125217f, 0.16043988f, -0.15246402f, -0.52751386f, 
    -0.22116463f, -0.01870053f, 0.09674361f, -0.03801442f, 0.11269227f, 0.03306163f, 0.06126456f, 0.01352510f, 
    0.18165787f, 0.09591453f, 0.09564969f, 0.12279546f, 0.04317371f, -0.02762172f, 0.00838668f, 0.18084121f, 
    -0.03038701f, 0.06761038f, 0.05256699f, 0.04039059f, -0.34382576f, 0.18728010f, -0.02016210f, 0.14577128f, 
    -0.10378568f, -0.05102363f, -0.19203715f, -0.18423216f, 0.07498728f, -0.09458372f, 0.00876311f, 0.06881554f, 
    0.38391903f, -0.04289965f, 0.13644424f, -0.05731270f, -0.14409527f, 0.09961981f, -0.17903507f, 0.02215842f, 
    -0.09954492f, -0.12153010f, -0.07504080f, -0.03636124f, 0.10981177f, 0.14220920f, -0.22515510f, -0.03622894f, 
    -0.13035038f, -0.00941416f, -0.00078646f, -0.03803045f, 0.05733340f, -0.05957034f, -0.04145039f, 0.04537743f, 
    0.05897343f, -0.16581953f, 0.00061339f, -0.39388186f, -0.02241435f, -0.05300701f, 0.03442129f, 0.00455373f, 
    -0.03992369f, 0.02046115f, -0.17374223f, -0.09987144f, -0.03143216f, -0.01056259f, -0.11011682f, 0.17765483f, 
    0.11014643f, 0.01734106f, 0.02490136f, -0.14691366f, -0.07226488f, -0.03402375f, -0.00658570f, -0.07902138f, 
    0.27358142f, 0.01494239f, -0.03151752f, -0.13327347f, 0.03664929f, -0.05852312f, -0.08683757f, 0.02835861f, 
    -0.00506290f, -0.05866753f, 0.01995740f, 0.05573411f, 0.05099924f, 0.00992157f, 0.12291871f, 0.02001563f, 
    0.06473082f, 0.00551108f, -0.07457685f, -0.05820764f, 0.22058719f, -0.01012180f, 0.02836706f, 0.08146235f, 
    -0.00055754f, -0.01189671f, 0.30921224f, -0.10034786f, 0.04739438f, 0.01225143f, 0.08460405f, -0.17988694f, 
    0.00238167f, 0.25705814f, 0.01397623f, -0.13803421f, -0.28964749f, 0.32207468f, -0.05652284f, -0.09059631f, 
    -0.01141538f, -0.13758332f, -0.07537695f, -0.06384432f, 0.09537814f, 0.02963209f, 0.06436336f, -0.04482113f, 
    -0.02283177f, -0.66163552f, 0.17100629f, -0.12614560f, -0.11951292f, -0.02311069f, 0.01407559f, -0.01817789f, 
    -0.02778528f, 0.14731497f, 0.05274181f, -0.04932839f, -0.38270900f, -0.11428072f, -0.82891059f, 0.21559897f, 
    -0.04654860f, 0.00018311f, 0.14778391f, -0.05520755f, -0.02379466f, -0.04978819f, 0.05888261f, 0.07898290f, 
    -0.18504205f, -0.32518482f, 0.06465196f, 0.04041582f, 0.00308833f, 0.11693235f, -0.02270184f, 0.05214318f, 
    0.01968168f, 0.01460429f, 0.01433257f, -0.05863075f, -0.20324436f, -0.05231142f, -0.21005273f, 0.30775672f, 
    -0.14202796f, 0.19174948f, -0.21747547f, -0.04052159f, 0.06604158f, -0.08648074f, -0.02844688f, -0.07952835f, 
    -0.29442096f, -0.21310902f, 0.14331172f, -0.04644309f, 0.05700184f, 0.13847825f, -0.23732914f, -0.24406923f, 
    -0.15475616f, -0.14507155f, -0.01033809f, 0.04189136f, -0.41064912f, 0.15320353f, 0.32531005f, -0.04451305f, 
    -0.12238780f, 0.10856827f, 0.10046919f, 0.02696746f, 0.04656024f, 0.09984460f, 0.07257470f, -0.06074266f, 
    -0.33380035f, 0.07480045f, 0.19440775f, -0.36341190f, -0.24965850f, 0.00210683f, -0.00195048f, 0.20515095f, 
    0.11243413f, 0.06558233f, -0.03534635f, -0.02213327f, -0.06909584f, 0.11840534f, 0.02834547f, 0.26229590f, 
    -0.16790533f, -0.00308776f, -0.03607859f, 0.09970395f, 0.05700925f, 0.04336342f, 0.02069183f, 0.08444943f, 
    -0.31993434f, 0.47227347f, -0.17520858f, -0.09865093f, -0.02674335f, -0.09290909f, 0.14946334f, 0.08225505f, 
    0.00150657f, -0.10594644f, -0.13824444f, -0.06290346f, 0.02257924f, -0.08919721f, 0.22184274f, -0.06767479f, 
    0.01665153f, -0.01955339f, 0.01865725f, -0.05263368f, 0.03787440f, 0.02000112f, 0.08591023f, 0.00014676f, 
    0.18655533f, -0.05475814f, -0.33311725f, 0.10719123f, 0.18662676f, -0.03569738f, -0.02917803f, 0.13146448f, 
    0.01463968f, 0.09759186f, 0.02888684f, -0.03103727f, 0.24985398f, -0.25180748f, -0.02794501f, -0.29575425f, 
    -0.11617244f, 0.06828514f, -0.00531137f, 0.18561822f, 0.08117278f, 0.06192661f, -0.00137727f, -0.05040196f, 
    -0.08583447f, -0.24702571f, -0.11688671f, 0.05076113f, -0.09923822f, 0.20157517f, 0.07580676f, 0.02771628f, 
    0.06983299f, 0.07449400f, -0.01800732f, -0.04314692f, -0.24137659f, -0.01028746f, -0.43422627f, -0.17648922f, 
    0.08126771f, -0.08753476f, 0.00061938f, 0.10292519f, 0.00205054f, 0.01427999f, -0.08767591f, -0.02384690f, 
    0.07437505f, 0.04089990f, -0.30192515f, -0.02231819f, 0.03527220f, 0.01269163f, 0.17802237f, -0.05230886f, 
    -0.02332127f, -0.06061225f, -0.02238098f, -0.00355561f, 0.18496586f, -0.16567041f, 0.19147114f, 0.03305898f, 
    -0.04755452f, -0.02444074f, -0.06180362f, -0.04157176f, 0.05408500f, 0.04856186f, 0.14114605f, 0.08134703f, 
    -0.21674041f, 0.13730896f, 0.11688903f, -0.16716409f, -0.02135935f, -0.06085740f, -0.09786528f, -0.02308743f, 
    0.12982677f, -0.05494665f, 0.10890638f, -0.04787020f, 0.06599269f, 0.08872423f, -0.18396924f, 0.05790198f, 
    0.21698426f, -0.00457400f, 0.02667445f, -0.05220809f, 0.12016616f, -0.09781963f, 0.04731423f, 0.01478914f, 
    -0.26790503f, -0.39040476f, 0.27707779f, -0.10059122f, -0.02350393f, 0.18172067f, -0.13770708f, 0.10544802f, 
    -0.06950320f, -0.01146534f, 0.02812085f, 0.05411309f, -0.33830884f, 0.29971012f, -0.30389836f, -0.49180782f, 
    -0.18950143f, 0.03542062f, -0.17236272f, 0.20738538f, 0.07498264f, -0.07126377f, -0.05146175f, -0.21169098f, 
    0.03831819f, -0.20303594f, 0.10802743f, -0.06857037f, 0.00158606f, -0.05606782f, 0.06912077f, 0.04229192f, 
    -0.01330872f, 0.17593414f, 0.15218909f, 0.08748799f, -0.14453323f, -0.06587284f, -0.22743902f, 0.10174127f, 
    0.06835436f, 0.08068035f, 0.11168794f, -0.08258626f, -0.04387491f, -0.02283337f, -0.05425088f, -0.11942908f, 
    0.07427231f, 0.23003386f, 0.15811527f, -0.40447709f, 0.00044366f, -0.12278537f, -0.13704097f, -0.13178372f, 
    0.00629397f, -0.01518099f, 0.10411122f, 0.06380321f, -0.51667690f, -0.46699789f, 0.10286438f, -0.17977433f, 
    0.20486811f, -0.13979039f, -0.06435369f, 0.22704063f, -0.01735247f, 0.00611163f, 0.00365904f, -0.07046009f, 
    -0.39601195f, -0.03361954f, 0.01969178f, -0.54343909f, 0.01349813f, -0.17629905f, 0.09038782f, 0.01076205f, 
    0.00619930f, 0.12207573f, -0.11662225f, 0.03295731f, 0.29372165f, 0.39345899f, -0.00265515f, -0.12749051f, 
    -0.12422063f, 0.02077641f, 0.07155046f, 0.17677316f, 0.02985511f, 0.05283303f, 0.05670285f, -0.02368586f, 
    -0.55472594f, -0.53705198f, -0.56313026f, 0.31937513f, -0.01025202f, 0.10828553f, 0.17546722f, 0.03831550f, 
    -0.02607848f, 0.00788125f, -0.01825952f, -0.10525639f, 0.24564704f, -0.06915843f, 0.36666939f, 0.37476775f, 
    0.06170358f, -0.11670881f, -0.08426436f, -0.19552565f, 0.02275183f, 0.07600684f, -0.10337567f, 0.11576599f, 
    -0.00094412f, 0.01417313f, -0.20151691f, -0.16453113f, 0.00472649f, 0.02113658f, 0.11016107f, -0.00293425f, 
    -0.09899133f, -0.07580725f, -0.20368440f, -0.04065357f, 0.04509378f, 0.20198649f, -0.14183010f, 0.08116400f, 
    0.01927218f, -0.13674903f, -0.07441334f, 0.05478924f, 0.03506977f, -0.05440815f, 0.07789782f, 0.06701709f, 
    -0.16225888f, 0.07969444f, 0.23810735f, 0.28225273f, 0.06190111f, -0.36187008f, -0.17533886f, -0.02002584f, 
    0.04030881f, -0.04237580f, -0.10292612f, 0.02968843f, 0.19976497f, -0.49138090f, 0.17415544f, -0.29982573f, 
    0.19754621f, -0.04756257f, 0.02276392f, -0.00792283f, -0.03491550f, 0.01082851f, -0.09089053f, 0.10967893f, 
    0.01799276f, 0.01304799f, -0.15571162f, -0.13854456f, 0.03558848f, 0.05821768f, 0.07028067f, 0.02780324f, 
    0.11337772f, 0.00433459f, -0.07267884f, 0.04831395f, 0.44897887f, -0.44724107f, 0.00739062f, 0.03148236f, 
    -0.08251045f, 0.10459075f, 0.14260954f, 0.24359933f, 0.02941369f, -0.08190294f, -0.07899623f, -0.25174403f, 
    0.25660828f, -0.09388682f, 0.17685516f, 0.28151345f, 0.08065216f, -0.15246551f, -0.17951101f, -0.10613669f, 
    -0.03437112f, 0.22533512f, -0.19332998f, -0.07052921f, -0.40455112f, 0.27913624f, -0.52362782f, 0.10231510f, 
    0.18732852f, -0.05046421f, 0.20499191f, 0.05186877f, 0.12536630f, 0.00585387f, 0.05660065f, 0.02281055f, 
    -0.32690573f, 0.17680420f, -0.44664517f, -0.10635279f, -0.04854045f, -0.24018264f, -0.00634134f, 0.16024481f, 
    -0.02543026f, 0.03417842f, 0.00439505f, 0.01785813f, -0.37055779f, -0.23808703f, 0.04771519f, -0.40358135f, 
    0.09461134f, -0.01166566f, 0.04658911f, 0.15216067f, 0.00413068f, -0.05282357f, -0.03434514f, 0.06711598f, 
    0.06780305f, 0.09994802f, 0.00206349f, -0.15418087f, -0.04723770f, 0.00890448f, 0.03365667f, 0.12484694f, 
    0.05486165f, -0.01343559f, 0.03683560f, 0.00761125f, -0.13425702f, -0.13719694f, -0.11023630f, 0.18341602f, 
    0.13457137f, 0.21774437f, 0.15256043f, -0.04489516f, 0.12952462f, 0.02631493f, 0.08427588f, 0.04606462f, 
    0.05213519f, 0.09946875f, -0.07025935f, -0.03955260f, 0.00956152f, 0.00200929f, 0.02372986f, 0.00682360f, 
    0.10023668f, 0.13747598f, 0.17857684f, 0.26095217f, -0.07300083f, -0.04020293f, -0.32092911f, -0.17035991f, 
    0.02048836f, 0.01726112f, -0.10954095f, -0.14060299f, 0.18330447f, -0.10005997f, 0.01573280f, -0.04776422f, 
    0.00740517f, -0.00015917f, 0.23906955f, -0.30690855f, 0.01500682f, -0.07582469f, 0.00231674f, -0.00733728f, 
    0.05363806f, 0.03460340f, 0.05542153f, 0.18415403f, -0.33390746f, -0.03921911f, -0.02770398f, 0.22836319f, 
    0.10446698f, -0.03691369f, -0.11357612f, -0.13989536f, 0.12183412f, 0.03967854f, 0.00531251f, 0.01483374f, 
    0.16189931f, -0.02765227f, 0.02678541f, -0.04496105f, -0.07846341f, 0.01326938f, 0.02550142f, -0.07967916f, 
    0.11412230f, 0.06655008f, -0.17542136f, -0.08158816f, 0.11200342f, -0.15711518f, -0.21135934f, -0.29637641f, 
    0.12277620f, -0.09337017f, 0.10806604f, 0.02528261f, -0.09771375f, 0.04112456f, -0.09910256f, -0.12934358f, 
    0.01099727f, 0.14749713f, 0.02540297f, -0.26649299f, -0.03191544f, 0.05509838f, 0.00713207f, -0.01600540f, 
    0.13120066f, 0.06194076f, 0.13313153f, -0.02896413f, -0.39809117f, 0.13043359f, -0.16993749f, -0.10830934f, 
    -0.01450083f, -0.04339227f, 0.09938704f, -0.07780761f, 0.08644046f, 0.10326743f, 0.01685661f, 0.18329681f, 
    0.05478354f, 0.20308752f, -0.12409346f, 0.10564574f, 0.07901909f, 0.01324571f, -0.12588389f, 0.03122724f, 
    -0.11484512f, 0.11017592f, 0.11353598f, 0.06246816f, -0.17099093f, 0.17851460f, -0.27104580f, 0.24848431f, 
    -0.07159612f, -0.05090325f, 0.01463515f, 0.06297123f, 0.01638755f, 0.00393685f, -0.12302446f, 0.05007811f, 
    0.36832693f, 0.37868798f, 0.01234505f, -0.14101072f, -0.18673526f, -0.03437778f, -0.02507954f, 0.06651438f, 
    -0.11865405f, 0.13356455f, -0.14251631f, 0.05071938f, -0.10514116f, 0.25489384f, -0.01040579f, 0.03758071f, 
    0.03913932f, 0.10077062f, 0.08967221f, 0.10666919f, 0.04208647f, 0.05709132f, 0.04288289f, 0.04554769f, 
    -0.05011196f, 0.03487676f, 0.34161833f, 0.15080094f, -0.09104624f, 0.01842057f, -0.30373684f, 0.21854493f, 
    0.13379364f, -0.07396302f, 0.03151604f, -0.12074447f, 0.06246829f, 0.16040567f, -0.04285669f, -0.02391386f, 
    0.00454592f, -0.28746367f, 0.10317308f, 0.06561241f, -0.01709658f, 0.02977436f, -0.08147432f, -0.12029002f, 
    -0.27814001f, -0.23055764f, -0.27295855f, 0.19905807f, -0.02490372f, 0.11208463f, -0.04658718f, -0.00799531f, 
    -0.03609009f, 0.13170926f, 0.03983872f, -0.05810018f, 0.27142099f, 0.04970413f, 0.21058875f, -0.19024347f, 
    -0.06388211f, 0.05001725f, 0.07180624f, 0.03691569f, -0.06218756f, 0.09252372f, -0.06265327f, -0.16012885f, 
    -0.23753254f, 0.23556173f, -0.39657503f, 0.03563414f, 0.03507647f, 0.06241002f, 0.02927997f, -0.13968077f, 
    -0.10260552f, 0.14409816f, 0.15071458f, 0.08996251f, -0.28328925f, 0.25082693f, -0.03832984f, 0.04392831f, 
    -0.02149032f, 0.08204990f, 0.00243235f, -0.17367072f, 0.01997471f, 0.07059044f, 0.01862362f, 0.17487581f, 
    0.15101364f, 0.01277779f, -0.02139515f, 0.37269381f, -0.02337830f, 0.01578414f, 0.03000025f, -0.09746048f, 
    0.12229618f, 0.04160091f, -0.03139846f, 0.06900603f, -0.09505209f, -0.08368466f, -0.09642336f, -0.07146343f, 
    -0.12051910f, 0.03916705f, 0.05866256f, 0.03058835f, -0.11050546f, 0.05036838f, -0.27880409f, 0.04342616f, 
    -0.16513719f, 0.09137646f, 0.35759825f, 0.19664724f, -0.12339619f, -0.05473089f, 0.02839638f, 0.00415572f, 
    0.07437274f, 0.04571360f, 0.15180969f, -0.05432504f, -0.15475963f, 0.01266454f, 0.09191996f, 0.03338163f, 
    -0.01916604f, -0.09130481f, -0.06937629f, 0.04903280f, -0.12405041f, 0.06186692f, -0.02003109f, -0.15564692f, 
    0.13218547f, 0.05976615f, 0.23699182f, -0.13256016f, -0.15059575f, -0.07812972f, 0.10908413f, 0.07159806f, 
    0.06600904f, -0.08425400f, 0.20390259f, 0.05548190f, 0.03974092f, -0.09216801f, 0.26165405f, 0.12130869f, 
    0.04910441f, 0.11600543f, 0.13832292f, 0.08975206f, -0.22274293f, 0.08694726f, 0.02324264f, -0.01994560f, 
    -0.50105053f, 0.14432092f, -0.20197290f, 0.06001702f, -0.03433782f, 0.22088160f, 0.12361451f, 0.05255794f, 
    -0.07242557f, -0.09349658f, -0.02190586f, -0.12087907f, 0.14332043f, 0.32849151f, -0.26412264f, -0.01750944f, 
    -0.13387388f, 0.14272779f, 0.01098936f, -0.28681728f, -0.07885583f, -0.09342930f, -0.22395004f, -0.13770378f, 
    -0.18397081f, -0.15145861f, 0.23134093f, 0.04265172f, -0.07615073f, -0.03085008f, -0.26485708f, 0.12766303f, 
    0.11308916f, -0.16280080f, 0.05062805f, -0.11878836f, -0.01832040f, 0.32120740f, -0.07901105f, -0.04188094f, 
    0.12027793f, 0.01320606f, -0.01430757f, -0.00476318f, -0.02750889f, 0.01226720f, -0.11197061f, -0.01998078f, 
    -0.41129163f, 0.10372737f, 0.25082508f, 0.02907339f, -0.05422744f, 0.06025830f, 0.06425838f, -0.04491279f, 
    -0.21235733f, 0.06998564f, 0.03871099f, 0.19407494f, 0.12050636f, -0.56729078f, -0.02271577f, -0.03215456f, 
    0.00564054f, -0.15290137f, 0.03701790f, 0.05091946f, 0.03501306f, -0.02810424f, 0.08534075f, -0.03974978f, 
    -0.07040475f, -0.23132753f, -0.10459146f, 0.07836128f, -0.01031495f, -0.05711228f, -0.06535548f, 0.02679524f, 
    -0.01721351f, 0.10486931f, 0.10445118f, -0.04299102f, -0.01494638f, -0.18225165f, -0.14413057f, 0.01225289f, 
    -0.07819592f, 0.04789653f, -0.26429012f, -0.02231881f, -0.03063581f, 0.02678902f, 0.04129066f, -0.04485402f, 
    0.02053126f, -0.36337647f, 0.05598872f, 0.17250399f, -0.05883699f, 0.08305348f, 0.08687405f, -0.04315188f, 
    -0.23708689f, -0.11888907f, 0.08668126f, -0.01546994f, 0.09226920f, 0.05670121f, -0.03169346f, 0.04199644f, 
    0.05561211f, 0.05170285f, 0.05798694f, -0.08517386f, -0.01655058f, 0.09655104f, -0.01503534f, 0.13306163f, 
    -0.15450050f, 0.14586911f, -0.11764415f, 0.25925517f, 0.03031600f, -0.14062947f, 0.05993930f, 0.14006583f, 
    -0.15447846f, -0.00992807f, -0.07707129f, 0.01881741f, -0.25359932f, 0.00747424f, -0.03416911f, -0.14641447f, 
    0.06603633f, 0.12382783f, -0.13982986f, 0.03489219f, -0.15450273f, -0.00578632f, 0.00360641f, -0.23334683f, 
    -0.02842806f, -0.15828742f, 0.12946928f, 0.17328118f, -0.11026785f, -0.15953268f, 0.06186530f, 0.00011900f, 
    -0.22958849f, 0.03043741f, 0.00365935f, 0.05255071f, -0.23188107f, 0.10077717f, 0.18071337f, 0.14048198f, 
    0.04381742f, -0.03441355f, -0.12568742f, 0.07554711f, 0.05179518f, -0.04203498f, 0.06160804f, 0.05154510f, 
    -0.12636879f, 0.21404682f, 0.02409175f, -0.07197563f, -0.02046614f, -0.12355595f, -0.00193770f, 0.05856211f, 
    -0.06051559f, 0.06590775f, 0.14483719f, 0.00171456f, -0.12320375f, -0.00396048f, -0.36079028f, 0.00782984f, 
    0.03878662f, -0.12514549f, 0.04667319f, 0.01621891f, 0.01296735f, -0.06261346f, -0.31109250f, -0.52162224f, 
    0.25599879f, -0.04187823f, 0.26037583f, -0.05544369f, -0.08687665f, 0.19684768f, 0.04902850f, 0.10674988f, 
    0.11631328f, 0.06131974f, -0.03975494f, -0.11708961f, -0.22074611f, -0.14366670f, -0.05263837f, -0.16863008f, 
    -0.10969787f, 0.02870025f, 0.10540940f, 0.06148494f, -0.28409919f, 0.01811988f, 0.02619021f, 0.00420897f, 
    -0.14224663f, -0.23869093f, 0.00522921f, -0.12952322f, -0.02049193f, 0.01893809f, 0.05640305f, -0.09225342f, 
    0.09047969f, -0.09411837f, -0.15084837f, -0.04541674f, 0.31371531f, -0.21486688f, 0.44157138f, 0.14439362f, 
    -0.17627904f, 0.03247781f, 0.10942762f, -0.01486366f, -0.07839426f, 0.05656091f, 0.07893419f, 0.28320220f, 
    -0.09933155f, 0.21766293f, -0.23969889f, -0.05109644f, -0.04984453f, 0.00780151f, -0.11630819f, -0.08321358f, 
    0.02617240f, 0.02008364f, -0.18808082f, -0.14092542f, -0.06293306f, -0.10423616f, 0.02535183f, -0.01827071f, 
    -0.03990702f, 0.10715112f, -0.00840287f, 0.01504011f, 0.10107343f, -0.00890624f, 0.14852227f, 0.04231548f, 
    0.05654039f, 0.12837213f, 0.06991068f, -0.01338034f, -0.00360828f, -0.15435140f, 0.02886428f, 0.07797779f, 
    -0.14481497f, 0.11378661f, -0.04116823f, -0.09485960f, -0.55154091f, 0.06244614f, -0.57702607f, 0.14990810f, 
    -0.02432856f, 0.25463888f, -0.44878668f, 0.03283414f, 0.04031242f, 0.08982010f, 0.16837375f, 0.02206201f, 
    0.05185439f, -0.17876758f, 0.20217554f, 0.09961274f, -0.12135977f, -0.04159394f, 0.15529796f, 0.07486413f, 
    0.00789030f, -0.07206523f, -0.04449930f, 0.02865307f, -0.17201161f, -0.14303938f, -0.08141653f, 0.01177075f, 
    -0.09880947f, 0.07959793f, 0.03616615f, -0.29132482f, -0.31541023f, 0.09899073f, 0.08949175f, 0.04405522f, 
    -0.31655437f, 0.28938171f, -0.05710661f, 0.08287450f, -0.06679605f, 0.11863537f, 0.12707835f, -0.06205067f, 
    -0.06092987f, 0.12725630f, 0.01687565f, -0.04899497f, -0.27301833f, 0.09225724f, 0.01165105f, -0.04201111f, 
    0.01356948f, -0.02426297f, 0.05032845f, -0.01545494f, -0.05160306f, -0.02448947f, -0.05732764f, -0.13615657f, 
    -0.01046951f, -0.01989647f, -0.02518170f, -0.01164349f, -0.00300733f, -0.14567493f, 0.01242417f, -0.11334585f, 
    -0.05298025f, 0.04525182f, 0.10855848f, -0.16074003f, -0.11563152f, -0.18802178f, 0.20242043f, -0.04468653f, 
    0.03302567f, 0.05211713f, 0.09314098f, 0.03629095f, -0.07005159f, -0.00299846f, -0.01549756f, 0.05062811f, 
    -0.21638905f, 0.05540506f, 0.21727382f, -0.03020356f, -0.19101726f, 0.10391415f, 0.05951803f, 0.08530357f, 
    -0.00898530f, -0.03145086f, 0.07490975f, 0.05486288f, -0.46854630f, 0.11233868f, -0.04837425f, 0.07943602f, 
    -0.18961273f, 0.05681314f, -0.38765198f, 0.29038104f, 0.05091079f, -0.08056484f, 0.07648023f, 0.05885151f, 
    0.01151728f, 0.15991133f, 0.06962158f, 0.09583956f, 0.03162419f, -0.03832753f, 0.08574769f, 0.02667423f, 
    -0.06053803f, 0.06939600f, 0.09964599f, 0.06778860f, -0.13285348f, 0.19304790f, -0.13059339f, 0.02630955f, 
    -0.13948844f, -0.04574757f, -0.10931023f, -0.08804057f, 0.16270603f, 0.11447263f, -0.08259676f, 0.05255829f, 
    -0.01641304f, 0.15827319f, 0.00030558f, -0.08644959f, 0.01566801f, 0.02778260f, -0.03977665f, -0.02237475f, 
    0.15084095f, 0.00210889f, -0.02160032f, 0.03248494f, 0.01538051f, -0.15963291f, -0.11199026f, -0.16263659f, 
    -0.27708957f, -0.22328989f, -0.07009900f, -0.01033693f, -0.18919466f, 0.13834649f, -0.19584017f, -0.04573698f, 
    -0.15731244f, -0.12353602f, 0.31700489f, 0.15824081f, -0.13739648f, 0.17328016f, -0.10711508f, 0.25259936f, 
    -0.06530324f, -0.07646222f, 0.03291106f, 0.08187199f, -0.17325944f, 0.01464763f, 0.07708217f, 0.14723730f, 
    -0.06545430f, 0.24119399f, -0.34345591f, -0.13811222f, -0.04015707f, -0.19826588f, -0.00365952f, 0.09664627f, 
    0.08809648f, -0.16656303f, -0.15017632f, 0.04152464f, -0.08047985f, -0.00133420f, 0.00783995f, 0.13739580f, 
    -0.02525042f, 0.07510249f, 0.02322824f, -0.11952255f, -0.29574436f, -0.32508767f, -0.19254155f, -0.38538209f, 
    -0.16717644f, -0.14180219f, -0.14857784f, -0.03658855f, -0.10605814f, -0.03761885f, 0.03174435f, -0.01421771f, 
    -0.02745920f, 0.08138954f, -0.02125715f, 0.00724826f, -0.04252715f, 0.01790832f, 0.03455311f, 0.11286055f, 
    -0.16433786f, -0.39963120f, -0.47718832f, -0.47753483f, -0.07365188f, 0.31051099f, 0.13232602f, 0.10325763f, 
    -0.17653818f, 0.04173693f, 0.01950214f, 0.06240835f, -0.25855014f, 0.08118520f, 0.17564194f, -0.05670496f, 
    -0.08969440f, 0.06116773f, 0.02206822f, 0.16955605f, 0.08716809f, -0.13894619f, -0.24079692f, 0.16380484f, 
    -0.19996792f, -0.11762480f, -0.23825569f, -0.32817075f, -0.04134391f, -0.09907849f, 0.16921139f, 0.12417880f, 
    0.05594392f, -0.04319542f, 0.04962337f, 0.07939791f, 0.03571817f, -0.32610494f, -0.42076635f, -0.07719198f, 
    0.07113439f, 0.01723444f, -0.05665725f, -0.13674437f, -0.16716808f, -0.00053983f, 0.10361877f, -0.05715213f, 
    0.17398272f, -0.05645961f, 0.16127609f, 0.06366128f, 0.20043561f, 0.04515857f, -0.00343815f, 0.19301382f, 
    -0.03174577f, -0.08011666f, 0.16671558f, -0.10786793f, 0.10817147f, 0.13258626f, 0.00739808f, 0.17925768f, 
    -0.16647567f, -0.13383619f, -0.14177923f, -0.09997173f, 0.09469591f, -0.04914019f, -0.05550641f, 0.00112852f, 
    0.01606121f, 0.02443930f, -0.02939567f, 0.04005694f, -0.03556851f, 0.06879433f, -0.15071794f, 0.14957543f, 
    0.07799034f, 0.04381490f, -0.04086749f, -0.05127109f, 0.03955891f, 0.03145900f, -0.05185061f, -0.17327370f, 
    -0.30397570f, -0.06068046f, -0.04864664f, 0.09243798f, 0.01779398f, -0.05240079f, 0.07177263f, 0.01950009f, 
    -0.09020393f, -0.01690414f, -0.14880571f, 0.01014740f, -0.54384005f, -0.13171573f, -0.11074101f, 0.29800516f, 
    -0.04941058f, 0.02903069f, -0.10612219f, 0.06148752f, -0.04488795f, -0.02317610f, 0.13170230f, 0.02178737f, 
    -0.07222949f, -0.33479598f, 0.23117173f, -0.20257181f, -0.01947733f, 0.06488156f, 0.11951179f, -0.15632983f, 
    -0.06399579f, -0.11900493f, 0.03249377f, 0.04179669f, -0.09616501f, 0.00669311f, -0.18236081f, 0.00589967f, 
    -0.07315177f, -0.07318718f, 0.08627398f, 0.03467305f, -0.29167333f, -0.10244781f, 0.11747237f, 0.07657348f, 
    -0.54268825f, 0.16843663f, 0.02933740f, -0.17221594f, -0.02092301f, 0.00384611f, 0.11171342f, 0.07796275f, 
    -0.18192460f, -0.00114373f, -0.01622797f, 0.02786814f, 0.13045433f, 0.24245404f, -0.16228688f, -0.61993986f, 
    0.01636305f, -0.24740674f, 0.07353250f, -0.04796305f, 0.12469845f, 0.05309631f, 0.02928511f, -0.07178759f, 
    -0.48700142f, -0.29566371f, -0.44193614f, 0.31708908f, -0.09252106f, -0.13966134f, 0.06113540f, -0.18035568f, 
    0.01035826f, -0.03508604f, 0.00089130f, 0.12772246f, 0.13703506f, -0.25932607f, 0.23262206f, -0.04208155f, 
    0.10044185f, 0.03716885f, 0.07098719f, -0.08487478f, -0.00053754f, 0.00932532f, -0.02529644f, -0.09823579f, 
    -0.44975501f, 0.19206634f, -0.20132439f, 0.30543384f, 0.19798955f, -0.16213825f, 0.08041438f, -0.08349006f, 
    -0.05071909f, -0.11340700f, -0.10723594f, -0.07846816f, 0.08148800f, 0.03643671f, 0.16881402f, 0.16703936f, 
    0.25125080f, -0.06388056f, 0.20732492f, -0.06618886f, -0.00910418f, 0.05886635f, 0.03279050f, -0.06318328f, 
    -0.29269695f, 0.12818335f, 0.13280241f, 0.04091430f, -0.11909255f, 0.01426968f, -0.07873212f, 0.13128497f, 
    -0.19642435f, 0.08288651f, -0.02032534f, -0.13876230f, 0.02083672f, -0.03306041f, 0.04312341f, 0.04480118f, 
    0.01801798f, -0.09855191f, 0.03116410f, -0.03530622f, 0.03958195f, 0.03289950f, 0.07050086f, 0.00564835f, 
    -0.24016924f, 0.23901333f, -0.05983059f, -0.14747865f, -0.02661379f, -0.01124643f, -0.03368500f, 0.15608867f, 
    -0.02571595f, -0.03388399f, -0.01384583f, -0.20503962f, -0.09981305f, 0.03823807f, -0.01809918f, 0.00329703f, 
    0.01061240f, 0.08752453f, 0.04914872f, -0.08379143f, -0.01889458f, -0.10602630f, -0.02589649f, -0.12332101f, 
    -0.11749578f, -0.01893758f, 0.10051347f, 0.01396680f, 0.07901724f, 0.01170707f, -0.14101881f, 0.02805133f, 
    -0.09836856f, 0.13319531f, 0.08261184f, -0.00302011f, 0.09676722f, -0.28879154f, 0.44693476f, -0.40158853f, 
    -0.10217103f, 0.07329822f, -0.12433129f, 0.19851184f, -0.10029614f, 0.02262401f, -0.08143923f, -0.09322678f, 
    -0.34657389f, 0.12453819f, -0.28694001f, 0.10538203f, 0.11121772f, -0.19805281f, 0.11859750f, -0.06506734f, 
    0.08673237f, -0.00711369f, 0.22404021f, 0.07232626f, 0.54463565f, -0.32540479f, 0.36040103f, 0.25753859f, 
    -0.10330461f, -0.23366810f, -0.08729713f, 0.05237955f, -0.06748674f, 0.10795406f, -0.01304646f, 0.06488664f, 
    0.09381468f, 0.13211861f, -0.12038261f, 0.05436925f, -0.07517443f, 0.03425035f, -0.04388524f, 0.02728008f, 
    0.01533638f, -0.00437495f, -0.03023788f, 0.05825252f, -0.62164563f, 0.30019292f, -0.57554340f, 0.21462151f, 
    0.15048967f, -0.02062952f, 0.00242858f, -0.09383485f, -0.08039396f, -0.04335565f, 0.16394247f, 0.21316233f, 
    -0.08395227f, 0.06294577f, -0.10330762f, 0.18237048f, 0.12437943f, 0.14136294f, 0.09185112f, -0.17398025f, 
    0.03550268f, 0.17115781f, 0.05202790f, 0.02642219f, -0.33526242f, -0.03757374f, 0.01982280f, 0.27939308f, 
    -0.15067710f, -0.01836963f, 0.08739908f, -0.11416791f, 0.02753297f, 0.08596148f, -0.03355051f, -0.10304588f, 
    -0.24970761f, 0.04726562f, -0.29808861f, 0.01202184f, -0.16398945f, -0.06963018f, 0.09794878f, -0.24542218f, 
    -0.04955509f, 0.07998626f, -0.11185641f, -0.07731728f, 0.14171982f, -0.06300005f, 0.09264193f, -0.18884102f, 
    -0.19562846f, -0.14323063f, 0.00382043f, -0.03539087f, -0.00484832f, 0.00788902f, 0.01999308f, -0.03729568f, 
    0.31627315f, -0.01963712f, 0.45216444f, -0.03222073f, -0.01856692f, -0.02173561f, -0.10421576f, 0.09359385f, 
    -0.16642711f, 0.04279678f, 0.00799990f, -0.01363924f, 0.00870697f, 0.13463327f, -0.11291236f, -0.05794407f, 
    -0.14677817f, 0.05317084f, -0.02613777f, 0.04602114f, -0.06222980f, -0.13984428f, 0.05080116f, -0.06693128f, 
    0.03254917f, -0.21063422f, 0.32445005f, 0.12699997f, -0.09713224f, 0.03482125f, -0.21567701f, 0.00910017f, 
    0.01815250f, -0.14012857f, 0.01829733f, 0.16465420f, -0.10884670f, 0.01695787f, -0.17319019f, 0.11106555f, 
    -0.32455117f, -0.07907583f, -0.01006051f, -0.06096563f, 0.03775353f, -0.02353546f, -0.13690488f, 0.03442854f, 
    0.12955104f, 0.18387128f, 0.09525356f, 0.10189642f, -0.12390574f, 0.11941625f, 0.02308117f, -0.11807895f, 
    -0.18628070f, -0.08684635f, 0.16016975f, -0.08963348f, 0.22747728f, 0.01941702f, 0.31491560f, 0.00015670f, 
    -0.02358088f, -0.10445760f, 0.11449112f, 0.06920453f, 0.02597973f, -0.04505115f, 0.03249189f, 0.06717329f, 
    0.10935923f, -0.17011972f, 0.40423888f, 0.12700872f, 0.04881323f, -0.02638104f, -0.06363143f, -0.04803864f, 
    -0.18095168f, 0.08100403f, -0.13519897f, 0.00695526f, -0.08952395f, 0.23570839f, -0.04399437f, -0.27308416f, 
    -0.02984298f, -0.12308840f, -0.07068353f, 0.00011741f, -0.05369042f, 0.10821844f, 0.14233077f, 0.10357964f, 
    0.03547340f, -0.24060439f, 0.09727550f, -0.14293000f, -0.15340129f, -0.02228002f, 0.01443121f, 0.05203670f, 
    -0.00163923f, 0.00930244f, -0.08158336f, 0.08444822f, 0.43160605f, 0.06076875f, 0.17974012f, -0.06604590f, 
    0.07326782f, 0.10977916f, 0.05814667f, 0.14620407f, -0.09128467f, 0.03741289f, 0.06917503f, 0.10217145f, 
    -0.35881451f, 0.23407796f, -0.08493529f, -0.21326175f, -0.08579377f, 0.01042857f, 0.18722899f, -0.15914032f, 
    0.04577150f, 0.00352971f, 0.05389811f, 0.05491175f, -0.06241655f, 0.08988620f, 0.08409651f, -0.06947621f, 
    0.08154625f, 0.07665952f, 0.03315724f, -0.30061027f, -0.05413739f, -0.03784259f, 0.02295598f, -0.01291982f, 
    -0.04269079f, -0.00951867f, 0.03449555f, 0.13015687f, -0.01262089f, 0.03249870f, -0.03343590f, 0.01073446f, 
    0.01537353f, 0.05285785f, 0.12176505f, 0.11423974f, 0.20484294f, 0.06127681f, 0.09314948f, 0.00464002f, 
    0.04542092f, -0.05850707f, -0.05897525f, 0.07640831f, -0.04045461f, -0.05988865f, -0.06965035f, -0.11538520f, 
    -0.26076111f, 0.06309509f, -0.00232037f, -0.18262351f, 0.00026675f, -0.19334897f, 0.10875547f, -0.15790556f, 
    -0.00927371f, -0.00214631f, -0.12627248f, -0.12165013f, -0.20711623f, -0.46203369f, 0.09577562f, 0.09649425f, 
    -0.12574184f, -0.02972918f, -0.25688079f, 0.01569899f, -0.03832320f, 0.09020957f, 0.01617483f, -0.09650584f, 
    0.02726645f, -0.46626914f, 0.15865269f, -0.07194307f, -0.11008348f, 0.08838101f, 0.02575956f, 0.14536022f, 
    -0.20443021f, -0.08758423f, 0.10839900f, -0.03243496f, -0.45682216f, -0.05745873f, -0.01110513f, 0.24411692f, 
    -0.07004471f, -0.01220908f, 0.04577421f, -0.21098265f, -0.01365086f, -0.10289818f, -0.02266258f, 0.10978680f, 
    0.33462727f, -0.25639805f, 0.18137811f, 0.08131842f, -0.01272652f, -0.14346379f, -0.13548720f, 0.03688727f, 
    0.00563998f, 0.09227265f, 0.00538440f, -0.02355868f, -0.09646501f, -0.19678457f, -0.41675481f, -0.10024016f, 
    0.11369856f, -0.17127421f, -0.06396619f, -0.05697454f, 0.04532846f, 0.09035950f, 0.22141023f, 0.14840469f, 
    0.32107204f, 0.13500893f, 0.14632373f, 0.02380052f, 0.01922989f, 0.03518613f, -0.23420933f, 0.07710148f, 
    -0.00976026f, -0.04823054f, -0.11022373f, 0.09275901f, -0.10173267f, -0.38822418f, 0.18154186f, -0.17681149f, 
    0.00221728f, -0.04837180f, -0.04683262f, 0.22313924f, 0.03201021f, 0.03301593f, 0.05155997f, 0.13856597f, 
    0.13273147f, -0.05701632f, -0.20008996f, -0.03992498f, 0.01466217f, 0.02400048f, -0.04933546f, 0.15542331f, 
    -0.00543668f, 0.13975994f, 0.21031065f, -0.18429710f, 0.19663543f, 0.31391659f, -0.15929417f, -0.11826539f, 
    -0.04070963f, -0.09333976f, 0.13097124f, 0.30290025f, -0.07177284f, -0.04265979f, -0.08924288f, -0.10222414f, 
    0.15132955f, -0.17181531f, 0.20467085f, 0.23000884f, 0.01995827f, 0.07628528f, -0.01921917f, 0.03276487f, 
    -0.10085935f, 0.03851122f, 0.17033035f, 0.03475937f, -0.07659849f, 0.23530026f, 0.34203574f, 0.19674365f, 
    0.11432117f, 0.18280244f, 0.12754102f, -0.05681263f, 0.01397915f, -0.00069539f, 0.17579478f, 0.19756509f, 
    -0.01949402f, -0.17725362f, -0.13021716f, 0.03597504f, 0.10706854f, -0.19413576f, -0.07009394f, 0.05616340f, 
    0.08601783f, 0.11628146f, 0.13193811f, 0.02023153f, 0.36301896f, -0.08665922f, 0.33094057f, -0.26965249f, 
    -0.00333017f, 0.05129801f, 0.01238463f, 0.00565002f, -0.07516895f, 0.02674723f, 0.09604213f, 0.01014652f, 
    -0.04771280f, -0.27751172f, 0.52105051f, 0.00237192f, 0.11884601f, -0.06152616f, 0.08988688f, -0.00187869f, 
    0.07260940f, -0.02694548f, 0.10791496f, 0.21560010f, -0.54269242f, 0.17954941f, -0.28678632f, 0.11209928f, 
    -0.10150275f, 0.26058984f, 0.03865179f, -0.09792653f, 0.00922544f, 0.04898449f, 0.04830946f, 0.05197354f, 
    -0.01885977f, -0.05147291f, -0.05165180f, -0.27785814f, -0.16408119f, 0.03177889f, -0.03357995f, -0.18962874f, 
    0.02164639f, 0.04709974f, 0.03863598f, -0.12336250f, 0.22726466f, 0.12324530f, -0.01522275f, -0.12500292f, 
    -0.03962437f, -0.12626882f, 0.03920726f, 0.12157214f, -0.04293145f, 0.03401903f, -0.05291114f, -0.15439257f, 
    -0.12611781f, -0.03332976f, -0.02993453f, -0.09108829f, 0.02910006f, 0.01793940f, 0.01970558f, -0.03704907f, 
    0.10573453f, 0.08748513f, 0.13581292f, 0.11364376f, 0.11676204f, -0.09795200f, 0.09713165f, 0.08567321f, 
    0.19190130f, 0.01441763f, -0.07369608f, 0.04016981f, 0.04648820f, -0.12602054f, -0.02248137f, 0.14909022f, 
    -0.42101273f, 0.16423713f, -0.09518762f, -0.02180405f, -0.06006431f, 0.09033723f, 0.11949013f, 0.17365210f, 
    -0.17478496f, 0.06325070f, 0.12595783f, -0.01594162f, -0.20380871f, -0.05070665f, 0.27034754f, -0.15205546f, 
    -0.06662619f, 0.05617840f, -0.14242753f, 0.04307695f, -0.04101306f, 0.08914500f, 0.16274522f, 0.08483019f, 
    -0.06515567f, -0.12234269f, -0.07381933f, -0.11428075f, 0.06394904f, 0.00407311f, -0.12883528f, -0.02886511f, 
    -0.20803955f, -0.07604494f, -0.21905875f, -0.22031054f, 0.04875296f, 0.05747658f, 0.26294300f, -0.00992930f, 
    0.01285089f, -0.07760745f, -0.17171903f, 0.12477121f, -0.22082478f, -0.02903707f, -0.02509688f, -0.01295606f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14872551f, 0.08296315f, 0.06896470f, -0.12254608f, -0.05695678f, 0.04518535f, 0.00981841f, -0.14584358f, 
    0.01731070f, 0.00540395f, -0.00233057f, 0.01957711f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
