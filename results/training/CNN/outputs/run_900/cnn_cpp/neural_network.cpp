#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.42225993f, 0.66036326f, -1.62161696f, -0.48779568f, 0.76872033f, -0.00690407f, 0.59472734f, -0.54430509f, 
    0.10907857f, -0.51152015f, -0.74665970f, -1.14732349f, 0.41626400f, -0.08399360f, -0.78801012f, -0.45906743f, 
    0.64013469f, 0.64886409f, -0.04236317f, 0.80530041f, -0.01289696f, -1.13508916f, -0.01182001f, -0.92596340f, 
    -0.06591300f, 0.44824693f, -0.56277990f, -0.93706143f, 0.89800400f, 0.79420495f, -1.14286673f, 0.10034800f, 
    0.89579165f, -0.41683349f, 0.21871433f, 0.54736489f, 1.19596088f, -1.43383324f, 0.41867828f, -1.12389362f, 
    -0.19007707f, 0.33017007f, -0.00457792f, 0.62542427f, 0.37360194f, -1.09791160f, -1.24418545f, -0.84005922f, 
    0.39647546f, 0.60077703f, 0.03302501f, 0.53746998f, -0.72195190f, -0.06466295f, -1.13463712f, 0.07282122f, 
    -0.32142925f, 0.07965381f, 1.09979796f, -0.42376745f, 0.57856447f, 0.18539065f, 0.73861706f, 1.11656916f, 
    0.47744066f, 0.69233352f, -0.50852919f, 1.22204208f, -0.39239112f, 0.30035278f, -0.01658486f, -0.06758066f, 
    -0.96189564f, -0.94075453f, -0.91950744f, -0.79882377f, 0.34889209f, 1.13822103f, 0.04382257f, 0.12527519f, 
    0.59441763f, 0.48940989f, -1.07405853f, -0.76638657f, 0.81395996f, 1.09283102f, -0.18486503f, -0.48406288f, 
    -0.42979926f, -0.44310203f, 1.02467430f, 0.98485518f, -0.12950829f, 0.85236859f, 0.60700876f, -0.07108096f, 
    -0.21143936f, 0.81162453f, 0.00333208f, 0.10534844f, -1.10748863f, 0.20304090f, -0.95985764f, 0.06504946f, 
    -0.89506358f, -0.84245783f, -0.58859688f, -0.75339937f, 0.69756216f, 0.59978312f, 0.62864041f, -0.93967593f, 
    -0.82255918f, -0.77426666f, -0.48841622f, -0.86602873f, 0.03440315f, 0.42681655f, 0.18880133f, 0.61566138f, 
    -1.02906191f, -0.98369139f, -0.31103086f, -0.08377182f, 0.70747834f, 0.32493883f, 0.93230921f, -1.11066818f, 
    -1.32450128f, 0.07745115f, -0.57569057f, -0.58655626f, -0.08352026f, -0.08272959f, 0.09366145f, -1.09879649f, 
    0.50875127f, -0.55991340f, 0.18718237f, 1.45803761f, 0.81448841f, -0.36403015f, -0.46064809f, -0.60351205f, 
    0.42439389f, 1.08959210f, 1.08462524f, 0.07544966f, -0.51833075f, -0.45398793f, 0.15684398f, -0.52621704f, 
    0.03532991f, 0.88577688f, 0.67015493f, 1.20507431f, 1.18829894f, 0.55805051f, -0.62263775f, 0.20958138f, 
    0.71472067f, -0.20717750f, 0.94352704f, 0.93579501f, 1.23378968f, -0.79823351f, 0.37180617f, -0.34041995f, 
    0.25160906f, 0.24604967f, 0.44376230f, -1.30202568f, 0.30716273f, 0.67962426f, 0.26990348f, -0.86261886f, 
    -1.03535962f, -0.08742053f, 0.17867506f, 0.85529852f, 0.38342518f, -0.00102937f, -0.23022209f, -1.61047482f, 
    0.26502922f, -0.95882273f, 0.45136085f, 0.43825346f, 0.42212844f, 0.88842702f, 0.37336645f, 1.24370492f, 
    0.57673967f, 0.03432231f, 0.22438626f, 0.33804202f, -0.59141898f, -0.48963451f, -0.57234603f, -1.23457551f, 
    -0.99467373f, 0.42406380f, 0.53227472f, 1.19511473f, 0.07141313f, -0.31695732f, -0.42938283f, -0.24230601f, 
    0.43292478f, 0.37990525f, 0.86315089f, -0.28249606f, -1.19914758f, -0.63237989f, -0.42354441f, -0.20852271f, 
    1.16882181f, -0.77846915f, 0.69101173f, 1.01037359f, -0.71737814f, -0.06430697f, -0.16848502f, 0.04739425f, 
    0.77744758f, -1.16211450f, 0.02027385f, 0.87413031f, -0.43021590f, 0.73280543f, -1.05970073f, -0.08423506f, 
    -0.10077839f, -0.55440503f, 1.26394391f, 0.71112561f, 0.70635605f, -0.23134129f, -1.13243377f, 0.78521585f, 
    -0.32397792f, 0.42932150f, -0.53980279f, -0.97765189f, 0.87300986f, -0.51957893f, 0.96862072f, -0.30496410f, 
    -0.62379909f, -0.33218300f, 0.23935910f, -0.61035043f, 0.25615475f, 0.47134063f, 1.04562664f, 0.57020485f, 
    -0.89239615f, 0.31300393f, 0.28900316f, 0.15881762f, 0.63407236f, -1.20624423f, -0.67754483f, -1.06915975f, 
    0.30152899f, -0.84769481f, 0.24752459f, -0.01805818f, 0.14952217f, 0.25773022f, 0.69191802f, 0.32720447f, 
    0.18153234f, -0.77217072f, -1.40541565f, -1.05060124f, 0.06785496f, -0.12173477f, 0.25808334f, -0.56205833f, 
    -1.04696476f, -0.55650067f, -0.91746062f, 0.71167195f, -0.02118788f, 0.53346539f, 1.02646148f, 0.34463811f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22042644f, 0.33887216f, -0.02331698f, -0.08534753f, -0.21037038f, -0.11898534f, -0.00122450f, 0.15687501f, 
    -0.08836799f, -0.09059657f, 0.13911727f, -0.01277802f, 0.20333102f, 0.12790263f, 0.36393040f, -0.11080606f, 
    -0.09889320f, 0.12137446f, 0.32248190f, 0.02408155f, -0.06388578f, 0.06919172f, 0.04609184f, -0.27606750f, 
    -0.21710473f, -0.03348204f, 0.03898462f, -0.17540228f, -0.12505406f, 0.07219195f, 0.06192553f, 0.10765910f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.22893733f, -0.09542521f, -0.09233189f, 0.06976073f, 0.05433126f, 0.07210368f, 0.05337771f, 0.02471024f, 
    -0.15186411f, 0.06662229f, -0.22281393f, -0.16171834f, -0.07502767f, -0.18678258f, -0.03578393f, 0.03478888f, 
    0.11317694f, -0.01959816f, 0.02745941f, -0.13130951f, -0.24090777f, -0.14893071f, -0.13283382f, 0.19710958f, 
    0.09948327f, 0.09312283f, -0.04720372f, -0.12756890f, 0.34509757f, -0.40291193f, 0.00955827f, 0.11890773f, 
    -0.06359479f, 0.15288872f, 0.09279620f, 0.22720788f, -0.32223520f, 0.15188015f, 0.05555865f, 0.01035800f, 
    0.02366424f, 0.05177573f, 0.17408015f, -0.18263640f, 0.06264249f, 0.06192290f, 0.11007342f, -0.15555947f, 
    -0.13802660f, 0.02359846f, 0.00283448f, 0.22227208f, 0.24752043f, 0.06415289f, 0.20383379f, 0.06486469f, 
    0.01024912f, -0.07523477f, 0.06232918f, 0.24105389f, 0.25220153f, -0.01957410f, -0.01867643f, 0.17314418f, 
    -0.22998422f, -0.03748943f, -0.01130823f, 0.07651512f, 0.07010996f, 0.11599161f, 0.14630851f, -0.04172473f, 
    0.24982935f, 0.01304188f, 0.22731444f, 0.00969410f, -0.32479060f, 0.04644990f, 0.14748253f, 0.05936787f, 
    0.07589089f, -0.00947499f, -0.11644668f, 0.32154784f, -0.04764809f, 0.28645608f, -0.17231084f, -0.01667670f, 
    0.06323060f, -0.25147918f, -0.07863907f, -0.20383470f, 0.19190001f, 0.11773390f, -0.00156214f, 0.17996536f, 
    -0.06565440f, 0.04135381f, 0.09688221f, -0.16802755f, -0.34009778f, 0.11580522f, -0.03635022f, 0.03612739f, 
    0.23445693f, -0.13258916f, -0.01708271f, 0.03609996f, 0.18396214f, -0.54511958f, -0.00323965f, 0.12694848f, 
    0.08682701f, 0.20541100f, -0.32926667f, -0.09314744f, 0.04835999f, 0.08932208f, -0.08520661f, -0.16121288f, 
    -0.08149537f, 0.13363045f, 0.08715117f, -0.03114114f, -0.00137077f, 0.05039812f, -0.07401614f, 0.10053275f, 
    0.41051471f, -0.19589821f, 0.10732182f, -0.09546568f, -0.02383259f, -0.06750020f, -0.05379120f, 0.21024013f, 
    0.14162268f, 0.04028108f, -0.17481707f, 0.06006232f, 0.11492606f, 0.12909512f, 0.02535670f, 0.02924788f, 
    -0.31266096f, -0.12883927f, -0.04263333f, 0.20962426f, 0.05402964f, 0.11840390f, -0.15393513f, -0.11983741f, 
    -0.13248314f, -0.47926068f, -0.10309955f, 0.08163656f, -0.00459056f, 0.11728702f, 0.07707810f, -0.23138368f, 
    0.03067976f, 0.13074754f, 0.16606976f, -0.09997600f, -0.18009108f, -0.05601684f, 0.12060682f, 0.10539978f, 
    0.08859050f, 0.02483571f, 0.10704187f, -0.40164888f, 0.07683150f, -0.13692503f, 0.04545981f, 0.13152553f, 
    -0.20084071f, 0.15363322f, -0.20242783f, 0.22786474f, 0.09962045f, -0.25260574f, -0.23242763f, -0.25842509f, 
    0.04170965f, 0.14189403f, 0.06307143f, -0.13541727f, -0.08495270f, -0.22053471f, 0.03293904f, 0.13745087f, 
    0.18480054f, 0.16664824f, 0.06642022f, -0.27329990f, 0.00368288f, -0.06238792f, 0.34854925f, 0.18830474f, 
    0.04921685f, -0.20116223f, 0.06517670f, -0.11333261f, 0.09875534f, 0.16740668f, -0.00064508f, -0.59890765f, 
    -0.34343129f, -0.10700830f, 0.03349551f, 0.12903133f, 0.17108390f, -0.17865668f, -0.04966795f, -0.13308328f, 
    -0.11523931f, 0.04774101f, 0.01568125f, 0.14887273f, -0.10534511f, 0.06452698f, 0.08184148f, -0.09392524f, 
    0.05028690f, -0.28175938f, -0.10239802f, -0.20554709f, 0.09953732f, 0.17010373f, 0.07783058f, 0.10219673f, 
    0.10665991f, 0.02103328f, -0.26034221f, -0.32997283f, -0.20692356f, -0.00581048f, -0.02451159f, 0.07825498f, 
    0.02168512f, -0.09607572f, 0.05497224f, -0.20157751f, -0.27235246f, -0.33779278f, 0.05681299f, 0.09854968f, 
    -0.06514884f, 0.22480071f, -0.19549166f, -0.11353198f, -0.15832056f, 0.16421120f, 0.01504251f, 0.14182423f, 
    -0.11321671f, -0.13501443f, 0.20727874f, -0.03151011f, 0.04621608f, -0.18501993f, -0.13608877f, -0.15211055f, 
    -0.00326355f, -0.03219906f, 0.04936968f, 0.01917280f, 0.24639504f, 0.06423754f, 0.27303490f, -0.48204330f, 
    -0.06394754f, 0.04709909f, 0.14981684f, 0.10078185f, -0.02655389f, -0.02297973f, 0.06925623f, 0.12678479f, 
    -0.18513101f, -0.03973468f, -0.04362396f, -0.03025897f, 0.10131071f, 0.21696550f, 0.07189165f, -0.07699452f, 
    0.02283580f, -0.04570313f, -0.02396375f, 0.04215577f, -0.04429022f, 0.00609531f, 0.00470063f, -0.03691640f, 
    -0.06011262f, 0.01641486f, -0.02094164f, 0.04234360f, -0.05022031f, 0.04323934f, -0.03325823f, 0.04841524f, 
    -0.04288225f, -0.04889132f, 0.05259983f, 0.02451212f, 0.01251134f, -0.05752358f, -0.01577545f, -0.04921241f, 
    0.05039940f, -0.00232648f, -0.02634577f, -0.00529547f, -0.03558854f, 0.02149499f, 0.02908071f, -0.06163481f, 
    -0.04310943f, -0.04955817f, -0.00283679f, 0.03855662f, -0.05424457f, 0.01365060f, -0.04853685f, 0.03458495f, 
    -0.02677383f, -0.04848080f, -0.01787777f, 0.00301062f, -0.00005600f, -0.05982082f, -0.05901130f, -0.04076374f, 
    -0.01195473f, 0.00481347f, -0.01464617f, -0.01454706f, -0.06236222f, 0.04914578f, -0.04601639f, -0.01062297f, 
    0.00428732f, 0.03475243f, 0.01686108f, -0.01291093f, -0.01942500f, -0.01314354f, 0.00502719f, -0.02322698f, 
    -0.01364218f, 0.01520809f, -0.04567303f, -0.03898332f, 0.02461137f, 0.00283893f, -0.05851086f, 0.01808723f, 
    0.02047774f, -0.06350104f, -0.06026989f, -0.01665680f, -0.02204652f, -0.06180411f, -0.00195973f, -0.02740602f, 
    0.03500097f, -0.01028481f, -0.04985774f, -0.02195535f, -0.03254717f, -0.04451624f, -0.04208918f, 0.03433293f, 
    -0.03369216f, -0.03393123f, 0.05157196f, 0.00904087f, -0.03638352f, 0.01290976f, -0.03928243f, -0.02478646f, 
    -0.03980748f, 0.00884233f, -0.05025779f, 0.04546440f, -0.04765506f, 0.05124778f, 0.03886994f, 0.01991012f, 
    -0.03778805f, 0.03529269f, -0.01612462f, -0.01403408f, -0.06263861f, -0.03832986f, -0.05387885f, 0.00045499f, 
    -0.04580098f, 0.01431109f, -0.01425260f, -0.00217815f, -0.03954770f, -0.03001808f, -0.06158061f, 0.04543128f, 
    0.01492761f, -0.06257284f, 0.03942221f, -0.02879702f, 0.03942360f, -0.05917703f, 0.02384814f, -0.05354943f, 
    0.02904854f, -0.00499463f, 0.01077878f, -0.01049670f, -0.02984926f, 0.02371267f, -0.06110604f, -0.06689920f, 
    -0.05139157f, -0.04365084f, -0.01384040f, -0.05521378f, 0.01397452f, 0.02140839f, 0.01474422f, -0.05071067f, 
    -0.00663275f, -0.04657815f, -0.05388935f, 0.02141410f, -0.00208717f, -0.00228050f, -0.03292250f, -0.06220371f, 
    -0.05576103f, 0.01167718f, 0.01617956f, 0.00680180f, -0.06268699f, 0.01708397f, 0.04326870f, -0.00420363f, 
    -0.02925887f, -0.06219598f, -0.00185925f, -0.02505356f, 0.00431229f, -0.01184141f, -0.02559581f, -0.02046717f, 
    -0.04688182f, -0.00214665f, 0.01231340f, -0.06606402f, -0.04067820f, 0.04123728f, 0.02061649f, -0.03452844f, 
    0.00031722f, -0.05990756f, -0.00047005f, -0.00851738f, -0.02155564f, 0.00824847f, 0.00105639f, -0.02287100f, 
    -0.04940305f, 0.04955072f, 0.03975514f, -0.00708659f, 0.04751267f, -0.03471204f, 0.00222979f, 0.00003440f, 
    -0.02827151f, -0.04271748f, -0.02598291f, 0.01988856f, -0.02980985f, 0.04483365f, -0.06318785f, 0.02619463f, 
    0.02930949f, 0.01927029f, -0.05076041f, 0.04200272f, 0.04807189f, 0.03645623f, -0.02087365f, 0.02536998f, 
    0.00630161f, -0.04826626f, 0.00216717f, -0.00853458f, 0.04624692f, -0.00536134f, -0.03366787f, 0.03271636f, 
    0.04145515f, -0.03063927f, -0.00901639f, -0.06662153f, -0.04976692f, -0.01762495f, 0.02962394f, -0.03661288f, 
    -0.01040627f, -0.05207750f, -0.06515336f, -0.00879751f, -0.00004393f, 0.02791328f, -0.03624173f, -0.03932777f, 
    -0.01161515f, 0.00011882f, 0.01915165f, 0.01723506f, -0.04318969f, -0.05831382f, 0.01691909f, -0.04372740f, 
    0.01944472f, 0.02681855f, 0.02813621f, 0.01121585f, -0.03352281f, 0.03806543f, 0.03664175f, 0.01469337f, 
    0.00183834f, 0.03788638f, -0.03814914f, 0.02375370f, -0.06384899f, 0.00077280f, 0.03125192f, 0.04848507f, 
    -0.03948216f, -0.01879006f, 0.01493137f, 0.00117365f, -0.04206718f, 0.00436687f, -0.04934815f, 0.00128681f, 
    0.03843557f, 0.01883725f, 0.02453464f, 0.03591101f, -0.03973890f, 0.02725874f, -0.00624642f, -0.00129743f, 
    -0.00826905f, 0.04311372f, 0.01356504f, 0.00534702f, 0.04278140f, -0.00783496f, 0.03941983f, -0.05215430f, 
    0.03962879f, -0.01728136f, -0.06560082f, -0.05512913f, 0.00391366f, 0.01750692f, 0.03468306f, -0.02427267f, 
    -0.01021792f, -0.04302422f, 0.04526612f, 0.02995127f, -0.02663712f, 0.03291510f, -0.03494444f, 0.04340039f, 
    0.01794512f, 0.04169099f, -0.01387371f, 0.03812171f, 0.02103977f, -0.04471133f, 0.00341702f, 0.00925523f, 
    -0.03666622f, -0.06676899f, 0.03714880f, 0.01944662f, 0.00106172f, -0.03121594f, 0.02883556f, 0.00174823f, 
    0.01002934f, 0.00801528f, -0.04509828f, 0.00694331f, -0.04490797f, 0.00804216f, 0.00924471f, 0.03456693f, 
    0.01683633f, 0.00922451f, -0.00522177f, -0.01118615f, 0.00432860f, 0.04911041f, 0.05335491f, -0.05707018f, 
    0.03255132f, -0.02302963f, 0.01217327f, -0.03761228f, 0.03277821f, -0.00919114f, -0.03183541f, -0.01550247f, 
    -0.01021756f, -0.06136320f, 0.01274266f, 0.00298206f, -0.00551176f, -0.00564412f, -0.05541598f, 0.04122558f, 
    -0.04130806f, 0.02339799f, 0.00046137f, -0.02084438f, -0.03161873f, 0.05086001f, -0.01607068f, 0.01441729f, 
    0.04195077f, -0.01267930f, -0.03672458f, 0.04799780f, 0.05050032f, -0.04289988f, -0.04516493f, -0.00683049f, 
    -0.05728856f, 0.02164800f, -0.04291777f, -0.05007647f, 0.01003154f, 0.02112962f, -0.01100139f, -0.05241868f, 
    -0.05280253f, -0.02387139f, -0.07310477f, -0.01641622f, 0.05942375f, -0.05306468f, 0.00765645f, -0.05458375f, 
    0.04293322f, 0.04122918f, 0.02241588f, 0.01006267f, 0.04304720f, -0.00518992f, 0.03253543f, -0.04692339f, 
    -0.05390399f, 0.03458023f, -0.06012744f, 0.04062499f, 0.01404737f, -0.03598591f, -0.01304971f, -0.04271659f, 
    0.02867180f, -0.01018583f, 0.00564339f, 0.04833348f, -0.06019759f, -0.02371764f, 0.00570141f, -0.03872640f, 
    0.04286006f, 0.04446123f, -0.03500267f, -0.04324721f, 0.04467280f, 0.02481033f, -0.03437801f, 0.03358104f, 
    0.02728963f, 0.03758923f, -0.05801092f, -0.03441366f, -0.03753623f, -0.05308405f, 0.00336547f, -0.01563131f, 
    0.03365454f, 0.04262620f, -0.01985860f, -0.06692933f, -0.05904560f, 0.01524425f, 0.01674865f, -0.01776304f, 
    -0.02297135f, -0.04428292f, -0.05389835f, 0.04797095f, -0.01550908f, 0.05282085f, 0.00299636f, -0.04697363f, 
    0.01127795f, -0.03275105f, 0.02360603f, -0.02024643f, 0.01537324f, -0.01869914f, -0.02699851f, 0.05011668f, 
    -0.02541712f, -0.05298203f, 0.01340530f, -0.05328457f, -0.04969246f, 0.04804181f, -0.01720724f, -0.01642952f, 
    -0.00727487f, -0.01079033f, -0.05326309f, -0.00792821f, 0.05035074f, -0.03602336f, -0.00986388f, -0.00896035f, 
    -0.02742270f, -0.01229697f, 0.01059598f, -0.01123905f, 0.03130971f, 0.04221659f, 0.00757292f, -0.03764294f, 
    0.02604595f, -0.05568494f, -0.02622765f, -0.03243074f, -0.06181611f, 0.00399997f, -0.00474163f, -0.03020284f, 
    -0.03318341f, -0.02458917f, 0.04404305f, 0.04858474f, 0.01030370f, -0.02216795f, -0.02447822f, -0.01570619f, 
    0.00170571f, 0.04206132f, -0.04177749f, -0.04360940f, 0.04057160f, -0.00088476f, -0.04976895f, -0.07428702f, 
    0.03527938f, -0.04291179f, 0.02382416f, 0.03190722f, 0.03040543f, 0.04071267f, 0.04470060f, 0.03518164f, 
    -0.03738851f, 0.01284471f, 0.05122118f, 0.04213308f, 0.04057875f, 0.02678548f, 0.03023129f, -0.03946216f, 
    -0.04625589f, -0.03797225f, 0.05884348f, 0.01379287f, -0.06019289f, -0.03759007f, -0.02750521f, -0.04731097f, 
    0.03970777f, -0.06672936f, -0.06855574f, 0.01235464f, 0.01915286f, 0.03015845f, -0.00097586f, -0.04315988f, 
    -0.05344757f, -0.03144247f, -0.03299250f, 0.02894676f, 0.01637763f, 0.01967093f, -0.04368180f, 0.02456303f, 
    -0.01975667f, -0.00192611f, 0.06196595f, -0.02523192f, 0.04271571f, -0.02116851f, -0.01826835f, -0.06376612f, 
    0.01783331f, 0.04640636f, -0.05139284f, -0.00953443f, -0.03189493f, -0.04666761f, -0.01357910f, 0.05675428f, 
    -0.01433611f, -0.01752712f, 0.00364536f, -0.02959846f, -0.02133803f, -0.04021290f, -0.05906158f, 0.00572560f, 
    0.03948955f, 0.04109629f, -0.02354939f, 0.03089935f, -0.03132343f, -0.02634309f, -0.01999916f, -0.04532043f, 
    -0.00471530f, 0.03095262f, 0.01558360f, -0.03522648f, -0.02856013f, -0.06874508f, 0.04549447f, -0.01006578f, 
    -0.05681644f, 0.04457603f, 0.00595294f, -0.03209660f, 0.02343258f, -0.04678033f, 0.02091604f, 0.00507246f, 
    -0.30419710f, -0.05296456f, -0.02090275f, 0.05151087f, -0.10980073f, 0.13287714f, -0.02273414f, -0.06852233f, 
    0.00879198f, -0.28194398f, -0.07416837f, 0.20647459f, 0.15345837f, -0.02577654f, -0.04998983f, 0.08784156f, 
    0.03373753f, 0.11661027f, 0.05357849f, 0.14659652f, 0.03107806f, 0.05680688f, -0.03960176f, -0.25299871f, 
    -0.31555116f, 0.17512658f, 0.16286318f, -0.03918536f, 0.01507020f, 0.25802156f, -0.06869437f, 0.13319251f, 
    -0.20122640f, -0.08969679f, 0.04521376f, -0.08066902f, -0.53892910f, -0.20788525f, -0.26856726f, 0.06728554f, 
    -0.26162559f, 0.21153723f, 0.03703800f, -0.07279885f, 0.12239240f, -0.59520233f, 0.15220331f, 0.11095678f, 
    0.18262368f, -0.07939919f, -0.06585748f, 0.24423522f, -0.07002136f, 0.07734748f, -0.37524220f, -0.02282416f, 
    -0.06558876f, 0.07435501f, 0.12204403f, 0.02225451f, 0.09085717f, -0.21143955f, -0.04870155f, -0.40937644f, 
    0.46480685f, 0.22555399f, 0.03936772f, -0.00522804f, 0.00100715f, -0.00709469f, 0.00879558f, -0.09499924f, 
    -0.24612503f, -0.34871474f, -0.17287493f, 0.03362040f, 0.10931697f, 0.14389969f, 0.02259405f, -0.25131750f, 
    0.10379583f, -0.10332079f, 0.09471511f, 0.24320096f, -0.02864755f, -0.21809085f, -0.23625395f, -0.17648214f, 
    0.24872983f, 0.03465451f, -0.49909419f, -0.05077037f, 0.05884558f, -0.24072531f, 0.17019062f, 0.00471339f, 
    -0.07637656f, -0.08802136f, 0.00055034f, 0.03467249f, 0.24985756f, 0.17491402f, 0.08233070f, 0.02721081f, 
    -0.00096497f, 0.11375038f, 0.10945249f, 0.08650830f, 0.11808958f, 0.00445696f, 0.10639657f, -0.01857277f, 
    0.10044622f, -0.11751197f, 0.26209697f, 0.04264845f, 0.17335971f, -0.08434962f, -0.20891809f, 0.16289181f, 
    -0.17835292f, -0.09395492f, 0.08104249f, -0.02415034f, 0.35362700f, 0.12734102f, 0.02856770f, -0.06741632f, 
    0.30214298f, 0.07192942f, -0.15708801f, 0.12738176f, 0.07008303f, 0.20802850f, 0.16238609f, 0.18369338f, 
    -0.09505874f, 0.03367139f, 0.27885377f, -0.06399658f, 0.30742145f, -0.02508717f, -0.06402835f, 0.13079979f, 
    0.04147124f, 0.17287381f, 0.32860044f, 0.00298010f, 0.12864891f, 0.00581166f, 0.08707935f, -0.00377832f, 
    0.10143945f, -0.26959756f, 0.21784361f, 0.15396346f, -0.03616110f, 0.08202666f, -0.06925689f, 0.09268399f, 
    0.06943715f, 0.14455269f, -0.28239334f, 0.14356284f, 0.18418387f, -0.04823481f, -0.02730981f, 0.12129253f, 
    -0.09968392f, 0.07391963f, -0.13668114f, -0.10959364f, -0.07700143f, -0.24526608f, 0.01109993f, 0.11403795f, 
    -0.15157261f, 0.03691995f, 0.01459344f, -0.06184110f, -0.15105717f, 0.12079592f, -0.07248868f, 0.01000636f, 
    0.00633347f, 0.21133888f, -0.22828159f, 0.02441336f, -0.04076924f, 0.10402814f, 0.22868055f, 0.06942988f, 
    -0.03481150f, 0.27850169f, -0.23089908f, 0.27081940f, -0.02609793f, 0.27560723f, -0.49271506f, -0.09507106f, 
    -0.15263407f, 0.18331598f, -0.15152104f, 0.16254833f, 0.02848913f, 0.04503727f, 0.04686705f, 0.21324831f, 
    0.00474011f, -0.11771394f, -0.19243723f, 0.11440434f, 0.04660952f, 0.34911969f, 0.01199333f, 0.10507520f, 
    -0.11457222f, -0.19999860f, -0.13438953f, 0.05552398f, 0.12693948f, -0.21930242f, -0.42511347f, -0.08579927f, 
    0.02864096f, -0.05200077f, 0.12515698f, -0.06017541f, 0.04872229f, -0.11278936f, 0.16570921f, -0.04921345f, 
    -0.10672179f, 0.08107769f, -0.26515424f, 0.08034400f, 0.38334844f, 0.15752779f, 0.16651987f, 0.09656989f, 
    0.17810768f, -0.08068953f, -0.08830094f, 0.38067994f, -0.11627141f, 0.02501368f, -0.04248306f, 0.11070202f, 
    0.18938048f, -0.07042670f, 0.11859532f, 0.10026392f, -0.02075351f, -0.07286684f, 0.02725206f, -0.02382396f, 
    0.01945413f, -0.13997811f, -0.13496956f, -0.13170893f, -0.26310685f, -0.62611622f, -0.43619227f, -0.21248344f, 
    0.26594922f, 0.03059350f, 0.03725607f, 0.03949788f, -0.11157290f, -0.03337315f, -0.20988014f, -0.30611831f, 
    0.22042261f, -0.12657449f, -0.11629137f, -0.16754124f, 0.07960936f, 0.13784410f, 0.21012723f, -0.22914109f, 
    0.27340251f, 0.10370263f, 0.22268493f, 0.01015241f, 0.19692852f, 0.18472615f, -0.19389077f, -0.04820433f, 
    0.02889840f, -0.05469182f, 0.03035408f, -0.05563257f, 0.01329915f, -0.04788142f, -0.00580866f, -0.03646376f, 
    -0.03102565f, 0.00398292f, 0.00918371f, -0.02232368f, -0.05789808f, 0.03419517f, -0.08621827f, -0.02361375f, 
    -0.03387489f, 0.01464903f, -0.01175356f, -0.08301506f, -0.08463332f, -0.04951429f, -0.02658245f, 0.01226185f, 
    -0.03826670f, -0.02429950f, 0.01405601f, -0.02407561f, -0.05927205f, 0.05120425f, -0.08064611f, -0.02420343f, 
    0.03405119f, -0.04102012f, -0.00513940f, -0.01740003f, -0.01128296f, 0.02987292f, 0.00864338f, -0.04624658f, 
    -0.05154078f, -0.04804714f, 0.00168789f, -0.03459706f, -0.04231754f, -0.03431012f, -0.02345296f, 0.04976715f, 
    0.00999426f, 0.05511301f, 0.01044626f, -0.04128433f, -0.03440078f, 0.00457162f, 0.01391862f, 0.03131074f, 
    0.02910461f, -0.07457140f, -0.00932793f, -0.05176735f, -0.01990254f, -0.06217016f, 0.00794562f, 0.01943912f, 
    -0.00030090f, -0.01153559f, -0.04329293f, 0.02546442f, 0.00138019f, 0.02080984f, 0.02098157f, 0.00369307f, 
    -0.02147368f, -0.03930277f, -0.04047609f, 0.03627957f, 0.04059367f, 0.01118143f, -0.07427140f, 0.01898509f, 
    -0.02468754f, 0.01263842f, 0.01275393f, 0.03183524f, 0.04788123f, 0.03975529f, 0.03823783f, 0.02635027f, 
    -0.02208985f, 0.01918566f, -0.00210749f, -0.05769361f, 0.04768858f, -0.00021842f, -0.05810935f, 0.03927816f, 
    0.01559857f, -0.05551101f, -0.06303671f, -0.00935814f, 0.03446782f, -0.04991474f, -0.00434373f, 0.02640329f, 
    -0.05550030f, 0.04170031f, 0.03889592f, 0.04195555f, -0.01436693f, -0.08703440f, 0.02926996f, -0.00657694f, 
    0.01197124f, -0.00029514f, -0.01297164f, -0.02667365f, 0.01385556f, -0.06160342f, -0.00176864f, 0.02099356f, 
    0.01988188f, -0.01040175f, -0.04102293f, -0.07112103f, -0.03506770f, 0.03107372f, 0.03084781f, -0.02761843f, 
    0.00971147f, 0.03218823f, -0.04060519f, -0.01114964f, -0.00141559f, -0.01556777f, -0.01023465f, -0.07636538f, 
    -0.03953362f, 0.03869663f, 0.03255411f, 0.04297079f, -0.03069548f, -0.04861683f, -0.03440187f, -0.06293115f, 
    -0.08618440f, 0.04735784f, 0.04530694f, 0.02574872f, 0.01413640f, -0.04329387f, -0.02258252f, -0.07600040f, 
    0.02720268f, 0.01914813f, 0.02614953f, 0.05857528f, 0.02648908f, -0.05382076f, 0.02562281f, 0.00470659f, 
    -0.06299226f, -0.02651760f, 0.01228322f, -0.05839378f, 0.04514029f, -0.04828796f, -0.07925861f, 0.03808861f, 
    -0.05272405f, 0.01060825f, -0.04636683f, -0.04848651f, 0.02626134f, -0.07333950f, 0.00943581f, -0.05791090f, 
    0.01786092f, -0.05962100f, -0.01337798f, 0.01199824f, -0.00996040f, -0.05873913f, -0.06698709f, 0.01091077f, 
    0.03616259f, -0.05235314f, 0.01590674f, 0.02060167f, -0.05688702f, 0.03221798f, 0.04968777f, -0.03057327f, 
    0.02568588f, -0.07759008f, 0.02697298f, -0.08499426f, -0.00604083f, -0.02311466f, 0.01444489f, 0.04234523f, 
    0.00765993f, 0.01499265f, 0.00544998f, 0.02496430f, -0.06484158f, -0.07113446f, -0.07670823f, -0.01718334f, 
    0.02930420f, -0.07921806f, -0.02644895f, -0.03179667f, 0.01321155f, 0.01090574f, 0.04629378f, -0.05847963f, 
    -0.06712455f, -0.08347733f, -0.01948047f, -0.00899566f, 0.00088615f, -0.02850968f, -0.02094473f, 0.00750195f, 
    -0.05156624f, -0.07190623f, -0.03394593f, 0.00545998f, -0.00354787f, -0.05927503f, 0.02941064f, -0.02775339f, 
    -0.05586143f, 0.04187907f, -0.06626880f, -0.03617224f, 0.04690892f, 0.00436049f, 0.00939587f, -0.08035706f, 
    -0.07849234f, 0.01283128f, 0.04676081f, -0.01641109f, 0.01505992f, 0.00839581f, -0.07329959f, 0.00094260f, 
    -0.02520998f, -0.06712759f, 0.02492238f, -0.01727743f, 0.00516865f, -0.03757073f, -0.01170774f, -0.03545589f, 
    -0.03162870f, 0.03112288f, -0.01023515f, -0.03594533f, -0.04483664f, -0.07997804f, 0.03514531f, -0.00272286f, 
    -0.05328643f, -0.02209330f, -0.06396469f, -0.01487288f, -0.03740344f, -0.03182447f, -0.02429954f, -0.05628576f, 
    0.03449444f, 0.03314763f, -0.03001257f, 0.01507998f, -0.03540525f, 0.03361385f, -0.01906344f, -0.07485762f, 
    0.03120279f, -0.01287262f, -0.01396444f, -0.00702565f, -0.02848672f, 0.00614233f, -0.03475815f, 0.02989256f, 
    0.04119242f, 0.12801710f, -0.05682235f, -0.01601058f, 0.06542772f, -0.15352690f, 0.03373976f, 0.00742353f, 
    0.05979632f, -0.17426442f, -0.17474855f, -0.03232256f, -0.10825711f, -0.13963746f, -0.07631842f, -0.01836766f, 
    -0.03876796f, -0.00101810f, 0.29796752f, 0.40282068f, 0.14315534f, 0.14468759f, 0.17086487f, 0.00264743f, 
    -0.01230919f, 0.05529445f, -0.01658953f, 0.17434615f, 0.02572759f, -0.08831155f, -0.45131728f, 0.28442881f, 
    0.16184691f, -0.06676747f, -0.01833184f, -0.17984056f, 0.65935433f, 0.04729640f, -0.08268192f, 0.16624570f, 
    0.18038543f, 0.10760342f, 0.05598667f, -0.06032000f, -0.07247342f, 0.35771361f, -0.15649752f, 0.15628576f, 
    -0.20166664f, 0.00375238f, -0.07338415f, 0.04930013f, 0.15160446f, -0.00506952f, 0.41331759f, 0.08380127f, 
    0.03149644f, -0.15266585f, -0.13615786f, -0.21285187f, 0.06562405f, 0.01680486f, -0.13617860f, -0.21228260f, 
    0.30462486f, -0.08071662f, -0.05927268f, 0.01324055f, 0.24911241f, 0.08107559f, -0.21503365f, 0.14363663f, 
    0.58313078f, -0.12006465f, -0.07729606f, -0.10116657f, -0.00148290f, 0.24686524f, 0.06967924f, -0.22274666f, 
    0.00943424f, 0.30010691f, -0.33612403f, -0.17435606f, -0.05058843f, -0.11795483f, -0.05416055f, -0.04997763f, 
    0.00631162f, 0.18651168f, -0.04768655f, -0.00845518f, 0.05362211f, -0.09543145f, -0.10713421f, 0.19023606f, 
    -0.15322174f, 0.12498783f, -0.06814767f, -0.58315557f, 0.05661030f, 0.04920954f, 0.03769519f, 0.26376426f, 
    -0.16993289f, -0.00683773f, -0.26105922f, 0.05425740f, -0.03265179f, 0.62854666f, 0.18803452f, -0.02457586f, 
    0.18879502f, -0.06335658f, 0.13997361f, 0.02432540f, 0.06947673f, -0.02219512f, 0.31587753f, -0.03066920f, 
    0.26782608f, 0.10138116f, -0.20083703f, -0.21012227f, 0.26854008f, -0.12056746f, -0.00876911f, -0.49196863f, 
    -0.28171495f, -0.19233790f, 0.15552737f, 0.09914918f, -0.13531810f, 0.03532870f, -0.08317573f, 0.31821421f, 
    0.01771474f, -0.29296419f, -0.07217026f, -0.19227666f, 0.08736950f, -0.10628385f, -0.04628303f, 0.25839826f, 
    0.13182794f, 0.14500374f, -0.27487588f, 0.00228329f, 0.27537283f, 0.05167041f, 0.07715718f, -0.26134574f, 
    -0.03164464f, -0.34059519f, -0.34917194f, 0.01452151f, -0.01384185f, 0.14322570f, -0.02001369f, -0.04453173f, 
    0.08076193f, -0.04475068f, -0.19525759f, 0.37316009f, -0.16053887f, 0.04723105f, 0.10050517f, 0.14040472f, 
    0.04247961f, -0.16909936f, -0.04856328f, 0.35253802f, 0.35830724f, -0.29283115f, 0.02905544f, -0.14836769f, 
    -0.00500340f, 0.14347261f, 0.19382322f, -0.05111539f, 0.28709173f, 0.28596473f, -0.12021296f, 0.25039068f, 
    0.21027465f, 0.00542105f, -0.27820212f, 0.14605170f, 0.01818386f, -0.30345654f, 0.19341514f, 0.12635618f, 
    0.02044454f, 0.04568955f, 0.14557329f, 0.08792236f, 0.05165066f, 0.09032393f, 0.53032464f, -0.04087289f, 
    -0.23991314f, -0.11160710f, -0.01992185f, 0.04045133f, 0.01280138f, -0.00337334f, 0.21421903f, -0.06840396f, 
    -0.36319247f, -0.06441777f, 0.17851402f, -0.00199390f, 0.00471918f, -0.00986430f, -0.07148426f, 0.03017204f, 
    -0.96325231f, -0.21419774f, 0.05028970f, -0.08799069f, 0.30717853f, -0.29100236f, -0.22478253f, 0.14003456f, 
    -0.19221593f, 0.40073636f, -0.31589204f, -0.38410860f, -0.14226945f, 0.01301446f, 0.02304841f, -0.06138163f, 
    -0.19744267f, -0.02922622f, -0.59812003f, 0.38617983f, -0.16668786f, -0.05420806f, 0.18458742f, 0.17532916f, 
    0.10623986f, -0.08586349f, 0.04083333f, 0.32596236f, -0.25620189f, 0.09249890f, -0.06764064f, 0.02183690f, 
    0.13490939f, 0.00155825f, -0.03351346f, -0.01492359f, -0.35344139f, 0.19461583f, -0.01205222f, 0.10968288f, 
    0.22804779f, -0.12918867f, -0.26982170f, -0.13835290f, -0.22375736f, -0.33386323f, -0.01765677f, 0.01266894f, 
    -0.19752781f, 0.18406247f, -0.12798035f, -0.04905909f, -0.01198027f, 0.18326488f, -0.10064438f, 0.37838778f, 
    0.02267470f, 0.17385404f, 0.03078671f, -0.06922674f, -0.16927014f, 0.21005957f, 0.01238184f, 0.61003017f, 
    -0.09790834f, 0.09574379f, -0.13782315f, 0.17266461f, 0.04332818f, -0.22877690f, 0.09570315f, -0.11558326f, 
    -0.03401568f, 0.26696548f, 0.25766581f, 0.02778392f, -0.03366969f, 0.06871063f, 0.31710723f, -0.02287442f, 
    0.08110706f, 0.24811779f, -0.06639355f, -0.01817655f, 0.05986473f, -0.04056029f, -0.04166258f, 0.52030659f, 
    0.07447641f, 0.06405044f, 0.39203969f, 0.15517245f, -0.23992904f, -0.00243096f, 0.05961158f, 0.06776879f, 
    0.03729647f, 0.11848798f, 0.14642334f, -0.19887508f, -0.02827256f, -0.07240555f, -0.40590775f, -0.04125790f, 
    -0.06940664f, 0.16505909f, -0.11866587f, 0.03249293f, -0.58109444f, -0.00788472f, -0.19495466f, -0.07851867f, 
    -0.59344053f, -0.16944747f, 0.15741110f, 0.36506152f, 0.18879049f, -0.14279030f, 0.04938336f, -0.01589021f, 
    -0.18754216f, 0.03268137f, 0.05357915f, -0.17704572f, 0.14028609f, 0.12908076f, -0.08243915f, 0.16766565f, 
    0.15908684f, 0.01435056f, 0.27158689f, 0.19988210f, -0.02842593f, 0.01303775f, -0.42285866f, 0.13376386f, 
    0.27054918f, 0.06058411f, 0.21408577f, 0.02913565f, 0.08238515f, 0.00683517f, 0.06145934f, 0.10200870f, 
    -0.34587550f, 0.11051186f, -0.26695666f, 0.24986640f, 0.08781297f, -0.11710437f, -0.05706321f, 0.07329685f, 
    0.12870668f, -0.50361520f, -0.08538882f, -0.06007559f, 0.15462622f, 0.00414603f, 0.02349784f, -0.12680373f, 
    -0.26842475f, -0.09191826f, -0.24516621f, -0.14071620f, -0.11134921f, 0.08199446f, 0.25609413f, -0.02051708f, 
    0.02375220f, -0.16488668f, -0.01857120f, 0.08273575f, 0.08629777f, -0.04586253f, -0.22387680f, 0.01326059f, 
    -0.08998940f, 0.05524545f, -0.22186156f, -0.13895477f, 0.61907458f, 0.38179493f, -0.13994507f, -0.01182542f, 
    -0.08460528f, -0.09080936f, 0.07832770f, -0.00515546f, 0.19190015f, 0.24761169f, 0.09193397f, -0.06444679f, 
    0.17843713f, -0.22273086f, -0.11427543f, 0.25599313f, 0.11466908f, -0.03170234f, -0.18824534f, -0.10120981f, 
    -0.33437601f, 0.21128348f, -0.15618876f, -0.20531300f, 0.13001937f, 0.07910530f, 0.29061186f, -0.70018923f, 
    0.00496115f, -0.03540288f, 0.09729621f, 0.23016378f, 0.31572065f, -0.25790134f, 0.01109128f, -0.00388733f, 
    0.71717465f, 0.10080680f, -0.12131020f, 0.02050301f, 0.08482239f, -0.25813419f, 0.19679208f, 0.10755852f, 
    0.08134796f, 0.03079119f, -0.34438038f, -0.15752414f, 0.15274449f, 0.00682182f, -0.03486646f, 0.14761944f, 
    0.24471724f, -0.00865128f, 0.56521618f, 0.34188691f, 0.08982079f, 0.11469265f, 0.07448163f, 0.10713890f, 
    0.16117631f, 0.05617325f, 0.02212508f, -0.10568605f, -0.00874661f, -0.05983922f, -0.02758010f, -0.06738561f, 
    -0.04400433f, 0.16712785f, -0.20052463f, -0.04884122f, -0.32728803f, 0.17503272f, -0.13557671f, 0.14808714f, 
    -0.11716164f, 0.02299384f, 0.09289736f, 0.06827071f, -0.24354367f, -0.18886949f, -0.11800219f, 0.06030044f, 
    0.19342577f, 0.26305950f, 0.19512343f, 0.09179683f, 0.08091445f, 0.11157919f, -0.34494627f, 0.18803793f, 
    -0.47380671f, 0.20614085f, 0.14373964f, 0.00637323f, -0.21488863f, -0.03634889f, 0.04199820f, -0.14094836f, 
    -0.34073853f, -0.02321142f, 0.06034117f, 0.21718888f, -0.38588455f, 0.07236660f, 0.18948057f, 0.18918340f, 
    -0.29572514f, -0.53582531f, -0.07334229f, 0.13435362f, 0.06040537f, 0.12376235f, 0.04367948f, 0.11111540f, 
    -0.19842742f, -0.04754793f, -0.10733543f, -0.29618907f, -0.14255682f, -0.02305588f, -0.09331194f, -0.19071509f, 
    0.14493942f, 0.10657509f, 0.30312571f, -0.03037401f, -0.05987455f, 0.31697249f, -0.05494116f, 0.12777424f, 
    0.19675304f, 0.10779905f, 0.02362383f, -0.11646733f, 0.05042546f, 0.20541674f, 0.01389467f, 0.03259303f, 
    -0.14635184f, 0.05008451f, -0.15302010f, 0.16450642f, 0.15335880f, -0.28304797f, 0.00256178f, 0.04800216f, 
    -0.01346456f, 0.18856879f, 0.06035016f, -0.02297327f, -0.11384903f, 0.24735846f, 0.14050210f, -0.28886989f, 
    -0.07111517f, -0.10500383f, -0.09438705f, 0.32580566f, 0.08130616f, -0.09582587f, 0.43173656f, 0.22778757f, 
    -0.26914430f, 0.16325124f, -0.17319967f, -0.02211408f, 0.26698345f, 0.11480150f, 0.15849344f, -0.24992096f, 
    0.06085348f, -0.32182378f, 0.03745158f, 0.18070911f, 0.09668241f, -0.00451393f, 0.09530159f, -0.18205088f, 
    -0.07334912f, 0.22995798f, 0.25724658f, 0.22161511f, -0.06867162f, 0.00602357f, -0.01330509f, 0.23536754f, 
    0.04994546f, 0.24304116f, 0.09071494f, 0.19315562f, -0.00872274f, -0.12378959f, -0.12129333f, 0.05582225f, 
    -0.16729067f, -0.06345171f, -0.13731326f, 0.21894653f, -0.42898795f, 0.00850894f, 0.12525454f, -0.08016939f, 
    0.11371356f, 0.18369825f, 0.09771734f, -0.19543362f, 0.41138566f, 0.20104995f, 0.04762582f, 0.20250811f, 
    0.03371765f, 0.10286324f, -0.05860353f, -0.10547768f, -0.01592535f, -0.33299398f, 0.15076046f, 0.12001290f, 
    -0.01888883f, 0.06271735f, 0.06657400f, 0.29197305f, 0.20376049f, -0.21067984f, -0.14074202f, 0.09350187f, 
    0.02728629f, -0.37994614f, -0.05814183f, 0.01893826f, 0.13983454f, -0.05341153f, -0.23884852f, -0.16692208f, 
    0.29032850f, 0.05959710f, -0.15826872f, 0.16257370f, -0.10942724f, -0.11161777f, -0.18579751f, 0.11778972f, 
    0.35377178f, 0.04324815f, 0.08610517f, -0.05599605f, -0.04746270f, -0.16138187f, 0.05909817f, 0.06193139f, 
    -0.16950470f, -0.30331415f, 0.14172260f, -0.08864132f, -0.05388969f, 0.12073757f, -0.03855194f, -0.14766395f, 
    -0.04018205f, 0.01402960f, -0.14791845f, 0.20721787f, 0.03883108f, 0.02483529f, -0.05458378f, 0.03880794f, 
    0.09687234f, 0.16592094f, 0.65032506f, 0.25717726f, 0.01299356f, -0.00481148f, 0.05689228f, 0.00743007f, 
    0.06804553f, -0.03086958f, -0.14283031f, -0.14483589f, -0.13587220f, -0.10644170f, 0.07036317f, 0.05320366f, 
    0.17034870f, -0.06157855f, 0.00910576f, 0.37783551f, 0.15823293f, 0.24327697f, -0.09526464f, 0.05488628f, 
    -0.04757756f, 0.15010405f, 0.02718634f, 0.23304375f, -0.08936526f, -0.03258061f, 0.12775446f, 0.02393486f, 
    0.15341265f, -0.02644700f, -0.04525983f, 0.31162557f, 0.01717158f, -0.09287257f, 0.30987117f, 0.12681143f, 
    0.18646517f, 0.16615756f, 0.00482242f, -0.00152706f, 0.07358237f, -0.12777501f, 0.03517380f, -0.68453056f, 
    -0.52990717f, 0.18211094f, -0.15985887f, 0.07399710f, 0.11537897f, -0.09097157f, -0.01681951f, 0.15890856f, 
    0.17164446f, 0.33688873f, -0.32522759f, 0.01158775f, -0.50853187f, 0.07054119f, -0.06039590f, -0.09541658f, 
    -0.25495911f, 0.21156494f, 0.15945300f, -0.32592675f, 0.05909462f, -0.05623997f, 0.01362474f, 0.09742212f, 
    0.05586121f, 0.19373602f, 0.06717426f, 0.33298117f, -0.01082877f, 0.05203951f, -0.13968509f, -0.11514910f, 
    0.07107485f, 0.00985456f, -0.19136631f, -0.23054732f, 0.22261785f, -0.12822831f, -0.18255094f, -0.21025029f, 
    0.03470690f, 0.11867273f, -0.08384456f, -0.00847089f, 0.03670128f, -0.36655647f, -0.24932076f, 0.14708984f, 
    -0.06295942f, 0.08903332f, 0.00900488f, -0.01341191f, 0.00676562f, 0.13951744f, 0.12043113f, 0.10987362f, 
    0.10873911f, -0.05865589f, 0.10626397f, -0.01402310f, 0.03297544f, -0.01026868f, -0.27579519f, -0.23527400f, 
    0.18468122f, 0.03303567f, 0.00277249f, 0.23443112f, -0.25042552f, 0.00705550f, 0.05231300f, -0.18283153f, 
    -0.17592014f, -0.67282355f, -0.21766025f, -0.10781726f, -0.02102051f, 0.17507488f, -0.14412896f, 0.17650397f, 
    0.37271971f, -0.08440830f, -0.40312651f, -0.05881904f, -0.00695608f, 0.03325936f, -0.03956499f, 0.04857479f, 
    -0.05772029f, -0.59714317f, 0.15616128f, -0.35661834f, 0.00529788f, 0.15254569f, 0.07361760f, -0.23081729f, 
    0.13677916f, -0.15560170f, 0.36059326f, 0.06293484f, 0.07887920f, -0.03074832f, 0.10377855f, -0.05488632f, 
    -0.02792267f, 0.17371166f, 0.00874498f, -0.25062820f, -0.27124527f, 0.16254161f, -0.03819243f, 0.11259763f, 
    -0.12601772f, -0.05578384f, 0.08783785f, 0.05204183f, 0.18963595f, 0.19522664f, -0.33851343f, -0.17047860f, 
    -0.02917534f, -0.00737293f, 0.20554353f, -0.00731731f, 0.08381706f, 0.06284045f, -0.05946823f, 0.33155170f, 
    -0.06890406f, -0.01956728f, 0.01777603f, -0.12375528f, -0.07084211f, -0.07366685f, 0.22190727f, 0.27889761f, 
    -0.34286261f, 0.11479673f, 0.02446095f, 0.00844019f, 0.19607544f, 0.08264636f, -0.11469275f, 0.08183575f, 
    -0.23249935f, -0.00539335f, 0.11770854f, -0.03620427f, 0.07610398f, -0.17189246f, 0.00817342f, -0.12371036f, 
    -0.03496240f, -0.00922724f, 0.01967832f, 0.02769022f, 0.00097348f, -0.04590954f, -0.02960600f, 0.04327065f, 
    -0.04854110f, -0.03550845f, -0.02651463f, -0.04415881f, 0.00340417f, -0.02033295f, 0.04896379f, 0.01500483f, 
    0.04112681f, -0.05457647f, -0.06113835f, 0.00794092f, -0.02085707f, -0.02621323f, 0.02844629f, -0.05185581f, 
    -0.05527336f, 0.01760582f, -0.00855998f, 0.02246587f, 0.03403622f, -0.05015050f, -0.02709584f, -0.00269004f, 
    -0.02393653f, 0.00352923f, 0.01399550f, 0.04361553f, 0.01795751f, -0.01848897f, 0.04720734f, 0.00131419f, 
    -0.04543811f, 0.02290571f, -0.01110138f, -0.06282537f, 0.02088329f, 0.03888159f, 0.01537010f, 0.00009507f, 
    0.02777652f, -0.00062709f, -0.04370862f, -0.01029925f, 0.04289445f, -0.01086910f, -0.06081020f, 0.02651754f, 
    -0.05130027f, -0.03593736f, -0.05421730f, -0.01586828f, 0.02396654f, -0.03844519f, -0.00163459f, 0.01459310f, 
    -0.05342321f, -0.04061265f, -0.01793543f, -0.01861690f, -0.03213208f, 0.01055461f, 0.03156297f, 0.03033736f, 
    0.05135533f, -0.04280803f, 0.03623580f, -0.05156523f, -0.04507592f, -0.02562927f, -0.00841667f, -0.04376435f, 
    0.03929188f, -0.03341021f, -0.03342191f, -0.05557868f, -0.00704783f, 0.00245939f, -0.03268973f, -0.05632177f, 
    -0.05938171f, 0.02689044f, -0.02328550f, 0.00737089f, 0.00944298f, 0.02873021f, 0.05329581f, -0.01308527f, 
    0.04455348f, -0.05383069f, -0.00134473f, 0.04370226f, -0.00244650f, 0.02545839f, -0.05076820f, -0.03884147f, 
    0.01045457f, 0.04905258f, -0.00883645f, -0.03227961f, -0.01257061f, -0.03825068f, -0.02933002f, 0.01609990f, 
    0.05201347f, -0.00380937f, -0.03607030f, -0.00091507f, 0.02375112f, 0.03224626f, -0.06199083f, 0.03577179f, 
    -0.04161406f, -0.02789322f, -0.01190035f, -0.02352103f, 0.03846708f, -0.04636530f, -0.00106393f, -0.02737221f, 
    0.00399370f, -0.00744142f, 0.01481517f, -0.00083742f, -0.04306642f, -0.01041569f, 0.04762295f, 0.04791509f, 
    -0.05969569f, 0.03673552f, 0.00241322f, -0.05184918f, -0.02766732f, 0.02520157f, -0.04575648f, -0.03944912f, 
    -0.05494608f, -0.05509935f, -0.01502634f, -0.04110219f, -0.06023399f, 0.01549294f, 0.00223855f, -0.04847936f, 
    0.03325982f, -0.05156738f, 0.04655166f, -0.00791354f, 0.00223153f, -0.03507592f, -0.05872277f, 0.02789447f, 
    0.02883838f, 0.03710083f, 0.03108604f, 0.02589214f, -0.00710695f, -0.05368891f, -0.03731029f, 0.03728775f, 
    -0.04198064f, 0.03341903f, 0.02255666f, -0.02464238f, 0.00400939f, 0.03840852f, -0.01130158f, 0.04832160f, 
    -0.04020317f, 0.04772692f, 0.00657070f, 0.02199942f, 0.00927742f, -0.01087975f, -0.00401345f, -0.05496332f, 
    0.03391173f, -0.00666905f, -0.02416640f, -0.00925040f, 0.05068164f, -0.05966375f, -0.04696869f, 0.00943808f, 
    -0.05483411f, 0.00291603f, -0.03519538f, 0.00816745f, -0.04948733f, -0.00205884f, -0.00523725f, -0.02363323f, 
    0.00263056f, -0.06482614f, -0.03511281f, 0.02968298f, -0.05664577f, -0.04619820f, -0.01890991f, 0.04734036f, 
    -0.03665461f, 0.00341325f, -0.02035199f, -0.02116345f, -0.02105073f, 0.00616139f, -0.03832823f, 0.04483181f, 
    -0.06461008f, -0.02963687f, -0.03627363f, 0.01021613f, -0.01017684f, 0.05162815f, -0.01031595f, -0.00983666f, 
    -0.00974615f, 0.01919394f, 0.04304278f, -0.00274586f, 0.02512610f, 0.00784264f, -0.00035872f, 0.02209749f, 
    -0.05624048f, -0.00548909f, -0.00201335f, 0.01848708f, -0.03656771f, 0.03907616f, -0.00399680f, -0.04701501f, 
    0.00446138f, -0.00094321f, 0.04995130f, 0.03572560f, 0.00160341f, 0.04485277f, -0.00771516f, 0.01808742f, 
    -0.05472128f, -0.03186870f, -0.03430481f, 0.00624307f, 0.03253071f, 0.04312613f, -0.06648469f, 0.01466975f, 
    -0.04697468f, -0.00577191f, 0.00006465f, -0.06765652f, -0.01750869f, -0.04976975f, 0.03862276f, -0.03911712f, 
    -0.04018594f, 0.00523058f, -0.01095787f, -0.03667828f, 0.00547559f, 0.02729911f, -0.02973981f, -0.00767119f, 
    -0.03210423f, -0.04180041f, 0.05248479f, -0.04344439f, 0.04375857f, -0.01598248f, -0.02442155f, 0.03370425f, 
    -0.04048587f, 0.05030093f, 0.04867367f, 0.02473188f, -0.01218498f, -0.00554675f, 0.00567124f, -0.05181652f, 
    -0.01706564f, 0.21746643f, 0.27140144f, -0.16543676f, -0.04350689f, -0.06351449f, -0.01736097f, -0.09638903f, 
    0.07369216f, -0.17401034f, -0.41172731f, -0.11737718f, 0.11435559f, 0.04661408f, 0.00573089f, -0.08743889f, 
    -0.01352458f, 0.13141696f, 0.09843535f, 0.07442611f, -0.35482523f, 0.27767989f, -0.12215246f, 0.06043314f, 
    0.21516792f, -0.00665507f, 0.08804212f, -0.38193050f, 0.17034727f, -0.00044238f, 0.00197806f, -0.25156340f, 
    0.00153778f, 0.10767038f, -0.00600466f, -0.02088516f, -0.13698876f, -0.29617980f, -0.12162379f, -0.11872630f, 
    0.24239530f, -0.06746452f, 0.33079210f, -0.21410494f, -0.00379686f, 0.05763402f, -0.04930167f, -0.22806045f, 
    0.28911549f, 0.16533303f, -0.02675677f, 0.04250270f, -0.18908891f, -0.15215023f, 0.45430964f, -0.04247884f, 
    0.11015458f, -0.02461848f, -0.07815164f, -0.12090464f, 0.16099387f, -0.29743659f, -0.30118233f, 0.02952839f, 
    -0.09069950f, 0.02450141f, -0.20232657f, 0.00696267f, 0.21637593f, 0.07049587f, 0.07078443f, 0.11813705f, 
    -0.26203194f, -0.26518777f, -0.34659198f, -0.00415777f, 0.14017861f, -0.01486740f, -0.10859064f, -0.16364491f, 
    0.25205824f, 0.00743533f, -0.70276570f, -0.38726631f, 0.07374366f, -0.02743621f, 0.09408734f, -0.01451706f, 
    0.13002925f, -0.09623098f, -0.05669297f, 0.17827132f, 0.00106530f, 0.14591786f, -0.07762208f, 0.01752852f, 
    -0.03956860f, -0.04788763f, -0.05921254f, 0.13257879f, -0.05250444f, -0.07799560f, 0.09208158f, 0.24909666f, 
    0.23223622f, 0.22352406f, 0.19820508f, 0.09559117f, 0.11409105f, 0.33989063f, 0.05414981f, -0.08065403f, 
    0.01671167f, 0.07669538f, 0.05531970f, 0.31731012f, 0.12275188f, 0.15659232f, 0.43453771f, -0.03336069f, 
    0.02132029f, -0.09938495f, 0.21221451f, -0.14646067f, 0.00488377f, 0.20598824f, -0.43394303f, -0.25115561f, 
    0.14272575f, -0.05142665f, 0.03956485f, 0.04367396f, -0.09541676f, 0.09994479f, -0.15410957f, 0.64011627f, 
    0.39853400f, -0.34009525f, -0.01361301f, -0.10897037f, 0.03740415f, 0.16430078f, -0.13426837f, -0.16377406f, 
    0.04356302f, 0.09674843f, 0.25954956f, -0.14370205f, 0.02720453f, 0.11087904f, 0.00658662f, -0.03247377f, 
    0.06968281f, 0.05707827f, -0.18219383f, 0.42324170f, -0.32690683f, 0.28988340f, -0.04668763f, 0.20343409f, 
    0.10205398f, 0.13571332f, 0.29932699f, 0.18189934f, 0.15498577f, -0.04622377f, 0.09388050f, 0.05485549f, 
    -0.17105205f, -0.05412002f, 0.07986096f, -0.13391365f, 0.15285137f, -0.00215992f, 0.09691299f, -0.26325625f, 
    -0.23223796f, -0.23862810f, 0.15308306f, 0.03902187f, 0.16031654f, 0.04788234f, -0.37011558f, 0.19156267f, 
    -0.10672943f, 0.03544047f, -0.02555953f, -0.16984260f, -0.08798268f, -0.14701343f, -0.08432993f, 0.20073693f, 
    -0.08395560f, 0.16351809f, 0.17637478f, 0.23021783f, 0.24232790f, -0.15653877f, 0.07655434f, -0.08943973f, 
    -0.58175087f, 0.15346853f, 0.23390403f, 0.14982951f, -0.05394790f, -0.13903908f, 0.01971157f, -0.34286469f, 
    0.18070959f, 0.04608334f, -0.16561453f, -0.01002263f, -0.06016586f, 0.06907842f, -0.05172510f, 0.12104371f, 
    0.08229492f, -0.03090601f, 0.07555143f, -0.13677803f, 0.04760904f, -0.09661356f, 0.23046903f, 0.12228668f, 
    -0.18736875f, -0.13710782f, -0.03627638f, 0.23034905f, -0.00403159f, 0.07223742f, -0.08465436f, 0.06661675f, 
    0.15481319f, 0.05435054f, 0.27982697f, 0.27168313f, 0.16062990f, -0.10083572f, -0.27535507f, -0.19446518f, 
    -0.24913351f, 0.17816786f, 0.17020290f, -0.26329216f, -0.04006930f, -0.22449224f, 0.02445134f, -0.23237488f, 
    -0.06728651f, 0.15408076f, -0.07308986f, 0.03185578f, -0.02042862f, 0.29979047f, 0.18321221f, 0.05810690f, 
    0.37437326f, -0.16846861f, 0.03391662f, -0.26186308f, -0.13837080f, -0.29402149f, -0.29480392f, -0.18621686f, 
    0.11567777f, 0.15206429f, -0.01680147f, 0.11564279f, 0.04580823f, 0.15673262f, 0.19871789f, 0.36910862f, 
    0.17732812f, 0.09234768f, 0.09795130f, 0.16406997f, -0.19337778f, 0.23683244f, 0.23994891f, -0.12182891f, 
    -0.31092510f, -0.23112075f, 0.01556310f, 0.04159667f, 0.06555659f, 0.11159100f, -0.18365252f, -0.14502910f, 
    -0.00472801f, -0.02759621f, -0.02767188f, 0.03842004f, -0.00806788f, 0.01078992f, 0.05051852f, 0.02488232f, 
    -0.05346435f, -0.01204735f, 0.04148510f, -0.01377303f, 0.04862547f, -0.05493423f, 0.02421191f, 0.03092618f, 
    -0.05820959f, -0.01354037f, -0.04272592f, 0.04466495f, 0.02497887f, 0.01564180f, -0.05192911f, 0.02999709f, 
    0.04091938f, 0.03213124f, -0.03243175f, -0.02051959f, -0.05735357f, 0.01840160f, -0.00757963f, -0.04804975f, 
    -0.01457839f, -0.02024326f, -0.03157441f, -0.01110453f, 0.02099090f, -0.02630077f, 0.02660214f, -0.00074923f, 
    -0.06450377f, -0.04026731f, -0.02824776f, -0.01486274f, -0.03838614f, 0.01049144f, -0.02788525f, -0.05006850f, 
    0.04650728f, 0.00948920f, 0.03060883f, 0.00177670f, 0.01618641f, 0.02527708f, 0.01994084f, 0.04952501f, 
    0.02463737f, 0.04411075f, -0.02520393f, -0.06008757f, 0.03328856f, -0.01512022f, 0.01382808f, -0.05562744f, 
    0.01343336f, 0.03675411f, -0.06217248f, 0.00860920f, 0.03009079f, -0.03881194f, 0.05051464f, -0.03005780f, 
    -0.03751822f, -0.05949881f, -0.01821323f, 0.00734388f, -0.00963540f, 0.00870085f, -0.04218111f, -0.06366540f, 
    -0.00196920f, 0.01372261f, 0.03930758f, -0.06128630f, -0.05343068f, 0.01996755f, 0.04872477f, 0.03064401f, 
    0.02360238f, -0.02211667f, -0.05192658f, 0.02210757f, -0.03199897f, 0.02903809f, 0.01299310f, 0.00179040f, 
    0.02396853f, -0.03283153f, 0.01722180f, -0.01341526f, 0.01115842f, -0.03889765f, -0.04962609f, -0.05210530f, 
    0.01254314f, 0.01302291f, -0.05351935f, -0.03006135f, -0.05444081f, -0.01209752f, 0.00140158f, 0.01426456f, 
    0.02213612f, -0.03800267f, 0.04382057f, -0.03885130f, -0.01200023f, -0.02152357f, 0.03881983f, -0.05617113f, 
    -0.03377904f, -0.03365566f, 0.03123963f, -0.05084514f, 0.01762290f, -0.03705475f, 0.03977849f, 0.02719618f, 
    -0.00325133f, -0.01880506f, -0.00928723f, 0.00929364f, 0.04149915f, -0.05209616f, -0.02550302f, -0.00413053f, 
    0.01279554f, 0.01908989f, -0.02033063f, 0.02007907f, -0.05576776f, 0.04245708f, -0.04374821f, 0.02198821f, 
    0.04549549f, -0.01875562f, 0.01612265f, -0.06277317f, -0.05238847f, -0.04457233f, -0.03026035f, 0.01114684f, 
    0.04699504f, -0.02989389f, -0.02494141f, -0.03987263f, -0.00630538f, -0.02431490f, -0.04485891f, -0.01589247f, 
    -0.02433159f, 0.01807490f, -0.06465235f, -0.01274864f, -0.04796907f, -0.04643995f, 0.04330088f, 0.00099542f, 
    -0.00480056f, -0.01159030f, -0.00227671f, -0.05551915f, -0.05324923f, -0.04554701f, -0.04203580f, -0.01065389f, 
    0.03234984f, -0.04892953f, -0.05374735f, -0.03490343f, 0.03858916f, 0.02380857f, -0.05402224f, 0.03861644f, 
    -0.04723369f, -0.00371106f, 0.01895658f, 0.02526769f, -0.03150625f, -0.05262195f, 0.01688343f, 0.04927875f, 
    0.01339951f, -0.03456899f, -0.01263361f, -0.02875990f, -0.04489030f, 0.00871681f, -0.05034418f, -0.03011594f, 
    0.04153587f, 0.01997085f, 0.03753840f, -0.01554220f, 0.04552401f, -0.01227175f, 0.02753701f, -0.02618242f, 
    -0.02621943f, 0.00498606f, 0.04585617f, -0.02907109f, -0.05751539f, 0.02107636f, 0.02667964f, -0.05345093f, 
    -0.03623046f, 0.01377409f, -0.04694021f, -0.04281391f, -0.02067071f, -0.05007338f, 0.03606946f, 0.00765710f, 
    -0.02330207f, -0.06061963f, 0.03287007f, -0.03646055f, 0.04633966f, 0.02324432f, 0.00344753f, -0.02351884f, 
    -0.04603603f, 0.04383544f, 0.00326256f, 0.04572145f, 0.04065129f, 0.02795350f, 0.00310621f, -0.00207340f, 
    -0.06514964f, 0.01769602f, 0.00291351f, 0.00914606f, 0.03890043f, 0.02476755f, 0.00167554f, -0.05647719f, 
    -0.06354499f, -0.05244990f, -0.03494385f, 0.01634788f, -0.00374262f, 0.01220647f, -0.05686503f, 0.01334771f, 
    0.01654617f, -0.01728406f, -0.01323435f, -0.02008297f, -0.03148524f, 0.05595099f, 0.00623050f, 0.05225678f, 
    -0.04010576f, -0.00049019f, -0.01383514f, -0.05760012f, -0.04027988f, 0.01739155f, 0.00653729f, 0.00932205f, 
    -0.02450815f, -0.05554429f, -0.04018598f, 0.00610337f, 0.00305031f, -0.05046739f, 0.02702751f, 0.00460505f, 
    0.00369052f, -0.04395701f, 0.05266719f, -0.02875767f, 0.01062099f, -0.02710108f, 0.00605375f, -0.00880954f, 
    0.04706185f, -0.03488289f, -0.04059289f, -0.02124614f, 0.01226908f, 0.04119427f, 0.01557511f, 0.01187815f, 
    0.00317125f, -0.05941588f, -0.03879764f, -0.01806561f, 0.02295727f, 0.02080993f, -0.01626277f, -0.03724204f, 
    -0.06004713f, -0.03726736f, 0.00835935f, 0.05073176f, 0.00405332f, 0.00470233f, -0.03057573f, -0.04755442f, 
    0.03964755f, -0.03910653f, -0.00966258f, 0.05079519f, 0.02654192f, 0.03436937f, -0.02045101f, 0.01771865f, 
    -0.03789327f, 0.02446491f, -0.04549804f, 0.03848837f, 0.01190863f, -0.00030275f, 0.04078538f, -0.04460415f, 
    0.00797777f, -0.05042742f, -0.05212529f, -0.04399644f, -0.01512255f, 0.00844616f, 0.00694198f, -0.05126385f, 
    -0.01503893f, -0.01671384f, -0.04253601f, 0.03271851f, 0.02103376f, 0.00486276f, 0.01758809f, 0.04203053f, 
    -0.00041598f, -0.03050342f, -0.02150293f, 0.04360660f, 0.04986715f, -0.03563943f, 0.04229625f, -0.05582174f, 
    0.05043215f, -0.02190668f, -0.05109920f, 0.04495342f, -0.05660832f, 0.03542767f, -0.01326216f, 0.05009272f, 
    -0.02967172f, -0.01200607f, -0.00725508f, -0.05033784f, -0.00979472f, 0.05015027f, -0.00190147f, 0.02614983f, 
    -0.04530250f, -0.03059099f, -0.05205966f, 0.04905867f, 0.03962043f, -0.02576343f, -0.04416557f, -0.02940388f, 
    -0.02765986f, 0.01004062f, -0.01645872f, 0.04719665f, -0.05687911f, 0.02747689f, -0.02062401f, 0.04693701f, 
    0.00225840f, 0.01717367f, -0.01554454f, 0.00798001f, -0.01583792f, 0.00307904f, 0.03721889f, -0.04726223f, 
    0.05207750f, 0.00780307f, 0.03283392f, 0.01337487f, -0.02235771f, -0.00543443f, -0.03036173f, 0.02188278f, 
    -0.05558323f, 0.05547456f, -0.06553226f, -0.03201913f, -0.04484833f, -0.05150306f, -0.02569835f, 0.00954483f, 
    -0.04144463f, -0.04078072f, -0.03993460f, 0.00310344f, 0.00221517f, -0.04082721f, 0.02869007f, -0.00782031f, 
    -0.03012219f, -0.00776581f, 0.00305910f, 0.03545222f, 0.00381149f, 0.01515544f, -0.02260219f, 0.03436453f, 
    -0.01739291f, 0.03513102f, -0.02918980f, -0.05065851f, -0.00791066f, -0.01577271f, -0.05832327f, -0.00568265f, 
    -0.04637287f, 0.00447892f, 0.03936619f, -0.05107647f, -0.02205889f, -0.05305884f, -0.02642205f, 0.03561721f, 
    0.05396697f, 0.03243156f, 0.01065231f, -0.04771357f, 0.01970798f, 0.04950354f, 0.03231641f, -0.04927320f, 
    -0.04162114f, -0.01167388f, -0.00409780f, -0.04224823f, -0.02915051f, 0.00396707f, -0.04231038f, 0.02859544f, 
    -0.04352957f, -0.02080033f, 0.04681234f, -0.03101917f, -0.04018775f, -0.06095387f, -0.04699276f, -0.01455296f, 
    0.02826740f, 0.03281586f, -0.00838399f, -0.04084858f, -0.00206845f, 0.03944290f, 0.02603661f, -0.04614965f, 
    0.02947396f, -0.05896611f, -0.06141564f, -0.04254410f, 0.04170094f, -0.00274576f, -0.03699207f, -0.03666002f, 
    -0.06766583f, -0.06926264f, -0.06182648f, 0.01758110f, -0.03747271f, -0.02805659f, 0.04331390f, -0.04557652f, 
    0.00027816f, 0.00569350f, -0.04705048f, 0.01154069f, 0.00876167f, -0.03008955f, 0.04101307f, -0.05414444f, 
    0.03657078f, -0.04203793f, -0.05020329f, -0.05050579f, 0.04786352f, 0.03014966f, -0.05259530f, 0.00394543f, 
    0.04017832f, 0.00968831f, 0.00350371f, -0.01194437f, 0.02463880f, -0.06207675f, 0.02911687f, 0.00341686f, 
    0.00574426f, -0.00811900f, -0.00542851f, 0.04882210f, -0.04395992f, 0.03347624f, 0.00462749f, 0.03720518f, 
    -0.04056496f, -0.02532046f, -0.03624387f, 0.04384343f, 0.01902348f, 0.02953711f, -0.01121373f, -0.05644051f, 
    0.02101674f, -0.01853338f, 0.00073576f, -0.00083933f, -0.00182223f, -0.02408862f, 0.00134084f, 0.03816688f, 
    -0.02561580f, 0.03576458f, 0.01625468f, -0.04296111f, -0.00298646f, 0.02195091f, -0.01875859f, -0.05399640f, 
    -0.02530609f, -0.03325675f, 0.01016473f, 0.03584742f, 0.01612596f, -0.03693872f, 0.04551651f, -0.01590079f, 
    -0.00837058f, -0.05253937f, 0.04410233f, -0.03570501f, 0.02173210f, 0.01308014f, -0.06390727f, -0.04663614f, 
    -0.03684578f, -0.02490500f, -0.01424589f, 0.05734694f, -0.05951126f, -0.02822288f, -0.04317466f, -0.02529171f, 
    0.03257958f, -0.00093941f, -0.00391763f, 0.03189227f, -0.02062607f, 0.02947519f, -0.04491499f, 0.00825839f, 
    -0.38669857f, -0.27375826f, 0.64205807f, 0.09958677f, -0.01154851f, -0.09029705f, 0.25134948f, 0.08156161f, 
    0.02521557f, -0.11139772f, 0.04975079f, -0.33083281f, -0.12659509f, 0.20616053f, 0.01245942f, 0.02445282f, 
    0.14020814f, 0.10316920f, 0.15969911f, 0.01057211f, -0.31101960f, 0.08725924f, 0.16453195f, 0.01290667f, 
    0.14698498f, -0.06991865f, 0.03010179f, 0.02899078f, 0.00394989f, -0.16668826f, -0.09791923f, -0.22676617f, 
    0.20754611f, 0.15915480f, 0.12332223f, -0.05487929f, 0.41222966f, 0.01561441f, -0.02351419f, -0.14757285f, 
    -0.23942262f, -0.24722917f, 0.12225828f, -0.08265051f, 0.00333919f, -0.30746937f, 0.10231639f, -0.44505861f, 
    -0.17325149f, -0.19285586f, 0.03443630f, -0.09467866f, 0.27475673f, -0.14817382f, -0.08663905f, -0.21078542f, 
    -0.17059796f, 0.05688715f, -0.10638940f, 0.05737158f, 0.07805818f, -0.31307364f, -0.01544855f, 0.25446817f, 
    0.04854966f, 0.19475211f, 0.11769468f, 0.23644824f, 0.00071975f, -0.20125145f, 0.01057936f, 0.01367777f, 
    -0.58160567f, -0.45782638f, -0.00877508f, 0.13069294f, 0.32495198f, 0.12611198f, 0.12766571f, -0.02446683f, 
    -0.09679372f, -0.12904057f, -0.81570882f, -0.27395508f, -0.04124048f, 0.01967702f, 0.01323592f, -0.12552349f, 
    -0.21686071f, -0.13636194f, 0.06383660f, -0.08224557f, 0.21382202f, -0.18245244f, 0.11195172f, -0.03436473f, 
    -0.07678807f, 0.13627596f, -0.06986925f, -0.03152184f, -0.22596805f, 0.04115392f, 0.07842869f, 0.08264931f, 
    0.17277007f, -0.25747859f, 0.04047110f, -0.19903541f, -0.04197342f, -0.05470708f, 0.10530698f, -0.01416551f, 
    -0.02274322f, 0.18399753f, -0.12600978f, -0.07309324f, 0.01534313f, 0.12517315f, 0.23410018f, -0.02024265f, 
    0.04900550f, -0.07649900f, 0.13119254f, -0.01181935f, -0.20426533f, 0.20608309f, -0.53782338f, -0.16316386f, 
    -0.28301600f, 0.03573332f, 0.09364324f, -0.17556281f, 0.01732581f, -0.09487970f, -0.21002831f, -0.32881370f, 
    -0.42610472f, -0.36472687f, -0.14283428f, -0.04453897f, -0.23954457f, 0.01981341f, -0.01121099f, -0.09051424f, 
    0.31251091f, 0.05163576f, 0.36607316f, 0.15709171f, 0.00617553f, 0.17495576f, 0.13203797f, 0.09125201f, 
    -0.10160199f, -0.01811347f, -0.07506597f, 0.28030851f, -0.01674213f, -0.04321599f, 0.12416050f, 0.00495876f, 
    0.13784629f, -0.14663352f, 0.24381956f, 0.25192568f, 0.20048973f, 0.09061231f, -0.01209530f, -0.09956296f, 
    0.08546369f, -0.06372830f, 0.06109983f, 0.25673953f, -0.24786147f, 0.10606709f, -0.06650824f, 0.19907653f, 
    0.13661864f, 0.14545143f, 0.25958258f, 0.19883299f, 0.42096195f, 0.16297252f, -0.14607143f, 0.13336261f, 
    0.00547608f, 0.00387956f, -0.03864558f, -0.19686021f, 0.14226252f, 0.15973943f, 0.11485586f, 0.30326661f, 
    0.16416401f, 0.13515604f, 0.17525768f, 0.15315165f, 0.04554611f, -0.05440004f, -0.20040941f, -0.33390373f, 
    -0.25691918f, -0.04595310f, 0.05728667f, 0.07927297f, 0.00445761f, -0.14321488f, -0.31858113f, 0.05957656f, 
    0.03332961f, 0.06989447f, -0.07149602f, 0.14751144f, -0.12573650f, 0.27724952f, 0.17423818f, 0.21974754f, 
    -0.26817426f, 0.10822459f, -0.07247107f, -0.22367266f, 0.13790092f, -0.19752832f, 0.09619294f, -0.29515815f, 
    0.11369170f, 0.10800927f, -0.33204326f, -0.52446276f, -0.13699606f, -0.01660116f, -0.19389908f, 0.06124955f, 
    -0.04974484f, 0.07525878f, -0.04735434f, 0.41229984f, 0.17861290f, -0.05709740f, 0.34961504f, 0.09024321f, 
    0.30926770f, -0.02814033f, 0.14448921f, 0.01878082f, -0.26577467f, -0.14437769f, -0.00654172f, 0.22661954f, 
    -0.26787034f, 0.06848294f, -0.14187068f, -0.19204916f, 0.30156115f, 0.19144806f, 0.39347845f, -0.14863475f, 
    -0.09360247f, 0.12239615f, 0.13653836f, 0.12057979f, 0.08858353f, -0.32547742f, 0.09232256f, 0.04974290f, 
    -0.34912026f, 0.16228780f, -0.04039387f, -0.07453679f, 0.00581162f, -0.06877011f, -0.03268357f, 0.25335401f, 
    -0.11150303f, -0.08338514f, 0.03108384f, 0.28849667f, -0.04159987f, 0.11383189f, 0.13151108f, -0.04004854f, 
    0.10185760f, -0.38048285f, -0.18070421f, 0.19617267f, 0.13770531f, 0.15485562f, -0.27501073f, -0.01084937f, 
    -0.03138769f, 0.38299242f, -0.16152669f, 0.04978298f, -0.13354923f, 0.26865938f, 0.14800376f, 0.05792772f, 
    0.11766873f, -0.27645645f, -0.32075381f, 0.30318198f, -0.02895698f, 0.11129251f, -0.00360342f, -0.02181670f, 
    0.08590910f, 0.02627070f, -0.30768636f, 0.14068356f, 0.28703466f, 0.11535813f, 0.06957604f, 0.05194189f, 
    -0.19003329f, 0.15819895f, -0.34998232f, -0.28834161f, 0.09088098f, 0.01049828f, 0.14357498f, 0.02398503f, 
    -0.21964198f, 0.00706188f, 0.05981256f, 0.09135187f, -0.24828430f, 0.02709725f, -0.36973354f, 0.04504538f, 
    0.07469082f, 0.10634694f, -0.10166015f, 0.02093234f, 0.13453968f, -0.50165498f, -0.44316086f, 0.56306434f, 
    0.01725822f, 0.11771978f, -0.22607529f, -0.06605550f, 0.03995192f, -0.07477624f, -0.34631941f, -0.26249048f, 
    0.11873926f, 0.02993001f, 0.01197014f, 0.22535288f, -0.06239144f, -0.18867001f, -0.02017479f, -0.11836157f, 
    0.00376177f, -0.28412005f, 0.28896827f, 0.06962337f, -0.00440875f, -0.04365463f, -0.02025159f, 0.02660642f, 
    -0.24189812f, -0.23120232f, 0.34203592f, -0.05248544f, 0.13873981f, 0.01596355f, -0.05132399f, -0.13306879f, 
    0.11935468f, 0.42444718f, 0.01696604f, 0.12140746f, -0.27893093f, -0.16777919f, 0.01141919f, -0.05905207f, 
    0.07016203f, 0.07699098f, 0.23081574f, 0.14008905f, 0.14231920f, 0.07563946f, -0.15840799f, -0.17966107f, 
    0.11956955f, 0.13889469f, -0.09998811f, -0.19575982f, -0.04810921f, -0.08993175f, -0.03803000f, 0.18971018f, 
    -0.01068741f, 0.27284729f, -0.09566408f, 0.29631978f, -0.41647202f, -0.22813228f, -0.14965037f, 0.18588020f, 
    -0.04703550f, 0.10231937f, 0.10265687f, 0.08596761f, 0.10860820f, 0.10978628f, 0.03317836f, -0.17843343f, 
    0.23929799f, 0.04220163f, -0.05222713f, -0.01894927f, -0.01537295f, -0.02762901f, -0.00881590f, 0.14923102f, 
    0.22357716f, 0.01908596f, -0.18036254f, -0.05209664f, -0.01766844f, 0.03844062f, -0.13133724f, 0.00891971f, 
    -0.05012425f, 0.13523267f, 0.10301672f, -0.14950605f, -0.13518415f, -0.04990710f, 0.24331783f, -0.06963514f, 
    -0.25259575f, 0.11061632f, -0.05694872f, 0.04011388f, -0.07163626f, -0.09496240f, -0.23498069f, 0.02291534f, 
    -0.11878037f, 0.11725292f, 0.28342280f, -0.06988271f, 0.06267554f, -0.01139602f, -0.04109787f, -0.16750030f, 
    0.23796928f, 0.20029309f, -0.21777876f, 0.21350354f, -0.08542485f, 0.08799815f, 0.10365031f, 0.03305333f, 
    0.01377976f, 0.07190148f, 0.13903284f, 0.11585556f, -0.51429796f, -0.23252620f, 0.23587906f, 0.02725218f, 
    0.20386377f, 0.15693887f, -0.06626081f, 0.30722019f, 0.16810249f, 0.08580077f, -0.27917036f, -0.00148783f, 
    0.03424308f, 0.12427344f, 0.12576543f, -0.02544685f, 0.25689909f, -0.00148017f, 0.30893046f, -0.07487235f, 
    -0.08759815f, 0.04758561f, -0.22883525f, -0.09319786f, 0.04116577f, 0.14581467f, 0.02032923f, -0.24579798f, 
    0.21654341f, 0.11465189f, -0.07468121f, -0.10687928f, -0.22290812f, 0.09361687f, -0.05722609f, 0.04696603f, 
    -0.14230676f, -0.56362247f, -0.09764478f, -0.17098521f, -0.10572240f, -0.01422114f, -0.09871674f, 0.05627428f, 
    -0.06420851f, 0.03628685f, 0.05118262f, 0.19082254f, 0.02997038f, -0.03604586f, -0.26254046f, 0.10635665f, 
    -0.10176840f, -0.53706425f, -0.08286550f, -0.43363652f, 0.32538721f, 0.20858228f, 0.16972789f, -0.02358601f, 
    0.06085557f, -0.15544163f, -0.16743191f, 0.12373549f, -0.03389372f, 0.01721314f, 0.13959444f, -0.03840264f, 
    -0.04305796f, 0.08918463f, -0.00103817f, -0.31639731f, -0.22255003f, -0.03179425f, 0.10443916f, -0.13430475f, 
    -0.03046994f, 0.08781838f, -0.08022725f, -0.10733990f, -0.04454499f, 0.25611278f, -0.04615659f, 0.24663799f, 
    -0.08915159f, -0.06503710f, -0.23396456f, 0.14886749f, 0.23481347f, -0.82319403f, -0.27322158f, 0.48311719f, 
    0.14801174f, 0.06598721f, -0.03071250f, -0.01108944f, 0.02805205f, 0.15845221f, -0.05005051f, -0.05958535f, 
    -0.14273703f, 0.20425694f, -0.12976095f, 0.02455896f, 0.04490744f, 0.02125732f, -0.06855386f, -0.09094807f, 
    -0.06209419f, 0.06441544f, -0.13065343f, -0.01006081f, -0.03238390f, -0.05213397f, -0.04156415f, -0.16397510f, 
    -0.02686208f, -0.02858568f, -0.05782685f, -0.04519178f, 0.00581572f, 0.05164008f, -0.00050125f, 0.03967771f, 
    0.00394351f, -0.00793556f, 0.05253203f, -0.04064256f, -0.00467198f, -0.05687679f, -0.02337179f, -0.01358807f, 
    0.01750397f, -0.06159940f, -0.01424533f, 0.03910172f, -0.04639598f, 0.01156048f, -0.03786203f, 0.04176921f, 
    -0.03001924f, 0.02541585f, -0.06975614f, -0.00581176f, -0.02404637f, 0.00028494f, -0.03820920f, 0.01005019f, 
    0.00989457f, -0.00696469f, 0.00185005f, -0.00318219f, 0.01478912f, 0.02379064f, 0.04021375f, 0.00661835f, 
    -0.04278798f, 0.00673524f, 0.00152051f, 0.00456933f, 0.02107532f, -0.01053559f, 0.02838995f, 0.04054716f, 
    -0.04613024f, 0.03672847f, -0.04929956f, -0.05417202f, -0.05921742f, -0.04405871f, -0.04947232f, 0.00677845f, 
    0.02604826f, -0.04991444f, -0.00994467f, 0.01593248f, -0.02729556f, -0.02664962f, -0.01319893f, -0.00256014f, 
    0.03039528f, 0.03752890f, 0.01340375f, -0.01272048f, -0.05722149f, 0.02192388f, -0.05552515f, 0.02006545f, 
    -0.03802309f, 0.01418494f, -0.05417489f, 0.02258569f, -0.00659456f, -0.02568117f, -0.05640027f, -0.02621149f, 
    -0.02789414f, 0.03822672f, 0.01307163f, 0.03360197f, -0.02594157f, 0.00128598f, 0.05385643f, -0.03972745f, 
    -0.00685812f, -0.02002290f, 0.04181688f, 0.03078057f, -0.06832059f, 0.03371256f, 0.02806276f, 0.03878428f, 
    -0.01515589f, -0.05596669f, 0.02669606f, -0.00481959f, -0.02449444f, 0.04783388f, 0.00131832f, 0.00942155f, 
    -0.00916829f, 0.03767668f, 0.04627382f, 0.00122196f, 0.01982184f, -0.03035865f, -0.05777042f, 0.01373095f, 
    -0.01462869f, 0.01072693f, 0.03236119f, -0.00402021f, -0.00111085f, -0.06199943f, -0.00773221f, 0.02303098f, 
    0.00459545f, 0.02367700f, -0.01615142f, -0.02300717f, -0.05308338f, 0.03619483f, -0.02086135f, -0.01072654f, 
    -0.05814002f, -0.01187898f, 0.03299247f, 0.05561796f, -0.04691691f, 0.04402143f, 0.02283238f, 0.04888595f, 
    -0.06087551f, -0.05488793f, -0.04626642f, 0.03792175f, 0.03403981f, 0.02084939f, 0.01836669f, -0.05780402f, 
    -0.04678598f, 0.00841600f, -0.04968501f, -0.00092334f, -0.03735954f, 0.02771907f, -0.00904626f, 0.04566360f, 
    0.03212626f, -0.05856885f, -0.04001927f, 0.01658332f, -0.05746114f, -0.01353019f, 0.01633457f, -0.02146158f, 
    0.00404218f, 0.01814161f, -0.00010497f, -0.04592542f, -0.02162818f, 0.01485344f, -0.06839690f, -0.00952904f, 
    0.00921890f, 0.03460217f, -0.06110920f, -0.00325212f, -0.03010803f, -0.01719219f, 0.03456393f, 0.00919522f, 
    -0.01118667f, -0.01341491f, 0.03755539f, 0.03581822f, 0.01649707f, -0.04100022f, 0.03789496f, -0.02363917f, 
    -0.02894383f, 0.01318051f, -0.02740756f, -0.03641163f, -0.01500246f, -0.05182179f, 0.03937332f, -0.03066313f, 
    -0.06745780f, 0.04756366f, 0.02493336f, -0.04579917f, 0.04942057f, -0.00693050f, 0.02636652f, -0.00585040f, 
    -0.04591415f, -0.05849657f, -0.03551592f, -0.00867636f, -0.01501397f, -0.02737430f, 0.00205836f, 0.02335696f, 
    0.04690287f, 0.00506739f, -0.00204053f, -0.00811888f, -0.05084755f, -0.05316650f, 0.03734729f, -0.00265302f, 
    0.06163719f, 0.01628804f, -0.03255633f, -0.04908782f, 0.04670548f, 0.02170216f, -0.01705191f, -0.01407954f, 
    -0.03197901f, 0.03699257f, 0.03852447f, -0.02913676f, -0.03348960f, 0.04186716f, 0.03411067f, -0.04388987f, 
    -0.05484099f, 0.04239850f, 0.00501486f, 0.03192899f, 0.01257610f, -0.00268391f, 0.01761006f, -0.04952094f, 
    -0.05775212f, -0.04586399f, -0.02617625f, 0.03339701f, 0.03948543f, -0.05097244f, 0.01819235f, 0.01252400f, 
    0.00152391f, -0.00944814f, 0.03795568f, 0.01987376f, -0.05045770f, 0.00882622f, 0.03451975f, -0.06986529f, 
    -0.05101465f, 0.01990233f, -0.00357222f, 0.01904089f, -0.02300191f, -0.03113864f, -0.02607849f, -0.03919899f, 
    -0.02485441f, -0.02715827f, -0.02047966f, 0.01709329f, -0.05091703f, 0.04310708f, 0.06044456f, -0.00045564f, 
    -0.02032417f, -0.03608131f, -0.03318985f, -0.05054150f, 0.00740913f, 0.03867991f, 0.00739876f, 0.02220757f, 
    -0.04762455f, 0.01285297f, -0.01196608f, -0.04244011f, -0.03970363f, 0.02963965f, -0.06588703f, 0.02882868f, 
    -0.00356412f, -0.00536937f, -0.01277091f, 0.02325794f, -0.01234886f, 0.03837718f, 0.02852090f, 0.04608214f, 
    0.00768402f, 0.00204483f, 0.04109277f, 0.04319905f, -0.05799155f, -0.02205504f, 0.03565744f, -0.01661845f, 
    0.03567682f, -0.06808359f, 0.05820464f, -0.04674705f, -0.00274556f, -0.03282612f, -0.03651180f, -0.01473717f, 
    0.01838690f, -0.02321686f, -0.04429219f, -0.05595730f, 0.04126325f, -0.02046563f, -0.05330107f, 0.00683704f, 
    0.01143107f, -0.01812590f, -0.06500439f, -0.02793542f, -0.05946638f, -0.01879163f, -0.00129394f, -0.03264546f, 
    0.02121631f, 0.04541165f, 0.01230285f, -0.00529246f, 0.01127180f, -0.01378520f, 0.01374102f, -0.02578802f, 
    -0.02780163f, -0.03062147f, -0.01719230f, -0.05392933f, -0.03492033f, -0.03459197f, -0.01671599f, -0.02650090f, 
    -0.00182128f, -0.05464526f, -0.05082430f, -0.02353262f, -0.04158848f, 0.02113082f, -0.04835588f, -0.01931867f, 
    -0.00929848f, -0.00419828f, 0.04739319f, -0.03032573f, -0.00972415f, 0.02439090f, 0.02722766f, -0.00984711f, 
    -0.03045169f, 0.00036857f, -0.03968112f, -0.03344185f, -0.03504293f, -0.06613787f, -0.01816307f, 0.04077178f, 
    0.03507080f, -0.02451377f, 0.04083419f, -0.04081894f, 0.00809255f, 0.03424045f, -0.06258710f, 0.00235843f, 
    -0.05936674f, -0.00065062f, -0.03735572f, 0.03550692f, -0.02315440f, 0.00847074f, 0.03381823f, 0.02715311f, 
    0.02941871f, -0.05307139f, -0.01080716f, -0.05636363f, -0.00905570f, 0.00916281f, 0.02979676f, 0.01381768f, 
    -0.05951146f, -0.03103390f, -0.05565530f, 0.04806994f, -0.02171322f, 0.02245385f, -0.04744985f, -0.02964798f, 
    -0.00826855f, -0.06030938f, 0.00367310f, -0.01947840f, -0.00068708f, 0.01353505f, -0.00310421f, -0.02780422f, 
    0.00735560f, -0.04998228f, 0.00867372f, -0.05842628f, -0.00248037f, -0.03094259f, -0.06662714f, 0.03118307f, 
    -0.00443077f, -0.04102846f, -0.04094752f, -0.05250854f, 0.04007706f, 0.00094723f, -0.05456820f, 0.01980785f, 
    -0.02964730f, 0.02214840f, -0.05439391f, 0.02958140f, -0.04605363f, 0.02769245f, -0.06978703f, -0.02962776f, 
    0.02824471f, 0.02657287f, 0.02330119f, -0.06524043f, -0.06346533f, -0.05218969f, 0.03925224f, -0.06396922f, 
    -0.04985731f, 0.02864868f, 0.02827928f, 0.01919754f, 0.02795240f, 0.01840254f, -0.06256117f, -0.02292022f, 
    0.01514116f, -0.04357122f, -0.03836191f, 0.02274077f, -0.04231795f, -0.04155565f, 0.03676151f, 0.04165882f, 
    -0.00964198f, -0.03155127f, 0.04094765f, -0.01727227f, 0.01306380f, -0.05980383f, 0.00720218f, -0.00652373f, 
    -0.00618168f, -0.02784499f, -0.04770819f, -0.03509751f, -0.03256769f, 0.02497271f, 0.04307997f, -0.02178408f, 
    -0.04525423f, -0.01738189f, 0.02980898f, 0.02812056f, -0.05557054f, -0.03394807f, 0.02096703f, -0.00533373f, 
    0.00046291f, -0.06070173f, -0.05972907f, 0.02684114f, -0.00428130f, 0.01782953f, -0.00403396f, 0.03439249f, 
    -0.01693235f, -0.00049927f, -0.04796589f, 0.04464003f, 0.03082256f, -0.03881302f, -0.02951220f, -0.03501067f, 
    -0.02236007f, -0.07433213f, -0.05873502f, 0.00248125f, -0.05929054f, 0.01612997f, -0.05510930f, -0.00530985f, 
    -0.00648512f, 0.04051235f, 0.00356239f, -0.06299482f, -0.00999948f, 0.00135186f, -0.06144508f, 0.01851089f, 
    0.03937879f, 0.03639021f, -0.02424430f, 0.03844886f, -0.04777947f, 0.02727878f, 0.02934887f, -0.01538838f, 
    -0.03230867f, -0.00566766f, -0.02569840f, -0.04394528f, 0.01374904f, -0.03668826f, -0.01778866f, -0.02298586f, 
    0.04515772f, 0.05556346f, -0.02789688f, -0.00593101f, 0.03556980f, -0.03471485f, 0.05149689f, 0.01824327f, 
    0.01971710f, -0.02370427f, -0.01537281f, -0.04101163f, -0.04528242f, -0.00514990f, -0.07082958f, 0.03722569f, 
    -0.03112145f, -0.05882178f, 0.01043889f, 0.01787579f, 0.04124773f, 0.04175019f, 0.05549455f, 0.03799476f, 
    -0.04320518f, 0.01003776f, 0.04990779f, 0.00273414f, -0.05830364f, 0.00271914f, -0.00636489f, 0.03647204f, 
    0.03392627f, 0.01337207f, -0.03296970f, -0.04539083f, 0.02299531f, -0.02203798f, -0.00848900f, -0.06205565f, 
    -0.02596375f, -0.02999382f, 0.00481656f, 0.03249224f, -0.02565660f, -0.03312147f, 0.04151153f, 0.03671999f, 
    -0.03792508f, -0.30805561f, 0.21763703f, -0.11440834f, -0.23207796f, -0.21291964f, 0.00498890f, 0.10644559f, 
    -0.02124431f, -0.60529685f, 0.00746372f, 0.07841434f, 0.20878419f, 0.02853350f, 0.08979604f, 0.02506475f, 
    0.12702170f, -0.01181866f, 0.08994184f, 0.16703118f, 0.21762997f, -0.18653247f, -0.08819524f, 0.08531134f, 
    -0.24529971f, 0.03602516f, 0.04056658f, 0.42361945f, -0.42601612f, -0.18219130f, -0.21746542f, -0.13828628f, 
    -0.20392662f, 0.03203787f, 0.12884076f, 0.03420702f, 0.48782665f, 0.15815406f, -0.32350802f, -0.33757606f, 
    0.07233520f, -0.10114828f, 0.06450171f, -0.02332214f, 0.01398754f, -0.68106604f, -0.10967933f, -0.03223288f, 
    0.29565522f, 0.08373930f, -0.12308233f, 0.07525975f, 0.04416596f, 0.01492107f, -0.02039557f, -0.48891327f, 
    0.06108713f, 0.13311695f, 0.07598569f, 0.02519686f, 0.01936349f, -0.07716202f, -0.09214179f, -0.32212627f, 
    -0.00285979f, 0.14789042f, -0.07572188f, 0.03233254f, 0.00289694f, 0.07156939f, 0.00624021f, -0.20777157f, 
    -0.11195635f, -0.20558037f, -0.28452563f, 0.23313807f, 0.06812386f, -0.04287851f, -0.01993196f, -0.11464034f, 
    -0.13426343f, -0.34196347f, 0.20312110f, -0.00692897f, 0.14534673f, -0.32144684f, 0.13473316f, -0.23119269f, 
    -0.03788823f, 0.15234827f, -0.52781337f, 0.04261989f, 0.05333687f, 0.15402833f, -0.11884646f, 0.01703310f, 
    -0.10607520f, 0.17195286f, -0.12344684f, 0.21707575f, 0.31956166f, -0.17065245f, 0.15663613f, -0.06502760f, 
    -0.01659484f, -0.08895371f, -0.05591476f, -0.02340974f, 0.00246311f, -0.01503962f, 0.14479323f, 0.03399132f, 
    -0.01696242f, -0.14567776f, -0.08767207f, 0.07062462f, 0.04205137f, 0.07876177f, 0.13322781f, 0.18846795f, 
    -0.13043348f, 0.00183980f, 0.18373001f, -0.00313629f, -0.08310789f, 0.01950672f, 0.10676590f, 0.14978361f, 
    -0.24820146f, -0.08014059f, -0.05366766f, -0.03601337f, 0.00053428f, 0.25928721f, 0.07776731f, 0.16431201f, 
    -0.41504636f, -0.19689226f, 0.04152424f, 0.27508384f, -0.02899382f, 0.00938138f, -0.14951983f, 0.06578451f, 
    -0.06809566f, 0.12636416f, 0.28428331f, 0.04688152f, 0.03726519f, -0.24156658f, -0.02238397f, 0.04978209f, 
    0.14874268f, -0.42415830f, -0.05228273f, 0.02474473f, -0.01643963f, 0.06341289f, -0.10521995f, 0.18749671f, 
    -0.03481843f, 0.00740936f, -0.33848324f, -0.00422117f, 0.31033897f, 0.00908626f, -0.00837059f, 0.02764287f, 
    0.03197377f, 0.15800920f, -0.15333702f, 0.05788198f, -0.10964419f, -0.29139206f, 0.12635522f, -0.06363466f, 
    0.34341693f, 0.00497481f, 0.06670063f, 0.08075075f, -0.02617853f, 0.18865399f, 0.11283477f, -0.18567398f, 
    0.23587725f, 0.24782905f, 0.31890613f, -0.14399673f, 0.01368787f, 0.32913020f, 0.03355744f, 0.00403344f, 
    0.03138196f, 0.03199407f, 0.02091121f, 0.21401002f, -0.06076949f, 0.02970627f, -0.03691566f, 0.03709880f, 
    -0.17369589f, 0.07842927f, 0.05641610f, 0.10098379f, 0.05681057f, -0.05336649f, -0.00458787f, 0.03168497f, 
    0.31021100f, 0.14327551f, -0.03811549f, 0.20024154f, -0.17297643f, 0.00747124f, 0.16824304f, 0.07601197f, 
    0.18101008f, -0.00248332f, -0.49527660f, -0.18456352f, -0.12699151f, -0.20812872f, 0.03027724f, 0.01135571f, 
    -0.32831347f, -0.00968994f, -0.23723437f, -0.04514600f, -0.06006822f, 0.07554112f, -0.13601331f, -0.01708628f, 
    -0.01993512f, -0.00599230f, 0.24758376f, -0.09838931f, 0.29170495f, 0.27269205f, 0.14003128f, 0.21613033f, 
    -0.05288927f, 0.07089192f, -0.17693034f, 0.03077651f, -0.00585843f, 0.19245535f, 0.13090175f, 0.02999699f, 
    -0.08877753f, 0.17522222f, -0.13397463f, -0.12030713f, -0.02368665f, -0.25820035f, 0.05143031f, -0.12481913f, 
    -0.14928508f, -0.15574539f, -0.06667018f, 0.00450470f, 0.01685550f, -0.58583850f, -0.12272374f, -0.07435939f, 
    0.27144316f, 0.28625393f, -0.06855638f, 0.05853642f, 0.05534495f, -0.13195421f, 0.03038908f, 0.08796775f, 
    0.19800547f, -0.32806486f, 0.01506704f, 0.19562207f, 0.03125902f, -0.02124430f, -0.04718218f, -0.29677242f, 
    0.19657667f, 0.18467842f, 0.06301287f, 0.10365386f, 0.01381169f, 0.10613068f, -0.00544255f, -0.12135839f, 
    -0.01925079f, -0.03640759f, 0.04508919f, -0.06302344f, -0.03850256f, -0.01575477f, -0.06072034f, -0.01695460f, 
    0.04071927f, -0.00574589f, 0.02839700f, 0.05358912f, 0.04995207f, -0.01243525f, -0.04843086f, -0.05256205f, 
    -0.04860477f, 0.04837023f, 0.05336692f, -0.01395166f, -0.05895856f, -0.02592167f, 0.03506874f, 0.04188546f, 
    0.01398690f, -0.02402787f, -0.01966786f, 0.01638716f, 0.01024836f, -0.02747230f, -0.03906834f, -0.02038056f, 
    -0.05236780f, -0.00185736f, -0.06104918f, -0.03314628f, 0.03828831f, 0.01936341f, 0.00598354f, 0.04218654f, 
    -0.01053630f, 0.03678412f, 0.00681106f, 0.01549383f, -0.03999819f, -0.01335104f, -0.00215063f, -0.06736506f, 
    0.05563272f, -0.04000222f, 0.05105928f, 0.03984897f, 0.04911968f, 0.00650838f, -0.02444438f, 0.01195889f, 
    0.00405420f, -0.04311436f, -0.00126417f, 0.05040643f, 0.01401285f, 0.04595867f, 0.05389351f, -0.00860783f, 
    -0.04768966f, -0.00697829f, -0.06197904f, -0.01658359f, -0.05055106f, -0.06389502f, 0.01887407f, -0.06889253f, 
    0.00511994f, 0.02647575f, -0.06656425f, 0.00657077f, -0.03950956f, -0.03640462f, -0.02832188f, -0.05332027f, 
    -0.06131506f, -0.00691444f, 0.00872838f, 0.04444413f, 0.02592611f, 0.02923040f, 0.01525476f, -0.04969208f, 
    0.01428646f, 0.00452519f, -0.01020629f, -0.00918820f, -0.03474658f, -0.01048637f, 0.01076234f, -0.02167418f, 
    -0.05813328f, -0.00611413f, 0.03153104f, 0.01116973f, -0.00460592f, -0.05678487f, -0.00244402f, -0.01986942f, 
    0.00735339f, -0.05247759f, 0.04261850f, -0.03668433f, 0.01170149f, 0.02545564f, 0.04192924f, -0.05777683f, 
    0.02247461f, -0.05860041f, -0.02924384f, -0.04924012f, 0.01579597f, 0.05330038f, 0.00858803f, 0.04218487f, 
    0.02975393f, 0.05431180f, -0.05633858f, 0.03465043f, -0.03261972f, 0.00826453f, -0.05685025f, 0.00370112f, 
    0.02750744f, -0.04604030f, 0.05564880f, -0.00336026f, -0.01124173f, 0.03933315f, -0.01626349f, 0.02382927f, 
    -0.00278257f, -0.03678669f, -0.03187389f, 0.05131372f, 0.04111662f, -0.00003382f, 0.01625708f, 0.01407400f, 
    -0.02407255f, -0.06214905f, 0.03124500f, -0.01358247f, -0.05660884f, -0.06570451f, 0.01903357f, -0.03574098f, 
    0.02174205f, -0.05391745f, -0.01182607f, -0.01677108f, -0.02911085f, -0.00226525f, 0.04678909f, -0.06017321f, 
    -0.03688235f, 0.00430594f, 0.01053442f, 0.01518987f, -0.01955119f, -0.02532031f, 0.02148387f, -0.05379397f, 
    0.01501029f, 0.02170736f, 0.01950748f, -0.01061083f, 0.01036749f, -0.04812463f, -0.05043358f, -0.04312155f, 
    0.02244007f, 0.00977803f, 0.04411775f, 0.04826055f, 0.01040731f, -0.05542101f, -0.06354808f, 0.04397521f, 
    -0.06326653f, -0.03367504f, 0.01326803f, 0.00120901f, -0.04568984f, 0.04016416f, 0.05904477f, -0.03720630f, 
    -0.04263305f, 0.02157858f, -0.03361100f, -0.06316903f, 0.04402001f, 0.00461386f, -0.04385836f, -0.02712855f, 
    0.05553027f, 0.01109088f, -0.04244970f, -0.02840754f, -0.05455796f, 0.02922141f, 0.03421918f, -0.00098710f, 
    0.04643324f, -0.00966132f, 0.02916273f, -0.03763813f, -0.02376098f, 0.01194399f, 0.01675296f, 0.01665090f, 
    -0.05660075f, -0.00996148f, 0.03917075f, -0.03357086f, 0.01117584f, -0.02275156f, -0.05327104f, -0.00781282f, 
    -0.03596834f, -0.05471374f, -0.03393504f, 0.04954423f, 0.00474409f, 0.02079867f, -0.03779374f, 0.05076692f, 
    0.02328157f, 0.01249128f, -0.04209577f, 0.04721361f, 0.03112239f, -0.02447460f, -0.00073392f, -0.03920681f, 
    -0.05301059f, 0.04193815f, -0.04645803f, 0.03081411f, 0.01082946f, 0.00693652f, -0.02991422f, -0.03666142f, 
    0.04913005f, -0.03094103f, 0.03100078f, -0.00314268f, -0.03405043f, 0.03204521f, 0.04920037f, 0.04894155f, 
    -0.05042327f, -0.03410890f, 0.03043410f, -0.03420347f, -0.03316400f, -0.04162075f, -0.04539979f, 0.03444663f, 
    -0.02813034f, -0.02121175f, 0.00056538f, -0.01141543f, 0.06361052f, 0.01348812f, -0.03794491f, 0.03036098f, 
    -0.01767967f, 0.01049429f, -0.02228452f, -0.02484496f, -0.04893626f, -0.02059624f, -0.05230531f, -0.02801926f, 
    0.04457410f, 0.03857633f, -0.03253167f, -0.05073750f, -0.01449104f, -0.03299288f, -0.02537704f, -0.00027346f, 
    -0.03678440f, 0.00998837f, 0.00101166f, -0.00760048f, 0.03342904f, -0.02742874f, -0.04429954f, -0.02790322f, 
    -0.01516330f, 0.02689948f, -0.04080348f, -0.00596942f, 0.02795200f, -0.06759060f, -0.01607019f, 0.01554500f, 
    -0.00583178f, 0.04082597f, -0.06487056f, -0.03588405f, -0.02087421f, 0.04618036f, -0.06755276f, 0.02453991f, 
    -0.03782858f, -0.07039561f, -0.00565941f, 0.02665266f, 0.04018251f, -0.00420500f, -0.00477684f, -0.05090920f, 
    0.01512719f, -0.04984299f, -0.00597117f, -0.01393682f, 0.02818866f, -0.02435114f, 0.01281673f, 0.01574999f, 
    0.00383930f, -0.03164626f, 0.01561920f, -0.00532943f, -0.02203989f, -0.03192272f, 0.03973601f, -0.03300198f, 
    -0.00789712f, 0.02539472f, 0.04637967f, -0.06243807f, 0.01206453f, -0.05411706f, -0.02539594f, -0.04583911f, 
    0.00339239f, -0.03402631f, -0.01214658f, -0.03401795f, 0.04052700f, 0.04846353f, -0.00963799f, 0.01566949f, 
    -0.05755692f, 0.01503569f, 0.02659866f, 0.01220148f, 0.00862232f, -0.03336922f, 0.01546112f, -0.05912488f, 
    0.03017057f, -0.03749441f, -0.02965003f, -0.03251400f, 0.04967641f, -0.01277560f, 0.02421364f, -0.04918391f, 
    0.04472603f, 0.02145539f, 0.01478621f, -0.00583785f, 0.03054904f, -0.03810344f, -0.06078289f, 0.03379287f, 
    -0.06317698f, 0.03002445f, 0.01606392f, -0.02708676f, 0.04445893f, 0.03975814f, -0.00334353f, -0.01227558f, 
    0.03727940f, -0.04171713f, 0.04059093f, 0.03063581f, -0.04005926f, -0.05638409f, 0.00998207f, 0.04498659f, 
    -0.03082078f, 0.04803548f, -0.00154437f, -0.04908687f, -0.02871462f, -0.02465406f, 0.04950159f, 0.02217922f, 
    0.00627907f, -0.04998315f, 0.03744013f, -0.06753763f, 0.03139422f, 0.03906943f, -0.05523826f, -0.06706750f, 
    -0.00868022f, -0.04407009f, 0.03696407f, -0.01684948f, -0.02413735f, -0.00412617f, -0.05031534f, 0.01418594f, 
    0.02100023f, -0.04695087f, -0.04669031f, -0.03458296f, 0.04147055f, -0.06640765f, -0.06600890f, 0.03786835f, 
    0.05022140f, -0.02896704f, -0.00497319f, -0.04530948f, -0.06470989f, -0.01486974f, -0.02035803f, 0.03065760f, 
    0.03157979f, -0.00803000f, -0.05121602f, 0.00150969f, 0.04073434f, 0.03142196f, -0.01101142f, -0.05036879f, 
    0.04053085f, 0.00521762f, -0.02485345f, -0.01655403f, 0.04537642f, -0.04236129f, 0.04202145f, -0.00198338f, 
    -0.01250070f, 0.02867080f, -0.06761912f, -0.02584195f, -0.05403552f, 0.01837360f, 0.00001422f, 0.01346852f, 
    0.01868610f, -0.03304931f, -0.02687391f, -0.06631999f, 0.04927842f, -0.04490544f, -0.02658548f, 0.01045608f, 
    -0.03284292f, 0.01610203f, -0.03183810f, 0.02840383f, 0.01896208f, 0.04863631f, -0.04948839f, -0.00864080f, 
    0.01772143f, -0.05540442f, -0.02398348f, -0.00912114f, 0.02575410f, -0.02103148f, -0.04289620f, -0.04054833f, 
    -0.02566168f, 0.02306147f, 0.03465195f, 0.04244278f, -0.05995322f, 0.02699197f, 0.03866622f, -0.04526554f, 
    0.01385252f, 0.00360795f, -0.01522370f, 0.01615549f, 0.04431793f, 0.02984997f, -0.00623493f, 0.00250083f, 
    -0.01359810f, 0.00033471f, -0.05264364f, -0.01165990f, -0.03513127f, -0.04891388f, -0.02454542f, 0.00726775f, 
    -0.04005664f, -0.01388890f, -0.03674755f, -0.01571603f, 0.02405722f, -0.03769021f, 0.00153701f, -0.04285061f, 
    -0.03521365f, -0.01978608f, -0.00801377f, -0.03452583f, -0.05223592f, 0.01773755f, -0.05602254f, -0.00966611f, 
    -0.00873267f, -0.03207127f, -0.03185418f, -0.02080079f, 0.03208941f, 0.03073035f, 0.01758418f, 0.02274726f, 
    -0.02268596f, 0.04086446f, 0.01831809f, -0.05819419f, 0.05141803f, -0.03422223f, -0.05781191f, -0.02219069f, 
    -0.04318160f, 0.04378732f, 0.04452110f, 0.02785747f, 0.01170729f, -0.04136638f, 0.03047010f, 0.03953173f, 
    -0.04408706f, -0.00574851f, 0.02483649f, -0.02595826f, -0.00940572f, 0.04034691f, -0.05885611f, -0.03078066f, 
    0.02585269f, 0.01758274f, 0.03364947f, 0.03015066f, -0.01087160f, -0.01994840f, -0.00988184f, 0.00304366f, 
    0.02758099f, 0.02805224f, 0.02511517f, -0.04094462f, -0.04675326f, -0.00001902f, 0.01437410f, -0.05114987f, 
    -0.05443296f, 0.01479382f, 0.00095897f, 0.01241796f, 0.04175546f, -0.00942639f, 0.00448995f, 0.02278970f, 
    0.02626038f, -0.00710088f, -0.05526549f, 0.03724309f, -0.04995686f, -0.01325396f, -0.04538597f, 0.01945740f, 
    -0.00473561f, -0.00599797f, -0.05609670f, -0.06649323f, 0.03970729f, -0.03935226f, -0.00452376f, -0.05072823f, 
    -0.01726734f, -0.05663555f, -0.01527270f, -0.00957401f, 0.02873523f, -0.04095489f, 0.04577717f, 0.03764668f, 
    -0.04786196f, 0.02417339f, 0.03098940f, -0.05617429f, 0.04878772f, -0.06743144f, -0.04995986f, 0.02780655f, 
    0.02510157f, -0.05517929f, -0.02335157f, -0.00874877f, -0.03918179f, 0.02174173f, 0.03060476f, 0.03768736f, 
    0.04700801f, -0.06137545f, -0.00827132f, -0.02079788f, -0.01666689f, -0.02486153f, 0.04254017f, -0.04109506f, 
    0.03449104f, -0.04744086f, -0.00199005f, 0.02073765f, 0.04760925f, 0.01438162f, 0.04602408f, -0.06332363f, 
    -0.04599831f, -0.04751284f, -0.05191760f, -0.05623360f, -0.06390750f, 0.01850232f, -0.05316630f, -0.05876484f, 
    -0.05988939f, 0.01277031f, 0.02281842f, -0.05525852f, 0.04635861f, 0.04196306f, -0.00099154f, 0.02996119f, 
    -0.02188689f, -0.02080792f, -0.05125941f, -0.05095921f, 0.03856895f, -0.02796503f, -0.04768411f, -0.02325718f, 
    0.03786743f, -0.05163278f, 0.00547876f, -0.01935110f, -0.06259389f, 0.00263270f, 0.01097239f, 0.02633137f, 
    -0.00856904f, 0.03954663f, 0.00478182f, 0.02726810f, 0.02888789f, -0.02651404f, 0.01840463f, -0.02855558f, 
    0.00190070f, 0.04579112f, 0.03847755f, 0.02066167f, 0.00592226f, -0.01558409f, 0.04912803f, -0.00974939f, 
    0.01526988f, -0.02403353f, -0.02529874f, 0.01693275f, 0.04602055f, -0.04561350f, -0.01374075f, 0.02107152f, 
    -0.04851633f, 0.02045914f, -0.02204682f, -0.05769494f, -0.02864063f, -0.05334947f, 0.02694699f, 0.02637878f, 
    -0.00530150f, -0.01152258f, -0.03729078f, -0.02300492f, -0.04390609f, 0.02046592f, -0.01215072f, -0.01526736f, 
    -0.04716465f, 0.03245021f, -0.02259869f, -0.00022946f, -0.05571294f, -0.04608802f, 0.05133124f, 0.03682178f, 
    -0.03219397f, -0.02194041f, -0.02390819f, 0.00109270f, 0.02786699f, -0.04968455f, -0.01947641f, 0.02222252f, 
    -0.00228579f, 0.03152118f, -0.00854357f, -0.01697700f, 0.05226971f, -0.02357510f, 0.00094055f, -0.05385682f, 
    -0.03212256f, 0.00897823f, 0.04432847f, -0.00587286f, 0.04359448f, 0.00241096f, -0.01897588f, 0.02523126f, 
    0.04610534f, -0.01557969f, -0.05265183f, 0.04031188f, 0.00316154f, -0.00474805f, 0.03684227f, -0.00413148f, 
    0.01008793f, 0.01164080f, 0.00087123f, -0.00557946f, -0.01920953f, -0.06323833f, -0.01310403f, -0.04615533f, 
    -0.03185775f, 0.01458341f, -0.04849274f, -0.01737570f, -0.06468122f, 0.00741564f, 0.00938985f, -0.04501062f, 
    -0.05972674f, -0.00072283f, 0.01557478f, 0.04489693f, -0.06135783f, -0.01139436f, -0.04291775f, 0.03041842f, 
    -0.05724696f, -0.00098739f, 0.04163412f, 0.04575168f, -0.02965895f, -0.03478532f, 0.04422627f, 0.04515943f, 
    0.04728226f, -0.02750484f, 0.00522440f, 0.00620153f, -0.02905426f, -0.05480959f, -0.00293249f, 0.00998299f, 
    -0.03207834f, -0.04677059f, -0.06363729f, -0.01706498f, 0.00849035f, -0.02349538f, 0.04933582f, -0.03034396f, 
    -0.01088399f, -0.01800461f, -0.03850257f, 0.03601892f, -0.00425701f, 0.00169635f, -0.04847517f, -0.05885981f, 
    -0.05205693f, 0.02741849f, 0.01499561f, -0.04852982f, -0.04669327f, -0.04936460f, 0.03243074f, 0.02820474f, 
    0.01533762f, -0.04679960f, -0.01054999f, -0.04714564f, 0.05105516f, -0.00316851f, 0.02807678f, 0.04245225f, 
    0.01337814f, -0.05249403f, 0.00542360f, -0.05724240f, -0.01786964f, -0.05621256f, -0.03543455f, 0.05163417f, 
    0.00508261f, -0.06140525f, -0.01008915f, -0.03764765f, 0.04707251f, 0.02054413f, 0.04764593f, 0.03071810f, 
    0.00213680f, -0.05210387f, 0.00331618f, -0.05916069f, 0.01490180f, 0.00310630f, 0.01613228f, -0.01287890f, 
    -0.02551462f, 0.04653429f, 0.02911245f, -0.03007327f, -0.05189996f, -0.05351227f, 0.04763840f, 0.02548397f, 
    -0.02224926f, -0.01570760f, 0.02104943f, -0.02572931f, 0.01449711f, -0.05653642f, -0.03785817f, -0.01946665f, 
    -0.00483619f, -0.05858986f, 0.02447519f, -0.06842961f, 0.01886068f, 0.04978275f, 0.00158968f, 0.04296395f, 
    0.06161189f, 0.19632477f, -0.16053754f, -0.04940047f, -0.04173202f, -0.07718196f, 0.22025235f, -0.01306123f, 
    -0.04015223f, -0.17069644f, 0.06919607f, 0.00784191f, 0.18049352f, -0.24351759f, -0.15317966f, -0.03581864f, 
    -0.12657963f, 0.04395660f, 0.04731244f, 0.07446402f, -0.04670535f, -0.02251179f, -0.02367221f, -0.28722414f, 
    0.05793364f, -0.02736915f, 0.08594877f, -0.22058436f, 0.12518848f, 0.36906922f, -0.06596217f, -0.01279849f, 
    -0.11684185f, 0.08425161f, -0.02750701f, -0.29023787f, 0.08726519f, -0.05325353f, -0.12673436f, -0.09635436f, 
    -0.09424859f, -0.12404143f, 0.00126638f, -0.00188791f, -0.11063610f, -0.15344426f, -0.25244814f, 0.21345504f, 
    0.00134423f, 0.21803012f, -0.00028143f, -0.03222946f, 0.12156874f, 0.30051553f, 0.15180025f, 0.07664008f, 
    0.24977931f, 0.16559155f, -0.09611143f, 0.10020544f, -0.03347968f, -0.03412575f, 0.18811262f, 0.07576735f, 
    0.00904447f, -0.17767848f, 0.29607859f, 0.06598390f, 0.14902896f, -0.12398316f, -0.18745081f, 0.03957209f, 
    0.10789123f, 0.03802349f, 0.26250693f, 0.02821075f, 0.05142850f, -0.06014503f, -0.17264915f, -0.14730372f, 
    -0.10530750f, -0.13459198f, 0.19621587f, 0.08867966f, -0.09272642f, -0.10840946f, 0.08499061f, 0.18941401f, 
    0.07173955f, -0.03150157f, 0.06577680f, 0.01330342f, 0.19502775f, 0.12384766f, 0.22930013f, 0.12708759f, 
    -0.07045342f, 0.13433066f, -0.24114533f, 0.19367892f, 0.05573891f, 0.17793693f, -0.14381588f, 0.13246921f, 
    -0.03285070f, 0.07574225f, -0.06931221f, 0.07783659f, 0.08615925f, 0.06874653f, -0.17509149f, 0.10188782f, 
    0.13537957f, -0.11721933f, -0.01714244f, 0.09496348f, 0.20491770f, -0.05617846f, -0.07061970f, -0.02701875f, 
    0.18591081f, -0.12321307f, -0.23692708f, 0.16861433f, 0.04965804f, 0.07222431f, 0.13804525f, 0.36351389f, 
    -0.19391939f, -0.30301613f, 0.07857310f, -0.33372170f, 0.18540746f, 0.26816502f, -0.02267578f, -0.06569383f, 
    0.16173944f, 0.14032458f, -0.18185665f, -0.16745889f, 0.12016665f, 0.11692830f, 0.05442451f, 0.22773050f, 
    0.17402139f, -0.34868592f, 0.07730407f, 0.19040489f, 0.04730359f, -0.11680554f, 0.03360780f, 0.07167652f, 
    0.20227891f, 0.15185170f, -0.08299971f, -0.03291695f, 0.05371618f, 0.14912239f, 0.22745092f, 0.00604529f, 
    0.17766744f, -0.22045937f, 0.05551961f, -0.05671371f, -0.15182924f, 0.05405277f, 0.10760901f, -0.00294252f, 
    -0.22170854f, -0.11667828f, 0.06154846f, 0.01051557f, -0.01512928f, 0.13181558f, -0.10373060f, -0.00921902f, 
    -0.22088499f, 0.09424363f, -0.06708178f, -0.13503256f, -0.14402829f, 0.26191828f, -0.02998100f, -0.14609191f, 
    0.01950823f, -0.38418701f, -0.15361188f, 0.02986896f, 0.04168657f, -0.41344428f, -0.08037520f, -0.09117945f, 
    0.01321029f, 0.12543494f, 0.18038943f, 0.16669704f, -0.07469719f, -0.32572588f, -0.08589619f, 0.00637906f, 
    0.34326991f, -0.09010263f, 0.17760582f, 0.16898523f, -0.01747636f, 0.00271661f, 0.23795116f, 0.22197014f, 
    -0.13414820f, 0.16429530f, -0.06330795f, -0.12487490f, -0.03472482f, 0.05284317f, 0.19223839f, 0.10583191f, 
    0.28241616f, 0.01425138f, -0.22476661f, -0.23176545f, 0.06215419f, 0.06498912f, -0.08945725f, 0.16508855f, 
    -0.34648904f, 0.17833783f, 0.29323635f, 0.37664020f, -0.11545675f, -0.22283545f, 0.07207223f, -0.00259004f, 
    -0.10966642f, 0.18314405f, -0.28485218f, -0.34416649f, -0.42710990f, 0.36165941f, 0.11461093f, 0.06976739f, 
    0.15878382f, -0.01781969f, -0.41838929f, 0.18694448f, 0.04576631f, 0.09243022f, -0.27696759f, -0.19213849f, 
    0.14705639f, 0.10380059f, 0.03632399f, 0.17164119f, 0.08063944f, -0.14853254f, 0.04647569f, -0.05868191f, 
    -0.02877635f, -0.01229364f, -0.16654582f, -0.03583476f, -0.14087030f, -0.05414337f, -0.07807677f, 0.09321470f, 
    0.20891285f, -0.02754914f, 0.13303363f, -0.10942534f, -0.07654210f, 0.08880847f, 0.08804384f, 0.00075241f, 
    -0.11922391f, -0.07751843f, 0.01017659f, -0.14841914f, 0.15392120f, -0.07272346f, -0.01323733f, -0.08227068f, 
    -0.02722334f, 0.24396200f, 0.11571259f, -0.01237741f, -0.08671804f, -0.02255106f, -0.03316622f, 0.02202057f, 
    0.02811523f, -0.02961471f, 0.03019013f, -0.04866984f, 0.03263395f, 0.00368007f, 0.02472355f, -0.00173183f, 
    -0.07536864f, -0.08232493f, -0.01090342f, -0.06224516f, -0.01947814f, -0.04994231f, -0.01075691f, 0.02476472f, 
    0.01421941f, -0.03486094f, 0.01674910f, -0.03336360f, -0.06807804f, 0.02348842f, 0.01852197f, -0.04091519f, 
    -0.02689738f, -0.02158793f, -0.01563109f, -0.01152904f, -0.00554848f, -0.01345543f, -0.00344006f, -0.02932166f, 
    0.01008467f, -0.02379156f, -0.04898253f, -0.00621754f, -0.00402947f, -0.06020258f, -0.04967385f, -0.04893522f, 
    -0.04632143f, 0.03607571f, 0.00409158f, -0.02157374f, 0.00676922f, -0.01181338f, -0.03634282f, -0.02988331f, 
    0.00027460f, -0.05688867f, -0.06377362f, -0.00266397f, -0.02260089f, -0.03152181f, -0.06317881f, -0.06213988f, 
    -0.06127141f, 0.00593220f, 0.00920758f, -0.02620513f, -0.03980058f, -0.05705449f, -0.03671725f, 0.01671651f, 
    0.02304219f, 0.00323682f, -0.07200416f, -0.06102545f, -0.00038157f, -0.00497407f, 0.02696032f, -0.02721491f, 
    -0.01224871f, 0.01452261f, 0.03378331f, -0.04833657f, -0.02485844f, 0.01239459f, -0.06938354f, -0.01419772f, 
    0.01217728f, -0.07931641f, -0.02157533f, -0.07740430f, 0.04670912f, -0.02608498f, -0.06202038f, 0.02604460f, 
    -0.00868080f, -0.01229021f, 0.02374329f, 0.03586065f, -0.06688003f, 0.02403454f, -0.04944864f, -0.05244533f, 
    0.04053519f, -0.07819196f, -0.00233811f, 0.01232558f, -0.02727429f, 0.03448325f, 0.02375428f, -0.02778970f, 
    -0.04974780f, 0.04080196f, -0.01302126f, -0.05727493f, 0.01862835f, 0.05218680f, -0.00768722f, -0.01113460f, 
    -0.00655961f, -0.00305643f, -0.00295976f, -0.05924879f, -0.05425011f, 0.01436100f, 0.00724134f, 0.00516772f, 
    0.02610386f, -0.02751708f, -0.05835738f, -0.03611306f, 0.04281812f, -0.01797283f, -0.03357067f, -0.06042609f, 
    -0.06787009f, 0.00762318f, 0.02641681f, 0.04780262f, -0.03045651f, -0.01297420f, -0.03691848f, 0.02486537f, 
    0.05129714f, -0.00118187f, 0.00851283f, -0.02293433f, -0.07290066f, 0.04630949f, 0.03101682f, -0.00974916f, 
    0.00448545f, -0.04355367f, -0.01162596f, -0.01686235f, -0.04074416f, 0.01830785f, -0.07028013f, 0.01567097f, 
    0.00146337f, -0.01433586f, 0.05198980f, -0.06564244f, -0.01484539f, 0.03156884f, 0.02301292f, -0.02751594f, 
    -0.06314649f, -0.00383743f, 0.03636140f, 0.02020870f, -0.06842820f, 0.02679309f, 0.01066589f, -0.05618104f, 
    -0.07687595f, -0.04821240f, -0.01403309f, 0.03661169f, -0.02965315f, -0.07011203f, -0.05789287f, -0.07227995f, 
    -0.06578102f, -0.00804622f, -0.05152493f, 0.03056084f, 0.01534392f, -0.07566625f, -0.03167677f, -0.00605583f, 
    0.00725343f, 0.02114887f, 0.00727831f, 0.00974395f, -0.05589870f, -0.06811307f, 0.04037175f, -0.07330184f, 
    0.04755675f, 0.03631194f, 0.00814167f, -0.01111653f, -0.06461149f, -0.06616215f, 0.00827325f, -0.05133440f, 
    -0.03127142f, 0.00861478f, -0.04947819f, -0.03634202f, -0.02155276f, 0.00469822f, 0.01663407f, -0.02641197f, 
    -0.06668691f, 0.01981594f, 0.00547544f, -0.03059237f, 0.03071001f, -0.03047611f, 0.01914068f, 0.04615019f, 
    -0.00340284f, 0.00249321f, -0.01149712f, -0.05305433f, -0.01135388f, -0.02541988f, 0.00679357f, -0.05117869f, 
    -0.04847515f, -0.02329407f, -0.04220954f, -0.04767659f, 0.03044261f, 0.04032718f, 0.04710940f, -0.01110722f, 
    -0.03812613f, 0.01040655f, -0.02095453f, 0.03219040f, -0.03097160f, -0.01185648f, -0.05843706f, -0.04945869f, 
    0.04467769f, 0.01656927f, 0.02594630f, 0.01596458f, -0.02645591f, -0.00616889f, 0.00808019f, -0.00257851f, 
    0.00136596f, 0.00300100f, -0.02497515f, -0.06452047f, -0.04557345f, 0.02075177f, 0.04294755f, -0.00062946f, 
    0.00701339f, -0.03476176f, 0.01669908f, 0.01289086f, -0.01878994f, -0.00984892f, 0.01283169f, -0.04520101f, 
    -0.03235428f, -0.03714744f, 0.00439179f, 0.03821270f, 0.01046307f, 0.05536182f, -0.04153500f, 0.03958662f, 
    -0.01518810f, 0.04619001f, -0.05731881f, -0.06366303f, -0.07432265f, 0.04021490f, 0.04159212f, -0.02847783f, 
    -0.06289253f, -0.04521501f, -0.07091744f, 0.03449951f, -0.01477260f, -0.02696419f, 0.01526972f, -0.05481283f, 
    -0.18535849f, -0.13386975f, -0.38526490f, -0.01363365f, -0.10865278f, 0.07253424f, 0.01243135f, 0.00773335f, 
    -0.02589189f, 0.30968246f, 0.30971119f, -0.17940569f, -0.25502911f, -0.02812929f, 0.06717868f, 0.16752973f, 
    0.17813756f, 0.06720576f, 0.16685946f, 0.21946004f, 0.17038159f, 0.19534831f, 0.02101191f, 0.33028823f, 
    -0.11073279f, -0.09362939f, -0.24077801f, -0.47869036f, 0.00928352f, -0.19107941f, 0.01208158f, -0.15425374f, 
    -0.12323734f, 0.23999470f, 0.17049031f, 0.15894419f, -0.05190434f, -0.08690099f, 0.10119297f, -0.15909366f, 
    0.05540499f, -0.04519513f, 0.18628466f, 0.10335764f, 0.32613361f, 0.32658726f, 0.41889647f, 0.13775955f, 
    -0.04944764f, -0.04748300f, 0.11678374f, 0.11323468f, 0.07132507f, -0.00233194f, -0.03000662f, 0.27457955f, 
    0.11540415f, -0.21722656f, 0.08831646f, 0.00138237f, 0.04290664f, -0.02263824f, 0.10933215f, -0.75694549f, 
    -0.66330874f, -0.19240913f, 0.18206100f, 0.20855919f, 0.00101415f, -0.01492744f, -0.02250638f, -0.07378957f, 
    -0.03164482f, 0.28547132f, 0.22402272f, 0.27254573f, -0.01525962f, -0.22051577f, 0.04321004f, 0.23809071f, 
    0.10402457f, 0.30143410f, 0.26285380f, -0.24572790f, 0.01449075f, 0.22797570f, 0.09076571f, 0.21766946f, 
    0.02016481f, -0.12220736f, -0.74285358f, -0.70173192f, -0.37265670f, -0.21149568f, -0.01526285f, -0.09606686f, 
    0.23204070f, 0.06174301f, -0.15720567f, -0.18655181f, 0.34800687f, 0.46949321f, -0.11577183f, 0.16936558f, 
    0.13272458f, -0.21427253f, -0.30183697f, -0.49571934f, -0.19970734f, 0.31992266f, 0.32223761f, 0.15470409f, 
    0.07328727f, 0.14881697f, 0.03713672f, -0.01346037f, -0.02370526f, 0.40772364f, 0.11974320f, 0.00306740f, 
    0.15065794f, -0.07178704f, 0.00322406f, -0.12658516f, 0.08658200f, 0.27616647f, 0.12263227f, 0.33934107f, 
    -0.07397471f, 0.25168234f, -0.14190669f, -0.07851461f, -0.11634823f, -0.00490032f, 0.06454472f, 0.31869256f, 
    -0.09412977f, -0.11124082f, -0.03166026f, 0.06244968f, -0.17254852f, 0.13786298f, 0.22287844f, -0.08523309f, 
    -0.60292476f, 0.20361546f, -0.05719263f, 0.13566554f, -0.03566813f, -0.01896836f, -0.27661014f, -0.01279010f, 
    -0.02627049f, -0.88436669f, -0.44059905f, -0.35894063f, 0.02339600f, -0.00299775f, -0.17043601f, 0.00437581f, 
    0.07801102f, 0.27063817f, -0.73696285f, -0.21951251f, -0.03506429f, 0.26261494f, 0.04279305f, 0.06995677f, 
    -0.20318995f, -0.04072828f, 0.07953417f, 0.40990749f, -0.22604534f, -0.48958680f, -0.01334049f, -0.10384404f, 
    -0.03397245f, -0.00918480f, 0.02621622f, 0.13117997f, 0.04143777f, -0.05881367f, 0.05794933f, 0.15912706f, 
    0.11888716f, 0.19801739f, -0.34501454f, -0.22015914f, 0.15836136f, -0.74858445f, -0.31331581f, -0.07459859f, 
    0.15272018f, -0.07533725f, -0.08226856f, -0.11021356f, -0.08993824f, 0.09014734f, 0.33500174f, 0.21533750f, 
    0.17888120f, -0.03503787f, 0.01679599f, -0.20534782f, -0.07276648f, 0.22109465f, -0.01197223f, -0.04445061f, 
    -0.08803217f, -0.18235043f, 0.07903361f, -0.06954437f, 0.01384375f, 0.03111433f, -0.08417448f, 0.21851622f, 
    -0.47747624f, -0.47575584f, 0.15472019f, 0.37301296f, 0.04699737f, 0.05137018f, 0.21797343f, 0.21384610f, 
    0.26765400f, -0.08648685f, 0.27082577f, -0.04365176f, 0.05405947f, 0.05488376f, 0.18244268f, -0.16044147f, 
    0.01914633f, -0.20730063f, -0.62747294f, -0.58963788f, 0.22662005f, 0.08277231f, -0.08625717f, -0.06825278f, 
    0.20827174f, -0.21969900f, -0.15880947f, 0.02595787f, -0.17080614f, -0.10981009f, 0.04802373f, 0.01154649f, 
    -0.14678258f, 0.20635913f, -0.02888678f, -0.18950610f, -0.71408427f, -0.33406702f, 0.00761438f, 0.25302827f, 
    -0.17603776f, 0.03722193f, -0.31310108f, 0.26329568f, 0.24818654f, 0.23912022f, 0.37670013f, 0.31327960f, 
    -0.02340333f, 0.09158272f, 0.21075574f, -0.04710250f, 0.27991363f, 0.05130123f, 0.42772263f, 0.14973241f, 
    0.06510166f, 0.20035133f, -0.00016592f, 0.21236667f, -0.22123644f, -0.08426677f, 0.03266536f, -0.10241029f, 
    0.28036124f, 0.06403404f, 0.04219457f, -0.15884694f, -0.21374631f, -0.03533380f, 0.10023560f, 0.22933167f, 
    0.01201458f, -0.03736609f, -0.03899560f, -0.05039859f, 0.03464920f, 0.03447705f, -0.01299396f, -0.03877454f, 
    -0.00882310f, -0.03135743f, -0.03904457f, -0.06422466f, -0.03227219f, -0.01610162f, -0.05613380f, 0.04049452f, 
    -0.01316319f, -0.00206503f, -0.05028179f, 0.00217011f, -0.06119891f, -0.03944917f, -0.03458097f, 0.03521536f, 
    0.04398510f, -0.01275280f, -0.02814138f, -0.01516518f, -0.05080061f, 0.04494796f, 0.01934014f, 0.03597213f, 
    -0.04052304f, 0.01680417f, -0.05316370f, -0.04574187f, 0.00841248f, 0.00989696f, 0.04052775f, -0.05942327f, 
    0.03298823f, 0.04486498f, 0.03021803f, 0.02089831f, 0.00323606f, 0.03151518f, -0.05361448f, 0.04312061f, 
    0.03025539f, 0.01249234f, -0.05655615f, 0.01372776f, 0.03231503f, -0.03722689f, 0.04619968f, 0.04600362f, 
    -0.01249028f, 0.04378640f, 0.00259207f, -0.04944338f, 0.02570313f, -0.01069696f, 0.04157609f, -0.02065725f, 
    0.04894345f, 0.01773270f, 0.02801628f, 0.01042375f, -0.03831829f, -0.05310632f, 0.03605452f, 0.00991669f, 
    -0.05340160f, 0.03777982f, 0.04155763f, -0.00948270f, -0.04321934f, 0.02368910f, -0.00752030f, -0.00274432f, 
    0.03247646f, -0.03597834f, 0.01792988f, 0.00739640f, -0.03546417f, 0.00056749f, 0.01186934f, -0.03257471f, 
    -0.03086132f, 0.03908273f, -0.03284976f, 0.01451652f, -0.04088629f, 0.02040627f, -0.02696912f, 0.03264033f, 
    -0.06045480f, 0.01160033f, -0.05948870f, 0.00766702f, 0.00102934f, -0.01700617f, -0.03171010f, 0.01333066f, 
    0.00063008f, 0.02223144f, 0.01582881f, 0.00821617f, -0.04457546f, 0.01475235f, -0.05241851f, 0.00000715f, 
    0.03276591f, -0.06081459f, 0.01608659f, -0.01169940f, 0.05006623f, -0.02363583f, -0.05025275f, 0.01222972f, 
    -0.04642668f, 0.02522045f, -0.02733471f, -0.04660044f, -0.04677344f, -0.02439235f, 0.04867562f, 0.00232021f, 
    -0.00820442f, 0.02533351f, 0.01877348f, 0.05167643f, -0.03553892f, -0.05572883f, -0.02644852f, -0.02366581f, 
    -0.04399173f, 0.00300608f, -0.01759148f, 0.02363543f, -0.05832229f, 0.02843295f, 0.03025538f, -0.05973548f, 
    0.01232385f, 0.00879349f, -0.05335926f, -0.00279268f, -0.05651903f, -0.05522981f, -0.00012562f, -0.00202181f, 
    -0.01539597f, 0.02213878f, -0.02072069f, 0.00511485f, -0.04645510f, -0.03487092f, 0.00655144f, -0.05090329f, 
    0.01114257f, 0.03573762f, -0.06110166f, -0.01244629f, -0.05254696f, 0.01810597f, 0.03359651f, -0.03087123f, 
    -0.03057537f, -0.03673859f, -0.00204340f, -0.03281736f, -0.06056884f, -0.01178434f, -0.03667381f, 0.03243084f, 
    0.01536947f, 0.03397594f, 0.03548657f, -0.05408936f, -0.05399540f, 0.04641870f, -0.03725025f, -0.05874341f, 
    -0.02909139f, 0.03702415f, -0.06155086f, -0.01647413f, -0.05809918f, 0.01841960f, -0.03987104f, -0.03128429f, 
    -0.03062179f, -0.03553045f, -0.02874763f, 0.01973240f, -0.02462576f, -0.03318933f, -0.03836274f, -0.05677884f, 
    0.04050214f, -0.01215236f, 0.01263131f, -0.00107049f, 0.05401578f, -0.02111335f, -0.01021691f, -0.06378514f, 
    0.03103563f, 0.00030607f, -0.05118451f, -0.00856361f, -0.00792467f, -0.05644495f, 0.02918350f, 0.00433818f, 
    0.03437239f, 0.00546262f, -0.03290301f, 0.03059373f, 0.02966159f, -0.01284290f, -0.00292897f, 0.01836559f, 
    0.01064385f, -0.00734061f, 0.01180665f, -0.00199961f, -0.02990368f, 0.02537232f, -0.02151433f, 0.05094216f, 
    -0.05751726f, -0.04617120f, -0.04274539f, -0.03231495f, 0.01329220f, -0.02134769f, 0.01887436f, -0.04753766f, 
    -0.04909771f, 0.01386974f, -0.04923071f, 0.02971916f, 0.01667249f, 0.02693372f, 0.03803232f, 0.03830735f, 
    -0.01164408f, 0.05451614f, 0.02777308f, 0.05422299f, -0.03101910f, -0.03171756f, -0.03212496f, -0.03369158f, 
    -0.04791310f, 0.02093176f, -0.01110707f, -0.03038583f, -0.03465952f, 0.03610587f, -0.03866512f, 0.04083496f, 
    -0.04835719f, -0.06081593f, 0.03900490f, -0.03968840f, -0.01037199f, -0.03576496f, -0.01207110f, -0.00428205f, 
    -0.06684802f, -0.01841712f, 0.02842907f, -0.02379019f, 0.00040326f, 0.01480102f, 0.00596827f, -0.00114608f, 
    -0.02384549f, 0.02139587f, -0.04371228f, -0.03570732f, 0.03595711f, 0.02648430f, 0.02618194f, -0.01032293f, 
    -0.06072936f, -0.01763396f, 0.04162746f, 0.01249618f, 0.02951480f, -0.04784551f, 0.01135331f, 0.03607270f, 
    0.02688417f, -0.05691694f, 0.04757429f, 0.03277040f, 0.02831116f, -0.05767854f, -0.01674437f, -0.00989210f, 
    -0.01131116f, 0.00880812f, -0.05036082f, -0.05201056f, 0.02825313f, 0.01983289f, -0.05336804f, -0.03616381f, 
    -0.04540185f, 0.00647948f, -0.00674083f, -0.03531061f, 0.01013325f, -0.07038072f, 0.04452611f, 0.04641546f, 
    -0.04580835f, -0.03349994f, 0.02674548f, -0.00152536f, 0.01860738f, 0.02503301f, -0.00160176f, -0.05199613f, 
    -0.00704845f, 0.01980258f, 0.03424526f, 0.01732405f, -0.05503565f, 0.01972807f, 0.03956612f, -0.00345693f, 
    -0.00692840f, 0.04455563f, 0.03075853f, -0.00983814f, 0.04993599f, -0.03318538f, -0.03568799f, -0.05392772f, 
    0.02682088f, 0.02674704f, -0.00454439f, -0.02029529f, 0.01121288f, -0.03605892f, -0.05439080f, 0.00637260f, 
    0.02911413f, -0.01850000f, -0.01453217f, 0.04254474f, -0.02566142f, -0.02351798f, -0.00011723f, 0.02874097f, 
    0.02459325f, 0.00828787f, -0.01198914f, -0.04273387f, -0.01563033f, 0.04628043f, -0.03840590f, 0.01939319f, 
    0.04281878f, -0.01073018f, -0.00192858f, -0.06170020f, -0.01047658f, 0.03036626f, 0.01984637f, -0.06475709f, 
    -0.05360612f, -0.03502272f, 0.02340804f, 0.03726400f, -0.03237158f, -0.05980815f, -0.05027488f, -0.01573881f, 
    0.00103259f, -0.06240297f, 0.03496878f, -0.05951533f, -0.01863042f, 0.01908499f, -0.05385682f, -0.04458139f, 
    -0.05948940f, -0.02094706f, 0.00263115f, -0.04572856f, -0.02380782f, -0.00363983f, -0.02875260f, -0.05173801f, 
    -0.07063884f, -0.00829448f, -0.04260629f, 0.00631732f, -0.00746741f, 0.01829262f, 0.02239490f, 0.03814716f, 
    0.03919904f, -0.02647834f, -0.06503602f, -0.04847772f, -0.06312831f, 0.03355678f, -0.02237962f, -0.03195666f, 
    -0.06885974f, -0.06107361f, -0.05271548f, -0.03187267f, -0.00913864f, -0.04632910f, -0.01349763f, -0.01652863f, 
    -0.03218541f, 0.03152614f, -0.05614420f, -0.02765772f, 0.05053275f, -0.03961316f, -0.03148146f, -0.04714386f, 
    0.01515777f, -0.04811633f, -0.03830045f, 0.00460248f, -0.05535792f, 0.02503485f, 0.03066102f, -0.03909060f, 
    0.02061462f, 0.03663316f, 0.04055669f, -0.00088449f, 0.02930115f, 0.00724312f, 0.01707606f, -0.00510271f, 
    -0.00450543f, 0.00752376f, -0.03905100f, -0.00947859f, 0.03546860f, -0.06236858f, -0.06448254f, 0.02743131f, 
    -0.06369665f, 0.04195400f, 0.03254328f, -0.05194890f, -0.05702703f, -0.01778302f, -0.00775708f, -0.03350567f, 
    -0.03951367f, -0.04393730f, 0.03554121f, -0.01987568f, 0.01195626f, -0.06120399f, -0.02570790f, -0.01255241f, 
    0.01217419f, 0.01741942f, 0.00975308f, 0.04575227f, -0.00444208f, -0.00835433f, 0.02867238f, -0.01168796f, 
    -0.04817751f, -0.00137497f, 0.00376187f, 0.00235343f, 0.02713534f, 0.02839897f, 0.03612769f, 0.01390695f, 
    -0.06928550f, -0.05943750f, 0.01101116f, -0.01721456f, -0.05607076f, -0.03388885f, -0.00672167f, 0.04054257f, 
    0.00435683f, 0.02168240f, 0.00503114f, -0.01591853f, 0.03113878f, 0.01334734f, 0.05066409f, 0.00854020f, 
    -0.00866970f, 0.01023579f, -0.00118930f, 0.00317897f, -0.04365650f, 0.03841702f, 0.04524819f, 0.02458828f, 
    -0.07293777f, 0.04430071f, -0.02463248f, -0.02392853f, 0.01494570f, -0.00308848f, 0.00558653f, 0.01988066f, 
    -0.03592194f, 0.00568082f, 0.00286583f, -0.02599644f, 0.03677787f, -0.01526471f, -0.02614399f, 0.01320899f, 
    -0.04071720f, -0.06227408f, -0.05968870f, -0.01329844f, -0.01916523f, -0.01052361f, 0.01270927f, -0.02788298f, 
    0.01030015f, 0.03046013f, 0.01589299f, -0.04902024f, 0.01468940f, 0.01771604f, 0.04413144f, -0.04643573f, 
    -0.03329596f, -0.02644423f, -0.03113390f, -0.01280030f, -0.03132353f, 0.02477153f, 0.04156042f, 0.00242436f, 
    -0.03291108f, 0.02055783f, -0.03306862f, -0.01122778f, -0.06961703f, -0.02036858f, 0.02991940f, -0.00650500f, 
    0.04455411f, -0.03442731f, -0.01305575f, 0.00318037f, -0.02365025f, -0.02669476f, -0.00473837f, 0.00462804f, 
    0.00853210f, -0.07165053f, 0.03033099f, -0.05520778f, 0.02861067f, -0.03219321f, 0.02462167f, 0.04119718f, 
    0.03277595f, -0.06548321f, -0.02336170f, 0.14331980f, -0.02401492f, -0.28278551f, -0.02154065f, 0.03190156f, 
    0.19449359f, 0.17804421f, 0.17560591f, -0.26201400f, -0.01989795f, -0.07525409f, -0.04146043f, 0.03302348f, 
    -0.07390165f, 0.09878076f, -0.03325229f, -0.14848709f, -0.33225143f, -0.10764354f, -0.00324455f, 0.27810007f, 
    -0.04022651f, -0.17977899f, 0.06601371f, -0.24828325f, 0.18922910f, 0.16557497f, -0.19163580f, -0.06251813f, 
    -0.16212606f, -0.01271086f, 0.08572043f, -0.04678670f, -0.03142882f, 0.07201120f, -0.38177761f, 0.14915127f, 
    -0.05222335f, 0.24857107f, 0.00111796f, 0.03862288f, -0.02852994f, -0.10134858f, 0.28608415f, 0.29469976f, 
    0.22519626f, 0.15646937f, -0.02546102f, -0.25647968f, 0.03161669f, -0.08695919f, -0.45691952f, 0.11241443f, 
    -0.14397356f, -0.15104045f, -0.02535249f, 0.03983042f, -0.34094280f, -0.10339189f, 0.02476469f, 0.26188597f, 
    -0.17221589f, -0.11158971f, 0.13051012f, -0.16035393f, 0.15796372f, -0.02407921f, -0.06228542f, 0.11358543f, 
    -0.09931136f, 0.37993538f, 0.50179470f, -0.02750646f, 0.01049158f, 0.00328506f, -0.13580163f, 0.01847624f, 
    0.16552973f, 0.36099723f, -0.14088516f, 0.10912240f, 0.16787730f, -0.01170489f, 0.17133328f, -0.36904457f, 
    0.04271919f, -0.28787798f, 0.32127339f, -0.27409199f, 0.10291563f, 0.02611786f, 0.01607626f, -0.06895214f, 
    -0.04353492f, 0.07963648f, 0.20895767f, -0.18856108f, -0.04187007f, 0.01779439f, -0.09362522f, 0.10172019f, 
    0.05260523f, -0.05400693f, 0.04555614f, 0.11298104f, -0.12103080f, -0.04033738f, -0.01796081f, 0.03834537f, 
    -0.08664250f, -0.03127601f, -0.19967087f, -0.26402292f, 0.07124016f, 0.00814177f, -0.10087962f, -0.35228759f, 
    0.18347447f, -0.11343821f, 0.08467770f, -0.13651721f, 0.02470363f, 0.00395823f, 0.22531137f, 0.26752692f, 
    0.05036482f, 0.16751085f, -0.16405764f, -0.29806599f, -0.04410604f, -0.05396838f, -0.01053431f, -0.05991278f, 
    -0.31143555f, 0.03495038f, -0.20422310f, -0.04541397f, -0.12802315f, -0.16256912f, -0.01712918f, 0.06607679f, 
    0.55838376f, -0.09407257f, 0.13636217f, 0.03931177f, 0.04299331f, -0.19368492f, 0.07773070f, -0.24486434f, 
    0.05780672f, 0.40784329f, -0.20554161f, 0.13304947f, 0.02733021f, -0.01857298f, -0.09012082f, -0.03009200f, 
    0.00868460f, 0.11339406f, 0.24616580f, -0.00570956f, -0.06329769f, 0.22226995f, -0.02608446f, 0.06298798f, 
    0.03543093f, -0.11911795f, 0.04974732f, -0.22256318f, 0.00718653f, -0.15291817f, 0.02973143f, 0.07686608f, 
    0.05145795f, -0.14755926f, 0.03772979f, -0.24635258f, 0.12597710f, 0.26481903f, -0.53196532f, -0.02126551f, 
    0.01405157f, -0.03518868f, -0.05455739f, -0.07251358f, -0.04796891f, 0.38251612f, -0.10883122f, -0.02948624f, 
    0.08252317f, 0.09118635f, -0.23190400f, 0.06420993f, 0.03165576f, -0.05037124f, -0.07293824f, 0.19245344f, 
    0.37275183f, 0.20203388f, 0.09752960f, -0.18977433f, -0.32522032f, 0.00851408f, -0.15150538f, -0.29743454f, 
    0.06193626f, -0.05344140f, 0.08220152f, 0.04718572f, -0.07541208f, 0.10015359f, -0.28138658f, 0.15817361f, 
    -0.29438895f, 0.11125749f, 0.01348119f, -0.03724127f, -0.27811536f, -0.06491459f, 0.28018147f, 0.19685471f, 
    -0.09084233f, -0.08933917f, 0.26989529f, -0.31565368f, -0.13139415f, -0.07987463f, 0.03236512f, -0.09867316f, 
    -0.04394918f, -0.02802658f, 0.03418748f, 0.37387550f, -0.13118714f, 0.25296682f, 0.06391180f, 0.01586912f, 
    0.04441903f, 0.06845088f, -0.03050694f, -0.54818004f, -0.05469790f, 0.02060999f, 0.15061872f, 0.19758573f, 
    -0.04799990f, -0.15051842f, -0.14977460f, 0.29979920f, 0.38879713f, -0.20050432f, 0.18277176f, 0.11387773f, 
    -0.00836041f, -0.42117733f, 0.23587659f, 0.06161969f, 0.16119532f, 0.02772387f, 0.62854850f, 0.10438047f, 
    0.10634674f, 0.16797628f, -0.13545495f, -0.13594185f, 0.06526905f, -0.23411490f, 0.08034096f, -0.15894915f, 
    -0.29325423f, 0.23661260f, -0.02044591f, 0.00610902f, -0.07234120f, -0.06658334f, -0.03808921f, 0.17803569f, 
    0.33382413f, -0.12706104f, -0.04104302f, -0.20088835f, 0.04981176f, -0.06401674f, 0.01421863f, 0.04839731f, 
    0.51537645f, -0.40865040f, -0.07211668f, 0.03697890f, 0.19058797f, 0.04544305f, -0.01860637f, 0.03017990f, 
    0.03878934f, 0.05242324f, -0.00855331f, -0.15185444f, 0.05879492f, -0.01939475f, -0.09975912f, -0.05650603f, 
    0.06751110f, 0.10320751f, -0.17817363f, -0.07163598f, -0.49658939f, 0.03620890f, 0.12276487f, 0.19982009f, 
    0.00688169f, -0.03411313f, -0.05112883f, -0.31258276f, 0.03335547f, -0.79098737f, 0.13381734f, 0.13887465f, 
    -0.05312747f, -0.17340280f, 0.06698677f, 0.14720365f, -0.64015365f, -0.30169234f, -0.06260160f, -0.00390589f, 
    0.08701856f, -0.17101818f, -0.07915732f, 0.09401920f, 0.08308353f, 0.35229054f, 0.51328576f, -0.10326620f, 
    0.13206676f, 0.09970492f, -0.00784329f, 0.15219910f, 0.07580215f, -0.14754584f, 0.11337676f, 0.10132209f, 
    0.04591745f, -0.03128132f, 0.29396668f, 0.11035791f, -0.27182639f, -0.00537580f, -0.14268120f, 0.19506095f, 
    0.02434733f, -0.05646370f, -0.18196125f, -0.22717628f, 0.09658194f, 0.02826585f, -0.01006233f, -0.08655800f, 
    0.22242323f, 0.28058055f, 0.14687468f, 0.16235590f, -0.15617520f, -0.08123313f, -0.10767888f, 0.07953570f, 
    0.13755815f, 0.17323881f, -0.56753629f, -0.07187846f, 0.19396566f, 0.10703656f, -0.29142022f, 0.08815335f, 
    0.10364377f, -0.02706196f, 0.14647366f, 0.09588705f, 0.13468820f, -0.26922172f, -0.17706345f, -0.16806647f, 
    0.05197123f, 0.00238306f, 0.16897167f, 0.02547253f, -0.06912028f, 0.33783618f, 0.17632368f, 0.08198778f, 
    0.10128381f, 0.12865460f, 0.03309526f, -0.16654529f, 0.15108691f, 0.00237037f, 0.15997848f, -0.02571506f, 
    -0.00888965f, 0.23818526f, -0.07810361f, 0.12492205f, -0.01715499f, -0.32918796f, -0.19212462f, -0.29735848f, 
    0.08492954f, -0.01909607f, -0.04114769f, -0.08395032f, -0.12901813f, 0.11608779f, -0.15471533f, 0.08002160f, 
    0.40736747f, -0.14484730f, 0.04415207f, -0.01000569f, -0.10572626f, -0.17308044f, -0.07439996f, 0.29524937f, 
    0.17161976f, -0.05975112f, 0.14488046f, -0.01978962f, -0.31430486f, 0.15230438f, 0.04747464f, -0.09119136f, 
    0.18186508f, 0.07454681f, 0.09668600f, -0.22986066f, -0.00878800f, 0.10368298f, -0.18666378f, -0.09514966f, 
    -0.10499945f, -0.18867142f, -0.11291286f, 0.34872290f, -0.22575164f, -0.16474968f, -0.08589467f, -0.18465622f, 
    -0.07938039f, 0.15570036f, 0.15886307f, -0.06834731f, -0.05611172f, -0.14176044f, -0.08958051f, 0.06379890f, 
    0.14484084f, -0.01928344f, 0.08738606f, -0.55122393f, -0.08260199f, -0.39248985f, 0.11691663f, -0.02532426f, 
    0.14370152f, 0.04474708f, -0.24553850f, 0.24598543f, -0.11971968f, -0.34935302f, -0.29943392f, 0.03571888f, 
    -0.09352376f, 0.22148670f, 0.05401969f, -0.01023437f, -0.09977985f, -0.00333878f, 0.22589645f, 0.16729127f, 
    0.10106048f, -0.07083426f, 0.01303023f, -0.11651799f, 0.15728709f, -0.08108073f, 0.32453954f, 0.32721385f, 
    -0.13427189f, 0.16422847f, -0.06866828f, -0.15644786f, 0.12572010f, 0.10429972f, 0.01112621f, 0.12275682f, 
    -0.39048609f, -0.02386350f, 0.00552253f, -0.04766553f, -0.14396414f, -0.19262065f, 0.08116008f, 0.29892498f, 
    -0.33422098f, -0.21538155f, 0.19392671f, -0.17075674f, 0.16083539f, -0.06408437f, 0.24724914f, -0.02212344f, 
    0.26477304f, -0.49535298f, -0.14664662f, -0.44380811f, 0.06519604f, 0.04641924f, 0.31047615f, 0.11035054f, 
    -0.11454486f, -0.02548338f, 0.10039125f, 0.13116020f, 0.00077161f, 0.03135122f, -0.16513251f, 0.07268866f, 
    -0.01108630f, -0.00063693f, -0.02576279f, 0.00512055f, -0.66885149f, -0.60515571f, 0.04953111f, 0.15967207f, 
    -0.05764923f, 0.20031151f, -0.08610487f, 0.04238257f, 0.05322023f, 0.07249894f, 0.09174692f, -0.03712033f, 
    -0.03019297f, -0.04738248f, -0.03446303f, 0.07602474f, -0.03963810f, 0.06944349f, 0.50695503f, -0.17240492f, 
    0.19337375f, -0.22789221f, 0.25198352f, 0.12485319f, -0.03274921f, -0.08690292f, -0.21083356f, -0.05194491f, 
    0.09863155f, 0.03777982f, -0.06929515f, 0.08622346f, 0.10584776f, 0.09038758f, 0.26069626f, 0.28596494f, 
    -0.19592300f, 0.06278789f, -0.15379290f, 0.24804214f, 0.07515407f, 0.06882644f, 0.00415682f, -0.00704169f, 
    0.00018463f, -0.23159875f, -0.33247629f, 0.03891225f, -0.08479510f, -0.15708025f, 0.15775430f, 0.07717243f, 
    0.24828838f, -0.39782059f, -0.01836347f, -0.14681534f, 0.07012636f, 0.06420469f, -0.09743593f, 0.04325027f, 
    -0.12432143f, 0.16470598f, 0.18336502f, 0.03911639f, -0.50319397f, -0.03686795f, 0.10047223f, -0.14450201f, 
    -0.08232739f, -0.28056675f, -0.05871324f, 0.22723237f, -0.13150892f, 0.16474862f, 0.02893147f, 0.10372916f, 
    -0.05135448f, -0.00014528f, 0.01933812f, 0.17431191f, -0.03534697f, -0.05622721f, -0.31919590f, 0.26458621f, 
    0.13260697f, 0.14612748f, -0.11746579f, -0.10345331f, -0.03322408f, -0.19319569f, -0.00401633f, 0.40990183f, 
    0.21677582f, 0.01765964f, 0.03704852f, 0.07861585f, -0.03247644f, -0.04552497f, -0.01793502f, 0.03420091f, 
    -0.26009655f, 0.06094869f, -0.10784017f, 0.04048712f, -0.05807909f, -0.10971868f, 0.22082935f, 0.12745355f, 
    0.13778920f, -0.42251942f, 0.12608233f, 0.19761901f, 0.16764739f, -0.05642192f, -0.20725906f, -0.05365418f, 
    -0.02883533f, 0.04718872f, 0.59620011f, -0.20884404f, 0.03919820f, -0.10299970f, -0.10662085f, 0.07828794f, 
    0.25050294f, 0.01343020f, 0.16978762f, -0.18943052f, -0.25409925f, 0.02665309f, 0.05684246f, -0.01435317f, 
    0.04172921f, 0.07848839f, 0.09537870f, -0.10873064f, -0.33740538f, 0.10345663f, -0.06846520f, -0.08148239f, 
    -0.24481227f, 0.09000675f, 0.10008062f, -0.30616575f, 0.22530571f, -0.10939640f, 0.03686056f, 0.38426569f, 
    -0.01173403f, 0.07219782f, -0.07193783f, 0.35959405f, -0.38533163f, -0.10729401f, -0.16749568f, -0.03871680f, 
    0.04301652f, -0.04969568f, -0.02916370f, 0.15181516f, 0.07545284f, 0.11498504f, -0.24910523f, -0.09960068f, 
    0.17277725f, 0.08937989f, -0.14523658f, 0.12242498f, -0.13006355f, 0.04294765f, -0.56342787f, 0.28519341f, 
    -0.18746567f, 0.10418850f, 0.03286766f, -0.05293969f, -0.17611033f, -0.14939590f, -0.08565853f, 0.42722628f, 
    -0.14834495f, 0.11716416f, -0.46401203f, -0.05161425f, -0.06999277f, 0.41577280f, 0.09164640f, -0.00154732f, 
    0.05267797f, -0.07550725f, 0.35190472f, 0.19326437f, 0.04833728f, 0.01432871f, 0.06511072f, -0.05298175f, 
    0.01418752f, -0.03961027f, 0.02413478f, 0.14971966f, 0.13516514f, -0.02792445f, 0.04167211f, -0.06808729f, 
    -0.03219756f, 0.18271077f, 0.07133626f, -0.21503794f, -0.13316618f, 0.09235851f, 0.18356183f, 0.05340488f, 
    -0.04924543f, -0.07451346f, -0.02707699f, 0.02207632f, -0.29240733f, 0.15594514f, -0.04801750f, -0.01916428f, 
    -0.27965531f, 0.15898763f, -0.14070959f, 0.11272287f, 0.42025253f, 0.45201832f, -0.86505669f, 0.05055137f, 
    -0.04578895f, 0.08425006f, 0.04593357f, 0.07506450f, -0.01063812f, 0.18405254f, 0.26630053f, -0.07374910f, 
    0.08918508f, -0.03679651f, 0.05581444f, 0.16406663f, 0.07375034f, -0.04491379f, -0.07125425f, 0.13205095f, 
    0.45232359f, -0.14791858f, 0.07917354f, -0.05299905f, 0.16584061f, 0.10240076f, -0.17262791f, -0.13021085f, 
    -0.28418425f, 0.09131488f, 0.01087392f, -0.23358746f, -0.16062666f, 0.07371185f, -0.03529771f, 0.30340439f, 
    -0.19447771f, 0.12065921f, 0.02822398f, 0.00054687f, -0.07947182f, -0.10194601f, 0.34890887f, -0.02147022f, 
    0.07475039f, -0.24584252f, -0.41578504f, -0.51895976f, -0.09901905f, 0.06834714f, 0.05467848f, -0.16938998f, 
    -0.06569491f, 0.00714019f, -0.14043897f, -0.07888108f, -0.12386712f, 0.22693050f, 0.02679618f, -0.01597983f, 
    -0.00308447f, 0.20497945f, -0.12685426f, -0.14164804f, -0.19939911f, -0.44342172f, -0.08735898f, -0.03678486f, 
    -0.17270543f, 0.17536277f, -0.11492819f, -0.09943785f, 0.39476779f, 0.17929798f, 0.21077965f, 0.24438533f, 
    0.06230326f, -0.22243167f, 0.19453229f, -0.14725371f, 0.19256319f, -0.53286761f, 0.11039481f, 0.17001967f, 
    0.13928692f, -0.05078916f, -0.02049657f, 0.03607774f, -0.14304364f, -0.07926390f, -0.06329744f, -0.06924702f, 
    -0.36176935f, 0.06093591f, 0.11126272f, -0.08127218f, 0.03751916f, 0.20511441f, -0.02690630f, 0.25452891f, 
    -0.01963297f, -0.08224124f, -0.00880393f, 0.11962977f, 0.14147614f, -0.06039029f, 0.06990992f, -0.14740129f, 
    -0.15942673f, 0.19865267f, 0.12088095f, -0.03618565f, 0.06141520f, -0.05075014f, 0.18114583f, 0.01548148f, 
    0.26911151f, -0.19945651f, -0.12209260f, 0.26592553f, 0.15080835f, -0.13314550f, 0.20767239f, -0.18815935f, 
    0.29199663f, -0.09954997f, -0.31236306f, -0.26553568f, 0.09600140f, -0.19834684f, -0.02163089f, 0.03327562f, 
    -0.14443664f, -0.17134613f, 0.05566207f, -0.02948080f, -0.24054220f, -0.06205947f, -0.06604813f, -0.05283005f, 
    -0.16239460f, 0.01232650f, 0.14401338f, 0.21597424f, -0.28424668f, -0.60333198f, -0.04454754f, 0.13561565f, 
    0.06374484f, -0.05123610f, -0.19682010f, 0.17651407f, -0.24180484f, 0.09285508f, 0.30983084f, 0.27676740f, 
    -0.00071474f, -0.12832822f, -0.07118656f, 0.21174355f, -0.13650949f, -0.01804870f, 0.47917753f, 0.14744638f, 
    0.11533356f, 0.05994727f, 0.06963012f, -0.15674841f, 0.08311716f, 0.17285390f, -0.14499784f, 0.02129470f, 
    0.22043948f, -0.15918708f, 0.19502752f, -0.11776413f, 0.13564302f, -0.04129262f, 0.16268621f, 0.11788315f, 
    0.07233555f, 0.15731843f, -0.32582042f, 0.27255344f, -0.05318014f, -0.24014938f, 0.08492734f, -0.01694773f, 
    -0.01255494f, 0.22675070f, -0.09130273f, -0.05205673f, -0.08234046f, -0.20413218f, -0.01124466f, -0.10923751f, 
    0.27019230f, -0.03013538f, -0.00441419f, 0.04624749f, -0.08172953f, 0.19293466f, 0.06975663f, 0.10065216f, 
    0.07727209f, 0.40240708f, 0.09591371f, -0.04785679f, -0.24064431f, 0.04057786f, -0.05418424f, 0.18684676f, 
    0.05434351f, -0.03906852f, -0.08461837f, -0.12444818f, -0.03592998f, -0.00489984f, 0.06381952f, -0.08844174f, 
    0.14093073f, -0.11282037f, 0.24880761f, 0.09487212f, 0.05914484f, 0.07482240f, -0.12489374f, 0.11526679f, 
    -0.44566947f, 0.02835992f, 0.10898493f, -0.21584149f, 0.20614035f, -0.00043193f, 0.03214991f, -0.22471879f, 
    0.35174242f, 0.14046437f, -0.12938172f, -0.05013527f, -0.13587371f, -0.04714980f, 0.03887025f, 0.83347267f, 
    0.43966019f, -0.29016143f, 0.09795003f, 0.06156718f, -0.21849588f, 0.06821217f, -0.25316876f, 0.18613845f, 
    0.14744563f, 0.15290126f, -0.13336813f, -0.10257059f, -0.04982107f, -0.01660935f, 0.09559581f, -0.19055702f, 
    -0.01735956f, -0.06572571f, 0.29943746f, 0.01971704f, 0.02429488f, 0.00822892f, 0.31170678f, 0.03868580f, 
    0.25420544f, 0.24684654f, 0.18535359f, 0.19857003f, -0.04749404f, -0.02350375f, -0.02331785f, 0.00238810f, 
    -0.11236547f, 0.10636930f, -0.00647742f, -0.12635578f, -0.41599137f, -0.16208068f, -0.11658621f, -0.07835968f, 
    -0.23368134f, 0.10116413f, 0.22938859f, 0.19671339f, -0.38734663f, -0.39019710f, 0.02734670f, -0.07496674f, 
    0.04490216f, 0.10892248f, -0.18425925f, 0.13970731f, 0.04597868f, 0.13532275f, 0.23636478f, -0.21268389f, 
    0.07206735f, -0.14228107f, -0.00194122f, 0.13718651f, 0.06544403f, 0.17072240f, 0.38597095f, 0.15116847f, 
    -0.31836566f, 0.02597493f, 0.17050432f, 0.14935090f, 0.10882510f, -0.24620655f, 0.00473238f, -0.27375609f, 
    0.09850182f, 0.22820157f, -0.08432228f, -0.07044943f, -0.40774676f, 0.05564164f, 0.16042939f, 0.03267716f, 
    0.05252397f, -0.07209893f, -0.24458721f, -0.04523256f, -0.08800031f, -0.12270918f, -0.04564702f, 0.02156316f, 
    -0.12106823f, -0.30922046f, -0.22817281f, 0.20539895f, -0.08024032f, 0.17890315f, -0.07979014f, 0.08600838f, 
    -0.13165197f, -0.02868560f, 0.35193118f, -0.10970178f, 0.07502308f, -0.26563945f, 0.03071957f, 0.03494091f, 
    -0.06889033f, 0.04963048f, 0.11278439f, -0.07754170f, 0.05461402f, 0.00211492f, 0.18767437f, -0.01923152f, 
    -0.17363891f, 0.03527967f, 0.10968127f, -0.10672529f, 0.01069391f, -0.00614953f, -0.19424315f, -0.05307977f, 
    0.10322689f, -0.10622251f, -0.13177460f, -0.12586339f, -0.02362047f, 0.15879920f, -0.07969798f, -0.12569810f, 
    0.18472978f, 0.05460364f, 0.10992322f, 0.01242235f, 0.26137578f, -0.23193775f, -0.30236888f, 0.03317612f, 
    0.19389135f, -0.20792992f, 0.09715497f, 0.14018168f, -0.08547805f, -0.00755476f, 0.11842888f, -0.37979016f, 
    -0.26636744f, 0.11235063f, 0.13417266f, -0.05280071f, 0.01199672f, 0.28093296f, 0.09156869f, -0.00950238f, 
    0.19765250f, -0.05703425f, -0.65086436f, 0.06528677f, -0.21972799f, 0.01102366f, -0.11346210f, 0.03530064f, 
    0.03916668f, -0.04434595f, 0.20540518f, -0.11295201f, -0.22022523f, -0.00745772f, 0.23876797f, 0.13431542f, 
    0.03941892f, -0.24576002f, -0.15198298f, 0.03398857f, -0.09941202f, -0.04516629f, 0.12389590f, 0.10402338f, 
    -0.22400406f, -0.03067455f, 0.00176545f, -0.23990169f, -0.26420930f, 0.06442526f, -0.10328724f, -0.27029300f, 
    -0.13755289f, -0.09487475f, -0.00600020f, 0.01299483f, -0.04102069f, 0.24316497f, 0.05495137f, -0.30668631f, 
    -0.15839340f, -0.25189844f, -0.04464654f, -0.10077568f, 0.07991616f, 0.18579860f, 0.37698814f, 0.03180585f, 
    0.00391400f, -0.11848676f, 0.18976648f, 0.17157622f, 0.22050187f, -0.01940404f, -0.19551799f, 0.45686793f, 
    0.18578658f, 0.04277333f, 0.00004338f, 0.15953003f, -0.04214496f, -0.15739928f, -0.38462150f, -0.03342170f, 
    -0.33262402f, 0.13684350f, 0.06137929f, 0.00606704f, 0.09768255f, -0.05373399f, -0.10348312f, 0.06822342f, 
    -0.07827369f, 0.20018588f, -0.26312810f, 0.12486440f, -0.11624803f, -0.03049551f, 0.01364420f, 0.14218901f, 
    -0.01143093f, -0.01294405f, 0.11499494f, 0.03613704f, 0.15148632f, 0.12295491f, -0.25948563f, -0.00932336f, 
    0.12680689f, 0.12803602f, 0.23463295f, 0.12752946f, 0.00583006f, -0.28242940f, -0.10752831f, 0.00566961f, 
    0.13178681f, -0.11537229f, -0.11031436f, 0.25223807f, 0.47456747f, 0.37082329f, -0.17942406f, 0.08137226f, 
    0.17483769f, 0.16552755f, -0.23322767f, -0.10025126f, 0.27176863f, -0.36425251f, -0.09402244f, -0.14187898f, 
    0.04793058f, 0.08603479f, -0.15998995f, -0.17163640f, 0.01197196f, 0.19975193f, 0.00767134f, 0.01517189f, 
    -0.03879543f, -0.00954665f, 0.04552126f, -0.17592573f, 0.03175638f, -0.09670155f, 0.29301029f, 0.34360752f, 
    -0.14422561f, -0.03609022f, -0.01778494f, -0.01464674f, 0.03172593f, -0.01706958f, 0.14926356f, 0.01647913f, 
    0.53824335f, -0.13662043f, 0.37972811f, 0.02099313f, -0.06678744f, 0.16079949f, 0.30411622f, 0.36987841f, 
    -0.26274219f, -0.49154082f, 0.11879227f, -0.08584675f, 0.06701881f, 0.07323053f, 0.06015740f, 0.18090031f, 
    0.10227367f, -0.23776591f, -0.29767528f, -0.03743525f, -0.08641744f, -0.01822173f, 0.08509836f, 0.00866613f, 
    0.03678693f, -0.11610904f, 0.15420362f, -0.27355608f, 0.12435191f, -0.08243521f, 0.15764676f, 0.11804885f, 
    -0.17604069f, -0.09695379f, 0.02405882f, -0.01082368f, -0.14386678f, 0.31822404f, 0.06924651f, -0.07881317f, 
    -0.10460173f, 0.14211446f, -0.31236318f, -0.03796600f, -0.27087551f, -0.07855969f, 0.16124292f, -0.22219685f, 
    0.04213500f, -0.12299197f, -0.27489400f, -0.17860045f, -0.15191926f, -0.68392253f, -0.16806647f, -0.10000063f, 
    -0.12740226f, 0.03231861f, 0.09273774f, 0.14192642f, 0.18919428f, 0.18379276f, 0.31306902f, 0.11891624f, 
    -0.12489395f, 0.26029769f, 0.15234905f, -0.01046876f, -0.02585424f, 0.27859059f, 0.19307238f, 0.48932266f, 
    -0.08270350f, 0.20624974f, -0.11826630f, 0.02562585f, 0.17020831f, -0.05024827f, 0.17539427f, 0.07851889f, 
    0.45728785f, -0.20915724f, -0.29748994f, 0.21617952f, -0.09938287f, 0.16489743f, -0.05907165f, -0.06212493f, 
    0.08286133f, 0.25954363f, 0.41396067f, 0.34889680f, 0.01365576f, 0.11002536f, 0.06237356f, -0.30909905f, 
    -0.14670484f, 0.18958949f, -0.24793503f, -0.72890949f, 0.00785705f, -0.20048553f, -0.00993802f, -0.01220731f, 
    -0.04746599f, -0.04167259f, 0.20498227f, 0.89482993f, 0.12581930f, 0.12632075f, -0.01280339f, 0.02650846f, 
    0.01377491f, 0.09808616f, -0.12388935f, -0.12979603f, -0.06203189f, -0.38509548f, -0.15712306f, 0.15321700f, 
    0.11936494f, 0.00743906f, 0.01737156f, -0.04160704f, -0.07647174f, 0.25647563f, 0.20738672f, 0.08033813f, 
    -0.20018241f, -0.07320838f, 0.08386704f, -0.13190761f, 0.22198243f, 0.14759326f, 0.52406067f, -0.34300932f, 
    -0.18556371f, -0.06437599f, 0.03847453f, -0.03548462f, -0.11784466f, 0.04709591f, 0.04001813f, -0.52980751f, 
    0.23235820f, 0.18721470f, -0.04838733f, -0.13251960f, -0.04837136f, 0.23062383f, 0.04966452f, -0.15658769f, 
    -0.13054515f, -0.42067990f, -0.09667335f, 0.17476155f, -0.02829610f, -0.15220696f, 0.25316212f, -0.13513960f, 
    0.20528369f, 0.06436772f, -0.14442098f, 0.20137914f, 0.10108567f, 0.05116720f, 0.02975343f, 0.23938979f, 
    -0.05594341f, 0.07826903f, 0.23475340f, 0.10315580f, 0.31253427f, -0.14411490f, -0.00976643f, 0.08760238f, 
    -0.19889671f, -0.04292990f, -0.13252498f, -0.11691191f, 0.04146174f, 0.06435001f, -0.03330153f, -0.02271160f, 
    0.09350247f, -0.21665405f, -0.01211323f, 0.05519677f, -0.20891446f, -0.01571183f, -0.39028358f, -0.10430990f, 
    -0.02804489f, -0.10233105f, 0.17822453f, 0.07342348f, -0.22903605f, 0.16309348f, -0.40280175f, 0.08872219f, 
    -0.14868729f, -0.07727576f, 0.17785856f, -0.14116687f, -0.21562424f, -0.12897716f, 0.12101505f, 0.00716729f, 
    0.08737465f, 0.20637766f, -0.01874303f, -0.03983058f, 0.03810361f, -0.05908131f, 0.18453996f, 0.24635167f, 
    0.14579472f, -0.04303033f, 0.09469987f, 0.07906278f, 0.11651670f, 0.09454224f, 0.07354845f, 0.07547273f, 
    0.24895562f, -0.11845181f, 0.09896173f, -0.24927817f, -0.02363699f, -0.01851723f, 0.02457043f, -0.08807621f, 
    0.16014650f, -0.03844340f, -0.47801304f, 0.36536822f, -0.11316751f, -0.38440287f, 0.10121675f, -0.07159449f, 
    0.00167083f, -0.06559454f, -0.05331479f, -0.53409749f, 0.01868765f, 0.09952573f, 0.01080985f, 0.02022900f, 
    0.16001688f, -0.04034504f, -0.12764619f, 0.27756292f, -0.02664273f, -0.04280762f, 0.03489977f, -0.14378954f, 
    0.21704203f, -0.06728081f, 0.17349873f, -0.00145053f, 0.20740810f, 0.10995227f, 0.19435112f, 0.06195648f, 
    0.09385831f, -0.28752187f, -0.02008886f, -0.21008687f, -0.05422922f, -0.10797144f, 0.19652309f, 0.14357187f, 
    0.04518336f, 0.09913450f, -0.02079712f, -0.02188958f, 0.06078326f, -0.03241002f, 0.10624603f, -0.43717828f, 
    0.41706893f, 0.07303814f, 0.06018805f, 0.17818937f, 0.02665656f, -0.05143827f, 0.18955116f, -0.15378073f, 
    -0.23766232f, 0.08543287f, -0.04569324f, 0.02244229f, -0.11347328f, -0.19742133f, -0.02820302f, 0.25868127f, 
    0.21207364f, -0.08952749f, 0.22054116f, 0.22629334f, 0.27255952f, 0.00203092f, 0.16941112f, -0.18907124f, 
    -0.00816984f, 0.03447909f, -0.27935180f, 0.17673673f, 0.04590428f, -0.04176664f, 0.11952509f, 0.04227771f, 
    0.14293006f, -0.06719780f, 0.06027585f, 0.06935658f, 0.30581835f, 0.16730101f, 0.20300604f, 0.16588394f, 
    0.10087078f, -0.04177611f, -0.02401039f, 0.14144549f, 0.14735928f, -0.10111362f, -0.21528530f, 0.10894588f, 
    -0.08004076f, -0.00621815f, -0.21410042f, -0.03071208f, 0.03440104f, 0.09733290f, 0.09097804f, -0.11164878f, 
    -0.06423879f, 0.00493420f, 0.17649439f, -0.06891157f, -0.00543186f, -0.02667041f, 0.04477742f, -0.13525712f, 
    0.04112991f, 0.07039815f, 0.04522095f, -0.13570324f, 0.08688369f, 0.02672562f, 0.05364509f, -0.25719410f, 
    0.41571450f, -0.21348938f, -0.17545262f, -0.06256258f, -0.03582352f, -0.02708355f, -0.00190283f, -0.07343480f, 
    -0.05234538f, -0.35429874f, 0.02631639f, 0.33253416f, -0.27380380f, -0.08219822f, -0.01114386f, 0.05478116f, 
    -0.07660367f, -0.05182907f, 0.17454718f, 0.03043097f, -0.22331712f, -0.17420408f, 0.09682755f, 0.06302442f, 
    0.00137794f, -0.11571906f, 0.10240462f, -0.47870818f, -0.02232426f, -0.32820922f, 0.06011254f, -0.21144667f, 
    0.22191051f, -0.15014823f, -0.14592925f, -0.06935265f, -0.01477479f, 0.27374202f, 0.01512790f, 0.01560736f, 
    -0.04371442f, 0.10386866f, -0.08506835f, -0.01721801f, 0.24610379f, -0.05677833f, 0.08071999f, 0.23921473f, 
    -0.14309794f, -0.10658742f, -0.11874773f, -0.23025453f, -0.16100143f, -0.21115580f, -0.00578563f, 0.13677529f, 
    -0.02365983f, 0.18850054f, 0.16292089f, -0.14964774f, -0.05360862f, 0.24616536f, -0.11379299f, 0.00730376f, 
    0.09928725f, 0.07114670f, -0.09142234f, 0.05035644f, -0.16684730f, 0.01810934f, 0.02913260f, 0.22873633f, 
    0.30814067f, 0.05612845f, -0.11286170f, -0.10423845f, -0.00484857f, 0.12759767f, 0.01456173f, 0.26399878f, 
    0.05617494f, -0.03228587f, -0.25181442f, -0.19522262f, 0.24668147f, -0.14876042f, 0.14338061f, -0.11824490f, 
    0.00762683f, 0.05584720f, -0.05754053f, 0.02560491f, -0.00798663f, -0.16091271f, -0.11266667f, 0.08544338f, 
    -0.15847348f, -0.11257119f, -0.06793980f, 0.16126113f, 0.08626284f, -0.24220569f, -0.11513973f, -0.01259520f, 
    0.04423652f, -0.00175610f, -0.10351177f, -0.05951585f, -0.14573340f, 0.20067680f, -0.06940310f, -0.05452451f, 
    -0.20152000f, -0.14959843f, -0.26829985f, 0.37582344f, 0.05061970f, -0.20378698f, -0.13118938f, -0.01956149f, 
    -0.07775285f, -0.01832260f, 0.03438758f, -0.04156078f, 0.58885694f, 0.27646604f, -0.13339326f, -0.16618431f, 
    0.22180004f, 0.05860636f, -0.23263381f, 0.18100801f, -0.06861474f, -0.39687708f, 0.12887986f, 0.50454450f, 
    0.01632425f, 0.29682881f, 0.28341085f, 0.16281199f, 0.02110721f, 0.05385316f, -0.05181679f, -0.04467539f, 
    0.20097072f, -0.03323872f, -0.08144719f, 0.01445528f, 0.21141267f, 0.07698982f, -0.01058662f, 0.41024211f, 
    -0.24873927f, -0.14839147f, -0.00156562f, 0.05073655f, 0.17108129f, -0.02683777f, 0.10779320f, -0.29168949f, 
    0.20423798f, -0.14045720f, 0.38152695f, -0.00659022f, 0.00063795f, -0.23667121f, -0.07286158f, -0.06444022f, 
    0.01271360f, -0.28792650f, 0.18731429f, 0.79781520f, -0.40961647f, 0.09086854f, -0.19997056f, -0.06811540f, 
    0.00893739f, 0.11577948f, -0.03486166f, 0.21841033f, 0.11558442f, 0.03662434f, 0.01849541f, 0.03803448f, 
    0.08642410f, 0.04886528f, 0.02620840f, 0.01552321f, -0.24796560f, 0.40576103f, -0.09669840f, 0.03451943f, 
    0.20026150f, -0.11859228f, 0.00666913f, 0.13774770f, -0.07712318f, 0.09993804f, -0.15916269f, 0.03496990f, 
    -0.07507969f, -0.00572369f, -0.25114581f, -0.05402061f, -0.05614026f, -0.38488778f, 0.29745144f, 0.01397055f, 
    0.12736021f, -0.14990415f, -0.18712610f, -0.06499700f, 0.00587118f, -0.08109038f, 0.16735885f, -0.11091477f, 
    0.08298895f, -0.29851651f, -0.06886797f, -0.22680551f, -0.16099928f, 0.24614751f, -0.15444499f, -0.08991975f, 
    0.03211559f, 0.23604931f, -0.21473709f, 0.01761886f, 0.03947862f, -0.17344324f, 0.07123520f, -0.05749099f, 
    0.05849043f, -0.05501232f, -0.12989227f, 0.12546496f, 0.18421975f, -0.03158836f, 0.07075077f, 0.05490101f, 
    -0.01368999f, 0.00738699f, -0.07671038f, -0.05745726f, -0.01429402f, 0.02264228f, -0.04066239f, 0.09204004f, 
    -0.22735447f, 0.09294964f, 0.05030802f, -0.29078266f, -0.07898547f, 0.05240464f, 0.09617095f, 0.00969675f, 
    -0.00384490f, -0.04171780f, -0.20578334f, -0.01051449f, 0.02167111f, -0.34266654f, 0.21496294f, -0.34564060f, 
    -0.17631143f, 0.03294231f, 0.03530138f, 0.00592202f, 0.26043421f, -0.05062034f, -0.09250814f, 0.07650454f, 
    -0.11951929f, -0.20574503f, -0.11984437f, 0.09748533f, -0.13175064f, 0.39950183f, -0.03630164f, -0.30304962f, 
    -0.12803772f, 0.09389289f, 0.18410580f, 0.03954720f, 0.00228521f, -0.07441206f, 0.09365339f, 0.08430310f, 
    0.59353083f, -0.21228227f, 0.19789371f, 0.17400950f, 0.07134629f, -0.09913071f, 0.14497007f, 0.14457598f, 
    -0.05219735f, -0.21708842f, 0.11557990f, -0.22981505f, 0.07370785f, 0.17973861f, 0.17890880f, 0.22770494f, 
    0.17215163f, 0.08236553f, -0.26421177f, -0.25526321f, -0.18009190f, 0.02931108f, -0.28681597f, 0.04873423f, 
    0.05851974f, 0.39399463f, 0.16243111f, -0.13000898f, 0.03818358f, 0.06396592f, -0.03399970f, -0.06037656f, 
    0.10103098f, 0.13677537f, -0.42740941f, 0.51749998f, -0.25392142f, 0.13878255f, 0.16827600f, -0.06397776f, 
    -0.05912923f, -0.07391023f, -0.05622287f, -0.14485815f, -0.01925761f, -0.12211630f, 0.35868758f, -0.13659893f, 
    0.02965712f, -0.06137164f, 0.05057744f, -0.00294208f, -0.38775340f, 0.10298837f, -0.12417985f, -0.00382803f, 
    0.09927552f, 0.05571137f, -0.15851621f, -0.15828699f, 0.08696222f, -0.09304439f, 0.03227139f, 0.36292726f, 
    0.41293335f, 0.03062075f, 0.12987781f, -0.08380982f, -0.11681332f, -0.03110401f, 0.02165441f, 0.24253663f, 
    -0.29093587f, 0.01757607f, -0.16590111f, 0.02343791f, -0.12113441f, 0.10373776f, -0.24686739f, 0.47080240f, 
    0.03549700f, 0.19949037f, -0.11370569f, 0.13550709f, 0.04615138f, -0.12001088f, 0.00654634f, 0.03391109f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.17031294f, 0.02085692f, -0.03660939f, 0.03677506f, 0.02351109f, 0.07584608f, 0.08882660f, 0.21575241f, 
    -0.05738705f, 0.07658428f, 0.03926597f, 0.04468364f, -0.00400494f, 0.22371008f, -0.06789137f, -0.01047799f, 
    -0.03392355f, 0.00824635f, -0.03049808f, -0.01024127f, -0.08064519f, 0.04162812f, 0.00913875f, 0.02860231f, 
    0.02617291f, -0.05521425f, 0.12076316f, 0.00051635f, 0.13880511f, -0.11422027f, 0.18422668f, -0.05963882f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04733867f, 0.08528342f, 0.00595290f, 0.16993907f, -0.00816604f, 0.02086606f, -0.26342800f, -0.18979874f, 
    -0.09426684f, 0.47900060f, 0.09045947f, 0.09968663f, -0.84178734f, -0.48088840f, 0.07763223f, -0.07150687f, 
    -0.33007723f, 0.03230020f, 0.04627734f, 0.09076212f, 0.35955742f, 0.15137175f, -0.12791172f, 0.12854235f, 
    0.04196275f, -0.59670538f, 0.21689144f, -0.23010446f, 0.71921235f, -0.01540169f, -0.69738704f, -0.15307318f, 
    0.36791763f, 0.16559049f, 0.13834575f, -0.36850345f, -0.01029966f, -0.01860308f, -0.29226911f, 0.03239752f, 
    0.04299286f, 0.26310369f, -0.05501242f, -0.07044754f, 0.26314676f, -0.19520229f, 0.06675480f, -0.09379156f, 
    -0.06956964f, -0.04287086f, -0.12478366f, -0.08629848f, -0.60670382f, 0.12322209f, -0.18672939f, 0.14202060f, 
    0.11614633f, -0.07169656f, 0.96474278f, 0.11008400f, 0.08389888f, 0.02399794f, 0.01199395f, -0.00790307f, 
    -0.09166767f, -0.07073113f, -0.13442576f, -0.05533422f, -0.01627008f, 1.05637836f, -0.33565128f, 0.10589489f, 
    0.06837476f, -0.18901159f, -0.12387260f, 0.04604601f, -0.22450383f, -0.42463475f, 0.13662790f, 0.10532494f, 
    -0.10306119f, 0.09003984f, -0.06518333f, -0.00187414f, -0.28201464f, 0.14795798f, -0.38583308f, -0.11517604f, 
    0.08366849f, 0.16727215f, -0.10855221f, 0.61442524f, 0.05709839f, -0.67711526f, 0.00356320f, 0.23976873f, 
    -0.00460426f, -0.12808713f, -0.05636613f, 0.02887102f, -0.09814352f, 0.04397769f, -0.06650033f, 0.09255499f, 
    -0.09764645f, -0.21155898f, -0.01065661f, -0.02592497f, -0.17320539f, -0.25716868f, -0.04814783f, 0.05601398f, 
    -0.99089640f, 0.01847106f, -0.17275181f, 0.03144689f, 0.26684019f, -0.06146635f, 0.30758634f, 0.04295678f, 
    0.12119323f, -0.57964623f, -0.87458628f, 0.00306160f, -0.33762509f, 0.62893951f, 0.18037981f, -0.16027991f, 
    -0.16268906f, -0.10017521f, -0.10059929f, 0.70491511f, 0.09533175f, -0.10066543f, 0.11733304f, -0.01948012f, 
    0.12142636f, -0.39442906f, -0.06145103f, -0.06040127f, -0.66535789f, 0.05345137f, 0.07689156f, -0.04422216f, 
    0.36986530f, -0.05573285f, -0.01676841f, -0.06266310f, 0.23103777f, -0.02223915f, -0.24649398f, 0.08981773f, 
    0.15674488f, -0.30797404f, -0.28816003f, -0.13602352f, -0.18352130f, -0.07025526f, 0.48699433f, 0.34331295f, 
    -0.36765051f, -0.12101741f, -0.15781868f, 0.32436463f, 0.03882797f, -0.49443033f, 0.17729129f, -0.91777015f, 
    0.02600078f, 0.24905668f, -0.07821049f, 0.11562937f, 0.59123415f, 0.23680484f, -0.04112728f, 0.13864855f, 
    0.16144799f, -0.09551400f, -0.03938584f, -0.02047233f, -0.26860335f, 0.03116205f, -0.10500704f, -0.14073943f, 
    0.09396315f, 0.13585766f, -0.24060315f, -0.20292643f, 0.51816005f, 0.30773821f, 0.02770635f, -0.62607622f, 
    -0.60649842f, -0.10393566f, 0.06958646f, 0.03327236f, 0.09618475f, 0.23137316f, 0.53571594f, 0.33959001f, 
    0.14466284f, 0.00414727f, 0.08292437f, 0.10366794f, 0.86817676f, -0.53239417f, -0.10107804f, 0.10462709f, 
    0.01550133f, 0.13684036f, 0.07208913f, -0.14439413f, 0.26989880f, -0.11215647f, -0.21346715f, 0.03516058f, 
    0.14763695f, -0.21979378f, -0.34693211f, -0.86079496f, -0.56559271f, -0.03520349f, -0.24059741f, -0.41275427f, 
    0.12684371f, -0.03427094f, 0.00100695f, -0.22613293f, 0.06255607f, -0.28466466f, -0.41681811f, -0.81462276f, 
    0.15600336f, -0.57695174f, 0.14679581f, 0.13665478f, 0.05094485f, -0.05547847f, 0.09971399f, 0.00186353f, 
    0.33134651f, 0.15066046f, 0.05037157f, 0.14846374f, 0.20521630f, 0.07855950f, 0.23248987f, -0.13396144f, 
    -0.06146008f, 0.13885558f, -0.17712201f, -0.09252887f, -0.14338209f, 0.41192949f, -0.64033633f, 0.84897542f, 
    0.24623007f, 0.00285750f, -0.08493401f, -0.01449987f, 0.10052855f, -0.57087314f, -0.28905058f, -0.16044119f, 
    0.16042621f, 0.03697997f, 0.07256141f, -0.01764805f, -0.05574287f, 0.66773474f, 0.05309541f, 0.09838851f, 
    -0.03049558f, 0.15805411f, 0.16095598f, -0.00099995f, 0.05653920f, 0.14765671f, 0.08618448f, -0.06366578f, 
    -0.09849014f, 0.87229609f, 0.30439240f, 0.88613629f, -0.50667596f, -0.44111621f, -0.25711176f, -0.09165467f, 
    -0.35999325f, -0.06273467f, 0.10528387f, -0.14819379f, 0.02755235f, -0.19868264f, -0.27685329f, 0.74332231f, 
    0.10713282f, 0.15194328f, -0.05046134f, -0.08767465f, -0.35627925f, 0.67234045f, 0.02830204f, 0.10078588f, 
    0.79868501f, 0.07687396f, -0.14551678f, 0.13361943f, 0.32870278f, -0.05008853f, -0.15036234f, -0.10792834f, 
    -0.07698067f, 0.12400848f, -0.54351372f, -0.36093047f, 0.24285042f, -0.26103568f, -0.48371354f, -0.22538039f, 
    0.60661799f, -0.07574967f, 0.09428125f, -0.47163039f, -0.06512489f, 0.43830401f, 0.03491867f, -0.03057677f, 
    0.11379468f, -0.74266100f, -0.11577912f, 0.01451406f, 0.12886819f, 0.34052929f, -0.17645413f, -0.12143179f, 
    -0.50915170f, 0.11177526f, 0.01399693f, -0.05646548f, -0.29236761f, -0.18435639f, 0.77042890f, -0.07020977f, 
    -0.16676016f, -0.29297349f, -0.26424873f, -0.19561815f, -0.02160406f, -0.38422665f, 0.04797586f, 0.02126789f, 
    0.32630149f, -0.04144003f, 0.01311110f, -0.44576854f, -0.00560859f, -0.03260361f, 0.75239938f, 0.04870917f, 
    0.00733607f, 0.05370059f, 0.11854761f, -0.01244339f, -0.45643634f, -0.75883627f, 0.09603704f, -0.15459487f, 
    -0.58679271f, -0.11467646f, -0.05448726f, 0.02161856f, 0.24034140f, -0.09559507f, -0.30146962f, 0.14085904f, 
    -0.04152700f, 0.43433821f, -0.09307634f, -0.35523474f, -0.58483237f, 0.00975635f, 0.28829226f, -0.06150778f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08315322f, 0.15358296f, -0.43366036f, -0.13846861f, 0.22143854f, 0.03412383f, 0.13620731f, -0.10782034f, 
    -0.19414416f, 0.04631514f, 0.14935049f, -0.14440480f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
