#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.51575941f, 0.19193108f, 0.19704276f, 0.07284033f, 0.18588710f, -0.77330303f, 0.40766665f, 0.45273134f, 
    -0.69768631f, -0.76452160f, -0.23589528f, 0.17113996f, -0.17004438f, 0.31272081f, 0.04654983f, 0.04931451f, 
    -0.01136843f, 0.07393189f, 0.00582871f, 0.11068381f, -0.34357938f, -0.15356891f, -0.27574816f, -0.14544554f, 
    -0.17051756f, 0.52496469f, 0.71128571f, 0.24118575f, 0.41186979f, 0.67567563f, -0.14951612f, 0.25272763f, 
    0.49236929f, 0.20540294f, 0.14687821f, -0.24604087f, -0.04570667f, 0.29195854f, 0.24510765f, 0.01873607f, 
    -0.14849193f, 0.23089479f, -0.17791006f, -0.10336480f, -0.23191290f, -0.13772516f, -0.24923359f, -0.18314038f, 
    0.32066518f, -0.09966812f, -0.11824524f, 0.71271539f, -0.34469098f, -0.34607252f, 0.22957963f, 0.57437849f, 
    -0.62255466f, -0.69562781f, -0.66514200f, 0.09967628f, -0.20425715f, 0.11672733f, 0.18463916f, 0.10028189f, 
    0.16086787f, 0.25355735f, -0.02350209f, 0.10479373f, -0.00300811f, -0.04413765f, 0.22560200f, 0.04374161f, 
    0.29906735f, -0.36650923f, -0.22067894f, -0.60667878f, -0.38352039f, -0.37302601f, 0.45141080f, -0.07302237f, 
    0.61396503f, 0.28761914f, -0.05819061f, -0.16437015f, -0.55336595f, -0.32021478f, 0.36840284f, -0.28523961f, 
    0.48555374f, 0.13007359f, 0.13292015f, -0.11765440f, -0.55032921f, -0.11989406f, -0.11366145f, -0.04690761f, 
    0.11399665f, 0.26239324f, 0.06335294f, 0.11243556f, -0.39204237f, -0.25700250f, 0.69681978f, 0.90047866f, 
    0.22828476f, 0.23532948f, 0.08527855f, 0.48076975f, 0.30549392f, 0.27869362f, -0.31274861f, -0.35384643f, 
    -0.18338697f, -0.03202378f, -0.41701487f, -0.09976423f, 0.00080820f, -0.11518295f, -0.01586176f, -0.22596313f, 
    0.43511131f, 0.04101284f, -0.36782292f, -0.34257379f, -0.13623963f, -0.01170050f, -0.05844606f, -0.57861370f, 
    -0.50191188f, -0.58766991f, 0.37342346f, 0.57697481f, 0.42842701f, -0.28754294f, 0.02526211f, -0.45943075f, 
    -0.22431152f, -0.40851223f, -0.07465435f, 0.06060566f, -0.16330417f, -0.17798941f, 0.11982381f, 0.07024102f, 
    0.07233060f, -0.00619458f, -0.02572145f, -0.10747696f, -0.14262402f, 0.20985280f, 0.60379261f, -0.38138160f, 
    0.65702748f, 0.67014819f, -0.26659784f, 0.16387720f, -0.54396105f, 0.45496273f, -0.12572408f, 0.17679347f, 
    0.34428307f, 0.11420710f, 0.23748398f, -0.08207393f, 0.15063590f, -0.48160207f, 0.23508865f, 0.44526702f, 
    0.16606241f, 0.06117382f, -0.35640451f, -0.15470330f, -0.23309913f, 0.16917472f, -0.02832457f, 1.05835772f, 
    0.84097803f, 0.21525253f, -0.60683960f, -0.73062479f, -0.29896063f, -0.52899569f, 0.14400740f, -0.25433633f, 
    0.21983713f, 0.26624072f, -0.01656896f, -0.11546149f, -0.09354720f, -0.24438545f, -0.17086613f, -0.31171519f, 
    -0.26344582f, -0.29864135f, 0.06419080f, 0.01371845f, 0.25305587f, -0.24548487f, -0.00385803f, -0.19176996f, 
    -0.13351470f, -0.02329810f, -0.33879533f, -0.40211877f, -0.04918330f, -0.29524297f, -0.83239186f, -0.44715476f, 
    -0.29333881f, 0.17771067f, 0.42127472f, 0.29350045f, 0.18300217f, -0.04652467f, -0.14874120f, -0.12274475f, 
    0.13882864f, -0.01369681f, 0.22571127f, 0.63867235f, 0.34969494f, 0.03362235f, -0.09885304f, 0.16952677f, 
    0.29147103f, -0.49150512f, -0.60858995f, -0.85231268f, -0.52873957f, -0.22149763f, 0.29827723f, 0.13659611f, 
    0.19076133f, 0.39215207f, 0.43815783f, -0.31214714f, -0.07024600f, 0.25260067f, -0.29112229f, -0.29031667f, 
    -0.23852834f, -0.02931517f, 0.24006167f, 0.38766494f, -0.35911340f, -0.05887980f, 0.04158014f, -0.14875279f, 
    -0.27427542f, 0.22903815f, -0.15246885f, -0.41742149f, -0.24606580f, 0.10010952f, -0.37192148f, -0.34462416f, 
    -0.39999837f, 0.01362131f, -0.21829997f, 0.05391231f, -0.46645364f, -0.02878803f, 0.22278321f, 0.20834166f, 
    -0.17101642f, -0.40773869f, -0.18640301f, -0.60313171f, 0.15757634f, -0.01522650f, -0.43242335f, 0.18071261f, 
    0.12138880f, 0.13381085f, 0.26290268f, 0.29136574f, -0.01163219f, -0.25345719f, -0.30392495f, 0.21826869f, 
    0.51437181f, 0.32348251f, 0.33308494f, 0.51978517f, 0.77162617f, 0.09492398f, -0.43151087f, 0.13430978f, 
    -0.39790756f, -0.13292745f, -0.21756411f, -0.13019536f, -0.39785984f, 0.11311503f, -0.01834048f, -0.05686622f, 
    -0.25553557f, -0.28210819f, -0.14621782f, 0.09273013f, -0.13812116f, 0.31784672f, 0.15712385f, -0.31467718f, 
    0.16095269f, 0.07355618f, 0.00029677f, -0.85395736f, 0.51056296f, -0.42035207f, -0.43173638f, -0.31795079f, 
    -0.46093160f, 0.10542104f, -0.00011360f, -0.18844865f, 0.07764413f, -0.50644070f, -0.41893095f, -0.34378043f, 
    -0.05073542f, 0.02399441f, 0.04928329f, 0.28854057f, 0.04791103f, 0.54830498f, 0.62639260f, 0.61793202f, 
    0.94649863f, 0.68625975f, 0.35349748f, 0.10593639f, -0.52194196f, -0.29425922f, -0.05588254f, 0.09688537f, 
    -0.17640533f, -0.02311959f, 0.16747548f, -0.46362242f, -0.13836470f, 0.01657927f, 0.25653243f, -0.10796902f, 
    -0.00962030f, -0.12740707f, 0.37766096f, -0.12805413f, 0.10437185f, -0.02131771f, -0.11136137f, -1.03551972f, 
    -0.58472717f, -0.06215807f, -0.22516763f, -0.41607556f, 0.66462922f, 0.57434165f, -0.45191288f, 0.29420450f, 
    -0.09252434f, -0.09274939f, -0.32407123f, -0.42186350f, -0.07824368f, 0.00865912f, 0.11811776f, -0.03573244f, 
    -0.15834029f, -0.04240678f, 0.05265765f, 0.11912862f, 0.16713025f, 0.17286505f, 0.05629843f, -0.42290288f, 
    0.12897064f, 0.90437114f, 0.56858093f, -0.57973295f, -0.66955394f, -0.28063059f, 0.21832150f, -0.19597478f, 
    -0.43099755f, 0.22632158f, 0.10291304f, 0.04589720f, 0.07778351f, 0.41026768f, -0.11271705f, 0.30291545f, 
    0.10817986f, -0.01554483f, 0.03097305f, 0.20296107f, 0.09338447f, 0.07568321f, 0.15526929f, -0.02989917f, 
    -0.21266201f, -0.29998061f, -0.27792537f, -0.06966579f, 0.38165787f, -0.58714092f, -0.52908516f, -0.07058115f, 
    -0.10931841f, -0.61665505f, -0.00548990f, 0.31085572f, -0.08994666f, 0.25094318f, 0.33543444f, 0.24556075f, 
    0.17827331f, 0.19551082f, 0.00971004f, 0.11608440f, 0.05750493f, -0.10298738f, 0.17972533f, 0.00937083f, 
    0.22483656f, -0.75891340f, 0.72762960f, -0.13491511f, -0.61622071f, 0.80716705f, -0.01236149f, -0.35697943f, 
    -0.12904190f, -0.54693502f, -0.30957457f, 0.26948330f, -0.16115479f, 0.11427967f, 0.10424280f, -0.13753584f, 
    -0.15464586f, -0.09514517f, -0.24860808f, -0.15997258f, -0.10443456f, 0.10368375f, 0.16668351f, 0.15615749f, 
    0.20788625f, 0.14562018f, -0.08396671f, -1.09238458f, 0.01942482f, 0.58045119f, -0.20999549f, -0.49087423f, 
    0.64534062f, 0.35691020f, -0.48215431f, -0.05747010f, 0.32195610f, 0.41755262f, -0.01495927f, 0.19949536f, 
    0.30441490f, -0.02193085f, -0.07634246f, -0.22598985f, 0.13344875f, -0.35129339f, -0.07409691f, 0.04974457f, 
    0.15528183f, 0.22522262f, 0.16649613f, -1.02716887f, 0.30265290f, 0.85989696f, -0.29066026f, 0.16373330f, 
    -0.51659691f, 0.76656741f, 0.02163114f, 0.08544031f, 0.19376139f, -0.12035240f, 0.30498987f, 0.26899692f, 
    0.11297365f, -0.13942158f, -0.05701616f, -0.25303602f, 0.08990845f, -0.14663252f, 0.01863479f, 0.27625293f, 
    0.23504464f, -0.11977477f, 0.00670159f, -0.28244510f, 0.68520451f, 0.60985756f, 0.92038244f, 0.63609260f, 
    0.38610911f, -0.49054894f, -0.43900555f, -0.61178339f, -0.46692851f, -0.13517153f, 0.09335259f, 0.08878077f, 
    -0.42860588f, 0.25586095f, 0.23967347f, 0.10457595f, -0.28346285f, -0.23195143f, 0.13707444f, 0.09805302f, 
    0.13310538f, 0.10680122f, 0.20524314f, 0.11079752f, 0.37768650f, -0.43276721f, -0.44784439f, -0.09088536f, 
    -0.30288583f, -0.05624605f, -0.53771293f, 0.57653815f, 0.71194130f, -0.53630120f, 0.00391598f, -0.19567287f, 
    0.04892017f, 0.23942253f, -0.12527114f, -0.18822192f, -0.36748186f, -0.24846408f, -0.10829015f, 0.36294693f, 
    -0.18332644f, 0.14001852f, -0.04848823f, 0.19557831f, -0.07906128f, -0.11978059f, 0.30425665f, 0.89696258f, 
    0.75956720f, -0.48805425f, -0.20074973f, -0.76537192f, 0.57707405f, -0.49506500f, -0.23033306f, -0.17480434f, 
    0.16919056f, 0.13998207f, -0.03715391f, -0.29607019f, 0.36928320f, 0.05438168f, -0.01167426f, 0.22813176f, 
    0.12907429f, -0.33935955f, -0.20376226f, -0.29633379f, -0.01483569f, 0.07013346f, 0.18404073f, 0.08807091f, 
    -0.35575956f, -0.51036185f, -0.41534999f, -0.26561081f, -0.39320755f, -0.28524455f, -0.01690558f, 0.32766122f, 
    -0.47551233f, -0.47050574f, -0.25876451f, 0.34487435f, -0.09703117f, -0.45140916f, 0.25594777f, -0.26243570f, 
    -0.10088914f, -0.09200694f, -0.12765917f, -0.05441885f, 0.11150455f, 0.08962735f, -0.09871877f, 0.11597904f, 
    -0.45587215f, 0.32866231f, -0.34117192f, -0.63959104f, -0.46901914f, 0.30849367f, 0.39678711f, -0.30823588f, 
    0.02429965f, 0.40377587f, -0.16292065f, -0.22497787f, -0.29558238f, -0.27126938f, -0.35707808f, 0.10846556f, 
    0.11994933f, -0.05929409f, 0.07138287f, 0.09936702f, -0.18714376f, -0.25249475f, -0.17587951f, -0.11361998f, 
    0.12400252f, -0.77729368f, -0.73920131f, -0.38864437f, 0.13025849f, -0.12860008f, -0.46651554f, -0.23722288f, 
    -0.31404650f, 0.08787937f, 0.18695663f, 0.55394197f, 0.14403048f, -0.14617723f, 0.17893040f, -0.24778189f, 
    0.17482477f, 0.20597135f, 0.34277728f, -0.32050043f, -0.01476311f, -0.10696019f, 0.15617378f, -0.02725936f, 
    -0.01642477f, -0.15986115f, -0.21284989f, -0.44374159f, 0.49473521f, -0.46904612f, -0.40547827f, -0.13879164f, 
    -0.27887902f, -0.70579684f, -0.20589143f, 0.11847912f, -0.08017684f, 0.22622667f, 0.04101016f, 0.08135209f, 
    -0.31815037f, -0.44066602f, 0.17774008f, 0.10755555f, -0.06820323f, -0.11357196f, 0.03955406f, -0.13957426f, 
    0.40444469f, 0.28874290f, -0.08207181f, 0.28356579f, 0.53952307f, 0.37188697f, -0.43603376f, 0.39479658f, 
    -0.45438167f, -0.22304156f, 0.43422705f, 0.57056719f, -0.26733363f, -0.07890739f, -0.29360372f, 0.28812861f, 
    0.21304107f, 0.38949081f, 0.08500119f, -0.11147660f, -0.00401308f, -0.36297482f, -0.35409269f, 0.28000721f, 
    -0.22129805f, 0.39141256f, -0.14251903f, 0.36988395f, 1.01788354f, -0.36060861f, -0.19792916f, 0.95280629f, 
    0.29228914f, -0.68334466f, 0.45451018f, 0.14685802f, -0.08335866f, 0.23702750f, -0.07617639f, -0.01652899f, 
    0.05918656f, -0.31505072f, 0.13411227f, -0.12461732f, -0.09358530f, 0.04719768f, 0.21894723f, -0.19088751f, 
    -0.16186415f, -0.12885357f, -0.20887332f, -0.23879820f, 0.22444861f, -0.74193484f, 0.83561772f, -0.14357628f, 
    -0.03354728f, 0.28378525f, -0.09861329f, 0.73023051f, 0.45467240f, 0.12190563f, 0.41114157f, -0.32940638f, 
    0.01935660f, 0.38058260f, -0.31421086f, 0.30044040f, 0.10524496f, -0.02299230f, -0.21121392f, 0.08987711f, 
    -0.05312233f, 0.19827652f, 0.30401903f, 0.21635637f, 0.45826390f, 0.04933901f, -0.60826248f, -0.62873316f, 
    -0.75544071f, 0.09124418f, 0.50745535f, 0.02754961f, 0.85101032f, 0.29357630f, 0.46567723f, 0.35635853f, 
    -0.00736688f, -0.05194857f, 0.06467867f, -0.06483096f, -0.09288377f, -0.01878900f, 0.09190319f, -0.09181134f, 
    -0.05081444f, -0.23160808f, 0.08879270f, -0.24189782f, -0.21938694f, -0.09479973f, -0.08221281f, -0.96167243f, 
    0.98979557f, -0.20565999f, -0.71682644f, -0.60282987f, 0.63133687f, 0.24894750f, -0.47801349f, 0.47284338f, 
    0.26381916f, 0.06151013f, -0.09845325f, -0.11817466f, 0.16794528f, -0.06073008f, 0.02975358f, 0.01549924f, 
    0.19904764f, 0.08963681f, -0.27092519f, -0.06316495f, -0.20618550f, 0.15664193f, 0.06527152f, 0.09557906f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14381881f, 0.05417310f, 0.26321724f, 0.16266483f, 0.07855025f, -0.09324989f, 0.20767079f, 0.31367961f, 
    0.03500150f, -0.08467721f, 0.21462157f, 0.16438127f, 0.05693329f, 0.08166202f, 0.04413695f, 0.34337926f, 
    0.31988400f, 0.14145504f, 0.00305944f, 0.15248708f, 0.36273846f, 0.01316066f, 0.17497154f, 0.19786957f, 
    0.07239255f, 0.32247299f, 0.07077071f, 0.22132587f, 0.07875013f, 0.04963981f, 0.18743110f, 0.20655088f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25559163f, -0.20607564f, -0.11972034f, -0.06133052f, 0.13354446f, 0.03626919f, 0.00559189f, -0.13614778f, 
    -0.13436347f, 0.11939143f, -0.02542456f, 0.09785590f, 0.28164604f, 0.04701877f, 0.05871748f, 0.18477261f, 
    0.14304520f, 0.05515762f, -0.04849143f, -0.02718233f, 0.01283320f, -0.01096728f, 0.02644987f, 0.04928472f, 
    -0.29179168f, -0.08005530f, -0.01330821f, -0.06059355f, -0.01382504f, 0.05758085f, 0.01347589f, 0.02231808f, 
    0.16089748f, 0.04675186f, 0.10670108f, -0.01314635f, -0.05116295f, -0.02068319f, -0.20872383f, -0.13151129f, 
    -0.10480291f, -0.08940322f, 0.04687113f, 0.07862645f, -0.03886206f, 0.00259573f, -0.16077326f, 0.13703348f, 
    0.20340894f, 0.07852655f, 0.04773149f, -0.07233801f, 0.10201026f, -0.04321345f, -0.07977124f, 0.07713197f, 
    0.00542631f, 0.14939296f, 0.09156920f, -0.06274509f, -0.15694682f, 0.13365439f, -0.02489282f, 0.09240841f, 
    0.09955309f, -0.03757755f, -0.11129090f, -0.01717666f, -0.02099908f, 0.07902160f, 0.00632933f, -0.07807453f, 
    -0.19362660f, 0.23355059f, 0.09984513f, -0.02745179f, 0.09867454f, 0.05932591f, -0.07620865f, -0.12852134f, 
    0.09311435f, -0.09842749f, 0.23081400f, -0.00635430f, 0.14219479f, -0.03154379f, -0.04906109f, -0.14897871f, 
    0.03557958f, -0.01286862f, 0.14638534f, -0.11092718f, 0.04001961f, 0.08401476f, 0.03893202f, -0.05597512f, 
    -0.00243114f, 0.03473186f, 0.06131853f, -0.00141737f, -0.13551563f, 0.01415188f, 0.04637077f, 0.07258378f, 
    0.07855193f, 0.16143698f, 0.00599668f, 0.16680354f, -0.08446369f, -0.11041054f, 0.17818342f, 0.36713573f, 
    0.00292063f, 0.03699876f, -0.15750298f, -0.10691615f, 0.02616705f, -0.07609130f, 0.10753021f, -0.06400321f, 
    -0.24763097f, -0.02692874f, -0.04093330f, -0.06183304f, 0.01951215f, 0.03228793f, 0.08959612f, 0.01539413f, 
    -0.06457038f, 0.02258323f, 0.03353734f, -0.11546250f, 0.06558404f, -0.03774194f, 0.13628712f, 0.18869577f, 
    -0.05886111f, -0.10176226f, -0.06561040f, 0.05021041f, 0.04197824f, 0.02983449f, -0.07988632f, 0.00461865f, 
    -0.11668342f, 0.04196716f, -0.15844999f, 0.06905255f, -0.11074639f, 0.08919549f, 0.02308031f, 0.03915216f, 
    -0.01085999f, -0.00098146f, -0.08211818f, -0.10213660f, -0.10275186f, 0.01620034f, 0.20387910f, -0.01078740f, 
    0.24163418f, 0.01096461f, 0.05206280f, -0.04325063f, 0.05785978f, -0.08182634f, 0.05230940f, 0.00954996f, 
    0.00027148f, 0.01122908f, -0.12751538f, 0.18331996f, -0.07004450f, 0.01079920f, 0.04034513f, 0.06131132f, 
    0.09932551f, 0.06310625f, -0.14243276f, 0.00969078f, -0.01758799f, -0.20810947f, 0.02133518f, -0.19818316f, 
    -0.08278792f, -0.00240718f, -0.10599737f, 0.03800422f, 0.06015267f, 0.01258198f, -0.07294456f, 0.12200224f, 
    -0.13197486f, -0.09704529f, -0.04410471f, -0.11827217f, -0.01080484f, 0.01011186f, 0.00502743f, 0.11456730f, 
    0.06703623f, 0.02899774f, 0.00867957f, 0.18947721f, -0.05879652f, 0.02880330f, -0.37884113f, -0.20998123f, 
    0.03232504f, 0.10822222f, 0.06116401f, 0.04709329f, 0.01703919f, 0.04718208f, 0.03135481f, -0.04224350f, 
    -0.03703926f, 0.04613443f, -0.06908383f, -0.07644785f, -0.05710702f, 0.03312230f, 0.04598811f, 0.19186994f, 
    -0.14530787f, -0.18180138f, -0.08113762f, 0.01944119f, 0.00847808f, 0.09421882f, -0.12491780f, -0.12260047f, 
    -0.06621431f, 0.01278962f, 0.14826638f, -0.10296439f, 0.05742203f, 0.06698805f, 0.00670837f, -0.12074923f, 
    -0.19754529f, -0.05414942f, 0.13147350f, 0.16109972f, 0.06579254f, 0.08213794f, 0.05666674f, -0.03144200f, 
    -0.01086038f, 0.14983319f, 0.08895136f, 0.16448098f, 0.20678851f, -0.02858062f, 0.07920308f, -0.03146074f, 
    -0.07370751f, 0.06284153f, 0.04188772f, 0.07805488f, -0.18421541f, -0.01176906f, 0.15925862f, -0.12273043f, 
    -0.00711431f, -0.16382056f, -0.10615419f, -0.12285154f, 0.05561720f, 0.11535336f, 0.01119382f, -0.04586880f, 
    0.10806932f, -0.10810006f, 0.05961212f, 0.20496467f, -0.06309836f, -0.15239079f, -0.12695512f, 0.00926306f, 
    -0.00051970f, 0.03021186f, -0.02099863f, 0.15632074f, -0.07005856f, -0.08091552f, -0.00257355f, 0.05497605f, 
    -0.17328729f, 0.00011825f, 0.05384505f, 0.18014564f, 0.07910426f, -0.17799436f, 0.05430152f, 0.07131335f, 
    -0.01573679f, 0.00613111f, 0.04389077f, -0.03630734f, 0.09156448f, -0.01337460f, 0.28235987f, -0.04117042f, 
    0.09987510f, 0.05271712f, 0.02477632f, -0.02525230f, 0.07036176f, 0.02747068f, 0.03339304f, 0.14820801f, 
    0.16986009f, 0.04171458f, -0.03598721f, -0.05509637f, 0.02486471f, -0.03472892f, 0.15773231f, -0.02529947f, 
    0.06587169f, -0.06574547f, 0.00953090f, -0.02518285f, 0.15228809f, -0.18484072f, -0.02857533f, 0.08338984f, 
    0.18711622f, 0.08612360f, 0.00388398f, 0.17548664f, -0.08601675f, -0.06603655f, 0.00017876f, 0.16224673f, 
    0.01904959f, 0.04056039f, 0.05148870f, -0.05344522f, 0.05447655f, -0.02695645f, -0.08270665f, -0.09075744f, 
    -0.06152882f, 0.00925754f, 0.01334914f, -0.04902190f, 0.10536318f, 0.00382345f, 0.05180252f, 0.08294093f, 
    -0.07114328f, 0.01488979f, 0.02043645f, -0.07501890f, 0.06947950f, 0.05200171f, 0.16506821f, -0.07253145f, 
    0.10688908f, -0.08807123f, 0.02354984f, 0.09192011f, -0.00987613f, -0.02877968f, -0.15168236f, 0.04158216f, 
    0.10391764f, 0.07995468f, 0.01586676f, -0.03552191f, -0.37510368f, -0.04217725f, -0.02759677f, 0.07348775f, 
    0.14143673f, -0.09840672f, -0.01949468f, 0.05961625f, 0.10094788f, 0.10860102f, 0.13326043f, 0.02193413f, 
    -0.03925322f, -0.00734991f, -0.21505237f, 0.06418413f, 0.02868662f, 0.00063654f, -0.07177176f, -0.14028905f, 
    0.01188178f, 0.08089732f, -0.01468753f, 0.13774788f, 0.33986142f, -0.09188872f, 0.07628443f, 0.20470178f, 
    0.17304546f, 0.02407712f, 0.01006813f, 0.03663877f, -0.04157306f, -0.21864031f, 0.14242454f, -0.01361860f, 
    -0.24529479f, 0.00896705f, 0.17442165f, -0.03769958f, 0.00303417f, -0.12644006f, 0.05078732f, -0.03162749f, 
    0.14921249f, 0.01227413f, 0.07092550f, 0.00908406f, -0.31139392f, 0.10019945f, -0.19271131f, -0.20226048f, 
    0.01635437f, 0.07588157f, 0.05853180f, 0.06213319f, -0.02647937f, -0.04776223f, -0.07954627f, 0.10503405f, 
    -0.07383230f, 0.26856175f, 0.03789549f, 0.27415922f, 0.06657287f, -0.10533356f, -0.14924037f, 0.10375546f, 
    0.07763939f, -0.04838257f, -0.05847403f, -0.06285351f, -0.10113230f, 0.08987396f, -0.00214225f, -0.14616352f, 
    0.17860125f, 0.05569864f, -0.12714052f, 0.06936043f, 0.03051867f, 0.12628314f, -0.01158641f, -0.06197370f, 
    -0.14686640f, 0.04539157f, -0.08992381f, 0.21115783f, 0.02492432f, 0.14984354f, 0.01360631f, -0.07479111f, 
    0.04255671f, -0.01027323f, 0.32771826f, 0.01378376f, 0.17779009f, 0.02352530f, 0.20506206f, -0.16171211f, 
    -0.07109256f, -0.11758957f, -0.02428047f, -0.09653988f, 0.06533094f, -0.04397913f, 0.00532007f, -0.06196519f, 
    0.00852054f, -0.05625351f, 0.18961662f, 0.10916159f, -0.09584374f, -0.04587606f, 0.15388787f, 0.14843933f, 
    0.13022850f, 0.18888345f, 0.09095938f, 0.35543719f, 0.06211665f, -0.08094001f, -0.02371809f, 0.17883690f, 
    0.14998180f, 0.09748008f, -0.05834810f, 0.08373278f, 0.04781597f, -0.19876119f, 0.06727116f, -0.16595925f, 
    -0.13417715f, -0.12503171f, -0.10973994f, 0.01668350f, 0.00423893f, 0.04878079f, 0.09469353f, 0.07572038f, 
    -0.18421343f, -0.13645341f, 0.10637844f, -0.14561342f, 0.38502279f, 0.07838725f, 0.08272086f, 0.02162167f, 
    0.12981795f, 0.06286255f, -0.07178403f, 0.00876984f, -0.10875739f, 0.05037816f, -0.11925928f, -0.01431473f, 
    -0.07689711f, -0.08852864f, 0.22178026f, -0.05239721f, 0.01611192f, -0.00944766f, 0.12458658f, 0.14601468f, 
    0.10608929f, -0.04568724f, -0.15727223f, -0.14835602f, 0.03449336f, -0.08577051f, 0.10282433f, 0.35121763f, 
    -0.02166661f, 0.05492074f, 0.00848188f, 0.02423168f, 0.03688966f, -0.05675505f, 0.07573316f, 0.08488955f, 
    -0.48326862f, 0.27118799f, -0.16044773f, 0.08075584f, -0.02543483f, 0.03245031f, 0.02703881f, 0.12445974f, 
    0.12926522f, 0.01176534f, -0.16107506f, 0.04947217f, -0.16479868f, 0.04889874f, -0.10390913f, 0.15490024f, 
    -0.07553155f, 0.03459527f, -0.01090740f, 0.03017075f, 0.09214868f, 0.06350310f, 0.03815677f, 0.10276525f, 
    -0.00306984f, 0.01204127f, 0.09898636f, -0.04476159f, 0.03823721f, -0.04232890f, -0.01285903f, 0.12683035f, 
    -0.00351353f, 0.16384031f, 0.08520465f, 0.24134515f, -0.04274616f, 0.08285962f, 0.00185294f, -0.03979896f, 
    -0.02219169f, 0.09754080f, 0.02562520f, 0.02783297f, 0.09105740f, -0.02105039f, 0.04310000f, 0.13044758f, 
    -0.41097322f, 0.08101154f, -0.15642121f, 0.06566869f, 0.07751694f, 0.06644184f, -0.01707996f, 0.05744981f, 
    -0.07476871f, -0.03244550f, -0.12687398f, 0.20105337f, -0.27601656f, 0.17128366f, -0.08278501f, -0.09874491f, 
    -0.01674958f, -0.05979612f, 0.07888241f, 0.07193474f, 0.08736282f, 0.06753379f, 0.06035966f, -0.08855529f, 
    0.03095686f, -0.15062901f, 0.14029534f, 0.29195487f, -0.00219077f, 0.01890461f, 0.09169632f, 0.07044515f, 
    0.01420293f, 0.02921755f, 0.09213181f, 0.12493321f, -0.27171338f, 0.17153706f, -0.06453086f, -0.10493489f, 
    -0.07135505f, -0.02122553f, 0.01000291f, 0.09518427f, -0.03367917f, 0.01184763f, 0.11257111f, -0.11681800f, 
    -0.15011908f, 0.21522675f, -0.12839715f, -0.08008652f, -0.14676076f, 0.09101383f, 0.10071529f, -0.05995100f, 
    -0.04012930f, -0.06717998f, 0.25311446f, 0.10879992f, -0.20782645f, -0.20596354f, 0.02762170f, 0.02242254f, 
    0.02846575f, 0.07092783f, 0.06113420f, 0.09129328f, -0.04679671f, -0.08503087f, -0.01997959f, -0.10829829f, 
    0.18051553f, 0.01983168f, 0.10611312f, -0.14566359f, 0.13703102f, -0.06634924f, -0.12761472f, -0.05434841f, 
    -0.04410352f, -0.02571280f, -0.00391962f, -0.04603520f, -0.00417564f, -0.15297070f, 0.00607041f, 0.21825430f, 
    0.14738233f, 0.07981066f, -0.02900231f, 0.12430228f, 0.07785595f, -0.02866942f, 0.05864168f, 0.24559824f, 
    -0.10034923f, 0.08781530f, 0.11933392f, 0.05882468f, 0.06486055f, -0.06118577f, 0.11695222f, 0.01118039f, 
    0.09018581f, -0.16820817f, 0.05721801f, -0.04034064f, 0.27673316f, -0.01826497f, -0.05049177f, 0.02674976f, 
    0.01240123f, -0.01631521f, 0.05927068f, -0.00239798f, 0.07642990f, 0.01128106f, 0.01194263f, 0.13270085f, 
    -0.01668112f, -0.17445181f, -0.10964770f, 0.27469340f, -0.12207855f, -0.04465542f, -0.04581451f, -0.14399929f, 
    0.13392906f, 0.01615511f, 0.10955774f, -0.01423232f, 0.04529479f, 0.19032758f, -0.01036320f, 0.00274415f, 
    0.09534667f, 0.11426789f, 0.06099705f, -0.01852038f, 0.19887991f, 0.04645367f, 0.11492061f, -0.01136695f, 
    0.10182981f, 0.41737407f, -0.04562140f, -0.02365446f, 0.12008327f, 0.04890782f, -0.05573234f, -0.05817556f, 
    -0.01454403f, 0.09290147f, -0.08692836f, -0.13510859f, 0.02465415f, -0.06385175f, 0.07691848f, -0.26084089f, 
    0.07357031f, -0.05280200f, 0.01223955f, -0.03459527f, 0.15254880f, -0.13080211f, 0.11541448f, 0.00515935f, 
    0.11839657f, 0.06582215f, -0.05141115f, 0.04434843f, 0.04740980f, 0.11301854f, -0.00497645f, 0.02110112f, 
    0.12899533f, -0.03282868f, 0.06263096f, 0.06984927f, -0.08128542f, -0.09040070f, -0.13363221f, -0.14298299f, 
    -0.08775264f, -0.09655293f, -0.10893158f, -0.13858707f, -0.06480511f, -0.08996532f, 0.10829987f, -0.05530411f, 
    -0.07520852f, 0.12996884f, 0.16838294f, 0.06919111f, 0.05077351f, -0.01266562f, -0.04738917f, -0.00781848f, 
    -0.07371642f, -0.01484308f, 0.00581818f, 0.01913932f, -0.04175229f, 0.04961131f, 0.09077963f, -0.09563225f, 
    0.09226099f, 0.02790459f, 0.00401425f, 0.05943921f, 0.18628614f, 0.00596386f, 0.08405504f, -0.02803836f, 
    -0.03566083f, 0.00349029f, -0.21457613f, 0.09394001f, 0.03274106f, 0.01934338f, -0.01323249f, -0.02916617f, 
    -0.07303073f, -0.02073015f, 0.01619331f, 0.04816491f, 0.16342098f, 0.01341222f, 0.11047544f, -0.04752471f, 
    -0.12950890f, -0.08413254f, 0.18509029f, 0.14824449f, 0.13142417f, -0.09574412f, 0.01459281f, 0.13269582f, 
    -0.02638995f, -0.20122559f, -0.17680338f, -0.00479697f, -0.13207057f, -0.03612032f, 0.04212165f, -0.14954546f, 
    -0.03826959f, 0.06240426f, -0.20484847f, 0.01602805f, -0.51293612f, -0.15203384f, 0.22890300f, 0.01490055f, 
    -0.08925731f, 0.09514136f, 0.07119737f, -0.10498741f, -0.00507936f, -0.04649844f, 0.02916027f, 0.06166428f, 
    0.14684321f, 0.04836119f, 0.13951293f, -0.01110920f, 0.12558915f, -0.15468912f, 0.00680376f, -0.05665108f, 
    0.06453408f, -0.05079028f, 0.02715038f, -0.01191473f, 0.20459889f, 0.16620111f, -0.10172915f, -0.05478852f, 
    -0.01284514f, 0.04158364f, 0.27920240f, 0.08845469f, -0.06209938f, 0.01222254f, 0.00725815f, -0.05604601f, 
    0.19187067f, -0.01144402f, -0.06199894f, 0.19177113f, -0.09249602f, 0.07426418f, -0.08300351f, 0.00947822f, 
    -0.03056744f, 0.01096255f, 0.10130230f, 0.14478830f, 0.04166440f, -0.01694208f, -0.23117562f, -0.18198444f, 
    -0.00904352f, 0.06013377f, 0.18276709f, 0.00695647f, -0.05987148f, 0.01302839f, 0.08721580f, 0.05951763f, 
    0.07697845f, -0.02246879f, 0.17975281f, -0.08933252f, 0.18178765f, -0.02077992f, -0.00419943f, 0.05611919f, 
    -0.00796435f, -0.04783400f, 0.09594323f, 0.11772028f, -0.11097103f, 0.11475040f, -0.06520733f, -0.00212069f, 
    -0.04210634f, -0.03755723f, -0.24388751f, -0.04170367f, -0.05161906f, 0.05922228f, 0.03523823f, 0.03733784f, 
    -0.07222753f, -0.01837092f, 0.06971098f, -0.05938541f, 0.06894363f, 0.01422556f, -0.01857467f, 0.12336590f, 
    -0.11859255f, 0.05031245f, 0.13256299f, -0.00356913f, 0.10434299f, 0.10405207f, -0.22153744f, 0.16881528f, 
    0.02022514f, 0.07231749f, 0.12643926f, -0.14488435f, -0.07162292f, 0.04281628f, 0.09850141f, 0.00450228f, 
    0.18218754f, -0.02843380f, -0.06135564f, 0.13358773f, -0.00686463f, -0.05315099f, -0.12746924f, -0.07963561f, 
    -0.00786912f, -0.01912523f, -0.06117669f, -0.03591110f, 0.01610638f, 0.19516572f, 0.26571009f, 0.01635921f, 
    0.03372366f, -0.13684468f, -0.25756514f, -0.00216088f, 0.08109111f, 0.06524888f, 0.02362447f, -0.03760235f, 
    0.14581236f, -0.00240304f, -0.06050322f, -0.06191898f, 0.04073774f, -0.10910892f, -0.11227613f, -0.03916467f, 
    0.11173239f, 0.12083369f, -0.09321024f, -0.08205038f, 0.38301840f, -0.03628249f, -0.01981741f, 0.17039049f, 
    0.07801963f, 0.05960415f, -0.00825410f, -0.04118779f, 0.01466608f, 0.03460308f, 0.03100898f, -0.01804633f, 
    -0.10674097f, 0.17444892f, 0.08070607f, 0.05030739f, -0.06581268f, -0.01951660f, -0.10489663f, -0.05875451f, 
    -0.06003047f, -0.07887360f, 0.01186509f, 0.00447875f, 0.20296541f, -0.00345362f, 0.01240561f, 0.04505475f, 
    -0.03424391f, 0.13802163f, -0.00872982f, -0.00933697f, 0.00722269f, 0.00311716f, 0.02792381f, 0.05211015f, 
    -0.27732533f, -0.00001114f, 0.23876895f, -0.08039991f, -0.02759337f, 0.06275575f, -0.09237953f, -0.05952966f, 
    -0.00984879f, -0.02808982f, -0.09267290f, -0.10733991f, 0.11850779f, 0.04070071f, 0.11158167f, 0.08565300f, 
    -0.04615482f, 0.12442028f, 0.21164386f, -0.02357554f, 0.04198859f, 0.16338351f, 0.08296082f, -0.00423302f, 
    0.36821392f, 0.03744429f, 0.02309481f, 0.05092599f, 0.06630567f, 0.06499792f, 0.17973258f, 0.05048909f, 
    0.00538153f, 0.03919801f, 0.03718188f, 0.03323206f, 0.23609665f, -0.16478612f, 0.09895779f, 0.10809226f, 
    0.13365972f, -0.05607834f, -0.10860728f, 0.09749556f, -0.06370735f, 0.00517134f, -0.01570566f, -0.00864923f, 
    -0.05742109f, 0.08782922f, 0.26508832f, -0.03643214f, -0.04184308f, 0.04351559f, -0.22763827f, -0.00997051f, 
    -0.08122683f, 0.22043763f, -0.11667863f, 0.10473013f, 0.00673703f, -0.01835682f, -0.13011010f, -0.11465632f, 
    -0.21554296f, 0.01165832f, -0.07907893f, -0.10511147f, -0.00374306f, -0.01167999f, 0.09252863f, -0.04760384f, 
    0.24962449f, -0.01675303f, -0.09656770f, 0.07332308f, -0.12671976f, 0.07737873f, 0.09021070f, -0.07291607f, 
    -0.09242016f, 0.00955078f, 0.08231693f, -0.06019855f, 0.13915740f, -0.06257126f, -0.18008412f, -0.03130583f, 
    -0.02794416f, 0.02474303f, -0.08534843f, -0.11498976f, -0.00672728f, -0.03650753f, -0.07850448f, 0.04958186f, 
    0.05240038f, 0.11998760f, -0.08233716f, -0.05939899f, -0.03999850f, -0.01340869f, 0.09640358f, 0.08698099f, 
    0.03810670f, 0.05711916f, 0.05877299f, 0.11434390f, 0.65076691f, 0.15696740f, -0.11809509f, 0.04915716f, 
    0.09833269f, -0.08017019f, 0.15753882f, -0.02838961f, -0.07289837f, 0.01882626f, -0.10977103f, -0.05653673f, 
    0.01713033f, -0.00001073f, 0.01152187f, -0.01638897f, 0.01878509f, -0.02989935f, 0.03522545f, -0.00679517f, 
    -0.00085153f, -0.01724892f, 0.01385031f, 0.00479837f, -0.02452759f, -0.03935867f, 0.02158006f, -0.04302615f, 
    -0.05698922f, 0.02321784f, 0.02924686f, -0.04039759f, -0.02447255f, -0.01508661f, -0.02146132f, 0.03769711f, 
    -0.03595908f, 0.03860396f, 0.02049446f, -0.00967996f, -0.01504027f, -0.04524436f, 0.00069458f, -0.05923725f, 
    -0.05886467f, -0.01241836f, 0.02212508f, -0.05293380f, -0.01045594f, -0.01409945f, 0.01448631f, -0.04792776f, 
    -0.00157266f, -0.02845008f, -0.03834499f, -0.04901682f, -0.04869664f, -0.04751137f, 0.04067995f, -0.04505069f, 
    -0.05031266f, -0.00333230f, -0.02883387f, -0.01101282f, -0.03124186f, -0.01165351f, -0.02779241f, 0.02862559f, 
    0.03641395f, 0.00603402f, 0.00679786f, 0.00534081f, -0.04641655f, -0.02870949f, 0.02648982f, 0.00873750f, 
    0.00471399f, 0.03714614f, -0.04755240f, 0.03509311f, -0.00668622f, 0.01848065f, 0.02177756f, 0.03076659f, 
    0.01402034f, 0.02489835f, 0.02336286f, 0.03281456f, 0.02422235f, -0.01254392f, 0.03956791f, -0.02393940f, 
    0.01670950f, -0.04009672f, 0.01186737f, -0.01436210f, -0.01851755f, 0.04011915f, 0.04014890f, -0.04597500f, 
    0.01257544f, -0.05194986f, 0.02473803f, -0.04505964f, -0.02045313f, -0.03183292f, 0.04103390f, -0.04141427f, 
    0.03099756f, 0.00423082f, 0.00278169f, 0.01158597f, -0.05798775f, -0.05812988f, 0.03184749f, 0.03926596f, 
    -0.00314112f, 0.04205367f, -0.03339273f, 0.04111343f, -0.04840596f, -0.04714248f, -0.00922355f, -0.00961362f, 
    -0.00119237f, -0.00582662f, 0.03018202f, -0.05104767f, 0.00121473f, 0.00036037f, 0.01512125f, 0.01894641f, 
    -0.05615019f, -0.03737563f, -0.02756540f, -0.02485353f, -0.04413821f, 0.03299623f, 0.03438042f, 0.01758769f, 
    -0.04283636f, -0.02516523f, -0.05956862f, -0.03872795f, 0.02708917f, -0.00452902f, 0.03358060f, -0.01955507f, 
    0.02185161f, -0.01494724f, -0.01536932f, 0.03386225f, 0.02321322f, -0.05574106f, -0.00548465f, 0.04049176f, 
    -0.02270978f, -0.02968029f, -0.01553350f, -0.00562284f, -0.05565995f, 0.03216307f, -0.03468242f, -0.02878553f, 
    0.03483061f, 0.03561621f, 0.00621632f, -0.05616662f, -0.00333635f, 0.02512384f, 0.00373973f, -0.02325867f, 
    0.02512560f, -0.02696544f, -0.02565279f, -0.02941429f, -0.00636491f, 0.01273777f, -0.03432629f, 0.03125788f, 
    -0.01583936f, -0.06031890f, 0.04079765f, -0.04232467f, 0.00507695f, 0.01613978f, 0.03571923f, -0.04961679f, 
    -0.00953932f, -0.02932159f, 0.01186764f, -0.01209214f, 0.01845480f, -0.01434327f, 0.01281852f, 0.03081004f, 
    -0.01332364f, 0.03354531f, 0.01706005f, -0.02195754f, 0.01664567f, -0.05654730f, -0.01049449f, -0.00823115f, 
    0.03947763f, -0.01262099f, -0.02548044f, 0.02101264f, 0.01301880f, -0.04697593f, 0.03978300f, 0.01447141f, 
    -0.02275266f, -0.02737547f, -0.02946739f, -0.02269690f, -0.02959183f, -0.05121512f, -0.05429736f, -0.05489088f, 
    -0.00162042f, -0.03143464f, -0.01278066f, -0.04327657f, 0.03783125f, 0.02420094f, 0.03218017f, -0.04962187f, 
    -0.00753136f, 0.02906894f, -0.02579191f, 0.01939383f, 0.04009836f, -0.01110573f, -0.05541220f, -0.03350862f, 
    -0.04744167f, 0.03981704f, 0.02585681f, -0.04784649f, 0.02621282f, 0.03519539f, 0.00189460f, -0.02378925f, 
    -0.02916029f, 0.02887230f, 0.03659330f, -0.02698397f, -0.05740434f, -0.05699287f, 0.00082275f, -0.00489438f, 
    -0.00526531f, 0.01734131f, 0.03058320f, 0.00364475f, -0.02919557f, -0.01908266f, 0.03371662f, 0.02852347f, 
    0.01643356f, -0.04280112f, 0.01947592f, -0.01512324f, -0.04669641f, -0.05198941f, -0.02634004f, -0.04505217f, 
    -0.04380852f, 0.01699266f, 0.00802101f, 0.02525161f, 0.03119064f, -0.01827343f, -0.05451041f, -0.00940653f, 
    -0.04824875f, -0.05710260f, 0.00427659f, -0.01125162f, -0.03758287f, 0.00374078f, -0.03657436f, -0.04948786f, 
    -0.04986237f, -0.05942147f, 0.00963293f, 0.01224763f, -0.00577931f, -0.05205724f, -0.04108212f, 0.03766569f, 
    -0.05590449f, 0.02361269f, -0.03270078f, 0.01013942f, -0.00905310f, -0.04956565f, 0.01662166f, -0.03162706f, 
    0.03319936f, -0.03396920f, -0.04244560f, -0.02165380f, -0.00926684f, -0.03769124f, -0.01719281f, 0.04035852f, 
    -0.03704473f, -0.05975804f, -0.00581866f, 0.00976954f, 0.00328523f, -0.02533904f, -0.01088479f, -0.04136347f, 
    0.00556034f, 0.03271598f, 0.03116493f, 0.02211662f, -0.01452936f, 0.01493290f, -0.00660832f, -0.02819316f, 
    -0.03089166f, -0.03939379f, 0.01904103f, -0.01197391f, -0.05615559f, -0.03620192f, -0.05095692f, -0.01816352f, 
    0.03008625f, 0.02261850f, -0.04407028f, 0.03002224f, -0.03109667f, -0.00635469f, -0.03817611f, 0.02190872f, 
    -0.00506635f, 0.02097209f, 0.00418937f, -0.02676840f, -0.05652770f, -0.02434371f, 0.01483332f, 0.02306194f, 
    -0.04069328f, -0.01655612f, -0.04591373f, 0.02772380f, 0.03890212f, 0.02132680f, -0.02264746f, -0.05644488f, 
    -0.04900231f, -0.04761347f, 0.01176927f, -0.04172702f, -0.02945558f, 0.02770983f, -0.02386970f, -0.01063302f, 
    -0.02551128f, -0.04543749f, 0.03926520f, -0.00754871f, 0.04051942f, 0.01235655f, -0.05737245f, 0.04214769f, 
    0.03569003f, -0.00890051f, 0.00365712f, -0.02496169f, 0.01128364f, -0.01774497f, 0.03121478f, -0.00963170f, 
    0.02243865f, 0.02396139f, 0.02295224f, -0.01748349f, -0.01250808f, 0.00180603f, -0.06111982f, -0.05332543f, 
    0.01527087f, 0.00794999f, 0.01633552f, -0.02603073f, 0.00281621f, -0.04573351f, 0.01729867f, 0.02009218f, 
    0.41963896f, -0.15001893f, -0.16296829f, 0.00044507f, -0.01566187f, 0.01370745f, -0.04983456f, 0.01798425f, 
    0.02394167f, -0.01531422f, -0.08919302f, -0.03865019f, 0.04271297f, 0.14730343f, 0.16638154f, -0.03735745f, 
    0.15559964f, 0.08930469f, 0.11905999f, -0.00498282f, -0.03495629f, -0.08463550f, -0.01956115f, 0.11945380f, 
    -0.18140878f, -0.06131350f, 0.06061001f, -0.16487178f, -0.14033101f, 0.07347018f, 0.03431966f, 0.05343912f, 
    0.02909589f, 0.03476131f, -0.04943888f, 0.01569241f, -0.10394032f, -0.00502985f, 0.02449812f, 0.16616230f, 
    -0.06590654f, 0.12350545f, -0.06645866f, -0.00029195f, -0.03079567f, 0.08032274f, -0.02415678f, 0.06587778f, 
    0.13346691f, 0.08906183f, 0.04351748f, -0.11463223f, -0.05990839f, 0.02213194f, -0.06652200f, -0.14790328f, 
    0.07778168f, 0.11302904f, 0.00244192f, 0.03748149f, 0.06150465f, 0.30121601f, 0.01949107f, 0.07907156f, 
    0.12939203f, 0.10171289f, -0.06311799f, 0.08717688f, 0.01219988f, -0.01437476f, -0.03446867f, -0.02285209f, 
    0.05505867f, 0.30183786f, 0.04523816f, -0.04258626f, -0.00317828f, 0.10141611f, -0.01488494f, 0.09053844f, 
    -0.00470990f, -0.13707140f, 0.12129754f, -0.16337264f, 0.25436142f, 0.15554059f, 0.09957520f, 0.02233875f, 
    0.08497927f, -0.03211909f, 0.11520187f, -0.01648864f, -0.10464653f, 0.07984955f, 0.07750987f, -0.00340011f, 
    -0.23023370f, -0.16646561f, 0.22683378f, -0.07332007f, -0.09378888f, -0.06196164f, -0.07765600f, -0.09748616f, 
    -0.11323488f, 0.04810461f, 0.04305340f, 0.04197828f, 0.07186524f, -0.09703090f, 0.01909013f, 0.10553514f, 
    0.10070407f, 0.12991837f, -0.06974775f, 0.09962048f, 0.04862803f, -0.03658013f, -0.05517422f, 0.05692577f, 
    -0.15671964f, 0.05830236f, 0.07011838f, 0.01328123f, 0.05014205f, -0.04248835f, 0.04604677f, 0.03563835f, 
    -0.11353789f, 0.09025793f, 0.03414268f, 0.08179428f, 0.07182774f, 0.15215032f, 0.18861446f, -0.06657468f, 
    -0.00811811f, -0.08725240f, -0.03586343f, 0.11263431f, 0.07381295f, 0.05543111f, -0.09346065f, -0.01783962f, 
    -0.14079072f, 0.02490822f, -0.12746374f, 0.08779139f, -0.18710858f, 0.06037832f, 0.10539883f, -0.04210281f, 
    0.01390454f, -0.01584227f, 0.02782245f, -0.01089090f, -0.03978562f, 0.02337558f, 0.09529481f, -0.03813772f, 
    0.15210928f, -0.05023103f, 0.08068913f, -0.07450254f, -0.05372835f, 0.09525988f, -0.11567873f, -0.04627714f, 
    0.48595205f, 0.03602222f, -0.14336203f, 0.15600291f, -0.01707859f, 0.00444945f, 0.04486158f, 0.05432464f, 
    0.01343311f, 0.08636591f, -0.03572437f, -0.01000430f, 0.29967955f, 0.15666106f, -0.08431502f, -0.06393065f, 
    0.01479115f, -0.05359199f, -0.07537261f, 0.02496906f, 0.05872748f, -0.06162734f, -0.06469157f, -0.06195870f, 
    -0.04371681f, -0.11608700f, -0.11497238f, -0.03204736f, -0.08472590f, -0.01099425f, 0.02229836f, -0.02261196f, 
    0.00111416f, -0.01588556f, -0.01098293f, 0.04485449f, -0.05274357f, -0.43451533f, -0.14070676f, 0.00812819f, 
    -0.10466278f, 0.09932120f, -0.00029939f, -0.04339924f, -0.02051564f, 0.02418501f, -0.01560197f, -0.00327492f, 
    0.30264890f, 0.05562520f, 0.01326907f, 0.00862280f, -0.13038620f, 0.02030337f, -0.16649927f, 0.13184389f, 
    -0.10142100f, -0.00731617f, 0.01224786f, -0.04740459f, 0.34092629f, -0.30356589f, 0.00933429f, -0.13223301f, 
    0.05727191f, 0.03830636f, 0.07440291f, -0.05668041f, -0.04149699f, 0.03415427f, -0.00463327f, -0.00508117f, 
    0.11639619f, -0.03096168f, -0.11824236f, -0.07729995f, 0.01274951f, 0.10846648f, 0.04501361f, -0.03689844f, 
    -0.17923009f, -0.01870606f, -0.05396070f, 0.04218112f, 0.33942115f, -0.08228327f, -0.11554757f, 0.23802042f, 
    0.14591195f, -0.04835748f, -0.00913346f, 0.03453252f, -0.14066999f, 0.08013923f, 0.03411650f, -0.06587368f, 
    0.47160143f, -0.07003133f, -0.03686394f, 0.10801515f, 0.02529278f, 0.07024185f, -0.05175909f, 0.08215012f, 
    -0.05238589f, -0.08934785f, 0.08280853f, -0.00950149f, -0.05046830f, 0.01868496f, -0.09464253f, 0.20681916f, 
    0.08987894f, -0.07148071f, -0.06807514f, 0.17985532f, -0.00122089f, 0.03850095f, -0.09226459f, 0.00808074f, 
    0.02986522f, -0.05082414f, 0.05982293f, -0.10575385f, 0.06001506f, -0.02029181f, -0.02804693f, 0.00984025f, 
    0.06724899f, -0.03428466f, -0.03484151f, -0.04351825f, 0.05883063f, -0.14156950f, -0.05019821f, 0.18709698f, 
    -0.04450046f, 0.03126731f, -0.00891093f, -0.05512690f, -0.10822527f, 0.05055020f, 0.01955077f, -0.05405116f, 
    -0.01552003f, -0.14317583f, -0.06307034f, 0.04223606f, 0.07392994f, 0.03389633f, 0.09469140f, 0.04078567f, 
    -0.06526582f, -0.17587632f, 0.21658187f, -0.11196901f, -0.04133940f, -0.01528791f, -0.02027971f, 0.06563374f, 
    0.17560580f, -0.00701021f, 0.12261225f, 0.05153923f, 0.00530579f, -0.07433355f, 0.02914700f, 0.04614253f, 
    0.00540920f, 0.09668385f, 0.03577927f, -0.14688358f, 0.19649936f, -0.02764408f, -0.02270743f, -0.08149681f, 
    0.04806753f, -0.01146027f, -0.01812843f, 0.10136840f, 0.20842692f, -0.12352605f, 0.10576626f, -0.15725759f, 
    -0.05832506f, -0.06520500f, 0.00964567f, -0.02026894f, 0.06430643f, 0.01900735f, 0.07739234f, 0.03503314f, 
    0.14959086f, 0.02407791f, -0.01466782f, -0.15361032f, 0.05928518f, 0.10248836f, -0.09175111f, 0.01538373f, 
    -0.00803302f, -0.00079035f, -0.02949523f, 0.00001188f, -0.39895669f, -0.24422549f, 0.22770733f, 0.02439293f, 
    0.04013063f, -0.02406575f, -0.03555908f, -0.06661899f, -0.04357112f, 0.01172187f, 0.11651139f, 0.06461845f, 
    -0.10441159f, 0.01279277f, 0.16941424f, 0.01865983f, 0.02739439f, -0.03009731f, 0.03760326f, -0.06525231f, 
    0.02543141f, -0.02090982f, -0.02873962f, 0.04229449f, 0.13198714f, 0.02268900f, 0.25771704f, 0.01131957f, 
    -0.13313329f, -0.02624543f, 0.06973252f, 0.06587833f, 0.05782025f, 0.05503888f, -0.05355741f, 0.03089271f, 
    0.02550031f, -0.02883276f, 0.11696229f, 0.30037645f, -0.04259665f, 0.03844847f, -0.01710977f, -0.04417153f, 
    0.06032697f, -0.01227815f, -0.01647353f, 0.02555959f, -0.04759977f, 0.06962524f, 0.09727920f, -0.27024889f, 
    0.04692688f, -0.05563411f, 0.07760080f, -0.01675632f, 0.01894194f, -0.07082587f, 0.12949860f, -0.05395564f, 
    -0.05369739f, -0.09817099f, 0.07226714f, 0.03928316f, -0.10778832f, 0.15868658f, 0.17526516f, 0.05010900f, 
    -0.03632684f, 0.03315675f, -0.05475149f, 0.04294908f, -0.03796485f, -0.11550812f, 0.00978894f, 0.16060822f, 
    -0.03479897f, -0.07639393f, 0.12177577f, 0.05481008f, -0.02841471f, 0.01852674f, 0.08711243f, 0.07139681f, 
    0.24652022f, -0.03291089f, -0.05697111f, -0.23493557f, 0.08159772f, -0.05052764f, 0.00911297f, 0.06637069f, 
    -0.08980356f, -0.02510721f, -0.04543446f, -0.11837573f, -0.04066308f, -0.07123388f, -0.27729467f, 0.02934905f, 
    -0.10960291f, 0.00188801f, -0.06797453f, 0.14214797f, 0.04066201f, 0.02853080f, 0.05325767f, -0.07494463f, 
    -0.19436164f, 0.14947680f, -0.12133171f, 0.22573164f, 0.11067514f, 0.08761189f, 0.01348441f, 0.03073940f, 
    -0.01894618f, -0.10141665f, -0.09758926f, 0.00824205f, -0.17269188f, 0.07086506f, -0.09319441f, 0.21976601f, 
    0.03158432f, -0.02818273f, 0.03973066f, -0.13630441f, -0.10282549f, 0.08755447f, -0.03224554f, -0.01916418f, 
    0.07291094f, -0.08592888f, 0.01084383f, 0.06727280f, -0.00480112f, 0.06796502f, -0.08514411f, 0.08865061f, 
    -0.01145334f, -0.11990600f, 0.14624813f, 0.11752983f, -0.13238235f, -0.02361669f, -0.13747376f, 0.06589810f, 
    -0.08944011f, -0.01553735f, -0.01310940f, -0.04419317f, -0.15302265f, -0.02880820f, 0.15256925f, -0.04595853f, 
    0.44922075f, 0.04435497f, -0.18148765f, 0.01586544f, 0.02312759f, -0.11255231f, -0.00596439f, 0.02382181f, 
    0.01009076f, 0.22911811f, 0.07151365f, 0.09311037f, 0.28151947f, -0.05574963f, 0.10427545f, 0.40413100f, 
    0.00481616f, 0.06453618f, 0.09251072f, 0.01203793f, 0.05019933f, -0.03517706f, 0.00612195f, 0.08582564f, 
    -0.11903109f, 0.06548622f, 0.26812413f, 0.06637698f, 0.13304526f, 0.01446156f, 0.00986683f, 0.07431114f, 
    0.00328909f, 0.04147942f, 0.03061394f, -0.00590870f, 0.12800114f, -0.29003775f, -0.05508671f, -0.12650290f, 
    -0.05595241f, -0.07784059f, 0.03170811f, 0.10351609f, 0.01072825f, 0.01388786f, 0.01660347f, -0.06458677f, 
    -0.13326809f, 0.03875374f, 0.09825696f, -0.00425899f, 0.00020980f, -0.12032413f, -0.08734457f, -0.04231735f, 
    0.00446561f, -0.20300120f, -0.07031688f, -0.11572473f, -0.17221120f, 0.10813904f, 0.21245793f, 0.38340876f, 
    -0.00593752f, -0.13822930f, -0.05154993f, -0.01832874f, -0.07465653f, -0.08674522f, 0.02026969f, 0.00506191f, 
    0.05572768f, -0.01152731f, 0.06173108f, -0.15925698f, 0.08714671f, 0.03272323f, 0.06548464f, -0.04331363f, 
    0.12510708f, 0.01417827f, 0.00507018f, 0.01252413f, 0.05805205f, 0.18492308f, 0.11230756f, 0.17192107f, 
    0.01274988f, 0.04828931f, -0.03337976f, -0.01198731f, 0.08736540f, -0.03333673f, -0.05661950f, -0.05617831f, 
    0.17262660f, -0.10633640f, -0.08880625f, 0.26557025f, 0.02822810f, -0.02049986f, 0.04227969f, -0.01215688f, 
    -0.00225791f, -0.05552242f, 0.04655099f, -0.24092481f, -0.26877284f, 0.05754052f, 0.09378896f, -0.01260651f, 
    0.06738867f, 0.05419518f, 0.02598831f, -0.01982905f, 0.06719939f, -0.06364723f, 0.04405952f, 0.08200049f, 
    0.14985026f, 0.16379082f, -0.04599143f, 0.11805634f, 0.01613853f, 0.03685741f, 0.17094024f, 0.01824579f, 
    -0.01876449f, 0.00343613f, -0.11353547f, -0.11568394f, 0.17955655f, 0.21321149f, -0.17444223f, 0.14024180f, 
    -0.03585108f, 0.02269343f, 0.02122070f, -0.18921685f, 0.07927481f, 0.17428680f, -0.01132217f, -0.01294881f, 
    0.10925573f, 0.17923863f, -0.05244432f, 0.20124583f, 0.04259871f, 0.04892690f, 0.02475761f, 0.04497873f, 
    -0.11263391f, 0.03688766f, 0.06651629f, 0.03313501f, -0.04231554f, -0.02647248f, 0.04510807f, -0.09205883f, 
    -0.06688335f, -0.04270800f, -0.03352074f, -0.02578193f, 0.07156169f, 0.11488894f, 0.03613705f, -0.08034357f, 
    0.06387159f, -0.05878158f, 0.10536763f, 0.04898836f, 0.00042599f, 0.12649201f, -0.02686060f, -0.08234784f, 
    0.05935564f, 0.09302875f, -0.18950449f, 0.15698604f, 0.02547362f, 0.05841002f, -0.15889055f, 0.14985284f, 
    -0.04853521f, -0.08508459f, 0.02940739f, -0.08117095f, -0.03608604f, 0.06450783f, 0.02205811f, -0.09029391f, 
    0.44363007f, 0.32670277f, 0.14269432f, -0.21883208f, 0.00204807f, 0.10875449f, 0.14347540f, 0.04383934f, 
    -0.02413796f, -0.01071371f, 0.08801769f, -0.05309070f, -0.29057559f, 0.19475079f, 0.01350274f, 0.08710292f, 
    -0.01864335f, 0.04347967f, 0.03308731f, 0.10402788f, -0.12586926f, -0.08029364f, -0.12840544f, -0.09680060f, 
    -0.33144993f, 0.02723878f, 0.15907069f, -0.00126198f, -0.06555757f, 0.04372303f, 0.14146134f, -0.18886977f, 
    0.05401042f, -0.11560650f, 0.10451252f, 0.05104468f, 0.57934260f, 0.23931365f, -0.06013238f, 0.17354320f, 
    0.04010579f, 0.02675431f, -0.01441504f, -0.03226410f, 0.02553311f, -0.04462514f, -0.05604765f, 0.06140870f, 
    -0.00139838f, -0.05305173f, -0.00445228f, -0.01342693f, -0.00138658f, -0.05739900f, -0.02040660f, -0.01678360f, 
    0.01499607f, 0.00746666f, 0.01254128f, 0.01662442f, -0.01247241f, 0.00488363f, 0.01945324f, 0.04169080f, 
    -0.03368217f, -0.00526944f, 0.04720080f, -0.04944470f, -0.00014270f, -0.04708011f, -0.02029594f, 0.01773718f, 
    0.00763802f, -0.00317654f, 0.01907949f, 0.00026448f, -0.01152145f, -0.01954649f, 0.00224835f, 0.00220868f, 
    -0.00940261f, 0.02359928f, -0.05842084f, -0.05308637f, 0.01173655f, -0.02797545f, 0.03475977f, -0.05552541f, 
    0.03159446f, -0.02936455f, -0.03857435f, -0.01895969f, -0.02428883f, 0.01361565f, 0.02091383f, -0.04496688f, 
    -0.00685596f, 0.00507120f, -0.05309710f, 0.05558075f, -0.04718673f, 0.04276360f, -0.03684755f, 0.01339835f, 
    -0.02114617f, -0.00306630f, 0.02326433f, -0.04386071f, -0.03359043f, 0.03128309f, -0.01779444f, 0.00558899f, 
    -0.04949598f, -0.02800540f, -0.05950841f, -0.01716852f, 0.01615589f, -0.01798580f, -0.01079388f, 0.03367762f, 
    0.01914173f, 0.03662313f, -0.01437068f, 0.04312712f, 0.00246733f, -0.00174214f, 0.01216102f, 0.01330747f, 
    -0.01353119f, 0.01788319f, 0.02692948f, 0.02338222f, 0.00802624f, -0.02684834f, -0.05436782f, 0.00303190f, 
    0.02214300f, -0.03312248f, -0.00630534f, -0.03323401f, 0.04062156f, -0.05179310f, 0.01907927f, -0.03674658f, 
    0.00885018f, -0.00886235f, -0.00366464f, 0.03890572f, 0.03286780f, -0.03663340f, -0.05630526f, -0.04435004f, 
    -0.01468121f, 0.02895304f, -0.05140670f, -0.00349598f, -0.02534444f, 0.00282730f, 0.04704731f, 0.00391099f, 
    0.03758051f, -0.02499396f, 0.01411523f, -0.00638046f, -0.03792667f, 0.02286551f, -0.04045124f, -0.02007558f, 
    -0.05704787f, -0.02695568f, 0.03519669f, 0.02613966f, -0.00209515f, -0.00130291f, -0.02871793f, -0.00145173f, 
    -0.01689225f, 0.03005558f, -0.03664357f, -0.00386524f, 0.01619208f, 0.02531191f, 0.01369605f, -0.03274117f, 
    -0.04582369f, 0.00905987f, -0.03960070f, 0.02633364f, -0.01186926f, -0.04515789f, -0.01652323f, -0.01073494f, 
    -0.01708075f, 0.02990568f, -0.03527243f, -0.01146569f, -0.04871838f, 0.02518356f, -0.03955147f, 0.02517857f, 
    -0.01565594f, -0.01488553f, -0.02282115f, -0.02585316f, 0.02517152f, -0.01160886f, -0.03077784f, 0.04774370f, 
    -0.01039156f, 0.02629474f, -0.00272274f, -0.01173354f, -0.00133934f, 0.00158463f, -0.00711335f, -0.04720641f, 
    0.03550474f, 0.02294382f, 0.03818441f, -0.03748490f, 0.00567764f, -0.02499306f, -0.01516380f, -0.04631205f, 
    0.02287167f, 0.01915657f, -0.04492432f, -0.01426580f, 0.02450573f, -0.00731295f, -0.05699341f, 0.03140764f, 
    -0.02459002f, 0.01551576f, 0.03177270f, -0.02863930f, 0.00594225f, -0.03144975f, 0.03801167f, 0.01929381f, 
    0.01058797f, -0.04268258f, -0.03250151f, 0.04267601f, -0.05679309f, 0.01985176f, 0.01465182f, 0.03314412f, 
    -0.05397203f, 0.01024592f, -0.01390410f, -0.01758831f, -0.02607682f, 0.03017085f, 0.01998790f, -0.00055251f, 
    -0.00689758f, -0.03291028f, -0.01177979f, -0.00888570f, 0.03556987f, 0.00257631f, -0.03849776f, -0.02106497f, 
    -0.04876801f, 0.04456894f, 0.03431705f, 0.00355741f, 0.01690610f, -0.01693293f, -0.00194351f, -0.04004004f, 
    -0.00695163f, -0.04187334f, -0.03914558f, 0.01230135f, 0.00359110f, -0.02584384f, -0.04065691f, 0.01151487f, 
    0.02330390f, -0.00492779f, -0.01711382f, 0.04179281f, 0.02560988f, -0.03652965f, 0.04253772f, -0.00133840f, 
    0.02989985f, 0.03127942f, 0.03143601f, 0.02504134f, -0.00462522f, -0.03776068f, 0.01864056f, -0.05585066f, 
    -0.04013579f, 0.00412507f, 0.01984479f, 0.03264330f, 0.03393976f, -0.04711419f, -0.00113175f, -0.01591647f, 
    -0.04626385f, 0.03495588f, -0.01956727f, -0.03565727f, 0.03148600f, -0.00192339f, -0.01286455f, -0.04540273f, 
    -0.05098199f, -0.02269370f, -0.01484057f, 0.03065619f, -0.04423392f, 0.00186863f, 0.00104689f, 0.02000591f, 
    -0.02413479f, 0.01696780f, -0.05146670f, 0.02025338f, -0.04712350f, -0.00402128f, 0.03298851f, 0.02743021f, 
    0.00430011f, 0.03216988f, -0.01296816f, 0.00986216f, 0.02428777f, 0.00485636f, 0.01395491f, 0.03578752f, 
    -0.01877704f, 0.00081597f, 0.03387855f, -0.02756222f, -0.03812522f, -0.02777229f, -0.04804952f, -0.01621058f, 
    0.01622836f, 0.03903897f, -0.04742361f, -0.01392470f, -0.03138952f, 0.02147306f, -0.03580141f, 0.02581562f, 
    -0.00478734f, -0.01480626f, -0.05479831f, 0.00359465f, 0.03446655f, 0.02801323f, 0.01170787f, 0.04483759f, 
    -0.01420187f, -0.04745207f, -0.00060090f, 0.01706481f, -0.04630705f, 0.03319819f, -0.04917784f, 0.03220672f, 
    -0.05112513f, -0.04548914f, -0.01673501f, 0.00426260f, -0.01779702f, -0.03430939f, -0.05797645f, 0.04065621f, 
    -0.03649382f, 0.03397278f, -0.00756938f, -0.05824365f, 0.03717972f, -0.04508629f, -0.03275796f, 0.00715556f, 
    0.00599030f, 0.02013474f, 0.02765602f, 0.02868400f, 0.02833981f, 0.00495175f, 0.00134960f, -0.02105705f, 
    -0.04016767f, 0.02092808f, 0.02025253f, -0.03258320f, 0.00010626f, 0.01358034f, 0.02859028f, -0.02267523f, 
    -0.05632551f, 0.02258868f, -0.02666853f, 0.01788995f, -0.04220657f, -0.00747091f, 0.02677562f, -0.00179210f, 
    -0.04213545f, -0.01183832f, 0.01451065f, -0.00158377f, 0.02110371f, -0.00168075f, -0.02468752f, -0.02310144f, 
    -0.04827165f, 0.02090703f, -0.03146031f, 0.02479644f, -0.05767011f, -0.01190722f, -0.02510228f, 0.00123684f, 
    0.03385324f, 0.00118173f, -0.00794116f, -0.01224812f, 0.00445193f, -0.05870714f, 0.02810006f, -0.00161214f, 
    -0.00255875f, -0.03537069f, -0.03582558f, -0.03669787f, -0.03035647f, -0.02765473f, -0.01255260f, -0.02681799f, 
    0.03050760f, -0.02467974f, 0.04051451f, 0.01008060f, -0.00728495f, -0.04241162f, -0.04349767f, 0.00497766f, 
    0.03393732f, 0.01537512f, 0.01014296f, -0.05989802f, 0.04162898f, 0.01971496f, -0.01636845f, 0.01102260f, 
    -0.03178067f, -0.04564528f, 0.03700013f, 0.00023216f, -0.01495045f, 0.02916754f, 0.02701296f, -0.01940018f, 
    -0.03394737f, -0.00200475f, -0.01264244f, -0.04966364f, 0.03143973f, -0.01602473f, -0.03244361f, -0.03940013f, 
    -0.02715548f, 0.01477596f, 0.03749019f, -0.02079477f, -0.02822623f, -0.02854257f, 0.01716793f, 0.00303569f, 
    0.00377976f, 0.01753443f, 0.03800613f, -0.00831520f, 0.02050542f, -0.04574469f, -0.01477650f, -0.01712584f, 
    -0.04618542f, 0.01062500f, 0.03871578f, -0.04759581f, 0.00065994f, 0.02429369f, -0.01242537f, -0.00719509f, 
    -0.03555217f, 0.01119829f, -0.05419551f, -0.02188623f, -0.04029210f, 0.03310082f, -0.05897729f, -0.00944800f, 
    -0.02612326f, 0.01626162f, 0.02948975f, 0.01067394f, -0.00583713f, -0.00551852f, -0.00490723f, -0.03293436f, 
    0.01355152f, 0.00361287f, -0.04155991f, -0.00529059f, -0.01067542f, -0.00507981f, 0.02630245f, -0.02430789f, 
    0.03868641f, -0.00108056f, -0.00135114f, -0.03909785f, 0.01817794f, -0.01648487f, -0.01710979f, -0.01435921f, 
    0.01143713f, -0.04384715f, 0.02271297f, -0.00135632f, -0.04131781f, -0.01275578f, 0.01925758f, -0.05259061f, 
    -0.05322159f, -0.03019640f, -0.05820429f, 0.02439028f, -0.05477254f, -0.05283138f, -0.05484040f, 0.02340368f, 
    -0.02160882f, 0.03128145f, 0.01600713f, -0.03585628f, -0.04443323f, 0.03997878f, 0.03420670f, -0.05699731f, 
    -0.02169648f, 0.03065296f, -0.00988545f, 0.01416282f, -0.05809930f, -0.05906106f, -0.02915885f, -0.01230216f, 
    -0.04064524f, 0.01999418f, 0.01816075f, 0.00976764f, -0.01097753f, 0.00932045f, 0.00834733f, -0.03542090f, 
    0.01575772f, 0.00322073f, 0.00136145f, -0.02536739f, 0.02166859f, -0.00054849f, -0.03377303f, 0.02281041f, 
    0.03794058f, -0.04371195f, 0.00448977f, 0.02398603f, -0.01120371f, 0.00705615f, 0.02913397f, -0.04044871f, 
    0.00824661f, -0.05876495f, 0.03967449f, -0.03672891f, -0.04710579f, 0.00632917f, -0.05416197f, 0.01066699f, 
    -0.04220353f, 0.02118468f, 0.00031882f, -0.01090742f, -0.02433077f, -0.03406005f, 0.03290176f, -0.01205613f, 
    -0.02795080f, 0.00519527f, 0.01675593f, -0.05363492f, 0.03426457f, 0.03845947f, 0.00468733f, -0.03845072f, 
    -0.03173309f, 0.01739221f, -0.03874383f, 0.00062214f, -0.00363782f, -0.01974921f, -0.02448292f, 0.00138963f, 
    -0.04604873f, 0.01148335f, 0.03847831f, -0.01343067f, 0.02875390f, 0.03959654f, 0.00163376f, 0.00500023f, 
    -0.04157038f, 0.00521699f, 0.00966825f, -0.02855063f, 0.01415721f, 0.01208170f, 0.00996628f, 0.01992899f, 
    -0.02350446f, -0.01130101f, 0.02017618f, 0.01378877f, 0.00318804f, -0.01742002f, -0.04365120f, 0.04005118f, 
    0.00743088f, -0.00681091f, 0.03603421f, -0.03492089f, -0.03124468f, -0.05751172f, -0.01515040f, 0.01014198f, 
    0.00434570f, -0.02828935f, -0.01009720f, -0.00258853f, -0.01236359f, 0.01135353f, -0.02379318f, 0.00987095f, 
    -0.05913866f, -0.01194286f, -0.05913864f, 0.00926890f, 0.02168057f, -0.00427209f, -0.05927406f, -0.04183818f, 
    -0.02119866f, 0.00110963f, -0.02867617f, 0.02931235f, -0.04240944f, -0.02243735f, -0.02289253f, 0.02961021f, 
    0.02623073f, -0.03642007f, -0.03140031f, 0.01309492f, -0.05943880f, 0.00342494f, -0.02339955f, -0.02923582f, 
    -0.04679583f, 0.02880455f, -0.02985101f, -0.00334194f, -0.04614109f, -0.01940220f, -0.04518215f, -0.03341574f, 
    -0.00237628f, 0.04020169f, 0.01746601f, 0.03739049f, 0.03684887f, -0.02451089f, -0.05833432f, 0.02486468f, 
    0.03864314f, -0.01280648f, -0.02628705f, -0.03093780f, -0.02861382f, -0.02962520f, 0.01767239f, 0.00678259f, 
    0.03923735f, -0.04055823f, 0.00931622f, -0.05968049f, -0.05648592f, -0.01403086f, 0.02183678f, 0.01993753f, 
    -0.05094631f, -0.01408268f, -0.01681259f, 0.00979783f, 0.03407778f, -0.01686203f, -0.02263806f, -0.04441874f, 
    0.02302472f, -0.04631433f, -0.01725404f, -0.02371154f, -0.00989825f, -0.03303994f, 0.01541748f, -0.00280664f, 
    0.01205385f, -0.05965735f, 0.00015116f, -0.03182039f, -0.02335862f, -0.05668145f, 0.00967345f, 0.00644513f, 
    -0.04620763f, 0.02167023f, -0.04527926f, -0.00824852f, 0.03394924f, -0.03076347f, -0.02461989f, 0.02367281f, 
    0.03593888f, -0.03069881f, -0.05971384f, 0.02796171f, -0.01594446f, 0.01528898f, -0.00304308f, 0.02209815f, 
    0.01914572f, -0.00439100f, 0.03852340f, 0.03661757f, 0.01665435f, -0.02969350f, -0.01208974f, 0.03565612f, 
    0.00559578f, 0.03266202f, -0.04379218f, -0.05632336f, 0.00022940f, -0.05107856f, 0.00168244f, 0.00970098f, 
    -0.01038455f, -0.04646740f, -0.02486692f, 0.00756551f, 0.03061896f, 0.00954294f, 0.02494296f, -0.00742480f, 
    -0.01102806f, -0.00391699f, -0.03997624f, -0.04816298f, -0.00817225f, 0.03094549f, -0.02802972f, 0.04001129f, 
    0.01151139f, 0.02067095f, 0.04037721f, 0.01319327f, -0.02283134f, -0.05966753f, -0.04086513f, 0.03346795f, 
    0.03113702f, 0.02016014f, 0.00101900f, -0.02563553f, 0.03186233f, -0.04565844f, 0.02776316f, -0.02686730f, 
    -0.05713128f, -0.01727698f, -0.01773089f, 0.02534537f, 0.00193191f, -0.03605548f, -0.00713796f, -0.00312111f, 
    -0.00223550f, -0.04608812f, -0.05440699f, 0.02775417f, -0.04917803f, 0.01361753f, -0.03278252f, -0.00132432f, 
    0.22100444f, -0.05866225f, 0.23508546f, 0.09392885f, 0.12307448f, -0.04196115f, 0.13005553f, -0.05769922f, 
    -0.10830365f, 0.05886630f, -0.04713209f, 0.05745665f, 0.20060036f, 0.07541590f, 0.32360682f, 0.11768047f, 
    -0.11368409f, 0.12133589f, 0.08804553f, -0.05847634f, -0.08935406f, 0.06493895f, 0.03333385f, 0.03020786f, 
    0.08751318f, 0.02422528f, 0.14058153f, 0.18834832f, -0.12848833f, 0.08755732f, -0.05190279f, 0.05615371f, 
    -0.05071942f, 0.05031379f, 0.01096883f, 0.11735345f, -0.03196121f, 0.17406477f, -0.16099405f, -0.18725377f, 
    -0.04395308f, -0.02726107f, 0.12066579f, 0.03193399f, -0.10388333f, 0.02212216f, -0.06813245f, 0.07501142f, 
    0.22065699f, 0.24542716f, 0.06955588f, 0.00624142f, -0.02583127f, -0.06526307f, 0.10285117f, 0.02913346f, 
    -0.00627296f, 0.12327334f, 0.11705133f, 0.01625411f, -0.18883044f, -0.07736494f, 0.04593456f, 0.13756269f, 
    0.05211210f, -0.03390151f, 0.03198986f, 0.09098086f, -0.05110653f, -0.01016353f, 0.04996052f, 0.03041498f, 
    0.09544767f, 0.04326929f, 0.04168090f, -0.01187298f, -0.12288113f, 0.07339993f, -0.01404381f, -0.01033935f, 
    0.07383677f, -0.10207040f, 0.07175960f, -0.12701598f, -0.15506966f, -0.25045350f, -0.06263556f, 0.24234687f, 
    -0.15570253f, 0.05033269f, 0.11296330f, 0.03227246f, -0.08051928f, 0.01006302f, -0.00307547f, -0.12499000f, 
    -0.18786617f, 0.17539069f, -0.10501656f, 0.09773056f, -0.02438524f, 0.02721787f, -0.00066370f, -0.04483231f, 
    -0.07754698f, 0.04988563f, -0.03274870f, -0.02015327f, -0.23547411f, -0.06349859f, -0.01465607f, 0.06890225f, 
    -0.00798987f, 0.04667801f, 0.00602486f, -0.01821975f, -0.10877933f, 0.07220662f, 0.04390723f, 0.04581469f, 
    0.05039902f, -0.00501848f, 0.00641369f, 0.05651081f, 0.08914161f, 0.06200033f, -0.02311233f, 0.00488939f, 
    -0.07093600f, -0.07678439f, 0.02663757f, -0.02227138f, -0.16881120f, 0.11963806f, -0.04511154f, 0.03172279f, 
    -0.05114843f, 0.01608842f, -0.07682940f, -0.10772280f, -0.07476628f, -0.02824414f, 0.08544613f, 0.01027013f, 
    0.23999195f, 0.19187188f, -0.06454054f, 0.01141471f, -0.05723890f, 0.07586996f, -0.05825764f, -0.01152740f, 
    -0.00419275f, 0.16535990f, 0.03407397f, -0.05132307f, -0.12306965f, 0.00450203f, 0.32996833f, 0.10466250f, 
    -0.00919783f, 0.16108249f, 0.05450679f, -0.02977640f, -0.07099059f, -0.09250346f, -0.02024341f, 0.13096920f, 
    0.09116965f, -0.16668367f, 0.02095988f, 0.00364517f, 0.08339064f, 0.09554409f, 0.10028819f, 0.15989017f, 
    -0.00996223f, 0.06801242f, -0.08778377f, -0.02056526f, -0.03279050f, -0.16627176f, 0.09876857f, -0.08028226f, 
    0.02351764f, -0.09502273f, -0.03250875f, 0.04228002f, -0.05770158f, -0.02093937f, -0.08620510f, 0.01985853f, 
    -0.00333242f, -0.06373782f, 0.13806464f, 0.09798602f, 0.02077392f, -0.05409857f, -0.13222083f, -0.07710973f, 
    0.06918660f, -0.01777544f, 0.05107018f, 0.08280559f, 0.11573692f, 0.13575912f, -0.13166940f, -0.09607683f, 
    -0.04682383f, -0.03623787f, 0.04573737f, -0.05119076f, -0.06699684f, -0.05212351f, 0.00039557f, -0.07264472f, 
    -0.06151948f, -0.02813573f, 0.05398675f, -0.11012142f, -0.05942083f, -0.04295985f, 0.00598868f, 0.14066917f, 
    -0.13013639f, -0.18667257f, -0.04968021f, 0.03132559f, -0.01702771f, 0.17246537f, 0.02852815f, 0.01829277f, 
    -0.00224448f, 0.04840278f, 0.12431718f, -0.06958259f, 0.06147403f, 0.04016543f, -0.09657410f, -0.01009149f, 
    -0.31827384f, -0.07329017f, 0.14405063f, 0.23099510f, 0.05800369f, 0.02447722f, -0.05110452f, -0.12146997f, 
    -0.01207842f, -0.02834900f, 0.12361122f, -0.08333880f, 0.29521576f, -0.09924468f, 0.14928764f, -0.06121928f, 
    0.08396889f, 0.06578007f, -0.09123421f, 0.07007018f, -0.08225583f, -0.02174770f, 0.10083612f, 0.00763120f, 
    -0.26127186f, -0.04430301f, 0.15151647f, 0.08203489f, -0.02848384f, 0.10172869f, 0.05923029f, 0.04401802f, 
    0.05193848f, -0.05230146f, -0.06082214f, 0.06743892f, 0.32533708f, -0.06682385f, -0.04501339f, 0.14277336f, 
    -0.02343917f, 0.07467137f, 0.00786926f, 0.07715557f, -0.03216993f, -0.00447518f, -0.03254585f, 0.10051896f, 
    -0.27204725f, 0.05853905f, 0.09697811f, 0.22227533f, 0.11139795f, -0.04240821f, 0.02121676f, 0.09928986f, 
    -0.01696752f, 0.04992381f, -0.01667980f, 0.04205063f, -0.09333012f, 0.06040341f, 0.04250537f, 0.00263832f, 
    0.02391510f, 0.03943501f, 0.01337643f, -0.02769935f, 0.03379568f, 0.09229743f, 0.08002534f, 0.11696502f, 
    0.08515923f, 0.15584315f, 0.11721943f, 0.01428268f, 0.00005024f, 0.03246691f, 0.00703752f, 0.07567826f, 
    0.16371173f, 0.04701155f, -0.06585286f, 0.13220282f, 0.13840578f, -0.03009108f, -0.02060018f, 0.17073973f, 
    0.08982430f, -0.03124356f, 0.02070491f, -0.02456267f, -0.04011612f, 0.03859471f, -0.00990936f, 0.11640054f, 
    0.30182800f, 0.06085367f, 0.26461533f, -0.25730723f, -0.20789780f, 0.05868086f, 0.03009097f, -0.00074062f, 
    -0.03272192f, -0.04213836f, 0.12984431f, -0.02898279f, -0.03981270f, -0.02827680f, 0.04969643f, 0.03428578f, 
    -0.08782680f, -0.05638025f, 0.05236204f, -0.02514024f, 0.05237779f, -0.02711152f, -0.07785766f, -0.02271351f, 
    -0.20349447f, -0.09944367f, -0.03739274f, 0.01443553f, -0.02208301f, 0.07669416f, 0.00178194f, -0.13072857f, 
    0.06854828f, 0.02026150f, 0.12908515f, -0.00889431f, -0.18171774f, 0.16279519f, 0.11626029f, 0.10332789f, 
    0.02374807f, -0.08386122f, 0.09410451f, 0.12704517f, 0.01619653f, 0.03658426f, -0.00588057f, 0.00209097f, 
    -0.22569381f, -0.03086300f, 0.02404936f, -0.10238424f, 0.08259100f, 0.01180869f, -0.10542311f, -0.04160826f, 
    -0.03063630f, 0.04459226f, -0.10473632f, 0.12201045f, -0.10576796f, -0.03763026f, -0.08579399f, 0.03768114f, 
    0.19188087f, -0.00586807f, 0.00432097f, -0.03355482f, 0.14819340f, -0.08450907f, -0.21687020f, 0.03689886f, 
    0.23817164f, -0.09441916f, -0.15241839f, 0.01547536f, 0.11579190f, -0.04502365f, 0.00371542f, -0.03864423f, 
    0.09820151f, 0.10852955f, 0.11147916f, 0.00441216f, 0.16643266f, -0.15180054f, 0.00411505f, -0.01094479f, 
    -0.14361040f, -0.03615133f, -0.03652291f, -0.10731868f, -0.04117521f, -0.01863585f, -0.04718869f, 0.08224465f, 
    -0.11941075f, -0.11187086f, -0.07048123f, -0.13418972f, -0.05495531f, 0.00400750f, -0.22572285f, 0.03064889f, 
    0.04955146f, 0.07213838f, 0.08081942f, -0.09063152f, 0.27025184f, -0.01698584f, -0.20489720f, 0.01145312f, 
    -0.16138011f, 0.07135917f, 0.00610637f, -0.02105844f, -0.05843598f, 0.02207606f, 0.02597170f, -0.20471075f, 
    -0.22396888f, 0.09443988f, 0.04083264f, 0.13394146f, 0.07291292f, -0.01251746f, -0.03259103f, 0.01248847f, 
    -0.04052192f, 0.04789674f, 0.18808290f, -0.04310735f, 0.19525182f, 0.15868150f, -0.22646771f, -0.11065913f, 
    0.11262410f, 0.01661310f, -0.05374858f, 0.10991921f, 0.19948788f, 0.14968543f, 0.05543362f, 0.05195623f, 
    -0.03770717f, 0.10600465f, 0.00705218f, 0.00160805f, -0.06194519f, 0.06700817f, -0.04328347f, -0.12140282f, 
    0.05931821f, 0.06441627f, 0.03037161f, 0.11113414f, 0.09255119f, 0.14783153f, 0.04998481f, 0.13432992f, 
    -0.14471498f, 0.00955066f, -0.03591715f, -0.09279566f, 0.06555486f, -0.19223416f, 0.01858190f, -0.04401354f, 
    0.01032069f, 0.02594838f, -0.05999416f, -0.04280979f, 0.02974841f, -0.00497726f, 0.00844405f, 0.01334152f, 
    0.13283873f, -0.09279003f, 0.07949527f, -0.04361701f, 0.08802956f, -0.03208832f, -0.02925234f, -0.05203230f, 
    -0.01892992f, -0.05706474f, 0.02317125f, 0.00026855f, 0.04937953f, -0.05986854f, -0.12850650f, -0.01363448f, 
    0.18250126f, -0.20366934f, -0.11362647f, 0.09947802f, -0.05958310f, -0.08043937f, 0.09269220f, 0.08020153f, 
    0.07627796f, 0.07576039f, -0.08943613f, -0.09472778f, 0.19740717f, -0.29372045f, 0.07004458f, 0.20977652f, 
    0.20588969f, -0.01172147f, -0.02002555f, -0.20628473f, 0.06043842f, -0.00645164f, 0.13753156f, 0.09929554f, 
    0.52189243f, -0.04885333f, 0.03954813f, 0.27224007f, -0.09131607f, 0.00299459f, 0.12406772f, -0.02720248f, 
    0.10012800f, 0.10599381f, -0.13684826f, 0.03646395f, -0.09375635f, 0.08743680f, -0.04256313f, 0.00983284f, 
    -0.03558033f, -0.07312905f, -0.08775726f, 0.01396445f, 0.07512005f, -0.04124021f, 0.06406616f, 0.16535787f, 
    0.00327542f, 0.07089616f, 0.06197320f, -0.13617906f, -0.01401360f, 0.04933216f, -0.05445408f, 0.04490579f, 
    -0.12318119f, 0.09145308f, 0.01203645f, 0.11449494f, 0.09156132f, 0.01656926f, 0.07345345f, 0.09790323f, 
    0.14018357f, 0.07493954f, 0.07967252f, -0.11859025f, 0.07730054f, 0.07351956f, -0.02486691f, 0.05747712f, 
    0.20405285f, 0.00103778f, 0.02730997f, -0.06195057f, 0.00347700f, 0.01858375f, 0.13583262f, 0.02127967f, 
    -0.02530068f, -0.06153182f, -0.05960986f, -0.01666124f, -0.18459947f, 0.27982980f, -0.24811044f, -0.08446636f, 
    0.03671119f, 0.06782854f, -0.06930444f, 0.03695254f, 0.04554809f, -0.04707851f, 0.08169933f, 0.01855290f, 
    0.10977076f, -0.17525105f, -0.16768332f, 0.16115031f, 0.07614809f, 0.07014021f, 0.02606368f, -0.02411877f, 
    0.06826100f, 0.12745026f, 0.07758497f, 0.15360861f, 0.06233790f, 0.24075733f, 0.08015618f, -0.09441207f, 
    -0.09463226f, -0.11899129f, 0.09516913f, 0.06310853f, 0.00533346f, -0.08209164f, 0.05072724f, -0.04292302f, 
    0.37251505f, 0.06798070f, -0.26976785f, 0.08238834f, 0.09411708f, 0.02490610f, 0.08578587f, 0.00379331f, 
    0.01823642f, -0.06488232f, 0.02888351f, 0.23259944f, -0.13411933f, 0.08071907f, -0.04236870f, -0.11063303f, 
    -0.03411186f, -0.07835899f, 0.00483929f, -0.03739801f, 0.03232787f, -0.08074704f, 0.04079207f, -0.00997541f, 
    -0.11912917f, 0.17658849f, -0.05051791f, -0.04098655f, -0.01929745f, 0.02953748f, -0.04324875f, -0.03608715f, 
    0.00016605f, 0.01396666f, -0.07873131f, -0.12692574f, 0.14456384f, 0.16046833f, 0.04750818f, -0.25632685f, 
    -0.04743891f, -0.08728126f, 0.04453211f, -0.14470635f, -0.10076271f, -0.01156131f, 0.06699680f, 0.10330832f, 
    -0.03203913f, 0.04567154f, -0.12194242f, 0.00388924f, -0.03232202f, 0.04592614f, 0.09931968f, -0.06207468f, 
    0.00303279f, -0.07999526f, 0.06345525f, -0.07115208f, -0.19178122f, 0.02475813f, -0.02996719f, 0.10566026f, 
    0.18986619f, 0.05758263f, 0.15755527f, 0.07676831f, 0.03297239f, 0.03567005f, -0.02917976f, 0.04141431f, 
    -0.03798992f, -0.02887478f, -0.08349331f, -0.03832215f, 0.23430958f, -0.04112760f, -0.14757532f, -0.09039988f, 
    0.06600539f, -0.00077271f, -0.04494020f, -0.04187137f, -0.27339119f, 0.24808504f, -0.03270895f, -0.05645044f, 
    0.03775308f, 0.02137025f, -0.05931332f, 0.17033780f, -0.05265267f, 0.04236432f, 0.15083764f, 0.00636395f, 
    0.14331844f, 0.04245114f, -0.00362148f, 0.06215807f, -0.00845829f, -0.12107024f, -0.04958510f, 0.05515950f, 
    0.01873071f, -0.04141694f, -0.01943053f, -0.11894602f, -0.28701985f, 0.19540858f, -0.11886234f, 0.05293082f, 
    0.12615578f, 0.09374309f, -0.08049962f, 0.01821256f, 0.06502561f, 0.11486565f, 0.02264790f, 0.02221299f, 
    -0.05490478f, -0.00536664f, 0.02686598f, 0.02024718f, 0.03673055f, 0.04217864f, -0.02409115f, 0.02311181f, 
    -0.03720931f, 0.03945271f, 0.03803867f, -0.00779921f, 0.02821022f, 0.00775873f, -0.01319865f, -0.00052519f, 
    -0.04764624f, -0.00861997f, 0.03763438f, 0.01231528f, -0.04686100f, -0.04514461f, -0.03458814f, -0.04823929f, 
    -0.03613892f, -0.02458057f, -0.00864014f, -0.01176629f, -0.02263030f, -0.04835533f, -0.04745602f, -0.01600571f, 
    -0.00879117f, 0.00380959f, -0.00561362f, 0.00808831f, -0.03715458f, 0.02072828f, 0.02677385f, -0.04898976f, 
    -0.02178019f, -0.03349243f, 0.04175242f, 0.03720475f, 0.04219867f, 0.00721444f, -0.01345920f, -0.00194547f, 
    -0.04796541f, -0.05463676f, -0.00058879f, 0.03954002f, -0.03844851f, 0.02882870f, -0.00158560f, 0.03932067f, 
    0.02731936f, 0.03631718f, -0.04367279f, -0.02889112f, -0.05439446f, -0.02178726f, 0.00152577f, 0.01416616f, 
    -0.05493189f, -0.01337080f, 0.00216936f, -0.01279917f, -0.02743446f, 0.02225262f, 0.03600090f, -0.03871255f, 
    -0.01927690f, -0.00044190f, -0.04639050f, 0.00532934f, 0.01056944f, -0.04723204f, -0.03554104f, -0.01088614f, 
    -0.02756179f, 0.01911964f, 0.02501700f, 0.01901581f, 0.03127772f, -0.00218473f, 0.02584730f, -0.00637684f, 
    -0.02766951f, 0.02601462f, 0.00438234f, 0.00776216f, 0.04485677f, 0.00081838f, -0.05535290f, -0.04182586f, 
    0.02023615f, 0.02413298f, -0.01048487f, -0.04380995f, -0.04591210f, 0.02791765f, 0.03394745f, -0.00277287f, 
    -0.00149079f, -0.01531445f, -0.04948750f, -0.00673695f, 0.02990646f, -0.05559309f, -0.03863719f, 0.01012683f, 
    -0.03796280f, -0.00339735f, 0.03025234f, 0.00550543f, -0.04196439f, -0.03369024f, -0.00693258f, -0.02014761f, 
    0.02591375f, -0.05548044f, 0.03930453f, 0.04520712f, -0.05001836f, -0.01936615f, -0.01740830f, 0.03219129f, 
    -0.01737568f, 0.00029480f, 0.03803371f, -0.02022329f, -0.03912042f, -0.03949987f, 0.02242119f, -0.05580818f, 
    0.02936769f, -0.01594452f, -0.00800222f, -0.05137980f, 0.03528701f, -0.05527007f, 0.00015858f, -0.05165594f, 
    0.02410512f, 0.02088046f, 0.00827428f, -0.01143945f, 0.00042413f, 0.03807336f, -0.04650297f, -0.00027044f, 
    -0.03689320f, -0.02044786f, -0.05217006f, 0.01997803f, 0.04256858f, -0.03103375f, -0.03346103f, 0.02953589f, 
    -0.01386988f, 0.03152620f, -0.05267427f, -0.05181826f, -0.01729945f, 0.02514518f, -0.04262172f, 0.00079082f, 
    0.03961445f, -0.02928527f, 0.04287567f, -0.02811837f, -0.01422175f, 0.05271615f, 0.01030821f, 0.00057492f, 
    -0.04255276f, -0.04559044f, -0.01665439f, 0.02651802f, -0.04313450f, 0.00315880f, 0.01216076f, -0.02207446f, 
    -0.01939182f, 0.00301598f, -0.02076823f, -0.00492984f, 0.01788029f, 0.01940272f, 0.01493708f, 0.00007695f, 
    -0.03884745f, -0.03419141f, 0.00582315f, 0.03343656f, 0.03333065f, 0.03534347f, -0.01953251f, -0.01269604f, 
    -0.02813925f, -0.05234624f, 0.02244123f, -0.01129870f, -0.02722523f, 0.03197335f, -0.05414350f, -0.05610723f, 
    0.03339329f, -0.02681842f, -0.02054662f, 0.00179658f, -0.04863117f, -0.04728558f, 0.02983142f, 0.04125844f, 
    -0.04739723f, -0.03694710f, -0.04382740f, -0.03218983f, 0.02067693f, 0.02911342f, 0.03312246f, -0.01846841f, 
    -0.02698977f, 0.01580508f, -0.04670533f, -0.00571531f, 0.01706921f, -0.03592316f, -0.05747250f, 0.01934042f, 
    -0.04237640f, -0.02579732f, -0.03978936f, -0.02788900f, 0.01039235f, -0.05363914f, 0.03953209f, 0.04205590f, 
    0.00665163f, 0.03411848f, -0.00220751f, 0.04198312f, -0.05312358f, 0.00511138f, -0.04606366f, 0.00908247f, 
    0.01226697f, -0.05287430f, 0.02092196f, 0.03259861f, -0.01835648f, -0.05689184f, 0.01387570f, -0.00415746f, 
    0.02701359f, -0.04847679f, -0.04778815f, -0.03053833f, 0.03567997f, -0.01487090f, -0.01208263f, -0.01803919f, 
    -0.03756903f, 0.02354978f, -0.03490935f, -0.01920808f, -0.04118977f, 0.03654189f, -0.04974797f, -0.04122837f, 
    -0.00954593f, 0.02721616f, 0.01167373f, -0.04993331f, 0.00716501f, -0.04074131f, -0.02324556f, 0.02941444f, 
    0.01411647f, -0.03405749f, -0.03731168f, -0.01394593f, 0.01688564f, -0.01840217f, 0.00777092f, -0.01965821f, 
    -0.01856646f, 0.00190424f, -0.04705815f, -0.02491665f, 0.03967774f, 0.02219770f, -0.05020125f, 0.02159102f, 
    0.04165169f, -0.00306393f, -0.00096705f, 0.03657144f, -0.04560501f, 0.03389482f, -0.03473655f, 0.00429013f, 
    0.03671587f, 0.02079013f, -0.00320016f, -0.04217923f, -0.02727181f, 0.03956054f, -0.03093891f, -0.02586149f, 
    -0.01978161f, 0.02081404f, -0.00135857f, -0.02475476f, 0.02849600f, -0.03552265f, 0.01826142f, -0.04063366f, 
    -0.05001689f, -0.03089426f, -0.01847838f, -0.03883919f, -0.02337522f, -0.00051125f, -0.05119748f, -0.05366280f, 
    -0.02251140f, 0.00622947f, -0.04297418f, -0.03357736f, 0.00110913f, -0.00135060f, 0.02697992f, 0.00675594f, 
    -0.00205165f, 0.01277362f, -0.03468406f, -0.05147322f, -0.05757555f, 0.04114110f, -0.00873483f, -0.01395821f, 
    -0.00033439f, -0.01981296f, 0.02914221f, -0.00401565f, 0.00268078f, 0.01066682f, -0.03523337f, -0.05050887f, 
    -0.00353275f, -0.01526471f, -0.00979463f, 0.00553111f, -0.00625063f, -0.02475243f, -0.01447785f, 0.01785357f, 
    -0.00553794f, 0.04029830f, -0.03757271f, -0.00581010f, 0.00087629f, 0.03940568f, -0.01724930f, 0.04155302f, 
    -0.03298820f, -0.00997637f, 0.02355810f, -0.05124902f, 0.04012262f, 0.00540369f, -0.01526423f, 0.00716529f, 
    -0.03793526f, -0.04468595f, -0.03895287f, 0.00402408f, 0.00604843f, 0.03512475f, 0.00409716f, -0.02431723f, 
    -0.02324835f, -0.00201268f, 0.04011293f, 0.00152513f, -0.04009112f, -0.04813099f, -0.04661150f, 0.00764198f, 
    0.04257450f, 0.04306794f, -0.02611958f, -0.00881979f, 0.01701800f, 0.01726417f, -0.00759431f, -0.00496942f, 
    -0.05530698f, -0.02944064f, -0.01091275f, -0.02162629f, 0.02010375f, 0.02638867f, 0.00343186f, -0.01523936f, 
    -0.01224003f, 0.00705503f, 0.01377665f, 0.00804261f, -0.00915067f, -0.01227842f, 0.00985270f, -0.01596914f, 
    -0.03990977f, -0.00815614f, -0.01805388f, -0.03789831f, -0.01889799f, 0.01887021f, -0.05440611f, -0.00781020f, 
    0.03221483f, -0.02135627f, -0.05482136f, 0.00424857f, -0.01680912f, -0.04922830f, -0.00121175f, 0.03357001f, 
    0.02065695f, -0.03630376f, -0.05170847f, 0.01411840f, 0.01755050f, -0.00278702f, -0.04361578f, 0.00517666f, 
    -0.04575342f, -0.01130505f, 0.01030337f, 0.03834897f, -0.05628003f, -0.03500842f, -0.02414379f, 0.02533633f, 
    0.03552360f, -0.00033614f, -0.00133625f, 0.02068438f, 0.03956579f, 0.00888558f, -0.03600346f, -0.02380221f, 
    -0.05241299f, 0.01088948f, -0.00345980f, -0.01504240f, -0.03262541f, -0.03769035f, 0.02964520f, -0.04324847f, 
    0.04151141f, 0.02743628f, 0.00509017f, -0.04904255f, 0.03701833f, -0.01999188f, -0.04144317f, 0.02237206f, 
    0.03094687f, 0.01024321f, -0.03661280f, -0.03424098f, -0.03007179f, -0.00602945f, 0.00857400f, 0.03964634f, 
    -0.04550369f, 0.03126763f, 0.02226521f, -0.03992286f, 0.02947019f, 0.03750155f, -0.02843827f, -0.00265477f, 
    -0.01056907f, 0.03392743f, -0.03986446f, 0.04072234f, -0.01590126f, -0.01992365f, 0.02256562f, 0.02984921f, 
    -0.00905958f, 0.03290572f, -0.04319696f, -0.03770775f, -0.04577676f, -0.01990237f, -0.01509786f, -0.02513790f, 
    -0.02403178f, 0.00283303f, -0.03247965f, -0.02147433f, 0.02584811f, 0.01522055f, -0.02447893f, -0.02391620f, 
    -0.03522860f, -0.00326844f, -0.00684220f, -0.04068427f, -0.03473628f, -0.03729087f, -0.03152707f, 0.02835644f, 
    -0.04282212f, 0.03944134f, 0.00587637f, 0.03145288f, 0.00183803f, 0.04011624f, -0.05827029f, -0.03605440f, 
    -0.04234589f, 0.01737988f, -0.04138691f, -0.03602748f, 0.02958986f, 0.00393389f, 0.01337732f, -0.04718645f, 
    -0.00902697f, -0.02027492f, 0.01510393f, 0.00302155f, 0.02658814f, 0.03221288f, 0.04106821f, -0.00828708f, 
    -0.03819618f, 0.03580850f, 0.00048897f, -0.02060498f, -0.01649328f, 0.02681318f, 0.00870080f, -0.05351625f, 
    0.03365975f, 0.00754064f, -0.04268798f, -0.03038591f, -0.03424967f, 0.00543694f, -0.04379278f, -0.00781873f, 
    -0.01060428f, 0.01345299f, -0.04104519f, 0.00767577f, 0.00986303f, -0.04341754f, -0.00827084f, 0.01490317f, 
    -0.03591244f, -0.04822974f, 0.00745585f, 0.01017926f, 0.00058068f, 0.01022134f, 0.01649904f, 0.01239603f, 
    -0.03915010f, 0.02706925f, -0.00256808f, 0.01606482f, 0.04273646f, 0.00306398f, -0.02200729f, -0.04815374f, 
    -0.00970075f, -0.03049321f, 0.03162735f, -0.04575664f, 0.02139580f, -0.01637012f, -0.03764505f, -0.03789774f, 
    -0.03033219f, 0.01276645f, 0.03192784f, 0.00899003f, -0.02706836f, -0.00412645f, -0.02510246f, 0.03387854f, 
    -0.01211347f, -0.02203833f, -0.00195232f, 0.01831259f, -0.00594916f, 0.02870329f, 0.04228086f, -0.00511261f, 
    0.02311557f, 0.01442726f, 0.01798716f, -0.04126350f, -0.05533638f, -0.01278325f, -0.00487740f, 0.02732242f, 
    0.02498847f, -0.00963744f, -0.04362443f, -0.05034211f, -0.01956625f, -0.00671959f, -0.03466417f, 0.00938918f, 
    -0.02477334f, -0.03148730f, 0.01744815f, -0.00129437f, -0.03231363f, -0.03313735f, 0.03643924f, -0.03891220f, 
    0.00167305f, -0.02235826f, -0.05729812f, -0.02545561f, 0.03499850f, -0.04053594f, -0.04650561f, -0.00711995f, 
    -0.03935775f, 0.01980072f, 0.03268356f, -0.01559627f, -0.01460398f, -0.02139126f, -0.05452770f, 0.01988660f, 
    -0.00214103f, -0.04188253f, 0.01982715f, 0.00100314f, 0.02485255f, 0.03604962f, 0.02559297f, -0.04451535f, 
    -0.00110312f, 0.01601299f, 0.03156637f, 0.02504074f, 0.01458592f, -0.03176081f, -0.04156430f, -0.03133664f, 
    0.03989303f, 0.01590054f, -0.00613947f, -0.04624781f, -0.04960439f, -0.00294745f, -0.01143040f, -0.01540912f, 
    0.01738370f, 0.00484444f, -0.03615965f, -0.03831412f, -0.05173475f, 0.01003269f, -0.03218132f, 0.02906998f, 
    -0.02972445f, 0.02423558f, 0.00089082f, 0.00417279f, -0.04402514f, 0.00790841f, -0.03997897f, -0.03791159f, 
    0.03155454f, 0.02603824f, 0.02731442f, -0.00151661f, 0.01298153f, -0.02370568f, -0.02690508f, -0.05525064f, 
    0.00924849f, 0.02661865f, 0.01174597f, -0.04370366f, -0.02416368f, 0.02520661f, 0.00895174f, 0.03999890f, 
    -0.04415856f, -0.05424909f, 0.02151426f, 0.03906787f, -0.01066510f, -0.03927081f, -0.03192991f, -0.04624590f, 
    -0.02086249f, -0.00981934f, -0.00429532f, 0.01085336f, -0.04032884f, 0.02817450f, 0.03425616f, -0.05173220f, 
    -0.01786530f, -0.02551223f, -0.03694128f, -0.05260922f, -0.03692342f, -0.01486461f, 0.04160965f, 0.03179243f, 
    -0.02240852f, 0.01560379f, -0.05045148f, 0.04321939f, -0.05499747f, 0.01626134f, -0.01640978f, 0.03828400f, 
    -0.05404273f, 0.01538637f, -0.00011823f, -0.03281248f, -0.01152396f, -0.05646018f, -0.00378002f, -0.03584097f, 
    -0.04705695f, -0.01719544f, 0.02623306f, 0.02889905f, -0.01211005f, 0.01094478f, 0.02135128f, 0.03988448f, 
    -0.04766162f, -0.03918908f, 0.01475921f, -0.03675026f, -0.04523597f, -0.02166422f, -0.00972447f, 0.01198519f, 
    -0.05494806f, 0.01779717f, -0.05473036f, 0.00094044f, -0.04855754f, -0.05288772f, -0.00755948f, -0.05389073f, 
    -0.08574349f, -0.14549051f, 0.16473220f, 0.04687680f, 0.01944843f, -0.08862148f, 0.00240004f, -0.06899600f, 
    -0.09951693f, 0.00634591f, -0.10879087f, -0.06323399f, -0.22143187f, -0.23190929f, -0.26254943f, -0.19591075f, 
    0.02437467f, 0.02468905f, -0.12490340f, 0.06185801f, 0.04769860f, -0.10616852f, -0.07782222f, -0.09156420f, 
    0.22024646f, 0.02588428f, -0.15336883f, 0.20482594f, 0.08458786f, 0.07926761f, -0.07413857f, -0.05758251f, 
    0.02496179f, -0.00455225f, 0.15488397f, -0.00815101f, 0.17089623f, -0.08447688f, 0.17657308f, 0.15135230f, 
    0.00805562f, -0.02597893f, -0.01104817f, -0.02708510f, -0.03718765f, -0.02365099f, 0.04102191f, 0.00425256f, 
    -0.11675899f, -0.19922955f, -0.11683509f, -0.34037250f, -0.00837635f, 0.00521753f, -0.08013442f, 0.09414607f, 
    -0.06095482f, -0.06339626f, 0.05591287f, 0.01311718f, 0.26845822f, -0.07578478f, -0.01462631f, 0.10505395f, 
    -0.03716440f, 0.23768413f, 0.09790145f, -0.00935020f, -0.02634163f, 0.08121339f, -0.00584573f, -0.10588745f, 
    -0.23817626f, -0.03667518f, -0.03874468f, -0.12145369f, 0.13004738f, -0.18923818f, -0.00128825f, 0.04285680f, 
    0.00477235f, 0.01155058f, 0.01654639f, -0.05768963f, 0.19653811f, 0.14184313f, -0.03293201f, 0.04109848f, 
    0.07104924f, -0.07392307f, -0.18508162f, -0.03099551f, 0.12895297f, 0.08592282f, 0.03607976f, 0.07370196f, 
    0.23118022f, 0.09671551f, -0.10922486f, 0.16120213f, 0.06658472f, -0.09487392f, -0.12461051f, 0.00233472f, 
    0.09381447f, 0.03626227f, -0.11251924f, 0.01922342f, 0.11918076f, 0.21067594f, 0.16975088f, 0.02599645f, 
    -0.09521852f, 0.12315534f, 0.10876185f, -0.16159956f, 0.11440279f, 0.04743013f, 0.04253132f, 0.00495087f, 
    0.18911240f, 0.19733062f, 0.12952638f, 0.04353286f, 0.14445044f, 0.00121569f, -0.02527586f, -0.04849607f, 
    0.18984675f, 0.09356544f, -0.00327197f, -0.00632117f, -0.00480196f, -0.19540928f, -0.09660663f, -0.05818650f, 
    -0.08101342f, -0.03839007f, 0.12882306f, 0.09879292f, 0.15593240f, 0.02841162f, -0.00943920f, -0.05531389f, 
    0.05910741f, 0.06052050f, -0.00896381f, 0.08896154f, -0.00127435f, -0.04448737f, 0.01707917f, 0.04800165f, 
    0.08547272f, -0.04427841f, 0.03216626f, 0.07220078f, -0.06900464f, -0.24591137f, -0.29781172f, -0.31835589f, 
    0.03990389f, -0.10782444f, -0.00950867f, -0.04334267f, 0.08441059f, -0.09284101f, 0.00751978f, -0.05799314f, 
    0.17198139f, 0.16310298f, 0.17272158f, 0.07694241f, 0.05658889f, 0.08007666f, 0.07569502f, 0.04562095f, 
    0.06401263f, 0.04479580f, -0.07784066f, -0.19069619f, 0.05172790f, 0.03501157f, 0.23423472f, 0.00526552f, 
    -0.11083874f, -0.03668807f, 0.00210326f, 0.02419527f, 0.01321408f, -0.05319173f, 0.03334193f, 0.02220494f, 
    0.06993303f, 0.12547432f, 0.08181868f, 0.08566965f, -0.01955035f, -0.04348816f, 0.01549591f, 0.01799058f, 
    -0.06810560f, 0.09113451f, -0.07072852f, -0.02702675f, 0.02235327f, 0.05407355f, 0.01659304f, 0.29136059f, 
    0.14761482f, -0.02688933f, -0.02309959f, 0.03823804f, 0.06455843f, 0.02843341f, 0.03382828f, 0.05154008f, 
    -0.01993907f, 0.11907931f, 0.11643481f, 0.01747822f, 0.05810842f, 0.06898398f, 0.05996507f, 0.02837531f, 
    0.03970410f, 0.03595532f, -0.05706882f, 0.05672827f, -0.09036299f, 0.12123629f, -0.10670453f, -0.04299761f, 
    0.04318230f, 0.09564664f, -0.03727857f, 0.09580879f, -0.01174724f, 0.05053220f, 0.08537738f, 0.04728699f, 
    0.15407200f, -0.09361905f, -0.16335247f, -0.10665551f, 0.04801984f, -0.13846363f, 0.06126691f, 0.00178669f, 
    0.09410622f, 0.06867179f, -0.03568007f, 0.03688844f, 0.05242162f, 0.09147218f, 0.22193210f, -0.05168522f, 
    0.06802195f, 0.05204339f, 0.15030910f, -0.01722456f, 0.00963603f, 0.00080432f, -0.07106021f, -0.11487933f, 
    0.28294232f, -0.18088064f, -0.06616562f, 0.08700079f, -0.11330006f, -0.08310705f, 0.02422717f, -0.00244132f, 
    0.04619914f, 0.00785021f, 0.04519510f, 0.22444475f, 0.13686301f, 0.23478380f, 0.09311418f, 0.08818962f, 
    0.02123797f, -0.00848136f, -0.03211663f, -0.12433934f, -0.08132003f, -0.01584460f, 0.07735831f, -0.04317442f, 
    -0.08822926f, 0.20686117f, -0.03943117f, 0.21247621f, -0.05859531f, -0.00440987f, 0.01662255f, 0.06532338f, 
    -0.02370989f, 0.02447231f, -0.03527250f, 0.00495539f, 0.08249143f, 0.24755993f, 0.24828081f, -0.09004551f, 
    0.05687001f, 0.02016220f, 0.03595941f, -0.07821127f, -0.05197791f, -0.02841678f, 0.08891249f, -0.00301895f, 
    0.19784994f, 0.10584465f, -0.02907714f, 0.22387101f, 0.02876114f, 0.09586682f, -0.06059302f, -0.04560779f, 
    0.03835249f, -0.01480493f, 0.00817572f, -0.14022191f, 0.00088199f, -0.08880620f, 0.01950478f, -0.05589677f, 
    0.12948430f, 0.09728968f, 0.04000273f, 0.06139923f, -0.01849871f, -0.02819410f, -0.05253851f, 0.14294618f, 
    -0.48094597f, 0.01669027f, -0.17407817f, -0.15972802f, 0.07793835f, -0.08813196f, -0.06879729f, -0.07609181f, 
    0.01325874f, -0.10647282f, -0.14641371f, -0.09443238f, -0.40270901f, -0.02804756f, -0.00603753f, -0.10282040f, 
    0.04228007f, 0.11796211f, -0.09772581f, 0.10169698f, -0.08276063f, 0.01638188f, 0.03297382f, 0.05019639f, 
    0.01456950f, -0.03641069f, 0.09281414f, -0.04698786f, -0.03088951f, -0.15733662f, 0.07136562f, 0.00776011f, 
    -0.01224653f, -0.03305563f, -0.00137259f, -0.02681486f, -0.18430629f, 0.11812186f, -0.18152852f, 0.17642672f, 
    0.12180384f, -0.00633806f, -0.07067690f, 0.02241337f, 0.01577416f, 0.11537494f, 0.01085766f, 0.09074736f, 
    0.18092908f, -0.17778037f, 0.00213805f, 0.08405355f, -0.07690825f, -0.11202911f, 0.10681841f, -0.06238267f, 
    0.13907473f, 0.01034954f, 0.13320559f, 0.02516658f, 0.07371825f, -0.00674532f, 0.07302283f, 0.04479084f, 
    -0.10950803f, 0.01317597f, 0.00977197f, 0.00317269f, 0.03150213f, 0.08244970f, 0.14327337f, -0.12717763f, 
    -0.22165589f, 0.10094084f, 0.04040099f, 0.12801570f, 0.01773750f, 0.03677187f, 0.00490387f, -0.00466144f, 
    -0.04868814f, 0.02345406f, 0.03665942f, -0.06370393f, -0.14254746f, 0.05640220f, 0.03603345f, -0.03317912f, 
    0.11749902f, 0.08634678f, 0.07530570f, 0.06115712f, 0.04623301f, 0.05421860f, 0.04012538f, -0.05391813f, 
    0.19303088f, 0.02065498f, 0.19529696f, -0.06376979f, 0.01421217f, -0.04263043f, 0.06848445f, -0.06039987f, 
    -0.05487331f, -0.15055183f, 0.00120926f, 0.12616108f, -0.11035472f, 0.04029279f, 0.13619328f, -0.00625089f, 
    0.07253350f, 0.09706803f, -0.01260143f, -0.05514953f, 0.09739121f, 0.02829630f, -0.01260476f, 0.01620312f, 
    0.26835343f, -0.06396706f, -0.08390047f, -0.20805727f, 0.13649793f, -0.05157599f, 0.01532579f, -0.01283564f, 
    0.00742235f, 0.06769882f, -0.10429537f, 0.12921974f, -0.02214937f, 0.02754518f, 0.00756651f, 0.08641721f, 
    0.04099697f, -0.00259177f, -0.11801236f, -0.00156954f, 0.00659766f, -0.02286769f, -0.08136046f, 0.00862682f, 
    0.09576504f, -0.02853753f, -0.01814937f, -0.03921865f, 0.12403794f, -0.06413354f, 0.05253727f, 0.03811159f, 
    0.03818451f, -0.04080696f, -0.05965971f, 0.05184682f, -0.12925635f, -0.07641269f, 0.01373984f, -0.04825217f, 
    0.07878776f, 0.12578544f, 0.02910941f, -0.01297914f, -0.05625283f, 0.07728417f, 0.08251830f, -0.02862945f, 
    0.05545657f, -0.00846431f, 0.13990298f, 0.01237733f, 0.02097264f, -0.00330016f, 0.14565907f, 0.01163945f, 
    -0.05453243f, -0.01557176f, 0.05360322f, 0.03930893f, -0.09643699f, -0.09459483f, -0.08730119f, -0.00900006f, 
    -0.00633722f, 0.06168313f, -0.00539894f, -0.08053895f, 0.02321022f, -0.01965797f, 0.09313817f, -0.05199438f, 
    -0.10268348f, 0.11482059f, 0.12732984f, -0.07592021f, 0.09044691f, 0.06843907f, -0.06683457f, 0.02744714f, 
    -0.02129622f, -0.02023098f, 0.09858204f, 0.03312961f, -0.09103292f, 0.29109222f, -0.09637455f, -0.15848084f, 
    -0.10072789f, -0.00899442f, -0.05101417f, 0.05035935f, 0.08917365f, -0.03861859f, -0.02538316f, -0.00848995f, 
    -0.46539009f, 0.20977648f, 0.12385408f, -0.32308507f, 0.15842022f, 0.00916322f, -0.00159656f, -0.00577614f, 
    -0.10209256f, 0.00464319f, 0.03657766f, -0.00282553f, 0.26965928f, -0.11211273f, 0.20635523f, -0.06900512f, 
    0.08714201f, -0.01495092f, 0.13989796f, 0.02163946f, 0.06218246f, 0.10662124f, -0.04747710f, -0.04795665f, 
    -0.08916520f, -0.05831044f, -0.03411052f, 0.03976391f, 0.00491815f, 0.01340929f, 0.01367774f, -0.04115658f, 
    0.07376433f, 0.02077372f, -0.06938431f, 0.03203875f, -0.24921688f, -0.07081474f, 0.08123964f, 0.22049135f, 
    -0.05456096f, -0.10176756f, -0.10158798f, 0.11835217f, 0.00778227f, -0.03229729f, -0.01157124f, 0.05487517f, 
    -0.17905876f, 0.01981042f, -0.02406870f, -0.03730023f, 0.19312942f, 0.07117487f, 0.07695387f, -0.03644369f, 
    0.10617369f, 0.16111103f, 0.11109741f, 0.08647450f, 0.19381842f, -0.25060046f, 0.25002319f, 0.14243330f, 
    0.06889122f, -0.05841913f, -0.06437899f, 0.00594829f, 0.07367720f, 0.01456884f, -0.01357063f, 0.03705723f, 
    -0.02532943f, 0.14935988f, 0.10971802f, -0.11001705f, -0.09176861f, -0.06108631f, -0.04126250f, 0.02075073f, 
    0.07287475f, 0.09510486f, 0.03525594f, -0.01806530f, -0.18075003f, -0.19592513f, 0.04346332f, -0.07845810f, 
    0.07905114f, 0.09905206f, -0.02855430f, -0.08981855f, 0.05614246f, 0.06541331f, 0.06332911f, -0.00995744f, 
    -0.08045366f, -0.21034630f, 0.20875098f, 0.04357523f, -0.05434428f, -0.11423904f, -0.05008228f, -0.09566909f, 
    -0.06153853f, 0.09369311f, 0.05580205f, -0.01198346f, 0.11930987f, 0.10763897f, 0.07360220f, 0.06547967f, 
    0.05884402f, 0.13723613f, 0.01122933f, -0.00968820f, -0.04930450f, -0.04321896f, 0.08324435f, -0.03394724f, 
    0.14860436f, 0.01026098f, -0.04169775f, 0.15799727f, -0.03406704f, 0.03146273f, 0.07444691f, -0.00694082f, 
    0.04490511f, -0.01031667f, -0.03500804f, 0.13303120f, -0.19300310f, -0.03344016f, 0.17620336f, 0.05176640f, 
    0.06959794f, 0.13071376f, -0.00423334f, -0.03136209f, 0.02830656f, 0.11973792f, -0.01146237f, -0.02548897f, 
    0.10581046f, 0.06058590f, -0.00762479f, 0.07259817f, 0.01260704f, 0.01553984f, -0.00909636f, -0.00995483f, 
    -0.07457183f, 0.05228849f, -0.13109088f, 0.02555490f, 0.19703677f, -0.04133614f, 0.13554677f, -0.03113279f, 
    -0.05753453f, 0.08541384f, -0.08444239f, 0.03444652f, -0.00566867f, -0.00893647f, 0.14052422f, -0.12172997f, 
    -0.07752347f, 0.16766492f, -0.02539339f, 0.07173430f, -0.10190928f, -0.06556989f, 0.05948051f, 0.00478251f, 
    -0.08615016f, -0.02524592f, 0.03699288f, 0.03700476f, 0.15370715f, -0.17583448f, 0.11333723f, 0.08309140f, 
    -0.05541717f, 0.06037904f, 0.10105125f, -0.05697506f, 0.01696281f, -0.04638077f, -0.05097874f, -0.06278285f, 
    -0.31875700f, -0.04724190f, 0.14083432f, 0.06646156f, 0.04120975f, 0.15335317f, 0.07942659f, -0.10477364f, 
    0.04559150f, -0.04957344f, 0.02504731f, 0.06173531f, 0.27280602f, -0.00818298f, 0.03930294f, 0.24444416f, 
    -0.00643348f, -0.03806271f, -0.00131122f, -0.02993423f, 0.05594918f, -0.05762723f, 0.05559672f, 0.02682422f, 
    -0.12393094f, 0.01252449f, 0.32440746f, 0.06610029f, 0.01790855f, -0.09365937f, 0.13904719f, -0.11306644f, 
    -0.09271453f, -0.04277435f, -0.00224579f, 0.03254215f, 0.21538490f, -0.07899843f, 0.01650926f, 0.01080705f, 
    -0.18904446f, -0.01642304f, 0.00562398f, 0.06916278f, 0.01777590f, 0.02474742f, -0.03759002f, -0.13026643f, 
    0.10384305f, -0.02311388f, 0.03611821f, 0.33238485f, -0.12761898f, -0.12613353f, -0.01620638f, -0.03956390f, 
    -0.00054533f, -0.00172199f, 0.02591680f, 0.08881924f, -0.08681680f, 0.21171345f, -0.05592854f, -0.17632888f, 
    0.06543154f, -0.11297607f, 0.09312037f, 0.11876058f, -0.05376089f, -0.04195600f, 0.05480440f, 0.10338531f, 
    -0.10282955f, 0.17245910f, -0.05315410f, 0.04071984f, 0.00985689f, -0.00846336f, 0.11030161f, 0.04276029f, 
    -0.02883928f, 0.03131260f, 0.06064538f, 0.05157383f, -0.24352276f, -0.16449298f, 0.14011604f, 0.13888119f, 
    0.08438770f, -0.02378792f, 0.16269757f, -0.01275636f, -0.04289583f, 0.00709467f, 0.07221834f, 0.06686144f, 
    -0.00284976f, -0.08530280f, -0.16103245f, -0.15445340f, -0.01426311f, -0.04143815f, 0.01029063f, -0.01617295f, 
    0.09797010f, 0.00422612f, 0.04981494f, -0.06775549f, 0.12835188f, -0.27239507f, -0.03971498f, -0.05374614f, 
    -0.18987918f, -0.00093006f, 0.01840696f, -0.04543935f, 0.01488606f, 0.09759501f, 0.04477167f, -0.09061281f, 
    0.04227135f, 0.09067272f, -0.13246438f, 0.36676443f, 0.06888015f, 0.03459705f, 0.03758049f, 0.09474232f, 
    0.04107624f, 0.05909738f, -0.02674985f, -0.06867600f, -0.04283461f, 0.14683172f, -0.01732498f, 0.10398297f, 
    0.07999423f, -0.04608538f, 0.12454708f, -0.04727583f, -0.03969405f, 0.11026677f, 0.08770049f, 0.05822354f, 
    0.14554787f, -0.01655600f, 0.08683041f, 0.13173403f, -0.02213152f, 0.05603803f, -0.05059580f, 0.11985767f, 
    -0.02282268f, 0.00919469f, -0.05211250f, 0.01928877f, -0.13180359f, -0.06154520f, -0.11883329f, -0.05639613f, 
    -0.03028953f, 0.01634301f, -0.05389483f, -0.04282048f, -0.06048057f, 0.06576158f, 0.02451613f, -0.02192640f, 
    0.25186032f, 0.18253252f, 0.06044376f, -0.00837233f, -0.09830172f, -0.13599975f, -0.01117273f, 0.10996841f, 
    0.00461570f, 0.11155117f, 0.08029081f, 0.01463853f, 0.03922663f, 0.06507255f, -0.02742467f, 0.19883962f, 
    -0.15626259f, 0.15066028f, 0.05784377f, 0.06909291f, -0.04425055f, -0.13157703f, 0.02257922f, 0.01143877f, 
    -0.30277786f, 0.02311499f, 0.18449992f, 0.06474426f, 0.08073074f, 0.08724813f, 0.07655946f, 0.19393696f, 
    -0.03130854f, -0.06204819f, 0.10124255f, -0.01100750f, -0.09557872f, -0.18673438f, -0.00762311f, 0.07104322f, 
    -0.05894200f, -0.04496145f, -0.09496392f, -0.07456020f, -0.04597338f, 0.02073248f, -0.06398357f, -0.01279194f, 
    -0.01387416f, 0.10765319f, 0.24542528f, 0.27011526f, -0.00145488f, -0.13948596f, -0.06422701f, 0.05322941f, 
    0.01604349f, -0.09972517f, 0.09542305f, -0.08237656f, 0.05892339f, 0.20939745f, -0.09615213f, 0.14339197f, 
    -0.00954002f, -0.11324585f, -0.04726859f, 0.00407617f, -0.08679643f, 0.04951344f, -0.04233032f, -0.01441760f, 
    -0.52064109f, 0.08305171f, -0.02598500f, 0.09217405f, 0.10079299f, 0.09637631f, -0.03255798f, -0.05696946f, 
    -0.04292112f, -0.05438250f, -0.12142521f, 0.13813862f, -0.41607767f, 0.37319171f, 0.02422620f, -0.06530876f, 
    0.08125491f, 0.06134798f, 0.01598501f, -0.02143899f, 0.02021253f, -0.02819018f, -0.04117263f, 0.00145266f, 
    -0.01452961f, -0.11587107f, 0.19157842f, 0.31999034f, -0.05201634f, -0.12861212f, 0.01943449f, -0.00269547f, 
    0.11182001f, -0.03302574f, 0.07277972f, -0.08178446f, -0.11671402f, 0.20631303f, 0.30882522f, -0.13318573f, 
    -0.02164448f, 0.05074961f, -0.06791775f, 0.02131590f, -0.06547463f, -0.04594898f, 0.04804518f, -0.01933914f, 
    -0.28278959f, -0.06055861f, 0.08392591f, 0.01475059f, -0.16121313f, -0.01826203f, 0.11040727f, -0.00481485f, 
    0.12273007f, 0.05146139f, -0.00428627f, 0.06990611f, 0.36510128f, 0.09608401f, 0.01638540f, 0.17342626f, 
    -0.01646831f, -0.02515165f, 0.07756575f, -0.06299213f, -0.02492897f, 0.11895479f, -0.01585770f, -0.02590661f, 
    -0.12523621f, 0.04545376f, 0.16381167f, 0.12833722f, 0.00485525f, -0.01863343f, 0.03316724f, 0.11298060f, 
    0.02335078f, 0.14001235f, 0.01898562f, 0.02965447f, -0.00768662f, 0.32197586f, 0.08846243f, 0.13871917f, 
    0.16590494f, 0.08320971f, -0.02080304f, 0.08971012f, 0.08867700f, -0.00945075f, 0.05838633f, -0.03825268f, 
    0.09273489f, 0.12182562f, 0.11548105f, 0.25382045f, 0.04138917f, -0.03468821f, -0.06817295f, 0.07857944f, 
    0.18667753f, 0.02166279f, -0.15763594f, 0.00948040f, 0.40081501f, -0.09796376f, -0.09154642f, 0.04674503f, 
    0.03192061f, -0.07752941f, -0.01405305f, -0.05541566f, 0.06495686f, 0.03918943f, -0.10324747f, 0.11052428f, 
    -0.01254117f, 0.07846548f, 0.00833776f, -0.07101092f, -0.15390667f, 0.01950492f, 0.05191722f, -0.07489181f, 
    0.05063857f, -0.06387524f, 0.02154675f, -0.06696574f, -0.25026622f, 0.12655142f, 0.00886908f, -0.11306662f, 
    0.12217019f, 0.00468206f, -0.06765358f, -0.06086763f, 0.01722333f, -0.03576722f, -0.08355981f, -0.12882552f, 
    -0.29158080f, 0.18230832f, -0.05663423f, -0.04705586f, 0.09855758f, 0.04201695f, 0.23274179f, -0.04162748f, 
    -0.01150173f, 0.02307593f, 0.17710905f, -0.03753975f, 0.12623456f, 0.15616469f, 0.01910482f, -0.11739982f, 
    0.07452739f, -0.00174675f, 0.11343580f, 0.10576344f, 0.06264267f, 0.03548653f, -0.03427284f, 0.03954953f, 
    -0.04423836f, -0.04890429f, -0.04904856f, -0.04788551f, -0.00384293f, -0.04875267f, 0.04673790f, 0.00281397f, 
    0.04172041f, 0.01815561f, 0.02371163f, -0.03227900f, -0.04207877f, 0.04009613f, -0.00176675f, 0.04789031f, 
    -0.03846500f, -0.00067362f, -0.02950573f, -0.01670950f, 0.03344132f, -0.02422129f, -0.01007701f, -0.00359688f, 
    -0.03609009f, 0.03205204f, -0.01571823f, 0.01150059f, -0.02274318f, -0.02824135f, 0.03317439f, -0.05766930f, 
    0.03486619f, -0.04390473f, 0.03816947f, -0.04921291f, 0.01553437f, -0.02156118f, -0.03574450f, 0.00780135f, 
    -0.00368558f, 0.00142403f, -0.04854295f, 0.01030675f, -0.03914054f, -0.02075260f, -0.05005026f, -0.04998854f, 
    0.01059655f, -0.02941985f, 0.00302254f, -0.02418549f, -0.00721757f, 0.00572926f, -0.04368456f, 0.00487058f, 
    0.04570929f, -0.03369439f, 0.01776854f, -0.03921808f, -0.02748464f, -0.02459419f, -0.01127413f, -0.05301427f, 
    -0.05078798f, 0.01312706f, 0.03185132f, -0.05318842f, 0.03229415f, 0.02029104f, 0.04737093f, 0.01331318f, 
    0.01631621f, -0.01499778f, -0.02826671f, 0.01911810f, 0.03306452f, 0.04709214f, -0.05557676f, 0.02319416f, 
    0.01536712f, 0.02668113f, -0.01861944f, -0.02148749f, 0.01593666f, 0.01418297f, -0.05127372f, 0.01406091f, 
    0.03447363f, 0.01957465f, 0.00681244f, 0.01063049f, 0.01399320f, 0.01229731f, -0.00701510f, -0.01338425f, 
    0.01148469f, 0.01367683f, -0.02049494f, 0.01623643f, 0.03151289f, -0.00363888f, 0.00732743f, 0.00086223f, 
    -0.01025078f, -0.01379344f, 0.01082780f, -0.04310087f, -0.02787878f, -0.02207417f, 0.03140697f, -0.04990422f, 
    0.04236861f, -0.04584075f, -0.04039058f, 0.02590317f, 0.02662457f, 0.02752345f, -0.01418777f, -0.03659237f, 
    0.04012382f, 0.04027603f, 0.04333968f, 0.01922584f, 0.01664991f, -0.00253979f, -0.00785876f, 0.03799726f, 
    -0.05379894f, -0.00948829f, -0.02821025f, -0.00694365f, -0.00759949f, -0.00256257f, -0.01310499f, 0.00836562f, 
    0.02772906f, -0.04075062f, 0.01442085f, -0.02232973f, 0.00844062f, 0.01351871f, -0.00579242f, 0.02137657f, 
    0.02371402f, -0.04019327f, -0.00512456f, 0.00499370f, -0.03326526f, -0.03277356f, 0.04214657f, 0.02170319f, 
    -0.03251404f, -0.04345515f, 0.04660834f, 0.00094282f, 0.03826829f, 0.00013892f, 0.02555464f, -0.00065774f, 
    0.00721232f, -0.03165931f, 0.03741750f, -0.02124541f, 0.03443605f, 0.02260112f, 0.01114400f, 0.01355319f, 
    -0.02637469f, -0.04369191f, -0.03015209f, 0.02185020f, -0.01968614f, -0.04503033f, 0.01119584f, 0.04775696f, 
    0.00362711f, -0.01661675f, 0.01448614f, -0.02241508f, 0.02267868f, 0.00274736f, -0.00408832f, -0.01834391f, 
    -0.01237038f, 0.01618486f, -0.00543908f, -0.01070467f, -0.05696518f, 0.01311152f, 0.03601382f, 0.03113583f, 
    -0.02097327f, -0.02112478f, -0.01025039f, -0.03513434f, -0.00750680f, -0.04874657f, -0.02684098f, -0.04330670f, 
    -0.04724457f, -0.00065760f, -0.03502630f, -0.04673047f, -0.02485229f, -0.00412211f, -0.04382978f, 0.02675161f, 
    0.03913274f, -0.01586352f, -0.04340822f, -0.00318690f, -0.03256017f, -0.05351022f, -0.04378829f, -0.04996881f, 
    -0.02362936f, 0.01821924f, -0.03482844f, -0.00345144f, 0.01511433f, -0.00875064f, -0.02874588f, 0.03409262f, 
    0.02279044f, 0.01085654f, -0.05318082f, -0.03438975f, -0.03985786f, 0.00282791f, 0.03075909f, -0.03273932f, 
    -0.04954682f, -0.00916310f, 0.01884633f, -0.04551518f, -0.03670332f, 0.01898446f, -0.04085952f, 0.01993528f, 
    0.02074649f, -0.03959721f, -0.01385703f, 0.03461993f, 0.01213511f, -0.03082953f, -0.03741249f, 0.01454034f, 
    -0.05583300f, -0.03579732f, -0.05220098f, 0.02433204f, -0.03156490f, 0.03656875f, -0.01032757f, 0.00674502f, 
    -0.01775638f, 0.04397442f, 0.03876676f, -0.04150039f, 0.04199177f, 0.00080867f, 0.01287633f, -0.02791252f, 
    -0.04839144f, 0.00430357f, -0.04661261f, -0.00745848f, 0.03999302f, -0.04038895f, 0.04492445f, -0.01955982f, 
    -0.05130208f, 0.02829762f, -0.05633676f, 0.03513511f, 0.03661459f, 0.04163467f, 0.00381054f, -0.03809906f, 
    -0.00327325f, 0.00108815f, -0.01378554f, 0.01667888f, 0.01910670f, -0.00723101f, 0.01233419f, 0.00838723f, 
    0.02234492f, -0.03265383f, -0.02764541f, 0.03026117f, 0.04730118f, 0.02166258f, -0.05331102f, 0.03054021f, 
    -0.04972091f, 0.00332187f, 0.03910695f, 0.04911010f, -0.00471443f, -0.02277843f, 0.03605562f, -0.04287984f, 
    -0.02664487f, -0.01987593f, -0.01006076f, 0.02820763f, -0.03746599f, -0.04910420f, 0.02279696f, 0.00716948f, 
    0.00363584f, -0.02166742f, -0.01894547f, 0.00343204f, -0.05179002f, 0.02450158f, 0.03153785f, -0.05443437f, 
    -0.01786799f, 0.01163268f, -0.02382406f, -0.01070462f, -0.03397751f, -0.02913061f, 0.03210408f, -0.02765459f, 
    0.03108231f, -0.04371405f, -0.00991723f, -0.00590436f, 0.02635365f, -0.01015143f, -0.02098767f, 0.01370285f, 
    -0.02939718f, 0.03133895f, 0.02362475f, -0.02787473f, -0.01290493f, 0.02103894f, -0.02483110f, -0.04184997f, 
    -0.03345412f, 0.01214418f, -0.01539521f, -0.00608398f, -0.04915172f, -0.03436952f, 0.01002256f, 0.04534032f, 
    0.02245272f, -0.01788327f, -0.01206258f, -0.01637013f, -0.05264129f, -0.04444152f, 0.00135347f, -0.04334680f, 
    -0.00102486f, 0.00820743f, -0.05192947f, -0.00157813f, -0.03454582f, -0.04288241f, -0.05018989f, -0.01232260f, 
    0.01558594f, -0.00301288f, 0.02462536f, 0.01198779f, -0.02530454f, -0.05278786f, -0.05148366f, 0.03551640f, 
    0.00907231f, -0.01039361f, -0.05451594f, 0.01478482f, 0.00493306f, 0.03619733f, 0.01105864f, 0.01671791f, 
    0.12039724f, 0.02300463f, -0.25301704f, 0.13784096f, -0.01592251f, -0.00133336f, -0.03646301f, 0.06192085f, 
    0.12734823f, 0.07727247f, 0.20110595f, 0.06141339f, 0.18962617f, 0.30729815f, 0.32358366f, 0.12493164f, 
    0.05985360f, 0.01742289f, 0.04863339f, -0.09836445f, 0.08545689f, 0.06027609f, 0.05305692f, -0.00276722f, 
    -0.20855299f, -0.02227794f, 0.20115396f, -0.01734271f, 0.04331510f, -0.01349853f, 0.12901780f, -0.03962729f, 
    0.03374545f, 0.07015888f, -0.01457610f, -0.01724677f, -0.30477804f, -0.07953551f, -0.03386461f, -0.12125812f, 
    0.05560666f, 0.15616934f, -0.04858361f, -0.05626949f, -0.01406117f, 0.07443416f, 0.12632801f, -0.00743319f, 
    0.11060368f, 0.15316986f, 0.15953769f, 0.17173003f, 0.04211671f, 0.03930651f, -0.05653767f, -0.05568779f, 
    0.09103780f, 0.02581149f, -0.16761746f, 0.01759214f, 0.01317778f, 0.22967248f, -0.13703263f, -0.13079564f, 
    0.14522690f, 0.02094078f, -0.01632124f, 0.09633218f, 0.11258304f, -0.00481813f, -0.10931875f, 0.00735266f, 
    0.11640208f, 0.07740637f, 0.06060617f, 0.12537816f, 0.07710843f, 0.09211659f, -0.00978498f, 0.06235851f, 
    0.07149222f, -0.05462000f, -0.03508440f, 0.09196903f, -0.18103048f, 0.24461614f, 0.04275093f, 0.13754727f, 
    -0.00764222f, -0.12009086f, -0.02589606f, -0.01140309f, -0.01350901f, -0.07680744f, 0.00664810f, -0.00365374f, 
    -0.17208330f, -0.08760489f, 0.08718827f, 0.04150539f, -0.01849584f, -0.01687188f, 0.06793319f, -0.09488508f, 
    -0.03091273f, -0.01429956f, -0.01052198f, 0.03827417f, -0.19379686f, -0.26996726f, -0.16535433f, -0.08939964f, 
    0.29563585f, 0.11543403f, 0.02754912f, 0.09209726f, -0.03502910f, -0.06720358f, -0.00200282f, 0.04110503f, 
    -0.15311062f, -0.12783542f, -0.11370484f, 0.01108474f, -0.01239397f, 0.03941230f, 0.06006556f, -0.03656330f, 
    -0.12356219f, -0.05773035f, -0.02255795f, 0.01081587f, 0.17139153f, 0.00730029f, 0.00887137f, -0.06276695f, 
    0.09304495f, -0.00970124f, -0.05733757f, -0.02733526f, -0.05469647f, 0.00205533f, 0.03030818f, 0.07832044f, 
    -0.05452817f, -0.13310604f, 0.03496718f, 0.07644308f, -0.01058374f, 0.03359403f, 0.06819050f, 0.00245778f, 
    -0.07264176f, 0.02785485f, -0.05329264f, 0.00291746f, 0.22625603f, 0.24837646f, 0.32470226f, 0.10524468f, 
    -0.10815336f, -0.03607627f, 0.12779619f, 0.01660575f, 0.06311890f, 0.16333894f, 0.06097589f, 0.10449798f, 
    -0.38001963f, 0.11017505f, -0.12523489f, -0.26196948f, 0.10135387f, -0.02058819f, -0.01894073f, 0.11050000f, 
    -0.03897903f, -0.01318572f, -0.00542511f, 0.03727968f, 0.24739088f, 0.02972181f, -0.10309916f, 0.12802973f, 
    0.08727330f, 0.03620426f, 0.05956429f, 0.07358912f, 0.10082131f, 0.04234497f, -0.01857977f, 0.00253553f, 
    -0.06496593f, -0.00422779f, -0.03690453f, -0.04754165f, 0.00385755f, -0.05604924f, -0.06327163f, -0.06606624f, 
    0.02353713f, -0.01924702f, -0.01187306f, 0.01915747f, -0.32764003f, -0.18937895f, 0.23718324f, 0.22245033f, 
    -0.13132337f, -0.07188226f, -0.02833904f, -0.03790587f, -0.10064697f, -0.04789471f, 0.01572550f, 0.05315334f, 
    0.01893176f, -0.01540082f, -0.02959452f, -0.06697962f, 0.04153085f, 0.07624295f, -0.04724360f, 0.02348699f, 
    0.08282628f, 0.01495603f, 0.06864440f, -0.07993241f, 0.25052014f, -0.24489480f, 0.06917200f, 0.11781333f, 
    0.12854694f, -0.06763013f, -0.01938633f, -0.06568395f, 0.04237738f, 0.02246061f, 0.03813142f, -0.09760298f, 
    0.27077991f, 0.26817772f, 0.10832157f, 0.03301753f, -0.06715768f, 0.01283586f, -0.10832594f, 0.03214883f, 
    -0.07688189f, 0.06655989f, 0.03508145f, 0.10506067f, -0.34808487f, -0.15039933f, -0.36969781f, -0.08737780f, 
    0.05626832f, -0.04380957f, -0.00462504f, 0.04852226f, 0.03024596f, -0.00808214f, -0.00948347f, -0.01823644f, 
    0.24493112f, 0.27206060f, 0.11031553f, 0.14325184f, 0.03735242f, -0.05702370f, -0.05993438f, -0.01102810f, 
    -0.00961825f, -0.03107271f, -0.02422360f, -0.08692227f, -0.22188872f, -0.12385955f, 0.00994443f, -0.06753894f, 
    0.07542237f, 0.09516801f, -0.01906434f, -0.06682787f, 0.06981905f, -0.11697070f, 0.00914335f, 0.01238492f, 
    0.24771908f, -0.17715088f, -0.03244645f, -0.09939887f, 0.02982879f, 0.02304310f, 0.02279266f, -0.00540789f, 
    0.02956735f, 0.01075902f, -0.02278091f, 0.02298531f, -0.34304327f, -0.24643004f, -0.25082824f, 0.04583910f, 
    0.07353770f, 0.06833735f, -0.00068078f, 0.08941787f, 0.04980633f, 0.04363258f, -0.03655301f, 0.03302206f, 
    -0.20798984f, -0.11074603f, -0.07042500f, 0.08270570f, -0.04469386f, 0.00387213f, 0.08144187f, -0.10262893f, 
    -0.14085092f, 0.06822763f, 0.06917264f, 0.06427138f, 0.04338809f, 0.24389449f, 0.09806176f, 0.08695387f, 
    -0.04210063f, -0.06061399f, 0.01613533f, -0.01673458f, 0.08938634f, 0.00723825f, 0.19401294f, -0.12221154f, 
    0.34965912f, 0.16772750f, 0.12691610f, 0.17081276f, -0.08363826f, 0.04238941f, -0.00625917f, 0.09908002f, 
    0.04455509f, 0.05551057f, 0.04919627f, 0.11373551f, 0.08070447f, 0.10830940f, 0.05609878f, 0.03969618f, 
    -0.05450424f, 0.10455403f, 0.06549941f, -0.03150454f, 0.12080664f, 0.06401388f, 0.00157094f, -0.01673020f, 
    -0.18937615f, -0.05502192f, 0.01614350f, -0.20533642f, 0.13766049f, 0.15969047f, -0.02041308f, 0.08448636f, 
    0.04227968f, -0.04992685f, -0.01720951f, 0.04673528f, 0.12891375f, -0.26662543f, -0.02595157f, 0.08096810f, 
    -0.03274921f, 0.09261355f, 0.09385668f, -0.04989502f, 0.00131557f, 0.01814775f, -0.02344917f, -0.09016677f, 
    -0.03932917f, 0.00292478f, 0.02944358f, 0.00759752f, -0.00042949f, -0.04129048f, 0.01259732f, 0.00691137f, 
    -0.03912257f, -0.00887636f, -0.00119636f, 0.02242525f, 0.00789960f, 0.04382623f, -0.05140045f, -0.05050768f, 
    -0.02784106f, 0.03518630f, -0.03159915f, -0.01225648f, 0.02751975f, -0.04513570f, -0.01016332f, 0.01731165f, 
    0.01911528f, -0.02164725f, -0.05518890f, 0.03641366f, 0.02553245f, 0.02034084f, -0.03904107f, -0.03479177f, 
    0.02907750f, -0.05665900f, 0.02823575f, -0.05951460f, 0.02810258f, 0.01056006f, -0.03761350f, -0.02115466f, 
    0.01693038f, 0.01732701f, 0.02636491f, -0.02360871f, 0.04162505f, -0.00755955f, 0.01306952f, 0.03414336f, 
    -0.05359458f, -0.04047052f, 0.01579657f, 0.03613368f, 0.02592419f, -0.00904623f, 0.03075601f, -0.04127909f, 
    0.02830976f, -0.01811253f, -0.04841402f, -0.01562052f, -0.00807860f, 0.04017324f, 0.00056948f, -0.04118707f, 
    0.00240507f, 0.02607672f, -0.03315337f, 0.01875070f, -0.04220370f, -0.00531124f, -0.04790060f, -0.05444004f, 
    0.00041362f, 0.03255942f, 0.02200299f, 0.01817158f, 0.03724370f, -0.04765026f, -0.01942426f, -0.00119222f, 
    0.01709503f, 0.02674919f, -0.05140035f, 0.01109881f, 0.00594727f, -0.02314772f, -0.03882354f, -0.02410639f, 
    -0.04417318f, -0.02820904f, 0.01376009f, 0.02808559f, 0.02216966f, 0.02437057f, 0.01789403f, 0.00930366f, 
    -0.02492148f, 0.02719609f, 0.03300793f, -0.04563528f, -0.04121823f, 0.01290137f, 0.02024467f, 0.03484222f, 
    0.00452513f, -0.02929680f, -0.03168798f, -0.01493290f, -0.02418127f, 0.02336586f, -0.04488750f, 0.03717225f, 
    -0.02367731f, -0.04378015f, -0.01642746f, -0.01262242f, 0.01836442f, 0.02583923f, 0.02915145f, 0.01979810f, 
    -0.00850854f, -0.05555683f, -0.01402536f, 0.00130548f, 0.01492684f, -0.01011316f, -0.03601724f, -0.05500307f, 
    -0.01906530f, -0.04218670f, 0.00877577f, 0.02972242f, 0.00618664f, -0.04806161f, -0.01027416f, -0.05477347f, 
    0.00530043f, -0.01434610f, -0.00302724f, 0.02315374f, 0.04458403f, 0.02078350f, 0.04152890f, 0.02396278f, 
    0.02917895f, 0.00758893f, -0.04786868f, 0.01628537f, -0.01949203f, -0.01669483f, -0.02498262f, 0.03496373f, 
    -0.02451323f, -0.05999039f, -0.04090341f, 0.00892035f, 0.02356260f, -0.04542227f, 0.04213461f, 0.02005923f, 
    -0.00040734f, -0.05612022f, -0.00613010f, -0.00495576f, -0.02912109f, -0.05290918f, 0.02839178f, 0.02431247f, 
    -0.00384088f, 0.00020131f, 0.01540149f, -0.01619316f, 0.04426099f, -0.04234608f, -0.02833030f, 0.04029276f, 
    -0.01009557f, -0.00303330f, 0.03066489f, -0.01322086f, 0.01517256f, -0.03687390f, 0.03733783f, 0.02809370f, 
    -0.03107493f, 0.03715779f, -0.02156273f, 0.03780321f, -0.00279786f, 0.00752868f, -0.00409471f, -0.02532078f, 
    -0.03039099f, -0.03732437f, -0.00889183f, -0.05922792f, -0.01450035f, 0.02350660f, 0.01073880f, -0.04107657f, 
    -0.05616783f, -0.05731234f, -0.05228830f, 0.03586743f, -0.05598367f, 0.02665635f, -0.05565403f, 0.02567864f, 
    0.00553709f, -0.05251854f, -0.00601905f, -0.04914892f, -0.04016407f, -0.03380569f, -0.01710179f, 0.01968735f, 
    -0.02529726f, 0.03608498f, 0.00116859f, -0.00375576f, -0.01036436f, 0.03845332f, 0.01488215f, -0.04201136f, 
    0.03333445f, -0.02280315f, -0.03985271f, 0.03186464f, 0.02332547f, -0.04883164f, 0.03492188f, -0.02625494f, 
    -0.03179681f, -0.02983640f, -0.02133246f, 0.03601372f, -0.03665838f, -0.02426285f, 0.03168475f, -0.00499790f, 
    -0.01542272f, 0.02415907f, -0.04768026f, -0.01265769f, -0.04498355f, -0.04434418f, -0.01121018f, 0.03508582f, 
    -0.01648863f, -0.04846720f, 0.00604101f, -0.03881486f, 0.02174493f, -0.01987853f, 0.04083151f, -0.04225356f, 
    -0.03106206f, 0.02832319f, -0.02258301f, -0.05131932f, -0.02124932f, -0.00848604f, 0.00388100f, -0.05319462f, 
    -0.01868267f, 0.00204925f, 0.03594584f, -0.02192477f, 0.01803617f, -0.01782081f, 0.02619103f, -0.03962333f, 
    0.01251451f, -0.03619914f, -0.04301450f, 0.00858125f, -0.03326049f, -0.05043609f, -0.00823596f, 0.01257806f, 
    -0.05944041f, 0.02103751f, 0.03643259f, 0.00445248f, 0.03183023f, -0.01988891f, 0.02739900f, -0.00825531f, 
    0.03768472f, 0.00657567f, 0.02275296f, 0.01311391f, -0.03228198f, -0.05756896f, 0.01139792f, -0.04172833f, 
    0.00311534f, -0.05219898f, -0.01262048f, 0.00064100f, -0.00565992f, 0.03169555f, 0.03915769f, -0.01578663f, 
    -0.01384377f, -0.04533494f, 0.03473972f, 0.01687613f, -0.04536394f, -0.01511947f, 0.03465139f, 0.00028755f, 
    0.00132363f, -0.04611096f, -0.05461470f, 0.02967782f, 0.04587867f, 0.00418017f, 0.02580523f, 0.00647424f, 
    -0.04635804f, 0.02100304f, 0.02258372f, -0.05684263f, -0.01093595f, -0.05409171f, 0.03117208f, 0.01397515f, 
    -0.01759665f, 0.02175101f, -0.04623283f, -0.05580780f, -0.02567188f, -0.03451673f, 0.04150458f, 0.00875701f, 
    -0.04415635f, 0.01069567f, 0.00785120f, 0.02816501f, -0.02443329f, 0.03717958f, -0.05739937f, -0.03829455f, 
    -0.02502834f, 0.02040141f, 0.03295270f, 0.01799509f, 0.01189503f, 0.04318928f, -0.03625647f, -0.05795865f, 
    -0.04811120f, 0.01257792f, -0.02911958f, -0.02271714f, 0.01108905f, 0.02388947f, -0.02907717f, -0.05224904f, 
    0.00617361f, 0.01189632f, 0.04034651f, -0.01465253f, 0.03630206f, 0.03036545f, 0.01576219f, -0.00450166f, 
    -0.03020930f, 0.00479930f, -0.01734632f, 0.03254554f, -0.00615112f, -0.01146719f, -0.03151995f, 0.00409196f, 
    0.03203258f, 0.01657354f, -0.05574001f, -0.05213840f, -0.02644448f, -0.01502583f, -0.04005469f, 0.03018089f, 
    0.00087518f, 0.14145432f, -0.19039215f, -0.10531104f, 0.00775211f, 0.03728007f, -0.10503097f, 0.04870311f, 
    -0.06944963f, 0.05136390f, 0.10873414f, -0.06829643f, -0.16268864f, 0.26372537f, 0.09095986f, -0.08572005f, 
    0.10057455f, -0.06311393f, 0.02064876f, 0.01791836f, 0.08704849f, 0.10450251f, -0.07844747f, 0.02102307f, 
    0.08061191f, -0.09698830f, 0.02062384f, -0.07691468f, 0.18443671f, 0.08694617f, 0.07414059f, 0.12341060f, 
    0.02780304f, -0.03584408f, 0.07529532f, 0.09913956f, 0.16815192f, -0.10638155f, 0.03378872f, -0.00018867f, 
    -0.08532776f, 0.01455464f, -0.08111779f, -0.01462122f, 0.02068818f, 0.11532182f, -0.02347512f, 0.04112023f, 
    0.01368208f, -0.01994316f, -0.12655912f, -0.19935183f, 0.10105721f, 0.08730150f, -0.07730182f, 0.09826872f, 
    0.00121608f, 0.11115444f, 0.01060883f, -0.09855782f, 0.14715031f, -0.00643315f, -0.15094902f, 0.07009061f, 
    -0.06142393f, -0.03747397f, -0.04206542f, -0.07821020f, 0.04905005f, 0.04887002f, -0.03835294f, -0.04707899f, 
    -0.33355737f, -0.05481126f, 0.14105579f, 0.01653394f, 0.00266142f, -0.06689294f, -0.06131614f, 0.03111318f, 
    0.09099653f, 0.01733081f, -0.06282189f, -0.01234692f, -0.04944398f, 0.20544149f, 0.06042771f, 0.10276710f, 
    0.06988108f, -0.03733615f, 0.11172242f, -0.03970006f, 0.06269514f, 0.02848265f, 0.02327104f, 0.08441789f, 
    0.10263119f, -0.13236921f, 0.00681120f, -0.03552994f, -0.06064051f, 0.11696994f, -0.01444296f, -0.05114747f, 
    0.01100495f, 0.05568592f, 0.06733381f, -0.11814833f, 0.16056304f, 0.00701644f, -0.09653312f, -0.08499520f, 
    -0.02942777f, -0.05629096f, 0.00128892f, -0.03686526f, 0.02043641f, -0.02779435f, -0.07980711f, 0.01309439f, 
    -0.15331033f, 0.15175605f, -0.06998490f, 0.01607345f, 0.01397533f, 0.02952611f, -0.00829617f, -0.05120666f, 
    0.13504118f, 0.03024353f, -0.11161466f, -0.08378973f, 0.06307601f, -0.10328496f, 0.07275546f, 0.03736966f, 
    0.04637460f, -0.10411253f, 0.14620920f, 0.12155750f, 0.14324112f, -0.04670098f, -0.04615705f, 0.18577728f, 
    -0.14311817f, 0.03871765f, -0.02404731f, 0.23975535f, -0.07945407f, -0.01126740f, 0.11147273f, 0.03429352f, 
    -0.04058341f, 0.00170429f, -0.06412982f, -0.10906259f, 0.27153254f, 0.03416926f, 0.13494124f, -0.40314960f, 
    -0.01865152f, -0.01187637f, 0.10256860f, -0.01389441f, -0.09720405f, 0.01692983f, 0.08041163f, -0.03263412f, 
    0.33947173f, -0.13096093f, -0.12725766f, 0.05545825f, -0.07513598f, -0.00487015f, -0.01680230f, -0.08026181f, 
    0.04609059f, -0.01954738f, 0.09432223f, 0.02081980f, -0.12667492f, 0.19228400f, -0.02147349f, 0.02608353f, 
    -0.00997369f, 0.02678097f, -0.01039976f, 0.11033706f, -0.00113696f, -0.07532031f, 0.00604371f, 0.00292872f, 
    0.19457048f, -0.01423723f, 0.00149871f, -0.02912089f, 0.07772016f, 0.11020986f, 0.00949369f, 0.04174963f, 
    -0.05457101f, 0.01608532f, 0.03400965f, -0.03430044f, 0.03169746f, -0.05582030f, -0.15469581f, -0.09513362f, 
    0.13645883f, 0.07524344f, 0.08078733f, -0.08068255f, 0.04104971f, 0.04327670f, 0.00234117f, -0.01588647f, 
    0.08174286f, -0.00535093f, -0.06268344f, 0.11546580f, -0.07985552f, 0.00506220f, 0.04579407f, 0.03032598f, 
    -0.03391855f, -0.08276192f, -0.00982439f, -0.17134896f, -0.12925290f, 0.08887732f, -0.26655766f, -0.04721685f, 
    -0.10346133f, -0.01742776f, 0.07270642f, 0.01019596f, 0.03466039f, 0.02588063f, 0.13469034f, -0.01321204f, 
    0.21885569f, 0.34464031f, 0.08664320f, -0.08577084f, -0.01797363f, 0.07663678f, 0.04422705f, 0.07092275f, 
    0.03625898f, 0.07645129f, -0.04235888f, 0.12936769f, 0.16204639f, 0.12923622f, -0.20081516f, -0.04559456f, 
    -0.10447585f, -0.05338707f, -0.01011321f, 0.07261223f, 0.06004414f, -0.00954370f, 0.05311132f, -0.00239996f, 
    0.20118515f, 0.06214286f, -0.00493904f, 0.05657152f, 0.14040343f, -0.04202289f, 0.05647955f, 0.04877892f, 
    0.04739114f, -0.00300270f, -0.12736449f, 0.18642873f, -0.14167899f, -0.02457406f, -0.05161158f, -0.20627543f, 
    0.07357065f, -0.08907831f, 0.03420922f, 0.09811717f, -0.02445759f, -0.12856466f, 0.03003720f, 0.05543668f, 
    -0.09257088f, -0.17526658f, -0.04657365f, 0.01697674f, -0.05848299f, 0.00471136f, 0.00832314f, -0.16707507f, 
    0.06323273f, -0.01229013f, -0.02831405f, -0.07354565f, 0.28935111f, 0.10006461f, -0.22649480f, -0.09357598f, 
    -0.02403001f, -0.06116856f, 0.11042206f, 0.04586581f, -0.04224441f, -0.05574485f, 0.10277317f, 0.00305982f, 
    -0.17062268f, 0.03265364f, -0.06578425f, 0.16396496f, -0.05510631f, 0.06651191f, -0.09755097f, -0.02118464f, 
    0.03674166f, 0.04299929f, 0.11798722f, 0.03841744f, -0.20593923f, 0.20550442f, 0.12655956f, 0.07010296f, 
    0.02622071f, 0.06166063f, 0.06815697f, 0.10830823f, -0.03325501f, -0.03784186f, -0.05865638f, 0.07648370f, 
    0.09336601f, -0.04618306f, 0.03193603f, -0.14105317f, 0.13108709f, 0.10036106f, -0.07893462f, 0.18198363f, 
    0.02565039f, 0.05951465f, -0.09752528f, 0.10541877f, -0.32832024f, 0.01085259f, -0.10126611f, -0.08819801f, 
    0.00937748f, -0.00612149f, -0.08010669f, 0.02712069f, -0.01032508f, 0.12221171f, 0.10294079f, -0.03041751f, 
    0.24088137f, -0.16314536f, -0.10203450f, -0.05238125f, 0.00491859f, 0.02121045f, -0.06868138f, 0.19463947f, 
    0.01574698f, -0.06641208f, 0.05904851f, 0.10069186f, -0.32338241f, -0.24796574f, -0.06812249f, 0.09975307f, 
    0.04046985f, 0.08377672f, -0.06671289f, 0.00410652f, -0.03708150f, 0.17566659f, 0.00694752f, -0.02763746f, 
    -0.03282595f, -0.01151199f, -0.03400600f, -0.02274034f, 0.09635184f, 0.18338238f, 0.02589501f, 0.03095197f, 
    -0.01073538f, -0.04289418f, -0.03384135f, -0.02112558f, -0.15139861f, 0.05441451f, -0.14538054f, 0.12133477f, 
    0.14595361f, -0.07901683f, -0.11526299f, -0.09299504f, 0.09655485f, 0.08547793f, 0.00636678f, 0.11489055f, 
    0.30629736f, 0.12486065f, -0.25784218f, -0.31981763f, 0.08601129f, -0.01435812f, -0.06378373f, -0.05687162f, 
    0.04011753f, -0.02575581f, -0.02030858f, -0.09312390f, 0.41592649f, -0.25545391f, 0.03112096f, 0.31061193f, 
    0.05197892f, 0.06051275f, -0.12045365f, -0.01905081f, 0.08907618f, 0.04200946f, -0.12559117f, 0.00179706f, 
    0.17087629f, -0.21417886f, -0.04136150f, 0.01595690f, -0.03575202f, -0.00368400f, -0.02706873f, -0.08156510f, 
    0.02992474f, 0.00424111f, 0.16104749f, -0.07693413f, 0.29564255f, 0.10326554f, -0.03580886f, -0.11686084f, 
    -0.07731102f, 0.01563070f, 0.14743401f, 0.01918906f, -0.10155351f, 0.02245753f, -0.01802969f, 0.00541147f, 
    -0.06256731f, 0.08363551f, 0.06888698f, 0.16515388f, -0.07242435f, -0.14862891f, -0.05258031f, -0.01026024f, 
    -0.04991996f, 0.08110411f, -0.11396726f, 0.11117863f, -0.06835180f, 0.13903876f, -0.15524790f, -0.06098202f, 
    0.08210186f, 0.05581312f, 0.00597590f, 0.04208200f, -0.03453745f, 0.10891128f, -0.00965103f, 0.10266460f, 
    0.01636592f, 0.15235487f, 0.12113956f, -0.41565254f, 0.07881115f, 0.02753102f, 0.01435739f, -0.00257403f, 
    0.04118710f, -0.02820118f, 0.14305581f, -0.05222655f, 0.19104108f, 0.19136278f, 0.33243337f, -0.06154588f, 
    -0.13230768f, -0.06309913f, 0.12580250f, 0.14896551f, 0.03269750f, -0.00845586f, 0.04445728f, 0.03786406f, 
    0.13859494f, 0.16069999f, 0.17814511f, -0.08851923f, 0.15513258f, 0.00912679f, -0.06464811f, 0.02580361f, 
    0.03973251f, 0.06382555f, -0.08641206f, 0.00474688f, 0.04576010f, 0.05755302f, 0.09189679f, 0.06492513f, 
    0.02588881f, -0.03617984f, 0.09785527f, 0.05663852f, 0.07476399f, 0.09232920f, -0.02532401f, 0.07258050f, 
    -0.16691858f, -0.11860114f, -0.17204431f, 0.00441031f, 0.13518806f, -0.01845844f, -0.03450243f, -0.06831716f, 
    -0.00805495f, -0.11227085f, 0.10901811f, 0.06232695f, -0.00961226f, -0.06436530f, -0.10815367f, 0.04374482f, 
    0.11536581f, -0.08674970f, -0.08443464f, -0.07133777f, 0.02910931f, 0.05644840f, 0.07914542f, -0.18551970f, 
    0.88726884f, -0.12785108f, 0.27165094f, 0.16376045f, -0.10229292f, 0.03222738f, 0.02799744f, -0.14441812f, 
    0.06750962f, 0.09774803f, 0.13223262f, 0.08875289f, -0.02134898f, 0.07210590f, 0.01726745f, -0.00099193f, 
    0.12315958f, -0.00229856f, 0.05440145f, -0.08638962f, 0.02123073f, -0.02615122f, 0.06177359f, -0.03357163f, 
    0.00068230f, -0.03543122f, -0.04818363f, -0.16539864f, 0.05251189f, 0.27290642f, 0.05730316f, 0.00819909f, 
    -0.01219483f, 0.06773125f, 0.03661940f, -0.04361946f, 0.07574336f, -0.04789703f, -0.02799606f, -0.32748568f, 
    0.18114521f, 0.08149525f, 0.05333482f, 0.01563975f, 0.09600529f, 0.07744727f, 0.08096354f, -0.10625641f, 
    0.58811158f, -0.20206226f, 0.07954681f, -0.01741154f, -0.08696961f, -0.02137198f, 0.11026835f, -0.09456021f, 
    0.04563798f, 0.05315914f, 0.04826380f, 0.00062780f, 0.19468825f, -0.14323126f, 0.07301819f, -0.05979836f, 
    -0.03700946f, 0.07779100f, -0.10272820f, 0.03448887f, -0.08535579f, -0.10782174f, 0.05160401f, 0.06190285f, 
    -0.05026964f, -0.04655688f, -0.06194409f, -0.07922153f, 0.08164687f, 0.06554572f, 0.02638306f, 0.01667669f, 
    0.10226311f, 0.08345501f, -0.09080793f, 0.08227353f, 0.52721059f, 0.00078099f, 0.26572108f, 0.14097045f, 
    0.05975175f, -0.01826656f, 0.10274998f, -0.02099500f, 0.07986230f, -0.06884269f, -0.09609974f, 0.09572730f, 
    0.18595509f, -0.18011361f, -0.17057244f, -0.04001277f, 0.17150520f, 0.05098977f, -0.07991329f, -0.02545388f, 
    0.06430474f, -0.06142289f, -0.00256398f, 0.03572270f, -0.09227867f, 0.05799141f, 0.02865777f, -0.18173243f, 
    -0.06493990f, -0.05761447f, -0.06250174f, 0.10816539f, 0.01613187f, -0.07290450f, -0.00452912f, 0.05966826f, 
    -0.10214515f, 0.18382354f, -0.02872004f, 0.10303091f, -0.00199692f, 0.08340570f, 0.05029574f, 0.01188772f, 
    0.00724333f, -0.06628411f, -0.01518739f, -0.04651147f, 0.09483809f, 0.01064940f, 0.12191823f, -0.05117715f, 
    -0.06745618f, -0.04435622f, 0.05951225f, -0.04669252f, -0.08883756f, -0.08959883f, -0.08200402f, -0.05005104f, 
    0.09785493f, -0.05862780f, -0.04116940f, -0.07711539f, 0.00629431f, -0.08436582f, 0.02301092f, 0.05528796f, 
    -0.04425174f, 0.00741519f, 0.17996672f, -0.08078001f, -0.42062441f, -0.05582407f, 0.05697866f, -0.16787371f, 
    0.10260424f, 0.04077794f, -0.13436849f, 0.08939020f, 0.04057680f, 0.04592477f, -0.04991260f, -0.03872733f, 
    0.24830687f, 0.01609466f, -0.06958753f, 0.19891074f, 0.26919886f, 0.02288419f, 0.04398487f, 0.10061077f, 
    -0.03630368f, 0.02423274f, -0.14352377f, 0.03798904f, 0.40526056f, -0.05401611f, 0.05337288f, 0.09242047f, 
    0.15443458f, 0.04053865f, -0.09861287f, -0.03369511f, -0.07346030f, 0.02272784f, 0.05995536f, 0.12556730f, 
    0.39828399f, -0.19663967f, 0.09993713f, 0.17456791f, 0.01684442f, -0.05381522f, -0.06365824f, 0.20843947f, 
    0.03310123f, 0.06728030f, -0.00169421f, 0.13821286f, -0.19577569f, 0.20248826f, -0.10314473f, 0.11036982f, 
    0.07996826f, 0.07146135f, 0.02381695f, 0.19295382f, -0.07734267f, 0.04906416f, 0.02890177f, 0.00476166f, 
    -0.24170381f, 0.17900230f, -0.12176473f, -0.10152780f, 0.03603176f, 0.08575601f, -0.08331230f, 0.02797413f, 
    -0.20473392f, 0.00951112f, 0.02790054f, 0.00969600f, -0.13174360f, 0.35601056f, 0.13325967f, -0.05438206f, 
    -0.00822384f, -0.07274691f, 0.01988637f, 0.08082596f, 0.12156003f, 0.02630695f, -0.07426853f, -0.03750516f, 
    0.23097676f, -0.08512236f, -0.05183858f, 0.12730137f, 0.17860815f, -0.03091934f, 0.08438967f, 0.05168715f, 
    0.03059359f, 0.07853047f, 0.18320079f, 0.04818170f, 0.18147966f, -0.11604787f, 0.00945546f, -0.14104067f, 
    -0.08583567f, -0.06617081f, 0.07684029f, -0.02659702f, -0.02698522f, 0.10337362f, 0.01936875f, -0.04642638f, 
    -0.12361152f, -0.02489324f, -0.14542116f, -0.08885760f, 0.02026303f, 0.11276919f, -0.06302012f, 0.16700543f, 
    -0.06507461f, 0.03498739f, -0.01983892f, -0.07298100f, 0.17747101f, -0.13614048f, -0.22813419f, 0.04518754f, 
    -0.11395800f, -0.06707732f, 0.01525311f, -0.10967840f, -0.02664641f, 0.01533785f, 0.02654552f, -0.02981120f, 
    -0.29217061f, -0.14506967f, 0.17725709f, 0.08368530f, 0.02688905f, -0.05643916f, -0.05017173f, -0.07703242f, 
    0.06986447f, 0.07779240f, 0.00102667f, 0.00988504f, -0.09200460f, 0.09917326f, -0.11285821f, 0.12596002f, 
    0.11727867f, 0.00099034f, -0.05464503f, 0.11542147f, 0.15102993f, -0.01532669f, 0.04663238f, 0.04498094f, 
    0.12082750f, -0.06901950f, -0.17233089f, 0.05594759f, 0.01404102f, 0.15693647f, -0.02063696f, 0.04003266f, 
    0.02091077f, 0.02822615f, -0.00652403f, -0.12083775f, 0.18853648f, 0.07012919f, -0.10122211f, -0.11812487f, 
    -0.00064881f, -0.01187163f, 0.02920471f, -0.11176561f, 0.04322051f, -0.02603889f, -0.06420254f, 0.05854199f, 
    -0.04824377f, 0.06425241f, -0.08404829f, 0.02331107f, -0.00328320f, 0.05607329f, 0.01698693f, -0.00072589f, 
    0.20555039f, -0.02738242f, -0.06153968f, 0.00276466f, 0.10651041f, -0.26901934f, -0.00959124f, -0.03784509f, 
    0.02128222f, -0.07851254f, 0.04762203f, -0.04468162f, 0.05585280f, -0.16389427f, -0.05377997f, 0.21787673f, 
    0.01407937f, -0.02554235f, -0.08206626f, 0.13408428f, -0.00540197f, 0.03192180f, 0.19212106f, 0.11102397f, 
    0.00045849f, 0.09845877f, -0.14272341f, -0.14772196f, 0.36041203f, -0.05744312f, 0.12888008f, -0.33286372f, 
    -0.06998877f, -0.06603926f, 0.13219318f, -0.04773080f, 0.05418601f, 0.04857999f, 0.21564944f, 0.00878012f, 
    0.19095816f, -0.11092041f, 0.03062085f, -0.03118439f, -0.01078265f, 0.09001318f, 0.01599134f, -0.01345186f, 
    0.13058998f, 0.00689960f, -0.01834126f, -0.03743474f, -0.21513620f, 0.06602775f, 0.01237486f, 0.10373387f, 
    -0.00641367f, -0.00289818f, 0.09965838f, 0.11522634f, 0.07110186f, -0.04646313f, 0.08702414f, 0.07964846f, 
    0.14449266f, 0.02927002f, 0.05622695f, 0.04638762f, 0.17355138f, 0.07952042f, 0.04054779f, 0.04128325f, 
    -0.08605728f, 0.04088419f, 0.06026465f, -0.01088853f, 0.01952922f, 0.03980818f, 0.02519711f, 0.06518184f, 
    0.10445542f, -0.05148027f, 0.11968637f, -0.01694361f, 0.01812875f, 0.08797864f, -0.07652609f, -0.02448836f, 
    -0.07436572f, 0.01671927f, 0.01203335f, 0.16189498f, 0.01167548f, 0.05704911f, 0.13875745f, 0.01665475f, 
    -0.08260724f, -0.02364238f, -0.04529341f, -0.10374247f, -0.36485967f, 0.27473581f, -0.33353773f, 0.01164600f, 
    -0.02607446f, 0.04681944f, -0.04762378f, 0.00225588f, 0.04259620f, 0.03366980f, 0.13443033f, -0.06026325f, 
    0.31328186f, 0.27145687f, 0.01462049f, 0.07324786f, 0.05706989f, -0.08814172f, 0.07063539f, 0.10446425f, 
    0.06916529f, 0.11092160f, -0.05483949f, 0.15050638f, -0.05011253f, 0.10646129f, -0.12934232f, -0.16280760f, 
    -0.08555459f, -0.04104364f, 0.05384002f, 0.06866065f, 0.13073675f, -0.11774182f, 0.02048834f, -0.05885702f, 
    0.06006405f, 0.07452076f, -0.00647666f, 0.07598141f, 0.04595075f, 0.02803154f, 0.11665194f, -0.02750599f, 
    0.10645214f, -0.02498920f, -0.18960002f, 0.22206396f, -0.00561473f, 0.00394362f, 0.04892343f, -0.23470448f, 
    0.04938797f, -0.06763954f, 0.14092700f, -0.10575148f, -0.03171195f, -0.06246653f, 0.02584260f, 0.00834761f, 
    -0.09392856f, -0.05986825f, -0.18961772f, 0.09284725f, -0.10986041f, 0.03476586f, -0.00434163f, -0.14387119f, 
    0.01194770f, 0.02916957f, -0.03068206f, -0.11165494f, 0.18197361f, 0.28868517f, -0.23181923f, -0.16710286f, 
    -0.00954481f, -0.09318990f, 0.04707879f, 0.00087838f, -0.02104396f, -0.04610481f, 0.09059994f, 0.12117175f, 
    -0.17903152f, 0.03884422f, -0.14013435f, 0.22145852f, -0.04941236f, 0.05160096f, -0.06845806f, -0.05507027f, 
    0.02829802f, 0.14845976f, 0.05972720f, 0.00515195f, -0.11061485f, 0.23932773f, 0.07275960f, 0.04723432f, 
    -0.01468472f, 0.01434756f, 0.09413967f, 0.10298420f, 0.06605621f, -0.03278327f, -0.09592118f, 0.02403049f, 
    0.16604348f, -0.05319209f, 0.13711311f, -0.06955529f, -0.06070466f, 0.14968304f, -0.11763756f, 0.16604000f, 
    -0.02339951f, 0.03847035f, -0.06962959f, 0.05426839f, -0.53027171f, 0.16646443f, -0.04943267f, 0.01277064f, 
    0.08388357f, 0.04632199f, 0.02481193f, 0.03090947f, -0.05059411f, 0.16899283f, -0.03266467f, -0.00473253f, 
    0.06526075f, -0.15156642f, -0.05762951f, -0.01826711f, 0.08331175f, -0.02527341f, 0.04332387f, 0.06010588f, 
    -0.00538662f, -0.06254762f, 0.08286233f, 0.02128853f, -0.11985735f, -0.10667267f, -0.28480586f, 0.18313666f, 
    0.00801659f, 0.01224587f, -0.04834151f, -0.02898858f, -0.01835961f, 0.18866777f, 0.01199094f, -0.10485213f, 
    0.02407233f, -0.05049498f, -0.01785881f, -0.03458552f, -0.02548560f, -0.00319258f, 0.04097869f, -0.00768342f, 
    -0.03085295f, 0.02667792f, -0.00901996f, -0.02919918f, -0.03354852f, 0.00398975f, 0.02652276f, 0.00045488f, 
    -0.01426119f, 0.00282226f, 0.00717807f, 0.01597761f, 0.03308314f, -0.04960942f, 0.01175659f, -0.00993315f, 
    -0.01791833f, -0.02704908f, -0.06045257f, -0.05148469f, -0.00351549f, -0.02621506f, -0.00379954f, -0.03135367f, 
    -0.05092784f, -0.03087649f, -0.00477892f, 0.00931377f, -0.03646654f, -0.04263460f, -0.00555406f, -0.01908310f, 
    -0.00750720f, -0.01954194f, 0.02921268f, -0.03662185f, -0.01727607f, 0.03344891f, -0.03419959f, -0.04701929f, 
    -0.04980367f, -0.05058167f, -0.00632580f, -0.00790234f, -0.02401853f, -0.04132622f, -0.00986461f, 0.03170997f, 
    -0.03086314f, -0.04853441f, -0.05388943f, -0.04739818f, -0.01126101f, -0.03675855f, -0.02147859f, 0.03457015f, 
    -0.04133849f, -0.02379096f, -0.04460435f, -0.04518585f, 0.03665007f, -0.00876758f, 0.00859750f, 0.02129795f, 
    -0.00684154f, -0.04003683f, 0.00390693f, -0.00937820f, 0.00129929f, 0.01414647f, 0.02628562f, 0.03909409f, 
    -0.04682544f, -0.04342575f, -0.02445001f, -0.00784406f, -0.03032308f, -0.02400595f, 0.02091592f, -0.04994296f, 
    -0.01982353f, -0.04749624f, -0.04937755f, 0.03938209f, -0.00177612f, 0.03604919f, 0.01701336f, -0.02132752f, 
    -0.05229286f, 0.00979573f, -0.02980031f, -0.01563872f, 0.02441982f, 0.03021414f, 0.03493497f, 0.03867559f, 
    0.01583482f, 0.03950476f, -0.05580932f, -0.01736276f, 0.03687416f, -0.05836873f, -0.03760458f, 0.01188692f, 
    -0.00282524f, 0.02028547f, -0.05495819f, 0.02582368f, 0.03908570f, -0.04830529f, -0.03124444f, 0.01749088f, 
    -0.01014771f, 0.01332237f, -0.04337759f, 0.02400635f, -0.01091501f, 0.03048318f, 0.02008797f, -0.01028447f, 
    -0.02798322f, -0.02824345f, -0.04842046f, -0.02792942f, 0.01867092f, 0.00822778f, -0.03511300f, -0.03250668f, 
    -0.01193117f, -0.03992768f, 0.01733714f, 0.02443234f, 0.03662885f, -0.00075530f, -0.00994214f, -0.03718582f, 
    -0.04305027f, -0.00581910f, -0.02375957f, -0.05329930f, -0.00164926f, -0.03686576f, 0.01870572f, -0.02254761f, 
    -0.04195648f, -0.05212520f, -0.02564484f, -0.04650611f, 0.03250318f, 0.02494950f, -0.04027633f, 0.01730759f, 
    -0.04649293f, -0.00288382f, 0.01951824f, 0.02730027f, -0.02899555f, 0.02991906f, 0.02357345f, 0.01402214f, 
    0.03059804f, 0.02453921f, -0.01256342f, -0.03560307f, 0.01265016f, 0.02801466f, 0.03686934f, -0.00540827f, 
    -0.05462157f, -0.04427412f, 0.01498994f, 0.02780552f, -0.04558899f, 0.00387292f, 0.02684215f, -0.03549211f, 
    0.00300412f, 0.02879417f, 0.00691912f, -0.03393745f, -0.03049787f, -0.04271916f, 0.03518117f, -0.05339902f, 
    -0.00696997f, -0.01828953f, 0.03435118f, -0.01112585f, 0.02508168f, -0.02611623f, -0.02503815f, 0.03087947f, 
    0.01576941f, 0.04155241f, 0.02630300f, -0.03922323f, -0.02770914f, -0.03373236f, -0.00296730f, -0.00843827f, 
    -0.02029054f, -0.02808228f, -0.00477858f, -0.03972765f, -0.00986441f, -0.06017060f, -0.02969127f, 0.01380338f, 
    -0.01351751f, -0.01937139f, -0.01522585f, -0.00682859f, -0.03758080f, 0.00992777f, -0.04865449f, 0.01628276f, 
    0.01102299f, 0.02824541f, 0.00570064f, -0.00221712f, 0.02029771f, -0.04741803f, -0.05803369f, 0.00854827f, 
    -0.00940340f, -0.05868971f, -0.04403376f, 0.00536796f, -0.01279813f, -0.05253944f, -0.01963449f, -0.01727557f, 
    -0.01904815f, 0.00072083f, -0.01846098f, 0.04314348f, 0.03267628f, 0.04107139f, -0.03540172f, -0.02046271f, 
    -0.01538791f, -0.03100412f, 0.02130125f, -0.03033327f, -0.04909512f, 0.03626676f, 0.00893379f, 0.02248317f, 
    0.01894893f, 0.02282865f, 0.01321011f, -0.02527898f, -0.02619741f, 0.02982589f, -0.00016142f, -0.02416261f, 
    0.01240909f, 0.01116633f, -0.05716198f, 0.02654706f, -0.05205687f, 0.03416762f, -0.03961227f, -0.01585521f, 
    0.02265453f, -0.04738697f, -0.00393882f, 0.00184150f, -0.01820920f, 0.02488670f, 0.01453134f, 0.00842322f, 
    -0.05253916f, -0.05117885f, 0.00976911f, -0.03092922f, -0.02403242f, -0.03541311f, 0.02423741f, -0.01660693f, 
    0.01564942f, 0.02616842f, -0.00089452f, -0.03256083f, 0.01523621f, -0.04274311f, 0.03012282f, -0.05711369f, 
    0.00498003f, -0.00615146f, 0.02783480f, -0.05248604f, 0.01830590f, 0.00567163f, -0.02167083f, 0.03917573f, 
    0.01943096f, -0.05646009f, -0.04892096f, 0.00480448f, 0.00786268f, 0.02012575f, 0.01940759f, 0.02201249f, 
    -0.04892508f, -0.04115620f, 0.01588045f, 0.00338259f, -0.00659781f, 0.01562309f, 0.01607668f, -0.03788709f, 
    0.02107016f, -0.01428462f, 0.02436870f, 0.01158904f, -0.01346761f, -0.02601317f, 0.02115984f, -0.02816554f, 
    -0.05090318f, -0.05567007f, 0.04079419f, -0.01874603f, -0.05416898f, -0.01841152f, 0.00845742f, -0.02900382f, 
    -0.05156692f, -0.01954233f, 0.03074252f, -0.01314051f, -0.04407268f, 0.03832640f, 0.03867794f, 0.02607914f, 
    0.04247402f, 0.02430871f, -0.00321409f, -0.00917420f, -0.00367081f, -0.00672719f, 0.01212581f, 0.00152386f, 
    0.00269817f, -0.01353132f, -0.03011501f, 0.01115628f, -0.00934603f, 0.00637484f, 0.00292045f, 0.00878071f, 
    0.04091029f, 0.02904727f, -0.00926282f, 0.03980841f, 0.04091820f, 0.00854312f, 0.02086322f, 0.02886601f, 
    -0.04617036f, -0.04928977f, 0.00265867f, -0.00498611f, 0.02218261f, -0.04992915f, 0.03090271f, -0.04770698f, 
    0.01212144f, 0.03382077f, 0.01529317f, 0.03129753f, -0.02758681f, -0.04693568f, -0.00298007f, 0.03320743f, 
    0.01117874f, -0.03515596f, 0.00743624f, 0.02134879f, -0.03170094f, -0.03568743f, -0.04770083f, -0.03771712f, 
    0.00030837f, 0.00353612f, -0.05072575f, -0.03435208f, -0.02390686f, 0.02037680f, 0.04174638f, 0.01609846f, 
    0.03124110f, -0.05614199f, 0.03489842f, -0.00396812f, -0.01489249f, 0.01783993f, 0.01663986f, -0.03585542f, 
    -0.01961727f, 0.02596386f, -0.03216545f, -0.03390251f, -0.04176292f, 0.02954371f, -0.01808132f, -0.01777512f, 
    0.00290461f, 0.03434274f, 0.01044301f, 0.03222258f, -0.02506891f, 0.02052146f, -0.00361639f, -0.00872487f, 
    -0.03513020f, -0.02717729f, 0.03003531f, 0.04160469f, -0.03453457f, 0.02401103f, -0.03975968f, 0.01234220f, 
    -0.00435476f, -0.01230140f, -0.00706206f, -0.05768957f, -0.01389787f, 0.01280888f, -0.03530001f, -0.01565599f, 
    -0.01031090f, -0.03593933f, -0.02715289f, 0.03849780f, 0.03169778f, 0.03368063f, -0.03905913f, -0.00985913f, 
    -0.05710578f, 0.00150301f, -0.03743866f, -0.03136078f, -0.01963724f, 0.02747035f, -0.01409282f, 0.00624105f, 
    0.01308679f, -0.02237253f, -0.02570610f, -0.00642581f, 0.00966610f, 0.03189133f, 0.01373691f, 0.02477104f, 
    0.03260553f, -0.05873201f, -0.00504821f, 0.02799209f, -0.01526529f, 0.00076166f, 0.02745606f, 0.00574529f, 
    -0.05216568f, -0.02081234f, 0.00239420f, -0.00511676f, 0.04250968f, -0.00193377f, -0.03097200f, -0.02099936f, 
    0.04009737f, -0.02936494f, 0.02987010f, -0.00326624f, -0.02784797f, 0.01495942f, -0.05941485f, 0.03492007f, 
    -0.02016947f, -0.00017443f, -0.05393674f, -0.01584278f, -0.04631153f, 0.03597284f, 0.01257655f, -0.01413798f, 
    -0.00145978f, 0.01788364f, -0.01564859f, -0.00756605f, 0.00125611f, 0.00273316f, -0.05697007f, 0.00171436f, 
    -0.04452575f, 0.02975927f, -0.05099372f, -0.00786863f, 0.01977031f, -0.04391200f, -0.04578067f, -0.04405164f, 
    0.01973521f, -0.02352516f, 0.04162688f, -0.05258870f, -0.04452258f, -0.04535703f, 0.00387587f, -0.01485966f, 
    0.03896900f, -0.03555926f, 0.01320660f, -0.02621439f, -0.02659665f, -0.04481748f, -0.00312068f, 0.00512219f, 
    -0.03114671f, 0.01670613f, 0.00975962f, 0.02626824f, 0.00952353f, 0.03697234f, -0.04784896f, -0.01921028f, 
    -0.00535628f, 0.00578993f, -0.05107931f, -0.00301519f, 0.00599085f, -0.04635528f, 0.01134216f, 0.02290128f, 
    -0.04349322f, 0.02065147f, -0.01011428f, -0.02599930f, -0.00110005f, -0.03812744f, 0.01206407f, -0.03665040f, 
    -0.04460414f, -0.05013317f, 0.04153215f, 0.04280832f, -0.00031476f, -0.02964354f, -0.02648823f, -0.03332081f, 
    -0.03687311f, 0.01101623f, -0.04289712f, 0.03092332f, -0.00135719f, -0.03766663f, -0.04608730f, -0.04992041f, 
    0.02503293f, -0.05206282f, 0.00526285f, 0.03933934f, 0.02422882f, -0.00777305f, 0.00385518f, 0.00879891f, 
    0.00800173f, 0.03720379f, 0.02449989f, -0.03965488f, 0.01333676f, 0.02039414f, -0.03362282f, -0.05560821f, 
    0.00567173f, -0.02612036f, -0.02681316f, -0.05520017f, -0.04268092f, -0.03727882f, -0.03290745f, -0.02492710f, 
    -0.02606340f, -0.03283611f, -0.00913045f, 0.00579387f, -0.01508421f, -0.02636659f, -0.01234130f, -0.02543949f, 
    0.00976769f, 0.00289636f, -0.00457668f, -0.03874598f, -0.00373469f, -0.04496475f, -0.01095817f, -0.00048699f, 
    0.04235455f, -0.00384971f, -0.03266038f, -0.02317715f, 0.00414879f, -0.00557810f, -0.03701651f, -0.04548923f, 
    -0.03127656f, 0.03656526f, 0.00646754f, -0.04019648f, -0.02211413f, 0.00824738f, -0.01788121f, -0.03340634f, 
    -0.02568936f, 0.02930749f, -0.01249543f, -0.03395617f, 0.02116272f, -0.03008755f, 0.02692340f, 0.02829385f, 
    -0.00932357f, 0.03071559f, 0.00105666f, -0.00264287f, -0.02483520f, -0.01482286f, 0.03663218f, 0.02737800f, 
    0.02872710f, 0.02934732f, -0.04691791f, -0.03931817f, -0.03818757f, 0.02001512f, -0.04770258f, 0.02954796f, 
    -0.02785596f, -0.02501288f, 0.01738957f, -0.03688390f, 0.01716660f, -0.01691448f, 0.00082512f, 0.01977060f, 
    -0.00992848f, -0.00945445f, -0.03415063f, -0.01762440f, -0.03603373f, -0.04446912f, -0.02562277f, 0.03490892f, 
    -0.01438060f, 0.03551346f, -0.03780609f, -0.01050143f, -0.01363826f, -0.05530371f, 0.01361213f, -0.01711451f, 
    0.02958465f, -0.05403803f, 0.00286360f, 0.01395589f, 0.01681485f, -0.04756071f, 0.00480439f, -0.01584714f, 
    0.00770358f, 0.02156329f, -0.04501726f, 0.00852632f, 0.00054700f, -0.00302134f, -0.02988860f, -0.01313210f, 
    -0.00462402f, 0.03109558f, 0.01944569f, -0.02098033f, 0.00588873f, 0.02889471f, -0.05793850f, -0.01294326f, 
    -0.01937843f, 0.01525331f, 0.02552042f, -0.02352551f, 0.02647570f, -0.03024453f, 0.03815772f, -0.00829227f, 
    -0.03698656f, 0.03817106f, 0.01918079f, -0.03098906f, -0.01460176f, 0.00141015f, -0.01059174f, -0.01463419f, 
    -0.04759677f, 0.00400629f, -0.03887033f, 0.01134105f, 0.00077516f, -0.03369269f, 0.03051473f, -0.00596813f, 
    -0.01237302f, -0.01961197f, -0.02669513f, 0.02593868f, -0.04436775f, 0.00605388f, -0.03364087f, -0.00861738f, 
    -0.00662421f, 0.02873182f, 0.03075565f, -0.00268086f, -0.02290717f, -0.02498817f, -0.02212128f, 0.03053018f, 
    0.00388857f, -0.01843780f, 0.00671531f, -0.05103953f, 0.00533767f, 0.03774245f, -0.00091904f, -0.02229666f, 
    0.02392636f, 0.02715490f, -0.02811241f, 0.00819871f, -0.01280784f, -0.04423752f, 0.03272014f, 0.00164049f, 
    -0.02356365f, 0.03459663f, 0.00332960f, -0.04865491f, 0.00494927f, 0.03157142f, 0.01356347f, -0.00296655f, 
    -0.00598033f, 0.01698073f, 0.02867403f, 0.02109608f, -0.04197533f, 0.03337694f, -0.02238095f, 0.03723792f, 
    0.02069260f, 0.03126790f, -0.04958372f, -0.01388005f, 0.02517190f, -0.05637638f, -0.04831889f, -0.04565602f, 
    -0.00349831f, 0.01245467f, -0.03608349f, -0.00249740f, 0.03182054f, -0.01593364f, 0.03954902f, 0.01580275f, 
    -0.03650041f, -0.02374582f, -0.05700200f, -0.05603066f, 0.04401711f, 0.00178834f, -0.05191687f, -0.01510049f, 
    0.02521531f, -0.01063590f, -0.00223893f, -0.02006264f, 0.01513387f, -0.02705483f, -0.02258008f, -0.01119795f, 
    -0.04024699f, 0.01608861f, 0.01988620f, 0.00377580f, -0.00128074f, 0.05080946f, -0.01369730f, -0.02700250f, 
    0.00909003f, -0.00453528f, -0.03979351f, 0.03570144f, -0.01506713f, -0.04293901f, 0.00569779f, 0.00935583f, 
    0.03085574f, 0.01692647f, 0.01411650f, 0.01709658f, 0.03070617f, -0.03112340f, 0.00754065f, -0.00918282f, 
    -0.03489505f, 0.03236613f, -0.02328076f, -0.02962674f, -0.03308483f, -0.00326549f, -0.04136926f, 0.04344793f, 
    -0.01266940f, -0.03080151f, -0.03026620f, -0.03895045f, -0.01941533f, 0.03760337f, -0.03550979f, 0.01147018f, 
    0.02948804f, -0.00848878f, -0.02593797f, 0.01507742f, -0.04592362f, -0.05415565f, -0.00148750f, -0.02925898f, 
    0.03129060f, -0.05987081f, 0.01491373f, -0.00004755f, -0.00798383f, -0.02821752f, -0.04150894f, -0.00171556f, 
    -0.00019171f, 0.00580632f, 0.00930573f, -0.04262667f, -0.00959574f, 0.01723946f, -0.01240821f, -0.01550002f, 
    -0.03798246f, 0.01589173f, -0.03208185f, 0.04141705f, 0.01356472f, -0.02320728f, 0.03497192f, 0.00255954f, 
    -0.00137852f, -0.01741900f, -0.05620648f, -0.00570286f, -0.02443217f, -0.00556050f, -0.04018138f, -0.01831250f, 
    -0.01717200f, 0.02592733f, 0.02091459f, -0.00751524f, -0.02510698f, -0.04761365f, 0.04201773f, -0.03144648f, 
    0.00173137f, 0.02737785f, 0.01286453f, -0.03227425f, -0.03249596f, 0.01951958f, -0.03392090f, 0.01891633f, 
    0.02791186f, 0.00918018f, -0.04730368f, 0.00284574f, 0.00769925f, 0.02232600f, -0.03840443f, 0.01045834f, 
    -0.01044842f, 0.02110816f, -0.00313418f, 0.00574211f, -0.01871571f, -0.04751162f, -0.02680294f, -0.04316349f, 
    0.01211603f, 0.04754585f, -0.01125112f, -0.02779003f, -0.00427554f, -0.03380322f, -0.00242188f, 0.01818392f, 
    -0.00094892f, 0.01614044f, 0.01805872f, -0.02974079f, -0.03534376f, -0.03735915f, 0.01389178f, -0.03596115f, 
    -0.03316770f, -0.00209853f, -0.04048526f, -0.02461460f, -0.01589566f, -0.03659831f, -0.01132186f, 0.03361973f, 
    -0.01548421f, 0.02187995f, 0.02381077f, 0.00229555f, 0.03455212f, -0.01525622f, -0.02308609f, 0.01476435f, 
    -0.04097395f, 0.00962871f, -0.01835975f, -0.02153298f, -0.03100816f, 0.04700140f, -0.04192175f, -0.03725036f, 
    0.03527015f, -0.01042762f, 0.03299006f, -0.05012428f, 0.00188004f, -0.01512752f, -0.05835435f, 0.01746305f, 
    0.01437840f, -0.02828846f, 0.01507555f, -0.04095573f, 0.01611524f, -0.02752569f, 0.01375247f, -0.03777955f, 
    -0.04259614f, 0.04549280f, 0.02632228f, 0.03627816f, 0.00024479f, 0.04362626f, 0.04868567f, 0.02238755f, 
    -0.01642634f, 0.03092152f, 0.03742018f, 0.02888419f, 0.02025457f, -0.04065775f, 0.03382634f, 0.04161065f, 
    0.00024225f, -0.00575603f, -0.02511547f, 0.01003741f, 0.00784338f, 0.02559441f, -0.05227033f, -0.02586221f, 
    0.02682872f, 0.02136847f, -0.03014986f, -0.03409051f, 0.04119114f, -0.03874491f, -0.04439580f, 0.04089048f, 
    -0.04483808f, -0.01726454f, 0.02568790f, -0.05405356f, -0.05383658f, 0.02979091f, -0.02335523f, 0.02145065f, 
    0.03953019f, 0.01702907f, -0.01445529f, -0.03611281f, 0.01097368f, 0.00285518f, -0.01768960f, 0.01448463f, 
    -0.03384217f, -0.02596102f, 0.03347576f, 0.04233810f, 0.04299728f, -0.00972343f, 0.00521282f, 0.04489284f, 
    0.02255416f, 0.04966889f, 0.03280855f, -0.04558571f, 0.02107550f, -0.01780868f, -0.02279140f, -0.02801544f, 
    -0.03320632f, -0.04149590f, 0.01956773f, 0.00778517f, -0.00413754f, 0.00317444f, -0.02757408f, 0.02858612f, 
    -0.02018164f, 0.02785823f, -0.04675310f, -0.01196455f, -0.00538830f, 0.02552311f, 0.04061053f, 0.02387372f, 
    -0.00770945f, 0.01261043f, 0.02377379f, -0.00768425f, -0.03750321f, -0.01669256f, 0.01662814f, -0.01895161f, 
    -0.01392998f, 0.00438234f, 0.02116435f, -0.03205394f, 0.00040738f, -0.00038197f, 0.03267910f, -0.02001349f, 
    0.00783677f, -0.02382863f, 0.01276489f, -0.04609236f, -0.03225149f, -0.01491674f, 0.05174218f, -0.00489425f, 
    -0.00544255f, -0.02793309f, 0.03306389f, -0.03665193f, -0.03224254f, 0.02171893f, -0.01235677f, -0.00202916f, 
    -0.04439573f, -0.01551663f, -0.00571733f, -0.03497339f, 0.03671972f, -0.00449172f, 0.00461173f, 0.01765313f, 
    -0.00268803f, 0.03414439f, 0.03425129f, 0.00477135f, 0.03399314f, -0.02816103f, 0.04363874f, -0.02290072f, 
    0.01042520f, 0.03398003f, -0.04054202f, 0.01498721f, -0.01851303f, -0.01480685f, -0.04558607f, 0.04039136f, 
    0.02074307f, -0.04284647f, -0.04390255f, 0.02919447f, -0.00140875f, -0.03429460f, -0.03587372f, -0.00675607f, 
    -0.03699023f, -0.04536909f, 0.04511206f, 0.02992367f, -0.00787221f, -0.02400406f, -0.05270981f, 0.04005691f, 
    -0.03084765f, -0.03306566f, 0.03580781f, -0.02626857f, -0.03517902f, -0.04163220f, -0.01282143f, -0.00579114f, 
    0.01258764f, -0.03974018f, 0.03900154f, -0.01688118f, -0.03865957f, 0.02699192f, 0.03145161f, -0.03423461f, 
    -0.01295027f, -0.02697079f, 0.00659037f, -0.00502562f, -0.05366789f, -0.02837785f, -0.04224274f, 0.00136290f, 
    0.04713977f, -0.03875132f, -0.02560476f, -0.01014788f, 0.03607915f, -0.03021915f, -0.04585391f, 0.03448774f, 
    0.04928869f, 0.02632211f, 0.02203171f, -0.00151189f, -0.02470463f, 0.04378431f, -0.04463967f, -0.06188612f, 
    -0.05549730f, -0.04714588f, -0.03672436f, -0.03989303f, -0.01071065f, 0.01438030f, 0.03173448f, -0.04450658f, 
    0.00633321f, 0.01654143f, 0.03338351f, 0.00577696f, 0.01505790f, 0.04311319f, -0.05709699f, -0.01369884f, 
    -0.01008396f, -0.03208281f, -0.02772949f, -0.04585654f, -0.03253715f, -0.02674518f, 0.02077454f, -0.01051151f, 
    -0.03884775f, 0.02330054f, -0.00970655f, -0.04762201f, -0.04521699f, -0.04710100f, 0.01711260f, -0.02843263f, 
    0.04798363f, 0.02772619f, -0.05682026f, 0.02021750f, -0.02989745f, 0.03497174f, 0.01855621f, -0.02177152f, 
    0.01494834f, -0.00316315f, 0.03553144f, 0.02941529f, -0.01050131f, 0.04319661f, -0.01264494f, -0.03735904f, 
    -0.03796753f, 0.03617155f, -0.04985085f, 0.02341805f, 0.00506893f, 0.00693862f, -0.02811186f, -0.04207313f, 
    -0.04336505f, -0.00451522f, 0.00724098f, -0.04415602f, -0.03009432f, 0.03327162f, 0.02370212f, 0.02090262f, 
    0.02943479f, -0.02821650f, 0.01115353f, 0.04223798f, -0.01513112f, -0.01982189f, 0.03452447f, -0.04705559f, 
    -0.04979992f, -0.03755050f, -0.00437874f, -0.03541086f, 0.03514448f, -0.05631926f, 0.02808665f, 0.03093809f, 
    -0.00855953f, -0.06193326f, 0.04445422f, 0.03801997f, -0.02569510f, 0.02452253f, 0.01280518f, -0.02969424f, 
    0.01778143f, 0.00955727f, 0.04481825f, 0.03459572f, 0.04711218f, -0.02187791f, 0.02753456f, -0.05314947f, 
    0.04539210f, 0.02435767f, -0.02767317f, -0.01079084f, 0.03116061f, -0.01814388f, 0.04506820f, -0.00707135f, 
    -0.04527703f, 0.03915431f, 0.03399242f, -0.05981777f, 0.03701561f, -0.05162473f, 0.00465783f, 0.00864894f, 
    -0.02550766f, -0.01929088f, 0.01915376f, 0.02911130f, -0.00564469f, -0.00239853f, -0.01227503f, -0.00065599f, 
    -0.03384374f, 0.01864760f, -0.02487767f, 0.05001931f, -0.04743629f, 0.03793515f, -0.05239518f, 0.03364050f, 
    0.04675610f, -0.04922173f, -0.04029869f, -0.01046988f, 0.02792466f, 0.00146896f, -0.00469124f, 0.00760986f, 
    0.03775588f, 0.03703291f, -0.03230174f, -0.00219503f, 0.02726096f, 0.03719071f, 0.03866983f, 0.04312259f, 
    0.03435728f, 0.03905798f, 0.03962071f, 0.02639899f, -0.04796494f, 0.00188771f, -0.02384036f, 0.01200482f, 
    -0.03274589f, 0.03654274f, 0.02168075f, 0.00123466f, -0.01986799f, -0.04337839f, 0.01279136f, -0.02947136f, 
    -0.05232874f, -0.04236789f, 0.04094095f, -0.01362724f, -0.03507844f, -0.01624170f, -0.01060036f, 0.00790686f, 
    0.03621366f, 0.00586069f, -0.03008577f, -0.03928024f, -0.00809507f, -0.00969925f, -0.01069196f, 0.00472522f, 
    0.03098203f, 0.01359639f, -0.05581872f, -0.00642110f, 0.04566198f, -0.00858844f, -0.05564231f, -0.05109915f, 
    0.00377969f, 0.02080956f, -0.02851982f, -0.03058043f, -0.00976824f, -0.04494851f, 0.02379305f, 0.00201139f, 
    -0.02821611f, -0.03586701f, -0.00283019f, 0.04931066f, -0.03144979f, -0.00974703f, -0.02576393f, -0.03168583f, 
    0.01719257f, 0.04175192f, 0.01832803f, -0.00062678f, 0.01603129f, -0.03096028f, -0.00611468f, -0.01243009f, 
    0.02495719f, -0.01700060f, -0.02044839f, -0.00675260f, -0.01321888f, -0.03366258f, 0.01004170f, 0.02005688f, 
    0.00380681f, -0.00238859f, 0.01269177f, 0.00521084f, -0.05513540f, 0.04098191f, -0.00663204f, -0.03074941f, 
    -0.02765235f, -0.00791954f, -0.03782729f, 0.00405490f, -0.03508730f, 0.02584338f, -0.02902702f, -0.01954525f, 
    0.03992764f, -0.03737574f, -0.05088369f, -0.03732514f, -0.02584128f, -0.01483520f, -0.05068313f, -0.02418450f, 
    -0.01930991f, 0.03084568f, -0.05632994f, -0.00744883f, -0.04305448f, -0.03967625f, -0.00694575f, 0.02853942f, 
    -0.02603870f, 0.03216271f, 0.00480227f, 0.02558869f, 0.00755090f, 0.00454622f, -0.03257461f, 0.00785583f, 
    0.01811640f, 0.01546589f, -0.06104825f, -0.00150867f, -0.05511295f, 0.03126559f, 0.02834933f, -0.03931898f, 
    -0.00529189f, 0.03365258f, 0.02016644f, 0.00660604f, -0.00422556f, 0.00931140f, -0.02854551f, -0.04048378f, 
    0.04348660f, 0.00197758f, -0.03042974f, -0.02417106f, 0.00239173f, -0.02900632f, 0.01373010f, -0.02730334f, 
    0.03774675f, -0.01068524f, -0.00607400f, 0.00184214f, -0.04273333f, 0.03398913f, -0.05303352f, -0.02918165f, 
    -0.03645950f, -0.04763759f, 0.00687751f, 0.04606332f, 0.01251077f, 0.02674580f, -0.02461987f, 0.04690845f, 
    -0.01941039f, -0.00443827f, 0.02724011f, 0.03020578f, 0.00310278f, 0.04086432f, -0.02868503f, 0.04180252f, 
    0.03747259f, 0.01872967f, -0.03202013f, -0.02118157f, -0.00927818f, 0.01180208f, 0.02117886f, -0.03794923f, 
    0.02453620f, 0.04076277f, 0.01433916f, 0.03583136f, -0.00122374f, -0.04371016f, -0.01658433f, 0.00725096f, 
    -0.01015281f, 0.00526316f, -0.00422508f, 0.01947401f, 0.02520789f, -0.01785524f, 0.00730650f, -0.02754096f, 
    -0.00861678f, 0.01741337f, 0.04013621f, -0.00784017f, 0.03417632f, -0.04682765f, 0.03768702f, -0.03616033f, 
    -0.04265989f, -0.02887269f, 0.01107220f, -0.01760681f, -0.01813820f, 0.04545408f, -0.02160780f, -0.00947537f, 
    0.02429636f, 0.02346046f, -0.03865605f, 0.03296261f, 0.00938584f, 0.01918803f, -0.05392161f, 0.01745268f, 
    -0.01961843f, 0.00558941f, 0.03571596f, 0.03502853f, 0.04680822f, 0.02844521f, -0.01870764f, -0.05236270f, 
    -0.04915456f, -0.02686396f, 0.02957538f, 0.02889610f, 0.00651972f, -0.04248980f, -0.00891181f, -0.01748170f, 
    -0.04367515f, 0.02221030f, -0.04233957f, -0.00426239f, -0.02958987f, 0.02117912f, -0.00926448f, -0.02646063f, 
    -0.17266981f, 0.18435131f, -0.01363243f, 0.01680474f, 0.02675361f, 0.02313609f, -0.06089692f, 0.16704342f, 
    0.03939267f, -0.01049995f, 0.04328034f, -0.01456979f, 0.13552862f, -0.12927385f, -0.22965495f, 0.02966662f, 
    0.14884619f, -0.03289350f, 0.03320081f, 0.03607068f, 0.00655432f, -0.03592945f, -0.02930200f, 0.04531747f, 
    0.07891387f, -0.04786817f, -0.02053422f, -0.22905505f, -0.01333739f, -0.01380439f, 0.02853102f, -0.03316082f, 
    0.03961102f, -0.11158971f, -0.10190786f, 0.05040944f, -0.01615918f, 0.07246023f, -0.03126624f, 0.11309619f, 
    -0.00063437f, 0.04462645f, -0.08833180f, 0.00405766f, 0.04144502f, -0.10965221f, 0.02380434f, 0.04365833f, 
    -0.22758675f, -0.07703502f, -0.00905930f, 0.24968752f, -0.09044363f, 0.00372984f, -0.03280107f, 0.02058839f, 
    0.09997604f, 0.04636118f, 0.00178751f, -0.05489831f, -0.06345952f, 0.02383294f, 0.01912012f, -0.11130124f, 
    0.05790319f, -0.00523188f, 0.08148050f, 0.00526128f, -0.02320296f, 0.03267326f, 0.05659987f, 0.05697391f, 
    0.10369407f, 0.05865490f, -0.05116255f, 0.15825821f, 0.02196532f, 0.08753676f, -0.01298077f, 0.09003503f, 
    -0.09485881f, 0.05023777f, 0.08331908f, 0.02018774f, 0.37381577f, 0.21684971f, 0.05336014f, -0.30030170f, 
    -0.00126510f, -0.01966111f, 0.01953174f, -0.00965053f, 0.03465405f, 0.04107147f, 0.02601546f, 0.08260293f, 
    -0.03677024f, -0.02114832f, 0.16427676f, -0.07791664f, -0.01435166f, -0.04877973f, 0.00156206f, 0.06243177f, 
    0.10657473f, -0.05056694f, 0.13286467f, 0.10048675f, 0.10800115f, 0.01851935f, 0.02685163f, 0.02365654f, 
    -0.04395279f, -0.11719043f, -0.04555848f, 0.13110007f, 0.07681582f, -0.16055052f, -0.06199945f, 0.01078106f, 
    -0.11249738f, 0.03152385f, -0.06342945f, -0.08886105f, 0.00932715f, -0.09261598f, -0.04494327f, 0.07508262f, 
    -0.08643459f, 0.04358323f, 0.11472226f, 0.09238048f, 0.13822678f, 0.12178569f, 0.10076600f, -0.04690742f, 
    0.10877149f, 0.02342149f, 0.02180276f, 0.09191533f, 0.01652215f, 0.13172309f, -0.03259799f, -0.09144828f, 
    0.09423417f, -0.13387117f, 0.00697958f, -0.05171942f, 0.02871322f, -0.01595854f, 0.02528108f, -0.05289334f, 
    0.08025329f, -0.10481862f, 0.08354297f, 0.04837411f, 0.25763944f, -0.10129815f, -0.11207315f, 0.35591090f, 
    0.09268387f, -0.02827939f, -0.01465477f, -0.01108745f, 0.04278063f, 0.09439264f, -0.00583649f, -0.07381748f, 
    0.02776011f, 0.10144848f, -0.04680863f, 0.26811269f, -0.08902720f, -0.07565138f, -0.01359417f, -0.10120267f, 
    0.11794125f, -0.02110346f, 0.03529418f, 0.04353079f, -0.14577591f, 0.15220888f, -0.20645566f, 0.16919252f, 
    0.04600210f, 0.05633145f, -0.07918982f, -0.10039066f, -0.03351511f, -0.00813313f, -0.01277080f, 0.07065296f, 
    -0.13566150f, 0.07432704f, -0.02959002f, 0.03039923f, -0.02967268f, -0.00920380f, 0.06188709f, 0.05866992f, 
    0.04659114f, 0.01379007f, -0.05260802f, -0.05909111f, 0.08258589f, -0.05636191f, 0.14019050f, -0.13588610f, 
    0.04918180f, 0.10678799f, -0.02932027f, -0.01085233f, 0.04385417f, -0.02905872f, 0.03287143f, 0.01503694f, 
    0.03455234f, -0.02513287f, -0.07072450f, 0.04309490f, -0.02304871f, -0.07868607f, -0.08338966f, -0.07787018f, 
    0.03863388f, 0.00320064f, 0.04862191f, 0.06128334f, -0.09268988f, 0.10033461f, 0.01639130f, -0.01400673f, 
    -0.11420863f, 0.09585093f, 0.00911607f, 0.08311513f, -0.07024068f, 0.01505062f, 0.10177093f, 0.01950085f, 
    0.19532688f, -0.18015476f, -0.13276421f, 0.06271510f, 0.14593065f, 0.15144673f, 0.05141538f, 0.01048279f, 
    -0.00470655f, -0.09491263f, -0.06296057f, -0.00692385f, -0.12423576f, 0.22496498f, -0.06623918f, 0.09897143f, 
    -0.04577395f, -0.09965036f, 0.11208711f, 0.02667307f, 0.04955240f, 0.00101807f, -0.04499583f, 0.04210165f, 
    0.33203971f, 0.26321840f, -0.22629768f, -0.04526480f, 0.06623301f, 0.10860986f, 0.07660697f, -0.00429958f, 
    -0.03279315f, 0.03019547f, 0.17358741f, -0.07664830f, -0.20314349f, -0.04473549f, 0.02679307f, -0.07707320f, 
    -0.00773979f, -0.10896681f, -0.06631942f, 0.04801727f, 0.05665896f, 0.15370484f, -0.07007626f, -0.02643110f, 
    0.17029366f, -0.00081393f, 0.16208768f, -0.21346316f, -0.00547530f, 0.07668271f, -0.05413242f, -0.01356183f, 
    0.00206521f, 0.01203832f, 0.05912971f, 0.02165475f, -0.02522994f, -0.15128653f, -0.04135449f, 0.09269555f, 
    -0.09738708f, -0.07569301f, -0.01014138f, 0.09024762f, 0.04969619f, -0.06167689f, -0.00026390f, -0.03231509f, 
    -0.11703566f, -0.11480400f, 0.01673440f, -0.16372651f, -0.02670858f, 0.01468575f, 0.09290300f, 0.12835652f, 
    0.04047453f, -0.12577887f, 0.11160727f, -0.08590341f, -0.05912508f, 0.04628051f, -0.03517307f, -0.10423225f, 
    0.00346177f, 0.01615231f, 0.04349737f, 0.00369919f, 0.04109091f, 0.12687506f, -0.06490612f, -0.05340378f, 
    0.00411750f, -0.08708073f, -0.17786442f, 0.29580912f, 0.21433558f, -0.02544104f, 0.06902304f, -0.00698847f, 
    0.16030234f, 0.05491008f, 0.01202775f, 0.04809396f, 0.20713457f, 0.12078716f, -0.05015247f, -0.11678306f, 
    0.07248379f, 0.00583680f, -0.08445471f, 0.05474710f, -0.02020673f, -0.02408588f, 0.03733798f, -0.00628905f, 
    0.36080742f, 0.29553404f, -0.11254624f, 0.01878880f, 0.01150856f, -0.03418946f, -0.00523041f, 0.01058033f, 
    -0.02158104f, 0.16071825f, -0.07911709f, -0.00439348f, 0.18061562f, -0.01197943f, 0.08692614f, -0.33529225f, 
    -0.02303904f, 0.10809523f, 0.00420086f, -0.01811208f, 0.02145435f, -0.11071857f, 0.01505589f, 0.05336314f, 
    0.10353468f, -0.13402690f, -0.22495297f, 0.01559997f, 0.08520352f, 0.06715563f, -0.04815627f, -0.13686225f, 
    -0.03865677f, 0.13820945f, 0.08252551f, 0.08014428f, 0.06223334f, 0.19000885f, 0.16650574f, 0.18092544f, 
    0.16605417f, -0.01426525f, -0.01250507f, -0.03158695f, 0.01861791f, -0.12910290f, 0.02741203f, -0.01276285f, 
    -0.09188146f, 0.04746939f, 0.03712489f, -0.14308296f, 0.07454509f, -0.04787740f, 0.06393455f, 0.00504587f, 
    0.11086142f, 0.10920691f, 0.18163441f, -0.05336913f, -0.07812139f, -0.12403266f, -0.08219285f, -0.01927515f, 
    0.03328701f, 0.16451122f, -0.00211789f, -0.04526326f, -0.03808455f, 0.08531993f, -0.05196858f, 0.01618711f, 
    0.11249001f, 0.17543751f, 0.07924849f, 0.02571474f, 0.17423038f, -0.04966250f, -0.18213788f, -0.00928468f, 
    -0.00123670f, -0.02222803f, 0.00444462f, -0.11706797f, 0.24322577f, 0.23159863f, -0.23551947f, -0.16518985f, 
    -0.01344898f, 0.09775273f, -0.16262931f, 0.02091237f, 0.09619860f, 0.01518529f, -0.15941976f, -0.22267371f, 
    -0.14852889f, 0.11185798f, 0.14417674f, 0.17242277f, -0.01597232f, 0.07348318f, -0.03938872f, -0.20437950f, 
    0.07233630f, 0.01365966f, 0.17183223f, 0.10032210f, 0.02028566f, 0.16975434f, -0.00904737f, 0.08431710f, 
    0.05811045f, -0.07475344f, -0.00189206f, -0.05367098f, 0.07203352f, -0.05168536f, -0.08391626f, -0.03349409f, 
    0.09862281f, -0.03218965f, 0.08192862f, -0.13338146f, -0.03415818f, -0.05559826f, 0.08125807f, -0.02568174f, 
    0.01924944f, 0.18923312f, -0.00080131f, 0.21977179f, 0.03643302f, -0.00820376f, 0.05816169f, -0.18848594f, 
    0.13002627f, 0.24804066f, -0.09741937f, 0.04682928f, 0.09520551f, -0.18433088f, 0.14964683f, -0.07760081f, 
    -0.07264686f, -0.03424683f, 0.04861523f, -0.01851048f, 0.08271945f, 0.05126018f, 0.12842467f, -0.01850727f, 
    -0.01742071f, -0.12068196f, -0.05875991f, -0.09380455f, 0.25989926f, 0.01072486f, 0.04584134f, -0.05939770f, 
    -0.01032936f, 0.00883467f, -0.15353006f, -0.11198206f, 0.02837232f, -0.06727765f, -0.20936187f, 0.10079151f, 
    -0.28325030f, -0.10884070f, 0.12485309f, 0.14407898f, -0.05276295f, 0.10148031f, 0.13345319f, 0.06045081f, 
    0.04346231f, -0.07902209f, -0.24365179f, -0.27198634f, -0.04222081f, -0.08770731f, 0.23018546f, -0.08429358f, 
    -0.00568502f, -0.02234825f, 0.05634794f, -0.00592736f, 0.02543996f, 0.00722548f, 0.10919022f, 0.05076646f, 
    0.01508200f, 0.02603910f, -0.15951332f, -0.19143011f, 0.07184513f, 0.15557067f, 0.05227142f, 0.07595276f, 
    0.16440395f, 0.10043664f, -0.19169407f, 0.01082126f, -0.00296940f, 0.09599344f, 0.04886785f, -0.00729782f, 
    0.06295666f, -0.01836606f, 0.02365255f, 0.03770895f, 0.03417251f, 0.05122685f, 0.08078426f, 0.15093406f, 
    -0.01165547f, -0.05805155f, -0.03350894f, -0.15632747f, 0.08747053f, 0.06184633f, 0.01683591f, 0.11376431f, 
    0.00840701f, 0.14015706f, 0.04209634f, 0.22211406f, -0.07273234f, 0.00009316f, 0.00593145f, -0.04992576f, 
    0.04353445f, 0.05825181f, 0.15705056f, 0.09790259f, 0.01241233f, 0.05704073f, 0.05866954f, 0.10599566f, 
    -0.05522405f, 0.04432760f, -0.07360845f, 0.11699751f, -0.00026011f, 0.12103786f, 0.06910682f, 0.06336737f, 
    -0.07001460f, -0.02194149f, 0.02286668f, 0.02253829f, -0.02487755f, -0.18185605f, -0.10160669f, -0.05762223f, 
    0.09744968f, -0.06950282f, -0.05583235f, -0.03293996f, 0.03853267f, 0.10545728f, 0.04050317f, -0.04011565f, 
    -0.04430310f, 0.02270601f, 0.10401094f, 0.05446921f, -0.03963302f, 0.00126378f, 0.07950184f, 0.00894482f, 
    -0.01958156f, 0.14548767f, -0.06660499f, 0.22907406f, 0.16481495f, -0.19111748f, -0.04241362f, -0.07153711f, 
    -0.05666859f, 0.00167598f, -0.01829766f, 0.04574768f, -0.00096470f, -0.04191728f, 0.13818932f, -0.16216105f, 
    0.06828450f, -0.01874807f, -0.11377215f, 0.05009095f, 0.03193517f, 0.06124685f, -0.04474584f, -0.05379085f, 
    -0.01177065f, -0.15750107f, 0.03257774f, 0.29269412f, -0.09907701f, -0.24615763f, 0.16128978f, -0.20113899f, 
    0.12070389f, 0.11397178f, 0.05062733f, 0.07942440f, -0.04135556f, -0.25032628f, 0.08148843f, -0.06247786f, 
    0.08714270f, 0.03989563f, -0.05694875f, -0.08056779f, 0.06568538f, -0.04605902f, -0.07994287f, -0.15994056f, 
    0.02210529f, -0.14578451f, -0.11836188f, -0.07414979f, -0.11397053f, -0.04657935f, 0.04871652f, 0.03442935f, 
    0.17603153f, -0.00630665f, 0.03922230f, 0.01281071f, 0.03256341f, 0.03703688f, 0.13931677f, 0.26062867f, 
    -0.04349542f, 0.10824050f, -0.07539178f, 0.17789480f, 0.00816904f, -0.06081810f, 0.18610728f, -0.08019554f, 
    0.01468052f, -0.02566442f, 0.15905693f, -0.10719199f, -0.06975387f, 0.01015406f, 0.19899349f, 0.00242258f, 
    0.11859350f, 0.09642198f, 0.04821762f, 0.15512446f, 0.01815572f, -0.14376913f, -0.00247433f, 0.07733162f, 
    0.03894679f, -0.14140794f, 0.08820479f, 0.18605183f, -0.11964852f, -0.06809368f, -0.18783809f, -0.00297928f, 
    0.04281376f, -0.06873327f, -0.00990771f, -0.07039980f, -0.07343495f, 0.06261097f, 0.10190489f, -0.02110277f, 
    0.03232650f, 0.12013549f, 0.05922785f, -0.05625844f, 0.24027677f, 0.16043112f, 0.10132677f, 0.10033099f, 
    0.08658158f, -0.05976908f, 0.05501900f, -0.14074817f, 0.13408615f, 0.08232021f, -0.24936400f, 0.04408210f, 
    -0.02288391f, -0.05092205f, -0.13094027f, -0.08656418f, -0.49053243f, -0.14321053f, -0.02977377f, 0.03689450f, 
    0.08746842f, -0.12706828f, -0.04734994f, -0.14795898f, 0.07270919f, 0.00245914f, 0.11071836f, 0.00616992f, 
    -0.00537733f, -0.00730971f, 0.00782151f, 0.02042605f, -0.02358324f, 0.02066213f, -0.05277539f, 0.01142821f, 
    -0.03423249f, -0.00988242f, 0.00043698f, -0.02044053f, -0.02896525f, 0.01108847f, -0.00449518f, -0.02276173f, 
    -0.01884837f, 0.00328982f, -0.05871951f, 0.02494849f, 0.01668023f, -0.02594574f, 0.04142688f, 0.03629080f, 
    0.02819827f, 0.03016908f, -0.04207904f, -0.00845627f, 0.04229322f, -0.00231494f, -0.03069734f, -0.01630224f, 
    0.00031291f, -0.03030534f, 0.04368504f, -0.05530627f, -0.04852656f, 0.03894199f, 0.02419983f, -0.02522886f, 
    0.04215674f, -0.02786589f, 0.02983521f, 0.00259729f, -0.05363072f, -0.01590886f, -0.03780785f, -0.03181168f, 
    -0.00186952f, -0.00635594f, 0.03764887f, 0.02756422f, -0.04323135f, -0.02889360f, -0.03703644f, 0.04208799f, 
    -0.02134403f, -0.03740866f, -0.05524113f, 0.00440445f, -0.03244731f, -0.05604057f, 0.03340204f, -0.05367652f, 
    0.03196271f, 0.04077963f, -0.05066410f, 0.00482493f, -0.00983976f, -0.01291149f, 0.02146951f, 0.02454724f, 
    -0.01534012f, 0.00390908f, 0.03638013f, -0.03682708f, 0.00698484f, 0.02848825f, -0.04576603f, -0.00312859f, 
    0.02656178f, 0.00397532f, 0.02450115f, -0.00150112f, 0.01799587f, 0.02176036f, -0.02522463f, 0.04463185f, 
    -0.04827702f, -0.05435321f, -0.02453952f, -0.04351440f, -0.03000604f, 0.02119897f, -0.00059680f, -0.00815020f, 
    0.02440262f, -0.01965662f, 0.01866044f, 0.03688107f, -0.02831558f, -0.04581454f, 0.03910340f, 0.00300163f, 
    0.00913138f, -0.03909943f, 0.02643187f, -0.04028672f, -0.03546351f, 0.03803764f, -0.03115982f, -0.03576050f, 
    -0.02514350f, -0.01171086f, -0.05507361f, -0.00275614f, -0.01981856f, -0.01823206f, -0.01569808f, 0.01709367f, 
    0.03181865f, -0.01636754f, -0.02767992f, -0.05530711f, 0.02999895f, -0.00918297f, 0.03274846f, -0.04802856f, 
    -0.04596088f, 0.04142618f, -0.02007842f, 0.02685382f, -0.03113032f, 0.03854206f, 0.03664442f, -0.01455346f, 
    0.02056275f, -0.04305922f, -0.05306590f, -0.04592314f, 0.02799881f, -0.04017871f, -0.02192730f, 0.01738994f, 
    -0.00997579f, 0.02288636f, 0.03062659f, 0.00481691f, 0.03915231f, -0.05368437f, 0.02542360f, -0.01649255f, 
    -0.00185614f, -0.03492105f, -0.05259462f, 0.03109137f, -0.01225219f, -0.00532157f, 0.00322190f, -0.03666684f, 
    -0.05690568f, -0.03102802f, 0.04345346f, -0.02188218f, -0.03477544f, -0.04992298f, 0.03552274f, -0.03537874f, 
    -0.03308540f, 0.02005919f, -0.01386701f, -0.04471695f, -0.05320222f, -0.05255055f, 0.04487341f, 0.02800236f, 
    -0.03316139f, -0.05563749f, -0.02048269f, 0.03639308f, -0.03925462f, -0.02437058f, -0.03666795f, -0.02939385f, 
    -0.01732314f, -0.00773942f, 0.01163772f, -0.04516081f, 0.02813906f, -0.02291061f, -0.00772142f, -0.00723281f, 
    0.04015932f, 0.03779917f, 0.03126384f, -0.00169318f, 0.01684763f, 0.01089819f, 0.03084410f, 0.04121663f, 
    -0.01620999f, 0.00433516f, -0.05665388f, 0.02249907f, -0.04285592f, -0.03755118f, -0.03185699f, -0.00171567f, 
    0.03375394f, -0.04989522f, -0.01822175f, 0.02425021f, -0.05555333f, -0.04028666f, -0.04451453f, -0.05439846f, 
    -0.00255631f, -0.02762007f, -0.03311606f, -0.00618587f, -0.01602595f, -0.03989210f, -0.05470332f, -0.05802432f, 
    0.01407411f, 0.03066688f, 0.00948088f, -0.04325733f, -0.01449981f, -0.05713133f, 0.00449986f, -0.05951459f, 
    -0.02899827f, 0.01695380f, 0.00208527f, -0.01092840f, -0.02775769f, 0.02231484f, -0.05584458f, -0.00723457f, 
    -0.03730221f, -0.01142238f, -0.03884657f, -0.02632550f, 0.03187026f, 0.01263512f, 0.03482975f, 0.03982801f, 
    -0.02689755f, 0.03839225f, -0.02820294f, 0.02399247f, -0.05239501f, -0.03167978f, 0.03005541f, -0.00163463f, 
    0.00739921f, 0.02671673f, 0.00540782f, -0.04237118f, 0.00483519f, -0.00484545f, -0.03328743f, 0.01209934f, 
    -0.01970959f, -0.01095278f, -0.01820108f, -0.01321015f, 0.00945511f, -0.05602847f, -0.03214992f, -0.04798541f, 
    -0.02435046f, 0.03718592f, -0.05310726f, -0.04190468f, 0.00137194f, 0.03490496f, -0.04397453f, 0.01539218f, 
    0.00050612f, -0.02863300f, -0.03777301f, -0.00545153f, -0.02930108f, -0.03393150f, -0.03839481f, 0.03021400f, 
    -0.04262384f, -0.04543940f, 0.02614684f, -0.04576617f, -0.05436919f, -0.00279086f, 0.03084323f, -0.02592712f, 
    0.04322905f, 0.03298804f, 0.03269141f, 0.02846622f, -0.01568338f, 0.00545708f, 0.01640703f, 0.04450294f, 
    0.02234291f, 0.02601660f, -0.04590080f, 0.00561216f, 0.00537608f, 0.01166306f, 0.02093358f, 0.00793109f, 
    -0.01147254f, -0.00096972f, -0.02819095f, -0.04233914f, -0.01702933f, -0.03746516f, -0.04712538f, -0.00170442f, 
    -0.04150220f, 0.00684429f, -0.01714791f, -0.00529997f, -0.01593122f, -0.00548030f, 0.03277359f, -0.03735923f, 
    0.02368853f, -0.02402434f, -0.00026059f, 0.03526225f, -0.04007259f, 0.01008561f, 0.00022725f, -0.05808330f, 
    0.01377421f, -0.04643470f, -0.05019007f, 0.02882170f, 0.01996310f, -0.01775185f, 0.01654312f, 0.02960892f, 
    -0.04740936f, -0.01294016f, 0.03344600f, 0.03105279f, 0.00232502f, 0.02410200f, 0.00568577f, -0.04315368f, 
    -0.03081391f, 0.03169909f, -0.01878639f, 0.04161673f, -0.04441367f, -0.01911301f, 0.01490206f, 0.04157565f, 
    0.01105273f, 0.00784117f, 0.04210886f, -0.05489718f, -0.01878519f, 0.00398764f, -0.02151346f, 0.00885731f, 
    0.02995980f, -0.00583342f, -0.03949869f, -0.04585158f, 0.03723628f, -0.01570113f, -0.02633517f, -0.04677114f, 
    0.01205165f, 0.00875447f, 0.04045985f, -0.00163528f, -0.00730032f, 0.04296099f, -0.03485658f, -0.01012215f, 
    0.01683475f, -0.05041446f, -0.04267153f, 0.04575360f, 0.01723089f, -0.00198726f, 0.04164713f, -0.00671183f, 
    -0.05643326f, -0.01392411f, -0.01623893f, 0.03254664f, -0.01995424f, 0.03835147f, 0.03451244f, -0.01457138f, 
    0.02177412f, -0.05786854f, 0.03736747f, 0.01513758f, -0.02396114f, 0.02567562f, 0.02479711f, -0.01976404f, 
    -0.02984905f, -0.04635910f, 0.00866604f, 0.01261352f, 0.00505352f, -0.04822119f, 0.01446457f, 0.02788467f, 
    -0.02456345f, 0.02712926f, -0.04871611f, 0.02955788f, 0.03854528f, -0.00565612f, -0.03355087f, -0.01086499f, 
    -0.03598561f, -0.01691654f, -0.00721477f, -0.02739182f, -0.05100808f, 0.01864847f, 0.01340928f, -0.00642549f, 
    -0.03076258f, -0.05385710f, -0.00883549f, -0.00426972f, 0.02255025f, -0.01632514f, -0.05623862f, -0.01183203f, 
    -0.03071384f, -0.03654288f, 0.01876463f, 0.00319772f, -0.03487606f, 0.00907182f, -0.02082837f, 0.03081297f, 
    0.03192896f, -0.04434056f, -0.00538562f, -0.01317550f, -0.01362374f, -0.02443862f, 0.03020050f, -0.00378533f, 
    -0.05682283f, 0.01147026f, 0.01320538f, 0.02025723f, -0.01265869f, 0.00437570f, -0.02844782f, -0.01173406f, 
    0.01581534f, -0.04658299f, -0.01012145f, 0.01364838f, 0.02750837f, 0.00887552f, -0.04606469f, 0.02745832f, 
    -0.02707804f, -0.04668425f, -0.04268649f, -0.02570401f, 0.04779812f, 0.00950295f, -0.00900356f, -0.00172357f, 
    0.04134710f, -0.02210486f, 0.02817169f, -0.03721714f, 0.00927011f, 0.03043589f, 0.01913745f, -0.05011684f, 
    0.01441296f, 0.02370312f, -0.03598416f, 0.03659852f, 0.01158328f, -0.05226672f, -0.04040409f, 0.02536457f, 
    0.03182175f, 0.01792463f, -0.04950487f, 0.03811227f, 0.00259195f, 0.04090557f, 0.00008989f, 0.04047205f, 
    -0.02903190f, 0.04316286f, -0.00181022f, 0.02159962f, -0.04170108f, -0.03756618f, 0.04184846f, -0.01149706f, 
    0.03249476f, 0.04841383f, 0.01334732f, -0.01255739f, -0.03029811f, 0.04209288f, -0.00915245f, -0.01809366f, 
    -0.02678228f, -0.04203959f, 0.02041286f, -0.02173240f, 0.00306463f, -0.01692971f, -0.04200910f, 0.03454746f, 
    0.03795231f, -0.04391579f, -0.02825566f, -0.02770185f, -0.05094104f, 0.03723729f, 0.03050799f, 0.00312908f, 
    0.00129106f, 0.01395192f, 0.02074766f, 0.02482585f, 0.03316696f, -0.04694367f, 0.02523370f, -0.04738213f, 
    -0.03455603f, -0.00386934f, -0.00453758f, -0.00343375f, -0.04211099f, -0.02216167f, -0.01973466f, 0.00273036f, 
    0.03524963f, 0.03714490f, -0.01746173f, -0.05420099f, -0.03070286f, -0.02028680f, -0.00950887f, -0.01317730f, 
    0.04114843f, -0.05110787f, -0.00098037f, -0.00754901f, 0.02668151f, -0.01305591f, -0.03895138f, 0.00470126f, 
    0.03862466f, 0.01704223f, 0.03610078f, -0.05038180f, -0.05759030f, 0.02505150f, -0.03151049f, -0.05730201f, 
    0.01926171f, 0.03134780f, -0.01556689f, 0.01036389f, -0.05501649f, -0.01903757f, 0.04674270f, 0.02228913f, 
    -0.02365355f, -0.01715900f, -0.00330984f, -0.02527035f, -0.01585656f, 0.03585244f, -0.01812489f, 0.01165751f, 
    -0.04910702f, 0.02016995f, -0.03349748f, 0.02709005f, 0.02074724f, -0.04686700f, 0.00992879f, -0.01181583f, 
    -0.00217519f, -0.01620100f, -0.05384397f, 0.02223224f, 0.03910854f, 0.03863380f, 0.00012527f, 0.04626422f, 
    0.02985798f, 0.01547237f, -0.03210039f, 0.00075039f, -0.01886967f, 0.02040445f, -0.02467160f, 0.00867221f, 
    0.01955086f, 0.03270889f, 0.03915251f, -0.02748355f, 0.03508146f, -0.04628415f, -0.05317592f, -0.05008553f, 
    -0.00536206f, -0.03324341f, 0.02745001f, -0.00759635f, 0.02556608f, -0.05688982f, -0.05592738f, 0.01630874f, 
    0.00238630f, -0.02165668f, 0.02696424f, -0.00843413f, -0.02166881f, -0.02527064f, 0.05430289f, 0.02958520f, 
    0.01200534f, -0.03033727f, -0.05222559f, -0.04955841f, 0.01239287f, 0.04737523f, -0.01478119f, -0.01122668f, 
    -0.00450476f, 0.01191186f, -0.05202369f, 0.02972269f, -0.05100261f, 0.02702014f, 0.02186816f, -0.01388104f, 
    -0.02656335f, 0.03327069f, -0.03819054f, -0.02026272f, 0.02446930f, 0.02772205f, 0.04341273f, 0.04186895f, 
    -0.03901616f, -0.03229212f, -0.00164020f, -0.04189065f, -0.04991970f, 0.04347885f, -0.00354141f, -0.01697684f, 
    0.04300381f, -0.01237532f, -0.01065281f, -0.01006088f, 0.03498457f, 0.01686209f, 0.02104188f, 0.03008442f, 
    -0.03228357f, 0.03579743f, 0.01460305f, -0.04458996f, 0.04342439f, 0.02546725f, -0.05330796f, 0.03553719f, 
    0.04534359f, -0.02312095f, -0.02436412f, -0.02488562f, -0.04476887f, -0.05048858f, -0.02859958f, 0.02023827f, 
    -0.01576431f, -0.02291730f, -0.02045848f, -0.02413937f, -0.01420895f, -0.02574603f, 0.00897836f, -0.05018623f, 
    -0.02356696f, 0.02365319f, -0.05510031f, 0.02876293f, -0.02693713f, 0.01631215f, -0.00060420f, 0.03836222f, 
    0.00421677f, -0.05182249f, 0.02271670f, -0.00617871f, -0.01614395f, -0.03394008f, -0.01228727f, -0.02102792f, 
    -0.00682632f, 0.00358393f, -0.03495589f, -0.01977671f, 0.03503736f, -0.00356010f, 0.00149355f, 0.02710926f, 
    0.03235757f, 0.04646619f, -0.05585946f, -0.00622789f, 0.00398042f, 0.03699411f, 0.02553890f, -0.04537763f, 
    -0.03298496f, 0.02114419f, -0.03118228f, 0.04060731f, -0.02060768f, -0.05873989f, -0.03643021f, 0.01443016f, 
    -0.00215131f, -0.01215870f, 0.00354717f, -0.00378877f, -0.05247311f, 0.00816735f, -0.00544083f, -0.01438114f, 
    0.01302896f, -0.00185747f, -0.00272227f, -0.01048745f, 0.03077751f, 0.04409048f, -0.05929391f, 0.02674328f, 
    -0.01179745f, -0.01577027f, -0.05356043f, -0.01046879f, -0.03240781f, 0.01254187f, -0.05345209f, -0.01944733f, 
    -0.05779983f, -0.00907005f, 0.21145138f, 0.12570907f, -0.04693149f, -0.07320473f, 0.01967031f, 0.08462575f, 
    0.09572934f, -0.00541687f, -0.01504112f, -0.01529878f, -0.18781288f, -0.02719289f, 0.04825216f, -0.21954887f, 
    -0.09490070f, 0.02712865f, 0.10149758f, 0.02628755f, -0.00259859f, -0.08908112f, -0.07993983f, 0.00058074f, 
    0.08884428f, 0.06872401f, 0.08187030f, 0.44240397f, 0.06186026f, -0.03951668f, 0.07919876f, 0.00182042f, 
    -0.02776632f, 0.08602099f, 0.09741555f, 0.06115983f, -0.13731091f, 0.03913600f, 0.23932424f, -0.07957271f, 
    0.09909464f, 0.08856890f, 0.06516119f, -0.06162238f, 0.00947725f, -0.01065719f, 0.19914213f, -0.03580952f, 
    -0.27544984f, 0.03018914f, 0.05845399f, -0.10155141f, -0.03651643f, -0.02154299f, 0.00083406f, -0.05383565f, 
    -0.00347175f, 0.01100142f, -0.08314900f, 0.02371850f, 0.23452778f, -0.10075586f, -0.09849286f, 0.04854418f, 
    0.01463939f, 0.09994386f, 0.04903035f, 0.07515392f, 0.08605465f, 0.05306679f, 0.13093697f, -0.04702190f, 
    0.13097045f, -0.03246100f, -0.08888166f, -0.04876835f, 0.08618811f, 0.02420919f, 0.04745064f, 0.02273521f, 
    -0.08276038f, -0.06672253f, 0.06748561f, -0.02582339f, 0.04921030f, 0.07009675f, -0.10396883f, 0.11112960f, 
    0.06519146f, -0.05201465f, -0.17378472f, 0.13984308f, 0.01480556f, -0.04297644f, 0.05576782f, -0.06798651f, 
    -0.00443734f, 0.07027625f, -0.09098707f, 0.29768103f, 0.10430725f, -0.05261395f, -0.07376000f, 0.01376833f, 
    -0.00430830f, -0.04139028f, -0.14061473f, 0.09376169f, 0.05482044f, 0.11402050f, -0.23075794f, -0.09645166f, 
    0.03498222f, 0.12564822f, 0.05431991f, -0.08712783f, 0.04447081f, -0.04925255f, -0.01873528f, 0.04122977f, 
    0.19988780f, -0.08284168f, 0.03805542f, 0.17143832f, -0.07193528f, 0.03921846f, 0.13719314f, 0.02222959f, 
    0.03379436f, -0.00936112f, 0.11459044f, 0.09820189f, -0.02018426f, 0.02893984f, -0.14689721f, -0.24419747f, 
    -0.09291963f, 0.02421597f, -0.10155205f, -0.08147759f, -0.01222455f, 0.00049950f, -0.00484749f, -0.05937349f, 
    0.28575492f, -0.01853090f, 0.04150080f, 0.07630316f, -0.07295143f, -0.05345739f, 0.10849763f, 0.08300049f, 
    0.01266580f, 0.13337776f, -0.09032559f, -0.00940613f, -0.00650579f, -0.23748808f, -0.03032833f, 0.23870505f, 
    -0.09052213f, 0.07205612f, 0.08982931f, -0.08264758f, 0.09769746f, 0.09411256f, -0.01207139f, 0.15107885f, 
    -0.21823984f, 0.13837387f, 0.04939350f, -0.02931810f, 0.15553656f, 0.00962747f, 0.02352017f, 0.19490851f, 
    -0.04474517f, 0.10038907f, -0.04040347f, -0.08427554f, 0.14461108f, 0.02906792f, 0.00879115f, 0.12526104f, 
    -0.01050317f, -0.02538738f, 0.07969161f, -0.01990387f, -0.02703824f, -0.03668645f, 0.04362958f, -0.00941684f, 
    0.00078599f, 0.07502783f, 0.12243411f, 0.09833935f, 0.03960806f, -0.16484196f, -0.07462436f, -0.08311670f, 
    -0.09332979f, -0.10252828f, 0.01399175f, -0.01425862f, -0.05415291f, 0.07010401f, 0.43487364f, 0.52674741f, 
    -0.08036848f, -0.06468026f, -0.06412676f, 0.00367597f, -0.02461679f, 0.05819219f, -0.04810349f, 0.03323793f, 
    -0.06686971f, 0.15450267f, 0.09624918f, -0.01657930f, 0.14577287f, 0.02945900f, -0.03745305f, -0.08612175f, 
    0.12601469f, 0.05406739f, -0.00894515f, 0.07559192f, -0.06034366f, 0.12829709f, 0.09854034f, 0.12234083f, 
    0.13900320f, -0.03494951f, -0.09219643f, 0.06126895f, 0.01061926f, 0.02715802f, 0.04690152f, 0.08914559f, 
    0.25881776f, -0.13706008f, -0.28828070f, 0.09610406f, -0.03048784f, -0.02646017f, 0.05066296f, 0.02872482f, 
    -0.05392169f, -0.05656814f, 0.02161901f, -0.07321040f, -0.29637641f, 0.10767346f, 0.03247441f, -0.05438745f, 
    0.08707467f, -0.02551924f, 0.04433987f, 0.02380940f, 0.06078919f, 0.02664026f, 0.00891619f, 0.02436085f, 
    0.11254725f, 0.08542954f, 0.00184131f, 0.20237249f, -0.10810713f, -0.05924578f, 0.16520528f, 0.05686923f, 
    -0.10059831f, 0.03875105f, -0.01518509f, -0.08799253f, 0.21432647f, 0.22721633f, 0.03155941f, 0.24218081f, 
    0.10051028f, 0.09498587f, 0.07508987f, -0.17675652f, 0.07389263f, 0.14314385f, 0.02905023f, -0.04518414f, 
    0.19135812f, 0.17099421f, -0.08793300f, -0.02435045f, 0.04587179f, 0.09896263f, -0.02774234f, -0.02788078f, 
    0.00108039f, -0.00420354f, 0.02575772f, 0.04817349f, -0.04450378f, 0.09094568f, -0.11720415f, -0.00315976f, 
    0.06128166f, -0.05781109f, -0.01678788f, -0.01188009f, 0.07017455f, 0.07452731f, 0.05118874f, -0.08611035f, 
    -0.03517223f, 0.13126479f, 0.12633081f, 0.23070560f, 0.00141945f, 0.06011942f, -0.03602394f, -0.07230111f, 
    -0.00078572f, 0.02707729f, -0.12686144f, -0.02912235f, 0.12812577f, 0.11945904f, -0.02193499f, 0.00108370f, 
    -0.08126602f, -0.02751059f, 0.08413114f, -0.13088088f, -0.01738629f, 0.10202720f, 0.10268687f, -0.08573302f, 
    -0.10396274f, 0.07668060f, -0.01260950f, -0.07394437f, -0.10335242f, 0.04897382f, 0.03567307f, -0.09352557f, 
    0.04574854f, -0.04835148f, -0.03146394f, -0.03769077f, -0.52586794f, 0.14362198f, 0.01051277f, -0.12173108f, 
    -0.09761765f, 0.01614713f, -0.00732723f, 0.08315748f, -0.01676047f, 0.04789402f, -0.10335590f, 0.01946903f, 
    -0.29793146f, 0.23989840f, 0.01679301f, -0.19884516f, -0.00369456f, 0.00006577f, 0.03388926f, -0.23219550f, 
    -0.09015033f, -0.06778190f, -0.01581725f, -0.09769511f, 0.35795993f, 0.15940802f, 0.00944808f, -0.06989560f, 
    -0.07588960f, -0.00756246f, -0.05699925f, -0.14770988f, 0.00448229f, -0.08438101f, 0.01929538f, 0.04698181f, 
    -0.18568568f, 0.39081931f, 0.09992626f, -0.08902146f, 0.05898980f, 0.14634852f, 0.09019881f, 0.13637342f, 
    -0.02838756f, -0.00330054f, 0.06418366f, 0.01943644f, 0.16481230f, 0.13105480f, -0.07049353f, 0.15261608f, 
    -0.14247684f, -0.01266237f, 0.06732365f, 0.00937511f, 0.01397822f, 0.20960625f, 0.04923847f, 0.11081985f, 
    0.12749882f, 0.01642906f, 0.03953348f, -0.23456578f, -0.07841768f, 0.05553252f, -0.02279072f, 0.04443770f, 
    -0.04269837f, -0.08425151f, -0.13247557f, 0.09315943f, 0.16786636f, 0.05290204f, -0.17678763f, 0.07473683f, 
    0.08412526f, -0.11067416f, -0.07068472f, 0.16179259f, 0.07952468f, 0.05658555f, 0.03538902f, -0.04525944f, 
    0.13790624f, 0.02340364f, -0.05790599f, 0.29481712f, -0.03075158f, 0.03213422f, 0.11539084f, 0.03422906f, 
    0.00913474f, 0.07162654f, 0.17803383f, 0.08765401f, -0.22359529f, -0.12316754f, 0.12918045f, -0.05450451f, 
    0.02249935f, -0.18055235f, 0.07537723f, -0.02516873f, 0.05196529f, -0.03963244f, -0.03436129f, 0.17021446f, 
    0.08668943f, -0.07784405f, 0.12780105f, 0.08194809f, -0.07764523f, -0.07597791f, 0.07357137f, -0.01734585f, 
    0.06339941f, 0.11147073f, -0.17942625f, 0.13895863f, -0.10005050f, -0.13098606f, -0.00486930f, -0.01936971f, 
    -0.00525625f, 0.15088512f, 0.13104089f, -0.02257598f, -0.06633567f, 0.04512003f, 0.03425208f, 0.09660285f, 
    0.03482196f, -0.00021712f, 0.00516601f, -0.13205993f, -0.01033417f, 0.11188204f, 0.04361863f, -0.00282809f, 
    0.02997558f, -0.11067221f, 0.05418085f, -0.17386441f, 0.00462854f, -0.00436264f, 0.06425966f, -0.11964939f, 
    -0.07949302f, -0.20379660f, 0.08926329f, 0.08896700f, 0.01413788f, 0.15584576f, -0.04552151f, 0.15213279f, 
    -0.04706459f, 0.00530177f, -0.04199345f, -0.05289166f, -0.01002759f, -0.01291174f, -0.10314545f, 0.03258348f, 
    0.04883508f, 0.11007921f, -0.04128224f, -0.01266598f, -0.12453181f, 0.02201732f, 0.05606829f, 0.08443557f, 
    0.12173058f, 0.00637432f, 0.18543352f, 0.13150850f, 0.00632104f, 0.03318508f, 0.10469492f, 0.16150758f, 
    -0.04003605f, 0.06486502f, 0.11777143f, -0.11367168f, 0.15676965f, 0.00031951f, -0.07962969f, -0.01655969f, 
    0.01768607f, -0.04340005f, 0.23342042f, 0.18621990f, 0.25861394f, 0.20323496f, -0.04630845f, -0.03646379f, 
    -0.09334867f, -0.00690190f, -0.07535207f, 0.07112316f, -0.04517118f, -0.00478491f, 0.05530236f, -0.12739980f, 
    0.05274907f, -0.21101563f, -0.08001203f, 0.02520736f, -0.04693835f, -0.08456250f, -0.06431408f, -0.11537325f, 
    0.01984107f, -0.13187779f, 0.19661863f, 0.10195288f, -0.28186241f, 0.01644717f, -0.07580038f, 0.03638911f, 
    0.06601806f, 0.09418184f, 0.03295657f, -0.02603626f, -0.06596248f, -0.02717607f, -0.10203902f, -0.02340351f, 
    -0.01257190f, 0.02377233f, 0.02406782f, 0.12759265f, -0.02746502f, 0.16888294f, 0.09036396f, 0.02971915f, 
    0.13830754f, -0.03118622f, 0.02310207f, -0.09718475f, 0.25220913f, 0.12255978f, -0.14627694f, -0.44715503f, 
    0.09050740f, 0.03510289f, 0.01068704f, -0.05415845f, 0.01120570f, -0.00634671f, 0.08510362f, -0.05132951f, 
    -0.07737470f, -0.13479966f, -0.02934548f, 0.06534402f, -0.07695362f, -0.09466146f, 0.08710948f, 0.00085017f, 
    0.03347936f, 0.07784369f, -0.05785123f, -0.12812315f, -0.11421905f, 0.07033569f, -0.00738573f, 0.04989905f, 
    -0.12182271f, 0.09064592f, 0.12175919f, 0.03332227f, -0.01940218f, -0.04574089f, 0.02923554f, 0.05616244f, 
    -0.05355644f, 0.10612354f, 0.17972893f, -0.05002866f, 0.10942069f, -0.03057990f, -0.00602764f, 0.08894823f, 
    0.12734316f, -0.10977216f, -0.05971474f, -0.04627020f, 0.07802010f, 0.07935908f, -0.02571013f, 0.02760211f, 
    -0.05615867f, -0.04638113f, -0.07733663f, -0.03855493f, 0.03893618f, -0.03540763f, -0.06772807f, 0.16525389f, 
    -0.25759223f, 0.15307015f, 0.06963451f, -0.13175310f, 0.11087618f, 0.04579056f, -0.02276190f, -0.04171066f, 
    0.14707465f, 0.06359714f, -0.05783032f, -0.13944997f, -0.04640591f, -0.16066325f, 0.01066605f, -0.19908334f, 
    -0.11284691f, -0.08068927f, 0.04349540f, 0.06801669f, 0.05980257f, 0.06217952f, 0.02398947f, 0.13577925f, 
    -0.10566759f, -0.19438265f, 0.11614799f, -0.01219299f, -0.08116034f, 0.06237819f, 0.13888349f, 0.06243787f, 
    0.03869662f, 0.08183050f, 0.10837688f, 0.02176704f, 0.09266505f, -0.04176068f, -0.17304701f, 0.07788236f, 
    -0.04393546f, -0.00479551f, 0.11184660f, 0.16358644f, -0.02910486f, -0.10190352f, -0.05629361f, -0.08693816f, 
    -0.08393735f, -0.09180585f, 0.00060230f, -0.11730036f, 0.02055291f, 0.01362987f, -0.11082111f, 0.13040988f, 
    0.10439605f, 0.19161102f, 0.00002912f, 0.07309800f, -0.00734366f, 0.07935760f, 0.01472135f, -0.04258585f, 
    -0.05367516f, 0.05855168f, -0.03318524f, -0.04953976f, 0.01095846f, 0.15116921f, -0.05650928f, 0.03402369f, 
    0.25532541f, -0.13912816f, 0.06036035f, 0.20316720f, -0.01989984f, 0.12789249f, 0.09323716f, 0.13139881f, 
    0.04633456f, 0.18038699f, 0.10448802f, 0.07853342f, 0.25014970f, -0.01058483f, -0.09632215f, 0.02815792f, 
    0.12728857f, -0.02881128f, -0.05889275f, 0.00612384f, -0.12508209f, 0.01369446f, -0.07404492f, -0.02593368f, 
    0.23158805f, -0.12871438f, -0.09346254f, 0.18818784f, 0.00988483f, 0.04120761f, 0.17855451f, 0.24152894f, 
    0.04002425f, 0.12739390f, 0.08910432f, 0.10667503f, 0.16121572f, -0.04004761f, 0.12885873f, -0.12852564f, 
    -0.12407263f, 0.08319490f, 0.05657057f, 0.09926958f, -0.08627381f, 0.01313563f, -0.07983492f, -0.03795897f, 
    -0.03670647f, 0.03595373f, 0.02139419f, -0.01757834f, -0.05527179f, -0.02244440f, 0.02090620f, 0.03665846f, 
    -0.00249399f, 0.01888241f, -0.03834433f, -0.00100774f, -0.05188943f, 0.01898837f, 0.03542001f, -0.04834726f, 
    -0.04366699f, 0.04158898f, -0.00174268f, 0.03919998f, -0.00852875f, -0.01677116f, 0.00506461f, 0.00484170f, 
    -0.00570087f, -0.02274599f, 0.02644575f, -0.05163499f, -0.03879218f, 0.01752611f, -0.02167184f, 0.00595989f, 
    -0.02847038f, -0.03863019f, 0.02749492f, 0.00519344f, -0.01790920f, 0.03162999f, -0.01105745f, 0.00690729f, 
    0.01401391f, -0.03152376f, -0.02366481f, 0.02660173f, 0.01736332f, 0.01601937f, -0.04838938f, -0.01213321f, 
    -0.03346365f, -0.04960692f, -0.05200966f, 0.01355370f, 0.01270790f, -0.01569786f, -0.05381905f, 0.03496070f, 
    0.02596929f, 0.00723753f, -0.01687964f, -0.05384364f, -0.04432951f, -0.04700044f, 0.02124261f, -0.00874591f, 
    -0.03592400f, 0.00154504f, -0.04534979f, 0.02578993f, -0.01492006f, 0.01509858f, 0.01059238f, 0.02391098f, 
    0.00238692f, 0.01525775f, -0.05253625f, -0.00591940f, 0.02193041f, 0.01537294f, 0.00383443f, 0.02626162f, 
    -0.02192974f, -0.00597942f, -0.01223486f, -0.01624369f, -0.05458672f, -0.03032624f, -0.00991737f, 0.00042831f, 
    -0.02169117f, -0.04244072f, 0.02373948f, 0.02132394f, 0.03082473f, -0.00865634f, 0.00957197f, -0.01293446f, 
    0.01632621f, 0.03352427f, -0.03153682f, 0.01986163f, -0.03906187f, 0.02195414f, 0.03848395f, 0.01927702f, 
    0.01285587f, 0.03099732f, 0.00594230f, -0.02544069f, 0.04151844f, -0.00066295f, -0.05879222f, -0.04649599f, 
    0.00395580f, 0.04307910f, -0.04504074f, -0.01336394f, 0.03102376f, 0.00250259f, -0.01218196f, 0.01853601f, 
    -0.02927482f, -0.04453758f, 0.03853001f, -0.03452680f, 0.00110054f, -0.02430914f, -0.02555382f, 0.03682915f, 
    0.01947726f, 0.02882271f, -0.04029089f, -0.04482211f, -0.04137702f, -0.02200407f, -0.02826619f, -0.02515370f, 
    -0.01012766f, -0.02475301f, 0.01245362f, -0.02744620f, 0.01690648f, 0.02821419f, -0.02073159f, -0.02905577f, 
    -0.05330418f, -0.04868084f, 0.00556903f, 0.01847604f, -0.00380608f, 0.03192872f, -0.03236577f, -0.00316287f, 
    -0.05009262f, -0.00136482f, -0.05309511f, 0.00424790f, -0.02820049f, -0.05411332f, 0.00416106f, -0.03281227f, 
    0.02769436f, -0.05041111f, -0.03882360f, 0.00377887f, 0.02144181f, 0.03492907f, 0.01968349f, -0.00044343f, 
    0.04270282f, 0.04405429f, -0.05601303f, 0.04162965f, 0.04665368f, -0.03754962f, -0.01040454f, -0.04443214f, 
    -0.04748036f, -0.01420223f, 0.01605942f, 0.00964090f, -0.04402506f, -0.05345947f, -0.03949744f, 0.03226016f, 
    -0.05073887f, 0.03619868f, 0.01551905f, 0.04024604f, 0.01365027f, -0.01926717f, -0.01934850f, -0.05173459f, 
    -0.02518550f, 0.02385937f, 0.01283657f, 0.00240251f, -0.03220506f, -0.01708206f, -0.01858993f, 0.03821981f, 
    -0.02911520f, 0.03485981f, -0.00789426f, -0.05572778f, -0.02172024f, -0.00190195f, -0.03627170f, 0.03891201f, 
    -0.00244815f, 0.00200296f, -0.01714916f, -0.00868712f, 0.03345639f, -0.04622649f, -0.01670536f, -0.04947311f, 
    0.03482882f, -0.00506689f, -0.05319412f, -0.04109194f, -0.04601670f, 0.01789796f, -0.03951829f, -0.03682069f, 
    0.01556566f, 0.01284895f, -0.04127081f, -0.05483218f, 0.01984850f, -0.01225732f, 0.01240014f, 0.02916098f, 
    0.01252111f, -0.00342922f, -0.04952506f, -0.02809781f, 0.03943765f, 0.02825011f, -0.00822005f, -0.03098017f, 
    0.03168949f, -0.03815642f, -0.04307107f, -0.05982788f, -0.00140260f, -0.03944924f, 0.00631118f, 0.01980068f, 
    -0.00380236f, 0.02218460f, 0.04269952f, -0.02680410f, -0.04424915f, -0.00583629f, -0.01611980f, -0.04632996f, 
    0.03083027f, 0.03130837f, 0.02593591f, 0.02086427f, -0.05744987f, 0.00817170f, 0.03019885f, -0.02256349f, 
    0.00040599f, 0.01418095f, 0.03112293f, -0.00680891f, -0.04056925f, -0.05282170f, -0.05743410f, 0.01047893f, 
    -0.01008676f, 0.00443533f, -0.00161000f, 0.02080110f, -0.01349013f, -0.01517567f, 0.04130069f, 0.04979780f, 
    0.04193150f, 0.00639525f, 0.02795133f, -0.04967253f, 0.03712342f, 0.02961439f, -0.01945170f, -0.01712678f, 
    -0.00818594f, -0.00561434f, 0.04029581f, -0.01530163f, 0.01338301f, -0.00882500f, -0.03689977f, -0.02770111f, 
    -0.03097518f, -0.00948313f, 0.03458190f, 0.02954708f, 0.01109953f, -0.00883927f, 0.01065236f, -0.03924395f, 
    -0.05352290f, 0.01411461f, -0.04744579f, -0.02348015f, -0.03330928f, -0.02601558f, 0.00512877f, -0.04024453f, 
    -0.04320128f, -0.05531693f, 0.00468897f, 0.03607586f, 0.02340779f, -0.02205906f, -0.05573267f, 0.03204994f, 
    0.01822260f, 0.01731334f, -0.00938959f, 0.01914866f, 0.03367494f, -0.03796691f, 0.01457401f, -0.02135188f, 
    -0.05677576f, -0.02196064f, -0.02044534f, -0.05375798f, -0.04089076f, 0.00078991f, -0.05168388f, 0.00041304f, 
    -0.05215946f, 0.04023535f, -0.04844878f, 0.02306417f, -0.00114590f, -0.00405996f, 0.03932252f, 0.00571504f, 
    -0.04657192f, 0.01344462f, -0.02707177f, -0.00880648f, -0.04413864f, 0.03162628f, 0.02901985f, -0.03761072f, 
    -0.05028309f, -0.00896660f, -0.01145609f, 0.01406116f, 0.03216436f, 0.04205760f, 0.01312190f, -0.01488123f, 
    -0.01791592f, 0.02961067f, 0.01232902f, 0.01419025f, 0.02856186f, -0.02793231f, 0.01023740f, -0.01809561f, 
    -0.01224565f, 0.00202154f, 0.00248521f, 0.01906452f, 0.00035753f, -0.03443260f, -0.01245667f, 0.01637284f, 
    -0.00602339f, -0.03197818f, 0.04305445f, 0.03628840f, 0.01942806f, 0.01998103f, 0.01279392f, -0.04168896f, 
    0.00152852f, -0.02483353f, -0.03538373f, 0.04283228f, 0.03148061f, -0.05670581f, -0.04950131f, -0.02640472f, 
    0.04096308f, -0.03141768f, 0.03756545f, 0.03832050f, -0.01317785f, 0.02162715f, 0.00409340f, 0.02003908f, 
    -0.05749381f, -0.03423731f, -0.01258099f, 0.03133907f, 0.00564808f, 0.00863564f, -0.03338839f, 0.02919482f, 
    -0.00167202f, -0.04318321f, -0.00745850f, 0.01629036f, -0.05606511f, -0.00448523f, -0.03347500f, 0.01104910f, 
    0.01394602f, -0.04132343f, 0.01155854f, -0.01900924f, -0.01619529f, -0.01850584f, 0.02484269f, -0.01741674f, 
    -0.00911412f, -0.02457349f, 0.01983949f, 0.02190870f, 0.03206995f, 0.03701850f, 0.02183229f, 0.02143508f, 
    -0.00373467f, 0.02885359f, 0.00234794f, 0.01350242f, -0.05123306f, 0.04009562f, 0.00827510f, 0.01350965f, 
    -0.00755532f, -0.00898550f, -0.02436803f, -0.04907888f, 0.04062633f, -0.03872802f, 0.03873270f, 0.01612374f, 
    -0.00355812f, 0.03118142f, -0.03781110f, -0.00023803f, -0.05343292f, 0.04310527f, 0.03134728f, -0.04665868f, 
    0.03765773f, -0.00976112f, 0.00856949f, -0.04417230f, 0.03821184f, -0.02666825f, -0.02436271f, 0.01658040f, 
    0.02506685f, -0.05187875f, -0.04101086f, -0.02302748f, -0.05005799f, 0.00715582f, -0.04294266f, 0.02651437f, 
    -0.05412969f, -0.03357241f, -0.04587074f, -0.02227736f, -0.00755163f, -0.05192775f, -0.00681312f, 0.00623788f, 
    -0.01852206f, 0.00057495f, -0.00234548f, -0.04917347f, -0.01716583f, 0.02475234f, 0.00187975f, -0.03203198f, 
    -0.00958684f, -0.03825936f, -0.02996037f, -0.03940499f, 0.02327584f, -0.05500819f, -0.05422760f, -0.04402829f, 
    -0.05779021f, 0.02675869f, -0.04908394f, 0.00818405f, -0.05103359f, -0.02274076f, -0.03144867f, 0.03197962f, 
    0.02567388f, -0.01916604f, 0.02117557f, -0.04347748f, -0.03331426f, 0.00841837f, -0.04377437f, -0.02923958f, 
    0.00010353f, 0.01830294f, 0.04243813f, 0.01230122f, 0.01715501f, -0.04160875f, -0.00373617f, -0.03391556f, 
    -0.02530424f, -0.03421433f, 0.01089877f, -0.03791143f, 0.01188312f, -0.03195868f, 0.02015747f, 0.00386329f, 
    -0.01941841f, 0.03907351f, -0.01651777f, 0.02403612f, -0.02722575f, 0.00627795f, 0.00010687f, 0.02117710f, 
    -0.02830159f, 0.02427365f, 0.04152052f, -0.02753301f, -0.04041076f, -0.01575490f, 0.02622074f, -0.05093693f, 
    -0.00744772f, -0.05140801f, 0.04387453f, 0.02375676f, 0.01738756f, 0.04300062f, -0.04417017f, -0.04728352f, 
    -0.03712471f, 0.03627056f, -0.00386779f, -0.01118829f, 0.01908723f, -0.05165901f, 0.04033051f, -0.00412767f, 
    -0.04430433f, -0.01890040f, 0.00609245f, -0.04104190f, -0.01247509f, 0.01446964f, -0.04481157f, 0.01028985f, 
    -0.00396715f, 0.01207074f, 0.03634709f, -0.03319374f, 0.03353705f, -0.00512463f, 0.02229208f, 0.03964940f, 
    -0.01364275f, 0.03363420f, -0.01066007f, -0.03060502f, -0.04015619f, -0.02578825f, 0.02327214f, 0.03126526f, 
    0.00260146f, -0.01103031f, -0.03250706f, -0.05540489f, 0.03580781f, 0.03940205f, -0.01613029f, -0.04679701f, 
    -0.02959459f, 0.04149217f, -0.02555043f, -0.04605871f, -0.04785302f, 0.02038695f, -0.02999539f, 0.01887640f, 
    -0.01649340f, -0.01708321f, -0.01747681f, -0.01965749f, -0.03651151f, -0.01538251f, -0.01927463f, -0.01115315f, 
    -0.05308357f, 0.00462842f, 0.04387845f, -0.04410819f, 0.01274829f, -0.05503617f, -0.01619327f, 0.00105498f, 
    0.00657354f, 0.02346141f, 0.00179191f, -0.03260309f, 0.04261342f, -0.00005502f, -0.01762380f, 0.02652172f, 
    -0.01259118f, -0.04412186f, -0.02334632f, -0.05607346f, -0.03175998f, -0.04655319f, -0.04592722f, -0.01349034f, 
    -0.04616179f, -0.05597199f, -0.05722214f, -0.00083240f, -0.00672424f, -0.00078325f, 0.00332068f, -0.01572281f, 
    0.01849921f, -0.03444859f, 0.01388243f, 0.03232739f, 0.04126774f, -0.04740031f, -0.03222660f, 0.00692046f, 
    0.01046910f, -0.00082118f, 0.02091921f, 0.02614996f, -0.04549905f, 0.03204286f, -0.04078227f, -0.02352000f, 
    -0.03944418f, 0.02024309f, -0.01331939f, 0.01879110f, -0.04115322f, 0.02238862f, -0.01142458f, -0.03993413f, 
    -0.02661079f, -0.02472902f, 0.02911124f, -0.02047548f, 0.02786201f, -0.02184193f, -0.05532048f, -0.03834617f, 
    -0.01830553f, -0.04947790f, -0.02605834f, -0.01659227f, -0.02035624f, -0.01246223f, 0.03630318f, -0.05226042f, 
    0.02943173f, 0.04169618f, -0.04012792f, 0.01273502f, 0.00015946f, -0.05548528f, -0.03197121f, -0.00114135f, 
    -0.02302495f, -0.05143227f, 0.04211618f, -0.02357196f, -0.05367699f, 0.03582842f, -0.04101864f, 0.01458767f, 
    -0.02599444f, -0.02239262f, 0.02438518f, -0.01528936f, 0.00303777f, 0.02759997f, 0.02335223f, -0.01048750f, 
    -0.01787061f, -0.04646708f, 0.03541738f, 0.00368577f, 0.03693274f, 0.00561438f, -0.04158398f, 0.02557901f, 
    0.03041584f, -0.04335633f, -0.02135617f, 0.01530992f, -0.00731383f, 0.04361965f, -0.05798183f, -0.00481783f, 
    -0.04747072f, 0.02014548f, -0.02725572f, -0.04727170f, -0.02892254f, -0.02742591f, 0.01855388f, -0.01996901f, 
    -0.05531126f, -0.00021322f, -0.01080824f, -0.01173278f, -0.00057439f, -0.03382119f, 0.01473288f, -0.02609402f, 
    0.02477518f, 0.00419666f, -0.01449858f, -0.01344081f, -0.04037223f, -0.05033429f, 0.03942501f, -0.02234561f, 
    -0.01588603f, -0.02318378f, -0.01578283f, -0.05221011f, -0.03551460f, 0.00619598f, -0.05261325f, 0.02084289f, 
    0.01301300f, 0.01379350f, 0.02887643f, -0.04478551f, -0.02758303f, -0.01057558f, -0.03827171f, -0.02893593f, 
    -0.03962678f, 0.02885376f, 0.03222200f, -0.05358930f, 0.02659455f, -0.01494472f, -0.01907970f, 0.00654666f, 
    0.37303162f, 0.05415381f, 0.13133731f, -0.01078990f, -0.10058502f, 0.02408423f, 0.13459311f, 0.12817381f, 
    0.07518096f, -0.05078589f, -0.02951082f, -0.03609690f, -0.09057578f, -0.07285758f, -0.22774132f, -0.14004497f, 
    -0.03654379f, 0.06367137f, 0.07437778f, -0.01339109f, -0.04390214f, 0.16544893f, 0.03664559f, 0.01388402f, 
    -0.01974442f, -0.10764767f, 0.06334434f, -0.07469443f, -0.03530474f, 0.15091635f, 0.03357672f, 0.09870450f, 
    -0.15456234f, -0.07478692f, -0.14574194f, 0.07590421f, 0.14011091f, 0.05622447f, 0.18679693f, 0.21999332f, 
    -0.01918863f, -0.04025253f, -0.02888948f, 0.11311001f, 0.10514960f, -0.05715524f, 0.06653345f, -0.00995712f, 
    0.13922258f, -0.05013587f, -0.08114432f, -0.15958835f, -0.04871306f, 0.06714011f, 0.15392482f, -0.01395095f, 
    0.03076257f, 0.06314775f, 0.13549274f, 0.23271869f, -0.26829815f, 0.03171204f, 0.26809460f, 0.32221773f, 
    0.06099091f, -0.08026309f, 0.08876470f, 0.08265945f, -0.00592935f, -0.05393844f, 0.09520353f, 0.22335370f, 
    0.03150020f, 0.02422458f, -0.04797542f, -0.18200371f, -0.07697216f, 0.03783011f, 0.04815027f, 0.22445844f, 
    -0.09137176f, 0.02613585f, -0.18565986f, -0.09355555f, -0.17710614f, -0.24580236f, 0.32816553f, 0.14490633f, 
    -0.08488584f, 0.12334750f, 0.17420904f, -0.08178556f, -0.12990703f, 0.02182790f, 0.00519648f, 0.02088074f, 
    0.10777196f, -0.01535473f, 0.06920575f, 0.05000073f, 0.02188105f, 0.00415754f, -0.05076336f, -0.05828359f, 
    -0.04455961f, -0.03564992f, -0.01941808f, -0.16132042f, -0.09836621f, -0.06074612f, 0.03387237f, 0.22758767f, 
    -0.09378973f, -0.12526554f, 0.14845254f, 0.05086626f, 0.01681049f, 0.32251626f, -0.11052494f, 0.15829718f, 
    0.11132953f, 0.16405919f, -0.03038754f, 0.09654329f, -0.02924976f, 0.01443725f, -0.12866859f, -0.05872266f, 
    0.04260568f, 0.18487684f, -0.01887372f, 0.05745145f, -0.25959241f, 0.03072570f, 0.06064643f, 0.10924514f, 
    0.04455780f, -0.07282643f, 0.24299742f, 0.25735754f, 0.07698181f, 0.13351403f, 0.13123597f, -0.02345122f, 
    0.06056718f, 0.13045029f, -0.06193236f, -0.00513895f, 0.00389627f, 0.00261727f, -0.12367119f, -0.00635024f, 
    -0.03123737f, 0.03532819f, 0.19592577f, 0.20305698f, -0.22743991f, 0.22047077f, -0.17651169f, -0.27528423f, 
    0.11481728f, 0.04657877f, -0.10404931f, 0.02487986f, -0.04773266f, -0.00994606f, -0.18947633f, -0.07800147f, 
    0.25267261f, -0.13953429f, -0.03350608f, 0.18248606f, -0.02340054f, -0.13778278f, -0.11980696f, -0.06508599f, 
    -0.16913435f, 0.00113491f, 0.22672772f, -0.01362998f, 0.22241038f, 0.08140650f, 0.06268335f, 0.00076353f, 
    -0.04543278f, 0.11783263f, -0.07668173f, 0.00759374f, -0.01637969f, 0.04883512f, 0.03459449f, -0.12692678f, 
    0.22511426f, -0.03643291f, -0.13783798f, 0.15994357f, -0.07426929f, 0.03822440f, 0.01854482f, -0.11287344f, 
    -0.01221551f, -0.11633956f, -0.04012245f, -0.13788314f, 0.22804634f, -0.10425474f, -0.34556165f, -0.02042097f, 
    -0.00107750f, -0.07118052f, -0.06895036f, -0.10617740f, -0.02477629f, -0.06338248f, -0.00970997f, -0.07752802f, 
    0.21386980f, 0.02108748f, 0.04892880f, -0.07660183f, -0.04250756f, -0.10516148f, -0.07437481f, 0.00368015f, 
    0.03786900f, 0.11158554f, 0.01398205f, -0.12873687f, 0.38036698f, -0.03363014f, 0.08016925f, 0.00939982f, 
    0.02610688f, 0.08258409f, 0.07178066f, -0.03087062f, -0.03069879f, 0.07759027f, -0.02419085f, 0.04865073f, 
    -0.15230040f, 0.13577785f, -0.00904167f, -0.28139892f, 0.05627647f, 0.02433539f, -0.06566887f, -0.06891774f, 
    0.02222153f, -0.08174771f, 0.09415033f, -0.06093764f, 0.21095751f, 0.02748278f, 0.07550298f, 0.22732875f, 
    0.10641816f, 0.02895992f, -0.06402436f, 0.00111072f, -0.04153288f, 0.13397308f, -0.10579209f, 0.11696858f, 
    0.01293380f, -0.15308517f, 0.24433817f, -0.08885868f, -0.00631177f, -0.00439724f, -0.03215783f, 0.07217709f, 
    -0.00719503f, 0.15501487f, 0.02059373f, -0.21267994f, 0.13815892f, 0.15675953f, -0.08158123f, 0.26494828f, 
    -0.04528879f, -0.04846391f, -0.03048170f, 0.03260517f, -0.01648060f, 0.24540037f, -0.04184110f, 0.08346666f, 
    -0.04784485f, -0.24825968f, 0.20913959f, 0.15447749f, -0.01986335f, 0.05296119f, 0.15245368f, 0.13519721f, 
    0.05127431f, 0.14004840f, 0.13730928f, 0.09573431f, 0.28244984f, -0.01436701f, 0.11048853f, 0.11949509f, 
    -0.11527711f, 0.12199436f, -0.00483981f, -0.04332529f, -0.07437637f, 0.00770766f, -0.04043160f, -0.17040120f, 
    0.23042233f, -0.07375033f, 0.08534618f, -0.23570134f, 0.00343817f, 0.18367197f, -0.18723401f, 0.13582300f, 
    0.02024829f, 0.07218185f, -0.06623588f, 0.09550308f, 0.09703492f, -0.12309941f, -0.14591731f, 0.11307931f, 
    0.00726064f, -0.04065381f, -0.07271320f, -0.07035822f, -0.05789166f, 0.06713658f, 0.10875131f, 0.03421851f, 
    -0.26668760f, 0.03850477f, -0.07844613f, -0.25155309f, 0.14011665f, 0.03029233f, 0.19645894f, 0.02528948f, 
    -0.07412345f, 0.07719010f, 0.03067736f, 0.01113448f, 0.38022196f, -0.23567936f, -0.00747119f, 0.00966272f, 
    -0.02626510f, 0.04519809f, 0.01645381f, 0.04703864f, -0.11550073f, -0.02926669f, 0.01032332f, 0.02288089f, 
    0.06734738f, -0.18309017f, 0.03475714f, 0.11193470f, -0.07082932f, -0.07213569f, 0.16842766f, 0.18789299f, 
    0.05319969f, 0.05105199f, 0.08907530f, 0.10904769f, 0.17026067f, -0.04095232f, 0.22580042f, 0.15933286f, 
    -0.06492242f, 0.11148927f, 0.17236939f, 0.08924655f, -0.09927693f, 0.06695390f, -0.01375515f, 0.06345616f, 
    0.31577963f, -0.22930028f, -0.03110484f, 0.03786572f, 0.09568304f, 0.02761412f, -0.03529842f, -0.08125267f, 
    0.05586223f, 0.10740560f, -0.16298851f, -0.01041459f, -0.09365760f, -0.12883198f, -0.02802406f, -0.00249069f, 
    0.12496602f, 0.04480743f, -0.00627962f, -0.13415851f, -0.03872961f, -0.08867724f, -0.01597508f, 0.09998962f, 
    -0.00272477f, 0.12187441f, -0.03009206f, -0.00555846f, 0.03452529f, 0.04756021f, 0.00088135f, 0.00003861f, 
    -0.02214175f, 0.10102510f, 0.09213424f, -0.00853506f, 0.08157725f, -0.05364708f, -0.03703593f, 0.15371548f, 
    -0.06477457f, 0.09161840f, 0.02464654f, -0.01998115f, -0.03567753f, 0.05820971f, -0.18089013f, 0.03889716f, 
    0.10501680f, 0.05939737f, -0.04596853f, -0.07431871f, 0.07249721f, -0.16830221f, -0.14671341f, -0.11215618f, 
    0.03422360f, 0.11931685f, 0.07380852f, -0.01094397f, 0.12736632f, 0.19540910f, -0.04269675f, -0.09978684f, 
    0.02613135f, 0.08226530f, -0.04029565f, 0.08677164f, -0.01877875f, 0.05785646f, -0.03024195f, -0.06471485f, 
    -0.06880534f, 0.21771194f, -0.03674879f, 0.16813634f, -0.11895955f, 0.16492747f, 0.00938042f, -0.07658675f, 
    -0.01669173f, 0.00722771f, 0.25655839f, 0.00462490f, -0.11265114f, -0.08215231f, 0.09495479f, 0.11761451f, 
    0.09305469f, 0.05060223f, 0.07723738f, 0.02223495f, 0.00478651f, -0.00227913f, -0.02072348f, -0.00494913f, 
    -0.00691061f, 0.17261334f, 0.15579940f, -0.13604008f, -0.04533002f, -0.08670340f, 0.00017841f, -0.09195229f, 
    -0.03655541f, 0.12851062f, 0.00517890f, 0.22894567f, -0.03916975f, 0.03294168f, 0.17643571f, -0.01463563f, 
    -0.03672408f, 0.15032126f, -0.12602246f, 0.02012356f, 0.03163394f, -0.09854601f, 0.11835250f, -0.01361236f, 
    0.16213530f, -0.04849808f, 0.03247663f, 0.01523113f, 0.08747327f, 0.05475380f, 0.05398449f, -0.07080275f, 
    -0.05565078f, 0.03687186f, 0.03234914f, -0.09543917f, 0.10877205f, 0.17057441f, 0.09130222f, 0.02017694f, 
    -0.03388016f, 0.07338792f, -0.15912493f, -0.01752931f, 0.05330711f, 0.06396852f, -0.08110786f, -0.00035581f, 
    -0.07209934f, -0.04785130f, -0.03687290f, 0.10947383f, -0.02581565f, 0.14272401f, 0.03456920f, -0.04603881f, 
    0.06808963f, -0.02254368f, -0.11632168f, -0.15805525f, -0.40284291f, -0.24067448f, 0.11403927f, 0.07503080f, 
    0.15266678f, 0.05793038f, -0.10076819f, -0.10583082f, 0.02212072f, 0.00560928f, -0.00037409f, -0.00749971f, 
    0.38209608f, -0.08369454f, -0.03233072f, 0.13934658f, -0.07403812f, 0.00942911f, 0.10105155f, 0.04135803f, 
    0.04076186f, 0.11264280f, -0.17790082f, -0.03201286f, 0.10160037f, 0.04742081f, 0.06183198f, -0.12730639f, 
    0.11606583f, -0.04509855f, 0.03546458f, 0.05985793f, -0.01042630f, -0.00093685f, 0.04640275f, 0.11199479f, 
    0.19358677f, -0.05568649f, -0.00697446f, -0.07560837f, 0.05588491f, 0.08724094f, -0.07564938f, 0.00943380f, 
    -0.02348091f, 0.18356876f, 0.05877749f, 0.19970073f, 0.20384270f, 0.03431773f, -0.13790973f, -0.14769751f, 
    0.07489347f, 0.10285776f, 0.01786261f, -0.00662561f, 0.04232902f, 0.04029430f, 0.02352958f, 0.00255708f, 
    0.35376164f, -0.02498635f, 0.00168442f, -0.08797683f, -0.15373750f, 0.03212767f, -0.02776863f, 0.06039785f, 
    0.01116081f, -0.09282719f, -0.00221105f, 0.04988863f, 0.24491338f, -0.12053409f, -0.04145546f, -0.18562268f, 
    0.08930905f, -0.00336033f, 0.09490523f, -0.09111755f, -0.01360009f, 0.12657878f, -0.08562826f, -0.00854575f, 
    -0.29429942f, -0.13756819f, -0.02859283f, -0.02769339f, 0.07101190f, 0.10204457f, 0.05860914f, -0.07978141f, 
    -0.06217453f, 0.06467256f, 0.08791900f, 0.15011486f, 0.52719492f, -0.17288102f, 0.12883671f, 0.06411242f, 
    0.05286647f, 0.02512606f, 0.00105205f, 0.02089945f, -0.09650262f, 0.07191029f, 0.01309442f, -0.11403634f, 
    -0.15797560f, -0.19764608f, -0.02865900f, -0.03906307f, 0.06680503f, 0.12165141f, -0.04741939f, 0.12162240f, 
    -0.00218673f, -0.13287853f, 0.10278096f, 0.13065670f, 0.00031033f, -0.18287128f, 0.03121328f, 0.07763737f, 
    -0.02338162f, 0.14685069f, 0.02053926f, 0.08262172f, -0.00192633f, -0.08269264f, -0.05923312f, 0.10796572f, 
    -0.19961977f, 0.16715969f, 0.04783964f, 0.02698592f, 0.14302452f, 0.03970650f, 0.02238588f, 0.02977660f, 
    0.09578984f, -0.06334130f, -0.08933944f, -0.01085778f, 0.02300989f, -0.05246794f, 0.24070635f, 0.16443709f, 
    0.06283305f, -0.01617131f, 0.00688224f, -0.07280976f, -0.03082360f, 0.06717512f, 0.07834043f, 0.12164089f, 
    0.13353197f, 0.13645916f, 0.08586503f, -0.06111683f, 0.01301102f, -0.06826329f, 0.14738786f, 0.04512141f, 
    0.04752119f, -0.14251947f, 0.13452971f, -0.18512903f, -0.08306180f, -0.10275660f, -0.00171169f, -0.02522389f, 
    0.18713859f, 0.01825847f, 0.05655470f, 0.03736152f, -0.06608572f, -0.00718361f, 0.02813401f, 0.18900554f, 
    -0.17551720f, -0.17948894f, -0.01964085f, -0.03415887f, 0.04993951f, -0.06505910f, -0.05474434f, -0.08071782f, 
    -0.07978509f, -0.06675392f, 0.00028039f, -0.10660779f, 0.22466968f, -0.11530573f, 0.06988751f, -0.04009892f, 
    -0.00497006f, -0.01700949f, 0.05511212f, -0.04108725f, 0.21437214f, 0.10843706f, 0.19856372f, 0.20213448f, 
    0.12709820f, -0.03497376f, 0.01869769f, 0.03645856f, -0.01473979f, -0.03036028f, -0.17544243f, -0.03301500f, 
    0.02062208f, 0.06892519f, -0.08016105f, -0.07590271f, -0.45863891f, 0.15447672f, 0.10285939f, -0.02510633f, 
    0.08390540f, -0.11509819f, 0.01603327f, -0.02610909f, 0.04160789f, -0.06975656f, 0.16036291f, 0.02778241f, 
    -0.03428616f, 0.19643064f, 0.29301852f, -0.04540930f, -0.05208525f, 0.00976197f, 0.09320957f, 0.23558487f, 
    0.10488324f, -0.08348592f, 0.05401360f, -0.04199281f, -0.36242092f, -0.02588038f, -0.08094674f, -0.19425313f, 
    -0.14799760f, -0.02966686f, -0.08382598f, 0.04212078f, 0.00610738f, 0.19107413f, -0.07040565f, 0.11040953f, 
    0.29874876f, 0.05741824f, -0.00709276f, 0.20192973f, -0.03505531f, 0.28527793f, -0.08979247f, 0.21316467f, 
    -0.00860503f, 0.00421781f, -0.05031721f, 0.02928466f, 0.30058175f, 0.06445952f, 0.10652217f, 0.27612242f, 
    -0.00426233f, -0.02293751f, 0.04488893f, -0.00137871f, 0.05462342f, 0.15870745f, 0.05629849f, -0.01902593f, 
    0.16316670f, -0.11679795f, 0.05405083f, -0.29797044f, 0.09537066f, -0.05061572f, 0.09874807f, -0.00932608f, 
    -0.07708485f, 0.01692265f, 0.10465859f, 0.08208612f, -0.11892594f, -0.29167068f, -0.02942928f, 0.08434650f, 
    -0.04573607f, 0.15958796f, -0.00049007f, -0.04032165f, 0.09218208f, -0.06933248f, -0.02137900f, 0.09956858f, 
    0.14953783f, -0.05864395f, 0.13164327f, -0.06508669f, 0.10308535f, -0.08128156f, 0.10055169f, 0.04437758f, 
    0.04244060f, 0.08659755f, -0.15082866f, 0.03220595f, 0.10079734f, 0.00837472f, 0.10952031f, 0.40624374f, 
    0.13998556f, 0.21143205f, 0.04773029f, 0.05938213f, 0.06128397f, 0.03182897f, -0.00181126f, 0.10309329f, 
    0.27957970f, 0.06937699f, -0.19408076f, -0.04483354f, 0.08541322f, 0.06831180f, -0.09027522f, -0.03891502f, 
    -0.13214827f, -0.07236915f, -0.20074014f, -0.15739623f, -0.13239251f, -0.17958003f, -0.04933399f, -0.35279438f, 
    -0.26285094f, -0.06894194f, 0.01590533f, -0.01470829f, 0.06682144f, 0.19034424f, -0.02336585f, 0.15404746f, 
    0.06918778f, 0.16355327f, 0.05835132f, -0.09083425f, 0.01102024f, -0.03949784f, 0.05529113f, -0.06641471f, 
    0.28512815f, 0.18619627f, 0.05532178f, 0.11255785f, -0.32742086f, -0.04573777f, -0.01852816f, 0.03758403f, 
    -0.04808240f, 0.04432787f, 0.05536698f, 0.16172147f, 0.15082338f, 0.00313352f, 0.12549210f, 0.00455727f, 
    -0.00012716f, 0.14560799f, 0.21103741f, 0.08455832f, -0.03482423f, 0.13197218f, -0.11516313f, -0.02759239f, 
    0.03370825f, 0.10714664f, 0.24386360f, 0.12607446f, -0.07309683f, 0.08244927f, -0.15113778f, -0.48505527f, 
    0.14494556f, 0.00734129f, -0.00601762f, 0.03517165f, -0.03226006f, -0.06605633f, 0.05850235f, -0.07547149f, 
    -0.00572694f, -0.27356642f, -0.23087870f, -0.12855048f, 0.07240869f, -0.02323780f, -0.02621449f, -0.16058648f, 
    -0.06894311f, -0.06212699f, 0.11590850f, -0.06834473f, -0.04366966f, 0.11142343f, 0.40442240f, -0.13113789f, 
    0.12947322f, 0.08629037f, 0.06147376f, 0.11303799f, -0.09257898f, -0.03657633f, -0.02191185f, -0.02276691f, 
    0.08554801f, 0.12736535f, -0.01257024f, 0.14851955f, -0.05124449f, 0.08932116f, 0.08750991f, -0.05927436f, 
    0.07868200f, -0.01673024f, -0.07672976f, -0.03970515f, 0.25495240f, 0.00363288f, -0.07140762f, -0.07337534f, 
    -0.02289395f, 0.02147391f, 0.05367856f, 0.05740019f, 0.03341108f, 0.04306990f, 0.04860101f, 0.04456455f, 
    -0.07925878f, 0.06076297f, 0.02806763f, -0.00657783f, -0.03152294f, -0.14399771f, 0.10206410f, 0.02713824f, 
    0.02337040f, 0.03340393f, 0.08781805f, -0.02077075f, 0.09550154f, -0.07101267f, 0.07618140f, 0.04165400f, 
    0.02534626f, 0.05906747f, -0.01372108f, 0.02014207f, -0.03396016f, 0.11796596f, 0.03136757f, 0.13601565f, 
    0.00365228f, 0.18574478f, 0.01041783f, -0.28303781f, 0.19476828f, 0.06451355f, -0.04208874f, -0.02015939f, 
    0.04319952f, -0.04565400f, -0.05641486f, -0.01823737f, 0.00349348f, -0.12348194f, -0.08939871f, -0.01021994f, 
    0.04197418f, 0.09391754f, 0.01356847f, -0.03142574f, -0.05924826f, 0.10527596f, -0.01840680f, 0.18085176f, 
    -0.07791284f, -0.02069777f, 0.18580279f, 0.22649662f, 0.09361107f, -0.09276778f, -0.04464781f, 0.02255609f, 
    0.01364718f, 0.09993153f, -0.04694709f, 0.05347168f, 0.11794440f, -0.00249289f, 0.04605443f, -0.04922104f, 
    -0.01830737f, -0.06986778f, 0.02012523f, 0.07510054f, 0.02749145f, 0.05647726f, -0.03692466f, 0.05960018f, 
    -0.23350358f, -0.21069351f, -0.04834389f, 0.03129213f, -0.21817008f, 0.14012550f, 0.11188237f, -0.02443025f, 
    0.14229654f, 0.06268245f, -0.03876905f, 0.06129501f, 0.09728877f, 0.22886339f, -0.04364162f, -0.20431495f, 
    -0.05528695f, -0.06184930f, 0.12977996f, -0.01150279f, -0.03580478f, 0.17577171f, -0.06715955f, -0.10272773f, 
    0.17905848f, -0.00643790f, -0.13509759f, 0.01284341f, 0.02705875f, -0.03327842f, -0.14932457f, 0.04254972f, 
    0.03959199f, 0.05056538f, 0.03531890f, 0.11893085f, 0.01834307f, -0.00223560f, 0.24675003f, 0.00522321f, 
    -0.03821876f, 0.12803124f, -0.02239245f, 0.04168799f, 0.02745054f, 0.02158238f, 0.01658441f, -0.02514908f, 
    -0.50056118f, -0.06600413f, -0.04657734f, -0.23800348f, 0.14224449f, -0.08829410f, 0.12106579f, 0.05281293f, 
    -0.04135805f, 0.09154227f, 0.09555221f, 0.22394216f, -0.07345735f, -0.27615416f, 0.07743050f, -0.08977184f, 
    -0.00891194f, -0.07903139f, 0.00336143f, 0.11312135f, -0.03321498f, 0.00117697f, -0.03040399f, 0.01654707f, 
    -0.05144090f, -0.32457229f, -0.16145667f, 0.09421390f, -0.08014374f, -0.06689075f, 0.08253443f, 0.03510785f, 
    -0.02222339f, 0.04388248f, 0.05627603f, 0.04640460f, -0.12090866f, -0.30140889f, 0.12825601f, 0.16222392f, 
    -0.18997896f, 0.14943086f, -0.02469058f, 0.09107699f, -0.12643461f, 0.09013144f, -0.01852730f, 0.03916290f, 
    -0.04467113f, 0.02256649f, 0.02766521f, 0.01727451f, -0.02955453f, -0.01436635f, 0.01822071f, -0.00578709f, 
    0.01849950f, -0.04443421f, -0.01371546f, -0.03339744f, 0.01817181f, 0.01094340f, -0.01920306f, -0.04511942f, 
    -0.04090687f, 0.00751493f, -0.03117003f, -0.01774500f, 0.01760534f, 0.01566748f, -0.03204482f, -0.00818851f, 
    0.01960920f, -0.00596875f, -0.01227360f, -0.03684391f, 0.00558615f, 0.03639109f, -0.00974459f, -0.04586491f, 
    -0.02278514f, 0.03359421f, -0.00114735f, -0.05408986f, 0.02382329f, 0.04169051f, -0.00176473f, 0.03351761f, 
    0.00577332f, -0.04221984f, 0.00415511f, 0.02250315f, -0.03652465f, -0.03211540f, 0.02227597f, 0.02058609f, 
    -0.00388603f, -0.04493389f, -0.01418463f, -0.04093051f, 0.00289807f, -0.01080878f, -0.03137916f, 0.04206421f, 
    -0.05582348f, 0.02023745f, -0.00286373f, -0.01815646f, 0.03296595f, 0.03435290f, -0.00075986f, 0.02450968f, 
    0.02055827f, 0.00279678f, 0.00242289f, -0.00522743f, 0.01639363f, -0.00991381f, -0.01304439f, -0.01528547f, 
    0.00079638f, 0.02847888f, -0.04604567f, 0.00154588f, 0.01093346f, -0.04364078f, -0.04469853f, 0.04309226f, 
    -0.03947307f, 0.02386125f, -0.02532022f, 0.01190960f, 0.02674339f, 0.03627154f, 0.03447459f, -0.03989109f, 
    0.00650911f, -0.00444108f, -0.02238492f, -0.03785067f, -0.03967291f, -0.00091327f, 0.04203359f, -0.05109210f, 
    -0.01168032f, 0.00923483f, 0.01213043f, 0.02028492f, 0.04404063f, -0.03163651f, -0.00559349f, -0.02404198f, 
    0.01024230f, -0.02838579f, -0.00078325f, 0.03546904f, 0.04307630f, 0.02210811f, 0.00306545f, 0.03627637f, 
    -0.00426764f, 0.02186367f, 0.01741903f, 0.01885295f, -0.03533572f, 0.02888700f, 0.02571376f, -0.02189213f, 
    -0.04370053f, 0.03390039f, 0.03545038f, 0.00188408f, -0.00458875f, -0.00080680f, 0.00274016f, -0.01238739f, 
    -0.03559588f, -0.02150456f, 0.01230809f, -0.00702960f, -0.01729284f, 0.04025836f, -0.02141504f, 0.04374580f, 
    0.04284165f, -0.03651088f, -0.03867022f, 0.02397724f, 0.00911014f, -0.04722214f, -0.00094204f, -0.01188915f, 
    -0.00870360f, 0.00702905f, -0.03758375f, -0.02873093f, -0.04576133f, -0.04573974f, -0.00310881f, -0.04841002f, 
    -0.05213320f, 0.03007692f, 0.03226013f, 0.00689986f, -0.03727495f, -0.01752705f, -0.00988340f, -0.04030457f, 
    -0.05374974f, 0.00623027f, 0.03561972f, -0.03421185f, -0.05500937f, 0.01133769f, -0.01393755f, -0.01342745f, 
    -0.03258789f, -0.04386036f, -0.03130889f, -0.04720929f, -0.00070361f, -0.02136805f, 0.00882654f, 0.00769240f, 
    0.02840150f, 0.02815191f, -0.03076970f, -0.00913505f, -0.05190849f, 0.02148904f, 0.03841867f, 0.04179118f, 
    -0.05479130f, -0.04846757f, 0.03802245f, -0.04815282f, 0.01825681f, -0.01747824f, 0.04081833f, -0.02213097f, 
    -0.05330605f, 0.03724558f, -0.03654316f, -0.01368577f, -0.01081946f, 0.03822201f, -0.04196815f, -0.04249195f, 
    -0.01212529f, -0.01756015f, 0.01927886f, -0.00328376f, -0.01135000f, 0.02995729f, -0.04133291f, -0.02934360f, 
    0.00053156f, 0.02473778f, -0.05300701f, 0.02314097f, -0.01022165f, -0.01927956f, -0.01125779f, 0.03742449f, 
    -0.05407686f, 0.02705222f, 0.03706912f, 0.02617037f, -0.04604631f, -0.02909190f, 0.04006986f, 0.02125048f, 
    -0.02493486f, -0.03596729f, -0.02179420f, 0.02169760f, -0.01106536f, 0.03806252f, -0.05407232f, 0.00484579f, 
    0.01873047f, -0.05073890f, -0.00547169f, -0.04563070f, 0.03511019f, -0.04408719f, -0.01150011f, -0.04072403f, 
    0.03214840f, 0.04338260f, 0.01982307f, -0.03871702f, -0.02844688f, 0.01267816f, 0.03473130f, -0.04853285f, 
    -0.04990027f, -0.04126668f, -0.00462533f, -0.04266202f, 0.00141688f, 0.01759612f, 0.01281716f, -0.02663384f, 
    -0.02190420f, -0.03431699f, 0.01408871f, -0.04980887f, 0.02463520f, 0.04560347f, -0.05545497f, -0.00410031f, 
    -0.02134276f, 0.01737949f, -0.00740601f, -0.04829133f, -0.03038919f, -0.04905615f, -0.04130359f, 0.03986383f, 
    0.02066986f, 0.03903284f, -0.02467082f, -0.02093833f, -0.00127802f, -0.02074953f, -0.00856919f, -0.00802607f, 
    -0.02120468f, -0.05005953f, 0.04026905f, -0.00022463f, -0.00694976f, 0.02135257f, -0.05551903f, -0.00192144f, 
    -0.01951153f, -0.03161573f, -0.03958299f, -0.00785114f, -0.01068507f, -0.01289296f, -0.02646794f, 0.00390842f, 
    0.02469065f, -0.03680843f, -0.03644753f, -0.03491843f, -0.02411429f, 0.00490544f, -0.01308749f, -0.02140819f, 
    0.03376875f, -0.05012111f, 0.00378004f, -0.03146271f, -0.00620094f, 0.03852042f, 0.04151154f, -0.01163383f, 
    -0.01534052f, 0.00394435f, 0.01349944f, -0.02282189f, 0.03766418f, 0.02252369f, -0.02445841f, -0.02064976f, 
    0.04442882f, -0.03932121f, -0.00103328f, -0.01001702f, -0.03296452f, -0.02447235f, -0.02888303f, 0.00616894f, 
    0.01052446f, 0.02837179f, -0.02096489f, 0.00030753f, -0.05388109f, -0.04724951f, -0.01774763f, 0.00956025f, 
    -0.03861573f, -0.00989496f, -0.01857252f, 0.00223002f, -0.00876331f, -0.04059214f, -0.04466582f, -0.00459187f, 
    -0.03949063f, 0.04245161f, -0.01537099f, 0.03136860f, -0.05200526f, -0.02083180f, -0.00127714f, -0.02545526f, 
    0.02576368f, -0.01098473f, 0.04148241f, 0.02906464f, -0.02677814f, 0.02975075f, 0.01190569f, -0.01509761f, 
    0.01544764f, -0.04178587f, 0.01070830f, -0.00198946f, -0.03827390f, -0.01946393f, -0.01132422f, 0.02705161f, 
    0.02502079f, -0.01061196f, -0.05411470f, -0.03410600f, -0.00880348f, -0.01197971f, -0.04318478f, 0.01906664f, 
    -0.05174553f, -0.04876667f, -0.04832217f, -0.00989177f, -0.00637839f, 0.00440138f, -0.04181765f, 0.01033712f, 
    -0.04746014f, -0.01186617f, 0.03801733f, 0.02448655f, -0.01231767f, 0.03700659f, 0.03542626f, 0.02652499f, 
    -0.00569207f, 0.01220283f, 0.03122309f, 0.02497893f, -0.02855700f, 0.02279205f, 0.03961487f, 0.04191858f, 
    -0.02196161f, -0.01163976f, 0.03354736f, -0.02598882f, 0.02846097f, 0.01808554f, -0.02257343f, -0.03545307f, 
    -0.01690386f, -0.04238501f, -0.03946639f, -0.04298380f, -0.00656401f, 0.02554345f, -0.05133546f, -0.04541378f, 
    -0.01184503f, -0.00924185f, -0.05415767f, 0.01797541f, 0.03837717f, -0.00441591f, 0.02822401f, 0.01523297f, 
    0.02826806f, -0.04454295f, -0.00104864f, 0.00106265f, 0.01627378f, 0.03840140f, -0.02231201f, -0.03549924f, 
    -0.00758246f, -0.04782018f, -0.04717216f, -0.02432241f, 0.03784841f, 0.00756233f, 0.03489766f, -0.02181276f, 
    -0.00736401f, 0.00689073f, 0.01954740f, -0.01779849f, 0.03719130f, -0.02452082f, -0.01803055f, -0.01784495f, 
    0.01032580f, -0.02803982f, 0.02829655f, -0.01221900f, -0.01786274f, -0.05633872f, -0.00107369f, -0.01840838f, 
    0.02516964f, -0.02023650f, 0.02914262f, -0.02849014f, -0.02967778f, -0.02986905f, -0.01343853f, 0.03425414f, 
    0.01538164f, -0.00761348f, -0.00473206f, -0.03842626f, -0.04381251f, -0.00990460f, 0.02234194f, 0.04219457f, 
    -0.04111011f, -0.05098389f, -0.01707708f, -0.01016394f, 0.04134753f, -0.01637855f, -0.05174679f, 0.00197848f, 
    0.00214977f, 0.04901240f, 0.01983199f, -0.03393542f, -0.01450416f, 0.04183598f, -0.01605754f, -0.03397406f, 
    0.00233750f, -0.05108980f, -0.01363862f, -0.04740823f, -0.04384027f, -0.04738274f, -0.02223868f, -0.02563592f, 
    -0.01837274f, -0.04277866f, -0.00879541f, -0.03787727f, -0.00669768f, -0.02301572f, 0.01290764f, 0.03117471f, 
    -0.01848975f, 0.02497170f, -0.03559091f, 0.02898596f, -0.03317862f, 0.01555389f, -0.04278788f, -0.01417199f, 
    0.03756386f, -0.00669356f, 0.00831006f, 0.01185473f, 0.04507164f, 0.00658121f, -0.03947626f, -0.01943536f, 
    -0.00426432f, -0.01634710f, -0.02891335f, -0.00802869f, 0.03068906f, 0.04110825f, -0.03048251f, -0.04251948f, 
    -0.05317075f, -0.00205195f, -0.00486779f, 0.02859632f, -0.05304327f, -0.05351630f, -0.02795038f, -0.04053324f, 
    -0.01024409f, 0.02333299f, 0.02397129f, -0.00877909f, -0.05509284f, -0.03408913f, -0.01590088f, 0.03468957f, 
    -0.00392656f, 0.00090905f, -0.01584195f, 0.01081899f, 0.02041489f, 0.00731923f, -0.04794767f, 0.02014466f, 
    -0.00586932f, -0.01449974f, 0.03336520f, -0.01136818f, -0.01747794f, -0.03162709f, 0.02632738f, 0.02777301f, 
    -0.02053112f, -0.03104579f, -0.04949623f, -0.01286823f, 0.02653370f, 0.00091115f, -0.02343551f, 0.01747827f, 
    0.01559117f, 0.01072048f, 0.02388209f, -0.04959459f, -0.05385629f, 0.00647871f, -0.05399194f, -0.03708280f, 
    -0.02983394f, -0.04561402f, -0.04505812f, -0.05378478f, -0.03640745f, -0.03251572f, -0.00676767f, -0.05563581f, 
    0.02875858f, 0.03449215f, -0.04570099f, 0.00728040f, -0.05284674f, -0.02158452f, -0.03230542f, 0.03474500f, 
    0.00902783f, -0.02455609f, -0.02648600f, 0.04047753f, 0.01631591f, 0.01122350f, -0.02825785f, 0.01965444f, 
    -0.00700164f, -0.01726511f, 0.03409888f, -0.01796850f, -0.01948743f, 0.03966748f, -0.03713904f, -0.02822793f, 
    -0.05372494f, -0.03013280f, -0.02909143f, 0.01841324f, -0.02960373f, -0.04351150f, 0.03328846f, -0.05499584f, 
    -0.04084410f, -0.05128970f, -0.03381639f, 0.00807005f, -0.04823156f, -0.02267943f, -0.04596822f, -0.01684666f, 
    -0.02137823f, 0.03959075f, 0.01344386f, -0.03673152f, -0.04355042f, 0.03781383f, 0.01105430f, 0.03849081f, 
    0.01357561f, 0.03870359f, 0.04536664f, -0.03439798f, -0.02194075f, -0.01630892f, 0.02603243f, -0.02761249f, 
    -0.02989392f, -0.04470297f, -0.01235058f, -0.00055402f, 0.03066605f, 0.03372203f, 0.00520574f, -0.01273384f, 
    -0.04526359f, -0.00372313f, -0.00486069f, 0.01358666f, 0.00253006f, 0.01111009f, -0.01502477f, -0.03653982f, 
    0.01093135f, -0.03936155f, 0.02603609f, 0.03763109f, -0.04274170f, 0.00234343f, -0.03156792f, 0.03265085f, 
    0.03691675f, 0.00731808f, 0.03756268f, -0.03434594f, 0.03142815f, 0.01196892f, -0.00522166f, -0.00998979f, 
    -0.03245087f, 0.01163798f, 0.02992037f, 0.00019954f, -0.02694522f, -0.02571039f, -0.01832818f, 0.00432067f, 
    -0.00873435f, -0.03833433f, -0.01252613f, -0.04065663f, 0.01686526f, -0.04886271f, -0.00590390f, 0.03994739f, 
    0.01017028f, 0.04250961f, 0.03329095f, -0.00169813f, -0.00575673f, -0.01570921f, -0.05175846f, 0.02692167f, 
    0.01311700f, -0.02581234f, 0.02535113f, -0.04663792f, -0.01921449f, -0.00530297f, 0.01617761f, 0.03032061f, 
    -0.04086556f, -0.00090827f, -0.04306412f, -0.01940274f, 0.03024609f, 0.01928148f, 0.01419323f, 0.03207626f, 
    -0.05087494f, -0.02623905f, -0.01285818f, 0.04171615f, -0.01937255f, -0.00856976f, -0.03306751f, 0.03999064f, 
    -0.00828400f, -0.04431014f, 0.01299375f, 0.00795491f, -0.00113277f, -0.01993310f, -0.01295872f, 0.00979227f, 
    0.04350565f, 0.03785455f, -0.02511173f, -0.02083047f, 0.03722597f, -0.02112409f, -0.05097797f, 0.03117828f, 
    -0.00459177f, -0.04046554f, -0.01105954f, -0.00729998f, 0.04622638f, -0.01444119f, 0.01664954f, 0.01556830f, 
    -0.01459657f, 0.00177583f, 0.00494210f, 0.03771148f, -0.03700642f, 0.03595265f, -0.04605811f, -0.00381178f, 
    -0.05002411f, -0.03453085f, 0.02174314f, -0.00912245f, 0.00828748f, -0.05390024f, 0.03482125f, 0.02940265f, 
    -0.01842301f, -0.02904936f, -0.04908327f, 0.00213654f, -0.03741602f, -0.01883552f, -0.04109702f, -0.03276364f, 
    -0.04058119f, -0.09110009f, 0.03656901f, -0.02437034f, -0.10710696f, -0.05663033f, -0.02363978f, 0.08736847f, 
    -0.03336218f, -0.01276418f, 0.05984973f, 0.00287186f, 0.03815506f, 0.18229441f, 0.24453598f, -0.04419021f, 
    0.01075944f, 0.01714995f, -0.02834357f, 0.04890597f, 0.08652241f, 0.01945966f, -0.13111573f, 0.00378928f, 
    0.02291305f, 0.04972327f, -0.02215413f, 0.26303768f, 0.00939870f, 0.10620940f, -0.04918153f, 0.10152449f, 
    0.07724132f, 0.10033745f, 0.14797270f, -0.03274354f, -0.14067674f, -0.01057804f, 0.07072674f, 0.05382358f, 
    -0.03396487f, 0.12140109f, 0.04181324f, -0.01436057f, -0.00941091f, 0.11326570f, 0.10859691f, 0.09517919f, 
    0.05730758f, -0.03770655f, 0.16935502f, -0.18842463f, 0.08513987f, -0.04374350f, -0.08623856f, 0.06073037f, 
    -0.07005532f, 0.01080930f, -0.02801541f, 0.04808484f, 0.03747137f, -0.07516409f, -0.25363445f, -0.12168128f, 
    0.04238414f, 0.19407241f, 0.00369809f, -0.01273007f, -0.00255046f, -0.02005746f, -0.03053235f, -0.08477110f, 
    0.18684885f, 0.06406904f, 0.07587312f, -0.08415409f, 0.19241548f, 0.02643066f, -0.04283413f, -0.07250538f, 
    0.09220374f, -0.05318768f, 0.09024967f, -0.02903384f, 0.40540674f, 0.25202525f, -0.14738947f, 0.22375007f, 
    0.12700899f, 0.05627691f, -0.04619344f, 0.10571390f, 0.09874995f, 0.06784465f, 0.08467110f, 0.06529351f, 
    -0.03451313f, -0.02187899f, -0.02734672f, 0.08479785f, 0.00713355f, -0.00200044f, -0.10459000f, -0.06434714f, 
    -0.08613624f, -0.06452950f, -0.15551364f, -0.00016647f, -0.28534138f, -0.23432504f, -0.18689547f, -0.23247679f, 
    0.04272104f, 0.20374443f, -0.18100908f, -0.07797264f, 0.02986357f, -0.15266095f, 0.04315930f, 0.04265349f, 
    -0.19392957f, -0.02522597f, 0.01463733f, -0.07841915f, 0.03805722f, -0.04082036f, 0.12581241f, 0.00711303f, 
    0.06525908f, -0.06098340f, 0.14088726f, 0.03815946f, 0.00609157f, -0.09969474f, 0.00178153f, -0.05858953f, 
    -0.05022535f, 0.04745120f, -0.08778714f, -0.00895986f, 0.05164246f, -0.01607067f, 0.06710604f, 0.04794385f, 
    0.03934138f, 0.03808294f, 0.09967697f, 0.15764844f, -0.12143479f, 0.06956084f, -0.01360290f, -0.04644234f, 
    0.00394814f, 0.07883605f, 0.01381831f, -0.01972087f, 0.11630991f, 0.05872521f, 0.13997890f, -0.01069155f, 
    0.07284323f, -0.00676108f, 0.03948586f, -0.08211760f, 0.03160077f, -0.03672995f, 0.07875169f, 0.08259232f, 
    -0.33073023f, 0.07534291f, -0.15169369f, -0.15930149f, 0.10972048f, 0.04678659f, 0.05829699f, 0.09717719f, 
    0.03624222f, -0.08963808f, -0.18002774f, -0.04172536f, 0.11464601f, -0.01331331f, 0.35453168f, -0.02771273f, 
    0.07676122f, -0.10132851f, -0.04047681f, 0.13662757f, 0.08230876f, -0.02284796f, -0.01696443f, 0.06509317f, 
    -0.15755214f, 0.08779138f, 0.09731598f, -0.03473167f, 0.00251553f, -0.05868405f, 0.00353490f, -0.05239139f, 
    -0.00563370f, -0.02408104f, -0.06474870f, 0.12837735f, -0.13057567f, -0.15330803f, 0.22364190f, 0.33664054f, 
    -0.05845193f, 0.01908805f, 0.05540321f, 0.06119482f, -0.09142044f, 0.00739918f, 0.01835535f, 0.06610185f, 
    -0.20493755f, 0.04137094f, -0.02932985f, -0.10466701f, 0.11826748f, -0.03768105f, 0.10222089f, 0.11672945f, 
    -0.03750392f, -0.07242630f, 0.04576588f, 0.03905687f, -0.07030232f, -0.02783413f, 0.03583147f, 0.00539971f, 
    0.06292856f, 0.04737246f, -0.05179198f, 0.07140847f, -0.00989663f, 0.01603854f, -0.02540998f, 0.00422103f, 
    0.27349547f, 0.15351829f, -0.03382524f, 0.00936231f, 0.09066214f, 0.03207655f, -0.03507827f, -0.03192007f, 
    -0.05053779f, 0.06911898f, -0.05845862f, 0.08997075f, -0.40912783f, -0.05669900f, -0.22006352f, -0.12174954f, 
    0.05739213f, 0.06689085f, 0.04675071f, 0.02241128f, -0.01339759f, 0.03374085f, 0.15201358f, 0.06474425f, 
    0.34578025f, 0.11637930f, -0.00999772f, 0.32774785f, 0.11528704f, -0.05866498f, 0.03750086f, -0.00066087f, 
    -0.07519916f, 0.05845131f, 0.03565930f, 0.25068536f, -0.04968246f, 0.05595855f, -0.02334057f, -0.01107340f, 
    0.03246925f, 0.05680868f, -0.08357843f, 0.04232651f, 0.01632368f, -0.10803182f, 0.06044000f, 0.04136841f, 
    -0.03225433f, -0.00388787f, -0.20529820f, -0.03415234f, -0.11770022f, 0.03736902f, 0.01416042f, -0.04974464f, 
    -0.03348150f, -0.02588975f, -0.08076779f, 0.00900894f, -0.24833243f, 0.10723966f, -0.02019039f, -0.20270455f, 
    0.01087183f, -0.00252626f, 0.02182709f, -0.06530853f, 0.02583746f, 0.18130891f, -0.01207053f, 0.02618797f, 
    0.02675954f, -0.03783859f, -0.25094578f, 0.14017347f, 0.04943394f, -0.06886749f, 0.17477331f, -0.04377379f, 
    -0.02539432f, -0.15037347f, -0.01572469f, 0.05327962f, 0.08887710f, 0.08008765f, 0.17758702f, 0.16445731f, 
    0.12767589f, 0.13865809f, 0.07855409f, 0.12064174f, 0.04230078f, -0.05657441f, 0.12415946f, -0.04733506f, 
    -0.23942931f, 0.11799613f, 0.00977053f, -0.09064803f, 0.02049284f, -0.11114576f, -0.07643734f, -0.04700037f, 
    0.06342555f, 0.03699616f, 0.04904045f, 0.16079359f, -0.26652959f, -0.04268827f, 0.07677689f, 0.01221143f, 
    0.06159104f, -0.02711451f, 0.08104692f, 0.09126106f, 0.04807114f, 0.04598028f, -0.08482697f, -0.09179385f, 
    -0.31432745f, -0.11716352f, -0.03700683f, -0.13719404f, 0.13905083f, 0.02788255f, 0.03367747f, -0.12033697f, 
    0.02502743f, -0.10690363f, -0.01404088f, -0.09684613f, -0.25170311f, -0.23357475f, -0.00733174f, 0.11581502f, 
    -0.05797423f, 0.11113991f, -0.10966075f, 0.00784455f, 0.05161095f, 0.06892605f, 0.02185252f, 0.06258040f, 
    -0.02764640f, -0.00946501f, 0.01137600f, 0.01434155f, 0.02628172f, 0.03786955f, -0.03629800f, 0.02586158f, 
    -0.00727652f, 0.00391982f, -0.04677504f, -0.03336776f, -0.02758681f, -0.04542522f, 0.03754403f, -0.00935140f, 
    -0.03814156f, 0.04986313f, 0.02061364f, -0.05210677f, 0.02039393f, 0.02607197f, -0.04124722f, -0.05216018f, 
    -0.03174334f, 0.01948485f, 0.04443330f, -0.02535842f, 0.01288074f, 0.04170015f, 0.01410374f, 0.03117220f, 
    -0.02180061f, 0.00738869f, -0.03784798f, 0.00990044f, -0.04962567f, -0.02822754f, 0.04167002f, -0.02754084f, 
    -0.01656753f, -0.04680728f, 0.02098906f, 0.03843239f, -0.04900684f, 0.01865845f, -0.03276065f, -0.04989354f, 
    0.00456215f, -0.00814583f, -0.01649559f, -0.02382383f, -0.01965593f, -0.02791932f, 0.04698521f, -0.00444942f, 
    0.01633962f, 0.05030098f, 0.02387877f, 0.01994704f, 0.03586413f, 0.01774238f, 0.02436097f, 0.02448508f, 
    0.04972750f, -0.01233467f, -0.01203339f, -0.00226265f, 0.00361965f, 0.00422411f, 0.01807553f, -0.03911917f, 
    0.00257336f, -0.00513189f, -0.04842602f, 0.00085619f, -0.00524551f, -0.00071607f, -0.03771195f, -0.00162272f, 
    0.00538270f, 0.03726903f, 0.01266406f, 0.01846616f, -0.02901588f, 0.04197475f, -0.00785507f, -0.04452012f, 
    0.02729617f, -0.03611335f, 0.01489375f, 0.03001493f, -0.02614594f, -0.04532938f, -0.03742464f, -0.03806269f, 
    -0.01970761f, -0.03773887f, 0.03893793f, -0.03015443f, 0.02103355f, -0.02692785f, -0.01532211f, -0.00699548f, 
    -0.02357975f, 0.01784825f, 0.01611853f, 0.04146430f, -0.04211771f, -0.02841535f, 0.02992877f, -0.03400537f, 
    0.00034765f, 0.02051036f, -0.03112245f, 0.00769367f, -0.00814518f, -0.03641686f, -0.05430408f, -0.01795267f, 
    -0.04347310f, 0.03822067f, -0.01196325f, 0.01705141f, 0.01546105f, 0.01461469f, 0.02749535f, -0.00448803f, 
    -0.03009998f, -0.03609537f, 0.01447557f, 0.00479136f, 0.03127526f, -0.03212353f, 0.00049266f, -0.05291154f, 
    0.04489977f, -0.03036269f, 0.04673585f, 0.01038861f, 0.04929826f, 0.00379907f, -0.04716728f, 0.01122727f, 
    0.02052337f, 0.00544733f, -0.05398773f, -0.01208917f, 0.04425220f, -0.05048236f, -0.02964977f, -0.01791693f, 
    -0.01787980f, 0.02895505f, -0.01141526f, 0.01853713f, 0.01777494f, -0.00606697f, -0.03101806f, 0.01351043f, 
    0.03392759f, -0.02422729f, -0.00250533f, -0.02624695f, 0.03286896f, -0.00053400f, -0.00215712f, -0.02281542f, 
    -0.04021941f, 0.02497182f, 0.01954270f, -0.00886306f, 0.01990417f, -0.05193428f, -0.04253056f, 0.00122940f, 
    0.04213674f, -0.02080215f, -0.02451603f, 0.01638809f, 0.01338941f, -0.04615871f, -0.02750093f, 0.02296109f, 
    0.03986318f, -0.02136444f, -0.03561723f, -0.03173074f, 0.04446781f, 0.02431194f, -0.03286780f, -0.00992309f, 
    -0.00605213f, -0.01950283f, -0.03025898f, -0.03760919f, -0.02294581f, 0.01954794f, 0.01538388f, -0.03779279f, 
    0.03549396f, -0.00808760f, -0.00531272f, 0.00650880f, 0.05049644f, 0.02331627f, 0.04739242f, -0.01101890f, 
    0.01618650f, -0.05582740f, -0.05620581f, -0.01247176f, 0.02821649f, 0.01007905f, 0.01640866f, 0.01616876f, 
    0.01231588f, -0.02792615f, -0.04551381f, -0.00619433f, 0.00009757f, -0.01614174f, 0.02075292f, 0.05242930f, 
    0.00148845f, 0.02518326f, 0.03795458f, -0.01267579f, 0.04037865f, -0.04119034f, 0.02478590f, 0.02574986f, 
    -0.04852115f, -0.01829296f, -0.01151988f, 0.02565189f, -0.01625053f, -0.03036798f, -0.00409433f, -0.05810022f, 
    -0.01865121f, -0.00586691f, -0.02833211f, -0.04743808f, 0.00360266f, -0.01484318f, -0.00281106f, -0.00808137f, 
    0.00255527f, 0.04362981f, -0.02661262f, 0.02423237f, 0.02296616f, 0.01433625f, -0.00346001f, -0.02470179f, 
    -0.04765228f, 0.00781614f, -0.02431806f, 0.03776859f, 0.03072829f, -0.03094149f, 0.01770047f, -0.00105222f, 
    0.01884411f, 0.01789585f, 0.02274488f, 0.03459539f, -0.03237648f, 0.01095724f, -0.02896705f, 0.03146764f, 
    0.00471296f, -0.00968324f, -0.02108181f, 0.00970644f, -0.01540045f, -0.02281960f, -0.02627041f, -0.04472231f, 
    -0.02933778f, -0.03361461f, -0.01335361f, 0.02149897f, -0.00815840f, 0.01695494f, 0.01347579f, 0.01379007f, 
    0.02097056f, -0.01354046f, 0.03020246f, 0.04715898f, -0.01812429f, -0.01601912f, -0.00350234f, -0.03695456f, 
    -0.02266162f, -0.05278746f, -0.02257869f, 0.01570360f, -0.01591414f, -0.03102177f, -0.00411085f, -0.04707816f, 
    -0.00147102f, -0.02181303f, 0.04213529f, -0.04619271f, 0.02637874f, -0.04153498f, 0.04504180f, -0.00585142f, 
    0.03201340f, 0.01826812f, 0.01211778f, 0.03462733f, -0.02372444f, -0.00309539f, -0.04534634f, -0.03592909f, 
    0.03027806f, -0.01878962f, 0.00765535f, -0.01763661f, 0.01287834f, 0.02129245f, 0.04305917f, 0.00109887f, 
    -0.03639610f, -0.02212576f, 0.02986654f, 0.02761003f, -0.02508767f, -0.02176639f, -0.03785477f, -0.01374949f, 
    0.00998828f, 0.00629918f, -0.03600562f, -0.03762916f, -0.02898169f, 0.03343285f, -0.01909951f, 0.03968456f, 
    -0.05032190f, -0.00200791f, 0.00375302f, -0.01854875f, 0.03309196f, -0.01976286f, -0.02923539f, 0.01297786f, 
    -0.04358061f, -0.02709591f, -0.05456470f, -0.01501083f, 0.00039715f, -0.04582941f, -0.04554954f, 0.03091276f, 
    0.00289939f, -0.03930102f, -0.05014877f, -0.00053501f, -0.05787779f, -0.01829614f, 0.01810369f, -0.03181733f, 
    -0.00850386f, -0.00167534f, -0.04259327f, 0.02134032f, 0.02956376f, 0.00275841f, 0.03879708f, -0.01817615f, 
    -0.02336632f, 0.00952923f, -0.02074556f, -0.01671657f, -0.00763196f, -0.03871004f, -0.01508319f, -0.03438554f, 
    -0.01418535f, 0.00002041f, -0.02330345f, -0.02461991f, 0.02087727f, -0.04732121f, -0.02175619f, -0.01605832f, 
    -0.05251256f, -0.04595398f, -0.02908827f, 0.00365990f, -0.01721475f, 0.03043916f, -0.03822134f, 0.04369131f, 
    -0.00004093f, -0.04599153f, 0.01077943f, -0.02889580f, 0.00698009f, 0.03621092f, -0.01626788f, 0.02292262f, 
    0.03491179f, -0.03820807f, -0.04992605f, -0.05098149f, -0.02278138f, 0.04144377f, -0.01251428f, -0.01652011f, 
    0.02025230f, 0.02494422f, -0.01887241f, 0.01612743f, -0.01935171f, 0.00521649f, -0.00133220f, 0.03804641f, 
    0.04406682f, -0.05021913f, 0.03005511f, 0.02410143f, -0.04004250f, -0.03734879f, -0.02232569f, 0.03582139f, 
    0.03264233f, 0.02000031f, -0.00319083f, -0.05213851f, -0.05018460f, 0.01019965f, -0.00446188f, -0.04659785f, 
    -0.04385361f, -0.05352865f, 0.05029771f, 0.02491257f, 0.01030107f, -0.00003495f, 0.02386776f, -0.04042430f, 
    0.02969760f, 0.02254360f, -0.02368458f, -0.03817903f, -0.05028788f, -0.04689312f, 0.03073330f, -0.04108590f, 
    0.03681401f, -0.01252576f, -0.03628091f, -0.00037575f, -0.04240678f, 0.01101980f, -0.01282923f, -0.02087856f, 
    -0.05290795f, 0.01128887f, 0.00730500f, -0.04538341f, 0.01024071f, -0.04719295f, 0.04467002f, -0.04391963f, 
    -0.04721056f, 0.02035880f, -0.01763771f, 0.01404096f, -0.04829628f, 0.02603118f, -0.01638635f, 0.01648364f, 
    -0.05299973f, -0.02416098f, -0.01859951f, -0.01734241f, 0.00949528f, 0.01084316f, -0.01629026f, -0.02331658f, 
    -0.01327765f, -0.03281263f, -0.00427957f, -0.03812265f, -0.05441417f, 0.01921690f, 0.02883134f, 0.02120479f, 
    -0.00275611f, 0.04398768f, -0.03967806f, 0.03450577f, -0.05426751f, 0.01257888f, 0.02464657f, -0.02273612f, 
    0.03555937f, -0.00887425f, -0.02245126f, -0.03150798f, -0.05019067f, -0.01634625f, 0.02807245f, -0.01872516f, 
    -0.03692681f, -0.03955958f, 0.01681105f, -0.01872862f, 0.00439014f, -0.01424258f, 0.02218219f, -0.00950179f, 
    0.03361737f, -0.02157588f, 0.03561757f, 0.01258272f, 0.03178368f, 0.02251543f, 0.00217894f, -0.05299241f, 
    0.01611770f, 0.03996178f, -0.03901585f, -0.01394209f, 0.04351241f, -0.03547524f, -0.02121202f, -0.00172888f, 
    -0.02395306f, 0.03132961f, 0.01352954f, -0.04844081f, 0.02654891f, 0.01464235f, -0.03332553f, 0.04577334f, 
    -0.03118325f, -0.00141128f, 0.00259355f, 0.04446598f, 0.00093036f, 0.00845725f, -0.01833695f, -0.00963585f, 
    -0.04276354f, 0.00250968f, 0.00305741f, -0.02398453f, -0.00709757f, 0.01571318f, -0.05520903f, 0.00223704f, 
    0.03139545f, 0.03039255f, -0.02669903f, -0.02560407f, -0.03073063f, 0.00648076f, 0.03732829f, -0.04007043f, 
    -0.03902635f, 0.00178006f, -0.05470503f, -0.02278182f, -0.00251536f, -0.03867668f, 0.01198124f, -0.00466122f, 
    -0.02576423f, -0.00433413f, -0.01316613f, 0.00843629f, 0.04267582f, 0.03302697f, -0.05195210f, -0.04026655f, 
    -0.02227820f, -0.01733026f, 0.01489528f, 0.04466246f, -0.04721969f, -0.03072209f, 0.02030002f, -0.03449058f, 
    0.00394199f, -0.02688846f, -0.00902525f, 0.02182879f, 0.03584031f, 0.02301254f, -0.01937066f, -0.00654293f, 
    -0.02468018f, -0.05078358f, 0.03206981f, 0.00699228f, -0.02769076f, 0.02398949f, -0.00319415f, 0.01507643f, 
    0.02512494f, 0.04179464f, -0.02741843f, 0.02599443f, 0.02465529f, -0.02140503f, -0.03147518f, -0.05317985f, 
    0.03599689f, 0.03612089f, 0.01170346f, 0.00183426f, -0.01513746f, 0.01918698f, -0.03105834f, 0.01360859f, 
    -0.02545318f, -0.04026359f, -0.00714999f, -0.03471887f, -0.01037025f, -0.04785201f, -0.00817907f, -0.01266026f, 
    -0.04879053f, 0.01010574f, -0.04179472f, -0.00978330f, -0.04088417f, 0.02412005f, 0.00009156f, 0.02875664f, 
    -0.02424968f, 0.00301424f, 0.01612583f, 0.01352271f, -0.00228970f, -0.04074840f, 0.04361978f, -0.03903776f, 
    0.02253493f, -0.01074822f, 0.02000982f, -0.01279736f, 0.02690275f, 0.03874039f, -0.05063246f, -0.02229604f, 
    -0.05558836f, -0.04095380f, 0.02749604f, -0.02950607f, -0.01561040f, -0.04280487f, -0.00224914f, 0.00157945f, 
    -0.04866829f, -0.02735977f, 0.03048388f, -0.02259356f, -0.02627520f, -0.05103336f, -0.00203434f, -0.00406240f, 
    -0.04856289f, -0.01610545f, -0.05364038f, -0.01607792f, 0.02063432f, -0.04427456f, -0.01526353f, 0.02808785f, 
    0.00591724f, -0.03694567f, 0.02246498f, 0.00716260f, -0.00882645f, -0.02051450f, 0.03795489f, -0.03394990f, 
    -0.01135214f, -0.02131893f, -0.01845967f, -0.04956072f, 0.02419165f, -0.04478393f, -0.02093643f, 0.00984378f, 
    -0.04693303f, -0.02577100f, -0.05592776f, 0.04572382f, -0.02915091f, -0.03588849f, 0.04251679f, 0.02759502f, 
    0.02239119f, -0.02718540f, -0.04269274f, -0.01495907f, -0.02710511f, 0.03622350f, -0.03691391f, -0.00176596f, 
    0.03317882f, -0.05229104f, -0.00533615f, 0.03966966f, -0.04691041f, 0.00202683f, 0.01803986f, 0.00314232f, 
    0.01306789f, -0.03030938f, 0.02109415f, 0.04325217f, 0.04573743f, 0.01721138f, 0.04065228f, 0.00242252f, 
    -0.03492535f, -0.00949147f, -0.04789070f, 0.03910444f, 0.02621693f, -0.04224838f, 0.00754815f, 0.02944350f, 
    -0.00112114f, 0.04149830f, 0.01629647f, 0.01646845f, -0.04882574f, -0.00880081f, 0.03860493f, 0.02715366f, 
    0.00948860f, 0.02267350f, 0.00529475f, -0.03892366f, -0.05228321f, 0.02688896f, 0.01457028f, -0.00202105f, 
    -0.05310737f, -0.02086068f, 0.03482761f, 0.02029639f, 0.02667836f, -0.03284096f, -0.05318933f, 0.01870298f, 
    -0.03566319f, -0.04884619f, 0.03499435f, -0.02677082f, -0.00262018f, -0.01647362f, 0.02001064f, -0.04131288f, 
    0.34644035f, -0.16446918f, -0.01393672f, 0.03513639f, -0.06096270f, -0.02479528f, -0.00216118f, -0.06926133f, 
    -0.00353476f, 0.01598254f, 0.00396795f, -0.00653765f, -0.23443231f, 0.08792444f, 0.07651921f, -0.10102965f, 
    0.05381611f, 0.05698762f, 0.05419412f, -0.03989744f, 0.03894957f, 0.08855031f, -0.03907109f, 0.05771451f, 
    -0.12404180f, -0.09763478f, 0.03390793f, 0.17550714f, 0.11549424f, 0.15643384f, -0.00816693f, 0.08592466f, 
    -0.05540009f, 0.03914333f, 0.14092454f, 0.02456876f, 0.18087509f, -0.04862384f, 0.09114262f, -0.10374481f, 
    -0.05449139f, -0.03214636f, 0.13722916f, -0.08239821f, -0.01202547f, 0.05748318f, 0.00206089f, -0.00542999f, 
    0.16683318f, -0.04960690f, -0.00794094f, -0.27508941f, 0.04965901f, 0.07989264f, 0.02678907f, 0.02917794f, 
    -0.04820455f, 0.02181089f, -0.06510670f, 0.09223668f, 0.14736129f, 0.07566696f, -0.04217980f, 0.26824594f, 
    -0.02451849f, -0.04065276f, 0.02489936f, 0.10250103f, -0.05104250f, -0.04345512f, 0.01783680f, -0.01476143f, 
    -0.15863788f, -0.02500816f, 0.12105019f, -0.19799273f, 0.04993553f, 0.00284707f, -0.01566244f, 0.07592882f, 
    0.02917346f, -0.01982518f, -0.03391104f, -0.05953718f, -0.48229975f, -0.03621117f, 0.01867483f, 0.28876397f, 
    0.02992398f, -0.02098482f, 0.03571789f, -0.03186541f, -0.00618505f, -0.05415796f, -0.01787665f, 0.01645014f, 
    0.04592815f, 0.11677565f, -0.07690823f, 0.13590606f, 0.05469674f, 0.11399650f, 0.00063079f, -0.06195297f, 
    -0.01454112f, -0.02567460f, -0.11975721f, -0.10448257f, -0.07985461f, -0.00702051f, -0.03599826f, 0.18518004f, 
    -0.04822673f, 0.08583549f, 0.07397282f, -0.14322585f, -0.04815023f, 0.15649146f, 0.04423550f, 0.02775800f, 
    0.13603750f, 0.04983817f, -0.09433270f, 0.13099271f, 0.06506111f, 0.11735711f, -0.01007637f, -0.19094133f, 
    0.21935946f, 0.07489681f, -0.07239752f, 0.03542243f, -0.09968896f, -0.13398734f, -0.04567500f, 0.11908938f, 
    -0.11364941f, -0.03541375f, 0.15629932f, 0.05111189f, -0.02660408f, -0.07446761f, 0.06943783f, 0.07789258f, 
    0.08998212f, 0.13074957f, -0.10854029f, 0.15009351f, -0.02298827f, 0.10293712f, 0.04263364f, 0.02068459f, 
    -0.03706884f, 0.14062338f, -0.06434346f, 0.03257879f, -0.17886975f, 0.06733207f, 0.12681973f, -0.34110165f, 
    0.11967334f, 0.00028534f, -0.01879000f, -0.09441496f, 0.07491527f, -0.05548654f, -0.03086513f, 0.06048944f, 
    0.11804441f, -0.04815922f, 0.13173811f, -0.03978569f, 0.01336350f, 0.02251343f, 0.03566754f, -0.00723952f, 
    -0.08826370f, 0.06425849f, 0.08042778f, -0.01476784f, 0.25967544f, -0.07338329f, 0.12358764f, -0.08770536f, 
    -0.07026478f, 0.00711935f, 0.04338640f, 0.17394409f, 0.02020812f, 0.06705526f, 0.00022979f, -0.01359180f, 
    0.23690765f, -0.07793450f, -0.16088329f, -0.06999251f, 0.04912033f, 0.01290017f, -0.05930131f, -0.05467584f, 
    0.00945332f, -0.01096654f, 0.00818239f, -0.01213357f, -0.11043859f, -0.09194665f, -0.07658920f, 0.29020128f, 
    -0.01654378f, -0.07292828f, 0.04034893f, -0.06866018f, -0.06061805f, -0.05115499f, -0.02337109f, -0.04057234f, 
    0.25695682f, 0.09542602f, -0.02202282f, -0.19489031f, -0.01867285f, 0.05402390f, 0.04803473f, 0.04104075f, 
    0.00939640f, -0.01139280f, 0.09115987f, -0.08454382f, 0.37859735f, -0.02597984f, -0.19028805f, 0.03659494f, 
    0.03827194f, 0.01356139f, 0.01860024f, 0.00454447f, 0.07693481f, 0.07134228f, -0.04290839f, -0.03561402f, 
    -0.08353877f, 0.29945794f, 0.04985946f, -0.13952348f, -0.01398850f, -0.06354076f, 0.00565024f, -0.07014217f, 
    -0.00555500f, 0.04650909f, 0.10101603f, 0.04176234f, 0.16302980f, -0.12425694f, -0.06854571f, -0.02856595f, 
    -0.02123397f, 0.09873468f, 0.00082984f, 0.07526708f, -0.03448497f, -0.04269891f, 0.04943099f, 0.03371705f, 
    -0.03578356f, -0.16538908f, 0.17217886f, 0.06883078f, 0.05863189f, 0.00081923f, 0.04231594f, -0.02301881f, 
    -0.08031262f, -0.00031530f, -0.22582310f, -0.01148189f, 0.09312293f, 0.17220926f, -0.14127935f, 0.09320159f, 
    0.05099408f, 0.09947415f, 0.07934101f, -0.11870726f, 0.06665756f, 0.00036456f, 0.04254688f, -0.00446602f, 
    -0.02915301f, -0.05844877f, -0.10299627f, 0.30716720f, 0.00328543f, -0.02162966f, 0.06342284f, 0.03492921f, 
    -0.02579912f, 0.01143368f, 0.02615542f, 0.02051573f, 0.14456359f, 0.11048270f, 0.04022274f, -0.14219260f, 
    -0.03887463f, 0.00326176f, -0.01508255f, -0.10800738f, -0.05295158f, 0.09719439f, 0.06816032f, 0.05137055f, 
    0.12110510f, 0.03791150f, -0.03257806f, 0.00581586f, -0.09045349f, 0.18494585f, -0.06042826f, -0.08359182f, 
    -0.02852898f, 0.14565709f, -0.04931640f, 0.15030673f, -0.08768346f, 0.00427883f, 0.02823257f, 0.14158683f, 
    -0.02763534f, 0.02255296f, 0.02524314f, 0.02712980f, -0.04200812f, -0.03656502f, 0.04905570f, 0.06245903f, 
    -0.04324232f, 0.22311093f, 0.12464140f, -0.36601052f, 0.08422793f, 0.09279901f, 0.01557537f, 0.08761717f, 
    -0.10260250f, 0.02454520f, 0.06584395f, -0.02716734f, -0.19445774f, -0.03459325f, 0.04556669f, 0.14245237f, 
    -0.16417043f, 0.00767397f, 0.04885643f, 0.00857094f, -0.04239940f, 0.09526396f, -0.00501047f, -0.02194845f, 
    -0.19697745f, -0.25788242f, 0.14123532f, -0.05098016f, -0.09736368f, -0.00446937f, -0.00218643f, 0.06386504f, 
    0.08126513f, -0.16595218f, 0.05252834f, 0.09723884f, -0.00067043f, -0.07364109f, -0.07283513f, 0.36381066f, 
    0.05011081f, -0.05160920f, 0.02849551f, -0.03012095f, -0.06605598f, 0.15785679f, 0.03672449f, -0.04547644f, 
    0.03628238f, 0.04266480f, 0.02740676f, 0.03891392f, -0.04684187f, -0.01554036f, -0.04142995f, -0.01356876f, 
    -0.02661857f, -0.04116809f, 0.03648496f, -0.02642588f, 0.01470234f, 0.03324090f, -0.00068136f, -0.02422283f, 
    -0.04180915f, 0.02539078f, 0.02075360f, 0.00984855f, -0.02787729f, 0.02301841f, -0.01606710f, -0.04417675f, 
    0.03482428f, -0.01364675f, -0.00468562f, -0.00687945f, 0.02906850f, -0.01272378f, -0.04793048f, -0.04082997f, 
    -0.03704423f, 0.03417767f, -0.01648531f, -0.04712595f, -0.04737238f, -0.02139745f, 0.03481557f, 0.00857679f, 
    0.01316748f, -0.00820226f, 0.01602242f, 0.01897624f, -0.02586788f, 0.02180585f, -0.03284320f, 0.01254282f, 
    -0.05577575f, 0.01008562f, -0.05496444f, 0.00257402f, -0.04628880f, -0.00204258f, -0.02036628f, -0.05165977f, 
    -0.04670561f, 0.01562635f, 0.03546046f, -0.00931301f, 0.03523286f, 0.03856823f, -0.04045314f, -0.00866140f, 
    0.00191919f, -0.00329743f, 0.04434139f, 0.02999569f, 0.02890497f, 0.02298079f, -0.04512005f, -0.02916534f, 
    0.02583923f, -0.01432230f, 0.00664585f, -0.00241427f, -0.01980993f, -0.04960869f, -0.02312039f, 0.00294305f, 
    -0.01291759f, -0.02496523f, 0.04044610f, 0.03836872f, -0.04589549f, 0.03343119f, 0.02903502f, 0.01068613f, 
    0.03705636f, -0.02499223f, -0.03395862f, -0.04366770f, 0.04381628f, 0.00082474f, -0.04220571f, -0.00746532f, 
    0.03194445f, -0.02877156f, 0.03125650f, 0.04318560f, -0.02150174f, -0.03865258f, 0.01132572f, 0.00859490f, 
    -0.02546153f, -0.03161159f, -0.02978007f, 0.01304862f, 0.04058653f, -0.02949601f, 0.03711738f, 0.00535966f, 
    -0.02252435f, -0.04942444f, -0.01015140f, 0.01691338f, 0.00481208f, -0.00591227f, 0.02482547f, 0.01703262f, 
    -0.00341849f, -0.04260168f, 0.01224684f, -0.04821026f, -0.01674982f, -0.04028504f, 0.03929595f, -0.04189067f, 
    0.01817131f, 0.01351081f, -0.03359705f, -0.00886048f, 0.02973663f, -0.01597375f, 0.03235960f, 0.03116749f, 
    0.00670708f, -0.03661722f, 0.04514162f, -0.03887692f, -0.03895091f, -0.04433745f, -0.00723802f, -0.01483462f, 
    -0.02993510f, 0.02076685f, 0.01526746f, 0.00385311f, -0.02037249f, 0.04039339f, -0.00150445f, -0.05174616f, 
    0.03212850f, -0.03966218f, -0.01782346f, -0.01306912f, 0.04243223f, -0.01923970f, 0.00340508f, 0.01757152f, 
    -0.02185217f, -0.03958785f, -0.00536747f, -0.00042693f, 0.01832225f, 0.00816911f, 0.00621941f, -0.02568672f, 
    -0.03689578f, 0.03937920f, 0.04665063f, -0.00367983f, -0.03590331f, -0.00723069f, -0.01990027f, 0.01966593f, 
    -0.02620015f, 0.04374319f, -0.02690600f, 0.01110128f, 0.03755916f, 0.00469808f, -0.05361160f, 0.02638022f, 
    -0.03160455f, -0.01233492f, -0.01341586f, 0.00069550f, -0.03507346f, -0.04078551f, 0.04663152f, -0.05532242f, 
    0.04069441f, 0.04200500f, 0.02017429f, -0.00425027f, -0.01197796f, -0.04057306f, 0.03160878f, 0.02513399f, 
    0.03672425f, 0.03148846f, -0.02673989f, 0.00803004f, 0.02636618f, 0.02475318f, -0.01780007f, 0.01155413f, 
    -0.00427330f, -0.01088519f, -0.05311453f, 0.03656399f, -0.03905897f, 0.01490368f, 0.03131684f, -0.01859615f, 
    -0.01777942f, 0.04456107f, -0.04362968f, 0.01392846f, -0.05333956f, 0.00999946f, -0.01691233f, -0.04529501f, 
    0.00242895f, 0.00802387f, 0.04148595f, -0.01048062f, 0.04289746f, -0.01990210f, -0.05358698f, 0.00490670f, 
    -0.04100926f, -0.00173779f, -0.01189795f, 0.00054653f, 0.01270813f, -0.01742298f, -0.05286244f, 0.04192802f, 
    0.02012792f, 0.02878715f, 0.04387664f, -0.05366620f, 0.00451849f, 0.01223846f, -0.04912574f, 0.03808524f, 
    0.01124602f, -0.02404660f, 0.04672632f, -0.01774199f, -0.00185886f, 0.01814969f, -0.00497668f, -0.00043190f, 
    0.02534432f, 0.02111500f, 0.00827878f, -0.04331638f, -0.03295426f, -0.04837888f, -0.01897198f, -0.01676268f, 
    -0.03532006f, 0.04596708f, 0.00767476f, -0.00108436f, -0.04637034f, 0.02590598f, -0.04826046f, 0.01727136f, 
    0.04547761f, 0.00510987f, -0.05219531f, -0.02400399f, 0.01839423f, -0.00019477f, -0.01342533f, -0.00188270f, 
    0.01974477f, -0.03574627f, -0.04740815f, -0.02864947f, 0.02935439f, -0.02732886f, -0.01698332f, -0.04461221f, 
    -0.02109589f, -0.04163427f, 0.04438656f, -0.02030938f, 0.00698603f, 0.03968990f, -0.00322673f, 0.01891782f, 
    -0.00436941f, 0.02710803f, -0.03360905f, -0.03013089f, -0.05325356f, -0.02350825f, 0.01170073f, -0.05096943f, 
    -0.00802702f, 0.01106809f, -0.04815368f, 0.03554264f, -0.04709947f, -0.00159516f, 0.04021952f, -0.04010239f, 
    0.02666606f, -0.04254925f, 0.03568381f, -0.01244689f, 0.01962736f, 0.02810348f, -0.03771860f, -0.01710925f, 
    -0.01333220f, -0.03478010f, -0.04715174f, 0.03320021f, -0.00445999f, 0.02254671f, -0.05087198f, 0.01340716f, 
    -0.01659433f, 0.04290331f, 0.03013240f, -0.03213856f, -0.05211993f, 0.00036434f, -0.04732458f, 0.00309539f, 
    -0.01696463f, 0.02201117f, 0.00877880f, -0.00962438f, -0.03398202f, -0.00984229f, 0.04353561f, -0.02894261f, 
    -0.00263389f, 0.00385627f, 0.01593324f, -0.03118806f, 0.00339833f, -0.04956242f, -0.03242024f, -0.02162093f, 
    -0.00726974f, -0.01083525f, 0.01244416f, 0.03452577f, 0.01511356f, -0.00940460f, -0.03752925f, -0.03402291f, 
    0.02107921f, -0.03381276f, -0.04050600f, -0.04000253f, -0.05315933f, 0.04369858f, 0.00181064f, 0.02685551f, 
    0.01873057f, 0.03513815f, -0.05388361f, 0.01174260f, -0.04767474f, -0.00723386f, 0.01089983f, 0.01617325f, 
    0.04600593f, 0.02973109f, 0.02501751f, 0.00219829f, -0.01767182f, -0.04487526f, -0.02347917f, 0.01811007f, 
    -0.39221108f, 0.29227117f, 0.12615587f, -0.01227686f, 0.13561574f, 0.04783631f, -0.00945301f, -0.05948807f, 
    -0.04422727f, 0.03265071f, -0.01106559f, -0.03697028f, 0.32033738f, 0.00732617f, -0.01201118f, 0.18879442f, 
    -0.09572381f, -0.09101852f, 0.05406319f, 0.02241969f, 0.02033863f, 0.00675716f, -0.00935015f, 0.08142921f, 
    0.25680870f, 0.07741667f, 0.04992586f, -0.16063362f, -0.07035782f, -0.19095284f, 0.05023553f, -0.03179054f, 
    0.05977124f, -0.06220860f, -0.01526039f, 0.04515233f, 0.07417884f, 0.06952681f, -0.17148747f, -0.05318071f, 
    -0.01795196f, -0.06362510f, 0.02626999f, 0.05507805f, -0.01587414f, -0.04831764f, -0.04580424f, 0.03632120f, 
    -0.12042724f, 0.10290987f, -0.11425647f, 0.35501230f, 0.01122076f, 0.04901289f, -0.02877637f, 0.08179424f, 
    0.00293111f, 0.07138886f, 0.08169411f, -0.09419469f, -0.15303358f, -0.08220624f, 0.03193245f, -0.14816141f, 
    0.02895010f, -0.12502795f, 0.14006326f, -0.08654001f, -0.01231913f, 0.09009238f, 0.04842676f, 0.11572967f, 
    -0.00297466f, -0.03756919f, 0.04058958f, 0.26636931f, -0.07625593f, 0.03890250f, -0.03191024f, -0.00219290f, 
    0.07934166f, 0.12101018f, 0.03605671f, 0.01972131f, 0.15115970f, -0.04494292f, -0.06152032f, -0.16990112f, 
    -0.05637531f, 0.06349456f, 0.11837173f, 0.00204633f, 0.00125414f, 0.10813641f, 0.03365409f, 0.03990164f, 
    -0.01910370f, -0.05333025f, 0.05524238f, -0.07680254f, -0.05108856f, 0.09674380f, 0.06308167f, 0.08044084f, 
    0.06587958f, 0.00771632f, 0.09233203f, -0.01258360f, 0.08360945f, 0.10868128f, 0.03009770f, -0.13494264f, 
    0.05678078f, -0.15579885f, 0.04613205f, 0.09458096f, 0.04834840f, -0.04776913f, -0.03148278f, 0.05960450f, 
    -0.05830276f, 0.02019317f, 0.00559412f, -0.04880227f, -0.04019340f, 0.04616238f, -0.05925825f, 0.10971858f, 
    -0.05625499f, -0.05915586f, -0.04800837f, -0.05059603f, 0.10758496f, 0.06570946f, 0.07787085f, 0.02728844f, 
    0.13254124f, 0.00303420f, 0.00214185f, 0.05409576f, 0.02679683f, 0.09895424f, -0.05618554f, 0.11320815f, 
    0.03422893f, 0.02013733f, 0.01094937f, -0.09354586f, 0.09243251f, -0.11223715f, 0.02647896f, 0.02039113f, 
    0.02793483f, -0.10304169f, 0.09406731f, -0.01516715f, 0.27387932f, -0.08932342f, 0.07657666f, 0.30513594f, 
    -0.15150496f, 0.01345858f, 0.05008237f, 0.09214577f, -0.04408059f, 0.00843056f, 0.09342268f, -0.06180306f, 
    0.15550151f, -0.11199357f, -0.02749285f, 0.02823673f, -0.07182649f, 0.02243180f, -0.02456650f, -0.02757312f, 
    0.03948550f, -0.04703364f, 0.03555442f, 0.13425496f, -0.45227793f, -0.00500493f, -0.20935735f, 0.10108820f, 
    0.09835696f, 0.01038048f, -0.00987096f, -0.13114153f, -0.00078125f, -0.03727043f, -0.01329211f, 0.09445729f, 
    -0.11106252f, 0.03294274f, 0.19174471f, 0.04636221f, -0.01334948f, 0.04422374f, 0.02950099f, 0.11411536f, 
    0.03938893f, 0.02904783f, 0.07495863f, -0.06516999f, 0.26928508f, 0.20558348f, -0.07084452f, -0.36139616f, 
    0.08184749f, 0.00873653f, 0.04445859f, 0.02025850f, -0.01037534f, 0.10251822f, 0.03777869f, -0.02439474f, 
    -0.24783540f, -0.09918085f, -0.08033390f, 0.14872372f, -0.04111722f, 0.06953547f, 0.01680589f, 0.02209132f, 
    -0.04425299f, -0.07053067f, -0.14703389f, 0.05885280f, -0.54735118f, 0.34711891f, -0.10796080f, 0.03227276f, 
    -0.05404013f, 0.06675222f, 0.01236363f, 0.02110025f, 0.02082875f, -0.10635818f, 0.01324467f, 0.02994388f, 
    0.01962001f, -0.14223573f, 0.13963252f, 0.32318529f, 0.05414520f, -0.04376398f, 0.04285837f, 0.01162284f, 
    0.06292234f, -0.04527664f, -0.04974874f, -0.04141057f, 0.11933346f, 0.18407729f, 0.13750999f, -0.09438191f, 
    -0.02374593f, -0.09043452f, 0.01957648f, 0.05359755f, 0.00917467f, -0.04662995f, 0.05366786f, 0.01551521f, 
    -0.19263096f, 0.28366151f, -0.15852299f, -0.14908260f, -0.00980796f, 0.06755088f, 0.03100864f, 0.02250670f, 
    0.18414406f, 0.03581600f, 0.08076555f, -0.01203757f, -0.03419288f, -0.16651197f, 0.05361426f, -0.13941365f, 
    -0.10542223f, -0.12499014f, 0.01990476f, 0.08700441f, -0.00240248f, -0.00467586f, -0.03529634f, 0.01580400f, 
    -0.13649823f, 0.01074975f, 0.12798469f, -0.20773879f, -0.02420561f, 0.05537426f, 0.07276063f, 0.02825846f, 
    0.00814822f, 0.08832231f, 0.06292246f, -0.01724219f, -0.01634421f, 0.05345474f, -0.10370295f, 0.12676375f, 
    0.01325600f, -0.01142392f, 0.07413036f, 0.19410828f, 0.08197194f, -0.13847581f, 0.03046918f, 0.07336920f, 
    -0.15195568f, 0.05101375f, 0.05038292f, -0.01682244f, 0.05421245f, -0.15479682f, 0.07229512f, 0.15657166f, 
    0.17661163f, 0.05449117f, 0.07652936f, -0.01405194f, -0.00064894f, 0.02270771f, -0.07766829f, -0.09193791f, 
    0.00253285f, 0.01873182f, 0.01846601f, 0.00932763f, 0.05946990f, 0.04374314f, -0.13654621f, 0.06568276f, 
    0.29030189f, -0.13089061f, -0.00309435f, 0.31910577f, -0.05464973f, 0.11635771f, -0.01440885f, 0.03827119f, 
    0.04409062f, 0.02982311f, -0.02154258f, -0.02017945f, 0.01077683f, 0.15855168f, -0.06648790f, -0.00564354f, 
    0.11120460f, -0.04979000f, -0.05115442f, -0.05470492f, 0.00295378f, -0.00901744f, 0.08619446f, 0.03564104f, 
    0.27266452f, 0.18275478f, -0.11350801f, 0.12018927f, 0.07102738f, 0.03218447f, 0.00228053f, 0.13964199f, 
    -0.05873808f, 0.15195404f, 0.07908519f, 0.00340241f, -0.03256019f, 0.16792330f, 0.08803651f, -0.32132104f, 
    0.03332699f, 0.03598088f, 0.02930596f, 0.10834444f, 0.03998166f, 0.01319621f, -0.07049318f, 0.06229803f, 
    0.03155117f, -0.03929752f, -0.04356686f, -0.03143955f, -0.04204380f, 0.01728498f, 0.02267595f, -0.01194783f, 
    -0.01734211f, 0.03363404f, 0.03097052f, 0.03570871f, 0.01154354f, -0.01342114f, -0.02540297f, 0.04173899f, 
    0.02795218f, 0.00526627f, -0.04242955f, -0.04340406f, 0.02386817f, -0.02157387f, -0.01651888f, 0.01619581f, 
    -0.00331817f, 0.02912874f, -0.02162602f, -0.00355110f, 0.00119329f, 0.01753543f, 0.00611319f, 0.04052638f, 
    0.01844618f, 0.04345572f, 0.02436853f, -0.03482489f, 0.04348163f, 0.00298886f, -0.01413611f, -0.02310966f, 
    -0.00659820f, -0.04055613f, -0.03606615f, -0.00077126f, 0.03384614f, -0.00228786f, 0.02836478f, -0.03843421f, 
    -0.05062636f, -0.00572529f, -0.02494042f, -0.01192170f, 0.01976979f, 0.02281459f, 0.02468664f, -0.00831058f, 
    0.01438157f, 0.02545411f, 0.01736975f, 0.01680972f, -0.04970320f, 0.00468763f, -0.02440546f, -0.05066085f, 
    -0.03619161f, 0.01141687f, 0.03184668f, -0.02062265f, -0.02535072f, -0.05451795f, 0.02699077f, -0.03152688f, 
    -0.00958064f, -0.05379317f, -0.03973662f, -0.05159319f, -0.04466981f, 0.00137340f, 0.03504267f, -0.03642064f, 
    0.03949942f, 0.01998060f, 0.04444886f, 0.01860584f, -0.05053313f, -0.05146203f, 0.02333544f, 0.02483678f, 
    -0.01671561f, 0.04367555f, -0.00229117f, 0.01733224f, -0.03592223f, -0.02765802f, 0.01635841f, 0.00349401f, 
    -0.03096354f, -0.00020612f, 0.00201997f, -0.02909377f, -0.05609658f, 0.03008036f, -0.01830737f, -0.03472733f, 
    0.00402261f, -0.00769678f, -0.01166905f, 0.04156315f, -0.03082046f, 0.01413233f, 0.03154529f, -0.03961973f, 
    -0.04655574f, 0.03636421f, 0.02621975f, -0.05496688f, 0.00938787f, -0.01100765f, -0.00553336f, -0.00680378f, 
    -0.04276529f, 0.01339342f, 0.03502030f, 0.03720934f, 0.01298971f, -0.02815369f, 0.04433259f, 0.02280918f, 
    -0.01930342f, 0.02296154f, -0.01889077f, 0.01619158f, 0.02277316f, -0.00436147f, -0.03136332f, 0.00164757f, 
    0.02552825f, -0.05646652f, 0.00381621f, -0.02614032f, 0.03150633f, -0.04718514f, -0.05167637f, 0.02326617f, 
    -0.01836632f, -0.04000555f, -0.01307611f, -0.01670554f, -0.01032649f, -0.04871960f, -0.05084338f, 0.03031543f, 
    0.01943062f, -0.01323443f, 0.01700203f, 0.01326424f, -0.03949579f, -0.01619641f, 0.03188839f, 0.01601155f, 
    0.01902498f, 0.03589329f, -0.01489320f, -0.00169831f, 0.00641155f, 0.03146670f, -0.05168409f, 0.02408076f, 
    -0.02968939f, -0.01757398f, 0.02033411f, -0.01890798f, -0.00223379f, 0.00841572f, -0.00706053f, -0.01587827f, 
    -0.01960179f, 0.04323924f, -0.05418906f, 0.04606233f, -0.01723499f, 0.04065887f, 0.02889547f, 0.01160485f, 
    -0.02070152f, -0.01393909f, -0.01932646f, 0.01555463f, 0.03387642f, 0.03210045f, -0.01222053f, 0.04289071f, 
    0.00712774f, -0.02003118f, 0.02154819f, 0.02358122f, 0.03603841f, -0.02672162f, -0.01849796f, 0.01961949f, 
    0.00468756f, -0.05341816f, -0.02031443f, 0.04534238f, -0.04024297f, -0.01243737f, -0.04508716f, 0.03854934f, 
    0.02400856f, 0.02452371f, 0.03302575f, 0.02903950f, -0.00965420f, 0.04684965f, -0.04293680f, 0.00551673f, 
    -0.02426226f, -0.03382345f, -0.02498740f, -0.00175668f, -0.02002747f, -0.00803977f, 0.02748504f, -0.02125995f, 
    0.00861929f, 0.00591935f, -0.03552586f, 0.03993154f, -0.02710710f, 0.04846419f, -0.01922934f, 0.01671191f, 
    -0.05625680f, -0.05559804f, -0.02706433f, -0.03150450f, 0.01499193f, -0.04928198f, -0.05351725f, 0.00421796f, 
    0.03063479f, -0.02054429f, -0.05024067f, -0.02527864f, -0.00960388f, -0.04143349f, -0.03302495f, -0.05730475f, 
    -0.04821467f, 0.03922119f, -0.01623140f, 0.00742101f, -0.00995654f, -0.04043302f, -0.01350834f, -0.02752630f, 
    0.04057501f, -0.02579439f, -0.01140302f, -0.02619563f, 0.02245244f, 0.03908379f, -0.00113291f, -0.02977174f, 
    -0.04213944f, 0.01744442f, 0.00439470f, 0.04304352f, 0.02554915f, 0.03274063f, 0.00488461f, 0.00024716f, 
    -0.03516116f, -0.04811262f, 0.01569595f, -0.00771040f, -0.01642775f, -0.00976284f, 0.01681796f, 0.02276075f, 
    0.04306357f, 0.00709572f, 0.01990823f, 0.02689817f, -0.03244937f, -0.03036596f, -0.03764848f, 0.00541584f, 
    0.02928003f, -0.05406322f, -0.03077511f, -0.00130611f, 0.01687108f, -0.00669276f, 0.04099644f, -0.02147174f, 
    -0.00606606f, -0.05399990f, -0.04876024f, 0.01649941f, -0.00791229f, -0.04084162f, -0.03110458f, -0.01220598f, 
    0.02694439f, -0.00467369f, 0.00026875f, 0.00346808f, -0.05202728f, -0.01052193f, -0.05052575f, -0.01627311f, 
    0.03108204f, 0.04093718f, 0.00742448f, 0.01986063f, 0.03410742f, -0.03688967f, 0.04087180f, -0.04317767f, 
    0.02366738f, -0.02533987f, -0.00726723f, -0.02219054f, -0.05673599f, 0.03647129f, 0.03883895f, 0.03921982f, 
    -0.01547201f, -0.05045527f, -0.01918273f, -0.05038422f, -0.01995536f, -0.03913317f, -0.04416982f, -0.01405951f, 
    0.04376593f, -0.01380114f, -0.04082312f, -0.02348895f, -0.05284912f, 0.04058618f, -0.00901388f, -0.00045127f, 
    0.01843931f, 0.04305391f, -0.02310316f, -0.02801968f, 0.02953084f, -0.00760514f, 0.02124975f, -0.03977771f, 
    -0.04817705f, -0.04649844f, -0.00981121f, -0.01256535f, 0.00803080f, -0.01717991f, -0.00792840f, -0.01342996f, 
    -0.00201575f, -0.05060903f, 0.02877391f, -0.03267161f, -0.04917318f, 0.01461089f, -0.00000308f, -0.05014948f, 
    0.02144795f, 0.01588295f, -0.05494681f, -0.01688917f, -0.01262035f, 0.00286652f, 0.00714459f, 0.02293421f, 
    0.03184622f, -0.04435203f, 0.03452990f, -0.05165219f, 0.00223257f, 0.02235975f, -0.04446309f, 0.04098037f, 
    0.15394247f, 0.03638341f, 0.11550546f, -0.02533124f, -0.15475588f, -0.00110609f, 0.06792741f, 0.23662120f, 
    0.09169330f, -0.08037505f, 0.04386797f, -0.02623958f, -0.50358832f, -0.13425723f, -0.07592934f, -0.32968071f, 
    0.02513217f, 0.03848981f, -0.03789503f, -0.00330651f, 0.05469499f, 0.08099070f, -0.05437304f, 0.09336903f, 
    0.18633178f, -0.02231585f, 0.03189063f, 0.25591663f, 0.09099881f, 0.33645386f, -0.05523355f, 0.11029513f, 
    -0.12104567f, -0.02065027f, 0.05641356f, -0.03859228f, 0.21380660f, -0.00714935f, 0.28522569f, 0.18209052f, 
    0.01275285f, 0.03568346f, 0.10046530f, 0.00644371f, 0.03704114f, 0.06122578f, 0.16894595f, 0.02573968f, 
    -0.10549646f, -0.17541207f, 0.02692134f, -0.39414516f, 0.06340128f, -0.08360224f, 0.00205895f, -0.01462043f, 
    -0.07723100f, -0.02663055f, -0.07239417f, 0.12975112f, 0.08921658f, -0.17695341f, 0.01838036f, 0.12869534f, 
    -0.11858831f, 0.14050262f, -0.00370978f, 0.05024940f, 0.10284001f, -0.09048821f, 0.05967202f, 0.05467137f, 
    0.09985162f, -0.07938617f, 0.02064776f, -0.11817230f, 0.11691647f, 0.08300564f, 0.10751759f, 0.09615261f, 
    -0.11282407f, 0.07494839f, -0.02993591f, -0.04348148f, -0.08531939f, 0.06997919f, 0.09537382f, 0.37864152f, 
    0.09624184f, 0.15074927f, -0.03641704f, 0.04151652f, 0.09502080f, -0.00079706f, 0.02297747f, -0.00094499f, 
    0.19207621f, 0.13917936f, -0.13954122f, 0.15679330f, 0.04943689f, 0.01473376f, -0.04551717f, -0.06498662f, 
    -0.05167771f, -0.10489811f, -0.12100928f, -0.03046910f, -0.02442202f, -0.11772456f, -0.25234789f, -0.08028807f, 
    -0.25165698f, 0.01266654f, -0.03639917f, 0.01782578f, -0.02452214f, 0.09023702f, -0.09683090f, 0.12456571f, 
    0.15296392f, 0.06370967f, -0.01820117f, 0.11822980f, -0.02803506f, -0.01304488f, 0.01111781f, -0.06562758f, 
    0.25708708f, 0.15558088f, 0.17819797f, 0.16685319f, -0.13589700f, -0.01282065f, -0.03449245f, -0.00348326f, 
    -0.08117769f, 0.04296191f, 0.11995798f, 0.07429103f, 0.03332501f, -0.04232672f, 0.14682145f, -0.09860113f, 
    0.11978614f, 0.01132658f, 0.09203506f, 0.13619713f, -0.03356905f, 0.09578351f, -0.04338728f, 0.01161280f, 
    0.04110194f, 0.09298103f, 0.01879646f, 0.05060195f, -0.27569869f, -0.09633656f, -0.15203655f, -0.24040361f, 
    0.23789576f, 0.03357663f, 0.01333572f, -0.09090091f, 0.03035906f, 0.05268922f, -0.06209859f, 0.11502805f, 
    -0.05028255f, 0.00451970f, -0.14327122f, 0.10089181f, 0.02419794f, -0.06867149f, 0.04689005f, -0.03764323f, 
    -0.11950938f, 0.05357101f, 0.00398487f, -0.09332817f, 0.27703372f, 0.24307901f, 0.20298487f, -0.10759258f, 
    0.00460643f, 0.05194076f, 0.07543052f, 0.11025087f, -0.06919834f, -0.00678856f, 0.01361091f, -0.02478254f, 
    0.29617101f, 0.08345184f, -0.09695746f, 0.07500743f, 0.00156187f, -0.00562726f, 0.01388038f, -0.14505194f, 
    -0.00009519f, 0.05389702f, -0.06335317f, -0.05293849f, 0.16912206f, -0.03309008f, 0.14618005f, 0.39979136f, 
    -0.03133042f, -0.01645062f, -0.02052845f, -0.02863079f, 0.13835849f, -0.00821805f, 0.00724417f, 0.10605993f, 
    0.25669700f, 0.11056878f, 0.00435141f, -0.08083966f, 0.07818303f, -0.06847937f, 0.02620680f, -0.03115506f, 
    0.16237891f, 0.17132138f, 0.18105377f, -0.02186000f, 0.36900932f, -0.05522761f, 0.08484791f, 0.09467708f, 
    0.14906180f, 0.01735492f, 0.01670442f, 0.07634785f, 0.00236685f, 0.11000156f, 0.01673230f, 0.14822061f, 
    0.06202946f, 0.08200155f, -0.21699131f, -0.23560487f, 0.14496009f, 0.09288979f, -0.04084099f, -0.05018939f, 
    -0.06855600f, -0.02260583f, 0.12574255f, -0.03110685f, -0.10502128f, -0.01938484f, -0.15740123f, 0.05645802f, 
    0.02728840f, 0.00538658f, 0.06624803f, 0.01447291f, 0.02574399f, 0.08321063f, -0.04345750f, 0.09413964f, 
    0.10993810f, -0.07048682f, 0.20608173f, 0.29000020f, 0.07290690f, -0.04321500f, 0.02440803f, 0.05112764f, 
    -0.19522692f, 0.09039848f, 0.00166363f, -0.07857782f, 0.04346865f, 0.25247791f, -0.08907808f, 0.20787734f, 
    0.00477546f, 0.06653316f, -0.00183877f, -0.11952230f, 0.08909977f, 0.22797298f, 0.00108702f, 0.02289082f, 
    0.08895073f, -0.15160666f, -0.11649313f, 0.11226703f, -0.11507902f, 0.05791055f, -0.00197523f, 0.04609087f, 
    0.02211146f, 0.02112022f, 0.00011073f, 0.04866549f, 0.06307281f, 0.06233058f, -0.11048646f, -0.24561302f, 
    -0.09519932f, -0.03266707f, 0.08076957f, -0.13640006f, 0.03053466f, 0.12871045f, -0.01078973f, -0.05688295f, 
    0.21423772f, 0.00565025f, -0.04338466f, -0.16175315f, -0.01214945f, 0.18727659f, -0.09276357f, 0.00121892f, 
    -0.06703120f, -0.02154628f, -0.03009717f, 0.12128932f, -0.02299121f, 0.05683275f, 0.05423912f, 0.07033250f, 
    -0.02896194f, 0.10330152f, 0.06501207f, -0.02200879f, 0.00367907f, 0.01954084f, 0.17386207f, -0.10484709f, 
    -0.55606830f, -0.03345324f, -0.04793032f, -0.25765985f, 0.17413308f, -0.00444004f, 0.17360792f, 0.05066234f, 
    0.03268078f, 0.05510150f, 0.03148924f, 0.08123399f, -0.15775847f, -0.10220486f, 0.06712227f, -0.07364592f, 
    -0.12166095f, -0.05666481f, 0.07807165f, 0.09965751f, -0.07645445f, -0.03912891f, -0.06317767f, 0.08855876f, 
    -0.15108401f, -0.06393674f, -0.05692074f, 0.02359354f, -0.16683523f, -0.11459370f, 0.09536513f, -0.07340392f, 
    0.03453419f, -0.05021177f, -0.03240989f, 0.02979169f, 0.19564758f, -0.16269290f, 0.07859407f, 0.15704465f, 
    -0.17877829f, 0.11002486f, -0.04213526f, -0.04165143f, -0.12889631f, 0.05740015f, 0.04501786f, 0.04817836f, 
    0.13413344f, -0.04800267f, -0.20497392f, 0.02850106f, -0.07139782f, 0.04628325f, -0.02551539f, 0.07816439f, 
    0.09647052f, -0.07276769f, 0.02201423f, -0.03649666f, 0.02599074f, -0.04480271f, -0.21234517f, 0.01274903f, 
    0.21041590f, -0.00666449f, -0.05541550f, -0.04012038f, 0.06822530f, -0.13112195f, 0.09471889f, -0.08869115f, 
    -0.23033851f, -0.04488763f, -0.06903764f, -0.23222372f, 0.06928725f, -0.05562257f, 0.03143071f, -0.06728373f, 
    -0.06586214f, -0.00579934f, -0.07092057f, 0.00682898f, -0.09527553f, -0.01899079f, 0.18918522f, 0.28055558f, 
    0.01054022f, 0.18930322f, -0.14250506f, 0.02420279f, 0.02145782f, -0.07692350f, 0.00544230f, -0.02014419f, 
    -0.12369010f, 0.09434926f, -0.01016271f, 0.00942852f, 0.03202721f, -0.04157577f, -0.11534159f, -0.06554220f, 
    0.05272539f, -0.10186440f, -0.02450897f, -0.01205540f, 0.17206939f, 0.23885082f, 0.15307584f, -0.08128259f, 
    0.06509960f, 0.07084340f, -0.06874039f, 0.07395227f, 0.09171632f, 0.04599676f, -0.09388738f, -0.07705795f, 
    -0.11226464f, 0.11613427f, -0.12810045f, 0.03544549f, 0.07744775f, 0.00884034f, -0.06490154f, 0.03872791f, 
    -0.09622086f, -0.01075510f, 0.13752434f, 0.12165466f, 0.32894623f, 0.26557121f, 0.29366326f, -0.18257363f, 
    0.09517711f, -0.08744033f, -0.00689419f, -0.07787210f, 0.04812746f, -0.07799416f, 0.00804960f, 0.03426378f, 
    0.17728548f, -0.12594023f, 0.20132823f, -0.05501942f, -0.08887644f, -0.16932558f, 0.07368318f, 0.09653055f, 
    0.03909599f, 0.02132617f, 0.08985665f, 0.14271824f, 0.31226033f, 0.08548853f, 0.15225309f, 0.05244501f, 
    0.11152042f, 0.06245299f, 0.03453439f, 0.14009999f, 0.15823746f, -0.08273214f, -0.04435470f, -0.13690621f, 
    0.00759299f, -0.01693160f, 0.02277647f, 0.05950008f, -0.01593976f, -0.09005185f, 0.11277500f, 0.01976598f, 
    -0.08550716f, 0.10314465f, -0.02173238f, -0.01187298f, 0.29747680f, 0.12127456f, 0.16019478f, -0.06707150f, 
    0.07854641f, 0.00952486f, 0.05870391f, 0.11894353f, 0.11714020f, 0.09344581f, -0.16627917f, -0.16960305f, 
    -0.24458691f, -0.06484789f, 0.08195831f, 0.03279748f, 0.00427340f, -0.01440885f, 0.04966307f, -0.01234957f, 
    -0.01193896f, -0.24967937f, -0.09069248f, 0.04837164f, -0.18059675f, 0.04437668f, -0.18025731f, -0.08589392f, 
    0.05825443f, -0.02644674f, 0.04662877f, -0.04506705f, 0.05208854f, 0.07588413f, -0.06632072f, -0.11515101f, 
    -0.04535280f, 0.25875285f, 0.05831809f, 0.08761395f, 0.03687557f, -0.00569632f, 0.06132248f, -0.02607730f, 
    0.05026110f, 0.09979274f, -0.06210070f, 0.02029104f, 0.19275162f, 0.22945657f, -0.09264436f, 0.19165765f, 
    -0.01475644f, 0.08302154f, -0.05662717f, -0.11331505f, 0.04872361f, -0.03986019f, 0.08294812f, 0.00261973f, 
    0.02501302f, 0.06717192f, -0.16066921f, -0.09972581f, -0.05405760f, -0.02035252f, 0.02735675f, 0.05327104f, 
    -0.05599074f, 0.08167975f, 0.05267074f, 0.03365304f, -0.05609714f, -0.26362398f, 0.04468597f, 0.17998375f, 
    0.03059880f, 0.13579088f, 0.03543847f, 0.12466125f, 0.06356155f, 0.05879412f, 0.04348678f, 0.10007627f, 
    0.04894952f, 0.02480152f, -0.04949813f, 0.16804077f, 0.05889784f, 0.09549937f, -0.13049333f, -0.06737387f, 
    0.05894168f, 0.13286883f, 0.04266475f, 0.09941926f, 0.11502525f, -0.23481865f, 0.10892805f, -0.11454705f, 
    0.02344659f, 0.03261076f, -0.03698751f, 0.07940818f, -0.04419305f, -0.00125597f, 0.12095659f, -0.02122343f, 
    0.24742071f, -0.02130981f, -0.14741248f, -0.18009384f, -0.06052124f, 0.09839617f, 0.01132403f, 0.03032329f, 
    -0.07348969f, 0.02885152f, -0.05224442f, 0.12888184f, -0.07330086f, 0.01470348f, -0.03596495f, 0.14003049f, 
    0.02613475f, -0.05521636f, 0.12198925f, -0.06329662f, 0.05744028f, 0.16406602f, -0.04722198f, -0.16393735f, 
    0.35431021f, -0.05952962f, -0.00467204f, -0.08856869f, -0.11087508f, -0.00060658f, -0.13969003f, -0.02909034f, 
    -0.00324488f, 0.01675737f, 0.18374546f, -0.02700958f, -0.09674890f, 0.10825976f, 0.05401713f, 0.02993153f, 
    0.06029666f, 0.07232884f, 0.02655345f, 0.02537582f, -0.02685270f, 0.00096251f, -0.02815729f, -0.11192639f, 
    0.31240088f, -0.01821972f, 0.07866906f, -0.19743983f, 0.12325870f, -0.01470909f, -0.03632947f, -0.01664917f, 
    0.00178400f, -0.01543988f, 0.04738823f, 0.00220656f, 0.04636331f, -0.19052719f, 0.02141772f, 0.22270302f, 
    0.04084830f, 0.07298831f, -0.01486954f, 0.02312480f, -0.03100176f, -0.14989565f, 0.08443391f, -0.02118351f, 
    -0.01186044f, -0.01302915f, 0.06050193f, 0.03094582f, 0.07734855f, 0.03482617f, 0.10534136f, -0.04041862f, 
    -0.15752307f, -0.10441668f, 0.16713445f, -0.13750242f, 0.08960912f, -0.01835586f, -0.00369008f, -0.19364487f, 
    -0.02223024f, 0.01103751f, -0.01681061f, 0.05437357f, 0.08854179f, -0.10161712f, 0.12270518f, 0.00618249f, 
    -0.32520199f, -0.05070514f, -0.25829169f, 0.32097816f, 0.11969578f, -0.13307030f, -0.08591943f, -0.03742293f, 
    0.16286363f, -0.04028121f, -0.10143439f, 0.04982639f, 0.35722888f, -0.03185393f, 0.08458698f, -0.12318394f, 
    0.07877303f, 0.01871793f, -0.04493453f, -0.02347563f, 0.06289892f, 0.02440818f, 0.10751002f, 0.08344520f, 
    0.30564249f, 0.34290227f, 0.06114929f, -0.09082776f, 0.09259263f, 0.03364167f, -0.03189989f, 0.07652052f, 
    -0.04257726f, 0.12815559f, -0.14510290f, -0.06380098f, -0.06113294f, -0.13902609f, 0.01807581f, -0.14522739f, 
    -0.01221989f, -0.02760255f, 0.08286127f, -0.12077527f, 0.02536685f, -0.12142749f, 0.10295959f, -0.01321361f, 
    -0.07937270f, 0.09319586f, 0.01038382f, -0.03990760f, -0.10124441f, -0.06060851f, 0.05894606f, 0.18653864f, 
    0.07475080f, -0.04645738f, 0.22261949f, -0.06200914f, 0.27437562f, 0.21205135f, 0.22088708f, 0.03815123f, 
    -0.07536593f, -0.04372340f, 0.08482861f, 0.12503964f, 0.04390826f, 0.09875497f, 0.05355662f, -0.02435161f, 
    -0.12857500f, 0.00773095f, 0.09964421f, 0.04721062f, -0.08764135f, 0.04453374f, 0.07557897f, 0.05974811f, 
    0.01361047f, -0.04692391f, -0.09929749f, 0.03637688f, -0.16733398f, 0.07320756f, 0.02100653f, 0.07970145f, 
    0.08975346f, 0.17032935f, -0.06048068f, 0.04639956f, 0.02529900f, 0.03735080f, 0.14088538f, 0.01505237f, 
    0.06747981f, 0.11863923f, 0.24277298f, 0.12986436f, -0.03901596f, 0.09537610f, 0.14670095f, 0.04828336f, 
    0.00529860f, 0.00128796f, 0.00567992f, 0.11271261f, -0.13417867f, 0.00709151f, 0.00264034f, -0.00293253f, 
    0.20573288f, 0.01151638f, 0.05951402f, -0.05526847f, 0.15037137f, 0.01011292f, -0.01996068f, 0.12256790f, 
    0.35616440f, -0.01444131f, 0.01635608f, -0.12018272f, 0.12910964f, -0.08437688f, 0.01115264f, 0.04398728f, 
    0.06118286f, -0.06917792f, -0.13227160f, 0.04110898f, 0.39886642f, 0.19411016f, -0.02080465f, 0.04367991f, 
    0.01832014f, -0.01843463f, -0.00341956f, 0.05828529f, -0.01604958f, 0.08281710f, 0.06668589f, 0.05357832f, 
    -0.08991350f, -0.30069259f, -0.06891665f, -0.00084762f, -0.00568447f, -0.04972262f, -0.00439701f, 0.00251887f, 
    -0.04920243f, -0.05675132f, -0.07602642f, -0.04580885f, -0.01319375f, -0.15938881f, -0.06857171f, -0.15294869f, 
    0.16517062f, 0.06561038f, -0.04610727f, 0.05066786f, 0.04318495f, 0.08054283f, -0.04019599f, 0.09749038f, 
    -0.15305701f, 0.01537485f, 0.09543622f, 0.01604614f, -0.03999136f, -0.10453101f, 0.01698764f, 0.12172151f, 
    -0.11294506f, 0.04297408f, -0.01202384f, 0.04578007f, -0.10375893f, -0.02081771f, 0.13942146f, 0.04406291f, 
    0.11498438f, -0.02089232f, -0.03247971f, 0.04103117f, 0.02703526f, 0.08149477f, 0.11601163f, -0.01806214f, 
    -0.01336824f, 0.08744400f, 0.12450537f, -0.09312177f, 0.00282199f, -0.09662496f, -0.04448191f, -0.01921829f, 
    -0.04261275f, -0.05014960f, 0.21611473f, 0.16673999f, 0.30906877f, 0.33227375f, 0.01163448f, -0.04411767f, 
    -0.10447967f, -0.02161279f, 0.05460991f, 0.17012110f, -0.02393973f, 0.06857188f, -0.10314894f, -0.05879685f, 
    -0.41663724f, 0.10944119f, -0.06810508f, -0.18306032f, 0.16802642f, 0.03012210f, -0.08597771f, -0.02177913f, 
    -0.01431885f, -0.05612190f, 0.04539417f, 0.03606148f, 0.05944956f, -0.01649386f, 0.01960189f, 0.07315021f, 
    0.11143091f, 0.01371224f, -0.02301917f, -0.04340794f, -0.03474802f, 0.02904843f, -0.09009270f, -0.00363729f, 
    -0.22647405f, 0.02004315f, 0.06773565f, 0.10463488f, 0.03699334f, -0.08764503f, 0.11991201f, -0.02590400f, 
    0.06196288f, -0.05515245f, 0.02631120f, -0.13678332f, -0.16140604f, -0.30741602f, 0.09999734f, 0.08333638f, 
    -0.16989686f, -0.08128202f, 0.00672818f, 0.09231365f, -0.14248142f, -0.03180957f, 0.07258472f, 0.05921897f, 
    -0.32051069f, 0.03950437f, -0.05665173f, 0.20487824f, 0.07085969f, 0.01051876f, -0.06067856f, 0.00520038f, 
    0.01891322f, 0.10511951f, 0.12274053f, -0.04132623f, -0.08561309f, -0.16813105f, 0.24449715f, 0.10290911f, 
    0.00733540f, 0.06059615f, -0.03978024f, -0.01547537f, -0.04122568f, -0.07229815f, 0.01757281f, 0.07945571f, 
    0.39707121f, 0.15338258f, 0.06899463f, -0.09636443f, -0.08525568f, -0.06756035f, -0.02622946f, 0.12304762f, 
    -0.00973276f, -0.05130474f, -0.05706058f, -0.03114530f, -0.39700732f, -0.01555224f, -0.16096441f, -0.02056307f, 
    0.18282165f, -0.02154508f, -0.11047567f, -0.04427223f, 0.03602213f, 0.05877852f, 0.05618402f, 0.12666160f, 
    0.20551512f, 0.09054227f, 0.06410909f, 0.13631101f, 0.04896698f, -0.05838691f, -0.01281242f, -0.04371137f, 
    0.03439243f, 0.04810334f, 0.03027667f, -0.04069189f, -0.00913802f, 0.01551604f, -0.00416632f, -0.02503814f, 
    0.00797354f, -0.07190214f, -0.00342188f, 0.09061359f, 0.05834191f, 0.06236903f, -0.04196208f, -0.04785667f, 
    0.18103026f, -0.12280434f, 0.08743077f, -0.03944070f, -0.09340774f, -0.02119314f, 0.01282399f, -0.06592812f, 
    0.06774913f, 0.06919137f, 0.03577789f, 0.11406492f, -0.09725778f, -0.01590648f, -0.22673519f, 0.05642952f, 
    0.06109641f, 0.00117260f, 0.00353680f, 0.07615756f, 0.04211885f, 0.10662059f, -0.01846526f, -0.14392635f, 
    -0.10049046f, -0.17249177f, -0.13397902f, 0.13410465f, 0.00067915f, -0.04799437f, -0.06698062f, 0.07410304f, 
    -0.04975299f, -0.01125895f, 0.07447827f, 0.09092180f, 0.16693331f, 0.06339396f, 0.13665774f, -0.05378479f, 
    -0.04382375f, -0.00179205f, -0.01509964f, -0.03607418f, 0.05644533f, 0.00752810f, 0.09854854f, -0.10387105f, 
    0.07838216f, 0.09675596f, 0.08089124f, 0.08159737f, 0.01607051f, 0.02461819f, 0.09371253f, 0.01495604f, 
    0.07772577f, 0.07873370f, 0.03167031f, 0.16649511f, 0.00378102f, -0.07352193f, 0.09824650f, -0.01697405f, 
    0.09561198f, -0.01982109f, 0.05995196f, -0.07676898f, 0.01790192f, -0.12257572f, -0.06792041f, -0.06371937f, 
    -0.12755577f, 0.03344814f, -0.02183923f, -0.08579585f, 0.24014187f, 0.14099351f, 0.09554163f, -0.02660075f, 
    0.02912794f, 0.03851163f, 0.09720364f, 0.02491383f, 0.18407632f, -0.25786659f, 0.16485795f, -0.03834128f, 
    -0.09770530f, 0.16764235f, -0.04670022f, 0.02101072f, 0.07569405f, 0.01059057f, -0.06850113f, 0.08335907f, 
    -0.05413958f, -0.00157748f, 0.03049570f, 0.02638828f, 0.03963604f, -0.02100094f, 0.03060625f, -0.05212147f, 
    -0.02418823f, 0.00497480f, 0.01354762f, -0.01706289f, 0.02598579f, 0.00560227f, -0.04372083f, 0.03723110f, 
    -0.03211406f, -0.04275320f, -0.01051342f, -0.01373919f, -0.03303329f, 0.02344468f, 0.03968048f, 0.04394227f, 
    0.03589943f, -0.04219839f, -0.02648867f, -0.02197762f, -0.04922179f, 0.03504139f, -0.01703749f, -0.04286224f, 
    -0.04765689f, -0.01868187f, -0.04583372f, 0.00494416f, 0.02775585f, -0.03708959f, 0.03932084f, 0.01253841f, 
    -0.02678193f, -0.05341395f, -0.04937876f, -0.03877281f, -0.02545481f, 0.03323368f, -0.02874086f, 0.03732837f, 
    0.01653513f, -0.05574143f, 0.03926820f, -0.00200880f, 0.03134903f, -0.00764923f, -0.03601888f, -0.01812132f, 
    -0.02667407f, -0.02830818f, 0.00051659f, -0.02172802f, -0.03063830f, -0.02802606f, 0.02139451f, -0.02041779f, 
    -0.05545037f, 0.03354145f, -0.05417939f, -0.05618632f, -0.00689930f, 0.03129350f, -0.03236826f, 0.04383625f, 
    0.04088499f, -0.05239163f, -0.01608626f, 0.02627678f, -0.01886026f, -0.03544577f, -0.00732471f, -0.02687793f, 
    -0.01067346f, -0.05301635f, -0.05591095f, -0.02993848f, 0.03372429f, 0.00852439f, -0.00795452f, -0.02936973f, 
    0.03301796f, -0.03682290f, -0.05296595f, -0.02214354f, 0.01329075f, -0.04707373f, -0.03376648f, -0.03837739f, 
    0.00267889f, 0.01011962f, -0.00804400f, -0.01813881f, 0.00150692f, 0.00296967f, 0.00512793f, -0.00752716f, 
    0.01023303f, -0.05476965f, -0.00795308f, -0.05575365f, 0.00463603f, 0.00331436f, -0.02996669f, -0.02466952f, 
    -0.01880783f, 0.02999377f, 0.03788818f, 0.00153383f, -0.04806202f, 0.02903071f, -0.02945461f, 0.00031755f, 
    -0.03309363f, 0.02737561f, -0.01963593f, -0.04260973f, -0.04363799f, -0.00259510f, 0.02391672f, -0.01765862f, 
    -0.00832030f, 0.04264425f, -0.01947984f, -0.00618834f, -0.03149261f, -0.01476059f, -0.01746124f, 0.00720597f, 
    -0.01408343f, 0.03098061f, 0.02535943f, 0.02269412f, -0.03440229f, -0.04851438f, 0.04217784f, 0.03000370f, 
    -0.00277337f, -0.05211195f, -0.01502456f, 0.00850963f, 0.04085096f, 0.00368326f, -0.04193912f, 0.02742867f, 
    -0.03356860f, -0.00521430f, 0.01906531f, -0.01507708f, 0.02302642f, 0.02920111f, -0.04077121f, 0.01346268f, 
    -0.04973366f, 0.01666975f, -0.01482389f, -0.00888316f, -0.05694048f, -0.00821043f, -0.04661283f, -0.03115970f, 
    -0.05557711f, 0.02219532f, 0.03963339f, -0.03601377f, -0.01432020f, -0.02706434f, -0.01587699f, -0.03849554f, 
    0.00893665f, -0.04451258f, -0.03030455f, -0.00054742f, -0.02052148f, 0.04283715f, -0.00447582f, 0.03212771f, 
    0.01509107f, -0.00353852f, -0.00478294f, -0.02692449f, 0.02754952f, -0.05127420f, -0.01614968f, 0.00971213f, 
    0.00195090f, -0.03042168f, -0.01203664f, -0.05241686f, -0.01758345f, -0.02442779f, 0.03364769f, -0.04393989f, 
    0.03585412f, 0.01664161f, -0.01109123f, -0.03953632f, -0.05291415f, 0.01815913f, -0.01574204f, -0.02635236f, 
    -0.01507652f, -0.03861585f, 0.03736041f, -0.02487706f, -0.03382063f, 0.03808141f, 0.01470582f, 0.04181147f, 
    0.02099042f, -0.04716403f, 0.02492938f, -0.00704439f, -0.05655376f, 0.04160341f, -0.02796934f, -0.05674167f, 
    0.01530900f, 0.00635009f, -0.04733875f, 0.03009611f, -0.01998054f, 0.03752105f, 0.03453243f, -0.04539744f, 
    -0.04945124f, -0.04934800f, -0.04412527f, 0.01821283f, -0.02706657f, 0.03156050f, -0.01919317f, 0.02370904f, 
    0.00152129f, -0.01214154f, -0.03600267f, -0.05018729f, 0.01944761f, 0.02278951f, 0.04068146f, 0.03945212f, 
    -0.05206463f, -0.02565749f, 0.03986795f, 0.04039923f, -0.03778712f, -0.05459864f, 0.01327367f, 0.01520338f, 
    0.00722793f, 0.03352402f, -0.04240459f, -0.04892898f, -0.01886330f, 0.03222463f, -0.03392025f, 0.03790372f, 
    0.00318505f, -0.00885745f, 0.01913381f, -0.03437647f, -0.05609397f, -0.03615248f, 0.04432815f, 0.02725112f, 
    -0.00848369f, 0.01223950f, 0.04484918f, 0.00037730f, -0.00969743f, 0.03653592f, -0.01454282f, 0.01047587f, 
    -0.03326691f, -0.01686694f, 0.02831585f, 0.01204288f, -0.04788001f, 0.01998954f, 0.02978335f, -0.03460556f, 
    -0.01586325f, -0.00254767f, -0.01730095f, -0.00516619f, -0.03091561f, 0.03047677f, 0.03470242f, -0.05175706f, 
    -0.03939157f, -0.05030033f, 0.02182712f, 0.01857775f, -0.04693709f, -0.02189569f, -0.00586873f, 0.02857085f, 
    -0.01914973f, 0.03899741f, -0.03605100f, 0.02065250f, 0.02449332f, 0.04032547f, -0.00602573f, 0.00268167f, 
    -0.01767671f, 0.02435291f, 0.04491109f, -0.04455096f, 0.03580565f, -0.01760453f, -0.05380492f, 0.02280302f, 
    -0.03966939f, -0.04145738f, -0.02548712f, 0.02418461f, 0.03667859f, 0.01968865f, 0.01507117f, 0.01100932f, 
    0.01018196f, -0.04268459f, -0.04192930f, -0.02704381f, -0.02036899f, -0.03499457f, -0.01011952f, 0.00731776f, 
    -0.01378740f, 0.03962861f, -0.05699299f, 0.00009983f, -0.01540935f, -0.03355110f, 0.01827684f, -0.01744790f, 
    -0.04584580f, 0.00394596f, 0.02480898f, 0.02325311f, -0.00649068f, -0.04876751f, -0.03357271f, -0.05618752f, 
    0.02618984f, -0.05494588f, -0.04309516f, -0.00690400f, 0.02846189f, 0.01203889f, 0.00278674f, 0.02220058f, 
    0.03060287f, 0.03605508f, -0.02074317f, -0.02528660f, 0.01616703f, -0.02872928f, 0.00132289f, -0.02571161f, 
    0.02501311f, -0.03752458f, -0.00088032f, -0.00045245f, -0.02331319f, 0.02132682f, -0.00871965f, 0.02492366f, 
    -0.05467655f, -0.02266999f, 0.00978093f, -0.00733731f, -0.04772712f, 0.00394782f, 0.01920703f, 0.03815263f, 
    -0.02506722f, -0.00873592f, -0.03214042f, -0.02889315f, -0.00349634f, -0.01180061f, -0.05026106f, 0.02028985f, 
    -0.05225141f, -0.00400201f, -0.02752328f, 0.02459339f, -0.01397904f, -0.02473672f, 0.04414412f, -0.01560867f, 
    -0.01999065f, 0.02568243f, 0.01679558f, 0.02954953f, 0.01431296f, -0.00495950f, 0.01871249f, 0.04525006f, 
    0.01284531f, 0.03695544f, 0.03794488f, 0.00762959f, -0.00706624f, 0.04179442f, 0.00838974f, 0.01945783f, 
    -0.05489122f, -0.03715909f, 0.00506567f, -0.01152837f, 0.01642044f, -0.02991105f, -0.02670187f, 0.02197924f, 
    -0.01728605f, -0.04769879f, -0.04889981f, -0.02380401f, -0.03207219f, 0.02517420f, 0.04181305f, 0.03683142f, 
    -0.04665773f, -0.02895935f, -0.05784472f, 0.02702031f, 0.02748256f, 0.00368179f, -0.03315393f, 0.02845477f, 
    -0.02378921f, 0.02304854f, 0.00535776f, 0.03450733f, -0.00531904f, -0.02136233f, -0.02763462f, -0.01255295f, 
    -0.05052477f, -0.00511662f, -0.02116560f, 0.01679542f, 0.02645019f, 0.00383713f, 0.02453171f, 0.04606567f, 
    -0.02664546f, 0.05060403f, 0.02273151f, -0.04808066f, -0.00645797f, -0.01736792f, -0.03349013f, -0.01925136f, 
    0.00233257f, -0.03746953f, 0.03189238f, 0.02298287f, -0.01117098f, -0.00713358f, -0.04914202f, 0.03585479f, 
    0.00386515f, -0.02114377f, -0.01154143f, 0.00090662f, 0.01073903f, -0.04380802f, 0.04232948f, -0.05351711f, 
    0.03467721f, 0.03258073f, -0.01172317f, 0.03547717f, 0.01224326f, -0.03261348f, -0.01575940f, -0.03772696f, 
    -0.04277895f, 0.04884679f, -0.03214369f, -0.04455265f, -0.05960559f, -0.03413071f, -0.05637894f, -0.03651429f, 
    0.02356115f, -0.01255382f, 0.03433783f, -0.02189148f, -0.02904579f, 0.04993766f, 0.01797595f, 0.02417510f, 
    -0.02598294f, -0.02759071f, 0.01650808f, 0.01259310f, -0.03135476f, 0.01384712f, 0.00704891f, -0.03272065f, 
    -0.03610332f, 0.04725604f, -0.01073888f, -0.02125876f, 0.01868379f, -0.02882542f, -0.06002989f, -0.05424760f, 
    -0.01864532f, -0.05148516f, -0.01082894f, 0.04129583f, -0.00714933f, -0.03588359f, -0.02290658f, -0.01091236f, 
    -0.03539837f, -0.05105872f, 0.00947001f, -0.01232852f, 0.02927915f, 0.02806542f, 0.02021666f, 0.00900331f, 
    -0.03402713f, -0.00740056f, 0.01806519f, -0.01304710f, 0.00431272f, -0.04524519f, -0.04455210f, -0.06828825f, 
    0.03096615f, -0.03339875f, -0.03545981f, -0.03993181f, -0.05435743f, 0.00360350f, 0.02686899f, 0.03260008f, 
    0.05204951f, -0.00940380f, -0.04215220f, -0.02023622f, -0.02319161f, -0.03312791f, 0.03343112f, -0.01400869f, 
    -0.00453096f, -0.01041977f, 0.04589517f, -0.04157780f, 0.04411862f, 0.01526466f, 0.02285153f, 0.01092168f, 
    -0.04126727f, 0.01107824f, -0.03801394f, 0.00992897f, 0.02433445f, -0.01939036f, 0.01555604f, 0.00170155f, 
    0.04014629f, 0.01978025f, 0.02487000f, 0.00467668f, -0.04320714f, 0.00179918f, 0.02641949f, 0.02297712f, 
    0.04204380f, 0.02498846f, -0.02817256f, 0.02449073f, -0.03902709f, 0.01739658f, 0.00065190f, 0.00189007f, 
    0.02424244f, 0.04786558f, -0.02175935f, -0.02662287f, 0.02638059f, 0.04003612f, -0.01941947f, -0.03150278f, 
    -0.04337754f, -0.05447715f, 0.02862639f, 0.02761444f, 0.03680631f, 0.03032071f, 0.04596990f, 0.01605796f, 
    -0.01979958f, 0.03526293f, -0.00049596f, 0.02691574f, -0.04857014f, 0.03815750f, 0.02404557f, -0.05289329f, 
    0.02202446f, 0.04711148f, 0.03639561f, 0.00066773f, -0.03227697f, 0.03657518f, -0.04862939f, -0.03693663f, 
    0.04450593f, 0.00649857f, 0.02092793f, -0.05957492f, 0.02039174f, -0.03224131f, 0.02247474f, -0.03491564f, 
    -0.05117444f, -0.01180053f, -0.02936123f, -0.04659414f, -0.01614764f, -0.05300810f, -0.01598371f, -0.03426744f, 
    0.03355215f, -0.03485264f, -0.03843678f, -0.03401864f, 0.00229370f, -0.01984231f, 0.01787973f, 0.03818972f, 
    0.02593636f, 0.00432537f, 0.00780296f, 0.02521335f, -0.05728590f, 0.01756749f, 0.00970981f, 0.02553445f, 
    0.04176252f, -0.02220213f, -0.01525832f, 0.02040768f, 0.00301663f, -0.00309290f, 0.03655098f, 0.00715906f, 
    -0.05605736f, 0.01129303f, 0.03182281f, -0.01247816f, -0.00137748f, -0.05212558f, 0.00853038f, 0.03019674f, 
    0.04040346f, -0.00503830f, 0.01285872f, -0.01808559f, -0.04991325f, 0.00541601f, -0.03312149f, 0.03370611f, 
    0.02039167f, -0.02243415f, -0.01274274f, -0.01145821f, -0.00999357f, 0.02020852f, 0.00014150f, 0.02729026f, 
    -0.01277141f, -0.03800598f, -0.00853245f, -0.00412296f, 0.04515437f, -0.02852326f, -0.02881086f, 0.01521475f, 
    -0.05646184f, 0.01270868f, 0.03728000f, -0.04090539f, -0.03782517f, -0.04975909f, -0.04708254f, 0.01920467f, 
    0.01185857f, 0.02258495f, -0.00102493f, -0.00548452f, 0.03508643f, 0.01003353f, 0.01368949f, -0.00805084f, 
    0.04170274f, -0.05425337f, 0.01145082f, -0.03323551f, 0.02664551f, -0.03933383f, 0.00934525f, 0.04174547f, 
    0.01453772f, -0.01883219f, -0.03357496f, 0.02600559f, 0.03117809f, -0.03286850f, -0.01734933f, 0.03401347f, 
    -0.02048368f, -0.02461463f, 0.01097202f, 0.01785216f, -0.04900005f, 0.03148827f, -0.00012979f, -0.05647033f, 
    -0.00213932f, -0.00323789f, 0.03392039f, -0.01881832f, -0.03909958f, -0.02839118f, 0.01437262f, -0.02857655f, 
    -0.01963937f, -0.05837689f, 0.00898828f, -0.02744986f, -0.01061334f, -0.03324991f, -0.05073290f, 0.01412282f, 
    0.01591269f, -0.02673658f, -0.01158652f, -0.02504288f, -0.02561407f, -0.05496082f, -0.02689783f, -0.01075603f, 
    0.03414164f, -0.00496905f, 0.03706244f, 0.02850606f, 0.00309104f, -0.00170896f, -0.01426937f, -0.02576811f, 
    -0.02937957f, 0.03026325f, 0.04223887f, -0.01648671f, 0.00351283f, -0.01652101f, -0.04662372f, 0.02818517f, 
    -0.04327868f, 0.00826023f, -0.03380572f, 0.02995056f, 0.03216888f, 0.03673775f, -0.00218703f, 0.02729463f, 
    -0.01218085f, 0.03746048f, -0.04740686f, 0.03087888f, 0.03097743f, -0.01396266f, -0.04668073f, 0.02302957f, 
    -0.03872045f, -0.04380045f, 0.02619346f, -0.03555208f, 0.00176887f, 0.03651776f, 0.02485847f, 0.03356051f, 
    -0.03963605f, -0.02899971f, 0.02037545f, -0.03360931f, -0.01354136f, -0.05359406f, -0.01743059f, -0.01078700f, 
    0.02346271f, 0.01279728f, -0.01616075f, -0.03432050f, -0.03918499f, 0.01007056f, 0.03168027f, 0.01220347f, 
    -0.01341792f, 0.03362429f, -0.04289205f, 0.01163639f, -0.03577944f, 0.03431972f, 0.01719817f, 0.01356413f, 
    0.02486997f, 0.00836207f, -0.03317300f, 0.03992642f, -0.05257642f, -0.02220791f, 0.00608422f, 0.01532563f, 
    0.01622518f, -0.02022450f, -0.02590423f, -0.00601048f, -0.02620918f, -0.01856749f, -0.05754921f, 0.03925916f, 
    -0.03909765f, 0.00270649f, -0.00914044f, -0.04756161f, 0.03848599f, 0.00425395f, -0.03975836f, 0.03512490f, 
    0.02333944f, -0.00517565f, 0.04007877f, -0.01681101f, 0.03786026f, 0.00202252f, -0.01762719f, -0.03656917f, 
    0.03282544f, -0.03243692f, -0.02703436f, -0.04360085f, -0.01669661f, -0.01088273f, 0.01083919f, -0.03208090f, 
    -0.01070826f, 0.02440053f, -0.00196261f, 0.00036754f, 0.04435460f, -0.02010018f, -0.00628194f, -0.00646665f, 
    -0.05369972f, -0.02990055f, 0.02638525f, 0.04392262f, 0.04161261f, 0.03655402f, -0.03369536f, 0.04102433f, 
    -0.04627459f, -0.01635846f, -0.02449854f, -0.04885462f, -0.03737927f, 0.03255265f, -0.04448348f, 0.00630681f, 
    -0.00893120f, 0.01003872f, 0.00524942f, -0.04425503f, -0.00268467f, -0.05159140f, -0.03097252f, -0.03753518f, 
    -0.01720856f, 0.02997283f, -0.04045395f, 0.03229316f, -0.05840486f, -0.05645954f, -0.05484350f, 0.02506938f, 
    -0.04194470f, -0.00761484f, -0.05537220f, -0.00313182f, 0.02352062f, 0.02912946f, 0.01899845f, -0.04966477f, 
    -0.03455980f, -0.01140938f, -0.03938896f, -0.05388788f, 0.03380109f, 0.00721216f, -0.03572354f, -0.03732839f, 
    0.04291263f, -0.04707693f, 0.03932145f, 0.02141145f, -0.00345529f, 0.02855647f, -0.00774594f, -0.01149409f, 
    -0.02139929f, 0.01009561f, 0.03982480f, -0.01494660f, 0.02392084f, -0.06052653f, 0.00743349f, -0.04639059f, 
    -0.04740675f, 0.01309249f, 0.01484309f, -0.02827623f, -0.04282271f, 0.03426696f, 0.02390066f, 0.01262053f, 
    0.00954011f, 0.02363061f, 0.02081972f, -0.01521761f, 0.02608764f, 0.02878717f, 0.03481368f, -0.00232274f, 
    -0.05264417f, -0.00936652f, 0.00477166f, 0.02657326f, -0.00665953f, -0.03308190f, -0.03613741f, -0.00087722f, 
    -0.04815745f, 0.02391148f, -0.01035153f, -0.04155474f, 0.02689526f, 0.00971648f, -0.04715995f, 0.01291585f, 
    -0.02434327f, -0.03788712f, -0.04668856f, 0.02090762f, -0.02571985f, -0.00562680f, -0.04666172f, -0.00030575f, 
    -0.01855257f, -0.01576478f, 0.00977667f, 0.01528094f, -0.02269904f, -0.00478398f, -0.04305140f, 0.00433396f, 
    0.02805540f, -0.03647172f, 0.04850489f, -0.02906972f, 0.00625400f, 0.03145592f, 0.02250858f, -0.04028367f, 
    -0.00556812f, -0.02690278f, 0.04166649f, 0.03445685f, -0.02007143f, -0.04956783f, 0.02827928f, 0.01003628f, 
    0.01457614f, 0.00657988f, -0.00594175f, -0.01787133f, -0.02275557f, -0.00671697f, -0.05757032f, 0.03659555f, 
    0.00306455f, -0.03074920f, 0.01320435f, 0.01054888f, -0.03425372f, -0.01235648f, 0.04096260f, -0.05329273f, 
    0.03804221f, -0.04707324f, 0.03761879f, -0.04324296f, -0.01969609f, 0.02458868f, 0.01292719f, -0.04272379f, 
    -0.04859875f, -0.02540909f, 0.01896477f, -0.00990636f, -0.05400420f, -0.05477350f, -0.01547948f, -0.05506164f, 
    -0.04706050f, 0.00751048f, 0.01745968f, -0.01822446f, -0.04039106f, -0.01215469f, -0.00805711f, -0.01064827f, 
    0.00990714f, -0.01380029f, 0.00279117f, 0.01573379f, -0.02445641f, -0.01783392f, 0.02720540f, 0.01863997f, 
    0.01351821f, -0.02068350f, 0.00028278f, 0.01879981f, 0.03267136f, -0.02823585f, 0.01914418f, 0.02080518f, 
    -0.03004286f, 0.00095356f, 0.02261540f, 0.04216585f, 0.03402571f, -0.00773302f, -0.05585305f, 0.02068176f, 
    0.03063612f, -0.02417439f, -0.05350772f, -0.03316854f, -0.02578014f, 0.01104868f, -0.05009864f, -0.05654439f, 
    0.04204245f, -0.01262112f, -0.01464207f, -0.04164825f, 0.03287647f, 0.03092267f, -0.00456072f, 0.03697816f, 
    0.00781624f, -0.05743333f, 0.01925671f, -0.04857085f, -0.00257498f, -0.00384552f, -0.01542805f, -0.04295929f, 
    -0.04348863f, -0.01516843f, 0.02591851f, 0.03691331f, -0.04555378f, 0.01472304f, 0.02262529f, 0.03235755f, 
    -0.05345314f, 0.00291119f, -0.03399349f, 0.00364283f, -0.04572395f, -0.03837112f, -0.03720774f, -0.00905516f, 
    -0.02918646f, 0.02344341f, -0.03775165f, 0.01229950f, 0.03652688f, -0.00662508f, -0.04641721f, -0.04677080f, 
    -0.01444920f, -0.02712376f, 0.02514500f, 0.03396331f, -0.04426641f, 0.04946880f, -0.04921338f, 0.01087912f, 
    0.03017698f, 0.01150845f, -0.04845241f, 0.01583901f, -0.03081426f, -0.04794817f, -0.01689033f, 0.03711351f, 
    -0.00334905f, -0.01933201f, -0.05441206f, -0.01300584f, -0.00111036f, -0.02647294f, 0.01221701f, -0.03345339f, 
    0.04164008f, -0.04994381f, -0.05704243f, 0.02583341f, -0.04623481f, 0.03234058f, 0.00068775f, 0.00420505f, 
    0.04015346f, -0.04005269f, 0.03015238f, -0.04183333f, -0.02910569f, -0.02494203f, 0.00922600f, 0.02142045f, 
    0.18582429f, 0.09221825f, -0.05944038f, 0.08301143f, -0.12611106f, 0.08026239f, 0.02057325f, 0.07072238f, 
    0.06332593f, 0.02649625f, 0.07676283f, -0.03271384f, 0.13617218f, 0.08082676f, -0.05347861f, -0.03955583f, 
    0.01800145f, 0.06647187f, 0.03359243f, 0.07034769f, -0.09107649f, -0.03153356f, 0.20058431f, 0.01953860f, 
    -0.21003404f, -0.01375436f, 0.22464314f, -0.12138786f, -0.04778209f, 0.01115712f, 0.11279990f, 0.06645747f, 
    -0.10136127f, -0.04704239f, -0.11699632f, 0.07556968f, -0.16294162f, 0.16407710f, -0.12885907f, 0.29133064f, 
    0.04481677f, 0.09158423f, 0.04075154f, 0.14838368f, 0.07372536f, 0.02011723f, -0.01507488f, -0.01684012f, 
    0.08119379f, 0.24962005f, 0.01431243f, 0.20358837f, 0.09019840f, -0.06800722f, 0.04230652f, -0.08542112f, 
    0.05542085f, -0.01250631f, 0.05192247f, 0.07744407f, -0.05291415f, 0.10626279f, 0.23019049f, -0.01111446f, 
    0.11607625f, -0.01050491f, -0.09737768f, 0.02317530f, 0.05908918f, -0.06748488f, -0.06311744f, 0.08593915f, 
    0.03252558f, 0.06808208f, -0.07951894f, 0.07884867f, -0.10909072f, 0.12140602f, 0.06399851f, 0.01054257f, 
    0.08750670f, 0.06417322f, -0.01772395f, -0.00080094f, 0.02428939f, -0.13682267f, 0.38611811f, 0.10350733f, 
    -0.00915212f, -0.00787753f, 0.21450628f, -0.09218828f, -0.14388262f, -0.08700715f, 0.06692486f, 0.07374620f, 
    0.09646627f, -0.30594125f, 0.20590335f, -0.10735740f, -0.02865605f, -0.07253673f, -0.01246119f, 0.01204144f, 
    -0.04549930f, 0.09664842f, 0.02940479f, -0.02015482f, 0.07267880f, -0.22541143f, 0.02255553f, -0.14088511f, 
    0.19352552f, 0.07494231f, 0.06644733f, 0.10937294f, 0.08843251f, 0.02312302f, 0.04106793f, 0.11666128f, 
    -0.05221711f, 0.01014830f, -0.02874348f, -0.02014228f, -0.04166771f, -0.02135006f, -0.01817737f, 0.03106386f, 
    -0.10245972f, 0.10893632f, -0.14611648f, -0.02154049f, 0.07368037f, 0.06353107f, 0.18594289f, -0.11787884f, 
    0.09187909f, -0.01029788f, 0.01694261f, 0.11246330f, 0.11931915f, 0.14190842f, 0.00950117f, 0.07995209f, 
    -0.32891420f, 0.09452393f, 0.21905375f, -0.00975700f, 0.01083841f, 0.07465710f, -0.01823612f, 0.01105225f, 
    -0.03596302f, -0.14893174f, 0.10504052f, 0.00257573f, -0.16836070f, 0.22485584f, 0.00735553f, -0.28698575f, 
    -0.11928337f, -0.04018220f, 0.07648063f, 0.07603381f, -0.02614826f, -0.02013482f, -0.11260184f, -0.09415739f, 
    -0.06622078f, -0.02007744f, -0.20050153f, -0.08085451f, 0.00070790f, -0.04882738f, -0.13538457f, 0.01572985f, 
    -0.02703984f, -0.05765413f, 0.12358598f, 0.04766407f, 0.05824101f, 0.21639779f, -0.02701418f, 0.21624961f, 
    0.05990075f, 0.13512440f, -0.00617942f, -0.05399719f, -0.05615079f, 0.04172429f, 0.06975510f, -0.00839841f, 
    0.14888373f, -0.06142017f, 0.04389441f, 0.11035708f, 0.00046118f, 0.05222503f, 0.03013348f, 0.06905319f, 
    0.04870814f, 0.05007581f, 0.08761955f, -0.02458763f, 0.09995772f, -0.17674690f, -0.27757010f, -0.19216381f, 
    -0.08479932f, 0.03858842f, 0.03761674f, 0.07541630f, -0.01874884f, 0.05339557f, 0.04297330f, 0.02591968f, 
    -0.23130952f, -0.00440677f, -0.03269507f, 0.21467626f, -0.03821911f, -0.00919174f, -0.08845323f, 0.01907947f, 
    -0.08027377f, 0.04874263f, -0.06308141f, 0.02604504f, 0.09184226f, -0.30412677f, 0.07085213f, -0.09825557f, 
    0.02185249f, -0.01960857f, 0.05089080f, -0.06419042f, -0.08171214f, 0.02784622f, -0.03965671f, 0.05347775f, 
    -0.01774532f, 0.12902594f, 0.22748055f, -0.25237814f, -0.13686244f, 0.02961526f, -0.01728309f, 0.01313738f, 
    -0.01319221f, -0.08403346f, -0.03084252f, 0.10900065f, 0.21140017f, -0.07789890f, -0.07655307f, 0.14124407f, 
    0.00952033f, 0.04427529f, -0.09821478f, 0.04996894f, -0.05420733f, 0.14546789f, -0.07506960f, -0.05637185f, 
    -0.18493666f, -0.11331919f, 0.21465202f, -0.12953466f, -0.04828594f, 0.05130625f, -0.14010036f, 0.06569728f, 
    0.02749196f, 0.07897206f, 0.09897970f, -0.03046923f, -0.02059450f, -0.20186341f, 0.15386197f, 0.05187235f, 
    0.07492271f, 0.02456559f, 0.00219901f, 0.11091811f, -0.01747353f, -0.05868430f, -0.01263259f, 0.00456849f, 
    0.05592420f, -0.19465712f, 0.22173090f, -0.11291020f, 0.05297807f, -0.01547232f, 0.08253017f, 0.05377158f, 
    0.10028121f, -0.00327355f, 0.03699537f, 0.05029734f, 0.00603628f, -0.06379970f, -0.06209523f, 0.35743597f, 
    0.08106476f, 0.10691503f, -0.02241852f, 0.18989772f, -0.07063201f, -0.06699247f, 0.00005164f, -0.07514907f, 
    -0.08871914f, 0.00591435f, 0.05739174f, -0.00047443f, 0.11911841f, -0.01097025f, -0.08587243f, 0.09776526f, 
    -0.00978976f, 0.01154577f, 0.07133725f, -0.09899041f, 0.21808845f, -0.00040004f, 0.11417287f, -0.03462714f, 
    -0.04618621f, -0.01172641f, -0.00611774f, 0.00169419f, -0.04360591f, 0.01310317f, 0.10582490f, 0.13922615f, 
    -0.17219736f, -0.21828389f, -0.00905909f, 0.15175606f, -0.10485438f, -0.01510569f, 0.02829772f, -0.02922245f, 
    0.05073445f, 0.01507215f, 0.01588956f, -0.02203882f, 0.32999665f, -0.20404647f, 0.08915700f, -0.17035070f, 
    0.03467194f, 0.03111718f, 0.02301413f, -0.12745403f, 0.13832185f, 0.05734600f, 0.08123391f, 0.05206453f, 
    0.23246978f, 0.03884690f, -0.13254376f, -0.06092687f, 0.16945313f, 0.14788848f, -0.05195043f, 0.11042406f, 
    -0.00411855f, 0.10409252f, 0.03112911f, 0.04045051f, -0.33147550f, -0.33966181f, 0.32466289f, -0.11356984f, 
    -0.06196433f, -0.05516247f, 0.13051011f, -0.03701528f, -0.00883241f, -0.04381465f, 0.09531523f, -0.01640323f, 
    0.20917855f, -0.12148812f, -0.07106358f, -0.00095862f, -0.00090717f, -0.16638558f, 0.06767461f, -0.06701946f, 
    0.00014513f, -0.00073835f, 0.07017613f, 0.15951486f, 0.11308841f, -0.09933370f, -0.06957013f, 0.01003757f, 
    0.17406185f, 0.04786031f, -0.01350036f, 0.01936023f, 0.04540165f, 0.10742065f, -0.00276857f, 0.00088898f, 
    -0.23686391f, -0.16647004f, -0.12352459f, 0.10209391f, -0.00197081f, 0.16200273f, -0.04621617f, 0.04842050f, 
    0.06204652f, -0.02568716f, 0.01313356f, 0.06486905f, -0.03110072f, -0.02601290f, 0.10024441f, -0.15252475f, 
    0.04496819f, -0.18308234f, 0.04631998f, 0.02827744f, 0.05381905f, -0.12126943f, 0.00693083f, 0.13361971f, 
    0.12760797f, -0.12671918f, 0.03075538f, -0.26472723f, 0.01747965f, 0.02005048f, -0.01227115f, 0.11005618f, 
    -0.01936759f, -0.01011440f, 0.04194897f, 0.09842429f, -0.27887759f, -0.04707500f, 0.15299608f, 0.30796278f, 
    0.03050958f, 0.05239356f, -0.08783028f, -0.03218219f, 0.01813051f, 0.02918516f, 0.04638577f, -0.09013099f, 
    -0.06333459f, 0.04726330f, 0.04286753f, -0.23654015f, 0.22082701f, -0.02959869f, -0.09492916f, 0.04040394f, 
    0.01349479f, 0.06314392f, 0.14810860f, -0.03498520f, 0.05637391f, -0.01181295f, 0.09438685f, -0.06002389f, 
    -0.01804376f, 0.06041918f, 0.01709728f, -0.11789120f, 0.19621666f, 0.02842256f, 0.08368604f, -0.00950718f, 
    0.12794669f, 0.04094476f, -0.02321819f, 0.08530685f, -0.03203695f, -0.03849586f, -0.06551208f, 0.05572301f, 
    0.00041789f, 0.03658288f, -0.10696836f, 0.03183814f, -0.23100926f, -0.04064382f, 0.18627715f, 0.45900041f, 
    -0.08496622f, -0.00604627f, -0.12749712f, -0.04854294f, -0.02776311f, 0.13677210f, -0.05606745f, -0.07249831f, 
    -0.10613186f, 0.07943987f, -0.00955126f, 0.00646782f, 0.03277075f, -0.03690808f, -0.03903757f, 0.01253014f, 
    0.13826428f, 0.03852233f, 0.07264981f, -0.02021708f, -0.05324794f, -0.08341079f, 0.03324220f, 0.27093202f, 
    -0.01687094f, -0.04797503f, 0.20687285f, 0.16035564f, -0.02729025f, -0.00695056f, 0.05471970f, -0.15034799f, 
    0.03140150f, 0.03600276f, -0.03698374f, 0.06854096f, -0.05486351f, 0.00249306f, -0.01904282f, 0.09608861f, 
    0.04805040f, 0.09945986f, 0.00243741f, 0.17581603f, -0.12595041f, 0.17131813f, -0.05184674f, -0.16500850f, 
    0.29519063f, 0.02094994f, -0.09176917f, -0.03314947f, 0.11109995f, -0.10679331f, 0.00355614f, 0.02758115f, 
    -0.42326149f, 0.13652556f, -0.05374799f, 0.13700984f, -0.06850055f, -0.06103354f, -0.01789176f, -0.03345463f, 
    -0.03725753f, -0.04790968f, -0.00182782f, -0.10286769f, 0.26930785f, -0.23057491f, 0.12967904f, -0.21690752f, 
    -0.06282247f, 0.02696737f, 0.00511746f, 0.09369224f, 0.04512591f, 0.01301619f, -0.04808958f, -0.00138350f, 
    0.00986410f, 0.02856538f, -0.12344549f, -0.00659567f, -0.08746298f, 0.00386241f, 0.03068863f, -0.01627259f, 
    0.05321413f, 0.01296706f, -0.03613484f, 0.07943670f, -0.17552705f, -0.09717696f, -0.23649652f, 0.18376884f, 
    -0.02555490f, 0.01185701f, -0.07139350f, 0.04264168f, 0.04815440f, -0.07154170f, 0.11246232f, 0.03814477f, 
    -0.12666339f, 0.16958143f, -0.07202964f, -0.16639322f, 0.14245564f, 0.00962052f, 0.00341494f, 0.04799173f, 
    -0.06402148f, -0.01048452f, 0.12337942f, 0.01998956f, 0.25707495f, 0.03930839f, -0.01510990f, 0.03459857f, 
    -0.04830980f, 0.11490814f, 0.01529266f, 0.07949790f, 0.06092175f, 0.10260674f, 0.05898128f, -0.09968002f, 
    0.01639923f, 0.09392608f, -0.01346981f, 0.00817367f, 0.19056380f, 0.01979690f, -0.05638197f, -0.10160858f, 
    0.07456885f, 0.08498794f, 0.07038921f, -0.05902471f, -0.31116229f, 0.06563315f, -0.06075930f, 0.04212725f, 
    0.02265534f, 0.03532108f, 0.06527565f, -0.02967607f, -0.07061093f, 0.03941507f, 0.04255871f, 0.01608970f, 
    0.15487137f, -0.23463602f, 0.05314578f, 0.02590351f, 0.04738711f, -0.02053517f, 0.02753853f, -0.10795587f, 
    -0.04646384f, 0.06332782f, -0.01756772f, 0.12753321f, -0.12107781f, 0.17721529f, -0.18352096f, 0.07359626f, 
    -0.01897412f, 0.07279191f, -0.04291562f, 0.00825449f, -0.01878722f, 0.15284535f, 0.07176130f, 0.00265991f, 
    -0.03097278f, -0.12499772f, 0.02630669f, 0.32392308f, -0.02763000f, -0.07764196f, 0.01711055f, 0.07409947f, 
    -0.09533089f, 0.05944622f, 0.08986424f, 0.03024760f, 0.14628585f, -0.01932498f, 0.29603314f, -0.15343560f, 
    -0.07010955f, 0.06687127f, 0.01422839f, -0.12405611f, 0.09099069f, 0.05717119f, -0.02087754f, -0.02529861f, 
    0.24837188f, -0.15842424f, -0.08757430f, -0.21273291f, -0.04212686f, 0.08086270f, 0.01609696f, -0.03173453f, 
    -0.02414326f, 0.02139865f, -0.09919018f, 0.19492112f, 0.16807920f, -0.16773315f, -0.06738156f, 0.12470183f, 
    0.03951791f, 0.13404122f, 0.02898110f, 0.12862152f, 0.01069828f, -0.02594729f, 0.07492651f, 0.12834395f, 
    -0.33926791f, 0.18162620f, -0.13236617f, -0.19506073f, 0.23475969f, -0.05798697f, 0.12717840f, 0.00398575f, 
    -0.03738215f, 0.05732106f, 0.05384301f, 0.08333758f, 0.18998976f, -0.12361141f, 0.00758386f, 0.20056506f, 
    -0.04521080f, 0.03449696f, -0.01769355f, 0.08225112f, -0.02913196f, -0.13652475f, 0.01045643f, -0.14050093f, 
    -0.09539626f, -0.15338504f, 0.09692536f, 0.15482968f, -0.09283449f, -0.08483230f, 0.09669492f, 0.00094923f, 
    0.08100086f, -0.11208408f, 0.03090564f, -0.03481178f, 0.12291041f, -0.06143849f, -0.04274713f, 0.20739301f, 
    0.04690716f, 0.01998853f, 0.08189078f, -0.01596910f, -0.04174832f, 0.11869795f, 0.03603481f, 0.09389982f, 
    -0.01675311f, -0.01823085f, -0.03081070f, -0.02182947f, 0.03677676f, 0.01082773f, -0.01082555f, 0.01310555f, 
    0.00461333f, 0.01591943f, 0.04411668f, -0.04858439f, -0.04961015f, 0.01752714f, 0.03995033f, 0.04561473f, 
    0.00005012f, -0.00582900f, -0.03266916f, -0.01940078f, -0.03814801f, -0.00365303f, -0.01290682f, 0.03337181f, 
    0.00962143f, -0.02253246f, 0.04575604f, -0.01494078f, -0.03629136f, 0.01105992f, -0.04545216f, -0.05012232f, 
    -0.00185411f, -0.00422145f, -0.05142691f, 0.04349208f, -0.04816866f, 0.00784091f, 0.02874435f, -0.02355838f, 
    -0.03946681f, 0.02731860f, 0.03837032f, -0.01474479f, -0.00231367f, -0.03191625f, 0.01440050f, -0.02028374f, 
    0.01508838f, -0.01488939f, -0.02272990f, 0.00498690f, -0.05268298f, 0.03737608f, 0.05765059f, 0.01577487f, 
    -0.02572430f, 0.05253645f, -0.03507431f, 0.02171674f, -0.03988056f, 0.00516784f, 0.04552604f, -0.01676397f, 
    -0.00513682f, -0.05103598f, -0.01186862f, -0.01039127f, 0.01637383f, 0.01733343f, -0.04421862f, 0.01103559f, 
    0.03747687f, -0.04422939f, -0.01015074f, -0.01618301f, -0.00604677f, -0.04613066f, -0.03656417f, -0.05115520f, 
    -0.02275914f, -0.02107005f, -0.02035855f, -0.02994017f, 0.03611404f, -0.00564133f, 0.04643093f, 0.00533368f, 
    -0.05103596f, 0.00754135f, -0.04541719f, 0.01400530f, -0.02200396f, 0.00159394f, 0.02460886f, 0.00728133f, 
    0.02614223f, -0.03379064f, 0.00979536f, -0.00224761f, 0.01362274f, -0.01092591f, 0.01096300f, 0.03422544f, 
    0.03182805f, -0.00884490f, 0.00505268f, -0.03734645f, -0.02205821f, -0.03578963f, -0.00056729f, -0.04265419f, 
    0.03232640f, -0.01621410f, 0.01941732f, -0.00442414f, 0.00101792f, -0.04219376f, -0.04579950f, 0.02858195f, 
    -0.04041328f, -0.00296688f, -0.01270018f, 0.00207177f, 0.00042549f, -0.00382852f, 0.02361966f, 0.02777507f, 
    0.03360879f, -0.00534853f, 0.03229335f, 0.01047799f, -0.00615297f, 0.02778055f, -0.01136432f, -0.01017202f, 
    0.04515799f, 0.02631416f, 0.01146490f, 0.03775816f, -0.02355049f, 0.04651633f, -0.04996270f, -0.00553101f, 
    -0.01438063f, -0.04793182f, -0.05437273f, -0.02478147f, 0.02009544f, -0.01799289f, 0.02733888f, -0.03481039f, 
    0.03026712f, -0.02810195f, -0.02704003f, -0.04335706f, -0.02966960f, -0.02567836f, -0.05586905f, -0.00286085f, 
    -0.03173545f, 0.01966494f, -0.03412233f, -0.04587708f, -0.01654179f, -0.00732549f, 0.01275749f, -0.04943053f, 
    0.00209300f, -0.02187410f, -0.04372456f, 0.03114697f, 0.04071145f, 0.03801192f, -0.02783527f, 0.02698794f, 
    -0.02994882f, 0.02050274f, 0.02972523f, 0.02445956f, -0.00141774f, -0.00423963f, -0.02049592f, 0.01879843f, 
    -0.02345175f, -0.03517100f, -0.04928931f, -0.03099066f, -0.01298795f, 0.00815545f, -0.04885502f, -0.00454061f, 
    0.00052190f, 0.01973396f, 0.01686786f, 0.03843104f, 0.00471027f, 0.03700844f, 0.00874477f, 0.02179309f, 
    -0.05219226f, 0.04088775f, 0.02615794f, -0.02190340f, -0.01599199f, 0.00278383f, 0.01456749f, -0.01024955f, 
    -0.01649524f, 0.01022090f, -0.03457119f, 0.04635887f, 0.04729084f, -0.01591808f, 0.00272181f, 0.01069057f, 
    -0.05391455f, 0.03199598f, -0.02260785f, 0.04657423f, -0.01996009f, 0.02217226f, 0.00995556f, 0.04735612f, 
    0.02265782f, 0.04454367f, -0.01449502f, -0.00088347f, 0.04186611f, -0.03945965f, -0.03096470f, -0.03189810f, 
    0.04065906f, -0.02855502f, 0.03243616f, -0.03780758f, -0.03167304f, -0.01968718f, -0.04572044f, -0.04761573f, 
    -0.05016398f, -0.03776948f, 0.03560914f, -0.01947901f, 0.01208903f, -0.00821308f, 0.03473578f, -0.01848420f, 
    0.00027381f, 0.01794739f, -0.00736787f, 0.03085265f, 0.00775908f, 0.00617543f, 0.04670566f, 0.01321803f, 
    -0.03611274f, 0.00588542f, -0.03972420f, 0.04562156f, 0.03718395f, -0.02353794f, 0.04379732f, -0.01280521f, 
    -0.04894030f, -0.04402538f, -0.03820036f, -0.01852765f, -0.01384381f, -0.03917516f, -0.00482520f, -0.03222800f, 
    -0.02283648f, -0.03548282f, 0.03396273f, 0.04190763f, -0.00494756f, 0.04538403f, 0.02833667f, -0.04093621f, 
    0.04586666f, -0.01866069f, -0.03496220f, -0.00925005f, 0.02888598f, 0.01103213f, 0.02317955f, -0.04270225f, 
    -0.04688659f, -0.05240129f, 0.03095982f, -0.02628129f, -0.02458569f, 0.04706309f, 0.01100944f, 0.00500145f, 
    -0.03990974f, 0.03151120f, -0.03074098f, 0.00451908f, -0.03049276f, -0.01274249f, -0.00544642f, -0.03711037f, 
    0.02933006f, -0.03688817f, -0.01154185f, 0.00344877f, -0.00154399f, -0.01903565f, 0.00146379f, -0.01060518f, 
    -0.04133518f, 0.00370977f, 0.02967742f, -0.05332357f, 0.01545646f, -0.03459076f, -0.00792229f, 0.01940853f, 
    -0.02071767f, -0.00380669f, 0.00956839f, -0.03154854f, 0.04539927f, 0.00460667f, -0.04837842f, 0.01500126f, 
    -0.03535410f, 0.01732023f, -0.03311625f, -0.03842683f, 0.04232692f, -0.04858190f, 0.03197922f, -0.04369946f, 
    -0.05045305f, -0.01309201f, 0.00114923f, -0.04062059f, 0.00005890f, -0.04644142f, -0.04053073f, 0.04816835f, 
    -0.02159484f, 0.04180982f, 0.04530001f, -0.01360014f, -0.02767416f, -0.04497695f, -0.00302190f, -0.03682544f, 
    -0.02994293f, -0.02766558f, 0.01009119f, 0.02201829f, -0.01169848f, -0.03050653f, 0.02615320f, 0.03578612f, 
    0.03620613f, 0.00189129f, -0.02899116f, 0.01943005f, 0.02389363f, -0.05297017f, -0.03270674f, -0.00969778f, 
    0.03057359f, 0.03007936f, 0.04238417f, 0.02116635f, -0.00643525f, -0.02456512f, 0.01159348f, 0.01428218f, 
    -0.01779974f, 0.00094250f, 0.01618903f, 0.04724796f, 0.02737025f, 0.04283357f, 0.04607316f, 0.01972412f, 
    -0.17364036f, 0.14131197f, 0.08992936f, 0.02936732f, 0.04156436f, 0.13688888f, -0.08767479f, 0.00043877f, 
    -0.06861947f, 0.12954284f, 0.00027401f, 0.00548494f, -0.14282054f, 0.26092771f, 0.20514104f, -0.00723292f, 
    -0.04847526f, 0.00697733f, 0.02707125f, -0.01611087f, 0.01528511f, -0.11636867f, -0.04757316f, 0.06210767f, 
    0.25187907f, 0.09510800f, 0.13030112f, 0.10061160f, 0.08386614f, -0.13401663f, 0.05279005f, -0.02210316f, 
    0.04470224f, 0.09539334f, 0.08782032f, -0.03409512f, 0.02462181f, -0.01120103f, -0.03948114f, -0.00292723f, 
    -0.11059576f, 0.12153631f, 0.02314519f, -0.07644439f, -0.05365248f, 0.07525041f, -0.00845546f, -0.03442287f, 
    -0.12762004f, 0.07554340f, -0.03052649f, 0.23790808f, 0.03716451f, 0.04208199f, -0.01178272f, -0.01474773f, 
    0.06575504f, 0.11259402f, -0.02664706f, -0.17817332f, 0.44215432f, 0.00970603f, -0.25737149f, -0.17355171f, 
    -0.06752077f, 0.03751965f, 0.06049966f, 0.07438804f, 0.05544120f, 0.04230285f, -0.00638491f, -0.01463788f, 
    0.06705045f, -0.09946234f, 0.10499693f, 0.24919672f, -0.03891690f, 0.15801623f, -0.01255742f, -0.08303799f, 
    0.00371093f, -0.06114819f, 0.07202005f, -0.02169013f, -0.15696082f, 0.08889215f, -0.13533370f, 0.12323441f, 
    0.04406512f, -0.01000612f, -0.01833764f, 0.16571470f, -0.03175795f, 0.00067335f, -0.02872641f, 0.04846565f, 
    -0.03768645f, 0.06056096f, -0.01391615f, -0.02077639f, 0.01116794f, 0.08671748f, 0.08751252f, -0.06341919f, 
    -0.03190506f, 0.02896098f, 0.05754934f, 0.08620907f, 0.19795015f, 0.08229245f, -0.17004372f, -0.31266132f, 
    0.05223535f, 0.08962450f, -0.00806756f, -0.02556248f, 0.01148126f, -0.14928545f, 0.00276053f, 0.13112992f, 
    0.13899156f, -0.12087943f, 0.02380434f, 0.04633296f, -0.07749389f, 0.08270177f, 0.09013180f, -0.00443056f, 
    -0.01513365f, -0.11385622f, -0.01224058f, -0.03819686f, 0.16705379f, 0.07458965f, -0.04881608f, -0.19394366f, 
    -0.01531814f, -0.00347223f, -0.18703513f, -0.20247671f, 0.01291513f, -0.11357963f, -0.12188692f, 0.22011350f, 
    0.03695998f, -0.03195187f, 0.03209876f, 0.07952204f, 0.02288274f, 0.01836206f, 0.19026878f, 0.10972332f, 
    0.00878518f, 0.02170393f, -0.12618987f, -0.21122558f, 0.13412583f, -0.25095940f, 0.18989097f, 0.14532213f, 
    -0.17560144f, -0.03452728f, 0.15098272f, 0.01020716f, 0.00863101f, 0.08208603f, 0.11476295f, 0.06174942f, 
    0.39293462f, -0.15513128f, -0.00248661f, -0.10016910f, 0.05013664f, 0.12806977f, 0.10824554f, 0.08882160f, 
    0.10312641f, 0.11266980f, -0.07482353f, 0.04520191f, -0.24978746f, 0.13806456f, -0.14875017f, 0.06692911f, 
    0.04963890f, -0.00130789f, 0.02476416f, 0.08904374f, 0.03632114f, -0.01832660f, 0.03401468f, 0.01569783f, 
    0.09362032f, 0.01721784f, 0.10984628f, -0.02022597f, 0.14478038f, 0.01506792f, -0.00211381f, -0.00089787f, 
    -0.05121303f, 0.06948773f, 0.09521646f, 0.07661999f, 0.15365405f, 0.15274063f, 0.30143452f, -0.01077553f, 
    0.05948360f, -0.04184049f, 0.08659426f, -0.07972788f, -0.02357932f, 0.10822627f, -0.06634135f, -0.04703804f, 
    0.13717037f, -0.07934948f, 0.03756652f, 0.11151776f, -0.13191235f, 0.09270623f, 0.01797512f, 0.03713469f, 
    0.05999000f, -0.06640326f, -0.07225981f, -0.04017333f, -0.25129437f, 0.12550369f, -0.09214568f, 0.02441955f, 
    0.07413008f, -0.09341468f, -0.01813718f, -0.04389735f, 0.04878081f, -0.01883997f, 0.09202778f, 0.00868398f, 
    0.04875961f, -0.02073815f, -0.08444533f, 0.09784200f, -0.05111641f, 0.04661090f, 0.01970489f, 0.07816587f, 
    -0.03857389f, 0.07479004f, -0.03459800f, 0.08137525f, 0.23191772f, 0.01440572f, -0.02839318f, -0.09784811f, 
    -0.05330129f, -0.04788654f, 0.01803691f, 0.15106294f, 0.11941123f, -0.05660175f, 0.06631107f, -0.00570598f, 
    -0.10252655f, 0.28954619f, -0.10158093f, 0.09157801f, 0.06867239f, 0.04115045f, 0.13592142f, 0.07717296f, 
    0.06629794f, -0.06115909f, -0.02492282f, 0.01558018f, 0.02637309f, -0.17291842f, 0.14624767f, -0.15407741f, 
    0.11349814f, 0.01097484f, 0.13339144f, -0.02442411f, 0.01480650f, -0.09419250f, 0.06696321f, -0.03279038f, 
    0.07211149f, 0.14856011f, -0.09311006f, -0.19933227f, 0.06277815f, 0.05958612f, -0.06171127f, -0.10104501f, 
    0.06918731f, -0.11655777f, -0.08551899f, -0.08947392f, -0.07500445f, 0.10382333f, -0.32273430f, 0.06269509f, 
    0.03521691f, -0.12631419f, 0.03772051f, 0.03202441f, -0.02223890f, -0.06848346f, 0.11863709f, 0.13483709f, 
    -0.24311279f, 0.11995195f, 0.07160976f, 0.26140136f, -0.05549999f, -0.05412022f, 0.10222616f, 0.05614762f, 
    0.04679779f, 0.01963227f, 0.13915443f, -0.10255294f, -0.19812205f, 0.20086843f, 0.08992730f, -0.02807971f, 
    0.05076827f, 0.00561543f, 0.13176055f, -0.00880101f, -0.02363209f, 0.05312247f, -0.11816844f, -0.03663971f, 
    0.32109433f, -0.11634779f, 0.17730722f, 0.07590862f, -0.18710174f, 0.06264704f, -0.10541514f, 0.03603379f, 
    0.02038774f, -0.02644124f, -0.03307123f, -0.03577486f, -0.43705928f, 0.20276618f, 0.00540922f, -0.12583475f, 
    -0.06174638f, 0.02008662f, -0.05104789f, 0.00597397f, 0.09180108f, 0.20993207f, 0.02864441f, 0.14436981f, 
    0.07402858f, 0.09041721f, -0.17676939f, -0.18958859f, 0.04748045f, 0.06631456f, -0.16117615f, -0.10728125f, 
    -0.03591281f, 0.04118872f, -0.04490099f, -0.01979337f, -0.12677124f, 0.07793351f, -0.04315263f, -0.04543038f, 
    0.00869812f, -0.03373515f, -0.04916909f, 0.02694296f, 0.08860264f, -0.01049062f, 0.04938319f, -0.00122292f, 
    0.30256474f, 0.03088436f, -0.35191762f, 0.06391352f, -0.02941402f, 0.03543890f, -0.12648442f, -0.03613397f, 
    -0.01582772f, 0.14295928f, 0.08031480f, 0.05769680f, 0.01367371f, -0.01390004f, 0.23624238f, 0.03780824f, 
    0.13777603f, 0.01272789f, 0.04894294f, -0.04185499f, -0.04586142f, 0.03355354f, 0.13103433f, -0.01582765f, 
    -0.30462104f, 0.05745102f, 0.23482108f, -0.02603238f, 0.16717359f, -0.04029969f, 0.14294375f, 0.03151724f, 
    -0.02052894f, 0.08636889f, 0.10567854f, -0.04612490f, -0.22628881f, 0.03214449f, -0.01011643f, -0.28410965f, 
    0.02505554f, 0.10081253f, 0.14297493f, -0.09668158f, -0.04062186f, 0.07093684f, -0.01781601f, -0.04162266f, 
    -0.05897707f, 0.16348742f, -0.02854544f, 0.11591318f, 0.06410814f, -0.05825614f, -0.02716599f, 0.01881280f, 
    0.06203880f, 0.02878926f, -0.19970790f, 0.01669089f, 0.11509529f, 0.22460219f, -0.07852655f, -0.04577398f, 
    0.07197184f, -0.01007813f, -0.15807100f, 0.20465536f, 0.09294827f, -0.06953601f, -0.07730442f, -0.06485016f, 
    -0.16803367f, -0.06888540f, 0.07729636f, 0.08092342f, 0.01667754f, 0.19838153f, -0.02888047f, -0.02089222f, 
    -0.03443760f, -0.07541561f, 0.13582751f, -0.00899029f, -0.47601241f, 0.03999718f, 0.13149732f, 0.12058657f, 
    0.01230193f, -0.10539786f, 0.00523477f, -0.00499571f, 0.00523077f, -0.10690417f, -0.02512621f, -0.12357135f, 
    0.03965417f, -0.01010073f, 0.17625509f, 0.14002402f, -0.02356132f, 0.04149721f, 0.19210799f, -0.02707182f, 
    0.05061051f, 0.07311416f, 0.09633773f, 0.16519263f, -0.04933985f, -0.11084740f, -0.16106933f, 0.02682681f, 
    0.11049510f, 0.15379299f, -0.00804940f, 0.02161910f, -0.08318052f, -0.05918359f, 0.05028425f, -0.00950927f, 
    -0.00096729f, -0.19545278f, -0.14416371f, 0.14349861f, -0.09251247f, 0.14041202f, 0.06822641f, -0.16509549f, 
    -0.06141271f, -0.07857784f, -0.02237814f, -0.05647762f, 0.29143396f, 0.01080128f, -0.07703716f, -0.06237207f, 
    -0.04229316f, -0.00925220f, -0.04484579f, -0.12775509f, -0.12977666f, -0.08028963f, -0.04223602f, 0.13991164f, 
    -0.10980845f, -0.07213923f, 0.16204010f, 0.06240210f, -0.01947964f, 0.05140121f, 0.05963476f, 0.08039448f, 
    -0.08306798f, 0.07785571f, -0.27937123f, -0.18768948f, -0.08782829f, 0.02378067f, 0.21397105f, -0.12275726f, 
    0.01145746f, 0.02821212f, 0.11148448f, -0.01821745f, 0.08472694f, 0.04623710f, 0.02852423f, 0.12171018f, 
    -0.27374935f, 0.09612624f, -0.08861981f, -0.09932816f, 0.00310594f, 0.02716999f, 0.06599671f, 0.12705779f, 
    0.02269057f, 0.04575960f, -0.12285808f, 0.07014872f, 0.07601989f, 0.13908458f, -0.13661563f, -0.00270577f, 
    -0.07241649f, 0.05138447f, 0.09882527f, 0.10281751f, 0.05569398f, 0.15086871f, -0.01191900f, 0.11410931f, 
    0.24926269f, -0.08358682f, -0.10023692f, -0.07072463f, 0.06936001f, -0.03111859f, -0.01130569f, 0.02212282f, 
    -0.01733775f, 0.08339038f, 0.02987842f, 0.15859038f, -0.13823012f, 0.12311502f, 0.15941769f, 0.14749491f, 
    -0.06844091f, -0.00984882f, 0.04961482f, -0.07242487f, -0.00171797f, 0.00423887f, 0.02061406f, 0.12563659f, 
    0.02233423f, 0.07664227f, -0.07743488f, -0.03761660f, -0.00186279f, 0.02673958f, -0.05016479f, 0.10813530f, 
    -0.01677555f, -0.04515112f, -0.02772943f, -0.08066783f, 0.12755537f, -0.04013737f, -0.15534149f, 0.07884815f, 
    0.08201541f, -0.09354533f, 0.08037218f, 0.00193572f, 0.19113329f, 0.17446405f, -0.02860143f, -0.07038046f, 
    -0.09186281f, 0.14491694f, 0.12107986f, -0.01899209f, -0.09077071f, 0.08219067f, -0.02326936f, 0.05037242f, 
    -0.03169245f, 0.12506938f, 0.12086182f, 0.10204208f, -0.06289472f, -0.11818556f, -0.30595413f, -0.01385650f, 
    -0.07399114f, 0.03358541f, -0.08823946f, 0.03076632f, -0.00087968f, -0.01182409f, 0.07866589f, -0.07415432f, 
    -0.15920679f, 0.18867859f, 0.14455241f, -0.00531846f, -0.01112509f, 0.05692462f, 0.06884184f, -0.02406461f, 
    -0.12752384f, 0.00099552f, -0.01805260f, 0.02076876f, -0.15356475f, -0.13946410f, 0.03515469f, 0.03912693f, 
    0.14768267f, 0.21326871f, 0.14807852f, -0.07055956f, 0.08144796f, -0.08027919f, 0.03637229f, -0.00124343f, 
    0.30718285f, -0.09220269f, -0.05682885f, -0.07524583f, 0.14293529f, 0.00718029f, -0.04537905f, -0.01890105f, 
    0.01866609f, -0.05029428f, -0.03034264f, -0.05649337f, 0.01862370f, -0.25536719f, -0.09348430f, 0.10531091f, 
    0.04082465f, 0.04240447f, -0.06266487f, 0.06718582f, 0.02927087f, 0.03665988f, 0.02950586f, 0.18534973f, 
    -0.10979608f, 0.15521961f, 0.13947688f, -0.01346419f, 0.00492535f, 0.07886639f, 0.01048030f, -0.07332467f, 
    -0.01281166f, 0.02130435f, 0.01926548f, 0.00768130f, 0.07040745f, 0.11495363f, 0.02798880f, 0.11415701f, 
    -0.10243792f, -0.02838610f, 0.07061944f, -0.05776654f, 0.03657798f, 0.04117393f, 0.05059176f, -0.03356046f, 
    0.07511190f, -0.09732737f, 0.09159028f, -0.03350629f, -0.18716684f, 0.02777098f, -0.12422951f, 0.08857121f, 
    0.06048438f, 0.00375176f, 0.14202471f, -0.04683882f, -0.13260789f, 0.10730861f, -0.08491737f, 0.13204023f, 
    -0.21947645f, 0.07561835f, 0.05320283f, -0.05324703f, 0.19911423f, 0.18099347f, 0.05900000f, 0.08179732f, 
    -0.11101861f, 0.04153764f, 0.01093102f, -0.14599258f, -0.02401468f, 0.11748301f, -0.07820781f, 0.01112572f, 
    0.05300814f, -0.07223877f, -0.07168671f, -0.06203275f, 0.11971592f, -0.14275092f, -0.02520402f, 0.10686847f, 
    0.09700498f, -0.04776251f, 0.10773151f, -0.13131188f, 0.05312930f, -0.03463503f, 0.12660456f, -0.05577961f, 
    0.00048217f, -0.02552229f, 0.03191581f, -0.02449927f, -0.01616574f, -0.04257926f, -0.00234281f, 0.03843301f, 
    -0.03828857f, 0.02655709f, -0.04409684f, -0.00289733f, 0.01194660f, -0.05360354f, 0.02346320f, -0.01264300f, 
    -0.00536218f, -0.01316403f, -0.05840782f, 0.00286991f, 0.04227325f, 0.02902820f, 0.01373999f, -0.03467781f, 
    0.01819473f, 0.03394867f, 0.01213459f, -0.05193455f, -0.01198645f, -0.02030730f, -0.04133369f, -0.05499299f, 
    -0.00570018f, 0.00458932f, -0.04830496f, 0.02316220f, -0.05489646f, 0.00696529f, -0.05757720f, -0.00232612f, 
    0.03231653f, 0.03602109f, 0.03796102f, -0.01799507f, -0.00420474f, -0.00965260f, -0.01392253f, 0.03703059f, 
    -0.01525929f, -0.00616852f, -0.04778980f, -0.02479437f, -0.03984460f, -0.04326668f, -0.00927577f, -0.02075115f, 
    -0.02217370f, 0.03346455f, 0.01516336f, -0.01306559f, -0.04344920f, -0.00325312f, -0.03788763f, -0.02761274f, 
    0.04044566f, -0.02814057f, -0.05549056f, 0.03545972f, 0.01548591f, 0.03222281f, -0.00103248f, 0.02621800f, 
    0.02116215f, -0.03244524f, 0.01858410f, 0.04120479f, -0.04299970f, 0.02231350f, -0.04438083f, -0.01277635f, 
    0.02447774f, 0.02983138f, 0.02788311f, -0.02077817f, -0.02995425f, 0.03927918f, -0.02737208f, -0.05471408f, 
    0.00003040f, -0.01331615f, 0.01833544f, 0.00878471f, -0.00030224f, -0.00860066f, -0.01391124f, 0.02582759f, 
    -0.03793738f, 0.00187055f, -0.02651908f, -0.04186111f, -0.02674798f, 0.00143688f, -0.04432441f, 0.01080838f, 
    -0.01910364f, -0.04979588f, 0.03741588f, -0.03915476f, 0.04360146f, 0.00636787f, -0.01470799f, -0.00862937f, 
    -0.03404208f, -0.02268266f, -0.02978478f, 0.03380477f, 0.00474445f, 0.04187930f, -0.05284987f, -0.05422669f, 
    0.00702337f, 0.01424805f, 0.04501234f, -0.05637426f, -0.05124111f, 0.02531021f, 0.03877124f, -0.02403351f, 
    -0.00245500f, 0.01399850f, 0.02946927f, 0.03988425f, 0.03774613f, 0.01926535f, -0.04773211f, -0.02753525f, 
    -0.02641612f, 0.02821684f, -0.05262928f, 0.03740630f, -0.00057100f, 0.03273926f, 0.01934953f, -0.04692129f, 
    -0.03697969f, -0.05575154f, -0.02415382f, 0.01707632f, -0.01571351f, -0.05216184f, -0.03536885f, -0.00015177f, 
    -0.04028319f, -0.01814820f, 0.03973518f, -0.02658353f, 0.00391860f, -0.05035078f, 0.02632687f, 0.02393422f, 
    -0.00012454f, -0.03594378f, 0.01540945f, -0.05119817f, 0.02033555f, -0.04473248f, 0.02321000f, -0.00508021f, 
    0.00349608f, 0.04406611f, -0.00519437f, -0.00837215f, 0.03825355f, -0.00694103f, -0.03982630f, -0.05298281f, 
    0.01469187f, -0.02029416f, 0.01790586f, -0.00545372f, -0.03582743f, -0.03423207f, 0.00627781f, -0.01185907f, 
    -0.00757525f, 0.03103491f, 0.02693897f, -0.03861636f, -0.04029735f, -0.02458988f, -0.04671489f, -0.04715031f, 
    -0.05430581f, -0.02375777f, 0.02710730f, -0.05317380f, 0.02948003f, -0.04384242f, 0.03820383f, -0.00993372f, 
    0.03636868f, 0.03398854f, 0.01352558f, -0.03726553f, -0.01456715f, -0.04436684f, -0.04629889f, -0.04831520f, 
    0.02407381f, 0.03383990f, 0.04831269f, -0.00897658f, 0.00945966f, -0.04718500f, -0.03889082f, 0.00366434f, 
    -0.05557043f, -0.02168146f, -0.04144846f, 0.02412371f, -0.04445412f, -0.02126727f, 0.04182963f, 0.01670384f, 
    0.03125507f, 0.01824478f, -0.02296784f, 0.03197912f, 0.04324086f, 0.00368168f, -0.00175141f, -0.02544398f, 
    -0.02100225f, -0.00798043f, 0.00294077f, -0.01723620f, -0.01179913f, -0.01084334f, 0.00704640f, -0.04989073f, 
    0.00478793f, -0.01108869f, 0.03378896f, 0.00622544f, -0.03778739f, 0.02469621f, 0.01232720f, -0.01177675f, 
    -0.02194829f, -0.00153755f, -0.01648610f, -0.05110256f, -0.03677578f, 0.01176002f, -0.00844894f, 0.02785893f, 
    0.00578580f, 0.01944730f, 0.03595559f, -0.01793291f, 0.01350673f, -0.01806625f, -0.01159455f, -0.01633326f, 
    -0.03928341f, 0.00435324f, -0.01461806f, -0.01361880f, 0.04181273f, -0.00360116f, -0.00200153f, -0.00920490f, 
    -0.01962159f, 0.04380566f, -0.04314504f, -0.00631926f, -0.03781907f, 0.04372888f, -0.05435744f, 0.03639876f, 
    -0.01722721f, 0.01391072f, 0.04087579f, 0.01269767f, -0.03070857f, 0.04326985f, 0.03406877f, 0.02655115f, 
    -0.02877124f, -0.03448039f, 0.01726656f, 0.02760079f, 0.01823935f, 0.02549666f, -0.04330860f, -0.02115087f, 
    0.02700955f, -0.02408393f, -0.03695856f, -0.03974973f, 0.02293384f, -0.01886526f, 0.03801313f, 0.04221169f, 
    -0.02577256f, 0.03634137f, 0.01074229f, 0.04273139f, -0.02966562f, -0.01473453f, -0.00198405f, 0.00743901f, 
    -0.03480526f, 0.01278971f, 0.02297416f, -0.00789830f, -0.01398118f, -0.00475153f, -0.01729666f, -0.04957477f, 
    0.00726690f, 0.03337893f, 0.02286329f, 0.00423488f, -0.05444428f, 0.00251192f, -0.01613310f, 0.03680385f, 
    -0.03619489f, 0.03897006f, -0.03633069f, -0.03853015f, 0.01156568f, -0.05655136f, 0.01979580f, -0.03215065f, 
    -0.04374972f, 0.02141794f, 0.03020160f, 0.01262168f, -0.03624572f, -0.01278497f, -0.04252101f, 0.03068791f, 
    -0.02713937f, 0.01934512f, 0.03306616f, 0.01587695f, 0.02055424f, -0.00820117f, -0.04087490f, -0.05172993f, 
    0.02638491f, 0.01712139f, -0.02053456f, -0.03702553f, -0.03232375f, -0.04819075f, -0.00638194f, -0.00627114f, 
    -0.04491634f, -0.03908673f, 0.00421544f, -0.03484260f, 0.03519567f, -0.00905898f, -0.00345274f, -0.04731295f, 
    0.03743440f, 0.01356941f, 0.01030094f, -0.00849992f, -0.03112973f, -0.00250435f, -0.05035326f, 0.01094273f, 
    -0.03325867f, -0.04670862f, -0.01863557f, 0.02577377f, 0.04433701f, 0.03414536f, -0.05286266f, -0.05125109f, 
    -0.08928072f, 0.12129860f, 0.01783727f, -0.14764145f, 0.11535353f, 0.11259370f, 0.02643682f, -0.01667263f, 
    -0.01453440f, 0.02080223f, -0.00651357f, 0.06289149f, 0.03661650f, 0.04315469f, 0.01416142f, 0.09438854f, 
    0.07154627f, -0.03588568f, -0.08652968f, -0.03681034f, 0.09537608f, 0.23202978f, 0.04931792f, 0.12267873f, 
    0.05687083f, 0.11710666f, -0.17588365f, -0.26820281f, 0.06227291f, -0.02794825f, -0.10334893f, 0.03391553f, 
    0.03779624f, -0.02833911f, -0.11499660f, -0.04308592f, 0.30324697f, -0.19633916f, 0.00753902f, -0.12746832f, 
    0.08757114f, -0.07565111f, -0.06744488f, -0.04759469f, 0.04257080f, 0.01968804f, 0.09369035f, -0.14934096f, 
    0.23645167f, -0.27655220f, 0.06144620f, 0.09365737f, -0.07660893f, 0.10536863f, 0.08545148f, -0.02001674f, 
    -0.01536562f, -0.07501096f, 0.07429558f, 0.10387040f, -0.04158740f, 0.06951724f, -0.04427068f, -0.03689431f, 
    -0.09500279f, -0.14600542f, 0.04146878f, 0.01667557f, -0.00624693f, 0.01621206f, -0.03425806f, 0.06752931f, 
    0.13474832f, 0.05526654f, 0.13244422f, -0.03527804f, 0.05586004f, -0.07819592f, 0.02909436f, 0.05309967f, 
    -0.03919733f, 0.07590920f, -0.17352273f, 0.12366156f, -0.40048137f, 0.09907050f, -0.33623230f, -0.05093882f, 
    0.05325735f, 0.10823673f, 0.04095029f, 0.04820793f, -0.03099589f, 0.04152755f, -0.05287320f, 0.05856769f, 
    -0.08061402f, 0.13549040f, -0.01686879f, -0.25780547f, 0.10905840f, 0.05703087f, 0.01033241f, -0.00258242f, 
    0.02890918f, -0.14107971f, 0.13499519f, -0.12298667f, -0.19257514f, 0.11358354f, 0.25633842f, 0.06978086f, 
    -0.10437918f, -0.11621422f, 0.02307369f, 0.02511963f, -0.06522671f, 0.10071295f, -0.03805712f, -0.07453123f, 
    -0.08078938f, 0.00064350f, 0.09666618f, -0.21226117f, 0.05650839f, 0.05948820f, -0.14319022f, -0.01908152f, 
    0.04470039f, 0.00571655f, 0.07132562f, 0.03082493f, -0.17393970f, 0.04878131f, -0.05705485f, 0.18818867f, 
    0.00923190f, 0.05231654f, 0.10885669f, 0.05844344f, -0.03872208f, -0.00611883f, 0.13701826f, 0.09758072f, 
    -0.00703996f, -0.09147154f, -0.15291360f, -0.15137541f, 0.18657501f, 0.01145233f, -0.11687417f, -0.11702959f, 
    0.05529329f, 0.10306124f, 0.12703073f, 0.13663518f, 0.11550017f, 0.12486757f, -0.04649650f, 0.15809627f, 
    0.05801912f, 0.02503216f, -0.11580463f, 0.06503624f, 0.00096694f, 0.04073441f, 0.11677862f, 0.02016742f, 
    0.28798673f, -0.11049803f, 0.22776799f, -0.02617892f, -0.12232069f, -0.08621152f, -0.08020462f, -0.11045845f, 
    -0.00754452f, -0.03057850f, 0.08342853f, 0.15848988f, 0.07107825f, -0.15943155f, 0.05917716f, -0.14588928f, 
    0.09840666f, 0.04138412f, 0.12548873f, -0.01580408f, 0.05403260f, 0.06833483f, -0.06696203f, -0.03627019f, 
    -0.06821878f, -0.04251637f, -0.08834134f, -0.21199995f, -0.00931075f, 0.21580334f, -0.00217213f, -0.02524277f, 
    0.04489196f, 0.01533773f, -0.03137009f, -0.05915093f, -0.06106019f, 0.16141398f, -0.00756608f, -0.27266771f, 
    0.09871893f, 0.03168413f, -0.10951272f, -0.01446178f, 0.07837134f, -0.04477938f, 0.04286748f, -0.01731830f, 
    0.51518226f, -0.17302999f, 0.07603576f, -0.19023855f, -0.03778454f, -0.04906545f, 0.13446777f, -0.03506116f, 
    0.14777960f, 0.11553739f, 0.14159356f, -0.06499652f, 0.27902013f, -0.08695626f, 0.15250172f, 0.20478003f, 
    -0.08278215f, 0.05741441f, -0.02885826f, 0.00869690f, 0.00933198f, -0.02348288f, -0.04708036f, 0.09950334f, 
    -0.18043357f, 0.04913676f, 0.00345203f, -0.07515006f, 0.18758149f, 0.05659788f, -0.01225071f, 0.02477118f, 
    0.11672216f, 0.08930521f, -0.00977110f, -0.09276085f, 0.16220039f, -0.08047420f, 0.05947271f, 0.05376458f, 
    -0.06798868f, 0.03029236f, 0.10972482f, -0.08625018f, 0.09102809f, -0.04749165f, 0.02235949f, 0.22561628f, 
    -0.01348421f, 0.06678871f, -0.07847438f, -0.08700244f, 0.16097513f, 0.02230955f, -0.04107427f, -0.03933619f, 
    0.03697845f, 0.05374304f, -0.11526077f, -0.06894509f, -0.24190509f, 0.03094145f, -0.06278899f, -0.23604919f, 
    -0.00481008f, 0.03215952f, -0.01503955f, 0.01875709f, 0.07969894f, 0.09161031f, 0.10182361f, 0.12319546f, 
    -0.01933055f, 0.04258374f, -0.13088451f, 0.13592497f, -0.05404516f, 0.04361121f, 0.13869736f, 0.07817856f, 
    0.04676916f, 0.07280380f, 0.02777732f, 0.01977783f, -0.05985596f, -0.22451328f, 0.09403256f, -0.26757118f, 
    -0.08735987f, -0.04426690f, 0.01238679f, -0.04920688f, 0.02301525f, 0.00912807f, -0.13854307f, 0.03724919f, 
    0.10309025f, -0.11409843f, -0.05684969f, -0.34724626f, -0.10400391f, 0.08104069f, -0.02359934f, -0.00957551f, 
    -0.09206174f, 0.20480607f, -0.01487253f, 0.13014378f, -0.35023749f, 0.08758412f, 0.05298238f, -0.04185902f, 
    0.03731275f, 0.09859988f, -0.15891625f, 0.03276694f, 0.02598391f, 0.11754130f, -0.04371035f, -0.14860006f, 
    0.43766749f, 0.11487621f, 0.01308381f, 0.15625338f, 0.13010260f, 0.08325884f, 0.12623626f, 0.20730267f, 
    -0.06622047f, 0.10872607f, -0.01021472f, 0.06207559f, 0.32332829f, 0.04183090f, 0.00011778f, 0.28767541f, 
    0.01179110f, 0.00214795f, 0.03683830f, 0.02119379f, -0.06960683f, -0.03583795f, -0.07611401f, 0.03605036f, 
    0.00855750f, -0.18013333f, 0.15354809f, 0.33382168f, -0.11613335f, -0.04736800f, 0.03687802f, 0.04595493f, 
    0.09762861f, -0.06896948f, 0.06580561f, 0.16987956f, 0.42320666f, 0.25770164f, -0.22924769f, 0.24164237f, 
    0.03581216f, 0.13982560f, 0.02011999f, 0.10754357f, -0.07696128f, 0.08794707f, -0.10397249f, 0.04635731f, 
    0.02564807f, -0.05144211f, 0.02516167f, -0.01111683f, -0.01467423f, -0.05910508f, -0.04772650f, -0.04754549f, 
    0.01323406f, -0.00492927f, -0.04300281f, -0.03526349f, -0.03256940f, -0.00560187f, -0.04447633f, -0.03906475f, 
    -0.04280389f, -0.01181191f, -0.01014636f, -0.00600320f, 0.00799063f, -0.03999722f, 0.00836967f, 0.02317530f, 
    -0.03280147f, -0.03703911f, -0.04576458f, 0.01533704f, 0.03620492f, 0.02761883f, -0.04424723f, -0.03127821f, 
    0.02906233f, -0.04110937f, -0.00880188f, 0.01472431f, -0.02767995f, -0.02191917f, -0.03138941f, 0.04719410f, 
    -0.02007228f, 0.04077947f, -0.00687880f, 0.02834654f, 0.03577950f, 0.02236778f, -0.02292557f, 0.03215718f, 
    0.00429189f, 0.03951879f, 0.00445430f, -0.02621981f, -0.03122910f, -0.06001847f, -0.01921415f, -0.00905635f, 
    -0.03222515f, 0.02083594f, -0.06662535f, -0.01299937f, 0.04941543f, 0.02495751f, -0.02550440f, -0.03684349f, 
    -0.03107539f, -0.00884559f, 0.00366871f, -0.00601490f, -0.01366069f, -0.04947281f, -0.04501063f, 0.01090979f, 
    -0.00699227f, -0.04465334f, -0.04754988f, 0.00505152f, -0.06010739f, 0.03109553f, -0.04070433f, -0.04355478f, 
    -0.02094974f, -0.00805192f, 0.00516980f, -0.02894524f, -0.00227872f, -0.05265913f, 0.04729744f, -0.02330843f, 
    -0.01090380f, -0.04238621f, -0.02733096f, -0.02092496f, -0.06564784f, -0.01109127f, 0.02443780f, -0.03551663f, 
    -0.05385473f, -0.01652661f, -0.01962944f, -0.02204903f, -0.05582860f, 0.00573492f, -0.06270796f, -0.00759695f, 
    -0.00435192f, 0.05562291f, -0.03429935f, 0.03686598f, -0.01608453f, 0.05326675f, 0.05923055f, -0.03292933f, 
    0.04451535f, 0.00535073f, -0.04695362f, -0.02643023f, -0.06340472f, 0.03133443f, 0.01695352f, -0.02620124f, 
    0.03579338f, -0.04422273f, -0.02925040f, 0.00750266f, 0.03317511f, -0.00791761f, -0.00326084f, -0.04322626f, 
    0.03309551f, -0.01798861f, 0.03084317f, 0.00408210f, -0.03850646f, -0.00972686f, -0.00233250f, -0.03741547f, 
    -0.04700369f, -0.01491705f, -0.00697247f, -0.03239845f, -0.01520367f, -0.01313347f, -0.04632460f, -0.01174105f, 
    -0.01326825f, -0.05075425f, 0.03690489f, -0.05293922f, -0.00114084f, -0.03381042f, -0.01959752f, -0.01114312f, 
    -0.01542874f, 0.03050700f, 0.03897635f, -0.05866652f, -0.03153490f, -0.03087180f, -0.04318698f, 0.01773486f, 
    -0.03836509f, 0.01677975f, -0.04547480f, -0.00889609f, 0.03471037f, 0.00450612f, -0.01157337f, -0.03479879f, 
    0.06008086f, 0.01370959f, 0.05764514f, -0.04265519f, -0.02242026f, -0.01067223f, -0.02297695f, 0.03046833f, 
    0.01148483f, -0.05388723f, 0.03120668f, 0.01585785f, 0.01280517f, -0.05953172f, -0.06898224f, -0.02118842f, 
    0.01028274f, -0.03345507f, 0.04145937f, 0.00373272f, 0.03692707f, -0.03381245f, -0.00572732f, 0.01484989f, 
    -0.01564328f, 0.01208818f, 0.00061250f, 0.04269619f, -0.03368317f, -0.05195018f, 0.01073364f, -0.02983256f, 
    0.00890932f, -0.02175397f, 0.02024765f, -0.00667506f, -0.04623906f, 0.01975746f, -0.01258644f, -0.00141276f, 
    -0.04508207f, -0.03213700f, -0.00355348f, -0.04850122f, -0.05287285f, -0.00833807f, -0.01529763f, 0.02335855f, 
    -0.01048816f, -0.01510992f, -0.01815745f, 0.03689715f, -0.04432016f, 0.00041067f, -0.02459326f, -0.03531279f, 
    0.03375172f, 0.05005387f, 0.00281447f, -0.05217679f, -0.00860623f, -0.04752977f, 0.04429656f, -0.00787110f, 
    0.00023936f, -0.03046769f, -0.00517704f, 0.03272890f, -0.02187176f, 0.01955395f, 0.03669692f, 0.02364947f, 
    -0.06534832f, 0.02637842f, -0.04937347f, -0.01413414f, 0.02007372f, -0.02235864f, -0.06012478f, -0.04744811f, 
    0.01033021f, 0.02322994f, 0.02584129f, -0.02534802f, -0.00142152f, -0.00548954f, 0.04362544f, 0.01424726f, 
    0.00818231f, -0.04622831f, -0.03538315f, 0.04350672f, -0.06055171f, -0.00140072f, -0.01933181f, -0.01358510f, 
    -0.01090411f, -0.05296149f, 0.03563454f, 0.04301635f, -0.03626233f, 0.04726225f, -0.00170866f, -0.02643631f, 
    -0.05388362f, -0.01792858f, -0.00373965f, 0.02370506f, -0.03481988f, 0.00943637f, 0.03203570f, -0.00097268f, 
    0.03843214f, 0.00166853f, 0.02614648f, -0.00240728f, 0.02067551f, 0.00905570f, 0.02390545f, 0.01464788f, 
    0.01262335f, 0.05961048f, -0.02724272f, 0.02462759f, -0.04938652f, -0.03995369f, 0.02370809f, 0.01573256f, 
    -0.05535854f, 0.00593789f, 0.00649672f, -0.01067899f, -0.03998977f, -0.02431972f, 0.02305375f, -0.04483193f, 
    -0.02266209f, -0.04428598f, 0.00098020f, 0.03099659f, -0.06043094f, 0.03709887f, -0.04415834f, -0.04131415f, 
    -0.00824251f, -0.04637052f, -0.02335048f, 0.00132716f, -0.05070958f, -0.01499080f, 0.01133568f, 0.01343879f, 
    0.01722989f, -0.05131498f, -0.00542343f, -0.00145246f, -0.02841588f, -0.02957340f, -0.06596191f, 0.00478001f, 
    0.00783096f, -0.02572357f, 0.03610217f, 0.04471129f, 0.03478695f, 0.02941314f, -0.04612575f, -0.04137115f, 
    -0.01350792f, 0.00899126f, 0.03352286f, 0.00573125f, -0.02032646f, -0.06084099f, -0.05386244f, -0.03944275f, 
    -0.05988922f, -0.01839388f, -0.02840663f, 0.03975284f, -0.04621425f, -0.01923569f, -0.03872692f, 0.01817974f, 
    -0.00145188f, 0.00627843f, 0.03752095f, -0.01820290f, 0.00774602f, 0.01550030f, -0.01200197f, -0.01349639f, 
    0.04613158f, 0.03636345f, -0.00555445f, -0.00871583f, -0.01075951f, 0.00565751f, 0.02128536f, 0.00696845f, 
    -0.00001468f, 0.03671015f, -0.03521086f, 0.01570617f, -0.02335578f, 0.04279216f, -0.02518997f, -0.01094844f, 
    -0.00976839f, -0.05409644f, 0.05106243f, 0.01306960f, -0.02685353f, 0.02832661f, -0.05789633f, 0.01630305f, 
    0.03245525f, -0.00338573f, 0.02895504f, -0.00474327f, -0.00158513f, 0.04058027f, -0.03651498f, -0.05327025f, 
    -0.03053089f, 0.00079073f, 0.01286650f, -0.05870229f, -0.00249998f, 0.03921119f, -0.05755182f, -0.03326689f, 
    -0.01735185f, -0.04148119f, -0.05432853f, -0.02588362f, -0.00181145f, 0.03843338f, 0.03430811f, 0.00480216f, 
    0.04307508f, 0.02862605f, 0.02004047f, 0.01705887f, -0.03307701f, -0.05366579f, 0.02378522f, 0.00338839f, 
    -0.00214051f, -0.00685488f, -0.05696893f, 0.03492946f, -0.03221449f, -0.00250024f, -0.04444694f, -0.05261146f, 
    -0.04642580f, 0.01734879f, -0.01405228f, -0.01037892f, 0.03135930f, 0.01339518f, 0.02612219f, -0.05003650f, 
    -0.00562796f, -0.04843871f, 0.04172657f, -0.01302809f, 0.03444684f, -0.03728967f, -0.00833710f, -0.02695895f, 
    -0.05434899f, -0.01837999f, 0.03020716f, 0.03045472f, 0.00381225f, -0.02118474f, -0.01698308f, 0.02354663f, 
    -0.04321733f, -0.04133442f, -0.03931845f, -0.02233276f, -0.04964798f, 0.03901632f, -0.02069331f, 0.00485405f, 
    0.02372891f, -0.02817100f, -0.05790120f, 0.03922182f, 0.00527848f, -0.01844207f, 0.02861600f, -0.01823735f, 
    0.04324611f, -0.03248275f, -0.00701102f, 0.02766002f, -0.02032074f, 0.01394564f, -0.01090512f, -0.01073604f, 
    -0.00614607f, -0.01211257f, 0.03030409f, 0.00021308f, 0.02466664f, -0.01274067f, 0.02022130f, -0.03679625f, 
    -0.02284845f, -0.03153982f, 0.03683029f, 0.03396152f, 0.02941592f, -0.03775038f, 0.00493825f, -0.05344165f, 
    -0.04639610f, -0.03756933f, 0.01043674f, 0.03469617f, 0.04036779f, 0.00329481f, 0.00142755f, 0.00124092f, 
    0.02607100f, -0.03854689f, 0.02439285f, -0.02169273f, -0.04903898f, -0.00184073f, -0.04733808f, -0.02867820f, 
    -0.01937147f, 0.02073412f, -0.02127938f, 0.04048400f, 0.03828556f, 0.00519071f, 0.01095380f, -0.02119443f, 
    -0.01493479f, 0.03583579f, -0.05481363f, -0.04207051f, -0.01177458f, 0.02503018f, -0.05811168f, 0.00799084f, 
    0.00116159f, -0.01478767f, -0.03126270f, 0.03076080f, 0.00556491f, 0.03388697f, 0.00604243f, -0.04581780f, 
    0.03707842f, 0.03359471f, -0.05691583f, -0.05365222f, 0.00847888f, 0.02834600f, -0.01524387f, 0.03446863f, 
    0.01425678f, -0.02530787f, -0.03050062f, 0.01192689f, -0.01323604f, 0.02535773f, -0.04723776f, -0.03193841f, 
    0.00858530f, -0.02610963f, 0.02856779f, -0.01946810f, -0.01880655f, -0.05506796f, -0.00734762f, -0.01593617f, 
    0.00373408f, 0.02109473f, -0.05598326f, -0.05544391f, -0.02974896f, 0.00671227f, -0.00762554f, -0.00925697f, 
    -0.01911954f, 0.04168601f, -0.01517739f, -0.03194037f, 0.03082611f, 0.04544612f, -0.01158562f, -0.04800969f, 
    0.01438635f, 0.02359342f, -0.03762283f, -0.04872876f, -0.01801868f, -0.05146330f, 0.03792098f, 0.03220226f, 
    0.00016370f, -0.03353157f, -0.01810200f, -0.03773081f, 0.00423490f, 0.01135123f, 0.00885283f, -0.02693234f, 
    0.03701745f, -0.04024127f, -0.02550895f, -0.04902698f, -0.03173403f, -0.05525579f, -0.02902267f, -0.05718601f, 
    -0.03907743f, -0.01819646f, -0.02573546f, 0.01766631f, -0.04054214f, -0.01899716f, -0.01184471f, -0.05739660f, 
    -0.05166731f, 0.00997036f, 0.00249985f, -0.04239659f, 0.02004168f, -0.03198379f, -0.04896464f, 0.00354475f, 
    -0.01507146f, 0.01074664f, 0.02492579f, -0.02132997f, 0.02593440f, 0.00779373f, -0.01907521f, -0.05224066f, 
    0.00019218f, 0.03787003f, 0.01732233f, -0.03550389f, 0.01722338f, -0.00404962f, 0.03351685f, 0.00050873f, 
    -0.02061480f, 0.02222014f, 0.04005041f, -0.02667360f, -0.02271294f, 0.01164036f, -0.02891575f, -0.00087534f, 
    0.03625007f, 0.00843359f, -0.00617847f, -0.01421950f, -0.02255246f, 0.00464646f, -0.00955435f, 0.00921217f, 
    -0.01280734f, -0.01955957f, -0.04524682f, -0.02607677f, 0.00583548f, -0.04245505f, -0.05269497f, 0.03745131f, 
    -0.04933005f, -0.04632185f, 0.03892554f, 0.02493586f, -0.01717045f, -0.02529522f, 0.03036307f, 0.02776686f, 
    -0.01466564f, -0.01112504f, 0.01148086f, -0.00550975f, 0.01250746f, -0.05097362f, 0.01523011f, -0.03943829f, 
    -0.02987340f, -0.05299112f, 0.03884114f, 0.02145765f, 0.03426517f, 0.02294597f, -0.02933033f, 0.02097670f, 
    0.03778966f, 0.00347034f, 0.02251298f, -0.05025146f, 0.00803999f, -0.03616747f, 0.01049753f, 0.03904964f, 
    -0.02389457f, 0.01205399f, 0.01629159f, 0.03122639f, 0.00224836f, -0.04868099f, -0.01655530f, 0.02353586f, 
    0.01047028f, -0.05756395f, -0.02386596f, 0.01097365f, -0.03065622f, -0.02857572f, 0.03173497f, -0.05068962f, 
    -0.04374909f, -0.00015927f, 0.00001693f, -0.00889405f, 0.00798770f, -0.00379287f, -0.01082810f, -0.02333858f, 
    -0.00384483f, -0.03582832f, -0.05381536f, -0.01688026f, -0.00088394f, 0.00941991f, -0.00672585f, -0.02560852f, 
    -0.05741369f, 0.03455060f, -0.01959847f, -0.03004825f, 0.00827991f, 0.01218613f, 0.02377592f, -0.00532638f, 
    0.03849876f, -0.01920631f, 0.00581778f, 0.02516197f, -0.01189751f, -0.01658009f, -0.02590596f, -0.05721229f, 
    0.04282208f, 0.02025411f, -0.03923820f, 0.03101269f, 0.02179749f, 0.03256927f, 0.01802611f, -0.02476861f, 
    0.03743041f, -0.00217598f, 0.03855360f, -0.03558855f, 0.00027348f, 0.02025379f, -0.05349074f, -0.04716488f, 
    -0.05451822f, -0.05720538f, -0.05458986f, -0.01152259f, -0.00213904f, -0.02218363f, 0.01239251f, 0.02532277f, 
    -0.01086457f, -0.02822089f, -0.01686667f, -0.05411724f, -0.00777364f, -0.01998178f, 0.02769271f, -0.04700578f, 
    0.03908772f, -0.05760508f, 0.03412421f, 0.03657108f, 0.01225944f, 0.00680201f, 0.01321875f, -0.02557141f, 
    0.00457597f, -0.01273746f, -0.04884803f, -0.04235621f, 0.01856254f, -0.05102915f, -0.02786628f, 0.03986626f, 
    0.01137426f, 0.01345007f, -0.02739372f, 0.01791835f, 0.01706737f, -0.02066169f, 0.03626848f, 0.03814509f, 
    -0.01681226f, -0.04446601f, -0.00709935f, 0.00079932f, 0.00232710f, 0.01988980f, 0.03358540f, 0.02414339f, 
    0.02232702f, 0.02665735f, -0.05661929f, -0.02512089f, 0.03950201f, 0.01240895f, -0.01851108f, 0.01762891f, 
    0.02921890f, -0.03490258f, -0.01205595f, -0.05116841f, 0.03151910f, -0.00026109f, -0.00012408f, -0.02087071f, 
    -0.02726457f, -0.01236540f, 0.01387094f, -0.01518441f, -0.02347355f, -0.00575699f, 0.03314719f, 0.04040802f, 
    -0.02305858f, -0.05980230f, 0.03501056f, 0.03114006f, 0.01863413f, 0.00960554f, -0.00471644f, -0.02822511f, 
    0.02613313f, -0.02274220f, 0.01950060f, 0.01401984f, -0.02318130f, -0.04794918f, 0.00674956f, -0.03884932f, 
    0.02823138f, -0.04560336f, 0.00903579f, -0.04265979f, 0.02585765f, -0.02155140f, -0.02718252f, -0.05860255f, 
    -0.00160618f, 0.02743811f, -0.02117876f, -0.00102324f, -0.01125104f, -0.02205667f, -0.05690487f, -0.01637505f, 
    -0.04154537f, 0.01245466f, -0.02588538f, -0.05931010f, 0.04049864f, -0.02462258f, -0.04939856f, -0.04749233f, 
    0.03941764f, 0.01316875f, -0.02733148f, -0.05658922f, -0.05465838f, -0.00368867f, 0.00310450f, -0.00451984f, 
    -0.05286068f, -0.03217795f, 0.03315580f, -0.00873853f, -0.05130051f, -0.03483795f, -0.01999879f, -0.03253220f, 
    -0.01906963f, 0.02682850f, -0.04394386f, -0.04480235f, -0.00136531f, 0.01289364f, 0.03412964f, -0.04413483f, 
    -0.05135082f, 0.01604510f, 0.03448720f, 0.03472445f, -0.01273017f, 0.01080785f, 0.02901977f, -0.05147294f, 
    0.01028766f, 0.04474048f, 0.02175678f, -0.00886148f, 0.00808436f, 0.00149005f, -0.03591667f, 0.01414308f, 
    0.01083389f, -0.03550096f, -0.02885906f, -0.01354201f, 0.01066489f, -0.01578285f, 0.00594864f, -0.02256225f, 
    0.02034895f, -0.03196652f, -0.03068052f, 0.04010976f, 0.03792167f, 0.02256152f, 0.03187785f, 0.02219367f, 
    -0.04984310f, 0.01775763f, -0.04911910f, 0.03289512f, -0.03648386f, -0.02522138f, -0.02472210f, -0.02032567f, 
    -0.00511226f, 0.03358481f, 0.02239202f, 0.00570084f, -0.02134015f, -0.00080448f, -0.01136007f, 0.01422235f, 
    -0.02969751f, 0.00201556f, 0.03432948f, 0.04720857f, -0.03348617f, 0.02512814f, 0.03074062f, -0.02523708f, 
    -0.05065212f, -0.05195089f, -0.01349588f, -0.04169537f, 0.02956340f, -0.00729942f, -0.05707469f, -0.03843561f, 
    0.02178905f, 0.04525977f, -0.05257211f, -0.03791505f, 0.00908435f, -0.02420325f, -0.00920231f, -0.02417366f, 
    -0.00371397f, -0.05278707f, 0.02799630f, 0.00935554f, 0.01519181f, -0.05673901f, -0.05399224f, 0.01963855f, 
    0.00677617f, -0.06125577f, 0.03451182f, 0.00805311f, 0.02641842f, 0.00584857f, -0.05787430f, -0.05151378f, 
    0.03192495f, -0.04750353f, -0.00165868f, -0.03080045f, 0.01794728f, 0.03101710f, -0.01461873f, 0.00330341f, 
    -0.04991527f, 0.03321912f, -0.05764366f, 0.02111251f, -0.01810764f, 0.00380342f, -0.04804791f, -0.01230706f, 
    0.04705517f, -0.00916492f, -0.05767692f, -0.04028985f, -0.02684571f, 0.02471749f, 0.03584576f, -0.00681401f, 
    -0.02390459f, -0.04926749f, -0.05048198f, -0.00428822f, -0.03477698f, -0.03390982f, 0.01274406f, -0.04022315f, 
    0.01963827f, -0.00300079f, -0.02905832f, -0.04139683f, 0.03148558f, 0.02383266f, 0.00093096f, -0.01025746f, 
    0.01586166f, 0.01939932f, 0.02978699f, 0.02464656f, -0.01061402f, -0.05294362f, 0.01534281f, -0.05690258f, 
    -0.05054777f, -0.04554219f, -0.05720888f, -0.00183730f, -0.02382511f, 0.03393396f, 0.03287121f, -0.03894067f, 
    -0.00281691f, 0.01864229f, 0.02648215f, 0.01277634f, 0.03203078f, -0.01869661f, 0.01066871f, 0.02480240f, 
    0.03455734f, -0.00314109f, -0.02472101f, 0.00280450f, 0.01544225f, -0.00492224f, 0.03188436f, -0.05568873f, 
    -0.04732794f, -0.02536335f, -0.01251057f, -0.04874505f, -0.04118420f, 0.03281371f, -0.04816323f, -0.00878696f, 
    0.00862688f, -0.04738333f, 0.03884651f, -0.05230539f, -0.02460529f, -0.01608820f, 0.01302257f, -0.05096401f, 
    -0.01054754f, 0.02284805f, -0.01585755f, 0.01025421f, -0.03683271f, 0.00982936f, -0.05336508f, -0.01397884f, 
    0.00554139f, -0.01581512f, 0.00676340f, 0.04217274f, -0.04043365f, 0.03582984f, -0.01390944f, 0.03476382f, 
    -0.05514484f, 0.02597489f, 0.01913860f, 0.01574256f, -0.02006578f, -0.02864214f, 0.02435293f, -0.00219263f, 
    -0.04287782f, 0.01425112f, -0.02918258f, -0.01896290f, -0.06500047f, 0.04204990f, -0.04044712f, -0.04152826f, 
    -0.04623913f, 0.04044142f, 0.04853266f, -0.00871891f, -0.00359530f, 0.01325733f, -0.02788826f, -0.00613762f, 
    -0.02397122f, 0.01274121f, 0.03062725f, -0.04958481f, -0.00826796f, 0.02576312f, -0.00386705f, -0.03340133f, 
    -0.04602123f, -0.01750549f, -0.03548812f, 0.04430192f, 0.02463301f, -0.01377945f, -0.02872573f, -0.02552014f, 
    -0.01105925f, -0.05352116f, -0.03896703f, -0.02600370f, 0.04260611f, 0.01141437f, -0.00581970f, -0.02321634f, 
    0.00919813f, -0.00351728f, 0.03940025f, -0.03147667f, -0.00975960f, -0.00421493f, -0.01496258f, -0.06471139f, 
    -0.03896387f, 0.01960937f, -0.04436059f, -0.01595219f, 0.02773570f, 0.01735113f, -0.02731856f, -0.01810012f, 
    0.02698329f, -0.01920347f, 0.01962455f, 0.01010689f, -0.02338007f, -0.04209097f, -0.03168656f, 0.02559227f, 
    -0.05648270f, -0.00094377f, -0.02683495f, 0.02728976f, -0.04671766f, -0.00139093f, 0.04391830f, -0.04700604f, 
    -0.19186205f, 0.04035545f, 0.26028040f, 0.02052803f, 0.13432300f, -0.00166328f, 0.06400606f, -0.13078265f, 
    -0.05530503f, 0.04399200f, -0.11989343f, 0.04943785f, 0.17014447f, -0.26247254f, -0.22015588f, 0.05548078f, 
    -0.06918009f, -0.00177913f, 0.00319581f, 0.03886170f, -0.01511105f, -0.08409699f, 0.05100935f, -0.04426803f, 
    0.13439742f, -0.04939337f, -0.02603672f, 0.19402222f, -0.04077916f, -0.05744013f, -0.05092745f, -0.10300998f, 
    -0.01981409f, 0.00003053f, 0.04882497f, 0.05896318f, 0.03267512f, 0.20118353f, -0.11357170f, -0.15589599f, 
    0.02135054f, -0.16565782f, 0.01976034f, 0.17137598f, 0.03990784f, -0.08191673f, -0.12585454f, 0.14691660f, 
    -0.20948018f, 0.12011360f, -0.22474982f, 0.12102574f, -0.01497374f, -0.04320097f, -0.01755193f, 0.09574472f, 
    -0.02425257f, 0.03513124f, 0.08440372f, 0.05250040f, -0.30846527f, -0.24793886f, 0.16862835f, 0.09125584f, 
    -0.00252133f, -0.04145299f, 0.09139489f, 0.00133818f, -0.07006172f, 0.08743733f, 0.07086782f, 0.00057120f, 
    -0.23437083f, -0.04024657f, -0.12666500f, 0.10204157f, -0.00429921f, -0.00082259f, 0.00419757f, -0.01445740f, 
    -0.01568628f, 0.07717419f, 0.14302140f, 0.00884365f, 0.12161683f, -0.25693280f, 0.18813460f, -0.19662870f, 
    -0.11388320f, -0.02474883f, 0.03614018f, -0.08326618f, 0.14320683f, 0.03175624f, 0.10762134f, 0.04321007f, 
    0.14392881f, 0.08680166f, 0.04957948f, 0.28100252f, -0.04126826f, 0.00988076f, 0.08167436f, 0.07680761f, 
    0.08441161f, 0.16257711f, 0.00834320f, 0.08479173f, 0.09726475f, 0.17523421f, 0.02850038f, 0.19640355f, 
    -0.07775710f, -0.08068877f, 0.08590452f, -0.02688604f, 0.05271507f, -0.03529106f, 0.04675896f, -0.08796693f, 
    0.14020240f, -0.01074749f, -0.02546945f, 0.10900643f, 0.02925041f, 0.00935336f, -0.05914736f, 0.09756916f, 
    -0.03483504f, 0.07070255f, -0.01133808f, -0.07333151f, 0.06961627f, -0.01116752f, -0.03031564f, -0.02351081f, 
    0.02178051f, -0.02013903f, 0.13336657f, 0.05330121f, 0.03130228f, 0.11041263f, -0.01751419f, -0.08071783f, 
    0.10790142f, 0.11066299f, 0.04860858f, -0.00499220f, 0.06817715f, -0.08268396f, 0.04783332f, 0.08509060f, 
    0.06863146f, -0.00768958f, 0.07734960f, 0.01686570f, -0.09353269f, -0.09898952f, -0.09750073f, 0.22039902f, 
    -0.06218871f, 0.13906942f, -0.02368451f, -0.02840512f, 0.01006059f, -0.07163864f, 0.04945265f, 0.08904547f, 
    -0.16085283f, 0.00702756f, 0.01335626f, 0.21326159f, -0.02336608f, -0.00558331f, 0.04966900f, 0.15208980f, 
    -0.01925743f, 0.02300080f, -0.01828647f, -0.08662516f, -0.26615515f, -0.04750193f, -0.00256719f, 0.11157174f, 
    -0.15580189f, 0.07437075f, -0.06133468f, -0.05308683f, -0.06441309f, 0.02553818f, 0.02504557f, 0.09321009f, 
    0.03729857f, 0.07347436f, 0.17720851f, 0.17510612f, -0.02568017f, -0.03130232f, -0.03789533f, 0.14345878f, 
    0.01334683f, 0.06885450f, 0.03904893f, 0.08634211f, 0.26570916f, 0.36044136f, -0.17874710f, -0.06739207f, 
    0.06125938f, 0.04088765f, 0.03977418f, -0.06078648f, 0.06206187f, 0.04841603f, 0.07596062f, 0.00235339f, 
    -0.41428623f, 0.03372833f, -0.07272829f, 0.05152047f, 0.05111609f, 0.08936807f, -0.07107066f, 0.03245703f, 
    -0.12305630f, -0.12853520f, -0.22907901f, 0.16387981f, -0.48566359f, 0.54108930f, -0.07628793f, -0.12044614f, 
    -0.06983527f, 0.00401029f, 0.10726085f, 0.09108389f, 0.05809930f, 0.06869513f, 0.07599291f, -0.02606932f, 
    -0.13661209f, -0.19484116f, 0.20293458f, 0.30780804f, 0.04031997f, -0.08129162f, 0.00002490f, -0.05256725f, 
    0.13775051f, -0.00701985f, 0.14135288f, 0.02838664f, 0.04689277f, 0.30089673f, 0.24986836f, -0.06611379f, 
    -0.03313296f, -0.03568552f, 0.02599340f, 0.06197771f, -0.03050797f, 0.03674875f, 0.02833974f, -0.06536666f, 
    -0.30243200f, 0.08355882f, 0.04339431f, -0.13689968f, -0.11972512f, 0.06325772f, 0.09765717f, -0.02930287f, 
    0.12848723f, 0.01413474f, 0.14492154f, 0.05879206f, 0.12404758f, -0.01873934f, 0.05514000f, 0.05924558f, 
    -0.12192641f, 0.03964513f, 0.05199508f, 0.02378639f, -0.09308869f, 0.04613471f, -0.03626410f, -0.00705784f, 
    -0.22845832f, 0.08672271f, 0.20592649f, 0.06995631f, 0.06364623f, -0.05836264f, -0.01001163f, 0.04509919f, 
    -0.02463356f, 0.14145355f, 0.03241403f, 0.04409524f, 0.18534702f, 0.21612920f, 0.15696815f, 0.16095209f, 
    0.09669799f, 0.10108124f, -0.01470897f, 0.09605338f, 0.08257037f, -0.07428677f, 0.09099188f, 0.08066376f, 
    0.14319724f, 0.21197273f, 0.18429911f, 0.04058887f, 0.06311781f, -0.01832715f, 0.02667847f, 0.01698722f, 
    0.15686071f, 0.00802744f, -0.13436072f, -0.08014279f, 0.28661212f, -0.17389631f, -0.13824306f, 0.09839296f, 
    0.08299509f, 0.03191455f, 0.01399477f, -0.00061661f, 0.09772573f, 0.03804469f, -0.08946701f, 0.25083664f, 
    -0.25334847f, -0.12949090f, -0.17426705f, 0.15063792f, -0.03307025f, 0.06166218f, -0.01513885f, -0.14535713f, 
    0.12786448f, -0.03389810f, 0.08255406f, -0.06754150f, -0.04692967f, 0.11345844f, -0.09540730f, -0.13633773f, 
    0.10869263f, -0.01320717f, -0.10228159f, 0.00825361f, 0.02567726f, 0.03357551f, 0.09728723f, -0.00144983f, 
    0.14900966f, 0.24607000f, -0.12037395f, 0.01528437f, 0.05049454f, -0.06438869f, 0.16613069f, 0.03785717f, 
    -0.11086186f, 0.13902070f, 0.02159283f, -0.08118733f, 0.00527171f, 0.20636104f, 0.08886512f, -0.25979084f, 
    0.09371483f, -0.01258180f, 0.05962615f, 0.04719104f, 0.10358482f, 0.03669684f, 0.08501305f, 0.01126784f, 
    0.04081482f, -0.01902542f, 0.01716301f, 0.04539032f, -0.03727392f, -0.04260547f, -0.03890175f, -0.03446553f, 
    -0.03438893f, -0.04032170f, -0.02829250f, 0.01673461f, -0.00528612f, 0.01129558f, -0.00649326f, 0.02796012f, 
    0.03919303f, -0.05384310f, 0.00207641f, 0.04781097f, -0.01387243f, -0.01276160f, -0.02745014f, -0.02541468f, 
    0.01882459f, 0.02739265f, -0.03555641f, 0.00479517f, -0.01198341f, -0.04337477f, -0.03986424f, -0.02450250f, 
    0.00532883f, 0.03375043f, 0.00982638f, -0.03395460f, 0.04450648f, 0.00833186f, 0.01210454f, 0.02655373f, 
    -0.04489348f, -0.05587645f, 0.01163254f, 0.01627959f, -0.04051669f, -0.00723025f, -0.04963950f, -0.02296583f, 
    -0.02566813f, -0.03767989f, -0.04044932f, -0.05437773f, 0.00316316f, 0.02711272f, 0.02065227f, -0.02824256f, 
    0.00736890f, -0.02822959f, 0.03630475f, -0.02326601f, -0.00485069f, -0.01655361f, -0.04888536f, -0.05017781f, 
    -0.00676051f, -0.00827422f, -0.05382257f, -0.01325021f, 0.01718085f, -0.04312844f, -0.03558084f, 0.00692800f, 
    -0.03643264f, -0.05474233f, -0.03064150f, -0.04143662f, -0.05471970f, 0.00709169f, -0.03114380f, 0.00086656f, 
    0.00672593f, 0.03982778f, -0.04973681f, -0.01747182f, -0.03666136f, -0.05099915f, 0.03985249f, -0.03667779f, 
    -0.02699044f, 0.03938594f, -0.02468421f, -0.05147400f, 0.02722006f, 0.03178035f, 0.00880384f, 0.03807573f, 
    0.00269398f, -0.02777242f, 0.03293810f, -0.01244244f, -0.00913130f, 0.02750998f, -0.03834697f, 0.05160375f, 
    -0.04302068f, 0.00127281f, -0.02648159f, -0.04383719f, 0.01199863f, -0.04628276f, -0.02213795f, 0.00921588f, 
    0.02369255f, 0.01771303f, 0.00316444f, -0.00778046f, 0.01886544f, 0.04172547f, 0.03965994f, 0.02744328f, 
    0.04008313f, 0.03184713f, -0.03284140f, 0.01301499f, -0.01059536f, 0.03821127f, -0.00587382f, 0.01529752f, 
    0.01410229f, -0.06102800f, -0.00345233f, -0.03215865f, -0.05440034f, -0.03833194f, -0.00522907f, -0.02583762f, 
    -0.00812121f, 0.00053147f, 0.00157117f, 0.01672667f, -0.02987569f, 0.00851623f, 0.02300759f, -0.04685194f, 
    -0.02102852f, -0.04245589f, 0.00563940f, 0.04154630f, -0.04362979f, -0.00457524f, 0.02663291f, 0.00931685f, 
    -0.04241427f, -0.01751256f, 0.03275714f, 0.00178811f, -0.05555900f, -0.01637943f, 0.00211644f, -0.05941976f, 
    -0.00679178f, 0.02417883f, -0.05906305f, -0.01919112f, -0.04269000f, -0.01854760f, 0.03941748f, 0.00226386f, 
    0.02657010f, 0.01035228f, 0.03251265f, -0.03506625f, -0.04350825f, 0.01044286f, -0.01072094f, 0.03158151f, 
    0.01471721f, 0.02091110f, -0.00013546f, 0.02409985f, 0.00855817f, -0.00640547f, 0.02822186f, 0.01514519f, 
    0.03915801f, -0.05849845f, 0.00314365f, -0.04235292f, -0.01914256f, -0.04832147f, -0.02207117f, 0.01237697f, 
    -0.03205099f, 0.01906269f, -0.01581712f, -0.04221236f, 0.02011437f, -0.02384060f, 0.03320201f, 0.00169887f, 
    0.03265464f, 0.01724011f, -0.00942736f, -0.00020510f, -0.03107341f, -0.04588854f, 0.00356997f, 0.00669642f, 
    -0.05294354f, -0.00098923f, 0.02573535f, 0.01482635f, -0.01685872f, 0.02335026f, -0.04521094f, 0.00322617f, 
    -0.03866751f, -0.04518309f, 0.04291394f, -0.04821400f, -0.01705809f, 0.02945032f, 0.00025460f, -0.04420242f, 
    0.02009251f, -0.02592511f, -0.03017425f, 0.04489093f, 0.00389755f, 0.02537189f, -0.02519278f, -0.06486074f, 
    0.04105687f, 0.03134036f, -0.01524804f, -0.03429062f, 0.00350701f, 0.01387120f, 0.03646449f, -0.02557972f, 
    -0.03021070f, -0.03420904f, 0.00335583f, -0.04635661f, -0.00650957f, -0.00508933f, -0.03181535f, -0.01755762f, 
    -0.05848845f, 0.04190481f, 0.00424992f, 0.01617458f, -0.00356224f, 0.03664183f, 0.02092988f, 0.02338581f, 
    0.03625461f, 0.01882924f, -0.00012123f, 0.03236939f, 0.00496687f, -0.04893581f, -0.03562747f, -0.04746120f, 
    -0.00893146f, -0.00544557f, -0.02563673f, 0.02810700f, 0.00229067f, 0.00876824f, -0.00618655f, -0.02221527f, 
    -0.01959238f, -0.01193928f, -0.02646341f, -0.00057141f, 0.06201624f, 0.01265170f, 0.01328102f, -0.03800366f, 
    0.01708116f, -0.00277976f, 0.04359247f, 0.01335159f, 0.03203374f, 0.00729543f, -0.01578350f, 0.04389432f, 
    0.02169482f, -0.02595294f, -0.00536850f, 0.02322095f, 0.03097676f, -0.00882257f, -0.03583519f, 0.00018531f, 
    -0.03314050f, -0.00524593f, -0.04716913f, 0.00973202f, -0.02152590f, -0.01075547f, 0.01680362f, 0.01261988f, 
    -0.03335618f, -0.01826334f, 0.01463312f, -0.04210753f, -0.00515763f, -0.01450046f, -0.01943333f, -0.00100284f, 
    0.00346187f, -0.00026617f, -0.04018641f, -0.00798620f, 0.04253737f, -0.00887952f, -0.01365955f, -0.01525833f, 
    -0.05327548f, -0.03322047f, -0.00158910f, 0.01544974f, 0.00669742f, 0.00145358f, 0.00654949f, -0.05158940f, 
    0.02118535f, -0.02715162f, 0.03511300f, -0.02588486f, -0.00877796f, -0.00957725f, 0.00400349f, -0.00365538f, 
    -0.06129254f, 0.03421593f, 0.01125400f, -0.01289858f, 0.00419830f, -0.03691499f, -0.04356325f, -0.00268933f, 
    -0.00452516f, 0.02301589f, -0.03149361f, 0.01627713f, -0.00050784f, 0.00851671f, -0.05534212f, 0.00413582f, 
    -0.01427028f, -0.04271721f, 0.00322683f, 0.00095591f, -0.05391844f, -0.05777086f, -0.02020939f, -0.02729757f, 
    0.00907677f, 0.03224313f, -0.00855548f, -0.01576096f, 0.03865964f, -0.03376650f, -0.01006810f, -0.05765777f, 
    -0.05487088f, -0.01353564f, 0.03808895f, -0.01172910f, 0.03265873f, 0.02926190f, 0.02724167f, -0.01679033f, 
    0.02986669f, 0.01824458f, 0.00811574f, -0.03002737f, -0.03705152f, 0.01971792f, -0.03813368f, -0.00713962f, 
    0.01722440f, 0.00264625f, 0.00300903f, -0.00689790f, -0.01134386f, 0.01151063f, -0.03069128f, 0.01785707f, 
    0.00680970f, -0.03043110f, 0.02811619f, 0.03945739f, -0.04660619f, -0.02944213f, -0.04965115f, -0.02411424f, 
    -0.04290035f, 0.01371371f, -0.01286967f, -0.01012701f, 0.03865869f, -0.01099180f, 0.01349393f, 0.01277775f, 
    -0.05584187f, -0.05640938f, 0.01328348f, -0.03854313f, 0.00897685f, 0.02433960f, -0.05460402f, 0.04592133f, 
    0.00873587f, -0.02714993f, 0.00755105f, 0.03778955f, -0.05966496f, 0.00198231f, -0.03446797f, -0.03769680f, 
    0.01601752f, 0.01054337f, 0.01088004f, 0.02078454f, 0.01001083f, -0.00534080f, -0.03531875f, -0.00778309f, 
    0.04554781f, 0.01048889f, 0.04611890f, 0.00323591f, 0.02750734f, -0.05244996f, 0.03188604f, 0.02653479f, 
    0.00562640f, -0.00217048f, -0.05266618f, 0.01185731f, 0.02306421f, 0.00534831f, 0.01647745f, -0.02868513f, 
    -0.01837040f, -0.05439039f, -0.04580945f, -0.02911129f, 0.04151695f, 0.02579186f, -0.03773607f, 0.00485944f, 
    0.01765959f, 0.00068363f, -0.01798136f, -0.04892839f, -0.02750469f, 0.02209070f, -0.03821147f, -0.05004951f, 
    0.02920710f, 0.01514541f, -0.05488393f, -0.03550300f, 0.04071500f, -0.03862784f, 0.00640171f, 0.04206663f, 
    -0.03227233f, 0.02243668f, 0.00593183f, -0.04023028f, -0.00363411f, -0.04995565f, -0.03142460f, 0.03556699f, 
    0.01865677f, 0.02271883f, 0.03231398f, 0.02716051f, -0.00897650f, 0.02938320f, 0.02047513f, 0.02733161f, 
    -0.05204635f, -0.00740023f, -0.01477697f, 0.00593832f, 0.03496951f, -0.04761180f, 0.01756105f, -0.03348349f, 
    -0.04499934f, -0.02497213f, -0.00894929f, -0.01189119f, -0.03566734f, -0.04473780f, -0.01014423f, -0.04225110f, 
    -0.00135628f, 0.01851889f, -0.00333325f, 0.02293057f, -0.05766084f, -0.00339080f, 0.03134491f, -0.00994551f, 
    0.01818535f, 0.02609565f, 0.02720243f, 0.02612950f, -0.05583223f, -0.02588950f, -0.03172997f, -0.05057018f, 
    0.03765275f, 0.03848116f, -0.02333638f, -0.03858242f, -0.04310852f, -0.04560288f, -0.03603153f, -0.01912956f, 
    0.01411129f, 0.02706347f, -0.01491830f, 0.03592522f, -0.02343730f, 0.01547784f, 0.03557225f, 0.00649614f, 
    0.01197521f, 0.00361575f, 0.01666700f, -0.05517551f, 0.04052848f, 0.01050990f, -0.03669754f, -0.01121322f, 
    0.02814222f, 0.01796808f, 0.02847759f, -0.00557138f, -0.01522468f, -0.05381262f, -0.04090834f, -0.04558473f, 
    -0.00720632f, -0.00349406f, 0.04447906f, -0.00497495f, -0.04113858f, -0.04455912f, 0.01850533f, 0.01877906f, 
    0.01335520f, -0.02592205f, 0.03193888f, 0.00815439f, -0.05209073f, -0.01462058f, 0.03026781f, 0.02793602f, 
    -0.01912348f, -0.02550218f, -0.01868710f, -0.02142206f, 0.00709382f, -0.03749739f, 0.02039165f, 0.00562567f, 
    0.02420097f, -0.02429476f, -0.04102062f, -0.05383940f, 0.00386512f, 0.01272043f, -0.00949616f, -0.05932710f, 
    -0.04608045f, -0.04861629f, -0.01075646f, -0.01150379f, -0.04497066f, 0.01263604f, 0.03710237f, 0.03738979f, 
    -0.02525329f, 0.04247792f, -0.04253439f, -0.03089262f, 0.03627794f, -0.05036766f, 0.03438473f, 0.04010367f, 
    0.01887305f, 0.03321091f, -0.02992486f, -0.02690293f, -0.00546694f, -0.02550205f, -0.00681280f, 0.02781541f, 
    -0.03922113f, -0.01890140f, 0.03153448f, -0.03218815f, 0.03477486f, -0.01683871f, 0.01816596f, 0.01646182f, 
    -0.01410741f, 0.02974153f, -0.03747043f, 0.02193904f, -0.04407455f, -0.02070700f, 0.03692352f, -0.01486265f, 
    0.02227100f, -0.03644300f, -0.04312888f, 0.00972591f, 0.01653262f, -0.04629083f, 0.01991304f, -0.03072306f, 
    -0.05108727f, 0.02832188f, -0.04962700f, 0.03803271f, 0.01458700f, -0.00553887f, 0.03929907f, -0.01893016f, 
    -0.03313504f, 0.04598665f, 0.03539330f, -0.05830780f, 0.02742634f, 0.03268107f, -0.03815999f, 0.04637458f, 
    0.03177823f, -0.03984578f, 0.00980442f, 0.04435738f, 0.01075785f, -0.04817132f, 0.02094996f, -0.02775681f, 
    0.02357311f, -0.01543993f, -0.00703549f, -0.01984496f, 0.03475308f, 0.01000037f, 0.02761177f, -0.03671458f, 
    0.04206503f, -0.03416707f, -0.02975703f, 0.00670866f, 0.01002344f, -0.02486618f, -0.03603940f, 0.03221817f, 
    0.00559950f, 0.01493596f, -0.01423165f, -0.04166443f, -0.01983006f, 0.03426699f, -0.04070925f, -0.01734301f, 
    0.03892440f, 0.01756599f, -0.03230648f, -0.03293159f, 0.00076723f, -0.00712419f, -0.00017116f, -0.01897454f, 
    0.03909324f, -0.02074101f, -0.01502658f, -0.00703004f, -0.04759506f, -0.02258833f, -0.00139664f, 0.00227705f, 
    -0.04519257f, -0.03272148f, 0.01467470f, -0.05518492f, -0.05004405f, -0.03923187f, -0.05207266f, 0.03636423f, 
    -0.02175635f, 0.02143578f, 0.01667669f, 0.03187939f, -0.01348076f, -0.01514976f, 0.01160915f, 0.03828904f, 
    0.00686699f, 0.02189876f, 0.03011524f, 0.01392605f, 0.02526249f, 0.03747644f, -0.01164697f, 0.00610678f, 
    0.01635220f, -0.02342140f, 0.02330699f, 0.00698773f, -0.03605822f, 0.01101033f, -0.04594570f, -0.00788042f, 
    0.04435253f, -0.00812729f, -0.02309214f, 0.02604959f, -0.00567131f, -0.01389374f, -0.03422865f, -0.02070223f, 
    0.02723821f, 0.04611327f, 0.02219930f, -0.01298928f, -0.05798941f, -0.02548614f, 0.03305446f, -0.00490004f, 
    -0.04354024f, -0.03747986f, -0.02235604f, -0.01644487f, -0.02693231f, -0.00463526f, -0.03870864f, -0.00902811f, 
    -0.02479830f, 0.03590094f, 0.04373345f, -0.04092313f, -0.00977463f, 0.03479484f, -0.05487469f, 0.00825975f, 
    0.01526107f, -0.01606935f, -0.02889845f, -0.00755169f, -0.02095783f, -0.02934188f, -0.04034663f, -0.02399075f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05973674f, 0.07348220f, 0.01410589f, -0.00638420f, -0.05907623f, -0.07965796f, -0.03952156f, 0.01890864f, 
    -0.01438157f, 0.04485890f, -0.00032592f, 0.02172918f, 0.06645167f, -0.00707271f, 0.03507616f, -0.02881963f, 
    0.02232367f, 0.03865067f, 0.12025192f, 0.02387171f, 0.04372077f, 0.00671344f, 0.02069212f, -0.05937157f, 
    -0.03167125f, -0.01047984f, 0.02661359f, -0.02219936f, -0.01064846f, -0.01373283f, 0.09355190f, 0.00416132f, 
    -0.04066880f, -0.02851903f, 0.08209351f, 0.12421750f, 0.04308228f, -0.04940799f, 0.04916450f, 0.02999539f, 
    -0.04828248f, 0.01038874f, 0.03502009f, -0.00188034f, -0.05097208f, 0.02201346f, -0.04012827f, 0.02614768f, 
    0.01817489f, 0.04373048f, 0.01579741f, -0.00098361f, 0.04944431f, -0.00029870f, 0.03698020f, 0.06158020f, 
    -0.02512453f, 0.03243772f, -0.04037211f, 0.01156191f, 0.00252417f, 0.02117221f, -0.05094200f, -0.01168861f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.42532256f, 0.20758407f, 0.41440919f, -0.08365381f, -0.27015957f, 0.08842114f, -0.02714866f, 0.07751355f, 
    -0.31874812f, -0.39290422f, -0.10220664f, -0.05859800f, -0.55901045f, 0.20669809f, -0.01062220f, -0.00546863f, 
    0.23383939f, -0.04504202f, -0.21773437f, -0.05085365f, -0.11388638f, 0.06732880f, -0.12545498f, -0.13084815f, 
    -0.09960075f, 0.23583253f, -0.03025753f, -0.03828600f, 0.06945938f, 0.11242744f, 0.19561309f, -0.05803021f, 
    -0.08044244f, -0.23390254f, -0.34673375f, -0.43098077f, 0.05587547f, 0.04122811f, -0.25610042f, 0.06960534f, 
    0.01138165f, -0.53965920f, -0.09266422f, 0.15634704f, 0.00521526f, -0.28720286f, 0.26799110f, 0.24132390f, 
    0.09116209f, -0.08178757f, 0.08970368f, 0.12796022f, -0.45534968f, 0.04789552f, 0.12926768f, 0.12422495f, 
    0.07817957f, 0.01741278f, 0.00398455f, 0.04525229f, 0.03127547f, -0.05348292f, -0.10145155f, 0.06138972f, 
    0.19201380f, 0.16243932f, -0.58854723f, -0.07988014f, 0.19266197f, -0.19346334f, 0.11472218f, -0.06412298f, 
    0.08966307f, 0.15887310f, -0.13274027f, -0.01793350f, -0.10137568f, -0.33822116f, 0.02839288f, 0.03989951f, 
    0.00370456f, -0.02206323f, 0.21771957f, 0.11854657f, 0.17470904f, -0.10413748f, -0.11632420f, -0.08813449f, 
    0.05932652f, 0.11836449f, 0.21940018f, -0.04539985f, 0.09591585f, -0.32385701f, 0.17828874f, -0.04491611f, 
    0.00960840f, -0.32450449f, 0.06865028f, -0.26294243f, -0.03162082f, -0.09243977f, 0.02836868f, -0.03163972f, 
    -0.08176326f, -0.42126021f, -0.06116379f, 0.32291436f, 0.05744537f, -0.65087372f, -0.01969350f, 0.05520818f, 
    -0.11837066f, 0.08276724f, -0.04559251f, 0.11164889f, -0.38717878f, 0.06589701f, 0.26549178f, -0.10878382f, 
    -0.00911172f, -0.20623046f, -0.09419723f, 0.05940221f, -0.02471874f, 0.12805647f, -0.12628216f, -0.04305448f, 
    0.07572224f, -0.02597627f, 0.25622147f, 0.02087138f, 0.34020635f, 0.10864673f, 0.02703151f, -0.05252826f, 
    -0.02354231f, 0.07776886f, 0.10412875f, -0.11675113f, -0.65769553f, -0.54122013f, -0.49285799f, 0.00302169f, 
    0.04300795f, -0.11795782f, 0.17336503f, 0.16969714f, -0.11757749f, -0.05108101f, 0.03872885f, -0.09747273f, 
    -0.02951442f, 0.20772205f, -0.18088697f, -0.08593453f, -0.11206593f, -0.34852555f, 0.12998269f, -0.10353614f, 
    -0.03528642f, 0.23418766f, 0.06808192f, -0.43768987f, -0.02344720f, -0.04651020f, -0.59475029f, 0.11866154f, 
    0.04208181f, 0.22206093f, 0.02542619f, -0.04603327f, 0.05134672f, 0.00855962f, 0.03335783f, -0.23005985f, 
    0.06874242f, 0.11602123f, -0.09229244f, -0.08534116f, 0.06186824f, -0.08208020f, -0.06665948f, 0.23241469f, 
    -0.08973192f, 0.20751895f, 0.06568568f, -0.09579305f, 0.07262844f, -0.20764630f, -0.03288582f, 0.01864661f, 
    -0.38754058f, -0.09738130f, 0.01762074f, 0.01735335f, -0.36220235f, 0.28098023f, -0.03306227f, 0.09173290f, 
    0.26079789f, 0.13910590f, -0.10613926f, -0.09604399f, 0.01614710f, -0.25628725f, 0.19992827f, 0.05515134f, 
    -0.76615614f, 0.02001715f, -0.34834465f, -0.03187377f, -0.17442712f, 0.04113198f, 0.09876291f, 0.02527396f, 
    -0.02675461f, 0.14220525f, -0.37572724f, -0.04695334f, 0.00808304f, 0.24285480f, 0.10171392f, 0.09218667f, 
    0.09671335f, -0.03975441f, 0.07781278f, 0.14525576f, -0.08459270f, -0.10730360f, -0.13620445f, -0.02094598f, 
    0.11786964f, -0.22332364f, -0.08827546f, 0.18455452f, 0.08307957f, 0.21862037f, -0.31967825f, -0.21059993f, 
    -0.04163482f, -0.03074172f, -0.11670922f, -0.30600184f, -0.32162637f, 0.10090246f, 0.24071094f, -0.37237737f, 
    -0.05440225f, -0.05946823f, -0.06220401f, -0.00109193f, 0.08839089f, 0.26842448f, 0.10640801f, -0.10047539f, 
    0.17306176f, 0.12990168f, 0.16271777f, 0.06240222f, -0.36048084f, 0.23504668f, -0.00589643f, -0.04474214f, 
    0.26481259f, -0.39391822f, -0.06656121f, 0.04444806f, -0.07091115f, 0.19576320f, 0.32955164f, 0.10212973f, 
    -0.08943257f, -0.01730893f, -0.18245853f, -0.36222208f, -0.11448350f, 0.03282229f, -0.05373220f, 0.08399560f, 
    -0.03516242f, -0.18440199f, -0.24024181f, 0.05771503f, 0.11724990f, -0.12675267f, 0.17715150f, 0.05843075f, 
    -0.00598933f, 0.07643453f, -0.21773459f, -0.08968431f, 0.07553852f, 0.02388264f, -0.11300027f, 0.06160615f, 
    0.11450680f, 0.07476256f, 0.06732127f, 0.04535881f, 0.01480192f, -0.14311792f, -0.27733094f, 0.07327303f, 
    -0.08422077f, 0.03000563f, -0.06362420f, -0.00261888f, 0.29912677f, -0.08080072f, -0.40046430f, 0.04374317f, 
    0.11550428f, -0.04471042f, -0.09417444f, -0.05910029f, 0.03161504f, 0.31402990f, 0.03551039f, -0.02946397f, 
    0.10248037f, 0.23198013f, -0.15859330f, -0.03495761f, 0.23953114f, 0.07274450f, -0.11152268f, -0.07595883f, 
    0.11122813f, -0.06453100f, 0.02263163f, -0.09644538f, -0.20206349f, 0.10955773f, -0.05239798f, 0.04695281f, 
    0.24829376f, 0.11069595f, -0.00351541f, -0.48927417f, 0.00301268f, -0.07646009f, -0.01772373f, 0.00755356f, 
    -0.11709945f, -0.15953308f, 0.25668955f, -0.11248479f, -0.08385465f, 0.20661649f, -0.31856439f, -0.06694572f, 
    0.01202688f, -0.29999945f, 0.09063520f, -0.19209258f, -0.03377154f, -0.00890837f, 0.28759369f, -0.05512575f, 
    -0.05488144f, 0.08773520f, -0.08130199f, -0.27242276f, -0.08242913f, 0.05404042f, 0.04133729f, 0.09860069f, 
    -0.06706236f, 0.05627648f, 0.09841636f, 0.01962339f, -0.04921716f, -0.12090366f, 0.18383636f, 0.38385561f, 
    -0.07741240f, -0.49444446f, -0.12530513f, 0.05750372f, -0.11375168f, -0.19206122f, 0.08156686f, 0.10528293f, 
    -0.19190383f, -0.42535430f, -0.01974647f, 0.07560838f, -0.08523164f, 0.14082487f, -0.02021555f, 0.10063414f, 
    0.08056293f, -0.22858579f, 0.00804089f, 0.10614742f, -0.25566679f, 0.19842738f, -0.24880950f, -0.00962552f, 
    0.14128439f, -0.06199610f, 0.18192245f, 0.11386316f, 0.21055467f, 0.10971981f, 0.03627901f, -0.10550287f, 
    -0.13435999f, -0.34533203f, -0.02890850f, 0.10488118f, 0.07241067f, -0.13999662f, 0.18053208f, 0.07089070f, 
    0.09113901f, -0.00283026f, -0.19026411f, 0.27989265f, 0.05403470f, 0.09122836f, 0.15511507f, -0.13274868f, 
    0.02950802f, 0.30494010f, 0.09578670f, -0.23463561f, 0.04045144f, 0.15915374f, -0.44234899f, 0.14745642f, 
    -0.02709222f, 0.08111028f, 0.02438640f, -0.11490475f, -0.05833696f, -0.08830059f, 0.05541160f, 0.00050755f, 
    0.04197302f, 0.31633615f, 0.04554748f, 0.04519112f, 0.07301584f, -0.64941669f, -0.03447570f, 0.07726013f, 
    -0.01478409f, -0.39707336f, 0.14147641f, 0.09761557f, 0.24194984f, 0.23984703f, 0.03985173f, 0.09806179f, 
    0.16693792f, 0.03502710f, -0.06140580f, 0.10518970f, 0.27966386f, 0.20583935f, 0.13215859f, -0.04319479f, 
    -0.19970240f, -0.09902984f, -0.39625737f, 0.23873515f, -0.26003864f, -0.09152902f, 0.03364053f, -0.01072195f, 
    -0.01761207f, -0.38863939f, -0.04724763f, -0.10422663f, 0.08411082f, 0.14760940f, -0.39783710f, 0.06223908f, 
    0.03631308f, 0.11437959f, 0.21567596f, -0.37743342f, -0.06132346f, -0.12932667f, -0.35567132f, -0.10215016f, 
    0.01218042f, 0.34050307f, -0.06797695f, -0.34421214f, -0.01933853f, -0.03518701f, 0.10281634f, -0.28219283f, 
    -0.07858717f, 0.02895455f, -0.12876576f, -0.17686972f, -0.03387433f, 0.09163067f, -0.08362896f, -0.30552748f, 
    0.06396369f, 0.00253257f, 0.11107221f, -0.02499417f, 0.09894233f, -0.02524121f, 0.12673154f, 0.01669761f, 
    0.28431228f, 0.21955565f, -0.38194877f, -0.02818789f, -0.00258872f, 0.15489984f, 0.04738991f, -0.05113285f, 
    -0.04947963f, 0.20517649f, -0.05027626f, -0.01580177f, -0.02184158f, 0.18809523f, -0.32637104f, -0.04226140f, 
    0.04410841f, 0.04900883f, -0.35330254f, 0.25760165f, -0.34092844f, 0.12502891f, 0.02841885f, -0.12617186f, 
    0.04497752f, 0.16261393f, 0.22862098f, -0.08598244f, -0.09427959f, -0.26259762f, -0.14566074f, -0.11768106f, 
    -0.10430666f, -0.51502788f, 0.19094458f, -0.45417351f, 0.03637624f, 0.00673989f, 0.20108253f, -0.11488015f, 
    -0.04299220f, -0.23075172f, 0.00993912f, -0.05394657f, 0.03764013f, -0.31448612f, 0.07653074f, -0.09448902f, 
    -0.02653048f, -0.11353800f, 0.02342952f, -0.54067129f, 0.31830263f, 0.03747023f, -0.22261602f, -0.02733428f, 
    0.11563720f, 0.36893016f, -0.03373631f, -0.10258477f, 0.12178787f, -0.15123850f, 0.08721352f, -0.07932924f, 
    0.02291350f, -0.05589663f, -0.09863846f, 0.12207991f, 0.36582103f, -0.36262771f, -0.01219176f, 0.01522802f, 
    -0.05754090f, -0.45807061f, 0.03791493f, -0.06825707f, -0.11579555f, 0.20881176f, -0.20557128f, -0.10379065f, 
    -0.06607462f, 0.09114146f, -0.13906980f, 0.06032183f, -0.63398987f, 0.03448051f, -0.08811303f, -0.11738996f, 
    0.04198975f, 0.07420170f, -0.07027022f, 0.11125144f, -0.02036617f, -0.30889863f, 0.12613843f, 0.01974070f, 
    0.09050518f, 0.27844453f, 0.14435297f, 0.27864638f, 0.07962810f, -0.07975284f, 0.01247149f, 0.03878304f, 
    -0.07244953f, -0.12067666f, -0.08345595f, -0.21609302f, -0.02857413f, 0.18023816f, 0.30850369f, 0.18085225f, 
    0.07951041f, 0.12190415f, -0.05505777f, 0.37827349f, 0.15082133f, -0.02489820f, -0.59289610f, -0.17099035f, 
    0.05645544f, -0.12750669f, 0.07424134f, 0.04657730f, 0.09892248f, -0.13811445f, 0.03343171f, -0.00739162f, 
    0.06933071f, 0.04859912f, 0.17296822f, -0.00930483f, -0.50384897f, -0.55320305f, -0.01473367f, 0.02313841f, 
    -0.23922224f, 0.12194991f, 0.09328046f, 0.02715754f, 0.23534721f, -0.15837170f, -0.17188810f, -0.04104907f, 
    -0.61686599f, -0.01151209f, 0.29685685f, 0.15419187f, 0.33111137f, -0.01082024f, 0.00449748f, 0.01771838f, 
    -0.01353349f, -0.18763165f, 0.31297675f, 0.05874146f, 0.09766244f, -0.20591226f, 0.00753665f, -0.04649825f, 
    -0.05803054f, -0.08968461f, 0.25813973f, 0.11013377f, -0.07206318f, 0.01316155f, -0.37688822f, 0.04343991f, 
    0.08836105f, 0.20422566f, 0.08066595f, -0.06128894f, 0.07462677f, 0.13831088f, 0.12283509f, -0.60548317f, 
    0.09017551f, -0.08010031f, -0.01557057f, 0.06428980f, -0.03501856f, -0.05083614f, 0.12528265f, 0.26982239f, 
    0.08033673f, -0.12782550f, 0.01067054f, 0.07059334f, 0.11307177f, 0.22008257f, 0.00425793f, -0.09845256f, 
    -0.18203130f, -0.09257819f, -0.33872232f, 0.01520432f, 0.00520922f, 0.21021275f, -0.09592162f, -0.12382389f, 
    -0.47062436f, 0.25786695f, 0.07278930f, -0.00717244f, 0.32981068f, -0.09889946f, 0.01236599f, -0.04224712f, 
    -0.17459129f, 0.11244361f, 0.21277328f, -0.09719808f, 0.28566954f, 0.07950210f, 0.04447225f, 0.11255892f, 
    0.10053423f, 0.21183436f, -0.24942161f, -0.03899219f, 0.06979620f, 0.19455169f, -0.12604484f, -0.02722772f, 
    0.02634760f, -0.09202424f, -0.51036823f, 0.09550242f, 0.06038417f, 0.05312616f, 0.31032345f, 0.03221054f, 
    -0.04190540f, -0.02945738f, 0.00000269f, -0.14496975f, -0.06264964f, 0.23534240f, 0.18869662f, 0.21737260f, 
    -0.02435125f, 0.07971215f, 0.10815469f, -0.33549455f, 0.29576594f, 0.02837455f, -0.23555888f, -0.39143005f, 
    0.06419674f, -0.24583466f, 0.07842654f, 0.02261178f, -0.01380364f, -0.01337117f, 0.11085313f, -0.07038456f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09268364f, -0.00362395f, -0.06387176f, -0.04823543f, 0.11232523f, 0.06072083f, -0.00897823f, 0.04181945f, 
    0.07053364f, 0.02799099f, 0.12441136f, 0.01590000f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
