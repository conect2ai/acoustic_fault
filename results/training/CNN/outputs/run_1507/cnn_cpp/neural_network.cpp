#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.19892666f, -0.01279024f, -0.56120098f, -0.15791789f, 0.42344189f, -0.44255111f, 0.14208268f, 0.20149545f, 
    -0.08074807f, 0.22455624f, 0.10555618f, -0.18291630f, -0.20791452f, -0.05854748f, -0.12951374f, 0.17141010f, 
    -0.01553315f, -0.09265307f, 0.00727730f, 0.21298414f, -0.29922792f, 0.17011987f, 0.13413440f, -0.04981597f, 
    0.04464324f, -0.59157711f, 0.68332964f, -0.49719182f, 0.55778730f, -0.06737889f, 0.15922104f, -0.36716244f, 
    -0.34155521f, 0.28103158f, 0.32481819f, -0.31385437f, -0.02352998f, -0.12552063f, -0.02223547f, -0.23906218f, 
    0.01773778f, 0.14631806f, 0.12554437f, 0.13724291f, -0.01228364f, -0.18959160f, -0.09677620f, -0.02467239f, 
    -0.19152793f, 0.14036626f, -0.31786236f, -0.38168955f, 0.03197202f, -0.03652668f, 0.29559156f, -0.36606222f, 
    0.01678986f, -0.29410627f, 0.04442209f, -0.22697134f, 0.26764768f, -0.25074640f, -0.18099479f, 0.16215397f, 
    -0.05853911f, 0.01141476f, -0.31553119f, 0.05687108f, -0.26549947f, -0.08045093f, -0.12758243f, -0.21081108f, 
    0.09838735f, 0.21667898f, -0.14280766f, 0.10025837f, 0.00854875f, 0.04797443f, -0.37562558f, 0.33913985f, 
    0.09133206f, -0.03366148f, -0.29005235f, -0.31316119f, 0.24547645f, 0.08944231f, -0.07186035f, -0.16949232f, 
    -0.15227459f, 0.34853503f, -0.03218298f, 0.40407875f, -0.35221794f, 0.20932014f, -0.41181836f, -0.14415500f, 
    0.10772434f, 0.16105901f, 0.29673848f, 0.31673646f, 0.12509535f, 0.78074741f, 0.53506416f, -0.51852071f, 
    0.08145932f, 0.30878258f, -0.60271740f, -0.47133180f, -0.14301197f, -0.64803332f, -0.04723306f, 0.23112483f, 
    -0.14365882f, -0.02936831f, 0.43746036f, 0.10675806f, -0.31200016f, -0.19878140f, 0.10412695f, 0.22212338f, 
    0.01380825f, 0.25113302f, 0.04515529f, -0.04336691f, 0.04250225f, -0.68445885f, -0.55981261f, 0.34228140f, 
    0.49348116f, 0.26941228f, -0.31091440f, -0.35661602f, 0.60492265f, 0.00127185f, 0.14624491f, -0.09041449f, 
    0.21823387f, -0.07174294f, 0.28630850f, -0.39103380f, -0.08335947f, 0.21112530f, 0.04214051f, -0.09099033f, 
    0.46946523f, -0.13926487f, -0.28283045f, -0.16482985f, -0.00595513f, 0.04356095f, -0.52874446f, 0.15851176f, 
    0.13238646f, 0.20754305f, 0.03262296f, 0.16314791f, 0.32684544f, -0.11597062f, -0.16607757f, 0.14688490f, 
    0.07433271f, 0.20051454f, 0.16890140f, -0.18185356f, -0.08799431f, -0.16520050f, 0.11761011f, -0.00085486f, 
    0.04004544f, -0.01185132f, 0.31298086f, 0.19741398f, -0.05282703f, 0.10558432f, -0.28391245f, -0.39073291f, 
    0.07954299f, 0.13333935f, 0.10100950f, 0.25762939f, -0.18249086f, 0.08448336f, -0.07868563f, -0.04362904f, 
    -0.20841651f, -0.08880553f, -0.33604074f, -0.22358294f, 0.26309118f, -0.19156763f, 0.09707341f, 0.05377255f, 
    0.06546726f, 0.07072608f, 0.23295288f, 0.17156756f, -0.11789142f, -0.08283637f, 0.03896809f, 0.41685319f, 
    -0.82287633f, 0.39639834f, 0.11518340f, -0.86482996f, -0.11870012f, -0.01474815f, 0.19109373f, 0.18473919f, 
    0.17845961f, -0.14659861f, -0.23675959f, 0.01790252f, -0.12551862f, -0.19418097f, -0.30959722f, 0.17532885f, 
    -0.12752502f, -0.19849131f, -0.25636068f, -0.12946853f, -0.05356111f, 0.30681786f, -0.00678629f, -0.00162984f, 
    -0.24547125f, -0.17186745f, -0.28100693f, -0.37321600f, -0.12136079f, -0.29471508f, 0.42923164f, 0.34985352f, 
    0.00602458f, -0.15935177f, 0.18910708f, -0.16661683f, 0.26180214f, 0.03485385f, -0.04670824f, -0.04508895f, 
    -0.39385912f, -0.10897408f, 0.21992758f, -0.34865630f, -0.18439494f, 0.09178881f, 0.32589620f, -0.03020611f, 
    0.37785032f, 0.40067437f, -0.55028617f, 0.09574074f, 0.54447126f, 0.28066391f, -0.19518915f, -0.13791664f, 
    -0.37335262f, -0.17942005f, -0.44718647f, -0.59905952f, 0.12261597f, -0.02677573f, -0.00050589f, -0.39779937f, 
    -0.14467101f, -0.24345425f, 0.02059266f, 0.15205842f, -0.21596833f, -0.01011582f, -0.00412196f, 0.02289496f, 
    0.15670255f, 0.18166699f, -0.25436589f, 0.34002277f, 0.19296415f, -0.00615921f, 0.01918684f, -0.00442709f, 
    0.39074460f, 0.28089035f, -0.19947793f, 0.04222447f, -0.08303378f, -0.11950466f, 0.02671941f, 0.11499856f, 
    -0.27735257f, -0.17639120f, -0.01411389f, 0.06690884f, -0.14870617f, -0.09341475f, 0.20088817f, -0.02646789f, 
    -0.21508931f, -0.21555193f, -0.04750841f, -0.25349203f, -0.67568952f, -0.34214705f, 0.08368257f, 0.08341587f, 
    -0.39970124f, -0.03879255f, -0.38303527f, -0.05564891f, -0.20055409f, 0.48732698f, -0.09872758f, -0.06337918f, 
    0.13433234f, 0.29370785f, 0.04766187f, -0.03073574f, 0.23229612f, 0.10258224f, 0.13479349f, 0.25573009f, 
    -0.00460606f, -0.05954825f, 0.11476395f, -0.38306823f, -0.17010714f, 0.45618784f, 0.25170499f, 0.35885245f, 
    0.20066904f, 0.07423465f, 0.03129689f, -0.14859013f, 0.10628705f, 0.13906267f, 0.20822029f, 0.06731867f, 
    0.17360936f, -0.04838115f, 0.04076964f, 0.01476604f, 0.07997096f, -0.18315633f, -0.21673921f, 0.20929420f, 
    0.00371605f, -0.25352257f, -0.21564752f, -0.20896021f, -0.08397034f, -0.33396062f, -0.44368303f, -0.44764963f, 
    -0.55601466f, -0.23264137f, -0.31286657f, 0.02736663f, 0.00207079f, 0.01258646f, 0.32054675f, 0.27933869f, 
    0.00551460f, -0.30704752f, -0.40482008f, -0.19779910f, -0.19099273f, -0.05565360f, -0.00531281f, -0.02233649f, 
    0.06779217f, -0.38551500f, -0.07424562f, 0.15261739f, 0.07185640f, 0.06421576f, 0.31600925f, 0.45362386f, 
    0.00112956f, -0.10178209f, -0.36632040f, -0.10561913f, 0.19163640f, -0.03920673f, -0.00098122f, -0.45146430f, 
    0.42805824f, -0.28563619f, -0.28242505f, 0.26118645f, 0.11706728f, 0.22544739f, 0.04584978f, 0.06494893f, 
    0.14412721f, 0.23354650f, -0.39222237f, -0.07867039f, 0.01306042f, -0.23000695f, 0.23707660f, -0.03057155f, 
    -0.32482961f, -0.35888338f, -0.40694293f, -0.05061879f, 0.18842904f, -0.26524305f, -0.15660553f, -0.14845835f, 
    0.14886083f, -0.54426670f, 0.33921406f, -0.25785026f, -0.02040057f, -0.12390899f, 0.11714754f, 0.09287223f, 
    0.07000871f, 0.08516240f, -0.06394041f, -0.15787229f, -0.19686534f, 0.14601308f, 0.37184009f, 0.13801332f, 
    0.17255761f, 0.64451939f, -0.44172126f, -0.00687347f, 0.41085646f, 0.01588594f, -0.07952636f, -0.16959611f, 
    -0.09852145f, 0.03420959f, 0.20659356f, 0.34740558f, 0.02050483f, -0.35248029f, -0.04329120f, -0.02238179f, 
    -0.06171833f, 0.20628729f, 0.01661495f, 0.07537881f, 0.08617153f, -0.08294780f, -0.16043968f, -0.11524939f, 
    0.03860135f, -0.29977241f, -0.08974111f, -0.73700124f, -0.78620714f, -0.39769781f, -0.45659181f, 0.23731954f, 
    0.37137741f, 0.50431651f, 0.21448109f, -0.00675889f, 0.51515245f, 0.18372925f, 0.24276572f, -0.27218351f, 
    -0.02535781f, 0.08125855f, -0.06664363f, 0.04956838f, -0.12053391f, -0.06307214f, -0.16965228f, -0.29407653f, 
    0.20029227f, 0.17129448f, -0.03365524f, 0.34498018f, 0.34244487f, 0.11520410f, 0.25421712f, -0.37815118f, 
    -0.06487576f, 0.28730497f, 0.10582817f, -0.24933943f, 0.17115329f, 0.01455288f, -0.07109151f, 0.08878309f, 
    -0.04273171f, 0.14891927f, 0.18214786f, -0.34545574f, -0.26175410f, -0.11278073f, -0.11788229f, 0.09024170f, 
    0.20585302f, -0.15517712f, -0.03028379f, 0.39592177f, -0.18279755f, -0.33789957f, -0.26915768f, 0.57175028f, 
    0.17807634f, -0.39020801f, -0.48107958f, -0.40256733f, 0.48412421f, 0.29742044f, -0.09023075f, -0.14290251f, 
    -0.06883641f, 0.42715195f, 0.13608924f, -0.29683897f, 0.22029057f, -0.09271570f, -0.36770853f, -0.33116391f, 
    0.15793164f, 0.19771311f, 0.20472366f, 0.06854790f, -0.10554474f, 0.80484837f, 0.72534335f, -0.09871008f, 
    -0.12465046f, -0.09555107f, -0.21431513f, -0.13839051f, 0.05922382f, 0.06759906f, 0.10754276f, -0.04326194f, 
    -0.13194345f, 0.32285640f, -0.21500146f, -0.26864165f, -0.06664249f, 0.13177752f, -0.01274317f, -0.07033840f, 
    0.09080153f, -0.11057872f, -0.01225045f, 0.09623227f, 0.25882533f, -0.10380681f, -0.42006150f, -0.01798866f, 
    -0.14517255f, -0.26940593f, 0.30292234f, 0.09352162f, 0.26369905f, 0.11010993f, 0.22391959f, -0.03667105f, 
    0.07410203f, 0.13034421f, 0.03771795f, -0.10808625f, -0.13202067f, 0.05980274f, 0.25411293f, 0.08204708f, 
    0.21951026f, -0.16500913f, -0.13711010f, -0.06216251f, -0.17330769f, -0.33473083f, 0.18127812f, -0.62681985f, 
    -0.45973003f, -0.29884481f, 0.32825977f, 0.28822458f, 0.43258893f, 0.33274537f, -0.25833523f, 0.23392311f, 
    0.13939157f, -0.03915358f, 0.00203400f, -0.38768509f, -0.17282099f, -0.35566592f, 0.26956463f, 0.31109151f, 
    -0.16068925f, -0.15220542f, -0.10237686f, -0.27969319f, 0.16621588f, -0.28405452f, -0.21348499f, -0.25225621f, 
    -0.08537929f, 0.53797495f, 0.05960006f, -0.13052179f, 0.01211017f, -0.16588089f, -0.22226004f, 0.36761022f, 
    -0.16661680f, 0.21420637f, -0.30466735f, -0.05100781f, 0.41184106f, -0.05864725f, -0.25612664f, 0.18706848f, 
    0.15382917f, -0.14384460f, -0.24811071f, 0.17258832f, 0.13058962f, 0.27213272f, 0.14764822f, -0.19816369f, 
    -0.35772365f, -0.26730567f, 0.14837709f, 0.43691719f, -0.41418251f, -0.44786960f, 0.24631955f, 0.06317884f, 
    -0.08522987f, 0.09545680f, -0.04082750f, -0.32568550f, -0.01832054f, -0.07209255f, 0.07094730f, 0.25328025f, 
    0.32010791f, -0.12508053f, -0.44465294f, -0.31807888f, 0.02031771f, -0.17628926f, -0.11943591f, 0.45282510f, 
    0.21206802f, -0.01802339f, -0.68554175f, 0.12600398f, 0.06617283f, -0.79318941f, -0.52489996f, 0.47087169f, 
    0.02803640f, -0.12988169f, 0.26405933f, 0.38740733f, 0.09415630f, 0.00923390f, -0.17056373f, -0.17154549f, 
    0.23376991f, 0.03597372f, 0.30781069f, -0.06261232f, -0.10388166f, -0.17059869f, 0.07088240f, -0.24903940f, 
    -0.23180963f, -0.17173374f, -0.11851811f, -0.54696620f, -0.65015250f, -0.31743389f, -0.44940037f, -0.48634940f, 
    0.29466981f, 0.22240180f, 0.39288291f, 0.26352179f, 0.27259731f, 0.28060168f, 0.11421154f, -0.05680514f, 
    0.27381343f, 0.22044395f, -0.00744246f, -0.15894552f, -0.20958105f, 0.04089074f, 0.25066131f, -0.06633530f, 
    -0.20924267f, 0.15239765f, 0.14922455f, -0.38329443f, -0.70046830f, 0.23506509f, -0.47213385f, 0.45916668f, 
    -0.19311956f, 0.06903341f, 0.25938630f, -0.17294070f, -0.15900169f, 0.69883448f, 0.02719321f, 0.30701765f, 
    -0.11560020f, 0.15051457f, 0.05453128f, -0.32091394f, -0.05225268f, 0.11035850f, -0.12013850f, 0.08818488f, 
    -0.00601382f, 0.15771461f, 0.12404341f, -0.18287145f, 0.13546324f, -0.40690017f, -0.36887890f, -0.54651284f, 
    -0.50064665f, -0.32017937f, 0.45368001f, 0.17980337f, -0.03894296f, -0.18022037f, 0.00653712f, -0.30119312f, 
    -0.31306615f, -0.24057344f, -0.03123054f, -0.13866368f, 0.11868893f, 0.17126641f, -0.10471893f, -0.15813223f, 
    0.04704194f, 0.05369248f, -0.15649140f, -0.07743998f, 0.06625276f, -0.23801234f, 0.09243402f, 0.39996791f, 
    0.09532221f, -0.34071505f, 0.35439390f, -0.57375115f, -0.51174343f, 0.54423589f, 0.42930457f, 0.28813791f, 
    0.04788925f, -0.02128214f, 0.32156846f, 0.17086437f, -0.06838477f, 0.11334185f, -0.27177441f, 0.18576349f, 
    -0.19521765f, -0.34305751f, 0.05180262f, -0.29729661f, 0.08050045f, 0.08366079f, 0.12830338f, -0.41820014f, 
    -0.28248963f, -0.29229689f, -0.24320598f, 0.27475157f, -0.29737502f, -0.48809290f, -0.29446322f, -0.24277702f, 
    0.02803732f, 0.21431023f, -0.30638528f, -0.04856287f, 0.30139315f, -0.28326243f, 0.20455351f, -0.07053392f, 
    0.04184909f, 0.11216567f, -0.10986897f, -0.09200837f, 0.07945861f, 0.32476458f, 0.05695186f, 0.41487405f, 
    -0.52693570f, -0.47323072f, -0.36577934f, 0.00885271f, 0.36479339f, 0.22602963f, -0.54590678f, -0.08978112f, 
    -0.27978775f, -0.32282436f, -0.15367524f, 0.20508602f, 0.19766511f, 0.48943028f, -0.36963487f, 0.29672512f, 
    -0.36209738f, -0.28798836f, 0.03346247f, 0.37403983f, 0.08049197f, 0.02088447f, 0.17460391f, -0.23489662f, 
    -0.29300091f, -0.10065976f, 0.53428644f, 0.57199752f, -0.42568043f, -0.45109469f, -0.16868591f, -0.32563469f, 
    -0.04971336f, 0.20286930f, 0.20788626f, -0.04276061f, -0.32976192f, 0.03778017f, 0.25256795f, -0.13163522f, 
    -0.09713394f, 0.01902374f, 0.17405605f, -0.08073088f, -0.17547406f, -0.02147418f, -0.17395240f, -0.20849524f, 
    -0.43181512f, -0.50818181f, 0.74232960f, 0.97894138f, 0.22089346f, -0.57475078f, -0.21111834f, -0.25434458f, 
    -0.12186537f, 0.03795558f, -0.14137900f, -0.46621433f, -0.21840638f, 0.00222613f, -0.13764882f, 0.18011925f, 
    0.05673677f, 0.20351049f, -0.13902941f, 0.20204097f, 0.20750989f, -0.41700548f, 0.08229364f, 0.09764108f, 
    -0.09915432f, 0.26187614f, -0.18683474f, -0.82925928f, 0.41076869f, 0.04947628f, -0.56297940f, -0.20970850f, 
    0.26624259f, 0.78749484f, -0.23577018f, -0.12154075f, -0.21378224f, -0.02209318f, -0.14819074f, -0.23784579f, 
    -0.39773414f, 0.33478120f, -0.13123512f, -0.03217255f, 0.01787078f, 0.10662644f, -0.05171754f, 0.04567695f, 
    -0.14116797f, 0.04666820f, -0.20673448f, -0.38777614f, 0.04149224f, -0.36517534f, -0.45740399f, 0.11295009f, 
    0.52789778f, -0.54022205f, -0.28206286f, -0.18682377f, -0.26599404f, -0.43201220f, -0.04231442f, 0.02212392f, 
    0.42152429f, 0.44863060f, -0.29969177f, -0.01132016f, 0.04438658f, -0.02741188f, 0.05117401f, -0.05452580f, 
    -0.16877708f, 0.04422761f, 0.04950842f, -0.12262478f, -0.06976186f, -0.82112294f, -0.63232285f, -0.47383660f, 
    -0.34152180f, -0.22881255f, 0.48640370f, 0.45397863f, 0.22121386f, 0.18065602f, 0.45514229f, 0.08859929f, 
    -0.01307702f, -0.04604992f, -0.31779730f, 0.11731839f, 0.00732476f, 0.01026984f, -0.11777885f, 0.34092271f, 
    -0.04097370f, -0.03068899f, 0.14046493f, -0.00719293f, -0.20396288f, 0.05750022f, 0.16572058f, 0.04870280f, 
    -0.42260656f, -0.31459239f, 0.35249388f, -0.29829040f, -0.54672587f, -0.74661142f, -0.58478642f, -0.28339961f, 
    0.14035870f, -0.14012121f, 0.29444742f, 0.57082075f, 0.11897306f, 0.00623334f, -0.17932588f, 0.11455388f, 
    -0.13824756f, -0.23423196f, -0.43784830f, -0.02784702f, 0.09240791f, 0.12221247f, 0.03917213f, 0.08817919f, 
    0.02515680f, -0.05727551f, 0.16097927f, 0.48700693f, -0.11768340f, -0.21321748f, -0.03185903f, 0.31548566f, 
    0.31005934f, -0.12777641f, -0.07409756f, -0.30607650f, 0.37207288f, -0.15836138f, 0.41484931f, 0.06948820f, 
    -0.11679611f, -0.17892887f, -0.42255253f, -0.52335775f, 0.31677228f, 0.02827452f, -0.18074863f, -0.25055400f, 
    -0.59510386f, 0.10119557f, 0.46946687f, -0.39295536f, -0.29789847f, 0.20557654f, -0.15509571f, 0.30321705f, 
    0.35268509f, -0.14065973f, -0.41150153f, 0.06228245f, 0.19739750f, 0.54846030f, -0.29531050f, 0.31726637f, 
    0.33937106f, -0.14416003f, -0.27767876f, -0.22820821f, -0.13492884f, 0.16290610f, 0.27010834f, -0.29083967f, 
    -0.17445762f, 0.39235914f, 0.48419493f, 0.28707153f, 0.08173437f, 0.25687966f, 0.05590833f, 0.10176056f, 
    0.06413910f, -0.17551711f, -0.16609389f, 0.12919171f, 0.17302327f, 0.10747804f, -0.24199381f, -0.34356114f, 
    -0.27540839f, -0.03027262f, 0.03723797f, 0.17664690f, 0.15616894f, 0.14405085f, 0.20859155f, -0.00856008f, 
    -0.19187684f, -0.16026850f, -0.14445858f, 0.41223100f, 0.17282368f, 0.03135055f, -0.27216268f, -0.34384349f, 
    -0.36504290f, -0.07366782f, 0.36749247f, 0.36190802f, 0.07810528f, 0.25975707f, 0.21828727f, -0.34928542f, 
    -0.31006399f, 0.01043403f, -0.11099491f, 0.02478516f, 0.22698611f, -0.05659896f, 0.11096735f, -0.13614765f, 
    0.11560486f, 0.04346834f, -0.00865160f, -0.35399222f, -0.10972484f, -0.00243232f, -0.47465277f, -0.30854785f, 
    -0.07473404f, 0.14898193f, 0.05860575f, -0.04325116f, -0.31068262f, 0.20458885f, 0.47557011f, 0.03904180f, 
    -0.10135038f, 0.16177626f, -0.36348429f, -0.23421659f, -0.19762763f, -0.08998924f, -0.36167303f, 0.08711337f, 
    0.34213829f, -0.23689887f, 0.21345581f, 0.19659108f, -0.06389096f, -0.14142093f, 0.09511338f, 0.03137647f, 
    0.30925599f, -0.32364777f, -0.29228926f, 0.21242343f, -0.28794265f, 0.54836160f, -0.07968964f, -0.08182120f, 
    0.11268318f, -0.15876766f, 0.13285697f, -0.06324787f, 0.28000945f, -0.15135033f, 0.09540446f, -0.00443759f, 
    0.32522264f, -0.28437117f, 0.16552398f, 0.18783167f, -0.17092325f, -0.28616253f, 0.19354224f, 0.34540939f, 
    0.12420873f, 0.01502187f, -0.07237654f, -0.20638622f, 0.05796525f, 0.32202220f, 0.24387403f, 0.20639090f, 
    0.08011019f, -0.19049056f, -0.42646357f, -0.30095896f, 0.07275211f, -0.04098854f, 0.21718049f, 0.05152508f, 
    0.07250647f, 0.12773553f, -0.32783893f, -0.19713798f, 0.08079016f, -0.37404820f, 0.29255721f, -0.46391317f, 
    -0.12559514f, 0.02444638f, 0.37838143f, -0.43148413f, -0.22698900f, 0.24320246f, 0.10410718f, 0.29949978f, 
    -0.43819892f, -0.23873080f, 0.12788318f, -0.28942567f, 0.48097157f, -0.07549007f, 0.02989329f, -0.10683732f, 
    -0.03521046f, -0.44744885f, -0.22774066f, 0.05499724f, -0.36373514f, -0.42320555f, -0.29628170f, -0.48855150f, 
    -0.06853116f, -0.25440851f, -0.41934779f, -0.18720512f, -0.08391517f, -0.18611130f, 0.16558893f, -0.19221461f, 
    0.30008948f, -0.22302330f, -0.16506705f, -0.03129486f, -0.12299122f, -0.01189172f, 0.05872688f, 0.02786617f, 
    -0.00350494f, -0.09401122f, 0.22154260f, 0.16480151f, -0.28836265f, -0.19466755f, 0.01789331f, -0.23966175f, 
    0.21460134f, 0.14811708f, -0.11227242f, 0.01446125f, 0.03794497f, -0.04954097f, 0.27605346f, 0.10126642f, 
    0.12887996f, -0.24324840f, -0.15304650f, 0.09934629f, -0.01024255f, -0.16918963f, -0.13833889f, 0.12992214f, 
    0.26325080f, 0.18057065f, -0.33528465f, -0.35447630f, -0.03141788f, -0.04093260f, 0.25040880f, 0.26933146f, 
    0.04569675f, -0.36780328f, -0.24775867f, 0.16359061f, 0.49291751f, -0.02871498f, -0.11323372f, 0.56262279f, 
    -0.02597951f, -0.35475004f, -0.51916158f, -0.23014584f, 0.05923131f, -0.14049007f, 0.33520538f, -0.18993892f, 
    -0.23547882f, 0.11466590f, 0.21040528f, -0.00535519f, 0.13289225f, -0.14600536f, -0.05701888f, 0.12716697f, 
    0.16416101f, 0.25742194f, -0.39256570f, -0.07524849f, 0.40966916f, -0.46311519f, -0.49731234f, 0.36605743f, 
    0.18402158f, -0.07882317f, 0.15477601f, 0.40641725f, 0.02337959f, -0.18360743f, 0.22882897f, -0.15706478f, 
    0.13054866f, -0.24232805f, -0.16018225f, 0.15599938f, -0.08355706f, -0.42247921f, -0.11894989f, 0.33392462f, 
    0.36207506f, 0.25860772f, 0.10684537f, 0.49894124f, 0.41893652f, 0.29579881f, 0.40647569f, 0.09154637f, 
    -0.52597040f, -0.42461804f, 0.12388094f, 0.31048161f, 0.06185138f, 0.21734478f, 0.20763582f, 0.07627620f, 
    0.13836358f, -0.15039510f, 0.01123805f, 0.16070361f, -0.11634410f, -0.09502812f, -0.22851330f, -0.10694592f, 
    -0.02634293f, -0.05631160f, -0.04223147f, -0.01916355f, -0.39973539f, -0.58459669f, -0.35238808f, 0.35522574f, 
    0.65446877f, -0.75315940f, -0.31298777f, -0.43068701f, -0.03219229f, 0.46363580f, -0.03426073f, -0.07162441f, 
    0.20974317f, 0.18589583f, -0.06866881f, 0.02565018f, 0.10586779f, -0.00838771f, -0.13648342f, -0.11812960f, 
    0.19043012f, -0.15430021f, 0.14831531f, -0.11837813f, 0.02572143f, -0.53297240f, -0.41135240f, -0.10846108f, 
    -0.18522711f, 0.17105603f, -0.02674144f, -0.01262733f, -0.48269635f, 0.00485802f, 0.24084920f, -0.14016549f, 
    -0.30519637f, -0.26199421f, -0.22572748f, -0.19373767f, -0.04774798f, -0.16869698f, -0.27466810f, -0.24800302f, 
    -0.36201465f, -0.20292674f, -0.26370314f, -0.15689427f, -0.01834609f, -0.02034652f, -0.08941782f, -0.62833363f, 
    0.37153837f, 0.52177775f, 0.08691092f, -0.23127249f, -0.09197659f, -0.34267858f, -0.25400260f, -0.09174873f, 
    -0.03732683f, 0.15261103f, -0.34316069f, 0.10286669f, 0.08009954f, 0.17427471f, 0.30366510f, -0.15345357f, 
    0.16278684f, -0.17774719f, 0.07154642f, -0.29738945f, -0.37151846f, -0.26865554f, 0.34790865f, 0.16049735f, 
    -0.64714301f, -0.24557628f, 0.03207726f, 0.64042467f, -0.47098559f, 0.38956764f, 0.18983427f, 0.31218490f, 
    -0.24220203f, -0.03444118f, -0.09964700f, 0.11720185f, -0.09748907f, 0.28463960f, 0.06374285f, -0.28404531f, 
    0.11412467f, -0.14174671f, 0.21020734f, -0.00097831f, -0.18308978f, -0.13239095f, 0.30030000f, -0.04723991f, 
    -0.69772708f, -0.45741668f, -0.23487128f, 0.36187905f, 0.53459978f, 0.61301130f, 0.31235150f, 0.50673443f, 
    0.43546796f, 0.21465594f, 0.29664180f, 0.13301748f, 0.11822675f, -0.06178168f, -0.14808328f, -0.24769835f, 
    -0.15314859f, 0.25293466f, -0.31871304f, -0.27947721f, -0.11927247f, -0.02980570f, 0.19032827f, 0.15527403f, 
    -0.01353940f, 0.02253509f, -0.32959571f, -0.01446062f, 0.25916603f, -0.16149700f, -0.07624222f, -0.32682669f, 
    -0.44488373f, -0.37982559f, -0.06675678f, 0.16841309f, -0.22254844f, -0.21119954f, -0.01721978f, 0.07976542f, 
    0.03150997f, 0.19479261f, 0.31349230f, 0.23909360f, -0.15981592f, -0.39363673f, -0.13285032f, -0.24190779f, 
    -0.26354814f, -0.44483855f, 0.01489034f, -0.29470113f, -0.10125454f, -0.31606233f, -0.35217318f, -0.44230071f, 
    -0.31692910f, -0.14535600f, -0.23372050f, 0.11162660f, 0.08583803f, 0.09659640f, 0.09080797f, -0.13588905f, 
    0.26949024f, -0.21778181f, -0.12092226f, -0.11707714f, -0.13499363f, -0.30806449f, -0.02331528f, -0.16992979f, 
    -0.28928745f, -0.26320949f, -0.03568844f, -0.74748653f, -0.53786147f, -0.58931857f, 0.40648085f, 0.58561498f, 
    0.04544620f, 0.04524102f, -0.65102869f, 0.35730758f, -0.51151854f, 0.53395766f, 0.13713455f, 0.17781052f, 
    -0.15986700f, 0.14599921f, 0.16014796f, -0.09191937f, 0.05355162f, -0.00369300f, 0.31542689f, 0.21965997f, 
    -0.30791220f, 0.14357631f, 0.03909750f, -0.14339773f, 0.39522639f, 0.36030760f, -0.10044532f, -0.25803530f, 
    0.07140362f, -0.14245275f, -0.10660581f, -0.03970566f, 0.03729977f, 0.02685482f, 0.29329440f, -0.17611693f, 
    0.07208020f, 0.06770489f, -0.08185055f, -0.02019366f, 0.07139328f, -0.09396800f, 0.22159877f, 0.01888262f, 
    0.16896932f, 0.12869778f, -0.15465984f, 0.02238714f, 0.36787972f, 1.17374980f, -0.42347991f, -0.66416085f, 
    -0.01140112f, 0.54816461f, 0.04623610f, 0.66696030f, 0.02743619f, -0.51146924f, -0.56177360f, -0.18091823f, 
    0.19429852f, 0.14646649f, -0.09460990f, -0.32998240f, -0.11204990f, -0.16802894f, 0.29353800f, -0.09935470f, 
    0.23018192f, -0.00859762f, -0.13168105f, -0.06265187f, 0.25956103f, -0.27627587f, -0.34274417f, -0.31844121f, 
    0.25525668f, 0.21343538f, 0.05649644f, 0.28783771f, -0.09660538f, -0.42792982f, -0.12827688f, -0.18173900f, 
    -0.05670521f, -0.07970146f, 0.00787926f, 0.32746294f, -0.51076424f, -0.08075172f, -0.33483288f, -0.20022920f, 
    -0.02838255f, -0.12939835f, 0.03569000f, -0.17726271f, -0.26745170f, -0.00948365f, -0.30687895f, -0.45990402f, 
    -0.84095669f, -0.04870522f, 0.69710809f, 0.50556982f, 0.14396609f, -0.15635718f, -0.19794534f, 0.10513403f, 
    -0.06782259f, -0.26075637f, 0.03618894f, -0.43988973f, 0.14320664f, -0.05277316f, -0.01473263f, 0.05000038f, 
    -0.18857870f, 0.33167869f, 0.38443318f, -0.23109348f, -0.22355863f, -0.07981606f, -0.24630828f, 0.01212021f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14226693f, 0.14542624f, 0.15783352f, 0.14011936f, -0.02185784f, 0.10866771f, -0.21995091f, 0.15739407f, 
    -0.18614741f, 0.15965006f, 0.19170652f, 0.14997396f, -0.03188160f, -0.24677579f, -0.19945690f, 0.10864495f, 
    -0.14013161f, 0.09219293f, 0.25685212f, 0.10785779f, 0.17902683f, 0.08853766f, -0.18712135f, -0.05264191f, 
    0.21582229f, -0.04562742f, 0.09304746f, 0.01327040f, 0.15183677f, -0.31220347f, 0.08422721f, -0.11263409f, 
    -0.17816909f, 0.15880992f, 0.05946422f, 0.13064058f, -0.07639463f, 0.21068820f, 0.09388039f, -0.01758263f, 
    0.03016938f, -0.20769861f, 0.21955411f, -0.13123709f, 0.14976396f, 0.07364549f, -0.02948594f, -0.19626835f, 
    -0.18350682f, 0.07518939f, 0.06045050f, -0.18798035f, -0.09477048f, -0.20048118f, -0.07218006f, 0.23427984f, 
    0.04236066f, -0.01774041f, -0.13109361f, 0.10029338f, 0.27227145f, 0.15202549f, 0.08263474f, -0.09712887f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04799716f, -0.06069799f, -0.00565038f, -0.15084238f, 0.18538991f, -0.10159233f, 0.06868476f, -0.10517786f, 
    -0.08551940f, -0.00992118f, -0.06322771f, 0.01375159f, 0.04905637f, -0.04950817f, 0.14648719f, -0.18365292f, 
    -0.01878455f, 0.02741904f, -0.17720896f, -0.08795586f, 0.04899799f, -0.06847625f, 0.09967911f, 0.06830691f, 
    0.13492575f, 0.06614030f, 0.03155744f, -0.10819571f, 0.06824613f, -0.01227459f, 0.05226140f, -0.01714363f, 
    -0.01584817f, 0.02207447f, -0.05438156f, -0.06434514f, 0.01751677f, -0.20782402f, 0.04502878f, -0.01798113f, 
    0.11825459f, -0.03216253f, -0.15039837f, -0.07442533f, -0.17922376f, -0.14124304f, -0.13356751f, -0.11903930f, 
    0.08345353f, 0.48523104f, -0.32596928f, -0.07848544f, -0.07233375f, -0.02314183f, -0.13624570f, 0.27600187f, 
    -0.07802849f, -0.09330203f, -0.18641974f, -0.03336876f, 0.07170984f, 0.03443309f, -0.35280246f, 0.17240262f, 
    -0.00972040f, -0.03096856f, 0.10547698f, 0.05310014f, 0.04117347f, 0.03697524f, -0.09378439f, 0.21738823f, 
    0.18427573f, 0.11058313f, -0.08845546f, -0.09262178f, 0.14206961f, 0.00019546f, -0.10658131f, 0.00828425f, 
    -0.02625719f, -0.01937843f, -0.09355225f, 0.05737402f, -0.05741559f, -0.08552447f, -0.12229963f, -0.13485260f, 
    0.03660870f, -0.09356484f, -0.01174263f, 0.03024686f, 0.04950716f, -0.01509792f, -0.06368924f, -0.14771709f, 
    -0.07435670f, 0.23564722f, 0.03216736f, 0.29762068f, 0.11124971f, 0.12966411f, -0.04952113f, 0.08782092f, 
    0.02891580f, -0.13037288f, 0.02959114f, 0.14669259f, 0.22752047f, -0.02286461f, 0.02891152f, -0.10784254f, 
    0.08439495f, 0.16167915f, 0.04446724f, 0.05077542f, 0.01980713f, -0.09205838f, -0.00185459f, 0.03030036f, 
    -0.02808595f, 0.31049511f, -0.05894638f, 0.06561282f, -0.06174016f, -0.05220561f, 0.07300410f, 0.24993977f, 
    -0.03821556f, 0.01092037f, -0.02832272f, -0.07726112f, 0.10884469f, 0.03319231f, -0.06001546f, -0.02455468f, 
    0.03503425f, -0.05423229f, 0.01165515f, 0.09195319f, -0.02781270f, 0.05412044f, 0.03969889f, 0.04035723f, 
    0.22662026f, 0.07507120f, 0.07951000f, 0.16434662f, -0.01855614f, 0.04488074f, -0.03912794f, -0.04653961f, 
    0.11128625f, 0.04185938f, 0.07046648f, 0.07649536f, -0.10300680f, -0.07424828f, 0.12289659f, -0.03498138f, 
    -0.04093813f, -0.07212971f, -0.05695624f, -0.13712505f, 0.05408248f, 0.05468190f, 0.17995296f, 0.15974982f, 
    0.20997004f, 0.29855862f, 0.23582239f, -0.03226701f, 0.10349233f, 0.12904933f, 0.01959015f, 0.05674046f, 
    -0.00575841f, -0.01073456f, 0.03630594f, 0.06684798f, -0.19820522f, -0.30583900f, -0.09110360f, -0.11184926f, 
    -0.15049867f, 0.04873312f, -0.11289512f, -0.18207730f, 0.02374553f, -0.02283804f, -0.03732367f, 0.02325389f, 
    0.15788583f, 0.17645672f, 0.20265365f, -0.12996328f, 0.13484953f, 0.05387287f, 0.14850843f, -0.01538487f, 
    0.06318983f, -0.02931683f, 0.04678945f, -0.01436267f, 0.02464860f, -0.15647230f, 0.12600912f, -0.08103054f, 
    -0.17103633f, -0.14688915f, 0.02042241f, -0.04548556f, 0.15407227f, 0.02781006f, 0.02148131f, 0.29552051f, 
    0.30223772f, -0.06679145f, -0.08879751f, -0.17509928f, 0.11550663f, 0.01293546f, 0.23366712f, -0.06571727f, 
    -0.06582666f, 0.03275571f, 0.05837351f, 0.09895913f, -0.10738078f, -0.01947285f, -0.06014918f, 0.16068906f, 
    0.00454366f, -0.02590632f, -0.17424738f, -0.03514234f, -0.10087673f, -0.01095343f, -0.03592989f, 0.06687643f, 
    0.09188626f, -0.22311714f, 0.34876335f, 0.06746692f, -0.02360629f, -0.02916666f, -0.02432057f, 0.02282344f, 
    -0.01385771f, -0.22170243f, -0.05570660f, -0.12371440f, -0.21757349f, 0.04940971f, -0.02422155f, 0.02354984f, 
    0.06771969f, 0.00139568f, -0.06097617f, -0.06764292f, 0.11804121f, -0.08161610f, 0.02673675f, 0.02121922f, 
    0.11339701f, -0.09368377f, -0.11863063f, 0.16829383f, -0.05421367f, -0.00910417f, -0.01441873f, 0.01860177f, 
    0.09350456f, 0.04067611f, 0.04136888f, 0.05908263f, 0.17444414f, -0.08552797f, 0.03152931f, 0.15847345f, 
    -0.01022117f, 0.00359216f, 0.05425853f, 0.06686632f, 0.17197111f, 0.05018711f, -0.05018321f, 0.14691943f, 
    -0.08633453f, -0.02195844f, -0.22520447f, 0.02339903f, 0.00593604f, 0.00051690f, -0.06974743f, 0.01404465f, 
    0.11345311f, -0.10276246f, -0.02683507f, 0.04001784f, -0.10865899f, 0.22306466f, 0.06862278f, 0.10925594f, 
    0.05021990f, 0.11373149f, -0.00256490f, -0.07352005f, -0.07347423f, -0.06492840f, -0.07893469f, 0.07785255f, 
    -0.02633023f, 0.00530575f, 0.15991782f, 0.01819424f, -0.07469539f, 0.14092650f, -0.02127895f, -0.00412767f, 
    0.07456039f, 0.05550668f, -0.01872774f, 0.21171130f, 0.26969704f, -0.11515655f, -0.15467627f, 0.04863326f, 
    0.08311578f, -0.04313711f, 0.05937573f, -0.03754811f, 0.04283394f, 0.04040590f, 0.08044647f, 0.20041582f, 
    0.35947272f, -0.12911783f, -0.20935120f, -0.25011149f, 0.06489453f, -0.01612061f, -0.22793931f, -0.24678560f, 
    0.13278361f, 0.01877666f, -0.06193734f, -0.06892253f, 0.05952231f, 0.11006979f, 0.32027188f, 0.11157949f, 
    0.07839847f, 0.04499169f, 0.01344106f, 0.10184069f, 0.09521315f, -0.01574344f, 0.02794461f, 0.06390241f, 
    -0.30804709f, -0.17370018f, 0.08557639f, 0.10939097f, -0.04168195f, -0.02737058f, -0.02670191f, -0.21017456f, 
    0.14813185f, 0.00485866f, 0.05441201f, -0.09189130f, 0.14097275f, 0.08441352f, 0.28092921f, 0.09531219f, 
    0.01827637f, 0.01686772f, -0.02993010f, -0.02418897f, 0.04160004f, -0.06734852f, 0.04392010f, -0.09069540f, 
    0.16801006f, -0.05391930f, 0.02580863f, -0.09261441f, -0.02487428f, -0.03654237f, 0.08706962f, 0.16905183f, 
    0.14025706f, 0.04924047f, 0.04304846f, 0.02580097f, -0.19066563f, 0.08249753f, 0.12368023f, -0.02494184f, 
    -0.03581530f, 0.02481638f, -0.05943222f, -0.11131140f, 0.11233968f, 0.04516490f, 0.08318433f, 0.18965665f, 
    -0.46885395f, 0.32491317f, -0.13438740f, 0.27347022f, 0.00264275f, -0.06939802f, -0.05570282f, -0.23032825f, 
    -0.01031742f, 0.02136029f, 0.02839180f, -0.03179145f, 0.00012799f, 0.09526055f, -0.11663516f, -0.01809344f, 
    0.00798375f, 0.04533625f, -0.05644358f, 0.06452107f, 0.10893261f, -0.08815432f, -0.01760030f, 0.21331388f, 
    0.20357057f, 0.07562321f, 0.16874164f, 0.01934965f, -0.04831217f, -0.14001006f, 0.21997200f, 0.02651965f, 
    0.02590090f, -0.02028471f, 0.09712726f, -0.02022467f, 0.28824452f, 0.04149605f, -0.07199699f, 0.03567343f, 
    0.04012174f, 0.12640347f, 0.02503532f, 0.12518528f, 0.15263379f, -0.12250578f, -0.07003882f, 0.00384954f, 
    0.16323470f, 0.15031180f, 0.35192698f, 0.12456857f, -0.02291127f, 0.04016574f, 0.10524963f, 0.10923507f, 
    -0.01564176f, 0.03894217f, 0.02825276f, -0.12871553f, -0.03115213f, -0.21969379f, 0.03456484f, 0.14339936f, 
    0.06331874f, -0.03811258f, -0.03636159f, -0.18401198f, 0.07678790f, 0.00855351f, -0.04072456f, 0.05714065f, 
    -0.10371111f, -0.09757339f, -0.14886086f, 0.21286429f, -0.08109035f, 0.12605709f, -0.05086962f, 0.09293614f, 
    0.10464732f, -0.13585921f, -0.05584990f, -0.00706417f, 0.11629086f, 0.07324305f, -0.03771028f, 0.06483692f, 
    0.11508871f, -0.09034875f, -0.01366307f, 0.11565712f, 0.14727543f, -0.08219073f, 0.02949533f, -0.00877031f, 
    -0.20429488f, 0.03574931f, 0.01320585f, -0.05452707f, 0.10504185f, -0.01329830f, -0.12966533f, 0.01103943f, 
    0.11082008f, -0.10565084f, 0.09468492f, 0.08828460f, 0.03729123f, 0.21074745f, -0.08330801f, 0.16603710f, 
    0.20179759f, 0.15574342f, -0.03160053f, 0.11855805f, 0.10995023f, 0.17691049f, -0.07683685f, 0.08568063f, 
    -0.15641162f, -0.14338696f, -0.17907971f, -0.07812417f, 0.03860559f, -0.08376358f, -0.05383682f, -0.21410096f, 
    0.04308486f, 0.01120126f, -0.10002293f, -0.05882747f, 0.02046946f, -0.04910218f, 0.15196067f, -0.04874943f, 
    -0.07501382f, 0.02107873f, 0.03026301f, 0.04407258f, 0.08988254f, 0.02402398f, 0.18005587f, 0.20329815f, 
    0.01485046f, -0.28506881f, -0.02287240f, 0.25298575f, 0.06376113f, 0.00505410f, -0.03818687f, -0.25973463f, 
    0.07289911f, 0.07925047f, -0.07868279f, 0.01095766f, 0.14904802f, 0.12380528f, 0.08330672f, 0.17641090f, 
    0.16540575f, 0.07825813f, -0.00158020f, -0.06516032f, 0.06186609f, 0.05523784f, -0.06205192f, 0.05061819f, 
    -0.09010877f, 0.01544414f, -0.24377550f, 0.11748219f, 0.18269747f, -0.03679449f, 0.10106116f, -0.10926022f, 
    -0.06586247f, 0.02065149f, 0.01234994f, -0.13631506f, -0.01976594f, -0.12934725f, -0.11591247f, -0.18358970f, 
    0.03851566f, -0.11459370f, 0.03179061f, 0.12461779f, 0.00954464f, -0.08798434f, -0.08816642f, -0.12898301f, 
    0.16856477f, -0.02185310f, -0.15075332f, -0.20473547f, 0.02575934f, 0.26321045f, -0.17993832f, 0.02793428f, 
    0.06910587f, -0.11212030f, -0.02956787f, 0.08488298f, -0.34660619f, -0.23193461f, 0.15529686f, 0.21003766f, 
    -0.02142021f, -0.02279013f, -0.18313733f, -0.06665290f, 0.12688419f, -0.02007223f, 0.11451317f, 0.08709276f, 
    0.26970419f, 0.04210467f, 0.27391145f, -0.07789822f, 0.13160914f, -0.13230513f, 0.00086900f, -0.03764416f, 
    0.02525773f, -0.01726010f, -0.05805025f, -0.04137858f, 0.10943426f, 0.11967297f, 0.08340038f, 0.16610950f, 
    0.13287003f, 0.02891602f, -0.00900642f, 0.01849588f, 0.05438676f, 0.08630254f, -0.11602764f, 0.01021751f, 
    0.10602080f, -0.10020952f, 0.00142482f, -0.11677089f, 0.05894432f, -0.09925127f, -0.13202967f, 0.12467859f, 
    0.06970701f, -0.04530090f, -0.11619928f, 0.08865741f, 0.13260612f, -0.22818966f, -0.06274544f, -0.00985863f, 
    0.04314642f, -0.19074120f, 0.08721080f, -0.13665727f, -0.05413846f, 0.07316415f, 0.01575757f, 0.02565883f, 
    0.32984623f, 0.05939537f, -0.03340106f, -0.14680901f, -0.03554235f, -0.00968101f, 0.09578229f, 0.03592458f, 
    -0.03759540f, 0.05326475f, 0.03738312f, -0.04534592f, 0.18086988f, 0.03878698f, 0.17496225f, -0.03347353f, 
    0.01539388f, 0.00964605f, 0.00549345f, 0.11110586f, 0.10017639f, 0.11508457f, 0.11358859f, 0.19549099f, 
    0.00522660f, 0.06346063f, 0.11280958f, 0.15740077f, 0.05041245f, 0.15254620f, -0.01072003f, -0.01132981f, 
    0.10055973f, 0.14061797f, 0.05076825f, 0.13424005f, 0.40148598f, -0.07214689f, -0.15642503f, -0.14900634f, 
    0.12076942f, -0.02297543f, 0.03888561f, 0.12643749f, 0.09644010f, 0.09503696f, -0.00875465f, 0.12988620f, 
    -0.29725203f, -0.07576449f, -0.01244747f, -0.17013364f, 0.10453480f, -0.01832294f, -0.04598142f, -0.04409690f, 
    -0.02292056f, -0.03663719f, -0.12423337f, -0.11037885f, 0.44079551f, -0.07609463f, -0.03498160f, -0.13760160f, 
    0.03202962f, -0.19293998f, 0.28610924f, -0.04407543f, 0.06418405f, 0.05926566f, -0.02278990f, 0.06869482f, 
    0.06458893f, -0.08534246f, -0.02173106f, 0.00867453f, 0.03286691f, -0.05447939f, 0.02805786f, 0.04777554f, 
    -0.06576432f, 0.02585578f, 0.03864405f, 0.03147537f, 0.07861082f, -0.16701183f, 0.25370249f, 0.00631328f, 
    -0.05295529f, -0.09407935f, 0.00501870f, 0.04577040f, 0.15991111f, 0.07095342f, -0.00764842f, 0.08868544f, 
    -0.13916653f, 0.03541240f, -0.03812703f, -0.12433871f, 0.00094427f, -0.05885971f, 0.04853394f, -0.13306303f, 
    0.00150924f, 0.06166391f, -0.05200940f, 0.01613791f, 0.02032038f, -0.09416223f, -0.03960628f, -0.16744061f, 
    -0.01990180f, -0.01327106f, 0.03862263f, -0.15784861f, -0.05660590f, -0.20704897f, 0.05127714f, 0.14594400f, 
    0.12033362f, 0.10480580f, -0.05197706f, -0.09977452f, 0.04736376f, 0.01818877f, 0.03120304f, -0.03489278f, 
    -0.08257475f, 0.00617320f, -0.03272445f, 0.05817498f, 0.06031061f, -0.06857704f, 0.10633425f, 0.06056890f, 
    0.00832602f, 0.09778375f, -0.11659919f, 0.08264893f, 0.08383124f, 0.02331933f, -0.03694094f, 0.02654293f, 
    -0.14130510f, 0.26984319f, -0.06100523f, 0.07712288f, -0.03759936f, -0.13643658f, -0.10317063f, 0.19899097f, 
    0.02753303f, 0.14407299f, -0.04775489f, 0.02948011f, 0.22311832f, -0.02061137f, -0.09561888f, 0.08747168f, 
    -0.20144990f, -0.02469188f, 0.02238789f, 0.05401491f, -0.11618932f, 0.01012849f, -0.05856982f, -0.04345240f, 
    0.27199954f, 0.05890643f, 0.06542161f, 0.07699453f, 0.05603013f, 0.01968035f, 0.00756681f, 0.05085750f, 
    -0.00076264f, 0.09202211f, 0.02388784f, -0.03245356f, 0.06163956f, -0.00174057f, -0.01870181f, 0.00345724f, 
    0.00189238f, 0.00204190f, -0.07240010f, 0.01819395f, 0.02052795f, 0.08392436f, 0.00529901f, 0.06395292f, 
    -0.31770894f, 0.19212769f, -0.08205771f, 0.26488546f, 0.01996010f, 0.05191026f, 0.07885053f, -0.07189259f, 
    0.01234643f, -0.15043816f, -0.04645671f, 0.00781869f, 0.16016407f, -0.21508889f, 0.08886699f, -0.05810403f, 
    0.00973702f, 0.23904563f, 0.07805300f, -0.03343950f, 0.15992102f, -0.12792018f, 0.10997979f, -0.00715654f, 
    -0.08440161f, 0.25762907f, -0.04445848f, -0.07330799f, 0.02646522f, 0.06094232f, 0.07386921f, 0.12704127f, 
    -0.02632327f, 0.03017679f, 0.02202314f, -0.12384303f, 0.15460691f, 0.09045407f, -0.01485829f, 0.11816505f, 
    0.03672051f, 0.03458746f, 0.02811345f, 0.03073585f, 0.14391571f, -0.00789117f, 0.09617992f, -0.08132300f, 
    0.16745821f, -0.11850289f, 0.04139033f, 0.11238319f, -0.00335840f, -0.01644423f, -0.08466309f, 0.15081817f, 
    0.01363884f, 0.08940813f, 0.03700988f, -0.05287184f, 0.10371399f, 0.09351266f, 0.15504265f, 0.07660329f, 
    0.03699544f, -0.04019792f, -0.02583094f, 0.06542882f, 0.09499677f, 0.09018843f, 0.00453599f, 0.04868530f, 
    -0.20239986f, 0.06123241f, 0.03786002f, -0.04255870f, 0.06955997f, 0.18228468f, -0.08550707f, -0.05998996f, 
    0.03556400f, -0.04115380f, -0.06641839f, 0.19515893f, -0.14112785f, -0.12070198f, 0.05054792f, -0.05242956f, 
    -0.04043148f, 0.16420299f, -0.12543148f, -0.12464557f, -0.04405038f, 0.05809211f, 0.10286433f, 0.01516914f, 
    -0.04149232f, -0.00222428f, -0.08613086f, -0.13527408f, 0.06343916f, 0.11266742f, 0.08803237f, -0.04857932f, 
    0.05858037f, 0.05646448f, -0.00313961f, 0.02715049f, 0.14665946f, 0.06949831f, 0.12593371f, -0.03953053f, 
    0.01531675f, -0.04068167f, -0.00910897f, 0.01112111f, 0.04543348f, 0.07807186f, 0.12367994f, 0.08822845f, 
    0.03150126f, -0.09393143f, -0.04120795f, -0.02670849f, 0.01678433f, 0.05432510f, 0.08933209f, -0.16260295f, 
    0.05404500f, -0.18822241f, -0.00265019f, 0.07906660f, 0.08415623f, 0.10732280f, 0.04018962f, 0.19827880f, 
    0.07287441f, 0.01566863f, -0.00218888f, 0.03937821f, 0.08849517f, 0.03630431f, 0.00580554f, 0.13395919f, 
    0.00394044f, -0.25999808f, 0.24610656f, -0.05709720f, -0.10079955f, 0.15324007f, -0.01123038f, -0.01920270f, 
    -0.03388907f, 0.03338472f, 0.07978165f, 0.00227943f, 0.05652218f, 0.15391004f, -0.01386312f, 0.00178183f, 
    0.07966876f, 0.06665686f, 0.04608744f, -0.01648133f, 0.24091800f, -0.03256974f, 0.03709989f, 0.04959404f, 
    0.06081281f, 0.09271874f, 0.03116377f, 0.04208846f, -0.03068021f, -0.03021427f, -0.00144743f, -0.03023818f, 
    -0.02202438f, -0.04063268f, -0.02377612f, 0.10620103f, 0.14061926f, -0.33773547f, 0.06383308f, -0.21136479f, 
    -0.09569423f, -0.08372895f, 0.03255853f, -0.09673031f, 0.04857197f, 0.00413547f, -0.18737771f, -0.04648809f, 
    0.09425399f, 0.04271509f, -0.10844149f, 0.21009104f, 0.07010109f, -0.06632874f, 0.13761745f, -0.05003108f, 
    0.07158834f, 0.08003013f, -0.01109298f, 0.06254933f, -0.07898637f, 0.15121512f, -0.04855404f, 0.17733182f, 
    0.05865087f, 0.07601304f, -0.06205171f, -0.19465235f, -0.19710337f, 0.04104559f, -0.05056277f, -0.22023177f, 
    -0.18493566f, -0.02376152f, 0.06734251f, 0.02848671f, 0.02425900f, 0.04148163f, -0.02747998f, 0.03380403f, 
    0.14399070f, -0.07889692f, -0.05498469f, 0.02083149f, 0.14333740f, 0.00405289f, -0.08885272f, 0.05968784f, 
    0.05772364f, -0.00476645f, 0.02634786f, 0.05328601f, 0.18561567f, -0.02618095f, -0.07243812f, 0.00580795f, 
    0.32708681f, -0.10129698f, -0.01811815f, -0.01822510f, 0.08661139f, 0.01034263f, 0.02025160f, 0.05215591f, 
    0.00703752f, -0.02177329f, 0.13032204f, -0.02266135f, -0.23638122f, 0.01328280f, 0.23296961f, -0.13461944f, 
    0.02496801f, -0.08674414f, -0.10600699f, 0.00593649f, -0.05336133f, -0.05966552f, -0.02743588f, -0.03226562f, 
    -0.07812736f, 0.04402336f, 0.07693495f, 0.10379298f, 0.00679460f, 0.03741143f, 0.08195123f, -0.01104840f, 
    0.08446480f, -0.13928090f, 0.01067908f, -0.02362543f, -0.10849720f, -0.07854014f, 0.19211264f, -0.06352018f, 
    0.18879731f, 0.21072736f, 0.08359893f, -0.03237067f, 0.03687381f, -0.00617015f, 0.02781291f, 0.00651010f, 
    0.07709969f, -0.09603238f, 0.08224779f, -0.14592190f, 0.15008458f, 0.09489804f, 0.23832344f, 0.08857200f, 
    -0.01440486f, 0.04196128f, -0.01778718f, 0.00633844f, -0.14187773f, 0.04620496f, 0.05038104f, -0.00846963f, 
    -0.01645848f, -0.03127143f, 0.00198549f, 0.00104394f, 0.07204709f, 0.00327120f, 0.01195924f, -0.04367700f, 
    -0.14619328f, 0.24611293f, -0.06722883f, 0.13887279f, 0.00718438f, 0.07693531f, -0.09011467f, 0.03785421f, 
    0.07580041f, 0.08615771f, 0.04209477f, 0.06175238f, -0.16302380f, 0.05647366f, -0.10301764f, -0.15361859f, 
    -0.07613879f, -0.28711969f, 0.00971446f, 0.09816349f, -0.05993217f, 0.01318585f, -0.13895656f, 0.05197238f, 
    -0.01194727f, 0.01369317f, 0.13553779f, -0.07873674f, 0.00993957f, 0.00554264f, 0.19548026f, 0.01607097f, 
    -0.07871369f, 0.01452265f, -0.02403918f, 0.04794928f, 0.03140717f, -0.10465446f, -0.03332482f, 0.00731850f, 
    -0.11706723f, -0.05366853f, -0.04889095f, 0.00225875f, 0.17898728f, 0.00030254f, -0.14029850f, 0.00798122f, 
    -0.18221162f, 0.08826923f, 0.19442065f, -0.04423408f, 0.15755242f, 0.06211545f, 0.05527002f, -0.00502264f, 
    -0.05937007f, 0.02144204f, -0.06016024f, -0.06904687f, 0.01861103f, -0.04328005f, 0.18502845f, 0.00755783f, 
    0.05797893f, 0.02528152f, 0.12335295f, -0.06496719f, 0.16814828f, -0.20536818f, -0.14073154f, 0.10448880f, 
    -0.18375267f, -0.12567610f, -0.07359725f, 0.11878769f, -0.00382340f, 0.05862457f, 0.03552912f, -0.10144846f, 
    0.00184696f, -0.02672383f, 0.07777328f, -0.11782546f, 0.16923158f, 0.14335877f, 0.02908530f, 0.17458640f, 
    0.07809467f, -0.00231109f, 0.05706717f, 0.04956893f, 0.16537678f, 0.05560295f, 0.08960543f, 0.00019832f, 
    0.04429270f, 0.07067063f, 0.02252376f, 0.02698325f, -0.00664963f, -0.18485758f, 0.02213971f, 0.09729073f, 
    0.07464260f, 0.13460121f, 0.05289187f, 0.07315475f, -0.03077463f, 0.01737320f, -0.09176044f, 0.10052237f, 
    0.06873143f, 0.18096419f, 0.03549193f, 0.01624407f, 0.05756185f, 0.02992739f, 0.01812392f, -0.00789130f, 
    0.01322108f, -0.03090746f, 0.00063862f, -0.03024567f, -0.14064595f, -0.04074964f, -0.08649975f, 0.18218251f, 
    -0.05923244f, 0.14882681f, 0.09682375f, 0.01459089f, 0.14302219f, 0.07261321f, 0.06403899f, 0.02041802f, 
    0.02318900f, -0.02713774f, -0.01133733f, 0.08640163f, -0.05192986f, -0.09646581f, -0.00696181f, 0.07763273f, 
    -0.02082858f, -0.23526613f, 0.04912381f, -0.03268678f, -0.01393587f, -0.00218652f, -0.01562150f, -0.06018227f, 
    -0.04001433f, -0.06947657f, -0.05863979f, -0.07889352f, -0.04750391f, 0.06841350f, -0.00243438f, 0.23408200f, 
    0.18848146f, 0.13920084f, -0.10850005f, -0.00863890f, -0.03131718f, -0.08443058f, 0.01405933f, -0.03486798f, 
    0.06632997f, 0.03079447f, 0.03869629f, 0.14122483f, 0.09034070f, 0.08507087f, 0.09873949f, -0.05832592f, 
    0.11129346f, -0.09884516f, 0.03521848f, 0.01565189f, 0.09233072f, -0.01309713f, -0.10536975f, 0.00308304f, 
    -0.10386509f, -0.02018839f, 0.06793682f, -0.08285835f, 0.04452968f, 0.01803234f, 0.04574637f, -0.09847310f, 
    0.16072798f, -0.01630562f, -0.05852750f, -0.10292534f, 0.03778528f, 0.06963815f, 0.01563177f, 0.02336553f, 
    -0.01896724f, -0.19219413f, 0.14301020f, 0.01256505f, -0.09184225f, 0.00577724f, 0.12155673f, 0.10063393f, 
    0.07953548f, -0.02701913f, -0.01922762f, -0.00873124f, 0.17656510f, -0.00095633f, 0.06314632f, 0.13201195f, 
    0.23623298f, -0.03936512f, 0.36277023f, -0.19034289f, 0.04508310f, 0.02832089f, -0.05797238f, 0.02034771f, 
    -0.03931413f, -0.02523783f, -0.01034066f, 0.01203205f, 0.00669059f, 0.02387804f, 0.04307126f, -0.02864113f, 
    -0.11330528f, -0.10813297f, -0.03004617f, 0.04217783f, -0.02005080f, -0.17492096f, -0.24156366f, -0.00749371f, 
    0.08431999f, -0.18817496f, 0.06604407f, -0.03984946f, 0.01101392f, 0.13274117f, -0.24530080f, -0.03284935f, 
    -0.16189799f, -0.04551224f, 0.06589592f, 0.14302172f, 0.22377194f, -0.17176683f, 0.10204274f, -0.00827418f, 
    -0.07998119f, -0.02819125f, 0.07814699f, 0.08747849f, -0.06994646f, 0.00965967f, 0.01609059f, 0.12041263f, 
    0.36559382f, -0.01864441f, 0.15924336f, -0.06486951f, -0.02440270f, 0.01870579f, 0.11916126f, 0.06241172f, 
    -0.04697986f, -0.16075592f, -0.08167129f, -0.08135965f, -0.04147708f, -0.10540831f, 0.04520754f, -0.17891875f, 
    0.01411707f, 0.10878889f, -0.01024491f, 0.01876611f, -0.18277059f, -0.08412945f, -0.06351923f, -0.00792246f, 
    0.11239804f, 0.05564023f, 0.07384718f, 0.18135099f, 0.08401417f, 0.08604156f, -0.04435131f, -0.06506433f, 
    0.08100887f, -0.11589658f, -0.12660375f, -0.02489327f, 0.39602551f, -0.19736113f, -0.20041139f, -0.19233127f, 
    0.06163062f, -0.00771187f, -0.05473716f, 0.08505631f, 0.10288654f, 0.08576397f, -0.07257487f, 0.13411002f, 
    -0.00096423f, 0.06318209f, 0.06055203f, 0.05710935f, 0.01876818f, -0.00273187f, -0.00242271f, 0.00246322f, 
    0.04710652f, 0.07498137f, 0.00415537f, 0.12621814f, 0.17068991f, -0.09709369f, -0.10942413f, -0.17020833f, 
    -0.04030620f, -0.00315025f, 0.15295784f, -0.00087956f, 0.19579117f, -0.00608817f, 0.11877857f, 0.02710159f, 
    0.20897256f, 0.09575453f, 0.00373720f, -0.11140154f, -0.01024053f, -0.15721650f, -0.08104045f, -0.05041958f, 
    -0.00885411f, 0.02523006f, -0.04912113f, -0.09514586f, 0.09107690f, -0.28723434f, 0.14490214f, -0.29661110f, 
    -0.21737936f, -0.09592530f, -0.13824634f, 0.00145876f, -0.17163967f, -0.04288996f, -0.17563875f, -0.19393665f, 
    0.23073083f, 0.16612886f, 0.02848773f, 0.04346909f, 0.03530130f, 0.16478312f, -0.14324629f, -0.13643657f, 
    0.05846598f, 0.01488947f, -0.07870911f, 0.07982313f, -0.15698913f, 0.02491509f, 0.13660826f, 0.11901824f, 
    -0.02055211f, -0.01621316f, -0.06110745f, 0.02926271f, 0.05291424f, -0.08053318f, 0.15046597f, -0.02440493f, 
    0.13195960f, 0.13622867f, 0.17417054f, 0.08637834f, 0.12288881f, 0.07091570f, 0.18053183f, 0.04290804f, 
    -0.00870015f, -0.05876570f, -0.02534989f, 0.05357121f, 0.09694170f, 0.12789825f, -0.11552897f, 0.07894742f, 
    0.02534191f, 0.08402647f, -0.00951683f, 0.02867996f, 0.04160946f, -0.06371740f, 0.04172232f, 0.05834692f, 
    0.19783075f, 0.20679528f, -0.31442747f, 0.03050185f, 0.11417730f, 0.02769307f, 0.04230648f, -0.01892253f, 
    0.01648819f, 0.05377409f, -0.03740650f, -0.02241871f, -0.07072076f, -0.10192863f, 0.08241727f, 0.05812319f, 
    0.22513665f, -0.08624154f, -0.02731514f, 0.06432292f, -0.11794183f, 0.11357873f, 0.04920392f, 0.11258322f, 
    -0.22857118f, -0.00840266f, -0.06544993f, 0.01432901f, 0.02248793f, 0.00861472f, 0.02265512f, 0.07551407f, 
    0.05041700f, 0.03118332f, 0.11806256f, -0.10046107f, 0.07920222f, -0.04917203f, 0.01783828f, 0.13186508f, 
    -0.02248753f, 0.10205159f, -0.07889062f, -0.00984957f, 0.04407325f, 0.05194561f, 0.02323943f, -0.00758687f, 
    -0.12338962f, 0.29712516f, 0.11562735f, -0.08589556f, 0.00035441f, 0.00950800f, 0.08277502f, 0.00729683f, 
    0.04170841f, -0.04286737f, 0.12002029f, 0.07741748f, 0.09753113f, 0.13820738f, 0.02836677f, -0.01170228f, 
    0.09923833f, 0.06977334f, -0.11951438f, -0.03135859f, 0.07687614f, -0.06762089f, 0.01264585f, -0.16358730f, 
    0.04302352f, 0.07361005f, 0.15934786f, -0.06932174f, 0.09042450f, 0.07515351f, 0.14638442f, 0.13549355f, 
    0.05941208f, -0.02382511f, -0.00197858f, -0.01327888f, -0.11679591f, -0.30455923f, -0.22355640f, -0.05430409f, 
    0.01329100f, 0.03050950f, -0.01910738f, 0.01627824f, 0.09113870f, 0.04914291f, 0.04983886f, -0.03278598f, 
    0.17836408f, 0.19594903f, 0.12088086f, 0.03734558f, -0.12960450f, -0.10525779f, 0.00224398f, 0.13445811f, 
    -0.05756602f, 0.04517908f, 0.07263629f, -0.03894969f, -0.17975721f, -0.11613441f, -0.07916661f, 0.02268577f, 
    0.04916436f, 0.04722632f, 0.02429089f, -0.06060908f, -0.02378121f, 0.04815496f, 0.03570011f, -0.06753940f, 
    0.07545675f, 0.13036324f, 0.18205701f, -0.00956630f, 0.04103200f, 0.14304738f, -0.05963097f, -0.04541527f, 
    0.02857755f, -0.08727048f, 0.02729251f, 0.00537985f, -0.07147638f, 0.06686378f, 0.01591128f, -0.16013564f, 
    -0.02769604f, 0.01314003f, -0.12265321f, -0.02679431f, 0.11450660f, -0.01439318f, 0.03615977f, -0.22157556f, 
    0.07409357f, 0.20861259f, 0.17084531f, 0.09180729f, 0.03847282f, 0.02477303f, 0.11036798f, -0.04888175f, 
    -0.07552227f, -0.07328697f, -0.04626393f, -0.04807417f, -0.15879795f, -0.03384518f, -0.08487857f, 0.05355892f, 
    0.02762665f, -0.01496455f, -0.06275704f, 0.16300179f, -0.05791617f, 0.19977731f, 0.09542988f, -0.01104982f, 
    0.17203814f, 0.07560143f, 0.06684031f, 0.03823391f, 0.19903655f, 0.02868950f, 0.08523633f, -0.11914878f, 
    -0.02343179f, 0.01711953f, -0.00771288f, 0.00267951f, -0.09192491f, -0.17007290f, -0.15552406f, -0.04164018f, 
    0.04925821f, 0.03436482f, 0.01094394f, 0.02357952f, 0.05433721f, -0.02154187f, 0.00818450f, 0.16999246f, 
    -0.02137568f, 0.07617586f, 0.19083986f, 0.10466982f, 0.08543408f, 0.02167806f, 0.06009489f, 0.12563345f, 
    0.07203563f, -0.03316906f, -0.05796158f, -0.09942918f, 0.12146122f, -0.15847401f, 0.05646469f, -0.05457814f, 
    0.07344740f, 0.08346192f, -0.07553248f, 0.03883004f, 0.03685367f, -0.00637794f, 0.03223858f, 0.02503247f, 
    -0.05844376f, -0.06322728f, -0.07423954f, 0.01594796f, 0.01919580f, 0.04498940f, 0.00850860f, 0.07711726f, 
    -0.04320511f, 0.01689275f, 0.18884052f, 0.08232360f, 0.00467531f, 0.01309986f, 0.13022573f, 0.05084045f, 
    0.01179485f, 0.00058158f, 0.05058450f, -0.02418565f, -0.02189390f, -0.03915266f, 0.01882296f, 0.15539208f, 
    -0.10656626f, -0.09746701f, 0.06539512f, -0.01249038f, 0.04317889f, -0.00838958f, 0.01643655f, 0.05587548f, 
    0.02277150f, 0.05087406f, 0.02655549f, 0.00312703f, -0.00776965f, -0.08231243f, -0.18027902f, -0.16483964f, 
    0.21167681f, -0.16726577f, 0.05414176f, -0.10546459f, -0.05642125f, 0.15633035f, -0.18689185f, -0.00738072f, 
    -0.19040430f, 0.27176976f, 0.04915647f, 0.00797425f, 0.01602681f, 0.01907953f, 0.02610965f, 0.11645389f, 
    0.14049359f, -0.02381886f, 0.12614250f, 0.16040939f, -0.00990417f, 0.02066039f, -0.02014143f, 0.11401211f, 
    0.09887791f, 0.01220720f, 0.07800706f, 0.07470295f, 0.04486461f, 0.17573069f, -0.03258049f, -0.04650965f, 
    -0.37420368f, 0.03909092f, 0.02529372f, 0.10532185f, 0.01237319f, 0.02126140f, 0.04290023f, 0.06342722f, 
    -0.05435775f, 0.03832484f, 0.07929228f, 0.02163485f, 0.06714886f, 0.20766929f, 0.11991477f, 0.03568471f, 
    0.10135038f, 0.01060526f, 0.06197535f, 0.08466965f, -0.04358302f, -0.05615161f, -0.05270793f, -0.03852195f, 
    -0.15055312f, -0.16995773f, 0.16721432f, -0.00162028f, -0.07040512f, 0.02383355f, -0.01739742f, 0.01038243f, 
    0.00705909f, 0.06816615f, -0.02720764f, 0.07024791f, 0.10308063f, 0.27810746f, 0.23718473f, 0.08259773f, 
    0.08898690f, 0.07125512f, 0.04202227f, 0.02733748f, -0.04079688f, -0.02523459f, 0.00329348f, -0.01256038f, 
    0.13502316f, 0.21452655f, -0.03163904f, 0.01163099f, 0.11929361f, -0.09519655f, 0.09326025f, 0.00104219f, 
    -0.09046538f, 0.04563339f, 0.00563174f, -0.00819193f, -0.25304440f, -0.04482056f, -0.01058211f, 0.00844828f, 
    0.04956278f, -0.03196700f, 0.00352157f, 0.02713185f, 0.10816292f, 0.00450913f, 0.03367630f, -0.07497428f, 
    0.01815618f, -0.24165206f, -0.09780597f, -0.14238039f, 0.06758478f, -0.02270062f, -0.03735275f, -0.04643739f, 
    -0.06840894f, 0.11465843f, 0.03642172f, -0.03002723f, -0.08854967f, 0.41529658f, 0.08578032f, -0.00755821f, 
    -0.04009626f, 0.02845332f, 0.16097042f, 0.17201430f, 0.03688965f, 0.05050532f, -0.03924805f, 0.10351099f, 
    0.34060270f, 0.29173517f, 0.13335808f, -0.20810427f, -0.03328753f, -0.11815825f, -0.04072548f, 0.00603477f, 
    -0.05240983f, 0.05689556f, 0.00331142f, -0.02686141f, -0.11822969f, 0.22425854f, 0.00767322f, 0.04746789f, 
    0.16108453f, 0.13665299f, 0.12579657f, -0.01269077f, -0.00220623f, -0.06368886f, 0.01068362f, -0.03434664f, 
    0.18472795f, 0.23306794f, 0.12777638f, -0.15040152f, 0.01748843f, 0.14129736f, 0.06910576f, 0.06712670f, 
    -0.06441448f, -0.01366599f, -0.05099671f, -0.00094777f, -0.27356052f, -0.16253199f, -0.04928086f, 0.00967633f, 
    0.04384976f, 0.06125620f, 0.06466141f, 0.02556290f, 0.05261346f, 0.02161615f, -0.08609308f, 0.10171786f, 
    -0.06861541f, -0.13518642f, -0.01073523f, 0.03185812f, 0.09633403f, -0.03066942f, 0.19221596f, -0.02506216f, 
    0.14044842f, -0.01906563f, -0.06212872f, 0.02706414f, 0.00839023f, -0.14860262f, -0.18645069f, -0.06177426f, 
    0.01470278f, 0.02573859f, -0.04064071f, 0.07044167f, 0.10059997f, 0.06976184f, -0.00983337f, -0.00583390f, 
    -0.24270476f, -0.03202444f, 0.16106303f, 0.04218457f, 0.08266445f, -0.07719648f, -0.01036592f, -0.02329513f, 
    0.03114863f, 0.04503648f, 0.01343135f, 0.07319149f, 0.21758498f, 0.09469593f, 0.10116947f, -0.08056221f, 
    0.02953060f, 0.11102800f, 0.10082881f, 0.11316665f, -0.08505102f, -0.03359349f, -0.00441027f, -0.09086344f, 
    -0.12657046f, 0.06304876f, 0.10450842f, -0.01413403f, -0.03051380f, 0.00172162f, 0.00307451f, 0.15819591f, 
    -0.09270108f, 0.03938165f, 0.01542425f, -0.02193613f, -0.30801958f, -0.18146373f, -0.10663300f, 0.01627993f, 
    0.06701780f, -0.05359621f, 0.06009779f, 0.03522714f, 0.09529201f, -0.08264551f, 0.04354558f, 0.05312030f, 
    -0.21579534f, -0.22492395f, 0.12229109f, 0.07956772f, 0.05138233f, -0.01499618f, -0.06484672f, 0.08998124f, 
    0.09984862f, -0.00991870f, -0.08739010f, 0.01084210f, 0.02830168f, 0.19013689f, 0.17718785f, 0.07740278f, 
    0.06522898f, 0.05617152f, 0.07896902f, 0.16897051f, -0.08050250f, 0.01064112f, -0.03247733f, -0.07170249f, 
    0.04304713f, -0.07437219f, -0.18775235f, -0.05061175f, 0.10255654f, 0.09205233f, -0.03950361f, -0.08538577f, 
    -0.05477155f, 0.01171280f, 0.19030860f, 0.03387860f, 0.08067734f, -0.06908999f, 0.06323761f, 0.17532051f, 
    0.06123843f, 0.01794523f, 0.05508361f, 0.02252334f, 0.08446756f, 0.04923077f, -0.01331121f, -0.04806145f, 
    -0.10047755f, -0.01147406f, -0.08794042f, -0.16263157f, -0.00982648f, -0.00198864f, -0.00723873f, -0.12105540f, 
    0.09036162f, 0.02086389f, -0.07466780f, -0.08529003f, -0.17873253f, -0.08604289f, 0.09786522f, 0.08816528f, 
    0.04153332f, 0.05804521f, -0.01259694f, -0.05278679f, 0.02791098f, 0.11621949f, 0.13969210f, 0.10664892f, 
    -0.02871343f, 0.13021916f, 0.42958421f, -0.00121524f, 0.04914656f, -0.07690174f, 0.01638846f, 0.09754599f, 
    -0.02160811f, -0.09839220f, -0.05929537f, 0.03240480f, 0.04219394f, 0.15641223f, 0.20805778f, 0.09818853f, 
    -0.06234668f, -0.05129508f, -0.07122707f, 0.07076036f, 0.08274236f, 0.00388399f, 0.05515078f, 0.11094227f, 
    -0.04031194f, -0.07534586f, 0.23698358f, -0.04804110f, 0.14275318f, 0.09184228f, -0.09521090f, 0.20346762f, 
    0.01208862f, 0.00828992f, 0.13459048f, 0.09132276f, -0.10920331f, -0.15196043f, -0.05442291f, 0.14231008f, 
    0.01337564f, -0.00031046f, 0.01553118f, 0.08607389f, 0.01735705f, 0.01636693f, 0.00439990f, 0.06507896f, 
    -0.38498789f, -0.19410822f, -0.20632555f, 0.26974896f, 0.00417508f, -0.00841483f, -0.01195790f, -0.01362807f, 
    -0.16754168f, -0.06389050f, 0.10883602f, 0.00007794f, 0.10345648f, 0.11240647f, 0.10291271f, -0.10697808f, 
    0.03003089f, -0.03341444f, 0.02545596f, 0.13245681f, 0.03178939f, -0.03320471f, 0.03248696f, -0.00987919f, 
    0.10923076f, 0.10897074f, 0.09421200f, 0.04559844f, -0.06486022f, -0.05719434f, -0.04521215f, -0.00454052f, 
    0.09977034f, 0.11251967f, 0.08025163f, 0.11331594f, 0.02603226f, 0.24655586f, 0.25010008f, 0.10997619f, 
    0.10939076f, -0.09660823f, 0.24720471f, 0.06997950f, -0.03460602f, -0.05440461f, 0.00680028f, -0.01318139f, 
    0.02974198f, -0.06142304f, -0.04016077f, 0.00092296f, -0.10676989f, 0.07213847f, -0.02000145f, -0.00548088f, 
    -0.00948124f, 0.02022127f, -0.00466712f, 0.06898323f, 0.28495604f, -0.18674599f, -0.39048856f, -0.37102696f, 
    -0.13541949f, 0.15997055f, -0.15517406f, 0.17570747f, -0.03982041f, -0.01284438f, 0.01401018f, -0.02640137f, 
    0.10816041f, 0.20386925f, 0.07437956f, 0.08026799f, -0.05967794f, -0.06430340f, -0.06980997f, -0.09336197f, 
    0.06979278f, -0.11006674f, 0.03663872f, 0.07960697f, 0.01517453f, 0.07013629f, 0.18011631f, 0.02377209f, 
    -0.01724185f, -0.11134291f, 0.02488002f, 0.02475472f, 0.05596976f, 0.03554292f, -0.05948845f, -0.04933456f, 
    -0.03321824f, -0.01673181f, -0.03411908f, 0.02260557f, 0.01829368f, -0.03331944f, -0.00575175f, -0.03773594f, 
    -0.01686182f, 0.02218547f, 0.00516410f, 0.01515535f, -0.04348946f, 0.01708736f, 0.00545596f, 0.00965058f, 
    0.02360598f, 0.00455717f, -0.01143846f, -0.04331099f, 0.01243668f, -0.01449280f, 0.00335129f, -0.03108856f, 
    0.00840736f, -0.04582969f, -0.02731944f, -0.04213542f, -0.01977880f, -0.02290635f, -0.00857718f, -0.03542351f, 
    -0.00083334f, 0.00423821f, -0.01783989f, 0.01720671f, 0.02214104f, -0.01549568f, 0.01999705f, -0.01493500f, 
    -0.00585252f, -0.03239729f, -0.00758141f, -0.00679264f, -0.00489332f, -0.02951246f, -0.02422761f, -0.02191486f, 
    -0.02559253f, 0.02332013f, 0.02541180f, 0.02812954f, -0.00170293f, -0.02388921f, 0.01940333f, 0.03030214f, 
    0.02452084f, 0.02394391f, -0.03697271f, -0.00454456f, 0.00845960f, 0.01415059f, 0.01917362f, -0.00377693f, 
    -0.03268171f, -0.02935734f, 0.00580941f, 0.01893885f, -0.03664450f, 0.01608630f, 0.02792932f, 0.00592462f, 
    -0.00892261f, -0.03824723f, -0.03686239f, 0.02894587f, 0.01202351f, -0.00691197f, 0.00068966f, 0.00354705f, 
    -0.02915152f, 0.00104638f, 0.01929883f, -0.01073459f, 0.00142082f, 0.02817733f, -0.03171083f, -0.04170881f, 
    -0.03967006f, 0.00427692f, -0.02718977f, -0.01226478f, -0.02390943f, 0.02727282f, 0.02423933f, 0.00724985f, 
    0.00790001f, -0.02650299f, -0.04178854f, 0.02206852f, -0.02446441f, -0.02522063f, 0.00901910f, 0.00233394f, 
    -0.01416762f, 0.01882746f, 0.01949309f, -0.00165609f, 0.00577361f, 0.01150397f, 0.02686523f, -0.00012328f, 
    -0.04358336f, 0.01332957f, -0.04010998f, -0.00988771f, 0.02821552f, -0.02788673f, 0.03043737f, 0.02818864f, 
    -0.00698798f, -0.04770799f, 0.00673367f, -0.00031436f, 0.01882658f, -0.03878939f, 0.02181559f, -0.03481055f, 
    -0.00258355f, 0.00604152f, -0.02328993f, -0.02523903f, -0.00203395f, -0.03282601f, 0.00959761f, 0.02398410f, 
    0.02612608f, 0.02464372f, 0.02287148f, -0.01117004f, 0.01409358f, 0.02056565f, -0.01764016f, 0.01321152f, 
    -0.02191174f, 0.01805198f, 0.01393246f, -0.03565831f, -0.02740061f, -0.03037173f, -0.02910195f, -0.00635776f, 
    -0.01839859f, 0.00683152f, 0.01441587f, -0.01750144f, -0.04030957f, -0.02254168f, -0.02656508f, 0.03243610f, 
    0.02487035f, 0.01667335f, 0.02554153f, -0.02995082f, 0.01054701f, -0.02072437f, 0.00554568f, 0.02396962f, 
    0.02141400f, -0.02010954f, -0.00987855f, 0.00383244f, -0.02677045f, -0.04068442f, 0.02156121f, 0.00457601f, 
    -0.00156076f, 0.02018052f, 0.00236895f, -0.02442603f, -0.01132131f, 0.00334815f, -0.01008294f, 0.00515450f, 
    0.00622558f, -0.00371568f, 0.01470104f, 0.03654983f, -0.02220245f, 0.03243244f, -0.01242433f, -0.02198851f, 
    0.02390129f, -0.03846758f, -0.00108956f, -0.01953606f, -0.00296473f, -0.02566762f, -0.03478400f, -0.00074598f, 
    0.01132691f, -0.00912895f, -0.02554187f, 0.00661832f, -0.03275720f, -0.03065770f, -0.02842019f, 0.01038161f, 
    -0.02486272f, 0.01286073f, -0.02997127f, -0.00272017f, -0.00280578f, -0.03314763f, 0.00722014f, 0.01668745f, 
    0.00997169f, -0.01584934f, 0.01853542f, -0.03086267f, -0.02070554f, -0.03846067f, -0.01055890f, -0.03973840f, 
    0.02546685f, 0.02272369f, -0.03142935f, -0.00355260f, 0.01430184f, -0.03564116f, -0.02904951f, 0.00609170f, 
    -0.04056244f, 0.02158404f, -0.00110936f, 0.03044327f, -0.00258214f, -0.02173970f, -0.00061211f, 0.00012913f, 
    -0.02414911f, 0.01278347f, -0.03830344f, 0.00858008f, -0.02329386f, -0.00550543f, 0.01556507f, -0.00731519f, 
    -0.02918324f, 0.03194124f, 0.02219429f, 0.02760894f, -0.03652398f, 0.01701221f, -0.03251956f, 0.00277322f, 
    0.00103431f, -0.03664127f, 0.02871273f, -0.00611673f, 0.01780889f, -0.01129491f, 0.03170983f, -0.01768667f, 
    0.00552506f, 0.00023794f, -0.00024236f, 0.01843454f, -0.01304547f, 0.00195786f, -0.01062474f, -0.03426300f, 
    0.00184271f, -0.00231327f, 0.00937841f, 0.03332098f, -0.01388985f, 0.01311232f, 0.02198184f, 0.00862283f, 
    0.01715644f, -0.00361775f, 0.02277292f, -0.00185531f, 0.01345926f, 0.01953406f, 0.00419449f, -0.01820449f, 
    0.00159109f, -0.02431620f, -0.01768570f, -0.02752991f, -0.00774022f, -0.01280008f, -0.03579664f, -0.00747367f, 
    -0.02357957f, -0.02781505f, 0.01336050f, -0.02444470f, 0.01799867f, 0.01899265f, -0.00225967f, -0.04020425f, 
    -0.00342461f, 0.00993800f, 0.01882177f, -0.01861923f, 0.00637321f, 0.01299093f, 0.02714758f, -0.01505882f, 
    0.00347515f, -0.01935673f, -0.01619159f, -0.00791129f, -0.02695478f, -0.03528326f, -0.03534820f, -0.00647656f, 
    -0.02373982f, 0.00731735f, -0.01402148f, -0.03850313f, -0.03518934f, -0.01794048f, 0.01046281f, -0.04431179f, 
    -0.02733861f, 0.00638416f, -0.02450748f, -0.03441702f, 0.01887050f, -0.00490045f, -0.03790855f, 0.00029496f, 
    0.02461373f, -0.02961195f, 0.02493256f, 0.00396832f, 0.01668010f, 0.00842275f, -0.00790873f, 0.02788785f, 
    0.02431069f, 0.03739806f, -0.01418614f, -0.03401878f, -0.01483137f, 0.00288526f, 0.00303765f, 0.01344427f, 
    0.00530651f, 0.00066645f, 0.01881028f, 0.02394203f, 0.00102264f, -0.04058498f, -0.04060211f, -0.02155210f, 
    -0.03040293f, -0.01226844f, 0.00361483f, 0.00247823f, -0.00686172f, -0.00195095f, 0.00957973f, 0.00584496f, 
    -0.00978057f, 0.00108534f, 0.01275808f, 0.01032313f, 0.02569550f, 0.02573214f, -0.03069260f, -0.00336522f, 
    -0.02244829f, -0.02757683f, -0.02193799f, -0.03730502f, 0.01361053f, 0.01064674f, -0.00995704f, -0.00394361f, 
    0.00658651f, 0.01567555f, -0.02138316f, 0.02239393f, -0.04903347f, 0.01382244f, -0.00887881f, 0.00883323f, 
    -0.00133264f, 0.02811143f, -0.00437200f, 0.01124064f, -0.01303924f, -0.00001797f, -0.00010563f, 0.00113024f, 
    -0.01293673f, 0.02569701f, -0.02309649f, 0.01747062f, 0.00383661f, -0.01826949f, -0.03140491f, 0.01502531f, 
    0.02121472f, -0.02985075f, 0.02548274f, 0.01224400f, 0.01066635f, -0.01902634f, 0.02489301f, 0.02166888f, 
    0.01827627f, -0.01651654f, 0.00484167f, -0.02623840f, -0.04058408f, -0.00099533f, -0.00743135f, 0.01567320f, 
    0.01640196f, -0.02586288f, -0.04251797f, -0.01987544f, -0.00797048f, -0.02953611f, -0.01243767f, -0.03400031f, 
    0.01613329f, -0.02312596f, 0.01156313f, -0.01475520f, 0.00867445f, -0.02336847f, 0.01320983f, -0.03394356f, 
    -0.02782490f, -0.01152653f, 0.03476960f, 0.00505555f, -0.01593248f, -0.01818916f, -0.00430153f, 0.00138277f, 
    -0.02175481f, 0.02958129f, -0.02572558f, 0.01904766f, 0.00268111f, -0.00493040f, -0.02965180f, -0.04318283f, 
    -0.00528476f, 0.00205203f, 0.01439787f, -0.03687199f, 0.01564865f, 0.02458375f, -0.02192553f, -0.00427637f, 
    -0.00231683f, 0.03076294f, -0.03193343f, -0.03119744f, -0.01977370f, 0.02721590f, 0.02245640f, -0.01999640f, 
    -0.03322806f, -0.01973459f, -0.02927546f, 0.00435378f, -0.01674302f, 0.02448512f, -0.02059853f, -0.02516836f, 
    0.01710044f, -0.00315349f, 0.03371126f, 0.01888808f, -0.02399558f, 0.00415412f, -0.02037024f, -0.03094551f, 
    -0.00236693f, -0.02321785f, 0.01391186f, 0.01264883f, -0.00420573f, -0.00317032f, -0.03432671f, 0.02754483f, 
    -0.03512302f, 0.02725492f, -0.00047870f, -0.00485154f, -0.03375879f, -0.00973771f, -0.02273181f, -0.00985536f, 
    0.02377006f, -0.01975079f, 0.02052761f, -0.03020114f, -0.04055779f, 0.00846962f, 0.03386724f, -0.03612641f, 
    -0.02122255f, -0.03381150f, 0.00376317f, 0.00198700f, 0.02444692f, 0.02124608f, 0.00689854f, -0.02172345f, 
    -0.00038745f, 0.02478119f, -0.02932191f, -0.00393813f, -0.03180443f, 0.01224155f, 0.00627687f, -0.02241262f, 
    -0.02797657f, 0.02245090f, -0.01212619f, -0.00859506f, 0.01766715f, 0.00933190f, -0.03669752f, 0.01813854f, 
    -0.02116626f, 0.02553211f, -0.00547290f, 0.01763021f, 0.01233597f, -0.02603957f, 0.02949575f, 0.00065152f, 
    -0.02835622f, -0.03620665f, -0.03845824f, -0.03150884f, 0.00171225f, -0.03920766f, -0.03516612f, -0.01870888f, 
    -0.01527311f, 0.03171742f, 0.00072576f, 0.02741520f, 0.03182156f, -0.03729789f, -0.01128288f, -0.00780321f, 
    -0.04587830f, 0.00116902f, 0.02513172f, -0.03354423f, 0.01309865f, -0.00548387f, 0.00301405f, 0.01317649f, 
    0.01034205f, -0.01683511f, -0.04326654f, 0.01031829f, -0.00658631f, -0.02959469f, 0.02584529f, -0.01324736f, 
    0.01199988f, -0.03594792f, 0.00175937f, -0.01104491f, 0.00147595f, -0.01630115f, -0.01991194f, -0.02130289f, 
    -0.03142166f, 0.00650692f, -0.01897974f, -0.02068134f, -0.01499140f, -0.02602020f, -0.02104618f, 0.00606619f, 
    -0.01376693f, -0.00541853f, -0.01590749f, 0.00050464f, 0.01832473f, -0.00843939f, 0.02470185f, -0.02573525f, 
    0.00852098f, 0.03148983f, -0.03303527f, 0.01838501f, 0.02327815f, -0.03943826f, -0.02416675f, 0.02668858f, 
    -0.02245915f, -0.00258408f, -0.00196689f, -0.00395953f, 0.02824306f, -0.00683856f, -0.02523786f, 0.01936320f, 
    0.02619280f, -0.03353237f, -0.02024037f, 0.00003270f, -0.00840457f, 0.02657621f, -0.03570176f, 0.02574206f, 
    0.00653763f, 0.02042193f, -0.00067303f, 0.00586069f, 0.00186450f, 0.02958893f, -0.01898871f, -0.00634045f, 
    0.02033972f, 0.03699379f, 0.01569752f, -0.00092617f, 0.00275726f, -0.03685457f, -0.02773963f, 0.01751274f, 
    -0.01630751f, 0.02784436f, 0.02573167f, -0.01489349f, -0.01396624f, 0.00407994f, 0.01808818f, -0.02279590f, 
    -0.01716789f, 0.02612204f, -0.00219562f, -0.02886998f, -0.00201346f, -0.02326210f, 0.00554659f, -0.00743250f, 
    -0.00079750f, 0.02125664f, 0.00789421f, 0.00480848f, -0.03318945f, 0.02860774f, 0.01822365f, -0.03326744f, 
    0.00992751f, -0.02749752f, 0.01976158f, 0.00336185f, -0.00997040f, -0.00055523f, -0.00685380f, 0.00956212f, 
    -0.00680276f, -0.03700181f, -0.00635743f, 0.02623487f, -0.00155182f, 0.03235637f, 0.01257434f, -0.00599323f, 
    -0.02010683f, 0.02209428f, -0.01003000f, -0.03439923f, 0.00720158f, -0.03399518f, 0.01393805f, -0.03733467f, 
    -0.02404077f, -0.00803789f, 0.02149636f, -0.04014444f, 0.02422150f, 0.00340102f, -0.02785260f, -0.02181639f, 
    -0.01665326f, 0.01949413f, -0.03869966f, -0.03160316f, 0.00580074f, -0.01266529f, -0.02963085f, -0.03430513f, 
    0.00386476f, 0.02103846f, -0.03914178f, -0.00025700f, -0.01716006f, -0.00745163f, 0.01556362f, -0.00992653f, 
    -0.02974090f, -0.02771507f, -0.01542473f, -0.02796778f, -0.00956708f, 0.00452448f, 0.00207199f, -0.02498376f, 
    -0.01059339f, 0.01770276f, 0.00613014f, -0.00723223f, -0.01685610f, -0.02003355f, 0.02835306f, -0.01802514f, 
    -0.03906167f, 0.02909399f, -0.02866042f, -0.00214102f, -0.03745919f, 0.01759307f, -0.00227379f, -0.01147574f, 
    0.02421083f, 0.04268099f, -0.02900177f, 0.00989866f, -0.02601279f, -0.00688404f, 0.03690824f, -0.04279647f, 
    -0.03062748f, 0.00610027f, -0.02357451f, -0.00206758f, -0.01429639f, 0.02669354f, -0.00326665f, 0.00986288f, 
    -0.02329104f, -0.01663914f, 0.01678537f, 0.00165638f, -0.01176061f, 0.01407656f, 0.01176441f, -0.02487112f, 
    0.03332007f, -0.02519349f, 0.01236525f, 0.01116038f, -0.01120659f, -0.01551073f, 0.02497591f, 0.01277881f, 
    -0.00542296f, -0.25591201f, 0.01210379f, 0.00584981f, 0.11634351f, -0.00044743f, 0.08970638f, 0.20336737f, 
    -0.00639238f, -0.02976040f, 0.15308151f, 0.04958995f, 0.18422014f, -0.06923351f, -0.02607627f, 0.18209410f, 
    0.04031817f, 0.02281144f, 0.01957240f, 0.03715638f, 0.08011934f, 0.23061150f, -0.01361908f, -0.01264059f, 
    -0.16649650f, -0.12324459f, -0.09038918f, -0.02279717f, 0.01905545f, -0.01804016f, 0.03730167f, 0.09373459f, 
    -0.02766197f, 0.04274563f, 0.11033539f, 0.10468020f, 0.02136419f, -0.12223619f, -0.00994299f, -0.04622426f, 
    0.06077390f, 0.02194163f, 0.15384448f, 0.00886264f, -0.01186477f, -0.06245493f, -0.08832829f, -0.07037316f, 
    0.03986824f, -0.21886459f, 0.02800586f, -0.14338546f, 0.15349694f, 0.11758856f, -0.05880914f, -0.13463026f, 
    0.03160228f, -0.09541754f, -0.02171891f, -0.00129845f, -0.09879459f, 0.06083899f, -0.02416641f, 0.09579840f, 
    -0.19398865f, 0.01565502f, -0.02492891f, -0.01194475f, 0.19194831f, 0.12537746f, 0.08407082f, 0.09174769f, 
    0.00969995f, -0.09234143f, 0.01812313f, -0.00100165f, 0.03675466f, 0.06828834f, -0.04078466f, -0.07066792f, 
    0.15951923f, -0.13637672f, -0.03148947f, 0.04998467f, -0.11658572f, -0.04627034f, 0.00124371f, -0.00552336f, 
    0.00549899f, 0.10677697f, 0.20462367f, 0.14410676f, -0.07003777f, -0.06588240f, 0.02577906f, -0.02877725f, 
    -0.07381423f, -0.10887082f, -0.07142410f, -0.09844012f, 0.01785710f, -0.00669667f, 0.04277613f, 0.06096961f, 
    0.13069677f, 0.09278018f, 0.03406440f, 0.09551129f, -0.12335629f, -0.09605941f, 0.06567696f, 0.00154391f, 
    0.12593955f, -0.09940398f, -0.13809316f, 0.02028348f, -0.13130835f, 0.07966666f, -0.13987865f, 0.10821298f, 
    -0.08339021f, -0.15436992f, -0.10096903f, 0.02747190f, 0.06426264f, 0.10782789f, 0.01586223f, -0.08328884f, 
    0.01117560f, -0.01142075f, 0.01929129f, 0.04171921f, 0.04103281f, 0.05603350f, 0.13692954f, -0.01011312f, 
    -0.01092538f, 0.03262465f, 0.06531345f, 0.01752031f, 0.10101157f, 0.13059811f, 0.09477094f, 0.17944287f, 
    -0.10237727f, -0.07392613f, -0.07052439f, -0.00135127f, -0.06416626f, 0.06921231f, 0.02545172f, -0.24514735f, 
    0.05167111f, -0.01791203f, -0.00926426f, 0.02678184f, 0.08295090f, 0.01437129f, -0.01050459f, -0.00645728f, 
    -0.01566269f, 0.02001215f, -0.00900702f, -0.03831767f, 0.20244946f, 0.00024421f, 0.14513378f, 0.18095365f, 
    -0.09941524f, -0.14356090f, 0.00449225f, 0.01988790f, -0.03464389f, -0.05310421f, 0.14487323f, 0.14812362f, 
    -0.04461657f, -0.00179787f, 0.14361638f, -0.02085762f, 0.20539202f, -0.01062500f, -0.05220328f, 0.00974367f, 
    0.17862916f, -0.09270986f, 0.19409534f, 0.09740778f, 0.11887215f, 0.08274397f, -0.04376721f, 0.13401948f, 
    -0.21470819f, -0.23955390f, -0.09320810f, -0.16557375f, -0.02396480f, -0.09396482f, -0.04098099f, -0.01203411f, 
    -0.05163915f, -0.09212065f, 0.03207037f, -0.07750604f, 0.06311142f, -0.00938765f, -0.04414769f, 0.06535313f, 
    0.02422709f, 0.10002088f, 0.10094367f, -0.08150669f, 0.24512027f, -0.01776128f, -0.05290657f, 0.07703076f, 
    -0.05303353f, 0.30220968f, 0.22841714f, 0.00926344f, -0.03721852f, -0.07470299f, -0.07874284f, 0.02170733f, 
    0.10796373f, 0.21087174f, 0.15399867f, 0.01932953f, 0.12328503f, 0.01616886f, 0.07200154f, -0.04019253f, 
    0.00670481f, 0.00638847f, 0.03784039f, 0.03411007f, -0.00435062f, -0.00583737f, -0.08374747f, -0.20282361f, 
    0.15672427f, -0.05469459f, -0.27128565f, 0.21483773f, 0.05767271f, -0.10074455f, 0.03436980f, 0.07492215f, 
    0.00054739f, -0.07070523f, 0.02392839f, 0.06619173f, 0.14108911f, 0.01747130f, 0.02423442f, 0.02501033f, 
    0.04935671f, -0.02910971f, 0.08239929f, 0.03110207f, -0.06628906f, 0.01463501f, -0.06477755f, -0.06696245f, 
    -0.02456632f, -0.02383877f, 0.04579943f, -0.02186852f, 0.03429234f, -0.07981189f, -0.07479714f, -0.07323185f, 
    0.06705371f, 0.00745609f, -0.10022359f, 0.08609746f, -0.00388552f, 0.11690891f, 0.04992760f, 0.23054785f, 
    0.01040475f, 0.05615298f, -0.06488973f, 0.10708821f, 0.18258545f, 0.11773631f, 0.14847714f, 0.07687656f, 
    0.15805417f, 0.04207439f, -0.06216520f, -0.01909597f, 0.00582076f, 0.11714619f, 0.04571178f, 0.06042999f, 
    0.05312180f, -0.11865845f, 0.05598917f, 0.03223313f, -0.08497774f, -0.02233600f, -0.09776754f, -0.10811025f, 
    -0.00878469f, 0.13685623f, -0.07828774f, 0.07082534f, 0.17537993f, -0.10203575f, 0.08791243f, 0.10675262f, 
    0.15935303f, 0.06588186f, 0.11082055f, 0.06138403f, -0.00829618f, -0.06207835f, -0.00086366f, -0.07268940f, 
    0.09259047f, 0.13756435f, 0.06574134f, 0.03165839f, -0.00045631f, 0.16214570f, 0.26151645f, 0.04516762f, 
    -0.09963999f, -0.05129446f, -0.14303587f, -0.16911495f, -0.07950416f, 0.09040312f, 0.33189708f, 0.15845279f, 
    -0.01906339f, 0.03163321f, 0.23954962f, 0.18523663f, 0.02875469f, -0.02108584f, -0.07625154f, 0.01405926f, 
    0.05356241f, -0.02184041f, -0.08453551f, 0.18181643f, -0.15581489f, -0.26692879f, -0.17690417f, -0.10591461f, 
    -0.01928145f, 0.04182674f, -0.02677272f, 0.07117224f, 0.06449784f, 0.08354722f, 0.10225285f, 0.10657964f, 
    0.10690846f, 0.33413696f, -0.07424855f, 0.07880261f, 0.00384061f, -0.05330225f, -0.00442092f, -0.00493216f, 
    -0.04814964f, 0.06100675f, -0.01376320f, -0.13480628f, -0.23819947f, -0.38624617f, -0.20888674f, -0.22148070f, 
    -0.06410218f, -0.11388126f, -0.00919661f, -0.02842372f, -0.09447314f, -0.08583764f, -0.00467754f, -0.04674289f, 
    -0.27779540f, -0.27627602f, -0.00270007f, -0.10738845f, -0.02149764f, 0.05024562f, -0.11897411f, -0.10981750f, 
    0.11311918f, -0.05951665f, 0.03271641f, 0.02085191f, 0.23206346f, 0.20710310f, -0.09797370f, 0.00512666f, 
    -0.08506347f, 0.02277768f, 0.00135366f, -0.04343174f, 0.02811541f, 0.14568885f, 0.10489313f, 0.20551133f, 
    0.28033409f, 0.08377766f, -0.07200143f, -0.24672632f, 0.08908350f, 0.03582835f, 0.22035910f, 0.05978105f, 
    0.00951093f, -0.01763749f, -0.08807744f, -0.03931928f, -0.07119273f, -0.25631353f, -0.02604969f, -0.07958787f, 
    0.01469173f, 0.10079296f, -0.03856700f, -0.07826412f, 0.17398621f, 0.07199027f, 0.16769846f, 0.02594560f, 
    -0.28383330f, -0.26382878f, -0.18970574f, -0.06161303f, 0.05726134f, -0.02032383f, -0.04538557f, 0.02579012f, 
    0.01101945f, -0.04745846f, -0.03172400f, -0.00356195f, -0.04229072f, -0.00945555f, 0.36027730f, 0.13657366f, 
    0.07813723f, -0.00676168f, -0.06805313f, -0.02859249f, 0.09684047f, 0.08380300f, 0.16171661f, 0.23665047f, 
    -0.06844801f, -0.30312634f, -0.20780821f, -0.10985381f, 0.00098798f, -0.03355914f, -0.06706522f, 0.00859798f, 
    0.07189525f, -0.06432097f, 0.06001105f, 0.03601851f, 0.35288706f, 0.15241431f, -0.12464125f, 0.13415708f, 
    0.02802704f, 0.02128863f, -0.08942744f, 0.04433249f, -0.07340042f, 0.14595498f, 0.29582065f, 0.05608634f, 
    0.04540960f, 0.26219544f, -0.14104193f, 0.07332850f, -0.00472525f, -0.01672705f, -0.06998803f, -0.01992797f, 
    0.10508873f, 0.08967345f, 0.09779067f, 0.18082921f, -0.01716268f, 0.00122911f, 0.12853457f, -0.03425657f, 
    0.04650068f, 0.09153844f, -0.04035706f, -0.02509508f, 0.00448730f, -0.04936341f, -0.06814970f, -0.04382286f, 
    0.17624490f, 0.02000336f, -0.09825121f, 0.20599017f, 0.04059210f, 0.14876290f, 0.10727306f, -0.05078501f, 
    0.09394000f, -0.05692881f, -0.04209165f, -0.08473220f, -0.17415924f, 0.15713848f, 0.06783791f, -0.12942618f, 
    -0.01864897f, -0.10815093f, -0.11069932f, -0.10999075f, 0.19705093f, 0.02465824f, -0.04939111f, 0.11240354f, 
    0.17250700f, -0.10241002f, -0.11279815f, 0.09217025f, 0.12333502f, 0.12476909f, 0.17258333f, -0.00707060f, 
    0.08306274f, -0.01456404f, -0.07267257f, -0.01281360f, 0.01886735f, 0.03829532f, 0.01950608f, 0.13532242f, 
    0.01922566f, 0.04818812f, 0.07613325f, -0.08955441f, 0.20541324f, 0.21586660f, 0.07441140f, 0.13831346f, 
    0.26722106f, 0.26967072f, -0.00243116f, 0.06020112f, -0.04524269f, -0.08530137f, 0.00285923f, 0.01458004f, 
    0.04733566f, 0.06753657f, 0.25203949f, 0.16195396f, -0.15504721f, -0.15952103f, -0.11823003f, -0.20015348f, 
    -0.10084847f, -0.06852301f, 0.01537285f, -0.02858908f, 0.03162064f, 0.07684270f, 0.06664035f, 0.13955598f, 
    -0.02255184f, -0.00534659f, 0.05284916f, -0.01531016f, 0.09206279f, -0.04309663f, 0.01621270f, 0.01963729f, 
    0.01071921f, 0.00786403f, -0.18860354f, -0.12011715f, -0.17546910f, -0.14651851f, -0.07136782f, -0.04141752f, 
    0.09438056f, 0.01088469f, -0.01736006f, 0.12708229f, -0.03802939f, -0.09170733f, -0.04015856f, -0.03575465f, 
    -0.06140644f, 0.03494179f, 0.00738369f, 0.13818853f, 0.07302066f, -0.09027031f, -0.09313105f, 0.02647754f, 
    0.03431802f, 0.14755578f, -0.04329950f, 0.03041380f, 0.15249081f, 0.03333412f, -0.15368287f, 0.01928976f, 
    -0.04597668f, 0.01521556f, 0.08574234f, 0.00972088f, 0.02938862f, -0.02091066f, -0.02774663f, -0.01567753f, 
    -0.14874274f, -0.30739492f, -0.36424232f, 0.02689653f, -0.03322659f, -0.06348787f, 0.02245417f, 0.06035934f, 
    -0.03472190f, 0.03177715f, 0.02320903f, 0.01963963f, -0.09112062f, -0.10414442f, -0.08789211f, -0.04558779f, 
    0.07851307f, 0.08479190f, 0.12113704f, 0.04844746f, -0.13048761f, 0.06698064f, 0.18686776f, 0.12009602f, 
    -0.04656814f, 0.06262793f, -0.20551640f, 0.16021673f, 0.02349013f, 0.00484629f, 0.12694465f, -0.07391907f, 
    0.02726195f, 0.12111104f, -0.03024086f, -0.04010000f, -0.05591042f, 0.22280344f, 0.14445135f, 0.04496684f, 
    0.05078336f, -0.02249068f, 0.02705646f, 0.01581422f, 0.07427122f, 0.13552214f, 0.04441894f, 0.05579095f, 
    -0.05410734f, 0.15671290f, 0.36580613f, 0.28248671f, 0.06450918f, -0.00749300f, -0.08765218f, 0.00451831f, 
    0.02537207f, 0.09322774f, 0.04038375f, 0.07597224f, 0.06372100f, -0.16222863f, 0.00177843f, 0.10541072f, 
    0.01640163f, 0.00627114f, 0.09919980f, 0.05889268f, 0.17369579f, 0.17317721f, 0.18798965f, 0.08672179f, 
    -0.05870621f, -0.07935890f, -0.03115057f, -0.14306496f, -0.03397643f, -0.01785326f, 0.17158058f, -0.00167805f, 
    -0.01735425f, 0.06450704f, 0.06598645f, 0.14795615f, -0.21081425f, -0.19018419f, 0.08499428f, 0.05727031f, 
    0.02675628f, -0.01431934f, -0.21686037f, 0.01979741f, 0.03400144f, 0.06052891f, 0.05444422f, -0.01751436f, 
    0.09806254f, 0.03965525f, -0.00601183f, -0.10079896f, 0.11455052f, 0.03960313f, 0.12145132f, 0.06317651f, 
    0.05006529f, -0.01539066f, -0.01667758f, -0.15166773f, -0.30359423f, -0.08980058f, 0.30726621f, -0.04541499f, 
    0.28166941f, -0.08024065f, 0.02829569f, -0.00305981f, 0.12935793f, 0.02506428f, -0.02595779f, -0.04495872f, 
    -0.15533757f, -0.17044872f, 0.08836579f, 0.09598947f, -0.00959377f, 0.16636989f, 0.17094088f, 0.14939560f, 
    0.04062703f, 0.13700476f, 0.03504578f, 0.13980515f, -0.09138697f, 0.05822005f, -0.14188781f, 0.21991193f, 
    0.15879345f, 0.19708471f, -0.02786346f, 0.17988198f, 0.12544261f, 0.17563388f, 0.19493139f, 0.20649210f, 
    -0.24258402f, -0.09113706f, 0.07019155f, -0.13253276f, -0.00163333f, -0.05405175f, -0.06023680f, -0.03279832f, 
    -0.04149978f, 0.07944103f, 0.01598870f, 0.01584309f, -0.10154524f, 0.01471418f, -0.09055918f, -0.02182830f, 
    0.06774937f, 0.09503954f, 0.11191511f, -0.10860927f, 0.02282539f, -0.10134146f, 0.03547826f, 0.07656100f, 
    -0.11182452f, 0.12487536f, 0.09630309f, 0.10849386f, 0.03151029f, -0.03353457f, -0.01779850f, 0.02383331f, 
    0.06628154f, 0.03122332f, -0.04614953f, -0.09627601f, 0.06689923f, -0.03332161f, -0.06112483f, 0.07186766f, 
    0.09525018f, 0.02143467f, 0.16527155f, 0.06692970f, -0.12992285f, 0.14440000f, -0.05412014f, -0.00135300f, 
    0.13095799f, -0.05449787f, -0.10490565f, 0.26066834f, -0.09414428f, 0.03452477f, 0.34137177f, 0.10025999f, 
    -0.07113259f, 0.02156802f, 0.03837508f, -0.11563936f, -0.10278963f, -0.00012617f, 0.13473651f, 0.05851973f, 
    0.03814845f, 0.05627909f, -0.05175072f, -0.07415403f, -0.06849805f, 0.08344220f, -0.00848670f, 0.09785727f, 
    0.03357903f, -0.01101783f, 0.05603701f, -0.02083109f, 0.05113277f, -0.00486708f, -0.09073282f, 0.05339815f, 
    0.01896420f, 0.07126646f, -0.15466569f, 0.00954292f, -0.18227108f, -0.15169908f, -0.05386380f, -0.04967237f, 
    0.04391564f, 0.09734752f, 0.03815765f, -0.00438742f, 0.03021247f, -0.02218643f, -0.05170487f, -0.04252438f, 
    -0.03235844f, 0.00052464f, 0.11233858f, 0.05893984f, 0.07043684f, -0.00581811f, -0.02569066f, -0.07607526f, 
    0.05573698f, 0.01332599f, -0.03159342f, -0.03794556f, 0.33999091f, 0.18537371f, 0.14724575f, 0.04627489f, 
    -0.11321703f, 0.10992783f, 0.16247366f, 0.05365209f, -0.06012555f, -0.01437540f, 0.14607316f, 0.00398277f, 
    -0.09379728f, -0.25706747f, -0.09532608f, 0.11749758f, -0.01975826f, -0.00066512f, -0.01416298f, 0.12483727f, 
    -0.00198372f, -0.03267413f, -0.03213758f, -0.06959517f, 0.21674313f, 0.00701819f, 0.06363262f, -0.04312187f, 
    0.04778119f, -0.01327012f, -0.07092233f, -0.02551906f, -0.05329207f, 0.05928124f, -0.04182483f, -0.00081793f, 
    -0.20805438f, 0.15518266f, 0.05327903f, -0.00901944f, -0.09428262f, -0.11406511f, 0.02376967f, -0.06321087f, 
    0.03572497f, 0.08921584f, 0.01950040f, 0.03024985f, -0.03381270f, -0.07363182f, -0.07850835f, -0.10185998f, 
    -0.01149912f, 0.06842756f, 0.02691197f, 0.00714586f, 0.02084831f, 0.05852153f, 0.03922726f, -0.11887529f, 
    0.07024520f, 0.13619877f, 0.01937821f, 0.04011589f, -0.05431184f, -0.09486390f, -0.04273907f, -0.03584759f, 
    0.00247073f, 0.01791462f, -0.07933667f, -0.18645290f, 0.05787720f, 0.08813049f, 0.01645477f, 0.14537863f, 
    0.02063136f, -0.00553793f, 0.02233974f, 0.07940888f, 0.00251626f, 0.01624364f, 0.01255940f, -0.00119553f, 
    0.02431589f, 0.22493772f, 0.23065782f, 0.30776930f, 0.06933857f, -0.17953537f, 0.03938720f, 0.27908623f, 
    0.07048742f, 0.03762179f, 0.02395433f, 0.01518064f, 0.05403038f, -0.17928168f, -0.01696397f, -0.14557616f, 
    -0.04243201f, 0.03881032f, -0.07923953f, 0.09392986f, -0.06405537f, 0.03500728f, 0.02261732f, -0.01858882f, 
    0.29336941f, -0.08632243f, 0.14800128f, 0.09736571f, -0.01216338f, -0.06802586f, -0.07330696f, 0.09769309f, 
    -0.03859226f, -0.06629165f, 0.01032101f, 0.08814374f, -0.06501111f, -0.21047845f, 0.12979658f, -0.10020803f, 
    0.02417615f, 0.02511071f, -0.01068980f, -0.01551504f, -0.04197155f, -0.01579758f, 0.00582160f, -0.02389551f, 
    -0.12511757f, 0.10880902f, -0.05183060f, 0.07397337f, 0.05306261f, 0.05048990f, 0.00229852f, 0.11230487f, 
    -0.03862201f, -0.05656233f, 0.08774090f, -0.03473184f, -0.21251242f, -0.13984320f, -0.38346970f, 0.11238505f, 
    -0.04165639f, 0.05651270f, 0.05270620f, -0.03672299f, 0.05208655f, -0.08303434f, 0.05265366f, -0.08788098f, 
    0.00369955f, -0.02749444f, 0.07920378f, 0.01476221f, -0.00896162f, 0.02185670f, -0.02569650f, -0.02587204f, 
    0.14447387f, 0.08462193f, -0.03359574f, -0.10206728f, 0.12194989f, -0.05337004f, 0.05581706f, 0.19115242f, 
    -0.02656201f, -0.01003614f, -0.06718195f, -0.03154944f, 0.01585593f, 0.02446993f, -0.07404394f, -0.04811352f, 
    -0.13374773f, 0.02543236f, -0.11850252f, -0.00943289f, 0.00169297f, -0.02974021f, -0.02596870f, -0.03226142f, 
    0.09047838f, -0.04269388f, -0.05750466f, 0.05450036f, -0.14631496f, 0.16821413f, -0.07048868f, 0.12467533f, 
    -0.08464726f, -0.06091902f, 0.19277167f, 0.07505023f, -0.10284939f, 0.03942021f, -0.02840260f, -0.12847809f, 
    0.04801358f, 0.04468336f, -0.07015015f, -0.02062565f, -0.04378121f, -0.04661543f, -0.01581535f, -0.01920610f, 
    0.00961888f, 0.07054482f, 0.08882014f, -0.11227560f, 0.07172656f, 0.02253304f, -0.06069956f, -0.04458490f, 
    -0.01858949f, -0.12105548f, -0.04331700f, 0.01826102f, -0.03214559f, -0.04157928f, -0.02279454f, 0.01206778f, 
    0.10306302f, 0.26982218f, -0.01844062f, -0.17823890f, -0.03932398f, 0.06645866f, -0.02139912f, -0.05193736f, 
    0.02874903f, 0.00476887f, 0.02834119f, 0.06102844f, -0.01182946f, -0.01435312f, 0.00150125f, 0.05053511f, 
    0.10781936f, 0.01911567f, -0.09436813f, 0.02310310f, 0.05763067f, 0.04074361f, -0.05888379f, -0.11735818f, 
    -0.23379217f, -0.02219815f, -0.02993596f, -0.00448570f, -0.00578489f, 0.04696814f, -0.02192549f, -0.05553389f, 
    0.10051092f, -0.18042801f, 0.00638697f, -0.02672209f, 0.02244381f, 0.24179089f, 0.21504796f, 0.32975844f, 
    -0.09410024f, -0.06167490f, 0.00491270f, 0.11843773f, 0.02897678f, 0.13308835f, -0.06520744f, -0.01174162f, 
    -0.08436409f, 0.26059076f, 0.16137855f, 0.14964996f, -0.25666615f, -0.09804860f, -0.10403265f, 0.12108994f, 
    0.02145895f, 0.14097734f, -0.03611109f, 0.04222415f, 0.00966303f, 0.08220686f, -0.15918556f, -0.11071670f, 
    0.04255447f, -0.06585665f, 0.02379042f, -0.00524195f, -0.09980157f, -0.20423169f, -0.01712969f, 0.09870294f, 
    -0.21619302f, 0.08533344f, -0.31743133f, -0.02168992f, -0.01790192f, 0.06524127f, 0.19938330f, 0.01885760f, 
    0.01963373f, -0.00632145f, -0.08650319f, -0.00803513f, -0.01336972f, -0.01157205f, 0.13120103f, 0.09357329f, 
    0.17496511f, -0.04008348f, -0.17763977f, 0.02876800f, -0.01326948f, -0.06408665f, -0.03705360f, 0.10400078f, 
    -0.15945064f, 0.24431720f, 0.11869141f, 0.13527472f, -0.03851604f, 0.03887749f, 0.04241479f, 0.00166508f, 
    0.00144593f, 0.08945925f, 0.02973831f, 0.00681305f, 0.27810130f, -0.03086478f, 0.06225602f, 0.02410625f, 
    -0.03057077f, -0.12625551f, -0.08292458f, 0.04153557f, -0.01247704f, 0.00725220f, -0.13825813f, -0.06497645f, 
    0.21885304f, 0.35467643f, 0.16228262f, 0.33312058f, -0.06217365f, -0.05312686f, 0.14045888f, 0.15614705f, 
    0.05136545f, 0.15229948f, 0.01032787f, -0.00487687f, -0.09128782f, 0.14023778f, -0.04453493f, -0.04648751f, 
    0.04929988f, -0.06925729f, 0.03924811f, -0.07895408f, -0.02662546f, 0.00247122f, -0.19661179f, -0.10530121f, 
    0.00183742f, 0.42026767f, -0.06844818f, 0.07774770f, -0.10296548f, -0.13377170f, -0.01918097f, 0.09925953f, 
    0.06634844f, -0.02396511f, -0.07217137f, -0.14259641f, -0.02253937f, -0.15283318f, -0.16883028f, 0.09725205f, 
    0.04800996f, -0.04327471f, 0.13068895f, -0.04474995f, 0.02157461f, 0.00072726f, -0.01104085f, 0.03429798f, 
    -0.32575378f, 0.04590194f, -0.10908166f, -0.12847203f, -0.02824135f, 0.06658060f, -0.02983860f, -0.00715645f, 
    0.04140547f, -0.06720621f, 0.00484353f, 0.05554596f, 0.05367760f, 0.13532288f, 0.15914936f, 0.03437046f, 
    -0.02105582f, 0.00562055f, 0.06813156f, -0.02997184f, -0.01788197f, -0.00313277f, 0.12908304f, -0.00465018f, 
    -0.17891487f, -0.05363649f, 0.02803083f, -0.06752958f, -0.08842928f, 0.11303256f, 0.01834770f, 0.04883974f, 
    -0.02658600f, -0.00192828f, 0.06331645f, -0.05104867f, -0.00672472f, 0.01219772f, 0.05963661f, -0.00495801f, 
    -0.03663544f, -0.03795144f, -0.08112016f, -0.12093551f, -0.02245152f, -0.00749737f, 0.13019153f, 0.05576362f, 
    -0.05573035f, 0.07782902f, 0.12533478f, -0.11917506f, 0.09831371f, 0.03115769f, 0.07822494f, -0.02992090f, 
    -0.04348362f, -0.21098201f, -0.08678452f, 0.09886174f, -0.07081747f, 0.01149786f, 0.15082468f, 0.08883637f, 
    0.00192104f, 0.03928809f, -0.08297115f, 0.00259658f, 0.13177335f, -0.00132196f, 0.00540621f, -0.00657703f, 
    0.03641821f, 0.07723799f, -0.04986914f, -0.04861502f, -0.00649725f, -0.07754713f, -0.01029840f, 0.00874480f, 
    0.02357598f, 0.03083478f, 0.10851555f, -0.00140206f, -0.04183106f, -0.15291896f, 0.21198307f, -0.03894236f, 
    0.09614895f, 0.16889548f, -0.07328605f, 0.11609266f, 0.06109508f, -0.06901660f, 0.05848955f, -0.02133609f, 
    0.26411462f, 0.25963467f, 0.02082002f, -0.20192792f, -0.04070134f, 0.03753958f, 0.15923391f, -0.01282932f, 
    -0.14044710f, -0.11851370f, 0.05588331f, 0.07434553f, -0.20676558f, -0.12420556f, -0.22812486f, -0.08097616f, 
    -0.01111174f, 0.04885834f, 0.08863774f, -0.02791462f, 0.02961090f, -0.00288663f, -0.03639943f, -0.04943042f, 
    -0.49949664f, -0.00400714f, 0.10827696f, 0.26750886f, -0.05777806f, 0.08732604f, 0.03520056f, -0.18043055f, 
    0.07246537f, 0.13552254f, 0.04271722f, 0.00555209f, 0.06992196f, 0.02409860f, 0.01900837f, 0.12509458f, 
    0.09440330f, 0.02852033f, 0.08932130f, -0.03112694f, 0.08895927f, 0.13388300f, -0.04484100f, -0.04290406f, 
    -0.08101267f, -0.21683870f, 0.03198788f, -0.08057926f, 0.06105891f, 0.00752736f, 0.07410366f, 0.06017319f, 
    0.00182897f, 0.00735324f, -0.01642342f, -0.05485405f, -0.16470979f, 0.01009792f, 0.13830569f, -0.03712520f, 
    0.05400964f, 0.04157466f, -0.07651130f, -0.04338472f, -0.00662101f, -0.09382033f, 0.09528977f, 0.14105859f, 
    0.31298012f, 0.25804248f, 0.11314673f, 0.11883662f, 0.02660828f, -0.00693433f, -0.04841150f, -0.04561463f, 
    -0.06730036f, 0.06240831f, -0.02460875f, -0.00029672f, 0.14121568f, -0.01626283f, -0.03098992f, 0.02114285f, 
    -0.03244334f, 0.08356246f, 0.03193441f, 0.13025625f, 0.10593265f, 0.00455899f, 0.02225677f, -0.00462407f, 
    0.04914187f, 0.15816988f, 0.18414520f, 0.11999816f, 0.04408328f, 0.08681635f, 0.00469977f, -0.04248679f, 
    0.13541766f, 0.08026464f, 0.10269028f, -0.00424411f, -0.07283949f, -0.07156467f, 0.15985331f, 0.26408213f, 
    -0.01618874f, -0.01699845f, -0.11629289f, -0.01500568f, 0.05347350f, -0.05965634f, 0.11037520f, 0.14685108f, 
    -0.02778756f, -0.05807342f, -0.03187612f, 0.03474268f, 0.01126830f, 0.03552578f, 0.15017630f, -0.02699962f, 
    -0.01256836f, 0.05801837f, -0.03119009f, 0.03479884f, 0.37087548f, -0.23217808f, 0.21355905f, -0.44909370f, 
    0.08865503f, 0.15711637f, -0.13851200f, 0.05241879f, 0.02629826f, -0.05680088f, -0.02564635f, 0.05340525f, 
    0.02765882f, -0.05290291f, 0.00155522f, 0.07885188f, 0.06943014f, 0.05404891f, 0.03933756f, -0.05695784f, 
    -0.00672023f, 0.04190739f, -0.19758973f, 0.00621385f, -0.09603330f, -0.12311466f, 0.08919937f, 0.02101639f, 
    -0.11021528f, 0.02194106f, -0.10353016f, -0.08555630f, 0.03818473f, -0.03341150f, -0.06780986f, -0.00227272f, 
    -0.07718571f, -0.09433842f, -0.06921817f, -0.09251581f, 0.09655517f, 0.00335168f, -0.01329525f, 0.13023026f, 
    -0.07966376f, -0.00437107f, 0.02442141f, -0.11761077f, 0.33504200f, -0.14181773f, 0.00543232f, -0.09078575f, 
    -0.05829506f, 0.05764182f, 0.03708290f, 0.03193881f, -0.08771382f, 0.10834965f, 0.07690831f, -0.03244390f, 
    -0.01386698f, 0.01736208f, -0.13881105f, -0.00324875f, -0.05189317f, -0.01678794f, 0.01060885f, -0.01081780f, 
    -0.03782594f, 0.02291081f, 0.03661622f, -0.01393938f, -0.10783614f, -0.12156978f, 0.00982911f, 0.10440344f, 
    -0.03278238f, -0.02699910f, -0.10875116f, -0.13001733f, -0.31548068f, -0.12919456f, -0.29667863f, -0.18055554f, 
    -0.12022620f, 0.27514291f, 0.22769842f, 0.08426050f, 0.04999464f, 0.08275713f, -0.08246369f, -0.01219425f, 
    -0.01044850f, -0.18100297f, -0.22887835f, -0.19765463f, 0.00799703f, 0.09478413f, -0.20525631f, -0.03339592f, 
    -0.13257267f, 0.04241022f, 0.06802565f, 0.02990571f, 0.04342629f, 0.10018919f, 0.09414621f, 0.05226807f, 
    0.25810486f, 0.01991930f, 0.13293448f, -0.08845844f, 0.15314412f, -0.07189597f, -0.04428869f, 0.02024649f, 
    -0.08533169f, -0.15450454f, -0.11383794f, -0.01670583f, -0.04341234f, 0.08945092f, -0.02888602f, -0.07697026f, 
    0.07074024f, 0.09134428f, -0.04712234f, -0.06527933f, -0.09127994f, 0.04601499f, -0.27051175f, -0.15360343f, 
    0.32337511f, -0.09864157f, 0.04689730f, 0.24070047f, 0.00660536f, 0.00374269f, -0.02700214f, -0.00362533f, 
    0.02017420f, -0.08815633f, -0.02373678f, 0.12110012f, 0.04358551f, 0.00967637f, 0.05386280f, 0.11747158f, 
    -0.02734310f, -0.04889061f, 0.02467854f, -0.10386553f, -0.13915092f, -0.12418411f, -0.14698048f, -0.14311142f, 
    0.11098359f, 0.16856788f, 0.06021756f, 0.24264872f, 0.04136893f, 0.01324323f, 0.07765621f, -0.02559401f, 
    -0.06392752f, -0.04396856f, -0.04459962f, -0.10210016f, 0.02515044f, 0.13423593f, 0.00735429f, -0.06987312f, 
    0.04976825f, -0.00053485f, 0.02859325f, 0.10510819f, 0.06085276f, 0.16371927f, 0.11409100f, 0.15496261f, 
    0.15729252f, -0.01327983f, 0.11903287f, 0.12956843f, 0.13042520f, -0.04368250f, 0.00118342f, -0.10756104f, 
    0.03245612f, 0.00474601f, -0.02736023f, 0.14195818f, -0.11060809f, -0.12470165f, -0.05040218f, -0.09405545f, 
    0.00391917f, 0.06035819f, 0.00704746f, -0.11523461f, 0.04109727f, 0.05805979f, 0.15121779f, 0.20462117f, 
    -0.07288573f, 0.00123348f, 0.06810133f, 0.21975239f, -0.00549921f, -0.03045812f, 0.09825239f, -0.08315923f, 
    -0.02100488f, 0.04375105f, -0.02834455f, -0.06598558f, -0.28355819f, 0.00817828f, -0.10702114f, -0.01834085f, 
    -0.16907845f, 0.05497595f, -0.05415483f, -0.09122622f, -0.11754555f, 0.00464324f, -0.07215551f, 0.02250879f, 
    0.07057972f, -0.05508722f, 0.02660400f, 0.01938917f, 0.04960816f, -0.00268332f, -0.04575731f, 0.00132835f, 
    -0.02341641f, -0.08465333f, 0.04519873f, -0.11313990f, -0.18261348f, -0.11000919f, 0.08116860f, -0.04113274f, 
    -0.14227070f, -0.02029983f, 0.06116726f, -0.03330344f, 0.14681934f, 0.13874209f, -0.05067577f, 0.20593314f, 
    0.00747522f, 0.21683349f, 0.21038303f, 0.16956592f, -0.05334660f, -0.06379457f, 0.02125006f, -0.08699131f, 
    -0.04449465f, 0.03341398f, -0.01719069f, 0.02227210f, -0.12558721f, 0.02743187f, -0.00557245f, 0.06198467f, 
    0.16797256f, 0.00751697f, -0.13743976f, 0.05580306f, -0.15421140f, -0.14766590f, -0.03679841f, -0.14131241f, 
    0.08231483f, -0.05169172f, -0.00310505f, -0.03281084f, -0.05269846f, 0.02789569f, -0.09120129f, -0.07530156f, 
    -0.15452576f, -0.14564529f, -0.11884940f, -0.00507543f, -0.23704243f, 0.04523215f, -0.02866131f, 0.08285561f, 
    0.03375380f, 0.01385664f, -0.01986217f, 0.05036592f, -0.00420909f, -0.04385829f, 0.05672982f, -0.06707434f, 
    0.26301274f, 0.07786141f, -0.00261799f, 0.09185565f, 0.07218127f, 0.03454839f, 0.09442986f, 0.00042644f, 
    0.05982453f, -0.03499214f, 0.00892146f, -0.06177536f, -0.00007248f, -0.04914167f, 0.04787061f, -0.02420857f, 
    0.00158710f, 0.00282521f, 0.02717130f, 0.03219248f, 0.05386589f, 0.14733060f, 0.14502029f, 0.18722884f, 
    0.03736105f, -0.03086955f, -0.06942590f, -0.09573787f, 0.02265646f, 0.09111255f, -0.03082025f, 0.04872886f, 
    0.04141491f, -0.20840034f, 0.03434244f, 0.00859223f, -0.01912264f, 0.15139192f, -0.02647832f, 0.22023690f, 
    -0.04506061f, 0.19452420f, -0.10683056f, -0.02500349f, -0.08339059f, -0.13356598f, -0.10284136f, 0.11665502f, 
    0.25268623f, -0.14460665f, 0.01271486f, 0.28791988f, 0.00420229f, 0.02254911f, -0.05888216f, -0.09919209f, 
    0.02843248f, 0.04574942f, -0.07121814f, 0.30300403f, 0.20695664f, 0.14914012f, 0.21163428f, 0.17933679f, 
    -0.05641893f, -0.06991548f, 0.02339622f, 0.01452847f, 0.05477910f, 0.10584323f, 0.00701450f, 0.15057969f, 
    0.38499480f, 0.01405654f, -0.11959288f, -0.10879569f, 0.06806485f, 0.01484737f, -0.15072244f, -0.10759235f, 
    0.05021160f, -0.05675860f, -0.06811354f, -0.03484033f, -0.14968945f, -0.13985169f, 0.05743859f, 0.14108488f, 
    0.03604469f, -0.06378249f, -0.00858810f, 0.15273155f, 0.03516099f, 0.05607024f, 0.00292770f, 0.14894970f, 
    -0.10484280f, -0.03995467f, -0.15863012f, 0.07725321f, -0.08825395f, 0.04018370f, -0.08269384f, -0.25507647f, 
    -0.05915031f, -0.08206656f, 0.00162274f, -0.19988376f, -0.03495077f, -0.07533857f, -0.06891518f, 0.03522082f, 
    -0.02503222f, 0.08667330f, -0.14421865f, 0.03669056f, -0.01118860f, -0.05539302f, 0.03945629f, -0.07607240f, 
    0.06018600f, -0.01643371f, 0.06652004f, -0.06807330f, 0.05544604f, 0.01448851f, -0.05253243f, 0.15999325f, 
    0.13535616f, 0.08619206f, 0.02403238f, 0.07329304f, 0.25758684f, 0.07781114f, 0.02401673f, 0.03730323f, 
    -0.01737994f, -0.09035049f, 0.05899349f, -0.18062849f, 0.11717380f, 0.07498117f, 0.12855831f, 0.33960110f, 
    -0.28157344f, 0.34565032f, 0.23294674f, 0.28374439f, 0.01723530f, -0.05869830f, -0.03854556f, -0.09349763f, 
    -0.11787345f, 0.06142439f, -0.03919004f, -0.06352675f, 0.20586516f, -0.17847593f, -0.04535606f, 0.16793643f, 
    0.00931807f, -0.11746946f, -0.06117646f, -0.09750539f, -0.00915719f, -0.00742501f, 0.11914594f, 0.19291656f, 
    -0.01550360f, -0.10940490f, 0.12973851f, 0.12821527f, -0.04070487f, 0.04426617f, 0.04320270f, 0.06379712f, 
    0.07645715f, -0.01899467f, 0.16002671f, -0.07024331f, 0.03703831f, -0.05015393f, 0.25155210f, 0.14978063f, 
    -0.04455102f, -0.01719522f, -0.05908862f, 0.00398795f, 0.02883522f, -0.02728754f, 0.01872709f, -0.00970519f, 
    -0.08339130f, 0.04914559f, 0.11521731f, 0.22245708f, -0.03566530f, -0.02084617f, -0.02016887f, 0.05617436f, 
    -0.01283743f, -0.03015239f, 0.10206678f, -0.13336594f, 0.04021562f, -0.10935698f, -0.02995110f, 0.04213176f, 
    -0.09860215f, 0.06653636f, -0.08881313f, -0.14753282f, 0.03201572f, -0.00212739f, 0.20696470f, 0.17771150f, 
    0.32561213f, 0.06500918f, 0.06622493f, 0.19422866f, -0.12984516f, 0.12994914f, -0.08971607f, -0.00719487f, 
    0.03658011f, -0.08344867f, -0.05198438f, 0.12863180f, -0.06069147f, 0.03839458f, 0.06180487f, -0.05746029f, 
    0.16121894f, -0.05690055f, 0.13642688f, 0.02771581f, 0.06410178f, -0.08432397f, -0.09762862f, 0.07636961f, 
    0.04162048f, 0.01405090f, -0.16468190f, -0.10013699f, -0.03840905f, 0.05918270f, -0.07491020f, -0.09832829f, 
    0.07281230f, -0.14481343f, 0.02417887f, -0.05362869f, 0.13072674f, 0.09835134f, 0.11103947f, 0.23704089f, 
    0.01252158f, -0.13137193f, 0.03863059f, -0.10644829f, -0.04260791f, 0.04791065f, -0.08595207f, -0.04125542f, 
    -0.02362958f, -0.19092764f, -0.11327454f, -0.09180699f, 0.01626653f, -0.08451983f, -0.05935872f, -0.15316862f, 
    0.06720696f, -0.07816485f, -0.21508573f, -0.07221903f, 0.17876774f, -0.01516366f, 0.01785835f, -0.06258745f, 
    -0.04461407f, 0.11137110f, 0.12170813f, 0.03368901f, 0.23816571f, 0.10820050f, 0.12171477f, 0.20880295f, 
    -0.01989339f, 0.01054421f, -0.21142326f, -0.06485138f, -0.01054225f, -0.09760477f, -0.04490493f, -0.14252360f, 
    0.04856897f, 0.09496816f, 0.01540614f, 0.21000959f, 0.08200261f, -0.15905219f, -0.05200087f, 0.09335597f, 
    0.07088862f, -0.04305296f, 0.00633122f, 0.00686080f, 0.03129964f, 0.05309161f, -0.06790322f, 0.10463204f, 
    -0.10983741f, 0.04664402f, -0.00028776f, -0.05478054f, 0.04437962f, 0.01740384f, 0.04125094f, -0.01214387f, 
    -0.18236861f, -0.21479465f, -0.09672488f, -0.23035726f, -0.03296019f, 0.03983842f, 0.00723177f, -0.01214549f, 
    -0.02240012f, -0.04573203f, 0.05464057f, -0.04211419f, -0.31243178f, -0.05075893f, -0.16517502f, -0.24873787f, 
    0.17173409f, 0.12955289f, 0.10841484f, 0.18432291f, -0.04453737f, 0.03314107f, -0.07188164f, -0.17654954f, 
    -0.12551358f, -0.22998625f, -0.05311032f, -0.09252587f, -0.28211960f, -0.24741711f, 0.04622019f, 0.06641138f, 
    -0.16882648f, 0.11007808f, 0.00714144f, -0.03691193f, 0.08625979f, 0.01816946f, 0.06910634f, 0.11288734f, 
    0.13384031f, 0.00480003f, -0.14047104f, -0.05159060f, 0.05494980f, 0.08516031f, -0.08607970f, -0.09056810f, 
    -0.07221876f, 0.05190304f, -0.00289439f, 0.02361331f, -0.12692535f, -0.05880750f, -0.04008677f, 0.14125112f, 
    0.02710500f, -0.03405746f, 0.01108766f, -0.03752538f, 0.03750038f, 0.01350771f, -0.01955486f, 0.13935760f, 
    -0.03766745f, 0.08767819f, -0.05593403f, 0.25109920f, -0.05108640f, -0.04464800f, -0.10181022f, 0.07007816f, 
    -0.01233257f, 0.19998485f, -0.07278641f, -0.07804796f, 0.09950231f, 0.16795710f, -0.15182997f, -0.19965211f, 
    0.01293100f, -0.08758682f, -0.01546526f, -0.02728766f, -0.07856226f, 0.09114149f, -0.09380908f, -0.11086971f, 
    0.26636457f, 0.23227911f, 0.15170577f, -0.18433473f, 0.04367217f, 0.02814394f, 0.07781751f, -0.01487216f, 
    -0.01466539f, -0.02694523f, -0.05975158f, -0.11134011f, -0.06082905f, -0.02807616f, 0.05369789f, 0.22636127f, 
    0.05955551f, 0.01100990f, -0.01061127f, -0.03315737f, 0.19504599f, 0.18148784f, 0.09528127f, 0.24814020f, 
    -0.11139897f, 0.04282673f, 0.05670091f, 0.23701403f, 0.02048888f, 0.04314684f, -0.03965535f, -0.00295066f, 
    0.03834685f, 0.11965651f, 0.07618888f, 0.17913842f, 0.13314986f, 0.06254791f, -0.19364981f, -0.15994509f, 
    0.10474925f, -0.00655919f, -0.17551093f, -0.01111243f, 0.05246361f, -0.02876978f, -0.02748619f, 0.11834588f, 
    -0.30642956f, -0.03555071f, -0.03174493f, -0.03687642f, 0.03343645f, 0.03595370f, -0.01448086f, 0.02731365f, 
    -0.16407782f, -0.17522651f, -0.19001015f, -0.41726035f, -0.19691904f, 0.14393730f, 0.37172401f, 0.17860319f, 
    0.08757275f, -0.18237363f, 0.12830825f, 0.00380662f, 0.06922787f, 0.04679736f, 0.07998256f, 0.02685841f, 
    -0.08088098f, 0.03155833f, 0.07923325f, 0.06414396f, 0.06824563f, -0.02428010f, 0.01113007f, 0.01309314f, 
    -0.04234365f, 0.08337849f, 0.09177404f, 0.13423052f, -0.12006187f, 0.08877899f, 0.00570873f, -0.01025674f, 
    -0.10618947f, 0.03289317f, -0.01773114f, 0.04762820f, 0.10300022f, 0.20223497f, 0.07314651f, 0.15540029f, 
    0.03907866f, -0.01288862f, 0.10999610f, 0.29428911f, -0.00626253f, 0.21105987f, -0.01745446f, 0.07843573f, 
    0.05068939f, -0.03877664f, 0.03961391f, -0.01897797f, 0.22557440f, -0.00357716f, -0.00751060f, 0.27786022f, 
    0.03061402f, -0.08453029f, 0.05146243f, 0.18623023f, -0.01517452f, 0.06070507f, -0.02422252f, 0.05357759f, 
    -0.07156457f, -0.10007936f, 0.01735701f, 0.17869607f, -0.02389785f, 0.00795621f, 0.01240490f, 0.05613993f, 
    0.10160945f, 0.04501624f, 0.11333339f, 0.11090962f, -0.07961950f, 0.04163612f, 0.07126854f, -0.06004486f, 
    0.09223236f, 0.14711609f, 0.05119126f, 0.16429678f, 0.07981687f, 0.06693996f, 0.17696784f, 0.04284421f, 
    -0.23921213f, -0.07107522f, 0.31887943f, -0.18004654f, 0.18441214f, 0.13819738f, -0.01846977f, -0.11743583f, 
    -0.07223592f, 0.00503719f, -0.05977989f, 0.08575327f, -0.00533591f, -0.11303008f, -0.05381117f, -0.10536523f, 
    0.00492357f, 0.13426244f, -0.12165168f, -0.00524276f, 0.09962478f, 0.06796740f, 0.22251268f, -0.04436889f, 
    -0.08057982f, 0.04708769f, -0.05528408f, -0.02699024f, 0.01414341f, -0.03610356f, 0.03714575f, -0.01357136f, 
    0.11353067f, 0.08771321f, 0.16382405f, -0.00616298f, 0.00872783f, 0.04548816f, 0.06042556f, 0.15403463f, 
    0.06452488f, 0.07071621f, 0.02088661f, 0.06601976f, -0.07300366f, -0.03624803f, 0.03190499f, 0.04774758f, 
    -0.01785987f, -0.05659777f, 0.01487312f, -0.07888814f, 0.08825998f, -0.10239163f, 0.16950211f, -0.00129661f, 
    0.09455685f, 0.02906144f, 0.07019319f, -0.06827046f, -0.19321786f, 0.05844608f, 0.00424752f, -0.02509017f, 
    -0.00540969f, -0.01130712f, 0.05713612f, 0.05776691f, 0.00414168f, 0.13075419f, -0.05934945f, -0.11778358f, 
    0.00085885f, -0.02671387f, 0.16263489f, 0.05738481f, 0.08046357f, 0.01000735f, 0.06638491f, -0.14514716f, 
    0.05647340f, -0.02051868f, 0.04565085f, -0.05306786f, 0.02770950f, 0.01000693f, 0.04864293f, -0.06715151f, 
    -0.10853973f, -0.00320591f, -0.02028663f, -0.05365031f, 0.10595823f, -0.00441138f, -0.01108397f, -0.00254340f, 
    -0.05297023f, -0.17531569f, -0.13999116f, 0.06229875f, 0.01276939f, 0.06057771f, 0.04370162f, 0.07379227f, 
    -0.06352304f, -0.00096217f, -0.05773377f, -0.06317141f, 0.12166597f, 0.08421618f, -0.05462998f, -0.05416281f, 
    -0.07311330f, -0.04914954f, -0.04557657f, -0.01791888f, 0.08417552f, 0.02128977f, -0.01960610f, -0.01711608f, 
    -0.19442168f, -0.10957094f, -0.11622344f, 0.09296300f, -0.10243060f, 0.03422638f, 0.00806104f, 0.09629080f, 
    -0.04064242f, -0.04748592f, 0.03076364f, 0.04577454f, 0.08905480f, 0.22964092f, 0.20385127f, -0.11052542f, 
    0.08967172f, 0.00287444f, 0.13270351f, 0.17491582f, 0.00117558f, 0.08619238f, 0.00330907f, -0.12048534f, 
    -0.23686790f, -0.12572427f, -0.04717160f, 0.13842137f, -0.08210624f, 0.01455305f, -0.01083187f, -0.03514162f, 
    -0.05964923f, -0.10425721f, -0.10870762f, -0.07617701f, -0.02595181f, 0.12336042f, -0.11277863f, 0.09265801f, 
    0.06739035f, 0.06253663f, 0.05511459f, 0.11568522f, 0.01530872f, -0.02800212f, -0.06477661f, -0.08893583f, 
    -0.22982326f, 0.12122060f, 0.11558242f, 0.03072911f, -0.22074194f, -0.00966210f, 0.09330337f, 0.17244773f, 
    0.10151222f, 0.15026808f, -0.03838813f, -0.17240085f, 0.19830000f, 0.19270574f, 0.04220303f, -0.16036043f, 
    -0.05393165f, -0.06488483f, 0.04419291f, 0.02386560f, 0.02897580f, 0.01948751f, -0.00175356f, 0.06479107f, 
    -0.00067042f, -0.13052236f, -0.22923666f, 0.12896086f, 0.06823154f, 0.04836211f, 0.03034207f, 0.01457386f, 
    -0.06984171f, 0.16212939f, 0.11222928f, 0.03246394f, 0.40840709f, -0.02009036f, 0.44181648f, -0.01490930f, 
    -0.02356540f, -0.01881967f, -0.09096830f, 0.06520598f, -0.04906286f, 0.05723136f, -0.01791411f, -0.11219919f, 
    -0.03215588f, -0.02237351f, -0.13014305f, -0.22754763f, -0.08034882f, -0.06880679f, -0.02772622f, -0.03912444f, 
    0.00200560f, 0.08454959f, 0.10812522f, 0.05930386f, -0.21223894f, -0.02031957f, 0.10897370f, -0.04543646f, 
    0.03726506f, -0.03195709f, -0.09684966f, 0.02386219f, 0.01041209f, -0.09180124f, 0.08178549f, 0.01975422f, 
    0.35852256f, 0.05915900f, 0.24575068f, -0.11344835f, -0.00520878f, 0.07709125f, 0.06078834f, -0.05478041f, 
    -0.11734707f, 0.00269739f, 0.06018110f, -0.11633962f, 0.03295984f, 0.00228133f, 0.09460956f, -0.03499560f, 
    0.10274171f, 0.11696192f, 0.08658234f, -0.02820268f, 0.04933595f, 0.13344432f, -0.10783610f, 0.13757944f, 
    0.02209424f, 0.09377071f, 0.06191710f, 0.08770265f, 0.04015764f, -0.13189107f, 0.19787267f, 0.07464090f, 
    0.00280096f, -0.02286965f, -0.03087989f, 0.04779845f, -0.19686900f, 0.06685279f, 0.08593151f, -0.02194884f, 
    -0.15687428f, -0.03135942f, 0.03941929f, 0.12204649f, 0.12208611f, 0.06491186f, -0.11894295f, -0.06693286f, 
    -0.08966056f, 0.06977988f, -0.01389276f, 0.15962093f, -0.00443292f, 0.04528170f, 0.10621060f, 0.14755447f, 
    0.10462628f, 0.06610844f, 0.14443846f, 0.02266475f, -0.22803394f, 0.00274154f, 0.03903275f, 0.00076182f, 
    -0.09382338f, -0.12580822f, -0.01508428f, 0.08759550f, -0.02075837f, 0.06125802f, 0.00729220f, 0.03551396f, 
    0.36188552f, 0.03582896f, 0.03131211f, -0.14612809f, 0.00009823f, 0.00527615f, -0.02160573f, 0.04240151f, 
    -0.08822961f, 0.12058064f, 0.14189532f, 0.06190993f, -0.16678670f, -0.22469649f, -0.09312153f, 0.02136694f, 
    0.00211885f, 0.00828187f, 0.02209108f, 0.04315652f, -0.04325578f, -0.09135938f, -0.08629639f, -0.01654337f, 
    -0.19961485f, -0.16093698f, 0.19396709f, 0.12453271f, 0.04285737f, 0.02455086f, -0.03707330f, -0.11641582f, 
    -0.02124001f, -0.02501665f, -0.05194587f, -0.00851339f, 0.22636671f, -0.08360859f, 0.00151532f, 0.08817568f, 
    0.01128904f, 0.03930425f, 0.12675175f, 0.02915335f, 0.02685807f, 0.16155425f, -0.02591161f, -0.07712673f, 
    0.43127415f, -0.18981332f, 0.24466202f, -0.14603949f, 0.05327113f, 0.00919092f, -0.08835540f, 0.21618535f, 
    -0.09203300f, 0.02312358f, 0.08773777f, -0.04642431f, -0.06796743f, 0.01196569f, 0.09466286f, 0.06784403f, 
    0.03538192f, -0.03936254f, 0.20722237f, 0.04612998f, 0.06470153f, 0.18364179f, 0.02230691f, -0.15094313f, 
    -0.15296414f, -0.09679654f, 0.05846368f, 0.00596930f, 0.04867311f, 0.14005224f, -0.15216006f, -0.03461289f, 
    0.07889312f, -0.00388091f, -0.07183518f, -0.00848607f, -0.28569391f, 0.02381205f, 0.14313160f, 0.06792075f, 
    -0.05409032f, -0.03585824f, 0.03634783f, 0.14636785f, 0.03537495f, 0.04263734f, 0.10452462f, -0.00376092f, 
    -0.29082146f, -0.19562173f, 0.00868015f, -0.03326108f, 0.09528095f, 0.12977357f, -0.10992231f, -0.02646491f, 
    0.04080720f, 0.04436190f, -0.00247661f, 0.09076787f, 0.19961928f, 0.00265611f, -0.07542420f, 0.01160355f, 
    -0.11333326f, 0.00805586f, -0.13807744f, 0.01285155f, 0.01289861f, -0.01193166f, 0.16182859f, 0.10464858f, 
    0.06337454f, -0.11104366f, 0.15096383f, -0.07975639f, 0.08595711f, -0.02139524f, 0.14996344f, -0.16037506f, 
    -0.01041412f, 0.04781577f, 0.13312420f, 0.10317894f, -0.01407978f, 0.15352845f, 0.20019050f, -0.12517145f, 
    -0.08525927f, 0.02522641f, -0.05666541f, 0.00610521f, -0.13874911f, -0.06329186f, -0.02627255f, -0.03462427f, 
    0.26936513f, 0.09515616f, 0.06740031f, 0.06907508f, 0.00529152f, 0.03624085f, 0.07870269f, 0.03780295f, 
    -0.04154645f, 0.09478386f, 0.01434225f, -0.06344087f, -0.10670616f, -0.06427903f, 0.03149620f, -0.09191634f, 
    -0.16132681f, -0.04553032f, 0.01180128f, 0.05017113f, -0.00429990f, 0.00455430f, 0.03755250f, -0.04970361f, 
    0.12208173f, -0.03924347f, -0.02355119f, 0.13636245f, 0.24015133f, 0.10629566f, 0.06680763f, 0.24505509f, 
    -0.01056276f, 0.07359416f, 0.11201232f, 0.00589862f, 0.01497863f, -0.00827010f, -0.17523356f, -0.09546237f, 
    -0.02244741f, -0.04800504f, -0.00985443f, -0.00401347f, -0.08791986f, -0.00665138f, -0.03640930f, -0.04633097f, 
    0.17870763f, 0.09141510f, -0.08164927f, -0.03942191f, -0.09368098f, -0.01873920f, -0.09007064f, 0.16620365f, 
    0.14810707f, 0.11980096f, 0.15284799f, -0.01486715f, -0.13797413f, -0.09433022f, 0.04454520f, -0.06760602f, 
    -0.08911196f, -0.13778895f, 0.06364387f, 0.15718731f, -0.02165243f, -0.02157130f, -0.01912914f, -0.04450576f, 
    0.02132607f, 0.00501389f, 0.02113983f, -0.07433016f, -0.07525977f, 0.12924093f, -0.04838649f, 0.09470145f, 
    0.00899770f, 0.01308135f, 0.12496493f, -0.00640245f, -0.13656254f, 0.28158388f, -0.01540306f, 0.13902405f, 
    -0.00322917f, 0.04798736f, 0.14549263f, -0.00490211f, -0.05592591f, 0.11787395f, -0.00282896f, 0.05423723f, 
    -0.19932412f, -0.00183278f, -0.02100911f, 0.06132654f, -0.06115115f, -0.10743988f, 0.07544074f, 0.02600796f, 
    0.02806719f, 0.18309774f, 0.04013480f, -0.03573999f, 0.31844199f, 0.08378393f, 0.09522499f, -0.11101689f, 
    -0.03058713f, -0.05767862f, 0.00094854f, -0.00671329f, -0.07643901f, 0.01110535f, 0.02093267f, -0.10270032f, 
    -0.13358691f, -0.27406591f, -0.15639281f, 0.18059294f, -0.01511990f, 0.12248094f, 0.04441890f, 0.15240666f, 
    0.00521533f, 0.04099606f, 0.04120281f, -0.04480776f, -0.19537881f, -0.11678217f, 0.01207127f, -0.03735978f, 
    -0.03668743f, -0.03616939f, -0.04506034f, 0.05042708f, 0.09069476f, 0.08140001f, 0.11114687f, 0.00486034f, 
    -0.14012100f, 0.12530042f, 0.05054181f, 0.16665101f, 0.06510109f, 0.16976829f, 0.08553657f, -0.07031018f, 
    -0.01798676f, -0.01966425f, 0.08833221f, -0.04541606f, 0.00153402f, 0.08455165f, -0.11697676f, 0.07336171f, 
    -0.06236584f, 0.08954478f, 0.02355835f, 0.14414699f, 0.13706410f, 0.14317800f, 0.09188309f, 0.03230471f, 
    -0.25120580f, -0.02850819f, -0.11362569f, -0.12134759f, -0.09418748f, -0.08895008f, -0.07233837f, 0.04176079f, 
    0.11917633f, 0.06405180f, 0.12036896f, 0.08300260f, -0.11450655f, -0.04864987f, -0.10694247f, 0.02203762f, 
    0.02910254f, -0.03574639f, -0.01307923f, -0.00975984f, 0.06806597f, 0.03827932f, -0.00054102f, 0.04797575f, 
    -0.08617391f, -0.12346859f, -0.05347448f, -0.01953507f, 0.01867873f, -0.03775836f, 0.04653122f, 0.01942106f, 
    0.08712346f, 0.13042998f, 0.02122791f, -0.02304680f, -0.18609862f, -0.09348888f, 0.15637702f, 0.27288821f, 
    -0.00327207f, 0.04961494f, 0.02431274f, 0.14357078f, -0.05822061f, 0.02562058f, -0.01495330f, -0.15412676f, 
    0.13346794f, -0.06539506f, 0.08005254f, -0.02771645f, 0.08871612f, 0.16138066f, 0.01528389f, 0.13247906f, 
    0.04789650f, 0.03709195f, 0.06806325f, 0.03055294f, -0.29708242f, 0.38644236f, 0.13058457f, 0.21679065f, 
    -0.12166027f, 0.25173739f, 0.01078924f, 0.15277413f, -0.07386495f, -0.01039791f, 0.09745698f, 0.05264304f, 
    -0.11793833f, 0.04131748f, 0.10941660f, 0.05330957f, 0.07329465f, 0.06211452f, -0.00639134f, 0.06660104f, 
    0.09613290f, 0.04077595f, 0.09483746f, 0.03647964f, -0.16805822f, 0.06625283f, -0.07940888f, 0.16008222f, 
    0.14277934f, 0.09448779f, 0.05389931f, 0.05441260f, -0.05014873f, 0.11003127f, 0.11152440f, 0.11800416f, 
    0.18741983f, 0.03829244f, 0.01782223f, 0.11757931f, 0.09136413f, 0.11168774f, 0.06617576f, -0.09513593f, 
    0.00751658f, -0.02016219f, -0.06626379f, 0.10860870f, 0.20276746f, 0.03140480f, 0.20333709f, -0.09210880f, 
    -0.07470034f, 0.01369007f, -0.06323242f, 0.07489177f, 0.00817424f, -0.00445315f, 0.07303626f, -0.03268710f, 
    0.13251916f, -0.02845412f, -0.03207999f, 0.10203339f, 0.07640376f, 0.00668932f, 0.04589922f, 0.01483571f, 
    0.12670529f, -0.01674623f, 0.00680365f, 0.01870655f, -0.09998976f, 0.12558816f, 0.10164706f, -0.08693634f, 
    -0.02127161f, 0.03900779f, -0.13475902f, -0.04558520f, 0.02134811f, -0.03834256f, 0.09271965f, 0.11835506f, 
    -0.26571208f, 0.43110743f, 0.10908523f, -0.22361337f, -0.05519738f, 0.05328166f, -0.12542185f, 0.13660094f, 
    0.02187472f, -0.01161909f, -0.08187938f, 0.01504497f, 0.22683378f, 0.00610633f, -0.14101765f, -0.05348497f, 
    0.28313869f, 0.01789753f, -0.04786630f, -0.06070088f, 0.09527498f, -0.00722443f, 0.04815079f, 0.03713997f, 
    0.04326225f, 0.16289648f, -0.02994115f, -0.00193789f, -0.22777611f, -0.00572789f, -0.10453303f, -0.06735906f, 
    -0.00862939f, 0.03142301f, 0.08540770f, -0.07227391f, 0.12459023f, 0.15191440f, -0.04181833f, -0.03480777f, 
    0.07091263f, -0.03130716f, 0.03233312f, -0.00317765f, 0.00661271f, -0.02100141f, 0.03694534f, 0.02955698f, 
    -0.09848284f, 0.06296054f, -0.16062653f, -0.03412231f, 0.08102638f, 0.07224496f, 0.15008147f, 0.05760326f, 
    0.03148621f, 0.06303529f, 0.08174849f, 0.00093998f, -0.11430473f, -0.13555676f, -0.10713896f, -0.11402962f, 
    -0.00901287f, 0.11887620f, -0.05723431f, 0.01807740f, 0.03826167f, -0.01625436f, -0.02894315f, 0.05736355f, 
    0.11642628f, 0.21298549f, 0.20517856f, 0.10585800f, -0.08317654f, -0.04388604f, 0.01931072f, 0.10203662f, 
    0.06537358f, -0.00263094f, 0.01813104f, -0.01598068f, -0.12174962f, 0.11991225f, 0.04926052f, 0.19690214f, 
    -0.05584066f, -0.01946496f, -0.07520622f, 0.08783326f, 0.03260432f, 0.00536790f, 0.01332380f, -0.03401627f, 
    0.31801921f, -0.18369995f, -0.12183850f, -0.08723303f, 0.17977871f, 0.06145466f, 0.07640861f, 0.20214668f, 
    -0.02301777f, -0.01197692f, 0.03347477f, -0.03281536f, 0.02069305f, 0.07291943f, 0.18399478f, 0.05190403f, 
    -0.04266835f, -0.08515973f, -0.13323882f, -0.09548172f, -0.02832830f, -0.05867229f, 0.02873792f, 0.08917725f, 
    -0.09645298f, -0.26664460f, -0.03809746f, -0.00323241f, 0.04126015f, 0.01099151f, -0.03470226f, 0.12492572f, 
    -0.05133024f, -0.05622390f, 0.13721791f, 0.24119706f, -0.28412211f, 0.17062300f, 0.18937503f, -0.12034520f, 
    -0.06643375f, -0.06651819f, 0.13174754f, 0.01107697f, 0.08828949f, 0.11981712f, -0.04774191f, -0.03083668f, 
    0.11081804f, -0.10550106f, -0.10487562f, -0.07941007f, 0.20285647f, 0.09294159f, 0.07597210f, 0.05338756f, 
    -0.02713517f, -0.03845619f, -0.00054651f, 0.01035594f, 0.04133408f, 0.02744159f, 0.03828064f, -0.00185424f, 
    -0.02640600f, 0.02304234f, 0.10363195f, 0.00786190f, -0.12121487f, 0.08833397f, 0.00623541f, 0.04756264f, 
    -0.11859811f, -0.48069739f, -0.26334453f, -0.17127307f, 0.04322688f, -0.07192642f, 0.02262080f, 0.06776039f, 
    -0.06373087f, -0.06155499f, 0.03707386f, 0.02730573f, -0.06570461f, 0.29834619f, 0.00739753f, 0.18209578f, 
    -0.05501445f, -0.01741425f, -0.10965129f, -0.08294903f, -0.01279695f, -0.03896414f, -0.01758069f, 0.16275190f, 
    0.46159312f, -0.16854757f, 0.28423953f, -0.07374918f, 0.07863782f, 0.04355456f, -0.01644643f, 0.07408332f, 
    0.03178483f, 0.04574459f, 0.06076154f, 0.00996347f, 0.05030716f, 0.20151582f, 0.30254808f, 0.11717724f, 
    -0.00173892f, -0.00310574f, -0.07457258f, -0.02570573f, 0.02843185f, -0.03811142f, 0.00886712f, 0.04437955f, 
    -0.01097077f, -0.05365193f, -0.16647920f, -0.07362819f, -0.07999973f, -0.02745081f, 0.01153096f, -0.10043807f, 
    -0.03969955f, -0.01299023f, 0.23269597f, 0.21506561f, -0.09319936f, -0.03402408f, -0.07929072f, -0.08263364f, 
    0.01197934f, -0.02251876f, 0.07832529f, 0.02616381f, -0.04772655f, -0.03441571f, 0.09381003f, 0.00006159f, 
    -0.00247580f, 0.04431065f, 0.13439913f, 0.16066605f, -0.05265392f, -0.01212736f, 0.07106570f, 0.01648639f, 
    -0.07930340f, 0.03150863f, 0.04618762f, 0.00823694f, 0.05755493f, 0.08619171f, -0.02128970f, 0.02855186f, 
    0.10449893f, 0.01148674f, 0.01936567f, -0.08085105f, 0.07288722f, 0.03627428f, 0.08570826f, 0.19664568f, 
    -0.24985632f, -0.14874876f, -0.00379860f, -0.06148824f, -0.02797540f, 0.10025793f, 0.04959184f, 0.22080867f, 
    0.08207253f, 0.03026955f, 0.00529555f, 0.09136116f, -0.06786523f, -0.40820652f, -0.34385893f, -0.18463112f, 
    -0.00191256f, -0.05239251f, -0.05563978f, 0.08342934f, 0.15131727f, 0.00558427f, 0.03870296f, 0.09079986f, 
    0.25560439f, -0.06474730f, -0.13860147f, -0.06293244f, -0.06973232f, -0.03989493f, -0.10924391f, -0.08270077f, 
    -0.01586039f, -0.03571287f, 0.10567990f, -0.05661329f, -0.03814033f, 0.08756404f, -0.08099151f, -0.12947200f, 
    -0.09710611f, -0.06329789f, 0.07051354f, 0.12640911f, -0.00317690f, -0.02362790f, 0.03382602f, 0.10213389f, 
    0.15989237f, 0.02779149f, 0.13895795f, -0.08355363f, 0.01954048f, -0.07756799f, -0.03846375f, -0.12426411f, 
    -0.02133805f, 0.03395708f, 0.07625411f, 0.02280200f, 0.04588716f, -0.07086854f, 0.06158183f, -0.13042717f, 
    0.12295474f, 0.09648310f, 0.03009477f, 0.02239718f, 0.04682851f, -0.05390127f, 0.09467927f, 0.01657369f, 
    0.18506812f, 0.12706850f, -0.05600220f, -0.17297737f, 0.30164176f, 0.10843197f, 0.13412015f, 0.12128457f, 
    0.05536130f, -0.15691966f, 0.02415390f, -0.04651053f, -0.21341214f, -0.14446416f, 0.23666948f, 0.09170326f, 
    -0.06387758f, 0.19997236f, 0.17803429f, 0.15020685f, 0.01913164f, 0.00355090f, -0.05296129f, -0.22425325f, 
    -0.33524308f, 0.14892910f, 0.16519247f, 0.26393241f, 0.13370925f, -0.04446978f, 0.01089967f, 0.13999401f, 
    -0.07030422f, 0.01177038f, 0.08092018f, -0.00932339f, -0.09317112f, 0.23430853f, -0.23340677f, -0.02089472f, 
    -0.07015306f, 0.00895568f, 0.21428737f, 0.16880344f, 0.00108470f, 0.05640453f, -0.07715665f, 0.01579126f, 
    0.18769476f, 0.00356443f, 0.14702857f, -0.01509033f, 0.14809200f, 0.04681345f, -0.00020484f, 0.15149145f, 
    0.12207960f, 0.02263704f, -0.06756686f, -0.02238105f, -0.02467049f, -0.29350212f, -0.39244783f, -0.33901608f, 
    0.05228992f, 0.01716314f, 0.04837213f, 0.09607266f, -0.00742841f, -0.05166650f, 0.06914567f, 0.06351537f, 
    -0.09503883f, -0.01533013f, 0.20856515f, -0.08773752f, 0.11263654f, 0.06687033f, 0.02891023f, -0.04502765f, 
    0.00863647f, 0.01993920f, -0.03582586f, 0.01794534f, 0.09560970f, -0.08737081f, 0.18700087f, 0.02515721f, 
    0.03638669f, -0.02710282f, 0.01686242f, -0.10824984f, 0.13579358f, -0.07010890f, 0.14432283f, 0.00506666f, 
    0.00014704f, -0.35164109f, -0.19360754f, -0.08301657f, 0.05997919f, 0.01773638f, 0.08146521f, -0.08308405f, 
    0.01251370f, 0.05041692f, 0.12804846f, 0.01404925f, -0.01594606f, 0.19792289f, 0.19361648f, 0.12614816f, 
    -0.14403041f, -0.04613994f, -0.09788340f, -0.00486068f, 0.00723784f, 0.00401198f, 0.01190460f, -0.08289294f, 
    0.05434408f, 0.13071261f, 0.09302366f, -0.02267461f, -0.02098439f, -0.05689690f, -0.01525509f, -0.04877057f, 
    -0.03572615f, 0.03408075f, -0.07397866f, 0.16292249f, -0.15974648f, -0.16011980f, -0.21999866f, 0.06735381f, 
    0.04720938f, 0.06724481f, 0.08668846f, 0.13943809f, 0.14287251f, -0.00398464f, 0.09145165f, 0.05867723f, 
    0.16368967f, 0.03727920f, -0.00908500f, -0.22072215f, 0.21323761f, -0.00774385f, 0.01588162f, -0.02544648f, 
    -0.04168008f, 0.08795258f, -0.06437378f, 0.08206297f, 0.00838931f, 0.00360517f, 0.07913675f, -0.08027964f, 
    -0.09078071f, -0.02362999f, 0.04925121f, 0.03112522f, -0.01293509f, 0.05317226f, -0.06718389f, 0.04572096f, 
    0.14813237f, -0.13297649f, 0.16217294f, 0.11414417f, 0.04320388f, 0.03640419f, -0.02998590f, -0.09802891f, 
    0.07402186f, 0.17237931f, -0.07589483f, -0.26344156f, 0.11994135f, 0.08044535f, -0.10893876f, -0.07870722f, 
    0.11208408f, -0.08853277f, 0.13723367f, 0.16379303f, -0.03560722f, 0.04999787f, 0.05986682f, -0.04261250f, 
    -0.02189537f, -0.01445994f, -0.04215258f, 0.16458663f, -0.01872477f, -0.01162447f, -0.08041748f, -0.09614235f, 
    -0.03046914f, -0.01596602f, 0.09051531f, 0.05209368f, 0.05135705f, 0.28685465f, -0.17720371f, -0.04310104f, 
    -0.00745524f, -0.08674928f, 0.11779255f, -0.01051156f, 0.01012876f, 0.04167128f, -0.04031453f, 0.08999991f, 
    -0.12642615f, -0.21491836f, -0.10980681f, -0.02015692f, -0.12313486f, 0.14207710f, -0.07329968f, -0.05337534f, 
    0.13011156f, 0.07986714f, 0.01989090f, 0.06820394f, 0.10167461f, 0.12103910f, 0.27910134f, 0.12730135f, 
    0.03156291f, -0.06247321f, -0.13776565f, -0.10594364f, -0.01265391f, -0.07475206f, 0.02290920f, -0.03278836f, 
    0.61568207f, 0.08603756f, 0.28304484f, -0.17424814f, 0.22877303f, 0.00142084f, 0.01180856f, 0.07545564f, 
    0.07380573f, -0.02247420f, -0.00360597f, -0.00192014f, -0.10861330f, -0.07091670f, 0.11328851f, -0.10097656f, 
    0.07437234f, 0.04708463f, -0.00321064f, 0.05349510f, 0.14212890f, 0.05105686f, -0.02483102f, -0.00523842f, 
    0.10495619f, 0.03321016f, 0.15129358f, 0.03766187f, 0.15904060f, 0.15811446f, 0.11633016f, 0.10998143f, 
    -0.01826019f, 0.02755564f, 0.08451770f, 0.16706359f, 0.27262339f, -0.06720465f, -0.17097762f, -0.11180714f, 
    0.05221866f, -0.11426500f, 0.02526652f, -0.13339087f, -0.00978304f, 0.01080955f, 0.05909091f, 0.00796278f, 
    0.22352059f, -0.01652499f, -0.12955664f, -0.23030645f, -0.07026367f, -0.01530590f, -0.03090479f, -0.20008425f, 
    0.04731294f, -0.05079972f, 0.17442116f, 0.09167526f, 0.05175499f, 0.01675331f, 0.17540485f, 0.04337652f, 
    0.04371643f, 0.02845323f, 0.08891870f, 0.07112464f, -0.04723234f, 0.04011355f, -0.00501671f, 0.06402464f, 
    0.02224619f, -0.18878815f, -0.05384309f, 0.10167543f, 0.08808442f, -0.04002020f, -0.09807944f, 0.08882210f, 
    -0.02633766f, -0.04869915f, -0.05294641f, -0.02329091f, 0.38751671f, 0.06712384f, 0.03098246f, -0.24158314f, 
    0.09397753f, 0.13966359f, 0.17967476f, 0.07414541f, -0.01056761f, 0.01668824f, 0.03396066f, -0.06449335f, 
    -0.19573548f, 0.05559491f, -0.03098339f, 0.01575316f, 0.04200701f, -0.00820598f, -0.07063475f, -0.10489358f, 
    -0.00954013f, 0.02790408f, -0.03609020f, 0.02487153f, 0.02314126f, 0.33729970f, 0.06317104f, 0.47162682f, 
    -0.08304094f, 0.08966080f, 0.22672763f, 0.34368685f, -0.00625119f, 0.07157726f, 0.05961565f, 0.07077125f, 
    -0.05111145f, 0.14990686f, 0.02504557f, 0.02003917f, -0.00927899f, -0.02311275f, -0.01812404f, 0.13649462f, 
    0.01073234f, -0.11179046f, 0.09854644f, -0.14975761f, 0.16320975f, 0.09667061f, 0.05109178f, -0.08278214f, 
    0.24314821f, 0.02723538f, 0.06652391f, -0.05877959f, 0.09521919f, 0.03074932f, 0.07605050f, 0.07368232f, 
    0.00380465f, -0.02977335f, -0.00522421f, -0.01425925f, -0.01073875f, -0.01679812f, 0.01351168f, -0.03570097f, 
    -0.03440520f, 0.00408737f, 0.02646052f, 0.00122249f, 0.01603118f, 0.00154491f, -0.01721393f, 0.01424607f, 
    0.01979565f, -0.03058357f, 0.01131916f, -0.00099100f, -0.01499531f, 0.01488682f, 0.00702491f, -0.01055870f, 
    0.01238211f, 0.01286644f, -0.03430808f, -0.02787289f, -0.02301347f, -0.03649772f, -0.01186540f, 0.00081357f, 
    0.00745365f, 0.02525745f, 0.00062447f, -0.04243294f, -0.01144045f, -0.01003726f, -0.03002114f, 0.02832665f, 
    0.00953859f, 0.00651940f, 0.02054611f, -0.01764557f, 0.01141698f, 0.02605322f, 0.02460513f, 0.03036276f, 
    -0.01377057f, -0.02861899f, -0.03481723f, 0.02063565f, -0.03047838f, 0.00608703f, -0.00240750f, -0.02025321f, 
    -0.03811498f, -0.01900129f, 0.02358092f, 0.00495470f, 0.01814505f, -0.01956094f, 0.01046832f, -0.03864151f, 
    0.00761378f, -0.03007390f, 0.00503083f, 0.01162769f, -0.03897623f, 0.02566122f, -0.03825038f, 0.02217923f, 
    -0.00167383f, -0.03172139f, 0.01498232f, -0.01692351f, -0.01543296f, -0.02368852f, -0.02459352f, 0.00100083f, 
    0.02522252f, -0.03521071f, -0.02616970f, 0.03427441f, -0.02988786f, -0.03627836f, -0.00318599f, -0.02693266f, 
    0.00706437f, 0.01983535f, 0.00683174f, -0.00721914f, 0.01935213f, 0.00773483f, -0.01863008f, -0.03119143f, 
    -0.00606099f, -0.00993688f, -0.02861297f, -0.02236400f, -0.03149363f, -0.03379096f, 0.02190031f, 0.02481216f, 
    0.01668229f, -0.01787275f, -0.00139152f, -0.03619213f, 0.01386817f, -0.01089309f, 0.00425190f, 0.02033537f, 
    -0.03871374f, 0.02423337f, 0.00332362f, -0.00187262f, -0.02044750f, 0.01678217f, -0.03448397f, 0.02088581f, 
    0.00429292f, -0.00890714f, 0.00938262f, -0.03677629f, 0.02375617f, -0.03533459f, -0.00148706f, -0.03648224f, 
    -0.00910611f, -0.02569991f, -0.00592558f, -0.00186856f, 0.01996172f, 0.01451014f, -0.03230374f, -0.01462926f, 
    -0.04388890f, -0.02231522f, -0.01609349f, -0.00114361f, 0.03436789f, 0.01778721f, -0.01902907f, -0.02391916f, 
    -0.02800213f, -0.01658871f, -0.03541243f, 0.01918134f, -0.00512568f, -0.03167816f, -0.01154548f, 0.02127605f, 
    0.00641737f, -0.00916859f, -0.00641747f, -0.04059159f, -0.03642481f, 0.02674832f, -0.00880989f, -0.00897984f, 
    -0.01978867f, 0.00497744f, -0.03270750f, -0.02282269f, 0.02600693f, 0.01318133f, -0.00406692f, 0.02908942f, 
    0.02399292f, -0.02906190f, 0.00126989f, -0.01882456f, 0.01606572f, -0.02710718f, 0.00313792f, 0.01989638f, 
    0.00095403f, -0.04050805f, -0.01124182f, -0.03719953f, 0.02532123f, 0.02218482f, 0.01021316f, 0.02465286f, 
    0.02387221f, 0.01835110f, -0.02879949f, -0.01309026f, -0.01585645f, 0.00624468f, 0.02809212f, -0.01038668f, 
    0.02082216f, 0.02019757f, -0.02975679f, -0.01416693f, -0.03445771f, 0.02846053f, 0.01891620f, 0.02797582f, 
    -0.02350346f, -0.02433337f, -0.01487217f, 0.00389116f, -0.02384544f, 0.00145251f, 0.00805244f, 0.01895864f, 
    -0.02734560f, -0.00241249f, 0.01817317f, 0.00661745f, -0.02122402f, 0.00177741f, 0.00343449f, -0.02379894f, 
    -0.00147540f, -0.04048491f, -0.03185362f, -0.04520433f, 0.02348695f, -0.03341545f, -0.04252234f, 0.01668286f, 
    -0.01417663f, -0.02152954f, 0.00065932f, 0.02530641f, 0.02343794f, -0.00081615f, 0.02046134f, 0.02952572f, 
    0.00264563f, 0.02354364f, -0.00032340f, -0.01390718f, -0.00852784f, 0.01448553f, 0.00003016f, 0.01344097f, 
    -0.03853140f, -0.03259451f, 0.01833245f, -0.02151690f, -0.02991563f, -0.03619954f, -0.00454810f, 0.01083315f, 
    -0.02124803f, -0.02724073f, -0.00707671f, -0.03865339f, 0.00901522f, -0.03307570f, -0.03699159f, 0.02961617f, 
    0.01881344f, -0.03953736f, -0.03857437f, -0.02081478f, 0.00559101f, -0.02745700f, 0.02832687f, 0.03122821f, 
    -0.02271906f, -0.01347532f, 0.00685111f, 0.01592789f, -0.01273871f, 0.00574965f, -0.01370590f, -0.00915620f, 
    0.01253862f, -0.00732312f, 0.00572624f, 0.02351217f, 0.00568416f, -0.02084927f, 0.02191948f, 0.01435721f, 
    -0.01327672f, -0.01411419f, 0.01851767f, 0.02069834f, -0.03803948f, -0.01912914f, 0.02720468f, -0.00402209f, 
    -0.03464326f, -0.03474747f, -0.02282455f, -0.01254665f, 0.00441765f, -0.02440483f, 0.01361464f, -0.03018979f, 
    -0.04079036f, 0.02419940f, 0.01777908f, 0.01731319f, -0.02031026f, -0.01348385f, 0.02900010f, -0.03017313f, 
    -0.02653776f, -0.02425952f, -0.03096706f, -0.01061675f, 0.01328474f, 0.01519913f, -0.04573397f, -0.01526594f, 
    -0.04200855f, 0.01666533f, -0.04171527f, 0.01122811f, -0.04080505f, -0.03364816f, 0.00819879f, -0.03073476f, 
    -0.01412256f, 0.02396770f, -0.01881580f, -0.04254080f, 0.02493902f, -0.00778538f, -0.03492239f, 0.01190254f, 
    -0.01514120f, 0.01788451f, -0.01962630f, -0.03587458f, -0.00495336f, 0.01435340f, 0.02586969f, 0.01609714f, 
    0.02192599f, -0.02145043f, -0.01685577f, -0.00528470f, -0.02941418f, 0.00758625f, -0.03414908f, 0.02936909f, 
    -0.02413107f, 0.02645326f, -0.02531919f, -0.00082939f, -0.01906745f, 0.02657972f, -0.04243474f, -0.00535682f, 
    0.01571684f, -0.02791897f, -0.02044315f, -0.01901178f, 0.00423559f, -0.03774122f, -0.02064035f, 0.02007508f, 
    -0.03763323f, -0.00361557f, 0.01967755f, 0.01917079f, -0.01686939f, -0.01339789f, 0.01823558f, -0.03061277f, 
    -0.01767590f, -0.00067447f, 0.03505972f, -0.00627579f, -0.00090387f, 0.02220747f, 0.02408833f, 0.01236064f, 
    -0.02974433f, -0.01420787f, 0.01831523f, -0.01909212f, 0.00107725f, -0.03690407f, 0.01961611f, 0.02219037f, 
    -0.01458345f, -0.03650638f, -0.00128246f, -0.02704281f, 0.02542529f, 0.00936873f, -0.00409361f, 0.03079323f, 
    -0.03273945f, -0.03171062f, -0.01884587f, 0.01392788f, -0.01476577f, -0.04895437f, 0.02713196f, -0.02127495f, 
    -0.04178181f, -0.02570588f, -0.02298455f, -0.00861096f, 0.00343759f, -0.02104493f, -0.03264818f, -0.01369436f, 
    -0.04216642f, 0.00631783f, -0.01980774f, 0.01777489f, -0.02055403f, 0.02388371f, -0.01316354f, -0.02060995f, 
    0.00959976f, 0.00280919f, -0.00619583f, -0.02665485f, -0.01508309f, -0.04277421f, 0.00372065f, -0.03225150f, 
    0.01889515f, 0.01419639f, -0.02017961f, -0.02199504f, 0.01292555f, -0.00759800f, 0.02853289f, 0.01008681f, 
    -0.00781816f, -0.03181528f, -0.01667755f, 0.01113483f, -0.02810022f, 0.02741297f, -0.02250437f, 0.02089272f, 
    0.01143625f, -0.04519622f, 0.01451320f, 0.00030805f, -0.00682976f, 0.00013450f, -0.04967933f, 0.02839190f, 
    -0.00528464f, -0.03871013f, -0.02611797f, -0.04299554f, 0.01369153f, 0.01462052f, -0.02951297f, -0.02367909f, 
    0.00793940f, -0.02596755f, -0.02970421f, -0.00184874f, -0.01966279f, -0.01575367f, 0.00481014f, -0.00891507f, 
    -0.00072608f, 0.01262210f, 0.00344778f, 0.01734774f, -0.01403127f, 0.03178833f, 0.02440839f, -0.01772302f, 
    0.01331538f, 0.01044273f, 0.00603688f, 0.01691788f, -0.02141795f, -0.01782718f, 0.01426507f, -0.01247352f, 
    -0.02502745f, -0.00010377f, -0.03431747f, -0.01516956f, -0.02922358f, -0.01349597f, 0.01521062f, -0.03384139f, 
    0.03436184f, -0.03634204f, -0.02880321f, -0.00414120f, 0.00815057f, 0.00736367f, 0.00318665f, 0.00802830f, 
    0.01140530f, -0.02477032f, -0.02216183f, 0.02349270f, -0.03717097f, -0.01630034f, 0.01451251f, 0.03292853f, 
    0.02431197f, -0.00084337f, 0.02683245f, -0.00650063f, -0.02279738f, -0.00578186f, -0.03041445f, -0.03531634f, 
    -0.00390395f, -0.00347322f, 0.03100655f, 0.00347733f, 0.01525797f, -0.02302507f, -0.03987892f, -0.04031990f, 
    -0.04308920f, -0.03303558f, 0.01834038f, 0.00389958f, -0.00084143f, -0.00743497f, 0.02284932f, 0.00794482f, 
    0.02141180f, -0.04217465f, -0.00003472f, -0.03546605f, -0.00543063f, -0.03298756f, -0.00647991f, 0.02425504f, 
    -0.01030877f, -0.02864845f, -0.03339539f, -0.02083692f, 0.00859834f, -0.02245785f, -0.03548371f, -0.03182187f, 
    0.00629522f, -0.00422108f, 0.02254857f, 0.00429770f, -0.02726838f, -0.02860732f, -0.02171142f, 0.00619588f, 
    0.00079805f, 0.00954364f, 0.01005928f, 0.01020493f, -0.00796250f, -0.03363625f, -0.02483219f, -0.02302972f, 
    0.02608832f, -0.00261774f, 0.03430688f, 0.01820480f, 0.00213446f, -0.03169664f, 0.01673352f, 0.02748892f, 
    0.00343073f, 0.01101838f, 0.02359629f, -0.00946649f, -0.02496668f, 0.02655257f, -0.02428970f, -0.00107731f, 
    0.02040351f, 0.00571139f, -0.01681538f, -0.03569398f, 0.03137242f, -0.01329123f, -0.03226458f, -0.03419665f, 
    0.02858221f, 0.03221507f, 0.01030989f, -0.02051476f, 0.02462380f, -0.02754805f, -0.01679058f, -0.03361933f, 
    0.02131608f, -0.03631039f, -0.03177833f, -0.03092901f, 0.00360154f, -0.04176545f, -0.02057429f, 0.00540890f, 
    -0.03984234f, 0.01912193f, -0.02333386f, 0.00730625f, -0.02657481f, 0.00889409f, -0.02822541f, -0.02344929f, 
    0.01597238f, -0.02542840f, -0.00753653f, -0.01747263f, -0.01391104f, 0.00637952f, -0.03349014f, -0.02354932f, 
    -0.01635532f, -0.03007484f, -0.01538183f, 0.00049859f, -0.01451573f, -0.00890766f, 0.00524291f, -0.01696464f, 
    0.02386913f, -0.03916159f, -0.02204831f, -0.02317625f, 0.01863674f, -0.02207890f, -0.00213795f, 0.03189694f, 
    0.03279486f, -0.00785974f, -0.01326834f, -0.02834378f, 0.00416280f, 0.00099388f, 0.02268373f, -0.01963158f, 
    -0.01157589f, -0.01078488f, -0.03099837f, -0.00956642f, 0.00734764f, -0.02084341f, -0.03731857f, -0.03898153f, 
    0.00884858f, -0.03259888f, 0.02269849f, 0.03132204f, 0.00781255f, 0.02159313f, 0.00036217f, -0.00926370f, 
    0.00478434f, 0.00040898f, -0.02049161f, 0.01829348f, -0.00226754f, -0.00511648f, -0.03190267f, -0.01705669f, 
    -0.03665134f, -0.00508319f, 0.02596500f, 0.00892468f, 0.01939517f, -0.02792217f, 0.03153422f, -0.00914869f, 
    0.02285572f, 0.00279709f, -0.04513748f, -0.01346794f, -0.03692290f, -0.03217140f, -0.04029062f, 0.02284787f, 
    -0.00125417f, -0.02595986f, 0.03252009f, -0.03357535f, -0.01814653f, 0.01200583f, 0.00860638f, -0.03082016f, 
    -0.01311868f, -0.00853734f, -0.03971299f, 0.01951712f, 0.00199295f, -0.00274548f, -0.03674763f, -0.04272921f, 
    -0.00831340f, 0.00530634f, 0.01722726f, -0.00600199f, 0.02955364f, 0.01431401f, -0.03135222f, 0.02190939f, 
    0.00325999f, -0.01242426f, 0.00519269f, 0.01621569f, 0.00240077f, -0.03325027f, -0.03996190f, -0.03990236f, 
    0.00507190f, 0.02334751f, -0.02392838f, 0.02968031f, -0.01384191f, 0.00779352f, -0.01591097f, -0.00922648f, 
    0.01697313f, -0.01922157f, 0.03184112f, 0.01291672f, 0.01324999f, -0.01180295f, -0.03314391f, -0.00938030f, 
    -0.00150597f, 0.01753675f, 0.01776287f, 0.00432891f, -0.03704860f, -0.00998077f, 0.02549526f, -0.01493014f, 
    -0.01676926f, 0.01755816f, 0.00897830f, 0.00585280f, 0.02230731f, 0.02138198f, -0.04392046f, -0.02921929f, 
    -0.02133685f, 0.01925194f, -0.03210885f, -0.01285633f, -0.02210029f, -0.02641037f, 0.02495538f, -0.01091990f, 
    0.02518888f, -0.04132218f, -0.02578645f, -0.00569587f, -0.02104468f, 0.01453903f, -0.00958594f, -0.03036814f, 
    0.00618855f, -0.01358992f, 0.00413676f, -0.03902052f, 0.01745317f, -0.01618698f, 0.01047256f, 0.01454779f, 
    0.07611796f, 0.16392046f, -0.12138424f, -0.08511145f, 0.07271200f, -0.06467831f, -0.06872065f, 0.02767903f, 
    0.00712452f, 0.00230991f, 0.01866372f, 0.00372411f, -0.16020028f, 0.17724934f, 0.02702238f, -0.15533258f, 
    -0.08073236f, 0.00369291f, 0.03809668f, -0.02623213f, 0.03251751f, 0.10590257f, 0.06162173f, -0.02672540f, 
    0.18685180f, 0.03928243f, 0.02731423f, -0.14178297f, -0.02490149f, 0.06837332f, 0.02206263f, -0.02821962f, 
    -0.03976626f, -0.05780803f, -0.05167625f, 0.00788505f, -0.05475752f, 0.12251315f, -0.21541807f, 0.05601867f, 
    0.00394101f, 0.02504383f, -0.12811345f, -0.23107645f, -0.24130031f, -0.15937671f, -0.08933160f, -0.15521765f, 
    0.18278310f, 0.16813469f, -0.34399095f, 0.21526618f, -0.06818534f, 0.09614352f, 0.08750030f, 0.11661165f, 
    0.08810050f, -0.09531654f, 0.01366716f, -0.05043063f, 0.04434997f, 0.11004662f, 0.18435924f, -0.25222355f, 
    0.06307090f, -0.00365749f, 0.04824891f, 0.07245322f, -0.04601058f, 0.04701109f, -0.07370605f, 0.13768674f, 
    0.11797394f, 0.16565414f, -0.01182972f, -0.00877861f, -0.17814055f, -0.04659104f, 0.09711885f, -0.08743111f, 
    -0.06243402f, 0.08234452f, -0.00569318f, 0.09803696f, 0.09658646f, -0.05075885f, -0.14897402f, -0.13208188f, 
    0.10604195f, 0.00073401f, -0.08383512f, 0.01991886f, 0.04532348f, -0.04135063f, -0.02242652f, -0.17860590f, 
    0.04685476f, 0.03669475f, 0.02549220f, -0.01780261f, -0.00993307f, 0.23000640f, -0.11926367f, 0.07365065f, 
    0.03344373f, 0.00939018f, 0.08415407f, 0.06338625f, 0.02718426f, 0.00874838f, -0.18257162f, 0.06555758f, 
    0.04116016f, -0.06131981f, 0.01022582f, -0.09720176f, 0.02669812f, -0.17363320f, -0.10829081f, -0.07885969f, 
    0.07358520f, 0.12781341f, -0.02059007f, -0.02521361f, 0.02271995f, 0.04131851f, 0.02373646f, 0.08633717f, 
    0.00788294f, -0.01739461f, -0.09400557f, 0.06179400f, -0.19263107f, 0.08243828f, -0.01231597f, 0.08452526f, 
    -0.02762949f, -0.16326274f, 0.06220683f, -0.01910370f, -0.02651866f, 0.00348206f, 0.02425130f, 0.03439493f, 
    0.14502156f, 0.09831312f, 0.07099666f, -0.18321973f, 0.17536624f, 0.08156054f, -0.03299225f, -0.01729494f, 
    0.07701296f, 0.00236542f, 0.03627567f, 0.06966925f, -0.10566019f, -0.04111360f, -0.08714920f, 0.17606679f, 
    -0.04098774f, 0.03825941f, -0.00161527f, -0.05115775f, -0.08359995f, -0.06684440f, 0.08201503f, 0.04277254f, 
    0.13925397f, 0.05414509f, 0.10084292f, -0.07977048f, 0.05139795f, 0.05344376f, -0.02384897f, -0.03627958f, 
    0.00399439f, 0.04827922f, 0.01342030f, 0.00127992f, -0.12778699f, 0.12358315f, -0.16380060f, 0.09701954f, 
    -0.03676208f, -0.08020740f, -0.04743114f, -0.02485213f, 0.01801047f, -0.06756070f, -0.02226979f, 0.20288420f, 
    0.20422252f, 0.05084973f, -0.02818360f, -0.15463562f, 0.00231023f, 0.13192868f, -0.00631531f, 0.01610157f, 
    -0.00877472f, -0.06726673f, -0.07446734f, -0.02556571f, -0.23029539f, -0.11288650f, 0.11640353f, -0.03428741f, 
    -0.06246501f, -0.11719401f, -0.01143706f, -0.06634801f, 0.06807948f, 0.14383502f, -0.05254075f, 0.07588707f, 
    0.15562235f, -0.06162719f, -0.14832671f, 0.00121582f, 0.06028941f, 0.01335019f, 0.03281288f, -0.01110047f, 
    -0.06751068f, -0.07253691f, -0.04125579f, 0.04346100f, -0.01608454f, -0.09746230f, -0.23878324f, 0.31943113f, 
    0.10319532f, 0.02203752f, 0.08327683f, -0.12229361f, -0.20087095f, -0.09200134f, 0.06738499f, -0.06590380f, 
    -0.03845194f, 0.17634726f, 0.20622636f, -0.25467768f, 0.05862540f, 0.14144595f, -0.03684257f, 0.02143537f, 
    0.00076171f, -0.10653426f, -0.25380939f, -0.13032350f, -0.49557090f, 0.02484030f, -0.33542883f, 0.06373816f, 
    -0.01328645f, -0.05577492f, -0.04870515f, 0.01521233f, -0.06508351f, -0.16387217f, -0.08947255f, 0.11664033f, 
    0.06489681f, 0.05516289f, -0.15138729f, 0.02449099f, 0.00308060f, 0.12724808f, 0.08431378f, 0.12181230f, 
    -0.02640115f, 0.07948858f, 0.08662306f, 0.01568644f, 0.21478283f, 0.11754438f, -0.09425047f, -0.05979811f, 
    -0.02371791f, -0.00457905f, 0.11047474f, 0.05367019f, 0.05258848f, 0.22568670f, 0.06628910f, 0.03044811f, 
    -0.48972359f, -0.15483366f, 0.00662834f, 0.06764673f, -0.04951711f, -0.04744285f, -0.03641165f, 0.01397569f, 
    -0.01432384f, -0.17084537f, 0.05969535f, -0.01000539f, 0.16750488f, -0.08184536f, 0.05576060f, 0.00126278f, 
    0.00659541f, -0.01691204f, -0.07023533f, 0.09381121f, -0.07799564f, -0.14745630f, -0.00730456f, 0.04805941f, 
    0.12835516f, -0.05624194f, -0.03648387f, -0.08932557f, -0.02621079f, 0.14809710f, -0.04834274f, 0.09053211f, 
    0.03754116f, 0.06602503f, 0.07418575f, 0.02063403f, 0.09677325f, -0.16135696f, -0.14605337f, -0.08656103f, 
    0.00380115f, 0.08867521f, -0.03551879f, -0.04577056f, 0.04640156f, -0.01102666f, 0.03533462f, 0.14593989f, 
    -0.07884515f, -0.00723986f, 0.01718023f, -0.10419798f, 0.06360232f, -0.05258217f, 0.04939095f, -0.18154784f, 
    0.01227592f, 0.02745567f, -0.02664309f, -0.00177600f, 0.19146334f, 0.03645793f, -0.06253457f, 0.01393427f, 
    0.11450581f, 0.13867025f, 0.09857006f, -0.03031723f, -0.05371682f, 0.01936920f, 0.03773700f, 0.12478635f, 
    -0.05069056f, -0.36019510f, 0.05673466f, 0.09212846f, -0.07608145f, 0.05888333f, -0.02508113f, 0.01779407f, 
    0.00331903f, -0.02617678f, -0.08869320f, 0.00522315f, 0.19620940f, 0.20452011f, 0.02833959f, -0.13179955f, 
    0.04170454f, 0.07960189f, -0.04508441f, 0.01309059f, -0.08942813f, 0.01266951f, -0.02128499f, -0.06697420f, 
    0.31310031f, 0.12678404f, -0.08310759f, -0.01988450f, 0.11615812f, 0.10879663f, 0.07421092f, 0.13990366f, 
    -0.05853337f, 0.00896095f, 0.07602258f, -0.02558394f, -0.17117698f, -0.14384511f, 0.11527374f, 0.06171338f, 
    -0.09111179f, 0.06844103f, 0.02666434f, -0.00828361f, 0.08183951f, -0.06178379f, 0.10304067f, 0.14376394f, 
    -0.19094773f, -0.01364396f, -0.22976911f, 0.41906109f, 0.06246582f, 0.06867228f, 0.07258809f, -0.20345408f, 
    0.06695144f, 0.09350581f, -0.02144113f, 0.03787789f, 0.09943695f, 0.06446360f, -0.11648640f, 0.03654449f, 
    0.00743684f, 0.09367147f, 0.09310625f, 0.04083954f, -0.02997232f, -0.12979692f, 0.08961004f, 0.18298808f, 
    0.23771898f, 0.13577233f, 0.10244066f, -0.04310985f, 0.03736400f, -0.02648359f, 0.06924787f, 0.05838682f, 
    0.03317859f, 0.07174410f, 0.05001880f, -0.04868354f, 0.29277033f, 0.04625233f, -0.18009433f, -0.09264527f, 
    0.05836179f, 0.04841601f, 0.08014403f, -0.02610609f, 0.05760900f, 0.01203610f, 0.01558441f, 0.04261759f, 
    0.15356047f, 0.20939022f, -0.05762709f, -0.00958547f, 0.00930214f, 0.01342297f, -0.01598391f, 0.00853922f, 
    -0.01583274f, 0.02482407f, 0.04740546f, -0.04895899f, -0.12557103f, 0.05079896f, 0.26053959f, -0.04749696f, 
    -0.13698335f, -0.02403769f, -0.01782016f, 0.05018504f, -0.09306586f, 0.12038933f, -0.09372088f, -0.06903065f, 
    0.07906291f, -0.25269523f, 0.20916115f, -0.10600300f, -0.11961579f, 0.09835739f, -0.09892404f, 0.07402506f, 
    0.08691155f, 0.04590900f, -0.08194128f, 0.02614983f, 0.03271094f, 0.02256044f, -0.15469995f, 0.39056778f, 
    0.05094565f, -0.01555627f, 0.12612632f, 0.02840148f, 0.04013024f, -0.07763243f, -0.04784780f, 0.02928112f, 
    -0.30309945f, -0.25063112f, 0.11842106f, -0.19133583f, -0.03290188f, -0.05144399f, 0.02304593f, 0.03947797f, 
    0.06040826f, -0.11611990f, 0.05066933f, 0.01693577f, 0.12124839f, -0.03683398f, -0.04914590f, 0.08808409f, 
    0.13694841f, 0.01867069f, -0.00155545f, -0.02395386f, 0.00651533f, -0.10951567f, -0.03681130f, -0.11114840f, 
    -0.25654158f, 0.19673103f, 0.07945018f, -0.22976707f, 0.00239932f, 0.01598159f, 0.01172008f, -0.11259330f, 
    -0.07328288f, -0.06623384f, -0.13954730f, 0.00337368f, -0.03238309f, -0.02491501f, 0.21024790f, -0.07269617f, 
    -0.00826097f, -0.02836334f, 0.06510556f, 0.07389119f, 0.03596283f, 0.12473524f, 0.04877817f, 0.03257477f, 
    -0.19143584f, 0.06588308f, 0.06915325f, -0.02826411f, -0.13177291f, 0.00284598f, 0.11133713f, -0.08773011f, 
    -0.05074784f, 0.11961806f, -0.07704105f, 0.06242180f, 0.16358991f, 0.14147697f, -0.04254680f, 0.00980589f, 
    0.15369894f, 0.22178300f, 0.13495620f, -0.00090743f, -0.02816612f, -0.04454961f, 0.00845859f, 0.09589799f, 
    -0.10446806f, -0.06474604f, -0.16949458f, -0.03525302f, 0.10209240f, -0.22196759f, 0.01515588f, 0.02255560f, 
    -0.14900142f, 0.09693445f, -0.01869658f, -0.06686421f, 0.16091822f, -0.12811339f, 0.02167752f, -0.15272540f, 
    0.00400835f, -0.11195662f, 0.00017494f, 0.00226892f, -0.01615733f, -0.08224389f, -0.14044668f, -0.11444160f, 
    0.06194006f, -0.28928506f, 0.04385100f, 0.06478038f, 0.03118017f, 0.10522538f, -0.13953000f, -0.10705968f, 
    0.11538674f, -0.08906685f, -0.05553086f, 0.07722407f, -0.08038617f, -0.10082349f, 0.12939197f, 0.17161663f, 
    -0.09707645f, 0.15974441f, -0.03881436f, 0.04994582f, -0.06383311f, 0.05944964f, -0.02087792f, 0.00709428f, 
    0.24060716f, 0.36504549f, 0.17630826f, -0.20599033f, 0.16179529f, 0.04671879f, 0.06580748f, -0.04602401f, 
    -0.04241579f, -0.07125140f, -0.02672540f, -0.00282782f, 0.14462574f, 0.11430012f, 0.02304902f, -0.00748801f, 
    0.01925492f, 0.07854430f, 0.06446885f, -0.03372965f, -0.06490676f, -0.08249751f, 0.04845768f, 0.00394090f, 
    0.19056424f, -0.07431902f, -0.04095604f, -0.31996983f, 0.05846783f, -0.12885508f, 0.07929959f, 0.17187731f, 
    0.04263871f, -0.01626466f, 0.02308841f, -0.02622670f, 0.05303520f, -0.05099845f, -0.24019744f, -0.14282128f, 
    -0.05513685f, -0.07725475f, -0.07548831f, -0.12067845f, -0.01372440f, 0.05993501f, -0.06464811f, -0.02519115f, 
    0.25680435f, 0.24510890f, -0.03608838f, -0.01833449f, 0.11281124f, 0.04846026f, 0.04130783f, -0.03134681f, 
    0.05374155f, 0.07817656f, 0.03970170f, -0.02675125f, 0.09832045f, 0.04362799f, -0.04577188f, 0.02977654f, 
    0.12384842f, 0.07516743f, 0.02136413f, 0.00977505f, 0.06866876f, 0.05918804f, 0.06811580f, 0.12150488f, 
    0.09245559f, 0.08909841f, 0.02426685f, -0.05537492f, 0.05012696f, -0.01495493f, -0.03287202f, 0.00242799f, 
    -0.04817101f, -0.02978831f, 0.05257706f, 0.09300626f, 0.22242574f, 0.19925065f, -0.07208805f, -0.27029181f, 
    0.04541451f, 0.01443540f, 0.06391509f, -0.03041653f, 0.04319884f, -0.05111049f, 0.08095272f, -0.11072004f, 
    -0.20563841f, -0.14951304f, -0.20047122f, 0.17036623f, 0.01326987f, -0.02485460f, -0.03058046f, -0.07195517f, 
    0.00486971f, -0.15941890f, -0.14129379f, -0.26073065f, 0.11489248f, -0.05907897f, -0.26913229f, 0.34748694f, 
    0.08674885f, -0.34942439f, -0.06973986f, 0.00087579f, 0.12607794f, 0.07312207f, -0.13347328f, -0.05858500f, 
    0.15781279f, 0.04736860f, -0.00940384f, -0.04290520f, -0.01824904f, -0.08499339f, 0.04928178f, 0.05573610f, 
    -0.00422949f, -0.03663278f, 0.03728540f, 0.05329100f, 0.29981092f, 0.05561906f, 0.02533702f, -0.17638174f, 
    0.06399063f, 0.06962940f, 0.09669329f, -0.02064587f, 0.05008155f, 0.00916537f, 0.03159718f, 0.01205065f, 
    0.02079319f, -0.00431748f, -0.01913610f, 0.01514563f, -0.01154771f, -0.02753902f, 0.00731411f, -0.03696965f, 
    -0.01142046f, -0.04071318f, -0.00921695f, -0.01638990f, -0.03865960f, -0.02441986f, -0.03689552f, -0.02160409f, 
    -0.02653578f, -0.02047161f, -0.00832838f, -0.01601396f, -0.03405937f, -0.03575352f, -0.02415192f, 0.02233552f, 
    -0.01768243f, 0.01019002f, -0.02660193f, -0.00835881f, -0.02936448f, 0.03058448f, -0.03311355f, 0.03422569f, 
    0.00491964f, 0.01429563f, -0.01980291f, 0.00989759f, 0.01046850f, 0.02929182f, 0.02447324f, -0.02657657f, 
    0.00109642f, 0.01437851f, -0.01778645f, -0.03950904f, -0.00668823f, 0.02284377f, 0.02506948f, -0.02096009f, 
    -0.02644771f, 0.01974283f, -0.01325642f, 0.02167238f, -0.01511678f, -0.01100090f, -0.01539760f, -0.03391000f, 
    0.02778846f, -0.03129866f, -0.01893437f, 0.02409194f, 0.00019989f, -0.02211814f, 0.01859044f, -0.03682259f, 
    -0.01980214f, -0.01758862f, 0.00719624f, -0.03204775f, -0.02534461f, -0.03411976f, -0.02413674f, -0.01916371f, 
    0.00455470f, -0.02359302f, -0.03478038f, 0.00806769f, 0.01854053f, -0.03093766f, 0.02323674f, -0.01265606f, 
    -0.03427264f, -0.00370292f, -0.00591217f, 0.02481598f, 0.00247284f, -0.01445334f, 0.02485560f, -0.02348582f, 
    0.02102985f, -0.01993895f, -0.00375217f, 0.01523783f, 0.00280426f, -0.01682417f, 0.00396763f, 0.02630403f, 
    -0.03108276f, -0.03269866f, 0.03178948f, -0.01912815f, -0.00728989f, -0.03545394f, 0.01367301f, -0.02851573f, 
    -0.02676991f, -0.01352558f, 0.01387956f, -0.02011581f, 0.02513788f, -0.03320146f, 0.02609418f, 0.02522761f, 
    0.00663591f, -0.03745872f, -0.01038733f, -0.01600353f, -0.01552255f, -0.01493148f, 0.02941956f, 0.02279152f, 
    -0.03137054f, -0.02431504f, -0.01239150f, 0.02778987f, -0.00466802f, -0.01003706f, -0.00760431f, -0.00671309f, 
    -0.02677118f, -0.00743537f, 0.00685705f, -0.00177328f, 0.01303888f, -0.01608573f, 0.00591323f, -0.03087663f, 
    0.01138772f, -0.03971216f, -0.03089072f, -0.03496357f, -0.03023452f, -0.02380589f, -0.02313376f, -0.00136783f, 
    0.03251617f, 0.03511862f, -0.01135263f, -0.03480254f, 0.02500250f, -0.02982284f, -0.00608766f, -0.02558416f, 
    0.02346964f, -0.03605855f, -0.00437970f, -0.01486664f, 0.01239020f, -0.02881129f, 0.00764384f, 0.01560650f, 
    -0.00448264f, -0.01666547f, 0.01383858f, 0.01352265f, -0.02906314f, -0.02029086f, 0.02397020f, 0.00770171f, 
    0.00916111f, -0.00487172f, -0.00513392f, -0.02644459f, -0.00978881f, -0.01407159f, -0.03027169f, -0.02088958f, 
    -0.03535923f, -0.02326025f, -0.03278818f, -0.01185072f, -0.00930216f, -0.00321267f, 0.00362404f, -0.03204108f, 
    -0.00067207f, -0.02797982f, -0.00161807f, 0.02294617f, 0.02178673f, -0.03458765f, -0.03808047f, 0.00318653f, 
    -0.01201755f, 0.03319648f, -0.02636018f, -0.01470578f, -0.00420544f, -0.02512377f, -0.00063830f, -0.03379965f, 
    -0.02347929f, -0.03766067f, -0.01189054f, 0.00598142f, 0.02838043f, 0.01222548f, -0.01570350f, -0.01976600f, 
    0.00471025f, -0.01200101f, 0.02612345f, -0.02706730f, 0.00549134f, -0.03001777f, -0.01994990f, -0.01957466f, 
    -0.00662612f, -0.00505893f, -0.03179718f, 0.00449001f, -0.00179029f, -0.01991736f, 0.03053631f, -0.01652568f, 
    -0.04100388f, -0.01136852f, 0.02684460f, -0.00997023f, -0.01942299f, -0.01456354f, -0.03026113f, 0.02948222f, 
    0.01347161f, -0.00719991f, -0.02881558f, -0.00596707f, -0.01233683f, 0.00334584f, -0.01666215f, 0.01519521f, 
    -0.02923131f, -0.03531981f, -0.01719382f, 0.01666415f, -0.04059487f, 0.00300484f, -0.01194527f, -0.00817219f, 
    0.01517675f, 0.00178425f, -0.01040937f, -0.00875931f, -0.01733170f, 0.02904155f, 0.00956636f, -0.00910670f, 
    -0.02320264f, -0.01108780f, -0.02264079f, -0.01792316f, -0.00819026f, 0.00957005f, -0.02067933f, 0.00099822f, 
    0.01904855f, -0.02125802f, -0.00630518f, -0.04125096f, -0.03639008f, -0.02323131f, 0.01090486f, 0.00312542f, 
    -0.01342279f, -0.00478072f, -0.02463691f, 0.02570589f, -0.01190834f, -0.02679617f, -0.03276945f, 0.01257701f, 
    -0.01755627f, 0.01025084f, -0.03652591f, -0.03978733f, 0.02407409f, 0.00746063f, 0.01775943f, 0.03311091f, 
    0.01328764f, -0.04057256f, 0.02315764f, -0.02583899f, 0.01669073f, -0.00375200f, 0.01058894f, 0.00102274f, 
    0.02464971f, 0.00138664f, -0.02721389f, -0.00445213f, -0.02085144f, 0.02779148f, 0.00839825f, -0.02679621f, 
    0.01037856f, -0.00039889f, 0.02352167f, 0.01933152f, -0.03235650f, -0.02033417f, 0.02028617f, -0.00928193f, 
    0.01371209f, 0.02344097f, -0.01532162f, -0.00336915f, -0.00717378f, -0.02812738f, 0.02985343f, -0.02016371f, 
    0.00787540f, 0.01915999f, -0.01539104f, -0.00192570f, -0.02941818f, -0.00288477f, 0.00055711f, 0.00001298f, 
    -0.01465641f, -0.03703366f, -0.00174806f, -0.01169269f, -0.03348663f, 0.01290990f, -0.04089881f, 0.00129359f, 
    0.00607123f, -0.00513034f, -0.01017753f, 0.00744521f, 0.00565772f, -0.03911706f, -0.02381492f, -0.03711844f, 
    0.00555990f, -0.01106444f, -0.00543266f, 0.00557530f, -0.03527546f, -0.02621816f, -0.01467131f, -0.02446023f, 
    -0.01501038f, 0.02805391f, -0.02943972f, 0.01905929f, -0.02188705f, -0.03442403f, -0.01813104f, -0.03246136f, 
    0.01054713f, -0.03213688f, 0.00518787f, -0.02906019f, 0.02971702f, -0.03869031f, 0.00062482f, -0.03368139f, 
    -0.02099040f, 0.02263677f, 0.00286715f, -0.02993579f, 0.03072756f, -0.00031121f, -0.00869341f, -0.03099815f, 
    -0.00742922f, -0.02752522f, -0.02710841f, -0.01488158f, -0.02163104f, 0.00949254f, 0.01699368f, -0.03522475f, 
    -0.00960435f, -0.03257670f, 0.00760328f, -0.01860676f, 0.02356372f, -0.00498581f, -0.02402452f, 0.01191368f, 
    -0.03072638f, 0.03496443f, -0.01637382f, -0.00879008f, 0.02277285f, -0.02858531f, -0.00061391f, -0.03710650f, 
    0.01495021f, -0.01290612f, -0.01190637f, 0.02591683f, -0.03255196f, -0.00132517f, -0.00493670f, 0.00424604f, 
    0.01394106f, -0.02788919f, -0.00748418f, 0.00963907f, -0.03674017f, -0.03450996f, 0.01264970f, -0.01839251f, 
    0.01388284f, 0.00048917f, 0.00256653f, 0.02523573f, 0.01886999f, 0.02615902f, -0.01446815f, -0.02617044f, 
    0.01784633f, 0.01500477f, 0.00667235f, 0.02633943f, -0.00742045f, 0.02239112f, 0.03558866f, -0.01963205f, 
    -0.01665733f, -0.02795101f, 0.00554245f, 0.01367532f, 0.01476517f, -0.02754707f, 0.00759085f, 0.01839129f, 
    0.00830124f, 0.01128218f, 0.02087116f, -0.01140105f, -0.03157023f, -0.01876447f, 0.03027549f, -0.03544756f, 
    0.02123217f, -0.01687028f, -0.02686039f, -0.03951949f, 0.00831860f, -0.00352102f, 0.00076290f, 0.02068736f, 
    0.00320698f, 0.01544920f, -0.03599763f, -0.02736856f, -0.00405832f, -0.01842862f, -0.01666366f, 0.02051629f, 
    -0.01123228f, 0.01373829f, -0.02318859f, 0.01604100f, 0.01214263f, -0.01453271f, -0.01431036f, 0.00546983f, 
    0.01999660f, 0.01771577f, 0.01598252f, 0.02023042f, -0.01817053f, 0.02733262f, -0.03574730f, -0.02647293f, 
    0.01248457f, -0.03726080f, 0.03349026f, -0.02606267f, 0.02010398f, -0.00166031f, 0.01439004f, -0.01504978f, 
    -0.00559741f, -0.01604726f, 0.00861588f, 0.00807008f, -0.00089371f, -0.00687800f, 0.00948274f, 0.00592880f, 
    -0.01683890f, -0.01829536f, 0.01337476f, -0.00353446f, -0.00741328f, 0.01007198f, 0.00392804f, -0.02980785f, 
    0.00328409f, 0.01533098f, -0.02249384f, -0.01129887f, -0.00791996f, 0.01661235f, -0.00775935f, -0.00915448f, 
    -0.00454674f, -0.01340485f, 0.03019141f, 0.02264589f, 0.02711115f, -0.03170766f, 0.00146182f, 0.00775005f, 
    -0.03958061f, 0.02323899f, -0.04017642f, 0.00294929f, 0.00973592f, -0.00865413f, -0.03138681f, -0.03279537f, 
    0.00851736f, -0.03902218f, 0.02417008f, 0.00478613f, 0.00627285f, -0.00052877f, 0.00045086f, 0.02230868f, 
    0.01338610f, -0.01842315f, -0.01781357f, -0.00206778f, 0.01844025f, -0.02843989f, 0.00622119f, -0.00646431f, 
    -0.01734894f, 0.01815177f, 0.01859407f, 0.02723767f, 0.02961246f, -0.00110594f, 0.02506302f, 0.02498032f, 
    -0.01138578f, -0.02514112f, 0.00913619f, 0.01208410f, 0.01295346f, -0.03919316f, 0.02420275f, 0.02644993f, 
    0.00287480f, -0.00973019f, -0.01295892f, 0.03604697f, 0.00939229f, -0.03555772f, 0.03472897f, -0.00327082f, 
    -0.00869423f, 0.00451473f, -0.01315127f, -0.03423250f, -0.03792702f, 0.02516316f, 0.02168487f, -0.03799283f, 
    0.00228921f, -0.03293609f, -0.02417415f, -0.01667281f, -0.02334866f, -0.00837245f, 0.02072754f, -0.02337927f, 
    -0.03359826f, 0.02485469f, -0.01054311f, 0.02736408f, -0.01519439f, 0.02928964f, 0.00184179f, 0.02295220f, 
    -0.01291102f, 0.03432570f, 0.03429870f, 0.02438807f, -0.01622079f, 0.01865521f, 0.01652776f, 0.00128917f, 
    -0.01975468f, -0.03213622f, -0.01439296f, 0.00400976f, 0.00463887f, 0.01340181f, -0.02766230f, -0.00531922f, 
    -0.00227752f, -0.00982947f, -0.02401577f, -0.01515001f, 0.02553098f, -0.04044947f, -0.01537788f, 0.00440154f, 
    0.02246086f, 0.00582386f, -0.01358745f, 0.01750526f, 0.00907841f, -0.02269874f, 0.03207899f, 0.02111816f, 
    0.01511698f, -0.02223173f, -0.00571484f, -0.02551899f, 0.03385925f, -0.03422442f, -0.02149152f, -0.03498964f, 
    -0.00025153f, -0.01137180f, -0.00862684f, 0.01532713f, 0.02138560f, 0.02802731f, 0.00588432f, -0.02747086f, 
    -0.01714779f, -0.00035862f, -0.00726573f, -0.00697416f, -0.02756795f, -0.00643349f, 0.01164396f, 0.02842773f, 
    -0.03296849f, 0.00495448f, 0.00674762f, -0.02456853f, 0.00336485f, -0.01609724f, -0.00631385f, 0.01814823f, 
    -0.03257019f, -0.03055226f, -0.01801155f, -0.01174517f, 0.02459725f, -0.02303102f, -0.00511717f, 0.02528440f, 
    0.01059778f, -0.00970478f, -0.00530643f, -0.02231590f, 0.01966473f, 0.02993225f, -0.01975648f, 0.00930404f, 
    0.01663660f, -0.03414634f, 0.01868602f, -0.03729795f, -0.00700248f, -0.02697636f, 0.01088025f, -0.02671554f, 
    0.03115796f, -0.00593299f, 0.02214126f, -0.01984046f, 0.00044106f, -0.01508776f, -0.00676658f, -0.00832407f, 
    0.02145198f, -0.03263550f, -0.03010701f, -0.01231577f, -0.01612977f, 0.03311929f, -0.01343438f, -0.01969256f, 
    0.00887030f, 0.02922647f, 0.01675352f, -0.03271146f, -0.01386230f, -0.01541533f, -0.03486664f, 0.01607934f, 
    -0.03630274f, -0.01882826f, -0.02328445f, -0.00591703f, 0.01405150f, -0.01837993f, -0.04042283f, -0.00754216f, 
    -0.02202734f, 0.02665058f, -0.03380992f, 0.03520402f, -0.00691286f, -0.00438279f, -0.01195448f, 0.02860785f, 
    -0.03990531f, -0.00753726f, 0.02034933f, 0.00465490f, -0.00085288f, 0.02541726f, -0.02019567f, 0.01274742f, 
    -0.01109052f, 0.02929226f, -0.03827833f, -0.01729788f, -0.01361499f, -0.01813218f, 0.02521532f, -0.00914775f, 
    0.00323243f, 0.03033859f, 0.02738831f, -0.00133001f, 0.02836272f, -0.01531652f, -0.00881486f, 0.01600338f, 
    -0.00272455f, 0.02621724f, -0.02402845f, -0.00915044f, -0.02241497f, -0.03315754f, 0.00736955f, -0.00818505f, 
    -0.01148803f, -0.00168374f, 0.00790347f, -0.03556652f, -0.03530386f, -0.00469186f, 0.00881803f, -0.02846261f, 
    0.02153119f, 0.02479585f, 0.02998196f, 0.02282378f, 0.02653990f, 0.00593335f, 0.00821946f, -0.00807569f, 
    -0.11403941f, -0.09720239f, -0.00625328f, 0.22826374f, 0.06612861f, 0.00689964f, 0.02197987f, 0.03760415f, 
    -0.04785150f, 0.05493060f, 0.05301264f, 0.01870917f, -0.12994877f, 0.06111830f, 0.08747340f, 0.07170816f, 
    0.05614227f, 0.01970502f, -0.19369271f, -0.04269077f, 0.10744916f, 0.10116261f, -0.00096903f, 0.10975189f, 
    -0.07931870f, -0.06856330f, -0.00877093f, 0.12752524f, 0.02813387f, 0.04887791f, -0.03941492f, 0.14700894f, 
    0.03764628f, 0.06078596f, 0.00892118f, -0.04005562f, 0.00792847f, 0.08954598f, 0.02768650f, -0.08891610f, 
    0.24263693f, -0.07664396f, 0.04355420f, 0.11746458f, -0.01599695f, 0.12110244f, 0.03823401f, -0.02341384f, 
    0.24581735f, 0.03618386f, 0.10095900f, -0.00339846f, 0.02742291f, -0.03538631f, -0.03389516f, 0.01113964f, 
    -0.16612773f, -0.05096726f, 0.13679057f, -0.02852795f, -0.15981586f, 0.06411307f, 0.00066193f, -0.10980234f, 
    0.03003118f, 0.21721052f, 0.06418494f, -0.14870289f, 0.07523781f, -0.08532448f, 0.02642941f, 0.09074882f, 
    0.01820964f, 0.04659650f, -0.02078089f, 0.00304143f, -0.01854033f, -0.00807392f, 0.06694724f, 0.00168595f, 
    0.00660711f, -0.00508982f, -0.07808945f, 0.13882586f, -0.04690145f, 0.00387044f, 0.01919263f, 0.02528675f, 
    0.01873976f, -0.01696062f, 0.14106204f, -0.05844944f, -0.05474419f, -0.11324106f, -0.07487532f, -0.04852157f, 
    -0.13307884f, -0.07263105f, -0.04282550f, 0.07843897f, 0.02800115f, -0.09903640f, 0.07857078f, 0.15514466f, 
    0.08159272f, 0.01945235f, 0.14547130f, -0.02154598f, -0.02657266f, 0.05072173f, 0.04098186f, 0.00685456f, 
    -0.01590845f, 0.00708538f, 0.13474879f, 0.18207240f, -0.07078972f, 0.14692317f, -0.03736634f, 0.00628894f, 
    -0.12639250f, -0.10532188f, 0.05284354f, 0.00644401f, 0.03807768f, -0.03533168f, 0.02579061f, -0.09477603f, 
    -0.12531984f, 0.08059894f, 0.01390353f, -0.00533383f, 0.24339104f, 0.09106492f, 0.06649061f, -0.01672010f, 
    -0.00873738f, -0.02644654f, -0.04461563f, -0.02939360f, 0.09778840f, 0.13702287f, 0.07883201f, 0.13224915f, 
    -0.17045134f, 0.03089305f, -0.03596899f, -0.01919359f, -0.00168698f, 0.02389794f, -0.04511369f, -0.10380428f, 
    -0.13543272f, -0.16043486f, -0.03504099f, -0.13614254f, 0.10347014f, 0.04203853f, 0.01972349f, -0.01237601f, 
    -0.02828329f, -0.05097822f, -0.07911289f, -0.06193206f, 0.29493639f, 0.09140863f, 0.11884066f, -0.00014218f, 
    0.00311636f, 0.00903662f, -0.09159108f, 0.00857317f, -0.00069869f, 0.01443293f, 0.03865415f, 0.10575027f, 
    -0.09432379f, 0.04281096f, -0.04856304f, -0.11330850f, 0.23109989f, 0.09624275f, 0.05147442f, -0.01224531f, 
    0.31676096f, -0.00947741f, 0.24661727f, 0.21163027f, 0.08981860f, 0.11194431f, 0.07718495f, -0.17829655f, 
    -0.16403636f, -0.04786843f, 0.04506541f, 0.14319266f, -0.04315884f, -0.02781410f, 0.09790651f, 0.12319112f, 
    -0.12008739f, -0.06505035f, -0.01468616f, -0.12191078f, 0.09943592f, 0.08972444f, 0.04647046f, 0.00386627f, 
    0.01572988f, 0.13991383f, 0.13492727f, 0.00251377f, 0.21814798f, -0.06932521f, -0.02341473f, 0.06953774f, 
    -0.06563537f, -0.16542333f, -0.04889176f, -0.12474065f, -0.10252269f, 0.03704577f, 0.17067973f, 0.14816688f, 
    0.12375680f, 0.18658572f, 0.12474965f, -0.01121330f, 0.32774732f, 0.15247883f, 0.12411415f, -0.01316098f, 
    -0.12070264f, 0.00271233f, 0.02611461f, -0.00969491f, 0.03924682f, -0.01059686f, -0.02572040f, -0.03095511f, 
    -0.16207796f, -0.16009240f, -0.10568124f, 0.12145305f, 0.04810055f, 0.02565998f, 0.12028425f, 0.11634696f, 
    -0.03185263f, -0.05526610f, 0.23492460f, -0.05236417f, 0.37201592f, 0.14014737f, 0.33001855f, 0.04054951f, 
    -0.00994451f, -0.13369918f, 0.05548159f, -0.03245864f, 0.02921241f, 0.06124359f, 0.04883737f, -0.07355475f, 
    -0.07553462f, -0.06122718f, 0.00825833f, -0.06835286f, 0.01917096f, 0.01653201f, -0.06171370f, -0.07094309f, 
    0.03458778f, -0.04253719f, -0.17278753f, -0.15360516f, 0.01084475f, 0.01124797f, -0.01687437f, 0.26597270f, 
    0.06085409f, 0.03369185f, -0.13415779f, 0.01462896f, 0.09282183f, -0.04202761f, -0.10753034f, -0.02922609f, 
    0.21479777f, 0.08951189f, 0.08872670f, -0.11163568f, 0.00763084f, 0.06529453f, -0.01210013f, 0.00164803f, 
    -0.05426479f, -0.03501857f, 0.08973817f, -0.05507665f, -0.09207629f, 0.06220493f, 0.21934633f, 0.02754008f, 
    0.00474525f, 0.09041335f, 0.22089927f, -0.02189660f, 0.08410659f, -0.02151611f, 0.02504741f, -0.09772075f, 
    -0.05518585f, 0.04806539f, 0.04596802f, -0.12694834f, 0.09034375f, -0.03240049f, -0.02202503f, -0.00283744f, 
    0.04095641f, 0.03773035f, 0.07327685f, -0.06739496f, -0.00600805f, -0.10450482f, -0.15829566f, -0.16497709f, 
    -0.11564421f, -0.01140749f, 0.01871655f, 0.03662435f, -0.03479390f, 0.03727172f, -0.05583365f, -0.13218330f, 
    0.03433212f, 0.21340895f, -0.15002435f, -0.10262904f, -0.03692110f, 0.06690098f, 0.04572584f, -0.03320049f, 
    -0.10522585f, 0.08622152f, -0.04205861f, -0.08436073f, -0.04088419f, 0.00005758f, 0.19001347f, 0.05395621f, 
    0.04331562f, 0.03092683f, 0.10811963f, 0.07783742f, 0.00701676f, 0.00009139f, -0.05748472f, -0.06671868f, 
    0.07936445f, 0.15354565f, 0.04045818f, -0.15801352f, -0.00412196f, 0.10289382f, -0.02469159f, 0.03125054f, 
    0.10540259f, 0.02299326f, 0.11169896f, 0.06556785f, -0.10669550f, -0.10464194f, -0.01603757f, 0.18589838f, 
    -0.04010687f, -0.14263357f, 0.06336299f, 0.01611989f, -0.08789235f, -0.03101713f, -0.07454358f, -0.06480960f, 
    -0.25788221f, -0.19845267f, 0.19791403f, 0.17368653f, -0.09540875f, 0.04019702f, -0.05483272f, -0.05824805f, 
    -0.08051540f, 0.00540588f, -0.08369584f, -0.03569701f, 0.05999127f, -0.12713836f, 0.00772686f, -0.18253136f, 
    0.07958936f, 0.15396090f, -0.08999055f, 0.08591999f, -0.05628343f, 0.04264067f, 0.00697482f, -0.03968648f, 
    0.52144301f, 0.05005907f, 0.09267652f, -0.06817456f, -0.08205751f, -0.18952906f, 0.14237988f, -0.00290241f, 
    0.02246593f, -0.09214715f, 0.12273695f, -0.01547181f, -0.07061013f, -0.09027851f, 0.11397405f, 0.02792959f, 
    0.08132575f, 0.00942946f, -0.01106723f, -0.04527770f, 0.08679600f, -0.06437579f, 0.01675775f, -0.02434019f, 
    -0.13570689f, -0.03543746f, 0.00677535f, 0.03487828f, -0.05627633f, 0.01581237f, -0.01137113f, 0.03085547f, 
    0.01026659f, -0.06345457f, -0.01082294f, 0.02436027f, 0.04782243f, 0.03266663f, -0.15331356f, -0.03125996f, 
    -0.01005992f, -0.02267049f, -0.00949860f, -0.00299389f, -0.15900204f, 0.00323164f, 0.01232980f, -0.09022634f, 
    -0.05757855f, -0.06395373f, 0.08314106f, 0.14114746f, -0.02948052f, -0.03013481f, -0.01509643f, 0.19335248f, 
    -0.00961598f, 0.05278585f, 0.06211866f, 0.04704031f, 0.12650187f, 0.01361723f, -0.04295130f, 0.03644016f, 
    0.06649036f, 0.02440408f, -0.06172180f, 0.07029523f, -0.02247011f, 0.20510185f, -0.04271017f, 0.07794143f, 
    -0.27859291f, 0.01900498f, 0.15577908f, -0.07582298f, 0.05562098f, 0.13715555f, -0.01125456f, -0.03581696f, 
    0.04845481f, -0.02972675f, 0.25668937f, 0.12181932f, 0.20165192f, 0.14859959f, 0.11136059f, 0.03396891f, 
    -0.08193815f, 0.03634030f, -0.08163843f, -0.10545645f, -0.03816087f, 0.01838500f, 0.06520408f, 0.03185143f, 
    0.11237962f, 0.10261238f, 0.10835721f, 0.02579654f, 0.15385893f, 0.18939245f, -0.05865673f, -0.10980420f, 
    -0.01995388f, 0.06120657f, 0.06771841f, -0.06949843f, -0.26625052f, -0.03919256f, -0.11112374f, -0.03616178f, 
    -0.00647010f, 0.03124455f, 0.04238930f, 0.13122460f, 0.05555709f, 0.16841207f, -0.03277867f, 0.05611983f, 
    -0.08661771f, 0.09637364f, -0.05968031f, 0.08889919f, 0.05695374f, 0.00134211f, 0.02172997f, 0.01539140f, 
    -0.00393046f, 0.00181371f, 0.05139875f, 0.06644202f, 0.09362753f, -0.01492368f, 0.10488442f, -0.03241910f, 
    -0.05172098f, 0.11789305f, -0.05809074f, -0.11817883f, -0.11754510f, 0.01983218f, 0.07248592f, 0.08162507f, 
    0.28855997f, 0.06266429f, -0.08158395f, -0.04777170f, 0.06366961f, 0.08063269f, -0.12996601f, -0.04736777f, 
    -0.06179731f, 0.02486715f, 0.10087311f, 0.05194877f, -0.10104614f, -0.06846546f, 0.03154944f, -0.05056316f, 
    -0.06074820f, -0.02165550f, 0.04916105f, -0.00127368f, -0.03644275f, -0.06465168f, -0.07887605f, -0.02330235f, 
    0.13847972f, 0.03965580f, 0.09589463f, -0.00872466f, -0.03483784f, 0.02366194f, 0.05931181f, -0.00220608f, 
    0.09120369f, 0.04900954f, 0.01259089f, 0.01843387f, -0.16074286f, 0.17231843f, 0.08666737f, -0.05927867f, 
    -0.01702456f, 0.11885415f, 0.02267103f, 0.00417711f, 0.03349600f, 0.04628441f, -0.00353586f, 0.05378183f, 
    -0.04936233f, 0.11418451f, -0.03180849f, -0.20961261f, -0.01009351f, -0.01932026f, 0.14205973f, 0.05501532f, 
    -0.07147986f, 0.10779012f, 0.04208702f, -0.12760952f, 0.18706924f, 0.03112016f, 0.10843040f, -0.07224432f, 
    0.03140559f, -0.00877736f, -0.03388142f, -0.04380374f, 0.04873261f, -0.02558681f, 0.03691490f, 0.03459885f, 
    -0.31501245f, -0.19355668f, -0.22500078f, 0.19531168f, -0.11106689f, -0.00972769f, 0.07228108f, -0.07028566f, 
    0.00905759f, 0.08467974f, 0.11183893f, -0.01833904f, 0.06743003f, -0.05822614f, -0.08557647f, 0.10655361f, 
    0.05781967f, -0.05702320f, -0.07075550f, 0.17652519f, -0.00766670f, 0.15711343f, 0.11307368f, 0.00166417f, 
    -0.13637222f, 0.23677793f, -0.08492878f, -0.16938075f, 0.07061151f, -0.07629676f, 0.03124528f, -0.22118591f, 
    0.10650586f, -0.07982635f, -0.21826789f, 0.01947051f, -0.06154499f, -0.03788554f, 0.03726353f, 0.05414744f, 
    0.01254108f, 0.18585594f, 0.07187411f, -0.17457728f, 0.16750826f, 0.10868882f, 0.12952596f, 0.04695081f, 
    0.07877658f, 0.02259826f, -0.00753147f, -0.07798609f, -0.06995599f, 0.00038066f, -0.04116250f, -0.01746375f, 
    0.02815693f, 0.05461613f, -0.02404001f, -0.00279697f, -0.02221817f, -0.02342954f, -0.04814479f, -0.01506999f, 
    -0.03550322f, 0.04128675f, 0.07784791f, 0.09434492f, 0.04090837f, -0.06819341f, -0.00250629f, -0.03014433f, 
    -0.04562712f, -0.05704212f, -0.02596632f, 0.01218335f, -0.03077342f, 0.03478573f, 0.08968594f, 0.13571671f, 
    0.12840353f, 0.04808911f, 0.07973884f, 0.03826549f, -0.15538405f, -0.21390182f, 0.11938163f, 0.32986167f, 
    -0.05379962f, 0.12120426f, 0.09310433f, 0.16851225f, -0.07019308f, 0.03448693f, -0.01429654f, -0.01922909f, 
    0.11649855f, 0.07206633f, 0.10011507f, -0.04038723f, 0.10975751f, 0.03429348f, 0.03358533f, -0.02194501f, 
    -0.05258508f, -0.00839945f, 0.05424469f, -0.05171357f, 0.37494335f, 0.27384707f, 0.30689135f, 0.24927877f, 
    0.01244474f, 0.08883405f, 0.28280622f, -0.10403046f, -0.01362398f, 0.05618301f, 0.00592774f, 0.31703264f, 
    -0.04687512f, -0.15621415f, 0.01149138f, 0.18688101f, 0.03008581f, 0.06882320f, 0.01227608f, 0.01929319f, 
    -0.03679631f, 0.12738270f, -0.09295394f, 0.11697350f, -0.13730671f, -0.02813729f, -0.10817461f, 0.06146330f, 
    0.10482554f, 0.14513139f, 0.00219983f, 0.04227308f, 0.03441244f, -0.06170039f, 0.03838662f, 0.10165248f, 
    0.08541007f, 0.07094890f, -0.08697148f, 0.09801456f, 0.02570179f, -0.05306325f, 0.00273744f, -0.03317464f, 
    -0.07068226f, 0.02076977f, -0.01885956f, 0.04478484f, -0.32351452f, 0.32583556f, -0.01091028f, -0.20869073f, 
    -0.00730090f, 0.05548923f, -0.25876233f, -0.08360653f, 0.07132121f, -0.07056170f, -0.02888153f, 0.03822197f, 
    -0.00283808f, 0.02445023f, 0.03332495f, -0.06670732f, 0.07927296f, 0.07246604f, -0.06019030f, 0.00767642f, 
    -0.03748302f, 0.00083152f, -0.06949323f, -0.11349843f, 0.04728516f, -0.04162877f, -0.07408198f, 0.02161106f, 
    0.04556252f, 0.01586985f, -0.05081251f, -0.05876999f, 0.02179887f, 0.10831285f, 0.13240634f, 0.16197121f, 
    0.21506222f, -0.35051882f, -0.06888287f, -0.01611089f, -0.08566196f, -0.01494511f, 0.14103180f, 0.12075543f, 
    -0.06874632f, 0.05885076f, 0.06287348f, 0.13806844f, -0.26271531f, 0.30751544f, -0.10045178f, -0.13777870f, 
    0.07171986f, 0.02284553f, 0.02977917f, -0.10679166f, -0.00044137f, -0.08650033f, -0.17429003f, -0.05390620f, 
    -0.08158287f, 0.04170081f, -0.00399389f, -0.24668184f, 0.02671136f, 0.08915401f, 0.05154058f, -0.07350332f, 
    -0.01570038f, 0.07186376f, -0.01317041f, 0.16310510f, -0.14747180f, -0.00946104f, -0.14575407f, -0.23133755f, 
    -0.02689583f, -0.01536014f, 0.04523849f, -0.08173712f, 0.16391459f, 0.05455695f, 0.03985921f, -0.06025031f, 
    0.25176921f, 0.09456525f, 0.05188357f, 0.17926976f, 0.00043759f, 0.07317578f, -0.06555916f, 0.11866671f, 
    -0.16444735f, 0.01534874f, -0.04702515f, 0.00061504f, 0.06087133f, -0.01938380f, 0.02928317f, 0.01060964f, 
    0.07536632f, 0.12338094f, 0.14634869f, 0.15309848f, 0.11159309f, 0.10173825f, 0.09004590f, 0.17600386f, 
    -0.10111907f, -0.01900082f, -0.06735614f, -0.08487280f, 0.01765262f, -0.08462917f, 0.00553481f, 0.02209686f, 
    0.00034766f, 0.10419641f, -0.02408137f, 0.12563555f, -0.00758554f, 0.16028877f, -0.11387047f, 0.02280127f, 
    0.02647992f, -0.13756433f, -0.05216537f, -0.07652491f, -0.11749096f, 0.01242530f, -0.03606561f, -0.08900834f, 
    -0.13934466f, 0.09886408f, -0.01088102f, -0.06016203f, 0.12331132f, 0.08008615f, -0.07557912f, -0.03155361f, 
    -0.04290382f, 0.00654564f, -0.01194867f, -0.07676277f, -0.13485147f, -0.00122398f, -0.03539239f, -0.06956590f, 
    -0.05562956f, -0.11715214f, -0.09285216f, -0.05103472f, 0.01749167f, -0.02678848f, -0.01136396f, -0.14683515f, 
    0.18910198f, 0.19257842f, 0.04060453f, 0.00496591f, 0.15119734f, 0.10981103f, 0.05465238f, -0.07425100f, 
    0.02963946f, 0.08566006f, -0.02383843f, -0.09631315f, 0.14399296f, -0.14337084f, 0.01986564f, 0.25131157f, 
    -0.05176717f, -0.04425090f, -0.03154380f, 0.01769359f, 0.00388519f, -0.04773014f, 0.16553164f, -0.09257124f, 
    -0.00891522f, 0.10204883f, -0.00511516f, 0.05289099f, 0.01186965f, 0.05897937f, 0.14058253f, -0.02415016f, 
    -0.05447071f, 0.05128908f, 0.01683055f, 0.03099966f, -0.18939702f, 0.08870047f, 0.11510040f, -0.10778611f, 
    -0.14209473f, 0.02171499f, -0.02448878f, -0.08377794f, -0.02508473f, -0.02085194f, 0.10927028f, 0.00041788f, 
    0.02560731f, -0.10302968f, -0.10538099f, 0.03641364f, 0.10790590f, 0.15216050f, 0.13542739f, -0.00771806f, 
    0.01839863f, 0.04216828f, 0.06971094f, 0.10176340f, -0.02963892f, -0.08048374f, 0.02725696f, 0.01754708f, 
    -0.16304100f, 0.08789193f, -0.00732170f, -0.10296948f, -0.04957850f, -0.10851725f, 0.07949141f, -0.00500288f, 
    -0.08172193f, 0.13889177f, -0.04577627f, -0.02375649f, -0.06205283f, -0.11776140f, 0.13356110f, 0.03958344f, 
    0.06521036f, -0.01053009f, 0.01896832f, -0.02250759f, -0.41167819f, -0.11501107f, 0.03619946f, -0.06756510f, 
    -0.01218386f, -0.24297501f, 0.03272753f, -0.15057753f, -0.03909335f, 0.07146166f, -0.04687847f, 0.07083991f, 
    -0.01096712f, -0.10683596f, -0.00368001f, -0.03619314f, 0.01663577f, 0.05351873f, -0.06368168f, -0.17380226f, 
    0.12937656f, 0.08056490f, -0.03675019f, -0.01419086f, 0.12359023f, 0.23641840f, -0.14842151f, 0.07653292f, 
    0.08514664f, -0.00328848f, 0.01023227f, 0.04573802f, -0.03477218f, 0.00481291f, -0.13660339f, -0.06995435f, 
    -0.22716603f, 0.04688566f, -0.10238854f, 0.00207232f, -0.01256352f, -0.17529121f, -0.13602461f, 0.04907725f, 
    -0.01647870f, 0.06075382f, 0.04164419f, 0.03382649f, 0.13458401f, -0.03782589f, 0.20652887f, 0.06967553f, 
    0.02260963f, -0.05355828f, 0.09130859f, 0.04958616f, -0.15013976f, -0.02006966f, 0.04305413f, -0.04791976f, 
    0.17782594f, -0.01569874f, 0.12303215f, -0.04456681f, 0.05029714f, 0.08135165f, -0.04327281f, 0.05640949f, 
    -0.14872533f, 0.00784353f, -0.12104272f, -0.11167844f, 0.00382615f, -0.19596356f, -0.18904044f, -0.07710990f, 
    0.08841277f, 0.10555299f, -0.02192108f, -0.17263782f, -0.04067054f, -0.03315001f, 0.00889068f, -0.07800123f, 
    -0.16364095f, -0.11407823f, -0.09293930f, -0.25714648f, 0.01892196f, 0.12454092f, -0.14875373f, -0.11590432f, 
    -0.00621981f, 0.04900530f, -0.10104311f, 0.02150409f, 0.32363355f, 0.14695825f, 0.10386340f, 0.10743434f, 
    0.10574871f, 0.07179431f, 0.09398863f, -0.08834222f, 0.06437877f, -0.01539529f, -0.04700384f, -0.14860451f, 
    -0.32114068f, -0.03985845f, 0.05851170f, -0.23230875f, -0.07146747f, 0.00710759f, 0.02583564f, 0.06025980f, 
    0.18115130f, 0.05847922f, -0.00048295f, 0.10838993f, 0.09704939f, 0.11513090f, -0.05024087f, 0.11683425f, 
    -0.03023591f, 0.00184717f, 0.04318239f, -0.05674370f, 0.03965691f, 0.08674598f, -0.08591782f, -0.06547797f, 
    -0.01057810f, 0.12621328f, -0.24444158f, 0.11779440f, -0.03014601f, 0.00053920f, -0.02143863f, -0.02987877f, 
    -0.11755470f, -0.05458212f, 0.04965404f, -0.10840781f, -0.09291448f, -0.12014369f, 0.17593379f, -0.15732984f, 
    -0.02654892f, 0.01908986f, -0.05094348f, 0.09277877f, -0.03384990f, -0.07940406f, -0.08827727f, -0.16340975f, 
    -0.18796659f, -0.42204154f, 0.23089565f, -0.18259817f, -0.20176645f, -0.09347148f, 0.22317640f, -0.05120283f, 
    0.05639271f, -0.00754131f, 0.09804460f, 0.09723171f, 0.24898988f, 0.01623669f, 0.11705001f, 0.06566519f, 
    0.07941604f, 0.07257870f, -0.00939610f, -0.03821634f, 0.00548878f, -0.09287919f, -0.11877733f, -0.05087913f, 
    0.10931049f, 0.12493697f, -0.17636308f, 0.14008641f, -0.05844725f, -0.09531669f, 0.13187285f, -0.01679882f, 
    -0.05719320f, -0.07115703f, 0.03390458f, -0.06752429f, 0.28571147f, 0.12082245f, -0.17020570f, -0.03007559f, 
    0.13581170f, 0.11548570f, 0.01546041f, -0.05957580f, -0.02447942f, 0.04375046f, -0.01381030f, 0.02572129f, 
    0.08778758f, 0.03952835f, -0.07310749f, 0.08105785f, -0.12218612f, -0.08146241f, 0.06999617f, 0.10199961f, 
    0.04850462f, 0.02148363f, 0.07749637f, 0.01769583f, -0.20673417f, 0.07451899f, -0.04409534f, 0.04025897f, 
    0.08019385f, -0.16627893f, -0.03031516f, 0.01837955f, -0.22276749f, -0.04920620f, -0.22736195f, -0.03444176f, 
    0.00914127f, 0.08189163f, 0.15913843f, 0.05904102f, -0.04641850f, 0.07999589f, -0.03944552f, 0.17578901f, 
    -0.09771783f, -0.02495069f, 0.01973257f, 0.00941426f, 0.05415552f, -0.14035542f, -0.19985737f, 0.03763564f, 
    -0.07136427f, -0.13932966f, -0.05614304f, -0.01986395f, -0.10869202f, -0.00895502f, 0.02066409f, -0.01825075f, 
    -0.22400399f, -0.09863268f, 0.31229842f, -0.21918644f, 0.10909269f, 0.07985914f, -0.11348245f, 0.00077437f, 
    0.05298367f, 0.00679186f, -0.07249772f, 0.04557747f, 0.01711415f, 0.02294743f, 0.03599875f, 0.10076772f, 
    0.11330651f, 0.18114606f, 0.06173307f, 0.23590130f, -0.05121603f, 0.05121026f, -0.00891285f, 0.04589404f, 
    -0.21862538f, 0.15144829f, -0.08585856f, -0.08190677f, -0.02211592f, 0.02013447f, -0.02054121f, -0.13891855f, 
    0.03945834f, 0.00885876f, 0.11299126f, 0.10283857f, -0.07612702f, 0.16039312f, 0.21378163f, -0.16781192f, 
    0.00025531f, 0.04425116f, -0.04394600f, -0.19192013f, -0.11708976f, -0.08990081f, -0.05616631f, -0.12693068f, 
    -0.16020037f, 0.05741496f, -0.02001495f, 0.09548013f, -0.02882025f, -0.01050720f, -0.04212831f, -0.14015874f, 
    -0.13288814f, 0.03980586f, -0.11610539f, -0.17004101f, 0.19168916f, 0.07182604f, 0.02263571f, 0.04978832f, 
    0.13794735f, 0.13512683f, -0.01597384f, -0.17496158f, -0.04094657f, -0.00171235f, -0.04642774f, -0.04676746f, 
    0.09870215f, -0.21833389f, -0.00112787f, -0.06551322f, -0.03474142f, -0.05674818f, 0.02643970f, -0.22146513f, 
    -0.03321355f, 0.18471949f, 0.04305861f, 0.10059159f, -0.15769422f, 0.11817563f, -0.00641259f, -0.12441391f, 
    0.12726785f, 0.03467207f, -0.02311197f, -0.05143598f, 0.17265841f, 0.07003395f, 0.10360336f, 0.13073057f, 
    0.10464364f, -0.16946220f, 0.08906144f, -0.10789181f, 0.02582383f, 0.14488618f, 0.02048969f, 0.01664834f, 
    -0.00541954f, 0.07951709f, 0.11895037f, 0.10717378f, -0.29437515f, -0.16455729f, -0.04888076f, -0.18001723f, 
    -0.01361105f, -0.00776473f, -0.06849323f, -0.11470794f, -0.01134812f, -0.05204446f, -0.17246546f, 0.01607126f, 
    -0.05065243f, 0.18312719f, -0.13670047f, -0.03321919f, 0.02991710f, -0.07607051f, 0.13605595f, 0.06040442f, 
    0.07526816f, -0.11696534f, -0.06200726f, -0.12723848f, 0.21651331f, 0.07742180f, -0.05835681f, 0.02045110f, 
    0.06892110f, 0.01530756f, -0.02511203f, 0.01663687f, -0.05249044f, -0.02834505f, -0.15256159f, -0.24350141f, 
    -0.13424757f, 0.20145427f, -0.19213034f, -0.18443222f, 0.12504175f, -0.16185986f, -0.00718848f, -0.08410605f, 
    -0.00774975f, -0.08099468f, -0.00185103f, 0.04095836f, -0.16568890f, 0.19513741f, -0.11173473f, 0.07145006f, 
    -0.03483921f, -0.00844147f, -0.01027080f, -0.14521419f, 0.02075368f, 0.01739212f, 0.03460927f, -0.02725230f, 
    0.02562993f, -0.02673290f, -0.22457422f, -0.24972752f, 0.12524672f, 0.04052933f, 0.03446385f, 0.04783162f, 
    -0.04129091f, 0.11084621f, 0.06300243f, 0.03008258f, -0.05892503f, 0.03832959f, 0.00010416f, -0.01885129f, 
    -0.03514725f, -0.00464487f, 0.04516613f, -0.01609223f, 0.00085979f, -0.09618289f, 0.04537722f, -0.03962652f, 
    0.06197876f, -0.03875095f, -0.02875817f, -0.02657444f, -0.00833347f, 0.11647164f, -0.03514699f, 0.11060342f, 
    -0.06702078f, -0.07929004f, 0.03877847f, -0.07549477f, -0.12469707f, 0.12083971f, -0.24429619f, 0.04824144f, 
    -0.01492202f, 0.08252156f, 0.22313163f, 0.04431418f, 0.06207481f, 0.02243212f, 0.02533633f, 0.03674639f, 
    -0.10391523f, -0.02916782f, -0.04078168f, -0.07369317f, 0.00814219f, 0.01372752f, 0.02634157f, -0.05419343f, 
    -0.02435655f, 0.10821038f, 0.18431664f, 0.13570642f, 0.47286367f, 0.14512058f, 0.02888708f, 0.45857698f, 
    0.02367220f, -0.12585212f, 0.09406735f, -0.04822147f, -0.09899097f, 0.07285053f, 0.01879575f, -0.05834041f, 
    -0.01953672f, 0.03501554f, -0.13973077f, 0.05482299f, -0.00580331f, -0.06437896f, 0.00909733f, 0.07046559f, 
    -0.07731186f, -0.10387559f, -0.09620440f, -0.13455102f, 0.02449469f, 0.20947671f, -0.14154762f, -0.06085498f, 
    0.07235180f, 0.04455835f, 0.07782353f, -0.07267586f, 0.03916454f, -0.10675474f, -0.04713447f, -0.09605993f, 
    -0.08372194f, -0.05381631f, -0.05098775f, -0.10562987f, 0.11217839f, -0.01770075f, -0.05993451f, 0.07721694f, 
    -0.07112997f, -0.03581850f, 0.13018939f, -0.04716317f, -0.17177881f, 0.02730479f, 0.03607813f, 0.11468134f, 
    -0.03234171f, 0.00403862f, 0.04670065f, -0.07526647f, 0.11902191f, 0.04979222f, -0.00287231f, 0.01643232f, 
    0.04830210f, 0.06283830f, 0.08011366f, 0.09883737f, 0.03775764f, -0.00977890f, -0.01663336f, 0.07744131f, 
    -0.05844829f, -0.01866677f, -0.02288955f, -0.05035812f, 0.13338661f, 0.14823030f, -0.10065444f, 0.00875286f, 
    0.11581367f, 0.03365569f, 0.06320881f, -0.06543302f, -0.18733627f, -0.04990618f, -0.04191561f, -0.18015414f, 
    0.39812702f, 0.03393033f, -0.36394173f, 0.22953829f, -0.05214148f, 0.08023774f, 0.14623353f, -0.13258940f, 
    -0.13757101f, -0.10949204f, 0.03761153f, -0.06623416f, -0.19607083f, -0.01502132f, 0.26099235f, 0.02819932f, 
    0.07336203f, -0.01289029f, 0.10021902f, -0.04731132f, 0.08476645f, 0.06659238f, -0.04358345f, 0.14620045f, 
    -0.07152031f, 0.02780340f, 0.05744680f, 0.07948997f, 0.00703197f, 0.09160911f, 0.00304792f, -0.02123636f, 
    0.06890830f, -0.07076626f, -0.09679852f, 0.03253311f, -0.18995139f, -0.16885504f, 0.08070815f, -0.02407086f, 
    0.00624109f, -0.02130859f, 0.05504138f, -0.05214266f, -0.08975942f, -0.08687570f, -0.09647082f, -0.09285371f, 
    -0.30701211f, 0.00849563f, 0.06077613f, -0.17853160f, 0.01797165f, -0.01894988f, 0.10665365f, 0.07457259f, 
    0.01751550f, 0.04544467f, 0.14867327f, 0.02817277f, 0.09263210f, 0.13488278f, -0.07295556f, 0.04019912f, 
    -0.13434784f, -0.14051749f, -0.16744702f, -0.03734807f, -0.10806969f, -0.10541683f, -0.12727962f, -0.05673197f, 
    -0.06037664f, -0.25275704f, -0.07562974f, -0.04556488f, 0.02176723f, 0.00593939f, 0.01434113f, 0.06033850f, 
    -0.10554881f, -0.08762828f, 0.00089370f, -0.02745803f, 0.10123988f, -0.12353709f, 0.17513038f, 0.07543848f, 
    0.00828810f, 0.00515360f, 0.02323426f, 0.05796431f, -0.02459529f, 0.10459886f, 0.09199232f, 0.11750981f, 
    -0.19545677f, 0.15133294f, -0.00843497f, -0.21248157f, -0.22514968f, -0.02529707f, -0.04097156f, -0.15303186f, 
    0.08400896f, -0.10140624f, -0.07997285f, 0.03632608f, 0.10355103f, -0.04683587f, -0.02787100f, 0.06855359f, 
    0.06203645f, 0.07307406f, 0.05497796f, 0.00443330f, 0.16622913f, 0.15445513f, 0.15085657f, 0.10478935f, 
    0.24318247f, 0.08377042f, 0.09381632f, -0.11742759f, 0.03427291f, -0.04272424f, -0.01672849f, -0.00266628f, 
    -0.17725198f, -0.04847697f, -0.09966814f, -0.07812662f, 0.39002693f, 0.13997729f, -0.12434448f, -0.07741571f, 
    0.09407162f, 0.07572683f, 0.08246140f, 0.06379096f, 0.03486497f, -0.03427442f, -0.04851802f, 0.08606554f, 
    0.08135837f, 0.07856412f, 0.19522803f, 0.02817191f, 0.04458853f, -0.13904573f, -0.01481046f, 0.19353840f, 
    -0.12888236f, -0.11308032f, -0.05068940f, -0.12872815f, 0.16982508f, -0.17792405f, 0.03081249f, 0.14971223f, 
    -0.02298372f, 0.06367636f, 0.01994741f, 0.08526959f, 0.08755034f, 0.04518307f, 0.07818741f, 0.00143363f, 
    0.31189114f, -0.12873393f, -0.00900609f, -0.15719958f, -0.00604903f, -0.08892156f, -0.13417572f, 0.14712127f, 
    -0.07306231f, 0.01597888f, 0.00752057f, 0.03112436f, 0.22837365f, -0.00197175f, 0.13516806f, 0.02586847f, 
    -0.05056720f, 0.03248691f, 0.05707119f, 0.00504965f, 0.00420956f, 0.04883068f, -0.02457662f, 0.02478831f, 
    -0.12009954f, 0.18268028f, 0.01662588f, 0.09922394f, 0.13076580f, -0.00397999f, 0.11084821f, 0.08990187f, 
    0.06777715f, -0.13181064f, -0.05736750f, 0.00351554f, 0.32588756f, -0.02366034f, 0.05615013f, 0.10516661f, 
    0.05709620f, -0.03543343f, 0.08553109f, 0.05287022f, -0.07520086f, -0.00034701f, -0.03018866f, -0.04727263f, 
    -0.07620979f, -0.02650585f, 0.05969116f, 0.05908294f, -0.01531368f, 0.01019192f, -0.06668070f, 0.02905886f, 
    0.00461538f, 0.01966073f, -0.02969817f, -0.13271098f, 0.13644002f, 0.02971722f, 0.04343414f, 0.28187016f, 
    -0.03010293f, 0.06031349f, -0.12464314f, -0.01899436f, 0.12065125f, 0.05320782f, 0.11994436f, 0.10239998f, 
    -0.12743403f, 0.00731937f, 0.06518728f, -0.02649878f, 0.04356329f, 0.05770547f, 0.04333461f, 0.07359891f, 
    0.01603176f, -0.01242281f, 0.04509530f, 0.02053439f, -0.18739785f, 0.03081088f, -0.04779214f, -0.24772467f, 
    -0.01432534f, -0.10945573f, 0.09473333f, 0.04223017f, 0.14553985f, -0.15477264f, -0.05196723f, -0.00839752f, 
    -0.12617253f, 0.13880339f, -0.11270281f, -0.30740198f, -0.22022037f, -0.07512393f, -0.03750003f, -0.01486517f, 
    0.06145374f, 0.08564372f, 0.20046145f, -0.02006630f, 0.02574420f, 0.00486762f, -0.16062015f, -0.13720903f, 
    -0.14214300f, -0.10262428f, -0.04916887f, -0.01466234f, -0.07899064f, -0.02643798f, 0.05735883f, 0.11363131f, 
    -0.12987457f, 0.29959124f, 0.09796622f, -0.02123404f, -0.08184157f, -0.04072633f, 0.02015430f, -0.10212553f, 
    0.05866309f, 0.04987800f, -0.19606027f, -0.04582679f, 0.19099964f, 0.06590892f, -0.10994643f, -0.07807135f, 
    0.04903574f, 0.15085395f, 0.05473380f, 0.06751963f, -0.04995003f, -0.05875365f, -0.03029643f, -0.00577189f, 
    0.07464483f, 0.10621895f, 0.15031368f, 0.10701376f, 0.03094378f, 0.10455573f, 0.01248162f, 0.02812101f, 
    0.05585055f, 0.07498560f, -0.01509385f, -0.02494418f, 0.13300788f, 0.16988783f, 0.10215402f, 0.06058638f, 
    -0.12127727f, -0.11864695f, 0.03942037f, 0.00538986f, -0.12528417f, -0.00673857f, -0.11207090f, -0.08960589f, 
    0.02187316f, 0.00978614f, 0.15891728f, -0.07897712f, -0.08606563f, 0.04774343f, -0.05992489f, -0.02832997f, 
    0.06660900f, 0.02777225f, -0.13136978f, -0.03079390f, -0.14825739f, -0.01747920f, -0.11027814f, -0.09121034f, 
    -0.04071385f, -0.05518558f, 0.06474663f, -0.01029612f, -0.04295896f, -0.05340501f, 0.07830314f, 0.13922867f, 
    0.45405686f, -0.02480513f, -0.35029379f, -0.07872139f, 0.01575689f, 0.03202161f, 0.23087391f, -0.01449803f, 
    0.00250207f, 0.01492225f, -0.14806037f, 0.05188280f, -0.16654471f, 0.06501035f, -0.02637289f, -0.07734324f, 
    -0.03518220f, 0.14764811f, -0.04204376f, 0.06048042f, 0.12648246f, -0.12004869f, 0.09266482f, 0.19090101f, 
    0.00660824f, 0.19055267f, 0.16567336f, -0.19286570f, -0.03674442f, -0.02095686f, 0.01194347f, 0.07195851f, 
    0.04396655f, 0.05298014f, -0.09466296f, -0.02408158f, 0.10698872f, 0.10849352f, -0.09576783f, -0.19532019f, 
    -0.06991701f, -0.03605758f, -0.02041703f, -0.08358404f, -0.01104264f, -0.14982291f, -0.06843267f, -0.02213414f, 
    0.35688367f, 0.27342439f, 0.01930310f, 0.02219811f, -0.06728695f, -0.00913673f, 0.04406368f, 0.15888505f, 
    -0.00611092f, 0.00688800f, -0.04632161f, 0.00720939f, 0.11263870f, 0.15174821f, -0.07939278f, 0.14011994f, 
    0.09810940f, 0.02402860f, 0.01767728f, 0.08914915f, 0.06299611f, 0.29605263f, 0.00260440f, 0.02203489f, 
    -0.28344622f, 0.15327279f, -0.03530809f, -0.09143533f, -0.05001045f, -0.10792014f, -0.00826505f, 0.04505632f, 
    0.09961231f, -0.03765452f, 0.09375104f, -0.00372526f, 0.11458681f, 0.00900749f, 0.08273946f, 0.24785669f, 
    -0.03778685f, 0.21353103f, 0.03755823f, 0.00537428f, 0.04124701f, 0.01146649f, 0.03342798f, 0.06646704f, 
    -0.16653553f, 0.05040548f, 0.17482607f, 0.15348211f, 0.01424236f, 0.12661655f, 0.09679391f, -0.06771769f, 
    0.01259410f, -0.03937148f, -0.03304741f, -0.10880198f, 0.03240494f, 0.08422314f, 0.05739354f, -0.09391730f, 
    -0.03094973f, -0.12391526f, -0.03758338f, 0.06001725f, 0.01440535f, 0.03052095f, -0.06062157f, -0.02163795f, 
    -0.08595248f, 0.18692605f, 0.05954383f, -0.01975905f, -0.04337106f, 0.07035065f, 0.05596817f, -0.00186706f, 
    -0.01261512f, -0.05128679f, -0.05858666f, -0.13268504f, -0.15422474f, -0.09022728f, 0.10438126f, 0.17131355f, 
    -0.10807352f, 0.04737910f, 0.13479678f, -0.08958351f, 0.12931602f, 0.03414250f, 0.24148393f, 0.14920528f, 
    0.17392871f, 0.07381590f, 0.26475927f, 0.01832790f, 0.04226680f, 0.00289543f, 0.05225578f, -0.06248857f, 
    0.03394116f, -0.04760078f, 0.10255150f, 0.21826901f, 0.02751526f, 0.15855639f, 0.10286913f, -0.21136585f, 
    -0.08105676f, 0.05302623f, 0.06757827f, 0.02703429f, 0.00955836f, -0.06607591f, 0.00846238f, 0.04367379f, 
    0.08900701f, 0.05043058f, 0.04592986f, 0.00885163f, 0.07597435f, -0.04280048f, -0.01468861f, 0.08564840f, 
    -0.02173819f, 0.12193622f, -0.08907765f, -0.10742142f, -0.11787925f, -0.35155860f, 0.23787992f, -0.03632573f, 
    0.06293948f, 0.08520955f, -0.14798623f, 0.05922763f, -0.02135101f, -0.02970833f, -0.02952027f, -0.05115182f, 
    0.07985866f, 0.17717385f, -0.00679731f, -0.06845237f, -0.11842956f, -0.05355066f, 0.08537021f, -0.03760956f, 
    0.02480417f, -0.02443949f, -0.25319996f, -0.04109713f, 0.17961584f, 0.07936244f, -0.02084806f, 0.16920552f, 
    0.10251416f, 0.05817549f, 0.11720897f, 0.06243956f, 0.02538604f, 0.04313443f, 0.07908803f, 0.10893223f, 
    -0.24768387f, 0.08793671f, 0.15522952f, 0.05100106f, 0.04491124f, -0.02877014f, 0.01759627f, -0.12286358f, 
    0.01172945f, 0.07425975f, -0.10060797f, -0.00393394f, 0.16138239f, 0.07309771f, 0.07230399f, 0.08295421f, 
    0.09582089f, 0.04525662f, 0.08617929f, 0.06370781f, 0.00189260f, 0.12327813f, 0.12333586f, 0.05987694f, 
    -0.07408308f, -0.16059998f, -0.00902364f, -0.27537602f, 0.12966938f, 0.02166576f, 0.16652110f, 0.10090620f, 
    0.09251374f, 0.01752917f, -0.07217180f, -0.15983137f, -0.18243240f, -0.02754165f, 0.14562844f, 0.07400064f, 
    0.19770464f, 0.05165323f, -0.00964845f, -0.07992857f, 0.09651465f, -0.01683527f, 0.09852485f, 0.10753064f, 
    0.02892358f, 0.14931303f, 0.15880723f, 0.39390600f, -0.01116416f, -0.05809368f, -0.07411681f, 0.00322432f, 
    -0.08018368f, -0.05517058f, -0.03224000f, -0.03732502f, 0.18469293f, -0.09418764f, -0.10292593f, -0.00353588f, 
    -0.04585318f, 0.04648833f, 0.08799221f, 0.19752602f, 0.12771603f, 0.12064018f, 0.07730974f, -0.04643793f, 
    0.11243755f, 0.15492734f, 0.11090292f, -0.11941586f, -0.04289916f, -0.09761663f, 0.12722363f, 0.05316215f, 
    0.04036191f, 0.06923662f, 0.13793732f, 0.11573014f, -0.16000979f, -0.04436575f, 0.31753799f, 0.17968190f, 
    -0.03148202f, 0.04333718f, -0.08945197f, -0.03747519f, 0.02813532f, -0.01434745f, 0.07742132f, -0.09400845f, 
    0.16416599f, 0.00927222f, 0.04627090f, 0.02085495f, -0.01100061f, 0.03027246f, 0.07733083f, -0.04548299f, 
    -0.06262170f, -0.06703205f, -0.13665873f, -0.05115124f, 0.50763637f, -0.13496645f, 0.04287441f, -0.16694377f, 
    0.05785682f, 0.13750602f, -0.12156550f, 0.16777013f, -0.01629084f, 0.04168096f, -0.03708157f, 0.03653117f, 
    0.09360980f, -0.19563545f, 0.02545474f, 0.17688444f, -0.05971914f, 0.08639038f, 0.09024482f, -0.00153973f, 
    0.00453675f, 0.06349289f, -0.05866711f, 0.18777293f, 0.10283902f, -0.13364804f, 0.02721182f, 0.05280707f, 
    0.08578097f, 0.08754282f, -0.09902035f, 0.06829577f, 0.19246219f, 0.02058498f, 0.08053318f, 0.05787427f, 
    0.09641346f, 0.09710488f, 0.03974140f, 0.12393382f, 0.09978271f, 0.13591418f, 0.04069009f, -0.11645398f, 
    0.05524172f, 0.05523570f, -0.05308731f, 0.08105712f, -0.19975147f, 0.00149001f, 0.14583538f, 0.08572602f, 
    -0.01912674f, -0.05625260f, -0.10128049f, 0.07468367f, 0.09989913f, -0.09503691f, 0.09182153f, 0.06462669f, 
    0.06697895f, 0.14517689f, 0.17339250f, 0.03251387f, 0.11624949f, 0.11363109f, 0.14806093f, 0.04982688f, 
    0.02312691f, -0.00429973f, -0.00670973f, 0.01191218f, 0.02137909f, -0.00699716f, -0.05834446f, -0.09586816f, 
    0.20924813f, 0.11388960f, -0.01896211f, 0.14399169f, 0.05691087f, 0.00339710f, 0.02825326f, 0.01160157f, 
    0.08515725f, 0.05327055f, -0.36099958f, -0.11273032f, 0.17975821f, -0.02844881f, -0.06371846f, 0.09875803f, 
    -0.01904500f, 0.04009401f, -0.07463197f, 0.05103898f, -0.07582113f, -0.16517994f, -0.09919009f, 0.08210500f, 
    0.13800445f, -0.02054916f, -0.04435761f, -0.01042481f, 0.00385800f, 0.03178967f, 0.07449163f, 0.06742807f, 
    -0.05264224f, -0.04451656f, -0.06991509f, 0.00900135f, -0.01160307f, -0.04312917f, -0.08100935f, 0.03261056f, 
    0.01270550f, 0.07580356f, 0.06744021f, -0.06593183f, -0.08207846f, -0.07750791f, -0.03511680f, 0.07583804f, 
    0.10581522f, -0.02565048f, 0.06236647f, 0.10320595f, 0.02129955f, -0.01927148f, -0.00393932f, 0.04381901f, 
    -0.34623200f, 0.32246685f, -0.00693654f, -0.08456092f, 0.09402607f, 0.00137337f, 0.06394905f, 0.05562908f, 
    0.14904632f, -0.04641166f, 0.03228000f, -0.07687605f, 0.03663483f, -0.02453715f, 0.03105020f, -0.11333323f, 
    -0.00229647f, 0.11588856f, -0.01553219f, 0.06624844f, 0.13549814f, -0.09008156f, -0.01094433f, -0.10719199f, 
    -0.06312630f, 0.10496016f, 0.07418548f, -0.28181106f, 0.08635461f, 0.04678911f, 0.13523257f, 0.18126301f, 
    0.04021599f, -0.05575297f, 0.02891598f, -0.07016652f, 0.15573071f, -0.15660092f, -0.07193833f, 0.09234853f, 
    -0.04564881f, -0.06185958f, -0.06759955f, -0.05270912f, 0.08281115f, -0.07879754f, 0.01737121f, -0.07715847f, 
    0.01384177f, -0.02003433f, 0.00287865f, 0.05928985f, -0.14799447f, -0.00078386f, -0.04644769f, 0.13026920f, 
    -0.01437755f, 0.03591573f, 0.08379337f, -0.11592904f, -0.08325032f, -0.02957018f, 0.01918963f, 0.07769083f, 
    -0.03896962f, -0.03506392f, -0.09691556f, -0.05278209f, -0.02687487f, -0.03447976f, -0.03640337f, -0.05380220f, 
    0.01905679f, 0.25018108f, 0.14115585f, -0.11799338f, 0.00172251f, 0.20569533f, -0.05688873f, 0.10539789f, 
    -0.00890701f, -0.08320156f, -0.10634745f, 0.04511913f, 0.19353263f, -0.05372985f, 0.03033045f, -0.15769710f, 
    0.12802461f, 0.13242824f, -0.07818255f, 0.00283877f, 0.16592468f, 0.08597710f, 0.08366714f, -0.07831538f, 
    -0.14686131f, 0.19791080f, 0.13391218f, 0.03547002f, -0.04270275f, 0.12112006f, 0.22865692f, -0.02377703f, 
    -0.08221642f, -0.03891240f, -0.03773525f, -0.03837748f, -0.02850899f, 0.03702123f, -0.05929930f, 0.03945876f, 
    0.03025922f, -0.03899303f, -0.08378565f, 0.09618287f, -0.01961062f, 0.01951424f, 0.04736563f, -0.02870003f, 
    0.19563921f, 0.16568683f, -0.01811374f, -0.11013744f, -0.01735275f, -0.01705877f, 0.07906472f, -0.03838163f, 
    0.08115330f, 0.00768683f, -0.11035062f, 0.00275414f, 0.17979166f, 0.00483981f, -0.05536027f, 0.02102441f, 
    -0.02871604f, -0.05574505f, -0.06698449f, 0.00738254f, 0.04069349f, -0.01496137f, -0.04938113f, 0.20130664f, 
    -0.23477599f, -0.12442286f, 0.20470385f, 0.17181641f, 0.00258977f, 0.00598734f, 0.17542130f, 0.14681314f, 
    0.09932415f, 0.02769177f, 0.11451874f, -0.06298271f, 0.36927882f, -0.08699253f, 0.27428129f, -0.05958074f, 
    -0.01584454f, 0.01781275f, -0.05396632f, -0.03285617f, 0.05002784f, -0.12575316f, -0.06747590f, -0.02533804f, 
    -0.10659773f, -0.06703081f, -0.07627781f, -0.04299328f, -0.06057511f, -0.05435191f, -0.05611654f, 0.01451642f, 
    0.06327450f, 0.06962057f, 0.14523113f, 0.14459051f, 0.03945529f, -0.08728701f, 0.19103584f, 0.11850956f, 
    0.04330852f, -0.09775555f, -0.04542561f, -0.04896101f, 0.11138493f, -0.12770663f, -0.16987148f, 0.02425182f, 
    0.08054955f, -0.08580541f, 0.10685407f, 0.12796070f, 0.04445204f, -0.00396048f, 0.03639631f, 0.00465504f, 
    -0.04737370f, 0.03980709f, 0.00108689f, -0.01176849f, -0.02566921f, -0.04736666f, -0.04029086f, -0.17925078f, 
    0.20152473f, -0.06531157f, 0.10132865f, -0.03808693f, -0.00482353f, 0.13827728f, -0.09472647f, -0.12008532f, 
    -0.16015534f, 0.34588793f, 0.08187072f, -0.17657968f, 0.00067293f, -0.02161550f, 0.00524189f, 0.12036925f, 
    0.15424210f, -0.00757747f, 0.05396048f, -0.00244233f, -0.06308317f, 0.11825707f, -0.08592433f, 0.00296662f, 
    -0.05330693f, -0.08570060f, 0.00528462f, -0.02901921f, 0.14708267f, 0.13753121f, 0.01949968f, -0.09220602f, 
    -0.12086309f, -0.06607245f, 0.02681660f, 0.06488792f, -0.05060786f, -0.06964555f, -0.05792148f, 0.04166718f, 
    0.00784552f, 0.12281387f, 0.14499381f, 0.00011986f, 0.08096504f, 0.24439417f, 0.28560081f, -0.03980722f, 
    0.05242665f, 0.00568091f, 0.01884284f, -0.02863644f, 0.00760973f, -0.01897640f, -0.10095256f, -0.18144809f, 
    -0.07947958f, -0.05980004f, 0.15973645f, -0.01460615f, -0.02521944f, 0.00835830f, -0.00118745f, -0.00133786f, 
    0.03554380f, 0.07084004f, 0.06025973f, 0.11046185f, -0.06959065f, 0.12107256f, 0.23037513f, 0.00587303f, 
    0.08749877f, 0.09800571f, 0.19638845f, -0.02087298f, -0.03664195f, -0.06822006f, -0.02127536f, 0.01778819f, 
    -0.00138073f, 0.08225336f, 0.04944550f, 0.03862617f, 0.04451601f, -0.09346160f, 0.13180396f, -0.06855017f, 
    -0.00588531f, 0.01203970f, -0.01596857f, -0.04083667f, -0.20042244f, -0.08690739f, -0.00151947f, -0.07372275f, 
    0.10059885f, 0.04707024f, -0.03012530f, 0.03264938f, 0.11131405f, -0.00222653f, -0.02735095f, -0.21495645f, 
    0.25107801f, -0.26121935f, -0.19674063f, -0.15396297f, 0.15513252f, 0.03128277f, -0.10297466f, -0.05451602f, 
    -0.01122030f, -0.01957406f, -0.03418806f, -0.04882414f, -0.16942050f, 0.40821451f, 0.13204621f, -0.16585672f, 
    0.04527728f, 0.00593735f, 0.11104310f, 0.15947795f, 0.12400628f, 0.08198521f, -0.15066943f, -0.11309339f, 
    0.07347196f, 0.17065643f, 0.05067886f, -0.16890873f, -0.05824612f, -0.11839359f, 0.11067218f, -0.05493538f, 
    0.01509048f, 0.05407571f, -0.03831749f, 0.05795925f, -0.20729339f, 0.23154728f, -0.02413300f, -0.02936606f, 
    0.00058988f, 0.00311843f, -0.00679072f, 0.03577582f, 0.11716329f, -0.03173186f, -0.06382463f, 0.04366433f, 
    0.00740661f, 0.10148941f, 0.10472604f, -0.24554279f, 0.10808250f, 0.09082638f, 0.07157147f, -0.03906205f, 
    -0.02158561f, 0.06351037f, -0.02746641f, 0.05979000f, 0.03866521f, -0.19465502f, 0.09734640f, 0.26994741f, 
    0.08148432f, 0.06741381f, 0.06374662f, 0.03111157f, 0.11217423f, -0.03380765f, -0.14395894f, 0.04765379f, 
    -0.31860659f, -0.16209213f, 0.00971151f, 0.01992460f, 0.08865388f, -0.05137914f, 0.16027683f, -0.04432986f, 
    0.11327051f, -0.17218238f, 0.05461465f, -0.01430859f, 0.11853687f, -0.05549457f, -0.03857272f, 0.02119161f, 
    -0.01881275f, -0.06585582f, -0.10817004f, -0.00957497f, -0.05820131f, -0.05608274f, -0.04439206f, -0.05222073f, 
    -0.08639099f, 0.04999341f, 0.24415405f, 0.08490556f, 0.06316260f, -0.02658736f, 0.01848009f, 0.08478173f, 
    0.00930670f, 0.04918693f, -0.01073237f, 0.04511410f, 0.03282595f, 0.05700548f, -0.02694971f, -0.16434518f, 
    -0.06946760f, 0.17508142f, 0.01525299f, 0.15740424f, 0.07172765f, -0.09021022f, -0.09632243f, -0.08304124f, 
    -0.06761981f, -0.04651305f, -0.03107443f, 0.06647339f, 0.08575647f, 0.01025382f, 0.04858824f, 0.28980419f, 
    -0.12157697f, 0.14379950f, 0.03238303f, -0.01942480f, -0.11835973f, -0.08697455f, -0.00464583f, 0.10126953f, 
    -0.04560944f, -0.08909221f, -0.06799804f, 0.01749317f, -0.07734284f, -0.15518749f, 0.07252914f, -0.01177932f, 
    0.09702814f, -0.19341257f, 0.16546769f, 0.25464135f, -0.00496534f, 0.07817276f, -0.06278637f, 0.01403982f, 
    0.06544603f, -0.01166045f, -0.01533112f, -0.19706342f, -0.05620690f, 0.20275229f, 0.19430421f, 0.12490397f, 
    0.02187000f, 0.05405810f, 0.05140933f, 0.05898108f, -0.02683373f, -0.05826024f, -0.02210157f, -0.16098697f, 
    0.06618284f, -0.13754997f, -0.12109191f, -0.05367118f, 0.06679574f, 0.00694992f, -0.00864412f, -0.09087660f, 
    -0.00763537f, 0.01638272f, 0.07366665f, -0.06282860f, -0.05187689f, -0.10518240f, -0.11897432f, -0.05373471f, 
    0.02721049f, 0.07587509f, 0.16709644f, 0.08024981f, 0.18680759f, 0.02736834f, 0.04152302f, 0.03843753f, 
    -0.13835314f, -0.02272472f, -0.00838915f, -0.15630522f, -0.09492716f, 0.00516730f, -0.03270454f, 0.06527373f, 
    0.13973708f, 0.10995979f, 0.01527642f, -0.09459858f, -0.09753313f, -0.04791499f, 0.20864034f, 0.05189183f, 
    0.01105195f, -0.01902069f, -0.11720394f, -0.08008726f, -0.04983598f, -0.09443472f, 0.00711709f, -0.01556873f, 
    -0.13720016f, -0.12328429f, 0.35941055f, 0.01658364f, -0.00613828f, -0.09051143f, 0.06125599f, 0.14378163f, 
    0.02228753f, -0.00589991f, -0.05271449f, 0.03339279f, 0.06788757f, 0.12821035f, 0.15161274f, -0.00649340f, 
    -0.00480335f, 0.08866855f, 0.00497752f, 0.07113899f, 0.12630543f, 0.04087384f, -0.15658702f, -0.09861965f, 
    -0.02431510f, -0.12713268f, 0.07865983f, -0.16005202f, 0.23713034f, 0.23499353f, -0.08714673f, 0.14492358f, 
    -0.02453172f, -0.12606065f, 0.03609697f, 0.14244998f, 0.08819218f, -0.22034569f, 0.08250082f, 0.24898657f, 
    -0.01306424f, 0.02008125f, 0.05911199f, 0.10475405f, 0.10043428f, 0.03464412f, 0.09563887f, 0.15686361f, 
    -0.17573602f, -0.18765356f, -0.02263284f, 0.15404893f, -0.15321499f, -0.08285892f, -0.06762479f, -0.04690616f, 
    0.00627252f, 0.00719019f, 0.08198131f, 0.03594156f, 0.04528236f, 0.05054856f, 0.01834782f, -0.22560167f, 
    0.05148011f, -0.00801515f, -0.05290491f, 0.09749530f, -0.07294807f, -0.06228088f, -0.03883310f, -0.13181815f, 
    0.16105317f, 0.06817006f, 0.04054634f, -0.04793297f, 0.07621933f, 0.05037799f, -0.04507246f, -0.10839663f, 
    0.06694766f, -0.00159146f, -0.03007698f, -0.04760564f, -0.01267733f, -0.04631289f, 0.17916070f, 0.17284216f, 
    0.05984390f, -0.09331036f, 0.22594954f, 0.17821702f, 0.06280406f, 0.02898942f, -0.05519908f, -0.00422383f, 
    0.06001223f, -0.08056183f, 0.04692290f, -0.03290101f, 0.07738472f, 0.09723242f, -0.05157911f, 0.06040555f, 
    0.04291232f, -0.03131633f, -0.02098891f, 0.10722627f, 0.38077596f, -0.09245884f, -0.53456759f, -0.33484790f, 
    -0.18296282f, 0.14956772f, 0.05385065f, 0.08712837f, -0.01931830f, -0.09364509f, 0.03864476f, 0.07160073f, 
    0.11859789f, 0.10298166f, 0.01598894f, -0.01280195f, 0.00966926f, -0.00502581f, -0.04615929f, -0.01147407f, 
    0.06323247f, -0.11132501f, -0.02698481f, -0.13463600f, 0.03222765f, -0.08731760f, 0.14836547f, 0.01411577f, 
    0.08278814f, -0.02987687f, -0.04201564f, -0.03532853f, 0.06630792f, 0.02170078f, -0.06235155f, -0.09169339f, 
    -0.10425200f, -0.15870288f, 0.06871273f, -0.10864472f, 0.05197183f, -0.03625236f, -0.00640779f, 0.05229386f, 
    -0.04308466f, 0.07351782f, 0.10280098f, 0.00229263f, 0.26424980f, -0.26766828f, -0.01036335f, 0.10066544f, 
    -0.02480050f, 0.11705326f, 0.13439432f, 0.04316807f, 0.01369970f, 0.01249389f, 0.03858880f, -0.01562035f, 
    -0.12032156f, 0.13446023f, 0.04777144f, 0.22602881f, 0.02518632f, 0.02358040f, 0.05224890f, 0.11659215f, 
    -0.01748702f, -0.01135249f, 0.03641991f, 0.00099786f, -0.02887576f, -0.11137683f, 0.10363830f, 0.02407836f, 
    0.02509734f, 0.01490103f, 0.14338760f, 0.06030642f, -0.09094261f, -0.01155811f, -0.02228121f, -0.06936684f, 
    -0.07046696f, 0.13485305f, -0.04992512f, 0.16581723f, 0.07139255f, 0.12086073f, 0.19614066f, -0.13533254f, 
    0.00010610f, -0.06488559f, -0.07682367f, -0.14980210f, -0.12550832f, -0.08927590f, 0.04898855f, 0.23252758f, 
    -0.03514825f, 0.02149843f, -0.05925077f, 0.05337858f, 0.01853954f, 0.19112429f, -0.03659963f, -0.01099414f, 
    -0.05434466f, -0.11553516f, 0.07593733f, -0.02695480f, 0.26885369f, 0.09928263f, -0.09027299f, -0.00449624f, 
    0.09524097f, 0.09801497f, -0.03350125f, -0.03876032f, -0.21089660f, -0.08860378f, 0.01810352f, 0.05406417f, 
    0.02843031f, 0.15144785f, 0.05437296f, -0.02809375f, -0.03287850f, 0.06581506f, 0.00714813f, -0.01187108f, 
    -0.01856440f, 0.02281991f, 0.05787027f, 0.05043272f, 0.10899267f, -0.02232669f, 0.19136448f, 0.01304562f, 
    0.11391556f, -0.16710064f, 0.02400149f, 0.00527305f, 0.24802965f, 0.16452476f, 0.25842813f, -0.08361161f, 
    -0.04045368f, -0.06344035f, -0.08902791f, -0.11088691f, -0.09873316f, 0.01614436f, -0.00520719f, 0.03121839f, 
    -0.01696691f, -0.18810567f, 0.04782232f, 0.28592539f, 0.06036985f, 0.13438603f, 0.08583154f, 0.08645103f, 
    0.00627458f, -0.10988195f, 0.04305572f, -0.08427799f, 0.07891708f, -0.02900421f, -0.00395863f, -0.15268902f, 
    0.03692822f, -0.02065576f, -0.02708721f, 0.03251299f, 0.16842535f, 0.03497585f, 0.10235382f, 0.04689847f, 
    -0.02482265f, -0.05099407f, 0.16133480f, 0.11684995f, -0.06697847f, -0.09810886f, 0.01264929f, -0.06807857f, 
    0.04866410f, 0.03708824f, -0.03583753f, 0.09236117f, -0.11038230f, -0.19556393f, -0.14563116f, -0.10668876f, 
    -0.07361212f, -0.00159019f, 0.05701811f, -0.03234191f, 0.10430814f, 0.14038464f, 0.09392317f, 0.08072884f, 
    -0.15002590f, -0.06055107f, 0.08936916f, 0.15542801f, -0.08779231f, -0.03724755f, -0.01578473f, 0.04241138f, 
    0.01450948f, 0.02894087f, 0.01185049f, -0.05359020f, 0.02154507f, 0.12112629f, -0.10909247f, -0.08440120f, 
    -0.06116923f, 0.15056266f, 0.04426444f, 0.04653005f, -0.05209134f, 0.01231789f, -0.07994560f, 0.03770914f, 
    -0.08445794f, 0.07703672f, 0.09282044f, 0.23798424f, 0.09388950f, -0.15260927f, 0.01199866f, 0.09068058f, 
    0.01728867f, -0.03594407f, -0.00266961f, -0.04664589f, -0.02010686f, -0.29315200f, -0.05253877f, -0.10338631f, 
    0.01999444f, 0.10674756f, -0.07270849f, 0.08708604f, 0.07393894f, 0.05805747f, 0.04134796f, 0.02392989f, 
    0.10582434f, 0.20707062f, 0.25628549f, 0.13875212f, 0.00745529f, -0.10694611f, -0.05487515f, 0.16950533f, 
    -0.12232837f, 0.06408450f, 0.00470568f, 0.03698078f, 0.00880610f, -0.17222984f, -0.00917042f, -0.20311236f, 
    0.04979159f, -0.02150238f, 0.00637666f, 0.02751010f, 0.05282819f, 0.04388757f, 0.02789439f, -0.00636329f, 
    0.07731710f, -0.06661951f, -0.07766407f, 0.31642818f, 0.02385514f, 0.11309072f, -0.09401346f, 0.01371666f, 
    -0.03674812f, 0.02829327f, -0.10198228f, -0.02534197f, 0.01447034f, -0.09487240f, -0.38831636f, -0.01981555f, 
    -0.05013623f, 0.10133132f, 0.02595069f, -0.00377524f, 0.09343205f, 0.00506207f, 0.08881994f, -0.09543983f, 
    0.08460941f, -0.02978943f, 0.04198432f, 0.02823769f, 0.07857326f, 0.05010340f, 0.12344307f, 0.08759009f, 
    0.06657089f, -0.06131613f, 0.03827847f, -0.00163244f, -0.02194497f, -0.12269434f, 0.21348114f, 0.14135976f, 
    -0.03427610f, 0.02520177f, -0.09355547f, 0.14486575f, 0.11804966f, 0.07712549f, 0.12759294f, 0.09973919f, 
    0.14779183f, -0.05484140f, -0.14449686f, 0.02136886f, -0.05277559f, 0.10385029f, 0.10153823f, -0.04052618f, 
    0.12040681f, -0.08150227f, 0.01096004f, 0.07548703f, -0.11965323f, 0.27700436f, -0.28795990f, 0.17374648f, 
    -0.06472480f, 0.10771073f, 0.01873631f, 0.04558674f, -0.00258453f, -0.03861032f, -0.12078061f, 0.03163600f, 
    0.08321413f, -0.01294901f, -0.04232071f, 0.05833479f, -0.02339965f, -0.09364180f, 0.09422631f, 0.02049051f, 
    0.09792992f, -0.04444351f, 0.06726977f, 0.09183819f, 0.10931244f, 0.26100424f, 0.21730377f, 0.11220808f, 
    0.03478796f, -0.19517036f, -0.09102588f, 0.03397464f, 0.02104307f, 0.09165519f, -0.02656505f, 0.05586125f, 
    0.20772858f, 0.13159998f, 0.10565934f, -0.10512765f, 0.00058924f, 0.05529779f, -0.02709054f, 0.02342347f, 
    0.10716432f, 0.06120035f, 0.00139997f, 0.00031777f, -0.32474867f, -0.08901946f, -0.06842761f, 0.04648368f, 
    0.05480962f, -0.01785487f, -0.09485758f, 0.19011241f, 0.05796352f, 0.04864763f, -0.07195749f, 0.07492416f, 
    -0.20998552f, 0.06928913f, -0.17715445f, 0.14180395f, -0.12325699f, 0.01538333f, 0.00770688f, -0.15655345f, 
    -0.03082182f, 0.00786898f, 0.01320086f, -0.16983849f, -0.11679629f, -0.05664455f, 0.07465890f, 0.18858171f, 
    -0.03928167f, 0.03929591f, -0.00149437f, 0.10828402f, -0.01528772f, 0.01588610f, -0.05165879f, 0.05883715f, 
    -0.26678455f, 0.04436831f, 0.28479102f, 0.04949630f, 0.04176661f, 0.04317234f, -0.11438895f, 0.13080505f, 
    0.18773007f, 0.11630245f, -0.06392872f, 0.09098411f, 0.19534743f, 0.14654842f, -0.24342550f, 0.10566780f, 
    -0.05961387f, -0.08367089f, 0.05492747f, -0.07765912f, 0.05019869f, -0.03144546f, -0.01147534f, 0.17793673f, 
    -0.10030755f, 0.37072009f, -0.40491590f, -0.11020637f, 0.02933156f, 0.09198350f, 0.14388053f, -0.07348605f, 
    -0.07706750f, 0.12700093f, -0.12666798f, 0.00006030f, -0.08629330f, 0.00075284f, 0.11473814f, 0.08183276f, 
    0.02760511f, -0.12515108f, -0.01462915f, 0.12245581f, 0.08546437f, -0.02715586f, 0.02733226f, 0.08795236f, 
    -0.23888558f, 0.01628734f, 0.11218160f, 0.08850358f, 0.07925597f, 0.16234699f, 0.02043024f, 0.05260140f, 
    0.06906807f, 0.10943907f, -0.00286809f, -0.00282862f, -0.07926982f, -0.05871351f, 0.34892535f, -0.01866473f, 
    0.04028670f, -0.00499607f, -0.05173311f, 0.10205826f, 0.04296959f, -0.02765581f, -0.00744706f, 0.01090591f, 
    -0.05519318f, 0.15494014f, 0.18725742f, 0.20972632f, -0.03863639f, 0.08354148f, 0.07785667f, 0.07008000f, 
    -0.07331259f, -0.03782509f, -0.06084643f, -0.07143659f, 0.08352910f, -0.09975609f, -0.11516844f, 0.11910859f, 
    0.01798211f, 0.04929592f, 0.00734868f, -0.13248807f, 0.07900544f, 0.01349130f, 0.11737956f, -0.02501734f, 
    0.30404657f, 0.42619023f, -0.22366571f, 0.20385627f, 0.04762932f, -0.09038188f, 0.02483026f, -0.04456652f, 
    0.20258723f, -0.01815730f, -0.07687528f, -0.04264483f, -0.11362876f, -0.18049468f, -0.07182125f, -0.04107990f, 
    0.13050450f, 0.12093008f, 0.17617150f, 0.00574221f, 0.21752539f, -0.02198748f, 0.00260846f, 0.03934470f, 
    -0.21030782f, -0.04066097f, -0.29654619f, -0.00922206f, -0.03168792f, 0.03636451f, 0.07594924f, -0.07393453f, 
    0.13782071f, 0.04587886f, 0.02576862f, -0.01442585f, 0.13769782f, 0.23460138f, 0.24029547f, 0.06916706f, 
    -0.11952899f, -0.14676058f, 0.05182524f, -0.13858418f, 0.10757741f, -0.03662084f, 0.00567734f, 0.05944559f, 
    -0.03027044f, -0.24843089f, 0.00979008f, -0.01080929f, 0.00128652f, 0.09361389f, 0.02686339f, 0.12513617f, 
    0.04833999f, 0.04592439f, -0.00823021f, -0.15731214f, -0.06012664f, -0.12530762f, -0.06918023f, 0.09035988f, 
    -0.04723554f, -0.00325079f, -0.00724680f, 0.07782314f, 0.24948791f, 0.06667479f, 0.13497807f, 0.08234186f, 
    0.08670164f, -0.12753673f, 0.00946714f, 0.00429600f, -0.01960858f, -0.10399853f, 0.09148858f, -0.03785405f, 
    0.15028183f, -0.07717928f, 0.02714426f, 0.14315876f, -0.17482089f, -0.09484817f, 0.09280539f, 0.07244673f, 
    0.00447151f, -0.10372958f, -0.08518874f, 0.18616726f, 0.09813698f, 0.00173618f, -0.04293126f, 0.07606698f, 
    -0.09427577f, -0.00117195f, -0.15175587f, -0.14492624f, 0.05713755f, -0.01626815f, 0.01458841f, 0.00640335f, 
    0.02602709f, 0.04486829f, 0.08146159f, -0.06275652f, -0.07077255f, -0.15185022f, 0.19097213f, 0.00083439f, 
    0.14489575f, 0.06889307f, -0.10497514f, 0.18146771f, -0.02973109f, -0.06594238f, 0.01613367f, -0.11103474f, 
    0.26829877f, 0.23086250f, -0.02809318f, -0.14690457f, -0.05884691f, -0.10279027f, -0.01150393f, -0.14680669f, 
    0.01155241f, -0.00207523f, 0.02714901f, 0.04972148f, -0.22656089f, -0.30510336f, -0.28229788f, -0.02951858f, 
    -0.08339104f, 0.04782143f, 0.11148846f, -0.04735667f, 0.08245106f, 0.04846604f, 0.05760509f, -0.05606553f, 
    -0.28667060f, -0.28342789f, 0.03941220f, 0.23493974f, 0.04742527f, 0.13695623f, -0.08807124f, 0.00275550f, 
    -0.01073372f, 0.09772123f, -0.07925768f, 0.04458795f, -0.17907315f, 0.00482444f, 0.10235276f, 0.17790017f, 
    0.00226205f, -0.00713413f, 0.07935265f, 0.05408765f, 0.06676424f, 0.12723587f, -0.03599482f, 0.11516681f, 
    -0.21713714f, -0.35169780f, 0.09833336f, 0.20224203f, 0.11004320f, 0.14210647f, 0.02735767f, 0.11035313f, 
    0.02925249f, 0.15123773f, 0.05202026f, -0.05590825f, -0.24608876f, 0.01180373f, 0.09224460f, -0.09075432f, 
    0.14847672f, 0.03063119f, -0.06162199f, 0.03832036f, 0.04556111f, 0.08244981f, 0.00777568f, 0.06879096f, 
    0.14876549f, 0.18005851f, 0.27910864f, 0.12047923f, 0.05053957f, -0.02715370f, -0.07586936f, -0.04040550f, 
    -0.03268365f, 0.07467807f, 0.02129226f, 0.01587867f, 0.08071937f, -0.10724127f, 0.04243546f, 0.13887280f, 
    -0.00604651f, 0.14914496f, -0.01815807f, 0.13775222f, 0.13979024f, 0.04239272f, 0.01435558f, 0.08744586f, 
    -0.04948125f, 0.12259834f, 0.17216186f, 0.21573092f, 0.02149335f, -0.04063677f, 0.05397663f, -0.01875956f, 
    0.10682783f, 0.01743450f, 0.03134756f, 0.10616308f, -0.12877709f, -0.12650065f, 0.23249735f, 0.15190263f, 
    0.11620842f, 0.00703155f, -0.21897641f, 0.07277757f, 0.06474154f, 0.00662489f, -0.03768473f, 0.07869519f, 
    0.00625767f, -0.05930933f, -0.15367797f, -0.09799237f, -0.05951453f, -0.00116426f, 0.16435502f, -0.03250964f, 
    0.04393877f, 0.10074428f, -0.05118454f, -0.02149467f, -0.26126733f, -0.08503368f, 0.34024537f, -0.53726363f, 
    0.13540727f, 0.00471564f, -0.08225185f, 0.08402696f, 0.12124416f, -0.06582756f, 0.03019304f, -0.04354548f, 
    -0.08700289f, -0.00231521f, 0.14676061f, 0.16161345f, 0.09852009f, 0.10751271f, 0.01691757f, -0.02801357f, 
    0.03288763f, 0.05666486f, -0.13317019f, 0.17091288f, -0.24380113f, -0.14556530f, 0.10159586f, 0.17900904f, 
    -0.03431076f, 0.01531880f, -0.17241111f, 0.10649130f, 0.04420481f, 0.21788779f, -0.06752181f, 0.07796434f, 
    0.02732169f, 0.01955933f, 0.00133274f, -0.01267723f, -0.02291982f, -0.03873088f, 0.01046393f, -0.00783299f, 
    -0.02511592f, 0.02231396f, -0.02625660f, -0.03799254f, -0.03549941f, 0.03253118f, -0.01275069f, -0.04266271f, 
    -0.03051332f, 0.03201206f, -0.03612868f, -0.01962493f, 0.00515799f, -0.01133515f, 0.00390624f, 0.01455671f, 
    0.02643023f, -0.00599870f, -0.00389448f, -0.01659223f, -0.02815955f, -0.02722577f, -0.00634847f, -0.00886947f, 
    -0.01246380f, -0.01576544f, -0.02029042f, -0.00918063f, 0.00879961f, 0.02946527f, 0.02098020f, -0.00943421f, 
    0.02491022f, -0.03076061f, -0.01214149f, -0.02498498f, -0.01625410f, 0.02622024f, 0.03039381f, 0.01123967f, 
    0.01837604f, -0.01378009f, 0.01595666f, 0.01649854f, -0.00651705f, 0.02406167f, -0.03006630f, 0.00409180f, 
    -0.03730566f, 0.01694147f, 0.00029307f, 0.01418806f, -0.03752542f, 0.00249857f, -0.02495211f, 0.02170072f, 
    0.00383361f, -0.00554360f, -0.01666897f, 0.01446172f, 0.00313317f, 0.01892015f, -0.02391765f, -0.03829592f, 
    -0.02283077f, 0.01485235f, -0.01823907f, -0.03912636f, 0.02239030f, -0.00680934f, 0.02714521f, -0.03572130f, 
    -0.01938000f, 0.02126494f, -0.01083056f, -0.04447377f, -0.01815405f, -0.02365856f, -0.03435927f, 0.01376059f, 
    -0.02158944f, -0.02814170f, 0.00730532f, -0.02704809f, -0.00595297f, 0.02507506f, -0.03785571f, -0.04273314f, 
    -0.02227406f, 0.01817049f, -0.01677543f, 0.01522141f, -0.00502196f, -0.00648429f, -0.01540072f, -0.04163623f, 
    0.02715910f, 0.01148042f, 0.00439454f, -0.04150600f, 0.02333286f, -0.00626876f, -0.01304884f, 0.02166914f, 
    0.02045616f, -0.01769197f, -0.02319853f, -0.02950321f, 0.02066063f, -0.00641543f, -0.01154914f, -0.01844557f, 
    -0.03418969f, -0.04289748f, -0.00361553f, 0.01799379f, 0.01837416f, -0.00822710f, 0.02190172f, 0.02556569f, 
    0.00796829f, 0.02012908f, -0.01538072f, 0.01510146f, 0.02145173f, 0.02925426f, -0.04156677f, -0.02532312f, 
    -0.01055219f, -0.01077447f, 0.00371720f, -0.01756250f, -0.01324456f, -0.02226645f, 0.02367037f, -0.04096739f, 
    -0.03392867f, -0.02291712f, 0.00034024f, -0.00222852f, 0.01044058f, 0.01569690f, -0.00011318f, 0.01492060f, 
    0.02306694f, 0.03068562f, -0.02418364f, -0.01156173f, -0.03295713f, 0.02105415f, -0.03054742f, -0.01422635f, 
    -0.03273126f, -0.00717632f, -0.03231014f, -0.00689102f, -0.03108654f, -0.02974386f, -0.00866877f, -0.03643847f, 
    0.01420035f, 0.02538321f, 0.01361722f, -0.01961435f, 0.00291756f, 0.00712515f, 0.00727565f, 0.00650679f, 
    0.01379604f, 0.00099657f, 0.00063433f, -0.00988811f, 0.02450078f, -0.03324467f, -0.01816427f, 0.02613699f, 
    0.02575815f, -0.00708979f, -0.02981019f, -0.02997628f, -0.01440300f, -0.00142878f, 0.00549328f, -0.02152802f, 
    0.01666579f, -0.01657140f, -0.01646845f, -0.01858180f, -0.02282899f, -0.02102602f, -0.00936324f, 0.02045656f, 
    -0.00097364f, 0.00888767f, -0.02238801f, -0.01600584f, 0.01635090f, 0.01846038f, 0.02376830f, 0.03070032f, 
    -0.03419656f, 0.00451078f, 0.00871764f, 0.00173934f, -0.01699027f, 0.00908917f, 0.02151847f, -0.03232000f, 
    -0.02065327f, -0.03287740f, 0.03062814f, 0.02401592f, -0.01463335f, -0.02526993f, 0.00063435f, -0.02644831f, 
    -0.00567894f, -0.00389856f, -0.02012491f, 0.02068944f, 0.02464622f, -0.03943730f, -0.03245225f, 0.02580588f, 
    0.00663386f, -0.01004128f, 0.01267808f, 0.00322616f, 0.00123003f, 0.00342698f, 0.02574147f, -0.01350559f, 
    -0.01069522f, -0.01611294f, 0.02700999f, -0.01591691f, -0.03252907f, -0.00237490f, -0.02305525f, 0.02012214f, 
    -0.02800275f, 0.00782913f, -0.02507272f, 0.02966928f, -0.03454511f, -0.02509581f, -0.02285567f, -0.00342323f, 
    -0.04458294f, 0.02194530f, 0.00300879f, -0.03295152f, 0.02047279f, -0.04274583f, 0.01145060f, -0.01642714f, 
    0.01851853f, -0.03823246f, -0.02406889f, -0.03472649f, 0.01202853f, -0.04387659f, -0.02328469f, -0.00325797f, 
    0.02763516f, -0.00250478f, 0.01370895f, 0.02140169f, -0.02919700f, -0.04087061f, -0.03877987f, -0.03746752f, 
    -0.00606860f, -0.02977472f, 0.00411956f, 0.01283479f, 0.01642982f, 0.02405494f, -0.02901279f, 0.01924730f, 
    0.01101518f, -0.01872974f, -0.03259830f, -0.00762456f, 0.00222322f, 0.01564932f, -0.01429332f, 0.00168415f, 
    0.01777131f, 0.00237441f, -0.03206909f, 0.01349630f, -0.02674739f, 0.01026222f, 0.00835234f, 0.00538646f, 
    -0.03411059f, -0.00070840f, -0.03013557f, 0.02329287f, -0.03136427f, 0.02628152f, 0.01879471f, -0.01246627f, 
    -0.03738480f, -0.03399375f, 0.00515447f, -0.02617683f, -0.03325522f, 0.01066104f, -0.01559583f, -0.02923577f, 
    0.01454177f, 0.00539787f, 0.00036882f, -0.02825955f, -0.03225350f, -0.03204472f, -0.01328179f, 0.02887984f, 
    -0.02975560f, 0.03379802f, -0.00877331f, 0.02786317f, 0.02696660f, 0.01720538f, -0.03980410f, 0.02439175f, 
    0.00129989f, 0.00753791f, -0.03149519f, 0.01596561f, -0.04249237f, 0.01769268f, -0.03771742f, -0.04062184f, 
    0.02672761f, 0.01850798f, -0.02685354f, 0.01259102f, -0.00454726f, 0.02567752f, 0.01228180f, -0.00082785f, 
    -0.02216247f, -0.01558180f, 0.01306850f, 0.01482927f, -0.00080233f, 0.02261713f, -0.02744424f, -0.01513195f, 
    0.00413828f, 0.01594780f, 0.00055002f, 0.01495016f, 0.00464898f, -0.00525227f, 0.02184442f, 0.00374248f, 
    -0.03447452f, -0.00950589f, -0.03508502f, -0.02274318f, -0.02898902f, 0.00163333f, -0.01724270f, -0.01225269f, 
    -0.00643817f, 0.02193767f, 0.00037184f, -0.03418988f, -0.02394155f, -0.00214351f, -0.02661170f, -0.01494800f, 
    0.02600105f, -0.02070362f, -0.01606054f, -0.02576157f, 0.00341405f, -0.00569567f, 0.02374903f, 0.02344839f, 
    0.01932126f, -0.03674864f, 0.02764757f, 0.02896138f, -0.00847378f, -0.00332799f, 0.00985555f, 0.02629855f, 
    -0.02579926f, 0.00773083f, -0.02103763f, -0.02147598f, -0.00894408f, -0.01534293f, -0.03159919f, -0.04109902f, 
    -0.00722607f, 0.01078001f, -0.00631300f, -0.02103325f, 0.01832986f, -0.00279832f, -0.01110406f, 0.00318459f, 
    -0.01644571f, -0.03644270f, 0.01329374f, -0.03661264f, 0.02391338f, 0.01719359f, -0.01609329f, 0.01111093f, 
    0.00631266f, -0.02312648f, 0.03133328f, -0.02916075f, 0.02141085f, -0.00475310f, -0.03501664f, -0.03361414f, 
    0.01731141f, -0.01526852f, 0.01040141f, -0.03119941f, -0.01970930f, -0.00737933f, -0.02928020f, -0.04375480f, 
    0.01558916f, -0.01273959f, -0.00206157f, -0.01742856f, 0.02431724f, -0.00738549f, -0.02720755f, -0.03758265f, 
    -0.01970829f, -0.00851467f, -0.02742708f, -0.02427078f, -0.00243194f, -0.02839561f, -0.04221299f, -0.01722476f, 
    0.01698352f, -0.02313275f, -0.03449724f, -0.03027510f, -0.00345417f, -0.00124060f, -0.01673687f, 0.00329447f, 
    -0.00088437f, 0.02495311f, 0.02522056f, -0.03061586f, -0.02256689f, 0.02079329f, 0.00108378f, -0.03243261f, 
    -0.01142232f, -0.01529778f, -0.04508477f, -0.03285773f, 0.00305196f, -0.00409372f, 0.02420909f, -0.02288718f, 
    0.01028950f, -0.04053625f, -0.00033383f, -0.01604006f, -0.00572373f, 0.01336211f, -0.01006471f, -0.01553423f, 
    0.00186803f, 0.00517056f, -0.03371532f, -0.02044778f, 0.01344126f, 0.02384657f, 0.01323780f, 0.02011055f, 
    -0.03134868f, -0.00693894f, 0.01192918f, 0.00564870f, 0.00108372f, -0.04118698f, 0.02452191f, -0.01723114f, 
    0.00194893f, -0.03549315f, -0.02657246f, 0.01273168f, -0.01241053f, 0.02210713f, -0.01685548f, -0.04006416f, 
    0.02060468f, -0.03405412f, -0.00837915f, -0.01620014f, -0.02837277f, 0.00348526f, 0.01111991f, -0.03970278f, 
    -0.03305912f, 0.02228712f, -0.01382641f, -0.04283116f, 0.01246210f, 0.01815627f, 0.01404779f, 0.01878493f, 
    -0.03666321f, -0.00764495f, -0.03060526f, 0.01482162f, 0.01107065f, 0.01679747f, -0.00285454f, -0.03206237f, 
    0.00740429f, -0.02196586f, 0.01138350f, 0.01054086f, 0.02754379f, -0.04396136f, -0.02605443f, 0.02968467f, 
    -0.01396048f, -0.02933909f, -0.02728090f, 0.01535820f, -0.01140424f, -0.01717952f, 0.01374163f, 0.00293853f, 
    -0.00602204f, -0.03133861f, -0.03785760f, -0.02887617f, -0.01002415f, 0.00463832f, -0.01841622f, -0.00874614f, 
    -0.02323332f, 0.02206015f, -0.01204895f, 0.01771327f, -0.03872377f, -0.03792863f, 0.00331205f, 0.00123556f, 
    -0.03827791f, 0.00463861f, -0.02554287f, 0.01365410f, -0.03130315f, -0.00798282f, 0.00548034f, -0.02234536f, 
    -0.02246297f, 0.01905840f, 0.01501643f, 0.01893623f, -0.02146274f, -0.02686718f, 0.01092719f, 0.02086855f, 
    0.00061976f, -0.01113056f, -0.01932838f, -0.02374080f, -0.01189844f, 0.01327166f, -0.00416997f, 0.02096739f, 
    0.02171837f, -0.02015305f, 0.02163342f, 0.01720296f, -0.04017183f, -0.03297084f, -0.03814172f, -0.00142121f, 
    -0.01182053f, 0.01894179f, -0.01230805f, -0.01714499f, -0.04028385f, -0.01627414f, 0.01698600f, -0.01204244f, 
    -0.00979225f, -0.01607392f, -0.01948413f, -0.00790893f, -0.03660842f, -0.04238285f, 0.01506840f, -0.01241052f, 
    0.00005490f, 0.01992413f, -0.03094160f, -0.00130072f, -0.00597497f, 0.03397768f, 0.01574282f, -0.02604422f, 
    -0.01371127f, -0.02143827f, -0.04378463f, 0.02621175f, -0.03527704f, -0.00925377f, 0.01449731f, 0.02135008f, 
    -0.02938729f, 0.02741180f, -0.02263466f, 0.01007945f, -0.04088600f, -0.01927733f, -0.00599969f, -0.03064525f, 
    0.01486544f, -0.03297137f, -0.00545165f, -0.01794665f, 0.00714996f, -0.01902246f, 0.01330106f, 0.00467316f, 
    0.01787376f, 0.01742166f, -0.02819618f, -0.02055322f, 0.00060242f, 0.01920776f, 0.01645125f, -0.00048515f, 
    0.00279855f, -0.02717172f, 0.00232487f, -0.01285763f, -0.01077359f, 0.01080021f, -0.01133831f, -0.00091182f, 
    -0.01003362f, 0.03646941f, -0.01188930f, -0.01936844f, -0.00139343f, -0.01637741f, -0.03126805f, 0.01996147f, 
    -0.03116272f, -0.04126846f, 0.00202613f, 0.01621851f, 0.00822818f, -0.00692081f, -0.00636996f, -0.04531310f, 
    -0.01867424f, -0.00979551f, -0.00507871f, 0.02553060f, -0.02605003f, -0.03763368f, -0.00043626f, -0.03679725f, 
    -0.04024553f, 0.00956583f, -0.01349531f, -0.02193399f, -0.03293185f, 0.01727533f, -0.03086520f, 0.00872359f, 
    -0.03332496f, -0.02327252f, -0.04267051f, -0.01650955f, 0.02519388f, -0.01680604f, -0.03865636f, -0.01091841f, 
    0.02697148f, 0.01468876f, 0.02430983f, -0.01577781f, 0.00546786f, 0.01129956f, 0.01377400f, 0.03768354f, 
    -0.00906150f, -0.03979864f, -0.00658815f, 0.02251919f, 0.02044509f, 0.00438771f, -0.01824822f, 0.00373503f, 
    -0.01292165f, 0.01991030f, 0.01076632f, -0.04052789f, -0.00899780f, 0.00096549f, -0.00824331f, -0.00114581f, 
    0.00142458f, 0.00232774f, -0.04298405f, 0.01391148f, 0.01350888f, -0.01385328f, -0.01041689f, 0.00134269f, 
    0.00544591f, 0.01537117f, -0.02882702f, 0.01503973f, -0.00379725f, -0.02798647f, 0.00982401f, 0.01617834f, 
    0.01469133f, -0.02732794f, 0.01504329f, 0.01455910f, 0.02788400f, 0.01003677f, -0.02901357f, -0.03767635f, 
    -0.00562552f, 0.00421639f, 0.02698109f, 0.01246367f, -0.03137311f, -0.04305864f, -0.04232159f, 0.00874300f, 
    -0.03197994f, 0.02583031f, 0.01873423f, -0.03186246f, -0.00280284f, 0.03259716f, 0.00644439f, -0.01183425f, 
    -0.01677948f, -0.02966929f, -0.00731919f, -0.01945168f, 0.00547273f, 0.01616269f, -0.00171859f, 0.00409750f, 
    0.02518574f, -0.03770358f, -0.00380138f, -0.04150813f, 0.02634759f, -0.01545899f, -0.02875117f, -0.00120641f, 
    -0.02251804f, -0.01034061f, -0.03710017f, -0.01817491f, 0.01381518f, -0.02015376f, -0.03174144f, -0.03763802f, 
    0.02575167f, -0.01536030f, -0.00520563f, -0.01240700f, 0.02621319f, 0.01800464f, -0.03607953f, -0.01477410f, 
    0.00722162f, -0.00849232f, -0.02013824f, -0.04102788f, 0.00114258f, 0.00638975f, 0.02458127f, -0.02301456f, 
    -0.01025229f, 0.00806428f, -0.02086406f, -0.02574770f, -0.02121215f, -0.03754052f, -0.01916162f, -0.03163530f, 
    0.00453500f, -0.03012146f, -0.00485374f, 0.00042881f, 0.02664749f, -0.00716433f, -0.02131722f, 0.01768773f, 
    0.00997080f, -0.01311395f, 0.02559559f, 0.00542337f, -0.02254453f, -0.01535412f, -0.03085363f, -0.02317525f, 
    0.02884733f, -0.02047935f, 0.00602497f, -0.00514244f, 0.00339265f, -0.03435153f, 0.01623626f, -0.02667888f, 
    0.01263567f, -0.01025446f, 0.00682260f, -0.02415675f, 0.00122136f, -0.01250787f, -0.00793497f, -0.03182514f, 
    -0.00791867f, 0.00112444f, 0.01208359f, -0.03379113f, -0.00487833f, -0.03997582f, 0.01451126f, 0.00770699f, 
    0.02380385f, -0.00832738f, 0.00047184f, 0.02033331f, -0.01886603f, -0.02053069f, -0.03584099f, -0.04201186f, 
    0.00564385f, -0.01603823f, 0.02188801f, 0.00394466f, 0.00315198f, 0.01016665f, 0.00490399f, 0.02074081f, 
    0.01036802f, -0.01234439f, 0.02397758f, -0.02487124f, 0.02528362f, -0.00307194f, -0.02856956f, -0.02592149f, 
    0.01709621f, 0.00379737f, -0.03901407f, -0.03209852f, -0.02659812f, 0.00914899f, -0.00912017f, -0.00728934f, 
    -0.00048085f, -0.03571705f, 0.00332491f, -0.02442739f, -0.00740979f, -0.02085411f, -0.01316838f, 0.01877344f, 
    -0.02296491f, 0.01738322f, -0.00124835f, -0.00987085f, -0.02196554f, 0.02267978f, 0.01490510f, -0.01174983f, 
    -0.01578370f, -0.00434095f, -0.00478881f, -0.02942489f, 0.00662124f, -0.04095329f, -0.03449680f, 0.01022710f, 
    -0.02985724f, -0.01233135f, 0.01625925f, -0.00056986f, -0.03312603f, -0.00494711f, 0.01458989f, -0.00944284f, 
    0.01847116f, 0.02205011f, -0.03224951f, -0.00977562f, -0.00834303f, -0.01072601f, 0.00751268f, -0.03317365f, 
    0.00915876f, -0.04113129f, -0.00936334f, -0.01504333f, -0.02860258f, -0.01953906f, -0.01888258f, -0.01526850f, 
    -0.01813947f, -0.02068940f, -0.02816605f, -0.02044243f, 0.01667678f, -0.02365755f, -0.02282583f, -0.03300976f, 
    -0.03108679f, 0.02756596f, -0.03247487f, 0.01549568f, 0.01394751f, 0.01059282f, 0.02658191f, 0.01365332f, 
    -0.00939737f, 0.00281766f, -0.01049723f, 0.01368877f, -0.00204987f, -0.03959099f, 0.01846135f, 0.02579526f, 
    0.00858110f, 0.02507416f, 0.02303050f, -0.00004968f, -0.03277478f, -0.03789525f, -0.00334712f, 0.01899937f, 
    0.01797041f, 0.00317901f, 0.01754159f, -0.01953730f, -0.01543085f, 0.02464978f, 0.00589485f, 0.01260659f, 
    -0.00974286f, -0.02928049f, 0.02043746f, -0.04100513f, 0.02598335f, -0.03765597f, -0.02856039f, 0.00330000f, 
    0.01506525f, -0.01313852f, -0.03391605f, 0.03331386f, 0.01008970f, -0.00180747f, 0.02755447f, -0.03299351f, 
    -0.01628903f, 0.02611202f, -0.03089286f, -0.02436163f, -0.03237844f, 0.00065629f, 0.01116914f, 0.00364750f, 
    0.01819471f, -0.00620555f, 0.02211557f, -0.00990850f, -0.03461687f, 0.00154915f, -0.01891491f, 0.01728463f, 
    0.02472943f, -0.03764325f, 0.00556377f, 0.00223896f, 0.03138287f, -0.00417767f, -0.00941310f, -0.02629596f, 
    -0.03398954f, -0.03270853f, -0.02137931f, -0.01011436f, 0.00124612f, -0.00616452f, -0.00724296f, -0.00875336f, 
    -0.00343297f, -0.03276942f, -0.04166675f, -0.02277215f, 0.01008286f, 0.01126398f, -0.00164996f, 0.02124444f, 
    0.00603379f, -0.01984492f, -0.00890605f, 0.02127260f, 0.01706794f, -0.02749926f, 0.02179111f, -0.00968793f, 
    -0.02454641f, 0.01730426f, -0.00959332f, -0.02550430f, -0.00120237f, -0.04006913f, -0.02002522f, -0.02075150f, 
    -0.03769830f, 0.02088779f, -0.00299713f, -0.02556165f, 0.02368115f, 0.00386116f, 0.02545653f, -0.01161428f, 
    0.00003290f, -0.02093557f, -0.04197876f, -0.03395248f, 0.01407685f, 0.01320129f, 0.02591702f, -0.01901556f, 
    -0.03963957f, 0.02208073f, -0.03715314f, -0.01763316f, 0.02192735f, 0.01863480f, 0.00396389f, -0.00934116f, 
    0.00634771f, -0.01377485f, -0.02539999f, -0.00573549f, -0.01730871f, 0.00243903f, 0.02499672f, -0.02465837f, 
    0.02016788f, 0.01034329f, -0.02286277f, 0.01508113f, -0.00036167f, -0.00351518f, -0.02132810f, -0.02697210f, 
    0.01679215f, 0.01910014f, -0.02327769f, -0.03987145f, 0.00905065f, 0.00383092f, 0.02303635f, -0.00433422f, 
    -0.03345791f, -0.03253401f, -0.00770871f, 0.00327986f, 0.01280150f, 0.00411910f, 0.02551505f, -0.01752842f, 
    0.01912666f, -0.01011917f, 0.02602393f, 0.01200233f, -0.02710345f, -0.02384804f, -0.01728837f, -0.00504669f, 
    -0.00955967f, -0.03990019f, -0.04221879f, -0.01561687f, 0.03771412f, -0.03480044f, -0.03563061f, -0.00026612f, 
    0.02255553f, 0.02055875f, -0.03289121f, 0.01274647f, -0.01864158f, -0.03225568f, -0.02822759f, -0.01815634f, 
    0.01028624f, 0.01656238f, -0.02095085f, -0.00653760f, 0.01444816f, -0.03826730f, -0.03990452f, -0.00380610f, 
    0.02057671f, 0.00061533f, -0.03058743f, 0.02487879f, -0.03526596f, 0.01284204f, 0.02763408f, -0.02166159f, 
    0.01024274f, 0.02546597f, -0.01964701f, 0.02593753f, 0.02189399f, 0.02360741f, -0.00372216f, -0.00847934f, 
    -0.01931986f, -0.03652296f, -0.02999362f, -0.02289136f, -0.00804759f, -0.01925282f, 0.02920227f, 0.03069604f, 
    -0.02401196f, -0.00971344f, -0.02046164f, -0.00905453f, 0.01975296f, 0.00645183f, -0.01350332f, -0.01384785f, 
    0.00060438f, 0.00346073f, -0.02746128f, -0.00090865f, 0.00167575f, -0.01912001f, 0.02800371f, -0.00693611f, 
    -0.00889136f, 0.00572958f, 0.01699096f, 0.01073437f, -0.04026256f, -0.01128199f, -0.00225731f, 0.00496218f, 
    0.02553441f, 0.02018125f, 0.01173680f, -0.03449507f, -0.03076930f, -0.02629940f, -0.01372236f, -0.01074681f, 
    0.01898381f, 0.02616046f, 0.02458583f, -0.02238733f, 0.00880019f, -0.00185648f, -0.00072204f, -0.01164280f, 
    -0.02477857f, -0.00040089f, -0.01519449f, 0.02904357f, -0.03387650f, -0.00449062f, -0.01393769f, 0.02557166f, 
    0.00657006f, 0.02968060f, -0.01212167f, -0.03005817f, -0.02652455f, 0.02772080f, 0.01535318f, 0.00614857f, 
    -0.00507594f, 0.00496659f, -0.02538400f, 0.00668040f, -0.01472029f, 0.00705972f, 0.01881110f, 0.02320933f, 
    -0.01987815f, 0.01799735f, -0.02125297f, -0.01620983f, 0.00075891f, 0.02042017f, 0.02354882f, -0.00443063f, 
    -0.04289893f, -0.00748276f, -0.01660224f, -0.00691087f, -0.00552650f, 0.01250416f, -0.02509752f, 0.01148898f, 
    0.00668761f, -0.03207640f, -0.03620231f, -0.03197369f, 0.00209715f, -0.01101659f, -0.00528839f, 0.01252125f, 
    -0.02101091f, 0.01226859f, -0.03466083f, -0.04267175f, -0.01950590f, -0.01089883f, -0.04029056f, -0.03695802f, 
    -0.04133400f, -0.03903082f, -0.01399094f, -0.02714041f, -0.01668276f, 0.00021983f, 0.02408656f, 0.00753361f, 
    0.01733860f, -0.00771710f, 0.01837155f, -0.03843667f, -0.00103071f, 0.01041237f, 0.00691473f, 0.00143099f, 
    0.00723417f, -0.03844175f, 0.01326374f, -0.04310810f, -0.02686894f, -0.04051884f, -0.00369281f, -0.03562232f, 
    0.01082871f, 0.02437042f, -0.02655227f, -0.02307395f, 0.01534442f, -0.00471390f, 0.01982302f, -0.03296895f, 
    0.00064211f, 0.00087666f, -0.01407973f, -0.03864741f, -0.00541437f, -0.00540977f, 0.02573029f, -0.02320073f, 
    -0.01608589f, -0.03231407f, -0.01191518f, 0.02144905f, -0.02474297f, -0.01140508f, 0.02505287f, -0.00785874f, 
    -0.01907956f, 0.01372296f, 0.02219411f, -0.01941234f, 0.00169076f, 0.01784038f, 0.01600154f, 0.00689857f, 
    0.00256585f, -0.01439765f, 0.01627835f, -0.03906889f, -0.00970826f, 0.02128389f, -0.04239916f, 0.02608917f, 
    0.00028354f, 0.00505392f, -0.03339003f, 0.01270912f, 0.01389500f, 0.01832713f, 0.00854678f, -0.01555661f, 
    0.00954782f, -0.03322995f, 0.01258290f, 0.00724093f, -0.00328647f, 0.02559564f, -0.02043656f, 0.01944132f, 
    -0.00451468f, -0.04142447f, 0.00594353f, -0.00250185f, -0.01018216f, -0.03030737f, 0.01712258f, 0.02134679f, 
    -0.01282514f, 0.00673102f, 0.02549432f, 0.02462819f, -0.01315933f, -0.01148533f, -0.01209472f, 0.02092082f, 
    0.01016110f, -0.00814670f, -0.03421529f, 0.00767278f, -0.03691379f, 0.01383109f, -0.03721693f, 0.02087920f, 
    -0.00126058f, 0.02767073f, 0.01473617f, 0.01977101f, -0.00771984f, -0.02578308f, 0.00201890f, -0.03432934f, 
    0.00873457f, 0.02342435f, -0.00094484f, -0.02794553f, 0.02545013f, -0.00937145f, -0.00647906f, -0.00260996f, 
    -0.01285441f, 0.01752004f, -0.02534467f, -0.03425599f, 0.01635662f, -0.02299042f, -0.01158369f, -0.02703735f, 
    -0.00440566f, 0.00807120f, 0.02820091f, -0.00720216f, -0.01128185f, 0.00548346f, -0.02720998f, 0.00871766f, 
    -0.03591270f, -0.01068588f, -0.03100992f, -0.03317868f, 0.00760740f, -0.03355140f, -0.03451302f, 0.00801973f, 
    0.02323644f, 0.00376643f, -0.03333573f, -0.00114530f, -0.01798559f, 0.02413689f, 0.03057889f, -0.02022157f, 
    -0.01814236f, -0.04391481f, -0.03564487f, -0.00462440f, 0.02734647f, 0.00820337f, 0.02251883f, -0.01987892f, 
    -0.01747087f, -0.02528535f, 0.00128326f, -0.00179749f, -0.02350426f, 0.02816155f, -0.03136402f, 0.02077558f, 
    -0.03971852f, 0.02720070f, -0.03870329f, -0.04060727f, 0.01114838f, 0.02599989f, -0.02829650f, -0.00238290f, 
    -0.01572246f, -0.02206570f, 0.00284733f, -0.02252246f, 0.00562555f, -0.03896412f, 0.00879132f, -0.02236054f, 
    0.00401531f, 0.02453357f, 0.00738551f, -0.01308806f, -0.02673152f, -0.03121732f, 0.01720010f, -0.00288592f, 
    0.01124478f, -0.03862803f, 0.01859821f, -0.04004855f, 0.00825589f, 0.02878176f, -0.02351583f, -0.01869028f, 
    0.02497033f, 0.01308960f, 0.02458977f, -0.00219147f, 0.01511208f, -0.03839680f, 0.00284954f, -0.00654056f, 
    -0.00715945f, -0.00025736f, 0.01898118f, -0.01641148f, 0.01388645f, -0.00551951f, -0.02961833f, -0.01795414f, 
    -0.00208866f, -0.03478904f, 0.01506718f, -0.00514814f, -0.02743243f, 0.02049617f, -0.00635420f, -0.03857745f, 
    -0.01096426f, -0.02998882f, 0.00922202f, -0.01053702f, 0.01851879f, -0.03796367f, -0.02714454f, -0.02830187f, 
    -0.01517422f, -0.03993002f, 0.01107750f, 0.01138937f, -0.00155625f, -0.02221576f, 0.02264367f, 0.03130452f, 
    0.00445568f, -0.03897006f, 0.00562362f, -0.02733868f, -0.01530432f, -0.03993010f, -0.01254003f, -0.04408723f, 
    0.02254953f, 0.01359841f, -0.00942462f, -0.00321159f, -0.02762621f, 0.00848657f, -0.02699569f, -0.03132595f, 
    -0.01736211f, -0.02964533f, 0.00238432f, -0.00677312f, -0.01871584f, 0.00099610f, -0.02827177f, -0.00683219f, 
    -0.04092450f, -0.00831927f, 0.01103771f, -0.02304774f, 0.01495422f, -0.03658405f, 0.01534956f, -0.02642546f, 
    -0.01657667f, -0.03476289f, 0.01613011f, -0.04047219f, -0.02750102f, -0.00282406f, -0.02887432f, -0.00381049f, 
    0.11008886f, -0.01287284f, 0.03379897f, 0.08658042f, 0.01666759f, -0.06211387f, 0.06493997f, 0.08292741f, 
    -0.02341670f, 0.04003887f, 0.01108223f, 0.02244330f, 0.08139189f, 0.06433363f, 0.02220981f, -0.08335381f, 
    -0.02030271f, 0.03466318f, -0.15499873f, 0.11891280f, 0.05346088f, 0.12338163f, 0.04432596f, 0.02626620f, 
    -0.08911283f, -0.09391200f, -0.10984524f, -0.04656361f, 0.02345680f, -0.01051219f, -0.02417371f, 0.05595643f, 
    0.00202537f, 0.01104745f, 0.06568456f, 0.03422751f, 0.00472775f, -0.22858301f, 0.16107389f, -0.04390654f, 
    -0.11130124f, 0.08230751f, -0.16124108f, -0.05599661f, -0.02874562f, -0.05073189f, -0.13793820f, 0.08873611f, 
    -0.16947830f, -0.32094827f, 0.18385261f, -0.20680146f, 0.08810495f, 0.04356706f, -0.06997097f, -0.02982024f, 
    0.02801038f, -0.12950242f, -0.09899849f, -0.08105733f, -0.05138714f, 0.23019300f, -0.17222375f, 0.02531197f, 
    -0.00945151f, 0.06579441f, 0.12379713f, 0.11673358f, 0.05239254f, 0.05101875f, 0.07170467f, 0.02583832f, 
    0.18181093f, -0.17249772f, 0.16699608f, -0.00277372f, 0.14504759f, -0.00511409f, -0.10113534f, -0.00373507f, 
    0.00495712f, -0.16405751f, -0.01555092f, 0.01872141f, -0.07266465f, 0.11380770f, -0.09515572f, -0.04638534f, 
    0.00876089f, 0.02924520f, 0.11970612f, -0.01239305f, -0.05878637f, 0.02538104f, 0.03982782f, -0.02784152f, 
    0.29175064f, 0.06153207f, -0.00316685f, 0.15832499f, -0.02415253f, -0.00478812f, -0.06267728f, -0.02624427f, 
    -0.07284873f, 0.15270379f, -0.02853560f, 0.15294476f, -0.08454408f, -0.11809463f, 0.18199989f, -0.01838063f, 
    0.05442661f, 0.02070208f, -0.00449691f, -0.03367897f, -0.04805678f, 0.07263249f, -0.03119079f, 0.13663602f, 
    -0.03149774f, 0.09164843f, -0.11217411f, 0.05422299f, 0.10240636f, 0.07389154f, 0.07756785f, 0.01997636f, 
    -0.07949434f, -0.00974517f, -0.00396807f, 0.06470442f, -0.05331021f, 0.13857986f, -0.03576763f, -0.10300997f, 
    0.02044595f, 0.01114336f, 0.11456273f, 0.04058510f, 0.12601916f, 0.12335296f, 0.12636945f, 0.08468452f, 
    -0.01205749f, -0.10275970f, 0.01970800f, 0.09929739f, 0.13291357f, 0.06583690f, -0.05056886f, -0.05204426f, 
    -0.05425703f, -0.02305250f, 0.01306763f, 0.06682391f, -0.10979059f, -0.14781800f, -0.12306014f, 0.03109857f, 
    0.01639704f, -0.09620915f, 0.02431815f, 0.02430727f, 0.08240116f, -0.01820128f, 0.02568075f, 0.02939005f, 
    -0.03284938f, 0.03673032f, 0.07773013f, 0.05954912f, -0.00884885f, -0.05163336f, 0.03132658f, -0.07776016f, 
    -0.05351300f, 0.03119799f, 0.06623200f, -0.01966734f, 0.03804683f, -0.08217577f, -0.11378281f, 0.00835006f, 
    -0.03797027f, -0.05234166f, 0.07398882f, 0.01544301f, 0.07799234f, 0.02550292f, 0.08055361f, -0.05508643f, 
    -0.09384551f, -0.13336816f, -0.13241035f, -0.11086426f, -0.01698151f, 0.04167345f, 0.05554077f, -0.11089880f, 
    -0.09338456f, -0.06532203f, 0.04144803f, -0.02997269f, -0.26488185f, 0.04154492f, 0.05821318f, 0.02360420f, 
    -0.06745634f, 0.02814134f, 0.17733636f, -0.14240605f, 0.16134109f, 0.02382135f, 0.00743807f, 0.13102980f, 
    -0.17969352f, 0.34525785f, 0.10487036f, 0.03781322f, -0.01990635f, 0.03675309f, 0.08972391f, -0.14100865f, 
    -0.01942216f, 0.01375273f, 0.08905108f, -0.03791434f, 0.02506283f, 0.01003079f, -0.01256478f, 0.06490073f, 
    0.08208359f, -0.07407355f, 0.01952063f, -0.03783240f, -0.11873371f, -0.11251047f, -0.01432971f, -0.12614800f, 
    0.09076095f, -0.03505740f, -0.08141497f, 0.04472206f, -0.10973974f, -0.05174657f, -0.02415279f, -0.01828346f, 
    -0.03569316f, -0.13007948f, -0.04837430f, -0.00438018f, -0.28307137f, -0.02122552f, -0.01896589f, -0.02187182f, 
    -0.07643446f, -0.20219284f, 0.00517991f, 0.02344137f, -0.04063567f, 0.07869960f, -0.01010842f, 0.01483421f, 
    0.08863061f, 0.06037298f, 0.07051074f, 0.01304768f, 0.11553745f, -0.00919492f, 0.04547755f, 0.01040074f, 
    0.00234464f, -0.06748366f, -0.07523055f, 0.04903618f, -0.04046040f, 0.17718093f, -0.06704552f, -0.05746339f, 
    0.02008683f, 0.02008970f, -0.01586048f, 0.06657507f, 0.05462240f, 0.04701591f, 0.01443300f, 0.07061450f, 
    0.05984324f, 0.06835638f, -0.12322456f, 0.15154521f, 0.00010361f, -0.02980977f, -0.01555186f, 0.14091150f, 
    -0.05973418f, 0.11192030f, 0.01458498f, 0.02607230f, 0.17203724f, -0.00634446f, 0.11146704f, 0.08684364f, 
    -0.06310588f, 0.18056867f, -0.18447286f, -0.01601893f, -0.03524140f, 0.01327559f, 0.08466310f, -0.06883423f, 
    0.26453212f, -0.06857871f, 0.15520833f, 0.20787878f, 0.03133582f, 0.05427038f, -0.00635169f, -0.02467925f, 
    -0.00655632f, 0.02107304f, -0.10891593f, 0.13995974f, -0.01347437f, 0.16046917f, 0.22173862f, 0.15549029f, 
    -0.02993196f, 0.03908548f, -0.05786850f, -0.05760755f, -0.02261098f, -0.00409219f, 0.19560376f, 0.03169839f, 
    0.20232221f, -0.30617025f, 0.18738343f, 0.09365691f, 0.10368056f, 0.08489270f, -0.18943609f, 0.15249346f, 
    0.02188911f, -0.05437157f, -0.01141885f, -0.02104552f, -0.01131883f, -0.11586056f, 0.03026737f, 0.09058737f, 
    -0.01845455f, -0.06076206f, 0.00990370f, 0.04712391f, -0.08176824f, -0.01281627f, 0.03835964f, 0.08036154f, 
    -0.05690746f, 0.14187357f, -0.20911385f, 0.08832317f, -0.06836109f, -0.10786103f, 0.05526645f, 0.02644770f, 
    -0.02223647f, 0.03396904f, -0.05781254f, -0.15476683f, -0.09207016f, -0.22632702f, -0.13432741f, -0.10275882f, 
    0.04903022f, 0.07576935f, -0.00854210f, -0.01572651f, -0.07191719f, -0.08800998f, -0.03067889f, -0.06333663f, 
    -0.12304664f, -0.10436070f, -0.15793267f, 0.03588722f, 0.13354024f, 0.05728277f, -0.03907183f, 0.04292530f, 
    -0.05124567f, -0.02949809f, 0.02538691f, -0.05306613f, 0.26364356f, 0.08288471f, 0.08019932f, -0.00397769f, 
    -0.06574964f, 0.09156466f, -0.00927234f, 0.02592265f, 0.08332276f, 0.20346065f, 0.10922951f, 0.12528038f, 
    0.04930389f, -0.14869174f, 0.28309283f, -0.36632556f, -0.13253853f, -0.18451153f, -0.00351340f, -0.05395018f, 
    0.06865495f, -0.10355998f, -0.00349648f, 0.00110657f, 0.22003427f, -0.19816050f, 0.04531108f, -0.02192513f, 
    0.03628070f, 0.09575941f, -0.01644549f, -0.08289369f, 0.03937390f, -0.03276150f, 0.07209446f, -0.02044823f, 
    -0.15926984f, -0.30481935f, -0.26279277f, 0.13864428f, 0.02431159f, -0.00603602f, 0.09438075f, -0.00208681f, 
    -0.01452216f, -0.04144775f, -0.00221545f, -0.05550542f, 0.04617001f, 0.05762840f, 0.27531511f, 0.15889208f, 
    0.02399679f, 0.01623731f, 0.01898785f, 0.10460997f, -0.05489745f, -0.05780793f, 0.07240146f, 0.07477531f, 
    -0.21233839f, -0.26653558f, -0.11060926f, -0.05580756f, -0.02231825f, -0.03645901f, -0.04011266f, -0.05518809f, 
    0.00725444f, -0.06073812f, 0.02807104f, -0.06825440f, 0.04730945f, -0.07282790f, -0.11422525f, 0.08860703f, 
    -0.10780320f, -0.05396205f, -0.04417897f, 0.11306234f, -0.02001365f, 0.06682561f, 0.16353191f, 0.02488167f, 
    0.20448339f, 0.16862872f, 0.02352019f, 0.14295645f, -0.09175977f, 0.09841584f, -0.02119676f, 0.03957679f, 
    -0.02215984f, 0.08406214f, -0.04083605f, 0.15324996f, -0.13409352f, -0.15696001f, -0.04583362f, -0.16126835f, 
    -0.00542730f, -0.13134316f, -0.00259307f, 0.11042595f, -0.00766522f, -0.07302197f, -0.09299268f, -0.05597676f, 
    0.16459484f, -0.06247059f, -0.09367790f, 0.06869886f, 0.07255080f, 0.05867093f, -0.05194901f, -0.01246139f, 
    0.12989290f, -0.04948746f, -0.01270904f, 0.03097129f, -0.09551769f, 0.08001022f, 0.02880217f, -0.01453613f, 
    -0.00086963f, -0.12087152f, -0.08741385f, -0.05027066f, -0.06750853f, 0.05857116f, -0.01462324f, -0.04456417f, 
    0.12503830f, -0.21432227f, -0.14233114f, 0.17278430f, -0.01046562f, 0.05122635f, 0.00603431f, 0.05425427f, 
    0.10920940f, 0.03347249f, -0.03853375f, 0.16469568f, 0.13173047f, 0.03419411f, 0.11379301f, 0.02931959f, 
    0.04577067f, 0.14075376f, 0.05680275f, -0.00484115f, 0.14421895f, 0.16550007f, 0.02058745f, 0.00593412f, 
    0.04060262f, 0.11778264f, -0.24903452f, 0.12397493f, -0.09711424f, -0.11097441f, -0.04428883f, -0.04251253f, 
    -0.01858229f, 0.16816495f, 0.11344257f, -0.04191076f, 0.08236206f, -0.13841365f, -0.07861762f, 0.07156442f, 
    0.05900225f, -0.04094527f, -0.02557381f, -0.05920746f, -0.15414439f, 0.05130960f, -0.02820160f, 0.08964145f, 
    -0.07165430f, -0.21287665f, 0.15405856f, -0.16927294f, -0.10273948f, -0.02763708f, -0.00152521f, -0.14269209f, 
    -0.12973642f, -0.11345686f, -0.07966560f, 0.01541283f, -0.12622669f, 0.14235045f, -0.19645241f, -0.01580601f, 
    -0.02226038f, -0.03812813f, 0.06350224f, -0.03993978f, -0.21513370f, -0.01392561f, -0.03600470f, 0.06701473f, 
    0.11374895f, -0.04996702f, 0.23082909f, 0.06895844f, 0.01715272f, -0.01848533f, -0.13563482f, 0.10610662f, 
    -0.03920564f, -0.03397905f, 0.09694044f, 0.02719136f, -0.22222443f, -0.34356403f, -0.21194372f, -0.02579030f, 
    -0.18759280f, -0.04994368f, 0.03769093f, 0.04954826f, 0.03558780f, -0.07079339f, -0.10888422f, 0.05379368f, 
    0.06536610f, -0.09639139f, -0.30449110f, -0.06340975f, 0.03441633f, -0.01301854f, -0.03163582f, 0.17908949f, 
    -0.00053932f, -0.07836378f, -0.00278449f, -0.05699332f, -0.01709693f, -0.01591576f, -0.02952734f, 0.01657956f, 
    -0.01561852f, -0.07256376f, -0.02945939f, 0.01901535f, -0.04950169f, 0.01099949f, 0.01026297f, 0.01570056f, 
    -0.28964445f, 0.15329880f, -0.20506346f, 0.25606945f, 0.06220837f, -0.15544969f, -0.04456650f, -0.09676848f, 
    0.02741996f, 0.07738957f, 0.09052005f, 0.04115952f, 0.09166703f, 0.34104541f, 0.04192469f, 0.02327554f, 
    0.03160343f, -0.17062019f, 0.14983107f, 0.00225608f, -0.06937124f, 0.08257695f, 0.00797277f, -0.10913140f, 
    0.01000334f, 0.11544921f, 0.28576607f, -0.23691931f, 0.12371408f, 0.08264129f, -0.00184317f, 0.11553138f, 
    -0.08537479f, 0.04845431f, 0.03509916f, 0.02062850f, -0.21159233f, -0.10093135f, 0.07674935f, 0.07641479f, 
    -0.00803517f, 0.02014282f, 0.05675482f, -0.07425266f, 0.13229205f, 0.02695409f, 0.13443230f, 0.11510562f, 
    -0.09730563f, -0.03208578f, -0.08343603f, 0.00636117f, -0.02980657f, 0.05611805f, 0.02745722f, 0.04129788f, 
    -0.05522283f, 0.05942264f, 0.03856346f, 0.05001026f, -0.16681962f, 0.02391439f, -0.23768473f, -0.12459137f, 
    0.09269930f, 0.04894651f, 0.01163195f, 0.07605423f, 0.08111825f, 0.00775893f, -0.11586980f, -0.07582814f, 
    -0.03455959f, 0.07791778f, -0.11079779f, -0.12819947f, 0.04450515f, -0.03933234f, 0.01556034f, 0.05474544f, 
    -0.01284232f, -0.11159116f, 0.03792644f, -0.16832587f, -0.20537341f, 0.21347952f, 0.24943912f, 0.34339976f, 
    0.03264834f, -0.25376633f, 0.20945245f, -0.13909169f, 0.05461956f, 0.03353922f, 0.05914254f, -0.01780301f, 
    -0.07211863f, 0.12055061f, 0.04947602f, -0.00783108f, 0.07257060f, 0.07577404f, 0.02005113f, 0.07251757f, 
    -0.04286939f, -0.02292913f, 0.13849826f, -0.07677368f, -0.12960945f, 0.20543373f, -0.20089202f, 0.06440945f, 
    -0.01986801f, 0.00937256f, -0.02066123f, 0.12549256f, 0.06061321f, 0.07651062f, 0.13999885f, 0.00379789f, 
    -0.03426021f, -0.01251321f, 0.01865680f, -0.00475700f, -0.00744402f, -0.01520542f, 0.02572250f, -0.02302226f, 
    0.01466028f, 0.02042913f, 0.00306104f, 0.00346361f, 0.01331490f, 0.01780134f, -0.00859835f, -0.00309568f, 
    0.02142339f, -0.03203587f, 0.00264817f, 0.02646636f, -0.02816107f, -0.03355861f, 0.00781527f, -0.00096738f, 
    0.02391359f, 0.02936871f, 0.01035842f, -0.02228995f, 0.02844015f, -0.00063513f, -0.03495629f, 0.02508769f, 
    0.00696606f, -0.03121007f, -0.03618884f, -0.03225014f, -0.02058617f, 0.00657459f, -0.00415174f, -0.01713772f, 
    -0.03203930f, -0.01722608f, -0.00547498f, -0.04353897f, 0.00537778f, -0.03746060f, -0.02776230f, -0.02380426f, 
    0.00641599f, 0.01056654f, 0.00929450f, -0.00042227f, 0.02102009f, 0.02401254f, -0.00502235f, -0.02020545f, 
    -0.03239128f, 0.00677364f, -0.00842477f, -0.02334325f, -0.02732183f, -0.01425193f, 0.00973308f, -0.02030421f, 
    0.02860164f, -0.00083587f, -0.01388357f, -0.01433593f, -0.04072000f, 0.02000173f, -0.03772852f, 0.00405685f, 
    -0.03327619f, -0.01965658f, 0.00232405f, 0.00479406f, -0.04364662f, 0.01791817f, -0.01121097f, -0.02333873f, 
    0.01503040f, 0.02141464f, -0.01721366f, -0.02698611f, 0.00259487f, -0.00112276f, 0.00448765f, 0.00904702f, 
    -0.02070376f, -0.00249098f, -0.04192966f, -0.00271666f, 0.02624868f, -0.02623757f, 0.01889766f, -0.02797662f, 
    0.00955313f, 0.00023800f, 0.02930949f, -0.01965337f, -0.03181080f, 0.01709326f, 0.00059555f, -0.03283836f, 
    -0.02293880f, -0.00109157f, -0.03838857f, -0.03849013f, -0.03390458f, -0.03441911f, -0.00483076f, 0.01655057f, 
    -0.00480374f, -0.01808573f, -0.03221780f, -0.02423866f, 0.02550736f, -0.03045460f, -0.02144992f, -0.02064808f, 
    0.02199364f, 0.00320093f, 0.00511903f, 0.02020699f, 0.00505491f, -0.03615510f, 0.01436110f, -0.02974780f, 
    0.02139421f, -0.01481777f, -0.01976396f, -0.01426291f, 0.00767826f, -0.01384316f, -0.02448164f, -0.03141561f, 
    -0.01281674f, -0.02479601f, 0.00894865f, 0.01922207f, 0.00168831f, -0.00739468f, -0.00943222f, -0.02181263f, 
    0.02736619f, -0.01895219f, 0.02067343f, -0.00004012f, 0.00069055f, 0.02784483f, 0.01936688f, -0.03717788f, 
    -0.02421797f, -0.00432127f, -0.03355294f, 0.00515220f, 0.01552554f, -0.01946092f, 0.00994694f, -0.01865990f, 
    0.00829982f, 0.03168485f, 0.00308594f, 0.00212968f, 0.02487050f, 0.03426378f, 0.00778691f, -0.01709125f, 
    -0.00285964f, -0.01059871f, 0.01723608f, 0.01396477f, -0.02319110f, 0.01315005f, 0.03036053f, 0.00826242f, 
    -0.02516142f, -0.02197778f, 0.00240767f, 0.03042094f, 0.00601929f, -0.03309196f, 0.00012929f, 0.00166719f, 
    -0.02747122f, -0.00179703f, -0.01659912f, -0.03741756f, 0.01061413f, -0.01216610f, 0.02155988f, 0.02838062f, 
    0.00851924f, -0.01205722f, -0.03514558f, -0.01985583f, -0.00343841f, -0.02739423f, -0.03726012f, 0.02160940f, 
    -0.01872807f, -0.03688107f, -0.03142033f, -0.00343585f, 0.03191756f, 0.00512453f, 0.00645793f, -0.02222284f, 
    0.01731553f, 0.01852721f, -0.00186760f, -0.01010357f, 0.00004608f, 0.01421675f, -0.02690355f, -0.04204514f, 
    -0.01352142f, 0.00035782f, -0.02237443f, 0.00923649f, -0.04012990f, -0.00973284f, 0.00529208f, -0.02342632f, 
    -0.00543902f, -0.00970877f, -0.02098007f, 0.01424563f, 0.01808669f, -0.03044204f, -0.01249364f, 0.01956073f, 
    -0.01000474f, 0.00987129f, -0.01854337f, -0.03397163f, 0.01629115f, -0.02770582f, -0.01986585f, 0.01119031f, 
    -0.02713518f, 0.02069073f, 0.01183376f, 0.01091809f, -0.04255351f, 0.01136565f, -0.03989976f, 0.01673793f, 
    -0.00159770f, 0.01121789f, -0.01250215f, 0.02813101f, -0.02019796f, -0.03467431f, 0.03557678f, -0.01200008f, 
    -0.02940909f, -0.01463288f, -0.01645985f, 0.02279735f, 0.00398281f, -0.01230234f, -0.03312176f, -0.04662138f, 
    -0.02298770f, -0.00678808f, -0.02676298f, -0.03190104f, -0.04381007f, 0.00793130f, -0.03733679f, -0.01355864f, 
    -0.03950757f, -0.02553613f, -0.00776224f, -0.00107861f, -0.02808623f, 0.01678556f, -0.02153385f, 0.02614344f, 
    -0.02730606f, -0.00910210f, 0.00494879f, 0.01222119f, 0.03002068f, 0.02870195f, 0.00426722f, 0.00753866f, 
    -0.04311002f, 0.01154020f, 0.01253250f, 0.02199282f, -0.02141914f, 0.00359637f, -0.01375638f, -0.01076070f, 
    -0.01877773f, -0.01420432f, -0.03926536f, 0.00193377f, -0.03031551f, -0.03882963f, 0.02141399f, -0.02549487f, 
    0.00826356f, 0.02826132f, -0.03449496f, 0.00564616f, -0.01905854f, -0.00506508f, 0.02755548f, 0.02497550f, 
    -0.04119947f, -0.01498875f, 0.03219821f, -0.02230509f, 0.01165342f, -0.02422545f, -0.01938956f, 0.02393483f, 
    0.01466963f, 0.02387029f, -0.01556800f, -0.01477046f, -0.02447768f, -0.01391193f, 0.01548117f, -0.03629617f, 
    0.01911126f, -0.00885931f, -0.01372924f, -0.01964567f, -0.03910175f, -0.01865095f, 0.00555792f, -0.02760052f, 
    -0.03091775f, 0.01772118f, 0.00041808f, 0.01615362f, -0.00476725f, 0.00746416f, 0.01300787f, 0.03113595f, 
    -0.03861077f, -0.01749967f, 0.01954557f, -0.02805753f, 0.02207989f, -0.04002120f, -0.01025549f, -0.00148179f, 
    -0.03366446f, -0.02982670f, -0.00814807f, 0.03167428f, 0.01164688f, -0.00223378f, 0.03341551f, -0.02211067f, 
    -0.02179551f, -0.00588701f, 0.00778888f, 0.00561990f, -0.03427096f, 0.02146201f, 0.01773421f, -0.00431032f, 
    0.00108928f, -0.01528545f, 0.02111570f, -0.00297287f, -0.01517520f, -0.00731618f, -0.00242873f, -0.02617934f, 
    0.01432492f, -0.01343418f, 0.01422401f, 0.02986131f, -0.02164577f, 0.02732035f, 0.00201208f, 0.00329448f, 
    -0.03711477f, 0.00985285f, 0.01171087f, -0.01031714f, 0.00997527f, -0.02801229f, -0.03198158f, 0.02257249f, 
    -0.03911549f, 0.02830822f, -0.03006979f, 0.02358888f, -0.01027194f, -0.01556164f, -0.00783385f, 0.00125591f, 
    0.02561573f, -0.00125500f, 0.00673291f, -0.01892757f, 0.02576827f, 0.00015745f, -0.00707222f, -0.01943969f, 
    0.00286601f, -0.01431152f, 0.00863782f, -0.01984684f, -0.03274710f, 0.02139303f, 0.01883216f, -0.04120870f, 
    -0.04039175f, -0.00876169f, 0.02757178f, -0.03618641f, -0.01469330f, 0.02190926f, -0.00166611f, 0.00874850f, 
    -0.03424226f, 0.00298286f, -0.01858892f, 0.02829468f, 0.01203688f, -0.02011035f, -0.00471697f, -0.03107604f, 
    0.00007000f, 0.03079962f, 0.02444762f, 0.02616223f, -0.02871914f, 0.02474208f, -0.01011658f, 0.02323923f, 
    0.02433798f, -0.03600112f, 0.00010410f, 0.02004683f, -0.02429628f, -0.01945456f, 0.02760735f, 0.01049095f, 
    0.02403964f, 0.02347984f, -0.01175612f, -0.02917553f, -0.03712997f, -0.02055443f, -0.00960204f, 0.02147329f, 
    0.02369962f, 0.01129090f, 0.01369052f, 0.02521722f, 0.01729339f, -0.00203760f, 0.02047859f, -0.01409809f, 
    -0.03228291f, -0.03113436f, -0.02754642f, 0.01284778f, 0.01965439f, -0.00203384f, -0.01194547f, -0.01628344f, 
    0.03523212f, 0.00603530f, -0.00865517f, 0.01567795f, -0.00116137f, 0.01141743f, -0.01693415f, -0.01107765f, 
    -0.02075699f, -0.03622204f, 0.02505881f, 0.00281625f, 0.02832349f, -0.01926839f, -0.01181797f, -0.02349587f, 
    0.01803398f, -0.02971637f, 0.03048083f, -0.01128429f, -0.03612626f, 0.02219404f, 0.01679709f, 0.02391457f, 
    0.00308711f, 0.00494099f, 0.02912659f, -0.03761983f, -0.03220111f, 0.01884561f, -0.04568102f, -0.01310236f, 
    -0.01625516f, 0.03457503f, -0.01156165f, -0.02433394f, -0.01029936f, -0.02592160f, 0.02204816f, 0.00630027f, 
    0.01112696f, -0.01109603f, 0.01628323f, 0.00127109f, -0.01984774f, 0.01637279f, -0.03787886f, 0.00302965f, 
    0.02008138f, -0.02497903f, -0.02057298f, -0.00380205f, 0.01576210f, -0.02849689f, 0.03941716f, -0.03196571f, 
    -0.03448759f, -0.00551646f, 0.01035353f, 0.02321973f, -0.01614087f, -0.03056148f, 0.01417935f, -0.01413003f, 
    -0.03170729f, 0.02095463f, 0.01051427f, 0.02019214f, 0.03679479f, 0.01475219f, 0.03428924f, 0.00592176f, 
    0.00526589f, 0.00999293f, 0.01815045f, 0.01991386f, 0.02898957f, 0.01056410f, -0.00135669f, -0.02521269f, 
    0.02136805f, -0.01120844f, -0.01814699f, -0.04663512f, -0.01977093f, 0.01638042f, -0.02899865f, 0.01739727f, 
    -0.00413255f, -0.00751521f, -0.00940275f, 0.03725049f, -0.03527223f, -0.02597759f, -0.01991731f, -0.00773050f, 
    -0.01511740f, -0.00487775f, -0.03790134f, 0.00861943f, -0.01188453f, -0.02597620f, 0.01438866f, -0.01845095f, 
    -0.01687617f, 0.00680014f, 0.02390548f, 0.01280315f, -0.01622643f, -0.03127782f, 0.01465727f, 0.02588532f, 
    -0.00242516f, 0.00266346f, -0.00099398f, -0.03105266f, -0.03174582f, 0.02103279f, -0.03939884f, 0.01777651f, 
    0.01209658f, -0.04187173f, -0.03021364f, 0.02485009f, 0.00377430f, -0.03754958f, 0.00357581f, -0.03594315f, 
    -0.00823168f, -0.02880209f, -0.02884612f, -0.01130558f, -0.01878481f, 0.01210544f, -0.03334327f, 0.01582850f, 
    -0.00761380f, -0.00753501f, 0.00540378f, -0.00177252f, -0.03186428f, -0.03427348f, -0.01734699f, -0.00727457f, 
    -0.02645781f, -0.01305196f, 0.01040978f, -0.02811016f, -0.01190750f, 0.00575272f, 0.01636036f, -0.01256508f, 
    0.00528535f, -0.03600452f, 0.00218921f, -0.01560671f, 0.03503503f, -0.01739857f, -0.00487218f, -0.02441975f, 
    0.02189326f, -0.03902365f, -0.01304977f, 0.01956179f, -0.03152762f, -0.01576031f, -0.01127719f, 0.00488306f, 
    0.00688791f, 0.00496166f, -0.01431693f, 0.02616104f, -0.00832058f, -0.01280393f, -0.03131221f, 0.00925319f, 
    -0.03705652f, -0.03550187f, -0.03701023f, -0.03076845f, -0.02183999f, 0.02558952f, -0.02734418f, 0.01652477f, 
    0.03036266f, 0.00284115f, 0.00206531f, 0.01616574f, -0.01568850f, 0.03198986f, -0.03693875f, -0.02860781f, 
    -0.00771833f, 0.00137364f, -0.03657811f, -0.01398838f, -0.01965191f, -0.03092914f, -0.04013086f, -0.03204760f, 
    -0.01248222f, -0.00028629f, -0.01569973f, -0.00401515f, 0.01164610f, -0.02756643f, 0.03666427f, -0.00819138f, 
    0.00397088f, 0.00930241f, 0.00096661f, -0.01157657f, -0.03451797f, 0.01472597f, 0.03130118f, 0.02153166f, 
    0.01360874f, -0.00228584f, 0.01199933f, -0.00944209f, -0.03719943f, -0.01053129f, -0.01085093f, 0.01069365f, 
    -0.03107877f, 0.02313057f, 0.02189782f, -0.02596627f, -0.00430545f, 0.01659898f, -0.03025468f, -0.03836814f, 
    -0.00096012f, 0.03612277f, -0.00533210f, 0.02159006f, 0.02096349f, 0.02435060f, -0.02462688f, -0.01365990f, 
    -0.02405000f, 0.00087806f, -0.02707783f, -0.03359184f, 0.02659803f, -0.02874215f, 0.01789727f, -0.03890232f, 
    -0.03796057f, 0.02902986f, -0.00637060f, 0.01559446f, -0.00185662f, 0.02593975f, -0.04107434f, -0.02087438f, 
    0.01959640f, -0.02698089f, 0.00353133f, -0.03190946f, -0.03469272f, 0.00863516f, -0.00644474f, -0.02157959f, 
    0.01876699f, 0.00681485f, 0.00397474f, -0.00371824f, 0.02599562f, -0.02648957f, 0.00782672f, 0.01674469f, 
    0.03123373f, 0.00285164f, -0.00392931f, -0.02643523f, -0.01525910f, -0.03670080f, 0.00830475f, 0.02635500f, 
    0.01685418f, 0.03312555f, 0.01887323f, -0.02104681f, -0.03926900f, -0.01182110f, 0.01148312f, -0.00838734f, 
    -0.01245569f, -0.00012349f, -0.01828725f, 0.02671674f, -0.01979998f, -0.03421586f, -0.00402086f, 0.01340356f, 
    -0.03402618f, 0.01130293f, 0.00803854f, 0.11480395f, -0.04482016f, -0.02006705f, -0.04147393f, 0.20175035f, 
    -0.01775124f, -0.08260287f, -0.00519454f, -0.15431893f, 0.12482401f, 0.10412765f, -0.07502848f, -0.02925423f, 
    0.01371395f, -0.03316624f, 0.03604811f, 0.02727125f, -0.01536321f, 0.11443571f, -0.05727233f, 0.11094864f, 
    -0.05676363f, -0.15186666f, -0.09412801f, -0.06787696f, -0.04557956f, -0.00190441f, -0.08846558f, 0.00436637f, 
    0.06015153f, 0.04723837f, 0.08027989f, 0.04011277f, 0.01524726f, -0.04483392f, -0.06878183f, 0.09277294f, 
    0.05957751f, 0.03366948f, -0.03736397f, 0.03417229f, 0.02826430f, 0.10495897f, -0.01755455f, 0.03229160f, 
    -0.03928860f, -0.35031900f, 0.39982346f, -0.00552225f, 0.07221978f, 0.07526655f, 0.01300357f, -0.00761200f, 
    -0.09058012f, -0.00788904f, 0.02526275f, 0.06988528f, 0.00940765f, 0.09806344f, -0.09884287f, -0.22048524f, 
    -0.08597387f, 0.12084761f, 0.05572824f, -0.01107327f, 0.09984064f, -0.03578958f, 0.09719692f, -0.01234795f, 
    0.01936366f, -0.02015183f, -0.02474789f, -0.11898614f, 0.00374464f, -0.00497311f, 0.04323338f, -0.00348215f, 
    -0.03222192f, 0.01270099f, 0.04337719f, 0.11365753f, 0.03681353f, 0.07501339f, 0.05789801f, -0.01416860f, 
    -0.01800762f, -0.02692688f, -0.00873483f, -0.05218209f, -0.01503320f, -0.02773452f, -0.06597526f, -0.12298635f, 
    0.35286072f, -0.22739007f, 0.08712775f, 0.16568941f, -0.01258304f, -0.10007293f, -0.09812423f, 0.07563540f, 
    -0.16616724f, 0.15271331f, -0.03574163f, 0.06320383f, -0.05126209f, -0.00037504f, 0.02223915f, 0.22352843f, 
    0.07877847f, -0.04652835f, 0.15958858f, 0.02190389f, 0.00508783f, 0.09314486f, -0.00085029f, 0.10125981f, 
    0.07099651f, 0.07645609f, -0.06597785f, 0.09664877f, 0.05072328f, -0.06774659f, 0.01483172f, -0.16288596f, 
    -0.04051577f, 0.03376838f, -0.07429888f, 0.06294991f, -0.05173868f, 0.05932966f, 0.05620211f, -0.04139610f, 
    -0.07354138f, -0.02253375f, 0.01512118f, -0.05088889f, -0.01737233f, 0.08121925f, 0.03259992f, 0.05572436f, 
    -0.18961427f, 0.01842632f, -0.05826076f, -0.00193139f, 0.15413930f, 0.13155027f, 0.13244873f, -0.03280510f, 
    -0.11297622f, -0.12736709f, -0.09628944f, -0.05730838f, -0.02224452f, -0.01857179f, -0.11377344f, -0.10654289f, 
    -0.03566846f, -0.05713992f, -0.04293317f, 0.01180876f, 0.10802718f, 0.00052981f, 0.02137023f, 0.00795489f, 
    0.06368531f, 0.04970107f, -0.15867120f, 0.09412004f, 0.01581426f, -0.03590953f, 0.11629229f, -0.03715791f, 
    -0.03721384f, 0.02734659f, -0.00209725f, 0.01656871f, 0.10703101f, -0.06885870f, 0.02988038f, 0.10453296f, 
    0.15367076f, 0.06469014f, 0.09964911f, 0.06709292f, -0.06321389f, 0.00132876f, 0.05898593f, 0.02401366f, 
    -0.02375066f, -0.14707750f, -0.10120196f, 0.04077655f, -0.09622962f, 0.03123192f, -0.06244245f, 0.00409576f, 
    0.00858943f, -0.00207093f, -0.04037707f, -0.04540531f, -0.10959234f, 0.14492323f, -0.08414308f, 0.00228062f, 
    0.02295086f, -0.05685290f, 0.05856373f, -0.09905339f, 0.12139764f, -0.05332203f, -0.04968246f, 0.00195688f, 
    -0.14543264f, 0.18301582f, 0.02031138f, 0.17251888f, -0.10367240f, 0.13061990f, 0.15164302f, 0.09050582f, 
    0.14126268f, 0.06381331f, 0.06418929f, -0.03316394f, -0.11335692f, 0.08252242f, 0.09371118f, -0.04180492f, 
    0.05360115f, -0.00574376f, 0.04300448f, -0.05545170f, -0.11222576f, -0.01230370f, 0.09743895f, -0.11837102f, 
    -0.03321452f, 0.07549292f, -0.29036480f, -0.20060188f, 0.01587853f, -0.03868812f, 0.07296132f, -0.03974525f, 
    -0.09111863f, 0.02253419f, -0.01212831f, 0.14508735f, -0.21566105f, -0.02436058f, 0.16410118f, 0.00382140f, 
    -0.08088363f, -0.04362081f, 0.01881234f, 0.00292413f, -0.03579953f, 0.08674724f, 0.00208400f, -0.03595711f, 
    -0.04072087f, 0.08503918f, -0.01532110f, -0.12242182f, -0.04614153f, 0.03538944f, -0.00105156f, -0.03418118f, 
    -0.00507532f, 0.06491407f, -0.10815311f, -0.08118238f, 0.00756546f, 0.16741921f, -0.07380957f, -0.03041113f, 
    0.01200286f, -0.03651303f, 0.01075148f, 0.07805135f, -0.00399018f, 0.05597978f, 0.03129863f, 0.02449615f, 
    0.11176445f, 0.11244454f, 0.11479183f, -0.13500331f, -0.02601358f, 0.04917368f, -0.07012565f, 0.01886232f, 
    -0.04515079f, 0.01880358f, -0.01402655f, 0.00271741f, 0.08411951f, -0.07373112f, 0.34285551f, 0.13701801f, 
    -0.02296676f, 0.03972461f, -0.01370434f, 0.07568377f, -0.03950623f, -0.02534569f, 0.14480674f, 0.02561394f, 
    0.28191602f, -0.11780336f, 0.02679569f, 0.24372755f, 0.05206565f, 0.07431931f, 0.08822902f, 0.04150521f, 
    -0.18808708f, 0.07331375f, -0.02740685f, -0.00239717f, -0.05214268f, 0.04676272f, 0.09741594f, -0.04770315f, 
    0.00587629f, 0.14313290f, 0.11973857f, 0.16170882f, 0.01316857f, -0.06012271f, -0.02727466f, -0.06183892f, 
    -0.06546111f, -0.03180080f, -0.10194121f, 0.00215395f, 0.03126454f, 0.08584937f, 0.04757652f, 0.03172158f, 
    0.04865123f, 0.05520312f, -0.00300855f, 0.08212014f, 0.02266539f, -0.09940687f, 0.11160568f, 0.21902937f, 
    0.01093294f, -0.02318984f, 0.07080989f, -0.07769816f, 0.01355792f, -0.00004641f, 0.04301548f, 0.13004716f, 
    0.27803880f, 0.04661811f, -0.09523764f, -0.12672596f, 0.07668273f, 0.02448653f, -0.01360672f, 0.11978455f, 
    0.07189059f, 0.09838453f, 0.08526523f, 0.13092148f, 0.08739646f, -0.15248457f, -0.17986979f, 0.10325403f, 
    -0.02588092f, -0.05016353f, -0.06904254f, -0.01333106f, -0.05552497f, -0.01828151f, -0.10284181f, -0.09083139f, 
    -0.00815510f, -0.21003722f, 0.03235880f, 0.22761868f, -0.13077860f, -0.04797193f, -0.04971774f, -0.10366436f, 
    -0.06215492f, -0.03782844f, 0.00075823f, -0.00318988f, 0.17236891f, -0.03520063f, 0.03079495f, -0.09752487f, 
    0.07125733f, -0.01082744f, -0.04768215f, 0.03931326f, -0.05094929f, 0.13224249f, 0.17070587f, 0.13782103f, 
    0.08116373f, -0.18225767f, 0.41790870f, 0.04534548f, -0.06551557f, -0.05979492f, -0.05179563f, 0.11259128f, 
    -0.00388784f, -0.15044861f, 0.14159910f, -0.06928699f, 0.27889302f, -0.25726753f, 0.14785753f, 0.23223425f, 
    0.11405959f, 0.13133243f, -0.03080500f, -0.15672013f, -0.11815352f, 0.03353561f, 0.13228270f, -0.01093218f, 
    0.02600910f, -0.16235590f, -0.01200504f, 0.29781529f, 0.00552129f, 0.09528897f, -0.00476964f, -0.05614891f, 
    -0.00658187f, -0.11954089f, 0.00862646f, 0.04468161f, 0.19573270f, 0.16445002f, 0.10751810f, 0.20193040f, 
    -0.02979823f, 0.06401314f, 0.09005840f, 0.09351467f, -0.05276487f, 0.10642679f, -0.00737866f, -0.01873638f, 
    -0.04951571f, -0.19479294f, -0.09024514f, 0.22648352f, 0.01560997f, -0.01505167f, 0.01348238f, 0.04374304f, 
    0.06233992f, 0.00041356f, 0.11326232f, 0.08474788f, -0.01909787f, 0.24512401f, -0.13269252f, -0.23958729f, 
    -0.10385422f, -0.14575022f, -0.14069878f, 0.10199191f, -0.05606269f, 0.01840932f, 0.01841374f, 0.20531079f, 
    0.12806398f, 0.11024203f, 0.32827908f, -0.00611994f, -0.05301262f, -0.00079501f, 0.00068461f, 0.17214584f, 
    -0.14637676f, 0.16024764f, 0.04913689f, 0.06153397f, -0.13485786f, 0.04447314f, 0.12375398f, -0.09424593f, 
    -0.03260754f, -0.09748369f, 0.01092819f, -0.03368612f, -0.13814731f, -0.01289300f, -0.09849039f, -0.03306831f, 
    0.27018997f, 0.02385076f, 0.02080455f, -0.08500432f, 0.08108621f, 0.08623055f, 0.07269718f, 0.00882894f, 
    -0.01212636f, -0.05199805f, 0.00281434f, -0.08427078f, -0.04220036f, -0.03406883f, 0.09437602f, 0.19931337f, 
    0.04706609f, -0.08874931f, 0.01447349f, 0.13568880f, -0.07807919f, 0.14300005f, 0.02299842f, 0.03784712f, 
    -0.00011139f, 0.08254069f, -0.05011008f, 0.06866753f, 0.08503063f, 0.00696004f, 0.06141290f, -0.13724950f, 
    0.13707092f, 0.00607761f, 0.04223361f, 0.09538449f, 0.17731434f, 0.08519556f, -0.06075884f, -0.12749426f, 
    0.04105344f, -0.02834737f, 0.02162538f, -0.07084035f, -0.04108191f, 0.14007510f, -0.02292554f, -0.01115709f, 
    0.01781477f, 0.25684428f, -0.24539886f, -0.21088862f, -0.08338800f, 0.03299451f, -0.08585452f, 0.02069861f, 
    0.00599540f, 0.08785557f, 0.09483384f, 0.21390279f, 0.03704872f, -0.17416197f, -0.12796926f, 0.01846840f, 
    -0.06210636f, -0.03181794f, 0.02702784f, -0.11284352f, -0.05022389f, -0.02802177f, -0.00460907f, 0.10402633f, 
    -0.07930261f, -0.02204253f, 0.01945091f, -0.05332907f, -0.13207094f, 0.04088113f, 0.02373368f, 0.04840970f, 
    -0.01874342f, 0.01110797f, 0.01319365f, 0.07450120f, 0.00616689f, 0.20682013f, 0.02083554f, 0.07149123f, 
    0.03771059f, 0.08660577f, 0.07278162f, -0.07413507f, -0.08155447f, -0.04934094f, 0.00012290f, -0.02768556f, 
    -0.03017680f, 0.01782818f, 0.12731884f, 0.23605271f, 0.11066808f, -0.04010469f, 0.06601829f, 0.08310268f, 
    -0.00732409f, 0.02705909f, 0.13341109f, 0.08259171f, 0.11792153f, 0.11590280f, -0.11730992f, -0.18059807f, 
    -0.04091714f, -0.07752882f, -0.00199512f, -0.02305613f, 0.00226328f, 0.02973497f, -0.05016860f, 0.02863377f, 
    0.03084111f, 0.06669078f, -0.45316949f, 0.04636820f, -0.08819396f, 0.00367380f, 0.11962742f, -0.02828469f, 
    -0.00193134f, 0.01235510f, 0.03230748f, -0.03673350f, -0.04168177f, -0.14731635f, -0.20660946f, 0.02008154f, 
    0.01301757f, -0.05121990f, -0.05306570f, -0.01132593f, -0.04262882f, 0.01091359f, 0.05053858f, 0.01576736f, 
    0.05792340f, 0.27875799f, -0.20896032f, 0.22082645f, -0.13685308f, -0.19127625f, 0.02205705f, -0.17629915f, 
    0.02352955f, 0.00932209f, -0.14742053f, -0.17740330f, 0.12891610f, 0.17302735f, -0.02464644f, -0.11359388f, 
    -0.07147972f, 0.02769991f, -0.03336199f, 0.01991353f, 0.10848106f, 0.02904200f, -0.06136082f, -0.07995528f, 
    -0.02058029f, 0.03752926f, -0.15265954f, -0.33896679f, 0.00205949f, -0.01373760f, 0.03730285f, 0.08585875f, 
    0.13313474f, 0.09415335f, -0.08698596f, 0.02292046f, -0.17493485f, 0.04994087f, -0.14188036f, 0.11566605f, 
    0.06663375f, -0.03234046f, 0.04136603f, -0.10925728f, 0.03625698f, 0.09088842f, 0.06117560f, 0.08632093f, 
    -0.12319412f, -0.06800312f, -0.14773095f, -0.00019068f, 0.03107642f, 0.07149675f, 0.05818672f, 0.16059993f, 
    0.06248420f, 0.06588946f, 0.01736595f, 0.01699693f, -0.08035012f, -0.02137103f, -0.20527685f, 0.16999994f, 
    -0.10101857f, 0.13085029f, -0.03410969f, -0.10359194f, 0.02271809f, 0.02419654f, -0.02448277f, -0.03642825f, 
    -0.00759718f, 0.04059795f, 0.10714450f, 0.01568137f, 0.10768890f, 0.07655121f, -0.05414322f, 0.12174729f, 
    -0.03500890f, -0.01335753f, 0.07347605f, -0.11106084f, -0.21033792f, 0.11603279f, 0.25413081f, 0.54749984f, 
    -0.09438512f, 0.00888018f, 0.02861059f, -0.17656311f, -0.07830020f, 0.02773154f, 0.05442651f, 0.06198316f, 
    -0.00823622f, -0.09445953f, -0.00778492f, 0.03802808f, 0.02354785f, 0.02494936f, 0.01603144f, 0.02923322f, 
    0.01561796f, 0.08236953f, 0.09690727f, 0.08732257f, -0.05314376f, 0.15399317f, -0.12879054f, 0.10561512f, 
    -0.02060425f, 0.00832210f, 0.15034935f, -0.01186122f, 0.04058341f, -0.09112696f, 0.10172357f, 0.12454070f, 
    0.26919329f, 0.09998613f, 0.11367854f, 0.07947882f, -0.05517885f, 0.18619888f, -0.03342959f, 0.04338442f, 
    0.13784821f, -0.03706997f, -0.08216418f, 0.04773632f, 0.31059214f, -0.05458043f, 0.11605188f, 0.05234229f, 
    -0.01248917f, -0.08230881f, 0.14968112f, 0.23424511f, -0.03258627f, 0.05834879f, 0.01571701f, 0.02812047f, 
    0.09988055f, 0.05702596f, 0.03107172f, 0.08118239f, -0.02406219f, 0.05163590f, 0.06707915f, -0.03383931f, 
    0.13655572f, 0.05077734f, 0.04548331f, 0.13594761f, -0.16253720f, 0.03320426f, 0.02870848f, -0.00512129f, 
    -0.09833114f, 0.03913158f, -0.10143273f, 0.06091210f, 0.25466594f, 0.01884526f, 0.17860025f, 0.19164746f, 
    -0.42298859f, -0.10288068f, 0.17885619f, -0.18046609f, 0.22724739f, 0.14707969f, 0.00091306f, -0.04536423f, 
    0.11926305f, 0.02575557f, -0.02196770f, 0.08069254f, 0.16518557f, -0.19300507f, -0.14716820f, -0.01621938f, 
    0.24647690f, -0.05904791f, -0.07839924f, 0.19256227f, 0.06987449f, 0.07044611f, 0.15760539f, -0.11884692f, 
    -0.11197852f, -0.01112892f, -0.03724476f, -0.02728250f, -0.04413526f, -0.01650555f, -0.01932262f, -0.05592928f, 
    0.08193490f, 0.15512742f, 0.18078645f, -0.08488562f, 0.16466548f, 0.09573522f, 0.06588651f, 0.11875016f, 
    0.06564990f, 0.05162001f, 0.02214471f, 0.04975485f, 0.07968786f, 0.14120069f, 0.02752623f, 0.08809040f, 
    0.23505047f, 0.03527437f, 0.02491388f, -0.03398172f, 0.06990695f, 0.01896198f, 0.10935019f, 0.01517657f, 
    0.02097256f, 0.09899528f, -0.00116861f, -0.04669343f, -0.17990448f, 0.04689456f, -0.09970235f, 0.09515177f, 
    -0.02204599f, 0.04278877f, 0.03156764f, -0.08968528f, 0.23898885f, 0.07845479f, 0.01326929f, 0.00217154f, 
    0.30044091f, 0.24218245f, 0.29348782f, 0.12567230f, 0.06303473f, 0.05939486f, 0.03489359f, 0.02670563f, 
    0.11752456f, 0.02857357f, -0.04621148f, 0.03366160f, -0.22516362f, -0.01637630f, -0.08624811f, -0.05032185f, 
    -0.07174465f, 0.00709724f, -0.01073525f, -0.04821230f, -0.00497195f, -0.13492589f, 0.00367369f, -0.12112468f, 
    0.07500917f, -0.23158939f, -0.00469608f, 0.09149205f, 0.20911093f, 0.04919999f, 0.14011483f, 0.31721547f, 
    -0.03564834f, -0.03371114f, -0.01045501f, -0.03832079f, -0.08157375f, -0.01433855f, -0.05714798f, -0.06532275f, 
    -0.05090379f, 0.00291106f, -0.06182742f, -0.04771567f, -0.14155808f, -0.10599319f, -0.17645726f, 0.05162934f, 
    -0.16847403f, -0.13293330f, 0.01786577f, 0.12750997f, 0.04951966f, 0.07232959f, 0.00996832f, 0.10213461f, 
    0.02733101f, 0.00357803f, 0.10786961f, 0.26863867f, -0.24884309f, -0.02072951f, 0.10704178f, 0.02104251f, 
    -0.07447163f, 0.06704133f, 0.08223716f, 0.16411594f, -0.04565145f, -0.10435826f, -0.04891482f, 0.07008967f, 
    0.05291143f, -0.00121428f, -0.18914066f, 0.07752270f, 0.08530730f, 0.21572866f, -0.00009527f, -0.08128066f, 
    0.02160861f, 0.00748561f, 0.00171166f, 0.08138911f, -0.16087282f, 0.06449241f, -0.08748709f, 0.00347846f, 
    0.06922318f, -0.00748432f, -0.01198487f, 0.01857089f, -0.05471630f, 0.07682227f, -0.06286886f, -0.18352215f, 
    -0.24131066f, 0.05617261f, -0.12419151f, 0.12396194f, -0.00110701f, 0.13270013f, 0.07565662f, 0.04343897f, 
    0.03807745f, -0.05543792f, -0.07347068f, -0.04580149f, -0.32681078f, 0.05678652f, -0.01744404f, 0.03069490f, 
    0.08740629f, -0.01451789f, 0.02035450f, -0.00924101f, -0.04874659f, 0.02339336f, 0.16372867f, 0.20704374f, 
    0.30529672f, 0.00594097f, 0.02944770f, -0.13249020f, 0.15728478f, -0.00851818f, 0.01872694f, -0.09677158f, 
    0.02698633f, 0.20660402f, 0.00798819f, 0.21544518f, -0.08696013f, -0.05222840f, 0.01888778f, 0.11576816f, 
    -0.03884915f, 0.13243550f, -0.10247763f, 0.03079788f, 0.02252557f, -0.07488649f, -0.06483725f, 0.01332534f, 
    -0.05413364f, -0.02168334f, -0.16692384f, -0.18653648f, 0.00094659f, -0.10332149f, 0.12987305f, 0.10228523f, 
    -0.05730254f, 0.06898914f, 0.29120207f, 0.20903103f, -0.20095265f, 0.05460674f, -0.02933629f, -0.26859444f, 
    0.09060168f, -0.01459514f, 0.12031076f, 0.05049321f, -0.11125372f, -0.10159105f, 0.05723716f, -0.06969485f, 
    0.01425391f, 0.04156670f, 0.16409807f, 0.15846223f, -0.00647380f, 0.06495452f, 0.03543090f, -0.06664106f, 
    -0.13760655f, 0.06476387f, 0.03589850f, 0.00407289f, 0.18504848f, -0.18817526f, -0.08440258f, 0.05472434f, 
    0.13956352f, -0.01040434f, -0.05162138f, 0.09645128f, 0.07312501f, 0.07235575f, -0.00452756f, 0.24417153f, 
    -0.07906524f, -0.04248584f, -0.06317817f, 0.21832478f, 0.07080678f, -0.02336675f, 0.22982350f, 0.17423134f, 
    -0.01733088f, -0.10226747f, -0.00037276f, 0.06128852f, -0.23034078f, -0.14431725f, -0.05080954f, 0.08819014f, 
    0.01699322f, 0.04429189f, 0.09969145f, 0.25193471f, 0.15259190f, 0.00737662f, -0.15248819f, -0.14726423f, 
    -0.04287789f, -0.23078717f, 0.06745187f, 0.08288288f, -0.05520502f, -0.04796518f, 0.12838314f, 0.10619286f, 
    0.06204162f, 0.05755251f, 0.21864530f, -0.01760533f, -0.11410486f, 0.13950799f, -0.10631361f, 0.03784166f, 
    -0.04955219f, -0.04944023f, -0.01365683f, -0.06804430f, -0.05263130f, -0.03523687f, -0.01666710f, -0.00313343f, 
    0.22576419f, -0.14244607f, -0.03392301f, 0.02904901f, 0.10350417f, -0.10867412f, -0.06304984f, 0.02099065f, 
    -0.11498858f, 0.11220590f, 0.11056906f, 0.20909478f, -0.03215004f, 0.03236902f, 0.03754120f, -0.00811682f, 
    0.15845229f, 0.17545041f, -0.00877875f, 0.07238277f, 0.04305835f, -0.01268164f, 0.11362814f, 0.10983737f, 
    0.21129374f, 0.21044713f, -0.08414424f, 0.05598405f, 0.17699970f, 0.00571131f, 0.15802707f, 0.00331906f, 
    0.03423711f, -0.04211768f, 0.00032960f, -0.08558262f, -0.02706202f, -0.13747102f, 0.02906698f, 0.21123214f, 
    -0.00007065f, 0.05634271f, 0.15425983f, 0.10192534f, 0.01713721f, 0.04857213f, -0.13943656f, -0.24738027f, 
    -0.43629640f, -0.21982946f, 0.20082091f, 0.21093760f, 0.20491783f, 0.17113343f, -0.13951716f, 0.12626944f, 
    -0.07810139f, 0.01378975f, 0.03116652f, -0.03530670f, 0.08972665f, 0.23885591f, -0.00668534f, 0.15336047f, 
    -0.05724169f, 0.06015399f, 0.27950820f, 0.16110086f, -0.06278335f, 0.07375737f, 0.01410999f, -0.20404921f, 
    0.29931563f, 0.09521751f, 0.10074453f, 0.10712069f, 0.16284892f, 0.09225635f, -0.03731110f, 0.00090768f, 
    0.07055785f, 0.14583290f, -0.00974476f, -0.02895294f, -0.32569897f, -0.05589566f, -0.01880070f, -0.02354199f, 
    -0.00034870f, 0.04515148f, 0.21746139f, 0.19801120f, 0.03714341f, 0.05970078f, 0.12168155f, -0.00896817f, 
    -0.00457057f, 0.01866719f, 0.05622885f, -0.14662312f, 0.14012064f, 0.10178589f, 0.04744813f, -0.11328431f, 
    -0.01686023f, -0.04876469f, -0.04173948f, 0.07197692f, 0.02450418f, -0.08857916f, 0.08801927f, -0.14443283f, 
    -0.09154972f, 0.05344419f, -0.02738737f, 0.03455156f, -0.00476714f, -0.11404281f, 0.12823869f, 0.01670717f, 
    0.34495047f, -0.25000000f, -0.06417402f, 0.10706869f, 0.11818071f, -0.00627020f, 0.13695265f, 0.02060669f, 
    0.02331905f, 0.13961385f, -0.08714776f, 0.07846947f, -0.20844319f, 0.00001406f, 0.06074047f, -0.07177128f, 
    -0.07999597f, -0.03396583f, -0.03447259f, 0.00436284f, -0.10125943f, 0.02763722f, -0.00524242f, -0.10529011f, 
    0.21868192f, 0.04046707f, -0.05771498f, 0.03764970f, -0.10454495f, -0.14566590f, 0.00374434f, 0.14712901f, 
    -0.05852129f, 0.09777492f, 0.01578362f, 0.04763846f, 0.21413729f, -0.11831746f, 0.07585707f, 0.10694718f, 
    -0.08717243f, 0.00033650f, 0.12259420f, 0.04235784f, 0.09799638f, -0.10119475f, 0.04451752f, -0.05729700f, 
    0.12406586f, -0.05328863f, 0.08013991f, -0.08367116f, 0.20332532f, 0.00391317f, 0.08181709f, 0.11017531f, 
    0.01740238f, 0.07512802f, 0.09336964f, -0.00095738f, -0.04406827f, -0.08662454f, -0.22114229f, -0.15268873f, 
    0.01560542f, -0.11799436f, -0.08706981f, 0.14261159f, -0.01087898f, 0.01614649f, -0.08173679f, -0.19115368f, 
    -0.01741965f, -0.07241125f, -0.05361976f, 0.00353427f, -0.01241372f, 0.01754569f, 0.01601771f, 0.15668711f, 
    0.12603195f, 0.06324343f, -0.02774388f, -0.18322855f, 0.03278014f, 0.09093025f, 0.07488829f, 0.08736529f, 
    0.09540005f, -0.06730689f, 0.06123115f, 0.15169327f, -0.02522997f, 0.03392924f, -0.01513967f, -0.03367611f, 
    -0.11127697f, -0.04057656f, -0.03541541f, 0.04902809f, 0.03538675f, 0.07507738f, -0.16318157f, -0.02084049f, 
    0.10673929f, 0.05479775f, 0.07366066f, 0.09217756f, 0.20306222f, 0.30520689f, -0.11696464f, 0.19748881f, 
    0.05626052f, 0.01692830f, 0.11401676f, -0.00013858f, 0.05515875f, 0.11599375f, 0.01674658f, 0.11387029f, 
    -0.22133864f, -0.13886432f, -0.00644121f, 0.29818103f, -0.02874506f, -0.05575575f, -0.13572410f, -0.06200182f, 
    0.22825217f, 0.15325195f, -0.00127580f, 0.14991933f, -0.03163303f, 0.14423387f, 0.09898544f, 0.06558004f, 
    -0.01387099f, 0.00127315f, -0.01531332f, -0.10206293f, -0.08001816f, 0.00282821f, 0.00381684f, -0.06343120f, 
    0.51931322f, 0.12834154f, 0.20780253f, -0.05795018f, 0.14001165f, -0.00291627f, 0.04665467f, 0.22205138f, 
    0.04983413f, -0.00520039f, 0.03632739f, 0.13091689f, -0.19448985f, 0.00914188f, 0.11012362f, -0.13829392f, 
    0.07370360f, 0.06136888f, 0.05658541f, 0.03264501f, 0.20512262f, -0.04969555f, -0.07571521f, 0.01506003f, 
    0.15855454f, -0.01206934f, 0.14066954f, 0.23716113f, 0.03103234f, 0.21096195f, 0.05399597f, 0.16873115f, 
    -0.00027380f, 0.01516299f, 0.17606579f, 0.01736180f, 0.20630263f, -0.05074225f, -0.22262654f, -0.05066700f, 
    0.01397085f, -0.08168704f, -0.05445391f, 0.22100921f, 0.02303087f, 0.04121427f, 0.00452696f, 0.06694952f, 
    -0.17330067f, -0.03262914f, -0.26602447f, -0.25361782f, -0.08531342f, -0.08076214f, 0.01145153f, -0.06687392f, 
    0.18269978f, 0.10762601f, 0.12422223f, 0.10464972f, -0.07970416f, 0.12243757f, 0.09022118f, 0.04722286f, 
    0.11166905f, -0.07019199f, 0.01545663f, -0.08535413f, -0.11205290f, -0.08888425f, -0.12146334f, -0.07469780f, 
    0.05298979f, 0.00598201f, 0.00156309f, 0.06575499f, 0.16521518f, 0.01578542f, -0.01629676f, 0.05382705f, 
    -0.02735992f, -0.09173577f, -0.07648940f, -0.15730640f, 0.10747387f, 0.33356223f, 0.08333214f, -0.22940010f, 
    0.01982678f, -0.04739694f, 0.18610555f, 0.02323888f, 0.08097547f, 0.04373406f, 0.01441243f, -0.11126690f, 
    -0.14657225f, -0.03372654f, -0.06432949f, 0.05803337f, 0.11990838f, 0.06829373f, -0.03879320f, 0.03830918f, 
    0.15278581f, 0.04839431f, 0.10218420f, 0.09138662f, -0.44108832f, 0.13967864f, -0.31832588f, 0.21878538f, 
    -0.18514495f, 0.14447701f, 0.01091322f, 0.14100434f, 0.01756649f, -0.14285129f, -0.00151418f, -0.01780224f, 
    -0.00609306f, 0.32518032f, 0.12749715f, -0.08266213f, 0.06545783f, 0.05265770f, 0.02950428f, 0.06474235f, 
    0.06911003f, -0.11392771f, 0.15516299f, -0.13783045f, 0.11620276f, 0.24100772f, 0.07395302f, -0.04335178f, 
    0.14128649f, 0.01004405f, 0.18577307f, 0.05974045f, 0.02799656f, 0.03343982f, 0.05733447f, 0.02167125f, 
    -0.00443743f, 0.10749644f, 0.09835336f, 0.16455135f, 0.10403616f, 0.01019429f, 0.04607504f, 0.03363169f, 
    0.02783122f, 0.05238942f, 0.02633638f, -0.02241842f, -0.36528748f, 0.34272248f, 0.00607907f, -0.00082389f, 
    0.11579269f, 0.11318067f, -0.11486040f, -0.00570982f, 0.13464023f, 0.08856047f, 0.04719779f, 0.10217494f, 
    -0.01589206f, -0.06444722f, 0.01646440f, -0.19061545f, 0.10851768f, 0.07396243f, -0.02250534f, 0.06323548f, 
    -0.00177225f, 0.01010247f, 0.02411169f, -0.12065477f, 0.10910726f, 0.02218559f, -0.06721863f, 0.12678456f, 
    0.06534915f, -0.03568865f, 0.10271275f, -0.00026098f, 0.02824894f, 0.14491522f, 0.06762225f, 0.13452348f, 
    0.20110182f, -0.32843909f, -0.08166462f, -0.05985522f, -0.02393687f, -0.30565247f, -0.00941216f, 0.03412581f, 
    -0.02018824f, 0.02458540f, 0.08326236f, 0.05146278f, -0.16001745f, 0.16621983f, 0.06389704f, -0.06009217f, 
    0.06528498f, 0.14260505f, 0.13006873f, 0.01455642f, 0.12302427f, -0.07662320f, -0.02090017f, -0.02263035f, 
    -0.06554874f, -0.11368309f, 0.03459451f, -0.04553916f, -0.08513871f, -0.09040312f, 0.07560188f, -0.00302657f, 
    -0.19110169f, -0.08575017f, 0.10664180f, 0.16714665f, -0.06057229f, 0.07178859f, -0.03501828f, -0.09653231f, 
    -0.01991374f, 0.03088434f, 0.12937368f, -0.06249996f, 0.05985472f, 0.05626955f, 0.05574782f, -0.02108205f, 
    0.20694968f, 0.06412519f, -0.00098556f, 0.06852031f, -0.05199890f, 0.03134627f, -0.16790853f, 0.12942629f, 
    -0.10061965f, 0.06889235f, -0.09190789f, 0.08183718f, -0.06463160f, 0.04379792f, 0.09048536f, 0.20523456f, 
    0.03551080f, 0.00539813f, 0.10234638f, 0.16979294f, 0.07236801f, 0.00103415f, -0.00083774f, 0.07161608f, 
    -0.02160371f, 0.00933426f, -0.21948434f, -0.20018937f, 0.07257108f, -0.06476393f, 0.06161066f, 0.01559659f, 
    -0.00721394f, 0.04518957f, -0.00212649f, 0.15206847f, 0.09784295f, 0.04371868f, 0.00194302f, 0.09845026f, 
    -0.02246473f, -0.04441879f, -0.03209385f, -0.04461285f, -0.13751149f, -0.08039667f, -0.08501440f, -0.00228634f, 
    -0.15564653f, 0.23747946f, -0.02325107f, -0.03288909f, 0.05349815f, 0.04804900f, 0.05501575f, 0.01548098f, 
    -0.03345076f, -0.08717278f, 0.08650999f, -0.01168537f, -0.07047708f, 0.01207161f, 0.00018793f, 0.05818409f, 
    -0.03862378f, -0.05545167f, -0.01776228f, 0.00214345f, -0.05923841f, -0.13006458f, -0.11637998f, -0.12222981f, 
    0.10452341f, 0.27284467f, -0.03875435f, -0.05105169f, 0.06759927f, 0.02645941f, 0.08642051f, -0.03045500f, 
    0.05889793f, 0.08650687f, -0.14528814f, -0.15456530f, 0.09966646f, -0.08311098f, 0.04743512f, 0.18876588f, 
    0.24869622f, -0.04274419f, 0.06392095f, 0.02577269f, 0.07705779f, -0.02482207f, 0.14647833f, -0.06552286f, 
    -0.10584784f, 0.07466484f, -0.10845805f, -0.07664493f, -0.15110686f, -0.02845609f, 0.06434137f, -0.05831382f, 
    -0.09356067f, 0.04786851f, 0.00718274f, 0.06525176f, -0.15102313f, 0.21543247f, 0.02959108f, 0.03477732f, 
    0.00077498f, 0.02832187f, -0.00536446f, -0.02853923f, -0.06411517f, -0.03967923f, -0.02739823f, 0.04857621f, 
    0.05257056f, 0.06778993f, 0.01590570f, 0.09489600f, -0.03221445f, 0.15046182f, 0.02521995f, -0.09752253f, 
    0.14567406f, 0.03717510f, 0.05892014f, 0.02342124f, 0.11490951f, -0.04338395f, 0.09542929f, -0.02596037f, 
    -0.14153634f, 0.01467831f, 0.03816057f, 0.00472397f, 0.00374345f, -0.01514740f, 0.08060296f, -0.01290859f, 
    -0.39502075f, 0.28072768f, -0.27391207f, -0.16043286f, 0.05375887f, 0.02213320f, 0.19357096f, -0.04780040f, 
    -0.00356534f, 0.06764556f, 0.06421761f, 0.00020255f, -0.08649345f, -0.03895226f, 0.23845884f, -0.08127932f, 
    -0.02096960f, -0.18495691f, -0.00927829f, 0.01344589f, -0.08783284f, 0.03096384f, 0.05230811f, 0.10899720f, 
    -0.07828756f, 0.00386561f, 0.06329238f, -0.01899600f, -0.02489355f, 0.00673912f, -0.10962793f, 0.02386309f, 
    0.06805312f, 0.06459548f, -0.10466480f, -0.09921686f, 0.14259823f, 0.30147129f, -0.13699605f, 0.13680409f, 
    -0.00709411f, 0.02888538f, 0.00817987f, -0.07472111f, 0.05469121f, -0.02773628f, -0.16308562f, -0.05404980f, 
    -0.07683396f, 0.07932022f, 0.18875378f, 0.02603432f, -0.00526336f, -0.16652639f, -0.09049998f, 0.10583309f, 
    -0.04855444f, 0.04021256f, -0.05336798f, 0.08352476f, 0.20184837f, -0.21347754f, 0.22087611f, -0.05350754f, 
    0.04345958f, -0.09021335f, 0.10310612f, 0.08737415f, 0.11086385f, 0.06019409f, 0.06933482f, -0.14541155f, 
    0.33009928f, 0.08873954f, 0.07863291f, 0.00352272f, 0.14600098f, 0.09277833f, -0.15419777f, -0.03231464f, 
    -0.09797336f, 0.04761024f, 0.05025429f, -0.04487858f, 0.04276766f, 0.09393580f, 0.06947739f, -0.03590960f, 
    -0.02483978f, 0.12499426f, 0.04771585f, -0.06557335f, -0.05043409f, 0.03657603f, -0.00201008f, -0.12072899f, 
    -0.24659672f, 0.04860513f, 0.10548314f, 0.00271140f, -0.03988786f, 0.07500976f, 0.11230344f, 0.07193134f, 
    -0.04923624f, 0.03109302f, -0.02348719f, 0.03963112f, 0.30926421f, 0.03902685f, 0.02954551f, 0.15274264f, 
    0.07131405f, 0.05016437f, 0.02494420f, -0.22062849f, 0.06980320f, 0.02121233f, -0.00394437f, -0.14348890f, 
    -0.10216452f, -0.05957484f, 0.15239160f, -0.08228845f, -0.03103533f, 0.10100118f, 0.02821159f, 0.16429332f, 
    0.09947769f, 0.08471926f, 0.02510584f, 0.22794482f, 0.04532501f, 0.05838244f, -0.22247805f, -0.03831423f, 
    0.01808899f, 0.01303210f, 0.13819274f, 0.02329746f, -0.06618786f, 0.00914977f, -0.04741696f, 0.01646385f, 
    -0.02331469f, 0.00391903f, -0.35264960f, 0.08460063f, -0.08327163f, -0.06027187f, 0.01471805f, -0.03556683f, 
    -0.17854953f, -0.06254854f, 0.08295912f, -0.04903702f, 0.02072459f, 0.02480268f, 0.08659746f, -0.11333396f, 
    0.13189505f, -0.04133831f, -0.08693209f, 0.08875103f, 0.03768107f, 0.04465169f, 0.09051052f, 0.05950105f, 
    0.17296255f, -0.35142663f, 0.39583904f, -0.25513509f, -0.17058411f, -0.16501741f, -0.02278463f, -0.07921527f, 
    -0.01524651f, -0.10694188f, 0.02888168f, 0.03571524f, 0.33474150f, -0.12100862f, 0.26585057f, -0.06907219f, 
    0.09504520f, 0.11850313f, -0.05821520f, -0.02992570f, -0.01439642f, 0.00776793f, 0.02577017f, -0.03807535f, 
    -0.01990544f, 0.02695410f, -0.30870664f, -0.00179602f, -0.03585808f, 0.00560059f, 0.10053845f, -0.05833784f, 
    -0.03143166f, -0.11734909f, 0.05629895f, 0.00671577f, 0.20614769f, 0.33572382f, 0.00994257f, 0.17433234f, 
    -0.05840380f, 0.01162435f, 0.03943678f, -0.13051176f, -0.04495910f, 0.10571297f, 0.01349315f, -0.00674316f, 
    0.02183237f, -0.14963365f, -0.28253219f, -0.08706809f, 0.06904124f, -0.00001758f, 0.03874562f, 0.04088168f, 
    0.13531454f, 0.07380353f, 0.11471142f, 0.05013768f, -0.32013106f, 0.26578087f, -0.00921136f, 0.02921231f, 
    -0.02367656f, -0.00895115f, 0.06573676f, 0.16684841f, -0.13414614f, 0.18122286f, -0.18003774f, 0.13330390f, 
    -0.08935368f, 0.10495404f, 0.27933937f, 0.04194973f, 0.01085547f, -0.00117083f, 0.02530332f, 0.18357031f, 
    -0.04447463f, -0.02931139f, -0.03422880f, 0.13555332f, -0.02377106f, -0.11192352f, -0.07207064f, -0.04492189f, 
    -0.08278597f, -0.23562287f, -0.11445341f, -0.01938718f, -0.19209357f, -0.03727242f, 0.01729947f, 0.09599880f, 
    0.03939061f, -0.01460234f, 0.22949922f, -0.01433503f, 0.05216955f, 0.14457470f, -0.03548576f, 0.03846877f, 
    -0.05078441f, -0.02668053f, 0.09873585f, 0.07959552f, -0.03518279f, -0.10448050f, -0.05744374f, -0.09333658f, 
    0.06582989f, 0.09818163f, -0.07766531f, 0.18146215f, -0.12901187f, -0.02504039f, -0.20223886f, 0.01246411f, 
    -0.25022018f, 0.24068892f, -0.04108601f, 0.14019100f, -0.01619735f, 0.03789577f, 0.03737888f, -0.11934766f, 
    0.04206626f, -0.06591407f, 0.07522635f, 0.11254121f, -0.00000799f, 0.10339203f, 0.05775238f, 0.01077328f, 
    0.03273825f, -0.00896745f, -0.02900517f, -0.07629457f, -0.06052132f, -0.07655761f, -0.02510203f, -0.02412631f, 
    -0.14510861f, 0.33061340f, 0.06179080f, 0.10794217f, -0.04899101f, 0.12325964f, -0.01547070f, 0.01307992f, 
    -0.10435510f, 0.08840208f, 0.04128571f, -0.01318542f, 0.11458641f, -0.01867748f, -0.07095467f, 0.03041519f, 
    0.02748427f, 0.14459448f, -0.09698661f, -0.22476779f, 0.00241143f, 0.03610776f, -0.06623971f, 0.00364348f, 
    -0.03245255f, -0.11298540f, 0.14237328f, -0.07439590f, -0.19064012f, -0.06584401f, 0.00319383f, 0.00597276f, 
    -0.04660840f, 0.07476149f, 0.03611744f, 0.17545578f, -0.04015630f, -0.02780483f, 0.05835557f, -0.03740066f, 
    0.04295336f, 0.09592241f, 0.06278073f, -0.06930051f, 0.02714205f, 0.12485307f, 0.16506635f, 0.13933414f, 
    -0.03182123f, 0.03501118f, 0.29311559f, 0.08596874f, 0.01623822f, -0.01432923f, -0.01109510f, 0.09341424f, 
    -0.02272702f, 0.02903482f, 0.02258601f, 0.02363275f, -0.07744680f, 0.04625781f, -0.00377187f, -0.02407671f, 
    -0.06317172f, -0.06221887f, -0.04867889f, 0.04724999f, -0.07397211f, -0.02314068f, -0.06034512f, 0.10213505f, 
    -0.25859880f, 0.20671646f, -0.43797818f, -0.06250796f, -0.02299909f, -0.02136582f, 0.14744340f, -0.04622621f, 
    -0.00714216f, -0.08823390f, 0.00034380f, -0.02260555f, 0.20138063f, 0.01089287f, -0.17069420f, -0.05455048f, 
    0.06484260f, -0.01782721f, -0.09593109f, -0.01379048f, -0.01454769f, 0.00682266f, -0.05919745f, -0.17779696f, 
    -0.08023575f, 0.21959387f, -0.23758541f, -0.18819642f, -0.01153786f, -0.04667732f, -0.08566479f, -0.05420690f, 
    0.15734360f, -0.11060429f, -0.14062683f, -0.08126280f, 0.06533735f, 0.23732919f, 0.13404118f, 0.12877668f, 
    -0.12356211f, 0.13070177f, -0.00192046f, -0.06492035f, 0.10860265f, 0.01758875f, 0.06004819f, -0.09411203f, 
    -0.20895620f, -0.12191898f, -0.09711879f, -0.00690215f, -0.10876157f, -0.06078897f, -0.00117308f, 0.04186092f, 
    0.04375601f, -0.06035005f, 0.00552759f, 0.01898649f, -0.13702811f, 0.09751406f, -0.09747926f, -0.06174456f, 
    0.12140441f, -0.01119764f, 0.00529111f, -0.07539481f, 0.15208961f, -0.06723656f, 0.01276891f, -0.01143248f, 
    -0.02960471f, -0.07441133f, -0.17070624f, -0.20323028f, -0.02824322f, 0.07492809f, -0.05348933f, 0.06372967f, 
    -0.02463972f, 0.02410368f, -0.03511575f, -0.06732811f, -0.21845800f, 0.19511868f, -0.24771422f, 0.17086945f, 
    -0.04892651f, 0.03769548f, 0.17623560f, 0.00020581f, 0.02548776f, 0.02911477f, 0.00524997f, 0.03579010f, 
    0.01148321f, 0.06052966f, 0.04976275f, 0.04528231f, -0.11044317f, 0.01958388f, 0.02079380f, 0.08892465f, 
    -0.10458208f, -0.07590509f, 0.15189737f, 0.06881857f, 0.38208580f, -0.04588179f, -0.01814095f, 0.38329330f, 
    -0.03422841f, -0.18020974f, -0.03105962f, -0.11436433f, -0.16263832f, 0.11518990f, -0.00147773f, 0.08975482f, 
    0.24293947f, 0.11709451f, -0.15475470f, 0.02490450f, -0.00237988f, -0.00939910f, 0.06492853f, 0.01510709f, 
    -0.04862864f, -0.00910937f, 0.07337928f, -0.00096690f, 0.07308786f, 0.24757509f, -0.25684881f, -0.04362825f, 
    0.06692007f, 0.11713011f, 0.08802117f, -0.07514988f, 0.17548142f, -0.11357857f, 0.06187034f, -0.05655110f, 
    -0.00018357f, 0.01212755f, 0.01724742f, 0.01879135f, 0.00981801f, -0.00522540f, 0.02180286f, 0.00577212f, 
    -0.01991264f, 0.00692910f, 0.01821596f, 0.01843416f, 0.00127769f, 0.01045079f, -0.02449286f, -0.00281018f, 
    -0.02545128f, 0.01496668f, 0.01543942f, -0.00617751f, -0.03541705f, 0.01323243f, 0.00782580f, -0.03346330f, 
    0.01610901f, 0.01296206f, -0.04019403f, -0.02872280f, -0.03694555f, 0.00534391f, 0.01081221f, -0.01154018f, 
    0.02390298f, 0.00762695f, -0.02841813f, -0.01461728f, -0.02172945f, 0.00066387f, -0.04055715f, 0.01907962f, 
    -0.00189586f, -0.00854530f, 0.00232941f, 0.02655686f, -0.00541914f, 0.01644849f, -0.03283997f, -0.03133848f, 
    -0.01459195f, -0.00844975f, -0.01752744f, -0.03868541f, -0.02257117f, -0.01267401f, -0.04158901f, 0.00687487f, 
    0.02303064f, -0.00567343f, -0.03416530f, -0.00789484f, -0.02131329f, -0.00741220f, -0.02335082f, -0.00670742f, 
    -0.03174613f, -0.02584577f, 0.00622493f, -0.02955135f, -0.02892856f, 0.00125975f, 0.01767698f, 0.01874915f, 
    -0.03633323f, -0.03255886f, -0.01188230f, 0.02183945f, -0.02923980f, -0.01946017f, 0.01079970f, -0.01565971f, 
    0.02561409f, -0.02419892f, 0.00490510f, -0.04021740f, -0.00502817f, -0.03853251f, 0.00116918f, -0.00971702f, 
    -0.01997764f, 0.02267398f, -0.02140040f, -0.03462076f, -0.00418907f, 0.02790882f, -0.03266378f, 0.01815557f, 
    -0.01027028f, 0.00656438f, -0.04102498f, -0.01925700f, -0.01037351f, 0.02245292f, -0.00257112f, 0.00358176f, 
    -0.01277937f, -0.03015254f, -0.00676063f, 0.00479436f, 0.02447067f, -0.03586466f, 0.02955418f, 0.00032444f, 
    -0.01965979f, -0.04037416f, 0.00899980f, -0.02616618f, 0.00360480f, 0.00300879f, -0.02619408f, -0.00431186f, 
    0.01093683f, -0.04080407f, 0.02456852f, -0.02541693f, 0.02811659f, 0.00346099f, -0.01803113f, -0.01997762f, 
    0.01113882f, 0.02019217f, -0.02715061f, -0.04240840f, 0.00725754f, 0.00195895f, -0.03771859f, -0.03817096f, 
    0.00736349f, 0.01666559f, -0.01567368f, -0.01637265f, 0.02292882f, -0.03458323f, -0.02957595f, 0.00651863f, 
    0.01721971f, 0.01843908f, 0.02884373f, 0.00066431f, 0.01626705f, -0.00783405f, -0.01197502f, 0.01903499f, 
    -0.02939540f, -0.01477462f, 0.02760817f, -0.01030904f, -0.03267725f, -0.03529887f, -0.00971715f, -0.03345039f, 
    0.00781976f, -0.03103745f, 0.01511963f, -0.04162737f, -0.02321961f, 0.02242861f, 0.00507679f, 0.02350222f, 
    -0.02314705f, 0.00391237f, 0.01631989f, 0.00203230f, -0.00076227f, 0.02061275f, 0.02586084f, -0.04178617f, 
    0.01235445f, 0.00369237f, -0.01936106f, -0.01526657f, -0.01436973f, 0.00424965f, -0.03772295f, -0.02005404f, 
    -0.02232116f, -0.00808984f, 0.00107696f, -0.01898593f, -0.02681107f, -0.03408661f, 0.02689450f, -0.01483570f, 
    -0.03593587f, 0.00202682f, 0.00345942f, -0.00314299f, 0.02093229f, -0.03459624f, -0.02669341f, -0.00231528f, 
    -0.02397157f, -0.01287922f, 0.01661499f, -0.02435299f, -0.04347043f, 0.01394122f, 0.00893685f, -0.03843676f, 
    0.00746756f, 0.00602769f, -0.00412604f, 0.01071669f, -0.02668396f, -0.00923296f, -0.03209006f, -0.00369250f, 
    -0.00518811f, 0.00366569f, -0.02136376f, 0.02501605f, -0.03663496f, 0.02614954f, -0.03752396f, 0.00696001f, 
    -0.01451337f, -0.03243069f, -0.03030669f, -0.02696095f, 0.02255276f, -0.02252273f, -0.02009171f, -0.02435486f, 
    -0.01093348f, -0.02923510f, -0.03477354f, -0.02478956f, -0.01537797f, -0.00554784f, -0.02772827f, -0.01366785f, 
    0.00168308f, 0.00752617f, -0.01728298f, -0.00667384f, 0.00027429f, -0.00376326f, -0.02158085f, 0.01579886f, 
    0.01653164f, -0.03258497f, 0.02480272f, 0.00386067f, 0.01071627f, 0.00498371f, 0.00189039f, -0.02658832f, 
    0.00968268f, 0.00783268f, 0.00759839f, -0.02063235f, 0.00875515f, -0.00455707f, 0.00135622f, 0.01437517f, 
    0.01472353f, -0.03063165f, -0.03233331f, -0.03399435f, -0.02520283f, -0.03214778f, -0.02388385f, 0.00488254f, 
    0.02706018f, -0.01205939f, -0.01635328f, 0.01358542f, 0.00209331f, -0.03743602f, -0.02774867f, 0.00755947f, 
    -0.00220331f, 0.02669405f, -0.02656118f, -0.02263063f, -0.00759161f, 0.00072857f, -0.03693456f, -0.01018236f, 
    -0.03989577f, 0.00160676f, -0.02874373f, -0.02074137f, 0.02371472f, 0.01034021f, 0.02530009f, 0.01726163f, 
    0.01792062f, 0.01164880f, 0.00921070f, 0.02790693f, -0.02113962f, 0.01149080f, 0.00234561f, 0.00924759f, 
    -0.02307169f, 0.00640833f, -0.00996931f, -0.02071661f, -0.03308066f, 0.02144746f, 0.01700975f, -0.03768117f, 
    -0.03831814f, -0.02762484f, -0.00349241f, -0.04247414f, -0.01619214f, -0.04189547f, 0.00483280f, 0.02206754f, 
    -0.03839986f, 0.01788322f, -0.02720198f, 0.02678231f, 0.01442751f, 0.02301028f, 0.01240999f, -0.01369601f, 
    0.02760505f, -0.01505906f, -0.00638182f, -0.03180691f, -0.02245116f, -0.02651373f, -0.03343667f, -0.03145525f, 
    -0.03946706f, -0.04126544f, -0.00502014f, 0.00019250f, -0.00678901f, -0.03697519f, 0.00243216f, 0.01100114f, 
    0.03041749f, 0.02904920f, -0.01028958f, -0.02615646f, 0.01941051f, -0.02575764f, 0.01332170f, -0.03803188f, 
    0.00854696f, -0.04060688f, -0.01274086f, 0.00807440f, 0.02272296f, 0.00099525f, -0.02622672f, -0.04083298f, 
    -0.01129348f, 0.01887753f, -0.03393154f, -0.01293250f, -0.03190409f, -0.01001849f, -0.02925853f, -0.01580050f, 
    0.02451098f, -0.02960074f, -0.01844215f, 0.01026177f, -0.02833705f, 0.02110531f, 0.01840959f, 0.02741937f, 
    -0.01364967f, -0.01530090f, 0.00760161f, -0.01064037f, -0.02164577f, -0.01534388f, 0.00806605f, -0.00015134f, 
    -0.02897123f, -0.02459955f, -0.02495159f, -0.03271054f, -0.03730965f, -0.03031392f, 0.01622286f, -0.02423100f, 
    -0.02075987f, -0.02994829f, 0.00679839f, -0.03292759f, -0.02393343f, 0.00767058f, -0.03183115f, 0.02226664f, 
    0.00058579f, 0.00288402f, -0.02519802f, 0.01052088f, -0.02625827f, -0.02585669f, 0.00466055f, -0.04032667f, 
    0.01850840f, 0.01299944f, 0.03462959f, -0.00712521f, -0.02234536f, -0.04024348f, -0.02921720f, 0.00564466f, 
    -0.02061518f, -0.00883491f, 0.00476727f, -0.02935906f, -0.03030461f, -0.00374516f, -0.03497384f, -0.00731276f, 
    0.00787525f, -0.00288973f, 0.01891914f, 0.00474291f, -0.01727651f, -0.01993338f, -0.01235341f, -0.01626915f, 
    0.02365473f, -0.01706885f, 0.02620820f, -0.01796172f, -0.02415089f, 0.01352497f, 0.00303757f, -0.00553574f, 
    -0.00088821f, -0.02770811f, -0.01056445f, 0.00963378f, -0.03656534f, 0.00470306f, 0.01838473f, -0.03467333f, 
    -0.02447232f, -0.02028466f, -0.01834065f, 0.00338336f, -0.01997109f, -0.02132911f, -0.02931439f, 0.01016443f, 
    -0.00646061f, -0.02494768f, -0.04207943f, -0.00903408f, -0.03148515f, 0.00548735f, -0.02331859f, -0.02248782f, 
    0.01164085f, -0.01248308f, -0.02385871f, -0.01983563f, -0.02146779f, -0.04022127f, -0.01438244f, 0.02148524f, 
    0.02133018f, -0.00830505f, 0.02720821f, -0.01334965f, -0.03156092f, 0.00075552f, 0.01131603f, -0.02455191f, 
    -0.00177822f, -0.03157925f, 0.01976098f, -0.03945369f, -0.02157021f, -0.01832620f, 0.01745869f, 0.02359435f, 
    -0.01877035f, -0.01590779f, 0.02896142f, 0.01283791f, -0.00925685f, 0.01783689f, -0.02320294f, 0.00405978f, 
    -0.03310337f, -0.03673504f, 0.03544824f, 0.01382986f, -0.03143219f, -0.01098100f, -0.00478612f, -0.02580086f, 
    -0.00202057f, 0.02766641f, 0.01735725f, -0.00914007f, -0.00484554f, -0.00642774f, -0.00344566f, -0.01764153f, 
    0.00384385f, 0.01038079f, 0.00258885f, -0.02650100f, -0.04002408f, 0.02603158f, -0.02977505f, -0.03031245f, 
    -0.00679082f, -0.00989408f, 0.00971503f, -0.03189782f, -0.03093750f, 0.00815095f, 0.00632688f, 0.02185156f, 
    -0.01635791f, -0.01605277f, -0.01052641f, -0.01951031f, 0.00987916f, 0.00798044f, -0.03102121f, -0.02133113f, 
    0.01091163f, 0.00397045f, -0.02857266f, -0.00783480f, 0.00228767f, -0.04195095f, 0.02537300f, -0.01703072f, 
    0.01077071f, 0.01706308f, -0.01305209f, -0.00498545f, 0.02554050f, -0.00418955f, -0.02386005f, -0.02939715f, 
    0.01646882f, 0.01542123f, 0.01833023f, -0.02045956f, -0.00953997f, 0.00014302f, 0.02022003f, -0.00606390f, 
    0.00667231f, -0.03861101f, -0.01724946f, -0.02978491f, -0.03598720f, -0.01674165f, 0.02532028f, -0.02178957f, 
    0.00595035f, -0.00815374f, -0.02572861f, -0.01017829f, 0.00229962f, -0.01181540f, -0.00566859f, 0.00860070f, 
    -0.03849507f, 0.01108831f, -0.01865894f, 0.00102418f, -0.01499732f, 0.01056535f, -0.01222689f, 0.03040158f, 
    0.00148561f, -0.02200158f, -0.03316327f, 0.01512341f, 0.01368671f, 0.01118464f, -0.01852906f, -0.01538574f, 
    -0.03868233f, -0.02093437f, 0.01913969f, -0.03456070f, -0.03112401f, -0.01408778f, -0.00677636f, 0.00979801f, 
    0.02910031f, -0.01780462f, -0.03834762f, -0.02865729f, -0.01525414f, -0.04205895f, -0.02763046f, -0.03195227f, 
    -0.01199243f, -0.00977363f, -0.01300427f, 0.02058870f, -0.03814544f, 0.02428218f, 0.02591965f, 0.02827035f, 
    -0.04118584f, 0.00505142f, 0.00755490f, -0.01368359f, 0.02001033f, -0.02374280f, -0.03888398f, -0.01079170f, 
    -0.00037320f, -0.03033934f, -0.01039351f, -0.00729912f, -0.03729114f, -0.01772594f, -0.04157021f, -0.02320802f, 
    -0.02787563f, -0.00038550f, -0.03546504f, -0.03619577f, -0.01504606f, 0.02725989f, -0.00843066f, -0.01227809f, 
    -0.01179681f, 0.02493057f, 0.02359735f, 0.02307661f, 0.01125916f, -0.03531026f, -0.02190734f, -0.00136737f, 
    -0.02498242f, -0.00598067f, 0.02645241f, -0.03912251f, -0.02982069f, 0.00267927f, -0.02454001f, 0.01816190f, 
    -0.03697168f, -0.02314338f, -0.00255061f, -0.00561818f, -0.02069917f, 0.02160729f, -0.00385396f, 0.01585603f, 
    0.00503430f, 0.01994184f, 0.01282240f, -0.01275461f, -0.00983413f, 0.01721631f, 0.01449326f, -0.03949665f, 
    0.00730702f, 0.00664246f, 0.02194848f, 0.02594266f, 0.01392242f, 0.02082156f, -0.02962527f, -0.02847054f, 
    -0.02560868f, -0.02090187f, -0.03046359f, -0.00134165f, -0.00278541f, 0.00728521f, 0.00076248f, 0.00361493f, 
    -0.01815717f, -0.02752018f, 0.01682056f, -0.04046617f, -0.03664622f, -0.01452836f, -0.04307886f, 0.00563960f, 
    0.02217366f, -0.00190982f, -0.02204743f, -0.00803989f, 0.01645101f, 0.01490523f, -0.02556358f, -0.03424203f, 
    -0.03846126f, -0.02500177f, -0.03311682f, 0.02394084f, -0.00937441f, -0.03050774f, -0.03022703f, -0.02345533f, 
    -0.03072952f, 0.01147459f, 0.00044439f, 0.02146201f, 0.02335653f, -0.03200153f, -0.03212471f, -0.00388354f, 
    -0.02770950f, -0.02633413f, 0.01485725f, -0.01059256f, 0.01946413f, 0.01742709f, -0.00002995f, -0.00376647f, 
    0.01668492f, -0.02991083f, -0.01140924f, -0.00311586f, -0.01577237f, 0.00334605f, 0.02998115f, -0.01645289f, 
    0.00586013f, -0.02670437f, -0.01841587f, -0.03724005f, 0.02815070f, -0.01859570f, 0.01318034f, -0.00474965f, 
    0.01149023f, 0.01713975f, 0.02026190f, -0.00081826f, -0.00427419f, 0.01027232f, 0.02563898f, -0.00573214f, 
    -0.00917136f, 0.02294956f, 0.01114599f, -0.02040491f, -0.00791851f, -0.00404266f, -0.01285619f, -0.01286207f, 
    0.01913666f, 0.02132446f, -0.01594339f, -0.03015253f, 0.02456861f, -0.00114170f, -0.03116997f, -0.00210607f, 
    0.07769968f, -0.09606555f, 0.02050056f, 0.17607130f, 0.02876524f, 0.15555602f, -0.07900860f, 0.07852793f, 
    0.09943756f, -0.01317549f, 0.03022675f, -0.02940212f, 0.21124405f, -0.29848123f, 0.04440865f, 0.25206125f, 
    0.01704109f, -0.13440236f, 0.01631312f, 0.18044652f, -0.01869691f, 0.09683023f, 0.06008198f, -0.03347741f, 
    0.00677586f, -0.08906192f, 0.06513120f, 0.09704076f, -0.10671740f, -0.04159592f, 0.03417768f, -0.06047455f, 
    -0.00873354f, 0.02116026f, 0.08297958f, -0.00662907f, -0.01957807f, -0.08447979f, -0.04586825f, 0.02946443f, 
    0.06266968f, 0.04918955f, 0.00547948f, 0.09616908f, -0.08761493f, -0.16260970f, -0.07136919f, -0.22114773f, 
    -0.08039970f, 0.18507411f, 0.10633077f, -0.07495839f, 0.28013054f, 0.28568202f, -0.14601897f, 0.01027840f, 
    -0.00343341f, -0.02877350f, -0.06695493f, 0.07052914f, 0.02378184f, -0.21204095f, -0.08636835f, 0.05372543f, 
    0.02448959f, 0.07405119f, -0.04758577f, -0.04276207f, -0.02706948f, 0.13270862f, 0.18119036f, 0.17665499f, 
    -0.11021495f, 0.00300195f, -0.15544470f, -0.03081514f, 0.04403485f, -0.03455907f, 0.02164083f, 0.01394392f, 
    -0.03922142f, -0.02892311f, 0.04967025f, -0.06413829f, -0.01246282f, -0.06228992f, 0.03999850f, 0.17104940f, 
    0.02951675f, 0.07615034f, -0.08486950f, 0.13963163f, -0.02206975f, -0.10277476f, -0.07140835f, 0.00013635f, 
    -0.18599144f, 0.09371725f, 0.09070444f, -0.03416279f, 0.07574063f, -0.12786771f, -0.01343881f, -0.03498062f, 
    0.16742215f, -0.02571707f, 0.05194029f, 0.04146071f, -0.00426639f, 0.15090761f, 0.00134388f, -0.00987775f, 
    0.08096188f, -0.10116085f, -0.01235100f, 0.01648866f, -0.20320961f, -0.13900229f, -0.11150990f, -0.15510626f, 
    0.05072297f, 0.18608424f, 0.18660745f, 0.03425102f, 0.00961759f, 0.01522829f, 0.01335862f, -0.10239685f, 
    0.04142731f, -0.05328627f, 0.02128047f, -0.08520205f, -0.08437054f, -0.17445175f, -0.02270802f, -0.08955351f, 
    0.05346109f, 0.06755556f, 0.04638278f, 0.03938626f, 0.08223739f, 0.06899502f, 0.04306994f, 0.08894864f, 
    0.26821229f, 0.00599099f, 0.00032725f, 0.20471701f, -0.07878675f, -0.00005129f, 0.07719070f, -0.02401984f, 
    0.08232844f, 0.00800469f, 0.04489161f, 0.09835630f, -0.03895544f, -0.03905985f, -0.12660147f, -0.05540328f, 
    -0.00933435f, 0.04895010f, 0.03743996f, -0.04932790f, -0.03312913f, 0.07616767f, 0.02714450f, 0.16525285f, 
    -0.02341435f, 0.07264823f, 0.12917338f, 0.10782972f, -0.11171745f, -0.04286727f, -0.00318988f, 0.09737205f, 
    -0.01418701f, -0.02248388f, 0.10324790f, -0.03662595f, 0.11511184f, 0.11481655f, 0.11394333f, -0.26112610f, 
    -0.00528502f, 0.04440616f, -0.08938091f, -0.02558383f, -0.07855433f, 0.11773075f, 0.02639602f, -0.01444845f, 
    0.00779026f, -0.02038727f, 0.28313404f, 0.01257171f, -0.04452530f, 0.00300007f, -0.10756906f, -0.13838346f, 
    -0.02613860f, -0.09048443f, -0.03129877f, -0.13002306f, -0.07274444f, 0.01468643f, -0.14463323f, 0.19208726f, 
    0.01957468f, -0.09409708f, 0.06559003f, 0.12793879f, 0.06087209f, 0.08493390f, -0.01562233f, 0.17395115f, 
    0.00451139f, 0.43810979f, 0.39630589f, 0.15812141f, -0.02829013f, -0.12361458f, 0.07327550f, 0.11380190f, 
    -0.09632902f, 0.03548197f, -0.05083446f, -0.04392237f, -0.07038057f, -0.06044534f, -0.14515851f, -0.18242840f, 
    0.02461646f, -0.02462887f, 0.04622216f, 0.10754683f, -0.03921954f, 0.00769961f, -0.03898368f, -0.06338397f, 
    0.15021275f, -0.20669770f, 0.00602828f, 0.26637262f, 0.05610222f, 0.00764560f, -0.03911136f, 0.04974308f, 
    0.07371278f, -0.10358665f, 0.03155250f, -0.06829104f, 0.11973555f, -0.28679255f, 0.31267148f, -0.14573462f, 
    0.06461022f, 0.14189927f, -0.09675811f, 0.08378173f, 0.06448944f, -0.03023692f, -0.05908216f, -0.10311881f, 
    -0.03062510f, -0.02035813f, -0.01781489f, 0.02943685f, 0.01109682f, 0.01541799f, -0.00074879f, 0.08045527f, 
    -0.10230488f, -0.03670906f, 0.10590813f, 0.09879120f, -0.10940252f, -0.12003214f, 0.16806997f, 0.11478207f, 
    0.01926889f, 0.01724837f, -0.04532326f, -0.06243432f, 0.06704962f, 0.12256034f, 0.22384644f, 0.27724761f, 
    0.22973391f, -0.19329667f, 0.09828859f, -0.23800161f, 0.04815028f, 0.15656336f, -0.01654824f, 0.06348915f, 
    0.03207820f, -0.05918347f, 0.04480099f, -0.09274384f, -0.09894244f, -0.00429458f, 0.00686227f, -0.16644318f, 
    0.08335539f, 0.05298528f, -0.01110145f, -0.13847208f, -0.08876729f, 0.00215711f, -0.17281716f, 0.15233639f, 
    0.02565768f, 0.23669761f, 0.19446582f, 0.22732072f, -0.06732941f, -0.04229441f, 0.06647573f, -0.01141598f, 
    0.05561325f, 0.09168977f, -0.00294034f, 0.28294557f, -0.02499265f, 0.30278480f, 0.33676893f, 0.30970296f, 
    -0.07127138f, -0.10407754f, 0.10464547f, 0.07648608f, -0.02348096f, 0.14385419f, 0.02913199f, 0.16115442f, 
    -0.11708075f, 0.00886730f, -0.03384627f, 0.32367200f, 0.11107305f, -0.05087244f, 0.05686924f, 0.09593372f, 
    0.00738210f, 0.07805286f, -0.02031998f, 0.13287097f, -0.27187100f, -0.01548159f, 0.23779640f, -0.02585603f, 
    -0.14920351f, 0.00128394f, -0.06180755f, 0.09762087f, -0.00473133f, 0.04618111f, 0.04923419f, 0.08365307f, 
    0.19107796f, -0.07893883f, 0.04789680f, -0.06732711f, 0.01365731f, 0.05261408f, 0.01459716f, 0.06327800f, 
    -0.08926020f, -0.04894247f, 0.00465306f, -0.04615145f, 0.00384672f, -0.12411947f, 0.18450154f, 0.04118748f, 
    -0.03375367f, -0.04101587f, -0.10861191f, 0.06056715f, -0.02351056f, -0.10168706f, 0.02535689f, -0.15684353f, 
    0.03334583f, -0.26900852f, 0.32727954f, 0.00688112f, 0.03769087f, -0.11704250f, -0.05629326f, -0.17323136f, 
    0.15094297f, -0.01531890f, -0.00739857f, 0.01423904f, 0.10001948f, 0.02793784f, -0.00340958f, 0.07784902f, 
    0.03433051f, -0.01754008f, 0.00503738f, -0.11364570f, 0.15166859f, 0.16102573f, 0.17994836f, 0.19103241f, 
    0.19837546f, -0.14172348f, 0.03020349f, -0.03025866f, 0.13150163f, 0.07049152f, -0.15543565f, 0.03665980f, 
    -0.04898365f, 0.10132153f, -0.00332749f, -0.02500068f, -0.13174564f, 0.10075532f, -0.05076016f, 0.08670770f, 
    -0.07263014f, -0.04124356f, 0.05976918f, -0.11927738f, 0.06267831f, 0.19379175f, 0.09073608f, 0.04951172f, 
    0.09750034f, -0.12606964f, 0.25528920f, -0.03324107f, -0.00129332f, -0.01085395f, -0.14072864f, -0.13712913f, 
    0.04784420f, 0.02127116f, 0.05685850f, -0.04702401f, -0.22202909f, 0.20819481f, 0.34088799f, 0.26677799f, 
    0.04939331f, 0.01966277f, 0.09987998f, 0.11484191f, 0.03275932f, -0.03077514f, 0.07065416f, 0.09497073f, 
    -0.10884298f, -0.09093341f, 0.21655077f, -0.09257607f, 0.06350398f, 0.03114745f, -0.07817062f, -0.05388854f, 
    -0.05967529f, -0.06701776f, 0.02068977f, -0.03225700f, 0.16221371f, -0.20832250f, -0.10968832f, 0.08126844f, 
    0.03307648f, 0.03752952f, -0.08398390f, 0.05706808f, 0.10285905f, -0.04379449f, 0.16480708f, 0.12906399f, 
    0.07788077f, -0.20839638f, 0.16592929f, 0.12838291f, 0.01727841f, 0.11622633f, 0.17230672f, -0.12896165f, 
    0.08068792f, -0.10384984f, 0.10394815f, 0.12533936f, -0.06271183f, -0.02366489f, 0.05428945f, -0.17389609f, 
    0.01763758f, 0.14999115f, -0.04242229f, 0.05358098f, -0.01833959f, -0.04245481f, -0.05586167f, -0.03952919f, 
    0.10339172f, -0.02617613f, -0.01329191f, 0.05315354f, 0.00044193f, -0.00119758f, 0.04029188f, 0.07037540f, 
    -0.05172079f, -0.09934008f, -0.03239933f, -0.11755560f, 0.10963301f, 0.21305375f, 0.10010320f, 0.08429113f, 
    -0.00045222f, -0.05204599f, -0.03559799f, -0.06177665f, -0.03430039f, 0.01501130f, 0.00170447f, -0.01550410f, 
    0.14761406f, -0.15051486f, -0.04145841f, 0.04216976f, 0.17541559f, -0.02367029f, 0.05333172f, 0.09209666f, 
    0.05364741f, 0.02566991f, -0.02917681f, -0.07764001f, -0.03282359f, -0.13368341f, -0.19107147f, 0.02227280f, 
    -0.01638440f, 0.01339884f, 0.16349000f, 0.08663810f, 0.10962706f, 0.04089588f, 0.08977599f, 0.18404362f, 
    0.07389532f, -0.09346747f, -0.13707505f, -0.00579040f, -0.02743922f, -0.01977422f, -0.10518011f, 0.14669277f, 
    0.16364659f, 0.15780555f, 0.22751389f, 0.20627920f, -0.09629550f, 0.03938763f, 0.08560133f, 0.07296850f, 
    -0.11710098f, -0.11252781f, 0.14347628f, 0.06052352f, -0.01412017f, 0.01339290f, 0.01076346f, 0.04802865f, 
    -0.01643233f, -0.03354049f, -0.17060992f, -0.06099407f, 0.01947150f, 0.02046910f, 0.01614961f, 0.09850053f, 
    -0.04398542f, -0.06398174f, 0.05554006f, -0.17475842f, -0.08901142f, 0.03867452f, -0.03622341f, 0.11705989f, 
    0.00728264f, -0.04604252f, 0.14337415f, 0.07653439f, -0.17490231f, -0.04641875f, -0.16196080f, -0.07245576f, 
    -0.13260968f, 0.10566504f, -0.06313897f, 0.07187676f, 0.03902582f, -0.03882463f, 0.10353936f, 0.00062744f, 
    -0.07865068f, -0.02160666f, -0.08560045f, -0.10334387f, 0.10841303f, -0.05436862f, 0.07152126f, -0.07240611f, 
    -0.01509651f, 0.01678604f, -0.00514891f, 0.06163868f, 0.06752779f, 0.00712892f, 0.06220325f, 0.04753480f, 
    0.14100836f, -0.18568361f, 0.13827327f, 0.07524829f, 0.03663564f, -0.09644682f, -0.08342388f, -0.02301364f, 
    -0.01149316f, 0.03665355f, 0.07487827f, -0.03834964f, -0.17967631f, 0.04088536f, 0.11520506f, 0.01432696f, 
    -0.03927983f, 0.00157536f, -0.02960690f, -0.14286590f, -0.02458570f, 0.03388824f, 0.13503349f, 0.17009708f, 
    0.03940918f, 0.04263699f, 0.10057336f, 0.20098865f, -0.04418173f, -0.01163733f, 0.03262741f, 0.08234470f, 
    0.05210448f, 0.00604809f, -0.00588782f, -0.00539414f, -0.00865269f, -0.14576913f, -0.10413887f, 0.05305438f, 
    0.06313864f, -0.00208934f, 0.02868151f, 0.24695240f, 0.07403626f, 0.12174843f, 0.01118167f, 0.04354316f, 
    -0.32220256f, -0.05488328f, -0.07811154f, 0.17401037f, 0.02946258f, 0.01660238f, 0.05091336f, 0.11880953f, 
    -0.11427744f, 0.07467844f, -0.05462404f, -0.05108823f, 0.07566271f, -0.02288664f, 0.03224079f, 0.08913020f, 
    -0.05137703f, -0.11669368f, -0.08074749f, -0.00042024f, 0.03242891f, 0.20264278f, 0.09535992f, 0.10962523f, 
    -0.03125452f, 0.08596215f, 0.05585346f, -0.01434806f, 0.02003560f, 0.01217224f, -0.06066770f, -0.10634102f, 
    0.00268485f, 0.22516492f, 0.09641562f, 0.10502934f, 0.05228542f, -0.12252329f, 0.32416949f, 0.21285470f, 
    0.06267334f, -0.11598097f, -0.10140606f, 0.02113723f, -0.06380688f, -0.00570996f, -0.01469091f, -0.10034061f, 
    -0.00129797f, -0.15450597f, 0.06929892f, -0.02836889f, 0.04301304f, 0.14318193f, -0.11824197f, 0.13838740f, 
    0.03595844f, -0.08654764f, -0.07235117f, -0.07266799f, -0.38051081f, -0.04884810f, -0.21727310f, -0.15299553f, 
    -0.03616289f, 0.07574676f, 0.04749928f, 0.10326264f, -0.02629743f, 0.05872310f, -0.00917348f, -0.04053311f, 
    -0.16363004f, -0.06604738f, 0.09312166f, -0.00877610f, 0.04151099f, -0.04608531f, -0.05403976f, -0.08313934f, 
    0.06487981f, 0.00307483f, 0.20638700f, 0.14118022f, 0.03626876f, -0.14252107f, 0.24230769f, 0.28721601f, 
    -0.04742935f, -0.01076363f, -0.02281310f, 0.00878069f, 0.01277053f, 0.15152578f, 0.15888074f, 0.16666003f, 
    0.01025983f, -0.00867489f, -0.01027299f, -0.00258580f, -0.03212878f, -0.03308978f, -0.01469528f, 0.03638012f, 
    0.01750571f, 0.01655413f, -0.00347936f, -0.02661878f, 0.00474082f, -0.00710893f, -0.03049452f, -0.00071714f, 
    0.01271267f, 0.01616983f, -0.01582055f, -0.02749318f, -0.00566474f, 0.00602124f, 0.01478462f, 0.03297652f, 
    -0.02595107f, -0.00685634f, -0.00891062f, -0.02074355f, 0.00200913f, -0.03198607f, 0.01301350f, 0.02804042f, 
    0.00398124f, 0.00251824f, 0.02594529f, -0.00480548f, 0.02725602f, -0.00090183f, 0.00771855f, -0.00640135f, 
    -0.00670222f, -0.03274113f, -0.04401520f, 0.02880843f, -0.00744693f, 0.00622637f, -0.02085396f, -0.01565491f, 
    0.00212045f, 0.01714578f, -0.04627932f, 0.01830592f, 0.01632083f, -0.03883512f, -0.02682888f, -0.02198755f, 
    -0.02327484f, 0.00343561f, -0.00036001f, -0.03231325f, 0.03021466f, 0.01805854f, 0.02455514f, -0.02623413f, 
    0.01028552f, -0.00337054f, -0.01329106f, -0.00612205f, 0.01432349f, 0.01383032f, -0.03580690f, -0.02041944f, 
    -0.01004832f, -0.00357229f, -0.00758302f, 0.01026153f, -0.01299342f, -0.01045565f, -0.03921472f, 0.01280262f, 
    0.01433473f, -0.02810133f, 0.00425519f, 0.00491168f, -0.01203995f, -0.02391680f, -0.02777549f, 0.01991639f, 
    0.01983775f, -0.02746855f, 0.00672623f, 0.01963275f, 0.00916347f, -0.00202441f, -0.02757075f, -0.00514569f, 
    -0.01290553f, 0.01934824f, 0.01684295f, 0.02415339f, 0.02784057f, 0.01372695f, -0.00042588f, -0.03529054f, 
    -0.02602984f, -0.01636653f, 0.02713368f, -0.00275282f, -0.03258810f, -0.02232115f, 0.01331073f, -0.02823259f, 
    0.01630798f, -0.02939915f, 0.02699397f, -0.01245836f, -0.03567198f, -0.03649218f, -0.04355588f, -0.04323271f, 
    0.01919704f, 0.03044784f, 0.00700327f, -0.00676378f, 0.01074119f, -0.01924450f, -0.01391587f, -0.02081809f, 
    0.00910784f, -0.00772014f, 0.01872443f, -0.01721055f, -0.00496597f, 0.02548273f, 0.00196014f, -0.02174144f, 
    0.00292565f, -0.00287831f, -0.01330961f, 0.00331324f, -0.00889612f, -0.01993147f, 0.00319820f, 0.00541245f, 
    0.01146650f, -0.01537187f, -0.02776982f, -0.00311940f, -0.00047594f, 0.01532039f, -0.01127908f, -0.03858685f, 
    0.00831543f, 0.00191937f, -0.01560185f, 0.00133949f, 0.03296999f, -0.01826473f, -0.00940306f, 0.02769106f, 
    0.02466769f, 0.02846008f, -0.01978819f, 0.02405347f, -0.01486398f, 0.01895116f, 0.02226132f, -0.00869202f, 
    -0.03769830f, -0.03492681f, -0.04081375f, -0.01892149f, -0.03416401f, 0.00138975f, 0.01945280f, -0.02180135f, 
    0.01911015f, 0.01924185f, 0.00383082f, 0.03816156f, -0.01491271f, -0.00825786f, -0.04110643f, 0.03234450f, 
    -0.01572312f, 0.02354644f, -0.01178161f, -0.03208486f, -0.00090321f, -0.04006051f, -0.03091188f, -0.01195688f, 
    -0.04606562f, -0.02430691f, 0.02683709f, -0.00218530f, 0.02283309f, -0.02250458f, -0.01786160f, 0.01723235f, 
    0.02904079f, -0.00451395f, -0.02035041f, -0.03092962f, -0.00182027f, -0.02029447f, -0.01601594f, 0.02991604f, 
    -0.02408334f, 0.01893549f, -0.01656436f, 0.01418121f, 0.02926622f, 0.02277520f, 0.01699613f, -0.02247566f, 
    -0.03830559f, 0.02087719f, -0.01332494f, -0.03192030f, 0.02659678f, 0.00982637f, -0.04048035f, 0.01814026f, 
    -0.03492690f, 0.03006600f, 0.03725407f, 0.02911934f, 0.00040823f, -0.02466067f, -0.02853919f, -0.01714329f, 
    0.01625706f, 0.01514308f, 0.00252332f, 0.00439594f, 0.02319886f, -0.02452035f, -0.00992896f, -0.04245016f, 
    0.02515924f, -0.02527124f, -0.02239165f, -0.04163987f, -0.00836595f, 0.00924564f, -0.00030112f, -0.02678738f, 
    -0.02498531f, 0.02113488f, -0.02420405f, -0.02053388f, -0.01867221f, 0.01439430f, 0.01304551f, 0.00529288f, 
    0.01005234f, 0.00486852f, -0.00011537f, 0.01605176f, -0.03294145f, 0.02105448f, -0.00905557f, 0.01145267f, 
    -0.00456932f, 0.01708287f, -0.00973050f, -0.02111625f, 0.02778368f, 0.01896822f, 0.02442906f, -0.00440181f, 
    -0.00318620f, 0.01727054f, -0.01608839f, -0.02883843f, -0.02115783f, 0.03029152f, 0.00006198f, -0.01898908f, 
    0.02979806f, -0.03873967f, 0.00722474f, -0.03333517f, -0.02209137f, 0.00030976f, -0.00266520f, 0.02905936f, 
    0.01030381f, 0.01225184f, 0.01426919f, -0.00868797f, -0.03631862f, 0.02605941f, -0.01678577f, -0.00111425f, 
    -0.02342173f, 0.01126080f, 0.01516890f, -0.03726219f, 0.00557940f, -0.00846242f, -0.01291029f, 0.00535106f, 
    -0.00518264f, -0.00848005f, 0.01053752f, 0.01054225f, 0.02312375f, 0.01815542f, 0.01960259f, -0.00472039f, 
    -0.00933807f, -0.02262365f, -0.04565224f, -0.04325391f, 0.02925875f, -0.00252580f, -0.03568831f, -0.02971123f, 
    0.02604418f, 0.02101794f, 0.02047755f, -0.00987133f, -0.00795176f, -0.00633057f, 0.02250540f, 0.03357139f, 
    0.02050219f, 0.01949711f, 0.00523181f, -0.00788083f, -0.01022377f, -0.00301344f, 0.00676061f, 0.02166231f, 
    0.02134030f, -0.02159502f, 0.00368718f, -0.00889539f, -0.00637377f, 0.01243685f, 0.01822061f, 0.00499061f, 
    -0.01285582f, -0.02316375f, 0.00586934f, 0.00476975f, -0.00687730f, -0.02274887f, 0.01690119f, 0.00937338f, 
    0.01268292f, 0.01098705f, -0.00793433f, -0.02063974f, -0.01411691f, 0.00035837f, 0.03979773f, -0.02650886f, 
    -0.01633996f, -0.02135406f, -0.01264553f, 0.01146670f, -0.01839786f, -0.01882804f, -0.03258775f, -0.03488722f, 
    0.01315484f, -0.02678516f, 0.01630699f, -0.02242696f, 0.00413602f, -0.02178262f, 0.01483309f, -0.00913864f, 
    -0.03540659f, -0.02852649f, -0.03705092f, 0.02138087f, 0.02018958f, -0.03600851f, -0.02192057f, 0.02084989f, 
    -0.04176580f, -0.01714645f, 0.01715183f, -0.01153217f, -0.01723067f, 0.00794919f, -0.03549670f, 0.00915983f, 
    0.03132781f, 0.00506778f, 0.01167641f, 0.03283567f, -0.01206574f, 0.02212648f, 0.01412056f, 0.02057120f, 
    0.00621301f, 0.00803120f, -0.01890352f, -0.03628742f, 0.04271244f, -0.00142551f, 0.02753541f, 0.02473690f, 
    -0.02734544f, -0.03711586f, -0.04355823f, -0.00335332f, -0.00751943f, 0.00860430f, 0.02722263f, -0.02669933f, 
    -0.00687745f, -0.04411618f, -0.02073808f, -0.01764745f, -0.03644982f, 0.01766335f, -0.03365916f, -0.00225598f, 
    -0.02019955f, -0.01500579f, -0.00051118f, 0.01637810f, 0.01030498f, 0.03454104f, -0.00898890f, 0.02438165f, 
    0.01602989f, -0.01311022f, -0.02108334f, 0.01503472f, -0.01677538f, 0.01443442f, -0.03627161f, -0.02851603f, 
    -0.00266701f, 0.02120505f, -0.00864141f, -0.00330012f, -0.01803203f, -0.03132917f, 0.02528846f, -0.00491940f, 
    0.00948782f, -0.01276686f, 0.02538737f, 0.01743290f, -0.03476303f, 0.01987787f, 0.00601859f, -0.03779655f, 
    -0.01264035f, -0.01668681f, -0.03909194f, 0.02910178f, -0.03834349f, -0.02393053f, 0.02274314f, -0.02742551f, 
    -0.03307070f, -0.00976473f, -0.00570478f, 0.01578404f, -0.00423187f, 0.03554686f, 0.00614258f, 0.01058607f, 
    0.00062355f, -0.02150862f, 0.00701261f, 0.00401035f, 0.02213763f, 0.03406558f, 0.00285594f, 0.00905049f, 
    0.00695710f, -0.03540168f, 0.02131862f, 0.00134290f, 0.02932643f, 0.00995072f, -0.01620878f, 0.00760226f, 
    0.00769434f, 0.02170928f, 0.00209272f, -0.04055563f, 0.02569201f, -0.00741113f, -0.01670568f, -0.03170615f, 
    0.00157257f, -0.00576690f, -0.02585633f, -0.03338934f, -0.02616695f, -0.02430106f, 0.01934061f, 0.00141930f, 
    0.00406029f, -0.02917453f, -0.00994785f, 0.01551602f, -0.00588261f, 0.02398403f, 0.02533803f, -0.03579457f, 
    -0.03136030f, 0.02217049f, -0.02465082f, 0.02319995f, -0.00096095f, -0.03141547f, -0.00946996f, -0.03489603f, 
    0.01987733f, -0.02622216f, -0.03865929f, 0.00349702f, 0.01717841f, -0.02697008f, -0.00503147f, -0.03148903f, 
    0.01908433f, 0.01192785f, -0.02564138f, 0.00097544f, -0.02571453f, 0.01652263f, 0.02682557f, -0.01266883f, 
    -0.01328410f, -0.00727747f, 0.01547587f, 0.01401861f, -0.02623977f, -0.00855862f, -0.00149387f, -0.00030181f, 
    0.02417585f, 0.01038274f, -0.01874094f, -0.00592636f, -0.03580924f, 0.00058118f, 0.01227586f, 0.01657014f, 
    -0.01961005f, -0.03205387f, -0.01257359f, -0.00295588f, -0.01958955f, -0.03284772f, -0.01390013f, 0.00333439f, 
    -0.04201179f, -0.01454983f, -0.00863177f, -0.00910354f, 0.01940094f, -0.03056045f, -0.01658810f, -0.02332447f, 
    0.01992280f, -0.00732563f, 0.02814175f, -0.03148466f, 0.00951043f, -0.01403469f, 0.01484306f, -0.02191907f, 
    0.02414117f, -0.02701635f, -0.01747899f, -0.03933246f, 0.00509640f, 0.00231730f, -0.00070221f, -0.03512187f, 
    -0.02626682f, -0.01439933f, -0.00516037f, -0.03306631f, 0.00957855f, 0.00454638f, 0.01108288f, 0.03354522f, 
    0.02931301f, -0.03637876f, -0.01694356f, 0.00103941f, 0.02541094f, -0.03226346f, -0.00384506f, -0.01327341f, 
    -0.02420572f, -0.03449969f, 0.02287159f, -0.03450047f, -0.03166034f, -0.03538411f, 0.02371010f, -0.02623628f, 
    -0.00832041f, 0.03313285f, -0.00653391f, -0.03926035f, 0.02135579f, -0.01795984f, -0.00421131f, -0.00673920f, 
    -0.00912553f, 0.01549120f, -0.03741314f, -0.00999792f, -0.00468485f, -0.00885533f, 0.02006282f, 0.02539594f, 
    -0.01057126f, -0.02396182f, -0.01989095f, 0.02424010f, -0.03517012f, -0.02902667f, 0.02147238f, 0.00118858f, 
    0.02808878f, -0.02286040f, 0.02987212f, 0.00633734f, 0.02336842f, -0.00526663f, 0.01371640f, 0.00649856f, 
    0.00314770f, 0.02301697f, -0.00597370f, -0.02438479f, 0.00754630f, -0.00177635f, -0.01159493f, 0.01744979f, 
    0.01674910f, 0.02426792f, -0.02295176f, 0.00949017f, -0.01358743f, -0.00285735f, 0.01635709f, 0.02263167f, 
    -0.02293982f, -0.01409609f, -0.02564451f, 0.01877811f, -0.00546740f, 0.02197979f, -0.02954663f, 0.02981990f, 
    -0.03668544f, -0.04544570f, -0.01387382f, -0.02652150f, 0.03166576f, -0.00077666f, -0.00074392f, 0.02841212f, 
    -0.03111650f, -0.03604501f, -0.01845713f, 0.00359080f, -0.00443340f, -0.03352620f, 0.01397983f, -0.00912197f, 
    0.00223891f, -0.01201207f, 0.02472206f, 0.00408546f, -0.01143894f, 0.01934687f, 0.03185065f, -0.00844666f, 
    0.02460151f, 0.01242925f, 0.03019322f, 0.02391179f, -0.00340886f, 0.03323203f, 0.02100071f, 0.02358633f, 
    0.02180067f, -0.00849940f, -0.02866389f, 0.02718815f, -0.01077176f, -0.00917530f, -0.00984911f, 0.02892818f, 
    -0.01412775f, -0.01969715f, -0.00388611f, 0.02187651f, -0.00792107f, 0.01460491f, -0.00794007f, -0.02336346f, 
    0.00288744f, 0.00723803f, 0.01890203f, -0.00996079f, -0.02342199f, 0.01216437f, -0.01610432f, 0.00381824f, 
    -0.03005033f, 0.00344873f, 0.02386410f, -0.03957785f, 0.00623252f, 0.02200466f, -0.00029992f, 0.02316573f, 
    0.01888967f, -0.03764353f, 0.02010134f, -0.04248573f, 0.00657672f, -0.02139568f, 0.00363497f, -0.02171350f, 
    -0.00913766f, 0.02389700f, 0.02752113f, -0.01246001f, -0.02292599f, 0.00785772f, -0.02945049f, 0.01295922f, 
    -0.02365533f, -0.03544102f, -0.00407877f, 0.02243990f, -0.02266483f, 0.02519804f, -0.00578765f, 0.00634261f, 
    -0.00626243f, 0.01580631f, -0.01014449f, -0.00712694f, -0.00860975f, -0.00254012f, -0.01895760f, -0.01591397f, 
    -0.03137431f, 0.00646890f, -0.03051267f, 0.03537781f, -0.03009490f, 0.01031048f, 0.00919701f, 0.01858694f, 
    0.02654746f, 0.02244325f, -0.13274819f, -0.02983063f, 0.01874543f, -0.02770134f, -0.02182463f, 0.10525578f, 
    -0.09934311f, 0.02801207f, -0.02345125f, -0.01438435f, 0.02589619f, 0.02372968f, -0.14391659f, -0.07461323f, 
    -0.04537341f, 0.12952429f, -0.03467932f, 0.09726549f, -0.11768050f, 0.02432282f, 0.00827755f, -0.06813090f, 
    -0.10274728f, 0.07039594f, -0.06241640f, 0.02762327f, -0.02434826f, 0.13293415f, -0.03155294f, 0.01850875f, 
    -0.11512597f, 0.07723396f, 0.07139297f, -0.03142466f, -0.03374822f, -0.07791293f, -0.03817320f, 0.21194169f, 
    -0.03910086f, -0.06265409f, 0.05544987f, -0.06835442f, -0.02939004f, 0.11597436f, -0.07431236f, 0.13361412f, 
    0.16047709f, -0.11613473f, 0.16343261f, 0.14348873f, 0.01704711f, -0.00671054f, 0.12825799f, 0.07694064f, 
    0.04195064f, -0.00210355f, -0.03672318f, -0.02857901f, -0.22734669f, 0.13365696f, -0.00475256f, -0.01894508f, 
    -0.01289261f, 0.06711757f, -0.04326477f, -0.03383861f, -0.07468148f, 0.06675646f, -0.12690297f, -0.04473285f, 
    0.05861956f, -0.19605933f, 0.11663726f, -0.14624050f, 0.22181673f, 0.09481679f, 0.01022978f, -0.07105262f, 
    0.01618951f, 0.03097448f, -0.06799226f, 0.03020960f, -0.07913575f, 0.00214555f, -0.07554238f, -0.07342916f, 
    -0.06926803f, 0.13128977f, 0.08684843f, -0.05108966f, 0.09952929f, 0.07883505f, -0.00845020f, -0.06561568f, 
    0.47365224f, -0.10750052f, 0.06325190f, 0.21503721f, 0.07821834f, -0.00774820f, 0.04940435f, -0.01446219f, 
    -0.07684815f, -0.05648302f, 0.02540139f, 0.14250739f, 0.15117069f, 0.08708270f, 0.07696119f, 0.09710040f, 
    0.10642706f, 0.09046014f, 0.01060852f, 0.01042270f, -0.06451859f, 0.09073821f, 0.11300822f, 0.12865415f, 
    0.02605288f, 0.02345894f, 0.04694768f, 0.22807769f, 0.01566412f, -0.00659985f, 0.02547828f, 0.07426846f, 
    -0.07164118f, -0.01668648f, -0.06824518f, 0.01116402f, 0.11160443f, 0.05973349f, -0.00085954f, -0.17107400f, 
    0.05373282f, -0.04287149f, -0.01796232f, 0.03384607f, 0.11802661f, 0.01892070f, 0.01664759f, 0.02597842f, 
    -0.14462222f, 0.08538225f, 0.09048294f, 0.13700728f, 0.07547315f, -0.05774126f, -0.01924493f, -0.10918450f, 
    -0.00542493f, 0.03499074f, -0.02157838f, 0.08250371f, -0.21391006f, -0.07577994f, -0.14328642f, -0.06339432f, 
    -0.04471667f, -0.06162500f, -0.05078478f, -0.02881892f, 0.18156675f, 0.10348774f, 0.02562408f, 0.02537728f, 
    0.03947693f, 0.02372968f, 0.01422618f, 0.14728302f, 0.02940693f, 0.05672132f, 0.07131835f, -0.03693501f, 
    -0.04889162f, 0.02275407f, 0.06696481f, -0.00098109f, -0.12485951f, 0.08176102f, -0.01823364f, 0.23721705f, 
    -0.13223067f, -0.04129473f, -0.04050779f, 0.01165244f, 0.03055091f, -0.04680988f, 0.12671222f, -0.00057501f, 
    0.01319740f, 0.07047471f, -0.00751489f, 0.17057763f, 0.05239937f, 0.00733992f, 0.02856449f, -0.01338263f, 
    -0.00181839f, 0.07945748f, 0.09428690f, -0.02719820f, -0.14306869f, -0.07089300f, 0.00778030f, -0.10202183f, 
    -0.17089187f, -0.01408909f, -0.08776692f, -0.02334103f, 0.10730352f, 0.11024120f, -0.00026826f, 0.02613961f, 
    -0.04122175f, 0.06351557f, 0.08211520f, 0.19308360f, 0.10225133f, 0.00245460f, 0.04609555f, 0.00815922f, 
    -0.04014224f, 0.10027692f, 0.09259396f, 0.09307706f, -0.06471435f, -0.19304135f, 0.09098971f, -0.00781425f, 
    0.07102942f, -0.02045722f, -0.03749551f, 0.02436325f, -0.05299193f, 0.01595193f, 0.09781964f, -0.01547389f, 
    0.09967428f, 0.10730419f, -0.16104224f, 0.01862694f, -0.17723639f, -0.02973153f, -0.08500060f, -0.00424151f, 
    -0.05372362f, -0.04979109f, -0.06250346f, 0.04752146f, -0.27604976f, -0.05830128f, -0.22365437f, 0.08450556f, 
    -0.11863278f, -0.03374302f, -0.00477892f, -0.04670375f, 0.03443829f, 0.03690088f, 0.06194081f, -0.03884228f, 
    0.07403199f, -0.01346390f, 0.00921649f, 0.00709849f, 0.16641894f, 0.05982861f, 0.02753518f, -0.02516333f, 
    0.04418349f, -0.02309870f, 0.00825248f, -0.02246867f, -0.03413766f, 0.12270759f, -0.05300182f, 0.02493540f, 
    0.05901535f, 0.14214651f, -0.01334630f, 0.12119231f, -0.14697011f, -0.03616380f, -0.03503115f, 0.06320584f, 
    0.17189749f, -0.01649201f, -0.08173246f, -0.05991899f, -0.11185056f, 0.00966111f, -0.07970954f, -0.00332743f, 
    0.05652270f, -0.10223401f, -0.02091361f, 0.01712886f, 0.08801758f, 0.01197823f, -0.01020314f, 0.24935377f, 
    -0.07118727f, 0.05660528f, 0.04556930f, 0.07023550f, -0.10863825f, -0.06496095f, -0.03514398f, 0.02680093f, 
    0.26786777f, -0.06776111f, -0.02922002f, 0.26821548f, 0.12955998f, -0.00608232f, -0.01000331f, -0.00891842f, 
    -0.09904508f, 0.05305260f, 0.01211965f, 0.14652282f, -0.08872081f, -0.00374455f, 0.04205532f, 0.09073216f, 
    0.13329162f, -0.05174086f, 0.06851035f, -0.06725676f, -0.12483709f, 0.08637338f, 0.01348082f, 0.01280643f, 
    0.18487620f, 0.06373011f, -0.10037114f, -0.24713904f, 0.08592647f, 0.09674917f, -0.06556626f, 0.02662193f, 
    -0.08138324f, -0.00561104f, -0.00963764f, 0.04251697f, -0.09055988f, -0.04531245f, 0.02462679f, 0.17723234f, 
    0.07154179f, 0.01046513f, -0.04636407f, 0.02277512f, -0.02357590f, 0.07038125f, -0.02611278f, 0.06522705f, 
    -0.29066867f, 0.01472109f, -0.15897156f, -0.03625477f, -0.11551791f, 0.03077422f, 0.03587227f, -0.10959043f, 
    0.05197987f, -0.01801115f, 0.01502609f, -0.03793808f, -0.03686707f, 0.00914077f, -0.10700798f, 0.23268332f, 
    0.02406930f, 0.11507197f, -0.05968253f, 0.00722158f, 0.02555772f, 0.05381842f, 0.00203696f, -0.03195528f, 
    -0.23504223f, 0.17530075f, -0.05501549f, 0.14648470f, -0.08893763f, 0.02499244f, -0.20609958f, 0.10265149f, 
    -0.01101373f, 0.12966102f, -0.01299220f, 0.00250454f, 0.25581178f, 0.09598005f, -0.01901092f, 0.00140974f, 
    -0.11640971f, -0.08305110f, -0.01234856f, -0.13806911f, -0.03236693f, -0.09213188f, 0.01323906f, 0.12680131f, 
    -0.17153282f, 0.08029210f, 0.21042328f, 0.08588661f, -0.10465713f, 0.02900614f, 0.09824220f, -0.07968120f, 
    0.14073427f, 0.06800281f, 0.03944163f, -0.02188852f, 0.28381735f, -0.13728862f, 0.09886530f, 0.19352199f, 
    0.16884892f, -0.06977394f, -0.10063154f, -0.00854714f, -0.02049080f, -0.00504302f, 0.04353531f, 0.00425223f, 
    -0.02712579f, -0.02882877f, -0.03589016f, 0.28800374f, 0.03161409f, 0.01105154f, 0.04419846f, 0.02161555f, 
    -0.00316251f, -0.01348240f, 0.10548913f, -0.04404328f, 0.12879615f, 0.09587501f, 0.11211378f, 0.06210845f, 
    0.17054491f, 0.03773831f, 0.08535711f, 0.05419226f, -0.05933609f, 0.06144835f, 0.02749453f, -0.00742582f, 
    0.00115036f, 0.04341139f, 0.04697904f, 0.34830043f, 0.01740649f, -0.01090668f, 0.09115860f, 0.11733612f, 
    0.00695688f, -0.01494076f, 0.09297848f, -0.04442097f, -0.10391498f, 0.08902889f, -0.16969734f, 0.00637314f, 
    -0.08019331f, -0.08046123f, -0.02109034f, 0.02447234f, -0.15023607f, 0.00333002f, 0.01453275f, 0.04490205f, 
    0.38216850f, 0.29537520f, -0.01282861f, 0.21207786f, -0.08832972f, -0.08597931f, 0.04523215f, 0.06242584f, 
    0.03754155f, 0.03212435f, -0.10796502f, 0.02470433f, -0.02152311f, -0.22492656f, -0.16830085f, 0.07131003f, 
    0.01881825f, -0.04129661f, 0.06016809f, -0.02371379f, 0.19660719f, -0.03465163f, -0.10996559f, 0.00537049f, 
    -0.09111580f, 0.06437415f, -0.13363747f, -0.19205348f, -0.01480588f, 0.10888952f, -0.09291158f, -0.04693723f, 
    0.08490027f, -0.02884186f, 0.02214797f, 0.03146999f, 0.12539268f, 0.04142043f, 0.10623112f, 0.18082502f, 
    0.04017513f, -0.01718194f, 0.14165932f, 0.13118094f, -0.05044525f, 0.05684940f, -0.02791310f, 0.11559702f, 
    -0.14645536f, -0.01564263f, 0.02100839f, -0.09301212f, -0.08477569f, 0.03805416f, 0.05660991f, -0.11645061f, 
    0.10996037f, 0.00788641f, 0.04989846f, 0.06884100f, 0.08959256f, 0.03539659f, -0.04621884f, -0.07595772f, 
    0.01260372f, 0.03634602f, 0.06178764f, -0.10068269f, 0.09677883f, 0.00185077f, 0.01790043f, 0.00281552f, 
    -0.09967162f, 0.19023667f, -0.06677259f, -0.04884717f, -0.12275524f, -0.03585936f, -0.01758996f, -0.08880069f, 
    0.01027201f, -0.00488006f, -0.16000631f, 0.00832248f, 0.04523738f, -0.12332978f, 0.04934172f, 0.17516856f, 
    0.02565758f, -0.06174868f, -0.06789575f, -0.13005467f, 0.00668110f, 0.04234217f, 0.00478016f, 0.09549526f, 
    -0.03501590f, -0.12456638f, -0.05516241f, -0.11893951f, 0.03879140f, -0.08618502f, -0.01343170f, -0.08205995f, 
    -0.04810409f, 0.11530503f, 0.09089039f, -0.04720478f, -0.01798479f, 0.08891512f, 0.09642909f, 0.07776337f, 
    0.07153620f, 0.11717746f, -0.07110475f, 0.07248049f, -0.08640244f, -0.04788731f, -0.03852417f, -0.07006078f, 
    0.41684791f, 0.14777224f, 0.11091798f, 0.01835107f, 0.09179840f, -0.04113747f, -0.03068845f, -0.08574543f, 
    -0.06106489f, -0.05917612f, 0.10893013f, 0.09139436f, -0.36779979f, -0.14815375f, -0.23896603f, -0.07797474f, 
    -0.19060770f, -0.05387948f, -0.05041446f, -0.08914470f, 0.08616056f, 0.10201909f, 0.01266175f, 0.03196182f, 
    -0.21951248f, 0.02161002f, -0.27836424f, 0.12852688f, -0.05660958f, 0.09956042f, -0.12109084f, 0.00284633f, 
    -0.00378131f, -0.06155732f, -0.04897348f, -0.04128856f, -0.09634150f, -0.01816896f, -0.08288662f, 0.16202512f, 
    0.11665217f, 0.09058233f, 0.06756394f, -0.04345925f, -0.08166163f, 0.02263514f, -0.06097209f, -0.07737634f, 
    -0.06240016f, 0.05168582f, -0.11910419f, 0.27361608f, -0.06092673f, -0.08817194f, -0.07491115f, 0.05238604f, 
    -0.07453430f, 0.03188701f, -0.04530564f, -0.08760457f, -0.10363789f, 0.35050887f, 0.00980345f, -0.21860752f, 
    0.04673793f, 0.08777798f, -0.03664386f, -0.01685517f, -0.07526742f, 0.05554939f, 0.02176371f, 0.01085641f, 
    0.16962437f, 0.24085580f, 0.09959546f, -0.19180650f, 0.22220170f, 0.09062756f, -0.00833720f, 0.03627914f, 
    -0.14689231f, -0.00004043f, 0.01335552f, 0.10724164f, -0.03122309f, 0.05723726f, 0.06788492f, 0.21560423f, 
    -0.04602062f, 0.03307286f, -0.00696629f, -0.00291126f, 0.02652973f, -0.04622624f, 0.07726172f, 0.07789398f, 
    -0.12427744f, 0.02879171f, 0.11743979f, 0.18175827f, 0.05233922f, 0.11898106f, -0.01176127f, 0.01234529f, 
    -0.02020635f, -0.01158220f, 0.03854711f, 0.09528051f, -0.23918922f, 0.10978343f, -0.20579191f, 0.01147631f, 
    0.21812582f, 0.12481716f, -0.14972849f, 0.02409101f, 0.01913210f, 0.01877071f, 0.02399171f, 0.06474444f, 
    -0.05906916f, -0.01955703f, -0.10800619f, 0.02070667f, 0.04407376f, 0.07258634f, 0.10146861f, -0.00171968f, 
    0.06136186f, 0.05729136f, 0.05993979f, -0.01954937f, 0.07549817f, 0.03172033f, 0.30680984f, 0.06585182f, 
    0.23455088f, -0.19318123f, 0.00374445f, 0.02223190f, 0.07304109f, -0.00984255f, -0.00963333f, -0.02547531f, 
    -0.16503726f, 0.11993866f, 0.04910009f, 0.08210719f, 0.05767653f, 0.06936355f, 0.03172449f, -0.04309507f, 
    -0.09326719f, -0.01532606f, -0.04781195f, -0.00082667f, -0.30873564f, 0.21266282f, -0.10084967f, 0.19047546f, 
    -0.15819733f, 0.13818325f, -0.09819087f, 0.04524639f, -0.09568424f, 0.00629474f, 0.01467343f, 0.01796527f, 
    -0.02929419f, -0.02636531f, 0.02866651f, 0.00620344f, -0.03731940f, -0.00082245f, -0.01359381f, 0.00510934f, 
    -0.04085073f, 0.02490536f, 0.01503608f, -0.02790109f, -0.03032888f, -0.00878041f, -0.03446130f, -0.02974001f, 
    0.01688790f, -0.02711214f, -0.01975376f, -0.02900789f, -0.00822710f, -0.03173473f, 0.01684605f, 0.02161326f, 
    -0.01947796f, -0.01570044f, -0.00481392f, -0.03426218f, -0.02294268f, 0.02010907f, 0.02435793f, 0.00152110f, 
    -0.01987653f, 0.01936791f, 0.01775796f, -0.00607826f, -0.01248745f, -0.03568982f, 0.00889308f, -0.02200476f, 
    -0.04091676f, 0.01331026f, -0.02920111f, 0.03034511f, -0.01318664f, -0.02688787f, -0.00039226f, -0.01806222f, 
    -0.00451886f, 0.03402274f, 0.01031766f, -0.00655101f, -0.03228663f, -0.00397266f, 0.00175154f, 0.01871445f, 
    0.00511034f, 0.01803198f, -0.01157438f, 0.02466571f, 0.01571736f, 0.02849304f, 0.00026450f, 0.01457978f, 
    -0.02374619f, 0.02114445f, -0.02524678f, 0.02318352f, 0.00889400f, 0.01724685f, -0.02502689f, 0.01842927f, 
    -0.03697266f, -0.04144669f, -0.00643706f, 0.02426987f, 0.03829485f, 0.01809242f, -0.01672405f, -0.00744206f, 
    0.02971623f, -0.00058322f, 0.01651098f, -0.03161374f, -0.00602610f, -0.02311520f, -0.03671892f, -0.02517607f, 
    -0.01089557f, 0.02519327f, -0.03264868f, 0.01101766f, -0.02149215f, 0.00517797f, 0.01890388f, 0.01382406f, 
    0.01474072f, 0.02554704f, -0.01582581f, 0.01758069f, -0.00967822f, 0.02232682f, -0.02927875f, -0.00056717f, 
    -0.00033074f, -0.03165118f, 0.00462750f, -0.02184960f, -0.02224102f, 0.02744829f, 0.03098415f, 0.02850529f, 
    0.02733231f, 0.00896046f, 0.01368345f, 0.01310834f, -0.02475489f, -0.00213490f, -0.03612253f, -0.03477436f, 
    0.01644484f, 0.00057135f, -0.03163724f, -0.00035265f, -0.01029483f, -0.02279748f, 0.00415037f, -0.03429091f, 
    0.00193847f, 0.02073543f, -0.03425561f, -0.01229472f, 0.00182303f, -0.01565488f, 0.00024219f, 0.01372662f, 
    -0.00970548f, -0.02150372f, -0.00222878f, -0.03591740f, 0.00420843f, -0.02564103f, 0.03908870f, 0.03491902f, 
    0.00728387f, 0.03034451f, 0.00945437f, 0.01521714f, -0.01475100f, 0.02666721f, -0.00276767f, 0.00140149f, 
    0.02557018f, -0.00808309f, 0.02533340f, -0.03116260f, 0.00678294f, 0.00818017f, -0.00831106f, 0.00755394f, 
    -0.03707614f, -0.03181947f, -0.02268410f, -0.00995524f, -0.00745244f, -0.03381443f, 0.02223317f, 0.00142338f, 
    0.03370705f, 0.02782067f, -0.01907077f, -0.00677004f, -0.00127539f, 0.02214663f, -0.04181984f, -0.01552992f, 
    -0.02476546f, -0.03782998f, -0.00954005f, -0.03622784f, -0.03172611f, -0.03645095f, 0.00328325f, 0.02799606f, 
    -0.02575020f, -0.02216174f, 0.01837612f, -0.01114840f, -0.01705889f, -0.00024150f, -0.03330062f, -0.01678752f, 
    0.03948984f, 0.00463811f, 0.03560442f, -0.02343775f, 0.00615408f, 0.01009953f, 0.01592971f, 0.02206145f, 
    -0.00289848f, 0.01190414f, 0.00273195f, 0.02558279f, 0.00420397f, -0.02675261f, -0.01723194f, -0.00282817f, 
    -0.00581506f, 0.00053834f, -0.01380044f, 0.03480691f, -0.00603137f, 0.01890181f, -0.00190790f, 0.02125713f, 
    0.03887039f, 0.00097783f, -0.00815795f, 0.01874913f, -0.03425600f, -0.00567345f, 0.00165465f, -0.01154644f, 
    -0.04174089f, 0.02794982f, -0.03497798f, -0.01049497f, -0.04331524f, -0.01363878f, -0.01492489f, -0.03430387f, 
    0.00120200f, -0.00269706f, -0.00758931f, -0.01097205f, 0.00077816f, -0.02629956f, 0.02487820f, 0.01996531f, 
    -0.03438700f, 0.00750849f, -0.02624014f, 0.03212119f, -0.00275651f, -0.02818833f, -0.04007604f, 0.00833931f, 
    -0.01680631f, -0.04124051f, -0.01812042f, 0.01821861f, -0.01644757f, -0.00879624f, 0.02305602f, 0.02246231f, 
    0.00441741f, -0.03533322f, 0.02726391f, -0.02171352f, -0.01229880f, 0.00157604f, 0.00268430f, -0.00691707f, 
    -0.03482760f, 0.01881808f, -0.00393740f, -0.01304843f, 0.00652262f, 0.00870025f, 0.02321304f, -0.02783881f, 
    -0.03020296f, 0.03387849f, 0.03147138f, 0.02192928f, 0.02794171f, -0.00898789f, -0.02045024f, -0.03808501f, 
    -0.03031557f, -0.00148399f, -0.03018940f, -0.01689933f, -0.01947785f, -0.00330523f, 0.01028892f, -0.04106372f, 
    0.01551042f, 0.01943791f, -0.00917336f, -0.03670112f, -0.04229603f, -0.01831921f, -0.00919381f, 0.00678799f, 
    -0.03931620f, -0.01046134f, -0.01589736f, -0.01803939f, -0.01120062f, 0.01685830f, -0.01261101f, -0.03372040f, 
    -0.02283232f, 0.01682242f, -0.01802169f, -0.01017687f, -0.01554782f, -0.01577807f, 0.00389601f, -0.00766265f, 
    -0.00717252f, 0.01949711f, 0.02823605f, -0.03662491f, -0.04011977f, -0.00744505f, -0.00019643f, 0.02567423f, 
    -0.01911728f, -0.01433355f, 0.00724824f, -0.00983089f, -0.01391651f, -0.02084399f, -0.03145773f, 0.02721616f, 
    -0.00984015f, 0.01929251f, 0.01777442f, -0.03698079f, 0.01738641f, -0.00823019f, -0.00507453f, -0.01954648f, 
    0.00111383f, 0.01682378f, -0.01386128f, -0.01006174f, -0.03589375f, 0.00377314f, 0.01718826f, -0.01160133f, 
    0.02989374f, -0.03134282f, 0.00415156f, 0.02849691f, -0.00192540f, -0.02071222f, 0.00663092f, 0.03877613f, 
    -0.04132853f, -0.00558170f, 0.00175921f, -0.04256741f, -0.02619450f, -0.03452975f, -0.01841260f, 0.00992539f, 
    -0.01309942f, -0.02241866f, -0.03859321f, -0.01312595f, -0.02799217f, -0.01823402f, 0.01843163f, -0.00406888f, 
    -0.01358986f, -0.02981415f, 0.01006612f, 0.02587428f, -0.00492875f, 0.00107924f, -0.00614967f, 0.00006932f, 
    -0.00634289f, 0.00936335f, -0.00701692f, -0.03331652f, 0.00850524f, -0.00110997f, -0.00217028f, -0.01206452f, 
    -0.02175938f, -0.01460494f, 0.00918854f, -0.01210283f, -0.01577150f, -0.00126023f, 0.00515285f, -0.00370607f, 
    -0.02412311f, -0.04097645f, 0.02210125f, 0.02454178f, -0.03273597f, 0.00119087f, -0.01057154f, 0.01290102f, 
    0.00838511f, 0.00882980f, -0.02660577f, 0.01135210f, 0.00988871f, 0.02620993f, -0.00272171f, -0.03180419f, 
    -0.02398407f, 0.00317460f, 0.00684920f, 0.02461817f, -0.01116041f, -0.04006899f, -0.02146730f, -0.03345196f, 
    0.00042607f, -0.02133330f, 0.00357392f, 0.02653473f, -0.00253234f, -0.02217014f, 0.02247915f, -0.02590309f, 
    -0.00979472f, -0.03106327f, 0.01381527f, -0.03476246f, -0.01694779f, -0.00316376f, -0.00504058f, -0.00855634f, 
    0.00363193f, 0.00067882f, -0.00751805f, -0.03849104f, -0.00409688f, -0.04107113f, 0.00599340f, 0.00134983f, 
    -0.03284240f, -0.02628587f, 0.00517808f, -0.03122351f, -0.00817138f, -0.00280969f, -0.02507070f, -0.02274415f, 
    -0.01270571f, 0.01012960f, -0.00453512f, 0.00462832f, 0.03140330f, 0.01274403f, -0.00239776f, 0.01866027f, 
    0.00812181f, 0.01122544f, 0.00374568f, -0.00226755f, 0.02509607f, 0.02229154f, 0.00425304f, -0.01173140f, 
    -0.03715680f, -0.01093362f, 0.02111843f, 0.01467498f, 0.00315240f, 0.01811410f, -0.00828147f, -0.04047759f, 
    0.01336080f, -0.01233459f, -0.01720259f, -0.04006524f, -0.03408042f, 0.02261121f, 0.03000029f, 0.00077578f, 
    -0.02479436f, -0.01210374f, -0.02417984f, -0.03411422f, -0.03492952f, -0.04126322f, -0.03956948f, -0.03540428f, 
    -0.00793162f, -0.00038820f, -0.00457209f, 0.02615311f, -0.02723206f, -0.01396816f, -0.01481033f, -0.01039524f, 
    -0.00870205f, -0.00905326f, -0.01510835f, -0.00992637f, -0.02641474f, 0.03773778f, 0.01561285f, 0.02850742f, 
    0.02245456f, 0.02056559f, -0.01160027f, -0.01712059f, 0.02573718f, -0.00287195f, -0.00719556f, -0.03272255f, 
    -0.00096277f, -0.02548359f, -0.02090170f, 0.01568551f, 0.02981481f, 0.03070105f, -0.02104688f, -0.02431391f, 
    -0.00718968f, -0.03655014f, -0.01505450f, -0.01459060f, -0.02014805f, -0.01197960f, -0.00180797f, 0.01635766f, 
    -0.00806842f, 0.01502786f, 0.02077603f, -0.01797947f, 0.01947812f, -0.02092350f, -0.01562153f, 0.02328837f, 
    -0.00339085f, 0.00317564f, -0.02744189f, -0.00057142f, 0.00591943f, -0.00220699f, 0.01482097f, -0.01569901f, 
    -0.00019280f, -0.01259671f, -0.00336324f, -0.03482915f, 0.00073525f, 0.01806581f, -0.02267824f, 0.02561832f, 
    -0.02200547f, 0.01789607f, 0.02172486f, 0.01324594f, 0.01157883f, 0.00109196f, 0.00955088f, -0.03694603f, 
    -0.00797013f, 0.02916460f, 0.01233690f, 0.01107859f, 0.02734733f, 0.00497189f, 0.03656980f, 0.04271502f, 
    0.01541345f, -0.00699657f, 0.01126254f, -0.00775330f, 0.01774783f, -0.00966721f, 0.02195908f, -0.00567190f, 
    0.00545047f, 0.01067672f, -0.00013388f, -0.04345670f, 0.01959744f, -0.00450719f, 0.01146790f, -0.02292512f, 
    0.03200409f, -0.03399683f, -0.03372370f, -0.00745645f, -0.01376331f, 0.00684521f, 0.01313544f, 0.02606156f, 
    0.03094213f, -0.01325542f, -0.02945819f, 0.01207135f, 0.02301712f, 0.01692582f, 0.02266525f, 0.00220308f, 
    -0.00337060f, 0.02491382f, -0.00544961f, 0.02422218f, -0.03209613f, -0.04253234f, -0.00486080f, -0.01475060f, 
    0.00122697f, -0.00223941f, 0.02473159f, -0.01504998f, 0.00768314f, -0.02001757f, 0.02071607f, -0.01574036f, 
    0.01862762f, -0.03430856f, -0.01177349f, -0.01631302f, -0.01088819f, 0.01841967f, -0.00384487f, -0.02376669f, 
    -0.00748296f, 0.01709654f, -0.00726041f, 0.03378871f, 0.02036930f, 0.03012477f, 0.01820679f, -0.00608090f, 
    -0.03460355f, -0.00907689f, -0.03810279f, 0.00025938f, 0.02950837f, 0.00037051f, 0.02579045f, 0.03221588f, 
    0.02635150f, 0.00986355f, 0.02520141f, 0.00985441f, -0.02477511f, 0.01200161f, -0.03509673f, -0.01478641f, 
    0.02854122f, -0.03407065f, -0.03421456f, 0.00796741f, -0.01753756f, 0.00412467f, 0.00610681f, 0.02141038f, 
    -0.00882991f, 0.02464684f, -0.02545849f, -0.02310880f, -0.00927582f, 0.01299341f, -0.01618895f, -0.00502003f, 
    -0.01300358f, 0.02359639f, -0.02737569f, 0.03008846f, -0.01775664f, -0.03812058f, -0.03418341f, 0.00067359f, 
    -0.01980965f, 0.02750166f, 0.02740536f, -0.01016935f, -0.02216846f, -0.01949922f, 0.00871464f, -0.04062481f, 
    0.02042191f, -0.01612522f, -0.01266272f, -0.02278712f, -0.02932561f, -0.01105951f, -0.02880963f, -0.01897157f, 
    -0.03040677f, -0.03481620f, -0.02631664f, -0.01599404f, 0.00933665f, -0.00603034f, -0.02902814f, 0.00375467f, 
    0.00523481f, -0.03592016f, -0.00217827f, -0.01025598f, 0.01012390f, -0.01748439f, 0.00041048f, -0.01858331f, 
    0.01653131f, -0.04033649f, 0.02499663f, 0.01230902f, -0.01327157f, -0.02321029f, -0.02628987f, 0.00827066f, 
    -0.00211821f, 0.02327731f, 0.02654282f, 0.00507082f, 0.02590304f, 0.01668504f, 0.00732424f, 0.00117628f, 
    -0.00062483f, -0.03091585f, -0.02786826f, 0.00642734f, -0.00936942f, -0.03203497f, -0.02463380f, 0.02046656f, 
    -0.00370545f, -0.02019062f, 0.01126839f, -0.03529059f, -0.00425586f, 0.00220687f, 0.00039149f, -0.03382893f, 
    -0.01768536f, -0.01118318f, -0.00837406f, -0.00483748f, -0.02928152f, -0.02012980f, 0.02732957f, -0.00747148f, 
    0.02459163f, 0.02203889f, -0.01418200f, 0.01541975f, -0.01451470f, 0.00898942f, 0.01146926f, -0.00266591f, 
    -0.03669218f, 0.00352542f, -0.02169417f, -0.02506490f, -0.00208611f, 0.01485702f, 0.00587945f, -0.02094113f, 
    0.02062904f, 0.01437180f, -0.00382686f, 0.02139366f, 0.00297902f, -0.00486986f, -0.01904102f, -0.02583025f, 
    0.05492757f, -0.01986415f, 0.08958527f, -0.18156567f, -0.05910707f, -0.06728349f, 0.14757285f, -0.03532282f, 
    -0.08088149f, 0.10445248f, -0.09609454f, 0.07202607f, 0.05137051f, 0.25155708f, -0.00348251f, -0.11114954f, 
    0.00416431f, 0.18959367f, -0.04613451f, -0.08248904f, 0.00414631f, -0.03590649f, 0.09430221f, 0.02515946f, 
    -0.11916997f, 0.09507887f, -0.04225259f, -0.00517691f, 0.12391063f, 0.10323031f, 0.06980055f, 0.15474460f, 
    0.07738871f, 0.02771885f, -0.04971683f, 0.03644555f, -0.06085539f, -0.02786449f, 0.06684016f, -0.00032656f, 
    -0.08169916f, 0.02880164f, 0.04618593f, -0.01973589f, 0.16148707f, 0.16466941f, 0.06318723f, 0.24330026f, 
    -0.11874801f, -0.25700700f, 0.04313544f, -0.04163803f, 0.03080690f, -0.13509922f, 0.14146562f, 0.12054630f, 
    -0.03999878f, -0.01466981f, 0.05798253f, -0.09448631f, -0.05630581f, 0.05661864f, -0.02441746f, -0.00084671f, 
    0.03769724f, -0.02783439f, -0.06142273f, 0.06276795f, 0.06785840f, 0.05527047f, -0.07558632f, -0.07163192f, 
    0.11233214f, -0.06485151f, 0.16410339f, -0.02431207f, -0.04038389f, -0.03408172f, -0.09857733f, -0.05000295f, 
    -0.07215497f, 0.03570939f, -0.00483580f, -0.02580222f, -0.06254902f, 0.10342857f, -0.13327962f, -0.07849405f, 
    0.01465755f, 0.05897643f, 0.12895094f, -0.02563098f, -0.00414703f, 0.11309359f, -0.00602046f, -0.02974967f, 
    0.28412119f, -0.04593913f, -0.04956638f, 0.09842812f, 0.00737333f, 0.15361133f, 0.09084086f, 0.04324422f, 
    -0.01382754f, 0.07710223f, -0.09232407f, 0.00619364f, 0.06015944f, -0.10677544f, 0.28131709f, 0.02244528f, 
    -0.01902979f, 0.22859067f, 0.10313156f, -0.03715384f, 0.13077226f, 0.18825030f, 0.14963748f, 0.19627164f, 
    0.08446050f, -0.15677571f, -0.12634563f, 0.09665394f, 0.13144207f, 0.09795114f, -0.00449226f, 0.18916452f, 
    -0.03890521f, 0.00252884f, -0.02800573f, 0.03113684f, 0.10224296f, 0.24983086f, 0.05678614f, 0.09698347f, 
    -0.00050716f, -0.07096893f, -0.03145480f, -0.08392511f, 0.12146694f, 0.06368473f, 0.02955961f, -0.07578763f, 
    -0.28070742f, -0.11803772f, 0.00546358f, -0.06129069f, 0.06818399f, -0.00346884f, 0.04208509f, 0.12184118f, 
    -0.11203568f, 0.00259358f, 0.03726981f, -0.04287887f, -0.05414419f, 0.09418954f, 0.05731355f, -0.00298488f, 
    -0.05266469f, -0.02734426f, -0.05784217f, -0.09418008f, 0.06820988f, -0.02084782f, -0.04721772f, -0.11858141f, 
    -0.12739116f, -0.08671817f, -0.13290988f, 0.02996184f, 0.06784227f, 0.03274850f, 0.10197425f, -0.08574378f, 
    0.03246186f, -0.02664148f, -0.09225417f, 0.07628019f, -0.12515561f, -0.17697255f, 0.04923319f, 0.16852738f, 
    0.08424686f, 0.05464197f, 0.17545260f, 0.08280957f, 0.16961977f, -0.03057719f, 0.02105172f, -0.05445611f, 
    -0.11719276f, 0.05226890f, -0.24417907f, 0.08566762f, 0.07107304f, -0.00190024f, 0.11231863f, 0.11300225f, 
    -0.01614561f, 0.08709618f, 0.01739566f, 0.14421511f, 0.01011391f, -0.01538202f, 0.11574990f, -0.17570215f, 
    0.01608430f, 0.13182195f, -0.08165025f, -0.10515749f, -0.04701184f, 0.06745319f, 0.04094422f, -0.11926864f, 
    -0.03812047f, -0.21746753f, -0.09776420f, 0.08966727f, -0.02405114f, 0.06179120f, -0.04762485f, -0.00798504f, 
    0.16874392f, -0.00910818f, 0.07075230f, 0.10818908f, -0.02341516f, 0.09233502f, 0.17848344f, 0.17391102f, 
    -0.02303812f, -0.00846815f, -0.06689257f, -0.08796661f, 0.02373060f, -0.02936263f, 0.03302532f, 0.12752874f, 
    0.04369176f, 0.18475054f, -0.09938016f, -0.09118827f, 0.08515278f, 0.09405438f, 0.07018370f, -0.03151718f, 
    -0.06812355f, 0.11349789f, 0.10254025f, 0.10545106f, -0.10029452f, 0.23972350f, -0.34413448f, 0.16625690f, 
    -0.07176770f, -0.03598374f, 0.02106913f, -0.08968357f, -0.00918159f, -0.03845845f, 0.06991295f, 0.04485565f, 
    0.01998934f, -0.03949819f, 0.03482991f, -0.03684787f, 0.00492869f, -0.08477359f, -0.05377628f, -0.08898135f, 
    0.10726968f, 0.00823587f, -0.07194868f, -0.00934399f, 0.04878844f, 0.11147571f, 0.00448834f, -0.11353800f, 
    -0.01659890f, -0.02311482f, -0.01391099f, 0.06421155f, -0.00752876f, -0.04991470f, -0.26601917f, -0.25559616f, 
    -0.02089399f, 0.18746611f, -0.07647893f, 0.34132764f, -0.04639410f, -0.07432280f, 0.04282729f, -0.04500511f, 
    -0.05845990f, 0.05810194f, -0.05389971f, 0.16336180f, 0.07558901f, 0.09494157f, -0.09942918f, 0.26119137f, 
    0.00263813f, 0.09319460f, 0.08917405f, 0.16011150f, -0.04925347f, 0.06938478f, 0.12423705f, -0.11078151f, 
    0.06492319f, -0.18541154f, -0.08786194f, 0.02393479f, 0.12631266f, -0.01681965f, -0.02404003f, 0.03061383f, 
    -0.03333290f, -0.03227502f, 0.03980789f, -0.21319459f, -0.03361822f, -0.11699345f, -0.20306969f, -0.19788574f, 
    0.00615316f, 0.02942050f, -0.12983534f, -0.01105225f, 0.03812313f, 0.05437700f, 0.08351861f, -0.19169600f, 
    0.25402871f, 0.03982130f, 0.18956715f, -0.12540753f, -0.13524605f, 0.08928221f, -0.11068112f, 0.01868779f, 
    -0.12919717f, 0.00264154f, 0.11725911f, -0.02714440f, 0.06325337f, -0.02483468f, -0.24184884f, 0.02556453f, 
    0.10290309f, -0.06343956f, -0.01956606f, -0.11742916f, 0.01429681f, -0.01685233f, -0.08602014f, -0.08129866f, 
    -0.05877262f, 0.18969144f, -0.06751318f, 0.06687585f, -0.04488426f, -0.15011403f, -0.01986176f, -0.11803815f, 
    0.02733046f, -0.00110466f, -0.00531762f, 0.12109825f, -0.15609166f, 0.05161845f, -0.22617017f, 0.05964994f, 
    0.06827133f, 0.12942825f, 0.21280926f, 0.07746859f, 0.00156132f, 0.07092085f, -0.01419196f, 0.16804521f, 
    -0.10176126f, 0.32373726f, -0.31821600f, 0.04583756f, -0.02568465f, 0.08885991f, 0.08293748f, 0.24154891f, 
    -0.10678014f, 0.00834555f, 0.05553566f, -0.03898151f, -0.01584630f, 0.13078730f, -0.11467285f, -0.00812165f, 
    -0.06160412f, -0.01535559f, -0.00120866f, 0.10520029f, -0.07893728f, -0.07488032f, -0.11465006f, -0.22205946f, 
    -0.31290558f, 0.18493474f, 0.01646085f, -0.02039041f, 0.04211298f, 0.03569252f, 0.17142443f, 0.03587312f, 
    0.02060673f, -0.09472499f, 0.02119320f, -0.01322159f, 0.21361279f, -0.05380320f, 0.18284218f, 0.01061633f, 
    0.19281198f, 0.00903441f, -0.02848008f, 0.16916889f, -0.03393827f, -0.02347154f, -0.10145917f, -0.05968773f, 
    -0.14707164f, 0.04035982f, -0.28933546f, 0.16440192f, 0.09325549f, -0.00203037f, 0.24402718f, 0.09360423f, 
    -0.00003261f, 0.04575422f, 0.00778360f, 0.01346825f, 0.24631140f, -0.11595976f, 0.03041588f, -0.09621845f, 
    0.08142431f, -0.03809761f, -0.03653319f, -0.04891915f, -0.08034719f, 0.04928622f, -0.06129505f, -0.03539202f, 
    -0.06392155f, -0.00099798f, -0.17366613f, 0.03234886f, -0.00141869f, -0.01600281f, 0.18102208f, 0.02483791f, 
    0.02991730f, 0.05860049f, 0.02528201f, 0.06077898f, -0.00201398f, 0.28974935f, 0.09527157f, -0.03176964f, 
    -0.04092488f, -0.07806329f, 0.13809732f, -0.03028355f, -0.01656870f, 0.04908649f, -0.04923362f, -0.01958994f, 
    0.25146282f, 0.49674371f, -0.23090382f, 0.27903205f, -0.01014935f, -0.18140315f, -0.01337529f, 0.07824483f, 
    0.01411773f, 0.19981028f, -0.05038971f, -0.06428611f, 0.03531202f, -0.02999682f, -0.01923680f, 0.09905960f, 
    -0.01787372f, -0.17481840f, -0.00583168f, -0.11551848f, -0.05597987f, -0.02540716f, -0.04410765f, -0.01527926f, 
    0.04171066f, 0.13064559f, -0.11026206f, 0.05411572f, 0.01918879f, 0.10042676f, -0.06945770f, -0.08555323f, 
    0.10296439f, 0.02412547f, 0.08229656f, 0.16011420f, -0.08379740f, -0.12118907f, -0.02665124f, -0.06919207f, 
    -0.06692520f, 0.06379843f, 0.12182950f, 0.11225943f, 0.07863221f, 0.10155366f, 0.07986356f, 0.02889128f, 
    -0.08060279f, -0.03738394f, 0.09615512f, -0.01557291f, -0.04275791f, 0.04356828f, 0.01123178f, 0.05030479f, 
    -0.06510212f, -0.02695796f, 0.07561910f, 0.10791996f, 0.12710255f, 0.18854949f, 0.11829547f, 0.04676642f, 
    0.02713672f, -0.03737429f, -0.16865836f, -0.07888889f, 0.04299738f, 0.02894539f, 0.03232215f, -0.05936318f, 
    0.05180661f, 0.18597779f, 0.11623595f, 0.03835249f, -0.04423111f, -0.08256692f, 0.00372331f, -0.10903354f, 
    -0.03768700f, -0.07170252f, -0.17780802f, -0.22446491f, -0.00542765f, -0.07177967f, -0.05873962f, 0.09434014f, 
    0.08501896f, 0.02976637f, -0.15310287f, -0.08664221f, -0.02810487f, 0.00116216f, -0.04223264f, -0.02597294f, 
    -0.08524582f, 0.02845833f, 0.06459796f, 0.01250120f, -0.05114194f, -0.02928651f, -0.05988084f, -0.11012024f, 
    0.07210209f, -0.06972957f, -0.00015484f, 0.20334028f, 0.01043452f, 0.01528805f, -0.00524285f, -0.04917458f, 
    0.07317957f, 0.07201394f, -0.04293025f, 0.03529024f, 0.16217050f, 0.01108985f, 0.12082362f, 0.00706822f, 
    0.24468301f, 0.09833051f, 0.19440289f, 0.15259911f, -0.10825535f, -0.03444196f, -0.08842268f, -0.06111802f, 
    0.02474821f, 0.13806950f, 0.17967129f, 0.18181011f, -0.17983231f, 0.08388130f, -0.18477954f, -0.00622627f, 
    -0.03787772f, -0.01925151f, -0.03248484f, -0.20938766f, -0.02419734f, 0.01622455f, -0.04573349f, -0.02007196f, 
    -0.15581420f, -0.01276227f, -0.10339388f, 0.00194064f, -0.02054539f, 0.13737953f, 0.16125841f, 0.13638243f, 
    0.01152385f, -0.00854679f, -0.05195332f, 0.02802207f, -0.00212330f, -0.05397637f, -0.06862891f, -0.05112680f, 
    0.01418012f, 0.00734691f, 0.13756920f, 0.17116451f, 0.06275842f, -0.00924320f, -0.15678415f, -0.13735500f, 
    -0.06249327f, -0.10356873f, -0.00610606f, 0.10441457f, 0.08101235f, 0.12754257f, -0.03107141f, 0.01563124f, 
    -0.11876035f, -0.05486344f, 0.03127965f, 0.05427117f, 0.16172998f, 0.18797198f, 0.15057527f, -0.12716193f, 
    -0.11955187f, -0.00860110f, -0.01868640f, -0.09463564f, -0.02466591f, -0.03333055f, 0.11153423f, 0.03811151f, 
    0.36842868f, 0.15526290f, 0.31013948f, -0.03555055f, -0.09772968f, -0.10111587f, -0.08356755f, -0.15313372f, 
    0.14333636f, -0.04816168f, 0.03001897f, 0.11051370f, -0.07981884f, -0.07436822f, 0.06793061f, -0.03795224f, 
    0.07516501f, 0.11257545f, 0.06668915f, 0.01816470f, -0.08322606f, -0.19525917f, -0.09466853f, -0.05924780f, 
    0.02266372f, 0.02551717f, 0.01902090f, 0.07558976f, 0.01746297f, 0.15833880f, 0.09501742f, 0.13376090f, 
    0.05118808f, -0.13043402f, -0.05203484f, -0.05906278f, -0.07049213f, 0.08660718f, -0.31432772f, -0.10747387f, 
    0.06584184f, 0.10370560f, 0.19395009f, 0.00878153f, 0.01029636f, -0.06832046f, 0.00026290f, 0.08813990f, 
    -0.10183778f, 0.07917947f, -0.10103936f, 0.01188561f, 0.00200716f, -0.07619269f, 0.15338831f, -0.16845602f, 
    0.00879137f, 0.11438089f, 0.05650628f, 0.12232473f, 0.01640368f, 0.05665444f, 0.36677015f, -0.03075361f, 
    0.07311770f, -0.02991617f, 0.00994550f, -0.05856815f, 0.22117928f, -0.06129504f, 0.02141765f, 0.17153436f, 
    0.15577401f, 0.26356193f, -0.01999514f, -0.00778750f, -0.03843268f, 0.04977366f, 0.02607414f, 0.07669403f, 
    -0.07543916f, 0.00502800f, -0.08714895f, -0.17941254f, -0.14188586f, 0.22395800f, -0.16748092f, -0.09874930f, 
    0.01253105f, -0.00559724f, 0.08900940f, 0.02675185f, -0.09374814f, -0.13895617f, -0.05017419f, -0.10771218f, 
    0.01125317f, -0.02608398f, 0.02798563f, -0.02496340f, 0.02851713f, -0.00901304f, 0.01824912f, -0.00934496f, 
    -0.00773261f, -0.02244553f, 0.01961729f, -0.03817623f, 0.02497884f, 0.02381424f, -0.00299708f, -0.02650511f, 
    0.00941714f, 0.01803766f, 0.01125064f, 0.01204134f, -0.02119732f, -0.02462647f, -0.02446575f, 0.00133265f, 
    -0.03113246f, 0.01054642f, 0.02439079f, -0.03591412f, -0.03460795f, -0.01063413f, -0.02560390f, 0.01745755f, 
    -0.02216168f, 0.00846690f, 0.01195474f, -0.02310093f, -0.03086593f, -0.00256708f, 0.01585539f, -0.01894504f, 
    0.00728769f, -0.02859574f, 0.01326949f, -0.02884850f, 0.02823681f, -0.01410615f, 0.01411114f, -0.01405088f, 
    -0.03924378f, -0.02787987f, 0.01616394f, -0.00500524f, -0.02298264f, 0.00303972f, 0.00983771f, 0.00274117f, 
    0.01632053f, -0.01465914f, -0.02222286f, 0.02166350f, 0.00094334f, -0.00691513f, -0.01244374f, 0.01696970f, 
    -0.01742938f, -0.02120946f, 0.02701717f, 0.01437740f, -0.03635940f, 0.00456824f, -0.01375494f, 0.01798298f, 
    -0.03878440f, -0.02633978f, 0.00303336f, -0.00011342f, -0.04041208f, 0.00979884f, 0.02935447f, -0.03960247f, 
    -0.04021124f, 0.02036782f, 0.01077905f, -0.02974007f, 0.02217406f, 0.01279993f, -0.03620685f, -0.02240012f, 
    -0.00653036f, 0.01737872f, -0.03607110f, -0.00285934f, 0.00511456f, -0.01395003f, 0.03422550f, 0.00982420f, 
    0.01527325f, 0.02396051f, -0.00222573f, -0.02023734f, 0.00952013f, 0.01312962f, -0.01661590f, 0.00998889f, 
    0.02153216f, -0.02133663f, 0.00609150f, -0.00850883f, -0.03395136f, -0.04125054f, -0.01424729f, -0.01547507f, 
    -0.01615186f, 0.01506355f, -0.02383067f, -0.00301625f, 0.02590005f, -0.01220757f, -0.01032940f, 0.00311783f, 
    0.01000277f, -0.01008715f, -0.03575637f, 0.01381834f, -0.03529981f, -0.02726727f, -0.00999197f, -0.03565945f, 
    -0.04090463f, -0.01902266f, 0.02160776f, -0.01425200f, 0.00583746f, -0.02665908f, -0.01915052f, 0.02590147f, 
    -0.02488539f, 0.01633628f, 0.01470921f, 0.02727920f, 0.00323869f, -0.03318823f, -0.03555141f, -0.00508538f, 
    -0.01621269f, -0.01437229f, -0.00968256f, -0.00840812f, 0.00311912f, -0.02058332f, 0.00826638f, 0.03011012f, 
    -0.00664728f, -0.02828396f, 0.01425467f, -0.01252688f, -0.01945908f, 0.02381641f, -0.01470386f, 0.00847551f, 
    -0.02716359f, -0.00347320f, -0.01328149f, -0.00062342f, -0.02251426f, 0.01379959f, -0.00771892f, 0.00105727f, 
    -0.01207659f, -0.03924601f, -0.00421032f, 0.00840753f, -0.02129883f, -0.00176328f, -0.00945681f, -0.02105896f, 
    0.00676146f, -0.00378709f, -0.02704011f, -0.01706165f, -0.00704254f, 0.00668356f, -0.03465678f, -0.03511992f, 
    -0.01401639f, 0.00955491f, -0.01390953f, -0.02032582f, 0.02402903f, -0.02685546f, -0.03324963f, 0.00071599f, 
    0.01593724f, 0.01536375f, -0.04457209f, -0.02205688f, -0.01013156f, 0.02116020f, -0.00056245f, 0.03024116f, 
    0.01066986f, 0.00501443f, 0.02666341f, -0.02734437f, -0.03330864f, -0.00803070f, -0.01945200f, -0.00947187f, 
    -0.00086635f, -0.02327000f, -0.01449581f, 0.01956389f, -0.03570634f, -0.03040783f, -0.00689019f, -0.01545949f, 
    -0.00773263f, -0.01162636f, 0.02048026f, -0.00506605f, -0.00802402f, -0.03240565f, -0.03789774f, -0.00699694f, 
    0.03249725f, -0.01839282f, 0.02054814f, 0.02868662f, -0.00084053f, -0.02918188f, -0.00528097f, -0.02493650f, 
    -0.00401293f, -0.00560196f, 0.02725558f, -0.03373821f, -0.03701083f, 0.00047024f, -0.01667520f, -0.03797226f, 
    -0.00086225f, -0.00238745f, -0.01442664f, 0.00277621f, -0.00532519f, 0.02841675f, -0.04086696f, -0.02854329f, 
    0.02379468f, -0.03549717f, 0.01826126f, 0.01526181f, -0.00005774f, -0.03395617f, 0.00476370f, 0.01078890f, 
    -0.03568427f, 0.02590056f, -0.02371844f, 0.00337657f, -0.01346668f, 0.02543395f, -0.03031821f, 0.02843852f, 
    -0.01811602f, -0.03401839f, 0.00342131f, -0.03859698f, -0.04218789f, -0.00123339f, 0.01987921f, -0.00410877f, 
    -0.01330205f, 0.00007557f, -0.00175266f, 0.02953473f, -0.02911305f, -0.01224008f, -0.00689975f, 0.02221172f, 
    0.00989495f, 0.01295602f, -0.02414487f, -0.04226642f, -0.04080748f, -0.03109402f, -0.00806432f, -0.00859864f, 
    -0.04077578f, -0.03813678f, 0.00726093f, -0.00472081f, -0.01895223f, -0.02725131f, -0.00288621f, 0.02939103f, 
    0.01801516f, -0.02385926f, 0.00187324f, -0.03289195f, 0.01952435f, 0.03420736f, 0.00490636f, -0.02532453f, 
    -0.02930517f, 0.03384506f, 0.00473933f, -0.03988263f, -0.02179973f, 0.01101415f, -0.03458676f, -0.03980668f, 
    -0.02757968f, -0.01998681f, 0.00200208f, -0.03304965f, 0.01128680f, -0.02024087f, -0.00094280f, -0.02409215f, 
    -0.02872396f, -0.02744745f, -0.01399992f, -0.00757908f, -0.00346759f, -0.00136637f, 0.02451890f, 0.01328986f, 
    0.00285370f, 0.02573570f, -0.03111346f, -0.01743224f, -0.03292004f, 0.00820051f, -0.01132610f, -0.03645594f, 
    -0.00601272f, -0.01393117f, -0.02751081f, 0.00875067f, -0.01630799f, 0.01296663f, -0.00401495f, 0.01441433f, 
    -0.03576012f, -0.02496508f, 0.02104005f, 0.00651476f, -0.01617157f, -0.02304167f, -0.01847873f, -0.03245491f, 
    -0.03132454f, -0.01561467f, 0.01040648f, 0.01682920f, 0.03075630f, -0.02804744f, -0.02788411f, 0.00708154f, 
    0.00216940f, -0.00716065f, -0.01590990f, 0.01857471f, -0.02574656f, -0.04346590f, 0.01397232f, -0.03680151f, 
    0.02023988f, 0.01060475f, -0.01703067f, -0.01213963f, 0.01819796f, 0.01255219f, -0.01163175f, -0.01221323f, 
    -0.02916153f, -0.01830755f, -0.00995690f, -0.00659064f, 0.02147347f, 0.01099869f, 0.02871588f, 0.00019892f, 
    -0.01769747f, 0.00652897f, 0.02835914f, 0.01036558f, 0.00522981f, 0.01883862f, -0.02939569f, -0.03789838f, 
    -0.00676450f, -0.01700540f, -0.02292172f, -0.03956129f, -0.03390321f, -0.01019834f, -0.01966398f, -0.00266468f, 
    0.00363489f, -0.00662300f, -0.04180991f, 0.00192019f, -0.01728093f, -0.04072368f, -0.01754005f, 0.02291516f, 
    -0.01934833f, 0.01472454f, -0.00653728f, 0.00335780f, 0.02391375f, 0.02734315f, -0.03189583f, 0.01524241f, 
    -0.02507713f, 0.01248508f, -0.02634673f, -0.02890824f, -0.03937021f, 0.02618351f, -0.02687856f, 0.02410112f, 
    -0.02588071f, -0.00022316f, 0.02845057f, -0.02925636f, -0.00115445f, -0.02935681f, -0.00677050f, -0.00746123f, 
    0.00489850f, 0.02371945f, 0.00551418f, 0.01134736f, 0.02246673f, -0.01605129f, -0.02581961f, -0.01795281f, 
    -0.02057686f, 0.03460291f, -0.01718066f, -0.00590307f, -0.00283224f, -0.04040566f, -0.03555835f, 0.00216759f, 
    0.00613716f, -0.02787001f, -0.03935089f, 0.02857798f, 0.01577616f, -0.01425543f, -0.03701135f, 0.02093236f, 
    -0.01769937f, -0.01925302f, 0.02591368f, -0.01158640f, -0.00951518f, 0.00553916f, -0.00133468f, -0.01406965f, 
    -0.01962924f, 0.02430895f, 0.00980873f, -0.01889841f, -0.01919669f, 0.02280038f, 0.00637827f, -0.01732574f, 
    -0.01316777f, 0.00241666f, 0.00625396f, -0.04378266f, -0.02634906f, -0.00012852f, 0.02929914f, -0.02694873f, 
    -0.01635165f, 0.00891656f, -0.00875149f, -0.01183496f, -0.00787782f, 0.03022579f, 0.02624547f, -0.00981082f, 
    -0.03199989f, -0.00272688f, 0.02632601f, -0.04353060f, -0.00228917f, 0.01841152f, 0.02121143f, 0.01271741f, 
    0.02241681f, -0.03421573f, 0.00345424f, 0.00211449f, 0.01940087f, -0.03478259f, -0.03481425f, -0.00856109f, 
    -0.02496234f, 0.03028784f, 0.02089746f, -0.01079284f, 0.01860779f, -0.00943555f, -0.04037276f, 0.01790854f, 
    -0.01371824f, 0.01221586f, -0.00050965f, 0.00912269f, -0.02180538f, -0.01715268f, -0.02070706f, 0.00387492f, 
    -0.02525174f, 0.01783797f, -0.01324598f, -0.01963708f, -0.03546373f, -0.01969024f, 0.02933995f, 0.00499139f, 
    0.00109499f, -0.03748193f, -0.01073849f, 0.01741735f, -0.03247210f, -0.02362971f, 0.02252027f, -0.01039516f, 
    0.02149802f, -0.00721340f, 0.02138601f, -0.00099710f, -0.01501284f, 0.02110256f, -0.01593033f, -0.04053329f, 
    -0.01764931f, -0.01772255f, -0.03208286f, -0.03782278f, 0.02649024f, 0.02195310f, -0.01211092f, 0.02674677f, 
    0.00446918f, 0.01406679f, -0.03858665f, 0.03072417f, -0.02760546f, -0.01867486f, -0.01738035f, 0.02871077f, 
    0.02132098f, 0.02073118f, -0.01340377f, -0.00484164f, -0.00300690f, -0.03629112f, 0.02636810f, -0.02998178f, 
    -0.02340904f, 0.00839166f, 0.00417556f, 0.01686596f, -0.03639326f, -0.02070613f, 0.00034096f, 0.02542408f, 
    -0.01659017f, -0.00926546f, 0.01331799f, -0.02055864f, 0.01424516f, 0.02298560f, -0.02404566f, -0.00119809f, 
    -0.02853347f, 0.03327073f, 0.00428149f, -0.01664460f, 0.00126189f, 0.00669796f, 0.00410713f, -0.02894977f, 
    0.02453915f, -0.00637848f, 0.01732689f, 0.01777210f, 0.01393052f, -0.02839812f, 0.02456810f, 0.01306740f, 
    -0.00814264f, 0.00038854f, 0.01302967f, -0.00346121f, -0.01555083f, -0.01300435f, 0.00004147f, 0.01031941f, 
    -0.02529711f, -0.00745491f, 0.01461564f, 0.00919855f, -0.04267489f, -0.01646167f, 0.01567760f, -0.00752819f, 
    0.01646130f, -0.01530603f, 0.00464091f, -0.02120531f, 0.00185648f, -0.00378021f, 0.02422268f, -0.00052144f, 
    0.02432066f, -0.03099983f, 0.02138862f, -0.03902841f, -0.02349250f, 0.01952036f, -0.03031742f, 0.01835413f, 
    -0.01622190f, 0.02129674f, 0.02273876f, 0.02921083f, -0.00870904f, -0.03707286f, 0.00180198f, 0.02595381f, 
    -0.01042435f, -0.00981176f, -0.03025334f, 0.01416428f, -0.02474211f, -0.01405292f, 0.01615446f, 0.01996166f, 
    -0.03728700f, -0.00633516f, 0.01712014f, 0.00722665f, -0.01195909f, 0.01624946f, -0.00765157f, 0.01330696f, 
    -0.00206734f, -0.01446317f, -0.00419943f, -0.00704462f, -0.01071210f, -0.02186398f, 0.00737815f, -0.01356537f, 
    -0.00412817f, 0.01507276f, 0.00287603f, -0.03645618f, -0.03712009f, 0.02088587f, -0.03016624f, -0.01116451f, 
    0.00754169f, 0.03199268f, 0.01550682f, -0.02389153f, 0.02334563f, -0.03871860f, -0.01654340f, -0.01947574f, 
    -0.03270200f, 0.03111097f, -0.01786095f, -0.01253384f, 0.03066453f, -0.02785391f, -0.02120927f, -0.01139362f, 
    -0.01462057f, -0.03194351f, 0.02340616f, -0.03882801f, 0.01954529f, -0.02653841f, 0.00750158f, -0.03012970f, 
    -0.00362088f, -0.01881704f, -0.03186430f, 0.00780495f, -0.02951238f, -0.00441064f, 0.01851600f, -0.03323356f, 
    -0.01709986f, 0.02138604f, -0.00589802f, -0.01372274f, 0.01205556f, 0.02334698f, -0.01620697f, 0.02209113f, 
    -0.03239290f, 0.02665104f, 0.00915440f, 0.01073947f, 0.02532257f, 0.02588165f, 0.01294408f, 0.00451048f, 
    -0.04148662f, 0.00086125f, 0.02545342f, 0.00850702f, -0.04271477f, 0.02820093f, 0.02097907f, 0.01155823f, 
    -0.00437097f, -0.02481475f, 0.02704858f, 0.00394401f, -0.04224007f, -0.00312236f, 0.01381268f, -0.02009271f, 
    -0.01205344f, 0.01336512f, 0.00290320f, 0.01521705f, -0.02190609f, -0.02121837f, -0.02051902f, 0.00267053f, 
    -0.00430631f, 0.02454563f, 0.00475241f, 0.02599494f, 0.00374276f, 0.02440991f, 0.02671020f, -0.03185849f, 
    -0.01952284f, -0.00208124f, -0.01696944f, -0.03808270f, 0.02265377f, 0.02662869f, 0.02108737f, -0.03173805f, 
    0.01325298f, -0.01246287f, -0.01225366f, -0.02842296f, -0.00192257f, -0.02544886f, -0.02037156f, -0.03290152f, 
    0.02959913f, 0.00566224f, -0.02114226f, 0.01678694f, -0.02470896f, -0.02588846f, 0.01974363f, -0.00838038f, 
    -0.03372366f, -0.01200115f, -0.00848197f, 0.02336282f, 0.01168428f, 0.01009781f, -0.03559489f, -0.02932640f, 
    -0.03180172f, 0.00450967f, -0.02932019f, -0.01210489f, -0.01356439f, -0.04088310f, -0.04052166f, -0.00546922f, 
    -0.01630202f, -0.01153418f, 0.00177203f, 0.02611678f, -0.01796246f, -0.00436400f, 0.02253085f, -0.03347700f, 
    -0.00554796f, 0.01236796f, 0.02280687f, 0.00106375f, 0.02823142f, -0.01224065f, -0.01814881f, -0.01588163f, 
    -0.01068331f, -0.00384275f, -0.01806783f, -0.02205228f, -0.02992894f, 0.02640593f, 0.01655761f, 0.01119315f, 
    -0.01050517f, -0.02902263f, -0.01242611f, 0.01215220f, -0.02542834f, -0.00287870f, -0.00634128f, -0.02617688f, 
    -0.01584929f, 0.02746279f, -0.00840042f, 0.01273515f, -0.04098842f, -0.00765160f, 0.01856004f, 0.02351903f, 
    0.01963521f, 0.00703059f, 0.01492979f, -0.01682744f, -0.00385841f, 0.00967180f, -0.03262572f, -0.02151218f, 
    -0.03939893f, 0.02409783f, -0.03597422f, 0.01246565f, 0.02100097f, -0.00955006f, 0.03032900f, -0.00123619f, 
    0.01791520f, -0.02274614f, 0.03276480f, 0.02386451f, -0.01533860f, -0.02860504f, -0.02821325f, 0.00249361f, 
    0.03464950f, -0.02980147f, -0.00257814f, 0.03236370f, -0.03988395f, 0.02098244f, -0.01036877f, -0.02041831f, 
    0.00151302f, 0.01582596f, 0.03572320f, 0.03154435f, -0.03696660f, -0.03618697f, -0.00013582f, -0.01695031f, 
    -0.00685853f, -0.02605803f, -0.03255139f, 0.00339726f, -0.00743154f, -0.00054482f, -0.02698934f, -0.03600828f, 
    -0.01200843f, -0.00146640f, -0.01016711f, -0.01098266f, -0.00340736f, 0.00280230f, 0.02989115f, -0.03549950f, 
    -0.02817751f, 0.02420296f, -0.02148139f, -0.01369963f, 0.00272101f, 0.01630322f, 0.01121098f, -0.01930763f, 
    -0.01351746f, -0.02912125f, -0.03068086f, -0.03129932f, 0.00196360f, 0.00504115f, 0.02787470f, 0.00054889f, 
    -0.04007343f, -0.03524849f, -0.00339904f, 0.02645307f, -0.02256742f, -0.04015037f, -0.01184539f, 0.00086149f, 
    -0.01690434f, 0.00191251f, -0.00483935f, 0.01715404f, 0.02127841f, 0.00057615f, -0.01103653f, -0.02498644f, 
    0.00854944f, 0.00741722f, 0.01622079f, 0.01072697f, 0.02329461f, -0.03475762f, 0.00359473f, -0.03032187f, 
    -0.00769082f, -0.04055328f, -0.02979081f, -0.03730039f, 0.01906261f, -0.01223575f, 0.02083119f, 0.00637571f, 
    0.01703502f, 0.01942317f, 0.00002227f, 0.01778611f, -0.03335455f, -0.00301303f, -0.01268560f, -0.01457286f, 
    0.00989065f, 0.01721243f, -0.03861826f, -0.03709051f, -0.01322146f, -0.00204411f, -0.02965134f, 0.02115898f, 
    -0.02809685f, 0.02938378f, 0.01562867f, 0.01546083f, -0.02512360f, -0.02753516f, 0.01791363f, -0.00080096f, 
    -0.00510145f, 0.00756833f, -0.00620368f, 0.01203203f, 0.03477071f, -0.03168627f, 0.00585420f, -0.03868159f, 
    -0.00481428f, 0.01193656f, 0.02709316f, -0.04074591f, 0.00485172f, 0.00552311f, 0.02809868f, 0.02638946f, 
    0.02118403f, -0.00995973f, 0.01896321f, -0.00707802f, 0.02398246f, -0.02759082f, 0.00045921f, 0.00870513f, 
    0.00525587f, -0.01458372f, 0.00406213f, -0.03354693f, -0.03321570f, 0.02818546f, -0.03773891f, -0.03646686f, 
    -0.01019170f, -0.01302205f, 0.00335354f, -0.02506016f, 0.01759714f, 0.00061297f, 0.01353968f, 0.02752640f, 
    0.00944292f, 0.01465587f, -0.01022906f, -0.00808454f, 0.01715670f, -0.00552425f, 0.00297009f, -0.01683728f, 
    -0.02075024f, -0.02009023f, -0.00536713f, 0.00028702f, 0.02673034f, 0.01595364f, 0.00112836f, -0.02231860f, 
    0.01747365f, -0.01366916f, -0.01968897f, 0.00856578f, 0.01415627f, 0.02155657f, -0.03890789f, 0.02776494f, 
    0.01199674f, 0.02726320f, -0.00642610f, -0.02056192f, 0.01677067f, -0.00430720f, -0.03090406f, 0.02562421f, 
    -0.00101395f, 0.00940553f, 0.01835702f, 0.01679815f, -0.03918893f, -0.03375511f, -0.00389981f, 0.01247945f, 
    0.01330368f, 0.02502537f, -0.00385961f, -0.00106169f, 0.00030260f, -0.00939487f, -0.02636470f, 0.01017870f, 
    -0.00856815f, 0.01800189f, -0.00805924f, -0.03017166f, -0.01116746f, -0.00589661f, -0.00189365f, -0.02014809f, 
    -0.02891439f, -0.00683353f, -0.03239958f, -0.02189723f, -0.02186947f, -0.01065704f, -0.01231605f, -0.01773833f, 
    0.00913685f, 0.02477145f, -0.02676607f, 0.01342911f, 0.01021472f, -0.00397514f, 0.00281283f, 0.03579082f, 
    -0.01509362f, -0.02265176f, -0.00924384f, -0.02261554f, 0.00485215f, 0.02877481f, 0.01871263f, -0.03039898f, 
    -0.01694795f, -0.01753178f, 0.02649478f, -0.03456870f, 0.02667931f, 0.02947908f, 0.02126951f, -0.03526407f, 
    -0.03939980f, 0.02221506f, 0.00424396f, -0.01554308f, -0.00818968f, 0.02929160f, -0.00374243f, -0.03332152f, 
    -0.02911651f, -0.02304338f, -0.01270723f, 0.01883975f, 0.02179673f, -0.03716447f, -0.03490576f, 0.01548172f, 
    0.01018716f, -0.01089475f, -0.01663667f, -0.03130466f, 0.00077384f, 0.02520377f, 0.01194479f, -0.02441132f, 
    0.00687043f, 0.00838125f, -0.02794136f, -0.00130628f, -0.01264967f, -0.02639032f, -0.00015961f, 0.02411903f, 
    0.01344392f, 0.02721211f, -0.03617734f, -0.02598541f, 0.00124890f, 0.00511287f, 0.03015137f, 0.03035644f, 
    -0.02860173f, -0.03002555f, 0.01305733f, -0.03872620f, -0.02824657f, 0.00221790f, -0.01986779f, -0.01292361f, 
    0.00642238f, 0.01698228f, -0.00211726f, -0.01506118f, 0.01464677f, 0.00114452f, -0.03940951f, -0.02459275f, 
    -0.01492833f, 0.00094347f, -0.03476959f, -0.03390607f, 0.00948445f, -0.01781203f, -0.02032730f, -0.01274995f, 
    0.02807206f, 0.00485608f, 0.02557987f, 0.03015031f, -0.00770844f, 0.01180574f, 0.03603396f, -0.01369833f, 
    -0.03690258f, -0.00867643f, -0.02657868f, -0.00354876f, -0.00487758f, -0.02799151f, -0.00340044f, 0.00585567f, 
    -0.01559118f, 0.02320755f, 0.00558786f, -0.02726050f, 0.02733493f, -0.02032697f, 0.00411132f, 0.00597579f, 
    -0.00124220f, -0.03967936f, 0.02925826f, -0.02720554f, -0.03500804f, 0.02531521f, 0.01583705f, 0.02953345f, 
    -0.02408451f, -0.03588293f, -0.02435034f, -0.01478688f, 0.02390006f, 0.01034976f, -0.01729381f, -0.03850175f, 
    -0.03235597f, -0.03292967f, -0.03745553f, -0.01252655f, 0.01168883f, 0.02367255f, -0.00025677f, -0.03662372f, 
    0.00258614f, -0.02462528f, -0.01687853f, -0.00957867f, -0.02521312f, 0.02925771f, -0.01973025f, -0.03003300f, 
    -0.04070118f, 0.01247900f, -0.03613658f, 0.02430798f, 0.02030142f, -0.00665966f, -0.01109677f, -0.00944516f, 
    0.02810596f, -0.02403040f, -0.03471408f, -0.02767798f, 0.03061623f, -0.01864455f, -0.03805561f, 0.02044198f, 
    -0.01985625f, -0.02638763f, -0.00952789f, 0.00661067f, -0.04019481f, 0.02152307f, -0.03395668f, -0.04039275f, 
    -0.03006783f, -0.01174172f, 0.02143976f, -0.02478562f, 0.02440730f, -0.03401713f, 0.00603299f, -0.00120483f, 
    0.01156404f, 0.02268979f, 0.02907456f, -0.01101054f, -0.03729492f, -0.00751597f, -0.02110693f, -0.03489234f, 
    0.00735772f, -0.03360088f, 0.02460053f, -0.01734215f, 0.00072146f, -0.03459039f, 0.01930993f, -0.03211093f, 
    -0.01585220f, 0.01256297f, 0.01649014f, 0.00604237f, 0.00318848f, -0.03797786f, 0.01407776f, -0.02577466f, 
    -0.00759958f, -0.01135999f, -0.02058056f, 0.03472093f, 0.03003522f, -0.00184473f, -0.03017211f, -0.03248947f, 
    0.01080827f, -0.02596045f, -0.01869270f, -0.03473233f, -0.02346197f, 0.00763036f, 0.00375976f, -0.02066417f, 
    0.01683279f, -0.01910526f, -0.00899942f, 0.01761582f, 0.00890790f, 0.00624511f, -0.01329012f, -0.00931140f, 
    0.01971239f, -0.01146745f, -0.03994848f, -0.00985413f, -0.02198920f, -0.03678869f, -0.03260401f, -0.02634058f, 
    -0.00834852f, 0.00413522f, -0.04026116f, -0.00587837f, 0.00255478f, 0.00162535f, -0.04062753f, 0.01119744f, 
    0.02211951f, 0.03046031f, -0.03448575f, -0.00132495f, 0.00749444f, -0.01192458f, -0.03074656f, -0.00855957f, 
    0.00530724f, 0.02914648f, -0.01204399f, 0.01863113f, 0.02622319f, -0.02377451f, -0.01241022f, -0.03358099f, 
    0.00714909f, -0.00044347f, -0.03106529f, -0.00215274f, 0.02126446f, -0.00386778f, -0.03954076f, 0.02900770f, 
    0.00707983f, -0.03202758f, 0.02953191f, -0.01721834f, -0.03601880f, -0.03543727f, 0.00007618f, -0.00789405f, 
    0.01849663f, 0.00062721f, -0.01763331f, -0.01338366f, 0.01499693f, 0.02775155f, -0.02227115f, 0.01710433f, 
    -0.02873430f, 0.01457763f, -0.00493443f, 0.01652157f, -0.01505191f, -0.00825799f, 0.00238084f, 0.00336078f, 
    -0.00284165f, -0.00406991f, 0.01521582f, 0.02866768f, -0.02070354f, 0.02111464f, -0.01965341f, 0.00220703f, 
    -0.01275793f, -0.00864030f, -0.00039710f, 0.03154327f, 0.01481809f, -0.00948417f, 0.00772638f, -0.00120601f, 
    -0.00268645f, 0.01585795f, -0.00345403f, 0.00646570f, -0.02121414f, -0.03550322f, 0.01181068f, 0.00122710f, 
    0.00294814f, 0.02500355f, -0.01257779f, -0.02992740f, -0.01788173f, -0.00938876f, 0.01281506f, -0.00069876f, 
    -0.00943895f, -0.03235814f, -0.03880525f, -0.00939579f, -0.02659613f, -0.03226443f, 0.00721751f, -0.02751403f, 
    -0.02702478f, 0.02218496f, -0.03486631f, 0.01249747f, -0.01935672f, -0.01965564f, -0.03404896f, -0.02874787f, 
    -0.03156007f, -0.02716212f, -0.01286960f, -0.02429942f, 0.02272869f, -0.01000507f, 0.01470804f, -0.01165539f, 
    0.01248920f, -0.02172668f, -0.02713574f, -0.01579599f, 0.00764912f, 0.02138205f, -0.01661939f, -0.03712104f, 
    -0.03058373f, -0.01952804f, -0.00308318f, 0.03038136f, 0.03386996f, 0.00257784f, -0.02345395f, -0.03091850f, 
    -0.02498469f, -0.01800230f, 0.02064632f, -0.03467710f, 0.01579861f, 0.01211548f, -0.03106650f, -0.02938258f, 
    -0.02966114f, -0.00446863f, -0.01174217f, -0.02629887f, -0.01735141f, -0.03561236f, -0.03151403f, 0.02594154f, 
    -0.03128356f, 0.00235971f, -0.03209890f, -0.00753640f, -0.02531784f, -0.03639840f, 0.01467559f, -0.01463969f, 
    -0.00915965f, -0.02178946f, -0.01844817f, -0.00631694f, -0.00883682f, 0.00590288f, -0.03568856f, 0.00342293f, 
    0.01537308f, 0.02443299f, 0.01090363f, 0.00871703f, -0.02106822f, -0.02957039f, 0.03051323f, -0.01369973f, 
    -0.02332736f, -0.00206343f, 0.00979774f, -0.02080056f, -0.01819356f, -0.01547524f, 0.01050339f, 0.01738508f, 
    -0.01344647f, -0.02092028f, 0.02529350f, 0.01182003f, -0.01056110f, -0.03279153f, 0.01136781f, -0.02422100f, 
    -0.00864648f, 0.01466794f, -0.00982560f, 0.03161873f, -0.01959377f, -0.02586241f, 0.01783261f, 0.02443074f, 
    -0.02015071f, 0.02750587f, -0.00671895f, -0.03909805f, -0.02418609f, -0.03019793f, -0.01730112f, -0.03141302f, 
    -0.01709293f, 0.01635380f, -0.02484882f, -0.00333131f, -0.01715331f, 0.02030908f, -0.03503091f, 0.02399147f, 
    0.01093454f, -0.01377490f, -0.01621856f, 0.00389847f, 0.00614022f, 0.02109356f, -0.03709520f, -0.02817939f, 
    -0.00473787f, -0.00674478f, 0.01706354f, -0.00427460f, 0.02547093f, -0.00088488f, -0.02678757f, -0.01225949f, 
    0.02890978f, -0.01675417f, 0.00970896f, -0.03250699f, -0.00349793f, 0.02325821f, -0.02089900f, -0.02583267f, 
    -0.03328800f, -0.01138225f, 0.02658627f, -0.03872933f, -0.01333034f, -0.00863700f, -0.03795343f, 0.01338388f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00072647f, 0.02036182f, 0.04153222f, -0.02749664f, 0.14216122f, -0.05539637f, -0.07360072f, 0.10507344f, 
    -0.01455313f, -0.03629253f, -0.13247123f, -0.01749301f, 0.18059258f, -0.01078312f, 0.04119908f, 0.15334256f, 
    0.02172201f, 0.01889013f, -0.03033707f, 0.07850101f, 0.01163233f, 0.03910195f, 0.06646894f, 0.10766959f, 
    -0.03762633f, 0.06677041f, -0.01668399f, 0.01726133f, -0.01895419f, 0.14346175f, -0.00314996f, 0.02474036f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01792471f, -0.32339349f, 0.09414045f, -0.16777410f, 0.18532397f, -0.24782111f, -0.09689937f, 0.25172636f, 
    -0.16986844f, 0.13598612f, -0.36958665f, 0.14608745f, 0.13792624f, 0.11438588f, -0.06726011f, 0.23431349f, 
    0.19841491f, -0.07240739f, -0.00328991f, 0.35146180f, -0.00970937f, 0.15485232f, -0.14627169f, 0.01143000f, 
    0.11498988f, 0.30425176f, -0.04337333f, -0.07009643f, 0.17140028f, -0.05242724f, -0.15256277f, -0.01714549f, 
    0.00272863f, -0.08199787f, -0.10123987f, 0.14053209f, -0.15568864f, -0.10175367f, -0.05748361f, -0.02160458f, 
    -0.02430072f, -0.03595827f, 0.05761686f, 0.05141460f, -0.06655475f, -0.05358164f, 0.15857735f, -0.13959426f, 
    -0.12470386f, 0.17792232f, -0.14997534f, -0.04567733f, 0.02930350f, 0.06245865f, -0.07720439f, 0.04665108f, 
    0.16080441f, -0.07204913f, -0.16251358f, -0.09056174f, -0.10555790f, 0.12843668f, 0.15551460f, 0.00229039f, 
    0.14038846f, 0.04545569f, -0.12337229f, -0.05741105f, -0.01147854f, 0.13069028f, 0.24780300f, 0.06849054f, 
    -0.14093854f, -0.02393365f, -0.07722434f, 0.03627727f, 0.23910575f, 0.26305839f, -0.17185947f, -0.11315112f, 
    0.20173535f, -0.16396523f, 0.10628728f, 0.23154226f, -0.04445388f, 0.25654608f, -0.22998172f, 0.11964874f, 
    -0.02652856f, -0.17483839f, -0.16432285f, 0.28827694f, 0.13209097f, 0.18688001f, 0.05263284f, 0.16176838f, 
    0.36098242f, -0.03875786f, 0.12039025f, -0.09919122f, 0.07040279f, 0.27853170f, -0.28616595f, -0.07669204f, 
    0.32756776f, -0.09925909f, 0.07691612f, -0.01330851f, 0.15116428f, 0.23507857f, 0.35940570f, 0.06564593f, 
    0.19240490f, -0.08890051f, -0.16453224f, -0.36120382f, -0.02708095f, -0.36337754f, -0.15506233f, -0.27703774f, 
    0.05412904f, -0.26883021f, 0.06351651f, 0.06296380f, 0.17201099f, 0.06508400f, 0.04736375f, -0.16040242f, 
    0.30447119f, 0.02686753f, 0.22610161f, 0.05552551f, -0.15474483f, 0.07294318f, -0.09360505f, -0.14059125f, 
    -0.27901560f, 0.05481929f, 0.30675694f, -0.11342553f, -0.07794146f, -0.02866728f, 0.33044595f, 0.24923725f, 
    -0.08660351f, -0.01523887f, 0.00361525f, -0.45063922f, 0.07234401f, 0.05147412f, -0.08362275f, 0.10612909f, 
    0.05484362f, 0.23989987f, 0.10866822f, -0.09952201f, -0.04436054f, -0.27891588f, -0.11252806f, -0.02348389f, 
    -0.01597911f, -0.12298496f, 0.07661006f, 0.09670869f, -0.20736547f, 0.00991930f, -0.20501828f, 0.10003153f, 
    0.22323468f, 0.16760592f, 0.18272313f, -0.07674387f, 0.22738194f, -0.00778516f, 0.10650030f, 0.26426965f, 
    -0.07945433f, 0.12510431f, -0.01483158f, -0.48564446f, -0.04959292f, -0.02366030f, -0.14609087f, 0.24476084f, 
    -0.07740559f, 0.23261224f, 0.15662967f, 0.00805055f, -0.15625663f, -0.14274119f, 0.14095268f, -0.03878651f, 
    0.30873397f, 0.06728307f, 0.13041675f, -0.06307129f, -0.25060070f, 0.21282977f, 0.20374848f, -0.24034923f, 
    -0.27149445f, -0.00820713f, 0.19327495f, -0.03323479f, -0.07503415f, 0.23417801f, 0.07911904f, 0.23655280f, 
    0.18998665f, 0.06066235f, 0.05860335f, 0.03719228f, 0.01927214f, -0.05721929f, 0.12015719f, -0.04301870f, 
    -0.16586594f, 0.19665487f, 0.06179508f, 0.40236399f, 0.13827375f, -0.06346108f, 0.01202562f, -0.17342004f, 
    0.10975575f, -0.19422528f, -0.06178714f, -0.11959365f, -0.05305531f, -0.06567501f, -0.15580134f, 0.03303653f, 
    0.06060117f, 0.06278259f, 0.03638611f, -0.03741001f, -0.00357637f, -0.18959381f, 0.02671590f, -0.22302209f, 
    0.00649327f, -0.02907887f, -0.00004162f, -0.15814875f, -0.11533254f, -0.14967214f, -0.12659936f, 0.04377836f, 
    0.13305026f, 0.03217648f, 0.09418199f, 0.14295220f, 0.06386081f, -0.05739671f, 0.06428365f, 0.05603274f, 
    -0.12137655f, 0.18032971f, 0.12871170f, 0.00264488f, -0.03953338f, -0.21964473f, 0.27848986f, -0.10174756f, 
    0.12425159f, -0.15241645f, 0.26119122f, -0.11562539f, -0.12656508f, -0.01713636f, 0.09654126f, 0.00620853f, 
    -0.06080034f, -0.08377929f, -0.02015684f, -0.00446817f, -0.00816057f, -0.02672329f, -0.26177582f, -0.09661317f, 
    -0.12678096f, -0.10063521f, -0.08352738f, -0.05647930f, -0.07770026f, -0.01838042f, -0.00560220f, 0.04443078f, 
    0.14710572f, 0.20514408f, -0.00374349f, -0.15052852f, 0.14024672f, -0.13453045f, 0.39184678f, 0.02998732f, 
    -0.15024182f, 0.03307516f, 0.07515021f, 0.06384644f, -0.02641373f, -0.12425004f, -0.34114438f, -0.14702430f, 
    0.00099895f, -0.00221140f, 0.01708287f, 0.53632635f, 0.07045683f, 0.19921415f, 0.06254409f, -0.09106779f, 
    0.02596837f, 0.15846017f, 0.16835158f, 0.05503760f, 0.04124772f, 0.11483270f, 0.05527692f, -0.02465449f, 
    0.29318708f, 0.04159334f, 0.12735443f, -0.11998467f, -0.05816759f, -0.36348289f, 0.16593115f, -0.10256916f, 
    0.29723889f, -0.11184163f, 0.06357323f, -0.06865507f, -0.19833006f, -0.04536337f, -0.14854683f, 0.17814946f, 
    -0.04090908f, 0.10666111f, -0.06998621f, 0.12185205f, 0.01587052f, 0.04171570f, 0.17386869f, -0.07712584f, 
    0.05857729f, 0.24656110f, 0.11396850f, 0.10792622f, -0.01975294f, -0.11646056f, 0.04333970f, 0.05127444f, 
    0.04652951f, -0.10243617f, 0.06774298f, 0.06765626f, -0.11449572f, 0.17586114f, 0.10548356f, -0.03795815f, 
    -0.08070131f, 0.15212007f, -0.20634134f, 0.00664550f, 0.08796995f, 0.31714830f, -0.23020454f, -0.04100573f, 
    -0.17071141f, 0.05487018f, -0.14634429f, -0.06607421f, -0.08067769f, 0.31544995f, 0.05888949f, 0.05812870f, 
    -0.10943297f, 0.02556597f, -0.07215306f, 0.24458055f, 0.03346296f, -0.03618602f, -0.05879411f, 0.01990431f, 
    -0.03107862f, -0.16542776f, -0.07880815f, 0.03476251f, -0.10183307f, -0.05980429f, 0.35779878f, -0.01337467f, 
    0.33782372f, -0.16021271f, 0.28484946f, -0.12727337f, -0.14467072f, -0.02426667f, -0.19526266f, -0.29902506f, 
    -0.11395419f, -0.05960331f, -0.07461438f, 0.19037126f, -0.08428247f, 0.26801637f, 0.33319125f, -0.12418665f, 
    0.07024929f, -0.00818337f, 0.05800273f, 0.12959437f, 0.13742140f, 0.24220860f, 0.15670411f, 0.07089890f, 
    0.17344786f, -0.06935510f, 0.20079485f, -0.09414656f, 0.11017776f, -0.17194359f, 0.43278462f, 0.14653702f, 
    0.21672378f, 0.01239876f, -0.01830167f, -0.06592639f, -0.13087134f, -0.36247146f, 0.01712034f, 0.04340410f, 
    0.18653992f, -0.12300643f, -0.09641925f, -0.23713203f, -0.07181908f, -0.11735806f, 0.09946394f, -0.44334432f, 
    -0.15716252f, 0.32245347f, 0.05372914f, 0.17260091f, 0.12330165f, -0.37014505f, -0.16646490f, 0.07989516f, 
    -0.01234972f, -0.11762340f, 0.07945207f, 0.09232043f, 0.07494286f, 0.00607319f, -0.24316332f, 0.15604147f, 
    -0.03834118f, -0.11901589f, -0.32211512f, 0.01920147f, 0.30954149f, -0.03144563f, 0.20192386f, -0.09059407f, 
    -0.06693985f, 0.12293898f, -0.14167644f, -0.18338069f, 0.16442326f, 0.35093710f, 0.05914408f, 0.12866344f, 
    0.10255709f, 0.09606558f, 0.05481365f, 0.10936394f, -0.11145322f, -0.11101342f, 0.10514972f, 0.00353214f, 
    0.14910889f, 0.02274867f, 0.24982314f, 0.09649348f, 0.00660909f, -0.02862732f, -0.18622600f, 0.08184786f, 
    -0.17946061f, -0.11244218f, 0.21288048f, -0.04039996f, -0.23825660f, 0.00206988f, -0.10525317f, 0.32507324f, 
    0.10367392f, -0.09395576f, 0.08981942f, 0.14877604f, -0.10903446f, -0.25088850f, 0.24796039f, 0.19242378f, 
    -0.14460987f, -0.00995132f, 0.05754378f, 0.04579912f, -0.06637904f, 0.09687080f, -0.10414709f, 0.09687836f, 
    0.11665182f, -0.08800710f, 0.04104571f, 0.01084098f, 0.27849314f, 0.04073265f, -0.04350048f, 0.03900270f, 
    -0.10636158f, -0.01386500f, -0.46894914f, 0.06385917f, 0.13483958f, -0.05576646f, 0.30614769f, 0.15054499f, 
    0.06747568f, -0.04730599f, -0.05542178f, 0.29061714f, 0.08977422f, -0.17866798f, -0.17604192f, 0.10740736f, 
    0.16143772f, 0.11860815f, 0.03379228f, 0.05584984f, 0.11012675f, 0.03780477f, 0.11968678f, 0.16107766f, 
    0.06085443f, -0.31748009f, 0.12382906f, -0.17112558f, -0.10127606f, 0.00457358f, -0.05659419f, -0.13219987f, 
    -0.05077621f, 0.06567533f, 0.23360910f, -0.00124898f, 0.06371090f, 0.45514798f, 0.01573744f, -0.14602920f, 
    0.05603411f, 0.16713962f, -0.13043635f, -0.12458139f, -0.06711531f, -0.06697954f, 0.22306316f, 0.05597456f, 
    0.02082967f, -0.03048191f, -0.15351848f, 0.26621786f, -0.13322562f, 0.03896460f, -0.09503261f, -0.04491773f, 
    0.31644663f, 0.25277206f, -0.07537534f, -0.00211989f, 0.04461469f, 0.32834643f, 0.25018102f, -0.13873431f, 
    0.07893817f, -0.06260144f, -0.00639228f, -0.03906317f, 0.08681519f, -0.12866132f, -0.01025513f, 0.15605675f, 
    0.28869259f, -0.05615839f, -0.14508194f, -0.03210212f, -0.08265559f, -0.34855404f, -0.08197818f, -0.35242918f, 
    0.11677852f, -0.08855661f, -0.14860603f, 0.16185459f, 0.12250663f, 0.29980019f, 0.16765599f, 0.14486270f, 
    -0.07575247f, -0.27017063f, -0.07807347f, 0.15207627f, 0.17354921f, -0.27048141f, 0.13367438f, 0.17662096f, 
    0.07009725f, -0.14477281f, -0.14186773f, 0.04719808f, -0.00278578f, -0.17805338f, 0.11283021f, -0.10131247f, 
    0.19568478f, -0.16924858f, -0.13713339f, 0.47579050f, 0.08429282f, 0.10154114f, -0.14351574f, -0.06850754f, 
    -0.01281353f, 0.19240819f, 0.15142599f, -0.14574245f, -0.11241461f, -0.24725935f, -0.02981528f, -0.14982563f, 
    -0.25564015f, -0.00852811f, -0.11270180f, -0.13690099f, 0.16068092f, 0.02688305f, 0.30611870f, 0.03622218f, 
    -0.13447574f, 0.05601874f, 0.02635026f, -0.12675932f, -0.28658053f, -0.04703451f, -0.04127184f, -0.14890891f, 
    -0.15894723f, -0.08642760f, -0.02343250f, 0.32078609f, -0.07379875f, 0.08675465f, 0.04309607f, 0.20533177f, 
    0.11564250f, 0.08888298f, 0.11288062f, -0.06781837f, -0.01452367f, -0.03217751f, 0.05353121f, 0.05436560f, 
    0.15955158f, -0.04003335f, -0.12514260f, 0.04480300f, -0.06547397f, -0.07948527f, 0.28454629f, 0.23428266f, 
    -0.01314662f, -0.03409906f, -0.25062421f, -0.00631386f, 0.15651371f, -0.32230291f, -0.28805357f, -0.15401153f, 
    0.10014934f, -0.04999491f, 0.09993397f, -0.13129106f, -0.00565778f, 0.31199369f, 0.24829091f, -0.11373304f, 
    -0.01088134f, 0.20045330f, -0.03078866f, 0.05976824f, 0.15804522f, -0.20398904f, 0.07838392f, -0.11158147f, 
    0.28547853f, 0.07667623f, 0.10835051f, -0.00879842f, -0.13084432f, -0.18008360f, -0.54588294f, 0.21244277f, 
    0.46653089f, -0.13888577f, -0.19555233f, 0.02687901f, 0.26763543f, 0.35186464f, -0.14170454f, 0.38986385f, 
    -0.24334501f, -0.05845281f, 0.13661636f, -0.24727485f, -0.09910908f, -0.12605916f, 0.24793895f, -0.04365656f, 
    -0.13211262f, -0.19728515f, 0.06748556f, -0.20365188f, -0.05956631f, 0.34264922f, 0.00363917f, 0.00248142f, 
    0.04735589f, 0.19715488f, -0.26057711f, 0.05360802f, -0.02367437f, -0.17011704f, 0.20962909f, -0.12501299f, 
    0.03838824f, 0.00855567f, 0.17611361f, 0.03724081f, -0.03760513f, 0.00608088f, 0.14791484f, -0.17200659f, 
    -0.08380302f, 0.15620543f, 0.16910575f, 0.11457584f, 0.15718149f, -0.09601964f, -0.06821040f, 0.01485756f, 
    0.02506092f, -0.36385307f, -0.03480276f, -0.24143936f, 0.13985595f, 0.06670605f, -0.05453426f, -0.13666286f, 
    -0.04678956f, -0.32501227f, 0.10302995f, 0.12164470f, 0.18960944f, -0.07474002f, 0.16737022f, -0.10456131f, 
    -0.18509428f, 0.01790668f, -0.10103659f, 0.07880373f, -0.20798807f, 0.17094478f, -0.02016195f, -0.09340724f, 
    -0.00644278f, -0.01578480f, 0.12012941f, 0.14941667f, 0.05408671f, 0.30957103f, 0.24747214f, 0.16033973f, 
    0.18277590f, -0.09285266f, 0.06266455f, 0.28955626f, 0.07186054f, 0.29234308f, 0.09001853f, 0.10840017f, 
    -0.37926003f, -0.19680925f, 0.00263440f, 0.04937075f, 0.22092757f, 0.27901921f, -0.09708752f, 0.08967608f, 
    -0.43558145f, 0.07339770f, -0.15735269f, 0.02351074f, -0.01234332f, -0.22283538f, 0.14928403f, 0.06176952f, 
    0.36473781f, 0.11986779f, 0.00358229f, -0.02043231f, -0.08350380f, 0.11765130f, 0.05964080f, -0.02926059f, 
    0.09799725f, 0.19699255f, 0.03890838f, 0.14676945f, -0.16017443f, 0.14517216f, -0.09015858f, -0.06049382f, 
    -0.23728576f, -0.31447771f, 0.00073276f, 0.06563401f, 0.16742527f, -0.19352876f, -0.26681980f, 0.25254160f, 
    0.13457328f, -0.00557820f, -0.05421968f, 0.14927079f, 0.14641728f, 0.18936896f, -0.13226025f, 0.10690198f, 
    -0.03671889f, -0.00288998f, 0.00247513f, 0.30988577f, 0.14512070f, 0.26966625f, 0.17055370f, 0.16312988f, 
    0.01013377f, -0.07299559f, 0.05132174f, 0.13125162f, -0.07807119f, 0.26606867f, -0.08353836f, 0.02184458f, 
    -0.07034820f, -0.02236041f, -0.04382360f, -0.14070523f, 0.12092702f, 0.26502138f, 0.25983801f, 0.11764880f, 
    -0.01957768f, -0.00075850f, 0.05477591f, -0.07552692f, -0.08863084f, 0.10064533f, -0.12893245f, -0.22072433f, 
    0.22476420f, -0.14679278f, 0.12304129f, 0.17656019f, 0.11060425f, -0.03113138f, -0.04393291f, 0.08834407f, 
    0.01416219f, -0.21419130f, 0.03022114f, 0.30052885f, -0.12538156f, 0.23858435f, 0.10463499f, 0.09395652f, 
    -0.24916862f, -0.10123333f, 0.27720490f, 0.08504827f, -0.16788886f, 0.14667323f, -0.22587897f, 0.19385244f, 
    0.03640540f, -0.05215954f, -0.18710589f, 0.14141756f, -0.05056993f, -0.23979551f, 0.11169007f, 0.20286222f, 
    0.20910254f, 0.04644182f, 0.05323889f, -0.68931478f, 0.11813346f, -0.27434951f, 0.23609006f, -0.21049137f, 
    -0.17604603f, 0.10419154f, -0.04647834f, -0.02107106f, 0.12506150f, 0.14660387f, -0.05771276f, 0.09074181f, 
    -0.43118265f, -0.10045400f, -0.14397629f, -0.10393006f, 0.31200713f, -0.42577067f, -0.33305550f, 0.12636338f, 
    0.04043607f, -0.04943534f, -0.06211120f, 0.12427266f, 0.24617037f, -0.08364992f, 0.37369102f, -0.03935597f, 
    -0.23484325f, -0.14674658f, -0.14110015f, -0.03942792f, 0.13741417f, 0.26983088f, 0.08694170f, -0.06033384f, 
    0.17550252f, -0.00341623f, 0.05950382f, -0.02548242f, 0.10967015f, -0.08154292f, -0.17101707f, -0.12988855f, 
    0.25473320f, -0.32008651f, 0.12935044f, -0.05094829f, -0.00689781f, 0.14129834f, 0.22765982f, -0.09029537f, 
    -0.02515901f, -0.07591666f, 0.40076861f, -0.00382369f, -0.15204023f, 0.15669386f, 0.37094939f, -0.15241992f, 
    -0.02677430f, 0.02391970f, 0.04192566f, -0.21474715f, 0.00248183f, 0.16152805f, -0.15735540f, 0.14682007f, 
    0.16014348f, -0.03318683f, -0.08957565f, 0.08400354f, -0.07874683f, -0.01370363f, -0.10862653f, 0.09643643f, 
    0.30793446f, -0.25610745f, -0.10511529f, -0.03378249f, 0.13575256f, 0.25596845f, 0.16398783f, -0.19729427f, 
    -0.05903827f, -0.00708906f, 0.22216560f, 0.01550254f, 0.14059283f, -0.18394981f, 0.32477227f, -0.25236577f, 
    0.33027810f, 0.12833861f, -0.14216001f, -0.03884590f, 0.11792643f, -0.06229505f, -0.10840849f, -0.61254269f, 
    -0.07074474f, 0.11881315f, 0.12992817f, 0.01950679f, -0.04233552f, 0.08302392f, 0.04307696f, 0.15347411f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07882331f, 0.11068216f, 0.12782061f, 0.06899108f, -0.04874498f, -0.03535489f, 0.00946338f, 0.00969612f, 
    -0.29243726f, -0.14044228f, -0.00135597f, -0.09139363f, -0.10473415f, 0.11735139f, 0.20225161f, -0.07834615f, 
    0.05949685f, -0.00794857f, -0.07713297f, -0.08460914f, 0.06397507f, 0.13744189f, 0.14061390f, 0.21350570f, 
    0.06007753f, 0.12817042f, 0.20583099f, 0.15356095f, 0.01767763f, 0.11833859f, 0.12098129f, 0.12053654f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.53970104f, 0.03318271f, -0.23517080f, 0.11577349f, 0.27972484f, 0.15044071f, 0.11544847f, -0.06701063f, 
    0.14073615f, -0.12753421f, 0.19254632f, -0.10477913f, 0.00658321f, -0.06475150f, -0.37460077f, 0.15176305f, 
    -0.37930605f, 0.19738548f, -0.08531206f, -0.02867574f, -0.17204729f, -0.47214577f, -0.09413785f, -0.23190609f, 
    0.11900783f, -0.29487997f, -0.41000226f, -0.06154498f, -0.19295651f, -0.12449352f, 0.31645289f, 0.00339562f, 
    -0.01049562f, -0.12706807f, 0.22505310f, 0.23500954f, 0.19644935f, 0.18453068f, 0.20020235f, 0.00010994f, 
    -0.13834020f, -0.20912933f, -0.18886657f, 0.27463827f, -0.59522784f, -0.47787610f, 0.19943024f, 0.00067862f, 
    0.15639538f, 0.13869157f, -0.11529963f, -0.22461195f, -0.00882026f, -0.36737809f, 0.24964803f, 0.04934761f, 
    -0.09685744f, -0.05578308f, 0.14056048f, -0.12048949f, -0.25676581f, 0.17875025f, 0.02931873f, -0.46368897f, 
    0.25803536f, -0.01186991f, 0.06515604f, -0.36045885f, -0.18575385f, -0.11478564f, 0.03771950f, -0.10574014f, 
    0.03696959f, 0.22265799f, 0.18918587f, -0.12541315f, -0.18962801f, 0.13717918f, -0.04938092f, 0.10341241f, 
    0.24183299f, -0.63252097f, -0.09471000f, 0.12995009f, 0.00784499f, 0.16923086f, -0.16917908f, -0.38227892f, 
    0.17973600f, -0.06207316f, 0.03360515f, 0.03888761f, -0.39414755f, -0.58630925f, -0.58052939f, -0.31840646f, 
    -0.15033926f, 0.08658475f, 0.28992888f, -0.03881951f, -0.29905069f, -0.17710635f, 0.11477670f, -0.06832492f, 
    -0.48071063f, 0.12862828f, 0.15136103f, 0.27787778f, 0.21845691f, 0.07751238f, 0.02360001f, -0.09046035f, 
    -0.30256963f, 0.17709483f, -0.08735346f, 0.00981859f, -0.41209555f, -0.06526072f, -0.17929219f, -0.61556530f, 
    0.19814360f, -0.29960725f, 0.02031663f, 0.21639131f, -0.36437356f, -0.47311932f, 0.00097007f, -0.02623788f, 
    -0.23381847f, -0.05727300f, 0.07982958f, 0.04593870f, 0.12629041f, 0.00718129f, 0.14334042f, -0.03402658f, 
    0.12774390f, 0.05220044f, 0.01389945f, 0.06140730f, -0.21047324f, 0.18613352f, 0.00776759f, -0.10095483f, 
    -0.22182037f, -0.15447675f, 0.13109446f, -0.27263242f, -0.32733351f, 0.17912070f, -0.29867938f, 0.08229362f, 
    0.04276848f, 0.04556291f, -0.42424473f, 0.01695182f, 0.16705848f, -0.00195797f, 0.03666263f, 0.17667449f, 
    -0.08370069f, 0.16818181f, -0.46598184f, 0.21500504f, -0.16395155f, 0.00799346f, 0.08605954f, -0.03268350f, 
    -0.14957993f, -0.13164033f, 0.17350633f, -0.08536644f, -0.25593463f, 0.18988940f, -0.12958586f, 0.19186291f, 
    -0.12320137f, 0.06845648f, -0.00868836f, -0.25288713f, 0.07366046f, -0.19581883f, 0.30454150f, 0.02670805f, 
    -0.08394584f, -0.06702564f, 0.00526555f, -0.15331241f, 0.41934991f, -0.28147173f, -0.34984046f, -0.08051038f, 
    0.20167644f, 0.09728273f, 0.07455098f, -0.39298576f, 0.00828811f, -0.53374350f, -0.52108938f, -0.04340683f, 
    0.03118115f, 0.07894757f, -0.67164826f, -0.65608674f, -0.32847968f, -0.02201789f, 0.13664557f, -0.08019171f, 
    -0.01838274f, -0.22150616f, -0.28654048f, 0.25780523f, 0.20436542f, -0.01379475f, -0.43764225f, 0.13700472f, 
    0.03725064f, 0.33027792f, 0.19496225f, 0.03286147f, -0.28511602f, 0.37230727f, -0.55682105f, 0.18399757f, 
    -0.29615697f, 0.04930837f, 0.40815049f, 0.20414704f, -0.44712532f, 0.03156348f, -0.26384166f, -0.06141133f, 
    -0.19228713f, 0.15393694f, -0.19007421f, -0.22444360f, 0.31201470f, 0.14343032f, -0.11963930f, -0.54090798f, 
    -0.23948036f, -0.22910056f, 0.21328379f, 0.18630907f, -0.17685646f, 0.07393983f, 0.06474464f, -0.05909310f, 
    -0.53910041f, -0.33674115f, -0.03097028f, 0.16230690f, -0.29067913f, -0.35217661f, -0.14790913f, 0.27166554f, 
    -0.29329991f, 0.16133837f, -0.20426120f, -0.25508979f, -0.18174630f, -0.14853692f, -0.52813417f, 0.04377487f, 
    -0.21720988f, 0.02614171f, 0.10691775f, 0.22682422f, 0.39016867f, -0.46928075f, 0.14823607f, -0.07806368f, 
    -0.40608129f, -0.38812497f, -0.17892772f, -0.22617595f, 0.16255681f, 0.20777036f, 0.27733418f, -0.70406169f, 
    0.22220981f, -0.17639197f, 0.25758183f, -0.08250540f, -0.10271538f, 0.10268263f, -0.40008184f, 0.02244407f, 
    0.04986539f, 0.07200625f, -0.08951030f, 0.24052192f, -0.17859015f, -0.38693607f, -0.07720447f, 0.02800850f, 
    -0.37921673f, -0.14591944f, -0.12030843f, -0.28313535f, -0.41314283f, 0.07682635f, 0.07683011f, -0.10894199f, 
    0.37249923f, -0.30883217f, 0.10219003f, 0.06377848f, 0.19745810f, -0.24271205f, -0.37241551f, -0.51085496f, 
    -0.00896386f, 0.18259834f, -0.19287036f, 0.19282798f, -0.15415874f, -0.31183240f, 0.02785168f, 0.44037578f, 
    -0.13119353f, 0.16289511f, 0.32140452f, 0.01885180f, -0.47323897f, -0.03219246f, 0.02323960f, -0.16970268f, 
    -0.25323293f, -0.28129545f, -0.50669760f, 0.03902783f, 0.09784973f, -0.49490532f, 0.15575662f, 0.03231265f, 
    -0.20068231f, 0.19200236f, -0.15656224f, -0.29220688f, -0.32260680f, -0.25954717f, -0.16493370f, -0.46931657f, 
    0.32002395f, 0.37515932f, 0.14437532f, 0.36624262f, 0.36108428f, -0.32697991f, 0.03397384f, -0.29760581f, 
    0.21222597f, -0.06840313f, -0.49297136f, -0.04704872f, 0.09564774f, 0.42337862f, -0.12303437f, 0.11336046f, 
    -0.31323805f, -0.24951196f, -0.14728431f, -0.15446918f, -0.05551355f, 0.25694939f, 0.29283583f, -0.29401523f, 
    -0.00192048f, -0.24966531f, -0.47998253f, 0.13940427f, -0.13049957f, 0.14540207f, -0.04790531f, -0.50347364f, 
    -0.11399967f, -0.10173914f, 0.10133218f, -0.48804921f, 0.08791135f, 0.28030187f, -0.18056911f, -0.13887289f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.01805863f, 0.02715023f, 0.02918888f, -0.20445046f, -0.13965817f, -0.09067844f, 0.04323802f, -0.06323047f, 
    0.23832487f, 0.08811361f, -0.04616633f, 0.06242664f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
