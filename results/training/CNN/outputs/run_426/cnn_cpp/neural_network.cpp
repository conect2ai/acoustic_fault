#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.01523392f, -0.52141744f, 0.44997284f, 0.02584371f, 0.11447380f, -0.19515117f, -0.35774168f, 0.50335127f, 
    0.24186352f, -0.40282404f, 0.13569681f, -0.39349973f, -0.08461475f, 0.23979717f, -0.25281900f, 0.35117161f, 
    0.19613585f, 0.16651030f, -0.28799582f, -0.27010357f, -0.24322845f, -0.24753048f, -0.15816167f, -0.23955007f, 
    -0.06159918f, 0.09919644f, -0.24541844f, -0.35713437f, -0.48081335f, -0.27970070f, 0.05730364f, 0.67825019f, 
    0.34739509f, -0.23689854f, -0.09722627f, 0.13860315f, -0.00725482f, -0.33413875f, -0.31097245f, -0.06480821f, 
    0.11741546f, -0.01405378f, 0.05592676f, 0.11678813f, -0.16202159f, 0.11872423f, 0.11502632f, 0.08559985f, 
    0.03533641f, 0.13501801f, -0.41103381f, -0.32451749f, 0.03169296f, -0.57628542f, -0.13529854f, -0.16987659f, 
    0.07210806f, -0.47083092f, -0.54527557f, -0.31627318f, 0.11739291f, -0.19860138f, 0.22391824f, 0.21944638f, 
    -0.05035650f, 0.02923186f, -0.20462568f, -0.22670357f, 0.02793699f, 0.21433543f, -0.00998508f, 0.40502352f, 
    0.05796330f, 0.33156553f, -0.11664592f, 0.66177624f, 0.34666273f, 0.14134884f, 0.54239458f, -0.07277104f, 
    -0.14671178f, -0.17466655f, 0.29305965f, 0.10605449f, 0.13333374f, -0.36945942f, -0.14725907f, 0.04877027f, 
    0.11322339f, 0.10765887f, -0.09150564f, 0.36226076f, -0.30804002f, -0.10875983f, -0.07702928f, -0.42103189f, 
    0.09137297f, -0.12828892f, -0.16662693f, -0.29289392f, 0.78193277f, 0.57999736f, 0.26306441f, -0.07241830f, 
    0.06598324f, -0.26817283f, -0.71481073f, 0.27953872f, -0.31474888f, 0.28966564f, 0.11376061f, -0.00817186f, 
    -0.03885469f, -0.17242275f, -0.24688610f, 0.10310310f, -0.26019007f, -0.20930374f, 0.13066508f, -0.08287014f, 
    0.32111323f, 0.35744140f, -0.20419317f, -0.19874711f, -0.03523199f, 0.64524353f, 0.59106171f, 0.35132563f, 
    -0.05286700f, -0.51353157f, 0.12070880f, -0.06729107f, -0.25728580f, -0.21044484f, 0.39542517f, 0.00927313f, 
    0.36311293f, 0.19639805f, 0.22086790f, 0.21524267f, 0.18097126f, 0.09838773f, 0.35080916f, -0.15211076f, 
    -0.08244899f, 0.06530097f, -0.26968008f, 0.16636218f, -0.08250657f, 0.02360256f, -0.45458955f, 0.29066491f, 
    0.31011808f, -0.43295240f, 0.11489679f, -0.42155787f, 0.68195206f, -0.00234430f, 0.23835011f, 0.29721206f, 
    -0.08510351f, -0.19334529f, -0.02291799f, -0.00416496f, 0.26731130f, 0.32542336f, 0.29611588f, 0.19515170f, 
    0.21162251f, -0.18903638f, 0.21274164f, -0.07863303f, 0.15143567f, -0.13441736f, -0.17874454f, -0.35944167f, 
    -0.38845897f, -0.03046621f, -0.12959717f, -0.24600680f, 0.20963527f, 0.43615255f, -0.18066929f, 0.30360800f, 
    0.09226801f, -0.06002571f, -0.23409599f, -0.35517484f, -0.07425562f, -0.09662209f, 0.01683840f, 0.44011164f, 
    0.24010076f, 0.07354403f, -0.20018676f, -0.00163452f, -0.37306613f, -0.23928587f, -0.25081939f, 0.28050226f, 
    0.04274179f, 0.42305341f, 0.26776314f, -0.01373143f, -0.12881580f, -0.15924945f, 0.63841468f, -0.02840995f, 
    0.42036474f, 0.38791639f, -0.10142872f, 0.20471129f, -0.14669515f, -0.28536212f, 0.06151548f, -0.17491469f, 
    -0.01303520f, -0.15675317f, -0.25983432f, 0.02096932f, -0.14496240f, -0.06061181f, 0.13827161f, -0.13856868f, 
    0.16289061f, 0.34076354f, 0.19874848f, 0.34089506f, 0.68900436f, 0.42710060f, -0.36235020f, -0.15982467f, 
    -0.31245622f, -0.07565747f, 0.26947153f, 0.27363938f, 0.25840348f, 0.25860509f, 0.10184390f, -0.27388826f, 
    -0.12217587f, -0.05600386f, 0.03480517f, 0.01169519f, 0.23323236f, 0.07671604f, -0.13564785f, 0.34147513f, 
    0.17855994f, -0.01699706f, 0.13101643f, -0.18324530f, -0.60395396f, -0.50477248f, -0.46954948f, 0.56929052f, 
    0.49133986f, -0.36323768f, -0.33832094f, 0.12585846f, -0.08524375f, -0.25118080f, 0.04719104f, 0.27122429f, 
    -0.03194719f, -0.16213056f, -0.03491318f, 0.09351245f, 0.03657093f, -0.34456524f, -0.03175646f, -0.22626284f, 
    0.12198047f, -0.03240220f, 0.01250613f, -0.37183270f, -0.50382340f, 0.24206437f, 0.23998646f, -0.13466339f, 
    0.28761744f, 0.35694066f, -0.26099145f, 0.00957366f, -0.23157240f, -0.24257211f, 0.17088886f, 0.21618494f, 
    0.52982515f, 0.34019965f, -0.00687247f, 0.04195446f, 0.15413682f, 0.07711758f, 0.22272618f, -0.06975903f, 
    0.17288642f, -0.45514706f, -0.19005403f, 0.26649433f, -0.41127264f, -0.42278945f, -0.31848332f, -0.40724254f, 
    0.19826493f, 0.05586271f, 0.77174777f, -0.15198778f, -0.19515683f, 0.21164939f, -0.46168071f, -0.01883503f, 
    -0.05697766f, 0.02329289f, 0.16748033f, -0.05651847f, -0.01791862f, -0.04203266f, -0.03602095f, -0.02044324f, 
    0.40826234f, -0.29074597f, 0.18976605f, -0.06503358f, 0.10644253f, -0.25780827f, -0.51202512f, -0.15000005f, 
    0.00163189f, -0.19650465f, -0.19726345f, -0.50637251f, -0.18181956f, -0.10069488f, -0.22366308f, 0.05476057f, 
    -0.02600974f, 0.39858606f, 0.03628398f, -0.25541544f, 0.36390835f, 0.08170148f, 0.26792404f, -0.16782588f, 
    -0.18366249f, -0.01567626f, -0.12514932f, 0.01236870f, 0.09181596f, 0.00445801f, -0.21297659f, -0.27191246f, 
    -0.58523029f, 0.08380223f, -0.12021063f, -0.02314989f, -0.29893982f, -0.56984884f, -0.06116486f, -0.43599114f, 
    -0.13101439f, 0.36103085f, 0.27751651f, 0.18307602f, 0.12409922f, -0.02041226f, -0.50971007f, -0.18589553f, 
    0.16443352f, 0.03937702f, -0.02391207f, 0.34573513f, -0.21954860f, -0.13881983f, 0.05162742f, -0.15844864f, 
    -0.45534033f, -0.31770143f, -0.11230112f, -0.45817578f, -0.32288465f, 0.00120435f, 0.23762721f, -0.23407085f, 
    0.27921110f, 0.19377883f, 0.06102382f, -0.10254183f, 0.23397553f, -0.07467550f, 0.23346753f, 0.19608897f, 
    0.12318618f, -0.25416163f, -0.20173714f, -0.16556886f, -0.31156325f, -0.15621524f, -0.02188914f, 0.07804279f, 
    0.71255571f, 0.04793588f, 0.04842556f, 0.47764528f, 0.41880265f, -0.08848455f, 0.21723801f, -0.26509091f, 
    0.11659056f, 0.43038785f, -0.36868188f, -0.21878436f, 0.08845592f, 0.08487917f, -0.10420181f, 0.09077156f, 
    0.01190241f, 0.13230953f, -0.14899074f, -0.11511629f, 0.19634721f, 0.11613056f, 0.02941076f, -0.14209059f, 
    -0.05669994f, 0.52698141f, 0.51678795f, 0.11898284f, 0.24608319f, 0.50340021f, -0.00225801f, -0.08439927f, 
    -0.18590002f, -0.21777184f, -0.44361278f, -0.39062759f, -0.21980323f, -0.19719473f, 0.06596688f, 0.35886869f, 
    -0.22273351f, -0.06229197f, -0.04640520f, 0.12822907f, 0.22363280f, -0.08754140f, 0.09029197f, -0.05171507f, 
    -0.20239875f, -0.11555334f, 0.01650955f, 0.62793642f, 0.50190121f, -0.12174827f, 0.23263492f, -0.61145604f, 
    -0.47250563f, -0.26670215f, -0.72233838f, -0.05551403f, 0.27598128f, 0.25200206f, 0.12594783f, 0.23589030f, 
    0.05543534f, -0.03338629f, 0.11514144f, -0.25908732f, 0.14086014f, 0.16943751f, 0.21450564f, 0.13967162f, 
    0.24429500f, -0.07329805f, 0.12913628f, -0.29420331f, 0.05058128f, 0.22671025f, -0.02866741f, 0.38587648f, 
    0.39624599f, 0.08678011f, 0.29338339f, -0.30367336f, 0.11667355f, 0.26057017f, -0.43463305f, 0.31828821f, 
    0.09967285f, 0.08959699f, -0.15081412f, -0.11052761f, -0.46490747f, -0.09233505f, -0.14891043f, -0.10634977f, 
    0.09338459f, 0.28208253f, 0.27366671f, -0.14780553f, 0.49324131f, 0.52145565f, 0.41894433f, 0.34351471f, 
    0.51015538f, 0.44509032f, 0.10500844f, -0.30805013f, -0.49170122f, -0.43239415f, 0.43710896f, 0.05071253f, 
    0.08273491f, -0.05383446f, -0.37941897f, -0.28512922f, 0.14459103f, -0.14089437f, -0.20253050f, -0.10817296f, 
    -0.07206304f, 0.18701011f, 0.13806765f, 0.00021012f, 0.15158558f, 0.46330023f, 0.35031676f, 0.46559450f, 
    0.33806583f, -0.47373259f, -0.15126936f, -0.71913421f, 0.38812390f, 0.08809222f, 0.31487405f, 0.38267788f, 
    0.02917888f, -0.53781420f, -0.14931352f, -0.08694702f, 0.04728040f, -0.11118128f, 0.07980915f, -0.25946209f, 
    0.23232579f, -0.15489367f, -0.04423497f, -0.01080844f, -0.06510511f, 0.00179147f, 0.67739475f, 0.27756748f, 
    0.61896151f, 0.39156610f, -0.34435177f, 0.04588205f, -0.16771702f, -0.04303962f, -0.45769969f, -0.15429415f, 
    0.16243355f, -0.03177256f, -0.05912712f, 0.20029421f, -0.10648381f, 0.14747708f, 0.18641557f, 0.23433588f, 
    0.09578988f, -0.15058024f, 0.04549620f, -0.01010399f, -0.11095742f, 0.33189264f, 0.25221631f, 0.71700913f, 
    0.47113490f, -0.49291071f, -0.02865800f, -0.44145569f, 0.48199472f, 0.39909291f, 0.02099347f, 0.33226424f, 
    0.19551031f, 0.22376603f, -0.23753737f, -0.13039292f, -0.31357056f, -0.03766637f, -0.02596036f, 0.06502126f, 
    -0.29688856f, 0.06574745f, 0.16530532f, -0.00801188f, -0.30501279f, -0.00680837f, -0.22462624f, 0.12236653f, 
    -0.02274188f, -0.15692157f, -0.38449794f, -0.29865989f, -0.13922417f, -0.42342219f, 0.08835579f, 0.30207285f, 
    -0.17522299f, 0.24455588f, 0.13344087f, 0.01322505f, -0.32239881f, -0.33980826f, -0.51552254f, -0.30140230f, 
    0.34984624f, -0.03494751f, -0.24426934f, -0.01647691f, 0.04852497f, 0.32111859f, -0.13129066f, -0.32481098f, 
    -0.19580795f, 0.55194676f, 0.33017987f, 0.39325580f, -0.07529752f, -0.15626828f, 0.25224641f, 0.06339382f, 
    -0.05182242f, 0.08890890f, -0.31272590f, -0.62153471f, 0.06246308f, 0.13431567f, -0.12819925f, -0.51054168f, 
    0.03896704f, 0.19356802f, 0.29161954f, 0.00457692f, 0.08113363f, 0.09227288f, 0.25500670f, -0.19023804f, 
    0.26374266f, 0.35591161f, 0.57156014f, 0.47814897f, 0.40612760f, 0.20630281f, 0.26855683f, -0.16882892f, 
    -0.39840969f, 0.18671133f, -0.37378624f, -0.28623873f, 0.03428052f, -0.19051093f, 0.09919144f, 0.40932724f, 
    0.23534106f, 0.30062222f, 0.20361353f, 0.15953925f, 0.11961868f, 0.14513415f, -0.03278635f, -0.20945223f, 
    0.02013546f, 0.19482271f, 0.19470991f, 0.72129643f, 0.02569907f, -0.08990933f, 0.35646459f, 0.39153221f, 
    -0.00554807f, -0.58008254f, 0.17353079f, -0.16542353f, 0.30015683f, 0.13387588f, 0.06162380f, -0.13193351f, 
    0.11973431f, 0.18528353f, -0.13354322f, -0.30362874f, -0.32477477f, -0.06666595f, 0.05375359f, -0.11343815f, 
    -0.12474312f, 0.32079181f, -0.31872797f, -0.26333693f, -0.40884408f, 0.20180096f, 0.27459529f, -0.64682347f, 
    0.17100914f, 0.51581424f, -0.12687321f, -0.64430910f, 0.03670582f, -0.30543461f, -0.06746017f, -0.23307043f, 
    -0.23972116f, 0.08687773f, -0.07138423f, -0.49178940f, -0.07637314f, -0.15905556f, 0.17570531f, -0.03678918f, 
    -0.12707941f, -0.09450136f, 0.00514636f, -0.06427323f, 0.17348287f, 0.24960406f, -0.20174885f, -0.27688187f, 
    -0.40388381f, 0.58257216f, -0.63751137f, 0.57365215f, -0.13499095f, -0.66436493f, 0.20338506f, -0.12559150f, 
    0.03713558f, 0.15725701f, -0.21554491f, 0.07998832f, 0.21306786f, -0.04414416f, -0.04362288f, 0.39210877f, 
    -0.06418123f, -0.07097667f, -0.16755296f, -0.03915295f, -0.09438559f, 0.05512267f, 0.42915606f, -0.29793060f, 
    -0.26931715f, 0.73677123f, 0.21660729f, 0.35637903f, 0.56606716f, 0.43417758f, 0.50448090f, -0.23822869f, 
    -0.25851569f, -0.29521865f, -0.02977540f, -0.45142862f, -0.30712977f, -0.41974029f, -0.20109354f, 0.15321563f, 
    0.07600495f, -0.27871671f, 0.12343370f, -0.09197818f, -0.25877720f, -0.05224999f, -0.33321026f, 0.70081997f, 
    -0.18030293f, -0.02283898f, -0.37092456f, 0.40585312f, 0.33035347f, -0.04737148f, 0.08812231f, 0.28939915f, 
    0.20342563f, -0.44261491f, -0.17824928f, -0.53256047f, 0.00536576f, 0.24538362f, 0.15684038f, 0.03411639f, 
    0.17163408f, -0.15661420f, -0.14139202f, 0.26287884f, 0.34586111f, 0.09074339f, 0.29656804f, 0.20363690f, 
    -0.02774885f, 0.38918239f, -0.49059173f, 0.19579563f, 0.30700943f, 0.09216497f, -0.58389914f, -0.56430554f, 
    -0.23627096f, 0.23324549f, 0.26693389f, -0.28499207f, 0.04688843f, 0.23011145f, -0.24461584f, -0.01224873f, 
    0.22141659f, -0.12101554f, -0.12866098f, 0.21488857f, -0.11875062f, -0.08424596f, 0.21429919f, -0.23524503f, 
    -0.34763929f, 0.60517704f, 0.40513644f, 0.22185248f, 0.46471658f, -0.18962434f, -0.03006355f, 0.46202675f, 
    -0.11931552f, -0.07240943f, 0.49923462f, 0.25151625f, 0.26003784f, 0.01561806f, 0.11636117f, -0.13536198f, 
    -0.22505809f, -0.37213308f, 0.13695480f, 0.09351989f, -0.18502851f, 0.21334872f, 0.28253403f, 0.02673998f, 
    0.17920540f, -0.00042308f, -0.55106628f, -0.10195456f, 0.19569738f, 0.05520367f, 0.10474747f, -0.74403679f, 
    0.06290544f, -0.37625074f, -0.16633151f, 0.17693482f, 0.00674774f, -0.24967811f, 0.17046960f, -0.16330387f, 
    -0.23821943f, 0.03352498f, 0.25488466f, 0.32645309f, -0.37516013f, -0.01952167f, -0.16735855f, -0.05368803f, 
    -0.02436555f, 0.09646038f, 0.16960682f, -0.47759223f, -0.43799090f, 0.06899384f, 0.38267931f, 0.42394254f, 
    -0.35105258f, 0.27711725f, -0.08460134f, -0.23625593f, -0.54652005f, 0.21030979f, 0.26141784f, -0.18173379f, 
    0.04542893f, 0.05553177f, -0.37224776f, -0.14452130f, 0.39103812f, -0.15130395f, 0.07979717f, -0.22927493f, 
    -0.01942926f, -0.12594987f, 0.23921330f, -0.15882923f, 0.92543954f, -0.24486931f, 0.11134123f, 0.91639304f, 
    0.58109069f, 0.32300201f, 0.09404745f, -0.12362041f, 0.33363277f, -0.27552435f, -0.14901024f, 0.16913125f, 
    -0.03982480f, -0.10291096f, -0.21095450f, 0.07001109f, 0.21474689f, 0.04043480f, 0.35796660f, 0.14192638f, 
    -0.00498594f, 0.27219278f, -0.14525129f, -0.13617504f, -0.03240573f, -0.11584010f, -0.77416676f, -0.23533705f, 
    0.24107318f, -0.20447314f, -0.21766503f, 0.60928023f, -0.28048033f, 0.02314216f, 0.38469276f, 0.13035443f, 
    0.46370533f, -0.05202734f, 0.18270871f, -0.13980751f, -0.09325603f, -0.10933318f, 0.16221747f, 0.03877391f, 
    0.01319806f, 0.00653479f, 0.08529459f, 0.16980733f, 0.00944523f, 0.01715173f, -0.58928913f, 0.24396741f, 
    -0.54312789f, -0.53860223f, -0.25116932f, 0.26122397f, 0.01226478f, 0.03065176f, 0.31756014f, 0.52212703f, 
    -0.07454615f, 0.15832795f, -0.02201408f, -0.27919614f, -0.32051450f, -0.17743587f, -0.01281623f, -0.04651104f, 
    0.02067428f, -0.29587558f, -0.10603789f, -0.22414853f, -0.17340218f, -0.20488189f, 0.08218683f, -0.15686661f, 
    -0.19466019f, 0.34536198f, 0.71246022f, 0.31042963f, 0.11441764f, 0.33074537f, -0.38325989f, 0.35466278f, 
    0.24537915f, 0.00287572f, 0.02105443f, -0.09618987f, -0.28241760f, -0.27701923f, -0.08634756f, 0.06018797f, 
    -0.31996512f, 0.02107497f, 0.21323252f, 0.10566933f, 0.30634993f, 0.02914899f, 0.11520585f, -0.00839149f, 
    0.61184371f, 0.57739794f, -0.16870348f, 0.18576996f, 0.43018654f, -0.51771587f, -0.18518656f, 0.02934508f, 
    0.16248126f, -0.20385449f, 0.10825871f, -0.11486201f, -0.23844098f, -0.04078174f, -0.21393174f, -0.18343844f, 
    -0.16651346f, 0.04903361f, 0.11480778f, 0.26748678f, 0.30732307f, 0.08426706f, -0.20319337f, 0.04028099f, 
    0.11279133f, 0.68635863f, 0.32058990f, 0.48813629f, 0.61417258f, 0.41458169f, -0.09934872f, 0.14017892f, 
    -0.16491623f, 0.31599692f, -0.24722232f, 0.04765112f, 0.15335514f, 0.13611986f, 0.20590882f, -0.10014550f, 
    0.23050581f, -0.22936510f, 0.15841977f, 0.01644618f, 0.04644501f, -0.36565864f, 0.09827555f, -0.13677453f, 
    0.28730398f, -0.16922270f, 0.35066351f, 0.46869627f, 0.46607283f, 0.22698680f, 0.03088433f, -0.30586314f, 
    0.09582447f, -0.09881034f, 0.08098166f, 0.40895313f, -0.39396438f, 0.02149533f, 0.15791199f, -0.21593711f, 
    0.02947881f, -0.04612906f, 0.03901441f, 0.03379989f, 0.12041178f, 0.19046456f, -0.17050731f, 0.22969815f, 
    0.16543244f, 0.37845930f, 0.20400731f, 0.01872778f, -0.05347605f, -0.14232674f, -0.71068692f, 0.28364605f, 
    0.34554809f, -0.61932749f, 0.13114132f, 0.24304372f, 0.02331019f, -0.06595898f, -0.45393276f, -0.15874018f, 
    0.19859585f, -0.05503269f, 0.03380369f, 0.19789945f, -0.07154983f, 0.13074389f, -0.36034164f, -0.08048519f, 
    0.29047856f, 0.39972767f, 0.28712124f, -0.02372042f, -0.51441038f, -0.21609849f, -0.40015087f, 0.19091085f, 
    0.21940151f, -0.79420096f, 0.37064683f, 0.52498388f, -0.50371259f, 0.13262533f, 0.02566677f, 0.15753700f, 
    0.03899201f, -0.08772813f, 0.14938179f, -0.25504586f, -0.21390611f, -0.00815066f, -0.17829023f, -0.17188284f, 
    0.05233528f, 0.01188085f, -0.24045064f, 0.12289581f, -0.20324929f, -0.33784759f, -0.83591211f, -0.42421663f, 
    0.18218477f, -0.29462662f, -0.38576901f, 0.39053074f, 0.54554045f, 0.18345642f, -0.05722180f, 0.36155608f, 
    -0.01149566f, 0.03505692f, 0.12874596f, -0.26359421f, -0.28118968f, -0.14177874f, 0.16706920f, 0.00583578f, 
    -0.03042352f, -0.18607713f, 0.04668910f, 0.29897529f, -0.09956845f, 0.14555533f, 0.13640396f, -0.80798465f, 
    0.32325098f, 0.50163692f, 0.33756036f, 0.21103586f, 0.60723168f, 0.16164184f, 0.00776852f, 0.24358691f, 
    -0.21575874f, -0.01567462f, -0.05780038f, 0.06166548f, -0.15836616f, -0.30123457f, -0.29789272f, -0.14865948f, 
    -0.10838541f, -0.25176501f, -0.01835760f, 0.12963621f, 0.01511405f, -0.18462309f, 0.14817803f, -0.30376518f, 
    -0.27638626f, -0.10734119f, -0.43645552f, -0.07531185f, -0.20294520f, -0.08995888f, 0.09382208f, 0.04281874f, 
    -0.27051759f, -0.37248197f, -0.05909098f, -0.17263527f, 0.04541364f, -0.42035231f, 0.18106432f, -0.14213954f, 
    0.35048407f, 0.10190030f, -0.21361472f, -0.26670474f, 0.23179325f, -0.28372747f, 0.20560662f, 0.28317478f, 
    -0.65693980f, -0.04842065f, 0.19898383f, -0.22394507f, -0.00522352f, -0.67603886f, -0.39557287f, -0.16841960f, 
    -0.22094409f, -0.17583680f, 0.03704192f, -0.00149826f, 0.14307286f, 0.23799407f, -0.22578165f, 0.10626385f, 
    -0.26971373f, -0.11197668f, 0.32174164f, -0.09482951f, 0.23563302f, -0.16589274f, 0.12706250f, 0.00364361f, 
    0.22261196f, -0.45446175f, -0.53252852f, -0.30950522f, 0.42911854f, 0.52888334f, -0.50729096f, 0.33728692f, 
    0.19462316f, 0.00553818f, -0.59514248f, 0.21082459f, -0.11310975f, -0.16236117f, 0.10763607f, 0.23541071f, 
    0.30375996f, 0.43311077f, -0.14305075f, -0.09786952f, 0.37265950f, -0.20188181f, 0.04645369f, -0.01192057f, 
    0.03806012f, -0.01699322f, 0.07053214f, -0.07288010f, 0.26938063f, 0.27637205f, 0.17054704f, 0.12632509f, 
    -0.68622524f, -0.64168888f, -0.46554309f, -0.46435428f, -0.20568906f, 0.52822268f, 0.25700396f, 0.08276854f, 
    -0.21631378f, 0.41423991f, 0.31628335f, -0.00161138f, -0.15912588f, 0.22729470f, 0.31949267f, 0.05105578f, 
    -0.03987242f, 0.03123750f, -0.00941897f, -0.31848696f, -0.63313693f, -0.27241674f, 0.57466477f, -0.20857048f, 
    -0.56029910f, 0.42017874f, 0.60284096f, -0.34086016f, 0.11874780f, 0.26104331f, -0.04493381f, 0.17479059f, 
    0.14914104f, 0.33441451f, 0.05209741f, 0.17335948f, 0.26578411f, -0.17516004f, -0.08373491f, 0.16265090f, 
    -0.28538787f, -0.02906302f, -0.03952239f, 0.03555441f, 0.03961601f, -0.23341693f, -0.52606934f, -0.39795497f, 
    -0.22360630f, -0.24473983f, -0.07367861f, 0.29992080f, 0.28391737f, 0.09609421f, -0.29048240f, -0.31149951f, 
    0.26037154f, -0.01211337f, 0.05844488f, -0.42039433f, -0.01385167f, -0.13461077f, -0.01898909f, -0.18893242f, 
    -0.23246762f, 0.00782967f, -0.13026460f, -0.04446810f, 0.07799069f, -0.53360605f, -0.18895096f, 0.38511118f, 
    0.62763578f, 0.29120168f, -0.11670645f, 0.26294729f, 0.11506207f, 0.21959305f, 0.47266006f, -0.40181467f, 
    -0.29057154f, -0.05354248f, -0.34147814f, -0.06416000f, -0.10254005f, -0.29915690f, -0.23660393f, 0.14037034f, 
    0.04971711f, 0.25471401f, 0.20657131f, -0.08206045f, -0.17378972f, -0.05005141f, -0.07465538f, -0.40606189f, 
    -0.54022872f, -0.33722329f, 0.06228013f, 0.05987502f, -0.61494976f, -0.09852469f, 0.35650259f, -0.13744926f, 
    -0.32831678f, 0.05342780f, 0.37953117f, -0.11796382f, -0.30510944f, 0.00963040f, 0.21596526f, 0.08940998f, 
    0.24871016f, 0.13941082f, 0.03118343f, -0.10583559f, 0.21089143f, 0.12973034f, -0.18446416f, 0.80361193f, 
    -0.62062246f, -0.68261164f, -0.65153390f, 0.45946121f, 0.17445384f, 0.18713216f, 0.16206075f, -0.07290740f, 
    0.32271138f, -0.47270826f, 0.02179411f, 0.07321468f, 0.15335864f, 0.21435405f, -0.20942824f, -0.35230935f, 
    -0.01351470f, -0.09512132f, -0.06214888f, -0.02581191f, 0.08762017f, 0.08160228f, 0.34391680f, -0.12853926f, 
    -0.36967036f, -0.46417695f, 0.03387441f, -0.28054935f, -0.34178969f, 0.56032956f, -0.09094580f, 0.23595373f, 
    0.21735059f, 0.06885757f, -0.28985548f, -0.36144626f, 0.06550607f, 0.23869449f, -0.03327041f, -0.26571479f, 
    -0.13996942f, -0.25180396f, -0.20410518f, 0.12431400f, 0.31974500f, 0.15376678f, -0.07563352f, 0.13822119f, 
    -0.24245018f, -0.54950196f, 0.00097448f, 0.35749111f, -0.00654951f, 0.27588734f, 0.24298407f, 0.39552909f, 
    0.19786164f, 0.33779064f, 0.49457014f, -0.17206229f, -0.14002857f, -0.29493240f, -0.21136621f, -0.10061028f, 
    0.19297861f, 0.01354608f, -0.20964077f, 0.29318917f, 0.11081661f, -0.29938349f, -0.05263875f, -0.15429480f, 
    -0.04281325f, -0.30456764f, 0.70791948f, 0.24028598f, 0.03433656f, -0.24805674f, 0.32807922f, 0.01034725f, 
    -0.55076230f, 0.14931166f, -0.04664542f, 0.30711690f, -0.01319344f, 0.32449695f, -0.18090555f, 0.28919244f, 
    -0.12970394f, -0.11893137f, -0.15226118f, 0.18102552f, -0.07395618f, -0.39254925f, 0.06075013f, -0.06589291f, 
    -0.24487618f, 0.13482860f, 0.28162524f, 0.52431637f, 0.42181700f, 0.29320407f, -0.16333058f, -0.31457585f, 
    0.31566665f, -0.15990932f, -0.01774660f, -0.06905097f, 0.13637136f, 0.42215806f, 0.36175951f, 0.22251357f, 
    0.14348163f, -0.19651636f, -0.04272392f, 0.20872056f, 0.15279114f, -0.10294951f, 0.50485700f, -0.11995427f, 
    0.30190387f, 0.20201574f, -0.06879774f, 0.41525400f, 0.35101625f, 0.15815724f, -0.12732019f, -0.08045309f, 
    -0.18916498f, -0.44057330f, -0.30136538f, -0.14437629f, 0.43058041f, -0.46570373f, -0.33522782f, -0.38013056f, 
    0.32528794f, 0.24565746f, -0.02970590f, -0.03557245f, -0.28351074f, 0.07172883f, 0.14635195f, 0.09126943f, 
    0.40248731f, -0.01735396f, 0.07774261f, -0.01846213f, 0.20086519f, -0.38918602f, -0.55226386f, -0.40267849f, 
    -0.22818747f, -0.15936908f, -0.24358299f, 0.39241704f, 0.69834167f, -0.19995183f, 0.09713104f, 0.10625778f, 
    0.18044487f, 0.34619662f, -0.29482669f, 0.12978563f, -0.36883613f, 0.20947398f, -0.13855149f, 0.20433080f, 
    -0.06877996f, 0.24449719f, -0.02610064f, 0.02471205f, -0.05993294f, 0.22710335f, -0.62212622f, 0.79505658f, 
    0.12154993f, -0.40409940f, 0.27868053f, -0.44797137f, 0.63963956f, 0.36466634f, -0.44014752f, -0.26776600f, 
    -0.29795727f, 0.20424566f, 0.07006347f, 0.11324352f, 0.09083874f, 0.17005366f, 0.00244257f, 0.34588164f, 
    -0.01968624f, -0.17833023f, -0.12158544f, 0.09494035f, -0.24224482f, 0.16640332f, 0.16253078f, -0.06424928f, 
    -0.18984801f, -0.30174485f, 0.34314752f, -0.22994529f, -0.49073538f, -0.39775607f, 0.17058836f, 0.34426332f, 
    -0.11749200f, -0.21727750f, -0.08201834f, 0.29264796f, -0.07424091f, -0.28988177f, 0.33616230f, -0.16266081f, 
    -0.27999321f, -0.09848783f, 0.34071302f, -0.16901138f, -0.01901081f, 0.35591656f, 0.07060084f, -0.18326470f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10835519f, 0.16713014f, 0.19697431f, 0.02567614f, 0.10860614f, 0.06514739f, 0.20072654f, -0.13248524f, 
    0.16519946f, -0.09177084f, 0.26179561f, 0.18316983f, 0.02168065f, 0.20453149f, 0.17678624f, 0.04748019f, 
    0.13586177f, 0.13761449f, 0.28640008f, 0.07492436f, -0.00068620f, 0.05576681f, 0.07256857f, 0.17977688f, 
    0.16121727f, 0.19895150f, -0.10063934f, -0.00563968f, -0.10110730f, 0.17730048f, 0.05031120f, -0.03007545f, 
    0.22255522f, 0.04821135f, 0.02359410f, 0.05522323f, 0.13995402f, 0.00739922f, 0.16811626f, 0.21381453f, 
    0.14566582f, 0.03073689f, 0.15805790f, 0.43558425f, 0.19348679f, 0.28818604f, -0.01266731f, -0.12522501f, 
    0.32635450f, 0.24351673f, 0.00658834f, 0.21509600f, 0.17981690f, 0.00794772f, 0.09078296f, 0.13944255f, 
    0.03649987f, 0.03622100f, 0.07573394f, -0.06038090f, 0.12770498f, 0.00604095f, 0.13177809f, 0.10993914f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02780249f, 0.00890758f, -0.00920249f, 0.01627755f, -0.00423647f, 0.01582760f, -0.01939527f, -0.02632557f, 
    0.00188639f, -0.01094218f, -0.01749790f, -0.04153201f, -0.03965634f, 0.00235699f, 0.00913892f, 0.00222894f, 
    -0.02048318f, 0.00900897f, -0.01255035f, -0.01855581f, -0.04021729f, -0.04079932f, 0.01684937f, 0.02263439f, 
    -0.01851979f, -0.03281691f, -0.02379877f, -0.00424834f, -0.01406630f, -0.02203845f, -0.02761392f, 0.02164673f, 
    -0.00187927f, -0.03192097f, 0.00212664f, 0.01134183f, 0.01793567f, 0.02148774f, 0.00619133f, 0.00998320f, 
    -0.01046764f, -0.00196420f, 0.00057301f, -0.00853937f, -0.01267668f, -0.03553989f, -0.03341739f, 0.01135504f, 
    -0.02880544f, 0.00169573f, -0.00421319f, 0.01329258f, -0.01984073f, -0.01356282f, -0.02794129f, -0.02857745f, 
    0.02449659f, 0.00640627f, -0.00603129f, 0.01253472f, -0.03955642f, 0.00042207f, 0.02553087f, -0.01286988f, 
    -0.01344487f, 0.02255192f, -0.00158020f, 0.01240985f, 0.00739460f, -0.04080401f, 0.00458237f, 0.01217736f, 
    -0.02810689f, -0.01649356f, -0.00611180f, -0.02068524f, -0.02000307f, -0.02866245f, -0.02525876f, 0.00443027f, 
    0.02705126f, 0.02027911f, -0.01080448f, 0.02292814f, -0.01544939f, -0.03595389f, -0.02947181f, -0.00124442f, 
    -0.01355678f, 0.00967877f, -0.01750836f, 0.02244386f, -0.02743880f, -0.01824134f, -0.03561049f, 0.02145594f, 
    -0.02295629f, 0.01078930f, -0.00818680f, -0.02362974f, 0.01511926f, 0.00920952f, -0.03837863f, 0.01281967f, 
    0.00433410f, 0.02594380f, -0.04146158f, -0.01295344f, 0.00872998f, -0.02769019f, 0.02614952f, -0.01781642f, 
    -0.03304148f, 0.00811898f, 0.00267878f, -0.02373842f, -0.01128678f, -0.02225548f, -0.01155490f, 0.01051047f, 
    0.00943125f, -0.00476986f, -0.01696145f, -0.03402820f, -0.03941975f, 0.00611801f, -0.03891913f, 0.01343181f, 
    -0.02018087f, 0.00759316f, 0.00741656f, -0.02116510f, 0.02184278f, 0.02067792f, 0.01373512f, -0.02641568f, 
    0.00120886f, -0.03816682f, -0.00280299f, 0.01886874f, -0.01551968f, -0.03335400f, -0.00763242f, -0.03809047f, 
    0.01697678f, -0.02100686f, -0.03832655f, 0.00365922f, -0.03202040f, 0.02351193f, -0.01852054f, -0.00514737f, 
    -0.00579205f, -0.03743829f, 0.00301065f, -0.00480491f, -0.00701212f, -0.02845493f, 0.00229997f, -0.03714750f, 
    -0.02278057f, 0.01285058f, -0.02792682f, -0.00568009f, -0.02078343f, 0.00159101f, -0.01015966f, 0.00606581f, 
    0.01781956f, 0.02638740f, -0.00116515f, -0.03536467f, 0.00670107f, -0.01707614f, 0.02191376f, -0.01851292f, 
    -0.00850895f, -0.01405705f, -0.02586684f, 0.01306952f, 0.00062920f, -0.03026714f, 0.02049376f, 0.02031264f, 
    0.02711795f, -0.03489728f, -0.01016652f, -0.01216255f, -0.02961227f, -0.02563628f, -0.00767266f, 0.01415182f, 
    0.01597920f, -0.01086657f, 0.02882396f, -0.03257950f, -0.00944335f, 0.00896874f, 0.02590596f, -0.02298505f, 
    0.02216150f, 0.02644121f, -0.02668694f, -0.02701040f, -0.00318899f, 0.00263257f, 0.02221272f, 0.02864907f, 
    -0.03597959f, -0.02423524f, -0.01830875f, -0.01179035f, -0.01100786f, 0.00439265f, -0.02270774f, -0.03356334f, 
    0.01682525f, -0.00027818f, 0.00636565f, 0.00684522f, 0.02353791f, -0.03527689f, 0.01052509f, -0.03440120f, 
    0.02163908f, -0.00596547f, 0.01716585f, -0.02091316f, -0.00607354f, -0.02560262f, -0.02294330f, 0.00395745f, 
    0.01461904f, -0.00239406f, 0.01388690f, -0.04123671f, 0.01687108f, 0.01174575f, -0.00457367f, 0.02334466f, 
    0.02232269f, -0.03195994f, 0.00366220f, -0.03722930f, -0.02257465f, 0.01282205f, -0.02987737f, -0.03978269f, 
    -0.01539260f, -0.02688549f, -0.00315129f, -0.03490673f, -0.00144909f, 0.00418365f, 0.01147067f, 0.02839323f, 
    -0.00745276f, -0.01933884f, -0.02812484f, 0.01363797f, -0.00100967f, -0.03285502f, 0.02489919f, -0.00325362f, 
    0.00842658f, -0.02196203f, -0.02631463f, -0.01515889f, -0.01462473f, -0.03772689f, -0.01161243f, 0.01152059f, 
    -0.00629752f, -0.03936477f, -0.01492919f, 0.00373728f, -0.00421854f, 0.00803935f, -0.03930233f, 0.01189628f, 
    0.01255186f, 0.01968244f, -0.03495400f, 0.02218813f, -0.01380621f, -0.03832379f, -0.03723134f, 0.00077781f, 
    -0.02571167f, 0.02263818f, 0.02464944f, -0.02530378f, -0.03757334f, -0.03200420f, -0.01111462f, -0.02786074f, 
    0.02193904f, 0.01485355f, 0.00584190f, 0.02631397f, 0.02774758f, -0.03939668f, 0.01112492f, -0.02652443f, 
    -0.04080493f, -0.03320163f, -0.01044053f, -0.00089729f, 0.00508369f, 0.02212482f, -0.04001622f, 0.00781560f, 
    -0.01030841f, -0.03085175f, -0.00352416f, -0.01661583f, -0.02901593f, -0.03545039f, 0.00026167f, 0.01816981f, 
    0.02541330f, -0.01573692f, -0.03963276f, 0.00187132f, 0.02236662f, -0.01788386f, 0.01276803f, -0.01243612f, 
    0.00897248f, -0.02560256f, 0.01395202f, -0.00694698f, -0.00894835f, 0.02883507f, 0.00712491f, -0.02112975f, 
    0.00422374f, 0.00890173f, 0.00636966f, -0.02289722f, 0.02853465f, -0.02645529f, -0.03049113f, -0.03113514f, 
    -0.00461450f, 0.01808336f, 0.01079831f, -0.01166212f, 0.01919919f, 0.02568391f, 0.00831924f, -0.03866088f, 
    0.00839271f, -0.03678079f, -0.01111768f, -0.01407648f, 0.02743236f, -0.02754296f, -0.00154252f, -0.01922823f, 
    -0.03976614f, -0.02292225f, 0.02009809f, 0.00726451f, 0.01716466f, 0.01348646f, -0.01063342f, -0.00192071f, 
    0.00333806f, 0.02886512f, -0.03515653f, -0.02934722f, 0.02372001f, -0.03290138f, 0.01056110f, -0.00272252f, 
    0.02755620f, -0.01355123f, 0.02438025f, -0.00625922f, -0.03050155f, 0.01666323f, -0.02966918f, 0.01713370f, 
    -0.02275830f, 0.02682705f, 0.02592573f, -0.03985804f, -0.00326915f, -0.02446691f, 0.01972123f, -0.01508042f, 
    -0.03648067f, 0.02054316f, -0.03711260f, 0.00718110f, -0.02995845f, 0.02860224f, 0.02545931f, -0.02187681f, 
    0.01766376f, -0.01180382f, -0.03481405f, -0.01214893f, 0.00616753f, -0.02426858f, -0.00176203f, -0.00501815f, 
    0.01177653f, 0.00332214f, -0.01320754f, -0.03199351f, -0.03148142f, -0.02910564f, 0.01409130f, 0.01768418f, 
    0.01710577f, -0.01212716f, -0.00520232f, 0.00982127f, 0.02726283f, -0.00484085f, -0.03265736f, -0.01840395f, 
    -0.02590690f, 0.01859744f, 0.01448404f, -0.02716275f, -0.03045951f, -0.02091760f, -0.00279262f, -0.03872648f, 
    0.01103005f, 0.00867824f, -0.00260576f, -0.04118541f, -0.03956575f, -0.04132191f, -0.01569759f, -0.01101696f, 
    -0.02551794f, 0.02924029f, -0.00747332f, 0.01048159f, -0.03767448f, -0.03593747f, -0.03716436f, -0.00676694f, 
    -0.00275063f, 0.01858154f, 0.00690995f, 0.01415254f, -0.03007921f, -0.00668683f, 0.00780836f, 0.00545244f, 
    0.02028881f, -0.01835211f, -0.02901893f, -0.01740263f, -0.00653457f, -0.00502522f, -0.00874524f, 0.01200544f, 
    -0.01926730f, 0.02294787f, 0.01860774f, -0.03426751f, -0.04007633f, -0.03177133f, -0.01395820f, 0.00386036f, 
    -0.01168278f, 0.01266035f, 0.00170463f, -0.03110025f, -0.03449072f, 0.01334469f, 0.02484388f, 0.01917512f, 
    0.00710893f, -0.01922930f, -0.00166984f, 0.00505854f, -0.03502654f, 0.02162440f, 0.00371504f, 0.00360525f, 
    -0.01694465f, 0.00709135f, -0.02932654f, -0.03675797f, -0.00469294f, 0.02415126f, 0.02488103f, 0.02954393f, 
    0.02434599f, 0.01502913f, 0.02047592f, 0.00395813f, 0.00485636f, 0.02359131f, 0.01270520f, -0.00817683f, 
    -0.00732768f, -0.02305881f, -0.00490801f, 0.01601026f, -0.00835431f, 0.02756568f, 0.01302343f, 0.01608257f, 
    0.00415694f, -0.03389092f, -0.02421661f, 0.02711888f, -0.03744962f, -0.01163481f, -0.03972135f, -0.03666174f, 
    -0.03280587f, -0.02364858f, 0.02638115f, 0.00941122f, 0.02190202f, 0.01319977f, -0.02114137f, -0.03884225f, 
    -0.03008482f, -0.01968937f, 0.01427037f, -0.02815746f, -0.03796490f, 0.01678303f, 0.00997167f, -0.02797818f, 
    0.01555502f, -0.01506101f, 0.01501756f, 0.01478752f, -0.03191859f, -0.03790311f, 0.01401893f, -0.04032193f, 
    -0.00539247f, 0.00215046f, 0.00370653f, 0.00621370f, 0.01489404f, -0.03121143f, -0.01958407f, 0.01328353f, 
    -0.03792085f, -0.02162770f, 0.02463454f, -0.00417504f, 0.01492000f, -0.02489470f, -0.01877638f, -0.02661410f, 
    0.00601099f, -0.03089358f, 0.01575227f, -0.00885286f, -0.00879850f, -0.02924858f, 0.02954534f, 0.01770996f, 
    -0.04086964f, -0.00569568f, -0.03786310f, -0.03820509f, 0.01998374f, -0.03291817f, -0.01503466f, -0.00252949f, 
    -0.00363721f, -0.02931617f, -0.01193499f, -0.00040372f, 0.01632432f, -0.00255899f, -0.02531814f, -0.01680107f, 
    -0.00042664f, -0.04022573f, 0.00204283f, -0.01824522f, -0.03642624f, 0.02549099f, 0.00159394f, -0.00782359f, 
    -0.03295524f, -0.01598640f, -0.00679642f, -0.04071311f, 0.00269928f, -0.04185371f, -0.00625172f, -0.03008554f, 
    -0.01191040f, -0.00878735f, -0.00364663f, -0.02530494f, 0.00037498f, -0.02867836f, -0.00984499f, -0.02865276f, 
    -0.00134614f, -0.02886920f, 0.00907689f, -0.01969656f, -0.00907363f, 0.02315861f, 0.02273859f, -0.01732535f, 
    -0.02615158f, -0.02828087f, 0.01608410f, -0.03756017f, 0.01566356f, 0.01517572f, -0.01753252f, -0.00489408f, 
    -0.03484102f, 0.02288411f, -0.01416293f, 0.02466386f, -0.01942305f, 0.01473391f, 0.02513992f, -0.02235910f, 
    -0.03157627f, -0.01381937f, -0.01661224f, -0.03690968f, 0.00795322f, -0.00810392f, -0.01495677f, 0.00077488f, 
    -0.03801855f, -0.02938748f, -0.02809637f, -0.00784795f, -0.03474908f, 0.02248574f, -0.01485705f, -0.04054604f, 
    -0.03335041f, 0.02715197f, 0.01810403f, -0.01999853f, 0.02778263f, 0.02403435f, -0.02499749f, -0.02112692f, 
    -0.02821824f, -0.03378880f, -0.00212783f, 0.02084600f, 0.01654569f, -0.01837379f, 0.01709495f, -0.02753757f, 
    0.02517265f, 0.01094260f, -0.03450217f, -0.01524938f, -0.02013945f, 0.01297747f, 0.01513931f, -0.02126285f, 
    -0.00617411f, -0.00399995f, -0.03273626f, -0.02007271f, -0.02037187f, 0.02684619f, -0.02263707f, -0.00391338f, 
    0.01151534f, -0.02687027f, -0.02961519f, 0.02010169f, 0.00225130f, 0.00646409f, 0.00942016f, 0.00443478f, 
    0.00680297f, -0.01391075f, 0.01948062f, 0.00623579f, -0.04029669f, 0.01124330f, 0.02822886f, -0.01622308f, 
    -0.02446733f, 0.02295780f, -0.02445604f, -0.00926439f, -0.00371935f, -0.01351520f, -0.03011923f, 0.02584153f, 
    0.02216749f, -0.03664620f, 0.01329933f, 0.00585459f, 0.01309882f, 0.00893493f, 0.02797200f, 0.01384848f, 
    -0.02961948f, -0.03992020f, -0.03894725f, 0.01722231f, -0.02552202f, 0.01185343f, 0.02534078f, -0.02142469f, 
    0.00426294f, -0.02680400f, 0.02747250f, -0.03691547f, 0.02184388f, -0.01910882f, -0.00835988f, -0.01290501f, 
    -0.00854835f, -0.01836820f, 0.02036890f, 0.00147447f, -0.03970201f, 0.00141732f, 0.00434311f, 0.02576469f, 
    0.01341996f, -0.01950400f, -0.03316895f, 0.02314105f, 0.02015376f, 0.01047106f, -0.01287413f, -0.01713907f, 
    -0.02970404f, -0.04197940f, -0.03348676f, -0.01446326f, -0.02024312f, 0.00129207f, 0.02018993f, 0.00325468f, 
    0.01452094f, -0.01589079f, 0.00735152f, 0.01201671f, -0.02434869f, 0.02449245f, 0.02689690f, 0.01567129f, 
    0.00292542f, 0.02182231f, 0.01450939f, -0.02880614f, -0.02633961f, -0.00475142f, 0.01312160f, 0.01211491f, 
    0.20601498f, 0.07867308f, -0.08217766f, -0.07868401f, 0.08150136f, -0.00355914f, 0.01649188f, -0.04739958f, 
    0.04178900f, -0.04900971f, -0.00085481f, 0.07952266f, 0.04122322f, -0.06405634f, -0.03505660f, 0.15651296f, 
    0.13057527f, 0.09740311f, -0.08192750f, 0.07353076f, 0.06489807f, 0.06905840f, -0.00003734f, 0.06209691f, 
    0.06735460f, -0.07705271f, -0.09684239f, 0.06820765f, 0.09782971f, 0.04068724f, 0.09141623f, -0.05283105f, 
    -0.00548710f, 0.12627991f, 0.03082285f, 0.09774469f, -0.18013169f, 0.12270853f, 0.12287040f, -0.09918945f, 
    0.07770404f, 0.00413632f, -0.00358024f, -0.05233903f, -0.10479596f, 0.07200119f, 0.01877614f, -0.05978025f, 
    -0.27815211f, -0.05767194f, 0.26868671f, 0.00164853f, -0.07473446f, 0.02987428f, 0.16180223f, -0.03719058f, 
    -0.04853972f, -0.09542059f, -0.01522919f, -0.00233369f, -0.05331439f, 0.03229856f, 0.12185087f, -0.00072495f, 
    0.03114655f, 0.07455669f, -0.00653677f, -0.02999414f, -0.00949772f, 0.03803262f, 0.00499464f, -0.08967140f, 
    0.13413319f, -0.32535923f, 0.02419789f, -0.03611083f, 0.00759271f, -0.01464315f, -0.00049344f, -0.03983476f, 
    -0.02198410f, -0.02407758f, 0.07839671f, 0.04969293f, -0.00264769f, -0.06964101f, -0.02777144f, 0.11740419f, 
    0.19585115f, 0.07722817f, -0.00543332f, 0.06780393f, -0.05112355f, -0.02691145f, 0.03892949f, 0.06945476f, 
    0.15380329f, -0.11112154f, 0.12784421f, 0.01593632f, 0.02671358f, 0.05578875f, -0.00599263f, 0.00327601f, 
    0.07906980f, 0.02813695f, -0.08060139f, 0.03371540f, -0.18094376f, 0.14581721f, 0.13281344f, -0.22121307f, 
    -0.10115615f, -0.01549221f, 0.07167386f, -0.08281506f, -0.02714578f, -0.07898406f, -0.06304887f, 0.07622977f, 
    -0.28217477f, 0.06209118f, 0.07930636f, 0.13570456f, 0.10678890f, -0.00881720f, 0.03003429f, 0.09255637f, 
    0.10581654f, -0.03201126f, 0.07427106f, -0.08205166f, 0.06355397f, 0.13478814f, -0.09703964f, -0.02462194f, 
    0.07815318f, 0.03632788f, -0.06910369f, -0.04537820f, -0.07934067f, 0.03776282f, 0.10805296f, 0.06904126f, 
    0.00611375f, -0.15803216f, -0.15301697f, -0.05065719f, 0.13733058f, 0.09485912f, 0.00349005f, 0.01873667f, 
    0.06030592f, 0.06376296f, 0.03571888f, -0.09067211f, -0.00835418f, 0.05011323f, 0.00919597f, 0.04414035f, 
    0.15948211f, -0.00390654f, -0.01913260f, 0.00155475f, 0.05744867f, -0.05335257f, 0.07210249f, 0.07833058f, 
    -0.15420026f, -0.01301235f, -0.01470079f, 0.20109056f, 0.01174813f, 0.03269041f, 0.03842391f, 0.03380978f, 
    -0.06201605f, 0.21050726f, -0.00572483f, 0.15311562f, -0.01152942f, -0.02185450f, 0.03123702f, 0.16643775f, 
    0.07032920f, -0.01770134f, 0.05080084f, -0.00806961f, -0.01799391f, -0.05353167f, 0.06907323f, -0.00342516f, 
    -0.01763451f, 0.07251128f, 0.13078502f, -0.19296579f, 0.02373947f, -0.06916285f, 0.01412645f, 0.05188278f, 
    -0.05842845f, -0.01899326f, -0.01174792f, 0.02852129f, -0.13065425f, -0.00417685f, -0.00769240f, -0.03055841f, 
    -0.05773828f, -0.06876564f, 0.04859365f, -0.04283906f, -0.18395627f, 0.13260148f, -0.04617883f, 0.01498034f, 
    -0.07173261f, -0.01557205f, 0.07030766f, -0.10898858f, -0.13879684f, -0.02068763f, -0.02436335f, -0.08928077f, 
    -0.01275306f, 0.01374788f, -0.00314439f, 0.22017236f, 0.04167360f, 0.05845622f, -0.11329138f, 0.02612583f, 
    -0.04888662f, -0.02481205f, 0.17100225f, 0.14254941f, 0.00504594f, -0.03040111f, -0.00598650f, 0.03974658f, 
    -0.28739032f, 0.12177323f, 0.06739905f, -0.08308910f, 0.19393256f, -0.09021288f, 0.07726401f, 0.02148300f, 
    0.03885774f, -0.06665837f, -0.02685623f, 0.01601486f, -0.14901477f, 0.17744319f, 0.21253049f, -0.04143490f, 
    0.03688534f, -0.01094024f, 0.06772357f, -0.05146304f, -0.02109198f, -0.00641867f, 0.02931824f, -0.04684051f, 
    -0.16261216f, 0.12983671f, 0.16085111f, -0.09939209f, 0.09567276f, 0.11811964f, -0.02904848f, 0.05367248f, 
    0.03279064f, 0.03066419f, 0.01307166f, -0.00076519f, 0.15792204f, 0.13514420f, 0.11251839f, 0.00136541f, 
    0.01490270f, 0.02508812f, 0.00499086f, -0.06754487f, 0.01934695f, 0.02957642f, -0.01649485f, 0.02521630f, 
    0.11292605f, -0.10419007f, 0.04761178f, 0.11081531f, 0.05468388f, 0.04209081f, -0.00163238f, 0.04285536f, 
    0.07884131f, -0.01547755f, -0.02656180f, -0.00060242f, 0.00950171f, -0.02568283f, 0.22578725f, 0.03792192f, 
    -0.02482651f, -0.00464095f, -0.08398324f, 0.00663645f, 0.14895657f, -0.08389754f, 0.12252406f, 0.01237731f, 
    -0.09299430f, 0.00894677f, 0.04581619f, 0.00973007f, 0.09501716f, 0.08546522f, 0.04742956f, 0.00451785f, 
    0.03553856f, 0.00271510f, -0.04641711f, 0.10686246f, -0.36551589f, 0.11305787f, 0.13451654f, -0.08497471f, 
    -0.05057281f, -0.00267527f, -0.01005718f, -0.15858090f, 0.01132482f, -0.01913629f, 0.01237551f, 0.04452008f, 
    -0.35946688f, 0.13344964f, -0.07373222f, -0.06667107f, -0.00864004f, 0.00382868f, 0.02448546f, 0.03951192f, 
    -0.16087633f, -0.04897778f, 0.03266659f, -0.04879992f, 0.23723030f, -0.08041003f, -0.12552312f, -0.10415381f, 
    -0.07212218f, -0.02575687f, -0.00505851f, -0.07933050f, 0.00016439f, 0.06617220f, 0.05077105f, 0.00306936f, 
    0.07587834f, 0.16237806f, 0.05402881f, 0.11436757f, 0.05254347f, -0.04359690f, -0.08865664f, -0.03451588f, 
    -0.06945903f, -0.11173245f, -0.04536451f, -0.03016258f, 0.07353231f, 0.13637401f, -0.13067646f, 0.14529897f, 
    -0.02918820f, 0.00970856f, -0.07742344f, 0.07694627f, 0.14206089f, 0.00596886f, -0.00039235f, 0.06983848f, 
    -0.40969390f, -0.13057789f, 0.03296223f, -0.08840960f, -0.03438257f, -0.02366071f, 0.04834142f, -0.03104886f, 
    -0.00470688f, -0.08686870f, -0.05890032f, 0.15946065f, -0.23889144f, 0.02195566f, 0.13440990f, -0.05837286f, 
    -0.00755323f, 0.06678703f, 0.11633535f, 0.05045354f, 0.07430342f, -0.04178490f, -0.04685959f, 0.04865476f, 
    0.25075084f, -0.01657832f, 0.13028964f, -0.14894331f, 0.05775444f, 0.04182368f, 0.07667335f, -0.00130527f, 
    0.01003685f, 0.05821072f, 0.11316878f, 0.00006448f, 0.18513355f, -0.06293903f, -0.15435222f, -0.00440834f, 
    0.02956868f, 0.01972078f, -0.04452825f, -0.00558044f, -0.06934992f, -0.02025167f, 0.05343145f, -0.03761622f, 
    -0.15402800f, 0.35902223f, -0.06308602f, -0.18420643f, 0.14487717f, -0.02827496f, 0.02400162f, 0.03055980f, 
    0.00460044f, -0.01043234f, 0.05021476f, 0.09864360f, -0.23203538f, -0.12088684f, 0.13897909f, -0.05340355f, 
    0.06061194f, 0.02334077f, 0.12772666f, 0.00503380f, 0.03000564f, 0.05956840f, 0.07709582f, 0.04856583f, 
    -0.10402112f, -0.28797987f, 0.09756510f, 0.13749346f, 0.03031703f, -0.01845988f, 0.06919473f, 0.13011859f, 
    -0.07130599f, -0.00681008f, 0.05556423f, 0.07517256f, -0.13634388f, 0.00578258f, 0.03739596f, -0.22577061f, 
    -0.00448669f, 0.06386279f, -0.02666726f, -0.05709145f, 0.03951174f, 0.04844734f, 0.00094264f, 0.01947746f, 
    -0.15647294f, -0.18677357f, 0.08588363f, 0.04648735f, -0.02950501f, -0.17590795f, 0.03891837f, -0.00811540f, 
    -0.04508130f, -0.11573862f, -0.01735332f, 0.06766742f, -0.11125972f, 0.15319337f, 0.06928867f, -0.10751794f, 
    0.05396286f, -0.04242824f, 0.06183025f, -0.09426998f, -0.10893310f, 0.00801129f, 0.07668764f, 0.13569738f, 
    0.03864234f, -0.03597218f, 0.14692861f, -0.10534653f, -0.05222712f, 0.06253981f, 0.10369938f, -0.01727251f, 
    0.00469240f, 0.06595108f, 0.09230684f, -0.01025765f, -0.03351004f, -0.03062573f, -0.06808319f, 0.22383291f, 
    0.00754770f, 0.03015765f, 0.04032860f, 0.07432409f, 0.03916781f, -0.04475921f, 0.09297015f, 0.09934244f, 
    0.24514684f, -0.24477829f, -0.01114818f, -0.06729271f, 0.01946004f, -0.01158294f, -0.00991737f, 0.06663281f, 
    -0.06775874f, 0.03066560f, 0.09214482f, -0.15843670f, -0.10637347f, -0.09149611f, -0.03850695f, 0.14811541f, 
    0.09962986f, 0.03598749f, -0.00254898f, -0.00874209f, -0.10456523f, -0.01852794f, 0.11430444f, 0.04937131f, 
    0.08192299f, 0.03507301f, 0.01390620f, -0.16590893f, 0.06432781f, -0.00406320f, 0.03055136f, 0.06347916f, 
    0.00802655f, -0.08057781f, -0.00912637f, -0.02736815f, 0.06285620f, -0.13503130f, 0.03923091f, 0.10279571f, 
    0.17219809f, 0.14722262f, 0.05677653f, 0.11960617f, 0.00783962f, 0.07953294f, 0.03610833f, 0.11913233f, 
    0.20202178f, -0.21803775f, -0.00180902f, 0.00811315f, 0.08513043f, -0.00691939f, 0.03421600f, -0.03112902f, 
    -0.01374149f, 0.04325258f, 0.04367251f, 0.07410530f, 0.22241059f, -0.13472173f, -0.20690969f, -0.02681784f, 
    -0.01421087f, 0.04739144f, 0.06514289f, 0.00361159f, 0.03985867f, 0.07947570f, 0.09605329f, 0.14567320f, 
    -0.17303330f, 0.25130990f, -0.01484676f, -0.22077630f, -0.09971462f, 0.04719651f, -0.06009776f, 0.02174733f, 
    -0.00392595f, 0.06374393f, 0.11527505f, 0.10252101f, 0.21895982f, -0.07715829f, -0.11245816f, 0.00077835f, 
    0.12466883f, -0.01720634f, -0.02432060f, 0.07330389f, 0.00569195f, 0.00700343f, 0.01402924f, 0.05373679f, 
    -0.01850853f, -0.09102947f, 0.02179576f, 0.17720622f, 0.10232295f, 0.03727359f, 0.03235099f, 0.15532522f, 
    -0.12195566f, -0.02811263f, -0.04441617f, -0.06370390f, 0.17639443f, -0.12763864f, 0.01312124f, -0.08871435f, 
    0.01743358f, -0.00561024f, 0.04998654f, 0.02437284f, 0.00440987f, 0.01391178f, 0.02265107f, 0.02616827f, 
    -0.19755587f, -0.09934578f, -0.02620506f, 0.09864449f, 0.00797286f, 0.06793825f, -0.04961182f, -0.01896223f, 
    0.08292691f, -0.04463604f, 0.09616929f, -0.01780496f, -0.07341870f, -0.11401954f, -0.05076825f, 0.23141110f, 
    -0.13992447f, 0.09405471f, -0.08982672f, 0.01847687f, 0.06489948f, -0.05310662f, 0.03785902f, 0.02895250f, 
    0.02119104f, 0.07071581f, -0.08181387f, 0.04002542f, 0.10459486f, -0.10394873f, 0.07282545f, -0.10737669f, 
    0.03290202f, 0.01808840f, 0.05266923f, 0.05160654f, 0.22320919f, -0.09743480f, -0.01957563f, -0.06165812f, 
    0.10254558f, 0.02247583f, 0.07956913f, -0.01452825f, -0.02085946f, -0.04969295f, 0.06055075f, 0.00899457f, 
    -0.03113192f, 0.14401609f, 0.09533291f, -0.03414362f, 0.01106372f, 0.08968170f, -0.03086917f, -0.05088417f, 
    -0.11729795f, -0.09269790f, 0.10299417f, -0.00865916f, -0.07962921f, 0.24361886f, 0.05483380f, -0.04564480f, 
    -0.12696710f, 0.09365004f, 0.08435522f, -0.08591946f, 0.03326428f, -0.09729342f, 0.01597976f, -0.00806522f, 
    -0.14525449f, -0.25083429f, 0.10232431f, 0.13597861f, 0.05208380f, -0.05039484f, 0.05046961f, 0.07642984f, 
    0.07836515f, -0.00267234f, 0.01362667f, 0.00751384f, 0.06568102f, -0.05443447f, -0.06251820f, 0.12055857f, 
    0.08954877f, 0.02837008f, -0.09797762f, 0.07101642f, -0.05388051f, 0.01002652f, 0.10255357f, 0.00185089f, 
    0.46521848f, -0.26650456f, -0.08483903f, 0.11251788f, 0.00788110f, 0.10973647f, 0.01963814f, -0.03001636f, 
    0.10753509f, 0.06118546f, 0.00999617f, 0.01139474f, -0.10714459f, -0.08620977f, 0.04736247f, 0.06159651f, 
    0.04758843f, 0.09567635f, 0.01507168f, 0.00880906f, 0.00919700f, 0.04696588f, 0.01332539f, -0.03918022f, 
    0.02524250f, 0.02330143f, -0.02228004f, 0.00355763f, 0.00877075f, -0.01334768f, -0.01141120f, 0.01891127f, 
    -0.04080329f, -0.03032248f, -0.03916926f, -0.03929113f, -0.04142184f, 0.01311453f, 0.00548791f, 0.02348444f, 
    -0.03797400f, -0.01378324f, 0.00654094f, -0.01946290f, 0.01904495f, 0.02139315f, 0.02128822f, -0.00971648f, 
    0.00808035f, 0.00800964f, 0.01466858f, 0.01913836f, -0.04553667f, -0.01727772f, -0.00506594f, 0.02924500f, 
    -0.00195723f, 0.02223776f, -0.00687829f, -0.02940260f, -0.03756440f, -0.00080319f, -0.03801279f, 0.03479359f, 
    -0.00958835f, -0.02249913f, -0.00023390f, -0.02720423f, 0.01956162f, 0.03566647f, -0.00148072f, -0.00464458f, 
    -0.04268749f, 0.01825525f, -0.02292732f, 0.01780901f, -0.02012055f, -0.01694291f, -0.01153100f, -0.02188531f, 
    0.00916229f, 0.01502404f, 0.00898727f, 0.01292338f, -0.01419473f, -0.03005019f, 0.02004067f, 0.00429342f, 
    0.00486007f, -0.00300099f, 0.00862919f, 0.02676621f, 0.03327391f, 0.02751456f, -0.01601246f, -0.01069011f, 
    0.00624964f, -0.02806426f, 0.02846346f, 0.03095277f, 0.01545574f, 0.02060627f, -0.00664393f, 0.00379187f, 
    -0.03126296f, -0.00010919f, 0.01321623f, -0.01631032f, -0.03289524f, -0.03495350f, 0.01412892f, -0.01733758f, 
    -0.04185594f, -0.01356479f, 0.02721446f, 0.00110108f, 0.02617730f, -0.00120028f, 0.00697804f, -0.02740024f, 
    -0.02973751f, -0.02319469f, 0.01056020f, 0.01153103f, 0.02785624f, 0.03225068f, 0.00076001f, 0.01326028f, 
    0.02188146f, -0.00948729f, -0.01868148f, -0.04478964f, 0.00906380f, 0.04358250f, 0.03536823f, 0.02039460f, 
    0.00961874f, -0.00733363f, -0.00258892f, 0.02329806f, 0.01290078f, -0.00811824f, 0.02955268f, 0.00538736f, 
    0.01545103f, 0.01151809f, -0.02584264f, 0.00819260f, -0.03344539f, 0.01225202f, 0.02644062f, 0.02364350f, 
    0.00193502f, 0.01666809f, -0.01976413f, -0.00908743f, 0.00190232f, -0.01721494f, 0.00296683f, -0.01022962f, 
    0.01651405f, -0.01921814f, 0.00562139f, -0.03058208f, 0.03102405f, 0.01532352f, 0.00726917f, 0.00070120f, 
    0.00404904f, -0.00816744f, 0.02042187f, 0.02241367f, 0.02124530f, -0.01927888f, 0.00025314f, 0.03049401f, 
    -0.00091886f, -0.02470042f, 0.00188185f, -0.01612188f, -0.01164729f, -0.03513580f, -0.03575871f, -0.00243470f, 
    0.01692417f, -0.03216935f, -0.01916698f, -0.03676525f, 0.02448153f, -0.00674027f, -0.01808547f, -0.01594941f, 
    0.03087824f, 0.01226265f, -0.03227901f, -0.00566960f, -0.03444629f, 0.00450881f, -0.02214615f, -0.00812423f, 
    -0.00104279f, 0.00703214f, 0.00129260f, -0.00599441f, 0.00072064f, 0.00518633f, 0.01085504f, -0.00045202f, 
    -0.01482417f, -0.02472392f, -0.02483909f, 0.00728264f, -0.02244330f, -0.03408122f, -0.02656472f, -0.03206966f, 
    0.01068259f, -0.03313424f, -0.01033471f, -0.01402733f, -0.02060892f, -0.03847750f, 0.00099207f, 0.02886158f, 
    -0.01412506f, -0.01728276f, -0.00551287f, -0.02745584f, -0.00612878f, 0.00234051f, -0.02805296f, -0.03555217f, 
    0.00515029f, -0.01409644f, -0.02155751f, -0.04202296f, -0.00527563f, -0.03166996f, -0.00394784f, 0.00279827f, 
    0.00108627f, 0.03268302f, -0.01149403f, -0.00707165f, -0.01751391f, -0.00117994f, -0.02991151f, -0.01274550f, 
    0.00407006f, 0.02314362f, -0.02041664f, -0.02247946f, 0.01614045f, 0.00344792f, 0.02830774f, 0.02244409f, 
    -0.00432018f, -0.02528733f, -0.02225917f, -0.01795789f, -0.03928429f, 0.03073883f, 0.02323624f, -0.01573853f, 
    -0.03517376f, -0.02220425f, -0.02066419f, 0.01107814f, 0.03141995f, 0.02922432f, -0.00555823f, 0.00332220f, 
    -0.01131337f, -0.01246979f, 0.02694297f, -0.03068178f, 0.02818954f, -0.00801158f, 0.01774458f, 0.02542041f, 
    -0.00462868f, -0.03264357f, -0.04055370f, -0.01750832f, -0.00415842f, -0.01264549f, -0.02786529f, -0.00874241f, 
    -0.00528758f, -0.04344017f, -0.00814756f, -0.00552631f, 0.01510421f, -0.00771768f, -0.01054362f, 0.01474980f, 
    0.01160904f, -0.00858815f, 0.02154026f, -0.02676619f, 0.02625109f, -0.01889165f, -0.00357409f, 0.01532876f, 
    0.02374795f, 0.01296297f, 0.01380934f, 0.02609526f, 0.00115669f, 0.00279314f, 0.00043642f, -0.02727872f, 
    -0.01724752f, -0.03555490f, 0.01559584f, -0.00564557f, 0.02977640f, 0.00328685f, -0.00677701f, 0.02748311f, 
    0.02020667f, -0.01193808f, -0.01165074f, -0.00536373f, 0.00152219f, 0.02164125f, 0.03863468f, -0.01988909f, 
    0.00379943f, 0.00815604f, -0.01480982f, -0.01106499f, -0.00417245f, 0.02133285f, 0.00858435f, -0.00169095f, 
    0.01058836f, -0.02458777f, 0.00512532f, 0.02474634f, 0.02438104f, -0.00393381f, -0.01764860f, 0.01661904f, 
    -0.01824520f, 0.00921392f, -0.00080209f, 0.03001892f, 0.00588421f, -0.00838551f, 0.02454463f, 0.01689744f, 
    -0.01988229f, -0.03539223f, -0.01006158f, -0.01381383f, -0.00576562f, 0.01695702f, 0.02775933f, -0.00272127f, 
    -0.03047926f, -0.02722078f, 0.00965266f, -0.00031144f, -0.00941328f, -0.01257661f, -0.03683909f, -0.02776442f, 
    -0.00820461f, -0.03771138f, -0.04564384f, -0.02832326f, 0.02509749f, -0.01587639f, 0.00094634f, -0.01269169f, 
    -0.02356887f, -0.03446996f, -0.02190714f, -0.03540267f, 0.01058056f, 0.03323737f, 0.02231858f, -0.01179046f, 
    -0.02178090f, 0.02592645f, 0.02241059f, 0.01053293f, -0.00293916f, 0.02526179f, 0.00263269f, -0.02108704f, 
    -0.02739112f, 0.01465894f, 0.01624464f, -0.02577936f, 0.00203288f, -0.03544125f, 0.00542997f, 0.00062377f, 
    0.01574162f, 0.00865621f, -0.00874301f, 0.02371691f, -0.03085189f, -0.03398913f, -0.00821942f, 0.02528688f, 
    -0.01878133f, 0.01030619f, -0.00116100f, 0.03023608f, -0.02280686f, 0.01298556f, -0.01857994f, 0.01938675f, 
    -0.03857878f, -0.00501091f, -0.00252635f, -0.02401048f, 0.02328621f, -0.02878587f, 0.02698860f, 0.03365668f, 
    0.00998786f, -0.01396999f, -0.01824663f, -0.02395390f, 0.01325635f, -0.01173749f, -0.01383121f, 0.03034486f, 
    0.02324445f, 0.01997680f, 0.00015042f, -0.03832620f, -0.02968609f, -0.01291332f, -0.00380112f, -0.01876057f, 
    -0.01519748f, -0.01147675f, -0.02756353f, 0.00359820f, -0.03676398f, -0.01443793f, 0.02742111f, -0.02151731f, 
    0.00392614f, -0.01672632f, 0.02757331f, -0.02288402f, 0.01290655f, -0.02473084f, 0.01222154f, -0.03344285f, 
    -0.01332558f, 0.00937924f, -0.03225360f, -0.02357088f, -0.00912842f, 0.02911679f, -0.00866945f, -0.01021850f, 
    -0.00874557f, -0.03947070f, 0.01189430f, 0.01140893f, 0.03365372f, -0.00136764f, 0.02134799f, -0.02484508f, 
    0.02362298f, -0.02455802f, 0.01139640f, -0.01590363f, -0.02221691f, -0.01095765f, 0.02335321f, -0.00359601f, 
    -0.01148988f, -0.00230315f, -0.03074790f, 0.00742900f, -0.02846629f, 0.01161703f, 0.01467254f, -0.01567411f, 
    -0.00250829f, -0.03478327f, -0.03920989f, -0.02366830f, 0.03288464f, -0.02216217f, 0.03038569f, 0.02236424f, 
    -0.01768102f, 0.00404313f, 0.00575831f, 0.03510677f, 0.03086690f, 0.03212542f, -0.02851981f, 0.02862811f, 
    -0.02774923f, 0.01852597f, -0.00567878f, -0.00123526f, -0.02556280f, 0.00071735f, -0.01828215f, 0.02240633f, 
    -0.03003426f, 0.00047679f, -0.04062719f, 0.00479652f, -0.00366810f, 0.02787420f, 0.03358183f, -0.00319058f, 
    0.02057837f, 0.00312935f, 0.01345524f, -0.01288129f, -0.03005384f, 0.02209913f, 0.01152498f, 0.02348110f, 
    -0.01582560f, 0.00248587f, -0.00228092f, 0.03122931f, -0.02616316f, 0.02974970f, -0.00468271f, -0.01357168f, 
    -0.03519721f, 0.01837503f, 0.00295206f, 0.00871024f, 0.02372904f, -0.00029152f, 0.00631349f, -0.02106092f, 
    -0.01420186f, 0.01912069f, -0.01938059f, -0.04033716f, -0.00529982f, 0.01214896f, 0.00277731f, -0.03865591f, 
    -0.03343351f, -0.03746363f, 0.02011904f, 0.01257236f, 0.01062345f, -0.00130408f, 0.00214506f, 0.02321045f, 
    0.01278845f, -0.02428703f, 0.02236788f, -0.01513482f, -0.02092529f, -0.00528318f, -0.00912003f, 0.00713117f, 
    -0.01701544f, -0.00526588f, 0.00931101f, -0.00180326f, -0.00563412f, -0.00704411f, -0.01065248f, 0.00213670f, 
    0.01930418f, -0.02292679f, -0.00935441f, 0.02138302f, -0.02969096f, -0.01374511f, -0.01184319f, 0.04138998f, 
    0.00302663f, -0.00825357f, -0.03802911f, -0.04657372f, -0.03124652f, -0.04144917f, -0.04601358f, -0.00861696f, 
    -0.00315805f, 0.00878432f, -0.04187513f, -0.00742866f, -0.00244707f, 0.00663127f, 0.00110185f, -0.00127622f, 
    -0.02877121f, 0.02238668f, -0.00924988f, -0.01576113f, -0.00953946f, -0.03222385f, -0.02983169f, -0.00040613f, 
    -0.02203767f, 0.01428905f, 0.01896169f, -0.01092108f, -0.01962208f, 0.03282249f, 0.00715143f, 0.00968464f, 
    0.02848789f, 0.00903798f, -0.01976996f, 0.02158341f, -0.03449869f, 0.03993081f, -0.02766127f, 0.00952303f, 
    0.02777601f, -0.00376265f, 0.03191103f, -0.03857917f, -0.01359261f, 0.00598935f, -0.01874880f, 0.00657642f, 
    -0.03628043f, 0.03970629f, -0.00912677f, -0.00218631f, 0.02174323f, -0.00220465f, -0.00633250f, -0.01471409f, 
    -0.00066260f, -0.00759913f, -0.01483290f, 0.01608894f, 0.02925386f, 0.01059505f, 0.02635689f, -0.00280066f, 
    -0.03695913f, 0.01778093f, 0.01287063f, -0.01615016f, -0.04270868f, -0.03195094f, -0.02851066f, -0.02763679f, 
    -0.01506871f, -0.01688107f, -0.00144144f, -0.03851270f, 0.00048332f, 0.02189323f, -0.02315659f, 0.01995679f, 
    -0.01146986f, 0.02091184f, -0.04423311f, -0.01445309f, -0.03589177f, 0.01158373f, -0.03875941f, 0.02082778f, 
    0.00328859f, -0.00355349f, 0.00618024f, 0.00483967f, -0.00701234f, -0.01610424f, 0.01801335f, 0.01647845f, 
    0.01912685f, 0.02693061f, 0.02713968f, 0.00092674f, -0.02634036f, -0.03655317f, 0.00680747f, -0.02586975f, 
    0.00805918f, 0.03212229f, -0.01384680f, 0.02205689f, -0.00902995f, -0.00902872f, -0.02939837f, -0.03347460f, 
    -0.00754494f, 0.01561252f, -0.00844638f, 0.03140512f, -0.02092354f, 0.00865197f, 0.00768272f, -0.01402473f, 
    0.00086245f, -0.03613764f, 0.00504823f, 0.01023244f, -0.03235004f, 0.00128825f, 0.01175960f, -0.02603936f, 
    -0.02680269f, -0.01007955f, 0.02173159f, 0.01510303f, 0.00687097f, -0.02724890f, -0.00070104f, 0.02092784f, 
    0.02627639f, -0.01018475f, 0.00393708f, 0.00858191f, -0.02911579f, -0.00145227f, 0.00997199f, 0.02481111f, 
    0.02150743f, -0.01715995f, -0.02780605f, -0.00883243f, -0.02376426f, -0.00613351f, 0.01548051f, 0.02274395f, 
    0.01839097f, 0.00340680f, 0.00773769f, 0.02276961f, 0.02567265f, -0.01076151f, 0.02183261f, 0.01505036f, 
    -0.00338666f, -0.02279846f, -0.00134152f, 0.01015521f, 0.00503276f, -0.01090515f, -0.00028606f, 0.00123894f, 
    0.02188768f, -0.01787443f, 0.01976132f, -0.03958733f, 0.01005305f, -0.02017244f, 0.02817472f, -0.01302170f, 
    -0.00684721f, 0.01049925f, -0.01263643f, 0.02968208f, -0.01599386f, -0.00203797f, -0.01811485f, -0.00917520f, 
    -0.01759687f, 0.02524879f, -0.01046411f, 0.01434691f, -0.02995502f, -0.02540983f, -0.01052324f, 0.01381120f, 
    -0.02778066f, -0.01133363f, 0.01145802f, 0.02152058f, -0.01220438f, -0.00799274f, 0.00727322f, -0.03199748f, 
    -0.00453265f, -0.00051019f, -0.01753862f, 0.00189863f, 0.00053247f, -0.01178465f, 0.02891383f, 0.01013086f, 
    0.03164880f, 0.03328801f, -0.02415150f, 0.00123397f, -0.01930557f, 0.00686851f, -0.00465070f, 0.01635095f, 
    -0.02153620f, 0.02256088f, -0.01600825f, 0.02531111f, -0.00468723f, 0.03130838f, -0.01134175f, 0.01370729f, 
    0.01343166f, 0.02521330f, -0.01705652f, 0.01255357f, -0.04040919f, 0.02161499f, -0.00755894f, -0.01240560f, 
    -0.01834996f, 0.02678686f, 0.02293411f, 0.01413735f, -0.01264274f, -0.02029099f, -0.00386003f, 0.01462588f, 
    -0.03011976f, -0.03458826f, 0.01827740f, 0.00451710f, -0.00426793f, 0.02271762f, 0.03709999f, 0.01119287f, 
    -0.03356402f, -0.03710268f, 0.00058782f, 0.03520247f, 0.00722181f, -0.00462036f, -0.03852041f, 0.00455350f, 
    0.03106517f, -0.01468218f, 0.03007883f, -0.00853905f, -0.01845392f, -0.01136458f, 0.02175400f, 0.03780171f, 
    0.01082328f, 0.02697587f, -0.02297118f, -0.03818476f, -0.00720798f, 0.01651262f, -0.00692146f, -0.01193209f, 
    -0.02536768f, -0.02923788f, -0.01655892f, -0.02188230f, -0.01387826f, -0.01788993f, -0.00668429f, 0.01500528f, 
    -0.00605392f, -0.03599575f, 0.00701333f, -0.00878747f, 0.02894720f, 0.02093359f, -0.00960551f, -0.00594203f, 
    0.02954336f, 0.03182089f, 0.00787642f, -0.01615832f, -0.00627990f, -0.00278781f, -0.00196812f, 0.03424902f, 
    0.01442697f, -0.03405916f, 0.03186529f, -0.01825213f, 0.00986645f, -0.01822179f, -0.01180600f, 0.00044685f, 
    0.00815755f, -0.02101583f, -0.02626238f, -0.02858410f, 0.01141773f, -0.02719049f, 0.01551910f, -0.02077243f, 
    -0.00601478f, 0.00755680f, -0.01266751f, -0.00829143f, 0.00834826f, -0.03626593f, 0.00368213f, -0.02668685f, 
    -0.03011145f, 0.01979828f, -0.00845208f, -0.02735246f, -0.03021577f, 0.01214907f, 0.02272058f, -0.02530140f, 
    -0.00368544f, 0.01454263f, 0.02512892f, -0.00069101f, 0.02901381f, -0.02160290f, -0.02347233f, -0.01290504f, 
    0.00254138f, -0.01478908f, 0.00754656f, -0.03160809f, 0.03030983f, 0.02649632f, -0.00885429f, 0.02393134f, 
    0.01267746f, 0.01102359f, -0.01984652f, -0.00948751f, -0.01038598f, 0.02958989f, -0.02676993f, 0.02344410f, 
    0.00859135f, -0.01375065f, -0.01552497f, 0.00791581f, -0.00071571f, -0.00326280f, 0.01051269f, -0.03357981f, 
    -0.02098066f, 0.02799492f, -0.03524197f, -0.02354123f, 0.01432196f, 0.02260483f, 0.02710717f, 0.00854456f, 
    0.01609087f, 0.01675592f, 0.01733856f, -0.03860784f, -0.04449937f, -0.00237175f, 0.00000632f, 0.01787062f, 
    0.00130705f, 0.00117558f, -0.02473921f, 0.02549925f, -0.01401241f, 0.01055352f, -0.02942418f, 0.02141530f, 
    -0.00013039f, -0.02536887f, 0.00145358f, -0.00398948f, -0.01309930f, 0.02505035f, -0.01704238f, 0.01333821f, 
    0.00326568f, 0.02560098f, -0.03613291f, -0.01403250f, -0.00304770f, -0.00382723f, -0.03086876f, -0.00837169f, 
    0.03110189f, -0.00504695f, 0.03367708f, -0.01522640f, -0.02192825f, 0.00409368f, -0.03441349f, -0.01906595f, 
    -0.01460780f, 0.01265560f, 0.02883487f, -0.00876668f, 0.00367998f, -0.00681640f, -0.01269261f, -0.03555055f, 
    -0.01275221f, -0.03631197f, -0.01376912f, 0.00434397f, -0.03724998f, -0.01139238f, -0.00377812f, 0.02526436f, 
    -0.01517719f, -0.04129029f, -0.03786764f, 0.00655528f, -0.01541700f, -0.00748861f, 0.01517934f, 0.00032766f, 
    -0.02864285f, 0.02531569f, -0.02755518f, 0.01138377f, -0.00743198f, -0.00562886f, -0.04496666f, 0.03227770f, 
    0.00834222f, 0.00189490f, 0.02782967f, -0.01009453f, 0.00091576f, -0.03304667f, 0.03325986f, -0.03070072f, 
    -0.00155769f, -0.00365132f, 0.00356456f, -0.03338332f, -0.03824096f, -0.03000585f, -0.01279241f, 0.03263613f, 
    0.02476259f, -0.02187105f, -0.00505147f, -0.03152610f, 0.00441759f, -0.03283576f, -0.02178055f, 0.02800684f, 
    -0.01978039f, 0.00950693f, 0.00644233f, -0.00244648f, -0.01457058f, 0.02072078f, 0.00267294f, -0.00855958f, 
    -0.02821062f, -0.01092845f, -0.00274382f, -0.02968081f, -0.01280660f, -0.00996080f, 0.02412735f, -0.03355363f, 
    0.01073871f, -0.03663287f, 0.02218242f, 0.00034926f, -0.03161615f, 0.00362037f, 0.00119519f, -0.02112585f, 
    -0.00747229f, 0.02318107f, 0.00890049f, -0.02171182f, 0.03085658f, -0.02723414f, -0.01420566f, 0.00404368f, 
    -0.01448292f, 0.03284743f, 0.01763394f, -0.02463453f, -0.02981844f, 0.01730090f, 0.02316491f, -0.02679489f, 
    0.03336574f, 0.02993635f, 0.01751077f, -0.00406520f, 0.02111340f, -0.00312269f, -0.00692571f, -0.01137816f, 
    -0.03006518f, 0.03720135f, -0.01733761f, 0.01272327f, -0.01050146f, 0.01181946f, -0.00453625f, -0.01410093f, 
    -0.02885056f, -0.03176428f, -0.00381496f, -0.03903862f, 0.03791319f, 0.01814139f, 0.02787120f, 0.03609103f, 
    0.02406783f, 0.00227689f, -0.01224111f, -0.03738114f, -0.03605701f, 0.04233519f, 0.02075145f, -0.02936890f, 
    -0.00041615f, 0.03017321f, -0.02483508f, -0.03249340f, 0.00209526f, -0.03542185f, -0.01189939f, 0.01335680f, 
    -0.00432265f, 0.01490044f, -0.01109788f, -0.02851141f, 0.03463843f, -0.00726193f, 0.01821697f, 0.02684771f, 
    0.02769067f, 0.02291051f, -0.01517561f, 0.01874502f, 0.02902015f, -0.02450906f, -0.00404141f, -0.00155554f, 
    -0.02302220f, -0.02787031f, -0.02292609f, -0.02321760f, -0.01655109f, 0.02897192f, 0.01080937f, -0.02555321f, 
    -0.00629049f, 0.03185365f, 0.03007085f, 0.02557115f, 0.00025282f, -0.01825315f, -0.00722443f, -0.02331404f, 
    -0.00432113f, -0.00114480f, -0.01136890f, -0.00237872f, -0.01045506f, -0.01078148f, 0.01939283f, -0.00058775f, 
    0.00729972f, 0.01226878f, -0.02904304f, 0.00166151f, 0.02747578f, 0.01274085f, -0.03083504f, 0.00014995f, 
    -0.00784901f, -0.02265508f, -0.03089863f, -0.01431763f, 0.02853575f, 0.02437973f, -0.00697077f, -0.03222542f, 
    0.01269757f, -0.02423678f, -0.02426241f, -0.02157106f, -0.01562050f, 0.03500655f, 0.02121506f, -0.02024916f, 
    0.01716819f, 0.01707615f, -0.01983665f, -0.01018945f, 0.00018253f, -0.02580084f, -0.02166286f, 0.01339940f, 
    -0.00038690f, -0.02133809f, -0.00933307f, -0.02634324f, 0.02284481f, -0.03684263f, 0.01957849f, 0.02661556f, 
    0.02205059f, -0.03842030f, -0.00441420f, 0.02960204f, -0.02212772f, -0.00367759f, -0.02747264f, -0.02385366f, 
    -0.00869347f, 0.03003763f, 0.02162845f, 0.01105181f, 0.00508044f, 0.03022073f, 0.03679889f, -0.00836890f, 
    0.00321047f, -0.01693049f, -0.01197888f, 0.02043113f, 0.02641159f, 0.03406625f, 0.00072377f, -0.01473332f, 
    -0.03022881f, -0.00628569f, -0.00813310f, 0.02671427f, -0.01479642f, -0.02051836f, 0.02911331f, 0.04494718f, 
    0.02911638f, -0.02767859f, 0.01834066f, 0.03335902f, -0.00257885f, -0.00306450f, -0.01597540f, -0.02535482f, 
    -0.00571894f, 0.01414513f, -0.01831262f, -0.01975214f, -0.02100580f, -0.01861391f, -0.00113814f, -0.03814249f, 
    0.00237579f, 0.00525202f, -0.02894166f, -0.04091980f, -0.01865098f, 0.01454199f, -0.03332341f, 0.02094586f, 
    0.00182644f, 0.02804051f, -0.01869780f, -0.03706698f, -0.02097700f, -0.03681565f, 0.00232558f, 0.00280576f, 
    -0.02723981f, 0.02270088f, 0.00255275f, 0.02321882f, -0.00846583f, -0.02704347f, 0.02836798f, -0.03967273f, 
    -0.01163944f, -0.02003752f, -0.03327260f, 0.02709547f, 0.01344717f, -0.03628092f, 0.01585674f, 0.00214519f, 
    -0.01963387f, 0.03187130f, 0.02469205f, -0.03025371f, 0.01995243f, 0.02282069f, -0.00946850f, 0.01378511f, 
    -0.02914088f, -0.01107041f, -0.02458662f, -0.03561228f, 0.00576866f, 0.00100366f, 0.03336156f, -0.01822219f, 
    0.00721621f, -0.01359388f, -0.03665458f, -0.00799699f, 0.02427751f, 0.00050377f, 0.01316797f, -0.02455039f, 
    0.01822339f, -0.00037117f, -0.01649191f, -0.02411302f, 0.01400296f, -0.03580967f, 0.02289936f, -0.00655099f, 
    0.02891693f, -0.03651271f, 0.02791067f, -0.03153087f, -0.00982473f, 0.03118106f, 0.02912413f, -0.03683015f, 
    0.03740139f, -0.00233290f, 0.00260034f, -0.01581422f, 0.00486243f, -0.01169238f, -0.00884695f, -0.02958213f, 
    -0.01493159f, 0.03313334f, 0.00309931f, -0.03403255f, -0.01628638f, 0.00546799f, -0.03610673f, -0.00062213f, 
    0.00263112f, 0.00435037f, 0.01314875f, -0.02761720f, -0.00849704f, -0.00289116f, -0.02492383f, 0.02920213f, 
    0.03357941f, -0.01263628f, -0.03264425f, -0.02933586f, 0.01787433f, -0.03255106f, -0.02459323f, -0.03305060f, 
    0.02352320f, -0.01125252f, 0.01626573f, 0.00648581f, -0.03170470f, -0.02708604f, 0.01101428f, -0.02436730f, 
    0.01359931f, 0.00689634f, -0.00699274f, -0.03597870f, -0.03207818f, 0.01506414f, 0.03265291f, -0.03032184f, 
    0.03678854f, 0.00547624f, 0.02364936f, -0.00928176f, -0.02365998f, 0.02333878f, -0.01454143f, 0.00791800f, 
    0.01874283f, -0.02422732f, 0.03300653f, 0.00700006f, 0.00546114f, 0.00065220f, 0.00439928f, 0.02545485f, 
    -0.02185986f, 0.01414798f, -0.00699611f, 0.02137249f, -0.01900811f, 0.00782023f, -0.02455444f, -0.02764323f, 
    -0.00642082f, -0.01468245f, 0.00681310f, -0.03428662f, 0.00690994f, 0.02627890f, 0.03422169f, -0.01821789f, 
    0.00813755f, 0.03308782f, -0.01223382f, 0.02117242f, -0.01347865f, -0.02473522f, -0.02344680f, 0.00157012f, 
    0.02181770f, -0.01832070f, -0.02759054f, 0.02106595f, 0.01162207f, 0.02114303f, -0.02264995f, -0.01426445f, 
    -0.01234653f, 0.00991362f, -0.04032227f, -0.00429684f, -0.00613892f, -0.01890162f, -0.03173444f, 0.01124779f, 
    0.00433360f, 0.03306589f, -0.00655560f, 0.01023834f, -0.03048122f, -0.01935129f, -0.00497805f, 0.01223433f, 
    -0.01129609f, -0.02159471f, 0.00907243f, 0.03217208f, 0.03746369f, 0.01050791f, 0.02347487f, 0.01238823f, 
    -0.03661852f, 0.03203064f, 0.01521977f, -0.00417535f, -0.03901558f, -0.00358080f, 0.01507417f, 0.03178096f, 
    0.01385001f, -0.00524321f, -0.03974552f, -0.02120527f, 0.01660394f, -0.00497131f, -0.02079517f, -0.02614010f, 
    0.02050806f, 0.01519444f, 0.00580839f, -0.01248165f, -0.03424627f, 0.03591710f, 0.02648819f, -0.03440319f, 
    -0.00164538f, 0.00150130f, -0.04066762f, -0.03811842f, -0.03662325f, -0.00360100f, -0.01006056f, -0.01938367f, 
    -0.00958086f, 0.02089855f, -0.00572920f, 0.02190233f, 0.02560879f, 0.00876956f, 0.03315391f, -0.03892033f, 
    -0.02031498f, -0.00604337f, -0.02072265f, 0.02127067f, 0.01972716f, 0.02767080f, -0.03610837f, -0.03034775f, 
    -0.00381454f, -0.01755232f, 0.01197693f, -0.03022356f, 0.02216450f, -0.00948608f, -0.01602615f, 0.00152953f, 
    0.03176221f, 0.01074137f, -0.01361590f, 0.00903319f, -0.00402427f, -0.01454499f, 0.00492428f, -0.02617423f, 
    0.02266275f, 0.02815847f, -0.01082150f, -0.01939188f, -0.01519985f, 0.04336621f, -0.03289195f, 0.01082568f, 
    -0.03220304f, -0.03383123f, -0.00396844f, 0.02137503f, 0.02801759f, -0.00233484f, -0.01905239f, -0.01632893f, 
    -0.01749511f, -0.01683288f, 0.02744508f, 0.04044561f, -0.01617904f, 0.01243994f, 0.00253133f, 0.01475614f, 
    -0.01154831f, -0.02339082f, 0.03611349f, -0.02863468f, 0.00089435f, -0.00575380f, 0.00133068f, 0.03250653f, 
    0.00620013f, 0.00926074f, -0.01252568f, 0.02513492f, 0.02865486f, 0.01592865f, -0.02535834f, 0.03551043f, 
    0.02473039f, 0.01610998f, 0.02827879f, 0.01739144f, -0.00897859f, 0.01498430f, -0.02328884f, -0.03477443f, 
    0.02069646f, 0.00847346f, 0.02865869f, -0.03095050f, -0.03575197f, -0.03534982f, -0.00876005f, 0.01712987f, 
    -0.03492895f, -0.00225956f, 0.02692181f, -0.03476838f, -0.03224227f, -0.03562036f, -0.02635702f, -0.03546383f, 
    0.02137579f, 0.02625037f, 0.00411213f, -0.00302140f, -0.01695146f, 0.01949599f, -0.02583254f, 0.00833334f, 
    -0.03921592f, 0.01742825f, -0.02074564f, 0.02914149f, -0.00245891f, 0.01378962f, 0.02802097f, -0.04105004f, 
    0.02215403f, 0.00594522f, 0.01074712f, -0.00865783f, -0.01563362f, -0.03644978f, 0.02682788f, 0.00206957f, 
    -0.02425235f, -0.02672141f, 0.02553586f, 0.02650827f, 0.01080972f, -0.03745370f, 0.01793561f, 0.00537786f, 
    0.00421475f, -0.03549347f, -0.01737312f, -0.04267561f, -0.02309723f, -0.01062132f, 0.01201294f, -0.02904604f, 
    -0.01817794f, 0.00724299f, 0.02926110f, 0.02006206f, -0.00163228f, 0.01508665f, -0.03257474f, 0.02110481f, 
    -0.03791974f, -0.02507510f, -0.00014070f, 0.01642532f, -0.02235238f, -0.04065614f, -0.03003299f, -0.02982630f, 
    0.01530103f, -0.01858412f, 0.01855840f, -0.00324210f, -0.02245184f, 0.00430765f, -0.02485645f, 0.02732730f, 
    -0.00044134f, -0.00316393f, -0.03618185f, -0.03012313f, 0.02288681f, -0.04157719f, -0.01131793f, 0.04050559f, 
    0.02600253f, -0.01113253f, -0.00709937f, -0.01323321f, -0.02718261f, -0.00316590f, 0.01044437f, 0.03971996f, 
    0.02357964f, -0.00664097f, -0.02875206f, 0.02337388f, -0.02212696f, -0.00969254f, -0.00290100f, 0.01427955f, 
    0.00405748f, 0.01572649f, -0.03432870f, -0.02396782f, 0.01207992f, -0.02101334f, -0.03412271f, -0.00443224f, 
    0.01606940f, 0.00709265f, 0.01146794f, 0.01227010f, 0.02102507f, -0.01305012f, 0.00784450f, -0.04054390f, 
    -0.04233609f, 0.02826993f, 0.02691857f, -0.03972499f, 0.02407134f, 0.01641012f, 0.00533028f, 0.00713266f, 
    -0.00184129f, 0.00812045f, 0.00505652f, -0.03960045f, -0.03637584f, -0.03249073f, -0.02649695f, 0.02486962f, 
    0.00694774f, 0.01769911f, -0.00059679f, 0.01859361f, -0.02246727f, -0.00046177f, 0.00499910f, -0.03026073f, 
    -0.03403647f, -0.02923057f, 0.02300316f, -0.03765309f, -0.03272242f, -0.00043094f, -0.02353719f, -0.04161096f, 
    0.01546960f, -0.03968974f, -0.00594326f, -0.03880179f, -0.00492445f, 0.01194957f, -0.02054554f, -0.02138558f, 
    -0.02798905f, -0.02684149f, -0.02894285f, 0.01502783f, 0.00564636f, -0.03899340f, 0.02949052f, -0.02846359f, 
    -0.01051661f, -0.02255485f, -0.03263540f, 0.01115423f, 0.02091043f, -0.04245869f, 0.00289409f, -0.03004334f, 
    -0.01413516f, -0.00615900f, 0.00572177f, 0.01630356f, -0.00550542f, 0.00810841f, -0.00132156f, -0.03341023f, 
    -0.00267545f, 0.03609917f, -0.00426332f, 0.01669303f, 0.02232150f, -0.02313400f, -0.01397069f, -0.02649328f, 
    0.01500539f, -0.01391795f, -0.02348102f, 0.01774934f, -0.01618286f, -0.01847731f, 0.01090582f, -0.02876628f, 
    0.01835085f, -0.03356094f, -0.01032915f, -0.03431205f, -0.02244018f, -0.01488402f, 0.02713073f, -0.00496886f, 
    0.00907562f, -0.02831923f, -0.03441468f, -0.02038811f, 0.01676141f, 0.01744568f, -0.02106199f, -0.00598683f, 
    -0.01930950f, 0.00245718f, 0.02728743f, -0.03128650f, 0.00250705f, 0.01439154f, 0.02121599f, 0.00545930f, 
    -0.01977854f, 0.02427624f, -0.03943844f, 0.01072412f, 0.01505396f, -0.03985947f, -0.01452514f, -0.00709866f, 
    -0.00494381f, 0.02166449f, -0.02795243f, 0.01459591f, -0.00981166f, -0.01695129f, 0.01674889f, -0.02242729f, 
    -0.00910443f, 0.00678184f, 0.02335982f, 0.00631548f, 0.00041630f, -0.01949733f, -0.00089969f, -0.02092765f, 
    -0.02905039f, -0.03089499f, -0.02491480f, -0.03505368f, 0.01694253f, 0.01667361f, -0.03883748f, 0.00479381f, 
    -0.02848603f, 0.01355797f, -0.00894929f, -0.00775521f, -0.03036558f, -0.01062338f, 0.02648376f, -0.02354145f, 
    -0.00877159f, -0.01422459f, -0.02604153f, -0.02950935f, -0.03787978f, -0.01244777f, 0.00830745f, 0.02567423f, 
    -0.02178955f, -0.01683725f, -0.00259244f, -0.00240653f, 0.00069110f, 0.00544319f, -0.01655757f, 0.02495172f, 
    -0.03213976f, -0.01500416f, 0.02698424f, -0.03142302f, -0.00431023f, -0.00042412f, -0.04076027f, 0.00204486f, 
    -0.02467374f, -0.01749066f, 0.02137032f, -0.03219859f, -0.00758707f, 0.02829969f, -0.01759419f, -0.04153944f, 
    -0.03097606f, -0.01136656f, -0.02291499f, 0.02938765f, 0.02483717f, -0.01759218f, 0.02260599f, -0.04007328f, 
    0.01322917f, -0.03533864f, 0.01490366f, -0.02903433f, -0.01112885f, 0.01695961f, -0.02164643f, -0.00380650f, 
    0.02393697f, -0.02831092f, 0.03020224f, 0.02969372f, 0.01401950f, 0.02036314f, -0.03726957f, -0.02056742f, 
    0.01377195f, -0.04064384f, -0.03050450f, 0.01154042f, -0.00131909f, -0.00279043f, -0.02777983f, -0.00904935f, 
    0.01966220f, 0.02195793f, 0.00882705f, -0.03962121f, 0.01863989f, 0.03089029f, 0.00040831f, -0.00142269f, 
    -0.01552067f, 0.00977717f, 0.01375642f, -0.01530933f, -0.00611102f, -0.00245575f, -0.01504162f, -0.02656953f, 
    0.02119383f, -0.01445720f, -0.03719299f, 0.02892318f, -0.01814497f, -0.03178243f, 0.00203397f, -0.02343853f, 
    0.00530699f, -0.01942922f, -0.03390176f, -0.01955382f, 0.00223439f, 0.01882703f, -0.02132167f, 0.02194877f, 
    0.00235584f, -0.02999390f, -0.00410937f, -0.00120637f, 0.03244907f, 0.00388419f, 0.01837507f, 0.02483405f, 
    0.01276314f, -0.01503961f, -0.02245330f, -0.03793295f, -0.01694327f, -0.03491214f, 0.00809699f, -0.00978261f, 
    -0.03907855f, -0.02667140f, 0.02863031f, -0.03047061f, 0.02435215f, 0.02178000f, -0.01485528f, 0.00698295f, 
    -0.01590726f, -0.02593502f, 0.02146206f, -0.03044526f, 0.02394441f, -0.00662931f, 0.01446472f, -0.02022361f, 
    0.00185855f, 0.02198594f, -0.03871958f, 0.02712343f, 0.02437512f, 0.02037217f, -0.02224943f, -0.00638676f, 
    -0.01756829f, -0.01717358f, -0.00580264f, -0.01664121f, -0.02575749f, -0.02558374f, 0.01855774f, -0.03623087f, 
    0.00056956f, 0.00091103f, -0.01572484f, -0.00977276f, 0.01759379f, 0.02056168f, -0.01502948f, -0.02118450f, 
    -0.00222272f, 0.00496127f, -0.00177489f, -0.01211928f, 0.01171006f, -0.03426142f, -0.00063215f, 0.02527773f, 
    -0.00172419f, -0.01606233f, 0.02165524f, 0.01268970f, -0.00695561f, 0.00324958f, -0.01412838f, -0.00692103f, 
    -0.00404892f, -0.04120506f, -0.03856008f, -0.00770102f, -0.00551784f, -0.02306302f, -0.04153342f, 0.01006897f, 
    0.01587770f, -0.03595667f, -0.00005409f, 0.00352646f, -0.02306495f, -0.01682926f, 0.00584422f, -0.01024748f, 
    -0.01181937f, -0.01532114f, -0.03440427f, 0.00592742f, 0.01749146f, -0.03111808f, 0.00633143f, -0.04114432f, 
    0.01009397f, -0.01569902f, 0.01900936f, -0.03581136f, -0.02612874f, -0.02752241f, -0.03487995f, -0.00254151f, 
    -0.02400185f, 0.00688353f, -0.03512808f, -0.02103377f, 0.01983652f, 0.02577878f, 0.01282297f, 0.00459657f, 
    -0.01266036f, -0.00760983f, 0.01592142f, 0.01577742f, 0.00025408f, 0.02815600f, 0.02890373f, 0.00569509f, 
    0.02358585f, -0.03154757f, -0.01948757f, -0.04117792f, 0.02402958f, 0.01470885f, -0.00985197f, 0.00375574f, 
    -0.01672204f, 0.01765545f, 0.01465452f, 0.01153806f, -0.02468398f, -0.02521378f, -0.03825179f, -0.00019418f, 
    -0.00123405f, 0.02682516f, -0.03749005f, -0.03162370f, -0.02746679f, 0.00240514f, -0.03128084f, 0.01930279f, 
    -0.01942600f, 0.01350476f, -0.02783385f, -0.02943151f, 0.03226900f, 0.01039424f, -0.02402111f, -0.01358170f, 
    -0.02084106f, 0.00559891f, -0.01259854f, -0.00857016f, -0.00498624f, 0.00036571f, -0.02652756f, 0.00805608f, 
    -0.02558837f, 0.00583895f, 0.00606819f, -0.04129198f, 0.01987592f, 0.01301006f, -0.00270568f, -0.00102465f, 
    -0.03310006f, -0.00531177f, -0.02091920f, 0.00104135f, -0.01027925f, 0.01203011f, -0.01290637f, -0.00694273f, 
    0.02126587f, 0.00043870f, 0.02843230f, -0.01366506f, 0.00925896f, -0.00496358f, -0.02293765f, -0.00017598f, 
    -0.01346087f, 0.01931802f, -0.04102023f, -0.03484512f, -0.04100443f, -0.03544016f, -0.02373596f, 0.00366234f, 
    0.00864658f, 0.01995727f, -0.03835116f, 0.00621563f, -0.02863014f, 0.00801359f, 0.00127551f, -0.01904702f, 
    0.01070721f, -0.00815550f, 0.02327325f, -0.01647609f, -0.03558956f, -0.03390235f, 0.01179086f, -0.01590536f, 
    0.02840951f, -0.00961999f, 0.00198572f, -0.01563021f, -0.03205813f, -0.01378543f, -0.03717089f, -0.02291289f, 
    -0.04122398f, 0.02925265f, 0.02296199f, 0.02969941f, 0.01169045f, -0.00762115f, 0.01869436f, -0.03145817f, 
    -0.01002123f, 0.00823548f, 0.02180661f, 0.03119753f, -0.04244067f, 0.01460147f, -0.01087706f, -0.01445561f, 
    0.03040930f, -0.00078887f, -0.01444885f, -0.01197595f, -0.02552443f, -0.01447481f, -0.00035359f, 0.00383120f, 
    -0.03920179f, -0.02474149f, 0.02498004f, 0.00589801f, 0.00051964f, 0.02324845f, -0.02063506f, -0.00187986f, 
    -0.03531840f, -0.00389249f, 0.01847044f, -0.01674704f, -0.01669793f, 0.01290185f, -0.03693802f, 0.00958953f, 
    -0.00537042f, 0.00838376f, 0.01105653f, 0.01930243f, -0.02336693f, 0.02048109f, -0.02547467f, 0.01599368f, 
    0.02240739f, -0.01640153f, -0.04006832f, -0.00903914f, -0.02617805f, 0.01692046f, -0.00293762f, 0.03064859f, 
    0.01495894f, 0.01239702f, -0.02158298f, -0.01099139f, -0.00293852f, -0.00028980f, -0.01715590f, 0.02784174f, 
    -0.02388245f, -0.03461114f, -0.00331658f, -0.01012947f, 0.00638800f, 0.01685179f, 0.02153129f, -0.01011610f, 
    -0.03618358f, -0.03613766f, -0.00431208f, 0.01685424f, 0.01442316f, -0.03805875f, -0.02793161f, 0.01901141f, 
    -0.03922781f, 0.00850009f, -0.01913314f, 0.00031340f, 0.00895850f, 0.00672462f, 0.01841094f, -0.01335249f, 
    -0.03885666f, -0.01863210f, 0.01879536f, 0.02376121f, -0.00442014f, -0.02312633f, -0.01718260f, 0.02958740f, 
    0.02497439f, 0.00402757f, 0.02120702f, -0.03940440f, -0.02261802f, -0.00284603f, 0.01551110f, -0.04333938f, 
    0.00575065f, -0.03021252f, 0.00498977f, 0.01489193f, -0.00648711f, 0.00023719f, -0.01726698f, -0.01238629f, 
    0.02089694f, -0.00250014f, 0.01325005f, 0.00569209f, 0.00654107f, -0.03591698f, -0.01076555f, -0.00579372f, 
    0.00336568f, 0.02328681f, -0.00230552f, 0.02493206f, -0.00845866f, 0.02229526f, -0.03296381f, 0.01323698f, 
    -0.00240202f, -0.01470008f, -0.02509436f, -0.01929310f, 0.03840208f, -0.01860513f, -0.03817105f, -0.03850178f, 
    0.01984167f, 0.00595479f, -0.01569791f, -0.04150431f, 0.02713123f, 0.00367005f, -0.02721009f, 0.01447199f, 
    -0.03743962f, -0.03123694f, -0.03550150f, -0.00613314f, -0.00098870f, 0.00887925f, -0.02286633f, 0.01788252f, 
    -0.00002719f, -0.04051789f, -0.01794374f, 0.00136412f, -0.04016797f, -0.00818241f, -0.02688982f, 0.01402068f, 
    -0.00840164f, -0.02684345f, -0.02613754f, 0.01798690f, -0.01068763f, -0.02718812f, -0.00562923f, -0.02632370f, 
    0.02553565f, -0.02873919f, -0.01724348f, 0.00260105f, 0.00833109f, -0.01980454f, -0.03006999f, -0.01378816f, 
    -0.01566049f, 0.01886663f, 0.02433432f, -0.03948285f, -0.04029421f, 0.01582452f, -0.00227866f, -0.01117607f, 
    -0.01457835f, -0.00568449f, -0.03491666f, -0.03738752f, 0.02080391f, -0.00243034f, -0.03008720f, -0.00511052f, 
    -0.02773070f, 0.00131304f, -0.02199796f, -0.04146277f, 0.01152485f, -0.00158931f, -0.03507249f, -0.01995434f, 
    -0.01353873f, -0.01219939f, 0.02089944f, -0.02500675f, -0.01440132f, 0.01017339f, 0.00034913f, -0.01698629f, 
    0.01609928f, -0.01231934f, -0.02232561f, -0.04183398f, 0.00049615f, -0.00103641f, -0.03324846f, -0.02616269f, 
    0.01915856f, -0.01674644f, 0.01285753f, 0.02941008f, -0.01831420f, 0.01413796f, -0.00839110f, 0.00535250f, 
    0.00779255f, 0.01659062f, -0.00649971f, 0.00191096f, 0.01798573f, -0.03703664f, -0.01630291f, -0.00558094f, 
    0.01171055f, 0.02346563f, -0.01709548f, -0.02428352f, -0.02996350f, -0.01746133f, 0.01418378f, -0.02825274f, 
    -0.01471102f, 0.02469974f, 0.01601763f, -0.00759061f, -0.01827160f, -0.02116133f, 0.00236956f, 0.00388434f, 
    -0.00417323f, -0.00856332f, 0.01752368f, -0.00473062f, -0.02344340f, 0.01247492f, -0.03743375f, 0.02066268f, 
    -0.03943062f, -0.04236436f, -0.04275891f, -0.02841269f, -0.00945123f, 0.00882339f, -0.04232030f, -0.00560880f, 
    0.01899608f, -0.02245522f, 0.01478300f, 0.02816891f, 0.00563681f, 0.00728347f, 0.00649443f, 0.01838845f, 
    -0.01358838f, -0.04221390f, -0.04043553f, 0.02634156f, 0.01570979f, -0.00211197f, -0.01586992f, -0.03001344f, 
    -0.03145194f, -0.01076110f, 0.00368874f, -0.01262276f, -0.01181239f, 0.01188245f, -0.01453094f, -0.00496056f, 
    -0.00369674f, 0.00416194f, 0.01995742f, 0.00042009f, 0.00919347f, 0.00485265f, -0.03184765f, -0.02249032f, 
    -0.04374289f, 0.00519811f, -0.00490202f, -0.03360375f, -0.00643768f, -0.04307543f, 0.02871088f, -0.00431904f, 
    0.02088263f, -0.00264793f, 0.00316382f, -0.04027849f, -0.02308223f, 0.03755476f, -0.01437321f, -0.00779010f, 
    -0.02979885f, 0.03453488f, -0.00750830f, 0.02390770f, -0.04220780f, -0.02619181f, 0.00438627f, -0.03739122f, 
    0.00633809f, 0.02988952f, -0.02319135f, -0.01421404f, -0.02790400f, 0.01863998f, -0.01320472f, -0.03506259f, 
    0.01556794f, 0.01444322f, -0.02680088f, -0.03586137f, -0.01191515f, -0.00395202f, 0.01488441f, 0.01333388f, 
    -0.04255896f, 0.00183349f, 0.00296092f, 0.01517851f, -0.02909261f, -0.00852099f, -0.00833906f, 0.00313658f, 
    0.02339900f, 0.02773516f, 0.02061947f, 0.01704794f, -0.02358812f, 0.00406751f, -0.03421741f, 0.02923889f, 
    0.00662614f, -0.00248709f, -0.01649007f, 0.00997914f, -0.01462233f, -0.01133471f, -0.03838412f, -0.00761903f, 
    0.02349860f, 0.02139153f, 0.03768361f, -0.00657565f, -0.04004493f, 0.00418811f, 0.02775349f, -0.03047407f, 
    -0.03066995f, -0.00187202f, -0.04198602f, -0.03549067f, 0.02529192f, 0.00997461f, 0.01163547f, 0.00843641f, 
    0.00775165f, -0.01029796f, -0.00142121f, 0.02459844f, -0.01633618f, 0.01533424f, -0.04457282f, 0.00836677f, 
    -0.03553746f, 0.01429114f, 0.01851208f, -0.01584424f, 0.01108736f, 0.01893491f, 0.01038241f, -0.00442233f, 
    0.01812461f, 0.01737678f, -0.02079745f, -0.00224357f, 0.01431972f, 0.01237431f, -0.02738840f, -0.01442111f, 
    0.00031612f, -0.00865710f, -0.04201581f, -0.02771818f, 0.02386987f, 0.00180882f, 0.00571689f, -0.02238388f, 
    0.00001525f, -0.03601005f, 0.01242111f, -0.01299820f, -0.01574460f, -0.02412499f, 0.00867011f, 0.01184311f, 
    -0.00340179f, 0.01994112f, -0.02709157f, 0.02050876f, -0.01125918f, 0.00652051f, 0.00357766f, -0.02321295f, 
    -0.02996770f, -0.04119163f, 0.02238443f, 0.00859538f, 0.02659306f, -0.02314007f, 0.00158137f, -0.02188912f, 
    0.01892815f, -0.00861418f, -0.02854537f, -0.01815724f, 0.01719712f, -0.01910442f, 0.00288728f, -0.01991068f, 
    -0.02753041f, -0.00741508f, 0.01647510f, -0.01470177f, -0.04186352f, -0.02550455f, 0.00546572f, -0.01539199f, 
    0.01173885f, 0.02260389f, -0.04298811f, -0.01358580f, 0.00945388f, 0.00857004f, -0.02189081f, 0.00951593f, 
    0.00801105f, 0.01155044f, 0.01870048f, -0.02916536f, -0.01236544f, -0.02655082f, 0.01690184f, 0.00083717f, 
    -0.01771696f, -0.00531827f, -0.02119892f, -0.01341176f, -0.00141081f, -0.00241761f, -0.03981450f, 0.02347343f, 
    -0.04037908f, 0.02116493f, -0.01570727f, 0.02218304f, -0.02567190f, -0.00387996f, -0.01314194f, 0.02720858f, 
    -0.01172420f, -0.00140289f, 0.00350199f, 0.00896258f, 0.00970521f, -0.00591901f, -0.03449610f, 0.00786832f, 
    -0.01698050f, -0.02553439f, -0.01940046f, -0.02702851f, -0.03644419f, -0.00469121f, 0.01848732f, -0.04305088f, 
    -0.04482388f, 0.02065847f, -0.02669964f, -0.02225539f, -0.04264627f, 0.00643159f, 0.00835870f, 0.00933271f, 
    -0.01771326f, 0.00213594f, 0.01064185f, -0.03850847f, -0.01935084f, -0.03635632f, 0.00404468f, -0.03854245f, 
    -0.01113487f, -0.00395518f, -0.00022863f, 0.00482622f, -0.03041227f, -0.01163971f, 0.00156888f, 0.00286032f, 
    -0.02856521f, -0.00661473f, -0.02158838f, 0.00205668f, -0.01690130f, 0.03086983f, 0.01984856f, -0.03022617f, 
    0.02218896f, -0.01848142f, -0.01146584f, -0.01495892f, 0.01954770f, -0.01002619f, 0.01366017f, -0.02238478f, 
    -0.03739687f, 0.00113347f, 0.02111368f, -0.04345771f, -0.00635009f, 0.02291753f, -0.00301052f, 0.00794003f, 
    0.00945556f, 0.00455511f, 0.02193718f, 0.02830195f, -0.03035592f, 0.00800221f, -0.00454570f, 0.02934070f, 
    0.02335352f, -0.03621627f, -0.03049669f, -0.00961060f, 0.01196239f, 0.00308116f, -0.02783090f, 0.00845234f, 
    0.01916831f, 0.00943460f, 0.01957523f, 0.01866631f, -0.01317794f, -0.01614837f, 0.01971580f, 0.00949521f, 
    -0.03054550f, -0.04330562f, 0.02681447f, -0.02130881f, 0.01329021f, 0.00723567f, 0.00580272f, -0.02470542f, 
    -0.03760697f, -0.00508454f, -0.02468489f, -0.02016692f, 0.00901958f, 0.02085464f, 0.01085791f, -0.00449169f, 
    -0.02192285f, -0.03283312f, 0.00478952f, -0.01338148f, 0.02004991f, 0.01532195f, -0.01968426f, 0.02135413f, 
    -0.03010979f, 0.01857347f, -0.02977002f, 0.01932992f, -0.02122382f, -0.01176396f, -0.02958480f, -0.01221031f, 
    0.00801464f, 0.02665194f, 0.02289997f, 0.01503865f, 0.00914534f, -0.00536006f, 0.00250905f, -0.00346634f, 
    0.01408367f, -0.01065052f, 0.01567947f, -0.02570319f, -0.00596874f, 0.01239322f, -0.02329325f, 0.01490952f, 
    -0.00660408f, 0.02150619f, -0.02558362f, -0.00074955f, 0.02058235f, -0.01744816f, -0.00087227f, 0.00871746f, 
    -0.03281649f, -0.01865983f, -0.04274549f, -0.00398857f, -0.00301318f, -0.02788251f, -0.03367908f, -0.01810970f, 
    -0.02903188f, 0.01718023f, 0.02284681f, -0.04209877f, -0.01210854f, -0.03424068f, -0.00843295f, 0.02913029f, 
    -0.01879545f, 0.01037020f, -0.00798495f, 0.02925892f, 0.00146192f, -0.03173203f, -0.01011927f, 0.02269529f, 
    -0.03094215f, -0.02095680f, -0.01522997f, -0.01885080f, 0.02776669f, -0.00387508f, 0.00165511f, 0.01272327f, 
    -0.02132774f, 0.00441833f, -0.03456913f, 0.02575495f, -0.03568949f, -0.03054255f, -0.00066138f, 0.01398833f, 
    0.00350104f, -0.02591202f, -0.02653005f, 0.00789928f, -0.03411976f, 0.02269647f, -0.04118238f, -0.00951232f, 
    -0.04139530f, -0.02226535f, 0.02417462f, -0.01602830f, -0.01863433f, -0.02704450f, -0.01165874f, 0.00692932f, 
    0.00412776f, 0.00229699f, -0.02333513f, 0.00711932f, -0.02261101f, -0.01577277f, 0.02392088f, 0.00580077f, 
    -0.02654162f, 0.00601092f, -0.03425778f, -0.01740559f, 0.00088848f, -0.02582894f, 0.03125773f, 0.00803570f, 
    -0.03012569f, -0.00146713f, -0.01201187f, 0.02265442f, -0.02686295f, 0.02447317f, -0.03129378f, -0.03118665f, 
    0.02504775f, -0.01004057f, 0.02699349f, 0.01788536f, -0.00053254f, -0.02948066f, -0.00159696f, -0.02934569f, 
    -0.02410816f, 0.00623496f, -0.01630980f, -0.03938735f, -0.03089791f, -0.01108257f, -0.01332119f, 0.00526504f, 
    0.02197474f, 0.00456668f, 0.02154654f, 0.02685615f, -0.02979394f, 0.00962030f, 0.01176936f, -0.03781665f, 
    -0.00987703f, 0.02182310f, 0.02196397f, -0.03520275f, 0.00384367f, -0.01108485f, 0.00927285f, -0.01468462f, 
    -0.04019035f, 0.01901368f, 0.02368432f, 0.00410546f, 0.02149902f, 0.00733044f, -0.03979094f, 0.00297490f, 
    -0.00111854f, -0.00124693f, -0.01592311f, -0.01598937f, 0.00191132f, -0.04036040f, 0.00207095f, -0.01402525f, 
    -0.01041139f, -0.02685874f, -0.04091521f, 0.01287588f, -0.00842126f, -0.00326640f, 0.01716411f, -0.04027040f, 
    0.01258561f, -0.00178305f, -0.03937296f, 0.00010810f, -0.03675689f, -0.00249219f, 0.02256104f, -0.02289140f, 
    -0.03149361f, 0.03408150f, -0.00957869f, 0.02172817f, 0.00584559f, 0.01214699f, -0.02001002f, -0.03234076f, 
    -0.01145037f, 0.01746512f, 0.00588233f, -0.01381869f, -0.00068581f, -0.03522772f, -0.00201265f, -0.02091302f, 
    -0.02054182f, -0.00348219f, -0.00529717f, 0.00755437f, 0.00012877f, -0.01445049f, -0.01138357f, 0.00998196f, 
    0.00901797f, -0.01303438f, -0.00825730f, 0.00149448f, 0.02774869f, -0.01256105f, -0.03018610f, -0.03980459f, 
    0.00637194f, 0.01337434f, -0.03744061f, -0.01998387f, -0.03026830f, -0.03314195f, -0.02245820f, 0.00299721f, 
    0.00548267f, -0.03240214f, -0.00488787f, -0.02516981f, -0.03014232f, -0.03195020f, 0.00103964f, -0.02211697f, 
    -0.00383925f, 0.01196650f, 0.01454677f, -0.03841991f, 0.02352427f, 0.02740731f, -0.03955401f, 0.01436949f, 
    0.00325911f, 0.02108102f, 0.01157009f, 0.01335183f, 0.01642797f, 0.02437566f, -0.02697957f, -0.03098675f, 
    -0.00302804f, 0.00593938f, 0.01919822f, -0.03611570f, 0.00476304f, 0.02097178f, -0.02967486f, -0.03084130f, 
    0.01080266f, 0.01698074f, -0.00209227f, -0.00183555f, 0.00755962f, -0.00851946f, 0.01897723f, 0.01206154f, 
    0.02721314f, 0.01435972f, -0.01888037f, -0.03481444f, 0.01118307f, 0.01649069f, -0.01423863f, 0.00105377f, 
    -0.01779300f, -0.00832993f, -0.02456012f, -0.03195906f, -0.01623947f, 0.00678362f, 0.01593026f, 0.01321856f, 
    -0.03549879f, 0.01112475f, -0.02002101f, -0.02902750f, -0.03325059f, -0.00195296f, 0.01209247f, 0.02419878f, 
    0.01685971f, 0.02477567f, 0.02063834f, 0.01237889f, -0.00048769f, 0.00751253f, 0.01966476f, 0.00548675f, 
    -0.02998894f, -0.03590427f, -0.03566838f, -0.00764493f, 0.02148316f, -0.01931742f, 0.02524192f, 0.02148590f, 
    -0.01143561f, 0.00559911f, -0.00894937f, 0.01470150f, -0.01733849f, -0.03195645f, 0.01670920f, -0.01288216f, 
    -0.03561001f, -0.02596862f, -0.00143113f, -0.03418962f, -0.01598801f, -0.03721507f, 0.01386802f, -0.03078171f, 
    -0.03951115f, 0.01860126f, -0.01366547f, -0.03267469f, -0.02472359f, 0.01097326f, 0.00064027f, 0.00010695f, 
    -0.00718567f, -0.01918942f, -0.01110199f, -0.03288202f, -0.00330881f, 0.02946977f, -0.03106917f, 0.02148527f, 
    -0.03138538f, 0.00859029f, 0.02519438f, -0.00881478f, 0.00724490f, -0.00519732f, -0.00410307f, -0.04379674f, 
    0.00422156f, -0.03604904f, 0.02868919f, 0.02538767f, 0.02235727f, -0.03428005f, -0.04035052f, 0.00634384f, 
    -0.01741201f, -0.03101956f, -0.01184905f, 0.00117573f, -0.02907580f, -0.01146054f, -0.02127907f, -0.00455165f, 
    0.03038187f, -0.02339373f, -0.00911522f, -0.03438282f, -0.00648273f, 0.01974927f, -0.01404568f, 0.01678064f, 
    -0.03739296f, -0.01375892f, -0.03653828f, 0.01514815f, 0.00191224f, 0.01587223f, 0.00592998f, 0.01754316f, 
    -0.01002375f, 0.00324356f, -0.04279691f, -0.00493170f, -0.01942026f, 0.00448547f, -0.01700424f, -0.01619669f, 
    0.01663466f, -0.01804603f, -0.02958874f, -0.03644220f, 0.00542726f, -0.00799097f, -0.01500747f, -0.01021313f, 
    -0.01170781f, 0.00583151f, 0.02924287f, -0.01620881f, -0.04149989f, -0.00964193f, 0.00543745f, -0.02023096f, 
    0.03668271f, -0.02557541f, 0.00121068f, -0.03901849f, 0.02315575f, 0.00214638f, -0.01283214f, 0.00078527f, 
    0.00022198f, 0.00699416f, -0.00117476f, -0.03601457f, -0.00062312f, -0.00540538f, 0.01054076f, -0.00744195f, 
    0.02146090f, 0.01508963f, 0.02528230f, -0.02368180f, -0.04226053f, 0.01804964f, -0.02042004f, 0.01386672f, 
    -0.02857555f, -0.00867732f, -0.00944940f, -0.03025433f, -0.03703677f, 0.02107222f, 0.03605379f, -0.04271858f, 
    0.02181313f, 0.02147740f, 0.01003289f, 0.02755634f, -0.00311867f, 0.01508216f, -0.02834311f, 0.01953304f, 
    -0.02977339f, 0.01103652f, -0.03706637f, 0.02289665f, -0.01635685f, 0.00725750f, 0.00573989f, 0.02527385f, 
    0.00733355f, -0.01617616f, -0.01743563f, 0.01064655f, -0.01007138f, 0.01447462f, -0.01455371f, -0.04187914f, 
    0.00411536f, 0.00626514f, -0.01574307f, -0.02932514f, -0.01303838f, 0.02209053f, -0.02239076f, -0.01581752f, 
    0.02764913f, 0.00463415f, -0.03686262f, 0.01250855f, -0.01932742f, -0.02448055f, -0.01032617f, -0.02156957f, 
    -0.00423719f, -0.03963653f, -0.00055771f, -0.00668297f, 0.02404948f, -0.00915647f, -0.01425880f, -0.01837271f, 
    -0.01339855f, -0.02400760f, 0.02588790f, -0.02889927f, 0.01641701f, -0.01523429f, 0.00763771f, -0.01408356f, 
    0.01987689f, 0.00277897f, -0.01276097f, 0.00545369f, -0.01643004f, 0.02517822f, -0.01587443f, 0.02056988f, 
    0.01160283f, -0.00075728f, 0.01500329f, -0.02240932f, 0.00396959f, -0.01451429f, -0.00459068f, -0.00838188f, 
    -0.02679807f, -0.01431953f, -0.01867782f, -0.02363122f, 0.00647191f, 0.01649964f, -0.00541623f, -0.01036688f, 
    -0.02161344f, -0.00489703f, 0.00005917f, 0.02250000f, 0.02496310f, -0.02382701f, 0.03405945f, 0.01795384f, 
    -0.02002903f, -0.02472928f, 0.02490590f, 0.03392454f, -0.04242747f, 0.00910290f, -0.02245116f, 0.03321562f, 
    0.00722099f, -0.04017842f, 0.00551534f, -0.03125611f, -0.01078159f, -0.00037196f, 0.00975535f, -0.00317232f, 
    0.00510958f, -0.00709860f, -0.04250791f, -0.02606764f, -0.02071776f, -0.02734587f, -0.04179043f, -0.01398776f, 
    -0.00805201f, -0.02500699f, -0.00537787f, -0.00630422f, 0.00563379f, -0.00175228f, -0.03734932f, 0.01655526f, 
    -0.01482541f, 0.01828619f, -0.00213090f, -0.03201621f, -0.01702745f, -0.01202766f, -0.01056454f, 0.01161974f, 
    -0.02050515f, 0.02194093f, -0.03227628f, -0.03651907f, 0.02239173f, -0.00689047f, -0.00403537f, -0.01061699f, 
    -0.00376373f, -0.04422110f, -0.01684803f, -0.00767029f, 0.02142000f, 0.03259978f, -0.02800315f, -0.01331807f, 
    -0.00507104f, -0.03882640f, -0.02492838f, -0.03957510f, 0.02770228f, -0.00425742f, -0.00573082f, 0.01060285f, 
    0.01930476f, -0.03860923f, -0.02155215f, 0.02461784f, -0.03311900f, -0.02283678f, -0.02619239f, 0.01987126f, 
    -0.02907283f, -0.01562774f, -0.01930984f, -0.02921978f, 0.01111677f, 0.01496913f, -0.01286459f, 0.01948815f, 
    0.02080573f, 0.00489929f, -0.04218145f, -0.03360647f, 0.02911749f, 0.02288598f, -0.02731703f, -0.00885085f, 
    0.00123023f, -0.02352096f, -0.00230832f, -0.00692021f, 0.01272221f, -0.01901000f, -0.00212179f, 0.00800873f, 
    0.01016479f, 0.01372745f, -0.03346210f, -0.02411384f, 0.00578771f, -0.00091511f, 0.00409178f, -0.00956032f, 
    -0.02546778f, -0.01449531f, 0.00828875f, 0.01280550f, -0.01054145f, -0.04208413f, -0.01692154f, 0.02392597f, 
    0.02679719f, -0.02156885f, 0.03446883f, -0.01702641f, -0.02525421f, 0.00860354f, -0.03060232f, 0.01855248f, 
    -0.03932099f, 0.02282782f, -0.01391010f, -0.00650141f, 0.02525999f, 0.03369138f, -0.01681215f, 0.01897442f, 
    0.01271094f, -0.04410099f, 0.01508246f, 0.00559431f, 0.01454444f, -0.00688774f, 0.01944231f, 0.01673600f, 
    -0.02429939f, -0.01230001f, -0.02956975f, 0.02169996f, -0.01487840f, 0.00960985f, 0.00484654f, 0.01886742f, 
    0.02840126f, -0.02543931f, -0.02316575f, 0.02391871f, -0.02393647f, 0.02216074f, 0.01633993f, -0.03815588f, 
    0.02005302f, -0.02577756f, 0.01922848f, -0.00539396f, -0.03196526f, -0.02207494f, 0.02828875f, -0.03969038f, 
    -0.02035898f, -0.02229942f, 0.00438622f, -0.03121664f, 0.02956171f, 0.01192167f, -0.02362515f, 0.01467028f, 
    0.00162404f, -0.03835065f, -0.00879449f, 0.01482273f, 0.01440034f, 0.00123180f, -0.03020885f, 0.03859175f, 
    0.01436394f, -0.00717577f, -0.02790681f, 0.00827124f, 0.02830548f, 0.01553289f, -0.02742416f, 0.02889306f, 
    0.01247575f, -0.01510662f, 0.01711252f, -0.00978040f, 0.02713173f, 0.00385972f, 0.03624925f, 0.00126919f, 
    0.00637148f, 0.02813391f, 0.00416222f, 0.00851629f, 0.02030695f, 0.01832260f, -0.00665321f, 0.00694391f, 
    -0.01223157f, -0.02898218f, -0.00931053f, 0.00246127f, -0.00896761f, -0.00149099f, 0.00349874f, 0.00965276f, 
    -0.00680052f, 0.01923729f, -0.00154435f, -0.02217429f, -0.01856715f, -0.01320028f, -0.01474213f, -0.01046383f, 
    0.00728428f, -0.04095916f, -0.01543488f, -0.02406234f, 0.00639211f, -0.02183080f, -0.03002212f, 0.00979202f, 
    -0.02174395f, -0.01472142f, -0.02723091f, -0.02782768f, -0.02556043f, 0.01386290f, 0.00153935f, -0.01838329f, 
    0.00713956f, 0.02081855f, -0.02446778f, -0.01535859f, 0.00965371f, 0.00529412f, -0.01138815f, -0.02806486f, 
    -0.02160029f, -0.03511909f, -0.03876393f, 0.00111477f, 0.01430254f, -0.02192572f, -0.03844124f, 0.01139221f, 
    0.01193181f, -0.03881963f, -0.02889834f, -0.02887179f, -0.02793027f, 0.01295901f, 0.03293451f, -0.01884887f, 
    0.02251719f, -0.02989703f, -0.03103986f, -0.04121449f, 0.02413269f, -0.03613114f, 0.00890736f, -0.03429378f, 
    0.00336071f, 0.01625587f, -0.00980538f, -0.02790168f, 0.02025860f, -0.01386445f, -0.02248480f, 0.02915895f, 
    0.01472172f, 0.01339353f, -0.01361096f, 0.00921597f, -0.03468077f, 0.02721276f, 0.00423015f, 0.00477812f, 
    0.01008584f, 0.02719571f, -0.01184091f, -0.03004513f, 0.03463449f, 0.01953981f, 0.02717082f, 0.00115195f, 
    -0.02748440f, 0.00688303f, 0.02124652f, 0.00272838f, -0.02929730f, -0.04356596f, -0.02001496f, 0.02892303f, 
    0.03805334f, 0.02621971f, 0.00049821f, 0.02383471f, -0.01516731f, -0.01774807f, -0.04032032f, -0.03695960f, 
    -0.01055449f, -0.02536012f, 0.00546659f, 0.00140778f, -0.01559949f, 0.01355696f, 0.01547269f, 0.00767059f, 
    -0.03670280f, -0.01780927f, -0.00368787f, 0.00654695f, 0.00368505f, -0.02416122f, -0.00256168f, 0.00734652f, 
    0.01323980f, -0.02367778f, 0.02696873f, 0.01316364f, 0.01150395f, -0.01942325f, -0.01059906f, 0.00850516f, 
    -0.01008997f, -0.03062982f, -0.02857418f, 0.03450895f, 0.00632705f, -0.02143364f, -0.00637398f, 0.02268908f, 
    -0.04133993f, -0.02066211f, -0.02225408f, 0.00452078f, 0.00547658f, -0.01053422f, -0.01205960f, -0.03560255f, 
    -0.01199667f, 0.01533964f, 0.00964713f, -0.03957306f, 0.01622439f, -0.01997496f, 0.02712531f, -0.02196424f, 
    0.03076582f, 0.03587225f, -0.01738687f, 0.02781256f, -0.03318280f, -0.01904041f, 0.01266807f, 0.00317994f, 
    -0.02028169f, 0.00235992f, 0.01771510f, 0.02717060f, -0.01504031f, -0.03034525f, -0.00157346f, 0.00807594f, 
    0.00254467f, -0.01498373f, 0.03202220f, -0.02393349f, -0.02167277f, 0.03789138f, -0.00678011f, -0.04376255f, 
    0.02137980f, 0.01454221f, -0.01224995f, 0.00219227f, -0.02564586f, -0.01539380f, 0.02890010f, -0.01672098f, 
    0.01817361f, -0.02772096f, 0.02645004f, 0.00466700f, -0.03204342f, -0.00208162f, -0.03132538f, -0.02744564f, 
    -0.01356041f, -0.01826149f, 0.02069803f, -0.00122294f, 0.00828556f, 0.02389705f, -0.01785887f, -0.01236507f, 
    -0.02160988f, 0.00610566f, -0.01022994f, -0.00092949f, -0.02485905f, -0.03740582f, -0.03706012f, -0.01428394f, 
    0.01476297f, -0.01476584f, 0.01901288f, -0.01109794f, -0.03742025f, -0.00767962f, -0.03670127f, -0.00244451f, 
    0.01979334f, 0.00110521f, -0.00722359f, 0.01409006f, -0.00341107f, -0.01145199f, -0.01625383f, 0.00205076f, 
    0.01463214f, -0.01546264f, -0.01358910f, 0.01276985f, 0.03702480f, 0.00465402f, -0.03102506f, 0.01618532f, 
    -0.01092720f, -0.02610567f, 0.02940683f, -0.03092139f, 0.00269230f, -0.04387975f, -0.03515437f, 0.02685464f, 
    -0.03755852f, -0.00918366f, -0.00032330f, -0.01995326f, -0.02020611f, -0.03006794f, 0.01707269f, 0.02632409f, 
    0.02692528f, 0.00852078f, -0.00477467f, -0.02089730f, -0.03110764f, -0.01218999f, 0.00993287f, 0.01682723f, 
    0.00849156f, -0.03665441f, -0.02601536f, -0.02364536f, -0.00945562f, -0.02372889f, -0.02748000f, 0.01886862f, 
    -0.00988232f, 0.00935578f, -0.02060848f, -0.01383743f, 0.02172395f, 0.00400766f, 0.00752090f, 0.01983566f, 
    0.00816074f, -0.00003205f, 0.01776659f, -0.04110387f, -0.03245049f, 0.01301808f, -0.02636568f, -0.02103998f, 
    -0.00265836f, -0.02100009f, -0.03397336f, 0.02300015f, 0.00708929f, 0.01635003f, -0.00700337f, 0.00195677f, 
    -0.03925924f, -0.01393496f, -0.02564332f, -0.00070510f, -0.04210344f, 0.00376087f, -0.01284222f, -0.00597159f, 
    0.03974681f, 0.02401533f, 0.01968076f, -0.04222635f, -0.01612317f, -0.02562153f, -0.01778551f, -0.02233895f, 
    0.02940379f, -0.01527350f, -0.00509575f, -0.02171403f, -0.02476485f, 0.04068940f, 0.02667177f, -0.02615648f, 
    -0.00284118f, 0.02184716f, -0.03809987f, -0.00523283f, 0.00520269f, 0.01564384f, -0.00075974f, 0.02139664f, 
    0.01521705f, 0.04194023f, -0.01129661f, 0.01621763f, 0.00474953f, -0.00027863f, -0.02410517f, -0.03888064f, 
    0.01813065f, -0.04138034f, -0.04336328f, -0.03931461f, -0.01081326f, 0.02746546f, 0.00044250f, 0.00265397f, 
    -0.01689503f, 0.00332767f, 0.00773201f, 0.01633437f, 0.01496649f, -0.00810642f, 0.00938826f, 0.02735159f, 
    -0.00720942f, -0.00403446f, -0.00800170f, 0.01909673f, -0.01440340f, 0.00149637f, -0.02070117f, -0.01872549f, 
    -0.02055547f, -0.00375478f, -0.00828430f, -0.00918214f, -0.01210117f, 0.00680573f, 0.02792370f, 0.02304794f, 
    0.00979182f, -0.00484175f, 0.04018430f, -0.00390840f, 0.03611523f, 0.02150543f, -0.00361447f, -0.03136461f, 
    -0.01250848f, -0.03487700f, 0.03040922f, 0.00938469f, 0.01755019f, -0.01043922f, -0.02344771f, -0.02614355f, 
    -0.03177683f, 0.02079801f, -0.01615418f, -0.00378132f, -0.02265189f, 0.02063981f, 0.00868581f, 0.00200958f, 
    0.01768931f, 0.02500884f, 0.02719004f, 0.02142333f, 0.02185664f, -0.04023785f, -0.03351657f, -0.03903228f, 
    -0.01618453f, -0.02802255f, 0.02671682f, -0.01980686f, -0.00425395f, 0.00457937f, -0.04345215f, 0.02408739f, 
    -0.01359324f, -0.02353838f, -0.02300271f, -0.03525696f, -0.03814580f, 0.02088556f, 0.01262585f, -0.04191639f, 
    -0.01504549f, -0.01384644f, -0.03580243f, -0.00572597f, 0.01677310f, -0.02079499f, -0.01601005f, -0.00050181f, 
    -0.00719786f, 0.00825173f, 0.01217118f, 0.01083242f, -0.04129697f, -0.01043217f, -0.01888026f, -0.01622816f, 
    0.22044499f, 0.05878146f, 0.03560593f, -0.01548635f, 0.03119510f, -0.07201032f, 0.08710655f, 0.07470145f, 
    0.11883933f, 0.06471106f, 0.05422086f, -0.09977091f, -0.16561788f, -0.04218363f, -0.00140932f, -0.04486397f, 
    0.13259056f, 0.07170159f, 0.02682255f, -0.07196026f, 0.02523358f, -0.00514705f, 0.02851232f, 0.05214283f, 
    -0.21746926f, -0.14476308f, 0.09830566f, 0.09719636f, 0.00513364f, 0.09616786f, 0.01279549f, 0.10464934f, 
    -0.05487509f, -0.11017110f, -0.03628794f, 0.01800539f, 0.26394454f, 0.03563478f, -0.02753508f, 0.05205094f, 
    -0.08098235f, 0.00812870f, 0.08749863f, 0.03949858f, 0.10380794f, -0.01511621f, -0.00359707f, 0.03179025f, 
    0.31341869f, 0.00472884f, 0.05378484f, -0.05274999f, -0.05536880f, -0.00934157f, 0.03266793f, -0.01294295f, 
    -0.11124448f, 0.01763239f, 0.04555131f, 0.01002186f, 0.12516010f, 0.09195078f, 0.12445787f, 0.09335171f, 
    -0.11018488f, -0.10729064f, -0.03124011f, 0.04112130f, -0.01695159f, 0.00116617f, -0.03830298f, -0.00488052f, 
    -0.02861644f, -0.02018710f, 0.00389068f, -0.12753658f, -0.00005029f, 0.03692642f, -0.07040333f, 0.04919320f, 
    0.02042893f, 0.01743434f, -0.05929589f, 0.01729231f, -0.03089674f, -0.01165643f, -0.10649569f, -0.01956229f, 
    0.04168718f, -0.12441757f, 0.04298370f, 0.10024571f, 0.04196059f, 0.13140778f, -0.01467435f, 0.14400399f, 
    -0.17489724f, 0.01041517f, 0.15723446f, 0.02073924f, 0.11921974f, -0.06722919f, 0.02739362f, 0.03209194f, 
    -0.05581643f, 0.04983833f, 0.15711543f, 0.01406459f, -0.03217233f, -0.03898486f, 0.12105133f, 0.08256485f, 
    -0.08590925f, -0.07461030f, -0.02785616f, 0.01480581f, 0.05809378f, -0.06931780f, 0.01039084f, 0.04495030f, 
    0.03445358f, -0.12728573f, -0.02619578f, 0.04741742f, 0.02806520f, 0.07289162f, -0.00452282f, 0.02331303f, 
    0.12294477f, 0.16326402f, -0.13279381f, 0.14902064f, -0.18918625f, 0.08189251f, 0.02855842f, 0.03012586f, 
    0.00480241f, 0.04134163f, 0.03255954f, -0.01991876f, 0.06967825f, -0.03334137f, -0.06732365f, -0.01475508f, 
    -0.22170950f, -0.03258607f, 0.01516570f, -0.09580748f, 0.07575539f, -0.02284979f, -0.07195791f, 0.05255622f, 
    -0.01111853f, 0.02430838f, -0.09365881f, 0.17697713f, 0.02376583f, -0.04384790f, 0.06333848f, 0.07619552f, 
    0.02139607f, 0.10214038f, 0.00269541f, 0.08583321f, 0.04603855f, 0.12811553f, -0.12905189f, 0.01555089f, 
    -0.18072377f, 0.06572298f, -0.05174272f, 0.12391285f, -0.00916642f, 0.12303115f, 0.04133847f, 0.04519932f, 
    0.06551219f, -0.09174887f, 0.00517215f, 0.01418597f, -0.11433502f, -0.07710768f, -0.09922510f, 0.05529150f, 
    0.01811268f, 0.09629039f, 0.05638318f, 0.05212977f, 0.02701475f, 0.14435224f, -0.00781145f, -0.06004457f, 
    0.10211466f, 0.19001806f, -0.00982269f, 0.09055009f, -0.08121881f, 0.07634824f, -0.03518280f, 0.05030657f, 
    0.00042953f, 0.12732464f, -0.04592826f, 0.06189473f, 0.27881354f, 0.19942911f, 0.01950655f, -0.10544310f, 
    -0.04926779f, 0.08592401f, 0.00726449f, 0.08953483f, 0.07967158f, -0.09301703f, 0.02480394f, 0.08405118f, 
    -0.07898874f, -0.10872225f, 0.06489690f, 0.06044736f, 0.03671929f, 0.05002267f, -0.00106956f, 0.03435520f, 
    -0.00223074f, -0.04367407f, 0.03003545f, -0.09114682f, -0.03307465f, -0.12120023f, 0.01178586f, -0.07801351f, 
    0.05873878f, 0.04842941f, -0.02583577f, 0.01718893f, -0.15704297f, -0.01065449f, 0.14727119f, 0.12235399f, 
    0.14061540f, 0.09911514f, 0.01565199f, -0.04262637f, -0.15388636f, -0.01328235f, 0.03458772f, 0.07896666f, 
    -0.09676213f, 0.00496256f, 0.09590973f, -0.00600406f, 0.20854299f, -0.03249407f, 0.18603820f, 0.06829362f, 
    -0.12646668f, 0.01001550f, -0.00029719f, 0.00256730f, 0.08097944f, 0.02399921f, 0.04413761f, -0.00820067f, 
    0.32185686f, 0.05853372f, 0.05123135f, -0.01048754f, -0.00686650f, -0.09227098f, 0.01777835f, 0.00711297f, 
    -0.00976996f, 0.03012313f, -0.07916103f, -0.02443255f, -0.16073322f, -0.01209666f, 0.06487000f, 0.13213627f, 
    -0.02334420f, 0.02590552f, 0.05601379f, 0.08178650f, 0.09929976f, -0.02463500f, 0.05995147f, -0.04670270f, 
    -0.09485929f, 0.03969004f, -0.00329575f, -0.06809840f, -0.06455959f, 0.01102552f, 0.10224210f, -0.06755509f, 
    -0.10923029f, 0.04450787f, 0.15355483f, -0.00004056f, 0.10364139f, 0.19706087f, -0.05286299f, 0.09917894f, 
    0.06552051f, -0.00509652f, -0.03116565f, -0.00073942f, -0.06289718f, 0.03825500f, -0.08468629f, -0.00567312f, 
    0.36616609f, 0.15304264f, 0.20038652f, 0.00827531f, -0.10211013f, -0.12143871f, 0.00226524f, 0.00789194f, 
    0.02985615f, 0.05359107f, -0.01959658f, -0.14388664f, 0.23859346f, -0.04109593f, 0.05195500f, 0.03233713f, 
    -0.03104015f, 0.01079724f, -0.02205118f, 0.12496715f, 0.00737137f, -0.01363246f, 0.05019396f, 0.08802424f, 
    0.11606555f, -0.10472557f, 0.20958675f, 0.02522748f, -0.10182260f, 0.01898050f, 0.07828429f, 0.02312672f, 
    0.06512054f, 0.10136648f, 0.03399180f, 0.12140149f, -0.11373163f, -0.12727085f, 0.02467717f, 0.06171862f, 
    0.06723869f, 0.04535227f, 0.00954420f, 0.08882503f, 0.08681845f, -0.08086080f, 0.05424827f, -0.02388291f, 
    -0.23231274f, -0.06868757f, -0.10399397f, 0.05744838f, 0.07043215f, 0.14461370f, 0.12698114f, -0.02010940f, 
    0.04615951f, 0.05378844f, 0.03498433f, 0.16444696f, 0.17883018f, -0.14199287f, 0.00398359f, -0.11040483f, 
    0.17222874f, -0.05992987f, 0.01370280f, -0.04610413f, 0.02951634f, -0.03087834f, 0.01155423f, -0.08135395f, 
    0.17189555f, 0.01947706f, 0.02226901f, -0.06045560f, -0.10258490f, 0.07322853f, -0.00905669f, 0.03716655f, 
    -0.01243132f, -0.01795605f, -0.03257300f, -0.02360926f, 0.00302915f, 0.16531947f, 0.10221257f, 0.04881490f, 
    -0.08939388f, -0.03464677f, -0.06829610f, -0.00350974f, -0.02549066f, 0.04557951f, -0.10722037f, 0.02437340f, 
    -0.16072930f, -0.05001397f, -0.05691170f, -0.00074576f, -0.09155738f, 0.00043826f, 0.04652038f, 0.13684173f, 
    0.02882934f, 0.07713432f, 0.02808407f, -0.00595748f, -0.17493093f, 0.03699702f, -0.01452676f, -0.01057220f, 
    0.05318349f, 0.05845704f, 0.05772424f, 0.01447100f, 0.08096888f, -0.10299196f, 0.00309355f, -0.02267331f, 
    0.38439324f, 0.05991812f, -0.19476634f, 0.02287873f, -0.05441698f, 0.11343833f, 0.00525427f, -0.04596127f, 
    0.02314777f, -0.06451614f, -0.05740201f, -0.07058777f, -0.29236019f, -0.08028971f, -0.16381787f, 0.06454720f, 
    -0.00067733f, 0.07035273f, 0.04159930f, -0.02862281f, 0.01428137f, 0.03466925f, -0.10358682f, -0.10122996f, 
    0.12628970f, -0.11723458f, -0.11939954f, -0.17054531f, 0.04779298f, 0.03793694f, 0.01272857f, -0.07650137f, 
    0.11515068f, 0.11778073f, 0.02641774f, -0.01195763f, 0.10049128f, 0.15679283f, 0.03251811f, 0.02656146f, 
    -0.03881539f, 0.01540603f, -0.01929871f, -0.08373034f, -0.00680029f, -0.05321902f, 0.05163859f, -0.00116062f, 
    0.19695413f, 0.25747752f, 0.12239335f, -0.05658940f, -0.03975877f, 0.05914957f, -0.00472124f, -0.04488005f, 
    0.01980918f, 0.00799964f, -0.07963916f, -0.03170171f, 0.21428601f, 0.23302697f, 0.01853226f, -0.07841341f, 
    -0.15095636f, 0.01833137f, 0.00115339f, 0.12904082f, 0.16659763f, -0.06017340f, -0.04540844f, -0.04510107f, 
    0.03698294f, 0.14729321f, 0.07407922f, 0.09541681f, -0.03399933f, -0.07158088f, -0.04619391f, 0.07034315f, 
    -0.01483909f, -0.04087820f, -0.04516208f, -0.04051487f, 0.31801277f, -0.03106919f, -0.05212189f, -0.18144871f, 
    0.01428279f, -0.03606712f, 0.02059004f, 0.02619601f, -0.01541279f, 0.04384901f, 0.04153672f, -0.05211861f, 
    -0.33868349f, 0.06437823f, -0.09405925f, -0.03218083f, -0.08488747f, -0.03632599f, -0.01473552f, -0.00197239f, 
    0.01804506f, -0.07433873f, 0.03961295f, 0.08180376f, -0.21577011f, 0.11952349f, -0.23356734f, 0.01197307f, 
    0.01962633f, 0.03441205f, 0.08674297f, 0.04560459f, 0.04497587f, -0.01890619f, 0.04504375f, -0.03097648f, 
    -0.08176861f, 0.02006672f, -0.01013245f, 0.06733572f, 0.03113599f, 0.03925993f, 0.06913057f, -0.06275329f, 
    -0.06175872f, 0.08014171f, 0.08270676f, 0.20374282f, 0.13249239f, -0.00098498f, 0.02342059f, 0.03972428f, 
    0.02996027f, -0.12952991f, 0.06299300f, 0.03840385f, -0.05678185f, 0.01442709f, -0.02526056f, 0.04739931f, 
    -0.20055450f, -0.03905803f, 0.00412708f, 0.09394008f, -0.03767348f, 0.00670943f, -0.00884186f, 0.11666772f, 
    0.09072623f, 0.03686432f, -0.04396345f, -0.06660201f, -0.05097969f, 0.21808150f, 0.06870936f, 0.07930563f, 
    0.19337124f, 0.03727079f, 0.03287803f, 0.05842990f, 0.06581471f, -0.07834361f, 0.00388346f, -0.14429469f, 
    -0.09458451f, 0.05644108f, 0.16883112f, -0.02374411f, 0.03859367f, 0.01823174f, -0.05039772f, -0.01221607f, 
    0.00427539f, -0.03877951f, 0.02875158f, 0.00693292f, -0.33123061f, 0.10291988f, -0.09932572f, 0.05962393f, 
    0.07560647f, 0.03027739f, 0.00538232f, -0.01675925f, 0.04511530f, -0.08172912f, -0.05027454f, -0.01446030f, 
    -0.02381724f, -0.10026286f, 0.00991138f, -0.05657117f, 0.01835800f, -0.04632194f, -0.01803280f, -0.00569492f, 
    0.10213800f, 0.06314982f, 0.13171914f, 0.06750091f, 0.01372162f, 0.12356612f, 0.04015144f, 0.02842486f, 
    -0.07792971f, 0.09757967f, 0.03932386f, -0.02994435f, -0.06404512f, -0.10980402f, 0.05691706f, 0.06884051f, 
    0.17482644f, -0.14055474f, 0.00373771f, 0.00255819f, 0.04865751f, -0.04585255f, 0.11056034f, 0.06313068f, 
    -0.07571322f, 0.02928747f, -0.03913279f, 0.03632541f, 0.14236435f, -0.12207291f, -0.07058536f, -0.18633644f, 
    0.15864278f, 0.00787824f, -0.00772547f, 0.05971874f, 0.00177006f, -0.00508197f, 0.06780346f, 0.00596350f, 
    -0.01820087f, -0.18416873f, -0.03440072f, -0.01174951f, 0.09065378f, 0.11407842f, -0.02173223f, -0.02184217f, 
    0.05042282f, 0.06030604f, 0.01907110f, 0.11276335f, -0.11531543f, -0.05417813f, 0.04262636f, -0.03338242f, 
    0.00736243f, 0.11615025f, 0.05652335f, 0.06490819f, -0.01047360f, -0.00820320f, 0.01104907f, -0.02504103f, 
    0.26926267f, -0.00867695f, 0.14294757f, -0.06131094f, -0.08479707f, -0.01868394f, -0.02661905f, 0.04310190f, 
    0.07061861f, 0.09586201f, -0.09757102f, -0.03099300f, 0.04540472f, -0.15681687f, 0.06686345f, 0.01251746f, 
    -0.00747607f, -0.01930241f, -0.03603603f, 0.05635363f, -0.00618941f, 0.03055359f, -0.09378558f, -0.10738540f, 
    0.22023843f, 0.10025334f, 0.01069652f, 0.06764821f, 0.01307060f, 0.00232612f, -0.01746344f, -0.04913470f, 
    0.01373821f, -0.06075654f, 0.00239157f, 0.00954847f, -0.19146530f, -0.04864443f, -0.21868654f, -0.04922517f, 
    0.13644925f, 0.03712462f, 0.01452002f, -0.00604791f, 0.01755170f, -0.07145277f, -0.03071498f, 0.02463175f, 
    -0.23562331f, 0.09836072f, 0.16385467f, -0.00685223f, 0.01100134f, -0.09165152f, 0.14048591f, -0.00284426f, 
    -0.01895923f, -0.07114563f, -0.00615628f, 0.01167651f, -0.02186747f, 0.04457709f, -0.04247845f, 0.01166466f, 
    -0.00360769f, 0.03426223f, -0.06919441f, 0.07147478f, 0.03290053f, 0.05189320f, 0.04531619f, -0.04322300f, 
    -0.28718743f, 0.06782905f, 0.06722894f, -0.00304096f, 0.09320525f, 0.13358451f, -0.08376265f, -0.21131556f, 
    0.07505392f, -0.15836044f, 0.02099862f, 0.04574031f, 0.11837722f, 0.00477200f, -0.33336174f, -0.08561499f, 
    0.12156831f, 0.02908289f, -0.00106311f, 0.03541279f, 0.12794873f, -0.05344962f, -0.13490741f, 0.02830432f, 
    -0.11193533f, -0.04122197f, 0.01628831f, 0.08047681f, 0.13343377f, -0.07492776f, 0.02003170f, -0.03399149f, 
    -0.01361861f, 0.10668255f, 0.02630500f, -0.04595901f, 0.22840190f, 0.17069143f, 0.20614392f, 0.13096052f, 
    0.01658215f, -0.07424542f, 0.00227408f, -0.00884270f, -0.10242297f, -0.07771050f, -0.00233967f, 0.04820190f, 
    0.14794977f, 0.15703543f, 0.03580730f, 0.11935347f, -0.00990283f, 0.02211054f, 0.00233965f, 0.17055283f, 
    0.04518296f, -0.00498781f, 0.00911181f, 0.08078304f, 0.30688968f, 0.31769115f, -0.10214250f, 0.03121632f, 
    -0.01818350f, -0.04817863f, 0.08699390f, -0.00165599f, 0.03379123f, -0.01252477f, 0.05899561f, 0.02899277f, 
    -0.08981574f, 0.07142557f, -0.09283063f, -0.06949271f, -0.03817698f, 0.04290732f, -0.02623237f, -0.01900029f, 
    0.17593053f, 0.00069271f, 0.01859096f, -0.04053086f, -0.15863334f, -0.02134916f, -0.14332706f, -0.28089604f, 
    0.17477107f, 0.21241035f, -0.08227171f, -0.16312723f, 0.17679188f, -0.11528163f, -0.03686472f, -0.00537414f, 
    0.18775137f, -0.04584837f, -0.01704319f, 0.02181533f, -0.05779519f, 0.02197586f, 0.05716662f, -0.05894570f, 
    0.05174962f, -0.01052836f, -0.03092217f, -0.02297307f, 0.13912080f, -0.01468492f, 0.13363715f, -0.00835344f, 
    -0.06072071f, -0.02686087f, 0.10442384f, -0.04876525f, 0.01449138f, -0.05796451f, 0.05658641f, 0.02695093f, 
    0.06591063f, -0.13234948f, -0.20594332f, -0.05091529f, 0.05948910f, 0.04382101f, -0.04374500f, 0.02445530f, 
    0.00624104f, -0.04417189f, 0.05344613f, -0.09388926f, 0.01874371f, -0.10319762f, -0.03561464f, -0.00461772f, 
    -0.01442159f, 0.03942537f, -0.07720286f, -0.00857723f, -0.04419035f, 0.03610319f, 0.21828043f, -0.02922877f, 
    -0.09687773f, -0.01777505f, -0.20566536f, -0.22314702f, 0.03841568f, 0.09523846f, 0.01489563f, 0.01483539f, 
    0.03579685f, -0.02890789f, 0.09589436f, -0.18688767f, -0.10767156f, -0.06984816f, 0.05573926f, -0.11950173f, 
    0.00743515f, -0.06299255f, 0.04797707f, 0.01614646f, 0.06956198f, -0.11851042f, 0.09651264f, 0.09279022f, 
    -0.05919997f, -0.04842125f, 0.00840483f, -0.03465923f, -0.00219392f, 0.00049639f, -0.17634441f, 0.00109012f, 
    -0.07963851f, 0.14861557f, 0.07622159f, 0.00714142f, -0.30351505f, 0.05591933f, -0.17278759f, -0.06604263f, 
    0.06106432f, 0.03411469f, -0.09930874f, 0.00428641f, 0.13840058f, -0.04065561f, 0.04615349f, 0.06456611f, 
    0.23106132f, 0.04114011f, 0.10610272f, -0.01294879f, -0.02036353f, -0.04727066f, 0.01038943f, -0.01046335f, 
    0.11225149f, 0.00484539f, 0.02064163f, -0.03591413f, 0.11576239f, -0.02808902f, 0.03857743f, 0.12250108f, 
    -0.07029692f, -0.03557732f, 0.02494728f, -0.03521125f, -0.03051230f, 0.15732667f, 0.12626992f, 0.01809906f, 
    0.07656953f, 0.10936818f, 0.03436622f, 0.00623932f, -0.07410215f, -0.13667130f, 0.04404993f, 0.00103481f, 
    -0.03880660f, 0.08138784f, 0.04498187f, 0.16110665f, -0.03681114f, -0.04373212f, 0.17909148f, 0.06703866f, 
    -0.02779683f, 0.02285568f, 0.26666063f, 0.01748209f, 0.02786597f, -0.02489182f, -0.15864152f, -0.02900162f, 
    0.15757777f, -0.02548341f, 0.22916205f, 0.35095352f, -0.00913558f, 0.06429662f, 0.12573960f, -0.02599617f, 
    0.03223917f, 0.01060379f, -0.02062945f, 0.04169583f, 0.09625789f, 0.13593152f, -0.05364691f, 0.14127320f, 
    0.08976003f, -0.01763154f, 0.00588568f, -0.03256438f, -0.07402026f, 0.04341292f, 0.02096740f, 0.00494962f, 
    0.25792903f, 0.12671676f, -0.06767396f, 0.23048615f, 0.02335931f, -0.01717789f, -0.01785786f, -0.01448902f, 
    0.02052733f, -0.05378366f, -0.04501050f, 0.10642050f, 0.33452666f, 0.09706430f, -0.06756224f, 0.11587618f, 
    -0.01406427f, 0.00354843f, -0.18134776f, -0.07451831f, -0.15433834f, 0.08343140f, -0.13536429f, 0.02831433f, 
    -0.02184022f, -0.00276265f, -0.11274415f, -0.01459303f, 0.09244582f, -0.02687516f, -0.13161373f, 0.08359295f, 
    0.24171163f, -0.03528841f, -0.15227485f, -0.01639461f, 0.18743446f, -0.00595509f, 0.08032585f, 0.16923413f, 
    -0.01822772f, -0.01538752f, 0.01978493f, 0.00289937f, 0.01692485f, -0.04813203f, 0.09000393f, -0.05793786f, 
    0.16371548f, 0.21330710f, 0.04492909f, 0.16396630f, -0.00783371f, 0.04277693f, 0.00541248f, -0.06279077f, 
    0.01379648f, 0.03516612f, 0.01551515f, 0.21798494f, 0.05244599f, 0.11747432f, 0.14541845f, 0.03136985f, 
    -0.08444192f, -0.21580112f, -0.05555918f, -0.05564663f, 0.03825933f, 0.04670420f, -0.03100440f, 0.01899549f, 
    -0.14251058f, -0.12046828f, -0.02422199f, 0.21866955f, 0.00599736f, 0.10410339f, 0.02217976f, 0.05924240f, 
    -0.13881376f, -0.03341774f, -0.06823753f, -0.07553175f, -0.05462703f, 0.12791343f, -0.03893782f, -0.11270907f, 
    -0.06361644f, 0.02330887f, 0.05093181f, -0.01162716f, -0.04281305f, -0.02755669f, 0.00777270f, 0.08874826f, 
    0.10252633f, 0.03799370f, 0.09072051f, -0.04970170f, 0.03174203f, -0.05518242f, -0.16455404f, 0.02245934f, 
    0.04394073f, -0.02082827f, -0.06287976f, -0.12922914f, 0.15623328f, 0.07214689f, 0.06403318f, -0.03909845f, 
    -0.06283450f, 0.04536095f, -0.04383443f, 0.11706787f, 0.07998972f, -0.01742296f, -0.05490052f, -0.04834796f, 
    -0.04373413f, -0.06554557f, -0.04357711f, 0.03249302f, -0.02312160f, -0.09853821f, -0.00787981f, 0.00578256f, 
    0.02542094f, 0.01320127f, 0.07955535f, 0.06364022f, 0.31542206f, 0.03771020f, 0.11389831f, 0.17054455f, 
    -0.00536042f, -0.03703843f, 0.06181370f, 0.04200355f, 0.01720298f, -0.04087300f, -0.03764243f, -0.06154255f, 
    -0.04591473f, -0.02937782f, 0.01986608f, -0.06271737f, 0.03430133f, 0.02974642f, -0.05417886f, -0.16365404f, 
    -0.07325416f, -0.08863859f, 0.10872559f, -0.01374588f, -0.00431389f, -0.01626983f, 0.04150797f, -0.11726004f, 
    -0.01500409f, 0.01677517f, -0.00888069f, -0.03731199f, -0.03120185f, 0.06132800f, 0.01534136f, 0.05643823f, 
    0.07667576f, -0.04025764f, 0.27430296f, 0.04166302f, -0.04407054f, -0.02655566f, -0.09181204f, -0.02659372f, 
    0.02056139f, 0.06710122f, -0.05477384f, 0.08296526f, -0.09734876f, -0.10099190f, -0.22318031f, 0.12161778f, 
    0.06057660f, 0.00434193f, 0.02097227f, 0.04580871f, 0.06668786f, -0.10995854f, 0.04525249f, -0.03877231f, 
    -0.13547258f, -0.01332145f, -0.19975002f, -0.03054587f, 0.07555259f, 0.01842146f, -0.10070755f, -0.00453901f, 
    0.02634080f, -0.10711114f, 0.04493909f, 0.02667791f, 0.04499252f, -0.07998350f, 0.10928617f, -0.04893330f, 
    0.05191840f, -0.01594769f, 0.00878571f, -0.01201457f, 0.04751366f, 0.05081522f, 0.07604651f, -0.03885483f, 
    0.03481876f, 0.01256619f, -0.02693993f, 0.16613716f, -0.03843744f, 0.01373952f, -0.02865816f, 0.10620752f, 
    0.02415090f, 0.01409676f, -0.05293255f, 0.06506566f, 0.25705975f, 0.00512012f, 0.22058055f, 0.23166180f, 
    0.04876253f, 0.04078825f, 0.07075952f, -0.07097193f, -0.03244213f, 0.03915457f, 0.01676417f, 0.20352611f, 
    0.25782487f, 0.09805226f, 0.09779877f, -0.05910445f, -0.00749380f, 0.05471762f, 0.07810874f, -0.03640753f, 
    -0.05639460f, -0.02727425f, 0.07776096f, -0.12698662f, -0.09906088f, -0.04432196f, 0.10398216f, -0.04714118f, 
    0.06464590f, -0.08862226f, 0.04561235f, -0.02016439f, 0.07435088f, -0.04913226f, 0.02164548f, 0.03518729f, 
    -0.25352952f, 0.09091236f, 0.02039305f, -0.12780911f, 0.03598012f, -0.01820567f, 0.04221220f, 0.00586478f, 
    -0.00995088f, -0.01152116f, 0.00895132f, -0.05643488f, -0.27400953f, -0.20379357f, -0.00314275f, -0.07621466f, 
    -0.02532448f, -0.04405612f, -0.00925877f, -0.06721921f, 0.03211071f, -0.00934588f, 0.02621972f, 0.05253458f, 
    0.22827099f, 0.01584219f, 0.09931669f, -0.07782365f, -0.04215997f, 0.07459845f, 0.00391654f, 0.01164739f, 
    0.01783400f, -0.10351168f, -0.02957557f, -0.16510379f, -0.01341126f, 0.08178369f, -0.07072806f, -0.20679758f, 
    0.06925998f, 0.16171034f, -0.03774249f, 0.08370164f, 0.07136638f, 0.03635228f, -0.02217296f, -0.03058514f, 
    -0.06267153f, -0.04273233f, 0.06779727f, 0.05375837f, 0.04754134f, -0.02882770f, -0.06580542f, -0.00583433f, 
    -0.07340658f, -0.00671998f, 0.08397894f, 0.05757980f, -0.18909377f, 0.04338234f, 0.16277188f, -0.17437719f, 
    0.07417315f, 0.05954505f, -0.11345452f, -0.03399502f, -0.01384195f, 0.12801667f, -0.02959690f, 0.05791966f, 
    0.08491854f, -0.12082200f, -0.07671580f, 0.01399440f, -0.04031372f, -0.07157056f, -0.01170068f, -0.05312886f, 
    -0.01519737f, 0.05359988f, 0.07450646f, 0.13102764f, -0.22308810f, -0.03460580f, 0.06834057f, -0.06070056f, 
    0.09692305f, -0.04403410f, -0.06499415f, 0.07823299f, 0.08546223f, 0.04341419f, 0.04074088f, 0.05810419f, 
    -0.10388768f, -0.04465125f, -0.08259036f, -0.09862991f, 0.12651256f, 0.09989204f, -0.07461373f, -0.02901372f, 
    -0.07296954f, -0.10058530f, -0.02499488f, -0.01349585f, 0.02557640f, 0.06207651f, 0.04891974f, -0.06211704f, 
    0.09170210f, -0.00383823f, -0.02801116f, 0.03948229f, 0.00779080f, 0.06743954f, -0.04607036f, -0.11359836f, 
    -0.14211889f, -0.08842347f, 0.06643945f, -0.17792660f, 0.02267896f, -0.02068419f, -0.06020915f, -0.08721295f, 
    0.03932343f, 0.01171195f, 0.08699011f, -0.03371501f, -0.05659397f, -0.03413344f, 0.04523635f, -0.32597825f, 
    0.00407715f, 0.03589870f, 0.05951522f, -0.09510861f, 0.03630293f, 0.00371143f, 0.00014218f, 0.04409185f, 
    -0.23551683f, -0.23502672f, -0.10300308f, -0.05089859f, 0.07468245f, -0.01855671f, 0.00597116f, 0.02152469f, 
    0.04380986f, 0.00286754f, 0.14154363f, -0.15507025f, 0.07541578f, 0.10709055f, 0.07803030f, -0.04686205f, 
    0.06748444f, -0.14728151f, 0.00087956f, -0.09192429f, -0.01135706f, 0.02931990f, 0.00280300f, 0.05426851f, 
    0.08717027f, 0.17965274f, 0.01174699f, 0.10080007f, 0.04077053f, 0.02270437f, -0.04972460f, 0.05621098f, 
    -0.03781676f, -0.17132214f, 0.02403122f, 0.02436643f, 0.25911221f, 0.13013186f, -0.01274080f, 0.26179692f, 
    -0.06184115f, -0.02922135f, 0.03024983f, -0.14168677f, -0.03863939f, -0.03487638f, 0.12114165f, 0.02465451f, 
    -0.03265080f, -0.05557156f, 0.03743925f, 0.15154986f, 0.04130826f, -0.04085869f, 0.07717621f, 0.12771942f, 
    -0.03652584f, -0.00186728f, 0.08420404f, -0.04309669f, -0.17229155f, -0.20688018f, -0.09558902f, -0.03602936f, 
    0.06699808f, 0.01859240f, -0.01500629f, -0.04996555f, 0.01644501f, 0.03129868f, 0.09947327f, -0.02250920f, 
    -0.13373530f, -0.03430048f, -0.05205168f, 0.05550301f, 0.10203736f, 0.10790471f, -0.04118311f, -0.03704366f, 
    0.04564290f, 0.07472659f, 0.09874742f, -0.00851443f, -0.03129448f, -0.10521478f, 0.08725915f, -0.10764383f, 
    0.10923101f, -0.05318593f, 0.09307687f, -0.03611436f, 0.00849702f, -0.07902126f, -0.02963050f, 0.10271774f, 
    0.01980165f, 0.00869575f, -0.01945349f, -0.00982405f, 0.00627299f, -0.03870715f, -0.02212360f, 0.01682830f, 
    -0.00104977f, 0.01790516f, -0.01565111f, -0.00099316f, -0.00095913f, -0.03507646f, -0.01995525f, -0.00648549f, 
    0.01622784f, 0.00493169f, -0.00035128f, 0.00716002f, -0.01051830f, -0.02614673f, -0.02063653f, 0.02048006f, 
    0.01301138f, 0.02140959f, -0.02684429f, -0.03104366f, -0.03544597f, 0.01529668f, 0.00032805f, -0.02592003f, 
    -0.00068854f, -0.01967134f, -0.01127939f, 0.01749432f, 0.02168751f, 0.01028960f, 0.03363753f, -0.02402142f, 
    -0.01225667f, -0.01902167f, 0.00050318f, -0.01786559f, -0.02146964f, -0.02648352f, 0.03347066f, 0.00076382f, 
    -0.03675038f, -0.03317227f, -0.01140349f, 0.00199418f, -0.03429202f, -0.00627818f, -0.02541399f, -0.04096789f, 
    -0.00263822f, -0.02925391f, -0.03696235f, -0.03013318f, 0.03277913f, -0.02419272f, -0.03165111f, -0.00499322f, 
    0.01998988f, -0.03154645f, 0.00834421f, -0.03140865f, 0.02144986f, 0.02505559f, 0.01733570f, 0.00314497f, 
    0.03089841f, -0.01312604f, -0.03140588f, -0.02877692f, 0.01295030f, -0.00336627f, 0.03177220f, -0.00656506f, 
    -0.01560489f, 0.00227220f, 0.02527409f, 0.00843931f, 0.02125789f, 0.01814553f, -0.02298530f, -0.00656115f, 
    0.02558801f, -0.03710855f, -0.00285691f, 0.02037082f, 0.02025401f, -0.00349394f, -0.03017864f, 0.02746254f, 
    -0.03011676f, -0.03472911f, 0.01248869f, 0.00224300f, 0.01294170f, 0.00296232f, 0.01938870f, 0.02081450f, 
    0.01898894f, -0.03496219f, -0.00329871f, -0.03152525f, -0.03901608f, -0.01636990f, -0.03868848f, 0.03603004f, 
    0.00793529f, 0.02067933f, -0.03130557f, 0.02547845f, 0.02969259f, 0.00510698f, -0.00169499f, 0.02173963f, 
    -0.03902341f, 0.00136452f, 0.01745634f, -0.03648620f, -0.03664528f, 0.02309693f, -0.01400091f, 0.02831901f, 
    0.00005014f, -0.01024408f, -0.02388630f, -0.03017622f, 0.01628479f, -0.03413697f, 0.01921582f, 0.02567577f, 
    0.00987071f, -0.01088176f, -0.01008475f, 0.03014566f, -0.01080472f, 0.01623891f, -0.02297452f, 0.02748568f, 
    -0.01827862f, 0.02808913f, 0.01952770f, -0.01884978f, -0.00502193f, -0.03180614f, -0.00905532f, -0.01900147f, 
    -0.01681427f, 0.02302282f, -0.02350965f, -0.03300114f, -0.02362442f, -0.02577802f, -0.00266631f, 0.00009191f, 
    0.01430088f, 0.01513751f, -0.02089932f, 0.00322173f, 0.03326379f, 0.01171426f, -0.03964740f, -0.00442020f, 
    0.02643695f, -0.03330282f, -0.02237885f, -0.00854391f, -0.00491926f, 0.00245541f, -0.00520354f, -0.01149186f, 
    -0.01174937f, -0.00326127f, -0.03512961f, -0.02521447f, 0.02709974f, 0.00078633f, -0.02573203f, -0.02627231f, 
    0.02439674f, 0.02508968f, -0.03204580f, -0.01317523f, 0.00221551f, 0.02115890f, 0.00804199f, -0.00258962f, 
    0.01789819f, 0.03493772f, 0.01966275f, 0.00021590f, 0.01221607f, -0.03560347f, -0.00476052f, -0.01050879f, 
    -0.02894219f, -0.01456102f, -0.02361546f, -0.03637752f, 0.02358383f, 0.01214313f, -0.03392101f, 0.01943632f, 
    -0.04260571f, 0.02354374f, -0.01818769f, 0.03087940f, 0.01449644f, 0.01217295f, 0.01827864f, 0.01782149f, 
    0.00664192f, -0.03874101f, -0.00490947f, -0.01990311f, 0.02286232f, 0.01588691f, -0.03336851f, 0.01973814f, 
    0.02839466f, -0.04420268f, -0.03763229f, 0.04078665f, -0.02802090f, -0.03895894f, -0.02074332f, -0.00864792f, 
    -0.02195297f, -0.00626057f, -0.00628804f, -0.03512429f, 0.02015997f, 0.01701590f, -0.00092536f, 0.01184097f, 
    -0.03596433f, 0.00886338f, -0.00689495f, 0.01553602f, -0.01854324f, -0.02844599f, -0.01611772f, 0.02157758f, 
    0.01072474f, -0.03210065f, -0.01231708f, -0.04334787f, -0.02691896f, 0.00009708f, 0.01904424f, 0.01219049f, 
    -0.04081487f, -0.03014115f, 0.03097288f, 0.01216665f, -0.00353172f, -0.00903521f, -0.02694369f, 0.03263970f, 
    -0.02121983f, -0.01712029f, 0.01557126f, -0.02550073f, 0.02075106f, 0.01598717f, 0.02000215f, -0.00391805f, 
    0.01425749f, -0.02562355f, -0.00743507f, -0.02950991f, -0.01670856f, -0.03000648f, -0.02120886f, 0.00124009f, 
    -0.02255115f, 0.00930608f, -0.00625591f, -0.02558797f, 0.02511407f, -0.01764192f, -0.03066259f, 0.02216593f, 
    -0.00847760f, 0.00041558f, 0.00875663f, -0.03120315f, -0.00188334f, -0.01414338f, 0.02833545f, 0.02568555f, 
    -0.00322679f, 0.00171305f, 0.00745237f, -0.00992865f, -0.03340709f, -0.00785473f, -0.02604615f, -0.00133282f, 
    -0.04244215f, 0.02314430f, 0.01749866f, 0.00017643f, 0.02187330f, -0.01954789f, 0.01476649f, -0.00319971f, 
    0.01695827f, 0.01773710f, -0.02752518f, -0.00230267f, -0.01882987f, 0.00652405f, 0.01205538f, -0.01943335f, 
    -0.02364420f, 0.03282989f, -0.03664992f, -0.01416766f, -0.02391206f, 0.01084072f, 0.00158979f, 0.02499957f, 
    -0.01147667f, 0.00387994f, -0.00655141f, -0.02721608f, -0.00022099f, -0.01255968f, -0.02498126f, 0.00388342f, 
    -0.00494318f, -0.02986396f, -0.02377020f, 0.00943179f, -0.04123604f, -0.01876702f, 0.02276186f, -0.03259675f, 
    -0.00874036f, 0.00158283f, -0.03503284f, 0.01730497f, -0.02093363f, -0.02799409f, 0.00816591f, 0.02100485f, 
    -0.03947483f, -0.00295422f, -0.00356850f, -0.00347757f, -0.02257385f, 0.01516097f, -0.00474097f, 0.00887511f, 
    0.02612076f, -0.02614969f, 0.02784351f, -0.01487811f, -0.03152684f, -0.03505690f, 0.01692339f, 0.00806222f, 
    -0.01642415f, 0.00962750f, -0.01552145f, 0.01536817f, -0.03114248f, 0.03430355f, -0.01860272f, -0.00979284f, 
    -0.01557340f, -0.02437260f, 0.01787343f, -0.02970941f, -0.04333228f, 0.00079918f, 0.01362594f, -0.01552464f, 
    -0.01407000f, -0.00062610f, -0.01091679f, 0.01860527f, -0.02942856f, 0.00713629f, -0.02380511f, -0.03344662f, 
    -0.01468926f, -0.00076743f, 0.01722183f, -0.03053890f, 0.00943547f, -0.02553221f, 0.02454267f, 0.03208309f, 
    0.03259015f, 0.01176096f, 0.01880045f, 0.00470420f, -0.01610877f, -0.01617699f, 0.02380860f, 0.01536392f, 
    -0.01966138f, -0.00462033f, -0.02447439f, -0.01764945f, -0.03274945f, -0.03215966f, -0.02980186f, -0.02008779f, 
    0.02756012f, -0.04121319f, -0.01525601f, -0.02104690f, -0.00539412f, -0.02923282f, -0.03722878f, -0.01585265f, 
    -0.03191642f, -0.02783765f, -0.02378944f, -0.00289026f, 0.02038951f, -0.03338115f, -0.04075876f, -0.00945190f, 
    0.00000347f, -0.03254360f, 0.00317759f, -0.04145611f, -0.00519495f, -0.03393720f, -0.01693253f, -0.01060088f, 
    0.03265075f, -0.00411920f, -0.00788521f, -0.00957063f, 0.01793998f, -0.00728490f, 0.02005907f, 0.01599245f, 
    -0.02006519f, -0.03581512f, -0.00687858f, 0.00025091f, -0.00532254f, -0.00744431f, -0.03969558f, -0.01585647f, 
    0.01003294f, 0.00430972f, -0.00002079f, 0.00001301f, 0.01042675f, -0.02220978f, -0.02567987f, -0.00256416f, 
    -0.01886793f, -0.00739201f, -0.02929303f, 0.01705140f, -0.01375403f, 0.02058842f, 0.00503881f, -0.02780820f, 
    -0.00529727f, -0.02970879f, -0.03791599f, 0.02458079f, 0.00327231f, -0.00211010f, 0.00504143f, 0.00966828f, 
    -0.00718081f, 0.02429829f, -0.01158430f, -0.02845095f, 0.00619468f, 0.02754914f, 0.01783192f, -0.00443638f, 
    -0.00195567f, 0.01988351f, -0.00262290f, -0.02201268f, 0.03299130f, 0.01556836f, -0.02430785f, 0.01917685f, 
    -0.00365717f, -0.00276375f, -0.04023314f, -0.01536749f, -0.00332395f, 0.01182358f, 0.02046640f, 0.01914048f, 
    0.02133923f, 0.00491615f, 0.00468144f, 0.01052278f, -0.00882968f, -0.04101763f, -0.02823143f, 0.00656745f, 
    -0.00106711f, 0.01179357f, 0.02014255f, -0.00479932f, -0.03918476f, -0.01995297f, 0.02770834f, -0.04457551f, 
    0.00771301f, -0.03460823f, 0.01902000f, -0.01506408f, 0.00345624f, -0.04214846f, 0.01239268f, 0.02254879f, 
    0.00166117f, 0.01633205f, 0.02008362f, 0.00725490f, 0.01628076f, 0.01186886f, -0.03189874f, -0.01283812f, 
    0.02474992f, -0.03603004f, 0.01641545f, -0.02126899f, -0.00444143f, 0.02443387f, -0.03475279f, 0.02349635f, 
    -0.01640201f, 0.02208355f, -0.03391568f, 0.02282515f, -0.01294826f, -0.04148974f, -0.02698069f, -0.01583132f, 
    -0.00882387f, 0.01800475f, -0.03254281f, -0.00628564f, 0.04029616f, -0.02487941f, -0.01627334f, -0.01840392f, 
    -0.02314270f, 0.00822632f, -0.03248028f, -0.01291586f, -0.01650590f, 0.00812296f, -0.00757718f, 0.01710013f, 
    -0.00290335f, 0.00720809f, 0.01643905f, 0.02568770f, 0.01091408f, -0.03189810f, -0.00692027f, -0.03722801f, 
    0.02577094f, -0.02657947f, 0.00227632f, -0.02739076f, -0.04258290f, -0.02530853f, 0.01874254f, 0.00694806f, 
    -0.03618247f, 0.00106450f, 0.00821168f, 0.01182890f, 0.01681870f, -0.01257679f, -0.01061928f, -0.03756789f, 
    0.02727626f, -0.00577348f, -0.01771432f, -0.02668148f, 0.01446003f, -0.02290172f, -0.00029827f, 0.03343251f, 
    -0.02733183f, 0.01536411f, -0.02370157f, 0.01535126f, 0.00482986f, 0.02187199f, -0.03284044f, -0.01365195f, 
    -0.00145242f, 0.01499421f, -0.00239680f, 0.00664578f, 0.00400159f, -0.01951432f, 0.03009992f, -0.02577888f, 
    -0.01683646f, 0.01169446f, 0.01066659f, 0.02206186f, -0.02696834f, -0.01027395f, 0.01352148f, 0.00706936f, 
    0.02230950f, -0.01929140f, -0.01688838f, 0.01684702f, -0.03005218f, -0.01019756f, 0.02704444f, 0.01411867f, 
    -0.02989751f, -0.02682897f, 0.01049881f, 0.01811354f, 0.01871859f, 0.02377318f, 0.02749094f, 0.01778779f, 
    0.02833198f, 0.01177263f, 0.01267166f, 0.03297725f, 0.01088751f, -0.01725920f, 0.02277930f, -0.02252420f, 
    0.02180376f, -0.02714667f, -0.00838116f, -0.02790825f, -0.01175692f, -0.00415620f, -0.02845352f, -0.01817552f, 
    -0.02879670f, -0.02488000f, -0.03550598f, -0.01144730f, -0.02012818f, -0.00009653f, -0.03537252f, -0.03139066f, 
    0.01119399f, -0.00947496f, 0.01715799f, -0.02458612f, 0.01074532f, -0.01146597f, 0.03664773f, 0.02550316f, 
    -0.03760186f, 0.00708576f, -0.00255975f, 0.00521401f, -0.01827541f, 0.00272879f, 0.00649264f, -0.00516859f, 
    -0.01956182f, 0.02690674f, 0.02127182f, -0.04075314f, -0.03228408f, 0.00890037f, -0.01317681f, 0.03003821f, 
    0.02458546f, -0.03331348f, 0.02379029f, 0.00477683f, -0.02126742f, 0.02905276f, -0.03208238f, 0.00239835f, 
    -0.01870417f, -0.02021151f, -0.03002976f, -0.03662680f, 0.00455653f, -0.00678005f, -0.01393780f, -0.00125629f, 
    -0.02138177f, 0.00938839f, 0.00514188f, -0.01095561f, -0.03079111f, -0.01723132f, 0.00931012f, -0.00421440f, 
    -0.03631322f, 0.00487791f, -0.00996950f, -0.03398310f, 0.02742839f, -0.02827350f, 0.01023963f, -0.03021381f, 
    -0.00746073f, -0.04517266f, -0.01352090f, -0.00966722f, 0.01398419f, -0.01594162f, -0.00099729f, 0.02526402f, 
    -0.00934312f, -0.03648633f, -0.03550522f, 0.00933482f, -0.00835731f, 0.01938454f, -0.02024182f, -0.04248808f, 
    -0.03027985f, 0.01661499f, -0.01325581f, -0.04154610f, -0.00948334f, 0.00273906f, -0.02646690f, -0.04531329f, 
    0.01288008f, -0.00530229f, -0.00616459f, 0.02162629f, 0.01182242f, -0.00476872f, -0.01035471f, -0.01926926f, 
    0.02386535f, 0.00869357f, 0.02066291f, 0.02107464f, -0.00184614f, 0.02187443f, -0.00552027f, 0.00288064f, 
    -0.04357658f, -0.03313299f, -0.03004871f, 0.00395660f, -0.00284287f, -0.02659748f, 0.01536014f, -0.04191570f, 
    -0.25862649f, 0.09550942f, 0.00083579f, -0.07194843f, 0.00184705f, 0.12353998f, -0.06373917f, 0.03774948f, 
    -0.05339523f, -0.01238660f, -0.03465316f, -0.02409638f, 0.26147160f, -0.17498337f, -0.22572532f, 0.06983179f, 
    -0.03573688f, -0.02195129f, 0.00876701f, 0.04656907f, -0.04300709f, -0.04269350f, -0.04921413f, -0.02644124f, 
    0.19841564f, 0.13665408f, -0.05270775f, -0.16876088f, 0.05527146f, -0.00690028f, -0.01861899f, -0.13301286f, 
    -0.01006457f, -0.04793294f, 0.05996329f, -0.05176473f, -0.10400664f, 0.13816972f, 0.14460696f, -0.03875195f, 
    0.02412557f, -0.01756759f, 0.03241933f, -0.00747944f, 0.00570762f, -0.00465516f, -0.05392678f, -0.10784490f, 
    -0.28077286f, 0.07292574f, 0.14784648f, 0.05335839f, -0.07816570f, 0.12039788f, 0.08601572f, 0.02096239f, 
    0.03639456f, -0.06631158f, 0.07242111f, 0.09452207f, -0.09775912f, -0.00880950f, 0.01245471f, 0.09937045f, 
    -0.04544025f, -0.01180462f, -0.02307524f, -0.04819055f, 0.04612001f, 0.01279408f, -0.01186810f, -0.08461577f, 
    -0.17583293f, -0.03101587f, -0.13807291f, 0.04869640f, -0.08406758f, -0.05325034f, 0.07289014f, 0.11030476f, 
    0.04938871f, 0.07163390f, -0.11003233f, -0.06532693f, 0.04699720f, -0.01295491f, -0.15052877f, -0.01973442f, 
    -0.06564194f, 0.10518838f, -0.01722672f, 0.02327145f, -0.00745808f, 0.03846642f, -0.07312307f, -0.04409683f, 
    0.02371339f, 0.07497334f, 0.06364260f, 0.01634387f, -0.09889528f, -0.03339510f, 0.12180049f, -0.01994885f, 
    -0.02264097f, -0.06425010f, 0.11687563f, -0.05737666f, 0.01281726f, 0.09878228f, 0.16823091f, -0.05015698f, 
    -0.05884613f, -0.01823692f, -0.05312443f, -0.06315215f, -0.05927956f, 0.04012847f, -0.02784254f, -0.04730639f, 
    0.21117711f, -0.03921992f, -0.07363200f, 0.04607617f, 0.06495085f, -0.00590537f, 0.05309708f, -0.02239453f, 
    -0.11123127f, 0.03014114f, 0.01428611f, 0.01312378f, 0.11440115f, 0.01837766f, -0.02996481f, -0.07303181f, 
    -0.03264098f, -0.00258703f, -0.06125228f, 0.06019383f, -0.08362180f, -0.00903921f, 0.08112364f, -0.14618498f, 
    0.19421034f, -0.10382960f, -0.14444079f, -0.06494851f, -0.00017462f, -0.13668644f, 0.00382382f, 0.06891770f, 
    -0.02696074f, 0.16945741f, 0.04828379f, 0.04862883f, 0.10200370f, 0.13603088f, -0.01122224f, -0.12668519f, 
    -0.08099427f, 0.00275239f, 0.08958853f, 0.02577810f, -0.09462684f, -0.02483145f, -0.03056750f, 0.05023479f, 
    0.09960628f, 0.11541139f, 0.03062570f, -0.01518152f, 0.03038420f, 0.05250441f, -0.05304605f, -0.03135455f, 
    -0.10323334f, 0.02080074f, -0.02644666f, -0.03033912f, 0.09372712f, 0.11488989f, 0.00546872f, 0.09796152f, 
    0.00124298f, 0.00552749f, 0.02201963f, 0.06534076f, -0.03282745f, 0.00489032f, 0.06979976f, 0.00635004f, 
    0.12106372f, 0.00780334f, 0.17153814f, -0.08807972f, 0.01084243f, 0.03397153f, 0.03059765f, 0.10058673f, 
    -0.04427860f, 0.04400361f, 0.04412348f, -0.04757737f, -0.15345988f, 0.00246710f, 0.07727229f, 0.00262933f, 
    0.04178657f, -0.08782261f, 0.05364352f, 0.00147484f, 0.03076966f, 0.06783211f, -0.02824172f, 0.00958524f, 
    -0.07882717f, 0.12074509f, -0.05593122f, -0.09323179f, 0.04270601f, 0.01722438f, 0.02008751f, -0.06874090f, 
    0.08350625f, 0.09123813f, -0.01461710f, 0.01282134f, 0.11998195f, 0.03697921f, 0.00473319f, 0.10303779f, 
    0.01348239f, -0.03404205f, 0.16641279f, 0.01734599f, -0.07174010f, -0.03706442f, -0.04848667f, 0.00471848f, 
    -0.04218110f, 0.07752701f, 0.13290945f, 0.00886390f, -0.02822154f, -0.02768928f, 0.10069191f, 0.01623216f, 
    0.00889110f, 0.11079124f, 0.08737946f, -0.05150365f, -0.41557023f, 0.17285869f, 0.22719532f, 0.13299158f, 
    -0.06851210f, -0.11875129f, 0.05831385f, 0.08192770f, -0.08751740f, -0.06377909f, -0.01689511f, -0.02426618f, 
    -0.23155537f, -0.01712417f, 0.08686730f, 0.07727676f, 0.00231091f, -0.01448732f, -0.01248264f, 0.02796545f, 
    0.09164711f, 0.03155672f, -0.10586393f, 0.00929395f, 0.07931489f, -0.17815077f, -0.01151335f, 0.18903981f, 
    0.06722800f, -0.08486710f, 0.00623116f, 0.01989853f, 0.00703371f, -0.04374982f, -0.04922732f, 0.04154227f, 
    0.09970825f, -0.05846249f, 0.02025826f, -0.02944270f, 0.00618063f, -0.03400545f, -0.00458709f, -0.07314718f, 
    0.12900285f, -0.09322190f, 0.05297867f, -0.00079375f, -0.18935728f, -0.02927647f, 0.14352778f, 0.08179046f, 
    -0.14771345f, -0.04611177f, 0.03530433f, -0.08695462f, 0.06564803f, -0.03681654f, 0.03485667f, -0.13953191f, 
    -0.16829589f, 0.13446397f, 0.02282586f, 0.13219869f, -0.01507476f, 0.00279347f, 0.03278622f, -0.06461910f, 
    0.02729448f, 0.01823320f, -0.08080605f, 0.03464540f, -0.09388345f, 0.03380208f, 0.23269747f, 0.00099933f, 
    -0.02559792f, -0.05983799f, 0.05199700f, -0.05028073f, 0.03464885f, 0.08183841f, -0.03629905f, 0.10371453f, 
    -0.15082307f, -0.17004745f, -0.23782670f, 0.08343397f, -0.05855551f, 0.01340589f, 0.00888517f, 0.19802618f, 
    -0.06419960f, -0.01909003f, -0.12947455f, -0.11665174f, 0.19514725f, 0.06381336f, 0.06758477f, -0.15657835f, 
    0.00402899f, 0.09165253f, 0.03784839f, 0.04488600f, 0.01997080f, -0.08412874f, -0.03554726f, 0.03081480f, 
    0.08307526f, -0.29659387f, 0.00570504f, 0.00956742f, 0.04360615f, 0.00397969f, -0.04055388f, 0.13835435f, 
    0.09408560f, -0.08745771f, -0.07555970f, 0.10195719f, -0.14152072f, -0.06138742f, 0.15302226f, 0.16300280f, 
    0.01264983f, -0.04729339f, -0.09087279f, -0.13263926f, -0.01683962f, -0.05599888f, 0.00327060f, 0.08955926f, 
    -0.03973263f, -0.15356430f, -0.26958758f, -0.06483773f, 0.02468325f, -0.05199889f, 0.04822373f, -0.06920166f, 
    -0.07756420f, -0.05979782f, 0.01287851f, -0.00676284f, 0.04563007f, 0.07128572f, 0.23811875f, 0.04328923f, 
    -0.02417511f, 0.03997031f, -0.03003312f, 0.05744275f, -0.00619546f, 0.04512870f, -0.01720337f, 0.09425631f, 
    0.24042720f, 0.00862832f, -0.07508577f, -0.16808012f, 0.04171396f, 0.07772668f, 0.04995252f, -0.07109077f, 
    0.04094509f, -0.10674833f, 0.02740821f, -0.09385694f, 0.32315785f, -0.01323664f, -0.04589582f, -0.01412616f, 
    0.10167341f, 0.13531668f, -0.01048503f, 0.05517644f, -0.06714005f, -0.03014590f, -0.01795012f, -0.02110834f, 
    0.03490612f, -0.00396196f, 0.14441250f, -0.12880345f, -0.09115585f, 0.10638385f, -0.03977590f, -0.00205804f, 
    0.02648550f, -0.00176678f, -0.02439851f, -0.04063322f, 0.35727262f, -0.07663400f, -0.18483809f, 0.03415858f, 
    -0.08332063f, 0.01942192f, 0.04502570f, -0.00862176f, 0.00851770f, -0.04020827f, 0.03453068f, 0.06214266f, 
    -0.26319188f, -0.02785116f, 0.05151411f, 0.09371141f, -0.03479128f, -0.08565388f, 0.07158087f, 0.03710487f, 
    -0.01573069f, 0.10108832f, 0.09133234f, 0.00641802f, 0.21438307f, -0.01456647f, -0.06674276f, -0.12631905f, 
    0.01361239f, 0.14885327f, -0.00343953f, -0.03412801f, -0.01076284f, -0.02986143f, 0.15245280f, 0.02017572f, 
    -0.05348802f, -0.01310200f, 0.02174857f, 0.09523706f, 0.01898202f, 0.00468501f, 0.04771816f, 0.09254596f, 
    0.09731646f, 0.02328376f, -0.02459445f, 0.04088085f, -0.06263506f, 0.10837029f, 0.22258337f, -0.03180569f, 
    0.03675361f, -0.03030384f, 0.01351202f, 0.03992704f, -0.02920032f, 0.08422954f, 0.01464378f, 0.07303813f, 
    -0.04884403f, 0.17628799f, 0.25502616f, 0.01212536f, 0.00017648f, 0.00980741f, 0.14190097f, -0.03261266f, 
    -0.06789953f, 0.02277463f, 0.00798434f, -0.03950595f, -0.28098428f, 0.10205197f, 0.09931141f, -0.00259977f, 
    0.00721659f, -0.07710397f, -0.03244822f, -0.05164289f, -0.03719905f, 0.18423176f, -0.02315377f, -0.00717476f, 
    0.26719502f, -0.03852562f, -0.00344382f, -0.04494317f, 0.04684681f, 0.10690180f, 0.01045132f, -0.00895945f, 
    0.03575553f, -0.08790170f, 0.02622497f, -0.00225364f, 0.31328642f, -0.08675592f, 0.01182557f, -0.06011565f, 
    0.00562159f, 0.02229000f, 0.01650280f, 0.04850629f, -0.01940665f, -0.05356693f, 0.03425320f, 0.07446281f, 
    0.43448624f, -0.25778404f, 0.10163353f, -0.03135644f, -0.05330527f, 0.16775876f, 0.05669365f, 0.11019290f, 
    0.08186415f, 0.05306770f, 0.05858539f, 0.07135167f, -0.04309237f, -0.07108676f, -0.09091012f, -0.14309484f, 
    -0.02006061f, 0.03587734f, -0.04147580f, 0.04912799f, -0.00063019f, 0.08123833f, -0.07541563f, 0.02183094f, 
    0.24656166f, 0.07350359f, 0.00087455f, -0.03669147f, 0.10401695f, 0.05705383f, -0.06361071f, 0.01097995f, 
    -0.08352694f, 0.02759893f, 0.01110753f, 0.00894996f, 0.24919401f, -0.02558717f, -0.07305066f, 0.02452240f, 
    -0.03810090f, 0.11214763f, -0.09095009f, 0.11500346f, -0.03814109f, -0.01034523f, -0.01515094f, -0.09620775f, 
    0.02469265f, 0.06989436f, 0.03939516f, -0.08258405f, -0.10813463f, 0.16152325f, 0.06415623f, -0.01457739f, 
    0.00713156f, -0.01237356f, 0.05574419f, -0.18355329f, 0.33465642f, -0.10216468f, 0.02140453f, 0.02375657f, 
    -0.15205632f, 0.01058554f, -0.00362595f, 0.06442356f, -0.04445963f, 0.10401055f, 0.06891315f, 0.07680582f, 
    0.13275312f, -0.01623865f, -0.00902567f, -0.02270401f, 0.04586043f, 0.01179583f, -0.03882130f, -0.02024745f, 
    -0.01681153f, -0.07601311f, 0.00000196f, -0.09436173f, 0.14181273f, -0.02320981f, -0.13422903f, 0.00286116f, 
    0.06222626f, 0.03949041f, 0.03093021f, 0.00973191f, -0.02395676f, 0.02796906f, -0.08064847f, -0.00030641f, 
    -0.11110950f, -0.04027816f, 0.12713008f, -0.15392521f, 0.04328767f, -0.02050863f, 0.09085592f, 0.05607560f, 
    0.04067258f, 0.01512785f, -0.01557303f, -0.03588345f, 0.16057394f, -0.38905862f, 0.24543092f, -0.15949900f, 
    0.02358039f, -0.00184455f, -0.00587629f, -0.11901574f, 0.04996678f, -0.02943822f, -0.05309347f, 0.16527697f, 
    0.05716313f, 0.10666331f, -0.09165509f, 0.10000009f, -0.04880612f, 0.02071387f, 0.00197575f, -0.09024578f, 
    0.00901995f, 0.05258722f, 0.06189664f, 0.03352021f, 0.12127548f, -0.02727378f, -0.12640041f, 0.05725001f, 
    0.00194809f, -0.03969130f, 0.02364587f, 0.05701490f, -0.04463366f, 0.11178319f, -0.05718902f, 0.04324913f, 
    -0.01710722f, 0.00021864f, 0.06999312f, 0.01620020f, 0.04832000f, 0.04261577f, 0.03515843f, 0.09377724f, 
    0.12317538f, -0.04861811f, 0.02854709f, 0.06280640f, -0.18765952f, -0.04130900f, -0.01718446f, 0.13304988f, 
    -0.12571903f, -0.10917283f, -0.07530196f, -0.09589333f, 0.06856935f, 0.08361454f, 0.09982388f, -0.11886881f, 
    -0.23589534f, -0.23456536f, 0.01708964f, 0.13712887f, 0.01758930f, -0.09599654f, 0.05443454f, 0.07953722f, 
    -0.12791227f, -0.06728604f, -0.02882672f, 0.00659000f, 0.35209894f, -0.09719052f, -0.00540370f, 0.11511562f, 
    0.03491902f, 0.05257174f, 0.02186779f, -0.02570074f, -0.03309501f, -0.04120617f, 0.04751267f, -0.04512882f, 
    -0.15939234f, 0.01043789f, -0.29935867f, -0.12016674f, -0.06014494f, 0.13290797f, -0.04522113f, -0.10014725f, 
    0.00393724f, 0.06267376f, -0.09522237f, -0.04911334f, -0.02050599f, -0.04731092f, 0.05227216f, -0.12456131f, 
    0.03314102f, 0.04621685f, 0.09383551f, 0.05772313f, -0.07178396f, 0.03338730f, 0.04799312f, 0.14872998f, 
    0.02112419f, -0.02444430f, -0.03696308f, 0.00566510f, -0.01297577f, -0.01839045f, 0.00324893f, 0.00210728f, 
    -0.01752409f, 0.03002410f, 0.01828849f, -0.01907077f, 0.02168114f, 0.03084107f, 0.01513994f, 0.00360366f, 
    -0.00514886f, 0.02489852f, 0.01197852f, 0.00132526f, -0.03098286f, -0.01680412f, -0.03638083f, 0.01548422f, 
    -0.00274034f, -0.02033689f, -0.02571277f, -0.00442414f, -0.00888765f, -0.02823933f, 0.01380752f, -0.02672776f, 
    0.02553777f, -0.02223463f, -0.00838709f, -0.00904744f, -0.03830961f, -0.00977344f, -0.01419101f, -0.00135701f, 
    0.00710219f, -0.01140115f, 0.02451137f, -0.03063533f, -0.01158882f, -0.02009527f, 0.00422412f, 0.01715579f, 
    0.01879133f, -0.02660016f, 0.00298667f, -0.00306048f, -0.03475385f, 0.00645815f, -0.02827906f, -0.00471722f, 
    -0.00139971f, 0.02831529f, -0.02504648f, -0.01683334f, -0.02914337f, 0.02355320f, 0.02680845f, 0.01643882f, 
    -0.01948487f, -0.03224220f, 0.01577667f, -0.04227375f, -0.01029964f, -0.03095007f, 0.02171433f, -0.02556564f, 
    -0.01333480f, 0.00977236f, 0.03402507f, -0.02995226f, -0.03956926f, -0.00392639f, 0.00219261f, -0.01374476f, 
    -0.00799146f, -0.01020567f, -0.01567425f, 0.01298678f, 0.03376493f, 0.01358114f, 0.00138715f, -0.00549722f, 
    0.00187035f, -0.00029986f, 0.02145628f, -0.02064040f, 0.00446161f, -0.03510385f, -0.01039419f, -0.03516114f, 
    -0.03520142f, -0.03600350f, -0.02334337f, 0.01536842f, 0.03099249f, -0.03638306f, 0.00295070f, 0.01785968f, 
    -0.01001702f, -0.01679118f, 0.01376592f, 0.01247679f, 0.00886028f, -0.02660308f, -0.01153318f, 0.02811124f, 
    -0.01872632f, -0.01685105f, 0.01135566f, -0.04341223f, 0.02353132f, -0.00796271f, -0.01426100f, -0.03249481f, 
    0.01504170f, -0.02325015f, 0.01837779f, -0.03969026f, -0.00425651f, 0.00416975f, 0.00692097f, 0.02737859f, 
    0.00831256f, -0.02946921f, -0.00407258f, 0.00947639f, 0.02117984f, 0.01464446f, -0.00055769f, -0.02814650f, 
    -0.01311995f, -0.00582731f, -0.00469491f, -0.02445505f, -0.01433995f, 0.00795881f, -0.02069265f, -0.00964364f, 
    -0.00875981f, -0.02727422f, -0.00071532f, -0.02550459f, 0.00850308f, 0.00767920f, 0.01208706f, -0.00766314f, 
    -0.01778284f, -0.02033242f, 0.01999488f, -0.02744418f, -0.02419228f, -0.01797868f, -0.02973890f, -0.03579411f, 
    -0.00084811f, 0.02347594f, -0.01257685f, 0.00414537f, -0.02222432f, 0.02187777f, 0.02230275f, 0.03012579f, 
    -0.00192650f, 0.00693038f, -0.03290346f, -0.03381051f, 0.00825306f, -0.03636834f, -0.02778442f, 0.02033158f, 
    0.01673828f, 0.00363739f, 0.00055936f, 0.00332662f, -0.01563882f, -0.02525464f, 0.00126221f, 0.01433514f, 
    -0.00818525f, -0.01603134f, -0.01097101f, -0.00288406f, 0.02582266f, 0.01781136f, -0.03503950f, 0.00445668f, 
    0.00575724f, 0.02097802f, -0.00214401f, 0.00492066f, 0.02679008f, 0.01439585f, -0.01173541f, 0.02853058f, 
    -0.02656607f, -0.00205988f, 0.02868187f, -0.01605422f, -0.03741098f, -0.00957476f, -0.03346921f, -0.03187261f, 
    -0.03143111f, -0.03332616f, 0.01529689f, 0.02597294f, -0.00973755f, -0.02412966f, -0.02846763f, -0.00007552f, 
    0.00225008f, -0.02748156f, 0.01807206f, -0.02234459f, -0.02790159f, 0.01270194f, 0.02961147f, -0.00767895f, 
    -0.02444076f, 0.03202061f, 0.00138582f, 0.02202399f, -0.00419746f, -0.02844656f, 0.03357040f, 0.03399350f, 
    0.03010877f, -0.01176686f, -0.02889054f, -0.03821649f, 0.02084029f, 0.00835810f, 0.03019580f, -0.04042666f, 
    -0.01981341f, -0.00555013f, 0.01737757f, -0.01159517f, 0.02640286f, 0.01054384f, 0.01327772f, -0.00346066f, 
    0.01951029f, 0.00762119f, 0.02071873f, -0.01414936f, 0.02878525f, 0.02941146f, 0.01077264f, 0.00247109f, 
    -0.02162875f, -0.02305327f, -0.02627061f, -0.03812495f, -0.03259453f, -0.01649212f, -0.01707664f, -0.04038320f, 
    -0.03445578f, -0.01550443f, -0.01733203f, -0.02534935f, 0.01519354f, -0.01393391f, 0.02026710f, -0.04188523f, 
    -0.00806038f, -0.00933995f, -0.02586672f, 0.00103129f, -0.02947932f, 0.00746481f, 0.01288319f, -0.03175243f, 
    -0.01115945f, -0.00156438f, 0.03164956f, -0.00653873f, 0.00954697f, 0.01860888f, -0.00147207f, -0.02140604f, 
    0.02646947f, 0.02436831f, -0.00919762f, 0.00554463f, 0.02226515f, 0.02945897f, -0.03438274f, 0.02277011f, 
    0.02169859f, -0.00675496f, -0.00860375f, -0.03159015f, -0.00793690f, -0.02304728f, 0.01589406f, 0.01414799f, 
    0.00855824f, 0.00308734f, 0.00087158f, -0.00610062f, -0.02799814f, 0.02239726f, 0.01246712f, 0.03717816f, 
    -0.02545509f, 0.01748380f, -0.03906585f, 0.01653643f, -0.02140229f, -0.01305780f, 0.00291933f, -0.01735869f, 
    -0.03322749f, -0.01498380f, -0.01725106f, -0.02986899f, -0.00691166f, 0.02102124f, -0.03276913f, -0.00497391f, 
    -0.02037432f, -0.00538742f, -0.03248699f, 0.03057393f, -0.03276451f, 0.02543724f, -0.04099587f, -0.00462103f, 
    0.02295686f, -0.00147299f, -0.02097000f, 0.00688302f, 0.00184323f, -0.01037098f, 0.01984858f, -0.00557498f, 
    0.03427244f, 0.02332622f, 0.01642128f, -0.01103173f, 0.02457411f, 0.02323791f, -0.01751927f, -0.00134923f, 
    -0.01916854f, 0.01185079f, -0.02428596f, -0.00383689f, -0.01893977f, 0.01233854f, -0.03595512f, -0.02698945f, 
    0.01560291f, 0.02920989f, -0.01327852f, 0.00707869f, 0.01519596f, -0.00189590f, 0.01952741f, 0.01532531f, 
    0.00001528f, -0.00714985f, 0.00405363f, -0.02083015f, -0.02230919f, 0.02261075f, -0.02138587f, -0.02261343f, 
    0.01427412f, 0.02424937f, 0.02700351f, 0.01842814f, -0.04201279f, 0.01381028f, -0.01263599f, -0.02891302f, 
    0.02114419f, -0.00815765f, 0.03222074f, -0.03326999f, -0.03324114f, -0.01735206f, 0.01379081f, -0.02170813f, 
    -0.00271345f, 0.00193337f, 0.01796006f, -0.02990239f, 0.00065960f, -0.04349389f, -0.02764065f, -0.02296948f, 
    -0.00893067f, 0.01054530f, 0.01790533f, 0.01144752f, -0.03418082f, 0.01977606f, 0.01039123f, 0.01838870f, 
    0.01737536f, 0.00048667f, -0.02054017f, -0.02660190f, -0.02846086f, -0.02415642f, 0.01673986f, 0.01750861f, 
    -0.03281844f, 0.01418272f, 0.00875867f, -0.02479355f, -0.02691195f, 0.01690408f, -0.00662577f, -0.02300060f, 
    0.00753860f, -0.01820798f, 0.01099790f, 0.02079408f, -0.03262502f, 0.01728576f, -0.01827494f, 0.00523735f, 
    -0.03691005f, -0.03215984f, -0.03106849f, 0.03099489f, -0.00585017f, -0.02346330f, -0.01676088f, -0.01202887f, 
    -0.01236900f, -0.02475394f, 0.00796005f, 0.01590095f, -0.01604446f, 0.01915339f, -0.01142009f, -0.01672134f, 
    0.01553065f, -0.04330277f, -0.00717713f, 0.02862034f, -0.03049711f, 0.00952830f, 0.01644044f, -0.03550549f, 
    0.03179611f, -0.03180308f, -0.03358794f, 0.00075502f, 0.00235914f, -0.03187654f, -0.00044772f, -0.00114017f, 
    -0.03461828f, 0.01482277f, 0.00055473f, -0.03353773f, -0.00581384f, -0.03509846f, 0.01428912f, 0.02171181f, 
    0.01997717f, -0.03686374f, -0.02986291f, -0.00468231f, -0.00778261f, -0.00580222f, -0.04356912f, -0.03190544f, 
    -0.02430112f, 0.02879977f, 0.01293850f, 0.00887840f, -0.02640021f, -0.03471384f, -0.03004869f, -0.03413860f, 
    -0.01346432f, 0.02136315f, 0.02048071f, -0.02025640f, -0.00055118f, 0.01439655f, -0.02127572f, -0.02158100f, 
    0.01079207f, 0.01906591f, -0.03229751f, 0.03116986f, -0.01088434f, -0.00594720f, -0.03015107f, 0.02897432f, 
    0.00129978f, -0.00756141f, -0.01033528f, -0.00963089f, 0.01439178f, -0.00445348f, -0.02279485f, 0.01953270f, 
    0.02566689f, -0.01042067f, 0.02409141f, 0.00953556f, -0.00528852f, 0.01330813f, 0.02875070f, 0.00046758f, 
    -0.00732837f, 0.01047929f, -0.01965407f, -0.02912658f, 0.02449671f, -0.03109826f, 0.01054743f, 0.02290360f, 
    0.00248359f, 0.00448878f, -0.00045416f, -0.02887515f, -0.02200739f, -0.02262502f, -0.03592987f, 0.00760291f, 
    0.01630648f, -0.02753640f, -0.00989872f, -0.01892664f, 0.00051543f, -0.03544267f, -0.02052845f, 0.01654424f, 
    0.00149083f, 0.01755406f, -0.02408283f, -0.02056568f, 0.02314175f, 0.01441402f, -0.02162328f, -0.00644230f, 
    -0.01639982f, 0.00702955f, 0.00407556f, 0.02245097f, -0.02071852f, -0.01754639f, -0.02680185f, -0.00266734f, 
    -0.01403618f, -0.00303484f, 0.02115162f, 0.00004777f, 0.00722507f, -0.01095592f, 0.01868337f, 0.02277382f, 
    -0.03656840f, -0.03378825f, 0.02024887f, -0.02202430f, -0.02677192f, -0.03444925f, -0.01275292f, -0.00551176f, 
    -0.02513647f, -0.01842452f, 0.01993436f, -0.00317099f, -0.04096850f, -0.03024164f, -0.01260679f, 0.01128520f, 
    0.02639747f, 0.00440748f, 0.01169136f, 0.00902735f, -0.00148737f, -0.02403185f, 0.01828018f, 0.01928151f, 
    0.01376583f, -0.00856008f, -0.02948666f, -0.00148122f, -0.01051874f, 0.00624317f, -0.01643920f, 0.01948169f, 
    -0.01795893f, 0.01642351f, -0.00169360f, 0.01579924f, 0.01123740f, -0.00106894f, -0.03832772f, -0.02258836f, 
    -0.02073733f, 0.02775687f, 0.02739858f, 0.00820178f, -0.00449234f, -0.00030465f, 0.02093107f, 0.02084356f, 
    -0.00636253f, -0.01620909f, 0.01487661f, -0.00996288f, -0.03664212f, 0.00824905f, -0.02869824f, -0.02455799f, 
    -0.00818655f, -0.02211801f, -0.01783654f, 0.00090473f, -0.01319475f, -0.03243952f, -0.01955183f, -0.02505725f, 
    0.02840804f, 0.01148883f, 0.03264830f, -0.00299086f, -0.03010794f, 0.00311872f, 0.01236056f, 0.02339299f, 
    -0.01049234f, -0.01532542f, -0.00585633f, 0.01079403f, 0.02554513f, 0.02682619f, -0.01057863f, 0.01762142f, 
    0.00132800f, -0.02162957f, 0.02792881f, -0.02680909f, -0.00747678f, -0.00600930f, 0.00394501f, -0.02499025f, 
    -0.00493551f, -0.00118315f, 0.00405269f, 0.03047855f, -0.01684486f, 0.01558938f, -0.00382518f, -0.03296210f, 
    0.02290437f, -0.00935995f, 0.01173810f, -0.03315869f, -0.00912937f, 0.02281279f, -0.00234306f, 0.00619324f, 
    -0.01474977f, 0.01691695f, -0.00191830f, -0.02815870f, 0.00566125f, -0.03580939f, 0.02434791f, 0.02268996f, 
    -0.03901236f, -0.01744046f, 0.00160422f, -0.00898696f, 0.01135438f, 0.02367675f, -0.00622178f, 0.00943798f, 
    -0.02697331f, -0.02285600f, 0.01051368f, -0.00893161f, -0.02028754f, 0.02300744f, 0.02357319f, -0.01669026f, 
    -0.00501244f, -0.01870866f, -0.00475576f, 0.03207939f, -0.00273865f, -0.00014346f, 0.01733004f, -0.00773286f, 
    0.02064338f, -0.02988994f, 0.00713477f, -0.02931706f, 0.00527254f, 0.00527478f, 0.00848808f, 0.01206327f, 
    0.00121031f, 0.00958645f, -0.00981541f, -0.03777784f, -0.01764390f, -0.01960705f, -0.00613054f, -0.01232775f, 
    0.00995793f, -0.01473869f, -0.03960261f, -0.02112183f, -0.01435448f, -0.01091546f, 0.01255455f, -0.03868631f, 
    0.01912525f, -0.01535017f, -0.01885729f, 0.00019486f, -0.02558371f, -0.01961065f, -0.01785533f, 0.00632848f, 
    0.01506858f, -0.04006757f, 0.01857918f, -0.00845344f, -0.03906505f, -0.04023576f, 0.00417619f, -0.02369607f, 
    0.02476747f, -0.02975742f, -0.04262479f, 0.00695568f, -0.00390520f, 0.01561756f, -0.02066761f, -0.01946445f, 
    -0.04014805f, 0.00532472f, 0.01551787f, -0.00572358f, -0.03315169f, 0.00830177f, -0.03391559f, -0.02310236f, 
    -0.03495675f, -0.03121308f, 0.02241233f, 0.00944528f, -0.01060645f, 0.01438997f, 0.00429005f, 0.01501421f, 
    0.02497472f, -0.04339958f, 0.02230738f, -0.00510492f, 0.00163761f, -0.00292617f, -0.01562482f, -0.03098766f, 
    0.00165423f, 0.00572705f, -0.03623754f, 0.01959588f, -0.03008197f, -0.01254030f, 0.00639914f, -0.02979219f, 
    -0.02409026f, -0.01290873f, -0.01918085f, 0.00117492f, -0.01372706f, -0.01073372f, -0.00832085f, -0.01192209f, 
    -0.00004578f, -0.03636128f, -0.00314665f, 0.02507941f, -0.01009520f, -0.00714721f, -0.01142752f, -0.00122833f, 
    0.02496921f, 0.00803527f, 0.00688250f, -0.01106907f, 0.00182086f, -0.00284549f, 0.02336117f, 0.01242571f, 
    0.00230385f, -0.02396329f, -0.01876284f, -0.03374824f, -0.01436428f, -0.03733157f, 0.01990420f, -0.02218377f, 
    -0.03172915f, -0.02934294f, -0.01625193f, -0.00380853f, -0.01023540f, 0.00060319f, -0.04285092f, 0.00318262f, 
    -0.00931314f, 0.01965345f, -0.03065581f, -0.00374671f, -0.01958260f, -0.01434097f, -0.01761956f, -0.01847904f, 
    0.01752971f, 0.00786827f, -0.00179643f, 0.02450995f, 0.00814945f, -0.04154210f, 0.00090030f, 0.00363676f, 
    0.02416244f, 0.01621855f, -0.00008490f, 0.01603627f, -0.01823552f, 0.01952734f, -0.01656724f, -0.00490001f, 
    -0.01456014f, 0.02465941f, -0.00985705f, 0.00663183f, 0.00016752f, -0.02659970f, 0.01325383f, -0.02089077f, 
    0.02059622f, 0.00495443f, -0.00514826f, 0.01584713f, 0.00828078f, 0.00220590f, 0.02208504f, 0.02709654f, 
    0.00267257f, -0.00152107f, 0.02047959f, -0.00483674f, -0.01726815f, -0.00428402f, 0.00610932f, -0.02681562f, 
    0.02156259f, -0.01294704f, -0.00619640f, 0.00772569f, 0.01483723f, 0.01450886f, 0.04046863f, -0.02395678f, 
    -0.00655768f, -0.03804679f, 0.01342523f, -0.02803354f, 0.00839780f, -0.03173222f, -0.01661886f, -0.02676877f, 
    -0.04191005f, 0.00803992f, 0.00258083f, 0.00523315f, -0.03404768f, 0.02353294f, -0.01595446f, -0.02145107f, 
    -0.02849230f, -0.00672380f, -0.00047510f, 0.02442616f, -0.03056529f, -0.00980731f, 0.00178916f, -0.02633285f, 
    -0.03444507f, -0.02683099f, -0.00132718f, -0.02649491f, -0.01105848f, 0.01185299f, 0.02204690f, -0.01887559f, 
    -0.01663596f, 0.00188006f, -0.02073129f, -0.03888383f, -0.04029563f, -0.00815261f, 0.02242718f, -0.00723586f, 
    0.03163860f, -0.02272462f, -0.04110004f, -0.01720756f, -0.03826014f, 0.01911631f, -0.02129978f, -0.01295486f, 
    -0.02756544f, -0.02116917f, -0.03542440f, -0.02911955f, -0.00687529f, -0.01084032f, -0.00251581f, 0.01520888f, 
    -0.02125745f, -0.00132523f, -0.04255965f, 0.01960196f, -0.03203175f, -0.00825473f, -0.00673309f, -0.01827585f, 
    -0.03651051f, -0.00753800f, -0.02184113f, -0.01542429f, -0.04387429f, -0.02305780f, -0.04335655f, -0.04377744f, 
    0.01104517f, -0.03200414f, -0.01786528f, 0.00612438f, -0.00099455f, -0.04080406f, 0.01686459f, -0.01869104f, 
    -0.01783394f, -0.02886875f, -0.01186485f, -0.00414218f, -0.01968543f, -0.00817048f, 0.01314358f, -0.01801375f, 
    -0.00212467f, 0.02776842f, -0.00183326f, 0.02475854f, -0.02911480f, -0.03650993f, -0.02331425f, -0.01399113f, 
    -0.01931899f, -0.00910375f, 0.00062377f, 0.00336949f, -0.02890803f, 0.00210481f, -0.03339311f, 0.02432976f, 
    -0.03747521f, -0.04204699f, -0.02494532f, -0.01507104f, 0.02118609f, 0.01905631f, 0.02260108f, 0.00422412f, 
    0.00524136f, 0.02539583f, -0.02765169f, 0.00783934f, 0.01379734f, -0.00084414f, -0.00086387f, -0.01110311f, 
    0.00710836f, 0.00275253f, 0.02390235f, 0.01084098f, 0.02812410f, -0.01816105f, 0.01451623f, 0.00459149f, 
    -0.01435608f, -0.01195219f, -0.02543956f, -0.03423212f, -0.00156477f, 0.00535175f, -0.00073878f, 0.02985344f, 
    0.00121301f, -0.01573027f, -0.01509170f, -0.03703658f, 0.01845038f, -0.00637101f, -0.02390174f, -0.00303954f, 
    -0.01824316f, 0.00493921f, -0.02463298f, 0.01558774f, 0.00494475f, 0.01041508f, 0.00805094f, -0.00920858f, 
    0.02971516f, -0.00968388f, 0.01290151f, 0.02978903f, 0.01350989f, 0.00827879f, -0.02587961f, 0.02770954f, 
    0.01805116f, -0.01701057f, -0.00101061f, 0.00168718f, 0.02144535f, -0.00457621f, 0.02668874f, -0.01964826f, 
    -0.02381507f, -0.01539651f, -0.00916432f, 0.01473027f, -0.01961421f, 0.00330918f, -0.00779705f, -0.01996326f, 
    -0.03085554f, -0.03357909f, -0.02324928f, -0.00962982f, 0.00050087f, 0.00828362f, -0.01156666f, 0.03057428f, 
    -0.00168424f, -0.04310625f, 0.00716646f, 0.01266132f, -0.00493892f, -0.00827913f, 0.01982399f, -0.02973529f, 
    -0.00242227f, 0.01911141f, 0.02706493f, 0.00514241f, 0.03135899f, -0.02541557f, 0.03381061f, -0.02959959f, 
    0.00142337f, -0.04314231f, -0.01730435f, -0.03940106f, 0.00176090f, 0.00614752f, -0.01195902f, 0.00427251f, 
    -0.02536235f, -0.01471962f, -0.00856815f, -0.01038631f, -0.02387991f, -0.00825281f, -0.03718211f, -0.01433774f, 
    -0.00242491f, -0.01990252f, 0.01341422f, 0.00651053f, -0.02462311f, -0.03850313f, 0.00891137f, -0.00625184f, 
    -0.02751376f, -0.03379355f, 0.02729864f, 0.00693925f, 0.02639305f, -0.00802649f, 0.01669072f, -0.00539398f, 
    0.01472024f, -0.00987205f, -0.00301578f, -0.02885504f, -0.01233374f, 0.01439330f, -0.00768482f, -0.01397448f, 
    0.00773645f, -0.00451795f, 0.00915445f, 0.02133348f, 0.02389531f, -0.03368797f, -0.03198455f, -0.00336950f, 
    -0.03034121f, 0.02682593f, -0.04214637f, 0.02052801f, 0.02620059f, -0.01568400f, -0.01615099f, -0.04123461f, 
    0.02744518f, 0.01777020f, 0.00766374f, -0.00164983f, 0.00666699f, -0.00386603f, -0.00407890f, -0.00667099f, 
    -0.02727824f, -0.00933421f, -0.01470231f, -0.02307979f, -0.01620027f, 0.01938905f, 0.00248353f, -0.01449771f, 
    0.02709951f, -0.00201269f, -0.03991800f, 0.00337820f, -0.03150249f, 0.00495321f, -0.00230499f, -0.01814324f, 
    0.00577660f, 0.00189021f, 0.00069607f, 0.01241125f, -0.00478774f, -0.00260782f, -0.00807692f, 0.03304617f, 
    -0.01591226f, 0.00038167f, -0.00666634f, -0.02255229f, -0.00351452f, -0.00913315f, -0.00094079f, 0.02014815f, 
    0.00131343f, 0.00353890f, 0.02872898f, 0.02269747f, -0.01852631f, -0.03190077f, 0.01075647f, 0.03007365f, 
    -0.02117740f, 0.01222427f, -0.02553287f, -0.00119204f, -0.02674592f, -0.02713956f, -0.03277694f, -0.00201819f, 
    -0.02203697f, -0.04237050f, -0.02061726f, -0.04095303f, 0.00746358f, -0.04438709f, -0.00356387f, 0.01816506f, 
    -0.03647706f, -0.00190528f, 0.02240498f, 0.02059748f, -0.00066081f, -0.03740630f, -0.02454511f, 0.01491253f, 
    -0.03847726f, 0.00438862f, 0.01903535f, 0.02168819f, 0.00895706f, -0.02899435f, 0.02268427f, 0.02309436f, 
    -0.03720057f, -0.02661214f, 0.02308035f, -0.02517507f, -0.04323810f, -0.02839915f, -0.01867673f, 0.00432069f, 
    -0.03456967f, -0.00085057f, -0.00208593f, 0.02029441f, 0.00028964f, 0.00373252f, 0.01729219f, 0.02370162f, 
    0.00736342f, -0.01332808f, -0.03295629f, -0.03355078f, 0.02544864f, 0.03406033f, 0.00571345f, -0.02134276f, 
    -0.00321643f, -0.01639416f, -0.00371043f, -0.02103724f, 0.01808282f, -0.01931596f, -0.01070661f, -0.01746739f, 
    -0.00272501f, -0.02329181f, -0.01413913f, -0.00010180f, 0.01860506f, -0.02357326f, -0.04176051f, -0.00354796f, 
    0.01352717f, 0.02519218f, 0.02322297f, -0.00826770f, 0.02978106f, 0.00419854f, -0.02595209f, 0.00307866f, 
    0.01163676f, 0.01330841f, -0.02347593f, -0.02340765f, -0.03476598f, -0.00984755f, 0.01036065f, -0.01752227f, 
    0.01927097f, 0.03221143f, 0.01593090f, 0.01149614f, 0.01668935f, -0.03623993f, -0.00079250f, 0.03645299f, 
    -0.00818153f, -0.01921726f, 0.03015091f, -0.01744823f, 0.01754109f, -0.03892781f, 0.01539742f, -0.00111892f, 
    -0.00460965f, -0.02065962f, 0.01201299f, 0.02096092f, -0.02586396f, 0.00925594f, -0.02106506f, -0.00817240f, 
    -0.01251795f, -0.01585391f, -0.03040219f, -0.01619825f, 0.00960726f, 0.01410006f, -0.02057019f, -0.03667098f, 
    0.01663866f, -0.02022676f, 0.01726130f, 0.02687804f, -0.01010423f, -0.01287379f, -0.01010762f, 0.02162725f, 
    -0.01069988f, -0.03384821f, 0.01988017f, -0.03890621f, 0.02262404f, -0.03769160f, 0.01907360f, 0.02693960f, 
    -0.00642702f, -0.01029098f, -0.03591134f, 0.01166330f, 0.03619975f, -0.04056014f, -0.00372993f, -0.01531314f, 
    0.00949565f, -0.01966833f, -0.00181246f, -0.04251505f, -0.02510435f, -0.01031959f, 0.01110428f, 0.00075938f, 
    -0.04056280f, 0.00444324f, -0.02791303f, 0.01923452f, -0.00384405f, -0.01963086f, 0.02116392f, -0.00589546f, 
    -0.00898710f, -0.00571214f, 0.01959260f, 0.02032127f, 0.00660741f, -0.02058760f, -0.01877823f, 0.02815114f, 
    0.01691499f, -0.00863582f, 0.00510458f, -0.00079296f, 0.02473008f, 0.00153215f, 0.02344637f, -0.01457429f, 
    0.00046321f, -0.00306241f, -0.03662107f, 0.01020726f, 0.01978424f, -0.00339469f, -0.03322374f, -0.02016435f, 
    0.00416285f, -0.01510065f, -0.03601195f, 0.02515537f, 0.02282039f, 0.01753723f, -0.02731463f, -0.02755625f, 
    0.00948772f, 0.00166557f, 0.01663670f, -0.03427285f, -0.00079498f, -0.04060957f, -0.00559845f, 0.01560195f, 
    -0.01440071f, -0.02925128f, -0.01790670f, -0.02098731f, -0.00797012f, -0.03088617f, 0.02702722f, 0.01662367f, 
    -0.00025290f, -0.01240610f, 0.00877695f, -0.00654502f, 0.01589141f, -0.00190033f, 0.01937642f, -0.03064276f, 
    0.01994155f, -0.01478141f, -0.02023909f, 0.01633542f, -0.02997604f, -0.00780231f, -0.00244690f, 0.01324707f, 
    0.00718902f, -0.01163579f, -0.01667765f, -0.03554699f, 0.01632989f, -0.02340431f, -0.03337997f, -0.00748705f, 
    0.01693331f, 0.02806232f, -0.01480647f, 0.03335098f, 0.00209407f, -0.01985287f, -0.04362883f, 0.02846185f, 
    -0.03684432f, -0.02585715f, 0.02294195f, -0.00378820f, -0.00105667f, -0.02387617f, 0.02091245f, 0.01044818f, 
    -0.00831147f, 0.01802127f, -0.02138486f, -0.03673751f, -0.03167210f, -0.01066500f, 0.01063797f, 0.00718803f, 
    0.00140894f, 0.01750666f, 0.00982770f, -0.02694383f, -0.00863642f, 0.00406370f, 0.02408207f, -0.03558378f, 
    0.00786979f, 0.02238364f, 0.03078030f, -0.00935539f, 0.00642191f, -0.02768792f, -0.01078174f, 0.01610288f, 
    0.01982032f, -0.03057460f, -0.00842528f, 0.02343306f, -0.00037498f, 0.00287018f, -0.00149923f, -0.00503267f, 
    -0.02826184f, 0.00082204f, -0.01903368f, -0.00301719f, -0.02478405f, 0.00517013f, 0.02332431f, -0.02255790f, 
    0.01725288f, -0.00513354f, -0.03974934f, -0.00848780f, -0.01433714f, -0.01009932f, -0.00698047f, -0.01171026f, 
    -0.00501332f, -0.00400764f, -0.00113020f, -0.00950692f, -0.00925261f, -0.02472153f, -0.02241595f, -0.02765703f, 
    0.01598134f, -0.04016468f, -0.02839226f, 0.00415981f, -0.04115081f, -0.01323141f, -0.00408871f, 0.01446064f, 
    -0.00413229f, -0.00092727f, -0.00397606f, -0.01861269f, -0.01428860f, -0.02302138f, -0.03019072f, -0.03184551f, 
    -0.03689555f, 0.02721237f, 0.02295841f, 0.01290753f, -0.02632871f, -0.01084321f, -0.01823959f, 0.01162396f, 
    0.02151926f, 0.01282794f, -0.03018192f, 0.02178577f, 0.00531538f, -0.03070312f, 0.01198915f, 0.00792204f, 
    0.01739739f, -0.00259549f, -0.01783472f, -0.02161351f, -0.00148531f, -0.00927191f, 0.02258600f, -0.02337710f, 
    -0.00212251f, -0.04429381f, 0.02770196f, -0.02774277f, -0.03618822f, -0.02456825f, -0.03140660f, 0.01147037f, 
    -0.03271925f, -0.01669353f, -0.01864667f, -0.01461046f, 0.01189404f, 0.02414865f, -0.01925839f, -0.03993002f, 
    -0.00825984f, 0.01632559f, 0.00398751f, -0.01886804f, 0.01422564f, -0.03537402f, 0.00202666f, -0.01093786f, 
    0.01033905f, 0.00121638f, -0.01255062f, -0.03281230f, 0.01589219f, -0.02578576f, -0.03089316f, 0.01860557f, 
    0.02201707f, 0.02330302f, -0.02705252f, -0.00235068f, 0.02630868f, 0.00852964f, -0.00619099f, -0.02013006f, 
    -0.00595273f, 0.01779282f, 0.02718608f, -0.01417715f, -0.02690129f, 0.02185158f, -0.03773291f, -0.02926515f, 
    -0.00933946f, -0.03351039f, 0.03217396f, -0.02011288f, 0.01601408f, -0.03775422f, -0.03911784f, 0.01017027f, 
    -0.02860980f, -0.00627776f, -0.02506583f, -0.02110306f, -0.02865139f, -0.01963871f, 0.00905873f, -0.01544277f, 
    0.00634793f, -0.00857664f, -0.01637168f, -0.02691484f, 0.02315286f, -0.02459838f, 0.01751412f, 0.00585771f, 
    -0.02154115f, 0.02169216f, 0.00323194f, -0.03099046f, -0.02923043f, 0.02170829f, -0.01948728f, -0.00062065f, 
    0.02632535f, -0.03324457f, -0.03595147f, -0.02684920f, -0.02560987f, -0.03688888f, -0.03443039f, -0.02599947f, 
    0.00543704f, -0.02302541f, 0.01059642f, -0.02684026f, 0.00215642f, 0.00249079f, -0.00698763f, 0.00521138f, 
    0.01630586f, 0.01425317f, -0.03986277f, -0.00435376f, 0.02528124f, -0.03813741f, -0.03085848f, -0.03565622f, 
    -0.01442541f, -0.02368756f, 0.03295165f, -0.00128630f, -0.02157378f, -0.01791448f, 0.00785622f, -0.00656826f, 
    -0.02285440f, -0.00428419f, 0.00438493f, 0.03061534f, 0.00141289f, 0.01358066f, 0.01907916f, 0.02360968f, 
    -0.00933079f, 0.01529963f, 0.00441639f, -0.02122809f, -0.00126775f, -0.03449240f, 0.03114421f, -0.03184815f, 
    0.00638887f, -0.00398661f, 0.00647222f, -0.01694350f, -0.00023593f, -0.00913184f, -0.00152973f, -0.02897119f, 
    0.01840620f, -0.02649944f, -0.03107666f, 0.00556390f, -0.00436772f, -0.03258968f, 0.02401755f, 0.03191696f, 
    -0.02033814f, 0.00581652f, -0.02889602f, 0.02772700f, -0.00651938f, 0.02713629f, -0.00573527f, 0.00231454f, 
    0.00163177f, 0.02851338f, -0.02074283f, -0.00874276f, -0.02002007f, -0.01730225f, 0.00301676f, -0.02862919f, 
    0.02195647f, -0.03478606f, -0.03793260f, 0.00633982f, -0.02031985f, -0.00929284f, -0.01313215f, 0.03223082f, 
    -0.00466830f, -0.00819648f, -0.01709457f, 0.03425109f, -0.00779461f, 0.02986527f, -0.00232045f, 0.01544109f, 
    -0.03569013f, 0.01427082f, 0.01962322f, -0.01992196f, 0.00756448f, 0.01063741f, 0.00765154f, -0.03239488f, 
    0.01789898f, -0.00061053f, -0.03299770f, 0.03128069f, -0.02734920f, -0.01806850f, -0.00733962f, -0.03558128f, 
    -0.01410891f, -0.03080911f, 0.01763471f, -0.00109115f, -0.01095888f, 0.00016591f, -0.03377255f, 0.02724312f, 
    0.02494618f, 0.02316950f, 0.00104695f, 0.01017971f, -0.00985948f, -0.00788084f, 0.00557582f, -0.02757262f, 
    -0.01728359f, 0.01458919f, 0.02490414f, 0.00092624f, 0.01020302f, 0.03519097f, -0.02833845f, 0.02425950f, 
    0.00252383f, 0.01664381f, -0.02514235f, 0.00757023f, 0.02967730f, 0.02831653f, -0.03880541f, 0.02765800f, 
    -0.02709611f, 0.01284184f, 0.02860775f, -0.02457138f, -0.01112152f, 0.02611923f, 0.01811623f, 0.00209708f, 
    0.01306335f, 0.02659720f, -0.01110206f, -0.02286975f, -0.00159066f, 0.02676733f, 0.02811016f, -0.02783954f, 
    0.00349652f, -0.01256460f, 0.00227183f, 0.02699842f, 0.02714260f, -0.02138988f, -0.01286417f, -0.03395285f, 
    -0.00988417f, -0.02461615f, 0.01843137f, 0.02255454f, 0.01274121f, -0.01044799f, 0.00976687f, 0.01234431f, 
    0.00473249f, -0.03493263f, -0.04013055f, 0.01102763f, 0.00519049f, -0.03025054f, -0.02528720f, -0.02543196f, 
    -0.00992493f, 0.01898477f, -0.01695389f, -0.03782975f, 0.01778156f, 0.00591100f, -0.00674379f, 0.02235471f, 
    0.00558215f, -0.02091433f, -0.01648076f, -0.01506966f, 0.02840781f, -0.00156547f, -0.01940826f, -0.02935404f, 
    -0.03664522f, -0.00206232f, -0.02636513f, 0.01350098f, -0.01512010f, 0.00885019f, -0.02692351f, 0.02093327f, 
    0.00341082f, 0.00915090f, 0.01229520f, 0.00431277f, 0.02288083f, -0.00343569f, -0.01678868f, 0.03136024f, 
    -0.00452119f, -0.02771908f, -0.01399291f, -0.03182625f, 0.01725485f, -0.01670066f, 0.00426716f, -0.00772928f, 
    -0.01181718f, -0.02897993f, -0.02087881f, 0.00783355f, 0.01030907f, -0.01622745f, 0.02774187f, 0.00889214f, 
    0.00776767f, -0.01166217f, 0.00661993f, 0.02409638f, -0.02426126f, 0.01018228f, -0.00712661f, -0.01038966f, 
    0.02949062f, 0.00124104f, 0.00543419f, -0.00963688f, 0.02826321f, -0.01076321f, 0.02591859f, 0.03006812f, 
    0.01781920f, 0.03087706f, 0.00917099f, -0.01538040f, -0.03818129f, 0.02542869f, -0.03190921f, -0.03296538f, 
    -0.01912987f, 0.01256019f, -0.02003193f, 0.00585325f, -0.00391281f, -0.01283308f, -0.02103707f, -0.02975300f, 
    0.02844596f, -0.02073502f, -0.03034422f, 0.01383181f, -0.00910024f, -0.03037398f, 0.00024538f, 0.00911783f, 
    -0.02717783f, 0.00607980f, -0.03603400f, -0.01729388f, -0.02387470f, -0.00822001f, 0.00778447f, -0.00585702f, 
    0.03374610f, 0.02554493f, -0.03785750f, -0.00117867f, -0.00303442f, -0.01471172f, 0.02222547f, 0.00213417f, 
    -0.02854372f, 0.01393587f, -0.03041377f, 0.00351020f, 0.01200582f, 0.00409577f, -0.02420899f, -0.02138359f, 
    0.00522608f, 0.02546605f, -0.01296661f, -0.01994409f, -0.00494802f, 0.03679225f, 0.02508873f, -0.03208761f, 
    -0.01118357f, 0.02267219f, 0.00568124f, 0.00447989f, 0.01116396f, 0.01635019f, 0.01672191f, -0.01214613f, 
    -0.02572160f, -0.01380769f, 0.00122476f, -0.00711347f, 0.01688258f, 0.02168563f, 0.02843355f, -0.01768418f, 
    -0.02303656f, 0.00084917f, 0.01930431f, -0.00509411f, -0.04134475f, -0.00518807f, 0.02636357f, -0.03487173f, 
    -0.03178521f, 0.00735687f, 0.02210805f, 0.03566064f, 0.00360578f, -0.00481656f, -0.02012532f, 0.03376108f, 
    -0.02439555f, -0.00026682f, -0.03446837f, 0.02820333f, -0.01476586f, 0.01659016f, 0.02189208f, 0.02453350f, 
    0.02792945f, 0.01321761f, -0.02802228f, 0.01406515f, -0.02629224f, -0.02987520f, 0.01662799f, -0.00774202f, 
    -0.03385724f, 0.02407946f, -0.00127480f, 0.02264623f, -0.02600845f, 0.00362254f, -0.02500165f, 0.00272194f, 
    -0.01091521f, 0.00043643f, -0.02559971f, -0.03833172f, 0.01835265f, 0.02677253f, 0.01651409f, -0.00043122f, 
    -0.02560713f, -0.00740491f, -0.00557650f, 0.00825175f, -0.01225429f, 0.02306927f, 0.01238019f, 0.01168239f, 
    -0.03493588f, -0.02059189f, -0.01320027f, -0.00609993f, -0.03369893f, -0.02371703f, -0.00080408f, -0.01107389f, 
    0.03029192f, -0.01473222f, -0.03052851f, -0.02376297f, 0.02108119f, -0.01495630f, -0.03294926f, 0.02092614f, 
    0.00795009f, 0.03309149f, -0.01904586f, -0.02643103f, 0.01202716f, 0.00438138f, 0.01057666f, 0.00646791f, 
    -0.00021997f, -0.00798748f, 0.03074694f, -0.01241822f, 0.01728484f, -0.00800808f, -0.02668011f, 0.00329486f, 
    -0.00880466f, -0.00492792f, -0.03185402f, -0.01361483f, 0.00237158f, -0.03151768f, -0.00894984f, -0.00519306f, 
    -0.01502542f, 0.02756684f, -0.03259382f, 0.00910559f, 0.00127941f, -0.03051861f, 0.00959123f, 0.02392183f, 
    -0.03468021f, 0.00513897f, -0.03239901f, -0.01010213f, -0.02907087f, 0.00407534f, 0.00432274f, -0.00343617f, 
    0.02806797f, -0.02189471f, -0.01038765f, -0.00637626f, -0.02003311f, -0.03846798f, -0.00308102f, -0.02880324f, 
    0.00770575f, 0.02627862f, -0.02090590f, 0.00849481f, -0.03430657f, 0.03437136f, 0.01580771f, 0.01148662f, 
    -0.02052303f, 0.00826633f, 0.01984330f, 0.02672902f, 0.01335773f, -0.03309610f, 0.01652671f, 0.02246193f, 
    -0.02387225f, 0.02224601f, -0.01882511f, -0.01852400f, -0.03262247f, -0.00716668f, -0.01823358f, -0.01607425f, 
    -0.02909361f, 0.00926930f, -0.03384830f, -0.01266011f, -0.02267422f, -0.03903851f, -0.01811082f, 0.00266576f, 
    -0.01921083f, -0.01197612f, -0.02462550f, -0.00411173f, -0.03269944f, -0.02969963f, -0.01012012f, 0.03187212f, 
    -0.00240873f, 0.01492206f, -0.01475543f, -0.00237296f, -0.01312457f, 0.02412485f, 0.03306987f, 0.02761859f, 
    0.02042425f, -0.02204485f, -0.03751544f, 0.01901872f, -0.02445024f, -0.00474507f, 0.01376807f, -0.02423926f, 
    -0.02774572f, -0.01254205f, -0.01563330f, 0.03158303f, -0.00848318f, -0.04132973f, 0.02345188f, 0.03010402f, 
    -0.01537743f, -0.02577385f, -0.00080447f, 0.00272611f, -0.00143034f, -0.01246031f, -0.01150369f, -0.02761988f, 
    -0.03209296f, -0.00271276f, -0.02951326f, 0.00103858f, 0.00981285f, -0.01575108f, 0.02967363f, -0.00571972f, 
    -0.00791296f, -0.00484055f, -0.00293718f, -0.03200997f, 0.00894257f, 0.01156750f, -0.02758829f, 0.02876845f, 
    0.02141879f, -0.01239184f, -0.00613238f, 0.00450427f, -0.01230455f, -0.01232113f, 0.02790314f, 0.01239639f, 
    0.02939691f, 0.03185356f, -0.01252706f, -0.01776520f, 0.01288640f, 0.00687670f, -0.00020941f, -0.02635315f, 
    0.00482602f, 0.02498215f, 0.02725344f, -0.00624747f, 0.00222771f, -0.02543533f, -0.00444588f, 0.02143016f, 
    -0.00756025f, -0.02429655f, -0.03153969f, -0.02201353f, -0.02742868f, 0.01297132f, -0.03933115f, 0.01381828f, 
    -0.03668102f, 0.02811753f, -0.01201386f, 0.02479265f, -0.00960330f, 0.02112832f, -0.02400908f, -0.03576661f, 
    -0.00815650f, -0.02285450f, -0.03730212f, -0.03108787f, -0.01549121f, -0.01535791f, -0.02207466f, -0.02154279f, 
    0.02087603f, -0.00518851f, 0.00658825f, 0.01892786f, -0.00988443f, -0.02291972f, 0.01766123f, 0.00309532f, 
    0.00714745f, -0.00726228f, 0.01079525f, 0.00053113f, 0.03642134f, 0.03775039f, 0.03526580f, -0.03132495f, 
    -0.00918747f, -0.01267498f, -0.00785713f, -0.01345132f, -0.00099573f, -0.02704255f, 0.02954985f, -0.01082588f, 
    -0.02401035f, 0.02609592f, -0.00833024f, 0.00615045f, -0.02229761f, -0.03563754f, -0.01025924f, -0.00049696f, 
    -0.02285961f, -0.00971283f, -0.01737790f, -0.01091782f, -0.00503696f, 0.01446433f, 0.00637570f, -0.01552859f, 
    0.02647359f, 0.00392688f, 0.02198389f, -0.04023321f, -0.01003647f, 0.02121620f, 0.01142696f, -0.01464865f, 
    0.02083447f, -0.00798207f, -0.02893942f, 0.02284190f, 0.01136244f, -0.00345536f, -0.00643934f, -0.00541248f, 
    0.02512616f, 0.01947423f, 0.01860201f, 0.00079558f, -0.01186903f, -0.01396035f, 0.01484816f, 0.04011013f, 
    -0.00520623f, 0.01696733f, -0.01182768f, 0.01497322f, -0.01631827f, -0.02989854f, 0.03296277f, 0.00248393f, 
    0.03535745f, -0.03582499f, -0.02054551f, -0.02785584f, 0.01794794f, -0.00475907f, -0.01587598f, 0.00515911f, 
    0.01121600f, 0.03376263f, -0.00122870f, 0.02964393f, -0.00353272f, -0.04685675f, 0.00310025f, 0.00360836f, 
    0.00518652f, -0.01981460f, 0.01160674f, -0.02119830f, 0.00733690f, -0.03575894f, -0.00169188f, -0.00326175f, 
    0.03095115f, 0.00858036f, -0.02725945f, -0.02755862f, -0.00842706f, -0.01026539f, -0.03270032f, 0.00728540f, 
    -0.03735057f, -0.00073466f, -0.02989679f, -0.03399510f, -0.03262132f, -0.00959490f, -0.02467916f, 0.00812129f, 
    0.00211245f, -0.01155652f, -0.01195200f, 0.03198490f, -0.01439401f, 0.00226145f, 0.01425237f, -0.03994711f, 
    0.20138289f, -0.02447379f, 0.07701435f, -0.07320414f, -0.02929071f, -0.02507265f, 0.04445542f, 0.05517947f, 
    -0.00853417f, -0.01202374f, 0.05787995f, 0.08984459f, -0.01313411f, -0.10289069f, 0.12256333f, 0.25891581f, 
    -0.05602792f, 0.08624532f, -0.00280487f, -0.01787518f, -0.01126458f, 0.07647273f, 0.09989221f, -0.01567907f, 
    0.12156963f, 0.07104816f, -0.00027683f, 0.24977492f, -0.01568309f, 0.01099155f, -0.06077605f, 0.07532313f, 
    0.01820807f, -0.00256482f, -0.05370316f, 0.11718935f, -0.03403604f, 0.00509781f, 0.00205746f, -0.16744138f, 
    -0.03527124f, 0.12679648f, 0.03621000f, -0.04673781f, 0.08510970f, 0.05318048f, -0.00613014f, 0.10194830f, 
    0.10260401f, -0.09691449f, -0.20641494f, 0.18190494f, 0.02770174f, 0.08266836f, -0.00092954f, -0.02094219f, 
    0.03496171f, 0.12075999f, -0.03767462f, -0.05133063f, 0.00122333f, -0.12908608f, 0.01642097f, 0.15822865f, 
    0.09345704f, 0.03530629f, -0.02686095f, -0.00164080f, 0.00649490f, 0.00035136f, -0.02064926f, -0.00204785f, 
    0.01578091f, 0.08466928f, 0.14095213f, 0.08908437f, 0.10254097f, -0.05719447f, 0.02161918f, -0.04969918f, 
    -0.08770304f, 0.00140282f, 0.05352363f, 0.01850960f, -0.13247600f, 0.03755857f, 0.15925361f, 0.18404889f, 
    0.03534854f, -0.11071555f, 0.01900473f, 0.01847930f, -0.12697215f, 0.00925737f, 0.18015479f, -0.02706044f, 
    -0.18158972f, 0.03896420f, 0.03356691f, -0.05609529f, 0.13390823f, 0.07336938f, -0.10363142f, 0.15106499f, 
    -0.07014571f, -0.02382970f, -0.04006051f, 0.02322335f, -0.16358888f, 0.03748270f, 0.00562117f, -0.18923454f, 
    0.13008015f, 0.04664157f, -0.01317015f, 0.04792768f, 0.06371304f, 0.00150750f, -0.02706667f, 0.00262213f, 
    -0.09108911f, -0.00580579f, -0.05945686f, 0.27040887f, 0.01957990f, 0.07571746f, 0.00516205f, 0.01631097f, 
    0.02977066f, 0.02569009f, 0.00074464f, 0.05840022f, -0.07249604f, -0.05005436f, 0.01036356f, 0.08247210f, 
    0.10152203f, 0.02304598f, -0.01369095f, -0.05604362f, 0.01881507f, -0.01730504f, -0.11020545f, 0.08157608f, 
    0.04271831f, 0.11339778f, 0.00388637f, 0.32816768f, 0.05429060f, 0.05574282f, 0.01158816f, -0.09860560f, 
    -0.06034304f, -0.09403045f, 0.07396802f, -0.05575502f, 0.13107358f, 0.11467399f, -0.03899308f, 0.04850659f, 
    0.00744458f, -0.01788883f, -0.01493584f, -0.07743125f, 0.03907873f, 0.01955163f, 0.03524216f, -0.04140334f, 
    0.14883152f, 0.04082548f, 0.01216317f, 0.16812164f, 0.00758538f, -0.02177206f, 0.04538146f, -0.00802568f, 
    0.02814856f, 0.00150274f, 0.04270853f, 0.09584134f, 0.15974747f, 0.12319948f, 0.17313020f, -0.01555779f, 
    -0.01095406f, 0.00825519f, 0.05853279f, 0.01421613f, -0.00560748f, -0.03624715f, 0.05712340f, 0.00500052f, 
    -0.18102279f, 0.17993218f, -0.11959278f, -0.19585933f, 0.08376992f, 0.05222302f, 0.05642954f, -0.02827024f, 
    0.02208984f, -0.05751176f, 0.00872295f, 0.03261426f, 0.02831381f, -0.03459981f, -0.05577463f, 0.12318880f, 
    0.06764798f, 0.09172191f, 0.08983508f, -0.02453040f, -0.03789838f, -0.04279841f, 0.04531779f, 0.10149933f, 
    0.10911793f, -0.20235699f, -0.07264697f, 0.16567099f, -0.03410194f, -0.02936022f, -0.05115225f, 0.03188816f, 
    -0.00025471f, -0.07141647f, -0.02683994f, -0.08607543f, -0.08853202f, -0.04301989f, -0.11942312f, 0.00265923f, 
    0.07422363f, 0.03428612f, -0.04262300f, 0.10857665f, 0.06773055f, -0.02919839f, 0.08414073f, 0.06056529f, 
    -0.07657097f, -0.02364353f, -0.15777217f, 0.09502173f, 0.08730001f, 0.03027004f, -0.01843653f, 0.01424865f, 
    -0.01821320f, 0.00191178f, 0.01960524f, -0.00766469f, 0.25130850f, -0.06981753f, -0.10332144f, -0.26282611f, 
    0.06201308f, 0.10362574f, 0.02094329f, 0.03183728f, 0.08963984f, 0.06111675f, -0.00286005f, -0.06909837f, 
    0.14485568f, -0.11076690f, 0.10853694f, -0.13002184f, 0.01474110f, 0.01497584f, 0.02951785f, -0.04691163f, 
    0.04560112f, -0.05551096f, 0.06144648f, -0.04782854f, -0.21960784f, 0.19193381f, 0.02422681f, 0.01508531f, 
    -0.03655743f, 0.04519178f, 0.04497321f, -0.01641939f, 0.05832805f, 0.00013949f, 0.08587401f, -0.02317480f, 
    0.09914151f, 0.03728493f, 0.04546025f, 0.07614571f, 0.00101202f, 0.08603299f, 0.05859613f, 0.00646594f, 
    -0.09728920f, 0.18298657f, 0.02644583f, 0.02515296f, 0.03810461f, 0.00781128f, -0.05979750f, -0.04492657f, 
    -0.04124488f, 0.05028258f, 0.02977381f, 0.09219756f, 0.09893274f, 0.01723772f, -0.01402340f, 0.02254737f, 
    0.05453569f, -0.21704061f, -0.02569423f, 0.01359452f, -0.01984551f, 0.00922271f, 0.04528843f, -0.00308997f, 
    0.01919969f, -0.12902421f, -0.00340404f, -0.06051945f, -0.08133126f, 0.01992676f, -0.22257563f, -0.08086918f, 
    0.19333942f, 0.03825997f, 0.05913604f, -0.00619389f, -0.00331235f, -0.01386844f, 0.14238380f, 0.04216529f, 
    0.20645465f, 0.10755427f, -0.15619975f, 0.16891658f, -0.02080162f, -0.02923343f, 0.03463366f, -0.06831731f, 
    0.14657524f, 0.07771649f, 0.13196403f, 0.06312632f, -0.13201585f, -0.01745854f, -0.11516953f, 0.27318850f, 
    0.08067720f, -0.03606660f, -0.02127926f, -0.02844157f, 0.01199925f, 0.09834521f, 0.08362351f, -0.05254314f, 
    0.02000480f, -0.04764176f, 0.22697224f, -0.17419223f, 0.01262107f, -0.06192320f, 0.03634625f, -0.04593004f, 
    -0.03015009f, 0.05596283f, 0.13995318f, -0.01712138f, -0.08345114f, 0.06428100f, -0.15381601f, -0.02629625f, 
    -0.04674799f, 0.07535824f, 0.05968619f, 0.05635897f, -0.06286023f, -0.05527274f, 0.00019943f, -0.04067413f, 
    0.06402756f, 0.03929463f, 0.02682550f, 0.10022566f, 0.06378855f, 0.02420899f, 0.02599705f, 0.01566823f, 
    0.02082729f, 0.03180304f, 0.03893526f, 0.07608017f, -0.04435681f, -0.10649112f, -0.01173200f, -0.13856599f, 
    0.08286037f, 0.00731758f, 0.05435148f, -0.04680216f, 0.09557262f, -0.06908405f, 0.06128743f, -0.03787905f, 
    -0.05312319f, 0.16583456f, 0.11820255f, 0.06129061f, -0.05438587f, 0.02258063f, 0.00749133f, 0.06039228f, 
    -0.02028950f, -0.05339267f, -0.00124826f, 0.09520232f, -0.05844142f, -0.07118282f, 0.13718480f, -0.06801532f, 
    -0.00381391f, -0.00305121f, -0.04716077f, -0.01878309f, -0.03223496f, 0.08990203f, 0.00885415f, -0.05872459f, 
    -0.11953218f, 0.08790983f, 0.01361656f, -0.17083669f, 0.05947986f, 0.01798175f, 0.09030216f, 0.03570025f, 
    -0.00180366f, -0.01617931f, 0.03840571f, -0.00303311f, -0.01811694f, 0.23090820f, 0.18609901f, -0.05269497f, 
    0.18248746f, 0.02702672f, -0.02934274f, -0.06138356f, -0.07277523f, -0.02467894f, -0.02919455f, -0.04417044f, 
    -0.06767053f, 0.02803901f, 0.06307673f, 0.10589256f, 0.03050155f, 0.11993027f, 0.01328442f, 0.06548879f, 
    -0.01013629f, 0.09259266f, 0.03446363f, 0.08095209f, -0.11187610f, 0.11612455f, 0.02430233f, -0.15871212f, 
    0.07015187f, 0.00217078f, 0.06139931f, 0.06222432f, -0.04702040f, -0.01040354f, -0.03360393f, -0.01441207f, 
    -0.00704979f, 0.01152011f, -0.14403459f, 0.00964423f, 0.12117229f, 0.02979140f, 0.01147406f, -0.10806345f, 
    -0.03958480f, 0.00843247f, 0.02572233f, -0.01254365f, -0.20453994f, -0.02141704f, 0.02272809f, -0.18867499f, 
    0.01886487f, 0.00040094f, 0.04092017f, -0.01282736f, 0.01929086f, -0.03451143f, 0.00915046f, -0.06427297f, 
    -0.06532286f, -0.10811034f, -0.07697006f, -0.15100455f, 0.09367654f, -0.04098187f, -0.05035370f, 0.03967392f, 
    0.09681899f, 0.00323818f, 0.01129328f, -0.00739710f, 0.15716538f, -0.04399990f, -0.19220780f, 0.17968939f, 
    -0.01792356f, 0.06140454f, 0.00736960f, 0.06219576f, -0.04602265f, -0.05473080f, -0.01776840f, 0.08506349f, 
    -0.04573860f, -0.13310091f, 0.08379103f, -0.02996595f, 0.04974788f, 0.03374112f, 0.07849115f, 0.06331867f, 
    -0.00436904f, 0.03353713f, 0.04264957f, -0.04260850f, -0.01524256f, 0.05063143f, 0.08665925f, 0.00829854f, 
    0.06351437f, 0.05095138f, -0.01459383f, -0.02436737f, 0.02788698f, 0.06886791f, -0.04446144f, -0.12223538f, 
    -0.27494717f, 0.04186697f, -0.07637558f, -0.15011236f, 0.09262999f, -0.08107401f, -0.04176505f, -0.00173291f, 
    0.02378801f, 0.03949827f, 0.03334454f, 0.03490584f, 0.13285871f, 0.04193242f, 0.09538840f, 0.23422404f, 
    0.02267376f, -0.09258315f, 0.09561896f, -0.03351935f, 0.10219504f, -0.06593812f, 0.06540039f, -0.03514113f, 
    0.09279051f, 0.01022842f, 0.00366378f, 0.09416476f, -0.02643580f, -0.00115596f, 0.13643205f, -0.06170097f, 
    0.04466140f, -0.05598781f, 0.01350171f, 0.05311333f, -0.00326969f, 0.00880430f, 0.04084108f, -0.14537229f, 
    0.00212047f, -0.12748681f, 0.11008652f, -0.03333534f, -0.02299802f, -0.03733590f, 0.05293373f, 0.07522972f, 
    -0.01918206f, -0.09599515f, -0.10685450f, 0.14418323f, 0.01897402f, 0.03559443f, -0.03296715f, 0.09219091f, 
    -0.01887880f, -0.04092611f, -0.00838802f, 0.01635245f, -0.05217597f, 0.12701581f, 0.14441040f, -0.14388102f, 
    0.11768344f, 0.00140059f, 0.08199291f, -0.03276050f, -0.01954901f, -0.07997540f, -0.06771798f, -0.09345452f, 
    0.02396349f, 0.05872183f, 0.05305339f, 0.15735066f, -0.08813615f, 0.01922664f, 0.09150915f, -0.01411915f, 
    -0.00137134f, 0.08723055f, 0.06259659f, 0.11361288f, -0.01133368f, -0.02901640f, 0.07304705f, -0.22102854f, 
    -0.03360607f, -0.03535066f, 0.01504031f, 0.09142423f, -0.03011705f, 0.00041750f, 0.18103641f, 0.00918472f, 
    0.33096394f, 0.12541276f, -0.17884368f, 0.20864837f, 0.01948407f, 0.00845129f, -0.07898672f, 0.00777202f, 
    -0.01116219f, 0.03903051f, 0.03130886f, -0.02511314f, -0.13259894f, 0.13129765f, -0.10172994f, 0.39475155f, 
    0.01029125f, -0.00356663f, -0.00852879f, 0.12974645f, -0.02425420f, 0.04554644f, 0.04244541f, -0.05014749f, 
    0.01177548f, 0.05279289f, -0.01658468f, 0.02075197f, 0.07012183f, 0.02141695f, 0.00914856f, 0.08698656f, 
    0.03375545f, -0.10992888f, -0.02089399f, 0.08521771f, -0.20343113f, 0.13510740f, -0.04696659f, -0.12036882f, 
    0.04022735f, 0.07145663f, 0.00938463f, 0.06041259f, 0.02572984f, 0.01927162f, 0.15695867f, -0.03108757f, 
    0.00864540f, 0.02416944f, -0.13626654f, 0.10894057f, 0.04978353f, -0.03264909f, 0.07483410f, -0.00930972f, 
    0.01766822f, 0.06581784f, 0.02082163f, 0.02305827f, 0.03979866f, -0.12964180f, -0.01142365f, -0.00484408f, 
    0.08424304f, 0.01292675f, 0.05778901f, 0.11336853f, -0.01765425f, -0.04392642f, -0.11901059f, -0.07598577f, 
    0.23322949f, 0.18109822f, -0.03804439f, 0.07446572f, 0.00501363f, 0.01619314f, -0.01826146f, -0.11813644f, 
    0.08721010f, -0.00465701f, -0.09265555f, 0.01159676f, -0.09609448f, -0.01559359f, 0.13499741f, 0.07902464f, 
    -0.11311231f, 0.13159053f, -0.00639845f, -0.01696647f, -0.08668186f, 0.07169499f, -0.03184076f, -0.02891331f, 
    0.26459071f, -0.14514640f, 0.25746214f, 0.22292006f, -0.00967559f, -0.11528815f, 0.03496939f, 0.03070601f, 
    0.09067720f, -0.06448225f, 0.02644779f, 0.03451574f, 0.11234179f, 0.10693034f, 0.03102114f, 0.01665075f, 
    0.02554326f, -0.01693860f, -0.04458375f, -0.05372563f, 0.01528692f, 0.02471397f, -0.06128830f, -0.11924344f, 
    -0.02835776f, 0.01297382f, 0.02805976f, 0.13873202f, -0.01526427f, -0.01696955f, 0.07380088f, -0.09468791f, 
    0.07880167f, -0.04589677f, 0.10183289f, -0.01138643f, -0.10812350f, 0.04981835f, 0.03396645f, -0.11957809f, 
    0.08792028f, 0.08974146f, 0.00292063f, -0.05275052f, 0.09143601f, 0.06355777f, -0.02873315f, 0.02624067f, 
    -0.09478980f, -0.09522445f, 0.25177187f, 0.22467722f, 0.05207988f, 0.06373946f, -0.02003806f, 0.15126933f, 
    -0.09047295f, 0.02875846f, 0.02384336f, 0.01551759f, 0.33755732f, -0.01548900f, -0.02737068f, 0.09743097f, 
    -0.09380951f, 0.06606541f, 0.09811192f, 0.11862077f, -0.11530577f, -0.03058569f, 0.11831646f, 0.05782601f, 
    0.22508949f, -0.01900329f, 0.02575584f, 0.05288453f, -0.02189199f, -0.04694554f, 0.00496423f, 0.03683272f, 
    -0.04093769f, -0.04615831f, -0.05045911f, -0.00012811f, 0.15412651f, 0.11170331f, -0.00326020f, -0.06738786f, 
    -0.09305297f, -0.07992234f, 0.09601702f, 0.05531836f, -0.02683805f, -0.02460454f, -0.03125690f, 0.02849827f, 
    0.03314496f, 0.18523477f, 0.02767432f, -0.21055685f, -0.05503593f, 0.03306339f, -0.11790293f, -0.09080769f, 
    0.11278664f, 0.00785951f, -0.05593100f, 0.01963300f, -0.04240075f, 0.22545706f, -0.05049334f, -0.01385219f, 
    0.26403424f, 0.08219842f, 0.00353785f, -0.01356290f, 0.16839908f, 0.03172785f, 0.03429710f, 0.04101319f, 
    -0.12778364f, 0.01191436f, 0.10084034f, -0.05401696f, 0.04065574f, -0.00701789f, -0.05227531f, -0.00475339f, 
    -0.00748421f, 0.00983229f, 0.01589601f, 0.04605970f, -0.00221948f, -0.06856276f, 0.03992582f, 0.15891850f, 
    -0.07198345f, -0.09472308f, 0.06072901f, 0.06116726f, -0.00376749f, -0.08679777f, -0.01589122f, 0.03416163f, 
    -0.10401219f, -0.08636394f, -0.08385833f, -0.00299263f, 0.01977259f, 0.00462276f, -0.03271984f, 0.11238279f, 
    0.14697057f, 0.01367525f, -0.03137898f, 0.07325854f, -0.23097619f, 0.08157355f, 0.04030420f, 0.10124242f, 
    -0.00417260f, 0.09975060f, 0.00226574f, -0.01730171f, 0.02633474f, -0.00910096f, 0.02719385f, 0.01936151f, 
    -0.24158125f, 0.10420168f, 0.05780037f, -0.21622689f, 0.08815753f, 0.07270280f, -0.00352822f, 0.06874736f, 
    0.08006985f, -0.06208725f, -0.02224726f, -0.00319776f, -0.00079010f, -0.05225125f, 0.08799909f, 0.11207280f, 
    0.01759537f, 0.04128603f, -0.05568252f, -0.00210961f, 0.09627275f, 0.02776036f, 0.01340124f, 0.02208876f, 
    -0.08013357f, 0.01374929f, -0.02329248f, 0.04915596f, -0.04502431f, 0.07008919f, -0.06815916f, 0.13313171f, 
    -0.09467404f, 0.03202017f, 0.07756148f, 0.01186191f, -0.00501543f, 0.04331529f, -0.08183176f, 0.09140959f, 
    -0.00501909f, 0.12992041f, -0.05054464f, 0.03429474f, 0.06612799f, 0.09651453f, 0.05477639f, 0.05627655f, 
    0.24085881f, 0.06505445f, 0.01114020f, -0.01530205f, -0.06219190f, 0.06453838f, 0.00438180f, 0.03415202f, 
    0.03637516f, 0.02463448f, -0.06115680f, 0.02934304f, 0.32894397f, 0.07166590f, 0.05800567f, 0.02557387f, 
    -0.04444556f, 0.11275257f, 0.04317931f, -0.03733395f, -0.01519748f, -0.01168059f, 0.13479005f, 0.03782703f, 
    -0.10955866f, -0.05173013f, 0.07602023f, 0.19594245f, -0.05086963f, -0.08277921f, 0.03747559f, 0.01432754f, 
    -0.13258371f, -0.08703676f, -0.01785639f, -0.01990737f, -0.12401799f, -0.06543491f, 0.13229066f, -0.04128711f, 
    -0.01168300f, 0.05088662f, 0.05256265f, 0.07977944f, -0.10487200f, -0.05209060f, 0.07761738f, 0.03882589f, 
    0.16687448f, -0.07457942f, 0.27154297f, 0.30098635f, -0.16143639f, 0.00359136f, 0.12969489f, 0.07129396f, 
    -0.11381145f, -0.01210691f, -0.02793972f, 0.08661374f, 0.26300797f, -0.09299792f, -0.04655508f, 0.15609457f, 
    -0.09178253f, 0.03657799f, 0.03491623f, 0.04888926f, -0.01159937f, 0.00348550f, 0.06660943f, -0.03809030f, 
    0.33516940f, 0.06048520f, -0.09347823f, 0.14569594f, -0.06104596f, 0.06438762f, 0.07344993f, 0.03697871f, 
    0.00845366f, -0.02050843f, -0.05015694f, 0.05440491f, 0.16581923f, -0.02067613f, -0.03147361f, -0.01497711f, 
    -0.06677676f, -0.02302280f, -0.10408389f, 0.02598992f, -0.11890292f, 0.01767946f, -0.04552845f, -0.03543793f, 
    -0.00900689f, -0.01791451f, -0.03236403f, -0.00272122f, -0.00308315f, 0.06653970f, -0.05750535f, 0.00740181f, 
    -0.04593265f, 0.07954366f, 0.06540041f, 0.01963567f, 0.21153651f, 0.03322006f, -0.08128262f, 0.14888319f, 
    0.07328514f, -0.01168422f, 0.03492000f, 0.01054841f, -0.12499613f, -0.01361106f, -0.08416928f, -0.02102922f, 
    0.32605425f, 0.16145884f, 0.13526911f, 0.12172763f, -0.09280441f, 0.00105450f, 0.05809788f, 0.02841526f, 
    -0.01025590f, 0.03584665f, 0.06975912f, 0.00113777f, 0.20272426f, -0.05824075f, 0.04759320f, 0.08788707f, 
    -0.05385662f, 0.02816496f, -0.11234322f, 0.08166166f, -0.13329527f, -0.08345524f, 0.01721033f, 0.02348078f, 
    0.18044293f, -0.01758714f, 0.15209626f, 0.08993592f, -0.02849918f, 0.06097591f, 0.17515448f, -0.02734787f, 
    -0.08319233f, -0.00097192f, -0.00194230f, 0.01379426f, -0.00121356f, -0.11192966f, 0.15375805f, -0.10472514f, 
    -0.06240161f, -0.01898497f, -0.05020902f, 0.00871049f, -0.00268469f, -0.00906440f, 0.05906154f, -0.02376952f, 
    -0.05742974f, 0.25550047f, 0.04832085f, 0.00665242f, 0.01676374f, 0.11510527f, 0.00495320f, 0.02074708f, 
    0.01119933f, 0.04638114f, 0.04446615f, -0.01790164f, 0.22886100f, -0.18216297f, -0.04969430f, -0.15431200f, 
    0.09499502f, 0.03405352f, 0.06105560f, 0.00831775f, 0.10440163f, 0.05790062f, 0.02107929f, -0.03859798f, 
    0.04364670f, 0.06176057f, 0.09649237f, 0.07640264f, -0.11694386f, 0.02680383f, -0.00980700f, -0.03158529f, 
    0.02389149f, -0.08718622f, -0.00601152f, 0.03063578f, -0.07994432f, 0.09924565f, 0.09647650f, 0.03989695f, 
    -0.09184144f, -0.04292135f, 0.01803381f, 0.09649047f, -0.02060555f, -0.02278363f, -0.06616820f, -0.08876862f, 
    -0.03241123f, -0.02461573f, 0.04307476f, 0.13274601f, -0.04267520f, 0.02417987f, -0.05257574f, -0.01602246f, 
    -0.02031577f, 0.02742991f, 0.01223422f, -0.02857818f, -0.17818050f, -0.00117066f, 0.07939348f, -0.08818102f, 
    -0.01373386f, 0.01831688f, 0.01671182f, -0.05209338f, -0.01623702f, -0.05865162f, -0.03163755f, 0.00489426f, 
    0.22445148f, 0.02258704f, 0.02467104f, 0.09744672f, -0.01771443f, 0.07017668f, -0.03533404f, -0.07629098f, 
    0.05146926f, -0.07124966f, -0.03997193f, -0.03989275f, -0.29954609f, -0.01238322f, -0.02618513f, 0.13966219f, 
    0.02312856f, -0.04960949f, 0.01925015f, 0.03778410f, -0.05789792f, -0.01227336f, -0.07530691f, -0.06421096f, 
    0.29708096f, -0.09380101f, -0.19134326f, -0.09460908f, 0.15282831f, 0.07365763f, -0.02798142f, -0.12495427f, 
    0.13286874f, -0.02755347f, 0.01780973f, -0.02033625f, -0.08534146f, 0.13815036f, 0.11630516f, -0.01467744f, 
    -0.04676804f, 0.00721816f, 0.01228784f, 0.00431193f, -0.01808505f, 0.01767256f, 0.03070737f, -0.04708109f, 
    0.20347448f, 0.05366306f, 0.04052346f, -0.07388694f, -0.06971106f, 0.02947775f, 0.02051305f, -0.02023602f, 
    -0.03274116f, 0.02255654f, -0.04004104f, -0.01663895f, 0.21042065f, 0.08498996f, 0.01669502f, 0.19715919f, 
    -0.08514145f, 0.08529188f, 0.11338057f, 0.06379808f, 0.07389358f, -0.12037630f, -0.07844904f, 0.03452085f, 
    0.06444708f, 0.06732965f, -0.03036186f, -0.00973118f, -0.10287724f, -0.00260659f, 0.01405423f, 0.03723702f, 
    -0.11143848f, -0.01883994f, 0.01034293f, -0.08232884f, 0.22117580f, -0.15007076f, -0.05025097f, -0.08561961f, 
    0.04033312f, -0.06618006f, 0.07180919f, 0.05142531f, 0.07802015f, -0.03900441f, 0.02014069f, -0.01249497f, 
    -0.28865096f, 0.09769102f, -0.00192869f, -0.04475205f, -0.02701019f, -0.04502311f, -0.05191943f, 0.00334962f, 
    -0.03786207f, -0.02437031f, -0.00491333f, 0.05315187f, -0.26644167f, 0.04069103f, -0.23285297f, -0.00426262f, 
    -0.03881939f, -0.01127448f, -0.02931786f, -0.06008885f, 0.06209367f, -0.02392579f, 0.02507911f, 0.03097336f, 
    -0.29099327f, 0.25754854f, 0.09953501f, -0.01776422f, -0.05064145f, 0.05161928f, 0.04530738f, -0.03766719f, 
    -0.07237864f, 0.02938277f, 0.00993733f, -0.04609689f, 0.22612938f, 0.06880738f, 0.07721214f, 0.08344336f, 
    0.10904192f, 0.05728803f, 0.07748075f, 0.08007033f, -0.03976850f, 0.02162657f, 0.00763369f, 0.00771412f, 
    -0.07139969f, 0.03531936f, 0.04351176f, 0.23832016f, -0.06151442f, -0.03592389f, -0.01173712f, 0.06509018f, 
    -0.00503336f, 0.00907942f, -0.00945174f, -0.05659371f, -0.02758636f, 0.09519088f, 0.15228830f, -0.10973920f, 
    0.19587673f, 0.03416630f, -0.05442725f, -0.02247745f, 0.00779618f, 0.02850966f, -0.02332247f, -0.02000316f, 
    -0.01323213f, -0.10709992f, 0.14772856f, 0.21239856f, 0.06178636f, -0.04730445f, -0.00267732f, -0.08612971f, 
    -0.12017368f, -0.02584521f, -0.00488964f, 0.15577419f, -0.27444091f, 0.17595634f, -0.04350856f, -0.01711012f, 
    0.12962379f, 0.05615555f, -0.07843792f, -0.01629766f, 0.07281800f, -0.09923188f, -0.08390921f, 0.00741533f, 
    0.06502005f, -0.06591506f, -0.08586484f, 0.06632554f, 0.02384080f, 0.02344568f, -0.00852725f, -0.10435890f, 
    -0.10060386f, -0.04248305f, 0.11177521f, 0.06581855f, -0.12335262f, 0.20838080f, 0.04918731f, -0.04772349f, 
    -0.05300207f, 0.04081419f, 0.06950440f, 0.03145586f, -0.05146848f, 0.03444609f, 0.10205171f, -0.02696797f, 
    0.22892566f, -0.10042582f, 0.01136568f, 0.00499319f, 0.06108703f, -0.00012892f, 0.03613245f, -0.06621777f, 
    -0.09627392f, -0.01415921f, -0.01335515f, 0.00667041f, 0.13468906f, -0.16724861f, -0.06357350f, -0.29037526f, 
    0.07865714f, 0.06960362f, 0.01277575f, -0.05386871f, -0.07979129f, 0.05585479f, 0.10655815f, -0.02582225f, 
    -0.09169850f, -0.17820111f, -0.16961159f, 0.02980983f, 0.16170529f, 0.07010696f, -0.01162636f, 0.01601815f, 
    0.10570828f, 0.03616672f, 0.08473504f, -0.04921849f, 0.00151192f, 0.15131378f, 0.09214166f, -0.09944861f, 
    0.06966091f, 0.07273300f, 0.07474954f, -0.12443247f, -0.02383800f, 0.04703144f, 0.01785259f, -0.03337995f, 
    0.08306336f, 0.04641756f, 0.08137570f, -0.04327473f, -0.07212133f, -0.01786668f, 0.03867875f, 0.02379118f, 
    -0.02977437f, -0.07773105f, -0.04432778f, -0.05773312f, -0.04773036f, -0.02713271f, 0.06433062f, 0.08568880f, 
    0.00880923f, 0.00330446f, 0.02732262f, 0.04197373f, -0.14042081f, -0.16279927f, -0.06048397f, -0.04470778f, 
    0.28016421f, 0.24906512f, -0.01816618f, 0.11295541f, 0.03957419f, 0.02535488f, 0.06693271f, -0.05640457f, 
    -0.03230319f, 0.00967817f, 0.04841207f, -0.01284265f, -0.22874980f, -0.01985132f, -0.17247210f, -0.03900958f, 
    0.10233017f, 0.00932751f, 0.02314416f, -0.00665371f, -0.01847604f, -0.01935531f, -0.00328267f, 0.00052873f, 
    -0.14199817f, 0.11077957f, 0.22418885f, 0.09170186f, 0.07800558f, -0.06396044f, 0.03221730f, -0.03092443f, 
    0.00146531f, -0.05104954f, 0.06450814f, -0.01129553f, 0.20895980f, 0.03261356f, -0.05543871f, 0.00713723f, 
    0.01241948f, -0.03316367f, -0.07313386f, -0.06912904f, 0.07291707f, -0.04935565f, -0.09243440f, -0.04877253f, 
    0.26006976f, 0.00611972f, -0.00739563f, 0.14323807f, -0.03196657f, -0.00145970f, 0.09557416f, 0.09187292f, 
    0.11991420f, 0.19956589f, 0.04105382f, 0.00968602f, 0.06805917f, 0.08613674f, 0.12729263f, 0.07040662f, 
    0.02163952f, -0.00666855f, -0.03996630f, 0.07022099f, -0.09619526f, 0.02813238f, 0.05043038f, 0.02633608f, 
    0.10428423f, -0.01472426f, -0.10928163f, 0.00253975f, -0.01610656f, 0.10007311f, -0.10023423f, -0.00728509f, 
    0.06773756f, -0.02557495f, 0.03861767f, 0.01337951f, -0.18154559f, 0.10220702f, -0.06211475f, 0.01924048f, 
    0.05527559f, 0.08805525f, 0.04537910f, 0.03694033f, 0.11681711f, 0.04497775f, -0.02069973f, -0.01477298f, 
    -0.11128233f, 0.11267495f, 0.14528839f, -0.08796020f, 0.02401837f, 0.06743847f, 0.14192531f, -0.09115270f, 
    -0.10966306f, -0.04948848f, 0.07446043f, 0.03778095f, -0.10625288f, 0.06793508f, 0.20790327f, 0.01080408f, 
    -0.03332200f, 0.06310337f, 0.01498562f, 0.07539903f, -0.05707696f, -0.01861186f, -0.03729488f, -0.07512952f, 
    0.19366999f, -0.21607506f, 0.12505749f, 0.03647515f, 0.15386699f, 0.06186930f, 0.00170657f, 0.07464808f, 
    -0.12469909f, -0.08444434f, -0.05022306f, 0.03992860f, 0.27361327f, 0.00232499f, -0.04325356f, 0.08463053f, 
    0.02490126f, -0.01055896f, 0.16671310f, 0.27573860f, -0.04259798f, 0.02674739f, -0.06491480f, 0.10025528f, 
    0.10499982f, -0.05599976f, 0.01806030f, -0.02251701f, 0.04159723f, 0.09351414f, 0.06049213f, 0.04207753f, 
    0.08036349f, 0.04259446f, 0.08014029f, 0.07231127f, 0.04521933f, 0.27053642f, 0.06709670f, -0.05080163f, 
    0.00772076f, 0.02916706f, -0.06644621f, -0.05002338f, -0.01496851f, -0.08109238f, -0.00537621f, 0.05574877f, 
    0.07092248f, 0.05562054f, 0.19286102f, -0.01365657f, 0.01934581f, 0.06485822f, -0.00613268f, 0.07175329f, 
    0.08070053f, 0.16687529f, 0.02513362f, 0.08519144f, 0.21414161f, 0.06576382f, 0.03258368f, -0.00085489f, 
    0.10812353f, -0.02081115f, 0.15424266f, 0.00802510f, 0.08989402f, -0.09060096f, -0.16662452f, -0.05022030f, 
    0.19053376f, -0.15243587f, 0.02795544f, 0.00842781f, 0.03895222f, 0.02151365f, 0.00556354f, 0.02776507f, 
    0.02008115f, 0.05162266f, -0.04009062f, 0.23567170f, 0.08262799f, 0.07379056f, -0.06058657f, 0.08290095f, 
    0.08515175f, 0.05335478f, -0.09560735f, 0.02929733f, -0.07009334f, 0.18590245f, -0.12961589f, -0.07370424f, 
    -0.06314948f, 0.07027836f, 0.00944356f, 0.06333756f, 0.03755454f, 0.05739360f, 0.16701798f, -0.10948388f, 
    0.11234747f, -0.01164886f, -0.04957162f, -0.00015396f, 0.14256595f, -0.07235076f, -0.03501168f, 0.08277656f, 
    0.07821209f, 0.06561980f, 0.09243476f, 0.01549404f, -0.04176882f, 0.02343458f, -0.04100646f, -0.10461659f, 
    -0.17167632f, 0.09694288f, 0.08627980f, -0.01989914f, 0.02690814f, 0.07171855f, -0.04736206f, 0.07832992f, 
    -0.13348590f, 0.10945206f, 0.08583643f, 0.10988171f, -0.02025453f, 0.11248368f, -0.03696778f, -0.21418422f, 
    -0.00331792f, -0.02328826f, -0.03244403f, -0.00562929f, 0.00629499f, 0.01329587f, -0.15363804f, 0.01691914f, 
    0.07398091f, 0.17521983f, 0.07195161f, -0.12268174f, 0.02723504f, 0.17959546f, -0.06912126f, -0.07054502f, 
    0.00030597f, -0.07877277f, -0.05203616f, -0.08052977f, 0.18472230f, 0.01460399f, -0.01084523f, -0.11702796f, 
    0.00332177f, 0.07853761f, -0.08169295f, -0.01448910f, 0.05171119f, 0.07721752f, 0.18546112f, 0.07885581f, 
    -0.07357360f, 0.05256912f, -0.09236826f, -0.28097314f, 0.01423887f, -0.09840513f, -0.08453374f, 0.04698708f, 
    -0.07591147f, 0.04671869f, 0.02968476f, 0.09514356f, -0.07269546f, 0.18933178f, 0.20966053f, 0.09136008f, 
    -0.07422169f, 0.09500584f, 0.07812282f, 0.06408013f, 0.06040205f, 0.02773343f, 0.12346001f, -0.02835917f, 
    -0.08568143f, 0.02645811f, -0.02162553f, -0.04752943f, 0.07336614f, -0.04561829f, 0.05044237f, 0.08193789f, 
    -0.09881973f, 0.07055141f, -0.04907270f, -0.07874854f, -0.14721739f, -0.02863062f, 0.07087036f, -0.02360452f, 
    0.02829811f, 0.02837079f, 0.23668358f, 0.14255197f, 0.19682977f, 0.07737163f, 0.14843209f, 0.05472072f, 
    0.04880306f, -0.03555945f, 0.09569153f, 0.11315480f, 0.00239470f, 0.07848932f, 0.21147594f, 0.09016217f, 
    -0.07812870f, 0.09807019f, 0.11071264f, 0.11543291f, -0.13284832f, 0.08415353f, 0.10325645f, 0.06140688f, 
    0.04144787f, -0.09547310f, 0.01293694f, -0.02240453f, -0.00790771f, 0.09041455f, -0.06978343f, 0.13164133f, 
    0.03777411f, 0.09725636f, 0.05845828f, -0.13555385f, 0.04365089f, 0.01385488f, 0.04746938f, -0.01344632f, 
    -0.04230354f, -0.01138660f, -0.03942905f, -0.11077703f, 0.06506642f, 0.12871622f, 0.07178140f, -0.04790001f, 
    -0.03292238f, 0.10730777f, 0.04422937f, 0.08477244f, 0.00017605f, -0.03147591f, 0.14425398f, -0.01022841f, 
    -0.06972197f, 0.04482597f, 0.23179165f, -0.13043578f, 0.01142209f, -0.03991533f, -0.01775248f, 0.08343816f, 
    0.04756441f, 0.10149024f, 0.06995804f, 0.16309710f, 0.28603336f, 0.05192943f, 0.10098679f, -0.03348197f, 
    0.03094976f, 0.05912804f, -0.01132491f, 0.06730591f, -0.00658900f, -0.05470069f, 0.00671592f, -0.00349762f, 
    -0.11219113f, 0.07356559f, -0.16820920f, 0.05139473f, 0.08338424f, 0.10775672f, 0.10686236f, 0.08989593f, 
    0.01676981f, 0.05778962f, 0.02142024f, 0.28662741f, -0.03236100f, 0.17139414f, 0.04789867f, 0.00752520f, 
    0.12489015f, -0.02660195f, -0.03103359f, -0.02299337f, 0.01243079f, -0.02118332f, 0.09821130f, 0.12816691f, 
    0.03096835f, 0.10871124f, 0.21149904f, -0.02159865f, 0.05765073f, 0.12103262f, -0.04693067f, 0.08667634f, 
    0.03739397f, 0.01523487f, 0.00849163f, 0.01251832f, -0.11119200f, 0.18630421f, 0.01781798f, -0.07882643f, 
    -0.00572599f, 0.10591089f, 0.03648117f, -0.02119514f, -0.03153352f, 0.12573172f, 0.01709106f, 0.13392515f, 
    0.19007757f, -0.02622085f, -0.03287257f, 0.08217025f, 0.05344832f, 0.04195529f, 0.03354661f, 0.11807499f, 
    -0.00797171f, 0.16699998f, 0.01654771f, 0.02374259f, 0.30990928f, 0.08203686f, -0.00110616f, 0.24184617f, 
    0.07146309f, 0.08344114f, 0.03500220f, 0.09614530f, 0.08924790f, 0.00245521f, 0.04206762f, -0.00868804f, 
    -0.00468861f, 0.13763517f, -0.10284711f, -0.04292244f, 0.04587786f, 0.04701621f, 0.03410101f, -0.03667080f, 
    0.04405791f, -0.03395495f, 0.08435918f, -0.02259988f, 0.07520314f, -0.18379410f, 0.13346511f, -0.20784350f, 
    -0.01330624f, 0.04793236f, 0.02040376f, 0.03880626f, 0.04518887f, 0.10202627f, -0.02608362f, 0.05947094f, 
    0.15326357f, -0.15902242f, 0.07405005f, -0.11977116f, 0.02123624f, -0.02416658f, 0.15130600f, 0.11510905f, 
    -0.00969677f, 0.15305582f, -0.00759992f, 0.06169255f, 0.07590277f, -0.02260035f, 0.08587734f, 0.02472376f, 
    0.00264601f, 0.03533369f, -0.01630822f, -0.10747813f, 0.04453536f, 0.02120833f, 0.06414397f, 0.09425925f, 
    0.00286881f, 0.21977916f, 0.16144101f, -0.02613639f, 0.01261414f, -0.00807844f, 0.08349481f, -0.05244716f, 
    -0.03080873f, -0.07287671f, 0.02416032f, 0.06678837f, -0.03201535f, 0.23019132f, -0.10270907f, -0.19747911f, 
    0.03740392f, -0.04957464f, -0.03401689f, 0.02724857f, 0.04002765f, 0.01281132f, 0.02523860f, -0.04840872f, 
    0.00365330f, 0.07224500f, 0.06570129f, 0.08144304f, 0.05198396f, 0.11296788f, -0.01320086f, 0.04722178f, 
    0.00870245f, 0.03279285f, -0.05509080f, 0.16219504f, 0.00241445f, 0.17968844f, 0.00459363f, 0.11055718f, 
    0.02109477f, 0.09089907f, -0.07613412f, 0.00108209f, -0.03915731f, 0.13102604f, 0.06485787f, 0.07208377f, 
    0.30370376f, -0.05372551f, -0.04854419f, 0.04575233f, -0.02596207f, 0.05489795f, -0.00136608f, 0.09414756f, 
    0.05979260f, 0.02930922f, 0.07483376f, 0.04951652f, 0.30311611f, 0.10718436f, 0.02961628f, 0.17701544f, 
    0.02682376f, 0.02480603f, 0.07707529f, 0.06122617f, 0.04184986f, 0.05098796f, 0.09532133f, 0.10710887f, 
    0.16010348f, -0.11852834f, 0.04140351f, 0.04145419f, 0.05163136f, 0.08600557f, 0.04535109f, -0.05864537f, 
    0.07851140f, 0.13438834f, 0.11813916f, 0.21227869f, -0.03327411f, -0.16071381f, 0.00140601f, 0.09091455f, 
    0.02427176f, -0.08762284f, 0.08850760f, -0.02750934f, 0.01098484f, 0.08316674f, -0.02044529f, 0.09763423f, 
    0.09458488f, -0.04761194f, -0.00400138f, -0.00631549f, 0.06433816f, 0.08981551f, 0.00404657f, -0.02828252f, 
    0.09007070f, 0.03303557f, -0.00725329f, 0.01008044f, 0.36253455f, 0.04208650f, -0.04082618f, 0.27479684f, 
    0.03967003f, 0.13326658f, 0.12812744f, 0.02575876f, 0.10078099f, -0.10768465f, 0.11425612f, -0.07264821f, 
    0.04692449f, 0.31549656f, 0.10226460f, -0.11565995f, 0.06945726f, 0.05523509f, 0.03561527f, 0.02037276f, 
    0.06989039f, -0.02124740f, -0.02184750f, -0.11139020f, 0.32884717f, 0.05997531f, -0.09311040f, 0.04634445f, 
    -0.00404331f, 0.08970983f, 0.11054529f, -0.01468434f, 0.05572481f, 0.01438988f, 0.03400710f, -0.02969499f, 
    0.03048476f, 0.02549656f, 0.00026492f, 0.06888551f, 0.07845092f, -0.08435700f, 0.08705909f, 0.15406691f, 
    0.16121608f, 0.13132629f, 0.06235588f, 0.06368916f, 0.23159678f, -0.18894194f, 0.04278459f, 0.07587008f, 
    -0.03940417f, 0.11364391f, 0.02639403f, -0.14415427f, -0.01410124f, -0.00109076f, 0.03891333f, 0.16341485f, 
    -0.09388444f, 0.07075000f, 0.13457090f, 0.05089453f, 0.04331483f, 0.01160038f, 0.01210668f, 0.14823741f, 
    0.04480970f, 0.03688568f, -0.05293357f, 0.05831482f, 0.08744887f, 0.15291411f, 0.05911580f, 0.16113421f, 
    -0.01228893f, -0.00445720f, -0.06263062f, 0.08631542f, 0.07416476f, 0.00989244f, 0.07988623f, 0.15387043f, 
    0.26032639f, 0.21411438f, 0.02624767f, -0.05730993f, 0.04135708f, 0.02473925f, 0.04576239f, -0.06979761f, 
    0.01839879f, 0.08821631f, 0.03455136f, 0.16274337f, 0.19862884f, -0.22955728f, -0.02795105f, 0.00097808f, 
    0.03004478f, 0.24500845f, 0.12876137f, 0.04324118f, 0.02676684f, -0.06056216f, 0.02991192f, 0.03049408f, 
    0.05094650f, 0.08256499f, 0.18884313f, -0.04207596f, -0.00761269f, 0.01708090f, 0.12762512f, 0.01165092f, 
    -0.04754473f, 0.20710509f, 0.11361115f, 0.06018933f, -0.12104832f, 0.21616313f, 0.15890241f, -0.15381832f, 
    -0.05011220f, 0.01529964f, 0.07878902f, 0.09551880f, 0.00677873f, 0.10369059f, -0.08574656f, -0.02804742f, 
    -0.09260950f, -0.01230292f, -0.00407710f, -0.06703207f, 0.00914093f, 0.00514100f, 0.02066909f, -0.09339351f, 
    0.03099532f, 0.01842197f, 0.02938774f, 0.15019113f, 0.19418967f, 0.05264094f, -0.10076238f, 0.06142745f, 
    0.10896333f, -0.05091127f, 0.12207676f, 0.05955652f, 0.00040092f, -0.00410745f, -0.07235371f, 0.11028507f, 
    0.17893371f, -0.05873116f, -0.06301499f, 0.10319711f, 0.04967159f, 0.01522419f, 0.08086494f, 0.16315250f, 
    0.00191928f, 0.03657937f, -0.06097421f, 0.11404300f, -0.03106282f, 0.12073428f, 0.14154612f, 0.13178320f, 
    0.01905168f, 0.17921127f, -0.01395199f, 0.11581063f, -0.00584433f, 0.08784388f, 0.23858225f, -0.01604194f, 
    0.02290754f, 0.02098873f, -0.03595803f, 0.03298837f, 0.02021763f, 0.00441816f, -0.01374403f, -0.02817116f, 
    -0.01617890f, 0.01885668f, -0.00070581f, -0.01762231f, 0.02743546f, 0.03039533f, 0.02248105f, 0.00138100f, 
    0.01102476f, -0.01228307f, -0.00454521f, 0.03116760f, 0.03512715f, -0.00225533f, -0.00129126f, 0.02032331f, 
    0.00542200f, -0.02448283f, -0.02962703f, 0.00481221f, -0.02208481f, -0.01084997f, 0.00885805f, 0.00264020f, 
    -0.02483890f, 0.02133778f, -0.00321629f, -0.02999985f, -0.04054468f, 0.00062501f, -0.00797551f, -0.03513039f, 
    0.03147254f, -0.02118612f, 0.02188691f, -0.02315573f, 0.01130058f, 0.01495984f, -0.01986768f, -0.02392345f, 
    -0.01031417f, -0.03911868f, -0.03477035f, 0.02336315f, 0.00384933f, -0.03395954f, -0.03841852f, -0.00247965f, 
    -0.02406712f, 0.03159584f, -0.02639318f, 0.02312135f, 0.03823762f, -0.04415695f, 0.00344253f, 0.00255369f, 
    0.03282589f, -0.00600427f, -0.02630348f, -0.01400967f, -0.03645232f, -0.01362330f, 0.01909452f, 0.02605483f, 
    0.02032323f, -0.01568963f, 0.00263598f, -0.03706658f, -0.03049313f, -0.00339503f, 0.02186715f, 0.02224417f, 
    -0.00822989f, 0.02460576f, -0.02800500f, -0.01752323f, 0.02080948f, 0.02137540f, 0.01966124f, -0.04032988f, 
    -0.01704319f, 0.02050605f, 0.02544512f, -0.00924359f, -0.03303358f, 0.01107881f, -0.05011631f, -0.01302438f, 
    -0.02722772f, 0.01370862f, 0.00137881f, 0.01456169f, 0.01693948f, 0.01298670f, 0.03127786f, 0.00301188f, 
    0.02758616f, -0.00010859f, -0.02627269f, -0.00133530f, -0.00012300f, -0.02153340f, -0.04173151f, -0.01432306f, 
    0.00234015f, 0.03073874f, 0.02357744f, 0.02791450f, 0.00907451f, 0.00173773f, -0.03680383f, -0.01484459f, 
    -0.01886550f, -0.00041980f, -0.02644601f, -0.00196780f, -0.02317424f, 0.02844058f, -0.00242255f, -0.02598140f, 
    0.02004624f, -0.01133347f, 0.02618236f, 0.02466336f, 0.00340742f, 0.01692671f, -0.00243868f, -0.02767136f, 
    -0.00149065f, -0.02980847f, 0.02571650f, -0.01512902f, 0.00634831f, -0.02372524f, -0.04220222f, 0.01095678f, 
    -0.02473779f, -0.01020054f, 0.00607408f, 0.01406494f, 0.01433999f, -0.03646140f, -0.02944255f, -0.02180167f, 
    0.00175410f, -0.03562890f, -0.02236312f, 0.00827355f, 0.03767863f, -0.00143380f, 0.00137584f, -0.02064463f, 
    -0.02901270f, 0.01246415f, 0.01071343f, 0.00072627f, 0.01249447f, -0.03424415f, -0.02166739f, -0.03163964f, 
    0.01416541f, 0.03252693f, 0.00169904f, 0.00957490f, -0.02651069f, 0.02603702f, 0.00139662f, 0.01281214f, 
    -0.02800472f, 0.00307610f, -0.01922918f, -0.01944709f, 0.00960086f, 0.03080583f, -0.00884719f, -0.02549532f, 
    0.00921201f, 0.03054549f, -0.00258294f, 0.00400266f, -0.03912106f, -0.00403599f, 0.00887790f, -0.03747608f, 
    0.02742075f, 0.01557028f, 0.00142768f, -0.01919669f, 0.00591969f, 0.00520353f, -0.01594530f, 0.02067819f, 
    0.00921686f, -0.00860950f, 0.02263580f, -0.01956272f, 0.01018694f, -0.00947820f, -0.02893483f, -0.03566806f, 
    0.01330888f, 0.01129967f, -0.04054548f, 0.00919235f, 0.00322503f, 0.02744375f, 0.02749127f, 0.02997908f, 
    -0.01886527f, 0.00719624f, -0.03019079f, 0.01418749f, -0.00100875f, 0.02258766f, 0.02337226f, 0.03446662f, 
    -0.02627809f, -0.02231605f, 0.03025483f, -0.00750364f, -0.02422536f, -0.04397260f, -0.03474253f, -0.00519100f, 
    0.00058262f, -0.03645667f, 0.01821345f, 0.01777175f, 0.02098930f, -0.02637617f, -0.01198594f, -0.02487695f, 
    0.00962487f, -0.01937873f, -0.00300354f, -0.01489282f, -0.01506744f, 0.02247190f, -0.00463933f, -0.00841784f, 
    0.03621657f, -0.02752280f, -0.00528161f, 0.02105160f, -0.02320870f, -0.02009336f, 0.02125376f, 0.01591784f, 
    0.01828546f, -0.02459616f, 0.01610725f, 0.01785236f, -0.01431880f, -0.00068078f, 0.00431053f, -0.02606229f, 
    0.01071460f, 0.02406580f, -0.03896915f, 0.01134400f, -0.00019229f, -0.00718407f, -0.02017966f, -0.00902397f, 
    0.01289842f, -0.00471946f, 0.00103039f, 0.00935121f, 0.01886310f, -0.00511605f, -0.01025479f, -0.03727899f, 
    0.02722055f, -0.00424764f, -0.00003457f, -0.00570591f, 0.00913725f, 0.02098105f, 0.02866560f, -0.02986845f, 
    0.02949531f, 0.03651219f, -0.01856797f, -0.03212909f, -0.00842788f, 0.00485777f, 0.01562599f, 0.00399586f, 
    0.00216739f, 0.00974339f, 0.02819207f, -0.02091539f, -0.03869322f, 0.01629851f, -0.00886259f, 0.02155597f, 
    -0.03713430f, -0.03382010f, -0.01265600f, 0.01638929f, 0.00256680f, 0.02334366f, -0.01610548f, -0.00673892f, 
    -0.00054710f, -0.02115320f, 0.00705139f, 0.02327341f, 0.01184683f, 0.01542266f, 0.01766040f, 0.01173138f, 
    -0.03464826f, -0.04119634f, -0.01840318f, 0.01448420f, -0.03438978f, -0.03618117f, -0.00384273f, -0.00993570f, 
    0.01518342f, 0.00594150f, 0.01389862f, 0.02235861f, -0.03091816f, -0.03670223f, 0.00246959f, 0.01676108f, 
    -0.00359800f, 0.00293545f, 0.00466242f, -0.03156691f, -0.00983303f, -0.02538115f, 0.03286314f, 0.01033224f, 
    -0.01019857f, -0.03255980f, 0.02534903f, 0.01595268f, -0.00195805f, -0.03561967f, 0.01193582f, 0.00254305f, 
    -0.00729331f, -0.00905109f, 0.01282207f, -0.02404716f, 0.02878879f, 0.01463287f, 0.00082892f, 0.00281196f, 
    -0.00630634f, 0.02369942f, 0.01971086f, -0.01974818f, 0.03138289f, -0.01498976f, 0.00273533f, -0.02487535f, 
    -0.03484662f, 0.01376074f, -0.00461307f, 0.01829305f, 0.02185408f, 0.00465451f, -0.00562437f, 0.02645551f, 
    -0.03843115f, 0.00738252f, -0.02901219f, 0.01186557f, 0.02984620f, -0.00915850f, 0.02866619f, -0.00349247f, 
    -0.03049938f, 0.01378853f, -0.01269828f, -0.02764638f, -0.01006104f, 0.01778543f, 0.01414331f, -0.03233233f, 
    -0.03233717f, 0.02323567f, -0.00883868f, -0.01036830f, -0.00450187f, -0.02501555f, -0.01752066f, 0.01456489f, 
    0.03389306f, -0.02296301f, -0.04422561f, -0.03789388f, -0.02576734f, -0.02538894f, 0.00119140f, -0.01473558f, 
    0.02508982f, -0.02264657f, -0.01694948f, 0.00403758f, -0.02019574f, 0.03027583f, 0.00577134f, 0.03047526f, 
    0.01634952f, -0.00173145f, -0.02211061f, -0.02095425f, -0.04403008f, -0.00335994f, -0.03557179f, 0.02968095f, 
    -0.02691115f, -0.01504785f, 0.01351324f, 0.01837157f, -0.02918842f, 0.00039764f, -0.03390737f, -0.02385406f, 
    -0.00236707f, -0.02124698f, 0.01288803f, 0.01271473f, 0.01269471f, 0.00067449f, 0.01745468f, 0.02801731f, 
    -0.03784314f, -0.03242006f, 0.02080613f, -0.00173466f, -0.00059488f, -0.01850726f, -0.01827983f, -0.01524246f, 
    -0.02524455f, 0.01532288f, -0.02038216f, 0.02235680f, -0.01613093f, 0.01792101f, -0.03219010f, 0.00238191f, 
    0.02685178f, -0.01928251f, 0.02022335f, -0.00704729f, -0.01060510f, 0.01844310f, 0.02951442f, -0.01686434f, 
    -0.03482424f, 0.01981429f, 0.00321407f, -0.02371188f, 0.02797741f, -0.01753944f, -0.02970961f, 0.00916343f, 
    -0.00241717f, -0.02089840f, -0.00240238f, -0.02887849f, -0.03034760f, -0.00134012f, -0.02487478f, 0.01584199f, 
    -0.01826644f, -0.02801984f, 0.00343784f, -0.00821358f, 0.01509486f, 0.01280529f, 0.02648069f, 0.00366093f, 
    0.01932090f, -0.03656717f, 0.00966061f, 0.00757357f, -0.03158657f, 0.01152383f, -0.02002263f, -0.01199822f, 
    -0.00986197f, -0.03571038f, 0.00350738f, -0.01577101f, 0.02525056f, -0.02306315f, 0.03227362f, 0.03181659f, 
    -0.00191090f, -0.00320199f, -0.00770189f, -0.02537955f, -0.00260370f, -0.00479884f, -0.02094675f, -0.00801920f, 
    0.01049702f, -0.03151733f, 0.02700428f, -0.01759975f, -0.01839088f, 0.01597774f, 0.03259695f, 0.03724695f, 
    -0.00127345f, -0.01117317f, -0.03322502f, -0.01840565f, 0.00243532f, 0.00956139f, 0.03448352f, 0.02417519f, 
    -0.02315055f, -0.02715501f, -0.00807437f, -0.02209168f, 0.00182474f, 0.01161687f, -0.03516573f, 0.00786757f, 
    -0.00152971f, -0.03759144f, -0.00805979f, 0.03313905f, -0.00829577f, -0.00004133f, -0.01625397f, -0.02076548f, 
    -0.02737763f, 0.01172160f, 0.02824254f, 0.02694955f, 0.00649416f, 0.02172305f, -0.00032303f, 0.01438565f, 
    -0.01777286f, 0.02876354f, -0.02418947f, -0.00278859f, 0.02045658f, -0.01026463f, -0.01051232f, 0.00668229f, 
    -0.01703976f, 0.01127488f, 0.00142473f, 0.03671252f, -0.00660963f, -0.02158495f, -0.02548200f, -0.02563596f, 
    -0.01470580f, 0.00692795f, 0.02714809f, 0.03000629f, 0.00667002f, 0.03992600f, -0.02368717f, -0.02224081f, 
    -0.00288339f, 0.00917216f, 0.01748821f, 0.00641439f, 0.01105278f, 0.02160987f, 0.00798865f, -0.01225250f, 
    0.02486027f, 0.00649376f, -0.03248458f, 0.02497928f, 0.00808296f, -0.00845006f, 0.00263239f, 0.00211677f, 
    -0.00338215f, 0.01992730f, -0.02628084f, 0.01278162f, -0.00027520f, -0.02037087f, -0.00272984f, -0.02864156f, 
    0.03189111f, 0.01336281f, 0.02204841f, -0.02312806f, -0.02213778f, -0.01742208f, -0.01416312f, -0.03381309f, 
    0.00525655f, 0.00175298f, -0.03036135f, -0.02602515f, -0.03098165f, 0.01273694f, -0.02697304f, -0.01705281f, 
    -0.02167453f, 0.02238564f, -0.04038547f, -0.00325944f, -0.04002343f, -0.01095143f, -0.01490929f, -0.00005998f, 
    0.00332340f, 0.02403331f, 0.01503282f, -0.00198138f, -0.02483811f, -0.00565496f, 0.00439891f, 0.00878988f, 
    0.02049135f, -0.01008664f, 0.02824748f, -0.00275794f, 0.02351473f, 0.02738440f, 0.00317519f, -0.02733403f, 
    0.03676723f, 0.01357333f, 0.01954685f, 0.02142994f, 0.00378261f, 0.02632053f, 0.01772409f, 0.01019009f, 
    -0.02167832f, -0.00336854f, 0.02160613f, 0.00289395f, 0.00821956f, -0.02672680f, 0.01536742f, -0.03486498f, 
    -0.02335457f, 0.01968150f, 0.02386872f, -0.02693881f, 0.02555862f, 0.02898727f, 0.00564752f, 0.04083151f, 
    0.00976986f, -0.00736974f, 0.00806774f, -0.02376290f, 0.00584589f, -0.02126682f, -0.03497735f, 0.00249624f, 
    -0.01857080f, 0.00309414f, -0.01593767f, -0.03772141f, -0.02158391f, -0.00989495f, -0.03502434f, -0.01599232f, 
    0.02408844f, 0.01044240f, 0.02656003f, 0.03767645f, -0.01062207f, 0.00733446f, 0.02013716f, -0.00403342f, 
    0.03280577f, 0.00761219f, -0.01608666f, -0.00851671f, -0.03441930f, 0.01513844f, -0.01966917f, 0.02204264f, 
    0.01077638f, 0.00235844f, 0.00841983f, -0.02749038f, -0.03230265f, -0.02193626f, -0.01681903f, 0.01217779f, 
    -0.01817513f, -0.00656572f, -0.03274004f, 0.00498835f, 0.02449799f, 0.00860023f, -0.00685908f, -0.02843907f, 
    0.01413260f, -0.01953715f, -0.00418603f, -0.00698295f, -0.03599664f, -0.03409488f, 0.01175016f, 0.02471769f, 
    -0.01075261f, 0.02453060f, -0.01831913f, -0.03131282f, 0.01514780f, -0.02590174f, 0.00677972f, -0.01131988f, 
    -0.02834645f, 0.00799125f, -0.01908811f, 0.01493821f, 0.00960307f, 0.02964628f, -0.01533258f, 0.02259917f, 
    -0.01546558f, 0.02967449f, -0.00091270f, 0.02261886f, -0.03055838f, -0.00316831f, 0.00545261f, 0.02617056f, 
    -0.00400594f, -0.01546231f, -0.01244590f, 0.01794417f, -0.02864359f, 0.01980132f, -0.03671121f, 0.02260007f, 
    0.00418685f, -0.01425868f, -0.00987820f, 0.01224683f, -0.03489909f, 0.00036440f, -0.00461640f, 0.01293505f, 
    0.02193906f, 0.00829720f, 0.00689206f, 0.00538572f, -0.00335624f, 0.02953126f, 0.02252129f, -0.03179255f, 
    -0.00207541f, 0.00145352f, 0.01708686f, -0.00981317f, -0.01582926f, 0.00770363f, -0.01233281f, -0.01363228f, 
    -0.01356663f, 0.00511930f, 0.01211688f, 0.00199642f, -0.00432847f, -0.02355906f, 0.00088383f, -0.02182403f, 
    0.02518284f, -0.01770934f, -0.00757329f, -0.01278736f, 0.02793787f, 0.00722128f, 0.00922103f, -0.00812437f, 
    -0.00025135f, -0.02827082f, 0.00232826f, 0.02579238f, 0.01547583f, 0.03501469f, -0.02437140f, -0.00754925f, 
    0.02432280f, 0.01768739f, 0.01185489f, -0.02223439f, 0.00820245f, 0.00141359f, -0.02515566f, -0.00043804f, 
    -0.00519540f, -0.00739357f, 0.00997416f, 0.02859414f, 0.00907157f, 0.00872899f, 0.02522373f, 0.02447604f, 
    -0.03849753f, -0.03577863f, 0.01788517f, -0.03829554f, -0.00955595f, -0.01570779f, -0.02984637f, -0.04054203f, 
    -0.03535893f, 0.01425806f, 0.00092757f, -0.01860080f, -0.01360533f, -0.03186113f, 0.02647732f, -0.02064176f, 
    -0.02760552f, 0.02081798f, 0.02428398f, 0.02770294f, -0.01940283f, -0.04050337f, -0.00696331f, -0.01113097f, 
    -0.01128063f, 0.00857816f, 0.02412949f, 0.02099448f, 0.00485933f, -0.00728054f, 0.00272826f, 0.01168122f, 
    0.02543169f, -0.04069691f, -0.03196704f, 0.01623455f, 0.02945364f, 0.00704193f, 0.00612608f, 0.02492192f, 
    0.01363208f, 0.01831118f, -0.04076635f, -0.02220763f, -0.01158778f, -0.02910331f, 0.01944163f, 0.02332835f, 
    0.01781643f, -0.00609423f, -0.01168432f, 0.00680901f, -0.00246420f, 0.00646384f, 0.00172210f, 0.01580498f, 
    -0.03223420f, -0.03693153f, 0.02946729f, -0.03217665f, -0.03591448f, 0.01704282f, -0.01488322f, 0.00044729f, 
    0.02495917f, -0.02487430f, -0.00155323f, -0.02411411f, -0.00466882f, -0.02558428f, -0.03703108f, 0.00888162f, 
    -0.04127105f, -0.02241951f, -0.01714657f, -0.03240552f, -0.02808591f, 0.00683643f, -0.02807806f, -0.01376599f, 
    -0.00957442f, -0.03369109f, 0.00519747f, -0.00988881f, -0.03436621f, -0.01222014f, 0.01390467f, 0.01847040f, 
    -0.01557470f, 0.00520189f, 0.02249632f, -0.00542158f, 0.00082314f, -0.00483190f, 0.00282484f, -0.01661471f, 
    -0.03857714f, -0.00772050f, 0.01031302f, 0.01748529f, -0.02892425f, -0.02082514f, 0.01547844f, -0.03874738f, 
    -0.01395893f, 0.00157222f, 0.02124293f, 0.01057042f, 0.00479810f, 0.00569300f, -0.03825050f, -0.01060682f, 
    -0.04166942f, 0.00205665f, 0.02088349f, 0.00758190f, -0.00928452f, -0.00985859f, -0.03813388f, 0.01594144f, 
    -0.01402561f, 0.01643459f, -0.00484008f, -0.03460896f, -0.00911420f, -0.02792352f, 0.03651458f, 0.01374289f, 
    -0.01594331f, -0.03324369f, -0.02202991f, 0.01550971f, 0.00718117f, -0.00040981f, 0.01342364f, 0.00522687f, 
    0.02959308f, -0.04032464f, 0.00282820f, 0.02942990f, 0.02936280f, -0.02345782f, -0.02954523f, -0.02433494f, 
    -0.02791787f, -0.02767004f, -0.03639805f, 0.00227971f, -0.01553817f, -0.02004819f, 0.01353198f, 0.01878643f, 
    0.01200454f, 0.02021359f, -0.01388396f, 0.02643886f, -0.01043116f, 0.01929718f, 0.00379861f, 0.00907366f, 
    -0.00806907f, -0.01463605f, 0.02578068f, -0.02617142f, 0.01376314f, -0.02246713f, -0.03951743f, -0.01676863f, 
    -0.01949359f, -0.04164383f, 0.02905745f, -0.00103151f, -0.03859805f, 0.01353108f, -0.00500559f, 0.01863766f, 
    -0.02398214f, -0.01244381f, 0.00331925f, 0.01091642f, -0.01406227f, -0.01743721f, 0.01757751f, 0.01773526f, 
    -0.00800468f, -0.00002466f, -0.00478162f, 0.01597817f, 0.00146963f, -0.02095105f, 0.03610208f, -0.03173605f, 
    -0.02552346f, -0.02722786f, -0.01615146f, -0.00214676f, -0.00157446f, -0.01743985f, 0.02343283f, -0.01477969f, 
    0.00766556f, -0.01521473f, 0.00046370f, -0.01713722f, -0.03398966f, 0.03750440f, -0.01836493f, 0.02618325f, 
    -0.02075889f, -0.04012674f, -0.03273604f, -0.03869121f, 0.01443106f, 0.02278383f, 0.02672376f, -0.03916149f, 
    0.02080157f, -0.01239308f, -0.03949540f, -0.00906104f, 0.01594468f, -0.04028916f, 0.00434716f, -0.03368789f, 
    -0.00247259f, 0.01852008f, 0.02307307f, 0.00936307f, 0.00092907f, -0.03526767f, 0.00801961f, 0.00348955f, 
    0.01517630f, 0.02156144f, 0.02998473f, -0.02056508f, 0.02777564f, -0.03188457f, 0.00325694f, -0.01992505f, 
    -0.01610414f, 0.02501682f, -0.00327465f, -0.01467253f, -0.00176314f, -0.02270282f, -0.00809084f, 0.03815745f, 
    0.00632975f, 0.01424016f, 0.02012674f, -0.02634645f, 0.01915524f, -0.02794687f, -0.03841839f, -0.01964780f, 
    -0.01297175f, -0.00833618f, -0.02856970f, 0.01115206f, -0.03249322f, 0.01031731f, 0.02474600f, -0.01850990f, 
    0.00694446f, 0.03248126f, 0.00683332f, -0.00944967f, -0.03409464f, 0.02628502f, 0.00203066f, 0.00735658f, 
    -0.02900604f, 0.02373419f, -0.02312098f, 0.00644785f, 0.02863855f, -0.00762772f, -0.02320414f, -0.03684400f, 
    -0.00082098f, -0.04180425f, 0.02780825f, -0.00504884f, -0.03815947f, -0.01839875f, -0.02048261f, 0.02995453f, 
    -0.00117997f, 0.00405370f, -0.03796012f, -0.01984640f, 0.00961894f, 0.02238942f, -0.03807128f, 0.00340104f, 
    0.02658038f, -0.03861512f, -0.00318087f, -0.03639425f, -0.03438623f, 0.01931890f, -0.01968836f, 0.01263426f, 
    -0.01367772f, -0.04086325f, 0.00615992f, 0.00180821f, 0.02750824f, 0.00578006f, -0.01484532f, 0.01113263f, 
    -0.00309695f, -0.02780319f, 0.01279456f, 0.02693249f, -0.02301503f, -0.03738427f, 0.01697300f, -0.02808770f, 
    0.02542628f, -0.00130782f, 0.02181651f, 0.00204779f, -0.04073224f, 0.01751448f, 0.00147892f, 0.01112338f, 
    -0.04176022f, -0.02724757f, 0.01666492f, 0.00579114f, -0.02606898f, 0.00674946f, 0.00459304f, -0.03841504f, 
    -0.02651819f, 0.00726227f, 0.00680220f, -0.00083382f, 0.02638673f, 0.00107397f, -0.00175265f, -0.00836336f, 
    -0.01076977f, -0.03543269f, -0.00590122f, 0.01872989f, -0.00293208f, -0.04004697f, -0.01447107f, -0.01218745f, 
    -0.00481512f, -0.01964869f, -0.01195625f, 0.01429775f, 0.01113561f, -0.03801559f, -0.00291548f, -0.01114110f, 
    -0.04074895f, -0.03641341f, 0.02213470f, 0.00965945f, -0.03129558f, 0.02149934f, 0.01146965f, 0.02620598f, 
    0.02405019f, -0.03844588f, 0.00504023f, -0.00001926f, 0.01195644f, 0.00588865f, -0.00633521f, 0.01370060f, 
    -0.02012326f, 0.01071549f, -0.00374208f, -0.00614957f, -0.00712866f, 0.02231213f, -0.02953495f, -0.01885637f, 
    -0.01568197f, -0.00416202f, 0.01993876f, -0.04095618f, 0.00549573f, -0.04039208f, -0.00401338f, 0.01943997f, 
    0.02080314f, -0.03545252f, 0.00851074f, -0.00609944f, -0.00855344f, 0.02140552f, 0.02272403f, 0.02964889f, 
    -0.01568236f, 0.02022480f, 0.02436930f, 0.02671955f, 0.01175716f, 0.01300134f, 0.01258447f, 0.01765376f, 
    -0.02781914f, 0.00898363f, -0.03755146f, -0.01915026f, -0.03198712f, 0.00458769f, -0.03079218f, 0.02945849f, 
    -0.01190939f, 0.02201198f, 0.02457377f, -0.03891121f, -0.03543982f, -0.03565206f, -0.02025277f, 0.01530019f, 
    0.00748329f, 0.01794930f, -0.00737259f, -0.00179582f, -0.01514175f, -0.00621689f, 0.01940490f, 0.00509838f, 
    -0.02183416f, -0.01941814f, -0.03761500f, -0.00840742f, -0.00650908f, -0.03082398f, 0.00666345f, -0.03934344f, 
    -0.00724182f, 0.00201026f, -0.01088470f, -0.04094238f, 0.00047228f, 0.04080924f, -0.03129682f, -0.00080490f, 
    0.00620131f, 0.01660728f, 0.01804212f, -0.04009210f, 0.00997492f, -0.04179962f, -0.01953365f, -0.02156855f, 
    0.01861792f, 0.02623605f, -0.03367961f, -0.02563364f, 0.02485503f, -0.01239848f, 0.01302054f, -0.00573384f, 
    -0.01053596f, 0.02393239f, 0.01549201f, -0.00233809f, -0.03507119f, 0.00478704f, -0.01324960f, 0.02127273f, 
    -0.03461161f, -0.02567128f, -0.04009369f, -0.01727670f, -0.03664767f, -0.03813510f, 0.01345892f, -0.03935970f, 
    -0.02656530f, 0.02198373f, -0.03807963f, 0.01436347f, 0.01565671f, 0.02331879f, 0.02736727f, 0.00169817f, 
    0.00368704f, 0.01235606f, -0.03111193f, -0.00427290f, 0.02210150f, -0.00311784f, -0.02475727f, 0.00714611f, 
    -0.03469829f, -0.01688866f, 0.00675491f, 0.02300941f, -0.01124762f, 0.03320412f, 0.00826859f, -0.03760272f, 
    -0.01687225f, -0.04042690f, 0.00209154f, -0.03384361f, -0.03426209f, 0.00351395f, 0.01965982f, -0.01784040f, 
    -0.03924226f, -0.00328646f, 0.02293550f, -0.04173317f, -0.00895112f, -0.01352968f, 0.00472106f, -0.00122672f, 
    -0.03014281f, 0.01581198f, -0.02806976f, -0.02319648f, 0.00086344f, -0.02928187f, 0.02395957f, -0.00894758f, 
    -0.03812058f, -0.01659357f, -0.01534375f, 0.00456141f, -0.03318500f, 0.00699276f, 0.02105277f, 0.01669620f, 
    -0.01411779f, -0.00327868f, 0.02553362f, -0.02116651f, -0.03709204f, -0.01762758f, -0.01388641f, -0.01325835f, 
    -0.00541992f, -0.03102996f, -0.00238558f, 0.01897958f, -0.02975859f, 0.02946661f, -0.03155481f, -0.01491347f, 
    -0.02797904f, 0.01702756f, -0.00221518f, 0.00956056f, 0.02181856f, 0.01176066f, -0.02639015f, 0.02968381f, 
    -0.02256188f, -0.01345775f, 0.00977955f, -0.03039366f, -0.00672936f, 0.02480901f, 0.02990574f, -0.03681320f, 
    0.00244044f, -0.03253891f, -0.00997587f, -0.02983140f, 0.01498328f, 0.01754862f, -0.01739923f, -0.00099417f, 
    0.00931794f, -0.01239467f, -0.00172745f, 0.02347110f, -0.01715884f, 0.02241951f, -0.00846377f, 0.01583291f, 
    -0.00216824f, -0.01123019f, 0.00706401f, -0.00499201f, -0.04028681f, -0.03103552f, -0.04155580f, -0.03738738f, 
    -0.03120275f, -0.00581401f, 0.02169006f, 0.02193273f, -0.01167026f, -0.02508305f, 0.02732927f, 0.02072351f, 
    -0.01012739f, 0.00509008f, -0.01400237f, -0.00935579f, -0.01982201f, -0.00110170f, -0.01930665f, 0.00315380f, 
    -0.02333179f, 0.01199268f, 0.00371664f, 0.02223922f, -0.00337713f, 0.02924928f, -0.00824231f, 0.01550496f, 
    -0.03474005f, 0.00026154f, -0.00133266f, 0.00126230f, -0.02981215f, -0.00879334f, -0.01639857f, 0.00376164f, 
    -0.02185139f, 0.02198674f, -0.02590427f, -0.00295420f, -0.01669130f, 0.02781864f, 0.00538514f, -0.03499168f, 
    0.00691225f, 0.00377691f, 0.01425061f, 0.01565741f, 0.00312049f, 0.02185326f, 0.00112362f, -0.01414303f, 
    0.01677006f, -0.03437997f, -0.01396517f, 0.02784767f, -0.02195079f, 0.01407303f, 0.01817479f, -0.03223575f, 
    -0.01800490f, -0.01143755f, -0.00644064f, -0.03270429f, -0.00342337f, -0.02327688f, 0.02259961f, 0.02261612f, 
    -0.03768595f, 0.01332672f, 0.01070145f, -0.03886571f, -0.03236165f, 0.01652974f, -0.02395448f, -0.01514679f, 
    -0.02729931f, 0.01653400f, 0.02592115f, 0.01573538f, 0.01365713f, -0.03182029f, 0.03450991f, -0.01413309f, 
    0.02332878f, 0.01082781f, 0.00888468f, 0.00169351f, 0.01929833f, -0.00890971f, -0.01721909f, -0.03088202f, 
    -0.00970065f, -0.02770691f, -0.02773163f, -0.00796378f, 0.02423390f, -0.00103989f, -0.03516677f, 0.01610301f, 
    -0.00884907f, 0.02473276f, -0.02484666f, 0.02811990f, -0.01892871f, -0.00567586f, -0.03490776f, 0.01405170f, 
    0.01120769f, -0.03524420f, 0.00903696f, -0.00001183f, 0.01194860f, -0.03748220f, -0.02589269f, -0.03690091f, 
    -0.01318513f, -0.00751690f, -0.00429504f, -0.03841242f, 0.02470749f, 0.00965575f, -0.01233139f, -0.04153262f, 
    -0.02305713f, -0.02329233f, -0.02673415f, -0.03124909f, 0.00573468f, -0.03312036f, 0.02173104f, -0.02620524f, 
    -0.17327233f, 0.10434335f, -0.10805481f, 0.11059551f, 0.08952182f, 0.02969391f, -0.03285675f, 0.07223339f, 
    -0.07858758f, 0.04762923f, -0.03382582f, 0.03104581f, -0.17689601f, 0.22339250f, 0.42888528f, -0.13519610f, 
    -0.01230521f, 0.04449449f, 0.04406510f, -0.02045763f, 0.04721696f, 0.02266137f, 0.04612652f, 0.01036348f, 
    -0.23967001f, -0.12475935f, 0.18999389f, -0.12928136f, 0.03227399f, -0.01874132f, 0.17197494f, 0.10179029f, 
    -0.01575228f, 0.04926023f, 0.07278273f, 0.00301586f, 0.26849812f, -0.22530709f, -0.09422250f, 0.28580147f, 
    0.01033003f, 0.04771893f, -0.01141314f, -0.02703617f, 0.00135514f, 0.01684878f, 0.12270755f, 0.03439666f, 
    0.00626134f, -0.23444933f, 0.19780776f, -0.07919102f, -0.03652357f, -0.07283950f, -0.01803442f, -0.09119192f, 
    0.20082211f, 0.10154679f, 0.02365594f, 0.01372431f, 0.01690402f, -0.26096025f, -0.03378078f, -0.21778619f, 
    -0.00807261f, 0.00288303f, 0.13800602f, -0.11303889f, 0.12537283f, 0.04970455f, 0.12032451f, 0.11269223f, 
    0.00989961f, 0.28260073f, -0.16938379f, -0.04486511f, -0.08700117f, 0.08571278f, 0.02727308f, 0.09320385f, 
    0.21381837f, 0.23301286f, 0.04449378f, 0.00587162f, -0.00803839f, 0.23996542f, 0.20500533f, 0.14685409f, 
    -0.00700190f, 0.02192630f, -0.02682291f, 0.02968568f, 0.07508581f, 0.09029902f, -0.01536296f, -0.02772504f, 
    0.03165451f, 0.15581726f, -0.08719645f, -0.03028655f, 0.11481317f, 0.04569143f, 0.07637325f, -0.06421097f, 
    0.08785167f, 0.17476335f, -0.02775957f, -0.02079266f, 0.02862913f, -0.31977773f, -0.02915891f, 0.55410337f, 
    -0.00865534f, 0.01203549f, -0.00221134f, 0.07498638f, 0.10547596f, 0.16972797f, 0.09708897f, -0.00921406f, 
    -0.11714765f, 0.04933126f, 0.24710159f, -0.07288357f, 0.09240764f, -0.07200839f, 0.14833590f, 0.14384322f, 
    0.01072325f, -0.07525746f, 0.08398392f, -0.08860727f, -0.05088689f, 0.12944169f, -0.01147834f, -0.02194212f, 
    -0.05514186f, 0.10591909f, -0.06490671f, 0.07162487f, 0.03890325f, 0.10268105f, 0.10545565f, 0.03399909f, 
    -0.24111594f, 0.21795131f, 0.20740849f, -0.07552089f, 0.05915488f, -0.18359096f, 0.01763220f, 0.21269813f, 
    0.07602710f, 0.05968964f, 0.02465303f, -0.03881687f, -0.01108373f, -0.05411595f, 0.16554467f, 0.02873056f, 
    -0.01580237f, 0.08229325f, 0.15317035f, 0.09284010f, 0.06203781f, -0.06178515f, 0.11176531f, 0.17442924f, 
    -0.09820656f, -0.06895223f, -0.14065161f, -0.14873166f, 0.00517982f, 0.00226189f, 0.01003686f, 0.24304776f, 
    0.00955743f, 0.05872648f, 0.07433342f, 0.07760488f, 0.08428894f, -0.03101889f, 0.13952395f, 0.20371774f, 
    -0.02918324f, 0.00288368f, 0.01924924f, 0.19472252f, -0.07780541f, 0.09500267f, 0.01377824f, 0.16584173f, 
    0.40673915f, -0.24200939f, -0.04845740f, 0.44599503f, -0.06118942f, -0.06021627f, 0.05274598f, -0.00808783f, 
    0.22366385f, 0.06909265f, -0.04067036f, -0.01521120f, 0.24950023f, -0.00527813f, 0.21616906f, 0.21759753f, 
    0.16655375f, -0.02248539f, 0.03105499f, 0.02870439f, 0.01566267f, 0.10571283f, 0.12509501f, 0.06642788f, 
    -0.29714388f, -0.03181038f, 0.18676174f, 0.19456141f, 0.05292793f, -0.08967029f, 0.06322456f, 0.00552445f, 
    0.08606228f, 0.22074863f, 0.13475762f, 0.12601373f, -0.00193537f, 0.29847243f, -0.02263581f, -0.03592433f, 
    0.16370080f, 0.04366234f, 0.01343071f, 0.06942829f, 0.05859850f, 0.05506830f, 0.00974607f, 0.02155682f, 
    0.17778948f, 0.16470432f, 0.35674596f, 0.06772078f, 0.03691619f, 0.07264709f, 0.07153680f, 0.03903892f, 
    0.02403723f, 0.05023400f, 0.03908061f, 0.02751886f, 0.04842459f, -0.36762971f, 0.03189983f, 0.11021730f, 
    -0.00950857f, 0.08782776f, -0.01641162f, -0.18233570f, 0.08143530f, 0.05081048f, 0.05163546f, 0.21897478f, 
    -0.12147634f, 0.09652974f, 0.10025292f, 0.11953376f, -0.00654679f, 0.23465221f, 0.01059254f, -0.11485264f, 
    0.17336649f, 0.15540066f, 0.11774985f, 0.11301159f, 0.33973551f, -0.22924823f, 0.06445046f, -0.02640847f, 
    0.03890266f, 0.05962258f, -0.04469839f, 0.00213805f, -0.11383410f, 0.04569892f, -0.03929351f, 0.07389984f, 
    -0.07988036f, 0.01711789f, 0.16983436f, 0.03219311f, -0.01279432f, 0.06905057f, 0.02841195f, 0.00327696f, 
    0.16317110f, 0.01298830f, 0.02293578f, -0.03732529f, 0.14645295f, 0.13560435f, 0.07633090f, -0.06732947f, 
    0.11408884f, 0.20753524f, -0.07701524f, -0.03547170f, 0.00163951f, 0.09115236f, 0.11581018f, 0.06815877f, 
    0.03029061f, 0.00861150f, 0.16812116f, 0.22000784f, -0.00088953f, 0.07147763f, -0.04238590f, 0.05044577f, 
    0.02543730f, 0.20077755f, 0.08969965f, 0.12837984f, 0.00560868f, -0.27894324f, 0.06140687f, 0.33496761f, 
    0.15908183f, 0.06677040f, -0.00795829f, -0.03093613f, 0.07941948f, 0.10741578f, -0.17286241f, 0.05607456f, 
    0.05288584f, 0.02101371f, 0.13740484f, -0.29434624f, 0.19957696f, 0.12606902f, 0.05513499f, 0.07639398f, 
    -0.01389586f, 0.03758344f, 0.05073139f, 0.00478985f, 0.01481687f, -0.13861209f, 0.10543084f, -0.10622353f, 
    -0.01091329f, -0.04944264f, 0.10433217f, 0.02587611f, 0.11214689f, 0.08374227f, 0.05623358f, 0.05176892f, 
    0.17978987f, 0.27388591f, -0.17554970f, 0.26988274f, -0.02708949f, 0.05206858f, 0.00564464f, -0.05216629f, 
    0.11279874f, 0.10678767f, 0.05521549f, -0.04341560f, 0.30113989f, -0.36274269f, -0.01996425f, 0.02924062f, 
    0.09807587f, 0.02876385f, 0.04109507f, -0.00527027f, 0.21671735f, 0.19632541f, 0.02176580f, 0.15578583f, 
    -0.01645729f, -0.11923140f, 0.05491967f, 0.17511919f, -0.06055010f, -0.05014953f, 0.06790265f, -0.03264746f, 
    0.04395255f, 0.00763379f, 0.07473301f, 0.00928921f, 0.02325344f, -0.03639438f, -0.06659099f, 0.19372641f, 
    0.12752068f, 0.03889663f, -0.02521099f, 0.02946380f, 0.15524663f, -0.01840722f, -0.01621478f, -0.03957477f, 
    -0.15621805f, -0.01683195f, 0.01535988f, 0.16993855f, 0.07356191f, 0.04423475f, -0.01888614f, 0.01670204f, 
    0.13260134f, -0.02185243f, 0.09570570f, 0.00000770f, -0.47612756f, 0.06593507f, -0.16956849f, -0.00976883f, 
    0.04236966f, -0.04337380f, -0.04934785f, -0.00419869f, -0.04597162f, 0.01621906f, 0.04656055f, 0.10298803f, 
    0.25232920f, 0.02971900f, -0.11119686f, 0.47799671f, 0.12197430f, -0.01237245f, -0.00263611f, 0.02593185f, 
    0.11942635f, 0.09667710f, 0.04470677f, 0.12697117f, -0.23171858f, 0.11328633f, -0.06201381f, 0.22097725f, 
    -0.01271614f, -0.03241040f, 0.01816604f, 0.17332156f, -0.02858522f, 0.07513036f, 0.05074047f, 0.04021197f, 
    0.24975047f, 0.13778722f, 0.20020893f, 0.14604528f, 0.02656974f, -0.02203947f, 0.01596383f, 0.05648774f, 
    0.03333793f, -0.07132909f, 0.02511624f, -0.13196814f, 0.00941321f, 0.14693384f, -0.08214864f, 0.29641014f, 
    0.07086934f, 0.01853288f, -0.03351387f, 0.23695804f, 0.10437368f, 0.05965097f, 0.00440980f, 0.12802356f, 
    0.19021992f, -0.26912457f, 0.08942001f, 0.14207375f, -0.10216378f, -0.05459570f, -0.02257397f, 0.02760102f, 
    0.16932698f, 0.10492327f, 0.17203565f, 0.07418017f, 0.30191246f, -0.10459630f, -0.01349701f, 0.55585068f, 
    0.11075839f, 0.02374512f, -0.01056011f, 0.10728959f, 0.16048048f, 0.01456180f, -0.00843087f, 0.04433172f, 
    0.07804924f, -0.00877004f, -0.07505985f, 0.22170930f, -0.03803784f, 0.01108283f, -0.03535225f, -0.03466648f, 
    0.14566462f, 0.10259400f, 0.12169529f, 0.03546389f, 0.16121346f, -0.12059739f, 0.08125887f, -0.07288903f, 
    0.08132917f, -0.04207325f, 0.14875902f, 0.07890106f, 0.17403138f, 0.02914743f, 0.01938829f, 0.03010632f, 
    -0.13664174f, 0.14566994f, -0.11760602f, 0.16136131f, -0.01421802f, -0.00590468f, -0.07192814f, 0.03973487f, 
    -0.04103713f, 0.04624783f, 0.01823539f, 0.05282046f, -0.28594616f, 0.25989839f, -0.16283411f, 0.08020157f, 
    -0.03340445f, 0.07722704f, 0.02314575f, 0.13921134f, -0.02480441f, 0.05042553f, -0.04295599f, 0.09760645f, 
    -0.18737240f, 0.41918769f, -0.15505987f, 0.19180448f, 0.02092613f, 0.06818016f, 0.03811878f, 0.08091948f, 
    -0.02939240f, 0.05264622f, -0.05308277f, -0.08464810f, -0.02586286f, 0.06361493f, 0.23711066f, 0.05954939f, 
    0.01030989f, 0.13636498f, -0.07975169f, 0.11536998f, -0.07222539f, 0.01287492f, 0.03898375f, 0.02293159f, 
    -0.13517579f, 0.03794845f, -0.01746900f, 0.04128762f, -0.02222902f, -0.02063975f, -0.02802562f, 0.27139416f, 
    0.03330287f, 0.18360053f, 0.14581537f, 0.05714778f, -0.21702038f, -0.03239671f, -0.17210416f, 0.14707072f, 
    0.14836650f, 0.05780480f, -0.08735018f, 0.13842255f, 0.03229505f, 0.17245093f, 0.00705241f, 0.24172625f, 
    -0.11032002f, -0.07251441f, 0.28745720f, 0.09807795f, -0.01457966f, 0.06795961f, 0.03400081f, -0.04273722f, 
    0.04271989f, 0.17966489f, 0.10666168f, 0.17924102f, -0.18220067f, 0.05201589f, -0.25471613f, 0.28012565f, 
    0.03575304f, 0.08825202f, -0.14076164f, 0.07346220f, 0.05600552f, 0.11154534f, 0.01896374f, 0.12044182f, 
    0.10447065f, -0.18649516f, 0.03119707f, 0.10748594f, -0.00285721f, 0.03336363f, 0.02038932f, 0.09024476f, 
    -0.06439430f, -0.04251959f, 0.04775860f, 0.01192205f, -0.16268322f, 0.31991634f, -0.18664080f, 0.37924793f, 
    0.06057688f, 0.04164471f, -0.04007430f, 0.19194640f, 0.10813246f, 0.06530443f, 0.05348665f, -0.01296072f, 
    -0.10403630f, -0.17226303f, 0.03984348f, 0.05157883f, 0.00999681f, 0.08210628f, 0.19123816f, 0.03466757f, 
    0.06481877f, -0.01780197f, 0.05793263f, 0.03081688f, 0.12699832f, -0.28912622f, -0.06125797f, -0.02629066f, 
    0.14860217f, -0.04297011f, 0.09345569f, 0.03763808f, -0.03023853f, -0.00199785f, 0.07813944f, -0.08816820f, 
    -0.12675379f, 0.03813476f, 0.11881842f, 0.16979188f, 0.08481064f, 0.00954526f, 0.00308051f, 0.13636437f, 
    0.05118947f, 0.06065297f, -0.04991917f, -0.06214232f, 0.08421291f, 0.33278674f, 0.03186606f, 0.15520298f, 
    0.11806498f, -0.04032001f, -0.02062811f, 0.08890808f, 0.07206843f, 0.11704862f, -0.07241525f, -0.04482304f, 
    -0.12348472f, -0.32722780f, -0.02241436f, 0.00713917f, 0.04456023f, 0.11065453f, 0.02729408f, -0.06430459f, 
    0.16210657f, -0.09428118f, 0.00492137f, -0.05705909f, -0.01276458f, -0.09418207f, 0.07248013f, -0.16375187f, 
    0.07975324f, 0.14024651f, -0.03177379f, -0.12735225f, 0.03010850f, -0.02219190f, 0.15472403f, 0.19992439f, 
    0.01274261f, -0.14720187f, 0.04115429f, 0.07531048f, -0.00795994f, 0.10235839f, -0.00954538f, 0.11802803f, 
    0.08772707f, 0.07897022f, 0.04760039f, 0.07983527f, 0.00266244f, 0.28161988f, 0.05597558f, 0.02146975f, 
    0.01690177f, -0.07523172f, -0.07114923f, 0.16540107f, 0.02303733f, -0.06967069f, 0.01447210f, 0.03158836f, 
    -0.16829590f, 0.38764933f, -0.00034962f, -0.28695682f, 0.06536926f, 0.13097538f, -0.00997822f, -0.00240211f, 
    -0.04919306f, 0.10870534f, 0.14546518f, 0.00054340f, 0.07408056f, -0.11543485f, -0.20820335f, 0.21347216f, 
    -0.06793610f, -0.04012466f, 0.01136854f, -0.00219127f, 0.02193305f, 0.05695881f, -0.11463282f, 0.08908625f, 
    -0.32941586f, 0.17055133f, -0.04438736f, -0.11480608f, 0.15963300f, 0.09432060f, -0.11905041f, -0.00654359f, 
    -0.05563353f, -0.11371195f, 0.05659165f, 0.02257239f, 0.03407108f, -0.18341896f, -0.24545451f, -0.01920401f, 
    -0.05487763f, -0.02865762f, 0.05555948f, 0.03004185f, 0.05603367f, -0.01388640f, -0.05691022f, -0.10864718f, 
    0.13839991f, 0.08927809f, -0.06758095f, 0.06209040f, 0.01057865f, 0.02874170f, 0.00584995f, -0.02116625f, 
    0.06249392f, 0.10055868f, 0.04556442f, -0.01773002f, -0.14081669f, 0.19344729f, 0.05367775f, -0.10256796f, 
    0.09716552f, -0.11982454f, 0.01775957f, -0.02985456f, -0.00888820f, -0.08272995f, 0.01378078f, -0.00003388f, 
    0.16466241f, 0.20822030f, 0.04128297f, -0.00770585f, 0.12016330f, 0.06548864f, -0.04301106f, 0.08944408f, 
    0.10593556f, 0.01328086f, 0.09907304f, 0.07291302f, 0.18414670f, 0.03977492f, 0.00665574f, 0.05909402f, 
    0.11841065f, -0.06368709f, 0.04395316f, -0.00558915f, 0.04121665f, -0.02689273f, 0.03526201f, 0.09309863f, 
    -0.19243257f, 0.19550669f, -0.11842726f, 0.00351711f, -0.05146936f, 0.03434745f, 0.02121996f, 0.06735782f, 
    0.05109342f, 0.12204182f, -0.00884978f, -0.00209290f, 0.02277851f, -0.05895171f, -0.17925380f, -0.24499509f, 
    -0.22269346f, -0.01166311f, -0.11914741f, -0.27657598f, 0.06112850f, -0.08560637f, -0.11578648f, -0.13117982f, 
    -0.06881581f, 0.04585507f, -0.07910720f, -0.10129455f, -0.09053937f, 0.03934630f, 0.10717281f, 0.08176193f, 
    -0.12245443f, -0.06088187f, 0.05235386f, 0.00909620f, 0.40909180f, 0.12205559f, -0.02399946f, -0.18105312f, 
    0.11315136f, -0.00113688f, 0.02732522f, 0.04742600f, 0.07713912f, 0.07544798f, 0.04789758f, 0.04178585f, 
    0.35827774f, -0.25529358f, -0.21303079f, 0.03693369f, -0.02396280f, 0.04634190f, 0.04763579f, -0.02296886f, 
    -0.00181746f, -0.04532029f, 0.00774387f, -0.01494806f, -0.06531674f, -0.00925449f, -0.03879916f, 0.21422590f, 
    -0.04491638f, 0.06579258f, -0.08652421f, 0.11713426f, 0.00006487f, 0.08978526f, 0.16329725f, 0.05243317f, 
    0.28867307f, -0.00406380f, -0.18575405f, 0.04847749f, -0.13819146f, 0.05197256f, 0.04391916f, 0.01565148f, 
    0.00625587f, 0.08778021f, 0.12325175f, -0.06827882f, 0.06734021f, 0.17424347f, -0.08571467f, 0.00196340f, 
    -0.11403210f, 0.04866294f, 0.11000512f, -0.04172756f, 0.00363253f, -0.00731144f, 0.06845905f, 0.04179823f, 
    0.25101933f, 0.04090543f, 0.00864729f, 0.01343497f, 0.03889638f, 0.09875032f, -0.13214576f, -0.00004241f, 
    -0.04326416f, -0.02355822f, 0.12671962f, 0.01571082f, -0.09367381f, 0.13589069f, -0.19196561f, -0.08791062f, 
    0.01527503f, 0.01659606f, -0.01927931f, -0.09950231f, 0.02615753f, 0.00679073f, 0.05741450f, 0.07967809f, 
    -0.11925135f, -0.13912313f, 0.01596360f, -0.24808154f, 0.14200713f, 0.00411839f, 0.04667938f, 0.06387554f, 
    0.08162556f, -0.06170546f, 0.06126849f, -0.00137385f, -0.04345705f, -0.02319692f, 0.02247087f, -0.01220900f, 
    0.04207454f, 0.02388390f, 0.03844582f, -0.07878180f, 0.13787362f, 0.04914428f, 0.10653107f, 0.06180164f, 
    0.29892114f, 0.24037446f, -0.07093602f, 0.11580662f, 0.06934821f, 0.00579631f, 0.07904337f, 0.11471108f, 
    -0.00411992f, 0.06437297f, 0.01092614f, 0.10284039f, -0.19249605f, -0.19329125f, 0.20611207f, 0.10916704f, 
    0.02546195f, 0.04019170f, 0.11235103f, 0.02524739f, 0.05969553f, -0.04935700f, -0.08020316f, -0.05806389f, 
    0.23073053f, -0.29970157f, 0.04617111f, 0.14420636f, -0.01692428f, 0.06130700f, 0.07422927f, -0.03318394f, 
    0.19440521f, 0.03029907f, 0.07221881f, -0.02983169f, -0.07999834f, 0.18404998f, -0.10710768f, 0.02220803f, 
    0.07569844f, -0.02319900f, -0.05005687f, 0.03197443f, -0.02843952f, 0.02782637f, -0.03595688f, 0.02915754f, 
    0.07969492f, -0.06076747f, 0.06407563f, -0.05441863f, 0.02528454f, -0.04567060f, -0.01526359f, 0.01273002f, 
    0.00721770f, -0.04857421f, 0.01747314f, 0.07053463f, -0.00360951f, -0.22386970f, -0.02692351f, -0.04986409f, 
    0.10321876f, -0.01709807f, -0.07480653f, -0.06845395f, 0.06360507f, -0.00546956f, -0.04228605f, 0.04268905f, 
    -0.05476287f, 0.06862727f, -0.17658973f, 0.01487675f, 0.06360137f, -0.00169945f, -0.10085253f, -0.05648147f, 
    0.08175762f, -0.07182957f, -0.03246403f, -0.01557781f, -0.29316247f, -0.12739500f, 0.05249107f, 0.00442489f, 
    -0.07334598f, 0.10954911f, 0.07724515f, 0.01212854f, 0.11358219f, -0.02312948f, 0.02896089f, -0.06423385f, 
    -0.01219686f, 0.17264612f, 0.00269110f, -0.03205471f, 0.05332541f, -0.06528755f, 0.02096495f, -0.05824591f, 
    0.04819152f, -0.04701577f, -0.02312954f, 0.13485989f, 0.14086594f, -0.04787396f, 0.05385683f, 0.04155588f, 
    0.02097258f, -0.23989639f, 0.05094213f, 0.08639479f, 0.07692759f, 0.08196535f, -0.02896606f, 0.04247447f, 
    -0.04307374f, -0.34538582f, -0.02066481f, 0.32425830f, -0.04144897f, 0.08982614f, 0.06963791f, -0.00557791f, 
    0.05982889f, -0.04748986f, -0.15574171f, -0.02598665f, -0.01668817f, 0.07790031f, 0.02457744f, 0.06125302f, 
    0.11763097f, 0.05861177f, 0.08435219f, 0.06387611f, -0.02531657f, 0.05491845f, 0.06831738f, 0.03803530f, 
    -0.23644100f, -0.27133459f, 0.02477403f, -0.33484533f, 0.06465355f, 0.00729042f, -0.17065333f, 0.12397442f, 
    0.07083859f, -0.04338447f, -0.07444536f, -0.11106797f, -0.11417193f, -0.14063391f, 0.19283023f, 0.03191618f, 
    -0.01952647f, 0.00053621f, 0.16367817f, 0.05149131f, -0.04934472f, -0.01179626f, 0.02333758f, -0.03058515f, 
    0.48692578f, -0.01040617f, -0.15779814f, 0.17054915f, 0.07181180f, -0.15139839f, 0.13723214f, 0.07293364f, 
    0.03227136f, 0.03821620f, 0.06836882f, 0.09109388f, 0.14025363f, -0.14174825f, 0.10347006f, -0.11026575f, 
    0.06636605f, 0.00080008f, -0.00924299f, 0.01277567f, 0.10885485f, -0.01744204f, 0.05860321f, 0.04855780f, 
    0.01783263f, 0.27226338f, -0.21015282f, 0.07685454f, -0.05447751f, 0.05341687f, -0.04458421f, -0.04665582f, 
    -0.03842524f, -0.08151809f, 0.01802731f, 0.09234702f, 0.25652751f, 0.26418301f, -0.11331832f, 0.04112672f, 
    0.04784228f, -0.00366192f, 0.00652031f, 0.10110141f, -0.03060330f, 0.09317408f, -0.05931841f, 0.10773879f, 
    -0.21183911f, -0.26533067f, 0.17277151f, -0.33571047f, -0.03618294f, 0.03327960f, -0.07879072f, 0.01858808f, 
    0.06817784f, -0.02914389f, -0.02140694f, 0.08181658f, 0.22300664f, 0.03766241f, -0.35382146f, 0.05856276f, 
    0.06537558f, -0.01208680f, 0.00407429f, 0.06211681f, 0.07020027f, -0.14383179f, 0.02196721f, -0.13613605f, 
    -0.04462086f, -0.04565239f, -0.20592389f, -0.05567656f, -0.09867663f, 0.08711305f, -0.09883981f, -0.06411550f, 
    0.02912167f, -0.08867601f, -0.04007628f, -0.02836709f, 0.32369977f, -0.10177030f, -0.06399883f, -0.14997950f, 
    0.02765401f, 0.04239833f, 0.04434504f, 0.11549096f, 0.06262040f, 0.06686778f, 0.16611847f, 0.10095356f, 
    0.06519700f, 0.11876122f, -0.08478417f, -0.01716925f, 0.13411804f, 0.18197207f, -0.01707252f, 0.07737295f, 
    0.21152055f, 0.08710639f, 0.01930903f, 0.10389461f, -0.04565081f, -0.08845232f, 0.04845661f, -0.26502991f, 
    0.04020521f, 0.03289166f, -0.07621080f, -0.04501263f, 0.04475484f, 0.08538539f, 0.04609226f, 0.12428663f, 
    -0.07879725f, 0.15606208f, 0.03630729f, -0.10606595f, -0.00800050f, 0.00108450f, 0.06270389f, 0.07293501f, 
    -0.03837398f, 0.04581766f, -0.02158606f, 0.06256057f, -0.02664310f, -0.08679848f, 0.05951227f, 0.10896093f, 
    0.07378769f, -0.06690407f, 0.07748996f, -0.00496444f, 0.05457064f, 0.04354908f, -0.03863308f, -0.05719501f, 
    -0.15104976f, 0.30937147f, -0.16544050f, -0.02995116f, 0.12716652f, 0.08590041f, 0.08530488f, 0.08547085f, 
    0.03815196f, -0.03560052f, -0.02670402f, 0.00483405f, -0.07491116f, 0.09536412f, -0.06787635f, -0.09233765f, 
    0.03940458f, -0.00536665f, 0.01393609f, -0.01989309f, 0.09170146f, 0.07610417f, 0.03892746f, -0.03172748f, 
    0.06162994f, -0.07727914f, 0.01684750f, -0.08817950f, -0.01152623f, 0.02976415f, -0.02973923f, 0.12747082f, 
    0.05115499f, -0.02142821f, 0.04477498f, -0.10413456f, 0.05972728f, 0.21869323f, -0.15045515f, -0.06789345f, 
    -0.08411847f, -0.00215235f, -0.05018806f, 0.00410060f, 0.05983542f, 0.03364972f, 0.02749823f, -0.08687025f, 
    0.19486159f, 0.35369420f, -0.02946335f, 0.09409959f, 0.02265533f, 0.12591298f, 0.02566928f, 0.04197534f, 
    -0.06898100f, -0.02646880f, 0.06291938f, 0.11048280f, -0.06354734f, 0.25671473f, 0.05033495f, -0.03104652f, 
    -0.01468911f, -0.05082395f, -0.08791119f, 0.08401591f, -0.05737639f, 0.04864716f, -0.01939483f, 0.04132172f, 
    0.36431336f, -0.08611704f, -0.07423528f, 0.11374396f, 0.10690510f, 0.02021413f, 0.11019851f, 0.02079904f, 
    -0.09811626f, -0.06173909f, 0.05710318f, 0.03664517f, -0.22984402f, 0.23742822f, -0.01538373f, -0.02040532f, 
    0.05557928f, 0.03433006f, 0.02893059f, 0.08809153f, 0.03305799f, 0.01777377f, 0.04246232f, 0.06410854f, 
    0.05778785f, 0.01960533f, -0.12983200f, 0.01574922f, -0.02444739f, 0.15577228f, 0.00670580f, -0.11524178f, 
    0.02739852f, -0.05970653f, 0.01490134f, 0.06160861f, -0.09941747f, 0.03213080f, -0.23112018f, -0.23266308f, 
    0.03067030f, 0.01578932f, -0.01350293f, 0.14099231f, 0.02025131f, 0.12921856f, -0.08690083f, -0.00593197f, 
    0.13794786f, -0.06013446f, -0.10427563f, -0.06776240f, 0.00852571f, -0.12968713f, -0.03296607f, 0.00934937f, 
    -0.00388725f, 0.04714638f, 0.09416825f, -0.02403560f, 0.11590310f, -0.24203852f, 0.17878036f, -0.20003088f, 
    0.05690113f, -0.03641593f, 0.18744317f, 0.00356590f, 0.05769170f, 0.02689107f, -0.00964466f, 0.09986815f, 
    -0.07651729f, -0.19854520f, -0.12636013f, -0.04927678f, -0.16403738f, -0.05836302f, 0.04322734f, 0.02074185f, 
    -0.02544126f, 0.03219405f, 0.08442333f, -0.13233288f, -0.21460482f, 0.10776136f, -0.05553044f, -0.23320235f, 
    0.02804686f, -0.10094145f, -0.03419981f, 0.04828602f, -0.09445778f, 0.08196801f, -0.13882768f, 0.05353856f, 
    0.15376300f, 0.00264889f, 0.20729502f, 0.08868175f, 0.09836484f, 0.05498702f, 0.02804327f, 0.04540911f, 
    0.13730134f, -0.08881161f, -0.00145865f, 0.08398560f, -0.03161836f, -0.23541151f, -0.10288823f, 0.25509185f, 
    0.00301686f, -0.12769650f, -0.02820041f, -0.02990841f, 0.13369203f, 0.08215810f, 0.04158948f, 0.06940651f, 
    0.06262077f, 0.20587687f, 0.10903677f, 0.13929640f, 0.09594844f, 0.03877617f, 0.12159958f, 0.14564416f, 
    -0.01344367f, 0.06150386f, 0.01209029f, -0.00458423f, -0.21942869f, 0.00604432f, -0.06816497f, -0.00411438f, 
    -0.08273800f, 0.08452634f, 0.07289144f, -0.01447964f, 0.05327978f, 0.03057678f, 0.07581711f, -0.12143749f, 
    -0.44542500f, 0.21105769f, -0.09082922f, 0.06301354f, -0.07874757f, 0.04185884f, -0.11590808f, 0.11292864f, 
    0.07890634f, 0.06242142f, 0.09611728f, 0.00060254f, 0.04544380f, 0.03070239f, -0.06650900f, -0.05972361f, 
    0.13490261f, -0.05056295f, 0.05673982f, 0.06250085f, 0.07667772f, -0.03354915f, -0.02553071f, 0.15907721f, 
    -0.00914741f, -0.06111043f, 0.13990071f, 0.05736886f, 0.09192380f, -0.08587268f, 0.06281546f, -0.03473330f, 
    0.02690126f, 0.02290893f, 0.03008042f, 0.02623312f, -0.24578850f, -0.10378783f, -0.04473956f, -0.15443778f, 
    -0.03523382f, 0.01888667f, 0.12485639f, 0.02571349f, 0.10353091f, 0.01816400f, -0.00454818f, 0.04263513f, 
    0.01948859f, 0.00401923f, 0.01113341f, -0.11668886f, 0.02563139f, -0.08395991f, 0.07647377f, 0.10383432f, 
    -0.04311399f, -0.01441106f, 0.05083850f, 0.06204647f, 0.07047077f, -0.07550860f, 0.20247474f, 0.16598122f, 
    -0.01684346f, 0.07080837f, -0.06956739f, -0.00949977f, -0.03903499f, 0.05352198f, 0.05903869f, 0.10287172f, 
    -0.16412753f, -0.13956885f, 0.02971845f, 0.21775021f, 0.02159223f, 0.11157457f, -0.09676019f, -0.00688045f, 
    0.03278641f, 0.07408590f, 0.05076867f, -0.03640638f, -0.21057071f, -0.06036487f, -0.06910361f, 0.19656949f, 
    0.06243374f, 0.01168938f, -0.03205354f, -0.02052068f, 0.04813802f, 0.06103128f, 0.04178873f, 0.06872469f, 
    -0.16545571f, 0.10010626f, 0.03360581f, 0.06164756f, 0.03144684f, 0.02942752f, 0.11447999f, -0.08744572f, 
    0.09957475f, 0.09605699f, 0.03114218f, -0.03403217f, -0.16949630f, -0.20070235f, -0.02904119f, -0.27407739f, 
    -0.24367648f, -0.03737468f, -0.13623382f, -0.08073889f, 0.12289526f, 0.02233050f, 0.00884676f, 0.09965970f, 
    -0.17573735f, 0.05203401f, -0.00979976f, 0.11594327f, 0.11144397f, 0.03622193f, -0.09073532f, 0.02417126f, 
    -0.03160683f, 0.05277178f, 0.02057249f, 0.04048713f, 0.04035850f, -0.01984905f, 0.23082173f, 0.02108558f, 
    -0.01948612f, -0.02351917f, 0.00670958f, 0.06212279f, 0.05457962f, 0.14245117f, 0.00094238f, 0.03634137f, 
    -0.16138324f, -0.00931142f, -0.07511918f, -0.00947064f, -0.11961541f, 0.00425997f, 0.02629358f, 0.04446456f, 
    0.06430852f, 0.03912236f, 0.05436224f, 0.05746693f, -0.21670894f, -0.10468403f, -0.06038922f, -0.02854341f, 
    0.04216203f, -0.02133755f, -0.10339871f, -0.01485615f, 0.01273815f, 0.03138891f, 0.16933838f, 0.04230413f, 
    -0.28138736f, 0.17160445f, 0.00073618f, -0.07449710f, -0.08820178f, -0.10046851f, -0.02697718f, 0.06001493f, 
    0.04637362f, 0.00682582f, -0.00983936f, 0.03062193f, 0.17818707f, 0.02943439f, 0.09253431f, -0.02386294f, 
    -0.02950611f, -0.02561825f, 0.02537617f, 0.02357478f, 0.08048066f, 0.01467520f, 0.01481161f, 0.15123139f, 
    0.23473828f, 0.06055730f, -0.00198136f, 0.02309235f, 0.06895215f, 0.09741504f, -0.11513637f, 0.17934856f, 
    0.04484182f, -0.13548988f, 0.17443345f, 0.09868923f, -0.24803065f, -0.13223803f, -0.15472092f, -0.16319378f, 
    0.06987299f, -0.02127293f, -0.01997003f, 0.05280533f, 0.10458602f, 0.05194306f, 0.04743383f, 0.20530958f, 
    -0.06435909f, -0.10871807f, 0.17921855f, 0.14759371f, -0.05241289f, 0.03020641f, -0.02509272f, 0.04268347f, 
    0.10415843f, 0.02321988f, 0.12141095f, 0.04442496f, 0.10851357f, 0.06991088f, 0.19191428f, -0.01111363f, 
    0.05772197f, 0.04599567f, -0.06491707f, 0.08157086f, 0.06419739f, -0.01861958f, 0.19895263f, 0.00205472f, 
    -0.15529345f, 0.17073770f, 0.19528492f, 0.05571182f, 0.09422474f, 0.00099696f, 0.10642371f, 0.05281166f, 
    0.00341125f, -0.00481130f, -0.03770312f, 0.02654809f, -0.05241869f, 0.04133321f, -0.00565820f, -0.03651302f, 
    0.07824952f, -0.10339749f, 0.04228245f, 0.11025906f, -0.05857732f, -0.03119921f, -0.05810050f, 0.01531359f, 
    0.08765445f, -0.03433525f, 0.05597016f, 0.11747575f, -0.04920781f, 0.08068259f, -0.00681235f, 0.08931228f, 
    0.11742841f, -0.01161053f, -0.02038289f, 0.01115545f, -0.25369900f, -0.12634297f, -0.07634915f, 0.29397097f, 
    0.06823297f, 0.05774083f, -0.07022118f, -0.11423084f, 0.01792970f, -0.02357847f, -0.08025402f, 0.05940326f, 
    -0.23496856f, 0.00160747f, 0.23909825f, 0.19869545f, 0.05048328f, 0.07237566f, -0.06343022f, 0.04733717f, 
    0.05292786f, -0.12804544f, 0.04198085f, 0.09952256f, -0.16433421f, 0.11065409f, -0.12774959f, 0.11912969f, 
    0.02301098f, 0.17455988f, -0.19105890f, -0.10128380f, 0.01975598f, -0.08872050f, 0.02697933f, -0.07991654f, 
    -0.25898960f, 0.04627222f, -0.01262752f, -0.08671734f, 0.16561650f, 0.06675506f, -0.06774317f, 0.01206576f, 
    0.01103882f, -0.06022172f, 0.03844709f, 0.08301340f, -0.12872376f, -0.05136514f, 0.02281726f, 0.04111423f, 
    0.04933852f, 0.17017433f, 0.04957480f, 0.04524985f, 0.04908614f, -0.07126348f, 0.08989395f, 0.02880435f, 
    0.04156322f, 0.09583711f, 0.33291775f, 0.06449458f, 0.00483254f, 0.02023411f, -0.11492143f, -0.00910171f, 
    -0.02966899f, 0.03859719f, 0.14286269f, -0.02066220f, 0.13582769f, -0.11101091f, 0.05721670f, 0.15133384f, 
    -0.03616656f, 0.14840426f, -0.07935041f, -0.01241165f, 0.13431260f, 0.07459848f, -0.07528000f, 0.08993590f, 
    0.38627955f, 0.01422997f, 0.06534139f, -0.05190653f, -0.02117311f, -0.03041233f, 0.01009532f, -0.01701847f, 
    0.10013285f, 0.01631465f, -0.02799657f, -0.01158903f, -0.39953363f, 0.02011143f, 0.10275309f, -0.02957299f, 
    -0.05605112f, 0.05104899f, -0.03160301f, 0.04651634f, 0.12766987f, 0.02693832f, 0.10015610f, 0.06468377f, 
    0.10313478f, -0.06997599f, 0.03011776f, -0.18306245f, -0.15958373f, 0.00594285f, 0.00514459f, 0.06082596f, 
    -0.04512708f, -0.00091905f, 0.01429806f, 0.06359345f, -0.14599323f, -0.10384860f, 0.11785215f, -0.07909244f, 
    0.02114465f, 0.10256594f, 0.04466915f, 0.03369644f, 0.06783968f, 0.13755190f, -0.04157440f, -0.04211958f, 
    0.28118172f, 0.18670636f, -0.07531884f, 0.07931666f, -0.11213311f, 0.07828529f, 0.13892291f, 0.11669179f, 
    0.11488482f, 0.06300586f, 0.00753713f, -0.02292694f, -0.39219877f, -0.12655200f, -0.00412787f, 0.05159796f, 
    0.04862804f, -0.00811254f, -0.16539584f, 0.04310685f, 0.02273850f, 0.05323185f, 0.08673258f, -0.11016792f, 
    -0.03978863f, 0.08690632f, 0.02112582f, 0.00945951f, -0.00575504f, -0.09626742f, 0.01184202f, 0.00446448f, 
    0.09528249f, 0.05916778f, -0.05234614f, 0.12400099f, -0.06726652f, 0.10909864f, 0.05924949f, -0.14622788f, 
    -0.02442472f, 0.01479642f, 0.11637288f, 0.01654522f, 0.13521984f, 0.12039358f, -0.15325090f, 0.03112714f, 
    0.14234032f, 0.04403790f, 0.05842274f, -0.06665390f, -0.10512177f, -0.04037133f, 0.05009837f, 0.02548467f, 
    0.03181217f, -0.03573628f, 0.05947940f, 0.01225340f, -0.28477767f, 0.06698073f, -0.10069188f, -0.00410972f, 
    -0.05566363f, -0.03904226f, -0.06033479f, -0.02850500f, 0.05743591f, -0.03940890f, 0.04343536f, -0.05198111f, 
    0.04603153f, 0.05286036f, -0.20827051f, 0.07508251f, 0.02088023f, 0.08541233f, -0.08791568f, -0.11682975f, 
    0.00462115f, 0.09003864f, 0.13713416f, 0.10309410f, 0.16607781f, 0.16475080f, 0.02701331f, 0.06904273f, 
    -0.01386985f, -0.01940556f, 0.01957798f, 0.10235837f, 0.09053908f, -0.06251893f, -0.02080984f, -0.04029107f, 
    -0.07343976f, -0.06198266f, 0.12707150f, -0.04920225f, 0.00334214f, 0.10280779f, -0.03834208f, -0.01786164f, 
    0.04122202f, 0.04673090f, 0.10063993f, -0.04049133f, -0.01754640f, 0.09307806f, 0.25027984f, 0.17838705f, 
    -0.00123626f, 0.04938892f, 0.03643022f, 0.10403790f, -0.00679742f, 0.01473362f, 0.08416317f, 0.02864522f, 
    -0.30151376f, -0.01242095f, 0.02291393f, 0.05828930f, -0.01380898f, -0.05145724f, 0.06349836f, -0.02770266f, 
    0.05592268f, 0.09926571f, 0.09429552f, 0.00470281f, 0.10593218f, -0.03295157f, 0.07811064f, -0.06371449f, 
    -0.02302582f, -0.03781641f, 0.09641071f, -0.00795717f, 0.07065846f, 0.03986700f, -0.05728764f, -0.03453501f, 
    -0.38777190f, 0.11079321f, 0.03772230f, 0.03388370f, -0.01441282f, -0.02373776f, 0.10786431f, 0.03297753f, 
    0.02463841f, -0.02162552f, -0.13217619f, 0.14001872f, -0.11872868f, -0.05391759f, -0.03739341f, -0.19308239f, 
    -0.00088453f, 0.04427836f, 0.10310794f, 0.00377896f, 0.05019983f, 0.05660645f, 0.05632423f, 0.03515071f, 
    0.07999376f, 0.16411874f, 0.06809034f, 0.04052341f, -0.03335732f, -0.04672083f, -0.06344059f, 0.08989994f, 
    0.07961975f, -0.03191479f, -0.03543052f, -0.05716208f, 0.04858539f, 0.07096484f, -0.06265496f, -0.06508975f, 
    -0.12877452f, -0.11964300f, 0.03398068f, 0.03223739f, 0.12818956f, -0.05806835f, 0.04476559f, -0.06578275f, 
    0.08190779f, 0.22116706f, 0.07313642f, -0.03052922f, -0.03855507f, -0.04915380f, -0.02450416f, 0.07604217f, 
    0.00503179f, 0.04937170f, 0.07194437f, 0.06468119f, -0.26060840f, 0.16540034f, 0.07978775f, 0.08986427f, 
    0.10562666f, -0.11872595f, 0.07677516f, 0.02505185f, 0.03534594f, 0.01206943f, -0.05888784f, 0.01089830f, 
    0.30167127f, 0.07564205f, 0.13645805f, 0.00466966f, 0.03703260f, 0.04137326f, 0.02667505f, -0.03358291f, 
    -0.13306402f, -0.11478160f, 0.07089482f, 0.12411430f, -0.36106509f, -0.17135467f, 0.02271919f, -0.08102110f, 
    0.10747506f, -0.03876065f, 0.12292050f, 0.02499196f, 0.08660269f, 0.05363232f, -0.03377434f, -0.00713916f, 
    -0.07295422f, -0.12664995f, -0.08364203f, -0.01671026f, -0.06991067f, 0.17532834f, 0.04075251f, -0.05736090f, 
    0.00525386f, -0.04813726f, 0.03692494f, 0.05922162f, 0.00268617f, 0.22274995f, 0.03109560f, 0.12698326f, 
    0.04021002f, -0.08158045f, -0.01898898f, 0.13853975f, 0.05151035f, 0.01847289f, 0.02765704f, -0.06974974f, 
    -0.16932486f, -0.17757100f, -0.13892341f, -0.05773288f, -0.05934785f, 0.02611454f, 0.00356077f, -0.00967173f, 
    -0.00806218f, 0.02090688f, 0.05433356f, 0.04631566f, -0.11836438f, 0.03607177f, -0.07231285f, -0.20889881f, 
    0.07094847f, 0.14755230f, 0.01458739f, 0.01745530f, 0.05648754f, 0.04399560f, -0.00024838f, -0.06834555f, 
    -0.02946944f, -0.24650666f, -0.10300097f, -0.14213236f, -0.08910583f, 0.07038323f, 0.06303290f, 0.12878267f, 
    -0.02999675f, 0.05426551f, 0.00484328f, -0.10952151f, -0.03459172f, 0.11376542f, 0.03849696f, 0.01051192f, 
    -0.02352214f, -0.14614844f, 0.04448145f, -0.00692144f, 0.02488684f, 0.06347766f, 0.01472545f, 0.06308374f, 
    -0.23106439f, -0.06559989f, 0.05993884f, 0.14156608f, 0.00736934f, 0.05233973f, -0.05282734f, -0.00659029f, 
    0.12824146f, -0.03921933f, -0.00208088f, 0.05754603f, -0.12616122f, -0.17036559f, -0.23411602f, 0.30374181f, 
    0.07666256f, 0.08914140f, -0.02825784f, 0.05856958f, 0.02845894f, -0.11045818f, 0.06219114f, -0.05366307f, 
    0.04389862f, -0.03462695f, 0.18636931f, 0.08028454f, 0.12105978f, 0.09305517f, 0.04022918f, -0.01146542f, 
    0.03327278f, 0.05772296f, 0.08548239f, -0.06775600f, -0.21342094f, -0.16138636f, -0.05186980f, -0.21420832f, 
    -0.06268195f, 0.07296050f, -0.03590551f, 0.07382160f, 0.01324747f, 0.01567098f, 0.05969963f, 0.09175159f, 
    -0.27504790f, 0.15210402f, 0.14595962f, -0.02196679f, 0.07082187f, -0.09805305f, 0.00361844f, -0.07983486f, 
    0.07658052f, 0.07975167f, -0.06760638f, 0.05328013f, 0.15502189f, -0.17157063f, 0.02836054f, 0.03784776f, 
    -0.00796549f, -0.04339162f, 0.12298691f, -0.04067545f, 0.14515936f, 0.10871371f, -0.06941614f, 0.10318189f, 
    -0.03306238f, 0.05772112f, -0.10645833f, -0.19191152f, 0.12505485f, 0.05739544f, -0.09056477f, 0.08546201f, 
    0.00999966f, 0.04464424f, -0.05538625f, 0.01655710f, -0.04323338f, 0.06345465f, -0.07833897f, 0.10944840f, 
    0.11129025f, -0.09424061f, -0.02042415f, -0.01633511f, -0.03711414f, -0.06992206f, -0.01599948f, -0.02266817f, 
    -0.13690534f, -0.09485142f, -0.25716913f, -0.17520876f, -0.03415402f, -0.00122809f, -0.01393249f, -0.11954844f, 
    0.07191418f, -0.02219411f, 0.07049785f, -0.01561428f, -0.18686977f, 0.18928936f, 0.03389190f, -0.07594090f, 
    0.21795900f, -0.09612130f, -0.02285896f, 0.00746312f, 0.09987327f, 0.05814745f, -0.05370783f, -0.06260237f, 
    0.23025228f, 0.33950099f, 0.13360074f, -0.12876485f, 0.06762462f, -0.04138090f, 0.05118029f, 0.04432935f, 
    0.12658589f, 0.00922136f, 0.06195290f, 0.00415723f, 0.40448332f, 0.21052602f, 0.09440455f, 0.04383425f, 
    0.03770179f, 0.15111107f, 0.00536607f, -0.02828334f, 0.04873068f, -0.02923011f, -0.04942619f, -0.02105153f, 
    0.19203450f, -0.10411809f, -0.00153229f, 0.16457649f, -0.00278834f, -0.01897251f, 0.07789321f, 0.12063496f, 
    -0.08325838f, -0.00370013f, 0.01736014f, -0.01453510f, 0.08301354f, -0.22928949f, -0.05753586f, 0.01480937f, 
    -0.15145478f, -0.07628026f, 0.02405297f, -0.02501865f, -0.08462553f, -0.09885331f, -0.06638475f, -0.09658085f, 
    0.36530739f, -0.05184627f, 0.04962258f, 0.08864710f, -0.03667779f, 0.01611076f, 0.18957454f, 0.09292736f, 
    0.04834300f, 0.01732386f, 0.06650748f, 0.06047495f, 0.16736411f, 0.16365622f, -0.09936771f, 0.05653509f, 
    0.11068664f, -0.02697759f, 0.01677996f, -0.00311450f, 0.02983271f, -0.04232537f, 0.04360662f, 0.07200523f, 
    0.17953275f, -0.14225557f, 0.03869332f, 0.01758060f, 0.11269307f, -0.00931694f, -0.01727173f, -0.07949475f, 
    0.03385452f, -0.00289871f, 0.03034676f, -0.05587270f, 0.27003071f, -0.01179740f, 0.00336985f, 0.00699653f, 
    0.00274919f, 0.04236382f, 0.07314656f, 0.03620337f, -0.02068103f, 0.00963520f, 0.05307936f, 0.03190975f, 
    0.22417772f, -0.17061713f, -0.12131655f, 0.08912972f, 0.01340698f, 0.07647064f, 0.06423371f, -0.11063262f, 
    0.02117515f, -0.00923042f, 0.02056047f, 0.01930019f, -0.12983203f, -0.00485924f, -0.13062605f, -0.17426227f, 
    -0.00637641f, 0.04906245f, -0.00949194f, -0.05414740f, -0.01843125f, 0.02318002f, 0.02365042f, -0.07478245f, 
    -0.18907066f, -0.03839976f, -0.07251745f, -0.10842592f, 0.09339398f, 0.03950566f, 0.05179624f, -0.11060622f, 
    0.08198901f, 0.00214308f, -0.15298538f, 0.00377410f, -0.07662980f, 0.04137541f, -0.02738188f, -0.02734468f, 
    0.00490214f, -0.02982310f, 0.05821877f, -0.08971862f, -0.01445888f, -0.01846370f, -0.04919732f, -0.15011011f, 
    -0.02677271f, 0.20884101f, -0.01668422f, -0.06362415f, 0.19433533f, 0.02637512f, 0.03914082f, 0.02197623f, 
    0.00832325f, 0.06163196f, 0.06607738f, 0.02983851f, -0.10128475f, 0.05029685f, -0.07396702f, 0.07189908f, 
    0.11684567f, -0.04205338f, -0.02195775f, -0.02623320f, 0.02395059f, 0.06235941f, -0.12526278f, 0.06566370f, 
    0.29743829f, 0.11750249f, -0.04529738f, -0.03581773f, -0.03922949f, 0.03248737f, -0.04729304f, 0.01049848f, 
    0.05614919f, -0.01949509f, 0.02469837f, 0.02054374f, 0.08988243f, -0.02969630f, 0.00173832f, 0.03461282f, 
    0.01080412f, 0.05163847f, 0.04995674f, 0.02043679f, 0.07616169f, 0.09864783f, 0.10029421f, 0.04382017f, 
    0.22227600f, 0.00039779f, -0.09905931f, -0.04500991f, 0.24356504f, -0.00157960f, -0.01394272f, -0.10361844f, 
    0.13550566f, 0.09585283f, 0.10437511f, 0.02221363f, 0.15771461f, 0.23770012f, 0.20726861f, -0.12748878f, 
    0.12546073f, -0.03872160f, 0.00560092f, 0.09128123f, 0.03183261f, 0.10678066f, 0.03500874f, -0.02261092f, 
    0.17055348f, 0.13244203f, 0.03339497f, -0.07542174f, 0.14307368f, -0.07799716f, -0.06200919f, -0.02507916f, 
    0.00896051f, 0.09622829f, -0.02206245f, -0.05994873f, 0.22138828f, 0.02068263f, 0.12362032f, 0.09629881f, 
    0.14640372f, -0.03815216f, 0.18363415f, 0.05607650f, 0.06579261f, 0.03949289f, 0.07870857f, 0.07550023f, 
    -0.09698329f, 0.00044984f, -0.00035177f, 0.01172908f, -0.05082409f, -0.05426281f, 0.03465567f, -0.01517294f, 
    0.07763794f, 0.00380785f, -0.03211262f, 0.01532871f, -0.01672441f, 0.21931306f, 0.11371250f, -0.01382709f, 
    0.03675331f, 0.07217113f, 0.06706703f, -0.09630132f, 0.05505006f, -0.00948658f, 0.07067311f, -0.03382207f, 
    0.01182226f, 0.16095075f, -0.09383146f, 0.02345905f, 0.11305665f, 0.01118637f, -0.02868048f, -0.04586893f, 
    -0.01767767f, 0.02872936f, -0.14862858f, 0.00828391f, -0.09217712f, 0.11847179f, 0.02696471f, -0.02314847f, 
    0.03807849f, -0.09382018f, 0.11941508f, 0.05367876f, 0.05458773f, 0.07054262f, 0.13227098f, 0.01107106f, 
    -0.36998165f, -0.22857496f, -0.06787785f, 0.10309754f, -0.01656586f, 0.07500824f, -0.04890859f, -0.04898975f, 
    0.06301627f, 0.09204408f, 0.11373332f, 0.11387371f, 0.16579844f, 0.24634658f, -0.31353357f, 0.05432476f, 
    0.07469719f, 0.00149205f, 0.13958919f, -0.04084925f, -0.02324749f, -0.05161753f, -0.02965316f, 0.10424189f, 
    -0.19554371f, -0.05019396f, -0.05428039f, 0.10570172f, 0.17519240f, 0.01494271f, 0.04471867f, 0.07861335f, 
    0.07475095f, -0.08043554f, -0.04429359f, 0.07308518f, 0.00439489f, 0.34197301f, 0.03189663f, 0.16866086f, 
    0.04030621f, -0.07721167f, -0.01848830f, 0.11206379f, -0.08276749f, -0.15972964f, 0.05152059f, 0.05906669f, 
    -0.07112686f, -0.11035514f, -0.01325154f, -0.02233852f, 0.08974789f, -0.03947942f, 0.01350191f, 0.01615827f, 
    0.02162242f, 0.06949684f, 0.01384508f, 0.09725031f, 0.49871349f, 0.15500593f, -0.02296136f, 0.06524245f, 
    0.18915364f, 0.05742031f, 0.11022875f, -0.01166413f, 0.02614850f, 0.02999616f, 0.01202855f, 0.11576207f, 
    -0.01722613f, 0.00304324f, -0.08236863f, -0.16502413f, -0.05462601f, 0.02289754f, 0.07720261f, 0.00806760f, 
    -0.04944695f, 0.04125276f, 0.00606112f, 0.04074670f, 0.17183743f, 0.04298512f, -0.11369289f, 0.05684945f, 
    0.03709286f, 0.03642275f, -0.01623731f, 0.03195850f, -0.01292688f, 0.05998005f, 0.05959892f, 0.00486471f, 
    -0.22287594f, -0.00077861f, 0.10603753f, -0.01413027f, 0.12590721f, 0.03726181f, 0.02522366f, 0.08433314f, 
    -0.01146237f, 0.03811782f, -0.02898750f, 0.06593722f, 0.08709417f, -0.08183213f, -0.00177699f, -0.06629691f, 
    0.07045744f, 0.04091520f, 0.08896991f, -0.03001996f, 0.04604577f, -0.04327365f, 0.01356251f, -0.06194429f, 
    -0.03321191f, -0.10049248f, 0.10497352f, 0.06086132f, -0.06229563f, 0.00156467f, 0.07084543f, 0.13623708f, 
    -0.03447344f, 0.03259473f, -0.04325071f, 0.01128384f, 0.15775777f, -0.17880043f, 0.02800416f, 0.10523503f, 
    0.05369408f, 0.05534922f, 0.04324139f, 0.02763303f, 0.03055836f, 0.03602092f, 0.01175873f, 0.12325533f, 
    0.13925841f, 0.16254956f, -0.01322242f, 0.19426753f, 0.14569362f, 0.01503171f, 0.05438451f, 0.03660694f, 
    0.13436607f, -0.05615574f, -0.01440320f, 0.04789001f, 0.10773378f, 0.18229011f, -0.09585904f, -0.11794680f, 
    0.12409557f, 0.00702810f, -0.09133939f, -0.05897126f, -0.00617097f, 0.07996861f, 0.02528282f, 0.03980780f, 
    0.33881634f, 0.13018841f, 0.13985929f, 0.17015301f, 0.07819887f, 0.06784220f, 0.09061623f, 0.06798875f, 
    0.02115017f, 0.02280178f, 0.06168410f, 0.05534479f, -0.15013804f, 0.06428587f, 0.03543465f, 0.08391596f, 
    -0.01451545f, -0.01765396f, -0.06417467f, 0.00304870f, -0.05861560f, -0.03921039f, 0.07058549f, 0.07362090f, 
    0.06895000f, 0.03937896f, -0.11263904f, -0.04469777f, -0.03196710f, 0.06318852f, 0.07984044f, 0.05497433f, 
    -0.00932067f, 0.02485142f, 0.08405284f, -0.07845644f, -0.11451171f, 0.11167619f, 0.09222695f, 0.14072928f, 
    0.10251886f, -0.01993126f, -0.02172050f, 0.02620225f, -0.01899327f, 0.00606918f, 0.06965710f, -0.00109048f, 
    0.13299669f, -0.18121569f, -0.08115920f, 0.06207315f, 0.15291663f, -0.04745846f, 0.02501496f, 0.04037668f, 
    0.06027307f, 0.04416249f, 0.06172909f, 0.11437587f, -0.24109095f, -0.05810550f, -0.19070423f, -0.04384833f, 
    -0.12339135f, -0.02026198f, -0.01747689f, -0.12395079f, -0.06856629f, -0.05129884f, -0.00891579f, -0.04456438f, 
    0.00548089f, -0.09126735f, -0.14140953f, -0.08413402f, -0.03872077f, 0.03025664f, 0.01909352f, -0.02844610f, 
    0.05816148f, 0.04038594f, -0.00049905f, 0.07153190f, 0.11558594f, 0.04873425f, -0.00148390f, 0.00342267f, 
    -0.07843762f, 0.03827492f, -0.02960958f, -0.00793421f, 0.00197029f, 0.01275613f, 0.00212460f, -0.00035867f, 
    -0.04555266f, 0.13990356f, -0.07927731f, -0.13409372f, -0.05142806f, -0.01908599f, 0.00162300f, 0.02990280f, 
    0.09725586f, 0.03162809f, -0.07859890f, -0.07158133f, 0.12519957f, 0.11909122f, -0.02441127f, 0.05163407f, 
    0.02441434f, 0.01468951f, 0.03825848f, 0.06238029f, -0.05471729f, 0.04439013f, 0.02613552f, -0.00836231f, 
    -0.13781682f, 0.12925163f, -0.03275270f, -0.01654899f, 0.00909717f, -0.05559718f, -0.05694478f, 0.11001723f, 
    0.12213343f, 0.09803352f, -0.00413528f, -0.00033653f, 0.17698282f, -0.21170725f, -0.00562619f, 0.05857507f, 
    0.00638674f, 0.08329769f, -0.00964798f, -0.01741527f, 0.03082001f, 0.04952881f, -0.05322253f, 0.07178464f, 
    -0.24769977f, -0.00913441f, 0.00823762f, 0.00354975f, 0.02680242f, -0.03286669f, -0.05036145f, -0.02169757f, 
    0.05969060f, -0.03542852f, -0.00909503f, 0.01255843f, -0.17887536f, 0.26141122f, -0.06702548f, 0.22242680f, 
    0.02404201f, -0.10064124f, 0.00493219f, 0.05085513f, 0.07588785f, -0.04449650f, -0.03625985f, 0.13802265f, 
    0.00981466f, 0.10323870f, 0.16148305f, -0.04072129f, -0.08012692f, -0.07100649f, -0.04683100f, -0.05441868f, 
    -0.02583010f, -0.07436795f, 0.05538597f, 0.08765701f, 0.15449442f, -0.22878999f, -0.00864656f, 0.07388404f, 
    -0.05732024f, 0.09745585f, 0.03618131f, 0.23011954f, -0.13813876f, -0.01453157f, -0.01164238f, -0.03401577f, 
    0.26204178f, 0.19245295f, 0.06621377f, -0.01292260f, 0.04541899f, 0.03625185f, -0.03012703f, 0.01551756f, 
    -0.00897109f, 0.08739889f, 0.07270245f, 0.07711851f, 0.39223805f, 0.14835468f, 0.13646106f, 0.05255554f, 
    0.08015694f, 0.03849512f, 0.03086583f, -0.07389799f, 0.14473559f, 0.08690229f, 0.02921779f, 0.04788925f, 
    -0.20799731f, 0.00335750f, -0.09359736f, -0.02963141f, -0.09357885f, 0.02082770f, -0.04073777f, 0.06138347f, 
    0.02659183f, -0.04281658f, 0.02835450f, -0.04574593f, -0.11486486f, 0.16458042f, 0.04393164f, 0.14434901f, 
    0.02768119f, -0.01760708f, 0.02104981f, -0.01958729f, 0.02969833f, -0.04516000f, 0.01497680f, -0.07661657f, 
    0.15451787f, 0.00523704f, -0.19958936f, -0.00078164f, -0.07059260f, 0.16200788f, -0.00960430f, 0.07909961f, 
    -0.09710719f, -0.01094555f, 0.12642509f, -0.01218351f, -0.36067393f, 0.07863213f, 0.04446910f, -0.13520229f, 
    0.05485687f, -0.00195679f, -0.02261139f, 0.07438780f, -0.05270832f, 0.00893382f, 0.08185107f, 0.01788651f, 
    0.02737922f, 0.01596582f, 0.02724178f, 0.01112584f, 0.00483888f, -0.03017054f, -0.03526663f, -0.01003258f, 
    -0.01360200f, 0.01101478f, -0.02841336f, -0.02141965f, -0.03185621f, -0.01817890f, -0.01784755f, -0.01685292f, 
    0.00495923f, -0.03139396f, 0.01594103f, 0.01931384f, -0.01125875f, -0.01107065f, -0.01072636f, 0.01312945f, 
    -0.00936785f, -0.02336967f, 0.00623335f, -0.02403301f, 0.01958152f, 0.03159124f, 0.01547788f, -0.02771071f, 
    0.00133837f, -0.03141225f, -0.03322330f, 0.02790035f, 0.02525695f, 0.01860573f, -0.03073779f, -0.01043924f, 
    0.01029418f, -0.02759298f, -0.02121505f, -0.03979379f, 0.02035954f, 0.00259266f, 0.02677214f, 0.01908540f, 
    -0.02382531f, 0.02628030f, 0.00013606f, -0.01927072f, -0.03038650f, 0.01978941f, 0.03021277f, -0.00487985f, 
    -0.00430950f, 0.00463501f, -0.00462261f, 0.01029170f, -0.00802863f, 0.00409868f, 0.00360808f, -0.02596724f, 
    0.00574774f, -0.02618364f, 0.03523936f, 0.02763228f, -0.01238076f, -0.03888026f, 0.00281202f, 0.02143808f, 
    0.02675199f, -0.01263572f, 0.01647810f, 0.01531709f, -0.03160824f, -0.01127759f, 0.02737424f, -0.02449250f, 
    0.02197384f, -0.01079320f, 0.02461530f, 0.00529702f, 0.00446402f, 0.02631564f, -0.00474572f, 0.01550644f, 
    0.01720640f, 0.00393001f, -0.03476941f, -0.02514318f, 0.01994599f, 0.02283537f, 0.01110553f, -0.00741717f, 
    0.04112327f, -0.00729929f, -0.00342609f, 0.01835616f, -0.01183564f, -0.02687271f, 0.02930763f, 0.02462274f, 
    0.02000498f, 0.01948206f, 0.02477000f, 0.02546791f, 0.02345908f, 0.02557173f, -0.00712863f, 0.00338806f, 
    0.02323890f, 0.03801423f, -0.00595545f, -0.02656476f, -0.03041904f, -0.03703383f, -0.00003148f, 0.02628206f, 
    -0.03126194f, 0.01691847f, -0.02206090f, 0.01310312f, -0.03086417f, 0.01049183f, -0.00613101f, 0.02451672f, 
    -0.03667197f, -0.00439123f, 0.03019319f, -0.00759767f, -0.01827813f, -0.04241199f, 0.02854796f, -0.04021614f, 
    0.02161345f, -0.02313980f, 0.00004108f, -0.04162098f, 0.01282060f, 0.02485148f, -0.03114027f, -0.00056458f, 
    0.02321412f, -0.00112838f, 0.00664152f, -0.00891433f, -0.02511949f, -0.01543513f, 0.02318027f, 0.01934135f, 
    -0.01946026f, -0.01168643f, -0.03675931f, 0.03510466f, 0.02748154f, -0.03422739f, 0.01024218f, 0.01103355f, 
    -0.02101481f, 0.01536072f, -0.01684025f, 0.00080643f, -0.01750738f, 0.00310369f, -0.01899189f, -0.01892491f, 
    -0.02283562f, -0.03455840f, -0.00054968f, -0.00066275f, 0.00718218f, -0.04246635f, 0.02986724f, 0.00421990f, 
    -0.01673923f, -0.01338812f, -0.00187480f, 0.02219402f, -0.02799206f, 0.00350644f, 0.00199303f, 0.01069025f, 
    0.00280894f, -0.00069880f, 0.01949131f, -0.00389516f, -0.02234172f, 0.01266981f, -0.03747645f, -0.04193091f, 
    -0.02776876f, -0.01547221f, -0.00703167f, -0.02144152f, 0.00836752f, -0.02179158f, -0.01479968f, 0.00389650f, 
    -0.03494247f, -0.00170976f, -0.00495793f, -0.02494396f, 0.00734173f, 0.01001591f, -0.01725001f, -0.02976001f, 
    0.02099601f, 0.00004277f, -0.03668126f, -0.02379652f, -0.01278703f, 0.02976175f, 0.01983642f, -0.02211195f, 
    -0.03275279f, -0.02004798f, 0.00367466f, -0.01496749f, 0.00272143f, 0.00289160f, -0.02255856f, -0.00710364f, 
    -0.00351926f, 0.01530001f, -0.03812137f, -0.01063411f, -0.02306139f, -0.01628688f, -0.00850453f, 0.00384298f, 
    -0.02137733f, 0.02623795f, 0.02908691f, 0.02033189f, -0.03019675f, 0.01589265f, -0.03930428f, 0.02707884f, 
    0.01463214f, 0.00100615f, -0.00093643f, -0.01326908f, -0.03884624f, -0.01901407f, 0.01001489f, -0.03421731f, 
    -0.03951169f, -0.02799176f, -0.02753992f, 0.03490762f, 0.03040234f, -0.01119339f, 0.00857668f, 0.02770395f, 
    0.00287526f, 0.00796641f, -0.02427451f, 0.00540778f, -0.02046208f, -0.02641290f, -0.00816277f, -0.03612463f, 
    0.01958684f, -0.02284020f, -0.02831136f, 0.00814487f, -0.02190099f, 0.01947173f, -0.03574464f, -0.04005220f, 
    -0.03146342f, 0.01126090f, 0.00830969f, -0.03890687f, -0.00586479f, -0.01830960f, 0.00430556f, -0.03369394f, 
    0.02494083f, 0.03083225f, 0.02398227f, -0.00481895f, -0.00262313f, -0.03303980f, -0.01132428f, 0.00813106f, 
    -0.02962910f, -0.02268983f, -0.02661840f, 0.01735360f, -0.00747568f, -0.01611670f, 0.03327600f, -0.03356953f, 
    0.00656968f, -0.00829754f, -0.01459527f, 0.02873484f, -0.01053658f, 0.03708720f, 0.00871811f, 0.03928242f, 
    -0.03516056f, 0.00516981f, 0.01038128f, -0.03238294f, -0.02679620f, 0.00894681f, 0.01952139f, 0.01469580f, 
    -0.02862055f, -0.01185739f, -0.04051809f, 0.02756405f, -0.00141373f, 0.02271560f, 0.00520181f, -0.01361521f, 
    0.01325370f, 0.00360351f, 0.02038616f, -0.03264483f, -0.02581660f, -0.02886698f, 0.02562778f, -0.02625920f, 
    -0.02197830f, -0.00018092f, -0.01920543f, 0.00545086f, -0.00611624f, -0.01251466f, 0.00092962f, 0.01430231f, 
    -0.03517584f, -0.04262003f, 0.00692090f, 0.02611607f, -0.00207719f, 0.01984024f, 0.01265606f, -0.01043969f, 
    0.01857783f, 0.01591419f, 0.01667831f, 0.01770027f, -0.01735541f, 0.01964159f, 0.00528315f, 0.02587952f, 
    0.03268490f, -0.01683893f, -0.02889937f, -0.00308106f, -0.00340230f, -0.03654488f, -0.00031421f, -0.02611559f, 
    -0.02191391f, 0.02380446f, 0.02880595f, 0.02655590f, -0.03666179f, 0.02601205f, -0.01026757f, -0.01830249f, 
    -0.02870260f, -0.00532905f, -0.01272825f, -0.01975757f, -0.01395725f, -0.01584967f, -0.03882554f, 0.01760477f, 
    0.00937626f, -0.03474076f, -0.02822478f, -0.03114525f, 0.01182146f, 0.01980932f, 0.02119947f, 0.04165285f, 
    0.01497851f, -0.02168100f, -0.01786592f, 0.00883393f, -0.01424886f, -0.03791330f, 0.00880954f, -0.00368418f, 
    0.01460350f, -0.01664240f, -0.03012789f, 0.00369934f, -0.02396714f, -0.01340012f, 0.02527418f, 0.02871987f, 
    -0.02849700f, 0.04366478f, 0.01993821f, 0.02639825f, 0.00629401f, 0.02446528f, 0.03159962f, -0.02056235f, 
    -0.01161846f, -0.04313980f, 0.01401597f, -0.03104755f, 0.01593867f, -0.01238270f, -0.00675581f, -0.01553280f, 
    -0.01861350f, -0.00743223f, 0.00879627f, -0.04108919f, 0.02263947f, 0.01801386f, -0.01281936f, -0.01120582f, 
    0.01948112f, -0.00411895f, 0.01350274f, -0.01264136f, -0.00821533f, -0.02168583f, -0.01262730f, 0.01867576f, 
    0.02625300f, -0.01211007f, 0.02199021f, -0.00933519f, -0.02616920f, 0.00385332f, -0.01927045f, -0.03706887f, 
    0.02251043f, 0.00533575f, -0.02220558f, -0.01940530f, 0.02084555f, -0.00955639f, -0.01145623f, -0.02208745f, 
    0.02779846f, -0.00508785f, -0.00286780f, -0.03433707f, -0.00017689f, -0.03070179f, 0.02744977f, 0.00783689f, 
    0.01056410f, -0.03652174f, -0.01679324f, 0.03566715f, 0.02287638f, -0.03283132f, -0.02553627f, 0.00667951f, 
    -0.00806483f, 0.00330605f, -0.03669886f, 0.03432039f, -0.01993587f, 0.01748460f, 0.01872906f, -0.03352297f, 
    0.00755642f, 0.01951567f, 0.02812726f, 0.00072321f, 0.03349811f, 0.00288917f, -0.02404498f, 0.00451452f, 
    -0.04246998f, 0.00562563f, -0.03342498f, 0.00676311f, -0.02667617f, -0.01124652f, -0.01008626f, 0.01905351f, 
    0.00046980f, -0.01188242f, -0.00581649f, -0.02498449f, -0.02875204f, 0.02710682f, -0.04001662f, 0.02038449f, 
    0.00662825f, 0.02517727f, -0.00522188f, -0.01993557f, -0.03209756f, -0.02272297f, -0.00972360f, 0.02024097f, 
    -0.01297052f, 0.02890547f, -0.00532340f, 0.02793900f, 0.02917987f, -0.00394106f, -0.03557478f, 0.01970585f, 
    -0.00970354f, -0.01489945f, -0.03322930f, -0.00271002f, 0.01871048f, -0.04145020f, -0.01527435f, 0.00419851f, 
    -0.02123212f, -0.03850800f, -0.00674799f, -0.00549993f, -0.01182462f, -0.02113005f, 0.02416653f, 0.03027802f, 
    -0.00355226f, -0.02425664f, 0.02425258f, 0.00141195f, -0.01438443f, -0.01297772f, -0.00286503f, -0.03298659f, 
    -0.01099066f, 0.02282754f, 0.03080488f, -0.03164916f, 0.01556327f, -0.03803708f, 0.02881329f, -0.01045424f, 
    0.01431517f, 0.01977054f, -0.01703853f, -0.02293831f, -0.02642817f, -0.00185602f, 0.02883297f, -0.01030737f, 
    0.02912915f, 0.02227757f, -0.01561096f, -0.02077405f, -0.01240954f, -0.04021832f, -0.02084032f, 0.01963218f, 
    0.02359303f, 0.02895364f, -0.03168189f, -0.02132302f, -0.03634568f, 0.02130575f, -0.02160596f, 0.01287764f, 
    0.02668228f, -0.00281172f, 0.00976638f, 0.00113968f, -0.02710988f, -0.00026429f, 0.01328066f, 0.03129197f, 
    0.00730818f, 0.02561100f, -0.00241611f, -0.03795647f, 0.00481051f, -0.00994281f, -0.01836590f, -0.02054151f, 
    0.02276831f, 0.03716181f, -0.01324251f, -0.00965144f, 0.02683558f, 0.01067806f, 0.02621196f, -0.02637558f, 
    0.01316081f, -0.00420947f, -0.00703455f, 0.02036502f, -0.03291744f, -0.00837100f, 0.02435306f, -0.03790170f, 
    -0.02835196f, -0.03905625f, -0.03323922f, -0.03527148f, -0.00222526f, -0.01680009f, 0.02135563f, 0.00283093f, 
    -0.00415259f, -0.03392332f, -0.03700325f, -0.04109741f, 0.01269378f, -0.01614743f, -0.00584407f, 0.02624297f, 
    -0.02451568f, -0.00223590f, -0.00755068f, -0.00353504f, 0.01431663f, -0.01384816f, -0.03668741f, -0.03716161f, 
    0.00661785f, 0.02394579f, 0.02209424f, 0.02117373f, -0.00048685f, -0.00667072f, 0.01470952f, 0.02934960f, 
    0.00035224f, -0.00407660f, -0.00574235f, 0.02141958f, 0.02688955f, -0.02554148f, -0.00030708f, -0.02313278f, 
    -0.01094089f, -0.03504732f, -0.03042703f, -0.02734324f, -0.00950716f, -0.02298472f, -0.00981806f, -0.03229872f, 
    -0.00066167f, 0.00745978f, -0.00946498f, -0.03764162f, -0.00899063f, 0.00534176f, -0.02390275f, -0.00618509f, 
    0.01097345f, -0.03896826f, 0.00848887f, 0.00533846f, 0.00255404f, -0.00264415f, -0.04050608f, 0.01808974f, 
    0.01362819f, 0.02469121f, -0.00235241f, 0.01169834f, 0.02477949f, 0.01355797f, 0.02789098f, 0.01566886f, 
    -0.02523190f, -0.02376009f, -0.02627195f, 0.01728342f, -0.00222224f, 0.01277172f, -0.01042912f, 0.01796196f, 
    0.03203752f, 0.01508380f, -0.01119071f, -0.01977941f, -0.02591258f, -0.00263802f, 0.01262784f, -0.00380768f, 
    0.01838531f, 0.00863239f, -0.00719506f, 0.01828818f, -0.03280681f, 0.01430673f, -0.03688770f, -0.03907370f, 
    -0.00073887f, 0.02571564f, -0.03521576f, -0.02924957f, 0.00368731f, -0.04015740f, -0.00956302f, -0.02248977f, 
    -0.02821798f, -0.01085784f, 0.02004316f, 0.02671890f, -0.01583666f, -0.00875698f, 0.02781827f, -0.01308357f, 
    -0.00670999f, 0.01312838f, 0.01843159f, -0.00450178f, -0.03605895f, 0.02245688f, -0.02596369f, 0.01520916f, 
    0.00303696f, -0.02084296f, -0.04366274f, 0.01675066f, -0.02609956f, -0.02271273f, 0.02413647f, -0.02067184f, 
    0.02860662f, -0.01674995f, -0.03208208f, -0.01039596f, 0.01735769f, 0.01094981f, -0.02376779f, 0.02293673f, 
    0.00953966f, 0.02065138f, -0.01567932f, -0.00218591f, -0.02105036f, 0.01085575f, -0.02888373f, -0.02004156f, 
    0.03160625f, 0.01438900f, 0.00684498f, 0.02379952f, -0.00155494f, 0.03046010f, 0.02641202f, -0.01665480f, 
    0.00084385f, -0.00291281f, -0.00740623f, -0.03295945f, -0.00425770f, 0.00647544f, -0.01750261f, -0.02904581f, 
    -0.00873548f, -0.02726554f, -0.03288425f, -0.01866559f, 0.00067811f, -0.02458629f, -0.00190038f, -0.03232600f, 
    0.00037585f, -0.00033614f, 0.02106968f, 0.01311793f, -0.00307950f, 0.00896551f, -0.00619530f, 0.00264987f, 
    -0.00224364f, -0.01515079f, 0.01789014f, 0.02688796f, -0.00411439f, -0.00299040f, 0.03278846f, 0.01985596f, 
    -0.01720984f, 0.00303017f, 0.00319404f, -0.01133480f, 0.01790798f, 0.00000483f, -0.00352236f, -0.02843927f, 
    0.00177014f, 0.01589941f, -0.01324833f, -0.02203127f, -0.00801387f, -0.02061410f, -0.03996278f, -0.02263242f, 
    0.03554581f, 0.01704774f, -0.03396837f, -0.02492830f, 0.00880681f, 0.03238033f, -0.03985878f, -0.00464910f, 
    -0.02919668f, 0.01046628f, 0.01970525f, 0.00425636f, 0.01636805f, 0.00813515f, -0.00303446f, 0.01651806f, 
    0.02129451f, -0.04202633f, -0.01089071f, 0.02784855f, 0.00606320f, -0.03198472f, 0.00647032f, -0.00135256f, 
    0.02187495f, -0.01252862f, 0.01493774f, 0.03189056f, 0.01820393f, 0.00875707f, 0.03038445f, 0.02692086f, 
    -0.03446853f, 0.02799940f, 0.01736281f, 0.01267483f, -0.00737222f, -0.01259348f, -0.02372906f, 0.01491739f, 
    -0.01424182f, -0.03043156f, -0.00113208f, -0.03895630f, 0.01312817f, -0.02841460f, -0.02633879f, 0.00984259f, 
    -0.00232742f, -0.00705269f, -0.00117236f, -0.01143126f, 0.01547837f, 0.02519397f, 0.03912567f, 0.02426250f, 
    -0.02691256f, 0.01769796f, -0.01003364f, -0.03949482f, -0.01945215f, -0.00948645f, 0.01785203f, 0.02933053f, 
    -0.02086196f, -0.04096870f, -0.02885429f, -0.02772812f, -0.03205037f, -0.02211452f, 0.02598373f, -0.02944066f, 
    -0.03455107f, -0.02400376f, -0.00511048f, -0.02057924f, -0.02719098f, -0.04192252f, 0.02663825f, -0.01988635f, 
    -0.00395664f, -0.02426941f, 0.00239665f, 0.00295733f, 0.02792791f, -0.00478016f, -0.00141353f, -0.01237275f, 
    -0.03834544f, -0.03961274f, 0.01619568f, -0.00677752f, 0.02834659f, -0.00761012f, 0.00195803f, 0.00199755f, 
    -0.02762094f, -0.01888674f, -0.00003922f, 0.02209025f, 0.00046454f, -0.02084448f, -0.00543862f, -0.00538778f, 
    -0.02225132f, 0.01604352f, 0.01480549f, 0.01331537f, -0.00787860f, -0.03436854f, -0.04037568f, 0.01938454f, 
    -0.00004542f, 0.00810393f, -0.01025725f, -0.03876254f, -0.00162151f, 0.02963080f, 0.01710458f, 0.02035577f, 
    0.02993920f, -0.00052303f, 0.00120629f, -0.01887677f, -0.03197588f, -0.00908370f, -0.02441894f, -0.00053455f, 
    -0.02306854f, 0.02443803f, -0.03593615f, 0.03098800f, -0.00683234f, -0.02929612f, 0.00330841f, 0.01287019f, 
    0.02731709f, 0.01994516f, -0.01952134f, 0.01185416f, -0.02057502f, -0.02586230f, -0.03919109f, -0.00565322f, 
    -0.03297126f, 0.00353247f, -0.03083930f, 0.01028496f, 0.02500265f, -0.01623194f, -0.01399801f, 0.03871036f, 
    -0.02119115f, 0.00814702f, 0.02311795f, 0.01650210f, -0.00968852f, -0.02927089f, -0.00231659f, 0.01432011f, 
    0.00230207f, -0.03475573f, -0.00871019f, 0.01467216f, 0.01813571f, -0.01839127f, 0.00561926f, 0.01912966f, 
    0.00131371f, -0.02653355f, 0.02058874f, -0.00074321f, 0.02149189f, -0.02912358f, 0.00378353f, -0.03223876f, 
    -0.00141852f, -0.00310212f, -0.03542763f, 0.00762510f, -0.03281256f, -0.01123514f, -0.01476054f, 0.02354979f, 
    -0.03171275f, 0.01675731f, -0.02392107f, 0.00798106f, -0.00656612f, -0.01582188f, -0.02334926f, -0.00351918f, 
    0.00950787f, 0.01454308f, -0.02852250f, -0.01813696f, 0.01933300f, -0.01186259f, 0.01272158f, -0.02389425f, 
    -0.01237503f, 0.00838368f, -0.01527838f, 0.00503333f, -0.01406295f, -0.03105135f, 0.01162374f, 0.00277133f, 
    -0.00037595f, 0.01753225f, 0.01911733f, -0.02020295f, -0.04097888f, 0.02678353f, -0.02812918f, -0.01373128f, 
    -0.03611976f, 0.00834510f, -0.01965460f, -0.00953897f, 0.00959233f, 0.03365953f, 0.01903984f, 0.01156279f, 
    -0.04179319f, 0.02703424f, -0.01083379f, 0.02533378f, -0.01365411f, -0.02589753f, -0.03146477f, -0.00509852f, 
    0.00772197f, 0.00175103f, 0.04133562f, 0.02074913f, 0.01400608f, -0.03649929f, 0.02791240f, -0.03450874f, 
    -0.02294568f, -0.00001869f, -0.02122035f, -0.01786783f, 0.01881596f, -0.00722700f, -0.02486874f, -0.00093223f, 
    -0.02959179f, -0.04005339f, -0.03278117f, -0.01660450f, -0.02491789f, 0.01648575f, -0.02375656f, 0.01855914f, 
    0.02174149f, -0.01363166f, -0.04012678f, 0.03335272f, 0.00842911f, -0.01878355f, -0.03200423f, 0.02365703f, 
    0.02477121f, 0.01345914f, 0.02569484f, 0.00205695f, 0.02856103f, -0.02430409f, -0.02560659f, -0.03856695f, 
    -0.00770286f, 0.01514069f, -0.01086528f, -0.00289685f, 0.01327049f, -0.03231521f, -0.03090800f, -0.01925557f, 
    -0.01206411f, 0.01439463f, -0.02745761f, 0.01529243f, 0.03473170f, 0.01596136f, 0.00835881f, -0.03743748f, 
    -0.03699111f, 0.01578770f, -0.00500120f, 0.00485784f, -0.01371269f, -0.01763982f, 0.02016773f, 0.02314653f, 
    -0.00590124f, -0.02712844f, 0.01894049f, 0.02615570f, 0.01180375f, 0.00559147f, 0.00909062f, 0.01219642f, 
    0.00244615f, -0.02903884f, -0.03344560f, -0.03174219f, -0.01601405f, 0.00984077f, 0.02509821f, 0.00947458f, 
    -0.01083352f, -0.01326730f, 0.02795896f, 0.02036948f, 0.00649047f, 0.00891401f, 0.02346067f, -0.03213694f, 
    0.02315721f, 0.01569663f, 0.00255588f, 0.02601627f, -0.03289916f, -0.03451797f, -0.00788514f, 0.01972486f, 
    -0.01470297f, 0.01278312f, 0.02498448f, 0.03943755f, -0.00092238f, 0.00029782f, -0.02574693f, -0.02336868f, 
    0.02518349f, 0.02693817f, 0.00568243f, -0.01909107f, -0.00446565f, -0.00667159f, -0.01692445f, 0.02744377f, 
    -0.03614878f, 0.00463412f, 0.01885782f, -0.03083818f, -0.00637652f, -0.01939684f, 0.01299386f, -0.00497323f, 
    0.01085542f, -0.02245754f, -0.01060862f, -0.02460057f, -0.01490830f, 0.01748929f, -0.01404985f, 0.01480858f, 
    0.02298357f, -0.00923492f, 0.02741830f, -0.03335324f, -0.01621732f, -0.02828329f, -0.00908195f, -0.01387338f, 
    0.02149921f, -0.01176186f, -0.02041506f, -0.03748007f, 0.03697126f, -0.01406852f, -0.01959732f, 0.00942450f, 
    -0.00768633f, -0.03059843f, -0.00043619f, 0.01445360f, -0.02543424f, -0.01235642f, -0.03918161f, 0.02382353f, 
    -0.03965208f, -0.04012845f, 0.01107164f, 0.01630877f, -0.02321612f, -0.00515590f, 0.01340249f, 0.02647524f, 
    0.03273068f, -0.02820783f, 0.00235940f, -0.03127263f, -0.00516251f, 0.00245145f, -0.00039791f, 0.00421134f, 
    0.00339340f, -0.04175465f, 0.00428520f, 0.02226485f, 0.02827001f, 0.02993502f, -0.01321234f, -0.01105293f, 
    0.02976729f, -0.02623502f, 0.00128830f, 0.00568593f, -0.00828905f, 0.02908135f, 0.02974558f, 0.00412126f, 
    -0.02126016f, 0.03483658f, -0.01242857f, 0.02102780f, 0.02218492f, 0.00610745f, -0.01031856f, 0.01086044f, 
    -0.01133218f, 0.00010301f, -0.01411461f, -0.03294764f, -0.02049678f, -0.02661008f, -0.00697732f, 0.02936264f, 
    -0.00740633f, 0.02992834f, 0.01140391f, 0.00259929f, -0.02691032f, -0.01212364f, -0.02798987f, -0.03638624f, 
    0.02222619f, -0.02366455f, -0.02406252f, -0.01400269f, 0.02550176f, -0.00912731f, 0.02606579f, 0.01748338f, 
    0.03801746f, 0.01605090f, -0.02995432f, 0.01290863f, -0.01846319f, 0.03003005f, 0.00280129f, 0.01698972f, 
    0.01966910f, 0.01410837f, 0.03442655f, 0.01211009f, 0.03307010f, -0.02647603f, -0.00945336f, -0.00705472f, 
    0.01805339f, -0.02815847f, -0.00014058f, 0.00972018f, 0.00297847f, 0.00123124f, -0.02277059f, -0.03149448f, 
    0.01229789f, 0.03584285f, 0.02422624f, 0.01992134f, 0.00658426f, -0.03527565f, 0.02664983f, 0.00126548f, 
    -0.03071219f, -0.02413738f, -0.02405560f, -0.02042948f, -0.04169669f, -0.03377644f, 0.00936118f, -0.02878997f, 
    -0.00243471f, -0.01846336f, -0.00089431f, -0.02435593f, 0.03493606f, 0.01865260f, 0.00480905f, 0.02266549f, 
    0.01645891f, -0.01288117f, -0.00810601f, -0.01458647f, -0.03781582f, -0.00432411f, -0.02636388f, -0.01787980f, 
    -0.02994891f, 0.01602561f, -0.03726554f, 0.02541805f, -0.01750207f, 0.02817878f, -0.01643970f, -0.00656460f, 
    0.01550847f, 0.01185182f, 0.00666547f, -0.00869016f, 0.01536729f, -0.00959257f, -0.00674922f, -0.00225810f, 
    0.01940239f, -0.03166522f, -0.03909964f, -0.01482235f, 0.00892922f, -0.01269953f, -0.02698988f, 0.00968177f, 
    -0.00632721f, 0.02932754f, -0.02925800f, 0.03560205f, -0.02529627f, -0.02420398f, -0.01293731f, 0.01050869f, 
    -0.03629310f, -0.00958639f, -0.03066339f, 0.01367181f, -0.02549710f, 0.01538219f, -0.00882498f, -0.02493237f, 
    0.02622291f, -0.04165144f, -0.02448103f, 0.02343655f, 0.00175406f, 0.02089030f, -0.02745903f, -0.02765944f, 
    -0.02566791f, 0.01170498f, -0.00137092f, -0.00062664f, 0.00203124f, 0.00677763f, 0.02748281f, 0.02625695f, 
    -0.02398684f, 0.02554714f, -0.00888397f, 0.01098138f, -0.02771556f, -0.04083812f, -0.03060997f, 0.00369137f, 
    0.00622406f, -0.03864781f, 0.00233364f, 0.01090883f, 0.01771082f, -0.01286783f, 0.02933522f, 0.01573605f, 
    0.02244104f, 0.02493285f, -0.01845352f, 0.00785935f, -0.01187401f, -0.00350587f, -0.00630322f, 0.00269270f, 
    0.01472738f, -0.03438016f, -0.00926577f, 0.02518069f, 0.02470445f, -0.04197589f, 0.01660554f, -0.04056671f, 
    -0.03230669f, 0.00464116f, -0.00687689f, 0.01717523f, -0.02398061f, -0.01659809f, -0.00756340f, -0.02651893f, 
    -0.00604455f, 0.02816187f, -0.00707422f, 0.00379621f, -0.00207313f, -0.03558792f, -0.02015938f, -0.01570422f, 
    0.02401485f, 0.00164798f, -0.03348962f, -0.02331675f, 0.02168620f, -0.00609250f, -0.01470514f, 0.02062854f, 
    -0.02926728f, -0.00112212f, -0.02041218f, -0.01246381f, -0.04156315f, -0.00181523f, -0.02454958f, -0.00855366f, 
    0.02863772f, -0.00325786f, 0.00069205f, -0.00363294f, -0.00162871f, -0.00625617f, -0.01938324f, -0.02136420f, 
    -0.03690876f, -0.03519489f, -0.02843169f, -0.01584780f, -0.02331165f, 0.01067207f, -0.03070605f, -0.01193972f, 
    0.01203408f, -0.01049696f, -0.01347941f, -0.01277204f, 0.00006214f, -0.03435373f, 0.02316423f, -0.00121143f, 
    -0.00813313f, -0.03271569f, -0.01884809f, 0.00495571f, -0.01768372f, 0.02225404f, -0.04095201f, 0.01701497f, 
    0.00894507f, 0.00980206f, 0.01885709f, -0.01743183f, -0.00264561f, -0.01306423f, -0.03698650f, -0.00105439f, 
    0.02557215f, -0.01065832f, -0.01570317f, -0.03337124f, -0.01594306f, 0.00251335f, -0.02914631f, -0.02963011f, 
    0.00202284f, -0.02506202f, 0.00780429f, 0.01000223f, -0.03859190f, 0.03124591f, -0.00846440f, 0.02677276f, 
    0.00724925f, 0.02200732f, 0.02773716f, -0.03044703f, -0.01111535f, 0.00474893f, 0.00572037f, 0.02028470f, 
    -0.03855941f, -0.00263343f, 0.02634276f, -0.03474999f, -0.02195871f, -0.04141981f, 0.01424532f, -0.00704138f, 
    -0.02824644f, 0.01504979f, 0.02018156f, 0.01616028f, -0.02547988f, -0.03529467f, -0.02324557f, -0.01617537f, 
    -0.02100159f, 0.01821433f, -0.00335696f, 0.02469457f, 0.02315741f, 0.00129217f, 0.00706432f, -0.03567735f, 
    -0.03234531f, -0.00957688f, 0.00708498f, -0.03961948f, -0.00897439f, 0.01384985f, 0.02165492f, 0.02051478f, 
    -0.02426657f, -0.03308941f, 0.01267640f, 0.01136002f, -0.02523658f, -0.00407728f, -0.02006506f, -0.02303108f, 
    -0.03526917f, 0.02761681f, -0.03369951f, 0.02132744f, 0.01770182f, -0.02863667f, -0.03363721f, 0.00689628f, 
    -0.00971419f, -0.00156839f, 0.00974348f, 0.01258467f, -0.03621085f, -0.03299066f, -0.03190354f, -0.01954888f, 
    0.01943578f, -0.01442625f, -0.02187435f, -0.02227002f, -0.04501523f, -0.03306043f, 0.03003480f, 0.00338148f, 
    -0.01427363f, -0.00225117f, 0.01949410f, -0.03124365f, -0.02399026f, 0.00645706f, -0.02454527f, -0.02537756f, 
    -0.03981233f, 0.00007280f, 0.00149958f, -0.00133140f, -0.01670902f, -0.01896070f, -0.01496392f, -0.01230714f, 
    -0.00105062f, -0.03456906f, -0.00204621f, -0.01808966f, -0.00597377f, -0.02163868f, -0.01092300f, -0.02778268f, 
    0.00711944f, -0.01533593f, 0.03657648f, 0.02678585f, 0.00269272f, 0.01086274f, -0.02344286f, -0.01124456f, 
    0.01044512f, 0.01804308f, 0.01292181f, 0.02050100f, -0.01334933f, -0.00316851f, -0.00330741f, -0.02491447f, 
    0.00372524f, 0.01534448f, -0.01804453f, -0.01628495f, -0.00393769f, 0.02168616f, 0.02519923f, -0.01992949f, 
    -0.00504496f, 0.01942121f, -0.02831174f, 0.03215513f, 0.03088714f, 0.00849623f, 0.02782450f, -0.00297054f, 
    -0.02485644f, 0.03351662f, 0.02033717f, -0.01279594f, -0.02376877f, -0.02373422f, 0.01489831f, 0.02139217f, 
    0.03033128f, -0.02879598f, 0.00373349f, -0.00865662f, -0.02178966f, -0.03376493f, -0.03484207f, -0.04501195f, 
    0.00874037f, -0.00295817f, 0.00435000f, -0.02545880f, 0.03142083f, 0.03813495f, 0.00922145f, 0.00682658f, 
    -0.03553933f, -0.01245456f, -0.02714311f, 0.00730612f, 0.00670941f, 0.02539508f, 0.01170627f, 0.00329854f, 
    0.02295355f, 0.01996891f, -0.01182689f, -0.01056619f, -0.02299646f, 0.02959213f, 0.01589395f, 0.02670148f, 
    -0.04358507f, -0.00447866f, 0.04113745f, -0.02778791f, 0.02925600f, 0.03696136f, -0.02543403f, -0.00241230f, 
    0.02126993f, -0.04795871f, -0.02281180f, -0.02225678f, 0.00304375f, -0.02136144f, -0.00617091f, -0.01103839f, 
    0.00750677f, -0.01609898f, 0.01092193f, -0.02768780f, -0.00733772f, -0.04079843f, 0.00429049f, 0.00109033f, 
    -0.00797574f, 0.00526748f, 0.03397025f, -0.02212386f, -0.00673029f, 0.02657859f, -0.03093040f, -0.01522304f, 
    -0.01599474f, 0.02591089f, -0.02815937f, -0.02833374f, -0.00419575f, 0.00080404f, 0.02460620f, -0.00261192f, 
    -0.01250544f, -0.01626504f, -0.02842731f, 0.00566067f, 0.00469866f, 0.00637259f, 0.00938620f, -0.02592574f, 
    0.00349812f, 0.00698575f, -0.00506711f, 0.02730745f, 0.00912459f, 0.00182328f, 0.02980589f, -0.00798983f, 
    -0.03498420f, 0.02621017f, -0.01755489f, -0.02089088f, -0.00941517f, 0.01397580f, -0.00930797f, -0.00751109f, 
    -0.01680065f, 0.03512566f, 0.01119541f, 0.01192838f, -0.00797143f, 0.02573664f, -0.03822637f, -0.03974354f, 
    -0.03226928f, 0.01530411f, 0.00958692f, -0.04050978f, -0.02102703f, -0.03710673f, -0.03603816f, -0.01414471f, 
    -0.00702737f, -0.02622592f, -0.02325521f, -0.00145242f, -0.02562118f, -0.03876201f, -0.00749199f, 0.00038091f, 
    0.02642369f, -0.02815885f, -0.02159534f, 0.01987109f, -0.01748000f, -0.02528653f, 0.02358663f, -0.02669113f, 
    -0.02533440f, -0.03782375f, -0.02033626f, 0.02226513f, -0.01512362f, -0.01168982f, 0.02435598f, -0.03511478f, 
    0.01243769f, -0.02909533f, 0.02355062f, 0.00592776f, 0.02526191f, -0.02008830f, -0.00967267f, -0.02550368f, 
    -0.00100884f, 0.00471430f, -0.03167576f, -0.01511811f, 0.03114543f, 0.02073964f, 0.00778987f, -0.00888368f, 
    -0.00278775f, -0.02889217f, -0.00586859f, -0.00939842f, -0.03601015f, 0.01449830f, -0.03358632f, -0.03503191f, 
    -0.00496021f, -0.00456874f, -0.01304753f, 0.02425439f, 0.02996594f, -0.02285463f, -0.02380056f, 0.02137827f, 
    -0.02768133f, -0.00912277f, -0.02130340f, -0.00385323f, -0.00968088f, 0.03517175f, -0.01436706f, -0.03003777f, 
    0.00772644f, 0.01275947f, -0.02640255f, 0.03668943f, -0.00385978f, 0.00929391f, -0.03396598f, -0.00973233f, 
    0.00574330f, 0.01691904f, -0.01041760f, -0.00458225f, 0.02893383f, -0.02944003f, 0.02473409f, 0.02429962f, 
    -0.03510866f, -0.00197727f, 0.01791853f, -0.00112210f, 0.00104985f, -0.01226067f, -0.02507370f, 0.00395159f, 
    -0.02815231f, -0.03625965f, 0.02406710f, -0.00038439f, -0.00074026f, 0.03113393f, -0.02900175f, 0.00517945f, 
    0.00521009f, 0.00946360f, -0.00397103f, 0.01543600f, -0.01321430f, -0.00015771f, -0.01457048f, -0.00208191f, 
    -0.02429059f, -0.01997976f, -0.02245980f, -0.01482125f, -0.00039234f, 0.01779345f, -0.03058895f, -0.01103131f, 
    0.02546017f, 0.02063897f, 0.03215646f, -0.00570593f, -0.01613226f, 0.02410941f, -0.01858476f, 0.02213470f, 
    0.00571026f, 0.00338895f, 0.01986906f, -0.03419385f, -0.03700268f, 0.00646621f, -0.01994522f, 0.01013028f, 
    0.02115568f, 0.01767130f, 0.00162343f, -0.00040339f, 0.01898414f, 0.00147091f, 0.01367272f, -0.02430511f, 
    -0.03512279f, 0.01215515f, -0.03011069f, -0.01963517f, -0.03731041f, -0.01385780f, -0.02169898f, -0.00696337f, 
    -0.02207403f, 0.03400404f, -0.02956427f, 0.01196004f, -0.00173770f, -0.02619789f, 0.02677762f, 0.00176041f, 
    -0.03371430f, 0.00151635f, 0.00975220f, -0.03558293f, 0.02503587f, -0.00761239f, -0.02588504f, -0.03931464f, 
    0.01157349f, 0.01183697f, -0.00782229f, 0.02453902f, -0.02662381f, 0.00859166f, 0.02511539f, -0.03938232f, 
    -0.02491279f, -0.00693106f, 0.01751430f, -0.04694857f, 0.01949512f, -0.03631245f, -0.02071755f, 0.02002323f, 
    -0.00787888f, 0.01514012f, 0.00426321f, 0.00236838f, -0.01020638f, -0.01229946f, 0.02029101f, 0.01561448f, 
    0.02671272f, 0.00876580f, 0.01728929f, 0.02617364f, -0.01976419f, -0.01050804f, 0.00606050f, 0.02051136f, 
    0.01114073f, -0.01938053f, -0.03212152f, -0.00567008f, -0.02420010f, -0.00219569f, -0.02330011f, -0.03140689f, 
    0.02310158f, -0.00358454f, -0.02182504f, -0.04127792f, -0.01124395f, 0.00145707f, -0.00207373f, -0.01329801f, 
    -0.02787297f, 0.01124827f, 0.02062798f, 0.00587631f, 0.01472876f, 0.03455337f, -0.00133990f, 0.02852529f, 
    -0.00530001f, -0.02871221f, -0.01390673f, 0.00375932f, 0.01536727f, -0.03741806f, -0.01184945f, -0.03273243f, 
    -0.02359282f, -0.00452832f, -0.01185408f, -0.00650700f, -0.03576833f, 0.00222296f, -0.03798407f, -0.00387675f, 
    -0.02441194f, -0.01830634f, 0.02035955f, -0.03158646f, -0.00061780f, -0.00132782f, -0.03103532f, -0.03149221f, 
    -0.02314568f, 0.03289558f, -0.03790034f, 0.02577642f, -0.00306564f, -0.03529439f, -0.02743710f, -0.00463139f, 
    -0.02355751f, 0.00608100f, 0.01127298f, 0.00726537f, 0.02876055f, 0.01550769f, -0.04244375f, -0.04055877f, 
    0.01568042f, -0.00158533f, 0.01924492f, 0.02545772f, -0.00315432f, 0.02270796f, 0.03634727f, -0.00968169f, 
    -0.00478831f, 0.01827157f, -0.01389025f, 0.00709437f, -0.00480467f, 0.01057537f, -0.02120934f, -0.01353497f, 
    0.03037187f, -0.03281246f, -0.04285508f, 0.00772233f, 0.04105186f, -0.00255371f, 0.01956119f, 0.01192465f, 
    -0.04120144f, 0.01114307f, -0.00891008f, 0.00969046f, -0.00672821f, 0.03117426f, 0.00149604f, 0.01805720f, 
    0.00863100f, 0.01100575f, -0.01656580f, 0.02778117f, 0.02341615f, -0.01995209f, -0.00933993f, 0.01968297f, 
    -0.00821941f, -0.01056282f, 0.02507722f, -0.00485382f, -0.02159167f, 0.02421106f, 0.00072183f, 0.02354385f, 
    0.01397452f, 0.01134072f, -0.01987856f, -0.02421093f, 0.00326563f, -0.00156614f, 0.01763734f, -0.00703237f, 
    0.02846651f, -0.01740880f, 0.01499775f, -0.01287096f, -0.00739592f, 0.03002198f, 0.03096294f, 0.02704701f, 
    0.00633628f, -0.01676163f, -0.01505556f, -0.02286994f, -0.01544204f, -0.04638020f, -0.00430209f, 0.01914571f, 
    0.00773100f, -0.03060326f, 0.00345873f, 0.00758730f, 0.02931324f, 0.02576661f, -0.01057167f, -0.01314185f, 
    -0.03386034f, 0.02207164f, -0.03021264f, 0.00655696f, 0.02564984f, -0.00270894f, 0.01977095f, -0.01990912f, 
    0.00727716f, -0.02920458f, -0.01598988f, -0.00607812f, 0.00907324f, -0.02553401f, 0.02079056f, -0.04383899f, 
    -0.00711704f, 0.00418694f, 0.03003935f, 0.00628472f, 0.01942753f, 0.01798154f, 0.00266181f, 0.00476952f, 
    0.01539271f, -0.00772470f, 0.00978839f, -0.01193021f, -0.03043990f, 0.03052611f, 0.00150316f, -0.03772091f, 
    0.01069092f, 0.01723927f, 0.02938273f, -0.00857955f, 0.02353790f, -0.03136733f, -0.01591079f, 0.00278612f, 
    -0.02836969f, 0.01974610f, 0.00485707f, -0.00525886f, 0.03837609f, 0.02637949f, -0.03532928f, -0.03869824f, 
    0.02512851f, 0.00922402f, 0.00343445f, 0.00591464f, 0.03097061f, -0.01666961f, -0.00657604f, -0.00715039f, 
    -0.00365946f, -0.00185964f, -0.03095020f, -0.03352674f, 0.01063538f, 0.03445606f, -0.00160987f, 0.01964527f, 
    0.01815901f, 0.00610988f, -0.01898353f, 0.00790892f, -0.01388095f, -0.01712399f, 0.00406446f, 0.02002316f, 
    -0.00869810f, -0.00688201f, -0.02289030f, 0.02701167f, -0.01004348f, -0.03213916f, 0.01032908f, -0.03405221f, 
    -0.03691007f, 0.03521134f, 0.02835272f, -0.03215402f, 0.01547544f, 0.02457551f, -0.03631637f, -0.00781703f, 
    -0.03924187f, -0.01377569f, -0.02544173f, -0.02632142f, 0.02270905f, 0.03293441f, -0.00207357f, -0.03723987f, 
    -0.01725701f, 0.00700142f, 0.01262710f, -0.01178540f, -0.03006158f, -0.01028499f, -0.01550026f, 0.00393239f, 
    -0.04411238f, -0.02504984f, -0.00042939f, -0.02504118f, 0.01027791f, 0.00237054f, -0.00431934f, 0.02305659f, 
    0.01165088f, 0.01986538f, -0.00992035f, -0.03880999f, 0.02425491f, 0.00995888f, -0.01919851f, -0.02819873f, 
    -0.01789113f, 0.00903058f, -0.03780851f, -0.02250312f, -0.03047284f, 0.00651380f, 0.04129925f, 0.01273287f, 
    0.00230691f, -0.03137639f, 0.01033727f, 0.00783869f, -0.01610236f, -0.04186701f, -0.03900647f, -0.01295690f, 
    0.02772141f, 0.01876574f, 0.03218865f, -0.02873454f, 0.01356114f, -0.03128452f, -0.00697221f, -0.03666310f, 
    0.00946116f, 0.00339561f, -0.02676172f, -0.00189011f, -0.00959786f, -0.02294625f, 0.02566668f, -0.00480033f, 
    -0.00016516f, 0.03551818f, 0.00500105f, 0.02180832f, 0.01046344f, -0.03230354f, -0.00925629f, -0.00096664f, 
    -0.02575513f, -0.03337515f, -0.03156956f, 0.00859446f, -0.02843485f, -0.02941261f, 0.00905556f, 0.02771864f, 
    -0.01969395f, -0.00308079f, -0.03065315f, -0.03479151f, 0.03199549f, 0.00302773f, 0.02517779f, -0.03758907f, 
    -0.00869039f, -0.01904001f, -0.02662790f, 0.02647186f, -0.03667367f, -0.00552341f, 0.02995355f, -0.03111601f, 
    -0.03815352f, 0.03304146f, -0.00437789f, 0.01699198f, 0.00131355f, -0.00917998f, -0.00027339f, -0.02506552f, 
    0.00559126f, 0.01839300f, -0.03829115f, -0.01262591f, -0.00183125f, 0.01930552f, 0.00079211f, -0.01235864f, 
    -0.02260442f, 0.01365456f, 0.00189117f, 0.00250369f, 0.02361271f, -0.01567233f, 0.00696934f, 0.01410624f, 
    0.00097564f, 0.03118127f, -0.02526674f, -0.00257101f, -0.00505357f, 0.01261079f, 0.02285413f, -0.01828032f, 
    0.00471346f, -0.00997706f, -0.02635457f, -0.00122539f, 0.01003533f, -0.01184587f, 0.02484846f, -0.01894163f, 
    -0.01577882f, -0.03776965f, 0.02963140f, -0.02974531f, -0.01554908f, 0.02031200f, -0.03440044f, 0.00659162f, 
    0.00192794f, -0.00629136f, -0.00598504f, -0.02292026f, -0.02889912f, 0.01082041f, -0.02769741f, -0.01903792f, 
    0.24638362f, -0.05222441f, 0.14749755f, -0.02976020f, -0.00202713f, -0.03600125f, 0.06985842f, 0.12812406f, 
    0.03715614f, 0.06423499f, 0.02899844f, 0.08514392f, -0.06951826f, -0.15150155f, 0.04912384f, 0.18743120f, 
    -0.06746492f, 0.01392113f, 0.03068338f, -0.00678525f, -0.03725146f, 0.07222042f, 0.09734546f, -0.01752787f, 
    0.15248004f, 0.06722743f, -0.04815445f, 0.09665020f, -0.07137899f, -0.01400753f, -0.02723925f, 0.05257144f, 
    -0.03188399f, -0.05379608f, -0.02826026f, 0.10678971f, -0.09526195f, 0.03413940f, 0.06658738f, -0.10892610f, 
    -0.01820793f, 0.13577351f, 0.02669512f, -0.05405552f, 0.06979096f, 0.06269126f, 0.01289027f, 0.14255907f, 
    -0.03682299f, -0.07433324f, -0.17113918f, 0.26536423f, 0.05370766f, 0.07520797f, -0.07446357f, -0.03420125f, 
    -0.00906195f, 0.09128752f, 0.01675476f, -0.08479356f, -0.14637467f, -0.13930488f, 0.02018234f, 0.29051766f, 
    0.11687975f, 0.01316334f, -0.08370265f, -0.01554614f, -0.03962133f, 0.05444134f, -0.00640482f, 0.02799666f, 
    0.01797489f, 0.05354144f, 0.15038995f, 0.20245165f, 0.08441423f, 0.00855323f, 0.11574626f, -0.01784219f, 
    -0.04788327f, -0.02011687f, 0.10207077f, 0.03748071f, -0.13890095f, -0.10329261f, 0.13453178f, 0.12572242f, 
    -0.15430024f, -0.11224486f, 0.03401067f, 0.08115168f, -0.11002378f, -0.00376410f, 0.13616253f, 0.01238227f, 
    -0.21298261f, 0.04518096f, -0.04082784f, 0.00856690f, 0.14679882f, 0.08850767f, -0.07492815f, 0.10953080f, 
    -0.07693921f, -0.02275422f, -0.05418034f, 0.01338321f, -0.09510307f, 0.05451801f, 0.03188525f, -0.18058015f, 
    0.13442305f, 0.01231911f, -0.02501016f, 0.01911025f, 0.06880202f, 0.11424758f, 0.00410554f, 0.00427641f, 
    -0.08612868f, 0.01628456f, -0.09177195f, 0.23006356f, -0.05084680f, 0.06652374f, 0.04689502f, 0.00337015f, 
    0.04030302f, 0.03655622f, 0.00737380f, 0.06022660f, -0.05881470f, -0.10315064f, -0.01608180f, -0.02312827f, 
    0.08617300f, -0.02484837f, -0.00090422f, -0.01028326f, 0.02812509f, 0.00168321f, -0.05759486f, 0.10657375f, 
    -0.03038000f, 0.08857277f, 0.00476598f, 0.30280301f, 0.02901334f, 0.00985085f, 0.03771016f, -0.10037097f, 
    -0.03493901f, -0.05099446f, 0.04185605f, 0.00025107f, 0.18309510f, 0.06723868f, -0.08697683f, 0.06652526f, 
    0.01465682f, -0.01922085f, 0.00572530f, -0.04729176f, 0.01953014f, 0.02999761f, 0.02016520f, 0.00695273f, 
    0.20825607f, 0.02896185f, 0.02664764f, 0.11955636f, 0.08106938f, 0.01619060f, 0.06280737f, 0.03173579f, 
    0.07198383f, -0.11950460f, 0.02870862f, 0.07084709f, 0.01551189f, 0.02604013f, 0.09165791f, -0.14386684f, 
    0.04495055f, 0.04717833f, 0.05743309f, 0.03573279f, 0.03436068f, -0.01594047f, 0.02114501f, 0.01921769f, 
    -0.30493367f, 0.10674177f, -0.05982916f, -0.07582709f, 0.05519983f, 0.08943067f, 0.02948957f, -0.00499172f, 
    -0.00855661f, -0.01033418f, 0.05470341f, 0.04858274f, -0.01251039f, 0.09454051f, 0.05321330f, 0.02340994f, 
    0.02896155f, 0.08109920f, -0.00228965f, -0.01922488f, 0.01266551f, -0.05273094f, 0.07785584f, 0.07311785f, 
    0.02557168f, -0.08867320f, 0.04793752f, 0.15702775f, 0.02931906f, 0.03636897f, -0.05029290f, 0.01277778f, 
    0.00632534f, -0.03952261f, -0.06434979f, -0.08470384f, -0.06358775f, -0.04432185f, -0.09794576f, -0.05564748f, 
    0.08038745f, -0.08396533f, -0.09962197f, 0.10527837f, 0.06755041f, -0.00729899f, 0.01759678f, 0.03446723f, 
    -0.13029918f, 0.00535839f, -0.16880456f, -0.03923830f, -0.00463890f, 0.04918420f, -0.10776591f, 0.01699011f, 
    0.09775284f, -0.00863189f, 0.04909980f, -0.03636979f, 0.04506706f, -0.07229237f, -0.09479754f, -0.09216953f, 
    0.14039010f, 0.09641829f, -0.01069742f, -0.01263562f, 0.07950871f, 0.01235730f, -0.00561441f, -0.03718918f, 
    -0.02519271f, -0.07960895f, 0.21060000f, -0.05747418f, 0.03492476f, 0.05442850f, 0.03249411f, 0.00257270f, 
    0.02864195f, -0.05371244f, 0.08185770f, -0.00128010f, -0.34103465f, 0.19281593f, 0.01093663f, 0.04756778f, 
    0.02253303f, 0.09673623f, 0.08105920f, -0.04584889f, 0.16623722f, -0.01939440f, 0.15747379f, -0.06722092f, 
    -0.03307893f, 0.10404236f, -0.00186631f, 0.08435122f, 0.03018151f, 0.07660428f, 0.02676302f, -0.01315770f, 
    -0.10569056f, 0.09784333f, 0.10835154f, 0.06779652f, -0.08604041f, 0.04042520f, -0.09693905f, -0.02016103f, 
    -0.01448584f, 0.09049672f, 0.05128919f, 0.06463205f, 0.11616401f, -0.01442758f, 0.06700342f, 0.04613505f, 
    0.00176608f, -0.16900975f, 0.08255310f, -0.00615920f, -0.01720867f, -0.00758471f, -0.04929953f, -0.02797950f, 
    0.01881409f, -0.05439520f, 0.11264028f, -0.09262187f, -0.02138517f, 0.00449066f, -0.16695757f, -0.11112023f, 
    0.09819825f, 0.12466748f, 0.03028864f, 0.02829805f, 0.09580062f, -0.01306529f, 0.11875259f, 0.00261092f, 
    0.31743765f, 0.14477240f, -0.13203175f, 0.10092758f, 0.00107817f, -0.04314421f, -0.02364823f, -0.08766010f, 
    0.17091045f, 0.07923912f, 0.05085120f, 0.04100474f, -0.25616449f, -0.05077867f, -0.06985489f, 0.27405572f, 
    0.03681622f, -0.01692543f, -0.01220565f, 0.00412081f, 0.10567458f, 0.04564343f, 0.10542081f, -0.04643099f, 
    0.09777325f, -0.10602020f, 0.09539865f, -0.21506287f, -0.04633753f, -0.06909840f, 0.09990460f, -0.04659230f, 
    -0.01817151f, 0.03626645f, 0.11288848f, 0.03728357f, -0.22152525f, 0.04593613f, -0.05994437f, -0.07390068f, 
    -0.07479207f, 0.04827616f, 0.08097743f, -0.02231285f, -0.10034725f, -0.01790289f, -0.03518957f, -0.06677467f, 
    0.21657726f, 0.15153529f, 0.01033296f, 0.09199475f, 0.02741998f, 0.10994394f, 0.00577377f, 0.11635168f, 
    0.09055896f, 0.04160866f, 0.00863959f, 0.04140812f, -0.20920701f, -0.15718196f, -0.07326588f, -0.15873563f, 
    0.05264082f, 0.04061425f, -0.05851306f, -0.05982580f, 0.08441547f, 0.03977079f, 0.10769881f, -0.00467396f, 
    -0.06044862f, 0.18151137f, 0.11240908f, 0.00004139f, -0.06222810f, 0.00835982f, 0.03986783f, 0.07820363f, 
    0.00718752f, 0.01009224f, -0.05531504f, 0.11907758f, 0.01383487f, 0.02188336f, 0.20389010f, -0.09690566f, 
    0.02287038f, 0.00256407f, 0.03027827f, 0.04627100f, 0.09228035f, 0.10670486f, -0.08259923f, -0.07249144f, 
    -0.05541056f, 0.12299125f, 0.04083439f, -0.18140827f, -0.02961344f, 0.04329097f, 0.06761542f, 0.06469025f, 
    0.02562762f, -0.00351208f, 0.04646301f, -0.00063892f, -0.05927434f, 0.19745515f, 0.16618539f, -0.08075901f, 
    0.12465066f, 0.02705913f, -0.05889798f, -0.03291988f, -0.05434937f, 0.01038525f, -0.02426257f, -0.04183639f, 
    -0.12447239f, 0.08176871f, -0.00977640f, 0.11216831f, -0.05442124f, 0.06075249f, 0.04916134f, 0.06291410f, 
    0.02526810f, 0.11056577f, 0.08953298f, 0.11708598f, 0.03886816f, 0.13131391f, -0.02011260f, -0.16471210f, 
    0.07174930f, -0.00937380f, 0.03822027f, 0.06334653f, 0.01431615f, -0.00272731f, -0.01633542f, -0.00497117f, 
    -0.10301586f, 0.06601984f, -0.02737859f, 0.03534495f, 0.09371960f, 0.02946559f, 0.03501595f, -0.09704305f, 
    -0.02968365f, 0.02601498f, 0.03780087f, -0.05718715f, -0.28087929f, 0.02339954f, 0.08274118f, -0.23245145f, 
    -0.01058196f, -0.00474766f, -0.00642657f, -0.04946398f, -0.01606561f, 0.01476664f, 0.07907868f, -0.07122930f, 
    -0.24155016f, -0.05047492f, -0.03059273f, -0.10954411f, 0.10226754f, -0.03408763f, -0.05184452f, -0.00949596f, 
    0.11301199f, 0.08661674f, -0.00610760f, 0.08173779f, 0.13212983f, 0.03544876f, -0.14745462f, 0.13578455f, 
    -0.03585972f, 0.07136436f, -0.01430331f, 0.05378515f, -0.06326237f, 0.00181191f, -0.04589180f, 0.05681402f, 
    -0.14013483f, -0.06838659f, 0.12267853f, 0.02986623f, 0.06564999f, -0.01118048f, 0.17011024f, 0.00134913f, 
    0.03406376f, 0.05558136f, 0.00781578f, 0.05259348f, 0.04683361f, 0.03154168f, 0.11975814f, -0.11390413f, 
    0.07320414f, 0.05448150f, -0.00200274f, 0.02666628f, 0.03343662f, 0.09642016f, -0.01113474f, -0.06911666f, 
    -0.14218253f, -0.02705683f, -0.03704769f, -0.08323935f, 0.06598395f, -0.14812253f, -0.10641994f, -0.00369996f, 
    0.01161735f, 0.04219348f, 0.00801976f, 0.06837023f, 0.08418994f, 0.05881311f, 0.01268413f, 0.16413622f, 
    -0.06251652f, -0.12178245f, 0.06116381f, -0.05422124f, 0.11233033f, -0.08575770f, 0.07844341f, -0.00591022f, 
    0.09686499f, 0.03808839f, 0.02972704f, 0.00886709f, -0.03108349f, -0.02745654f, 0.06241929f, -0.05092488f, 
    0.06558505f, -0.10850286f, -0.01738938f, 0.02240536f, -0.04786509f, 0.01511443f, 0.07278076f, -0.01922898f, 
    0.02614564f, -0.15076876f, 0.08592922f, -0.01560384f, 0.01694089f, -0.07473991f, 0.00186813f, 0.04243302f, 
    0.15216748f, 0.02655228f, -0.01320401f, 0.15859988f, 0.00410744f, 0.05208656f, -0.00672753f, 0.02210075f, 
    -0.01299492f, -0.03374293f, 0.02521216f, -0.01210178f, -0.08484741f, -0.00546431f, 0.14181028f, -0.13916799f, 
    0.05015345f, -0.02826169f, 0.17505631f, -0.01406526f, -0.01446234f, 0.00458574f, -0.06394974f, -0.07350121f, 
    0.00076993f, 0.03301022f, 0.04832590f, 0.14352688f, -0.14131537f, 0.04813976f, 0.11382882f, 0.02801395f, 
    0.05112573f, 0.07878055f, 0.02184338f, 0.08014757f, 0.04933987f, -0.02023593f, 0.03921754f, -0.14678921f, 
    0.00912767f, -0.08464621f, -0.03872777f, 0.08309335f, -0.00866748f, -0.01062309f, 0.09835431f, 0.00959304f, 
    0.20473860f, 0.11730424f, -0.20464563f, 0.19751386f, -0.02662241f, 0.00570073f, -0.10751110f, -0.00921335f, 
    -0.04962908f, 0.05917895f, -0.03653705f, 0.00948446f, -0.15367277f, 0.17303769f, -0.06601003f, 0.29211593f, 
    -0.02343924f, 0.00698179f, -0.01796676f, 0.09891107f, 0.02743195f, 0.01046749f, 0.01060650f, -0.08454601f, 
    0.06543426f, -0.02100594f, -0.01997374f, -0.02430199f, -0.07272315f, 0.05605269f, 0.08330611f, 0.11137573f, 
    -0.00113298f, -0.06087373f, -0.01679280f, 0.08330783f, -0.18734592f, 0.07644723f, -0.03913165f, -0.08564702f, 
    -0.03496597f, -0.00000674f, -0.06388428f, 0.04281957f, 0.04694537f, 0.02612524f, 0.13923267f, 0.00450801f, 
    -0.13233727f, -0.05028963f, -0.10602591f, 0.11090116f, 0.06030465f, -0.04618780f, 0.03859011f, -0.01917282f, 
    0.03767086f, 0.12913465f, -0.01454750f, 0.03630032f, -0.06290852f, -0.12144422f, -0.12580401f, 0.07535440f, 
    0.09717266f, 0.01281222f, -0.03476422f, 0.14485648f, 0.08112013f, -0.04138483f, -0.06619206f, -0.08362669f, 
    0.12892650f, 0.13339233f, 0.03659040f, 0.09827922f, 0.04284346f, 0.04397304f, -0.03625029f, -0.13542730f, 
    0.09871835f, -0.00463329f, 0.00182112f, 0.00181345f, -0.14233735f, -0.08151521f, 0.12040687f, -0.02948937f, 
    -0.14729165f, 0.11950259f, 0.03916267f, -0.02738414f, -0.02893230f, 0.05100732f, -0.04761284f, 0.00647466f, 
    0.10928279f, -0.06542470f, 0.22493939f, 0.19781309f, -0.02984270f, -0.09345400f, 0.06151335f, 0.02005348f, 
    0.02858711f, -0.04451175f, -0.01165742f, 0.02405611f, 0.09851418f, 0.04321910f, 0.06090031f, 0.00850466f, 
    0.01048751f, 0.00324093f, -0.01675178f, -0.00689397f, 0.07657854f, 0.09481115f, 0.02490805f, -0.09511228f, 
    -0.27340648f, -0.00434916f, 0.08960622f, 0.10729704f, 0.03023432f, 0.04646429f, -0.07008249f, 0.02459767f, 
    -0.03661884f, -0.01510754f, 0.03227543f, 0.04550143f, 0.32987446f, 0.04146736f, -0.07263349f, -0.06876189f, 
    -0.11356528f, 0.02064185f, -0.02672955f, 0.04115639f, -0.06154795f, -0.03510573f, 0.03081648f, -0.01454420f, 
    0.20397064f, 0.22166575f, 0.20565599f, -0.05791035f, 0.04175511f, -0.01016077f, -0.01919555f, -0.00894476f, 
    0.01409304f, 0.06847353f, 0.04467132f, -0.10110001f, 0.10206162f, -0.10888562f, -0.05093474f, 0.03962661f, 
    -0.05226879f, -0.03039983f, 0.01618683f, -0.02017344f, 0.09542907f, -0.09250493f, -0.03220266f, 0.05083856f, 
    -0.04485220f, -0.03346191f, -0.19256660f, 0.09018789f, 0.05700818f, 0.12778716f, 0.00698376f, 0.09660787f, 
    0.05590787f, 0.02213864f, 0.00613049f, 0.07159503f, -0.05667001f, -0.05425461f, -0.14543045f, 0.02449782f, 
    0.00841104f, -0.02298888f, 0.01555610f, -0.01084369f, 0.03714551f, -0.05030052f, 0.07183956f, 0.05118901f, 
    -0.20533128f, 0.22404498f, -0.08116113f, 0.05391994f, 0.00590819f, -0.04210005f, 0.05869412f, 0.05380720f, 
    0.09439848f, 0.01978233f, -0.05195382f, -0.05477770f, -0.02492719f, 0.19788867f, 0.04303322f, -0.06867453f, 
    -0.12048303f, 0.04366021f, -0.00109219f, 0.09258447f, 0.05946472f, 0.02842529f, 0.01400422f, -0.02659884f, 
    -0.07267538f, 0.11406927f, -0.15002537f, 0.01559722f, -0.03132966f, -0.04506295f, 0.05048782f, -0.01295915f, 
    0.01014406f, -0.03258290f, 0.04237771f, 0.01243385f, 0.03081858f, -0.11404672f, 0.00099452f, 0.04358511f, 
    0.07915641f, 0.06722517f, -0.03362964f, -0.00338088f, -0.08800001f, 0.01491317f, 0.01916736f, -0.10218859f, 
    0.35376605f, 0.08220512f, -0.00152446f, -0.10688879f, -0.04361578f, 0.04529560f, 0.03401952f, -0.02876399f, 
    -0.12872492f, 0.02148231f, 0.02974762f, 0.03639137f, 0.06287184f, -0.05210609f, 0.05037175f, 0.00339975f, 
    -0.10968139f, -0.08020153f, 0.02485445f, 0.12743302f, -0.05579192f, 0.02575064f, 0.01802849f, -0.09233376f, 
    0.28779188f, 0.16993546f, 0.11861524f, 0.03498427f, -0.04337542f, -0.10617693f, 0.02476678f, 0.08625666f, 
    -0.07395127f, 0.15783423f, 0.09131923f, 0.00929561f, 0.05699890f, 0.02883042f, 0.07508364f, 0.05663882f, 
    -0.08880198f, -0.01005761f, 0.12314667f, 0.04622743f, -0.09583396f, -0.01660447f, -0.00560942f, 0.03586975f, 
    0.28915492f, 0.09740144f, 0.16950372f, -0.03808632f, -0.01915162f, -0.07979318f, -0.01992906f, 0.01580278f, 
    0.04974264f, 0.00801132f, 0.04595975f, -0.11496542f, 0.15836570f, 0.14180782f, 0.16178299f, -0.01599794f, 
    -0.08051012f, -0.05722980f, 0.00543071f, 0.04649454f, 0.00587419f, 0.01412411f, 0.06910840f, 0.12797485f, 
    0.07348862f, -0.10858568f, -0.08487384f, 0.07207810f, -0.01697421f, 0.04882838f, 0.03288599f, -0.01028914f, 
    0.02519760f, -0.02304626f, 0.07551517f, -0.06967087f, -0.15437980f, -0.04891871f, 0.02820821f, 0.05941571f, 
    0.04608977f, 0.05730926f, 0.02965819f, 0.04270633f, 0.07218287f, -0.07946972f, 0.04364962f, 0.01403636f, 
    -0.07077526f, -0.08664124f, -0.14498599f, -0.03724898f, 0.09881870f, 0.05220957f, 0.03513159f, 0.03352240f, 
    0.09377488f, 0.01225091f, 0.03210637f, -0.04488972f, 0.05343620f, 0.00321191f, 0.09060168f, 0.07982343f, 
    -0.03690989f, -0.03478787f, 0.05499593f, -0.11147302f, 0.04216783f, 0.00684085f, -0.09410783f, -0.04451371f, 
    0.01705028f, -0.02133416f, -0.00245912f, 0.02523410f, -0.01827506f, 0.05921219f, -0.03156823f, -0.00454830f, 
    -0.11994018f, 0.06825685f, 0.01704329f, -0.08301253f, -0.10145870f, 0.01345586f, -0.17920227f, 0.02189703f, 
    0.08104744f, -0.05133905f, -0.02045443f, -0.00962933f, -0.10094079f, -0.03709247f, -0.07353456f, 0.10256762f, 
    -0.07161584f, -0.19058233f, -0.08455321f, 0.04903051f, -0.02795367f, -0.02077730f, 0.01879401f, -0.02427114f, 
    -0.00204047f, -0.04246016f, -0.05327795f, -0.00376312f, 0.04840853f, -0.12025953f, -0.12089344f, 0.01135657f, 
    -0.00255568f, -0.00673749f, -0.07427845f, 0.04070998f, -0.01685227f, 0.06852694f, -0.07224417f, 0.02411791f, 
    0.17912903f, 0.04294052f, -0.05511819f, -0.00539588f, -0.05824442f, 0.01645940f, -0.03485594f, 0.02104537f, 
    0.07716540f, -0.00401590f, -0.00590097f, 0.03983559f, -0.02832552f, -0.16215524f, -0.06282672f, 0.00113586f, 
    -0.07584219f, -0.04855101f, 0.04728857f, 0.05930383f, -0.04674788f, 0.00778813f, -0.02233930f, -0.02857124f, 
    -0.18749498f, -0.13504158f, -0.16346924f, 0.03737281f, 0.01585556f, 0.04037346f, 0.07354508f, -0.00709653f, 
    -0.04416961f, -0.08501422f, -0.08168440f, 0.03398986f, 0.13437961f, -0.05562780f, 0.04707505f, 0.02974327f, 
    0.02489090f, 0.01390386f, 0.02882166f, -0.01737406f, 0.01700025f, 0.06792273f, -0.08987039f, -0.00822550f, 
    0.17798969f, 0.04904377f, -0.09027904f, 0.00867021f, -0.08321998f, 0.01712365f, 0.01949971f, 0.17635296f, 
    0.14743091f, -0.03048023f, -0.05280662f, -0.04457896f, -0.06516922f, 0.04498386f, 0.18329886f, 0.00517376f, 
    0.05627540f, 0.10761981f, 0.04174853f, 0.05000300f, -0.02037262f, 0.05700899f, 0.01491085f, -0.00017574f, 
    0.13998650f, -0.31647089f, 0.03579054f, 0.00773306f, -0.02618247f, -0.05388941f, 0.02272462f, 0.06210231f, 
    0.08373825f, 0.03916467f, 0.02461437f, -0.01480695f, -0.11641562f, -0.06595019f, 0.06213214f, 0.07953633f, 
    -0.05390433f, -0.00410001f, 0.03067141f, -0.15565772f, -0.10765588f, -0.02024784f, -0.01860498f, 0.00140548f, 
    0.16911948f, 0.04167278f, -0.19380379f, 0.04343902f, 0.05124002f, 0.04445921f, -0.03071203f, -0.06674407f, 
    -0.02533056f, 0.03079353f, 0.04169450f, -0.12771869f, 0.19530600f, -0.06846841f, -0.03787835f, 0.04865805f, 
    0.00039765f, 0.01784800f, -0.05216022f, -0.02090778f, -0.00780382f, -0.03281978f, -0.01367925f, 0.03213510f, 
    -0.04484352f, -0.03076636f, 0.06170208f, 0.06883451f, 0.08572491f, 0.01551745f, 0.04447096f, -0.05110204f, 
    -0.02653239f, -0.13264027f, -0.01358572f, 0.01673399f, 0.04379547f, -0.04422360f, 0.13452810f, 0.05628958f, 
    0.03521683f, -0.00766718f, -0.02060089f, 0.03209930f, -0.05515825f, 0.04206393f, -0.01197594f, 0.05621003f, 
    0.06366929f, -0.23299745f, 0.20488137f, 0.13183203f, -0.04122521f, 0.05553234f, -0.05902850f, 0.01625104f, 
    0.00529684f, 0.06083516f, 0.02889519f, -0.05960654f, 0.56168944f, 0.11677080f, -0.07000642f, 0.14897618f, 
    -0.11081702f, -0.03131205f, -0.08452850f, 0.05665191f, -0.02426410f, -0.05855203f, 0.05445467f, 0.14660107f, 
    -0.13868552f, 0.30166963f, 0.03773226f, -0.04458752f, -0.05055143f, -0.02088977f, -0.01120146f, -0.00875905f, 
    -0.00551409f, 0.04363790f, 0.05634107f, -0.00600699f, 0.04624987f, 0.02121974f, -0.12993029f, 0.04483574f, 
    0.12658110f, 0.03631745f, 0.02573352f, 0.03771234f, -0.02957671f, -0.09024727f, 0.19117011f, -0.03558455f, 
    -0.11912192f, -0.10908378f, -0.11178113f, 0.00924881f, 0.11475683f, 0.13030204f, -0.00170731f, 0.03905925f, 
    0.04382874f, 0.06647355f, 0.05160598f, -0.00319669f, -0.06079074f, -0.17290530f, -0.00431702f, 0.08525138f, 
    0.01161074f, -0.00284637f, -0.01592849f, 0.01775628f, 0.00988244f, 0.03234441f, 0.00389840f, -0.02446800f, 
    -0.09813201f, 0.00982370f, 0.00316171f, -0.02739868f, 0.06154642f, -0.03786404f, 0.01285985f, 0.00047699f, 
    -0.09382439f, -0.14323185f, -0.05917135f, 0.06544240f, -0.10248950f, 0.10906983f, 0.19759794f, -0.00348961f, 
    -0.04673569f, 0.01390930f, 0.04336764f, -0.07495568f, 0.00262615f, 0.12654911f, 0.03868597f, 0.01460080f, 
    0.12232618f, 0.12583952f, 0.16888900f, 0.07156532f, 0.05923253f, 0.05831609f, 0.02361799f, -0.08351264f, 
    0.09429191f, 0.05165787f, 0.00359532f, 0.17574200f, 0.39731240f, -0.09817503f, 0.13736503f, -0.02207248f, 
    -0.07094782f, -0.05582213f, -0.04737787f, 0.09869342f, -0.02012907f, -0.01236936f, 0.01275801f, 0.08666461f, 
    0.29410687f, -0.18800032f, 0.02653345f, 0.06458340f, -0.04245643f, 0.09194220f, -0.01973841f, 0.07342821f, 
    0.06489622f, 0.03721718f, 0.01715221f, -0.01429148f, -0.01113142f, 0.08579209f, 0.09833833f, -0.12308272f, 
    -0.04727607f, 0.02914272f, -0.07787225f, 0.04793823f, 0.03788606f, 0.04135567f, -0.08320705f, 0.01351288f, 
    -0.04725317f, 0.14570414f, 0.16643378f, -0.01161089f, 0.11321034f, 0.06352875f, 0.00943878f, 0.07112164f, 
    -0.01556641f, -0.04544650f, 0.04704956f, -0.00143261f, -0.09621955f, -0.02689623f, 0.14565054f, 0.00452134f, 
    -0.07603336f, 0.03220118f, -0.04210963f, 0.05521890f, -0.03825110f, -0.02616763f, 0.01485416f, -0.01058539f, 
    0.03072431f, -0.30256268f, -0.11058570f, 0.08845313f, 0.01564800f, 0.04568498f, 0.05974391f, 0.05754969f, 
    0.00013992f, 0.02033970f, -0.08199041f, -0.10222151f, 0.14271094f, -0.04103554f, 0.23017715f, 0.05772776f, 
    -0.15440448f, -0.06917927f, 0.01062354f, 0.00234068f, -0.07299995f, 0.10502130f, 0.11034120f, 0.11334471f, 
    0.18572693f, 0.08359139f, 0.10493451f, -0.11027455f, -0.11915030f, 0.01551898f, 0.06421337f, -0.06941164f, 
    0.04530026f, 0.03533005f, -0.01681058f, 0.00640198f, -0.14775723f, 0.02324562f, 0.00416004f, 0.02878614f, 
    0.12820138f, -0.00021498f, 0.01228297f, 0.01430684f, 0.03152983f, -0.06089243f, -0.02276190f, -0.02159775f, 
    0.25143522f, 0.24029601f, 0.15882294f, -0.12454434f, -0.04657087f, -0.02084848f, 0.08705366f, 0.04012368f, 
    -0.01478997f, 0.05187236f, 0.00697104f, 0.03184979f, 0.18454991f, -0.06372099f, 0.26911995f, -0.15386222f, 
    0.04849081f, 0.02163310f, 0.03724533f, -0.07492376f, -0.02019555f, 0.07464581f, -0.00281530f, 0.05461794f, 
    0.11533614f, 0.17167562f, 0.10977630f, 0.09721434f, -0.07121415f, 0.02341932f, 0.02200464f, 0.05606808f, 
    0.02508119f, 0.02706919f, 0.01622400f, 0.00689395f, -0.13823375f, 0.04910336f, -0.04260162f, 0.07379100f, 
    -0.02255017f, -0.10101900f, -0.12931956f, 0.05277905f, 0.04499658f, 0.05181555f, -0.00204948f, 0.05619005f, 
    -0.11286934f, -0.07296576f, -0.15013665f, 0.10163931f, 0.09851347f, 0.00948028f, 0.04375359f, 0.07182196f, 
    0.10769443f, -0.02901509f, -0.07918821f, 0.02957468f, 0.00106281f, -0.17579450f, -0.12432757f, 0.00103341f, 
    0.03564543f, -0.14235565f, -0.10529529f, 0.02886867f, 0.02226724f, 0.10994341f, 0.06267561f, -0.02201702f, 
    -0.10088048f, -0.11846581f, 0.00520724f, -0.08029287f, 0.05122256f, -0.02199563f, 0.07327354f, 0.13013650f, 
    -0.04372856f, -0.02542933f, -0.06090163f, 0.00333075f, 0.40296921f, -0.02852734f, 0.23848671f, 0.01639740f, 
    -0.13610101f, -0.04478858f, 0.06888049f, -0.04292717f, -0.00444621f, 0.04536688f, 0.03506512f, 0.07896947f, 
    -0.24755572f, 0.08459280f, -0.01517091f, -0.15933010f, 0.04670209f, 0.01187610f, -0.10212780f, -0.04965500f, 
    -0.03420321f, 0.11741536f, -0.00990268f, 0.08711240f, 0.13349125f, 0.03370241f, 0.09619326f, -0.00530978f, 
    0.11823098f, -0.09382745f, 0.17575763f, 0.03845171f, -0.11147957f, 0.00774491f, 0.01148152f, 0.15460505f, 
    -0.00303315f, -0.03595894f, 0.02899676f, 0.00758057f, -0.03741127f, 0.02967886f, 0.02221495f, 0.01018227f, 
    -0.02455369f, -0.03257990f, 0.01509598f, -0.01904272f, 0.01462036f, -0.01943778f, -0.01690318f, 0.02549178f, 
    -0.00486130f, 0.01236876f, 0.00369529f, 0.00086842f, -0.01542360f, 0.02572424f, -0.03250648f, -0.03284404f, 
    0.01000239f, -0.00098756f, -0.03968005f, -0.00571363f, 0.00019548f, -0.02224595f, -0.03267483f, -0.00742521f, 
    0.02415562f, -0.03713917f, -0.02034950f, -0.01226477f, -0.03636663f, -0.01617403f, 0.03105311f, -0.02532215f, 
    -0.00740523f, 0.01165737f, -0.03321551f, 0.01118471f, 0.02713362f, 0.01849555f, 0.01184941f, -0.00075995f, 
    0.00265355f, -0.02202655f, 0.00913590f, 0.02244969f, 0.00695753f, 0.00259796f, -0.03219473f, -0.02792430f, 
    -0.01426820f, 0.01294906f, 0.02441081f, -0.00516843f, -0.03481828f, -0.01452035f, -0.03562937f, -0.02825709f, 
    0.02611463f, 0.00028634f, -0.03785579f, -0.00551299f, -0.03997156f, -0.02994217f, -0.01633566f, -0.01306376f, 
    0.01213964f, 0.02430877f, 0.00660454f, 0.01133341f, 0.01945399f, 0.00221797f, 0.02569041f, -0.00792503f, 
    -0.00056096f, -0.03577653f, 0.01386148f, 0.01341222f, 0.02217661f, 0.00862215f, 0.01325045f, -0.01993433f, 
    0.01821679f, 0.01452167f, 0.00190740f, 0.02945130f, -0.00001172f, -0.00339583f, 0.00512685f, -0.01628231f, 
    0.02947465f, -0.02241693f, -0.03154345f, -0.03369370f, 0.01023174f, -0.03692854f, -0.03847987f, -0.02178961f, 
    0.00218302f, 0.00500018f, -0.03709373f, -0.00376573f, -0.03992218f, 0.01329861f, 0.01738203f, -0.02533731f, 
    -0.02627193f, -0.01132750f, 0.01940589f, 0.02649559f, 0.02161433f, -0.01976838f, -0.01153805f, 0.02325429f, 
    0.02004167f, 0.01863700f, 0.00749831f, -0.02871950f, -0.03058442f, -0.02050607f, -0.02570060f, -0.02484071f, 
    0.01812260f, -0.00102446f, 0.00414196f, -0.01269317f, 0.00038126f, -0.00989942f, -0.03762722f, -0.02819938f, 
    -0.04133983f, -0.00854021f, 0.00177964f, -0.00230028f, 0.02997697f, -0.02208732f, -0.03951767f, -0.03867022f, 
    -0.01680539f, -0.03361544f, -0.04081184f, -0.01127046f, 0.02904359f, -0.00313208f, -0.03961920f, -0.03660172f, 
    -0.02860785f, -0.04139715f, -0.02786329f, -0.02457607f, -0.01409080f, 0.03598500f, -0.02481575f, -0.01596261f, 
    0.02194138f, 0.01346798f, -0.02489868f, 0.00321146f, 0.00282691f, 0.00087267f, -0.00776472f, -0.02634406f, 
    -0.01660963f, 0.01530130f, 0.00530033f, -0.03071921f, -0.00929568f, -0.00517779f, 0.00076074f, 0.02780569f, 
    -0.03841675f, 0.00482634f, -0.04132083f, 0.02957189f, -0.02586484f, 0.00442478f, -0.02623209f, -0.02591212f, 
    0.01107034f, 0.00092777f, -0.03810895f, -0.01043754f, -0.02384314f, 0.00405219f, -0.02184551f, 0.02681965f, 
    0.00820956f, -0.03563181f, 0.00429952f, -0.01501797f, -0.00480262f, -0.03791945f, 0.00100364f, 0.01827694f, 
    -0.01490111f, 0.02198426f, -0.03185196f, -0.03218752f, -0.03641130f, 0.02277277f, -0.03094334f, 0.00807353f, 
    -0.02856666f, -0.00030009f, -0.01871239f, -0.00349840f, -0.02984791f, 0.02887136f, -0.01554132f, -0.00828521f, 
    0.00589421f, 0.00474851f, -0.01644238f, 0.02505342f, 0.02170289f, -0.02299318f, 0.01633475f, -0.00630550f, 
    -0.01839882f, -0.00933705f, -0.00150309f, -0.01031256f, -0.02696614f, 0.01851328f, -0.03479342f, -0.00021042f, 
    -0.01324545f, 0.03110203f, -0.00649660f, -0.00142721f, -0.02592326f, -0.02215146f, -0.01337932f, 0.01487316f, 
    -0.00906166f, 0.01600822f, -0.01892111f, -0.01942581f, 0.00199586f, -0.02663741f, 0.01905836f, 0.01424196f, 
    -0.00970743f, 0.02045608f, 0.02576194f, -0.03289918f, -0.01399987f, -0.02483965f, -0.01076765f, 0.02717843f, 
    -0.04086236f, -0.01642259f, 0.01966551f, -0.00376138f, -0.02611152f, 0.01546221f, 0.02119742f, 0.02899241f, 
    -0.02773499f, -0.01167676f, -0.03932770f, 0.02230856f, -0.01804730f, 0.02879059f, -0.03054645f, 0.00935014f, 
    0.01523490f, -0.00156399f, 0.02667062f, -0.02229514f, -0.01607272f, 0.01580950f, -0.00541854f, -0.00640170f, 
    -0.03001333f, -0.01961912f, 0.03033192f, -0.03720072f, 0.01948192f, -0.00078597f, 0.01011693f, -0.02496972f, 
    0.01142982f, -0.03814642f, -0.02943981f, -0.02442384f, 0.00690189f, -0.01741815f, 0.03554386f, 0.00610000f, 
    -0.00757188f, -0.00173211f, -0.03173782f, -0.02535935f, -0.02006995f, -0.02079602f, -0.00190745f, -0.03653049f, 
    0.02600003f, -0.03470751f, -0.03864319f, 0.00796961f, 0.00603697f, 0.00033516f, 0.00509732f, -0.03140308f, 
    -0.00770550f, -0.03197342f, -0.04198633f, -0.01558708f, -0.02865550f, -0.00459296f, 0.02769474f, 0.00930693f, 
    -0.02128838f, -0.00089872f, -0.00306532f, 0.01803045f, 0.00766521f, 0.00285402f, 0.01924137f, -0.00871079f, 
    -0.03183424f, -0.03551714f, -0.03626445f, -0.00846465f, 0.00366092f, 0.01385503f, -0.00912798f, 0.01442015f, 
    0.02848767f, 0.02068888f, -0.02487288f, -0.03495180f, -0.03909049f, -0.03376751f, -0.03532496f, 0.00312227f, 
    -0.03609247f, -0.02361814f, 0.01465701f, -0.01103594f, 0.02855546f, -0.00342225f, 0.01912433f, -0.03386411f, 
    0.00390828f, -0.00826341f, -0.01645723f, -0.02801070f, 0.02639920f, -0.02722126f, -0.00773246f, -0.02239553f, 
    -0.01267193f, -0.02904787f, 0.01809802f, 0.01694770f, -0.03590528f, -0.00240637f, -0.03959165f, 0.01795226f, 
    0.00228465f, 0.00446832f, 0.01035143f, -0.02804297f, -0.01305622f, 0.00732264f, -0.00190575f, 0.00812944f, 
    -0.00300268f, 0.00693851f, -0.03092034f, -0.03843257f, 0.00159757f, 0.00792591f, -0.03789489f, -0.02924639f, 
    -0.03940814f, 0.03005259f, 0.00024617f, -0.01800619f, 0.02080592f, 0.02238781f, -0.03803606f, 0.00951170f, 
    -0.03730437f, -0.02118029f, 0.00794773f, 0.00496377f, -0.02222995f, -0.01552471f, -0.02600449f, -0.01387845f, 
    0.02013853f, 0.00676621f, -0.01436626f, 0.02848075f, -0.04186692f, 0.00470380f, -0.01616631f, 0.02921500f, 
    -0.02802079f, -0.00591095f, 0.01046903f, 0.00247334f, -0.02956751f, -0.02608602f, -0.02095179f, -0.02086362f, 
    -0.02071345f, -0.00014140f, 0.02060771f, -0.04196493f, 0.02300593f, 0.02684042f, -0.02307664f, -0.02620976f, 
    -0.03672567f, 0.00757311f, -0.00259089f, -0.01437713f, -0.02904422f, -0.02249635f, -0.03784572f, 0.02376995f, 
    -0.02196682f, 0.01410362f, 0.01410609f, -0.01618982f, 0.01744984f, -0.02293061f, -0.01526967f, 0.00008880f, 
    -0.00206386f, -0.04179377f, -0.01591840f, -0.02425247f, -0.00977123f, 0.01305577f, -0.01394007f, -0.03782413f, 
    -0.03791783f, 0.01871755f, 0.00009966f, 0.00992647f, -0.02450133f, -0.02969160f, 0.00627828f, -0.02569404f, 
    -0.02079108f, -0.00970083f, -0.02175904f, -0.01334216f, -0.01166345f, -0.02678535f, 0.01584264f, 0.02818680f, 
    0.02774447f, -0.04021660f, -0.02001771f, -0.00180440f, -0.04091505f, 0.01762701f, 0.01779788f, -0.00317547f, 
    -0.00217482f, -0.00871238f, 0.01525718f, 0.00234823f, 0.01688422f, 0.02414933f, 0.00971151f, 0.01428510f, 
    -0.03839407f, 0.02380948f, 0.00465515f, -0.03565750f, -0.03672070f, -0.00492810f, 0.01811380f, -0.01321526f, 
    0.02285401f, 0.02136859f, -0.02606791f, 0.02097143f, -0.03045755f, -0.01053168f, -0.02049623f, -0.02718503f, 
    0.01253944f, 0.00787987f, -0.03368730f, -0.02772877f, -0.03743764f, -0.02439876f, 0.02413768f, -0.03510017f, 
    -0.00325038f, -0.03100560f, -0.02244256f, 0.00582149f, -0.03454806f, -0.02966822f, 0.02517836f, 0.01524794f, 
    0.00915763f, 0.01060812f, -0.02997506f, 0.02428870f, 0.00587395f, 0.01184645f, -0.00275785f, 0.00271588f, 
    -0.01308419f, 0.00209661f, 0.02727763f, -0.00927804f, 0.01242295f, -0.03364787f, -0.00085729f, -0.02966299f, 
    -0.01352610f, -0.02848476f, -0.03221227f, 0.02952486f, 0.01645785f, -0.02808525f, 0.00115040f, 0.00476078f, 
    0.00536976f, -0.01221238f, 0.00670934f, -0.01114782f, 0.02301762f, -0.02844879f, 0.01853655f, 0.00468131f, 
    -0.00110466f, -0.02201641f, -0.00219999f, 0.00272602f, -0.01362870f, -0.00971538f, 0.01963550f, -0.00921426f, 
    0.01346926f, -0.01208650f, -0.02057273f, 0.00963258f, -0.00753021f, -0.04040791f, 0.02372193f, 0.00806550f, 
    -0.00185581f, 0.00537127f, 0.02720683f, -0.01052768f, -0.03095699f, -0.00401435f, -0.02844100f, -0.03158661f, 
    -0.01994992f, -0.03056893f, 0.00368803f, -0.02567660f, -0.02369339f, -0.02847953f, -0.03045830f, 0.00509276f, 
    -0.02205116f, -0.01941163f, -0.00167783f, -0.03974440f, -0.00388676f, -0.01587623f, -0.03579441f, 0.02203048f, 
    -0.01046575f, -0.00452340f, -0.00798849f, 0.00677651f, 0.02135345f, 0.01201649f, -0.03484969f, -0.02172673f, 
    0.00227015f, 0.00856499f, 0.02111162f, -0.00767939f, -0.00539611f, -0.01179940f, -0.01990619f, -0.02477238f, 
    0.01242300f, 0.00782569f, 0.02592459f, -0.01004754f, -0.02755894f, 0.01984330f, -0.00320916f, -0.02637140f, 
    0.00510581f, 0.01132008f, 0.02544756f, 0.02168658f, 0.00622513f, -0.00868802f, -0.01618056f, -0.01246959f, 
    0.00795182f, -0.00415699f, -0.00889621f, -0.02827527f, -0.01342132f, -0.01096980f, -0.02532949f, 0.00483048f, 
    0.01465566f, -0.00918857f, -0.02311957f, 0.03203188f, -0.01605609f, -0.00852731f, -0.02934493f, 0.01218287f, 
    0.01250374f, 0.02894470f, -0.01741885f, 0.01168893f, -0.01780688f, 0.00899009f, 0.00683651f, -0.00439607f, 
    0.00892138f, 0.00558097f, -0.03595611f, -0.01467864f, -0.02032208f, -0.01722789f, 0.01116678f, 0.01925557f, 
    -0.02033858f, -0.03379986f, -0.03857522f, 0.00429179f, 0.01146175f, -0.01050954f, -0.01576186f, -0.02334048f, 
    0.02849724f, 0.00644841f, 0.00985008f, 0.00531521f, -0.01839704f, 0.01540632f, 0.00100434f, 0.01296874f, 
    -0.01587935f, -0.02656535f, 0.02774572f, 0.02724511f, 0.01475198f, -0.02759167f, -0.03555907f, -0.00865803f, 
    -0.02625074f, 0.02288504f, -0.01249564f, -0.02053334f, 0.01210123f, -0.02537528f, 0.02499102f, -0.04103025f, 
    0.01257466f, -0.01636918f, -0.00141272f, 0.03550403f, 0.02065773f, -0.01725991f, 0.01050433f, 0.02451417f, 
    -0.02064626f, -0.00613686f, -0.01080060f, -0.02712553f, -0.01746474f, -0.03267168f, 0.00915991f, 0.00416873f, 
    -0.02577374f, -0.00791621f, 0.02735488f, 0.00987554f, -0.00051543f, -0.03901957f, -0.01346205f, 0.01063144f, 
    0.01826997f, -0.02259080f, 0.00870763f, -0.01052026f, -0.03945883f, 0.02647868f, -0.00675220f, 0.01719937f, 
    -0.00156111f, -0.02590177f, -0.03194157f, -0.03704988f, 0.02845393f, 0.01395126f, 0.00109939f, 0.00294848f, 
    0.00834033f, -0.00212329f, 0.01753581f, -0.02346781f, 0.02880308f, 0.02545445f, -0.02595001f, -0.02102746f, 
    -0.00177711f, 0.02800376f, -0.00797089f, -0.01190000f, 0.00645525f, -0.00422700f, -0.01661852f, -0.02500653f, 
    0.01463662f, -0.03674095f, -0.00587277f, 0.00741348f, 0.01143242f, 0.02910431f, 0.02118974f, -0.02570233f, 
    0.00796581f, -0.03227325f, 0.00858257f, -0.01523131f, -0.03324731f, -0.01457102f, -0.01315087f, -0.01878819f, 
    -0.01919368f, -0.02777233f, -0.01299310f, 0.00939581f, -0.03844956f, -0.02762337f, 0.01408567f, 0.00955858f, 
    -0.03836636f, 0.02763919f, -0.02908604f, -0.00646264f, -0.00151014f, -0.03849052f, 0.00205838f, -0.02213348f, 
    -0.12835531f, 0.06415930f, 0.04508436f, 0.05073311f, 0.07948282f, 0.06526157f, -0.05457883f, -0.12215223f, 
    0.02840054f, -0.07225633f, 0.03711513f, 0.06297746f, 0.11428938f, 0.03737635f, -0.25812888f, -0.11601765f, 
    0.00488441f, -0.02558341f, 0.03409256f, 0.11742643f, 0.09932832f, -0.00283713f, -0.06428909f, 0.08223043f, 
    -0.05200249f, 0.06455569f, -0.05158728f, -0.04823575f, 0.05549984f, -0.07574722f, 0.08699064f, -0.08620809f, 
    0.07056697f, 0.16380847f, 0.07464082f, -0.01630767f, -0.07268279f, 0.03463083f, 0.12352740f, 0.04707678f, 
    0.11903920f, -0.20601781f, -0.04951933f, -0.05389401f, -0.01150398f, -0.05523400f, -0.01052157f, 0.02851219f, 
    0.11504888f, 0.22317518f, 0.07962234f, -0.04919432f, 0.03782563f, 0.09799211f, -0.01575190f, 0.17438173f, 
    0.08887543f, -0.04238399f, 0.05729062f, 0.06577542f, 0.26345742f, 0.24788520f, -0.12623653f, 0.02083186f, 
    0.03003772f, 0.02000400f, 0.03030348f, -0.03536499f, 0.03433685f, 0.02437448f, 0.09156045f, 0.01950015f, 
    0.04308802f, -0.18802543f, -0.01358400f, 0.00323799f, -0.02026062f, 0.03908350f, 0.01067162f, 0.04247454f, 
    0.04839003f, 0.00107675f, 0.09139790f, -0.04184387f, -0.00024330f, -0.11986349f, -0.03197903f, -0.25632927f, 
    0.02168420f, 0.11337458f, -0.07454488f, -0.22703367f, 0.15153694f, -0.08797742f, -0.03141721f, 0.04803782f, 
    0.35293078f, -0.07299352f, -0.04998701f, 0.01459545f, -0.12225135f, -0.05247819f, 0.06612888f, -0.08949955f, 
    0.13638912f, -0.01159774f, 0.00625493f, 0.06676652f, 0.17005767f, -0.05010137f, -0.03909706f, -0.15798903f, 
    0.07382388f, 0.04142063f, 0.05773732f, -0.06395891f, 0.00932261f, 0.04197770f, 0.04105006f, 0.02439541f, 
    0.16835108f, -0.00438953f, -0.01229169f, -0.10409126f, 0.02747525f, 0.06989255f, 0.02030029f, -0.01249971f, 
    0.00092726f, -0.11130422f, 0.09041695f, -0.08938918f, 0.15447043f, -0.09951164f, -0.08028208f, 0.00200743f, 
    0.04206653f, -0.08829673f, -0.00961475f, 0.03978243f, 0.00840960f, 0.06023477f, 0.20921655f, 0.01777450f, 
    0.13167004f, -0.05767935f, -0.16294107f, -0.08596039f, -0.07874194f, 0.10785171f, 0.09467646f, -0.05827331f, 
    0.05295286f, 0.06655141f, 0.08246000f, -0.12697731f, -0.12358068f, 0.01644807f, 0.00152388f, -0.07916886f, 
    0.02373843f, -0.07568965f, 0.12776028f, 0.05645784f, 0.06768247f, 0.00309826f, 0.08822277f, 0.02584209f, 
    0.01925401f, -0.02578207f, 0.10273818f, 0.02091016f, 0.01048147f, 0.02322835f, -0.04860891f, 0.01707057f, 
    0.05393756f, 0.14435507f, 0.04389867f, -0.01039156f, -0.27884990f, -0.00061838f, -0.09372188f, -0.14570600f, 
    0.02930778f, -0.05093642f, -0.01295173f, -0.10887392f, 0.07964116f, -0.04063049f, -0.00697018f, 0.02754614f, 
    -0.02181722f, -0.00804085f, 0.08121102f, 0.07725972f, 0.04339845f, -0.05584209f, 0.00198509f, -0.02256382f, 
    0.02377049f, 0.00098374f, 0.09718051f, -0.04107747f, -0.14683254f, -0.08337660f, -0.10789987f, 0.01343861f, 
    0.00593256f, -0.07624917f, -0.04605976f, 0.00928989f, 0.03847844f, 0.14118437f, -0.05010428f, -0.11235781f, 
    0.19171967f, 0.16548546f, -0.01871229f, -0.21349923f, 0.04503587f, 0.00578958f, 0.04605332f, 0.09923150f, 
    0.10543902f, 0.03135183f, 0.08080948f, 0.12152237f, 0.05690146f, -0.03286618f, 0.11465009f, 0.12754512f, 
    -0.06217919f, 0.02091045f, 0.18020010f, -0.06420755f, 0.07339153f, 0.07328401f, -0.12552351f, -0.10444199f, 
    0.07605649f, -0.10269475f, -0.13435321f, 0.03514247f, 0.10673644f, 0.10038387f, -0.01423919f, -0.02082093f, 
    0.15586178f, 0.03048839f, -0.04761885f, -0.07262948f, 0.02088518f, 0.24975462f, -0.09364510f, 0.02771017f, 
    0.18009889f, -0.10003862f, -0.03337240f, -0.05273554f, -0.07191275f, 0.03882533f, -0.07522239f, 0.04397408f, 
    0.06913367f, 0.10061625f, -0.08402555f, 0.06101003f, 0.06424136f, -0.02151920f, -0.08507591f, -0.00133671f, 
    -0.05889006f, -0.03812151f, -0.02082465f, 0.07903459f, 0.19500573f, 0.13908200f, -0.08780275f, 0.00087427f, 
    0.04358206f, 0.01856739f, -0.13355468f, -0.06241539f, -0.02697765f, 0.04961017f, -0.03067022f, 0.08664590f, 
    -0.03776300f, 0.06877367f, -0.16253915f, -0.01029447f, 0.02712401f, -0.00032897f, -0.11347789f, 0.13361591f, 
    0.22326098f, -0.05970494f, -0.17853920f, -0.00299867f, 0.00885758f, -0.05700272f, 0.07790595f, 0.00059909f, 
    0.05303247f, 0.04150134f, 0.05644939f, 0.02944486f, 0.01538478f, -0.08641694f, 0.10227068f, -0.06929880f, 
    -0.03826522f, -0.05829438f, -0.10988477f, -0.08902749f, 0.05959853f, 0.06639821f, -0.06685203f, -0.01576182f, 
    0.05112774f, 0.00993612f, -0.02032541f, 0.12406243f, 0.02949428f, 0.06400884f, 0.03763735f, 0.05008795f, 
    -0.07841305f, -0.10560261f, 0.02244423f, -0.08326846f, 0.09901512f, 0.08266658f, 0.02897912f, 0.05218529f, 
    -0.28552210f, -0.04847071f, 0.08348664f, 0.14872216f, 0.00944609f, -0.00482633f, -0.07830967f, -0.00014214f, 
    0.00261797f, -0.03925600f, -0.01513537f, -0.07129359f, -0.02311750f, 0.22548799f, -0.16157301f, -0.03613563f, 
    0.00377740f, 0.01983727f, 0.06820491f, -0.00072222f, -0.08390976f, 0.04324664f, 0.04361726f, 0.10051735f, 
    0.00226877f, -0.11692924f, 0.02736227f, 0.04908561f, 0.00104815f, -0.11623010f, -0.14056723f, 0.03636391f, 
    0.05344518f, -0.00497412f, -0.01759104f, -0.08917777f, 0.01859541f, 0.21217254f, 0.10177294f, 0.00755917f, 
    -0.11935524f, -0.00532982f, -0.02192141f, 0.13200118f, -0.00916085f, -0.04431212f, -0.05249935f, 0.04910184f, 
    -0.01591491f, -0.00904863f, 0.05463186f, -0.02189413f, 0.09993434f, -0.08762098f, 0.06942719f, 0.10268154f, 
    0.05901268f, 0.09052877f, 0.04988145f, 0.06087122f, 0.28474340f, 0.00743198f, -0.11111914f, 0.10465837f, 
    0.07508717f, -0.04717255f, 0.02360771f, 0.01960652f, 0.02438590f, -0.01126211f, 0.05937417f, -0.00268655f, 
    -0.05084720f, -0.04183996f, 0.02846571f, -0.08310160f, 0.05639043f, 0.00761098f, 0.09211096f, -0.05974078f, 
    -0.04960717f, -0.05311523f, 0.07199627f, 0.07815473f, 0.12074223f, 0.08758884f, -0.10667905f, 0.11777297f, 
    0.02411158f, 0.00956072f, 0.04544196f, 0.07418251f, 0.04436835f, 0.06697463f, 0.04933416f, 0.06091776f, 
    -0.18443921f, -0.14377269f, 0.13502114f, -0.00706900f, 0.02805788f, -0.07905542f, -0.03005593f, 0.00717327f, 
    -0.05776513f, 0.06035122f, 0.02509023f, 0.11739285f, 0.05573083f, -0.15462127f, -0.15772921f, 0.07704836f, 
    -0.02315434f, -0.03882593f, 0.07532155f, 0.06286245f, 0.14664729f, -0.05611419f, 0.10758194f, 0.04550403f, 
    -0.12539503f, 0.01848977f, -0.04266140f, -0.03482724f, -0.03522576f, 0.00761770f, -0.09603026f, 0.06268165f, 
    -0.01787087f, -0.12997302f, 0.01199120f, 0.08402194f, 0.12517434f, -0.16703145f, -0.03063121f, 0.08480983f, 
    0.03044498f, -0.01150170f, 0.09481705f, 0.03711886f, 0.05465946f, 0.04385012f, -0.00139023f, 0.03100721f, 
    -0.14269258f, 0.03272498f, -0.07057137f, 0.11963934f, 0.03812211f, 0.07242034f, -0.02059526f, 0.12433954f, 
    0.00394147f, 0.05369907f, 0.06413570f, 0.03287632f, -0.01797677f, -0.13606748f, -0.00182585f, -0.03314320f, 
    0.06547163f, -0.00340100f, -0.03270730f, -0.10955426f, -0.03883146f, 0.08557852f, 0.13430914f, 0.15218696f, 
    0.22416711f, -0.06514820f, 0.07719984f, 0.00596243f, 0.07005929f, 0.05960411f, 0.08222583f, -0.07805252f, 
    0.03012928f, -0.01853946f, 0.03583303f, -0.05574778f, -0.18810774f, 0.06131328f, 0.24438430f, 0.06495271f, 
    -0.00462891f, -0.05697532f, 0.06425387f, 0.00278345f, 0.06432543f, 0.01594496f, 0.02944126f, 0.04583415f, 
    -0.05477855f, 0.06507716f, -0.05282689f, -0.00518163f, 0.08642064f, 0.02743585f, 0.02697691f, 0.05559188f, 
    0.12439780f, 0.00991265f, 0.00024930f, 0.01333660f, -0.00906398f, -0.12845430f, 0.12443241f, -0.05103776f, 
    0.08631980f, -0.07502859f, -0.03698958f, 0.02150823f, 0.00181959f, 0.02254999f, 0.05530355f, 0.05355787f, 
    0.37023291f, -0.10127194f, 0.05348381f, 0.04065199f, -0.02917512f, 0.01331493f, -0.05459986f, 0.00482165f, 
    0.08083342f, -0.07996732f, -0.03615644f, -0.13980508f, -0.10632037f, 0.01214551f, -0.11980224f, -0.18578248f, 
    -0.03019919f, 0.17110839f, -0.03021145f, 0.12991749f, 0.11151847f, -0.00279057f, 0.07155251f, -0.06621209f, 
    -0.00284024f, 0.04310041f, 0.10019389f, -0.08043146f, 0.07857589f, 0.02932343f, -0.01376342f, 0.00182837f, 
    0.01526027f, 0.04395783f, 0.11845896f, 0.10798679f, -0.14852719f, 0.05172222f, 0.04570441f, 0.05362786f, 
    -0.02799286f, -0.06804273f, 0.02993364f, -0.01606108f, 0.04599127f, 0.07730616f, 0.01500287f, 0.07636902f, 
    0.12037256f, -0.05401540f, -0.17676474f, -0.22499733f, 0.01995489f, -0.05881513f, 0.09894875f, 0.06019407f, 
    0.02832747f, 0.08243277f, 0.01958479f, 0.03135017f, -0.06148849f, -0.10416153f, 0.06170820f, 0.05209158f, 
    0.04918886f, -0.10608609f, 0.03653473f, 0.03104707f, 0.09361107f, 0.11891773f, 0.09750596f, 0.02096451f, 
    -0.10754128f, 0.08730350f, 0.00514356f, -0.16001168f, 0.10531215f, 0.13015027f, -0.02868186f, 0.02817510f, 
    0.07735739f, -0.04795205f, -0.09010863f, -0.03239914f, 0.06615819f, -0.12216143f, 0.02190269f, 0.10752733f, 
    0.10024606f, -0.09217360f, -0.02097513f, -0.05752381f, 0.03297614f, 0.04082363f, -0.15215969f, -0.02752635f, 
    -0.23095526f, -0.02708418f, 0.12152402f, -0.13811313f, -0.00450708f, -0.04239176f, -0.08009777f, 0.06867779f, 
    0.08454781f, 0.01946155f, 0.08749209f, 0.04464414f, -0.01312401f, 0.23770876f, 0.08114474f, -0.12230714f, 
    -0.07731628f, 0.01945652f, 0.01269887f, -0.04480424f, 0.16386400f, 0.04852334f, -0.02510029f, 0.04782356f, 
    -0.04096069f, -0.11239237f, 0.07448751f, -0.13860551f, -0.08043773f, -0.07630523f, 0.00291090f, -0.01400394f, 
    -0.03055159f, 0.03068228f, 0.09755135f, -0.10276042f, 0.01083847f, -0.13225523f, 0.01320710f, 0.04811209f, 
    0.02076553f, -0.16675323f, -0.00980658f, -0.10297607f, -0.01391043f, 0.00161943f, 0.00468504f, 0.10813439f, 
    0.09671251f, 0.21540308f, -0.00971831f, 0.11182682f, 0.02405743f, 0.07059949f, -0.10882708f, 0.03757749f, 
    -0.01036774f, -0.09921870f, 0.08029981f, 0.10233956f, 0.25249007f, 0.16846573f, -0.11072384f, 0.04279956f, 
    0.02243851f, -0.04007615f, 0.00299177f, -0.10872779f, 0.11471170f, 0.05950698f, 0.12126540f, 0.16528319f, 
    -0.13921480f, -0.16462190f, 0.10401700f, -0.04424085f, 0.06838226f, -0.00159067f, 0.05385836f, 0.14760062f, 
    0.04516293f, 0.03136531f, 0.08056282f, -0.08171648f, -0.01951244f, -0.02806336f, 0.01156339f, 0.00665069f, 
    0.05608306f, 0.02674284f, 0.02542832f, -0.00105402f, 0.06038334f, 0.01306861f, 0.11792146f, 0.02937267f, 
    -0.05777569f, -0.12234219f, -0.07703365f, -0.06584831f, -0.02415910f, 0.17690141f, -0.11706940f, 0.07021647f, 
    0.06233695f, 0.09997644f, 0.08283739f, 0.01786129f, -0.16024284f, -0.05133462f, 0.14117572f, 0.02997083f, 
    0.06259523f, -0.09246631f, 0.16736771f, 0.06954188f, -0.01577636f, -0.07646686f, 0.05429666f, 0.17024530f, 
    -0.01577203f, -0.01250410f, -0.03417489f, 0.00101949f, -0.03736424f, -0.03906193f, -0.03079147f, 0.00987337f, 
    -0.03735159f, -0.03775360f, 0.00796649f, -0.04255982f, -0.02980316f, 0.00755115f, -0.02461582f, -0.01650222f, 
    0.00519673f, -0.03693787f, 0.03157263f, -0.00428614f, 0.01617431f, 0.00545729f, 0.01389855f, 0.00834611f, 
    0.00480232f, 0.02930479f, -0.03066820f, -0.03570536f, 0.02330964f, 0.02750622f, -0.02546883f, -0.02450773f, 
    -0.02475837f, -0.00118841f, -0.02543859f, -0.01362713f, -0.03481301f, -0.03851411f, -0.03713807f, 0.01297930f, 
    -0.00659357f, -0.01774928f, -0.00846595f, -0.02987150f, 0.02262551f, 0.02027719f, 0.01517082f, -0.02473551f, 
    -0.01029193f, -0.01319116f, -0.00275897f, -0.00580234f, -0.00197252f, -0.01040909f, -0.01867626f, -0.02960235f, 
    -0.02168561f, -0.03321463f, -0.00377319f, -0.02105624f, -0.02769358f, -0.01773954f, -0.01818245f, -0.01559705f, 
    0.03115711f, -0.02499757f, 0.02236758f, -0.03995553f, -0.00365542f, -0.00392691f, -0.02215460f, 0.03074612f, 
    0.01580674f, -0.02440274f, -0.02745667f, 0.00568423f, -0.01594184f, 0.00068617f, -0.01792453f, -0.03358491f, 
    -0.03273720f, -0.00579213f, 0.02122328f, 0.01448525f, -0.00481386f, 0.00061536f, -0.01911288f, 0.01201342f, 
    -0.00179917f, 0.00407420f, -0.03266883f, -0.01384490f, 0.02526837f, -0.02703083f, 0.02050255f, 0.02781809f, 
    -0.00940254f, -0.00060336f, 0.01429811f, 0.01866206f, -0.00794782f, -0.00875640f, 0.00076518f, -0.04227792f, 
    -0.00980113f, 0.02495046f, -0.03786246f, -0.02047949f, -0.00702128f, 0.01668243f, -0.02816867f, -0.03663939f, 
    -0.01662119f, -0.00900463f, 0.01579055f, 0.02253793f, -0.03207703f, -0.00183946f, -0.02023705f, -0.01204327f, 
    -0.03088839f, -0.00008442f, 0.00921947f, -0.02999057f, -0.03126294f, 0.01171243f, -0.02271226f, 0.00627636f, 
    0.02553748f, -0.02662606f, -0.03558386f, -0.01162685f, 0.00570092f, 0.00921519f, -0.01534185f, -0.00235773f, 
    -0.02040672f, 0.01275100f, -0.01047688f, -0.02410428f, 0.03292334f, 0.01981841f, 0.01346584f, -0.02274937f, 
    0.01582035f, 0.02406951f, 0.00528722f, -0.00948693f, 0.01019108f, -0.04099010f, 0.00122329f, -0.01944325f, 
    0.02682123f, -0.00224583f, -0.03528088f, -0.01532350f, -0.02848260f, -0.01973973f, -0.03786033f, -0.02209716f, 
    -0.01738342f, 0.01775362f, -0.00789932f, -0.00551716f, 0.01775170f, 0.00936575f, -0.04058992f, -0.03256624f, 
    0.03392024f, -0.03385604f, -0.00967313f, -0.01898083f, 0.03161477f, -0.02666876f, -0.02441389f, -0.02488795f, 
    0.02506997f, -0.02179750f, -0.03282834f, -0.01188546f, -0.01613818f, 0.01764645f, -0.03746286f, -0.00003238f, 
    -0.00572002f, 0.01428205f, -0.03254894f, -0.02920110f, -0.00972227f, 0.02870212f, -0.00924207f, -0.02989071f, 
    0.00707492f, -0.01436683f, -0.03523645f, -0.02019304f, -0.02040680f, -0.01391042f, -0.00890005f, 0.01649323f, 
    0.02244872f, 0.00092989f, 0.02272410f, -0.03757178f, -0.02175282f, -0.03868602f, -0.02136229f, 0.02587245f, 
    0.01940497f, 0.01662563f, -0.00507516f, -0.01980295f, -0.03733842f, -0.00185255f, -0.03958645f, -0.03356468f, 
    -0.02835875f, 0.01052496f, 0.01372967f, 0.01653506f, -0.00441417f, 0.01092589f, 0.00217044f, -0.00587029f, 
    -0.03468070f, 0.01182666f, -0.02715028f, -0.01161785f, 0.01792691f, -0.01841684f, 0.02288767f, 0.00919196f, 
    0.01249482f, -0.03400886f, 0.00720928f, -0.04027049f, -0.02888120f, -0.04211728f, -0.01095213f, -0.02338444f, 
    0.01646146f, 0.01904519f, -0.02761236f, 0.00598169f, -0.00718193f, -0.00215627f, -0.01023011f, -0.02768160f, 
    -0.04391976f, -0.01757980f, 0.01467278f, -0.03009813f, -0.00356474f, -0.02686176f, -0.00068178f, -0.02183797f, 
    -0.01063529f, -0.01324958f, 0.02279307f, -0.00509906f, -0.00447324f, 0.01470775f, -0.01706970f, 0.00719175f, 
    -0.04096168f, -0.03117721f, 0.01135812f, -0.01131400f, -0.01842140f, -0.02366875f, -0.00418228f, 0.00013819f, 
    0.02949496f, -0.02519797f, 0.00661345f, -0.01146787f, -0.02508623f, 0.00324727f, 0.02129188f, -0.00681349f, 
    0.01678133f, 0.00635925f, 0.01152763f, -0.01960663f, 0.00301698f, -0.00285091f, 0.02489857f, -0.01082463f, 
    -0.01371028f, 0.01385867f, 0.03013557f, 0.00454464f, -0.00031172f, -0.00955702f, -0.03024590f, 0.01397391f, 
    -0.00445570f, 0.00207382f, -0.01785449f, -0.00385943f, -0.02852551f, -0.03755170f, -0.01570368f, -0.03633634f, 
    -0.01720971f, 0.02489837f, -0.03206889f, -0.00002494f, -0.01911229f, 0.02047703f, 0.00668640f, 0.02022853f, 
    0.02693977f, -0.03108949f, -0.01107926f, -0.00477957f, -0.03009915f, -0.00290705f, -0.02992572f, 0.02177895f, 
    -0.02214313f, 0.04161284f, -0.02222366f, -0.02937721f, -0.03867939f, -0.00885741f, 0.00439847f, -0.03284333f, 
    0.00567283f, -0.01211933f, 0.00723982f, -0.03262651f, 0.01550996f, 0.02367510f, 0.01541904f, -0.00312578f, 
    -0.01007306f, 0.02510384f, 0.01260538f, -0.01626827f, -0.01240437f, 0.02668705f, 0.02589344f, 0.00129113f, 
    -0.02651042f, 0.00086849f, 0.02197375f, -0.01895836f, 0.00698130f, 0.02364754f, 0.01137874f, -0.01839386f, 
    -0.03824656f, -0.02347683f, 0.01058710f, -0.02668353f, 0.01581110f, -0.00099539f, 0.00163026f, -0.02571244f, 
    -0.00330266f, -0.01953073f, -0.03261931f, -0.03421868f, -0.00140600f, -0.01573301f, -0.02633623f, -0.03984980f, 
    0.01057692f, 0.02090125f, -0.03231071f, 0.01689454f, -0.03437689f, -0.00073963f, -0.02697397f, -0.03619279f, 
    -0.02918573f, -0.00910608f, -0.01877457f, -0.02728528f, 0.02356065f, -0.02385366f, -0.01741215f, 0.00345855f, 
    0.02641306f, 0.00574187f, 0.00103618f, -0.00856007f, -0.01228876f, -0.04041390f, 0.00148078f, 0.00160102f, 
    -0.03897858f, 0.00591849f, 0.02659819f, 0.00522439f, 0.00483476f, -0.00156606f, -0.02948254f, -0.02482062f, 
    0.03435210f, -0.04344230f, -0.02883988f, -0.03498442f, -0.02339303f, 0.02278343f, -0.01874561f, 0.00038538f, 
    -0.02063608f, 0.00493085f, 0.01074960f, -0.00228833f, -0.00820423f, -0.01516851f, 0.01078694f, 0.00817009f, 
    0.02288738f, 0.02871368f, 0.01068113f, -0.03997169f, 0.00783040f, 0.01546411f, 0.01235489f, 0.00451037f, 
    0.00732457f, -0.03650265f, -0.02692890f, -0.02744935f, -0.00206837f, 0.00318450f, 0.00313131f, 0.01165731f, 
    -0.04168587f, -0.00878930f, -0.03096156f, 0.01378006f, -0.04289633f, 0.02503777f, -0.00264590f, 0.03966771f, 
    0.02258539f, -0.01787896f, -0.00054878f, -0.01376044f, 0.00347204f, 0.01269444f, -0.02104022f, -0.01877230f, 
    0.02381063f, -0.01733704f, 0.02780268f, -0.03975929f, -0.00760730f, 0.02020591f, -0.02698760f, -0.03620904f, 
    0.01236661f, 0.01367546f, -0.02625978f, 0.00923493f, 0.02785196f, 0.01057347f, 0.00206035f, 0.00262555f, 
    0.00069489f, 0.01224991f, 0.02633548f, -0.04042308f, -0.04394319f, 0.00044159f, 0.02501101f, -0.01741721f, 
    0.00250459f, -0.04057070f, -0.03096483f, -0.01127506f, -0.04045662f, -0.03873939f, -0.01709918f, 0.00739721f, 
    0.02036755f, 0.00519756f, 0.02304113f, 0.01010802f, -0.00789752f, 0.00227110f, -0.00665467f, 0.02477728f, 
    -0.00377107f, 0.02136659f, 0.01003736f, -0.02539458f, -0.02314793f, -0.01537848f, 0.02705397f, -0.02263390f, 
    0.01582413f, -0.00821877f, 0.01897526f, -0.03884790f, -0.01017004f, -0.00708000f, -0.03900873f, 0.01299498f, 
    -0.03828606f, 0.02596034f, -0.02403377f, -0.01806176f, -0.00635793f, -0.01097418f, 0.02749345f, -0.02041623f, 
    -0.02091850f, 0.02637840f, 0.00164927f, -0.02004734f, -0.00299558f, -0.03591882f, 0.01975096f, -0.04242736f, 
    -0.00541005f, -0.02076558f, 0.01766437f, -0.03238780f, 0.01708589f, -0.00637925f, -0.02614729f, 0.02010925f, 
    -0.00659803f, -0.03246901f, -0.01663051f, -0.02846450f, 0.01056664f, -0.00030668f, -0.01585807f, 0.01064637f, 
    -0.02817403f, -0.00875133f, 0.02695805f, -0.03146786f, -0.04034885f, 0.00142640f, 0.03561931f, 0.00442305f, 
    -0.01244055f, -0.02889442f, -0.03019099f, -0.01505504f, 0.00657299f, -0.00042450f, -0.02766225f, 0.02263840f, 
    0.02305702f, -0.02469012f, 0.02816225f, -0.00526814f, -0.01982388f, -0.02546668f, -0.03871866f, -0.01861506f, 
    0.00711013f, -0.03950231f, 0.00459442f, 0.00695029f, -0.00740907f, -0.00507881f, 0.00485031f, -0.00869749f, 
    -0.01755614f, -0.00039023f, -0.02671797f, -0.00556600f, 0.02241673f, -0.03812837f, -0.02747963f, -0.02427662f, 
    -0.00455031f, 0.01170392f, -0.01873791f, -0.03512732f, -0.00198934f, 0.00760332f, 0.01385885f, 0.00423747f, 
    -0.02562726f, 0.01608100f, -0.03481472f, -0.04014349f, -0.02898230f, -0.03151518f, -0.00685760f, 0.01206730f, 
    0.02888204f, 0.02198797f, -0.04257627f, -0.04105578f, -0.03376079f, 0.02519747f, -0.04206818f, 0.01627735f, 
    0.01043651f, -0.01650628f, -0.02932481f, -0.02332670f, -0.00661025f, -0.01582522f, -0.04388909f, -0.03090173f, 
    -0.03405974f, -0.03427492f, -0.03508985f, -0.01541597f, -0.00771613f, -0.03749095f, -0.02421098f, -0.04188142f, 
    -0.03394315f, -0.00529361f, -0.02005232f, -0.01891277f, -0.03959358f, 0.01467830f, -0.01383387f, -0.00320943f, 
    0.02585741f, -0.01044790f, 0.02815426f, -0.02862017f, -0.01389999f, -0.04114188f, -0.01952618f, -0.03062240f, 
    -0.00903997f, -0.02434473f, 0.01789543f, -0.03334802f, -0.02396878f, -0.03480625f, -0.03817212f, -0.03035117f, 
    0.00171321f, -0.01696588f, -0.01595728f, 0.01354216f, -0.03632695f, -0.02469639f, 0.02051057f, -0.03505868f, 
    0.01314681f, 0.01932077f, -0.02649567f, 0.01829966f, 0.01177706f, -0.02566648f, 0.01128856f, 0.00794917f, 
    -0.02346667f, 0.01605676f, -0.02661335f, 0.00096340f, 0.00243252f, 0.00748089f, -0.02417503f, 0.02036395f, 
    0.02508760f, 0.01757883f, 0.03718287f, 0.00253308f, -0.03514174f, -0.03846465f, 0.01693138f, 0.00431400f, 
    -0.00507475f, 0.02200309f, 0.01440796f, -0.01205240f, -0.01466029f, -0.02307738f, -0.00560721f, -0.01207980f, 
    -0.01959168f, 0.02784847f, -0.00829179f, -0.00980466f, -0.01018008f, 0.02652896f, 0.00913056f, -0.00714278f, 
    -0.02492617f, 0.02281337f, 0.01821367f, -0.01932169f, 0.00136659f, -0.03721997f, 0.00923559f, -0.00081004f, 
    -0.04282310f, -0.00243615f, 0.01235744f, -0.00171700f, -0.01411033f, 0.00979528f, -0.01252542f, -0.00374081f, 
    -0.03673640f, 0.00949501f, 0.00199896f, -0.00195068f, 0.00566153f, -0.02496589f, -0.02351249f, -0.00780337f, 
    0.01548680f, -0.03398675f, -0.04163558f, 0.02224691f, 0.02360491f, -0.03242223f, -0.03097097f, -0.00696849f, 
    0.02135799f, 0.01132087f, 0.02222717f, 0.02143212f, 0.01144714f, 0.01153424f, 0.00499898f, -0.01400528f, 
    0.01409318f, -0.00805113f, 0.02242159f, 0.01054316f, 0.01474795f, 0.01652121f, 0.01225018f, 0.02546106f, 
    -0.01708085f, 0.01277186f, -0.04297124f, -0.03388889f, -0.03567364f, 0.01835679f, -0.02417688f, -0.01832793f, 
    -0.03454684f, 0.02163675f, 0.00472315f, -0.02070689f, 0.00340209f, 0.01587335f, -0.02622790f, -0.00453931f, 
    -0.01666812f, -0.03046612f, 0.02817750f, 0.02322560f, -0.01543352f, 0.01247008f, 0.00617478f, 0.01928407f, 
    0.01364500f, 0.01963185f, -0.03524393f, 0.01850669f, -0.00034573f, -0.00548050f, 0.01653139f, -0.01364474f, 
    -0.17393057f, -0.02032058f, -0.03607501f, 0.09486257f, -0.00697938f, 0.06232306f, -0.04341987f, -0.04675837f, 
    -0.04693814f, -0.13281666f, 0.05346245f, 0.08924466f, 0.12911707f, 0.07498754f, 0.10382176f, 0.11568562f, 
    -0.08472227f, 0.06113977f, 0.04480569f, 0.03152683f, 0.02390327f, 0.07496165f, -0.04842474f, 0.02004538f, 
    0.16037318f, 0.05589259f, 0.06000281f, 0.13408004f, 0.06069690f, -0.02483895f, 0.00743646f, 0.04483882f, 
    0.05424938f, 0.12071459f, -0.03340281f, -0.00927294f, 0.02581550f, -0.05338250f, 0.01118731f, -0.05411841f, 
    -0.08151321f, 0.05961495f, -0.02026114f, -0.01260146f, -0.11916774f, 0.01008324f, 0.07747736f, 0.01323528f, 
    -0.19650365f, -0.10584816f, -0.00513055f, 0.15591079f, -0.04827321f, -0.04413282f, 0.03895452f, 0.01850125f, 
    0.09175169f, 0.06334801f, -0.05896963f, -0.03719355f, -0.11264287f, -0.17277594f, -0.07509712f, -0.12950936f, 
    0.09808204f, -0.00137844f, 0.08465412f, -0.00928564f, 0.00367214f, 0.00902796f, 0.07548070f, -0.05777521f, 
    0.03634859f, 0.21450408f, -0.05915244f, 0.07145178f, 0.02939305f, -0.00098765f, 0.00335671f, -0.08034380f, 
    0.02219621f, 0.00328340f, 0.05875510f, 0.04215878f, -0.05760309f, 0.20263650f, 0.20281650f, 0.14869775f, 
    0.13927920f, 0.19078963f, -0.03928894f, -0.07589232f, -0.01611667f, -0.10300342f, 0.13143493f, -0.06570294f, 
    -0.01991092f, 0.05614893f, -0.15859212f, -0.12667653f, -0.03751145f, 0.10380042f, -0.09485824f, 0.02197801f, 
    -0.02963238f, -0.09122173f, -0.16931912f, 0.00985599f, 0.04027226f, -0.02086293f, -0.12507993f, -0.05127626f, 
    0.04191656f, 0.06986105f, -0.01650445f, -0.03117222f, -0.01363677f, 0.03997364f, 0.08457571f, -0.03319149f, 
    -0.12342892f, 0.09933481f, 0.01227897f, 0.03102482f, 0.04790917f, -0.04510394f, -0.00716672f, 0.08721806f, 
    0.02548842f, -0.12605083f, 0.10346244f, -0.09575027f, -0.05461288f, -0.05026738f, -0.01745974f, 0.06115888f, 
    0.02741322f, 0.09551419f, -0.04654064f, 0.06303150f, -0.01770930f, 0.05182902f, 0.06186593f, 0.02662202f, 
    0.09910204f, 0.12483744f, 0.05871889f, 0.01270708f, 0.02673000f, 0.08036339f, 0.04188111f, -0.00808055f, 
    0.09588951f, -0.11611696f, 0.09396254f, -0.18171901f, 0.03260977f, 0.07163054f, -0.01368437f, 0.05812722f, 
    0.05271946f, -0.07345153f, -0.01459768f, -0.10343522f, 0.03561155f, -0.09163639f, 0.16587739f, -0.02617800f, 
    0.18296230f, -0.05003755f, 0.00486377f, -0.02958589f, 0.03999696f, -0.05883904f, -0.10594618f, 0.02272299f, 
    -0.07887980f, 0.15484478f, 0.07943067f, 0.04559954f, 0.24270004f, 0.08439597f, 0.10392439f, 0.04571135f, 
    0.06024228f, 0.05511405f, -0.01278394f, 0.04798458f, 0.02016048f, -0.04209132f, 0.02643111f, 0.04858782f, 
    0.03508657f, -0.11274283f, -0.03464361f, -0.16340034f, 0.05733598f, -0.09861082f, 0.08092200f, -0.07166620f, 
    0.11925838f, -0.12302589f, -0.02682249f, -0.02016601f, -0.03034503f, -0.09044775f, 0.10314522f, 0.21409616f, 
    0.03979082f, -0.04508309f, 0.05472874f, -0.14416775f, -0.06871540f, 0.05116686f, 0.14687692f, 0.01476013f, 
    0.00642449f, 0.03743628f, -0.04920329f, 0.24196270f, -0.08081167f, -0.11783639f, 0.02473864f, -0.03439376f, 
    -0.01315016f, 0.09672984f, -0.01139614f, 0.06333911f, -0.09169987f, 0.11401989f, 0.00150967f, 0.05555959f, 
    -0.00470517f, -0.06315932f, -0.02795532f, 0.07713010f, 0.09096006f, -0.03421459f, -0.08699753f, -0.04000559f, 
    -0.11446175f, -0.06900515f, 0.20081688f, 0.21877714f, 0.10040953f, -0.05450772f, 0.00653611f, -0.11371711f, 
    0.03617760f, -0.04722405f, -0.07717799f, 0.04245391f, -0.02582918f, -0.05984616f, -0.18449640f, -0.12608577f, 
    0.06539124f, 0.11796853f, 0.00646252f, 0.00021350f, -0.12544431f, 0.02346583f, -0.00312205f, -0.00975474f, 
    -0.19772378f, -0.01636965f, -0.05111967f, 0.03551408f, -0.09426122f, 0.13611174f, -0.00244263f, -0.04532310f, 
    0.09655754f, -0.04748590f, 0.09217372f, 0.03283230f, 0.20942754f, 0.01549671f, -0.01177171f, -0.20526491f, 
    -0.06963756f, -0.03385666f, -0.10770825f, -0.15105064f, -0.14721912f, 0.04194044f, -0.03334208f, 0.05410423f, 
    0.20632672f, 0.03301648f, 0.05376229f, 0.09886753f, 0.06827245f, 0.02785873f, -0.11423656f, 0.00539155f, 
    0.04328594f, 0.03559154f, -0.09093247f, 0.04153419f, 0.01794725f, -0.09619713f, 0.06892264f, -0.01870306f, 
    -0.01745481f, 0.06092149f, -0.03770427f, 0.04518852f, 0.08336015f, 0.00843020f, 0.04809984f, 0.06881016f, 
    -0.24577163f, -0.02889855f, -0.14104736f, 0.16111523f, -0.02478427f, 0.06713785f, 0.03630284f, -0.01343298f, 
    0.02981894f, -0.01306930f, 0.07669227f, 0.15972920f, -0.20306587f, 0.01875890f, -0.09006762f, -0.07626094f, 
    0.14974071f, -0.00734404f, -0.02292268f, -0.09541580f, -0.03887946f, -0.06017433f, -0.03347581f, -0.08059374f, 
    0.11559825f, 0.20725948f, -0.10766309f, 0.01430386f, 0.18920992f, 0.09086662f, 0.04416189f, -0.04266025f, 
    -0.03395351f, -0.06775147f, -0.04605945f, -0.06692100f, 0.13283165f, -0.03497177f, 0.07743479f, 0.04368419f, 
    -0.01727443f, -0.07000916f, 0.00949449f, -0.07298376f, -0.08684099f, 0.10565754f, 0.00018772f, -0.03387062f, 
    0.24734035f, 0.25528640f, 0.23680218f, -0.19077833f, -0.09426271f, -0.11614411f, -0.16537610f, -0.03434407f, 
    0.01557185f, 0.03595008f, -0.02805610f, -0.23004062f, -0.05146978f, -0.08609785f, -0.09603046f, 0.05179225f, 
    -0.10927334f, 0.09358923f, 0.06295598f, 0.04026433f, -0.00085986f, 0.12230708f, 0.03925922f, 0.05189540f, 
    -0.06898753f, -0.01811391f, 0.04668162f, 0.14106894f, 0.07401118f, -0.08034042f, -0.00317674f, -0.10356494f, 
    0.07860991f, 0.00722538f, 0.03579652f, 0.03790873f, -0.09493257f, -0.19283888f, -0.00138051f, -0.11949787f, 
    0.03472905f, 0.04640556f, 0.06389572f, -0.02340756f, 0.08805677f, -0.07461521f, 0.06123157f, -0.08929166f, 
    0.14974274f, 0.21476935f, 0.05607848f, 0.17088920f, 0.08492987f, 0.04444808f, -0.07380988f, -0.04435514f, 
    0.01685663f, -0.03226895f, 0.05033306f, 0.01163471f, 0.00811766f, -0.06846696f, 0.11582899f, -0.14378771f, 
    -0.06175416f, -0.09379439f, -0.01528948f, -0.09238976f, -0.05710280f, 0.13315815f, -0.05145066f, 0.02468222f, 
    -0.26700139f, 0.05858907f, 0.17610365f, -0.04000140f, 0.06611190f, -0.09810994f, -0.02947377f, -0.01883090f, 
    0.03191358f, 0.05902491f, 0.05751629f, 0.11334633f, 0.15353018f, 0.14788161f, 0.25762630f, 0.00272502f, 
    0.09292909f, 0.05078453f, 0.02435349f, 0.07078926f, -0.01221360f, -0.09060866f, 0.10757694f, 0.04474330f, 
    0.01504503f, 0.11018158f, 0.00151775f, 0.14529751f, 0.06820348f, 0.11325084f, 0.04272965f, 0.02796643f, 
    -0.03077433f, -0.09513488f, -0.00352974f, 0.06186405f, -0.18522903f, -0.03310490f, -0.00023835f, -0.19795172f, 
    -0.03786758f, -0.01276639f, 0.01978301f, 0.12403836f, 0.00167411f, 0.10792402f, 0.00196024f, 0.04083991f, 
    -0.03731221f, -0.22759654f, -0.09994174f, 0.04885669f, 0.02877356f, -0.04907177f, -0.01955476f, -0.05251641f, 
    -0.05353693f, 0.01811930f, 0.09802211f, 0.03249684f, -0.08081618f, -0.17628625f, 0.01970606f, 0.22541249f, 
    0.10479735f, 0.01240761f, 0.01609267f, -0.10928012f, -0.17129222f, -0.01533797f, 0.00585984f, 0.01126375f, 
    0.01452856f, -0.02105968f, -0.14035611f, -0.18798341f, -0.01457083f, -0.01774202f, -0.04254048f, -0.06361198f, 
    0.03852205f, 0.08118574f, 0.03333143f, 0.00240375f, -0.01543672f, -0.11073482f, -0.03687089f, 0.22596888f, 
    0.09135526f, 0.03826452f, 0.04121114f, 0.02082114f, 0.04449078f, -0.10901240f, -0.00050744f, 0.09683845f, 
    0.27904242f, -0.04506781f, 0.05719070f, 0.02541721f, 0.15306255f, -0.00385670f, 0.04678978f, 0.03161123f, 
    -0.06044504f, 0.11350708f, 0.01606401f, -0.08727720f, 0.01092153f, -0.09697674f, 0.06697902f, -0.05389804f, 
    0.00638844f, 0.08511794f, -0.05448456f, -0.05255719f, 0.02916869f, 0.02104745f, -0.01785082f, 0.04291817f, 
    -0.23663905f, 0.18842104f, -0.03884396f, -0.17881316f, 0.01599813f, 0.00748416f, -0.12618412f, 0.06666356f, 
    0.06169147f, -0.00577026f, -0.10618990f, -0.14540346f, 0.17286475f, 0.13988125f, 0.13871558f, 0.16600955f, 
    0.12842454f, 0.15015957f, -0.05468295f, 0.00124293f, 0.06269237f, -0.02991738f, 0.06520171f, -0.00594944f, 
    0.15904962f, 0.06909333f, -0.04254170f, 0.20968522f, 0.04738175f, -0.04029961f, 0.04579590f, -0.08283640f, 
    -0.01606448f, -0.05151917f, 0.01425353f, 0.06575929f, 0.03745621f, -0.20431161f, -0.02005992f, -0.21410087f, 
    -0.01396482f, -0.00909069f, -0.00589267f, -0.02685902f, -0.01992831f, 0.09667804f, -0.04060349f, 0.13962200f, 
    0.06331068f, -0.09428138f, -0.05677031f, 0.27681011f, 0.00027826f, -0.04203305f, -0.02298022f, 0.02253735f, 
    -0.00189433f, 0.06099649f, 0.02094953f, 0.06735342f, 0.29992148f, -0.01450633f, 0.02616273f, -0.13996594f, 
    0.00167022f, 0.05536603f, -0.04713896f, -0.00315562f, 0.02755356f, 0.02264423f, -0.04368347f, 0.02244016f, 
    0.16472751f, 0.05235904f, -0.08319658f, 0.18069440f, 0.02465756f, 0.11477188f, 0.04021215f, -0.08057005f, 
    -0.15187740f, -0.03051226f, -0.07153840f, -0.03376775f, -0.12534855f, 0.07281578f, -0.11806219f, -0.19227955f, 
    -0.00265014f, -0.09193740f, -0.00813178f, 0.08641278f, 0.03870352f, 0.16999283f, 0.09185666f, -0.09295338f, 
    0.12522854f, 0.09865088f, -0.07854040f, 0.05824681f, 0.00343821f, 0.10009366f, -0.06724030f, -0.11313505f, 
    -0.00981880f, 0.02026362f, 0.08131910f, -0.06786285f, -0.04545812f, -0.11068863f, 0.04187794f, 0.10396937f, 
    -0.05105110f, 0.03005059f, 0.12332281f, -0.06414381f, -0.11239149f, -0.00511535f, -0.02029691f, -0.05265908f, 
    -0.04087168f, 0.14018729f, -0.08617827f, 0.17761104f, 0.00960285f, -0.00940767f, 0.12993944f, 0.09564828f, 
    0.05486920f, -0.05405725f, -0.06326248f, -0.12705281f, 0.04812245f, 0.25770280f, 0.00322632f, -0.05726787f, 
    -0.02916940f, -0.07091170f, -0.05680157f, -0.13078997f, 0.03974449f, 0.03751660f, 0.03438715f, 0.01659810f, 
    -0.26712757f, -0.02524293f, -0.10916850f, 0.06166913f, 0.09772640f, 0.02614363f, 0.04479736f, -0.04386557f, 
    -0.05726719f, -0.07189795f, 0.02113182f, -0.04931161f, -0.18037361f, 0.06726493f, -0.03200400f, 0.04222553f, 
    0.04282435f, 0.06515921f, 0.09174907f, 0.01370896f, -0.00568755f, -0.12910821f, 0.02124448f, 0.09364317f, 
    0.13017519f, 0.17428483f, 0.00061673f, 0.04730805f, 0.03803575f, 0.01360251f, 0.00316577f, 0.00122837f, 
    0.03480331f, 0.06706649f, -0.00636784f, -0.03359986f, 0.08264765f, 0.07440081f, 0.15219706f, 0.10325155f, 
    -0.05794965f, 0.09634144f, -0.01249765f, 0.03822314f, -0.02364801f, 0.08302767f, -0.02778311f, -0.01962049f, 
    0.18081963f, -0.01462947f, 0.03921673f, 0.20497897f, 0.01621257f, 0.00712645f, -0.06982279f, -0.03437779f, 
    0.10813712f, 0.05445227f, 0.05204370f, 0.04415638f, 0.29277384f, -0.05260380f, -0.06249935f, 0.01619375f, 
    0.06770717f, 0.03827538f, -0.00291529f, -0.15469451f, 0.00948310f, -0.02055949f, -0.16339596f, 0.00414313f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00756208f, -0.00644342f, 0.01851112f, -0.03324491f, 0.02069440f, -0.02024656f, 0.00993233f, -0.02697827f, 
    0.04677773f, 0.01434731f, -0.00228471f, -0.00928932f, -0.03505166f, 0.01818765f, 0.02226597f, -0.03785219f, 
    0.00560300f, -0.02056720f, -0.03482480f, 0.02512765f, 0.10940611f, 0.09116049f, 0.02058909f, 0.01576357f, 
    -0.03394260f, -0.00827739f, 0.07878010f, -0.00184166f, 0.02618400f, 0.08353453f, 0.01247810f, 0.02896461f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.01029751f, -0.06584430f, 0.11024389f, 0.14345495f, -0.03626140f, 0.00427017f, -0.15191242f, -0.06714252f, 
    0.43092051f, 0.07171318f, -0.50799674f, -0.02508590f, 0.08490216f, -0.10241317f, -0.26154560f, 0.30001843f, 
    -0.13633573f, -0.00864258f, 0.03240004f, 0.21499224f, 0.14451741f, 0.12619731f, 0.07798928f, -0.07760616f, 
    -0.06476780f, -0.03004644f, -0.21793033f, -0.12313899f, -0.14803931f, 0.25659701f, 0.05046199f, 0.24018300f, 
    0.08946954f, 0.34136257f, 0.10098832f, -0.06954262f, 0.02282575f, 0.04420560f, 0.03191321f, 0.18292886f, 
    0.02473859f, 0.01153502f, -0.45481083f, 0.12218808f, -0.08001782f, 0.10443669f, -0.18012039f, -0.04686293f, 
    0.19745582f, 0.14370175f, -0.08258212f, 0.23924194f, -0.34610602f, -0.04750105f, 0.14631160f, 0.08813658f, 
    0.08562192f, 0.07929983f, -0.18898436f, -0.20186785f, 0.12255159f, 0.17441061f, -0.15083981f, -0.36686945f, 
    -0.14072631f, -0.19411127f, 0.05463766f, 0.06932168f, 0.14294259f, 0.15373668f, -0.15722875f, 0.18423057f, 
    -0.33940506f, -0.09180172f, 0.24750376f, 0.15547031f, 0.06660274f, 0.09335395f, 0.31003940f, -0.23475994f, 
    0.25971428f, 0.10485869f, -0.04611477f, -0.10146862f, 0.23764934f, -0.23434407f, 0.16345173f, -0.10800437f, 
    -0.17205422f, 0.01617773f, 0.27583277f, 0.16899294f, -0.00887328f, -0.17005378f, -0.06491579f, -0.15678784f, 
    0.15240781f, 0.26939136f, 0.12620620f, 0.11846355f, 0.12405372f, -0.11718670f, 0.04046362f, -0.20772754f, 
    0.28050527f, -0.11280090f, 0.50337136f, 0.03465620f, 0.09481761f, 0.16814791f, -0.27520591f, -0.27559355f, 
    0.12337993f, -0.13207427f, -0.00009875f, 0.04174240f, 0.00843112f, 0.09606005f, 0.20898460f, -0.11230724f, 
    0.12666367f, 0.08283342f, -0.19625817f, -0.09630252f, 0.16082734f, 0.17458752f, 0.09639241f, 0.00638442f, 
    0.13734062f, -0.06718709f, 0.05175081f, 0.12704436f, 0.11961874f, 0.00632940f, 0.13397883f, 0.16646428f, 
    -0.08863972f, -0.06600986f, -0.19962682f, -0.13446668f, -0.04665533f, -0.09630725f, 0.17345436f, 0.15003130f, 
    0.28093272f, 0.09581273f, 0.16253370f, 0.19660158f, -0.27912065f, -0.21077909f, -0.09854774f, -0.12629668f, 
    -0.11477650f, -0.16686480f, 0.12196171f, -0.03678070f, 0.03240722f, -0.26718420f, -0.15782066f, 0.00788728f, 
    0.14162144f, 0.02616828f, -0.11432293f, 0.02170156f, 0.00535046f, 0.16999185f, -0.03162713f, -0.28161281f, 
    0.09922019f, 0.07746071f, -0.01370299f, 0.15780836f, 0.08940674f, 0.16272201f, 0.03732484f, -0.09279830f, 
    0.10865268f, 0.02568842f, 0.03772739f, -0.03782910f, 0.03414861f, 0.46526939f, -0.18414555f, -0.11668886f, 
    0.01212364f, -0.05868908f, 0.34672105f, 0.11220673f, -0.13393566f, 0.03388151f, 0.03205216f, 0.29398578f, 
    0.02861070f, 0.41776863f, 0.03236419f, 0.16143350f, -0.03575354f, 0.00805052f, -0.01658881f, 0.08180392f, 
    -0.15698721f, -0.10256705f, 0.49859980f, -0.12573430f, -0.12865303f, -0.00974003f, -0.26963905f, -0.13897564f, 
    0.16268459f, 0.07212047f, 0.12846504f, 0.15415528f, 0.07637489f, 0.25279784f, -0.16900249f, 0.13141488f, 
    0.05370048f, 0.01421910f, -0.21448810f, -0.06477911f, 0.09876890f, -0.07050707f, -0.18060578f, -0.12786914f, 
    -0.02745277f, -0.03464532f, -0.12115189f, -0.09147219f, -0.10901788f, -0.17364813f, 0.06884353f, 0.41694170f, 
    0.28334534f, -0.03492787f, 0.09384724f, -0.06267818f, 0.05147620f, -0.06349337f, -0.27329326f, 0.21348497f, 
    0.04002171f, -0.08011845f, 0.05781291f, 0.19633673f, -0.01787646f, 0.06284624f, 0.24589826f, 0.02237972f, 
    -0.03125943f, -0.14158128f, -0.27728775f, -0.13343604f, -0.11722092f, -0.16072887f, 0.11918806f, -0.32117024f, 
    -0.02116412f, -0.07387818f, 0.07737019f, -0.09398033f, -0.10103255f, 0.08499932f, -0.12303796f, -0.16224676f, 
    -0.08683598f, -0.10681771f, -0.14411078f, 0.08662235f, 0.09832465f, 0.05342681f, -0.11284890f, -0.16137154f, 
    -0.09922787f, 0.02478660f, -0.08520387f, -0.06137722f, -0.12130232f, 0.12402604f, 0.07903484f, -0.05627710f, 
    -0.03459859f, 0.15540180f, 0.17866623f, 0.13480778f, 0.06620155f, -0.15942694f, 0.06444698f, -0.17717299f, 
    0.06236437f, -0.35295880f, -0.00864291f, -0.08905858f, 0.02010495f, -0.14712098f, -0.12939198f, 0.19471231f, 
    -0.34762549f, -0.08357567f, -0.39509374f, -0.01228689f, -0.09917434f, 0.11374325f, -0.16050638f, 0.08647343f, 
    0.24341114f, 0.01508087f, -0.05965771f, 0.14503162f, -0.20427327f, 0.15285403f, 0.00249215f, 0.12009052f, 
    -0.10213922f, -0.07523039f, 0.11857055f, -0.06781330f, 0.06582436f, -0.24598959f, -0.05555541f, 0.01911337f, 
    0.13545436f, -0.06278256f, -0.10151722f, 0.12027117f, -0.06310705f, -0.11268472f, 0.16817945f, 0.04807375f, 
    -0.02957690f, 0.12339694f, 0.14674546f, 0.01504820f, -0.00850329f, 0.07546139f, 0.07978150f, -0.01112293f, 
    -0.10164611f, -0.00042447f, -0.10351595f, 0.00896902f, 0.01822904f, -0.18610527f, -0.14930369f, 0.09669181f, 
    0.00084878f, -0.12391008f, 0.03257788f, -0.02852698f, 0.01272725f, -0.09034080f, -0.11621399f, -0.09769948f, 
    0.09584694f, 0.20613194f, -0.08724505f, 0.01579026f, 0.02586789f, 0.02196005f, 0.14222752f, 0.07709544f, 
    -0.02406555f, 0.04648058f, -0.06077424f, -0.09568360f, 0.14245848f, 0.07198177f, 0.30005828f, -0.00245575f, 
    0.14221588f, -0.00950673f, -0.17319140f, -0.19757360f, -0.30878758f, 0.21218584f, 0.12921278f, -0.09282945f, 
    0.07832243f, -0.16549736f, 0.43753216f, -0.12234905f, -0.06003287f, 0.00172236f, 0.08547219f, -0.27619103f, 
    0.10864252f, 0.21742551f, -0.15698209f, 0.01223540f, 0.02738786f, -0.02448879f, -0.05803568f, 0.04639213f, 
    -0.02406336f, -0.14577331f, 0.05343710f, -0.04963040f, 0.17449583f, 0.02164705f, -0.07811710f, 0.13261026f, 
    0.18326071f, -0.11695157f, 0.18135893f, -0.08236559f, 0.31524327f, 0.08494954f, 0.18248691f, 0.01565159f, 
    -0.16165255f, -0.14242215f, 0.00236407f, -0.32646599f, 0.16870229f, 0.03468036f, 0.06942222f, -0.01532113f, 
    0.07738040f, 0.01310726f, 0.13472213f, 0.15504993f, 0.12506391f, 0.07721285f, 0.09101452f, 0.11616889f, 
    0.29046348f, -0.13800025f, 0.34365934f, 0.04205525f, 0.15406390f, -0.15379070f, -0.10466207f, -0.33485076f, 
    0.06077998f, -0.16110574f, 0.13835709f, -0.10638076f, 0.29028025f, -0.13480943f, 0.08084610f, -0.11180091f, 
    0.09183532f, -0.00807024f, 0.17906879f, 0.23856033f, -0.09477337f, 0.37858385f, 0.14400567f, -0.25999466f, 
    -0.10092379f, -0.29206109f, 0.01300231f, -0.17745490f, -0.12938574f, -0.10881208f, -0.15657964f, -0.11134908f, 
    0.19410205f, -0.01499716f, 0.26872113f, -0.13126801f, 0.04026074f, 0.06499419f, -0.09264129f, 0.25882003f, 
    -0.05449314f, -0.13158873f, 0.16204746f, 0.17113549f, 0.35794541f, 0.18814997f, -0.13998030f, -0.13951729f, 
    0.04103381f, 0.16989358f, -0.08219134f, 0.50340593f, 0.08679572f, 0.12011947f, -0.16160494f, 0.29969060f, 
    0.09783120f, -0.22733682f, 0.06593458f, 0.06049831f, -0.08821224f, -0.02243256f, -0.06054060f, -0.09593321f, 
    -0.15702243f, -0.07735635f, 0.06534015f, 0.10543513f, -0.17695972f, -0.02623186f, 0.23952740f, -0.14052743f, 
    -0.05167204f, -0.01031005f, 0.03310364f, 0.14415327f, 0.07597894f, -0.05084689f, 0.04122474f, 0.15541780f, 
    -0.02120155f, 0.08334025f, 0.28219581f, 0.32705462f, -0.16597161f, -0.20735118f, 0.08200514f, 0.10668347f, 
    0.07544505f, 0.04278339f, -0.11468271f, 0.04990065f, 0.14994705f, -0.03659512f, 0.02547221f, 0.23840858f, 
    -0.19355984f, -0.07483706f, -0.54799032f, -0.11031177f, -0.16612503f, 0.17046259f, 0.41909379f, 0.00098100f, 
    0.03109349f, -0.10991406f, -0.06440468f, 0.18370698f, -0.09554354f, 0.01908314f, 0.03021649f, -0.08953618f, 
    -0.06912638f, 0.04402059f, 0.30004716f, -0.33614409f, 0.07856417f, -0.22419682f, 0.16878705f, 0.11135811f, 
    0.12064435f, -0.02280181f, 0.01227642f, -0.11090620f, -0.06559629f, 0.17127126f, 0.07373485f, -0.01039299f, 
    0.03950663f, -0.05871233f, 0.00571465f, 0.02332172f, 0.04745773f, -0.07196890f, -0.00416040f, 0.02875410f, 
    -0.15248838f, 0.12962911f, 0.05788240f, -0.05957431f, 0.02733043f, -0.01958076f, -0.04620839f, 0.11969180f, 
    -0.03684403f, -0.03412346f, 0.06027612f, -0.03819067f, 0.08499894f, -0.00532513f, 0.00039093f, 0.08421828f, 
    -0.17615128f, 0.18863797f, 0.10214117f, 0.10109198f, -0.04419109f, -0.04699055f, 0.13238974f, -0.25173092f, 
    0.15874936f, -0.16256037f, 0.17249766f, -0.17567717f, 0.02270872f, 0.16766672f, 0.19446483f, -0.25242957f, 
    -0.21772191f, -0.13465367f, 0.04136248f, 0.13230723f, -0.13770778f, 0.25154856f, 0.11929005f, -0.13996236f, 
    -0.15242742f, -0.02174949f, 0.30051103f, -0.06195838f, -0.05086766f, 0.21758598f, -0.04479304f, 0.06681347f, 
    -0.08788915f, 0.20280042f, 0.10713312f, -0.09612044f, 0.00682097f, 0.11431403f, -0.15878390f, 0.03487467f, 
    0.38483632f, -0.11455405f, 0.01095038f, -0.15846030f, -0.11667095f, 0.10871547f, 0.23583966f, 0.33209199f, 
    -0.27200496f, 0.10842530f, 0.01807230f, 0.09025043f, 0.11468954f, -0.04295095f, -0.00581868f, -0.01185637f, 
    -0.06320667f, 0.03507170f, -0.03352272f, -0.10051762f, 0.14455961f, -0.05936500f, -0.14544332f, 0.39119354f, 
    -0.07025321f, -0.07923909f, 0.10040327f, -0.06190299f, 0.07078635f, -0.07134317f, 0.01570533f, -0.07949867f, 
    0.06877139f, -0.01349405f, -0.15437156f, -0.11370151f, -0.14731878f, -0.03233403f, -0.09211136f, -0.06520718f, 
    -0.10168926f, 0.12653323f, -0.13916212f, -0.17657629f, -0.02819129f, 0.00048648f, -0.06072649f, -0.11231277f, 
    -0.07182508f, -0.03783004f, 0.01761719f, -0.05460345f, -0.05677248f, 0.17503741f, 0.17423117f, -0.15415198f, 
    -0.02908623f, 0.06181515f, 0.05902591f, 0.02896720f, 0.13510990f, 0.01110906f, 0.12748963f, 0.08240871f, 
    0.06852587f, 0.09540171f, 0.34424147f, 0.03118273f, -0.12168066f, -0.14678317f, -0.45158198f, 0.21547712f, 
    0.11428060f, 0.04808377f, 0.14365363f, 0.31660786f, -0.15458742f, 0.07160054f, -0.01962429f, -0.01069557f, 
    0.14903240f, -0.02843426f, -0.41134894f, -0.08524140f, 0.14326780f, -0.02854533f, -0.08580936f, -0.25521904f, 
    -0.10909165f, 0.04583776f, 0.10201968f, -0.12597750f, 0.06676467f, 0.13734837f, 0.15411884f, -0.33150741f, 
    -0.03406922f, 0.17479801f, -0.33390093f, 0.12197771f, -0.03557688f, 0.04175919f, 0.20227179f, -0.28600052f, 
    0.05219861f, 0.14501275f, -0.09662821f, 0.13401555f, 0.32873791f, 0.19804122f, 0.16157836f, -0.01223584f, 
    -0.06246173f, 0.10356270f, 0.12282199f, -0.06088877f, -0.12660523f, 0.17906749f, -0.15433183f, 0.01051681f, 
    -0.03437248f, 0.36929840f, -0.07667635f, -0.11162548f, 0.10522905f, 0.12584449f, -0.01451041f, -0.27013966f, 
    0.09621137f, -0.15827975f, 0.35303479f, -0.07736854f, 0.03708168f, -0.10668015f, -0.12202635f, -0.29588693f, 
    0.20771047f, -0.12129854f, -0.06569501f, 0.03025191f, -0.13419870f, -0.30136129f, 0.29548544f, -0.14309411f, 
    0.15935451f, -0.08699168f, -0.30867699f, 0.15950352f, 0.09168277f, 0.10278668f, -0.16432895f, 0.12834524f, 
    0.07509949f, 0.38318634f, -0.09617618f, -0.07782710f, -0.11949988f, 0.13775264f, 0.08916707f, -0.30798763f, 
    -0.09363087f, 0.02500220f, -0.09708465f, -0.10417743f, 0.08344041f, 0.04830178f, 0.18931103f, -0.11511611f, 
    0.22323656f, -0.06682984f, 0.08559017f, -0.00287536f, -0.18493381f, -0.42625591f, 0.06612752f, -0.05380000f, 
    -0.13639916f, -0.10542126f, -0.13354832f, -0.12336975f, 0.02920243f, 0.20360895f, 0.07186566f, 0.33115041f, 
    0.00269539f, -0.61974949f, 0.06649983f, 0.12144608f, -0.05610952f, -0.04454189f, 0.01712426f, 0.23171692f, 
    0.14603242f, 0.15711480f, 0.13513571f, 0.12848783f, -0.05953975f, 0.00581182f, -0.06705058f, -0.06267130f, 
    0.15995611f, -0.13386759f, -0.12446624f, 0.08628247f, 0.29855502f, 0.28001854f, 0.25340217f, -0.00657708f, 
    -0.09770140f, -0.08982778f, -0.03737539f, 0.13388602f, -0.08138904f, 0.27708343f, 0.14201945f, -0.28964067f, 
    0.00963730f, 0.13556136f, 0.12375473f, -0.03719424f, -0.05132885f, -0.08616333f, -0.02009543f, 0.13988298f, 
    -0.08218704f, 0.12082415f, 0.15839764f, -0.12362567f, -0.02636280f, 0.04291482f, 0.07885643f, 0.13506593f, 
    -0.14232871f, 0.11051941f, -0.04185916f, -0.16462106f, -0.06522086f, -0.06540044f, -0.05945027f, 0.12259347f, 
    -0.08322715f, 0.00313275f, 0.10521621f, -0.05196684f, -0.00923907f, -0.06274885f, 0.11751619f, -0.10398760f, 
    -0.05410945f, 0.31367218f, 0.08128930f, 0.00341148f, 0.06840853f, -0.05274883f, 0.05188145f, -0.15178201f, 
    -0.23311135f, 0.02679578f, 0.00016884f, 0.00247881f, -0.10017560f, -0.13676798f, 0.10526260f, -0.02247141f, 
    0.21203183f, -0.03250137f, 0.11730799f, -0.05672260f, 0.21987060f, 0.01475781f, 0.06358656f, 0.15545398f, 
    0.05990583f, 0.00232822f, 0.34887159f, -0.38190854f, 0.15746982f, -0.23008467f, -0.05011915f, 0.30941218f, 
    0.09642404f, 0.00527602f, 0.05634188f, 0.05697811f, -0.05884953f, 0.10724552f, 0.03383042f, 0.44126046f, 
    0.11784115f, 0.00319044f, -0.15237948f, -0.16805641f, -0.05125590f, -0.06191489f, 0.09337925f, 0.34985650f, 
    -0.09007737f, -0.00405157f, -0.09682391f, 0.19405763f, 0.01026354f, 0.46769699f, -0.26746914f, -0.15938927f, 
    0.02130612f, 0.07172357f, 0.20261875f, -0.10581413f, 0.13322522f, -0.10629579f, -0.01843107f, -0.10369918f, 
    -0.13936426f, 0.10967904f, 0.06064854f, -0.00076957f, 0.09908652f, -0.14959866f, -0.00735505f, -0.11781728f, 
    -0.26138723f, 0.15242758f, 0.19324210f, -0.08513004f, 0.08264847f, 0.11302417f, 0.29961184f, 0.05017511f, 
    0.18378578f, -0.11180923f, 0.09746508f, 0.00018665f, -0.19928081f, 0.00055018f, -0.27626407f, 0.18296950f, 
    -0.16665916f, 0.10679317f, 0.04255008f, 0.19786963f, 0.02038201f, -0.36517036f, -0.15674312f, 0.31431767f, 
    -0.02216791f, -0.10593829f, -0.11732265f, 0.05863573f, -0.16116680f, -0.10482195f, -0.12709244f, 0.00957515f, 
    -0.10703386f, 0.14603475f, 0.11651064f, -0.15274547f, 0.08128037f, 0.00207701f, -0.07535543f, -0.15638645f, 
    -0.05633431f, 0.03389678f, -0.10185754f, -0.11896025f, -0.09732035f, -0.04556598f, 0.03056649f, -0.14930694f, 
    0.07409197f, -0.03343345f, -0.13111074f, 0.16507784f, -0.12269302f, 0.08972685f, 0.02792247f, 0.10676063f, 
    -0.12652783f, 0.09770997f, -0.01818288f, 0.15364073f, -0.09475597f, -0.11931597f, -0.04799538f, 0.40253097f, 
    0.13736443f, -0.03768441f, -0.01839315f, -0.01045528f, -0.09211143f, 0.12113616f, 0.10905293f, 0.39959443f, 
    0.29061067f, -0.05033236f, -0.10331086f, -0.23505057f, 0.23626642f, -0.04108694f, 0.02998288f, -0.14255238f, 
    -0.16127148f, 0.16382636f, -0.13924934f, -0.13118093f, -0.09927528f, 0.03900664f, -0.08128798f, -0.28854191f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03177824f, 0.15428431f, -0.07078802f, 0.00155673f, 0.11364894f, 0.08133084f, 0.09912413f, -0.10955542f, 
    0.14165652f, 0.03898852f, -0.11564883f, 0.16990772f, -0.02913658f, 0.21062249f, -0.04744979f, 0.17769445f, 
    -0.02259268f, 0.06838327f, 0.19798347f, 0.16847590f, -0.10436778f, 0.00350020f, 0.21416888f, -0.02073984f, 
    -0.09529381f, -0.10063914f, 0.02940319f, 0.14024612f, 0.04029459f, -0.06863891f, -0.04031899f, -0.11997064f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.15627730f, 0.21468286f, -0.14445743f, -0.19172595f, 0.12713233f, -0.42781904f, 0.03456816f, 0.24785195f, 
    0.13337298f, 0.44798926f, -0.06061579f, -0.41352823f, -0.05828816f, -0.23925380f, 0.03977352f, -0.51952362f, 
    -0.17063864f, 0.12310721f, -0.56943160f, -0.29797757f, -0.16301511f, 0.27059153f, -0.23633750f, -0.31920317f, 
    -0.47986114f, 0.10045691f, -0.08145451f, -0.23834084f, 0.27225870f, -0.46765012f, 0.12488274f, 0.16974370f, 
    0.01872806f, -0.03137779f, -0.16674131f, 0.08216750f, -0.10514074f, -0.36307380f, 0.21816157f, 0.30222702f, 
    0.08604419f, -0.38233146f, -0.08843523f, -0.63121361f, -0.03039577f, 0.19274735f, 0.23365822f, 0.18724948f, 
    -0.48552120f, -0.12901405f, -0.09671238f, 0.18761005f, 0.00440024f, 0.32436985f, -0.26578692f, 0.23595686f, 
    -0.24887154f, -0.05100125f, -0.10982331f, -0.43821210f, 0.05533960f, 0.19486561f, -0.12342844f, -0.01954591f, 
    -0.23071271f, -0.03239626f, 0.05392800f, 0.28890580f, 0.09714564f, -0.21069863f, 0.12267021f, 0.03298599f, 
    0.01538212f, -0.02791016f, -0.15565495f, -0.39086482f, 0.13208339f, -0.14076784f, -0.15408094f, -0.05067664f, 
    -0.51813680f, -0.02484004f, -0.14916700f, -0.19500726f, -0.17617452f, 0.17210114f, -0.05841820f, 0.48619607f, 
    0.30428344f, -0.12763233f, 0.02686585f, 0.29336336f, -0.57856488f, -0.08212928f, 0.03559716f, -0.05397440f, 
    -0.21737748f, -0.29120401f, 0.05806836f, -0.78255284f, 0.16174266f, 0.33589399f, -0.25189972f, -0.57239503f, 
    0.13047603f, 0.22917832f, 0.03533436f, -0.11859318f, -0.16312914f, -0.16602866f, 0.35553581f, 0.13011737f, 
    -0.03159440f, 0.16010329f, -0.02655678f, -0.23263246f, -0.07080190f, -0.79660642f, 0.04189346f, -0.56198376f, 
    -0.55107552f, 0.13821740f, -0.11925379f, -0.11364451f, 0.32801259f, -0.02937708f, 0.13646917f, -0.21116455f, 
    -0.19313984f, 0.00008063f, -0.11578795f, -0.31419438f, 0.02147918f, -0.14587839f, 0.20097075f, 0.12159454f, 
    0.02540157f, 0.20629039f, -0.13298006f, 0.14840652f, 0.05497289f, -0.43482137f, -0.15789318f, 0.06908463f, 
    0.38755614f, -0.07541761f, 0.18678005f, 0.18120937f, 0.06385945f, -0.05315269f, -0.11126427f, -0.39761201f, 
    -0.45077518f, -0.13790250f, -0.08886480f, 0.07955035f, 0.30234870f, -0.06406315f, 0.06798208f, -0.17373209f, 
    0.25519523f, -0.09593745f, -0.51197392f, -0.04711381f, -0.08306897f, 0.08044333f, -0.07166726f, 0.03405664f, 
    0.15932062f, -0.40227330f, 0.05340188f, -0.18779270f, 0.19065434f, -0.09631837f, 0.10609572f, -0.51642925f, 
    -0.07698316f, -0.05307334f, -0.00985177f, 0.46656364f, -0.02710742f, -0.21026750f, 0.00959654f, -0.21484268f, 
    0.10937694f, -0.15239489f, -0.07046322f, 0.11345500f, 0.28252414f, -0.36839312f, 0.06592248f, 0.20441908f, 
    -0.40572396f, -0.10161761f, 0.17714278f, 0.16362645f, -0.17469642f, 0.11365706f, 0.13218513f, 0.08299316f, 
    0.11511978f, -0.21471721f, -0.13853401f, 0.36347240f, 0.16123867f, 0.35973623f, -0.10545928f, -0.32609293f, 
    -0.40504578f, 0.11224902f, -0.00113351f, -0.27112007f, 0.04324088f, -0.20480092f, -0.23094301f, -0.06928336f, 
    -0.55375755f, 0.07452354f, -0.08851558f, -0.00806098f, 0.09327353f, -0.74924529f, -0.08777957f, 0.29927683f, 
    -0.33984584f, -0.33882925f, 0.15518670f, -0.15671247f, 0.20481913f, 0.18850797f, -0.39938486f, -0.12721696f, 
    -0.03183946f, 0.05539157f, -0.10498866f, 0.13728350f, -0.36417073f, -0.14071918f, 0.10377236f, 0.08551584f, 
    0.12045374f, -0.13337690f, -0.05701952f, 0.16669235f, 0.17004211f, -0.00404051f, -0.33818638f, 0.13952364f, 
    0.35496047f, -0.52460635f, -0.08885938f, 0.04774318f, 0.03099419f, 0.19922370f, 0.02985772f, -0.17254384f, 
    0.31811881f, 0.07780745f, -0.41297346f, 0.11127555f, -0.30856788f, 0.13584644f, -0.18087421f, -0.10006843f, 
    -0.00964736f, -0.32513005f, 0.04538986f, 0.15812282f, -0.15771461f, 0.22437881f, 0.20311619f, 0.06692827f, 
    -0.31718329f, -0.01328835f, 0.39911821f, -0.01020492f, 0.01703871f, -0.10544711f, 0.13072327f, 0.20660326f, 
    0.06371799f, 0.07707661f, 0.03685490f, -0.57955182f, -0.22558190f, -0.46323463f, 0.00291826f, -0.55487055f, 
    -0.25298986f, 0.29408881f, -0.00028047f, -0.16026120f, 0.11082568f, -0.17964570f, -0.01069369f, -0.11227536f, 
    -0.13385750f, -0.03432662f, -0.03206702f, 0.32673535f, 0.16542490f, 0.03984964f, -0.68017662f, -0.36037835f, 
    0.18986030f, 0.15060832f, 0.01701657f, -0.32870528f, -0.00543033f, -0.30107328f, 0.00359672f, 0.16003630f, 
    0.30155894f, -0.17458002f, -0.14465153f, 0.11385003f, -0.01861314f, -0.30402419f, 0.04820229f, 0.15148649f, 
    -0.32054248f, -0.33541948f, 0.10444573f, 0.10015386f, -0.25282615f, 0.19774793f, 0.30215308f, -0.60283047f, 
    -0.15039730f, -0.17939761f, 0.08212694f, -0.47060320f, 0.11173373f, 0.21808110f, 0.20329995f, 0.13114065f, 
    -0.18766075f, 0.09385017f, 0.16878016f, -0.30226219f, 0.13257580f, -0.45834872f, 0.25879118f, -0.05113573f, 
    -0.07999690f, -0.01671924f, 0.16863249f, 0.15719578f, 0.00436234f, -0.22700167f, -0.11732282f, -0.49490553f, 
    0.02474232f, -0.21354702f, 0.30400628f, -0.37506470f, -0.00914680f, -0.33261991f, -0.51203036f, 0.06421155f, 
    -0.05932001f, -0.04972663f, 0.16014186f, -0.15558589f, 0.14848357f, 0.17283815f, 0.06752370f, 0.16359356f, 
    0.15525313f, -0.00648561f, -0.08890157f, 0.15394352f, 0.15686637f, -0.94031918f, 0.11981191f, -0.27112240f, 
    -0.36122632f, 0.25444680f, -0.01329780f, -0.00696983f, 0.01205921f, -0.81385988f, -0.16157584f, 0.17069732f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.01034859f, -0.10646266f, -0.12540959f, 0.06110932f, -0.01668301f, -0.12455560f, -0.12699361f, -0.04195418f, 
    0.01128338f, 0.17466235f, 0.12824681f, 0.06285512f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
