#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.67136759f, -0.38465720f, -0.69402951f, 0.23379856f, 0.28958061f, -0.42210099f, 0.52200973f, 0.56097114f, 
    -0.02519803f, -0.04949622f, 0.05544716f, -0.19489327f, 0.13459142f, -0.15461138f, 0.13043438f, -0.00743676f, 
    -0.13043152f, -0.14927772f, -0.12552589f, -0.07617780f, 0.08164191f, 0.07167950f, -0.13995910f, 0.09977789f, 
    0.03821044f, -0.36264011f, -0.54007125f, -0.60713112f, -0.52073586f, -0.13910812f, 0.38045269f, 0.23586486f, 
    0.21878321f, 0.32393038f, 0.42179891f, 0.20761557f, -0.07490584f, -0.07861907f, -0.23654924f, 0.06373356f, 
    0.02557255f, -0.17339376f, 0.26915151f, -0.11991431f, -0.09899864f, -0.14124328f, -0.09141441f, 0.02507496f, 
    0.06199814f, -0.02181462f, 0.59125119f, 0.00016161f, 0.55347389f, 0.55192232f, 0.36672056f, 0.53599489f, 
    -0.10327027f, -0.04174477f, -0.29035917f, -0.13572104f, 0.15800494f, -0.06050693f, -0.09406005f, 0.16294226f, 
    -0.06172692f, -0.07138857f, -0.13349865f, 0.00568182f, 0.07064522f, -0.04844706f, -0.02380223f, 0.18068835f, 
    0.18746158f, 0.19643612f, 0.22467218f, -0.16759959f, -0.50173420f, 0.44296253f, 0.51706791f, 0.01563760f, 
    -0.30668062f, -0.27764589f, 0.37072477f, -0.09339971f, -0.56881946f, -0.03647841f, -0.11196114f, -0.23216008f, 
    0.32531315f, 0.10011564f, 0.11144509f, 0.32502016f, -0.04605080f, -0.14650948f, -0.04907669f, 0.08536567f, 
    -0.12762690f, -0.08922106f, -0.00328833f, 0.02203763f, 0.63331491f, 0.24057683f, -0.50208360f, 0.76477134f, 
    0.24007072f, -0.02788386f, 0.29370850f, -0.21959212f, 0.45694327f, 0.13052121f, -0.05438217f, -0.00298562f, 
    -0.06018461f, -0.15091835f, -0.21404551f, -0.16029614f, -0.13499819f, -0.23270956f, -0.18614802f, -0.23950483f, 
    0.02651688f, 0.13735455f, 0.03471196f, 0.06681173f, -0.07559156f, 0.39144361f, -0.08907875f, 0.26848078f, 
    0.33013114f, 0.44364536f, 0.46967509f, 0.43501642f, 0.22607981f, 0.25703681f, 0.23288316f, -0.27696455f, 
    0.34600937f, 0.03218688f, -0.00227035f, 0.19013226f, -0.08661350f, -0.16990137f, 0.24025309f, -0.04305889f, 
    -0.12226888f, 0.11615556f, -0.03616026f, 0.17516129f, 0.06168227f, 0.12840837f, -1.02437186f, 0.66965944f, 
    0.21610995f, -0.30550727f, -0.15264848f, 0.16062784f, 0.68788046f, 0.16489217f, 0.22862856f, 0.37976119f, 
    -0.10467647f, 0.03843816f, 0.09295929f, -0.21158880f, 0.06704126f, 0.14707169f, 0.03622754f, 0.04189914f, 
    0.05936474f, -0.09563209f, 0.09062282f, 0.03865440f, 0.03584405f, 0.00372941f, 0.06574701f, 0.43303770f, 
    0.56547153f, -0.41637328f, -0.14347777f, 0.63353384f, -0.26008955f, -0.53470057f, 0.42438993f, 0.08469252f, 
    0.34263024f, -0.44216007f, -0.11438300f, -0.14183699f, -0.24474478f, 0.05435655f, 0.18413332f, -0.07125014f, 
    -0.27206114f, -0.02289020f, 0.14532150f, -0.01940766f, 0.04387810f, -0.11359929f, -0.20115533f, -0.18351883f, 
    -0.46742868f, -0.11185207f, 0.16283861f, -0.01543436f, -0.00713467f, 0.24416874f, -0.31347635f, -0.43279138f, 
    -0.47202125f, -0.62519544f, -0.30624962f, -0.03142754f, 0.24837239f, -0.11067235f, 0.11957499f, -0.20962305f, 
    -0.31824166f, -0.25886124f, 0.00853159f, 0.20796311f, 0.29441109f, 0.37027246f, -0.04611672f, 0.00437994f, 
    -0.04954406f, 0.32818463f, 0.58441150f, 0.54757309f, 0.57982701f, 0.25250152f, -0.12623611f, 0.08841462f, 
    -0.33803940f, -0.04325235f, -0.03568770f, 0.08900283f, 0.13346258f, 0.17268586f, 0.03242342f, -0.11370189f, 
    0.29247025f, 0.25063512f, 0.08949502f, -0.11443196f, 0.03443163f, 0.17484999f, -0.03374394f, -0.17247796f, 
    0.16313590f, 0.15629697f, 0.91081893f, 0.13726509f, -0.01848608f, 0.53000194f, 0.28696182f, -0.34929901f, 
    0.14013626f, 0.23981644f, -0.41500002f, -0.27247855f, -0.02804379f, -0.04377153f, 0.02518649f, -0.02595019f, 
    0.08908746f, 0.06870468f, 0.19422320f, 0.19080141f, 0.21122003f, 0.17043863f, 0.01282245f, 0.07820525f, 
    -0.00773303f, -0.12585928f, -0.04348193f, 0.54193658f, -0.45556939f, -0.31489170f, 0.24469124f, 0.29378605f, 
    0.45150584f, 0.12326515f, -0.49675208f, 0.19260304f, 0.22443835f, 0.08791802f, 0.29264852f, -0.23672074f, 
    0.29346490f, 0.09682590f, 0.06191497f, -0.16801199f, 0.01436528f, 0.15592064f, -0.00465804f, 0.18394308f, 
    -0.07688362f, -0.03007973f, -0.08971397f, 0.15593462f, 0.67535353f, 0.45901382f, 0.66818011f, -0.07465173f, 
    0.13041696f, -0.27426830f, 0.00414532f, -0.45319745f, 0.13269831f, 0.03489915f, 0.03575100f, 0.17101015f, 
    0.09543964f, -0.00436949f, 0.20733237f, -0.24511975f, -0.09280360f, -0.11792187f, -0.22675088f, -0.07135051f, 
    -0.30108297f, 0.13849655f, -0.09050851f, -0.24402098f, -0.05809519f, -0.42138788f, 0.61301160f, -0.13620141f, 
    -0.46160191f, -0.51030445f, 0.29550877f, 0.00611306f, -0.12732151f, -0.63828766f, -0.25129715f, 0.25886637f, 
    0.23321691f, -0.24125607f, 0.20123167f, -0.05323442f, -0.00244509f, 0.09312749f, -0.15288238f, 0.04256930f, 
    -0.06031039f, -0.20015611f, 0.09306978f, 0.19352497f, 0.04546536f, 0.41643924f, 0.69108009f, 0.51606947f, 
    0.00000527f, -0.21332169f, -0.13661703f, 0.23338574f, 0.41714743f, 0.30609292f, 0.45252755f, 0.41635892f, 
    -0.04494156f, 0.02366034f, -0.19286664f, -0.20132257f, -0.40374139f, -0.09671556f, -0.01592550f, -0.03060203f, 
    -0.10879735f, 0.14968012f, -0.11979079f, -0.33912721f, -0.06719173f, -0.13767709f, 0.09185258f, 0.19588788f, 
    0.32860646f, -0.49984428f, -0.68993872f, -0.73284203f, 0.22929330f, -0.44178566f, -0.15757193f, -0.14830235f, 
    -0.32687184f, 0.14386253f, 0.00164599f, 0.33853093f, 0.28497311f, 0.02066229f, 0.24537201f, -0.02227107f, 
    0.01661942f, 0.18647699f, 0.25831518f, 0.02127587f, -0.01114526f, -0.06117653f, -0.01258670f, 0.15086591f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02930565f, 0.11988165f, 0.09239716f, -0.11953922f, 0.12746404f, 0.06972589f, 0.01489010f, 0.06391289f, 
    0.22447330f, 0.13476853f, -0.14682563f, 0.16110376f, 0.14147131f, -0.04732619f, -0.00145266f, 0.26780739f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00599660f, 0.30034608f, -0.01297479f, 0.11823941f, 0.00048050f, -0.06194848f, 0.03755546f, -0.02061619f, 
    -0.10956856f, -0.05200749f, 0.00687567f, 0.04033865f, -0.05014963f, -0.15454499f, -0.03662588f, -0.09912498f, 
    0.02215688f, -0.00051077f, -0.04225319f, 0.20145193f, 0.00116845f, 0.00414433f, 0.02587021f, 0.05901693f, 
    0.08522641f, -0.04714293f, 0.01145154f, 0.25393528f, 0.07600256f, 0.05232656f, 0.06495847f, 0.04850958f, 
    -0.01669552f, 0.04440055f, 0.01947982f, 0.04280811f, -0.19287050f, -0.00352500f, 0.08864901f, 0.22746003f, 
    0.01867391f, -0.13261917f, -0.01531367f, -0.03906830f, 0.00214559f, -0.07737913f, 0.15910813f, 0.08624417f, 
    0.36092594f, -0.08098643f, -0.04092468f, 0.22771221f, 0.04626301f, 0.04227533f, 0.05797133f, 0.00147716f, 
    0.07451332f, 0.16836514f, 0.07193167f, -0.05431736f, 0.13656901f, 0.05174019f, -0.05163326f, 0.06675391f, 
    0.04821796f, 0.00489410f, 0.05201444f, -0.02888524f, 0.09393010f, -0.04911039f, -0.07654706f, 0.03005448f, 
    0.20675883f, 0.06250268f, 0.13685460f, -0.15518129f, -0.08562115f, -0.07146292f, 0.10307744f, 0.00755718f, 
    0.08255707f, -0.00182466f, -0.00063825f, 0.06386191f, 0.03650289f, -0.09140015f, -0.05333864f, 0.08829909f, 
    -0.08614489f, 0.04735506f, 0.12769102f, 0.09214655f, 0.13854304f, 0.14483216f, 0.11333807f, 0.07201076f, 
    -0.19043535f, -0.13761595f, -0.00149281f, -0.10959253f, -0.09732831f, 0.09415226f, -0.10882659f, 0.05340014f, 
    -0.06360311f, -0.01291701f, 0.00841072f, 0.08309729f, 0.34127855f, -0.04507573f, -0.01532865f, 0.34866768f, 
    0.06313283f, 0.04456948f, 0.12019725f, -0.04909803f, -0.06789406f, -0.06663430f, -0.03898628f, -0.09148116f, 
    0.22195956f, 0.10555007f, -0.03451626f, 0.26881212f, 0.22575404f, 0.08790375f, 0.02063602f, 0.00791546f, 
    -0.02206390f, -0.13315047f, 0.05274140f, -0.04979531f, 0.31260157f, -0.06258039f, 0.26186287f, 0.09212787f, 
    -0.06241294f, 0.00554724f, -0.03115420f, 0.10909612f, -0.07410982f, 0.02466075f, 0.01520631f, 0.00446607f, 
    0.45379379f, 0.08829044f, -0.11179492f, 0.07415045f, -0.05177035f, 0.05431813f, 0.10678452f, 0.04387726f, 
    0.16234584f, 0.04789196f, -0.02710711f, 0.03608654f, -0.03454156f, 0.04365174f, -0.01268937f, -0.41806346f, 
    -0.14652355f, 0.10470410f, -0.03245685f, 0.03451468f, 0.00543468f, -0.11332383f, 0.03382852f, 0.02315383f, 
    0.21238357f, 0.21826917f, 0.06682083f, 0.10452292f, 0.00805759f, -0.02619006f, -0.04503511f, 0.07829709f, 
    -0.07666097f, 0.09604192f, 0.04232231f, 0.07456077f, -0.07244522f, -0.14910604f, 0.12551847f, -0.35531613f, 
    -0.08901520f, 0.01146203f, 0.08454379f, 0.01838798f, -0.01453155f, -0.06537261f, -0.06992877f, -0.02547899f, 
    0.05254351f, -0.01141255f, -0.03876365f, -0.06362932f, 0.01393526f, 0.01581051f, -0.04151095f, 0.01413748f, 
    0.03454792f, -0.07908046f, -0.02812629f, -0.06863145f, -0.04212449f, -0.07712745f, 0.03274456f, -0.06902087f, 
    -0.08084033f, 0.03514566f, 0.03775340f, -0.00487830f, 0.02329663f, 0.05807485f, -0.04803653f, 0.06078902f, 
    0.01030139f, 0.00211613f, -0.07508285f, -0.06408496f, -0.02038031f, -0.03398350f, 0.05927300f, -0.03650847f, 
    -0.00992962f, 0.04281421f, -0.02813860f, 0.03723130f, 0.03205148f, -0.01651907f, 0.00534864f, 0.02513317f, 
    0.00282095f, -0.02359645f, -0.05963015f, -0.01268862f, 0.03366329f, -0.07316965f, -0.03013566f, -0.02400003f, 
    0.01876739f, -0.00262971f, 0.04406848f, -0.00031242f, 0.05546816f, -0.03653916f, 0.02332403f, -0.02835626f, 
    0.03758671f, 0.01958469f, -0.02696841f, -0.01929660f, -0.03190597f, -0.08128903f, 0.01343509f, 0.04052255f, 
    -0.00672252f, -0.06650794f, 0.04652363f, 0.00838121f, -0.04213182f, -0.06857136f, -0.04633308f, 0.04449627f, 
    -0.00937597f, -0.03034663f, -0.04607630f, -0.06453543f, 0.03459829f, -0.04976900f, -0.01919886f, -0.05028069f, 
    -0.00839526f, -0.02418529f, 0.00921010f, 0.01095076f, -0.01257515f, -0.07553168f, 0.04147361f, 0.03724652f, 
    0.03028845f, 0.00170561f, 0.01494222f, -0.05763525f, -0.01720409f, 0.06175567f, 0.02996962f, 0.02238750f, 
    -0.05341465f, 0.04390392f, -0.02819351f, 0.02847994f, 0.04072464f, 0.05692383f, -0.05076920f, 0.02320398f, 
    0.05962696f, 0.01663328f, 0.02822907f, -0.03977656f, -0.07510491f, -0.06067706f, -0.01324792f, 0.05529949f, 
    -0.00617270f, 0.02187850f, 0.01551038f, -0.08194518f, -0.00600713f, -0.05988199f, 0.05531145f, 0.01707601f, 
    0.05433145f, -0.03139054f, -0.07821281f, -0.08051120f, -0.03235222f, 0.00761925f, 0.01759195f, 0.01415061f, 
    -0.00679265f, -0.02414113f, -0.06747670f, -0.02164227f, 0.04269328f, -0.05063105f, -0.06438852f, 0.01898102f, 
    0.02943365f, 0.02593252f, -0.06301588f, 0.03591016f, -0.01095451f, 0.05911238f, -0.06676243f, 0.01086772f, 
    -0.04159345f, -0.05181499f, -0.07513408f, -0.04547944f, -0.02170803f, 0.05432982f, -0.01576769f, -0.04351654f, 
    0.00872104f, -0.00279130f, -0.05868834f, 0.03546880f, 0.03175060f, -0.05692270f, 0.04538808f, 0.05914240f, 
    -0.07815266f, -0.01780023f, -0.00300346f, 0.03370046f, -0.05706189f, -0.01052566f, 0.00961970f, 0.01420476f, 
    0.01052165f, -0.08231643f, 0.04603201f, 0.01107260f, -0.07344978f, 0.03183152f, 0.02593383f, 0.03403196f, 
    -0.00793762f, 0.04113970f, -0.03833647f, 0.03642562f, 0.05552766f, -0.08211261f, -0.06598411f, -0.01233686f, 
    0.02604302f, -0.02291575f, -0.04264504f, -0.01929679f, -0.03701925f, -0.05892184f, -0.03339780f, 0.04915531f, 
    -0.57699674f, -0.08751483f, -0.20841955f, -0.07356367f, 0.12983619f, 0.03549275f, 0.16868500f, 0.02226075f, 
    -0.05283892f, -0.09112476f, -0.02705941f, 0.05408214f, -0.38234207f, -0.01746628f, -0.13938756f, 0.18945424f, 
    0.09405807f, -0.08269490f, 0.01165236f, -0.02242386f, -0.04843676f, 0.06354038f, 0.08055148f, -0.00047346f, 
    0.06677108f, 0.09895621f, 0.29136655f, 0.24144135f, -0.08914105f, 0.06009989f, 0.04514488f, 0.07208081f, 
    0.20417997f, -0.06804880f, -0.06646543f, 0.05570640f, -0.26031718f, 0.02983607f, 0.24659356f, -0.11707813f, 
    0.13195300f, 0.00776270f, -0.07862097f, 0.08596677f, 0.03386897f, 0.05315346f, -0.13865857f, 0.03685957f, 
    0.14802623f, -0.01298129f, 0.03440999f, -0.09463031f, -0.09425964f, -0.02017552f, 0.09786316f, 0.03326114f, 
    0.14387116f, 0.01004766f, -0.05318517f, 0.08651222f, -0.03363053f, -0.00112786f, -0.00063733f, -0.06532386f, 
    0.07603189f, -0.09279893f, -0.00651943f, 0.11048167f, 0.00662685f, -0.03751549f, -0.01848450f, 0.05911076f, 
    -0.09178896f, 0.15102495f, 0.06138560f, 0.08697353f, -0.11435272f, -0.00590770f, 0.13935088f, -0.13070710f, 
    0.02537379f, -0.04810499f, -0.07565357f, 0.04587035f, 0.23991320f, -0.13432001f, -0.00681965f, 0.10726047f, 
    -0.11643456f, 0.00343073f, 0.04927783f, -0.11269968f, 0.06193858f, 0.12837455f, 0.06030355f, -0.03397212f, 
    -0.03316639f, -0.02509105f, 0.23497123f, -0.01043501f, 0.08182397f, 0.01948302f, -0.05690629f, 0.18227102f, 
    0.02734229f, 0.02730282f, 0.15388742f, 0.09788097f, 0.09536787f, 0.16217126f, -0.02878223f, 0.27362910f, 
    -0.16034958f, -0.00522821f, 0.10264766f, 0.07315443f, 0.12198839f, 0.09772962f, -0.04007698f, 0.11400529f, 
    0.16666535f, 0.09322069f, 0.29827550f, 0.12046689f, -0.02524580f, -0.01412627f, 0.00302981f, -0.13953279f, 
    0.16959710f, -0.13330220f, 0.08522830f, -0.08207238f, -0.19870929f, 0.24824724f, 0.08897710f, -0.03118684f, 
    0.13298468f, -0.15808006f, 0.13705526f, 0.06033780f, 0.03287577f, -0.00963686f, -0.03100084f, 0.04049758f, 
    -0.00500339f, 0.00027221f, 0.16161816f, 0.19137199f, -0.09473820f, -0.03773911f, 0.00380750f, 0.09028445f, 
    0.09686490f, 0.07150631f, 0.01699495f, 0.02467670f, 0.16213703f, -0.06010025f, 0.09151162f, 0.07475800f, 
    -0.02663010f, 0.03790803f, 0.15813176f, 0.02754383f, 0.07538249f, -0.11493441f, 0.04414171f, 0.02998274f, 
    -0.13914336f, -0.08868637f, -0.19487147f, 0.00239560f, -0.01095909f, 0.10715497f, -0.03270198f, -0.05563311f, 
    -0.01317006f, -0.06089801f, 0.09519732f, 0.03555730f, 0.16437830f, 0.15884069f, -0.17858034f, 0.21603984f, 
    0.04819348f, -0.01145360f, 0.05579394f, -0.13251632f, 0.03728491f, -0.03030023f, 0.04396453f, -0.06140560f, 
    0.06809611f, -0.03794135f, 0.21262571f, -0.04765940f, -0.03765517f, 0.09948137f, -0.02896353f, 0.03315857f, 
    0.05981547f, 0.10015278f, -0.02114042f, -0.02127864f, 0.04154361f, 0.23241089f, 0.13715948f, 0.24391964f, 
    0.18165056f, 0.10123561f, 0.01583461f, -0.15830332f, 0.06754109f, 0.02016600f, -0.07292871f, -0.05858720f, 
    -0.05461002f, -0.08181284f, 0.03452145f, 0.13061731f, -0.05578629f, 0.00742740f, 0.06865171f, -0.02005587f, 
    0.10684472f, 0.01879351f, -0.09907335f, 0.00523168f, 0.07641535f, -0.06630652f, 0.01796319f, 0.14056920f, 
    -0.15557732f, -0.04273718f, 0.03668221f, 0.09144494f, 0.02653901f, 0.03554295f, 0.06862982f, 0.01234354f, 
    0.04789700f, -0.04075024f, -0.07911760f, -0.25859314f, 0.03743967f, -0.18949379f, -0.12282076f, -0.12229437f, 
    0.08581411f, -0.11186884f, -0.10410609f, -0.17071913f, 0.07452516f, 0.09753341f, 0.06520834f, -0.12336164f, 
    -0.00924135f, 0.02192535f, 0.00498871f, 0.04090970f, 0.15579556f, -0.01585191f, -0.07644755f, -0.00113451f, 
    -0.40827203f, 0.18319295f, 0.03867567f, 0.00091799f, 0.11870403f, -0.04927505f, -0.10087273f, 0.10315210f, 
    0.11204199f, -0.04444545f, 0.12664773f, -0.00639049f, 0.07414680f, 0.30285388f, -0.00089252f, 0.01117664f, 
    0.12975267f, -0.09794363f, -0.24395776f, -0.11864437f, 0.01331157f, 0.00288717f, -0.04827968f, -0.00969523f, 
    0.03963693f, -0.05552645f, 0.07231544f, 0.34434274f, -0.19826725f, -0.07232875f, -0.02497052f, 0.12015406f, 
    -0.03347689f, 0.13948017f, -0.00146028f, -0.07104125f, 0.08185876f, -0.21333998f, -0.06719892f, 0.04486807f, 
    0.08992424f, 0.04543998f, -0.08921945f, -0.04214242f, 0.05005363f, 0.05546996f, -0.06407679f, 0.27133772f, 
    -0.10482371f, -0.17855404f, 0.11689352f, 0.05674944f, 0.03889388f, -0.04808286f, 0.07074782f, 0.04392016f, 
    -0.10677470f, 0.01898328f, 0.07252906f, -0.00381080f, -0.13478020f, 0.14312142f, -0.05070404f, 0.10461064f, 
    -0.00627994f, 0.10075428f, -0.17223041f, -0.10826759f, 0.03400291f, 0.02263767f, -0.06892385f, 0.00104000f, 
    0.20828229f, -0.10652118f, -0.13709599f, -0.03292780f, 0.03119569f, 0.02620175f, 0.13767891f, -0.09007783f, 
    -0.11519926f, -0.01072273f, -0.00607358f, -0.01378729f, 0.10610332f, 0.13909501f, 0.21480116f, 0.31237635f, 
    0.11522771f, -0.15397471f, -0.16609071f, 0.08436254f, 0.02214401f, -0.03724391f, 0.10421856f, 0.20265247f, 
    0.49988788f, 0.02496542f, -0.10122994f, -0.08414859f, -0.00739865f, 0.18644498f, -0.20225240f, -0.02732579f, 
    -0.05957636f, 0.05363170f, -0.05486868f, 0.07602908f, 0.08220302f, 0.38223207f, -0.09377433f, -0.05135943f, 
    0.03088333f, -0.15845290f, -0.11563776f, 0.04416882f, 0.13141139f, 0.01660330f, 0.15216057f, 0.06120031f, 
    0.32800069f, -0.08726474f, -0.10961911f, 0.07602675f, 0.00174784f, 0.06752267f, -0.13263106f, -0.01870298f, 
    0.00456497f, -0.08993518f, 0.07691720f, 0.03994400f, -0.13110372f, -0.08785168f, 0.02279201f, 0.17738330f, 
    -0.07607481f, 0.06545141f, -0.02528464f, 0.20743683f, 0.10391527f, -0.01082109f, 0.02245788f, 0.08129759f, 
    -0.09434248f, 0.39608383f, 0.19172595f, -0.00691133f, 0.09324543f, 0.04916120f, 0.01627590f, 0.02015888f, 
    0.00910470f, -0.01703344f, 0.04681195f, -0.08670777f, -0.06490462f, 0.00944662f, -0.23552853f, -0.09817922f, 
    -0.06701744f, -0.00549198f, 0.00715844f, -0.00036316f, -0.12142725f, 0.07391713f, 0.00201643f, -0.00722014f, 
    0.39375097f, -0.03737319f, -0.00090669f, 0.03859827f, 0.01847156f, 0.11986557f, 0.04533810f, 0.08090197f, 
    -0.06319410f, -0.05031085f, 0.04273376f, 0.04704731f, 0.27650511f, 0.13922361f, 0.05648868f, 0.03746416f, 
    -0.03622106f, -0.09296696f, -0.01066819f, 0.08521888f, 0.02148745f, -0.04355910f, -0.02597156f, 0.00803840f, 
    0.00148119f, -0.18731013f, -0.25267866f, -0.13315897f, -0.03043769f, -0.06607462f, 0.03262381f, -0.08196643f, 
    0.03583071f, 0.02895149f, 0.01455038f, 0.02624819f, 0.04181026f, -0.14190976f, 0.02479977f, -0.08172558f, 
    -0.03359229f, 0.00792191f, 0.05266279f, -0.00640896f, 0.07224096f, 0.01608850f, 0.07397801f, -0.13620663f, 
    -0.27616349f, -0.07912359f, -0.08896759f, -0.21000709f, -0.08954544f, -0.02834465f, 0.08066896f, -0.13281307f, 
    0.01962752f, 0.01692391f, 0.00134184f, -0.06106454f, 0.14836995f, 0.15153673f, 0.18758066f, 0.04374588f, 
    0.02787939f, 0.00510761f, 0.01147265f, -0.01929614f, 0.00386901f, -0.07002254f, 0.02288402f, -0.10152072f, 
    0.18787552f, 0.13689128f, -0.03247381f, 0.23325495f, 0.08248515f, -0.06038276f, -0.03615875f, 0.06905227f, 
    -0.00700505f, -0.05609420f, 0.01801477f, 0.08674683f, 0.19701391f, 0.00750614f, 0.02644331f, -0.06611438f, 
    -0.01281128f, 0.12441714f, -0.05877037f, 0.11501300f, -0.10978305f, 0.04186483f, -0.03259871f, -0.00953680f, 
    -0.03289392f, 0.08168926f, 0.05931878f, -0.00821518f, 0.10256750f, -0.01623847f, 0.06723697f, 0.00908890f, 
    0.05191123f, 0.01523785f, -0.01142334f, -0.04144264f, -0.12854637f, 0.14150147f, -0.13984625f, -0.30558971f, 
    0.06484819f, 0.00784892f, -0.05898893f, -0.00898401f, -0.11582676f, -0.05924677f, 0.02463255f, 0.08277909f, 
    0.34720364f, 0.16397856f, 0.12012733f, 0.12769504f, -0.10198689f, -0.21097656f, 0.00331926f, 0.04298377f, 
    -0.08076247f, -0.09927443f, -0.02514234f, 0.04157590f, -0.06203624f, -0.01217944f, 0.14010553f, -0.00126152f, 
    0.01645915f, 0.03724331f, 0.15203489f, 0.08989499f, -0.10024694f, 0.04121443f, 0.09033537f, -0.12151161f, 
    -0.02756372f, 0.00797903f, -0.00005799f, 0.04537006f, 0.04347984f, -0.06466424f, -0.02421853f, 0.03003165f, 
    0.03199827f, -0.04015630f, -0.00688229f, 0.01338813f, -0.07052347f, -0.00207074f, -0.05184582f, -0.06007788f, 
    -0.08076639f, -0.04112966f, -0.05453724f, -0.00110183f, 0.02998170f, -0.05517645f, 0.03699408f, -0.03323561f, 
    0.00253485f, -0.04095548f, -0.04857277f, 0.04001610f, -0.05084810f, -0.02839503f, -0.06534242f, -0.01927549f, 
    -0.07972791f, -0.06531945f, -0.07640129f, -0.02229211f, 0.02579033f, -0.02219110f, 0.04595036f, 0.00189333f, 
    0.05621410f, -0.04605665f, 0.02131172f, -0.01326576f, -0.04374586f, 0.04582514f, 0.01546135f, -0.06189881f, 
    -0.01420306f, 0.00033263f, -0.06411387f, -0.04772212f, -0.01495874f, -0.06649387f, 0.00961430f, -0.05598755f, 
    0.06162120f, 0.05510223f, 0.00725939f, 0.03212234f, -0.06698777f, 0.03145269f, 0.00726380f, 0.05661367f, 
    -0.07326641f, -0.06401474f, -0.06036486f, 0.05375044f, 0.00248112f, 0.04438490f, -0.06731072f, -0.04850575f, 
    -0.03743266f, 0.04316284f, 0.02549919f, -0.01302342f, 0.04479439f, -0.09393286f, 0.04779551f, -0.00535772f, 
    0.04873317f, 0.01854068f, -0.03306475f, -0.00373970f, 0.03467468f, -0.03203243f, -0.07586210f, -0.07531238f, 
    -0.05825833f, 0.01246836f, -0.04004316f, -0.07689705f, 0.04249154f, 0.01181838f, 0.05270717f, -0.07365444f, 
    -0.06674138f, 0.01671518f, 0.05058248f, -0.02625364f, -0.07016944f, 0.02248945f, -0.00465350f, -0.03981211f, 
    -0.04426501f, -0.07709983f, 0.00910927f, 0.01064378f, -0.01346336f, 0.03100755f, -0.04170589f, -0.06165855f, 
    -0.00347732f, -0.02215751f, -0.01191388f, -0.05269023f, -0.07000470f, -0.06632712f, -0.00137387f, 0.01187141f, 
    0.02748382f, -0.04684590f, -0.04532859f, -0.03053062f, -0.01759393f, 0.00134523f, -0.05589901f, 0.04141017f, 
    0.05409180f, -0.07664694f, -0.03542355f, -0.05355952f, -0.02183276f, -0.09165244f, -0.07342385f, -0.05142790f, 
    0.00540876f, -0.02238656f, -0.03197337f, -0.08311055f, 0.03006425f, -0.03087122f, 0.00718452f, -0.02830418f, 
    0.04068237f, 0.01333118f, 0.00972722f, 0.03988371f, 0.00015713f, -0.00030614f, -0.05235472f, -0.01472914f, 
    -0.05727630f, -0.06403479f, -0.01862012f, -0.08675201f, -0.00523464f, -0.01250882f, 0.01503931f, -0.00391423f, 
    -0.00029423f, 0.00925669f, -0.01211405f, 0.01358057f, -0.01674331f, -0.01977760f, 0.00184259f, 0.05380335f, 
    -0.08918693f, -0.05164936f, -0.01958417f, -0.04879978f, 0.04482063f, -0.07535895f, 0.04240364f, 0.03967370f, 
    -0.00967687f, -0.01501973f, 0.04658215f, 0.02301499f, 0.02345114f, 0.02852691f, 0.04926918f, -0.03789014f, 
    -0.03826389f, -0.05809641f, -0.02208214f, -0.04359701f, -0.04395194f, 0.00780049f, -0.01097944f, 0.01492034f, 
    0.02611421f, 0.11805226f, -0.04968826f, -0.10838844f, 0.00410968f, 0.00440756f, 0.00855466f, 0.03378381f, 
    -0.06397882f, 0.07231919f, -0.01410076f, 0.01402915f, -0.09007483f, 0.07108929f, 0.02453772f, -0.02989565f, 
    0.00335401f, -0.11248469f, 0.00135018f, 0.06142967f, 0.04718233f, -0.00871662f, -0.05129365f, 0.08014595f, 
    -0.12585318f, 0.08572333f, 0.15307766f, 0.31559578f, -0.08559112f, 0.05241960f, -0.03255021f, 0.03957736f, 
    0.04061505f, 0.01858576f, -0.05810229f, 0.02301686f, -0.16396475f, -0.13107845f, -0.03484474f, 0.18057807f, 
    -0.08352243f, -0.01950971f, -0.06758896f, 0.10506195f, -0.00058691f, 0.12023578f, 0.04133946f, 0.06146272f, 
    0.31782165f, -0.02251548f, -0.04734989f, 0.07226452f, -0.01675788f, -0.13122721f, -0.04376179f, -0.04141788f, 
    0.17165035f, -0.02925687f, -0.05972683f, -0.04786732f, 0.29546344f, 0.16844852f, 0.17231899f, 0.11967662f, 
    0.00075970f, -0.00315785f, 0.01705169f, -0.02198087f, 0.13229370f, -0.00741763f, 0.00601599f, 0.04492839f, 
    -0.03038161f, 0.10952347f, -0.00946899f, -0.02158496f, -0.03850236f, -0.04171104f, -0.06632178f, 0.01329109f, 
    0.12950042f, -0.01047209f, 0.05709894f, 0.03465335f, 0.02876719f, 0.01195215f, 0.08686937f, 0.03187690f, 
    0.04202371f, -0.03338657f, -0.04720908f, -0.01501163f, -0.01143556f, 0.02017660f, -0.01968855f, 0.01238390f, 
    -0.22420473f, -0.05263177f, -0.03641779f, -0.05255276f, -0.07671087f, -0.05431428f, -0.02657702f, 0.09900735f, 
    -0.08017334f, 0.21367830f, 0.03722955f, -0.07966910f, 0.23400830f, -0.03724334f, 0.07456649f, 0.25823653f, 
    0.06778880f, 0.04458063f, -0.08066812f, -0.16281062f, 0.01074094f, -0.02304840f, 0.11963539f, 0.20154399f, 
    -0.02512446f, -0.07161728f, -0.01947955f, 0.17329049f, 0.00739526f, -0.01105434f, -0.08717275f, -0.00081425f, 
    -0.02447325f, 0.05456109f, 0.09977891f, 0.05444329f, 0.06633016f, 0.00753481f, 0.03031949f, 0.03286729f, 
    -0.04196649f, 0.01267432f, -0.05424588f, 0.11346377f, -0.07094572f, 0.04699688f, 0.03967488f, 0.00022726f, 
    0.07615475f, -0.11276779f, -0.07769326f, 0.08049992f, -0.00514179f, 0.09113809f, 0.12923506f, -0.02387870f, 
    -0.04411272f, -0.11966859f, -0.06003528f, -0.07241995f, -0.19037800f, 0.13990316f, -0.01003205f, -0.14369786f, 
    0.03446560f, 0.02557616f, -0.05408995f, 0.10629575f, 0.07345802f, -0.03021351f, 0.02975993f, 0.08369095f, 
    0.56734842f, 0.14263523f, 0.08558033f, 0.07605276f, 0.02072744f, 0.04727053f, -0.18134148f, -0.03914362f, 
    -0.12856816f, 0.00416227f, 0.00216524f, 0.00843839f, -0.02840308f, 0.16979644f, -0.07825661f, -0.15821163f, 
    0.01090940f, 0.02967059f, 0.03165141f, 0.08361237f, -0.00237759f, 0.08983036f, 0.03524340f, 0.05673089f, 
    0.25912726f, -0.33150640f, 0.05014574f, 0.03300155f, -0.09345499f, -0.10620850f, -0.04688123f, 0.01546396f, 
    0.01740960f, 0.06031761f, -0.00410243f, -0.02744406f, -0.18747956f, 0.06905974f, 0.05497782f, 0.20481057f, 
    -0.25868228f, 0.03995383f, -0.10542681f, 0.14192475f, -0.01255534f, -0.07905428f, 0.18109721f, 0.15547498f, 
    -0.06077272f, 0.45268318f, 0.12307401f, -0.08184966f, 0.12370589f, -0.12574904f, -0.09087048f, -0.01015907f, 
    0.03399530f, -0.03729847f, 0.11288753f, 0.00618733f, 0.33131549f, -0.03862423f, 0.15562554f, -0.14293855f, 
    0.09569196f, 0.00397242f, 0.05765141f, -0.07775502f, 0.00410331f, -0.05352782f, -0.03908740f, -0.01871566f, 
    0.12238359f, 0.06428531f, 0.03940855f, 0.03010698f, 0.09716646f, 0.05725811f, -0.03376817f, -0.01545431f, 
    -0.13975821f, -0.05715901f, 0.10634047f, 0.08968336f, 0.10864556f, 0.12504096f, 0.06061986f, 0.16769734f, 
    0.04602007f, -0.11041208f, -0.10137514f, -0.11849436f, -0.15380567f, 0.01212254f, -0.05372973f, -0.09256958f, 
    0.36514115f, 0.11046642f, -0.00977334f, 0.19406357f, -0.01531405f, 0.08055882f, 0.02201508f, -0.00273736f, 
    -0.06343266f, -0.03469848f, 0.00359969f, 0.06895200f, -0.06625409f, -0.06326516f, -0.07693494f, 0.18158390f, 
    -0.07502408f, -0.00641519f, 0.14707942f, -0.02676841f, -0.01596361f, 0.03114466f, 0.22550717f, 0.02217326f, 
    -0.03434808f, 0.01405298f, -0.22167306f, -0.19945066f, 0.04188112f, -0.07282633f, 0.02257478f, -0.09631479f, 
    0.15378867f, -0.05968616f, 0.00274742f, 0.14045478f, -0.16599545f, 0.22430235f, 0.10496239f, 0.03541796f, 
    0.18531467f, 0.00036745f, 0.02799610f, -0.07685518f, 0.04989620f, 0.02565293f, 0.02607687f, -0.24971166f, 
    0.01835100f, 0.17073795f, 0.11818150f, -0.00061223f, 0.10550918f, 0.00114367f, 0.07395627f, -0.07637607f, 
    0.03189084f, 0.02618728f, 0.08217305f, -0.10417160f, -0.01524349f, 0.28407359f, 0.15944552f, -0.11114226f, 
    -0.11846113f, 0.04815774f, 0.17124866f, -0.00424969f, 0.04840802f, 0.01476318f, 0.11093212f, -0.05133757f, 
    -0.34797484f, 0.05069536f, 0.07296281f, 0.04090819f, 0.17810591f, 0.11108247f, -0.17557245f, -0.07318588f, 
    -0.09155101f, 0.04625525f, -0.04577132f, 0.06179151f, 0.19393997f, 0.04767165f, 0.01216505f, -0.16174042f, 
    0.16443367f, -0.05458237f, 0.00200307f, -0.10909663f, -0.03194997f, -0.05231787f, -0.00678323f, -0.04028233f, 
    -0.05373870f, 0.13605042f, 0.12875515f, 0.25518635f, -0.09786900f, -0.13030910f, 0.15561612f, 0.04370932f, 
    0.10059867f, 0.01118631f, 0.13354993f, 0.00424225f, -0.12315086f, 0.11295632f, -0.11777949f, 0.12468027f, 
    0.02597469f, -0.05600504f, -0.02468678f, 0.07634776f, -0.04980440f, -0.00389159f, -0.07012098f, -0.08524223f, 
    0.19513749f, 0.20051229f, 0.03524000f, 0.18511601f, -0.03052923f, 0.00708620f, -0.04811529f, -0.11544371f, 
    -0.04027929f, -0.00151749f, -0.01805155f, 0.06252511f, 0.14307272f, -0.02069671f, 0.28651145f, 0.15271798f, 
    -0.03886827f, -0.06756853f, -0.14598836f, 0.17829125f, -0.02901803f, -0.02675190f, -0.01753730f, 0.14183414f, 
    -0.03071917f, -0.00650196f, 0.04378071f, 0.05772910f, 0.12634847f, -0.01608713f, -0.07167874f, 0.05103199f, 
    -0.05938957f, 0.11618749f, 0.03714958f, 0.00243645f, -0.07849650f, 0.12196549f, 0.05776027f, 0.19186391f, 
    -0.10781594f, 0.09158508f, 0.05497515f, -0.07007559f, -0.09701409f, -0.01627849f, 0.06396738f, -0.04753200f, 
    0.45867750f, -0.12906756f, -0.07967182f, 0.12577130f, 0.00834139f, 0.15084900f, 0.12429208f, 0.07521139f, 
    -0.12164421f, 0.08351022f, 0.10478253f, 0.02571880f, 0.11272010f, -0.11304903f, -0.19861902f, 0.10706889f, 
    -0.16043827f, -0.06177034f, 0.04069823f, 0.00108095f, -0.14574860f, -0.00935368f, -0.10094880f, -0.04270811f, 
    0.12445568f, 0.21479219f, -0.09199721f, -0.07759055f, -0.09186886f, -0.01542787f, 0.11975917f, 0.12485008f, 
    -0.00976439f, 0.12162900f, -0.08796514f, -0.07990485f, 0.11679747f, -0.12874508f, -0.18544349f, 0.01326289f, 
    -0.00288338f, 0.00327608f, 0.26091796f, 0.08990427f, 0.10626797f, -0.03340093f, 0.01549731f, -0.00570402f, 
    -0.10033310f, -0.07367542f, 0.01810223f, -0.06763059f, -0.13443817f, 0.00160463f, -0.04489253f, -0.12419095f, 
    0.02647569f, -0.12893744f, 0.04390839f, 0.10618065f, 0.26810741f, -0.10890161f, -0.11939618f, 0.26849216f, 
    -0.10894411f, -0.05749559f, 0.10560767f, 0.03843285f, -0.05244648f, -0.13352768f, -0.09692967f, -0.25512001f, 
    0.50509793f, 0.18823703f, 0.18755728f, 0.19367245f, 0.23102683f, 0.13873295f, -0.03739537f, 0.05405488f, 
    -0.03386967f, -0.04654855f, -0.09677385f, -0.07254989f, 0.31874844f, -0.24473408f, 0.25906289f, -0.09082674f, 
    -0.06815061f, 0.00988906f, -0.07581548f, 0.07017961f, -0.09122267f, -0.14194585f, 0.01862367f, -0.11024119f, 
    0.14047882f, 0.13196000f, -0.24254787f, -0.02084769f, -0.12847054f, -0.08634722f, 0.07693857f, 0.05871336f, 
    0.09219748f, 0.13685825f, 0.08877107f, 0.03063393f, 0.18213169f, 0.08650040f, -0.19474436f, -0.40315905f, 
    -0.08602903f, 0.00205834f, -0.14227849f, -0.06103606f, -0.04061501f, 0.09719308f, -0.03097276f, -0.06597071f, 
    -0.09046263f, 0.09752350f, 0.03958786f, -0.01653350f, -0.09630992f, -0.20772594f, 0.32345039f, 0.15910493f, 
    -0.03992768f, 0.04499725f, 0.03630471f, -0.03422253f, -0.06757431f, -0.05071410f, -0.00360559f, -0.01873259f, 
    0.01640782f, 0.08533072f, 0.18869701f, -0.00232956f, -0.09571987f, 0.05917450f, 0.01813330f, -0.10734326f, 
    0.43154320f, -0.01077342f, 0.02486306f, 0.04442214f, -0.00758287f, 0.00716950f, -0.08196733f, 0.09901553f, 
    0.00124874f, 0.07514282f, -0.08430347f, 0.00851316f, 0.18134287f, 0.22311616f, 0.00777071f, 0.29466164f, 
    0.04066507f, -0.01901875f, 0.16687596f, 0.16287957f, 0.11200074f, -0.00315150f, 0.02223537f, -0.04992757f, 
    -0.11400808f, 0.22670168f, -0.08229692f, 0.01368400f, 0.07208069f, 0.05087380f, -0.11553256f, -0.02571878f, 
    0.07203274f, -0.08479732f, -0.12404314f, 0.01099239f, 0.11817306f, 0.05928865f, -0.13353427f, -0.00831964f, 
    -0.06304458f, -0.05317655f, 0.05767046f, 0.00638359f, -0.08389301f, 0.02923468f, 0.01457488f, -0.00650533f, 
    -0.02018567f, 0.00596709f, 0.00262078f, 0.01179611f, 0.03925721f, -0.02971373f, -0.00316690f, -0.04898903f, 
    0.10186592f, -0.07924163f, -0.07607216f, 0.04746259f, -0.07942218f, 0.26477915f, -0.11267676f, 0.09195689f, 
    0.05617881f, -0.06635831f, -0.03623864f, 0.00989391f, 0.15864460f, 0.03000311f, 0.07097946f, -0.07531131f, 
    0.09444105f, 0.10726561f, 0.08828531f, -0.11437729f, 0.05615339f, 0.00444421f, -0.01211096f, 0.00365203f, 
    0.00545454f, 0.03920072f, 0.00353748f, 0.13203065f, 0.17321400f, -0.21984240f, -0.03160881f, 0.12682652f, 
    -0.11168350f, 0.01728800f, 0.04187322f, 0.07729499f, 0.06683009f, 0.00436525f, -0.00675713f, 0.00238536f, 
    0.03251777f, 0.15290573f, -0.11957960f, -0.09748639f, 0.08005195f, -0.02657266f, 0.17673220f, -0.01093864f, 
    -0.06499402f, 0.02483466f, 0.03137746f, 0.10381562f, -0.29559255f, 0.02909322f, 0.04309496f, -0.10143816f, 
    0.04905159f, 0.08122679f, -0.18419743f, -0.03743120f, -0.06342290f, 0.00281097f, 0.04170658f, -0.04060854f, 
    -0.27256337f, -0.00057654f, -0.16870603f, 0.07909641f, 0.00441614f, 0.05677609f, -0.00068122f, -0.02112408f, 
    0.05163204f, 0.06737295f, 0.02534835f, -0.04393771f, -0.12845248f, 0.24003313f, -0.10685938f, 0.11782485f, 
    0.15514478f, -0.03156378f, 0.03723191f, -0.04845086f, 0.05673959f, 0.05561923f, 0.05288924f, 0.03782447f, 
    -0.32277513f, -0.16212058f, 0.09519478f, 0.02532111f, 0.15437825f, 0.12149768f, 0.00906580f, -0.08943051f, 
    -0.05962775f, -0.02160126f, -0.06263848f, 0.07847496f, -0.12072983f, -0.07672748f, 0.03141985f, 0.00130037f, 
    0.19795926f, 0.17162624f, 0.08840207f, 0.05259832f, -0.02766837f, 0.10803705f, -0.00442135f, -0.00235894f, 
    0.01041157f, -0.03793053f, 0.16499497f, 0.08969737f, -0.10217409f, 0.07147666f, 0.04256099f, 0.05964694f, 
    0.10297576f, 0.02502438f, -0.01083907f, 0.04965512f, -0.02350113f, 0.13401748f, 0.26544321f, -0.15816182f, 
    0.04672039f, 0.09117186f, 0.23451127f, 0.09584165f, -0.00772171f, 0.06211593f, 0.00656215f, 0.05677418f, 
    0.06736703f, 0.21256001f, -0.15192185f, -0.01005320f, 0.08130755f, -0.00417538f, 0.10519607f, 0.12599711f, 
    -0.09039519f, -0.01598918f, 0.08222903f, 0.10788151f, -0.03663082f, -0.15307252f, -0.22890545f, -0.19335556f, 
    0.00773908f, 0.09321364f, -0.01357784f, 0.07541401f, 0.08142983f, -0.00477464f, -0.04887992f, 0.12295659f, 
    -0.02739851f, 0.06880070f, 0.22224091f, 0.15555665f, -0.03402329f, 0.06113057f, 0.02476745f, 0.08020987f, 
    0.05952010f, 0.05256491f, 0.09204055f, 0.00471433f, -0.18537374f, 0.05551964f, -0.15947312f, 0.20578913f, 
    0.12190793f, -0.02504300f, 0.02949667f, 0.06547730f, 0.11758665f, -0.04528987f, 0.04938870f, 0.06152041f, 
    0.10981116f, -0.10638197f, -0.02178585f, 0.14987631f, -0.03050993f, 0.01285607f, 0.04991106f, -0.01637976f, 
    0.10698956f, 0.00056961f, 0.00762155f, -0.09289515f, 0.22440235f, 0.01390697f, 0.06488014f, 0.03487389f, 
    0.02994319f, -0.03597660f, -0.00331241f, 0.02003315f, 0.09604630f, 0.06180755f, 0.02708569f, 0.07507080f, 
    -0.10323532f, -0.08582132f, -0.01403331f, -0.19943736f, -0.08099660f, -0.02483173f, -0.02361934f, -0.07121125f, 
    0.06481912f, 0.05834185f, 0.00228233f, 0.03303274f, -0.01160027f, -0.11354466f, 0.30890152f, -0.07131251f, 
    -0.05048952f, -0.00103116f, 0.14592952f, 0.00780439f, -0.00451991f, -0.06878060f, 0.08851475f, 0.06597237f, 
    0.00934161f, 0.01789460f, 0.05211611f, -0.05979406f, 0.04829412f, 0.01465043f, 0.00735210f, -0.03156503f, 
    -0.08033031f, 0.09879092f, 0.04392388f, 0.02924167f, 0.13729943f, 0.03914796f, 0.16517909f, 0.17077304f, 
    0.05120505f, 0.13722053f, 0.03533590f, -0.12008159f, -0.03674079f, -0.02275477f, 0.12558807f, 0.03667852f, 
    0.05876896f, 0.01634449f, -0.08729222f, 0.07595424f, -0.08984730f, 0.06425476f, -0.07190657f, 0.10510435f, 
    0.00553126f, 0.08331148f, 0.05352573f, 0.11388520f, 0.08115691f, -0.17488860f, 0.06124533f, 0.01663572f, 
    0.14514062f, 0.05692250f, 0.02088909f, 0.18527199f, 0.03655517f, 0.05700383f, 0.06045390f, 0.08432634f, 
    -0.11526655f, 0.13539504f, 0.08848891f, 0.09151711f, 0.07988927f, 0.10342202f, 0.10431673f, 0.01895005f, 
    -0.03450481f, -0.00496071f, -0.05379821f, 0.12441270f, -0.37129506f, 0.08855153f, -0.08643213f, -0.27564958f, 
    -0.10547031f, 0.13739482f, 0.11282152f, 0.09517848f, 0.14053164f, 0.04468135f, 0.00670919f, 0.03245540f, 
    0.21271804f, -0.02153804f, -0.01020825f, 0.08740995f, -0.01598475f, -0.00621280f, -0.20113724f, 0.04451528f, 
    -0.00640512f, 0.01237416f, 0.08492754f, 0.07533395f, -0.04533308f, -0.16923469f, 0.07131339f, -0.18582331f, 
    -0.04977090f, 0.01946935f, 0.14265379f, -0.00131705f, -0.06987374f, 0.01623095f, 0.04385886f, 0.04252315f, 
    -0.02815971f, -0.04541389f, 0.08012910f, 0.10387303f, 0.15874505f, -0.00325223f, 0.06571890f, 0.11736156f, 
    -0.04497799f, -0.04974587f, 0.03766271f, -0.12030575f, -0.00985358f, -0.17755194f, -0.03321711f, 0.04401378f, 
    0.12137347f, 0.07884960f, 0.04036639f, 0.05414088f, 0.01459315f, 0.06751423f, 0.16114202f, 0.00515900f, 
    0.21855143f, -0.01871492f, -0.10225368f, -0.14872269f, -0.00756112f, -0.03444212f, -0.03674892f, 0.00001672f, 
    -0.09787710f, -0.08808775f, -0.02733695f, -0.04998486f, 0.30711326f, 0.01714582f, 0.05737351f, -0.15722744f, 
    0.09307211f, 0.02410303f, 0.01348088f, 0.07861448f, -0.01702072f, -0.18279026f, -0.00022986f, -0.06799845f, 
    -0.36376721f, 0.18261893f, 0.12417077f, -0.13515371f, -0.00398716f, 0.02756610f, 0.12786703f, -0.03269554f, 
    -0.01170291f, -0.07181459f, -0.05387642f, 0.09359091f, -0.12471261f, 0.05026584f, 0.10173022f, -0.02507507f, 
    0.07193019f, -0.04880280f, -0.07482609f, 0.02881790f, -0.00117959f, -0.13955519f, -0.09784091f, 0.04324761f, 
    0.05615227f, -0.33671945f, 0.03604458f, 0.04587359f, 0.18949249f, -0.01722531f, -0.05390203f, -0.01759994f, 
    -0.06331249f, -0.02271123f, 0.03743421f, 0.10068695f, -0.02601476f, 0.17891034f, 0.06317096f, -0.03089561f, 
    -0.08005518f, 0.11152302f, 0.06571084f, -0.03571543f, -0.02931998f, 0.07931058f, 0.09855832f, 0.00376353f, 
    0.06357805f, 0.07431660f, -0.04825962f, 0.07594620f, -0.02316759f, 0.10233732f, 0.05660819f, 0.05956538f, 
    0.06656849f, 0.04899481f, -0.05085751f, 0.01295123f, 0.05732590f, 0.26116338f, 0.14930344f, -0.25143170f, 
    0.03445784f, -0.11423516f, -0.04580491f, 0.06163092f, -0.04478135f, -0.04071917f, -0.08750190f, -0.07533555f, 
    -0.10438304f, 0.16061357f, -0.07127908f, -0.08365485f, -0.04493172f, -0.09162817f, 0.08857663f, -0.08975854f, 
    -0.10834002f, -0.07763156f, -0.13477796f, 0.07409947f, 0.01524507f, 0.11123113f, -0.18297385f, -0.18277910f, 
    -0.04642325f, -0.01107657f, 0.08026459f, -0.12419868f, 0.07088277f, 0.04529575f, -0.03054777f, -0.19895843f, 
    0.24711291f, 0.20429166f, 0.24146207f, -0.05550924f, 0.00376011f, -0.03134084f, 0.06782072f, -0.09937296f, 
    -0.09635751f, -0.05527300f, 0.09193050f, -0.00468092f, 0.01942342f, -0.24426788f, 0.11388474f, 0.38336655f, 
    0.09298253f, -0.03599411f, -0.14534327f, 0.03390002f, -0.00170366f, 0.04366382f, 0.03687080f, -0.13361236f, 
    -0.07913251f, 0.13834220f, 0.21742287f, -0.04092549f, 0.00746294f, 0.03048513f, -0.07411764f, -0.05139696f, 
    0.13343650f, -0.06016888f, 0.02681808f, -0.00727946f, 0.05354987f, 0.03741334f, 0.03587494f, 0.22246876f, 
    0.06603546f, -0.08475099f, -0.07496066f, 0.07988580f, 0.07457345f, -0.07262363f, -0.04610725f, -0.02252205f, 
    -0.24104097f, 0.12841703f, -0.08479546f, -0.13665473f, 0.08554047f, -0.02651428f, 0.05985173f, 0.02505730f, 
    -0.01416864f, 0.02408704f, -0.04095999f, 0.07556647f, 0.20842548f, 0.16317356f, -0.00142837f, -0.13662039f, 
    0.20302095f, -0.01257722f, 0.06414600f, -0.10612510f, -0.00638197f, 0.09361012f, 0.01248747f, 0.03147972f, 
    -0.02932797f, 0.00555202f, 0.18587345f, 0.22052722f, -0.19013062f, -0.05602575f, 0.05641292f, 0.00398545f, 
    -0.04278188f, 0.07861675f, 0.04010152f, 0.03043945f, -0.11141909f, 0.06304672f, 0.15168625f, 0.19358931f, 
    0.01006411f, 0.06575664f, 0.07270750f, 0.00153708f, 0.03078868f, -0.02902289f, 0.06798501f, -0.05925355f, 
    0.06850555f, 0.06690841f, 0.01682646f, 0.13716523f, -0.17114894f, 0.04206051f, -0.03830116f, -0.06608407f, 
    -0.00200673f, 0.03087357f, 0.01236543f, -0.06794576f, 0.12629466f, -0.03443417f, 0.04683490f, 0.06366863f, 
    -0.08532187f, 0.08164210f, -0.00220923f, -0.00566784f, 0.02059761f, 0.04478404f, -0.06808283f, 0.04693406f, 
    -0.32159448f, 0.10655919f, 0.07209402f, -0.11870427f, 0.01296746f, 0.02011646f, -0.00165230f, -0.14392087f, 
    0.04379051f, 0.05457089f, 0.03024442f, 0.04649134f, 0.07383811f, -0.03617021f, 0.23374639f, -0.05805103f, 
    -0.10560597f, 0.05991291f, -0.02008408f, -0.02572291f, 0.03089213f, 0.00295254f, -0.04532118f, -0.03129409f, 
    0.07537670f, 0.09103180f, 0.10645330f, 0.17562677f, 0.07737503f, 0.06400707f, -0.15708482f, 0.00266546f, 
    -0.15591416f, 0.02760777f, 0.05279006f, -0.05242995f, 0.02657745f, 0.06357349f, -0.02034525f, 0.11580352f, 
    -0.15289049f, -0.03046119f, 0.19380134f, 0.02144852f, 0.05608007f, 0.01646871f, -0.04810213f, -0.03879024f, 
    0.37564752f, 0.11884699f, 0.33608502f, 0.12086801f, -0.17572971f, 0.09448698f, -0.09253016f, 0.00582668f, 
    0.09843966f, 0.02910250f, -0.02238832f, -0.02861058f, 0.19456421f, -0.03129856f, 0.03176745f, 0.05708660f, 
    -0.05806651f, -0.13597900f, 0.02263294f, -0.02787440f, 0.06281091f, -0.02469404f, -0.14575292f, -0.02866766f, 
    0.04598721f, 0.08049799f, -0.04817848f, 0.22441591f, -0.16864946f, -0.04571507f, 0.08488771f, 0.10607482f, 
    -0.02190545f, -0.02344599f, -0.04813548f, -0.07390326f, 0.04609007f, -0.04801977f, 0.08551311f, 0.06708270f, 
    -0.00649735f, -0.02493607f, 0.06892570f, 0.13698253f, -0.02283666f, 0.11646795f, -0.16253842f, 0.04533457f, 
    0.00810498f, -0.06478192f, -0.08679396f, -0.05840894f, -0.06969493f, 0.02429608f, -0.14276539f, -0.03819692f, 
    0.01190127f, 0.06501002f, 0.01518687f, -0.10926934f, 0.22663450f, -0.18499507f, 0.01675764f, 0.19416828f, 
    0.00329523f, 0.02984553f, 0.12199677f, 0.10904323f, -0.03965567f, 0.01035409f, -0.06991649f, -0.04144938f, 
    0.06268375f, -0.18453614f, -0.03283167f, -0.01236723f, -0.08227886f, -0.01422134f, 0.07143722f, 0.09018045f, 
    -0.03402937f, 0.03456293f, -0.15757631f, 0.02844474f, 0.15961310f, 0.18039717f, -0.15091500f, 0.12634698f, 
    0.05455725f, -0.06834030f, 0.16416040f, -0.09677640f, -0.01429409f, -0.00434537f, -0.02051530f, -0.07850980f, 
    -0.20557642f, 0.10887113f, 0.11501423f, 0.07558639f, 0.05455490f, 0.06856947f, -0.00358127f, -0.13256571f, 
    0.10558177f, 0.07075222f, -0.06069579f, 0.07899392f, -0.16783889f, -0.08501025f, -0.03041807f, 0.00835773f, 
    -0.01322226f, -0.10140457f, -0.13090211f, 0.06672747f, -0.00458707f, 0.15146770f, -0.07858235f, 0.05011059f, 
    0.06745477f, -0.26023105f, -0.03923049f, -0.04038033f, 0.10480919f, -0.06512055f, -0.00423018f, 0.00046742f, 
    0.17763871f, -0.10676689f, -0.12488415f, -0.05268320f, 0.01974670f, 0.14364800f, -0.04614671f, -0.02994356f, 
    0.16211388f, 0.03860271f, -0.01817845f, 0.04290329f, 0.16181456f, 0.03922468f, 0.11418034f, 0.06746749f, 
    -0.35400376f, 0.12828942f, 0.03215007f, -0.00465227f, -0.02976985f, -0.02948608f, -0.10827632f, 0.04402783f, 
    -0.02509768f, -0.01185254f, 0.12724653f, 0.08717629f, 0.06461489f, -0.11893424f, -0.08039055f, 0.14563268f, 
    0.05097713f, -0.01787511f, -0.16409202f, -0.10597945f, 0.02520246f, 0.01955886f, -0.07375032f, -0.06046410f, 
    0.21859504f, 0.13155130f, -0.01220212f, 0.08435287f, 0.03441697f, 0.06906275f, 0.05534487f, 0.03744505f, 
    0.02636008f, 0.14297500f, 0.05652863f, 0.00239790f, -0.20297852f, -0.15531030f, -0.02958173f, -0.10234570f, 
    0.04348614f, 0.17920649f, -0.08669274f, 0.06106286f, 0.00300230f, 0.12451167f, 0.15132175f, 0.19624041f, 
    -0.50907463f, -0.16960280f, 0.09195511f, -0.03413111f, 0.02786971f, -0.14494008f, 0.07427857f, -0.11605293f, 
    0.05594998f, 0.14493904f, 0.13495710f, 0.06054031f, -0.09180006f, 0.14098488f, 0.02175621f, 0.12736817f, 
    0.13495636f, 0.03368425f, 0.08454692f, 0.02758926f, 0.10950655f, 0.06710692f, 0.07751224f, 0.10815969f, 
    -0.13229264f, -0.12931634f, 0.20673105f, 0.01547796f, 0.19595946f, 0.14123978f, 0.05157126f, -0.02604518f, 
    0.04610383f, -0.07317525f, -0.10541348f, 0.00867302f, -0.15951209f, -0.07826458f, -0.00325218f, 0.22210658f, 
    0.10637680f, 0.09868408f, 0.01516340f, 0.04920223f, 0.12784080f, 0.15215176f, 0.06832567f, -0.08227700f, 
    0.03581466f, -0.20192517f, -0.14851280f, -0.12315787f, 0.07340133f, 0.15893555f, -0.11449383f, -0.09178369f, 
    -0.04308293f, -0.03755717f, -0.06356120f, 0.04446439f, 0.09337172f, -0.03578070f, -0.04045831f, -0.06058006f, 
    0.13187930f, -0.00078140f, -0.03319842f, 0.05586176f, 0.09175740f, 0.18342091f, 0.12810965f, 0.06799106f, 
    0.04009070f, -0.07389055f, -0.06252014f, -0.01764027f, -0.04908839f, -0.00934438f, -0.06270064f, 0.03999591f, 
    -0.07457691f, -0.01474477f, 0.03381804f, 0.04751026f, -0.04103654f, 0.01191772f, -0.03669389f, -0.06791984f, 
    0.05622798f, -0.06616168f, 0.03136709f, -0.07695804f, -0.05682522f, 0.05786606f, 0.00549202f, -0.03768725f, 
    0.00035501f, 0.05638501f, 0.04893455f, 0.03352977f, -0.05568538f, 0.04566275f, 0.03856687f, 0.02170156f, 
    -0.03508230f, 0.03017424f, -0.02284036f, 0.03408822f, -0.01335259f, -0.02464817f, 0.02517632f, -0.00605302f, 
    0.06130575f, -0.07417705f, -0.07226618f, -0.07640416f, -0.04083365f, 0.01420266f, 0.01975780f, -0.02880116f, 
    -0.03492683f, -0.00112656f, 0.00588436f, -0.02091428f, 0.02694006f, 0.01456983f, 0.05430091f, -0.07885823f, 
    0.05696071f, 0.03657487f, 0.00504529f, 0.02908457f, 0.01364908f, 0.05532996f, -0.00330475f, -0.04400975f, 
    0.01017365f, 0.04809131f, 0.04953113f, 0.06241034f, -0.07755955f, 0.03426077f, -0.02694758f, 0.06198079f, 
    -0.03938283f, -0.03458524f, -0.00923291f, -0.01023268f, -0.01528171f, 0.02550858f, -0.06069447f, -0.04038188f, 
    -0.06161229f, -0.05619341f, -0.06550180f, -0.01878517f, 0.00841813f, -0.02747364f, -0.04697729f, -0.07659395f, 
    -0.00206717f, 0.02158868f, -0.05202040f, -0.02832958f, -0.06288671f, -0.00521253f, 0.03694151f, -0.02716754f, 
    0.02105635f, -0.02111619f, -0.05588846f, -0.01241717f, -0.00025365f, -0.05744948f, 0.03821697f, 0.00464711f, 
    0.02296240f, -0.01300304f, -0.03875671f, 0.05410607f, -0.05091572f, 0.02143163f, 0.05895381f, -0.05545081f, 
    0.05028434f, -0.04018313f, 0.00106853f, -0.04043883f, -0.00633291f, -0.01861572f, 0.04828060f, 0.02539754f, 
    0.04477413f, -0.04090639f, -0.05467020f, -0.01489260f, -0.06043556f, 0.02544922f, -0.01909033f, -0.04844531f, 
    -0.03749786f, -0.02523709f, 0.01881152f, -0.06941607f, 0.02942866f, -0.03144161f, -0.07534270f, -0.04891325f, 
    -0.04993986f, -0.01825134f, -0.05000407f, -0.01166029f, -0.05995441f, -0.00684019f, 0.04172305f, -0.05721359f, 
    -0.05489629f, -0.05531940f, -0.04602190f, -0.07340191f, -0.01080032f, -0.00270674f, 0.01187144f, -0.03558981f, 
    -0.04088078f, -0.04119470f, -0.02387219f, 0.06311028f, -0.00646780f, -0.06080866f, 0.03510603f, -0.03990155f, 
    0.06223135f, -0.02571792f, 0.05631938f, 0.04686813f, -0.01494800f, 0.04725638f, -0.02853143f, -0.06339929f, 
    -0.05039069f, 0.04369246f, 0.02785035f, -0.03723666f, -0.05059227f, 0.03718172f, 0.01218665f, -0.00221705f, 
    0.01253908f, -0.02308628f, -0.07743192f, -0.02300002f, 0.05220553f, 0.00199508f, -0.04780340f, 0.04301045f, 
    0.03874662f, 0.02447796f, -0.05141887f, 0.05165661f, -0.06349687f, -0.04324825f, 0.01002341f, -0.06652626f, 
    0.13403302f, 0.15914674f, 0.12731345f, 0.08258799f, -0.02499985f, -0.03544207f, -0.08649997f, 0.07430749f, 
    -0.01119239f, 0.11217329f, -0.06783771f, 0.06099066f, 0.20622259f, 0.20148250f, 0.07868866f, 0.02901079f, 
    0.01563817f, 0.05697988f, 0.09301439f, -0.04563949f, 0.08087590f, -0.00311295f, -0.09528559f, -0.13885540f, 
    0.11464294f, -0.25935170f, -0.12803239f, -0.00535119f, -0.01847413f, -0.05169583f, -0.02101531f, -0.09125543f, 
    -0.00656538f, 0.03060010f, 0.00093425f, 0.03537531f, 0.08463102f, 0.01408568f, 0.04854682f, 0.17624682f, 
    -0.01941333f, -0.02085830f, -0.03262937f, 0.07685836f, -0.03160882f, -0.02024508f, 0.09615545f, 0.00351022f, 
    -0.08868202f, 0.00783665f, 0.02944867f, 0.01750185f, 0.11332753f, -0.11825626f, -0.06984948f, -0.10839779f, 
    0.05858937f, 0.09405991f, 0.15758382f, 0.00871092f, -0.19635276f, -0.09296841f, -0.09300946f, -0.08372134f, 
    0.06057457f, -0.05695712f, 0.03629931f, -0.06689625f, -0.01057185f, -0.03263466f, 0.12056697f, -0.10787372f, 
    0.17093013f, 0.21630852f, 0.19605283f, 0.06184373f, 0.06503766f, 0.12292451f, -0.07022525f, 0.10973835f, 
    0.01878106f, 0.00492638f, 0.03423840f, -0.04238869f, 0.05698670f, 0.14918087f, -0.08702013f, 0.17068927f, 
    0.12993883f, -0.04786941f, -0.04249656f, 0.06750769f, 0.04497347f, -0.08807739f, 0.07240384f, 0.05200940f, 
    0.08901377f, 0.02526657f, 0.11940578f, 0.18852367f, -0.02668752f, 0.06159057f, 0.09116720f, 0.04668942f, 
    0.02812497f, -0.05522167f, -0.12007844f, 0.09262476f, -0.09786016f, -0.26714844f, -0.17589945f, -0.00879055f, 
    0.00504339f, -0.07356117f, -0.07780148f, -0.04771183f, -0.06313054f, 0.02100588f, 0.00329042f, 0.10285898f, 
    -0.19540675f, -0.02736595f, -0.19250408f, -0.05145279f, 0.06893741f, 0.10711922f, 0.10380195f, -0.08062048f, 
    0.01659803f, -0.04334876f, 0.02558396f, -0.10713473f, 0.00923952f, -0.07719956f, 0.05715217f, 0.18874136f, 
    0.05845714f, 0.04163500f, 0.06647298f, -0.01138734f, -0.00790124f, -0.10848975f, -0.03510978f, 0.02871818f, 
    0.24746174f, -0.02207706f, -0.14524195f, -0.08654708f, -0.08452916f, 0.08833445f, 0.01129536f, 0.03367130f, 
    0.00355018f, 0.03342117f, -0.06268584f, -0.11994746f, 0.18799217f, 0.05032744f, 0.12197948f, 0.10270080f, 
    0.10642349f, 0.00909905f, -0.03077550f, 0.08961081f, 0.06595688f, 0.03426745f, 0.17148229f, -0.05428248f, 
    -0.19040132f, 0.00244373f, -0.17032485f, -0.15189292f, 0.03314176f, 0.07433376f, 0.13944152f, -0.06175682f, 
    0.08229654f, 0.03281138f, -0.06997667f, 0.10033897f, 0.04179385f, 0.09470371f, -0.05015276f, -0.22745678f, 
    0.04605305f, -0.08265103f, -0.03540111f, 0.04865355f, 0.05725320f, 0.07466815f, -0.04983598f, 0.06883120f, 
    0.02059231f, -0.03384881f, -0.07620005f, 0.04868858f, 0.01889139f, -0.04263804f, -0.07422840f, -0.02718553f, 
    -0.06275168f, -0.07714501f, 0.05658311f, -0.02005528f, 0.00496965f, 0.01592315f, -0.04560808f, -0.01760201f, 
    0.03837888f, 0.00285086f, 0.00304034f, -0.04121871f, -0.04379983f, -0.02825195f, 0.03765991f, -0.03913737f, 
    0.05237666f, 0.04539374f, -0.02773680f, -0.03426820f, -0.03236030f, -0.04159162f, -0.01565215f, -0.06712820f, 
    0.00306667f, 0.06093620f, 0.01582839f, -0.01221799f, 0.01619995f, -0.02393391f, 0.01246125f, 0.00903578f, 
    0.04788474f, -0.05236292f, -0.03993498f, 0.01024527f, -0.03414928f, 0.03073756f, -0.04645136f, 0.04432948f, 
    0.01251785f, 0.01121072f, 0.05516380f, -0.08005682f, 0.02442112f, 0.03461025f, -0.03210605f, 0.04064372f, 
    0.03928936f, 0.04487345f, 0.00585470f, -0.01682481f, -0.03310191f, -0.08043529f, -0.03601775f, -0.00604546f, 
    0.01039494f, 0.02482755f, -0.01990408f, 0.05935106f, 0.04800173f, 0.05366537f, -0.00618317f, 0.04548959f, 
    0.01476129f, -0.03787176f, 0.02233799f, -0.06072829f, -0.07022143f, 0.03795258f, -0.04433341f, 0.00142535f, 
    0.06342851f, -0.02610777f, -0.05906677f, 0.02491728f, -0.04669018f, -0.00329478f, 0.02346873f, -0.02696325f, 
    -0.06413787f, 0.02217959f, -0.01920294f, -0.07736349f, -0.02287390f, 0.01607643f, -0.02490308f, -0.06336679f, 
    -0.05215478f, -0.02100913f, 0.01433354f, -0.06531575f, -0.00240496f, -0.06436016f, -0.07248172f, 0.01713991f, 
    0.00254067f, -0.05523527f, 0.01673855f, -0.04464800f, 0.02754404f, -0.04630116f, -0.04594133f, -0.04382552f, 
    -0.06769352f, -0.07979350f, -0.05980477f, 0.02408640f, -0.05219554f, 0.03990716f, 0.02468393f, 0.02415802f, 
    -0.03271396f, 0.01508507f, 0.05493618f, 0.00463550f, -0.01949085f, 0.00734319f, -0.02115231f, -0.08286732f, 
    -0.00614793f, -0.04806707f, 0.02984207f, -0.00281147f, 0.04350298f, 0.04826865f, -0.04048085f, -0.05208577f, 
    -0.01022307f, -0.01980695f, 0.03401180f, 0.01416412f, 0.00270712f, -0.04534394f, 0.04022151f, -0.02465496f, 
    0.00168515f, 0.04853845f, 0.05537149f, 0.01598001f, -0.03768480f, 0.00590243f, -0.02791172f, 0.04898675f, 
    0.06155016f, -0.01446793f, -0.06301568f, -0.00246793f, -0.00118538f, 0.02104665f, -0.04237937f, -0.03217498f, 
    -0.05377829f, -0.01073667f, 0.01259306f, -0.02913663f, 0.05798323f, -0.08134337f, -0.01819210f, -0.02334797f, 
    0.03203064f, 0.03964964f, 0.00591748f, 0.04142082f, -0.04456761f, -0.03563808f, -0.06067105f, 0.00352955f, 
    0.03677599f, 0.05992017f, -0.02675624f, -0.03987232f, 0.03605608f, -0.06902984f, 0.05237033f, -0.02427506f, 
    -0.01563554f, 0.01427357f, -0.06850944f, -0.01897795f, 0.00601442f, -0.06074524f, 0.05884083f, 0.05505637f, 
    -0.06535023f, 0.22314766f, -0.03212905f, -0.02709163f, 0.10264586f, 0.08195177f, 0.00161779f, 0.11398895f, 
    -0.03825746f, -0.01740975f, 0.02395786f, -0.01663304f, 0.12491554f, -0.06016496f, -0.02957014f, -0.17344476f, 
    0.25250199f, 0.08599389f, 0.02003443f, -0.04551602f, 0.07152163f, 0.01116874f, -0.08793646f, 0.06150727f, 
    0.05328296f, -0.18971895f, 0.05426088f, 0.02206457f, -0.09244555f, 0.02997628f, 0.13963327f, 0.06680301f, 
    -0.01262850f, 0.15050784f, 0.05407986f, 0.09649784f, -0.14177075f, 0.10567306f, -0.15985702f, -0.00065275f, 
    -0.12049039f, 0.01174532f, -0.12312279f, 0.03978080f, 0.00415945f, -0.03412738f, 0.02268450f, -0.03143006f, 
    0.04389949f, 0.04413056f, -0.05838729f, 0.00442342f, 0.10033525f, -0.05536062f, 0.00358955f, -0.06879791f, 
    -0.01690935f, -0.01708362f, -0.04209210f, -0.03614502f, 0.21184400f, 0.00101130f, 0.13732158f, 0.07451725f, 
    -0.08866779f, 0.00926888f, 0.06284239f, 0.00385821f, 0.09133305f, -0.03874718f, -0.08254182f, 0.11576031f, 
    -0.32576668f, -0.19640924f, 0.01016347f, -0.12712996f, 0.05239318f, 0.07003353f, -0.03218169f, 0.01153318f, 
    0.10538360f, -0.03725155f, 0.12980457f, 0.01695640f, 0.04330106f, 0.08205277f, 0.19956298f, -0.18993981f, 
    0.02941778f, -0.00787537f, -0.01693925f, -0.03380901f, -0.04079347f, -0.07548603f, -0.01866013f, -0.05252850f, 
    -0.03991285f, -0.04229039f, 0.03324232f, 0.13695952f, -0.20087843f, 0.00726522f, -0.06505435f, -0.06845400f, 
    -0.10472056f, 0.09282002f, -0.03420236f, -0.01585080f, 0.29729721f, -0.03468671f, 0.07812827f, 0.05388868f, 
    -0.02247332f, 0.08271780f, -0.00297722f, 0.01391761f, 0.07600251f, -0.09265364f, 0.06472393f, 0.16560201f, 
    0.04026133f, 0.01803124f, -0.03574746f, 0.12564397f, -0.12214877f, -0.02136581f, -0.03572593f, 0.05745281f, 
    0.03840756f, 0.09412031f, 0.08704623f, 0.17064600f, 0.17992045f, -0.27235422f, -0.09270676f, 0.01198269f, 
    0.04490685f, -0.06688236f, -0.16387178f, 0.12431272f, -0.08374675f, -0.00431053f, -0.03912924f, -0.00630757f, 
    0.37113634f, 0.10276050f, 0.00538433f, 0.09161657f, 0.02416194f, -0.11839513f, 0.04517357f, -0.02067788f, 
    0.00838770f, -0.08550902f, -0.10117241f, 0.02276737f, -0.25894347f, -0.08726710f, -0.11719988f, 0.06601723f, 
    -0.21814376f, -0.05847000f, 0.00548071f, -0.03830137f, -0.05163521f, 0.02706407f, -0.02989676f, 0.00100351f, 
    0.31895089f, 0.07588976f, 0.01979732f, -0.04326206f, 0.04349715f, 0.00030744f, -0.11260960f, 0.03052745f, 
    -0.04717714f, -0.01516904f, -0.16659646f, -0.06192034f, 0.16748163f, -0.10125682f, 0.02818795f, 0.00053751f, 
    -0.03938471f, -0.06609888f, 0.07968095f, 0.04273878f, 0.00137822f, 0.03200777f, 0.07787897f, 0.01661159f, 
    -0.00907846f, 0.03906262f, -0.00687512f, 0.04540566f, -0.06499110f, -0.01536942f, -0.05163109f, -0.01762119f, 
    -0.00813897f, -0.03384085f, 0.01818012f, 0.00945810f, -0.04934101f, -0.01232064f, -0.04409023f, -0.00883567f, 
    -0.03245345f, -0.07359545f, -0.01426052f, -0.07035318f, -0.07674435f, 0.01453189f, 0.03319520f, 0.00494468f, 
    -0.02783015f, -0.05318904f, 0.03892231f, 0.01000461f, 0.04276523f, -0.04300791f, -0.07585867f, 0.00324581f, 
    -0.03330171f, -0.07227276f, -0.06789787f, -0.03244395f, -0.01550321f, -0.00664398f, -0.07491749f, 0.03405774f, 
    -0.03938179f, 0.04389146f, -0.06132553f, 0.05035364f, -0.00307441f, 0.02334370f, -0.00626890f, 0.05317528f, 
    -0.01435493f, 0.02812793f, 0.03232263f, 0.00573171f, -0.01867718f, -0.07997601f, 0.04972224f, -0.04273004f, 
    -0.04273978f, -0.05014206f, 0.02837325f, 0.02960091f, 0.00976543f, -0.00320854f, -0.06301135f, 0.04820946f, 
    0.03599114f, 0.04619207f, -0.04216184f, -0.05311596f, -0.02062257f, 0.05479205f, 0.01284405f, 0.02319876f, 
    0.04811373f, -0.05040387f, -0.06306881f, 0.04271282f, -0.04643838f, 0.03644233f, -0.07068095f, -0.06291389f, 
    0.02349074f, -0.00422420f, 0.04860264f, -0.06855731f, -0.07802051f, 0.03149213f, -0.06912328f, 0.04979110f, 
    -0.03115357f, -0.01180190f, -0.05153350f, -0.05512211f, -0.04993940f, 0.04040518f, -0.02348608f, -0.00677729f, 
    -0.03355478f, -0.01930797f, -0.07831880f, 0.06305623f, 0.02254188f, 0.03518234f, -0.06178755f, -0.06839033f, 
    0.04196292f, 0.04606987f, -0.06960956f, -0.05675259f, -0.06634390f, 0.01654474f, 0.03978252f, 0.04198617f, 
    -0.07507872f, 0.04944578f, -0.02065981f, 0.01583815f, -0.00367864f, 0.01120867f, -0.06366748f, -0.04728153f, 
    -0.03261490f, 0.03948617f, -0.04758702f, -0.02976451f, 0.02460421f, -0.03686486f, 0.01548633f, -0.03216516f, 
    -0.07636997f, -0.03694582f, 0.02186645f, 0.01632627f, -0.03298034f, 0.05672675f, -0.02195964f, -0.01447241f, 
    -0.01210985f, -0.02247892f, 0.00319155f, 0.01518052f, 0.02297634f, -0.00509141f, 0.04971960f, 0.02913921f, 
    0.04325351f, -0.00403877f, 0.03356405f, -0.02162320f, -0.02145853f, 0.06377913f, -0.03948645f, -0.04968518f, 
    0.00100230f, -0.02737505f, -0.06276181f, -0.01607443f, 0.06078456f, 0.04040885f, -0.00642749f, 0.04697810f, 
    -0.03752238f, 0.02146306f, -0.05751633f, -0.00735039f, -0.02416747f, 0.05432097f, -0.03781038f, 0.00210440f, 
    -0.05619093f, 0.05970945f, -0.04609504f, -0.06879468f, -0.04729077f, 0.03629863f, 0.04535866f, -0.04172010f, 
    -0.02432257f, 0.05397274f, -0.02292257f, -0.04173693f, 0.04307887f, -0.05811637f, 0.01162740f, 0.00509415f, 
    -0.05479633f, -0.02142717f, 0.02086671f, 0.01529735f, 0.03324212f, 0.04463466f, -0.01703236f, 0.02049342f, 
    0.35645869f, -0.22061881f, -0.02556957f, 0.03593522f, 0.01335298f, -0.04314352f, 0.07027768f, 0.11824264f, 
    0.02880139f, -0.07736005f, 0.06391379f, -0.01557667f, -0.12394232f, -0.08179573f, -0.10178351f, 0.14045967f, 
    -0.14987333f, 0.01433276f, 0.11361051f, 0.13020030f, -0.06803014f, -0.03008940f, 0.05945731f, -0.11005602f, 
    0.06475875f, 0.32288572f, -0.11081930f, -0.23411368f, 0.24092166f, -0.01854805f, -0.16143706f, -0.02047937f, 
    -0.00581514f, -0.12074084f, -0.05341091f, 0.01078267f, 0.18298452f, -0.09070951f, 0.04422175f, -0.26901484f, 
    0.11440758f, -0.15914287f, 0.04647469f, 0.03862625f, -0.12401456f, 0.12355094f, -0.04933901f, -0.02166100f, 
    -0.12500565f, 0.07057261f, 0.09131926f, -0.03477718f, 0.04268467f, 0.06812629f, 0.05855716f, 0.00772677f, 
    0.01652736f, 0.01251702f, 0.05844970f, 0.12297343f, 0.08670304f, 0.16525827f, -0.04158242f, 0.06600960f, 
    0.12389121f, -0.03719082f, -0.12061810f, 0.00642651f, -0.06542686f, 0.01908459f, 0.00519720f, -0.01814625f, 
    0.30362156f, -0.21195719f, -0.06601044f, 0.13751887f, 0.04536188f, -0.02257217f, 0.06377612f, 0.03296003f, 
    -0.12053502f, -0.04249992f, 0.03267564f, 0.03429179f, -0.13991444f, 0.08087305f, -0.23696269f, 0.23932086f, 
    0.03731552f, 0.09750281f, -0.09518322f, 0.05161309f, 0.06413916f, 0.04721636f, 0.19446158f, 0.06591762f, 
    0.03066504f, -0.03817234f, -0.24677363f, -0.24667865f, 0.02875932f, 0.05714734f, 0.12615192f, 0.00706291f, 
    0.07702193f, 0.02865145f, -0.02997774f, 0.12854004f, -0.09798966f, 0.06052039f, 0.16117403f, -0.07509634f, 
    0.35147002f, 0.05495004f, -0.24061993f, -0.02183227f, 0.04742691f, 0.02953512f, 0.07631493f, 0.00545265f, 
    -0.38298970f, 0.07239897f, -0.23251779f, -0.12877114f, 0.16764162f, 0.01989613f, -0.00677130f, -0.14202756f, 
    -0.06231517f, 0.06931742f, -0.01995794f, 0.07372093f, -0.17570037f, 0.39109644f, -0.08651625f, -0.03988518f, 
    0.03364923f, 0.02751843f, 0.08677858f, 0.00312132f, 0.03133257f, 0.00766481f, 0.03341130f, -0.01936880f, 
    -0.07632760f, -0.08683253f, 0.12023321f, -0.09535335f, 0.21388130f, 0.18102697f, -0.05849883f, -0.15310562f, 
    0.06216083f, 0.02081721f, 0.04983284f, 0.07437651f, -0.11398264f, -0.07059245f, 0.00466344f, 0.00922992f, 
    0.11383484f, 0.09212377f, -0.10340209f, 0.01662141f, 0.03843076f, 0.01694426f, 0.04762869f, 0.06829579f, 
    -0.01228154f, 0.13811429f, 0.08163320f, 0.22368559f, 0.02028744f, 0.09791920f, 0.02711019f, -0.00457288f, 
    0.14172658f, -0.09062960f, -0.04029757f, 0.06840102f, -0.12955722f, 0.15721035f, -0.01872972f, -0.14022575f, 
    0.07900696f, -0.04095787f, 0.01460456f, 0.01417013f, 0.04287729f, -0.02483207f, -0.02937619f, -0.03860378f, 
    -0.03776794f, 0.01036567f, -0.00235464f, -0.06764404f, 0.03620346f, 0.01730074f, -0.03148346f, 0.00272971f, 
    0.03797252f, -0.03012603f, 0.03812434f, -0.06651854f, -0.06020120f, 0.06602218f, -0.07624456f, 0.00862319f, 
    -0.04756218f, -0.02924250f, 0.04068268f, -0.03421179f, -0.06852268f, 0.03253642f, 0.05139589f, 0.02339524f, 
    -0.05594135f, -0.04343542f, -0.01481231f, -0.03756945f, 0.02078024f, 0.04449034f, -0.05619756f, 0.03863804f, 
    0.01471330f, -0.04024379f, 0.00425647f, -0.05564990f, -0.01584872f, -0.03961143f, 0.02032171f, -0.02744936f, 
    -0.00134658f, 0.01712065f, 0.02015218f, 0.00250414f, 0.01728838f, 0.01891017f, -0.01031943f, -0.07271201f, 
    -0.07179137f, 0.03169219f, -0.07440671f, -0.00167469f, 0.01091886f, -0.03363198f, 0.00298015f, 0.04486987f, 
    -0.06567149f, -0.03295305f, -0.03828611f, -0.03735046f, -0.07048176f, 0.01432339f, -0.03021903f, -0.04678348f, 
    -0.06854268f, -0.07815237f, 0.02647420f, -0.02130331f, -0.05152092f, 0.03573050f, -0.00713567f, -0.06448950f, 
    -0.02227339f, 0.00833761f, 0.03638606f, 0.02842379f, 0.06389537f, -0.02187854f, 0.03335857f, -0.05085025f, 
    0.00507055f, 0.03426277f, 0.04678396f, -0.01316741f, 0.03935483f, 0.03311767f, 0.00574752f, -0.06366310f, 
    -0.07437691f, -0.04581536f, -0.06406396f, -0.04815722f, 0.02401686f, -0.03123589f, -0.04998212f, -0.04380414f, 
    -0.00297258f, -0.03832300f, 0.02803510f, 0.04064450f, -0.01429956f, 0.05507018f, 0.00135049f, -0.02556957f, 
    0.00617988f, 0.03039599f, -0.01872015f, 0.06156974f, 0.01104381f, -0.05839782f, -0.04842146f, 0.03055898f, 
    0.04218265f, -0.01816693f, -0.00180457f, -0.05714750f, -0.00571788f, -0.01921683f, 0.05539040f, 0.06377323f, 
    0.00572077f, -0.05738675f, -0.07302573f, -0.05927530f, 0.06576647f, -0.03467118f, -0.03861487f, -0.01123042f, 
    -0.04928049f, 0.00990378f, -0.05494254f, -0.03585832f, -0.06286123f, -0.05568834f, 0.05403697f, -0.04699497f, 
    0.04105804f, -0.02669972f, -0.03112933f, 0.03716044f, -0.01533496f, -0.03832923f, -0.02664885f, -0.04963668f, 
    0.00862302f, -0.02970263f, 0.00593609f, 0.05930891f, -0.04081602f, -0.06611635f, -0.04438837f, 0.03972332f, 
    0.04522061f, 0.05212592f, 0.03794598f, -0.05168381f, -0.05293801f, 0.06237308f, -0.03031570f, -0.00440509f, 
    -0.07433897f, 0.04060436f, 0.03805952f, 0.01420435f, 0.03739186f, 0.04345987f, -0.06465829f, 0.00615696f, 
    -0.00011533f, 0.05036240f, 0.01000156f, -0.04376757f, 0.05783631f, 0.04654950f, 0.01009204f, -0.06191319f, 
    0.01801024f, -0.02079654f, -0.05816035f, -0.04086880f, -0.06274424f, -0.03960816f, 0.03534357f, 0.03247976f, 
    -0.07250820f, -0.00935649f, 0.01966048f, -0.02117339f, 0.02466308f, -0.00664949f, -0.07236388f, -0.00683444f, 
    -0.06351286f, 0.05281729f, -0.07110856f, -0.03946792f, -0.03100255f, 0.00607687f, 0.01522997f, 0.05212128f, 
    -0.06775700f, -0.05300560f, -0.05165902f, 0.03116694f, -0.02827514f, -0.07261778f, 0.04416396f, -0.03733118f, 
    -0.05664708f, 0.04966807f, -0.04061953f, 0.04163355f, -0.08709647f, 0.03377244f, -0.03388121f, 0.03228828f, 
    -0.03290938f, -0.02822340f, -0.05191364f, -0.03348679f, 0.02951718f, -0.02142942f, 0.03388460f, -0.05778374f, 
    0.00362174f, -0.04156392f, -0.09755060f, -0.08032731f, -0.02671210f, -0.07433693f, 0.01097381f, 0.04716687f, 
    0.04051326f, 0.01991223f, 0.00701522f, -0.07565257f, -0.03255272f, -0.01737947f, -0.06928735f, 0.02290484f, 
    0.03143650f, 0.00133362f, 0.01356492f, -0.06003792f, 0.02969508f, 0.03802605f, 0.03934554f, -0.09225916f, 
    -0.04882774f, 0.00752837f, 0.03725057f, -0.03372364f, 0.02159194f, -0.04454929f, 0.04055348f, -0.03940430f, 
    0.05946781f, -0.03152147f, -0.03445239f, -0.07249217f, -0.07305071f, 0.00592095f, -0.04833312f, 0.02127394f, 
    -0.00846002f, 0.03733814f, -0.05416507f, 0.01236393f, 0.02765869f, 0.01927138f, -0.02813572f, -0.04496896f, 
    -0.03129886f, 0.04453795f, -0.06902187f, -0.03244061f, -0.06712503f, -0.01304719f, 0.03932580f, 0.04777993f, 
    0.06078964f, -0.03166777f, 0.02243991f, -0.10113852f, -0.09397665f, 0.05555159f, -0.04435900f, 0.02408693f, 
    -0.04992814f, -0.02014191f, -0.08740541f, -0.08379550f, -0.06579845f, 0.01529875f, -0.07330263f, 0.05770779f, 
    -0.07648547f, -0.08980925f, 0.05214716f, -0.08797257f, -0.07964663f, 0.04249766f, 0.02024431f, 0.01409640f, 
    0.04018522f, 0.04306516f, 0.02428819f, -0.09694599f, 0.01962068f, 0.03423270f, -0.09886596f, 0.01568932f, 
    0.05215751f, -0.02431365f, -0.04052641f, -0.05069931f, 0.04932126f, 0.02970857f, 0.04444225f, -0.03757631f, 
    -0.04317066f, 0.02088931f, -0.02998148f, -0.08461281f, -0.05878962f, 0.01131042f, -0.02787123f, -0.04560433f, 
    -0.04977092f, -0.05166550f, -0.02244741f, 0.04534343f, 0.04415251f, -0.07597739f, 0.02836582f, -0.00821302f, 
    0.04361476f, -0.00168986f, -0.03901801f, -0.01843658f, -0.06942748f, -0.03151478f, 0.03536817f, -0.02321874f, 
    0.01472300f, 0.04345540f, 0.06605604f, 0.02689681f, -0.07721060f, -0.02528189f, 0.01705822f, 0.01033135f, 
    -0.00592707f, 0.04905370f, -0.01504003f, -0.01373068f, -0.00324217f, 0.03680524f, 0.02307450f, -0.02263661f, 
    -0.00331057f, -0.06143156f, -0.05924869f, 0.00256423f, 0.04552754f, -0.00138277f, -0.07288013f, -0.06523418f, 
    -0.09761517f, -0.04847147f, -0.06072000f, 0.02695569f, -0.08236410f, 0.02710025f, -0.07543691f, -0.07332283f, 
    0.01057156f, -0.00235225f, -0.01305647f, 0.04165236f, -0.04923294f, -0.07174515f, -0.04183167f, -0.03663795f, 
    0.18251579f, 0.08027598f, -0.18419887f, 0.18434812f, -0.10354356f, -0.04687195f, 0.00675130f, 0.09171020f, 
    0.02476566f, 0.08876009f, 0.08632952f, 0.00138240f, 0.02257867f, -0.23050478f, -0.16401331f, -0.08951873f, 
    -0.14112611f, -0.06563787f, 0.03131088f, 0.10312145f, 0.16041733f, -0.05154479f, -0.06206095f, -0.04255796f, 
    0.06440236f, 0.01574408f, -0.18840316f, -0.19374356f, 0.18378367f, 0.04161498f, -0.00036348f, 0.12660791f, 
    0.01071526f, -0.11538980f, 0.04469568f, -0.02524280f, 0.26513991f, -0.01099472f, -0.12060883f, -0.02831611f, 
    0.20584530f, 0.04141309f, 0.04809090f, 0.09830604f, 0.07708000f, -0.02283047f, -0.00027982f, -0.16894208f, 
    -0.26482001f, 0.00193132f, 0.00138457f, -0.32098639f, 0.00260566f, -0.04327572f, 0.19493173f, -0.05204191f, 
    0.08129595f, -0.05382008f, 0.08353578f, 0.12704045f, -0.12317225f, 0.15859620f, 0.24287100f, -0.21286316f, 
    0.09124298f, 0.06814281f, -0.07097491f, 0.11999338f, 0.05244986f, 0.00026604f, 0.22264126f, 0.07711577f, 
    0.22199243f, -0.26724532f, -0.05716747f, -0.06236564f, 0.05988778f, -0.04070504f, -0.09656378f, 0.03181719f, 
    -0.02614071f, 0.00208828f, 0.01075752f, 0.02557534f, -0.16627614f, -0.04872916f, 0.06471127f, -0.12298676f, 
    0.23029262f, 0.09338546f, 0.10860290f, -0.00977582f, -0.07476109f, 0.03535981f, 0.17221019f, 0.14704992f, 
    0.22278672f, 0.06677414f, -0.05654484f, 0.02033156f, -0.09030453f, 0.01620862f, 0.12359700f, 0.15928985f, 
    -0.05585490f, 0.08450840f, -0.01663765f, -0.01073732f, -0.12466583f, -0.00516357f, 0.07841824f, -0.32529044f, 
    0.20775938f, 0.12629898f, 0.00110771f, -0.07969556f, -0.06908917f, 0.03828172f, 0.04893485f, 0.10752782f, 
    -0.28271359f, 0.02609852f, -0.28675285f, -0.23669207f, 0.10305367f, 0.05081107f, 0.06365459f, 0.10684761f, 
    -0.22522056f, 0.02146352f, 0.00377710f, 0.11421859f, -0.13967703f, 0.02733175f, -0.09433810f, -0.07731748f, 
    -0.05687972f, 0.14379480f, 0.04998768f, 0.10190460f, 0.08172280f, 0.17164728f, 0.16066091f, 0.01990895f, 
    -0.14660148f, 0.13249254f, 0.00359546f, -0.16530792f, 0.37732035f, 0.11633832f, 0.03681165f, -0.03488042f, 
    -0.06111053f, -0.13426441f, 0.05125996f, -0.01735629f, -0.33852327f, -0.12241973f, 0.14664319f, 0.19914757f, 
    0.00856008f, -0.02019561f, -0.06171325f, 0.23615140f, -0.02653697f, -0.02470490f, 0.11229592f, 0.05138019f, 
    0.14993843f, 0.05325611f, 0.05594793f, -0.10794084f, 0.03168037f, 0.04133804f, 0.00231143f, 0.07041594f, 
    0.09303845f, -0.03776328f, 0.07931714f, 0.11309864f, -0.36861870f, -0.07271820f, 0.19472644f, -0.07998049f, 
    0.10574117f, -0.12000715f, -0.07007010f, 0.09282966f, 0.06219118f, -0.14140213f, -0.01331670f, -0.02312198f, 
    0.07165115f, -0.03103488f, 0.13597263f, 0.00060869f, -0.00976408f, 0.06779505f, -0.06832647f, -0.03964340f, 
    0.05647305f, 0.06864998f, 0.13407809f, -0.04672479f, 0.33146688f, -0.02892519f, -0.11909785f, -0.46001437f, 
    -0.18788157f, -0.05238825f, 0.05645109f, -0.04725824f, 0.00612398f, 0.12084756f, -0.04121392f, 0.08371753f, 
    0.09194259f, -0.21295305f, 0.16682948f, -0.19597955f, -0.13306256f, -0.11142216f, 0.02035046f, -0.01257559f, 
    -0.06793036f, 0.18908113f, 0.11124156f, -0.05772260f, 0.15446132f, 0.05012117f, 0.00301684f, -0.00799376f, 
    0.16214830f, 0.27280796f, 0.04988889f, -0.08001869f, 0.12597175f, -0.08739158f, 0.08871365f, -0.07168624f, 
    -0.33675370f, 0.14546086f, 0.01331430f, 0.26986656f, 0.01646664f, 0.14511640f, 0.00623757f, 0.11009388f, 
    -0.18549521f, 0.02191857f, 0.11565421f, 0.05809750f, 0.14169598f, -0.14522545f, 0.03614192f, 0.04074815f, 
    -0.11945771f, 0.08248550f, -0.06559969f, -0.07724933f, -0.19076665f, 0.08687143f, 0.01189595f, 0.01546144f, 
    0.20235978f, 0.07065186f, -0.09346797f, 0.13668174f, 0.09391074f, 0.16691114f, 0.01050251f, 0.06451318f, 
    -0.01824324f, 0.01124235f, 0.01878886f, 0.02363503f, -0.39517546f, 0.27658880f, 0.14769478f, -0.00190002f, 
    0.17492308f, 0.05309043f, -0.03640430f, 0.17314862f, 0.01850816f, -0.11932687f, -0.00312840f, 0.10800730f, 
    0.21008390f, -0.01972474f, -0.06004233f, -0.02479515f, 0.21020597f, 0.03611082f, 0.00667562f, -0.05770975f, 
    0.03731063f, -0.09596466f, 0.03703927f, 0.00456939f, -0.04116647f, 0.18138835f, 0.00088010f, -0.13281582f, 
    -0.09503235f, -0.09505564f, 0.10638744f, -0.01982273f, 0.01430692f, 0.00582119f, -0.01360723f, -0.09509120f, 
    0.03270202f, 0.15325500f, 0.09401615f, -0.11340505f, -0.07718655f, 0.10071446f, 0.06890783f, -0.01868365f, 
    0.05981227f, -0.05523339f, 0.05124095f, 0.02765029f, 0.05150067f, -0.13529088f, 0.09971339f, 0.02514789f, 
    -0.13673376f, -0.03512942f, -0.02558731f, 0.05098474f, 0.11802655f, 0.08790559f, -0.13425069f, -0.01713927f, 
    0.05125884f, 0.32079655f, -0.01089365f, 0.06755620f, 0.03105395f, -0.00358889f, -0.06683140f, -0.00968051f, 
    0.06768752f, 0.15261728f, 0.06012743f, 0.09542366f, 0.20493002f, 0.07353818f, -0.04603839f, 0.24403062f, 
    -0.08128145f, 0.00809991f, 0.17154890f, -0.16491714f, 0.05866849f, 0.10506895f, 0.00982985f, -0.01677015f, 
    -0.47794920f, 0.06931821f, 0.02625862f, -0.01078909f, 0.01667269f, -0.08678616f, 0.16966823f, -0.06175428f, 
    0.20270027f, 0.02989651f, 0.11185787f, -0.08306006f, 0.00941032f, -0.28246558f, -0.25202233f, 0.24628480f, 
    -0.08749700f, -0.04214811f, -0.09066332f, 0.05453913f, -0.03369141f, -0.18469894f, -0.12129775f, 0.01164457f, 
    0.06278438f, 0.04130585f, 0.01615559f, -0.03079555f, 0.01944471f, -0.06956231f, 0.02870036f, -0.00879948f, 
    0.02992741f, 0.00830753f, -0.04215320f, -0.05007573f, -0.02255624f, -0.03740855f, -0.04317966f, -0.02736438f, 
    0.03211113f, -0.07466644f, -0.05295540f, 0.01319833f, -0.05727046f, -0.05042548f, 0.03431153f, -0.00316604f, 
    -0.06471621f, 0.02069030f, -0.03269293f, -0.03107448f, -0.00747256f, -0.00048330f, -0.06213428f, -0.02077409f, 
    0.02685426f, 0.04343604f, 0.03361769f, -0.07197131f, 0.06730801f, 0.00615216f, -0.03420927f, -0.02607234f, 
    -0.02606547f, 0.01848865f, -0.06264711f, -0.03398861f, -0.05361730f, 0.01546468f, 0.06028498f, -0.08159467f, 
    0.01760066f, 0.00333876f, 0.01779845f, 0.05299724f, -0.00402807f, -0.00289684f, -0.00746771f, 0.06560167f, 
    0.04731087f, -0.05390470f, 0.02391014f, -0.04401406f, 0.03216685f, 0.04677311f, 0.02681414f, -0.05502181f, 
    0.02499730f, 0.05395661f, -0.05161182f, 0.04149557f, 0.00097443f, -0.02254606f, 0.02224617f, -0.05302877f, 
    -0.00274661f, 0.00811213f, -0.02668476f, 0.00874986f, -0.05859426f, -0.03767485f, 0.06109701f, 0.00425086f, 
    -0.05438897f, 0.00756674f, 0.03276606f, 0.04616164f, -0.01491728f, -0.08253451f, -0.03877704f, 0.00955929f, 
    0.01148060f, 0.00097797f, 0.03923408f, 0.00253375f, -0.03165058f, 0.04054856f, 0.06078939f, 0.04451187f, 
    -0.06601880f, -0.05553881f, -0.07783970f, 0.03342026f, -0.07172988f, -0.06150464f, 0.03944669f, -0.07425012f, 
    0.05667460f, -0.08015597f, -0.06796506f, -0.05612332f, -0.04479153f, 0.02469257f, 0.00373741f, 0.00815835f, 
    -0.05520091f, -0.06764571f, -0.01015473f, -0.00942804f, 0.02513047f, 0.04709025f, 0.05840953f, -0.06099653f, 
    0.06222768f, -0.07023399f, -0.04715345f, -0.00961050f, -0.02192869f, 0.01287241f, -0.05158821f, -0.03277164f, 
    -0.01735217f, -0.01191529f, -0.00276456f, -0.03832345f, 0.04380339f, -0.05521070f, -0.00722163f, -0.02625000f, 
    0.04897803f, 0.05594440f, -0.07043475f, 0.04719386f, -0.04691038f, 0.04589905f, 0.02091198f, -0.05967188f, 
    0.04128411f, -0.02437495f, -0.02236444f, 0.01742908f, 0.05728308f, -0.00341786f, -0.07206988f, -0.07311932f, 
    -0.01557234f, -0.02948680f, 0.04518288f, -0.01536699f, 0.00407519f, -0.06678329f, 0.04689959f, 0.03262196f, 
    0.00778086f, 0.01277315f, -0.03406854f, -0.07103495f, 0.02564186f, -0.07717267f, -0.06798527f, -0.01559235f, 
    0.01897521f, 0.03298865f, 0.01771839f, 0.00045449f, 0.01998804f, -0.03644586f, -0.01699076f, 0.05681721f, 
    0.06145934f, -0.02306127f, 0.03268137f, -0.06526305f, 0.05590981f, -0.01314237f, -0.02083366f, -0.06202576f, 
    -0.03779276f, -0.07581192f, -0.00898025f, 0.03819857f, -0.08066037f, 0.02955227f, 0.05599326f, -0.03352302f, 
    -0.02883425f, 0.06230209f, 0.04055799f, -0.04589148f, -0.01123746f, -0.01717000f, -0.00849798f, -0.06431860f, 
    0.02276010f, -0.03782532f, -0.03073016f, 0.05467935f, -0.02746275f, -0.00379080f, 0.05659486f, 0.03732539f, 
    -0.01103980f, -0.02983939f, -0.03078131f, 0.01025300f, -0.01367088f, -0.00202489f, -0.07991606f, -0.06422613f, 
    -0.06360777f, 0.06353974f, -0.05047855f, 0.02578933f, 0.06394865f, -0.02007875f, -0.05372872f, -0.02261865f, 
    -0.03817873f, 0.04613585f, 0.05234451f, 0.00499339f, 0.01674426f, 0.06201490f, -0.00257324f, 0.04682210f, 
    0.02563224f, -0.05602306f, -0.03155744f, -0.01863120f, -0.03841111f, 0.06037623f, -0.07596730f, 0.06262136f, 
    -0.06222794f, 0.01798393f, -0.00828851f, 0.00550732f, -0.07445534f, -0.06015493f, -0.07565564f, 0.04708714f, 
    -0.06356320f, 0.04254202f, -0.01489623f, -0.03205062f, 0.01459136f, -0.00859586f, 0.05978829f, 0.06286059f, 
    0.01105512f, -0.02367320f, -0.00052910f, 0.06247363f, 0.01682427f, 0.01858361f, 0.05415850f, 0.04740861f, 
    0.02197424f, -0.03272820f, -0.05446909f, 0.02809995f, -0.03513804f, 0.01496612f, -0.07514718f, 0.03152651f, 
    0.04493051f, 0.04924569f, -0.05407220f, -0.04617355f, -0.07535142f, -0.05027576f, -0.03297187f, -0.00025739f, 
    0.02487432f, -0.02402908f, 0.00184680f, -0.03165397f, -0.05960874f, -0.01686267f, 0.05379588f, 0.03741835f, 
    -0.07629260f, -0.07343557f, 0.01388584f, -0.02418533f, -0.05326118f, -0.04609597f, 0.04729239f, -0.03301341f, 
    -0.05690084f, -0.05801099f, -0.02242881f, -0.03876031f, 0.03602108f, -0.00118220f, 0.06131263f, -0.06354833f, 
    -0.03862954f, 0.03710002f, 0.01216760f, -0.02710723f, 0.06359773f, -0.06016495f, 0.02863150f, -0.04927408f, 
    -0.04740924f, -0.07276967f, -0.06196695f, 0.01208950f, 0.02489279f, 0.05138794f, 0.01526658f, 0.01578785f, 
    -0.02807897f, -0.02265852f, -0.00329670f, 0.03554457f, 0.05855360f, 0.01714084f, 0.01786153f, -0.03944819f, 
    -0.04097364f, -0.07273415f, 0.02544250f, -0.07917771f, -0.02831303f, 0.01883819f, -0.00236695f, -0.08021898f, 
    -0.03831530f, -0.00548416f, -0.03516496f, 0.03774687f, -0.06363022f, -0.07060151f, 0.03186959f, 0.03619560f, 
    -0.07613418f, 0.00718956f, -0.06788152f, -0.06557690f, -0.06270139f, 0.03074845f, -0.07095841f, 0.04006224f, 
    -0.03619404f, 0.01233528f, -0.03433876f, -0.00210451f, -0.07557986f, 0.00873967f, 0.00098962f, -0.01887734f, 
    0.03163007f, -0.02471415f, 0.00396721f, 0.03369217f, -0.00817819f, -0.06613255f, 0.06522042f, 0.04125735f, 
    -0.05564341f, -0.07948053f, 0.00706317f, -0.01023967f, -0.02902254f, -0.04294907f, -0.07176542f, -0.06876040f, 
    0.00933241f, 0.01905009f, -0.05555596f, 0.04633199f, 0.02917774f, 0.01000184f, -0.06553307f, -0.04349910f, 
    0.29929534f, 0.03883347f, 0.04072722f, 0.10808570f, -0.00156768f, 0.05226156f, 0.04228654f, 0.02945809f, 
    -0.03534248f, 0.11197321f, 0.15132290f, 0.12916361f, 0.32839668f, 0.21033856f, 0.11392353f, 0.06239150f, 
    -0.10057330f, 0.15699112f, 0.08296855f, 0.19319789f, -0.03579959f, 0.09163169f, -0.09226673f, 0.00813635f, 
    -0.01890404f, 0.09195798f, 0.02764031f, -0.05818702f, 0.08990627f, -0.06388441f, -0.14471991f, -0.05182371f, 
    -0.10468622f, 0.02368809f, 0.03293675f, 0.12350886f, 0.25579226f, 0.07850862f, -0.08985427f, 0.33925349f, 
    0.08611547f, 0.01164058f, -0.06781102f, -0.06831993f, 0.03592203f, -0.00714298f, 0.02957179f, -0.12144919f, 
    0.02438950f, -0.06505672f, -0.05633501f, -0.03098604f, 0.06705050f, 0.01453405f, -0.01396464f, -0.05481450f, 
    -0.07210918f, 0.12956011f, 0.06115790f, 0.15011190f, -0.22964397f, -0.06293975f, -0.28934005f, -0.20403360f, 
    -0.06004700f, -0.05754835f, -0.07510041f, -0.16598588f, -0.15136482f, 0.02745464f, -0.04851712f, -0.01592374f, 
    0.48401994f, 0.20499995f, -0.08860794f, -0.02754972f, 0.11350298f, 0.08914387f, 0.00151180f, 0.08010053f, 
    -0.05112463f, 0.07911943f, 0.01691353f, -0.02395291f, 0.09880584f, 0.01210362f, -0.20194824f, 0.01120855f, 
    0.00071943f, 0.05499403f, -0.02350165f, 0.02090706f, 0.03669303f, 0.05399409f, 0.06190026f, 0.12903476f, 
    0.08448157f, 0.11234774f, 0.04698832f, 0.05754839f, 0.01254717f, -0.04521046f, -0.02459436f, -0.17819703f, 
    0.14704685f, 0.06824858f, -0.04401216f, 0.02020635f, -0.20520598f, -0.03812516f, -0.09505139f, -0.02690767f, 
    0.04128473f, -0.04375334f, 0.00308820f, -0.12322359f, 0.00170964f, 0.07648269f, -0.10314912f, -0.03225655f, 
    0.17718866f, 0.04542686f, 0.12572269f, 0.11341202f, 0.02678325f, -0.03757108f, -0.04626136f, -0.11803027f, 
    -0.08223783f, -0.10743853f, 0.01982325f, -0.13059576f, 0.01219154f, -0.14007232f, 0.12199824f, 0.04702088f, 
    0.08691376f, -0.06033514f, 0.14876318f, -0.04790291f, 0.03910920f, -0.01519136f, -0.07193375f, -0.03365676f, 
    -0.28580350f, -0.06873374f, -0.08300503f, -0.02962034f, -0.07969580f, 0.14175043f, -0.10072929f, -0.09109505f, 
    -0.06934784f, -0.05843343f, -0.00074290f, 0.01206532f, 0.07557975f, 0.20590988f, 0.10206160f, 0.02091332f, 
    0.04407667f, -0.08978020f, -0.00188271f, 0.08639851f, 0.10249358f, 0.03077067f, -0.04633373f, -0.03538946f, 
    -0.16395193f, -0.16060846f, -0.08098260f, -0.11052105f, 0.03395994f, -0.07498511f, 0.11001443f, -0.10399195f, 
    0.03592822f, 0.01225070f, 0.13048498f, 0.10960145f, -0.14865091f, -0.02094678f, -0.05915724f, 0.01763974f, 
    -0.08974148f, 0.02737220f, 0.04325926f, 0.05560374f, 0.01453171f, 0.07027598f, -0.05993173f, 0.02677021f, 
    0.13950653f, -0.05067265f, 0.14637907f, 0.07765611f, 0.08058614f, 0.07787412f, -0.11114886f, 0.16250376f, 
    0.13283417f, 0.06864081f, 0.03571672f, -0.06183752f, 0.08998658f, 0.08922256f, 0.12834668f, 0.28073812f, 
    0.11930448f, 0.14479053f, 0.09999101f, 0.07289623f, 0.11728720f, 0.07349678f, 0.07230287f, 0.01328917f, 
    0.20859091f, 0.28134570f, -0.17533305f, -0.27338132f, 0.08517362f, 0.01908807f, -0.12235342f, -0.03695947f, 
    0.00099744f, 0.01298541f, -0.10129785f, 0.04038696f, 0.26327533f, 0.10257219f, -0.14993723f, -0.14046189f, 
    -0.03973762f, 0.02810682f, -0.10493691f, -0.01768667f, 0.02801642f, 0.12178171f, -0.01519421f, 0.01386361f, 
    -0.24758825f, 0.16573513f, 0.10685878f, -0.14831530f, 0.06722882f, -0.01846246f, -0.04649975f, 0.09511674f, 
    0.06903125f, 0.07587032f, 0.13840048f, 0.14467031f, -0.10682969f, 0.06106323f, 0.02808336f, 0.05323753f, 
    -0.00135698f, 0.03199158f, -0.06298901f, 0.05257251f, 0.05980788f, 0.05938783f, 0.01437903f, -0.07216980f, 
    0.41080442f, -0.25782794f, 0.02342290f, 0.18294033f, 0.15523212f, 0.08616371f, 0.09428811f, -0.05854109f, 
    0.00782502f, 0.08205855f, 0.06541182f, 0.03729201f, 0.12261733f, -0.00491954f, -0.01377017f, -0.02564437f, 
    0.05845923f, 0.07956225f, -0.06250367f, 0.01045311f, 0.03192232f, 0.03792882f, 0.04040986f, 0.00632584f, 
    0.02026078f, 0.13589047f, -0.07142234f, 0.03158348f, 0.03642478f, 0.05753455f, 0.22256900f, -0.01010560f, 
    0.06594389f, -0.04170291f, -0.06601308f, 0.14293157f, 0.01605895f, 0.24722584f, 0.13837698f, -0.18908212f, 
    0.12994024f, 0.02226532f, -0.05544829f, 0.03022844f, 0.03202109f, 0.08623178f, 0.04658173f, 0.04742058f, 
    -0.10958836f, 0.24456716f, -0.24378379f, 0.00303775f, -0.08927500f, -0.17706031f, 0.01003761f, -0.07158152f, 
    -0.01674146f, 0.00066181f, -0.12829924f, 0.00145234f, -0.20669305f, 0.10145044f, -0.12576590f, -0.05268673f, 
    0.13854179f, -0.07068238f, 0.00911068f, 0.04929506f, -0.01832038f, 0.11195165f, 0.03906171f, 0.06211426f, 
    0.05824146f, 0.07811811f, 0.12356645f, -0.10526658f, 0.14037153f, 0.06014303f, -0.10853527f, -0.03427811f, 
    0.04430272f, 0.02222698f, 0.10031909f, -0.02704327f, 0.00606793f, -0.09629941f, 0.04815850f, 0.32885656f, 
    0.09127588f, 0.04149976f, -0.00055285f, -0.04489776f, -0.08636050f, 0.03119280f, 0.05837804f, -0.01679371f, 
    0.10912117f, 0.02468934f, 0.19694862f, -0.03635552f, 0.00866266f, -0.02939699f, 0.12960462f, 0.06381597f, 
    0.22645651f, -0.03701490f, 0.01076578f, 0.01038820f, -0.12389616f, 0.17995168f, 0.21577525f, 0.06283662f, 
    0.07604106f, 0.08732869f, 0.02410566f, -0.03420604f, 0.05660536f, 0.05554098f, 0.00266006f, 0.02405328f, 
    -0.05711834f, -0.20095445f, -0.07010398f, 0.00473213f, -0.03770832f, 0.11590666f, 0.04531880f, 0.00329070f, 
    0.16395260f, 0.03992266f, 0.08121019f, -0.07764892f, -0.13155054f, -0.12653819f, -0.22752498f, -0.13388413f, 
    0.06111784f, 0.02458151f, 0.06975105f, -0.13321066f, 0.02979997f, 0.11727948f, -0.04556508f, 0.04075613f, 
    -0.02390753f, -0.00519072f, 0.20713972f, -0.12021442f, -0.00677922f, -0.00423008f, 0.07617124f, -0.09927410f, 
    0.04053671f, 0.12895876f, 0.04267791f, 0.07921111f, 0.05263488f, -0.06300566f, 0.08815974f, -0.24938427f, 
    0.05452450f, 0.04614243f, 0.03296324f, 0.03384315f, 0.15192272f, 0.04151977f, -0.01181518f, -0.00256545f, 
    -0.05697043f, -0.03857281f, 0.02322111f, -0.14539953f, 0.05363022f, -0.05340491f, -0.10876213f, 0.05152104f, 
    0.00114602f, -0.02055027f, -0.04348164f, 0.04248639f, 0.17040187f, 0.00490648f, 0.28581142f, -0.04861983f, 
    -0.03606357f, 0.14080286f, -0.12183530f, 0.15670824f, -0.05462963f, -0.07988672f, 0.06968287f, 0.06212014f, 
    -0.33904722f, -0.23682293f, -0.29884046f, -0.03104889f, -0.10476928f, 0.05354140f, 0.03020001f, 0.07918850f, 
    -0.02417351f, -0.08490584f, 0.01937168f, 0.01832050f, -0.26069009f, 0.15689340f, 0.24691013f, -0.06768763f, 
    0.14094456f, 0.10711333f, 0.03638716f, -0.11770266f, -0.03868923f, 0.04018234f, 0.00153768f, 0.07980675f, 
    0.26792964f, 0.03736219f, -0.00719005f, 0.09193688f, 0.14930767f, -0.07517410f, -0.02426051f, 0.10404932f, 
    -0.02320706f, 0.13666600f, 0.08368443f, 0.01811041f, 0.10657139f, 0.18839039f, 0.05000037f, -0.14727932f, 
    -0.03009704f, 0.07163044f, -0.08580207f, -0.05256756f, 0.04709270f, 0.05220782f, 0.04219655f, 0.11171339f, 
    -0.09168024f, 0.05128292f, 0.27660900f, -0.14881946f, -0.12603585f, 0.00431584f, -0.15276805f, 0.02101384f, 
    -0.00171935f, 0.07435426f, -0.01639262f, 0.17512617f, -0.04297643f, -0.05834629f, -0.05416667f, -0.07169866f, 
    -0.10277192f, 0.01945831f, -0.02097068f, 0.16163190f, 0.05097710f, 0.15161496f, 0.01993156f, 0.07834674f, 
    -0.04281372f, 0.22942574f, 0.07731780f, 0.14136831f, 0.16950469f, -0.07574621f, -0.04373330f, -0.10344580f, 
    0.00553943f, 0.07645039f, 0.01453185f, 0.01888978f, -0.11830541f, 0.05933220f, -0.14458776f, 0.26433063f, 
    0.00087587f, -0.01666450f, 0.08214963f, -0.08672142f, -0.01784833f, -0.02525156f, 0.03142735f, 0.05575373f, 
    -0.03166487f, -0.02005160f, -0.12088633f, 0.00393105f, -0.05624399f, -0.00391340f, -0.03167696f, -0.12866440f, 
    -0.01590777f, -0.01893081f, 0.16642934f, -0.03765990f, 0.13255966f, -0.00745792f, -0.18869106f, 0.11682441f, 
    0.13459302f, 0.00519739f, -0.14696059f, 0.03130080f, 0.05964676f, -0.06553881f, 0.04709102f, 0.02113554f, 
    -0.09108738f, 0.34302858f, -0.20524189f, 0.02943346f, 0.12537800f, 0.08850919f, -0.05630274f, 0.17812979f, 
    -0.16379148f, 0.00430491f, 0.04819172f, 0.06774521f, 0.20548744f, 0.06295455f, -0.00577314f, -0.11171778f, 
    0.22789717f, 0.12085099f, 0.14358626f, 0.01565583f, 0.10849313f, 0.06645990f, 0.00371505f, -0.01901979f, 
    0.31924257f, 0.04850570f, -0.19479735f, 0.08697155f, -0.09979604f, -0.13115023f, -0.12577951f, 0.08518227f, 
    -0.04494987f, 0.00333372f, -0.03877053f, 0.11009494f, -0.07615913f, 0.11504386f, -0.15387926f, 0.26953015f, 
    -0.01452094f, -0.12866284f, -0.11116435f, -0.06309786f, -0.10938721f, -0.00056970f, -0.03860179f, 0.13498636f, 
    -0.17849979f, 0.01684356f, -0.04426879f, 0.14011788f, -0.07095105f, -0.10375778f, 0.03287069f, -0.00511913f, 
    0.09730231f, 0.04776570f, 0.04101198f, 0.07743000f, -0.18399146f, 0.03228921f, -0.31604499f, -0.01964947f, 
    -0.00040905f, -0.26635984f, 0.09133092f, -0.02861744f, 0.15032966f, 0.04924042f, -0.03456269f, -0.03199403f, 
    0.49427217f, -0.14311822f, 0.33442679f, -0.02480628f, 0.08540007f, 0.07516900f, -0.01901983f, -0.04644034f, 
    0.00837800f, -0.02942704f, 0.03297809f, -0.04466913f, 0.33536190f, -0.02636749f, -0.03772718f, -0.04174322f, 
    -0.10046929f, 0.00851266f, -0.12302350f, 0.01640020f, 0.06046093f, 0.08846824f, 0.04324277f, 0.00760064f, 
    -0.23876289f, 0.06112693f, 0.12695052f, -0.00949941f, -0.07990985f, 0.06198535f, 0.13285430f, 0.08976354f, 
    0.01107736f, 0.00552870f, 0.08729953f, 0.03139864f, -0.05263523f, -0.07704169f, 0.05827370f, 0.04264243f, 
    0.05443213f, -0.12685394f, -0.19110766f, 0.06677710f, 0.02923099f, 0.07625755f, -0.06961737f, 0.20249905f, 
    -0.12050238f, 0.05266387f, -0.29862016f, 0.14827517f, -0.14436559f, -0.06892898f, -0.17251374f, -0.02086108f, 
    0.16933836f, -0.03610276f, -0.02632825f, 0.01737212f, -0.10599224f, -0.04320469f, -0.02966761f, 0.20281793f, 
    0.22085705f, -0.12928353f, 0.10009933f, -0.01116583f, 0.05675259f, 0.04159787f, -0.02759114f, 0.03382938f, 
    0.14362063f, -0.09552461f, 0.06584925f, -0.14030507f, -0.12294469f, -0.04989738f, -0.12147044f, -0.04948283f, 
    -0.00552978f, -0.09202031f, -0.01983253f, 0.07511486f, -0.23284048f, -0.06855435f, 0.15776083f, -0.32193041f, 
    0.08082116f, 0.16529849f, -0.02192212f, 0.12906274f, 0.03994840f, 0.04085073f, 0.08861196f, 0.03261558f, 
    0.16655092f, -0.15876813f, -0.14993232f, -0.17194675f, 0.04392438f, 0.17810468f, -0.05746347f, 0.02800154f, 
    0.07713090f, 0.08480798f, 0.00451359f, 0.03043463f, -0.09077795f, 0.03889484f, 0.25103605f, -0.29867873f, 
    -0.03869629f, 0.04585848f, 0.06895842f, -0.19118731f, 0.09713084f, 0.00701242f, -0.01350970f, 0.06354443f, 
    -0.01479442f, -0.02922528f, -0.01951580f, 0.00116033f, -0.03054066f, -0.00072621f, 0.00365930f, 0.04118893f, 
    0.02231417f, 0.04196328f, -0.04820236f, 0.02521814f, 0.27097276f, -0.10852585f, -0.09102545f, -0.21012932f, 
    0.11730450f, -0.06096348f, 0.05899657f, -0.16574009f, -0.00919084f, -0.06163572f, -0.07319669f, 0.04803158f, 
    -0.08935215f, -0.27411669f, 0.11028688f, -0.19169495f, -0.03036666f, 0.05548727f, 0.17334941f, 0.08201636f, 
    -0.01888110f, 0.19948743f, 0.08412238f, -0.01310236f, -0.15900965f, 0.10700587f, -0.14775363f, -0.07874963f, 
    0.01222836f, 0.12440015f, -0.10706183f, 0.03312907f, 0.00963273f, 0.04894272f, 0.04330422f, -0.05536478f, 
    -0.03660247f, -0.10295001f, -0.08103556f, 0.06370823f, 0.09687372f, -0.00031784f, 0.00127839f, 0.12879343f, 
    0.01810763f, -0.09927832f, 0.04608279f, -0.11109578f, 0.11711355f, -0.09297512f, 0.18502440f, -0.07645336f, 
    -0.05480539f, 0.12492269f, 0.07339396f, 0.11993607f, -0.02243159f, -0.06014912f, -0.01021045f, 0.15724732f, 
    -0.40107319f, -0.02393364f, -0.24102366f, -0.09326508f, -0.03279738f, 0.10134579f, -0.01554536f, 0.09692188f, 
    0.05449592f, 0.03511694f, 0.11168783f, -0.06476263f, -0.28133926f, 0.15892771f, 0.17939506f, -0.10998310f, 
    0.19214709f, -0.04886157f, 0.00400005f, 0.09972192f, -0.01927923f, -0.03847127f, -0.10656185f, 0.05409665f, 
    0.31251514f, 0.12070331f, 0.06361324f, 0.14727812f, -0.01309458f, 0.08293591f, 0.01347626f, -0.00938287f, 
    -0.08411796f, 0.08514390f, -0.00991697f, -0.07490596f, 0.08402292f, -0.01311221f, 0.10764390f, -0.21067086f, 
    0.09328996f, 0.06355051f, 0.07951176f, 0.00496828f, 0.06240995f, -0.00424213f, 0.05788765f, 0.18571521f, 
    -0.07314605f, 0.01405832f, 0.04194712f, -0.02639601f, -0.05286741f, -0.07652912f, -0.14277218f, 0.00836942f, 
    0.02401770f, 0.08732443f, 0.01925753f, 0.08168675f, 0.22763237f, -0.36781830f, -0.05173333f, 0.02550897f, 
    0.09360349f, 0.10582593f, -0.12982710f, 0.21177101f, 0.09369051f, 0.07041797f, -0.10116430f, 0.01112124f, 
    0.06146375f, 0.12407926f, 0.13777693f, 0.11515742f, 0.14064533f, 0.00153935f, 0.11143854f, -0.02432127f, 
    0.05140124f, 0.03402231f, -0.04798538f, 0.04553523f, -0.23519610f, -0.12718630f, -0.13791065f, 0.13862328f, 
    -0.04810635f, -0.01035213f, 0.01578187f, 0.02933195f, 0.01201236f, 0.15552041f, 0.02174614f, -0.02586899f, 
    0.02114182f, -0.00960299f, -0.05656838f, 0.00814319f, 0.07171118f, 0.01987523f, -0.01312980f, -0.04465300f, 
    0.04653606f, -0.04278430f, -0.07229273f, 0.03268172f, 0.08226858f, -0.23952860f, -0.03903902f, 0.15541959f, 
    -0.02825767f, 0.06670073f, 0.04176072f, 0.03058771f, -0.01345614f, 0.07215579f, 0.02524781f, 0.04270599f, 
    -0.06820858f, -0.05614273f, 0.03434962f, -0.00909128f, -0.05484273f, 0.01595974f, -0.02203127f, 0.06046525f, 
    -0.05399906f, 0.05226912f, -0.06480385f, 0.03995412f, 0.02375584f, -0.07122903f, -0.06838988f, 0.02157536f, 
    -0.00481106f, 0.01006091f, 0.06723426f, -0.04375705f, -0.01276270f, 0.02320974f, 0.01767986f, 0.06357749f, 
    -0.06419017f, -0.04098762f, 0.00055124f, -0.03903415f, -0.07560667f, -0.07206433f, 0.04202570f, 0.02401271f, 
    0.02860873f, -0.00419092f, 0.00100645f, -0.04118484f, 0.00426072f, -0.01741528f, 0.05992385f, -0.03261179f, 
    -0.07271143f, 0.00527372f, 0.02120485f, 0.06632631f, 0.05071067f, -0.05874957f, -0.06447987f, 0.04190008f, 
    -0.05306878f, 0.04364519f, 0.04592253f, 0.02546989f, -0.03325991f, -0.04423646f, 0.06400261f, -0.01784602f, 
    -0.06611528f, -0.06910566f, 0.01533252f, -0.01582366f, -0.01551734f, -0.03491103f, -0.03933917f, -0.05082949f, 
    0.05382114f, 0.06284824f, 0.03533687f, -0.04002310f, 0.03452515f, 0.03947821f, -0.05072239f, -0.02522226f, 
    -0.02578507f, -0.03840465f, -0.01869374f, -0.06251006f, -0.07445419f, 0.05139866f, -0.00055155f, -0.04500694f, 
    0.04419034f, -0.00212815f, 0.02162759f, -0.04169357f, 0.04261842f, -0.01542190f, -0.00302362f, -0.01950202f, 
    -0.01709918f, -0.03000537f, -0.04461466f, -0.07343595f, 0.05731568f, -0.03050907f, -0.05628736f, 0.02604318f, 
    -0.00828313f, 0.00808566f, -0.00988368f, 0.04409434f, 0.00791007f, -0.01019788f, -0.02312035f, -0.02488638f, 
    0.05107500f, -0.01911440f, 0.00019949f, 0.03018045f, -0.01626730f, 0.04021066f, -0.03190110f, -0.00466174f, 
    0.06219079f, 0.00254751f, 0.04048654f, 0.06974638f, 0.01315126f, -0.02844422f, -0.00062449f, -0.02957257f, 
    -0.06699421f, 0.04028691f, -0.03296519f, -0.06551423f, -0.06007933f, 0.03005791f, 0.05925723f, -0.07245668f, 
    0.02381898f, 0.05454329f, -0.06494754f, -0.06598403f, -0.06591674f, -0.06383998f, 0.04317905f, -0.06019350f, 
    0.03582144f, -0.04698241f, -0.03041972f, 0.01373013f, -0.00080171f, -0.07330543f, 0.05442775f, -0.06543110f, 
    -0.03729549f, 0.03710363f, -0.00539697f, 0.04681451f, 0.02947229f, -0.05326052f, 0.06471659f, -0.01801793f, 
    -0.04821298f, 0.00983842f, -0.05699126f, -0.03749203f, 0.02664969f, -0.05975099f, 0.03154039f, 0.00010955f, 
    -0.01682555f, -0.07139235f, 0.00179176f, 0.00929307f, -0.07161414f, -0.02687569f, 0.03474395f, -0.00711217f, 
    -0.01475336f, 0.03044940f, -0.02858981f, -0.04427346f, 0.05683536f, -0.03263747f, 0.05913596f, -0.02546604f, 
    -0.05909296f, 0.00023347f, -0.02129765f, -0.02740123f, -0.02106684f, -0.03206450f, 0.00181798f, -0.04288045f, 
    -0.03027903f, 0.03700694f, -0.03303518f, 0.04064431f, 0.05963369f, -0.02679532f, -0.01910091f, -0.04390858f, 
    0.29250070f, 0.01400037f, -0.09236889f, 0.08847283f, 0.02575325f, 0.06387216f, -0.03599687f, 0.10769257f, 
    -0.08212311f, -0.07185377f, -0.03502369f, -0.01937987f, 0.20598933f, -0.04733440f, 0.03431614f, 0.29453969f, 
    0.04094882f, -0.05413397f, 0.00997028f, 0.17956595f, 0.00299770f, 0.02339510f, -0.08838878f, -0.01265456f, 
    -0.08265110f, 0.08101530f, 0.10731176f, -0.14079498f, 0.15170185f, 0.10264342f, 0.03433009f, 0.05526330f, 
    0.05213170f, 0.13699324f, 0.15250686f, -0.02574752f, -0.41591898f, 0.19025163f, -0.19735461f, -0.15513644f, 
    -0.15729591f, -0.00602429f, -0.10485321f, 0.03319933f, -0.15195985f, 0.02244410f, 0.06074339f, 0.03180892f, 
    0.17248435f, -0.18788703f, -0.13949296f, 0.09534518f, 0.17796908f, -0.02116386f, -0.01573408f, 0.03018109f, 
    0.15886632f, -0.04594582f, 0.02633647f, 0.11844458f, 0.18182778f, 0.04042148f, -0.00425292f, -0.04817940f, 
    0.02302154f, 0.08063702f, 0.02827909f, 0.13508609f, 0.04486457f, -0.00568848f, 0.00454725f, 0.11259829f, 
    -0.39236054f, -0.03571299f, -0.19573621f, -0.14659657f, -0.08372593f, 0.04242419f, 0.00894262f, 0.10890228f, 
    -0.09623125f, 0.11091678f, 0.12508231f, -0.02943504f, -0.00207496f, -0.03651416f, -0.12364048f, 0.04988170f, 
    0.07577605f, -0.02528383f, 0.08639923f, 0.06320515f, 0.20276472f, 0.04307150f, 0.03570449f, 0.03432434f, 
    -0.02765292f, 0.13011646f, 0.00387307f, 0.02694725f, -0.15210196f, 0.02215067f, 0.00617135f, -0.06757200f, 
    0.06646708f, 0.04897023f, -0.03946238f, 0.09670550f, 0.23899621f, -0.06717513f, -0.00975129f, -0.10006167f, 
    0.02667057f, 0.10690480f, -0.02918850f, -0.05142921f, -0.00633424f, -0.05317790f, 0.04232073f, 0.00825924f, 
    -0.18646932f, -0.06774718f, -0.08772632f, 0.13869083f, 0.17065024f, -0.10062095f, -0.04699099f, -0.03392943f, 
    0.09042751f, 0.05367925f, -0.15291017f, 0.05745908f, 0.36596289f, -0.22768712f, 0.02272893f, -0.06712707f, 
    0.19716138f, 0.07858621f, -0.07648777f, 0.12036785f, -0.09758961f, 0.08211046f, -0.17529303f, 0.03265706f, 
    0.16820386f, -0.01545813f, 0.15744141f, 0.07706099f, 0.07190589f, -0.02502269f, 0.06974812f, -0.08979546f, 
    0.24448153f, 0.06380561f, -0.03139302f, 0.04676258f, -0.14288725f, -0.23002306f, -0.27648845f, -0.20084111f, 
    -0.01486210f, 0.06844882f, 0.01526586f, -0.07076421f, 0.05005589f, 0.09901346f, 0.13101931f, -0.07613463f, 
    0.09823131f, -0.10655787f, 0.17499137f, -0.06714107f, -0.01066149f, -0.00678567f, 0.07649229f, -0.02727570f, 
    -0.02277940f, -0.07075221f, -0.04895312f, 0.10394666f, 0.17784226f, -0.10398313f, 0.15083703f, -0.05838681f, 
    0.07408500f, 0.17715539f, 0.15736268f, 0.10520419f, 0.02262134f, 0.22346672f, 0.09281144f, -0.06938458f, 
    -0.34110552f, -0.05896408f, -0.18642266f, -0.03168128f, 0.03773498f, -0.00510972f, 0.20558545f, 0.01491712f, 
    -0.03917644f, -0.14439051f, 0.05594122f, 0.09397416f, -0.26070338f, -0.05979912f, -0.23038563f, -0.17092839f, 
    0.00681496f, 0.07525054f, -0.06016178f, -0.00135119f, -0.00523120f, 0.05162220f, 0.15713744f, 0.07372888f, 
    0.06057864f, 0.20324247f, 0.14210062f, -0.00697487f, -0.07416931f, 0.00946153f, 0.07054951f, 0.14395262f, 
    -0.01405970f, -0.13410507f, -0.02839787f, -0.01314322f, 0.05043229f, 0.00032882f, 0.14431512f, -0.08464209f, 
    0.20258994f, 0.07202341f, 0.15219656f, -0.04640634f, 0.01613187f, 0.03303238f, -0.11922292f, -0.01615961f, 
    -0.06020718f, 0.06292947f, 0.16791324f, 0.06297104f, -0.20881155f, 0.17264165f, 0.13964388f, 0.04167023f, 
    0.02532885f, 0.04846739f, -0.09885802f, 0.11849743f, -0.08444431f, -0.03877144f, 0.13209529f, -0.03246659f, 
    0.02046584f, -0.03121941f, -0.05234122f, 0.00605690f, -0.03708561f, 0.04804138f, 0.09278401f, 0.05838889f, 
    0.02225025f, -0.07665062f, 0.01306229f, 0.06263188f, -0.01034171f, -0.06327276f, 0.11561253f, -0.17022529f, 
    0.00921694f, -0.03408308f, -0.13418840f, 0.03437491f, 0.12462083f, -0.20496194f, 0.23400337f, -0.09161188f, 
    -0.16790804f, 0.19763236f, 0.10774057f, -0.05675540f, -0.05934504f, 0.06715856f, 0.07313810f, 0.02468114f, 
    0.12468845f, 0.02554427f, 0.05080426f, -0.05001014f, 0.20699729f, 0.07144906f, -0.05958480f, 0.03741471f, 
    -0.07343546f, 0.01858653f, 0.16308267f, 0.14386593f, -0.10377793f, 0.31616470f, 0.07823639f, 0.01677940f, 
    -0.00345698f, 0.05257961f, 0.00855890f, 0.04639227f, 0.01649735f, 0.06946971f, 0.02267779f, -0.15442422f, 
    0.26333627f, 0.11586950f, 0.18129812f, -0.10771202f, -0.09926841f, 0.02585298f, -0.00621078f, 0.00909144f, 
    0.04271046f, -0.01237577f, -0.02571218f, 0.02286215f, -0.02788718f, 0.14496858f, -0.04138816f, -0.17716867f, 
    -0.01274342f, -0.11386608f, 0.23376706f, 0.10953601f, 0.04641502f, 0.04502808f, 0.07713718f, -0.04759575f, 
    -0.33212391f, 0.07248281f, 0.14913134f, 0.13263288f, -0.03428699f, -0.00831551f, -0.04972606f, 0.15081359f, 
    -0.08091003f, -0.05851278f, 0.04635150f, 0.05771306f, -0.10496363f, -0.03893022f, 0.12799561f, 0.10688285f, 
    0.06054908f, 0.06159271f, 0.12221216f, 0.12589027f, -0.00475583f, -0.04591413f, -0.09843521f, -0.01591311f, 
    -0.17817536f, 0.03044644f, 0.05073714f, 0.01748275f, -0.06397229f, -0.04793858f, -0.09021226f, 0.08927937f, 
    0.05158087f, -0.01618371f, 0.12347265f, 0.00039648f, 0.01322891f, -0.15832959f, 0.06184478f, 0.25828490f, 
    -0.03529891f, 0.01626578f, -0.00946944f, 0.01225034f, 0.01586026f, -0.11293817f, -0.05926035f, -0.00493931f, 
    -0.06210460f, 0.00333491f, 0.01621390f, -0.01501171f, -0.01006440f, 0.03159730f, 0.03095311f, -0.07345761f, 
    -0.01830285f, -0.08017881f, 0.05938733f, 0.02310302f, -0.00356647f, -0.01042815f, 0.05472388f, -0.05776661f, 
    -0.07312715f, 0.01687198f, 0.05929193f, 0.01824779f, 0.00598770f, -0.03200417f, -0.07495120f, 0.00824583f, 
    -0.04574985f, -0.02436591f, 0.02759208f, -0.03030256f, -0.00811811f, 0.03475505f, -0.07696401f, -0.06936222f, 
    -0.01061549f, -0.00669282f, -0.00303353f, -0.06332095f, -0.05238893f, -0.06493977f, -0.03028748f, -0.06411912f, 
    -0.06261826f, -0.07504135f, 0.02310921f, -0.00320899f, -0.02646058f, 0.04309509f, -0.05008734f, -0.07819387f, 
    -0.01288541f, -0.02915826f, 0.04327382f, 0.05812530f, 0.04869938f, -0.04100690f, 0.05695790f, 0.01122086f, 
    -0.05310419f, -0.02663987f, -0.01437068f, 0.02705842f, 0.00808953f, 0.02102361f, 0.02823384f, 0.05742714f, 
    0.03559421f, -0.01488656f, -0.03238173f, -0.04541481f, -0.05071823f, -0.06760506f, 0.00559268f, -0.00002669f, 
    -0.02617487f, 0.05672466f, 0.06089614f, -0.01676643f, -0.01669737f, -0.05494973f, -0.04705080f, 0.00935872f, 
    -0.05116533f, -0.00004410f, -0.00155724f, -0.00479631f, 0.00549843f, -0.02922004f, -0.02453481f, 0.01522679f, 
    -0.06659750f, -0.05574316f, -0.05309282f, -0.00818044f, -0.00784993f, -0.05844855f, -0.07082395f, -0.06441640f, 
    -0.04504678f, 0.05325149f, -0.07824791f, 0.00643608f, -0.03722624f, 0.06220572f, 0.03944522f, -0.05301965f, 
    -0.06008893f, 0.00269759f, -0.00508940f, -0.04076898f, -0.07175115f, 0.02508690f, 0.04055482f, 0.00712485f, 
    -0.00787876f, -0.03061306f, 0.01109761f, -0.06086318f, -0.04681759f, 0.05070530f, -0.01734135f, -0.01596381f, 
    0.01226168f, -0.04047861f, 0.03418584f, 0.06229633f, 0.05094478f, -0.01442791f, -0.00824121f, -0.02516237f, 
    -0.02803444f, -0.06715661f, 0.04974463f, 0.04811229f, 0.05892939f, -0.04758908f, 0.04144412f, -0.04715362f, 
    -0.02389222f, -0.00217598f, 0.04771881f, -0.06357697f, 0.00930923f, 0.00293305f, -0.04748185f, -0.01667120f, 
    0.00935165f, -0.04982525f, 0.02063797f, -0.02529724f, -0.03959087f, -0.05394636f, 0.03871350f, -0.03897951f, 
    -0.06997756f, -0.08044086f, -0.02026260f, -0.02878565f, 0.00255937f, 0.00488656f, -0.03253991f, 0.04909521f, 
    0.00437461f, -0.00551065f, 0.01117959f, 0.02944512f, -0.01886204f, -0.03293884f, -0.02724679f, 0.01604149f, 
    0.00797861f, 0.06129192f, 0.00356661f, -0.03042570f, -0.05228609f, 0.03950820f, -0.03365764f, 0.06162059f, 
    -0.02142361f, 0.00413661f, -0.02870801f, 0.04532630f, 0.05111658f, 0.02398580f, -0.03154082f, 0.04020626f, 
    -0.06515568f, 0.03589200f, -0.02497687f, 0.01469668f, -0.05352398f, -0.03212764f, 0.03422537f, -0.02624756f, 
    0.26958016f, 0.08216742f, 0.32586211f, 0.04597944f, 0.02054690f, -0.05558664f, 0.07966620f, -0.01670356f, 
    -0.05661252f, 0.11287052f, -0.00749883f, 0.08364465f, 0.15161882f, 0.26644582f, 0.22634430f, -0.03408555f, 
    -0.09292118f, 0.02872156f, -0.01021044f, -0.02796269f, 0.03319809f, 0.02870329f, -0.00853679f, 0.09362340f, 
    -0.12219433f, -0.15690148f, 0.01902528f, 0.16828063f, -0.05696614f, -0.06603531f, 0.08036703f, -0.06359379f, 
    0.02001180f, -0.05718237f, 0.06107683f, 0.03713213f, -0.21979411f, -0.16413638f, 0.11643069f, 0.08601815f, 
    -0.05270961f, -0.05001650f, 0.05982275f, -0.06913720f, -0.08122493f, 0.03330429f, 0.10195312f, 0.12402868f, 
    0.21042837f, 0.05287421f, -0.02728589f, 0.33367100f, 0.02469572f, 0.00601517f, -0.12291559f, -0.07531096f, 
    -0.12640683f, -0.07398546f, 0.04754777f, -0.01291514f, 0.23945992f, -0.05668565f, -0.13234843f, 0.21859670f, 
    -0.13131736f, -0.05143518f, 0.08783867f, -0.08288684f, -0.14096878f, 0.04582856f, -0.07357964f, -0.05755623f, 
    -0.11253038f, 0.19809741f, 0.00679972f, 0.10520324f, -0.13893610f, -0.04632109f, 0.02117625f, 0.10302876f, 
    0.03809150f, 0.05695500f, -0.00016476f, -0.00232020f, -0.20120826f, 0.16650897f, -0.11395047f, 0.10725819f, 
    -0.00737192f, 0.05831717f, -0.07668679f, 0.00084583f, 0.18089907f, 0.06488413f, 0.01782367f, -0.00323121f, 
    -0.17306525f, -0.16266753f, -0.12596573f, 0.04584861f, -0.11199965f, 0.03115832f, 0.02067719f, -0.01965203f, 
    0.10150392f, -0.12446261f, -0.04462196f, -0.12637106f, 0.16917259f, -0.25227487f, -0.17092197f, 0.05378568f, 
    -0.03233962f, -0.06298564f, 0.05996174f, 0.01659322f, -0.09495776f, -0.20076828f, -0.07608977f, -0.01268859f, 
    0.21452704f, -0.12359486f, 0.07579587f, 0.06523686f, 0.21752450f, 0.09098652f, 0.04062672f, 0.02659815f, 
    0.04169723f, 0.11751968f, 0.00579700f, -0.04475347f, 0.29559872f, 0.06994451f, 0.15567552f, 0.17129116f, 
    -0.22395870f, 0.10650449f, -0.14309292f, -0.14825438f, 0.00899403f, 0.02702184f, -0.06771259f, -0.09007329f, 
    0.30133694f, -0.09684050f, -0.20356815f, -0.02183574f, -0.01817489f, -0.03503214f, 0.00375986f, -0.01185091f, 
    0.00331680f, 0.05147255f, 0.07659098f, 0.06475574f, 0.35851485f, 0.25034979f, -0.11321855f, -0.21036297f, 
    -0.02110803f, -0.00182450f, -0.10175730f, -0.11549762f, -0.02859634f, 0.10842946f, -0.08762781f, 0.01929994f, 
    0.06686659f, 0.09480392f, 0.00666186f, 0.24327530f, -0.05988142f, -0.01977505f, -0.01863854f, 0.02646106f, 
    -0.01125122f, 0.09427889f, -0.12160054f, 0.11536930f, 0.17860501f, 0.05361537f, -0.11179484f, -0.15678076f, 
    0.04595792f, -0.00456641f, -0.06133429f, 0.17465256f, 0.06928588f, 0.09313857f, -0.02294189f, -0.04632609f, 
    -0.07474628f, -0.02434666f, 0.13392471f, 0.08430685f, 0.06793120f, -0.08578016f, 0.11351286f, 0.02824520f, 
    -0.00097367f, 0.00769192f, 0.09183668f, 0.04464235f, 0.12631598f, 0.10818225f, 0.09629292f, 0.04531597f, 
    0.03211153f, 0.08036646f, 0.08120713f, 0.01908039f, -0.05823502f, 0.05356620f, 0.09179142f, -0.00123845f, 
    0.17306294f, -0.01240037f, -0.20066197f, -0.15509118f, 0.00887030f, -0.14387798f, -0.04720162f, -0.02620499f, 
    -0.02084489f, -0.00243070f, 0.03194521f, -0.07271280f, 0.29448768f, 0.11862545f, 0.21419913f, -0.05889528f, 
    0.02266481f, 0.03252425f, 0.12098728f, -0.05214885f, -0.04011812f, -0.05877465f, 0.03773240f, -0.01119289f, 
    -0.24727061f, 0.18261342f, 0.15166274f, -0.02955306f, 0.04325388f, 0.06616562f, 0.07439993f, 0.02480298f, 
    -0.10925084f, 0.09490802f, 0.16828512f, 0.11230380f, -0.20880447f, -0.10900673f, -0.13690320f, 0.01913144f, 
    0.09612311f, -0.06964623f, -0.04923323f, -0.12989047f, -0.11880881f, 0.10755255f, 0.02024741f, -0.12931250f, 
    0.11179452f, -0.04902885f, 0.09809047f, 0.09198551f, 0.05991177f, 0.11645433f, 0.10096024f, 0.00576885f, 
    -0.13595653f, 0.00730431f, -0.08019181f, 0.05646916f, 0.07641532f, 0.17322147f, -0.00795992f, 0.14709686f, 
    -0.03324658f, 0.12363922f, 0.07769650f, -0.00446513f, 0.10558490f, 0.11766555f, 0.13529220f, 0.12311994f, 
    0.12722962f, 0.00837470f, 0.06418943f, 0.20294367f, 0.09731948f, -0.00515260f, -0.04118367f, 0.08211239f, 
    0.03896952f, -0.15942976f, 0.04857744f, 0.23404394f, -0.16029006f, 0.06084018f, -0.03924754f, -0.19387089f, 
    0.04512500f, -0.13401130f, -0.02968456f, 0.04590193f, -0.08998633f, 0.10707471f, -0.15891872f, -0.08795948f, 
    0.01204369f, 0.00880382f, 0.00835299f, -0.13275419f, 0.04837260f, 0.06812076f, 0.18858711f, -0.01974216f, 
    -0.04547721f, -0.09509994f, -0.04943799f, -0.06266346f, -0.09368359f, 0.28665805f, 0.03830294f, -0.09142426f, 
    -0.07659809f, -0.07022396f, 0.06963662f, -0.15379633f, 0.02794765f, 0.01272338f, -0.07231767f, -0.01033992f, 
    0.16667140f, 0.11638058f, 0.06524394f, 0.01230848f, -0.12160445f, 0.01708739f, -0.03198336f, 0.02649424f, 
    -0.01463880f, 0.00320297f, 0.07897596f, 0.05763323f, 0.29820833f, -0.08948694f, 0.09923160f, 0.18352807f, 
    0.05699181f, -0.02429304f, -0.05212315f, 0.02830491f, -0.06433633f, 0.09191766f, 0.02346189f, -0.09763023f, 
    -0.28902823f, 0.01214089f, -0.00784309f, 0.08864444f, 0.01906462f, 0.02724268f, 0.16578516f, 0.04282745f, 
    0.12317159f, 0.06130217f, 0.00729716f, -0.05366105f, 0.14837708f, 0.08342332f, -0.01388876f, 0.18671666f, 
    0.07153413f, -0.03916728f, -0.10998512f, 0.08804329f, 0.03135743f, -0.08563974f, -0.15806739f, -0.03275935f, 
    0.21507572f, -0.15728623f, 0.01719619f, -0.04560046f, 0.06436701f, 0.16140425f, -0.12469622f, 0.11138095f, 
    0.06969182f, -0.06919432f, 0.01850921f, -0.01312932f, 0.05692018f, 0.22123596f, 0.15663594f, 0.34445107f, 
    0.04701921f, 0.04966494f, 0.13900220f, 0.08698852f, -0.01557201f, -0.04353554f, 0.00097686f, -0.05639075f, 
    0.02517707f, 0.33844450f, -0.06087537f, -0.18146715f, -0.04499944f, -0.10499772f, -0.09855616f, 0.00363460f, 
    0.01188812f, -0.04488279f, -0.03715292f, 0.09487491f, 0.06986877f, 0.11172994f, -0.08195656f, -0.05533038f, 
    -0.01890263f, -0.01740947f, -0.01913788f, -0.01963880f, 0.01065012f, 0.11476096f, 0.02843168f, 0.05975669f, 
    -0.19420452f, 0.05014964f, -0.02336881f, 0.02584348f, 0.00618900f, -0.00454145f, -0.02864134f, 0.03297432f, 
    -0.03840628f, -0.03281251f, -0.06517167f, 0.08011634f, -0.11779124f, 0.11277001f, -0.21242170f, 0.01188999f, 
    -0.05986590f, -0.09705216f, 0.04693490f, -0.06781020f, 0.02409755f, -0.02794033f, 0.02835890f, -0.02726431f, 
    0.09250413f, -0.03012885f, 0.10106473f, 0.07287887f, 0.13122116f, -0.00370489f, 0.03462022f, -0.11030833f, 
    0.07943593f, 0.01062449f, -0.03679305f, 0.09090164f, 0.18364488f, -0.11895258f, -0.08624567f, -0.04905183f, 
    -0.10618658f, 0.08829429f, 0.00388440f, 0.00810440f, -0.04896704f, -0.12078816f, -0.10233675f, -0.06853670f, 
    -0.03675280f, 0.18968084f, -0.09538696f, 0.00090139f, 0.07826570f, 0.02785950f, 0.05636599f, -0.06343783f, 
    0.03137979f, -0.05280985f, 0.02496409f, 0.05543343f, -0.30406767f, 0.03478145f, 0.17488629f, -0.12452741f, 
    -0.06659266f, 0.02548784f, -0.10357694f, 0.01921605f, 0.03201343f, -0.02849058f, 0.07410124f, 0.10087561f, 
    -0.26727402f, 0.03889849f, -0.02556048f, 0.02243255f, -0.18206412f, -0.01286265f, 0.01359545f, -0.00632982f, 
    0.08221256f, 0.05477793f, -0.02520354f, 0.00200802f, -0.26778409f, 0.23738721f, -0.04001166f, 0.09691844f, 
    0.04648057f, -0.11520343f, 0.11399196f, 0.01756744f, -0.03594488f, -0.04105078f, -0.00446126f, -0.06848152f, 
    -0.35272825f, -0.23074786f, 0.15076172f, -0.08563454f, -0.04045083f, -0.05947233f, -0.02688992f, 0.03789598f, 
    -0.03459946f, -0.00858332f, -0.02925134f, 0.06601669f, 0.09273918f, -0.07165878f, 0.00932468f, 0.25107959f, 
    0.17905185f, -0.01832481f, 0.15591457f, -0.01053056f, -0.04563911f, -0.02698399f, -0.06634690f, -0.07415765f, 
    -0.22403176f, -0.12445089f, 0.05672263f, -0.04917833f, -0.03210477f, 0.06964038f, 0.06716253f, 0.02670145f, 
    0.14359286f, -0.09083985f, -0.07781374f, 0.04617847f, -0.02453985f, 0.06424930f, 0.08291786f, 0.15942465f, 
    -0.03885429f, 0.08443707f, 0.06623757f, -0.02469935f, 0.02791676f, 0.09151114f, 0.11452422f, -0.07013132f, 
    -0.14379257f, -0.14258346f, 0.12084366f, 0.13193902f, -0.03453856f, -0.07569637f, 0.05661372f, -0.05150673f, 
    -0.03239184f, 0.01959396f, 0.03307627f, -0.06626192f, -0.06028144f, 0.08311119f, 0.02804930f, 0.14161424f, 
    -0.07218740f, 0.05525208f, 0.08611186f, 0.05595772f, -0.12108613f, 0.06732695f, 0.16930605f, -0.01180977f, 
    0.00426384f, -0.13893001f, -0.00326389f, -0.21189693f, 0.16550729f, -0.01375086f, -0.08985550f, -0.13568597f, 
    0.04423529f, -0.05517317f, 0.04638878f, -0.04642117f, 0.03139265f, -0.09708677f, 0.22859143f, -0.24768899f, 
    0.01312786f, -0.02727025f, -0.02406871f, 0.05091543f, -0.01239688f, -0.08188225f, -0.08156594f, 0.00330928f, 
    -0.02806473f, 0.02189880f, 0.01146526f, -0.15946710f, 0.17757225f, -0.04945381f, 0.03149065f, -0.03815670f, 
    0.00354769f, 0.06841820f, 0.09675736f, 0.14199263f, -0.08360780f, -0.16355394f, 0.01327177f, -0.09724645f, 
    0.11455414f, -0.01440317f, -0.03492095f, 0.11443181f, -0.07938009f, -0.03145542f, -0.06814638f, 0.04049304f, 
    0.09141786f, 0.10918042f, -0.04555013f, 0.25049293f, -0.04600237f, 0.17537186f, 0.10136627f, 0.18102691f, 
    -0.13181190f, 0.04052688f, -0.00956837f, -0.02171424f, -0.16603450f, 0.16458885f, -0.28850624f, 0.24184336f, 
    0.10435402f, 0.02749773f, 0.02777133f, -0.08338712f, 0.12053109f, 0.08315802f, 0.11778209f, -0.00159947f, 
    0.17332935f, -0.00238433f, 0.03441663f, 0.00409441f, 0.00893560f, 0.03012706f, -0.01673511f, -0.04257058f, 
    0.24139830f, -0.17234212f, -0.03331722f, 0.20274159f, 0.08569201f, 0.08640816f, -0.05219612f, -0.06692143f, 
    0.19026315f, 0.00286311f, 0.02658975f, 0.00849744f, 0.03698757f, 0.05667546f, 0.00890216f, 0.03226540f, 
    -0.07223693f, 0.13493574f, 0.11015589f, -0.10843915f, 0.31402355f, 0.04876824f, 0.10989749f, -0.09045314f, 
    0.04341846f, -0.06826384f, -0.00765989f, -0.03418279f, -0.05131838f, 0.19431564f, 0.14379492f, 0.02102910f, 
    -0.00791807f, -0.02498620f, 0.09752718f, -0.06737351f, 0.03131519f, -0.03808704f, -0.02618988f, 0.02155677f, 
    0.18991958f, 0.06782804f, -0.05397595f, 0.04746287f, 0.06385282f, -0.02806610f, -0.12233737f, -0.00710287f, 
    0.13852149f, 0.09008615f, 0.17262553f, 0.07698988f, 0.36052963f, -0.13349120f, -0.05418674f, 0.24963823f, 
    0.01085148f, -0.17980082f, -0.04272050f, -0.19083382f, -0.02413933f, -0.04149361f, 0.13638657f, -0.05952459f, 
    -0.34303251f, 0.00589501f, -0.10155844f, 0.06154411f, 0.08513961f, 0.10845197f, 0.20678250f, -0.03786315f, 
    0.10290332f, -0.01752721f, 0.07810847f, -0.01338386f, 0.07870669f, 0.06248352f, -0.22646219f, 0.24454986f, 
    0.03331053f, -0.00509948f, -0.12116718f, -0.06960123f, 0.14385697f, -0.05721417f, -0.02519072f, -0.01921735f, 
    -0.13080005f, 0.07258879f, 0.07109958f, 0.06375957f, 0.12681188f, -0.02623197f, 0.09233060f, -0.01805281f, 
    -0.04295973f, -0.01829159f, 0.07089944f, -0.01203886f, -0.08691230f, -0.16963655f, -0.15704691f, -0.22632466f, 
    0.06048821f, 0.06816591f, 0.02624072f, -0.01501564f, -0.06641103f, 0.06677222f, 0.06357296f, 0.12513910f, 
    0.29150075f, -0.07444046f, 0.12810144f, -0.11438906f, 0.06136197f, 0.03199675f, 0.09884304f, -0.03953394f, 
    -0.01507649f, 0.00349629f, 0.06805060f, 0.00121907f, -0.40744483f, -0.03163152f, 0.05255606f, 0.03973011f, 
    0.03300694f, -0.10006329f, -0.04015541f, 0.09563757f, -0.04958208f, -0.00118443f, 0.05445822f, 0.21372910f, 
    -0.02372727f, -0.07437688f, -0.02657234f, 0.34753314f, 0.06235229f, -0.03382828f, -0.03680487f, 0.01160871f, 
    0.11532803f, 0.03875872f, 0.15766689f, 0.10798899f, 0.35032880f, -0.13033022f, 0.05083052f, 0.15216012f, 
    -0.02738172f, 0.01488523f, -0.04143438f, 0.08777232f, 0.00789195f, 0.08013495f, 0.03567351f, 0.09313381f, 
    -0.10952588f, -0.17086875f, -0.03601539f, -0.05237575f, -0.14793760f, -0.03935008f, 0.00213514f, -0.01793884f, 
    -0.02024517f, 0.00241224f, 0.00384970f, -0.07714140f, -0.22878474f, 0.03504337f, 0.01479536f, 0.06775581f, 
    0.01818335f, 0.03382716f, -0.05485740f, 0.00400404f, 0.13922651f, 0.14357229f, 0.02981610f, -0.00204472f, 
    0.01741686f, -0.00501628f, -0.04584312f, -0.14320730f, 0.00707053f, 0.10059242f, -0.00341684f, 0.01681231f, 
    0.13548507f, -0.01915117f, 0.12779005f, 0.07338239f, 0.36668059f, 0.04308555f, -0.02950798f, 0.02877760f, 
    0.02656394f, -0.04359310f, -0.08945552f, 0.06875809f, 0.06737742f, -0.03578121f, 0.12221777f, 0.10666511f, 
    -0.14225480f, -0.03374422f, -0.14175795f, 0.07221118f, 0.08385217f, -0.05739455f, -0.13581136f, -0.08668264f, 
    0.13627765f, 0.02287179f, 0.05377198f, 0.09166032f, 0.22242817f, 0.05539202f, 0.10363667f, 0.07251973f, 
    -0.00799643f, -0.02468040f, -0.04022341f, 0.07503087f, 0.03360713f, 0.08713839f, -0.05942721f, 0.07514729f, 
    0.24920426f, 0.04533794f, 0.13699734f, 0.05198141f, 0.14681025f, -0.09745012f, -0.04382650f, 0.03173646f, 
    0.18809651f, 0.01139254f, 0.08671828f, 0.17211989f, -0.03391311f, 0.00889075f, -0.14975688f, -0.19912891f, 
    -0.18416524f, 0.13185360f, 0.08805604f, -0.11217850f, 0.00794437f, 0.02668311f, 0.14187527f, -0.00612096f, 
    -0.04380602f, 0.09735014f, -0.02278566f, 0.17016341f, 0.12204212f, 0.06150208f, -0.08707276f, -0.09464617f, 
    0.06708961f, 0.05670775f, 0.06752542f, 0.03903388f, 0.24699858f, -0.15630156f, -0.03422028f, -0.11595625f, 
    0.01908612f, 0.16797313f, -0.05925590f, 0.02242096f, 0.14735764f, 0.05172276f, -0.02017606f, -0.05140237f, 
    0.05951237f, 0.19148763f, 0.02441685f, -0.03138908f, 0.00069171f, 0.10532763f, -0.08202429f, 0.04024921f, 
    0.07373314f, 0.04569945f, 0.01686491f, 0.00021461f, -0.02214720f, -0.00102644f, 0.05692225f, -0.01013044f, 
    0.04355788f, -0.04069249f, -0.05306614f, 0.03299621f, 0.05210411f, -0.01312441f, -0.09361099f, 0.04122156f, 
    0.09430907f, -0.02063148f, 0.07464740f, 0.10610101f, -0.02243081f, 0.05002604f, 0.02308454f, 0.02929223f, 
    -0.03155117f, 0.04550934f, -0.05256397f, 0.04310734f, -0.04306758f, -0.05820258f, -0.20860900f, -0.02375942f, 
    -0.09943540f, 0.06066868f, -0.06900630f, 0.01111345f, 0.10273790f, 0.04345148f, 0.00175794f, 0.05281491f, 
    0.28885764f, 0.06549835f, -0.03969665f, -0.02603452f, 0.05079586f, -0.02010468f, -0.03539492f, -0.00313522f, 
    0.11870177f, 0.04580760f, 0.12737715f, 0.00523609f, 0.09385000f, 0.04300199f, 0.20164697f, 0.06708859f, 
    -0.02806195f, -0.03601109f, -0.01833658f, -0.00094949f, 0.14188914f, -0.04530391f, -0.09873355f, -0.02892447f, 
    0.10331911f, -0.12728411f, 0.02705643f, 0.03682331f, -0.01184021f, 0.07196477f, 0.00846703f, 0.00623274f, 
    0.08167914f, -0.06020769f, 0.11922877f, -0.07876357f, -0.07391075f, 0.21840630f, -0.00574362f, -0.05131485f, 
    0.18519634f, -0.10071085f, 0.01854061f, 0.00027628f, 0.06721117f, 0.05938973f, 0.06279718f, -0.03892491f, 
    -0.17586116f, -0.16393870f, -0.02215896f, 0.04483175f, -0.15356982f, -0.02343666f, -0.02776168f, 0.01531682f, 
    0.04307172f, 0.11782779f, 0.05678520f, -0.04710924f, 0.42060354f, -0.10726871f, 0.01176378f, 0.11808918f, 
    0.08289241f, 0.08120462f, -0.05036972f, -0.08340831f, -0.00195160f, -0.06385791f, 0.06680351f, 0.03669744f, 
    0.10763256f, 0.07492787f, -0.09221125f, 0.15061426f, 0.12325127f, 0.03478838f, 0.00043064f, 0.06581393f, 
    0.03845922f, 0.02929308f, -0.02569545f, 0.08410336f, 0.15602891f, -0.15387739f, 0.11713152f, 0.03758628f, 
    -0.01950081f, 0.15252289f, -0.16225313f, 0.11172596f, -0.07929144f, 0.04366472f, 0.03292651f, 0.01306689f, 
    0.44664469f, 0.09091131f, -0.06157512f, 0.02317101f, 0.07071293f, 0.04022469f, 0.07016095f, -0.03079667f, 
    0.05553584f, 0.03636943f, -0.01381500f, -0.05727528f, -0.08740182f, 0.14178281f, -0.11083896f, -0.04925711f, 
    -0.03567474f, -0.07307643f, -0.16001268f, -0.14489476f, 0.00565056f, 0.06798889f, 0.16534930f, 0.01596221f, 
    0.51691622f, 0.20449698f, 0.06809524f, -0.05496622f, -0.01041967f, 0.03694390f, 0.00646181f, 0.00337116f, 
    -0.06500857f, 0.00076463f, 0.05593397f, 0.08991591f, -0.10787915f, 0.08066078f, -0.06259815f, -0.28102353f, 
    0.03716141f, -0.10799748f, -0.02900633f, -0.03988595f, -0.01355674f, -0.01505888f, 0.09718278f, 0.01175784f, 
    -0.25391579f, -0.12115615f, 0.09832479f, -0.14733827f, -0.11385199f, 0.04446749f, 0.13203293f, -0.02099827f, 
    0.03062900f, 0.04521620f, -0.03598599f, 0.00853541f, -0.20880556f, 0.15770945f, -0.04927318f, 0.27234557f, 
    0.08115581f, -0.04799132f, -0.00102879f, -0.20882562f, -0.07268815f, 0.02069146f, -0.11096149f, 0.05163662f, 
    -0.17061874f, 0.15863493f, 0.22094229f, 0.26618150f, 0.00588759f, 0.05846674f, 0.05068161f, -0.09148599f, 
    0.09333844f, -0.13712071f, -0.01431599f, -0.04299915f, -0.18824840f, -0.19216552f, 0.08076917f, -0.04989536f, 
    0.05915685f, -0.06695505f, -0.01311617f, 0.18129544f, 0.05483305f, 0.14246254f, -0.03334831f, 0.10926662f, 
    0.15497431f, -0.15702645f, 0.00454855f, -0.15596800f, -0.04281889f, -0.19858097f, -0.05984026f, -0.07257093f, 
    0.05208741f, -0.07007003f, -0.22368717f, -0.13307597f, 0.10617765f, 0.04525476f, 0.14142290f, -0.00217791f, 
    0.11460220f, 0.05655428f, -0.06492393f, 0.05911952f, 0.02482664f, 0.01101113f, -0.00244895f, 0.06483731f, 
    -0.27371666f, 0.18666367f, 0.10799443f, 0.11001715f, -0.08378744f, 0.00141268f, -0.08982169f, -0.08056360f, 
    0.08427583f, -0.05816133f, 0.02829564f, -0.02229719f, 0.06703518f, 0.06767368f, 0.04266155f, 0.06880008f, 
    0.08148304f, -0.08301529f, -0.09761044f, -0.10931482f, -0.03566423f, 0.16129716f, -0.13418858f, -0.03298554f, 
    0.04380053f, 0.06051721f, 0.15955962f, 0.10756098f, 0.14933912f, 0.07200453f, -0.10510933f, 0.10163590f, 
    0.00752431f, 0.10331947f, 0.04279414f, -0.12252187f, -0.04302304f, -0.06235611f, -0.03077820f, 0.13266648f, 
    -0.01288243f, 0.12394799f, -0.00595456f, 0.01104784f, 0.06797991f, 0.05940207f, 0.02832956f, 0.22469221f, 
    -0.18100689f, -0.09733580f, 0.21826412f, -0.01404842f, -0.02541916f, -0.00346967f, 0.06094277f, -0.00229619f, 
    0.07074199f, 0.01991099f, 0.10484069f, 0.09449518f, -0.17866281f, 0.14386156f, 0.04969103f, 0.13938639f, 
    0.09047813f, 0.02615675f, -0.00965245f, -0.05826112f, 0.04387058f, -0.08013822f, 0.06240132f, 0.12778790f, 
    -0.07707498f, -0.23371379f, 0.05164089f, 0.13116421f, 0.16576052f, 0.07780253f, -0.01955898f, 0.03408312f, 
    -0.07587314f, -0.12870844f, -0.14767981f, -0.00410165f, -0.01744058f, 0.12339903f, 0.10279672f, 0.23410991f, 
    0.11642133f, -0.01144614f, 0.02563868f, -0.03255260f, 0.11547093f, -0.10673293f, 0.02400718f, 0.09088041f, 
    0.32958922f, -0.05218407f, -0.10687743f, -0.00718868f, 0.06484278f, 0.18706830f, -0.22611608f, -0.12017352f, 
    -0.07885762f, -0.07429527f, -0.05438476f, -0.00654138f, 0.09040486f, 0.28493229f, -0.20639744f, 0.09235644f, 
    0.06944375f, -0.08481025f, -0.09817477f, -0.07063374f, 0.15263912f, 0.13934363f, 0.05139907f, -0.00898750f, 
    0.21575989f, 0.08450057f, -0.02493980f, 0.06208976f, 0.02805622f, 0.05017049f, -0.04214789f, 0.06898864f, 
    0.07919765f, 0.07793695f, 0.08120093f, 0.10310956f, 0.00290707f, 0.03393295f, 0.03419475f, 0.02493533f, 
    0.02877274f, 0.19564793f, 0.07698957f, 0.16879100f, 0.04752625f, -0.01669668f, 0.02404541f, 0.07094916f, 
    0.19560589f, 0.22574970f, -0.26123199f, -0.11051945f, -0.01302291f, -0.00943155f, -0.01994356f, 0.08189082f, 
    -0.08348913f, -0.02069530f, -0.06728116f, -0.01063678f, 0.36109766f, 0.19567972f, -0.13411507f, 0.21154423f, 
    0.12048621f, 0.08405103f, 0.06725413f, -0.13163665f, 0.11809521f, -0.03252619f, 0.00874800f, -0.07916493f, 
    -0.21738079f, 0.14509961f, 0.11874675f, 0.02091403f, -0.11821902f, 0.07006092f, -0.02242704f, 0.00658993f, 
    -0.02733087f, -0.08948851f, -0.02165817f, 0.08687434f, -0.08819036f, 0.06427100f, -0.10112749f, -0.00118854f, 
    -0.01457062f, 0.00112785f, 0.03889925f, -0.16651364f, 0.01370907f, 0.08720093f, 0.08939397f, -0.01822259f, 
    0.26133773f, -0.15034547f, 0.16557486f, -0.09875088f, 0.17938714f, -0.04218565f, 0.06579085f, -0.15155844f, 
    0.09072886f, 0.11161962f, 0.02055201f, 0.12752603f, 0.32106984f, -0.19518082f, 0.19669229f, -0.10510308f, 
    -0.04886001f, 0.04809227f, 0.06884060f, 0.07662481f, -0.00829590f, -0.09335475f, 0.03848321f, -0.05490515f, 
    -0.12733397f, 0.19182409f, -0.09053221f, -0.04323317f, 0.02280243f, -0.08525042f, 0.07217180f, -0.06267650f, 
    -0.12418561f, -0.04086298f, -0.13414691f, 0.06782605f, -0.15827265f, 0.06876024f, 0.06006090f, -0.14832056f, 
    -0.01136973f, 0.01783757f, -0.03080459f, -0.07368520f, -0.01189283f, -0.01257322f, 0.03356899f, -0.04331754f, 
    0.12567000f, 0.11892228f, -0.21730991f, 0.02277080f, -0.15718499f, 0.10080478f, -0.08596062f, 0.11057057f, 
    -0.05553870f, -0.05387410f, -0.11572445f, -0.04111832f, -0.07877880f, 0.12561093f, -0.13310042f, -0.00576871f, 
    0.15231900f, -0.00004903f, 0.05729854f, -0.01631111f, 0.06722113f, 0.07485323f, 0.12608533f, -0.01058295f, 
    -0.13182454f, -0.03336969f, 0.18019766f, -0.14838569f, 0.00301893f, -0.06107618f, 0.05098178f, 0.04307465f, 
    -0.06835718f, 0.00744556f, 0.03600942f, -0.03185991f, -0.21853189f, 0.08034493f, 0.20114362f, 0.03166874f, 
    0.08720297f, 0.17220281f, 0.04987511f, 0.19898434f, -0.06117935f, -0.00858478f, -0.13285990f, 0.06472950f, 
    0.11280891f, -0.09077636f, 0.14141554f, -0.06569184f, -0.05010767f, -0.02344988f, 0.08784894f, 0.07170843f, 
    -0.00795322f, 0.11822708f, -0.08617394f, 0.07030702f, -0.14299487f, 0.12236809f, 0.18727681f, -0.04071656f, 
    0.00350026f, 0.01613316f, 0.10736831f, -0.01923513f, -0.09342750f, -0.01143619f, 0.03688638f, 0.03857807f, 
    -0.05614099f, 0.04021433f, -0.03740073f, -0.04266774f, 0.02376778f, -0.02943553f, 0.02535412f, -0.01891924f, 
    0.02907280f, 0.05697400f, -0.03608886f, 0.01112784f, -0.05809970f, -0.02501159f, 0.02664660f, 0.00152093f, 
    -0.06614666f, -0.03860329f, 0.01809552f, -0.04872388f, -0.01833530f, 0.06066779f, -0.00593220f, 0.04921370f, 
    -0.01306981f, 0.00741690f, -0.03944872f, -0.00191884f, -0.04853815f, -0.01621249f, -0.03514820f, 0.05166513f, 
    -0.04163711f, -0.04563533f, -0.04302697f, 0.05555388f, -0.02658279f, -0.02161355f, 0.00087889f, 0.00420670f, 
    -0.02358587f, -0.02770805f, -0.04568663f, 0.04290068f, -0.00859454f, 0.00985217f, -0.07903586f, -0.05619727f, 
    0.04866765f, 0.06668646f, 0.01613607f, -0.02282694f, 0.05276229f, -0.07202148f, 0.01837362f, 0.04008447f, 
    -0.00335397f, -0.08614831f, -0.03688481f, -0.04277349f, 0.02305509f, -0.05544669f, -0.06523364f, -0.02100797f, 
    -0.03449328f, -0.01209041f, -0.05937172f, -0.00474750f, 0.05443044f, -0.03200334f, 0.05757805f, 0.02378209f, 
    0.05399688f, -0.04175106f, -0.04181321f, -0.01634273f, -0.01193713f, 0.05335144f, 0.06094144f, 0.05066311f, 
    -0.00684551f, -0.02711823f, -0.03748104f, -0.03090668f, -0.04304083f, 0.07021644f, 0.02894877f, 0.00941234f, 
    0.04675383f, 0.04634260f, 0.02619444f, 0.00862168f, -0.03348398f, 0.05208939f, 0.02035951f, -0.02423968f, 
    0.03486770f, -0.00533584f, 0.06007754f, -0.02374201f, 0.04854432f, 0.00889409f, -0.04870899f, 0.00823198f, 
    -0.02988056f, -0.02311008f, 0.05800366f, 0.02368483f, 0.02906098f, 0.00588254f, 0.04520450f, -0.04536354f, 
    -0.05833014f, 0.06654572f, -0.06701734f, -0.02054389f, -0.03875241f, 0.01186038f, -0.03985332f, -0.04780996f, 
    -0.01773893f, 0.04458576f, -0.04550696f, -0.02355013f, -0.01770615f, -0.01929905f, 0.01819818f, -0.03300708f, 
    0.01496175f, -0.04117555f, 0.03902785f, 0.05435487f, -0.07986775f, 0.00359068f, -0.00352979f, 0.02344182f, 
    -0.00113491f, 0.02165863f, -0.00563635f, -0.02359461f, 0.03611856f, 0.05991679f, -0.05847992f, 0.03719459f, 
    -0.05718750f, -0.05434062f, 0.00411968f, 0.00234509f, 0.03916348f, -0.01600174f, -0.00395855f, 0.03365798f, 
    -0.05942455f, -0.06753119f, -0.02217332f, 0.03094244f, -0.04488362f, 0.05355731f, -0.02399979f, -0.02801416f, 
    -0.07312829f, 0.05962947f, -0.07630535f, -0.00884302f, 0.04464984f, -0.06744189f, -0.03960321f, -0.00119272f, 
    -0.06182421f, -0.04901493f, 0.01182655f, -0.02384250f, -0.04155578f, -0.06332038f, -0.03848625f, 0.03975622f, 
    0.04677938f, 0.03253778f, -0.02103403f, -0.01089192f, -0.03111773f, 0.03664353f, -0.06498827f, -0.04084332f, 
    -0.04322137f, -0.02726879f, -0.04845870f, 0.02915893f, -0.07577144f, 0.02595782f, 0.04689714f, -0.07070252f, 
    0.14775515f, -0.03256552f, -0.11638179f, 0.16184179f, 0.02216103f, -0.09288938f, 0.08801958f, 0.03061923f, 
    0.03357980f, 0.03300367f, 0.04289090f, -0.01843609f, 0.07439883f, -0.03448194f, -0.02480673f, 0.21526772f, 
    -0.08988038f, -0.04966971f, -0.05892767f, 0.18242978f, -0.06933702f, 0.00359398f, 0.14157802f, -0.05242293f, 
    -0.10705500f, -0.01343092f, -0.04868694f, -0.09177197f, 0.17747104f, -0.01427108f, -0.08197311f, 0.03256097f, 
    0.06627417f, -0.09670590f, 0.04358731f, 0.04422667f, 0.06186094f, 0.11722171f, 0.24951556f, -0.07086861f, 
    -0.02405720f, -0.03427764f, -0.01416095f, -0.04816954f, -0.06136562f, -0.11615368f, -0.00594031f, -0.07108773f, 
    -0.00173462f, -0.01714393f, 0.00342956f, -0.04855784f, 0.06059195f, -0.00630348f, 0.10105918f, 0.05503114f, 
    -0.02734951f, 0.08508103f, -0.05617385f, 0.15623824f, -0.26675916f, -0.01581816f, -0.18308561f, -0.08947530f, 
    0.08288673f, 0.00001388f, 0.02773787f, 0.07304224f, -0.09231660f, -0.04876308f, 0.01910799f, 0.05710248f, 
    0.02905903f, 0.13140787f, 0.01860202f, -0.04967118f, -0.00782046f, 0.05967827f, 0.03001767f, 0.08912183f, 
    -0.12052917f, 0.04362230f, -0.08345331f, 0.01810635f, 0.10832344f, 0.00848088f, -0.25019163f, 0.21973968f, 
    -0.00674220f, -0.00797005f, 0.10389235f, -0.01770421f, 0.08558931f, 0.10644548f, 0.11964079f, 0.02302986f, 
    0.18012202f, 0.20516299f, 0.08739492f, 0.09431430f, 0.08536441f, 0.07524864f, 0.05189453f, -0.03683301f, 
    0.02461983f, -0.13210437f, -0.04959805f, 0.17379117f, -0.32426599f, 0.09015585f, -0.03308544f, -0.13533741f, 
    0.06158442f, 0.06828244f, 0.05856016f, 0.08446679f, -0.11131745f, -0.01510835f, -0.12099691f, -0.11110027f, 
    -0.08257445f, 0.02029207f, 0.04866530f, -0.05064090f, 0.12523679f, 0.07677330f, 0.12254453f, -0.01376846f, 
    0.02096652f, -0.08562015f, -0.14863120f, -0.02320670f, -0.00545685f, 0.11270867f, 0.17007101f, -0.06675098f, 
    0.04206176f, 0.01571384f, 0.10405136f, -0.07070667f, -0.06092469f, -0.02935793f, -0.04698141f, 0.04346941f, 
    -0.07758999f, 0.05794121f, -0.03813554f, -0.04343701f, -0.03554725f, 0.08402221f, -0.04249460f, 0.00657035f, 
    0.08360926f, 0.06052757f, 0.06909690f, 0.07035428f, 0.25201282f, -0.08143540f, 0.04984292f, 0.09252796f, 
    0.07607202f, 0.05255774f, -0.01706666f, -0.02989768f, 0.03529496f, 0.03337191f, -0.04812539f, -0.01653479f, 
    -0.46846813f, -0.08515944f, -0.00340042f, -0.10441388f, 0.02763432f, 0.05917831f, 0.25710779f, 0.09602625f, 
    0.11079251f, 0.05019155f, -0.00500408f, 0.06962572f, 0.01100540f, -0.07550621f, -0.00399461f, 0.08152240f, 
    0.03781699f, 0.04388782f, 0.06319069f, 0.08770219f, -0.01601320f, 0.03386081f, -0.07447234f, -0.03388072f, 
    -0.06592163f, 0.07705032f, 0.04589551f, -0.05282676f, 0.05337324f, 0.10477325f, -0.07013034f, 0.00684076f, 
    -0.02128384f, -0.00246460f, -0.05153401f, -0.07826519f, 0.19707638f, -0.06454471f, -0.16844259f, -0.08739927f, 
    0.08069669f, -0.11264564f, -0.08629768f, -0.12082178f, 0.06893929f, 0.13115692f, -0.04357019f, -0.09147530f, 
    -0.03139920f, -0.19386406f, 0.24594700f, -0.04683597f, -0.03795859f, 0.02734714f, -0.00824052f, -0.09972425f, 
    0.10778956f, 0.06785359f, -0.01360669f, -0.04581215f, -0.23627414f, 0.10439451f, 0.04928143f, -0.09273155f, 
    0.02466303f, 0.05359210f, -0.15377778f, 0.04720960f, -0.07177593f, 0.03380422f, 0.05660943f, -0.02612429f, 
    0.13646129f, -0.02183441f, -0.01838085f, 0.01859565f, 0.16510713f, -0.05530993f, -0.04926084f, 0.04436136f, 
    0.12579338f, -0.08871074f, 0.09005661f, -0.08645485f, 0.21513973f, -0.06445437f, 0.16291896f, -0.08174144f, 
    0.04642245f, 0.02380484f, 0.03476290f, 0.07710142f, 0.03574102f, -0.05911737f, 0.01766110f, -0.04622046f, 
    -0.76028496f, 0.07637602f, -0.15042593f, -0.13811895f, -0.05848686f, 0.02812877f, -0.10213275f, 0.10863268f, 
    0.00410533f, 0.01012681f, 0.00726427f, -0.02049805f, -0.09193962f, 0.25502235f, -0.05559143f, 0.23929650f, 
    0.11267656f, -0.02187924f, 0.01397767f, 0.00124086f, 0.12595925f, -0.03804673f, 0.00853463f, -0.03658677f, 
    0.21923211f, -0.10992048f, 0.04108001f, 0.19371451f, 0.00847203f, 0.17912890f, 0.00367778f, 0.03003081f, 
    -0.04487708f, -0.04205696f, 0.02019959f, 0.08011476f, 0.23675369f, -0.00700426f, 0.00067324f, -0.10627687f, 
    -0.11019449f, 0.01227800f, -0.05072513f, -0.00199789f, -0.02787226f, 0.01883165f, -0.06621852f, 0.06811925f, 
    -0.20278999f, -0.09592731f, 0.15494283f, -0.06135814f, 0.06432927f, -0.01367895f, 0.07690016f, -0.02926561f, 
    0.05276879f, 0.03464923f, -0.07454835f, 0.00620651f, 0.29197359f, -0.23700278f, -0.08609173f, -0.04961566f, 
    0.06344662f, -0.04799088f, -0.04568172f, -0.03093997f, -0.02486323f, -0.02307412f, -0.14501651f, 0.00410928f, 
    0.35587293f, 0.14227207f, -0.02982831f, 0.27666169f, 0.00703538f, 0.01538880f, 0.01803382f, -0.01986704f, 
    0.09140040f, 0.12178063f, 0.09798216f, -0.00364665f, 0.06332976f, -0.28085041f, -0.11467864f, 0.05184608f, 
    -0.13161848f, -0.00327820f, -0.04687266f, -0.07610943f, 0.10536481f, 0.10043532f, 0.05524135f, -0.01390573f, 
    0.04233738f, 0.01446616f, 0.10215835f, -0.01375741f, 0.08105628f, -0.01086332f, 0.06232611f, -0.07764641f, 
    0.09251522f, -0.07447251f, -0.00158281f, 0.05814587f, 0.27902761f, -0.34530240f, -0.10500886f, 0.09484438f, 
    0.08741242f, 0.11748325f, -0.02164703f, 0.04448063f, 0.01890571f, 0.10167790f, 0.07982434f, -0.04153145f, 
    0.25384882f, 0.09251399f, -0.07402667f, -0.01262488f, -0.05541817f, -0.05339353f, -0.00295367f, 0.05454760f, 
    -0.12705857f, 0.04410914f, -0.13313530f, 0.08564851f, 0.25685033f, 0.06577902f, -0.11205228f, 0.08505904f, 
    0.01625203f, -0.14694245f, -0.00302553f, 0.03144897f, 0.08126410f, -0.06544723f, -0.04508563f, -0.10521780f, 
    -0.07382866f, -0.16981760f, 0.08498190f, 0.16483670f, 0.09660790f, -0.05199505f, 0.05550338f, -0.01738712f, 
    0.03034986f, 0.03694180f, -0.00893345f, 0.06771213f, -0.33099198f, 0.03943817f, 0.03159787f, 0.27561679f, 
    -0.07381961f, 0.06545271f, -0.10813814f, -0.00015270f, -0.04419229f, 0.10071936f, 0.07041711f, 0.00340519f, 
    0.30857623f, -0.27279970f, -0.10973448f, 0.11303442f, 0.07681197f, -0.15670933f, 0.01121992f, -0.03117741f, 
    0.14627525f, 0.11217462f, 0.09165245f, 0.01582392f, 0.02601779f, -0.01562296f, -0.08235420f, -0.13461931f, 
    -0.00308336f, -0.01762128f, 0.06129275f, -0.02210620f, -0.03140879f, 0.06589910f, 0.11320853f, 0.14452375f, 
    -0.13556518f, 0.41837841f, 0.10169789f, -0.17874512f, -0.14574100f, -0.02254776f, -0.12059098f, 0.14807370f, 
    0.02113631f, 0.12210829f, 0.05456879f, 0.08740328f, 0.05521977f, -0.00300979f, -0.08243123f, 0.13854057f, 
    -0.02993284f, -0.06918098f, 0.03901541f, 0.04822007f, 0.03804649f, 0.01819179f, -0.02656938f, -0.02115189f, 
    0.04527867f, -0.00151724f, 0.00718429f, 0.02345582f, 0.00208343f, 0.10536177f, 0.04738145f, -0.02055660f, 
    0.06307877f, 0.03502279f, 0.02999686f, 0.06531547f, -0.06963366f, -0.26276225f, -0.11088931f, 0.20520879f, 
    0.00811488f, 0.05994111f, -0.04155935f, -0.10268694f, -0.02358446f, 0.04532559f, 0.03644934f, 0.16023007f, 
    -0.27783051f, -0.16511390f, -0.01728306f, 0.12520090f, 0.17420007f, 0.14490199f, 0.00650420f, -0.05526787f, 
    0.04960186f, -0.03566656f, 0.15933956f, -0.00901514f, 0.12109288f, -0.18550256f, 0.18280642f, 0.24542154f, 
    0.12711895f, 0.02390157f, -0.00307177f, 0.01472106f, -0.01677542f, -0.03600949f, 0.08140072f, 0.08150622f, 
    -0.06877011f, -0.08790629f, -0.07454812f, 0.04812951f, 0.05244028f, 0.19729586f, 0.08511284f, -0.05831717f, 
    0.13389118f, 0.03199974f, -0.04672500f, -0.01044809f, -0.06106311f, 0.00280150f, 0.02210625f, -0.13082874f, 
    -0.03748276f, 0.07051546f, -0.02094957f, -0.00736857f, 0.15389054f, 0.04703869f, -0.01176537f, -0.10190567f, 
    0.01162122f, -0.13797089f, -0.01158754f, -0.14936887f, 0.11495280f, 0.19778958f, -0.07370187f, -0.02154576f, 
    -0.06666256f, -0.04729500f, -0.07107545f, 0.16329485f, -0.00423425f, -0.07031509f, -0.00273174f, -0.19818069f, 
    0.01280932f, 0.10229208f, 0.16065934f, 0.02712147f, -0.01026781f, 0.10308116f, -0.03183306f, -0.03204174f, 
    0.15212242f, -0.11721594f, 0.03550186f, 0.00885912f, 0.12747909f, 0.02143881f, 0.07981474f, 0.04071761f, 
    0.07104637f, 0.06175019f, -0.02569749f, -0.03014890f, 0.01206735f, 0.18120001f, 0.08679028f, 0.22962154f, 
    0.10312019f, -0.00888515f, 0.03208571f, 0.06744410f, 0.07666861f, -0.01334132f, 0.12175614f, -0.05398891f, 
    -0.12067442f, 0.12071999f, -0.30401969f, -0.05085530f, -0.05617655f, -0.07947060f, -0.02899143f, 0.00198699f, 
    -0.07208218f, -0.08338007f, -0.06653807f, 0.01352648f, 0.35727730f, 0.01985478f, 0.24809861f, 0.13098626f, 
    -0.03195467f, 0.01804819f, 0.16479033f, -0.11125756f, -0.01308230f, -0.04227950f, 0.10402469f, -0.08640275f, 
    -0.15598802f, 0.11798482f, 0.04283481f, -0.19031662f, -0.02747384f, 0.05936252f, -0.10966580f, -0.03375993f, 
    -0.19377188f, -0.06985249f, 0.01857352f, 0.15536276f, -0.28391510f, 0.11878716f, -0.21459275f, 0.00722746f, 
    -0.09496829f, -0.01400742f, -0.08717626f, -0.07944897f, -0.06630680f, -0.02463667f, -0.00291987f, -0.11674573f, 
    -0.31184822f, 0.12189328f, 0.07196721f, -0.04384878f, 0.18726297f, -0.00079125f, -0.06907730f, 0.14472383f, 
    -0.04556477f, -0.02678814f, -0.05930087f, 0.12790476f, 0.19796240f, 0.02985055f, 0.00806676f, -0.04881816f, 
    -0.04652885f, 0.16455425f, -0.06520988f, 0.02747411f, -0.07611322f, 0.01641386f, -0.02626335f, 0.08948185f, 
    0.05469614f, 0.09005860f, 0.06619915f, 0.22314054f, -0.03849991f, 0.00051350f, -0.07204010f, 0.06706923f, 
    -0.05358986f, -0.08044998f, -0.09875469f, 0.07337781f, -0.29794395f, -0.02849685f, -0.04135509f, 0.03694976f, 
    0.03297509f, -0.00510012f, 0.02869541f, 0.07586494f, -0.02888520f, 0.13055435f, -0.02550596f, -0.09709620f, 
    0.10653484f, 0.01490304f, 0.21139868f, 0.09143529f, 0.01593059f, 0.02003557f, 0.13248177f, 0.01530157f, 
    -0.02117911f, -0.04148451f, -0.07766821f, -0.11108153f, -0.16641295f, 0.08682986f, -0.13732232f, -0.07939550f, 
    -0.06778642f, 0.07076841f, -0.04685976f, -0.20333803f, -0.04344201f, -0.03623946f, -0.07013882f, -0.05290517f, 
    -0.08187017f, -0.12783150f, -0.05573990f, 0.05802596f, -0.10862353f, 0.09191316f, -0.03451087f, -0.05089066f, 
    -0.04103570f, 0.05753369f, 0.13998649f, -0.00306755f, 0.27364326f, 0.08029458f, 0.15794964f, 0.12241195f, 
    0.13683677f, -0.11429950f, -0.00646727f, 0.12730128f, -0.01346617f, -0.04363171f, -0.14828661f, -0.05464725f, 
    -0.10510012f, -0.06588157f, 0.04046196f, -0.11116667f, -0.09296270f, 0.05554368f, 0.04780762f, 0.04374785f, 
    0.07024888f, -0.04288919f, -0.06771416f, 0.03444205f, 0.06903840f, 0.22054140f, -0.04640830f, 0.13203920f, 
    0.05669176f, 0.00501838f, -0.03365456f, 0.16982315f, 0.04357290f, -0.05856274f, -0.05352218f, -0.04141269f, 
    0.43481681f, 0.04158807f, -0.16736491f, 0.00024758f, 0.02545238f, 0.06263383f, -0.07385024f, 0.07336871f, 
    0.00861518f, 0.04753442f, 0.03330824f, 0.02784482f, 0.14928089f, 0.07322555f, 0.21741657f, 0.08526721f, 
    -0.06127949f, 0.05913535f, 0.07836722f, -0.00248546f, 0.09154284f, 0.01905498f, -0.11771061f, 0.08009145f, 
    -0.17926441f, 0.04420802f, 0.09170809f, 0.06576747f, -0.07249051f, -0.03525914f, -0.07948706f, -0.06743640f, 
    0.06982507f, 0.20711194f, 0.07043082f, 0.07835967f, -0.10759558f, 0.12196242f, -0.28060439f, 0.17063370f, 
    0.00653726f, 0.18606089f, -0.15757363f, -0.04723107f, 0.13376053f, 0.03898217f, 0.06841738f, -0.06634284f, 
    0.32173792f, -0.19261162f, -0.17129381f, 0.17704768f, 0.06554231f, -0.06784856f, 0.02320093f, -0.07012174f, 
    0.00585807f, 0.08061972f, 0.06045550f, 0.04168917f, 0.26237464f, -0.08074233f, -0.07597937f, 0.03571208f, 
    -0.22927035f, -0.05139300f, -0.05463216f, 0.02649592f, -0.12233974f, 0.00128821f, -0.06885107f, 0.08667117f, 
    0.36467195f, 0.16320482f, -0.29477000f, -0.11041919f, -0.02670607f, 0.03072866f, 0.01475834f, 0.09699747f, 
    0.00322243f, 0.00321381f, -0.00595398f, -0.12528269f, -0.03481221f, -0.13633114f, -0.01695650f, -0.07009207f, 
    0.07675735f, -0.07110697f, -0.01299555f, 0.14710596f, 0.08492486f, -0.13234557f, -0.02811504f, 0.00142836f, 
    -0.03702902f, 0.06081962f, -0.16480932f, -0.20558706f, -0.06416744f, 0.01394680f, -0.02543481f, -0.16629520f, 
    0.22212517f, 0.05275328f, 0.08571672f, -0.13504322f, 0.05696259f, -0.00757801f, -0.03278726f, 0.21226524f, 
    -0.07131988f, -0.03795422f, 0.07666034f, -0.11873287f, 0.15790892f, -0.07119783f, 0.11247320f, -0.10540316f, 
    0.16821805f, 0.03594151f, 0.17200346f, 0.20230141f, -0.03165621f, 0.07740501f, 0.11059893f, 0.00214448f, 
    0.08722652f, 0.03286191f, 0.02583919f, 0.03070407f, 0.09041151f, -0.42623213f, 0.09803224f, -0.15833946f, 
    0.03792897f, 0.02318426f, -0.08266024f, 0.15580949f, -0.06935771f, -0.04128766f, -0.09792928f, 0.04555399f, 
    -0.14356574f, 0.11339527f, 0.00086498f, 0.04697516f, -0.03402182f, 0.08322965f, 0.00870974f, -0.05767603f, 
    0.15205166f, 0.13259187f, -0.04289509f, 0.06670761f, -0.00944917f, 0.04839166f, -0.21036702f, -0.32611078f, 
    0.02035966f, 0.00189765f, -0.00310985f, -0.13511539f, 0.07026544f, -0.00840575f, -0.04349370f, -0.11264102f, 
    0.13934402f, -0.05548462f, 0.00100679f, 0.02087542f, -0.03532879f, -0.20140709f, 0.12944569f, -0.03255118f, 
    -0.21272501f, -0.00946501f, 0.09331293f, -0.04364398f, -0.23905247f, -0.07695025f, -0.20896977f, -0.25330424f, 
    -0.01628845f, 0.01366276f, 0.10687908f, 0.00633140f, -0.04718681f, 0.05273645f, -0.05776881f, -0.10419673f, 
    -0.15646276f, 0.05670116f, -0.21764693f, -0.02519550f, 0.09549884f, -0.02380809f, 0.10355690f, -0.02205837f, 
    0.09592351f, -0.08551641f, -0.04447987f, 0.07038441f, -0.06731382f, -0.02213814f, -0.07297808f, 0.21002452f, 
    0.05742488f, -0.02847736f, 0.08731534f, 0.12506497f, 0.03746983f, 0.12212143f, 0.11223876f, 0.21773365f, 
    -0.36806905f, 0.08273386f, 0.08059289f, 0.13482484f, -0.02630678f, 0.00483845f, -0.16253975f, -0.01467772f, 
    0.11195722f, -0.24382447f, 0.04680395f, 0.08334511f, -0.00283844f, -0.15408720f, 0.14204639f, 0.12206380f, 
    0.12646556f, -0.03858464f, -0.10316183f, -0.01594348f, 0.01647162f, 0.02511899f, -0.00784312f, -0.05544188f, 
    0.40999424f, -0.26280987f, -0.14575325f, -0.06151043f, -0.06098552f, 0.01059617f, 0.00503861f, 0.03793567f, 
    0.07184689f, 0.07374195f, -0.04087930f, 0.16093101f, -0.38344008f, -0.01613896f, -0.35730666f, -0.19156668f, 
    -0.03227844f, -0.03315860f, -0.15993410f, -0.05657646f, -0.05759517f, -0.09596096f, -0.02301096f, 0.05915448f, 
    -0.46490216f, 0.29040974f, -0.06280862f, -0.34227073f, -0.04186863f, 0.13333480f, 0.06980591f, -0.09406073f, 
    0.08536802f, 0.03425609f, -0.03432943f, 0.05617904f, 0.30114040f, -0.03211699f, -0.12674533f, 0.12406052f, 
    -0.15026920f, 0.06571742f, 0.13645303f, -0.10707390f, 0.02047501f, 0.17690475f, 0.01629615f, 0.07885701f, 
    0.15179192f, 0.10567392f, 0.09135117f, 0.08292136f, 0.16743946f, 0.22404002f, -0.06924713f, 0.08121964f, 
    0.05067902f, 0.04339456f, 0.05330269f, 0.18016429f, -0.29931450f, -0.05937517f, -0.22860810f, 0.01882526f, 
    -0.08002073f, -0.06667683f, -0.12027390f, -0.03861470f, -0.08117618f, 0.03157648f, 0.03155833f, -0.04966830f, 
    0.40474054f, -0.05291558f, 0.19174072f, -0.09415248f, -0.06938528f, 0.07912575f, 0.05693917f, -0.02019262f, 
    -0.00808597f, -0.10954367f, -0.06410506f, -0.10026181f, 0.03704008f, -0.08303107f, 0.01309582f, -0.00086747f, 
    0.03163567f, -0.00802433f, 0.01718456f, 0.02434243f, -0.04699419f, -0.02781555f, 0.01052428f, 0.01846066f, 
    -0.11714349f, -0.06494260f, -0.12790310f, 0.10787831f, -0.15368702f, 0.12027802f, 0.21303935f, -0.04956541f, 
    0.09591272f, 0.02457310f, -0.01761590f, 0.01958982f, 0.06308077f, 0.04713617f, 0.04602814f, -0.11643560f, 
    0.06556737f, -0.06662114f, 0.04315506f, 0.21003114f, 0.11484098f, 0.06525092f, -0.12781797f, -0.01994951f, 
    -0.17863013f, -0.03526952f, -0.16146223f, -0.22230311f, -0.13751128f, 0.06491350f, -0.05808986f, -0.09636777f, 
    -0.09870485f, 0.07083009f, 0.10082220f, 0.09776992f, 0.11597931f, 0.03013856f, -0.03015045f, 0.24041061f, 
    -0.11431383f, 0.07265465f, 0.17869419f, 0.02511507f, -0.12647951f, 0.00333995f, -0.07899953f, 0.03095831f, 
    -0.15757531f, -0.06706724f, 0.05138475f, -0.00833200f, -0.01875380f, -0.06381477f, 0.11408635f, 0.04251811f, 
    0.00181010f, 0.09821074f, -0.01248616f, 0.08143377f, -0.02958062f, 0.04418458f, 0.01941449f, 0.14796028f, 
    0.09952907f, -0.12974077f, 0.04045060f, 0.05013015f, 0.00992836f, 0.06227936f, -0.02857004f, 0.00954662f, 
    -0.14933045f, 0.00676662f, -0.02447768f, 0.23096402f, 0.04809161f, 0.01181574f, -0.06276763f, -0.01943973f, 
    0.00801321f, -0.12264600f, -0.00478645f, 0.05401333f, 0.06556211f, -0.01458256f, 0.17130274f, 0.11455895f, 
    -0.06693771f, 0.01785866f, 0.06346212f, -0.06535801f, 0.02897847f, -0.08190570f, 0.08985472f, 0.00402546f, 
    0.15236872f, -0.00328010f, -0.11847213f, -0.03498738f, 0.05752367f, -0.02040484f, 0.03160522f, -0.02985931f, 
    0.05908659f, 0.01398805f, -0.16104132f, -0.03855743f, -0.13892196f, 0.15965471f, -0.07231880f, -0.15924832f, 
    0.00482969f, -0.06998387f, -0.04560564f, -0.15649894f, -0.09910750f, -0.00957243f, 0.05324817f, 0.02318982f, 
    -0.28791186f, 0.32833233f, 0.18327105f, 0.00666965f, 0.02769496f, 0.06986383f, -0.06561292f, 0.07741994f, 
    0.05392214f, 0.07939438f, -0.04313608f, 0.00743413f, 0.21647809f, 0.05305111f, -0.10129046f, 0.17756611f, 
    -0.08754343f, -0.01115803f, -0.10449992f, -0.11146511f, 0.08251459f, -0.02138271f, -0.07781789f, 0.00359117f, 
    0.12117980f, 0.02711504f, 0.11620723f, 0.17428885f, -0.01518633f, -0.01258510f, 0.01981566f, 0.01872582f, 
    -0.00427154f, 0.01776459f, 0.01376437f, 0.09331451f, -0.19394711f, -0.13144313f, -0.12396140f, 0.13314269f, 
    -0.07037863f, -0.02287867f, -0.06568832f, 0.00846853f, -0.13017835f, 0.10939561f, -0.04739159f, 0.01762290f, 
    -0.02507188f, -0.07117320f, 0.08807096f, 0.08014963f, 0.03290397f, 0.05677396f, 0.09053790f, -0.06666792f, 
    -0.02840656f, -0.03718857f, 0.04571372f, -0.06700861f, -0.07258305f, 0.18434590f, -0.01076617f, 0.22122957f, 
    0.04638076f, -0.04154989f, 0.01857156f, -0.07470507f, 0.03766837f, -0.08748294f, -0.04648273f, 0.04980607f, 
    0.01234413f, -0.12063695f, -0.07172792f, 0.01719479f, 0.02627779f, 0.15544637f, 0.06430890f, 0.04185219f, 
    0.03163816f, -0.01518845f, -0.01838694f, -0.03119320f, 0.15791476f, -0.10949403f, 0.20353299f, 0.02592444f, 
    0.17049260f, -0.10655090f, -0.05827960f, 0.13554321f, 0.10508327f, 0.03339965f, -0.06218923f, -0.05564075f, 
    -0.12125053f, -0.11365161f, -0.11759754f, -0.17286423f, 0.02032323f, 0.11335809f, -0.02100572f, -0.07525069f, 
    -0.06319239f, -0.02440400f, -0.07266059f, 0.08154081f, -0.02740361f, 0.15698621f, -0.04040332f, 0.00123668f, 
    0.10570475f, 0.04385209f, 0.00800605f, 0.07577781f, 0.03951140f, 0.15500812f, -0.02780386f, 0.05186506f, 
    0.32793242f, 0.00576425f, 0.07762055f, -0.10656098f, -0.04797252f, 0.00970829f, 0.01436329f, 0.01775521f, 
    -0.08647794f, -0.04429552f, 0.02844527f, 0.07771517f, 0.16199079f, 0.25971633f, 0.06911518f, -0.19378959f, 
    -0.06801728f, 0.01713802f, -0.00364819f, -0.03622759f, 0.03139416f, 0.02563439f, 0.01527598f, 0.23086597f, 
    -0.09042294f, 0.07590897f, 0.16271067f, 0.20674446f, -0.00221640f, 0.04497539f, 0.05066323f, 0.02362757f, 
    0.01834016f, -0.07954263f, 0.08739443f, -0.04179967f, -0.11404512f, -0.03419447f, -0.11652979f, 0.10084549f, 
    0.08338432f, 0.08534268f, 0.00900047f, -0.04080901f, -0.06482513f, 0.06146985f, -0.03109140f, 0.03256008f, 
    0.21028662f, -0.12185556f, -0.06759480f, 0.31250861f, -0.06227150f, 0.05638280f, 0.02161129f, 0.12737659f, 
    -0.05011918f, -0.14018424f, -0.03328526f, -0.16913743f, 0.23037407f, -0.00772586f, 0.08323385f, 0.18821126f, 
    -0.10709554f, -0.02269780f, -0.05791243f, 0.00903954f, -0.06732002f, 0.08187716f, -0.02411840f, 0.07142080f, 
    0.08210906f, 0.25252557f, 0.01246861f, 0.00941654f, 0.01461273f, -0.15535893f, -0.01373974f, 0.01520545f, 
    0.13857800f, -0.02007579f, 0.01992546f, 0.04089971f, -0.11521718f, -0.13810657f, 0.06710746f, -0.04289104f, 
    -0.14029950f, 0.09773064f, 0.01741640f, 0.09337664f, 0.00674682f, -0.02827715f, -0.08028929f, -0.02069160f, 
    0.06023735f, 0.02291140f, -0.01669168f, -0.28585443f, 0.05415626f, 0.04086425f, 0.04707221f, -0.01209553f, 
    0.05228154f, 0.10151935f, 0.08442850f, -0.17166626f, -0.01021613f, -0.05633627f, 0.05333399f, 0.14738038f, 
    0.04823293f, -0.06094752f, 0.01243141f, -0.05746923f, 0.00193402f, -0.09496354f, 0.16060957f, -0.06906042f, 
    0.28880894f, -0.15238328f, 0.09514610f, 0.13777621f, -0.11630190f, 0.01851948f, -0.17279181f, 0.11966333f, 
    0.13926393f, 0.15077369f, 0.14442715f, 0.01577967f, 0.12282387f, -0.11193877f, 0.07264298f, 0.03101058f, 
    -0.04315870f, -0.05986685f, 0.06086405f, 0.07211976f, 0.00360351f, -0.07714120f, -0.01607042f, 0.03678087f, 
    -0.36515939f, -0.01692984f, -0.00343283f, 0.07724217f, 0.05502060f, -0.04342590f, 0.06666056f, -0.01059126f, 
    -0.10825525f, -0.04804665f, -0.10858069f, -0.03938615f, -0.10331999f, 0.27830523f, -0.08247528f, -0.22948916f, 
    0.04274343f, 0.13706404f, 0.05537998f, 0.06768173f, 0.10778774f, 0.03377955f, -0.10114251f, 0.05576928f, 
    0.02215994f, -0.05961721f, -0.08179206f, 0.27450910f, -0.01406529f, -0.06465086f, -0.14829259f, -0.04807614f, 
    -0.07218418f, -0.03496231f, -0.00576103f, -0.01211737f, 0.01067321f, 0.01178406f, -0.09231269f, -0.04748246f, 
    -0.00936933f, 0.00665786f, 0.12905540f, 0.01395878f, 0.00490547f, 0.16233075f, 0.03672085f, 0.02459843f, 
    -0.56742722f, 0.26221731f, -0.38431066f, -0.30379939f, 0.15514474f, 0.07475858f, 0.03086871f, 0.05115123f, 
    0.03751736f, 0.11651030f, 0.04356388f, 0.24557127f, -0.04592924f, 0.01900175f, -0.24541794f, -0.44158089f, 
    0.27151459f, -0.04465708f, 0.15462971f, 0.09615297f, 0.06251601f, 0.05960410f, 0.07770764f, 0.13821043f, 
    0.10655194f, 0.03283850f, 0.13754581f, 0.13136537f, -0.03363421f, 0.02734268f, -0.08965489f, -0.04211023f, 
    -0.02342498f, -0.12971683f, -0.04082353f, 0.10289877f, 0.07842317f, 0.08675823f, -0.06819072f, 0.19879515f, 
    0.15986320f, -0.00665271f, -0.04831248f, -0.13740428f, 0.10157098f, 0.02659790f, 0.00256389f, 0.15979312f, 
    -0.10885672f, 0.12848088f, 0.05314209f, 0.00870757f, 0.02442436f, 0.00910397f, 0.04110185f, -0.01722892f, 
    0.02755210f, 0.04201415f, 0.01402417f, -0.02659874f, -0.17614801f, 0.06958621f, 0.06187107f, -0.14286473f, 
    0.00682125f, -0.03381328f, -0.07263888f, -0.12155413f, 0.00934611f, -0.08936994f, -0.07309745f, -0.01899822f, 
    0.29054636f, -0.08762756f, 0.21555036f, -0.09841428f, 0.11645591f, 0.03102495f, -0.02088376f, -0.18596393f, 
    0.04452428f, -0.00392005f, 0.04802872f, -0.05911724f, 0.34384793f, -0.08830250f, 0.26239997f, 0.04972834f, 
    -0.03087450f, 0.04942482f, 0.10952430f, -0.10549247f, -0.11051460f, 0.02188461f, 0.00802999f, -0.00110087f, 
    -0.25766057f, -0.00628089f, 0.10442803f, 0.18193406f, 0.08029854f, 0.13252023f, 0.03794301f, 0.19401063f, 
    -0.11175375f, 0.08385909f, 0.08783974f, -0.02041920f, 0.02739162f, 0.02585704f, 0.11251461f, 0.17295785f, 
    -0.08396326f, 0.06355169f, -0.02338353f, -0.19256195f, -0.10857905f, -0.08675686f, -0.03086606f, 0.09790459f, 
    0.32842985f, 0.25208563f, 0.04068529f, 0.11592712f, -0.18412130f, -0.07967542f, -0.21657777f, -0.12769356f, 
    0.04411071f, -0.06986547f, -0.17701951f, -0.07701224f, -0.15502934f, -0.22055413f, 0.08110162f, -0.03660747f, 
    0.15801600f, -0.21388748f, 0.18127221f, 0.11774126f, 0.16894715f, -0.08270304f, 0.04558385f, -0.06292827f, 
    0.07766882f, 0.04449694f, 0.15956827f, 0.18450753f, -0.03662379f, 0.03072893f, 0.04900533f, 0.00003027f, 
    -0.18924868f, -0.10448596f, -0.09294686f, -0.02052256f, -0.22616516f, -0.14889202f, 0.24406320f, 0.10797747f, 
    0.06536808f, 0.05293732f, 0.00007274f, 0.11858211f, 0.00820423f, 0.00002635f, 0.04602794f, -0.00131105f, 
    0.12274406f, -0.02350282f, -0.06483699f, -0.17992267f, -0.02148279f, 0.11322089f, -0.03043948f, -0.04617522f, 
    0.02789224f, 0.10529857f, 0.00272094f, -0.09676494f, -0.07134189f, -0.02901270f, 0.16431142f, 0.07680772f, 
    -0.05701007f, -0.03375972f, 0.03592028f, -0.00702815f, 0.07238051f, -0.04037427f, -0.02526937f, -0.05383634f, 
    0.19613843f, 0.10286632f, 0.12354153f, -0.03919148f, -0.02324571f, 0.08176478f, -0.12354058f, -0.00722781f, 
    0.07179971f, 0.10551191f, 0.11724879f, 0.03024959f, -0.06146143f, 0.05556674f, 0.09724762f, 0.00648672f, 
    -0.03019891f, -0.02409760f, 0.06290139f, 0.12982216f, 0.14941387f, -0.09096220f, -0.11545926f, 0.02020739f, 
    0.01918029f, 0.12117252f, 0.19094718f, 0.14956488f, 0.06715039f, 0.09374845f, -0.01705812f, -0.04219001f, 
    -0.07831222f, 0.10193643f, 0.07475105f, -0.01912253f, -0.09411229f, 0.05376768f, -0.27845094f, -0.00857080f, 
    -0.11058056f, 0.02784715f, -0.14414088f, -0.02328655f, -0.00327904f, 0.01119888f, -0.02769445f, 0.12862055f, 
    0.18460059f, 0.06231951f, 0.00730133f, 0.10067040f, 0.00227729f, 0.04996672f, -0.04635527f, 0.07274835f, 
    0.01158975f, -0.03592657f, 0.14699362f, -0.03878066f, 0.33069396f, 0.05569817f, 0.07809547f, 0.15703040f, 
    -0.01473299f, -0.08210523f, 0.06839345f, 0.05761806f, 0.02496724f, 0.03776414f, -0.01207456f, -0.01951557f, 
    0.28984663f, 0.00106108f, -0.07179730f, 0.01978857f, 0.03440917f, 0.02420427f, 0.01336738f, 0.03681030f, 
    0.06067077f, 0.02223960f, 0.06967593f, -0.01925202f, -0.05544838f, 0.05987611f, 0.00593414f, -0.08489062f, 
    0.14039728f, -0.01365008f, 0.06114281f, 0.07426970f, 0.03356232f, 0.03140627f, 0.02959116f, -0.09742276f, 
    -0.22764741f, -0.11153632f, -0.18397003f, -0.19255197f, -0.06167535f, -0.00066091f, 0.06209479f, -0.08195873f, 
    0.10388380f, 0.11360691f, -0.02582072f, -0.08397414f, 0.30764878f, 0.00185852f, 0.09641589f, 0.16936533f, 
    0.13958904f, 0.02534819f, -0.09303585f, -0.04162802f, 0.09730708f, -0.14256959f, 0.03134849f, 0.02821641f, 
    -0.03074753f, 0.11348739f, -0.16798730f, 0.15249410f, 0.05654892f, -0.11271164f, -0.13338563f, 0.06066883f, 
    0.00615998f, 0.03808212f, 0.05409039f, 0.09032826f, 0.06265802f, -0.03938917f, 0.05754351f, 0.07526556f, 
    -0.07549252f, 0.01274164f, -0.04922149f, 0.18820195f, 0.00356355f, 0.07983098f, -0.01044728f, -0.00454435f, 
    0.10266373f, -0.00328749f, -0.05938861f, -0.00691163f, 0.09351801f, -0.04918457f, 0.05989961f, -0.04242728f, 
    0.02697930f, -0.03188565f, -0.07055763f, -0.02132428f, -0.04589982f, 0.15561029f, -0.13168499f, -0.13260858f, 
    -0.02529599f, 0.01460464f, -0.01136881f, -0.15593976f, -0.04146095f, 0.06394262f, 0.15231095f, 0.03175858f, 
    0.44710350f, 0.07396175f, 0.10861193f, 0.09874789f, 0.03831666f, -0.10466771f, 0.00239465f, 0.06633034f, 
    -0.05702699f, -0.06465276f, 0.07882609f, 0.06220345f, -0.15691569f, 0.17446001f, -0.07980842f, -0.22032659f, 
    0.02753914f, -0.01348130f, -0.04636765f, -0.03931908f, -0.01289650f, 0.03528294f, 0.08245219f, 0.04029440f, 
    -0.16478793f, 0.02744053f, -0.15157668f, 0.05051938f, 0.18298267f, 0.02303588f, 0.01835377f, -0.00249515f, 
    0.04647254f, -0.06197037f, 0.05837827f, -0.03488512f, -0.17953706f, -0.27192041f, -0.09143250f, -0.04109021f, 
    0.07784087f, -0.04808325f, -0.05473679f, 0.05514961f, 0.01181097f, 0.04106997f, 0.11715702f, -0.08071794f, 
    0.03177913f, -0.01978397f, 0.14334078f, -0.11750416f, -0.01828894f, 0.06460368f, 0.14351630f, 0.10768821f, 
    -0.01265926f, -0.02033754f, 0.08639990f, 0.06717244f, -0.05309389f, 0.12144857f, 0.03401937f, -0.18753365f, 
    0.05154995f, -0.08091523f, 0.03227958f, 0.01492548f, 0.08728369f, -0.12690796f, 0.00696330f, -0.08621296f, 
    -0.01156268f, -0.00157105f, 0.14415807f, -0.05279714f, -0.03481851f, -0.00237730f, 0.00252676f, -0.03460743f, 
    0.11408092f, 0.01959187f, -0.03040079f, 0.06145721f, -0.01692875f, -0.01234085f, 0.08754676f, -0.08404656f, 
    0.03653765f, 0.09910855f, -0.01947502f, 0.14078517f, 0.04713219f, 0.02606579f, -0.01709503f, 0.15617158f, 
    -0.21490850f, -0.25341487f, -0.07544648f, -0.07543163f, -0.04701523f, -0.01288068f, -0.04537744f, 0.00441543f, 
    -0.09140173f, 0.09726071f, 0.06737483f, 0.04864858f, 0.07039857f, 0.00096147f, 0.13653658f, -0.00318946f, 
    -0.00182622f, -0.01425651f, -0.00044290f, -0.11793126f, 0.09951454f, 0.00427589f, 0.12766929f, 0.05610187f, 
    0.06048759f, -0.01477730f, 0.04009743f, 0.06739514f, 0.01303340f, 0.09935863f, -0.10686001f, -0.03663802f, 
    -0.18450558f, -0.09492327f, 0.15481764f, 0.04923311f, 0.21422058f, 0.19139585f, 0.19523126f, -0.02956803f, 
    -0.04844767f, 0.07006754f, 0.02257540f, 0.07304578f, -0.01474737f, -0.05393980f, 0.04386558f, -0.04929557f, 
    -0.07140794f, 0.04857686f, 0.16404048f, 0.08528675f, 0.08394233f, 0.02590821f, 0.02695067f, -0.05124964f, 
    0.02077715f, -0.08520013f, -0.03885298f, 0.09223615f, 0.06450729f, -0.01191585f, -0.06711036f, -0.09947361f, 
    0.14552920f, -0.02762162f, -0.05587287f, 0.00242321f, 0.00395821f, 0.12093700f, -0.07406282f, 0.00208379f, 
    0.24093410f, 0.20079453f, 0.18209979f, 0.09211346f, -0.07221469f, 0.03147242f, 0.00864781f, -0.02530257f, 
    0.03112677f, 0.01005762f, 0.13756673f, 0.12909932f, -0.19080661f, -0.22876135f, 0.02930355f, 0.14888409f, 
    -0.07973836f, -0.03651744f, 0.04847822f, 0.09773991f, -0.01617913f, 0.03110568f, 0.06879006f, -0.03885334f, 
    0.04278333f, 0.05860529f, 0.15085185f, -0.06007917f, 0.00314386f, -0.02957129f, -0.02636143f, 0.00934880f, 
    0.03387180f, -0.08352488f, 0.05775526f, 0.03070850f, 0.13058522f, -0.16588412f, 0.11428473f, 0.15310508f, 
    0.12503585f, -0.00982869f, 0.07650065f, 0.00214344f, 0.04199385f, -0.02221147f, -0.06868698f, -0.02844654f, 
    -0.33792439f, 0.08512665f, -0.01562281f, -0.06738409f, 0.07196156f, -0.09471484f, 0.31173554f, 0.03764141f, 
    -0.02187409f, -0.06415704f, 0.00596707f, 0.05173377f, -0.11814353f, -0.08630013f, -0.13346149f, -0.14462441f, 
    0.13494381f, 0.10254059f, 0.00079187f, 0.00646854f, 0.02001857f, 0.08700945f, 0.18399487f, 0.00419245f, 
    0.09226524f, -0.19765919f, 0.00038650f, -0.01899311f, -0.07699990f, 0.03722870f, 0.11185021f, 0.11831398f, 
    0.10366585f, -0.12430458f, 0.03912055f, 0.06383768f, 0.12156537f, -0.01048204f, 0.36077064f, -0.04141887f, 
    0.02689483f, -0.09067967f, 0.18574582f, 0.00337813f, -0.04329924f, -0.04683678f, -0.04447097f, -0.02198144f, 
    -0.20964968f, 0.08415986f, -0.01323961f, -0.02976294f, -0.09689000f, 0.06157806f, 0.03931091f, 0.04897112f, 
    0.03832222f, 0.07947882f, 0.01433842f, 0.12300557f, -0.14588165f, -0.09183118f, -0.03410749f, -0.02131379f, 
    0.08697334f, -0.00179613f, 0.04389435f, -0.01335628f, 0.02198125f, 0.04459734f, -0.05731958f, -0.02366393f, 
    -0.27133107f, -0.01282393f, 0.13217530f, 0.01907385f, 0.05378689f, -0.07224225f, 0.00996006f, 0.00403562f, 
    -0.03977542f, 0.01099605f, -0.08145408f, 0.05450099f, 0.04399640f, 0.15833649f, 0.14932625f, 0.04280613f, 
    -0.09681899f, 0.06654654f, 0.04487120f, -0.04139033f, -0.05007306f, 0.10122445f, -0.02598929f, 0.05614340f, 
    0.26533306f, -0.01679696f, 0.15234974f, 0.24440718f, 0.12406768f, 0.09918275f, -0.03023025f, 0.09509253f, 
    -0.06885298f, 0.01953432f, 0.17603645f, 0.11169629f, -0.02732225f, 0.07193047f, 0.01162467f, -0.07298124f, 
    -0.11582485f, -0.03921380f, 0.02839164f, 0.10701034f, -0.01437915f, 0.03699248f, -0.05183148f, 0.03119825f, 
    0.17733206f, -0.08827383f, 0.27744654f, -0.09296782f, 0.06886429f, 0.04275263f, 0.08238318f, 0.01649750f, 
    0.02225907f, -0.00802190f, 0.00479533f, 0.04278465f, 0.02391572f, 0.24543996f, -0.11270246f, 0.06597112f, 
    0.04443874f, -0.01311492f, 0.02614827f, -0.13851437f, 0.09343629f, 0.05081386f, -0.01385602f, -0.04408872f, 
    0.08207685f, 0.11028222f, -0.05850711f, 0.02382193f, -0.09381641f, -0.01688435f, -0.02398221f, 0.05597894f, 
    0.06285661f, -0.02133279f, 0.13021232f, 0.05191284f, 0.17204203f, -0.14045541f, 0.16858381f, 0.21398577f, 
    0.02595724f, -0.05159769f, 0.02937903f, 0.16937909f, -0.00778328f, -0.03102337f, -0.06799836f, 0.13355786f, 
    -0.22523592f, 0.00775654f, -0.10435041f, 0.00973536f, 0.01257697f, 0.08900861f, -0.14883478f, -0.04548676f, 
    0.03991630f, 0.17981566f, 0.06651779f, -0.00319317f, 0.27131712f, -0.11680207f, 0.00649740f, 0.22264035f, 
    0.12823167f, 0.06327203f, -0.06975067f, -0.02871062f, 0.15289403f, -0.04632110f, -0.08787213f, 0.07683335f, 
    0.16311656f, -0.15682566f, -0.14106414f, 0.14855467f, -0.09910517f, 0.01578816f, 0.13204117f, 0.12472206f, 
    -0.08550196f, 0.01345884f, -0.05904570f, 0.08917246f, 0.23677178f, 0.03719776f, -0.06329750f, 0.00183180f, 
    -0.08574825f, -0.10879157f, 0.00279239f, 0.01091018f, 0.00111723f, 0.05793096f, 0.01347132f, 0.11878781f, 
    -0.31868210f, -0.04004828f, 0.27581510f, 0.05662323f, 0.01837271f, 0.05167848f, 0.04569764f, 0.11001515f, 
    0.05702891f, 0.03030087f, 0.08486653f, 0.00963827f, -0.29443964f, 0.05025042f, 0.02897567f, -0.03195578f, 
    -0.02670799f, 0.12327677f, 0.06842338f, 0.08349080f, -0.12112320f, 0.01179612f, 0.01988419f, -0.03720788f, 
    0.19155623f, -0.26326481f, -0.16423172f, 0.29999834f, 0.08245361f, 0.08175173f, 0.05893444f, 0.04706372f, 
    -0.10334577f, 0.06145433f, -0.03396289f, 0.00680056f, 0.00951182f, -0.09747002f, -0.09680933f, 0.05315049f, 
    -0.08198867f, 0.04145199f, -0.00567187f, 0.09383437f, -0.03211955f, -0.00314330f, 0.03907255f, 0.02938458f, 
    -0.28461656f, 0.34727776f, -0.11554070f, -0.05489774f, 0.01053954f, -0.07071254f, 0.03071547f, 0.07386782f, 
    -0.01369700f, 0.07670876f, -0.05074164f, 0.11200261f, -0.03311868f, -0.17620896f, 0.03142784f, 0.09654734f, 
    -0.06392061f, 0.01131785f, 0.16376294f, 0.07040223f, 0.07647034f, -0.21263212f, -0.09692527f, 0.09703963f, 
    0.27275112f, 0.13446276f, 0.08677622f, -0.16231610f, 0.20440432f, 0.09122121f, 0.03008606f, 0.00459384f, 
    0.02950528f, 0.02587470f, 0.00373451f, 0.12632497f, -0.31222746f, -0.11542896f, -0.09355042f, -0.00302271f, 
    -0.06091064f, 0.08161982f, 0.07649755f, 0.07847352f, -0.07689720f, 0.04390311f, 0.03984174f, -0.04540972f, 
    -0.03598736f, -0.19713973f, 0.17578430f, -0.03682072f, 0.10285857f, 0.12565550f, 0.02124099f, -0.01856275f, 
    0.09264582f, 0.05538702f, 0.13907050f, 0.03380525f, 0.17780010f, -0.17429285f, 0.08395725f, 0.06513925f, 
    -0.00943174f, -0.02447245f, 0.00714335f, -0.10261750f, 0.02757151f, -0.13870685f, -0.00173186f, 0.01806697f, 
    -0.45770961f, 0.02290363f, 0.01014801f, 0.13430265f, 0.12171957f, 0.06484848f, -0.02803290f, 0.09146119f, 
    -0.06350395f, -0.06776829f, -0.09061809f, -0.01316237f, -0.01016339f, -0.06383204f, -0.10045695f, -0.07403052f, 
    0.03459743f, 0.10463682f, 0.05996377f, 0.12068062f, 0.21310398f, 0.18441056f, -0.14139192f, -0.07845624f, 
    -0.41189569f, -0.11318509f, 0.01752120f, 0.01802202f, 0.02466285f, 0.06543989f, 0.01165719f, -0.00504627f, 
    -0.01764342f, -0.09362692f, -0.04762116f, 0.02131857f, 0.14910191f, -0.27756935f, 0.04818646f, 0.01594064f, 
    -0.03854171f, 0.17374964f, 0.14939034f, 0.14353740f, -0.02853472f, 0.13285603f, -0.02416176f, 0.02197028f, 
    0.05529953f, 0.16729969f, 0.06976642f, -0.00654929f, -0.07635714f, 0.13037813f, 0.04671928f, 0.08638398f, 
    0.02447853f, 0.10939205f, -0.03594995f, 0.07857251f, 0.32236022f, 0.23107246f, -0.04634830f, -0.09700428f, 
    0.04147198f, 0.00834167f, 0.15918283f, -0.07679239f, 0.03837325f, 0.04208366f, -0.19518360f, -0.06591535f, 
    -0.23311383f, -0.29224706f, 0.00606274f, 0.06442714f, -0.03910352f, -0.03400623f, -0.02598530f, 0.01820914f, 
    -0.04801947f, 0.08963437f, -0.05293125f, 0.06809142f, -0.03545584f, 0.09112594f, -0.14036052f, 0.19470839f, 
    -0.08109407f, 0.10376417f, -0.04284885f, 0.09309255f, -0.00754449f, 0.09976256f, 0.09099834f, -0.04262865f, 
    0.09935960f, -0.19004324f, -0.19495191f, -0.03643278f, 0.13141692f, -0.01429823f, 0.10148646f, 0.08277594f, 
    -0.04162965f, 0.05164246f, 0.07268766f, 0.00870067f, -0.04908594f, -0.12233813f, -0.00631274f, -0.05707807f, 
    -0.02242637f, 0.13749243f, 0.02386016f, 0.00121745f, -0.07584864f, 0.04106526f, 0.05820169f, 0.03951331f, 
    -0.03891924f, 0.33786842f, -0.05012583f, -0.04027614f, 0.01634965f, 0.05730636f, -0.03036662f, 0.12965536f, 
    0.10247596f, -0.01892962f, 0.01864338f, -0.01564872f, 0.01208645f, 0.05346835f, 0.00736927f, 0.06802454f, 
    0.09933288f, -0.01587090f, 0.08579691f, -0.00199374f, 0.07805205f, -0.11023083f, 0.02079528f, 0.07013744f, 
    0.15074192f, 0.11686030f, 0.16179314f, 0.13089600f, -0.00521256f, -0.05194272f, 0.05834636f, -0.01041781f, 
    -0.01276978f, 0.13226801f, -0.07116750f, 0.03891022f, -0.17632155f, -0.19662315f, -0.11082061f, 0.02189729f, 
    0.04314212f, -0.00785843f, 0.08638205f, -0.01634750f, -0.00573666f, 0.07362641f, 0.08411182f, 0.10906392f, 
    0.01395654f, -0.10053644f, 0.03087569f, -0.07980628f, 0.00400939f, 0.13185060f, 0.03032688f, 0.07642535f, 
    0.00823107f, 0.02721863f, 0.07176935f, -0.08052382f, -0.06500226f, -0.25938687f, 0.17974649f, 0.14315273f, 
    0.05287191f, 0.07737358f, -0.04637413f, 0.02774114f, 0.09114297f, -0.08358887f, 0.05149259f, 0.06199041f, 
    -0.10348698f, -0.01552982f, -0.09125642f, -0.00932802f, 0.02350405f, 0.02530941f, 0.05108317f, 0.05709182f, 
    0.12074397f, 0.07201069f, -0.03406842f, 0.00861643f, 0.01231159f, 0.17502436f, -0.03141392f, 0.02236980f, 
    0.02561850f, 0.07918760f, 0.03048455f, 0.06967680f, 0.05710251f, 0.16058005f, 0.08961594f, -0.06876729f, 
    -0.16749074f, -0.18243994f, -0.23315239f, -0.14123832f, 0.07926610f, 0.04204839f, 0.07349005f, 0.00256161f, 
    -0.00819768f, 0.00843952f, -0.01551543f, -0.01758561f, -0.04997497f, -0.02296128f, -0.04218180f, -0.01177545f, 
    0.03994076f, 0.06443913f, 0.07627530f, -0.01488203f, 0.01492564f, 0.06265350f, 0.01655125f, 0.02858935f, 
    -0.25693470f, 0.00072187f, 0.05069648f, 0.18286377f, 0.10880018f, -0.03297361f, 0.05544731f, -0.09219338f, 
    -0.00273946f, -0.07249442f, 0.14138333f, 0.00559868f, -0.06918611f, -0.19750802f, 0.09318402f, 0.06330373f, 
    -0.06664062f, 0.00873377f, 0.01069419f, 0.12841415f, -0.14092290f, 0.06277404f, 0.09004973f, 0.02301298f, 
    0.16132572f, -0.06843410f, -0.13687667f, -0.13896184f, 0.10126754f, -0.08895232f, -0.05181199f, 0.02084120f, 
    -0.00904287f, 0.05831748f, 0.08732843f, -0.00077778f, 0.04434665f, 0.07982994f, 0.26767960f, -0.21824342f, 
    0.12301426f, -0.06450783f, 0.02479942f, -0.05542233f, -0.07036451f, -0.04629016f, -0.00961802f, 0.05270343f, 
    -0.14192729f, 0.15818109f, 0.03267743f, -0.13767056f, 0.06043029f, 0.08112080f, 0.04948038f, -0.02112882f, 
    -0.06435734f, 0.21459773f, 0.16421050f, 0.18748194f, -0.18791816f, -0.17369650f, -0.06377640f, -0.00266686f, 
    0.12704480f, -0.06430392f, 0.06007158f, -0.03582244f, -0.07483072f, 0.07641619f, -0.13076589f, 0.05950997f, 
    0.04444335f, -0.12312467f, -0.05898995f, 0.12960191f, -0.05705682f, 0.14633842f, 0.09282961f, 0.16934839f, 
    -0.09749117f, 0.03464227f, -0.04438645f, -0.01688818f, -0.08098219f, 0.17177179f, -0.21394759f, 0.17661326f, 
    0.01132387f, -0.00686188f, 0.16480695f, -0.08404254f, 0.13689338f, 0.05392499f, 0.18006785f, 0.13400842f, 
    -0.01075764f, -0.09725698f, 0.02826068f, 0.03630333f, 0.03222382f, 0.12225161f, -0.06387062f, -0.07174901f, 
    0.13255878f, -0.24407095f, 0.01920482f, 0.14765458f, 0.11852042f, 0.18279372f, 0.01001127f, -0.07070414f, 
    0.07938153f, -0.01725971f, 0.07292292f, 0.05761216f, 0.05809454f, 0.03488129f, -0.17930818f, -0.15645720f, 
    0.06051721f, 0.12169757f, 0.15024629f, 0.00014155f, 0.17211653f, -0.01061057f, 0.08380723f, -0.10330607f, 
    -0.02052571f, -0.11713025f, -0.20521843f, -0.07904471f, 0.09686030f, 0.04606966f, 0.11286588f, -0.09331466f, 
    0.04193855f, 0.02488078f, 0.11598001f, -0.00765503f, 0.05531619f, -0.04706718f, -0.13098407f, -0.01488074f, 
    0.37612465f, 0.22144523f, -0.05827775f, 0.00092740f, -0.03255443f, -0.06111411f, -0.00242932f, -0.07412136f, 
    0.23689865f, 0.05338638f, 0.18062823f, 0.12844138f, 0.34061590f, -0.17275941f, 0.08067251f, 0.02853967f, 
    -0.06718690f, -0.11769535f, -0.06220989f, -0.14696030f, 0.03761243f, 0.05778490f, 0.14151885f, -0.13518094f, 
    -0.40519774f, 0.02990756f, 0.03687496f, -0.01726597f, 0.09030040f, 0.08506392f, 0.23318046f, 0.03288372f, 
    0.10403246f, 0.11448487f, 0.06452307f, 0.02454252f, 0.16624980f, -0.09363592f, -0.10596490f, 0.21066293f, 
    0.09860465f, 0.02858001f, -0.09795651f, -0.07152142f, 0.07984910f, -0.13861580f, -0.17128228f, -0.06877045f, 
    -0.03873152f, 0.05026264f, -0.05378911f, 0.02824535f, 0.03756321f, 0.01432966f, 0.05535493f, -0.04257869f, 
    -0.07852513f, 0.00713320f, 0.01202499f, -0.05773950f, -0.00620929f, -0.04803533f, -0.07583839f, -0.01232995f, 
    -0.04742889f, 0.02016278f, -0.00738678f, -0.04713661f, -0.05858999f, -0.00459342f, 0.05489980f, -0.05074826f, 
    0.04501771f, -0.06614812f, -0.03077577f, 0.04071852f, -0.03481854f, -0.03450640f, -0.06137303f, -0.02140627f, 
    -0.03765793f, 0.01956139f, -0.03403037f, 0.00688532f, 0.03918330f, -0.00781466f, 0.04547413f, 0.01222169f, 
    -0.01626069f, -0.00326820f, -0.02790025f, -0.00431768f, 0.03233387f, -0.02328101f, 0.04388965f, 0.04053842f, 
    0.05754751f, 0.03051030f, -0.02830053f, 0.04202737f, 0.01767375f, -0.04562267f, -0.03632457f, -0.06567492f, 
    0.00478754f, -0.04814622f, 0.02181317f, 0.05530561f, 0.01623122f, -0.02892794f, 0.00164189f, 0.02656676f, 
    0.05991999f, -0.05353576f, -0.02506330f, 0.06135056f, -0.01708379f, -0.04224094f, -0.03868248f, -0.03906364f, 
    -0.04698125f, 0.01473969f, 0.05294438f, 0.03440047f, -0.05878166f, -0.02623885f, -0.02690407f, -0.07472991f, 
    0.01024600f, -0.03000056f, -0.06682887f, -0.03070279f, -0.03077679f, -0.01600333f, -0.01089677f, 0.03354189f, 
    -0.03989425f, 0.00088408f, -0.06130641f, -0.04582090f, -0.02722534f, 0.01676932f, 0.04648551f, -0.02463889f, 
    -0.00958927f, -0.03646491f, 0.02807649f, 0.01965925f, 0.04780519f, 0.05388522f, -0.05812434f, 0.06068909f, 
    -0.02511619f, 0.00099044f, 0.04572513f, -0.03506530f, 0.03880550f, -0.06783758f, -0.03132104f, -0.07620606f, 
    0.06075926f, 0.05913158f, -0.01637522f, -0.00211046f, -0.01016403f, -0.05351522f, 0.06128980f, 0.02374537f, 
    0.00463672f, -0.01831629f, -0.06993912f, -0.06890446f, -0.06986661f, -0.01403762f, -0.03186352f, -0.00197232f, 
    -0.02358263f, -0.01894641f, 0.00946807f, 0.06878886f, -0.00716849f, -0.02165991f, -0.05456499f, 0.05423779f, 
    0.00802502f, -0.03590085f, 0.04727181f, -0.02257636f, 0.01994518f, 0.03986135f, 0.03779537f, -0.05019860f, 
    -0.04876594f, -0.02231100f, 0.02464719f, 0.01387298f, -0.01655989f, 0.00804574f, -0.07807809f, -0.04315527f, 
    0.00171645f, -0.02023842f, -0.07240614f, 0.03103208f, 0.02616860f, 0.00451700f, 0.00826107f, 0.01559843f, 
    -0.03147487f, -0.07658841f, -0.02342250f, 0.01922546f, -0.04837157f, -0.01237998f, 0.05792509f, 0.04862622f, 
    -0.07145144f, 0.04700395f, 0.06313001f, 0.03217057f, -0.00952240f, -0.04006558f, -0.03143911f, -0.02876895f, 
    -0.00229457f, -0.06160662f, -0.04077933f, 0.00927286f, 0.02642256f, -0.05327251f, -0.07952774f, -0.04464912f, 
    -0.03848223f, -0.05037312f, -0.01376414f, 0.01436194f, -0.02185809f, -0.05679053f, 0.05962847f, -0.00453314f, 
    -0.38079265f, 0.05108739f, -0.10423714f, 0.02457160f, 0.17571892f, 0.06699986f, 0.06564356f, -0.01380647f, 
    -0.06645288f, -0.10862441f, 0.03107361f, -0.03905591f, -0.19538523f, -0.24938498f, -0.15334216f, -0.03776379f, 
    0.13855754f, 0.05970422f, 0.01026740f, 0.02414857f, -0.06517723f, 0.02761799f, 0.13833360f, -0.09429269f, 
    0.16015574f, -0.06436942f, 0.06704516f, -0.19153024f, 0.00624014f, -0.07350020f, 0.09307248f, 0.13283105f, 
    0.10875136f, -0.01561713f, 0.08917566f, -0.02820305f, -0.16389029f, 0.02431717f, 0.03201878f, -0.16489711f, 
    -0.01070441f, -0.07440509f, 0.00547221f, 0.07224122f, -0.04192249f, -0.04789946f, 0.03346369f, 0.04923472f, 
    -0.17029780f, -0.00877636f, 0.14900357f, 0.04330396f, -0.06425982f, -0.03027251f, 0.08359984f, -0.00324104f, 
    0.04199609f, 0.07917080f, -0.02016729f, 0.07356869f, -0.06025627f, 0.03374856f, 0.07441350f, -0.01006627f, 
    0.06647450f, -0.00565609f, 0.03873773f, 0.17695014f, 0.09088381f, -0.00466796f, 0.02618301f, 0.13406797f, 
    -0.28093112f, -0.16355462f, -0.04471428f, -0.03252947f, 0.02072484f, -0.02001421f, 0.00355390f, -0.04228156f, 
    -0.11909007f, -0.00467633f, 0.03678869f, 0.10742018f, 0.02897226f, -0.07856467f, 0.09253763f, 0.08819085f, 
    -0.09692896f, -0.00209029f, -0.06315872f, -0.12780304f, 0.10053114f, 0.05112523f, 0.01968728f, 0.01545076f, 
    0.12905988f, 0.05934227f, 0.03023610f, 0.10586053f, 0.08002047f, 0.14317141f, -0.08175647f, -0.00192107f, 
    -0.00890720f, -0.02175144f, 0.11251806f, 0.05170259f, 0.12595439f, 0.26288295f, 0.08942960f, -0.01310196f, 
    -0.02739354f, -0.01725703f, -0.01888318f, 0.10293148f, 0.14530548f, 0.00482424f, 0.05444981f, 0.09504938f, 
    -0.15743569f, 0.08802364f, 0.05695657f, 0.01929927f, -0.05142540f, -0.02442632f, -0.02706369f, -0.12679440f, 
    0.02053888f, 0.00749158f, -0.06807140f, 0.14067130f, 0.03113465f, -0.03443781f, -0.04972988f, 0.00458171f, 
    0.12303934f, -0.08854940f, 0.10302378f, -0.01090366f, 0.01246409f, 0.07071443f, -0.10321212f, 0.07629769f, 
    0.17760825f, 0.15117937f, 0.21801552f, 0.14642842f, -0.01760327f, -0.05354974f, -0.12156475f, 0.02975337f, 
    0.08694728f, 0.01869267f, 0.11237317f, 0.07538187f, -0.03774387f, -0.29314631f, 0.03957779f, 0.18484250f, 
    -0.01886518f, 0.03044713f, 0.00960091f, -0.04696484f, 0.07011603f, 0.00557011f, 0.06523558f, -0.05505145f, 
    -0.09537438f, -0.08632357f, 0.10040246f, -0.00533176f, 0.08550142f, 0.05393860f, -0.06969775f, -0.05760976f, 
    0.05690816f, -0.04423794f, 0.11386465f, 0.01645377f, 0.26422936f, -0.14403088f, 0.16265494f, 0.10469328f, 
    0.01454689f, 0.02522507f, 0.07735419f, -0.04731373f, 0.11132322f, -0.02625804f, -0.01077227f, -0.04271306f, 
    -0.28999788f, 0.15157154f, -0.09822383f, -0.06034172f, -0.04073063f, 0.08248129f, -0.14944372f, 0.03974947f, 
    0.01935260f, -0.08399259f, 0.14271335f, 0.07766886f, -0.23254967f, -0.04049496f, -0.00482325f, 0.05977307f, 
    0.03496359f, 0.00804845f, -0.01570552f, 0.01062116f, -0.04449137f, -0.12737538f, -0.04263045f, 0.00109608f, 
    0.22503334f, 0.24389870f, 0.11970172f, 0.13628687f, -0.04020476f, 0.08585647f, -0.11707881f, -0.02559631f, 
    0.05834849f, 0.00545166f, -0.05826254f, 0.10936659f, 0.16561694f, 0.06872163f, -0.11272351f, 0.05716592f, 
    0.16377692f, 0.06778374f, 0.02314394f, -0.03651023f, 0.10291830f, -0.02536100f, -0.08017232f, -0.03823750f, 
    0.04046828f, 0.21383806f, 0.15470098f, -0.03843011f, 0.03371880f, -0.04900863f, 0.00916517f, 0.11959782f, 
    -0.00399963f, 0.05108548f, -0.02664691f, -0.06534424f, -0.01384411f, 0.20965745f, 0.19081865f, 0.05142365f, 
    0.04145375f, -0.05824667f, 0.07122497f, 0.04015712f, 0.08577307f, 0.09164379f, 0.08086623f, 0.08531939f, 
    0.62389874f, -0.03563889f, 0.19972034f, 0.05749432f, 0.07443139f, 0.03320387f, 0.13776541f, -0.17020656f, 
    0.11124773f, -0.10013450f, 0.08266462f, 0.01243533f, 0.12286557f, -0.20061560f, 0.18014099f, -0.10254656f, 
    -0.02651997f, 0.06042722f, 0.15580599f, -0.01142591f, -0.06427835f, 0.12351910f, 0.00163227f, -0.02585576f, 
    -0.34351590f, -0.04326117f, 0.03172549f, -0.06204686f, 0.05047273f, -0.03427333f, 0.05985605f, -0.03138955f, 
    -0.04364725f, 0.04240139f, -0.03155976f, -0.07552458f, -0.04771108f, 0.20625727f, 0.20588998f, 0.16170004f, 
    0.02157491f, 0.02442680f, 0.02172453f, -0.04678714f, 0.03848749f, 0.11104709f, 0.03688631f, 0.00829772f, 
    0.03935616f, 0.32629234f, -0.16183288f, 0.05611454f, -0.09335142f, 0.05345905f, -0.04271417f, 0.08579709f, 
    -0.04471940f, -0.06514462f, 0.09736725f, 0.03414278f, -0.17433442f, -0.04925344f, 0.03498135f, 0.03664475f, 
    0.06179747f, -0.02999622f, 0.17233014f, 0.16153355f, 0.07768532f, 0.07828867f, 0.05626278f, 0.03314333f, 
    -0.08596825f, 0.11468653f, 0.10472039f, -0.04392364f, 0.06290979f, -0.02657989f, -0.00986526f, 0.03045279f, 
    0.01146137f, -0.01500692f, -0.02888938f, -0.05062344f, -0.09973948f, -0.05392384f, 0.12662399f, -0.00079086f, 
    0.06580793f, 0.09667066f, 0.02808572f, -0.01138208f, 0.02519124f, -0.14051263f, -0.01245829f, 0.07988093f, 
    0.28600091f, 0.09675927f, 0.02337337f, -0.05778849f, 0.05837594f, 0.03424101f, 0.03931055f, 0.08988027f, 
    0.04652736f, 0.09265269f, 0.06637473f, 0.02250864f, -0.32343036f, 0.15058883f, 0.10021181f, -0.06265420f, 
    -0.09022749f, -0.00774833f, 0.00023832f, -0.16688730f, -0.05903830f, -0.13196734f, 0.08584192f, 0.04516448f, 
    -0.36731800f, 0.25018376f, -0.08491288f, -0.10098076f, 0.00502274f, 0.10367706f, 0.06259315f, -0.05570700f, 
    -0.04278777f, -0.05950886f, 0.04895651f, 0.04654848f, 0.10602216f, -0.08117931f, -0.13206129f, -0.21262693f, 
    0.18979032f, 0.03439524f, -0.02859649f, -0.12049018f, 0.10688981f, 0.10471915f, 0.02386985f, 0.00031938f, 
    0.10762315f, -0.15101612f, 0.11674026f, 0.13152418f, -0.15820475f, 0.06308632f, 0.15522766f, 0.03681384f, 
    -0.01414359f, 0.03621532f, 0.06567452f, -0.00714015f, -0.09086958f, 0.07296002f, -0.07052677f, 0.16321765f, 
    -0.10649952f, 0.05645297f, 0.04286307f, 0.04636731f, 0.12260924f, -0.12152947f, -0.00441396f, 0.15042436f, 
    -0.02260313f, -0.01463563f, -0.06800972f, 0.14696078f, -0.16142748f, 0.03438884f, 0.03179988f, -0.07672216f, 
    0.05502118f, -0.07211208f, -0.05377452f, 0.05789537f, 0.08046137f, -0.13564451f, 0.04557877f, -0.06830789f, 
    -0.04963097f, 0.07253906f, -0.03645092f, -0.06045691f, 0.10868143f, 0.00072705f, -0.07649960f, 0.07346322f, 
    -0.22397640f, -0.08518982f, 0.05061950f, -0.11556827f, 0.02754035f, -0.07784336f, 0.06340647f, -0.13448644f, 
    0.05182250f, -0.02602792f, 0.00156992f, -0.01798889f, 0.01586593f, -0.04586742f, 0.31119683f, -0.08965226f, 
    -0.09417871f, 0.03788873f, -0.03900934f, -0.00954803f, -0.04911198f, 0.00577495f, -0.03210616f, -0.01215175f, 
    -0.08320629f, 0.02030607f, 0.11271661f, 0.24043775f, 0.01860921f, 0.03806891f, -0.05109693f, 0.02185261f, 
    -0.14593902f, 0.08034384f, 0.12977256f, 0.00486122f, 0.13125160f, -0.02059647f, 0.05350498f, 0.04893329f, 
    -0.16346395f, -0.01839862f, 0.02872306f, 0.03163195f, -0.02215691f, 0.02166317f, -0.10070287f, -0.01517382f, 
    0.21995506f, 0.05838669f, 0.03559333f, 0.08747824f, -0.07405280f, 0.04470801f, -0.11646218f, 0.07509196f, 
    0.09295950f, -0.01666090f, -0.05476819f, 0.07457881f, 0.19087230f, -0.14459531f, -0.07224979f, -0.06783704f, 
    0.13669704f, -0.02541979f, -0.03139870f, 0.08107184f, -0.02942159f, -0.08037869f, 0.03553076f, -0.00519902f, 
    0.21538889f, 0.13300061f, 0.02475805f, 0.07173864f, -0.12481815f, -0.12973525f, 0.12777859f, 0.08031157f, 
    -0.06155790f, 0.03073619f, 0.02016528f, -0.03850590f, -0.15380675f, 0.03174782f, 0.03690166f, 0.05453435f, 
    -0.07044713f, 0.04393706f, 0.08705124f, 0.13033614f, 0.01994227f, -0.01243858f, -0.00069700f, 0.09167983f, 
    0.07874087f, 0.01617774f, -0.01812474f, -0.12065274f, -0.04073093f, -0.04571899f, -0.25219578f, -0.05639027f, 
    -0.03601561f, 0.05511999f, 0.06016450f, -0.03377571f, 0.24539571f, -0.14938420f, 0.08157253f, 0.04186131f, 
    -0.06048873f, 0.06243804f, 0.07820593f, 0.12031207f, 0.05363871f, -0.00038303f, 0.07976510f, 0.03489281f, 
    -0.02010544f, -0.02358576f, -0.04657226f, 0.02591848f, -0.00849563f, 0.00539805f, 0.01755166f, 0.00215033f, 
    0.04647829f, -0.03486361f, -0.02457499f, -0.04053668f, -0.04981200f, -0.03310123f, -0.02596897f, -0.01055601f, 
    -0.03619266f, -0.03333141f, -0.05526029f, -0.02773748f, -0.02069897f, 0.05023842f, 0.00520196f, -0.05462343f, 
    0.05856291f, 0.08874242f, -0.06800804f, -0.03378283f, -0.07968824f, -0.00957616f, -0.07779153f, 0.04251260f, 
    -0.01714529f, -0.01285767f, -0.04842464f, -0.05486846f, -0.03348838f, -0.00173870f, -0.01437527f, 0.03578772f, 
    -0.04353492f, -0.02756622f, -0.02067349f, -0.06047278f, 0.02709734f, -0.06992398f, -0.00743162f, 0.07288416f, 
    0.08224992f, -0.03147846f, 0.03309621f, 0.03142879f, -0.04417094f, -0.06282198f, -0.04755789f, -0.00042202f, 
    -0.03353892f, -0.02121169f, -0.06968288f, -0.02392918f, 0.04368392f, 0.02031883f, 0.01596886f, 0.03449705f, 
    -0.00973505f, 0.06120831f, -0.07564518f, -0.02996117f, -0.05421163f, 0.02414400f, -0.08076867f, 0.04145317f, 
    -0.06920400f, -0.01619854f, -0.04412224f, 0.02579106f, 0.00456392f, 0.00751677f, -0.04262821f, -0.01682605f, 
    0.01920458f, -0.07376537f, 0.04912779f, -0.01662386f, -0.02219861f, 0.04178109f, -0.01187236f, 0.00039343f, 
    -0.01730823f, 0.04108596f, 0.05542112f, -0.07868033f, -0.05819216f, -0.03726206f, 0.02749998f, -0.04900946f, 
    -0.06167201f, 0.07173727f, 0.03794812f, 0.06009878f, -0.05752445f, -0.01104206f, 0.00238768f, -0.02492238f, 
    -0.01598076f, -0.02295905f, -0.02968366f, 0.01736813f, 0.00245359f, -0.03564933f, 0.04496957f, -0.01656980f, 
    -0.01895792f, -0.02634989f, -0.00407450f, -0.08576836f, 0.04626903f, -0.05156192f, 0.00272805f, -0.05417657f, 
    -0.04752319f, 0.06237229f, 0.02271103f, -0.03010371f, 0.05676057f, -0.01026970f, 0.06029164f, -0.05471066f, 
    -0.03792286f, 0.01642364f, -0.07850140f, 0.03742474f, -0.03283347f, -0.03488472f, -0.03172541f, 0.03479730f, 
    -0.04279764f, -0.00889247f, 0.05834005f, 0.01979465f, 0.05507023f, -0.01895640f, -0.06717101f, -0.07328289f, 
    -0.02346011f, -0.03132898f, -0.05989565f, 0.03424818f, 0.00711136f, -0.07612848f, 0.00780475f, 0.01908590f, 
    0.04903170f, -0.03128409f, -0.05397902f, 0.04565236f, 0.04973223f, 0.05720582f, -0.07854108f, -0.05683991f, 
    -0.05197909f, 0.05829698f, 0.00349072f, 0.01105055f, -0.03738734f, -0.03984592f, 0.06035119f, 0.04651226f, 
    0.01962176f, -0.06503566f, -0.06024743f, 0.04571718f, -0.02201172f, 0.04428825f, -0.07435715f, -0.00373498f, 
    -0.02155946f, 0.00046346f, -0.04807441f, 0.05873661f, 0.04230469f, 0.02822030f, -0.07344871f, 0.01635771f, 
    0.05300986f, 0.04897909f, -0.00018598f, 0.04561474f, 0.02383818f, 0.07009578f, 0.05338882f, -0.06173540f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03047901f, 0.03552236f, 0.02269438f, 0.05543451f, -0.06681591f, 0.01403312f, -0.07324813f, -0.03478732f, 
    -0.02405827f, 0.11721136f, 0.13266237f, 0.04764690f, -0.03436203f, 0.17701843f, -0.07729351f, 0.03110356f, 
    -0.05625299f, 0.05437439f, -0.01813817f, 0.02640447f, -0.05801798f, -0.02539162f, -0.00677612f, 0.08595226f, 
    -0.04100205f, 0.05013627f, 0.01697454f, 0.07684287f, 0.08167931f, 0.01148053f, 0.17115180f, -0.05535043f, 
    0.10393757f, -0.00296170f, -0.02068727f, -0.01470305f, 0.00750719f, 0.01800999f, 0.11871502f, 0.05783490f, 
    0.01695737f, 0.01030959f, 0.00762035f, -0.07768299f, 0.01458634f, 0.05395732f, 0.05898480f, -0.00554202f, 
    -0.01866078f, 0.08487534f, 0.05232570f, 0.01317052f, 0.08053185f, -0.12143877f, 0.14419295f, 0.03941084f, 
    0.13607413f, 0.11955485f, 0.00676294f, 0.00837981f, 0.10196602f, -0.10783628f, 0.05766963f, 0.04594854f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14303412f, -0.03030121f, 0.07398172f, 0.12736104f, 0.00822885f, 0.02530182f, -0.01305273f, 0.00879596f, 
    0.20658912f, -0.15200661f, -0.15134265f, 0.22411670f, 0.13681415f, -0.09820971f, 0.00443787f, -0.09928142f, 
    -0.06704395f, 0.19265911f, -0.00678790f, -0.13302945f, -0.08250760f, -0.04505144f, -0.12942536f, 0.15443653f, 
    -0.03877820f, -0.00648929f, -0.18770373f, 0.00100257f, 0.20237871f, -0.31948733f, -0.02425972f, 0.00244740f, 
    0.14577183f, -0.02172437f, -0.01515097f, 0.24467555f, 0.13581984f, -0.20827085f, 0.28542143f, 0.16752364f, 
    0.11022539f, -0.03936033f, -0.24618526f, 0.07831339f, 0.04863556f, 0.26192039f, -0.05983332f, -0.01138100f, 
    -0.25458249f, -0.04267200f, 0.02120629f, -0.16229300f, -0.24096844f, -0.02547543f, 0.14361984f, 0.22262922f, 
    0.01805884f, -0.12991399f, 0.34798166f, 0.03488243f, 0.12251212f, -0.10631336f, 0.14618541f, 0.01026930f, 
    0.12432413f, -0.02258248f, 0.15115230f, 0.18679336f, 0.06549291f, 0.03150903f, 0.20569913f, 0.04791420f, 
    -0.06129136f, 0.03267936f, 0.24358451f, -0.14470117f, 0.13267948f, 0.19914477f, -0.08973630f, -0.10125292f, 
    0.04968563f, -0.03108701f, -0.03629756f, 0.11414269f, 0.05044439f, -0.01948269f, 0.21835832f, -0.25903982f, 
    -0.01869296f, -0.08641562f, -0.20901850f, -0.06906957f, 0.15655389f, -0.14074369f, -0.08242584f, 0.05837135f, 
    -0.07695717f, 0.25161445f, -0.01203916f, 0.13931675f, -0.04154363f, -0.20963363f, -0.17167561f, 0.18138531f, 
    -0.02363166f, 0.24811682f, 0.05967645f, 0.06980260f, -0.03773471f, -0.08235717f, 0.06524815f, -0.09856065f, 
    -0.41064709f, 0.20049992f, 0.13934432f, 0.27304748f, 0.12954974f, -0.13033113f, 0.02987663f, 0.18182805f, 
    0.10866024f, 0.01298403f, -0.15003957f, -0.01542730f, 0.06971267f, 0.05854822f, 0.20456944f, 0.07601661f, 
    0.16693673f, 0.09606062f, 0.32709679f, 0.00552567f, 0.16565424f, 0.11896782f, 0.00218666f, 0.12121025f, 
    0.15512881f, 0.02462874f, 0.00363556f, 0.33160806f, 0.00256468f, -0.11623197f, -0.04580944f, -0.17550482f, 
    0.11159895f, 0.04641834f, -0.01210029f, 0.20322324f, 0.04285354f, 0.02269619f, 0.16965118f, -0.32470983f, 
    0.02882189f, 0.10650599f, -0.18309605f, 0.08378615f, -0.01302570f, 0.29187071f, -0.21786332f, 0.08913351f, 
    0.11271568f, 0.09267195f, 0.03228660f, -0.24180265f, 0.02300560f, 0.05522552f, 0.17796384f, 0.15458876f, 
    0.26610723f, 0.09800225f, -0.02024177f, 0.03539123f, -0.05928161f, 0.01964181f, -0.16035555f, -0.12071512f, 
    -0.20523989f, -0.00695011f, -0.09664815f, -0.09007981f, 0.23031370f, 0.07137276f, 0.23224029f, 0.00079926f, 
    -0.36096525f, -0.24633162f, 0.23724094f, -0.01678954f, 0.14561570f, 0.26028463f, 0.08576247f, 0.03861580f, 
    -0.55222720f, 0.03308555f, 0.21805924f, 0.29516268f, -0.07567006f, 0.05754763f, -0.40536234f, -0.49292976f, 
    -0.20719770f, -0.06046835f, -0.24391624f, 0.24595411f, 0.04511147f, 0.14826243f, 0.06574689f, 0.04422006f, 
    0.07314719f, -0.03389211f, -0.08252231f, -0.12346879f, -0.00367987f, -0.10900252f, -0.02869940f, -0.06193439f, 
    0.04062042f, 0.02553681f, 0.22083808f, 0.22139199f, 0.27543446f, 0.04081780f, 0.12998840f, 0.07918887f, 
    0.05888257f, 0.00058378f, 0.09716303f, -0.57607692f, 0.07495383f, 0.38181865f, 0.11806063f, -0.12428897f, 
    -0.20215711f, 0.26814783f, 0.19442700f, -0.11424260f, 0.07497201f, -0.12045612f, -0.17464282f, 0.17316157f, 
    0.05060332f, 0.28818610f, 0.07839053f, -0.44028649f, 0.04493045f, -0.34622630f, 0.08005150f, 0.14023638f, 
    0.05254604f, 0.20307828f, 0.12292011f, -0.09451691f, 0.25676060f, -0.06723166f, 0.25730631f, 0.12686971f, 
    -0.31526062f, 0.11847630f, 0.00507724f, 0.23078091f, -0.12058721f, 0.02122385f, -0.27554289f, -0.27649462f, 
    0.07730717f, 0.04254819f, -0.32758895f, 0.18200833f, 0.08625615f, 0.09865680f, 0.05398235f, 0.03797019f, 
    -0.03969452f, 0.07559869f, 0.06343692f, -0.13366908f, 0.02137274f, -0.00293399f, -0.03922049f, -0.09087293f, 
    -0.07422970f, -0.12248169f, 0.05236925f, 0.26318118f, 0.05541394f, 0.07708073f, -0.02794529f, 0.03724762f, 
    0.13352391f, 0.08782652f, 0.03810570f, -0.00785466f, 0.12698877f, 0.36424720f, -0.06152305f, -0.31689104f, 
    -0.12701227f, -0.06148135f, 0.30225128f, -0.01729244f, 0.10684381f, -0.02209094f, -0.34164011f, 0.44078070f, 
    -0.21222441f, 0.06247330f, -0.05171222f, -0.11586900f, 0.03499686f, -0.04324523f, -0.07419279f, 0.18071923f, 
    -0.10522082f, 0.03854214f, 0.06431611f, -0.06902589f, 0.01247847f, -0.03848296f, -0.01664451f, 0.05960359f, 
    -0.01239602f, 0.12113782f, -0.07054575f, 0.11568611f, 0.04925200f, 0.07275092f, 0.12396969f, 0.00608222f, 
    0.24689065f, 0.15409930f, -0.10912132f, -0.09372815f, 0.03297007f, 0.14814489f, -0.09864732f, 0.08574498f, 
    -0.05780855f, 0.05184771f, 0.06402255f, 0.07305031f, -0.10314038f, -0.10761468f, -0.13933472f, 0.11509920f, 
    -0.03637268f, 0.08832237f, 0.13513730f, 0.03624097f, 0.14568499f, -0.27349964f, 0.13350777f, -0.09862401f, 
    0.23977844f, -0.18788297f, 0.12531260f, 0.32354656f, 0.13785501f, -0.01398758f, 0.03351756f, 0.06705727f, 
    0.09142043f, -0.05179503f, -0.19611716f, 0.09256177f, 0.23055129f, 0.26771733f, 0.07807009f, 0.14726582f, 
    0.44952229f, 0.19804661f, 0.09086633f, 0.13679083f, -0.33287081f, 0.13411742f, -0.15620564f, -0.08370929f, 
    0.30010837f, 0.19304021f, -0.08702590f, -0.03849273f, -0.22289006f, -0.20081796f, -0.07336696f, 0.05409663f, 
    0.10805398f, -0.03984717f, -0.19190980f, -0.11107124f, 0.12364978f, 0.09252045f, -0.10872173f, 0.19082047f, 
    0.22430208f, 0.21522924f, 0.09954733f, -0.18614411f, 0.17767745f, 0.16523251f, 0.11795668f, 0.15746193f, 
    -0.00605970f, -0.12543596f, 0.01647425f, 0.03109658f, -0.08245664f, 0.12458152f, 0.12772003f, -0.05468328f, 
    0.12082002f, 0.01707206f, 0.50064105f, 0.05205790f, -0.30781141f, 0.05062708f, -0.06562075f, 0.00067421f, 
    0.18330260f, -0.03882918f, 0.01882535f, -0.09456962f, 0.10700020f, 0.22357857f, -0.10919596f, -0.24919106f, 
    -0.09300336f, -0.29727563f, 0.31620172f, -0.09581386f, 0.16908646f, -0.11022799f, 0.28453359f, 0.29835147f, 
    0.38384774f, 0.44334009f, 0.11962190f, 0.03897694f, -0.13106528f, -0.04175477f, 0.03041100f, -0.10667259f, 
    0.35837418f, 0.24883768f, 0.03627211f, -0.02475264f, -0.05095884f, 0.04715554f, -0.03806044f, 0.07298281f, 
    0.15266877f, 0.08148624f, 0.14650346f, -0.35319710f, 0.00333267f, -0.10220668f, 0.18359250f, -0.08001517f, 
    0.12110679f, 0.01225027f, 0.14755368f, -0.39748135f, 0.13637759f, -0.07956322f, -0.01947079f, 0.09230793f, 
    0.01158233f, 0.06446363f, -0.04410497f, -0.22946423f, 0.05821903f, 0.01203753f, -0.36524066f, 0.14466289f, 
    0.11428756f, 0.08328656f, 0.10921214f, -0.02445237f, -0.37606746f, 0.43316701f, -0.11641377f, -0.09173676f, 
    0.16368271f, 0.05623150f, -0.08180679f, 0.04718825f, -0.20616975f, -0.00044286f, -0.28074008f, 0.21799098f, 
    0.05964704f, -0.07038999f, 0.07088513f, 0.08608989f, -0.11624271f, -0.07529254f, 0.28293613f, -0.39924100f, 
    0.44218394f, -0.02440504f, 0.03178694f, 0.11438616f, 0.18316674f, 0.23006701f, -0.13093621f, -0.14763585f, 
    0.09972062f, 0.07030989f, -0.03784522f, 0.07052703f, -0.10708320f, 0.13490449f, 0.24622297f, -0.12170768f, 
    0.15093538f, -0.00866265f, 0.09277575f, 0.28501809f, -0.24805357f, -0.09079129f, 0.13627039f, -0.49642310f, 
    0.05323227f, -0.02675526f, 0.13245560f, -0.11228047f, 0.24380228f, 0.09611844f, -0.11247473f, 0.37437272f, 
    0.11521833f, 0.27842948f, 0.10637695f, -0.32480961f, 0.11237773f, -0.10290102f, -0.15811004f, 0.21893600f, 
    -0.11279882f, -0.07643587f, -0.04686487f, -0.09932571f, -0.08528481f, 0.27809054f, 0.31802022f, 0.11765847f, 
    -0.08783590f, -0.23726797f, 0.00344964f, 0.06796005f, 0.06179997f, -0.18687329f, -0.04156144f, 0.11260537f, 
    0.21803789f, 0.06322785f, -0.16931501f, -0.04843092f, -0.21654479f, 0.34318438f, 0.17434919f, -0.16371527f, 
    -0.00614145f, -0.05337516f, 0.16205670f, 0.06487288f, 0.23778990f, 0.08116177f, 0.00935218f, -0.04825507f, 
    -0.02886455f, 0.27423465f, 0.01133876f, -0.04227939f, 0.00003458f, 0.10782099f, 0.30825102f, 0.05229542f, 
    -0.01470407f, 0.02009979f, 0.06281497f, 0.06773021f, -0.12121692f, -0.08448421f, 0.05821003f, 0.15324053f, 
    -0.00551888f, 0.15819621f, -0.19615190f, -0.09616949f, 0.14223172f, -0.04685755f, -0.01889885f, 0.15406191f, 
    0.07652546f, -0.18365173f, 0.05173401f, 0.04540233f, -0.03598028f, 0.03240323f, -0.22071393f, -0.03336323f, 
    -0.02804029f, -0.08876937f, 0.22356857f, 0.01973938f, -0.41977260f, 0.19774741f, -0.34668180f, 0.09605677f, 
    -0.04403130f, 0.10122141f, -0.03012933f, 0.21318676f, 0.19262968f, 0.27496922f, -0.00343228f, 0.06139135f, 
    -0.18310076f, -0.20668110f, 0.15809999f, 0.06070330f, 0.27625355f, -0.10699388f, 0.09327658f, 0.43973792f, 
    -0.25315738f, 0.63479221f, 0.33638093f, -0.17420277f, 0.14728385f, -0.07536311f, 0.10703686f, 0.14096907f, 
    -0.03922290f, -0.14346424f, 0.18130986f, 0.04308965f, 0.03969842f, 0.01059415f, -0.00571803f, 0.09300163f, 
    0.01718245f, 0.03917695f, 0.10070452f, 0.11516485f, 0.07752189f, -0.06540555f, 0.13460171f, 0.11122806f, 
    -0.14869779f, -0.06395090f, -0.01149529f, 0.14654937f, -0.02657710f, -0.09142198f, 0.03957348f, -0.03556257f, 
    -0.06663986f, -0.06265261f, 0.03223122f, 0.34169376f, 0.08845761f, 0.00917048f, 0.21853906f, 0.16299595f, 
    -0.07993271f, 0.04606812f, -0.23018123f, 0.10477818f, 0.35104972f, -0.04830340f, 0.00962053f, -0.02415395f, 
    -0.08820663f, 0.05403798f, -0.01502992f, 0.25966141f, 0.13740173f, -0.17944612f, 0.20671317f, 0.18871823f, 
    0.26367593f, 0.07969452f, -0.10956432f, 0.09295376f, -0.10752495f, 0.12117974f, -0.19474941f, -0.22666402f, 
    -0.42774794f, -0.55524480f, -0.13874775f, -0.12116299f, -0.15013957f, 0.22082797f, -0.05788026f, 0.15253375f, 
    -0.28304493f, -0.16419987f, 0.19647467f, 0.04242361f, 0.05909092f, 0.02547723f, 0.04360576f, 0.05837616f, 
    0.00982009f, 0.09827498f, 0.10520288f, -0.37389907f, -0.18456860f, -0.04069512f, -0.21218458f, 0.10581666f, 
    0.25583997f, 0.10400581f, 0.08517598f, -0.12359630f, -0.07026487f, 0.24742036f, -0.09525305f, 0.14484668f, 
    0.08444784f, -0.19954179f, 0.10172755f, -0.02689741f, 0.06678995f, -0.03177183f, 0.13744295f, 0.37098762f, 
    0.01741281f, 0.12491947f, 0.07893072f, 0.02965450f, 0.23308566f, -0.24999778f, 0.26842007f, 0.08044796f, 
    0.23421513f, 0.12827919f, 0.07543653f, -0.17255659f, -0.01390461f, -0.09206069f, 0.38485268f, 0.14692836f, 
    -0.20683698f, -0.20895247f, -0.24324369f, -0.07407375f, 0.31128910f, 0.19716795f, 0.18946163f, -0.20406215f, 
    0.25882378f, 0.28228590f, -0.02218693f, -0.08060887f, -0.41614956f, -0.12681799f, 0.07333191f, 0.06914847f, 
    0.50166982f, 0.31926465f, 0.25769368f, 0.05903705f, 0.19097282f, -0.14435965f, -0.27830118f, -0.09480420f, 
    0.07290018f, 0.12766436f, -0.06744448f, -0.05474861f, -0.02849502f, 0.12444265f, -0.02938488f, -0.06337840f, 
    0.03338186f, 0.08217118f, -0.11384371f, -0.05564424f, 0.00954803f, -0.02589467f, 0.03287904f, -0.02350380f, 
    -0.07993030f, -0.10554051f, 0.05966261f, -0.10974415f, -0.05949545f, 0.00096488f, -0.00095620f, -0.10394157f, 
    -0.03251951f, -0.06361379f, -0.02180354f, 0.02345239f, -0.00753057f, -0.04610270f, -0.06458358f, 0.06000505f, 
    -0.07820282f, -0.05241367f, 0.12473064f, -0.11915094f, 0.02111675f, 0.02635032f, -0.01465743f, 0.06314382f, 
    -0.07563534f, 0.09406338f, 0.04050903f, 0.05481571f, -0.13940054f, -0.09985926f, 0.00768020f, -0.04421326f, 
    0.02377716f, -0.11517385f, 0.03690965f, -0.09433648f, -0.10594764f, 0.05945388f, -0.13222206f, 0.01915672f, 
    -0.13983558f, -0.04078551f, 0.02836431f, 0.03420070f, 0.04225956f, -0.07202061f, 0.09329973f, -0.00075870f, 
    0.04743778f, -0.04764356f, 0.29832497f, -0.17848073f, 0.11676794f, 0.12339465f, 0.15855989f, 0.06399012f, 
    -0.02610503f, 0.14340222f, 0.22839901f, 0.05710291f, 0.23111853f, 0.14961198f, 0.10590491f, -0.28981054f, 
    0.08779613f, 0.07931755f, 0.06801908f, -0.14364545f, 0.00274290f, 0.10374099f, -0.09113683f, -0.14538217f, 
    -0.03252039f, 0.00393938f, -0.17609899f, 0.10124786f, 0.17700081f, -0.02239110f, 0.06993555f, -0.04912056f, 
    -0.01900789f, 0.32281432f, -0.02197643f, -0.29848245f, -0.08594569f, 0.17003737f, -0.16615379f, -0.11106112f, 
    -0.15073045f, 0.08587968f, 0.01991611f, 0.05293517f, -0.04203396f, 0.02726375f, -0.08796883f, 0.21738495f, 
    -0.24686137f, 0.61604923f, 0.05339984f, 0.06328368f, 0.34675416f, 0.00321809f, 0.03641977f, 0.13437144f, 
    0.12168002f, -0.11435246f, -0.18866141f, -0.09433114f, 0.18025573f, 0.13593127f, 0.27848113f, -0.08196118f, 
    0.00712506f, -0.03076749f, -0.08543536f, -0.11610073f, 0.01769067f, -0.05401427f, -0.12099716f, -0.11252953f, 
    0.03772852f, 0.04946490f, -0.05205837f, 0.03376965f, 0.03040659f, 0.05019838f, 0.12482409f, -0.05951786f, 
    0.11931214f, -0.08826105f, -0.02511445f, -0.05229278f, 0.02379765f, 0.00383674f, -0.10452579f, -0.02150075f, 
    -0.09869052f, 0.09036766f, 0.05812201f, -0.02803726f, -0.00501348f, 0.00835267f, -0.05963132f, 0.11416242f, 
    -0.05258331f, -0.09509651f, 0.00467734f, -0.10997742f, -0.06733392f, -0.04585953f, 0.00439773f, -0.09538518f, 
    -0.04598916f, 0.03373481f, -0.11071539f, 0.11948200f, 0.05424364f, -0.02346072f, -0.00928666f, -0.09617566f, 
    -0.07789150f, -0.06320596f, 0.00428286f, 0.07852477f, -0.00976264f, -0.12132326f, -0.08068061f, 0.04929453f, 
    0.01572229f, -0.08218366f, -0.05312791f, 0.06845002f, -0.07860500f, -0.04390562f, -0.08975086f, -0.04598567f, 
    -0.10229877f, 0.10050318f, 0.07949017f, -0.13353561f, 0.10629824f, -0.02517834f, -0.05499718f, 0.12109191f, 
    0.08270281f, -0.13512647f, -0.00799168f, 0.05114451f, -0.08106770f, -0.03613523f, -0.11008691f, 0.05170438f, 
    -0.03908018f, -0.13350265f, 0.04192330f, -0.05308042f, 0.11284396f, 0.03649518f, 0.02506136f, -0.09744322f, 
    -0.11915953f, 0.09004685f, 0.02828318f, -0.10172624f, 0.09682076f, 0.09307277f, 0.11248119f, -0.05724569f, 
    -0.04176572f, 0.09288909f, -0.05090353f, -0.14197040f, 0.05956107f, -0.01684483f, 0.10009005f, 0.03193687f, 
    0.04219935f, -0.00769942f, -0.08094451f, -0.08997908f, -0.00443430f, 0.09187787f, -0.10231669f, 0.07545531f, 
    0.11383758f, -0.07599440f, 0.08916634f, -0.11254529f, -0.10766136f, 0.08634501f, -0.10142522f, -0.03859484f, 
    0.08548766f, -0.10785106f, -0.12659453f, 0.05863417f, -0.08328395f, -0.01721086f, -0.07294999f, 0.00436759f, 
    0.19278204f, -0.12965019f, -0.06685781f, 0.21445729f, 0.06758591f, -0.01333697f, 0.13828383f, 0.22157641f, 
    0.11612062f, 0.02124087f, -0.05771519f, -0.11062451f, 0.17055175f, 0.07378429f, 0.09836932f, -0.12226286f, 
    0.11003219f, 0.11616462f, -0.06423996f, -0.08665390f, -0.07838479f, -0.04903986f, 0.08920493f, -0.15343215f, 
    0.11636135f, -0.00761387f, -0.17872989f, -0.10400502f, 0.07158943f, -0.17319661f, -0.08910543f, 0.01697104f, 
    -0.06369046f, 0.19090895f, -0.02265355f, 0.01941487f, -0.01434103f, -0.43596497f, -0.15680654f, -0.10758274f, 
    0.01432880f, 0.02406727f, -0.12300118f, -0.01685679f, 0.03301072f, 0.14396055f, 0.02292168f, 0.20721748f, 
    -0.06433155f, 0.19752580f, 0.06219267f, -0.03161620f, -0.01681309f, -0.19598606f, 0.18058869f, 0.20402430f, 
    0.20739286f, 0.04633649f, 0.01245036f, 0.11049367f, 0.01384926f, -0.16900085f, 0.15285863f, 0.09280340f, 
    -0.01907026f, 0.10848796f, -0.01752747f, -0.03937052f, 0.06579045f, 0.07717028f, -0.07356697f, -0.00392349f, 
    0.03795098f, -0.11371764f, 0.05033287f, -0.11325410f, 0.10445733f, -0.02022952f, -0.05314037f, 0.00291536f, 
    -0.06840155f, -0.11503824f, -0.08096031f, 0.03721694f, -0.01043501f, 0.00295971f, -0.07820413f, -0.02368961f, 
    -0.07600921f, -0.07061113f, -0.03497009f, 0.00476430f, 0.10844564f, 0.07943693f, -0.00957430f, 0.10089422f, 
    -0.06364013f, 0.10124545f, 0.01004744f, 0.01623615f, -0.11105032f, 0.06235687f, -0.12781562f, -0.01541595f, 
    0.03040882f, 0.08115931f, 0.05110642f, -0.07350176f, -0.04028955f, -0.07488338f, -0.07068530f, 0.10488430f, 
    0.10584416f, 0.07911122f, 0.04960019f, -0.00999917f, -0.07073979f, -0.00904980f, 0.02356073f, -0.08442065f, 
    -0.02279483f, -0.12539543f, -0.11022518f, -0.01001258f, -0.05997564f, -0.12814033f, -0.08338292f, -0.12385422f, 
    -0.01564462f, 0.11455625f, 0.28549039f, -0.07233731f, 0.11168000f, 0.02227485f, 0.05181075f, 0.18169661f, 
    0.29095465f, -0.04786194f, 0.01118072f, -0.25333011f, 0.24295668f, -0.14531986f, -0.10291959f, -0.15275274f, 
    -0.04911761f, -0.20128761f, -0.08501447f, -0.11718692f, -0.04560767f, 0.11876170f, -0.46224859f, 0.11271718f, 
    0.01224472f, -0.00316833f, 0.17785570f, -0.04037797f, -0.02055862f, -0.00881413f, 0.03136332f, 0.10068696f, 
    -0.12190320f, 0.17393966f, 0.09239244f, 0.25669703f, 0.08874969f, 0.03406905f, 0.12266783f, -0.05743367f, 
    -0.08347391f, 0.37145165f, -0.09146705f, 0.11591058f, 0.00959384f, -0.03474823f, 0.02558103f, 0.04253938f, 
    0.46588981f, 0.69755793f, 0.08364486f, 0.36583880f, 0.28659540f, -0.13125920f, -0.15293899f, 0.04178548f, 
    0.38178760f, 0.17167090f, 0.01960561f, 0.09245481f, -0.05805748f, 0.03316798f, 0.26147512f, 0.09419355f, 
    0.20863965f, -0.03046900f, -0.11107481f, 0.14110589f, 0.05195596f, 0.04500031f, 0.27841419f, 0.15040889f, 
    0.17549947f, 0.19791347f, 0.07519264f, -0.09768881f, -0.19359128f, 0.05205109f, -0.02916107f, 0.14746661f, 
    0.03970734f, -0.00719255f, -0.03805289f, 0.19546278f, -0.03398244f, -0.01053839f, -0.00984248f, -0.12492295f, 
    0.03298188f, 0.08436176f, 0.12766621f, 0.18943563f, -0.40559939f, 0.43226573f, -0.34836748f, 0.09375845f, 
    -0.06080740f, -0.04084935f, -0.03762393f, 0.23524779f, -0.04801295f, 0.28683391f, -0.22045517f, 0.02036887f, 
    0.21918713f, -0.03358026f, 0.26884842f, -0.11629124f, -0.08578464f, -0.34119064f, 0.10454763f, 0.21309020f, 
    0.15752274f, 0.16719900f, 0.02267352f, 0.07907455f, 0.01048335f, 0.29358637f, -0.14097637f, 0.01355421f, 
    -0.32307225f, -0.04396414f, -0.18860744f, -0.01977443f, -0.17938006f, 0.16756490f, -0.18028541f, 0.02480705f, 
    -0.05344505f, 0.12019297f, -0.09381323f, 0.06934461f, -0.05094177f, -0.00460978f, -0.12015776f, 0.03471626f, 
    -0.07171517f, -0.11539771f, 0.00641468f, -0.04123757f, 0.05190693f, -0.04632637f, 0.12975256f, -0.02774427f, 
    0.09435788f, 0.10200590f, -0.04813459f, 0.02617571f, 0.00094499f, 0.04973832f, 0.03621149f, 0.08074619f, 
    0.12700531f, -0.10168265f, -0.02306568f, 0.09687521f, -0.08132941f, 0.03268632f, 0.09570724f, -0.06803385f, 
    0.05447770f, -0.10344099f, 0.00543232f, -0.08631142f, 0.00558708f, -0.11843562f, 0.07198905f, -0.09369706f, 
    -0.02011574f, 0.08836324f, -0.00125702f, -0.03180084f, 0.04406295f, 0.08541346f, -0.10692010f, -0.03370849f, 
    -0.13575608f, -0.02697957f, 0.05235140f, -0.12116693f, -0.04020607f, 0.06373389f, -0.02236325f, 0.01854501f, 
    -0.00294565f, -0.12644365f, -0.02942837f, 0.04158838f, -0.03489467f, -0.09811510f, -0.04813213f, 0.05034690f, 
    0.09482852f, 0.05179306f, -0.26048470f, 0.02650041f, 0.21614653f, 0.08171854f, 0.20812370f, 0.17357680f, 
    0.06906392f, 0.18510666f, 0.11067325f, -0.03141800f, -0.19770589f, -0.00121942f, -0.05398867f, -0.07872088f, 
    -0.04618786f, 0.19629988f, -0.02367949f, 0.30819041f, -0.04762985f, 0.06222190f, 0.32410619f, 0.25341690f, 
    0.12504466f, -0.06185737f, 0.09932377f, 0.15398200f, 0.14617835f, -0.05672914f, 0.19931005f, 0.12179497f, 
    0.18731630f, -0.12044587f, -0.10041054f, 0.03767629f, -0.08170282f, -0.02379488f, 0.07899194f, 0.14259581f, 
    0.18741979f, -0.26569816f, 0.21714440f, -0.06901468f, -0.10851209f, 0.03279449f, -0.14436321f, -0.22799049f, 
    0.26590073f, -0.46216816f, -0.18786377f, 0.19296189f, -0.17811175f, 0.15817402f, -0.11763228f, -0.13328230f, 
    -0.11789536f, -0.02764263f, -0.02204009f, 0.09462100f, -0.14107125f, 0.09297747f, -0.14222522f, 0.07539163f, 
    0.01786572f, 0.08597715f, 0.06296513f, 0.09941030f, 0.35080138f, -0.03682455f, 0.32836774f, 0.45771754f, 
    0.04001942f, 0.19237450f, 0.06382428f, -0.24004069f, -0.12183157f, 0.13398646f, 0.06301632f, -0.08061881f, 
    0.08964586f, -0.26049730f, 0.10731367f, 0.43700761f, 0.00108498f, -0.08318993f, -0.27583534f, -0.16624504f, 
    -0.01272624f, 0.03943684f, -0.13706222f, 0.14102049f, -0.10772312f, -0.08043757f, -0.35532433f, -0.04507180f, 
    0.11745615f, -0.06740107f, 0.09448154f, 0.07729236f, -0.15565073f, 0.23489560f, 0.12053450f, 0.03776522f, 
    0.12193108f, 0.24546346f, -0.18900248f, 0.09024893f, -0.11456118f, 0.11268213f, 0.16412228f, -0.17311402f, 
    0.12018690f, 0.00009573f, 0.10969573f, 0.16968843f, -0.33906290f, 0.32461017f, -0.04241661f, -0.32281727f, 
    0.05597674f, -0.14464115f, -0.13824001f, 0.11118297f, -0.12588023f, 0.07988337f, -0.36687711f, 0.06375352f, 
    -0.15036747f, 0.07576820f, 0.20336884f, -0.01706296f, -0.12510826f, 0.00792780f, -0.09788426f, 0.05520396f, 
    -0.15862918f, 0.20196098f, -0.02818410f, 0.07552522f, 0.04834808f, 0.38644466f, 0.08177202f, 0.01101010f, 
    -0.05968958f, -0.25558260f, -0.10700314f, 0.27459043f, -0.02346193f, -0.02085127f, -0.07554669f, 0.05360119f, 
    0.03398680f, -0.03064940f, 0.22081737f, -0.00136050f, 0.00136872f, 0.09175957f, 0.00319230f, 0.06493922f, 
    0.05513361f, -0.05064275f, 0.02337573f, 0.11026352f, 0.12122983f, 0.30883074f, 0.17236520f, 0.03318168f, 
    -0.23176178f, 0.26262730f, 0.05678289f, 0.04433437f, 0.24685507f, 0.02063940f, 0.22645959f, 0.37926826f, 
    -0.05756798f, 0.61155772f, 0.33564949f, 0.06113316f, -0.16192795f, -0.08225589f, -0.13886297f, 0.05966723f, 
    0.20147656f, -0.01084428f, -0.05624890f, -0.03497865f, -0.00698776f, 0.01010507f, -0.19468462f, 0.08234120f, 
    -0.11373068f, 0.04786229f, -0.07326092f, -0.11405703f, 0.02862330f, -0.06143216f, -0.03762007f, -0.00398662f, 
    0.06394459f, -0.10695849f, 0.06309509f, 0.10493197f, -0.11234125f, -0.12031024f, 0.08746922f, -0.11152391f, 
    -0.07971150f, -0.10942645f, 0.06194149f, -0.05967595f, -0.06679141f, -0.05362350f, -0.04376082f, -0.01766813f, 
    -0.09406816f, -0.06849694f, 0.00514859f, -0.06501281f, -0.03327294f, 0.00743658f, 0.10203002f, -0.11512996f, 
    0.06844787f, -0.06144265f, -0.02747756f, -0.09734698f, -0.08159111f, 0.08265842f, -0.03953890f, -0.03856571f, 
    -0.07723556f, 0.06764600f, -0.04271129f, -0.00675147f, 0.09470529f, -0.02021701f, -0.06307767f, 0.04967145f, 
    -0.00231703f, 0.07364813f, -0.01401117f, -0.06609422f, 0.01457223f, 0.00318099f, 0.06641222f, 0.03617167f, 
    -0.03371111f, 0.07405330f, 0.01780456f, 0.06724679f, 0.03676282f, -0.04647891f, 0.08960674f, -0.10221337f, 
    0.10806483f, 0.06094330f, 0.03631844f, -0.02227898f, 0.04214154f, -0.02037743f, 0.09974267f, -0.06730875f, 
    -0.05575480f, 0.06309146f, 0.08703164f, 0.27134484f, 0.21833883f, -0.03868140f, 0.01110439f, -0.04514972f, 
    -0.00090220f, 0.12999780f, 0.02550126f, 0.02750661f, 0.10513869f, 0.06536499f, 0.12541254f, -0.11872163f, 
    0.04274133f, -0.10122828f, -0.18957750f, 0.06154080f, -0.13690276f, 0.23217832f, -0.01001038f, 0.11043780f, 
    0.10932713f, 0.13323002f, -0.10913862f, 0.00604895f, 0.24157637f, -0.01084811f, -0.12558749f, 0.01499333f, 
    0.00160172f, -0.14174920f, 0.26824650f, 0.05436729f, 0.09777548f, 0.22588371f, -0.09063426f, 0.26915538f, 
    -0.47338399f, 0.11746066f, -0.01661177f, -0.20712039f, 0.48740903f, -0.06974517f, 0.27457994f, 0.11151654f, 
    -0.15061133f, -0.21793014f, 0.22622363f, -0.08506093f, 0.27609402f, 0.03613062f, 0.29092163f, -0.02437809f, 
    0.16634056f, 0.10014645f, 0.26058686f, 0.00250589f, 0.07985087f, -0.03505340f, -0.09387915f, -0.06839439f, 
    -0.11520112f, 0.10508985f, 0.09457370f, -0.04554228f, -0.17585827f, 0.21222650f, -0.05741583f, 0.04598471f, 
    0.03650032f, -0.10594862f, 0.05793096f, 0.19474606f, 0.09526096f, -0.11437286f, -0.04541706f, -0.24908656f, 
    -0.09011746f, -0.07181898f, -0.31230682f, 0.05227105f, -0.11710432f, 0.18830048f, -0.16494250f, -0.05759119f, 
    0.12139292f, -0.00317025f, -0.07413227f, -0.17692818f, 0.08921430f, 0.05281845f, 0.12145543f, 0.17454925f, 
    -0.01474589f, 0.13444191f, -0.14540809f, 0.03661909f, 0.09201865f, 0.24097218f, -0.05136692f, -0.04915607f, 
    -0.50491393f, 0.33762950f, 0.06881879f, -0.20061763f, 0.17900756f, -0.07547524f, 0.01997340f, -0.06428479f, 
    -0.15909910f, -0.10072562f, 0.22458251f, 0.07141634f, 0.15449406f, 0.05334755f, -0.15247221f, -0.06754793f, 
    0.26900476f, -0.06054529f, 0.08805095f, -0.12133560f, 0.08083873f, -0.03498779f, 0.07137559f, 0.11918525f, 
    0.34137332f, -0.07558876f, -0.04349330f, 0.26182038f, 0.06589014f, -0.36245698f, -0.04580595f, 0.04978841f, 
    -0.08035828f, 0.01152154f, 0.06620289f, -0.15562388f, 0.06229608f, -0.12266859f, -0.02632621f, 0.12774572f, 
    0.04085125f, 0.10285284f, 0.11610587f, 0.11251812f, -0.15664054f, 0.14697321f, -0.23204526f, 0.01544725f, 
    -0.12222006f, 0.14784540f, -0.10709846f, 0.22752622f, 0.21536994f, -0.16375943f, 0.23631731f, 0.10281393f, 
    0.12222542f, -0.27670699f, 0.05351411f, -0.09580600f, 0.10670843f, -0.15139663f, -0.13023855f, 0.11774729f, 
    -0.11435315f, -0.06442913f, 0.07720096f, -0.15086497f, 0.29163954f, 0.13619013f, 0.16704604f, 0.21867487f, 
    -0.36501235f, -0.07704370f, 0.39654955f, 0.07732578f, 0.11673439f, 0.22762300f, 0.12854247f, 0.01235482f, 
    -0.23030631f, 0.03308550f, -0.07882950f, -0.13030250f, 0.03235786f, -0.05623652f, -0.24677496f, 0.05281696f, 
    -0.12602058f, 0.08582442f, -0.13534883f, 0.11369044f, -0.11454946f, 0.07890101f, 0.10935535f, 0.08980339f, 
    0.10893313f, -0.19917755f, 0.08798496f, 0.28232434f, 0.01844237f, -0.12188454f, -0.01110339f, -0.06080941f, 
    -0.00934386f, 0.06335869f, 0.13034652f, 0.20829396f, -0.02703600f, 0.17902595f, 0.11666879f, -0.10940161f, 
    0.19634615f, 0.08479096f, -0.05364216f, -0.01850016f, 0.26538891f, 0.38688895f, 0.19536488f, 0.13288338f, 
    -0.23129997f, -0.05499800f, 0.11059701f, -0.06880526f, 0.24305598f, 0.00612567f, 0.09520712f, 0.17951778f, 
    -0.20914863f, -0.13775572f, -0.01504618f, 0.05312832f, -0.29077113f, -0.10943258f, -0.02363026f, -0.00800328f, 
    0.17629431f, 0.03298482f, 0.14013736f, -0.04407066f, 0.17322685f, -0.17638148f, 0.00501418f, -0.02175100f, 
    -0.00990720f, 0.11534320f, 0.13310547f, -0.07901634f, 0.32431436f, -0.08529301f, 0.15991496f, 0.23704812f, 
    0.25058922f, -0.06609375f, 0.12026577f, 0.01920913f, -0.03191046f, -0.13455793f, 0.05653250f, -0.27241787f, 
    -0.09637690f, -0.07327738f, -0.05015025f, 0.08892488f, -0.06096133f, 0.02121411f, -0.03296114f, -0.20203008f, 
    0.04944604f, -0.04206538f, -0.10747480f, 0.12921326f, 0.21159175f, -0.24861723f, -0.02231770f, 0.00471654f, 
    0.27375695f, 0.17603093f, -0.10552628f, 0.03884032f, -0.01817733f, 0.04823687f, 0.00309008f, 0.13669887f, 
    0.10276225f, -0.00062230f, -0.03210963f, 0.06086054f, 0.07650793f, 0.01051435f, -0.12667912f, -0.06031853f, 
    0.22231844f, -0.11560605f, -0.10652258f, 0.17645901f, -0.21974173f, 0.24822588f, 0.21115202f, 0.01922889f, 
    0.02675753f, -0.23711047f, 0.17165011f, -0.02347811f, -0.05751201f, 0.11708927f, 0.03812880f, 0.01827047f, 
    0.11237813f, -0.07801048f, 0.03301147f, 0.39652961f, 0.15886992f, 0.05619596f, 0.15549508f, 0.00996571f, 
    0.27483284f, 0.09386305f, 0.02862206f, -0.06408712f, 0.22175337f, -0.05172260f, 0.09592915f, 0.16389206f, 
    -0.09156994f, 0.04408986f, -0.03592265f, -0.15100451f, -0.13086131f, 0.02115462f, -0.09124181f, -0.17682086f, 
    0.03989386f, -0.04519619f, 0.23007934f, -0.07903117f, -0.15487413f, 0.01636161f, -0.03490584f, -0.08544832f, 
    0.04517934f, -0.13726917f, 0.06215805f, 0.24337125f, -0.03907227f, -0.04261459f, -0.10207146f, -0.17214017f, 
    0.24374518f, 0.16826215f, 0.16566215f, 0.02391174f, -0.01132621f, 0.14068562f, 0.13402167f, 0.22889370f, 
    0.30104783f, 0.42279196f, 0.11666290f, 0.14154948f, -0.02681980f, 0.04701254f, -0.12509716f, -0.05875195f, 
    -0.01497753f, 0.22406045f, -0.10473547f, -0.05520709f, -0.23929977f, 0.12614536f, -0.00249956f, 0.04282879f, 
    0.20590231f, 0.06339268f, 0.28129637f, -0.31813183f, -0.05978335f, 0.02488279f, -0.08519669f, -0.22891076f, 
    0.15302609f, -0.11372403f, 0.13551371f, -0.12992527f, 0.27496445f, -0.11836853f, 0.11015265f, 0.04992620f, 
    0.06180219f, 0.21591657f, -0.06593598f, -0.26425675f, -0.02194032f, -0.13264732f, -0.45792642f, 0.28388041f, 
    -0.06087944f, -0.01838896f, -0.18601336f, -0.03000447f, 0.11925863f, 0.10702036f, 0.18777744f, -0.01316806f, 
    0.09080169f, 0.16109374f, -0.01090223f, 0.30325699f, 0.04375282f, -0.08921442f, 0.14300717f, 0.31258705f, 
    -0.03981447f, -0.10864470f, -0.08000813f, -0.07261481f, -0.00078944f, 0.28775719f, 0.08494213f, -0.21028885f, 
    -0.01294358f, 0.04095229f, -0.19485135f, 0.12942022f, 0.17389128f, -0.00982326f, 0.17323828f, 0.16252409f, 
    0.25405052f, -0.00742617f, 0.10579689f, -0.11229771f, 0.27306256f, -0.09658446f, 0.33474797f, 0.09817784f, 
    -0.06334210f, 0.02353411f, 0.17159407f, 0.28147268f, -0.06382950f, -0.04618508f, 0.21169865f, -0.24133381f, 
    -0.13267800f, -0.09501930f, 0.10998378f, 0.12694894f, 0.02774061f, 0.15561834f, -0.00648720f, 0.11762320f, 
    0.02799554f, 0.17655024f, -0.05625815f, -0.02343583f, -0.07290693f, 0.06967511f, 0.07457978f, -0.15140304f, 
    -0.04852960f, -0.08093438f, -0.29303369f, -0.06286498f, 0.14161623f, -0.09491748f, 0.10068149f, -0.02199313f, 
    0.03594044f, 0.11704797f, 0.03023906f, -0.13225630f, -0.05024057f, -0.06309545f, 0.19770934f, -0.03205369f, 
    0.20936511f, 0.43065432f, -0.15891764f, 0.08036175f, -0.05850662f, 0.30994847f, 0.20222607f, -0.08512928f, 
    -0.43510073f, 0.31542024f, 0.11756297f, -0.15119764f, 0.12288638f, 0.00415166f, 0.18216230f, 0.10571379f, 
    -0.12594940f, 0.08556668f, 0.14916992f, -0.01742755f, 0.13598461f, -0.05962282f, 0.09502932f, 0.01121723f, 
    0.16846041f, 0.07363498f, 0.15439972f, 0.07420444f, 0.16347478f, -0.08378053f, 0.28136784f, -0.16386920f, 
    -0.03816918f, 0.12823972f, 0.09678137f, -0.23456535f, 0.16538148f, 0.12383123f, 0.04882760f, -0.12077428f, 
    -0.09811658f, 0.10969155f, 0.03000830f, -0.13800332f, -0.04967907f, -0.01521169f, -0.02598822f, -0.38152716f, 
    -0.00114771f, 0.00065650f, -0.17362435f, 0.00986153f, -0.08898862f, 0.31089631f, -0.06874235f, -0.08748886f, 
    0.15185699f, 0.01285667f, -0.07408497f, -0.10201474f, -0.21376273f, 0.18222336f, -0.12721571f, 0.11536413f, 
    0.10874376f, 0.17833781f, 0.11342946f, -0.00902954f, -0.17498273f, -0.02764238f, 0.16340482f, 0.01308567f, 
    0.00977094f, 0.27249461f, 0.14394778f, 0.06289109f, 0.28834334f, 0.21450977f, 0.09584516f, 0.04929784f, 
    0.15106566f, -0.11137740f, -0.31253064f, 0.01948326f, 0.12674262f, 0.07702918f, 0.17746031f, -0.08711247f, 
    -0.11243665f, -0.03328802f, 0.00565665f, -0.03234413f, 0.00495308f, -0.06894135f, 0.03286435f, -0.00220354f, 
    0.04802079f, -0.00015332f, -0.14357628f, 0.05973212f, 0.02882523f, -0.15195313f, 0.07076389f, 0.04269836f, 
    0.02977215f, -0.07591341f, -0.08025605f, -0.01900698f, -0.07458073f, 0.00340838f, -0.01407950f, 0.07412277f, 
    -0.07997302f, 0.03655677f, 0.05318886f, 0.07010168f, 0.04199300f, -0.15257040f, -0.10003968f, 0.09869323f, 
    -0.03361528f, -0.15634637f, 0.05379992f, -0.06447037f, -0.07164547f, -0.05402163f, -0.05415080f, 0.02727900f, 
    0.09701094f, -0.00778987f, 0.01606827f, -0.06428319f, 0.06710608f, 0.05283951f, -0.04403020f, -0.00562597f, 
    -0.11165728f, -0.10124656f, -0.05075798f, -0.13542719f, 0.00495423f, -0.09877562f, -0.06536380f, -0.03634178f, 
    0.05037975f, -0.09325270f, 0.01953067f, -0.10317475f, -0.13933261f, -0.11883560f, 0.07023785f, 0.07897852f, 
    0.24799484f, -0.11410893f, -0.13970439f, -0.17424543f, 0.20169012f, 0.04288339f, -0.02156883f, -0.11397035f, 
    0.26263964f, 0.20879675f, 0.31002522f, -0.11588843f, -0.13884427f, -0.04547739f, -0.02068390f, -0.04291573f, 
    0.05716866f, 0.01727406f, -0.01045143f, 0.18814300f, 0.12180881f, 0.06172515f, 0.31610176f, -0.17753226f, 
    -0.03693606f, -0.08866698f, 0.12311897f, -0.02453953f, -0.03701603f, 0.09160010f, 0.23250102f, -0.06628172f, 
    0.28911918f, 0.16590413f, 0.03053067f, -0.06737214f, -0.08598660f, -0.14447550f, -0.17397755f, 0.03022259f, 
    -0.06379468f, -0.36469239f, 0.05017471f, 0.03526628f, 0.25050259f, 0.10837593f, 0.32212323f, 0.07896759f, 
    0.21881266f, 0.20133948f, 0.04105825f, 0.08152341f, -0.28490186f, -0.08564498f, 0.07840054f, 0.10739635f, 
    0.36177227f, 0.08982212f, -0.05063432f, -0.06703838f, -0.01418129f, -0.08659121f, -0.06143653f, 0.08202791f, 
    0.09849365f, -0.11845564f, -0.03339133f, 0.43934390f, -0.02057595f, 0.01663260f, 0.18624015f, -0.21964198f, 
    -0.01430903f, 0.08250060f, -0.02984710f, -0.18688460f, 0.27187091f, 0.27365428f, -0.10356950f, 0.16393049f, 
    0.02218767f, 0.29065546f, 0.05621703f, -0.21532001f, 0.07278948f, 0.02538552f, -0.15740825f, -0.07339816f, 
    0.09780590f, -0.10665043f, -0.21181978f, 0.04969038f, 0.10935496f, -0.01938271f, 0.35929203f, 0.12808436f, 
    0.33427462f, -0.13518043f, -0.10857819f, 0.13789138f, -0.17080690f, -0.10493854f, -0.08818334f, -0.05505611f, 
    0.16279688f, 0.30909806f, -0.19323371f, -0.05509552f, 0.01960033f, 0.38637969f, 0.39174929f, -0.12162413f, 
    0.20907161f, 0.27149829f, 0.16198143f, 0.01054723f, 0.09393674f, -0.02742830f, 0.12713695f, 0.04184452f, 
    0.21076564f, 0.31669360f, -0.04327324f, 0.11500717f, -0.00132333f, -0.10324541f, 0.15305804f, 0.00919958f, 
    0.03589637f, -0.06024636f, -0.08065797f, -0.06106995f, -0.11204604f, -0.05487803f, 0.01767054f, -0.06126473f, 
    -0.12654464f, -0.08635538f, -0.04521049f, 0.06372117f, -0.04754734f, 0.05356130f, 0.01420271f, -0.09427834f, 
    -0.11086497f, 0.06700499f, 0.08207361f, 0.01559508f, -0.07306278f, 0.07597858f, -0.05236996f, 0.08561852f, 
    -0.10482223f, -0.09810796f, -0.06442570f, 0.01639754f, 0.05865096f, -0.06213163f, 0.04907079f, -0.05025947f, 
    -0.05646108f, -0.12101039f, -0.01447328f, 0.07604948f, -0.00672633f, -0.07764392f, -0.02430815f, 0.03567183f, 
    0.00683062f, -0.00735671f, -0.13134009f, -0.07079464f, 0.08713763f, -0.02872304f, 0.05538492f, 0.03151534f, 
    -0.04910491f, -0.10061826f, -0.09427249f, -0.12102390f, 0.01778952f, 0.01293230f, -0.13654241f, -0.02862161f, 
    -0.08004591f, -0.00055824f, 0.01258794f, -0.08034667f, -0.01984105f, -0.06681272f, 0.09582154f, 0.04384050f, 
    0.10193113f, 0.07217523f, 0.00351731f, -0.01418201f, 0.08121771f, 0.08315238f, 0.00687160f, 0.09315373f, 
    0.01573998f, -0.02508713f, 0.17843063f, -0.03507620f, 0.21717331f, 0.16803989f, 0.00207819f, -0.25448951f, 
    0.08372135f, 0.16981257f, -0.10764451f, -0.09620610f, 0.05493250f, 0.09124272f, -0.30005768f, 0.10235620f, 
    -0.10058489f, -0.00083623f, -0.18790126f, -0.13982138f, 0.44073376f, -0.35483763f, 0.11899222f, -0.02227015f, 
    0.08178329f, 0.19676237f, 0.07626063f, 0.22079474f, -0.11791034f, -0.03461178f, 0.00694807f, 0.25140524f, 
    -0.06389634f, 0.20900406f, -0.19975089f, 0.04516361f, -0.09625712f, 0.23317273f, -0.04093810f, -0.15616605f, 
    -0.06868225f, 0.08373827f, -0.19785966f, 0.22730383f, -0.20625074f, 0.03929069f, 0.12933144f, 0.23374514f, 
    0.23582517f, -0.09650460f, 0.04775368f, -0.11904928f, 0.20724250f, -0.07557190f, 0.14125802f, -0.06435398f, 
    0.08252852f, 0.04307137f, -0.23307054f, -0.16954832f, 0.13994941f, 0.02975055f, -0.03844146f, 0.29098597f, 
    -0.02180722f, 0.02935518f, 0.12537734f, 0.08935422f, -0.00584686f, 0.01619500f, 0.04330114f, -0.00488900f, 
    0.08994512f, 0.09831641f, 0.01415230f, 0.24455334f, 0.10236026f, 0.10595770f, 0.02598421f, 0.33150005f, 
    0.00991898f, 0.02477769f, 0.22065032f, 0.13732538f, -0.01789355f, 0.08717228f, 0.17592339f, 0.08362635f, 
    -0.03146261f, 0.01660218f, 0.05150739f, 0.19071779f, -0.04499216f, 0.09622940f, 0.09843190f, 0.19068097f, 
    0.11438957f, -0.34734100f, 0.08365541f, 0.06801484f, -0.11144188f, -0.05571781f, -0.07868290f, -0.25730723f, 
    0.42703587f, -0.44029289f, -0.29383853f, 0.19555390f, -0.14686823f, 0.18372317f, -0.10847948f, -0.07644410f, 
    0.06705697f, 0.12977418f, -0.04472152f, 0.01912638f, -0.14862800f, 0.00067971f, -0.27537015f, 0.09694836f, 
    0.01114400f, -0.02100255f, -0.12343328f, 0.04084088f, -0.09035532f, 0.08401170f, -0.06706189f, -0.06164888f, 
    -0.01442862f, -0.06690419f, 0.02662578f, 0.10233159f, -0.06585044f, 0.09142142f, -0.11550669f, -0.11772879f, 
    -0.07716867f, -0.09113178f, -0.12313861f, -0.09502102f, -0.11372811f, -0.02104533f, -0.09687823f, -0.12442656f, 
    -0.01629879f, 0.03031768f, -0.10266200f, -0.06215864f, -0.11449622f, -0.08097152f, -0.10051005f, 0.02297483f, 
    -0.13016649f, -0.00650600f, -0.03498594f, 0.07947911f, -0.01370013f, 0.01758711f, -0.12059970f, -0.09956191f, 
    -0.04726845f, -0.00629925f, 0.08611811f, 0.10782698f, 0.02590749f, 0.04086977f, 0.10842873f, -0.02553400f, 
    0.07777335f, -0.05213071f, -0.04083012f, 0.02077235f, -0.09323531f, -0.01852855f, -0.06456614f, -0.02555203f, 
    -0.10251646f, 0.06844828f, -0.04151966f, -0.09624764f, -0.08744749f, -0.12191163f, 0.11095667f, -0.06516050f, 
    0.04431713f, 0.01050327f, 0.01823404f, -0.07335489f, 0.02048709f, -0.03203532f, 0.07184301f, -0.07681535f, 
    -0.06201232f, 0.04051522f, -0.06636230f, 0.10415309f, 0.04095548f, 0.11123186f, -0.04842306f, 0.06906355f, 
    -0.12102649f, 0.04062334f, 0.09787026f, -0.08479224f, 0.10174635f, -0.03642919f, -0.08970845f, 0.05033337f, 
    0.07621779f, -0.08497404f, -0.11821175f, -0.07646498f, 0.04990888f, -0.09353726f, 0.10934343f, -0.08179814f, 
    0.06692119f, -0.06742373f, 0.09617127f, -0.05104133f, -0.08742940f, -0.01879733f, 0.07651271f, -0.08953664f, 
    0.03099599f, 0.05587580f, -0.01554681f, -0.01766163f, -0.02747592f, -0.08920913f, -0.12812588f, -0.07347458f, 
    -0.09573788f, 0.00757782f, -0.02960966f, -0.06595448f, 0.00744589f, 0.04963907f, 0.05183393f, -0.07267587f, 
    -0.11137147f, 0.01797120f, 0.00689426f, -0.12087791f, -0.04354624f, -0.12200677f, -0.13349801f, 0.02013946f, 
    -0.12112561f, 0.01580209f, -0.02430665f, -0.04799366f, -0.08250841f, 0.12498631f, 0.09215941f, -0.07978038f, 
    -0.02963066f, 0.02485634f, -0.04343541f, -0.15607245f, -0.08698062f, -0.05898138f, 0.00880086f, 0.01769932f, 
    -0.04185510f, -0.07940667f, -0.08911248f, -0.08219925f, -0.00451231f, -0.00973197f, -0.05920015f, 0.07237560f, 
    -0.07159205f, -0.11382097f, 0.02387383f, -0.05681712f, 0.08876324f, -0.14807020f, -0.09930307f, 0.00014544f, 
    -0.11168468f, -0.00746047f, -0.03469574f, 0.00595267f, -0.07635535f, 0.00455424f, 0.08042037f, -0.11380861f, 
    0.00439242f, 0.01359941f, -0.00483161f, -0.09716429f, -0.10571230f, -0.08947210f, -0.11940061f, 0.02081195f, 
    -0.02293315f, -0.06684595f, -0.09615854f, 0.10800463f, 0.00280651f, -0.03249312f, -0.12937047f, -0.08200219f, 
    -0.12898046f, 0.07974304f, 0.00814987f, -0.03834666f, -0.04464720f, 0.07378244f, 0.01524105f, 0.06300257f, 
    0.14758593f, -0.11638042f, 0.23967575f, -0.02546697f, -0.08151813f, 0.05972093f, 0.19123007f, -0.03863741f, 
    0.23808016f, -0.08326864f, -0.03444153f, -0.24281704f, -0.07277144f, 0.06660853f, -0.09460512f, 0.08290441f, 
    0.10571130f, -0.09609082f, 0.03986239f, -0.11158493f, -0.07311200f, -0.05226171f, -0.15677582f, -0.02009100f, 
    0.09695293f, -0.10869196f, 0.16358373f, -0.10622200f, -0.09464670f, 0.23525363f, 0.07653166f, -0.01064377f, 
    0.06106295f, -0.11619283f, -0.08196059f, 0.12139878f, -0.05534933f, -0.08444749f, 0.09637684f, 0.12001077f, 
    0.12491535f, 0.21299998f, -0.27949595f, -0.05871343f, 0.08152462f, 0.01874713f, 0.29788977f, -0.25868019f, 
    0.29896280f, 0.37567347f, 0.13084492f, 0.01466194f, -0.07081585f, 0.12180038f, -0.13008618f, 0.04114507f, 
    0.11352716f, 0.30277631f, 0.16152196f, 0.09386802f, -0.06344721f, 0.05653480f, -0.07580581f, 0.01350632f, 
    -0.04137422f, 0.07385583f, -0.03207371f, 0.20425549f, -0.20628402f, 0.02421866f, -0.09162147f, 0.14098351f, 
    -0.22957760f, -0.00611856f, -0.05686048f, 0.16195856f, -0.05655937f, 0.06022092f, 0.07934953f, 0.28343850f, 
    -0.09315431f, -0.09927640f, 0.07604200f, 0.18318279f, -0.01389315f, 0.04018877f, 0.46775010f, 0.13452621f, 
    0.07926189f, -0.09438989f, 0.12008989f, 0.18895499f, 0.20155770f, 0.10932399f, 0.04613423f, 0.11364093f, 
    -0.16159520f, 0.13012759f, -0.06008763f, -0.18160261f, 0.19392079f, 0.14987950f, 0.15952538f, -0.12787552f, 
    0.02367547f, 0.11780173f, 0.02382911f, 0.03225091f, 0.04470944f, -0.03757156f, 0.07270572f, 0.09337220f, 
    -0.24981616f, -0.46791685f, 0.12259838f, -0.08690748f, 0.19847786f, 0.16866538f, -0.05246262f, 0.06860408f, 
    0.02580751f, 0.15204579f, -0.00234435f, -0.08747423f, -0.16186848f, 0.17281343f, -0.04322969f, 0.01755026f, 
    -0.09930384f, -0.05357366f, 0.13234240f, -0.17222691f, -0.07891541f, 0.08432846f, -0.21695493f, 0.21934584f, 
    0.18870689f, -0.02503797f, -0.16428509f, 0.02566819f, 0.18349624f, 0.04559311f, 0.08019999f, -0.02033018f, 
    -0.04168068f, -0.08126391f, -0.02652870f, -0.01093839f, -0.11456677f, 0.07382698f, -0.06053213f, 0.27792811f, 
    -0.03701015f, 0.06212536f, 0.35141975f, 0.00785440f, 0.01759684f, -0.18695818f, -0.17060687f, -0.13142659f, 
    -0.09080088f, 0.18543120f, -0.11419424f, 0.06040852f, 0.29561433f, 0.12139412f, 0.27748799f, -0.15796696f, 
    -0.09042884f, -0.11364308f, 0.01691665f, 0.00838031f, 0.36267737f, 0.14258088f, 0.06510843f, 0.17194106f, 
    -0.04725127f, 0.41595879f, 0.18842967f, 0.14636998f, 0.09468426f, -0.22507487f, 0.11744525f, 0.13802451f, 
    0.29456356f, 0.12954687f, 0.25422800f, -0.02948113f, -0.05944890f, -0.05463046f, -0.19264695f, -0.14366174f, 
    0.09730759f, 0.04758425f, 0.18893795f, -0.16230150f, -0.06976221f, -0.00625614f, 0.01666767f, 0.06694489f, 
    -0.14901951f, 0.10409304f, 0.10680218f, 0.26743650f, 0.13154753f, -0.21754172f, 0.04060800f, -0.16233841f, 
    0.08091438f, -0.11869381f, 0.08265711f, 0.21436200f, -0.03405224f, -0.04610904f, 0.34050298f, 0.13608232f, 
    -0.08455649f, -0.00354601f, 0.08284544f, 0.19799298f, 0.00809496f, 0.21220826f, -0.05025487f, -0.05741576f, 
    -0.27953365f, 0.38345668f, 0.06332556f, -0.30115283f, 0.09449909f, 0.02779334f, -0.07242403f, -0.05760866f, 
    0.00789883f, -0.06130013f, 0.32508969f, 0.00508443f, -0.04391154f, -0.31853804f, -0.23423804f, 0.13752632f, 
    -0.37856579f, -0.23491240f, -0.05048666f, 0.06713147f, 0.57992148f, -0.00582423f, 0.19314916f, 0.08288169f, 
    -0.28715467f, -0.13348064f, -0.05370855f, 0.03217607f, 0.05930593f, 0.18418270f, 0.12744100f, -0.04305992f, 
    0.06188197f, 0.07451575f, -0.09665818f, -0.01010985f, -0.15654752f, 0.06921541f, -0.11537741f, 0.00598018f, 
    0.07960723f, 0.03379472f, 0.03786774f, 0.17807181f, -0.06082765f, -0.15941183f, -0.00768808f, 0.31738174f, 
    -0.09941933f, -0.03927295f, -0.00127833f, -0.02455027f, -0.08848678f, 0.04905053f, 0.22347002f, 0.32837930f, 
    -0.09341730f, 0.02320208f, 0.31056836f, 0.17915873f, -0.30075651f, 0.20581743f, -0.08966290f, 0.03758809f, 
    -0.15751247f, 0.00876349f, 0.10436180f, -0.09658331f, 0.30383268f, -0.06288660f, 0.27151698f, -0.03148494f, 
    0.05478299f, -0.21462038f, 0.12191320f, 0.06945314f, 0.29679057f, 0.10375935f, 0.05175401f, 0.23586175f, 
    -0.03689913f, -0.07682969f, 0.05264755f, -0.07785937f, 0.06011572f, -0.04688349f, -0.08214612f, 0.16617054f, 
    -0.01766707f, 0.03843205f, 0.32306579f, -0.07648964f, -0.02493206f, -0.01655763f, -0.11847588f, -0.06239643f, 
    -0.20049931f, 0.11489095f, 0.21663465f, 0.06371018f, -0.13482980f, -0.11588369f, 0.07663958f, -0.00703865f, 
    -0.11871520f, -0.02490507f, 0.03342653f, -0.08124793f, 0.11181101f, 0.09311169f, -0.05202330f, 0.02669987f, 
    -0.00410661f, 0.00053525f, 0.10440385f, -0.08226150f, -0.03884285f, 0.10313785f, 0.29790336f, 0.26057777f, 
    0.04915690f, -0.10610098f, 0.09588738f, -0.06275880f, 0.16372018f, -0.37461686f, 0.29391629f, -0.09748477f, 
    -0.14452998f, 0.28530380f, 0.07198264f, -0.24802843f, -0.02196425f, 0.00946600f, 0.05764424f, -0.04313242f, 
    -0.10419511f, 0.35086140f, -0.18295604f, 0.03925065f, 0.17711505f, 0.08525848f, -0.05565657f, -0.08263069f, 
    -0.29428771f, 0.26058677f, 0.26222268f, -0.03297933f, -0.02613041f, -0.06487517f, 0.03294211f, 0.21767123f, 
    0.23072922f, 0.19938755f, -0.04527416f, -0.02485379f, -0.07415903f, 0.15006852f, -0.02242010f, 0.00850802f, 
    -0.03098440f, 0.08550612f, 0.07563269f, -0.04743781f, -0.07053542f, 0.09071242f, 0.07979599f, -0.09327532f, 
    -0.07805865f, -0.12224718f, 0.08868805f, 0.09358947f, 0.02102772f, 0.09551948f, -0.03814020f, 0.05102257f, 
    0.03837313f, 0.04981589f, 0.13072939f, -0.12287664f, 0.04159352f, -0.03401493f, 0.01873914f, -0.00610204f, 
    0.09914251f, 0.06254484f, -0.02037418f, -0.02594631f, 0.08136243f, 0.07825932f, -0.15200444f, 0.06768632f, 
    -0.10376212f, 0.01902987f, -0.00991192f, 0.06518505f, -0.14693609f, -0.06442148f, -0.11646708f, 0.04786155f, 
    -0.01469295f, -0.01276362f, -0.14963067f, -0.10252775f, 0.06145674f, -0.07277869f, 0.03030530f, -0.04362936f, 
    0.05147614f, -0.01566729f, -0.10921512f, -0.14581844f, 0.02986128f, -0.09144242f, 0.00352106f, -0.09618834f, 
    0.11305510f, -0.06549846f, -0.07190511f, -0.01132878f, -0.08117758f, 0.08698715f, -0.01548962f, 0.02627289f, 
    0.01647581f, 0.10392658f, 0.01503156f, 0.06851763f, -0.09302071f, -0.10482692f, -0.11743258f, 0.00870704f, 
    -0.12887593f, -0.02018275f, 0.09760202f, 0.01104145f, 0.02847416f, -0.08990145f, -0.00480693f, -0.00149636f, 
    0.01379676f, 0.02256895f, -0.01010797f, 0.07733532f, 0.07587804f, -0.05853864f, 0.00926048f, 0.04572276f, 
    -0.02062545f, 0.12192570f, -0.08278418f, 0.12180734f, -0.12207420f, 0.11942880f, -0.04946391f, 0.10907149f, 
    -0.09822884f, -0.09167302f, -0.01071215f, 0.05861438f, -0.12278329f, 0.06908873f, -0.11701953f, -0.04437191f, 
    0.00552508f, -0.10027580f, 0.11999395f, -0.08165520f, -0.02859071f, 0.11670719f, -0.11769157f, 0.11253418f, 
    -0.11800385f, -0.07979948f, -0.11825444f, -0.08423685f, -0.10178570f, -0.11833750f, -0.04492856f, -0.07265442f, 
    -0.13080482f, 0.11499933f, -0.08398351f, -0.07442012f, -0.08898779f, -0.12460700f, -0.03443885f, -0.10310841f, 
    0.14430256f, -0.05912371f, 0.13520809f, 0.01912989f, 0.15404002f, -0.08636042f, 0.21282291f, 0.15211181f, 
    -0.00484114f, 0.00174989f, -0.11648739f, -0.02361271f, -0.37052384f, 0.26290491f, 0.10020211f, 0.06029667f, 
    0.00425457f, -0.05905304f, -0.09292839f, 0.31753263f, -0.04052924f, 0.01336100f, 0.14057334f, -0.43016583f, 
    -0.06340367f, -0.01527194f, 0.06563025f, 0.07217334f, -0.18401796f, 0.11325083f, -0.10316832f, 0.07421733f, 
    0.27884781f, -0.18380532f, -0.11508471f, -0.00587896f, -0.22625335f, 0.24758643f, 0.22053072f, -0.02446948f, 
    0.11499029f, 0.33532903f, -0.14460774f, 0.07783292f, 0.28822362f, -0.12388726f, 0.26993227f, -0.10851739f, 
    0.10814714f, 0.13568006f, 0.09128457f, -0.08967393f, -0.33718437f, 0.15900260f, -0.08858550f, -0.17360035f, 
    -0.12925349f, -0.04398507f, 0.08876207f, 0.01023735f, 0.02382820f, 0.15580559f, -0.40103459f, -0.06990622f, 
    -0.08643281f, -0.06051199f, -0.08966178f, -0.12021198f, 0.23134518f, -0.06872730f, -0.02490375f, -0.02503238f, 
    -0.01508525f, 0.15342638f, 0.15392646f, 0.29087803f, -0.11920869f, 0.15826610f, -0.02625634f, -0.08138667f, 
    0.09231102f, 0.29209203f, 0.01754167f, 0.07741509f, 0.01067708f, 0.04189780f, 0.53585255f, 0.14436339f, 
    -0.09431290f, 0.06376162f, -0.00565056f, 0.22321323f, 0.40561038f, 0.21354897f, 0.26392731f, -0.10536257f, 
    0.14803588f, -0.03577863f, -0.08938348f, -0.19675475f, 0.01733873f, -0.00913843f, -0.05023314f, 0.15979809f, 
    0.19846961f, -0.16258693f, 0.14130583f, -0.03450741f, 0.01296823f, 0.06360318f, 0.08418588f, -0.28765169f, 
    0.09386776f, -0.36379960f, -0.27616751f, -0.11545645f, -0.04862150f, 0.21168216f, 0.31227604f, -0.11010404f, 
    -0.10775335f, 0.07477155f, -0.12478640f, -0.06924985f, 0.27380183f, 0.09335049f, 0.01277691f, 0.11407672f, 
    0.16395284f, -0.07745311f, 0.00600491f, -0.16129312f, 0.20706289f, 0.03637227f, -0.14891814f, 0.14968969f, 
    0.31021857f, 0.02546768f, -0.13209084f, 0.23080771f, 0.02234076f, -0.29417267f, -0.02513571f, -0.08709029f, 
    -0.07623655f, 0.02190882f, -0.02457592f, 0.00077648f, 0.00321920f, -0.10278509f, -0.12264547f, 0.20475188f, 
    0.03106005f, -0.02243739f, 0.05954790f, 0.13877678f, 0.03378714f, -0.19121704f, 0.07667393f, 0.07769528f, 
    0.22240385f, -0.07304713f, -0.11548594f, 0.13055618f, 0.24825940f, 0.01949929f, 0.17643832f, -0.05942280f, 
    0.13132182f, -0.34891173f, 0.03032728f, 0.05975583f, 0.09494719f, 0.03181491f, -0.23240952f, 0.11871196f, 
    0.46689093f, -0.35833102f, -0.20892896f, -0.07579216f, -0.10783476f, 0.20361090f, 0.18572034f, -0.12792826f, 
    -0.15657820f, -0.14405406f, 0.35148275f, 0.03561002f, 0.06445879f, 0.14620014f, -0.05179922f, 0.07830282f, 
    -0.05953993f, 0.01814205f, -0.05481265f, 0.62470776f, -0.20887540f, 0.04562047f, 0.18165591f, -0.10501552f, 
    -0.12801315f, 0.13281986f, -0.19861531f, 0.16375446f, 0.03206053f, 0.33203664f, -0.10559415f, 0.37882537f, 
    0.06017063f, 0.12517336f, 0.12551740f, 0.10189900f, -0.10872096f, -0.13797672f, 0.03928009f, -0.14633489f, 
    -0.04927954f, 0.08441946f, -0.08559632f, 0.17804219f, 0.07410259f, 0.08613372f, 0.02144847f, 0.01177668f, 
    0.11519470f, -0.34797263f, -0.08155315f, 0.34706622f, 0.16621645f, 0.05018354f, 0.21670879f, 0.07092818f, 
    0.01535024f, 0.28392464f, -0.06275366f, -0.03144935f, -0.06255978f, 0.12356362f, 0.19896689f, 0.30120751f, 
    -0.52256435f, -0.19570036f, 0.34192923f, -0.13536397f, -0.25280434f, 0.04705196f, -0.01828101f, 0.15968329f, 
    -0.21929641f, 0.02079155f, -0.06939480f, 0.07442963f, 0.08391255f, -0.15561931f, 0.09293716f, -0.13140279f, 
    -0.13108690f, -0.09524946f, 0.12892531f, 0.21996412f, 0.21371286f, 0.01251640f, 0.21591899f, 0.17226845f, 
    -0.15043902f, 0.16535930f, 0.13139412f, 0.11806729f, 0.09006788f, -0.02617312f, 0.10227023f, -0.02283396f, 
    0.02954313f, 0.20123021f, -0.01894897f, -0.02472157f, -0.10196504f, 0.06146352f, 0.16716512f, 0.18751808f, 
    0.09459795f, -0.06830126f, 0.19051708f, 0.19230746f, 0.09331371f, 0.07580885f, -0.02385206f, -0.03028710f, 
    -0.15525401f, 0.26385996f, -0.04960479f, -0.11845213f, -0.06205234f, 0.32283813f, -0.15366054f, -0.11611369f, 
    -0.01276381f, 0.20007241f, 0.27642548f, 0.02730362f, -0.18702818f, -0.30745584f, -0.16004139f, -0.09228891f, 
    0.27297348f, -0.28592545f, -0.09695999f, 0.34904671f, 0.29311442f, 0.16046743f, -0.16253829f, -0.07690145f, 
    -0.02128883f, 0.07324571f, -0.16652693f, 0.00118223f, -0.10234702f, 0.22875577f, 0.00997971f, 0.07664949f, 
    -0.05832751f, -0.02303995f, -0.16234320f, -0.18187709f, -0.07376101f, -0.12594792f, 0.05997762f, -0.45535809f, 
    -0.12436237f, -0.04758523f, 0.27326110f, 0.24168973f, 0.04402816f, 0.09730213f, -0.05904262f, 0.06486037f, 
    -0.08559600f, 0.34443697f, 0.01911330f, 0.02519468f, -0.09389781f, -0.02359799f, 0.40261191f, 0.17749950f, 
    -0.08981668f, -0.08444424f, -0.12394351f, 0.11606782f, 0.12831815f, 0.45818976f, 0.42538577f, 0.03301205f, 
    0.29786924f, 0.02907374f, 0.13103510f, -0.14527822f, -0.04084022f, 0.10375015f, -0.24151210f, 0.23873134f, 
    0.03770979f, -0.28304324f, 0.24866927f, 0.06794012f, -0.01742656f, 0.25704476f, 0.11624423f, -0.25289130f, 
    -0.24068952f, -0.42356321f, -0.24634746f, -0.00897519f, 0.13151796f, -0.05067031f, 0.23376717f, 0.09383798f, 
    0.05196586f, 0.09525232f, 0.03980677f, 0.12373421f, 0.28788397f, 0.15394752f, 0.32919341f, 0.01187810f, 
    -0.05645441f, -0.08938719f, 0.01422931f, 0.18643855f, 0.23556767f, -0.11741593f, 0.23055740f, -0.00551748f, 
    -0.05801372f, -0.13875715f, 0.25056753f, -0.00016730f, 0.05625432f, -0.03729208f, -0.11247534f, -0.38460013f, 
    -0.01263613f, 0.37155953f, 0.11855622f, -0.03345706f, 0.00429735f, 0.13522494f, 0.17324241f, 0.02936429f, 
    -0.13220426f, -0.08502022f, -0.45019573f, -0.06502865f, 0.46693403f, -0.19731013f, 0.33225724f, 0.04778246f, 
    0.26058003f, -0.00703774f, 0.02260184f, -0.26133180f, -0.23748635f, -0.28624612f, -0.28266725f, 0.03827037f, 
    0.07325803f, -0.00082829f, -0.08559225f, 0.11353034f, -0.11154326f, 0.37796962f, -0.01294203f, -0.02278454f, 
    0.07768142f, -0.00448453f, 0.01724016f, -0.04186208f, 0.09151647f, 0.06650516f, 0.31811243f, -0.12696514f, 
    -0.03024238f, -0.14265347f, -0.07758160f, -0.04732723f, 0.07131950f, -0.09305135f, 0.08716817f, 0.09532069f, 
    0.01297911f, 0.06372546f, -0.01949814f, -0.09088162f, -0.11942178f, -0.10889265f, -0.13425052f, -0.14281568f, 
    -0.13164280f, -0.06684783f, -0.13148560f, -0.05975278f, -0.06898390f, -0.06888312f, 0.02028839f, 0.01570687f, 
    -0.05293253f, -0.13932428f, -0.00362673f, 0.07187469f, 0.10155691f, -0.04591982f, -0.02016140f, 0.08880232f, 
    -0.03108530f, -0.11700641f, -0.10572277f, 0.07990344f, -0.06941565f, 0.08668105f, 0.09157161f, 0.04908863f, 
    0.01560369f, 0.00735514f, 0.00174168f, 0.02954809f, -0.03105190f, -0.02572566f, -0.09882087f, 0.01456213f, 
    0.08404670f, -0.11891763f, -0.11033012f, 0.02624924f, -0.01790258f, -0.09775731f, 0.08838130f, -0.04496258f, 
    0.08807753f, -0.08984997f, 0.01024715f, -0.04736683f, -0.03185133f, 0.03855395f, 0.01391642f, -0.10356537f, 
    0.01131887f, -0.01905676f, 0.05899980f, 0.00248386f, 0.00548245f, -0.07990655f, 0.07043956f, -0.02904047f, 
    -0.00737593f, -0.06789219f, -0.01257480f, -0.02481113f, -0.05453361f, -0.10400467f, -0.07355514f, -0.03319754f, 
    -0.10412249f, -0.11402690f, -0.05910499f, -0.11341151f, -0.10381644f, -0.10080386f, -0.04660420f, -0.01238587f, 
    0.03012885f, 0.02054567f, -0.00336419f, -0.04726397f, -0.01196039f, -0.09721078f, -0.03770499f, 0.01276247f, 
    0.10801497f, -0.09910449f, 0.03198730f, 0.09352213f, -0.01655585f, 0.07892413f, -0.03894683f, 0.04834267f, 
    -0.12186447f, -0.02459258f, 0.05439454f, 0.04378851f, -0.05124030f, -0.03174202f, -0.01968171f, 0.03948074f, 
    0.09376006f, 0.04510135f, -0.05020668f, 0.09438834f, 0.01432797f, 0.05026287f, -0.02902016f, 0.02745883f, 
    0.06459688f, 0.10941240f, -0.08555693f, -0.03426366f, 0.03287568f, 0.05030217f, 0.01902104f, 0.04310676f, 
    0.12357754f, -0.12165961f, -0.09257390f, -0.02622302f, 0.00391270f, 0.05189674f, -0.11081545f, 0.05700590f, 
    -0.10249840f, -0.12446558f, -0.04613022f, -0.03396245f, -0.00530838f, 0.10807508f, 0.03186367f, -0.10208285f, 
    0.00708348f, -0.14894964f, 0.08963797f, -0.05442371f, -0.12157188f, 0.03318457f, -0.12006564f, 0.03265475f, 
    0.10694964f, -0.04993195f, -0.02443704f, -0.14475894f, -0.04595502f, -0.05346843f, -0.06931686f, 0.10558165f, 
    0.00536166f, -0.09474386f, 0.01082147f, 0.08195557f, -0.06992956f, -0.03820185f, 0.00282996f, -0.10370798f, 
    0.05695242f, -0.07267904f, -0.12414983f, -0.04512230f, -0.00123912f, 0.09655651f, -0.08258218f, 0.04469143f, 
    -0.06059578f, 0.06401417f, 0.05230562f, -0.09517674f, 0.01218764f, 0.04612491f, 0.04809286f, -0.02425915f, 
    0.02563019f, 0.07083727f, -0.05987450f, -0.01835009f, -0.16702525f, -0.10585168f, 0.06268133f, -0.06485302f, 
    -0.13687798f, -0.01302440f, -0.10446981f, 0.01110843f, 0.03105932f, 0.03506955f, -0.10166209f, 0.05820854f, 
    -0.02187019f, -0.12350710f, 0.18836156f, -0.22501414f, 0.00976888f, 0.09152428f, -0.12870230f, 0.04378306f, 
    0.19882885f, -0.09423374f, -0.03930860f, -0.05521281f, 0.01703627f, -0.14845048f, 0.11577036f, -0.04406874f, 
    0.10196061f, -0.05287170f, 0.02385944f, 0.00240833f, 0.01235090f, 0.09251985f, -0.27003527f, 0.13798010f, 
    0.00568668f, 0.03108991f, 0.25877318f, -0.00607302f, -0.11051384f, 0.12745851f, -0.18836810f, -0.05511361f, 
    0.06467681f, -0.08013660f, -0.13075520f, -0.03786900f, 0.00869559f, 0.03859957f, 0.23755600f, 0.04300753f, 
    0.07738236f, -0.20828786f, -0.12085692f, 0.01764193f, 0.17411567f, -0.15507962f, 0.06026838f, -0.17453039f, 
    0.48688218f, 0.08061817f, -0.05321990f, -0.13868274f, 0.21532626f, 0.13432552f, 0.00850764f, -0.02306399f, 
    -0.03384186f, -0.05677465f, 0.23361073f, -0.10325614f, 0.10372804f, 0.09150369f, 0.02929788f, -0.02579553f, 
    -0.00503081f, 0.03374304f, -0.07939976f, 0.06572557f, -0.08284195f, -0.11762288f, -0.02593502f, 0.09640173f, 
    -0.02228881f, -0.09810220f, 0.04771104f, 0.09358976f, -0.11596886f, 0.00933753f, -0.02365100f, -0.08852284f, 
    -0.03218207f, -0.09017154f, 0.01063612f, -0.00389387f, -0.01048884f, 0.10942546f, 0.09473700f, -0.14667010f, 
    0.07178986f, -0.08559315f, -0.13211361f, 0.07916936f, -0.12402443f, -0.01648017f, 0.09939441f, -0.07621269f, 
    -0.07896435f, -0.13006487f, -0.07805264f, -0.05960652f, -0.08155334f, 0.01698304f, 0.11321103f, -0.05414751f, 
    -0.00057837f, 0.02794338f, -0.13508630f, -0.10604811f, 0.08200189f, 0.00543411f, 0.03154682f, -0.10490899f, 
    -0.07602833f, -0.09377639f, 0.00175572f, 0.10919006f, -0.02526391f, -0.02148870f, -0.03451176f, 0.11242283f, 
    -0.08015895f, -0.02064608f, -0.04227496f, 0.02469549f, -0.04709596f, -0.10824179f, 0.09431751f, -0.01251833f, 
    -0.12165421f, 0.01361548f, 0.13476603f, 0.05090594f, -0.12378903f, -0.08186813f, -0.17194508f, 0.26596403f, 
    -0.19670470f, 0.16942814f, -0.22714987f, 0.36169359f, -0.00008157f, 0.21184768f, -0.09762438f, 0.06227947f, 
    0.09278328f, -0.14099796f, -0.06701387f, 0.35037369f, 0.12255114f, 0.03983708f, 0.03768589f, 0.38926396f, 
    0.03693058f, 0.03838495f, -0.07140459f, 0.14896786f, 0.27412114f, -0.16521807f, 0.08887506f, 0.01800783f, 
    0.01963443f, 0.16749711f, 0.08231315f, -0.04875296f, 0.25526986f, 0.19006936f, 0.27272484f, 0.14391570f, 
    -0.19560553f, 0.08889595f, -0.12461403f, -0.11997177f, 0.18147387f, 0.13188776f, -0.12404308f, 0.27747709f, 
    -0.40624765f, -0.15262033f, 0.17685549f, -0.03015567f, -0.08829391f, -0.13565087f, 0.14290389f, 0.22948746f, 
    0.07793369f, -0.10137691f, 0.29814628f, -0.01111949f, 0.29559821f, -0.02812403f, -0.14335784f, 0.00411596f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05968450f, 0.01187357f, 0.07934652f, -0.03976696f, 0.05627575f, -0.05603634f, 0.16282649f, 0.06416486f, 
    0.10505646f, 0.03834682f, -0.09616677f, 0.24949709f, -0.00826999f, -0.04979721f, -0.09849991f, 0.01032356f, 
    0.02596590f, 0.03158866f, 0.09682214f, -0.10410886f, -0.06400333f, -0.01392407f, -0.07879471f, 0.04335267f, 
    -0.01728406f, 0.02094858f, 0.05873384f, 0.05266717f, -0.02527238f, 0.03671830f, 0.09598172f, 0.14528990f, 
    0.18003500f, -0.08370041f, -0.08151997f, 0.22098598f, 0.07370644f, -0.09426117f, 0.12663858f, -0.08276282f, 
    0.09079194f, -0.13137758f, -0.08109797f, 0.03582055f, -0.05391654f, 0.11611532f, 0.04870289f, -0.04651031f, 
    0.13020137f, -0.13258021f, 0.10963766f, 0.06677402f, 0.19384088f, -0.12231142f, 0.14072077f, 0.11839977f, 
    0.13870329f, 0.04430242f, -0.10342708f, 0.00428354f, -0.05526879f, -0.04923939f, -0.11598879f, 0.16574496f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.40405101f, -0.01828911f, 0.00900756f, -0.25957623f, -0.54630542f, -0.26800710f, 0.01770252f, 0.52841544f, 
    0.33558601f, 0.05987974f, -0.21000847f, -0.28467745f, 0.08497807f, 0.04463103f, -0.10768345f, 0.11808964f, 
    -0.44610971f, -0.10467408f, 0.14280626f, 0.17308727f, -0.03725769f, -0.06573369f, -0.45561215f, -0.22327793f, 
    0.00120953f, -0.01586448f, -0.30459011f, 0.17556249f, -0.39882797f, -0.14971671f, 0.02211518f, 0.17303322f, 
    -0.35803232f, 0.15078990f, -0.01801537f, -0.01779684f, -0.04856529f, -0.13549072f, -0.14115158f, 0.07180332f, 
    -0.11300053f, 0.05294051f, 0.05134883f, 0.10960235f, 0.00955282f, -0.13359340f, 0.17716567f, 0.07272524f, 
    -0.04940080f, 0.08547009f, -0.09101739f, -0.31054384f, 0.00084615f, -0.07697225f, -0.50602251f, 0.20086105f, 
    0.22562861f, -0.41663960f, 0.01203437f, -0.10297947f, 0.02651087f, 0.25883707f, -0.10846954f, -0.36271256f, 
    0.16256770f, 0.03760905f, -0.07661581f, -0.09196495f, 0.19785166f, 0.18186900f, -0.01059805f, 0.08339584f, 
    0.07095789f, -0.00008530f, -0.07414558f, -0.10104015f, -0.03398808f, 0.04092805f, 0.09689531f, -0.06574670f, 
    0.15718852f, 0.04906335f, 0.03001350f, -0.04501693f, -0.01237816f, 0.11150952f, -0.05664157f, -0.27240759f, 
    -0.09034577f, -0.01226323f, -0.31279823f, -0.10098037f, 0.07334618f, 0.18073885f, 0.13788857f, 0.14864026f, 
    -0.06762569f, 0.14954290f, -0.10383385f, 0.17818323f, 0.22659202f, 0.08161525f, 0.23543207f, 0.05274640f, 
    -0.09461798f, -0.11990595f, -0.06748419f, -0.04229987f, -0.45086664f, -0.27129322f, -0.29364866f, -0.33721104f, 
    -0.36268356f, -0.10433063f, -0.05709728f, -0.24123059f, 0.12168612f, 0.10254867f, -0.01331848f, -0.04292762f, 
    0.13176794f, 0.50127846f, -0.05279518f, -0.02546144f, -0.01339459f, -0.14777797f, 0.02718578f, -0.31198704f, 
    -0.22805487f, -0.16542521f, 0.06616770f, -0.24381271f, -0.28437111f, 0.16903602f, 0.20928518f, -0.05783324f, 
    -0.28239280f, -0.31178436f, -0.10863326f, 0.08336454f, 0.07474465f, -0.26374456f, 0.02526805f, -0.07271729f, 
    -0.14278930f, -0.06050435f, -0.09369025f, 0.17064673f, 0.13451479f, 0.23453611f, 0.08925303f, -0.25950763f, 
    0.01787219f, -0.25221783f, -0.39423513f, 0.05311476f, -0.02043906f, 0.18033341f, 0.23541577f, -0.42065224f, 
    -0.40001309f, -0.12089276f, 0.01601487f, 0.15436032f, -0.04147145f, -0.08361768f, -0.30689254f, 0.15305731f, 
    -0.03041678f, -0.05989395f, -0.02192678f, 0.09780138f, 0.09579215f, -0.04344347f, -0.06025932f, 0.06729358f, 
    -0.04934881f, 0.00844484f, 0.11575969f, 0.24255580f, 0.18345104f, 0.29418665f, -0.36232227f, 0.09334295f, 
    -0.15613545f, -0.07223161f, 0.03661129f, 0.07467534f, -0.03710756f, 0.18704166f, -0.01936306f, -0.41911700f, 
    0.13644767f, 0.19008207f, -0.43585286f, -0.32523608f, -0.21856804f, 0.18799615f, 0.17715721f, -0.31031293f, 
    0.06060543f, 0.25828686f, -0.42654723f, 0.16626182f, -0.06421234f, 0.02860972f, -0.01006991f, 0.01036513f, 
    0.43587944f, 0.01571116f, 0.29174766f, -0.02724447f, -0.07321014f, -0.55315125f, -0.50935382f, 0.18851772f, 
    -0.00403124f, -0.06566486f, -0.09130272f, -0.04419703f, -0.12775338f, -0.28304222f, 0.23468553f, -0.02635136f, 
    0.07174799f, -0.14232248f, 0.02555021f, 0.19616713f, 0.12379448f, 0.08354004f, 0.04737588f, -0.54634076f, 
    -0.01364543f, -0.10083621f, -0.02889140f, 0.14739653f, -0.03432203f, 0.27408791f, -0.19987440f, 0.15780188f, 
    0.17685243f, -0.04406748f, -0.10612781f, -0.12918265f, -0.51826602f, -0.50686914f, 0.09573778f, -0.38957828f, 
    -0.39620355f, -0.24623236f, -0.09383438f, -0.04929329f, -0.03234165f, -0.16593282f, -0.02411426f, -0.01126305f, 
    -0.10232310f, 0.02632374f, 0.22452532f, 0.17099732f, 0.19085391f, -0.16093293f, 0.01300622f, 0.16735145f, 
    -0.35987377f, 0.19033337f, -0.27984479f, 0.07213690f, -0.06468966f, 0.28362703f, 0.10740845f, -0.01444884f, 
    -0.12890439f, 0.06441654f, 0.25538772f, -0.02075656f, 0.03304820f, -0.21716371f, 0.36609235f, 0.17627588f, 
    -0.07762377f, 0.05201017f, 0.29055831f, -0.01672751f, 0.03691477f, 0.09972636f, -0.11617950f, 0.04388469f, 
    -0.05699280f, 0.16372021f, -0.06109699f, 0.02132650f, -0.12798569f, 0.08589607f, 0.00203348f, -0.21607414f, 
    -0.01628534f, 0.01488029f, -0.02419681f, 0.01194711f, -0.19971707f, 0.14533402f, 0.07068913f, -0.11617060f, 
    -0.05371777f, -0.03840380f, -0.09225187f, 0.27186492f, -0.07781078f, 0.01582771f, -0.30365986f, -0.09414659f, 
    -0.15813613f, -0.75016063f, -0.04007342f, 0.09135007f, -0.05784464f, 0.19935520f, 0.00758183f, 0.09845187f, 
    -0.00260030f, 0.18437423f, 0.18514223f, -0.45245799f, -0.27598414f, -0.36184639f, -0.31760550f, -0.26435363f, 
    0.10410471f, -0.21931703f, 0.05762108f, -0.25862253f, -0.08823199f, 0.26319396f, 0.05447483f, -0.10715578f, 
    0.15856996f, -0.04007969f, -0.10154496f, -0.24941733f, 0.04325175f, -0.05466923f, -0.16477869f, -0.15657064f, 
    -0.03718908f, 0.13692676f, 0.09970310f, -0.04998898f, -0.63436902f, -0.04739475f, -0.10835886f, -0.08439717f, 
    0.35292274f, 0.17256090f, 0.07395758f, -0.10854482f, 0.20483424f, 0.09497945f, 0.00860684f, -0.30071190f, 
    0.03829581f, -0.08781392f, -0.04359644f, -0.10501046f, 0.19953741f, -0.19406964f, 0.22721621f, -0.18031749f, 
    0.18399277f, -0.10169370f, -0.01002594f, 0.04565344f, 0.16832474f, -0.21286443f, 0.12045467f, 0.12360267f, 
    0.19583416f, 0.24011512f, -0.06568231f, -0.08527460f, -0.05384911f, -0.37074798f, -0.11917486f, -0.00808071f, 
    0.23908000f, 0.00728856f, 0.07038960f, -0.72261298f, -0.62084830f, -0.08730157f, -0.33052662f, -0.45577496f, 
    -0.26526397f, -0.15902863f, 0.24795337f, 0.13461427f, 0.06415433f, -0.00083594f, 0.07066546f, 0.07853386f, 
    -0.05701528f, 0.07528606f, 0.07848027f, -0.51389694f, -0.12410493f, 0.10962169f, -0.35103819f, -0.18309934f, 
    0.00173438f, 0.01760587f, -0.22300877f, 0.22031535f, -0.02428818f, 0.15079278f, -0.48389032f, 0.15608376f, 
    -0.15664557f, -0.35343897f, -0.06486626f, -0.10649511f, -0.33003503f, 0.01003973f, 0.21230794f, 0.21082449f, 
    -0.12607013f, -0.07306351f, 0.01845903f, -0.20607020f, 0.08863350f, 0.15520877f, 0.17850769f, 0.03940055f, 
    0.08550374f, -0.04830573f, -0.04824885f, -0.59803385f, 0.10643810f, 0.27754995f, -0.36005887f, 0.07811220f, 
    0.04209208f, -0.02549907f, 0.02491508f, 0.03977425f, 0.05274858f, 0.17103234f, 0.08515944f, 0.26532134f, 
    -0.18165100f, -0.32698062f, -0.22046006f, 0.55445004f, 0.41763115f, 0.12914144f, 0.09050632f, 0.04245152f, 
    -0.04883390f, 0.21138528f, 0.06052352f, -0.30884805f, -0.06562623f, -0.04863852f, -0.05766156f, 0.10097778f, 
    0.02646253f, -0.12784232f, 0.12214792f, 0.13022576f, 0.07319269f, 0.05879204f, 0.32295835f, 0.11609272f, 
    0.05602115f, -0.11291622f, -0.32427853f, -0.05666141f, 0.11623180f, -0.25234801f, 0.21576948f, -0.43457580f, 
    -0.26749951f, -0.18812272f, -0.05211028f, -0.57281142f, 0.00905661f, -0.03885146f, -0.31168911f, 0.15728702f, 
    0.10799589f, 0.09266891f, 0.08292333f, -0.19688039f, 0.21171497f, 0.14676701f, -0.02297501f, 0.08444776f, 
    -0.04280725f, -0.10878626f, 0.07647713f, -0.06081724f, -0.23762450f, 0.06277218f, 0.24207248f, 0.15981212f, 
    -0.46223605f, 0.01272097f, -0.04397496f, 0.01338141f, 0.02259194f, -0.02220769f, -0.11038125f, 0.15368159f, 
    0.01727477f, 0.18910004f, 0.08041108f, -0.06492935f, 0.04492599f, 0.13716559f, -0.51159990f, -0.00510298f, 
    0.09680058f, -0.22046596f, 0.29336831f, -0.31416872f, -0.12011380f, -0.29888615f, 0.02742682f, -0.02033608f, 
    -0.04583344f, -0.07628775f, 0.06613068f, 0.26923454f, -0.06794485f, 0.07358646f, 0.34689152f, -0.02547575f, 
    0.09704201f, -0.43461946f, 0.01959971f, -0.08216222f, -0.07134990f, 0.15125622f, 0.12445493f, -0.10512023f, 
    0.07270540f, 0.06832802f, -0.09236321f, -0.31396574f, 0.09305732f, -0.04219094f, 0.07880513f, 0.03818862f, 
    0.06299815f, -0.04341334f, 0.14243312f, 0.22888170f, -0.00200961f, -0.40573978f, -0.31123170f, -0.33429652f, 
    -0.13381132f, -0.08066256f, 0.01661380f, 0.28788340f, -0.10063510f, -0.18997504f, 0.29616708f, 0.07268570f, 
    -0.35081819f, -0.36888075f, -0.04212864f, -0.07243948f, 0.06322727f, -0.09183434f, -0.03822634f, -0.19109274f, 
    -0.05578369f, -0.01256591f, 0.15962549f, -0.36018813f, 0.04946239f, -0.19623597f, 0.07359349f, -0.37402102f, 
    -0.42039976f, 0.18263330f, 0.13739058f, -0.17205279f, -0.01915986f, -0.13695890f, -0.02160685f, -0.00751726f, 
    -0.32724410f, -0.03206629f, -0.55518872f, 0.23520668f, -0.01323343f, 0.12708950f, -0.03994230f, 0.06596401f, 
    -0.09191605f, 0.19445777f, 0.17467873f, 0.08761984f, 0.32868651f, -0.02517889f, -0.21563618f, -0.32181746f, 
    -0.20664991f, -0.11538692f, 0.00612906f, 0.16921696f, -0.43408969f, 0.09868553f, -0.32955983f, 0.11270155f, 
    0.05411323f, -0.08213133f, 0.02272976f, -0.32810390f, 0.10881727f, -0.09479295f, 0.19478771f, 0.17015055f, 
    -0.37256703f, -0.01149249f, 0.09379327f, 0.09439696f, 0.19745271f, 0.04656602f, 0.18659285f, -0.06739017f, 
    0.19771993f, -0.20777325f, 0.10252611f, 0.06380048f, 0.08428964f, -0.15800975f, -0.12617289f, 0.17482457f, 
    -0.34748811f, -0.04035022f, -0.50154787f, 0.54560155f, 0.05820396f, 0.18081319f, 0.13797909f, -0.01498340f, 
    0.00862558f, -0.15514877f, -0.21803376f, 0.33876786f, -0.11376549f, -0.05517190f, -0.11712171f, -0.00848352f, 
    -0.39235622f, -0.08862324f, -0.01877622f, -0.21422520f, -0.09530672f, 0.12510125f, 0.13000453f, 0.23754460f, 
    0.10703585f, -0.37939209f, -0.12156615f, -0.76296759f, 0.32914209f, -0.18245409f, -0.10984576f, -0.11570473f, 
    -0.13268353f, -0.02991456f, 0.07284441f, 0.18948275f, 0.20037732f, -0.04706399f, -0.01655625f, 0.30859542f, 
    0.06743076f, 0.04504463f, -0.05044321f, 0.05240526f, 0.14361592f, 0.03573599f, -0.28970513f, -0.08996955f, 
    0.18009803f, 0.04591462f, 0.08620100f, 0.14988674f, 0.23088412f, -0.36719722f, 0.07904048f, -0.01931725f, 
    0.22997156f, -0.26232669f, 0.08045257f, 0.02853068f, 0.01274181f, -0.34181899f, 0.06316438f, 0.15724190f, 
    0.36720926f, -0.24019867f, 0.07865336f, -0.25122917f, -0.24659728f, 0.07668804f, -0.23984596f, -0.05933043f, 
    0.29077449f, -0.04149734f, 0.06129174f, 0.20020047f, -0.12322177f, -0.35965291f, 0.12383075f, 0.08673152f, 
    -0.13909614f, 0.07764490f, -0.11450949f, -0.40406999f, 0.07620538f, -0.20587382f, -0.25416487f, -0.12158210f, 
    0.05344004f, 0.03177746f, 0.27572817f, 0.15928309f, 0.00174714f, -0.11868081f, -0.17246625f, 0.18870620f, 
    0.16069044f, -0.23766537f, 0.03782252f, -0.10376567f, 0.21792220f, -0.06746866f, -0.07939134f, -0.18708913f, 
    -0.03924000f, 0.08734347f, 0.04251577f, 0.12539968f, -0.06551771f, 0.02710083f, -0.34568590f, 0.18962894f, 
    -0.07177048f, 0.10048524f, 0.05650435f, 0.13478807f, 0.01012867f, 0.18250225f, 0.21270318f, -0.65851611f, 
    0.11988658f, -0.15695503f, 0.15942135f, 0.01070576f, -0.12488195f, 0.24001487f, -0.10043366f, 0.17870504f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.09577397f, -0.09705872f, -0.02817128f, -0.02147015f, 0.06050563f, -0.05230848f, -0.09494761f, -0.02457660f, 
    0.06877650f, 0.00085963f, 0.15507272f, -0.00436102f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
