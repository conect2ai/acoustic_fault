#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.21779457f, -0.07496928f, -0.44980350f, -0.44745779f, -0.32650119f, -0.62376785f, 0.54876429f, 0.74651873f, 
    -0.33401132f, -1.00976372f, -0.64797294f, 0.07618466f, -0.37908831f, -0.49192837f, -0.10235462f, -0.00598289f, 
    -0.20345330f, -0.30930349f, 1.02358007f, -0.11296792f, 0.20025319f, 0.23265235f, 0.01665746f, -0.18243769f, 
    0.04323752f, -0.14736538f, 0.75629109f, 0.48176154f, -0.03193784f, 0.75068611f, -0.57052475f, 0.06888046f, 
    -0.60137475f, 0.53975320f, 0.24450219f, 0.11040924f, -0.78328562f, -0.27180073f, 1.10126591f, -0.26207903f, 
    -0.34249339f, 0.54156232f, -0.12537462f, 0.12429890f, -0.43916035f, 0.60349947f, -0.17609477f, -0.43525702f, 
    -0.21744326f, -0.52557975f, -0.79102576f, -0.50138968f, -0.39997098f, -0.35922790f, -0.44364229f, -0.69615686f, 
    -0.55932641f, 0.44346064f, 0.96917242f, 0.09026229f, -0.44695535f, -0.52127498f, -0.52283788f, -0.25427765f, 
    0.35195300f, 0.16128981f, 0.67632455f, 0.61933547f, 0.47178265f, 0.10671219f, 0.43243423f, -0.41994801f, 
    -0.09431281f, -0.35179394f, 0.03755691f, 0.88037270f, -0.14737479f, -0.30047584f, 0.23553801f, -0.16373786f, 
    -0.44071847f, -0.21705125f, -0.42252675f, -0.15673640f, -0.45660254f, -0.68197906f, -0.83916783f, 0.15011744f, 
    0.20603466f, 0.76550704f, 0.69386590f, -0.10254344f, 0.92738014f, 0.28873068f, -0.48756221f, 0.44104460f, 
    0.04073666f, -0.22925720f, -0.41756836f, 0.65753311f, -0.10314213f, 0.04748119f, -0.05044529f, -0.37252536f, 
    0.02879487f, 0.42031470f, 0.71696329f, -0.30648270f, -0.81968617f, -0.24638721f, -0.95014876f, -0.02103299f, 
    0.12932649f, 0.39864379f, -0.27218705f, 0.61602563f, 0.16496459f, 0.78490657f, -0.89580476f, -0.59270680f, 
    -0.43665707f, -0.50675422f, 0.39902487f, 0.17296109f, -0.10169216f, -0.16042472f, 0.11554709f, -0.07544328f, 
    0.05640353f, -0.57961845f, -0.32235083f, 0.82972145f, -0.39868218f, 0.01334055f, 0.51610559f, -0.09872394f, 
    0.40348232f, -0.10521945f, -0.40126985f, 0.57458389f, 0.67881483f, 0.14088675f, -0.55214590f, -0.67392218f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.30518407f, -0.43937409f, -0.21551870f, 0.24998747f, 0.20910616f, 0.05270211f, 0.07952508f, 0.31003919f, 
    0.37503359f, -0.07959177f, -0.00638328f, 0.42025283f, 0.50570798f, 0.04607023f, 0.26947299f, -0.26951003f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05677701f, -0.23901662f, -0.05906710f, 0.03337834f, -0.15985088f, 0.10413169f, 0.09497585f, -0.02228500f, 
    0.04515298f, 0.30510539f, -0.06246492f, 0.07311498f, -0.18381509f, -0.35279581f, -0.05559340f, 0.05789012f, 
    0.04343629f, 0.02789959f, 0.06303015f, 0.33237121f, 0.15390328f, 0.05376100f, 0.09520253f, -0.10663549f, 
    0.13810480f, -0.06770796f, -0.10294262f, -0.05949380f, 0.13339771f, 0.08582943f, -0.00762248f, -0.05943150f, 
    0.33430445f, 0.15190001f, 0.06776116f, 0.10726084f, -0.09665782f, 0.11942347f, 0.12284366f, 0.10330851f, 
    0.09882139f, 0.23420571f, 0.00686619f, 0.19903865f, 0.01249498f, -0.20898384f, -0.20030798f, 0.06581391f, 
    -0.07688004f, -0.05646793f, 0.21507598f, -0.12691011f, 0.10085490f, -0.09809643f, 0.56025618f, -0.09919250f, 
    -0.28156888f, -0.07276383f, -0.21643332f, -0.04574633f, -0.02626057f, -0.07987408f, -0.12409685f, 0.19075084f, 
    0.14079390f, 0.18405572f, -0.15941313f, 0.01697554f, -0.05471568f, -0.08720800f, -0.27721316f, -0.04808792f, 
    0.05285351f, -0.21377844f, 0.24916258f, -0.03350299f, 0.32565969f, -0.05854913f, 0.09373431f, -0.12151755f, 
    0.28193945f, 0.05839862f, 0.07435467f, 0.49763048f, -0.16809174f, -0.03210330f, -0.03467051f, -0.02590177f, 
    0.08952139f, 0.06556007f, 0.19455911f, -0.19147858f, 0.02246389f, -0.14037107f, 0.04118721f, -0.15306494f, 
    0.06249576f, 0.02378587f, -0.03580273f, -0.04439707f, -0.20293370f, 0.37632507f, -0.06369402f, 0.19168514f, 
    0.18547720f, 0.07598143f, 0.10952213f, 0.09598419f, 0.47361302f, -0.73869252f, -0.56074160f, 0.03152692f, 
    -0.07778783f, -0.09717650f, 0.04823078f, -0.02481088f, -0.11129657f, -0.30337551f, -0.46373397f, -0.25290099f, 
    0.09405234f, -0.09316532f, 0.20831202f, 0.01146079f, 0.00011012f, -0.06996880f, -0.16084290f, -0.03380323f, 
    -0.09520102f, 0.13424189f, 0.14755113f, 0.02421927f, 0.12057725f, 0.00924665f, 0.15326713f, 0.00601397f, 
    0.11816904f, 0.17617834f, -0.01762609f, -0.35185480f, -0.16836686f, -0.21774364f, 0.05654231f, -0.00521234f, 
    -0.36056498f, -0.92672175f, 0.12909727f, -0.00237388f, 0.18182755f, 0.21304409f, 0.20185375f, -0.08449012f, 
    0.08058756f, -0.06632637f, -0.50976866f, -0.62177271f, -0.06354541f, -0.11422760f, -0.08987402f, -0.23450038f, 
    -0.05061124f, 0.15885937f, 0.45547339f, 0.11022909f, 0.10689702f, -0.17895624f, -0.20458564f, -0.17882298f, 
    -0.07295197f, -0.09549414f, -0.03435061f, 0.48542216f, -0.32178664f, -0.04008937f, 0.08526277f, -0.00896265f, 
    0.04736838f, -0.11944812f, -0.04351173f, 0.11061302f, 0.17130151f, -0.15013659f, -0.31438038f, 0.14985858f, 
    -0.02953236f, -0.00077646f, 0.22118196f, 0.13366011f, 0.00986121f, -0.23477425f, -0.36860120f, -0.55596596f, 
    -0.02899097f, 0.06146944f, -0.03936281f, 0.00297967f, -0.09674715f, 0.15979704f, -0.42827523f, -0.31422290f, 
    -0.31256133f, 0.00580704f, 0.09740794f, -0.08224307f, -0.08642641f, 0.02842114f, 0.08158575f, -0.03611992f, 
    0.32901117f, 0.33513996f, -0.12841272f, 0.05035141f, -0.07560056f, 0.12115517f, -0.13127026f, -0.08550058f, 
    0.11157759f, -0.23022899f, 0.08249187f, 0.20509286f, -0.02840422f, 0.00455592f, 0.13610440f, 0.05022473f, 
    -0.03808032f, -0.76173341f, -0.23011553f, -0.35945046f, 0.08225717f, -0.09731561f, -0.08718463f, 0.10393806f, 
    -0.07463489f, -0.15721877f, 0.17111562f, 0.13700613f, -0.00715129f, 0.09677593f, 0.15115243f, 0.09651516f, 
    -0.11500302f, -0.11385562f, 0.13778009f, 0.27873078f, 0.16515161f, -0.15124562f, 0.17445131f, -0.05743938f, 
    0.16209105f, 0.06259841f, -0.13658756f, 0.18786423f, -0.36774939f, 0.12848152f, 0.03180760f, 0.24239504f, 
    0.21903558f, 0.12034962f, 0.09341515f, -0.00827186f, 0.00731664f, 0.29617560f, 0.08380588f, -0.92931372f, 
    -0.08511562f, 0.13789906f, 0.04014565f, 0.07947593f, -0.04347133f, -0.07924339f, 0.25747928f, 0.13786425f, 
    0.03326255f, -0.17811696f, 0.01706769f, 0.08750224f, 0.03478867f, -0.03699184f, 0.06216411f, -0.24049914f, 
    0.28358263f, -0.00556235f, -0.13693953f, -0.03209501f, -0.02324409f, 0.21136478f, -0.06360746f, 0.08650088f, 
    -0.07090405f, 0.12413204f, 0.34361792f, -0.07875758f, 0.10872441f, 0.12327834f, 0.02629136f, 0.18647197f, 
    0.14432152f, -0.07000235f, -0.27331161f, 0.03047277f, -0.03587581f, -0.06668571f, -0.00766028f, -0.05963641f, 
    0.05487467f, 0.14775640f, -0.28342301f, 0.01494437f, 0.02489144f, 0.12201072f, -0.13643572f, -0.01141929f, 
    0.05905220f, 0.16513386f, 0.17571497f, -0.16082989f, 0.04009366f, 0.03768200f, -0.05391512f, 0.15098976f, 
    -0.01830751f, 0.15152083f, 0.22304928f, 0.19781268f, 0.21182375f, 0.00142775f, -0.12690985f, -0.13354437f, 
    -0.00161173f, -0.08684383f, -0.15876859f, 0.08132858f, 0.07119085f, 0.16254580f, -0.10511980f, 0.23013203f, 
    0.21702088f, 0.03537042f, 0.19281371f, -0.13866583f, 0.02526765f, -0.16801164f, -0.13297126f, 0.29377428f, 
    0.11789954f, 0.02538833f, -0.15055788f, -0.09191157f, -0.06303450f, -0.11066316f, -0.24295937f, -0.07148468f, 
    -0.19053726f, -0.08570766f, 0.08537845f, 0.26842225f, 0.01862349f, -0.12936781f, -0.02866837f, -0.07865900f, 
    -0.00681978f, -0.11316183f, 0.11681740f, 0.06410333f, -0.01932280f, -0.05246055f, -0.05008893f, -0.10274430f, 
    -0.03657418f, 0.03048201f, 0.07726192f, 0.34338850f, 0.13486345f, 0.05962187f, 0.08696244f, 0.04621268f, 
    0.14276357f, 0.22511448f, -0.39600897f, -0.18996184f, 0.03397054f, 0.00001993f, -0.18797715f, 0.00774163f, 
    -0.01395548f, 0.08611471f, -0.12721759f, -0.20879382f, -0.07451401f, -0.04581497f, -0.17507428f, 0.02263184f, 
    0.15873431f, 0.12448658f, 0.28335005f, 0.10076433f, -0.02189071f, 0.10471912f, 0.24244602f, -0.09980078f, 
    -0.31236467f, 0.04873017f, 0.03095466f, -0.06171555f, 0.21728086f, 0.02397829f, 0.13751790f, 0.39582190f, 
    0.30947307f, -0.01476914f, 0.18904930f, -0.14969881f, -0.10461642f, -0.17511681f, 0.32293653f, -0.17520966f, 
    -0.23635167f, 0.00888587f, 0.23779422f, 0.23809534f, -0.04199412f, -0.28223768f, -0.02917427f, -0.17208759f, 
    -0.12116566f, -0.29177877f, 0.21530576f, -0.17929110f, 0.15501653f, -0.28906581f, -0.15204762f, -0.43413126f, 
    -0.24897388f, 0.19570413f, -0.03111668f, -0.25478593f, 0.02432655f, -0.12704131f, 0.01221753f, 0.23258580f, 
    0.01029016f, -0.59330124f, -0.07370867f, 0.10532770f, -0.12357450f, 0.15570056f, 0.06121329f, -0.09386378f, 
    0.04085943f, -0.16322035f, 0.05707576f, 0.12882677f, -0.29186112f, -0.05518430f, -0.08187475f, -0.19755849f, 
    0.07335579f, 0.08974682f, 0.17094791f, 0.09422141f, 0.01427979f, -0.05621431f, 0.13985617f, 0.10228247f, 
    -0.01285375f, 0.12275872f, 0.13338064f, 0.21645211f, -0.01481378f, -0.31314182f, 0.09852746f, 0.13841173f, 
    0.09526564f, 0.18186985f, -0.05449408f, -0.15646514f, -0.01182365f, -0.05789673f, -0.11943745f, -0.16085652f, 
    0.05231659f, 0.10025608f, 0.08542655f, 0.01477416f, -0.07040777f, -0.23791128f, -0.23995614f, -0.15715678f, 
    0.27259079f, 0.09303683f, 0.13921891f, -0.06185388f, -0.30877066f, -0.30311358f, -0.17605597f, -0.06490876f, 
    0.17436735f, -0.11396369f, 0.16256596f, 0.07378835f, 0.10587361f, -0.03161760f, 0.18823372f, -0.03098199f, 
    -0.08209438f, 0.32244900f, 0.15229198f, 0.03148435f, 0.06402823f, 0.24288617f, 0.06245664f, 0.15467902f, 
    -0.18509203f, -0.01926617f, 0.12911245f, -0.25258648f, -0.08038755f, 0.17790030f, 0.03309394f, 0.19040954f, 
    0.01951470f, 0.03342316f, -0.06240831f, -0.16092628f, -0.37739208f, -0.15254542f, -0.16057868f, 0.10674883f, 
    -0.16029243f, 0.05549593f, -0.44253355f, 0.03881510f, 0.08004658f, 0.18905875f, 0.15141322f, 0.01088057f, 
    0.07253587f, 0.18974735f, 0.16693622f, 0.19411391f, -0.13801086f, 0.10157135f, -0.01120327f, 0.17574686f, 
    -0.08673420f, 0.00534183f, -0.02097915f, -0.12674679f, 0.03575241f, -0.07548229f, -0.03934835f, -0.10304347f, 
    0.15535648f, -0.11215481f, 0.00729007f, -0.13030769f, 0.14784144f, 0.08910373f, 0.34944937f, 0.13650389f, 
    0.10947090f, 0.25681376f, 0.04659815f, 0.47584167f, 0.15019394f, 0.11173768f, 0.11040312f, -0.03546501f, 
    -0.13582487f, -0.17856766f, -0.05890175f, -0.09649219f, 0.11602170f, -0.02368739f, -0.12797152f, 0.03907783f, 
    0.00488467f, 0.07374050f, -0.06162666f, -0.10184824f, 0.19307491f, -0.04153213f, -0.00379019f, 0.06905491f, 
    0.11802497f, -0.12785375f, -0.04762802f, 0.19271056f, -0.01696739f, 0.01364098f, 0.08063194f, -0.03496762f, 
    0.09523412f, 0.06071309f, -0.12985092f, -0.04905545f, 0.46912864f, -0.06560103f, 0.13264780f, 0.00654651f, 
    0.12918152f, -0.31361988f, 0.33416644f, -0.04439740f, 0.43214849f, 0.05604026f, -0.04086006f, 0.07960516f, 
    -0.05001272f, -0.02796103f, 0.22070298f, 0.01583649f, -0.11721209f, 0.38516974f, 0.30475333f, -0.21503243f, 
    0.10227486f, -0.01286128f, -0.04712209f, -0.00847106f, -0.25188276f, 0.17839091f, 0.05550832f, 0.17521566f, 
    0.05761608f, 0.02865748f, 0.06022308f, -0.04651424f, 0.01010276f, -0.36463240f, 0.03535367f, -0.29164112f, 
    -0.15579168f, -0.03187900f, -0.08612935f, -0.07019626f, -0.17634219f, -0.13301678f, -0.23060982f, 0.22787113f, 
    0.09147799f, 0.10163016f, -0.17552021f, 0.11893813f, 0.03125957f, -0.08775572f, 0.01886214f, -0.14601858f, 
    0.14056653f, -0.08698461f, -0.13554986f, 0.14609350f, -0.01422828f, 0.04884609f, -0.24448439f, -0.23111627f, 
    0.12342965f, 0.18772879f, 0.19141248f, 0.08771166f, 0.09807710f, -0.11884946f, 0.01836487f, 0.19880147f, 
    -0.22034626f, 0.17520398f, -0.14233571f, 0.10621493f, 0.17902230f, -0.04283431f, 0.07179571f, 0.09220500f, 
    -0.25948703f, -0.18459761f, -0.02934335f, 0.12689410f, 0.13741270f, -0.01173957f, -0.15843511f, 0.16521251f, 
    -0.15164879f, 0.03939791f, 0.19800319f, 0.12308718f, -0.08263960f, -0.17443322f, 0.01759642f, -0.09534867f, 
    -0.09078299f, -0.15148133f, 0.17229737f, 0.05025855f, 0.17894442f, -0.13944788f, -0.27735716f, 0.23045446f, 
    -0.09592950f, -0.05526942f, 0.02750964f, -0.25469866f, 0.06192429f, -0.02323902f, -0.04758980f, -0.34786388f, 
    0.28120026f, -0.03657529f, 0.24188745f, -0.04264403f, 0.12927039f, -0.12270650f, 0.14332186f, 0.01424233f, 
    0.00372033f, 0.16716529f, 0.26129913f, -0.03332919f, 0.31214815f, -0.08061101f, 0.09618997f, -0.25567552f, 
    0.60923576f, 0.26429319f, 0.09511378f, 0.11338713f, 0.04305090f, 0.06749602f, 0.14848039f, 0.03377309f, 
    0.04655510f, 0.66120839f, 0.35304448f, -0.01696408f, 0.13050811f, -0.23136316f, -0.20309080f, -0.00989956f, 
    0.16869090f, 0.06126822f, 0.04235532f, 0.00838821f, -0.03147381f, 0.19236173f, 0.07658714f, -0.13783407f, 
    0.12232397f, -0.01125088f, 0.03679703f, -0.11306207f, -0.06310863f, 0.14298627f, 0.02161342f, 0.00336855f, 
    -0.07794698f, 0.22017641f, 0.05467078f, 0.03712651f, 0.20479712f, 0.06605300f, 0.06907279f, -0.11638618f, 
    -0.06549470f, -0.18891826f, 0.17349686f, -0.12861954f, 0.08843340f, -0.14933890f, 0.03850580f, 0.31760001f, 
    -0.15029112f, 0.10286175f, 0.11077074f, -0.03731913f, -0.12600712f, -0.19799548f, 0.41443425f, -0.13265543f, 
    -0.24950637f, -0.02326747f, -0.07564843f, 0.08466917f, -0.16301019f, 0.07663626f, 0.05985143f, 0.07490446f, 
    0.07236362f, -0.00070484f, -0.01154863f, -0.24749137f, -0.16500381f, 0.14997032f, 0.06879089f, 0.11651788f, 
    0.00492118f, 0.21365148f, -0.25479713f, 0.02376850f, 0.03852334f, 0.16582872f, -0.15950443f, 0.08444664f, 
    0.01517129f, 0.25211620f, 0.43962118f, 0.15019865f, -0.15706624f, -0.14917424f, -0.07979434f, 0.08584643f, 
    0.01153848f, -0.03781943f, -0.32163161f, -0.29587618f, -0.16236715f, 0.16643247f, -0.04392791f, -0.01721867f, 
    -0.00306842f, -0.10211477f, -0.02421308f, -0.05646686f, -0.10557823f, -0.11327492f, -0.07416671f, 0.02879538f, 
    -0.13849035f, 0.09316994f, 0.25965351f, 0.04629973f, -0.00306152f, -0.05598421f, -0.10755068f, 0.12031996f, 
    0.18144618f, 0.12299091f, -0.14945854f, 0.24065483f, -0.03359966f, -0.12906861f, 0.09268602f, -0.08133031f, 
    -0.11119737f, -0.01234736f, -0.19237871f, -0.19246012f, -0.08342724f, 0.05063204f, -0.33614016f, -0.14491762f, 
    -0.12313577f, 0.12079857f, 0.19338538f, -0.39084366f, 0.06522821f, 0.06987569f, -0.27750534f, 0.09068949f, 
    0.09662428f, 0.08347569f, -0.00516984f, -0.28836715f, 0.02232072f, -0.17396596f, -0.03032273f, 0.26408112f, 
    -0.10953970f, -0.72543573f, -0.55536211f, -0.23157848f, 0.03718985f, -0.09053155f, 0.13723896f, -0.11407645f, 
    -0.13448372f, -0.44080028f, -0.06281705f, -0.10534300f, -0.41141939f, -0.07196798f, -0.28458154f, -0.08420810f, 
    0.05438730f, 0.16752134f, 0.14095734f, 0.06138895f, 0.30628550f, -0.04853542f, -0.09511264f, -0.17275202f, 
    -0.02486188f, 0.06153880f, -0.05039395f, 0.10353182f, 0.02794804f, 0.27438352f, -0.00289057f, -0.00784560f, 
    0.06818061f, 0.07065843f, 0.19212803f, 0.27474672f, 0.08733342f, -0.09914667f, -0.05109277f, 0.02742073f, 
    -0.07934963f, 0.23569763f, -0.11605691f, -0.07096494f, 0.05706978f, -0.16723429f, -0.17226569f, 0.02853839f, 
    -0.12222952f, -0.00243188f, -0.02739199f, 0.05634740f, 0.01585690f, 0.17603718f, -0.18966010f, 0.15507221f, 
    -0.00701030f, -0.11071979f, -0.04342942f, 0.01726177f, -0.23012425f, -0.02765212f, -0.10989279f, -0.08939825f, 
    -0.30583340f, -0.01995355f, 0.15167962f, -0.00836330f, 0.12110808f, 0.03403753f, 0.17861111f, -0.03816774f, 
    0.18175372f, 0.18786082f, -0.07217132f, 0.16749142f, -0.00609047f, 0.02433211f, 0.24443246f, -0.08400112f, 
    0.05668179f, -0.73078924f, -0.34499386f, -0.41252932f, 0.27424377f, -0.13176045f, -0.14220549f, 0.16665648f, 
    0.05352981f, 0.08065817f, -0.09385115f, 0.10503251f, 0.19033334f, -0.16074719f, -0.15837465f, -0.00359851f, 
    -0.08805142f, -0.09891552f, 0.15681513f, 0.26576558f, -0.03499333f, -0.02950137f, -0.02331842f, -0.10278289f, 
    0.10521756f, 0.19491886f, 0.12592773f, 0.11409418f, -0.21611896f, 0.39520288f, 0.39012349f, 0.15481454f, 
    0.11862974f, 0.08480731f, 0.03497688f, -0.03368003f, -0.03060243f, 0.04376476f, 0.14604533f, -0.04065403f, 
    0.08502036f, -0.07660901f, -0.00540494f, 0.03520895f, -0.04590769f, 0.08193336f, 0.15530667f, -0.21237607f, 
    0.27064297f, 0.09131905f, 0.12948945f, -0.04016788f, 0.20846914f, 0.32299703f, 0.00267995f, -0.19923674f, 
    -0.30674186f, 0.02367925f, 0.09842435f, -0.20080337f, -0.11355013f, -0.24697684f, 0.05300247f, 0.00477061f, 
    0.08517660f, 0.14428443f, 0.30665240f, 0.09898784f, 0.01926666f, 0.14318544f, 0.08916949f, 0.10964569f, 
    -0.24696606f, -0.03902954f, -0.04692795f, 0.18824354f, -0.03113809f, 0.00674807f, 0.11447520f, 0.35870650f, 
    -0.06082251f, 0.04612936f, -0.21737114f, 0.05704331f, -0.04309143f, -0.02531144f, 0.37739360f, -0.10486025f, 
    0.25958005f, -0.19081886f, 0.15692569f, 0.11817631f, -0.25675276f, -0.38239691f, -0.06659786f, -0.07861365f, 
    0.06248793f, -0.03176184f, -0.18096951f, -0.08650494f, -0.33385488f, -0.31240493f, 0.12405066f, 0.06445032f, 
    -0.08695517f, -0.15103899f, 0.06558915f, 0.00234778f, -0.09709706f, 0.16295151f, 0.28669849f, 0.26202542f, 
    0.04831769f, -0.08230152f, 0.10699039f, 0.12217215f, -0.06210208f, -0.12003106f, -0.10977966f, -0.19269094f, 
    -0.12044737f, 0.06734905f, -0.04152673f, 0.07951170f, -0.03754295f, 0.09080470f, 0.01436651f, 0.08667497f, 
    -0.10995527f, -0.61247236f, -0.08166756f, -0.05534833f, -0.07189731f, 0.27557951f, 0.03640441f, 0.02094457f, 
    -0.33105093f, -0.18282174f, -0.09945492f, 0.00568621f, 0.04682749f, 0.02503704f, 0.27668610f, -0.08123051f, 
    0.05641976f, 0.45830378f, 0.14288616f, 0.43705323f, -0.06382842f, 0.08509897f, -0.12694623f, -0.02983618f, 
    -0.02633266f, 0.14208484f, 0.21947859f, -0.64989614f, -0.58297020f, -0.21736719f, 0.12498334f, 0.07331735f, 
    0.06385304f, -0.26955980f, -0.08434647f, 0.04759657f, -0.21470380f, -0.22429505f, 0.10196398f, 0.26306632f, 
    -0.09102726f, 0.14784598f, -0.02744092f, 0.21264231f, -0.20196164f, -0.11891144f, -0.19889955f, 0.02527958f, 
    0.02351372f, 0.22341675f, 0.03545237f, -0.03333431f, 0.19310176f, 0.18376443f, -0.14479382f, -0.18775092f, 
    0.07820434f, 0.01550100f, 0.06888939f, 0.10621829f, 0.13461733f, -0.05369608f, -0.08675237f, -0.01724910f, 
    -0.08221620f, 0.30889046f, 0.16964099f, 0.07089664f, -0.12566778f, 0.14156917f, -0.18664037f, -0.13633470f, 
    -0.09122141f, -0.42383635f, 0.03251479f, -0.19711076f, -0.15036672f, -0.07386506f, -0.12842248f, -0.02731398f, 
    -0.02880724f, -0.06071744f, -0.11579978f, -0.13480744f, -0.19815581f, 0.07374743f, -0.10965145f, -0.14424728f, 
    -0.09479391f, 0.14075752f, 0.38837770f, 0.64346725f, -0.17388988f, -0.35876328f, -0.00770366f, 0.10094319f, 
    0.15484408f, 0.11790520f, -0.17067870f, -0.21309915f, -0.13685150f, 0.03262630f, -0.04398292f, 0.05065167f, 
    0.19433515f, 0.12687796f, -0.01757426f, 0.22025982f, -0.41306296f, 0.08210681f, 0.18156791f, -0.05530585f, 
    0.15299648f, 0.00497044f, 0.25244728f, -0.02960191f, 0.14424816f, -0.20775087f, 0.08920127f, -0.08048304f, 
    0.05795580f, -0.08669186f, -0.08858236f, 0.18603420f, -0.03713661f, -0.25486454f, -0.43931913f, -0.37584963f, 
    -0.00819327f, 0.16723906f, 0.09458705f, -0.03867590f, -0.00670260f, -0.28765032f, 0.20981060f, 0.16947088f, 
    0.21782047f, -0.01870585f, -0.21603984f, 0.00250721f, 0.09988255f, -0.28171384f, -0.01318844f, 0.12242230f, 
    0.16554196f, 0.29056746f, 0.01964135f, -0.02309895f, -0.01349750f, 0.10943990f, 0.07918262f, -0.06809213f, 
    0.12996383f, 0.09629340f, -0.06750691f, 0.06904420f, 0.03349431f, 0.17913990f, 0.00236382f, 0.00839030f, 
    -0.04273132f, -0.00250907f, -0.18246426f, -0.03007208f, -0.19380015f, -0.04175012f, 0.07219126f, -0.07246764f, 
    0.13423251f, 0.22256207f, -0.28055218f, -0.06544890f, -0.07212618f, -0.03910884f, 0.02610321f, -0.06861781f, 
    -0.15871173f, 0.12249792f, 0.04554698f, 0.01394419f, -0.00925045f, -0.05698147f, 0.08313233f, 0.05234968f, 
    -0.05167207f, 0.05674166f, 0.16806428f, 0.21624278f, 0.09928323f, 0.27871996f, 0.17607936f, -0.09426040f, 
    -0.00468880f, 0.03466579f, 0.08311537f, 0.20761026f, 0.19920816f, -0.04543296f, 0.09650004f, -0.71417546f, 
    -0.12638825f, 0.04464894f, -0.15073983f, -0.06640676f, -0.04902534f, -0.25566623f, -0.28109419f, -0.15643853f, 
    0.08496160f, -0.00219368f, 0.22223175f, -0.14342262f, 0.09854720f, -0.01530652f, 0.03329987f, -0.05316910f, 
    -0.38411841f, 0.21810260f, -0.09765300f, 0.06262743f, -0.08324105f, -0.09381097f, -0.03581975f, 0.12466293f, 
    0.02538660f, 0.05360757f, -0.04697295f, -0.01352018f, -0.09251162f, -0.03255903f, -0.00925359f, 0.02016964f, 
    0.03310683f, 0.02856313f, 0.01862863f, 0.01441644f, -0.05736686f, -0.05799389f, -0.09606443f, -0.08948520f, 
    -0.05672270f, 0.02065402f, -0.06836502f, -0.02924773f, -0.08936644f, 0.04309459f, -0.05513584f, -0.07883446f, 
    0.06404421f, -0.07317329f, 0.05497651f, -0.07916307f, 0.04525597f, -0.03042854f, -0.01256201f, 0.06164562f, 
    -0.03928631f, 0.06972097f, -0.00571799f, 0.00701937f, -0.05726765f, 0.00787100f, -0.06512697f, 0.01462699f, 
    -0.00824976f, -0.04816383f, -0.08285829f, -0.03149798f, -0.05965634f, 0.03754691f, 0.03342893f, -0.03002836f, 
    0.05217908f, 0.04109290f, -0.06714485f, 0.03485604f, 0.04958040f, -0.06895509f, 0.01677483f, -0.02496240f, 
    -0.02264665f, 0.01074098f, -0.07032567f, 0.03228367f, -0.07025204f, -0.07709180f, 0.01725135f, 0.04038514f, 
    -0.08682168f, -0.04957891f, -0.03338522f, 0.02778872f, 0.07093847f, 0.05785191f, -0.02917074f, -0.02800522f, 
    -0.03423881f, -0.03740689f, 0.03312879f, 0.04027331f, 0.01331151f, 0.07257482f, 0.00786033f, -0.04774456f, 
    -0.02402122f, -0.07803608f, 0.02796949f, 0.01094125f, -0.00606070f, -0.03907813f, 0.06963081f, -0.01920452f, 
    -0.04970616f, -0.00628728f, -0.01270709f, 0.01454676f, 0.05214209f, -0.05722778f, 0.00476460f, 0.00242643f, 
    -0.05432755f, -0.08345226f, -0.03779340f, 0.03071090f, -0.00268660f, 0.01259347f, -0.07386341f, -0.07376596f, 
    -0.02787971f, 0.00610011f, -0.01475973f, -0.06604800f, -0.01176444f, -0.06634093f, -0.06190859f, -0.01861946f, 
    0.06531973f, 0.02885916f, 0.01928304f, -0.00727128f, 0.01927385f, -0.03547831f, 0.05029755f, -0.05500636f, 
    0.01491536f, -0.08541945f, 0.06145060f, 0.04592705f, 0.05588923f, 0.07317849f, -0.03746570f, -0.01615558f, 
    0.02940997f, -0.03086032f, -0.02252000f, 0.00767594f, -0.07114830f, -0.02574194f, -0.04826149f, -0.04250095f, 
    0.01984299f, -0.00726642f, -0.04105706f, 0.06960317f, 0.01758410f, 0.01516532f, 0.07160090f, 0.00170284f, 
    0.03155336f, 0.06521560f, 0.12631990f, 0.08398014f, 0.33441621f, 0.03459129f, 0.08515172f, -0.16387679f, 
    0.00914583f, -0.30663371f, 0.05129420f, 0.06605683f, 0.12317922f, -0.20165749f, 0.04052619f, -0.24813041f, 
    -0.14808911f, 0.05935230f, 0.22532170f, 0.16879281f, -0.21154097f, -0.17662555f, 0.04375016f, -0.21300647f, 
    -0.14064839f, -0.31982458f, -0.22871652f, -0.00370403f, -0.03238798f, 0.00879062f, 0.14527726f, -0.05079748f, 
    0.12053566f, -0.07015567f, -0.27366662f, -0.41235012f, 0.53767300f, 0.15314023f, 0.02647297f, 0.22874810f, 
    -0.08612648f, -0.05243166f, 0.20280555f, 0.26632386f, 0.28097942f, 0.02681226f, 0.07194403f, 0.40885791f, 
    0.05162984f, 0.00128952f, 0.03023408f, 0.07228842f, -0.08510724f, 0.25895479f, -0.37876973f, -0.07821210f, 
    -0.00591430f, -0.02291480f, -0.09290171f, 0.23029467f, 0.11264530f, 0.11660446f, 0.09514108f, -0.08827416f, 
    0.08896846f, -0.06375221f, 0.19742091f, 0.12065780f, 0.09381516f, -0.03204750f, -0.00912219f, -0.06936269f, 
    -0.41756260f, 0.11979350f, -0.03521949f, -0.05748710f, 0.01411794f, 0.24796765f, 0.26536465f, 0.24525307f, 
    0.28250819f, -0.24329412f, -0.21373510f, 0.01154775f, 0.17961602f, 0.05217030f, 0.13742699f, -0.24427657f, 
    0.21683742f, -0.12161216f, -0.17466535f, -0.10130820f, -0.06939884f, 0.00280363f, -0.46938932f, -0.34714422f, 
    -0.19632365f, 0.15170392f, 0.46057937f, 0.00820014f, 0.21065308f, -0.14199840f, 0.02695340f, -0.11602183f, 
    0.08516935f, 0.00692506f, -0.04881778f, -0.02542149f, 0.16905969f, 0.00012612f, 0.38969323f, 0.03271731f, 
    0.10221040f, 0.08175969f, 0.00840459f, 0.03772020f, 0.02852565f, -0.17945680f, 0.14720279f, 0.18279819f, 
    0.17174895f, 0.00534811f, 0.11408989f, 0.06032516f, 0.06405855f, 0.10552660f, 0.09098963f, -0.04016372f, 
    0.04517419f, -0.01322462f, -0.03290864f, -0.05080638f, 0.33979529f, -0.01776420f, -0.00726663f, -0.10771182f, 
    -0.30679280f, -0.02174515f, -0.06114928f, -0.05261453f, -0.39909390f, 0.20773382f, 0.16037640f, 0.18535107f, 
    -0.00912909f, 0.22389354f, 0.15578705f, -0.01347198f, -0.10298520f, -0.11500758f, -0.01910993f, 0.15761022f, 
    0.12934950f, 0.52673995f, 0.33398733f, 0.18601479f, -0.45977995f, -0.03477935f, 0.09773578f, -0.01730447f, 
    -0.05859028f, -0.06715988f, 0.12974359f, 0.13089147f, 0.23526973f, 0.01903984f, -0.08280511f, -0.02474265f, 
    0.01275626f, 0.16280577f, 0.22984467f, -0.24930547f, -0.05868594f, -0.00664672f, -0.15463540f, -0.11538646f, 
    -0.05035203f, -0.14362249f, 0.11357224f, 0.13339911f, -0.49577010f, -0.37336516f, 0.20745493f, -0.05073128f, 
    -0.18513530f, 0.20830064f, 0.08669674f, 0.03187089f, -0.02088601f, 0.06017046f, 0.13111430f, 0.01495369f, 
    -0.00345438f, 0.07712851f, -0.07024226f, 0.02122648f, -0.00410075f, -0.00639037f, 0.29055238f, -0.36366332f, 
    0.29935604f, 0.07746641f, 0.08553095f, 0.05377084f, 0.18182930f, 0.00116565f, -0.15765971f, 0.12522656f, 
    -0.14875320f, 0.17671250f, -0.16864900f, -0.11231602f, -0.37484109f, -0.00345102f, -0.06888067f, -0.10297337f, 
    0.40627497f, -0.42039022f, -0.39763257f, 0.02120495f, 0.09791442f, -0.03714906f, 0.02283453f, -0.02685655f, 
    -0.08517760f, 0.03704119f, 0.29567760f, 0.19413643f, -0.03753835f, -0.04937457f, -0.18362159f, -0.09739213f, 
    -0.10526971f, 0.11708599f, -0.02462500f, -0.27816942f, 0.15071425f, -0.08698346f, -0.23183250f, -0.01745725f, 
    0.02877346f, 0.01215445f, 0.29983431f, -0.34296319f, -0.04219433f, 0.13974242f, -0.11825348f, 0.06845284f, 
    -0.01980638f, 0.04365483f, 0.12520212f, 0.28540546f, -0.10811283f, -0.01638300f, -0.13190731f, -0.24184863f, 
    0.07845225f, 0.17018165f, -0.05039326f, 0.23001780f, -0.07401222f, 0.26819339f, -0.06257860f, -0.10428263f, 
    -0.18315314f, 0.10699143f, 0.05866766f, -0.07959833f, 0.08989025f, -0.17199458f, -0.62346739f, 0.09284571f, 
    0.20389284f, 0.04581543f, 0.12614711f, -0.11695459f, 0.16474986f, 0.11767039f, 0.10452666f, -0.47397366f, 
    -0.41788730f, 0.23036818f, -0.02696344f, 0.00649762f, -0.00824692f, 0.07148705f, -0.01166791f, 0.01599031f, 
    -0.02603684f, -0.05899007f, -0.04319911f, -0.07220998f, 0.09043456f, 0.01898856f, 0.01980328f, -0.03519714f, 
    0.05265877f, 0.00713474f, 0.05545009f, -0.03539341f, -0.05795755f, -0.05323480f, 0.00077898f, 0.02028942f, 
    -0.09244768f, 0.05776236f, 0.04837541f, 0.01260825f, -0.00754876f, 0.02257825f, -0.07818181f, -0.03250689f, 
    0.01013023f, 0.06068238f, 0.02194873f, -0.04285921f, 0.05157304f, -0.03471826f, -0.01405264f, 0.03116986f, 
    0.00220480f, -0.09834857f, -0.07633721f, -0.03474888f, -0.05702642f, 0.05390909f, 0.01306641f, 0.01395257f, 
    -0.06966804f, -0.08308101f, -0.00004348f, -0.08755384f, 0.05435489f, 0.04438427f, 0.07396383f, -0.08596906f, 
    0.00925770f, 0.03295387f, -0.03434125f, -0.07115582f, -0.03316527f, -0.00289856f, -0.09504475f, 0.06338026f, 
    -0.08502022f, -0.08525835f, -0.00607128f, -0.06052663f, 0.05921989f, -0.01017883f, -0.00106982f, 0.01387550f, 
    0.02192190f, 0.07080381f, -0.03667172f, 0.05891914f, -0.01112754f, -0.10355474f, -0.08144142f, -0.07300562f, 
    0.01967370f, -0.01013637f, -0.04923218f, -0.06813096f, 0.03963417f, 0.00558428f, -0.01899056f, 0.02082361f, 
    -0.05319264f, -0.10371533f, -0.07212456f, -0.11555714f, 0.02569578f, 0.04836235f, -0.01901735f, 0.03901991f, 
    -0.05693348f, -0.04936028f, 0.01245727f, 0.01291496f, -0.03367622f, -0.00212182f, 0.01856268f, -0.06387936f, 
    -0.04272576f, 0.01608426f, -0.09403756f, -0.07234158f, -0.00623146f, -0.09325428f, -0.04731881f, -0.07439560f, 
    -0.05325025f, 0.04084485f, -0.06538910f, -0.02388981f, 0.03065005f, -0.05721459f, -0.07407209f, -0.04532005f, 
    0.06061675f, -0.08683489f, -0.04701470f, 0.03248093f, 0.00118557f, -0.00817150f, -0.02632056f, -0.09538971f, 
    -0.00787335f, -0.07236172f, 0.04447308f, -0.00637593f, -0.01504818f, -0.01261060f, -0.03222202f, -0.08180285f, 
    -0.03661383f, 0.06778087f, 0.03017662f, -0.03320865f, -0.03441612f, -0.05619011f, 0.04793484f, 0.00051502f, 
    0.02268145f, 0.02382868f, -0.02619499f, -0.07130603f, -0.04758808f, 0.01233835f, 0.10203353f, 0.02486501f, 
    -0.08982048f, -0.24381134f, -0.01895653f, -0.16933176f, -0.21076091f, 0.17251676f, 0.08965568f, -0.07992700f, 
    -0.03650232f, 0.23306294f, -0.07408874f, -0.36039725f, -0.01769532f, 0.08401419f, 0.08736765f, -0.22715601f, 
    0.01885480f, -0.29444382f, -0.22815225f, -0.46098292f, -0.57748747f, -0.09440189f, 0.08617017f, -0.28940311f, 
    -0.03086850f, 0.02920336f, 0.11118730f, -0.41647393f, 0.09974933f, 0.15418480f, -0.02128088f, 0.02013021f, 
    0.07068171f, -0.15093939f, 0.23594128f, 0.21121252f, 0.48327950f, 0.35479465f, -0.03160543f, 0.08780705f, 
    -0.03442518f, -0.15687765f, 0.18496360f, 0.07575599f, 0.18558258f, -0.02745561f, -0.03548578f, 0.11112186f, 
    0.01283380f, 0.06977040f, -0.02474044f, -0.01251855f, 0.05168280f, -0.25364608f, 0.07427401f, 0.00284232f, 
    0.02564104f, 0.02288164f, 0.12610136f, -0.31750628f, 0.05267789f, -0.03718540f, -0.04604647f, -0.20318913f, 
    -0.56651604f, -0.01155170f, 0.08211622f, -0.00025316f, -0.11410493f, -0.08346962f, 0.03977807f, -0.02178103f, 
    0.28466621f, 0.21368444f, 0.09870512f, 0.02915836f, 0.15983930f, -0.12841654f, -0.03882065f, 0.04392710f, 
    0.14543924f, -0.02899168f, -0.07042997f, 0.13691626f, -0.21758406f, -0.05708240f, -0.01672386f, 0.01671589f, 
    -0.23316728f, 0.06422841f, -0.27181199f, -0.28328222f, 0.20968243f, 0.17409953f, 0.05780029f, 0.05689643f, 
    0.04732672f, -0.07003417f, -0.05394740f, -0.29391044f, -0.08611287f, -0.07920200f, -0.02242157f, -0.05440364f, 
    0.29433700f, -0.08281286f, 0.19317628f, 0.08603679f, -0.21681705f, 0.04331774f, 0.29400572f, 0.08470763f, 
    0.08752731f, 0.10658557f, 0.27707306f, 0.05398836f, -0.04347133f, 0.30197513f, 0.30401927f, 0.13544624f, 
    -0.13444956f, 0.01900783f, 0.19689879f, -0.12311248f, 0.06640332f, -0.23968504f, 0.25069338f, 0.28962380f, 
    0.01498706f, 0.07935748f, 0.19635892f, -0.03986517f, 0.17020157f, 0.02003862f, 0.14528599f, -0.19352239f, 
    -0.05332294f, 0.15384281f, -0.05400424f, -0.06138171f, 0.13311389f, 0.01657419f, -0.03842175f, -0.03854876f, 
    -0.14853139f, -0.57717741f, -0.13546617f, -0.12294478f, 0.08708667f, -0.18620086f, -0.19409736f, -0.14476714f, 
    -0.13151287f, 0.25295001f, -0.13702124f, -0.12852293f, 0.05322634f, 0.02528668f, 0.18620887f, 0.00844268f, 
    -0.14100765f, 0.18677157f, 0.22135064f, 0.21517342f, 0.12091223f, 0.15159342f, -0.14049573f, 0.08069886f, 
    0.20332417f, -0.01255015f, -0.35569948f, 0.06971775f, 0.05245042f, 0.14570034f, 0.06521994f, -0.00178115f, 
    0.00671670f, -0.13664156f, -0.00803043f, 0.00584551f, 0.11109484f, 0.40912327f, 0.06781771f, 0.24568117f, 
    0.13158266f, 0.31652310f, 0.15770736f, 0.11026423f, 0.08384271f, -0.14811833f, -0.00566314f, 0.22255372f, 
    0.03036094f, -0.02481958f, -0.21451229f, -0.07267944f, 0.00887866f, 0.37320024f, -0.12053028f, -0.13022783f, 
    -0.16289119f, -0.21106724f, 0.11027177f, 0.28725836f, 0.03554469f, 0.04317791f, 0.41754204f, 0.09402847f, 
    0.02994242f, -0.11511759f, 0.06293110f, 0.21219143f, 0.25546023f, -0.01851145f, -0.04097835f, -0.10784718f, 
    -0.00291056f, 0.13570502f, -0.08854358f, -0.05692462f, 0.22624376f, 0.18030757f, -0.00288921f, 0.02156962f, 
    0.30846080f, -0.56531477f, -0.26092881f, -0.06549932f, -0.08125425f, -0.10320128f, -0.31240410f, -0.11155182f, 
    -0.17974873f, -0.39055312f, 0.14619607f, -0.00949723f, 0.23308501f, -0.06113724f, -0.11003432f, -0.08765467f, 
    0.05422860f, 0.02334135f, -0.12336157f, 0.16818060f, -0.03051217f, 0.16361310f, 0.13144994f, 0.18527323f, 
    0.07876451f, -0.00936912f, -0.09650096f, -0.18223204f, 0.11339210f, 0.10695700f, 0.14515080f, -0.05829069f, 
    0.09202391f, 0.00471407f, -0.13548040f, -0.05128044f, -0.01264176f, -0.13197611f, 0.13182513f, 0.43400913f, 
    0.02897138f, 0.13774599f, 0.10169074f, -0.01438897f, 0.10923842f, 0.05080906f, 0.13868614f, -0.11851448f, 
    0.15453456f, 0.02533303f, 0.26905355f, -0.08004183f, 0.04183279f, -0.01733927f, 0.01066469f, 0.01190366f, 
    -0.04997359f, 0.13311513f, -0.25904337f, 0.17566349f, -0.06488276f, 0.22397023f, -0.08660860f, 0.11253752f, 
    -0.17503138f, 0.05706478f, 0.26668113f, -0.16586362f, -0.08846907f, -0.01039134f, -0.13847193f, -0.08276947f, 
    -0.03895123f, -0.37033409f, -0.14062606f, -0.18349749f, -0.29615131f, -0.17618397f, 0.02219878f, -0.00792337f, 
    0.02634067f, 0.10700222f, -0.06959410f, 0.50718814f, 0.01400831f, -0.16539632f, 0.26838011f, -0.08711442f, 
    -0.26903948f, -0.10897138f, 0.05629809f, -0.37476316f, -0.18753494f, -0.26917946f, 0.16035981f, -0.11875747f, 
    0.01970798f, -0.01792062f, -0.00271296f, 0.04097002f, 0.06924219f, -0.08354314f, -0.09470880f, -0.10948391f, 
    0.00237071f, 0.22849007f, -0.05635274f, -0.09468951f, 0.11838602f, 0.35180447f, 0.14250594f, 0.22297445f, 
    -0.00401778f, 0.11802029f, -0.11705887f, -0.06867090f, 0.07808164f, -0.10387711f, -0.40945548f, -0.01562054f, 
    0.37346902f, -0.00979013f, 0.16092622f, -0.26473978f, 0.14080735f, 0.08933859f, -0.10462918f, -0.02488410f, 
    -0.12616646f, 0.29977268f, -0.17471871f, -0.16001043f, 0.03857616f, 0.15759054f, 0.00633777f, 0.13450767f, 
    -0.09299202f, 0.01894569f, -0.35031828f, 0.09715780f, 0.09007959f, 0.04561915f, 0.10874049f, -0.03037216f, 
    -0.03229339f, -0.20419049f, -0.04087063f, 0.33538157f, -0.05854809f, 0.07202710f, -0.19208825f, -0.10346787f, 
    0.05027850f, -0.00429568f, 0.01170774f, -0.20069531f, 0.11805294f, -0.11842795f, 0.17744841f, -0.03764065f, 
    0.05841000f, -0.03941629f, 0.07490372f, 0.08014340f, 0.17565432f, 0.17305306f, -0.10547090f, 0.04023540f, 
    0.20312697f, 0.03682810f, -0.06164848f, 0.23378749f, 0.12449763f, 0.15802968f, 0.42992821f, 0.05215785f, 
    0.05764704f, -0.04031095f, 0.16925532f, 0.18217753f, 0.09481236f, -0.07215964f, -0.07020838f, 0.29418552f, 
    -0.12315892f, 0.05865442f, -0.22084317f, -0.00848971f, -0.06568883f, -0.08563825f, -0.15400150f, -0.31771073f, 
    0.06777383f, 0.12076121f, -0.00387719f, -0.17607872f, 0.00167514f, 0.01320926f, -0.13745147f, -0.28443927f, 
    -0.20138249f, -0.09007512f, -0.15945558f, -0.11088971f, -0.19119358f, 0.07154076f, 0.00350638f, 0.01788785f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.17775755f, 0.20715542f, -0.08937748f, 0.20067978f, 0.05102324f, -0.09718918f, 0.20819351f, 0.10853292f, 
    0.22043350f, 0.00059253f, 0.30820709f, -0.02507409f, 0.06279923f, 0.13151798f, 0.01755833f, 0.26635030f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04180150f, -0.37092185f, 0.02390909f, 0.14768727f, 0.13201636f, -0.19370662f, 0.61595201f, -0.30334729f, 
    -0.55861777f, -0.15368930f, 0.40047193f, -0.53643435f, 0.08744799f, 0.38510779f, -0.01982217f, 0.14219737f, 
    -0.34201744f, 0.33192870f, -0.09181772f, 0.33167157f, 0.11354372f, -0.61168492f, -0.19120288f, 0.20925370f, 
    0.35935131f, -0.08168395f, 0.20185311f, 0.45347661f, 0.09681113f, 0.15834947f, -0.16271189f, 0.17873915f, 
    -0.34668681f, 0.23088077f, -0.11348381f, 0.45814744f, -0.20898351f, -0.04706869f, -0.02908644f, -0.18350433f, 
    0.53884804f, 0.00122908f, 0.21672273f, -0.17812678f, -0.04426775f, -0.70254350f, 0.27244726f, 0.05347367f, 
    0.12118658f, -0.14813083f, -0.06485748f, -0.21409968f, 0.02602157f, -0.22102547f, -0.02355599f, -0.11691859f, 
    -0.06331974f, 0.23404127f, 0.05390146f, 0.18021819f, 0.06272072f, -0.15096274f, -0.19007742f, 0.01750994f, 
    -0.29683316f, -0.36364368f, 0.16964230f, 0.10562879f, -0.21881267f, -0.16197930f, 0.12698239f, 0.17217818f, 
    -0.33509097f, -0.21558429f, 0.23560420f, -0.17449082f, 0.19773380f, -0.29660952f, 0.45858672f, 0.38277170f, 
    -0.15897162f, -0.24468116f, 0.50502390f, -0.01975062f, 0.18112405f, -0.17272085f, -0.30053806f, 0.71745962f, 
    -0.12321745f, 0.08281594f, -0.19802786f, 0.31265923f, -0.14051615f, 0.06921587f, -0.14563113f, 0.50999814f, 
    -0.68436873f, -0.44458187f, -0.01561954f, 0.00750099f, 0.02422328f, -0.28605905f, 0.43868542f, 0.03693664f, 
    0.22905271f, 0.13902937f, 0.43134701f, -0.32629240f, -0.13089518f, 0.03542219f, 0.13517000f, 0.40110251f, 
    -0.12298752f, 0.14624619f, -0.23212941f, -0.04284256f, -0.22961985f, 0.18581976f, 0.31178457f, 0.74564821f, 
    0.25811979f, -0.24851146f, 0.06244793f, -0.10849990f, 0.01690927f, -0.47935367f, -0.14080404f, -0.26319751f, 
    0.11733576f, -0.02125690f, -0.11887090f, -0.24563752f, 0.36131617f, 0.35825986f, -0.33206591f, 0.15353544f, 
    0.24235722f, 0.17312184f, 0.01854799f, 0.46914431f, -0.04234342f, 0.14298797f, -0.02626412f, 0.27159911f, 
    -0.32579651f, -0.08226890f, 0.16005015f, -0.03846061f, 0.33227280f, -0.25484091f, 0.16470440f, -0.21009511f, 
    -0.32186696f, 0.14059360f, -0.02886054f, 0.24302210f, 0.15275829f, 0.12443019f, 0.23802193f, 0.44652680f, 
    -0.08429027f, -0.45474347f, 0.55626374f, 0.41774595f, -0.05857968f, -0.31147471f, 0.21278505f, 0.25317660f, 
    0.17074260f, -0.21549682f, -0.17431240f, -0.11659509f, 0.23576593f, -0.06705111f, 0.03658886f, 0.42665303f, 
    -0.19533385f, -0.10149887f, -0.00449754f, -0.25845841f, -0.09505864f, -0.12624651f, 0.56279922f, -0.04728903f, 
    -0.53256935f, -0.19503300f, -0.08144276f, -0.29525921f, 0.09633622f, 0.37556151f, 0.34232304f, 0.46517316f, 
    0.14749423f, -0.06651478f, -0.24919303f, -0.09071563f, 0.15158461f, -0.32014349f, -0.25834996f, 0.11147032f, 
    0.20359719f, -0.17861122f, 0.21086609f, 0.00317053f, -0.15927994f, 0.11399864f, 0.15940383f, -0.26727393f, 
    -0.26453385f, -0.08934419f, 0.33685762f, -0.21347094f, 0.45757189f, 0.27478689f, -0.23405622f, -0.19485840f, 
    0.19717187f, 0.01316696f, 0.20041236f, 0.18846157f, -0.18652174f, 0.62957197f, -0.27535674f, -0.30790541f, 
    -0.07530181f, -0.22416145f, -0.02978444f, 0.19304028f, 0.13627888f, -0.18894985f, -0.15544558f, -0.19979391f, 
    -0.15690270f, 0.07237568f, -0.15705416f, -0.15585460f, 0.09897092f, -0.04248197f, -0.20156038f, 0.23008977f, 
    -0.33461377f, 0.01345061f, -0.43118387f, 0.14975502f, -0.02338057f, 0.17250706f, 0.14824206f, 0.12402138f, 
    0.34048179f, 0.05575963f, 0.31645194f, -0.03097748f, 0.05598528f, 0.32455394f, -0.23194832f, -0.53972584f, 
    0.55355543f, -0.78032243f, -0.07690231f, -0.17712344f, 0.06707183f, -0.04527599f, 0.01153314f, 0.25392947f, 
    -0.09662125f, -0.24044408f, 0.35866868f, 0.08699751f, -0.16343643f, -0.26452246f, 0.10641496f, 0.51059026f, 
    0.36105078f, 0.17969032f, -0.09404757f, 0.11208347f, -0.32346091f, 0.30001104f, 0.13565983f, 0.23477145f, 
    -0.29791597f, -0.07164267f, 0.08257685f, 0.64505416f, 0.02839305f, 0.53398126f, -0.35400116f, -0.06900071f, 
    0.52713716f, -0.03974320f, 0.54916316f, -0.22091669f, -0.35706490f, -0.19792572f, -0.35468209f, -0.16580394f, 
    -0.41593280f, 0.20743729f, 0.17794177f, -0.25982827f, -0.20445086f, 0.22371568f, 0.00704270f, 0.40123150f, 
    0.42471826f, -0.25318205f, 0.12633540f, -0.18271178f, -0.00055284f, 0.03469250f, -0.54810154f, 0.11353856f, 
    0.32651031f, -0.13657267f, 0.11534471f, 0.22596498f, -0.16486740f, 0.48796675f, -0.14234331f, 0.19269191f, 
    -0.11681384f, 0.10789448f, -0.22249642f, -0.24021018f, -0.22037208f, 0.03587675f, -0.22095174f, -0.13768503f, 
    0.09781787f, -0.13042837f, -0.14668602f, -0.05879474f, -0.16729194f, -0.03555423f, -0.09853038f, -0.00678924f, 
    -0.16740292f, 0.33834189f, 0.10263763f, -0.11161935f, -0.57957500f, -0.27125549f, -0.21502455f, 0.01493711f, 
    0.39729440f, -0.04555542f, 0.32604432f, -0.07922661f, -0.15161593f, -0.12929973f, -0.06637385f, 0.26732919f, 
    -0.47539005f, -0.22138785f, 0.44789499f, 0.23254377f, 0.10028989f, 0.05461890f, -0.00367121f, -0.26460120f, 
    0.26174617f, 0.02284359f, 0.19418293f, -0.38113827f, 0.16080065f, -0.21440211f, 0.01536037f, 0.45401517f, 
    -0.52828103f, 0.14932150f, 0.39985204f, 0.31934711f, -0.58490252f, -0.37109959f, 0.37985364f, 0.07596362f, 
    0.10059509f, 0.08328854f, 0.37050641f, -0.04006661f, -0.17031418f, -0.05709524f, -0.17121473f, 0.25602445f, 
    0.24244797f, -0.29536948f, 0.16779394f, -0.44922170f, 0.38897318f, 0.55415952f, -0.20078132f, 0.39955217f, 
    0.00592069f, -0.17703322f, -0.01398877f, 0.47261858f, -0.11534988f, -0.13146670f, -0.05623899f, 0.07288382f, 
    -0.06922991f, -0.55948198f, -0.24633721f, -0.19506329f, 0.03980676f, 0.36383235f, 0.22524668f, -0.07600413f, 
    0.48943657f, 0.26540074f, -0.26150671f, 0.27352121f, -0.00268435f, 0.26961070f, 0.14419825f, 0.41172460f, 
    0.17924045f, 0.19669470f, -0.03941558f, 0.50867599f, -0.14792460f, -0.16040714f, -0.22911046f, -0.01719677f, 
    0.05100787f, 0.20903310f, 0.05424203f, 0.40447375f, -0.07660063f, -0.13228044f, -0.05464242f, -0.07688718f, 
    -0.39983404f, -0.94351274f, -0.30442065f, -0.36507553f, -0.62048596f, 0.43560603f, 0.57226557f, 0.28750029f, 
    0.04379858f, -0.10726467f, 0.46266016f, -0.33286086f, 0.14903690f, 0.10977400f, 0.34732643f, -0.12853594f, 
    0.07163792f, 0.20618731f, -0.05448237f, -0.04177036f, -0.18966047f, 0.17753296f, -0.07699431f, 0.38089061f, 
    0.11275817f, 0.21427073f, 0.03825398f, -0.08653170f, 0.18270209f, -0.40713447f, 0.30743557f, 0.31281582f, 
    -0.14454719f, 0.09633105f, 0.29429120f, 0.08474893f, -0.04880439f, -0.22126013f, -0.21838655f, 0.56468588f, 
    -0.15694396f, -0.03317502f, -0.15874222f, -0.39965788f, -0.13885936f, -0.27553779f, 0.00061567f, -0.13771836f, 
    -0.02136904f, -0.48702475f, 0.26169193f, 0.42429459f, -0.35553613f, -0.20266116f, 0.34169856f, 0.32322264f, 
    0.17016064f, 0.15697336f, 0.20728360f, -0.36291006f, -0.06423930f, 0.10707058f, -0.31821588f, 0.17543045f, 
    0.28564614f, 0.01417523f, 0.10644796f, -0.20568235f, 0.23123613f, -0.10677725f, -0.24890502f, -0.08869944f, 
    0.22226961f, -0.11422446f, -0.14311552f, 0.13346991f, 0.18375184f, 0.12277974f, -0.00321845f, -0.27022755f, 
    -0.24111308f, 0.33226746f, -0.34017271f, 0.04938256f, -0.08920522f, 0.34426680f, 0.23349588f, -0.00515754f, 
    -0.13919680f, -0.17599034f, 0.02667036f, 0.50891399f, -0.15180860f, -0.16601554f, 0.17923304f, -0.33496410f, 
    0.16617043f, -0.21134892f, -0.10799027f, -0.25989410f, 0.17487982f, 0.31237853f, 0.24049264f, 0.21423580f, 
    -0.11248414f, -0.07134233f, -0.00924631f, -0.12388708f, 0.20571505f, -0.01702513f, -0.01171572f, 0.12167331f, 
    0.16358736f, -0.30993560f, -0.01814590f, -0.20296136f, 0.32168850f, 0.27776980f, 0.30958650f, -0.43748146f, 
    -0.45369443f, -0.19997771f, -0.11406054f, 0.34385297f, -0.05257162f, 0.07600667f, 0.29900506f, 0.19285440f, 
    0.22693059f, 0.08023669f, -0.05208602f, 0.11615274f, -0.01130263f, 0.33758378f, -0.09794259f, -0.06790830f, 
    0.05126476f, 0.00493675f, -0.31493133f, -0.14485358f, 0.03592401f, -0.06842323f, 0.09250525f, 0.25128740f, 
    -0.34939784f, 0.08803137f, -0.34078413f, 0.07950167f, -0.76488709f, 0.01515311f, -0.32908586f, -0.27794060f, 
    0.00699004f, -0.17306402f, 0.46986401f, -0.15375641f, -0.06661230f, -0.07005789f, 0.21034323f, 0.66419256f, 
    -0.11478341f, 0.26327276f, 0.01433707f, 0.42318574f, -0.19107915f, -0.19735283f, 0.22276707f, 0.64053977f, 
    -0.06484758f, -0.16264252f, 0.31327939f, -0.14061245f, -0.18532111f, -0.43068179f, 0.09497488f, -0.06162081f, 
    0.24175815f, -0.01498950f, 0.17731008f, 0.09281439f, -0.18567210f, 0.45251700f, -0.07452945f, -0.21881063f, 
    0.11644094f, 0.13869728f, -0.27681568f, -0.27544433f, 0.20170514f, -0.25163922f, 0.36647996f, -0.08506778f, 
    0.26777518f, -0.34061211f, -0.37732548f, 0.10577268f, -0.15621607f, 0.17611791f, -0.08839633f, -0.28314987f, 
    -0.32679960f, -0.21484049f, 0.31178629f, 0.34744903f, 0.21340626f, 0.22973295f, 0.11550222f, -0.31434688f, 
    -0.19398259f, -0.23587263f, -0.31590024f, -0.48789960f, 0.01034272f, 0.26509875f, -0.26541623f, -0.34885961f, 
    0.05095585f, 0.03621503f, 0.50895494f, 0.02988581f, 0.16856012f, -0.13317192f, 0.48243776f, 0.08362820f, 
    0.13447626f, 0.11187392f, -0.28300664f, 0.36641943f, 0.16853650f, -0.02471382f, -0.24107563f, 0.44162706f, 
    0.18131311f, -0.10376776f, 0.00048485f, 0.16644719f, 0.07809344f, -0.01824196f, -0.20681778f, 0.17437273f, 
    0.07490239f, -0.13849820f, -0.05131164f, -0.13507214f, 0.05499358f, -0.11389985f, -0.23585765f, 0.15165475f, 
    0.06612843f, 0.12470043f, -0.23541020f, -0.18587410f, -0.00011156f, 0.00324064f, -0.18987510f, -0.23350953f, 
    0.33843923f, -0.25078762f, 0.16492833f, -0.04180432f, 0.38597429f, 0.42552346f, 0.05478579f, 0.06430562f, 
    -0.37401074f, 0.17897758f, -0.16052304f, 0.29206356f, 0.15390712f, 0.60178787f, 0.07022213f, -0.18570538f, 
    0.24707222f, -0.20509602f, -0.26781827f, 0.06142309f, 0.23244578f, 0.30442700f, 0.37033251f, 0.29596052f, 
    -0.44796491f, 0.12197840f, -0.04054280f, 0.43755668f, 0.13256456f, 0.11723214f, 0.09282266f, -0.39062428f, 
    -0.77782351f, -0.22645958f, -0.00704246f, -0.37607372f, -0.66401267f, -0.20023127f, 0.06750088f, 0.08757045f, 
    0.42405707f, -0.13243836f, 0.45572248f, -0.45499045f, 0.15831934f, -0.04292639f, 0.42436472f, 0.46606582f, 
    -0.06617697f, -0.85802364f, -0.15933037f, 0.08634496f, -0.17300205f, 0.10055827f, 0.33992961f, 0.32349449f, 
    -0.12497307f, 0.15009573f, 0.25919572f, -0.20869716f, -0.19391516f, -0.03855775f, 0.05637946f, 0.45220706f, 
    0.35938844f, -0.37618425f, 0.10941832f, -0.13317601f, -0.07929257f, 0.31248432f, -0.42209741f, 0.42829621f, 
    0.36011553f, 0.09781285f, 0.01890061f, 0.05117167f, -0.00793460f, -0.28990012f, 0.19191803f, 0.10910523f, 
    -0.09076198f, 0.11840753f, 0.05480316f, -0.25087181f, -0.03429632f, 0.11349989f, -0.17477101f, -0.24007384f, 
    0.13389109f, 0.13772327f, -0.32346565f, -0.20020567f, 0.11596903f, -0.10249865f, -0.15736024f, 0.01177498f, 
    0.02934262f, -0.40434381f, 0.37481713f, 0.35142264f, 0.07880174f, -0.25954944f, 0.43563589f, -0.14764871f, 
    -0.25229785f, 0.17555653f, -0.03215412f, -0.19026119f, 0.12876812f, 0.44357765f, -0.05913635f, -0.22673084f, 
    0.57176399f, -0.32291695f, 0.40311664f, 0.07067928f, -0.10009556f, -0.13125758f, 0.02448800f, 0.08270510f, 
    -0.20644210f, -0.03975871f, 0.12812321f, -0.24545044f, 0.22426166f, 0.53672481f, -0.22591060f, 0.14292219f, 
    0.41748318f, -0.22054043f, -0.54105461f, 0.16661634f, -0.05753344f, -0.99162573f, -0.09276482f, -1.44247031f, 
    -0.19334678f, 0.04540989f, -0.38661885f, -0.01247569f, -0.27013233f, -0.00251787f, 0.32415494f, 0.30076614f, 
    0.18731254f, 0.20250134f, -0.11901051f, 0.07723938f, -0.38811865f, 0.01929462f, -0.19501802f, -0.31175587f, 
    -0.26929581f, -0.22647251f, 0.19067341f, 0.01478130f, 0.23348632f, 0.01572891f, 0.36521137f, 0.49585560f, 
    -0.09614281f, -0.55139846f, 0.49880520f, 0.19440134f, -0.05532288f, -0.05190209f, 0.38744083f, 0.05382195f, 
    -0.28580597f, -0.04709649f, 0.02638462f, -0.20838185f, -0.25253388f, 0.35466957f, -0.11417583f, 0.30016896f, 
    0.38390064f, -0.01050320f, -0.20035629f, 0.18087436f, -0.24939652f, 0.12181822f, -0.65155566f, 0.39968517f, 
    0.41327858f, -0.00239052f, 0.21167909f, 0.28841856f, -0.14357926f, 0.19456883f, -0.08865666f, -0.34436101f, 
    -0.15988795f, -0.11724111f, 0.07492995f, -0.39683986f, -0.62072462f, 0.32397136f, 0.17368028f, -0.07264531f, 
    0.07614569f, 0.08074051f, 0.27894914f, 0.15579678f, -0.05915539f, 0.58325016f, -0.14809211f, -0.15288737f, 
    -0.50113130f, -0.50275320f, 0.40700322f, -0.13857120f, 0.43025124f, -0.16924125f, 0.15320748f, -0.18339203f, 
    -0.15221505f, 0.10783906f, -0.08914833f, 0.29866290f, 0.20999125f, 0.17590272f, -0.06753393f, 0.23933971f, 
    0.29069868f, 0.11666232f, 0.20545872f, -0.26626274f, 0.05481968f, -0.10196147f, -0.00426089f, -0.15795828f, 
    0.03802662f, -0.10314403f, 0.00712605f, 0.06105212f, 0.05037784f, 0.09385577f, -0.18196955f, 0.40901342f, 
    -0.35934940f, -0.03711962f, -0.09642452f, 0.40011922f, 0.16239697f, -0.53346205f, 0.21662569f, -0.04741650f, 
    0.05754658f, -0.06874938f, 0.08056649f, 0.44527286f, -0.02964203f, 0.30010188f, 0.16648743f, 0.05225353f, 
    -0.12766354f, 0.06345419f, 0.19081479f, 0.12080661f, 0.25173897f, 0.09847105f, 0.23875223f, -0.14121661f, 
    0.05626164f, 0.14560053f, -0.12604737f, 0.09593741f, 0.16485052f, 0.67270976f, -0.25242311f, -0.38056681f, 
    -0.51669508f, -0.26378241f, 0.02258772f, -0.69247478f, -0.14206496f, 0.70270771f, -0.63449806f, 0.49688256f, 
    -0.35436258f, 0.03481906f, -0.08480074f, 0.32549354f, 0.02604630f, -0.06225238f, 0.36387655f, -0.12804565f, 
    0.20865923f, 0.06204458f, -0.44308108f, 0.16151331f, 0.08102818f, -0.01155265f, -0.29603094f, -0.28199497f, 
    -0.06555491f, -0.12295497f, 0.44607902f, -0.64101517f, -0.10861530f, 0.31226170f, -0.18686740f, -0.48338121f, 
    -0.15533429f, -0.14605431f, 0.03415166f, -0.00313829f, 0.14785625f, -0.37146553f, 0.30576870f, -0.19728732f, 
    0.15711899f, 0.18417621f, -0.14202535f, 0.28922206f, 0.21886094f, 0.24678379f, 0.14874150f, 0.49606997f, 
    0.35817221f, 0.22213699f, -0.10852359f, 0.27430081f, 0.22671540f, -0.28445801f, -0.25575787f, -0.03766761f, 
    0.05100790f, -0.15729973f, -0.34576330f, 0.45525900f, -0.05395210f, -0.44340661f, 0.02780552f, -0.17467774f, 
    0.20951638f, -0.25831649f, 0.05846365f, -0.01800909f, 0.20972259f, 0.38516915f, -0.21977305f, 0.00888305f, 
    -0.13648926f, -0.00668205f, 0.13163774f, 0.37566790f, 0.08830942f, -0.18739307f, 0.24436523f, -0.26873964f, 
    -0.22989348f, -0.58037311f, 0.24113722f, -0.06461634f, -0.50285113f, 0.09943045f, -0.02137974f, -0.01093587f, 
    0.48176265f, 0.19302253f, 0.31836367f, -0.47286883f, -0.18036249f, 0.41421679f, 0.15787970f, -0.12871611f, 
    -0.20273106f, -0.36684477f, 0.14335343f, 0.22750321f, 0.08893733f, -0.37422171f, 0.47402227f, -0.45152438f, 
    -0.34140772f, 0.13573383f, 0.50059968f, -0.58054143f, 0.05113232f, 0.00753077f, 0.28091678f, 0.06532955f, 
    0.44027722f, 0.18215111f, 0.35725859f, 0.06058576f, 0.23107761f, -0.10103145f, -0.27311352f, -0.08040252f, 
    0.33078986f, 0.16916054f, -0.53893375f, 0.27714536f, 0.22497165f, 0.25517723f, -0.21753332f, -0.35293221f, 
    -0.41671306f, 0.23061292f, -0.24252354f, -0.22553635f, -0.37479079f, 0.10192061f, 0.39936906f, 0.43279848f, 
    0.03627498f, -0.18560240f, 0.18878141f, -0.48919529f, -0.08940022f, 0.77701688f, -0.06341323f, 0.44957358f, 
    -0.30696225f, -0.03206844f, 0.32318795f, 0.44550210f, -0.22862180f, -0.48029345f, 0.21667719f, 0.32307008f, 
    0.26615915f, 0.05653070f, -0.13948508f, 0.31251484f, -0.12241035f, 0.17501923f, -0.34651464f, 0.22933456f, 
    0.37038165f, -0.19315787f, 0.31593257f, 0.11063192f, -0.10321859f, -0.71930301f, -0.15842545f, 0.01605888f, 
    -0.10427343f, 0.08510920f, 0.19107307f, -0.12331627f, 0.24725926f, -0.04887114f, -0.03366083f, 0.10232800f, 
    0.39722043f, 0.12002058f, -0.00290574f, -0.17765810f, -0.12796652f, -0.32177430f, 0.13155618f, 0.16298832f, 
    -0.20679621f, 0.00058833f, -0.15309744f, -0.33151680f, -0.19459195f, 0.40337721f, -0.07758310f, -0.17370725f, 
    -0.30800107f, -0.00980669f, -0.37758559f, 0.17210363f, 0.06550808f, 0.28068301f, -0.04184961f, -0.07542679f, 
    0.18008573f, 0.05634701f, -0.10709332f, 0.39891097f, -0.09520978f, 0.50509030f, -0.04418913f, -0.34890333f, 
    0.14580427f, -0.00042534f, 0.27976489f, -0.19194981f, 0.14490713f, 0.31441799f, -0.19175763f, -0.13556792f, 
    -0.40263647f, 0.14929990f, 0.27865884f, -0.04502936f, 0.17274243f, -0.39390337f, 0.26310399f, 0.17542684f, 
    0.42990530f, 0.04698240f, -0.10705505f, 0.19704230f, -0.34671682f, -0.04588452f, 0.23494537f, -0.07835352f, 
    0.17643283f, 0.07017293f, -0.01583444f, 0.01966914f, -0.15508997f, 0.35158208f, -0.21363226f, 0.09619571f, 
    -0.37869310f, -0.09287494f, -0.22847433f, 0.11780446f, 0.34228662f, -0.42792273f, 0.14172374f, 0.34782717f, 
    0.25404495f, -0.12423536f, -0.05824163f, 0.02981257f, 0.04572836f, 0.25338262f, 0.08255122f, 0.26496637f, 
    -0.44934386f, 0.00253927f, -0.02239012f, 0.44622904f, 0.07915033f, -0.21300362f, 0.43540654f, 0.35874420f, 
    -0.04091427f, -0.29614657f, 0.05454294f, -0.11998507f, 0.19636139f, -0.27910697f, 0.16196702f, 0.47112098f, 
    -0.77458769f, 0.19251010f, -0.47038496f, -0.33738735f, -0.56115657f, -0.27115175f, 0.33257124f, -0.01683627f, 
    -0.01075982f, -0.25046524f, 0.52455020f, -0.14851804f, 0.11484908f, 0.26725331f, 0.22809392f, 0.44451818f, 
    -0.26567155f, -0.00275225f, 0.21878289f, 0.03425158f, 0.22020052f, 0.09200457f, -0.17810489f, -0.15247825f, 
    0.16555817f, 0.03976711f, 0.07342347f, -0.18093997f, 0.18313025f, 0.32731041f, -0.17043455f, -0.01466468f, 
    0.39764366f, 0.12495396f, -0.07631312f, -0.00139300f, -0.04682212f, 0.16089270f, 0.00941999f, 0.00912115f, 
    -0.31937784f, -0.14736795f, 0.09539210f, 0.47032788f, -0.02992807f, 0.34040213f, 0.06942662f, -0.52493531f, 
    0.10212813f, 0.33696297f, -0.46206915f, 0.24528840f, -0.05261369f, -0.02462377f, -0.01626322f, -0.00358270f, 
    -0.29037645f, -0.07586966f, 0.31868622f, 0.53328574f, 0.16753550f, -0.19546820f, 0.02678409f, -0.19689119f, 
    0.28954881f, -0.23344900f, -0.10046506f, -0.35143289f, -0.41081288f, 0.25583783f, -0.56030375f, -0.09308410f, 
    0.19778956f, -0.03204272f, 0.22246905f, -0.12800337f, 0.19365202f, -0.16970216f, 0.46403572f, -0.09324509f, 
    -0.21205258f, -0.07584637f, 0.18582600f, -0.09724918f, -0.06478798f, 0.05212060f, -0.07602933f, -0.13289979f, 
    -0.00493562f, -0.21573842f, -0.11611888f, 0.03589696f, 0.02407742f, -0.17148551f, -0.22692066f, -0.06376404f, 
    -0.29001871f, -0.54185194f, -0.17804763f, -0.03836178f, 0.12821284f, 0.04116540f, 0.01599170f, 0.52339852f, 
    0.22947539f, 0.25233540f, -0.01312785f, 0.24117489f, -0.24198604f, 0.34820801f, -0.33768439f, 0.33017823f, 
    0.44294807f, -0.24226205f, -0.13464175f, 0.14048105f, 0.31947631f, 0.49461257f, -0.28984606f, 0.38826299f, 
    0.41039136f, -0.21263357f, -0.01421734f, -0.03126619f, -0.09522534f, -0.09076945f, -0.05751097f, -0.23634405f, 
    0.08710930f, -0.21419562f, 0.05313028f, -0.16246034f, -0.12295210f, 0.34483457f, -0.28976160f, -0.41239449f, 
    0.52430773f, -0.17443930f, -0.20263016f, -0.01665210f, -0.12336458f, 0.12321339f, 0.22196896f, 0.47254145f, 
    -0.33455667f, -0.05969620f, 0.31456974f, 0.15948267f, 0.25535524f, -0.19123231f, 0.30550694f, -0.52127331f, 
    -0.25094572f, -0.20730497f, 0.15574829f, -0.44912592f, 0.17860271f, 0.20084783f, -0.02644264f, 0.17684616f, 
    0.13698165f, 0.02298551f, 0.13156496f, 0.27723464f, 0.08255970f, -0.16385067f, 0.24618790f, 0.23540860f, 
    -0.31652826f, 0.17617811f, 0.07564662f, -0.03608591f, 0.07480282f, -0.21069178f, 0.04563677f, 0.21553670f, 
    -0.01707057f, -0.17439835f, -0.06021887f, 0.13590391f, -0.11497656f, -0.04930263f, -0.04952343f, -0.11404368f, 
    0.05758674f, -0.07106671f, -0.00918101f, -0.19145295f, -0.13709742f, -0.03284999f, -0.13545403f, 0.18543944f, 
    0.15271682f, 0.06594596f, -0.33015382f, -0.04997155f, 0.00067147f, 0.32159954f, 0.05398798f, 0.03277868f, 
    -0.18218935f, 0.09841031f, 0.23070420f, -0.31372026f, -0.08165663f, -0.11398099f, 0.22265637f, 0.05505811f, 
    0.11468752f, -0.32701746f, -0.14760639f, -0.33339798f, 0.13038404f, 0.53403831f, -0.30773428f, 0.44618934f, 
    0.35609087f, -0.12985674f, -0.20217182f, 0.43840784f, 0.16728605f, 0.21514329f, 0.07159960f, -0.02012886f, 
    -0.32092407f, -0.87106752f, -0.25119779f, 0.23774707f, -0.37959248f, 0.04834025f, 0.24433309f, 0.38474381f, 
    -0.13118082f, 0.23738864f, 0.33089715f, 0.03461064f, 0.06802013f, -0.01507171f, 0.22647135f, -0.11059132f, 
    0.21198694f, 0.33498690f, -0.14915791f, 0.15024704f, 0.02134390f, -0.34397671f, -0.11463528f, 0.27671596f, 
    -0.05451845f, 0.16812122f, 0.24644622f, 0.35752991f, 0.09242596f, 0.05482533f, -0.29316372f, -0.28160748f, 
    -0.38997591f, -0.13633882f, 0.03231658f, -0.28132391f, -0.35871372f, -0.35689226f, -0.15685681f, 0.25575694f, 
    0.29747972f, -0.01513881f, 0.31666636f, -0.17503761f, -0.12540111f, -0.17417735f, 0.34141132f, 0.50202048f, 
    0.00616999f, 0.24757190f, 0.12390684f, 0.08029593f, -0.23495729f, -0.50882304f, -0.28670299f, -0.26645610f, 
    0.01022896f, -0.09665830f, 0.32035094f, -0.46101683f, 0.10702784f, 0.06632612f, 0.20203859f, 0.22718842f, 
    0.06602098f, -0.19745137f, 0.17114414f, 0.13767688f, 0.41604787f, -0.01344794f, 0.07506715f, -0.29298714f, 
    -0.11645810f, 0.09304253f, 0.14440002f, -0.04134173f, 0.02540584f, -0.23799640f, 0.00708674f, -0.37551612f, 
    0.05295996f, 0.12475668f, -0.06310526f, 0.23724894f, 0.07677098f, -0.08948053f, 0.07094830f, -0.11146482f, 
    0.49201834f, -0.08496636f, -0.02383916f, -0.29666254f, -0.07206447f, 0.00686502f, -0.23895867f, -0.16213639f, 
    0.58061188f, -0.41111091f, 0.32070547f, 0.41139346f, -0.36594456f, -0.07435466f, -0.09492075f, 0.40596652f, 
    0.15451735f, 0.03397209f, 0.16945480f, -0.44723395f, -0.21552472f, -0.19850241f, 0.02207954f, -0.02568506f, 
    -0.39735118f, 0.20782244f, -0.15278076f, 0.18816394f, 0.14476469f, 0.03191410f, -0.18222503f, 0.30507797f, 
    0.37763020f, -0.07000963f, -0.11999801f, 0.40526810f, -0.00922957f, 0.12525499f, 0.08018492f, -0.23515284f, 
    0.23691201f, -0.35745263f, -0.01281439f, 0.08660745f, -0.02817228f, 0.50302571f, -0.17069170f, 0.15415850f, 
    0.17655464f, 0.13988301f, -0.06840629f, 0.58368522f, 0.22739123f, 0.04764167f, -0.21178226f, -0.10923892f, 
    0.14604433f, -0.22185503f, 0.27007371f, -0.18869638f, -0.44475183f, 0.05925520f, 0.08705446f, 0.15024246f, 
    -0.42394465f, -0.01204872f, 0.10150124f, -0.23117249f, -0.18486388f, -0.46150306f, 0.30409664f, 0.70050263f, 
    0.13955152f, -0.08017913f, 0.15369812f, 0.35737112f, -0.13696475f, -0.00778237f, -0.26845863f, -0.37242234f, 
    0.34877813f, 0.06033776f, 0.36818111f, -0.59134609f, 0.22126320f, 0.23761442f, 0.29523507f, -0.20760772f, 
    0.09640941f, -0.32207558f, 0.30639806f, 0.20676157f, 0.30352709f, 0.10073062f, -0.33214194f, 0.21616949f, 
    0.31223187f, -0.15661931f, 0.19681863f, 0.11235324f, 0.03656808f, -0.17145732f, -0.13530618f, -0.34540927f, 
    0.13758411f, -0.18668376f, 0.22797382f, 0.07261217f, 0.33345693f, 0.21747389f, 0.17180078f, 0.22753827f, 
    -0.46929669f, 0.12086969f, 0.18138504f, -0.30798456f, -0.18117748f, 0.30717978f, -0.13761595f, -0.29124281f, 
    -0.31132910f, 0.10066197f, -0.04077401f, 0.59689468f, -0.07597547f, -0.29952627f, 0.31462607f, 0.18843567f, 
    -0.19620721f, -0.23234585f, -0.00817223f, 0.06688898f, -0.12100174f, 0.06051848f, 0.40572536f, -0.02784915f, 
    0.21408309f, 0.20471375f, 0.10284314f, -0.16980036f, 0.36602393f, 0.29776222f, 0.19328582f, -0.69822901f, 
    0.07629968f, 0.00955953f, -0.17707916f, -0.01549589f, 0.20770837f, 0.13836588f, -0.26104331f, 0.27145579f, 
    -0.00172224f, -0.20735645f, 0.02213336f, -0.18390676f, 0.06850849f, -0.16942042f, -0.26481348f, -0.25076851f, 
    0.16382791f, -0.09085998f, -0.10573091f, 0.05655221f, -0.18039840f, 0.21208626f, -0.25158638f, -0.16205436f, 
    -0.18312925f, 0.11991981f, -0.10455757f, 0.08030669f, -0.08505859f, 0.15646672f, 0.08996233f, -0.30850512f, 
    -0.14229648f, -0.22498353f, -0.14809990f, -0.16056098f, 0.00031004f, 0.02886634f, 0.34570536f, 0.13109158f, 
    -0.22083582f, -0.26638520f, 0.03825357f, 0.03259440f, 0.38413012f, 0.51647848f, 0.05410932f, 0.21105078f, 
    0.15482828f, 0.04191938f, 0.14051707f, 0.06452213f, -0.19983818f, 0.80599988f, -0.38301051f, -0.26272780f, 
    -0.02994056f, -0.14277163f, 0.28738344f, 0.03221916f, 0.05766838f, -0.27144143f, 0.28714380f, -0.26231998f, 
    -0.30950710f, 0.13744184f, -0.07196083f, 0.16869849f, -0.14008084f, 0.31319913f, 0.11625533f, 0.43088412f, 
    0.15507862f, 0.06971533f, -0.03678527f, -0.15415341f, -0.18527688f, -0.12535281f, -0.07121699f, -0.06200465f, 
    -0.04491437f, 0.19120166f, 0.20174505f, -0.16999735f, 0.13365917f, 0.04702070f, 0.33998501f, 0.11658109f, 
    -0.33085567f, 0.14279127f, 0.17594947f, 0.38493326f, 0.04027995f, -0.33986855f, -0.21551584f, 0.04284030f, 
    0.15818031f, -0.21774694f, 0.26742837f, -0.00037208f, 0.06262466f, -0.27780816f, 0.14043152f, -0.17670834f, 
    -0.21379237f, 0.15900941f, -0.40905613f, 0.06198899f, 0.26554930f, -0.17816727f, -0.19984737f, 0.21491326f, 
    0.39112979f, -0.18991952f, 0.14559714f, 0.44959429f, -0.05911307f, -0.22754811f, -0.03697875f, 0.23906302f, 
    -0.11687049f, 0.07802395f, 0.12360429f, 0.30507931f, -0.13736282f, -0.17052540f, 0.01160983f, -0.01155717f, 
    0.32640842f, -0.22335288f, 0.06281459f, 0.12565628f, -0.10791875f, -0.06246458f, -0.07295577f, -0.34842163f, 
    -0.14378643f, -0.22054687f, 0.00874531f, 0.20446694f, -0.08596888f, -0.07641989f, -0.01817393f, -0.02365759f, 
    -0.11750495f, 0.18765450f, -0.20384955f, -0.06604826f, -0.19021854f, -0.07587177f, -0.11847109f, -0.23302016f, 
    0.29011685f, -0.07696843f, 0.13271286f, -0.13048011f, 0.07522930f, 0.11104048f, -0.23151557f, 0.07510573f, 
    -0.29970849f, -0.08902593f, 0.08487562f, 0.34463647f, -0.06292184f, -0.01497361f, -0.13276637f, 0.37269554f, 
    0.04382708f, -0.08873551f, 0.14126189f, 0.07846317f, -0.09541137f, 0.04860494f, 0.30262735f, -0.20279507f, 
    -0.36240602f, 0.03470827f, -0.09670476f, 0.42311832f, 0.01467022f, 0.02701338f, 0.27436161f, -0.26718169f, 
    -0.33559516f, 0.23112798f, -0.35392967f, -0.15816635f, 0.26501146f, -0.56582707f, 0.12451788f, -0.16582029f, 
    -0.18324922f, 0.24048656f, 0.17367825f, 0.34801546f, 0.23504037f, -0.32870930f, -0.34178004f, 0.07789640f, 
    0.39041808f, -0.17105252f, -0.09179942f, 0.46081504f, -0.13466541f, -0.41831037f, -0.04600887f, -0.39050123f, 
    -0.06340179f, 0.05638522f, 0.02066142f, -0.49655998f, -0.19083670f, -0.03769268f, 0.36362046f, 0.04409541f, 
    0.14461993f, -0.64424700f, -0.28829247f, -0.33850884f, 0.24395171f, 0.10475419f, 0.06205144f, 0.45650849f, 
    0.09121891f, 0.12972568f, 0.38588762f, -0.18769225f, 0.14449798f, -0.37318763f, 0.26038951f, 0.07300376f, 
    0.13127251f, 0.28568825f, -0.09232532f, 0.48186737f, -0.42636088f, 0.13665940f, -0.05158975f, 0.03940519f, 
    0.22979192f, 0.00762570f, -0.01146205f, 0.31649226f, -0.04946106f, -0.13554542f, 0.14261964f, -0.38374317f, 
    0.35235730f, 0.01594185f, 0.20403022f, 0.13690574f, 0.32534918f, -0.92729050f, -0.02600560f, -0.60544348f, 
    -0.05030097f, 0.13856673f, 0.03067040f, -0.47027341f, 0.21496384f, -0.77157450f, 0.08033953f, -0.26286599f, 
    -0.64508939f, -0.69026643f, 0.13134262f, 0.17156669f, -0.51881391f, 0.02628845f, -0.08199693f, 0.67985278f, 
    0.26001492f, 0.05485862f, 0.24679281f, -0.05998166f, -0.05870228f, 0.01662417f, -0.22636360f, 0.33259714f, 
    -0.18304308f, 0.03144614f, -0.13852412f, -0.20822008f, -0.01080622f, 0.01943452f, -0.10926290f, -0.07171664f, 
    0.04160834f, 0.20287843f, -0.09456375f, -0.16487233f, 0.20456626f, -0.18920872f, 0.02338213f, 0.13655779f, 
    -0.18926018f, -0.22421370f, 0.47630933f, 0.20721942f, 0.31557310f, -0.10015840f, 0.11268098f, -0.19037673f, 
    0.13413660f, 0.22232696f, -0.16839352f, -0.06014087f, -0.07542966f, 0.43357915f, -0.25941309f, -0.19073218f, 
    -0.23464985f, 0.00090053f, 0.15603843f, 0.36400065f, -0.24869585f, -0.21541475f, 0.34049404f, -0.13403045f, 
    0.02312417f, -0.09857588f, -0.04956337f, 0.20193531f, -0.23879588f, 0.32126027f, 0.14083292f, 0.04609070f, 
    -0.03807545f, -0.10861395f, -0.18460797f, 0.09498238f, 0.07345425f, -0.20774123f, -0.10883908f, -0.14748247f, 
    -0.08205336f, -0.22328340f, -0.19330889f, 0.16703017f, -0.23769018f, 0.05251657f, -0.17906511f, -0.18344542f, 
    -0.06303143f, -0.39017496f, 0.32041815f, -0.02719416f, 0.27468896f, -0.04044758f, 0.36185312f, -0.02266351f, 
    0.01790627f, -0.03666378f, -0.30837390f, 0.27649343f, -0.15828624f, 0.25527421f, 0.09774791f, 0.37287289f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.11318722f, 0.03843689f, 0.40689576f, -0.17154360f, 0.10776804f, 0.18435171f, 0.43125317f, -0.18849263f, 
    -0.06926009f, 0.18497254f, 0.29057372f, -0.12710543f, 0.12417231f, -0.05982859f, -0.11529400f, 0.34240392f, 
    0.15151873f, -0.12357292f, 0.07555548f, 0.37408572f, -0.13368556f, 0.37454161f, 0.51224250f, 0.46847871f, 
    -0.00918112f, 0.07918779f, 0.27203077f, 0.34326130f, -0.19678508f, 0.11209396f, 0.04614037f, -0.04237049f, 
    -0.08583079f, 0.25855514f, -0.00227010f, -0.19538189f, 0.22264494f, 0.16457446f, 0.12435395f, -0.13632245f, 
    -0.04620664f, 0.35255671f, 0.02492535f, -0.08513457f, 0.10289215f, 0.46538663f, 0.24635226f, 0.17254670f, 
    -0.21138293f, 0.31179345f, -0.13447481f, 0.32331210f, 0.06882769f, 0.31466782f, 0.36680475f, -0.21834238f, 
    0.28266728f, -0.05179819f, 0.13142172f, 0.16060674f, 0.10675183f, 0.24058782f, 0.40782470f, -0.24807604f, 
    -0.26978245f, 0.01933137f, 0.31698889f, -0.27166930f, 0.39632475f, -0.08754349f, -0.26056263f, 0.28866339f, 
    -0.09237655f, -0.26575312f, 0.00289795f, 0.45982793f, 0.42398581f, 0.00578559f, 0.21193583f, -0.21775843f, 
    0.08283659f, 0.14889245f, -0.11768523f, 0.16125134f, 0.22064400f, -0.21695675f, 0.00868442f, 0.11103496f, 
    -0.14299379f, -0.32004452f, -0.07617237f, 0.42810762f, 0.20676495f, -0.08394258f, 0.17220351f, -0.45858911f, 
    -0.11275878f, 0.01599300f, 0.15549122f, -0.21573953f, 0.04964960f, 0.19209696f, 0.29149237f, 0.10101481f, 
    0.33375281f, -0.16659845f, -0.21641690f, 0.11381833f, 0.30626631f, 0.27418467f, -0.01417630f, 0.22600639f, 
    0.45163071f, -0.01599758f, -0.10272208f, 0.16936192f, -0.20740378f, 0.22209701f, 0.25451624f, 0.26074475f, 
    -0.04255971f, -0.25372249f, -0.05151241f, 0.05273773f, 0.30270860f, 0.23495160f, 0.08808529f, -0.13315380f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14455985f, -0.10742820f, -0.05632313f, -0.03085130f, -0.27263740f, -0.04285714f, -0.66059971f, -0.06099836f, 
    0.17451690f, -0.29451892f, -0.80422765f, -1.06777203f, -0.18549830f, 0.16693543f, -0.04651616f, 0.31274939f, 
    -0.03243877f, 0.23470771f, -0.67270780f, -0.02553889f, 0.04963934f, -0.43275788f, -0.65558887f, -0.58183956f, 
    0.22474390f, 0.15535939f, 0.08097663f, 0.21496758f, -0.13121720f, -0.20323348f, -0.83759981f, 0.03148262f, 
    0.23188519f, -0.02388193f, 0.01499222f, 0.10628249f, 0.01471545f, -0.34686226f, -0.07311833f, 0.59638149f, 
    0.32236302f, 0.06188343f, -0.05658515f, 0.13145708f, 0.12653588f, -0.46630645f, -0.07258474f, 0.13073541f, 
    -0.04035186f, -0.78467739f, -0.40987992f, -0.38421273f, -0.16838232f, -0.35750410f, 0.19205351f, 0.19309388f, 
    -0.14856309f, -0.07292373f, -0.22970857f, 0.00365538f, 0.36920846f, -0.45031026f, -0.15845887f, 0.10207854f, 
    0.15607414f, -0.21155871f, 0.33627662f, 0.17279731f, -0.05387733f, -0.29508355f, -0.71838158f, -0.23153093f, 
    0.46128982f, -0.03347678f, -0.09060518f, -0.40634480f, -0.82867312f, 0.11813290f, -0.05664814f, 0.21668155f, 
    0.03546103f, 0.29001671f, 0.08806764f, 0.12709196f, 0.13342652f, 0.04809686f, 0.06004703f, -0.23053266f, 
    -0.04216321f, -0.17370680f, 0.26781878f, 0.13631198f, 0.00220966f, -0.22981180f, 0.03404349f, 0.11115020f, 
    0.05160524f, -0.45007882f, 0.12881525f, 0.24685685f, -0.42639661f, -0.34161785f, 0.08271628f, -0.11567679f, 
    -0.49433097f, 0.04276047f, -0.05394832f, -0.17113188f, 0.03357403f, -0.30802864f, -0.26445043f, -0.23572612f, 
    -0.01321736f, -0.10200316f, -0.07255080f, 0.03280716f, 0.08747268f, -0.11751706f, -0.57571167f, 0.10435703f, 
    0.15526170f, 0.08343834f, -0.04824837f, -0.07141669f, -0.14085643f, -0.11878962f, -0.03797330f, -0.03973547f, 
    -0.15046494f, 0.18279703f, -0.07299434f, 0.01971135f, -0.48615709f, 0.21061601f, -0.24392502f, -0.78940761f, 
    0.00630122f, 0.00103648f, -0.03006480f, -0.55742037f, 0.04560265f, 0.14149502f, 0.03545638f, 0.25921065f, 
    -0.34897977f, 0.22481360f, 0.11186618f, 0.10820696f, -0.03053746f, 0.29596877f, -0.27542505f, 0.18951555f, 
    -0.12775984f, 0.07704107f, 0.12118626f, -0.39744878f, -0.09071637f, -0.24114642f, 0.08007398f, 0.01544804f, 
    -0.00245886f, -0.03690235f, 0.01316025f, -0.03538543f, 0.17866042f, -0.05275568f, -0.05220802f, -0.18238153f, 
    -0.80182385f, 0.14073879f, -0.04687116f, 0.05576847f, 0.05663170f, -0.56665242f, -0.15496561f, -0.04126225f, 
    0.05717887f, -0.06522206f, 0.01602018f, 0.90326875f, 0.18964909f, -0.06564303f, 0.14399280f, 0.11733123f, 
    0.02738125f, -0.01604956f, 0.10918909f, 0.12033276f, -1.30303121f, 0.10247888f, 0.07501855f, 0.02024541f, 
    -0.10427251f, -0.19851576f, -0.52909309f, -0.02581773f, 0.20678027f, 0.36643142f, 0.12767197f, 0.11337869f, 
    0.33714211f, -0.18155205f, 0.14979616f, 0.14040710f, 0.08949925f, -0.08322438f, 0.01167447f, 0.08218719f, 
    0.19843319f, -0.88819927f, -0.04288232f, 0.27672610f, 0.02656811f, -0.16160795f, -0.30752820f, 0.04318494f, 
    -0.03298502f, -0.00231877f, 0.08661864f, -0.07540286f, 0.19948648f, -0.28938097f, 0.03971912f, -0.27361655f, 
    -0.10129582f, -0.07489197f, 0.12358104f, 0.12509917f, -0.36770409f, 0.00795283f, 0.04152716f, 0.00071769f, 
    0.07967384f, -0.14624414f, 0.03555893f, -0.04993740f, 0.16978225f, 0.05208541f, -0.05918539f, -0.00846043f, 
    0.11299999f, 0.06846341f, 0.06806176f, 0.05747529f, -0.01349408f, -0.06358355f, 0.18087186f, -0.63656282f, 
    0.07979684f, -0.13024586f, 0.09592695f, 0.04723657f, 0.03882070f, 0.15670560f, -0.07506229f, -0.00950657f, 
    0.26396307f, 0.01908769f, -0.08199737f, 0.03282779f, 0.08479519f, -0.72897989f, 0.25995532f, -0.34211200f, 
    -0.29128239f, -0.04977581f, -0.02442022f, 0.41041926f, -0.31955963f, -0.24511121f, 0.07002296f, 0.10657575f, 
    -0.03180599f, -0.23787147f, -0.34166774f, -0.33877316f, -0.03062858f, 0.12569991f, 0.10261922f, 0.09206712f, 
    -0.70130944f, 0.05680382f, -0.03205984f, 0.52369815f, -0.10668413f, -0.00510232f, 0.30174878f, 0.18935454f, 
    -0.18972175f, -0.05470579f, -0.44873130f, 0.13760161f, 0.31570706f, -0.15631780f, -0.14561905f, -0.08894329f, 
    -0.07161210f, -0.01914633f, -0.04753405f, -0.29041490f, -0.63194209f, 0.51535189f, 0.28736162f, -0.63165534f, 
    0.03943888f, 0.09873287f, -0.00734761f, -0.10208639f, -0.02733715f, 0.20415661f, -0.43984872f, 0.39982423f, 
    0.01682080f, 0.07230933f, -0.09610194f, -0.01231854f, -0.21132277f, -0.48677608f, 0.04741675f, 0.29892311f, 
    -0.43357244f, 0.34928051f, 0.05631789f, 0.35883835f, 0.37486538f, 0.19726852f, -0.13252546f, 0.24299540f, 
    -0.40830067f, -0.17868108f, 0.28382397f, -0.04780764f, 0.00707356f, 0.55258244f, -0.07922253f, -0.33660641f, 
    -0.38266903f, -0.22969151f, 0.07506777f, 0.00807949f, -0.45024836f, -0.07838684f, 0.11189945f, -0.02500437f, 
    0.04532123f, -0.08613849f, -0.69220752f, 0.20171034f, 0.12498194f, 0.17003445f, -0.05442504f, -0.04932951f, 
    0.02822383f, -0.18428256f, -0.14121711f, -0.65115762f, 0.01172862f, -0.10961446f, -0.84984183f, -0.36727250f, 
    0.00377535f, 0.21559665f, -0.06831913f, 0.03288762f, -0.07544596f, 0.02538048f, -0.01486640f, -0.09986182f, 
    -0.02320282f, -0.06556202f, 0.02561177f, -0.36035964f, -0.30794099f, -0.31506374f, -0.19431733f, -0.06665100f, 
    -0.12090363f, 0.24583367f, 0.28051639f, -0.00576090f, -0.03811521f, -0.04877252f, -0.02323210f, -0.01297433f, 
    0.33027565f, -0.55639821f, -1.05432761f, -0.03252078f, -0.02806871f, -0.06445051f, -0.26195699f, -0.03563363f, 
    -0.00925350f, -0.30190119f, -0.23992763f, -0.13904323f, -0.01962180f, 0.22086413f, -0.08183116f, 0.12741205f, 
    0.00745719f, -0.01346167f, 0.36718956f, 0.15657592f, 0.03286788f, -0.14937122f, -0.02860560f, -0.27692288f, 
    0.01976230f, 0.12401574f, -0.43258885f, 0.27675155f, -0.11862396f, -0.69939762f, -0.06688620f, 0.33848864f, 
    -0.28785059f, 0.09546047f, -0.09170974f, -0.12940431f, 0.02710989f, -0.29371721f, -0.05241209f, 0.00945305f, 
    0.30698892f, -0.17766351f, -0.05875889f, 0.12873760f, 0.01524696f, 0.24075502f, 0.02488733f, 0.15351683f, 
    -0.01881573f, 0.15398139f, 0.18548350f, -1.07961452f, -0.06325207f, -0.06635053f, 0.05047164f, 0.17866090f, 
    -0.18943147f, 0.10814626f, -0.47068393f, 0.09316548f, 0.27339000f, -1.22361207f, -0.36056906f, -0.27848014f, 
    0.03099172f, 0.20039542f, 0.29525194f, 0.40751573f, 0.09371950f, -0.45557484f, 0.06341265f, -1.30891263f, 
    -0.02496544f, 0.06865855f, -0.00861734f, -0.31202689f, -0.54477108f, -0.09905093f, 0.13010265f, 0.04159481f, 
    -1.13571012f, 0.32671311f, -0.02858614f, 0.10121606f, 0.19292341f, 0.15883954f, 0.12451677f, -0.22495762f, 
    0.01586823f, 0.15753914f, 0.12682013f, -0.01089413f, -0.70219618f, -0.00503660f, 0.23826133f, 0.26264602f, 
    0.37127307f, 0.09790261f, -0.14002001f, -0.10767666f, 0.09829793f, 0.20546240f, 0.09407057f, 0.21781105f, 
    -0.48603603f, 0.36543724f, -0.10085728f, -0.52827364f, 0.14480701f, -0.16142243f, -0.00414613f, -0.28020874f, 
    -0.42948374f, -0.15511678f, 0.03444348f, -0.01734628f, -0.18653624f, -0.18560708f, 0.15413398f, 0.07526599f, 
    -0.25220364f, 0.12999986f, -0.02736196f, -0.08055703f, 0.08203977f, -0.19726002f, -0.07005510f, -0.07968431f, 
    -1.34550512f, -0.11747052f, 0.05916635f, -0.06434043f, 0.22892857f, 0.29861253f, -0.20764023f, -0.33655316f, 
    0.09150710f, 0.08366442f, 0.15216075f, -0.10298230f, -0.19150636f, -0.16944052f, -0.03092708f, -0.83563423f, 
    0.30532211f, -0.01506640f, 0.20818210f, 0.04711893f, -0.04395360f, 0.12937197f, 0.09523644f, 0.07487552f, 
    0.19616619f, 0.05513125f, -0.15972616f, -0.04261046f, 0.21799134f, 0.51978004f, -0.00731069f, 0.03705950f, 
    -0.04576731f, 0.09527940f, 0.23795378f, 0.19975494f, 0.22798757f, -0.03324650f, 0.37395522f, -0.35157487f, 
    -0.01579081f, -0.02465185f, -0.02187793f, 0.06866323f, 0.00941816f, 0.10792670f, 0.15374458f, 0.15937230f, 
    -0.05619822f, -1.29821479f, -0.03069894f, -0.63169855f, 0.20626739f, 0.09410270f, -0.06593075f, -0.03375408f, 
    -0.08830304f, 0.20079221f, -0.20163999f, -0.19399840f, 0.13545638f, -0.67294616f, -0.05562111f, -0.11683467f, 
    0.03806004f, -0.21823552f, -1.21083403f, 0.01245154f, -0.05985514f, -0.08699283f, -0.83901352f, -0.06771872f, 
    -0.53702617f, 0.23376289f, -0.03399280f, -0.08829795f, 0.10929968f, 0.17928058f, -0.04180691f, -0.11356110f, 
    -0.05926212f, 0.13908824f, -0.05815939f, 0.00603725f, -0.07448523f, 0.13045749f, -0.15108107f, 0.05939505f, 
    -0.01544636f, 0.00475467f, 0.10486770f, -0.03326555f, -0.00017019f, 0.17700604f, -0.49878937f, 0.05561400f, 
    -0.00231806f, 0.09021925f, -0.04931306f, -0.06220097f, 0.51508391f, -0.29253083f, -0.00618622f, -0.05118968f, 
    -0.16113095f, 0.16897315f, 0.00986200f, -0.07605731f, -0.06824078f, 0.01354663f, 0.00855015f, -0.14104351f, 
    0.01339350f, -0.35259244f, -0.03490314f, 0.17476566f, 0.04260270f, 0.33150613f, -0.50118983f, 0.08185855f, 
    -0.21233492f, -0.20925620f, 0.04347342f, -0.01482804f, -0.19200695f, -0.09686770f, 0.07641757f, 0.09633615f, 
    0.13445470f, 0.04754504f, -0.02157264f, 0.03711991f, 0.00041042f, 0.25575894f, 0.06807239f, -0.44882530f, 
    -0.03525255f, 0.00092331f, 0.15249647f, 0.16554467f, 0.32454360f, -0.06957552f, -0.00834910f, 0.18971185f, 
    0.01206701f, -0.04806002f, -0.54379952f, -0.08757808f, -0.02362783f, -0.28736767f, -0.01617230f, -0.04004843f, 
    -0.04156480f, -0.02246464f, -0.07397325f, -0.11745228f, -0.03156446f, -0.66315603f, 0.18477005f, -0.07414415f, 
    0.06485676f, 0.07977083f, -0.20963353f, -0.08391774f, -0.86009026f, 0.16003779f, -0.26348493f, -0.28409895f, 
    -0.52202713f, 0.17384842f, -0.03904047f, 0.09050932f, 0.23762606f, -0.28233683f, 0.15087435f, 0.09300211f, 
    -0.00709222f, -0.00113033f, 0.02408313f, -0.46378177f, -0.48088270f, 0.19674683f, 0.07851973f, -0.06439858f, 
    0.03027537f, -0.22788903f, -0.03522765f, 0.02987448f, -0.00080778f, 0.77443427f, -0.04044165f, 0.10089158f, 
    -0.00401277f, -0.04517031f, 0.08902309f, -0.30245480f, 0.04884470f, 0.31052643f, -0.90287536f, -0.97911632f, 
    -0.19093965f, -0.16318288f, -0.13935685f, 0.22165352f, 0.29407763f, -0.64333946f, -0.00450316f, -0.06236470f, 
    0.24026169f, -0.30905104f, 0.02861382f, 0.15358873f, 0.16498065f, -0.47637686f, 0.10157289f, 0.09748584f, 
    0.00303747f, -0.10135782f, -0.00149062f, 0.13175793f, 0.05666642f, -0.03738673f, -0.31607872f, 0.12223404f, 
    0.05198665f, 0.17520213f, 0.09920057f, -0.14608335f, -0.31932831f, -0.19519751f, 0.14280894f, 0.22865781f, 
    0.05195194f, -0.03745779f, -0.03005200f, -0.07272574f, 0.08710729f, -0.10981736f, -0.18506297f, 0.01044524f, 
    0.16647319f, -0.05488835f, -0.00738985f, -0.06371552f, -0.09328739f, 0.53879136f, -0.23533581f, 0.24851108f, 
    -0.17798997f, 0.00998519f, 0.12659106f, -0.00982792f, -0.02576278f, -0.09169110f, -0.03922272f, -0.01774829f, 
    -0.11940119f, 0.17741957f, 0.27914837f, 0.07570764f, 0.34151039f, -0.72697556f, 0.36345941f, 0.35490093f, 
    -0.24646655f, 0.05001671f, -0.20558918f, -0.05284185f, 0.06756609f, -0.36902761f, 0.06979448f, 0.19824347f, 
    -1.29128397f, -0.69093221f, -0.20586836f, -0.94173235f, -0.02617951f, 0.33711070f, 0.26448369f, 0.38227522f, 
    -0.40684199f, -1.35141420f, -0.03956071f, -0.52819866f, 0.12617077f, -0.14765476f, -0.48332432f, -0.13051729f, 
    0.31040314f, -0.42003542f, -0.26743078f, -0.15800408f, 0.42354470f, 0.21002898f, -0.03855702f, -0.61349773f, 
    0.09583014f, -0.11515200f, 0.05568227f, -0.47390202f, -0.36420697f, 0.60761893f, -0.89650375f, -0.85224587f, 
    -0.10379179f, -0.58798558f, -0.66998810f, 0.19878213f, 0.09924401f, -0.44928035f, -0.44665077f, -0.23319688f, 
    -0.50288177f, -0.20638813f, 0.10789496f, -0.09912367f, -0.11931656f, -0.40365943f, -0.03693486f, -0.06854315f, 
    -0.10105041f, -0.17258114f, 0.20721827f, 0.08394715f, 0.17750825f, -0.42659554f, -0.14859585f, -0.54764158f, 
    0.10767789f, -0.06027522f, -0.61660588f, 0.03783782f, 0.25766230f, 0.66295773f, -0.06304356f, -0.19124489f, 
    0.08035789f, -0.10672054f, -0.02003114f, -0.36210084f, -0.29894522f, -0.68304610f, 0.09814349f, -0.06608889f, 
    -0.06193862f, -0.00982395f, -0.23825014f, -0.97173637f, -0.23982398f, 0.41607946f, 0.12230329f, -0.03129566f, 
    -0.00265702f, -0.22878425f, 0.21899641f, -0.39335760f, 0.14223403f, 0.12662426f, -0.94074196f, -0.39681187f, 
    0.22093381f, -0.26803914f, 0.02721651f, 0.09709058f, -0.48145780f, -0.04453481f, 0.04610517f, 0.17792858f, 
    0.05890887f, 0.06150294f, 0.06057221f, -0.56658643f, -0.07807070f, -0.20476669f, -0.15880829f, -0.29742116f, 
    0.15559781f, 0.17810133f, -0.67811763f, -0.01925857f, -0.20399295f, 0.00429725f, 0.08675230f, -0.52715844f, 
    -0.27739730f, 0.07761267f, -0.03611949f, -0.05524390f, 0.48252243f, 0.13424625f, -0.61126107f, 0.84298670f, 
    0.10883234f, -0.06895386f, 0.17353983f, -0.24289319f, 0.01034760f, -0.55189621f, 0.06495571f, -0.53995794f, 
    0.61619997f, 0.26310232f, 0.75243479f, 0.60300457f, 0.05844332f, -0.07558744f, -0.21283907f, -0.43595648f, 
    -0.12580319f, -1.04071486f, 0.15545222f, -0.75263131f, 0.11695410f, 0.03540862f, -0.39579901f, -0.01723457f, 
    0.05614696f, -0.00256739f, 0.01005453f, 0.00260404f, 0.14370306f, -0.04181986f, 0.05323744f, 0.56399119f, 
    -0.05519169f, 0.10353877f, -0.00302057f, 0.03230671f, 0.15154472f, -0.65759271f, -0.65264302f, 0.46714279f, 
    -0.22244322f, -0.04108803f, 0.47979003f, -0.85769606f, 0.07584679f, -0.41199479f, 0.31302148f, -0.65989137f, 
    -0.37027431f, 0.00990352f, 0.01583882f, 0.04593619f, -0.06720955f, -0.28719914f, -0.00038769f, 0.05755503f, 
    0.09996592f, -0.93819815f, -0.47300458f, -0.02400500f, -1.38071668f, 0.16756520f, 0.60550398f, -0.05022953f, 
    -0.26168755f, 0.05314557f, 0.16610275f, -0.03476923f, -0.42255425f, -0.74141282f, -0.11133268f, 0.12251202f, 
    0.07524814f, 0.49458665f, 0.03887487f, -0.27916688f, 0.17598814f, -0.02414076f, -0.31362683f, 0.02549448f, 
    -0.06621403f, 0.10864618f, -0.18512471f, -0.62705857f, 0.04846779f, 0.22429378f, -0.08003835f, -0.06696914f, 
    -0.02114185f, 0.26615393f, 0.09281552f, -0.33898035f, 0.34363794f, -0.06196361f, 0.05219996f, -0.16244575f, 
    0.03205215f, -0.05664612f, -0.01654604f, -0.04293460f, -1.12235522f, -0.02481084f, 0.00544931f, 0.01511818f, 
    -0.02956150f, 0.04763181f, 0.06454059f, 0.19248760f, 0.10622986f, -0.43596521f, -0.01093668f, 0.21441990f, 
    0.20148715f, -0.17496064f, -0.29464260f, 0.03914501f, -0.20396855f, -0.07274348f, 0.04126206f, -0.26353651f, 
    -0.00734776f, -0.01428959f, 0.18045838f, -0.00620641f, -0.23256636f, -0.94475096f, -0.11624292f, -0.83302665f, 
    -0.36672896f, -0.03466592f, 0.30046591f, -0.53519255f, -0.04854912f, 0.20951800f, 0.00124019f, -0.13704854f, 
    -0.85655236f, -0.00525992f, 0.22457077f, 0.03576278f, -0.03264770f, -0.03106976f, 0.31786391f, 0.27604219f, 
    -0.56383961f, -0.52215409f, 0.20656697f, -1.05256677f, -0.12513646f, 0.00874096f, 0.43176329f, -0.15874453f, 
    -0.43692225f, -0.31732306f, -0.32874802f, -0.21780746f, -0.52513170f, 0.06447491f, 0.16248432f, 0.03617952f, 
    -0.60278159f, -0.03173018f, -0.06085458f, -0.05458122f, -0.43200055f, -0.53713721f, -0.52822250f, -0.20317970f, 
    -0.07741700f, 0.30879557f, 0.13471465f, 0.52192712f, 0.10651155f, 0.39324749f, 0.17652200f, -0.03999858f, 
    -0.34331551f, -0.07338765f, 0.06446492f, 0.11094749f, -0.13415353f, 0.07183199f, 0.05345068f, -0.05013872f, 
    -0.04046039f, 0.22459254f, 0.20265236f, -0.24040078f, -0.33500707f, 0.13437128f, -0.23662938f, -0.17906056f, 
    -0.28749976f, 0.03001845f, 0.10985336f, -0.12746742f, -0.01619648f, -1.33685994f, 0.16197453f, -0.14596161f, 
    -0.32862324f, -0.33182731f, 0.06200721f, -0.85748780f, -0.08221661f, -0.10238342f, 0.18877003f, 0.10003102f, 
    -0.03710172f, -0.12279495f, -0.41341534f, -0.90627152f, -0.25717887f, -0.61184490f, 0.13116798f, -0.00079278f, 
    0.00083757f, 0.29545826f, -0.00688150f, -0.18327095f, -0.17169210f, 0.28358701f, 0.37168995f, 0.07242030f, 
    0.15348212f, -0.21882667f, -0.01043369f, 0.01684447f, 0.14790048f, 0.06940255f, 0.03002430f, 0.22745577f, 
    -0.20410757f, 0.20388776f, 0.02810201f, -0.10893345f, 0.10582820f, 0.13153687f, 0.24421257f, -0.89326704f, 
    0.15058945f, 0.20863231f, -0.90428507f, 0.03147839f, 0.29595882f, 0.13428234f, -0.05077288f, -0.01047933f, 
    -0.23629062f, 0.00073912f, 0.24669448f, 0.02452751f, 0.03874295f, -0.48847109f, 0.22588190f, 0.12119910f, 
    0.00617147f, -0.11287697f, 0.16346422f, -0.74143744f, 0.13964967f, -0.24574924f, 0.05682845f, 0.08671831f, 
    0.10494352f, -1.01162934f, -0.50257945f, 0.00234495f, 0.06293572f, 0.39932543f, 0.26993927f, -0.03457858f, 
    -0.74540305f, 0.19191264f, 0.15614554f, 0.01052865f, 0.15660095f, 0.29021266f, 0.10736505f, -0.17563601f, 
    -0.09802110f, -0.03428758f, -0.29230502f, 0.12307644f, 0.25212607f, 0.13504234f, 0.10597675f, 0.05360644f, 
    0.32793716f, 0.18905991f, 0.05088590f, -0.46043250f, -0.50199175f, 0.39355835f, 0.01131556f, 0.24557851f, 
    -0.06362769f, -0.66368443f, -0.35443464f, -0.70049816f, 0.10758319f, -0.15232666f, 0.40730140f, -0.31122997f, 
    -0.12987094f, 0.01053350f, -0.11440055f, -0.47851902f, -0.65095013f, 0.43325612f, 0.01220390f, -0.07827639f, 
    -0.03986203f, 0.19676509f, 0.02854510f, -0.00198222f, -0.31031975f, -0.29853371f, -0.12814873f, -0.50456202f, 
    -0.17811419f, 0.06269661f, -0.11515346f, 0.05623341f, 0.08225331f, -0.09319684f, -0.01377109f, -0.49748364f, 
    -0.14212151f, 0.46053746f, 0.04441369f, -0.43146226f, 0.21937269f, 0.37276134f, -0.22615241f, -0.04409404f, 
    -0.12642826f, 0.05468631f, -0.32672679f, 0.13803495f, 0.06556838f, 0.17373680f, 0.08177788f, -0.40142828f, 
    0.14470176f, 0.08057956f, -0.02761700f, -1.42152512f, -0.07956601f, 0.18222010f, 0.20477340f, -0.45505583f, 
    -0.05787173f, 0.12431313f, -0.04494916f, -0.03420875f, -0.29615676f, -0.13874759f, -0.01136770f, 0.13171613f, 
    0.42106986f, 0.03525170f, 0.07559957f, -0.13048473f, -0.40016738f, -0.03993828f, -0.04799387f, 0.34752500f, 
    0.00908247f, -0.33364674f, -0.06604300f, 0.02593598f, -0.28215057f, -0.07416796f, 0.01848881f, -0.06080099f, 
    0.24378644f, -0.04618110f, -0.24416444f, -0.00548576f, -0.09671317f, -0.06649862f, 0.16011786f, -0.08572438f, 
    0.20377870f, 0.32152539f, 0.10328384f, 0.31624749f, 0.00450852f, 0.44328621f, 0.01420340f, -0.07720785f, 
    -0.23041251f, -0.40854937f, 0.09064028f, 0.11040283f, 0.02979199f, -0.30187032f, 0.20926398f, -0.20901868f, 
    0.00872548f, 0.24621026f, -0.22662295f, -0.90929675f, -0.71490484f, -0.52125937f, -0.50799584f, 0.03279012f, 
    -0.08911208f, 0.11752471f, 0.57631707f, -0.20752601f, 0.13287002f, -0.74081153f, -0.27183375f, -0.35335326f, 
    0.19479236f, -0.19993320f, 0.03267014f, 0.29595828f, 0.06372120f, -0.21076380f, -0.09298546f, -0.31651098f, 
    -0.07352060f, 0.17847419f, 0.00635369f, -1.28397453f, -0.03067547f, 0.21827808f, -0.60894728f, -0.17838334f, 
    0.55063576f, 0.14815401f, 0.19388016f, 0.21714661f, -0.64925200f, -1.26822460f, 0.32772291f, -0.10237899f, 
    0.07388988f, -0.28800091f, 0.26403704f, -0.08957184f, -0.09413112f, -0.22533756f, 0.06264425f, -1.00067306f, 
    0.26399738f, -0.05236882f, -0.22646384f, 0.24522221f, -0.07810438f, 0.07594705f, 0.16899931f, -0.37567976f, 
    -0.94948906f, -0.67714435f, -0.03323753f, 0.04294379f, -0.04907950f, 0.28123727f, 0.31880817f, -0.13499118f, 
    0.11204971f, -0.23894773f, -0.04539657f, -0.56348723f, -0.65136272f, -0.11733316f, -0.06985419f, 0.21897309f, 
    -0.21149670f, -0.39671868f, -0.01809791f, -0.21445760f, -0.12036996f, -0.13309443f, -0.00346984f, -0.00386430f, 
    -0.12902048f, 0.24851419f, -0.01441323f, 0.02830347f, 0.26599714f, 0.26086709f, -0.20279814f, -0.09017949f, 
    0.14162779f, -0.11852869f, -0.05476163f, 0.19317450f, 0.10626627f, -0.53766435f, -0.40416169f, -0.18894485f, 
    -0.74150056f, -0.38559598f, -1.04116654f, -0.07861456f, 0.29626366f, 0.00971384f, -0.08305940f, 0.32791299f, 
    0.38350198f, -0.48946530f, -0.01718136f, -0.00251314f, 0.20481546f, -1.31714749f, 0.06376825f, -0.39472634f, 
    -0.45781997f, 0.10658765f, 0.21451747f, 0.62847292f, -0.21223003f, -0.82317817f, 0.07322571f, -0.45859522f, 
    0.08282924f, -0.27150944f, -0.20352249f, -0.65177041f, -0.02002049f, -0.56053036f, -0.10710353f, -0.09229362f, 
    -0.31086230f, -0.24099335f, -0.00117912f, 0.24861094f, -0.01559682f, -0.30150810f, -0.01653550f, -0.18094030f, 
    0.06631813f, 0.08350848f, 0.50818783f, -0.06546892f, -0.25787395f, 0.07357557f, 0.07656278f, 0.12860775f, 
    0.10321066f, -0.43396890f, 0.02483370f, 0.11900150f, 0.30200988f, -0.33148062f, 0.22883451f, -0.29150423f, 
    -0.05555874f, 0.34913418f, 0.02801481f, -0.21406013f, 0.20713620f, 0.10637252f, -0.71395415f, -0.49126357f, 
    0.05526008f, -0.13795464f, 0.00723103f, -0.06948072f, -0.38420144f, -0.04303918f, 0.01875935f, -0.22479963f, 
    0.09179626f, -0.31369177f, 0.31170875f, -0.19130296f, -0.41998911f, -0.64374620f, -0.10105786f, -0.36808130f, 
    -0.85420787f, 0.26118734f, -0.06142396f, -0.20395339f, 0.15617150f, 0.12043502f, -0.34501532f, 0.16791911f, 
    0.01262537f, -0.36594400f, -0.07900741f, -1.10232031f, -0.29168555f, -0.35453057f, 0.17286369f, 0.14500040f, 
    -0.01135260f, 0.11778913f, -0.54065657f, 0.44100651f, -0.21571194f, -0.30106649f, -0.08359689f, 0.08968349f, 
    -0.37091020f, 0.10903957f, -0.38503149f, -0.23192902f, 0.15324074f, -0.00805754f, -0.14343557f, 0.16886090f, 
    0.21041201f, -0.02854719f, -0.02139341f, 0.19535203f, -0.47395426f, 0.18754959f, 0.15297821f, -0.05936419f, 
    -0.40800902f, -0.16043547f, -0.01014010f, -0.13031273f, 0.37684366f, -0.23988853f, 0.14915532f, 0.15281600f, 
    0.02508579f, -0.53798836f, -0.19818561f, -0.05337745f, 0.01424549f, 0.09927928f, 0.03185308f, 0.17069773f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.29071403f, 0.16320233f, -0.18130970f, -0.06147685f, -0.07585277f, 0.08083231f, -0.00593062f, -0.30413017f, 
    0.14778396f, 0.12242372f, 0.07199540f, 0.06499488f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
