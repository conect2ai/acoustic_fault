#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.48362646f, -0.82899451f, -0.58463705f, 0.08979116f, 0.18173881f, 0.93977851f, 1.64455211f, 0.36292997f, 
    0.57287735f, 0.46298534f, -0.10977568f, -0.75368661f, -0.22567493f, -0.42421249f, -0.24099919f, -0.28426999f, 
    -0.00802032f, 0.03170968f, 0.09025585f, -0.70435673f, -0.24088536f, -0.66137230f, -0.36533064f, -0.33248743f, 
    0.10862996f, -0.96939397f, 0.97156483f, 0.51997626f, -1.01733077f, 1.22277629f, 1.29462743f, -0.51984888f, 
    -1.07386804f, -0.46163717f, -1.08058858f, -0.02881612f, 0.05072322f, -0.07525235f, 0.18936276f, -0.55866748f, 
    -0.54241949f, -0.23223734f, 0.15726301f, -0.32798511f, 0.13165937f, -0.03123141f, -0.04722212f, -0.34013730f, 
    -0.06042767f, -0.17655845f, -0.53892088f, -0.76590347f, -0.38500059f, 0.58493549f, -0.25880671f, -1.43776274f, 
    -0.09075439f, 0.55830002f, -1.10762489f, -0.05735351f, 0.60833335f, 0.54605430f, -0.45307830f, 0.07637543f, 
    0.13767235f, -0.06257337f, 0.00997084f, -0.52595133f, -0.10813294f, -0.59140259f, -0.29076397f, -0.29731104f, 
    0.05794010f, 0.00768329f, -0.23882493f, 1.00332618f, 0.16123340f, 0.85662842f, -0.56131023f, 1.30222797f, 
    -0.63852900f, -0.56292713f, -0.90486068f, -0.95862979f, -0.55956435f, 0.15182878f, 0.25931185f, 0.18594123f, 
    0.64466113f, 0.01852397f, 0.01285995f, 0.06246638f, -0.36709601f, 0.10910323f, 0.17433783f, 0.40885103f, 
    0.34280854f, -0.00806458f, -0.09957660f, -0.10739879f, -1.71663344f, -1.56154168f, -0.07649931f, 0.89351088f, 
    0.38414910f, 0.90076631f, -0.02703690f, 0.01037286f, 0.68748581f, -0.35899860f, -0.18537638f, 0.26510775f, 
    -0.10426673f, 0.72083032f, 0.24717166f, 0.11454038f, 0.30788293f, 0.22793788f, -0.01637360f, 0.17558053f, 
    -0.13070270f, 0.04194205f, -0.16364622f, -0.27278334f, -0.16910885f, 0.99990189f, -0.55585939f, -0.58713233f, 
    1.25786197f, 1.38281083f, 0.95061094f, -0.06401001f, -0.63700461f, 0.61109036f, -0.11242881f, 0.17075872f, 
    0.48008955f, -0.43205455f, 0.08400328f, 0.16057172f, 0.52717268f, -0.25440127f, -0.06325385f, -0.19344740f, 
    -0.26792172f, 0.48131591f, 0.12757294f, 0.13949050f, 0.10036265f, 0.34795839f, -0.19304380f, -0.79666674f, 
    -1.31512296f, -0.96652210f, -0.16830984f, -0.04536216f, -0.66921341f, -0.46385965f, -0.02343754f, -0.39633676f, 
    -0.49268061f, 0.14028512f, 0.70817906f, 0.25555891f, -0.35245502f, -0.30160898f, 0.16643374f, -0.65678084f, 
    -0.24204499f, 0.06291525f, -0.14494509f, -0.09164279f, 0.45238966f, -0.56855094f, -0.50162899f, 2.21367502f, 
    1.38320494f, -0.50855678f, 0.37084588f, -1.30584264f, -0.56387389f, 0.30938086f, 0.09904721f, 0.22284043f, 
    0.40173796f, 0.11213098f, 0.05675101f, 0.44844338f, 0.16297196f, -0.06020433f, -0.06088821f, -0.03808316f, 
    -0.05936994f, 0.06010009f, 0.14669949f, 0.17992666f, 0.14186502f, 0.19927208f, -0.04818176f, -0.12364922f, 
    1.80008471f, 0.96423823f, 0.62984562f, 1.75033104f, 1.47098374f, -0.17639318f, 0.21221174f, 0.21060485f, 
    0.34968433f, -0.08481874f, -0.50925952f, -0.17121395f, 0.26528624f, -0.24371175f, 0.15480931f, -0.10535081f, 
    -0.16698593f, 0.37324250f, 0.12371850f, 0.06190890f, 0.22777584f, -0.26271841f, 0.02144920f, -0.09167007f, 
    0.29442441f, -0.92712021f, -0.53004533f, -0.99371684f, 0.25626135f, 0.80247366f, -1.05039239f, 0.37554321f, 
    1.03409600f, 0.62699276f, 0.05308530f, -0.18361139f, -0.42255569f, -0.29969740f, -0.05099894f, -0.49465120f, 
    0.03597102f, -0.18349916f, 0.26163164f, -0.13120747f, -0.05183187f, 0.37906402f, 0.54661685f, 0.00499062f, 
    0.55163318f, -0.09783570f, 1.17168868f, -0.93627334f, 0.86415851f, -0.48532423f, -0.28760153f, 1.17973483f, 
    0.20026310f, 0.97206777f, 0.05868323f, -0.35047624f, 0.12053236f, 0.70972794f, -0.54935110f, 0.00156886f, 
    -0.27855983f, -0.17992882f, -0.16662423f, -0.31171662f, -0.25984949f, -0.35271290f, 0.22613104f, 0.05409091f, 
    0.27066797f, 0.21994358f, -0.16921017f, -0.96237773f, -0.65010166f, 0.00170599f, -0.61960828f, -0.78041273f, 
    -1.06203997f, 0.93221325f, 0.76519644f, -0.64022362f, 0.17770772f, -0.60575366f, -0.09229867f, 0.20832609f, 
    -0.01992492f, -0.05117660f, -0.22483902f, -0.15671541f, -0.30788285f, 0.07291609f, 0.06576275f, 0.45005906f, 
    0.54799575f, 0.28624997f, 0.07729249f, 0.23834416f, 0.89760637f, -1.50308025f, 0.82495278f, 1.56251800f, 
    0.30241033f, -0.71861726f, 0.62295210f, 0.86314559f, -0.20580660f, 0.43926424f, 0.60053569f, 0.15667325f, 
    -0.25268418f, -0.06350120f, 0.08065806f, -0.39519677f, 0.03225323f, 0.11232726f, 0.02929752f, -0.13939722f, 
    0.04053837f, 0.34460571f, -0.00373047f, -0.09474815f, -0.02297926f, -0.41716409f, -1.70934892f, -1.13261759f, 
    -0.36369070f, -0.16219072f, 0.12715451f, 0.89211214f, 0.88570559f, -0.25079009f, 0.69080299f, 0.05513483f, 
    0.19244941f, -0.24574989f, 0.29735613f, -0.23643732f, -0.27065918f, 0.12151551f, 0.05336751f, -0.00386903f, 
    -0.07446536f, -0.07366292f, 0.02411153f, 0.09217484f, 0.11371702f, 0.30519938f, -1.17501462f, -0.18126683f, 
    0.95728248f, 0.34045067f, 0.99736863f, -0.60248077f, -0.40086275f, 0.02790165f, -1.06060982f, -0.84221363f, 
    0.41344824f, 0.15340230f, 0.46815485f, 0.58494508f, -0.31560293f, 0.40269417f, 0.12435119f, 0.66272926f, 
    -0.05225812f, 0.47662580f, -0.12936990f, 0.04858018f, -0.44665030f, 0.53485423f, 0.12734364f, -1.57881987f, 
    0.36481705f, -0.65265089f, -0.87925005f, -0.96093142f, 0.70212251f, 0.74129486f, -0.68870586f, 0.60621983f, 
    1.22200429f, -0.25161782f, -0.16838068f, -0.06731580f, -0.06622964f, -0.12417702f, 0.08279172f, 0.42861423f, 
    0.61179590f, 0.40378696f, -0.01638378f, 0.08287998f, 0.04797091f, 0.32016331f, 0.08082025f, 0.32504949f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24105297f, 0.29797903f, 0.34538105f, 0.29082680f, 0.44259876f, 0.39219749f, 0.65902323f, 0.56065542f, 
    0.35084245f, 0.37359369f, 0.16830364f, 0.39194864f, 0.16107497f, 0.45062160f, 0.46783924f, 0.25367710f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.29956046f, 0.23494379f, 0.16711152f, -0.11136638f, 0.18388896f, 0.02703861f, 0.02969088f, 0.04308820f, 
    0.02306153f, -0.04540455f, -0.07614088f, 0.03391383f, -0.58178705f, 0.01803656f, 0.55992991f, -0.31372553f, 
    -0.15223469f, 0.13500308f, 0.21374120f, -0.14995721f, 0.06655081f, 0.01141097f, 0.00099842f, -0.03334125f, 
    -0.39378816f, -0.26683956f, -0.11045172f, 0.41975579f, -0.05204618f, -0.05667231f, -0.13418730f, -0.25861487f, 
    -0.05299615f, 0.02221379f, 0.17484021f, -0.01847781f, 0.36476803f, 0.02225538f, 0.16607712f, -0.44742841f, 
    -0.17439072f, 0.15456717f, -0.08981674f, 0.15804426f, -0.02806397f, -0.22187915f, -0.08851426f, -0.10018905f, 
    -0.53326958f, -0.18376879f, -0.24685645f, 0.20413655f, 0.37286291f, 0.05913547f, -0.02697353f, -0.03624491f, 
    -0.00306891f, -0.14208399f, 0.11846742f, -0.06308056f, 0.02908331f, -0.05316826f, 0.10739365f, 0.41498870f, 
    0.16960824f, -0.00083935f, -0.07170720f, 0.11985402f, -0.33124804f, 0.02284492f, 0.06932539f, -0.40415919f, 
    -0.39521757f, -0.55664915f, 0.23820052f, 0.00124668f, -0.00408041f, 0.02792329f, 0.11889254f, 0.03932174f, 
    -0.10452818f, -0.14862372f, -0.28449857f, -0.08457005f, -0.25911000f, -0.00142807f, -0.00887514f, -0.12300481f, 
    -0.34876159f, -0.19419603f, -0.15080410f, 0.10405735f, -0.00159212f, -0.05210596f, 0.09235895f, 0.14925970f, 
    0.32048440f, 0.06477852f, -0.17906724f, 0.43465912f, -0.46123859f, 0.03045366f, -0.09475854f, 0.13102837f, 
    -0.12332352f, 0.08828077f, -0.04312881f, 0.03750343f, -0.53272158f, 0.66389757f, 0.00436456f, 0.03298791f, 
    -0.00702498f, 0.04944747f, -0.10931931f, -0.02491308f, -0.00273583f, 0.06512651f, 0.05408949f, 0.08807711f, 
    0.16103415f, 0.05342109f, 0.04441628f, -0.10700837f, -0.04813811f, 0.12484579f, -0.03542005f, -0.27983823f, 
    -0.16880907f, 0.13226642f, 0.20524123f, -0.05167642f, -0.15036736f, 0.03451619f, -0.07043049f, -0.11306707f, 
    0.11306313f, 0.13229758f, 0.09680431f, 0.16603959f, 0.23296763f, -0.07469946f, 0.04228183f, -0.03425894f, 
    0.25670525f, -0.08589780f, -0.49679941f, 0.66171312f, -0.32127005f, -0.04007120f, 0.00480298f, -0.15733092f, 
    -0.10615297f, 0.00520400f, -0.18945715f, -0.02037298f, -0.26914981f, 0.21256521f, -0.10802747f, -0.74540514f, 
    0.09317670f, -0.06631579f, -0.12130793f, 0.07653467f, -0.01138373f, 0.12872078f, -0.07222582f, 0.01746710f, 
    -0.71256983f, 0.03159960f, -0.23601301f, 0.15543649f, -0.08456194f, 0.01705049f, 0.05020737f, -0.03709277f, 
    0.06788887f, -0.21774904f, -0.00209731f, -0.07845409f, 1.01101458f, 0.16627695f, -0.09811659f, -0.34131050f, 
    0.22925314f, 0.01427430f, -0.07151236f, -0.00042772f, 0.10547797f, -0.05400188f, -0.08015682f, 0.09246605f, 
    0.08751403f, 0.03625228f, -0.21767594f, 0.02944704f, 0.17980455f, 0.25912517f, -0.28250650f, -0.05188502f, 
    0.01637876f, 0.23893747f, -0.07032378f, -0.19387554f, 0.11511041f, -0.59177661f, -0.31082115f, -0.32333246f, 
    -0.04995392f, -0.03491206f, -0.11081608f, -0.01144022f, -0.17509072f, 0.03403005f, 0.01295749f, -0.17729813f, 
    -0.22692986f, 0.07302021f, -0.25699258f, 0.32997036f, -0.14691570f, 0.05205217f, -0.14765748f, 0.09495235f, 
    -0.12374089f, -0.07484185f, -0.25982445f, -0.00159937f, -0.10604426f, -0.15436718f, 0.20785564f, -0.04042903f, 
    0.08254833f, -0.20032395f, -0.01643338f, -0.08966810f, 0.06488799f, 0.13227089f, -0.04498687f, 0.09540927f, 
    0.36421350f, 0.55030960f, -0.56871444f, 0.01704464f, 0.00599909f, 0.06118024f, -0.02580920f, 0.10302249f, 
    -0.14094901f, 0.01469260f, 0.19749498f, 0.08022839f, 0.26350352f, -0.51867878f, 0.28159678f, -0.04284260f, 
    -0.15097967f, 0.14880607f, -0.12596811f, 0.10328658f, 0.00297259f, -0.02866587f, -0.15025592f, 0.15585899f, 
    0.04096397f, -0.01943101f, 0.22758766f, -0.34948760f, -0.14356253f, -0.18432982f, 0.24401556f, -0.00412861f, 
    -0.24762999f, -0.00233720f, 0.05000204f, -0.20296462f, 0.67515254f, -0.23872627f, 0.25187290f, -0.10034192f, 
    -0.11916105f, -0.37067407f, 0.13963009f, 0.06731266f, -0.00947007f, 0.04285180f, -0.11210153f, 0.19033799f, 
    0.60940480f, 0.14363702f, 0.17492247f, 0.69520491f, -0.09331180f, -0.03357730f, -0.06292855f, 0.12227562f, 
    -0.01188675f, -0.10333662f, 0.05753215f, -0.12335198f, 0.29673943f, -0.03131742f, -0.22752948f, -0.15401965f, 
    0.12366330f, 0.05128005f, -0.18046926f, 0.16376203f, 0.21988729f, -0.13269436f, -0.22020723f, 0.12101452f, 
    0.31943262f, -0.13326755f, 0.15648939f, -0.04016833f, -0.02699575f, 0.00781406f, -0.02780025f, -0.00902248f, 
    -0.06276903f, -0.20581952f, -0.27772394f, 0.06563860f, -0.09771495f, 0.13670734f, -0.23194844f, -0.02588661f, 
    0.05127246f, -0.11720634f, -0.18008047f, 0.00365245f, 0.09289724f, 0.05387582f, -0.07538363f, -0.06177581f, 
    -0.35346463f, -0.15503258f, 0.14436056f, 0.44792858f, -0.19981854f, -0.02703375f, 0.00462084f, 0.02642432f, 
    0.19237058f, -0.07550193f, 0.07278042f, -0.23052227f, 0.32338551f, -0.33739898f, -0.12643982f, -0.07381284f, 
    -0.13402711f, 0.16615815f, 0.09320881f, 0.06276564f, 0.12899020f, -0.26507428f, 0.01715910f, 0.09690899f, 
    -0.04251499f, -0.04240787f, -0.29439819f, -0.19508851f, 0.10521314f, 0.09449818f, -0.14603469f, -0.12354765f, 
    -0.15741920f, 0.19289564f, 0.14745139f, -0.03327676f, -0.77163190f, -0.08122716f, -0.14260943f, -0.36089036f, 
    0.08325689f, -0.26464507f, 0.09447254f, 0.08339703f, 0.31462681f, 0.12998097f, 0.01173504f, 0.02396215f, 
    0.38713500f, 0.00466920f, 0.20054714f, 0.19613537f, -0.12064183f, -0.12823722f, 0.03738008f, 0.31242025f, 
    0.17535830f, 0.03006856f, -0.06558596f, -0.11123286f, -0.20161323f, -0.23277782f, 0.05842916f, -0.12891349f, 
    0.11212188f, -0.00351988f, 0.10930061f, -0.06806270f, -0.21730389f, 0.09928878f, -0.29619363f, -0.05195059f, 
    0.90096718f, -0.28928155f, -0.17486393f, -0.44767365f, -0.18581679f, 0.18245699f, -0.08743514f, -0.14509761f, 
    0.04989440f, 0.06060844f, 0.18069839f, -0.28439221f, -0.40238523f, 0.09836307f, -0.35325369f, -0.31640413f, 
    0.27315953f, -0.06523512f, 0.03860161f, -0.31049424f, 0.14002712f, -0.00818731f, -0.05063065f, -0.12253828f, 
    0.20329092f, -0.29210666f, 0.06949356f, 0.09938965f, -0.38507766f, -0.03562753f, -0.30298358f, -0.26027179f, 
    -0.03636642f, -0.08234300f, -0.16888240f, -0.12019344f, -0.19334269f, -0.60121030f, 0.06517450f, -0.00552032f, 
    0.17130056f, 0.13576853f, -0.07704900f, -0.04127029f, -0.00288540f, 0.14416157f, -0.05774258f, -0.22403860f, 
    -0.67598438f, -0.32600045f, -0.17974746f, -0.37782237f, -0.03051840f, -0.08525106f, 0.08482981f, -0.02957095f, 
    0.23213990f, -0.00685248f, -0.25571811f, -0.11364800f, 0.14047658f, 0.11014575f, -0.23685041f, -0.28528109f, 
    -0.02453282f, -0.09723336f, 0.06066655f, 0.11190911f, -0.20149529f, 0.08800574f, 0.22710776f, -0.09174971f, 
    -0.16428712f, 0.16457218f, -0.18795168f, 0.02899779f, 0.17002040f, 0.03523176f, -0.10274564f, -0.03232330f, 
    0.00503905f, 0.12476227f, -0.09843555f, -0.08579416f, 0.16868895f, -0.14522114f, -0.44481647f, 0.38522771f, 
    -0.34687385f, 0.26024479f, -0.11786176f, -0.20940663f, 0.06984773f, 0.13538897f, 0.12650529f, 0.07986857f, 
    -0.45969450f, 0.27160233f, 0.23664936f, -0.10117903f, -0.07404188f, 0.02142742f, 0.03308481f, 0.01704869f, 
    -0.28415158f, -0.02719109f, 0.06031261f, -0.13746010f, 0.52674001f, 0.19156089f, -0.46703541f, 0.19649757f, 
    -0.24188542f, -0.03940956f, -0.11970279f, 0.02860327f, 0.04976331f, 0.03411059f, 0.05628121f, 0.10572054f, 
    0.41753531f, 0.20567855f, -0.06031287f, -0.06613243f, -0.13074011f, 0.21149100f, -0.02152759f, -0.00403775f, 
    -0.10229590f, 0.09693755f, -0.10841085f, -0.01212128f, 0.44857109f, -0.05154229f, 0.20877734f, 0.35892177f, 
    -0.21990995f, -0.38702962f, 0.06473909f, 0.12437422f, -0.02441697f, 0.04828217f, -0.11204680f, 0.08910619f, 
    0.55727291f, 0.11490746f, -0.69307494f, 0.21942002f, 0.09513427f, 0.16876140f, -0.09226909f, -0.04711136f, 
    -0.15587825f, -0.10358386f, 0.02043308f, -0.14064609f, 0.48432443f, 0.06959164f, 0.15795876f, 0.19959147f, 
    -0.13661763f, 0.02366738f, -0.05266951f, 0.03628992f, -0.11529952f, 0.21904597f, 0.09612580f, -0.13966899f, 
    -0.24947847f, -0.05634097f, -0.30157110f, -0.16802703f, -0.03199147f, -0.08258975f, 0.05577360f, -0.06716025f, 
    0.01049295f, -0.08988931f, 0.09323636f, 0.00806552f, 1.10269678f, 0.18658543f, 0.27155843f, 0.26153624f, 
    0.04712565f, 0.05482666f, -0.11320632f, 0.13485467f, 0.05589285f, -0.09328702f, -0.14855152f, -0.04625308f, 
    -0.01693488f, 0.23243271f, 0.41582739f, -0.00816129f, 0.14182766f, -0.03170393f, 0.06994415f, 0.01563334f, 
    0.14493251f, 0.09821040f, 0.13954736f, 0.09610158f, -0.21941535f, -0.03705897f, 0.26052856f, 0.15084708f, 
    0.06695832f, 0.21695594f, 0.17250994f, -0.00886475f, -0.06820515f, -0.02809972f, 0.08713793f, -0.18605559f, 
    0.32367337f, -0.16958410f, -0.30641508f, -0.04807864f, -0.05981323f, -0.17038409f, -0.01684631f, 0.09448131f, 
    -0.04651274f, -0.07491482f, 0.17561349f, -0.02868596f, 0.34216613f, 0.05229663f, -0.17646201f, 0.39731759f, 
    0.01981628f, 0.22899081f, -0.02626600f, -0.12782699f, 0.15675707f, 0.11913293f, 0.06427291f, -0.09679166f, 
    0.19170669f, 0.06804173f, -0.12416107f, 0.06919496f, -0.04227126f, -0.08011620f, -0.29705450f, 0.14917669f, 
    0.03850895f, 0.09435041f, 0.01817764f, 0.07302769f, -0.13116744f, -1.14562011f, -0.70292008f, 0.02076312f, 
    -0.17581312f, 0.01055813f, -0.05453110f, 0.03058144f, 0.10084566f, -0.05904732f, -0.08060408f, 0.13788928f, 
    -0.37484866f, -1.13965690f, -0.25958991f, -0.20539348f, 0.10284305f, -0.17176262f, 0.01455285f, -0.14479871f, 
    -0.00684785f, -0.15294270f, -0.00963338f, 0.04304389f, 0.10376028f, 0.21210368f, 0.25484568f, 0.17520045f, 
    -0.20925669f, -0.12071032f, 0.18927620f, -0.22848669f, -0.10230690f, 0.05546668f, -0.02971708f, -0.09750870f, 
    -0.21783490f, -0.40589190f, -0.26883319f, -0.19348779f, 0.04319920f, 0.10656583f, 0.05658805f, 0.04210108f, 
    -0.06701923f, 0.09049789f, -0.01925426f, -0.15443398f, 0.26815444f, 0.27418894f, 0.16999041f, -0.07095432f, 
    -0.08711556f, -0.26304495f, -0.01944828f, -0.02182791f, -0.04165513f, -0.12167083f, 0.07808845f, 0.25603896f, 
    -0.47523946f, -0.32287681f, 0.05173710f, 0.14593756f, -0.12798280f, 0.28603005f, -0.01683060f, 0.01719204f, 
    -0.17902070f, 0.15614551f, -0.12958404f, -0.23737986f, 0.33042020f, -0.35739741f, -0.11898429f, 0.06163206f, 
    -0.18504305f, -0.09682976f, -0.03526951f, -0.21706973f, -0.24744923f, 0.00946706f, 0.02515160f, 0.11025696f, 
    -0.46021158f, 0.02601121f, 0.66882205f, 0.17027244f, 0.12802354f, 0.09416908f, 0.14865774f, 0.03136601f, 
    -0.07742416f, 0.02312566f, -0.23513253f, -0.09140915f, -0.32815960f, 0.36542952f, -0.16708685f, -0.47427145f, 
    -0.09601228f, -0.09464148f, -0.06686591f, 0.03156886f, 0.00032011f, -0.31232432f, -0.14032137f, 0.16632333f, 
    -0.85523349f, 0.01785647f, -0.09522586f, 0.21757960f, -0.08423796f, -0.27039409f, 0.24464343f, 0.00155989f, 
    -0.06616533f, 0.09772887f, 0.14696383f, 0.20863441f, 0.22201028f, 0.55288833f, -0.32525450f, -0.43034348f, 
    -0.01337548f, 0.11411723f, -0.00798257f, -0.01931299f, -0.23017751f, 0.04313101f, 0.12858637f, 0.05167854f, 
    -0.30179811f, -0.22620292f, -0.07277886f, 0.11854663f, 0.05812481f, 0.06367950f, 0.11606543f, 0.01544121f, 
    -0.13823675f, 0.05568176f, -0.12385320f, 0.09879691f, -0.45163506f, -0.35499132f, 0.16618411f, 0.25488722f, 
    -0.03763013f, 0.03316270f, -0.07844868f, -0.10223886f, 0.22133204f, -0.16186246f, -0.03287937f, -0.08112070f, 
    -0.34353572f, 0.31597412f, -0.25214288f, -0.38462251f, 0.02095629f, 0.05733005f, -0.02305597f, 0.13801418f, 
    0.23157063f, -0.09922469f, -0.01486161f, -0.00372371f, 0.17043695f, 0.28714508f, -0.18723351f, 0.07502397f, 
    -0.18451133f, -0.07516150f, 0.19748838f, 0.00209822f, -0.04115216f, -0.16425858f, -0.03022194f, 0.10666659f, 
    0.07974762f, 0.10894373f, -0.05706543f, 0.16923870f, 0.00734437f, 0.10618459f, 0.10839271f, 0.42906612f, 
    0.18451321f, 0.21183814f, -0.03076635f, 0.12703238f, -0.03286477f, -0.57627374f, -0.00196257f, -0.08846656f, 
    -0.05599001f, 0.02909678f, -0.02535222f, -0.31085312f, -0.08134438f, 0.03636904f, 0.04815530f, -0.10160381f, 
    0.52676004f, 0.02476138f, -0.02687902f, 0.05072805f, -0.01655500f, 0.10473961f, -0.01508616f, 0.10261024f, 
    0.13787512f, 0.04350824f, -0.00552171f, -0.06113977f, 0.42242780f, -0.08626217f, -0.25831556f, 0.12225135f, 
    -0.08434651f, 0.14273515f, 0.16216488f, -0.06873343f, 0.04285713f, -0.05812858f, 0.11183812f, -0.03894619f, 
    -0.42950770f, 0.22441585f, 0.03224446f, -0.33894759f, 0.10855224f, 0.12458535f, -0.19728951f, 0.02733716f, 
    -0.01857203f, -0.13507067f, 0.04419450f, 0.05385236f, -0.52625400f, -0.19712794f, 0.22998601f, -0.16850157f, 
    0.08836130f, -0.09210927f, 0.03960625f, 0.10318176f, -0.15701823f, -0.29617339f, 0.07285372f, 0.07691005f, 
    -0.62336218f, 0.13172688f, 0.18414131f, -0.17352149f, 0.03451229f, 0.07141671f, 0.10934372f, 0.04174934f, 
    -0.08823606f, 0.02730273f, -0.14992410f, -0.17215441f, -1.21210849f, 0.32032204f, -0.14049074f, 0.25441855f, 
    0.22335160f, -0.09139537f, -0.00431717f, 0.07965648f, -0.02050683f, 0.11830390f, 0.08964208f, 0.05744103f, 
    -0.26286414f, 0.31247282f, 0.34172824f, 0.04027523f, 0.09836001f, -0.19959600f, 0.06783386f, 0.04509045f, 
    0.01079156f, 0.11853389f, -0.20609319f, -0.09117255f, 0.04211304f, -0.20561178f, 0.30953297f, 0.30057582f, 
    -0.16504775f, -0.18886106f, -0.09092699f, 0.04965342f, -0.13723457f, 0.03446762f, -0.01998586f, 0.03454806f, 
    -0.09208596f, 0.25667062f, -0.03114067f, -0.18165903f, -0.05284314f, 0.07907622f, -0.22067522f, -0.44533244f, 
    0.01875603f, -0.29403749f, -0.09351342f, -0.18126070f, -0.30191696f, -0.41498113f, 0.42215678f, 0.24203420f, 
    -0.05856771f, -0.01430613f, 0.13435331f, 0.03399175f, -0.02700791f, 0.11047763f, -0.06752677f, -0.00093644f, 
    0.15725368f, -0.10736365f, 0.09752728f, -0.28260672f, 0.19482379f, -0.07322906f, -0.01985968f, -0.11509379f, 
    0.02700655f, -0.06339679f, -0.17428842f, -0.07219235f, 0.32143214f, 0.12433944f, 0.45918143f, 0.29249457f, 
    -0.16390656f, 0.00966120f, 0.05425940f, 0.10014457f, -0.18403460f, 0.15243010f, 0.16594537f, 0.27743849f, 
    -1.08087111f, -0.03713816f, 0.13221830f, -0.15470552f, 0.14197299f, 0.10502871f, 0.12528633f, -0.32272670f, 
    -0.05739370f, 0.18636288f, 0.03596620f, -0.08512821f, -0.07703759f, 0.13509519f, 0.10544433f, -0.50077260f, 
    0.12568060f, 0.05388626f, -0.05782132f, 0.10661907f, 0.22841507f, 0.18929483f, -0.02575997f, 0.25550455f, 
    -0.13569655f, -0.63250035f, -0.01902346f, 0.12103073f, 0.02281340f, 0.01392706f, -0.21214370f, -0.08095003f, 
    0.09475507f, 0.11476871f, 0.27895981f, -0.00069978f, 0.38036659f, 0.49123555f, 0.02594361f, -0.01916041f, 
    -0.08146539f, -0.02274643f, -0.09288745f, 0.06341361f, 0.05745404f, -0.18043621f, 0.03114313f, -0.13038577f, 
    -0.02131198f, -0.08165360f, 0.43752027f, -0.37401187f, -0.01382053f, 0.25320616f, -0.01296416f, -0.14401880f, 
    0.05132619f, -0.07307508f, 0.15057123f, 0.26025021f, -0.07065482f, 0.12790783f, -0.03674015f, -0.46074775f, 
    -0.04428760f, 0.05340932f, 0.06597077f, 0.05539798f, 0.08328556f, -0.03311857f, -0.12725744f, -0.21415262f, 
    -0.36263710f, -0.05985760f, 0.13870817f, 0.21599790f, -0.10615685f, -0.31226170f, 0.05151696f, -0.05900066f, 
    0.27076581f, -0.13024823f, -0.34626612f, -0.08119442f, -0.40791425f, -0.36941618f, -0.77619129f, 0.05791850f, 
    0.20624578f, 0.11899279f, 0.15491436f, 0.25611255f, 0.00230597f, 0.13146342f, -0.07343022f, -0.15666975f, 
    -0.54508585f, 0.13231292f, 0.12221378f, -0.13032947f, 0.08864135f, -0.25053307f, -0.18520114f, 0.07695323f, 
    0.07052343f, -0.24250509f, 0.14729561f, -0.01463311f, -0.48150903f, 0.12555027f, -0.41152772f, -0.11626185f, 
    0.25419039f, 0.09092548f, -0.01384362f, 0.04099572f, -0.09302593f, -0.01547501f, 0.02943207f, 0.06740496f, 
    0.09350164f, -0.31665814f, -0.04361077f, 0.05575163f, -0.10719463f, 0.08477346f, 0.06701676f, 0.09928049f, 
    -0.03598112f, 0.04503245f, 0.22938003f, 0.36128336f, -0.12857991f, -0.00366051f, -0.20210499f, -0.11517866f, 
    0.16452903f, 0.18768606f, 0.13456158f, -0.25605899f, 0.05974103f, -0.23936464f, 0.27108693f, 0.00794798f, 
    0.03239963f, -0.80040348f, -0.06741001f, -0.28446448f, -0.17472376f, 0.28103146f, 0.05467204f, 0.17050453f, 
    0.21624109f, 0.03007096f, 0.03530200f, 0.45618969f, 0.10993575f, -0.34632558f, -0.03962317f, 0.11433993f, 
    -0.02562389f, 0.06428778f, 0.03995869f, 0.00882912f, 0.21377088f, -0.01921491f, -0.21980664f, 0.29486766f, 
    0.14467601f, -0.04426799f, -0.24453899f, -0.14176485f, -0.08180115f, 0.04301452f, 0.32611862f, 0.11234839f, 
    0.11932109f, 0.00033950f, 0.20738302f, -0.18380861f, 0.23638161f, 0.17320129f, -0.03338523f, -0.21479550f, 
    0.13005123f, 0.00593101f, -0.02609609f, -0.01870467f, -0.28074262f, -0.16698575f, 0.22419329f, 0.01889382f, 
    -0.19040942f, -0.53702617f, 0.10776682f, -0.16133285f, -0.08269184f, -0.01569783f, -0.01217484f, 0.09152283f, 
    0.04725851f, 0.02641326f, -0.20774232f, -0.09562112f, -0.01929704f, -0.09338494f, -0.08042128f, -0.31267056f, 
    -0.09471860f, 0.09457994f, 0.10780966f, 0.05253721f, 0.11571491f, -0.20317505f, 0.11472778f, -0.22627082f, 
    0.08879647f, 0.12697721f, -0.26900503f, -0.34096852f, -0.10170323f, -0.18065646f, 0.10996006f, -0.12612940f, 
    0.08872585f, 0.06434761f, -0.08903290f, 0.25982085f, -0.50684440f, 0.01325105f, 0.27594277f, 0.51005566f, 
    0.08033950f, 0.28337729f, -0.16462998f, 0.05179585f, 0.06481309f, 0.11071203f, -0.08024491f, -0.10155127f, 
    -0.23962104f, 0.37749177f, 0.34323537f, -0.76870805f, -0.15438655f, 0.01218262f, 0.18371603f, 0.12478034f, 
    0.07540525f, 0.05502766f, -0.11806558f, 0.15437809f, -0.22301088f, -0.19358119f, 0.08582582f, -0.16499677f, 
    0.21314543f, -0.07034393f, 0.18281932f, -0.18872795f, -0.16203870f, -0.18328843f, 0.15652519f, 0.13769031f, 
    0.05415453f, -0.17995533f, -0.07616267f, 0.61271590f, -0.05179077f, -0.03841297f, 0.02787450f, -0.16881447f, 
    -0.10358775f, 0.01475205f, 0.02046451f, 0.12714829f, 0.03328143f, -0.35736418f, -0.03259330f, -0.25823969f, 
    -0.22151098f, 0.06690887f, 0.01053924f, -0.28777492f, 0.07395031f, -0.12342416f, 0.10936777f, 0.11268709f, 
    1.12359333f, -0.43786106f, 0.42741138f, -0.24277778f, -0.07327687f, -0.04852137f, 0.22178240f, 0.05638396f, 
    -0.13044713f, 0.00454633f, -0.12927020f, -0.02046177f, 0.01898079f, -0.24230623f, -0.10096756f, -0.39778045f, 
    -0.12136145f, -0.03339129f, -0.05408524f, -0.19679107f, -0.02052452f, 0.15745644f, 0.00692195f, 0.08625729f, 
    0.15161282f, 0.02629106f, 0.01072189f, -0.22295199f, -0.00333553f, 0.08230652f, 0.17162685f, 0.12346373f, 
    0.17070748f, -0.10674103f, -0.42118505f, -0.39124212f, -0.06427404f, 0.03205083f, -0.14069489f, 0.15727472f, 
    -0.12523767f, 0.06100740f, -0.12268845f, -0.02540171f, -0.16781066f, 0.34956539f, -0.35475695f, -0.03369250f, 
    -0.29883465f, 0.24779780f, 0.16185905f, -0.13334413f, -0.06529257f, -0.04395454f, 0.04223749f, 0.06497641f, 
    -0.17632048f, 0.10251171f, 0.08790249f, -0.08641421f, -0.11456893f, 0.35333562f, -0.14695689f, 0.34569678f, 
    -0.01949064f, -0.09297912f, 0.01761249f, -0.05066660f, -0.12503743f, -0.08176331f, -0.02532167f, -0.29194185f, 
    0.46594152f, -0.07635319f, 0.30249920f, -0.04247459f, -0.19451214f, -0.13046047f, -0.12040743f, -0.17074636f, 
    -0.08487359f, -0.04835247f, -0.01157419f, -0.10256515f, -0.16827205f, -0.53083557f, -0.27307710f, 0.12133641f, 
    -0.18224466f, -0.17894255f, 0.00533783f, -0.05262849f, 0.02770476f, -0.06241294f, 0.20605133f, -0.12386233f, 
    -0.27653497f, 0.10120912f, 0.19848758f, -0.10642435f, 0.14822605f, 0.01791026f, -0.10449739f, -0.00524150f, 
    -0.09749716f, -0.02960474f, -0.08116002f, -0.04566669f, -0.77616715f, 0.23601685f, -0.14882724f, -0.12920779f, 
    -0.28133988f, -0.07320827f, -0.06620266f, -0.04397935f, -0.12780023f, 0.02457349f, -0.16554536f, -0.22561091f, 
    0.23149921f, 0.31735268f, 0.08949336f, 0.23505513f, -0.00363741f, 0.11653802f, -0.08489834f, -0.12139194f, 
    -0.06816205f, -0.17738269f, -0.05874414f, -0.11663289f, -0.29982480f, 0.13878860f, -0.03784044f, -0.26075748f, 
    -0.13867384f, 0.17321403f, -0.05494507f, -0.04275491f, -0.10901504f, -0.09912290f, 0.11050380f, -0.18432106f, 
    -0.47000539f, 0.24434103f, -0.04959708f, -0.32305852f, 0.01340488f, 0.04190350f, -0.08778672f, -0.22474903f, 
    -0.03270008f, -0.15916377f, -0.17538416f, -0.24940352f, 0.11173990f, -0.19296917f, 0.09443077f, -0.21534556f, 
    0.10203659f, -0.06199178f, -0.16592203f, 0.09474020f, -0.07691529f, 0.25400388f, 0.09247313f, -0.04306508f, 
    -0.20201333f, -0.52746409f, -0.26390815f, -0.12007090f, -0.07610615f, 0.12079459f, -0.17365843f, 0.05387330f, 
    0.15729631f, 0.07821193f, 0.11405997f, -0.08730385f, 0.23626290f, 0.15862598f, 0.39968619f, 0.14798172f, 
    0.24358305f, 0.03781294f, 0.09384622f, -0.11903809f, -0.10589045f, 0.00309897f, -0.15775864f, -0.10183989f, 
    0.80795366f, 0.31194940f, -0.25055444f, -0.20285884f, -0.26748064f, 0.00195306f, -0.00252277f, -0.08813807f, 
    -0.18377085f, -0.01904922f, 0.04213094f, 0.12234652f, 0.06015772f, 0.07134198f, 0.38636249f, 0.14373276f, 
    -0.06468714f, 0.19359487f, 0.19493851f, -0.03336608f, -0.03159896f, 0.20103486f, -0.10108030f, 0.04618627f, 
    0.21188554f, -0.48717040f, 0.17256984f, 0.18184386f, -0.08662242f, -0.12326950f, -0.03287559f, -0.19908048f, 
    0.16927315f, 0.10279214f, -0.25679910f, -0.23559059f, -0.06747626f, 0.31861019f, 0.17428052f, 0.28231388f, 
    0.34482986f, 0.05224657f, 0.12911169f, -0.01600309f, -0.11833352f, 0.11588594f, -0.03629036f, -0.01592766f, 
    0.34201261f, -0.12849779f, 0.20917732f, 0.10060490f, -0.29171824f, -0.06134617f, -0.25959286f, -0.48362014f, 
    -0.16553393f, -0.21283004f, -0.09010838f, -0.26953247f, -0.13119283f, -0.03127505f, -0.30516639f, -0.07620386f, 
    -0.05801369f, -0.14721522f, -0.52129555f, 0.25442582f, 0.07809574f, 0.10031879f, 0.18533295f, 0.01850758f, 
    -0.34846935f, -0.17241438f, 0.09960909f, -0.55542082f, 0.05851819f, -0.20969652f, 0.20746784f, -0.21782628f, 
    -0.02331978f, 0.06188768f, -0.14462417f, 0.32994100f, -0.40144920f, -0.26282996f, -0.77344877f, -0.29408580f, 
    -0.15824008f, -0.22794776f, -0.22435559f, 0.09542817f, 0.30031422f, 0.14692003f, 0.03064804f, -0.06558487f, 
    -0.29928285f, -0.40691963f, 0.55129480f, -0.04483632f, -0.20167288f, -0.12370092f, -0.18800421f, -0.16690710f, 
    -0.14836150f, 0.20429572f, 0.05249278f, -0.05864697f, -0.15273918f, -0.26808545f, 0.23839267f, 0.23832065f, 
    0.02513400f, 0.04939158f, 0.01616358f, 0.14956105f, -0.01143120f, 0.14356412f, -0.03006656f, 0.08192854f, 
    -0.62332428f, 0.18349831f, 0.05857725f, -0.47803244f, 0.13672771f, -0.13905846f, -0.18894514f, 0.10818290f, 
    -0.00134897f, -0.04857425f, 0.10397055f, -0.21366735f, 0.21169341f, 0.14264624f, -0.52945471f, -0.09340075f, 
    0.15186909f, 0.03912160f, -0.03782057f, -0.02600068f, 0.12374698f, 0.26167753f, 0.01542844f, 0.00870281f, 
    0.25442645f, -0.44035017f, 0.21708804f, 0.54657799f, 0.33600107f, 0.01212501f, -0.01948876f, -0.17722145f, 
    -0.11942989f, -0.03495501f, 0.31826279f, -0.28750387f, -0.02611297f, -0.09405973f, 0.28547797f, -0.10647015f, 
    -0.09818444f, 0.02698083f, 0.03726318f, 0.05254377f, 0.06477250f, -0.09298226f, -0.02027004f, -0.06219617f, 
    0.44224691f, 0.67288899f, -0.06818187f, 0.00187938f, -0.13434787f, 0.10893655f, 0.12141114f, -0.09406526f, 
    0.16134062f, 0.05207615f, -0.20711030f, 0.12653999f, -0.05633357f, -0.15095502f, 0.23920967f, -0.26387301f, 
    0.16578831f, 0.19444121f, -0.00703962f, -0.12155785f, 0.12812030f, -0.00301046f, 0.08284338f, -0.13545717f, 
    0.27421060f, -0.19022797f, -0.02482290f, -0.06318904f, 0.26824617f, -0.18829463f, -0.03820467f, 0.02195607f, 
    0.11047702f, -0.01796477f, 0.16092378f, -0.09527751f, -0.33430576f, 0.09270161f, 0.36505741f, 0.02798394f, 
    -0.08833607f, -0.08222236f, -0.10766542f, -0.14419685f, 0.04488646f, -0.17129813f, -0.08060750f, 0.08657251f, 
    0.12259815f, -0.47379005f, -0.06508709f, -0.11974937f, -0.04534607f, 0.10261861f, 0.01007338f, -0.17375933f, 
    -0.12471011f, 0.12243018f, 0.20261805f, 0.13985969f, -0.08432732f, -0.01875562f, -0.06849023f, 0.20852201f, 
    -0.23480405f, -0.05312295f, 0.07298958f, -0.00765160f, 0.18713333f, -0.18164486f, 0.04580338f, -0.01155554f, 
    -0.04509361f, 0.07388066f, 0.03652557f, 0.09671640f, 0.40683475f, -0.02435693f, -0.00905204f, 0.16338955f, 
    0.03473401f, 0.11466219f, 0.09014906f, 0.06910935f, -0.55550891f, 0.20098802f, -0.42870280f, -0.29256243f, 
    0.07349110f, -0.20364156f, -0.06590038f, 0.02538301f, 0.03194737f, -0.01526495f, 0.04346862f, -0.00432163f, 
    -0.19726509f, -0.24272330f, 0.01685097f, 0.08518736f, -0.21476275f, 0.00447811f, 0.03964262f, 0.09797084f, 
    0.23885946f, 0.07266276f, 0.37424728f, -0.10390634f, -0.18677923f, 0.29729539f, -0.51193702f, -0.31488088f, 
    -0.16105373f, 0.20887996f, 0.02008859f, -0.18425378f, -0.20051500f, -0.07637158f, -0.09799156f, -0.00729112f, 
    0.51747590f, -0.28416577f, -0.19165425f, 0.53653830f, 0.20874201f, -0.22834934f, 0.00039862f, -0.10276124f, 
    0.12789214f, -0.22930767f, -0.12456872f, 0.12502801f, -0.37375432f, 0.80556184f, -0.46332878f, -0.22951329f, 
    0.20307568f, -0.06725741f, -0.02113257f, -0.13632947f, -0.07280038f, 0.04414807f, 0.08069916f, -0.04639560f, 
    -0.48120561f, -0.22833088f, 0.03774170f, 0.38470662f, 0.04624880f, 0.28577957f, -0.15454482f, 0.04470145f, 
    0.09852967f, -0.10567128f, 0.01501771f, -0.08947879f, -0.47332448f, 0.33529636f, 0.39396265f, 0.06603158f, 
    -0.00324840f, 0.15479143f, 0.29854649f, -0.06786779f, -0.04246897f, -0.06309383f, 0.16197541f, 0.08090086f, 
    -0.71443671f, 0.31842691f, -0.43914771f, -0.11820477f, -0.01718222f, -0.07411928f, 0.12814216f, -0.18412185f, 
    -0.04199738f, -0.03770026f, -0.16498466f, -0.09482739f, -0.01492426f, -0.36615726f, 0.22310908f, 0.42749262f, 
    -0.06649874f, -0.01190247f, -0.13688882f, 0.05328077f, -0.37969896f, 0.05804903f, 0.08281357f, 0.10404148f, 
    0.71599430f, 0.23764773f, -0.12417181f, 0.23491365f, -0.02897281f, -0.03566134f, 0.12958127f, -0.00865960f, 
    -0.16948929f, 0.09264594f, 0.31204969f, 0.20044361f, -0.02061439f, -0.32657036f, -0.02047943f, 0.15548266f, 
    0.10746881f, -0.01132479f, 0.01604282f, -0.15696892f, -0.21623185f, 0.25828227f, -0.16529682f, -0.00471568f, 
    0.00562946f, 0.29426363f, -0.13280778f, -0.28288907f, -0.03449723f, -0.12320670f, 0.01285276f, -0.25881276f, 
    -0.03467327f, 0.10428125f, -0.07700118f, 0.30272302f, 0.17969924f, -0.32729411f, 0.14025736f, -0.03930914f, 
    0.20327757f, 0.11113789f, -0.11408754f, 0.16845234f, 0.09231395f, 0.13618676f, -0.07435322f, -0.15547442f, 
    0.29089803f, 0.05850542f, -0.38620237f, -0.11137111f, 0.13336237f, -0.11604867f, -0.08821083f, -0.01247238f, 
    0.09025516f, 0.00579693f, -0.19514148f, 0.05917351f, -0.24026170f, -1.16436422f, 0.17256778f, -0.31158552f, 
    0.11222792f, 0.08201245f, 0.00735295f, 0.17083062f, -0.16841306f, 0.03927318f, -0.06905523f, 0.02750230f, 
    0.47909155f, 0.07227397f, -0.13567297f, -0.14237587f, -0.19466843f, -0.09906297f, -0.04653040f, -0.01384254f, 
    -0.06723051f, -0.10500199f, -0.31077743f, -0.46813771f, -0.05429642f, 0.11769569f, -0.02841164f, -0.18426266f, 
    0.26365918f, -0.07069287f, -0.04249776f, 0.09918224f, 0.11704972f, -0.12829654f, 0.02338726f, 0.06410080f, 
    0.02192295f, 0.29034337f, 0.04593228f, 0.07594936f, 0.20987983f, 0.20325719f, -0.20527425f, 0.17570147f, 
    -0.12296179f, -0.32496238f, -0.34584802f, 0.14866307f, -0.03879483f, -0.02771153f, 0.11345882f, -0.48825672f, 
    0.27796835f, -0.23159482f, -0.14383592f, 0.21686164f, 0.05559983f, 0.11876513f, -0.15644784f, 0.31951091f, 
    0.34951535f, 0.22122437f, -0.19176397f, 0.10824563f, -0.20715977f, -0.03863978f, 0.07187933f, 0.08277934f, 
    -0.10658783f, -0.03585736f, -0.03879988f, -0.07011904f, -0.01514272f, -0.23046333f, -0.00907857f, 0.06592702f, 
    0.07507480f, -0.14497793f, 0.05015703f, 0.26686001f, 0.00833634f, -0.02541947f, 0.16399615f, 0.21980365f, 
    0.34073311f, 0.00808177f, 0.03876907f, -0.10788482f, -0.18123369f, 0.04457424f, 0.08718974f, -0.10390229f, 
    -0.27188420f, -0.00182085f, -0.04314528f, -0.12922709f, -1.42789018f, -0.73249745f, 0.46365529f, 0.13137738f, 
    0.23982273f, 0.06253453f, 0.16813006f, -0.17214549f, 0.24164473f, 0.14759335f, 0.06841037f, 0.08498079f, 
    -1.29214442f, -0.85304451f, -0.38181385f, -0.41509727f, -0.10450010f, -0.09284724f, -0.18250792f, 0.01530852f, 
    -0.01663559f, 0.10812623f, -0.05053917f, 0.03675659f, 0.18063830f, -0.54699129f, -0.13680188f, 0.01487635f, 
    0.21937889f, -0.09210499f, 0.12291171f, 0.17082167f, -0.01442454f, 0.12095553f, 0.06940639f, 0.04338038f, 
    -0.18456574f, -0.18716891f, 0.24827582f, -0.04083329f, -0.01856022f, -0.03179353f, 0.02632245f, -0.02535107f, 
    0.25589180f, 0.08004740f, 0.04626697f, -0.20248494f, 0.30741414f, -0.18408835f, -0.06870040f, -0.09382460f, 
    -0.14452814f, 0.09014840f, -0.00282224f, -0.09917428f, 0.20570488f, 0.25401142f, -0.02577096f, -0.06987624f, 
    -0.45983896f, -0.36508545f, -0.28502133f, -0.14790542f, 0.19537632f, -0.10278855f, -0.00736136f, -0.06727235f, 
    0.05612053f, 0.10098606f, 0.09836435f, -0.02713330f, 0.50119060f, 0.14887865f, -0.03070197f, -0.13182262f, 
    -0.21642278f, 0.07873032f, 0.02336456f, -0.01982000f, 0.08085755f, 0.00929916f, 0.11629104f, -0.28174430f, 
    0.25935692f, 0.53669339f, -0.07978627f, -0.30772600f, -0.09125461f, 0.05214514f, 0.00519122f, 0.19337203f, 
    0.07762271f, 0.09713019f, 0.47586164f, 0.09571269f, -0.13696356f, 0.30537051f, -0.29720926f, 0.13830781f, 
    -0.30356780f, -0.05127057f, 0.02693273f, -0.13772574f, 0.01109135f, 0.14125533f, 0.30479467f, -0.08996998f, 
    -0.13462631f, -0.47626168f, -0.09794345f, -0.13951255f, -0.02206640f, -0.14741690f, 0.20091590f, 0.28453219f, 
    -0.16484274f, 0.05042334f, -0.01516682f, 0.03342446f, 0.03279753f, -0.10635220f, 0.07942520f, 0.78264213f, 
    0.04093945f, 0.11655886f, 0.03911380f, -0.09941243f, 0.09385532f, -0.05615957f, 0.23190971f, 0.07330772f, 
    -0.49169257f, 0.47955433f, -0.32248193f, -0.26524699f, 0.18412533f, 0.05218440f, 0.09676837f, -0.01515620f, 
    -0.14748122f, 0.11844436f, -0.09340174f, 0.00595606f, 0.45004022f, 0.06897687f, -0.46182185f, 0.53543699f, 
    0.03134954f, -0.24136049f, 0.29830191f, 0.15574953f, 0.00280004f, 0.06796586f, -0.02007233f, -0.14944272f, 
    0.43984285f, 0.13937144f, 0.40940341f, -0.24887484f, -0.14676760f, 0.08311780f, 0.18758886f, 0.19160195f, 
    -0.08621057f, -0.11632019f, -0.01768990f, 0.14232469f, 0.24315321f, -0.45925537f, 0.21063051f, 0.12281316f, 
    -0.11796576f, -0.15271898f, 0.03802085f, -0.10134748f, 0.00114335f, 0.04250443f, -0.12908611f, -0.06617869f, 
    0.28988609f, 0.17619404f, -0.43166751f, -0.06547515f, 0.05228575f, -0.08454240f, -0.07867387f, -0.35089517f, 
    0.00495454f, 0.02778381f, 0.10290588f, -0.01120241f, 0.34054634f, 0.81055105f, -0.19791298f, -0.06042248f, 
    0.27048823f, 0.03924908f, -0.15172744f, 0.01768701f, -0.00059662f, 0.18646075f, -0.10105070f, 0.01090278f, 
    -0.31040069f, 0.17116442f, -0.31424502f, -0.38701850f, 0.09639327f, -0.03160480f, -0.03322987f, 0.09513921f, 
    0.10727174f, 0.06354729f, -0.08533309f, -0.00567242f, -0.74081540f, 0.25577903f, 0.00197464f, -0.07870675f, 
    0.13717419f, -0.03596836f, -0.04730273f, -0.18095502f, 0.07832985f, 0.07337579f, -0.01082575f, -0.19502828f, 
    -0.87362045f, -0.87039202f, -0.18490501f, -0.30747634f, 0.25048035f, 0.16884297f, -0.13462813f, 0.24921297f, 
    -0.06453225f, -0.04030050f, 0.12513615f, -0.16543755f, -0.45856792f, 0.52403837f, 0.23108600f, 0.26046321f, 
    -0.23353356f, -0.10218503f, -0.14193313f, -0.04790062f, 0.14679691f, -0.07120250f, 0.21005093f, 0.05750063f, 
    -0.44979951f, 0.18504164f, -0.39532059f, -0.45704994f, 0.11197255f, -0.03688707f, -0.03454330f, -0.04028773f, 
    0.02885567f, 0.01542473f, 0.02542076f, 0.14177683f, -0.07621876f, -0.04599994f, -0.20734622f, 0.03775759f, 
    0.06768396f, -0.05556721f, 0.04854015f, -0.21288975f, -0.03053735f, -0.05984199f, 0.04244849f, -0.19259524f, 
    -0.30707818f, -0.10090290f, -0.06932630f, 0.08136372f, -0.11441056f, 0.25299937f, 0.04652902f, 0.07210961f, 
    -0.11094949f, -0.11417189f, 0.01418987f, 0.03059171f, 0.22089083f, -0.14391337f, -0.04014397f, 0.14464466f, 
    -0.26703906f, 0.02098417f, -0.19174896f, 0.04846573f, -0.07739930f, -0.05888951f, -0.22661467f, -0.23509015f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17400932f, 0.08258945f, -0.08447364f, -0.03572740f, 0.03229467f, 0.08126580f, 0.03283155f, -0.19562446f, 
    -0.01665882f, 0.01978340f, 0.23343097f, 0.05813947f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
