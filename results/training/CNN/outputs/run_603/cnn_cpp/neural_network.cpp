#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.78295928f, 0.24769008f, -0.73461401f, -0.57828963f, -0.07788492f, -0.40650901f, -0.02824526f, 0.21315356f, 
    0.35247883f, -0.42205328f, -0.30899060f, -0.19899690f, 0.36742964f, -0.16609837f, -0.33056179f, 0.23027276f, 
    -0.10478109f, 0.36046633f, 0.06942427f, 0.15902117f, 0.29833233f, 0.12087584f, -0.01978911f, 0.24058405f, 
    -0.16546771f, 0.69886780f, 0.48392427f, 0.27031305f, 0.38932383f, 0.84602827f, -0.00078625f, -0.51157057f, 
    -0.39392248f, 0.22814843f, 0.17135789f, 0.28262055f, -0.18182127f, 0.00755470f, 0.06797742f, -0.28217077f, 
    0.07017781f, 0.16235772f, 0.34012499f, 0.05637230f, 0.01572860f, 0.33371693f, 0.00029559f, 0.18718049f, 
    -0.00486219f, 0.11759083f, -0.40059948f, -0.65706325f, -0.71004242f, -0.23059140f, -0.40426087f, 0.16492102f, 
    0.58515811f, -0.04800818f, 0.16126056f, 0.51030225f, -0.02828280f, 0.05775069f, -0.28665859f, -0.00927174f, 
    0.40388882f, -0.18297002f, 0.02631851f, 0.24108310f, 0.35117745f, 0.01584817f, -0.09324122f, -0.10099784f, 
    -0.38671765f, 0.10603882f, -0.34399915f, 0.68932247f, 0.56431192f, 0.85503072f, 0.79215276f, 0.48989484f, 
    0.28820530f, 0.16813552f, -0.17684419f, -0.02349971f, -0.04787638f, -0.06162844f, 0.26278695f, 0.13512300f, 
    0.05717381f, 0.00826184f, 0.12168118f, 0.39949587f, 0.27540067f, 0.13394530f, -0.28755721f, -0.12370402f, 
    -0.23424837f, -0.12083577f, 0.23795369f, -0.14543577f, -0.30234277f, -0.23970544f, 0.08452335f, 0.19625454f, 
    -0.50996041f, -0.13911220f, 0.38868275f, -0.73626983f, -0.46606967f, -0.11652546f, 0.04232324f, 0.55904478f, 
    -0.21563347f, 0.20761377f, 0.13832852f, -0.36049905f, -0.17321056f, 0.16607213f, 0.02307296f, -0.23685047f, 
    0.11419407f, 0.24403083f, 0.29803890f, -0.12623917f, 0.35064599f, -0.55261552f, -0.09404893f, 0.06517152f, 
    0.46528366f, -0.13624705f, -0.33334598f, 0.31440413f, 0.30463976f, 0.10174984f, -0.73748153f, -0.30081156f, 
    0.00013585f, -0.48232630f, 0.01528804f, 0.14108442f, -0.22534347f, -0.06671248f, 0.37919363f, 0.12881927f, 
    -0.44230017f, 0.10746533f, 0.16927105f, -0.27376041f, 0.41386443f, -0.14344287f, 0.21372345f, -0.36435944f, 
    -0.32805365f, 0.19321111f, 0.36378595f, 0.48016751f, 0.67185146f, 0.46800444f, -0.22428286f, 0.37357736f, 
    0.22711194f, -0.32791603f, -0.01548702f, -0.01980112f, 0.29288507f, 0.26716307f, 0.01076223f, -0.28626531f, 
    0.21682288f, 0.23359206f, 0.24386841f, 0.16386257f, -0.00005604f, 0.26702458f, -0.16142371f, 0.35960016f, 
    0.09690055f, -0.07726515f, -0.25263637f, -0.64420658f, -0.15672956f, 0.74862331f, 0.64415002f, 0.38629264f, 
    0.69350618f, -0.32865480f, -0.28266186f, -0.52643508f, -0.27030203f, -0.20242128f, 0.02656349f, 0.19931644f, 
    -0.09620067f, -0.27194083f, -0.29342949f, -0.02133799f, -0.21117452f, 0.34317932f, -0.00526165f, -0.29684293f, 
    0.72796166f, 0.70930099f, -0.05361835f, 0.40993792f, -0.63006532f, -0.12812184f, 0.12255770f, 0.34695444f, 
    0.18295094f, 0.13576351f, -0.17779344f, 0.06409585f, 0.17832482f, -0.04386696f, -0.32434672f, -0.09708960f, 
    -0.01170948f, 0.20215984f, 0.18778157f, 0.28323931f, -0.34346196f, 0.21869597f, -0.31420100f, -0.34044215f, 
    -0.18108989f, -0.89418417f, -0.71519345f, -0.14786161f, 0.20999682f, -0.29511908f, 0.41817877f, 0.04021851f, 
    0.14436769f, 0.29751638f, -0.36953232f, -0.11930926f, 0.17785302f, -0.17363636f, 0.54498458f, -0.06175367f, 
    -0.12012743f, 0.01248973f, -0.21282326f, 0.06050400f, -0.20666271f, -0.12050483f, -0.17420010f, 0.14903417f, 
    -0.30673850f, 0.08267992f, -0.40658250f, -0.19609089f, -0.13909109f, -0.33548200f, -0.30765328f, -0.30616376f, 
    0.25442722f, -0.14870498f, -0.36477160f, -0.22089508f, 0.03518907f, 0.24171978f, -0.39075172f, -0.36427537f, 
    -0.50029200f, 0.08807025f, 0.13345970f, -0.22512539f, 0.20081171f, 0.32367060f, -0.24330378f, 0.00554382f, 
    0.09575718f, 0.29613343f, -0.21812889f, 1.03558207f, 0.52280843f, -0.12282100f, 0.63456219f, 0.59736156f, 
    0.01597466f, -0.28767180f, 0.72548568f, 0.48148647f, -0.19096456f, -0.43378255f, 0.03501702f, 0.20222937f, 
    -0.34161448f, -0.08432382f, -0.04725029f, 0.04746103f, -0.07431636f, -0.01988837f, 0.18593371f, 0.25134924f, 
    -0.04569230f, 0.20215890f, -0.08758900f, -0.08445642f, 0.61366928f, -0.80346215f, -0.56348419f, 0.79338861f, 
    0.09385435f, 0.34084120f, 0.78629982f, 0.05670915f, 0.40633947f, 0.35685605f, -0.15395488f, 0.24682349f, 
    -0.04964000f, 0.09152941f, -0.15573797f, -0.12751949f, -0.10737421f, 0.08297004f, 0.14776595f, -0.19877699f, 
    -0.02299836f, -0.28665981f, -0.16768470f, -0.21354116f, 0.03316142f, 0.52573782f, 0.67688352f, 0.41510502f, 
    0.03712785f, 0.72319448f, 0.47799721f, -0.32606786f, -0.49228400f, -0.46826133f, -0.50858766f, 0.45147476f, 
    0.28530148f, 0.05624042f, 0.07712929f, -0.10057975f, 0.31009635f, -0.24053700f, -0.15971409f, -0.14176610f, 
    0.09757178f, -0.07739053f, -0.06720035f, 0.26224917f, -0.22994308f, -0.00061214f, -0.50980151f, -0.45120558f, 
    -0.13270599f, 0.01819685f, 0.00154503f, -0.90021175f, 0.74757648f, -0.07631350f, -0.73340082f, 0.29644722f, 
    -0.17410116f, 0.48523340f, 0.24139905f, 0.23637339f, 0.32999718f, -0.13053027f, -0.25118259f, 0.15290229f, 
    -0.20523231f, -0.36401334f, 0.24046046f, -0.05579199f, -0.09513872f, 0.15902387f, -0.22645891f, -0.10274784f, 
    0.44809398f, 0.21261689f, -0.03951969f, -0.72259599f, -0.35097268f, -0.27550244f, -0.38893890f, 0.30028862f, 
    0.31200296f, 0.18141942f, -0.16423894f, -0.51233619f, 0.21030737f, -0.08721639f, 0.00920548f, 0.18375900f, 
    0.36904454f, 0.03705863f, -0.45114049f, -0.36455157f, -0.54443151f, -0.24294353f, -0.27664694f, -0.02597778f, 
    0.09872530f, 0.11655003f, 0.65522963f, -0.23323780f, -0.47351152f, -0.54791826f, 0.76169306f, -0.36383337f, 
    -0.21999218f, -0.12256470f, 0.14658296f, 0.31326118f, -0.22532965f, -0.07001969f, 0.04710470f, 0.24041508f, 
    -0.04552305f, 0.12207773f, 0.03730482f, 0.16203076f, 0.23181689f, 0.11361627f, 0.40812099f, -0.17546622f, 
    0.31586710f, -0.41820592f, -0.93969738f, -0.16202123f, 0.70784742f, -0.00375550f, -0.52892202f, 0.57853764f, 
    0.96492416f, -0.64007550f, -0.11576929f, 0.16204244f, -0.07783429f, 0.24402799f, -0.00551587f, -0.01882386f, 
    -0.37157875f, 0.02076901f, -0.30414009f, 0.00358749f, 0.01477739f, 0.00684635f, 0.01793090f, -0.05416570f, 
    0.19671032f, 0.08764185f, -0.12321068f, 0.81942058f, 0.73789245f, -0.73746932f, 0.24823223f, -0.72516364f, 
    0.28278196f, -0.07374834f, -0.35944438f, -0.57876402f, 0.09456718f, -0.04344388f, -0.04279348f, 0.39552200f, 
    -0.23777269f, -0.26095122f, -0.28939605f, -0.08495604f, -0.23545411f, 0.01003380f, -0.24487653f, 0.03222928f, 
    -0.00240580f, 0.12244378f, -0.10781933f, 0.56551647f, -0.47568461f, -0.38879845f, -0.55999762f, -0.37238532f, 
    -0.06948830f, -0.15218797f, 0.18326503f, 0.02576580f, -0.61056983f, 0.29102522f, 0.21586643f, 0.04804678f, 
    0.26722333f, 0.00782471f, 0.15339644f, 0.21807787f, 0.06511820f, 0.16771732f, 0.52425092f, 0.05718871f, 
    -0.11234039f, -0.08931243f, -0.24035932f, 0.04145436f, -0.46114185f, -1.09469271f, 0.53764212f, 0.14027126f, 
    -0.27880439f, 0.54900867f, 0.50021887f, 0.44449258f, -0.02771571f, -0.16886984f, -0.09842879f, -0.18236727f, 
    -0.20334668f, -0.16101570f, -0.33362740f, 0.21523750f, 0.30521601f, 0.01926221f, -0.12300080f, -0.29404077f, 
    -0.24463110f, -0.27643174f, 0.10021346f, 0.06446256f, -0.13937107f, 0.72212178f, 0.28826851f, -0.44010451f, 
    0.65912122f, -0.10305174f, -0.33649072f, 0.09023727f, 0.16870241f, -0.00809113f, 0.48988712f, 0.13254490f, 
    0.30431837f, 0.25235552f, -0.03112834f, -0.15166232f, -0.36979818f, -0.15242945f, 0.31784829f, -0.40899232f, 
    0.17981246f, -0.05705528f, -0.15621352f, -0.01446411f, 0.47623995f, 0.03009447f, 0.84883541f, 0.45606405f, 
    0.58362794f, 0.80324900f, 0.44379339f, 0.16309451f, 0.17482328f, -0.44579965f, 0.21465476f, -0.19010411f, 
    0.03798811f, 0.15426594f, -0.34299225f, 0.18446618f, 0.00151947f, -0.19193976f, -0.31854245f, 0.02418579f, 
    -0.13963720f, -0.22039011f, 0.14610040f, 0.55929965f, -0.15989339f, 0.09502174f, 0.43951041f, 0.07289488f, 
    0.45427576f, 0.57257164f, 0.76825148f, 0.18785720f, 0.14648694f, -0.14397882f, -0.85232270f, -0.70209551f, 
    0.07892050f, 0.38509607f, 0.06950536f, 0.26494718f, 0.16596837f, -0.23403804f, 0.06486599f, 0.28517342f, 
    -0.11081856f, 0.10220394f, -0.20404537f, -0.00469799f, 0.15871586f, 0.22262512f, -0.14376755f, 0.01372731f, 
    -1.21695530f, 0.89460248f, 0.71658236f, 0.13337652f, 0.29020339f, -0.10339006f, 0.53062433f, 0.60421008f, 
    0.35647306f, 0.05964985f, -0.52247488f, -0.01948765f, -0.03162385f, -0.10390569f, -0.18366973f, -0.00896291f, 
    -0.11862676f, -0.18391453f, 0.09335852f, -0.18468516f, 0.20780219f, 0.01981939f, -0.04067302f, 0.05777907f, 
    -0.06420891f, -0.45515394f, -0.27108818f, -0.45438355f, -0.66657627f, -0.57779175f, 0.32335082f, 0.35139871f, 
    0.04894537f, -0.28596848f, 0.29254118f, -0.38999835f, 0.07461295f, -0.24192819f, 0.21220024f, -0.29193062f, 
    -0.09464289f, -0.20358200f, 0.07627558f, -0.05426532f, 0.03922904f, 0.03321188f, -0.02927201f, -0.10564329f, 
    -0.01814025f, 0.14186713f, -0.25505447f, -0.04578017f, -0.00533941f, 0.05062839f, -0.21628210f, -0.24841687f, 
    0.08469697f, 0.70103014f, -0.33648291f, 0.13902833f, 0.51753205f, 0.44687316f, 0.36099598f, 0.05536472f, 
    0.14884405f, 0.19885434f, 0.32719550f, 0.29539460f, 0.03553221f, -0.06049991f, -0.10640854f, -0.33494785f, 
    0.18251856f, -0.31427258f, 0.10689356f, 0.70552552f, -0.45443076f, -0.15006571f, 0.21817462f, -0.38940731f, 
    -0.05331220f, -0.61036122f, -0.17802927f, -0.48160276f, -0.47236386f, -0.44936615f, -0.03437454f, 0.65902883f, 
    0.13537861f, 0.01965290f, -0.19457997f, -0.50101542f, 0.04631158f, 0.25747392f, -0.20046999f, 0.04927356f, 
    0.29892558f, 0.14311272f, -0.09435333f, -0.10365746f, 0.20749483f, -0.45122269f, -0.82004273f, -0.88650489f, 
    -0.23946293f, 0.28801313f, -0.11511628f, 0.35390729f, 0.72312093f, 0.31800213f, -0.25884518f, 0.13556093f, 
    -0.03189386f, -0.15077688f, -0.13952567f, 0.09117612f, -0.15362158f, 0.00019813f, 0.01374932f, 0.00784591f, 
    0.04410303f, 0.13460037f, -0.21481542f, 0.20845626f, 0.03841215f, 0.85261679f, 0.75485837f, -0.39286119f, 
    -0.79662365f, -0.71783072f, 0.29420739f, -0.39309949f, -0.33834344f, -0.39926609f, -0.01823564f, 0.34203407f, 
    0.30891344f, 0.20467576f, 0.10422651f, 0.06273819f, 0.15884480f, 0.01200864f, -0.13476178f, 0.18968771f, 
    0.35443425f, -0.18372707f, 0.35251349f, 0.29029748f, -0.18930583f, 0.15871736f, 0.18574977f, -0.35957098f, 
    -0.10836767f, -0.19457760f, -0.01749009f, 0.10209014f, 0.61890030f, -0.49948373f, 0.19754329f, -0.36481634f, 
    0.08218212f, -0.44273055f, 0.10943661f, -0.07178123f, -0.65547413f, -0.04446883f, -0.04404715f, 0.12198364f, 
    -0.26360223f, -0.63588625f, -0.06827513f, -0.25410879f, -0.37324846f, -0.20614588f, 0.05915972f, 0.14446016f, 
    0.31762046f, 0.43138909f, -0.05899183f, 0.00587287f, 0.28830305f, 0.62605441f, 0.42476925f, -0.28215173f, 
    0.48973474f, -0.45377845f, -0.09797420f, 0.18543570f, -0.09721015f, 0.15179972f, -0.49987334f, -0.38176346f, 
    -0.27760327f, -0.13164587f, -0.39781782f, 0.27093828f, -0.27930844f, -0.15746574f, -0.12989075f, -0.10097305f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.31647143f, -0.06671157f, 0.08542658f, 0.27958184f, 0.13544120f, 0.05689416f, 0.04827839f, 0.11837742f, 
    0.05912887f, 0.20161511f, -0.00173478f, 0.24545394f, -0.02809177f, 0.14475538f, 0.12410831f, 0.11178184f, 
    0.18679771f, 0.16989903f, 0.05617215f, 0.02169116f, 0.19338734f, 0.05088165f, 0.21891940f, 0.19625026f, 
    0.15621608f, -0.08339891f, -0.01817657f, 0.24146795f, 0.18703100f, 0.33373186f, 0.14928630f, 0.11945528f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04073821f, -0.01017603f, 0.01324429f, -0.00252013f, -0.03900099f, -0.00156076f, 0.01983667f, 0.02774799f, 
    0.04157065f, 0.01925529f, 0.03440743f, -0.05022815f, -0.00598060f, -0.03351250f, 0.01583145f, 0.01494242f, 
    -0.01977895f, 0.02913073f, 0.02711191f, -0.00140137f, -0.05010838f, -0.00076183f, -0.03854381f, 0.01111609f, 
    -0.02352444f, -0.02546515f, 0.01462486f, -0.02342593f, 0.02468870f, 0.03039182f, 0.01730347f, -0.02742465f, 
    0.00440950f, 0.00675387f, 0.01048309f, -0.01710942f, -0.05526982f, -0.03950436f, -0.04086661f, 0.00441992f, 
    -0.04939684f, 0.03376345f, 0.03470529f, -0.00626949f, 0.03954604f, -0.03463489f, -0.02715804f, -0.02128121f, 
    -0.02735492f, 0.02395710f, -0.00212708f, -0.03024806f, -0.01521298f, -0.00504430f, 0.00963965f, -0.00598241f, 
    -0.05155424f, -0.03733985f, -0.03042031f, -0.01415878f, -0.02233451f, -0.04419705f, -0.00896179f, -0.01147399f, 
    0.04179706f, -0.01702878f, 0.01937129f, 0.01547500f, 0.02259161f, 0.02863804f, -0.04216076f, -0.02104616f, 
    0.03797275f, -0.00454150f, -0.04010053f, 0.00057346f, -0.04085077f, -0.02136005f, 0.02490208f, 0.00022581f, 
    0.03709492f, 0.01787913f, 0.02636875f, 0.04011649f, -0.04136755f, 0.00821572f, -0.00699547f, -0.05155060f, 
    -0.02500135f, -0.00229174f, -0.01246287f, 0.00541996f, -0.02254982f, -0.01524604f, -0.00100769f, 0.01783087f, 
    0.00584652f, 0.02216901f, 0.02233053f, 0.03774344f, 0.02396842f, 0.03198087f, -0.04257803f, 0.03158035f, 
    -0.03970644f, -0.00893656f, 0.02214366f, 0.01864547f, -0.00554420f, 0.03814094f, -0.04966291f, -0.04631381f, 
    0.00076513f, -0.01094352f, 0.00775098f, 0.00397259f, 0.01613775f, -0.03730229f, -0.02532737f, -0.00199189f, 
    -0.04116851f, -0.01931339f, -0.00843981f, -0.00609489f, -0.03823122f, -0.02313814f, 0.00254483f, -0.02387220f, 
    -0.02091276f, 0.03059780f, -0.03747524f, -0.05646731f, 0.00336261f, -0.04947374f, 0.00718012f, -0.05247736f, 
    0.01104911f, -0.01308384f, -0.00996756f, 0.03216338f, -0.03230691f, -0.02753509f, 0.03668321f, -0.00159783f, 
    -0.01125991f, -0.00828654f, -0.04285307f, 0.00920235f, -0.04747982f, -0.02749539f, -0.02237128f, 0.02295782f, 
    0.01974249f, 0.01156540f, -0.00442994f, -0.00090135f, -0.04015617f, 0.02797289f, 0.03088840f, 0.02379528f, 
    -0.05143817f, 0.00613928f, 0.01479335f, -0.04901918f, -0.03785896f, 0.01740255f, 0.01985858f, 0.04119244f, 
    -0.03885854f, -0.00001077f, 0.01947716f, -0.05350656f, 0.01000755f, 0.03318312f, -0.00761780f, -0.03824702f, 
    -0.00741696f, -0.02106322f, -0.04850777f, -0.01119888f, -0.00241339f, 0.02377736f, 0.02249678f, 0.00068736f, 
    0.03380939f, -0.00252202f, 0.00776000f, 0.02447929f, 0.01673266f, -0.04594536f, 0.05505072f, 0.00504374f, 
    0.04167508f, -0.04806462f, 0.03709677f, 0.02422008f, -0.01562303f, -0.02663371f, 0.04064512f, -0.05118717f, 
    -0.03694383f, 0.02565459f, -0.02983447f, -0.03694959f, -0.04295958f, -0.02753195f, 0.04126389f, -0.00181681f, 
    -0.02473986f, -0.03798795f, -0.00391657f, -0.00656647f, 0.00980894f, -0.00786017f, -0.04399797f, -0.04573301f, 
    0.01069489f, -0.01300187f, -0.02121294f, 0.02283783f, 0.03559885f, -0.04783728f, 0.01363049f, -0.02783233f, 
    0.00065800f, 0.00454667f, 0.00208234f, 0.01789659f, 0.03542496f, -0.03419865f, 0.03229918f, 0.03704321f, 
    0.03778480f, 0.01883190f, 0.02342064f, -0.04843711f, -0.01135320f, 0.01751096f, -0.02821512f, 0.03300916f, 
    0.01043478f, -0.02369930f, -0.05274021f, -0.03099531f, 0.03854242f, -0.01860056f, -0.03425756f, -0.05417055f, 
    0.03911863f, -0.04496318f, -0.01002043f, -0.03153834f, 0.02021082f, 0.04472599f, 0.04469187f, -0.02983370f, 
    0.01880409f, -0.05665783f, 0.03034812f, 0.00309896f, 0.01282718f, -0.05382686f, -0.02068193f, -0.02476835f, 
    -0.01462384f, 0.00854791f, 0.00728657f, 0.03002240f, 0.03079870f, 0.01980115f, -0.02412245f, 0.02852351f, 
    -0.05284104f, -0.01896587f, -0.04135798f, -0.02062055f, 0.01255560f, -0.00185759f, -0.05644790f, -0.04928825f, 
    -0.03967356f, -0.05112444f, -0.05546109f, -0.00162491f, 0.01172606f, 0.01977723f, 0.02648539f, -0.02476908f, 
    -0.05407979f, 0.01984214f, -0.02752703f, -0.02470206f, -0.04443926f, -0.01232215f, -0.05700408f, -0.04203887f, 
    -0.04291017f, 0.01538272f, -0.04555782f, 0.02287501f, -0.03879246f, -0.02099875f, 0.01262946f, -0.03615164f, 
    -0.01640893f, 0.01132438f, 0.03612970f, -0.03495826f, -0.04449702f, -0.02293603f, 0.02977717f, 0.03695201f, 
    0.03307290f, 0.02788308f, 0.02589503f, 0.02686342f, 0.00258931f, -0.05629538f, 0.01886501f, 0.00219623f, 
    -0.04759115f, 0.01316164f, -0.04162784f, -0.02901095f, -0.03070256f, -0.04399813f, -0.00932356f, 0.03702093f, 
    0.02541142f, -0.02113875f, -0.02471719f, 0.01493369f, -0.03073820f, 0.04155335f, -0.00479802f, 0.00158331f, 
    0.03413431f, 0.02901586f, -0.00434680f, -0.00207855f, -0.03941180f, 0.01026071f, -0.02232539f, 0.03571311f, 
    -0.04757217f, 0.02996910f, -0.04805619f, -0.02505501f, -0.05611773f, 0.02710907f, -0.02843845f, -0.01675859f, 
    0.03519790f, 0.02768017f, 0.02132799f, -0.05304065f, -0.05290437f, -0.04565188f, -0.00809480f, -0.00022949f, 
    -0.03711903f, 0.01389774f, -0.01722516f, 0.03728870f, -0.02877853f, 0.01354252f, -0.02167390f, -0.00314284f, 
    0.00997350f, -0.02375745f, 0.02038776f, 0.04244419f, 0.02127132f, 0.02340257f, -0.04204755f, -0.00827263f, 
    -0.03977455f, -0.04812126f, 0.02388375f, 0.00324939f, -0.02525496f, -0.02961137f, 0.03295438f, 0.00151688f, 
    -0.41985014f, 0.10516766f, 0.16006830f, -0.05961367f, -0.00949413f, 0.09774990f, 0.00163074f, 0.00099215f, 
    0.11636548f, 0.06954576f, 0.13149974f, 0.06310969f, 0.17131744f, -0.16264534f, -0.01664333f, 0.04087580f, 
    0.16930170f, -0.05878070f, 0.07851207f, 0.08070522f, 0.13166106f, 0.06660606f, 0.18938568f, 0.00999414f, 
    0.27854168f, 0.01665250f, -0.00929273f, -0.04613045f, 0.01480402f, -0.02800890f, 0.01049034f, 0.03768434f, 
    0.03283800f, -0.01261620f, -0.09687638f, -0.04242421f, 0.02102377f, -0.17500657f, -0.22170430f, 0.02612863f, 
    0.08166463f, 0.02842683f, -0.10251929f, -0.07825372f, 0.01756542f, -0.07296871f, 0.12890486f, 0.07241466f, 
    0.05690582f, -0.09801669f, -0.13779958f, 0.05505630f, -0.10554646f, 0.06419832f, 0.16481869f, 0.02926257f, 
    0.13448700f, 0.02189331f, 0.09652386f, 0.04593075f, -0.36264679f, 0.07008513f, -0.05864516f, 0.21765421f, 
    -0.11360497f, 0.08039046f, -0.04090331f, 0.11230836f, 0.05235350f, -0.01866645f, -0.02852540f, -0.06807253f, 
    0.10990875f, 0.18076748f, 0.08236968f, 0.18660839f, 0.15481566f, -0.01260472f, 0.17977673f, 0.01774090f, 
    -0.00132621f, 0.07215116f, 0.00776820f, 0.12220248f, 0.29247484f, 0.18251202f, -0.05512310f, 0.02749121f, 
    -0.07876879f, -0.00115904f, 0.17230263f, -0.10916688f, -0.07193542f, 0.07228630f, -0.05275356f, -0.03214683f, 
    -0.05869681f, -0.01237867f, -0.17824294f, -0.02803165f, 0.12377740f, -0.06298754f, -0.10600914f, -0.02693960f, 
    0.01045237f, 0.06637739f, 0.12165546f, 0.05496216f, 0.01196360f, -0.04518552f, 0.22079046f, 0.08632110f, 
    0.02033172f, -0.05087962f, -0.02545973f, -0.00963628f, 0.14348188f, 0.04003600f, -0.05820630f, -0.06624638f, 
    -0.20794205f, -0.01972927f, -0.07190667f, -0.05611895f, -0.06713962f, -0.07624653f, -0.01769589f, -0.11174653f, 
    0.02957680f, -0.12923688f, -0.04529818f, -0.05480560f, -0.15792766f, -0.04895524f, -0.15952009f, 0.12416030f, 
    0.07864185f, -0.00760340f, -0.05340556f, 0.06717420f, 0.05754570f, -0.06273991f, 0.03435970f, 0.06330281f, 
    -0.15909839f, 0.06178717f, -0.00502454f, 0.22790280f, 0.12986869f, -0.03687143f, -0.02215405f, 0.11006830f, 
    0.09534107f, -0.11760215f, -0.02280714f, 0.02427099f, 0.27999017f, -0.01399711f, -0.07163163f, -0.17546271f, 
    0.14531940f, 0.02978339f, 0.05112338f, -0.03358588f, 0.22574461f, 0.14869624f, 0.02563427f, 0.10192246f, 
    0.27307719f, -0.01985440f, -0.32775229f, 0.11164601f, 0.01938521f, 0.04910305f, 0.02807372f, 0.08684658f, 
    0.08070930f, 0.12030955f, 0.07347533f, -0.10293706f, 0.04215631f, -0.01865233f, -0.01832634f, -0.04448316f, 
    -0.07861160f, -0.09361047f, -0.03294934f, -0.07977574f, -0.02455930f, 0.00893399f, 0.05280642f, -0.07289697f, 
    0.10736056f, 0.04333908f, 0.06280200f, 0.00057659f, 0.01612756f, 0.10964850f, 0.02907542f, 0.03871584f, 
    0.05170663f, 0.18164684f, 0.06396947f, 0.26326552f, -0.23485048f, 0.27236730f, -0.21557176f, 0.02360885f, 
    -0.05899367f, 0.01176330f, -0.00737092f, -0.05013621f, 0.04109358f, -0.02431079f, 0.05915118f, 0.05895678f, 
    -0.06840949f, -0.02055478f, -0.27727738f, -0.09686657f, -0.03853280f, 0.07022393f, -0.12637019f, 0.09180665f, 
    0.09881237f, 0.06670845f, -0.04116168f, 0.03143854f, -0.19568491f, -0.05100403f, 0.05838163f, -0.29501408f, 
    0.08732458f, 0.14662386f, -0.07381917f, -0.14651673f, 0.00351089f, 0.05845442f, -0.08047190f, 0.08472494f, 
    0.08978292f, 0.18101288f, 0.25013688f, 0.02535286f, -0.00940413f, 0.01443012f, 0.11183537f, -0.07582351f, 
    -0.01730170f, -0.05120108f, -0.05658272f, -0.00529482f, -0.01417343f, -0.00887950f, -0.09330291f, 0.20145299f, 
    0.12912916f, 0.05296726f, 0.10418146f, 0.11885689f, 0.25145820f, 0.05404774f, 0.08344717f, 0.21111424f, 
    0.19908035f, -0.09720328f, -0.08499694f, -0.00937797f, 0.06432698f, 0.03837410f, 0.01875520f, 0.01963931f, 
    0.04546941f, 0.03752672f, -0.06915978f, 0.12474753f, 0.21542738f, 0.19905108f, -0.26328343f, -0.02627464f, 
    0.08893429f, 0.02939661f, 0.06308205f, -0.06620719f, 0.07135654f, 0.02445664f, 0.05816170f, 0.06772535f, 
    -0.23120725f, -0.15652464f, 0.07005801f, -0.00986652f, 0.12655662f, 0.08080786f, -0.12151074f, -0.01894119f, 
    0.10753182f, -0.03457902f, -0.01019001f, 0.00748880f, 0.05485630f, -0.05832921f, -0.01260619f, -0.24156033f, 
    -0.07661027f, 0.10260005f, -0.05244690f, -0.00039245f, 0.07045520f, -0.05194610f, 0.08916818f, -0.18055946f, 
    -0.06017236f, 0.17270462f, -0.09681702f, -0.04886994f, 0.05305959f, 0.00073409f, 0.03299666f, -0.01973380f, 
    0.09049802f, 0.10403614f, 0.18545765f, 0.00693734f, -0.11135541f, -0.01138685f, -0.01820343f, -0.04255575f, 
    0.19080928f, 0.01066635f, 0.03915989f, 0.06503403f, 0.10779160f, 0.13761608f, -0.10613689f, -0.11104343f, 
    0.10456765f, 0.18076947f, 0.07225079f, -0.07854845f, -0.01281571f, -0.07983907f, 0.12254915f, 0.13395040f, 
    0.11167682f, -0.10324458f, 0.00989312f, 0.07613757f, 0.01405249f, 0.17224632f, 0.15806487f, -0.21901584f, 
    0.18805172f, 0.09025505f, 0.10233310f, -0.15329683f, 0.04000445f, 0.03247871f, 0.01407376f, 0.14313708f, 
    0.08677810f, -0.09123348f, 0.00300488f, -0.04865596f, 0.13509871f, -0.07420685f, 0.08329751f, -0.13977404f, 
    -0.04824623f, -0.14951731f, -0.12544852f, -0.12172347f, 0.10643355f, -0.03733745f, 0.04062318f, -0.00401551f, 
    0.06267815f, -0.01163963f, -0.04490491f, 0.00966572f, 0.08219846f, 0.07899605f, 0.06704435f, -0.08465090f, 
    -0.00877475f, 0.30110928f, -0.17431106f, -0.01977993f, -0.03115404f, 0.03862710f, -0.07281403f, -0.04726844f, 
    0.02732323f, 0.06141126f, -0.01747821f, -0.01051545f, 0.10805013f, 0.07975143f, -0.03122560f, 0.14705542f, 
    0.04572467f, 0.09245058f, -0.17301489f, -0.17090812f, -0.04416175f, 0.00307067f, -0.02629408f, -0.09765216f, 
    -0.08912521f, -0.10649522f, 0.34406558f, 0.00103920f, -0.15902571f, 0.12907584f, 0.08304452f, 0.18155657f, 
    -0.00658635f, -0.13764092f, 0.01452056f, -0.04573197f, 0.04257873f, -0.02078406f, -0.10957587f, -0.03037442f, 
    0.10532231f, -0.08092487f, 0.01567618f, 0.00247684f, 0.01119920f, 0.08179402f, -0.09676476f, -0.06154082f, 
    0.16888902f, -0.03066775f, 0.13990371f, -0.20558628f, 0.06417757f, 0.01922085f, -0.06324419f, -0.08466199f, 
    0.03741295f, 0.02339786f, -0.18724875f, 0.18392006f, -0.06692670f, -0.06562888f, 0.20443611f, -0.08805899f, 
    0.04729307f, -0.13175626f, 0.21660124f, -0.11318198f, -0.10548636f, -0.08579583f, 0.08326317f, 0.05422463f, 
    -0.11104564f, 0.07479110f, -0.12769565f, 0.02460758f, 0.03749049f, -0.06252615f, 0.05360861f, -0.13075647f, 
    0.03359346f, -0.22014572f, 0.12058239f, -0.14912273f, -0.32502723f, -0.05814992f, 0.10384820f, 0.17149204f, 
    -0.02539076f, 0.13948016f, 0.04323567f, 0.16669136f, -0.04508205f, 0.06443512f, 0.11320796f, 0.11256185f, 
    -0.00527101f, 0.05882199f, -0.08449299f, 0.07365593f, 0.00349767f, 0.16695867f, 0.00997129f, -0.07985806f, 
    -0.00198113f, 0.07379378f, -0.02090109f, -0.02618801f, 0.28827441f, -0.09095682f, 0.19280350f, -0.01579614f, 
    0.08964574f, -0.08937282f, -0.10094124f, 0.15699691f, 0.06987641f, -0.10148519f, 0.13423139f, -0.09611398f, 
    -0.08333412f, -0.05096634f, 0.15125413f, 0.02486733f, 0.04422860f, 0.08776244f, -0.01578251f, 0.04419391f, 
    -0.05812463f, -0.05708960f, 0.19862664f, -0.14309856f, 0.24865235f, -0.03113587f, -0.24180183f, 0.07499786f, 
    0.08950278f, 0.03001328f, -0.07632851f, -0.04455792f, 0.09920895f, 0.02620382f, 0.09606737f, 0.01691855f, 
    -0.14977476f, 0.35303205f, -0.04777671f, 0.14990374f, -0.04837153f, 0.06745126f, 0.31759888f, -0.03368692f, 
    -0.01644156f, 0.07798131f, 0.07439637f, 0.03976068f, 0.08236677f, 0.09388021f, -0.01187142f, 0.04355372f, 
    0.00698112f, 0.03218393f, -0.16204153f, 0.02864825f, 0.01128989f, -0.09272851f, 0.15103643f, -0.21182971f, 
    0.00183102f, 0.00108855f, 0.09839071f, 0.07096013f, 0.01682507f, -0.03759170f, -0.03434857f, -0.21048015f, 
    -0.00473233f, 0.08136155f, -0.15894848f, 0.12485514f, 0.07296964f, -0.08510044f, 0.13452923f, -0.03420039f, 
    -0.09777860f, 0.05111321f, 0.10606182f, 0.24112220f, 0.18584691f, 0.30756703f, 0.10997193f, -0.00492620f, 
    0.06501554f, 0.06549394f, 0.02016160f, -0.07360079f, 0.00033356f, 0.03316145f, -0.03944553f, -0.12880948f, 
    -0.16011815f, -0.04169491f, -0.09249127f, -0.11396098f, 0.08800971f, 0.10748905f, 0.10846144f, -0.09972893f, 
    -0.08073448f, -0.02683257f, 0.05519905f, -0.00720233f, -0.02374682f, -0.02053666f, -0.03584927f, 0.13176586f, 
    0.01891108f, -0.13310063f, 0.02940128f, -0.11905351f, 0.01679721f, 0.06583414f, -0.11417415f, -0.23384917f, 
    0.09443282f, -0.02800473f, 0.17906751f, 0.08637363f, -0.09752429f, 0.15115292f, 0.02614272f, -0.14083721f, 
    -0.08165465f, 0.19428259f, -0.00990683f, 0.01582184f, 0.02499292f, -0.31150824f, -0.07874926f, -0.23815446f, 
    0.16177100f, -0.13465421f, 0.08992030f, -0.09267805f, 0.06785715f, 0.02219531f, -0.04557160f, 0.23611471f, 
    -0.08513394f, 0.13563716f, 0.05173469f, 0.02654598f, -0.10121120f, -0.03331825f, -0.00011852f, 0.06758234f, 
    0.03358762f, -0.10071632f, -0.00528067f, -0.00074899f, -0.06039479f, 0.17576078f, -0.00460999f, -0.04238205f, 
    0.12585074f, 0.09804457f, -0.15499517f, 0.03601433f, 0.12666102f, -0.06946111f, -0.07805381f, -0.21380349f, 
    0.06030849f, -0.01791767f, -0.02252270f, 0.06457534f, -0.08291249f, 0.01751164f, -0.13160738f, 0.10569052f, 
    0.11204691f, 0.05590137f, -0.19461347f, 0.05113840f, 0.02016900f, 0.01767798f, -0.05893200f, -0.02908504f, 
    0.46450081f, 0.10555378f, -0.03096194f, 0.08887117f, -0.10592395f, -0.09706017f, 0.08923226f, 0.03299391f, 
    -0.04933907f, -0.02048308f, 0.00690039f, 0.14641923f, -0.04715465f, -0.06751349f, 0.35026631f, 0.05373327f, 
    0.01445580f, -0.08017882f, 0.05906428f, 0.09306133f, -0.09283065f, -0.09843233f, -0.08222837f, 0.09928866f, 
    0.19983883f, -0.04260941f, 0.08877551f, 0.03681988f, -0.05602932f, 0.03290159f, 0.13084821f, -0.04721697f, 
    -0.16790226f, 0.07470053f, -0.27759010f, -0.20820180f, -0.00762551f, 0.12025131f, -0.15978527f, -0.03782126f, 
    0.00999377f, 0.04914213f, -0.01412911f, -0.07311662f, -0.01625123f, -0.04324452f, -0.18608667f, 0.11492522f, 
    -0.05488036f, 0.29510793f, 0.05479584f, 0.25443736f, 0.06795496f, -0.00788136f, 0.14648101f, 0.13835096f, 
    -0.17382960f, 0.11146612f, 0.05410103f, 0.08599055f, -0.03277667f, 0.06574661f, 0.12525553f, -0.06895952f, 
    -0.11328956f, 0.03785740f, -0.10806403f, 0.07316481f, 0.11007899f, -0.04498878f, -0.02977047f, -0.11182341f, 
    -0.08790995f, 0.11590440f, -0.05584615f, 0.00736194f, -0.03089671f, -0.08741087f, 0.18110164f, 0.18423331f, 
    -0.00159244f, 0.40091833f, 0.08211298f, 0.19176543f, -0.03041233f, -0.22737685f, -0.12476338f, -0.16725680f, 
    0.10335040f, 0.03193454f, 0.07521263f, -0.18251827f, 0.12500021f, 0.08172609f, -0.00770664f, 0.30618194f, 
    0.05321704f, -0.04121023f, -0.05327096f, 0.10022328f, -0.10971408f, 0.07777572f, 0.21365908f, -0.13209698f, 
    -0.01724889f, -0.08397947f, 0.03959174f, -0.01494737f, 0.29029307f, -0.07969557f, 0.14490294f, 0.14436719f, 
    -0.13249347f, -0.12835300f, 0.00083127f, 0.12396864f, 0.09656375f, 0.02272466f, 0.07181580f, -0.00058437f, 
    0.27513504f, 0.07307612f, -0.05363065f, 0.17419666f, 0.14437115f, -0.03470326f, 0.06593218f, 0.05512654f, 
    -0.01056169f, 0.10923941f, -0.04759154f, -0.02607397f, 0.27704921f, 0.21653104f, 0.02625270f, -0.07864390f, 
    -0.05839974f, 0.06893909f, -0.05347211f, 0.05926012f, 0.08060356f, -0.04119766f, -0.00553368f, 0.02737476f, 
    -0.00732720f, -0.13795574f, -0.14268909f, -0.08926224f, 0.05016278f, 0.01380511f, -0.03244970f, -0.00181234f, 
    0.03567166f, -0.04545362f, -0.01732606f, -0.08096878f, 0.02949194f, 0.08787169f, -0.22238915f, -0.04124525f, 
    0.02490789f, 0.05364068f, -0.17216687f, 0.05450712f, -0.07868041f, 0.02061496f, -0.07622343f, 0.02529053f, 
    0.03712009f, -0.05007595f, 0.00287344f, 0.07615218f, 0.04957712f, 0.06923596f, 0.02418610f, 0.04734508f, 
    0.19998795f, 0.03235538f, -0.03478916f, 0.15598495f, -0.01765572f, 0.03834493f, 0.09486480f, -0.00485503f, 
    -0.06819762f, -0.12297181f, 0.06979690f, -0.02435677f, 0.03831924f, -0.03063625f, 0.03744498f, 0.08689845f, 
    -0.02059465f, -0.03049006f, 0.19495510f, -0.14996548f, 0.11767766f, 0.02330280f, -0.00960105f, -0.00894919f, 
    0.11835219f, -0.21429947f, -0.01962210f, -0.04139329f, -0.01376147f, 0.21871001f, -0.18250610f, -0.19472505f, 
    -0.03531381f, 0.01471068f, 0.04868653f, 0.08221509f, 0.06271412f, -0.04226622f, -0.09875306f, 0.04839515f, 
    0.05478756f, -0.15605661f, -0.12896763f, -0.04368941f, -0.19603620f, 0.00544907f, 0.09156085f, -0.11766784f, 
    0.02306741f, 0.16814469f, 0.03237008f, 0.06897665f, 0.02024521f, 0.05668650f, 0.07441039f, 0.15391502f, 
    -0.03190380f, 0.06515288f, -0.01621286f, -0.00600361f, 0.07420474f, 0.03715787f, -0.06887818f, 0.03310554f, 
    0.20237954f, -0.15492733f, -0.08136584f, 0.07231365f, 0.08460718f, -0.01391863f, -0.07944238f, 0.07898922f, 
    0.03944729f, -0.08143827f, -0.08025093f, 0.05888793f, 0.07410342f, -0.02758227f, 0.13548444f, 0.01048864f, 
    -0.04229474f, -0.06640175f, 0.04005285f, -0.09940004f, 0.06384254f, 0.10762905f, 0.06971862f, 0.12209092f, 
    -0.02907292f, 0.11747377f, -0.17721830f, 0.03441162f, -0.05032652f, 0.07383278f, 0.05277811f, 0.17889459f, 
    0.06819309f, -0.14832483f, 0.06548510f, -0.08104087f, 0.15471730f, -0.11266942f, 0.01033782f, -0.02979272f, 
    0.01496383f, -0.02572384f, 0.17394467f, -0.22239242f, 0.01260948f, 0.06055441f, -0.14586185f, 0.12199254f, 
    0.09967884f, -0.10076997f, -0.16417862f, -0.12765098f, 0.07441810f, 0.05715545f, 0.03650884f, 0.01305529f, 
    0.17923047f, 0.06154789f, 0.08468445f, -0.06208856f, -0.27164409f, 0.06520016f, -0.29029071f, 0.09590311f, 
    -0.01419649f, 0.05335944f, -0.08753645f, -0.00652063f, 0.11386922f, 0.01572873f, 0.08797003f, -0.09137139f, 
    -0.19124104f, 0.41855797f, -0.23232414f, -0.08429908f, 0.04192020f, 0.00072385f, 0.07382201f, -0.10157871f, 
    0.04680227f, -0.02830338f, -0.06836025f, 0.02132962f, -0.04828780f, 0.10669960f, 0.11205031f, 0.04251985f, 
    0.07784225f, -0.05883650f, 0.04498811f, -0.10367207f, 0.00722908f, 0.09242941f, 0.07881466f, 0.04277540f, 
    -0.41289994f, 0.05327662f, -0.11357359f, -0.00951109f, -0.10733460f, 0.08840700f, 0.01169964f, 0.04278430f, 
    0.10101460f, 0.01878259f, -0.02975856f, 0.08341224f, 0.25920019f, -0.01660468f, 0.08266766f, 0.06806775f, 
    -0.05054253f, -0.03794473f, -0.06855893f, -0.05488420f, 0.05476680f, -0.03492191f, -0.07580014f, -0.03511428f, 
    0.47296509f, 0.13710585f, 0.33916593f, 0.09188848f, -0.11869336f, 0.02205426f, 0.02689492f, 0.03857983f, 
    0.09007230f, 0.06373913f, 0.00233325f, -0.04113763f, 0.14540887f, 0.13722727f, 0.15677272f, -0.07351570f, 
    0.02933977f, 0.01493454f, -0.01816458f, -0.11480437f, -0.04213350f, 0.04673950f, 0.12584198f, 0.00950604f, 
    -0.04399894f, 0.30389428f, -0.20662303f, -0.08799359f, 0.08530873f, 0.17795351f, -0.00274658f, 0.10634404f, 
    0.02200394f, -0.00630258f, 0.07594119f, -0.04095354f, -0.01604491f, 0.02558167f, -0.17445922f, 0.03258508f, 
    0.07535708f, 0.04670136f, -0.01316953f, 0.10919901f, 0.10339610f, 0.20426320f, -0.04124745f, -0.07735915f, 
    -0.24839410f, 0.17523089f, -0.05985365f, 0.02593269f, 0.12308218f, 0.08363169f, -0.01494164f, 0.13626726f, 
    -0.04815158f, 0.04577194f, 0.04488250f, 0.00980995f, -0.15617076f, -0.02648753f, 0.13907242f, -0.01188091f, 
    -0.02621931f, 0.03645683f, 0.02930395f, -0.03633180f, 0.05786144f, 0.09267304f, 0.11221583f, -0.05180505f, 
    0.02173432f, -0.18403268f, -0.08914262f, -0.11204298f, 0.22931920f, 0.05239667f, 0.08152331f, 0.00341489f, 
    0.08985218f, 0.03109848f, 0.07614629f, 0.05282364f, 0.09775855f, -0.20244461f, 0.01527583f, -0.06701791f, 
    0.10123383f, 0.07557620f, 0.12120090f, -0.06303336f, -0.00942500f, -0.03018058f, 0.08370003f, 0.05326400f, 
    0.10262208f, -0.00958884f, 0.00908590f, -0.07099433f, 0.06963701f, 0.08415233f, 0.06965734f, -0.01242402f, 
    0.02216072f, -0.08605324f, -0.02850695f, -0.09342816f, 0.06168187f, 0.33702853f, 0.06673647f, 0.02245928f, 
    -0.07736447f, -0.05940327f, 0.01612440f, 0.15393287f, -0.02864811f, -0.08627665f, 0.01400067f, 0.04755756f, 
    -0.02278877f, 0.03405567f, -0.00596622f, -0.01814037f, -0.02835789f, 0.03047994f, -0.01743066f, -0.00324923f, 
    -0.02937765f, -0.04339333f, 0.01233674f, -0.03421492f, 0.03430456f, -0.05644917f, 0.01976818f, 0.03572192f, 
    0.01034839f, 0.01288949f, 0.04052160f, 0.03990049f, -0.05603081f, 0.00831151f, 0.01370410f, -0.03978975f, 
    0.03299752f, 0.04235024f, 0.04082725f, 0.00175917f, 0.02082126f, -0.00569763f, 0.01320360f, -0.05116617f, 
    -0.05295287f, 0.03526439f, 0.01525585f, -0.05579610f, -0.02290911f, -0.04676396f, -0.04354944f, 0.03835652f, 
    0.01963561f, -0.04291329f, -0.04577715f, 0.00249254f, -0.05884842f, 0.03762570f, -0.01873372f, -0.01605294f, 
    0.03803265f, -0.00111375f, -0.03996003f, 0.03809140f, -0.03765836f, 0.02708160f, -0.02118408f, -0.05415934f, 
    0.03146996f, -0.05857247f, -0.01794323f, -0.05405236f, 0.01067902f, -0.03263262f, 0.00160736f, -0.01142046f, 
    -0.03543173f, 0.03373381f, -0.00443885f, -0.03298962f, 0.02510531f, 0.00631931f, -0.00844015f, -0.00208617f, 
    -0.05735958f, 0.01984658f, -0.04404314f, 0.03394917f, -0.02247139f, -0.05378103f, -0.00997552f, 0.02405141f, 
    -0.03883929f, 0.02627486f, -0.03980470f, 0.00005135f, -0.02330572f, -0.00335810f, -0.00525386f, -0.03315631f, 
    -0.03368413f, 0.01451618f, 0.00684837f, -0.01903930f, -0.05222213f, 0.00172407f, 0.03229443f, -0.01145895f, 
    -0.00834263f, -0.01292494f, -0.01724475f, -0.04254990f, -0.00870231f, -0.02111448f, -0.02438913f, -0.04832160f, 
    0.00604103f, 0.03782740f, 0.01035751f, -0.01333158f, -0.04820811f, 0.02791635f, -0.01043174f, -0.00992322f, 
    -0.04237833f, 0.03933199f, -0.00975084f, 0.00618418f, 0.00739204f, -0.03319970f, 0.01782675f, 0.00586258f, 
    -0.03661220f, -0.05535992f, 0.04069640f, 0.03341126f, -0.04192106f, 0.01204847f, 0.01028442f, 0.01909576f, 
    -0.03982928f, -0.05813142f, 0.01237980f, 0.01077999f, 0.02416245f, 0.00018249f, 0.00065506f, -0.00915977f, 
    0.03310536f, 0.02931090f, 0.01116576f, -0.04216301f, -0.04124594f, 0.04212333f, -0.02397011f, 0.04319053f, 
    -0.03668044f, 0.03568192f, 0.02296203f, 0.02050891f, -0.05592925f, -0.02380733f, -0.05803201f, -0.02889859f, 
    -0.03526000f, -0.05519869f, 0.00369721f, 0.01090504f, 0.00201497f, -0.02594055f, -0.03816037f, 0.02219640f, 
    -0.03096925f, -0.00802141f, 0.02975698f, -0.01689486f, 0.01701443f, 0.03633099f, 0.03716691f, -0.05491341f, 
    0.01837219f, -0.01946871f, -0.03647654f, 0.00831753f, -0.02397702f, -0.00736805f, 0.01759044f, 0.02157397f, 
    -0.04963209f, 0.03402987f, -0.00880588f, 0.01897006f, 0.01521592f, 0.02969472f, -0.00082433f, 0.02378787f, 
    -0.02083821f, 0.02062065f, 0.03821205f, 0.03733740f, -0.04056640f, -0.00693330f, -0.01076072f, -0.00084693f, 
    0.03918337f, -0.01536693f, -0.04087079f, -0.01589792f, -0.04181477f, -0.00870134f, -0.04810332f, -0.01405906f, 
    -0.02923493f, 0.00783793f, -0.01604749f, -0.01764639f, -0.02379560f, -0.01280580f, 0.02857265f, 0.00504298f, 
    0.01081156f, -0.04686737f, 0.01529905f, 0.00998579f, -0.00763629f, 0.03761575f, 0.00522255f, -0.01170001f, 
    -0.02403606f, 0.04305077f, 0.01852784f, 0.04466831f, -0.05207767f, 0.03787610f, -0.02969905f, 0.00922997f, 
    0.03735388f, 0.03436081f, -0.03879289f, -0.02158681f, -0.00158732f, -0.02714377f, -0.03395786f, -0.01378958f, 
    -0.03037149f, -0.00567232f, -0.01616818f, 0.02823103f, -0.04215190f, 0.03237834f, -0.02821892f, -0.02154141f, 
    -0.01258603f, 0.01802169f, -0.00821824f, -0.03950322f, 0.02683550f, 0.02067450f, -0.04191321f, -0.00484006f, 
    -0.04597819f, -0.04420118f, 0.03857265f, 0.04034442f, -0.02974966f, 0.00244745f, -0.02321555f, -0.02168068f, 
    -0.01149872f, 0.01791001f, -0.02083413f, -0.03783865f, 0.02137489f, 0.00567215f, 0.01302699f, -0.02572555f, 
    -0.01559645f, -0.05487300f, 0.04029558f, -0.01143003f, -0.04144205f, -0.00760528f, -0.00290089f, 0.03444608f, 
    0.02266512f, 0.02556992f, 0.02026278f, -0.00445385f, -0.01212351f, 0.02718537f, 0.00253701f, -0.04640191f, 
    0.02004716f, 0.01534731f, -0.02273890f, -0.03722379f, -0.01951598f, 0.00632479f, -0.03196437f, 0.00549945f, 
    -0.04248658f, 0.03321446f, 0.01082501f, 0.01725408f, -0.02158340f, 0.00904146f, 0.00376938f, 0.00968783f, 
    0.00969825f, -0.04368723f, -0.01065603f, -0.00631194f, -0.03466062f, 0.02485896f, 0.01224585f, -0.01047773f, 
    0.03427009f, 0.02100060f, 0.03633299f, 0.01739093f, -0.02331985f, 0.03925557f, -0.00236278f, -0.02914976f, 
    -0.01269894f, 0.01751671f, -0.01049649f, -0.02287799f, 0.04391916f, 0.01104052f, 0.01764105f, -0.05855187f, 
    0.02484516f, -0.03310348f, -0.05606339f, -0.02610565f, 0.01297022f, 0.01252380f, -0.03743415f, 0.00081759f, 
    -0.04039826f, -0.02794954f, -0.05214328f, -0.02906546f, 0.01027933f, -0.03664048f, -0.00408875f, 0.02167242f, 
    0.00155187f, -0.05100274f, -0.02610910f, -0.02171600f, 0.00400781f, -0.01511491f, -0.05442230f, 0.00959898f, 
    -0.00103364f, -0.03055162f, -0.01258378f, -0.04164139f, 0.01019580f, 0.01980572f, -0.03358905f, -0.04809436f, 
    0.01683901f, 0.01208762f, 0.03864101f, -0.00996250f, -0.03599407f, -0.03990845f, -0.03028342f, 0.02067344f, 
    -0.04457825f, 0.00526287f, -0.00678110f, -0.01835746f, -0.02425442f, -0.03647914f, -0.01844805f, -0.05463770f, 
    -0.04692355f, 0.01675102f, -0.04364008f, -0.00581365f, -0.01896046f, -0.01285584f, 0.00562637f, -0.03741843f, 
    0.03092108f, -0.02478857f, -0.01654753f, 0.00261873f, -0.02404867f, 0.00611301f, 0.01876186f, -0.05171742f, 
    0.20277256f, 0.08632068f, 0.10035750f, -0.00909198f, 0.06349766f, -0.00047724f, 0.08103669f, -0.06386294f, 
    -0.00782859f, 0.08843479f, 0.02107814f, 0.07204522f, 0.16963409f, -0.15350634f, -0.10933919f, 0.06066730f, 
    -0.00913426f, 0.06873996f, -0.02802668f, 0.00067471f, 0.06378477f, 0.13342446f, 0.01880655f, 0.17270680f, 
    0.12958540f, 0.13351515f, -0.11213760f, -0.07599881f, 0.01414440f, 0.02698216f, -0.03859439f, -0.07992963f, 
    0.01246068f, 0.04156588f, 0.08668521f, 0.04126794f, -0.12701201f, -0.17493202f, 0.00767410f, 0.04293023f, 
    -0.06742295f, 0.01030911f, 0.03492700f, -0.01817309f, 0.03263168f, -0.02929025f, 0.00448974f, 0.12567018f, 
    0.04639907f, 0.10745048f, 0.20261510f, 0.22443534f, 0.01390837f, 0.06149497f, -0.16307448f, 0.17501552f, 
    0.01565090f, 0.09637360f, -0.03208396f, 0.04177078f, -0.06867725f, 0.16165270f, 0.14522944f, -0.15972793f, 
    0.10503200f, 0.02759039f, -0.07283762f, -0.00270558f, 0.02607749f, 0.09297800f, 0.14654219f, -0.13953698f, 
    -0.24771921f, -0.00778389f, -0.00563543f, -0.11354858f, -0.01973374f, 0.11469455f, 0.09797467f, 0.02155829f, 
    -0.03521049f, 0.03395096f, 0.03084782f, -0.01720051f, 0.01213280f, 0.08786161f, -0.06662692f, -0.29569051f, 
    -0.06352226f, 0.11222224f, -0.05184054f, -0.02703772f, 0.00076880f, 0.17069528f, -0.02862542f, -0.02198699f, 
    0.03411859f, 0.07156970f, -0.05220907f, -0.12566662f, -0.12015266f, -0.00421715f, -0.08643172f, -0.01529836f, 
    0.02394806f, 0.03093581f, 0.09989092f, 0.12311569f, -0.21131781f, 0.00415146f, -0.09071659f, -0.10207456f, 
    0.08620994f, 0.11081492f, 0.02376745f, 0.08020720f, 0.03286174f, 0.00422332f, 0.05184168f, -0.02672315f, 
    -0.02126693f, 0.23170011f, 0.14815927f, 0.02637517f, 0.03574559f, -0.02000729f, 0.02219117f, 0.06923928f, 
    0.06687008f, 0.09572688f, -0.05004765f, -0.04999469f, 0.19191375f, -0.03076258f, 0.06658483f, -0.10879925f, 
    -0.01729727f, 0.06242967f, -0.08645536f, 0.02658282f, -0.02523807f, -0.02633709f, -0.02796921f, 0.06970341f, 
    -0.09797119f, 0.14559035f, -0.11059272f, -0.02637896f, -0.00005883f, -0.11795871f, -0.13830493f, -0.15204298f, 
    0.04000048f, 0.00872427f, -0.11132888f, 0.02940985f, 0.07872429f, -0.11967037f, 0.18178701f, 0.25450158f, 
    -0.11248878f, 0.03069710f, -0.02486655f, 0.04207216f, 0.02934842f, -0.00443778f, -0.01375354f, 0.06827110f, 
    -0.32999834f, 0.08346494f, 0.21935330f, 0.10690524f, 0.01834718f, -0.01523159f, -0.08533325f, -0.02962924f, 
    0.01266239f, 0.02735604f, 0.07620531f, 0.10090754f, 0.08855256f, 0.22183418f, -0.03587349f, 0.00372657f, 
    0.13992965f, 0.15587059f, -0.02097793f, -0.04895842f, -0.01155583f, 0.05749712f, -0.03416046f, 0.10402399f, 
    0.04765299f, 0.13985273f, 0.10763123f, 0.19979072f, -0.01778035f, 0.03683250f, -0.02826162f, -0.00288002f, 
    0.09537113f, -0.04240178f, -0.04389124f, -0.01999851f, -0.34673113f, 0.10816033f, -0.01683859f, -0.08768737f, 
    0.04325748f, 0.07265718f, -0.00948925f, 0.04193167f, 0.02387583f, -0.04849049f, 0.01106985f, 0.01979012f, 
    -0.13598703f, 0.31126192f, 0.37637627f, 0.29156080f, -0.11440026f, 0.02887924f, 0.00765016f, 0.19968265f, 
    -0.04283623f, -0.03862008f, 0.04211944f, -0.09331656f, 0.00165492f, 0.06252706f, 0.03766755f, 0.07886636f, 
    -0.02864019f, -0.11264136f, 0.04804810f, 0.01377804f, 0.03913927f, 0.03518998f, -0.06139193f, 0.11469398f, 
    -0.27904999f, 0.19698721f, 0.10280433f, 0.00460912f, 0.01930310f, 0.06417891f, 0.00459503f, 0.00366767f, 
    -0.03804019f, 0.04613741f, -0.00726627f, -0.10788494f, 0.11500540f, -0.11903350f, -0.12902784f, 0.05805180f, 
    -0.08565846f, 0.05351107f, -0.03328484f, 0.05776566f, 0.00666199f, 0.04948679f, 0.00376106f, -0.03697052f, 
    0.04459456f, -0.17894994f, -0.13333589f, 0.15544498f, -0.07687070f, 0.02181137f, 0.00181998f, 0.03522830f, 
    0.00828753f, 0.00243415f, -0.02228259f, 0.00508377f, 0.12447054f, -0.12970531f, 0.16724941f, 0.34608829f, 
    0.04408273f, -0.07352426f, 0.07406482f, -0.03919774f, -0.02182304f, 0.03803894f, 0.05509605f, 0.14272486f, 
    -0.37789115f, 0.17305043f, 0.16858786f, 0.02842875f, -0.02096273f, -0.04666492f, -0.11415178f, 0.03285032f, 
    0.09730817f, 0.02330968f, 0.02347534f, -0.01175141f, 0.19973248f, -0.04387634f, -0.00539296f, 0.07634059f, 
    -0.01018505f, 0.18536413f, 0.08585420f, 0.02230424f, 0.03248739f, -0.04761003f, 0.00117817f, -0.01621738f, 
    -0.16251713f, -0.00229266f, -0.02159815f, -0.07707445f, 0.09017368f, -0.08757012f, 0.03305029f, 0.02028339f, 
    0.15641141f, 0.08703526f, 0.02529105f, 0.14782047f, 0.42457247f, 0.11415463f, 0.14285281f, 0.27016330f, 
    0.07191523f, 0.05116192f, 0.02895891f, 0.07225022f, -0.05370673f, -0.04122427f, 0.03289798f, 0.12130394f, 
    0.30385655f, -0.04678923f, -0.17037302f, -0.23087239f, 0.12944283f, 0.05839285f, -0.04406529f, -0.17655876f, 
    0.00567905f, 0.02163902f, 0.00729257f, -0.09383882f, 0.03175423f, -0.12944777f, -0.05679478f, 0.10552172f, 
    0.05215222f, -0.12904640f, 0.01106072f, 0.03807297f, 0.05879210f, 0.09105598f, -0.11510830f, 0.02851435f, 
    0.02440683f, 0.11611217f, 0.11443299f, 0.12362714f, -0.09088057f, 0.09488025f, 0.09231950f, -0.09532355f, 
    -0.03026215f, -0.11547395f, -0.06100304f, 0.00552841f, -0.20360982f, -0.02767475f, 0.02443924f, -0.01964024f, 
    -0.01049338f, -0.05126443f, -0.02883975f, 0.02694006f, 0.05651324f, -0.04989225f, 0.03246674f, -0.16323473f, 
    0.15961814f, -0.13266261f, -0.05654692f, -0.05489878f, 0.07477114f, -0.09010626f, 0.01243032f, 0.12481704f, 
    0.02803181f, -0.08638676f, -0.05210285f, -0.07600188f, -0.16904229f, 0.26718861f, 0.16537210f, -0.13413632f, 
    -0.08503389f, -0.07772505f, -0.02819111f, -0.02583938f, -0.07182153f, -0.10313836f, 0.01000108f, 0.02927716f, 
    -0.16259034f, -0.03604898f, -0.06096997f, 0.04792453f, 0.15709607f, 0.08872130f, -0.02719758f, -0.00834151f, 
    0.00599339f, 0.03817935f, 0.04192106f, 0.02506896f, 0.21411610f, 0.27030519f, 0.27646703f, 0.12759736f, 
    -0.01703752f, 0.03508294f, 0.06813315f, -0.06045708f, 0.03070029f, 0.04708097f, 0.04639659f, -0.02349884f, 
    -0.06309977f, -0.03715300f, -0.08955134f, -0.11167958f, -0.00471591f, -0.07504215f, 0.02149397f, -0.02594519f, 
    -0.09091560f, -0.07060747f, 0.06791278f, -0.00002247f, 0.21165091f, -0.01111228f, -0.09244738f, 0.07585351f, 
    0.09969649f, 0.04906401f, 0.04534163f, -0.04263258f, 0.10397160f, 0.06729592f, -0.04520566f, 0.08423811f, 
    0.08891558f, -0.01367421f, -0.00354418f, -0.06805816f, -0.09584954f, 0.05493348f, -0.12036274f, 0.01943415f, 
    0.09027359f, 0.00508858f, -0.02170268f, 0.01683252f, 0.24890892f, -0.08709297f, -0.02599587f, 0.06322409f, 
    0.05195091f, -0.02933266f, -0.05701160f, -0.07520263f, 0.05950955f, -0.06625456f, 0.02907560f, -0.03607234f, 
    0.33396196f, 0.19420683f, 0.09707589f, 0.15624784f, 0.00980317f, -0.05165021f, 0.03219487f, 0.08618137f, 
    -0.03809353f, -0.03903892f, 0.01948345f, -0.03057343f, -0.25104749f, -0.06875851f, -0.09747004f, 0.08304556f, 
    0.02001417f, -0.01486911f, 0.10383319f, -0.05542423f, -0.15668711f, 0.00602240f, 0.03497363f, 0.16905087f, 
    0.06300822f, -0.05105633f, -0.17710739f, 0.08777222f, 0.06619518f, 0.01806078f, 0.08759118f, 0.07443249f, 
    0.02939586f, 0.13542044f, -0.01556159f, 0.13199233f, 0.07891431f, 0.13638934f, 0.25541732f, -0.02885676f, 
    -0.05291686f, -0.01615245f, 0.08670442f, -0.00297814f, -0.02039755f, 0.00638550f, -0.04881355f, -0.11675668f, 
    0.30928147f, -0.24493949f, 0.18561563f, -0.16777669f, 0.01000915f, 0.04745724f, -0.03632712f, -0.05416157f, 
    -0.00022792f, -0.03471604f, 0.07875758f, -0.08235570f, -0.10708145f, 0.14686254f, 0.03473449f, -0.00547154f, 
    -0.00527812f, 0.05046319f, 0.05899141f, 0.02691038f, -0.09366665f, 0.05492253f, -0.08512897f, 0.11521751f, 
    -0.00896538f, -0.07436026f, 0.05801734f, -0.03143762f, 0.01152825f, 0.03820815f, -0.03925363f, 0.06372491f, 
    0.00449742f, -0.08061781f, 0.05921519f, 0.07824142f, -0.07676900f, 0.09724046f, -0.01026057f, 0.02781916f, 
    0.15790406f, 0.06000895f, -0.09831597f, 0.01884169f, 0.02387180f, -0.15249543f, 0.08320631f, -0.00672099f, 
    -0.02372938f, -0.10544960f, -0.07802670f, -0.03110891f, 0.11605568f, -0.02380031f, 0.03440815f, -0.05813963f, 
    -0.05200250f, 0.01511958f, 0.06075330f, -0.07129085f, 0.23814444f, -0.30030867f, 0.10009857f, 0.00878358f, 
    0.04188150f, -0.01686846f, 0.09724279f, 0.04433870f, -0.09164331f, 0.00215247f, -0.00839109f, -0.11127567f, 
    0.18738417f, -0.01101623f, -0.05202806f, 0.02775497f, 0.00863516f, -0.08587363f, 0.06800818f, 0.00235543f, 
    -0.09317718f, 0.05483976f, 0.00167742f, 0.07271731f, 0.19394505f, -0.00739754f, -0.13919407f, 0.24572635f, 
    0.08940044f, -0.03072312f, 0.10339626f, 0.11226109f, 0.02143580f, 0.06624589f, 0.02861197f, 0.02593512f, 
    0.08523762f, -0.16297616f, -0.20048478f, 0.04272826f, 0.05722428f, 0.07701526f, 0.04193859f, -0.03907525f, 
    0.00578660f, -0.00756248f, 0.00356586f, 0.14052327f, 0.09111136f, 0.20110311f, 0.11171030f, -0.15255041f, 
    -0.13305175f, 0.04735049f, -0.05867865f, -0.11346913f, -0.16705540f, -0.03141723f, 0.03529089f, -0.03860501f, 
    -0.01518558f, 0.11959708f, 0.13518630f, 0.03491242f, -0.03741260f, -0.03438174f, 0.03114905f, 0.06131795f, 
    -0.09201818f, -0.05915642f, 0.17191857f, -0.12687586f, -0.01172633f, 0.06771720f, 0.18517785f, -0.08189510f, 
    -0.05083324f, 0.09294263f, 0.16526610f, 0.07589682f, 0.01644330f, -0.03482092f, -0.02019820f, -0.02275003f, 
    0.22774741f, -0.16781385f, 0.04259124f, 0.11851322f, -0.00804063f, -0.03880395f, 0.09503698f, -0.10109799f, 
    -0.03410420f, 0.03726156f, -0.01727613f, 0.03610768f, -0.05984908f, -0.03639462f, -0.12549752f, 0.02372874f, 
    0.12390806f, -0.03057704f, 0.10599149f, -0.02165452f, 0.07229213f, 0.05270152f, 0.01780809f, 0.05568928f, 
    0.14749338f, -0.09053190f, -0.02351611f, 0.09316657f, 0.02943165f, 0.01687705f, -0.14960821f, 0.02579014f, 
    0.15272011f, -0.05545273f, -0.00019831f, 0.00583020f, -0.04682947f, -0.11597943f, -0.01280635f, 0.01504436f, 
    -0.07676215f, -0.07731361f, 0.06312381f, 0.00653538f, -0.01982711f, -0.06622691f, 0.12745343f, -0.03114437f, 
    -0.11778896f, -0.18771103f, 0.02547082f, -0.13192986f, 0.03118503f, 0.10727365f, -0.03508334f, 0.06195171f, 
    0.06139711f, -0.02973746f, -0.00414393f, 0.06923044f, 0.05939904f, 0.24126448f, -0.08709405f, 0.08236699f, 
    -0.03652776f, 0.00068778f, 0.11800207f, 0.09381657f, -0.11065041f, 0.05526644f, -0.00987662f, -0.04076963f, 
    0.04023895f, -0.06262571f, -0.07099092f, 0.13159722f, 0.09950205f, 0.07557489f, -0.15412880f, -0.04268852f, 
    0.04390785f, 0.05413656f, 0.11074813f, 0.10045072f, 0.20882685f, 0.17404835f, 0.06147352f, 0.10706470f, 
    -0.08852398f, 0.05703185f, 0.03182189f, 0.06853095f, -0.06623491f, -0.01385107f, 0.07559110f, -0.04538139f, 
    0.02358398f, -0.04515998f, -0.02723800f, -0.02400845f, 0.04524000f, 0.03472891f, -0.02336799f, 0.03206740f, 
    -0.04128053f, -0.03101533f, -0.03984088f, -0.05920170f, -0.05630621f, -0.03964952f, 0.02624260f, -0.00243571f, 
    0.02512430f, -0.04959517f, -0.00899793f, 0.01036866f, 0.00008427f, -0.05048186f, -0.05087774f, 0.01146587f, 
    0.00936212f, 0.02288718f, -0.06436687f, -0.01937627f, -0.01497202f, -0.03970572f, 0.04011095f, 0.00092733f, 
    -0.04455907f, 0.00071103f, -0.01104353f, -0.01298655f, 0.03762799f, 0.04153804f, 0.01038099f, 0.00649356f, 
    0.00798482f, -0.03514240f, -0.01766148f, -0.02690294f, -0.02503011f, -0.00291406f, 0.02320575f, -0.04985396f, 
    -0.00369443f, -0.02593639f, -0.03852572f, -0.01649702f, -0.05825199f, 0.01216246f, -0.05159448f, -0.01289935f, 
    0.04230219f, -0.03451680f, -0.06054043f, 0.03748337f, 0.00034510f, 0.03801360f, 0.03806051f, -0.04774310f, 
    -0.01880147f, -0.04744448f, 0.01372973f, 0.03210402f, 0.03965576f, 0.02244664f, 0.04120062f, -0.00441942f, 
    -0.01443057f, 0.01003148f, 0.02745713f, -0.01268991f, -0.00508725f, 0.01460646f, 0.00369127f, -0.00070005f, 
    0.02262561f, -0.00623332f, 0.03162551f, 0.04344636f, -0.02451805f, -0.00810222f, -0.01625083f, -0.00884065f, 
    0.01208899f, 0.00775911f, -0.00381576f, -0.01410356f, 0.02894608f, 0.02963427f, -0.00009637f, 0.03741835f, 
    -0.02441205f, -0.01701798f, 0.01101537f, -0.01017632f, 0.02915308f, -0.04453295f, 0.03398798f, -0.01588262f, 
    0.02889266f, 0.02482269f, -0.00192736f, -0.03681885f, -0.01128980f, -0.04875191f, 0.00809484f, 0.00702771f, 
    -0.02028692f, -0.04867901f, 0.00430789f, 0.02407990f, -0.00614508f, 0.02910936f, -0.01660793f, -0.01351967f, 
    0.00456414f, -0.00236988f, 0.03349547f, 0.02204536f, 0.02979018f, -0.03329700f, -0.02931639f, -0.02799301f, 
    0.03346813f, 0.01831137f, -0.01653726f, -0.04934868f, -0.03372839f, -0.02386091f, -0.04924338f, -0.00585022f, 
    0.01381368f, 0.02959086f, 0.01080065f, -0.05161887f, 0.03143335f, 0.02408278f, 0.02073805f, -0.01995573f, 
    0.02323238f, -0.02696408f, 0.03751919f, 0.03009170f, 0.04148747f, -0.04361697f, 0.00390987f, -0.03781209f, 
    -0.05720543f, 0.03553759f, -0.01766259f, 0.01825999f, -0.01174506f, -0.02326486f, -0.00920452f, -0.04596771f, 
    0.01054302f, -0.02119833f, -0.00350996f, 0.01674920f, -0.03356915f, 0.00984475f, -0.00112128f, 0.03231110f, 
    0.00569431f, -0.04862424f, -0.03869018f, -0.03933182f, 0.01290994f, -0.05844640f, -0.01433646f, 0.03949743f, 
    0.02335707f, -0.01392168f, 0.01799359f, 0.03546572f, -0.01683888f, 0.01375597f, 0.03081227f, -0.01499631f, 
    -0.05178765f, -0.00368506f, -0.02583272f, -0.02533182f, -0.04283507f, 0.01657376f, -0.04626872f, -0.02036283f, 
    -0.00662747f, -0.02448489f, -0.00964450f, 0.01765542f, -0.03699983f, 0.01599337f, -0.01007660f, -0.02462521f, 
    -0.02255844f, -0.05512554f, -0.04949022f, -0.02557764f, 0.03942294f, -0.00820943f, 0.00859215f, -0.00051377f, 
    0.02766447f, -0.03621515f, -0.05208027f, -0.02211211f, -0.01118077f, 0.03167871f, -0.01771307f, -0.01443889f, 
    0.01253574f, -0.04211806f, -0.01323068f, 0.02622649f, 0.04221864f, -0.04722854f, 0.03852960f, -0.02182072f, 
    0.02247890f, -0.01595089f, -0.05633564f, -0.02117144f, -0.04999891f, 0.02678527f, -0.03233933f, -0.01929169f, 
    -0.01799674f, 0.04307171f, -0.01456014f, -0.04008202f, 0.03729044f, -0.00261200f, -0.00689326f, 0.02717629f, 
    0.00307262f, -0.04819065f, -0.05043267f, -0.03613872f, 0.02927019f, 0.03764148f, -0.03079246f, -0.03611846f, 
    -0.01657934f, 0.03490242f, -0.00127550f, -0.00222989f, 0.01205968f, 0.02642197f, -0.00697605f, 0.00489996f, 
    -0.02976733f, -0.01008648f, 0.01282077f, -0.03012416f, 0.00877035f, 0.03503036f, 0.03112257f, -0.05186681f, 
    0.04606906f, -0.03897338f, 0.01194341f, 0.03894073f, 0.00032452f, 0.01273182f, 0.02850364f, 0.00137680f, 
    -0.01022353f, -0.04237285f, -0.03614422f, -0.01932157f, 0.01154082f, 0.03130275f, 0.03326733f, -0.02545459f, 
    0.01523639f, -0.00920246f, -0.01889452f, -0.05172288f, -0.02414251f, 0.03034624f, -0.02291347f, -0.05389641f, 
    0.03686168f, -0.03411820f, 0.01388669f, -0.03200348f, 0.02140464f, -0.00084903f, -0.00061382f, 0.03372880f, 
    -0.01713191f, 0.02460549f, 0.02179021f, 0.01704176f, 0.00910387f, 0.02340632f, -0.02187902f, -0.02726564f, 
    -0.06113820f, 0.03693864f, 0.03342905f, 0.03282584f, -0.03201395f, 0.02196712f, 0.02179749f, 0.03408477f, 
    -0.00685763f, -0.02469873f, 0.03570147f, -0.04609482f, 0.00851676f, 0.04406953f, -0.04995645f, -0.05014981f, 
    0.03902328f, -0.05057108f, -0.03554892f, -0.01881060f, 0.03241115f, 0.01369296f, 0.00988411f, 0.03516396f, 
    0.04135872f, -0.04821264f, -0.01379225f, -0.00402639f, 0.01375267f, -0.01045970f, -0.01769114f, 0.03503761f, 
    -0.02006961f, -0.00973969f, -0.02759637f, 0.02975424f, -0.00890881f, 0.01084917f, 0.01522343f, -0.04383028f, 
    0.00015935f, 0.00819259f, -0.02371584f, 0.03562893f, 0.02168866f, 0.01184623f, 0.01858652f, 0.04313164f, 
    -0.05339676f, -0.04247544f, -0.04061571f, 0.00995054f, -0.04459670f, 0.00373766f, -0.04483186f, 0.01738608f, 
    0.01464241f, -0.02709344f, -0.01570525f, -0.04740052f, -0.04489760f, 0.03939663f, 0.01642871f, -0.00458184f, 
    0.00690557f, 0.01210108f, -0.02457411f, 0.00535262f, 0.04862420f, 0.03490313f, -0.01926323f, -0.05569572f, 
    -0.02943508f, 0.02359993f, 0.04185016f, -0.05371610f, -0.03698552f, -0.01261941f, -0.05453906f, 0.03336911f, 
    0.21089467f, 0.07592054f, -0.01557395f, 0.26258439f, 0.08494897f, -0.02299534f, -0.04187792f, -0.01140128f, 
    0.00101118f, 0.00327317f, -0.09578580f, -0.11286095f, -0.12292311f, 0.21444787f, -0.09472187f, -0.22810245f, 
    -0.09361391f, 0.02457894f, -0.01907848f, -0.05853949f, -0.08748075f, 0.01599239f, -0.17189510f, -0.04991889f, 
    -0.42815134f, -0.08535264f, -0.02578067f, 0.04224825f, 0.05896375f, 0.10694671f, 0.12528418f, 0.01975594f, 
    -0.05802678f, 0.03810319f, 0.07188100f, -0.03355789f, 0.00808139f, 0.23574360f, 0.17431459f, -0.32438698f, 
    0.02131982f, 0.01801729f, 0.06180957f, 0.09620788f, -0.00178880f, 0.10521632f, -0.03489497f, -0.07252403f, 
    -0.12611343f, 0.06790860f, 0.15655428f, -0.00145374f, 0.08490110f, -0.10814862f, -0.02647762f, -0.06152398f, 
    -0.09595624f, 0.01627891f, 0.02121368f, -0.03681738f, 0.29276299f, -0.14016832f, 0.16390118f, 0.06483404f, 
    0.09327075f, -0.01613656f, 0.14794970f, -0.08311830f, 0.02603287f, -0.05259210f, -0.08042917f, -0.01722542f, 
    0.01556488f, -0.12592591f, -0.07900046f, -0.02121325f, 0.14976369f, 0.11527384f, -0.06057023f, 0.05675313f, 
    -0.06252517f, -0.03932640f, 0.03345699f, -0.13601965f, -0.24230693f, -0.06892470f, 0.00684010f, 0.06286529f, 
    0.20851709f, -0.00493753f, -0.11610082f, 0.09416830f, 0.04608663f, -0.02634656f, 0.18927386f, 0.15809643f, 
    -0.11299397f, 0.15485701f, 0.15135571f, 0.04538074f, 0.09961256f, 0.04913554f, 0.09531820f, -0.04610359f, 
    0.02354783f, -0.04531767f, -0.07263556f, -0.06396283f, 0.01871955f, -0.03916078f, 0.05676548f, 0.02343414f, 
    0.10353585f, -0.07136860f, 0.05412094f, -0.11017551f, -0.06867705f, 0.07821476f, 0.03945785f, 0.10324699f, 
    0.17248756f, -0.11456759f, -0.01662716f, 0.15488987f, 0.10060855f, 0.07720561f, -0.01059863f, 0.11252948f, 
    -0.05067630f, -0.03383513f, 0.06732887f, -0.06030370f, -0.14090396f, 0.21942157f, 0.05801638f, -0.16015616f, 
    0.00166573f, 0.16900203f, 0.00281979f, -0.00523827f, 0.06065660f, -0.00374215f, 0.02106592f, 0.02894639f, 
    -0.23332855f, 0.08275343f, 0.04169578f, -0.18320483f, 0.13641641f, 0.04083861f, 0.09797205f, -0.04502194f, 
    -0.00475814f, 0.11527544f, -0.01702100f, 0.09362527f, -0.21427272f, 0.17033413f, -0.13070014f, 0.00549869f, 
    0.01278522f, 0.01886331f, -0.00200245f, 0.11521272f, -0.12483595f, -0.02844228f, 0.09537828f, 0.04368750f, 
    -0.30854827f, -0.16171612f, 0.09480985f, -0.03635176f, 0.02775964f, -0.03064789f, 0.09595184f, -0.02826532f, 
    -0.04810947f, 0.00703823f, 0.02841571f, 0.12725513f, 0.19002357f, -0.01150521f, 0.28312933f, 0.03083088f, 
    0.02329053f, -0.02958661f, 0.04767799f, 0.13128595f, 0.11379865f, 0.02468752f, 0.02385086f, 0.04726551f, 
    0.14927171f, -0.14594525f, 0.10265107f, 0.15439054f, 0.04976618f, -0.07651820f, 0.02105891f, 0.03715227f, 
    -0.13498814f, 0.04298248f, -0.06236023f, -0.11409911f, -0.29440677f, -0.05009457f, 0.01008412f, -0.03933408f, 
    0.12190719f, 0.01207532f, 0.01295375f, 0.12608522f, -0.01284476f, 0.04559462f, -0.05312965f, -0.08399075f, 
    0.25576633f, -0.51708102f, 0.24420689f, 0.10718790f, -0.03438230f, -0.03771756f, -0.04367007f, -0.04021245f, 
    0.04257606f, 0.00650056f, 0.06341283f, 0.04743068f, 0.10678589f, 0.02326453f, 0.02326318f, 0.26130998f, 
    0.05238066f, -0.00935104f, 0.04947902f, -0.04235360f, -0.00495217f, -0.10458505f, -0.03846278f, -0.10666033f, 
    0.31748822f, -0.11387558f, -0.21074426f, -0.04447562f, 0.19747750f, 0.05118429f, -0.02409393f, 0.09686034f, 
    -0.08609964f, 0.05323655f, 0.16491653f, 0.09433971f, -0.27189517f, 0.16197833f, 0.20511432f, -0.32931426f, 
    0.09456990f, 0.01965927f, 0.01896884f, -0.12405900f, -0.01999518f, 0.05640985f, 0.06030489f, 0.05514220f, 
    -0.15508662f, 0.27775174f, 0.05209022f, -0.25671342f, 0.06249161f, -0.03418292f, -0.04524521f, 0.00670135f, 
    -0.03843384f, -0.04108705f, -0.00540987f, 0.08065061f, -0.12231298f, 0.08482920f, 0.07035882f, -0.19199018f, 
    -0.01583509f, 0.01726505f, -0.03721934f, 0.13249874f, 0.00060235f, 0.00507816f, -0.06257807f, 0.01276508f, 
    0.22682448f, -0.22851416f, 0.12566540f, -0.00967347f, 0.08141221f, -0.16190366f, 0.06908000f, 0.10639328f, 
    -0.00641927f, 0.05344529f, 0.04715756f, 0.10663485f, -0.19637680f, -0.16830051f, -0.10531452f, 0.13469099f, 
    0.08401801f, 0.09058261f, -0.01476950f, -0.06117864f, 0.05000845f, 0.05183234f, 0.02722257f, 0.10621817f, 
    -0.02581719f, 0.00620777f, 0.05632149f, 0.02371958f, 0.07904541f, 0.05698165f, -0.01180180f, -0.01771508f, 
    -0.02240324f, 0.05332753f, -0.11341461f, -0.05512881f, -0.00423733f, 0.18354253f, -0.08236458f, 0.04370469f, 
    -0.01443836f, -0.01131050f, 0.05524024f, -0.03881473f, -0.03180416f, -0.15021168f, 0.06456918f, 0.13534045f, 
    -0.22059034f, -0.14728031f, -0.10624496f, 0.13700588f, 0.00421015f, -0.06378457f, -0.09883180f, 0.11322562f, 
    0.00898279f, 0.08011750f, -0.00412216f, -0.03251690f, 0.13786495f, 0.00154727f, 0.01713104f, 0.36381271f, 
    -0.03247083f, 0.00360247f, -0.12463100f, 0.04217994f, 0.01603582f, -0.00537362f, -0.01570478f, -0.08799881f, 
    -0.00887293f, 0.01862069f, -0.08329438f, 0.07070764f, 0.04338914f, 0.00029457f, -0.03030670f, 0.01390184f, 
    0.10701766f, 0.15208258f, 0.19635163f, 0.21288624f, -0.02151374f, -0.03272011f, 0.07762312f, 0.10473421f, 
    0.06073630f, 0.04511788f, -0.01867259f, 0.04300771f, -0.00000092f, -0.03397094f, -0.08053566f, 0.21243846f, 
    -0.04187657f, 0.20888607f, -0.12521629f, 0.17362215f, -0.00473734f, 0.02800199f, 0.08106539f, -0.05933521f, 
    0.05247625f, 0.00708631f, -0.02387483f, -0.01860278f, 0.28741625f, 0.16685510f, 0.10607114f, 0.02393609f, 
    0.04965814f, 0.08281057f, 0.06396569f, 0.04395396f, 0.12101157f, 0.12316933f, -0.06787716f, -0.03786822f, 
    -0.17916988f, -0.06650812f, 0.08613703f, 0.05096708f, -0.03027447f, 0.05639052f, 0.09264713f, 0.08882149f, 
    0.03437575f, -0.05816506f, 0.08860207f, -0.07479554f, 0.17521656f, 0.16704039f, 0.03177665f, -0.10666169f, 
    0.03243249f, -0.05045855f, 0.03364700f, 0.09554818f, 0.03697664f, 0.04965305f, -0.04509581f, -0.06328538f, 
    -0.04617399f, -0.01418351f, 0.19482531f, -0.15955502f, 0.04689978f, 0.03833389f, 0.00793266f, -0.01390280f, 
    -0.11497466f, 0.00600012f, 0.01785614f, -0.01606122f, -0.05694093f, 0.10933530f, 0.12822086f, -0.27559507f, 
    0.10501391f, -0.02349912f, -0.00457781f, -0.03342210f, -0.00118578f, -0.00819957f, 0.09627898f, 0.10046069f, 
    -0.27468023f, -0.07300284f, 0.08984438f, 0.03239935f, 0.17168906f, 0.01488986f, -0.01920221f, 0.08193220f, 
    0.06442082f, -0.08957613f, 0.07186987f, -0.02884470f, -0.29716703f, -0.00136952f, 0.10735244f, 0.08297440f, 
    0.05649857f, 0.01679356f, -0.02065309f, 0.07367069f, -0.05433632f, 0.00677075f, 0.11397696f, 0.07054523f, 
    -0.11247290f, 0.18006109f, 0.12401524f, 0.10978200f, -0.01667606f, 0.05092109f, 0.08134642f, 0.09632747f, 
    -0.03272561f, 0.03094082f, -0.00223051f, -0.00853216f, -0.16407824f, -0.16405860f, -0.02179289f, -0.29764357f, 
    0.04676334f, 0.07495815f, -0.01562435f, 0.00127155f, 0.12219752f, 0.05483577f, 0.12572461f, 0.03183660f, 
    -0.03920109f, -0.17203192f, -0.06227436f, -0.08604392f, -0.07614201f, 0.09710721f, 0.05033636f, 0.09095504f, 
    -0.02991887f, -0.00243827f, 0.11126934f, -0.10796739f, 0.04649566f, 0.21425249f, 0.11815590f, -0.07497394f, 
    -0.04123950f, 0.13019347f, 0.10485233f, 0.02336777f, 0.00933573f, 0.11174253f, 0.03113290f, -0.05936173f, 
    -0.21887201f, 0.03451217f, 0.15068313f, -0.07124417f, 0.02606848f, -0.00697790f, 0.12231880f, 0.07266466f, 
    0.08750837f, 0.05579231f, 0.07563970f, 0.13597982f, 0.10722429f, 0.10545564f, -0.00826019f, 0.21295296f, 
    -0.06323308f, 0.08974913f, -0.01397733f, -0.01956628f, 0.00451266f, -0.04559688f, 0.05054816f, -0.02632443f, 
    -0.28172249f, 0.01262814f, -0.03747272f, 0.09627338f, 0.11096314f, -0.07738077f, -0.00490825f, -0.12360661f, 
    -0.04327396f, -0.01832212f, 0.13286674f, 0.16423871f, 0.33946234f, 0.07035312f, 0.19361845f, 0.03261491f, 
    -0.02859689f, -0.00408145f, 0.06163191f, 0.07965969f, 0.19710973f, 0.25923309f, -0.04486961f, 0.07422713f, 
    0.18237987f, 0.01856408f, 0.02835668f, 0.15173283f, -0.00415531f, 0.11192760f, -0.00649620f, -0.09174672f, 
    -0.10752573f, -0.01212380f, -0.09738573f, -0.24297875f, -0.35744295f, -0.03665132f, 0.07615669f, -0.04608358f, 
    0.09950139f, 0.07067118f, 0.04448529f, 0.05114349f, 0.13099821f, -0.05126994f, 0.09168565f, 0.01810727f, 
    0.11210189f, 0.13962202f, -0.03878931f, 0.15359263f, -0.04191913f, -0.02492142f, -0.04706825f, -0.01637369f, 
    0.01821941f, -0.03097339f, 0.00402770f, -0.07767214f, -0.29749060f, 0.04108835f, -0.02480280f, 0.08232509f, 
    0.05685715f, -0.00444842f, 0.07916632f, -0.19375618f, 0.01902060f, -0.25296268f, 0.00328980f, -0.10182146f, 
    -0.23515086f, -0.21232928f, -0.01013929f, -0.16480392f, -0.05558324f, 0.07870384f, 0.03293264f, 0.11703455f, 
    -0.03880830f, 0.08599328f, 0.06785618f, -0.01053407f, -0.06389253f, 0.10799949f, 0.12303799f, 0.02475648f, 
    0.01571344f, -0.05668093f, -0.03354336f, 0.07958622f, -0.15249759f, 0.11210351f, -0.03975028f, -0.04435176f, 
    0.22662164f, 0.18790011f, 0.09426992f, -0.01715025f, 0.07025193f, -0.10194705f, -0.02764170f, 0.11207120f, 
    0.09638765f, -0.06489743f, -0.00384917f, -0.01054038f, 0.20978358f, 0.10537703f, 0.10625920f, 0.04575020f, 
    -0.07202828f, 0.07906488f, 0.01324553f, 0.02785640f, 0.02802662f, 0.02286902f, -0.12537804f, 0.03584712f, 
    0.08681884f, 0.17983784f, 0.09392839f, 0.07412127f, -0.11697801f, -0.06008236f, 0.12048519f, 0.22471081f, 
    -0.02199740f, 0.05403603f, -0.11792972f, 0.00166196f, 0.00307422f, -0.16572948f, -0.19040132f, -0.05799686f, 
    -0.04422628f, 0.10442454f, -0.00952839f, -0.12958735f, 0.04051204f, 0.02541608f, 0.03410410f, 0.12563859f, 
    -0.24888687f, -0.08348153f, 0.07615360f, 0.03431381f, 0.14328362f, 0.10819270f, 0.15060276f, 0.08494813f, 
    -0.03884899f, 0.14018571f, -0.09672896f, 0.04896995f, 0.00487000f, 0.10114637f, 0.00962249f, 0.05305324f, 
    0.12279040f, -0.01520087f, 0.01806279f, 0.00962945f, 0.05417977f, -0.05706040f, 0.02984752f, 0.13907254f, 
    -0.17467646f, 0.05049670f, -0.13751608f, 0.07549827f, 0.11104947f, 0.04718312f, 0.06096855f, -0.04922161f, 
    -0.07552312f, 0.12755311f, 0.08253873f, 0.04655309f, 0.04646426f, -0.10657147f, -0.07777403f, 0.12854314f, 
    0.02162161f, 0.05544657f, -0.03363736f, 0.07068221f, 0.07629090f, -0.05806007f, -0.08016144f, -0.12130459f, 
    -0.02021395f, 0.03777544f, -0.01158048f, -0.06236161f, -0.05835403f, -0.00926278f, 0.06155339f, -0.04751978f, 
    0.13132828f, 0.13861999f, 0.13186450f, 0.16529903f, -0.23268971f, -0.12579452f, 0.07263984f, 0.02108433f, 
    0.06330434f, 0.07006107f, -0.03885048f, 0.10714756f, 0.01733729f, -0.01779097f, -0.02377597f, 0.18973756f, 
    -0.00131609f, -0.06089446f, -0.04126217f, 0.15880364f, -0.04611165f, 0.07653670f, -0.00957856f, 0.00236073f, 
    0.07348674f, 0.09169674f, 0.07831196f, -0.06928523f, -0.37396917f, -0.06905860f, 0.00517327f, -0.07271560f, 
    0.08216394f, 0.01212775f, 0.05534545f, -0.02005475f, 0.07589155f, 0.05365014f, 0.02829570f, 0.04890232f, 
    -0.15551500f, 0.24649504f, 0.05222050f, 0.11330255f, -0.04769580f, -0.03241991f, -0.02746030f, 0.02004600f, 
    0.04141881f, 0.01453876f, 0.00462456f, -0.00745256f, -0.25599706f, -0.00228474f, 0.02978267f, -0.15477897f, 
    -0.02652536f, -0.06956423f, -0.03893253f, -0.03776676f, -0.05553135f, 0.09335703f, 0.14074539f, 0.06781216f, 
    0.02917380f, -0.02961298f, 0.10212629f, -0.04880115f, 0.11776985f, -0.01637749f, 0.06363334f, 0.00019161f, 
    -0.00437375f, 0.09920525f, -0.00750001f, -0.00206485f, 0.51834542f, -0.19142918f, 0.06940938f, -0.05515512f, 
    -0.00387550f, -0.08754382f, 0.06051306f, 0.06755172f, 0.01793617f, 0.06633440f, -0.02815240f, -0.06250907f, 
    0.02840726f, -0.07926187f, -0.03126337f, -0.03139750f, 0.02540035f, -0.09699360f, 0.06713787f, 0.06822851f, 
    0.04582808f, 0.04529967f, 0.11250640f, 0.01648456f, -0.01482868f, -0.03274055f, -0.08690450f, 0.04257278f, 
    0.04027886f, 0.08112140f, 0.06544463f, -0.11112326f, 0.13040836f, -0.06679563f, -0.04369573f, 0.14250243f, 
    -0.26714256f, -0.08427586f, 0.02046302f, 0.11696673f, 0.03038967f, -0.00900276f, -0.10277554f, -0.08435193f, 
    0.07293211f, 0.07791047f, 0.04085099f, -0.05395951f, 0.10575803f, -0.10198088f, 0.23817681f, -0.11337084f, 
    0.03688281f, 0.09595278f, 0.12078236f, -0.06106613f, 0.05025267f, -0.03093212f, -0.10404854f, -0.13736194f, 
    0.10899386f, 0.03219115f, 0.18787538f, 0.07918217f, 0.21495210f, -0.02432270f, 0.18929672f, -0.02606866f, 
    0.11526217f, 0.00887789f, 0.01003464f, 0.04698154f, 0.08624891f, -0.16546148f, 0.14051445f, -0.05231863f, 
    -0.01477863f, 0.04765156f, -0.06359685f, 0.03141304f, 0.04642537f, 0.08656509f, 0.17578259f, 0.06520275f, 
    -0.29729614f, 0.37372270f, 0.11445820f, -0.00624136f, -0.17291895f, -0.10915659f, 0.12486255f, -0.07006694f, 
    0.00590869f, -0.07253065f, 0.06044175f, -0.07315017f, -0.42017138f, 0.24146110f, 0.02308376f, 0.00216241f, 
    -0.04085503f, 0.05056637f, -0.02692840f, -0.05442273f, 0.09869193f, -0.00763968f, 0.11927186f, 0.05041968f, 
    -0.11232155f, -0.04065258f, 0.15192790f, 0.01232567f, -0.01191796f, 0.05402927f, 0.11841173f, -0.07435003f, 
    0.03388960f, 0.10235465f, 0.02508439f, 0.01496535f, -0.04992470f, 0.00538724f, 0.08678056f, 0.10111173f, 
    0.08092972f, 0.03855490f, -0.03778926f, 0.00293400f, -0.04001218f, 0.04638601f, -0.08321920f, 0.03733895f, 
    -0.01952206f, -0.13747557f, 0.21315353f, -0.03190123f, -0.05016421f, 0.06436123f, 0.04449089f, -0.04021465f, 
    0.04011725f, -0.01708927f, -0.08069687f, -0.01928045f, -0.10867672f, -0.16208073f, -0.04361629f, -0.22603644f, 
    0.04078694f, 0.08816292f, 0.14835371f, 0.09338646f, 0.06251584f, 0.03938611f, -0.07303938f, 0.11000983f, 
    0.03702789f, -0.11140739f, 0.21798056f, 0.11379994f, 0.02237522f, 0.06321433f, -0.07546417f, -0.08122092f, 
    -0.00311548f, -0.01386030f, -0.08354002f, -0.07508387f, 0.04589859f, 0.20573688f, -0.02551795f, -0.03010333f, 
    0.07597161f, -0.00459617f, -0.11916261f, -0.14217019f, 0.19901949f, -0.00077485f, 0.03659315f, 0.04296486f, 
    -0.06487050f, 0.10647342f, 0.13610375f, -0.06750557f, 0.03800996f, -0.00653709f, -0.01350351f, 0.01012962f, 
    0.01305066f, -0.01624112f, -0.01642922f, 0.05863826f, -0.12302660f, -0.06755195f, 0.03442867f, -0.07058491f, 
    -0.04001883f, 0.03112210f, -0.06870984f, -0.06070873f, -0.03277211f, -0.05633380f, 0.14206371f, 0.06086956f, 
    -0.34503344f, 0.10408417f, 0.09559089f, 0.02893265f, 0.05447377f, 0.00087960f, -0.02010043f, 0.01285875f, 
    0.09578056f, -0.02952876f, 0.01445976f, 0.16785750f, -0.31736857f, 0.10164859f, 0.00418727f, 0.06202346f, 
    -0.06714533f, -0.04452954f, -0.06286336f, -0.00831684f, 0.07612336f, -0.01418112f, 0.08450557f, 0.03291748f, 
    0.22584704f, 0.03126972f, 0.01031525f, 0.08002447f, -0.00036292f, -0.05245491f, -0.04087806f, 0.01249001f, 
    0.02045734f, 0.01927650f, -0.04864240f, -0.06934056f, 0.11338338f, 0.14204933f, 0.06891151f, 0.18626535f, 
    0.03398948f, 0.10244735f, -0.04301915f, 0.05850225f, 0.01509488f, -0.07782403f, -0.01515928f, 0.07858097f, 
    0.23435032f, 0.11662613f, -0.05427649f, -0.08545877f, 0.02251321f, 0.10127044f, 0.03912349f, 0.01717290f, 
    -0.09028936f, 0.08196570f, 0.05086975f, 0.26778781f, 0.05002150f, 0.15656364f, 0.02391918f, 0.04912440f, 
    -0.05076724f, 0.04591889f, 0.05862229f, -0.04356556f, -0.11273225f, 0.03527457f, 0.17740147f, 0.08680733f, 
    -0.02398329f, 0.11886552f, 0.00943923f, 0.23646867f, -0.01778525f, 0.12532002f, -0.02161956f, 0.02319169f, 
    0.01865096f, -0.01538580f, 0.00505433f, 0.00396189f, -0.24155879f, 0.17928512f, -0.07244574f, 0.11239146f, 
    0.01222916f, 0.05123105f, -0.04188226f, -0.12623078f, 0.19676560f, -0.00849982f, -0.02064516f, 0.02177068f, 
    -0.08201235f, 0.15732676f, 0.11447925f, -0.11702956f, -0.18280151f, 0.09474880f, 0.07171688f, 0.05205434f, 
    0.09639984f, -0.15434594f, 0.14047344f, 0.08205100f, -0.06276566f, -0.02166936f, -0.13623458f, 0.06039283f, 
    -0.06244113f, 0.09261974f, -0.10402497f, 0.02363219f, 0.02257815f, -0.05799782f, -0.12472873f, -0.11252431f, 
    -0.07023602f, -0.19359344f, 0.13987604f, 0.07472356f, -0.11553033f, 0.09790074f, 0.12050529f, 0.05355196f, 
    0.01362342f, -0.05372884f, 0.03405188f, 0.04788512f, -0.08648832f, 0.06595873f, 0.06166045f, 0.02102505f, 
    -0.01772088f, -0.03672061f, 0.01751680f, -0.05177781f, -0.01101583f, 0.03065685f, -0.02421242f, 0.02579224f, 
    0.28667864f, -0.14378741f, -0.06868576f, 0.01335592f, -0.03560751f, -0.01282009f, 0.05963852f, 0.12589300f, 
    -0.01490049f, 0.06730651f, -0.06118533f, 0.09454069f, -0.15137148f, -0.00227852f, 0.07968365f, -0.02777910f, 
    0.03486615f, 0.09713291f, -0.01115490f, -0.01213540f, 0.09310307f, 0.04306415f, -0.01687150f, -0.03048710f, 
    0.04315851f, 0.04679694f, -0.09501514f, -0.15430692f, 0.09837561f, 0.02983281f, 0.02089127f, 0.02687922f, 
    0.08309133f, 0.06521253f, -0.00351902f, -0.05301498f, 0.19173911f, 0.07188957f, -0.20128506f, 0.10362898f, 
    0.01123434f, 0.06156225f, 0.04982612f, 0.12810597f, -0.10840748f, 0.03208048f, 0.01630531f, 0.20718376f, 
    0.14448310f, -0.09293599f, -0.02358674f, 0.04408289f, -0.09695627f, -0.02808461f, 0.04452833f, 0.03804266f, 
    0.01312407f, 0.08018079f, 0.07809522f, 0.12898999f, -0.07332838f, -0.12232799f, 0.08910692f, 0.06247610f, 
    -0.01343427f, 0.05471653f, 0.03059062f, -0.01627298f, -0.04834590f, -0.07199402f, 0.11721135f, 0.03568365f, 
    -0.20197649f, -0.17031184f, 0.07538139f, -0.00957662f, 0.01780918f, -0.00276505f, 0.01819198f, -0.00872406f, 
    0.01216520f, -0.08178592f, -0.06038317f, 0.02280742f, 0.27382135f, 0.12199291f, -0.16262171f, -0.04053460f, 
    -0.19580340f, -0.06435220f, 0.07907851f, 0.11252301f, 0.05365464f, 0.03126187f, -0.05234919f, -0.04015411f, 
    0.00734824f, -0.01954315f, -0.06085209f, -0.04136110f, -0.05444147f, 0.08860227f, -0.07760631f, -0.06584541f, 
    0.05727332f, -0.05058286f, 0.10957894f, 0.16165201f, -0.21378560f, -0.05025300f, -0.05767247f, 0.12294949f, 
    -0.03752234f, -0.06260799f, 0.09108666f, 0.00859583f, -0.01822340f, 0.05448970f, -0.03588513f, 0.07084759f, 
    0.28780836f, -0.39094031f, -0.02107836f, -0.03008489f, -0.03246412f, 0.09184282f, -0.03016678f, 0.06343336f, 
    -0.07169585f, -0.02474636f, 0.07463855f, 0.09805988f, 0.11180279f, 0.02889160f, 0.10276304f, -0.22789460f, 
    0.08361017f, 0.05299697f, -0.00189077f, 0.01770888f, -0.02813096f, 0.01787501f, -0.00035653f, -0.08580245f, 
    0.39738101f, 0.18685903f, -0.16523337f, -0.04744033f, -0.01183210f, 0.14302276f, 0.05496658f, 0.10620993f, 
    0.02751729f, 0.01471110f, -0.08688077f, 0.04253976f, -0.23497862f, 0.01844389f, 0.08658865f, 0.14529431f, 
    0.09244755f, -0.02776414f, 0.16019318f, -0.12481508f, -0.09784963f, -0.06949138f, -0.01759543f, 0.00713126f, 
    -0.29874355f, 0.04467817f, -0.09416862f, -0.06562194f, 0.13866083f, 0.03025438f, 0.03340400f, -0.01083379f, 
    0.05857057f, -0.00367088f, 0.10179426f, 0.05953318f, 0.56270736f, -0.07156152f, -0.00527512f, 0.14465334f, 
    -0.08462927f, 0.01736638f, -0.02508726f, -0.00196779f, 0.05560147f, -0.02087426f, 0.00823341f, 0.01438308f, 
    -0.16021016f, 0.43186170f, -0.02888402f, -0.27788609f, 0.16211908f, 0.00131570f, 0.13881266f, -0.07503757f, 
    0.00258656f, -0.01687601f, -0.04159417f, 0.01600874f, -0.01540987f, -0.09168990f, -0.05688644f, -0.10720558f, 
    0.03092582f, -0.02099999f, 0.08408426f, 0.08303134f, -0.07959553f, -0.00048083f, 0.21400204f, 0.00080013f, 
    0.11902896f, -0.16244304f, -0.09612600f, 0.06061689f, -0.20383935f, 0.03090520f, -0.04232586f, 0.06228539f, 
    0.06924544f, -0.01215157f, 0.00703380f, 0.05451573f, 0.00589951f, -0.11874948f, 0.03301528f, 0.08406197f, 
    0.00259324f, 0.01685516f, -0.10235363f, 0.02804917f, 0.06410405f, 0.03801452f, -0.02227517f, 0.05150479f, 
    -0.22264284f, -0.00493503f, 0.19463682f, -0.01743035f, 0.03720734f, 0.11500709f, 0.09167780f, 0.06320786f, 
    0.00286435f, 0.12281094f, 0.16115186f, 0.03653211f, 0.01504239f, -0.00011110f, 0.07648886f, 0.02409554f, 
    0.08428762f, 0.11094277f, -0.06314430f, -0.03816348f, 0.08823095f, -0.02874704f, 0.02414013f, -0.05200629f, 
    0.10148551f, 0.15708394f, -0.36200345f, -0.09493174f, 0.09525906f, 0.17001009f, 0.04518204f, 0.06672238f, 
    -0.03516532f, 0.13076417f, 0.10339528f, -0.03392165f, 0.03852863f, 0.14944400f, -0.03179085f, -0.13735659f, 
    -0.11578791f, -0.24357246f, -0.02282471f, 0.06819395f, 0.01405308f, 0.09124762f, 0.03988812f, 0.02495315f, 
    0.04604933f, 0.01708210f, 0.09244372f, 0.00625530f, -0.06285434f, -0.00265691f, -0.02889391f, 0.11119183f, 
    -0.09707815f, -0.11348514f, -0.04505742f, -0.03980044f, -0.06586398f, -0.18928374f, 0.09106186f, -0.09630592f, 
    0.04461663f, 0.11447613f, -0.03068311f, -0.10294160f, 0.10352243f, 0.17632601f, 0.03216157f, 0.05991759f, 
    -0.02273114f, -0.10577140f, 0.04806803f, 0.00052739f, -0.13559280f, -0.01995058f, 0.04799645f, -0.04673192f, 
    0.05637913f, 0.00761911f, 0.03056265f, 0.02105275f, -0.08184898f, -0.09542669f, 0.01772218f, -0.08504708f, 
    -0.00262317f, 0.13187347f, 0.04539315f, 0.09083065f, -0.00068646f, 0.05389206f, 0.07561420f, 0.05670290f, 
    0.07388025f, -0.09253201f, 0.02998374f, -0.04934770f, 0.06418680f, 0.07829120f, -0.03183377f, 0.12050877f, 
    0.02762706f, 0.09420433f, 0.02202929f, 0.02251916f, 0.03327505f, 0.10043876f, 0.00667082f, 0.00349546f, 
    -0.05014545f, -0.03618842f, -0.01130766f, 0.06481941f, 0.06885201f, -0.07466174f, 0.08317293f, 0.11319131f, 
    -0.04118214f, 0.02313636f, 0.01323464f, 0.01327459f, -0.04615676f, 0.03029360f, 0.00363340f, -0.00855988f, 
    -0.00617542f, -0.01257211f, -0.00621253f, 0.00283580f, -0.05543517f, 0.03403422f, -0.02699580f, 0.01024640f, 
    0.00520179f, 0.03363622f, -0.00484649f, 0.03591865f, -0.02220952f, 0.00721300f, 0.04004381f, 0.03302132f, 
    0.01376688f, 0.03709674f, -0.05881149f, 0.00216948f, 0.02849676f, 0.02238366f, 0.01956499f, 0.03440086f, 
    0.02024751f, 0.02636169f, 0.04130799f, 0.03427436f, 0.01445828f, -0.01548516f, 0.01087571f, -0.02932462f, 
    -0.01790204f, 0.02308782f, -0.05265330f, -0.05123246f, 0.03723353f, -0.01414954f, 0.01413034f, 0.01656976f, 
    0.01418692f, -0.05539599f, -0.00496415f, -0.00322331f, -0.01011621f, 0.04226452f, 0.01963025f, -0.00328689f, 
    -0.03785791f, -0.01543343f, -0.00068508f, 0.00259151f, -0.04412268f, 0.00762835f, -0.03112369f, -0.00006741f, 
    -0.01386022f, -0.01504102f, 0.00749872f, -0.02770115f, -0.04976905f, 0.01179051f, -0.00882133f, -0.05739966f, 
    0.01187418f, 0.03968469f, -0.02089328f, -0.01023069f, 0.02197528f, -0.03376740f, -0.03829642f, -0.03500006f, 
    0.01660044f, -0.03828006f, 0.02334147f, 0.03530124f, 0.01197925f, -0.00770065f, -0.02865040f, -0.05426033f, 
    0.03316866f, 0.01394319f, 0.00520709f, -0.01094522f, -0.05791458f, 0.01937668f, -0.04795214f, -0.01209569f, 
    -0.02153808f, 0.02038168f, -0.02697818f, -0.00559495f, 0.03159550f, -0.02289586f, 0.00936591f, -0.01394549f, 
    -0.04398547f, 0.04289851f, -0.05913743f, -0.02266053f, 0.03967004f, 0.00026066f, 0.01340368f, 0.00053368f, 
    0.01170714f, 0.03308592f, -0.03359407f, -0.04984693f, -0.03868407f, -0.02959363f, 0.03151683f, -0.03139352f, 
    -0.02258418f, -0.02575949f, 0.03275336f, -0.04838151f, 0.03268009f, -0.02084419f, 0.00473750f, -0.05001643f, 
    0.03386960f, -0.01956265f, 0.02954967f, 0.03430963f, 0.03973835f, 0.03681143f, -0.00017591f, 0.00744083f, 
    -0.04072484f, -0.05047487f, 0.03997571f, -0.03550499f, -0.02060570f, -0.02381413f, 0.03335392f, -0.01865733f, 
    -0.02985953f, -0.00667057f, 0.01710008f, -0.02019070f, -0.04987947f, 0.00103174f, -0.02815658f, -0.03418923f, 
    0.01674437f, -0.01896810f, -0.05305899f, 0.03884406f, 0.00604940f, -0.04122423f, 0.03618744f, -0.05138876f, 
    -0.05518880f, -0.03806855f, -0.02467544f, -0.04642655f, 0.02009012f, 0.00028943f, 0.00900637f, 0.02094543f, 
    0.04055736f, -0.04173264f, -0.00672649f, 0.02607014f, 0.00131549f, 0.04175019f, 0.00125716f, 0.01228551f, 
    -0.03967443f, -0.02409292f, -0.02860942f, 0.04328022f, -0.00067630f, 0.00674769f, 0.02894346f, 0.02074862f, 
    0.00300316f, -0.01657043f, 0.01259267f, -0.00597743f, -0.00433841f, -0.03950808f, -0.04691469f, -0.01164433f, 
    -0.05615844f, -0.02359002f, -0.01825011f, 0.01438203f, 0.01327393f, 0.00576313f, 0.03218403f, -0.05405991f, 
    0.03474569f, -0.03562430f, -0.00546147f, -0.05127383f, -0.04287364f, 0.01780332f, 0.01168272f, 0.03828401f, 
    -0.05331689f, -0.00536250f, -0.03408035f, -0.01142320f, -0.04443709f, -0.02060659f, -0.02751395f, 0.00449605f, 
    0.01071962f, 0.01059878f, 0.02246566f, 0.04243513f, -0.02944293f, 0.01003117f, -0.01553963f, -0.03547066f, 
    -0.02865122f, -0.04025114f, 0.02921931f, -0.05444541f, -0.00990493f, 0.03129084f, 0.01429491f, -0.03594824f, 
    0.02576028f, 0.01635884f, 0.00248525f, -0.01660321f, 0.02098131f, -0.03235798f, 0.02669924f, 0.01567438f, 
    -0.03962276f, 0.00951388f, 0.00065873f, 0.00442935f, 0.02685066f, -0.02599182f, -0.00605992f, -0.00051344f, 
    0.02421169f, -0.02241342f, -0.00842812f, 0.00469609f, -0.00979253f, -0.04756686f, -0.01367203f, -0.04817523f, 
    -0.00734013f, -0.04958760f, -0.05912409f, -0.02478545f, -0.03101213f, 0.03113225f, -0.03849841f, -0.03553899f, 
    -0.01312689f, 0.04090600f, 0.03213139f, -0.05759414f, -0.01267652f, 0.01940848f, 0.04169562f, 0.01278494f, 
    -0.04250297f, 0.03110868f, -0.04616985f, 0.00114192f, -0.00273044f, 0.04324346f, -0.04773565f, -0.00526517f, 
    0.00872670f, -0.00379075f, -0.05788678f, -0.01998157f, -0.00630664f, 0.00625470f, -0.03414743f, -0.05270286f, 
    -0.01216559f, -0.04798071f, 0.01766460f, -0.03588857f, 0.03791343f, 0.00350677f, -0.00644040f, -0.05520132f, 
    -0.00931458f, 0.02415807f, -0.03611368f, 0.01463347f, -0.04659339f, -0.00686071f, -0.01787194f, -0.03117189f, 
    0.02662885f, -0.04661920f, 0.01376373f, 0.00038642f, -0.05467187f, -0.02955584f, -0.01367253f, 0.03296452f, 
    -0.00094505f, -0.04093434f, -0.04969854f, 0.00300713f, 0.02300978f, 0.04259298f, 0.01134937f, -0.00050615f, 
    -0.01939934f, -0.03458981f, 0.03132151f, 0.03786130f, -0.00331000f, -0.01620394f, -0.00654485f, -0.02982082f, 
    0.02121475f, -0.01066434f, 0.03907795f, -0.02764186f, -0.05895222f, 0.01904043f, 0.02759204f, -0.03998237f, 
    0.03478232f, -0.05346365f, 0.03246690f, -0.03602916f, -0.02192534f, 0.00091618f, -0.00701309f, 0.00237905f, 
    0.03459907f, -0.03344264f, 0.03546187f, 0.01466556f, -0.03234962f, -0.02305724f, -0.01066929f, -0.05692187f, 
    -0.01434674f, 0.03360291f, -0.04315207f, -0.03600439f, -0.02736738f, -0.03402192f, 0.04232517f, 0.02517709f, 
    -0.00471544f, -0.03711185f, 0.03136253f, -0.00436664f, 0.01512867f, -0.04675865f, 0.03843673f, -0.00330931f, 
    -0.01642827f, -0.01988451f, -0.01279106f, 0.03202402f, -0.01739193f, 0.01320690f, -0.01915528f, 0.01514129f, 
    -0.04328731f, -0.02523846f, -0.04361363f, -0.05212125f, 0.00209498f, -0.01883408f, 0.01398500f, 0.00669758f, 
    -0.05084497f, -0.01151714f, -0.05365419f, 0.03465122f, 0.00639755f, -0.04923505f, -0.01119687f, 0.01220703f, 
    0.01070020f, 0.01557892f, 0.01571086f, 0.00004727f, -0.00761667f, 0.00337710f, -0.01326227f, 0.00650617f, 
    0.02462802f, -0.02510120f, 0.02406315f, 0.00400808f, -0.03439978f, -0.04437487f, 0.03616007f, -0.00314372f, 
    -0.05144348f, 0.04251872f, 0.02179979f, 0.00935740f, -0.04732194f, 0.00342249f, 0.01519824f, -0.03039313f, 
    0.01987562f, -0.04963494f, -0.03718667f, -0.02670710f, -0.01105421f, 0.01911194f, 0.00047453f, 0.00687930f, 
    0.03819529f, -0.01743351f, -0.02356598f, -0.03935736f, -0.03112650f, -0.01079713f, 0.05007000f, -0.02763430f, 
    0.02973998f, -0.01483127f, -0.05271640f, -0.04026183f, 0.01073259f, 0.04198616f, 0.01304633f, -0.04333129f, 
    0.03838250f, -0.00053057f, -0.03047661f, -0.03568057f, 0.04061748f, -0.02891801f, 0.01493228f, 0.01760241f, 
    0.02615275f, 0.00699532f, 0.01299833f, -0.02131764f, 0.04450361f, 0.01011049f, 0.00617757f, 0.03718130f, 
    0.01895678f, -0.04764070f, 0.03863540f, -0.01735488f, -0.04178301f, -0.03077131f, -0.03204330f, 0.01324702f, 
    0.02650731f, 0.02017577f, 0.01090488f, -0.02077822f, 0.03894468f, -0.04083958f, 0.01941742f, -0.01760949f, 
    -0.02640395f, -0.03495285f, -0.00835359f, -0.05539848f, 0.05830886f, 0.01590366f, -0.04368446f, 0.01575626f, 
    -0.00104328f, -0.04599511f, 0.02979464f, -0.02239534f, -0.01621868f, 0.02009164f, -0.01457316f, 0.01594305f, 
    0.03759316f, 0.03700263f, -0.03045642f, -0.02047898f, -0.02458721f, -0.02261718f, -0.02973737f, -0.03796302f, 
    0.00955634f, -0.02993341f, 0.02144563f, -0.00045032f, -0.05484720f, 0.01019026f, 0.02727483f, 0.00433954f, 
    -0.04125709f, -0.04613305f, 0.03407476f, -0.03326091f, 0.02013709f, 0.00139722f, -0.04598219f, 0.03758411f, 
    -0.03400390f, -0.03330052f, 0.00116723f, 0.03209848f, 0.02565952f, -0.01560170f, -0.02768884f, 0.03840624f, 
    0.00016219f, -0.02833206f, 0.03215121f, 0.04576115f, -0.04108218f, 0.02543364f, 0.00269474f, -0.04578458f, 
    -0.00006505f, -0.03615987f, -0.04386963f, 0.01559763f, -0.00265463f, 0.01786018f, -0.01757789f, 0.02053725f, 
    0.02762908f, -0.03748394f, 0.02434716f, -0.02433887f, -0.01009210f, 0.04331524f, -0.04825714f, -0.00514414f, 
    -0.02530128f, -0.02434412f, 0.01840935f, -0.05066342f, -0.03041631f, 0.02400422f, -0.04146739f, -0.03543083f, 
    0.02464366f, 0.03933056f, -0.01669443f, -0.04331154f, -0.01034197f, -0.02781262f, 0.00964340f, -0.02442201f, 
    0.04430974f, -0.00730404f, 0.02076835f, 0.02429534f, -0.05082554f, 0.02460320f, -0.01488880f, 0.02602352f, 
    -0.00823666f, 0.03423345f, -0.02573114f, -0.01327736f, -0.02417498f, -0.00537683f, 0.02546224f, -0.05491626f, 
    -0.01094057f, -0.05362248f, -0.04533213f, 0.02053514f, 0.03938293f, -0.04909999f, -0.02020916f, 0.03477641f, 
    -0.03723494f, -0.03692233f, 0.03353509f, 0.02938570f, -0.02403900f, -0.03916525f, -0.01373329f, -0.04169695f, 
    0.03506867f, 0.00243631f, -0.00522515f, -0.01329213f, -0.03834993f, -0.02429282f, -0.01027766f, -0.01265723f, 
    -0.01913706f, -0.04467535f, 0.03056296f, -0.01877067f, 0.02326350f, 0.03131812f, 0.04100383f, -0.03262550f, 
    -0.03193296f, -0.00444223f, -0.04236038f, -0.05278426f, -0.01257348f, 0.03034172f, 0.03230432f, 0.03050977f, 
    0.02641827f, -0.01597109f, -0.00841034f, 0.01640976f, -0.03333578f, -0.00863718f, -0.03066134f, 0.03442054f, 
    0.01092832f, -0.03609829f, -0.00666252f, 0.04523405f, 0.03525865f, -0.04892717f, 0.02500692f, -0.02246356f, 
    0.00481743f, -0.04326160f, -0.02693625f, 0.00832766f, -0.00040444f, -0.00088305f, 0.01517392f, 0.01135497f, 
    0.03099032f, -0.00415740f, 0.02164257f, 0.00852599f, -0.01130322f, 0.00295368f, -0.03836338f, -0.03624542f, 
    0.00400628f, 0.02711224f, -0.02615080f, -0.03946003f, -0.03982753f, 0.00023635f, -0.00735841f, -0.01331957f, 
    0.02992984f, -0.04360389f, -0.04885428f, -0.02277281f, -0.00780941f, 0.02551019f, 0.00935529f, 0.02775184f, 
    0.04070977f, -0.03961374f, -0.03615835f, -0.03579527f, -0.02377443f, -0.00460428f, -0.01673629f, -0.03099440f, 
    0.02323969f, -0.00137169f, -0.00714029f, 0.00625938f, -0.00158298f, 0.00542330f, -0.05663026f, -0.03526692f, 
    -0.00325405f, 0.03708512f, -0.02527202f, 0.03347552f, 0.03673099f, 0.03568648f, 0.00129321f, -0.02006226f, 
    -0.02606531f, 0.03441903f, -0.05557905f, -0.04192974f, -0.02309902f, -0.03924143f, 0.02751111f, -0.04113406f, 
    0.04094831f, -0.02173810f, -0.02808194f, -0.02392595f, -0.00320170f, 0.03575190f, 0.00631695f, 0.00748787f, 
    0.04010858f, -0.00483612f, -0.00272957f, 0.02158497f, -0.04751764f, 0.01830670f, -0.03858897f, 0.03804335f, 
    -0.01283013f, -0.00444720f, 0.01902343f, -0.03006309f, -0.05490066f, 0.00596232f, -0.04399590f, 0.00231758f, 
    -0.05227202f, 0.04531581f, -0.01559873f, -0.00439419f, -0.01508323f, 0.04264152f, 0.01056901f, 0.00295134f, 
    -0.04014151f, -0.03252314f, 0.03971219f, -0.00536290f, 0.03505490f, 0.02492229f, 0.02929205f, 0.01013491f, 
    0.02865467f, -0.04469529f, -0.05361417f, -0.02845367f, 0.01507883f, 0.02417271f, 0.04182087f, 0.03703762f, 
    -0.00303931f, -0.04472302f, 0.04240194f, -0.01558398f, 0.00994196f, -0.03510991f, -0.01015598f, 0.00067329f, 
    -0.03455440f, 0.04229109f, 0.03417076f, -0.04003041f, 0.03288580f, -0.04194139f, -0.00331750f, 0.04383343f, 
    -0.04086511f, 0.02022468f, 0.03586173f, -0.00864196f, -0.02912210f, -0.02548231f, 0.01681704f, 0.01227886f, 
    -0.18848076f, 0.17152949f, 0.16183035f, -0.03255844f, 0.02697743f, 0.07479789f, -0.09818514f, -0.03153181f, 
    -0.02817168f, 0.14640370f, 0.08741838f, 0.04934621f, 0.05536512f, -0.09831005f, -0.02489595f, -0.14452796f, 
    0.05946428f, 0.00713956f, -0.13174272f, -0.06000783f, 0.02359758f, -0.11366374f, 0.03410578f, -0.04295320f, 
    0.08534209f, -0.05782605f, 0.12638180f, -0.08850905f, 0.13966624f, 0.02424314f, 0.01165810f, -0.00961756f, 
    0.06992366f, -0.20083874f, -0.05924843f, -0.08766104f, -0.01890222f, -0.03420130f, -0.19358748f, -0.10038969f, 
    0.04924348f, -0.02457499f, -0.07978258f, -0.00482013f, -0.08811850f, -0.06415733f, 0.02728386f, -0.04355607f, 
    -0.17780830f, -0.02177705f, 0.13705705f, 0.32219309f, 0.01223123f, 0.03802660f, -0.05777190f, 0.01243346f, 
    -0.06161019f, 0.10450693f, -0.01172885f, 0.10039150f, -0.11515461f, 0.06159180f, -0.05482202f, 0.25396207f, 
    -0.01214171f, 0.03063476f, 0.07761898f, -0.01681644f, 0.00630622f, -0.07958582f, 0.05428523f, -0.21000895f, 
    -0.05951804f, 0.30769584f, 0.06605367f, -0.06223617f, 0.18438202f, 0.00077160f, -0.02325913f, -0.02893558f, 
    -0.00407013f, -0.04662712f, 0.10904237f, -0.03782037f, 0.22773048f, 0.12588662f, -0.17770736f, 0.00060486f, 
    -0.11717778f, 0.11208065f, 0.13284178f, 0.04445588f, -0.06614950f, 0.05493009f, 0.09279588f, 0.01141212f, 
    0.03599668f, 0.22404365f, -0.09017242f, -0.12596969f, 0.04840915f, 0.00573710f, 0.09174486f, -0.14178485f, 
    0.03211195f, 0.04579387f, 0.02212906f, -0.02369604f, 0.01789682f, 0.04127406f, 0.00523229f, 0.32091698f, 
    0.16911113f, -0.03562812f, 0.05713468f, 0.05416263f, 0.11628348f, -0.03630445f, -0.06007172f, -0.00869710f, 
    -0.02584245f, -0.02519455f, 0.14134097f, 0.09324782f, 0.12671304f, 0.02430813f, -0.05002293f, 0.03773843f, 
    0.00124517f, -0.14054041f, 0.12035504f, -0.12931591f, 0.19743071f, 0.12527503f, -0.32103625f, -0.08066196f, 
    -0.04011368f, 0.02328658f, -0.10568275f, -0.11709215f, 0.05714879f, -0.04548585f, 0.04219613f, 0.00381852f, 
    -0.37059835f, 0.31358162f, -0.25231415f, 0.28870112f, 0.00866620f, -0.05006820f, 0.08113687f, 0.04114780f, 
    -0.07971840f, 0.01795530f, -0.06489030f, -0.05174147f, -0.04851700f, 0.07735950f, 0.09328046f, -0.24748044f, 
    -0.02581062f, -0.02254696f, -0.08822586f, 0.03831939f, 0.13178155f, 0.07865477f, 0.01983602f, 0.01143839f, 
    0.27473640f, -0.36385453f, -0.15132247f, 0.12413916f, -0.03298457f, -0.06939979f, -0.04004584f, 0.09009518f, 
    -0.02898839f, -0.00560965f, -0.11500924f, -0.06273948f, 0.00008949f, -0.09334128f, -0.01822952f, -0.01802129f, 
    -0.06358009f, 0.01794983f, 0.04786803f, 0.08640023f, -0.06174663f, 0.08745872f, 0.14651312f, -0.10616489f, 
    0.08361721f, -0.12539594f, 0.25004092f, -0.02302121f, -0.03486378f, 0.05061392f, -0.10013834f, 0.17141610f, 
    0.00910290f, 0.04171000f, -0.00642784f, 0.20130345f, -0.16041721f, 0.49750715f, -0.55754876f, 0.16195959f, 
    -0.13254906f, 0.03265932f, -0.18570560f, 0.07429162f, -0.11121549f, 0.05873146f, 0.05643911f, 0.01062671f, 
    -0.03562551f, -0.28308970f, -0.03655438f, -0.09786003f, -0.13100123f, 0.07006335f, -0.07173961f, -0.00643403f, 
    -0.00671508f, -0.07154739f, 0.06572384f, 0.09711844f, -0.03574524f, 0.04321780f, 0.16665706f, 0.03990450f, 
    0.07292598f, 0.01979964f, 0.00998657f, 0.01993582f, -0.00505370f, -0.00835944f, -0.23929125f, 0.07897174f, 
    0.29829794f, 0.45517698f, 0.12261336f, 0.13562009f, 0.26014709f, 0.02253501f, 0.08310796f, -0.06996428f, 
    -0.02960537f, 0.07595178f, 0.04463203f, -0.01388367f, -0.05769834f, 0.08188675f, 0.02998658f, -0.00210878f, 
    -0.04173928f, 0.04637708f, 0.17141558f, -0.02600561f, 0.04964556f, -0.03215029f, 0.07425687f, 0.02479557f, 
    0.07861743f, 0.05971182f, -0.19340873f, -0.10611480f, 0.01125750f, -0.12682047f, -0.05093205f, -0.15929088f, 
    -0.08130672f, -0.05947157f, -0.18580936f, 0.01099681f, -0.15191241f, 0.22382504f, -0.16455436f, -0.10781223f, 
    -0.12061745f, 0.04832245f, -0.16791299f, -0.00480230f, -0.11586324f, 0.05733085f, 0.03417998f, 0.11810012f, 
    0.15425344f, -0.19971243f, 0.15272047f, 0.20547783f, 0.12081244f, -0.01790454f, -0.10024257f, -0.10991571f, 
    0.00873678f, -0.08031037f, 0.04771133f, 0.09730330f, 0.09260152f, 0.17028534f, 0.21450299f, 0.05031716f, 
    0.17962217f, 0.02054001f, 0.09160791f, 0.15466906f, 0.20526558f, 0.01360557f, 0.04520188f, -0.00761755f, 
    -0.02258012f, 0.07625622f, -0.13359468f, -0.04937584f, -0.05727829f, 0.00164033f, 0.04637646f, -0.05069199f, 
    0.18397610f, 0.10309284f, 0.11825923f, -0.04997046f, -0.10442652f, 0.26592019f, -0.02100257f, 0.07847456f, 
    -0.00701801f, 0.08217295f, 0.01803059f, 0.03861767f, -0.16480428f, -0.05330049f, -0.13149992f, -0.00800809f, 
    0.32181230f, 0.07159743f, -0.05891765f, 0.07549747f, 0.07689848f, -0.01884622f, 0.02833857f, 0.19775411f, 
    0.06436002f, 0.09191732f, 0.06909589f, 0.03829087f, -0.34945783f, 0.16076903f, 0.38943812f, -0.29025349f, 
    0.06352925f, -0.03229627f, 0.02920859f, -0.07671168f, -0.12335709f, -0.02375143f, -0.02223491f, 0.02343362f, 
    -0.15686327f, 0.06943930f, 0.02287921f, 0.11572869f, -0.00067445f, -0.04937610f, 0.08560314f, 0.07474444f, 
    -0.05950647f, -0.01553390f, -0.20902681f, -0.04483885f, 0.14019075f, -0.06289975f, 0.01872249f, -0.28430113f, 
    0.05397645f, 0.04151922f, 0.16354477f, 0.02454881f, 0.15900962f, 0.14682475f, 0.00650837f, -0.00471416f, 
    -0.01152429f, -0.05526219f, -0.05599802f, -0.05339686f, 0.03231008f, -0.02948693f, 0.01317711f, -0.00189508f, 
    0.03849046f, 0.01729335f, 0.03378963f, -0.03562365f, 0.02020804f, 0.01445792f, 0.00289906f, 0.00233918f, 
    -0.00714708f, 0.01504911f, -0.00391298f, 0.03086748f, -0.04420182f, -0.05533222f, 0.01672333f, -0.02563592f, 
    0.05002271f, -0.03864207f, -0.04904737f, -0.00591408f, 0.02554808f, 0.00572454f, -0.02587134f, -0.02405787f, 
    -0.04100852f, 0.02615418f, -0.00974231f, 0.01799764f, 0.00669608f, 0.00625517f, -0.03538590f, -0.02976662f, 
    -0.01434315f, -0.03972274f, 0.01569984f, 0.00825972f, 0.00634497f, -0.02636735f, -0.04712424f, -0.00719104f, 
    0.02091612f, 0.02590973f, -0.03065115f, 0.03735406f, 0.01791862f, 0.01925999f, -0.04390956f, -0.00889852f, 
    0.03111893f, 0.00128383f, -0.03771890f, -0.03287516f, -0.04156914f, 0.00698374f, -0.05373941f, 0.00695970f, 
    -0.05173280f, -0.02614054f, 0.03510147f, -0.01351560f, -0.05191860f, -0.01940507f, 0.02600543f, 0.01477639f, 
    0.03554293f, 0.04468276f, -0.05288533f, -0.05170513f, -0.00147464f, -0.05127838f, -0.01460738f, 0.04199052f, 
    0.02675289f, 0.00280295f, -0.03185916f, 0.02801602f, 0.01449890f, 0.00111258f, 0.02194836f, -0.01507596f, 
    0.01483819f, 0.01270656f, -0.01152806f, 0.00816180f, -0.05797796f, 0.02906658f, -0.03764710f, 0.01735279f, 
    0.01028995f, 0.03548515f, -0.04758479f, -0.00934458f, -0.00004169f, -0.03258863f, -0.05125229f, -0.01620415f, 
    0.03815667f, -0.02864218f, -0.02382860f, -0.01961411f, -0.01628290f, -0.04584315f, -0.00846939f, -0.05113456f, 
    -0.05920741f, 0.00080789f, -0.02329841f, -0.00268987f, -0.04131124f, -0.04952984f, -0.01119610f, -0.05396271f, 
    0.03113134f, 0.04027769f, 0.00263783f, 0.01670520f, -0.00831706f, -0.02479716f, 0.03341858f, -0.02912044f, 
    -0.01457990f, 0.01753136f, 0.01439185f, 0.00747050f, 0.02808405f, -0.01365675f, 0.00554411f, -0.01384664f, 
    -0.03585035f, -0.03462198f, 0.04075933f, 0.04366472f, -0.04953143f, 0.02472088f, 0.04716685f, -0.03962982f, 
    0.00751381f, 0.04469847f, -0.02685452f, -0.02760129f, 0.01319166f, -0.00589874f, 0.01496844f, -0.02687601f, 
    -0.00985095f, -0.02624329f, -0.04038690f, 0.04120290f, 0.04569542f, -0.01730066f, 0.03592758f, 0.01947700f, 
    0.00198923f, -0.03005322f, -0.00663513f, -0.02213288f, -0.00710747f, -0.04900071f, -0.04688019f, -0.03574253f, 
    0.02380768f, 0.01878488f, -0.05856517f, -0.00474182f, 0.00269258f, 0.00152738f, 0.00503110f, -0.01522122f, 
    -0.03325363f, -0.03400383f, 0.02876416f, 0.03528909f, -0.04847432f, -0.00701092f, 0.01068345f, 0.04106290f, 
    0.01908607f, -0.02432300f, 0.03834401f, -0.01207925f, -0.03533996f, -0.00101988f, -0.02683185f, -0.00126328f, 
    -0.05184229f, -0.05668836f, -0.01394235f, 0.03727623f, -0.00071778f, 0.03188506f, 0.03461973f, 0.02646829f, 
    -0.01646564f, -0.05454656f, 0.04077336f, 0.02371133f, 0.01306964f, -0.01711566f, -0.04130226f, 0.00434026f, 
    -0.05748598f, -0.00319977f, -0.04096246f, 0.00103252f, 0.02915583f, -0.00117711f, 0.00785856f, -0.04806957f, 
    -0.04329617f, -0.02323583f, 0.00671681f, -0.00580444f, 0.02075121f, -0.02067606f, 0.00482197f, 0.00073844f, 
    -0.03454794f, 0.03621080f, 0.00792377f, 0.03200500f, -0.03473879f, 0.01618278f, -0.01769359f, 0.01231972f, 
    0.01991433f, 0.01634363f, -0.03676008f, 0.01222371f, -0.01082916f, 0.03481257f, -0.03237651f, 0.02438427f, 
    -0.01594137f, -0.03748325f, 0.02114512f, 0.02374684f, 0.03682107f, -0.02216331f, -0.01509846f, -0.02166210f, 
    0.02557617f, 0.03381209f, -0.01030767f, -0.02793366f, -0.02956623f, -0.00933591f, 0.02736825f, 0.03289719f, 
    0.00692614f, -0.03495823f, 0.02563413f, 0.02194805f, 0.01071682f, 0.01666013f, 0.00481459f, -0.04917707f, 
    0.03654773f, -0.05450528f, -0.03935246f, 0.02237493f, 0.00878333f, -0.04378951f, -0.02958019f, -0.00122894f, 
    0.02465934f, 0.02749675f, 0.04094706f, -0.05004612f, 0.00308331f, 0.02198216f, 0.00038806f, -0.04338976f, 
    0.04831619f, -0.05349562f, -0.04212562f, 0.00872399f, -0.03619308f, -0.01972175f, 0.01057077f, -0.01357972f, 
    -0.05800260f, 0.00269447f, -0.05092645f, 0.00763507f, -0.01679804f, -0.00510368f, 0.01749400f, -0.03091163f, 
    -0.04817842f, 0.03138847f, 0.01892398f, 0.01901240f, -0.05449558f, 0.02692922f, 0.03953731f, 0.02501057f, 
    -0.02227303f, -0.00932944f, 0.04268540f, 0.00149351f, -0.00434220f, -0.01582933f, -0.03326096f, 0.04460779f, 
    0.04903998f, -0.04589350f, 0.01866161f, 0.04348138f, 0.00762549f, -0.01123781f, -0.02517121f, -0.02387941f, 
    -0.00399697f, 0.00359365f, -0.01897845f, -0.01608861f, 0.04122435f, -0.04498401f, -0.05900501f, 0.02669955f, 
    0.04178952f, 0.02481423f, -0.03026682f, 0.02963333f, 0.01135618f, 0.01122294f, 0.02188057f, 0.01202070f, 
    -0.04852587f, 0.02000475f, 0.03923085f, 0.01353339f, 0.00684886f, 0.02709262f, -0.03461111f, -0.01985853f, 
    -0.04653505f, -0.03666872f, -0.05156539f, -0.00088532f, -0.02341906f, 0.02023069f, -0.01806017f, 0.03602210f, 
    -0.01768105f, 0.02352578f, -0.01027319f, 0.03788218f, 0.02282965f, -0.04523493f, 0.03091989f, -0.05019952f, 
    0.03406795f, -0.04983715f, -0.03180988f, -0.01662633f, 0.01393843f, 0.00298009f, -0.03054210f, 0.01471853f, 
    -0.00875054f, -0.00612406f, -0.03018516f, 0.01625385f, 0.02373593f, 0.02017935f, 0.02954803f, 0.04428057f, 
    -0.03610865f, -0.05018051f, -0.03106503f, -0.02761403f, 0.01556800f, 0.00415146f, 0.02584862f, -0.05507919f, 
    0.23521294f, 0.13482521f, -0.06123360f, 0.07500887f, 0.02920449f, 0.02635258f, 0.12078301f, -0.09436474f, 
    -0.03775194f, 0.10403045f, -0.01860010f, -0.04126484f, 0.12040137f, 0.03943830f, 0.16251910f, 0.00934055f, 
    -0.04340235f, 0.03992045f, -0.02278582f, 0.14111573f, 0.06490270f, 0.06152452f, 0.05241624f, 0.01145677f, 
    -0.07844741f, 0.12082665f, -0.02784836f, 0.00916749f, 0.07622372f, 0.08256667f, 0.06525952f, 0.00647404f, 
    -0.02576912f, 0.05985988f, 0.06856903f, -0.00973484f, 0.09713517f, 0.19377163f, 0.02659453f, -0.14490549f, 
    -0.13937677f, -0.01778184f, 0.00883747f, 0.08877855f, -0.02380417f, 0.08876258f, -0.01184647f, 0.03648568f, 
    -0.00799942f, -0.02505211f, 0.12173901f, 0.01357228f, 0.08390711f, 0.04974474f, -0.03293851f, 0.00807126f, 
    -0.03666618f, 0.06420518f, -0.08179832f, -0.07639203f, 0.15874581f, 0.04794577f, 0.20028311f, -0.13475446f, 
    0.18766397f, -0.00011047f, -0.02954149f, -0.09198459f, -0.01408829f, 0.05756348f, 0.04519293f, 0.01404164f, 
    -0.24814829f, -0.15462695f, 0.06856475f, -0.07046033f, 0.03460002f, 0.12364190f, 0.02217330f, 0.06047736f, 
    0.09768181f, -0.02583080f, -0.02217078f, -0.03016458f, -0.23088612f, 0.05576233f, 0.01940611f, -0.09614634f, 
    0.08930369f, -0.05798672f, -0.09733924f, -0.02557831f, 0.03130686f, -0.04354995f, 0.09420135f, 0.05809999f, 
    -0.03129894f, 0.06444308f, 0.16812271f, -0.06761184f, -0.03072244f, 0.04570800f, 0.01616563f, 0.04114106f, 
    0.03757985f, -0.01005515f, -0.07072462f, 0.00123330f, -0.17587474f, 0.09557832f, 0.01072544f, -0.24243537f, 
    0.07692027f, 0.06991455f, 0.02979878f, 0.08421558f, 0.08649094f, -0.05276244f, 0.00300213f, -0.01237555f, 
    0.08902772f, -0.01019598f, 0.05399583f, 0.07136572f, -0.00892936f, 0.09596361f, 0.13452843f, 0.09932181f, 
    0.01071374f, 0.05905816f, 0.07170147f, -0.16670594f, 0.13679436f, 0.08063193f, 0.14196679f, -0.07879718f, 
    -0.07818004f, 0.11635475f, 0.01191006f, 0.00754782f, 0.00919804f, 0.06740574f, 0.02778067f, -0.08477914f, 
    -0.05656814f, 0.09420811f, -0.02756840f, 0.05519208f, -0.12085249f, 0.00559022f, 0.07258775f, -0.01316242f, 
    -0.00319365f, 0.03598011f, -0.07339121f, 0.07479168f, -0.15533935f, 0.08586832f, 0.11704504f, 0.12019179f, 
    -0.11691573f, 0.00980570f, -0.00356132f, 0.04444326f, 0.01298990f, -0.10701727f, 0.12296933f, 0.07499322f, 
    -0.52158129f, 0.02337634f, 0.15826094f, 0.07610065f, 0.01602725f, -0.08751054f, -0.02043431f, -0.00788653f, 
    -0.03351300f, -0.11339264f, 0.11767736f, 0.15778264f, 0.25167134f, 0.07280768f, 0.03788877f, 0.01528291f, 
    0.11285305f, -0.00562469f, 0.07231933f, -0.08312978f, 0.15126608f, 0.14933532f, -0.09552054f, 0.06002288f, 
    0.17435633f, -0.11901264f, 0.09370506f, 0.13914007f, 0.00756241f, 0.03651263f, -0.04380302f, -0.08720370f, 
    0.04551336f, 0.00082123f, -0.03480529f, -0.19597547f, -0.48532626f, -0.06696383f, -0.05763506f, -0.01317000f, 
    0.02350297f, 0.09972619f, -0.02673037f, -0.01755792f, 0.12903897f, -0.01895715f, -0.01567990f, 0.00137153f, 
    -0.08346778f, 0.04670982f, 0.22295341f, 0.14948176f, -0.00245723f, 0.03922161f, 0.04992267f, -0.03477721f, 
    0.01522544f, -0.15519468f, -0.05298165f, -0.11304757f, -0.09250425f, 0.18822104f, 0.09742886f, 0.19734494f, 
    0.07617816f, -0.03809957f, -0.01757809f, -0.09937377f, 0.02168266f, -0.06450374f, 0.01422915f, -0.07048244f, 
    -0.23203808f, 0.03593651f, -0.00520173f, -0.02051781f, 0.00321370f, 0.12378109f, 0.00747328f, 0.06104607f, 
    -0.13011032f, 0.11708528f, 0.05057836f, 0.05878881f, 0.03615015f, 0.08167467f, 0.04905622f, 0.01679629f, 
    -0.07649490f, 0.02872557f, -0.18004985f, -0.08418074f, -0.11511187f, 0.13773538f, -0.05473736f, -0.03958596f, 
    0.21792188f, 0.11466987f, 0.06546468f, 0.05922050f, -0.09951582f, -0.15038222f, -0.05423116f, 0.09270933f, 
    0.02788772f, -0.07171137f, 0.00747859f, 0.03161170f, 0.03012490f, 0.10328586f, 0.08271631f, 0.01889393f, 
    0.00872338f, -0.11225069f, 0.00850904f, -0.01614858f, -0.00973819f, 0.06141229f, -0.04384422f, 0.03348266f, 
    -0.05093276f, 0.11457525f, 0.11867683f, 0.11708159f, -0.03714240f, -0.10014838f, 0.05656948f, 0.04712726f, 
    0.01528028f, -0.01870944f, -0.13885044f, 0.00251317f, 0.09878577f, -0.05176313f, -0.17241268f, 0.12180209f, 
    0.12339626f, 0.09083854f, 0.04883672f, -0.08252981f, 0.04686460f, 0.01021052f, -0.09999410f, 0.12763296f, 
    -0.25590831f, -0.00517667f, 0.04009023f, 0.04527733f, 0.12485740f, -0.00787877f, 0.05029251f, 0.03074819f, 
    0.03731947f, 0.15046902f, -0.05099492f, 0.06002301f, 0.11130863f, 0.08411703f, 0.06731462f, 0.12907051f, 
    -0.01937670f, 0.03052757f, 0.05839705f, 0.00821668f, -0.07126018f, -0.07465810f, 0.09233965f, 0.10845540f, 
    0.15700340f, -0.10750163f, -0.20443249f, -0.17384167f, 0.22579914f, 0.09501032f, 0.09154904f, -0.12375151f, 
    0.00699399f, 0.11011910f, 0.08557398f, 0.01616137f, -0.04531005f, -0.11621699f, -0.11107016f, 0.23342553f, 
    -0.05961768f, 0.05786617f, -0.02153593f, -0.01234922f, -0.04770145f, -0.07154556f, -0.01704966f, -0.04174557f, 
    0.00317741f, 0.15153635f, 0.05153062f, -0.04603570f, -0.07473858f, 0.05523728f, 0.12347706f, -0.03451818f, 
    0.05562805f, -0.01381545f, 0.03565698f, 0.04175941f, -0.15638979f, 0.00689579f, -0.06814805f, 0.03645627f, 
    0.05093762f, -0.03155482f, -0.02501796f, 0.10052870f, 0.02976253f, -0.13415155f, -0.06592727f, 0.11478426f, 
    -0.11499250f, 0.28886780f, -0.00543722f, -0.09038351f, 0.11307511f, 0.09081272f, 0.01167793f, -0.04417154f, 
    -0.05489755f, 0.05026354f, 0.04911518f, -0.00419758f, 0.19855148f, 0.11245470f, 0.13822542f, -0.03856429f, 
    0.08916417f, 0.15335511f, -0.14787956f, -0.12367436f, -0.03995088f, 0.08408578f, -0.03537420f, -0.12648839f, 
    0.09258755f, -0.07220986f, -0.06962378f, -0.40497580f, -0.00171677f, 0.10542773f, 0.00923226f, -0.01667927f, 
    0.07724081f, -0.10357073f, -0.07138075f, 0.09789893f, 0.09530152f, -0.03712973f, -0.12491964f, 0.12368944f, 
    -0.08330309f, -0.11823501f, 0.03392299f, 0.03568402f, 0.07066579f, 0.04690759f, -0.16665047f, -0.02710572f, 
    0.03105355f, 0.06720098f, 0.04953539f, 0.13294998f, -0.01946424f, -0.07053813f, -0.09923732f, -0.06755967f, 
    -0.03838004f, 0.16627246f, -0.19956623f, -0.01963597f, -0.22834961f, 0.15756269f, 0.18676439f, 0.07699651f, 
    0.15259397f, -0.06637695f, 0.11181297f, -0.09716716f, 0.01181504f, -0.01377976f, 0.18861336f, 0.10780068f, 
    -0.16482185f, 0.00658497f, 0.10162578f, -0.19901031f, 0.01425559f, 0.04503400f, 0.12013432f, -0.13107800f, 
    -0.07059378f, -0.21170078f, 0.04546963f, -0.18352219f, -0.02688241f, -0.05768891f, -0.20294952f, -0.15618609f, 
    -0.03594699f, 0.22430196f, -0.10808098f, 0.00136192f, -0.10181083f, 0.14174548f, 0.15670027f, 0.01474600f, 
    0.12168134f, 0.23708995f, -0.07863759f, 0.09369856f, -0.03106015f, 0.08445147f, -0.04084551f, -0.02002642f, 
    0.02395454f, 0.14356366f, -0.06929254f, 0.11070386f, -0.04242814f, 0.04103004f, 0.08508855f, 0.00963938f, 
    0.04243539f, 0.03048596f, -0.05362036f, 0.10968889f, 0.07815447f, 0.02193232f, 0.15523241f, -0.06107499f, 
    -0.13251209f, 0.15323125f, 0.15140699f, 0.01204954f, 0.09627435f, 0.15478849f, -0.06269631f, 0.17322721f, 
    -0.03182370f, 0.02542850f, 0.08798201f, -0.11956699f, 0.17081548f, 0.12107021f, -0.00229806f, -0.07420979f, 
    -0.02211789f, 0.06191622f, 0.01054845f, -0.09848513f, 0.01990497f, -0.04496871f, 0.00468390f, -0.18431573f, 
    0.06582913f, -0.08856921f, -0.06500206f, 0.08246727f, -0.12334632f, 0.02019915f, 0.15085228f, -0.08261586f, 
    0.15304434f, 0.05908502f, -0.09033314f, 0.03708781f, 0.21847920f, 0.03063746f, 0.11179980f, -0.04567519f, 
    -0.09440680f, 0.09058616f, -0.09739196f, 0.15086381f, 0.04872634f, -0.09541300f, 0.02354263f, -0.14594586f, 
    -0.06698065f, -0.03932882f, -0.07273368f, 0.08372474f, 0.04257588f, -0.01934540f, -0.19181432f, -0.09133466f, 
    0.04841963f, 0.05050837f, -0.08991663f, 0.18576702f, 0.14792982f, 0.26028556f, -0.02947995f, 0.23359609f, 
    0.01630481f, 0.15314563f, 0.07630679f, 0.02720893f, 0.14687794f, 0.18640858f, 0.01504434f, -0.10448930f, 
    0.07169852f, 0.11682732f, -0.03215020f, 0.24042320f, -0.03571768f, 0.03334022f, -0.10809857f, -0.06164400f, 
    -0.06302894f, -0.01318612f, -0.08586005f, -0.09970544f, 0.08539055f, 0.18947704f, 0.15538590f, 0.02987713f, 
    -0.04835157f, 0.06620841f, -0.04221979f, -0.05072850f, 0.08891085f, -0.08429710f, 0.06405710f, -0.00042249f, 
    -0.01921982f, 0.10595370f, 0.00928861f, 0.12844802f, -0.09124836f, -0.01949931f, -0.13612698f, 0.08379905f, 
    0.01654151f, -0.08391821f, 0.04610851f, 0.00103462f, -0.08355879f, 0.07876502f, -0.08169108f, 0.01445730f, 
    0.00202490f, 0.07047405f, 0.04368872f, -0.03549060f, -0.08294130f, -0.24716713f, -0.18402904f, -0.11281218f, 
    0.07826626f, -0.04722972f, 0.04219790f, -0.00704994f, 0.07205262f, 0.07375462f, 0.05139066f, 0.12771438f, 
    -0.14847185f, 0.16632235f, 0.06057610f, 0.01165330f, 0.07726847f, 0.09052934f, -0.08116665f, 0.16831288f, 
    -0.11381640f, -0.10847301f, -0.17144173f, -0.01156874f, -0.02952839f, 0.18696211f, -0.08624384f, -0.11436274f, 
    0.10339324f, -0.05558954f, -0.21774143f, 0.04424772f, -0.03743098f, -0.18135688f, -0.09420779f, -0.01223055f, 
    -0.16446041f, -0.09419882f, -0.02935351f, -0.05637346f, 0.20641650f, 0.09368441f, -0.12606348f, 0.12932555f, 
    -0.00687886f, -0.03828818f, -0.07769295f, 0.05902683f, -0.15065463f, 0.08800284f, -0.14449142f, 0.00593522f, 
    0.02219592f, 0.01670275f, 0.25572461f, 0.26746812f, -0.12311134f, -0.11823255f, 0.04535916f, -0.08884671f, 
    -0.03317912f, 0.00885433f, -0.02884888f, 0.08763099f, 0.14470094f, -0.01872158f, 0.09912889f, -0.24939567f, 
    -0.02964390f, 0.02825105f, 0.11458873f, -0.09011591f, -0.05372652f, -0.08624999f, -0.02661995f, 0.17736022f, 
    -0.14408036f, -0.15165767f, 0.02017802f, -0.05552480f, 0.02505454f, -0.03940599f, 0.08876892f, 0.00231076f, 
    0.11668976f, 0.09198239f, -0.19605434f, -0.29826328f, 0.33471367f, 0.06139082f, -0.01919894f, 0.03617937f, 
    0.04271335f, 0.06539781f, -0.11794608f, 0.00901686f, -0.05975488f, -0.03073842f, -0.14518081f, 0.11219978f, 
    0.22196339f, 0.01613010f, -0.15293801f, -0.32473958f, 0.01135341f, -0.00638760f, 0.15935563f, -0.08214270f, 
    -0.05998702f, 0.07893576f, 0.10557843f, 0.06591592f, -0.11109314f, -0.01324958f, -0.00809652f, 0.04365510f, 
    -0.01028561f, -0.02782447f, -0.09842546f, 0.20567077f, 0.00790624f, -0.09771363f, -0.07791103f, -0.00122707f, 
    -0.01285740f, 0.06097025f, -0.01482463f, 0.05270941f, 0.05499849f, 0.00083308f, 0.13572991f, 0.00695399f, 
    -0.02888525f, 0.18001850f, 0.06058846f, 0.14506985f, -0.06972720f, -0.17649554f, -0.09442019f, -0.02265563f, 
    -0.04733230f, 0.01968288f, 0.05549820f, -0.05145554f, 0.17845990f, 0.05473801f, 0.05225498f, 0.19895402f, 
    0.01594046f, 0.02815853f, -0.00488029f, -0.03399558f, -0.00500594f, -0.00969987f, -0.02630041f, -0.01902452f, 
    -0.05694825f, 0.00680362f, -0.02923181f, -0.01826155f, 0.03678810f, -0.04298741f, -0.05453373f, 0.01200459f, 
    -0.05395285f, -0.05121408f, -0.01859965f, -0.02466909f, 0.04026711f, -0.05408240f, -0.05441074f, 0.00661263f, 
    -0.01922715f, -0.05410690f, -0.05039541f, -0.04745774f, -0.02242371f, -0.04033726f, 0.00820329f, 0.02276473f, 
    -0.02496701f, -0.01421524f, 0.03826824f, 0.02701540f, 0.00092790f, -0.00930604f, -0.04500466f, -0.04455633f, 
    -0.04733555f, 0.01634268f, 0.03707356f, -0.01789042f, -0.03101856f, -0.03785351f, -0.00005838f, -0.00634083f, 
    -0.04993266f, 0.04327789f, 0.00388980f, 0.01745991f, 0.03225990f, -0.02260573f, -0.04769704f, -0.00831252f, 
    -0.04370997f, 0.04369234f, 0.04141745f, 0.04363107f, -0.01770602f, 0.02141084f, -0.01140615f, -0.02809057f, 
    -0.04908276f, 0.03756842f, -0.03495393f, -0.04154211f, -0.01452267f, -0.02209080f, 0.01815048f, -0.02509084f, 
    0.01100834f, -0.01045191f, 0.00980357f, 0.00199839f, 0.02108986f, -0.05005557f, 0.02993355f, -0.03318953f, 
    -0.00822586f, 0.04336084f, 0.04433070f, 0.02136437f, 0.01902380f, 0.03408593f, -0.05583676f, -0.03879324f, 
    -0.01984620f, 0.00182122f, -0.01069221f, -0.05172265f, -0.04622152f, 0.00879275f, -0.03253807f, -0.00867833f, 
    -0.00571038f, -0.03073106f, 0.01515271f, 0.00812566f, -0.01054727f, -0.05306398f, 0.00029469f, -0.01635348f, 
    -0.00431818f, -0.04688132f, 0.03394296f, -0.02310686f, -0.00396895f, -0.01709140f, 0.02001628f, -0.05373423f, 
    0.02026106f, 0.00283264f, 0.01941345f, 0.01300375f, -0.04895876f, 0.00693915f, -0.00720168f, -0.04082360f, 
    0.02843169f, -0.02924547f, -0.00065267f, -0.03940212f, 0.02963353f, 0.03167086f, -0.03356857f, 0.01937421f, 
    -0.05064433f, -0.05498063f, -0.03997033f, 0.03735079f, -0.04285217f, 0.02092992f, 0.01459874f, 0.01242995f, 
    -0.01589387f, -0.02700800f, 0.00753986f, -0.01310470f, -0.03534516f, 0.04067260f, -0.01479168f, 0.01357388f, 
    -0.01826911f, -0.02979208f, -0.05198250f, -0.03670371f, -0.01842324f, -0.05610259f, -0.05610650f, -0.03057766f, 
    0.00323252f, 0.03726004f, 0.02985819f, -0.01662722f, 0.01092187f, 0.01553293f, -0.00562049f, -0.00150057f, 
    0.00726457f, -0.04966300f, -0.00930661f, 0.03218844f, -0.02066455f, 0.02610744f, -0.01225569f, 0.03183325f, 
    0.02114765f, -0.02457315f, -0.04100905f, 0.02945330f, 0.00968606f, 0.00991029f, -0.03087626f, -0.04041071f, 
    -0.02903707f, 0.03726513f, 0.03169373f, -0.00115709f, -0.03801650f, -0.03445817f, 0.00182851f, 0.01729534f, 
    0.00464032f, -0.02914401f, 0.00906007f, -0.05295047f, 0.00354424f, -0.02046949f, -0.02708411f, 0.04306225f, 
    -0.02437051f, 0.02962637f, -0.04578521f, -0.04454982f, 0.02413094f, -0.05198883f, 0.04220641f, -0.03540605f, 
    -0.00195438f, -0.03234402f, -0.05117014f, 0.03147923f, -0.05389423f, -0.04007201f, -0.02869137f, -0.04426936f, 
    -0.01468342f, 0.02107259f, -0.04727676f, -0.04157361f, -0.04444249f, -0.02504628f, 0.00286054f, -0.03091105f, 
    0.04490337f, 0.02799176f, 0.01033664f, 0.03008519f, -0.03754641f, -0.01154813f, -0.03856436f, 0.04453263f, 
    -0.00910467f, -0.05562803f, -0.04798218f, -0.05692043f, 0.02904062f, 0.00935581f, 0.03262727f, -0.04924241f, 
    0.01129527f, -0.01165593f, -0.04227704f, 0.00394996f, -0.01579494f, -0.03422879f, -0.02856331f, -0.04112843f, 
    -0.01353688f, -0.02525079f, -0.02772996f, 0.00211880f, 0.02981550f, -0.05669610f, -0.04198984f, -0.01329710f, 
    0.04012232f, 0.00802296f, -0.02808802f, -0.02609079f, -0.00642985f, -0.05462179f, 0.04434375f, 0.03651083f, 
    0.02229386f, -0.00626411f, -0.02134458f, -0.01818564f, 0.04307821f, -0.01314536f, 0.03501255f, 0.03779704f, 
    0.03290743f, -0.03908560f, 0.01354079f, 0.03646025f, -0.04912554f, -0.00618479f, -0.00934589f, 0.03749023f, 
    0.03380756f, -0.04559264f, -0.05059979f, 0.01329182f, 0.00947792f, -0.02202847f, -0.00483965f, -0.01937307f, 
    0.04182934f, -0.05482333f, 0.00994386f, 0.03292057f, 0.04222769f, -0.05204282f, 0.01670847f, 0.01537265f, 
    -0.04174678f, -0.04865928f, -0.05076257f, 0.02669520f, -0.01967228f, -0.02218207f, 0.01649168f, -0.00792632f, 
    -0.00423400f, 0.02976970f, 0.02779216f, 0.00650940f, -0.05656093f, 0.00388650f, 0.00983284f, -0.02789499f, 
    -0.03967397f, -0.01027003f, 0.01437126f, -0.02362481f, 0.01159618f, -0.04344726f, 0.02194091f, -0.00603861f, 
    0.01574090f, 0.04853105f, -0.03998462f, 0.02213984f, -0.02737616f, 0.04426707f, 0.04221968f, 0.00279105f, 
    -0.01342050f, -0.04136125f, 0.03542270f, -0.04110971f, 0.03998111f, 0.01721724f, 0.01329021f, -0.02200832f, 
    -0.05534425f, -0.00083547f, 0.03513195f, 0.04345261f, 0.02498013f, -0.00470269f, -0.01942156f, 0.02823012f, 
    -0.02813538f, -0.02033307f, 0.01549459f, -0.04595433f, -0.03168270f, -0.05550098f, 0.02351347f, -0.04194134f, 
    -0.00398284f, -0.02562465f, -0.04338390f, 0.01506447f, -0.04965625f, -0.05236661f, -0.03325143f, 0.00512992f, 
    0.03399221f, 0.00420256f, -0.03195485f, -0.00515081f, 0.02726622f, -0.04944246f, -0.02076138f, 0.00108932f, 
    -0.04003719f, -0.02127261f, 0.00841175f, 0.03638313f, -0.04856921f, -0.03198259f, 0.02866171f, -0.00816074f, 
    -0.00144295f, 0.00200495f, 0.02444869f, 0.02839853f, -0.02113002f, -0.02141428f, -0.04314026f, -0.02533219f, 
    0.01102622f, 0.02812370f, -0.02909402f, 0.01061998f, -0.04423864f, -0.02664773f, 0.04488650f, -0.02160507f, 
    0.01584892f, -0.13139130f, 0.20677915f, 0.04222764f, -0.02326556f, 0.06732629f, -0.11539333f, 0.14358865f, 
    -0.02394974f, 0.08072879f, 0.07371921f, 0.00044032f, -0.45589381f, 0.07941759f, -0.02344374f, -0.28625128f, 
    0.00803372f, -0.04449369f, -0.02019558f, -0.00588419f, 0.03861733f, 0.02848572f, 0.05141892f, 0.06541192f, 
    -0.09250450f, 0.00307223f, -0.06459846f, -0.19301423f, 0.03863410f, 0.11524391f, -0.08326818f, -0.07282656f, 
    -0.03464624f, -0.01723292f, -0.04201767f, 0.10367616f, -0.42203769f, 0.02928476f, 0.09095748f, -0.22545427f, 
    -0.03535258f, 0.01220237f, -0.03925884f, 0.01735310f, 0.00380462f, 0.08144926f, 0.08025218f, -0.02350740f, 
    -0.04787166f, 0.14370842f, 0.09914073f, 0.20002811f, 0.03503887f, 0.00975496f, 0.02823635f, 0.01673086f, 
    -0.05394858f, 0.25275198f, 0.04003433f, -0.04206989f, 0.24650571f, -0.00468561f, -0.04799597f, 0.31901303f, 
    -0.01676189f, 0.01910806f, 0.13859300f, 0.03178132f, 0.04952378f, -0.06490629f, -0.03128197f, -0.06191398f, 
    0.11633518f, 0.01146467f, -0.01075990f, 0.01854864f, 0.01221955f, -0.00881625f, 0.01447129f, 0.02150783f, 
    -0.11544283f, 0.07221055f, 0.10630423f, -0.02717219f, 0.10261051f, -0.07815913f, -0.07951028f, -0.04993360f, 
    0.03425421f, 0.13763733f, 0.04428038f, -0.16032881f, 0.19012737f, -0.08581903f, 0.05850003f, 0.05516618f, 
    -0.27285895f, -0.01494096f, 0.04614859f, -0.02585269f, 0.09439722f, -0.01197367f, -0.04971241f, -0.08529429f, 
    0.01097852f, 0.01292406f, 0.09007151f, -0.00097091f, 0.11063841f, 0.06817462f, 0.05146725f, 0.22625518f, 
    0.09149940f, 0.05870958f, 0.14420289f, 0.02565303f, -0.02814053f, 0.03574023f, -0.13059677f, -0.03557536f, 
    0.15139270f, 0.10837968f, 0.16141495f, 0.10146923f, 0.26720032f, 0.00763919f, -0.08328518f, 0.10925490f, 
    0.06457517f, -0.08608308f, 0.04369836f, 0.05407486f, -0.11828989f, -0.05635704f, -0.01779388f, -0.10325629f, 
    -0.07652447f, 0.08088371f, -0.01868406f, -0.02268961f, 0.01376175f, -0.00931718f, 0.01827438f, 0.11451683f, 
    -0.32992455f, 0.24503270f, -0.04484314f, 0.03051394f, -0.04325225f, 0.01369441f, -0.03948754f, -0.03653322f, 
    -0.09212270f, -0.03180515f, -0.05424510f, 0.00474326f, -0.26150113f, 0.12362561f, -0.01400944f, -0.35143855f, 
    0.02840580f, -0.02578451f, -0.00339893f, 0.07601529f, -0.02845446f, 0.01915506f, 0.01680993f, 0.03553613f, 
    0.00498358f, -0.14972091f, 0.00703086f, 0.02564110f, -0.03924020f, 0.05759682f, 0.05667808f, 0.03295541f, 
    0.04694320f, 0.08018792f, -0.12676369f, 0.00840575f, -0.15365513f, 0.13555443f, 0.06416108f, 0.11109225f, 
    0.13521101f, 0.01155309f, -0.00022794f, 0.10367433f, -0.05165751f, -0.06630617f, 0.00569755f, -0.10934128f, 
    -0.14868587f, -0.11199439f, 0.30959734f, 0.04589586f, 0.09973601f, 0.03024484f, 0.05938918f, 0.02756771f, 
    0.01008151f, 0.08481565f, 0.05874312f, 0.08031478f, 0.13980356f, 0.14906032f, -0.11585154f, 0.04455861f, 
    0.02148356f, 0.07141454f, -0.05107278f, 0.10580219f, -0.02017319f, 0.01767399f, -0.07836232f, 0.09638318f, 
    0.03361652f, -0.31647259f, 0.21405239f, -0.05968934f, -0.05718140f, 0.12063562f, -0.05464152f, 0.05185479f, 
    0.05270177f, 0.03386713f, -0.03625877f, 0.07947312f, 0.15832457f, -0.00069815f, -0.01737648f, 0.00743104f, 
    0.07142872f, -0.02314205f, -0.07781845f, 0.01895601f, -0.01050058f, 0.08089183f, -0.02535197f, 0.08582237f, 
    0.42067361f, 0.24520992f, 0.05336928f, 0.10687714f, 0.18171537f, 0.05109475f, 0.02239678f, -0.03551716f, 
    -0.03742889f, 0.03815747f, 0.09113602f, -0.04322827f, -0.36811724f, 0.06394529f, 0.02112816f, -0.16970305f, 
    -0.02071115f, 0.10385460f, 0.03086636f, -0.02940820f, 0.11111408f, 0.00876513f, 0.05517362f, 0.13441981f, 
    -0.40390882f, 0.07442825f, -0.02202318f, -0.09502973f, 0.04010071f, -0.05249418f, -0.04191671f, -0.01258349f, 
    -0.09097667f, -0.00536208f, -0.02863644f, 0.13990226f, -0.22638123f, 0.19938882f, -0.02566032f, -0.05697085f, 
    -0.06073324f, 0.00035707f, -0.04658479f, 0.06936289f, 0.00410657f, -0.01082564f, 0.08697250f, 0.00398866f, 
    0.12401239f, -0.27072081f, 0.05040574f, 0.06273039f, 0.12856796f, -0.06681459f, -0.04297496f, -0.11877228f, 
    0.08843455f, -0.05282800f, -0.01707901f, 0.15044916f, 0.12072555f, 0.11284197f, 0.00336277f, 0.02456426f, 
    0.01342083f, 0.05640558f, 0.03346437f, 0.10205650f, 0.06514869f, -0.06315765f, -0.00462858f, 0.01966485f, 
    -0.00992211f, -0.01470719f, -0.05242049f, -0.06837459f, 0.00192886f, 0.02127085f, -0.03253566f, -0.01389272f, 
    0.10429575f, 0.02830869f, 0.07047863f, 0.05885975f, 0.13336034f, 0.15944891f, 0.05347555f, 0.16410516f, 
    0.02321985f, 0.05395861f, 0.06677977f, -0.07021487f, -0.17808613f, 0.00064153f, -0.05311141f, 0.05673473f, 
    0.16935737f, -0.04327707f, 0.01085889f, 0.03000813f, -0.05508524f, 0.00703676f, -0.10319307f, 0.06659210f, 
    0.06955640f, -0.06748320f, -0.02211449f, -0.10384189f, -0.29936370f, 0.04403627f, 0.17465164f, 0.07320411f, 
    -0.01156851f, -0.06215528f, 0.01178697f, -0.04650033f, 0.09020080f, -0.02953386f, 0.01504704f, 0.06186958f, 
    -0.03564864f, 0.19431747f, 0.10375704f, 0.03509689f, -0.04454784f, 0.11391405f, 0.03380761f, 0.04825887f, 
    -0.00444964f, -0.11054928f, 0.04238858f, 0.04110050f, -0.10165773f, -0.04156892f, -0.03733335f, -0.01514737f, 
    0.06234619f, 0.01940400f, -0.04020529f, -0.04910646f, 0.04484180f, -0.07764832f, -0.09920647f, -0.06518333f, 
    0.30935487f, -0.10224821f, 0.03449055f, 0.01414995f, -0.05075374f, 0.02395266f, -0.00226301f, -0.09191645f, 
    -0.03836907f, 0.00342165f, -0.02695066f, -0.00354468f, -0.11445892f, -0.24887770f, -0.25564262f, 0.18857090f, 
    0.05961004f, 0.05925202f, -0.03657482f, -0.18370199f, 0.00008563f, -0.07669395f, -0.04086076f, 0.13441998f, 
    -0.27492636f, 0.08968232f, 0.08508786f, 0.15706302f, -0.01558816f, 0.00349353f, 0.00005423f, 0.13909179f, 
    0.03038175f, -0.00794655f, 0.11344791f, 0.01755833f, -0.12177849f, -0.13314168f, 0.05175531f, 0.14120296f, 
    0.14889520f, 0.07686622f, -0.09105050f, -0.07702059f, -0.07848770f, -0.01236360f, 0.12671578f, 0.04413978f, 
    -0.06509595f, 0.19185962f, 0.21858190f, -0.06009986f, 0.09338044f, 0.14489552f, -0.11735462f, 0.03611688f, 
    0.02673126f, -0.16337545f, 0.00764438f, 0.17727220f, 0.07090548f, -0.02324937f, -0.06238025f, -0.20171587f, 
    -0.07517579f, 0.00473866f, -0.05213592f, 0.06665932f, 0.02651660f, 0.04271242f, 0.10001116f, -0.12552695f, 
    -0.12823208f, 0.14798403f, -0.16492526f, -0.18233974f, 0.02211298f, -0.05335499f, -0.08308054f, 0.03644004f, 
    -0.01391451f, 0.01344133f, 0.06785800f, 0.00809238f, -0.01916523f, 0.01543871f, -0.04586129f, 0.04555831f, 
    -0.04304461f, 0.13971227f, 0.08655833f, 0.20924905f, -0.00543862f, 0.12016302f, -0.14180072f, 0.06778002f, 
    0.11866478f, -0.16026022f, -0.12782751f, -0.08674181f, -0.09798275f, 0.07046327f, 0.07897388f, 0.06105889f, 
    -0.02706495f, 0.03119169f, 0.06714030f, -0.00537344f, -0.07254017f, 0.05743183f, -0.09101599f, 0.01342455f, 
    0.06611727f, 0.05734509f, 0.02267976f, -0.03696125f, -0.04214129f, -0.03634146f, -0.00731835f, 0.02114847f, 
    0.03917470f, 0.05889611f, 0.20068596f, 0.04509657f, 0.13648251f, -0.12639746f, 0.06005694f, 0.07460197f, 
    0.06836054f, 0.01802715f, -0.00958179f, 0.12806746f, 0.26826268f, -0.29256994f, -0.02606811f, 0.03587784f, 
    0.04942997f, -0.15628748f, -0.10139254f, -0.04017253f, 0.13852428f, -0.02801955f, 0.01665929f, 0.06233612f, 
    -0.18053706f, 0.34713218f, -0.13161273f, -0.14651118f, 0.03107753f, -0.08434395f, -0.04719161f, -0.12505810f, 
    -0.02145298f, 0.02007581f, 0.00742815f, -0.09922211f, -0.12395868f, -0.04865586f, 0.08524595f, 0.28408489f, 
    0.05009012f, 0.01657845f, -0.13168685f, -0.11050196f, -0.04832168f, 0.00735351f, -0.02009103f, 0.03512832f, 
    -0.12094874f, 0.11165785f, 0.27369466f, -0.11999016f, 0.02970717f, -0.02864541f, 0.01955366f, 0.05784599f, 
    0.02008172f, 0.10346528f, -0.07511085f, -0.04056923f, -0.03511885f, -0.05052656f, 0.05023417f, -0.09487002f, 
    -0.00213342f, 0.16893843f, 0.02130788f, 0.17485948f, -0.09664482f, -0.02092549f, 0.17051688f, 0.15253036f, 
    -0.17500806f, 0.26515034f, 0.15193601f, -0.02384770f, -0.16808294f, 0.03355147f, 0.04814038f, 0.04829429f, 
    -0.00473760f, -0.14580870f, -0.11162568f, 0.11794478f, -0.18394017f, 0.05382184f, -0.04896337f, -0.28384006f, 
    0.10712788f, 0.03286660f, 0.04482643f, 0.20236062f, -0.13703702f, 0.08503880f, -0.09475311f, -0.02238219f, 
    -0.01129187f, 0.17118479f, 0.18109782f, 0.06425264f, -0.03737102f, 0.05108732f, 0.07444157f, -0.12101236f, 
    0.05048962f, 0.03617834f, 0.14759187f, 0.01062913f, 0.09825820f, 0.06943535f, 0.09723675f, 0.10225866f, 
    -0.15408663f, 0.03743495f, 0.07612684f, 0.06073566f, 0.14423324f, 0.10882889f, -0.02835315f, -0.01839582f, 
    -0.23211119f, 0.14940415f, -0.07987767f, -0.06477536f, 0.06994611f, -0.08389498f, 0.02981139f, -0.01423025f, 
    0.09732982f, -0.01969953f, 0.00908335f, 0.01128606f, 0.04640441f, -0.29511505f, -0.04482901f, -0.12026029f, 
    -0.03492056f, 0.03658782f, 0.19646323f, -0.02780301f, 0.07853017f, -0.20468202f, 0.10725975f, -0.12446930f, 
    -0.02044803f, -0.10535558f, -0.01037641f, 0.17245468f, 0.06136477f, 0.09550235f, -0.05747065f, -0.15280874f, 
    0.15143944f, 0.03963785f, -0.02754958f, 0.05651747f, -0.29911160f, -0.15032671f, 0.14504117f, 0.24469981f, 
    0.06436224f, 0.00027742f, -0.09331424f, -0.05979644f, -0.01200326f, -0.07864244f, 0.06682098f, 0.07560814f, 
    -0.01963545f, 0.25467426f, -0.04780032f, -0.16882508f, -0.08328316f, 0.01432407f, 0.00845669f, 0.07469153f, 
    0.13702279f, 0.04079264f, 0.06525055f, 0.05801406f, 0.00255850f, -0.07001200f, 0.23258471f, 0.29455844f, 
    0.15952902f, 0.02927435f, -0.01780198f, 0.27177247f, 0.00956328f, -0.01340757f, 0.08600533f, -0.03200639f, 
    0.20446850f, -0.05335889f, -0.00297257f, -0.05811267f, -0.07478880f, 0.03711888f, 0.08888015f, -0.06987150f, 
    0.00138685f, 0.00833405f, -0.06295638f, 0.15137665f, 0.20971411f, 0.23343956f, 0.10122484f, 0.06972083f, 
    -0.05359889f, 0.05259191f, 0.06043370f, -0.03116066f, 0.07311880f, -0.07548317f, 0.07690043f, -0.01141856f, 
    -0.09214501f, -0.02041847f, -0.05367153f, 0.33512348f, 0.00923909f, 0.04248785f, -0.05522910f, 0.00697054f, 
    0.02529010f, -0.00323303f, -0.06319109f, -0.03061361f, -0.02447551f, -0.02798186f, 0.14097835f, 0.01340912f, 
    0.07394844f, -0.07368366f, 0.07811438f, -0.03340413f, 0.09157673f, 0.03412734f, 0.05431002f, 0.02900247f, 
    -0.12490217f, 0.08927965f, 0.16566978f, 0.08157434f, -0.06040727f, 0.04741427f, 0.05488835f, 0.09819243f, 
    -0.01242519f, 0.04149083f, -0.00089041f, 0.00521742f, -0.10466737f, 0.02696051f, 0.04652448f, -0.13022807f, 
    0.01810953f, -0.00954685f, 0.05406682f, 0.06093511f, -0.03154474f, -0.02677520f, 0.00914904f, -0.20280881f, 
    0.01466351f, 0.04424350f, -0.03464441f, 0.02539568f, 0.02454772f, -0.04322236f, -0.02754345f, 0.00599854f, 
    -0.02883367f, 0.00506298f, -0.03058904f, 0.00170015f, 0.02473271f, -0.00638731f, 0.02877778f, 0.01621494f, 
    -0.03795702f, 0.03080021f, -0.04357383f, -0.00786928f, 0.02360641f, 0.01107219f, -0.05192339f, 0.01727388f, 
    -0.00975216f, 0.01988424f, -0.04441731f, 0.02153756f, 0.00064654f, -0.04710336f, -0.00312771f, 0.03525497f, 
    0.00044245f, 0.02713546f, -0.00494878f, -0.03540649f, 0.00114971f, -0.03119935f, -0.00718866f, -0.01747533f, 
    -0.02380214f, 0.04429010f, 0.04420664f, 0.01028953f, -0.05258769f, -0.02993589f, -0.03751346f, 0.01317200f, 
    0.04904951f, -0.03360212f, -0.00569809f, -0.01845187f, -0.00796141f, 0.02373155f, 0.02425161f, -0.05569111f, 
    -0.01576006f, 0.02454263f, 0.00331742f, -0.01468260f, -0.02606675f, 0.00058316f, -0.00596009f, 0.01867398f, 
    -0.00425876f, 0.00432489f, -0.02193270f, 0.03307994f, -0.02578989f, 0.01464571f, 0.03801857f, 0.04116813f, 
    0.01004690f, 0.02408911f, -0.03106864f, -0.05108726f, 0.00355344f, -0.02767661f, 0.00545130f, 0.03977422f, 
    -0.00998158f, 0.03494858f, -0.02897028f, -0.00310297f, 0.03840078f, -0.00899431f, -0.04500072f, -0.03438195f, 
    0.05195223f, -0.05860668f, -0.01016420f, -0.02967243f, -0.00673054f, -0.04882573f, 0.01842313f, 0.00390737f, 
    -0.02615808f, 0.02372903f, -0.02719706f, -0.01267874f, -0.05566801f, 0.01021523f, -0.03362127f, 0.01702686f, 
    -0.05195404f, -0.04174805f, 0.04130282f, -0.02388165f, -0.00653281f, 0.02264405f, 0.03820678f, -0.02166849f, 
    -0.00140221f, -0.03309288f, -0.01199832f, -0.02853528f, 0.04788399f, 0.02418947f, -0.00564962f, 0.02440457f, 
    -0.04552896f, 0.04327520f, -0.03028469f, 0.02557371f, 0.00727081f, -0.01627408f, -0.03788741f, -0.05353332f, 
    -0.04048687f, -0.00122425f, -0.00207374f, -0.05384353f, -0.02354512f, -0.01716690f, 0.00401166f, 0.03164693f, 
    0.00264631f, 0.04116224f, 0.02669433f, -0.04825298f, -0.02060289f, -0.02656739f, 0.01448604f, -0.01615027f, 
    -0.00461589f, 0.02346998f, -0.05828592f, -0.02705646f, 0.00676027f, 0.02712445f, -0.00409836f, 0.02345442f, 
    -0.01185808f, -0.06084300f, 0.03206157f, -0.04968188f, 0.01042392f, 0.02694631f, -0.04800441f, -0.03565074f, 
    0.00726438f, 0.02142190f, -0.05295645f, 0.02945145f, -0.01452103f, 0.00530808f, 0.02553979f, -0.04839052f, 
    -0.04098604f, 0.01305455f, 0.00591187f, 0.01855306f, 0.04095462f, -0.05496439f, -0.01662841f, -0.00107114f, 
    -0.03252861f, -0.05937944f, -0.05237275f, -0.04106183f, 0.02976931f, 0.02593680f, 0.03332498f, -0.05897018f, 
    -0.01222749f, 0.03041905f, 0.02452700f, -0.02128787f, -0.04587169f, 0.03382050f, -0.01197737f, -0.05921405f, 
    -0.00244409f, -0.05007817f, 0.01048280f, -0.02103071f, 0.02953609f, 0.04185488f, -0.05932998f, 0.01323391f, 
    0.00676044f, -0.03394471f, -0.02936286f, 0.01576748f, 0.04437709f, 0.04197150f, 0.00869435f, 0.01973740f, 
    -0.01003699f, 0.02246015f, -0.00707176f, 0.00635891f, -0.05305623f, 0.03943414f, -0.02844748f, -0.02767495f, 
    -0.01413194f, -0.02930399f, 0.04005167f, 0.01132193f, -0.04315529f, 0.01126522f, -0.01827584f, -0.04451471f, 
    -0.03095137f, -0.04027260f, 0.03291102f, -0.05235978f, 0.00477446f, -0.02200953f, 0.00876736f, 0.02207263f, 
    0.03665846f, 0.02684632f, 0.01445867f, -0.00259220f, 0.01567872f, 0.02873453f, 0.01259549f, -0.03549100f, 
    -0.05049134f, -0.00412569f, -0.00647489f, -0.04803748f, 0.03638618f, -0.01972600f, -0.05430336f, -0.03484243f, 
    -0.01089235f, 0.02592916f, 0.00092968f, -0.01700300f, -0.02663618f, -0.04547041f, 0.01894886f, 0.04112830f, 
    0.01572748f, -0.00855393f, 0.01592868f, 0.03488437f, -0.04024900f, 0.00823639f, -0.02308747f, -0.00990168f, 
    -0.00060585f, 0.00332654f, 0.03383973f, 0.03209851f, -0.01930464f, 0.03702710f, 0.01111934f, -0.05323321f, 
    -0.04712530f, -0.00497537f, -0.02389733f, -0.05622090f, 0.01641865f, -0.01697190f, 0.02617874f, -0.01899669f, 
    -0.05758457f, -0.05283527f, -0.04435531f, -0.01324879f, -0.01021739f, 0.02624632f, -0.03816166f, 0.03671292f, 
    -0.00007472f, -0.05090723f, -0.01046734f, -0.00889744f, -0.02081520f, -0.04741005f, -0.02574953f, -0.00142870f, 
    0.00825748f, 0.02823224f, 0.01723837f, -0.00728692f, 0.00275668f, -0.01477245f, -0.02114204f, 0.02844314f, 
    -0.05590740f, -0.04303996f, -0.02684911f, -0.02539859f, -0.01441917f, 0.01643782f, 0.02575339f, -0.00570776f, 
    0.02250120f, 0.00234825f, -0.01060081f, -0.04770006f, 0.01622668f, -0.01985657f, -0.01218878f, -0.02269789f, 
    0.02109577f, -0.00811112f, 0.03863907f, -0.01251888f, 0.00665106f, 0.04556790f, 0.00188891f, 0.00526198f, 
    -0.01161531f, -0.02921566f, 0.03825689f, -0.04572806f, -0.04909397f, -0.00844302f, -0.00753171f, -0.02058788f, 
    -0.04922634f, -0.00670508f, -0.05770810f, 0.00689313f, 0.01691066f, -0.00149017f, -0.04611362f, 0.00879033f, 
    -0.00720133f, 0.02164961f, -0.01293844f, -0.05293015f, -0.02809310f, 0.00190356f, 0.03197149f, 0.03490889f, 
    -0.03722529f, -0.01746555f, -0.02245794f, -0.00238221f, -0.02788995f, 0.00195209f, 0.03530242f, 0.02477586f, 
    -0.00736621f, -0.05491935f, -0.04370051f, 0.02153374f, 0.03709695f, -0.02829036f, 0.03866493f, 0.01569229f, 
    0.00750151f, 0.05091404f, 0.01053176f, 0.00997403f, 0.01477187f, -0.05852527f, -0.00008883f, 0.01272134f, 
    -0.01104329f, 0.03282295f, 0.02498047f, 0.02897195f, 0.00172404f, -0.03908188f, -0.04253855f, 0.04208693f, 
    -0.02851856f, 0.03668633f, -0.01667140f, -0.04179958f, 0.03050412f, -0.00140581f, 0.04966037f, -0.00277022f, 
    -0.01957688f, 0.01986617f, -0.01135117f, -0.04177405f, 0.02720656f, -0.02636989f, -0.04582408f, -0.04227911f, 
    0.01931545f, -0.03635199f, 0.03941400f, -0.02002579f, -0.01941510f, -0.04739795f, 0.00544972f, -0.05481083f, 
    -0.05486045f, -0.01091876f, -0.03725873f, 0.01898080f, 0.01917879f, -0.03773880f, -0.02609357f, 0.00021944f, 
    -0.00739144f, -0.01486951f, 0.01115944f, -0.04348294f, -0.02807281f, 0.04501671f, -0.03934645f, 0.01419199f, 
    -0.03819167f, -0.02908735f, -0.01732546f, -0.02090926f, -0.03547254f, 0.02235071f, 0.04346275f, -0.00202316f, 
    -0.04895724f, -0.04279024f, -0.04202786f, -0.01605773f, -0.00581056f, -0.00053426f, 0.03916336f, -0.03703655f, 
    0.01283914f, -0.00210450f, -0.04312581f, -0.04682840f, 0.00016993f, 0.00691737f, -0.00941764f, 0.00004806f, 
    -0.02806126f, -0.05624722f, 0.02845041f, 0.04305260f, 0.00500613f, -0.04890979f, 0.02530232f, 0.05049757f, 
    0.01053577f, 0.04512952f, -0.04466479f, -0.04355954f, 0.03381576f, 0.00687656f, -0.00382735f, 0.00891398f, 
    0.02758699f, -0.00647459f, -0.05074695f, 0.02574944f, 0.00241026f, 0.03809714f, 0.00122845f, -0.00664533f, 
    -0.02503394f, -0.02082227f, 0.01217675f, 0.01498691f, 0.04622266f, 0.01586958f, 0.00047458f, -0.03924970f, 
    -0.02202042f, -0.02010250f, -0.05608116f, 0.02970094f, 0.04765333f, -0.01780354f, -0.04103357f, -0.02393614f, 
    -0.00630036f, 0.00629727f, -0.02946877f, 0.03803942f, 0.01902078f, -0.05379697f, 0.04781275f, -0.00905942f, 
    0.03912339f, -0.03942543f, 0.01080335f, -0.00300469f, 0.03271287f, -0.01326144f, 0.02632498f, -0.05469083f, 
    0.01390276f, 0.00650177f, 0.02934545f, -0.01028022f, 0.03797051f, -0.03614161f, -0.03397929f, 0.00332033f, 
    0.02870606f, 0.01962129f, 0.02178337f, -0.00918497f, 0.00526324f, 0.00007741f, -0.02131496f, -0.04448686f, 
    -0.02940777f, -0.04982908f, 0.01158213f, -0.04860928f, 0.01040472f, -0.05238068f, -0.04439325f, 0.03868169f, 
    0.02614408f, 0.03303296f, 0.01985000f, 0.00987302f, 0.02553436f, -0.02822628f, -0.01238074f, 0.04420286f, 
    -0.01947848f, -0.03043079f, -0.04514671f, 0.03936110f, 0.01133464f, -0.04751710f, 0.03353476f, -0.03718427f, 
    0.03902043f, 0.02414946f, -0.01561120f, 0.03122051f, -0.00467090f, 0.03686266f, -0.05627001f, -0.02154179f, 
    -0.04466116f, 0.03940060f, -0.05293360f, 0.00010395f, 0.02497382f, -0.04664698f, -0.03831581f, 0.01492106f, 
    0.01278022f, 0.03599722f, -0.02577182f, 0.00442510f, 0.02821375f, -0.01808341f, -0.00215175f, 0.03788918f, 
    -0.05073113f, -0.03683288f, 0.02835389f, -0.01934125f, -0.03883387f, 0.03998661f, 0.03882540f, -0.03297307f, 
    -0.03518526f, 0.03701739f, -0.01247300f, -0.00663476f, -0.05048538f, 0.02712466f, 0.03914098f, 0.01899731f, 
    -0.04253115f, 0.01756819f, 0.02068162f, -0.02720654f, 0.01942857f, 0.03094979f, 0.03957484f, -0.04948680f, 
    -0.03270513f, -0.00623460f, -0.01871350f, 0.01617848f, -0.01859472f, -0.03735988f, -0.02023029f, 0.04675139f, 
    -0.03712941f, -0.04508969f, -0.03472498f, -0.05044173f, -0.01762375f, -0.00294637f, -0.01553472f, 0.02021409f, 
    -0.03208548f, 0.01152401f, 0.02950995f, -0.02715738f, 0.01300695f, 0.03065743f, 0.03830650f, 0.03906435f, 
    0.01813597f, 0.00970619f, 0.02664300f, -0.01376876f, 0.04425976f, -0.04526680f, 0.04415228f, 0.00122669f, 
    -0.05062629f, 0.01438401f, 0.01522555f, -0.01566176f, -0.01065766f, -0.04354503f, -0.02824491f, 0.01175751f, 
    0.00612360f, -0.03085209f, 0.03216197f, 0.00098968f, -0.02985488f, 0.03633934f, -0.00117568f, -0.02523227f, 
    0.00122849f, -0.05309009f, 0.05059894f, 0.01343662f, 0.02855924f, 0.03613402f, -0.00913342f, -0.01345628f, 
    -0.01415764f, 0.03394804f, -0.01097257f, 0.00636944f, 0.03400638f, 0.02752409f, -0.03812998f, 0.02333782f, 
    -0.01667028f, 0.02586244f, -0.03665264f, -0.02565907f, -0.01916290f, 0.03189297f, -0.04674564f, 0.00869888f, 
    -0.00575699f, 0.00353758f, 0.01822890f, -0.02032991f, -0.03516686f, 0.04118978f, 0.03084997f, -0.01142535f, 
    -0.03144003f, -0.00107045f, 0.00617709f, -0.04523973f, 0.04526648f, -0.02931126f, 0.04414183f, 0.02386062f, 
    -0.01657075f, 0.04208155f, 0.00360637f, 0.02535189f, 0.04175492f, -0.03960240f, -0.01925578f, -0.04517721f, 
    0.04462814f, 0.03707527f, -0.00666057f, -0.05485223f, -0.04282795f, 0.01576541f, 0.00320067f, 0.04100615f, 
    -0.02119152f, -0.02678539f, 0.01864894f, 0.01170748f, -0.03061437f, -0.00332126f, 0.02587929f, 0.03816434f, 
    -0.00405245f, 0.03414297f, 0.01142911f, 0.00597878f, 0.03213058f, -0.00089913f, 0.00867265f, -0.05362908f, 
    -0.02428273f, -0.02500356f, -0.05365449f, -0.05159708f, -0.05476069f, 0.04599643f, -0.04788085f, 0.01350999f, 
    0.00345162f, -0.04054925f, -0.03828028f, -0.00365917f, -0.02020710f, -0.04572744f, 0.02842968f, -0.03586540f, 
    -0.01851412f, 0.01345960f, 0.02444779f, -0.01414888f, 0.02240066f, -0.00249983f, -0.01876246f, -0.02070068f, 
    0.00321075f, -0.02449618f, -0.04623710f, 0.03910885f, 0.00466537f, 0.03178693f, -0.04565016f, -0.02828744f, 
    -0.04613344f, -0.04990505f, -0.04270604f, -0.04075697f, -0.03558023f, -0.04495055f, -0.02557353f, 0.01756690f, 
    0.03742114f, -0.03196254f, -0.00296438f, 0.04793547f, -0.02742586f, 0.04083034f, -0.01833955f, 0.01015752f, 
    -0.00991034f, -0.02982495f, 0.04754514f, -0.02127187f, 0.01974601f, 0.04075955f, 0.03330969f, 0.04153688f, 
    0.22274753f, -0.06589428f, 0.08358231f, 0.22731638f, 0.11754148f, 0.04781813f, -0.07326049f, -0.04222140f, 
    -0.00614349f, 0.05020582f, -0.01854310f, -0.11146046f, -0.15716842f, 0.09231350f, -0.10070638f, -0.18787307f, 
    0.03592470f, 0.11134630f, 0.00517637f, 0.03538852f, 0.00132897f, 0.02415395f, -0.03607746f, 0.14250422f, 
    -0.25794628f, -0.01002621f, -0.15230879f, -0.11977636f, 0.06865915f, 0.03218101f, -0.01468624f, -0.04721918f, 
    0.02254694f, -0.04485425f, 0.08591204f, -0.02364209f, -0.20347004f, 0.02684858f, 0.13794225f, -0.13354462f, 
    0.06808753f, -0.00411726f, 0.03332227f, 0.05100100f, -0.05254898f, 0.01764399f, 0.03970186f, 0.03566575f, 
    -0.14018710f, 0.14478925f, 0.25983149f, 0.17631294f, 0.11496650f, 0.01427410f, -0.11882512f, 0.02719704f, 
    -0.04908243f, 0.06265921f, 0.05065696f, -0.10193051f, 0.23746078f, 0.02477293f, 0.17947954f, -0.06353494f, 
    0.11475673f, 0.02906220f, 0.05983394f, -0.05034276f, 0.12575121f, -0.00535086f, 0.10742121f, -0.16672604f, 
    -0.18638250f, 0.02080647f, 0.00277700f, -0.08649675f, 0.05684281f, 0.13491563f, -0.02839748f, 0.02937169f, 
    0.02059169f, 0.04246662f, 0.02386615f, -0.04245416f, -0.07622683f, 0.03032290f, -0.06316126f, -0.10373786f, 
    0.03558191f, 0.08425150f, -0.01598370f, -0.01844743f, 0.08523248f, 0.01588052f, -0.01741014f, 0.07068007f, 
    -0.03550720f, 0.12823087f, 0.05732964f, -0.00655732f, -0.07511624f, 0.03759902f, 0.01173573f, 0.06916896f, 
    -0.01536119f, 0.03764635f, 0.02292397f, -0.00062699f, -0.20817831f, -0.07484602f, -0.05995398f, 0.02472940f, 
    0.14360970f, 0.10029849f, 0.08331605f, -0.06151588f, 0.00105144f, 0.03931522f, 0.00865058f, -0.01543957f, 
    0.15982023f, 0.11298750f, 0.07138559f, 0.18618280f, 0.14518827f, 0.02071599f, -0.04018878f, 0.12262215f, 
    0.01865857f, 0.09874627f, -0.08086666f, -0.05309692f, 0.04637240f, 0.07356761f, 0.12524250f, -0.25402993f, 
    -0.03634617f, 0.07129960f, -0.02374667f, -0.01660958f, 0.06066477f, -0.00976642f, 0.02793578f, -0.02046306f, 
    -0.30161223f, 0.20436925f, 0.02508123f, -0.18817665f, 0.09581940f, -0.06804519f, -0.02518467f, -0.10887519f, 
    -0.00783082f, 0.10215759f, -0.07216635f, 0.01192934f, -0.19636001f, 0.01917400f, 0.12053509f, 0.12841588f, 
    -0.10810535f, 0.07370462f, 0.03405631f, 0.05939754f, -0.04287568f, -0.03007624f, 0.02578062f, 0.01897322f, 
    -0.25587183f, -0.13297881f, 0.19645321f, -0.00748107f, 0.01145532f, -0.14976592f, 0.00370075f, -0.03935300f, 
    -0.04073901f, 0.00104905f, 0.04556187f, 0.12229266f, 0.10200026f, 0.17066933f, 0.23112269f, 0.15574363f, 
    0.12291735f, 0.05857253f, -0.03295274f, 0.11260345f, -0.00020660f, -0.00174005f, -0.01021392f, 0.05818450f, 
    -0.01463068f, -0.01360214f, 0.22803827f, 0.26426718f, -0.00289870f, 0.01262834f, 0.02421203f, -0.00490523f, 
    -0.06002860f, -0.00840773f, -0.07395929f, -0.07579243f, -0.25221872f, 0.02180094f, -0.06557075f, -0.17695603f, 
    0.09634718f, 0.01961468f, 0.04633026f, 0.17507710f, -0.00876172f, 0.07688981f, -0.06535194f, -0.03218512f, 
    0.11434399f, -0.16131046f, 0.31523666f, 0.26864195f, -0.17364699f, 0.01830324f, 0.00669565f, 0.05421628f, 
    -0.02232915f, -0.02366180f, 0.04359478f, 0.00716906f, 0.07813560f, 0.03503900f, -0.00466575f, 0.26725143f, 
    -0.01802740f, -0.18983421f, -0.02718988f, -0.00032561f, -0.05504411f, 0.02612848f, -0.08199305f, 0.05549733f, 
    0.01167084f, 0.15115888f, -0.10392841f, 0.04532139f, 0.19239606f, -0.02146544f, -0.04875129f, 0.02149918f, 
    -0.03345545f, 0.04905843f, 0.11774988f, -0.01120538f, -0.14545368f, 0.07305581f, 0.10651739f, -0.19381441f, 
    -0.04588679f, 0.09339702f, 0.10918485f, -0.06187386f, -0.06638995f, 0.00637775f, 0.04566572f, -0.01889076f, 
    -0.13534118f, 0.07091380f, -0.03863887f, -0.12396174f, 0.00246033f, -0.04646687f, 0.00483300f, 0.03381852f, 
    0.01047840f, -0.01313641f, 0.02456637f, 0.00186658f, -0.09137449f, 0.05318597f, 0.15970694f, 0.05045344f, 
    -0.04161768f, -0.00330681f, 0.01470838f, 0.07226986f, -0.04403928f, -0.00295728f, 0.00800149f, 0.09750093f, 
    -0.09462956f, -0.06275097f, 0.18094686f, 0.03128316f, 0.06334001f, -0.07228433f, 0.04277644f, 0.09142551f, 
    0.07470243f, 0.05811223f, -0.01656365f, 0.06744654f, 0.08385009f, -0.03936649f, -0.12378268f, 0.19214629f, 
    0.00408470f, 0.14786240f, 0.06283847f, 0.04989846f, 0.05654882f, 0.00638726f, 0.04528595f, 0.06876371f, 
    -0.01719218f, 0.00149045f, -0.03099447f, -0.08502652f, 0.05950985f, -0.01462984f, 0.08429340f, -0.07413822f, 
    0.22129245f, -0.00231159f, -0.04139451f, 0.13437963f, 0.30325234f, 0.15679720f, 0.09988575f, 0.24324071f, 
    -0.00596850f, 0.01198396f, -0.01831194f, 0.08191474f, -0.05654890f, -0.06392582f, 0.07943958f, 0.11187092f, 
    0.02540708f, -0.20127986f, -0.13503236f, 0.00136475f, -0.00739223f, 0.02303329f, -0.02440207f, -0.08054556f, 
    -0.01368051f, 0.09801725f, -0.01636538f, -0.11473408f, -0.12532909f, -0.10194656f, 0.05478927f, 0.29616567f, 
    0.06637542f, -0.05010343f, -0.10686826f, 0.09497628f, 0.10331496f, -0.01320275f, -0.10940789f, -0.08276672f, 
    -0.01193693f, 0.10292991f, 0.03151990f, 0.07740372f, -0.06946474f, 0.10908633f, 0.05994810f, -0.06345247f, 
    0.11085299f, -0.06191672f, 0.06786630f, 0.16138735f, -0.18917403f, -0.06880596f, 0.07687099f, -0.08081774f, 
    0.02648561f, 0.00410395f, -0.04906628f, 0.03371553f, -0.03362700f, -0.06997278f, -0.07461918f, 0.00412194f, 
    -0.16078727f, -0.02661153f, -0.08407597f, 0.22538416f, 0.05667379f, -0.02181778f, 0.08969570f, -0.02357268f, 
    0.08795427f, -0.07782748f, 0.01590694f, -0.04231791f, -0.04885503f, 0.10222013f, 0.03476017f, -0.13728559f, 
    0.15717994f, -0.14121060f, 0.13609117f, 0.01125134f, -0.05345417f, -0.01285962f, 0.14594133f, 0.11556421f, 
    0.10253613f, 0.08530261f, -0.08514857f, 0.15403484f, 0.00899665f, -0.00573801f, 0.03811513f, -0.01905777f, 
    -0.11213396f, 0.02606536f, -0.10144491f, -0.02478834f, 0.13600260f, 0.19030584f, 0.14084320f, 0.00920906f, 
    0.11867892f, 0.07818258f, -0.02542269f, -0.18744820f, -0.02695429f, -0.03848356f, 0.02983551f, 0.01071791f, 
    0.24910697f, -0.15014680f, -0.14268085f, -0.03018600f, -0.01771734f, -0.20975371f, 0.12316933f, -0.02427487f, 
    0.05884898f, -0.05562695f, 0.11927520f, -0.09412626f, 0.27033842f, -0.08333781f, 0.01685830f, -0.11015398f, 
    0.00706271f, -0.00097781f, -0.11741932f, 0.08383847f, 0.09300655f, 0.08059998f, -0.06331086f, 0.03028612f, 
    0.19322287f, -0.09866769f, 0.04075839f, -0.00631167f, -0.08744954f, 0.00303961f, 0.04826285f, 0.11685736f, 
    0.06109026f, -0.03638322f, -0.15184492f, 0.09193192f, 0.29638249f, 0.08039568f, -0.07776947f, 0.02777093f, 
    0.04609753f, -0.11616392f, 0.07421577f, -0.11435153f, -0.04109591f, -0.06001090f, -0.05306535f, 0.01635528f, 
    0.05275445f, 0.20643559f, 0.11400027f, 0.10756244f, -0.00406344f, -0.02874197f, -0.09783744f, 0.03605049f, 
    -0.01264041f, 0.02931441f, 0.03684793f, 0.04434394f, -0.12188604f, -0.14445238f, 0.13893561f, -0.11028768f, 
    -0.06865346f, 0.03396116f, 0.01958202f, -0.08919654f, -0.09248284f, 0.13986419f, 0.02999533f, 0.11683996f, 
    0.15790318f, -0.00127941f, -0.11831126f, -0.04084906f, -0.07562833f, -0.03261783f, 0.09292292f, -0.08314957f, 
    -0.02552161f, 0.06350128f, -0.13455139f, 0.12460665f, -0.26898149f, 0.24273919f, 0.19522607f, -0.10349182f, 
    0.07649571f, 0.01545200f, 0.01929046f, 0.00213315f, -0.08256919f, 0.07203785f, 0.04403406f, -0.02064441f, 
    0.19440579f, -0.23383091f, 0.26040062f, -0.23148614f, 0.01418540f, 0.01688500f, -0.16156667f, 0.08290417f, 
    0.06394383f, -0.14423791f, 0.07120991f, 0.01436022f, 0.02687800f, 0.02333406f, -0.15231429f, 0.12713595f, 
    0.09235523f, -0.04014780f, 0.09103395f, -0.11340937f, 0.03797932f, 0.08274331f, -0.02733658f, 0.12578280f, 
    0.49453610f, -0.00812926f, -0.13872485f, -0.12123928f, -0.00351985f, 0.07644158f, 0.12337684f, 0.03991968f, 
    0.02583443f, -0.04374025f, 0.14483148f, -0.09111071f, 0.04181215f, 0.04521075f, -0.01668759f, 0.18263550f, 
    0.17206545f, -0.02271848f, -0.04484566f, -0.10010645f, -0.05609947f, -0.11028744f, -0.02017079f, 0.04840300f, 
    0.18293148f, -0.10118146f, -0.26278925f, 0.12394680f, 0.14360404f, -0.01426134f, 0.01091354f, -0.04359108f, 
    -0.06717169f, -0.01036960f, 0.10796355f, 0.02049080f, 0.47598201f, -0.32575476f, 0.11186408f, -0.01305525f, 
    0.07234666f, -0.01025611f, 0.04756440f, -0.04183279f, 0.17988051f, 0.00183493f, 0.05166727f, -0.03448358f, 
    0.35638693f, -0.03051929f, -0.24798343f, 0.25385326f, 0.01366789f, -0.02406638f, 0.06225222f, 0.18198906f, 
    0.07269593f, 0.07604105f, -0.02623976f, -0.05702616f, -0.06879707f, 0.01752705f, -0.17737608f, 0.07270125f, 
    0.15062319f, -0.04930934f, 0.00482317f, -0.02577054f, -0.02942863f, 0.00175429f, -0.03781940f, 0.14832695f, 
    -0.08516861f, -0.11158945f, 0.06879555f, -0.06749576f, -0.16634651f, 0.04532333f, -0.02666848f, -0.11389820f, 
    0.02421745f, -0.05900901f, 0.02048796f, 0.05523311f, 0.16461994f, 0.26038438f, 0.02928458f, -0.12981018f, 
    0.03484198f, 0.02909013f, -0.03033870f, -0.00435226f, 0.00939935f, -0.01701244f, 0.01911468f, 0.06272893f, 
    0.01923549f, 0.08458800f, 0.12902433f, -0.12976851f, 0.10607240f, 0.08347085f, 0.04017762f, 0.09469408f, 
    -0.03026563f, -0.06809864f, 0.15793413f, -0.00698587f, 0.30459252f, 0.01407015f, 0.05644280f, -0.13894826f, 
    -0.03813333f, 0.06132623f, 0.16871054f, -0.03936948f, 0.13014311f, -0.01702060f, 0.05859852f, -0.06175323f, 
    -0.03132230f, -0.16170351f, -0.04530080f, -0.09527132f, -0.01268461f, 0.07676478f, -0.02007687f, 0.00788832f, 
    0.05191401f, 0.08559149f, 0.02794251f, -0.04738722f, 0.14813057f, 0.05123023f, -0.31429893f, 0.02586181f, 
    -0.03975979f, 0.07753442f, -0.00180701f, -0.17361344f, 0.09404369f, 0.03974289f, 0.05523159f, -0.04962031f, 
    0.10715368f, 0.16096695f, 0.01717057f, -0.05862911f, 0.02162993f, -0.02479636f, -0.02911943f, 0.02997115f, 
    -0.00561387f, -0.04818754f, 0.09162667f, -0.01634541f, -0.26626024f, -0.03643855f, -0.14463711f, -0.05019163f, 
    -0.04970739f, -0.14472207f, 0.07473926f, 0.06547751f, 0.11482777f, 0.07958654f, 0.15384363f, -0.10462954f, 
    -0.18581319f, 0.07883908f, 0.00931378f, 0.08557268f, -0.01196485f, -0.01575277f, 0.03368773f, 0.02522784f, 
    0.07470107f, -0.01310437f, -0.05363537f, 0.02392718f, 0.05629124f, 0.21230122f, -0.25107706f, 0.09395169f, 
    0.05059445f, -0.04429147f, -0.02099704f, -0.05459512f, 0.06597617f, 0.09067670f, 0.04644790f, 0.05190906f, 
    0.08261174f, -0.12981042f, -0.07047660f, 0.04762533f, 0.12910354f, 0.09836620f, 0.01023208f, -0.08835646f, 
    0.02504280f, -0.05046273f, 0.10628433f, 0.00267763f, 0.23056273f, 0.14564320f, -0.03807312f, 0.01733881f, 
    -0.06605967f, 0.00831826f, -0.08933806f, 0.07314617f, -0.05579197f, -0.10326757f, 0.00060236f, -0.03399457f, 
    -0.03778313f, -0.01853849f, -0.03971377f, 0.03100332f, -0.01308236f, -0.02937210f, -0.02109474f, -0.04902098f, 
    -0.03822501f, 0.00541712f, -0.03002343f, 0.03572544f, -0.02417901f, 0.01897066f, -0.04252625f, -0.00372362f, 
    0.00523075f, 0.03862698f, -0.01574265f, -0.02522082f, 0.00640189f, -0.00011102f, -0.05758356f, -0.05435882f, 
    0.00210460f, -0.04614063f, 0.02252453f, -0.04871523f, -0.02552802f, 0.00561999f, -0.00696785f, -0.04545917f, 
    -0.02279992f, 0.01785157f, -0.03920591f, 0.01126560f, 0.01402127f, -0.03613440f, -0.05339309f, -0.04797115f, 
    0.00992016f, 0.01238719f, -0.01299331f, 0.03395002f, -0.02019769f, -0.01081379f, 0.02844556f, 0.03332769f, 
    -0.04400910f, -0.00809465f, -0.06171444f, -0.00707469f, -0.05392435f, -0.05847546f, -0.00242614f, -0.03447497f, 
    -0.05571779f, -0.01959223f, 0.02946508f, -0.02987084f, -0.04390441f, 0.01549890f, -0.01364302f, 0.02135352f, 
    -0.06265280f, -0.01825130f, -0.00160120f, -0.05140647f, 0.01964210f, -0.06021224f, -0.04814062f, 0.02704706f, 
    0.00623886f, 0.00723280f, -0.00799782f, 0.01593086f, -0.05485892f, 0.00956545f, -0.02779680f, -0.05126495f, 
    -0.03801569f, -0.01831524f, -0.02177270f, -0.02836351f, 0.00767433f, -0.01636718f, -0.04298800f, 0.00020413f, 
    -0.03133422f, -0.01472967f, -0.03253518f, -0.04769112f, 0.03808751f, 0.00058878f, -0.04234553f, 0.04934299f, 
    -0.04353233f, -0.00262388f, 0.01010522f, 0.03471318f, -0.03545473f, 0.02090864f, 0.00283707f, -0.02376830f, 
    -0.00310422f, 0.02560287f, -0.02624457f, 0.00958865f, -0.06144300f, -0.01250953f, -0.02539732f, 0.02143593f, 
    -0.02969252f, 0.02243014f, 0.03580228f, 0.04738498f, 0.00499849f, -0.03406694f, 0.01588803f, 0.03109614f, 
    -0.04803321f, 0.04324894f, 0.03372155f, 0.00231525f, -0.04149875f, -0.01906345f, 0.01401502f, -0.00678192f, 
    -0.05890855f, -0.06099942f, -0.06057212f, -0.03926652f, 0.01905137f, 0.02419810f, -0.01499108f, -0.02761781f, 
    0.02571356f, -0.00354447f, -0.04612691f, -0.05720097f, -0.05254259f, -0.02514337f, -0.05892321f, -0.02799234f, 
    0.00569631f, -0.06034923f, -0.05555074f, -0.03021880f, -0.05093858f, 0.00313073f, -0.03502554f, -0.00389150f, 
    0.00361234f, -0.03585254f, -0.04238007f, -0.00282482f, -0.02339865f, -0.06055172f, -0.04009168f, -0.02352757f, 
    -0.01771687f, 0.02245103f, -0.03943074f, 0.02148401f, -0.03472758f, -0.03053449f, -0.05598230f, -0.05426702f, 
    -0.04200709f, -0.04095782f, -0.03363672f, 0.00413936f, -0.01183586f, -0.02192562f, -0.03037162f, -0.04475345f, 
    -0.04606683f, -0.04210281f, -0.03894323f, -0.03808258f, 0.02960527f, -0.04349475f, -0.02070664f, -0.04390505f, 
    -0.01247365f, -0.04517680f, -0.04458093f, 0.02378680f, 0.02022533f, 0.03255985f, -0.03497681f, -0.01247433f, 
    -0.04765834f, 0.01510438f, 0.01808036f, -0.01222815f, -0.02633512f, -0.02590665f, -0.04040783f, -0.04820702f, 
    -0.03281612f, -0.02316507f, 0.03543932f, -0.02520405f, -0.00849433f, -0.01458447f, -0.05712436f, 0.03424112f, 
    -0.05389370f, -0.01620538f, 0.03823799f, 0.03699595f, 0.03558142f, -0.03680032f, -0.01501825f, -0.01235368f, 
    0.01878832f, 0.01576349f, -0.02391355f, 0.03401675f, -0.02044994f, 0.00435966f, 0.03135289f, 0.03866567f, 
    -0.04625295f, -0.02856217f, 0.00628879f, 0.03013885f, -0.00026682f, -0.02052460f, 0.03177015f, -0.03908236f, 
    -0.04075962f, -0.03330527f, -0.04480018f, -0.04091707f, 0.02793825f, -0.01057832f, 0.01290595f, 0.03766291f, 
    -0.04410774f, -0.05725165f, -0.04636174f, -0.01124057f, -0.03236270f, -0.05156362f, -0.03992997f, -0.04119099f, 
    -0.01847193f, -0.00944088f, -0.05867591f, -0.02969804f, -0.03348575f, -0.04005159f, -0.06272055f, -0.04092297f, 
    -0.02044164f, 0.01083796f, -0.02387473f, -0.05536442f, 0.03579355f, -0.02078825f, -0.01680181f, -0.06160755f, 
    -0.00006998f, -0.00914562f, 0.03542507f, 0.00166449f, 0.02127218f, -0.02484513f, 0.01515037f, 0.01802540f, 
    0.02521840f, -0.05129904f, 0.00695808f, 0.01315413f, -0.04112837f, 0.03800839f, 0.03921321f, -0.05359302f, 
    -0.01538985f, 0.03747978f, -0.05552478f, -0.00823117f, 0.00817352f, 0.01943727f, -0.01601605f, -0.02919235f, 
    -0.04044703f, -0.04752493f, 0.01989858f, -0.01646132f, -0.00068096f, -0.00927383f, 0.03915115f, -0.01331689f, 
    -0.00531889f, -0.04791602f, 0.00053790f, 0.01396333f, -0.04485117f, 0.02339878f, -0.04683804f, 0.04350302f, 
    -0.03280509f, -0.00781538f, -0.00135493f, 0.03091812f, 0.02133007f, -0.04177224f, -0.04801315f, -0.00688651f, 
    0.01825213f, 0.03455296f, -0.00373070f, -0.03249148f, -0.03252910f, -0.01374223f, -0.04715656f, -0.05958124f, 
    -0.01929305f, -0.03815748f, -0.01767692f, -0.05935851f, -0.00876026f, -0.03337307f, -0.01592804f, 0.01481984f, 
    0.00638225f, 0.00670369f, -0.04554468f, 0.00100765f, -0.00880444f, -0.01606004f, 0.03261390f, -0.02026715f, 
    -0.02255651f, 0.02962876f, -0.04821199f, -0.00743143f, -0.01786961f, -0.05678874f, -0.05493104f, -0.02995517f, 
    0.03028449f, 0.02679334f, -0.04567717f, -0.00892682f, -0.02236404f, 0.00491840f, -0.00392635f, -0.01130664f, 
    -0.05038997f, -0.03623541f, 0.01092634f, -0.03964695f, -0.04132210f, -0.03570721f, -0.02298123f, 0.02887999f, 
    -0.00358266f, -0.03411346f, -0.02111856f, 0.00017233f, -0.05268236f, 0.01474961f, 0.00974300f, -0.04169121f, 
    0.00225131f, 0.00504967f, 0.01041894f, -0.06123474f, -0.03646474f, 0.01410900f, 0.01918171f, -0.01671007f, 
    0.00138455f, -0.01131111f, -0.05546351f, -0.01799544f, -0.01921397f, 0.03128397f, 0.01872982f, 0.01117990f, 
    -0.13058713f, -0.04212887f, 0.13987079f, -0.29617587f, 0.01479876f, 0.05875108f, 0.12479048f, 0.07151964f, 
    -0.00108258f, -0.02636045f, 0.10204775f, 0.12597577f, 0.21272594f, -0.02216290f, 0.18126512f, 0.18412822f, 
    -0.10329252f, -0.00363343f, -0.04301890f, -0.01201819f, 0.03564299f, 0.03263010f, 0.06883626f, -0.08190317f, 
    0.23204637f, -0.17199528f, 0.01654384f, -0.20099357f, 0.02464261f, -0.03347959f, -0.05183855f, 0.03873732f, 
    0.04016676f, -0.00278425f, -0.02694607f, 0.07836165f, 0.13335159f, -0.06143047f, -0.03874081f, 0.26635090f, 
    -0.09560664f, 0.06641274f, 0.04032632f, 0.04144741f, 0.06122094f, 0.00876350f, -0.05198611f, 0.07935044f, 
    -0.15006138f, 0.01122431f, -0.12268295f, 0.04862406f, -0.00460724f, 0.11162411f, 0.06543393f, 0.05035129f, 
    0.05624207f, 0.09748077f, -0.04409250f, 0.12414503f, -0.34955037f, 0.23117331f, -0.17173950f, 0.24632888f, 
    0.03274560f, 0.04082783f, 0.03518957f, 0.04458410f, -0.07474867f, -0.05754417f, 0.00969364f, 0.14888683f, 
    0.07269320f, 0.10343280f, 0.05792401f, 0.03523768f, -0.03650081f, 0.01887149f, 0.00428849f, -0.05227056f, 
    0.01155410f, 0.07651538f, 0.02099173f, 0.05643601f, 0.09983009f, -0.06198351f, -0.00620209f, -0.01124311f, 
    -0.08809014f, 0.05528367f, 0.00973089f, -0.04845424f, -0.01360663f, 0.07491630f, 0.11819910f, -0.09755877f, 
    0.17183945f, -0.05603187f, -0.13309343f, -0.02589669f, -0.04165458f, 0.01105587f, 0.03531150f, 0.04895983f, 
    0.03216130f, -0.07245301f, 0.00856551f, 0.11734702f, 0.02107278f, 0.15047193f, -0.19142467f, 0.06621348f, 
    -0.03961529f, 0.03905196f, -0.04882677f, 0.13279368f, 0.06202979f, 0.00725337f, 0.02065215f, -0.01488720f, 
    -0.14069219f, 0.01967942f, -0.00861331f, -0.15106446f, -0.06806695f, 0.08509295f, -0.03558467f, 0.01243692f, 
    -0.02014369f, 0.01393278f, 0.13616961f, 0.08877142f, 0.09900244f, -0.08279146f, -0.11802652f, 0.22527364f, 
    0.00660990f, -0.02354711f, 0.05773593f, 0.04768168f, -0.04696415f, -0.01069246f, 0.02570194f, -0.00514539f, 
    0.32203773f, -0.21426572f, -0.15299214f, 0.18463993f, -0.02004361f, 0.08962066f, -0.03144307f, 0.03057766f, 
    -0.02909280f, 0.07939696f, 0.03200324f, 0.01321444f, 0.24953125f, -0.02425483f, 0.18120922f, -0.15430146f, 
    -0.00198013f, -0.02156116f, 0.02430599f, 0.09132520f, 0.06671023f, 0.00254310f, -0.02801123f, -0.04492202f, 
    0.10333046f, 0.03607411f, -0.06932142f, 0.05478980f, -0.01863729f, 0.09363330f, -0.11418604f, 0.03226154f, 
    0.08429452f, -0.00019180f, -0.00837477f, 0.01249797f, -0.16177711f, 0.06244015f, -0.11670831f, -0.01399962f, 
    -0.04302241f, 0.00002290f, 0.04499477f, -0.03349819f, 0.11067947f, 0.02259590f, 0.10321188f, -0.05894890f, 
    -0.27915910f, 0.16061392f, -0.04573236f, -0.10760256f, 0.05162915f, 0.04463644f, 0.03499117f, 0.04066756f, 
    0.12790687f, 0.02458016f, 0.08539762f, 0.05896837f, 0.15827566f, 0.19549935f, -0.04380428f, 0.24059372f, 
    -0.05548953f, 0.00582254f, -0.07790080f, -0.08953349f, 0.02220974f, -0.02243269f, 0.06625342f, 0.04518243f, 
    -0.35516524f, 0.41138643f, -0.09538010f, -0.29561943f, 0.12282380f, -0.00175071f, 0.09801211f, -0.02350668f, 
    -0.07483778f, 0.03338762f, -0.04199694f, 0.05378595f, 0.05455270f, -0.17244731f, 0.06340634f, -0.09625819f, 
    -0.03659081f, 0.07936730f, 0.08514762f, 0.12824745f, -0.01751522f, 0.04358410f, 0.07432618f, 0.06533355f, 
    0.10176515f, 0.00534418f, 0.04435602f, 0.06936599f, 0.03011972f, 0.07697562f, 0.05904969f, 0.05641784f, 
    0.09353983f, 0.06071426f, -0.00546530f, 0.05996276f, 0.20166457f, -0.05956837f, -0.00875530f, 0.32551411f, 
    -0.06526208f, -0.01709613f, -0.07971203f, 0.11422397f, 0.08245268f, 0.07122093f, -0.04900796f, 0.02901685f, 
    0.15969779f, -0.01683375f, 0.02237749f, 0.18561029f, -0.04750338f, -0.03001229f, 0.11282837f, 0.08782630f, 
    -0.09037317f, 0.05844614f, -0.00708862f, 0.02231347f, 0.13439429f, 0.10057401f, -0.00596812f, 0.11954982f, 
    0.08300153f, 0.07338624f, -0.00329546f, 0.01197162f, -0.05449394f, 0.05225072f, -0.01394853f, -0.03571407f, 
    0.00853094f, 0.15010746f, -0.06859369f, 0.16805153f, -0.02310664f, 0.10855980f, 0.13571399f, -0.00930356f, 
    -0.00710344f, -0.03118703f, 0.01561740f, -0.02327113f, -0.05281975f, 0.00234739f, 0.11569396f, -0.30309919f, 
    -0.05035361f, -0.17414083f, 0.03900152f, 0.02564682f, -0.04245296f, 0.04799130f, 0.07476451f, 0.03579577f, 
    -0.08454011f, -0.13873585f, 0.03821220f, 0.06689145f, -0.07892475f, 0.01146677f, -0.01939135f, 0.07307251f, 
    0.12256505f, 0.04321345f, 0.08350289f, -0.01822867f, 0.05799973f, -0.19850460f, 0.14364879f, 0.01107008f, 
    0.09118826f, 0.08074573f, 0.01210918f, 0.04768796f, 0.01522889f, 0.08155271f, -0.12023231f, 0.00787426f, 
    0.10509498f, -0.01561345f, 0.13314448f, -0.26854336f, -0.05262372f, -0.01003968f, 0.05605194f, 0.00254757f, 
    -0.01967097f, -0.04144492f, 0.06982119f, 0.14011909f, 0.04025016f, -0.07176935f, 0.17823984f, -0.21680680f, 
    0.00926362f, 0.04419709f, 0.06322137f, 0.14457583f, -0.13584702f, -0.03605855f, 0.09043685f, 0.08555073f, 
    0.01240528f, 0.01623066f, 0.07170089f, 0.05155829f, 0.17596334f, 0.01173998f, -0.03621710f, 0.12749435f, 
    -0.00777655f, 0.11790746f, -0.12303035f, -0.03295032f, 0.05654071f, 0.10891127f, 0.13929595f, 0.02407162f, 
    -0.02798976f, 0.00395733f, 0.17734969f, -0.04838374f, 0.05269423f, 0.11573108f, 0.09729255f, 0.04472309f, 
    0.09996590f, 0.04048155f, 0.11023025f, -0.05575893f, 0.03569176f, 0.00780302f, -0.04601202f, 0.05307097f, 
    0.03642622f, 0.03010194f, -0.03153359f, 0.03340062f, 0.12291098f, -0.13357447f, -0.10496513f, 0.07672688f, 
    -0.02861665f, 0.10633478f, 0.03135653f, -0.05539892f, 0.10997398f, -0.04076729f, -0.02927220f, 0.05387453f, 
    -0.26752153f, -0.10296624f, -0.09980968f, -0.20643963f, -0.01936080f, 0.03757915f, -0.03982027f, 0.02606390f, 
    0.09086875f, -0.03813960f, 0.12648292f, 0.01919952f, -0.03511917f, -0.11280903f, 0.00529880f, 0.06869078f, 
    0.02954703f, 0.01555188f, 0.11988994f, 0.02054006f, -0.00263099f, 0.09003899f, 0.02620062f, 0.08564367f, 
    -0.24419002f, 0.10505442f, 0.23665081f, 0.02889114f, -0.00047957f, 0.17509751f, -0.08833018f, 0.09862638f, 
    -0.08819806f, 0.05586868f, 0.04941460f, 0.09246321f, -0.22568157f, 0.16022052f, 0.01589985f, -0.05269276f, 
    0.01971052f, -0.01364788f, 0.14984360f, 0.02682947f, -0.00993220f, 0.02539154f, 0.09417115f, -0.13193089f, 
    -0.32952604f, 0.13850431f, 0.01642039f, -0.16238740f, 0.10360056f, 0.02673110f, -0.03529144f, 0.07619690f, 
    -0.06431508f, -0.03293783f, 0.07865039f, -0.07512875f, -0.07603752f, -0.04029619f, -0.01604950f, -0.03952427f, 
    0.06830566f, 0.13313708f, 0.00640383f, 0.12370161f, -0.00496787f, 0.05904956f, 0.00416008f, 0.01250157f, 
    0.11215477f, 0.08018269f, -0.16056226f, 0.07854956f, -0.13354148f, 0.07272917f, 0.00360880f, 0.06426444f, 
    -0.03089473f, 0.13161686f, 0.11914908f, 0.11358942f, -0.25351685f, -0.07574993f, -0.15447776f, -0.07911903f, 
    0.13470405f, 0.12404592f, -0.08804909f, -0.03018847f, 0.02231392f, -0.01640817f, 0.08532450f, -0.03451390f, 
    -0.09464694f, 0.03403012f, 0.03140603f, 0.03894368f, 0.01849900f, 0.00631861f, -0.04073818f, 0.21382691f, 
    0.05464381f, 0.00683188f, 0.07227477f, -0.03738517f, 0.17921565f, -0.07376479f, -0.01438597f, -0.01406964f, 
    -0.02519039f, 0.02008806f, 0.02185296f, 0.03911085f, 0.02211123f, -0.01211906f, 0.04127260f, 0.03768094f, 
    -0.23709369f, 0.18348683f, -0.12248122f, -0.02081019f, 0.00907866f, -0.07651736f, 0.03796156f, -0.14661045f, 
    0.06596240f, 0.13088764f, 0.05541846f, 0.10235365f, 0.21642596f, -0.02865452f, 0.21557957f, 0.24042082f, 
    -0.11749037f, 0.03814919f, -0.05493855f, 0.06944817f, -0.03250144f, -0.04782944f, -0.02396246f, -0.00396226f, 
    -0.38354626f, 0.03522822f, 0.15628570f, 0.05159026f, 0.11284541f, -0.09051008f, -0.07869383f, -0.01275391f, 
    -0.02798124f, 0.04196343f, 0.06561679f, 0.06092532f, 0.13761902f, 0.15366569f, 0.09604231f, -0.06495187f, 
    -0.03034073f, 0.07375672f, -0.05374369f, 0.14704368f, 0.10634730f, 0.06026776f, 0.09368803f, 0.05999634f, 
    -0.21958047f, 0.24051276f, 0.21933210f, 0.11471359f, -0.09761602f, 0.09530950f, -0.07616100f, -0.06216830f, 
    0.00037308f, -0.03206181f, -0.04265754f, -0.04056460f, -0.38479555f, 0.16021977f, 0.02894893f, -0.10565908f, 
    0.08000208f, 0.06013393f, 0.00340334f, 0.11909582f, -0.09607011f, -0.07850718f, -0.02869819f, 0.04976863f, 
    -0.17341739f, 0.19769478f, 0.24971117f, 0.13191703f, -0.11229432f, 0.07063920f, 0.02530113f, 0.11779966f, 
    0.01765697f, 0.01757781f, 0.11045377f, 0.05091504f, -0.04620619f, -0.05591014f, 0.02778301f, 0.13692583f, 
    -0.07723531f, -0.07545149f, 0.06823345f, -0.07126620f, 0.07425619f, -0.09433346f, -0.01524484f, 0.00668014f, 
    -0.10126628f, 0.02259811f, -0.05096954f, 0.02687108f, 0.07797016f, -0.02526798f, 0.05798063f, 0.03919977f, 
    0.01275729f, 0.12136592f, -0.01834069f, -0.01969032f, -0.06831176f, -0.11140332f, 0.00534907f, 0.06737187f, 
    -0.13351645f, -0.01962896f, 0.09562075f, 0.01964674f, -0.04097640f, -0.10672110f, -0.00999650f, -0.03797322f, 
    0.04614618f, -0.10506373f, -0.13594985f, 0.04437603f, 0.01291707f, -0.05881322f, -0.04654070f, -0.00602913f, 
    0.08637461f, -0.06774370f, -0.05116716f, 0.02274642f, -0.04925330f, -0.04197768f, 0.14119154f, 0.26690003f, 
    0.02666282f, -0.02380857f, -0.01262836f, 0.08280570f, -0.10467834f, -0.10210416f, -0.07623876f, 0.09545866f, 
    -0.21652669f, 0.17079528f, 0.21884076f, 0.13068944f, -0.05374778f, -0.11522062f, 0.00850410f, 0.10118271f, 
    0.00427581f, 0.00055559f, -0.01703409f, 0.05478523f, 0.01514142f, -0.21088038f, -0.00425999f, -0.08175794f, 
    -0.05897871f, 0.07975607f, 0.05195707f, 0.07291506f, -0.01384855f, -0.02429708f, 0.09224787f, 0.06332431f, 
    -0.10752361f, -0.18150117f, 0.02985387f, -0.05499258f, 0.04417890f, 0.02813803f, 0.14499007f, -0.00813961f, 
    0.24898340f, 0.03767659f, -0.06650136f, 0.10480661f, 0.35485256f, 0.14997306f, 0.15454869f, 0.22343232f, 
    0.11856461f, 0.06228045f, 0.00289648f, 0.06478280f, -0.01034140f, -0.10738410f, 0.03372028f, 0.10325999f, 
    -0.00929493f, -0.10116213f, -0.10789426f, 0.00015735f, 0.03258165f, 0.02427720f, -0.00963280f, -0.07323684f, 
    -0.03894162f, 0.05706019f, 0.03979520f, 0.00006967f, 0.00041510f, -0.12131236f, 0.08918804f, 0.11376452f, 
    0.03160492f, -0.09099948f, 0.01055439f, 0.10405788f, 0.06924565f, 0.00700000f, -0.05129247f, -0.05411418f, 
    -0.00851714f, 0.12940395f, 0.06181452f, 0.12273383f, -0.08949128f, 0.07098030f, 0.06450863f, 0.06451884f, 
    0.07298928f, 0.12081862f, 0.08354866f, 0.10142028f, -0.17963006f, -0.12769228f, 0.03274962f, -0.05136901f, 
    0.05502885f, 0.01650865f, 0.02998897f, 0.03056114f, 0.00771488f, 0.04503873f, 0.01434394f, -0.01877312f, 
    0.03611559f, 0.03972473f, -0.04283915f, -0.03964255f, 0.00964727f, 0.03329736f, -0.02315197f, 0.00283263f, 
    -0.03690681f, 0.03259046f, -0.04636311f, -0.03939655f, -0.01225960f, -0.05386373f, -0.02898942f, 0.00388782f, 
    0.00886843f, -0.01603746f, -0.01431029f, -0.03531142f, -0.03942880f, -0.05094846f, 0.03149450f, 0.04362068f, 
    -0.01766071f, -0.04890957f, -0.03465549f, 0.01831788f, -0.04981641f, -0.04755509f, 0.01830207f, 0.00644981f, 
    -0.02952672f, -0.03860667f, -0.01456587f, 0.00743567f, -0.01880588f, -0.03506313f, 0.03712042f, -0.00163184f, 
    0.04245135f, -0.00941356f, -0.04148044f, 0.04077153f, 0.02984527f, -0.04955573f, 0.02305606f, -0.02164744f, 
    -0.02844566f, -0.04481998f, 0.01446339f, 0.03897225f, -0.03724673f, -0.01347198f, -0.00812305f, -0.00820180f, 
    -0.01539906f, 0.00720184f, -0.04444708f, 0.00422585f, -0.00605707f, -0.03226151f, -0.00000943f, -0.03614524f, 
    -0.04167013f, -0.00274845f, -0.01062143f, -0.01101548f, -0.00285738f, 0.02212762f, 0.02035425f, 0.01251289f, 
    -0.05429704f, 0.00866547f, 0.01097549f, 0.00041303f, -0.00979194f, 0.02339232f, -0.02527521f, -0.05864290f, 
    0.00472415f, 0.03654021f, 0.04191614f, 0.02737674f, -0.00255583f, 0.04009362f, -0.00794869f, -0.05548431f, 
    0.02489457f, -0.04786341f, 0.04257496f, -0.03758149f, 0.01434780f, 0.03658031f, -0.05011733f, -0.02629280f, 
    -0.01935138f, -0.02574829f, 0.03951276f, -0.03675560f, -0.00242875f, -0.04642140f, -0.02202497f, -0.02302717f, 
    -0.02583313f, 0.00089973f, 0.04136494f, -0.04590344f, -0.00941033f, 0.03657393f, -0.01499151f, 0.03203409f, 
    -0.00134098f, -0.00425865f, -0.02768351f, 0.04431562f, -0.03360282f, -0.00384666f, -0.03733319f, -0.03432542f, 
    -0.03484870f, 0.00068175f, 0.03527867f, -0.05250774f, 0.01081978f, -0.00007826f, 0.00573215f, -0.02758007f, 
    -0.03813788f, -0.00089686f, -0.05678049f, -0.04738788f, -0.04800497f, 0.00177241f, -0.01961919f, 0.01208597f, 
    -0.03503900f, 0.03911580f, -0.00797229f, -0.03548554f, 0.02098223f, -0.03702194f, -0.04323458f, 0.00310088f, 
    -0.01132364f, 0.02836585f, 0.02671864f, -0.00748300f, 0.00183483f, 0.03308079f, 0.01451017f, 0.02378890f, 
    0.04280872f, 0.01363724f, 0.04197748f, 0.03433072f, 0.03452842f, -0.04630744f, 0.00006295f, -0.04620147f, 
    0.02283669f, -0.04400919f, 0.02231110f, -0.02146060f, 0.02706150f, -0.02546103f, 0.00871686f, -0.03484621f, 
    -0.00636752f, -0.02213688f, -0.00687813f, 0.03200934f, -0.05045275f, 0.02200034f, -0.04133687f, 0.00614987f, 
    -0.00355380f, -0.04853957f, -0.02447490f, 0.03349595f, -0.05370127f, -0.00150442f, -0.04395631f, 0.02281988f, 
    -0.04351098f, -0.01862714f, -0.00236327f, -0.05367771f, -0.00386069f, -0.02792325f, 0.01947917f, -0.04823384f, 
    0.00627810f, -0.02358644f, -0.00046344f, 0.03129350f, -0.02258467f, 0.03718885f, 0.00375838f, -0.01600092f, 
    -0.01653462f, -0.03130183f, 0.04060889f, -0.03270584f, -0.01659101f, -0.02846862f, 0.01880437f, -0.00557395f, 
    0.00016269f, -0.01243851f, -0.02955510f, 0.02515457f, -0.05247338f, -0.01261256f, 0.02259129f, -0.04897318f, 
    0.02272882f, 0.03222706f, 0.03062262f, -0.05596216f, -0.00514539f, -0.04281460f, -0.04868508f, 0.04337556f, 
    0.03178659f, -0.01136409f, -0.00873099f, 0.02479242f, -0.02722811f, -0.00862267f, -0.04323527f, -0.02438221f, 
    0.01290802f, -0.05527251f, -0.00951222f, -0.01396257f, -0.05766702f, -0.03800675f, -0.04957879f, -0.01758473f, 
    -0.05384834f, -0.03344497f, 0.02024203f, -0.01387580f, 0.03437489f, -0.01986793f, 0.01777469f, 0.02780630f, 
    0.01287648f, -0.04883078f, 0.00626788f, 0.02533510f, -0.00795242f, -0.02580437f, 0.01412932f, 0.02093681f, 
    -0.03026968f, 0.03189677f, -0.03471986f, -0.00401553f, -0.02498174f, -0.00465056f, 0.02539158f, 0.04187868f, 
    -0.02255292f, 0.04223930f, -0.05355589f, 0.02480886f, -0.01690862f, 0.00192335f, -0.04367396f, 0.02002298f, 
    -0.00976909f, -0.00042862f, -0.04523245f, -0.02364287f, -0.03610501f, -0.00636601f, -0.03451914f, 0.02663089f, 
    -0.05846792f, -0.01820199f, -0.03295712f, 0.04176494f, -0.04588427f, 0.03889355f, -0.00972586f, -0.04857839f, 
    0.03386466f, 0.00000817f, 0.00583556f, 0.02324574f, 0.03913231f, -0.04596634f, 0.04058844f, 0.04067291f, 
    -0.01579900f, -0.04929581f, 0.02443594f, 0.01006592f, 0.02022473f, 0.02602425f, -0.00939141f, 0.03880253f, 
    -0.03016415f, -0.03343294f, -0.02730680f, -0.04689119f, 0.01446494f, -0.04511773f, -0.03318551f, 0.00277130f, 
    -0.04095951f, -0.01017072f, -0.04427243f, -0.03304385f, 0.01701764f, -0.03019343f, -0.03959591f, 0.02955744f, 
    0.01962766f, -0.05172938f, -0.05659444f, -0.02592500f, -0.03332469f, -0.04246984f, -0.02408359f, 0.01080720f, 
    -0.02634828f, -0.00206078f, -0.05724007f, 0.01249285f, -0.05420756f, 0.00756703f, -0.00569406f, -0.02038404f, 
    0.00586907f, -0.05067313f, -0.03159402f, 0.00287017f, 0.04099429f, 0.03802471f, -0.04632295f, 0.02199394f, 
    -0.02676997f, 0.02996454f, 0.03773015f, -0.00631592f, -0.02562529f, -0.00865674f, -0.01880229f, -0.03269065f, 
    0.03184790f, 0.02642705f, -0.02669958f, 0.03528100f, 0.01867103f, 0.01178742f, -0.02018178f, 0.01105705f, 
    0.01648861f, 0.00141631f, -0.05115542f, 0.00735573f, 0.04247651f, 0.02606349f, 0.00148004f, 0.00646352f, 
    -0.03501721f, -0.04497212f, 0.00900752f, -0.02978587f, 0.02168016f, 0.03076478f, -0.01320098f, 0.02203720f, 
    -0.05485917f, 0.01157906f, -0.05515224f, -0.01464684f, -0.02175787f, 0.02899433f, -0.02231297f, -0.02619390f, 
    0.01280678f, -0.06025062f, 0.11690772f, -0.03407363f, 0.09640843f, -0.09866986f, 0.13007775f, -0.10959978f, 
    0.00918588f, -0.09860989f, -0.05820565f, 0.04064527f, 0.04577600f, 0.10489863f, 0.32943788f, 0.12239095f, 
    -0.19597229f, -0.15441389f, 0.02273618f, -0.04943511f, 0.18137403f, -0.00927401f, 0.07757913f, 0.08555499f, 
    -0.12565999f, -0.28647098f, -0.27234563f, -0.11663041f, 0.25514621f, 0.03588676f, 0.10698464f, -0.00747902f, 
    0.06432223f, 0.05485085f, -0.10594328f, -0.09093355f, 0.27251938f, 0.33810592f, 0.23844756f, 0.15086524f, 
    -0.12264666f, -0.00369678f, -0.02447404f, -0.00695208f, 0.07236243f, -0.01581417f, 0.01879919f, 0.17731224f, 
    -0.34505728f, -0.19451950f, 0.01087604f, 0.04686117f, -0.03527112f, 0.05457468f, 0.02213896f, -0.01071250f, 
    0.01461790f, 0.00415299f, -0.07509403f, -0.14363328f, -0.00442258f, 0.16973445f, -0.27626419f, 0.26742378f, 
    0.13884863f, 0.13403641f, -0.18905751f, 0.00880708f, 0.02653103f, 0.10623927f, -0.03018026f, 0.12467746f, 
    0.07760341f, 0.02446496f, 0.07022011f, -0.06713062f, 0.07203579f, -0.03751705f, -0.09149457f, 0.07639692f, 
    0.09628247f, 0.06561089f, 0.06189815f, 0.04967290f, 0.08933263f, -0.12399485f, -0.11384199f, -0.03998437f, 
    -0.02691997f, -0.02952691f, -0.01345686f, 0.01497807f, 0.08526044f, 0.05466577f, 0.08787774f, -0.00766080f, 
    0.07874942f, 0.21521154f, 0.26612535f, 0.02723863f, -0.01600986f, 0.02547428f, 0.09783271f, -0.02913934f, 
    0.07926246f, -0.11816341f, 0.04934209f, 0.05749707f, -0.32489166f, 0.05840935f, -0.39636144f, -0.13360943f, 
    0.05845879f, 0.11193327f, 0.01385523f, 0.06762294f, -0.03154446f, -0.01106988f, -0.11436270f, 0.09449042f, 
    -0.08370359f, -0.19341555f, -0.10293575f, 0.08522661f, 0.06257390f, 0.08729823f, -0.02833108f, 0.02720989f, 
    0.03600496f, 0.03489163f, 0.01869206f, 0.09134367f, 0.26568747f, 0.10856000f, 0.15364535f, 0.24718963f, 
    -0.08013460f, -0.01310454f, 0.02822241f, -0.09115452f, -0.02343347f, 0.08780564f, 0.00491478f, 0.04372839f, 
    0.15802863f, -0.20617266f, -0.10048620f, -0.08025873f, 0.13280624f, -0.01160571f, -0.00220235f, 0.10737915f, 
    0.03625776f, 0.07715944f, 0.07446335f, -0.15405205f, -0.08346824f, 0.25254998f, 0.39331153f, -0.03430030f, 
    -0.14454114f, -0.15845430f, 0.02200833f, 0.00046123f, 0.04631925f, 0.11344889f, 0.04941855f, 0.09274112f, 
    -0.37610936f, -0.23943202f, -0.14721039f, -0.06880735f, -0.04260676f, 0.05694579f, -0.02970642f, 0.12365282f, 
    0.09938481f, -0.08468497f, -0.02045883f, 0.01595627f, -0.10340289f, -0.02051696f, -0.16621213f, 0.10018115f, 
    -0.04344010f, 0.02417874f, 0.04371252f, 0.03474441f, -0.08965684f, -0.02064025f, 0.01733137f, -0.01908412f, 
    -0.17723997f, -0.05595664f, 0.03973344f, 0.05405122f, 0.02350843f, 0.03751065f, -0.07872860f, -0.11731818f, 
    0.11792199f, 0.02348136f, -0.03277187f, -0.02783988f, -0.19207934f, -0.00781956f, -0.32686409f, 0.06994921f, 
    0.09029054f, 0.05329226f, -0.13333634f, 0.12145793f, 0.00820818f, -0.02765469f, 0.06024066f, -0.02043142f, 
    -0.26858920f, 0.38283280f, 0.00889625f, -0.05990237f, -0.07027231f, -0.06848487f, 0.00723496f, -0.04005197f, 
    -0.05339887f, 0.01023400f, -0.03851790f, 0.01768341f, -0.15450783f, -0.10891613f, -0.03246020f, 0.10721237f, 
    0.04450046f, -0.01278062f, 0.04654363f, 0.04581003f, 0.11070304f, 0.12813500f, 0.00755651f, 0.09429609f, 
    -0.11752070f, 0.04137980f, -0.28899005f, 0.08277266f, 0.14044403f, 0.11601638f, -0.07697810f, 0.06393997f, 
    0.12345887f, -0.03122133f, -0.04320662f, 0.08570173f, 0.17665751f, 0.02995059f, 0.12804346f, 0.07756285f, 
    -0.19461498f, 0.09516421f, -0.03116153f, -0.15016155f, -0.01187708f, 0.01024939f, -0.05254794f, -0.02829936f, 
    0.10881918f, 0.17808707f, 0.33565694f, 0.18129097f, -0.08441056f, -0.12100241f, 0.11345083f, 0.00285288f, 
    -0.05748871f, 0.09810147f, 0.12042257f, -0.00251141f, -0.03010740f, 0.38463131f, 0.32345763f, 0.01851802f, 
    -0.14601627f, -0.02954722f, -0.08473454f, 0.01238957f, 0.08114915f, 0.06749333f, 0.09741487f, 0.08240843f, 
    0.18400285f, 0.16951317f, -0.13393718f, 0.13631491f, 0.16750976f, 0.05291094f, 0.03791264f, 0.04386691f, 
    0.00143738f, 0.06082905f, 0.07969742f, 0.03337241f, -0.32333842f, -0.19820805f, -0.30763403f, -0.16405545f, 
    0.26502040f, 0.00487971f, 0.11974979f, 0.13458423f, -0.04693349f, 0.11849719f, -0.11741510f, -0.10549513f, 
    -0.16641644f, -0.16639271f, -0.24365345f, 0.09920447f, 0.07444611f, 0.16953930f, -0.04370047f, 0.17818758f, 
    0.16042624f, 0.09628460f, 0.08790088f, 0.01623568f, -0.23848088f, -0.11365364f, 0.13203876f, 0.09704535f, 
    -0.05168047f, 0.00118815f, 0.09628859f, -0.10277203f, -0.08596987f, 0.00947072f, 0.14194791f, -0.03715382f, 
    -0.08704668f, -0.37789050f, -0.16633171f, -0.35132831f, 0.18881026f, 0.08804588f, 0.10269340f, 0.07757749f, 
    0.02516096f, -0.05643690f, -0.05811325f, 0.02618216f, -0.22813897f, -0.03024048f, 0.07848144f, -0.11334557f, 
    -0.06821285f, 0.07528043f, 0.13396664f, -0.03729513f, -0.05550765f, -0.07593211f, 0.10852621f, 0.06977981f, 
    -0.13421202f, 0.02879705f, -0.00503235f, -0.04469982f, 0.08635385f, 0.03745347f, -0.12402639f, 0.03504321f, 
    0.11231560f, -0.05002372f, 0.00380939f, -0.04128072f, 0.06482905f, 0.30969730f, 0.08211593f, -0.06596427f, 
    -0.02995168f, 0.09133590f, 0.04181118f, 0.11164513f, -0.07554858f, 0.14064117f, 0.00522878f, -0.00880252f, 
    0.00227464f, -0.04096544f, -0.02142273f, 0.00948162f, -0.05523759f, -0.00859497f, -0.02966864f, 0.00571940f, 
    0.03633002f, -0.05001012f, 0.02554474f, -0.03532841f, -0.01434202f, 0.01252349f, -0.01658304f, 0.03259340f, 
    0.01563969f, -0.02397785f, 0.03208067f, -0.04140469f, -0.02071665f, 0.03870225f, 0.00705826f, -0.04171334f, 
    0.03884776f, -0.01791847f, -0.00310951f, 0.01422443f, -0.03725813f, -0.02031080f, -0.02545740f, -0.04926325f, 
    0.04167935f, -0.00963497f, -0.03391616f, -0.00312289f, 0.00232853f, -0.04476028f, -0.01614412f, -0.01553382f, 
    0.01319027f, -0.02682607f, 0.01162137f, 0.03933403f, -0.03039450f, 0.01781164f, 0.01768304f, 0.00970151f, 
    0.02954593f, -0.01205748f, 0.02453463f, 0.00966031f, 0.04941779f, 0.02313834f, -0.04271781f, -0.01588249f, 
    0.03318955f, -0.00609839f, 0.03151412f, 0.03625900f, -0.02537179f, -0.01399679f, 0.01854445f, -0.01721562f, 
    -0.02447065f, -0.02257833f, -0.02857345f, 0.00135844f, 0.03739452f, -0.00928384f, -0.02619833f, -0.02230431f, 
    0.01959856f, -0.04134865f, -0.04202779f, 0.04025956f, 0.04496646f, 0.03024228f, -0.04695570f, -0.04180814f, 
    -0.02075498f, 0.01579797f, 0.04183957f, -0.04424705f, -0.04064973f, -0.02457420f, 0.01897564f, -0.02456480f, 
    0.02767142f, -0.03568298f, -0.04196568f, 0.03478991f, -0.04280892f, -0.04573497f, -0.00575816f, 0.03265747f, 
    -0.03526729f, -0.04293032f, -0.00742854f, -0.05113173f, -0.02107140f, -0.00422921f, 0.02985402f, -0.05796706f, 
    -0.01272549f, 0.00778114f, 0.02226905f, 0.02737980f, -0.00181392f, -0.04182031f, -0.03186388f, -0.05404595f, 
    0.00398768f, -0.05110123f, -0.01613472f, -0.01537849f, 0.03526318f, -0.01164437f, -0.01270416f, -0.01257650f, 
    0.03680153f, -0.03384124f, -0.04767916f, 0.00001029f, -0.04269327f, 0.00615579f, 0.01578417f, -0.04438788f, 
    -0.01308576f, 0.01319380f, -0.05338307f, -0.04769062f, 0.03245391f, 0.02887972f, -0.03010119f, 0.02881585f, 
    -0.00134082f, -0.00845769f, -0.05215942f, 0.04257474f, -0.03166398f, 0.04682663f, 0.03399480f, -0.02777221f, 
    0.02702321f, 0.03273971f, -0.04866623f, -0.00703127f, -0.01232745f, 0.04384698f, -0.05250793f, -0.03451757f, 
    0.00456678f, 0.02609664f, 0.02825329f, -0.02860492f, 0.01971750f, -0.01698177f, -0.03128866f, -0.05127541f, 
    0.03477542f, 0.00021368f, -0.02401187f, -0.00512692f, 0.01449436f, -0.03469132f, 0.00010649f, -0.03165428f, 
    -0.06325030f, 0.00803213f, 0.01960904f, 0.04275683f, 0.03708958f, -0.01374919f, -0.04304815f, -0.03556767f, 
    0.04917216f, -0.02664883f, -0.04458990f, -0.03725310f, 0.00513772f, 0.00671641f, -0.05669795f, 0.03241899f, 
    -0.00230919f, -0.04365596f, -0.02743041f, 0.01937090f, -0.04046275f, 0.03821968f, -0.02590988f, 0.04235321f, 
    -0.04905551f, 0.02028540f, 0.01391033f, -0.04067390f, -0.01332445f, 0.01149237f, 0.03014372f, 0.01895521f, 
    0.02338375f, -0.00598022f, 0.00923254f, -0.05860386f, 0.02208544f, 0.00082030f, -0.00050996f, 0.03277132f, 
    -0.00990215f, -0.03319815f, 0.01973390f, -0.03228095f, -0.00942785f, 0.01258287f, 0.00294333f, -0.00782608f, 
    -0.01515888f, -0.03319721f, 0.04693915f, -0.05042357f, 0.01948787f, 0.02124251f, -0.02947653f, -0.03340160f, 
    -0.02982874f, 0.04131012f, 0.03668581f, 0.00554552f, -0.00101113f, -0.06018493f, 0.02670083f, -0.03303682f, 
    -0.04207962f, -0.03076612f, -0.04909544f, -0.04341304f, -0.06117890f, -0.01810111f, 0.04511193f, 0.01334897f, 
    -0.04569560f, -0.02748064f, -0.01429160f, 0.00514407f, -0.00084696f, 0.04310982f, 0.00599657f, 0.02376436f, 
    -0.03703893f, -0.02861153f, 0.02917286f, 0.04428916f, 0.00738276f, -0.03332305f, 0.00336334f, -0.03362611f, 
    -0.02986805f, 0.00835502f, -0.00327577f, -0.03858877f, 0.01285047f, -0.05125381f, -0.02485423f, 0.01390997f, 
    0.01297203f, 0.01243935f, -0.01648900f, -0.00320636f, -0.01702148f, -0.00802173f, -0.04480985f, 0.03750398f, 
    -0.01469018f, -0.01641653f, 0.03463363f, -0.03159837f, 0.00479464f, 0.02739597f, -0.04738522f, 0.03075205f, 
    0.00546023f, -0.03920974f, -0.01670881f, 0.02795948f, -0.04745705f, -0.04790642f, -0.02818885f, 0.03994035f, 
    -0.01993089f, 0.04455559f, -0.03402944f, -0.04227012f, 0.04005999f, -0.02099579f, -0.03246945f, -0.00085176f, 
    0.03129312f, 0.05425995f, 0.03971571f, 0.03532550f, -0.03798949f, -0.02260108f, -0.02906005f, 0.01677735f, 
    0.00573737f, 0.03725672f, 0.01595271f, -0.05066649f, -0.00062175f, 0.01909012f, 0.04408481f, 0.00797263f, 
    -0.02362310f, -0.05000412f, -0.02343707f, 0.04325221f, 0.00107789f, 0.00238475f, -0.02523788f, 0.01124998f, 
    -0.01121803f, 0.00828275f, 0.04870922f, 0.03330945f, 0.00514356f, -0.01147812f, 0.01277077f, -0.01467377f, 
    0.04317097f, 0.01785094f, -0.02344006f, -0.00569064f, 0.00788206f, 0.02511562f, -0.00222689f, -0.04769340f, 
    -0.01176143f, 0.00023868f, -0.00210142f, 0.02200475f, 0.02699370f, -0.05004868f, 0.04314416f, 0.01449083f, 
    0.02096516f, 0.01630483f, -0.05211282f, 0.03086623f, -0.04452879f, -0.00522685f, -0.02451911f, 0.02442736f, 
    0.04713627f, -0.03102049f, -0.05018747f, 0.03923180f, -0.04611065f, 0.02647137f, 0.04980259f, 0.01437473f, 
    0.02139376f, 0.02600812f, -0.03226924f, 0.05076553f, -0.01311080f, -0.05672488f, -0.00925864f, -0.00458679f, 
    -0.05600805f, 0.03027431f, -0.00501692f, 0.00858113f, 0.00889895f, 0.01270869f, 0.03325209f, -0.04526848f, 
    0.01256298f, 0.00647764f, 0.01572290f, -0.02398710f, -0.04177712f, 0.02268822f, 0.04215911f, 0.01640594f, 
    0.29065070f, -0.13009529f, -0.00141318f, -0.23430113f, -0.08787078f, -0.00146087f, 0.04086399f, -0.00095921f, 
    -0.05735311f, 0.08117583f, -0.04139441f, 0.13916017f, -0.11725463f, -0.09353501f, -0.03423826f, 0.21994358f, 
    -0.09104022f, 0.06804854f, -0.14228514f, 0.01955632f, -0.06723326f, 0.04968229f, -0.05039574f, -0.08618947f, 
    0.07103404f, 0.11493430f, 0.14847602f, 0.09486996f, -0.04753833f, -0.02509222f, -0.04735503f, 0.13963933f, 
    0.05105593f, 0.02465835f, 0.06335833f, 0.10832262f, -0.09016210f, -0.04948594f, -0.13203520f, 0.04421783f, 
    -0.10002479f, 0.04633527f, -0.04548543f, 0.12144417f, -0.01995388f, -0.05237230f, -0.00757336f, 0.08824074f, 
    -0.12804694f, 0.05353876f, 0.06120537f, -0.00582296f, 0.03757314f, 0.18439326f, -0.11533666f, 0.07328435f, 
    0.08491570f, 0.13291098f, -0.15519018f, 0.10733157f, -0.02542838f, -0.09185102f, -0.01566356f, 0.11759177f, 
    -0.01089694f, -0.01326312f, 0.06984560f, 0.03132250f, -0.09363922f, -0.08512175f, 0.00524065f, 0.06670245f, 
    0.01794525f, 0.04094413f, -0.09095708f, 0.08642989f, -0.05295416f, 0.04884594f, -0.04923104f, -0.10232857f, 
    0.02353696f, 0.00381695f, 0.04035675f, -0.04072516f, -0.32567519f, -0.08180456f, 0.08224779f, 0.07953960f, 
    0.03825990f, 0.06868161f, -0.09563456f, 0.07495573f, 0.12798634f, -0.01052558f, 0.08591385f, 0.07493196f, 
    0.07558376f, -0.23209749f, -0.05543388f, -0.03328103f, 0.00049479f, 0.06811333f, 0.07361141f, -0.05079289f, 
    0.09568238f, -0.03654495f, -0.04631019f, 0.02523418f, 0.36477447f, 0.25361228f, -0.06549254f, 0.06942386f, 
    -0.03525987f, 0.03332305f, -0.01387477f, 0.19368802f, 0.08535689f, -0.03087501f, -0.05041718f, -0.05070720f, 
    0.03596193f, 0.04569365f, 0.27394909f, 0.08222018f, 0.08346468f, 0.04342392f, 0.00222401f, -0.04477462f, 
    0.04053465f, 0.04993472f, 0.09757172f, -0.05782994f, 0.39347327f, -0.30656451f, -0.14191185f, 0.21063110f, 
    -0.08188425f, 0.03729395f, -0.09771101f, -0.01788912f, 0.01960933f, 0.05486502f, 0.00084737f, 0.08876728f, 
    0.15472960f, 0.23706707f, -0.18366015f, 0.31846836f, -0.06171960f, 0.13168254f, 0.09858077f, -0.09163874f, 
    -0.17968345f, 0.09134953f, 0.01208356f, -0.09245299f, -0.20526609f, 0.06650924f, 0.10055990f, -0.11314694f, 
    -0.07541790f, -0.02058113f, -0.12052763f, 0.09834269f, -0.02669707f, -0.13274001f, 0.09823219f, -0.07635760f, 
    -0.31341025f, 0.11203019f, 0.25180376f, 0.05793577f, -0.06734739f, -0.03165061f, -0.12866583f, -0.03956296f, 
    0.09920087f, 0.09574714f, -0.10611777f, 0.06115334f, -0.13387653f, -0.03256387f, -0.05102208f, -0.08159322f, 
    -0.16576140f, 0.02354685f, 0.06346004f, 0.07891615f, 0.11815452f, 0.09512936f, 0.08166597f, 0.05301443f, 
    -0.25866738f, -0.02154633f, 0.11823493f, -0.15919523f, -0.03003257f, 0.07917454f, 0.06839986f, 0.04297615f, 
    0.10698491f, -0.02418284f, -0.08262838f, 0.07333736f, 0.02697590f, 0.14695667f, -0.00534107f, 0.09506678f, 
    -0.06441567f, 0.01901478f, -0.12888934f, 0.00636368f, -0.06393746f, -0.01434924f, -0.02275498f, 0.06216870f, 
    -0.38780025f, 0.02805486f, 0.18205538f, -0.34050450f, 0.10108969f, 0.04334451f, 0.01724238f, -0.18411545f, 
    0.01739413f, -0.11433162f, -0.06296514f, 0.06451778f, 0.28584328f, 0.09528632f, 0.12176405f, 0.00994379f, 
    -0.11920422f, 0.13456608f, 0.00960858f, 0.09537254f, 0.07558851f, 0.11889838f, 0.08283366f, -0.02876179f, 
    0.14350088f, 0.09745235f, 0.09089562f, 0.13993137f, 0.06368268f, 0.00617747f, -0.00718250f, 0.10031249f, 
    0.08151843f, 0.00987245f, -0.03428818f, 0.00363527f, -0.06372647f, -0.22037092f, -0.01313069f, 0.12716411f, 
    -0.08761705f, -0.07279347f, -0.07836352f, 0.02031321f, 0.06330482f, 0.04343056f, 0.00898275f, -0.04327876f, 
    -0.05634049f, -0.00643054f, 0.06181424f, 0.15686737f, -0.07796499f, -0.04094980f, 0.06390694f, -0.04691366f, 
    -0.07139938f, 0.00698048f, -0.10248130f, 0.03040171f, -0.39490175f, 0.02104388f, 0.03410434f, 0.07762607f, 
    0.07256740f, -0.04714163f, -0.18765426f, 0.03723112f, 0.01113368f, -0.03124879f, -0.04317788f, -0.05841591f, 
    0.24617068f, 0.16463582f, -0.05946409f, -0.00550385f, 0.02200052f, 0.03297863f, 0.13692182f, -0.07318775f, 
    -0.02606417f, -0.09499352f, 0.02208990f, 0.04215491f, -0.18386388f, 0.16742541f, 0.40153706f, 0.10596707f, 
    0.14328608f, -0.10942086f, 0.01431597f, 0.18045203f, -0.05263768f, 0.10993922f, -0.13723904f, 0.01501107f, 
    0.05918393f, -0.13994689f, 0.00958369f, 0.06974594f, 0.01622257f, -0.06060208f, -0.08219784f, -0.06160257f, 
    -0.04286372f, 0.04794589f, -0.06218772f, -0.04822515f, 0.12598239f, -0.08895344f, 0.09348306f, 0.04880996f, 
    -0.03611506f, 0.15246342f, -0.00193018f, -0.05139540f, -0.10953728f, -0.04251137f, -0.01809287f, 0.07487682f, 
    0.21476384f, 0.01618107f, 0.15859017f, -0.02075474f, 0.06537036f, -0.00847787f, 0.05261007f, 0.04864010f, 
    -0.04995264f, 0.05617589f, 0.05616307f, 0.02288115f, -0.06566104f, -0.14457946f, 0.09926749f, -0.10635764f, 
    -0.09048210f, 0.10967395f, 0.11297477f, 0.07814129f, -0.12002663f, 0.03194768f, 0.10586047f, -0.02667191f, 
    -0.08606815f, 0.16864726f, 0.13560380f, -0.06984419f, -0.07528570f, 0.04106580f, -0.02781376f, 0.24232295f, 
    0.02565028f, 0.06693592f, -0.12268397f, 0.04196957f, -0.02458048f, -0.01410071f, -0.08455321f, 0.03404839f, 
    0.04690003f, 0.06872526f, 0.11844860f, 0.01848771f, 0.08799081f, 0.06673470f, 0.07768616f, 0.07819008f, 
    -0.02112252f, -0.03645105f, -0.01767551f, -0.01073474f, -0.03990261f, -0.01839809f, -0.01133194f, -0.03163689f, 
    -0.00163728f, -0.03790377f, -0.02893216f, 0.00013295f, -0.01645088f, 0.02725050f, -0.02240936f, 0.00010939f, 
    0.00718482f, -0.03441885f, -0.01384197f, -0.00715163f, -0.01181582f, -0.03673096f, -0.03266648f, 0.02941947f, 
    -0.02451351f, -0.00716125f, 0.01303628f, -0.05610313f, -0.02553847f, -0.02481948f, 0.02765832f, -0.00457958f, 
    0.04943617f, -0.01322221f, 0.02036930f, -0.00264345f, -0.03493414f, 0.03328770f, -0.03331569f, -0.00710740f, 
    -0.03871924f, 0.00505861f, -0.01901136f, -0.04110041f, -0.04071826f, 0.03726402f, -0.03491218f, -0.03850909f, 
    -0.03982966f, -0.02418648f, -0.01593258f, 0.02688094f, -0.03343884f, -0.04375543f, 0.02190335f, -0.04923893f, 
    0.04217938f, 0.01650904f, 0.02546927f, -0.04901259f, 0.02782062f, 0.04025301f, 0.02159716f, 0.02545963f, 
    -0.03664579f, 0.03677395f, -0.04211482f, -0.00978915f, -0.04514380f, 0.01237720f, -0.02683534f, 0.00687630f, 
    0.04665479f, 0.04004449f, -0.02155881f, 0.03592351f, 0.04397373f, -0.04857221f, -0.00467352f, 0.01597662f, 
    -0.00266012f, -0.02867007f, -0.01090263f, -0.04720174f, 0.02105082f, -0.03887224f, 0.01291353f, 0.00349147f, 
    0.00427486f, -0.01428285f, -0.05439092f, -0.00209397f, 0.03739725f, 0.01852683f, -0.02891488f, 0.02230821f, 
    -0.00578975f, 0.01110757f, 0.03608668f, -0.02404947f, 0.00494148f, 0.01562640f, 0.02990116f, 0.03863151f, 
    -0.00241496f, 0.00105926f, 0.02645854f, 0.01295210f, -0.02559247f, 0.03932119f, 0.02434461f, 0.04496404f, 
    0.04062873f, 0.01727891f, 0.01711080f, 0.02813112f, -0.04042391f, 0.00193452f, 0.02456627f, -0.02588766f, 
    -0.04006035f, -0.02055006f, 0.03119024f, -0.02862319f, -0.02624705f, -0.03619546f, -0.04291696f, -0.01522487f, 
    -0.04147240f, 0.03851985f, -0.05274485f, 0.02636897f, -0.01404894f, 0.03682089f, 0.03750242f, -0.00640456f, 
    -0.03563364f, 0.05393342f, -0.02661246f, -0.01744388f, -0.02471255f, 0.00427551f, -0.04001832f, -0.01488734f, 
    0.01005351f, 0.01963167f, 0.01647617f, 0.04547551f, -0.04223081f, 0.01773796f, 0.02447047f, -0.02458650f, 
    -0.02912674f, 0.01475811f, 0.04012666f, 0.03149271f, -0.02132427f, 0.02990728f, 0.00076835f, 0.00021107f, 
    0.03873933f, 0.01778683f, 0.03035299f, -0.03752146f, 0.00228787f, -0.00282678f, 0.04429985f, -0.01199771f, 
    0.00456508f, 0.01865455f, 0.00912075f, -0.02477648f, -0.02915374f, -0.02272338f, -0.00222574f, 0.01721179f, 
    0.01113432f, 0.04257863f, -0.01684674f, 0.00182649f, -0.04778622f, 0.02930778f, -0.04343277f, 0.02810154f, 
    -0.03596583f, 0.02634360f, 0.04067601f, -0.03701951f, -0.03273514f, 0.00316824f, 0.01227587f, 0.00289123f, 
    -0.02824370f, -0.05221390f, -0.01563432f, 0.03639036f, 0.02772898f, -0.04340095f, -0.01152237f, -0.00952831f, 
    -0.01175096f, -0.05127239f, -0.05044821f, 0.02860172f, 0.01737498f, -0.03481656f, -0.01564104f, 0.00600497f, 
    0.01653698f, -0.00989974f, -0.03615057f, -0.04701357f, 0.00141386f, 0.05086130f, -0.03404118f, -0.01229017f, 
    0.04174421f, -0.04611038f, 0.01291238f, 0.01202616f, 0.00637553f, 0.05278945f, 0.02337170f, 0.04855490f, 
    0.02801500f, -0.03864758f, -0.02305991f, -0.02620595f, 0.01944475f, 0.00989511f, -0.00743358f, 0.03463776f, 
    0.00515584f, 0.03532617f, -0.01688761f, -0.04404011f, 0.01347843f, -0.04948781f, 0.03525572f, 0.02910710f, 
    -0.02029589f, 0.00835445f, 0.02732188f, 0.03492229f, 0.01174573f, 0.00187871f, -0.00353795f, 0.01144187f, 
    0.01545307f, -0.04296747f, -0.02339033f, 0.00633023f, 0.00375927f, 0.01682092f, -0.04045382f, 0.02538628f, 
    0.00081992f, 0.01466640f, -0.05414990f, -0.03370461f, 0.04462292f, -0.01058001f, -0.04590315f, -0.05028278f, 
    0.00964472f, -0.01193697f, 0.01442405f, -0.03045580f, 0.02108687f, -0.01639285f, -0.04662439f, 0.04205559f, 
    0.04225407f, -0.01460609f, 0.01541303f, -0.03924949f, 0.04960766f, 0.01511940f, -0.03731313f, -0.03963629f, 
    -0.02901828f, -0.00591716f, -0.05144652f, 0.00020417f, -0.05156423f, 0.03529612f, -0.01801190f, -0.04953774f, 
    0.01300297f, 0.04667772f, -0.04794389f, -0.00446059f, 0.04594614f, 0.01592094f, -0.01870470f, 0.03898489f, 
    -0.04029096f, -0.03847189f, -0.04347655f, -0.03760010f, 0.02528583f, -0.03152039f, 0.00281572f, 0.01176132f, 
    0.00626254f, 0.02373221f, 0.00570576f, -0.03458321f, -0.03201460f, -0.03857299f, -0.03152798f, 0.02571418f, 
    0.00108653f, 0.05044980f, 0.03269380f, 0.01180282f, 0.00824177f, -0.02651509f, 0.02907187f, 0.02521118f, 
    0.02975115f, 0.00789757f, -0.03232844f, 0.04799423f, -0.01402364f, -0.00793772f, -0.00562375f, 0.01152004f, 
    -0.01976282f, -0.01279054f, 0.00798774f, -0.04063946f, -0.04401729f, -0.05652186f, -0.00649696f, -0.02884710f, 
    0.03440259f, -0.04008541f, -0.00128815f, 0.03224994f, 0.01739576f, 0.04456872f, -0.05348430f, 0.00549465f, 
    -0.02838255f, 0.02301054f, -0.00231246f, -0.03660249f, -0.02070758f, 0.02639609f, 0.00719558f, 0.02089098f, 
    -0.01998219f, -0.02293144f, -0.04752462f, 0.01923631f, -0.04698168f, -0.00038789f, -0.02883510f, 0.03304452f, 
    -0.05002796f, 0.03900032f, -0.00244468f, 0.04039279f, 0.02990503f, -0.03970672f, -0.04426973f, -0.00605984f, 
    -0.00286475f, 0.03787306f, 0.00210347f, 0.03087786f, 0.01432243f, 0.04304457f, 0.02772504f, -0.01670141f, 
    -0.02847964f, 0.03232483f, 0.03636224f, -0.04263960f, 0.01300978f, 0.00020882f, -0.03263192f, -0.02226662f, 
    0.05272255f, -0.10804471f, -0.09076288f, 0.24218924f, -0.03459006f, 0.01655351f, -0.01876185f, 0.07441918f, 
    0.00953571f, -0.06079514f, -0.04717607f, -0.02452771f, -0.26147056f, 0.05970483f, -0.10848260f, -0.11563107f, 
    0.16142234f, -0.01910217f, 0.05209436f, -0.12773326f, -0.05506526f, -0.01375680f, -0.04923927f, 0.02174101f, 
    -0.18368076f, 0.03446999f, 0.14153758f, 0.21930628f, -0.22026083f, 0.05193251f, 0.10570866f, 0.11669142f, 
    -0.02502576f, 0.03625008f, 0.10424736f, -0.07831383f, -0.16519585f, 0.06249786f, 0.15543920f, -0.16802654f, 
    0.21767493f, 0.03050232f, -0.09003630f, -0.05104066f, -0.08921389f, 0.06674596f, 0.08415793f, -0.06237314f, 
    0.21942201f, 0.06112655f, 0.14001633f, -0.20345362f, 0.17801727f, -0.02782823f, 0.05065501f, -0.00712226f, 
    0.04784707f, -0.03579278f, 0.06924161f, -0.00216356f, 0.43741137f, -0.21166374f, 0.05329626f, -0.15611377f, 
    -0.08253267f, -0.03149961f, 0.00940913f, 0.06555913f, 0.02143428f, 0.02614724f, 0.03327217f, 0.06213467f, 
    0.08040544f, -0.09116115f, -0.10235130f, 0.02812969f, -0.03642606f, -0.04232748f, -0.00748835f, 0.11028942f, 
    -0.06939731f, -0.08071521f, 0.14383014f, 0.01990999f, 0.00491670f, 0.03917149f, 0.08239205f, 0.21256453f, 
    0.18258908f, 0.04217082f, 0.05223906f, 0.14004366f, -0.01341613f, -0.07346810f, 0.01307283f, 0.12009667f, 
    -0.19857088f, -0.03721168f, 0.09802229f, 0.15477911f, 0.03159559f, 0.08653805f, 0.05129919f, 0.03650919f, 
    -0.07300645f, 0.12309115f, -0.04739713f, -0.08316261f, 0.26219615f, -0.06369094f, 0.13976832f, -0.03927714f, 
    -0.09368812f, -0.03992737f, 0.09708197f, -0.06107556f, 0.01023986f, 0.09050103f, 0.05351417f, 0.02686356f, 
    0.22390281f, -0.02704758f, 0.06891751f, 0.02492273f, 0.03382211f, -0.08104733f, 0.00449987f, 0.02410992f, 
    0.00449640f, -0.06981853f, 0.00412872f, 0.08279504f, -0.16332944f, -0.00860284f, -0.01578563f, -0.11391389f, 
    0.10341907f, -0.01179554f, 0.06524774f, -0.05734700f, 0.07757979f, 0.10775120f, 0.04264003f, 0.07224791f, 
    -0.06724976f, 0.03563033f, 0.13304728f, -0.29557890f, 0.01503917f, -0.04141288f, 0.08768540f, -0.03940674f, 
    0.03166481f, -0.03190166f, 0.07293978f, 0.03564790f, -0.05863219f, 0.03794944f, -0.12923194f, 0.17265394f, 
    0.17568584f, 0.05309166f, -0.05915819f, -0.08966593f, -0.02501002f, -0.04723189f, 0.00519688f, -0.04433079f, 
    0.43144223f, 0.04859221f, 0.13001168f, -0.15644348f, 0.10562199f, 0.07790868f, 0.15117691f, -0.03734951f, 
    -0.01155857f, 0.02965528f, -0.02356737f, -0.02164956f, -0.00021618f, -0.08175126f, 0.25161359f, 0.16864824f, 
    0.11934922f, -0.02004438f, -0.03433540f, 0.13911819f, -0.02372560f, 0.07243320f, 0.03016289f, 0.12769927f, 
    -0.11426196f, 0.04827056f, -0.03647185f, -0.11242624f, 0.00907864f, -0.04781134f, 0.00196988f, 0.02733630f, 
    -0.15153219f, -0.13820371f, -0.09743668f, -0.02981135f, 0.56020546f, -0.14912365f, 0.22962764f, -0.20711280f, 
    -0.00011745f, 0.00751001f, 0.09844290f, 0.05660766f, -0.00716266f, 0.12826942f, -0.06903461f, 0.04055652f, 
    0.30382761f, -0.14330561f, 0.08260017f, 0.21706466f, 0.06523103f, -0.01133156f, -0.00159325f, -0.02032287f, 
    0.00752857f, 0.13656262f, 0.00305682f, 0.02835671f, -0.11019091f, -0.03210553f, -0.14175446f, -0.00208867f, 
    0.00002424f, -0.02937506f, 0.04846488f, 0.05152416f, 0.02830925f, -0.01972584f, 0.02727149f, -0.09677672f, 
    0.09470072f, -0.09887741f, -0.04736434f, -0.06888603f, -0.07409563f, -0.07505263f, -0.13307978f, 0.01274461f, 
    0.03656387f, -0.03013195f, 0.05253357f, 0.06557448f, -0.11817190f, -0.01576397f, 0.07170755f, -0.18972363f, 
    0.07779711f, 0.03414286f, 0.15296011f, -0.04391829f, -0.07439513f, -0.04104140f, 0.06035971f, 0.01137884f, 
    -0.32692328f, 0.06345921f, 0.01260081f, -0.20490757f, 0.24340974f, 0.08841746f, -0.01139583f, -0.02921894f, 
    0.17372265f, -0.01044781f, 0.12210495f, 0.06438161f, -0.12352608f, -0.18831161f, 0.05444099f, 0.04015949f, 
    0.03817829f, 0.09864343f, -0.12008915f, 0.03023798f, 0.09749197f, -0.01054868f, 0.03143499f, -0.06240231f, 
    0.34718111f, 0.01235998f, -0.22168379f, -0.13318504f, -0.09991569f, -0.00073914f, -0.01200669f, 0.06898885f, 
    -0.03476933f, 0.10639625f, 0.08710828f, 0.04622552f, 0.07363194f, 0.08805225f, 0.06619366f, 0.29681182f, 
    -0.12635563f, -0.00818280f, -0.07201122f, 0.02933208f, -0.03387108f, -0.06555308f, 0.07475516f, 0.08373285f, 
    0.41151908f, 0.06853174f, 0.10794261f, -0.07990764f, -0.09710637f, 0.04696956f, 0.01001407f, -0.01891617f, 
    -0.15348549f, -0.08727662f, -0.09525772f, 0.09521113f, -0.14832978f, 0.08218660f, -0.12088056f, -0.14093505f, 
    -0.02424300f, 0.07392963f, -0.02474977f, -0.03026489f, 0.12221048f, 0.02836640f, 0.10961203f, 0.07652814f, 
    -0.21851441f, 0.14037186f, 0.09305144f, 0.51446486f, -0.16041927f, 0.00087806f, -0.05668014f, 0.04903586f, 
    0.06603187f, 0.01975273f, -0.11301029f, -0.02274067f, -0.08003344f, 0.11619437f, -0.09826660f, 0.19175111f, 
    0.00018374f, 0.02451543f, -0.00697139f, 0.01860620f, 0.18851703f, 0.05155868f, 0.03832773f, -0.09339764f, 
    -0.06252492f, -0.00053610f, -0.00083890f, -0.03877755f, -0.03036587f, -0.00657830f, 0.09426700f, 0.12700343f, 
    0.13672732f, 0.16890202f, 0.26410115f, 0.03233117f, -0.00528084f, -0.10746853f, -0.06703166f, -0.02673382f, 
    0.05317610f, 0.03208154f, -0.02608188f, 0.00914495f, -0.04369628f, -0.00186124f, -0.10622186f, 0.07522921f, 
    0.01002428f, 0.22764328f, -0.14795004f, 0.07346186f, 0.04570066f, -0.01712077f, 0.05148344f, -0.00542659f, 
    -0.02305169f, 0.05855461f, 0.03303589f, 0.02029825f, 0.14692920f, 0.02282465f, -0.10575576f, 0.13187064f, 
    0.11049060f, 0.09128321f, -0.04358161f, -0.02798457f, -0.07471253f, 0.15689127f, 0.10294697f, -0.03976949f, 
    0.20001911f, 0.10425070f, 0.02884223f, 0.05665367f, -0.14396195f, 0.04984758f, 0.00553752f, -0.04229174f, 
    -0.06532371f, 0.08261786f, -0.04617631f, -0.01687788f, 0.04266697f, -0.04487047f, -0.06577083f, 0.03255188f, 
    -0.06441608f, -0.11430736f, 0.01862057f, -0.03006026f, 0.07627357f, -0.04723030f, -0.01543936f, -0.05768286f, 
    0.37356448f, 0.01221226f, -0.10219408f, -0.02979035f, -0.00880302f, -0.11734283f, 0.06468930f, -0.04772239f, 
    0.12175567f, 0.00809309f, -0.07118250f, 0.03826126f, 0.04124641f, -0.02491184f, 0.28119746f, -0.13728802f, 
    0.10886128f, -0.05697837f, -0.00678860f, -0.06568018f, -0.01568792f, 0.10563878f, 0.05122831f, 0.22780612f, 
    0.02464720f, -0.29286253f, -0.04411938f, 0.10560334f, -0.05229216f, 0.02300887f, 0.07067547f, -0.01564014f, 
    0.01596640f, -0.07407834f, -0.06590641f, -0.01795232f, -0.27693045f, 0.00939848f, 0.06097315f, -0.12791219f, 
    0.00090808f, -0.15332985f, -0.06819420f, -0.03396320f, -0.02326477f, 0.05478555f, 0.01960925f, 0.02370898f, 
    0.00213428f, -0.06162547f, 0.04999077f, 0.01313142f, -0.01959518f, 0.03156710f, -0.00549923f, 0.00879281f, 
    -0.04389706f, -0.03006534f, -0.04810304f, 0.09003425f, 0.13981777f, -0.01482605f, 0.29527619f, -0.10524680f, 
    -0.05587772f, 0.00032377f, -0.07976267f, 0.03816194f, 0.01294887f, 0.03925447f, 0.11372364f, 0.01527048f, 
    0.01639832f, 0.18981767f, 0.05431236f, -0.04251702f, -0.12208565f, 0.08438174f, 0.06571704f, -0.02022898f, 
    0.00797343f, -0.06318533f, -0.03629484f, -0.11038348f, -0.10151950f, -0.02578743f, 0.04478639f, -0.00178654f, 
    -0.00675789f, 0.03117903f, 0.00378798f, 0.05672928f, 0.03153900f, 0.01357596f, 0.11419659f, -0.05730788f, 
    0.33919165f, -0.28495759f, 0.10756623f, -0.01488085f, -0.09178714f, 0.09230865f, 0.03423519f, -0.00283637f, 
    0.11598161f, 0.04728009f, 0.00117921f, 0.01183085f, 0.11924975f, -0.13935165f, -0.15777516f, 0.19644740f, 
    0.03907863f, 0.02263172f, 0.03950614f, 0.02707799f, 0.09396688f, -0.01733157f, -0.04652444f, -0.03516173f, 
    -0.00067608f, 0.28324282f, 0.05205758f, 0.00189214f, 0.06896509f, 0.12177271f, -0.03768101f, -0.09749146f, 
    0.04732379f, 0.03094881f, 0.08673877f, 0.07399130f, 0.11878011f, 0.06967665f, -0.02639239f, 0.07937200f, 
    0.01629509f, -0.03221941f, 0.00801320f, -0.08135723f, 0.10086443f, 0.10639051f, -0.07744169f, 0.09815260f, 
    0.28591490f, 0.10443214f, -0.24565125f, 0.09295777f, 0.06168012f, -0.13831006f, -0.01503611f, 0.00686699f, 
    -0.01929924f, -0.08782562f, 0.06854700f, -0.09483577f, 0.37273097f, -0.15930653f, 0.47294140f, 0.09826098f, 
    0.05572740f, 0.00656467f, 0.15199080f, -0.17021316f, 0.11761069f, 0.05596665f, 0.13988952f, 0.05938081f, 
    0.12724587f, 0.03587146f, 0.07664301f, 0.18086070f, 0.17302744f, -0.06213234f, -0.07133356f, 0.15293635f, 
    0.04611609f, 0.00581345f, 0.02794318f, 0.03203244f, -0.07988521f, 0.02128525f, -0.06913761f, -0.11315449f, 
    -0.01804524f, 0.05116120f, -0.08933746f, 0.08176839f, 0.01721561f, -0.02652609f, 0.02975399f, -0.07994203f, 
    -0.08601822f, -0.24259317f, 0.14563252f, -0.08067572f, -0.15605386f, 0.07339964f, -0.11545540f, 0.10783688f, 
    -0.07095335f, -0.04973967f, 0.04906054f, -0.05110749f, 0.06096773f, 0.01068471f, -0.18717124f, 0.04503376f, 
    0.13614438f, -0.06368840f, -0.11939636f, 0.05106601f, 0.01418008f, 0.22802702f, -0.08588047f, 0.01304550f, 
    0.07803157f, -0.08024490f, -0.12790576f, -0.04878694f, -0.05404396f, 0.06559023f, 0.03001210f, -0.01734204f, 
    0.09236065f, -0.02983263f, 0.17061950f, -0.05730631f, 0.25388438f, -0.28504157f, -0.16710377f, 0.01436346f, 
    0.16142368f, -0.11592879f, 0.03450174f, -0.09246087f, 0.07339165f, 0.02482429f, 0.00020488f, -0.01550253f, 
    -0.17530474f, -0.00729420f, 0.00032539f, -0.14444070f, -0.04074716f, -0.01181723f, -0.03963876f, 0.00426266f, 
    -0.06168639f, 0.02049880f, 0.02113308f, -0.06765702f, 0.00284273f, -0.00392506f, 0.06106337f, 0.08863808f, 
    -0.11285114f, -0.07782204f, 0.01549317f, -0.18025343f, -0.14786744f, 0.01422981f, -0.04056781f, 0.03377444f, 
    -0.02800064f, 0.02988524f, 0.16109750f, 0.04574570f, 0.03671904f, -0.04532988f, -0.05673328f, 0.08252900f, 
    -0.23559657f, -0.06597246f, -0.06302116f, -0.09778448f, 0.08201491f, -0.08381267f, 0.01542942f, -0.05764581f, 
    0.07705255f, 0.00392241f, 0.03292993f, -0.06561521f, 0.21690695f, 0.03522031f, -0.06668646f, 0.08946054f, 
    -0.03378270f, 0.18956569f, 0.13743193f, -0.07270542f, 0.04117928f, 0.03599909f, 0.07519467f, -0.06302331f, 
    -0.06356486f, 0.00735835f, -0.02424232f, -0.03058470f, 0.22232929f, -0.07438224f, -0.30164975f, 0.09460574f, 
    -0.01361591f, 0.06764263f, -0.13725333f, 0.08827654f, 0.03948760f, 0.08927143f, 0.00829544f, 0.00659249f, 
    0.16223572f, -0.04552295f, -0.05900653f, -0.05632078f, 0.08322871f, -0.08486223f, -0.03496618f, 0.00342547f, 
    -0.07201044f, 0.05056375f, 0.08095337f, 0.05447195f, 0.09519963f, -0.08973458f, -0.16432486f, 0.09830477f, 
    -0.02479746f, -0.01918779f, -0.01718492f, -0.06068071f, 0.06974235f, -0.09716120f, 0.07631429f, 0.14004342f, 
    0.02021094f, 0.01024173f, 0.00153305f, 0.03882098f, 0.01887947f, -0.00717337f, 0.02570389f, 0.03399681f, 
    0.00412069f, -0.01401769f, -0.01266409f, -0.00892717f, -0.00416742f, -0.02641366f, 0.01740777f, -0.02183077f, 
    -0.05266147f, -0.04494000f, -0.00044941f, -0.04503362f, -0.00786624f, 0.00843627f, 0.01570534f, -0.00417322f, 
    -0.00807253f, -0.04898862f, -0.01873043f, 0.00173986f, 0.03216174f, 0.01112495f, 0.03656725f, -0.03791829f, 
    -0.00833481f, -0.04264199f, -0.05064639f, -0.03227409f, -0.04158045f, -0.02124546f, 0.01084873f, 0.00676777f, 
    -0.03389013f, 0.00051844f, 0.02749004f, -0.05703920f, 0.01353956f, 0.00035945f, -0.03023574f, -0.01215351f, 
    -0.01276937f, -0.00557048f, 0.02013007f, -0.01931515f, -0.05499577f, 0.02378220f, -0.02593544f, -0.02693760f, 
    0.01113383f, -0.02885967f, -0.05476740f, -0.00197153f, 0.02794372f, 0.01203127f, 0.00108537f, -0.01336382f, 
    -0.06014289f, -0.00041433f, -0.01166695f, -0.00252340f, -0.04132612f, -0.00859021f, -0.04216294f, -0.02862592f, 
    0.04787991f, -0.03742188f, -0.03034138f, 0.03160076f, -0.01280185f, 0.02468336f, 0.03240655f, -0.03201604f, 
    0.02832052f, -0.03429344f, -0.04213233f, 0.03188357f, 0.00462264f, 0.02241698f, 0.00335028f, -0.02601250f, 
    -0.01179367f, 0.02137893f, -0.00372485f, -0.02551269f, -0.04701276f, -0.02237678f, 0.01904332f, -0.00833256f, 
    0.02880260f, 0.03222332f, -0.02130176f, 0.01650200f, 0.03427052f, -0.04294595f, -0.00707373f, -0.04621958f, 
    -0.02853544f, 0.01848034f, -0.02954438f, -0.02336901f, 0.00299849f, -0.02135641f, 0.00468481f, 0.03760967f, 
    0.01578728f, 0.03739038f, 0.03571226f, 0.02764632f, -0.01005113f, 0.00814098f, 0.03569067f, 0.03273351f, 
    -0.03048711f, -0.02522108f, 0.00256767f, -0.05448299f, -0.00180626f, 0.03659403f, -0.01987056f, 0.03795245f, 
    0.01631563f, -0.03958286f, -0.04634421f, -0.05850418f, -0.03507442f, 0.02469991f, -0.02701868f, -0.01787412f, 
    -0.01390385f, -0.05369614f, 0.01260997f, 0.01832574f, -0.04977292f, 0.02079665f, -0.00659206f, 0.00073495f, 
    0.01839621f, -0.04284893f, 0.00669344f, 0.03699150f, 0.03136468f, -0.04599871f, -0.02069195f, 0.01393956f, 
    -0.03705236f, 0.02643615f, 0.00462264f, -0.05128587f, -0.02032736f, -0.02871123f, -0.01266750f, 0.03456212f, 
    0.02748752f, -0.03841133f, -0.02699628f, -0.03427173f, -0.03408056f, 0.00983464f, 0.02664689f, -0.04970697f, 
    0.02409839f, 0.01339234f, 0.02652915f, -0.03327796f, -0.03260631f, -0.01699204f, -0.04369723f, -0.00818690f, 
    0.02256687f, -0.03085777f, 0.00501315f, -0.03605942f, -0.04689948f, 0.00421698f, -0.00126016f, 0.03616219f, 
    0.02772723f, -0.03295612f, 0.01562649f, 0.03312525f, -0.04605214f, 0.03656715f, -0.04181825f, -0.02157232f, 
    0.01847872f, -0.04064817f, 0.02280615f, -0.01350974f, -0.05415579f, -0.01845562f, -0.04233262f, -0.04659422f, 
    0.01401150f, -0.02414927f, 0.00793409f, 0.02179150f, -0.01151764f, 0.00654006f, -0.00966928f, 0.00617388f, 
    -0.04900836f, -0.02503522f, -0.03885422f, -0.03921388f, 0.01890628f, -0.03287796f, -0.05063950f, 0.01326105f, 
    0.01836137f, -0.01236235f, 0.01771342f, -0.01569589f, -0.02330478f, -0.05156562f, -0.01214125f, -0.04638077f, 
    0.00332126f, -0.02860419f, -0.02972839f, -0.03282616f, 0.01121002f, 0.02820048f, -0.02822378f, 0.01218336f, 
    -0.02562102f, -0.05154067f, 0.00295493f, 0.00753573f, 0.00164519f, 0.01432177f, -0.00221159f, -0.03893782f, 
    -0.04235888f, -0.00822824f, 0.01067497f, -0.02433536f, -0.02530255f, -0.02761254f, -0.02446612f, 0.00757104f, 
    -0.02658157f, 0.01566945f, 0.01300425f, 0.01776831f, -0.00069196f, -0.01533345f, 0.00513577f, -0.01746057f, 
    0.01574682f, 0.01932208f, -0.05819236f, -0.03029007f, -0.02083697f, -0.04171107f, -0.01287831f, 0.01957877f, 
    -0.05845367f, -0.01896460f, -0.05582201f, -0.02377057f, -0.05586416f, -0.02736356f, -0.00469939f, -0.05648501f, 
    -0.02528278f, 0.01108428f, -0.00489628f, -0.01660524f, -0.04921403f, -0.02136236f, -0.03584559f, -0.03681608f, 
    -0.05989054f, 0.03279460f, -0.04088020f, 0.00976967f, 0.03677544f, -0.03306783f, -0.00647312f, -0.00855562f, 
    -0.01099715f, -0.03786370f, 0.01005037f, -0.01579327f, -0.04483956f, -0.02842821f, -0.01449077f, -0.05677449f, 
    -0.02537846f, 0.00822185f, 0.00641901f, -0.01963296f, 0.00308330f, 0.02083175f, 0.01346840f, -0.00471421f, 
    0.01885119f, -0.01304161f, -0.05865529f, 0.04161588f, 0.01252752f, -0.04770425f, 0.03194387f, 0.01569703f, 
    0.03609214f, -0.00627632f, -0.05228954f, 0.00713135f, 0.01151042f, 0.02746711f, 0.03813007f, -0.02724991f, 
    -0.00679391f, -0.02109744f, -0.06111337f, 0.04401504f, 0.03652027f, 0.02897552f, -0.03754564f, -0.02185700f, 
    0.00731777f, -0.04148362f, -0.00276456f, -0.05592270f, 0.02528865f, -0.03698445f, -0.06140890f, 0.01305163f, 
    -0.03996671f, 0.01805592f, -0.03955127f, 0.03856126f, -0.00970264f, -0.03283547f, 0.02588130f, -0.00728462f, 
    -0.01500511f, 0.00216622f, 0.02630288f, -0.00180715f, -0.05868105f, 0.03670371f, 0.00767806f, 0.01381996f, 
    -0.00877031f, -0.04276499f, 0.00320950f, -0.01352331f, -0.03963608f, -0.02920624f, 0.03484494f, -0.01159374f, 
    -0.04757655f, 0.02053543f, 0.00085428f, -0.02132322f, 0.03046273f, 0.01042328f, 0.02630469f, 0.01983425f, 
    -0.03454566f, -0.03553278f, -0.00463541f, -0.02485540f, -0.01948052f, 0.02989412f, -0.05147803f, 0.03336063f, 
    -0.04572270f, -0.04873863f, -0.00105254f, -0.02838444f, -0.00370589f, -0.06028247f, 0.01734087f, -0.00072590f, 
    0.27320832f, -0.11678723f, -0.13640530f, -0.13157727f, -0.06310470f, -0.04181612f, -0.09039791f, -0.02199082f, 
    0.05487102f, 0.03716639f, -0.00417004f, 0.02801562f, -0.14008458f, -0.15331045f, 0.00353308f, 0.10394254f, 
    -0.10965497f, 0.01338739f, -0.01103903f, -0.01796751f, 0.01888239f, -0.12724659f, 0.03101501f, -0.01173479f, 
    -0.20988280f, 0.14736547f, 0.05006324f, 0.22438331f, 0.16850421f, -0.02741434f, -0.01318096f, -0.01116515f, 
    0.08572104f, 0.00873666f, 0.03570504f, -0.06330092f, 0.25050023f, 0.12656642f, 0.06305173f, 0.08913454f, 
    0.06523655f, 0.00436790f, -0.05327168f, 0.01129491f, -0.02984044f, -0.00806570f, 0.12245815f, 0.04891210f, 
    -0.18837826f, -0.14139143f, 0.03091476f, -0.00171074f, -0.02200114f, 0.07763508f, -0.07812423f, 0.01861420f, 
    0.03325024f, -0.10376722f, -0.01294095f, 0.08618504f, -0.01294923f, -0.15034527f, -0.10468842f, -0.00656477f, 
    -0.01620553f, 0.03735219f, -0.04725917f, 0.04837697f, -0.01892235f, 0.05686812f, -0.09061151f, -0.20709708f, 
    0.11869786f, 0.22425719f, -0.09000893f, -0.00197388f, 0.02341771f, -0.00311870f, -0.16077611f, 0.02323276f, 
    0.07428397f, 0.01059045f, -0.01913154f, -0.00651564f, 0.12884790f, -0.03815447f, -0.07068876f, 0.08398538f, 
    -0.04790486f, -0.02253084f, -0.03484972f, -0.00781977f, 0.07719681f, 0.08368107f, -0.12546124f, -0.01548169f, 
    0.34391049f, 0.07291626f, -0.02719919f, -0.00486694f, 0.10336793f, -0.06309261f, -0.01266823f, -0.12071387f, 
    0.05253025f, 0.00572930f, 0.01808799f, -0.04766681f, -0.20135911f, 0.03992201f, -0.05987207f, 0.08906224f, 
    0.04309303f, 0.04817591f, 0.10665948f, -0.09231462f, -0.08210924f, -0.09998654f, -0.06589443f, 0.02005525f, 
    0.08485614f, -0.09846367f, 0.01483764f, 0.09060740f, 0.08600315f, -0.12859635f, 0.13643928f, 0.03358239f, 
    0.07902174f, 0.08757886f, -0.05157400f, 0.14830500f, 0.40695772f, -0.15175371f, -0.02247958f, 0.24012698f, 
    -0.01299958f, -0.09716727f, -0.11401443f, -0.06884946f, 0.03281024f, 0.03216977f, -0.06756769f, -0.02860618f, 
    -0.01867398f, 0.45799685f, -0.02328042f, 0.19378452f, 0.07941639f, -0.04257618f, -0.01697991f, -0.10779459f, 
    -0.05158688f, -0.01374672f, 0.04285029f, -0.09721576f, -0.21139967f, 0.05805438f, 0.05954420f, 0.07242425f, 
    -0.04070558f, 0.01310233f, -0.00277923f, 0.00058111f, -0.02453481f, 0.07736655f, 0.04305235f, 0.02379276f, 
    -0.36840823f, -0.01191046f, 0.14557737f, 0.01058324f, -0.10484458f, -0.02579014f, 0.08574781f, -0.00808152f, 
    -0.00411430f, 0.01620149f, 0.03127889f, -0.03922703f, -0.03906869f, -0.22510868f, -0.12675829f, -0.26927230f, 
    -0.08228071f, 0.04240799f, 0.01117182f, 0.14489192f, 0.00101243f, 0.00147216f, 0.08273967f, 0.01134030f, 
    0.05898444f, -0.09645594f, 0.09709163f, -0.18895711f, -0.09059746f, -0.00526588f, 0.05087857f, 0.01661020f, 
    0.09505785f, 0.01606777f, 0.02013762f, 0.05871293f, -0.50373292f, 0.03633041f, -0.27146220f, -0.10650552f, 
    0.05579092f, -0.09207369f, 0.05838707f, 0.16662219f, -0.18278772f, 0.00968735f, -0.04827252f, -0.08110211f, 
    -0.06458229f, -0.23662607f, -0.01933371f, -0.02999982f, -0.07396992f, -0.05666116f, -0.05079574f, -0.10845885f, 
    0.04621390f, -0.00459422f, 0.03074950f, 0.00451029f, 0.21595618f, 0.25716704f, 0.16384505f, 0.12025198f, 
    -0.04632591f, 0.06879181f, 0.06156392f, 0.05405175f, 0.08668122f, 0.17283863f, -0.07118074f, 0.03502782f, 
    -0.11973341f, 0.20353584f, -0.04926522f, 0.03347545f, 0.19167532f, -0.02227410f, 0.07793725f, -0.08117209f, 
    0.16167350f, -0.06136732f, -0.05985528f, 0.12214097f, 0.07922874f, -0.03663845f, 0.04182244f, -0.01959380f, 
    -0.05559177f, -0.00483982f, 0.07312951f, -0.11625492f, -0.03856796f, -0.18331644f, 0.01314274f, -0.14058381f, 
    0.16945459f, 0.13388172f, 0.15454204f, 0.20318097f, -0.06074721f, -0.01166703f, -0.03588718f, -0.04448238f, 
    -0.01007501f, -0.02389291f, -0.13233051f, 0.05085711f, -0.34483624f, 0.07496063f, 0.13809134f, -0.05001850f, 
    -0.01038834f, -0.12280615f, 0.01972743f, 0.03594186f, -0.00246181f, -0.04218743f, 0.12392197f, 0.08773511f, 
    0.16552775f, -0.01228689f, 0.12088943f, 0.11457976f, -0.01023993f, 0.00498090f, 0.05381838f, -0.01277710f, 
    0.05480435f, -0.03297542f, 0.02326019f, 0.02102465f, -0.13658243f, -0.03320890f, 0.16793777f, 0.16615897f, 
    0.34052107f, 0.10603174f, -0.00332779f, 0.20281841f, 0.02635095f, 0.00808938f, -0.00419894f, 0.00719564f, 
    0.17394155f, -0.00398161f, -0.16083178f, 0.06101486f, -0.04173081f, 0.08237232f, -0.09216588f, -0.10828897f, 
    0.07277497f, 0.08689157f, 0.12779523f, 0.15045498f, -0.02075091f, 0.14304364f, -0.06849758f, 0.04295299f, 
    -0.22178522f, -0.08350177f, 0.07260701f, 0.01404881f, -0.11721002f, -0.10299064f, 0.20028634f, -0.05285745f, 
    0.03866054f, -0.06238800f, 0.09432058f, 0.09529567f, 0.16629121f, 0.09387366f, -0.11645178f, 0.12095849f, 
    -0.01546638f, 0.01385794f, -0.03822100f, 0.07841669f, 0.13692454f, 0.24025278f, 0.11577094f, -0.06050103f, 
    0.01255208f, -0.00813737f, 0.12204321f, -0.10513125f, -0.11074485f, 0.08692772f, 0.07138366f, 0.00101854f, 
    -0.13451384f, 0.14207084f, 0.08565664f, 0.06129799f, -0.02692568f, 0.07092964f, -0.10151482f, -0.00620771f, 
    0.04345133f, -0.06246361f, -0.01746680f, -0.02673300f, 0.19382188f, 0.23478016f, -0.04107550f, 0.06155411f, 
    -0.00288443f, 0.08970919f, -0.02171891f, 0.15387395f, -0.12933697f, 0.09671865f, -0.04630793f, -0.12592711f, 
    -0.02144904f, 0.01360260f, 0.01322335f, 0.01240971f, -0.03000413f, -0.00396905f, 0.01115597f, 0.00035490f, 
    -0.04875233f, -0.04027830f, -0.03041756f, -0.02133826f, -0.02858065f, 0.03060761f, -0.00836464f, -0.04421765f, 
    -0.01450613f, 0.05120347f, 0.04549221f, 0.00869680f, -0.03150613f, 0.04289487f, -0.04022486f, -0.04800861f, 
    -0.00241541f, 0.01223289f, -0.01273246f, -0.01589123f, -0.03998555f, 0.03238565f, -0.04102578f, -0.02116508f, 
    -0.04383393f, 0.03673182f, -0.01766606f, -0.02929091f, -0.05723612f, -0.03526153f, -0.03609212f, 0.00927219f, 
    0.02086266f, -0.01590692f, 0.01908538f, 0.01498930f, 0.01375121f, -0.03396066f, -0.04273678f, 0.02325505f, 
    -0.00469505f, -0.01901042f, 0.01112215f, 0.03230569f, 0.03919579f, 0.03827861f, -0.00147758f, -0.01877658f, 
    0.02509331f, -0.00026407f, 0.03075217f, 0.03025807f, 0.00434828f, 0.01440560f, -0.02656055f, 0.00506731f, 
    -0.04361067f, 0.02537682f, -0.00079719f, 0.03552674f, -0.00151914f, -0.01161508f, -0.00875980f, 0.04769546f, 
    0.00936121f, -0.02033022f, -0.00940427f, -0.03498331f, -0.01444093f, -0.01654248f, -0.01901264f, -0.02912800f, 
    0.00202687f, 0.01607624f, -0.01584811f, -0.02004759f, 0.02304205f, -0.00422567f, -0.04080702f, -0.02481336f, 
    -0.05024213f, -0.01289812f, 0.03744300f, 0.03211760f, 0.02993963f, -0.02136355f, -0.00501307f, 0.03377344f, 
    0.02664872f, 0.00663438f, 0.02966780f, -0.05673753f, -0.01899189f, 0.00355827f, 0.03298173f, 0.00056707f, 
    0.01643181f, 0.02623655f, -0.01180055f, 0.04195437f, -0.02479402f, -0.03979253f, 0.04786570f, -0.01323929f, 
    0.00830939f, 0.02361078f, 0.00282774f, 0.00307763f, 0.04226298f, 0.00985285f, -0.02127094f, 0.00378266f, 
    0.00684991f, 0.01962132f, 0.02421491f, 0.03676991f, 0.01978808f, 0.05390879f, -0.04572508f, 0.00241124f, 
    -0.02756234f, 0.03290948f, -0.05337823f, -0.05548260f, -0.03273511f, 0.00943300f, 0.00948937f, -0.03583751f, 
    -0.04305451f, -0.02154941f, 0.00203363f, -0.00714008f, 0.03255057f, 0.02058353f, -0.04571936f, -0.01109921f, 
    -0.02068163f, -0.04408040f, -0.02127557f, 0.05540855f, -0.02864564f, 0.01389691f, -0.05231410f, 0.04618744f, 
    -0.00647191f, -0.00078198f, 0.04095642f, 0.00968834f, -0.05654849f, -0.05467600f, -0.00189706f, 0.03903547f, 
    -0.03160040f, -0.00172321f, 0.00994404f, -0.00664705f, 0.01166723f, -0.01610401f, 0.04491487f, -0.02484290f, 
    -0.05459177f, -0.02638703f, -0.04037359f, 0.03045934f, 0.04106338f, 0.02716596f, 0.02418141f, 0.01065010f, 
    0.05037335f, 0.03417929f, -0.04540063f, -0.05399939f, -0.01354051f, -0.04622867f, 0.01771995f, -0.00813625f, 
    -0.05663194f, 0.03114113f, -0.04747925f, -0.00001501f, -0.04865791f, 0.04614158f, 0.00808859f, -0.00799027f, 
    -0.03185216f, 0.04048265f, -0.05068873f, 0.04775426f, 0.03084698f, -0.00880533f, 0.02470386f, 0.03014388f, 
    -0.00764244f, -0.04864501f, 0.04522316f, 0.02660339f, -0.04376734f, 0.04015363f, 0.02517700f, -0.00338474f, 
    0.01326177f, -0.05018896f, 0.00246081f, -0.03505105f, -0.01464513f, -0.01506148f, -0.02761979f, -0.05547003f, 
    -0.04590669f, -0.04159324f, 0.01682006f, 0.00674884f, -0.00334637f, -0.04624338f, 0.01498667f, 0.00049603f, 
    0.02893256f, -0.03921835f, 0.03710319f, 0.01127780f, -0.01172659f, -0.00044232f, -0.02191201f, -0.01062754f, 
    0.02387480f, 0.02056597f, -0.05671315f, -0.04900813f, 0.03249269f, 0.03325150f, 0.01863802f, 0.00940111f, 
    -0.00644711f, 0.02672968f, 0.02056855f, -0.02688003f, -0.01589922f, -0.04315709f, -0.03282237f, 0.02407087f, 
    -0.02909414f, 0.01600890f, 0.03506567f, 0.01710134f, -0.01673609f, 0.04405198f, -0.03598796f, -0.00584733f, 
    -0.02795603f, 0.03772030f, -0.02170568f, -0.03506614f, 0.01786157f, 0.01153286f, 0.02514688f, -0.04816414f, 
    -0.02071070f, -0.01345821f, 0.02730390f, 0.00174856f, -0.03228012f, -0.03779130f, 0.03194230f, -0.04251681f, 
    0.04328856f, 0.01642269f, 0.03273546f, -0.02978718f, 0.01657929f, -0.01577285f, -0.03373555f, -0.04175509f, 
    0.01384837f, -0.03079449f, -0.03849690f, 0.03712698f, 0.00238752f, -0.04979096f, -0.04552121f, -0.05775260f, 
    0.01986373f, 0.02865570f, -0.01543261f, 0.02741501f, 0.02626804f, -0.00776350f, 0.03689774f, 0.00555504f, 
    0.03384936f, 0.00435414f, -0.02186752f, 0.03239157f, 0.01171045f, -0.02528577f, 0.01155843f, -0.01739015f, 
    -0.02517949f, -0.02510741f, 0.01620336f, -0.04077416f, 0.00194124f, -0.03830870f, -0.00381278f, -0.01479165f, 
    0.01860893f, 0.00612552f, 0.01315869f, 0.00150939f, 0.02283400f, 0.01034052f, 0.00279073f, -0.05744902f, 
    -0.01444852f, -0.00776485f, -0.00306767f, -0.00367323f, -0.01691171f, -0.04301905f, -0.02237267f, -0.02134206f, 
    -0.02987201f, -0.05313735f, -0.01699494f, -0.03396856f, -0.01012153f, -0.04205107f, 0.03886623f, 0.00424465f, 
    0.04241272f, -0.04518746f, -0.05130079f, -0.04408348f, -0.03695529f, -0.01659166f, 0.02711485f, 0.02331880f, 
    -0.04552141f, 0.02226651f, 0.02183091f, -0.00947737f, 0.00264716f, 0.03375465f, 0.00120792f, -0.01782699f, 
    -0.02687937f, -0.00466578f, -0.05663991f, -0.03631146f, 0.03141183f, -0.02114735f, -0.02762416f, -0.01502118f, 
    0.01618134f, 0.00354055f, 0.05460248f, 0.03808222f, -0.04308956f, -0.03800078f, -0.03677878f, 0.02672787f, 
    0.00421981f, 0.00741207f, -0.02180107f, 0.01509368f, -0.02289287f, 0.04128850f, -0.03952051f, -0.04404108f, 
    -0.05774657f, -0.00568802f, -0.01120765f, -0.00183177f, -0.00780784f, -0.04457252f, 0.03098345f, -0.04509813f, 
    0.31527007f, 0.01456900f, 0.01114313f, 0.19156361f, -0.05612313f, 0.06557387f, 0.00240191f, 0.02887578f, 
    -0.14836445f, -0.03563659f, -0.09094351f, 0.07669816f, 0.08279069f, -0.14094834f, -0.41462994f, 0.10054073f, 
    0.07374436f, 0.00427194f, -0.07441696f, -0.06883767f, -0.12267018f, 0.01691938f, -0.15147412f, -0.00253056f, 
    0.19683640f, 0.24125601f, 0.10968551f, 0.23229891f, -0.12511298f, 0.00216315f, 0.06746384f, 0.12329635f, 
    0.02114835f, 0.03965013f, -0.03164227f, -0.02819783f, -0.00279430f, -0.17329404f, -0.18707106f, 0.04785846f, 
    0.05399908f, -0.02950532f, -0.04972658f, -0.04300882f, 0.05787235f, -0.05216566f, -0.05329988f, 0.02822549f, 
    0.09039630f, 0.23067150f, -0.06055713f, 0.14831072f, 0.07213287f, -0.13366638f, -0.10027235f, -0.01833111f, 
    -0.09262615f, -0.10931840f, -0.06904726f, 0.18994029f, -0.05207844f, -0.08686795f, 0.27828127f, 0.00274571f, 
    -0.01845976f, -0.06899512f, -0.07298956f, 0.11487591f, -0.13202089f, 0.00233338f, 0.01985575f, 0.07473470f, 
    0.00264150f, -0.04371057f, -0.13530606f, 0.04503725f, -0.12712948f, 0.08823477f, 0.15160732f, -0.03359360f, 
    -0.06358678f, -0.04377882f, 0.00623583f, 0.02962928f, -0.18137608f, 0.00945197f, 0.02203961f, -0.13787857f, 
    0.03534800f, 0.03410961f, -0.07693153f, 0.03736009f, -0.03857039f, 0.08193848f, -0.13175972f, 0.04810323f, 
    0.16712458f, -0.35205841f, -0.09877370f, -0.08819763f, -0.12680925f, 0.06186607f, -0.13611117f, 0.04396849f, 
    0.10575765f, 0.03624603f, -0.04264525f, 0.16630392f, 0.16347757f, 0.10795695f, 0.13100185f, 0.19451042f, 
    -0.06901701f, 0.06609251f, -0.00165569f, 0.14586750f, -0.06257735f, 0.05843446f, 0.15253118f, 0.16288699f, 
    0.10051972f, 0.25140983f, 0.24864794f, 0.02429835f, -0.09630796f, -0.06677528f, -0.05566506f, 0.09822643f, 
    -0.17626609f, 0.05091260f, -0.09201720f, -0.08069274f, 0.06238953f, -0.18924811f, -0.11706454f, -0.02648933f, 
    0.03219536f, -0.07963243f, -0.01733237f, -0.00118598f, 0.19287452f, 0.00276545f, -0.09872880f, 0.15570152f, 
    0.11846470f, 0.02509026f, -0.18634491f, -0.03010013f, 0.10926872f, -0.05543534f, -0.00916791f, -0.02139023f, 
    0.00312240f, 0.06533087f, -0.00123286f, -0.00605752f, 0.13730988f, -0.10399761f, -0.21741086f, 0.15659353f, 
    0.08623478f, -0.05778848f, -0.09246473f, 0.06902776f, -0.09469514f, -0.09863941f, -0.06484338f, -0.21335895f, 
    -0.17659104f, 0.11871505f, 0.19289258f, -0.01693599f, -0.02949379f, 0.04013460f, -0.06172788f, -0.01894782f, 
    -0.03200591f, 0.00888710f, -0.10840704f, -0.04175230f, -0.04206114f, -0.01733407f, 0.04900927f, -0.05719187f, 
    -0.08176033f, 0.06480393f, 0.05253869f, 0.01871869f, 0.04865174f, -0.09225837f, 0.01532234f, 0.18322515f, 
    0.08322004f, 0.08679058f, -0.07981871f, 0.13263084f, -0.03470123f, -0.12611651f, -0.04151521f, 0.07620912f, 
    -0.10243481f, -0.05475651f, 0.04080034f, 0.11628334f, -0.00245714f, -0.00595481f, 0.46574819f, -0.01575469f, 
    -0.09216782f, 0.00820010f, 0.07572031f, -0.05028408f, -0.09219446f, 0.14797010f, -0.06039412f, 0.08466462f, 
    0.04710240f, 0.03546340f, 0.26905170f, 0.08271722f, -0.03349284f, 0.00551774f, 0.01112590f, 0.07175294f, 
    -0.05200462f, 0.04462145f, 0.06482428f, 0.09671002f, 0.29455715f, -0.05576910f, -0.02751133f, 0.05050549f, 
    -0.07906064f, 0.05816877f, -0.02462857f, 0.16420406f, -0.20983572f, 0.12793425f, -0.01553051f, -0.08070989f, 
    -0.02399317f, -0.01550084f, 0.19938244f, 0.12154812f, 0.02720145f, -0.06097458f, -0.03110498f, 0.18046452f, 
    -0.03781120f, 0.02631814f, 0.04200540f, -0.01431399f, 0.04262697f, -0.11834694f, -0.21231708f, -0.06443654f, 
    0.26214290f, -0.01559972f, 0.06964410f, 0.06120832f, 0.36041534f, -0.05696718f, -0.08366210f, -0.03393096f, 
    0.01134813f, -0.27900004f, -0.23940040f, -0.15435298f, -0.00862801f, -0.05078807f, 0.01101218f, -0.06957081f, 
    0.10876122f, 0.07937114f, 0.09531502f, -0.00993060f, -0.03215747f, -0.38715017f, -0.14251946f, 0.19189158f, 
    0.19689934f, -0.11555374f, 0.03304137f, -0.02681957f, 0.02574138f, -0.05818870f, -0.02865251f, -0.02412667f, 
    -0.43815857f, -0.06627239f, -0.02527444f, -0.43408576f, 0.01628886f, -0.03059566f, -0.07738055f, 0.04947390f, 
    -0.05046702f, 0.13324444f, 0.06344149f, 0.07311811f, 0.02283470f, 0.14269716f, 0.28329161f, 0.16026849f, 
    0.00317300f, 0.04910553f, 0.06828769f, 0.05091879f, -0.12694384f, -0.00250878f, -0.09715159f, -0.12856704f, 
    0.05961952f, -0.00746510f, 0.11125175f, -0.02321078f, -0.04770700f, -0.00598559f, -0.13885842f, 0.00957827f, 
    -0.15912043f, 0.07278958f, -0.02040008f, -0.12543283f, 0.23268855f, -0.07680828f, 0.06372435f, 0.08481408f, 
    -0.02183596f, 0.02292467f, 0.00762181f, 0.05597461f, 0.22434710f, -0.07072971f, -0.12623702f, 0.19593161f, 
    0.18151082f, 0.21273212f, 0.13445367f, 0.01126818f, 0.01209307f, 0.02333076f, 0.10878010f, -0.19533575f, 
    -0.04944110f, 0.05665682f, -0.02517495f, -0.11489012f, 0.42145997f, -0.04423031f, -0.18257385f, 0.22980513f, 
    0.09419618f, 0.04303590f, -0.12967896f, 0.09054212f, 0.01900064f, 0.21675988f, 0.04090153f, 0.01246169f, 
    0.15619938f, 0.00095707f, 0.05927747f, 0.13850120f, -0.02686458f, 0.01523981f, -0.04042908f, 0.07746531f, 
    -0.01479914f, 0.02460982f, 0.03205169f, -0.08700305f, 0.05521824f, -0.20041378f, -0.07791640f, 0.00107203f, 
    -0.03567410f, -0.07278219f, 0.01426640f, 0.03311676f, 0.14831804f, 0.14629775f, 0.19175383f, 0.01716542f, 
    -0.05588987f, -0.04733012f, -0.00372841f, -0.01683829f, 0.02944574f, -0.05037501f, 0.01852118f, 0.04124057f, 
    0.03068575f, -0.01997446f, -0.05914341f, 0.00392050f, -0.03157489f, -0.02104326f, -0.02970381f, 0.03727364f, 
    -0.05771292f, 0.04092312f, -0.03085785f, 0.03401220f, -0.04865612f, 0.01289939f, -0.04861481f, 0.00838761f, 
    0.00737678f, 0.03878257f, 0.02734978f, -0.05139523f, 0.01020975f, 0.02830376f, -0.04247304f, -0.02883736f, 
    -0.03600206f, 0.00764155f, -0.03376319f, -0.00508282f, 0.04203834f, -0.02760875f, -0.04047926f, 0.04045061f, 
    -0.00653481f, -0.02315985f, -0.04240122f, 0.00880012f, 0.03843857f, -0.01533510f, 0.01476097f, 0.02327152f, 
    0.00953108f, 0.02341443f, -0.00657167f, 0.01142608f, -0.00327627f, -0.03939412f, -0.03997718f, 0.02698755f, 
    0.03249006f, -0.03498563f, 0.02171231f, -0.01894605f, -0.02772006f, 0.00987522f, -0.05073587f, -0.04213505f, 
    0.02896365f, 0.03376164f, -0.02794976f, 0.01843532f, 0.01776752f, -0.02039064f, -0.03793717f, 0.00234563f, 
    -0.05052298f, -0.03378749f, -0.01625496f, 0.03931345f, -0.00975826f, -0.03943251f, -0.03172856f, 0.01149776f, 
    -0.03794914f, -0.00980196f, -0.01594405f, -0.03626352f, 0.00408100f, 0.01946623f, 0.03739579f, -0.04791113f, 
    -0.03307655f, 0.03545309f, 0.00147474f, -0.05061898f, -0.04243917f, 0.00781074f, -0.02118659f, -0.02838016f, 
    -0.03845040f, -0.02553396f, 0.00862250f, 0.01654772f, -0.01652813f, -0.02419757f, 0.00850219f, 0.03548350f, 
    0.03689018f, 0.03497426f, -0.02547116f, -0.02384155f, -0.05004863f, -0.04306379f, 0.03437809f, -0.00453337f, 
    -0.02508494f, 0.01713217f, -0.00321202f, 0.00847369f, -0.03874465f, -0.05106599f, 0.01755458f, -0.00049858f, 
    0.00409705f, -0.05559814f, -0.02665013f, 0.03183956f, 0.00649410f, 0.01147070f, -0.03007402f, 0.04203520f, 
    -0.05346079f, -0.02579831f, -0.04376614f, -0.04936613f, -0.02044301f, -0.02391838f, -0.04324671f, -0.02743917f, 
    -0.00580660f, -0.04682738f, -0.03830871f, -0.02346401f, 0.03033471f, 0.00764737f, -0.04852516f, 0.00133563f, 
    -0.02673697f, -0.04506635f, 0.04218127f, 0.04243355f, 0.03657605f, 0.04269146f, 0.03476451f, -0.02884502f, 
    0.00081666f, 0.01054298f, 0.00605864f, -0.03818691f, -0.01924239f, 0.01057517f, -0.01921042f, 0.00501989f, 
    0.00820020f, -0.03910165f, 0.02622559f, -0.01948227f, 0.02464842f, -0.05225460f, -0.05062471f, -0.05619726f, 
    0.01961506f, -0.03609175f, 0.03413243f, -0.02575730f, 0.00641314f, -0.04206225f, 0.02738789f, -0.00523891f, 
    -0.00370659f, 0.01657335f, -0.05450654f, -0.01307079f, -0.01694331f, -0.04691621f, 0.00846512f, -0.02523107f, 
    -0.05178308f, 0.00246374f, -0.03984234f, -0.01614873f, 0.03932134f, -0.05808073f, -0.04539313f, -0.03798924f, 
    -0.01994335f, -0.03509691f, -0.02528635f, -0.05392688f, -0.01360766f, -0.02558914f, -0.01521579f, -0.02241521f, 
    -0.03870537f, -0.04319820f, 0.00491979f, -0.02314233f, 0.00658577f, 0.00733501f, -0.05858644f, -0.02018446f, 
    0.01186702f, 0.01392681f, 0.02167561f, -0.04855626f, -0.00863763f, 0.00750326f, -0.04985449f, 0.01415075f, 
    -0.01190432f, 0.00017712f, -0.01187912f, 0.02760712f, -0.04794461f, -0.00350234f, -0.05023943f, -0.03009108f, 
    0.03364790f, 0.01224874f, 0.02597259f, -0.03421248f, -0.05011527f, -0.04842117f, -0.04365946f, 0.04147162f, 
    -0.04888003f, -0.02680111f, -0.01540773f, -0.02990697f, -0.02832231f, -0.02955190f, -0.00751517f, 0.04145256f, 
    -0.01413823f, 0.01307020f, -0.05546493f, 0.00749300f, -0.01341514f, -0.00188420f, -0.03299110f, 0.02714314f, 
    -0.01836478f, -0.04547993f, 0.04070503f, -0.04962572f, -0.05626758f, 0.01728383f, 0.04252141f, 0.01640634f, 
    -0.04465187f, -0.05268802f, -0.00282739f, 0.00293887f, 0.03139256f, -0.01465915f, -0.05036930f, -0.02937717f, 
    -0.00513233f, -0.02590932f, -0.02367895f, -0.03712666f, -0.00763844f, -0.03650110f, -0.03365792f, -0.00281724f, 
    -0.05288385f, -0.02011185f, 0.01831464f, 0.01294276f, 0.02708827f, 0.04035167f, -0.03915873f, -0.02579124f, 
    0.01673541f, -0.00472354f, -0.03251500f, 0.02876408f, 0.01195376f, 0.01088658f, 0.00719284f, 0.03629667f, 
    0.00215378f, 0.01959516f, -0.03885624f, 0.00909693f, -0.01944656f, 0.00772949f, 0.03796805f, -0.00382373f, 
    -0.03540959f, 0.03750673f, -0.01852678f, -0.01881539f, 0.02814681f, 0.01738008f, -0.02301369f, 0.00933155f, 
    -0.03669470f, 0.00504054f, 0.02980545f, -0.02689420f, 0.01091567f, 0.03053233f, 0.02226924f, 0.03501781f, 
    0.03263969f, -0.02143748f, -0.00362166f, 0.01660460f, -0.02129182f, -0.04190193f, -0.03445053f, -0.03460367f, 
    0.02854305f, -0.05598651f, 0.01806909f, -0.03200564f, -0.02385550f, 0.00770495f, -0.05117826f, 0.04222530f, 
    -0.00642804f, 0.00224586f, -0.01756905f, -0.00221115f, 0.00131009f, -0.03474531f, -0.00306603f, -0.01435018f, 
    0.03564493f, 0.04129626f, 0.03652273f, -0.01201955f, -0.03033896f, 0.00722253f, -0.04772758f, 0.01971054f, 
    -0.01111380f, 0.00628382f, 0.00633699f, -0.02208196f, -0.05589952f, -0.02901322f, -0.01637735f, -0.02688540f, 
    -0.04510800f, 0.00921097f, 0.00752698f, -0.04694897f, -0.02300688f, 0.02433009f, 0.00262462f, -0.05090954f, 
    -0.05122349f, -0.04021708f, 0.01052037f, -0.04565453f, -0.01190322f, 0.03183416f, 0.03639564f, -0.03613299f, 
    -0.03043622f, -0.00971754f, -0.01203966f, -0.05140219f, 0.01909056f, -0.05112883f, -0.02799401f, -0.01714564f, 
    -0.00158857f, 0.03966267f, -0.03497761f, 0.03873795f, -0.02189140f, -0.01136923f, 0.02083125f, 0.03237622f, 
    -0.08437131f, 0.21887378f, -0.09562393f, -0.07603905f, 0.02542072f, 0.01629097f, -0.03554822f, 0.13234453f, 
    -0.04463052f, -0.03398967f, 0.02780719f, 0.00062408f, -0.15451197f, 0.33081463f, 0.07326213f, -0.13374148f, 
    -0.00709739f, 0.06664236f, -0.03635171f, -0.02740725f, -0.05556384f, -0.08141848f, -0.10328388f, -0.24214131f, 
    0.00340341f, -0.01715607f, 0.27032298f, 0.10445640f, 0.00156456f, 0.10826810f, 0.09061215f, 0.07476862f, 
    0.01332017f, -0.02064966f, -0.02819221f, 0.03579970f, 0.04690179f, 0.19223388f, -0.11449642f, -0.16188946f, 
    0.01452874f, -0.02617412f, 0.00825256f, 0.08261787f, -0.05401652f, 0.04007307f, -0.05880782f, -0.19322425f, 
    0.05082242f, -0.07482856f, 0.06426395f, -0.10196329f, 0.00347542f, -0.03391764f, 0.12174372f, -0.08360119f, 
    0.04031789f, -0.01765535f, -0.10374890f, -0.03773249f, 0.12483394f, -0.11869317f, -0.03938702f, 0.19331728f, 
    -0.04080404f, -0.01788113f, 0.14167942f, -0.12123138f, 0.01507615f, -0.01796056f, -0.04920821f, 0.07587680f, 
    0.16129623f, 0.01081676f, 0.05548966f, 0.10004488f, 0.04834374f, 0.01835972f, -0.01989456f, -0.04968214f, 
    -0.00989234f, 0.00344635f, 0.00134776f, -0.05092996f, 0.00009820f, 0.03516490f, 0.21951497f, 0.20966558f, 
    0.05865639f, -0.08916045f, 0.00830758f, 0.01937117f, 0.03138437f, -0.04540816f, 0.16746484f, 0.01443333f, 
    -0.08323789f, 0.05527905f, 0.07663139f, -0.08568487f, 0.02875206f, 0.03389467f, 0.21317270f, 0.03655060f, 
    -0.07158739f, 0.00131023f, -0.08241108f, -0.11438126f, 0.28413641f, 0.07817472f, 0.10526432f, 0.33670643f, 
    0.06957503f, -0.13674322f, 0.00594619f, 0.04783166f, 0.00794443f, 0.00329664f, -0.05260479f, -0.07016159f, 
    0.16078365f, -0.04612741f, 0.12699601f, 0.09032327f, 0.09698986f, 0.18548222f, -0.09808654f, -0.03043126f, 
    -0.05900878f, -0.05650134f, 0.18901935f, 0.00191266f, -0.06400880f, 0.25347850f, -0.12113913f, 0.02715808f, 
    -0.05897158f, 0.08663774f, 0.09540097f, 0.06801420f, -0.05109522f, -0.01446251f, 0.04228008f, -0.06430926f, 
    0.01677481f, 0.07402913f, 0.10849191f, 0.13121569f, -0.04359946f, 0.16685213f, 0.13459501f, 0.12078618f, 
    -0.09328026f, 0.12411479f, -0.01749883f, -0.02897403f, -0.18741529f, 0.17365143f, -0.11023340f, -0.31881022f, 
    0.05579576f, -0.07633466f, 0.08589038f, 0.03751700f, 0.03248630f, 0.07221622f, 0.06510863f, -0.10101306f, 
    0.37369639f, -0.17922892f, 0.02627151f, -0.02590779f, -0.03827599f, 0.06324340f, 0.01490306f, 0.01595838f, 
    -0.01122841f, -0.00999657f, -0.12044910f, 0.02864670f, -0.08127944f, -0.13511391f, 0.04783482f, 0.08503179f, 
    -0.08977355f, -0.11186947f, 0.10123930f, 0.12426227f, 0.02832007f, 0.15875536f, 0.00891601f, -0.12778307f, 
    0.14326544f, -0.23020878f, 0.08243768f, -0.17793012f, 0.04225542f, 0.05961864f, -0.02479115f, 0.09150803f, 
    -0.06612202f, -0.03266363f, 0.05610267f, 0.07888694f, 0.39019167f, 0.02133705f, -0.10289107f, 0.24190566f, 
    -0.03899387f, 0.02408954f, -0.09618640f, -0.00774626f, 0.01522772f, 0.00669208f, -0.00598863f, 0.03547396f, 
    0.17265472f, -0.47039536f, -0.18210471f, -0.22783019f, 0.02733431f, -0.06171909f, 0.02561758f, -0.22808065f, 
    -0.04695300f, 0.05269808f, -0.04223263f, 0.05972920f, 0.14755237f, 0.09697497f, 0.04144307f, -0.01418443f, 
    0.07354134f, 0.08946324f, 0.00523383f, 0.03150083f, -0.03829222f, -0.12109467f, 0.08484153f, -0.08089062f, 
    0.47319254f, -0.07274595f, 0.07933891f, 0.14208357f, 0.08270114f, 0.06062855f, 0.05769071f, 0.07363250f, 
    0.01014802f, 0.06137827f, 0.14264642f, 0.03483334f, -0.23232433f, 0.21866733f, 0.11201596f, -0.16988981f, 
    -0.00278991f, -0.05844231f, -0.06076827f, 0.02538851f, -0.03590947f, 0.08523545f, -0.00572740f, 0.02773516f, 
    -0.08128695f, 0.22291414f, -0.04770327f, -0.11033127f, 0.07587404f, -0.07117917f, 0.03290238f, -0.04556585f, 
    -0.08668980f, 0.04715373f, -0.11467856f, 0.03177702f, -0.13172236f, 0.22835308f, -0.14482775f, -0.35571796f, 
    -0.05903172f, 0.07014991f, -0.19851369f, 0.07141113f, 0.00575065f, 0.11068457f, -0.05349129f, -0.11734615f, 
    0.52291960f, -0.24300623f, 0.01607813f, 0.10065801f, -0.01974873f, -0.04454287f, 0.18737003f, -0.17064373f, 
    -0.03052215f, -0.08216146f, -0.05340099f, 0.11454969f, -0.07893809f, 0.24388990f, 0.22519375f, 0.10993946f, 
    0.14968114f, -0.11586292f, 0.03895959f, 0.01658607f, -0.00754669f, 0.02772698f, 0.02318949f, 0.05897327f, 
    0.15200831f, -0.04466310f, 0.17770399f, 0.19083975f, -0.06244912f, 0.08782298f, -0.03358313f, -0.07764559f, 
    -0.11617578f, 0.05300983f, -0.03675123f, -0.24693939f, -0.32645065f, -0.01695639f, -0.15896657f, -0.23262443f, 
    -0.05956350f, 0.03515185f, -0.02392699f, -0.06080554f, -0.06973219f, -0.00380416f, -0.16155621f, -0.01651855f, 
    0.06325017f, 0.26667735f, 0.24113816f, 0.20973027f, 0.06880004f, -0.07771730f, 0.01930549f, 0.26599231f, 
    0.01306538f, 0.07584975f, -0.01975893f, 0.03706135f, -0.20155606f, 0.11119072f, 0.24501131f, -0.07584134f, 
    -0.10783584f, 0.07098924f, -0.02890932f, -0.02985495f, -0.07997876f, -0.07510624f, 0.03541966f, -0.07300162f, 
    -0.07236084f, -0.03172981f, -0.01492694f, -0.01248796f, 0.13092120f, -0.09735714f, -0.02455486f, 0.10105219f, 
    -0.01771838f, 0.15180025f, 0.03553287f, 0.05693220f, 0.15840602f, 0.01243243f, 0.03321256f, -0.07593277f, 
    0.01792731f, -0.04930034f, 0.17315532f, -0.05488777f, 0.10033251f, 0.13123930f, -0.01681608f, 0.25414219f, 
    -0.03932094f, 0.12212787f, 0.08871217f, 0.34018508f, 0.11627619f, 0.02311780f, -0.00854398f, -0.04466157f, 
    -0.00065303f, -0.01048016f, -0.02693804f, -0.13883869f, 0.01499700f, 0.10994819f, -0.28246561f, -0.34367359f, 
    0.13834122f, -0.02442901f, 0.11056941f, -0.01628231f, -0.11164881f, -0.03971254f, -0.01796922f, 0.12291121f, 
    -0.01920967f, -0.06568339f, -0.06117412f, 0.02229903f, -0.01871097f, 0.04378510f, 0.10475504f, -0.07449036f, 
    -0.00307882f, -0.09541640f, 0.06937440f, -0.05515494f, -0.10650169f, -0.05523848f, 0.09675609f, -0.17148878f, 
    0.15992939f, 0.04245155f, 0.03484700f, -0.10855726f, 0.00190777f, -0.02654508f, 0.02041331f, -0.03409967f, 
    0.20273148f, 0.03411268f, 0.14912087f, 0.21318458f, 0.02344576f, -0.05744578f, 0.03750261f, -0.00324712f, 
    -0.01607634f, -0.13879625f, 0.08430427f, -0.10323220f, 0.24178757f, 0.00786617f, 0.05837893f, -0.09255648f, 
    0.02605454f, -0.03287468f, -0.06244673f, 0.04567995f, 0.15989448f, 0.00251989f, 0.05464702f, -0.13606790f, 
    -0.08392175f, 0.04320866f, 0.12108097f, -0.11986888f, 0.15254597f, 0.05905499f, 0.03342439f, 0.16665608f, 
    -0.02619353f, -0.00511076f, -0.05130101f, 0.00693520f, 0.22328119f, 0.21590705f, -0.07048699f, -0.06423192f, 
    0.03008084f, 0.01937346f, 0.13417397f, 0.11860063f, -0.06905072f, 0.04213957f, -0.04475472f, 0.02918553f, 
    -0.18243432f, 0.13290012f, -0.01362270f, 0.01032483f, -0.09368140f, -0.02625734f, -0.02383175f, 0.00959568f, 
    -0.03621152f, 0.00662933f, 0.03886145f, 0.06272426f, -0.15095881f, -0.13149478f, 0.09876806f, 0.11950235f, 
    0.11742603f, 0.04597760f, 0.03904723f, -0.16631557f, 0.02635698f, 0.10069177f, 0.03649155f, 0.06244726f, 
    0.12794147f, 0.14743930f, -0.01424068f, 0.07282749f, 0.04416641f, 0.00898745f, 0.01916272f, 0.09096047f, 
    -0.04143740f, -0.06134680f, -0.09846041f, -0.04347486f, -0.32647538f, 0.32214943f, 0.05574214f, -0.31092098f, 
    0.08089110f, 0.03389269f, 0.04644100f, 0.02430707f, 0.00324283f, -0.02776930f, 0.05096012f, 0.08632264f, 
    -0.34869421f, 0.05159494f, 0.11676061f, -0.28837270f, 0.08348469f, -0.05500852f, -0.13956694f, 0.04488016f, 
    0.05260961f, 0.01467490f, -0.10230625f, 0.06871984f, 0.01094105f, -0.09121528f, -0.18146719f, 0.15009072f, 
    0.08558138f, 0.03587178f, 0.02149163f, -0.03292495f, -0.00289265f, 0.04198208f, -0.00892113f, 0.06005605f, 
    0.41629091f, -0.09039237f, -0.11324979f, -0.07314535f, 0.03115449f, 0.02704131f, 0.06987452f, 0.08408464f, 
    -0.08205815f, -0.01668107f, 0.03567149f, -0.04545676f, 0.13760668f, 0.11009680f, 0.15467912f, 0.18406591f, 
    0.11099506f, 0.05821240f, -0.08388960f, 0.05001947f, -0.13890179f, -0.15807928f, 0.02065112f, 0.03768986f, 
    0.24441600f, 0.05984031f, 0.01207360f, 0.22003098f, 0.02287382f, 0.00738247f, -0.01489233f, 0.09853905f, 
    -0.16991690f, -0.01925065f, 0.02109459f, 0.04404969f, 0.28048262f, 0.05173952f, -0.05267686f, -0.09297887f, 
    0.07124991f, -0.04237111f, 0.09074657f, 0.01873812f, 0.04427980f, 0.16714668f, 0.00231380f, -0.05459282f, 
    0.42271578f, -0.23116647f, 0.08015589f, 0.44221342f, -0.20933412f, 0.13210022f, -0.02701519f, 0.19030751f, 
    0.01738990f, 0.04719348f, 0.05145749f, 0.00274649f, -0.15745559f, -0.09803244f, -0.07926568f, 0.15840210f, 
    0.03940990f, -0.14922757f, -0.03133179f, -0.09521401f, -0.05591417f, -0.05946685f, -0.14198403f, 0.06682122f, 
    0.04673985f, 0.17597942f, -0.02672892f, 0.01688497f, 0.07670777f, -0.04612643f, -0.01237646f, -0.06541961f, 
    -0.05647343f, 0.04852096f, 0.05608209f, -0.06299838f, -0.13852639f, 0.17934585f, 0.11990186f, -0.22455738f, 
    0.08487353f, 0.13320199f, 0.24469729f, 0.06366356f, 0.02182445f, -0.07021495f, 0.11683074f, 0.01240603f, 
    -0.13229702f, -0.02962412f, -0.13933745f, -0.27040210f, 0.18979119f, 0.12941502f, 0.03965576f, -0.05089725f, 
    0.04951979f, -0.06521692f, -0.04980160f, -0.01182552f, 0.26242024f, -0.13797215f, 0.06015289f, -0.02186252f, 
    -0.03482291f, 0.01491024f, 0.12450762f, -0.06260590f, -0.00989461f, -0.02527114f, 0.07316672f, 0.04947693f, 
    -0.20325959f, -0.20377913f, 0.01770501f, -0.15176104f, 0.01550080f, -0.07114048f, -0.09089985f, 0.06957144f, 
    0.03395110f, 0.08318521f, 0.04490482f, 0.07831635f, 0.33452955f, 0.08734225f, -0.18749616f, 0.21747003f, 
    -0.07875747f, 0.14802073f, -0.04273154f, -0.05933917f, 0.10334532f, -0.04211708f, 0.12971415f, -0.06116764f, 
    0.04296438f, 0.20820439f, 0.06617014f, -0.12638536f, 0.04787058f, -0.05151301f, 0.05030493f, 0.04033275f, 
    0.11471625f, -0.09444189f, -0.00497636f, 0.05371325f, 0.00622531f, 0.17168011f, -0.15122242f, 0.03929536f, 
    0.01105575f, -0.07405390f, 0.03374109f, 0.14736465f, 0.01091718f, 0.02226349f, 0.05608495f, 0.03091333f, 
    0.05281790f, 0.02116263f, -0.10003373f, 0.22372898f, -0.07921962f, -0.08184339f, -0.05285738f, 0.01690907f, 
    0.04094705f, 0.05605714f, -0.09483398f, -0.07782323f, -0.06671431f, 0.02570853f, 0.12829642f, 0.18737173f, 
    0.14291064f, -0.11347067f, -0.05736406f, -0.02662772f, 0.11834617f, 0.06040765f, -0.12253045f, 0.00146407f, 
    0.03805235f, -0.09432304f, -0.11357377f, 0.14710355f, 0.02221650f, -0.04071277f, 0.10137041f, -0.15803400f, 
    0.00277940f, -0.02537278f, 0.11270233f, 0.00209782f, -0.04119626f, -0.14552920f, 0.08261772f, -0.17823265f, 
    0.08842488f, -0.04767857f, 0.03972014f, 0.02918578f, 0.02581797f, -0.08623514f, -0.07302871f, -0.05762937f, 
    -0.05474251f, -0.05155085f, -0.04399747f, -0.05587013f, -0.06287250f, -0.03232151f, 0.01572114f, -0.00793236f, 
    -0.04894929f, 0.00406228f, -0.04143469f, -0.03289592f, 0.03752462f, 0.04040679f, 0.02772307f, 0.03498271f, 
    0.02550940f, 0.04567116f, -0.05106605f, 0.03144581f, -0.04058634f, 0.03995676f, -0.03966278f, -0.01198234f, 
    0.04437869f, 0.02517655f, 0.00385373f, 0.01585326f, 0.04465201f, 0.03997147f, 0.00859826f, -0.01712433f, 
    0.02283888f, 0.01508796f, -0.04197111f, 0.02122406f, 0.01210694f, 0.01487189f, 0.02584337f, 0.03554998f, 
    0.03195790f, -0.04916637f, -0.01155100f, -0.05338457f, -0.05009041f, -0.02310134f, 0.00774214f, -0.01360237f, 
    0.01053455f, 0.00765964f, 0.03530421f, -0.01190710f, -0.00294722f, -0.00332864f, -0.01202435f, 0.02142401f, 
    -0.04446064f, -0.05249869f, -0.01659917f, -0.01651637f, -0.02531800f, -0.04117072f, -0.04999925f, -0.02813320f, 
    -0.03873810f, 0.00910300f, 0.03343817f, -0.00445169f, 0.00897093f, -0.03411335f, 0.00660723f, -0.04665736f, 
    -0.04915735f, 0.03768748f, -0.01913211f, -0.01027413f, 0.01173909f, -0.01799310f, -0.06259322f, -0.00749293f, 
    0.02395989f, 0.02255266f, 0.02431456f, -0.00786073f, 0.03229236f, 0.03421269f, -0.03628326f, -0.03658807f, 
    0.02975540f, -0.05505934f, 0.03275720f, -0.05530739f, -0.01594654f, 0.03821524f, 0.04335971f, -0.05544784f, 
    -0.02002666f, 0.03408971f, -0.01761922f, -0.03825592f, -0.00823528f, -0.04396930f, -0.01335545f, -0.00095064f, 
    -0.04424552f, 0.04629899f, -0.00807209f, -0.00743143f, -0.04840303f, -0.00749204f, -0.01678172f, 0.03128187f, 
    -0.00222821f, 0.01433323f, -0.01867574f, -0.05326326f, -0.00411220f, 0.03996228f, 0.03297062f, 0.04679228f, 
    0.02748256f, 0.01904995f, -0.00119459f, 0.01015021f, -0.00062634f, 0.00615113f, -0.04562788f, 0.04153174f, 
    -0.01672881f, 0.00129248f, -0.02727199f, 0.00345545f, -0.03044285f, -0.00724729f, 0.00737838f, -0.04330522f, 
    0.02112375f, 0.02787882f, 0.00748916f, -0.02853900f, -0.03992363f, 0.01455177f, 0.01879412f, -0.03012851f, 
    0.00462216f, -0.01421531f, 0.02460414f, -0.03453361f, 0.02306109f, 0.04336559f, 0.00538517f, -0.03409200f, 
    0.03855820f, 0.03324958f, -0.02290480f, -0.00634831f, -0.05184228f, -0.02319742f, 0.01041563f, 0.01567294f, 
    0.00933980f, 0.02518379f, 0.04314679f, 0.03657288f, 0.00183123f, -0.01012968f, -0.04134307f, -0.00231318f, 
    0.00709137f, -0.02051102f, 0.00405933f, 0.00633471f, -0.02291640f, 0.01186871f, -0.00433125f, -0.00185817f, 
    -0.04637209f, -0.03923674f, -0.05431309f, -0.01544026f, -0.01128921f, -0.00848297f, 0.00668024f, 0.02145561f, 
    0.00177506f, -0.06176151f, -0.04148927f, 0.01573004f, 0.02578119f, 0.01892301f, 0.02787430f, 0.01359949f, 
    0.03591344f, 0.00244367f, 0.01627880f, -0.03076938f, -0.01956592f, 0.03128500f, -0.05435172f, -0.01429745f, 
    -0.02817956f, -0.04182391f, 0.02776654f, -0.06074134f, -0.05341825f, -0.02890269f, -0.01156774f, 0.01966966f, 
    -0.01876722f, -0.04689705f, -0.01749233f, -0.03504389f, -0.01343459f, -0.03414892f, -0.00055353f, 0.03303891f, 
    -0.02863512f, -0.05101526f, 0.01548058f, 0.02702201f, -0.03732473f, -0.03038887f, -0.03795109f, 0.04969632f, 
    0.01128793f, 0.03874363f, -0.01876607f, 0.02266684f, 0.02186980f, -0.04331292f, -0.00604247f, 0.00953491f, 
    -0.05358011f, 0.04208594f, 0.00002371f, 0.02473190f, -0.03497927f, -0.00444404f, 0.03079332f, -0.01692212f, 
    -0.00182024f, 0.01511944f, -0.04942035f, -0.04836455f, 0.01859760f, 0.00577752f, 0.00129643f, -0.04354979f, 
    -0.00657852f, -0.00838180f, 0.02933291f, -0.04948832f, -0.04381150f, -0.05707283f, -0.04248749f, -0.00871278f, 
    -0.01382311f, 0.00273881f, -0.01245359f, -0.02013113f, 0.01367535f, -0.00205219f, -0.03110486f, 0.02100673f, 
    -0.00490470f, -0.05326644f, -0.05304640f, -0.01578665f, -0.01737983f, -0.02625745f, -0.00355640f, -0.05422488f, 
    -0.03830752f, 0.02747205f, -0.05413006f, 0.01411237f, 0.00926267f, -0.01725463f, -0.02300481f, -0.04381211f, 
    0.00432645f, 0.02782556f, -0.04542382f, 0.03058786f, 0.00407835f, -0.03808717f, 0.03394258f, -0.03999529f, 
    0.00354035f, -0.02102198f, 0.02964734f, -0.02541881f, -0.01680203f, -0.03525641f, 0.01734415f, -0.01875075f, 
    0.04284086f, 0.00645021f, -0.03808751f, -0.03938606f, -0.01206326f, -0.05324481f, -0.03549851f, 0.01877416f, 
    -0.05183042f, 0.01895134f, 0.01875252f, -0.02766499f, -0.00892574f, 0.04443023f, -0.04850769f, -0.02882828f, 
    -0.05382490f, 0.00981303f, 0.02801092f, -0.02601782f, -0.00811403f, -0.02598579f, -0.00301130f, 0.01986204f, 
    -0.04088516f, 0.04387531f, -0.04476038f, -0.04203526f, -0.01871346f, 0.02881054f, 0.01419951f, 0.02230714f, 
    -0.04865456f, -0.03244083f, 0.04021228f, 0.01946499f, -0.02653250f, -0.03226384f, 0.01320927f, -0.00373944f, 
    0.04172311f, 0.01697483f, 0.03515136f, -0.01483965f, -0.01090793f, -0.02230699f, 0.00642526f, 0.00570475f, 
    0.00696588f, -0.00977751f, -0.04556539f, 0.00736780f, -0.00510250f, 0.01718375f, 0.04030150f, 0.03461288f, 
    -0.06124676f, 0.01405253f, -0.02781192f, -0.05582776f, -0.03501423f, -0.02111050f, -0.04212904f, 0.00586335f, 
    0.03767157f, 0.03354474f, 0.01588178f, -0.03125257f, -0.03930936f, 0.01702981f, -0.03063427f, -0.04820571f, 
    -0.04940030f, -0.03437207f, 0.04046050f, 0.02258990f, 0.03930942f, 0.01097902f, 0.02556936f, 0.01644366f, 
    -0.03044932f, -0.03786888f, 0.00063573f, -0.02583490f, -0.01235281f, 0.01552402f, -0.02801541f, 0.01668091f, 
    -0.01348468f, -0.04853503f, 0.00183934f, 0.00770129f, -0.00018544f, 0.03409744f, 0.03987999f, 0.00015488f, 
    -0.01133326f, 0.01885504f, -0.03224080f, 0.00754236f, -0.05353522f, -0.01585340f, -0.01074533f, 0.03857454f, 
    -0.05221469f, 0.02807217f, 0.02129400f, -0.03692844f, 0.01286378f, -0.03002586f, 0.03719261f, 0.00822714f, 
    -0.03384146f, -0.05994589f, -0.00353827f, -0.04561746f, 0.02875233f, -0.01542207f, 0.03337143f, 0.02051759f, 
    -0.03897170f, -0.01186460f, -0.02410928f, 0.03331801f, 0.00775977f, 0.01344205f, -0.04140252f, 0.04024651f, 
    0.00149485f, -0.03954444f, -0.01609072f, -0.05022370f, -0.01521533f, -0.05663638f, -0.02834564f, 0.00501260f, 
    -0.03147617f, -0.02780279f, -0.02946013f, 0.04157993f, 0.03382613f, -0.00879399f, 0.03839748f, 0.01668887f, 
    -0.02116323f, 0.01388076f, 0.01143285f, 0.03380406f, -0.06193757f, -0.00406671f, 0.04043663f, 0.01179669f, 
    -0.03999842f, 0.03504623f, 0.00733277f, -0.00826522f, -0.02514694f, -0.03936351f, 0.02213782f, 0.01005835f, 
    0.03207008f, -0.00019286f, -0.04364609f, 0.02591861f, -0.03236496f, -0.00560143f, 0.02365845f, -0.02761180f, 
    0.02422035f, 0.03234772f, -0.00588923f, 0.00046076f, -0.01409075f, 0.04368022f, 0.00238326f, 0.02560726f, 
    -0.04182114f, 0.00351640f, 0.01479939f, 0.02610262f, 0.00456095f, 0.04683765f, -0.02566306f, 0.03357585f, 
    -0.01041619f, -0.03729524f, 0.04260775f, -0.03734447f, -0.00720388f, 0.04206976f, 0.00009699f, -0.03449545f, 
    0.00669815f, -0.03222227f, 0.03368659f, -0.06030467f, -0.01626727f, -0.01533937f, -0.02165110f, 0.01361179f, 
    0.00705377f, 0.01839254f, -0.00883254f, 0.01624984f, -0.04634442f, 0.02164824f, -0.02177132f, 0.00497541f, 
    0.00309101f, 0.01420644f, 0.03160966f, 0.01674100f, -0.05115353f, -0.04952274f, -0.01691731f, -0.00239101f, 
    -0.00277406f, -0.01225614f, 0.00830042f, -0.04088344f, 0.03148961f, -0.02001376f, -0.00011075f, -0.00423492f, 
    0.03112393f, -0.05446766f, 0.00782917f, -0.04314522f, 0.00111259f, 0.00822959f, -0.02985961f, 0.02562847f, 
    0.03587370f, 0.03237919f, -0.02387381f, 0.04652305f, 0.02270018f, -0.01501495f, 0.01670351f, 0.00217586f, 
    0.01156628f, 0.00926216f, 0.01057550f, 0.04532619f, -0.01190346f, -0.04479052f, 0.01139777f, 0.02753912f, 
    -0.05321488f, -0.05801069f, 0.02800058f, 0.03100362f, -0.00102275f, -0.04280537f, 0.02998066f, -0.01686158f, 
    0.00511489f, -0.02861852f, 0.04006684f, -0.02868664f, -0.06126261f, -0.02227788f, -0.03620027f, 0.01632559f, 
    0.03491444f, 0.00606605f, -0.02039583f, -0.02786232f, -0.03369113f, -0.04548141f, -0.02044242f, -0.04778402f, 
    -0.01984432f, -0.00230321f, -0.05016141f, -0.03032537f, 0.01832322f, -0.00553247f, 0.01878927f, 0.00292786f, 
    -0.03066203f, -0.01330286f, -0.04441879f, -0.00172017f, -0.02594188f, -0.02205538f, -0.01643005f, 0.01236124f, 
    -0.00060799f, -0.03296877f, -0.03420096f, -0.03128632f, -0.00209064f, -0.03639419f, 0.02909422f, -0.01108922f, 
    -0.02753857f, 0.00464273f, 0.02533130f, -0.00920746f, 0.01254672f, -0.02406430f, -0.02229740f, -0.01750751f, 
    0.01532250f, 0.03274791f, 0.03270574f, 0.04341574f, 0.04259486f, 0.01251166f, 0.03270885f, 0.00666270f, 
    -0.01881771f, -0.01425703f, -0.04405616f, -0.02529676f, -0.03492078f, -0.05542306f, -0.01725125f, 0.02857909f, 
    -0.04398806f, 0.02988285f, -0.04823866f, -0.00082408f, -0.06361725f, -0.04093479f, 0.00682094f, 0.02700015f, 
    -0.00500195f, -0.03248749f, 0.02476051f, 0.03034019f, -0.03982924f, -0.02617858f, 0.05063797f, -0.04452662f, 
    -0.03411649f, -0.00765260f, -0.02710270f, 0.02017809f, -0.03308173f, -0.02773231f, 0.04063016f, 0.03278939f, 
    0.00797148f, -0.03003473f, -0.01057529f, -0.00935609f, -0.01747941f, 0.03170838f, 0.00246412f, -0.00524204f, 
    -0.05207154f, 0.03934040f, 0.03136017f, 0.03025545f, 0.04195958f, -0.03176026f, -0.02274528f, 0.02804558f, 
    0.00464310f, -0.05067868f, 0.03404070f, 0.01672210f, 0.03216095f, -0.00295829f, 0.04402886f, -0.05135687f, 
    -0.02838799f, 0.01777782f, 0.01346522f, -0.03705214f, 0.03069749f, 0.03173572f, -0.02440527f, -0.04536847f, 
    -0.03096727f, -0.01448490f, -0.02597775f, -0.02682600f, -0.00857434f, 0.01385003f, 0.02408062f, -0.00649594f, 
    -0.00933724f, -0.04872651f, -0.00189221f, 0.02359236f, -0.01393239f, -0.01474996f, 0.01957216f, 0.00026834f, 
    -0.03071287f, 0.03589625f, 0.03370119f, 0.02126053f, -0.01973692f, 0.02226943f, -0.04717777f, -0.01785672f, 
    -0.01456121f, -0.05612726f, -0.04738156f, -0.00212145f, -0.03456498f, 0.00478287f, -0.04125357f, 0.01284885f, 
    -0.01190492f, -0.01643270f, 0.04051932f, -0.05154202f, -0.03911592f, -0.03262797f, -0.05729651f, -0.01549542f, 
    -0.00591628f, -0.03560304f, 0.03726307f, 0.00745892f, -0.02524193f, 0.01083475f, 0.03412369f, -0.02596475f, 
    -0.05429500f, -0.04431175f, -0.04147097f, 0.02530784f, -0.00298711f, -0.03509329f, 0.01882029f, -0.05321260f, 
    0.03605326f, 0.00043301f, -0.04895371f, -0.02444676f, -0.04902581f, -0.03384856f, 0.00281103f, 0.03291517f, 
    0.01855616f, -0.03969708f, 0.02023785f, 0.03945712f, 0.02899325f, 0.02386699f, -0.04450830f, -0.03539188f, 
    0.00560186f, 0.00214241f, 0.02287628f, -0.06033944f, -0.01230463f, 0.02696877f, -0.02601112f, -0.05459675f, 
    -0.03357965f, -0.03940447f, 0.04471324f, 0.04434171f, 0.04029816f, -0.05731161f, -0.00294858f, -0.02267641f, 
    -0.00367737f, -0.00049362f, -0.04145417f, -0.01870093f, 0.04238087f, -0.03473576f, 0.00006303f, 0.01528030f, 
    -0.01124200f, -0.02450635f, -0.03687121f, 0.03831989f, -0.03485637f, 0.00557177f, -0.05145955f, -0.04751195f, 
    0.00073982f, -0.04580994f, 0.01888976f, 0.00439905f, 0.03467302f, 0.00641007f, 0.01045806f, 0.03552923f, 
    0.01618467f, 0.00304605f, 0.01489235f, -0.05633019f, -0.04399636f, 0.02679502f, -0.03411785f, -0.04610929f, 
    0.02564722f, -0.01187088f, 0.02951664f, 0.04122610f, 0.02942207f, 0.04155778f, -0.01670532f, -0.03893758f, 
    0.02836308f, -0.00482799f, 0.04120485f, -0.01116026f, -0.04414834f, -0.03254164f, 0.00395640f, -0.01415364f, 
    -0.03411898f, -0.04847160f, -0.02745211f, -0.03730228f, -0.05528148f, 0.02708802f, 0.03832931f, -0.00989862f, 
    -0.05160964f, -0.04878575f, -0.00399642f, 0.01812825f, -0.03423868f, -0.02555755f, -0.01058559f, 0.03234530f, 
    -0.04628591f, 0.04036815f, -0.03528883f, -0.00267537f, 0.01300914f, 0.00202749f, -0.04284459f, 0.00988771f, 
    0.01487792f, -0.01852448f, 0.00811178f, -0.02368527f, -0.02760406f, 0.05022847f, -0.05424762f, 0.02900021f, 
    -0.03936445f, 0.03063168f, -0.05380842f, 0.02248079f, -0.02062429f, -0.02034915f, 0.00333457f, -0.04650224f, 
    -0.01543269f, 0.02242769f, 0.03677687f, 0.04119584f, 0.04460000f, 0.00493886f, -0.02696969f, 0.04514775f, 
    -0.00367329f, -0.02787418f, -0.03261651f, -0.00511053f, 0.01842249f, 0.01550757f, -0.03320477f, -0.04924497f, 
    -0.01735483f, -0.04975944f, -0.02549952f, 0.00067819f, -0.01601742f, 0.04441531f, 0.02952434f, -0.00373771f, 
    -0.04406026f, 0.03771662f, -0.00996774f, -0.05185219f, -0.05081485f, -0.02845572f, -0.00859503f, 0.04539393f, 
    0.00140474f, 0.01053531f, 0.02225868f, -0.03372022f, -0.04160802f, -0.01334905f, -0.03932518f, -0.04244506f, 
    0.02701753f, -0.03378249f, 0.02042497f, -0.06012391f, 0.00699615f, -0.00377450f, -0.02725677f, 0.01704118f, 
    -0.00674032f, -0.02368914f, -0.03460855f, -0.02152876f, -0.00488309f, -0.01948307f, -0.05533449f, 0.01493833f, 
    -0.03525503f, 0.01104135f, -0.01665259f, -0.04740452f, -0.01900429f, 0.03885107f, 0.02492527f, -0.01580303f, 
    -0.02238016f, -0.02038964f, -0.05354267f, -0.02783447f, -0.04733128f, 0.02928074f, 0.03704464f, 0.03007834f, 
    -0.03131436f, -0.04875917f, -0.02365094f, 0.01857778f, -0.00847437f, -0.01430504f, -0.03439362f, -0.02881098f, 
    0.03045793f, 0.02108108f, -0.02843930f, 0.01590201f, -0.02079461f, -0.03289390f, 0.00059777f, -0.05410357f, 
    0.01238433f, -0.02940454f, 0.04650257f, 0.04028763f, 0.01408258f, 0.01912883f, -0.05292570f, 0.02351215f, 
    -0.00736252f, -0.04345598f, -0.04496350f, -0.01144063f, 0.03755759f, -0.01082652f, 0.03318222f, -0.04678026f, 
    -0.01120586f, 0.04784359f, 0.02618206f, 0.02260194f, -0.03027008f, 0.02953316f, 0.02441546f, -0.02853895f, 
    0.00112048f, 0.00399802f, -0.05638447f, 0.03461672f, -0.01844774f, -0.01370522f, -0.00151225f, -0.02461308f, 
    0.01331256f, 0.02408172f, -0.00516832f, -0.04131491f, 0.01602648f, -0.04544426f, 0.03213120f, 0.01061807f, 
    0.03936044f, -0.00903065f, -0.01962686f, -0.00638571f, 0.01665696f, -0.02933817f, 0.01462413f, 0.00655647f, 
    0.03859208f, 0.00263616f, -0.05661265f, -0.04081926f, -0.02761618f, -0.03565137f, -0.04025920f, -0.04141980f, 
    0.00248980f, 0.00426201f, 0.02354375f, -0.01875481f, -0.04774336f, 0.00781790f, -0.01652965f, -0.02953872f, 
    0.01314710f, -0.05615182f, 0.00409814f, -0.05610405f, 0.01426295f, -0.04280861f, -0.02875817f, 0.00526842f, 
    0.00749127f, -0.03304573f, 0.02439851f, -0.05290670f, -0.05098655f, 0.02541973f, -0.03237132f, -0.02980016f, 
    -0.04231708f, -0.00503964f, 0.00542916f, -0.02911012f, 0.02222251f, -0.01546200f, 0.02008056f, -0.01977781f, 
    -0.01557969f, -0.02240122f, 0.04690119f, -0.01290797f, -0.00661321f, -0.03936254f, -0.03735605f, -0.03606271f, 
    -0.02038963f, -0.02587026f, 0.02967039f, 0.03582527f, -0.00466611f, -0.04927908f, -0.03345717f, 0.00051793f, 
    0.02673212f, 0.00034915f, -0.04544523f, -0.02058649f, 0.00895573f, -0.01981197f, 0.04443581f, 0.01470646f, 
    0.02817266f, -0.05372017f, 0.00907412f, 0.00798005f, -0.00088893f, -0.00294397f, 0.04215281f, 0.00448587f, 
    -0.03201143f, -0.03204954f, -0.04342677f, 0.01441905f, -0.01167450f, -0.03422714f, 0.01836301f, 0.03343554f, 
    -0.02715242f, 0.01764669f, 0.00597425f, 0.02674062f, 0.01554188f, 0.02182214f, -0.05365563f, -0.01919939f, 
    0.00070021f, -0.00809284f, -0.01602378f, 0.02997453f, -0.02717376f, -0.01427353f, -0.02124028f, 0.00488151f, 
    0.02807095f, -0.01419378f, 0.02423899f, 0.01583638f, 0.00367075f, 0.01471444f, -0.02839570f, 0.02263269f, 
    -0.03795239f, -0.02441824f, 0.03494759f, -0.00349893f, 0.00037906f, 0.03834302f, -0.00963633f, -0.01389881f, 
    -0.02305978f, 0.02891660f, -0.02053851f, 0.03871154f, 0.00309801f, 0.04181598f, -0.01393372f, 0.01644209f, 
    -0.03863752f, 0.01284570f, -0.04938564f, -0.00111290f, -0.01247546f, -0.05724594f, -0.04237470f, -0.04160472f, 
    0.02320178f, 0.00262725f, 0.04063972f, 0.01453507f, 0.02029714f, 0.02232597f, -0.03971931f, 0.00729356f, 
    0.02715760f, 0.01244021f, -0.01307207f, -0.02915321f, 0.03646514f, -0.05586323f, 0.03346491f, -0.02050296f, 
    -0.01374810f, -0.02298295f, -0.01622657f, -0.03273759f, 0.04789774f, 0.01001284f, 0.04557204f, 0.04036407f, 
    0.00051820f, 0.00005758f, -0.04693472f, 0.00725150f, 0.04426187f, 0.00753368f, -0.02719056f, -0.04976984f, 
    0.03435763f, -0.00414134f, -0.03806910f, -0.00532449f, 0.02651367f, -0.02279303f, -0.03444644f, -0.03822503f, 
    -0.01577981f, 0.02627151f, 0.03852786f, -0.02993789f, -0.01351734f, -0.03435159f, 0.00770188f, 0.01079209f, 
    -0.02447239f, 0.01117982f, 0.01387911f, -0.00145105f, 0.00118880f, -0.03571409f, 0.02147930f, -0.00571832f, 
    -0.05489754f, 0.01414848f, -0.04857720f, 0.01159131f, 0.02893773f, -0.04478453f, -0.01152408f, 0.00068100f, 
    0.01000437f, -0.04516635f, -0.01185277f, 0.01124210f, -0.05708655f, 0.01326934f, 0.03229985f, -0.02053082f, 
    -0.01305042f, -0.01428870f, -0.00162555f, 0.04960935f, -0.05351146f, 0.00488348f, 0.03612354f, -0.04162272f, 
    -0.01762814f, -0.00744875f, -0.01704212f, -0.01710643f, -0.02823483f, -0.05547624f, 0.02676030f, 0.03453422f, 
    -0.01721019f, 0.03262889f, -0.02850310f, 0.01436691f, 0.00856761f, -0.04145274f, -0.02371966f, 0.03983595f, 
    0.02410877f, 0.01695975f, 0.01022591f, 0.01194275f, 0.00990238f, -0.02622673f, -0.00287927f, 0.00778446f, 
    0.02629165f, -0.00743184f, -0.02772286f, -0.00297309f, 0.03034189f, -0.04322495f, -0.00600158f, -0.01182632f, 
    0.02919686f, -0.04513274f, 0.03662696f, 0.04518422f, 0.03884429f, -0.03381593f, -0.01022892f, -0.02775140f, 
    0.00827078f, -0.02180948f, 0.02865105f, -0.00996722f, -0.00755010f, -0.05304969f, -0.00748872f, -0.06035602f, 
    0.00036290f, -0.04132371f, -0.04899242f, -0.05261697f, 0.01181089f, -0.04490351f, -0.03748717f, 0.01265444f, 
    -0.05448257f, -0.01577226f, -0.00988947f, 0.02705429f, -0.04032324f, 0.02394543f, 0.01125105f, -0.01486811f, 
    -0.00585518f, 0.00667495f, -0.05522200f, -0.02400645f, -0.05765347f, -0.05758307f, 0.01041675f, -0.04029570f, 
    -0.04526242f, -0.05902385f, 0.02992063f, 0.01062863f, -0.05334104f, 0.01935863f, 0.01165597f, 0.02218643f, 
    0.00881820f, 0.01131671f, -0.03604397f, -0.03017981f, 0.02896430f, -0.06044748f, 0.04048610f, 0.02981264f, 
    0.03658528f, -0.05250387f, -0.05454934f, -0.04892375f, -0.02076902f, 0.03915688f, 0.02707874f, 0.00164510f, 
    -0.05466421f, 0.03774586f, 0.02814468f, 0.02562740f, -0.04806644f, -0.01557941f, -0.01004221f, 0.02269210f, 
    -0.03752868f, 0.01802020f, 0.02195877f, -0.02026791f, -0.04144230f, -0.04655958f, -0.01524689f, -0.01031321f, 
    -0.01730951f, -0.01322606f, -0.03560546f, 0.01812934f, 0.01505885f, 0.02717215f, -0.01077720f, -0.02766749f, 
    0.03528702f, 0.04125841f, -0.04584260f, -0.04897125f, 0.02592629f, -0.03210656f, -0.00642678f, 0.01702022f, 
    -0.01942013f, 0.00702723f, -0.02074472f, -0.04473608f, -0.03615469f, 0.03919371f, 0.03734807f, 0.01880929f, 
    -0.02317552f, 0.02168849f, -0.00991511f, -0.01798760f, -0.02066062f, -0.05538384f, 0.00031639f, 0.03130238f, 
    0.00866523f, -0.04184683f, -0.01128413f, 0.01708437f, 0.02334949f, 0.00543153f, 0.02018569f, 0.01090517f, 
    0.01379622f, 0.03850105f, 0.02643776f, -0.06286955f, -0.02835204f, -0.03047749f, -0.01562462f, 0.01898765f, 
    0.00778102f, 0.01958229f, -0.00654242f, -0.04402104f, -0.03806774f, -0.03856244f, 0.02091447f, -0.01041121f, 
    0.01420540f, 0.00887628f, 0.01005198f, -0.00932370f, 0.02372286f, -0.00203051f, 0.03596756f, 0.02564016f, 
    -0.04209014f, 0.03220230f, 0.02064352f, -0.00203594f, -0.00804631f, -0.01598904f, -0.02823613f, -0.03066815f, 
    0.00978517f, 0.01628296f, 0.02825941f, -0.04728876f, -0.06068337f, -0.05681882f, -0.01687301f, -0.04061667f, 
    -0.02361540f, -0.03655710f, -0.04388002f, 0.00238099f, -0.04320016f, 0.00050450f, -0.04373893f, -0.00223379f, 
    0.03581358f, -0.03702031f, -0.02007195f, 0.01824708f, 0.02219486f, -0.00445755f, -0.03516663f, 0.01190730f, 
    -0.03273787f, 0.03080730f, -0.04112327f, -0.01206287f, 0.03101036f, -0.05594181f, -0.04572760f, -0.01206665f, 
    -0.01488517f, 0.00420739f, -0.02481702f, 0.01752747f, -0.03992789f, -0.00644377f, -0.01741328f, -0.00423126f, 
    0.02542021f, -0.04538998f, -0.03645251f, -0.03326879f, 0.00025516f, 0.03048131f, -0.03415302f, -0.00392905f, 
    0.01266319f, -0.01315795f, -0.03037925f, -0.02139699f, -0.05363891f, 0.02424466f, 0.03679771f, -0.01614730f, 
    -0.03424644f, -0.00209158f, -0.00536866f, -0.00763730f, 0.00472087f, -0.02655756f, -0.05346807f, -0.02271617f, 
    -0.03295792f, -0.00766273f, -0.02069250f, -0.00894115f, -0.01593969f, 0.03899983f, -0.00010643f, 0.03759801f, 
    0.02415021f, -0.02687952f, -0.04909454f, -0.00090372f, -0.02357239f, 0.02405837f, 0.03544255f, -0.03654129f, 
    -0.05779907f, 0.00007538f, -0.02231038f, 0.01106769f, -0.01411347f, -0.02528839f, 0.04041534f, -0.01566077f, 
    0.01476523f, 0.01672899f, 0.04497838f, -0.00032338f, 0.01196719f, -0.01664422f, 0.02677123f, -0.06048167f, 
    -0.01128073f, -0.02053905f, -0.03212642f, -0.03978748f, -0.01818610f, -0.03590171f, -0.04864828f, -0.03612972f, 
    0.03590894f, -0.03594002f, -0.01719843f, -0.00640598f, -0.03918343f, -0.03520828f, 0.03732613f, -0.00392019f, 
    0.01372588f, 0.03762865f, 0.01716012f, -0.02550670f, -0.00383555f, -0.03743294f, -0.02096188f, 0.04037801f, 
    0.01304024f, 0.00675874f, 0.01943165f, 0.03443367f, -0.04907949f, 0.02325188f, -0.01487108f, -0.04100619f, 
    -0.04908364f, -0.02724966f, 0.02291151f, 0.02116506f, -0.00078092f, 0.00724750f, -0.04857870f, -0.02433692f, 
    -0.04998460f, 0.03203039f, 0.00574003f, 0.00301603f, 0.00233328f, 0.01933598f, -0.04881042f, -0.04195915f, 
    -0.05346962f, 0.02087587f, -0.03963021f, 0.02811266f, -0.02537347f, -0.04401627f, -0.04542584f, -0.00760945f, 
    0.02471066f, -0.00555969f, 0.01367600f, 0.02037974f, 0.00069035f, 0.02761847f, -0.00245657f, 0.02335470f, 
    -0.01025896f, -0.03365983f, 0.03662790f, -0.00029529f, -0.02608035f, -0.01566315f, -0.02115799f, -0.03124125f, 
    0.02597452f, -0.01320013f, 0.00660286f, 0.04004952f, -0.04769273f, -0.01200161f, -0.03489318f, -0.01289220f, 
    -0.03941235f, -0.00516140f, 0.03112574f, -0.06036690f, -0.00961156f, 0.00846484f, -0.02688565f, -0.04133155f, 
    0.02310070f, -0.00009015f, 0.00605832f, -0.03645442f, 0.01443155f, -0.05309245f, -0.00144966f, 0.03582494f, 
    -0.01117292f, 0.01717089f, -0.00810445f, -0.00796006f, 0.03868177f, -0.01167047f, -0.04941214f, -0.03652485f, 
    0.01575082f, 0.00486564f, 0.01816193f, -0.01791344f, -0.06134650f, -0.00704677f, -0.01334054f, -0.02242608f, 
    0.00751161f, -0.01677981f, 0.01916229f, 0.00532073f, 0.03695196f, 0.02072391f, 0.02830951f, -0.01958111f, 
    0.03568731f, -0.04496099f, -0.03370887f, 0.00271562f, -0.00911395f, -0.03033781f, 0.02697301f, -0.05756127f, 
    0.00005399f, -0.01623984f, -0.01394427f, 0.00543297f, 0.02733797f, 0.00974071f, 0.01619466f, 0.04510879f, 
    -0.04335304f, -0.01795146f, 0.00599560f, 0.03047518f, -0.03610159f, -0.04958142f, -0.01295993f, -0.03060368f, 
    -0.02542896f, 0.01932789f, 0.04580927f, -0.03202834f, 0.02334233f, 0.03831019f, 0.02414318f, 0.00205360f, 
    -0.00795142f, -0.03559274f, 0.03875651f, 0.04011368f, 0.04438996f, -0.04824458f, 0.01318690f, -0.00946644f, 
    -0.04668085f, 0.01105314f, 0.03965503f, -0.02237721f, -0.01735972f, 0.02977237f, 0.01595366f, -0.00343545f, 
    0.03941156f, -0.03828254f, -0.04950034f, -0.00682341f, 0.03326013f, -0.04581918f, -0.00800300f, -0.03628164f, 
    0.04623509f, 0.04438138f, -0.02504515f, 0.02101072f, 0.03022244f, -0.05377715f, -0.00071417f, -0.05933621f, 
    0.00566203f, 0.03845771f, -0.03970665f, -0.00966074f, -0.00717942f, -0.01209505f, 0.02169507f, -0.02782521f, 
    0.01410095f, -0.03697692f, 0.03680619f, -0.04649829f, -0.01507235f, 0.01088239f, -0.01905298f, -0.04087844f, 
    -0.00215146f, -0.01238335f, -0.04540175f, -0.01272723f, -0.02824412f, -0.00378326f, 0.01098795f, -0.00859949f, 
    -0.03867041f, -0.05139954f, 0.01017958f, -0.03036207f, -0.02421665f, -0.03417952f, 0.02085626f, 0.03824694f, 
    -0.01334523f, 0.02403296f, 0.03208060f, 0.00217917f, -0.01132569f, -0.04550875f, 0.04504644f, -0.04817500f, 
    0.00940646f, 0.02650395f, -0.05165553f, 0.03387963f, 0.01632321f, 0.02656544f, -0.01724117f, 0.02811110f, 
    0.00629267f, -0.01410852f, -0.01138354f, -0.04003048f, 0.01143503f, -0.00898805f, -0.00538087f, -0.01042844f, 
    -0.03414177f, 0.02653933f, -0.03471775f, 0.02145935f, -0.04332262f, 0.03812068f, -0.00214071f, -0.03495572f, 
    0.00145424f, -0.03239682f, -0.04729833f, -0.03172677f, -0.03530083f, -0.02943660f, -0.03137159f, -0.00603798f, 
    -0.03693962f, -0.02456617f, 0.02394469f, 0.00202382f, 0.03237546f, 0.02165676f, -0.01040707f, -0.00022655f, 
    -0.01493461f, -0.01256053f, 0.01189452f, 0.00577928f, -0.05069908f, 0.02909503f, 0.01525692f, -0.03732030f, 
    -0.02160098f, 0.01201216f, -0.01491410f, -0.01728169f, -0.01590001f, -0.00214440f, -0.01759823f, 0.01057376f, 
    -0.01269024f, 0.00088417f, 0.02762191f, 0.01014180f, 0.03896468f, 0.02107336f, -0.05257823f, 0.04115410f, 
    -0.01805036f, 0.01230371f, 0.02927154f, 0.03913066f, 0.01798773f, -0.00118907f, -0.02880792f, -0.00907348f, 
    0.03349705f, -0.00344698f, 0.02415167f, -0.05155506f, 0.00608104f, 0.01527393f, -0.06010917f, -0.03761289f, 
    -0.02558988f, -0.05620630f, -0.03272645f, 0.00441486f, -0.03808343f, -0.03402713f, -0.04265961f, -0.04356310f, 
    0.00786817f, -0.01446216f, 0.01368169f, 0.00562164f, 0.03034101f, 0.00693295f, -0.05697647f, -0.03382028f, 
    0.02797239f, 0.04103746f, 0.01630575f, 0.03899922f, 0.01954219f, -0.01968467f, -0.00772107f, -0.03421875f, 
    0.02204549f, -0.02978283f, 0.04476767f, 0.03472347f, -0.05519769f, -0.05274962f, -0.03736435f, -0.05728971f, 
    -0.01812105f, -0.04432814f, 0.04678768f, -0.04160246f, -0.03086028f, -0.03852525f, 0.00904609f, -0.04770127f, 
    0.03802769f, 0.01309242f, -0.00235515f, 0.02090751f, 0.04525445f, -0.04695044f, -0.01216895f, -0.02674202f, 
    -0.02379403f, -0.00005412f, 0.04576327f, -0.04384517f, 0.03680795f, -0.02662810f, 0.01324211f, 0.01672801f, 
    0.03707722f, -0.04557588f, 0.02140508f, 0.02975037f, -0.03345351f, -0.00953324f, 0.00088691f, -0.02106188f, 
    -0.01139988f, -0.01627393f, -0.03644483f, 0.01622772f, -0.03354129f, -0.00181847f, 0.00128586f, -0.01054801f, 
    -0.02067961f, 0.03252262f, 0.03562842f, 0.02747839f, -0.01938882f, -0.01284274f, -0.04240449f, 0.02514602f, 
    0.03482950f, -0.00538115f, 0.03486920f, -0.01695832f, 0.04922910f, -0.02644295f, 0.03236195f, -0.00908007f, 
    -0.01885951f, -0.05024319f, 0.02716626f, 0.03394419f, 0.03282816f, 0.04874084f, -0.03910263f, -0.00642582f, 
    0.00648031f, -0.05083147f, -0.02557886f, 0.02364383f, -0.00212203f, -0.04416380f, -0.00650087f, -0.03947646f, 
    0.01071446f, -0.00847837f, -0.02661348f, 0.01420502f, 0.03598079f, 0.04713825f, 0.01796525f, -0.03749211f, 
    -0.02753311f, 0.00649987f, 0.00516535f, -0.04996929f, 0.00805024f, -0.03282797f, 0.03129788f, -0.02525313f, 
    -0.02388153f, 0.02019290f, 0.00152645f, -0.00301659f, 0.02441237f, 0.03198715f, -0.00265861f, -0.04110087f, 
    0.01575776f, 0.03616069f, -0.02987270f, 0.03453722f, -0.04148095f, -0.02392602f, -0.03098618f, 0.00209253f, 
    -0.00418513f, 0.00299009f, -0.03699508f, 0.00377841f, -0.00708795f, 0.00647894f, 0.01104253f, 0.00924763f, 
    -0.02238438f, -0.01960901f, 0.02243602f, -0.03949543f, -0.02072655f, 0.02449589f, -0.04390595f, -0.02592166f, 
    0.03187506f, -0.01097850f, 0.02615714f, -0.04025640f, -0.01143746f, 0.04838162f, -0.03837055f, 0.02263222f, 
    0.02581275f, -0.01858008f, -0.04160567f, 0.00635439f, 0.02838577f, 0.02551822f, -0.03834321f, 0.03259939f, 
    -0.01627226f, -0.03005397f, 0.01860320f, -0.03677325f, -0.01304696f, -0.01570485f, -0.03987611f, 0.03111875f, 
    -0.02605748f, 0.04382392f, 0.01014513f, 0.02847476f, 0.01258200f, 0.03278698f, -0.03735564f, 0.00957546f, 
    -0.04640159f, 0.01191956f, 0.00055509f, -0.00970266f, -0.02070711f, -0.03076860f, -0.03816163f, -0.03077861f, 
    -0.02968046f, -0.04279888f, -0.00591084f, -0.03666417f, 0.04452388f, -0.00994101f, 0.02771282f, -0.04288334f, 
    0.00772296f, -0.03364613f, 0.02990349f, 0.00363082f, 0.04613337f, 0.03600259f, 0.02046068f, 0.04495197f, 
    -0.03172832f, 0.00562413f, -0.03402366f, 0.00940165f, -0.04708532f, -0.00622981f, -0.04973279f, -0.04054554f, 
    -0.00918928f, -0.02561744f, -0.02368617f, -0.04859496f, 0.01331416f, 0.03486969f, -0.01231217f, -0.04073152f, 
    -0.01162596f, 0.00092216f, 0.01316732f, -0.01888816f, -0.03437936f, 0.04050360f, -0.05640024f, 0.01158826f, 
    -0.03284540f, 0.00903657f, -0.03947873f, -0.04085644f, -0.04124150f, 0.02694360f, -0.05027567f, 0.04675891f, 
    -0.02325814f, 0.00930416f, 0.01882733f, 0.00270387f, 0.00953810f, 0.00640890f, 0.02345767f, -0.01422886f, 
    0.03621250f, -0.04164930f, 0.04679726f, -0.01268027f, 0.00206447f, -0.04842205f, 0.00020145f, -0.00253745f, 
    0.00346820f, -0.03616901f, -0.00429814f, -0.03456876f, 0.03765053f, -0.00736293f, 0.04158892f, 0.03101676f, 
    -0.01585688f, 0.00537251f, -0.00089324f, 0.03488512f, -0.05056993f, 0.03525104f, 0.00988956f, -0.04573179f, 
    0.00699803f, -0.01964859f, -0.00696728f, -0.03964773f, 0.02213402f, -0.01212834f, -0.04091137f, -0.01591603f, 
    0.00591248f, -0.03583353f, 0.02830953f, 0.00936578f, -0.04378008f, -0.00328150f, -0.04757861f, -0.03807122f, 
    0.04597905f, -0.04529711f, -0.00305654f, -0.01011491f, -0.05598961f, 0.01896283f, 0.04305933f, 0.03745084f, 
    -0.02909781f, -0.02899570f, -0.05535704f, 0.00116940f, -0.03674912f, -0.04112262f, -0.04569513f, -0.03069510f, 
    0.02679214f, 0.01151811f, -0.00093236f, -0.04216763f, -0.00054318f, -0.00603868f, -0.05083957f, -0.00480362f, 
    0.00090582f, -0.04692282f, 0.04134690f, 0.01961870f, -0.01527734f, 0.04172622f, 0.00108614f, -0.00654387f, 
    0.04674974f, 0.01076864f, -0.03746519f, 0.04012650f, -0.00583363f, -0.05083431f, -0.04069673f, 0.03590778f, 
    -0.00321780f, 0.04191627f, 0.03614845f, 0.02485755f, -0.05520847f, -0.00117234f, 0.00388611f, -0.01225766f, 
    -0.01475559f, 0.01001245f, -0.01165256f, 0.01568239f, -0.00150410f, -0.01796457f, 0.00451148f, 0.00618405f, 
    -0.01824956f, -0.04137354f, 0.04633116f, -0.00675856f, -0.00400288f, 0.02538697f, -0.02352932f, 0.03151869f, 
    0.04445059f, 0.04927616f, -0.01990199f, -0.02520213f, -0.04151923f, -0.04604912f, -0.04312522f, -0.02637635f, 
    -0.04508619f, -0.03795367f, -0.05060947f, 0.01014145f, 0.02039436f, -0.03010224f, -0.04901600f, 0.02496391f, 
    -0.03374053f, 0.01792178f, -0.01359222f, 0.03865564f, -0.05301815f, 0.02673647f, 0.02254344f, 0.00542690f, 
    -0.02961315f, -0.02993090f, -0.02719503f, 0.00204487f, -0.01116013f, -0.03096609f, 0.02245718f, 0.01434227f, 
    -0.00876523f, -0.02976380f, -0.00605668f, 0.03785043f, 0.03670752f, 0.04467587f, -0.03743561f, -0.00273538f, 
    -0.02749826f, -0.03740924f, 0.02701003f, -0.01490566f, -0.03342994f, -0.04665351f, -0.01039750f, -0.00453752f, 
    0.03705114f, -0.02901517f, -0.00244023f, -0.04711290f, -0.02530438f, -0.03683874f, -0.01189157f, -0.02746331f, 
    -0.03635925f, 0.03407512f, -0.04162920f, -0.01983987f, -0.05050299f, -0.02045667f, 0.00100063f, 0.00165277f, 
    0.00556102f, 0.03612211f, -0.03278797f, 0.01333588f, -0.04187921f, -0.04134759f, 0.03532199f, 0.00702371f, 
    0.02445441f, 0.03180039f, -0.02850207f, -0.02069047f, -0.04711569f, -0.01363428f, -0.03291671f, -0.04265946f, 
    -0.04041973f, -0.02450035f, 0.01837996f, 0.01202468f, -0.02596696f, -0.02999342f, -0.02414743f, -0.04719206f, 
    -0.05261346f, -0.00134233f, 0.01590865f, -0.02625662f, -0.01783052f, 0.01346975f, 0.03738943f, 0.00976413f, 
    0.01050597f, 0.00683373f, -0.02215209f, -0.04236178f, -0.05454379f, -0.02142869f, -0.03616495f, -0.00586280f, 
    -0.03139607f, -0.01263283f, -0.04080753f, -0.02319085f, -0.03193351f, -0.01065405f, -0.05547970f, -0.01024095f, 
    -0.02404224f, 0.03089029f, -0.04554436f, 0.02120510f, 0.00145272f, 0.00240018f, 0.01922949f, 0.03181194f, 
    0.01155403f, 0.00450546f, 0.02339853f, -0.01755286f, -0.03820680f, -0.02183485f, -0.04602216f, -0.00394979f, 
    -0.04411443f, -0.01060535f, -0.02389400f, 0.01143423f, 0.00620064f, 0.04407698f, 0.03552382f, -0.01396337f, 
    0.02369067f, -0.00235781f, -0.03127446f, 0.01691988f, -0.03847836f, 0.02765752f, -0.00815710f, 0.03279182f, 
    -0.00041670f, 0.00164815f, -0.02397440f, 0.00968371f, 0.03598915f, 0.02734397f, -0.05269456f, 0.00249785f, 
    -0.04111873f, 0.00236958f, 0.02287023f, -0.04400217f, -0.04281334f, -0.00233694f, -0.00882070f, -0.03017976f, 
    0.01672316f, 0.02923759f, 0.01981047f, 0.04626314f, 0.03271111f, -0.05319737f, 0.01835791f, 0.03281349f, 
    0.04766798f, -0.03629419f, -0.04034463f, 0.03316718f, -0.04006980f, 0.04683110f, 0.03935054f, -0.04695035f, 
    -0.14409193f, -0.13517886f, 0.11670256f, 0.07638828f, 0.03376104f, -0.04139920f, -0.00690344f, 0.17043439f, 
    0.05599600f, -0.04642456f, -0.00623427f, 0.00879592f, 0.13077420f, 0.14870007f, 0.01370687f, -0.02364881f, 
    0.01228992f, -0.08705741f, 0.01609659f, -0.02438206f, -0.10526478f, -0.05738957f, 0.04320203f, 0.03209261f, 
    -0.04789310f, -0.26463753f, -0.15199551f, -0.08437093f, 0.04157674f, 0.07151483f, -0.00043044f, -0.08913665f, 
    0.01499726f, 0.07274073f, -0.01841984f, 0.03505883f, 0.16049817f, -0.00451788f, 0.05606357f, 0.08671787f, 
    0.01923028f, 0.02185644f, -0.03618628f, -0.12004890f, 0.10398114f, -0.00325084f, -0.04258419f, -0.00838595f, 
    -0.02137624f, -0.01394959f, -0.21754946f, 0.08135901f, -0.03699028f, -0.11472046f, 0.03006738f, -0.09033369f, 
    0.02321853f, -0.01449990f, 0.09308176f, 0.06782460f, -0.12502944f, 0.09735324f, -0.00128581f, 0.17984700f, 
    0.03489912f, 0.10553738f, -0.03729153f, 0.00171969f, -0.02079854f, -0.01222777f, -0.07076275f, 0.10622732f, 
    0.21083589f, -0.00628036f, -0.00573892f, 0.01823223f, 0.00095867f, 0.02714103f, 0.00940568f, 0.03874019f, 
    -0.02400694f, 0.05484435f, -0.05468219f, 0.05418634f, 0.24238735f, -0.05563516f, -0.01189006f, -0.01914560f, 
    0.05690067f, -0.01670180f, -0.03337967f, -0.05538820f, -0.03881016f, 0.06637679f, 0.06363991f, -0.07225700f, 
    0.19531985f, 0.10579025f, 0.01644737f, 0.15429178f, 0.04851991f, -0.01245151f, -0.00661510f, 0.05962107f, 
    0.00031297f, -0.04616740f, -0.04594097f, 0.14886719f, -0.05969367f, -0.04772040f, -0.02933071f, 0.06865039f, 
    0.01571210f, -0.05218213f, 0.09555122f, 0.02032088f, -0.11656095f, 0.06435115f, 0.17352043f, 0.17220391f, 
    -0.10121142f, -0.02997481f, -0.16261172f, 0.02065971f, -0.04451768f, 0.01408634f, -0.02853214f, 0.04080024f, 
    -0.04176820f, 0.02569892f, -0.05284406f, 0.14642398f, -0.31630263f, 0.05335060f, 0.04076139f, 0.06336470f, 
    -0.00902586f, -0.09881462f, -0.01562565f, 0.02665722f, 0.02451254f, -0.06908919f, -0.03718817f, 0.01074316f, 
    0.27503270f, -0.31105277f, -0.01500237f, -0.10765362f, 0.16523486f, 0.04420743f, -0.04741771f, 0.11588800f, 
    0.16463533f, -0.05048020f, 0.10053114f, 0.03110078f, 0.23011988f, -0.05407173f, -0.02665581f, -0.06064838f, 
    0.08708368f, 0.02276570f, 0.01537530f, 0.00273221f, -0.04662722f, 0.10943619f, -0.07059611f, 0.05754368f, 
    0.08553295f, -0.02391268f, -0.21186870f, -0.05025843f, -0.02438802f, 0.09192321f, -0.02012026f, 0.06539952f, 
    -0.01562234f, 0.03552867f, -0.01031710f, -0.05834993f, -0.07555249f, 0.03872395f, 0.09411509f, -0.03273077f, 
    0.03224881f, 0.02205798f, -0.02677039f, 0.04077836f, 0.07829335f, -0.14202769f, 0.04959534f, 0.04541649f, 
    0.04463005f, 0.08795303f, -0.07688718f, 0.07746594f, 0.11167825f, -0.05667660f, -0.03424900f, 0.09748191f, 
    0.02388842f, 0.11469956f, 0.10790358f, 0.04038030f, 0.15922549f, -0.03398507f, 0.13799827f, 0.15092200f, 
    0.08854183f, -0.08094732f, 0.06586175f, -0.00983121f, -0.04791835f, 0.05605001f, 0.09898279f, 0.03305325f, 
    0.10550632f, 0.07539435f, -0.21203776f, -0.04436676f, 0.01893363f, -0.06389850f, 0.01719201f, 0.19774944f, 
    0.02655825f, 0.11115927f, 0.13540050f, 0.13908280f, 0.04715170f, -0.17869605f, -0.08695254f, -0.02465667f, 
    0.06455781f, 0.08092736f, 0.02918509f, 0.03615600f, -0.15258533f, 0.06359995f, -0.01982018f, 0.08329694f, 
    0.26284930f, -0.15361457f, -0.07000985f, -0.04033646f, 0.05460351f, 0.00564481f, 0.09885821f, -0.04430846f, 
    0.02044174f, -0.02693859f, 0.07344212f, 0.10842499f, 0.05622778f, 0.12912357f, 0.00562108f, -0.00369109f, 
    0.18629470f, -0.05860609f, 0.04793358f, 0.00211845f, 0.16022515f, -0.00095947f, -0.02455855f, 0.09413741f, 
    0.04595513f, -0.03950837f, 0.06546016f, -0.05483934f, 0.05104139f, 0.14042847f, 0.02165063f, -0.00648960f, 
    -0.04803602f, 0.00661693f, 0.10011175f, -0.08773210f, 0.27323771f, -0.02816639f, 0.02569511f, -0.11655422f, 
    0.07785588f, 0.06107798f, 0.14823686f, 0.04019256f, 0.03560431f, 0.04201361f, -0.04727805f, -0.00246680f, 
    -0.10498727f, -0.16196054f, 0.10408334f, -0.06758321f, 0.05496562f, 0.03571889f, -0.05282963f, -0.00782412f, 
    0.02507180f, 0.07649764f, 0.14055195f, -0.01670573f, -0.18938912f, -0.22193663f, -0.15598698f, -0.23440754f, 
    -0.07301969f, -0.07777692f, -0.01040577f, -0.13946851f, -0.00700434f, 0.08354676f, 0.06010202f, -0.07648722f, 
    -0.11995893f, 0.00973347f, -0.09608145f, 0.04459801f, -0.00985694f, -0.02081057f, -0.08495322f, 0.06262507f, 
    0.13990317f, -0.00721814f, 0.04496600f, -0.14410980f, 0.00403955f, -0.20686372f, -0.09076547f, -0.10516337f, 
    0.11256531f, -0.00438072f, 0.07034373f, 0.12418956f, 0.20720783f, 0.01544029f, 0.05801030f, 0.01670902f, 
    -0.20033382f, -0.11172818f, 0.01440224f, -0.15567832f, -0.04259486f, -0.03523219f, 0.01451112f, 0.09192646f, 
    0.08589820f, -0.00512408f, -0.03729264f, 0.08498522f, 0.31718421f, 0.09140242f, -0.04856837f, 0.04049357f, 
    0.03300998f, 0.03199104f, -0.05931664f, -0.02381774f, -0.04743203f, 0.03122614f, 0.06789280f, 0.10259868f, 
    0.14366136f, -0.14071339f, -0.08901367f, 0.11770156f, 0.22576201f, 0.06162785f, -0.09351049f, -0.00171245f, 
    -0.01783392f, 0.07285880f, 0.09262845f, -0.01710447f, 0.21729067f, 0.16058283f, 0.11519411f, 0.05111742f, 
    0.00839764f, 0.04256584f, -0.02718349f, -0.07107849f, -0.00872350f, 0.08604989f, 0.05415921f, -0.01069189f, 
    0.02988403f, -0.03400063f, 0.03751301f, -0.01946849f, 0.02577333f, -0.01957748f, -0.02868493f, 0.03979035f, 
    -0.04446215f, 0.02914427f, -0.03376109f, -0.00446570f, -0.00005294f, 0.04143959f, -0.01698874f, 0.01565085f, 
    -0.02383243f, 0.00947865f, -0.05431015f, 0.02923734f, -0.03098520f, -0.01061783f, 0.02263416f, -0.00327630f, 
    0.04279920f, 0.04338112f, 0.02631373f, 0.02197350f, 0.02333572f, -0.03568493f, 0.01714030f, -0.04201732f, 
    0.04451084f, -0.02406397f, -0.01247987f, 0.02439898f, 0.01830985f, -0.05454185f, 0.04019082f, -0.04895426f, 
    -0.02976251f, -0.05532009f, -0.05168521f, -0.04641644f, -0.01539895f, -0.05112300f, -0.02929708f, 0.03644923f, 
    -0.03247551f, -0.01247682f, 0.01823467f, -0.04060213f, 0.02423290f, 0.00671869f, -0.01367617f, 0.02001383f, 
    -0.03750062f, 0.01396668f, -0.01043469f, 0.00222935f, 0.03277688f, -0.01044293f, -0.02084973f, -0.01548161f, 
    0.00675126f, -0.01376211f, 0.03777353f, -0.01070992f, -0.00312614f, 0.01003651f, -0.01113894f, -0.04177676f, 
    0.02102475f, 0.00764001f, -0.02840515f, -0.04498776f, -0.04559038f, 0.01796921f, 0.00733053f, -0.01603392f, 
    0.04354988f, -0.05612893f, 0.00429915f, -0.00297621f, -0.01720137f, 0.01712841f, 0.01275776f, 0.01528562f, 
    -0.03193290f, -0.00721823f, -0.03397852f, -0.03905245f, -0.00703262f, -0.02606260f, -0.01841039f, -0.03163260f, 
    -0.03258078f, -0.05493318f, -0.02945792f, 0.00233124f, -0.02761373f, 0.02348969f, -0.05089944f, -0.00469122f, 
    -0.00878594f, -0.04822663f, 0.02752309f, -0.02342464f, -0.04703645f, -0.01101178f, -0.03616397f, 0.00601481f, 
    0.01709681f, 0.03088679f, -0.04269250f, -0.01631773f, -0.00690120f, 0.02241242f, 0.01014974f, 0.00912427f, 
    0.03197466f, -0.02843344f, -0.00447664f, 0.03512916f, 0.00082562f, -0.04092892f, -0.05658815f, 0.03742169f, 
    -0.03528644f, -0.01292302f, -0.03615940f, 0.01818473f, -0.00109995f, 0.00834106f, -0.04540403f, -0.03381629f, 
    0.00506072f, -0.02337118f, -0.00398848f, -0.00474601f, -0.03948301f, 0.01877781f, 0.01466507f, 0.03917442f, 
    -0.04371153f, -0.03689854f, 0.01206552f, -0.01618233f, -0.04935048f, 0.02500719f, -0.01190157f, -0.02500371f, 
    0.00378367f, 0.01096932f, -0.00339723f, 0.03873460f, 0.04042275f, -0.02795325f, 0.03876889f, -0.03049485f, 
    0.03141141f, -0.03139586f, 0.02528396f, -0.05526531f, -0.01671624f, -0.01840910f, -0.00273124f, -0.00060204f, 
    -0.01533151f, 0.03735310f, -0.05423505f, -0.03076713f, -0.04190982f, -0.00495750f, -0.00869445f, -0.00615306f, 
    0.03769982f, 0.01049112f, -0.03831573f, 0.04261616f, -0.02519761f, -0.03199578f, 0.00503716f, -0.02533177f, 
    0.03315949f, 0.03188764f, -0.03083537f, -0.04428010f, -0.00810175f, -0.04325984f, -0.04310110f, 0.01777139f, 
    -0.00276409f, -0.03335178f, 0.03707211f, -0.01631838f, -0.05181053f, 0.01958564f, -0.03562915f, 0.02354681f, 
    -0.00761018f, 0.00696174f, -0.03780746f, 0.04071745f, -0.05448082f, 0.02854644f, 0.00590680f, -0.00660296f, 
    -0.04269646f, -0.05229412f, 0.02684016f, -0.05257364f, 0.00922695f, 0.00848338f, 0.01409896f, -0.04891139f, 
    -0.03909823f, -0.05852503f, -0.04380783f, -0.00439582f, -0.04166269f, 0.03742179f, 0.00481015f, -0.03307001f, 
    -0.01283005f, 0.03367452f, 0.03136687f, 0.04460352f, 0.00613367f, 0.03720301f, -0.04193099f, -0.05232086f, 
    0.03851133f, -0.04201370f, -0.02746419f, -0.02788663f, -0.03839460f, 0.04231886f, -0.05556278f, -0.00494669f, 
    -0.04619458f, -0.02608862f, 0.00084082f, -0.04586448f, 0.02521727f, -0.04822436f, -0.05331974f, -0.05596796f, 
    0.01401392f, -0.03001468f, 0.00889584f, -0.01389095f, -0.02492680f, 0.01493948f, -0.02920276f, 0.00926917f, 
    0.01684922f, 0.00957551f, 0.03413685f, -0.00068867f, 0.04257271f, 0.02915736f, -0.02968074f, 0.02796220f, 
    -0.03621213f, -0.02132993f, -0.03038728f, 0.01822544f, -0.01702929f, 0.02778299f, -0.01806295f, 0.01334123f, 
    -0.03045334f, 0.03221252f, -0.00830441f, -0.02322526f, -0.00827761f, -0.04921667f, -0.01166294f, -0.01521186f, 
    0.02481701f, 0.03145438f, 0.02939978f, 0.02273597f, -0.00694243f, 0.03957511f, -0.05115665f, -0.00306594f, 
    0.02069177f, -0.00969665f, -0.02773909f, -0.05008128f, -0.00927043f, -0.02173989f, 0.03614231f, 0.00401312f, 
    -0.02229322f, 0.01373904f, 0.01006610f, 0.01834593f, -0.02831269f, -0.01045751f, 0.03346805f, 0.02495522f, 
    -0.02504723f, -0.01312196f, 0.03652324f, -0.02347507f, -0.00176268f, -0.00340728f, 0.02970388f, -0.05433137f, 
    -0.01368695f, 0.00351415f, 0.02100227f, -0.04449762f, 0.03040687f, 0.03064595f, -0.05747704f, -0.02178909f, 
    0.00934077f, -0.01737065f, 0.02882450f, -0.05545495f, -0.03992417f, -0.02621089f, 0.03138370f, 0.03090553f, 
    0.03607227f, -0.02602817f, 0.01925151f, -0.02581145f, 0.00211181f, 0.03021176f, -0.03196329f, 0.02982998f, 
    -0.05416645f, 0.02064131f, -0.00074290f, -0.05196475f, -0.03385516f, 0.01798938f, 0.01680263f, 0.03799388f, 
    -0.01463732f, -0.02607159f, 0.03542533f, -0.03218775f, 0.00898252f, -0.02663200f, 0.00781880f, -0.03775056f, 
    0.04192593f, 0.00433877f, 0.01518551f, -0.05896356f, 0.01597530f, -0.02740286f, -0.02772479f, 0.04161666f, 
    0.01213586f, 0.03158838f, -0.05308153f, -0.00042671f, -0.05083984f, 0.00237553f, -0.04907629f, -0.00943375f, 
    -0.01685995f, -0.02685433f, 0.00611296f, 0.03232042f, -0.05331996f, -0.05221029f, -0.02792303f, 0.01375605f, 
    0.03924680f, 0.01817052f, -0.04849781f, 0.03292090f, 0.01237789f, 0.02054193f, 0.04064531f, -0.02947737f, 
    0.03913956f, -0.05135958f, 0.00740019f, 0.00890752f, 0.02340168f, -0.01978000f, 0.01201074f, 0.00746963f, 
    0.04489316f, -0.05337375f, -0.01182233f, 0.03167630f, -0.05166344f, 0.03693601f, 0.01756733f, -0.02118051f, 
    -0.00800577f, 0.04066549f, 0.00303764f, -0.03258978f, -0.02084554f, -0.01194926f, -0.03971861f, 0.00858649f, 
    -0.01667401f, 0.04070196f, 0.00746349f, -0.03946468f, 0.00825981f, -0.00146288f, -0.00936041f, 0.03163319f, 
    -0.04392253f, -0.00931853f, -0.05643187f, -0.04219301f, 0.00472065f, -0.03132009f, -0.03983510f, 0.01162316f, 
    -0.01789648f, 0.02031737f, -0.01342969f, 0.03274193f, -0.02759905f, 0.03435549f, -0.01355113f, 0.02955291f, 
    0.03281516f, -0.02855105f, 0.02029556f, -0.05302076f, -0.04222294f, 0.03867760f, -0.03335343f, -0.05381526f, 
    0.02852078f, -0.01685571f, 0.00350002f, 0.03490749f, -0.03894963f, 0.03344937f, 0.04088893f, -0.04978001f, 
    0.04168514f, -0.05415446f, -0.00773322f, -0.04293297f, -0.03492199f, -0.04882130f, -0.00300183f, 0.01891875f, 
    -0.05360860f, -0.02280853f, -0.01485512f, 0.02784712f, -0.04988774f, -0.00682458f, -0.04043994f, -0.02771644f, 
    -0.03951178f, -0.01657402f, 0.00818871f, -0.02877460f, -0.00771690f, 0.04269348f, -0.03222887f, -0.01894949f, 
    0.00807094f, 0.02664046f, -0.05411381f, -0.01569341f, -0.02255273f, -0.03527357f, 0.02996166f, 0.04467588f, 
    -0.04785925f, -0.02518424f, 0.02927463f, 0.00448970f, -0.05575456f, 0.02765371f, -0.04219497f, 0.01745090f, 
    -0.03447909f, 0.03267507f, -0.04363112f, -0.01430932f, 0.03580798f, -0.03192621f, -0.01520438f, -0.01573991f, 
    -0.01786398f, -0.02617238f, 0.03839600f, -0.01408414f, 0.01919279f, 0.03773150f, 0.00468465f, 0.02701389f, 
    -0.03320782f, 0.01761303f, 0.00583571f, -0.03013874f, -0.03652963f, -0.02609645f, -0.01839904f, -0.03445160f, 
    0.00673799f, -0.04153567f, 0.02796593f, 0.03760824f, -0.04503086f, 0.01624376f, 0.00228950f, -0.04894278f, 
    0.02950338f, 0.04065449f, -0.02874539f, 0.03664703f, -0.00761705f, -0.02270950f, 0.02563905f, 0.03410695f, 
    -0.04563065f, -0.05599254f, -0.03131300f, 0.00615143f, -0.03639766f, 0.03206639f, -0.02020548f, -0.05395411f, 
    0.00447276f, 0.03256048f, -0.03530861f, 0.01968289f, 0.01315044f, -0.03607009f, -0.00679926f, -0.04914855f, 
    -0.05569538f, -0.04992088f, -0.03892666f, -0.00740016f, -0.05590533f, -0.01019964f, -0.04963300f, -0.01867661f, 
    -0.02187971f, 0.03285718f, -0.03966350f, -0.04745400f, 0.02630177f, 0.02237787f, 0.03166010f, -0.03516980f, 
    -0.00450243f, -0.04338158f, -0.05555979f, -0.01986822f, -0.03938099f, -0.03800629f, 0.00563966f, -0.01684123f, 
    0.02012841f, -0.02069251f, -0.03364606f, 0.03715323f, -0.02550620f, -0.01976866f, -0.02739123f, 0.02669836f, 
    0.03342412f, 0.00283652f, -0.05038663f, 0.01060381f, -0.02186293f, 0.00977547f, 0.01366548f, -0.04414141f, 
    -0.00159549f, -0.01911394f, 0.02156047f, 0.00136215f, 0.02165299f, 0.01722258f, -0.03933487f, -0.03557411f, 
    -0.01150018f, 0.01722143f, 0.01060179f, 0.03073344f, 0.02375925f, -0.03143677f, 0.02670721f, -0.05551336f, 
    -0.03097651f, -0.03474912f, 0.02731108f, -0.05441215f, -0.03475198f, -0.02511647f, -0.01995258f, 0.03564613f, 
    0.02773586f, -0.01415043f, -0.00478798f, -0.04384704f, -0.00738035f, -0.01768993f, -0.00055545f, 0.01534269f, 
    -0.02356461f, 0.04478200f, -0.04072417f, 0.02459746f, -0.04749325f, -0.05162624f, -0.04117851f, -0.01530020f, 
    0.00852553f, 0.02609314f, 0.03086577f, 0.04359356f, -0.02481432f, -0.00047151f, -0.00808409f, -0.03022703f, 
    0.03017481f, -0.00714730f, -0.01743958f, 0.02368248f, -0.03974743f, -0.04688862f, -0.05199973f, 0.01806661f, 
    -0.02414112f, -0.01945110f, -0.02981344f, 0.00966587f, -0.02050605f, 0.04055024f, -0.00031886f, 0.00023942f, 
    0.02372695f, 0.00803364f, 0.02702224f, -0.04968191f, 0.00900252f, 0.02681448f, 0.01531857f, -0.02593662f, 
    -0.01271895f, -0.03300072f, 0.03075054f, 0.03279164f, 0.03802864f, 0.00901778f, 0.00219236f, -0.02973616f, 
    -0.00939791f, -0.00328583f, -0.01791619f, -0.00650656f, -0.03284921f, 0.02841697f, -0.01476459f, -0.00158206f, 
    0.04138228f, -0.01386019f, 0.01716800f, 0.03656666f, 0.02561779f, 0.00720753f, 0.00173726f, 0.00818689f, 
    -0.03111032f, -0.04159381f, -0.04564124f, -0.04902935f, 0.02327307f, 0.00464574f, 0.03880791f, -0.05571233f, 
    0.02068830f, -0.03337693f, 0.00901371f, 0.00784397f, -0.02753647f, -0.04737988f, 0.03413662f, -0.04457875f, 
    0.00679427f, 0.02158031f, 0.02517577f, -0.04557730f, -0.00867677f, -0.00939195f, -0.00175942f, -0.01519603f, 
    -0.02881724f, -0.02652788f, 0.02365297f, 0.00998308f, -0.05057042f, 0.01579917f, -0.03602792f, -0.03490517f, 
    0.01290230f, 0.01660758f, 0.00697799f, 0.00891764f, -0.03878662f, 0.00730790f, 0.01957137f, -0.03122438f, 
    -0.03500202f, -0.02617181f, -0.04163798f, -0.04089737f, -0.00907792f, 0.00413831f, -0.04061506f, -0.01065823f, 
    -0.02719155f, -0.04456317f, 0.01228487f, 0.02411924f, -0.02867215f, -0.02655629f, 0.01337607f, -0.00718910f, 
    -0.00849541f, -0.02304919f, -0.01664685f, -0.03232636f, -0.00424484f, 0.02934647f, 0.01002723f, 0.04474216f, 
    -0.02285545f, 0.01831989f, -0.00069143f, 0.02332737f, 0.02418380f, -0.04772393f, 0.04506397f, -0.03880343f, 
    0.03977409f, 0.03690633f, -0.02771813f, -0.05490760f, -0.05624683f, -0.01464926f, 0.02052040f, -0.02410936f, 
    -0.02850262f, -0.05295660f, -0.01116647f, 0.00113269f, -0.00837873f, 0.03144985f, -0.00152485f, -0.01146067f, 
    -0.04784791f, -0.25298661f, 0.19427332f, -0.16182856f, 0.04271539f, -0.05237993f, -0.07249216f, 0.15006380f, 
    0.05305446f, -0.05124234f, -0.00033835f, 0.07306615f, -0.22927287f, -0.13063371f, 0.02924584f, 0.07647181f, 
    -0.05941654f, -0.05522382f, 0.01344373f, -0.02789703f, 0.00195959f, -0.04645634f, 0.06273042f, 0.15754528f, 
    0.10207871f, 0.07191298f, -0.17682293f, -0.14716157f, 0.10397451f, -0.03115987f, -0.06024697f, -0.11937838f, 
    -0.00042003f, -0.03608917f, -0.01824355f, 0.07001918f, -0.05326189f, -0.13206710f, 0.10142313f, 0.26199725f, 
    0.02239087f, 0.10145432f, 0.02992929f, -0.10423922f, 0.03827581f, -0.08574748f, 0.11074674f, 0.06946555f, 
    -0.09631515f, 0.05944872f, -0.07625607f, 0.12798773f, -0.04111261f, 0.00021713f, -0.05222512f, 0.15355438f, 
    0.04621870f, -0.00502463f, 0.15923104f, 0.04663978f, -0.11693253f, 0.11754596f, -0.19165953f, 0.21876007f, 
    -0.09957192f, 0.03592655f, -0.04664103f, 0.05864867f, 0.05612645f, 0.04598279f, -0.00543773f, -0.10236502f, 
    0.18713681f, 0.20514539f, 0.02095039f, 0.01811576f, -0.08362108f, -0.02899527f, 0.03046154f, 0.05182566f, 
    0.01418057f, 0.13195714f, -0.07728350f, 0.06460255f, 0.45327911f, -0.06960304f, -0.17959788f, -0.10209783f, 
    -0.12454972f, 0.14769509f, 0.06087646f, -0.12799922f, 0.01810351f, 0.08758039f, -0.13270253f, -0.12409617f, 
    0.29928568f, 0.02557963f, -0.09343632f, 0.01156645f, -0.00499877f, -0.11357240f, -0.00914946f, 0.06617963f, 
    0.06242988f, 0.00307307f, 0.12753999f, 0.01518137f, -0.21089417f, 0.01204289f, -0.16111752f, 0.24450706f, 
    0.04655555f, 0.00820059f, 0.12015062f, 0.00337102f, -0.07144160f, -0.04187061f, 0.01424305f, 0.05930068f, 
    -0.00175930f, 0.09351437f, -0.00042638f, -0.01037767f, 0.06099313f, -0.06523222f, 0.03335505f, 0.00645628f, 
    0.06884354f, 0.09949199f, -0.07553002f, 0.21379068f, 0.17227672f, -0.09978029f, 0.03865505f, 0.06028772f, 
    -0.04797822f, -0.08518278f, -0.01360311f, -0.03140290f, -0.09232570f, -0.06067669f, -0.01252963f, 0.09545518f, 
    0.22852074f, -0.03383296f, -0.10944287f, 0.05311537f, 0.02862421f, -0.03747538f, -0.23743816f, 0.01175880f, 
    0.04763469f, -0.04828654f, 0.11698472f, -0.07054139f, -0.03482789f, -0.04125492f, 0.14154564f, -0.08121701f, 
    0.07906882f, -0.00170687f, 0.03824961f, -0.06024243f, -0.01279458f, 0.03767113f, -0.17175727f, 0.11665445f, 
    0.29012361f, -0.08166074f, 0.03852658f, -0.03209575f, -0.05292643f, 0.10847130f, -0.04603510f, 0.16052695f, 
    0.03049233f, 0.02249652f, -0.06733726f, -0.11595953f, -0.24950787f, 0.14909232f, -0.17865141f, -0.00465902f, 
    0.15471588f, 0.14819598f, -0.12229071f, -0.02143232f, -0.19153520f, -0.22309619f, 0.15026848f, -0.04173311f, 
    -0.19901416f, 0.06667130f, -0.00668326f, 0.01586034f, 0.00077867f, -0.01814895f, 0.01538128f, 0.04492073f, 
    0.16910611f, -0.00514374f, 0.10880120f, 0.19210598f, 0.30116659f, -0.00975903f, -0.02215769f, 0.01833983f, 
    -0.02862788f, -0.01122214f, 0.05835255f, 0.05517697f, -0.07374866f, 0.01247350f, -0.04682598f, -0.01923956f, 
    -0.09118353f, 0.13763568f, -0.04214450f, -0.07670615f, 0.06950262f, 0.03321289f, 0.00692835f, 0.12483767f, 
    -0.04016438f, 0.05479937f, 0.00617174f, -0.02035844f, 0.25358275f, -0.15185267f, -0.02620453f, 0.00712175f, 
    0.00853747f, -0.01715749f, 0.07423785f, 0.06074718f, -0.01121618f, 0.24891260f, -0.05672782f, 0.22882427f, 
    0.04554708f, 0.26364172f, -0.03729213f, 0.11921611f, 0.03411989f, -0.02946680f, 0.07913200f, -0.23032497f, 
    0.11457480f, -0.08732703f, -0.10562161f, -0.03280178f, 0.18028240f, -0.12970847f, -0.05948453f, 0.08954043f, 
    -0.07049724f, 0.01549262f, 0.11755671f, 0.04275975f, 0.04597345f, -0.17026973f, 0.04187820f, 0.03383953f, 
    -0.13115141f, -0.22171104f, -0.02731585f, 0.15872307f, -0.07810140f, 0.11744335f, 0.05441119f, 0.06003881f, 
    -0.04533555f, 0.00927837f, -0.02253261f, 0.00032616f, -0.02231220f, 0.02869873f, 0.03800488f, 0.10879278f, 
    0.05619934f, -0.02033125f, 0.17220934f, -0.06421570f, 0.04182633f, 0.00037069f, 0.13906620f, 0.03489607f, 
    -0.13084997f, -0.02871483f, 0.02415861f, 0.05464220f, 0.06954537f, 0.09797324f, -0.04855001f, -0.17577851f, 
    0.11034555f, -0.02065080f, 0.04092002f, -0.06578214f, 0.09701766f, 0.02073109f, 0.04894862f, -0.12095673f, 
    0.10372490f, 0.03968855f, 0.03153795f, 0.12121885f, -0.00704906f, -0.04088457f, 0.04397207f, -0.09672373f, 
    0.10400978f, 0.00095016f, -0.11927818f, -0.06956872f, 0.06158504f, -0.08749436f, -0.15249522f, 0.01146429f, 
    0.21089813f, -0.06753462f, 0.16352081f, 0.17917542f, 0.20951343f, -0.15902667f, 0.12459138f, 0.08257516f, 
    -0.01130290f, 0.02793942f, 0.02109679f, 0.02813173f, 0.01460898f, 0.10978192f, 0.12082794f, -0.08878922f, 
    0.12824215f, -0.10125472f, 0.07222918f, -0.15044762f, -0.10223044f, 0.05848228f, -0.10417964f, -0.05198991f, 
    0.12555973f, -0.11165974f, 0.00691364f, 0.02350812f, -0.02437562f, 0.13354838f, 0.12930292f, -0.12907694f, 
    0.02733574f, -0.04272820f, 0.17457147f, 0.00072028f, 0.01549824f, 0.13874498f, 0.00041937f, 0.11042825f, 
    -0.01349235f, -0.01410892f, 0.08478002f, 0.09567123f, 0.10544880f, 0.16986264f, -0.13270688f, -0.01695492f, 
    -0.06402722f, -0.18400453f, -0.10067566f, -0.06262816f, 0.15856825f, 0.11911633f, 0.01662223f, -0.03605167f, 
    -0.02434715f, -0.03117434f, 0.03047740f, 0.01760240f, -0.05121154f, 0.04167967f, 0.01104040f, -0.28834438f, 
    0.04340166f, 0.03437193f, -0.02930015f, 0.02081181f, -0.02598293f, 0.01251300f, -0.04725835f, -0.02127827f, 
    -0.01951373f, 0.00446781f, -0.02888764f, -0.01546633f, 0.01008680f, -0.00081200f, -0.02894645f, 0.01770771f, 
    0.03169745f, -0.00481517f, -0.01994011f, 0.02352498f, -0.01560432f, 0.01423110f, 0.01744621f, -0.04620533f, 
    -0.01080797f, 0.02133029f, -0.04152508f, -0.00976574f, -0.02389770f, -0.03758234f, -0.01369087f, -0.05488880f, 
    0.04136013f, -0.04450198f, -0.04933216f, -0.04238372f, -0.03412438f, -0.04808654f, -0.01904850f, 0.02217001f, 
    0.03420280f, 0.02353212f, 0.02848092f, 0.02721083f, -0.02151699f, 0.00941720f, -0.03896856f, 0.03315371f, 
    0.02359045f, 0.03377185f, -0.04899722f, -0.03011034f, -0.05200947f, 0.04351170f, 0.00015297f, 0.01798425f, 
    0.01621064f, -0.02100400f, -0.04575339f, 0.01961817f, -0.02528515f, -0.03678428f, 0.04092303f, 0.03089759f, 
    -0.00600286f, 0.02048369f, -0.01603576f, -0.03347186f, -0.01890163f, -0.04081295f, 0.00223144f, 0.01366288f, 
    -0.04269619f, 0.01999648f, -0.03832098f, 0.02490368f, -0.00036777f, -0.03065202f, 0.04404951f, -0.01623666f, 
    0.02907222f, 0.01846469f, -0.05303777f, 0.01622449f, -0.02914949f, 0.01514692f, 0.01219165f, -0.02486274f, 
    -0.05462505f, 0.00676868f, 0.02309831f, -0.02342687f, -0.02730933f, 0.00967071f, -0.03145108f, 0.02445895f, 
    -0.01780362f, -0.00629552f, -0.05399285f, -0.03903918f, -0.01511966f, -0.04058005f, 0.00517291f, -0.04859209f, 
    -0.00915997f, -0.04652742f, -0.05356484f, 0.02879392f, 0.02060320f, -0.04274863f, 0.01014512f, -0.00630485f, 
    -0.03552827f, 0.01850294f, -0.03622573f, -0.00525908f, -0.03148692f, 0.01175715f, 0.04244805f, -0.04750122f, 
    0.00386523f, -0.03806529f, -0.00696284f, -0.01899234f, 0.04576939f, 0.03481654f, 0.02363931f, 0.00627293f, 
    0.04141762f, -0.00217166f, 0.00761593f, -0.00376675f, -0.00133390f, 0.00458276f, 0.04110933f, -0.00123849f, 
    -0.03958023f, 0.03787546f, 0.02763019f, 0.00988326f, -0.00104660f, 0.01434949f, -0.03006287f, 0.02767231f, 
    -0.05276143f, 0.01728354f, 0.01329936f, -0.04986510f, -0.04728829f, -0.02986436f, -0.04953628f, -0.00046479f, 
    -0.04822754f, -0.01456407f, 0.00171644f, 0.03101733f, 0.04232012f, 0.03185835f, 0.01785782f, -0.02524200f, 
    -0.01669811f, -0.04751150f, -0.04945822f, 0.04245509f, -0.05454341f, -0.03627081f, -0.02934085f, 0.03744633f, 
    0.02243155f, -0.00169180f, -0.05597016f, -0.00077263f, 0.01181657f, -0.04294788f, -0.00771720f, -0.03848179f, 
    -0.03730203f, -0.00169344f, 0.03825807f, 0.03416509f, 0.01039549f, 0.02202424f, -0.00867343f, -0.00494064f, 
    0.01201180f, -0.00704918f, -0.00789000f, 0.02163807f, 0.01231032f, -0.04522102f, 0.00503718f, -0.01041254f, 
    0.00438471f, 0.03933660f, -0.04626466f, 0.00150629f, -0.05104210f, 0.03123325f, -0.02873534f, -0.02225718f, 
    0.00347056f, 0.04316119f, -0.03078996f, -0.05265217f, -0.02855858f, -0.05167966f, 0.00891250f, -0.01265779f, 
    -0.04263621f, -0.03527811f, -0.02684337f, -0.04450183f, 0.03312539f, -0.03786312f, -0.04032947f, -0.02959959f, 
    0.03356710f, -0.05444939f, -0.00317988f, -0.05372514f, 0.04677379f, 0.04440637f, 0.04222178f, -0.04729877f, 
    -0.00060524f, -0.04176389f, -0.00741493f, -0.03288964f, 0.01281459f, -0.00908575f, -0.00225424f, -0.01025577f, 
    0.02369775f, -0.04100570f, -0.01444358f, -0.03513893f, 0.01015659f, -0.03773408f, -0.00461422f, -0.01661635f, 
    0.00376854f, -0.02079498f, 0.01601597f, -0.03427211f, -0.03953182f, 0.02621279f, 0.03720755f, 0.01158571f, 
    0.04380579f, 0.04398803f, -0.00071389f, -0.03167880f, 0.02800099f, -0.05029301f, -0.01444435f, 0.03315393f, 
    0.01870090f, 0.01938231f, -0.02619187f, -0.01322224f, -0.05497989f, -0.02401602f, 0.02172160f, -0.04113801f, 
    0.02701878f, -0.01990988f, -0.01406626f, 0.01729285f, -0.04596385f, -0.01122709f, -0.03063075f, -0.03316766f, 
    0.01229496f, -0.02421230f, -0.02181325f, 0.03213308f, -0.01956716f, -0.03614422f, -0.04571486f, -0.04173884f, 
    0.02894522f, 0.00458429f, 0.00976548f, -0.03993297f, -0.03041710f, -0.02638860f, 0.02555238f, 0.03353308f, 
    0.00450953f, 0.03995000f, -0.02001945f, -0.02632276f, -0.02622682f, -0.02731518f, -0.02180810f, 0.01834118f, 
    -0.01912823f, -0.01020222f, 0.03665157f, -0.00985155f, 0.01260600f, 0.04558972f, -0.03521541f, -0.04132257f, 
    -0.03815378f, -0.04237885f, -0.05684786f, -0.05093354f, -0.03273374f, -0.04412222f, 0.04413436f, -0.02590457f, 
    -0.01438196f, 0.02480877f, -0.02621931f, 0.04187460f, -0.00130038f, 0.03090494f, -0.03177517f, -0.00688740f, 
    -0.02306148f, 0.00107732f, 0.03569550f, 0.03733444f, -0.04870882f, 0.04198186f, -0.04515897f, 0.00157481f, 
    -0.01277085f, 0.03749169f, -0.03004232f, -0.05030712f, 0.00301251f, -0.00334650f, -0.03770173f, 0.02742732f, 
    0.03940385f, -0.05458910f, 0.03316183f, 0.00040706f, -0.05288374f, 0.03838842f, 0.02064642f, 0.04490858f, 
    -0.04831823f, -0.05214956f, 0.02256904f, 0.02621999f, 0.02493504f, -0.03641425f, 0.03132341f, 0.03896862f, 
    -0.00744216f, -0.03983851f, -0.04995096f, -0.01133179f, 0.02031871f, -0.02205213f, -0.00464446f, 0.03342457f, 
    -0.03108194f, -0.04248220f, -0.05095662f, 0.03536634f, 0.00992162f, 0.02878531f, -0.02352349f, -0.04035223f, 
    -0.01154239f, 0.01531820f, 0.00703126f, -0.03535825f, -0.04445804f, -0.00686255f, 0.00705898f, 0.04503208f, 
    0.01949686f, -0.04879031f, 0.03251306f, 0.04618478f, 0.03702989f, -0.01561199f, -0.01888170f, 0.02488079f, 
    -0.02422984f, 0.03604015f, 0.12086450f, 0.14267880f, -0.16473685f, 0.05266178f, 0.05542915f, 0.01410974f, 
    -0.02525802f, -0.00837916f, -0.00676817f, -0.05081025f, 0.08291439f, 0.07382480f, -0.02889832f, -0.08810651f, 
    0.05374436f, 0.00299793f, -0.06290022f, 0.01559676f, -0.02371378f, 0.01488791f, -0.10515658f, -0.12591514f, 
    0.04899617f, -0.17400375f, 0.00590693f, 0.10369790f, -0.01255764f, 0.03711754f, 0.12193264f, 0.04296107f, 
    -0.05253692f, 0.03501833f, -0.13877912f, 0.03731404f, -0.10621575f, 0.00682137f, -0.12826549f, -0.30672297f, 
    0.03152997f, -0.04951388f, -0.15195705f, 0.00886494f, 0.03106637f, -0.01613376f, 0.01986361f, -0.02780010f, 
    0.03897450f, 0.00169375f, -0.19071819f, 0.07097788f, 0.05313101f, -0.03800080f, 0.11136026f, -0.07876670f, 
    0.07954305f, 0.10370658f, 0.04788628f, 0.03460923f, 0.07962401f, -0.10948695f, 0.05786708f, 0.21496697f, 
    -0.00161029f, -0.02622353f, 0.02404206f, 0.03501804f, -0.17185643f, -0.07866215f, -0.13737227f, 0.21237966f, 
    0.24673590f, -0.17675796f, -0.16455886f, 0.12458852f, 0.11817017f, 0.02346341f, -0.00846765f, 0.03987545f, 
    -0.12038025f, 0.05588195f, 0.04020509f, 0.05322490f, -0.28999299f, -0.07636614f, 0.12018712f, 0.07432893f, 
    0.11067594f, -0.03104340f, 0.03365258f, 0.02886528f, 0.10198279f, -0.10487084f, 0.13921000f, 0.10880065f, 
    -0.32505712f, -0.22696751f, 0.06656466f, 0.02919994f, 0.25467360f, 0.13787337f, -0.04747546f, -0.11593600f, 
    0.10398708f, -0.19216502f, -0.06914670f, 0.06718900f, 0.43164510f, 0.05763683f, 0.07156406f, 0.01474282f, 
    0.05115714f, -0.08521841f, 0.12254886f, 0.10711756f, 0.02401019f, 0.01088170f, -0.00210697f, 0.13876355f, 
    -0.03204877f, -0.04568654f, -0.01864118f, 0.06034579f, -0.15589508f, 0.02664392f, -0.01562261f, -0.02999793f, 
    -0.04192566f, -0.15657192f, 0.00758395f, -0.02780364f, -0.41522521f, -0.11418412f, -0.13973424f, 0.04113284f, 
    0.03633767f, 0.10326346f, -0.12399814f, 0.05704702f, 0.10951298f, 0.03849433f, -0.00216267f, 0.15675111f, 
    -0.14674716f, -0.15562986f, -0.21523263f, 0.06014605f, 0.20280319f, 0.08447631f, 0.09058212f, 0.07966422f, 
    -0.00256768f, 0.06304002f, -0.07053772f, 0.06372384f, -0.02040205f, 0.03563053f, -0.17556968f, -0.15297945f, 
    0.12926844f, -0.06530525f, 0.05062144f, 0.07841660f, 0.11523195f, 0.02445107f, 0.03841636f, -0.02915471f, 
    -0.16033649f, 0.05323788f, -0.21350121f, 0.00007012f, 0.03513788f, 0.02602360f, 0.08203772f, 0.04873694f, 
    0.00732216f, 0.02193886f, -0.08265576f, 0.02713206f, 0.07512756f, -0.15478802f, 0.31221732f, -0.08737049f, 
    -0.14333667f, -0.12176760f, 0.15672860f, 0.08405692f, 0.12202460f, 0.05250366f, -0.10827343f, 0.18010008f, 
    0.12392956f, -0.12868647f, 0.08022616f, 0.00418971f, 0.09428120f, -0.01608836f, 0.10623144f, 0.04032520f, 
    -0.02963287f, 0.15897760f, 0.12668379f, 0.07144228f, -0.28998274f, 0.08630116f, 0.01763012f, 0.21154679f, 
    0.04934457f, -0.03692148f, -0.01601550f, -0.03753452f, 0.07824797f, 0.03455379f, 0.01247046f, 0.05928590f, 
    0.01551925f, -0.17487927f, 0.01629044f, -0.25864965f, 0.07672947f, 0.01829300f, 0.00248993f, -0.03696305f, 
    0.16722463f, -0.00064283f, 0.07947090f, 0.08144423f, 0.13263012f, -0.11967706f, 0.13149603f, -0.07770911f, 
    0.04348694f, 0.13685383f, -0.10115679f, -0.04549617f, -0.09785308f, -0.00933118f, 0.11388497f, -0.17761557f, 
    0.33674556f, 0.00503656f, 0.02564886f, -0.02949708f, 0.01729807f, 0.00121116f, -0.05495828f, 0.14306074f, 
    -0.07267820f, -0.06092083f, 0.10662587f, 0.00792745f, -0.24400344f, -0.05862299f, 0.10298450f, -0.00430270f, 
    0.27547112f, -0.02118874f, 0.06994540f, -0.01826752f, 0.26588356f, 0.04409949f, -0.06399159f, 0.25754306f, 
    -0.02838136f, 0.09860910f, 0.16164865f, -0.19282538f, 0.05929476f, -0.02721008f, 0.02556125f, -0.07493589f, 
    0.10764649f, 0.02092024f, -0.05392119f, 0.07343036f, 0.07280492f, 0.04546303f, -0.17131679f, -0.20714651f, 
    0.11458974f, 0.03146254f, -0.09967344f, 0.01994535f, 0.09772934f, 0.04530936f, 0.02678088f, -0.09032768f, 
    -0.02822219f, -0.10262456f, -0.07657475f, -0.29715434f, 0.17077315f, 0.05776900f, -0.07532626f, 0.15362844f, 
    -0.06773268f, 0.07195943f, 0.05480554f, 0.15729637f, -0.32312047f, -0.07182181f, -0.04959020f, 0.03057295f, 
    -0.13700601f, 0.05009674f, -0.07926654f, 0.00754902f, -0.01618912f, 0.07157642f, -0.00915688f, -0.00955275f, 
    -0.25971779f, 0.12015393f, -0.05305169f, 0.01472638f, -0.05829481f, 0.06024092f, -0.04743184f, 0.00538595f, 
    -0.18086436f, 0.06917758f, 0.03455666f, -0.27742887f, -0.12845226f, -0.03904236f, -0.10364416f, -0.00874095f, 
    0.11359187f, 0.04035626f, 0.07891665f, -0.05994265f, 0.17651229f, 0.06286598f, -0.04353999f, 0.17058294f, 
    -0.10889885f, -0.13411786f, 0.03088865f, 0.03005436f, 0.04573582f, -0.07742716f, 0.07639093f, 0.13358280f, 
    -0.00002981f, -0.02511475f, 0.07022678f, 0.02647747f, 0.31650484f, -0.12207755f, -0.00714317f, 0.15780485f, 
    0.07222333f, 0.13201952f, 0.01315637f, -0.04287557f, 0.06008818f, 0.05772435f, 0.10052850f, 0.07648786f, 
    0.20836455f, -0.05957429f, 0.00995565f, -0.06006366f, 0.12263285f, -0.02224622f, 0.09092892f, 0.03710259f, 
    0.05723897f, 0.05337237f, 0.09239800f, 0.01240348f, -0.01094527f, 0.04782797f, 0.05525360f, 0.11187212f, 
    0.07953086f, 0.13745202f, -0.03171762f, -0.02743755f, 0.01868995f, -0.01822795f, 0.02701400f, 0.17621522f, 
    0.07585636f, 0.17584361f, -0.27209157f, 0.01514464f, 0.05381031f, 0.00995821f, -0.05218730f, 0.00301676f, 
    0.06292462f, 0.03895725f, -0.02287998f, -0.08835092f, 0.02128583f, -0.02058637f, -0.00684818f, 0.06683750f, 
    0.13881314f, 0.07287792f, 0.02134834f, -0.08592484f, 0.06707725f, -0.07250121f, -0.00892926f, 0.03864333f, 
    -0.31394547f, 0.09536246f, 0.22618154f, 0.25057703f, -0.02170193f, -0.02012554f, 0.03956611f, 0.14283019f, 
    0.05247261f, -0.00007920f, 0.15112141f, -0.15266058f, 0.29829785f, 0.12985180f, 0.10623734f, 0.07949009f, 
    0.16419937f, 0.00888715f, -0.03613020f, 0.00105449f, -0.12250769f, 0.02635819f, 0.01040178f, 0.03877291f, 
    0.02535872f, -0.05439925f, 0.19692339f, -0.19779934f, -0.03537192f, -0.03192274f, -0.03520101f, -0.04797829f, 
    -0.06914953f, -0.15348844f, -0.03576384f, 0.11168044f, 0.03628674f, -0.08151712f, -0.00132781f, -0.16164112f, 
    -0.02036080f, -0.02106451f, -0.03048686f, -0.00367982f, 0.01597027f, 0.04317169f, 0.00826444f, -0.10099932f, 
    -0.07618406f, 0.11554223f, 0.02994951f, -0.05216070f, 0.04243731f, 0.00360096f, -0.07488377f, 0.01386936f, 
    0.08460438f, -0.05269758f, 0.09013572f, -0.02101549f, 0.18181036f, 0.11963346f, 0.02508250f, 0.13280101f, 
    -0.02192100f, -0.07958543f, 0.05252920f, 0.17390817f, -0.03993729f, -0.00049692f, -0.12189531f, 0.04431535f, 
    0.23880847f, 0.16319977f, -0.05826131f, 0.04680163f, -0.01911834f, 0.00026301f, 0.00940120f, -0.00645581f, 
    -0.08480018f, 0.07972530f, 0.10769035f, -0.06217390f, -0.28853855f, -0.22337882f, 0.09182429f, -0.12816635f, 
    0.08759082f, 0.05006287f, -0.02620698f, -0.12924103f, -0.00246785f, -0.03325471f, 0.05197622f, 0.08004683f, 
    -0.03563984f, -0.11408574f, -0.01683321f, 0.06497028f, -0.01651245f, -0.11128168f, 0.07330497f, 0.01059390f, 
    -0.01514380f, 0.04242825f, 0.01308886f, 0.08297510f, 0.28762621f, 0.04961234f, 0.06282917f, -0.02341240f, 
    0.10567798f, 0.00266236f, -0.01914951f, -0.08840489f, 0.08842953f, 0.11529055f, 0.04392455f, -0.02412504f, 
    -0.16206194f, 0.32261473f, 0.19420521f, -0.04882182f, 0.04849653f, -0.09037291f, 0.11983266f, 0.00385349f, 
    0.08351560f, 0.01694332f, 0.07195947f, -0.03838814f, -0.05561371f, 0.00543157f, -0.08594041f, 0.25934526f, 
    0.12579070f, 0.01040618f, 0.03170229f, -0.13654478f, -0.02557304f, 0.08008987f, 0.04560151f, -0.03391631f, 
    -0.06351556f, -0.07046841f, 0.10351852f, -0.03478645f, 0.02428556f, -0.00095630f, 0.04589177f, -0.06218281f, 
    -0.02167533f, 0.06322440f, 0.12465729f, 0.03364258f, 0.13772377f, -0.12598711f, 0.03194194f, -0.15687117f, 
    0.00867160f, -0.01769394f, -0.00569539f, 0.12132503f, 0.00833340f, 0.06916093f, 0.14015640f, 0.02689189f, 
    0.22111605f, 0.09328827f, -0.00037851f, -0.08668146f, -0.21208172f, -0.02009758f, 0.04275300f, 0.02107717f, 
    -0.11608436f, -0.06017102f, -0.09057198f, 0.00858530f, -0.29797643f, -0.10450984f, 0.02941386f, -0.20413089f, 
    0.10921394f, -0.03179209f, 0.05665606f, 0.10103852f, -0.13481386f, 0.05613872f, -0.03505821f, -0.00886977f, 
    0.28349385f, -0.28090930f, -0.09643924f, 0.26098722f, -0.08563245f, 0.04987149f, -0.02676812f, -0.07107065f, 
    0.03309923f, 0.08448838f, 0.15819326f, 0.05049353f, -0.09496769f, 0.21261331f, 0.04793601f, 0.08681556f, 
    -0.03354468f, 0.01430772f, 0.02519482f, -0.00302128f, 0.09970619f, -0.02680843f, -0.05084270f, -0.06391498f, 
    -0.20942305f, -0.03716828f, -0.05862466f, -0.06523915f, 0.03815680f, -0.05066552f, -0.01260469f, 0.00500989f, 
    0.12801933f, -0.08661669f, -0.01188654f, 0.08711690f, 0.10072157f, 0.03146729f, 0.08257645f, -0.13747959f, 
    0.08515497f, -0.05738038f, 0.12601478f, -0.10466978f, -0.13834809f, -0.13817886f, 0.16006325f, -0.10816501f, 
    0.17242691f, 0.10116098f, -0.01364224f, 0.05147384f, 0.16562605f, 0.04224405f, 0.01220567f, -0.06846520f, 
    0.09254285f, -0.04007873f, 0.00298324f, -0.05886460f, -0.13174492f, -0.06040366f, 0.07018642f, 0.04535566f, 
    -0.05080377f, -0.02726034f, -0.03749520f, 0.01035449f, 0.05948117f, -0.03571171f, -0.01807576f, 0.03654353f, 
    0.23307753f, -0.02718461f, 0.09550668f, 0.12320244f, -0.12645581f, 0.00686344f, 0.01251714f, 0.11236285f, 
    -0.00716716f, 0.06222887f, -0.00695519f, 0.04431320f, -0.11472563f, -0.08442858f, 0.10628788f, 0.24155903f, 
    0.09978653f, 0.10773510f, 0.01459575f, 0.04500288f, 0.05827780f, -0.10098203f, 0.04437053f, 0.06222887f, 
    0.25347474f, 0.06123899f, 0.03595302f, 0.04372611f, -0.06289063f, 0.10493988f, 0.07444899f, -0.06755619f, 
    0.00455764f, 0.09202963f, -0.04916183f, 0.06720708f, -0.22184861f, 0.25591579f, -0.15643433f, -0.01686178f, 
    -0.12152620f, -0.08384178f, 0.00445746f, 0.06287813f, -0.00141513f, -0.11406013f, 0.17794767f, -0.02943138f, 
    -0.18279310f, 0.13590707f, 0.09332138f, 0.37831932f, 0.08666083f, 0.04527601f, -0.00166886f, 0.07947899f, 
    0.00006541f, -0.01607726f, -0.04073808f, 0.06316482f, 0.07191283f, 0.25383687f, 0.00899047f, -0.04217743f, 
    -0.01352199f, -0.05017138f, 0.06590997f, -0.04099984f, 0.11311188f, 0.00314268f, 0.02336047f, -0.01429574f, 
    -0.13457017f, -0.04078333f, 0.01327254f, 0.01885068f, -0.03239568f, -0.07094796f, -0.00101577f, -0.05858203f, 
    0.09881889f, 0.06726393f, 0.12845142f, 0.05046130f, 0.06240668f, 0.01485670f, -0.04756291f, -0.04015854f, 
    0.02855081f, 0.09043983f, 0.00912649f, 0.05535160f, -0.12314517f, 0.03083753f, 0.01254214f, -0.09380863f, 
    -0.01703159f, -0.04745267f, -0.03925940f, -0.08430806f, -0.01661420f, -0.02239221f, 0.05780028f, -0.04690066f, 
    0.08158430f, -0.00303778f, 0.10504755f, 0.03753649f, 0.10558364f, -0.25732249f, 0.00859672f, 0.26609460f, 
    0.09882489f, -0.11876392f, -0.00635242f, 0.08779243f, 0.03357634f, 0.11066627f, 0.13934051f, 0.18036397f, 
    0.36642578f, 0.23071913f, -0.02454689f, 0.14454237f, 0.00626874f, -0.11354255f, -0.01958628f, -0.02065973f, 
    0.01722963f, 0.12720220f, -0.03418435f, 0.03909549f, 0.13085163f, -0.07645000f, 0.05424020f, 0.29762951f, 
    -0.00012823f, 0.05970727f, -0.03669322f, -0.15382524f, 0.02249111f, -0.04811471f, 0.06881975f, 0.22128250f, 
    0.25932702f, -0.06587651f, -0.24990728f, 0.09711815f, -0.02034860f, -0.04717128f, -0.08833147f, 0.13043611f, 
    0.19103138f, -0.04529040f, 0.06965367f, 0.02590187f, 0.01402419f, 0.03477913f, 0.03003180f, -0.10689472f, 
    -0.05313047f, 0.02529683f, -0.20630331f, 0.20172562f, 0.02222814f, 0.15275654f, 0.00442597f, -0.00927961f, 
    0.14842698f, -0.00862635f, -0.01565788f, 0.06420789f, -0.07459841f, -0.02274935f, 0.07994897f, 0.11023398f, 
    0.09374268f, 0.09656402f, -0.15624025f, 0.16168225f, 0.17232010f, 0.03571997f, -0.12058984f, -0.14539218f, 
    -0.05962247f, -0.03897341f, 0.06666762f, -0.10699661f, -0.04930124f, 0.09439751f, -0.20053318f, -0.05655169f, 
    0.15303861f, -0.05294079f, -0.01504286f, -0.02105095f, 0.03692183f, -0.03756344f, -0.21039775f, 0.01996600f, 
    0.07704615f, -0.04126513f, 0.07697441f, 0.09735518f, -0.09244271f, 0.04074717f, 0.11698266f, -0.13139461f, 
    -0.05492271f, 0.10250115f, 0.02383732f, 0.04052073f, -0.06352579f, 0.02243255f, 0.02213874f, 0.03475918f, 
    -0.02070936f, 0.15220717f, -0.07328562f, -0.05953522f, -0.08463858f, -0.07846574f, 0.14315376f, -0.07356917f, 
    0.04745847f, 0.13712102f, -0.16332427f, 0.10850512f, 0.05934625f, -0.11790801f, 0.06572424f, 0.13706610f, 
    0.06293577f, -0.15320277f, -0.04293366f, 0.06667959f, 0.06113686f, -0.01036803f, -0.00490976f, 0.07471529f, 
    0.31480411f, -0.09607909f, -0.02530693f, 0.08795997f, 0.01948770f, -0.06477934f, -0.23394121f, 0.00036219f, 
    0.13053627f, -0.19513428f, 0.00860578f, 0.03343706f, 0.09924803f, -0.13684799f, 0.08630436f, 0.27811196f, 
    0.04493989f, -0.03806164f, 0.05391873f, -0.09283590f, 0.12795277f, 0.05446011f, -0.08747769f, 0.10927182f, 
    0.13940252f, 0.15505101f, -0.13195176f, 0.04519799f, 0.04767944f, 0.13857037f, -0.01028718f, 0.10810820f, 
    0.09713335f, -0.01574934f, 0.10366159f, -0.07085264f, -0.11940971f, 0.09688234f, -0.22765481f, -0.04987122f, 
    0.17131783f, 0.14638574f, -0.03751399f, -0.16657761f, -0.10904618f, -0.16885363f, -0.00435206f, 0.08136553f, 
    0.11884057f, 0.11026967f, -0.25018185f, 0.02001749f, 0.02971444f, -0.06715396f, 0.09820317f, -0.03798633f, 
    0.16065346f, -0.02809842f, 0.09990683f, 0.11972927f, 0.10748066f, -0.06651067f, 0.13767533f, -0.03502723f, 
    -0.03693387f, -0.01559135f, 0.12606889f, -0.08888678f, 0.04477610f, -0.03024564f, 0.10378961f, -0.04288596f, 
    -0.12090772f, 0.34405434f, -0.07790915f, 0.13773243f, 0.05706972f, 0.02103728f, 0.04920975f, 0.08681635f, 
    0.02416540f, -0.00267045f, 0.01894039f, -0.09088827f, 0.03081289f, 0.02607964f, -0.09982459f, -0.19463876f, 
    0.00328016f, 0.07704946f, 0.02243633f, 0.09016737f, 0.10169084f, 0.19834186f, 0.01103874f, 0.16877846f, 
    -0.45648351f, 0.17428699f, 0.10956883f, -0.03267954f, -0.15180109f, 0.03763985f, -0.02435021f, -0.13197877f, 
    0.11473300f, -0.09405073f, -0.12754987f, -0.01986769f, 0.34208137f, -0.17340489f, -0.13530748f, 0.16806656f, 
    0.06747051f, 0.00279540f, 0.01377986f, 0.02880738f, 0.17902501f, 0.00800764f, -0.02032525f, -0.03198292f, 
    0.22510588f, -0.21199480f, 0.13750099f, 0.26706350f, -0.00590739f, 0.07810944f, 0.06235565f, -0.00781138f, 
    0.06793667f, 0.09249837f, 0.08593632f, 0.02835816f, 0.24408197f, -0.20473096f, 0.04491730f, 0.26181093f, 
    0.12980056f, -0.07156557f, 0.15676247f, -0.07405268f, 0.01433970f, 0.03446583f, 0.22523420f, 0.08821708f, 
    -0.35549289f, 0.18642201f, -0.09491079f, -0.10022948f, 0.08690511f, 0.16199823f, -0.17142108f, -0.03922182f, 
    0.11824549f, 0.03386804f, 0.13425305f, -0.18599930f, 0.26024103f, 0.13574918f, -0.07344471f, -0.00754478f, 
    -0.00513883f, 0.05434548f, 0.06737719f, -0.03193272f, -0.03759562f, 0.03519167f, 0.02416148f, -0.13818285f, 
    0.08837993f, 0.18041319f, -0.05127397f, -0.10350099f, 0.01894899f, -0.03115395f, -0.07146418f, 0.09800649f, 
    0.00988685f, -0.06560598f, 0.12939079f, 0.19977206f, 0.08038042f, -0.14541756f, 0.03659647f, 0.10533614f, 
    -0.00587568f, -0.04236270f, 0.00183864f, 0.04617701f, 0.23069176f, 0.10972654f, 0.13069573f, -0.12426279f, 
    0.10932039f, 0.02440831f, -0.00371368f, -0.17419983f, 0.07997260f, 0.13716979f, 0.04666267f, -0.08179756f, 
    0.07393400f, -0.12283204f, -0.01250446f, -0.04810827f, 0.17946488f, 0.03281838f, -0.27241534f, -0.13480814f, 
    0.19343539f, -0.02344130f, 0.11385939f, -0.02753848f, 0.01950012f, 0.10913277f, 0.09199510f, 0.17704193f, 
    0.15105258f, -0.00534532f, 0.07492954f, 0.02678480f, 0.00756711f, 0.14071564f, -0.04966731f, -0.07874125f, 
    -0.07454252f, -0.26417616f, -0.09584496f, -0.16890107f, 0.12859602f, 0.15405692f, -0.09979288f, 0.03433935f, 
    -0.05480241f, -0.00174963f, -0.03926416f, 0.12380072f, 0.01435346f, -0.08714153f, 0.08963960f, -0.23847897f, 
    -0.24974822f, -0.03455099f, 0.11794554f, -0.01823300f, 0.09602401f, -0.03049338f, -0.07531647f, 0.15928988f, 
    0.07261711f, -0.01537045f, -0.02456918f, -0.03518878f, -0.10660572f, 0.17152272f, 0.14952795f, 0.03098756f, 
    0.04373423f, -0.01746620f, 0.00361908f, -0.06109285f, 0.01908974f, -0.15857086f, -0.02379376f, 0.04173321f, 
    -0.32309014f, -0.28093177f, -0.20215854f, -0.22816077f, 0.18546614f, 0.04855907f, -0.02104189f, -0.07945208f, 
    0.08862333f, -0.04203853f, -0.05456724f, -0.04166893f, 0.28242585f, 0.16029027f, 0.16421889f, 0.13197009f, 
    0.09092278f, -0.03484696f, 0.00789502f, -0.11127535f, 0.00761565f, -0.06190286f, 0.08799240f, 0.07688098f, 
    -0.23421210f, -0.16588946f, -0.12230942f, 0.09044799f, -0.08787768f, -0.04456934f, 0.08544481f, -0.06737781f, 
    -0.07849785f, 0.06955221f, 0.08830310f, 0.09652390f, -0.20780967f, -0.06213688f, -0.00260696f, 0.32144141f, 
    0.05097222f, 0.06418853f, 0.03799133f, -0.03276645f, 0.02298766f, -0.01680330f, -0.04564866f, -0.12723215f, 
    0.27826843f, 0.19351424f, -0.06759886f, -0.01850598f, 0.05071217f, -0.08392028f, -0.03230267f, 0.03910842f, 
    -0.00219955f, 0.00285731f, -0.10284664f, 0.02274907f, 0.47211081f, 0.07413597f, -0.22455990f, -0.12734157f, 
    -0.03118036f, 0.03022043f, 0.04095470f, -0.04468332f, 0.04988466f, -0.03308304f, -0.07696255f, -0.01178309f, 
    0.26538414f, 0.23079710f, 0.06699330f, 0.19763897f, 0.02000200f, -0.12428753f, 0.04616036f, -0.06301829f, 
    0.01692789f, 0.02369980f, 0.03159666f, 0.12352423f, -0.40397462f, -0.25404897f, 0.05384427f, 0.22756657f, 
    0.05339697f, 0.00150768f, 0.03614086f, -0.06282398f, -0.16372088f, 0.07053736f, 0.07044452f, 0.03956797f, 
    -0.23181316f, -0.06838378f, -0.10159181f, 0.00430609f, 0.13825452f, -0.05469771f, -0.02411986f, 0.08812510f, 
    0.02548573f, -0.07151604f, -0.04086962f, 0.15191068f, 0.01386320f, 0.13321047f, 0.09624518f, 0.14765202f, 
    -0.01431369f, -0.02207856f, 0.00029663f, -0.13612862f, -0.05129657f, -0.00592979f, -0.06590870f, 0.04020213f, 
    0.01895876f, 0.03451879f, 0.08312026f, 0.05470571f, 0.04893401f, -0.03433535f, -0.05018991f, 0.06141113f, 
    0.07876302f, 0.03198308f, 0.01619385f, -0.04652471f, 0.00876241f, 0.12130205f, 0.01086289f, -0.02402566f, 
    0.09586555f, -0.03281047f, 0.08215188f, -0.07323924f, 0.04520028f, 0.14047761f, -0.09353732f, 0.11628237f, 
    -0.10557093f, -0.26228985f, -0.21349038f, -0.09759802f, -0.09009063f, 0.09341837f, 0.01881913f, -0.00487938f, 
    0.05971861f, 0.01335664f, 0.05948628f, -0.04880048f, -0.11415555f, -0.03245979f, -0.08159573f, 0.01445897f, 
    -0.03646107f, -0.00171995f, -0.12033061f, 0.11234003f, -0.04257992f, -0.12566692f, 0.19539100f, -0.14772390f, 
    0.01554294f, -0.16669649f, 0.07958198f, 0.06969402f, 0.07221495f, 0.01601055f, 0.04669541f, 0.00771382f, 
    0.04179356f, 0.03123761f, 0.06057605f, 0.17825206f, -0.18003504f, -0.04080308f, -0.07333250f, -0.04337465f, 
    0.11320610f, -0.06913443f, 0.07395671f, 0.04728876f, -0.10704359f, 0.03933603f, -0.03997376f, -0.00479539f, 
    0.15590976f, -0.32843244f, -0.00980403f, 0.02567500f, -0.10573533f, 0.05875813f, 0.00165932f, 0.13777438f, 
    0.01410060f, 0.06489587f, 0.13123304f, 0.10350576f, 0.05214898f, -0.14112063f, -0.17222385f, -0.06242415f, 
    0.09397162f, 0.06190705f, 0.00213502f, 0.09603769f, 0.03681307f, 0.13788998f, -0.04193740f, 0.10754707f, 
    0.32726279f, 0.10541276f, 0.00361905f, 0.00472175f, 0.13336058f, -0.03111576f, 0.06706966f, -0.11920222f, 
    -0.02546713f, 0.01038029f, 0.02417654f, 0.10708793f, -0.06662127f, 0.19690140f, -0.02213969f, -0.03341910f, 
    -0.03591697f, -0.01996850f, 0.13552994f, -0.05721442f, 0.11117483f, -0.06931846f, 0.08339541f, 0.13367595f, 
    -0.04046232f, 0.12255103f, 0.05074897f, 0.13425133f, 0.08607737f, 0.07772002f, -0.04190235f, -0.02075086f, 
    -0.16066775f, -0.00175482f, -0.06586667f, -0.07072546f, -0.01102098f, 0.20577666f, 0.06731483f, -0.06558608f, 
    -0.03933575f, -0.04693094f, 0.10135359f, 0.02157174f, -0.00150242f, 0.03254139f, 0.05389724f, 0.00451579f, 
    0.13548741f, -0.32880563f, 0.34227782f, 0.16179553f, 0.14384373f, 0.00707806f, -0.16966809f, -0.14408088f, 
    -0.00748814f, -0.02450598f, 0.06017742f, 0.01026813f, -0.31156525f, -0.27280834f, -0.11803984f, -0.14650762f, 
    0.10326283f, 0.02806001f, 0.09299862f, -0.00907501f, 0.08351006f, -0.04774819f, 0.06710801f, -0.00754472f, 
    0.05888065f, 0.01660710f, -0.15997745f, -0.06050098f, -0.05122493f, -0.09090052f, -0.11747189f, -0.03299096f, 
    0.14713775f, -0.01356804f, 0.21720402f, 0.02484075f, -0.15451929f, -0.00732316f, -0.12715134f, 0.04548634f, 
    -0.01331246f, -0.00369729f, 0.00930512f, 0.07891424f, 0.01440521f, -0.03848975f, 0.12060811f, -0.06895912f, 
    -0.14036956f, -0.12166921f, 0.05087747f, -0.12212350f, -0.02386444f, -0.05048095f, -0.05908136f, 0.13396282f, 
    0.09382250f, -0.08769421f, -0.00745876f, 0.06885345f, 0.00304346f, 0.29767087f, 0.07997776f, -0.15744071f, 
    0.07889695f, -0.00943393f, 0.02994210f, -0.06981374f, -0.01781031f, 0.01386876f, 0.02676530f, 0.08479258f, 
    -0.07892238f, -0.02164900f, -0.00475271f, 0.21351793f, 0.18814029f, 0.07244720f, -0.16307835f, -0.11673357f, 
    -0.00024147f, -0.09800950f, 0.02049593f, -0.02753560f, 0.33662665f, 0.15717059f, 0.03217938f, -0.02994314f, 
    0.00913564f, 0.13282721f, 0.00757267f, -0.01470132f, 0.01869801f, 0.21746472f, 0.02632909f, -0.18115604f, 
    -0.02261475f, -0.04958250f, 0.02854775f, 0.01646842f, -0.00266842f, -0.03274432f, -0.02430176f, 0.03028368f, 
    0.02926775f, 0.00600684f, 0.00616487f, 0.03181430f, -0.00482474f, -0.00501208f, 0.03008045f, -0.04673218f, 
    -0.00850634f, -0.00800674f, -0.02456892f, 0.01844207f, 0.02665590f, -0.02967443f, -0.03540446f, 0.02045480f, 
    0.04083458f, -0.03208650f, -0.03706896f, 0.01526654f, 0.01733135f, -0.03792085f, 0.00434812f, 0.03446903f, 
    0.02189149f, -0.04052049f, -0.00088320f, -0.01995160f, 0.00232665f, -0.01741335f, -0.00746110f, 0.03026442f, 
    0.01250625f, 0.01605430f, 0.02341517f, -0.02994903f, 0.02809211f, 0.03304187f, 0.02845355f, -0.01187070f, 
    0.02450508f, 0.02091579f, -0.03112946f, 0.00947866f, 0.03439674f, 0.03674776f, 0.02140808f, -0.04226506f, 
    0.03646487f, 0.01198222f, 0.01683677f, -0.02118717f, -0.02441878f, 0.01834101f, -0.00443462f, 0.03371354f, 
    0.00775415f, 0.03490400f, 0.02924057f, -0.02028550f, -0.00582748f, 0.02301258f, -0.04338823f, 0.02919124f, 
    0.01427964f, -0.04085547f, 0.02877206f, 0.02502735f, -0.04376347f, 0.02949975f, 0.01556007f, 0.02703115f, 
    -0.02484060f, -0.05284580f, -0.04954235f, 0.02159658f, -0.04491722f, -0.04118319f, -0.03752193f, 0.03017012f, 
    -0.03935847f, -0.04202966f, -0.01609438f, -0.02017255f, -0.01475798f, 0.03554920f, 0.02599498f, 0.01546630f, 
    -0.00433578f, -0.01645349f, -0.03222555f, -0.04650617f, -0.03502856f, -0.03133111f, -0.05184076f, 0.01792992f, 
    0.01311480f, -0.04542002f, -0.02562317f, -0.02022087f, -0.05707764f, 0.00388762f, -0.05673035f, -0.03536860f, 
    -0.00154910f, -0.01172177f, -0.03512801f, -0.00570768f, 0.01928460f, -0.05024521f, -0.01371756f, -0.03829045f, 
    -0.01744172f, -0.05235544f, 0.04218499f, -0.02152296f, 0.01392624f, -0.01414676f, -0.03428430f, -0.02983412f, 
    0.04206453f, -0.02513418f, -0.03320247f, 0.01412337f, 0.02163164f, 0.04140435f, 0.00933465f, -0.04201815f, 
    -0.02715150f, -0.05347284f, -0.03568423f, 0.00344478f, 0.01719657f, -0.05263722f, 0.03668027f, -0.04585927f, 
    -0.04385306f, -0.01660489f, -0.01734612f, 0.02798221f, -0.00231453f, 0.00395750f, 0.04198839f, -0.02699404f, 
    0.01829337f, -0.05385575f, 0.00226845f, -0.02733682f, -0.05611774f, -0.00848062f, -0.04511407f, 0.01220551f, 
    0.01063253f, -0.03855651f, -0.01488568f, -0.03658475f, -0.02142195f, -0.00099838f, -0.04488754f, 0.01624438f, 
    -0.03850589f, -0.02857954f, -0.02363917f, -0.00691200f, 0.03834516f, 0.03661359f, -0.00430855f, -0.04734942f, 
    -0.03423850f, 0.04277166f, -0.04713167f, 0.03038464f, -0.01962143f, -0.00573747f, -0.04908768f, -0.02322566f, 
    -0.04531163f, -0.00866737f, 0.04240378f, -0.01471790f, -0.01938530f, 0.02539061f, 0.00868777f, -0.04931597f, 
    -0.01323461f, -0.00619881f, 0.04219193f, 0.00224445f, -0.03248303f, -0.03071984f, 0.04342210f, -0.01032970f, 
    -0.03253435f, -0.04426226f, -0.01562750f, -0.04805424f, -0.02073890f, -0.02233391f, 0.02905984f, -0.03132775f, 
    0.01733330f, -0.04243646f, 0.04483446f, -0.03613069f, -0.02295063f, -0.02534636f, -0.00153089f, 0.03897003f, 
    -0.02025254f, 0.01721734f, 0.02867763f, 0.01979278f, -0.03994731f, -0.04304107f, 0.04231614f, -0.03719512f, 
    0.01321924f, 0.02645211f, -0.01983688f, 0.00075942f, -0.03077275f, -0.01247992f, -0.03750342f, -0.02328001f, 
    -0.01124397f, 0.02028861f, -0.00157304f, -0.05177565f, -0.00143545f, 0.00861927f, 0.03326276f, -0.04476112f, 
    0.00049549f, -0.02878194f, -0.03510416f, 0.03570222f, 0.00289373f, -0.00651335f, 0.02430765f, -0.03428240f, 
    0.02108747f, -0.01924743f, -0.02409486f, -0.05534249f, -0.00308201f, 0.02353501f, -0.05199195f, -0.03158442f, 
    -0.00415193f, -0.04710472f, -0.04643072f, 0.03773795f, 0.02490402f, 0.00553187f, -0.05685980f, -0.00110584f, 
    -0.04968382f, -0.00951918f, -0.00142726f, 0.01688069f, -0.00792114f, 0.01874950f, -0.01220310f, -0.04453811f, 
    -0.02354213f, -0.02216941f, 0.02346593f, 0.00469287f, -0.05371431f, 0.01530136f, 0.00114242f, 0.01460007f, 
    -0.03809783f, 0.02626536f, 0.00844584f, 0.02801575f, -0.05033537f, 0.02057779f, -0.04697510f, -0.00396058f, 
    -0.00524663f, -0.00776549f, -0.03672583f, -0.02540560f, -0.04732135f, -0.05461176f, -0.01044135f, -0.04904262f, 
    -0.05786981f, -0.01992166f, 0.01447707f, -0.03231984f, -0.03651129f, -0.02783498f, -0.04003073f, 0.01430675f, 
    0.01469231f, -0.05424488f, -0.01987126f, -0.04377308f, -0.03922008f, 0.01897327f, 0.00466879f, 0.00366948f, 
    -0.04307058f, -0.03197563f, 0.03981981f, -0.03335723f, -0.05159590f, -0.00812514f, 0.03547599f, 0.01067187f, 
    0.01867097f, 0.02053027f, -0.03712517f, 0.03897679f, 0.00927576f, 0.00725825f, 0.04172591f, -0.03391268f, 
    0.01559974f, 0.02638142f, 0.02718616f, 0.01386624f, -0.02308647f, -0.03177276f, -0.03220017f, 0.01477238f, 
    -0.02732897f, 0.02346484f, 0.03351222f, -0.00941989f, 0.04325720f, -0.04387686f, 0.02446764f, 0.02657689f, 
    -0.00600490f, -0.04938070f, -0.00484041f, -0.00400597f, -0.03900249f, -0.04269673f, -0.05347820f, -0.01383006f, 
    -0.02910547f, -0.02871563f, -0.04754736f, 0.01975658f, -0.04224694f, 0.00416481f, 0.02264924f, -0.01257823f, 
    -0.05897297f, -0.00460938f, -0.00561414f, 0.03496434f, 0.00824360f, -0.03773031f, 0.03598039f, -0.01018105f, 
    -0.03114955f, -0.05247268f, 0.04315015f, 0.00252401f, -0.03876626f, 0.00588512f, 0.03531930f, 0.03143277f, 
    -0.03093096f, -0.02635192f, -0.05274423f, -0.04632610f, 0.01112996f, -0.01351000f, 0.03577138f, -0.00358202f, 
    0.01044532f, -0.00485977f, 0.02591556f, 0.01717837f, 0.02748470f, -0.04676912f, -0.03133046f, -0.05365771f, 
    0.01527886f, 0.03579221f, 0.01831319f, -0.03947693f, 0.02906749f, 0.00233233f, -0.03044285f, -0.03474012f, 
    0.01934976f, -0.02015076f, 0.01704204f, 0.03607346f, -0.00441666f, -0.02940006f, -0.00524629f, -0.02344890f, 
    -0.04476845f, -0.04870666f, 0.00573422f, -0.03259941f, -0.00103776f, 0.03817173f, -0.00478069f, 0.03841477f, 
    -0.04805609f, 0.03988865f, -0.04646398f, 0.02575232f, -0.04452967f, -0.05146879f, -0.04487297f, -0.02000769f, 
    -0.00445840f, -0.03174084f, -0.03391955f, 0.00302849f, -0.03195556f, 0.02457554f, -0.00716321f, 0.02404263f, 
    0.01301846f, -0.00390716f, -0.04988533f, -0.02750463f, 0.01431540f, -0.01139517f, -0.00022943f, 0.03476848f, 
    0.04285768f, 0.01399745f, -0.01926770f, 0.02229369f, -0.01739963f, -0.02302290f, 0.01272445f, 0.02259646f, 
    0.01862111f, -0.01882390f, -0.04898786f, -0.00853263f, 0.02762362f, -0.05568295f, 0.04345876f, 0.01035050f, 
    0.00624011f, -0.02182959f, 0.03416979f, 0.04250767f, 0.02032946f, -0.05429920f, -0.01629295f, 0.01425259f, 
    -0.04028984f, 0.04449318f, 0.00969271f, -0.05312826f, 0.04081583f, -0.05123596f, -0.03548124f, 0.00969695f, 
    0.02084376f, -0.04279518f, -0.00433631f, 0.02475356f, -0.05217489f, 0.01847263f, -0.01017187f, 0.03939956f, 
    0.02942634f, -0.00642635f, -0.05348058f, 0.02854155f, -0.04134484f, 0.01059288f, 0.01431419f, -0.01879386f, 
    -0.01898260f, 0.02181485f, 0.03659952f, 0.02577215f, -0.03212411f, 0.01266590f, -0.04641291f, -0.02289999f, 
    0.02416845f, -0.05346164f, 0.02062669f, -0.04415926f, -0.00383315f, -0.04223723f, -0.01738032f, -0.02543603f, 
    -0.02700268f, 0.00007379f, -0.00359939f, -0.04248679f, -0.03916524f, 0.02461900f, -0.03863923f, -0.04740810f, 
    -0.05325618f, 0.01832533f, 0.04382017f, -0.03072400f, -0.01832165f, -0.04030562f, 0.02087337f, -0.00269824f, 
    -0.04132916f, -0.04232472f, -0.03852106f, 0.03539697f, -0.01689864f, -0.02661273f, 0.03327095f, -0.03978854f, 
    0.02184050f, 0.01810961f, 0.01392384f, 0.00299139f, 0.00794835f, 0.04207483f, -0.03018596f, -0.02670253f, 
    -0.00426223f, -0.02980391f, 0.00313164f, -0.00047639f, -0.00953642f, 0.01673770f, 0.03197539f, 0.04316539f, 
    -0.00652286f, 0.02217183f, -0.04317011f, 0.02675494f, -0.04814332f, -0.03919723f, -0.00616892f, 0.01714277f, 
    0.03654464f, -0.01161769f, 0.00514882f, 0.02420363f, 0.02322138f, 0.01670875f, -0.00034383f, -0.05132671f, 
    -0.04755357f, -0.00939643f, 0.02187735f, 0.00153130f, 0.01083404f, -0.02351883f, -0.02710407f, -0.04105749f, 
    0.02272511f, -0.02685020f, 0.01922908f, -0.01263275f, -0.04164124f, -0.03484697f, -0.03973014f, -0.04510600f, 
    0.00278765f, -0.05450286f, -0.02685679f, -0.00746770f, 0.01767362f, -0.02402033f, 0.02727241f, 0.01648532f, 
    -0.05625075f, -0.05228746f, -0.01550359f, -0.04713562f, 0.02175212f, 0.02788005f, 0.02955612f, -0.00810597f, 
    -0.02054381f, 0.01688437f, -0.03819733f, -0.00761200f, -0.03132224f, -0.01458544f, -0.03294244f, -0.04786074f, 
    -0.01974958f, 0.03302003f, 0.01484075f, -0.05402132f, -0.04564406f, 0.02917960f, -0.03569305f, 0.02609836f, 
    -0.03110233f, -0.04093530f, -0.05539760f, -0.03945083f, 0.02342682f, 0.03264626f, 0.01287912f, -0.02437047f, 
    -0.01206466f, -0.02302456f, -0.05350897f, 0.04090066f, -0.00029417f, -0.00638999f, -0.05056397f, -0.03871350f, 
    -0.04969679f, -0.00801777f, 0.02513142f, 0.01982568f, -0.02186400f, 0.00967789f, 0.01767404f, -0.00371742f, 
    0.00951051f, -0.03579786f, -0.02018189f, -0.04585698f, -0.01819057f, 0.02755430f, -0.04996396f, -0.00687954f, 
    0.03598490f, -0.04524853f, -0.04584824f, -0.03137624f, -0.05642894f, 0.04374560f, 0.01538876f, -0.03844688f, 
    -0.01050837f, -0.05549413f, -0.00685843f, -0.02384378f, -0.03503413f, 0.02331341f, 0.02969799f, 0.03944917f, 
    0.01875273f, 0.03497784f, 0.02321488f, -0.04908961f, -0.04094764f, 0.00316715f, -0.05599461f, -0.01528366f, 
    -0.04836588f, 0.04005274f, 0.00822201f, -0.00874947f, 0.01919468f, 0.00161987f, -0.02759645f, 0.04011951f, 
    0.01087805f, -0.00098333f, -0.03883510f, -0.00789856f, 0.04164809f, -0.03007514f, -0.00846327f, 0.00894674f, 
    -0.04824651f, 0.04347889f, 0.03498308f, -0.02284687f, -0.01518377f, -0.03149453f, -0.03073171f, -0.01508744f, 
    0.04158540f, 0.02444325f, -0.05556843f, -0.03241373f, 0.01728913f, -0.00203494f, -0.00684438f, -0.02435065f, 
    -0.04314872f, -0.02137003f, 0.01945150f, 0.02741272f, 0.03312749f, 0.02255206f, -0.04075617f, 0.03673491f, 
    0.02662492f, 0.00617032f, -0.03210050f, -0.03130680f, 0.00821104f, 0.02265172f, -0.02121598f, 0.00715459f, 
    0.00894802f, -0.02166954f, -0.03193930f, 0.00881504f, 0.02907995f, -0.02571259f, -0.04709295f, 0.01979624f, 
    0.02100764f, -0.00109930f, -0.05274300f, -0.03195868f, -0.01961824f, 0.02628367f, -0.04748326f, 0.04480006f, 
    -0.02435270f, 0.01584219f, 0.00056154f, 0.01524145f, 0.00734285f, 0.01837529f, 0.00235012f, -0.00667322f, 
    0.03375151f, -0.01384414f, -0.05688290f, -0.04740215f, 0.00988968f, 0.03151100f, -0.00827070f, -0.02881480f, 
    -0.05597892f, 0.01113311f, 0.02144126f, 0.02805316f, -0.02625263f, -0.05273444f, -0.04408115f, -0.02162637f, 
    -0.01416956f, 0.02740606f, 0.01400699f, -0.00571982f, -0.00718147f, -0.05128272f, 0.02857109f, -0.00716554f, 
    -0.02990556f, -0.00211505f, 0.02939241f, -0.05335251f, -0.01914180f, 0.02328270f, 0.02705197f, 0.03670476f, 
    0.21483470f, 0.06597272f, -0.13572599f, -0.11433849f, -0.09952000f, -0.05083911f, 0.11850058f, -0.08710503f, 
    -0.01885201f, -0.08698642f, -0.05874126f, 0.07473198f, 0.37492725f, -0.14069237f, 0.05376445f, 0.37199953f, 
    -0.04259927f, 0.03354549f, -0.03546388f, 0.00812068f, -0.05421583f, -0.00949717f, -0.06623900f, -0.01128287f, 
    0.20043194f, -0.06951461f, 0.16459106f, 0.17005481f, 0.01297755f, 0.02516443f, 0.06140428f, 0.12830801f, 
    0.03919348f, 0.04539924f, 0.08564518f, 0.02566084f, 0.24682479f, 0.10360386f, -0.06187585f, 0.06394907f, 
    -0.06658422f, 0.09719574f, -0.03847383f, 0.06366571f, 0.03287300f, -0.02654110f, -0.07987320f, -0.04275249f, 
    -0.00259282f, -0.06097401f, -0.08291439f, -0.08733622f, 0.05386020f, 0.09342640f, -0.08218768f, 0.04332709f, 
    0.06313702f, -0.09145174f, -0.13107510f, 0.10719821f, -0.17371666f, 0.07725488f, -0.13549627f, -0.16849345f, 
    -0.01354544f, -0.00414829f, -0.08697587f, 0.00958565f, -0.15302391f, 0.02286930f, 0.04816493f, 0.16647686f, 
    -0.06359699f, 0.01542715f, 0.03224972f, -0.00260373f, -0.02203010f, 0.00497631f, -0.03178943f, -0.08911304f, 
    0.13481045f, 0.02600162f, -0.01905997f, 0.02091557f, -0.25386980f, -0.04614120f, 0.14552559f, 0.10638011f, 
    0.00689292f, -0.03813159f, 0.00248407f, 0.20937710f, -0.04779655f, 0.05461772f, 0.10174901f, -0.02598521f, 
    0.17880027f, -0.11826917f, -0.00570428f, -0.08804386f, -0.06009568f, 0.05240420f, 0.15908800f, -0.00822391f, 
    0.03650675f, -0.14769119f, -0.04812027f, -0.02755558f, 0.04396883f, 0.19844018f, -0.29973730f, -0.03767926f, 
    -0.01467843f, -0.01351776f, -0.07504476f, 0.10490835f, 0.07477740f, -0.01737170f, 0.05559632f, 0.00971972f, 
    -0.02656595f, -0.08038655f, 0.06581663f, 0.01384158f, -0.13764000f, 0.00021730f, -0.04413331f, -0.05158510f, 
    0.00610220f, 0.14057602f, 0.12017296f, -0.02987832f, 0.27001128f, -0.02426258f, -0.05073095f, 0.28669527f, 
    0.02112493f, -0.06492425f, 0.07207756f, 0.02617460f, 0.09496168f, 0.07006467f, -0.02992423f, 0.00960917f, 
    0.32480118f, -0.16656403f, -0.12552144f, 0.09147053f, 0.03417267f, 0.13150543f, 0.09362587f, -0.02605791f, 
    -0.03694503f, 0.06778112f, 0.03174371f, -0.03782574f, 0.13204773f, -0.12407798f, 0.17186695f, 0.15131643f, 
    0.01057009f, -0.04323799f, -0.01736167f, -0.02420294f, -0.09691623f, -0.01027666f, 0.08590442f, -0.05933826f, 
    -0.09431181f, 0.22083506f, 0.07541520f, 0.02787733f, 0.00028902f, -0.00862304f, -0.03022633f, 0.03421363f, 
    0.01785646f, -0.13106614f, -0.02461434f, 0.01104257f, 0.09961291f, -0.17299448f, -0.06429983f, -0.20638430f, 
    -0.14849208f, -0.02136457f, 0.19104113f, -0.01231899f, 0.00690402f, 0.06567377f, -0.03833163f, 0.10829190f, 
    -0.02900108f, 0.15710203f, -0.16925497f, -0.14342904f, 0.04629210f, 0.02381674f, 0.03403109f, 0.03236351f, 
    -0.00530612f, -0.10106380f, -0.02625808f, -0.09652194f, -0.13842447f, 0.07061649f, -0.07585589f, 0.17356585f, 
    -0.01677000f, -0.00738014f, -0.07348429f, 0.01799345f, -0.07780159f, -0.00687658f, 0.03943631f, -0.09709021f, 
    -0.21308856f, 0.38766551f, -0.07349440f, -0.17846391f, 0.10986340f, -0.08542950f, 0.10595841f, -0.20315532f, 
    0.03266750f, -0.00520384f, 0.07406539f, 0.02413477f, -0.03094439f, 0.05884584f, 0.17794399f, -0.02078747f, 
    -0.04752245f, 0.02444250f, 0.11251698f, 0.13054343f, 0.02062368f, -0.00842856f, 0.05554093f, -0.11777622f, 
    -0.26823509f, -0.16722652f, -0.14275569f, 0.05216893f, -0.06291336f, 0.05710527f, -0.00553882f, 0.17943208f, 
    0.08396342f, 0.03027064f, -0.01313938f, -0.02516938f, 0.23177437f, -0.13955216f, 0.03879462f, 0.13292851f, 
    -0.04874784f, 0.01752230f, -0.02535650f, 0.04686394f, -0.03328693f, -0.01615374f, -0.03137564f, -0.10860012f, 
    0.35739240f, 0.03604089f, 0.17195201f, 0.07206103f, -0.07471280f, -0.00256345f, 0.08587535f, -0.05421718f, 
    0.07079090f, 0.06125779f, -0.05080381f, -0.03733869f, -0.01567844f, -0.11585264f, 0.14312419f, 0.05953351f, 
    0.00885841f, 0.01954520f, -0.06350614f, 0.02044746f, -0.05171176f, 0.01618588f, -0.00404483f, 0.02155810f, 
    0.06710491f, 0.33850503f, -0.26232469f, -0.09825204f, -0.01924992f, 0.21881540f, 0.17092952f, 0.13134909f, 
    -0.05763988f, 0.00482906f, 0.10644019f, -0.01200917f, -0.11573850f, -0.06442742f, 0.07735071f, 0.09167138f, 
    0.08597282f, -0.06962756f, 0.05032619f, 0.13622995f, -0.07753612f, 0.13020048f, 0.00203010f, -0.03362489f, 
    0.04859966f, -0.01531234f, 0.11595923f, 0.16851091f, -0.06572919f, 0.09554810f, 0.06134846f, 0.04904961f, 
    -0.14137429f, 0.04567448f, -0.08267180f, -0.05968239f, -0.15718840f, 0.00047563f, 0.06716330f, -0.04662470f, 
    -0.04677247f, -0.02776938f, 0.05989028f, -0.04043430f, 0.05067240f, 0.04036519f, 0.04064053f, 0.01302914f, 
    -0.03021783f, -0.02373129f, 0.07766517f, 0.04501105f, 0.15302150f, 0.05218827f, 0.09867340f, -0.02333855f, 
    -0.02979456f, 0.05069255f, 0.02052969f, 0.09107347f, 0.13302289f, -0.22764896f, 0.03832534f, -0.08003118f, 
    0.01292880f, 0.01104567f, 0.09811025f, 0.03196538f, -0.14524435f, 0.03603135f, 0.16457678f, -0.04541281f, 
    -0.03999750f, -0.06682635f, -0.01255361f, -0.09273847f, -0.00986767f, -0.08013172f, -0.03401858f, 0.18810417f, 
    -0.04053985f, 0.19429064f, -0.01910751f, -0.03659776f, -0.02131569f, 0.16434695f, 0.08919875f, -0.01491011f, 
    -0.04650131f, -0.03252385f, 0.12314545f, 0.03779147f, -0.06299362f, 0.03276344f, 0.11780570f, 0.16548097f, 
    0.04135614f, 0.05711967f, -0.02528482f, 0.16642652f, 0.05677060f, -0.01649083f, 0.08828235f, -0.10033975f, 
    -0.08693642f, 0.00109013f, 0.04288131f, 0.01104518f, 0.08651119f, 0.04814465f, -0.08921759f, -0.12864998f, 
    -0.00632324f, -0.13804290f, 0.01574198f, 0.06035447f, -0.20441544f, 0.00326782f, 0.02141271f, -0.04790821f, 
    0.33733621f, 0.02127958f, 0.10266428f, 0.18403214f, -0.02684608f, -0.02038989f, 0.12862352f, 0.06154983f, 
    0.00770797f, 0.07827567f, -0.08598971f, -0.05525641f, -0.01634251f, 0.08053452f, -0.06109165f, -0.14690635f, 
    0.04073180f, 0.07900353f, -0.08497410f, -0.07193068f, -0.00927751f, -0.06627779f, -0.10538442f, -0.08845808f, 
    0.21399082f, -0.06377577f, -0.14956313f, 0.05452560f, 0.10169193f, -0.04368648f, 0.12836218f, 0.02663207f, 
    0.06642502f, -0.09189340f, -0.06184712f, -0.10827863f, 0.26583183f, 0.00407289f, -0.11238205f, 0.12889902f, 
    -0.05091058f, 0.02729242f, -0.04321204f, -0.01669343f, -0.05165580f, -0.03048347f, 0.01927192f, -0.00172931f, 
    0.13205312f, -0.04333020f, 0.13402776f, 0.11037488f, -0.05223944f, 0.01392128f, -0.05607421f, 0.00581599f, 
    0.03911349f, 0.09408317f, -0.01550293f, 0.09464730f, 0.00718825f, 0.15511683f, 0.15777034f, 0.08189732f, 
    0.05381783f, -0.19387831f, 0.15309338f, 0.11052439f, -0.12571166f, -0.09012210f, 0.08363350f, -0.00948688f, 
    -0.18999982f, -0.09098139f, 0.15665652f, -0.08769212f, -0.03065158f, -0.03001235f, 0.06546881f, -0.05197060f, 
    0.03989856f, -0.11246118f, 0.01422956f, -0.00248905f, 0.30372688f, 0.22315447f, -0.06929171f, 0.09756981f, 
    0.03384990f, -0.05033206f, 0.06384605f, 0.05722825f, 0.02304632f, 0.01674500f, -0.12881644f, 0.08077739f, 
    0.13569750f, 0.05338878f, 0.07379203f, 0.09650306f, -0.00219061f, -0.01332262f, 0.04134205f, -0.17530113f, 
    -0.09444326f, 0.00403213f, 0.01555596f, -0.08008403f, -0.30317459f, 0.15534611f, -0.11631903f, 0.01614210f, 
    0.09601757f, 0.04039153f, 0.03226709f, -0.00821558f, -0.02277612f, -0.07703055f, -0.01821821f, 0.03530207f, 
    -0.01353861f, -0.24335302f, -0.01334959f, -0.05223024f, 0.11507890f, 0.09694058f, -0.00383824f, 0.07884879f, 
    -0.10733340f, -0.00705987f, -0.10826363f, 0.01430833f, 0.00177180f, -0.09845841f, -0.15053742f, -0.08086092f, 
    0.07078667f, -0.11191138f, 0.04280172f, -0.11750395f, -0.05954917f, 0.13044421f, 0.03876840f, -0.03730914f, 
    0.41508862f, 0.03285642f, -0.13401859f, -0.13174014f, -0.01307226f, 0.05349733f, 0.06548913f, 0.08948348f, 
    0.06843000f, -0.08270498f, -0.05949095f, -0.04603231f, 0.01003639f, -0.07030674f, 0.05152233f, 0.04572089f, 
    -0.01384078f, -0.14441842f, 0.12731732f, -0.10356990f, -0.13577469f, -0.11177900f, -0.00817336f, 0.12205196f, 
    0.18602486f, -0.08294819f, -0.09406890f, -0.07571787f, 0.10110954f, -0.08884834f, -0.03518969f, 0.14710250f, 
    -0.01643286f, -0.05181901f, 0.05629875f, 0.10945427f, 0.37053353f, 0.09474523f, -0.17876893f, 0.25113505f, 
    -0.02168544f, 0.03440672f, -0.15645184f, -0.04609275f, 0.04606013f, 0.15175752f, 0.10497205f, -0.04163035f, 
    0.12520333f, -0.07514746f, -0.06715575f, -0.00741700f, -0.03210755f, -0.01277676f, 0.07663537f, -0.03318833f, 
    0.09242743f, 0.08636523f, 0.04222866f, 0.07620111f, -0.09010904f, -0.05837258f, -0.02827535f, -0.01556795f, 
    0.12315473f, 0.00532545f, -0.02288342f, 0.02525507f, -0.12044246f, 0.04431523f, 0.04668203f, -0.06205581f, 
    0.02275401f, 0.14072864f, 0.08520774f, 0.07053530f, 0.00573298f, 0.02867281f, -0.06666308f, 0.02467442f, 
    0.05763544f, -0.08907853f, 0.06692378f, -0.02822723f, -0.03495473f, 0.00377777f, 0.06382417f, -0.05430485f, 
    0.17789666f, 0.04416410f, 0.13641943f, -0.01043808f, 0.11532256f, 0.07325208f, 0.02059720f, 0.10095617f, 
    0.04470549f, 0.12930173f, 0.04538243f, -0.19301786f, -0.01947933f, 0.04818720f, 0.01511284f, -0.09366354f, 
    0.03997989f, 0.07776920f, -0.01038398f, 0.03765611f, 0.13850357f, -0.02295963f, -0.08874767f, -0.16942078f, 
    -0.00467294f, 0.00292376f, -0.06043184f, -0.09702736f, -0.00225609f, 0.02057063f, 0.09162850f, -0.12453569f, 
    0.06012937f, -0.07380191f, -0.21231489f, -0.22126292f, 0.09434655f, 0.15967070f, -0.03319755f, 0.00004211f, 
    0.02225408f, 0.02788939f, 0.12459534f, 0.06598777f, 0.12570459f, 0.20015065f, 0.00209539f, 0.20950201f, 
    0.05361893f, 0.02580185f, -0.06579726f, 0.01405319f, 0.10768729f, 0.04732492f, -0.02868659f, -0.17014310f, 
    -0.00020928f, 0.11697969f, -0.02427936f, 0.00663600f, -0.11551776f, 0.02277425f, -0.01597346f, 0.07337564f, 
    -0.11543783f, 0.01611588f, 0.01430999f, -0.09683376f, -0.38539764f, 0.02316869f, -0.09237079f, -0.04081363f, 
    0.02878665f, 0.01208183f, 0.04529760f, 0.01597688f, 0.09648333f, 0.11127063f, -0.10665630f, -0.01837194f, 
    0.10896092f, 0.00720432f, 0.02939412f, 0.18471372f, 0.04053535f, -0.05088284f, -0.00464093f, 0.14768590f, 
    0.07224058f, 0.00140430f, -0.02324579f, -0.02416880f, -0.04040447f, -0.17114435f, 0.15483843f, 0.00050995f, 
    0.12646753f, -0.02226897f, 0.06541136f, -0.07718515f, -0.04028488f, 0.00834624f, 0.08678473f, -0.00133909f, 
    0.08562017f, -0.05458530f, -0.01756993f, -0.03842731f, 0.05895682f, -0.09853241f, 0.09371210f, 0.04785627f, 
    -0.11264204f, 0.00695703f, -0.11036327f, -0.13473268f, 0.12998950f, 0.06004345f, 0.07553439f, -0.09201375f, 
    -0.05310301f, -0.07664163f, 0.09923220f, -0.01810452f, 0.03426806f, -0.01852386f, 0.01851199f, 0.12631917f, 
    -0.25917405f, -0.07406832f, 0.12020972f, 0.06260103f, -0.06034345f, 0.12025712f, -0.05398871f, 0.17123309f, 
    0.09988413f, -0.01151909f, 0.03939431f, 0.04291321f, -0.25786904f, 0.16932127f, 0.10305161f, -0.20568316f, 
    0.02283885f, 0.07681540f, 0.08292944f, 0.01754623f, 0.07291479f, -0.01434470f, 0.00687195f, 0.01878445f, 
    -0.10902213f, -0.10139106f, 0.09883493f, -0.12693331f, -0.09865181f, 0.07030732f, -0.04799159f, 0.05844075f, 
    -0.04454249f, -0.06179791f, -0.05674547f, 0.10970451f, -0.31880724f, -0.10895235f, 0.05781060f, -0.17237790f, 
    0.07107481f, -0.01645405f, -0.03175751f, -0.01637242f, -0.04641582f, 0.14218503f, 0.05025429f, -0.12938985f, 
    0.05621256f, 0.05807961f, 0.00991091f, -0.11701635f, 0.09424538f, -0.02011238f, 0.19011615f, -0.06084504f, 
    -0.03894112f, 0.20200317f, 0.10263433f, 0.01465750f, 0.17159167f, -0.03460608f, -0.01465411f, 0.18643738f, 
    -0.04881728f, -0.02200373f, 0.18804307f, 0.14070347f, -0.06128657f, -0.07382401f, 0.04170175f, 0.10441750f, 
    0.15937017f, -0.14069945f, -0.07094443f, 0.07727592f, 0.02630577f, -0.06764504f, 0.05191810f, 0.02974879f, 
    -0.12809962f, -0.00404177f, 0.07876153f, -0.01600011f, -0.11246909f, -0.07251307f, 0.04925480f, 0.15978281f, 
    0.08755417f, 0.12813972f, 0.06030654f, -0.03096822f, -0.00370767f, -0.12613170f, 0.05486679f, 0.12207153f, 
    -0.40324047f, -0.11477029f, -0.00213795f, 0.17428756f, 0.11246771f, 0.03578535f, -0.04501403f, 0.01093619f, 
    -0.05889209f, 0.10284957f, -0.00837416f, -0.02632350f, 0.29130083f, -0.07370449f, 0.17762527f, -0.02036840f, 
    -0.10971013f, -0.02645074f, 0.02456646f, 0.02711619f, 0.01208192f, 0.07970317f, -0.03185186f, -0.08219925f, 
    -0.04000914f, -0.00732633f, -0.01901833f, -0.04677328f, 0.03441868f, 0.03506595f, -0.00561946f, 0.02790546f, 
    -0.03147926f, -0.17504826f, 0.15347771f, 0.07277592f, -0.41012836f, -0.01235879f, -0.01128583f, -0.10303356f, 
    -0.02698486f, 0.09756566f, 0.11708236f, 0.06237628f, 0.01631547f, 0.02799042f, 0.15045600f, 0.04379314f, 
    -0.15098768f, -0.09943897f, 0.10258731f, -0.08488657f, 0.00753641f, 0.09032186f, 0.14004812f, 0.03091153f, 
    0.07716125f, 0.04048464f, 0.09254303f, 0.04981206f, -0.02679491f, 0.18821460f, -0.17296809f, -0.32805178f, 
    0.11474172f, 0.10050431f, -0.05290941f, 0.02829549f, 0.09446665f, -0.05264135f, -0.01632123f, -0.03828459f, 
    0.30198780f, -0.01821539f, -0.06822182f, 0.03971241f, 0.02345909f, 0.03998698f, 0.08833651f, -0.02207056f, 
    -0.00082058f, 0.17818087f, -0.02398238f, 0.05840350f, -0.12417401f, 0.04584353f, 0.28301123f, 0.27312914f, 
    -0.00345763f, -0.07614723f, 0.06028650f, 0.03072859f, 0.03765712f, 0.12579638f, -0.01103631f, -0.04508559f, 
    -0.25031713f, -0.04772364f, 0.11616368f, 0.01000985f, 0.03407061f, 0.06654860f, 0.08169623f, -0.04641370f, 
    -0.12567911f, 0.07689751f, -0.04708889f, 0.00126758f, 0.44488925f, -0.08726402f, 0.16025193f, -0.03860449f, 
    0.00004183f, -0.01122015f, 0.07035282f, 0.04766246f, 0.06420630f, -0.02125569f, -0.04817550f, 0.10159085f, 
    0.03670974f, -0.01558856f, -0.05609401f, -0.13584054f, 0.10837626f, 0.07799261f, -0.07930974f, 0.01330405f, 
    -0.01046007f, 0.11047237f, -0.04459067f, 0.11350231f, -0.08648942f, -0.13965774f, -0.12514606f, -0.15438505f, 
    0.08287935f, 0.10597942f, -0.01230934f, -0.08430228f, 0.06064624f, -0.11780790f, 0.08175603f, -0.00710357f, 
    0.40198532f, -0.17268755f, 0.07252571f, -0.04142736f, -0.05430141f, -0.03014433f, -0.04150246f, 0.00116426f, 
    -0.01761274f, 0.09403712f, 0.10322334f, 0.00465942f, -0.23686665f, 0.01032213f, 0.01082542f, -0.01081522f, 
    0.00069785f, -0.04205476f, 0.00099943f, 0.06881390f, -0.00214142f, 0.01522453f, 0.03922880f, 0.15728265f, 
    -0.47447622f, 0.07543366f, 0.03327587f, -0.15539059f, 0.14833266f, 0.01287536f, -0.00865303f, -0.00877381f, 
    0.04133306f, -0.01832914f, 0.04190307f, 0.03752522f, -0.01870401f, 0.15898763f, -0.07006933f, -0.06271474f, 
    0.04785063f, 0.17575124f, -0.07326876f, 0.07500346f, 0.15857281f, -0.05451545f, -0.08534523f, -0.07353237f, 
    0.36402136f, -0.12139655f, -0.06477252f, 0.07819425f, 0.01510721f, -0.05509070f, -0.01555573f, 0.04869045f, 
    -0.02929139f, 0.07962881f, -0.10111145f, 0.08437746f, 0.00054286f, 0.05170403f, 0.00827415f, -0.22445463f, 
    -0.24664910f, -0.09018714f, -0.04073307f, -0.07301094f, -0.02109087f, -0.06974356f, 0.08460737f, 0.15666090f, 
    0.07662163f, -0.01043451f, 0.08208207f, -0.00303558f, 0.05682382f, 0.04532718f, 0.00104056f, 0.08901285f, 
    -0.01114518f, -0.02163409f, -0.01346841f, 0.02107318f, 0.04067552f, -0.01775475f, -0.01197645f, -0.11207806f, 
    0.08243300f, 0.13036814f, -0.00395004f, -0.08291578f, 0.02667670f, 0.06829127f, 0.01890554f, 0.09611744f, 
    -0.18217722f, 0.12000065f, 0.10772364f, 0.19240987f, -0.19441088f, -0.10144866f, 0.03319050f, 0.10242197f, 
    -0.01907464f, -0.02502907f, 0.05331587f, 0.04416498f, -0.15478314f, 0.10776379f, 0.01640582f, 0.08688141f, 
    -0.04818052f, 0.16678126f, -0.02359423f, 0.05817901f, 0.10162614f, 0.00967935f, 0.00693832f, 0.01534360f, 
    0.07616752f, -0.01003611f, 0.01626506f, -0.08136219f, 0.03159963f, -0.04383451f, 0.04512004f, 0.06227155f, 
    0.05601994f, 0.10488616f, 0.21413988f, 0.18861273f, -0.02190902f, -0.11566795f, -0.02111699f, 0.05929709f, 
    0.02719958f, 0.08985054f, -0.01160522f, -0.09780927f, 0.08125868f, 0.00904100f, -0.07469835f, 0.15379728f, 
    -0.00940082f, 0.03189003f, 0.03263696f, 0.02234743f, -0.00252691f, -0.04719299f, 0.03427523f, 0.02221576f, 
    0.00095406f, 0.02280540f, 0.01282589f, 0.03149149f, 0.00225446f, -0.01239855f, -0.00604452f, -0.01989353f, 
    -0.01936858f, -0.00441199f, -0.00816583f, -0.04343767f, 0.03301663f, -0.01496372f, 0.02628812f, -0.03364783f, 
    -0.01098694f, 0.03444421f, -0.03925996f, -0.05076993f, -0.01525606f, 0.02470486f, -0.00135798f, 0.01857089f, 
    -0.03053559f, 0.02059058f, -0.03947064f, 0.04565848f, 0.02139162f, -0.04718838f, -0.00900424f, 0.00266885f, 
    -0.05871101f, -0.01022981f, 0.03718494f, 0.02425034f, -0.03018752f, 0.02186794f, 0.00365901f, 0.02162001f, 
    0.02995764f, -0.04881766f, -0.02488617f, -0.05803508f, -0.03925294f, -0.02351902f, 0.02122616f, -0.01090878f, 
    -0.03651100f, -0.04814625f, -0.00484568f, -0.04237995f, 0.00222484f, 0.03094054f, 0.00642486f, -0.03607184f, 
    -0.05777024f, -0.05259250f, -0.05533266f, 0.00236042f, -0.01732137f, 0.02693971f, -0.02317281f, -0.03110142f, 
    -0.03919612f, -0.01551246f, -0.00361093f, -0.03591911f, 0.00482030f, 0.00191097f, 0.00602948f, 0.04040411f, 
    -0.03165735f, 0.04051554f, -0.00338824f, -0.04195746f, 0.01554796f, 0.01587786f, 0.03046828f, 0.02916917f, 
    0.02862632f, 0.00534056f, 0.00400196f, 0.01967707f, -0.00963206f, 0.00098120f, 0.00589573f, -0.00145151f, 
    0.03711770f, 0.00253289f, 0.02721475f, -0.04150878f, 0.03451368f, 0.00499137f, -0.03929324f, -0.00058962f, 
    -0.04584158f, -0.00953178f, -0.01542032f, -0.02679596f, 0.02918277f, 0.03097077f, -0.04610661f, 0.02740874f, 
    0.02932977f, -0.02601919f, 0.00634354f, 0.03842922f, -0.01606276f, 0.03339158f, -0.02332206f, -0.02238865f, 
    0.00877430f, -0.03306513f, -0.04498117f, 0.03917575f, -0.00586737f, -0.03260465f, -0.02091652f, 0.03330589f, 
    0.00433468f, -0.03795545f, 0.04053418f, 0.00373408f, -0.01749541f, -0.01790988f, -0.05362188f, 0.02281426f, 
    0.02079671f, -0.05694808f, -0.03023267f, 0.01613891f, 0.04068794f, 0.03322943f, 0.00708398f, -0.03309609f, 
    -0.03446840f, -0.05474152f, -0.03755882f, -0.05267303f, -0.03074617f, -0.05896300f, -0.02566337f, 0.01375751f, 
    -0.05045184f, 0.03341424f, 0.02207037f, 0.00833832f, 0.02881303f, 0.01112868f, -0.02930880f, -0.00730405f, 
    -0.02487269f, -0.00578573f, 0.01630746f, 0.04065219f, -0.03972529f, -0.01946593f, -0.04679770f, -0.00779677f, 
    -0.00055605f, -0.00059131f, 0.02452669f, -0.04841405f, 0.01428423f, -0.01679311f, -0.02372599f, -0.05377553f, 
    -0.02379432f, 0.00058298f, -0.00735308f, 0.03270029f, -0.03474997f, -0.03202971f, 0.01654305f, 0.04260358f, 
    -0.00137780f, 0.03829985f, 0.01740178f, 0.01118076f, -0.04807001f, 0.01612164f, 0.03041394f, 0.03387483f, 
    -0.03467012f, 0.00984242f, -0.01825264f, -0.04179261f, 0.03290232f, -0.03315048f, -0.02017231f, -0.00554533f, 
    -0.04590423f, -0.01504551f, -0.04615773f, 0.03024957f, -0.02624963f, 0.00833068f, 0.03046250f, -0.02535771f, 
    0.03724325f, -0.04853104f, -0.04994880f, -0.02891347f, -0.05112163f, 0.03750860f, -0.01704172f, 0.00406219f, 
    -0.02924909f, 0.01127097f, 0.02520976f, 0.03863025f, -0.04037642f, 0.01905966f, 0.03418238f, -0.05128646f, 
    -0.04557433f, 0.02777960f, -0.01431418f, -0.00300793f, -0.00760112f, -0.03471676f, -0.00487992f, 0.01254145f, 
    0.02547749f, 0.03772351f, -0.02987138f, -0.02357094f, -0.05374631f, -0.00270778f, -0.02136290f, -0.01569629f, 
    -0.04041588f, -0.04552741f, -0.01269526f, -0.04743610f, 0.02213051f, -0.02802846f, -0.04763006f, -0.00312008f, 
    0.02526409f, 0.02729620f, 0.03728006f, -0.00034107f, -0.03832867f, -0.03261665f, -0.04130690f, -0.03491638f, 
    -0.01476046f, -0.01428647f, -0.03215769f, -0.00377706f, -0.02685346f, -0.02548128f, -0.01347752f, 0.01681280f, 
    0.01100863f, -0.00764658f, -0.03937775f, 0.04231821f, 0.00464832f, -0.00271142f, 0.03365332f, -0.03058273f, 
    -0.04919322f, -0.01309054f, 0.01673688f, 0.01960822f, -0.01637104f, 0.02877906f, -0.00421206f, 0.00602529f, 
    -0.04222060f, 0.03368734f, -0.01787325f, 0.03798528f, 0.01422100f, -0.00661591f, -0.03925718f, 0.02653146f, 
    0.02404996f, -0.02364031f, 0.02873749f, -0.03233305f, 0.02818618f, 0.00933464f, -0.01417515f, -0.04435390f, 
    0.02899788f, 0.00186333f, -0.00012851f, -0.05014149f, -0.03176596f, 0.03093594f, 0.01133905f, -0.04434337f, 
    0.01775413f, 0.02317981f, 0.03454050f, 0.02815126f, 0.03123207f, -0.03870498f, -0.03359446f, 0.00096143f, 
    0.01954091f, 0.03170917f, 0.00467006f, -0.05110461f, 0.02252309f, 0.00524167f, 0.03178471f, -0.02391515f, 
    0.03221004f, -0.04738737f, -0.00375196f, -0.00265527f, -0.04054524f, -0.05515035f, 0.01798521f, -0.05634766f, 
    -0.04080071f, -0.05654292f, -0.05343572f, 0.03779437f, -0.01312788f, -0.04830700f, -0.00154289f, -0.03489766f, 
    0.01736352f, 0.01890058f, -0.01494256f, -0.00199789f, -0.05372064f, 0.02121808f, 0.01969574f, -0.04539289f, 
    -0.04794684f, -0.01450287f, -0.05344183f, -0.02296791f, -0.02800493f, -0.03374061f, -0.02765281f, 0.04038030f, 
    -0.03780619f, -0.04750987f, 0.03406409f, -0.03999283f, -0.00669192f, 0.00110299f, 0.04080835f, 0.03269029f, 
    0.01063690f, -0.00230055f, -0.04963162f, -0.05014997f, -0.02882166f, -0.02803888f, -0.03882135f, 0.02377134f, 
    -0.05251151f, -0.01393495f, -0.02889535f, -0.04080635f, 0.00890870f, 0.02101750f, 0.02925486f, -0.02559842f, 
    -0.00224827f, 0.02295546f, 0.01099131f, -0.05528413f, -0.05641722f, 0.00578145f, 0.04332246f, 0.03737665f, 
    -0.00779279f, -0.03487470f, -0.04883406f, 0.02534254f, -0.05198828f, -0.03789863f, 0.02311814f, -0.00258930f, 
    -0.02277091f, 0.04377641f, -0.02288680f, -0.01320181f, 0.01114964f, 0.02131405f, 0.04073494f, -0.04102022f, 
    -0.02406959f, 0.02441217f, -0.00503471f, 0.00332902f, 0.01287133f, 0.00381473f, -0.00856052f, -0.03582918f, 
    -0.04082444f, -0.04014726f, -0.02074954f, 0.03950055f, -0.05081841f, 0.00545136f, -0.02764417f, 0.02382450f, 
    -0.02618375f, -0.05529608f, 0.04123078f, -0.00377122f, 0.01617017f, -0.05551436f, -0.02915723f, -0.01211809f, 
    -0.03772533f, -0.02984375f, -0.00518020f, -0.02408451f, -0.00439065f, -0.02228702f, 0.01225203f, -0.02035320f, 
    0.05023226f, -0.01984114f, -0.04995633f, -0.02105640f, 0.00425782f, -0.00782342f, 0.00125629f, -0.01209673f, 
    -0.04537771f, -0.04007272f, -0.01762589f, 0.01676915f, -0.03200935f, -0.03423605f, -0.03697244f, 0.00302381f, 
    0.03200616f, -0.00575848f, -0.01640467f, 0.03462219f, 0.01214766f, 0.03017923f, -0.05411303f, 0.01587570f, 
    0.00777875f, -0.04885075f, 0.00239969f, 0.03804994f, -0.00920050f, -0.04081757f, 0.01769927f, -0.03527249f, 
    -0.00169572f, -0.02548370f, -0.01233030f, 0.01433294f, -0.00112359f, -0.05250017f, -0.04895110f, 0.02051005f, 
    -0.01472202f, 0.03049131f, -0.03489891f, 0.01493286f, -0.00593689f, -0.02047791f, -0.03153782f, -0.03965410f, 
    -0.00803116f, 0.01118184f, 0.00627388f, -0.04093051f, 0.02380553f, -0.04349671f, -0.00599157f, 0.02602357f, 
    -0.02615301f, 0.01955739f, 0.00074641f, -0.01739661f, 0.01152258f, -0.04119098f, -0.01882981f, 0.02492573f, 
    -0.05506905f, 0.04042785f, -0.04033972f, -0.03656485f, -0.02737076f, 0.03795362f, -0.00566825f, -0.03659088f, 
    -0.01904024f, -0.04398095f, -0.05446703f, -0.05877525f, -0.01661733f, -0.01943087f, -0.02557304f, -0.02215390f, 
    -0.01986180f, 0.03253396f, 0.02914669f, 0.02281800f, -0.02244772f, -0.03603587f, 0.04410336f, 0.03694710f, 
    0.03303801f, 0.03820077f, -0.00926931f, 0.03761777f, -0.02600679f, -0.04182718f, -0.00203417f, 0.02865461f, 
    0.02233730f, -0.03512386f, -0.00217962f, -0.03942980f, -0.00774703f, -0.05928851f, -0.03077621f, -0.01622523f, 
    0.02394358f, 0.03126501f, -0.02913705f, -0.01852605f, -0.03361327f, -0.05056591f, 0.04059127f, -0.01340825f, 
    -0.00824771f, 0.00670439f, 0.04061107f, -0.01676893f, 0.01022497f, -0.00437338f, 0.02749087f, -0.03164903f, 
    -0.02459417f, 0.02145772f, -0.03447460f, 0.04021403f, 0.02265516f, 0.01241484f, 0.00860471f, 0.00376712f, 
    -0.02027613f, 0.01645262f, -0.00649296f, 0.01306497f, -0.01880447f, -0.00974660f, 0.03426996f, -0.04939807f, 
    -0.00247911f, 0.03370706f, -0.02979776f, 0.02780573f, 0.01374618f, -0.04366463f, -0.04916058f, 0.02101128f, 
    0.04220833f, 0.00722745f, -0.04194344f, -0.03720627f, 0.04126546f, 0.03595312f, 0.02482252f, -0.01290599f, 
    0.02714628f, -0.01874239f, -0.04615645f, 0.00633518f, -0.02368076f, 0.04259904f, -0.03283501f, 0.01801208f, 
    -0.02166319f, 0.02199094f, 0.00616173f, -0.00878546f, 0.04815996f, -0.05605558f, -0.03480599f, 0.00744474f, 
    -0.03723350f, -0.00720060f, 0.00765175f, 0.02232749f, 0.00514638f, 0.01998117f, 0.01924150f, -0.01265380f, 
    0.03399521f, 0.00535282f, 0.03913697f, 0.03738504f, -0.04842050f, 0.01370118f, 0.01273015f, 0.04119477f, 
    0.02725367f, 0.00409731f, 0.03904399f, 0.02290273f, -0.02342624f, -0.03280509f, -0.00424982f, 0.00719917f, 
    0.02985174f, 0.03004680f, -0.02341820f, 0.03873074f, 0.02226263f, -0.03119737f, -0.02286425f, 0.03827923f, 
    0.00083980f, -0.01043028f, 0.03132161f, -0.05637640f, 0.02247893f, -0.02066578f, 0.00871000f, -0.01446269f, 
    -0.02790418f, -0.01469116f, 0.01284149f, -0.05508778f, -0.00484128f, 0.01916669f, -0.05353934f, -0.05476967f, 
    0.00454303f, -0.00823243f, -0.05124851f, -0.04242731f, -0.03557958f, -0.05589582f, 0.02883827f, -0.05143610f, 
    -0.02176936f, 0.03174642f, -0.02525538f, -0.01117398f, 0.00911479f, -0.02543325f, -0.04696308f, 0.02735886f, 
    -0.00231131f, -0.04126609f, 0.03997658f, -0.00320727f, 0.01047142f, -0.01826399f, -0.05053892f, -0.00862055f, 
    -0.04734773f, -0.05433205f, -0.04588282f, -0.03603833f, -0.04405598f, -0.04116640f, -0.04260221f, -0.05023097f, 
    0.03566307f, 0.01380605f, -0.04635749f, -0.03195352f, -0.03801366f, 0.00156264f, 0.00324483f, -0.03494718f, 
    0.01212948f, 0.02675992f, 0.02405663f, -0.00547197f, -0.01403422f, -0.03627393f, -0.00639573f, 0.02528417f, 
    -0.03575209f, 0.03654144f, 0.00652414f, -0.01773029f, -0.02286936f, -0.03207777f, 0.00095916f, -0.01130136f, 
    0.01976632f, -0.04510086f, 0.01319612f, -0.02834300f, 0.04384204f, 0.02943892f, -0.02440215f, -0.01125645f, 
    -0.02577410f, 0.03720246f, -0.00570657f, 0.02221896f, -0.02365476f, -0.03283753f, 0.02881092f, -0.01640559f, 
    0.03305248f, -0.02610297f, 0.03046696f, -0.00087539f, 0.03495145f, 0.03807363f, -0.00268723f, -0.05819672f, 
    -0.01056098f, 0.02040005f, -0.02133759f, -0.00225682f, 0.01481214f, -0.02224814f, -0.00612175f, 0.03278914f, 
    -0.00585022f, -0.00940145f, 0.01317808f, -0.00876072f, 0.00545233f, 0.03476958f, -0.04065663f, 0.00210221f, 
    0.00584353f, -0.02393313f, -0.04947997f, 0.03219213f, -0.04844717f, 0.00564301f, 0.03625158f, 0.01729772f, 
    -0.04829516f, -0.04129387f, -0.00261989f, -0.00385427f, 0.00800211f, 0.00228952f, -0.01298771f, -0.03986152f, 
    0.01707604f, 0.01510373f, -0.00169398f, -0.00841867f, -0.05407102f, -0.01894914f, 0.04444071f, -0.00924710f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05120897f, 0.07643344f, -0.02903997f, 0.01053463f, -0.02340758f, 0.07253896f, 0.01178798f, 0.02808045f, 
    0.05412639f, 0.02103566f, 0.00404012f, 0.11642738f, 0.02472619f, 0.02025507f, -0.04105829f, 0.01683906f, 
    -0.04100538f, -0.05118158f, 0.00496503f, 0.06651605f, 0.00702224f, 0.02368020f, -0.04094839f, 0.00872927f, 
    0.02131406f, -0.03788640f, 0.00501936f, 0.01138045f, -0.01714932f, 0.01522210f, -0.03438303f, -0.01652502f, 
    -0.00316415f, 0.10855598f, -0.01142167f, 0.02458772f, 0.00268132f, -0.05295839f, 0.05088510f, -0.02218013f, 
    -0.01923081f, 0.03030500f, 0.03983353f, -0.02578339f, -0.01843407f, -0.01788174f, -0.04323526f, -0.04268159f, 
    0.11247240f, 0.02573238f, 0.04158187f, 0.02320011f, -0.01863830f, 0.12658913f, -0.01611743f, 0.08135883f, 
    0.05592173f, 0.00857849f, -0.05608525f, -0.01469450f, 0.07317411f, 0.03992814f, 0.00277876f, -0.02189576f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02999922f, 0.15152593f, 0.10347748f, 0.10164676f, 0.05714634f, 0.15005918f, -0.17337133f, 0.05165011f, 
    -0.27994263f, 0.09512158f, -0.19145389f, -0.14991494f, 0.10490263f, 0.11092426f, 0.48985142f, 0.06773733f, 
    0.25149497f, 0.47290033f, -0.08473815f, -0.00830244f, -0.25973296f, 0.03212981f, 0.06890936f, -0.07014871f, 
    -0.34761626f, 0.03389388f, 0.25309920f, 0.15402479f, -0.00387613f, 0.18079539f, -0.02531536f, 0.25023246f, 
    0.02113792f, -0.75858879f, -0.13336153f, 0.04334141f, 0.04949079f, 0.00681847f, -0.46251997f, -0.05603950f, 
    -0.03796927f, -0.44283414f, 0.10424115f, 0.11376017f, -0.09979416f, -0.03376377f, -0.03022842f, 0.11393240f, 
    -0.11736286f, -0.00428614f, 0.04921198f, 0.06770281f, -0.04195306f, -0.19832902f, -0.21787192f, -0.06025234f, 
    -0.01501578f, -0.11029242f, -0.02124589f, 0.03377449f, -0.27701494f, -0.24074997f, -0.12237990f, -0.02860572f, 
    -0.05399848f, -0.10232124f, -0.56057996f, 0.22767952f, 0.01696575f, -0.13604741f, 0.20552996f, -0.11424341f, 
    -0.21413873f, -0.23446968f, -0.40071407f, 0.14342140f, -0.06713129f, -0.03416082f, -0.28730929f, -0.00864939f, 
    -0.11050958f, -0.35161614f, -0.11895247f, -0.27664384f, -0.04663043f, -0.07530771f, -0.08581793f, -0.25995246f, 
    0.10831315f, -0.11373169f, 0.17220442f, -0.19433314f, -0.02145682f, 0.33197159f, 0.09475475f, 0.14545323f, 
    -0.03644974f, -0.23826800f, 0.00487273f, 0.01604182f, 0.16027550f, 0.02441441f, 0.33318141f, -0.08767213f, 
    -0.09719487f, -0.39102048f, 0.03730214f, 0.01236692f, 0.02714130f, 0.07619472f, -0.06777295f, 0.01476678f, 
    0.20213854f, -0.08200949f, -0.06756166f, 0.27450651f, 0.10180241f, 0.05101743f, -0.15298824f, 0.19151637f, 
    0.16929555f, -0.04420998f, -0.01013741f, 0.25166315f, 0.11576680f, -0.36966050f, -0.11580011f, -0.08067413f, 
    -0.08742253f, 0.07302545f, 0.25067320f, 0.08272982f, 0.09200414f, -0.48959267f, -0.07716444f, 0.02756912f, 
    -0.43564010f, 0.02823122f, -0.23781483f, 0.25072432f, 0.10062988f, -0.11447149f, 0.16889541f, 0.10796120f, 
    -0.46061757f, -0.09306833f, 0.11891792f, -0.36632034f, 0.05045854f, 0.10212681f, -0.11209555f, -0.39442840f, 
    0.23637599f, 0.03513817f, 0.09996010f, -0.21905199f, 0.05288884f, -0.14680721f, -0.07075407f, -0.22505815f, 
    0.00367956f, 0.34135163f, -0.07336856f, 0.04000013f, -0.29862678f, 0.11536178f, -0.54648852f, -0.11336884f, 
    0.31083032f, 0.19033107f, -0.06155495f, -0.08452877f, -0.04412145f, 0.01357790f, -0.02121882f, 0.06062414f, 
    -0.06898902f, 0.08873468f, -0.12362200f, 0.00585852f, 0.04084572f, -0.37343642f, 0.15821013f, -0.09050861f, 
    -0.33345208f, -0.09115563f, 0.01638899f, 0.19155015f, 0.35642532f, 0.17234723f, -0.04565232f, 0.03923160f, 
    -0.06860662f, -0.22365992f, 0.24813937f, -0.36663544f, 0.00920498f, 0.20993130f, -0.21097913f, -0.08607000f, 
    -0.15793259f, -0.05109631f, -0.14674401f, 0.07997005f, -0.06319325f, -0.08808196f, -0.37701482f, 0.08116616f, 
    -0.16722789f, 0.32304713f, -0.02535459f, -0.06537474f, 0.35906968f, 0.02748559f, -0.02196088f, 0.05444326f, 
    -0.40118802f, 0.05545543f, 0.16180573f, 0.35314614f, -0.01936985f, -0.53697705f, 0.05445572f, 0.21439199f, 
    -0.06287524f, 0.14816034f, 0.18253565f, -0.05356699f, -0.33892965f, 0.04096838f, 0.30906966f, -0.07484116f, 
    -0.42141101f, -0.09113912f, 0.11981980f, -0.07567093f, -0.03056979f, -0.00098964f, -0.01764275f, 0.03832669f, 
    0.04639633f, -0.10710119f, -0.04489885f, 0.16807166f, 0.02054467f, -0.14092968f, -0.20861192f, -0.00022301f, 
    -0.57227850f, 0.00416397f, 0.06816325f, 0.05501254f, -0.39933348f, 0.08196563f, 0.02879614f, -0.04353442f, 
    0.11447791f, -0.30921289f, 0.24084176f, 0.13785495f, 0.06356412f, -0.06718452f, -0.08476028f, -0.02004207f, 
    0.17739004f, 0.17915100f, 0.23046406f, -0.08208217f, 0.03268972f, 0.08077635f, -0.13090301f, 0.02360219f, 
    0.24568449f, -0.24361567f, -0.06935930f, -0.08975016f, 0.34557816f, 0.00638147f, -0.04998504f, 0.04703161f, 
    -0.28234684f, 0.04602320f, -0.14787219f, 0.08438116f, -0.08105097f, 0.08221252f, 0.09118989f, 0.30615509f, 
    -0.09721053f, 0.14643733f, -0.19164206f, -0.07511972f, 0.32388222f, -0.06706490f, -0.15411855f, -0.04826664f, 
    -0.07204673f, -0.34994835f, -0.05073031f, -0.10664066f, -0.07000645f, -0.08316781f, -0.06402284f, -0.09569478f, 
    -0.29585895f, 0.12943865f, 0.07964550f, -0.30241349f, 0.07194096f, 0.02957309f, 0.23402207f, -0.22406808f, 
    -0.40586942f, 0.05762896f, 0.04943107f, 0.23532468f, -0.18780640f, -0.10892692f, -0.01082395f, -0.10592988f, 
    0.04246859f, -0.08201757f, -0.55569142f, 0.01303031f, -0.00567048f, 0.17524226f, 0.15835740f, 0.06966364f, 
    0.06719069f, 0.03551475f, -0.00431479f, -0.26093647f, -0.03414664f, 0.12890130f, 0.14175560f, -0.10402892f, 
    0.08952495f, -0.08743457f, -0.01006653f, 0.05171103f, 0.22162472f, -0.05946143f, -0.05720939f, 0.24750966f, 
    0.16082498f, 0.09998770f, -0.15766014f, 0.19413665f, -0.00871893f, 0.09828206f, 0.07106878f, -0.50131917f, 
    -0.05831997f, -0.04222992f, -0.36303309f, -0.08844174f, 0.21497497f, 0.06242298f, -0.29352501f, -0.07291567f, 
    -0.42132720f, 0.33119926f, -0.01584156f, 0.00840119f, -0.04731115f, 0.07448000f, 0.11860038f, -0.01017451f, 
    0.01290829f, 0.09496272f, 0.06291397f, 0.27383199f, 0.02652036f, -0.42747763f, 0.19254878f, 0.02653446f, 
    0.23906410f, 0.08375469f, -0.07727396f, -0.26414528f, -0.27907875f, -0.28872544f, -0.03309469f, 0.08921782f, 
    0.10774660f, -0.25040659f, -0.05403979f, 0.00324604f, -0.01265145f, -0.21675143f, 0.23138826f, -0.10254248f, 
    0.29352629f, 0.27094555f, -0.03838698f, 0.10089424f, 0.04826948f, -0.10312957f, -0.60150582f, -0.07880557f, 
    0.20030946f, 0.20628940f, -0.07405673f, -0.03945240f, -0.65208566f, 0.00877669f, -0.05315283f, 0.04308776f, 
    0.30055606f, 0.03702645f, -0.07862652f, -0.08590999f, -0.04936218f, 0.08442982f, -0.03424180f, -0.39036340f, 
    0.03589051f, 0.15194716f, 0.23302867f, -0.03753324f, -0.40296060f, 0.09304867f, -0.26698470f, 0.04393771f, 
    0.05529943f, 0.03217334f, -0.07296222f, 0.12163784f, 0.00357175f, -0.01570034f, -0.08106944f, -0.08436051f, 
    0.13579047f, 0.06558573f, -0.12867936f, -0.30527440f, -0.01954851f, 0.06807566f, -0.12799154f, -0.27700701f, 
    -0.06717402f, -0.12635989f, 0.08675443f, -0.19427593f, -0.13102531f, 0.30535141f, 0.09943314f, 0.05517263f, 
    -0.07657529f, -0.36968142f, 0.14607926f, -0.39377654f, 0.08720363f, 0.08204336f, -0.07198730f, -0.04751965f, 
    0.14371811f, -0.35630733f, 0.24876273f, -0.27857763f, -0.07860760f, 0.11112886f, 0.22330190f, -0.07056931f, 
    0.12717442f, 0.07053714f, -0.02433106f, 0.28758150f, 0.04442170f, 0.09955257f, 0.11383297f, 0.13804063f, 
    0.11557049f, -0.04262765f, -0.37174889f, -0.26552057f, -0.01474030f, -0.33642113f, -0.10338776f, 0.15865013f, 
    -0.13278340f, 0.20116293f, 0.17552869f, 0.00115173f, -0.01039595f, -0.00005727f, 0.12730764f, -0.08208040f, 
    0.27162260f, 0.27361500f, -0.08147431f, -0.00201908f, -0.03843115f, -0.08511312f, 0.02302505f, 0.05905214f, 
    -0.44055828f, -0.02578196f, -0.03983148f, -0.03603782f, -0.04448134f, -0.29032826f, -0.03771534f, -0.07940685f, 
    -0.11909519f, 0.03760981f, 0.01138931f, -0.35245824f, 0.22827850f, -0.20263235f, -0.03296967f, 0.04975896f, 
    -0.00731039f, 0.22455329f, 0.19063792f, -0.10252503f, -0.03252716f, -0.25591815f, 0.04241122f, 0.06424407f, 
    -0.38692150f, -0.12019591f, 0.22689648f, -0.18674771f, 0.04389218f, 0.05553363f, -0.30666095f, 0.06985291f, 
    -0.31939819f, -0.19494568f, 0.10956008f, -0.26492697f, 0.04178628f, 0.00373265f, 0.09036222f, -0.42744312f, 
    0.29008397f, -0.09809821f, -0.05483029f, -0.22492036f, 0.11869019f, -0.34737915f, -0.07987855f, -0.22853403f, 
    -0.02114251f, 0.11204043f, 0.20247266f, 0.05070300f, 0.26358128f, -0.07155735f, -0.08071078f, 0.05334997f, 
    -0.08065673f, -0.28954723f, -0.10929654f, 0.03878561f, 0.12129592f, 0.10000533f, 0.03222572f, 0.02753870f, 
    0.09954875f, -0.05544342f, -0.07582562f, 0.18049304f, 0.11882558f, -0.18038353f, 0.38388550f, 0.27456185f, 
    0.37250701f, 0.03455821f, 0.04334483f, -0.25515458f, -0.41231832f, 0.05783452f, 0.08060875f, -0.07204600f, 
    -0.07011952f, 0.01725331f, 0.21309827f, -0.22195435f, 0.02612904f, -0.45386788f, -0.00929868f, -0.00612249f, 
    0.33981740f, -0.09528537f, -0.09432225f, -0.10742150f, 0.10775951f, -0.03178937f, 0.44587442f, 0.00425260f, 
    -0.25052780f, -0.11697187f, 0.09303743f, 0.31027979f, -0.07442269f, 0.06270836f, 0.10081458f, -0.00953938f, 
    -0.17168304f, -0.02704580f, -0.04633709f, -0.05579782f, 0.08744206f, -0.04281138f, 0.04699596f, 0.02972788f, 
    -0.11315223f, 0.09267990f, -0.35499048f, 0.03791589f, 0.12070444f, 0.07763849f, -0.25420499f, -0.12087159f, 
    0.39133516f, 0.04290157f, 0.04391876f, 0.02982861f, -0.05179378f, -0.08420606f, 0.00925742f, 0.06575340f, 
    0.12303448f, 0.00073079f, 0.07370393f, -0.07439313f, -0.02396775f, 0.29475772f, 0.03272317f, -0.66099387f, 
    0.36483306f, 0.11071753f, 0.01441383f, -0.24244270f, 0.05246982f, 0.23719358f, 0.10950584f, -0.12721251f, 
    0.09164426f, 0.20233963f, -0.39040869f, 0.10990088f, -0.02277009f, -0.01306437f, -0.47517478f, -0.02479010f, 
    -0.20941843f, -0.28596210f, 0.24498872f, 0.28111303f, 0.02609810f, 0.10316553f, 0.03593929f, 0.05719404f, 
    -0.18288438f, -0.44672355f, -0.08350527f, 0.35675538f, 0.00209917f, -0.09272837f, -0.03969813f, -0.04609299f, 
    0.09490651f, 0.00204076f, -0.04129898f, -0.16905220f, -0.05295517f, -0.38374099f, 0.10346163f, -0.03157804f, 
    0.08229982f, 0.14282496f, -0.05399520f, 0.10516866f, -0.36791128f, 0.12047361f, 0.01228220f, -0.04003294f, 
    -0.24021851f, 0.13024697f, 0.10925183f, 0.09827194f, 0.03896951f, -0.02971553f, -0.09135836f, 0.06196558f, 
    -0.03027164f, 0.07521707f, -0.11473572f, 0.18301134f, -0.08011627f, 0.31075621f, -0.63831443f, 0.15505786f, 
    -0.29059732f, -0.10604303f, -0.08178455f, -0.38113427f, 0.24766755f, 0.33458638f, 0.08986957f, -0.05079264f, 
    -0.10698567f, 0.13081345f, 0.11575327f, 0.17753975f, 0.08352528f, 0.08357378f, -0.40397286f, -0.06259866f, 
    0.08125271f, 0.26779196f, -0.34169966f, -0.22743519f, 0.08484935f, 0.02953318f, -0.03310682f, 0.02079459f, 
    0.15821274f, 0.07066785f, -0.02393805f, -0.47662780f, -0.03877013f, -0.00495302f, -0.06508814f, -0.03463481f, 
    0.15298374f, -0.04521597f, -0.15099567f, 0.02767328f, 0.03807782f, -0.45759776f, -0.00316794f, -0.45519099f, 
    -0.06816676f, -0.02073036f, 0.28925112f, 0.00905630f, -0.22441605f, -0.01539221f, 0.19479842f, -0.10972793f, 
    -0.28827491f, 0.30549854f, -0.01987540f, 0.09448902f, -0.10986128f, -0.00331493f, -0.07512791f, 0.07271631f, 
    0.10177667f, 0.10822772f, 0.10514429f, -0.46614984f, -0.08319718f, 0.29735008f, 0.09951544f, 0.07726409f, 
    -0.49268931f, -0.04558775f, -0.02152532f, 0.14748463f, 0.23368685f, -0.33312529f, -0.02398497f, 0.07761047f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05901270f, 0.01393522f, -0.08866002f, 0.02292016f, -0.06123409f, -0.01071182f, -0.05582889f, -0.12096115f, 
    0.08647206f, 0.01758718f, 0.20773332f, 0.15765065f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
