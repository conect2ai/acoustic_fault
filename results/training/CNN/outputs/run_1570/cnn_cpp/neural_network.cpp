#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.28016523f, 1.02364743f, 0.41424546f, -0.86987913f, -0.00189460f, 0.22273034f, -0.24454443f, 0.59006649f, 
    -0.59534490f, -0.71917027f, 0.01720528f, 0.13720162f, -0.16783442f, -0.02642308f, -0.13540184f, 0.27534589f, 
    0.11277670f, 0.17568870f, 0.14273481f, -0.36985666f, -0.08283901f, -0.15281084f, -0.17371146f, 0.34308362f, 
    -0.17629240f, 0.12357338f, -0.06203356f, -0.35155064f, -0.02651423f, 0.19169745f, -0.18885320f, -0.22291142f, 
    0.21590473f, 0.55075210f, -0.40277493f, -0.30805019f, 0.22219077f, -0.04892600f, -0.26630497f, 0.17155258f, 
    -0.28612202f, 0.12333986f, 0.34992075f, -0.45005876f, 0.26018456f, -0.12293450f, 0.53401488f, -0.31475040f, 
    0.17755507f, 0.12598903f, -0.50044185f, -0.34969947f, 0.08197618f, 0.36159483f, -0.33608571f, 0.53323042f, 
    0.11079045f, 0.09382369f, -0.18467166f, -0.07652028f, 0.08317715f, 0.02792133f, -0.26480693f, 0.21401624f, 
    -0.31661513f, 0.03141861f, 0.01407747f, 0.18336788f, 0.29516879f, 0.38168117f, 0.27665791f, 0.08775733f, 
    -0.29557851f, 0.04679921f, -0.05210223f, -1.33792055f, 0.46971008f, -0.02861665f, -0.26230842f, 0.28692037f, 
    0.14980212f, -0.20948604f, -0.17193986f, 0.23711404f, 0.43428811f, 0.06151605f, -0.19064835f, -0.27310300f, 
    -0.27720335f, -0.19201878f, 0.14075656f, -0.09499635f, -0.30539146f, 0.05891009f, -0.03893842f, -0.00017986f, 
    -0.25065640f, -0.47680980f, -0.40009516f, -0.94218069f, 0.52364439f, -0.60229522f, -0.15442495f, 0.21369560f, 
    1.14122915f, -0.69263452f, -0.48557687f, -0.68297380f, -0.59024084f, -0.01379027f, -0.12747090f, -0.49268195f, 
    0.00272117f, -0.44791245f, -0.24726385f, 0.26264775f, 0.17295738f, -0.07892121f, 0.21399102f, 0.10728414f, 
    0.17051135f, -0.19009218f, 0.13811578f, -0.13566075f, 0.11632973f, -0.05795716f, -0.21488924f, -0.47840333f, 
    -0.55680060f, -0.78536797f, -0.58286464f, -0.36452860f, -0.41243312f, -0.63600010f, -0.53151631f, 0.37704432f, 
    -0.19492224f, 0.03002681f, -0.21784911f, 0.10276490f, 0.08262677f, -0.06481816f, 0.23587869f, -0.05255244f, 
    -0.21447472f, 0.16747299f, 0.32195178f, 0.37099308f, 0.24039693f, 0.19581728f, -1.14147043f, -0.89107656f, 
    0.25525951f, 0.79749686f, 0.66923535f, 0.17634015f, -1.00465500f, 0.67558253f, 0.14527234f, 0.30228391f, 
    -0.47385606f, -0.07342730f, -0.14125645f, 0.03203488f, 0.06460931f, 0.03632968f, -0.11573834f, 0.15213132f, 
    -0.09569362f, -0.06142600f, 0.00097919f, -0.06091865f, 0.11367696f, 0.01151008f, 0.31780902f, 0.19813263f, 
    -0.52025300f, -1.19881618f, -0.98613715f, -1.17177999f, 0.51657128f, 0.54373693f, 0.15618098f, 0.05565871f, 
    0.17396124f, 0.08246314f, 0.81765813f, -0.18646406f, 0.14601037f, -0.42025033f, -0.61352545f, -0.52678084f, 
    -0.34298858f, 0.25094527f, 0.04383383f, 0.39854196f, -0.51907206f, -0.15695556f, 0.42112690f, 0.22872172f, 
    -0.47931299f, -1.61956739f, -0.48992288f, 0.39620000f, 0.66311044f, 0.75156391f, 0.66453016f, 0.02205785f, 
    -0.41309285f, 0.28573206f, 0.27726948f, -0.17610359f, -0.07541725f, -0.11589505f, 0.19015215f, 0.34006253f, 
    -0.07478644f, -0.16820599f, 0.20557466f, -0.24633552f, -0.16913654f, 0.00652468f, -0.01777545f, 0.18118535f, 
    -0.16576606f, -0.75269115f, -0.55709428f, -0.70660919f, -0.38651219f, -0.37052569f, -0.05483059f, 0.05529848f, 
    0.31773576f, 0.54105437f, 0.54890937f, 0.33453643f, 0.16856357f, 0.10323003f, -0.20061180f, -0.08227413f, 
    -0.05969360f, -0.28610095f, -0.13206302f, -0.17277035f, 0.03496373f, -0.28854758f, -0.21270427f, -0.32900015f, 
    -0.23096627f, -0.20201808f, -0.57123679f, -0.30378157f, 0.21729043f, 0.49684167f, 0.08671103f, -0.11222359f, 
    -0.08424076f, -0.71917433f, -0.29205206f, -0.07422435f, 0.71016252f, 0.21605296f, 0.26780188f, -0.41867879f, 
    -0.25655553f, 0.26044849f, -0.18404764f, -0.12464376f, -0.23328632f, -0.13717504f, 0.06366318f, 0.04597329f, 
    0.03261821f, 0.18149355f, 0.23252590f, 0.39013907f, 0.07263923f, 0.30576220f, 0.01505167f, 0.11813651f, 
    -0.03011921f, 0.19367772f, 0.35694256f, 0.02997322f, 0.28140673f, 0.17997055f, 0.03276990f, 0.05186993f, 
    0.13503377f, 0.08258783f, 0.08449484f, 0.05535677f, 0.17724620f, -0.08692112f, -0.01152547f, 0.04615481f, 
    -0.08955164f, 0.13585438f, 0.07011927f, 0.00260783f, 0.68568081f, -0.20262751f, -0.42690864f, 0.16452476f, 
    -0.07774001f, 0.65297061f, 0.39285532f, 0.42767337f, -0.43780079f, 0.09831163f, -0.41810417f, -0.30590099f, 
    -0.15566994f, -0.01328134f, -0.31926271f, 0.20793450f, 0.10041921f, 0.07604095f, 0.11072493f, 0.04132833f, 
    -0.13891859f, -0.32917780f, -0.28433374f, -0.19062518f, -0.07570887f, -0.34735054f, -0.06230929f, -0.72862536f, 
    -0.70782596f, -0.12672542f, 0.04711663f, -0.03262750f, -0.10500369f, 0.00217644f, -0.10120423f, -0.38038561f, 
    -0.62721151f, -0.29792821f, -0.20458190f, 0.35431266f, -0.60417473f, -0.35371545f, -0.17536187f, 0.15587477f, 
    -0.07277533f, -0.06879126f, 0.27322701f, 0.08889052f, -0.18893245f, -0.10368796f, 0.47944084f, -0.70240235f, 
    0.20057221f, 0.08381370f, 0.09030469f, 0.19482376f, -0.12436311f, -0.40326104f, -0.00528391f, -0.25095224f, 
    -0.01968499f, 0.19057544f, -0.18352227f, 0.51078176f, -0.41251531f, 0.06966679f, 0.18289794f, 0.01320479f, 
    0.02317138f, -0.31268752f, -0.09618026f, 0.11814460f, 0.04864531f, 0.21942443f, 0.21104813f, -0.45589259f, 
    -0.40432867f, 0.11085816f, 0.41837248f, 0.41654050f, 0.61181897f, 0.14816242f, -0.84228504f, -0.05693019f, 
    0.19106977f, -0.34410101f, -0.13717687f, 0.47460371f, 0.04780186f, -0.20878567f, -0.26027739f, -0.28395241f, 
    0.13409273f, 0.10848571f, 0.01521738f, 0.30981061f, -0.29193610f, -0.19979833f, 0.29294565f, -0.08308887f, 
    -1.06060719f, -0.66036659f, 0.10157451f, -0.19338787f, -0.58395386f, -0.44823968f, 0.07100286f, -0.24141763f, 
    -0.62522209f, -0.38557985f, 0.29880592f, -0.44145802f, -0.59111911f, -0.37784904f, -0.24806412f, -0.18328333f, 
    0.03956524f, -0.26214179f, -0.13578299f, -0.33180532f, -0.14841551f, -0.18573783f, -0.11831862f, 0.16566209f, 
    0.23172025f, 0.18461880f, 0.49651283f, 0.41872624f, 0.46676898f, 0.37720352f, 0.49073806f, -0.31980008f, 
    -0.64584935f, -0.68000764f, -0.40104422f, 0.06884968f, 0.24687001f, 0.06642431f, -0.18876842f, -0.19192420f, 
    -0.31391537f, -0.06112842f, 0.30793595f, 0.18811429f, 0.14555995f, 0.05469073f, -0.12890446f, 0.09545776f, 
    -0.16782576f, -0.03917567f, -0.89262229f, -0.11669026f, -0.33335558f, -0.65183747f, -0.05088725f, -0.17613742f, 
    -0.38852274f, -0.64753968f, -0.62376326f, -0.24431163f, -0.29592490f, -0.44215396f, -0.08108758f, 0.20500335f, 
    -0.02757618f, 0.15599731f, -0.23718563f, -0.25231642f, 0.03692230f, -0.72378826f, -0.37675032f, 0.11597621f, 
    -0.05182382f, -0.47966418f, 0.29000965f, 0.69157189f, 0.19911666f, 0.08845614f, -0.04245429f, -0.10582075f, 
    0.32565862f, 0.39051759f, 0.34427953f, -0.26384819f, 0.02078423f, 0.09593321f, 0.18021479f, -0.51417780f, 
    -0.83064181f, 0.01709036f, 0.33483365f, -0.03294012f, -0.20551607f, -0.43756604f, -0.49384436f, 0.24146634f, 
    -0.15945145f, 0.12314276f, -0.12686200f, 0.16541883f, -1.50628912f, -0.63780600f, 0.08310953f, 0.08707995f, 
    -0.22091332f, 0.25195125f, 0.70246983f, 0.50970823f, -0.01576819f, -0.82779878f, 0.10594816f, -0.05011911f, 
    -0.05566442f, 0.94837481f, -0.31535968f, 0.15703498f, -0.25321919f, -0.52481765f, -0.42614150f, -0.16140653f, 
    0.20459646f, -0.09731838f, 0.15911739f, 0.19798175f, -0.40121010f, -0.11237265f, -0.43257630f, -0.47939959f, 
    -0.28051198f, 0.76549387f, -0.82062906f, -0.45147333f, 0.37114507f, 0.09806705f, -0.04439522f, -0.01013138f, 
    0.17854694f, 0.87350893f, -0.05630214f, -0.28000680f, 0.06160638f, -0.15908682f, -0.24460778f, -0.19843765f, 
    -0.14157315f, 0.16496359f, -0.04381703f, -0.11223290f, 0.16475700f, 0.15050645f, 0.27833146f, 0.01145122f, 
    -0.00058390f, 0.51652789f, -0.07190242f, -0.26012376f, -0.22573172f, 0.11014298f, -0.48668489f, 0.09987070f, 
    -0.15358421f, -0.02128881f, -0.69807249f, 0.10750140f, 0.27617308f, 0.15607399f, 0.46297759f, 0.01023682f, 
    0.14793502f, 0.08560103f, -0.16325328f, 0.32168952f, 0.30968153f, -0.49564922f, -0.80016804f, 0.25104177f, 
    0.49724758f, 0.28041196f, -0.15410927f, -0.27258953f, -0.49577498f, 0.06095415f, 0.42291257f, -0.09879855f, 
    -0.36192304f, -0.29785207f, -0.01892060f, -0.10293704f, -0.02065889f, -0.09667898f, 0.16236053f, -0.07932303f, 
    0.06778074f, -0.11497235f, -0.43670183f, -0.09868351f, 0.15726048f, 0.14016992f, 0.23505570f, 0.31179014f, 
    1.01099551f, -0.01994378f, -0.21833113f, -0.27987251f, -0.48573342f, 0.11018779f, -0.73995042f, -0.70150077f, 
    -0.91373348f, -1.32900870f, -0.01290701f, 0.02757245f, 0.02559973f, 0.59164345f, -0.09667449f, -0.09284836f, 
    -0.38413948f, 0.10283173f, 0.33492929f, 0.01219925f, -0.19287656f, -0.24948870f, -0.07049315f, -0.01302446f, 
    -0.11405669f, -0.31192005f, 0.13480675f, -0.81406599f, -0.78391218f, -0.23888227f, -0.66749144f, -0.42395288f, 
    -0.11717407f, -0.63400435f, -0.77529776f, 0.38753811f, 0.24218035f, 0.35528195f, -0.04467744f, -0.05582511f, 
    -0.19762731f, -0.22983529f, -0.32445499f, -0.23269694f, -0.21005143f, -0.20231277f, -0.40872821f, 0.17796189f, 
    -0.30579865f, -0.34663829f, 0.78384829f, 0.57232493f, 0.11607382f, -0.20909700f, -0.20032890f, 0.34137893f, 
    0.00050394f, -0.07327886f, -0.37866718f, -0.14337856f, 0.04812649f, 0.35181090f, -0.18251801f, -0.11969651f, 
    -0.18618180f, -0.25691727f, -0.24727495f, 0.17170075f, -0.11380173f, 0.09011009f, -0.21210061f, 0.30628720f, 
    -0.00603032f, -0.07462248f, -0.45842126f, -1.71271765f, 0.27827647f, -0.90911800f, -1.43875384f, -0.11257766f, 
    0.64491546f, 0.20078607f, 0.04930631f, 0.22860475f, -0.29924315f, -0.50473320f, -0.38321936f, -0.34776023f, 
    -0.40347725f, -0.44472006f, 0.38476515f, -0.21872595f, -0.20669621f, 0.13316406f, -0.04811252f, -0.00601368f, 
    0.00441114f, -0.14495656f, -0.08669063f, -0.25879395f, -1.04089439f, -0.77986246f, -0.49454921f, -0.29508734f, 
    -0.20093316f, 0.71747160f, 0.27199847f, 0.09570365f, 0.53635341f, 0.71782124f, 0.07328351f, 0.11432198f, 
    0.22762668f, 0.09501892f, 0.03310758f, -0.11705577f, 0.04236547f, -0.14215477f, -0.17126422f, 0.17577662f, 
    -0.10016447f, 0.09618734f, 0.12011687f, 0.06361780f, -0.02058236f, -0.46785551f, -0.57735765f, -0.21457915f, 
    -0.12712829f, 0.85072923f, 0.53636491f, -0.58432865f, -0.50539798f, 0.16873112f, -0.06042808f, 0.46136066f, 
    -0.07951859f, -0.02072777f, 0.16962604f, -0.24434489f, 0.00899467f, -0.31761882f, 0.25064865f, -0.13575570f, 
    0.04581459f, 0.02749846f, 0.29264453f, 0.03619897f, 0.08913433f, 0.16988668f, 0.56230932f, -0.82609624f, 
    -0.67378086f, -0.69415557f, 0.13974878f, -0.29888326f, -0.25958872f, 1.21623898f, -0.38746390f, -0.20694034f, 
    -0.04352833f, 0.05633860f, 0.20997262f, -0.54582518f, 0.04694365f, 0.09316797f, -0.18009195f, 0.06215847f, 
    0.33796760f, 0.00601387f, -0.07499969f, 0.21534745f, -0.35708869f, 0.03806673f, 0.32485196f, -0.18929064f, 
    0.39920190f, 0.67352468f, 0.64098090f, -0.01479215f, -0.46549878f, -0.83751345f, -0.35148045f, 0.12297322f, 
    0.08499107f, -0.13562764f, -0.45624581f, -0.23528524f, 0.02954032f, 0.82820195f, -0.12189537f, -0.02695872f, 
    -0.24361169f, 0.31860450f, 0.17679940f, 0.04388928f, 0.07494300f, -0.46705702f, -0.04401158f, -0.14885482f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.36110708f, 0.39641806f, 0.05047359f, 0.05964277f, -0.14261898f, -0.26981249f, 0.46065682f, 0.64238989f, 
    0.23595458f, -0.04981580f, 0.28954247f, 0.09127526f, 0.09175166f, 0.12005210f, 0.33166644f, 0.43232465f, 
    -0.14413032f, 0.31444967f, -0.48736668f, 0.52724266f, 0.15818554f, 0.36580640f, -0.11098219f, 0.28612557f, 
    -0.00879851f, -0.22055513f, 0.38190684f, -0.43570891f, 0.19205691f, 0.24444921f, 0.47732937f, 0.54813546f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07357927f, -0.21826068f, -0.76538748f, 0.20182960f, -0.17530251f, -0.05627324f, -0.21178919f, -0.32489741f, 
    -0.08107409f, 0.16361332f, -0.07029327f, 0.01932329f, -0.13058133f, -0.01092752f, -0.07268704f, 0.09371216f, 
    -0.22229251f, 0.01155559f, -0.09244680f, -0.03552080f, -0.06730980f, -0.07089792f, -0.00233507f, -0.21952309f, 
    0.20350192f, 0.02066906f, 0.06201141f, -0.09638014f, -0.32780945f, -0.20082009f, -0.15562138f, -0.10184695f, 
    0.00199174f, -0.01516051f, -0.06914654f, -0.04600837f, -0.07602756f, 0.14282213f, 0.07482263f, 0.01611248f, 
    -0.00347295f, 0.14339720f, 0.03966133f, 0.09941740f, 0.01475916f, 0.19275475f, 0.24938357f, 0.02435996f, 
    0.20115221f, 0.18503866f, 0.11221710f, -0.04278293f, 0.16292769f, 0.00776134f, 0.00174832f, -0.10048147f, 
    -0.03578209f, -0.01722915f, -0.00320818f, 0.05671685f, 0.37264678f, 0.20867077f, -0.15247926f, -0.15049951f, 
    0.12699258f, 0.25330651f, -0.05558875f, -0.07861321f, 0.06522639f, 0.03340953f, 0.02620216f, 0.05116712f, 
    0.40307805f, 0.22245224f, 0.47504753f, -0.57439715f, -0.29046950f, -0.11939222f, 0.16501927f, -0.08733777f, 
    -0.15586646f, -0.13805909f, -0.15557724f, -0.30801275f, 0.03253327f, -0.03567045f, -0.36875883f, -0.11341453f, 
    0.14262412f, 0.05295296f, -0.28401184f, -0.18895316f, -0.09264779f, -0.20557503f, -0.08464847f, 0.01539560f, 
    0.28928024f, 0.06795495f, -0.37547693f, 0.09252477f, 0.00124319f, 0.05132432f, 0.10455775f, -0.07541895f, 
    -0.14239408f, 0.02324723f, -0.00315448f, -0.01766562f, -0.07835590f, 0.09708314f, 0.09699026f, 0.10458478f, 
    0.15011376f, 0.06898436f, 0.13148697f, -0.05127113f, 0.02625827f, 0.10862941f, 0.12265281f, 0.15924515f, 
    0.12597641f, 0.28558946f, 0.04340276f, -0.19477889f, -0.04615280f, -0.09170561f, -0.04598814f, -0.22221015f, 
    0.03830410f, -0.12292005f, -0.04235836f, -0.14719205f, 0.02717116f, -0.00290054f, 0.05834901f, 0.07267387f, 
    -0.04459091f, 0.02851247f, 0.02165817f, 0.03209111f, -0.13017815f, -0.06622335f, -0.05802802f, -0.02911281f, 
    -0.29222763f, -0.36697319f, -0.26108977f, 0.06898952f, 0.10839742f, 0.07295652f, 0.09526394f, 0.08052374f, 
    0.09970044f, 0.02842862f, 0.02856077f, 0.02397292f, 0.18571272f, 0.12661350f, -0.07535359f, -0.15849675f, 
    0.19857605f, 0.09583865f, 0.05519354f, 0.03168186f, -0.07921586f, -0.22344244f, -0.17064855f, 0.03390530f, 
    -0.01276262f, -0.02464767f, -0.08189370f, -0.09675112f, -0.13714416f, -0.37067944f, 0.06540305f, -0.21770853f, 
    -0.04034683f, -0.07932589f, -0.08507682f, -0.03629211f, 0.38115630f, 0.23739989f, -0.27585769f, -0.11154009f, 
    -0.09278547f, -0.10699575f, -0.08395094f, 0.05683573f, -0.03518965f, -0.15376638f, -0.09036481f, -0.12806724f, 
    0.37600398f, 0.24172245f, -0.11596040f, -0.29448602f, 0.16253433f, 0.09033094f, 0.13761257f, 0.23215951f, 
    -0.06802560f, -0.02409591f, -0.09726844f, -0.22168629f, -0.25461799f, 0.15205778f, -0.44170246f, 0.17864002f, 
    0.03241757f, -0.07118375f, -0.05991896f, -0.16784598f, -0.03700251f, 0.01223606f, 0.07097432f, 0.07902245f, 
    0.29710537f, 0.26062620f, -0.04291333f, -0.15954459f, 0.08277878f, 0.19288854f, 0.07464974f, -0.06101988f, 
    -0.12838632f, -0.05669990f, 0.03133355f, -0.13487799f, -0.33549345f, -0.52162421f, -0.69802815f, 0.18855295f, 
    -0.03219016f, -0.00301514f, 0.02915457f, 0.04620941f, -0.05452828f, -0.04516595f, 0.07846951f, -0.03246684f, 
    0.16236769f, -0.31077743f, -0.17874022f, -0.19389096f, 0.02263583f, 0.08574120f, -0.00581691f, 0.06748628f, 
    -0.21849531f, -0.18478996f, -0.03281538f, 0.12448200f, 0.13110882f, 0.44268250f, -0.04940983f, -0.28042033f, 
    -0.03858669f, -0.01148846f, -0.11910830f, -0.33046815f, -0.07470289f, -0.18749423f, 0.00457483f, -0.03656360f, 
    0.03384505f, -0.07386758f, 0.23630357f, -0.06472781f, 0.03473891f, -0.08749827f, -0.02013535f, -0.02727370f, 
    -0.03444633f, 0.10447461f, 0.02833159f, 0.01408282f, -0.25061846f, -0.26836401f, 0.02894823f, 0.11458050f, 
    -0.03012098f, -0.00482409f, 0.06791330f, 0.02929133f, -0.07297752f, -0.04072354f, 0.01061523f, -0.00125202f, 
    0.40309334f, -0.02457598f, -0.43116939f, -0.13267283f, -0.00159188f, -0.34944209f, 0.06353884f, 0.10688742f, 
    0.00969625f, 0.11893136f, -0.00794376f, -0.00703626f, 0.43099111f, 0.25032458f, -0.22201888f, -0.09056159f, 
    0.03991979f, -0.03382787f, 0.08033290f, 0.25409153f, -0.09501261f, -0.12240296f, -0.10140117f, -0.10288750f, 
    -0.52431864f, -0.73978055f, -0.58804524f, 0.04918088f, 0.10287945f, 0.01342757f, 0.06610139f, -0.01267365f, 
    -0.11884715f, 0.06045369f, -0.06588517f, -0.02382686f, 0.14767566f, 0.26719299f, -0.10597182f, -0.13446456f, 
    -0.03016831f, 0.41937399f, 0.31475085f, 0.14088047f, -0.05540976f, 0.04391417f, 0.04976704f, -0.17059124f, 
    0.05373649f, 0.19970152f, 0.10546942f, 0.01751521f, 0.14088291f, 0.11648546f, 0.04855382f, -0.00503199f, 
    -0.05733066f, 0.09946050f, -0.07520794f, -0.04262101f, 0.29484573f, 0.27197006f, -0.11490618f, -0.12459024f, 
    -0.26088810f, 0.10086484f, -0.06232350f, -0.04322518f, -0.01575746f, -0.09171527f, -0.02768944f, -0.07257298f, 
    0.14421768f, 0.00155202f, -0.28840825f, -0.13035804f, 0.08173341f, -0.17520396f, -0.15929224f, -0.07199273f, 
    0.05233439f, -0.01886399f, -0.03098050f, 0.01309455f, -0.52952987f, 0.13028665f, 0.18916480f, -0.60070646f, 
    0.01696305f, -0.06906419f, -0.06363034f, -0.08627304f, 0.04102310f, -0.08818598f, -0.03333522f, -0.02671270f, 
    0.21508436f, -0.27712235f, 0.19597730f, -0.02953948f, 0.07083701f, -0.21965159f, 0.21371512f, -0.19838101f, 
    0.03046491f, 0.07567964f, 0.01686470f, 0.06637287f, 0.03797486f, 0.13377061f, -0.03530626f, 0.16412939f, 
    0.23336311f, 0.12774272f, -0.15032624f, -0.08048876f, -0.17669214f, 0.11285536f, -0.16186982f, 0.06254303f, 
    -0.02346906f, 0.00330010f, -0.04934589f, -0.09826874f, 0.00918188f, -0.01636951f, -0.06718095f, 0.01086884f, 
    -0.07269504f, -0.20860437f, 0.10440469f, -0.02400863f, -0.02685659f, 0.11896855f, -0.08163442f, -0.02208246f, 
    0.06259921f, 0.01609761f, -0.14664412f, -0.02616953f, -0.41393781f, -0.24538228f, -0.27968299f, -0.29929033f, 
    -0.38267899f, -0.02760348f, -0.94308436f, -0.40023378f, -0.05257355f, -0.13071609f, 0.11992597f, -0.45835459f, 
    -0.07402186f, -0.01295495f, -0.06095376f, -0.05095243f, 0.04538246f, 0.21121183f, 0.20992497f, -0.14036681f, 
    -0.17773026f, -0.10581454f, -0.18908720f, 0.09567209f, -0.11459454f, -0.02721421f, -0.04554569f, -0.01251068f, 
    -0.74260736f, 0.16275787f, -0.30454269f, 0.15882672f, -0.07379846f, 0.13278067f, 0.01635519f, 0.14673021f, 
    0.14322136f, 0.07770071f, -0.12059681f, 0.10951954f, 0.21037622f, -0.52003843f, -0.26567343f, -0.24618934f, 
    -0.05263145f, 0.19978312f, 0.07164877f, 0.09955785f, 0.21510972f, 0.02016615f, -0.08684292f, -0.00450425f, 
    0.42007828f, -0.25168043f, -0.16024412f, 0.13791409f, -0.00539703f, 0.01933579f, 0.07494763f, 0.03257059f, 
    0.09038334f, -0.19520749f, 0.08722329f, 0.00529675f, -0.09021220f, -0.04827834f, -0.21131939f, -0.11733314f, 
    -0.03705487f, 0.00776165f, 0.01848289f, -0.12724848f, 0.02957371f, -0.19267480f, -0.10318942f, 0.03751494f, 
    -0.19664830f, 0.15009479f, -0.27928483f, 0.02663201f, 0.08100864f, 0.27787936f, 0.05577391f, 0.26973313f, 
    -0.05411699f, -0.05823128f, -0.04720292f, 0.15090907f, 0.13986190f, 0.11399945f, 0.11831207f, 0.04480002f, 
    -0.07144747f, 0.02693301f, -0.00805484f, 0.03404921f, 0.05444330f, 0.06645435f, 0.11738701f, 0.04898509f, 
    0.54047143f, -0.01751440f, 0.01126439f, 0.18209834f, -0.03037688f, -0.05538576f, -0.06895936f, -0.00644723f, 
    0.24121645f, -0.25960520f, -0.00474450f, -0.07881285f, -0.16171195f, 0.28132245f, 0.14328481f, -0.03485355f, 
    0.11464948f, 0.14075646f, 0.04817036f, 0.26743534f, -0.04244436f, 0.08268352f, -0.03779389f, -0.19722468f, 
    0.02531870f, 0.03786436f, -0.11747935f, 0.01377967f, -0.00791383f, 0.12183789f, 0.06128300f, -0.21631925f, 
    -0.11403610f, -0.05583544f, 0.09286983f, 0.16601497f, -0.02835699f, 0.02045733f, 0.04765927f, 0.28708959f, 
    0.09585852f, -0.08240950f, 0.12932995f, -0.05559027f, 0.14738879f, 0.13893892f, 0.19679877f, -0.08675314f, 
    0.28653151f, 0.11403138f, 0.23664670f, -0.25756818f, 0.13300492f, -0.07105042f, -0.15516627f, 0.01461273f, 
    0.05819355f, 0.09321950f, -0.11021421f, 0.00213422f, 0.18794222f, 0.13783225f, -0.09489473f, -0.03472457f, 
    -0.03372072f, -0.08328333f, -0.19797558f, -0.03302123f, 0.01892837f, -0.01961294f, 0.04087685f, 0.08094700f, 
    0.05751022f, 0.20322585f, 0.26225945f, 0.36457318f, 0.27079895f, 0.02736337f, -0.01837249f, -0.26897016f, 
    0.03942973f, 0.06449596f, 0.03625926f, -0.06993478f, 0.66782331f, 0.09140250f, 0.46629661f, 0.34444162f, 
    -0.01975897f, 0.00435462f, 0.05923399f, 0.01098766f, 0.02422861f, 0.08636203f, -0.27272269f, 0.14588091f, 
    -0.39196622f, -0.73528397f, 0.27728316f, -0.13039681f, -0.03487118f, -0.00360900f, 0.14903645f, -0.07100488f, 
    -0.14250803f, -0.23069325f, -0.03441977f, -0.12792218f, -0.58137202f, -0.26419750f, -0.35178870f, 0.23882473f, 
    -0.01351870f, 0.16192822f, 0.18942310f, 0.02932904f, 0.14755821f, 0.08115725f, 0.12663749f, 0.09321102f, 
    -0.12482458f, 0.11380905f, -0.07994380f, 0.09757118f, 0.15495159f, -0.14901200f, -0.23499577f, 0.07574314f, 
    0.05121858f, 0.04774716f, -0.07218149f, -0.03649290f, 0.12069572f, 0.04844575f, 0.16073157f, -0.18799105f, 
    -0.12361098f, 0.02724471f, 0.01760953f, -0.03405010f, -0.06098332f, 0.05888487f, -0.01332639f, 0.05189865f, 
    0.40457809f, -0.11002745f, -0.14551528f, -0.27870134f, -0.41794193f, -0.14919990f, -0.31547007f, -0.09683973f, 
    -0.01369859f, 0.00940507f, 0.02850019f, 0.17569311f, -0.17565900f, -0.16784316f, 0.03862774f, 0.05551498f, 
    -0.00640275f, 0.16167310f, -0.05205390f, 0.06707407f, -0.02615512f, -0.03046127f, -0.01287612f, 0.12236711f, 
    0.46186483f, 0.09926701f, -0.03624024f, -0.00509470f, -0.01828963f, -0.09350641f, 0.02127612f, 0.02498803f, 
    -0.04106766f, 0.09415863f, -0.00135913f, 0.04471658f, 0.08594798f, 0.43416959f, 0.12661445f, 0.22460133f, 
    -0.09128509f, -0.11485853f, -0.17343612f, -0.16746534f, -0.02951831f, 0.02467169f, -0.10746195f, -0.19240622f, 
    0.26482055f, 0.04715276f, -0.26650649f, -0.19816907f, -0.09570362f, 0.03472435f, 0.09524100f, -0.03250398f, 
    -0.08746267f, -0.00452698f, 0.10088348f, -0.15766190f, -0.11639865f, 0.12966219f, -0.14957282f, 0.20970546f, 
    0.14370467f, -0.11478568f, 0.19899537f, 0.26937240f, -0.01745835f, -0.02497244f, 0.06399629f, -0.04352488f, 
    0.20307380f, 0.22902730f, -0.40757513f, -0.06135982f, -0.03639763f, 0.10978895f, 0.02894110f, -0.37476179f, 
    -0.06147168f, 0.01632403f, -0.22470282f, -0.02466569f, -0.04954044f, 0.20474076f, -0.05375515f, -0.20808280f, 
    0.04420095f, -0.06658430f, 0.03770767f, 0.09476147f, -0.02238074f, -0.02146038f, 0.03862702f, -0.02835068f, 
    -0.04007192f, -0.32716960f, 0.19101548f, -0.26605329f, 0.00227266f, -0.30341795f, 0.16994371f, -0.04152919f, 
    0.06816471f, -0.11403605f, 0.02569327f, 0.07000954f, -0.05358624f, -0.01177921f, 0.03413854f, 0.02306344f, 
    -0.23477985f, 0.03530693f, -0.04969422f, -0.03121311f, 0.01487267f, 0.00484394f, -0.00323281f, -0.00857965f, 
    0.04890697f, 0.04817250f, 0.15078129f, -0.09329856f, -0.15096006f, -0.24416913f, -0.18317561f, 0.22814639f, 
    0.07010639f, 0.05614930f, 0.00314370f, 0.04476000f, 0.13680488f, -0.04273340f, -0.04104786f, 0.16112453f, 
    0.00643368f, -0.06927188f, -0.02600995f, -0.00077960f, 0.04426108f, -0.00585564f, 0.16512732f, 0.46831071f, 
    -0.53694564f, -0.37290609f, -0.29770640f, 0.35041422f, -0.55669558f, -0.09292789f, -0.12613277f, 0.07090491f, 
    -0.01329729f, -0.01748257f, -0.01010261f, -0.04102211f, -0.62676615f, -0.44028834f, -0.07929295f, -0.49217209f, 
    -0.19661851f, -0.01169487f, -0.01565043f, -0.07429525f, 0.01003253f, -0.04225787f, 0.00292489f, -0.03156574f, 
    -0.08353291f, 0.22006391f, -0.62340999f, 0.15819885f, 0.09245181f, -0.00709844f, 0.08720708f, -0.11875109f, 
    -0.12089258f, 0.01178315f, -0.05280733f, -0.01486757f, 0.06273990f, 0.49062136f, 0.13289933f, 0.12011296f, 
    -0.02705709f, -0.00468365f, 0.00821243f, -0.01721612f, 0.07249157f, -0.07955913f, -0.15233967f, 0.02277394f, 
    0.13894911f, -0.30496469f, 0.41886476f, 0.07459012f, 0.10511304f, -0.02736884f, 0.02926237f, 0.11113373f, 
    0.10367855f, -0.05911887f, 0.09709625f, -0.00999809f, 0.15565120f, 0.33163175f, 0.11756722f, 0.30296049f, 
    -0.03507677f, 0.00581056f, 0.00226919f, -0.03383805f, -0.01779050f, 0.18597323f, 0.10822691f, 0.29452661f, 
    -0.06602550f, -0.12555954f, -0.19575885f, -0.10798387f, 0.31230095f, 0.02442382f, -0.11030792f, 0.15311162f, 
    -0.02578419f, 0.04847291f, -0.05180140f, -0.00778698f, -0.10841843f, -0.10306019f, 0.04011562f, 0.00610237f, 
    -0.04163552f, -0.05496649f, -0.01798012f, -0.02652417f, -0.03175401f, 0.01097522f, 0.09441256f, -0.06884273f, 
    -0.27113748f, -0.28588566f, -0.13695458f, -0.11077844f, 0.04911272f, 0.00502933f, 0.01901897f, -0.06613240f, 
    0.18397549f, 0.13118774f, 0.21248461f, 0.02219700f, -0.33326703f, 0.11080597f, 0.40880960f, 0.33306667f, 
    0.02509282f, 0.02181935f, 0.07304206f, 0.10361888f, -0.04817582f, -0.01364075f, -0.03699608f, -0.19050002f, 
    -0.09182838f, -0.00981664f, 0.01730691f, -0.00544236f, -0.11228903f, -0.17288433f, -0.16732240f, 0.07827272f, 
    0.02131765f, -0.18473712f, 0.08828258f, -0.03053624f, -0.09399809f, 0.20719191f, -0.14606464f, 0.01984586f, 
    0.05601711f, -0.10221955f, 0.14723475f, 0.15573867f, -0.05123375f, 0.04746380f, 0.25749362f, -0.47024772f, 
    -0.31126335f, -0.00890983f, 0.14747830f, -0.19683601f, 0.10885479f, 0.09987649f, 0.05973309f, 0.14562798f, 
    -0.00880139f, -0.02514852f, -0.01419565f, 0.06598561f, -0.10633527f, 0.23610274f, -0.07008368f, -0.79167724f, 
    0.07076684f, -0.15748636f, 0.03372902f, 0.18960820f, 0.05445224f, -0.03224423f, 0.06609255f, -0.04552653f, 
    -0.78390878f, -0.79624587f, -0.09552255f, -0.13422453f, 0.10512935f, 0.02086302f, -0.13372660f, 0.05526755f, 
    -0.00087296f, -0.02371642f, 0.04895041f, -0.04177685f, -0.14337416f, -0.31637830f, -0.08986460f, -0.12191229f, 
    0.03282039f, -0.03450599f, 0.02921792f, 0.00587887f, 0.08341335f, 0.05080003f, -0.26848456f, 0.02461720f, 
    0.31223780f, -0.18132077f, 0.41420770f, 0.13643830f, -0.08189075f, 0.06111382f, 0.13370851f, -0.00232972f, 
    -0.04125374f, -0.03724772f, 0.11324628f, -0.18439071f, 0.37824634f, -0.27514511f, -0.51354957f, 0.25527591f, 
    -0.11827905f, -0.00207753f, 0.10997024f, 0.07232083f, -0.01241714f, -0.02066610f, -0.01287351f, -0.00815367f, 
    -0.02169341f, -0.02586395f, -0.06794858f, -0.09722669f, 0.07480691f, -0.38295519f, -0.07460678f, -0.17040318f, 
    0.04549581f, 0.00311132f, -0.18697985f, 0.23066066f, 0.04290978f, -0.37575752f, -0.02859510f, -0.11003114f, 
    0.14660349f, 0.04300941f, 0.03575630f, -0.04001207f, -0.00661103f, -0.06230742f, -0.03942327f, -0.05149815f, 
    -0.93474424f, -0.24187131f, -0.00900835f, -0.53373122f, 0.04942619f, -0.03519749f, -0.14736797f, -0.34332520f, 
    0.04804337f, -0.05181113f, 0.08315853f, -0.10073906f, -0.64941800f, -0.04930829f, -0.06659426f, -0.27298075f, 
    -0.02751029f, -0.11401474f, 0.10909416f, -0.27620077f, -0.02107438f, 0.02872498f, 0.03973685f, -0.03890922f, 
    -0.20641202f, -0.05181647f, 0.03760915f, -0.42700267f, -0.05616087f, -0.03629921f, -0.01874471f, 0.04299378f, 
    -0.01822519f, -0.03092655f, -0.05221888f, 0.04703861f, -0.54445559f, 0.41710582f, 0.45753902f, 0.70040423f, 
    0.10679648f, -0.39326292f, 0.09337045f, 0.04802806f, 0.06069349f, -0.04077698f, -0.00532901f, 0.00240140f, 
    -0.14050759f, 0.12080154f, 0.37853667f, 0.47752947f, 0.02885988f, -0.03325943f, 0.07793723f, 0.00500877f, 
    -0.08366825f, 0.02498227f, 0.17212488f, 0.02864141f, -0.13235469f, -0.05456971f, -0.00172254f, 0.03559639f, 
    0.09556079f, -0.05148441f, -0.01015936f, 0.22285751f, -0.00705036f, 0.05440747f, 0.00354201f, -0.05382065f, 
    -0.16993360f, 0.54138660f, 0.25426993f, 0.12109415f, 0.09199753f, 0.00279913f, 0.10233653f, 0.06927554f, 
    0.09205030f, 0.03640264f, 0.06646835f, -0.01030109f, -0.26570895f, 0.20738381f, 0.05052199f, -0.20826393f, 
    -0.01219219f, 0.12706390f, -0.13137344f, -0.04918512f, 0.06366294f, -0.03627979f, -0.03076921f, 0.03603019f, 
    0.24031952f, 0.05475288f, 0.59550732f, -0.00270246f, -0.23614208f, -0.16217193f, -0.15092976f, 0.19446507f, 
    0.34949791f, 0.12874641f, 0.17269887f, 0.07462259f, 0.06031581f, -0.21452574f, 0.33875793f, -0.27910110f, 
    -0.13994665f, -0.31519517f, -0.35497081f, 0.10023186f, 0.00183489f, 0.24841993f, -0.20854485f, -0.15793893f, 
    -0.14327306f, 0.48285335f, 0.03801459f, 0.02698462f, 0.14944161f, -0.07705213f, 0.04441899f, -0.08169232f, 
    -0.25328520f, 0.06580017f, -0.07935463f, -0.29172334f, 0.55115032f, 0.02362634f, -0.13660872f, -0.12320872f, 
    0.13026816f, 0.18879765f, 0.22114713f, -0.20894013f, -0.08791949f, -0.03707941f, -0.06526571f, 0.00458062f, 
    -0.17485361f, 0.30763426f, -0.26656631f, 0.37563437f, -0.05952864f, 0.00373058f, 0.00626513f, -0.00124108f, 
    -0.01708541f, -0.08879288f, 0.00390536f, 0.08890577f, -0.03327262f, -0.19206247f, -0.00124975f, 0.28297228f, 
    0.01375450f, 0.18457517f, 0.09907109f, 0.04137247f, 0.08537744f, 0.02070097f, -0.07648438f, -0.25123167f, 
    -0.30204985f, 0.57491946f, -0.36037624f, -1.13035631f, 0.20553966f, -0.07069889f, -0.12200493f, 0.19793932f, 
    -0.16111226f, -0.07596195f, -0.13442969f, -0.04169630f, -0.19187260f, -0.05684648f, 0.00305529f, 0.37825850f, 
    0.03118015f, -0.14744318f, -0.02583702f, -0.07638229f, -0.08919962f, -0.00574630f, 0.22807121f, 0.11030475f, 
    -0.71706128f, 0.77863127f, -0.25764757f, -0.47285801f, 0.16516958f, 0.07339375f, -0.15430103f, -0.15830259f, 
    -0.28908658f, -0.08476752f, 0.02090554f, -0.05158524f, 0.09332692f, -0.16382040f, 0.04930324f, 0.17453828f, 
    0.15557255f, 0.01196071f, -0.07396255f, -0.27114701f, 0.00907821f, 0.05424051f, -0.01219639f, 0.09075007f, 
    0.11944363f, -0.03367496f, -0.13968173f, 0.06845088f, 0.08119141f, -0.03858162f, -0.09218598f, -0.07020272f, 
    -0.01708166f, 0.11370358f, -0.11990573f, 0.03629781f, -0.75390530f, -0.48163635f, -0.33112317f, 0.08308932f, 
    -0.04176315f, -0.37109303f, -0.00039905f, -0.12466197f, 0.06949180f, 0.02069653f, -0.06028153f, -0.15542074f, 
    0.19013804f, 0.58601201f, -0.25207970f, -0.10927515f, 0.31533533f, 0.12785062f, 0.26220599f, 0.03416228f, 
    -0.08979530f, -0.11878525f, 0.13141079f, -0.07362078f, 0.27003905f, -0.14488108f, 0.03090825f, 0.27031812f, 
    -0.04920484f, 0.00406564f, -0.10825838f, -0.00381860f, 0.05681323f, -0.10874605f, 0.11782416f, -0.07169302f, 
    -0.36976671f, -0.19387802f, -0.18260421f, 0.32136276f, 0.02769710f, -0.30518743f, -0.04279935f, -0.23236591f, 
    -0.37134162f, 0.11058949f, -0.07426831f, -0.05180084f, -0.61163253f, 0.54899251f, -0.47345722f, -0.56593043f, 
    0.26811460f, 0.20350139f, -0.05203925f, -0.17004408f, -0.28913584f, -0.10500196f, -0.22703464f, -0.06722473f, 
    -0.03645913f, -0.12589440f, 0.07067780f, 0.08995055f, 0.01495317f, 0.01469626f, -0.00389571f, -0.00663692f, 
    -0.01702474f, -0.00336014f, -0.09845595f, -0.00688021f, -0.43750510f, 0.40451229f, 0.05007158f, 0.17167141f, 
    -0.15540439f, 0.01941174f, -0.13491192f, -0.16507529f, 0.05813732f, 0.01400384f, -0.17353190f, 0.29386643f, 
    0.08420569f, -0.23943536f, -0.02928044f, 0.15711829f, 0.01480483f, 0.12387166f, -0.14945574f, 0.03598068f, 
    -0.14277735f, -0.11278942f, 0.06446867f, -0.04982811f, -0.46221811f, 0.20819183f, 0.12758918f, -0.10794407f, 
    0.21396028f, 0.06507555f, -0.07603797f, 0.02569068f, -0.15406442f, 0.28505823f, -0.01493657f, 0.00432198f, 
    0.00309098f, 0.28952345f, 0.00669189f, 0.06436191f, -0.00790602f, 0.08929357f, -0.07346738f, 0.07356827f, 
    -0.24699615f, 0.10422076f, 0.01710183f, 0.01023117f, -0.11750629f, -0.03427840f, -0.17151381f, 0.02328479f, 
    0.04936661f, 0.00014032f, 0.04634622f, 0.18677330f, 0.08204448f, 0.08997131f, 0.05338019f, -0.19318281f, 
    0.15003274f, 0.31141201f, -0.11515894f, 0.23807214f, -0.15069848f, 0.04730242f, -0.37466729f, 0.14070830f, 
    0.05999611f, -0.10388310f, 0.10565992f, 0.23495425f, 0.19480854f, 0.35542706f, 0.46777749f, 0.10214113f, 
    -0.17076911f, -0.20039098f, -0.24578807f, -0.11297984f, -0.09533878f, -0.15068783f, 0.23988904f, 0.14026134f, 
    -0.33836219f, -0.38567451f, 0.14140216f, 0.45778555f, 0.03932084f, 0.15000768f, 0.17232732f, 0.00849272f, 
    -0.04207662f, -0.18645884f, 0.02496583f, -0.10631127f, -0.05179652f, -0.24507615f, -0.06034051f, 0.09323507f, 
    -0.01206347f, 0.05433032f, 0.15404655f, 0.00312145f, -0.02776926f, 0.05973725f, 0.24085616f, -0.01023234f, 
    -0.81818950f, 0.38288364f, 0.37859011f, -0.11111087f, -0.19056454f, -0.26850685f, -0.34750590f, -0.04401096f, 
    0.20020229f, 0.04057497f, 0.00390389f, 0.05770147f, 0.66562957f, -0.39101523f, -0.04858851f, 0.21661465f, 
    0.04862938f, -0.04280906f, -0.15735725f, 0.04328328f, -0.00636432f, 0.09667908f, 0.19091110f, 0.18939410f, 
    0.14546448f, -0.33132675f, -0.00961398f, -0.01755540f, 0.29472101f, 0.21756409f, 0.09120692f, 0.03912818f, 
    -0.06660698f, -0.00369704f, -0.18183351f, 0.04636277f, -0.22270240f, 0.03783960f, -0.11352058f, -0.25798827f, 
    -0.00381391f, 0.04645622f, -0.24220139f, -0.08159997f, -0.02928640f, -0.04401443f, 0.00651485f, 0.13695811f, 
    -0.01005351f, 0.06149984f, -0.21684462f, 0.18373385f, 0.03112628f, -0.00812869f, 0.02963410f, -0.11466511f, 
    -0.03056259f, -0.24761024f, -0.12582844f, -0.01680418f, 0.16164768f, -0.22931822f, 0.23011765f, -0.23455286f, 
    -0.30483785f, -0.09200575f, 0.06882311f, 0.02017594f, 0.13353316f, -0.16429590f, -0.02486674f, -0.03072980f, 
    0.25208220f, 0.35080299f, -0.69858646f, 0.32203797f, 0.08508758f, 0.20945181f, -0.20102714f, -0.24269783f, 
    -0.00949637f, -0.05181351f, -0.15774222f, -0.16174129f, -0.01726022f, -0.08707803f, 0.06052246f, 0.00644445f, 
    0.00963678f, -0.25964829f, 0.14211422f, 0.06168156f, 0.01966776f, -0.18339889f, -0.04971834f, -0.19259101f, 
    0.07174808f, 0.00300411f, 0.16256987f, 0.03756157f, -0.03458752f, -0.03450778f, -0.10107042f, -0.15910575f, 
    0.00362152f, 0.07097195f, -0.14385504f, 0.03814892f, 0.11047269f, -0.18951195f, -0.08871475f, 0.07128303f, 
    -0.05955856f, -0.01287903f, -0.02357700f, -0.05822135f, 0.27692261f, 0.26863340f, 0.10061301f, 0.39976808f, 
    0.16627511f, -0.09215419f, 0.56973547f, 0.03902147f, 0.00270449f, 0.16062437f, -0.00387814f, 0.12680323f, 
    0.08192249f, 0.02021089f, 0.01224650f, 0.00948363f, -0.02941742f, 0.20387824f, 0.28753993f, 0.14359415f, 
    -0.01524874f, -0.14896199f, 0.13136026f, 0.21717478f, 0.06530611f, 0.01916044f, 0.05933345f, -0.01654214f, 
    -0.06800660f, -0.61799622f, 0.05539757f, 0.03635378f, -0.32158032f, 0.04139010f, 0.01328054f, -0.17413141f, 
    -0.18156813f, -0.04453977f, -0.16359738f, -0.03602834f, 0.20433952f, 0.19681397f, 0.04841086f, 0.22174765f, 
    -0.05310267f, -0.18580262f, -0.02074195f, -0.11297057f, -0.10920966f, -0.05340789f, -0.12994340f, 0.04069806f, 
    0.04411840f, -0.43669000f, 0.00240432f, -0.04693343f, -0.05425880f, 0.06515778f, -0.03583368f, 0.00335172f, 
    0.09304662f, -0.00455566f, -0.21572587f, 0.08202454f, 0.09886747f, 0.01443995f, -0.02491906f, 0.08796716f, 
    0.01914936f, -0.02685310f, 0.02476196f, 0.08728888f, 0.01249983f, 0.10623827f, 0.00832348f, 0.06332582f, 
    0.08050273f, 0.18728589f, 0.03798098f, 0.04562192f, -0.05902043f, -0.06570714f, -0.00210600f, 0.01153731f, 
    -0.11907934f, 0.05651214f, -0.05371069f, -0.01534360f, 0.03066055f, 0.06132570f, 0.05207665f, 0.02025049f, 
    0.15597202f, 0.12672871f, 0.04763711f, 0.01737890f, 0.07542819f, -0.08819026f, -0.13012981f, -0.02506558f, 
    -0.31918332f, 0.03604459f, 0.16225515f, -0.05893156f, 0.12710670f, 0.04576163f, 0.01810668f, 0.10566895f, 
    -0.10181624f, 0.11339960f, 0.00833525f, 0.28598243f, -0.25245681f, -0.18817210f, -0.09506243f, -0.06112373f, 
    -0.08628730f, 0.12035846f, -0.11325978f, -0.21434528f, -0.12453528f, 0.00166881f, -0.02968260f, 0.07286394f, 
    0.16035715f, -0.02730760f, 0.07865537f, -0.01164405f, 0.01706643f, 0.24586728f, -0.23440278f, 0.08424833f, 
    0.05382293f, -0.03496399f, -0.18747394f, -0.15632960f, 0.06787967f, -0.38286766f, -0.10552305f, -0.01771380f, 
    -0.11488975f, 0.14044419f, -0.03633228f, 0.02028880f, -0.23954219f, -0.00568358f, -0.13539693f, 0.05915148f, 
    -0.09260231f, 0.02194651f, 0.02941891f, 0.14713615f, -0.06786864f, -0.14087051f, -0.01417464f, -0.14708777f, 
    -0.04062064f, -0.03069423f, 0.03580520f, 0.09134836f, 0.29182515f, -0.23499222f, 0.07985717f, 0.47293085f, 
    0.16449380f, -0.09473876f, 0.24473211f, 0.04867324f, -0.01285501f, 0.00677926f, 0.04192097f, -0.03584502f, 
    0.06624545f, 0.17774089f, 0.06026492f, 0.20023915f, -0.09494826f, -0.06385586f, 0.06186419f, 0.07975061f, 
    0.02251086f, -0.02536329f, 0.03615106f, 0.07411558f, 0.00449883f, -0.19687532f, -0.46033514f, -0.33846352f, 
    0.13246728f, 0.03912138f, 0.08641835f, 0.00377418f, -0.00884386f, -0.07547048f, -0.09935527f, -0.21843483f, 
    0.14970767f, -0.31448922f, 0.09372023f, -0.06621272f, -0.14499909f, -0.11128017f, 0.04811371f, -0.01100368f, 
    0.08371785f, 0.08214609f, -0.05519094f, 0.06295922f, 0.12001208f, 0.09021860f, 0.18415403f, 0.01894266f, 
    -0.06536126f, -0.01771276f, -0.35148326f, -0.23579122f, -0.17553990f, -0.30051523f, -0.15162206f, -0.17521247f, 
    -0.02989878f, 0.05963355f, 0.03157836f, 0.17927818f, -0.33009443f, -0.05046812f, 0.13392112f, -0.39245647f, 
    0.03503243f, -0.11136369f, 0.02700650f, 0.01155475f, -0.05632771f, 0.01455969f, -0.17220685f, 0.14084241f, 
    0.08442426f, -0.04245515f, 0.07168330f, 0.07613140f, 0.04517775f, -0.01013700f, -0.07576927f, -0.16953079f, 
    0.08933659f, 0.42082873f, 0.23904823f, 0.09381704f, 0.22895330f, 0.17984015f, 0.06354425f, 0.08789638f, 
    -0.04604472f, 0.06559800f, -0.06352457f, -0.08007827f, 0.09120134f, 0.22898710f, 0.34846699f, 0.21318322f, 
    -0.00058034f, -0.07273538f, -0.09278059f, 0.03979671f, 0.16084893f, 0.00808144f, 0.20168678f, 0.06071319f, 
    0.13695824f, -0.20855901f, -0.56652832f, 0.06601059f, 0.14527528f, -0.00900789f, 0.13657200f, -0.17760479f, 
    0.00631561f, 0.03072531f, 0.07915079f, 0.01280278f, -0.16380636f, -0.39346731f, 0.05894937f, 0.19624975f, 
    -0.06379289f, -0.14203832f, -0.32403135f, 0.02290727f, 0.02571908f, 0.04072692f, -0.13428171f, -0.02792203f, 
    0.18952246f, 0.12608711f, -0.11217782f, 0.03832692f, -0.09012341f, 0.00116248f, 0.00358940f, 0.11330539f, 
    0.17521718f, -0.31771570f, -0.14697015f, 0.11283122f, 0.07021724f, -0.12357939f, 0.09639825f, -0.04196237f, 
    0.04275624f, -0.14924587f, -0.18437988f, -0.17910652f, 0.04639935f, 0.10959475f, -0.07565007f, -0.02795712f, 
    -0.24155366f, -0.14288925f, 0.17557898f, -0.20306717f, -0.25410870f, 0.07430736f, -0.30912843f, -0.27906978f, 
    0.12998646f, -0.03328690f, -0.02832669f, -0.05712756f, 0.02332309f, 0.10137564f, -0.21580903f, 0.33802521f, 
    -0.29801705f, -0.16948761f, -0.24871318f, -0.15505183f, -0.02987822f, 0.06212235f, -0.04479232f, 0.11861464f, 
    -0.41038799f, 0.28944722f, -0.40582857f, -0.28770733f, 0.07172120f, 0.17560919f, -0.24445350f, 0.13516675f, 
    -0.04156657f, -0.13113151f, 0.09635098f, -0.06417248f, 0.10993789f, -0.24571775f, -0.12329175f, 0.06273736f, 
    -0.17189948f, 0.13128994f, 0.06937641f, -0.09898192f, 0.17906950f, -0.02929446f, 0.21515608f, 0.13327560f, 
    0.00858701f, 0.06808453f, -0.19717433f, 0.05725197f, -0.00286325f, 0.11673661f, 0.29009476f, 0.04142613f, 
    -0.01284248f, 0.22314826f, 0.00495493f, -0.02757856f, -0.44374368f, 0.00445801f, 0.15281975f, -0.10650510f, 
    0.02007570f, 0.00418648f, 0.05903823f, 0.14635563f, -0.01912691f, -0.21947269f, -0.22996268f, -0.40035021f, 
    0.33430293f, 0.15475403f, 0.43312600f, -0.21357289f, 0.17141356f, -0.06101093f, -0.07469936f, 0.34839076f, 
    0.09755243f, -0.01741173f, 0.01441783f, 0.04339208f, 0.10228521f, 0.12404743f, 0.02675687f, 0.05712127f, 
    0.29476964f, 0.20416051f, 0.20612846f, 0.05518548f, 0.08424628f, 0.05229385f, 0.09815284f, 0.08992054f, 
    -0.15930709f, -0.31979793f, 0.37254238f, 0.18784180f, 0.16614762f, 0.03844229f, -0.13206919f, -0.11985871f, 
    0.09468674f, -0.10447263f, 0.07858051f, -0.06140928f, -0.17400852f, -0.05666436f, -0.12794700f, -0.31284234f, 
    -0.03070568f, 0.23838681f, -0.02300319f, -0.03129804f, 0.13991913f, 0.17530987f, -0.00506399f, -0.01840570f, 
    -0.32219377f, 0.18426496f, 0.21769740f, -0.32407227f, 0.04255046f, -0.12757488f, -0.04044301f, 0.00668396f, 
    0.02957334f, -0.11702066f, -0.34272569f, -0.06530858f, -0.27322212f, -0.43887389f, -0.10710128f, -0.09962377f, 
    -0.03878117f, -0.05882859f, 0.02628269f, 0.19998881f, -0.19971706f, -0.15942559f, 0.06436666f, -0.18176515f, 
    0.00775258f, 0.00259179f, 0.25775704f, -0.08492941f, 0.12939717f, 0.02610855f, 0.05584548f, -0.04970759f, 
    0.24036750f, -0.07123756f, 0.08123205f, 0.05793349f, -0.15160568f, -0.13911772f, -0.06542700f, 0.07984257f, 
    0.09841163f, -0.02491710f, -0.07209795f, -0.02410982f, -0.08458540f, 0.06844024f, 0.01032284f, 0.17881843f, 
    -0.15937710f, -0.04943504f, -0.27372137f, -0.13212457f, -0.07766373f, -0.01478075f, 0.05542191f, 0.06859010f, 
    -0.18156926f, -0.20681474f, -0.36628667f, -0.27706721f, 0.18372062f, 0.26613706f, -0.01553491f, -0.04996177f, 
    -0.08296083f, -0.25696185f, 0.09463339f, -0.07068750f, 0.19871175f, 0.10042418f, -0.06661021f, 0.04518411f, 
    0.02759553f, 0.05097584f, 0.03499189f, -0.13559867f, -0.07004572f, 0.11905403f, -0.02398267f, -0.09967352f, 
    0.22524171f, 0.13085587f, 0.15704246f, -0.00494981f, 0.02915250f, -0.15313129f, 0.35610300f, -0.10369685f, 
    -0.26435441f, -0.20632891f, -0.15170717f, 0.07694387f, 0.11247533f, 0.02283974f, 0.03556656f, 0.00655284f, 
    -0.05722988f, 0.24730757f, 0.01369932f, 0.16331716f, 0.00150414f, 0.22413805f, 0.08863742f, -0.07316376f, 
    0.14148435f, 0.02628105f, 0.07152923f, -0.00356359f, -0.10098765f, -0.32454482f, 0.05401228f, -0.18978658f, 
    0.09912522f, -0.07039653f, -0.06790089f, 0.11527535f, 0.08496013f, -0.04845125f, -0.03400189f, -0.12855412f, 
    -0.14001404f, 0.13622348f, 0.13626398f, -0.25016907f, 0.04615559f, 0.00386449f, -0.00510495f, 0.15847723f, 
    0.09173688f, -0.03864947f, -0.10532109f, 0.10434058f, -0.09357867f, 0.05232033f, -0.53876835f, 0.01590605f, 
    -0.00057148f, -0.05205434f, -0.04019040f, 0.01633185f, 0.11563800f, -0.15130459f, 0.30325073f, 0.30956563f, 
    -0.04302791f, 0.39240193f, -0.36633301f, 0.12425931f, 0.13746639f, -0.01223498f, -0.15147585f, -0.06192327f, 
    0.27533683f, 0.16546084f, -0.09018961f, -0.14677005f, 0.22895722f, -0.04981437f, 0.28209418f, -0.13420278f, 
    0.16615309f, 0.09996193f, 0.10949929f, -0.09584346f, -0.08924163f, 0.06932095f, -0.13325825f, 0.02331478f, 
    0.09543458f, -0.21597493f, 0.05979078f, -0.11732826f, -0.01555390f, -0.12327956f, 0.19855574f, 0.34367284f, 
    -0.06427295f, 0.08887421f, 0.28228346f, -0.23598038f, 0.00178652f, -0.16482407f, -0.21970910f, 0.26888308f, 
    0.28297308f, 0.04173238f, -0.16376266f, 0.02287373f, 0.04767307f, 0.00623352f, 0.02218963f, 0.13071056f, 
    0.03332870f, 0.24090479f, -0.32116720f, -0.13860673f, 0.02122217f, -0.17319494f, -0.02547767f, -0.08380534f, 
    -0.04918643f, 0.01518394f, -0.05959154f, -0.07040234f, 0.10809824f, 0.25225973f, -0.02139564f, -0.11766809f, 
    0.04277809f, -0.00281054f, -0.05753890f, -0.34424290f, -0.04645237f, -0.01101034f, -0.20019875f, -0.17011523f, 
    -0.07835435f, -0.17243195f, -0.34063503f, 0.11037816f, 0.09436662f, 0.14087145f, 0.01642422f, 0.03182147f, 
    0.11950247f, -0.23194407f, 0.07677491f, -0.10690089f, -0.55804533f, 0.29793847f, -0.13939159f, -0.46904010f, 
    0.00339425f, -0.06081713f, 0.23227865f, -0.04442992f, -0.01349510f, -0.04827721f, -0.02242733f, 0.13829555f, 
    -0.94890577f, -0.82138938f, -0.05443061f, -0.21709058f, -0.02208155f, -0.08116176f, -0.15719421f, -0.04877473f, 
    0.04694095f, 0.04341179f, -0.00898221f, -0.07341592f, 0.04739628f, -0.10947473f, 0.15081768f, -0.26788178f, 
    -0.07358973f, 0.23857702f, 0.19177090f, -0.34115437f, 0.08242169f, -0.00439188f, 0.02295393f, 0.09830156f, 
    0.12210759f, -0.26044223f, 0.14176694f, 0.10156143f, 0.21978003f, 0.01800316f, -0.05496567f, 0.13946630f, 
    -0.12765998f, 0.04160188f, 0.17972270f, 0.16324484f, -0.20273107f, -0.52599186f, 0.22511935f, 0.49478552f, 
    0.18258759f, 0.02686414f, 0.07942553f, 0.12227175f, -0.07507958f, 0.08258662f, 0.02596848f, 0.04842853f, 
    0.18756212f, -0.11625853f, 0.20002580f, -0.27389586f, 0.26065752f, 0.15051648f, 0.02723646f, 0.20596726f, 
    0.04509677f, 0.08395028f, -0.02423771f, 0.10533281f, -0.08911254f, 0.02596631f, 0.06423647f, -0.09109882f, 
    0.09413795f, 0.05688866f, 0.16292599f, 0.00604585f, 0.00825315f, -0.07696425f, -0.07672827f, 0.09106608f, 
    -0.10897813f, -0.02251046f, 0.09985064f, 0.02819164f, 0.23981164f, -0.06787426f, 0.18871202f, -0.28769448f, 
    -0.06983358f, 0.05009627f, -0.05354788f, -0.08111874f, -0.00966103f, 0.02946289f, 0.10445452f, 0.01016802f, 
    -0.00442462f, 0.06011391f, 0.14294896f, 0.07263578f, 0.23856878f, 0.13911684f, 0.33290443f, 0.01168368f, 
    -0.82615250f, -0.89226747f, -0.62650168f, 0.31485185f, -0.01138051f, -0.09946634f, -0.11418591f, 0.02858184f, 
    0.04660497f, -0.00210900f, 0.06460146f, 0.11512200f, -0.61576080f, -0.71343839f, -0.46563312f, -0.40871727f, 
    -0.27249816f, -0.39578339f, -0.14150126f, -0.20303710f, 0.03618859f, -0.03852565f, 0.00173972f, -0.15736197f, 
    -0.01224497f, -0.26151380f, -0.14539610f, 0.35950607f, -0.14380884f, -0.10066678f, -0.06298518f, 0.17297871f, 
    -0.17146286f, 0.07585330f, 0.10706946f, 0.07924542f, -0.15960564f, 0.57593930f, 0.66345620f, 0.73481035f, 
    -0.01222549f, -0.11966630f, -0.06056163f, -0.13110688f, -0.11150733f, 0.07722497f, -0.05919795f, 0.10224166f, 
    -0.34488744f, 0.25603873f, 0.30921048f, -0.15645044f, 0.01978797f, -0.02866027f, -0.04907237f, 0.09947877f, 
    -0.08138955f, 0.16127095f, 0.07400992f, -0.14060615f, -0.31144318f, 0.44757989f, 0.20264059f, 0.08499289f, 
    -0.07751480f, 0.00746699f, -0.05187732f, 0.04491448f, 0.05860163f, 0.08580671f, -0.02841933f, -0.10673036f, 
    -0.32285917f, -0.54625314f, 0.33721906f, 0.01633263f, -0.12796897f, -0.22650634f, -0.11964981f, -0.40636933f, 
    -0.03436615f, 0.06287317f, -0.14047366f, -0.11623922f, 0.15110900f, 0.03583046f, -0.13384730f, -0.00415948f, 
    0.04438859f, -0.03512250f, -0.07568525f, 0.02198326f, -0.18464468f, -0.20137234f, -0.41169834f, -0.13267559f, 
    -0.07032885f, 0.17597626f, 0.26465058f, -0.13380092f, -0.03427752f, -0.02487145f, 0.03201181f, -0.06566112f, 
    0.00353247f, 0.06185808f, 0.12616299f, 0.07353880f, -0.74272782f, -0.52664274f, -0.13890046f, -0.16540577f, 
    -0.08811512f, 0.12075172f, -0.10896316f, 0.01307563f, 0.02149662f, -0.02011136f, 0.08137470f, 0.11190528f, 
    -0.07659440f, 0.06563913f, 0.01933797f, -0.13135910f, 0.02663414f, 0.11904768f, 0.12883346f, 0.06334088f, 
    -0.00648220f, -0.03567689f, -0.06039561f, -0.05250304f, 0.05090234f, -0.13074636f, 0.03576417f, 0.16051212f, 
    -0.03304110f, 0.02406374f, 0.04231391f, 0.09352747f, 0.11998441f, 0.05473747f, -0.21466687f, 0.37223798f, 
    -0.74933213f, -0.88297653f, -0.37995631f, -0.11908130f, -0.22135177f, -0.23051141f, 0.07116308f, -0.49301091f, 
    -0.02965488f, -0.04424309f, 0.10424297f, -0.13402890f, -0.18475255f, -0.45728627f, -0.16883945f, 0.34974417f, 
    0.14045773f, 0.21379155f, 0.01916434f, -0.03257580f, -0.03896548f, -0.05269615f, 0.02068586f, 0.08975172f, 
    -0.60523915f, -0.56355828f, -0.71242273f, -0.19395122f, -0.19011046f, -0.17462422f, 0.12657653f, -0.32847944f, 
    -0.05376376f, 0.04632911f, -0.01555715f, 0.06847242f, 0.08172645f, 0.07446102f, -0.13602138f, -0.23786132f, 
    0.05121358f, -0.00955509f, 0.02038865f, -0.02922981f, 0.04607204f, 0.07860979f, -0.00654653f, -0.28284457f, 
    -0.45265502f, -0.11476732f, 0.58224452f, -0.90476662f, 0.01531255f, 0.05839998f, -0.07136826f, -0.02163246f, 
    -0.06904808f, 0.17112873f, 0.23887031f, 0.21594936f, -0.04634133f, 0.54133821f, -0.56216413f, -0.35373870f, 
    -0.04301052f, -0.14098023f, -0.19818774f, 0.06287758f, -0.10034071f, 0.20977126f, -0.03867085f, 0.03766554f, 
    -0.03415609f, -0.09678335f, -0.16856964f, 0.08583959f, -0.08174959f, 0.22229494f, -0.00360170f, 0.01803663f, 
    0.13726790f, -0.12738501f, 0.15675820f, -0.01959205f, -0.00446427f, -0.00679513f, -0.12933487f, -0.67919642f, 
    -0.15806866f, 0.04920538f, 0.07883026f, -0.02775031f, -0.02590824f, 0.02541462f, -0.01540899f, -0.01415614f, 
    -0.11253176f, -0.37522444f, -0.03326778f, 0.05392333f, 0.23940088f, 0.13026118f, 0.10177928f, -0.19919659f, 
    0.11573926f, -0.14450122f, -0.10179964f, 0.13924085f, -0.73802096f, -0.52016068f, -0.09435158f, -0.45455289f, 
    -0.11942263f, 0.06751594f, -0.25093099f, -0.13113748f, -0.02797469f, -0.11632838f, 0.04983419f, 0.06523697f, 
    0.19080749f, 0.03448828f, 0.12775974f, -0.03241421f, 0.05016272f, 0.00441892f, -0.01342896f, -0.03196354f, 
    -0.01632041f, -0.01029071f, 0.01957523f, 0.02583251f, -0.58189446f, -1.19489920f, -0.04009575f, -0.30773771f, 
    0.00124873f, -0.20653866f, -0.16667958f, -0.02039968f, 0.04591198f, 0.07231963f, -0.03577498f, -0.02581969f, 
    -0.77146858f, 0.50777769f, 0.36963922f, -0.00073756f, -0.04847661f, -0.14503890f, -0.13011439f, 0.06777328f, 
    -0.12634832f, 0.04318346f, 0.08250555f, 0.22823222f, -0.28512508f, -0.15815686f, 0.14325026f, 0.06882489f, 
    0.07030593f, -0.19323529f, -0.30688405f, 0.04648514f, -0.05521935f, -0.08628717f, -0.00257311f, -0.02266376f, 
    -0.19911958f, 0.80973637f, -0.01095408f, 0.23754396f, -0.23611844f, -0.05028902f, 0.02512043f, 0.14634472f, 
    0.10532889f, 0.02448175f, -0.02949551f, -0.03088107f, 0.12615006f, -0.28626072f, -0.41273698f, 0.23269041f, 
    -0.12726973f, 0.23694848f, 0.22404432f, 0.00591155f, -0.01568638f, -0.14211859f, 0.07549396f, 0.07506800f, 
    -0.29457554f, 0.39905891f, -0.21780309f, 0.10950927f, -0.27997097f, -0.03343580f, -0.02802863f, 0.01907237f, 
    -0.01232495f, 0.02317933f, 0.07210138f, -0.00377927f, 0.10689203f, 0.01413882f, -0.01709832f, -0.07042956f, 
    -0.17564102f, -0.04746502f, 0.18187292f, -0.03726340f, -0.00574431f, 0.01206253f, 0.00455065f, -0.07880593f, 
    0.03468352f, 0.04493796f, -0.03381640f, -0.00576694f, -0.20417716f, -0.14286007f, -0.27756789f, 0.05929176f, 
    0.04762201f, -0.01677299f, 0.02770951f, 0.04614220f, 0.26224935f, 0.02826876f, 0.07000025f, -0.06150709f, 
    0.01855782f, -0.06223382f, 0.01047244f, -0.07808067f, -0.01193524f, 0.00182215f, 0.05626307f, 0.02413866f, 
    -0.18843448f, -0.30600539f, 0.33644146f, -0.06357694f, 0.31651258f, -0.15600780f, -0.05059281f, -0.03965864f, 
    0.07116453f, -0.01001101f, -0.04419763f, 0.12183452f, -0.30753377f, -0.37566584f, -0.37931526f, 0.50421113f, 
    0.09001249f, -0.03277737f, 0.10560705f, -0.14372459f, 0.08304984f, 0.04333316f, -0.02011720f, -0.02657668f, 
    0.74882311f, -0.51620024f, 0.03162603f, -0.57936895f, -0.01808019f, -0.13966042f, 0.04127961f, 0.04949316f, 
    -0.09009568f, 0.13587114f, 0.00301418f, -0.28061321f, -0.82390946f, -0.68013805f, -0.94368297f, -0.54896188f, 
    -0.13261123f, -0.25771782f, 0.05714487f, -0.01826827f, -0.12652418f, 0.01356416f, 0.01876791f, 0.12912855f, 
    0.29162914f, -0.35581207f, 0.08795395f, -0.28192356f, 0.03021923f, -0.04881471f, 0.05487863f, -0.04675944f, 
    0.02063644f, 0.07828752f, 0.15379691f, -0.09917709f, 0.65843606f, -0.59935015f, -0.22994763f, -0.18505540f, 
    0.00172217f, -0.05612522f, 0.00258440f, 0.02608159f, 0.28297281f, 0.11546774f, -0.07134164f, -0.10564966f, 
    -0.00425642f, -0.04080571f, 0.33156988f, 0.08325476f, -0.08023775f, -0.14070879f, 0.04503927f, 0.02088413f, 
    0.02983465f, 0.01812922f, -0.06359052f, 0.06335181f, 0.04257509f, 0.00806861f, 0.01949292f, -0.02201026f, 
    -0.00786133f, -0.01114914f, 0.01087508f, -0.02432520f, -0.00297666f, -0.08880783f, -0.00124776f, -0.10005391f, 
    0.00384894f, 0.09751092f, 0.08773571f, 0.12085904f, 0.12050045f, 0.07462259f, 0.02910757f, -0.08819056f, 
    -0.04315648f, 0.15077199f, 0.13171887f, 0.07272054f, -0.32998884f, -0.02671626f, 0.00739569f, 0.05135095f, 
    0.01515257f, -0.13323769f, -0.02644822f, -0.01534526f, -0.03373039f, -0.10864443f, 0.01111857f, 0.12003294f, 
    -0.06354976f, -0.02495204f, 0.10251598f, -0.16804770f, -0.26122066f, -0.06226722f, 0.02741916f, -0.00238460f, 
    -0.04648636f, 0.07891224f, -0.03142237f, 0.01191745f, 0.32614151f, 0.07246327f, 0.15241133f, -0.38743633f, 
    0.05016087f, 0.10354043f, -0.07671925f, -0.06090463f, -0.16350761f, 0.04287460f, -0.03805964f, -0.26545039f, 
    -0.06853432f, -0.38457674f, -0.09301437f, 0.58690423f, -0.20060624f, -0.15263580f, -0.05623386f, 0.21868499f, 
    -0.05097635f, -0.00365909f, -0.15879871f, 0.02871467f, -0.02630304f, 0.20181592f, 0.07034706f, -0.18484488f, 
    -0.04880496f, -0.03290858f, -0.11857099f, 0.11186961f, 0.02079732f, 0.08727831f, 0.08270700f, -0.07322619f, 
    -0.24269162f, -0.19012479f, 0.18572594f, 0.31081903f, -0.07968057f, -0.24080165f, 0.18140189f, 0.02764275f, 
    -0.02626849f, -0.12408022f, -0.03615311f, -0.07785736f, -0.04338787f, 0.04727291f, 0.12950155f, -0.09849110f, 
    0.00599484f, 0.01148110f, -0.01106082f, -0.02868075f, 0.07488408f, -0.00182843f, -0.10039809f, -0.23903333f, 
    0.37470698f, 0.71745592f, -0.54167610f, -0.19301331f, 0.03421161f, -0.06265680f, -0.05318331f, 0.04941439f, 
    0.17617378f, 0.26334399f, -0.13606352f, -0.04448322f, -0.19487932f, -0.24557540f, -0.55700666f, 0.28742078f, 
    0.02404314f, -0.16497529f, 0.05129398f, -0.03884062f, -0.07992767f, -0.09718116f, -0.00508130f, 0.06014892f, 
    0.11107583f, -0.07020452f, 0.07997988f, -0.05075032f, -0.09419858f, 0.13285181f, 0.03863732f, -0.48642689f, 
    -0.08264567f, -0.14097121f, 0.13386969f, 0.08724810f, -0.13980472f, 0.31178665f, -0.25109115f, 0.15143965f, 
    -0.05912639f, 0.05866943f, -0.00420388f, -0.03669096f, 0.03866692f, -0.02166728f, 0.02659016f, -0.06963982f, 
    -0.90114731f, 0.60510707f, 0.41782600f, -0.15754607f, 0.13255195f, -0.07312550f, 0.01496251f, 0.25079703f, 
    -0.11749240f, 0.01629169f, 0.07129943f, -0.06587838f, -0.43207017f, 0.43573394f, -0.28754824f, 0.66667461f, 
    0.29345950f, -0.10916609f, 0.12343202f, -0.01334723f, -0.05248586f, 0.02024065f, 0.05717780f, 0.00352997f, 
    -0.12652777f, 0.23996972f, 0.05819981f, -0.03161736f, 0.00148780f, -0.00880115f, -0.02282684f, 0.01725708f, 
    0.08817849f, -0.03233540f, 0.07633888f, -0.07407182f, 0.12585975f, -0.20387827f, -0.54454684f, -0.43796340f, 
    0.17293268f, 0.02199501f, 0.18908268f, 0.23142979f, 0.03798202f, -0.08001506f, -0.06129367f, 0.11887331f, 
    0.72695863f, -0.28023258f, -0.24379727f, -0.43817645f, -0.02281593f, 0.00383180f, -0.07210263f, -0.01333798f, 
    -0.01038510f, -0.03140719f, 0.09148820f, 0.03502492f, 0.24786761f, -0.14089365f, 0.29842231f, -0.12862149f, 
    -0.38094956f, 0.08409227f, -0.23887488f, 0.18279840f, -0.00441181f, 0.07459154f, -0.00675742f, -0.04510071f, 
    -0.63335854f, 0.44725254f, -0.64297479f, -0.44310465f, -0.05181053f, -0.41618618f, 0.14151011f, -0.06407551f, 
    0.00202624f, 0.05504365f, -0.05470749f, -0.03515484f, 0.15934643f, -0.11988404f, -0.09369734f, -0.10801217f, 
    -0.03949439f, -0.06909414f, -0.16116622f, -0.12030138f, -0.00549940f, 0.12862779f, 0.00320915f, -0.01428841f, 
    -0.55317587f, 0.06278563f, 0.09963714f, 0.21288098f, 0.11993542f, -0.09708136f, -0.13933091f, 0.27906632f, 
    -0.00954673f, -0.07656930f, -0.08720594f, -0.11016096f, -0.14635666f, 0.03542224f, -0.01429223f, -0.01074051f, 
    0.17934866f, -0.02040005f, 0.10078832f, -0.05352612f, 0.05320496f, 0.16554296f, 0.03444148f, 0.26185468f, 
    -0.03998437f, -0.05760185f, 0.00843603f, -0.02099046f, 0.14298613f, 0.05444897f, 0.06969085f, 0.16450547f, 
    0.00807563f, -0.02022900f, 0.09006426f, 0.07586046f, -0.02872982f, -0.09355489f, -0.10632108f, -0.14106843f, 
    0.09153891f, 0.02942754f, 0.06723009f, 0.08358198f, -0.21681046f, 0.03816638f, -0.25154945f, -0.55506372f, 
    0.64051259f, -0.02722915f, 0.18264371f, -0.02089185f, -0.11256272f, -0.04376310f, -0.11493663f, -0.45111632f, 
    0.03580685f, 0.02296036f, -0.05699092f, -0.04055507f, -0.57693362f, -0.62439662f, -0.36397099f, -0.00403744f, 
    -0.04409831f, 0.03091355f, -0.19673324f, -0.12098198f, -0.09538411f, 0.04406589f, -0.02446768f, 0.11986194f, 
    0.58777386f, 0.18035911f, -0.77072185f, -0.50546455f, 0.29663917f, -0.19925693f, 0.01178692f, -0.07545257f, 
    0.25467256f, 0.19166383f, 0.28364211f, 0.36929694f, 0.02668595f, -0.66799647f, 0.07318440f, 0.64660203f, 
    -0.15395063f, 0.24542218f, 0.12857582f, 0.05684075f, -0.08145081f, -0.09275679f, 0.35553724f, -0.02079139f, 
    0.03785306f, -0.20063499f, -0.20255359f, -0.24116898f, -0.12377200f, -0.07579763f, -0.04884184f, -0.03118929f, 
    0.02852900f, -0.11221118f, 0.00809141f, -0.08991667f, -0.09253024f, -0.15167715f, -0.07507609f, -0.05563197f, 
    -0.00109007f, 0.15370674f, 0.01974127f, 0.04788961f, -0.18754822f, -0.12916902f, -0.16733252f, -0.34560415f, 
    0.34835544f, -0.38800755f, -0.29123917f, 0.11746706f, -0.15440740f, -0.14463675f, -0.03325067f, -0.07761478f, 
    0.18528362f, 0.18657108f, 0.13453536f, 0.01275325f, -0.16266705f, -0.01289857f, -0.07822572f, -0.13681400f, 
    -0.09504161f, 0.00225358f, 0.00412822f, -0.00700103f, 0.13382944f, -0.00215475f, 0.12272200f, 0.13564327f, 
    -0.46528760f, -0.27955541f, 0.17378546f, 0.02512447f, -0.13035977f, -0.07083253f, -0.08871827f, -0.20247115f, 
    0.03567460f, 0.00686844f, -0.24255334f, -0.27945471f, 0.32638308f, -0.41282776f, -0.10714428f, 0.21123056f, 
    0.14046158f, 0.07010248f, 0.01148839f, 0.14084291f, 0.08539594f, 0.12578554f, 0.03907114f, -0.00629004f, 
    0.18494524f, -0.07510800f, 0.12481360f, 0.05794119f, 0.14782970f, -0.16918224f, -0.17829695f, 0.14026316f, 
    0.18816857f, 0.17804955f, 0.03483164f, 0.13219890f, 0.24215068f, 0.01937845f, -0.03587791f, -0.13385592f, 
    0.06084113f, -0.08302277f, 0.12614447f, -0.06501202f, 0.12750597f, 0.00206934f, 0.15526058f, 0.30232108f, 
    -0.30478260f, -0.24199758f, -0.55137825f, -0.58901930f, -0.07591550f, -0.09282485f, 0.00087952f, -0.04328909f, 
    0.14918722f, 0.01863541f, 0.04121285f, 0.06304908f, -0.14435647f, 0.05942730f, 0.14215750f, -0.03286744f, 
    -0.24559413f, -0.14209950f, 0.10648872f, -0.11210489f, -0.04779272f, 0.08569444f, -0.08542580f, 0.00748809f, 
    -0.06105440f, -0.22177039f, -0.29203752f, -0.37086806f, 0.04187178f, -0.31629291f, -0.09222612f, 0.02510608f, 
    0.07511777f, -0.01218062f, -0.03024868f, -0.01969500f, -0.63376600f, 0.10955374f, 0.19852549f, -0.10301045f, 
    -0.13802125f, -0.04370915f, -0.07395225f, -0.10088100f, 0.01166483f, 0.06327382f, 0.02156976f, 0.04881412f, 
    -0.03697071f, -0.50094551f, -0.69520676f, -0.58116150f, -0.09190891f, 0.22528847f, 0.10266211f, 0.18561865f, 
    0.21221726f, -0.15252320f, -0.08397030f, -0.19278517f, 0.46551540f, -0.58260232f, -0.23935412f, 0.20672539f, 
    0.13489226f, -0.08260268f, 0.24516091f, -0.08816420f, 0.05254810f, 0.15735710f, 0.12274014f, 0.09805100f, 
    -0.28119147f, -0.05422697f, 0.02594022f, -0.15268867f, 0.13357654f, 0.19129360f, 0.13541470f, -0.07294609f, 
    -0.23345104f, 0.01116069f, -0.18778370f, -0.06035668f, -0.41537657f, 0.12574573f, -0.01715156f, 0.32928014f, 
    0.01080598f, -0.14116049f, -0.10799909f, 0.08022107f, 0.11242392f, 0.06473766f, 0.12430292f, 0.13450432f, 
    -0.41150668f, -0.14042124f, 0.30298033f, 0.09235004f, 0.30097044f, 0.12762393f, -0.13876753f, -0.38664001f, 
    0.06762540f, -0.08395516f, 0.06207182f, 0.05340093f, -0.22242557f, -0.57754785f, -0.64340544f, -0.55616039f, 
    -0.14973857f, 0.04259791f, -0.00941556f, -0.05955096f, -0.04526056f, 0.12794881f, -0.08018893f, -0.09857725f, 
    -0.54083878f, -0.00998477f, 0.04151003f, 0.00171506f, -0.05592493f, -0.09325287f, -0.04982951f, 0.01917026f, 
    -0.18456818f, 0.02922091f, -0.21506466f, -0.00777775f, 0.43174988f, -0.39638299f, -0.55283606f, 0.11290284f, 
    -0.12686582f, 0.07152754f, 0.10142882f, -0.00607003f, -0.04773176f, 0.04471527f, 0.04474568f, 0.01020393f, 
    -0.34795582f, -0.52179962f, -0.41186297f, -0.06829932f, -0.07415730f, 0.05747471f, 0.10807388f, 0.10934030f, 
    0.20628604f, 0.16980922f, 0.05134357f, 0.03174433f, 0.17978914f, -0.02738064f, -0.09582530f, -0.15791340f, 
    0.05862444f, -0.21198754f, 0.16286233f, 0.09633696f, 0.08704580f, 0.10479498f, -0.00711315f, 0.11229312f, 
    0.53318059f, -0.53851378f, -0.09913710f, 0.30418074f, 0.04899701f, 0.05965708f, 0.26584166f, 0.09143054f, 
    0.06748975f, -0.05339776f, 0.08546463f, 0.06581919f, 0.03052142f, 0.06000742f, 0.38013801f, -0.11026716f, 
    0.10223117f, 0.04124731f, -0.07601248f, 0.05643881f, -0.07645576f, -0.08759651f, 0.01631813f, -0.18179099f, 
    -0.52011377f, 0.12351550f, -0.43727359f, 0.11433985f, 0.10563768f, -0.09576217f, 0.17564674f, -0.00390496f, 
    -0.08812180f, -0.05125297f, -0.06309207f, -0.16112466f, -0.06881019f, -0.23634170f, -0.13922550f, -0.17789590f, 
    0.27244514f, -0.30876759f, 0.05934453f, 0.03179294f, 0.06028897f, -0.22368219f, -0.13930701f, -0.11052631f, 
    -0.11991053f, -0.17260446f, -0.03059050f, -0.06179449f, -0.03001662f, 0.24670100f, -0.15270746f, 0.06993598f, 
    0.26535839f, -0.24368946f, -0.06834263f, 0.04194988f, -0.13312225f, 0.03013223f, 0.23408490f, 0.19534880f, 
    -0.01897125f, 0.10335702f, -0.13920721f, -0.24514584f, 0.12951563f, 0.07930966f, 0.04958434f, 0.19372141f, 
    0.21488822f, -1.09576559f, -0.09571782f, -0.32633090f, 0.22678784f, -0.13265954f, 0.13543832f, -0.10697514f, 
    -0.00111892f, 0.08929206f, -0.00267820f, -0.06840358f, -0.20311481f, 0.13134575f, -0.08748025f, -0.46969181f, 
    0.10136794f, -0.17925636f, 0.17674072f, 0.11418759f, 0.07112488f, -0.01816356f, 0.05119421f, 0.01301950f, 
    0.00079672f, 0.05263248f, 0.02277027f, 0.27045831f, -0.06520155f, 0.04938461f, -0.06191580f, 0.02049280f, 
    0.19635276f, -0.08502353f, -0.00585135f, -0.15968476f, 0.14443202f, 0.21783580f, 0.56282198f, -1.41472447f, 
    -0.04410144f, -0.30067554f, -0.06033497f, 0.04264286f, -0.15801783f, -0.09622083f, 0.09066241f, 0.10096923f, 
    0.31596607f, -0.14114165f, 0.23583697f, 0.66742498f, 0.12157446f, 0.07908710f, -0.30735135f, -0.21149369f, 
    0.16581444f, -0.01363644f, 0.11700130f, 0.05028846f, 0.14525500f, 0.02642382f, 0.48297819f, 0.12527840f, 
    -0.00514654f, -0.21480045f, -0.01598503f, -0.18736975f, -0.01404934f, 0.04255899f, 0.05868083f, 0.12417950f, 
    0.21464974f, -0.24521983f, -0.13511036f, 0.10053200f, -0.11218961f, 0.14431137f, -0.10044930f, 0.15042982f, 
    0.00119077f, 0.05716490f, -0.12927993f, -0.13025071f, -0.11735856f, -0.14248314f, -0.06773302f, -0.03972550f, 
    0.14433780f, 0.12481955f, 0.10543686f, 0.01317650f, 0.11912916f, 0.04976079f, 0.15603536f, -0.04993700f, 
    0.16841085f, -0.11116847f, -0.10167179f, 0.08522074f, 0.14594677f, -0.07827425f, 0.12223033f, 0.08935834f, 
    0.11787431f, 0.24302910f, 0.00352976f, 0.25256795f, 0.23763473f, -0.35694420f, 0.15874738f, -0.03482546f, 
    -0.07035831f, -0.14637320f, -0.07464379f, -0.14107813f, 0.03977530f, 0.00753104f, 0.04696463f, -0.04111130f, 
    0.08929690f, -0.39416435f, -0.15143302f, -0.00111163f, -0.02270946f, 0.09159315f, -0.12904443f, 0.18684411f, 
    -0.00087432f, -0.08319578f, -0.14308466f, -0.21581958f, -0.05996447f, -0.74445015f, 0.17721401f, 0.07442363f, 
    -0.07870621f, 0.27666575f, -0.25596169f, -0.15217201f, -0.37884402f, -0.04762278f, -0.08421304f, 0.04010740f, 
    -0.54604566f, 0.25051171f, 0.01034998f, -0.05578064f, 0.04326890f, -0.10498939f, -0.09873914f, 0.23780181f, 
    0.04124960f, 0.13639148f, 0.19607528f, -0.06876708f, 0.16849460f, -0.71587652f, 0.26481417f, -0.08259901f, 
    0.05330651f, 0.28708124f, 0.08949088f, 0.00492952f, 0.08230710f, 0.07675652f, 0.02094893f, -0.01390957f, 
    -0.32078621f, 0.17684858f, 0.13668898f, -0.03403185f, -0.26225907f, -0.05215519f, 0.07387514f, 0.04262770f, 
    0.06112089f, 0.09596261f, 0.10071649f, -0.00718967f, -0.13645782f, -0.09362716f, 0.05340838f, -0.07225882f, 
    -0.04307478f, 0.14497019f, 0.01889100f, 0.02570435f, 0.08183563f, 0.15088764f, 0.16941163f, -0.18471073f, 
    -0.54081744f, 0.47192004f, -0.35729668f, 0.78375053f, 0.09995832f, -0.08063325f, -0.19783042f, 0.02619083f, 
    0.02021628f, -0.14226647f, 0.11252301f, 0.11008502f, -0.81961787f, 0.13183942f, 0.19491267f, 0.23981386f, 
    -0.00132632f, -0.57225591f, 0.06255203f, -0.07402645f, 0.11429562f, -0.16607128f, -0.09507310f, -0.14368422f, 
    0.22424001f, -0.33728540f, -0.24825743f, -0.13071559f, 0.07496851f, 0.20519777f, -0.00150393f, -0.00246775f, 
    0.08389775f, 0.12682755f, -0.02120341f, -0.07180212f, -0.45045587f, -0.08504170f, -0.32683167f, 0.28111935f, 
    0.04355210f, -0.12281605f, 0.16627122f, 0.02018277f, 0.01104583f, -0.15311874f, -0.03785355f, -0.07956161f, 
    0.39185452f, -0.03258470f, -0.10539623f, -0.19785254f, -0.17256258f, 0.13179438f, 0.15556672f, 0.11405174f, 
    -0.01507401f, 0.10304169f, -0.04560279f, -0.02305123f, -0.56098032f, 0.43602771f, 0.21527369f, -0.34756994f, 
    -0.14410120f, -0.12798800f, 0.25586402f, 0.17839721f, 0.07132071f, -0.00393246f, 0.10944719f, 0.12510429f, 
    0.08936320f, -0.23338023f, 0.01738636f, -0.16869910f, 0.05879135f, 0.24126700f, 0.14553429f, 0.06103934f, 
    0.20173188f, 0.09300652f, 0.00878012f, 0.03946348f, -0.40267617f, -0.03654976f, 0.00966598f, -0.22958779f, 
    -0.13173980f, 0.02609930f, -0.13296509f, -0.19480859f, 0.07343532f, 0.01954989f, 0.02861685f, -0.02188802f, 
    0.29744905f, 0.24499586f, 0.35326329f, 0.16117366f, -0.06452759f, -0.14073274f, -0.21456535f, -0.20957351f, 
    -0.03935048f, -0.18787642f, 0.04958820f, 0.09161884f, 0.02742745f, -0.24548469f, 0.19648515f, -0.09225921f, 
    0.11131771f, -0.18494315f, -0.13022864f, -0.02688930f, 0.00769585f, -0.11503918f, -0.13887873f, -0.06522372f, 
    -0.08411326f, -0.53449881f, 0.04411770f, -0.60154271f, 0.31546706f, -0.41335097f, 0.18308823f, 0.12932456f, 
    -0.27765080f, 0.04476645f, -0.02327803f, 0.16252688f, 0.16284703f, -0.32397282f, -0.52832425f, -0.06328408f, 
    0.06142123f, 0.20096514f, 0.13917139f, -0.04405453f, 0.03420628f, -0.12029725f, -0.10293863f, -0.00580633f, 
    0.39085931f, -0.68154848f, 0.35518920f, 0.26156238f, -0.29698622f, 0.00514605f, 0.18098314f, -0.03888726f, 
    -0.14230980f, 0.02587397f, -0.18554729f, 0.01629334f, -0.19302216f, 0.38295740f, -0.00334219f, -0.08468794f, 
    -0.24954119f, 0.11821453f, 0.20516713f, -0.04030608f, 0.09898712f, 0.12727226f, 0.37175295f, 0.33589908f, 
    -0.24456507f, 0.24871659f, 0.10573740f, 0.18989117f, 0.02404371f, 0.10477698f, -0.15883741f, -0.04842691f, 
    -0.45372909f, 0.22430716f, 0.02242926f, -0.18152152f, 0.12482024f, -0.00147262f, -0.05075853f, -0.14287086f, 
    0.04470084f, 0.02758419f, -0.05688750f, 0.09745508f, -0.37107435f, -0.04732018f, -0.29128215f, -0.55502933f, 
    -0.48526806f, 0.01589536f, -0.34358591f, 0.08553110f, -0.03655548f, 0.39111531f, -0.08278168f, 0.27706307f, 
    -0.01006693f, -0.00932720f, 0.09442728f, -0.12016816f, 0.03168342f, -0.35461417f, -0.04703407f, 0.24646908f, 
    -0.08198977f, -0.27493027f, 0.03470387f, -0.00944469f, 0.13203160f, -0.03477407f, 0.09475846f, 0.32054281f, 
    -0.62379372f, 0.10413360f, 0.55543387f, 0.46031952f, -0.25400031f, 0.17100589f, -0.02154657f, 0.19435197f, 
    -0.04305704f, -0.13966069f, 0.10525869f, -0.01871169f, 0.18230009f, -0.08294630f, 0.42500031f, -0.01550602f, 
    0.00355849f, -0.02015126f, -0.24643514f, 0.16698261f, 0.08035487f, 0.03859467f, 0.04934072f, -0.37818521f, 
    -0.58413243f, 0.23012029f, -0.07432136f, 0.04377416f, -0.00025538f, -0.05443609f, -0.12836692f, -0.06977047f, 
    -0.24852920f, 0.09400383f, 0.00319846f, 0.09155076f, -0.26521918f, -0.07874007f, -0.09542061f, -0.23161028f, 
    -0.02786095f, -0.07927702f, -0.12784387f, 0.04063653f, -0.02469947f, -0.31633160f, -0.38552484f, -0.41016158f, 
    -0.28251657f, -0.26742247f, 0.14073689f, 0.09644690f, -0.11371372f, 0.08111732f, 0.03314980f, -0.05326726f, 
    -0.00260740f, 0.00648900f, 0.19606127f, 0.15759152f, -0.25877237f, -0.12241229f, -0.08400129f, -0.45823178f, 
    -0.13699165f, -0.14325567f, -0.01996741f, -0.00777459f, -0.08098583f, 0.11903476f, 0.04348657f, 0.03663680f, 
    -0.16896649f, -0.11752726f, 0.27926672f, 0.13805859f, -0.08651768f, -0.03664146f, -0.21346192f, -0.21011512f, 
    0.07166328f, -0.00634154f, -0.15367831f, -0.12573616f, -0.08919208f, -0.01085731f, 0.00403127f, 0.20506313f, 
    -0.12812917f, 0.06172971f, 0.08412891f, -0.00274731f, 0.12460274f, 0.09808773f, -0.21074261f, 0.09811367f, 
    -0.17937540f, 0.48752305f, 0.05502542f, 0.27772164f, 0.05253501f, 0.16100228f, 0.13482453f, 0.38678738f, 
    -0.10209539f, 0.32003567f, 0.15869670f, 0.18468951f, -0.55134135f, 0.19950806f, 0.04827663f, -0.13521421f, 
    -0.03881215f, 0.16528286f, -0.24271721f, 0.02927739f, 0.13905379f, 0.06078386f, -0.04989157f, 0.08145276f, 
    -0.10280895f, -0.49748746f, -0.30542585f, 0.00334228f, -0.20604353f, 0.00615160f, -0.07331995f, -0.02611093f, 
    -0.00518938f, 0.01069354f, 0.06062050f, -0.04859442f, -0.22058569f, -0.37810320f, -0.32475796f, 0.14696258f, 
    -0.25675109f, -0.16055338f, -0.06064718f, 0.13215443f, 0.19555813f, 0.05847842f, -0.04531483f, 0.01206186f, 
    -0.04155118f, -0.08764282f, -0.54870820f, -0.00136763f, -0.25152782f, 0.20694377f, 0.04112510f, 0.16364001f, 
    0.08206264f, 0.18432727f, -0.04465200f, 0.00622974f, -0.21466383f, -0.05339583f, 0.03683015f, -0.11379682f, 
    -0.17436959f, -0.20527042f, -0.04964167f, -0.03783679f, -0.04015648f, -0.28200591f, 0.12744109f, 0.05796190f, 
    0.51992583f, 0.59972697f, 0.10457209f, -0.30739826f, 0.10426443f, 0.00647446f, -0.24647184f, 0.11465598f, 
    -0.01640305f, 0.02012213f, -0.18080172f, -0.05896608f, -0.52651304f, -0.05706778f, 0.20940244f, 0.10540241f, 
    -0.12303075f, 0.29297382f, 0.04619258f, 0.13241769f, -0.00919284f, -0.23708649f, 0.07174231f, 0.00429632f, 
    0.03341896f, 0.02165684f, 0.13088158f, -0.13573283f, -0.04386856f, 0.03445769f, -0.21294163f, -0.06240587f, 
    -0.28346327f, 0.06188537f, -0.12261000f, -0.07104858f, 0.06683601f, -0.27156934f, 0.13815972f, -0.19867323f, 
    -0.18791883f, 0.07910549f, 0.09125875f, -0.02509475f, -0.03962067f, 0.04956212f, 0.00732471f, 0.28977433f, 
    -0.05412955f, -0.01653531f, -0.22260450f, 0.15721296f, -0.16387604f, -0.12435620f, -0.30386335f, 0.08806414f, 
    0.16385415f, -0.04782655f, -0.02689044f, -0.15274945f, 0.04379734f, -0.74562448f, -0.08910653f, 0.24183816f, 
    0.03470434f, 0.06492905f, 0.04221544f, 0.07269298f, 0.12274386f, -0.05291874f, -0.14646058f, -0.03495380f, 
    -0.01338196f, -0.10668667f, 0.14189222f, 0.30342653f, -0.16414635f, -0.07241695f, -0.03254529f, 0.05661967f, 
    -0.10093340f, 0.09109410f, 0.00928849f, -0.11178666f, 0.43612641f, -0.48683727f, 0.07359228f, -0.05926454f, 
    -0.19268744f, 0.26220217f, -0.04733686f, 0.18632732f, -0.10812175f, 0.09371120f, -0.05142687f, -0.20333175f, 
    -0.06910166f, 0.20112219f, -0.07705688f, -0.22817229f, 0.13355108f, -0.13011092f, -0.06584104f, -0.06440078f, 
    -0.20252222f, 0.31066191f, 0.02485033f, -0.23493327f, -0.22558981f, 0.27744514f, -0.66695142f, 0.32170996f, 
    -0.10855301f, 0.12857133f, 0.23812151f, 0.11542197f, -0.20264310f, 0.07029563f, 0.07446998f, 0.07015490f, 
    -0.26203761f, -0.11213082f, 0.39947242f, 0.42182538f, 0.08468034f, 0.09139198f, 0.10423459f, 0.32159412f, 
    0.12832166f, 0.04969452f, 0.19866057f, 0.11135228f, -0.15113734f, -0.17378235f, 0.00831118f, -0.19249344f, 
    -0.22774985f, -0.07176600f, -0.04881272f, -0.19816405f, -0.00516943f, 0.08815724f, -0.08665005f, -0.07586547f, 
    0.43680137f, -0.15638334f, 0.59514576f, -0.33278060f, -0.13694270f, 0.22173083f, -0.09231629f, 0.23890100f, 
    -0.04484067f, -0.02809430f, 0.15582025f, 0.03836107f, 0.34993717f, 0.07246612f, 0.05963279f, 0.04079360f, 
    -0.08719983f, 0.14928809f, -0.27986333f, 0.00891121f, -0.10206897f, -0.00762779f, -0.11573813f, -0.28739366f, 
    -0.23563035f, 0.05405287f, -0.02718476f, 0.18095879f, -0.01204785f, -0.01589382f, 0.24118078f, 0.02984774f, 
    -0.02874672f, -0.22311878f, -0.17379591f, 0.07139389f, -0.09535126f, -0.04794317f, -0.13300513f, -0.11087458f, 
    0.02241905f, -0.06523744f, 0.10906963f, 0.02228400f, 0.16182236f, 0.12488714f, 0.22810748f, 0.23436043f, 
    0.23597343f, 0.15707599f, 0.17725813f, 0.00582036f, -0.38878185f, 0.08549327f, -0.07036068f, -0.18546315f, 
    0.01389206f, 0.02339325f, -0.01184291f, -0.02520257f, 0.15375336f, -0.17179947f, -0.01249659f, -0.13097323f, 
    -0.39276916f, -0.13735770f, -0.17502390f, -0.38890123f, 0.06290134f, -0.02268851f, -0.14664960f, -0.24579546f, 
    -0.34082428f, -0.39369518f, 0.11777686f, 0.23302381f, 0.36495492f, 0.09851315f, -0.03357883f, -0.08844653f, 
    0.04697637f, 0.02903459f, 0.28515652f, 0.07431120f, -0.51568466f, -0.15428652f, -0.76085860f, -0.03158875f, 
    0.03758597f, -0.05069713f, 0.19216263f, 0.12300377f, -0.09948376f, 0.00693729f, -0.14908867f, -0.01374733f, 
    -0.79803383f, 0.30793881f, -0.84787893f, 0.46668169f, 0.12085771f, -0.12707216f, 0.11358179f, 0.01583377f, 
    0.01021020f, 0.08892374f, 0.28032064f, 0.09726399f, 0.06066147f, -0.26228669f, -0.27975070f, -0.23299888f, 
    0.03959580f, -0.12520006f, -0.05630273f, -0.07947237f, 0.09917846f, 0.15676047f, 0.09677833f, -0.00811425f, 
    -0.24114546f, 0.25162974f, -0.29213157f, 0.05340342f, -0.01818879f, -0.37522033f, 0.22569248f, -0.10446028f, 
    -0.00753356f, 0.04878496f, 0.05861152f, -0.25754827f, 0.21432704f, 0.09613043f, 0.09106346f, -0.00728698f, 
    0.01820167f, 0.03226412f, 0.06658832f, 0.09195847f, -0.17197424f, 0.06104043f, -0.13924561f, -0.17739378f, 
    -0.30685359f, 0.22796181f, -0.02180203f, -0.13110416f, -0.06052418f, -0.02867532f, 0.07615882f, 0.21066682f, 
    -0.20960237f, -0.03479614f, 0.14565413f, 0.06553886f, 0.28059858f, -0.14414032f, -0.04535091f, -0.26953480f, 
    -0.12918660f, 0.00462478f, -0.03772700f, -0.11355463f, 0.10024395f, 0.09270857f, 0.20369655f, 0.07571776f, 
    -0.25632289f, 0.03253439f, 0.16758527f, 0.23344012f, 0.20624650f, 0.02951028f, 0.24891633f, 0.21943210f, 
    -0.33935067f, -0.06511682f, -0.09467496f, -0.16431454f, -0.36320615f, 0.04912713f, -0.34477362f, 0.28755081f, 
    0.21725301f, -0.21224697f, 0.21465893f, -0.07605880f, 0.01546866f, -0.00258714f, -0.23415172f, 0.07755645f, 
    0.05095953f, -0.35001236f, 0.03768983f, 0.16107447f, -0.27163279f, -0.07597964f, 0.02660243f, -0.18862326f, 
    0.07202923f, 0.04473563f, -0.06636108f, -0.02884446f, 0.19572854f, 0.42892379f, 0.12095720f, -0.31032410f, 
    -0.02289602f, 0.06338734f, 0.04489457f, -0.12541038f, -0.08195443f, 0.03766387f, -0.10593093f, -0.09577703f, 
    -0.18140587f, -0.53679675f, 0.04469781f, -0.09635928f, -0.43449324f, -0.03481483f, -0.39084104f, -0.15248686f, 
    0.06925288f, 0.03754104f, 0.17159870f, -0.04033802f, -0.24583514f, 0.17768881f, -0.16521674f, 0.12846740f, 
    -0.04792842f, 0.01212238f, -0.03908944f, -0.13379905f, -0.27649081f, 0.07792258f, 0.13377433f, -0.16683410f, 
    -0.23405062f, -0.28685781f, 0.20126681f, 0.38806394f, 0.11790431f, -0.07811658f, 0.14138906f, -0.01834172f, 
    -0.23957185f, -0.24973527f, -0.05143403f, 0.12893046f, 0.59550965f, -0.47025383f, 0.64724153f, -0.37388259f, 
    0.14643237f, 0.03852292f, -0.20832555f, 0.40643066f, 0.03632466f, 0.04224039f, 0.11967388f, -0.18343067f, 
    0.08428596f, 0.24349968f, 0.06855515f, 0.10302626f, 0.09350037f, 0.08121045f, 0.13502413f, 0.16012752f, 
    0.23470663f, -0.14772841f, 0.01858084f, -0.22317289f, 0.45907512f, 0.07898060f, 0.12322108f, -0.23695812f, 
    -0.07375973f, -0.03640586f, -0.15644903f, -0.07523014f, -0.15752538f, -0.08678822f, -0.11091842f, -0.24464576f, 
    0.09131550f, -0.54929030f, 0.52423888f, 0.05752697f, -0.09773164f, 0.06488305f, -0.25466800f, -0.06157449f, 
    0.07673520f, 0.08895799f, 0.19995530f, 0.17914009f, -0.57418197f, -0.82124293f, 0.27248091f, -0.19691484f, 
    -0.17442517f, -0.10164823f, -0.33539414f, 0.04940541f, -0.01478083f, 0.04476875f, -0.08846201f, 0.05577726f, 
    0.08997218f, 0.22680970f, 0.30410585f, 0.13647901f, -0.18499373f, 0.06076480f, 0.01281032f, -0.01374736f, 
    -0.14539224f, 0.09071095f, 0.14525546f, -0.01620882f, -0.00043276f, -0.12352938f, 0.67478681f, -0.39037204f, 
    0.13225573f, 0.18243238f, -0.00393346f, -0.18646885f, 0.06944374f, 0.02532681f, 0.28501174f, 0.15129614f, 
    -0.38333702f, -0.22186464f, -0.19901234f, 0.04511108f, 0.06539954f, -0.05210434f, -0.00451673f, -0.03909181f, 
    -0.12517230f, -0.18868339f, -0.33059523f, -0.22235326f, -0.00993777f, -0.10102862f, 0.06465619f, 0.34682778f, 
    0.13373926f, 0.10740513f, -0.15846211f, -0.03172993f, -0.05666706f, -0.13965310f, -0.03826213f, -0.23052889f, 
    -0.07162243f, -0.24518088f, 0.74585652f, -0.16387762f, -0.09149433f, -0.04295890f, -0.02392777f, 0.20299229f, 
    -0.12745681f, 0.09427876f, 0.07212851f, -0.16990137f, 0.63143224f, 0.70652854f, 0.09906365f, -0.14082336f, 
    0.34379351f, -0.07152034f, -0.03142716f, 0.00383846f, 0.12924822f, 0.03986930f, -0.06483193f, -0.04195110f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21935035f, 0.08018894f, 0.13543901f, -0.10546545f, -0.10800693f, 0.09429873f, 0.02395385f, -0.18933010f, 
    0.12710774f, 0.01882138f, -0.00117048f, -0.09071661f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
