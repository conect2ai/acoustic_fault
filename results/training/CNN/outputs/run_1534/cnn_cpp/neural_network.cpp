#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.69939506f, -0.98300523f, -1.07193077f, -0.62507987f, -0.55311769f, -0.80028659f, -0.62886292f, -0.64386517f, 
    -0.76424640f, -0.91350150f, -0.31228691f, -0.08234670f, 0.02332213f, 1.09890616f, -0.10156861f, 0.40841767f, 
    -0.37980580f, 0.05299447f, 0.46497288f, -0.22153762f, -0.17259926f, -0.10352214f, -0.30424964f, -0.12123991f, 
    0.06003265f, 0.63807923f, -1.21752310f, 0.57036012f, 0.30706510f, 0.94600123f, -0.82546198f, -0.64994991f, 
    -0.04434289f, -0.21693572f, 0.33169916f, -0.38131666f, -0.17692322f, -0.08364022f, -0.10380684f, 0.31426570f, 
    -0.05254085f, 0.04372423f, 0.11326820f, 0.41512242f, -0.20787679f, -0.29205379f, -0.09701167f, -0.18429539f, 
    -0.18648769f, -0.07606009f, -0.77852792f, -0.76210380f, -0.31653854f, -0.62144166f, -1.23125386f, 0.06305119f, 
    0.44244781f, 0.47717521f, 0.22790064f, -0.23388214f, -0.33263251f, -0.37421876f, -0.14690880f, 0.59138298f, 
    0.31513286f, -0.30283302f, -0.19419034f, -0.26471311f, -0.59612048f, -0.65950835f, -0.27254024f, -0.29913464f, 
    0.55019355f, -0.22505341f, -0.73852211f, -0.98178709f, -0.74050802f, -1.27778244f, -1.34209669f, -0.74752718f, 
    0.78902668f, 0.37365764f, -0.08526975f, -0.08592302f, 0.85577071f, -0.71757287f, -0.49809602f, -0.55892372f, 
    0.17309433f, -0.44001323f, -0.26425299f, 0.09265036f, 0.04384465f, 0.06859913f, -0.05454263f, 0.15423749f, 
    -0.20604961f, -0.07966913f, 0.27017984f, 0.06292451f, -0.54889983f, -0.13115674f, 0.13106602f, 0.19244957f, 
    0.42213187f, -0.18788894f, -0.09240020f, -0.20074798f, 0.66285408f, 0.65827620f, 0.38193244f, 0.16115440f, 
    -0.53672278f, -0.01205644f, 0.10399475f, 0.16477276f, -0.28109193f, 0.09286699f, -0.54722369f, -0.10640839f, 
    -0.24240556f, 0.19485614f, 0.45613813f, 0.41409338f, -0.09210411f, -0.54509473f, 0.63219690f, -1.54451263f, 
    -0.98637027f, -0.95545435f, -0.52432483f, -0.15481682f, 0.04525585f, -0.52388728f, 0.23333475f, 0.55705643f, 
    0.51441336f, 0.92909974f, -0.02093919f, 0.01470456f, -0.51952469f, -0.27303433f, -0.03203529f, -0.14527404f, 
    -0.26231262f, 0.00427710f, 0.09261391f, -0.32389358f, 0.20553157f, 0.53852844f, -1.28026104f, -0.44281268f, 
    0.21929836f, 0.60498923f, -0.63751471f, 0.38189605f, -0.71042538f, -0.30706954f, 0.61301345f, 0.43298048f, 
    -0.53064299f, -0.06827766f, 0.25393045f, 0.33798897f, -0.02471569f, 0.04937226f, 0.22109583f, 0.07354991f, 
    -0.31599230f, -0.57000005f, 0.34992108f, 0.48134288f, 0.25180078f, -0.18610895f, 0.15928128f, 0.73447126f, 
    1.32469797f, 1.36119795f, -0.58494806f, -0.60447299f, -1.29257977f, -0.56352860f, -0.20398265f, -0.21050465f, 
    -0.38286969f, 0.23838389f, 0.06477581f, 0.10483338f, 0.28400096f, 0.07823410f, 0.19824994f, 0.09705608f, 
    0.27274704f, -0.16422750f, 0.11298547f, -0.24002215f, 0.30545083f, -0.17631043f, -0.25245312f, -0.08625017f, 
    -1.16491330f, -1.10060298f, -0.55363661f, 0.63507551f, -0.28419814f, 0.50751984f, 0.81154013f, -0.20918228f, 
    0.06450661f, 0.14487995f, 0.36358857f, -0.12029690f, -0.25275916f, -0.52353728f, -0.30895033f, -0.07379629f, 
    0.25573310f, -0.15897396f, -0.02166818f, 0.00758747f, -0.35027832f, -0.48201308f, -0.36787063f, -0.23152125f, 
    -0.52374262f, -1.48648393f, -1.31021559f, 0.00396656f, 0.94115806f, 0.74456197f, 0.96507853f, 0.88105488f, 
    -0.24771763f, 0.02148283f, 0.46555308f, 0.03382514f, -0.12776482f, -0.14089793f, 0.33565968f, -0.50818956f, 
    -0.23454906f, -0.17546321f, 0.02314230f, 0.11182273f, -0.12085058f, -0.07636211f, -0.19316524f, -0.13650388f, 
    0.18544436f, -0.21031712f, -1.88391995f, 1.17643404f, -0.38621908f, -0.87504560f, 0.89957166f, 0.13124530f, 
    0.25561953f, -0.93036640f, -1.09497726f, -0.82855248f, 0.36729982f, 0.27883306f, -0.39915648f, -0.67839140f, 
    -0.31627166f, 0.41646868f, 0.00285055f, 0.00824054f, 0.18466009f, -0.07435803f, 0.45306599f, -0.13985534f, 
    -0.33014843f, -0.00768213f, -0.75906104f, 0.81318158f, 1.06229532f, 0.29975909f, -0.31771943f, 0.32784656f, 
    -0.48422566f, -0.34398240f, -0.11868943f, -0.61273605f, -1.02997553f, -0.20576276f, 0.35866383f, -0.19394636f, 
    -0.18084104f, -0.29574281f, 0.12393060f, 0.21875954f, 0.41521254f, 0.04936839f, -0.33153856f, -0.07542083f, 
    -0.19009095f, 0.09395455f, 0.32305065f, 0.27407131f, -0.20685139f, -0.55299407f, -0.37960741f, 0.05495397f, 
    -0.87715667f, -0.76294595f, -0.62025207f, -0.82034701f, -0.86200655f, -0.49474481f, 0.05420441f, -0.14991632f, 
    -0.23536630f, -0.29778746f, 0.40135717f, -0.45024848f, -0.10040169f, -0.10973408f, -0.27249095f, -0.50155962f, 
    0.00087952f, -0.22497652f, 0.23575391f, 0.38448983f, 0.20724006f, 1.36621237f, 0.27085775f, -0.37755331f, 
    -0.91948003f, -1.47854149f, 0.59508985f, 0.02269134f, 0.35949275f, 0.15476608f, -0.12498207f, -0.37185264f, 
    -0.18307732f, 0.48353288f, -0.28164044f, 0.33734974f, 0.19937974f, 0.25664520f, -0.13839594f, -0.34616956f, 
    -0.20154932f, 0.07023332f, 0.00385007f, -0.33555436f, 0.08463161f, 0.44776070f, -1.36430490f, -0.31169727f, 
    0.26450101f, 0.64631319f, 0.10290170f, -1.10800767f, -0.80285406f, -0.24414942f, 0.16925462f, -0.03742448f, 
    0.58576095f, -0.89970195f, 0.90646565f, -0.55428481f, -0.35648474f, -0.12311348f, -0.57466924f, 0.24391238f, 
    -0.30289403f, -0.36775491f, 0.27588734f, -0.36344266f, -0.33590865f, 0.00232865f, 0.60962349f, 0.28770098f, 
    -0.45167395f, 0.22874618f, 0.63764656f, 0.49738720f, -0.11467274f, -0.07424328f, 0.86529374f, 0.62642115f, 
    0.79795551f, 0.18840638f, 0.16924599f, 0.17281972f, -0.19896793f, 0.46975705f, -0.01654692f, 0.12631524f, 
    -0.05209187f, -0.28766978f, 0.06087218f, 0.03254170f, -0.41274521f, -0.09982041f, 0.09907487f, 0.06329946f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.35704926f, 0.31787172f, 0.12531006f, -0.23895374f, 0.90511769f, 0.66986907f, 0.48510656f, 0.54326016f, 
    0.14762302f, 0.40644002f, 0.62646276f, 0.00091114f, -0.39882872f, 0.70004994f, 0.45213950f, 0.44456959f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.48674497f, 0.26340410f, -0.00451717f, -0.32069704f, 0.11965139f, 0.14865674f, 0.16086088f, 0.05779492f, 
    0.01762409f, 0.02396289f, 0.04582686f, 0.13178703f, -0.14659841f, 0.14431156f, 0.50829810f, -0.60342509f, 
    -0.22349221f, -0.30156466f, 0.04490915f, -0.51324052f, -0.07771572f, -0.03108640f, -0.06939087f, 0.04810198f, 
    0.25352189f, -0.06436547f, -0.07692893f, -0.14634292f, 0.12285229f, 0.08539936f, -0.16942129f, -0.14582819f, 
    -0.24438271f, -0.17216559f, -0.13341370f, 0.31865072f, 0.30720612f, 0.12400325f, -0.10756467f, -0.04365057f, 
    0.07992087f, 0.16316071f, 0.19632073f, 0.15274447f, -0.02931022f, 0.05451017f, 0.01836773f, -0.14076683f, 
    -0.45742694f, -0.18493278f, 0.05955875f, -0.40768826f, -0.11028930f, 0.08211641f, 0.12719961f, -0.01096388f, 
    -0.15692031f, -0.33414885f, -0.48209321f, -0.16228177f, 0.49850306f, 0.28675371f, -0.13126449f, -0.14496432f, 
    0.17215422f, -0.26616004f, -0.15855038f, -0.37354708f, 0.08396569f, -0.11248023f, 0.04321974f, -0.01058575f, 
    0.02920525f, 0.34315789f, 0.25782669f, -0.40838638f, -0.16827241f, -0.29515043f, -0.18780157f, -0.09330796f, 
    -0.00755868f, -0.08834760f, -0.16947612f, -0.11542752f, -0.10257244f, -0.03034485f, 0.02615226f, -0.08311363f, 
    -0.15690067f, 0.18822071f, -0.02117153f, -0.25771731f, 0.04351908f, -0.02740626f, -0.10983482f, 0.06797110f, 
    0.49656200f, 0.06339716f, -0.29824519f, -0.16001686f, 0.14560995f, 0.06338980f, 0.06227982f, -0.05949188f, 
    -0.08304325f, -0.05989616f, 0.20893283f, 0.22167782f, 0.77990896f, -0.07403481f, -0.15810202f, 0.00084856f, 
    0.08146509f, 0.08769178f, 0.15976417f, 0.02747743f, -0.04610392f, -0.01049216f, -0.12153903f, 0.18443879f, 
    0.26196638f, 0.51416731f, -0.54632032f, 0.12445274f, -0.26704928f, -0.00830525f, -0.02138238f, 0.10557230f, 
    -0.08421460f, -0.08018054f, -0.13723943f, -0.09819394f, 0.09853702f, 0.05330129f, -0.61577952f, 0.03043278f, 
    0.02594663f, -0.17794579f, -0.09977674f, -0.14713535f, -0.01869865f, 0.16659433f, 0.06058842f, 0.03770966f, 
    0.44337970f, 0.24678975f, -0.02501526f, -0.41204277f, 0.18543564f, -0.02830057f, -0.05462717f, -0.19380355f, 
    -0.11742566f, -0.05067689f, 0.03871644f, -0.11589764f, -0.31338447f, -0.69745326f, -0.27997437f, -0.11123814f, 
    -0.07110170f, -0.03896917f, -0.17493474f, -0.32949767f, -0.18164515f, -0.30714265f, 0.02438025f, -0.01869472f, 
    0.26131514f, 0.51087457f, 0.38305566f, -0.44378337f, 0.11390254f, 0.04826018f, 0.00539678f, 0.19970715f, 
    -0.10154571f, -0.32344484f, -0.20632866f, -0.32196641f, -0.11979827f, -0.00480129f, 0.11808256f, 0.11267304f, 
    -0.01224521f, 0.08331982f, 0.14921035f, 0.00218106f, -0.39631382f, -0.28521460f, 0.01611597f, -0.06707895f, 
    0.08158417f, 0.00616105f, 0.53178227f, 0.30686730f, -0.02300661f, -0.04719485f, -0.06927390f, -0.19026051f, 
    0.00913376f, -0.05799139f, 0.05441786f, -0.11546358f, -0.07850688f, 0.57761419f, -0.35349014f, -0.20952517f, 
    -0.02436286f, 0.09989225f, -0.29491746f, -0.02584693f, -0.03171538f, -0.10430664f, -0.02909299f, -0.04807280f, 
    -0.25104579f, -0.15738599f, 0.38437241f, -0.14885817f, -0.01750306f, 0.10752518f, 0.03601934f, 0.07368096f, 
    -0.21209085f, 0.08733804f, 0.07941584f, -0.09174202f, 0.46599224f, 0.26921666f, 0.31351423f, -0.20924579f, 
    -0.00540927f, 0.22902799f, 0.01227929f, 0.02175708f, 0.01969640f, -0.14693686f, 0.03624216f, -0.26236376f, 
    -0.07479651f, 0.32490736f, 0.28041935f, 0.06068996f, 0.18913721f, -0.07643520f, -0.05668291f, 0.09363964f, 
    -0.12864034f, 0.05415338f, -0.09544366f, 0.11267336f, -0.43210992f, -0.69774610f, -0.01078749f, -0.05801466f, 
    0.16513261f, 0.39777496f, -0.18906024f, 0.14786999f, 0.08387201f, 0.07468808f, 0.07625469f, 0.03667562f, 
    -0.76617336f, 0.06522967f, 0.05094817f, 0.04097066f, -0.05544318f, 0.00354374f, 0.21641839f, 0.27556181f, 
    -0.10850914f, -0.02659203f, 0.14747302f, 0.05609347f, 0.15089174f, -0.17524377f, 0.09501345f, -0.27850917f, 
    0.08201680f, -0.06749415f, -0.38003516f, 0.06402633f, -0.04407046f, 0.05657258f, 0.02280943f, 0.10668543f, 
    0.34402555f, -0.08189113f, -0.28356275f, -0.06385314f, 0.00074920f, -0.06955814f, 0.02867134f, -0.09165232f, 
    0.18908198f, -0.33145720f, -0.38293526f, -0.22167899f, 0.63391036f, -0.20825541f, -0.00201905f, -0.04499492f, 
    -0.14497925f, -0.03085440f, -0.07200333f, -0.11546372f, 0.04374797f, -0.00602383f, -0.14617161f, -0.16709222f, 
    -0.22827055f, -0.46649548f, -0.06236351f, 0.03330532f, 0.01365167f, -0.00121151f, -0.09110620f, 0.16912907f, 
    -0.02888810f, -0.01764689f, -0.14286466f, 0.17401245f, 0.39559767f, -0.04413981f, -0.20488377f, -0.22523518f, 
    -0.30749246f, -0.38388643f, -0.04830910f, -0.38532203f, -0.05574584f, -0.01692193f, -0.10139594f, 0.16541161f, 
    -0.01426343f, 0.12175585f, 0.44486836f, -0.32019722f, -0.24544652f, -0.02361720f, -0.17195289f, 0.18840176f, 
    0.02891921f, 0.00253391f, 0.13628435f, 0.13844569f, 1.12682283f, -0.35144010f, -0.15542388f, -0.12031880f, 
    0.14854379f, 0.32677400f, 0.15155970f, -0.15425870f, 0.14705165f, 0.15159047f, -0.04085554f, -0.18794471f, 
    -0.90525830f, -0.00001946f, -0.55746830f, -0.19652158f, 0.14907216f, 0.19876347f, 0.11096597f, -0.26885641f, 
    0.10050451f, -0.00000074f, -0.06266990f, -0.04177399f, 0.21188186f, 0.13974248f, 0.23344822f, 0.19304731f, 
    -0.14605612f, -0.08800054f, -0.04268776f, -0.25434041f, 0.33047590f, 0.06458195f, 0.06500471f, 0.12438681f, 
    -0.97357404f, -0.74665552f, 0.07455001f, -0.46602023f, 0.03386844f, -0.09630317f, 0.09173606f, -0.23517860f, 
    0.05111561f, -0.00840346f, 0.04115269f, -0.06220849f, -0.29088140f, -0.07490215f, -0.31010151f, 0.39982310f, 
    -0.16838054f, 0.18612498f, -0.17708091f, -0.13814686f, 0.08296269f, -0.02678567f, 0.05636276f, -0.02585584f, 
    0.15228720f, 0.43716064f, 0.77339721f, 0.42813060f, -0.07373169f, 0.01245353f, 0.26664102f, -0.12131463f, 
    -0.06039810f, -0.12604497f, 0.05454319f, 0.00408465f, -0.14026938f, 0.27607718f, 1.09816206f, 0.45260322f, 
    -0.29382783f, 0.03154218f, -0.11609961f, 0.03661493f, 0.10003532f, 0.02087043f, -0.01982046f, -0.13089404f, 
    0.13339220f, -0.27148569f, -0.29719633f, 0.12862328f, 0.05850565f, 0.00234762f, 0.05479579f, 0.08528643f, 
    -0.06268378f, 0.11092848f, -0.34703627f, 0.14143923f, 0.41295788f, -0.04368789f, -0.18092380f, 0.24150530f, 
    0.04768097f, 0.02648327f, 0.08445042f, -0.17310929f, 0.04316561f, 0.02333426f, 0.04917344f, -0.00712280f, 
    0.25995308f, -0.16334058f, -0.01789949f, 0.48669708f, -0.19772558f, 0.07993863f, -0.38729745f, 0.10744179f, 
    -0.06639280f, -0.24906175f, -0.00729170f, 0.14409117f, -0.40961805f, -0.27653661f, 0.37484780f, -0.46159399f, 
    -0.08667143f, -0.13654745f, -0.35309905f, -0.16187225f, 0.05063649f, 0.01483988f, -0.05875939f, 0.08025889f, 
    0.02511303f, -0.07059725f, 0.45314968f, 0.04548845f, -0.07228978f, -0.05572649f, 0.10740787f, 0.04688114f, 
    0.10614341f, 0.03782365f, -0.00685660f, 0.24497670f, -0.27812365f, -0.26504105f, 0.19059837f, 0.26214945f, 
    -0.00686340f, 0.08524767f, 0.07731697f, 0.13904111f, 0.07729737f, -0.04403615f, 0.20410775f, -0.16934408f, 
    0.13610841f, -0.40852451f, 0.03249954f, -0.56178796f, 0.24785094f, -0.23124935f, 0.23281303f, 0.10473379f, 
    0.07731511f, 0.02190855f, -0.11219019f, 0.04685679f, -0.41105434f, -0.23468836f, 0.28897107f, -0.45219469f, 
    -0.22768067f, 0.02020774f, 0.25469941f, -0.04257269f, -0.05744087f, -0.13639483f, 0.02275644f, -0.07030439f, 
    -1.17581642f, -0.71888119f, -0.27375606f, -0.35319468f, -0.17096530f, 0.08240733f, -0.16586396f, -0.39310232f, 
    -0.16496590f, -0.12824266f, -0.13920407f, -0.13919012f, -0.51764733f, 0.66964924f, -0.01390948f, -0.18608564f, 
    -0.08376034f, 0.08060924f, -0.02363773f, 0.15657130f, 0.00901308f, 0.19810046f, -0.22875655f, 0.18432109f, 
    0.10835341f, 0.02046822f, -0.77290791f, -0.12505071f, 0.32840803f, 0.24576722f, -0.18483929f, 0.10805400f, 
    -0.06569183f, -0.08291253f, 0.13894497f, -0.00808286f, -0.22522236f, -0.10752217f, -0.14290738f, 0.20892611f, 
    -0.09433389f, 0.01603046f, 0.07176125f, 0.10600686f, -0.10595100f, 0.24845423f, -0.20896249f, 0.21573405f, 
    -0.08205678f, -0.46566376f, -0.19301900f, 0.22530107f, -0.10059868f, 0.10639232f, 0.00196663f, 0.11592130f, 
    0.01232549f, -0.14160687f, 0.26499164f, -0.16651879f, -0.84383667f, 0.17562154f, -0.20842417f, 0.39345804f, 
    0.13395077f, -0.14337264f, -0.02098263f, -0.24108477f, 0.10961610f, -0.02068885f, 0.22002909f, 0.22405943f, 
    0.30852658f, -0.06132702f, 0.15073608f, 0.40746811f, -0.08836158f, 0.14522426f, 0.03302411f, -0.05026360f, 
    -0.05252844f, 0.13263437f, -0.02231841f, 0.15001580f, 0.25686803f, -0.25290754f, -0.12131487f, 0.35169911f, 
    0.23983730f, 0.01205387f, 0.02457063f, -0.22766536f, -0.16781159f, -0.03123624f, 0.18024665f, 0.17571920f, 
    0.61326414f, 0.02771648f, -0.18493192f, -0.63237596f, -0.02645346f, -0.10247417f, -0.01432916f, -0.15544654f, 
    -0.04102564f, 0.33192018f, 0.08585642f, -0.16039205f, -0.07253805f, -0.08622380f, -0.10895938f, 0.47450754f, 
    0.22121324f, 0.08966814f, 0.07895882f, -0.15741053f, 0.20231871f, 0.22679532f, 0.01330312f, -0.09312222f, 
    0.48401105f, 0.16011316f, 0.13207324f, -0.45930263f, -0.22017197f, -0.10965606f, -0.19191417f, 0.01056961f, 
    -0.22763684f, 0.22014847f, -0.42730719f, 0.07422019f, 0.11398710f, -0.12015540f, 0.80653203f, -0.06798206f, 
    -0.28910857f, 0.09735741f, -0.20694259f, 0.07342999f, 0.02951108f, -0.10792974f, 0.10319407f, 0.07646117f, 
    -0.19720510f, 0.23538442f, 0.02786669f, -0.10425926f, 0.22531059f, 0.05190928f, 0.08572956f, -0.17181449f, 
    -0.08046822f, 0.04876915f, -0.05111695f, -0.04045093f, -0.66886169f, 1.01031685f, -0.51210022f, -0.73232865f, 
    0.35782069f, 0.35873967f, 0.14773846f, -0.16135640f, -0.56772417f, -0.17732944f, -0.03708366f, -0.17087705f, 
    0.23117724f, -0.23551045f, 0.04620513f, -0.08557007f, -0.06834025f, -0.01238210f, 0.00971747f, -0.14595714f, 
    -0.13503024f, -0.10859056f, 0.02489648f, 0.34548551f, -0.05394247f, -0.25096050f, 0.76618266f, 0.21136400f, 
    -0.15335041f, -0.08475861f, -0.03930273f, -0.05214727f, 0.18860497f, 0.12669918f, -0.29242840f, 0.16437775f, 
    -0.03981506f, -0.23331919f, 0.00729038f, 0.41162384f, 0.09673059f, -0.02159081f, 0.20322613f, 0.10497383f, 
    -0.20922777f, -0.00308359f, -0.25204876f, -0.19730340f, -0.57667232f, -0.07677826f, 0.10336935f, 0.57008559f, 
    -0.19343473f, -0.06266938f, -0.18650983f, 0.05947250f, -0.20345095f, 0.10211741f, -0.18330725f, 0.04723731f, 
    0.37660211f, -0.10866462f, -0.28817588f, -0.12801443f, -0.13597518f, -0.02369008f, -0.17508100f, -0.05636479f, 
    -0.22125363f, 0.02858367f, -0.06949534f, -0.33366302f, -0.40209910f, -0.21188015f, -0.00184865f, -0.34227774f, 
    -0.20992611f, -0.30031076f, 0.17921062f, -0.07616459f, -0.00675824f, 0.39039448f, -0.36885178f, -0.20267144f, 
    0.04757858f, 0.27311769f, 0.18854718f, 0.08796974f, -0.22562927f, -0.06951212f, -0.09757726f, 0.21118248f, 
    0.06356162f, 0.13570030f, -0.05745109f, 0.13608770f, 0.53017110f, -0.12822373f, 0.22481139f, 0.20054507f, 
    -0.16236867f, 0.04767772f, -0.12794445f, 0.06441775f, 0.05118396f, -0.01078439f, 0.09172165f, 0.11821521f, 
    -0.03312154f, 0.12676673f, 0.00521196f, 0.12112030f, -0.13984022f, -0.38813627f, 0.15769961f, -0.18796591f, 
    0.07603868f, 0.00483733f, 0.00245721f, 0.28072262f, -0.36792913f, 0.19338362f, 0.03112788f, 0.11033337f, 
    -0.38159740f, -0.08220876f, -0.21180788f, -0.18406253f, 0.06375285f, 0.08771736f, -0.09262050f, -0.02631401f, 
    -0.14896113f, 0.18540610f, -0.39067921f, 0.07065849f, -0.07875878f, 0.05133372f, 0.15671650f, -0.03191550f, 
    -0.25874528f, -0.27890527f, -0.34692758f, -0.28316358f, 0.19938852f, 0.50568014f, 0.28936070f, 0.19334128f, 
    -0.18021210f, -0.12353081f, -0.06293937f, -0.05438571f, 0.02696110f, -0.14038293f, -0.06322888f, -0.06489642f, 
    0.08041194f, -0.22106303f, -0.46113440f, 0.00078634f, -0.33795562f, -0.05276522f, 0.11182881f, -0.33739692f, 
    0.16822104f, -0.15430740f, 0.04652637f, -0.29234174f, 0.05582570f, 0.47627386f, -0.32829967f, 0.45567796f, 
    -0.01197363f, 0.21120284f, 0.04470716f, -0.20538154f, 0.17147641f, -0.04211107f, -0.03376541f, -0.16841717f, 
    0.01955348f, -0.29459628f, 0.04549608f, 0.16425106f, -0.21516283f, -0.09174509f, 0.05506142f, -0.09282738f, 
    -0.02174485f, 0.15018947f, 0.02520474f, 0.11340391f, 0.11150171f, -0.79161936f, 0.13298239f, 0.02997166f, 
    -0.25290591f, -0.00991091f, 0.02730903f, 0.01203645f, -0.07285424f, 0.11596976f, -0.05716629f, -0.00311663f, 
    0.22160357f, -0.13889374f, -0.11025861f, 0.45415711f, 0.21018343f, -0.29387850f, -0.17462148f, -0.16251187f, 
    0.09270126f, 0.06042788f, -0.03791454f, 0.02029742f, 0.20193435f, 0.36734077f, -0.29294929f, 0.50956184f, 
    -0.00820572f, -0.14408529f, 0.26049647f, 0.27506372f, 0.08286185f, -0.01175085f, 0.02875572f, -0.23241568f, 
    0.06065261f, 0.24713014f, 0.16719951f, 0.29660562f, -0.09742706f, 0.09185997f, 0.30105704f, 0.30352932f, 
    -0.08907913f, 0.03491744f, -0.10707623f, -0.01429963f, -0.34854355f, -0.06018265f, -0.45080388f, -0.18497422f, 
    -0.03260998f, -0.23090307f, -0.37833390f, -0.12040418f, -0.34386727f, -0.04500363f, 0.09662514f, -0.10166795f, 
    -0.30140007f, 0.23275924f, 0.14105892f, 0.26093155f, -0.21710603f, -0.10628918f, -0.13751215f, -0.23542461f, 
    -0.06682265f, -0.05131473f, -0.14739187f, 0.04772544f, 0.10588732f, -0.13387372f, -0.10564579f, -0.13023108f, 
    0.11443020f, 0.15743652f, 0.10919451f, 0.18011543f, -0.27606636f, -0.01813341f, 0.02467043f, 0.05835259f, 
    0.10285404f, 0.27165303f, 0.06025884f, -0.11473004f, 0.41682765f, 0.08073790f, -0.04390448f, -0.11093561f, 
    0.02704305f, 0.00042897f, -0.06113689f, 0.10880504f, 0.42030442f, -0.29271361f, 0.45213592f, 0.11798654f, 
    -0.00291912f, -0.17483255f, -0.12655804f, 0.11655616f, 0.03387819f, 0.05195493f, 0.01587437f, -0.11087541f, 
    -0.07457279f, -0.06440759f, -0.43470621f, -0.11027258f, 0.04730902f, -0.00176361f, -0.11736064f, -0.01514328f, 
    0.18317418f, 0.05128577f, -0.16330546f, -0.59976858f, -0.46173796f, -0.09082029f, -0.10867514f, -0.40302813f, 
    0.19695853f, -0.03849208f, -0.14776391f, 0.14468583f, -0.07055480f, 0.00082242f, -0.09573243f, 0.14278935f, 
    -0.34024325f, -0.18137227f, 0.19816017f, 0.29227307f, -0.23410614f, -0.02697225f, -0.03887274f, -0.13380677f, 
    0.32107282f, 0.08180229f, 0.33151934f, 0.25117499f, -0.03459808f, 0.09442758f, -0.14359821f, 0.01892103f, 
    -0.19323358f, 0.14505322f, -0.11304976f, -0.06051194f, -0.06264162f, -0.01383261f, -0.03546682f, 0.05421826f, 
    -0.10741103f, -0.44946006f, 0.05545354f, -0.16214509f, 0.35210985f, -0.13388979f, -0.10898422f, 0.09028719f, 
    0.04174284f, 0.04051848f, 0.07620699f, 0.20198123f, -0.23806734f, 0.09569107f, -0.54617739f, 0.33588356f, 
    0.07356999f, -0.25862840f, 0.11117373f, 0.03787892f, 0.04712182f, 0.08201536f, 0.01280789f, -0.03384067f, 
    -0.32458282f, 0.08032841f, -0.04463130f, -0.29952824f, -0.05728325f, 0.05743124f, -0.15654637f, 0.10784017f, 
    -0.13472761f, -0.31932718f, -0.28891829f, -0.05862166f, -0.45950371f, -0.30074984f, 0.03233398f, -0.01652418f, 
    -0.05439632f, -0.00452162f, 0.01963396f, -0.02120406f, 0.13574888f, -0.13969393f, -0.05561915f, -0.06824791f, 
    -0.42424685f, 0.83867389f, 0.33774439f, -0.48262575f, 0.06065909f, -0.04620929f, 0.12473013f, 0.19547234f, 
    -0.00711294f, -0.15912625f, 0.04948597f, -0.13307512f, -0.07939035f, 0.06001833f, -0.51341176f, -0.09590333f, 
    0.44959879f, 0.32656896f, -0.22375973f, 0.18008053f, 0.02901451f, -0.07560020f, 0.08319370f, 0.09988115f, 
    0.07763432f, 0.15725321f, -0.00398107f, 0.00811640f, 0.30579549f, 0.29120335f, -0.01790616f, -0.09414892f, 
    0.14068206f, 0.06487305f, 0.01355461f, 0.09320959f, 0.19295849f, -0.40961057f, -0.40763012f, -0.32936653f, 
    0.14871505f, -0.05168571f, -0.20138584f, 0.19945908f, 0.43702474f, -0.32648036f, 0.12861156f, 0.19153771f, 
    0.34326369f, -0.05692045f, 0.31291085f, 0.20917057f, -0.15618813f, 0.01290245f, 0.04396436f, 0.07415212f, 
    0.05296980f, -0.12024134f, -0.01712605f, 0.31582651f, -0.32753658f, -0.19927754f, 0.14371246f, 0.06750297f, 
    0.10025579f, -0.13446581f, -0.11291499f, 0.17226380f, -0.06136819f, -0.08884633f, 0.06159051f, -0.13302518f, 
    -1.27720571f, -1.37077451f, -0.73976147f, -0.71480769f, -0.18531501f, 0.05070205f, 0.17808840f, -0.40101647f, 
    0.05613926f, 0.00173431f, -0.06434014f, 0.03171217f, -0.23876190f, -0.43412346f, -0.55562520f, 0.35801896f, 
    0.00797167f, 0.15459609f, 0.22581869f, 0.37845576f, 0.02262229f, -0.00218723f, 0.09506828f, 0.25911978f, 
    -0.14998087f, 0.20360361f, 0.14108810f, -0.41439548f, -0.03935880f, 0.17237522f, -0.06939039f, 0.00844907f, 
    0.14820333f, 0.04222808f, 0.07904085f, 0.12115768f, -0.82561779f, -0.80845302f, 0.15530202f, 0.63735902f, 
    0.11231266f, -0.01197431f, 0.12621857f, -0.14582618f, -0.03062841f, 0.13503841f, -0.02141075f, -0.07049110f, 
    0.22541727f, -0.23027883f, -0.18505828f, 0.24511684f, 0.02605701f, 0.04431966f, -0.29127488f, 0.28254491f, 
    -0.01628235f, 0.14583942f, 0.11859653f, -0.43876165f, 0.01279015f, 0.06576657f, 0.24133810f, -0.53428954f, 
    -0.32052094f, -0.15227608f, -0.11774307f, 0.08788902f, -0.15627946f, 0.07045350f, -0.13011219f, -0.03570098f, 
    -0.39526731f, -0.11199631f, -0.30022720f, 0.01477487f, -0.00465448f, -0.24408597f, 0.16786419f, -0.10668555f, 
    -0.00420677f, 0.30427527f, -0.05637474f, -0.06725098f, 0.56582010f, -0.69079143f, -0.62050390f, -0.56474352f, 
    -0.11936949f, 0.31674680f, 0.14593013f, 0.04154639f, 0.04382106f, -0.03075829f, -0.08212886f, -0.07921014f, 
    -0.77238512f, 0.26026714f, 0.45588404f, 0.15972762f, -0.05740791f, 0.06841988f, 0.11445206f, 0.04260977f, 
    0.06428205f, 0.27775359f, 0.29295141f, 0.15786758f, -0.21034467f, 0.09885729f, 0.59395367f, 0.00756540f, 
    0.07513977f, -0.14875573f, 0.04202127f, 0.09860584f, 0.17715853f, 0.02919655f, 0.12277544f, 0.09151955f, 
    -0.50168842f, -1.24452555f, 0.12829490f, 0.55553395f, -0.08017717f, 0.15127321f, 0.01578915f, -0.29605094f, 
    -0.06209457f, 0.18008928f, 0.16630694f, -0.14333852f, -0.35009813f, -0.67043740f, -0.13622998f, -0.65663248f, 
    0.00742807f, 0.19195253f, 0.20885888f, -0.41089675f, 0.01778971f, 0.03954502f, -0.19183840f, 0.07954626f, 
    -0.50168777f, -1.33398581f, -0.96445316f, -0.48568240f, -0.36378628f, -0.53228396f, -0.20275451f, -0.40391621f, 
    -0.05896876f, -0.07973117f, -0.03371418f, -0.06941666f, 1.02389145f, 0.71040004f, 0.03708247f, -0.01973053f, 
    0.10343013f, -0.43128735f, 0.37682009f, 0.03745701f, 0.12875877f, 0.07623462f, 0.20950140f, -0.04268307f, 
    -0.06250824f, -0.77761859f, -0.05004581f, -0.13217536f, -0.05209406f, -0.06759421f, 0.29657972f, -0.24390036f, 
    -0.05741591f, 0.15206581f, -0.09306314f, 0.18985096f, 0.11507408f, -0.06741864f, -0.17333251f, -0.01162124f, 
    -0.06144365f, 0.08360064f, 0.01457376f, 0.26433599f, -0.03250228f, -0.27029178f, 0.03914364f, 0.03353759f, 
    -0.70859849f, -0.43292257f, -0.59298116f, -0.17010979f, 0.33074835f, 0.07583800f, 0.29786894f, 0.26959071f, 
    0.05893570f, 0.08732241f, -0.12292627f, -0.05063166f, 0.01636285f, -0.50147080f, -0.32949430f, -0.15336609f, 
    0.05627303f, -0.12768783f, 0.04229516f, -0.33355141f, 0.10656744f, 0.02132190f, 0.04787935f, 0.09512196f, 
    0.08783948f, -0.31751767f, -1.06586409f, -0.55420685f, 0.02154680f, -0.16764048f, 0.15280186f, -0.04461983f, 
    0.06870778f, 0.11807124f, 0.01950290f, 0.07631918f, -0.04442851f, -1.05165362f, -0.77728331f, -1.12261093f, 
    0.11463171f, 0.00978934f, 0.13900617f, 0.33949423f, 0.01263159f, 0.11613163f, -0.01345410f, 0.03488473f, 
    0.34666595f, -0.29210794f, -0.00020051f, -0.25004962f, -0.08034346f, 0.09353953f, -0.03020098f, -0.03870691f, 
    0.03438102f, -0.09226996f, -0.15743712f, -0.40809470f, -0.54462522f, -0.96127564f, -0.50660920f, -0.01384371f, 
    0.08210222f, -0.18253151f, 0.06267381f, -0.19140455f, -0.15413587f, -0.02723719f, 0.03355399f, 0.17867121f, 
    0.83056605f, -0.35711342f, 0.62588710f, -0.16725792f, -0.17611507f, 0.32786536f, -0.55847710f, 0.02297231f, 
    0.09577183f, 0.26103428f, 0.04479205f, -0.08889563f, -0.50309891f, 0.39842281f, -0.43237907f, 0.24547641f, 
    -0.25218365f, 0.00443243f, -0.12102381f, 0.17969644f, 0.07895206f, -0.02181120f, 0.05410068f, 0.04951559f, 
    0.42652294f, -0.57786834f, -0.24729401f, -0.35332769f, -0.03869327f, -0.10146891f, 0.04366140f, 0.19416682f, 
    0.16807300f, 0.11830050f, 0.29136255f, -0.08639172f, 0.63276207f, 0.24777795f, -0.25417909f, -0.82042336f, 
    0.00353382f, 0.04245156f, 0.00071823f, 0.01925777f, 0.10261773f, 0.24449725f, 0.07687189f, -0.22065775f, 
    0.22615258f, -0.20560266f, -0.01924185f, 0.21186048f, -0.02165411f, 0.13642080f, -0.02134541f, 0.00233631f, 
    -0.00602837f, -0.19482291f, -0.02770620f, -0.00365308f, -0.43515116f, 0.45742878f, -0.18594599f, 0.02708482f, 
    0.14156400f, -0.26485682f, -0.06988875f, 0.25099638f, -0.01468928f, 0.06574779f, 0.13236856f, 0.03862154f, 
    -0.89499038f, -0.58753794f, 0.17928712f, 0.87783355f, -0.05526599f, 0.08785965f, -0.06857616f, -0.11528044f, 
    -0.10173352f, -0.05845327f, -0.08131398f, -0.05805004f, -0.41145971f, 0.52259564f, -0.04075329f, 0.39999062f, 
    -0.35420799f, 0.23144667f, 0.19897720f, -0.03582298f, 0.03830567f, 0.10323378f, -0.01728545f, -0.05137982f, 
    -0.51220077f, -0.63210112f, 0.21732070f, 0.82756168f, -0.21765365f, 0.04298555f, -0.17135315f, 0.25150883f, 
    -0.13055383f, -0.15183736f, -0.23144215f, 0.02804247f, 0.15960586f, -0.12753393f, -0.00132817f, -0.13666455f, 
    0.06442566f, 0.08346486f, -0.07962818f, -0.07978189f, -0.25544146f, -0.22289628f, -0.39272562f, -0.20086177f, 
    0.40021932f, -0.53480101f, -0.51247007f, -0.03213168f, -0.22950011f, -0.06957037f, -0.14916505f, 0.03693546f, 
    -0.10597130f, -0.20893128f, -0.09950582f, 0.01332487f, 0.95377630f, 0.16661018f, -0.03252946f, -0.07160031f, 
    0.23398031f, 0.39991096f, -0.11480045f, -0.31722274f, 0.05984701f, -0.13388155f, -0.08554434f, -0.19934966f, 
    -0.40632656f, -0.68213362f, -0.30822298f, -0.09663699f, 0.19013354f, 0.30482602f, 0.09439272f, 0.29266518f, 
    -0.04472174f, 0.08078592f, -0.24561779f, -0.55508351f, -0.25389698f, -0.45467931f, -0.54721338f, 0.41258296f, 
    0.11177034f, -0.02766890f, 0.21549256f, 0.05598140f, -0.00787432f, -0.15973967f, -0.02693502f, 0.11097608f, 
    0.27574185f, -0.11581817f, -0.26734850f, -0.23218772f, 0.09689417f, 0.03780776f, 0.14748426f, 0.09971490f, 
    0.25642172f, 0.28253859f, 0.23697922f, 0.40279937f, -0.39206749f, -1.23025572f, -0.47165111f, -0.04542637f, 
    -0.05525285f, -0.08130208f, 0.05877411f, 0.17763650f, -0.17111024f, -0.14110087f, 0.03661576f, -0.11145078f, 
    -0.09919418f, -0.22930394f, -0.60608429f, -0.30328277f, 0.46480104f, -0.07029790f, 0.10780532f, 0.14725299f, 
    -0.19771832f, 0.10909433f, -0.07161634f, 0.27683896f, -0.49739736f, 0.27339002f, 0.13395977f, 0.19365591f, 
    0.15398797f, -0.16435283f, -0.27061480f, 0.06143311f, -0.13008219f, -0.00803516f, 0.09925351f, -0.04215960f, 
    -0.11044091f, -0.16394712f, -0.12033146f, 0.00034772f, -0.06549067f, 0.02131541f, 0.11459254f, 0.03601572f, 
    -0.11768825f, -0.02454646f, -0.32566252f, -0.53344154f, -0.00793239f, -0.20700306f, -0.71714360f, -0.58080786f, 
    -0.26976356f, -0.27723613f, 0.00938688f, 0.05879834f, 0.16612923f, -0.05406811f, 0.27689657f, 0.00205693f, 
    0.35971680f, 0.55737168f, 0.06461598f, -0.33264306f, 0.22404662f, 0.25335512f, 0.04888929f, -0.11918979f, 
    -0.13082245f, 0.16673617f, -0.39285305f, -0.03986464f, -0.73848295f, 0.25362557f, 0.11539214f, 0.37523979f, 
    -0.13413987f, 0.15057488f, 0.11994023f, -0.05408271f, 0.12759200f, 0.04073177f, 0.07066708f, 0.05253638f, 
    -0.25949261f, -0.95242864f, -0.67174172f, -0.57090330f, 0.11417221f, -0.29650572f, -0.02730172f, -0.11367931f, 
    0.15289547f, 0.12227259f, 0.16886175f, 0.11170727f, -1.55894637f, -0.06913186f, 0.06273887f, 0.55280417f, 
    0.18464604f, 0.06110009f, 0.06767199f, 0.00418447f, 0.00972492f, 0.10689747f, 0.02309009f, 0.15595764f, 
    0.88840663f, 0.26295257f, -0.40527681f, -0.19336465f, 0.26362848f, -0.09986370f, 0.11749154f, -0.08628445f, 
    0.25721297f, 0.19391127f, 0.21376728f, 0.22884218f, 0.13173778f, -0.15792601f, -0.19706732f, -0.35580131f, 
    -0.04216661f, -0.02837908f, 0.04170993f, -0.11944551f, 0.19930804f, 0.07174197f, 0.19094670f, 0.04526752f, 
    -0.77034086f, 0.34556308f, -0.08379415f, 0.49639809f, -0.32313907f, 0.00784003f, 0.16188236f, 0.10085470f, 
    -0.01076188f, 0.06763668f, 0.08878513f, 0.02960568f, 0.04997002f, -0.56415129f, -0.45734203f, -0.32239223f, 
    0.35614294f, -0.05367895f, 0.21000424f, -0.15958807f, -0.01874923f, -0.07766071f, 0.13707756f, -0.04075545f, 
    0.00162606f, 0.40552250f, -0.28609338f, 0.45329267f, 0.00413736f, -0.16124241f, -0.08087523f, -0.12219900f, 
    -0.08507320f, 0.00377538f, 0.36779812f, 0.07403304f, 0.60191232f, -0.08622089f, -0.19932300f, -0.26119268f, 
    -0.22306074f, -0.27380568f, -0.07279730f, -0.12241102f, 0.07910961f, -0.02439618f, 0.00313451f, 0.10441326f, 
    -0.18244572f, -0.08106063f, 0.23335204f, 0.29332000f, 0.14683905f, -0.20266183f, -0.05772932f, -0.17205416f, 
    0.13961998f, -0.22923288f, 0.00489553f, -0.22648364f, -0.11274447f, 0.90364200f, 0.35507536f, -1.17811131f, 
    -0.08591291f, -0.54516822f, 0.14853461f, -0.00800711f, -0.04543442f, 0.01866497f, -0.02716326f, 0.12305050f, 
    0.27657270f, 0.14079580f, -0.43417534f, 0.09884029f, -0.22163081f, 0.28022134f, -0.06085775f, -0.13411908f, 
    0.23596744f, -0.25375530f, -0.24668553f, -0.19224197f, -0.16457409f, 0.98793191f, -1.17993689f, 0.06414177f, 
    0.11100111f, 0.07313421f, 0.21981536f, 0.22802505f, 0.06555723f, -0.15978985f, 0.06316747f, -0.04595884f, 
    0.03020895f, -0.02678453f, 0.41204810f, 0.40641972f, 0.03857915f, 0.05621289f, -0.29174006f, -0.02565703f, 
    0.24517015f, 0.10618690f, 0.23343490f, -0.01247844f, -0.11675522f, -0.32486767f, 0.26155174f, 0.72115320f, 
    0.05758235f, 0.11734425f, -0.40565521f, 0.03125846f, -0.02613568f, 0.02259806f, 0.12994847f, 0.03295032f, 
    -0.57381696f, 0.02791995f, 0.25407055f, -0.67026722f, -0.27027187f, 0.15361048f, -0.11857592f, -0.09207588f, 
    0.14559622f, 0.19119126f, 0.13677555f, -0.07312544f, -0.23562488f, -0.08569164f, -0.64248246f, -0.04324206f, 
    0.24902141f, -0.17939556f, 0.12065792f, 0.26694086f, -0.09556396f, -0.14040378f, -0.06752352f, -0.23881629f, 
    0.14968251f, -0.24464197f, 0.12399419f, -0.54238170f, -0.07143050f, -0.28619286f, 0.08319101f, 0.35917777f, 
    0.06676275f, 0.02645204f, 0.05778105f, 0.02282169f, -0.34949398f, 0.23679999f, -0.58204991f, -0.98256367f, 
    -0.12663049f, -0.24425042f, -0.02242759f, -0.16672236f, -0.13228011f, 0.13540725f, 0.03130762f, 0.07860274f, 
    -0.71473461f, -0.06504429f, -0.83719695f, 0.30968466f, -0.21438447f, -0.26508626f, 0.23470499f, 0.02885075f, 
    0.09295002f, 0.22094610f, -0.11884831f, -0.18161353f, 0.00129058f, -0.09951810f, 0.06966479f, 0.16943653f, 
    0.08015826f, 0.12462837f, -0.00815082f, -0.09389190f, 0.12978859f, 0.01933903f, 0.05789135f, -0.05119346f, 
    -0.37822080f, 0.02910058f, -0.40358841f, 0.12471712f, -0.01595528f, -0.16576807f, -0.33645439f, -0.04993869f, 
    0.12986788f, 0.17153168f, -0.28100881f, 0.02279665f, -1.20643735f, 0.28952169f, 0.22590207f, 0.06467696f, 
    0.02407519f, 0.08208357f, 0.41957465f, 0.57057971f, -0.35125521f, -0.07411867f, -0.05051471f, -0.22970018f, 
    0.18315203f, 0.05511991f, -0.22640641f, -0.23554006f, 0.07856651f, -0.23766366f, -0.17873034f, 0.20927088f, 
    0.04604128f, -0.03925625f, -0.33534822f, -0.64261270f, -0.27028394f, 0.02149282f, -0.48415190f, 0.12912092f, 
    0.05732503f, -0.24647085f, 0.10723373f, -0.16139986f, 0.09807132f, 0.22668730f, -0.06530950f, -0.39057142f, 
    -0.31009161f, 0.33165926f, -0.07482287f, -0.54392368f, -0.06394727f, 0.08285696f, 0.39310965f, -0.08743183f, 
    -0.03086038f, 0.07979282f, 0.17262559f, 0.31594008f, -0.05800724f, -0.69223195f, 0.44706434f, 0.23527960f, 
    -0.15918453f, 0.26205841f, 0.30431378f, 0.05765979f, 0.08929900f, -0.06184077f, 0.24351291f, -0.10172536f, 
    -0.15836491f, 0.54888672f, 0.01292955f, 0.31426230f, 0.13321202f, 0.38591403f, 0.06477913f, -0.04732255f, 
    -0.10995683f, 0.28052106f, -0.10256555f, 0.26008046f, 0.02617531f, -0.72313964f, -0.14155251f, -0.08160222f, 
    -0.22854237f, -0.33412999f, 0.25041193f, -0.06794620f, -0.15783820f, 0.15620595f, -0.23064634f, 0.03119190f, 
    -0.20841956f, 0.11459628f, 0.06124786f, 0.24113886f, 0.07107823f, 0.39337078f, -0.48104951f, 0.00546996f, 
    -0.40332156f, -0.27292505f, -0.42603126f, -0.74180013f, -0.53254533f, 0.59125197f, 0.01322307f, -0.36362630f, 
    0.22108699f, -0.07047895f, -0.13244922f, -0.35312745f, 0.01336312f, -0.04628897f, -0.22461423f, -0.15151353f, 
    0.23104519f, -0.91532910f, 0.19281693f, 0.11913214f, -0.18802032f, 0.11099125f, -0.13057338f, 0.15833525f, 
    -0.11114766f, -0.31720483f, 0.04028991f, -0.04638773f, 0.12284819f, -0.43233734f, 0.55405521f, -0.33539432f, 
    -0.07670156f, 0.34172466f, -0.08326612f, -0.09883843f, 0.04272819f, -0.02350359f, 0.18496452f, 0.04705659f, 
    -0.41946468f, 0.02405033f, -0.59900349f, 0.19529603f, 0.00663306f, 0.25460285f, -0.00832752f, 0.12361328f, 
    0.15547554f, 0.31492198f, 0.12626669f, -0.01458973f, -0.17039767f, 0.11548919f, 0.57591748f, 0.56672573f, 
    0.06479447f, 0.00522323f, 0.05707430f, 0.03913163f, 0.04520742f, -0.14868081f, 0.19822538f, 0.07946008f, 
    -0.29793668f, -0.46091640f, 0.81161946f, 0.53396928f, -0.15773734f, 0.14295073f, -0.09034930f, 0.13951261f, 
    0.00754982f, -0.27885529f, 0.17546940f, 0.07288447f, -0.73496562f, 0.35036880f, 0.07823969f, -0.52855760f, 
    -0.25373429f, 0.16637783f, -0.18756227f, 0.17563829f, -0.07109204f, -0.19395928f, 0.31144673f, -0.15750244f, 
    0.35590506f, -0.55769640f, -0.06409159f, -0.48416901f, -0.12444274f, -0.30693227f, -0.42953143f, -0.14910750f, 
    0.03362117f, -0.09570199f, -0.02104565f, -0.07157665f, 0.22476089f, 0.05605771f, 0.26759201f, -0.30811462f, 
    0.18976174f, 0.14336459f, 0.20026010f, 0.17329237f, 0.09153032f, 0.19165275f, 0.07989103f, -0.00902561f, 
    -0.39087859f, -0.18650222f, 0.23031346f, -0.40791926f, -0.12583663f, -0.09051721f, -0.01085083f, 0.01341127f, 
    -0.11415616f, -0.07988856f, -0.03676845f, 0.21144451f, -0.12382865f, 0.86774111f, -0.44221559f, -0.64657354f, 
    0.33686674f, -0.03500742f, 0.24100024f, 0.04378172f, -0.12670426f, 0.07658490f, -0.02865369f, 0.07665309f, 
    -0.22625300f, 0.06625248f, 0.05071519f, 0.06344958f, -0.11348625f, 0.01065169f, 0.08447516f, -0.12276731f, 
    -0.02243984f, -0.19005938f, 0.02302519f, -0.22037788f, -0.59706533f, -0.39606643f, -0.01033767f, -0.35234031f, 
    0.19208698f, -0.15399638f, -0.09914389f, 0.17269169f, -0.07326922f, 0.07627954f, -0.21241999f, -0.17528871f, 
    -0.27416202f, -0.15183032f, 0.13960305f, 0.43841729f, 0.34764779f, 0.07659519f, 0.39636901f, -0.22434564f, 
    0.04583288f, -0.08640660f, 0.06184642f, -0.20856225f, 0.69604540f, -0.27322707f, 0.97227842f, -0.15251543f, 
    0.20703927f, 0.05374385f, -0.05099445f, 0.02270120f, -0.12203399f, 0.05881135f, 0.10624952f, -0.07552042f, 
    -0.53040642f, -0.21533479f, -0.33959675f, -0.03090777f, 0.21170725f, -0.03168325f, 0.25686774f, -0.06933308f, 
    0.11708632f, 0.12309391f, 0.45171532f, 0.26075259f, -1.02840543f, -0.01708741f, -1.06552851f, 0.47192153f, 
    0.30084133f, -0.05427905f, -0.01221160f, -0.25581303f, 0.10309904f, -0.02635942f, 0.14247286f, 0.14916261f, 
    -0.41891041f, 0.04846844f, -0.07334484f, 0.51971704f, -0.17741917f, 0.31309167f, 0.16491657f, -0.11333747f, 
    0.15034890f, 0.03175375f, 0.13383803f, 0.02440339f, 0.80712593f, 0.04739355f, 0.48705059f, -0.02213237f, 
    -0.19094796f, 0.17648834f, -0.59624290f, 0.07360625f, -0.18668936f, 0.05016515f, -0.19629182f, -0.28080878f, 
    -0.19533542f, -0.24145974f, -0.44470808f, -0.08896072f, -0.18858981f, -0.23062012f, 0.03211087f, -0.05406296f, 
    0.05440238f, -0.00401631f, -0.00912057f, -0.07712408f, -0.44654641f, -0.22968906f, 0.81343055f, -0.36214623f, 
    -0.14302820f, 0.14615847f, 0.14760396f, 0.12265275f, -0.28277218f, -0.07465424f, -0.07937679f, -0.05027000f, 
    0.31020227f, -1.17407680f, 0.15286632f, -0.10732576f, 0.20786831f, -0.38347155f, -0.01207877f, 0.30849919f, 
    0.15249300f, -0.04841560f, 0.55112147f, -0.12995832f, 0.05801918f, 0.19174686f, -0.31281933f, -0.10275991f, 
    0.07381628f, -0.10161086f, 0.14299311f, 0.10413403f, 0.07989270f, 0.06108298f, -0.18199679f, -0.08538597f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.32045317f, 0.25107235f, 0.04011526f, -0.16909385f, -0.22067726f, 0.10571640f, 0.07062306f, -0.15532498f, 
    0.06909624f, 0.01022078f, 0.08878525f, -0.03293328f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
