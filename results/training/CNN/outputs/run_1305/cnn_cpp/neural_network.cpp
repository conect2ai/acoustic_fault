#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.85958689f, 0.66121286f, 0.42059064f, -0.68410063f, 0.56233037f, 0.09287401f, 0.08988217f, 0.21946263f, 
    -0.02867418f, 0.28899565f, 0.44469741f, 0.13556534f, 0.31272876f, -0.30642855f, 0.14843191f, -0.59860235f, 
    0.93062133f, -0.65423638f, 0.16263482f, 0.34835157f, -0.95303506f, -0.73246235f, -0.67553413f, -0.48219502f, 
    -0.09006190f, -0.40623611f, -0.45948729f, 0.34728223f, -0.87475222f, 0.83924806f, -0.24685188f, -0.41122818f, 
    -0.23316368f, 0.52060395f, 0.49867344f, -0.28886956f, 0.33008793f, 1.37200248f, 0.53467137f, -0.70285428f, 
    -0.62883765f, -0.43654540f, 0.22806083f, -0.03913824f, 0.02174767f, 0.11497512f, -0.06562408f, 0.38739371f, 
    0.02910690f, 0.62539095f, 0.33809701f, -0.45552856f, 0.53449047f, 0.28948072f, 0.90567362f, -0.31177390f, 
    -0.05568347f, 0.75097001f, -0.30022192f, 0.27126437f, 0.29042518f, 0.29211533f, -0.39319107f, -1.31838548f, 
    0.01168013f, -0.48486736f, 0.43878752f, 0.68627036f, 0.54434890f, -0.23547600f, -0.19060361f, -0.27208066f, 
    0.11334388f, -0.41035360f, 0.51658410f, 0.66396207f, -0.03674764f, 0.34911913f, 0.10680815f, -0.06237144f, 
    -0.66218400f, 1.20043445f, -1.34762967f, -0.35151523f, -0.03156990f, 0.05982758f, 0.60486293f, 0.13681388f, 
    -0.27782455f, -0.03845318f, 0.51372617f, 0.11474810f, -0.96778101f, -0.49721703f, 0.72893751f, -0.59982175f, 
    0.42503667f, 0.01803447f, 0.24283554f, -0.01777616f, -0.40596822f, -0.50441206f, -0.60051340f, -0.35392755f, 
    -0.00834554f, 0.49441758f, 0.54803967f, 0.50501889f, -0.54316562f, -0.81681657f, -0.94519293f, 0.25485322f, 
    0.43151626f, -0.89282191f, -0.39256227f, -0.22133243f, -0.44951221f, -0.90625209f, -0.42454076f, -0.27661407f, 
    -0.17923068f, -0.43946463f, -0.60823369f, 0.24228051f, -0.30854645f, 0.11293211f, -1.01255417f, -0.74459195f, 
    -0.33751145f, 0.32743880f, 0.30633220f, 0.38003349f, 0.01060330f, 0.29226366f, 0.50555605f, 0.96853650f, 
    -0.07028150f, -0.21531832f, 0.46008962f, 0.34395111f, 0.47160488f, -0.25300542f, -0.58266765f, 0.01821392f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.42873698f, -0.01957802f, -0.07798944f, -0.07877837f, 0.10068744f, 0.09086213f, -0.22444984f, 0.15621096f, 
    -0.11765242f, 0.38833484f, 0.15639552f, 0.20555714f, -0.39498764f, 0.23847912f, 0.09694993f, -0.09686182f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02818483f, -0.01449510f, -0.00420702f, -0.01458066f, -0.05317620f, -0.06379933f, 0.00784098f, -0.03966176f, 
    0.03421330f, -0.02507410f, -0.01931495f, 0.00720511f, -0.02991676f, -0.00523867f, 0.00268285f, -0.03376801f, 
    0.04273796f, -0.01752693f, -0.00626496f, -0.00813871f, 0.04830753f, 0.02291047f, -0.01454495f, 0.02807714f, 
    0.04405124f, 0.00662001f, 0.01419645f, -0.01037073f, -0.04752486f, 0.00673444f, 0.04922351f, -0.02750229f, 
    -0.04808586f, 0.04100331f, -0.01570597f, -0.06096314f, 0.04434985f, 0.00464400f, -0.01094735f, -0.04500737f, 
    0.03806883f, -0.00065583f, -0.05620391f, -0.03178497f, 0.03903839f, -0.01791581f, -0.00239094f, 0.03777030f, 
    0.03462967f, -0.01664227f, -0.01379387f, -0.02511849f, -0.04348670f, 0.00287018f, -0.03289561f, -0.04016367f, 
    -0.02105136f, 0.01128629f, -0.04935487f, -0.00539844f, 0.01323311f, 0.02233401f, -0.01876436f, 0.03921315f, 
    -0.04289518f, 0.04019672f, 0.02028357f, 0.00897908f, -0.06209633f, 0.02408045f, 0.03323176f, 0.03047609f, 
    -0.06652440f, -0.00361144f, 0.00636546f, -0.00243045f, -0.04752792f, 0.04497641f, -0.02201366f, -0.01753468f, 
    -0.03709964f, 0.03039375f, 0.01881528f, 0.03031318f, 0.03815749f, 0.00779774f, 0.03751195f, 0.02532286f, 
    -0.04244329f, 0.02330430f, 0.01335934f, -0.05345796f, -0.03175716f, 0.02773740f, -0.04659695f, 0.02685287f, 
    -0.01414564f, 0.00960798f, -0.01004950f, 0.04095733f, 0.01285259f, -0.04694851f, -0.03645745f, -0.04391540f, 
    -0.05792132f, -0.02812277f, 0.05195670f, -0.00677510f, -0.02571073f, -0.00855923f, -0.03294263f, 0.04095944f, 
    -0.03087275f, -0.06031875f, -0.05973892f, -0.01857933f, -0.02852177f, 0.02062921f, -0.00460525f, -0.03567372f, 
    0.02921138f, -0.02263048f, 0.02102326f, -0.00358356f, -0.05316687f, -0.03732508f, 0.05179284f, -0.02273003f, 
    0.00906007f, 0.04624648f, -0.00357221f, -0.05721625f, 0.02852265f, 0.00360562f, -0.02456843f, 0.03575256f, 
    0.03619685f, -0.03706423f, 0.02412289f, -0.03912698f, -0.03479391f, -0.05423529f, 0.01298101f, 0.02773782f, 
    -0.05849828f, 0.00211391f, -0.01194414f, -0.05970316f, 0.04294341f, 0.04161789f, 0.00454222f, -0.03271009f, 
    -0.04371485f, -0.06033828f, -0.06232148f, -0.04776514f, -0.03085782f, 0.04306487f, 0.01633442f, -0.05517265f, 
    0.02192419f, -0.02629127f, -0.01434653f, 0.04134189f, 0.02676108f, -0.00516850f, 0.03831438f, 0.02975759f, 
    -0.03418119f, 0.01686956f, 0.00974265f, 0.04029160f, -0.01104504f, -0.01511945f, -0.05550740f, -0.04793808f, 
    0.03944559f, 0.04331993f, -0.05256305f, 0.03240706f, -0.06425779f, 0.02277499f, 0.03887063f, 0.03579433f, 
    0.02691476f, -0.02092064f, -0.06588941f, -0.02178631f, -0.00803086f, 0.01416575f, 0.00449127f, 0.04327058f, 
    0.03661708f, 0.01868853f, 0.03886871f, -0.00305679f, 0.01594425f, -0.02883636f, -0.01561896f, -0.04073249f, 
    -0.03267937f, -0.02695310f, -0.03027393f, -0.00813139f, 0.02682608f, 0.02045131f, -0.02459948f, -0.04023507f, 
    0.03426959f, 0.02004251f, 0.02848297f, -0.04049293f, -0.03802818f, -0.00696283f, 0.00565214f, -0.05555785f, 
    0.04387569f, -0.01290785f, 0.01001726f, -0.04539765f, 0.00217151f, 0.04396162f, -0.02775723f, 0.00184077f, 
    -0.04202997f, -0.02498938f, 0.03148216f, 0.00552722f, -0.05837956f, -0.01577054f, 0.03022449f, -0.02856568f, 
    0.04108110f, -0.05718816f, -0.02831427f, 0.03304090f, -0.02878268f, 0.02787833f, -0.06113672f, 0.02517802f, 
    0.03798298f, -0.01089460f, -0.03697699f, -0.01793316f, -0.03960901f, -0.01412360f, 0.00801488f, -0.03226503f, 
    -0.03218795f, 0.00570691f, 0.02816664f, 0.02181477f, -0.01796474f, -0.01235762f, 0.04218647f, 0.02127735f, 
    0.01148422f, -0.04686436f, 0.04380855f, 0.00310012f, -0.02708456f, -0.01361046f, 0.02557125f, 0.03871219f, 
    -0.00449652f, -0.01965909f, 0.01892650f, 0.03991031f, -0.03560247f, 0.03509843f, -0.02148515f, 0.04322082f, 
    -0.04825211f, -0.04328227f, -0.05977965f, 0.00105769f, -0.04202797f, 0.04207581f, -0.02051753f, 0.01140854f, 
    0.00603421f, -0.04676681f, -0.04346775f, -0.02544612f, -0.01618271f, -0.04929174f, -0.03950905f, 0.02823232f, 
    -0.02162258f, -0.02617389f, 0.00402512f, 0.02157161f, -0.02872669f, -0.05459731f, -0.05753008f, -0.04780807f, 
    0.00099756f, -0.04680770f, -0.03704488f, 0.00172061f, 0.00148540f, -0.05743641f, -0.01158121f, 0.03867130f, 
    0.00199733f, 0.03072865f, -0.00314863f, -0.06419100f, 0.00643497f, 0.02383833f, 0.04227283f, -0.03711263f, 
    0.01013103f, 0.01004474f, -0.06413786f, -0.02107457f, 0.00199089f, -0.01047423f, -0.03403637f, 0.03242255f, 
    -0.19772246f, -0.16855590f, -0.02657169f, 0.16059463f, 0.03485717f, -0.00272406f, -0.11976197f, -0.04139555f, 
    0.08643602f, 0.03511679f, 0.10151746f, 0.07133608f, 0.00883947f, -0.02448429f, 0.09511574f, 0.00197736f, 
    0.08193094f, 0.09792861f, 0.07187509f, 0.04207738f, -0.02648930f, -0.07790549f, 0.08313629f, 0.09785035f, 
    0.05312023f, -0.03303809f, -0.05615442f, -0.04917779f, -0.05906187f, -0.02695020f, -0.00935250f, 0.06357177f, 
    0.09502862f, -0.06034636f, -0.01746726f, -0.00644245f, 0.00688171f, -0.19474095f, 0.03625684f, 0.00071936f, 
    0.27573273f, 0.32732970f, 0.23609009f, -0.01362476f, -0.29693076f, 0.03704505f, -0.03316968f, 0.08714992f, 
    -0.06054796f, 0.21195944f, 0.07055721f, 0.04205471f, 0.01725138f, -0.02732650f, -0.07032988f, 0.01112458f, 
    -0.05412749f, 0.02796685f, -0.06622535f, -0.11210309f, -0.00148257f, 0.10499562f, 0.12730074f, -0.31638622f, 
    -0.02839887f, -0.12493207f, 0.05402559f, 0.21723987f, 0.18808222f, 0.10936344f, -0.01288238f, -0.02172819f, 
    -0.08752407f, -0.00307738f, -0.09842000f, -0.02223190f, -0.06769899f, 0.01110162f, 0.20928679f, 0.15304291f, 
    -0.30041164f, -0.04229692f, -0.40340742f, 0.15492232f, 0.06773999f, 0.12272051f, -0.15955773f, -0.00732822f, 
    -0.13745497f, -0.01297620f, -0.05871636f, -0.01862896f, -0.09184111f, 0.01553399f, -0.04735289f, 0.12932615f, 
    -0.11158189f, 0.08446815f, -0.13627724f, -0.12837791f, 0.03842154f, -0.26511696f, -0.03250177f, 0.02310752f, 
    0.09249182f, -0.00201723f, -0.04076285f, -0.12443446f, -0.06719568f, -0.06997800f, 0.05311875f, -0.03315949f, 
    0.00590814f, 0.09505293f, -0.06154611f, -0.03243437f, -0.06817959f, 0.08615678f, 0.00330377f, 0.02686861f, 
    0.01269835f, -0.14084145f, -0.24439232f, 0.05409965f, 0.03783885f, -0.01673468f, 0.00948649f, -0.14656463f, 
    -0.04149484f, -0.05689405f, -0.09415657f, -0.09124707f, 0.02251655f, -0.02988720f, 0.01518176f, -0.07048471f, 
    -0.03312436f, -0.02452807f, 0.07165395f, 0.06016810f, -0.20718801f, 0.31797257f, -0.07322037f, 0.03255961f, 
    -0.09066210f, 0.00305982f, -0.06832642f, -0.03635623f, 0.10417338f, -0.13027957f, 0.02285105f, -0.00605939f, 
    -0.11897150f, -0.06336240f, -0.01080142f, -0.00889303f, -0.04064755f, 0.07057484f, -0.12000126f, -0.14212199f, 
    0.14168100f, -0.04013471f, 0.04583210f, -0.03566038f, 0.08518151f, -0.08911653f, -0.07326195f, -0.04519833f, 
    0.00220523f, -0.03877602f, -0.12333436f, -0.02896848f, 0.09417365f, 0.04778429f, 0.15769042f, -0.11021424f, 
    -0.10880416f, -0.02579448f, 0.06929175f, -0.05192041f, 0.43148357f, -0.29992235f, -0.05757732f, 0.03906672f, 
    -0.02465539f, 0.08549345f, -0.16715026f, -0.08159463f, 0.07010866f, -0.09329985f, 0.00268084f, -0.02164390f, 
    -0.11686917f, -0.14882860f, -0.00629614f, -0.03324202f, -0.10961711f, -0.05903756f, 0.03765152f, 0.06275450f, 
    0.22811103f, 0.23976223f, 0.27373773f, 0.00569314f, -0.16283649f, 0.05737359f, 0.09806112f, 0.28615516f, 
    -0.07406434f, 0.06931192f, 0.10639559f, -0.20525807f, -0.07163089f, -0.03100716f, 0.00614983f, -0.07369060f, 
    0.02113512f, 0.10713235f, 0.03219252f, 0.26795575f, 0.13967538f, 0.19030419f, 0.23302729f, 0.05375876f, 
    -0.09906207f, -0.01408913f, -0.03915062f, 0.16674499f, 0.01342565f, 0.03900655f, -0.00307847f, -0.07090410f, 
    -0.06439000f, -0.11628089f, -0.06719819f, -0.02193348f, 0.05879097f, -0.02485828f, 0.05052782f, 0.24493285f, 
    -0.03854074f, 0.19470116f, 0.10804617f, -0.16971700f, -0.22738108f, 0.13335690f, 0.01011139f, 0.10818205f, 
    0.03515230f, 0.03784573f, 0.05027243f, -0.04128835f, 0.05185767f, -0.04134120f, -0.08897091f, 0.02138358f, 
    -0.04768712f, 0.21327576f, -0.00553206f, -0.11490985f, -0.06112829f, 0.27869847f, 0.22657196f, -0.07692199f, 
    -0.02052855f, 0.06961335f, 0.14462134f, 0.12636764f, 0.16431424f, 0.06250397f, 0.08631515f, -0.04138637f, 
    -0.01041583f, 0.08028137f, -0.04225887f, -0.06657681f, 0.00540545f, 0.01340875f, 0.06572544f, -0.05099335f, 
    0.03000304f, -0.06553377f, -0.08485239f, 0.03314504f, -0.07104609f, 0.06200674f, 0.00319987f, -0.04347965f, 
    0.17832273f, -0.05768050f, 0.00854289f, -0.10631365f, -0.13885573f, -0.10969674f, -0.13853157f, -0.07772490f, 
    0.06291492f, 0.04761295f, 0.02905441f, 0.10784926f, 0.04309500f, -0.07394921f, -0.06465904f, -0.06718418f, 
    0.09064037f, -0.08388120f, -0.08886570f, -0.08287948f, 0.01172628f, -0.01570240f, -0.09545680f, -0.01398693f, 
    0.00977669f, 0.13463667f, 0.12750787f, -0.00058882f, -0.01286671f, 0.12877992f, -0.04492876f, -0.03955987f, 
    0.04852968f, 0.00419550f, -0.01009780f, 0.00597852f, 0.00194315f, -0.00456919f, -0.01331604f, 0.01723328f, 
    0.03830747f, -0.04297297f, -0.06443587f, 0.00929008f, -0.02042471f, 0.01939810f, 0.02549699f, -0.01813395f, 
    0.02653627f, -0.00101629f, 0.04949577f, -0.01863254f, 0.05133673f, 0.01357093f, 0.03739697f, -0.00928914f, 
    0.03216146f, -0.05918207f, -0.02788766f, 0.03536104f, -0.04820608f, -0.02846305f, -0.04640604f, 0.00234256f, 
    0.02925662f, -0.01699829f, -0.04198364f, 0.00688649f, -0.01963033f, 0.01390036f, 0.03265653f, -0.01965210f, 
    -0.04427071f, 0.02379861f, -0.05310599f, 0.01671746f, -0.00601598f, -0.02650330f, 0.03073381f, -0.03454199f, 
    -0.01425335f, -0.02333512f, -0.01704794f, 0.02035296f, -0.02614051f, -0.03216260f, 0.03359336f, -0.01648181f, 
    0.04691499f, 0.00333427f, -0.03504655f, -0.04355724f, -0.05696618f, 0.03692690f, 0.00277039f, -0.03167569f, 
    -0.03075663f, 0.03679936f, -0.01368059f, -0.01806584f, 0.01308211f, 0.02538300f, -0.03932187f, 0.02635513f, 
    -0.04508593f, 0.03158190f, -0.05757044f, -0.04765246f, 0.02055180f, 0.03075539f, -0.01106714f, -0.05028002f, 
    0.04867999f, -0.05689875f, -0.02670744f, 0.03778747f, -0.03181932f, -0.03271833f, 0.01644197f, -0.02333306f, 
    -0.01214799f, 0.00592175f, -0.02583169f, -0.03030550f, -0.00488765f, -0.03359221f, -0.04582488f, -0.03633852f, 
    0.04350852f, -0.01153170f, 0.04853008f, -0.03551576f, -0.04787093f, -0.01769148f, 0.03183526f, 0.02185867f, 
    -0.03282860f, 0.02842789f, -0.05413159f, 0.02784831f, 0.03580711f, 0.03957214f, 0.01336996f, 0.03065854f, 
    0.01956789f, 0.03661713f, -0.04984845f, -0.03824223f, -0.02946331f, -0.01152445f, -0.00991089f, -0.03477963f, 
    0.03854511f, -0.05681252f, 0.00115358f, 0.00116088f, -0.00911180f, 0.03313648f, -0.04026042f, -0.04407984f, 
    -0.03625749f, -0.04332178f, 0.02881241f, -0.05342898f, 0.03917611f, -0.02447328f, -0.03107879f, -0.03887940f, 
    -0.03392860f, 0.01495478f, -0.01169328f, 0.03479792f, -0.00952730f, -0.00132775f, -0.00253979f, 0.01850670f, 
    -0.00043913f, -0.05856908f, -0.02038684f, -0.06160507f, 0.02104046f, -0.04454992f, 0.00382024f, -0.05756342f, 
    0.00421587f, -0.01412883f, -0.01691950f, -0.01343474f, -0.05556329f, 0.01800399f, -0.00652490f, 0.02853312f, 
    0.00519647f, -0.00361328f, 0.02938028f, -0.04941766f, -0.00090206f, -0.03015067f, -0.00228282f, -0.02935121f, 
    0.01688664f, 0.00031635f, -0.06636649f, 0.02258204f, -0.04108313f, 0.00429181f, -0.01365270f, 0.03227885f, 
    0.00483577f, -0.06506797f, 0.01579858f, -0.00598651f, -0.00496749f, -0.03441238f, -0.01093131f, 0.03747611f, 
    -0.03562038f, -0.04966303f, -0.05169893f, 0.03754760f, 0.03738062f, 0.02363227f, 0.02121236f, 0.04002987f, 
    0.05176979f, 0.00924305f, -0.01474091f, -0.01025713f, -0.01199034f, 0.00954241f, 0.02431034f, -0.02006029f, 
    -0.02637694f, -0.02717838f, -0.01996019f, -0.01630290f, -0.04455093f, 0.02029333f, -0.02487101f, -0.02059756f, 
    0.04314369f, 0.00113919f, 0.02209628f, 0.03889520f, 0.00974258f, 0.01095430f, 0.01361587f, -0.06127656f, 
    0.05154284f, 0.01606494f, 0.04413756f, 0.04189446f, -0.01139487f, 0.02493441f, -0.04758146f, -0.05756929f, 
    -0.03738299f, -0.02963707f, -0.03135041f, -0.04589272f, 0.03543603f, 0.02819475f, 0.02848349f, 0.01854493f, 
    -0.02949610f, -0.00120832f, 0.01651078f, -0.05843596f, -0.04071834f, 0.00474032f, -0.05088971f, 0.03635841f, 
    -0.04997861f, -0.04653030f, 0.01015438f, 0.00440887f, -0.05322117f, 0.02758397f, -0.04565356f, 0.03291991f, 
    -0.02945662f, -0.01867526f, -0.01783762f, -0.03563584f, -0.02766377f, 0.00674654f, -0.04082745f, -0.01662518f, 
    0.01956422f, 0.01598452f, -0.04834043f, 0.02965819f, -0.01995825f, 0.01033324f, 0.00419053f, 0.02613962f, 
    0.01765408f, 0.05084142f, -0.02282715f, 0.00459472f, 0.00946202f, -0.03938147f, 0.03881320f, 0.03039061f, 
    0.02315018f, 0.03465757f, -0.02868661f, -0.03502896f, -0.01762539f, -0.01854508f, -0.01620214f, 0.04870775f, 
    -0.03710068f, -0.00507948f, -0.04658425f, 0.01862238f, 0.02380155f, -0.04734028f, -0.01481429f, -0.00689072f, 
    -0.05733760f, -0.03801979f, -0.03935708f, 0.01461249f, -0.03605179f, 0.02193864f, 0.00570033f, -0.01424974f, 
    -0.02780441f, 0.02443632f, -0.05192531f, -0.03400927f, 0.00574377f, -0.01736129f, -0.03066326f, 0.00806730f, 
    -0.02578139f, 0.02888046f, 0.00182241f, 0.00968784f, -0.05683688f, 0.03285276f, 0.03027993f, 0.03263208f, 
    0.02658723f, 0.04162927f, -0.05500719f, -0.04495428f, 0.02695128f, -0.00057442f, 0.03249739f, 0.03532412f, 
    -0.01512084f, 0.02171309f, -0.03114416f, -0.05338093f, 0.02512659f, -0.01787815f, -0.03185464f, 0.03913307f, 
    -0.02473577f, -0.05353859f, -0.05553006f, -0.05732431f, -0.06249391f, -0.00994316f, 0.04186956f, 0.02043728f, 
    -0.05322881f, -0.02274396f, 0.00480673f, -0.03488584f, -0.05631448f, -0.06288766f, 0.04581420f, 0.00963686f, 
    0.00289135f, -0.04325597f, -0.05347675f, 0.04153671f, -0.01487045f, -0.02129329f, 0.03330383f, -0.02400143f, 
    -0.00146626f, -0.05775909f, -0.04005864f, -0.00091254f, -0.05567113f, 0.00027503f, 0.03001930f, -0.02320513f, 
    0.01102961f, 0.02862648f, -0.04836026f, 0.00741958f, 0.00034330f, 0.02109196f, 0.01087196f, -0.00841755f, 
    -0.00798950f, 0.01780515f, 0.00482063f, 0.04149880f, -0.04659556f, -0.06948234f, -0.00246459f, -0.03764576f, 
    -0.01621332f, 0.03465497f, 0.05421013f, 0.00812133f, -0.02501847f, -0.05714686f, 0.02309487f, 0.00766131f, 
    -0.03279695f, -0.00712052f, -0.00959445f, -0.03546678f, -0.04389467f, 0.00264715f, -0.03680050f, -0.04187001f, 
    -0.00618087f, -0.00032108f, 0.00652171f, 0.00530346f, -0.05825311f, -0.02746874f, 0.03273029f, 0.02430225f, 
    -0.02708489f, -0.02832749f, -0.03986789f, 0.03496125f, -0.03807297f, -0.03139940f, -0.00782944f, 0.06107442f, 
    -0.01021249f, -0.03630204f, 0.02042079f, 0.02749495f, -0.02779386f, -0.05598480f, -0.04189446f, -0.05343754f, 
    -0.04097911f, -0.01068321f, -0.00908612f, -0.02996396f, -0.04903096f, -0.00204741f, -0.00407687f, -0.02321156f, 
    -0.01850217f, 0.03883331f, 0.03975093f, 0.03581266f, 0.01602588f, -0.02253564f, -0.00427672f, 0.00376421f, 
    0.00597663f, 0.01522904f, -0.01877385f, -0.03072685f, -0.02920666f, -0.01527101f, 0.01941834f, -0.04358265f, 
    0.00876379f, 0.03395239f, -0.02205764f, -0.02887885f, 0.02293002f, -0.01406711f, -0.06627317f, -0.02673021f, 
    0.01425991f, -0.03800585f, 0.01793880f, -0.03567144f, 0.00513499f, -0.05138655f, -0.06058820f, 0.00254191f, 
    -0.00808932f, 0.00908435f, 0.00059579f, -0.01295277f, -0.00842300f, 0.01504273f, -0.05003649f, 0.00755917f, 
    -0.00940777f, -0.06941519f, 0.02923830f, -0.05372871f, -0.01980886f, -0.00396683f, -0.01654860f, 0.00718983f, 
    -0.05351186f, -0.03631198f, -0.01754381f, 0.03768694f, -0.06325512f, -0.04920839f, -0.03389553f, 0.04156836f, 
    0.00638957f, -0.03511810f, -0.05690449f, -0.04811538f, -0.00405130f, 0.01067687f, -0.02695588f, -0.04038275f, 
    -0.01156568f, 0.03685543f, -0.03487284f, -0.02755878f, 0.00360500f, -0.00972189f, -0.03537614f, 0.03627359f, 
    -0.06299071f, -0.02002843f, 0.04021334f, -0.02622955f, 0.01263468f, 0.00588147f, -0.05263273f, 0.03147023f, 
    -0.02891429f, 0.04306231f, 0.01079111f, -0.03343502f, 0.00361574f, 0.02155354f, -0.00234359f, 0.04340789f, 
    -0.02035712f, -0.00398368f, 0.00668603f, 0.04651574f, -0.04954351f, -0.02684017f, 0.05201174f, 0.03451211f, 
    -0.01435354f, 0.02972403f, -0.03997041f, 0.00332369f, -0.04075260f, 0.00187454f, 0.00303471f, -0.01430342f, 
    0.03667926f, -0.04193799f, -0.04868576f, -0.00426585f, 0.03850749f, -0.00252856f, -0.02840796f, 0.01557138f, 
    0.04313287f, 0.03697482f, 0.02406278f, 0.04010706f, -0.03470858f, -0.02814864f, -0.02734985f, 0.03256128f, 
    -0.00356965f, 0.00915148f, -0.04133611f, -0.06716648f, -0.02153368f, -0.04566557f, -0.02078486f, 0.03481242f, 
    0.00971793f, 0.04236452f, -0.01785237f, -0.00263486f, 0.00839063f, 0.01911888f, -0.05703906f, -0.05013468f, 
    -0.03105014f, 0.02354723f, -0.00747379f, 0.00637825f, -0.04164265f, 0.04651831f, -0.01102729f, 0.03784667f, 
    -0.05451000f, 0.02720881f, -0.03003565f, 0.03100710f, 0.02418737f, -0.01159143f, 0.02453901f, -0.05153298f, 
    -0.01446191f, -0.04949780f, -0.06287965f, -0.01999776f, 0.01904435f, -0.01256560f, -0.04311890f, -0.00419670f, 
    -0.00158919f, 0.03414273f, -0.04782914f, -0.03338818f, 0.02843891f, -0.05514198f, 0.04177510f, 0.02873692f, 
    -0.06161585f, -0.05411448f, -0.01185493f, 0.04832086f, -0.03873420f, 0.01896805f, -0.01071957f, -0.00344012f, 
    -0.02497759f, 0.00689352f, -0.04942819f, 0.03816110f, 0.02718533f, 0.03399495f, 0.02685452f, 0.04629137f, 
    0.01593116f, -0.05616476f, -0.01036809f, -0.04480981f, -0.06412763f, -0.04537640f, -0.04535859f, 0.00420313f, 
    -0.05592954f, 0.04648877f, 0.02645692f, 0.00584714f, 0.00301984f, -0.05433934f, -0.00201339f, 0.00932084f, 
    0.04252324f, -0.03711362f, -0.02673035f, 0.04506122f, -0.04512356f, -0.04006111f, -0.04649882f, -0.00594700f, 
    -0.03175496f, 0.00739418f, 0.03856805f, 0.03810212f, 0.03124117f, 0.02819833f, -0.01788885f, -0.04928954f, 
    0.00457806f, -0.02326283f, 0.02378313f, 0.00938499f, 0.04057895f, 0.00169638f, -0.04436840f, 0.01039201f, 
    -0.01784599f, 0.03564995f, -0.01602344f, -0.04165361f, -0.05515343f, -0.05532675f, -0.03477996f, -0.01053849f, 
    -0.00612255f, 0.00088182f, -0.00955260f, -0.02090735f, -0.03139807f, 0.00554917f, 0.03044662f, 0.04005807f, 
    0.01651665f, 0.03800734f, 0.04470255f, -0.02994959f, -0.02017720f, 0.03566130f, 0.00013616f, -0.03753298f, 
    0.01897092f, -0.00040867f, 0.02361614f, -0.01400878f, 0.01853377f, -0.01915816f, -0.03835458f, 0.04492227f, 
    0.01277375f, -0.01456143f, -0.02221373f, -0.05342568f, -0.01947130f, 0.03989286f, -0.04433588f, -0.05587020f, 
    0.03985536f, 0.03767203f, 0.00091573f, -0.03669489f, -0.03051885f, -0.00938790f, 0.01540463f, 0.03234223f, 
    -0.01878482f, 0.00628896f, -0.01918100f, 0.03728693f, -0.05915339f, -0.04781001f, 0.04163463f, -0.03719455f, 
    0.01898555f, 0.01248186f, 0.01591675f, -0.06403153f, -0.02868953f, -0.06391221f, -0.03390503f, -0.04689798f, 
    -0.03804671f, -0.04176782f, -0.06106981f, -0.05456085f, 0.04987359f, 0.02242353f, -0.05853742f, 0.03157999f, 
    -0.00561264f, 0.01066562f, -0.06133407f, 0.02591601f, 0.00152092f, 0.02016020f, 0.03201310f, 0.01773107f, 
    -0.03760643f, -0.05639563f, -0.04799581f, 0.01360190f, 0.01181226f, 0.02844293f, -0.04735267f, -0.03079704f, 
    0.04738612f, 0.04173499f, 0.00477348f, -0.05759713f, 0.04389302f, -0.00803827f, -0.01766737f, -0.04476101f, 
    0.03549499f, 0.03452578f, 0.00171125f, 0.01212281f, -0.06728166f, 0.02616802f, 0.02457883f, -0.01044961f, 
    -0.04713759f, -0.04997140f, 0.00903732f, 0.01041122f, -0.06590463f, -0.01412999f, 0.02246128f, -0.04742012f, 
    -0.06842362f, 0.01840146f, -0.03620838f, 0.01592293f, 0.03518261f, -0.02700022f, -0.06237340f, 0.03854775f, 
    -0.00619909f, 0.03245762f, 0.00692977f, -0.03850549f, -0.01174427f, -0.01922066f, -0.02563158f, 0.02830582f, 
    -0.04109957f, -0.06400756f, 0.01920062f, -0.02143202f, -0.02822430f, -0.03546131f, 0.03124237f, -0.00643086f, 
    -0.02600639f, -0.00339936f, -0.01400120f, -0.00205625f, -0.04165326f, 0.03995709f, -0.01327404f, 0.03385269f, 
    -0.01985455f, 0.02936663f, -0.00594642f, -0.02936577f, -0.03192101f, 0.02491664f, -0.02907053f, -0.04384458f, 
    0.00640696f, 0.02365695f, 0.01912854f, 0.03504380f, -0.03152130f, -0.05678265f, -0.02998761f, 0.03395301f, 
    -0.03984047f, -0.00281586f, -0.02285300f, -0.03477880f, -0.05254485f, 0.00036810f, -0.04652498f, -0.04978881f, 
    -0.02065520f, -0.03358633f, -0.05386329f, 0.02637346f, 0.04184040f, 0.02755762f, -0.05354904f, 0.00175678f, 
    0.00863256f, 0.02825597f, -0.05576172f, -0.03047304f, -0.01376955f, -0.04315500f, 0.02918351f, 0.02396590f, 
    -0.01701648f, -0.02022908f, -0.04110315f, -0.04270943f, -0.03698770f, -0.02723416f, -0.05907097f, -0.05378356f, 
    -0.00021331f, -0.01541402f, -0.03398950f, -0.03740037f, 0.01594319f, -0.01741739f, -0.05378890f, -0.00708973f, 
    0.04516932f, 0.02661107f, 0.02482942f, -0.04451127f, -0.03856396f, 0.01387953f, 0.02709540f, 0.02015247f, 
    0.02109339f, -0.02364727f, 0.01591769f, -0.06776699f, -0.01705671f, -0.04072501f, -0.00509718f, 0.02436158f, 
    0.04355520f, 0.01046327f, -0.02757354f, 0.00025158f, 0.02874284f, -0.01432663f, -0.04489418f, -0.05157479f, 
    0.02652866f, -0.01750272f, -0.04890991f, -0.01206102f, 0.02940546f, -0.02445377f, 0.04354848f, -0.03596210f, 
    -0.02124125f, 0.01222503f, -0.04380856f, 0.02925746f, 0.01589071f, -0.04392562f, -0.01756288f, -0.06528708f, 
    0.02162126f, 0.00875980f, 0.01643828f, 0.00457785f, -0.06259994f, -0.03411144f, -0.03732658f, 0.00139204f, 
    -0.01265982f, -0.03212879f, -0.03944336f, 0.00889160f, -0.01175626f, 0.03479952f, 0.02208799f, -0.03842189f, 
    -0.03894939f, -0.00043615f, 0.02327963f, -0.03577755f, -0.04202189f, -0.05119065f, -0.03161973f, -0.02464448f, 
    0.04506165f, 0.03880106f, 0.04485909f, -0.02936644f, 0.02322108f, -0.04356431f, 0.05467838f, -0.00902000f, 
    0.01027203f, 0.02397632f, 0.02145585f, -0.00233472f, -0.02003831f, 0.01775058f, -0.03499522f, 0.03833132f, 
    -0.04019093f, -0.06581586f, 0.04777507f, -0.00544438f, -0.04747976f, 0.00140772f, 0.00511081f, -0.00754758f, 
    0.03192287f, 0.02694394f, -0.05838839f, -0.04204638f, 0.04011769f, -0.04350464f, 0.03929249f, 0.00977228f, 
    -0.06409369f, -0.06531797f, -0.03515112f, 0.00206595f, -0.03692112f, 0.00736646f, -0.00101157f, -0.01701318f, 
    -0.04337085f, -0.00708275f, -0.01266584f, -0.03231942f, 0.00123773f, -0.05040924f, -0.03206721f, 0.01011344f, 
    -0.10744028f, -0.12514822f, 0.07278263f, 0.02015054f, 0.31347218f, 0.18204941f, -0.01173669f, -0.06770953f, 
    0.02007114f, 0.03932254f, -0.05784754f, 0.18103796f, 0.01114560f, 0.04462352f, 0.00794022f, 0.00067152f, 
    -0.02278453f, -0.03649541f, 0.01527319f, -0.09218643f, 0.25053814f, -0.00677580f, -0.33847782f, 0.01793602f, 
    0.14678538f, -0.19604041f, -0.04119383f, -0.38261664f, 0.26341888f, 0.00149540f, 0.03829361f, 0.03997540f, 
    -0.11423141f, 0.07924626f, 0.10900951f, 0.08336850f, -0.08219802f, 0.22495839f, 0.12377326f, 0.01519491f, 
    0.09981874f, 0.01130704f, 0.12084360f, -0.02155340f, 0.03056827f, -0.10551119f, 0.12289160f, -0.14090037f, 
    0.14234099f, 0.08311336f, 0.07679433f, -0.07995903f, -0.01750057f, -0.03716310f, 0.05625180f, -0.02548861f, 
    -0.06786180f, -0.03401262f, 0.18048854f, 0.13586761f, -0.69790429f, 0.47843876f, -0.19762404f, 0.00951750f, 
    -0.15807237f, 0.10211926f, 0.07856524f, -0.14928862f, -0.04952740f, -0.09136542f, 0.02567920f, -0.04545426f, 
    -0.09715442f, 0.08646939f, -0.23511702f, 0.09472432f, -0.18507597f, 0.09502617f, -0.13523108f, -0.23006287f, 
    0.00214761f, -0.18934083f, 0.84714967f, -0.31562781f, 0.36192086f, -0.13737018f, -0.08292167f, -0.57312685f, 
    0.19457595f, 0.05533269f, 0.15594669f, -0.01795087f, -0.14924067f, 0.02857047f, -0.13658063f, -0.01818975f, 
    0.00039949f, 0.02558641f, 0.02426002f, 0.04651919f, 0.32349193f, -0.22622822f, -0.21886201f, -0.02974655f, 
    0.26119384f, -0.05623886f, 0.03003985f, 0.02528880f, -0.19114162f, -0.16924033f, -0.03973116f, -0.05349888f, 
    0.05353430f, 0.02932561f, -0.02839092f, -0.03555965f, 0.04880254f, -0.16862497f, -0.12595184f, -0.18352529f, 
    -0.05939332f, 0.25737941f, -0.35528329f, 0.08484659f, -0.11110001f, -0.14911760f, 0.12291334f, -0.03603280f, 
    -0.04006265f, -0.29922026f, -0.09479736f, 0.02931011f, -0.02537901f, 0.10302076f, -0.06289565f, 0.09179718f, 
    -0.06044154f, 0.18597838f, -0.10300190f, -0.39572939f, -0.09671043f, 0.22323443f, 0.11211945f, -0.02215585f, 
    0.10570363f, 0.06893602f, 0.13554995f, 0.08270954f, -0.10871235f, -0.11305930f, -0.02551257f, -0.00908762f, 
    0.13775687f, 0.07193368f, 0.17037345f, -0.10476528f, 0.13346997f, 0.09462652f, 0.08557439f, 0.11506701f, 
    0.00002696f, -0.08816957f, -0.10142906f, -0.10756202f, -0.09156094f, 0.05195625f, -0.07137082f, 0.19719987f, 
    -0.08310667f, 0.07312915f, 0.02563530f, 0.02112433f, 0.02503981f, 0.21820387f, 0.10034240f, 0.02067085f, 
    0.06206147f, 0.18307145f, 0.12988858f, -0.11343218f, 0.08146751f, 0.53607827f, 0.00638791f, 0.17109647f, 
    -0.15635285f, -0.01996416f, 0.13805659f, -0.13787860f, -0.02112239f, 0.04524391f, 0.03575539f, 0.11339346f, 
    -0.01145536f, 0.00970057f, 0.05345549f, 0.02940651f, 0.14568938f, 0.27972022f, 0.00862487f, 0.05478496f, 
    0.04939708f, 0.33562922f, -0.42323577f, -0.03051859f, -0.20508599f, -0.03171496f, -0.02014693f, -0.06942685f, 
    0.07330623f, -0.06266744f, 0.11631451f, 0.02563188f, 0.02943472f, -0.01166851f, 0.02652289f, 0.20249014f, 
    0.04188080f, -0.14018156f, 0.08357171f, -0.00764325f, -0.03023048f, 0.16808426f, -0.17904864f, -0.05910457f, 
    -0.08477617f, 0.09178466f, 0.00996933f, 0.12333088f, -0.05612975f, -0.07145885f, 0.02359200f, 0.09008162f, 
    0.07253417f, 0.11169662f, 0.07023833f, -0.06330514f, -0.16926797f, -0.20245799f, -0.27294663f, -0.09552066f, 
    0.17856592f, 0.23443654f, 0.14306574f, -0.05577211f, 0.03235171f, 0.28971317f, 0.01263389f, 0.17614996f, 
    -0.17363967f, 0.04447334f, 0.08744980f, -0.03035561f, -0.00765239f, 0.08752283f, 0.04965594f, 0.22928154f, 
    0.02040159f, 0.01895590f, 0.00965405f, 0.20131122f, 0.21174645f, 0.15595639f, 0.07752767f, -0.02106859f, 
    0.05920443f, 0.21731286f, 0.14654677f, 0.06624223f, 0.03510375f, -0.04134992f, -0.02389954f, 0.02438108f, 
    0.00406146f, 0.06290030f, -0.01588192f, -0.03318986f, 0.00986931f, 0.08306260f, 0.03911773f, 0.15776737f, 
    -0.33759621f, 0.05686948f, -0.07168803f, -0.04252942f, 0.14303702f, 0.11687227f, -0.06826214f, 0.10867532f, 
    0.09650989f, -0.07573307f, -0.11499324f, 0.00252369f, -0.02119349f, -0.00839133f, 0.10930666f, -0.05014542f, 
    0.02221341f, 0.00491855f, -0.14945509f, -0.11056212f, 0.41506958f, 0.00642547f, -0.19579439f, -0.01152522f, 
    -0.03031687f, -0.02951209f, -0.02934024f, -0.09721540f, 0.03215282f, -0.09515203f, 0.09064354f, -0.13803445f, 
    0.06247659f, -0.14881553f, -0.09349906f, 0.08929452f, 0.01190567f, 0.21400546f, 0.17047410f, -0.05786556f, 
    0.04884088f, -0.08509426f, -0.25943884f, -0.10028019f, 0.07252321f, 0.01516929f, 0.01363345f, -0.14303815f, 
    -0.08973901f, 0.07681438f, 0.09230625f, -0.05055187f, 0.17748001f, 0.02911577f, 0.18611014f, 0.07955729f, 
    0.01587527f, -0.02053449f, 0.08311553f, -0.03543157f, 0.22620043f, -0.01900817f, -0.33495718f, -0.37116814f, 
    -0.01860108f, 0.03617710f, -0.07355069f, 0.10275934f, -0.08971191f, -0.08586848f, 0.05013692f, -0.07422987f, 
    -0.01137716f, 0.02754295f, -0.08265112f, 0.10910232f, 0.11289740f, -0.01889576f, 0.03751393f, -0.04241469f, 
    -0.34021410f, -0.07024126f, -0.04782366f, 0.11449273f, -0.04306647f, 0.08397910f, 0.00491538f, -0.03309264f, 
    -0.02192590f, 0.08955765f, -0.02569160f, 0.10465735f, -0.05167252f, 0.15090065f, 0.15850551f, 0.00246583f, 
    0.13479707f, 0.05510185f, -0.04386620f, 0.10172685f, -0.11268459f, -0.09102685f, -0.11986700f, -0.11363983f, 
    0.02061073f, 0.13559198f, -0.09555089f, -0.31152067f, 0.16808546f, -0.00922524f, 0.00285014f, -0.09823624f, 
    0.10029279f, 0.08059394f, 0.01157024f, 0.02886563f, 0.06215554f, -0.10551158f, -0.09704533f, -0.13413937f, 
    0.04823897f, -0.07384156f, -0.44346711f, 0.04961523f, 0.06441601f, 0.10143431f, 0.08489336f, 0.10792098f, 
    -0.24478519f, -0.01418384f, 0.00204671f, -0.15362659f, -0.01264192f, -0.09509224f, -0.06335302f, -0.01665279f, 
    0.07945160f, -0.10042559f, 0.15913278f, -0.10113510f, 0.00976446f, 0.02286745f, 0.10439102f, -0.05420724f, 
    -0.01630712f, -0.00903866f, -0.05771184f, 0.03026203f, -0.01436922f, -0.06452659f, 0.13399914f, 0.19938524f, 
    0.03197167f, -0.00436599f, 0.00284467f, 0.11509930f, -0.07366915f, -0.07158702f, 0.05404422f, -0.03890361f, 
    0.11011215f, -0.02781280f, 0.06323289f, -0.21391080f, -0.02405418f, -0.03378528f, -0.10983605f, 0.01805641f, 
    -0.01700670f, -0.09186832f, 0.20320934f, 0.05032991f, 0.01246866f, 0.08959820f, 0.02361858f, 0.17817448f, 
    0.06275341f, -0.05615392f, -0.02899344f, 0.04611822f, -0.18009150f, -0.09092348f, 0.52053702f, 0.32456401f, 
    0.10469884f, -0.09023450f, -0.21852523f, -0.12289625f, 0.02195753f, -0.01107970f, 0.30099818f, 0.02662557f, 
    0.01115476f, -0.08182439f, 0.08907355f, 0.19208136f, 0.15096706f, 0.02764725f, -0.00110665f, 0.05466996f, 
    0.21785505f, 0.13996308f, -0.03049227f, -0.07430802f, 0.06607384f, -0.12850355f, -0.06621698f, -0.18153729f, 
    0.09318333f, -0.07518611f, 0.07379337f, 0.05251168f, 0.07596390f, -0.09170434f, -0.13370889f, 0.16915929f, 
    0.04777897f, -0.08551788f, 0.00327547f, 0.15169585f, 0.32107145f, 0.09895035f, 0.17116940f, -0.17799419f, 
    0.05281373f, -0.03966868f, 0.08568282f, 0.01183072f, 0.01527226f, -0.03251993f, 0.19741473f, -0.04413687f, 
    0.12864780f, 0.09152884f, -0.01798709f, 0.04639478f, 0.07985797f, -0.18243742f, -0.05729204f, 0.05822474f, 
    -0.04599902f, -0.27815342f, 0.03821051f, -0.37887788f, -0.23188904f, 0.11689787f, 0.05812361f, 0.04487774f, 
    0.17519219f, 0.04961755f, 0.09252252f, -0.04095585f, -0.00216200f, 0.13383856f, 0.00840575f, 0.02049119f, 
    -0.02531011f, -0.09860013f, 0.05688377f, -0.23164791f, -0.08897356f, 0.08569813f, 0.13779987f, 0.07251398f, 
    0.06265017f, 0.04339552f, 0.05783566f, -0.11342675f, 0.03742654f, 0.12088962f, 0.14229591f, 0.02068246f, 
    0.08182011f, 0.09371220f, -0.00555263f, 0.04824817f, 0.01031791f, -0.02578478f, -0.05931358f, -0.15466811f, 
    -0.10176919f, -0.26967359f, 0.35034332f, 0.22460400f, -0.00173919f, -0.15728682f, -0.10047390f, -0.28343695f, 
    0.12290717f, -0.16325103f, 0.15882874f, -0.05370847f, 0.05027219f, -0.01061873f, -0.01949871f, -0.02528732f, 
    0.20393983f, -0.13155964f, 0.03003091f, -0.01759655f, -0.16581634f, -0.03949563f, 0.12737010f, 0.39012864f, 
    0.01700043f, -0.08000275f, -0.08405837f, -0.08475681f, 0.02802995f, 0.10924955f, 0.11119931f, 0.06017766f, 
    -0.01830750f, -0.01419627f, 0.04465899f, 0.05817185f, 0.19812511f, 0.10730337f, -0.11367779f, 0.02321943f, 
    0.21748900f, 0.08624811f, 0.22843221f, 0.22419621f, 0.00990747f, -0.27619216f, -0.10407387f, -0.03781812f, 
    -0.04114531f, -0.02657761f, 0.10823859f, -0.02575622f, 0.17681491f, 0.10008669f, 0.16693315f, 0.00120639f, 
    -0.02586660f, 0.07477690f, -0.00920927f, -0.07846791f, 0.14005587f, 0.04574543f, -0.07315756f, -0.23653370f, 
    -0.06195293f, -0.04817583f, -0.13456206f, 0.00344162f, -0.16853976f, 0.05638199f, -0.03997976f, 0.03753576f, 
    0.00755205f, 0.06561736f, -0.07355732f, 0.14034665f, 0.04264760f, 0.05169098f, 0.09756352f, 0.04135659f, 
    0.40146974f, 0.06212623f, 0.06955273f, -0.27258497f, 0.14457628f, -0.03058147f, 0.07798586f, -0.03868041f, 
    0.04006617f, 0.05431839f, -0.00631623f, 0.08905087f, 0.17155157f, 0.02109499f, -0.01487395f, -0.03081618f, 
    0.13197792f, -0.11147594f, 0.25020358f, 0.04042037f, -0.11444325f, 0.18654227f, 0.19284552f, -0.21799783f, 
    -0.30045074f, 0.01430366f, -0.02532943f, -0.01402744f, -0.01704213f, -0.05758306f, 0.07577115f, -0.10099842f, 
    -0.15223342f, 0.15027319f, -0.09661726f, 0.02939419f, 0.13541068f, -0.02467917f, -0.06186460f, -0.10027249f, 
    -0.21016052f, -0.45261684f, -0.38914928f, -0.14290345f, -0.05532510f, -0.03381597f, 0.01689344f, 0.00606484f, 
    -0.00730834f, -0.30069321f, -0.00804630f, 0.01110324f, 0.02546332f, -0.07924928f, 0.08301503f, 0.04682288f, 
    -0.05735593f, 0.18640777f, 0.00133174f, 0.03407023f, 0.15970349f, -0.12608296f, -0.46216553f, -0.03426016f, 
    -0.00304779f, 0.07633175f, 0.13676511f, -0.24600554f, 0.09898905f, -0.07955537f, 0.00133748f, -0.10486738f, 
    0.03925548f, 0.13549769f, 0.03345961f, -0.15035766f, 0.18907797f, 0.12428961f, 0.21513128f, -0.06216848f, 
    -0.00914946f, -0.35332111f, 0.10765053f, -0.54082978f, -0.02603687f, -0.17011155f, -0.13134892f, -0.07890225f, 
    0.01190812f, -0.16531897f, -0.08826856f, -0.15863682f, -0.07777000f, 0.00671927f, -0.06817363f, -0.12318906f, 
    0.01375778f, -0.00127566f, 0.05443927f, -0.09002539f, -0.07673024f, 0.01219567f, 0.06180348f, -0.19816160f, 
    -0.18241483f, -0.10072690f, -0.02711381f, -0.00128736f, -0.01529568f, 0.00656219f, 0.04795660f, 0.05813279f, 
    0.06704541f, 0.11989795f, 0.03413460f, -0.06554203f, -0.01200619f, -0.13488522f, 0.08521672f, -0.05372752f, 
    -0.11558176f, 0.03428354f, 0.08429559f, -0.16295746f, -0.20650028f, -0.05239662f, -0.08796991f, -0.04892343f, 
    -0.10224953f, -0.05071717f, 0.14670029f, 0.06240201f, 0.07011620f, 0.13477752f, 0.04802528f, -0.12313355f, 
    -0.04776533f, -0.06891914f, -0.06507818f, -0.05013047f, 0.19742319f, 0.16360046f, 0.03788809f, 0.04512973f, 
    0.28973094f, 0.03822622f, -0.07802688f, 0.05162906f, 0.05555575f, 0.15731874f, 0.05894820f, 0.10051212f, 
    0.16728593f, 0.16855235f, 0.12331501f, 0.14682212f, 0.02956417f, -0.17366557f, 0.09636887f, -0.03736320f, 
    -0.02979571f, 0.07597578f, 0.02217757f, -0.11241614f, -0.15889210f, -0.06952012f, -0.03730088f, -0.06918844f, 
    -0.04898238f, 0.03601146f, 0.14660154f, 0.08152872f, 0.19979650f, 0.12695216f, 0.11862285f, -0.02479499f, 
    0.02514853f, -0.16688965f, -0.09529779f, -0.08156011f, 0.28935242f, 0.77235770f, -0.09448572f, 0.06204622f, 
    0.40258354f, 0.08482816f, 0.04191753f, 0.06442422f, -0.01522831f, 0.30368680f, 0.22313985f, 0.12173949f, 
    0.22994091f, 0.16219068f, 0.13080481f, 0.09497181f, 0.11423358f, 0.16622669f, 0.07879189f, 0.14717980f, 
    -0.18683040f, 0.00356581f, -0.23490942f, -0.10297172f, 0.04679103f, -0.02330042f, 0.09107552f, -0.15440041f, 
    0.24165781f, -0.02811814f, 0.09551924f, 0.16444142f, 0.09541069f, 0.02322573f, -0.00340443f, 0.11309610f, 
    -0.01245806f, 0.05165933f, 0.12492320f, 0.08146313f, -0.36415017f, -0.08026212f, -0.42493019f, -0.08160464f, 
    0.08382044f, -0.09860271f, 0.07979700f, -0.06096100f, -0.02695316f, -0.04884686f, 0.01404882f, -0.05774274f, 
    -0.00257726f, 0.07184132f, -0.03519750f, -0.01245497f, -0.03107696f, 0.16807228f, -0.02912814f, 0.05822807f, 
    0.00724541f, -0.03968828f, -0.14709619f, -0.05644977f, -0.02124118f, 0.02067125f, -0.22940065f, 0.08776860f, 
    0.13702624f, 0.02621162f, 0.03670826f, -0.00777498f, -0.11944651f, 0.01949747f, 0.00311256f, -0.00638864f, 
    -0.13781345f, 0.06526355f, 0.09598666f, 0.00352744f, -0.11844492f, -0.23980878f, -0.18237048f, -0.02532240f, 
    -0.01957777f, 0.05617748f, 0.00420030f, 0.00481213f, 0.07159962f, -0.02950319f, -0.03660087f, -0.04181852f, 
    -0.07703338f, 0.08647826f, 0.07219078f, 0.00229083f, -0.01281412f, 0.13220643f, 0.11157798f, 0.07605396f, 
    -0.27343574f, 0.23485979f, 0.03188494f, -0.08629031f, 0.10353207f, -0.07718322f, 0.04716824f, 0.12632518f, 
    -0.02647442f, 0.11575688f, -0.04647209f, 0.06767547f, -0.08097976f, 0.04773118f, -0.01414684f, -0.00238976f, 
    0.03561360f, -0.08703490f, -0.05431773f, -0.03352122f, -0.20777218f, 0.16164644f, 0.26477852f, 0.00948502f, 
    0.17932451f, -0.08881433f, -0.01537708f, -0.02075177f, -0.16319931f, -0.00042716f, -0.04323452f, -0.08573285f, 
    0.15870297f, -0.07179415f, -0.04060465f, 0.09493288f, -0.05132569f, -0.24394965f, -0.06624221f, 0.02051917f, 
    0.00280737f, -0.01657317f, 0.02281565f, 0.01096145f, -0.00703564f, 0.02003977f, -0.04744658f, -0.06369270f, 
    -0.03232493f, 0.04117380f, 0.00461761f, 0.00262232f, 0.03445420f, 0.03364703f, -0.05473604f, 0.01816035f, 
    0.01005795f, 0.02927846f, -0.02181017f, -0.04067054f, -0.04745632f, -0.05281288f, 0.04484060f, -0.05226946f, 
    -0.03545303f, -0.03496910f, 0.01913250f, 0.03946840f, -0.04190334f, 0.02422561f, -0.05338147f, 0.03424828f, 
    0.03127753f, 0.03739274f, -0.00709972f, 0.04007623f, -0.01659968f, -0.01945190f, -0.03633389f, 0.04600431f, 
    0.03885853f, -0.00158326f, -0.02078030f, -0.05172613f, 0.03582820f, 0.04527621f, 0.05452566f, -0.04588782f, 
    -0.05578458f, -0.04600572f, 0.05424504f, 0.01948185f, -0.03362465f, -0.03353649f, -0.05679336f, 0.00794174f, 
    0.03817577f, 0.02226339f, 0.02838330f, 0.00270408f, -0.01713190f, -0.02185948f, -0.01407454f, -0.00341154f, 
    -0.00896371f, 0.00888934f, -0.00212874f, 0.02494374f, -0.01643706f, -0.02884954f, 0.01508901f, -0.05714219f, 
    -0.02454647f, -0.04888111f, -0.00868577f, 0.00830192f, 0.00299030f, -0.04240161f, 0.02525963f, -0.03735853f, 
    -0.00921123f, 0.00326774f, -0.03896081f, 0.01508950f, 0.01000040f, -0.04929280f, -0.03179410f, -0.03825400f, 
    -0.04986760f, 0.00992425f, 0.03235739f, -0.02475324f, -0.04016588f, 0.00767839f, -0.01152507f, 0.02185610f, 
    -0.04073380f, 0.01346535f, -0.03285623f, -0.02382296f, -0.05479595f, 0.04509807f, 0.03477557f, 0.03342610f, 
    -0.01754468f, 0.02244086f, -0.03494927f, 0.02465306f, -0.00260927f, -0.01038522f, 0.02557912f, -0.05051519f, 
    -0.05808127f, -0.01906040f, -0.02090988f, 0.01181452f, 0.04993527f, -0.05899173f, -0.01929785f, 0.03123026f, 
    -0.05499743f, -0.01862845f, -0.04965772f, -0.03278584f, -0.01714002f, -0.05252083f, -0.06245575f, -0.00587446f, 
    0.00996447f, 0.02705388f, 0.02795730f, -0.01539868f, 0.01253422f, -0.01249656f, -0.01375535f, -0.03822111f, 
    -0.04276988f, -0.00798769f, 0.00500200f, 0.03705946f, -0.02805165f, 0.03250713f, -0.05738461f, -0.01349334f, 
    -0.03070988f, 0.00759972f, -0.06267254f, 0.04416415f, 0.02650408f, -0.04985018f, 0.04577448f, -0.03091079f, 
    -0.01813760f, -0.01741216f, -0.00012547f, 0.03940430f, 0.00116199f, 0.01830938f, 0.00547424f, 0.00629657f, 
    0.01352765f, 0.02528898f, -0.02919417f, -0.04850706f, -0.03813543f, 0.03164999f, 0.04232282f, 0.02115760f, 
    -0.04014489f, -0.04834520f, -0.04853698f, -0.01420092f, 0.02622177f, 0.02403700f, -0.02752260f, -0.01661393f, 
    -0.03092417f, -0.03245089f, 0.02937267f, -0.01349790f, 0.03994635f, -0.04684984f, -0.06256432f, -0.00792090f, 
    0.00871891f, -0.03645335f, 0.04004674f, -0.05289078f, -0.05029299f, -0.02143603f, -0.01902441f, 0.03542064f, 
    0.03564460f, -0.02503174f, -0.00134381f, -0.02933618f, -0.02756678f, 0.04220760f, -0.00797518f, 0.01311364f, 
    -0.01474914f, -0.06118726f, -0.05828470f, 0.04120087f, 0.01270173f, -0.05850276f, 0.04258044f, -0.03545319f, 
    0.00545337f, -0.04793707f, 0.04996497f, -0.03169459f, -0.03045495f, 0.03235172f, 0.03710035f, 0.00674552f, 
    0.02658851f, -0.05624745f, 0.01765228f, 0.01362937f, 0.03272158f, 0.02391286f, 0.03356590f, 0.04667808f, 
    0.04471022f, 0.01459002f, -0.02568833f, 0.04497825f, -0.04008681f, -0.00012331f, -0.04136579f, 0.03106055f, 
    -0.02458693f, -0.05431744f, -0.02411568f, 0.02586499f, -0.05144984f, -0.04266023f, -0.03202463f, -0.04664443f, 
    0.02502749f, -0.02485620f, 0.00580670f, 0.01156642f, -0.00876185f, -0.03248836f, -0.04934432f, -0.02756720f, 
    0.00882726f, -0.00070720f, -0.02416610f, -0.02391190f, -0.04546873f, -0.02043353f, 0.02095729f, -0.04511249f, 
    -0.01910711f, -0.03169007f, -0.02127543f, -0.05063364f, -0.04404901f, -0.02166935f, 0.00873093f, 0.02126182f, 
    0.04677662f, -0.03026883f, -0.00802448f, 0.02823137f, -0.01963099f, 0.00308306f, -0.03701472f, 0.01585793f, 
    -0.05680972f, -0.02023457f, -0.06417365f, 0.04137165f, 0.02900516f, -0.02845871f, 0.01249893f, 0.03483067f, 
    0.02833697f, 0.00504718f, -0.00749067f, -0.05539537f, 0.00304721f, 0.04128328f, -0.04256270f, -0.05063184f, 
    -0.05532975f, -0.04284359f, -0.04639285f, -0.02157133f, 0.02997636f, 0.03373958f, -0.04431826f, -0.05328102f, 
    0.04600077f, -0.02092340f, 0.01707377f, 0.04384022f, 0.00833512f, -0.05303176f, -0.02491578f, 0.00448022f, 
    0.03302607f, 0.04143773f, -0.05157904f, -0.04381720f, 0.04435387f, -0.04401497f, 0.01519297f, 0.00426324f, 
    -0.01690320f, -0.00276564f, -0.04022006f, 0.01683615f, -0.05819165f, -0.05535601f, 0.00810797f, 0.01436696f, 
    0.27032816f, 0.14311269f, -0.08752094f, 0.05735986f, -0.21998692f, 0.09038284f, -0.04467507f, 0.04951783f, 
    0.07160792f, -0.17457062f, -0.24547759f, 0.13231570f, 0.02540321f, 0.06037219f, 0.10040040f, 0.08396616f, 
    0.09814221f, 0.16273929f, 0.08688667f, 0.05533041f, -0.06351052f, 0.27891564f, 0.42429844f, 0.29020321f, 
    -0.02181410f, -0.05344272f, 0.00557686f, -0.05338338f, 0.02611037f, -0.09872864f, 0.00220099f, 0.08399738f, 
    0.13675250f, 0.05047812f, 0.05466292f, -0.04021768f, -0.07049264f, 0.22113118f, -0.06491821f, -0.04616234f, 
    0.12840079f, -0.14726642f, -0.00285910f, 0.29548609f, 0.36998886f, 0.11111014f, -0.03978716f, 0.11792021f, 
    0.02224388f, 0.07820519f, 0.03873238f, 0.02827100f, -0.11698781f, -0.02189501f, -0.00302335f, 0.05097572f, 
    0.05555626f, -0.00109820f, -0.26314753f, -0.23607528f, 0.08194410f, 0.14267248f, 0.06366353f, 0.17018822f, 
    0.04135511f, 0.24779157f, -0.03778733f, 0.20304987f, 0.27960080f, -0.10797079f, 0.10768430f, -0.01286352f, 
    -0.11378822f, 0.05766529f, 0.11085977f, -0.10647945f, 0.09161471f, 0.22788846f, 0.42550164f, 0.14112239f, 
    -0.13132375f, 0.28876269f, 0.39364061f, 0.19727586f, 0.05713909f, 0.15202373f, -0.15977545f, -0.34825760f, 
    0.08540881f, -0.07496399f, 0.04851311f, 0.01985238f, 0.03430627f, 0.00308622f, 0.02700906f, -0.28806251f, 
    -0.17164966f, 0.24113168f, 0.02453400f, 0.08615609f, 0.00592955f, 0.04143202f, -0.08345705f, 0.07432264f, 
    -0.19353762f, -0.03374927f, 0.11781647f, 0.01400075f, -0.03955488f, -0.09367147f, -0.06176420f, -0.19809811f, 
    0.04642629f, 0.02429696f, 0.08591422f, -0.10473745f, 0.11616120f, 0.01852309f, 0.08500846f, 0.00675038f, 
    -0.08138341f, 0.05813847f, -0.01763605f, -0.02925537f, 0.01213280f, 0.04779475f, 0.06987720f, 0.00634038f, 
    -0.08110916f, -0.03439829f, 0.30811313f, -0.09531453f, 0.01026912f, 0.19713023f, 0.00348491f, -0.11443655f, 
    0.07791633f, -0.02390670f, 0.10927067f, -0.00401611f, 0.68062472f, 0.19408268f, -0.64168173f, -0.23553890f, 
    -0.14443195f, 0.16972642f, 0.18578766f, 0.03436304f, 0.10577621f, -0.00521513f, -0.18729706f, 0.00664712f, 
    -0.26845974f, 0.07982472f, -0.07326913f, -0.10609218f, -0.15652020f, -0.06038170f, 0.01588757f, 0.00447848f, 
    -0.07374875f, -0.00286085f, 0.24918163f, -0.01220673f, -0.15932818f, 0.05735877f, 0.02220668f, 0.04328030f, 
    -0.00895421f, -0.03782246f, 0.07628697f, -0.10624994f, -0.08567742f, 0.01404155f, -0.02575877f, -0.09708347f, 
    -0.08115844f, -0.09730466f, 0.06488398f, -0.18909451f, -0.00550377f, -0.11769298f, 0.00506929f, -0.07145387f, 
    0.09865700f, 0.18110159f, 0.09351472f, 0.24397731f, -0.26013228f, 0.04318215f, -0.11861864f, -0.18975514f, 
    -0.14275341f, 0.20478226f, 0.13189499f, -0.05694710f, -0.09361853f, 0.15519670f, -0.11141804f, -0.04887689f, 
    -0.15437356f, -0.10338674f, -0.06003945f, 0.14844275f, 0.24473724f, 0.00256653f, 0.13558222f, 0.33318835f, 
    0.08994021f, 0.22471970f, 0.04487925f, 0.09401657f, 0.03498243f, 0.09401026f, 0.01790929f, 0.02598880f, 
    0.06632273f, 0.07869093f, 0.05477110f, 0.17306387f, -0.04353603f, -0.27574328f, -0.24455322f, 0.06095381f, 
    -0.05317272f, 0.21189563f, -0.05780142f, 0.42894042f, 0.15837312f, 0.19614978f, 0.08784495f, 0.07865319f, 
    0.00446742f, 0.02761413f, -0.08371697f, 0.05950524f, 0.09840088f, 0.07807790f, 0.07182810f, 0.18775001f, 
    -0.18878582f, 0.20011239f, -0.07321230f, -0.02394957f, 0.32661188f, -0.02991046f, -0.09286863f, 0.08700741f, 
    -0.02066714f, 0.05579413f, -0.00742360f, -0.03865259f, -0.08254527f, -0.07905635f, 0.09045007f, 0.08788171f, 
    0.00465567f, 0.30171302f, -0.04740659f, 0.17030685f, 0.07031388f, -0.06061693f, -0.02273940f, -0.01935087f, 
    0.20722018f, 0.16637377f, 0.07324052f, 0.09375119f, 0.19522451f, 0.03030019f, -0.04652170f, 0.10324901f, 
    -0.04120204f, 0.00520666f, 0.06834058f, 0.03790938f, -0.00119572f, -0.04566250f, 0.03277195f, 0.15972231f, 
    0.28430513f, -0.24233763f, -0.37561414f, -0.20439604f, -0.12025026f, 0.10394677f, 0.11015215f, 0.02905740f, 
    0.07745180f, 0.17008999f, 0.08349818f, -0.00032112f, -0.07132396f, -0.07998597f, -0.10856850f, -0.03297448f, 
    0.06174170f, -0.04203907f, 0.07492296f, 0.02188499f, 0.02406397f, -0.00771163f, 0.17690492f, 0.25130472f, 
    -0.03019944f, -0.00640714f, 0.07709125f, 0.06937077f, -0.04327799f, -0.04449101f, 0.09619014f, -0.08575119f, 
    0.26055750f, 0.10065549f, 0.14724769f, 0.06679098f, -0.01820610f, 0.01983354f, -0.10114732f, -0.11631123f, 
    0.48099759f, 0.01288565f, 0.00642190f, -0.20945029f, 0.08572219f, 0.06299913f, 0.10185400f, -0.07356088f, 
    -0.01372105f, 0.00790605f, 0.07174763f, -0.08293213f, 0.11997559f, 0.11492953f, 0.08535778f, -0.00112318f, 
    -0.00205624f, -0.12553015f, 0.10069235f, 0.15030158f, 0.38958752f, 0.06010486f, 0.27934882f, 0.10951243f, 
    -0.07838719f, -0.01128088f, -0.04283705f, -0.03315824f, 0.03017744f, -0.08374017f, -0.07845297f, -0.01460060f, 
    -0.03889417f, 0.12839074f, 0.05441206f, -0.08987372f, -0.00446483f, 0.25715056f, -0.01082567f, -0.04005628f, 
    -0.35472161f, -0.18547323f, -0.25563061f, 0.22372320f, 0.18341337f, 0.18624935f, -0.06521436f, -0.15292855f, 
    -0.15627638f, 0.00172524f, -0.14952831f, -0.05087023f, 0.01773298f, 0.00447821f, 0.11114945f, 0.05414346f, 
    -0.02799591f, -0.04557507f, -0.03313348f, -0.00721517f, -0.25840324f, 0.22978316f, -0.07110867f, 0.29232618f, 
    0.11302053f, -0.04764751f, -0.07263455f, 0.01606986f, 0.14382035f, -0.00031721f, -0.08887146f, -0.10705402f, 
    -0.03092399f, 0.11988117f, -0.07989840f, 0.08146326f, -0.06038971f, 0.10740527f, -0.05140679f, 0.01153267f, 
    0.42879608f, 0.00190547f, 0.62251616f, -0.21253435f, 0.05547261f, 0.01529200f, -0.07549553f, -0.30452758f, 
    -0.03325773f, 0.00903885f, -0.13374990f, -0.03906352f, 0.05202635f, 0.05293465f, -0.09099343f, -0.04524060f, 
    -0.07009475f, -0.21011218f, 0.03591295f, 0.13970710f, 0.03902728f, -0.04576449f, 0.03479934f, -0.08375136f, 
    -0.11063045f, -0.05541078f, -0.05331973f, 0.01398749f, 0.00648235f, -0.05006294f, 0.06628913f, 0.03258270f, 
    -0.00973829f, -0.06939873f, 0.13341063f, -0.03708965f, -0.12111762f, -0.09496695f, -0.02577652f, -0.18080917f, 
    0.22628734f, 0.05485762f, 0.05302842f, 0.12367756f, -0.21248314f, -0.10681242f, -0.04006723f, 0.05055173f, 
    0.05840511f, -0.09528513f, -0.06955367f, 0.05662492f, -0.12547177f, 0.21032934f, -0.06787547f, -0.10066181f, 
    -0.02341118f, 0.15632217f, -0.03465946f, -0.08004642f, 0.12513223f, -0.27310759f, 0.40227655f, 0.01651377f, 
    0.10539166f, 0.10840040f, 0.19186686f, 0.07444832f, 0.03178261f, -0.18196474f, 0.02065574f, 0.14377424f, 
    -0.00058972f, -0.09048872f, 0.04868480f, 0.12706545f, -0.05061685f, -0.07101137f, -0.03635233f, -0.00820082f, 
    0.00180589f, -0.25904107f, -0.00004077f, 0.11524750f, -0.10069017f, 0.02418216f, -0.09231354f, 0.07931218f, 
    -0.06153748f, -0.06196933f, -0.03590566f, 0.16484806f, 0.11293316f, 0.03543593f, -0.08961997f, 0.06777828f, 
    -0.10114788f, -0.09930113f, 0.08738070f, -0.09708845f, 0.12502964f, 0.56119192f, 0.28623107f, 0.46855715f, 
    0.08673019f, -0.03125868f, 0.25362086f, 0.16614170f, 0.03887499f, -0.01993948f, -0.03079438f, -0.05942468f, 
    0.04303990f, 0.14804906f, 0.10009073f, -0.05764171f, 0.09228127f, 0.02999145f, -0.02314512f, 0.07509356f, 
    -0.04963814f, -0.43968832f, -0.20631666f, 0.36197504f, -0.02371504f, -0.09471248f, 0.13254251f, 0.10284144f, 
    0.18920493f, -0.12811442f, 0.04390668f, 0.00038636f, 0.12299810f, -0.01356692f, 0.05959393f, -0.00055737f, 
    -0.04918396f, -0.06860650f, 0.16976567f, 0.04354348f, -0.32822320f, -0.30994454f, -0.29869077f, 0.19250832f, 
    0.27650610f, -0.03884278f, 0.20697917f, 0.05320968f, -0.01600226f, -0.08713055f, 0.11523800f, 0.00530466f, 
    0.04622516f, -0.00266736f, 0.09075122f, 0.02873511f, 0.01126464f, -0.02132344f, -0.02294721f, 0.02242978f, 
    0.07938951f, 0.11515769f, 0.26926365f, 0.40822875f, 0.18494135f, -0.04594540f, -0.08045415f, -0.02135303f, 
    0.04775368f, -0.06041219f, 0.12015397f, 0.06864002f, 0.06394647f, -0.04730340f, 0.06737050f, 0.04257165f, 
    -0.05252862f, -0.08807442f, 0.06226557f, 0.12252941f, -0.06943143f, 0.04004278f, -0.03091224f, 0.37560144f, 
    0.24124752f, -0.04979681f, -0.22315383f, -0.13178055f, -0.03022524f, 0.04290123f, -0.04430071f, 0.08622639f, 
    0.04889508f, -0.08506866f, -0.00834658f, -0.01634009f, 0.09132231f, 0.08022227f, -0.07439128f, 0.12719032f, 
    -0.01451770f, -0.21723260f, -0.09742170f, 0.01989458f, -0.01989899f, -0.07119510f, 0.04304173f, 0.07324628f, 
    0.01702954f, -0.08046246f, -0.12716718f, 0.05677427f, 0.02681505f, -0.10268208f, 0.06558538f, -0.00421821f, 
    -0.07604846f, 0.01634540f, -0.11563747f, -0.08414961f, 0.37835470f, 0.07423241f, 0.07989124f, 0.16349521f, 
    -0.14660609f, -0.04415817f, -0.06325908f, -0.06545745f, -0.02871091f, -0.05481915f, -0.17743601f, -0.08495262f, 
    0.13380173f, -0.07033389f, -0.07036370f, 0.07144810f, -0.04298737f, -0.10399672f, -0.03270281f, -0.14911550f, 
    -0.10968599f, -0.20888221f, -0.10700399f, 0.06353476f, -0.15369387f, 0.14072178f, -0.20212372f, 0.03610351f, 
    -0.02088281f, 0.08858014f, 0.06172176f, -0.09447022f, -0.05748279f, -0.03549842f, 0.08883986f, 0.06780294f, 
    -0.06994054f, 0.04574429f, -0.18721516f, 0.05622636f, -0.06644158f, -0.34703246f, -0.01330586f, 0.05090310f, 
    -0.18685310f, 0.02553239f, -0.08072854f, -0.10228036f, 0.03156418f, 0.08396143f, 0.07661732f, 0.11086299f, 
    0.16930707f, -0.01182396f, 0.02790424f, -0.07860423f, -0.12512569f, -0.12384130f, 0.05372224f, -0.09906433f, 
    0.01925104f, 0.33093813f, 0.38955882f, 0.25025874f, -0.01065270f, 0.05689700f, 0.28495973f, 0.02610944f, 
    0.09526999f, 0.31142458f, -0.02084928f, -0.03315330f, -0.06315874f, 0.01637149f, -0.08836193f, -0.07461467f, 
    0.05566997f, -0.06690340f, -0.08041962f, -0.01579329f, -0.28289536f, 0.13263248f, 0.35100162f, -0.30434433f, 
    0.01105386f, -0.05090251f, 0.04141541f, 0.22264661f, -0.15101013f, 0.08184817f, -0.00315074f, 0.09410406f, 
    -0.06559861f, 0.05502072f, -0.02401204f, 0.03042749f, -0.07350347f, -0.00527544f, -0.12221316f, 0.01884618f, 
    -0.51878232f, -0.39629626f, -0.12775803f, 0.22754611f, 0.19888379f, 0.15371864f, -0.13950506f, -0.17029357f, 
    -0.17291358f, 0.18772526f, 0.12644577f, 0.11419009f, 0.11335168f, 0.09642553f, 0.12103767f, -0.05773187f, 
    -0.02225877f, 0.02511566f, -0.22866397f, -0.21278539f, 0.03600792f, -0.28684461f, -0.30653343f, -0.01030694f, 
    -0.07314764f, 0.09299948f, -0.09896018f, 0.01549246f, -0.02400483f, 0.04932079f, -0.02838459f, -0.07951672f, 
    -0.09270763f, -0.05610334f, 0.02611831f, -0.02677433f, 0.05967523f, 0.00947235f, -0.06781659f, -0.00663867f, 
    -0.06292240f, -0.16406140f, -0.36579567f, -0.14256404f, -0.07724451f, 0.04213021f, 0.04760540f, -0.06373917f, 
    0.00460359f, -0.01091660f, 0.04527252f, 0.05077443f, -0.06388187f, -0.11061554f, 0.03506757f, 0.01442933f, 
    0.06332455f, -0.00152291f, 0.07464602f, -0.01141823f, 0.06830382f, 0.07438274f, 0.15309632f, -0.03146533f, 
    -0.09119838f, 0.18194261f, 0.10003641f, 0.08130226f, 0.20107874f, -0.00877450f, -0.22664815f, 0.03963511f, 
    -0.04139825f, 0.04242588f, 0.14241429f, -0.07011196f, -0.07335145f, 0.01016983f, -0.12793511f, 0.04410213f, 
    0.05087708f, -0.20860443f, -0.09044137f, -0.24753928f, -0.12903094f, 0.05889925f, -0.09836867f, 0.11131695f, 
    -0.01351929f, 0.06240600f, -0.07308810f, 0.11430987f, -0.04963843f, 0.01646449f, 0.02695321f, -0.10956936f, 
    -0.18684228f, -0.00665757f, 0.06825344f, -0.03605729f, -0.11832572f, 0.08846185f, -0.08282900f, -0.13195628f, 
    0.07146551f, -0.11446408f, 0.01585542f, -0.01559346f, 0.01181112f, -0.11147506f, -0.10293088f, -0.17132591f, 
    -0.01953621f, -0.03586971f, -0.01877019f, -0.07270481f, -0.10926707f, -0.14471371f, -0.02851031f, 0.08961361f, 
    0.35817489f, 0.17866649f, 0.16669679f, 0.21981765f, -0.07513237f, 0.18565229f, 0.17494246f, 0.31650415f, 
    -0.07803658f, 0.03666017f, -0.02987970f, -0.01751541f, 0.03691711f, -0.01271722f, -0.01114349f, -0.01653740f, 
    -0.03046371f, 0.02255569f, 0.02871245f, 0.05698983f, 0.34619018f, 0.23422517f, 0.21844147f, 0.16509585f, 
    0.10329290f, 0.20055093f, 0.26427609f, 0.23494740f, -0.05050338f, 0.12836957f, 0.09922352f, 0.03542050f, 
    0.00747941f, -0.05855090f, -0.00920999f, 0.09528249f, 0.00446447f, -0.11017662f, -0.05590237f, 0.21384251f, 
    0.08057007f, 0.17998110f, 0.50703585f, 0.10348213f, 0.16897641f, -0.00179831f, 0.06185144f, 0.04171658f, 
    -0.04952639f, -0.03675438f, -0.06805042f, -0.05160606f, -0.00840640f, -0.03928616f, -0.11323390f, -0.00993291f, 
    0.07011528f, 0.01804143f, 0.03070622f, -0.05683315f, 0.27026662f, 0.43780228f, 0.26937824f, 0.13424240f, 
    0.23639874f, -0.06526233f, 0.15822446f, -0.11323317f, 0.15600859f, -0.03432328f, 0.01903879f, -0.06887170f, 
    0.00826086f, 0.01412378f, 0.03836231f, -0.02922243f, 0.01694207f, -0.06685773f, 0.03981042f, 0.17658776f, 
    0.12705676f, -0.00000036f, 0.02224745f, 0.07853834f, 0.29369223f, 0.16677408f, 0.03335910f, 0.09282008f, 
    0.17580663f, -0.11561275f, -0.01199542f, 0.03299972f, -0.04453640f, -0.05740165f, -0.06992185f, -0.03514798f, 
    -0.05488445f, 0.10749309f, -0.00173796f, -0.01662982f, 0.10047831f, -0.13943732f, -0.35071686f, -0.20408458f, 
    -0.25295728f, 0.08513398f, -0.00394958f, -0.07159900f, 0.07308026f, 0.01714848f, 0.16167472f, 0.09030639f, 
    0.03815496f, 0.18669738f, 0.15802921f, -0.10782009f, -0.03824282f, 0.04633638f, 0.08827092f, -0.01159895f, 
    -0.10535629f, 0.27481562f, -0.45512784f, 0.16766745f, -0.09277100f, 0.14758448f, 0.07937153f, 0.03347803f, 
    -0.06019395f, 0.05292662f, 0.08794004f, 0.03101349f, 0.05971196f, -0.04547109f, 0.08307321f, 0.13231207f, 
    0.07026584f, 0.00668671f, 0.05478963f, -0.05261148f, -0.16221035f, -0.01227558f, -0.09479894f, 0.15058780f, 
    0.11413161f, -0.04765822f, 0.04490975f, -0.16524884f, -0.21868686f, 0.15743083f, 0.15261690f, -0.03467070f, 
    0.05439600f, 0.09800364f, -0.10456064f, 0.26584861f, 0.00491412f, 0.01022726f, 0.05707548f, 0.08307742f, 
    0.21452904f, -0.18712512f, 0.13589391f, 0.27774444f, 0.34095031f, -0.01459368f, 0.04628190f, 0.12448180f, 
    0.24377309f, 0.00837668f, -0.00053850f, 0.01653615f, 0.02063388f, -0.11354317f, -0.16091755f, 0.08591980f, 
    0.07520603f, 0.05066961f, 0.15297683f, -0.02856348f, 0.32200527f, -0.21018206f, 0.02645635f, 0.46151987f, 
    -0.28077281f, 0.08419330f, 0.09042658f, 0.22241458f, -0.17512120f, -0.13956951f, 0.07652546f, 0.05454877f, 
    0.04859836f, -0.18278998f, 0.17832334f, -0.04722470f, 0.12301698f, 0.02402100f, -0.02224421f, -0.05739434f, 
    0.27416256f, 0.23304069f, -0.08961230f, 0.20547011f, -0.01508384f, 0.03077434f, 0.24863948f, 0.00489040f, 
    0.02155095f, -0.00190440f, -0.03821290f, -0.02904173f, -0.03143376f, -0.17788325f, 0.10191184f, 0.06390321f, 
    0.04229731f, 0.14078093f, -0.09963607f, -0.07408584f, -0.20702237f, 0.16835164f, -0.35529390f, 0.05516519f, 
    0.09900706f, 0.14883721f, -0.01999802f, -0.09612229f, -0.00515721f, -0.08785961f, -0.04654889f, 0.03668507f, 
    -0.02513822f, 0.13856229f, 0.13515241f, -0.03527326f, -0.02300161f, 0.00321417f, -0.10745301f, 0.06049220f, 
    -0.42465836f, -0.00802276f, 0.00962732f, -0.09587981f, -0.06443203f, 0.01339658f, 0.17650527f, -0.03304623f, 
    -0.20986724f, 0.04301254f, 0.05642316f, -0.08251622f, 0.15385400f, -0.04240022f, 0.02312879f, 0.12375076f, 
    0.08768043f, -0.14239413f, -0.26975715f, -0.18700506f, -0.33027065f, 0.32073030f, -0.19969022f, 0.07200275f, 
    0.08253599f, 0.02637317f, -0.06021597f, -0.15869212f, -0.03719960f, 0.17536204f, -0.05465745f, -0.08715079f, 
    0.15558583f, 0.23776898f, 0.05300573f, -0.15888779f, -0.08442850f, 0.00744767f, 0.01364540f, 0.08069566f, 
    -0.47020361f, 0.12626107f, 0.02116051f, -0.01396806f, -0.06937582f, 0.03297408f, 0.16964039f, -0.10663010f, 
    -0.09224818f, -0.12466445f, -0.02659560f, -0.05641836f, 0.15549250f, 0.10972079f, 0.06481940f, 0.03616555f, 
    0.11442757f, -0.01790758f, -0.09855954f, 0.02405890f, -0.37854445f, -0.17353676f, 0.36753055f, -0.23527391f, 
    0.16234887f, 0.14954922f, 0.07894232f, 0.07773416f, 0.23782808f, -0.22872800f, -0.03669259f, 0.07795534f, 
    0.29857448f, 0.09213569f, 0.12088438f, 0.16646788f, -0.08407397f, 0.08959907f, -0.00139444f, 0.03077346f, 
    -0.08420447f, -0.09874346f, 0.28264806f, 0.08160912f, 0.43567869f, 0.11450435f, 0.12644637f, 0.07240464f, 
    0.05438098f, 0.11884628f, -0.17049944f, -0.01394015f, 0.01924114f, -0.17285164f, -0.10490345f, 0.07144878f, 
    0.09446894f, -0.00103723f, 0.11301646f, 0.03109646f, 0.14333682f, -0.21952276f, 0.29773566f, 0.09847471f, 
    -0.02251164f, 0.08928701f, -0.03853498f, 0.10767969f, 0.04873899f, 0.21151024f, -0.03479620f, 0.06747328f, 
    -0.06842645f, -0.31001371f, -0.14021917f, -0.00629863f, 0.02775824f, 0.00695429f, -0.00844615f, -0.16235673f, 
    -0.44333389f, -0.07992386f, -0.07894818f, 0.03626661f, 0.15612869f, -0.17324573f, 0.00719504f, -0.15223034f, 
    0.19689974f, 0.05878816f, -0.21405198f, -0.01362604f, 0.09933575f, 0.09487385f, 0.04884791f, 0.05859714f, 
    0.26290441f, 0.23829965f, -0.00835470f, -0.10131278f, -0.12582579f, -0.21168925f, 0.13815683f, 0.11289755f, 
    0.05194315f, 0.06614690f, 0.00225776f, 0.02065226f, 0.07992651f, 0.16643329f, 0.04048419f, -0.07001191f, 
    -0.04225791f, 0.02023750f, -0.04090602f, 0.03414058f, 0.04055051f, -0.03984341f, 0.13209379f, 0.00066558f, 
    -0.13057017f, 0.11870960f, 0.16755506f, 0.19980584f, 0.08642147f, 0.09292192f, -0.04848957f, -0.18641719f, 
    -0.04209197f, 0.09998547f, 0.06682375f, 0.00764543f, -0.01677327f, -0.01722131f, -0.06422064f, -0.01402045f, 
    -0.10757145f, -0.16808337f, -0.10213099f, 0.00269920f, -0.34881502f, -0.04551374f, -0.11962882f, -0.18741770f, 
    0.02416552f, -0.14771344f, 0.05211576f, -0.03073683f, -0.13802794f, 0.04982146f, -0.03778183f, 0.10287371f, 
    0.06899326f, -0.01952193f, 0.09179441f, -0.06398415f, -0.03709624f, -0.03376196f, -0.18354927f, 0.15368581f, 
    -0.05379426f, -0.00859569f, -0.03485855f, -0.01182321f, 0.03576976f, 0.03009855f, -0.00907306f, 0.02409719f, 
    -0.05492033f, -0.03354967f, 0.02144040f, -0.01726625f, 0.01033160f, -0.02178271f, 0.00117046f, -0.00543738f, 
    -0.05712296f, 0.03747169f, -0.00869259f, -0.04811502f, -0.02615299f, -0.04846736f, 0.02063181f, -0.01261025f, 
    -0.05101395f, -0.00399441f, 0.01609801f, -0.04846904f, 0.02293034f, 0.02180426f, -0.04184923f, 0.00014797f, 
    -0.00537136f, 0.02948136f, 0.03881803f, 0.05343123f, -0.00415563f, -0.04462931f, 0.00974180f, -0.03270099f, 
    -0.01776416f, 0.02549677f, -0.01009089f, -0.00964426f, -0.00210963f, -0.01287082f, 0.04877110f, -0.02805316f, 
    0.04754549f, -0.04035952f, -0.04465920f, -0.01807936f, -0.00434705f, 0.00221570f, -0.00980552f, -0.04652097f, 
    0.02287590f, 0.01200514f, 0.02838309f, -0.02573529f, -0.03647240f, -0.02031543f, 0.05027043f, -0.03244401f, 
    -0.01575481f, -0.01309206f, -0.02008226f, -0.03331434f, 0.04020754f, -0.05844072f, 0.01141713f, -0.05664659f, 
    -0.00373682f, -0.03279123f, -0.03755571f, 0.02780469f, 0.00443662f, -0.04595682f, 0.03959161f, -0.00928585f, 
    0.00437962f, 0.01088503f, 0.01933223f, 0.05169781f, 0.04273587f, 0.00562630f, -0.00311969f, -0.01769773f, 
    -0.05188792f, -0.05517049f, 0.01393473f, 0.02030831f, -0.05403588f, 0.01911207f, 0.02881631f, 0.03649781f, 
    0.03102914f, -0.03496381f, 0.01626622f, 0.04797086f, -0.01976684f, -0.05221015f, -0.04639941f, 0.03089568f, 
    -0.03938469f, 0.01380036f, 0.02546860f, -0.05290451f, -0.00718671f, -0.01729398f, -0.00594031f, 0.04730173f, 
    -0.00480459f, -0.04579583f, 0.02136931f, -0.00075875f, -0.01617544f, -0.05244029f, 0.02055352f, 0.01539190f, 
    -0.04689561f, 0.02073145f, 0.01429214f, -0.05587132f, 0.00719735f, -0.01323810f, 0.03718890f, -0.04213929f, 
    0.02936906f, 0.05183211f, 0.04634519f, -0.04636941f, -0.04520312f, -0.04491609f, -0.01464942f, -0.00372100f, 
    -0.04280852f, -0.02765679f, -0.05577707f, 0.04481630f, -0.03085253f, 0.01614024f, 0.03916887f, -0.01802987f, 
    -0.01574241f, -0.00589519f, -0.02488173f, 0.00486503f, 0.04294120f, -0.00025042f, -0.03585249f, -0.00155113f, 
    0.01469461f, 0.04638388f, -0.01161893f, -0.04344707f, -0.05574070f, 0.00233526f, -0.00814925f, 0.01361177f, 
    0.00793050f, -0.00978444f, -0.02068971f, -0.00364130f, -0.03334348f, 0.02645332f, -0.02528168f, -0.03458089f, 
    -0.05948436f, 0.04658087f, -0.01637591f, 0.02314842f, -0.00318312f, -0.01617948f, -0.00816443f, 0.03603969f, 
    0.02855669f, -0.01568918f, -0.01118598f, -0.03009488f, -0.06050566f, -0.01959058f, 0.02790638f, -0.04067816f, 
    -0.04901820f, 0.01505575f, 0.02058811f, 0.02048146f, -0.01829327f, -0.00267656f, 0.00864292f, -0.03528473f, 
    0.02326039f, -0.04349556f, -0.02646377f, -0.04076538f, 0.01821565f, -0.00551135f, -0.03934358f, 0.02972533f, 
    -0.00126334f, 0.01084964f, -0.00277655f, -0.04012977f, -0.04210436f, -0.04113268f, 0.04379345f, 0.03157157f, 
    0.00809742f, -0.03646265f, -0.02016706f, -0.04263411f, -0.02500208f, 0.00978889f, 0.02053029f, -0.00817214f, 
    0.01086126f, 0.00277590f, -0.04806329f, -0.00608239f, -0.05235687f, -0.01798595f, -0.04695314f, 0.04340359f, 
    0.01647618f, -0.01573908f, 0.04273978f, 0.01382035f, -0.02380364f, -0.02166893f, -0.01445798f, -0.03673052f, 
    0.02266301f, 0.04739084f, -0.05808593f, -0.05981051f, 0.04834974f, 0.04681796f, -0.04260297f, -0.02698566f, 
    0.00044053f, -0.02423429f, 0.02393540f, -0.02989599f, 0.02482330f, -0.04362459f, -0.03985743f, 0.04547822f, 
    -0.04779003f, -0.02712416f, 0.01689794f, 0.00122294f, -0.05440266f, -0.00911692f, 0.04540286f, 0.04987724f, 
    -0.03222535f, -0.05659495f, 0.00986644f, 0.02133167f, 0.04783704f, -0.04008909f, 0.00326846f, 0.03480525f, 
    -0.03414586f, -0.03265197f, -0.03318809f, -0.00236980f, -0.03437256f, -0.01605649f, 0.00354288f, -0.02027623f, 
    0.03445762f, 0.03683836f, -0.05513414f, -0.05838767f, -0.01646913f, 0.00784983f, -0.02415335f, 0.01061847f, 
    0.00995653f, 0.01963375f, -0.01035595f, 0.04716903f, 0.01131856f, 0.04620205f, 0.00744184f, -0.01286538f, 
    -0.05602961f, 0.04900543f, 0.01104334f, 0.02562610f, -0.05777327f, -0.05725556f, 0.03827507f, 0.02530506f, 
    -0.03739635f, -0.01276748f, 0.02969819f, -0.03638715f, -0.00947757f, -0.02309583f, -0.00139197f, 0.02227688f, 
    -0.00574776f, -0.02963236f, -0.02132193f, -0.00073162f, 0.00870314f, -0.02671896f, 0.01739424f, -0.03615719f, 
    -0.03667971f, 0.01170918f, -0.01559985f, -0.00062959f, -0.03524707f, 0.03710335f, -0.03746247f, -0.05457738f, 
    0.09525065f, -0.03824836f, 0.04451005f, -0.05445556f, -0.06938650f, 0.12270108f, 0.06447394f, 0.11806310f, 
    -0.02490942f, -0.01519978f, 0.00624374f, -0.02546640f, -0.07568622f, 0.12924452f, -0.02013412f, -0.01504371f, 
    -0.10884505f, 0.09738845f, -0.23080258f, 0.02953248f, 0.43656987f, -0.11527842f, 0.01081444f, -0.07781595f, 
    0.08328123f, 0.03220284f, -0.00522629f, 0.06007707f, 0.03504389f, -0.09178893f, -0.00009330f, 0.04750646f, 
    0.00478996f, -0.03103908f, 0.10915080f, -0.06597714f, 0.00121589f, 0.13968158f, 0.18374166f, -0.10476925f, 
    -0.24075134f, 0.15213993f, 0.06105430f, 0.09314403f, -0.11338272f, 0.09265182f, 0.02198375f, -0.01829331f, 
    -0.10366029f, 0.32527411f, -0.07060832f, 0.01822774f, -0.03509020f, 0.01295480f, -0.03420355f, 0.04647884f, 
    0.06762518f, -0.02393694f, 0.17469014f, 0.22475995f, -0.51169181f, -0.13629729f, 0.05783821f, 0.09545611f, 
    0.07315612f, 0.04580977f, -0.06140690f, 0.26232550f, 0.04831196f, 0.10834656f, -0.00138620f, -0.01058068f, 
    0.05253907f, 0.09143798f, -0.10381623f, 0.04066202f, -0.03289389f, -0.03303116f, -0.32296756f, -0.11132188f, 
    0.09394050f, 0.00365991f, -0.10713427f, 0.06098285f, -0.17253098f, -0.05734432f, -0.07008464f, -0.08885668f, 
    -0.03746674f, 0.07818633f, 0.09061915f, 0.04439218f, 0.12444590f, 0.15485039f, 0.09833603f, -0.05743065f, 
    0.09562353f, -0.05415554f, 0.06685924f, -0.03363125f, 0.17644104f, 0.13440487f, 0.01049297f, 0.04233084f, 
    0.03007364f, -0.01325275f, 0.02363966f, 0.00722800f, 0.06711920f, -0.00859126f, -0.02140178f, -0.01732929f, 
    -0.02626671f, -0.07828123f, -0.08131257f, -0.01911576f, -0.04696181f, -0.04893931f, -0.10820269f, -0.16112699f, 
    0.22381741f, 0.05050183f, 0.05209326f, -0.00177299f, 0.01168807f, -0.04075615f, -0.01179595f, 0.11139152f, 
    0.17763990f, -0.00793762f, 0.03260540f, 0.06707855f, -0.03951740f, 0.06244222f, 0.00375784f, 0.11320612f, 
    -0.08729471f, -0.06447529f, 0.07254802f, -0.07871396f, 0.48790541f, -0.23161574f, 0.52520978f, 0.19684790f, 
    -0.26750284f, -0.00319664f, -0.09131566f, -0.10464466f, -0.02440244f, -0.01466209f, 0.04215763f, -0.10975562f, 
    0.01010611f, -0.13343616f, 0.07617280f, 0.03840788f, 0.12733141f, -0.08988690f, 0.06540913f, 0.02352491f, 
    0.09872241f, -0.04929278f, 0.08230685f, 0.06859401f, -0.05292287f, -0.04356293f, -0.02617978f, 0.09460248f, 
    0.06807562f, 0.02531832f, 0.07372732f, 0.05181490f, -0.06237933f, -0.07229056f, -0.10235153f, 0.11771251f, 
    -0.02712215f, 0.04645862f, -0.02852635f, 0.01802747f, 0.02089135f, -0.13455893f, 0.25542536f, 0.11895344f, 
    -0.35773924f, -0.08145130f, -0.11531484f, 0.01944885f, 0.02507477f, 0.00405281f, -0.18652861f, 0.02037564f, 
    0.01520844f, 0.17324950f, 0.01723713f, -0.01346154f, 0.08148234f, -0.01305560f, -0.05562255f, 0.08451647f, 
    0.01080217f, -0.13630317f, 0.14308833f, 0.08066541f, -0.37087432f, -0.05002294f, 0.03909315f, 0.06722569f, 
    0.14659117f, 0.07496488f, -0.07013757f, 0.01456452f, 0.08065459f, 0.16277263f, 0.02098317f, -0.07552907f, 
    -0.04060024f, -0.11152129f, -0.03809890f, -0.08685171f, -0.19976124f, -0.02035721f, 0.07754510f, 0.08307342f, 
    -0.11465462f, 0.05308751f, 0.18056336f, 0.10898092f, 0.10038158f, 0.02829592f, 0.13045286f, 0.01384587f, 
    0.17379592f, 0.05012610f, 0.01558093f, -0.01094940f, -0.10309834f, -0.05732004f, -0.23248537f, -0.02637234f, 
    0.27724555f, 0.00970285f, 0.30927512f, 0.27964580f, -0.06132654f, 0.05609194f, 0.07571305f, 0.01919711f, 
    0.16656674f, 0.07880794f, 0.02441850f, 0.05250847f, 0.02540133f, -0.07743339f, -0.07309645f, -0.13397893f, 
    0.10745088f, -0.21170537f, 0.06095110f, 0.24044301f, 0.16481158f, 0.21164198f, 0.12069434f, 0.31468192f, 
    0.09088859f, -0.21636550f, -0.03513892f, -0.10573580f, 0.02667492f, 0.17323557f, 0.04134837f, -0.02439923f, 
    0.01944448f, -0.16440821f, -0.09742298f, -0.02671837f, 0.01214765f, -0.10477406f, -0.14522502f, 0.04069633f, 
    0.41033784f, 0.03966719f, 0.16262275f, 0.08779392f, -0.06833939f, -0.04847346f, -0.15609497f, -0.05313654f, 
    0.01360323f, -0.12031835f, 0.07974737f, -0.08427094f, 0.29516351f, 0.01410519f, 0.00941337f, -0.02444349f, 
    -0.03344359f, 0.00159284f, -0.06831273f, -0.04561596f, 0.36582372f, -0.11378983f, -0.19427072f, -0.03733012f, 
    -0.18270381f, -0.03141636f, 0.02154244f, 0.03545929f, 0.07102016f, -0.01126233f, 0.03267063f, 0.14111418f, 
    -0.01425030f, 0.02769598f, 0.10862596f, 0.13471185f, 0.05212939f, 0.03794605f, 0.19697130f, -0.08882780f, 
    -0.00244615f, -0.04032558f, 0.06013501f, -0.10721184f, 0.24901247f, -0.04384197f, 0.05803599f, -0.07976732f, 
    -0.04552744f, 0.08784015f, 0.12349143f, 0.12266238f, 0.13076571f, -0.00920472f, 0.00827328f, -0.08442438f, 
    0.01315217f, -0.08249548f, 0.05939180f, 0.00558622f, 0.05486626f, -0.02248895f, -0.05655726f, -0.08507663f, 
    -0.01821947f, -0.10542549f, -0.02244085f, -0.08062457f, -0.00419486f, 0.03275776f, 0.01103516f, -0.05049390f, 
    -0.20388798f, 0.05319725f, -0.03531047f, 0.14548735f, 0.04794785f, 0.02604444f, -0.09436215f, 0.10924451f, 
    -0.26616636f, -0.59965158f, -0.52552539f, -0.34533301f, -0.16946748f, -0.02702564f, 0.12465353f, -0.02978140f, 
    0.07637907f, -0.35638440f, -0.04317370f, -0.00590883f, 0.09061202f, 0.00781948f, 0.04282957f, 0.11382651f, 
    -0.08056508f, 0.18692438f, 0.26043761f, 0.22261579f, 0.08949336f, -0.19690040f, -0.37676239f, 0.00861933f, 
    -0.15364392f, 0.07671884f, 0.14540014f, -0.10096389f, 0.04126884f, 0.10780025f, 0.05204697f, 0.00138407f, 
    0.06789093f, -0.09497157f, -0.01831078f, -0.06090196f, -0.00179416f, -0.07180533f, 0.04835464f, -0.21120831f, 
    0.35118625f, -0.24716707f, 0.10343895f, -0.35454896f, 0.04841936f, -0.17410761f, 0.10051442f, 0.01401343f, 
    -0.01751249f, -0.11263612f, -0.16060455f, -0.13632701f, -0.05455252f, -0.11432398f, -0.11010329f, -0.06514262f, 
    0.00969533f, -0.02155140f, 0.00485615f, 0.05005394f, -0.11492192f, 0.03652434f, 0.04427137f, -0.11060976f, 
    0.07028231f, -0.04064171f, 0.00140984f, -0.01378757f, -0.07314847f, -0.00540311f, -0.02765374f, 0.19226159f, 
    0.13068715f, 0.10953502f, 0.05918391f, -0.06838259f, -0.11708475f, -0.20137581f, -0.10059250f, -0.09756813f, 
    -0.11990315f, 0.05346442f, -0.01774690f, 0.01777797f, -0.14139575f, -0.01856385f, -0.06763902f, -0.01157188f, 
    -0.02254536f, -0.00059400f, 0.00903793f, -0.03275537f, 0.09083427f, 0.05413214f, 0.02429910f, 0.00380680f, 
    -0.10646899f, -0.08342609f, -0.15238951f, -0.11413012f, -0.38487026f, 0.00992118f, 0.45740992f, 0.16157904f, 
    0.37135381f, -0.01607066f, 0.02291583f, -0.02496341f, -0.04155372f, 0.20535769f, 0.09456520f, 0.15728286f, 
    0.22199792f, 0.26486212f, 0.18533245f, 0.07003420f, 0.07572058f, -0.03069380f, 0.12074605f, 0.08165757f, 
    -0.09595130f, 0.14062190f, -0.01777035f, 0.14148694f, -0.01776059f, 0.01744579f, -0.06580824f, -0.02414852f, 
    -0.09968744f, 0.10492474f, 0.22251631f, 0.07114585f, 0.20549016f, 0.19105887f, 0.03670540f, 0.00548008f, 
    0.11057490f, -0.01615848f, -0.05230843f, 0.05443692f, -0.04459738f, 0.48718977f, 0.11458000f, 0.24174310f, 
    0.25171709f, 0.04588304f, 0.11518826f, 0.03153922f, 0.17922357f, 0.26494876f, 0.16881841f, 0.16448130f, 
    0.27003703f, 0.09291314f, 0.10071527f, 0.12197801f, 0.20012595f, 0.11065864f, 0.18506920f, 0.13182355f, 
    -0.24094756f, 0.03060308f, -0.17437667f, 0.02047351f, 0.09496714f, -0.00656115f, 0.04753966f, -0.30015227f, 
    0.23245463f, -0.11130393f, 0.11010157f, 0.28464571f, -0.09062392f, -0.11355411f, 0.10015590f, 0.05872389f, 
    -0.10804911f, 0.03375087f, -0.01694614f, -0.05642958f, -0.28057560f, 0.02802981f, -0.14001937f, -0.19285299f, 
    -0.02979165f, -0.19755965f, 0.06061699f, -0.12226436f, 0.06969822f, -0.14981170f, 0.02851191f, 0.04689579f, 
    -0.00046642f, 0.00058170f, 0.02831795f, -0.05893292f, -0.04951625f, 0.06357938f, 0.01379142f, -0.23223354f, 
    0.00611218f, -0.30671459f, -0.22826831f, 0.23112200f, -0.26166260f, -0.00203408f, -0.05113085f, -0.10279597f, 
    0.09577923f, -0.06548122f, -0.00028799f, -0.00148903f, 0.02825575f, 0.00351723f, 0.03762286f, 0.10213748f, 
    -0.06818214f, 0.24354039f, 0.08899732f, -0.01206030f, -0.40042847f, -0.37730706f, -0.19106369f, 0.02861810f, 
    -0.11474665f, -0.01869327f, -0.08080134f, -0.06383530f, -0.02197208f, -0.04408725f, -0.01030369f, 0.01599660f, 
    0.01132085f, 0.05437523f, -0.03224590f, 0.09151959f, 0.04927598f, 0.17773974f, 0.15179706f, -0.05771574f, 
    -0.40155351f, 0.23377725f, 0.32081255f, 0.10751088f, 0.05410777f, -0.08313226f, -0.03816700f, -0.04577516f, 
    -0.18447076f, 0.21472377f, -0.08588892f, 0.05300288f, 0.03898392f, 0.04502233f, 0.09322748f, -0.03789540f, 
    -0.10353121f, -0.10584453f, -0.03442012f, -0.05214993f, -0.13811031f, 0.07674864f, 0.10706601f, -0.12137875f, 
    0.10709003f, -0.09255684f, -0.08328890f, -0.02808060f, -0.04879650f, -0.04113684f, -0.01455483f, -0.07051405f, 
    0.06746056f, -0.06515174f, -0.06442005f, 0.15695721f, 0.03142615f, -0.17076272f, -0.08964785f, 0.06341577f, 
    -0.38584566f, -0.13537681f, -0.26077083f, 0.32653946f, -0.09866548f, 0.17576264f, 0.03028590f, 0.07781221f, 
    0.04230686f, -0.00123384f, 0.14051749f, 0.05535199f, 0.07069325f, 0.19216299f, 0.06736223f, 0.11410069f, 
    0.04856784f, 0.13429515f, -0.04623199f, 0.03488935f, 0.06598388f, -0.24765098f, -0.47545147f, 0.14422904f, 
    0.24181046f, -0.09217537f, -0.06375864f, -0.12285373f, -0.08389597f, -0.02493436f, -0.11028955f, 0.10218325f, 
    -0.03344411f, 0.03253167f, -0.15363158f, 0.06297367f, -0.07440820f, -0.11608029f, 0.08727688f, 0.01870658f, 
    -0.02501972f, 0.24032988f, 0.20102035f, 0.14625643f, -0.24409986f, -0.00190036f, -0.08848268f, 0.10710730f, 
    -0.01778231f, 0.11042592f, 0.10309383f, 0.04879002f, 0.10489133f, 0.20228912f, -0.04025090f, 0.03559368f, 
    0.09210275f, -0.01024556f, 0.14053181f, 0.02819550f, 0.01948717f, 0.16094436f, 0.15137491f, -0.05928864f, 
    -0.13456570f, -0.06630253f, -0.13701163f, 0.13795774f, -0.03194004f, 0.03774466f, -0.05551480f, -0.01925704f, 
    0.21541885f, 0.00704857f, 0.05652208f, -0.06152214f, 0.09781196f, -0.11483031f, 0.21846728f, 0.14107479f, 
    0.20694137f, 0.35286799f, -0.65807605f, 0.40634817f, -0.44925812f, 0.18184714f, -0.10828868f, 0.00596987f, 
    -0.09206146f, 0.00908002f, -0.14132036f, -0.03150990f, 0.06358734f, 0.01816965f, -0.11583724f, 0.08468407f, 
    0.09648392f, 0.03572468f, -0.03458819f, 0.07792965f, -0.17064272f, -0.14890842f, -0.27233070f, 0.05517571f, 
    0.08697500f, -0.04389336f, 0.01898284f, 0.02345272f, 0.03726943f, -0.10840437f, 0.06537704f, 0.10839231f, 
    0.09089012f, 0.06674434f, 0.03327983f, 0.02679352f, -0.06064947f, 0.22768195f, -0.10955480f, 0.11044316f, 
    -0.36079457f, -0.09855288f, -0.22706187f, -0.18733695f, -0.01705274f, -0.04910726f, -0.04137556f, -0.10969601f, 
    0.11506920f, -0.04873407f, 0.12340363f, -0.09411582f, -0.04633202f, -0.01757179f, 0.09119602f, -0.00928585f, 
    -0.00449194f, -0.07193158f, -0.01336770f, -0.05323736f, -0.56706065f, -0.15211587f, 0.12683085f, 0.15426803f, 
    -0.15401736f, -0.14773497f, -0.06540912f, -0.04991427f, 0.05921446f, 0.05795385f, 0.17284228f, 0.05279307f, 
    -0.04493071f, -0.03711076f, 0.08670816f, 0.05814834f, -0.01248132f, 0.00590995f, -0.15982695f, -0.01138381f, 
    -0.13773060f, -0.19868186f, -0.12960607f, 0.03883974f, 0.09859551f, -0.12831779f, -0.03835265f, -0.29006162f, 
    -0.01327493f, -0.14370674f, -0.02130993f, -0.12652147f, -0.15398745f, 0.00981859f, 0.12544982f, -0.02954070f, 
    0.03230281f, 0.01504370f, 0.02545542f, 0.03638896f, 0.39218032f, -0.52805579f, 0.14038411f, -0.06217546f, 
    -0.17850417f, 0.09983653f, 0.05708344f, -0.06490777f, 0.27728486f, 0.01652902f, 0.13370705f, 0.02914074f, 
    0.13711971f, 0.05671477f, -0.01265232f, -0.01426124f, -0.16921823f, -0.08157498f, 0.17576778f, 0.12388106f, 
    0.14015023f, -0.35899347f, 0.31686831f, -0.10155035f, 0.11727521f, 0.03142879f, 0.03838473f, 0.09806103f, 
    0.13278665f, 0.02104795f, 0.01521655f, 0.00156547f, 0.01412570f, 0.11044790f, -0.01671680f, -0.09230497f, 
    0.08337105f, 0.02260708f, -0.11357047f, -0.07580794f, 0.12894937f, -0.03275090f, 0.31673634f, 0.15099999f, 
    -0.11902550f, -0.02586056f, -0.00490645f, -0.02857128f, 0.03108353f, -0.02639717f, -0.02717311f, -0.02293856f, 
    -0.02003585f, -0.06022520f, -0.10477424f, -0.05438592f, 0.15085238f, -0.07298505f, -0.05867707f, -0.09767073f, 
    -0.13126466f, -0.15290855f, 0.37084198f, 0.10884728f, -0.11426732f, -0.10229088f, -0.00105712f, -0.04455861f, 
    0.12450837f, -0.03199280f, -0.03628822f, -0.15669069f, 0.12824623f, -0.04727403f, -0.00508640f, -0.03158559f, 
    0.12633559f, -0.07638234f, 0.02815711f, -0.05129939f, -0.02780739f, 0.12426784f, 0.27619183f, 0.20520271f, 
    -0.05509428f, -0.09590695f, -0.03074444f, 0.10748203f, 0.09203035f, 0.12859924f, 0.16041888f, 0.00785118f, 
    0.05444616f, 0.04703745f, 0.01706790f, 0.06870987f, 0.06397638f, -0.14220236f, -0.00682768f, 0.15140340f, 
    0.32920825f, -0.17260997f, 0.01936511f, 0.18098436f, -0.20501874f, -0.23912720f, -0.10657456f, -0.03372796f, 
    0.00621186f, 0.07945154f, 0.21417257f, -0.04049367f, 0.08543269f, -0.10361168f, -0.01912572f, 0.02226996f, 
    -0.12792051f, 0.09805230f, -0.06770951f, 0.00906062f, -0.06717633f, -0.19778058f, -0.26512834f, -0.23839599f, 
    -0.12667674f, -0.25358492f, -0.00196889f, -0.14717314f, -0.15985163f, -0.03384996f, -0.11301272f, 0.00696206f, 
    -0.07953034f, -0.00786313f, 0.15413687f, -0.06120370f, -0.12826934f, 0.03698727f, 0.00472441f, -0.05240896f, 
    -0.02126277f, -0.03133100f, 0.02321660f, -0.03778347f, -0.01910825f, 0.01190394f, -0.05138359f, -0.05876250f, 
    0.04910794f, -0.04292565f, -0.03369848f, -0.05126297f, -0.03181842f, 0.02124898f, -0.03521103f, -0.01250237f, 
    0.02066816f, -0.01327960f, 0.02816214f, -0.04912725f, 0.03842010f, -0.02235610f, 0.02792725f, 0.00437717f, 
    -0.02393257f, 0.01413989f, 0.03644166f, -0.00406005f, -0.01787191f, -0.03225864f, -0.00149180f, -0.05327555f, 
    0.04114624f, -0.02090946f, 0.00432375f, -0.04662440f, -0.05345236f, -0.03382124f, 0.04256605f, 0.04667268f, 
    -0.05040868f, -0.04730969f, -0.02272214f, -0.01238463f, 0.04496819f, -0.04602861f, 0.04834246f, -0.02290432f, 
    -0.00240318f, 0.03193251f, 0.04236120f, -0.05927512f, -0.01376284f, 0.04656862f, -0.00629778f, 0.03821244f, 
    -0.06050386f, 0.01420322f, 0.04581594f, -0.05649013f, -0.02657593f, 0.00547305f, 0.03381002f, 0.00475562f, 
    -0.01252770f, 0.00829873f, -0.02010800f, -0.05337791f, -0.03937026f, -0.01258893f, -0.04011526f, 0.00983007f, 
    -0.02039591f, 0.04711641f, -0.03646545f, 0.03189985f, 0.03165789f, 0.00884557f, -0.04829916f, 0.02569574f, 
    -0.01177201f, 0.02655530f, -0.05453489f, 0.03331923f, -0.02697633f, -0.05544737f, -0.04879116f, -0.02629304f, 
    0.00602739f, 0.00469943f, 0.04828314f, -0.03434093f, 0.01052052f, -0.00738289f, 0.02390497f, 0.00936233f, 
    -0.02723448f, -0.04902668f, -0.03229342f, 0.02761934f, -0.04161677f, -0.05119696f, -0.03730997f, -0.03898140f, 
    -0.00581004f, -0.01706597f, -0.04319771f, 0.03439859f, 0.01867945f, -0.05202331f, 0.03583292f, 0.03154310f, 
    -0.00896058f, 0.00917857f, -0.03668124f, 0.00753616f, -0.05506361f, 0.04729723f, 0.03387632f, -0.01309250f, 
    -0.01101000f, 0.03973382f, -0.01721120f, -0.04329574f, -0.01730895f, -0.03529728f, -0.01404105f, 0.01984239f, 
    -0.06083647f, 0.04265459f, -0.00813910f, 0.05282839f, -0.01113042f, -0.02100609f, 0.04264751f, 0.02839786f, 
    -0.04868149f, 0.02806034f, 0.01608883f, 0.02081431f, -0.05316543f, 0.01812878f, 0.03178610f, -0.04367100f, 
    -0.02925697f, -0.05003032f, -0.05598773f, -0.02285380f, -0.03931548f, -0.05498682f, -0.05785738f, 0.03605745f, 
    0.04889190f, -0.05279041f, 0.01549428f, 0.02237960f, -0.04769617f, -0.01557143f, 0.04951278f, -0.03298825f, 
    -0.01196407f, -0.02936122f, 0.01501621f, -0.04965622f, -0.02056365f, 0.02492057f, -0.01684578f, 0.02127001f, 
    -0.00869623f, 0.00524152f, -0.00773112f, 0.01905694f, 0.03954751f, 0.00731699f, 0.01746815f, -0.00904910f, 
    -0.03911191f, 0.04700693f, 0.04470143f, -0.03484593f, -0.04749225f, 0.04577426f, -0.01313744f, -0.02281815f, 
    -0.02280045f, 0.00190191f, 0.00701142f, -0.04059910f, -0.04629526f, -0.04048785f, -0.05895491f, 0.03773934f, 
    -0.01541410f, -0.03131650f, -0.00965220f, -0.02202053f, -0.03712683f, -0.04653108f, 0.00254694f, -0.01031373f, 
    0.03147849f, 0.04351918f, 0.02775159f, -0.04281317f, -0.03540641f, -0.04509628f, 0.03934830f, 0.00982746f, 
    -0.02940998f, -0.06024686f, 0.00898850f, -0.01825560f, -0.04882463f, 0.01470003f, 0.02192220f, 0.02228608f, 
    0.00760572f, 0.03236789f, 0.03019208f, -0.00932821f, -0.01904595f, 0.01646759f, -0.01178538f, 0.00144397f, 
    0.04444908f, 0.04167635f, -0.04905938f, -0.04992128f, 0.04518622f, 0.03894676f, 0.04452433f, -0.02516377f, 
    -0.03882810f, 0.03265542f, -0.00911665f, -0.00805901f, -0.05986433f, -0.03881092f, 0.03345778f, -0.05430787f, 
    0.00628466f, -0.04824873f, -0.03451407f, -0.05188526f, -0.03787242f, 0.04020672f, -0.05071950f, 0.02899080f, 
    -0.04664369f, 0.03516310f, 0.03333315f, -0.02158159f, 0.04896808f, -0.05598892f, -0.00343468f, -0.04805217f, 
    -0.00424602f, 0.01855515f, 0.03761984f, -0.05497781f, -0.04919763f, 0.04464631f, 0.00914793f, -0.05825262f, 
    -0.03236898f, -0.01960509f, 0.00567154f, 0.01091828f, 0.00965921f, -0.02797332f, -0.03577749f, 0.02126964f, 
    0.01406707f, -0.03283774f, 0.01211288f, -0.01651141f, 0.04793068f, -0.00118824f, 0.04078127f, -0.03107846f, 
    0.00849899f, 0.04953706f, -0.02224209f, -0.05325945f, 0.01377902f, -0.00530196f, 0.03195177f, -0.01806280f, 
    -0.01813318f, -0.01935334f, -0.05156085f, -0.05129673f, 0.02412184f, 0.02493812f, -0.04650435f, -0.00841357f, 
    0.04195876f, 0.02145714f, -0.01676667f, 0.00485535f, -0.03023975f, -0.04024608f, 0.00181818f, 0.03801240f, 
    -0.00710743f, -0.03421305f, -0.05938876f, -0.04793556f, -0.00870400f, 0.04042515f, -0.03546940f, -0.04139064f, 
    -0.01087670f, 0.05356493f, 0.04364461f, -0.00998560f, -0.01814295f, -0.04832572f, -0.01626925f, -0.03112463f, 
    0.31412292f, -0.10583908f, 0.18752363f, -0.09412147f, -0.04910032f, -0.06406444f, 0.05872057f, 0.06050577f, 
    0.02384565f, 0.05624294f, 0.04017498f, -0.03559981f, -0.01347616f, 0.16371141f, -0.07083942f, -0.15966481f, 
    -0.06105892f, -0.02258295f, -0.01247827f, 0.02062420f, 0.29610553f, -0.00570406f, 0.26566952f, 0.18633366f, 
    -0.04169364f, -0.07972899f, -0.10574105f, -0.00591112f, 0.03114595f, -0.01435777f, 0.01903297f, 0.05556231f, 
    0.00764430f, -0.04224641f, 0.12285514f, -0.13574500f, 0.08857790f, 0.24654315f, 0.09256419f, -0.01339307f, 
    -0.24858622f, 0.00402359f, -0.21323793f, 0.06682003f, 0.14507480f, 0.02420183f, 0.13082811f, -0.09465897f, 
    0.07079331f, 0.02467306f, -0.06114659f, -0.10133784f, -0.07040336f, -0.01608495f, 0.03852138f, 0.01202102f, 
    -0.06693013f, -0.01076731f, 0.11371057f, 0.10986146f, -0.39945760f, -0.05777411f, 0.05261734f, 0.25999227f, 
    0.12079284f, 0.08647767f, 0.17173693f, 0.21681148f, 0.07790887f, 0.00089364f, -0.11593848f, -0.06532041f, 
    0.07165517f, 0.17030492f, 0.04685142f, 0.15853551f, -0.05577822f, 0.11509223f, -0.05050867f, -0.07791036f, 
    0.30921078f, -0.25679716f, 0.32501504f, -0.17413798f, 0.03532996f, -0.13421932f, -0.10176972f, -0.10519598f, 
    0.04322898f, -0.06922707f, 0.00085815f, 0.02812556f, 0.12882349f, 0.02954813f, -0.06834175f, 0.02035935f, 
    0.08742870f, -0.10519527f, 0.13924906f, 0.13061543f, 0.08691876f, -0.00456665f, 0.03019881f, -0.01766257f, 
    -0.12568957f, -0.03419967f, -0.01414484f, 0.11429162f, -0.00143680f, 0.05043400f, -0.04182671f, -0.08033774f, 
    -0.06761773f, -0.07967298f, -0.00164065f, -0.04139468f, 0.01884899f, -0.00836676f, 0.01330520f, -0.06923605f, 
    0.15153591f, 0.06143353f, 0.09173718f, 0.14876784f, -0.13549334f, -0.02188128f, -0.01909043f, 0.08186185f, 
    0.03442599f, -0.02735226f, -0.01870545f, 0.04433617f, -0.08602100f, 0.07637188f, -0.05327315f, 0.01904959f, 
    -0.06484348f, 0.09292155f, 0.10951687f, 0.03424037f, 0.46563295f, -0.37377924f, 0.29513189f, -0.16015865f, 
    -0.03083711f, 0.02122289f, 0.06615116f, 0.07643376f, 0.01231218f, 0.05550720f, -0.18160942f, 0.00871483f, 
    -0.01319788f, -0.02703759f, 0.02380819f, -0.00403517f, 0.02678350f, -0.11665238f, 0.09777652f, 0.01468410f, 
    0.03333297f, -0.04865498f, -0.04849362f, 0.20951292f, -0.25814211f, 0.09012958f, -0.06935866f, 0.16191652f, 
    -0.01516108f, 0.05730936f, 0.19750057f, 0.30792308f, -0.00237909f, 0.03539642f, -0.06461404f, 0.09874514f, 
    -0.06151649f, 0.05159678f, 0.05906827f, 0.05093876f, 0.00360668f, 0.43792397f, -0.00933468f, 0.23949093f, 
    -0.00515854f, -0.00344477f, 0.09072924f, 0.09785245f, 0.03096557f, -0.03964311f, -0.01730890f, -0.05836425f, 
    -0.02099459f, 0.10237151f, 0.05482997f, 0.08357601f, 0.14294890f, 0.04411602f, 0.02296590f, 0.01405477f, 
    -0.02396839f, -0.09378202f, -0.22436547f, 0.41811210f, -0.18038306f, -0.02551000f, 0.14504710f, -0.00029724f, 
    0.06127594f, -0.06620793f, -0.07971865f, 0.14101930f, 0.07925431f, -0.03519423f, 0.05952590f, 0.02778900f, 
    -0.11196653f, -0.00690937f, 0.12461589f, -0.12962072f, -0.21893434f, -0.09072041f, -0.26929775f, -0.03111118f, 
    0.12873983f, -0.04321713f, 0.28579119f, 0.03798017f, -0.01842016f, -0.01601182f, 0.03472939f, 0.07508256f, 
    0.05118847f, 0.06645439f, 0.04353499f, 0.03653672f, -0.09972864f, -0.02813541f, -0.02777985f, 0.02204973f, 
    0.44152564f, 0.22159223f, 0.02525816f, 0.34860498f, 0.20811585f, 0.08589999f, 0.05694132f, 0.08297736f, 
    -0.03909742f, -0.04698227f, -0.06986421f, 0.06241769f, -0.01637446f, -0.10482211f, -0.07375629f, -0.05203521f, 
    0.01699406f, -0.18929298f, 0.01632780f, 0.29481491f, 0.21306628f, 0.22990440f, -0.09127103f, 0.14774837f, 
    0.20257691f, -0.13916568f, -0.00235756f, -0.03123907f, -0.09680312f, -0.05519206f, -0.12293098f, -0.01202351f, 
    -0.06248730f, -0.08686469f, -0.06442140f, 0.02557796f, -0.02277529f, 0.00121036f, -0.16497754f, 0.08550686f, 
    0.03665093f, 0.04035904f, 0.07122273f, -0.17858393f, 0.01396105f, -0.06701563f, -0.05579817f, 0.12038957f, 
    -0.00086987f, -0.00153497f, -0.19371876f, 0.02581313f, 0.04605374f, 0.02365421f, -0.01903367f, -0.04054987f, 
    -0.03142688f, -0.02091664f, -0.02750834f, -0.07617384f, 0.27999786f, 0.11279077f, 0.04587080f, 0.25087032f, 
    -0.22613055f, 0.01749141f, -0.01765744f, -0.00075097f, 0.01927626f, -0.00722396f, 0.08645958f, 0.17640999f, 
    0.18526106f, -0.00406681f, 0.07157280f, 0.01775658f, -0.06439929f, -0.21723650f, 0.14382799f, -0.03088315f, 
    0.20662603f, 0.09506221f, 0.06512152f, -0.13226873f, -0.05053256f, -0.12048775f, -0.05467235f, -0.07311198f, 
    0.00116467f, -0.04691907f, 0.00829502f, 0.09346900f, 0.07548962f, -0.08313223f, 0.04835029f, -0.00656372f, 
    0.17892337f, -0.06996318f, 0.16135974f, 0.03551576f, -0.39110243f, 0.12585078f, 0.13614476f, 0.12673272f, 
    -0.11809427f, -0.06178499f, -0.00679298f, -0.07652289f, 0.00521942f, 0.05344977f, -0.00655677f, -0.07122727f, 
    -0.17769355f, 0.05553228f, -0.09985023f, 0.16958813f, 0.10009934f, 0.02283050f, -0.23732184f, 0.03516060f, 
    0.03908174f, -0.35474318f, -0.30075511f, -0.05246623f, 0.23987325f, -0.00216978f, 0.00074251f, 0.04262248f, 
    0.05096624f, -0.28990185f, 0.14361919f, -0.01875913f, 0.06029988f, 0.02696660f, 0.19273128f, 0.19001527f, 
    0.02883402f, 0.15630785f, -0.10074002f, -0.03875886f, 0.38559711f, 0.10119986f, -0.14566138f, 0.11952302f, 
    -0.05765732f, -0.02024655f, 0.03663674f, -0.10863294f, -0.05443039f, -0.14090446f, 0.02263497f, 0.01307862f, 
    0.03043381f, -0.05423794f, 0.20855048f, -0.10532171f, 0.05251012f, 0.11355028f, 0.23368885f, 0.09094146f, 
    0.00819773f, -0.06216956f, 0.43387613f, -0.18056273f, 0.09335539f, -0.10475918f, 0.02589302f, -0.01348955f, 
    0.12514904f, -0.16508497f, -0.13427897f, -0.05887493f, -0.04451812f, -0.12653963f, -0.07124975f, -0.01465293f, 
    0.02784110f, 0.08385371f, 0.06586192f, 0.08261407f, -0.14037740f, -0.01558600f, -0.04971972f, -0.06473602f, 
    -0.19432412f, -0.03264413f, 0.07464387f, 0.01145650f, 0.00616560f, 0.04950000f, 0.08808328f, 0.08339133f, 
    0.13163503f, 0.10014056f, 0.11735176f, -0.04976763f, 0.12444137f, -0.06321047f, 0.10945481f, 0.03256704f, 
    -0.23905988f, -0.02581822f, -0.04524372f, -0.00394389f, -0.17702626f, -0.08679937f, 0.02365541f, 0.01149831f, 
    -0.17442188f, 0.04232546f, 0.00660487f, 0.02096413f, 0.02734562f, 0.11011155f, 0.05765455f, -0.03928934f, 
    0.12455926f, 0.11292358f, -0.11077556f, 0.10805019f, -0.03998373f, -0.00443058f, -0.22853100f, -0.16000965f, 
    0.31750122f, -0.00723707f, 0.04859406f, 0.05170048f, -0.08220674f, 0.04114826f, 0.06413296f, 0.21390878f, 
    0.07765166f, 0.13337947f, 0.02671152f, -0.00387969f, 0.04413003f, -0.00605223f, 0.08032349f, 0.00358331f, 
    -0.21697327f, 0.08139224f, -0.02355301f, 0.01978811f, -0.16970900f, 0.02334741f, -0.05515110f, -0.01932276f, 
    -0.09045542f, -0.00453805f, 0.08783273f, 0.01600140f, 0.17801557f, 0.12703624f, 0.10746869f, -0.09543143f, 
    0.14339526f, -0.05287207f, -0.03984614f, -0.09860078f, -0.10894880f, 0.45493990f, -0.07930008f, 0.04625115f, 
    0.43279427f, 0.05989429f, 0.21723922f, 0.05174466f, 0.01675168f, 0.05906486f, 0.17203449f, -0.00294973f, 
    -0.01593856f, 0.02833364f, 0.11456405f, 0.02553818f, 0.11479196f, 0.08469106f, 0.16588789f, -0.04697173f, 
    -0.12100637f, -0.06346687f, -0.33057344f, 0.23295830f, 0.38706627f, -0.12756346f, 0.01156943f, -0.10685015f, 
    0.04128258f, 0.01284780f, 0.14542580f, 0.02036915f, -0.07148380f, -0.07820375f, 0.04925904f, 0.04630576f, 
    0.09185906f, 0.05194711f, 0.08617894f, 0.11618379f, 0.00336359f, -0.14316057f, -0.25348601f, -0.07198347f, 
    0.16888227f, -0.16943316f, -0.11451582f, -0.14523797f, 0.00266724f, -0.05044344f, -0.04543939f, 0.02373968f, 
    -0.13266921f, 0.00033144f, 0.05136219f, -0.07510059f, 0.07101605f, 0.09825335f, 0.08261743f, 0.00813176f, 
    -0.14938027f, 0.00770862f, -0.40745395f, -0.03002908f, 0.29906395f, 0.06495184f, -0.02230302f, 0.03167172f, 
    -0.07976758f, -0.00723021f, 0.05299459f, 0.07713015f, -0.00644299f, 0.09073422f, 0.22958966f, 0.15160581f, 
    -0.03153284f, 0.25870702f, 0.08575324f, 0.12297706f, -0.12651250f, -0.24425919f, -0.31694019f, -0.22122361f, 
    0.07646978f, 0.14236897f, 0.06340463f, 0.04878604f, -0.00762361f, -0.05791831f, 0.04851112f, 0.02599667f, 
    0.04813290f, 0.12227209f, 0.03360048f, 0.05068809f, -0.02153591f, 0.18776499f, 0.17389546f, 0.11011489f, 
    -0.30936962f, -0.07455530f, -0.14670032f, -0.14806834f, 0.04019576f, 0.00506537f, 0.06810812f, 0.08663149f, 
    0.06377365f, 0.15890099f, 0.07525495f, 0.12109505f, -0.21290758f, -0.05347598f, -0.02494398f, -0.04445036f, 
    0.10145404f, -0.04389580f, 0.06697199f, 0.05981236f, -0.41274133f, 0.06070626f, 0.23192646f, 0.05989472f, 
    0.08433914f, -0.03943585f, -0.05059904f, -0.08299511f, -0.07223623f, -0.05435316f, -0.13485464f, -0.13954146f, 
    0.07039155f, -0.06368680f, -0.01034362f, 0.01930915f, -0.00926948f, 0.04647988f, -0.21857367f, -0.02501755f, 
    0.12287447f, 0.09206532f, -0.24302021f, 0.17527479f, -0.09731692f, 0.12660468f, 0.04460920f, 0.02130228f, 
    0.03733388f, -0.05775830f, 0.09404312f, 0.04650469f, 0.11984260f, 0.19060290f, 0.06081996f, 0.11441636f, 
    0.07651500f, 0.31064013f, 0.10244191f, 0.13095641f, -0.09772628f, 0.25965047f, -0.03355401f, -0.00673320f, 
    0.12188079f, -0.00170730f, -0.12005249f, -0.20879024f, -0.11791699f, -0.20034572f, -0.04042419f, 0.12060764f, 
    0.00129888f, 0.09459894f, -0.01299445f, 0.01943384f, -0.11301842f, -0.19160128f, 0.21959841f, -0.09130246f, 
    0.04214618f, 0.04549924f, 0.25141430f, 0.24686143f, -0.14964762f, 0.19134006f, -0.05705068f, -0.01803724f, 
    -0.12508190f, 0.07491714f, 0.11767872f, 0.10279180f, -0.05978239f, 0.01497958f, 0.00838847f, -0.04701016f, 
    0.11972299f, -0.12773079f, -0.10670877f, -0.21483801f, 0.33121145f, 0.14816408f, 0.03254936f, -0.08497424f, 
    -0.12897794f, 0.20660633f, -0.03779007f, -0.09396680f, 0.03893786f, 0.02522676f, 0.00190712f, -0.08949909f, 
    0.02608069f, 0.09427127f, 0.17406404f, -0.13645752f, 0.30003011f, 0.02428321f, 0.21985379f, 0.10407983f, 
    -0.32475343f, 0.23780409f, 0.04556425f, 0.21592234f, -0.09721202f, -0.11111335f, -0.22294824f, -0.31185812f, 
    -0.06730358f, -0.10614581f, -0.05798391f, -0.13753851f, -0.01559224f, -0.01494177f, -0.00448651f, 0.16680431f, 
    0.11488293f, 0.19026971f, -0.02468336f, 0.03378615f, -0.04507712f, -0.11710417f, -0.07111306f, 0.18724097f, 
    -0.07727363f, -0.14010267f, -0.10147050f, -0.05362160f, -0.20410150f, -0.04466114f, 0.03515096f, 0.07788027f, 
    0.11528431f, 0.03516489f, 0.04174494f, 0.10874895f, 0.07012517f, 0.17886592f, 0.10605828f, 0.24626759f, 
    -0.16140085f, -0.02132049f, -0.08888851f, -0.22802432f, 0.02039320f, 0.08764315f, -0.02407196f, -0.28884548f, 
    -0.20100880f, -0.19393620f, 0.25299358f, -0.01287944f, -0.11738461f, 0.09427710f, -0.03029758f, 0.01824601f, 
    0.07363285f, -0.07557217f, 0.12473576f, 0.02233411f, -0.38164121f, 0.18599847f, -0.28688040f, -0.00079116f, 
    -0.08013771f, -0.18203226f, -0.18813924f, 0.02797904f, 0.00962911f, -0.08951554f, 0.25906584f, 0.04173856f, 
    -0.02460742f, -0.01196755f, 0.14745156f, 0.01356986f, -0.14295737f, 0.03234161f, -0.22889690f, -0.10881645f, 
    0.13175903f, -0.12590833f, 0.12052544f, -0.11960275f, 0.10156523f, -0.20277454f, -0.14766999f, -0.27455699f, 
    -0.07360582f, -0.28763014f, 0.00588458f, 0.02176021f, -0.14298321f, 0.04881974f, 0.14849763f, -0.03282561f, 
    -0.05836963f, 0.06097895f, 0.02190474f, -0.16668192f, 0.56665587f, -0.03681444f, -0.06982683f, -0.27461401f, 
    0.22393432f, 0.05697967f, 0.16644724f, 0.01117851f, -0.08199152f, 0.17460328f, 0.12786853f, 0.22573316f, 
    0.11626950f, 0.02981572f, 0.05472098f, -0.00928525f, 0.00412700f, -0.01820050f, 0.00784467f, 0.10002904f, 
    -0.09413972f, -0.54471040f, 0.06165850f, -0.46646592f, 0.23388703f, 0.16111802f, 0.03606236f, 0.09486961f, 
    0.07622416f, 0.06920789f, -0.01858815f, -0.08564165f, 0.03745589f, 0.23162936f, 0.01039864f, 0.09569083f, 
    0.12582923f, 0.04326107f, 0.09703937f, -0.04468231f, 0.08074460f, -0.25105980f, -0.10772613f, 0.09250210f, 
    0.01698812f, 0.14612176f, 0.08814416f, 0.03235902f, 0.00603288f, 0.12975584f, 0.04947275f, -0.03239322f, 
    0.06534038f, 0.04683038f, -0.10139063f, -0.00550319f, 0.23220611f, 0.02399302f, -0.12388995f, 0.30399641f, 
    -0.15594102f, 0.07298703f, 0.34868842f, -0.11800638f, 0.05107176f, 0.01618700f, -0.04734581f, 0.06270829f, 
    0.12476584f, -0.02418074f, -0.03907094f, -0.18969315f, -0.10334883f, -0.07624581f, -0.07900044f, -0.02926405f, 
    -0.02298370f, -0.23821530f, -0.08099139f, -0.19975038f, 0.03650266f, 0.02547416f, 0.24234259f, 0.15613090f, 
    0.07848134f, 0.22261845f, 0.12561733f, 0.08216582f, 0.30374467f, -0.04947327f, 0.05480367f, -0.05356030f, 
    -0.05323207f, 0.00343518f, 0.15318264f, -0.03475475f, 0.04337040f, -0.11095342f, -0.16212718f, 0.11817753f, 
    0.08350109f, -0.33651850f, -0.35307172f, 0.05476033f, -0.12323047f, -0.16794237f, 0.02739248f, 0.00307327f, 
    -0.01759414f, 0.08018307f, 0.18255852f, 0.06893726f, 0.11776442f, 0.00496552f, 0.02028027f, 0.11180606f, 
    0.15025751f, 0.11918563f, 0.03531750f, 0.07112109f, 0.10964530f, 0.08094406f, 0.05712010f, 0.11834412f, 
    0.07135177f, -0.13923389f, 0.00185388f, -0.18380265f, -0.25883946f, -0.03091867f, -0.04833344f, -0.04497282f, 
    -0.09237162f, -0.06647519f, 0.02033805f, 0.03328661f, -0.11785323f, 0.04958126f, 0.03890458f, -0.03242001f, 
    0.06717769f, 0.07886074f, 0.07658514f, -0.10485128f, -0.27950960f, -0.19058327f, -0.17120224f, 0.09586485f, 
    -0.24927795f, -0.06327430f, 0.03396274f, 0.00508957f, 0.17665865f, -0.05271969f, 0.03316544f, -0.17888777f, 
    -0.18259865f, -0.36090118f, -0.11514887f, -0.10503113f, -0.08423435f, 0.07233662f, 0.21277046f, -0.07451794f, 
    -0.23065110f, 0.12669730f, 0.00584858f, 0.26870629f, -0.16385069f, 0.01597000f, -0.04550268f, -0.18696316f, 
    0.17184183f, -0.13196689f, 0.10696683f, 0.18716167f, 0.24911074f, 0.13776226f, -0.14015986f, -0.06001911f, 
    0.01304455f, 0.02432254f, -0.05253338f, 0.04126012f, 0.28622320f, -0.04649082f, 0.28282109f, 0.11515886f, 
    0.25225791f, 0.09647446f, 0.01900049f, -0.14572558f, -0.03443144f, -0.15701437f, 0.05690979f, 0.04650953f, 
    0.16589072f, 0.19546629f, 0.16049269f, 0.25197986f, -0.01232681f, -0.56704783f, 0.17993961f, 0.03520119f, 
    0.23140797f, -0.08898658f, 0.09266414f, 0.21938755f, -0.10742226f, -0.00161418f, 0.23192987f, 0.14123815f, 
    0.02265072f, 0.10322131f, -0.05787074f, 0.05165478f, -0.00838010f, -0.12173700f, -0.19816142f, 0.03007545f, 
    -0.03176575f, -0.29770657f, -0.32362258f, 0.05785809f, 0.30390573f, 0.00957049f, 0.24608926f, 0.25119308f, 
    -0.16022995f, -0.08917122f, 0.07798714f, -0.20663144f, -0.07900050f, -0.05521030f, 0.21840519f, 0.02980004f, 
    -0.00526037f, -0.05102631f, -0.02841716f, -0.04041510f, -0.07134683f, 0.20579337f, -0.06340269f, -0.14553539f, 
    -0.25379482f, -0.11678512f, -0.28167081f, -0.05775029f, -0.01643983f, -0.11492254f, 0.06892607f, -0.08616392f, 
    -0.04014837f, -0.01009281f, 0.06093905f, -0.29633069f, -0.03070433f, -0.25561151f, -0.12513727f, -0.44301882f, 
    0.18323311f, -0.06406952f, 0.20807613f, -0.22678660f, -0.14553480f, -0.04246485f, -0.14689666f, 0.10209185f, 
    -0.20726053f, 0.04393385f, -0.12294346f, -0.02802966f, 0.17859127f, -0.00125509f, 0.12291932f, 0.03783504f, 
    -0.08814826f, -0.09097275f, -0.27943629f, 0.00694348f, 0.49118477f, -0.12887146f, 0.02945804f, -0.00328528f, 
    0.22210900f, 0.02797653f, -0.17288238f, -0.12539597f, 0.15493965f, -0.00591113f, 0.04303955f, -0.01682130f, 
    0.11224538f, 0.09762346f, 0.03873296f, 0.04888889f, 0.16122411f, -0.03608110f, 0.21785542f, 0.08994831f, 
    0.03794496f, 0.18822692f, 0.05844028f, 0.00910743f, -0.12533984f, -0.00927504f, -0.07318530f, -0.00858842f, 
    -0.10168723f, 0.12460296f, -0.00085370f, 0.14523725f, 0.10414895f, -0.07665856f, 0.01017077f, 0.09203926f, 
    0.14114363f, -0.02755626f, 0.00329289f, 0.21516883f, -0.43289813f, 0.13830882f, -0.04535293f, -0.12433638f, 
    0.27584794f, 0.04147807f, -0.19426607f, 0.34364885f, -0.08304043f, -0.15876490f, 0.03244357f, -0.00888753f, 
    0.02526915f, 0.06806993f, 0.02492495f, 0.14427307f, 0.04332617f, 0.01990918f, 0.05482312f, 0.08353993f, 
    0.30241761f, 0.50760812f, 0.17704923f, 0.19162373f, -0.22759406f, -0.00640356f, -0.09188206f, 0.06105306f, 
    -0.06057100f, 0.10628016f, 0.11447502f, 0.10330112f, 0.08079524f, -0.23754886f, -0.03040020f, -0.18370460f, 
    -0.24126348f, -0.08559679f, -0.01351776f, -0.23146202f, 0.13375662f, 0.26421750f, 0.16003086f, -0.08152130f, 
    0.01160822f, -0.22204678f, -0.12214692f, -0.06249899f, 0.08365149f, 0.14380585f, 0.04888303f, 0.12220625f, 
    -0.06338620f, -0.19962905f, 0.05664408f, -0.11204829f, -0.43075347f, -0.35364190f, 0.01989273f, -0.33033785f, 
    0.09810789f, -0.08369191f, -0.30632097f, 0.08385178f, 0.22875476f, 0.10271867f, 0.10070791f, -0.06012793f, 
    0.10577739f, 0.14100753f, 0.11824813f, 0.08642386f, -0.07821927f, 0.15230471f, 0.03225559f, -0.05703366f, 
    0.20764908f, 0.29115093f, 0.14899781f, 0.24001102f, 0.18018056f, -0.08790373f, -0.16962647f, -0.15885381f, 
    0.06029948f, -0.02214743f, 0.04001800f, -0.06947362f, -0.05866773f, 0.13717586f, -0.00379328f, 0.09459517f, 
    -0.14482841f, -0.03112533f, -0.03881897f, 0.03676976f, 0.05689655f, 0.17138730f, 0.24887945f, 0.08348072f, 
    0.26440427f, 0.56043446f, 0.38669544f, -0.03792486f, 0.25230807f, -0.00221445f, -0.11853582f, -0.10705192f, 
    0.03462842f, -0.10654289f, 0.04286673f, 0.07428577f, -0.15920590f, 0.10705534f, 0.07732744f, -0.08834857f, 
    -0.10099638f, -0.15380889f, -0.01523156f, -0.19527146f, -0.12542857f, 0.09438422f, -0.05793944f, -0.03955462f, 
    -0.10826386f, 0.28730842f, -0.29945472f, 0.09891962f, 0.17905396f, -0.06143900f, 0.06858323f, 0.03316664f, 
    0.13940169f, 0.29127482f, 0.13278763f, 0.04515781f, 0.17603305f, 0.00685022f, -0.02696483f, 0.15348858f, 
    0.12155078f, -0.13397431f, 0.46185505f, -0.12741773f, 0.24393040f, -0.10990889f, -0.00441701f, -0.01512414f, 
    0.13295269f, 0.01272853f, 0.01543934f, 0.16523193f, -0.00114302f, 0.17635418f, 0.01375438f, -0.04277590f, 
    0.10398836f, -0.00076229f, 0.17297436f, 0.09831820f, -0.02329257f, 0.00943794f, 0.20122313f, -0.00952101f, 
    -0.09731758f, -0.14803037f, -0.03692247f, -0.18940113f, 0.04492492f, -0.05360916f, -0.08906953f, -0.06167527f, 
    -0.06159113f, -0.01670927f, 0.07392529f, -0.04659530f, 0.05915213f, -0.00856426f, 0.05280693f, 0.00048665f, 
    0.07653747f, 0.01686567f, -0.06357253f, -0.29296932f, -0.19618757f, 0.08335834f, -0.01967406f, -0.04906049f, 
    -0.06665554f, -0.21434556f, -0.03050084f, -0.02493043f, 0.04045179f, -0.02821474f, 0.11001433f, 0.00813495f, 
    -0.15105592f, 0.04579723f, 0.01669906f, -0.15922533f, -0.12454102f, 0.21696950f, -0.31499052f, -0.30215612f, 
    -0.07049035f, 0.05276538f, 0.08932866f, -0.10595526f, 0.07436462f, 0.07421247f, 0.04001418f, -0.03023566f, 
    -0.01375903f, 0.07067090f, 0.00330362f, -0.01591727f, -0.02039549f, 0.21636885f, 0.04191425f, -0.10982130f, 
    -0.18116175f, -0.40287197f, 0.46458611f, -0.51318353f, 0.19687599f, -0.16781346f, -0.20418391f, -0.21577123f, 
    0.01295227f, -0.20192930f, -0.05925828f, 0.07060608f, -0.15476701f, -0.01646288f, -0.02792478f, -0.00108461f, 
    -0.11139311f, 0.06398061f, 0.03488767f, 0.01909398f, 0.04213855f, -0.23480563f, 0.01693962f, -0.11398286f, 
    -0.02628522f, -0.12529072f, -0.02254538f, -0.09341379f, -0.11741804f, 0.08011840f, 0.00723651f, -0.05753503f, 
    0.10285179f, 0.10543793f, 0.01309376f, 0.01760649f, 0.07202512f, -0.10102667f, 0.07023028f, 0.00113458f, 
    -0.07878787f, 0.04378943f, -0.21418506f, 0.13491112f, -0.12386902f, -0.12295313f, -0.01232065f, -0.16104136f, 
    -0.05503207f, -0.01326050f, -0.17852287f, 0.06426013f, -0.05941324f, 0.03922653f, 0.04153303f, -0.10334518f, 
    -0.15588160f, 0.15134297f, 0.04338515f, -0.05730293f, 0.06829420f, 0.14802083f, 0.02460178f, -0.07288834f, 
    0.15699618f, -0.01883562f, 0.15926459f, 0.20893504f, -0.04062995f, 0.00681981f, -0.03330709f, 0.08792670f, 
    0.11393455f, 0.11355737f, 0.02248509f, 0.04030421f, 0.03060948f, -0.01630696f, 0.00914704f, -0.11085375f, 
    0.04423020f, -0.13929443f, -0.11640272f, 0.04633471f, -0.12861469f, 0.06137222f, -0.11941665f, 0.09290230f, 
    -0.11719950f, 0.02458800f, 0.03442658f, 0.17091644f, -0.04925004f, 0.08875667f, 0.20001444f, 0.07421838f, 
    -0.07874937f, 0.10999413f, -0.06877558f, -0.20395045f, 0.22261345f, 0.84283787f, -0.16826390f, 0.46285698f, 
    0.11876179f, 0.05023395f, 0.15393306f, 0.00456358f, -0.04160884f, 0.41195002f, 0.16291484f, 0.21324471f, 
    0.18015809f, 0.03055343f, 0.13871333f, 0.07904657f, 0.15545432f, 0.28477618f, 0.05133578f, 0.05842772f, 
    -0.06914414f, 0.26512864f, -0.40626201f, 0.11154154f, -0.11904053f, -0.06965013f, 0.02727640f, -0.06268641f, 
    0.08259761f, 0.01727347f, 0.07256423f, 0.19067530f, 0.04587390f, -0.03022061f, 0.03333097f, 0.19862141f, 
    0.10135687f, -0.05284383f, 0.04680205f, 0.24221471f, -0.18527350f, 0.09485526f, -0.43569782f, -0.15912886f, 
    -0.02516439f, -0.05188883f, 0.00929056f, -0.07615311f, 0.00046786f, -0.08904050f, 0.11078720f, 0.02870956f, 
    0.02194662f, 0.17033879f, -0.00050939f, 0.00576161f, -0.00108224f, 0.10283269f, -0.01878111f, 0.23005019f, 
    0.30990270f, 0.24989013f, -0.17175889f, -0.14373071f, -0.08967704f, 0.18546379f, -0.07432649f, 0.23559043f, 
    -0.14229001f, -0.05603724f, -0.02402829f, -0.00574988f, -0.11222883f, -0.00529260f, 0.00429287f, 0.15707842f, 
    -0.16065490f, -0.11588708f, -0.02313912f, 0.04773379f, 0.11839290f, 0.18196407f, -0.09715761f, -0.26435983f, 
    0.00816577f, 0.11727962f, 0.11358265f, 0.06359804f, -0.00908517f, -0.20355150f, -0.00597713f, 0.02288167f, 
    0.03704894f, 0.03347797f, 0.05359985f, -0.04942654f, -0.06661180f, 0.12462156f, -0.07451769f, 0.03890124f, 
    -0.43402621f, 0.04506031f, 0.05215366f, -0.17317055f, 0.09250778f, 0.07400806f, 0.12561262f, 0.07743032f, 
    -0.03354438f, 0.16975689f, -0.17309707f, -0.00446384f, -0.02802717f, -0.03247098f, -0.02940839f, -0.03458673f, 
    0.07564593f, -0.03147476f, -0.01215180f, 0.04443863f, 0.01303087f, 0.02465853f, 0.07183553f, 0.08331450f, 
    0.06580164f, 0.02013357f, -0.05878126f, -0.17770770f, -0.06494077f, -0.16072828f, 0.03454392f, -0.15884183f, 
    -0.09051893f, -0.16602634f, -0.08750619f, 0.18199463f, 0.05429601f, -0.05915201f, 0.04842744f, -0.14342797f, 
    -0.46663067f, -0.00771920f, -0.15562916f, 0.37662509f, -0.07576603f, 0.17124180f, -0.07172687f, -0.04427826f, 
    -0.01593526f, -0.05206754f, 0.00904172f, 0.10805052f, -0.04099542f, 0.04062456f, -0.00498615f, 0.14270151f, 
    0.15548323f, -0.03515901f, -0.04009740f, -0.06069519f, -0.37274283f, -0.08354792f, -0.39711893f, 0.17183273f, 
    0.10745516f, 0.04478243f, -0.07185827f, -0.18575680f, 0.10862496f, 0.09454920f, -0.06143385f, 0.11057910f, 
    -0.14607671f, -0.05550718f, -0.05055972f, -0.01504179f, -0.13468418f, -0.08020544f, 0.05927755f, -0.01111985f, 
    0.31548357f, 0.36172405f, 0.56869453f, -0.06166882f, -0.06901329f, 0.00837339f, 0.19148114f, 0.09700167f, 
    0.20035765f, 0.33932689f, 0.01047387f, 0.02337298f, 0.04395488f, -0.02830854f, -0.07222784f, 0.02158589f, 
    0.13250177f, -0.06984646f, 0.06083603f, 0.04280021f, 0.25131115f, 0.27054659f, 0.07767155f, -0.24014707f, 
    -0.22864443f, -0.09993011f, 0.07328090f, -0.07317402f, -0.18007788f, 0.02292995f, 0.07578053f, 0.07843257f, 
    -0.11450110f, -0.01096467f, -0.07985001f, 0.01055236f, -0.11957663f, -0.09786174f, -0.08811346f, 0.03589167f, 
    -0.51411986f, 0.18594396f, -0.01165677f, 0.34619856f, -0.05533144f, 0.19044015f, -0.11041156f, -0.27741742f, 
    0.20357469f, 0.23083976f, 0.01346219f, 0.01475226f, -0.03048801f, -0.06151876f, -0.10080503f, 0.00587327f, 
    0.07723863f, 0.15119992f, 0.02240167f, -0.06477898f, -0.01029911f, -0.20723191f, -0.24469352f, 0.19339706f, 
    0.14389284f, 0.01615428f, 0.00672255f, -0.11642158f, -0.08870076f, -0.08203530f, 0.03931163f, 0.06739061f, 
    0.01427347f, 0.18292622f, 0.09542464f, 0.03892931f, -0.01179772f, 0.07615697f, -0.09636945f, 0.04801302f, 
    -0.38952330f, -0.11204048f, -0.29899815f, -0.20074159f, 0.23852228f, 0.04823859f, 0.09991766f, -0.09722479f, 
    -0.16038811f, -0.01354412f, 0.15343165f, 0.04752036f, -0.01142155f, -0.02118992f, 0.04476599f, 0.00376041f, 
    -0.10444436f, -0.09811566f, -0.15169892f, -0.24927133f, -0.14965932f, 0.35168093f, -0.18861721f, 0.09798550f, 
    -0.06611535f, 0.04212775f, -0.06127350f, 0.12612483f, 0.00925454f, -0.10630487f, 0.03776614f, -0.03374622f, 
    -0.11189145f, 0.08944482f, 0.15194559f, -0.08350451f, -0.04395901f, 0.11843280f, 0.01439001f, 0.09747331f, 
    -0.08195591f, -0.00490008f, 0.01399315f, -0.35553229f, 0.12361805f, -0.09986448f, -0.08123910f, -0.13076732f, 
    -0.05200846f, -0.05029435f, -0.08983697f, 0.03034645f, -0.09743333f, 0.10850578f, 0.13295943f, -0.11419073f, 
    -0.04121036f, -0.02894585f, -0.04819544f, -0.03491049f, 0.27325022f, -0.39688435f, -0.04598530f, -0.28011343f, 
    -0.13321790f, 0.08714999f, 0.00077558f, -0.01081470f, -0.03596250f, 0.05869408f, 0.10834546f, 0.12554665f, 
    0.02498597f, 0.15070762f, 0.13943718f, -0.04802180f, -0.14724754f, 0.08239096f, -0.01987886f, 0.06721420f, 
    0.23070772f, 0.23886858f, 0.03121831f, -0.33776206f, 0.07728110f, 0.04760815f, 0.02116804f, 0.10633647f, 
    -0.05155962f, 0.16848129f, 0.10562591f, -0.00252356f, 0.08960729f, -0.06394877f, 0.00866608f, -0.00141885f, 
    0.07637212f, -0.20730691f, 0.02492995f, -0.12282915f, 0.45209643f, 0.25926143f, 0.26220420f, 0.02457217f, 
    -0.02595625f, 0.03293157f, 0.03434362f, 0.09607812f, -0.08696701f, 0.05022399f, -0.01904679f, 0.09878942f, 
    0.01131898f, -0.05851152f, -0.06827849f, -0.05596645f, 0.01242540f, -0.10437667f, -0.15008533f, -0.02839392f, 
    0.15960747f, 0.07213026f, 0.17526630f, -0.29793501f, -0.14768670f, 0.11120810f, 0.14460598f, 0.27593493f, 
    0.00193636f, 0.14397080f, -0.10481957f, -0.14368677f, -0.05660650f, 0.06308635f, 0.09491372f, 0.09434342f, 
    0.05666279f, -0.00425039f, 0.09264244f, 0.16168500f, 0.29361749f, 0.24666172f, 0.25243381f, -0.06155761f, 
    -0.09568682f, 0.14742324f, 0.24998578f, 0.17988169f, 0.22045112f, 0.02602275f, 0.13694368f, -0.10681301f, 
    0.03816926f, 0.03080131f, -0.01769472f, 0.03830120f, -0.00691222f, -0.00933330f, 0.03456420f, 0.17214465f, 
    0.13103560f, -0.06569669f, -0.24600282f, 0.06787023f, 0.12414774f, 0.03639819f, -0.01248410f, 0.02198434f, 
    0.08198693f, -0.12809817f, 0.03884111f, -0.08286668f, -0.03240813f, 0.06263047f, -0.03667906f, 0.03889506f, 
    -0.03731228f, -0.01620767f, -0.07119258f, 0.00004483f, -0.16277009f, -0.18545102f, -0.28827173f, -0.20645924f, 
    0.08089733f, 0.07151760f, -0.01163679f, -0.09735535f, -0.13173118f, 0.08283277f, 0.05789997f, -0.01409696f, 
    -0.00022453f, 0.01319118f, 0.05155889f, -0.13669148f, -0.05154884f, 0.26654115f, -0.02562853f, 0.00163413f, 
    0.39087179f, 0.06027475f, 0.29075867f, 0.13527089f, -0.18481170f, -0.06708496f, -0.25482681f, 0.02344012f, 
    -0.04717766f, -0.01116288f, -0.05760848f, 0.11013930f, 0.01185902f, 0.04574588f, -0.05070920f, 0.00288266f, 
    -0.06611480f, 0.02604437f, -0.04596223f, -0.03604827f, -0.26220298f, 0.06013936f, 0.47420892f, -0.03826058f, 
    -0.07999191f, -0.24897186f, -0.20379083f, -0.18356147f, -0.06994622f, 0.14386764f, 0.08623873f, -0.08215598f, 
    0.10188590f, 0.01337082f, 0.10338267f, 0.21675725f, -0.01186155f, 0.03611074f, 0.14176491f, -0.05860081f, 
    0.12873262f, -0.13144854f, 0.01019098f, 0.05494586f, 0.12616144f, 0.01118569f, 0.36135674f, 0.22889812f, 
    0.15343672f, 0.06679536f, 0.09214922f, 0.02700537f, 0.06289855f, -0.12000694f, -0.12644447f, 0.10337517f, 
    0.10134093f, -0.02056488f, 0.03560340f, 0.17829135f, -0.18809777f, -0.49099132f, 0.01515302f, -0.17571443f, 
    -0.12939085f, 0.23223816f, 0.13929242f, 0.24919087f, -0.19528638f, -0.03803201f, 0.12009196f, 0.23438829f, 
    0.01411980f, 0.00861150f, -0.05124325f, 0.18144447f, 0.06105291f, 0.08028871f, -0.08378553f, 0.10925761f, 
    -0.70190597f, -0.36629045f, 0.05467482f, -0.11188071f, 0.42299843f, -0.22498116f, -0.08186477f, -0.06368045f, 
    -0.27889949f, 0.09138709f, 0.10827301f, -0.09444086f, -0.14755136f, -0.07447107f, 0.07047091f, 0.16284448f, 
    -0.10139123f, 0.03281177f, -0.15719229f, -0.04206316f, 0.00325089f, -0.11063734f, -0.27918792f, -0.16734533f, 
    -0.17624182f, -0.00619339f, -0.40535474f, -0.10713752f, 0.00936814f, -0.07545720f, 0.02915845f, -0.07741522f, 
    -0.09016820f, 0.07381909f, 0.03635003f, -0.13191359f, -0.07216094f, -0.01382851f, 0.09632868f, -0.12342300f, 
    -0.42024818f, -0.23421025f, -0.26514715f, -0.27518275f, -0.02396218f, -0.07383762f, -0.03339981f, -0.27657896f, 
    -0.28931215f, -0.02538078f, -0.00431695f, -0.00804698f, 0.10939221f, -0.11141040f, 0.01438777f, 0.05723442f, 
    -0.18574724f, -0.04285276f, 0.13184185f, -0.05125999f, 0.49421051f, 0.17575872f, 0.10648679f, 0.00232297f, 
    0.24026982f, 0.03994858f, -0.09273918f, -0.01695562f, 0.17377600f, 0.14239760f, -0.18971920f, 0.01183522f, 
    0.07652341f, 0.06542291f, -0.03267912f, -0.09178036f, 0.06356117f, 0.17175195f, 0.03037548f, 0.15842986f, 
    0.10857095f, 0.07160470f, 0.18572444f, -0.20520799f, -0.03406666f, 0.17096123f, -0.05488662f, -0.01177001f, 
    -0.09755381f, -0.06361537f, -0.08552304f, 0.08933289f, 0.03544389f, -0.08379340f, 0.03467534f, 0.04034304f, 
    -0.00587691f, 0.23871161f, 0.05958990f, 0.07105687f, -0.53145593f, 0.40910134f, 0.05996116f, -0.22930588f, 
    0.38596210f, 0.05744898f, -0.06086600f, 0.06800233f, -0.10556396f, 0.10149927f, 0.02471905f, 0.24964394f, 
    0.07105041f, -0.05743110f, 0.13185754f, 0.14680263f, -0.03647331f, 0.15911181f, 0.03176419f, 0.02708932f, 
    0.23655732f, 0.45369691f, 0.37728971f, 0.09294905f, 0.09445695f, 0.06295301f, -0.20651586f, 0.15504900f, 
    -0.18965439f, -0.09542298f, -0.08915453f, 0.08457182f, 0.09244260f, -0.11800154f, 0.00843723f, -0.02384366f, 
    0.03912076f, -0.10028406f, 0.05394481f, -0.07508799f, 0.01824342f, 0.11008168f, 0.00951995f, 0.06828099f, 
    -0.06421407f, 0.00445517f, 0.01825081f, 0.09272461f, 0.06496523f, 0.00451254f, -0.05549049f, 0.09433373f, 
    -0.10351751f, -0.18336423f, 0.01547309f, 0.15957838f, -0.03003512f, -0.21336679f, -0.01028280f, -0.00901029f, 
    -0.32316813f, -0.05616181f, -0.11648245f, -0.10575595f, 0.15091763f, 0.04242596f, 0.00020177f, 0.00142950f, 
    -0.02962662f, 0.06818933f, -0.16706721f, 0.01344019f, 0.04896096f, 0.05344585f, 0.00984019f, 0.20569910f, 
    0.20057993f, 0.18700998f, 0.01357840f, -0.05297687f, -0.00302528f, -0.10515595f, -0.04372840f, -0.10834178f, 
    0.02884756f, 0.03234955f, 0.20492582f, -0.07331120f, 0.18546979f, 0.05162087f, 0.00394398f, 0.07630496f, 
    -0.02503076f, 0.12201377f, 0.05997358f, 0.08573986f, -0.05021438f, 0.00703486f, 0.10804841f, 0.07641842f, 
    0.29269409f, 0.39557669f, 0.41633451f, 0.00041870f, 0.41751164f, 0.15629643f, -0.17175061f, -0.15646964f, 
    0.15923721f, -0.07082589f, -0.03529607f, 0.05237096f, -0.00997773f, 0.00759041f, 0.05868462f, 0.02625927f, 
    -0.13405490f, -0.16555347f, 0.08065887f, 0.11786050f, -0.48521763f, 0.10191563f, -0.28703231f, -0.06512018f, 
    -0.20222121f, 0.19222048f, -0.33786175f, -0.18118510f, -0.03974997f, 0.13131289f, 0.24626574f, 0.00426787f, 
    -0.02452970f, 0.04837965f, 0.03984094f, 0.01810792f, 0.10391016f, 0.13464096f, 0.20267136f, 0.02511702f, 
    -0.04389137f, -0.03892146f, 0.00592469f, -0.00676414f, -0.00751809f, -0.01721857f, -0.04432219f, 0.00866067f, 
    -0.04597004f, -0.05010110f, 0.03666505f, 0.02997376f, 0.01177064f, -0.06268349f, 0.01262961f, 0.03440283f, 
    0.00213564f, -0.01633202f, 0.00994891f, 0.02210300f, 0.05984839f, 0.07699955f, -0.03895252f, -0.02527596f, 
    -0.01492909f, -0.00821780f, 0.06342271f, -0.03487283f, -0.00169308f, -0.00560359f, 0.00367056f, -0.05401289f, 
    0.04421604f, -0.05776279f, -0.04379102f, 0.01312308f, -0.05409165f, 0.01524045f, 0.03035761f, 0.00049668f, 
    -0.03252264f, 0.02304736f, -0.06010048f, 0.00298364f, -0.03128004f, -0.03046734f, -0.06856567f, -0.00912431f, 
    0.03617413f, -0.01646331f, 0.04515441f, 0.02357886f, -0.05233224f, -0.05180519f, 0.01731915f, -0.01965617f, 
    0.02904150f, -0.08391073f, 0.00962240f, -0.02580496f, -0.07870121f, 0.02884730f, 0.01316023f, -0.00059695f, 
    0.01843450f, -0.07027514f, -0.02074731f, 0.01651538f, -0.02365370f, -0.04729351f, -0.04158381f, -0.00878422f, 
    0.00828416f, 0.02638829f, -0.08060852f, 0.02463726f, -0.06158651f, -0.03461891f, -0.00179395f, 0.01180468f, 
    -0.02129458f, 0.04184619f, 0.06155587f, -0.01041298f, 0.04824790f, 0.01015350f, -0.00218266f, -0.03180081f, 
    -0.03291452f, -0.04276026f, -0.04090633f, 0.01729873f, 0.00331949f, 0.02359262f, -0.06516296f, 0.00805451f, 
    0.04330157f, 0.03473728f, -0.03860832f, 0.02183171f, 0.02681410f, -0.00978865f, 0.00329459f, 0.05378404f, 
    -0.01224701f, -0.00758189f, -0.03666140f, -0.06011158f, -0.03259471f, -0.01190216f, 0.02212120f, -0.00079349f, 
    -0.02590217f, -0.03669201f, 0.00170584f, 0.01304504f, -0.07019420f, -0.02308161f, -0.00978111f, -0.03297612f, 
    0.00203030f, 0.08115851f, 0.03876818f, 0.01264332f, 0.01315922f, -0.00198046f, -0.03666491f, 0.02809131f, 
    -0.04569130f, -0.06295761f, -0.04575165f, 0.01978926f, 0.03676356f, 0.03435408f, -0.01220435f, 0.03442616f, 
    -0.01666413f, -0.04080442f, 0.02418075f, 0.01489220f, -0.01376944f, -0.05061696f, -0.00897198f, -0.02338390f, 
    0.00248766f, -0.05356523f, -0.03778925f, -0.02586211f, -0.04958173f, -0.00187572f, 0.04161977f, -0.06503308f, 
    -0.08229727f, -0.06135140f, 0.01411782f, -0.05990419f, 0.00875738f, -0.00331044f, -0.07410685f, -0.00834620f, 
    0.02597493f, 0.06172632f, -0.04140475f, 0.00492338f, -0.05604726f, 0.03143096f, -0.02138538f, 0.01307548f, 
    -0.03332679f, -0.00593009f, -0.06492555f, 0.01432766f, -0.03946074f, 0.02094596f, 0.04031843f, -0.05143151f, 
    -0.03177493f, 0.04562749f, 0.05008669f, -0.05080489f, -0.04300912f, 0.00200184f, -0.01946755f, 0.00005113f, 
    -0.02679921f, -0.03036000f, -0.02043697f, -0.06974661f, 0.03251888f, -0.03546013f, -0.06246463f, 0.00652426f, 
    0.01778642f, -0.06620258f, 0.01490133f, -0.04093576f, -0.04963236f, -0.05022593f, 0.03282729f, 0.00346876f, 
    -0.03231744f, 0.00654034f, -0.03780071f, -0.07310434f, -0.00076661f, 0.01186095f, 0.00319174f, -0.06948031f, 
    -0.08270146f, -0.00790836f, -0.02686073f, -0.06091119f, -0.00506687f, -0.02759419f, 0.02668385f, 0.00848197f, 
    -0.03269295f, 0.04256688f, 0.00770920f, -0.05305290f, -0.07029068f, -0.01177684f, -0.03613378f, 0.01104030f, 
    -0.05042108f, -0.02606911f, -0.05227272f, -0.07410739f, -0.06987173f, -0.03563444f, 0.00740984f, -0.01273668f, 
    0.02462870f, -0.03484799f, -0.04392093f, -0.07000975f, 0.01806888f, -0.06990396f, -0.07043077f, 0.01114179f, 
    -0.07598644f, -0.07851718f, -0.05353098f, 0.03579115f, -0.03206650f, -0.01110967f, 0.01415105f, -0.03635945f, 
    0.00625634f, -0.03396066f, 0.01749855f, 0.01480622f, -0.04949746f, 0.00343906f, 0.03923808f, -0.02440494f, 
    -0.07760765f, -0.08087803f, -0.03462993f, -0.01028103f, 0.00204527f, -0.05072728f, -0.04808743f, -0.00945370f, 
    -0.06507187f, 0.02789849f, 0.01794008f, -0.01490677f, -0.04627614f, -0.06315388f, -0.00338362f, -0.01500382f, 
    -0.03594652f, 0.03887231f, -0.04192165f, 0.03359300f, 0.00579906f, -0.07075313f, -0.08640260f, -0.06493381f, 
    0.01323038f, -0.04614008f, -0.03715031f, -0.08069082f, 0.00807575f, 0.00416094f, -0.00539341f, -0.08507341f, 
    -0.00029970f, -0.02581016f, -0.01745093f, -0.04261190f, -0.00222210f, -0.05936608f, -0.03192238f, -0.03697105f, 
    -0.06276859f, 0.01600468f, 0.01638102f, -0.04096039f, 0.01096506f, 0.00560165f, 0.05466307f, 0.02671706f, 
    -0.03249725f, -0.02944194f, 0.01192767f, 0.02053444f, -0.00511613f, 0.03023971f, -0.03746321f, 0.01720713f, 
    -0.03928928f, 0.02618582f, -0.02748224f, -0.00027712f, -0.03269178f, 0.05216501f, 0.04116000f, -0.04284855f, 
    -0.02821904f, -0.00802771f, -0.00469703f, 0.04459612f, -0.05413521f, 0.03788229f, -0.05993739f, 0.00919050f, 
    0.00164896f, 0.02293500f, -0.04454196f, -0.02646795f, -0.00620120f, 0.03661036f, 0.04208170f, 0.04342108f, 
    -0.02719635f, -0.00614166f, -0.05183316f, -0.03409380f, -0.00921610f, 0.02324857f, 0.00433162f, 0.00580550f, 
    -0.00615404f, -0.06433447f, -0.04878654f, -0.01356723f, -0.02570371f, -0.01738953f, -0.00764721f, -0.05356257f, 
    0.00956715f, 0.02176020f, -0.01485118f, -0.05681334f, 0.01643335f, 0.04373239f, 0.01707792f, -0.01527260f, 
    -0.02685739f, 0.02280228f, 0.00327521f, -0.01181676f, -0.00343335f, 0.04419625f, 0.04002065f, 0.05118822f, 
    -0.04356194f, 0.04192244f, -0.05616120f, -0.04761070f, -0.03811364f, 0.00978026f, -0.04654573f, 0.00476397f, 
    -0.04567335f, 0.03038277f, -0.03071079f, -0.05389457f, -0.00565677f, -0.04785518f, -0.04111713f, 0.04357849f, 
    0.04697594f, 0.04395834f, -0.00529720f, -0.02739420f, -0.01427439f, 0.01915545f, 0.04245519f, -0.05909595f, 
    0.03056058f, 0.00193360f, 0.01691466f, -0.05062635f, -0.05586657f, -0.06031075f, 0.03150370f, -0.01968734f, 
    0.01045243f, 0.01945776f, -0.02173905f, -0.01665615f, 0.04616589f, -0.03833263f, -0.01568028f, -0.00724447f, 
    -0.05202327f, -0.03613094f, -0.05132614f, 0.01889024f, -0.05040513f, 0.04253666f, -0.00644043f, -0.01219856f, 
    0.04835850f, -0.00226074f, -0.04525270f, -0.01531929f, -0.04243005f, 0.01284373f, -0.04147041f, 0.00577180f, 
    -0.07093395f, 0.02531553f, -0.04769712f, 0.01708552f, 0.03323907f, -0.04843928f, 0.02075964f, -0.05114551f, 
    -0.00854239f, -0.02989022f, -0.02324703f, -0.03424536f, -0.00022825f, 0.02955753f, -0.03903802f, 0.03166558f, 
    0.01557120f, -0.05994353f, -0.00128622f, -0.02835234f, 0.00099326f, -0.02462957f, -0.02527436f, -0.00275971f, 
    0.02177613f, -0.02380834f, 0.00115763f, -0.02570037f, -0.03870769f, 0.03147911f, -0.02075830f, -0.04386229f, 
    -0.03190089f, -0.00869788f, 0.04347612f, -0.04326637f, -0.05716228f, -0.04510514f, -0.05142168f, -0.04921920f, 
    -0.02896207f, -0.01118960f, -0.04367263f, 0.04821085f, -0.05881535f, -0.01907299f, 0.00332375f, -0.03137317f, 
    -0.00826874f, 0.00707739f, 0.00456721f, -0.02576115f, 0.03481973f, 0.02577537f, -0.03734033f, -0.04872335f, 
    -0.02322041f, -0.00546904f, -0.00647788f, 0.05014966f, -0.03765549f, -0.02151518f, 0.01683165f, -0.04649187f, 
    -0.00291052f, -0.03509981f, -0.04147855f, -0.01378281f, 0.03346463f, 0.01055381f, 0.03426893f, 0.02789161f, 
    0.01786948f, 0.01100370f, -0.03969371f, -0.03221222f, 0.00214539f, -0.05765719f, -0.04483423f, 0.00307133f, 
    0.01444535f, -0.02142309f, -0.04571673f, -0.05676265f, -0.04315155f, 0.02071179f, 0.04349116f, -0.02763978f, 
    -0.01685789f, -0.00593332f, 0.02828942f, 0.00276090f, 0.02800211f, 0.00562791f, 0.00431651f, -0.04190532f, 
    -0.00092610f, 0.01364800f, 0.06066646f, -0.02688032f, 0.02302544f, -0.04211969f, -0.00243185f, -0.04782442f, 
    0.00198569f, 0.04904541f, -0.01371015f, 0.00400935f, 0.01919718f, 0.05376042f, 0.05030266f, 0.04826264f, 
    0.01395984f, -0.03357232f, 0.02739334f, -0.00918638f, -0.06002853f, -0.05574130f, 0.02873014f, -0.04155245f, 
    0.03153004f, 0.02166483f, 0.00392621f, 0.00609794f, -0.00755775f, -0.03232956f, -0.01667678f, -0.05838352f, 
    -0.05166942f, 0.04324767f, -0.03291299f, -0.04955859f, 0.01401347f, -0.02583621f, -0.05844758f, 0.02246307f, 
    -0.03196176f, 0.00850622f, -0.01161437f, 0.00571164f, 0.02240654f, -0.00133924f, -0.01461734f, -0.02168360f, 
    0.03444463f, -0.00122807f, 0.03646537f, -0.04286722f, -0.00675030f, -0.03416883f, -0.02959597f, 0.03246760f, 
    0.00346617f, -0.04815433f, 0.01960339f, 0.00525208f, -0.00156051f, -0.04833781f, 0.01918548f, -0.04615127f, 
    -0.01434073f, 0.02156087f, 0.04663611f, -0.01645535f, 0.04363446f, 0.04349337f, -0.05434357f, 0.03426137f, 
    -0.05324046f, -0.02130691f, -0.04549481f, -0.04181798f, -0.04039916f, -0.02670531f, -0.00892913f, 0.03325128f, 
    0.00215308f, -0.05212974f, -0.00139668f, 0.00986170f, 0.03766045f, 0.01600809f, -0.01462342f, 0.04857808f, 
    -0.02927669f, -0.03859749f, 0.01353229f, -0.02941304f, 0.03089084f, 0.04730801f, 0.03834306f, -0.04610843f, 
    0.04999966f, -0.01795107f, 0.04633714f, -0.01051054f, -0.06763488f, -0.02172633f, -0.03792401f, 0.00250754f, 
    -0.01067417f, -0.00567790f, -0.03792118f, 0.02324905f, 0.05313319f, -0.06029651f, 0.01925444f, 0.02228193f, 
    0.03046183f, -0.00537650f, 0.03537171f, -0.01139384f, -0.00299358f, -0.03086761f, -0.03231758f, -0.02800966f, 
    -0.03374126f, 0.04001725f, -0.02793768f, 0.00035767f, -0.02954081f, -0.03230977f, 0.02100080f, -0.05068696f, 
    0.02965401f, 0.04710417f, 0.01418918f, -0.05069877f, -0.06252853f, 0.01717543f, 0.01356479f, 0.00841685f, 
    0.01989230f, -0.01077108f, 0.03546435f, 0.03813570f, -0.00693400f, 0.03315819f, 0.00793142f, -0.03841764f, 
    0.00021140f, -0.01656360f, -0.01815990f, 0.04639683f, -0.05576893f, -0.01542224f, 0.03955597f, 0.00010090f, 
    0.00865723f, -0.02022204f, -0.03908583f, -0.05155255f, 0.01339978f, -0.01547855f, -0.06504922f, -0.04373217f, 
    -0.05147449f, -0.05917807f, -0.02726774f, -0.05790948f, 0.02968214f, -0.00668289f, -0.02550043f, 0.02608815f, 
    -0.02590484f, -0.04397646f, -0.04334916f, -0.03381182f, 0.03923167f, 0.04488232f, -0.04218001f, 0.05516087f, 
    0.01493105f, -0.00945262f, -0.05628973f, -0.02521525f, -0.02815548f, -0.00433540f, -0.00737781f, -0.00438753f, 
    0.02691469f, -0.00176240f, -0.07064371f, 0.03252024f, -0.02840230f, 0.03364814f, -0.05524188f, 0.03545680f, 
    -0.04489272f, -0.01780882f, -0.06118864f, -0.02934930f, -0.03887250f, -0.05679256f, -0.05401250f, 0.02133704f, 
    0.01889646f, -0.03114083f, -0.05364311f, -0.01368804f, -0.03670688f, 0.03512137f, -0.05229214f, 0.02451745f, 
    -0.04315375f, 0.02160844f, -0.01895904f, -0.03328322f, 0.00730855f, 0.00086070f, -0.06208516f, 0.01178596f, 
    -0.03297772f, -0.00628001f, 0.03294429f, 0.03575356f, -0.03047739f, -0.01121555f, 0.02732299f, -0.00207373f, 
    0.01436037f, -0.02439139f, 0.01535781f, -0.05086961f, 0.04331695f, -0.00145604f, 0.04308573f, 0.03783998f, 
    0.01992244f, -0.03635164f, -0.01306167f, -0.05786893f, 0.02811337f, 0.00081711f, -0.00771563f, 0.02717725f, 
    -0.01928375f, 0.03275277f, 0.02858260f, 0.00675188f, 0.03654531f, -0.03032626f, -0.03155562f, 0.03286747f, 
    0.04282812f, -0.05447837f, 0.01427993f, -0.06789242f, -0.00055362f, -0.04471694f, -0.06432357f, -0.05208860f, 
    -0.03132873f, -0.01418469f, -0.04206828f, -0.01295995f, -0.04749883f, -0.01146158f, -0.06082500f, -0.01187370f, 
    -0.05349083f, -0.00453605f, 0.01864107f, 0.00938121f, -0.06747556f, -0.00660311f, -0.06512979f, -0.03139587f, 
    -0.03785468f, 0.03571983f, 0.03241521f, 0.00426647f, -0.05121415f, -0.02925351f, -0.04801146f, 0.00844219f, 
    0.02050540f, -0.04284753f, 0.03574684f, -0.01262332f, -0.05475834f, -0.00344927f, -0.03360314f, 0.03071152f, 
    0.00107567f, -0.01701921f, -0.00475516f, -0.05511253f, 0.03432807f, -0.00948399f, -0.01303873f, 0.02270212f, 
    -0.04706006f, 0.01764989f, -0.03968142f, 0.01522278f, -0.04501068f, 0.01336466f, -0.00778958f, -0.05447067f, 
    -0.04172687f, 0.00967865f, -0.01987313f, 0.01971194f, -0.01029277f, -0.02649071f, 0.00097974f, 0.00576242f, 
    -0.05150572f, 0.04237430f, -0.02035412f, -0.05078176f, -0.03401800f, -0.01177564f, -0.03563147f, -0.05307562f, 
    -0.02501365f, 0.00845109f, 0.02691635f, -0.04954297f, 0.03564195f, -0.06203004f, -0.06127849f, 0.03704163f, 
    -0.05334452f, -0.00394881f, -0.05830249f, 0.02803850f, -0.02478540f, -0.04150794f, 0.04659794f, 0.03979172f, 
    0.02953054f, -0.01116933f, 0.02012204f, -0.03397695f, 0.03620496f, 0.05064113f, -0.00834035f, 0.00019320f, 
    0.00498739f, -0.05340084f, 0.04043375f, -0.06160731f, -0.03130993f, -0.03381077f, -0.00090094f, -0.04447223f, 
    -0.03992967f, 0.04290630f, -0.04256549f, -0.00793568f, -0.02821513f, -0.03143431f, -0.02507473f, -0.06558307f, 
    0.02118372f, -0.03956050f, 0.01021433f, -0.01996169f, -0.05107366f, -0.06517976f, -0.06021398f, 0.04106182f, 
    -0.05049911f, -0.06480959f, 0.06170114f, 0.05668781f, -0.04085219f, -0.00526453f, -0.02698132f, 0.03719417f, 
    0.05990244f, 0.02083907f, 0.00688331f, 0.01843648f, -0.03531319f, 0.01219447f, 0.02734680f, 0.00864590f, 
    0.04171549f, -0.01286884f, -0.01433996f, -0.00001847f, -0.05499085f, -0.01842866f, -0.01014901f, -0.03416217f, 
    -0.01830165f, 0.05516079f, 0.01977753f, 0.02711321f, -0.02271007f, -0.04766412f, 0.01677814f, -0.03469024f, 
    -0.05175294f, -0.05689741f, -0.01242843f, -0.05009219f, 0.05232416f, -0.03982504f, -0.05235358f, 0.02923210f, 
    -0.02109271f, -0.02164028f, -0.05708240f, -0.04026873f, 0.03512357f, 0.01732332f, -0.01132845f, 0.01251224f, 
    0.00184891f, -0.01765902f, -0.04407991f, -0.01201630f, 0.02411473f, 0.01245328f, 0.03794993f, -0.02645024f, 
    0.03781157f, -0.03934355f, -0.06268673f, 0.04139432f, -0.01225094f, -0.05168780f, -0.05607144f, 0.03989648f, 
    -0.01347142f, 0.01417658f, -0.03899965f, 0.01731796f, -0.05667758f, 0.01270083f, -0.02350706f, 0.00845837f, 
    -0.00805635f, -0.02814256f, 0.03627862f, 0.05145863f, -0.01239490f, -0.05539989f, -0.02008602f, -0.03098120f, 
    0.04828783f, -0.01990672f, 0.04193765f, -0.04993295f, 0.00973502f, 0.01258940f, 0.00818799f, 0.03127732f, 
    -0.03202010f, 0.03621468f, -0.01886837f, -0.01470389f, -0.04903748f, -0.01144649f, 0.01354761f, -0.02499723f, 
    0.04905526f, 0.04082533f, 0.03531706f, 0.04810159f, 0.00565535f, 0.04674641f, -0.01364642f, 0.01293657f, 
    -0.00837634f, -0.05335376f, 0.02582522f, -0.00451594f, -0.04755440f, 0.02295785f, 0.00477062f, -0.04055850f, 
    0.00163193f, -0.03867658f, -0.03456857f, -0.00667187f, 0.03057680f, -0.02854771f, -0.02323843f, 0.02036691f, 
    0.02467602f, -0.04272523f, 0.01163016f, 0.02683653f, 0.01015245f, 0.02875675f, 0.03379195f, -0.03815977f, 
    0.04517976f, -0.02673795f, -0.05539847f, -0.05326351f, 0.05589142f, -0.01088427f, 0.00712854f, 0.04922123f, 
    -0.02431919f, 0.01325369f, 0.04113219f, -0.04444700f, 0.03288745f, 0.04797636f, 0.02549564f, -0.03576352f, 
    0.03311668f, -0.02833268f, -0.04819240f, 0.03981925f, 0.00217723f, 0.05071558f, -0.03199797f, -0.00078196f, 
    0.00379544f, 0.03271907f, -0.00791866f, -0.04258034f, -0.01675167f, 0.05293464f, 0.02071254f, -0.00574078f, 
    0.05036385f, -0.03927320f, -0.03768428f, -0.04068352f, -0.03532640f, -0.01094236f, 0.01023172f, -0.05419923f, 
    -0.04753939f, -0.01957443f, 0.00559184f, 0.05128367f, 0.01252726f, -0.04163976f, 0.02588929f, -0.02073460f, 
    -0.05355088f, -0.05248012f, -0.05329078f, 0.03284353f, -0.04230223f, 0.00790309f, -0.03730763f, -0.01994437f, 
    0.00012669f, 0.04535815f, -0.01591963f, -0.05209269f, -0.00047947f, -0.01501328f, 0.02063228f, 0.04596661f, 
    -0.01480891f, -0.03968773f, 0.01258738f, -0.00132176f, 0.01725661f, 0.04739432f, -0.03187601f, -0.02764173f, 
    0.04707360f, -0.01547624f, 0.01547423f, -0.00985695f, -0.03508298f, -0.04278877f, -0.02200693f, 0.04015816f, 
    0.01056965f, -0.05380850f, -0.01883879f, -0.02693241f, -0.02846788f, -0.01358089f, 0.04054734f, -0.02925028f, 
    -0.01126845f, 0.01596789f, 0.02268549f, -0.01851370f, 0.00914623f, 0.02039950f, 0.02432185f, -0.04155135f, 
    -0.02542065f, -0.00321815f, 0.00686569f, 0.00302706f, -0.03969146f, -0.01690464f, -0.00388992f, 0.03921364f, 
    -0.01230944f, -0.05248177f, -0.03558895f, 0.02275240f, 0.01740962f, 0.05196075f, -0.00456148f, 0.03215304f, 
    0.04218436f, 0.01765837f, -0.00512822f, 0.03191123f, 0.03894278f, -0.05574662f, -0.03331492f, -0.02696162f, 
    0.01215230f, -0.04246913f, -0.04263629f, -0.01596152f, -0.01124738f, -0.01949532f, 0.05186084f, 0.03170939f, 
    -0.00039092f, -0.02544556f, 0.04933659f, -0.02810080f, 0.01795410f, -0.03830993f, 0.05507176f, -0.04311157f, 
    -0.04203699f, -0.01001909f, -0.05086238f, -0.01381799f, -0.05374582f, 0.01358721f, 0.00331418f, -0.01485247f, 
    -0.02620665f, -0.02875273f, 0.03532353f, -0.01380571f, 0.04334590f, -0.04490112f, 0.04452159f, 0.00318990f, 
    -0.00865284f, 0.01411108f, 0.00593570f, 0.00561768f, -0.03985498f, -0.03834391f, -0.02960607f, -0.04935773f, 
    -0.04893691f, -0.05565325f, -0.04547030f, 0.04024961f, -0.03792000f, -0.04631449f, -0.03654184f, 0.05483468f, 
    -0.05195413f, -0.03606683f, 0.04970537f, 0.04240207f, 0.05576297f, -0.04652798f, 0.03276490f, 0.04518622f, 
    -0.05477531f, -0.03702174f, -0.03960168f, -0.01216368f, 0.01512854f, 0.02011250f, 0.04105450f, -0.01532413f, 
    -0.04655865f, 0.04622819f, -0.00729196f, -0.05007707f, -0.05516322f, -0.01804097f, 0.02991563f, -0.02659728f, 
    0.00976979f, -0.04541215f, -0.05588612f, 0.03772898f, -0.04280594f, -0.03720942f, 0.02155421f, -0.04123252f, 
    -0.02339403f, -0.02898191f, 0.03276301f, 0.04999103f, -0.04484739f, -0.00504293f, 0.04686172f, -0.03081423f, 
    -0.04676647f, -0.03640299f, -0.00509722f, 0.02340949f, -0.02219089f, 0.01142287f, -0.03790430f, 0.04964995f, 
    -0.03852112f, -0.01464553f, -0.04739557f, -0.04976453f, -0.05324383f, 0.02676979f, -0.03972564f, 0.05183131f, 
    -0.01089281f, -0.00885513f, 0.04596337f, 0.04051289f, 0.01230240f, -0.02013537f, -0.04900536f, -0.01499425f, 
    -0.03643348f, 0.00671021f, -0.00565991f, 0.02325757f, 0.04747811f, 0.05180444f, 0.04719085f, 0.03500706f, 
    -0.05536744f, -0.03367983f, -0.03965228f, -0.02579352f, -0.03694007f, -0.02401574f, -0.03439619f, -0.02999057f, 
    0.00012414f, -0.04164437f, 0.02529355f, -0.04131789f, 0.03034772f, -0.03763863f, -0.01947166f, -0.04626255f, 
    -0.02359025f, -0.01732294f, -0.03711743f, 0.02272254f, 0.02479757f, -0.03867789f, -0.00869024f, 0.00432318f, 
    0.03814703f, 0.14806399f, -0.16404761f, 0.06245561f, -0.11783838f, 0.00956034f, 0.00703371f, 0.08005194f, 
    -0.00642209f, -0.12188048f, 0.02552980f, 0.02995496f, -0.01970834f, -0.02345199f, 0.08566135f, 0.07731973f, 
    0.07432434f, 0.15376522f, 0.05031075f, 0.06360722f, -0.19314550f, 0.01901146f, 0.07769053f, 0.14459154f, 
    -0.03848254f, 0.01714627f, -0.02204253f, -0.03359689f, -0.11347965f, -0.05396999f, -0.00057008f, -0.05464366f, 
    -0.11289566f, 0.10602461f, -0.12728991f, 0.11266083f, -0.01446383f, 0.27628285f, 0.05557798f, 0.13128561f, 
    0.14681202f, -0.30063504f, -0.05846346f, 0.19431691f, 0.39454487f, -0.05954333f, -0.11468720f, 0.12895682f, 
    0.08629058f, 0.12382022f, 0.03126155f, 0.07264650f, 0.02393425f, 0.00120479f, -0.05503268f, 0.20519070f, 
    0.10129670f, -0.05722737f, 0.00381292f, 0.03189356f, 0.16753510f, -0.08250094f, -0.03339680f, 0.45505908f, 
    -0.10081734f, 0.02039033f, 0.02549321f, 0.00802393f, 0.02228678f, -0.05839324f, 0.12503953f, 0.01872641f, 
    -0.02060936f, -0.06103664f, 0.14191768f, -0.02803819f, 0.06975948f, 0.14493524f, 0.17372823f, 0.24465288f, 
    0.10651682f, 0.17436507f, 0.03955699f, 0.03438846f, -0.23691337f, -0.04498517f, -0.01647415f, 0.24074292f, 
    0.13812231f, -0.03330563f, -0.07673717f, -0.03171119f, -0.11418199f, -0.09832981f, -0.01819116f, -0.08648335f, 
    -0.04651308f, 0.28684053f, 0.00988057f, 0.07912562f, -0.09883755f, 0.08544193f, 0.00322795f, -0.00416187f, 
    -0.05613939f, -0.05666166f, -0.08184061f, -0.00726225f, -0.04280692f, -0.14419299f, 0.00584884f, -0.02104544f, 
    0.05893825f, 0.08484790f, 0.08062130f, -0.00711255f, -0.02557348f, 0.07696485f, 0.00164325f, 0.04531446f, 
    -0.16088723f, -0.06688386f, -0.07844064f, -0.00914522f, -0.09016801f, -0.10261212f, 0.04222867f, -0.15255977f, 
    0.05300849f, -0.03502549f, 0.03378314f, 0.01063529f, 0.06785248f, 0.04289253f, 0.04955583f, 0.00093125f, 
    0.08431649f, -0.03295754f, 0.08037674f, -0.02453890f, 0.05056939f, 0.38879374f, -0.40266183f, 0.07976279f, 
    -0.05422818f, 0.12720975f, -0.01174539f, -0.11450864f, -0.07823989f, -0.12562957f, 0.01109585f, 0.01472488f, 
    0.06954367f, 0.17637637f, 0.00579094f, -0.11932468f, -0.12502104f, 0.13345231f, 0.02536281f, 0.03552870f, 
    -0.27333510f, 0.02225601f, 0.01774553f, 0.03590760f, -0.01356058f, -0.06016307f, 0.04062146f, -0.06037761f, 
    -0.07517540f, -0.16225918f, 0.02363747f, -0.14560832f, 0.07890826f, 0.04893647f, 0.08717580f, 0.04636604f, 
    0.07142486f, 0.09186736f, 0.00937493f, -0.10998454f, -0.23700120f, -0.32575941f, 0.39809898f, 0.10323900f, 
    0.05174587f, 0.19372359f, 0.14619654f, -0.04826134f, 0.03704406f, -0.06577434f, -0.12850384f, 0.19603837f, 
    0.13647513f, 0.12650584f, 0.25613916f, 0.13824187f, -0.04143706f, 0.09242179f, 0.05336325f, 0.05725995f, 
    -0.10112659f, -0.15222825f, 0.24742353f, 0.22155108f, 0.40819868f, 0.06336757f, 0.03217736f, 0.01224913f, 
    0.02962588f, 0.06770902f, -0.08180268f, 0.01128108f, 0.14789613f, -0.01835669f, -0.02412118f, 0.04479048f, 
    0.07848525f, 0.07537115f, -0.00135147f, 0.18057781f, -0.09818400f, -0.33809641f, 0.08559594f, 0.19966963f, 
    0.00614975f, 0.11073380f, -0.03470572f, 0.01219811f, 0.06919952f, 0.03379297f, -0.04164372f, 0.00147146f, 
    0.07875409f, -0.10103504f, -0.04399448f, -0.01040625f, 0.10712534f, 0.00323583f, -0.05517203f, -0.11587634f, 
    -0.45816487f, -0.00883024f, -0.16117825f, -0.13617043f, 0.06342229f, -0.14834146f, -0.07920779f, -0.01412346f, 
    0.20690162f, 0.08568948f, 0.00187231f, 0.04645377f, -0.01787557f, 0.08365387f, 0.01701456f, 0.20030020f, 
    0.09446047f, 0.19342038f, -0.06674861f, 0.01364780f, -0.29806751f, -0.17959590f, -0.00738480f, 0.05282377f, 
    -0.05531487f, 0.18221162f, -0.12880169f, 0.02329281f, 0.10883493f, 0.17917448f, 0.01875240f, 0.01026760f, 
    -0.03910321f, -0.00850051f, -0.00798040f, 0.07873444f, 0.04468392f, -0.04252139f, 0.04210966f, -0.04238315f, 
    -0.07506179f, -0.02470723f, -0.06009421f, -0.01258033f, -0.10708158f, 0.15260834f, -0.03800674f, -0.16870214f, 
    -0.09118159f, 0.05124833f, 0.21738507f, 0.03629258f, 0.07208377f, 0.00848788f, 0.01471775f, -0.01124025f, 
    -0.01143193f, -0.02852851f, 0.07583218f, 0.00836341f, -0.17695969f, -0.10100017f, -0.09344081f, 0.05026078f, 
    -0.07192559f, -0.02062702f, -0.04731354f, -0.07490887f, -0.04610081f, -0.11128055f, -0.18089977f, 0.02965353f, 
    -0.02350413f, -0.13763784f, 0.01862407f, 0.08298017f, -0.00422679f, 0.16789757f, -0.00595148f, 0.00011377f, 
    -0.17320822f, 0.05400485f, -0.06558536f, 0.18351671f, 0.16281071f, 0.03205715f, 0.02156076f, -0.07476049f, 
    0.16056420f, 0.08342483f, 0.22810715f, 0.12058347f, 0.16744015f, 0.08759844f, 0.03434873f, 0.03916391f, 
    0.10248826f, 0.00964353f, 0.13252991f, -0.04503003f, 0.29733965f, 0.02887575f, -0.09106179f, 0.26812476f, 
    0.31423473f, -0.08144169f, 0.08114065f, -0.09908178f, 0.03670641f, -0.06975832f, -0.04564806f, 0.01968626f, 
    -0.02946936f, 0.03291244f, -0.08533747f, 0.03883453f, 0.06997902f, -0.00795992f, 0.06134404f, -0.07153668f, 
    0.10133566f, 0.07960820f, 0.06264499f, 0.04330259f, 0.03618561f, 0.09379847f, -0.27635089f, -0.14990133f, 
    -0.06976960f, -0.11671663f, 0.00457412f, 0.04315901f, 0.10008618f, 0.09147607f, 0.08834320f, 0.07842372f, 
    -0.08115070f, 0.16830969f, 0.10743143f, -0.21027681f, 0.11558262f, 0.16720724f, 0.07278209f, 0.22316161f, 
    -0.18039702f, -0.04790704f, 0.17779978f, 0.20636706f, -0.12256921f, -0.02180228f, -0.03194392f, -0.16820869f, 
    0.01339672f, 0.04948337f, 0.11068793f, -0.04448448f, -0.04180708f, 0.13531119f, 0.05227775f, 0.13185924f, 
    0.34182253f, 0.15513201f, 0.08501407f, 0.02636550f, -0.12466315f, 0.24759004f, 0.02466323f, 0.05285040f, 
    0.11275577f, -0.05618617f, -0.16618936f, -0.05655279f, -0.03883643f, -0.07743316f, -0.04150346f, 0.17563924f, 
    0.12926984f, 0.04576513f, 0.02377997f, 0.01981374f, 0.05459532f, 0.04383044f, 0.00573643f, 0.08268421f, 
    0.07382433f, -0.02727223f, 0.08004881f, 0.01380598f, -0.01153390f, 0.01331406f, 0.20477597f, 0.21013393f, 
    0.26235238f, 0.22835033f, 0.20459116f, -0.04257915f, -0.05807244f, -0.00818819f, -0.11202947f, 0.01769981f, 
    0.13054353f, 0.07367158f, 0.02943086f, 0.17637676f, 0.08281330f, 0.01519712f, 0.07503673f, -0.05571635f, 
    0.00447715f, 0.01133746f, 0.06035767f, 0.08481349f, 0.13009404f, 0.15252355f, 0.05924594f, -0.21432684f, 
    -0.17130125f, 0.02564886f, -0.12675548f, -0.12981026f, -0.81587017f, 0.17694655f, -0.23322912f, -0.13000864f, 
    -0.10170754f, 0.03216022f, 0.08874083f, -0.05964367f, -0.09237504f, -0.12479909f, 0.19017094f, -0.11784311f, 
    0.12743929f, 0.14409195f, 0.02262536f, 0.01066432f, -0.00068913f, 0.05046419f, 0.00892683f, -0.03830265f, 
    -0.03848870f, -0.06308559f, -0.01117307f, 0.12345486f, 0.13247721f, -0.11715463f, -0.02645118f, -0.06837059f, 
    -0.07902828f, -0.06633176f, 0.26000524f, 0.09015021f, 0.10544239f, 0.29877666f, 0.16107084f, -0.03756193f, 
    0.00897778f, -0.03171403f, -0.10464215f, -0.15419118f, 0.67502081f, -0.17181470f, 0.19081920f, 0.16737837f, 
    -0.16280764f, 0.11806247f, 0.14797473f, 0.03579434f, 0.06746658f, 0.15650286f, 0.21476009f, 0.11034995f, 
    0.36410713f, 0.06940784f, 0.11978780f, 0.03216098f, 0.06155664f, 0.08349045f, 0.11351933f, 0.30154577f, 
    -0.15464984f, -0.23452103f, -0.01179975f, 0.01039196f, 0.02199434f, -0.04597715f, 0.12340253f, 0.13099985f, 
    0.24164571f, 0.11499791f, 0.15233363f, 0.14448765f, -0.11162409f, -0.09198540f, -0.04378955f, 0.06767467f, 
    0.07418562f, 0.01255098f, 0.08430354f, 0.10304064f, -0.08796807f, -0.15503894f, 0.09697853f, 0.04704361f, 
    -0.09943838f, -0.11660442f, -0.00851500f, 0.03023279f, -0.00230240f, -0.05564175f, -0.03753982f, 0.10676223f, 
    -0.06297357f, -0.10541696f, -0.13189737f, -0.04565686f, 0.01169298f, 0.00934102f, -0.04495132f, 0.05706832f, 
    -0.10133069f, 0.08629102f, 0.10232056f, -0.06362858f, -0.16088283f, 0.04183758f, -0.13830598f, -0.01004666f, 
    0.13487352f, 0.09090279f, -0.00893899f, -0.07494197f, 0.03852549f, 0.07678559f, 0.06078492f, 0.05504254f, 
    -0.03761413f, -0.04714928f, 0.02759242f, 0.12186007f, -0.27889851f, -0.00259981f, 0.16356872f, 0.07401057f, 
    -0.09710742f, 0.11478870f, -0.03937766f, 0.15843870f, -0.01904212f, 0.00655746f, -0.03084633f, -0.03022122f, 
    0.00712596f, -0.03510718f, 0.05361479f, -0.04393570f, 0.05605759f, 0.04589582f, 0.11913146f, 0.09230484f, 
    -0.35560104f, -0.11406395f, -0.13894270f, -0.02499589f, -0.22054525f, -0.02176815f, -0.02779176f, -0.01237944f, 
    -0.04494334f, 0.14593935f, -0.00164239f, -0.08436465f, -0.03283596f, -0.07705468f, -0.20523976f, -0.06396545f, 
    -0.02931442f, -0.01641413f, -0.13544984f, -0.06424099f, 0.34772345f, -0.04279609f, 0.25144854f, 0.02985922f, 
    0.26693419f, -0.07777494f, -0.07338535f, -0.03788682f, -0.05665227f, -0.02052588f, -0.12418819f, 0.03872969f, 
    0.10308164f, -0.04458708f, 0.08714262f, 0.16756684f, 0.02861700f, 0.09988283f, -0.10420506f, -0.11980584f, 
    0.03266197f, -0.05441324f, -0.00539002f, -0.03712707f, -0.04676583f, -0.00207469f, -0.02734856f, 0.03097470f, 
    -0.01043468f, -0.04352072f, 0.02455579f, 0.01590106f, 0.01722535f, -0.02462841f, -0.04563038f, 0.00892888f, 
    0.00844114f, 0.04096003f, -0.03795681f, 0.01647872f, -0.02641711f, -0.04016790f, -0.03831656f, 0.04443714f, 
    -0.00583543f, 0.00458214f, 0.02202089f, -0.02937763f, -0.03920674f, 0.01589082f, 0.00193674f, -0.00583831f, 
    0.06133517f, 0.01613358f, -0.02423843f, -0.05629526f, -0.03196342f, -0.02205839f, -0.05937168f, -0.01277152f, 
    0.03635725f, 0.02053311f, -0.05185346f, 0.02113832f, 0.04680467f, -0.00711976f, -0.05070268f, 0.05443160f, 
    -0.01749340f, 0.04582622f, -0.03575643f, 0.01622073f, 0.04200578f, -0.01012072f, -0.02781177f, -0.05118303f, 
    0.02259351f, 0.01149016f, 0.01432411f, 0.03982452f, 0.03560496f, 0.03072516f, 0.02704617f, 0.01545876f, 
    0.01958500f, -0.01727735f, -0.00327254f, 0.01293487f, 0.02452399f, -0.01503809f, -0.02926236f, -0.03940761f, 
    -0.04795328f, 0.04564871f, 0.02436976f, -0.01332758f, -0.05400706f, -0.02321484f, -0.03344512f, -0.01618974f, 
    -0.01777590f, 0.03694449f, 0.00208866f, 0.03220828f, 0.05559728f, 0.02119893f, 0.04492094f, -0.03207988f, 
    -0.03501185f, -0.01737529f, -0.01803307f, -0.04272949f, -0.04297891f, -0.05916813f, -0.01232631f, -0.04183818f, 
    0.04099696f, 0.04065014f, -0.04046418f, 0.01170489f, -0.04091315f, 0.02017184f, 0.03833228f, -0.03115815f, 
    -0.02350787f, -0.02771156f, -0.04356266f, -0.03801079f, -0.00734754f, 0.02232762f, -0.01445713f, -0.01716535f, 
    -0.04741973f, 0.03483266f, -0.05743564f, -0.01457328f, -0.04091919f, 0.04491637f, -0.00374687f, 0.00608598f, 
    -0.05415918f, -0.04135584f, -0.03761641f, -0.03395571f, -0.02806270f, -0.02806138f, -0.05027326f, -0.03620181f, 
    0.03907899f, 0.01394049f, 0.04706629f, -0.03537248f, 0.00458947f, 0.04777627f, -0.04114971f, -0.01911095f, 
    0.04754460f, 0.05871275f, 0.02500831f, -0.02684480f, -0.01890898f, 0.04200425f, -0.01082802f, -0.05611524f, 
    0.01438978f, -0.00337768f, -0.03857863f, 0.01797410f, 0.03987553f, 0.03608680f, -0.00679919f, 0.01671428f, 
    -0.06063542f, -0.00056569f, 0.01833206f, -0.05268721f, -0.00993361f, -0.03864510f, 0.04876949f, -0.00542207f, 
    0.00910788f, 0.01457381f, -0.05079720f, -0.03019882f, -0.06171095f, -0.00619231f, 0.04537411f, -0.00388814f, 
    0.01558965f, -0.05029482f, -0.04251352f, -0.01982450f, -0.03916608f, 0.04364742f, -0.00192680f, -0.00384863f, 
    -0.05814411f, -0.05385399f, -0.05905404f, 0.03578389f, -0.05409641f, -0.04837309f, 0.02907185f, 0.04323228f, 
    -0.05851162f, 0.04096265f, 0.03008570f, -0.02934055f, -0.02524423f, 0.03596553f, -0.02570728f, -0.00104843f, 
    0.04882000f, 0.00185954f, -0.02826089f, 0.02272141f, 0.01679419f, -0.00606318f, 0.04692381f, -0.02354015f, 
    -0.06019788f, 0.01280317f, -0.05026155f, 0.00297109f, -0.02589549f, -0.00322590f, 0.03142947f, -0.05626122f, 
    0.00557967f, -0.03728108f, 0.00942163f, 0.02985488f, -0.01352471f, -0.00420010f, -0.05130325f, -0.01272154f, 
    -0.05890593f, 0.03364999f, 0.00468530f, -0.00491271f, -0.04189428f, 0.04434936f, 0.00496247f, -0.00577672f, 
    0.04163816f, -0.01424320f, 0.05033506f, 0.04008389f, 0.03225778f, 0.00801947f, -0.00254119f, -0.02535633f, 
    0.02956614f, -0.01533475f, 0.03299724f, 0.03005814f, -0.04676369f, -0.00262680f, -0.04857691f, -0.01127821f, 
    0.04087696f, 0.02930949f, -0.00947349f, -0.04262099f, 0.04359360f, -0.04525955f, 0.01211261f, 0.01472278f, 
    0.02525841f, -0.03615096f, -0.04984567f, -0.01147654f, -0.00781590f, -0.03294007f, -0.04185629f, -0.01057896f, 
    0.03200690f, 0.00287218f, 0.04838782f, 0.00633896f, 0.03474448f, -0.01920421f, -0.06174112f, -0.05496421f, 
    0.04387622f, 0.04525592f, 0.04289990f, -0.05265096f, 0.00861930f, -0.01932829f, 0.03324789f, -0.01368611f, 
    0.02695583f, -0.01821787f, -0.02201430f, -0.04835464f, -0.02772026f, -0.05208529f, -0.00722021f, -0.02574587f, 
    -0.01635725f, 0.01712437f, 0.03429493f, -0.03350069f, -0.04242081f, -0.05322148f, 0.03423203f, -0.04840476f, 
    0.02244557f, -0.02339534f, -0.00568610f, -0.03211905f, -0.05860468f, 0.02263507f, 0.02144219f, -0.03606837f, 
    0.00244804f, 0.02108575f, -0.01949183f, 0.05071642f, 0.03633498f, -0.02944393f, -0.00457473f, 0.00368338f, 
    0.01511726f, 0.04689387f, -0.00545978f, 0.00916515f, 0.05296732f, 0.01212224f, -0.01655930f, -0.01442756f, 
    -0.05257972f, 0.04231666f, -0.03046897f, 0.01921359f, 0.05255372f, -0.04663721f, -0.00433974f, -0.05905817f, 
    0.15962560f, -0.08041511f, 0.12841569f, -0.07953891f, 0.16886970f, 0.04115225f, 0.12984498f, -0.10828032f, 
    0.08920642f, -0.03002768f, -0.03174850f, 0.14278848f, -0.09417500f, 0.10832796f, 0.05671041f, 0.01698957f, 
    0.09480588f, 0.05056975f, 0.15945779f, 0.03360987f, 0.32183307f, 0.00464078f, 0.31729996f, 0.00540183f, 
    0.19659548f, -0.02783354f, -0.03091019f, -0.14006279f, -0.04590228f, -0.14620993f, -0.23145908f, -0.06081230f, 
    -0.15917553f, 0.05601696f, 0.00306548f, -0.03028711f, -0.00766900f, -0.11808303f, 0.10057775f, 0.02421099f, 
    -0.13712384f, -0.02786565f, 0.01788800f, -0.02256661f, -0.34795114f, 0.20602557f, -0.18435119f, 0.08259784f, 
    -0.21466662f, 0.10014747f, -0.06531055f, 0.02690342f, 0.01145041f, 0.08828319f, -0.07021166f, 0.12116764f, 
    -0.02065819f, 0.06982166f, -0.00641650f, -0.06027936f, -0.22141808f, 0.29308793f, -0.11588817f, -0.16218783f, 
    0.16071174f, 0.02529648f, -0.24346641f, 0.01238238f, 0.19020367f, 0.10194058f, -0.08048765f, -0.09947594f, 
    -0.03889154f, -0.06491393f, -0.12371590f, -0.04101413f, 0.05307076f, 0.02399786f, 0.16296326f, 0.12182178f, 
    -0.15884499f, 0.07505320f, 0.20919576f, -0.26463714f, -0.38474360f, -0.03643710f, -0.25497741f, -0.11501815f, 
    -0.12284841f, -0.02062162f, -0.29384628f, -0.00635059f, -0.03672602f, -0.06577273f, -0.21246627f, 0.07193949f, 
    -0.08863387f, -0.11317712f, 0.07221153f, 0.06301375f, 0.03847491f, -0.05902560f, 0.08017334f, 0.00047145f, 
    -0.00265920f, -0.13005307f, 0.00535478f, -0.11153294f, 0.02663867f, -0.09424834f, 0.12737705f, 0.14355303f, 
    0.14566667f, 0.03049257f, -0.00906696f, 0.08851505f, -0.00840474f, 0.04369092f, 0.12055688f, 0.06430412f, 
    0.03824758f, -0.01539261f, -0.02749602f, 0.04497042f, 0.01309226f, -0.22496890f, -0.12420204f, -0.08754647f, 
    0.02198982f, -0.04960232f, -0.01697939f, 0.14016621f, 0.00227411f, 0.15451913f, 0.14963335f, -0.02867709f, 
    -0.05600083f, 0.15350051f, 0.08413984f, 0.08873739f, -0.05568020f, -0.03655684f, 0.30277547f, 0.24184972f, 
    -0.11464799f, -0.03745434f, 0.04289548f, -0.07191461f, 0.11914612f, -0.13979238f, 0.15288968f, 0.08383694f, 
    0.03033558f, -0.08764656f, 0.01698166f, 0.05591777f, -0.10864411f, 0.01145200f, -0.07503952f, -0.06786094f, 
    0.04958157f, -0.26319268f, 0.11362702f, 0.04143974f, 0.12709114f, -0.15447108f, -0.06879706f, -0.15362601f, 
    0.02097266f, -0.16573068f, 0.07971639f, 0.00257832f, -0.04906383f, 0.06745027f, 0.18356094f, 0.03614176f, 
    -0.06633537f, 0.00912928f, 0.02646564f, 0.00134779f, 0.55929524f, 0.06439491f, 0.05464337f, 0.46015742f, 
    -0.19308537f, 0.06041431f, 0.00309318f, -0.00755153f, 0.10383401f, 0.20280689f, 0.04579936f, 0.14910977f, 
    0.11261094f, -0.00791074f, 0.05464669f, -0.02818348f, -0.01912661f, -0.04422503f, 0.02237705f, 0.06364637f, 
    -0.19550647f, -0.33753598f, 0.27823406f, 0.00716046f, -0.02341066f, -0.02727701f, 0.06347392f, 0.06604458f, 
    0.03976355f, -0.10981449f, -0.01981445f, -0.05269092f, 0.03565859f, 0.23120342f, 0.07478523f, 0.07421360f, 
    -0.01825435f, -0.04236416f, -0.00210652f, 0.23291413f, -0.31237981f, -0.20379263f, -0.24330144f, 0.10569735f, 
    -0.04899232f, -0.02855235f, -0.04757708f, 0.03264780f, -0.02393647f, -0.04854763f, 0.02245039f, 0.00116763f, 
    0.07469428f, 0.10946912f, -0.14154987f, 0.02021942f, 0.10780042f, 0.09159536f, 0.04789875f, 0.19617614f, 
    0.15255596f, -0.03391083f, 0.37615281f, 0.11886927f, -0.28263730f, 0.08269936f, -0.00915516f, 0.19035462f, 
    0.18736053f, -0.01388197f, 0.12219526f, -0.00827324f, 0.04682350f, -0.26985979f, -0.18381087f, -0.02698160f, 
    -0.12159839f, -0.25665024f, -0.04642231f, -0.05828812f, 0.02426122f, 0.19813548f, 0.20071135f, 0.17259496f, 
    0.06901876f, -0.01142951f, 0.01565340f, 0.07066645f, 0.09721281f, 0.01486998f, -0.00013695f, -0.04375079f, 
    0.06910197f, -0.14270130f, 0.03595484f, 0.09087732f, 0.04215353f, -0.00090318f, -0.19663168f, 0.03484732f, 
    0.21987239f, -0.32176143f, -0.10399574f, 0.03139705f, -0.15262641f, -0.09652492f, 0.01602864f, -0.06260701f, 
    0.11784396f, -0.02880934f, 0.08369027f, 0.02111053f, 0.13284752f, -0.03425019f, 0.01113534f, -0.08408157f, 
    -0.03580027f, -0.05895799f, 0.08534769f, -0.03028461f, 0.31122276f, -0.06088480f, 0.06013139f, 0.07622679f, 
    -0.17254983f, -0.17867820f, -0.03283128f, -0.11971229f, -0.13417013f, -0.04990707f, -0.22998080f, 0.07628145f, 
    -0.00446342f, -0.10056356f, -0.03670568f, 0.19549483f, -0.05043479f, 0.05053010f, 0.02588470f, -0.16554695f, 
    0.33427185f, 0.12039377f, 0.00751607f, -0.08872832f, -0.14310074f, -0.00178994f, 0.05037198f, 0.04867478f, 
    -0.04529386f, -0.00056112f, -0.03422136f, 0.05357044f, 0.10583509f, -0.04470667f, 0.02764159f, 0.07289186f, 
    -0.02310541f, -0.27160704f, 0.19256580f, -0.00049245f, 0.04121863f, 0.14624979f, 0.38061160f, -0.17525910f, 
    -0.12101527f, 0.05484289f, -0.25913242f, 0.23632914f, 0.07996535f, -0.16250323f, 0.08658652f, -0.15671100f, 
    -0.11810219f, -0.04002024f, -0.09457437f, 0.10340489f, 0.06182709f, -0.09720838f, 0.06426375f, -0.12021969f, 
    -0.41946447f, -0.52280802f, -0.22907656f, 0.05923493f, -0.37901586f, 0.07820723f, 0.05713946f, -0.06432550f, 
    -0.16195588f, 0.23087345f, -0.04272721f, -0.00624754f, 0.05649378f, -0.08839048f, 0.00523012f, -0.04624925f, 
    -0.00710276f, 0.00959469f, 0.03552619f, 0.15003392f, -0.09814292f, -0.30943003f, -0.12227131f, 0.12340389f, 
    0.16499941f, 0.14287421f, -0.00608834f, -0.22875637f, 0.12964432f, 0.12680957f, 0.12202725f, -0.01837059f, 
    0.07055717f, -0.11654200f, -0.27168787f, -0.09260499f, 0.16099770f, -0.13853753f, 0.03734655f, -0.03393722f, 
    -0.26609939f, -0.02138495f, 0.13046488f, -0.05834474f, -0.24511030f, -0.07386734f, -0.09735189f, -0.00092524f, 
    -0.07017588f, 0.07654317f, 0.08886272f, -0.17612772f, 0.05930917f, -0.02466395f, -0.13988112f, -0.02588597f, 
    -0.03567091f, -0.25174591f, 0.03516535f, -0.11029043f, -0.07337873f, 0.09718709f, 0.10654531f, -0.06478264f, 
    -0.09207430f, -0.23498166f, -0.14930595f, 0.12590845f, -0.17016855f, -0.15551424f, 0.08429597f, 0.00778011f, 
    -0.02435585f, 0.03541818f, -0.12717891f, 0.00735708f, -0.10822696f, -0.11796159f, -0.07529652f, 0.05324226f, 
    0.17437397f, -0.00938214f, 0.23382458f, -0.28312364f, 0.04298912f, -0.08744733f, -0.29324472f, -0.08789501f, 
    -0.07586066f, -0.26572230f, 0.18367551f, 0.01539523f, -0.03151039f, 0.02159150f, -0.09029208f, -0.08048969f, 
    -0.12378919f, 0.00354273f, -0.01722730f, -0.24288309f, 0.43226290f, 0.02750175f, 0.14964831f, 0.23007657f, 
    -0.09844721f, 0.15993398f, -0.11308371f, 0.05729554f, 0.32565349f, -0.12288056f, 0.09889412f, 0.03826257f, 
    0.03580881f, 0.04596730f, 0.31815547f, 0.22831659f, 0.10796676f, -0.00585716f, 0.10336726f, 0.07745255f, 
    0.17737813f, -0.03485928f, 0.13136141f, -0.24410385f, 0.12026599f, -0.20786026f, 0.16685708f, -0.13321428f, 
    0.15230803f, -0.16214889f, 0.19281822f, 0.05896107f, 0.06444255f, -0.07037976f, 0.04902789f, 0.03908138f, 
    0.01087906f, -0.13124901f, 0.07945738f, 0.04329115f, 0.33242330f, 0.19944322f, 0.02593590f, 0.16791013f, 
    0.11401723f, 0.15269099f, 0.04633017f, 0.30856320f, -0.28522256f, 0.03876842f, -0.03799864f, 0.20453790f, 
    0.13548286f, 0.08282097f, 0.09466389f, 0.00070828f, 0.09607107f, -0.05963837f, -0.04826077f, 0.13121113f, 
    -0.16145201f, -0.10264698f, 0.30993426f, -0.55097318f, -0.18383558f, 0.07806397f, -0.20713086f, 0.06852140f, 
    0.20151384f, -0.17728530f, 0.12129876f, 0.20652303f, 0.08881754f, 0.14912263f, 0.14188012f, -0.13231891f, 
    -0.14900301f, -0.03850035f, 0.00783687f, 0.01200208f, -0.34148040f, -0.18802471f, -0.29575720f, 0.15926830f, 
    -0.14065047f, 0.05060695f, 0.03151615f, 0.09218700f, 0.00144294f, -0.01080343f, 0.05147896f, 0.03098952f, 
    -0.02630568f, 0.06446300f, 0.00897036f, 0.20285214f, -0.20095174f, -0.00887783f, 0.17257477f, 0.02696625f, 
    0.22108105f, -0.54067075f, 0.10117586f, -0.07280399f, -0.28552091f, 0.05729849f, -0.27808711f, 0.15457125f, 
    0.45695600f, 0.11050008f, 0.14590092f, -0.19036002f, -0.02775169f, -0.12396177f, 0.11003290f, -0.05937397f, 
    0.01516926f, 0.10296949f, 0.10412021f, 0.03411013f, 0.12167078f, -0.18526955f, -0.09477499f, 0.12877019f, 
    -0.21383025f, -0.09498032f, -0.13485035f, -0.18406244f, 0.15142550f, 0.17397191f, 0.04866342f, -0.04638237f, 
    -0.10280525f, -0.07121261f, 0.06003694f, -0.03028225f, 0.10770690f, 0.23846938f, 0.09729540f, -0.00083677f, 
    0.45846957f, 0.12655436f, -0.02954729f, 0.06046999f, 0.07987836f, 0.07437229f, -0.00949555f, -0.02072798f, 
    0.13444625f, -0.13389757f, 0.08189665f, 0.20928589f, 0.03884412f, 0.04748584f, 0.17040616f, -0.06712960f, 
    -0.14441517f, 0.08544787f, 0.08638442f, -0.02266574f, 0.07785647f, 0.01305688f, 0.05848370f, 0.07991829f, 
    -0.05955574f, -0.05084914f, -0.15408650f, 0.23611459f, -0.25458139f, -0.13413078f, 0.00570928f, 0.10132250f, 
    0.07412677f, 0.04639474f, -0.05493302f, 0.15819237f, 0.04477307f, -0.01272212f, -0.01742091f, 0.03447426f, 
    -0.17348121f, -0.16583593f, 0.20541698f, 0.12037031f, 0.16812779f, -0.12917836f, 0.09700361f, -0.03783793f, 
    0.07282938f, 0.14924088f, 0.13065694f, 0.11170836f, 0.08400117f, 0.04838388f, 0.09195553f, -0.05547001f, 
    0.08336540f, -0.14015335f, 0.10753616f, -0.01800705f, 0.25308788f, 0.01016054f, 0.00279099f, 0.02857709f, 
    0.12048822f, -0.14303590f, -0.02487355f, 0.10225370f, -0.05384060f, 0.04040058f, -0.03409724f, 0.09256889f, 
    0.04939730f, 0.02390372f, 0.07755627f, -0.03734874f, 0.11374506f, -0.03465886f, 0.01751566f, -0.04753279f, 
    -0.07099147f, 0.25383940f, -0.02770542f, -0.28159204f, -0.35188672f, 0.03767631f, -0.04776923f, 0.01152651f, 
    -0.04104344f, -0.03698398f, -0.07489134f, 0.05668874f, 0.09570453f, 0.00840203f, 0.09139691f, -0.05340532f, 
    -0.24648607f, 0.18033598f, -0.09648307f, -0.09256694f, -0.23248722f, -0.07284413f, 0.08149895f, -0.29817808f, 
    0.10591974f, -0.03712833f, 0.27060887f, 0.07771915f, 0.22988939f, 0.16018061f, -0.01842234f, -0.05750424f, 
    -0.00563572f, 0.13715136f, -0.12984833f, 0.02571054f, -0.22445744f, 0.01453069f, 0.00383385f, -0.02364471f, 
    0.06708150f, -0.26846021f, -0.27375942f, -0.01550017f, 0.05771026f, -0.00928857f, -0.03453945f, 0.21128255f, 
    -0.14559071f, -0.12111042f, -0.10121765f, -0.01151240f, -0.00958574f, 0.03614057f, -0.00932728f, 0.12473763f, 
    -0.04830712f, -0.15215085f, 0.03547179f, -0.17451683f, 0.02327103f, 0.01170851f, 0.16470221f, 0.02594936f, 
    0.16646677f, 0.02302530f, 0.03164878f, -0.03214086f, 0.03807317f, 0.07304194f, 0.23351665f, 0.08079294f, 
    0.05310525f, 0.03633367f, 0.01040667f, -0.12279145f, -0.08799214f, -0.06638443f, -0.03498432f, -0.01604098f, 
    0.25053400f, 0.01990666f, 0.04702797f, 0.15583706f, 0.02228017f, 0.00223431f, -0.00222848f, 0.05897004f, 
    0.07828410f, -0.00887449f, 0.00353042f, 0.21009994f, 0.03458535f, 0.01019367f, 0.06473089f, -0.10674135f, 
    -0.19359827f, -0.02100847f, -0.04655847f, -0.03443687f, -0.14623171f, -0.13448027f, 0.42580914f, 0.04888724f, 
    -0.10107679f, -0.00081350f, 0.10167845f, 0.05046291f, 0.02643173f, -0.04439416f, -0.04732818f, -0.05530933f, 
    -0.02791352f, -0.01504251f, 0.02719335f, 0.07722398f, -0.01269394f, -0.02251903f, 0.00646323f, -0.03121514f, 
    0.23000179f, 0.07827197f, 0.07895824f, 0.09458851f, 0.14211431f, -0.08465029f, 0.01894628f, -0.04581558f, 
    0.02313406f, 0.03919114f, 0.14837873f, 0.22738597f, 0.08916545f, -0.01670831f, 0.10606847f, -0.05424926f, 
    -0.14091624f, -0.02056864f, -0.04961074f, -0.09158191f, 0.47224081f, 0.29337311f, -0.07353269f, 0.26391718f, 
    -0.19431286f, 0.12585481f, -0.03663365f, 0.00837620f, 0.14187193f, 0.10414941f, 0.10951336f, 0.01763194f, 
    0.19983155f, -0.04791598f, 0.03436210f, 0.01899863f, 0.05591405f, 0.05917048f, 0.08986129f, 0.17137335f, 
    -0.03246067f, 0.32543036f, 0.01923185f, 0.04316076f, -0.45329702f, -0.04603693f, 0.13233615f, 0.16175044f, 
    0.08156081f, 0.07632652f, 0.25851545f, 0.20353529f, -0.03498534f, -0.03704309f, 0.11667521f, 0.01240478f, 
    -0.14173043f, 0.06442509f, -0.02686422f, 0.10784853f, -0.40012872f, 0.24021779f, 0.06949908f, -0.10224976f, 
    -0.10981003f, -0.09528825f, 0.15076587f, 0.05798332f, 0.09022701f, -0.02609377f, 0.07746278f, 0.07168691f, 
    -0.12029511f, 0.09812358f, -0.03283370f, -0.02805636f, -0.10892504f, -0.08672190f, 0.03072678f, 0.04640076f, 
    0.49165511f, 0.18875080f, 0.07533566f, 0.04397708f, -0.30291802f, 0.09520050f, 0.01685443f, -0.05446812f, 
    0.05375121f, 0.00622764f, 0.00154794f, -0.09830245f, -0.01793350f, -0.17089865f, -0.14531749f, -0.05729150f, 
    -0.12502645f, 0.04243874f, 0.00384907f, 0.05475497f, -0.01709015f, 0.28994694f, 0.06918117f, -0.02728540f, 
    -0.00142176f, -0.09876873f, 0.01629470f, -0.06568114f, -0.16974907f, -0.01081581f, -0.07912903f, 0.00387534f, 
    -0.00277407f, -0.09316190f, -0.02146557f, 0.05935259f, 0.00569780f, 0.12653291f, 0.02362565f, -0.07330797f, 
    -0.18209413f, 0.15691124f, 0.23048903f, 0.00244459f, -0.08204974f, -0.15940717f, -0.00898022f, -0.02304537f, 
    0.07530233f, 0.01763779f, -0.23425265f, -0.06718554f, -0.04623005f, 0.07112338f, -0.08874293f, -0.10375293f, 
    0.00635706f, -0.06860477f, -0.08890957f, 0.01332905f, 0.36067560f, 0.04554395f, 0.16036320f, -0.00712508f, 
    0.07292444f, -0.07504558f, -0.09175041f, 0.06260846f, 0.01821505f, -0.05161661f, 0.08263357f, 0.18328893f, 
    0.03584193f, 0.18990748f, 0.10533513f, -0.00859869f, 0.02679166f, -0.03823967f, 0.04796658f, -0.06074425f, 
    0.32158551f, 0.18876939f, 0.07251332f, -0.19425890f, -0.00890987f, -0.01954832f, 0.00750795f, -0.00300264f, 
    -0.03161956f, -0.04590515f, 0.04705916f, 0.06504856f, 0.13121253f, 0.11984060f, 0.08624910f, 0.04434855f, 
    -0.02792888f, -0.13592267f, -0.01424452f, 0.11547390f, -0.13463341f, 0.10579844f, 0.12796074f, 0.04006894f, 
    -0.17290294f, -0.02077060f, -0.08090653f, -0.01955857f, 0.15158492f, 0.00449904f, -0.09851052f, 0.04889365f, 
    -0.13736026f, 0.10927109f, 0.03626845f, -0.01038703f, 0.09973285f, 0.12802884f, -0.02268775f, 0.00991561f, 
    -0.15964872f, -0.17621581f, -0.07835896f, 0.10555559f, 0.24535798f, 0.16373187f, 0.17515269f, 0.05464373f, 
    0.04176864f, 0.15358739f, -0.12176364f, -0.13480824f, -0.03649039f, -0.01784402f, -0.11676179f, -0.02493605f, 
    0.10300707f, -0.00581465f, 0.02928443f, 0.22584227f, 0.05502035f, 0.18155396f, -0.10759285f, 0.23189643f, 
    0.07527141f, -0.05559522f, -0.05251762f, -0.23614977f, -0.07887527f, -0.07424407f, 0.04222637f, 0.15842316f, 
    0.05257360f, 0.06205500f, -0.11908825f, -0.05325015f, -0.00751581f, 0.00909454f, -0.25264817f, 0.11170241f, 
    -0.09152061f, 0.16555031f, 0.86982363f, 0.00233803f, 0.08949204f, -0.05742460f, -0.00573065f, -0.13848321f, 
    0.11289250f, 0.01790407f, 0.05985387f, -0.02597467f, 0.04577426f, 0.02866512f, -0.01229317f, -0.09857408f, 
    0.04827679f, -0.22312276f, -0.15384924f, 0.03002532f, 0.01422007f, 0.04785026f, 0.04646740f, 0.02911872f, 
    -0.10717004f, 0.00877734f, 0.04060596f, 0.12524383f, 0.13327713f, 0.07959944f, -0.03792034f, -0.01751902f, 
    0.01888655f, 0.07359965f, 0.18275507f, 0.02701051f, 0.05444603f, -0.07949566f, 0.01821033f, -0.08669014f, 
    -0.17280591f, -0.00508714f, -0.03497317f, 0.08855251f, -0.03020142f, -0.06345367f, -0.00615090f, 0.03705642f, 
    0.13562679f, 0.04648238f, 0.01734274f, 0.19063975f, -0.03558642f, 0.25387186f, 0.04122549f, -0.03205081f, 
    0.13799565f, 0.13086331f, 0.02852297f, -0.02287383f, 0.34759638f, -0.23840964f, 0.32356679f, 0.05924587f, 
    0.20355864f, -0.03094024f, 0.22230513f, 0.16382343f, -0.01643873f, -0.08629368f, 0.07176875f, 0.02087737f, 
    -0.07075847f, -0.11486760f, 0.12584330f, -0.06382959f, 0.04556942f, -0.06235514f, -0.04922636f, -0.10197516f, 
    -0.13262853f, -0.06910838f, -0.08664131f, -0.00455447f, -0.08048221f, 0.03416672f, -0.07192084f, 0.11726615f, 
    0.07898235f, 0.05153814f, -0.07547263f, 0.14473127f, -0.03980329f, 0.13031101f, 0.01028643f, 0.02112289f, 
    0.09098684f, 0.09788205f, 0.06571073f, 0.01121092f, -0.26157877f, 0.29008421f, 0.17561530f, 0.16823396f, 
    0.17707784f, -0.10607891f, 0.11643576f, -0.01668761f, -0.10235032f, 0.01014743f, -0.03821477f, -0.00063046f, 
    -0.18237358f, 0.15506372f, 0.08412345f, -0.06444374f, 0.06294502f, 0.06500453f, -0.12918146f, -0.18426114f, 
    0.09070683f, -0.29034498f, -0.43220839f, 0.26869759f, 0.18086064f, 0.10723729f, -0.04061166f, -0.01213393f, 
    0.07938702f, 0.03353268f, -0.12587698f, 0.01894074f, 0.23464771f, -0.12503882f, -0.04407408f, -0.18050145f, 
    -0.07866232f, -0.17036241f, 0.07307755f, -0.08609339f, 0.09093230f, -0.17668301f, -0.24271226f, 0.08989614f, 
    0.34648210f, -0.00101250f, 0.06102717f, -0.07736361f, -0.15634930f, 0.02221063f, 0.09972147f, 0.00359374f, 
    0.05244932f, 0.02064130f, -0.02892769f, 0.00993490f, -0.05334381f, -0.02852309f, -0.05171264f, -0.10023962f, 
    0.13669558f, -0.00180971f, -0.01275354f, 0.18320695f, 0.41195050f, 0.08128507f, 0.15092079f, 0.13845709f, 
    -0.09500054f, 0.05525104f, -0.10980570f, -0.02881933f, -0.05291604f, 0.03176402f, 0.05398212f, 0.08129771f, 
    0.09447967f, -0.07293293f, 0.05297886f, 0.08317166f, 0.25663850f, 0.07431516f, -0.19126871f, 0.17328383f, 
    0.19399504f, 0.05034200f, 0.02966792f, 0.05436076f, 0.00628934f, -0.01472381f, -0.11595428f, -0.05060715f, 
    -0.04881721f, -0.08601233f, -0.11014915f, 0.05723936f, -0.02142357f, 0.06312874f, -0.04629182f, 0.12618272f, 
    0.13012514f, -0.10678072f, -0.17068438f, 0.11744282f, 0.20710307f, -0.00189400f, -0.01746074f, 0.23927830f, 
    0.04051820f, 0.06636577f, 0.20776810f, 0.02992553f, -0.04002716f, -0.11168519f, -0.03349553f, -0.00994811f, 
    -0.07355306f, 0.00762049f, -0.03479008f, -0.16159429f, -0.20508741f, 0.02295507f, 0.08998585f, 0.14321436f, 
    -0.09748891f, 0.06797756f, 0.05089702f, 0.02104668f, 0.08381516f, 0.06775168f, -0.04412980f, 0.01435695f, 
    -0.01642756f, -0.07163208f, 0.08320517f, -0.01482574f, 0.13714074f, 0.03550613f, 0.02824253f, -0.05646598f, 
    -0.14055100f, -0.11572301f, 0.02370064f, -0.05377631f, -0.18477581f, -0.03102561f, -0.00150996f, 0.07155718f, 
    0.03483300f, -0.19279109f, 0.16112824f, 0.01586804f, -0.04693032f, 0.06082076f, 0.11785286f, 0.01839366f, 
    0.20731379f, 0.14907916f, 0.08233766f, 0.04107133f, -0.18096489f, 0.00672741f, 0.15640935f, 0.10946494f, 
    0.08109576f, -0.06313359f, -0.06734966f, -0.06308168f, -0.06562060f, -0.14126007f, -0.14380194f, 0.01967391f, 
    -0.04689050f, -0.08369081f, -0.04020652f, -0.23280169f, 0.09981637f, -0.02445897f, -0.01048069f, -0.03148106f, 
    0.32712132f, 0.46987346f, 0.15280025f, -0.07331139f, 0.16526546f, 0.08812945f, -0.17183395f, 0.18255633f, 
    -0.06957184f, 0.13121626f, 0.00637414f, 0.03860680f, 0.01710944f, 0.12141332f, 0.06154012f, 0.10840859f, 
    -0.06407978f, 0.08194661f, -0.33005995f, -0.37092707f, 0.06901409f, 0.11598350f, 0.00866338f, -0.13171682f, 
    -0.01810608f, 0.00518525f, 0.01031404f, 0.07756446f, -0.00503763f, 0.16840471f, -0.06526931f, -0.02238349f, 
    0.03793563f, 0.08713034f, 0.14413673f, -0.02637618f, 0.11977078f, 0.16508992f, 0.13312842f, 0.37922540f, 
    0.00364486f, 0.27116781f, -0.26725322f, 0.16879144f, -0.16903150f, -0.01588188f, -0.14806661f, 0.19834135f, 
    -0.03121712f, -0.14644502f, -0.09547943f, -0.08675107f, -0.17283811f, -0.01416931f, 0.00750931f, 0.23364520f, 
    0.09016820f, -0.02641718f, -0.09088673f, -0.05480277f, -0.11917856f, -0.21901393f, 0.00850704f, -0.08221188f, 
    -0.15451133f, -0.06917492f, -0.11163650f, -0.04621958f, -0.11011762f, -0.15698533f, 0.15836087f, 0.05038365f, 
    -0.01907674f, 0.11709559f, 0.13941938f, -0.00292834f, 0.06094938f, 0.01680513f, 0.02238297f, -0.00811731f, 
    -0.14478855f, -0.23090369f, -0.15402451f, 0.07976279f, -0.10189522f, -0.16246273f, 0.00495608f, -0.15420125f, 
    -0.00221806f, -0.09084829f, -0.08652131f, 0.11910662f, 0.02080063f, -0.03313711f, 0.01227726f, -0.18197735f, 
    -0.04053917f, -0.02218249f, -0.00456599f, 0.09526344f, 0.35615820f, 0.30062672f, -0.30051225f, -0.14646478f, 
    -0.29364899f, -0.01791633f, 0.02377944f, 0.02605579f, -0.03404351f, 0.02641186f, 0.05124911f, -0.00707910f, 
    -0.00627479f, 0.01236751f, -0.02691748f, 0.07573557f, 0.02607257f, -0.03059396f, 0.01406794f, -0.07739188f, 
    0.02736818f, -0.15158121f, 0.02209075f, 0.12427653f, -0.09081054f, -0.12970722f, -0.03268041f, -0.03341022f, 
    -0.03225085f, -0.10136321f, -0.02140865f, -0.06084499f, -0.01776671f, -0.00885756f, 0.16423784f, -0.04021574f, 
    -0.03354002f, -0.04083662f, -0.02802777f, -0.15580907f, 0.38528270f, -0.20031846f, 0.08570494f, 0.14759763f, 
    -0.10690959f, 0.02866633f, 0.07924221f, -0.04755304f, 0.18159108f, 0.11285838f, -0.06204838f, 0.01130406f, 
    -0.07371651f, 0.02924449f, 0.13510451f, 0.01000562f, 0.03139299f, 0.06098248f, -0.01619212f, 0.12927344f, 
    -0.05068890f, -0.04318000f, -0.04705648f, 0.13500954f, 0.07756893f, -0.05221989f, 0.10308871f, 0.03401655f, 
    0.05418494f, 0.32450849f, -0.07752372f, -0.01496119f, 0.07742324f, 0.12119545f, -0.06286652f, 0.02639503f, 
    0.11440259f, 0.18219301f, -0.02927623f, 0.13971952f, -0.00316318f, -0.06834276f, -0.01453745f, 0.02790711f, 
    -0.01944385f, -0.11010707f, -0.15227458f, -0.00372098f, 0.05492673f, 0.12979603f, -0.06323772f, -0.05261089f, 
    0.04693811f, 0.08757897f, -0.02814651f, 0.04186573f, 0.06969134f, 0.02034707f, 0.10823097f, 0.21627668f, 
    0.27863273f, 0.54713768f, -0.07361192f, -0.10274166f, 0.08193037f, -0.06863666f, 0.08149465f, 0.09671275f, 
    -0.10810629f, 0.12922202f, 0.03903176f, 0.03492761f, 0.03004686f, -0.05784606f, 0.08999129f, 0.11132519f, 
    0.01176050f, -0.06044794f, 0.04144854f, 0.09085591f, 0.07515182f, 0.40085614f, 0.04425633f, -0.09611375f, 
    0.23614521f, 0.10079147f, 0.07635961f, 0.24612474f, 0.00506032f, 0.06847716f, -0.01510202f, 0.00441382f, 
    0.02179155f, 0.06805731f, 0.03923065f, 0.04300669f, -0.00271180f, -0.08618426f, 0.02383218f, 0.09398106f, 
    -0.04932220f, -0.21867155f, -0.34159598f, -0.19121532f, -0.28277639f, -0.01263626f, 0.03521188f, -0.11414756f, 
    -0.06719598f, 0.14970386f, 0.10547912f, -0.01145176f, 0.01465675f, -0.07395862f, -0.08909124f, 0.00136133f, 
    0.19787781f, 0.07408406f, 0.06696926f, 0.08228906f, -0.08421006f, -0.09135945f, 0.04565804f, 0.04183188f, 
    -0.03698065f, -0.08034298f, -0.05626436f, -0.11962932f, -0.00964407f, -0.09292547f, -0.03651207f, -0.01608587f, 
    -0.18998280f, -0.12877093f, 0.10096297f, 0.08006196f, 0.08366255f, 0.17870763f, -0.10355859f, -0.06991352f, 
    0.01525470f, -0.01191565f, 0.01764433f, -0.01553185f, -0.04247996f, 0.00818699f, -0.04061659f, 0.00356060f, 
    -0.06252627f, -0.01830933f, 0.03740234f, -0.01958230f, -0.01974374f, -0.04042661f, -0.04442595f, -0.05155750f, 
    -0.00460432f, -0.02783966f, -0.01384101f, -0.02928268f, -0.04098636f, -0.03461055f, -0.01156032f, 0.03892988f, 
    0.03184919f, 0.03739858f, 0.03840893f, -0.04914496f, -0.00579430f, 0.03146691f, 0.01178012f, 0.03795791f, 
    -0.03620848f, 0.00209576f, -0.04511322f, 0.03034815f, 0.03521859f, 0.00113079f, 0.01355732f, 0.03860790f, 
    0.01882081f, 0.03850292f, -0.03884580f, 0.04307936f, -0.01216993f, 0.00681007f, 0.02412127f, -0.03693347f, 
    0.00795325f, -0.00785494f, -0.03557238f, -0.03849592f, -0.01499500f, 0.04119165f, -0.00593181f, -0.04823296f, 
    0.05296182f, -0.01688038f, 0.04555650f, 0.00297583f, -0.05301498f, 0.03044550f, -0.03194753f, -0.05238064f, 
    0.00163453f, 0.03743858f, -0.01466899f, -0.01952324f, -0.00201663f, 0.02163666f, 0.01213659f, -0.03184025f, 
    -0.00956670f, -0.00601017f, -0.02799296f, 0.02155339f, 0.01674689f, 0.01864556f, -0.02872527f, -0.02528495f, 
    -0.00046029f, -0.04908206f, 0.02125733f, -0.00278511f, -0.00469321f, -0.04533992f, -0.03735748f, -0.02516893f, 
    -0.06069473f, -0.02223036f, 0.01529035f, 0.03004577f, -0.02099044f, 0.01913923f, 0.02311010f, -0.00856464f, 
    0.04148912f, -0.03483196f, 0.03245348f, -0.02385099f, 0.04375633f, 0.03506092f, 0.04987594f, 0.01209604f, 
    -0.00915146f, -0.04159130f, 0.02768746f, -0.04252572f, -0.04067025f, -0.02147382f, 0.00801437f, 0.03285975f, 
    -0.00904927f, -0.04038498f, 0.02928021f, -0.02896927f, -0.03753026f, -0.04256279f, -0.00701775f, -0.03958133f, 
    -0.03368677f, 0.05039271f, 0.01832418f, 0.02427696f, -0.03914696f, 0.00925800f, 0.02349055f, 0.01735974f, 
    0.00768230f, -0.05158098f, -0.00148630f, -0.04997760f, 0.02809681f, 0.00243473f, 0.01351007f, -0.04096086f, 
    0.00197545f, -0.06149257f, 0.02954956f, 0.04389598f, -0.03466041f, 0.05305529f, -0.05784963f, -0.01862102f, 
    0.02639392f, -0.03733676f, -0.02645234f, -0.05999583f, -0.00152252f, 0.01824568f, 0.03133762f, 0.05025918f, 
    0.03359432f, -0.01282018f, -0.02633631f, -0.03648109f, -0.01421939f, 0.01910499f, -0.05133978f, -0.00064598f, 
    0.04718779f, 0.02970294f, -0.05507684f, -0.02080517f, -0.01793340f, 0.04573901f, 0.02383384f, -0.05175461f, 
    0.02493965f, 0.01639623f, 0.01715245f, -0.04471425f, 0.04949975f, 0.04589938f, -0.02824239f, -0.02417580f, 
    -0.03469497f, 0.01098800f, 0.03131817f, -0.06326604f, 0.03029784f, 0.03087743f, 0.04904471f, 0.00799868f, 
    -0.04478392f, 0.02030288f, 0.02023080f, -0.00008296f, -0.01695031f, -0.04239601f, 0.02452412f, 0.02407234f, 
    -0.05793229f, 0.04431332f, -0.03597261f, -0.05964440f, 0.03382381f, -0.01457270f, -0.05462805f, -0.02985239f, 
    -0.00237758f, -0.05319490f, -0.04292932f, 0.04415034f, 0.01063337f, -0.01668084f, 0.04257766f, -0.02949644f, 
    0.01607567f, 0.04481791f, -0.03417199f, -0.00003298f, 0.05288120f, 0.03119906f, 0.01249432f, 0.01757587f, 
    0.03086131f, 0.00092911f, 0.04530477f, 0.04717641f, -0.02258333f, 0.01776519f, -0.03485177f, 0.01565991f, 
    0.02967522f, 0.01620874f, 0.01186186f, -0.02954034f, -0.06095440f, -0.06130152f, 0.02954640f, -0.02868383f, 
    -0.00702853f, 0.02190769f, -0.01930953f, -0.04061528f, 0.00718164f, 0.03287108f, 0.01553387f, -0.06230229f, 
    0.01852027f, 0.01566705f, -0.00661725f, -0.00078605f, -0.05130560f, -0.01925034f, 0.03452867f, -0.04742020f, 
    -0.00612740f, -0.00979774f, -0.00890809f, -0.01849185f, -0.00077293f, 0.02870296f, 0.04650753f, -0.04865059f, 
    -0.05905015f, 0.00270040f, 0.00077805f, 0.04242840f, -0.02148940f, 0.03813207f, -0.01874600f, -0.00405173f, 
    -0.02761809f, 0.03672181f, -0.04297415f, -0.04398461f, -0.04619255f, -0.05438136f, 0.04587575f, -0.03435750f, 
    0.00290314f, 0.04022226f, -0.02829727f, -0.02010959f, 0.01872748f, -0.04721188f, -0.03720522f, -0.02297989f, 
    -0.04556172f, -0.01742156f, 0.00762436f, -0.01878097f, -0.01282148f, -0.03357811f, 0.00511778f, 0.04833847f, 
    0.01298813f, -0.04290248f, 0.01513779f, -0.04941350f, 0.01840902f, -0.04366659f, -0.00899906f, 0.00703960f, 
    -0.02220876f, -0.03515366f, 0.02012751f, -0.04444774f, 0.03517593f, 0.05224404f, -0.05882031f, -0.02837132f, 
    -0.05418254f, -0.05001985f, 0.04655972f, -0.01745524f, -0.06095017f, -0.01267769f, 0.03771727f, -0.00954842f, 
    0.02655189f, -0.01376781f, -0.04898462f, 0.03177015f, -0.03888010f, 0.04979841f, -0.00800418f, 0.04684952f, 
    0.29587901f, -0.21414837f, 0.15843754f, -0.16021475f, 0.07977343f, -0.08289521f, 0.00331266f, -0.09541868f, 
    -0.00252044f, 0.10296057f, 0.09772953f, -0.00336937f, 0.09923641f, 0.14367710f, 0.06945232f, -0.11248045f, 
    -0.02024548f, -0.13906056f, -0.00670196f, 0.00410797f, 0.16564980f, -0.10265367f, 0.14888202f, 0.11850436f, 
    0.01707094f, 0.04820344f, -0.04916378f, 0.07106840f, 0.00738587f, 0.06826505f, -0.10389946f, -0.01509320f, 
    -0.01660872f, -0.02449752f, 0.03950327f, -0.04317911f, 0.04472801f, 0.05846193f, -0.13347393f, -0.11757151f, 
    -0.43505612f, 0.02347864f, -0.21922418f, -0.00644489f, -0.10042268f, 0.05540104f, 0.13536634f, -0.00155083f, 
    0.04764721f, -0.17978229f, -0.05663220f, -0.03679990f, -0.04085079f, 0.00236644f, 0.08257969f, -0.00865405f, 
    -0.04772482f, 0.11112891f, -0.02260971f, 0.07319663f, -0.20709078f, -0.00198434f, 0.00741567f, -0.08481270f, 
    0.11887047f, 0.04563235f, 0.02665239f, 0.08176273f, 0.17000364f, -0.05786436f, -0.00697660f, -0.07763784f, 
    0.11603801f, 0.11721560f, 0.00214778f, -0.06361090f, -0.01413267f, -0.06655452f, -0.01546695f, -0.09869337f, 
    0.16268739f, -0.41793221f, 0.25760072f, -0.10951605f, 0.31254646f, -0.03898061f, -0.04943477f, -0.03455601f, 
    0.02101731f, -0.12786664f, -0.06403876f, -0.05400540f, 0.04641994f, -0.01541842f, -0.03779676f, -0.10238107f, 
    -0.07705437f, -0.06076092f, 0.06675939f, -0.07124577f, 0.05848763f, -0.11823174f, 0.09374723f, -0.07848733f, 
    -0.06356382f, 0.04281258f, -0.02170505f, 0.07299957f, -0.00853828f, 0.13853693f, 0.12321736f, 0.10567766f, 
    0.01806320f, -0.06082729f, 0.10203549f, -0.15974501f, -0.09194835f, -0.15112719f, 0.06813277f, -0.13127825f, 
    0.06938726f, 0.01197786f, 0.02551820f, 0.06009934f, -0.16917029f, -0.00597241f, -0.05763914f, 0.11631874f, 
    0.01035756f, 0.04586320f, -0.05080650f, 0.13099483f, -0.02855997f, 0.09405967f, 0.09629627f, -0.05094202f, 
    -0.08945934f, -0.01299882f, -0.02951248f, 0.04131437f, 0.10425097f, -0.49735981f, 0.59790111f, -0.04750201f, 
    0.18935937f, -0.03922888f, 0.07452146f, 0.12093227f, 0.11958926f, 0.12491067f, 0.06612092f, 0.08749243f, 
    -0.09166190f, 0.02084987f, 0.03271814f, 0.01948430f, 0.03779081f, -0.04022864f, 0.02186055f, -0.09319125f, 
    0.03826947f, -0.03899961f, -0.03117869f, 0.10269642f, -0.14622433f, 0.09772518f, -0.08191104f, 0.07386340f, 
    -0.04543369f, 0.20388590f, -0.01486473f, 0.18802026f, 0.06336028f, -0.00966183f, -0.03447106f, 0.01118927f, 
    -0.03495833f, -0.05661432f, 0.11929645f, 0.06077898f, 0.03201038f, 0.57791483f, 0.05728209f, 0.17635463f, 
    0.21443290f, -0.12849388f, 0.11153101f, 0.05617864f, 0.19756033f, 0.13951656f, 0.14360297f, -0.17748971f, 
    0.05170161f, 0.12004940f, -0.04165975f, 0.00413411f, 0.13684462f, -0.04709097f, 0.06137639f, -0.08549573f, 
    0.07316099f, -0.28655314f, -0.24157371f, 0.47676265f, -0.19089815f, -0.04763138f, 0.20227458f, 0.01646437f, 
    0.07086481f, -0.06574362f, 0.04214669f, -0.01915908f, 0.01125595f, 0.00514871f, 0.00954143f, -0.09584305f, 
    -0.12333939f, -0.04030441f, 0.05644366f, -0.09812792f, -0.19435686f, 0.02404911f, -0.23075978f, -0.01872621f, 
    0.23137255f, -0.11715955f, 0.15990345f, -0.06911493f, -0.04777978f, -0.04742213f, 0.12839563f, -0.06834468f, 
    -0.00851962f, 0.02015263f, -0.00275769f, -0.01070064f, -0.08184882f, -0.00354522f, 0.03172343f, -0.06250816f, 
    0.20127620f, 0.05042164f, 0.21159564f, 0.43926635f, 0.23235472f, -0.03581423f, 0.07070526f, -0.10813613f, 
    -0.15063894f, -0.18867755f, 0.04449668f, 0.00274849f, -0.06857511f, -0.05038347f, -0.07646976f, 0.03711208f, 
    0.05311868f, 0.01345864f, 0.07017476f, 0.02732201f, -0.01795327f, 0.08817971f, -0.07285568f, 0.25217447f, 
    0.23754527f, -0.18999103f, -0.00563849f, -0.01528472f, -0.16980395f, -0.04255424f, -0.04494049f, 0.05314317f, 
    -0.06310881f, -0.03217958f, -0.04534267f, 0.05732371f, 0.08171812f, 0.11515339f, -0.07137317f, 0.10789013f, 
    -0.03691744f, 0.06617168f, 0.26883087f, 0.01560614f, 0.08788246f, -0.22001532f, -0.04166991f, 0.13402344f, 
    0.04926835f, 0.24810658f, 0.01679496f, 0.02874257f, -0.00207221f, 0.00965493f, -0.06047476f, -0.02744467f, 
    -0.09887376f, -0.01992717f, -0.10908988f, -0.16054116f, 0.00869563f, 0.13794476f, 0.12926300f, 0.09891402f, 
    -0.08606675f, -0.05409299f, -0.10342620f, -0.09808258f, -0.06173480f, 0.03774678f, 0.05658908f, 0.06282543f, 
    0.05116086f, 0.12362299f, 0.02563713f, -0.02754628f, -0.01011093f, -0.10175248f, 0.00970987f, -0.03205684f, 
    -0.15877396f, 0.00683925f, -0.09553599f, -0.04646129f, 0.06152864f, -0.09418610f, 0.10183043f, -0.06012117f, 
    -0.10285129f, 0.05969539f, 0.01318045f, -0.03956595f, 0.12578595f, 0.02422675f, 0.10624125f, -0.06339517f, 
    -0.02026853f, -0.13824461f, -0.19555593f, 0.03086197f, 0.31746694f, 0.00054043f, -0.17074618f, 0.14477271f, 
    0.17442496f, 0.04870864f, 0.03302378f, -0.01097687f, -0.04852371f, 0.00416594f, -0.14973223f, -0.06228905f, 
    -0.06102896f, -0.11914290f, 0.07201353f, 0.03085849f, 0.24060209f, 0.30698931f, -0.19744526f, 0.13090155f, 
    -0.09822451f, -0.08277333f, -0.09748280f, 0.10448527f, 0.33814919f, 0.02967339f, 0.06442704f, 0.03662971f, 
    0.20742713f, 0.18535386f, -0.00312106f, 0.00167841f, 0.09205236f, 0.00886510f, -0.04769810f, 0.07927277f, 
    0.08051179f, 0.09922244f, 0.25549331f, 0.23541148f, -0.19871540f, -0.10025626f, -0.03669245f, 0.35209799f, 
    0.04766890f, 0.00798784f, 0.04854066f, 0.17644620f, 0.04251737f, 0.00144991f, -0.07956925f, 0.12411903f, 
    0.02708895f, -0.15511402f, -0.03890944f, 0.19193563f, -0.02473872f, -0.14298247f, -0.09909770f, -0.07779712f, 
    0.65237391f, 0.22453640f, 0.14007324f, 0.09952651f, -0.16120687f, -0.10925320f, 0.19265240f, 0.11957344f, 
    -0.11823020f, 0.12865606f, -0.08071354f, -0.06217077f, -0.03563699f, -0.00131058f, 0.07966353f, -0.06670504f, 
    0.08760301f, 0.01699289f, -0.00044315f, 0.09098226f, -0.07308871f, 0.22319882f, 0.07885736f, -0.07792073f, 
    0.08887020f, -0.06009279f, 0.04265459f, -0.08474854f, 0.00264137f, -0.16336803f, 0.02829899f, 0.12657233f, 
    -0.01065849f, -0.06666319f, 0.06858519f, -0.11120124f, -0.09540409f, -0.17162737f, -0.23112461f, -0.15510432f, 
    0.18107304f, -0.03852845f, 0.02510771f, 0.07800865f, -0.11115996f, -0.07460284f, -0.05733048f, 0.17424978f, 
    0.06177371f, -0.05175810f, -0.13110603f, -0.03913683f, 0.15389827f, -0.00308106f, -0.16216695f, 0.10394969f, 
    0.04348020f, -0.06068048f, -0.22627963f, -0.08943237f, 0.02262749f, -0.14266402f, 0.20606434f, 0.02990525f, 
    -0.05184179f, -0.12038230f, -0.13083801f, -0.20109154f, -0.17999914f, -0.05348290f, 0.00900994f, 0.02457619f, 
    0.05987138f, 0.06759358f, 0.06651067f, 0.05466226f, 0.09307963f, -0.02328220f, 0.12805063f, 0.11433047f, 
    -0.13340387f, 0.11793111f, -0.04791287f, 0.24140556f, -0.09147193f, 0.01434937f, -0.06161179f, 0.08376552f, 
    -0.09761609f, 0.04288432f, -0.04789917f, 0.01602825f, 0.19037803f, 0.10205127f, -0.12562113f, 0.08974300f, 
    0.14478785f, -0.05749741f, 0.06296815f, 0.15749729f, -0.24046198f, -0.27717999f, 0.30975887f, 0.10247148f, 
    -0.19852342f, -0.09784311f, -0.03653444f, -0.01527700f, 0.11406199f, -0.37657970f, -0.07849897f, -0.14404285f, 
    0.04863732f, 0.10332674f, 0.05197613f, 0.08150526f, 0.09373479f, 0.02771359f, -0.04338155f, 0.03944178f, 
    -0.07203533f, -0.21222961f, -0.05695435f, 0.23474908f, -0.05439404f, -0.02976590f, -0.04975397f, 0.06116986f, 
    0.17914368f, 0.01953763f, 0.07875457f, 0.16747260f, -0.17725828f, -0.18083860f, 0.02243556f, -0.17435381f, 
    -0.05151818f, -0.04331126f, -0.10953324f, -0.13706549f, -0.10162403f, -0.12268081f, 0.24999622f, 0.06184748f, 
    0.07083417f, -0.00336662f, -0.10489732f, -0.02240330f, 0.09176010f, 0.10443292f, 0.07702018f, 0.11880115f, 
    0.05260312f, -0.16301949f, 0.01521810f, 0.03292563f, -0.14853193f, -0.12643696f, 0.03547690f, -0.37392643f, 
    -0.11862724f, -0.10388770f, -0.06505018f, 0.28080851f, 0.10088268f, -0.07828405f, 0.13269228f, -0.19727789f, 
    0.19018146f, 0.11260372f, -0.08290561f, 0.15116397f, 0.14980258f, 0.08340824f, 0.13922465f, 0.15624204f, 
    0.20870946f, 0.25463790f, 0.10277304f, 0.11198155f, -0.00412892f, -0.13765547f, -0.04852173f, 0.17360190f, 
    0.03639072f, -0.12152432f, -0.11328366f, -0.03151560f, -0.13282059f, 0.24971800f, -0.04400234f, 0.16392143f, 
    0.12536791f, -0.00583934f, -0.09401961f, 0.10979439f, 0.13407534f, 0.13650633f, 0.15529610f, 0.05524920f, 
    0.09823781f, 0.13217476f, 0.13623679f, 0.03579319f, -0.16300750f, -0.08935481f, -0.21176875f, -0.24293265f, 
    -0.18863386f, -0.07777847f, -0.00204481f, -0.04640971f, -0.02337200f, -0.09429259f, 0.04765906f, -0.06688479f, 
    -0.14643969f, 0.02350938f, -0.07847004f, -0.14861336f, 0.30127078f, -0.13283224f, 0.00378150f, -0.08909903f, 
    -0.13917901f, -0.11130390f, -0.05638848f, 0.04554117f, -0.00696027f, -0.07811391f, 0.00035905f, 0.08107404f, 
    0.17657980f, 0.07398407f, 0.06381997f, 0.09362943f, 0.04915525f, 0.04465317f, -0.14684291f, -0.03544432f, 
    0.03757280f, 0.00819253f, -0.00087807f, -0.02688366f, -0.00504756f, -0.03391462f, -0.01121220f, -0.00771578f, 
    -0.01146571f, 0.03422799f, -0.05666827f, -0.05957766f, 0.03024948f, -0.05694175f, 0.01634776f, 0.04132634f, 
    0.01458046f, -0.06368814f, 0.03219587f, -0.00031858f, 0.01317197f, 0.01376942f, -0.00781986f, 0.01649190f, 
    -0.00530139f, -0.01490956f, -0.03589090f, 0.00396618f, 0.03794499f, -0.01320608f, 0.04153942f, -0.04816737f, 
    0.05315943f, -0.00683872f, 0.04446400f, -0.03393320f, -0.00738024f, 0.03513123f, -0.04920613f, -0.04644327f, 
    -0.04259808f, 0.02997207f, -0.06427664f, -0.04944485f, -0.04416650f, 0.02426718f, -0.00885936f, -0.06165424f, 
    0.02899142f, -0.03707498f, -0.01605950f, 0.01999125f, -0.05350295f, -0.05111837f, -0.03661250f, 0.03365779f, 
    0.02815983f, -0.02871550f, -0.00486090f, -0.04278850f, 0.04168746f, 0.04799370f, -0.04933238f, 0.00030344f, 
    0.03293110f, 0.00758787f, 0.00649391f, -0.01794000f, -0.04452892f, 0.03295674f, 0.02437726f, -0.00062973f, 
    0.00581672f, -0.01209085f, -0.05900086f, -0.05310638f, 0.03412009f, -0.01475201f, 0.00064218f, 0.03938096f, 
    -0.01797370f, -0.01612715f, 0.02933150f, -0.06072683f, 0.03954150f, 0.04408757f, -0.01722924f, -0.01972759f, 
    0.00478391f, -0.05364888f, -0.02703057f, 0.01986796f, -0.03393423f, -0.05697341f, -0.01624116f, -0.00379174f, 
    -0.05085577f, -0.02368215f, -0.05289088f, 0.00092783f, -0.05142430f, -0.03671440f, 0.02231132f, -0.02000825f, 
    -0.02181402f, 0.02682807f, -0.02304119f, 0.02553148f, 0.02796036f, -0.00552655f, 0.01667569f, 0.04178305f, 
    -0.02684162f, 0.01234763f, 0.02791711f, -0.00693080f, -0.01500080f, -0.04932986f, 0.04212850f, -0.04878842f, 
    -0.04086896f, -0.06561846f, -0.00503231f, -0.01732560f, -0.03858800f, -0.02256055f, 0.02464383f, -0.05645537f, 
    -0.04016430f, 0.01996124f, 0.02606925f, -0.04901692f, 0.03750335f, 0.00587240f, 0.01860025f, 0.01885725f, 
    -0.03762904f, 0.01035456f, -0.02174878f, 0.00645080f, 0.03661606f, 0.00296192f, 0.04761657f, 0.02783466f, 
    0.04490433f, 0.02870306f, -0.01892422f, -0.03602591f, 0.01687300f, -0.06310562f, 0.03628684f, 0.02830193f, 
    -0.04383690f, 0.02512720f, -0.00401575f, -0.00789401f, 0.00814030f, 0.02745639f, -0.04358143f, 0.04229409f, 
    0.03359749f, -0.00732375f, -0.02099614f, -0.04895775f, -0.06044094f, 0.01650228f, -0.05722296f, -0.05166601f, 
    -0.00131429f, 0.03231402f, -0.05301073f, 0.02155918f, -0.05652483f, -0.00166084f, -0.04378034f, -0.01303956f, 
    0.00415535f, 0.01042587f, -0.00588831f, 0.03420084f, -0.01845661f, -0.01626053f, 0.00555181f, 0.01033558f, 
    0.03888663f, -0.03449877f, 0.04406996f, -0.03065978f, 0.03082255f, -0.01627589f, -0.00999471f, 0.00193331f, 
    0.04488445f, -0.03853255f, -0.06133407f, -0.00027351f, -0.03794551f, -0.05145022f, 0.04440116f, -0.04650026f, 
    0.00082283f, -0.05312852f, 0.01281321f, 0.00856153f, 0.01282170f, 0.02333810f, -0.02888802f, -0.04139261f, 
    -0.00312535f, 0.01101660f, 0.00359995f, -0.03463237f, -0.04933860f, 0.00507146f, -0.01294010f, -0.02222381f, 
    -0.02874565f, -0.05331108f, -0.03845147f, -0.02843625f, 0.01427258f, -0.01028277f, -0.01149238f, 0.03997533f, 
    -0.04670765f, 0.00581370f, -0.05971880f, -0.04422253f, -0.00717764f, 0.01433142f, 0.01526790f, 0.04755344f, 
    -0.04583817f, -0.01422066f, -0.05664807f, 0.01506801f, -0.01942540f, 0.01861481f, -0.03695603f, -0.05653911f, 
    -0.02805725f, -0.05093712f, -0.01122529f, -0.01608037f, -0.02064129f, 0.03324975f, 0.03896264f, -0.03517902f, 
    -0.06883448f, 0.02436982f, -0.03294415f, 0.01032772f, -0.02992493f, -0.01997234f, -0.03390066f, -0.05752434f, 
    -0.03348286f, -0.02253375f, -0.04234728f, -0.01898999f, 0.00463614f, -0.01685094f, -0.00404080f, 0.01270251f, 
    -0.04497712f, 0.02188613f, 0.03449520f, 0.01869553f, -0.04235587f, -0.04774546f, -0.00206805f, -0.05189602f, 
    -0.02274323f, 0.02935351f, -0.04639042f, 0.02742544f, 0.00327246f, -0.01195421f, -0.02025033f, -0.06237735f, 
    0.01549693f, 0.01225582f, 0.02478061f, -0.03645255f, -0.05714563f, -0.06240296f, 0.00725254f, -0.00512156f, 
    -0.05929904f, -0.01391647f, -0.04513782f, -0.00713734f, 0.03008679f, -0.04952583f, 0.00527244f, 0.00777683f, 
    -0.06155894f, 0.04567821f, 0.04009894f, -0.01398323f, 0.02548494f, 0.01525408f, -0.02505619f, 0.03232093f, 
    -0.00700657f, 0.03071251f, -0.02483822f, -0.04336069f, -0.03399818f, -0.05355002f, 0.00981496f, -0.03920759f, 
    -0.03856657f, 0.00996751f, -0.00860578f, -0.01827094f, 0.03233406f, 0.02267955f, 0.04628157f, -0.06355920f, 
    -0.14938651f, -0.20282970f, 0.06090697f, 0.05003158f, -0.06743971f, -0.02605968f, -0.07591727f, 0.10459123f, 
    0.01029250f, -0.08391847f, 0.03603333f, 0.13366526f, -0.04821044f, 0.02326769f, 0.18829906f, 0.10288926f, 
    0.12436200f, 0.17127238f, 0.09877089f, 0.08451037f, -0.09240543f, -0.21698827f, 0.07255281f, -0.10121670f, 
    0.00732813f, -0.07996351f, -0.05852343f, -0.05674613f, -0.05880650f, -0.12561746f, -0.15535419f, -0.03561766f, 
    0.01746346f, 0.01756806f, -0.01356482f, -0.09551953f, 0.05933840f, 0.01271897f, 0.23275845f, -0.11092616f, 
    0.07580198f, 0.24383576f, 0.13963443f, 0.13062547f, -0.01415037f, 0.09519947f, -0.12332232f, 0.00914627f, 
    -0.15723623f, 0.17952503f, -0.06799776f, 0.06111897f, -0.04836534f, 0.03622760f, 0.07245979f, 0.05590646f, 
    -0.01940938f, 0.05349989f, -0.25231832f, -0.20220000f, -0.25019652f, 0.19939888f, -0.07274564f, -0.13498703f, 
    0.01534602f, 0.03595299f, -0.09302336f, 0.07476383f, 0.02134451f, 0.15431732f, -0.02878791f, -0.15380464f, 
    -0.03003749f, 0.12690192f, 0.00439706f, 0.07676622f, 0.07449303f, 0.25565988f, -0.03502389f, 0.18530656f, 
    -0.21284208f, -0.07565145f, -0.23027019f, -0.00931279f, -0.28550446f, -0.07859934f, -0.20106438f, 0.12187266f, 
    -0.02514620f, -0.12690133f, -0.06161829f, -0.09366310f, -0.08808757f, -0.07528951f, -0.03855298f, 0.16556197f, 
    0.01919381f, -0.10195092f, -0.07952262f, -0.07741636f, -0.08628860f, -0.19245464f, 0.05917910f, -0.10423820f, 
    -0.14724874f, -0.08723810f, -0.00656334f, -0.02276275f, -0.04866441f, -0.11643680f, 0.16422838f, 0.08292999f, 
    0.06316994f, 0.14353466f, 0.01268334f, 0.04071800f, 0.13683274f, 0.02623812f, 0.08251711f, -0.00466121f, 
    -0.03725815f, -0.17955990f, -0.22058226f, 0.08013926f, -0.06321404f, -0.15048328f, -0.08333542f, -0.21722284f, 
    0.04311012f, -0.06146906f, 0.04486333f, 0.27802905f, 0.05976711f, 0.01705841f, 0.01544819f, -0.07577795f, 
    0.02307773f, 0.03212580f, 0.17683721f, -0.00617425f, 0.20999119f, 0.28666678f, 0.13804039f, 0.17104590f, 
    -0.25201803f, 0.01848895f, 0.01711664f, 0.00668992f, -0.08145967f, -0.07063942f, 0.17771931f, -0.04562744f, 
    -0.01000428f, 0.00767533f, 0.05918781f, 0.08142008f, -0.01984195f, 0.02146155f, 0.00886325f, -0.08082050f, 
    -0.02771486f, -0.24704583f, -0.08820459f, 0.10999168f, -0.04033635f, -0.12678738f, -0.04058677f, -0.02515243f, 
    0.02798272f, -0.13370712f, -0.04715849f, -0.05978795f, 0.05161522f, 0.02200146f, 0.13986608f, 0.05804754f, 
    -0.06123227f, -0.00843748f, 0.04173888f, -0.13036674f, 0.36500183f, 0.03020693f, 0.10085644f, 0.35401860f, 
    -0.25341633f, 0.00784887f, 0.13303196f, -0.18535459f, 0.10104868f, 0.09544138f, -0.08310886f, 0.05183979f, 
    0.01920734f, 0.11667498f, 0.12316078f, 0.13166133f, -0.00036292f, 0.05778828f, -0.02678279f, 0.12446413f, 
    0.00566083f, 0.04200911f, 0.15113686f, 0.07220990f, -0.03362854f, -0.01017683f, 0.13703984f, 0.12316532f, 
    0.13884605f, 0.12581298f, -0.18475930f, -0.15169513f, 0.06282772f, 0.19675459f, 0.02211636f, 0.09610551f, 
    0.09575491f, 0.08657309f, 0.03313212f, 0.18060219f, -0.18140316f, -0.01677964f, -0.03009064f, 0.21510704f, 
    -0.09226433f, -0.03647724f, 0.01881877f, 0.04982137f, 0.07777478f, 0.05446543f, -0.01469479f, -0.06896202f, 
    -0.02120198f, 0.10824142f, -0.05398548f, 0.10344188f, 0.08853997f, -0.01457802f, -0.05069449f, 0.19182685f, 
    0.19997358f, 0.45317408f, 0.30799565f, 0.07275861f, -0.22034214f, 0.08989789f, 0.01909328f, 0.08558903f, 
    0.12489218f, 0.13397220f, 0.07871339f, -0.07524313f, -0.00050710f, -0.02196611f, 0.01754455f, 0.07242856f, 
    -0.02658854f, -0.23602103f, -0.07085719f, -0.00909148f, -0.05017726f, 0.40566143f, 0.16173387f, 0.04169379f, 
    0.14914644f, -0.04734376f, -0.00208537f, 0.14447449f, 0.10592520f, 0.01704776f, 0.06658750f, 0.03725018f, 
    0.04055651f, -0.01893707f, 0.04710101f, 0.03462685f, 0.10648008f, -0.04626785f, -0.13152814f, 0.05495719f, 
    -0.03451613f, -0.20314443f, -0.13613819f, -0.02119657f, -0.22601281f, -0.06201594f, 0.07018157f, -0.09190109f, 
    -0.01532594f, 0.02255873f, 0.02019351f, -0.04232763f, 0.13282216f, 0.09205438f, -0.06583021f, 0.03702616f, 
    0.13776346f, -0.05245616f, 0.08010052f, 0.07501525f, 0.07884046f, -0.33312562f, -0.23045407f, 0.02303125f, 
    -0.08546130f, -0.06628928f, -0.03865907f, -0.10772579f, -0.00258635f, -0.07201237f, -0.03918360f, 0.00053222f, 
    -0.12006443f, -0.11735032f, 0.05464251f, 0.18154778f, -0.00397487f, 0.23137371f, 0.17023802f, -0.04993119f, 
    0.10497517f, 0.02753951f, 0.07565993f, -0.07569793f, -0.10868934f, -0.07153188f, -0.05660430f, -0.03731406f, 
    -0.08086646f, -0.00884383f, -0.00551384f, 0.08454741f, -0.00972741f, -0.06140309f, -0.01685869f, -0.09546769f, 
    0.10559607f, -0.08505609f, 0.07443184f, 0.03423971f, -0.14973700f, 0.20605189f, 0.45223501f, -0.01926905f, 
    -0.20726155f, -0.01963718f, -0.13985224f, -0.00952201f, -0.01975174f, -0.02936172f, 0.06010456f, -0.06796903f, 
    0.03601179f, 0.00854691f, -0.03186024f, 0.00983245f, 0.12087113f, 0.09249444f, -0.01883097f, -0.08569526f, 
    0.19392297f, -0.00427771f, -0.05667400f, -0.00182713f, 0.31026649f, 0.08264709f, 0.05614978f, 0.00932783f, 
    0.02240959f, -0.00640418f, -0.00090443f, -0.03109236f, 0.00306268f, -0.08710647f, 0.09302620f, -0.11743507f, 
    -0.04489098f, 0.03809633f, -0.18393657f, -0.18878111f, 0.18571714f, -0.06677531f, -0.03725381f, 0.00594465f, 
    0.07094585f, 0.11994123f, 0.19931708f, 0.05120390f, 0.00390040f, -0.04173569f, 0.03489719f, 0.06342496f, 
    -0.06415171f, 0.15148704f, 0.14569579f, -0.04150542f, 0.06849779f, 0.29779461f, 0.10928163f, -0.03044849f, 
    -0.08889762f, -0.03278313f, 0.15832524f, -0.02810229f, 0.23486611f, -0.14624055f, -0.14145809f, -0.02758106f, 
    0.09541791f, -0.17901675f, -0.02313492f, -0.00939840f, -0.01156701f, -0.08536389f, 0.03301042f, 0.07134520f, 
    0.01315490f, 0.09243368f, 0.06904444f, -0.03189078f, -0.01026239f, -0.03682420f, 0.09359236f, 0.03589483f, 
    -0.17079759f, -0.05247348f, -0.04464642f, -0.08779538f, -0.15504567f, -0.00011373f, 0.06623862f, -0.07716464f, 
    0.03921298f, 0.14253192f, 0.03326715f, -0.07318058f, 0.02246335f, -0.11440991f, -0.00816213f, -0.02340425f, 
    0.11666756f, -0.06880427f, 0.06381404f, -0.00024974f, -0.04524778f, -0.00737032f, -0.01348820f, -0.02412897f, 
    -0.07462791f, -0.01479655f, 0.05740454f, 0.04552261f, 0.09570018f, -0.01413719f, -0.04127893f, -0.15410674f, 
    -0.05212819f, 0.00635610f, -0.02359305f, 0.01392179f, 0.46276784f, 0.31246814f, -0.33708623f, -0.19146878f, 
    0.07923988f, 0.21573068f, 0.16401958f, 0.15067087f, -0.02240205f, -0.06551955f, -0.14753574f, -0.02478458f, 
    0.07724344f, 0.11712386f, 0.08675115f, -0.05437667f, -0.10331897f, -0.15489082f, -0.03732871f, -0.15128565f, 
    0.02470225f, 0.01349324f, 0.02566202f, -0.04213743f, -0.04670566f, 0.08283085f, -0.00511376f, 0.01331568f, 
    -0.07453193f, -0.03964451f, 0.06201989f, 0.10383283f, 0.06741301f, -0.06874046f, 0.04202217f, -0.12906434f, 
    -0.05540666f, -0.16223542f, -0.06718773f, -0.12910827f, 0.06328040f, 0.54203695f, -0.15610905f, 0.04472556f, 
    0.23471454f, 0.08106086f, 0.09499203f, 0.08054236f, -0.16355310f, 0.11086796f, 0.05257133f, 0.04187886f, 
    0.00857199f, 0.03389003f, 0.10032152f, 0.03649572f, 0.11533131f, 0.12210793f, -0.06698468f, 0.04768344f, 
    -0.11337744f, 0.26180509f, -0.32978192f, 0.00513130f, 0.04242552f, -0.02692579f, 0.02895165f, 0.06320290f, 
    -0.01574253f, 0.03391637f, 0.08260372f, 0.12605733f, 0.06920663f, -0.05458112f, -0.12105723f, 0.07043523f, 
    0.03808321f, 0.14022025f, 0.09691898f, 0.04952478f, -0.17230375f, -0.02215842f, -0.25168073f, -0.20482771f, 
    0.08340211f, 0.10148548f, 0.08567213f, 0.15152402f, -0.00161821f, 0.11156514f, 0.00771846f, -0.01365992f, 
    -0.09660609f, 0.05819643f, -0.00076052f, -0.04302021f, -0.10847770f, 0.09292785f, 0.07764746f, 0.13089894f, 
    0.29580268f, 0.30190852f, -0.34930459f, -0.02467932f, 0.26374516f, 0.19737750f, -0.01160826f, 0.15634577f, 
    -0.06664290f, 0.21451505f, -0.04746126f, 0.00604296f, -0.02514555f, 0.05867127f, 0.13118206f, -0.05166455f, 
    -0.12865090f, -0.03750471f, -0.05375576f, 0.05719569f, 0.11372201f, -0.02077836f, -0.21357745f, -0.24529430f, 
    0.12089675f, 0.19960457f, 0.11282661f, 0.05250815f, 0.07968090f, -0.00306342f, -0.09168015f, 0.04536200f, 
    -0.02438028f, 0.05128754f, 0.10473795f, -0.14775567f, -0.09993917f, 0.02408084f, 0.03009016f, -0.02705713f, 
    -0.32281080f, -0.01395409f, -0.17870995f, -0.27589220f, -0.03881700f, 0.12094057f, 0.05797613f, 0.01354899f, 
    -0.04704548f, 0.05888126f, -0.03243455f, 0.10790896f, -0.07245976f, 0.04881389f, -0.03618884f, 0.01418920f, 
    0.12588111f, -0.07485296f, 0.02803903f, 0.03895918f, -0.10779054f, 0.12461995f, 0.19363593f, 0.17531379f, 
    0.12526476f, 0.00389747f, -0.05786646f, -0.06941753f, -0.09901534f, -0.05262696f, 0.05863928f, -0.00083002f, 
    -0.03568314f, -0.14634944f, -0.09298396f, 0.04727478f, 0.02330134f, -0.04233203f, 0.01507640f, -0.02100516f, 
    -0.02829342f, 0.02827153f, -0.01103067f, -0.05758347f, -0.05753742f, 0.03359665f, -0.05772541f, -0.02023252f, 
    0.01371848f, 0.04265742f, -0.02319926f, 0.00424850f, 0.01992786f, -0.04358292f, 0.01210641f, -0.04958852f, 
    0.02727421f, -0.02985464f, -0.02031007f, 0.03825036f, 0.02990677f, -0.03903052f, -0.02334650f, -0.05849443f, 
    -0.03144138f, -0.04849224f, 0.02275935f, -0.03422162f, -0.03523792f, 0.04993321f, 0.05066532f, -0.00818963f, 
    -0.05947670f, -0.01865204f, 0.04057058f, -0.04257660f, 0.01002287f, -0.05620085f, 0.04707472f, 0.00327416f, 
    0.02470315f, 0.03377766f, -0.03648881f, -0.02372535f, -0.00286006f, -0.03452588f, -0.00014507f, -0.00304975f, 
    -0.00507388f, -0.04340491f, -0.02292619f, -0.02791917f, 0.00573523f, -0.03878494f, 0.02732887f, 0.00685007f, 
    0.02151865f, 0.02518070f, 0.02163303f, 0.04224603f, 0.02066648f, 0.01442990f, 0.02422006f, 0.01547579f, 
    0.03970002f, -0.04681797f, -0.02404057f, -0.04655619f, -0.03249317f, 0.01786187f, -0.03211220f, -0.02181409f, 
    0.03223166f, -0.02934036f, -0.00385822f, -0.03964285f, 0.03006336f, 0.01749254f, 0.03838972f, 0.00439627f, 
    -0.01883919f, 0.00895402f, 0.04939507f, 0.03616872f, -0.00496339f, -0.03921791f, 0.04455926f, 0.04708070f, 
    -0.03299299f, -0.04994345f, -0.04829627f, -0.03963562f, 0.00157392f, -0.04085617f, -0.02397991f, -0.01267852f, 
    0.02293817f, -0.01621682f, -0.01820727f, -0.02340750f, -0.01572283f, 0.01117305f, -0.04807881f, 0.01193237f, 
    -0.03217797f, -0.02419000f, -0.05372708f, -0.05590129f, 0.00657140f, 0.03526652f, 0.03630829f, -0.05946971f, 
    -0.06288580f, -0.01637501f, -0.00944357f, 0.03458348f, -0.03400701f, -0.03935746f, -0.00158800f, 0.01414048f, 
    0.04750762f, -0.03441282f, -0.03469048f, 0.01001241f, 0.03904829f, 0.02718233f, -0.02964602f, -0.05157707f, 
    -0.01372456f, 0.04229926f, 0.01828789f, -0.01852133f, 0.03343994f, -0.02433963f, 0.02165578f, -0.04907820f, 
    0.01492076f, -0.05915642f, -0.04680934f, -0.02773958f, -0.01646755f, -0.01093479f, -0.04694437f, -0.03855377f, 
    -0.04437041f, -0.05149930f, 0.03321467f, 0.00522990f, 0.03661166f, 0.05212571f, -0.01956614f, -0.04163975f, 
    -0.01067258f, 0.03494985f, -0.02945398f, 0.04899380f, 0.03860830f, -0.01033929f, -0.02928102f, -0.03148942f, 
    0.03103659f, 0.00726752f, -0.00667387f, -0.00866599f, -0.00354027f, -0.05645010f, 0.00099792f, 0.04004022f, 
    0.02521075f, 0.03458515f, -0.01662128f, -0.03870849f, 0.01147518f, -0.02636135f, 0.03068453f, 0.01221274f, 
    0.00236727f, 0.01751396f, -0.03027090f, -0.01718485f, 0.00347092f, -0.02291648f, 0.01367924f, -0.02046349f, 
    -0.00959624f, 0.04203202f, -0.00532973f, -0.04902737f, 0.02340552f, 0.03506561f, -0.00809494f, -0.00531612f, 
    0.03807504f, -0.02555638f, -0.03971266f, -0.01852807f, -0.05061264f, 0.04117285f, -0.04814995f, -0.00318665f, 
    -0.03072711f, -0.05648215f, -0.01520612f, 0.05167173f, 0.01833594f, 0.02458411f, 0.01964962f, -0.05316578f, 
    0.03680649f, 0.00623310f, -0.00411385f, -0.02403459f, 0.00076725f, -0.05883422f, -0.00497079f, -0.05052721f, 
    0.00366670f, -0.04445453f, 0.04054993f, 0.04575006f, 0.00127569f, -0.04663510f, -0.02157029f, -0.01569865f, 
    -0.04058307f, -0.05317772f, -0.00565116f, 0.04437536f, 0.04059836f, 0.02326451f, -0.02999908f, -0.05829755f, 
    -0.01574975f, 0.01877537f, -0.00728240f, 0.00284449f, 0.03133640f, 0.03700519f, 0.03245723f, 0.01992295f, 
    -0.00633361f, 0.02596748f, 0.04028777f, -0.03604069f, 0.01530865f, 0.01385538f, 0.03145889f, -0.04479571f, 
    0.00452008f, -0.03102064f, -0.02046132f, -0.05388799f, 0.05166661f, 0.04096707f, -0.05232970f, 0.03081037f, 
    -0.04808810f, 0.00308365f, -0.04480464f, -0.01972835f, 0.03809387f, -0.04255532f, 0.04981213f, -0.00076542f, 
    -0.02952606f, -0.02682903f, 0.05887448f, -0.01133036f, -0.00443764f, 0.02280324f, -0.02601893f, 0.03053506f, 
    0.03435772f, -0.05006062f, -0.00505435f, 0.00317836f, -0.06110416f, 0.01221266f, 0.01386151f, 0.00429479f, 
    0.03545986f, 0.03930005f, 0.04226297f, -0.01157797f, 0.02728309f, -0.04795889f, -0.02759314f, -0.03693055f, 
    -0.00660060f, -0.01661801f, -0.01074467f, -0.01894651f, -0.05199574f, -0.03968520f, -0.05034602f, 0.03920244f, 
    0.00009105f, -0.06394624f, -0.04762539f, 0.03255469f, -0.01327531f, -0.03091331f, -0.04259842f, 0.02976501f, 
    0.01012757f, -0.05017827f, -0.01959195f, 0.02399074f, -0.02284673f, 0.02281807f, -0.03016279f, -0.01251818f, 
    0.02273056f, 0.00658291f, -0.02731290f, 0.04025741f, 0.01359190f, 0.01581284f, 0.00091490f, -0.00021488f, 
    -0.20345719f, -0.08140524f, -0.07644219f, -0.18174051f, -0.23124199f, -0.03161994f, -0.09841613f, -0.06372168f, 
    -0.02076504f, -0.01029572f, -0.02499876f, -0.01265951f, 0.10525243f, -0.02235069f, -0.04406458f, -0.07155728f, 
    -0.02038073f, -0.18832979f, -0.03742941f, 0.04754074f, -0.47709727f, -0.40031272f, -0.41024935f, -0.25070626f, 
    -0.55173457f, 0.04179442f, -0.06397368f, 0.06623928f, -0.02754963f, 0.00080726f, -0.00905117f, 0.09100793f, 
    0.04231612f, -0.13322465f, 0.00321754f, -0.13203990f, 0.03176102f, 0.22636385f, -0.15270394f, -0.07606535f, 
    -0.04545323f, 0.22039041f, 0.20297755f, 0.02717611f, 0.23505351f, -0.04364999f, 0.03928783f, -0.03988454f, 
    0.11200240f, 0.18741681f, 0.03778362f, 0.00167980f, -0.03135285f, -0.06066248f, 0.08408493f, -0.02562143f, 
    0.01952088f, 0.06118410f, -0.17780918f, -0.11865085f, -0.02876394f, 0.11903375f, 0.12752679f, -0.14351849f, 
    0.16459747f, -0.16831793f, 0.11670129f, -0.02884554f, 0.09973207f, 0.00753485f, 0.04757067f, -0.02520980f, 
    -0.02449621f, 0.01630322f, 0.03988862f, 0.07002118f, 0.02615895f, 0.00467644f, -0.05456788f, 0.00049742f, 
    -0.46047762f, -0.13642840f, -0.03562204f, -0.07057682f, -0.07099271f, 0.01611210f, -0.02075371f, -0.10559127f, 
    0.02907356f, -0.01469019f, 0.03700209f, 0.03616723f, 0.00990001f, 0.07357124f, 0.13147785f, -0.11357381f, 
    0.12956247f, -0.09960113f, 0.07344212f, -0.00364596f, -0.16303764f, -0.16605468f, -0.13284951f, -0.10971724f, 
    -0.17390206f, 0.04246007f, 0.01238915f, -0.00377346f, -0.04633341f, -0.03681698f, 0.06024510f, 0.02615901f, 
    0.05678384f, -0.04011033f, 0.02862302f, -0.03454860f, 0.03122727f, -0.05184627f, 0.02892788f, 0.03579463f, 
    -0.11805391f, -0.28754431f, -0.02635227f, -0.15361172f, -0.14915524f, -0.00926760f, -0.02640555f, 0.09673399f, 
    -0.05919500f, -0.01999592f, 0.03974554f, 0.09377684f, 0.04227204f, 0.07444996f, 0.04327609f, -0.06690235f, 
    -0.01582922f, -0.01726807f, -0.05142713f, 0.06970936f, 0.67955029f, 0.00972928f, 0.04140738f, 0.01796514f, 
    0.00887169f, 0.12269317f, 0.14937158f, 0.12898552f, 0.05746837f, 0.09677257f, -0.00696073f, -0.05092229f, 
    -0.04071989f, -0.03811829f, 0.09220924f, 0.02818685f, 0.02251752f, -0.12885615f, -0.05384379f, -0.02958653f, 
    -0.11765644f, -0.17278819f, -0.17946182f, -0.16831575f, -0.21879071f, -0.08934412f, -0.02206830f, 0.01329069f, 
    0.09113359f, 0.12792869f, -0.05280802f, 0.14569288f, 0.10704417f, -0.02952501f, -0.00476372f, -0.03221476f, 
    -0.05805640f, -0.11218238f, 0.01385169f, 0.01953133f, 0.04551041f, 0.05154087f, -0.18762346f, 0.05807591f, 
    -0.00890046f, -0.09110090f, -0.00378996f, 0.09443957f, -0.18777290f, -0.02594613f, -0.10435775f, -0.19888626f, 
    -0.10681975f, 0.05781039f, -0.05137990f, -0.07928881f, -0.06054599f, -0.18057308f, -0.08774492f, -0.01322810f, 
    0.25089505f, 0.27960402f, -0.33102930f, 0.08630332f, -0.14803238f, 0.04875321f, -0.03424891f, 0.09573120f, 
    0.14205644f, 0.21517828f, 0.01601655f, 0.15476559f, 0.03096793f, -0.07648691f, 0.00181809f, -0.10759436f, 
    -0.03789829f, -0.10424477f, -0.02044286f, -0.06126719f, 0.32672569f, 0.24709894f, 0.00077297f, -0.02335720f, 
    0.17584790f, 0.03382722f, 0.06455930f, 0.12228992f, 0.04354679f, 0.15571551f, -0.01688509f, 0.07989413f, 
    0.00872121f, 0.01987693f, 0.03569909f, -0.00816870f, -0.10341015f, 0.01046362f, 0.06465955f, -0.00917874f, 
    0.63279212f, 0.23476166f, 0.08376347f, 0.18765545f, 0.24952769f, 0.02899408f, 0.12404636f, 0.15260756f, 
    -0.08663341f, 0.12651531f, 0.06182186f, -0.00583987f, -0.10111843f, 0.03254532f, 0.15922074f, 0.01822300f, 
    0.00150978f, 0.04564417f, -0.01850732f, 0.18992081f, 0.45258772f, 0.34730411f, 0.00990900f, 0.07204583f, 
    0.21861114f, 0.00707012f, 0.08428934f, -0.04046327f, -0.01576040f, -0.08150579f, 0.06975748f, -0.05693666f, 
    -0.05745391f, 0.01006143f, 0.01233529f, -0.00839765f, -0.06123868f, 0.06881121f, 0.05867121f, -0.02659869f, 
    0.07344218f, -0.03506600f, -0.13403748f, -0.01289584f, 0.07614374f, 0.01898656f, 0.09527589f, 0.16000004f, 
    -0.06650741f, -0.02424638f, 0.00234023f, -0.02739058f, 0.00534772f, 0.01089317f, 0.01224318f, -0.02405706f, 
    0.10058875f, 0.04459546f, -0.04115301f, 0.02892202f, -0.10084242f, -0.22443010f, -0.18038523f, -0.14177148f, 
    -0.27613190f, -0.01602085f, -0.04449840f, 0.00785003f, 0.03248500f, 0.01634031f, 0.12606257f, 0.07235428f, 
    0.05646080f, 0.12449849f, -0.03308320f, -0.08569675f, 0.12872234f, -0.00131510f, -0.09938808f, 0.05912389f, 
    -0.00256397f, -0.05294646f, 0.01713536f, 0.01255404f, -0.01106954f, -0.00216717f, 0.02727310f, 0.03721634f, 
    -0.00115307f, -0.01197534f, -0.02339475f, 0.04706981f, 0.02134691f, 0.01945746f, -0.00250629f, 0.03959573f, 
    -0.02686052f, 0.04561266f, -0.04313683f, -0.00535758f, -0.02579189f, -0.03308677f, 0.02358159f, 0.03112715f, 
    -0.04494108f, -0.00615095f, -0.03605452f, -0.02695755f, -0.04525072f, -0.04509493f, 0.03237211f, 0.03113857f, 
    -0.04638931f, -0.06016492f, 0.00441564f, -0.05825521f, 0.00294826f, 0.01121395f, 0.02621966f, 0.01801092f, 
    0.01590941f, 0.02599971f, -0.00348745f, -0.03273277f, -0.01810455f, -0.04584021f, 0.03018655f, 0.00916455f, 
    -0.04424974f, -0.02581016f, -0.04389229f, 0.00925092f, 0.00580375f, -0.01609048f, -0.05780185f, -0.02479185f, 
    -0.01181943f, -0.02766509f, 0.04259830f, -0.02955414f, -0.02672379f, 0.04396173f, 0.05875447f, -0.01015671f, 
    -0.01620891f, 0.01195374f, -0.03645545f, -0.04280185f, -0.00472099f, -0.03923393f, -0.01052054f, 0.01199431f, 
    0.01239594f, -0.02257497f, -0.00409238f, 0.00591497f, -0.04907289f, -0.02165461f, 0.02953011f, 0.00964425f, 
    -0.03976501f, 0.01212653f, 0.02556084f, 0.01499984f, -0.05597322f, 0.00360016f, 0.04173758f, -0.00734305f, 
    -0.02174961f, -0.02331614f, 0.03484422f, 0.03751156f, 0.00686265f, 0.01256449f, -0.03460771f, -0.00855739f, 
    -0.04211081f, 0.02707453f, 0.03843964f, 0.05338111f, 0.04034105f, 0.05703951f, -0.03368099f, -0.04566894f, 
    -0.05781835f, 0.00431019f, 0.01905087f, -0.04159341f, 0.02667713f, 0.02612326f, 0.05021360f, -0.02909300f, 
    -0.05984162f, 0.00021833f, -0.02503027f, 0.04792846f, 0.04345392f, -0.06079613f, -0.01902250f, 0.03497254f, 
    0.00733921f, 0.00200041f, 0.01662062f, 0.00668943f, -0.03181793f, -0.03388597f, -0.00501059f, -0.00906814f, 
    0.00524342f, -0.03566840f, -0.05575907f, -0.02162876f, -0.01214473f, -0.01773904f, -0.02464471f, 0.00309682f, 
    -0.01364824f, 0.00601841f, 0.04186089f, 0.04479321f, -0.02774019f, 0.00439918f, -0.00455686f, 0.01054487f, 
    -0.01494695f, -0.01284378f, -0.02222630f, 0.03621235f, -0.04140614f, 0.01385793f, 0.00249496f, -0.04570973f, 
    -0.03070453f, -0.01630029f, -0.02554774f, -0.04807633f, 0.00329418f, -0.05663946f, -0.00945098f, -0.04849669f, 
    0.03553109f, 0.04480036f, -0.05981955f, -0.05801775f, -0.00225975f, -0.05745952f, 0.01145420f, -0.01898449f, 
    0.01420118f, -0.03597559f, 0.04956030f, -0.02424425f, -0.03061998f, 0.01411380f, 0.02734699f, -0.03292339f, 
    -0.02666892f, -0.02585663f, 0.04384540f, 0.00291807f, -0.03092300f, 0.04075566f, -0.06219636f, 0.04551378f, 
    -0.00908250f, 0.00710771f, 0.03849143f, -0.00439343f, 0.02224661f, 0.02388096f, -0.02058456f, 0.01170362f, 
    -0.01736087f, 0.03075597f, -0.02722725f, -0.00129177f, -0.00668566f, -0.01314590f, -0.05395568f, 0.03168851f, 
    0.00008106f, 0.04319249f, -0.02538716f, -0.04953871f, -0.02111105f, 0.01625597f, 0.01866307f, 0.02594703f, 
    -0.02670578f, 0.00157695f, 0.01099276f, -0.00428978f, -0.03868366f, 0.02338180f, 0.00558373f, -0.02930713f, 
    -0.06157839f, -0.01988982f, -0.04385323f, 0.00938432f, 0.00881714f, -0.00326964f, 0.04721427f, 0.03239276f, 
    -0.00493291f, 0.03701645f, -0.02436920f, -0.01519152f, 0.00986365f, -0.04699847f, 0.01288704f, -0.03670467f, 
    0.00136534f, -0.06214740f, -0.04506579f, 0.03760481f, -0.04292405f, 0.05122586f, -0.02187728f, 0.01215584f, 
    -0.03532962f, -0.05222223f, 0.05083800f, -0.00032762f, -0.02166758f, -0.00869425f, -0.01606100f, -0.05132868f, 
    -0.02297587f, -0.04183908f, -0.05983787f, -0.02185312f, 0.02404454f, 0.01185232f, -0.04255911f, -0.03821025f, 
    -0.02782709f, 0.03900391f, 0.01660161f, -0.00506985f, 0.03136982f, 0.04614586f, -0.06092473f, -0.02394208f, 
    -0.05731843f, -0.05239600f, -0.02793102f, 0.00905539f, -0.02097586f, 0.01982702f, 0.03222994f, -0.04357009f, 
    -0.02673930f, -0.03868068f, -0.00823897f, 0.01147741f, -0.04339142f, -0.05534555f, -0.01483888f, 0.03243909f, 
    0.00756339f, 0.02814329f, -0.01531793f, -0.05315550f, 0.03280867f, 0.01758276f, -0.05251184f, -0.00144790f, 
    -0.02981014f, -0.00714265f, 0.00751127f, 0.04504019f, 0.02991263f, -0.02576375f, 0.02434328f, -0.00698769f, 
    0.04679950f, 0.04697903f, 0.04055591f, -0.04074240f, -0.01317815f, 0.02520234f, -0.01241496f, 0.01607510f, 
    0.04178389f, -0.00429827f, -0.01845926f, 0.03781850f, -0.01078788f, 0.03028082f, 0.03610741f, -0.03314193f, 
    -0.05830041f, -0.00699516f, 0.01405174f, -0.01182662f, 0.03874837f, -0.06180767f, 0.02215610f, -0.05924711f, 
    -0.21430403f, -0.06285815f, 0.09735066f, 0.21161291f, -0.10783905f, 0.02023970f, -0.01190972f, 0.14652376f, 
    0.15962356f, -0.07739291f, 0.10851044f, 0.09781457f, -0.09741256f, 0.10081501f, -0.11001101f, 0.00537153f, 
    0.06751916f, 0.08456239f, -0.04908381f, 0.00293333f, 0.01029712f, 0.04567255f, 0.02626325f, 0.37017074f, 
    0.16189176f, -0.02529813f, 0.02272283f, -0.12501286f, 0.05400486f, -0.09096349f, -0.14302959f, 0.14935116f, 
    -0.16212410f, -0.14870082f, 0.01737486f, -0.06733200f, -0.01157066f, -0.06194275f, -0.14820428f, -0.13579741f, 
    0.25862402f, 0.36444020f, 0.19739154f, -0.15493341f, -0.15411587f, 0.04128161f, -0.05543369f, 0.03757638f, 
    -0.05129429f, 0.02485110f, 0.02743755f, -0.02434633f, 0.10349604f, 0.09661351f, 0.11225156f, -0.00010310f, 
    -0.00060458f, 0.08608577f, 0.11086924f, -0.09521881f, 0.09209473f, 0.17999056f, 0.33340377f, 0.06150594f, 
    0.05559363f, -0.05377074f, 0.07041740f, 0.11001840f, -0.03735577f, 0.02062440f, 0.02602962f, -0.04015135f, 
    0.02051863f, 0.01741750f, 0.04577157f, -0.04437422f, -0.01033110f, -0.08416001f, 0.23066185f, 0.14245613f, 
    0.12687023f, 0.19829792f, -0.03289554f, 0.11286553f, -0.28787369f, 0.14621159f, -0.14688668f, -0.16500573f, 
    0.15039642f, -0.12919791f, -0.11180918f, 0.00743392f, -0.00319429f, -0.00616666f, -0.11685973f, 0.16217595f, 
    0.11435492f, 0.26027852f, -0.08245882f, 0.11703951f, 0.07402556f, -0.04291181f, -0.11435232f, 0.05151365f, 
    -0.07125060f, -0.04389050f, -0.01531426f, 0.00567347f, -0.06128067f, -0.09878015f, -0.04698450f, 0.01857332f, 
    0.09038833f, -0.03319294f, 0.07908633f, -0.00699639f, -0.00307727f, 0.05105460f, -0.04043103f, 0.07859033f, 
    0.03216650f, -0.00715421f, 0.05505451f, 0.06896423f, 0.01080764f, -0.05468491f, 0.01759372f, -0.06141168f, 
    0.01630754f, -0.00489509f, -0.00105664f, -0.00381163f, -0.09797699f, -0.07158995f, 0.15465121f, -0.16714042f, 
    -0.07593373f, -0.09766429f, -0.01170848f, -0.08018271f, -0.26576319f, -0.00987277f, -0.55377722f, -0.29267281f, 
    -0.31029966f, -0.11583194f, 0.04642199f, 0.04483036f, 0.04645436f, 0.07973566f, 0.13945670f, -0.02912241f, 
    0.00181588f, 0.10930885f, -0.02747784f, -0.07142675f, -0.06883405f, 0.00573301f, 0.04817726f, -0.00268117f, 
    0.01853357f, -0.16274607f, 0.05433717f, 0.04367822f, -0.00367595f, -0.15062435f, -0.11241478f, -0.07757763f, 
    -0.07469639f, -0.07482262f, 0.09555419f, 0.11714657f, -0.05389147f, 0.21217138f, 0.16093473f, -0.06291945f, 
    -0.06305195f, 0.06437370f, -0.02029527f, -0.14309208f, 0.58987886f, -0.52234775f, -0.31946889f, 0.10092505f, 
    -0.17359905f, 0.06596351f, -0.00842416f, 0.16752550f, 0.05252395f, 0.23649745f, 0.07768245f, 0.09099568f, 
    0.11015121f, 0.11381721f, -0.00496653f, 0.00078714f, -0.02875151f, 0.13998559f, 0.12533176f, 0.06844936f, 
    -0.08243725f, -0.17569354f, -0.07650673f, 0.13253406f, 0.05260068f, 0.01852473f, 0.00875110f, 0.01219787f, 
    0.09294742f, 0.11228316f, 0.07480849f, 0.16438890f, 0.04608281f, -0.00998534f, 0.04057204f, 0.08015153f, 
    0.08242223f, -0.03546882f, -0.10793570f, 0.04750877f, 0.12846902f, -0.05389096f, -0.09913787f, -0.00188432f, 
    -0.18676756f, 0.04096429f, -0.00622456f, 0.00941646f, 0.00149943f, 0.00680522f, 0.02864281f, 0.14703603f, 
    0.02824737f, 0.04078552f, -0.05848898f, -0.10114438f, 0.09342197f, -0.00030621f, 0.02753208f, 0.10045218f, 
    0.27020210f, 0.27767661f, 0.01851029f, -0.21112220f, -0.19266675f, 0.19756152f, 0.07827573f, 0.38562137f, 
    -0.06457299f, 0.15130487f, -0.01957376f, -0.02378157f, -0.10637539f, 0.01981965f, 0.06700624f, 0.09473144f, 
    -0.09031726f, -0.00770168f, 0.16838410f, 0.08277362f, 0.24259910f, 0.26504481f, 0.17911552f, -0.26114058f, 
    -0.06001973f, 0.11790603f, 0.18032400f, 0.21807806f, 0.04586586f, -0.02679589f, 0.03189144f, -0.07319877f, 
    0.01173986f, 0.02185738f, 0.01073931f, 0.03002516f, -0.08581257f, -0.10374202f, 0.10800294f, 0.10830617f, 
    -0.02755045f, -0.22385101f, -0.47976246f, -0.30132148f, -0.35944870f, -0.03542281f, 0.08947866f, 0.11625185f, 
    -0.00346657f, 0.20634079f, 0.09684911f, -0.05507752f, -0.10976734f, -0.09865791f, -0.10834347f, -0.03266052f, 
    0.08903680f, -0.00244441f, -0.05124644f, 0.07755835f, 0.19348314f, 0.03813465f, 0.19916201f, 0.18513428f, 
    0.06947555f, -0.11585548f, 0.06789124f, -0.12857220f, -0.06529703f, -0.06694439f, 0.02533029f, -0.10380798f, 
    -0.07831465f, -0.02314210f, 0.08940974f, -0.02690525f, 0.02284226f, 0.07109450f, 0.00302604f, -0.14713326f, 
    0.07133918f, 0.05987275f, -0.12107697f, 0.01174929f, 0.11132008f, 0.02211677f, -0.00871623f, -0.11650125f, 
    0.03626000f, 0.06473347f, 0.02705887f, -0.02332831f, 0.09003495f, 0.12625074f, -0.08010128f, -0.01787245f, 
    0.00547701f, 0.02023928f, 0.09166802f, 0.02072473f, 0.47180372f, 0.19473323f, 0.07148699f, -0.05266371f, 
    0.14556043f, -0.06804769f, -0.10574793f, -0.03316913f, 0.00186456f, -0.14374767f, 0.02720130f, -0.06006696f, 
    -0.07660188f, 0.04508622f, 0.06835969f, -0.06351106f, -0.15441245f, 0.12092811f, 0.17483827f, -0.13085142f, 
    -0.18614364f, -0.05814736f, 0.07318825f, 0.31882414f, -0.04002947f, 0.15124969f, -0.06704527f, -0.20924982f, 
    -0.21547084f, 0.14020181f, -0.01525372f, 0.07689566f, 0.09602569f, 0.09800599f, 0.10631417f, -0.09477459f, 
    0.13130061f, -0.00246098f, 0.04746671f, -0.03098166f, -0.32187581f, 0.14880002f, 0.04047905f, 0.10317716f, 
    0.01053599f, -0.00984120f, 0.06462535f, -0.11568940f, 0.09753140f, 0.05996675f, -0.07241701f, -0.21211445f, 
    -0.04804793f, 0.10849347f, -0.09214198f, 0.05670532f, -0.01045907f, -0.05150581f, 0.02384747f, -0.02502218f, 
    0.20682159f, 0.17236055f, 0.20903966f, -0.10997812f, -0.13162617f, 0.11383411f, -0.13164996f, -0.36734536f, 
    -0.01644729f, 0.08678399f, -0.06409279f, -0.09300676f, -0.01629020f, -0.00134160f, -0.09687358f, -0.07283226f, 
    -0.01198027f, -0.07473223f, 0.07168635f, -0.08145615f, 0.13182573f, -0.04764214f, 0.04865477f, 0.04872428f, 
    0.02138419f, -0.00975026f, -0.07088078f, -0.08710170f, -0.09062932f, -0.10189205f, 0.12915850f, -0.00269559f, 
    0.08070011f, 0.07745568f, 0.08252638f, -0.07955169f, -0.10017960f, -0.03603891f, -0.01781548f, -0.00978353f, 
    0.25478956f, 0.12360946f, 0.03639907f, 0.01151287f, -0.01989010f, -0.03857251f, -0.02391249f, -0.01370679f, 
    0.02366069f, -0.16372240f, 0.00515915f, -0.00610331f, -0.11360672f, 0.06037776f, -0.08495024f, -0.07862455f, 
    -0.07908729f, -0.03267661f, 0.08105694f, -0.17209823f, -0.34378609f, 0.05248787f, 0.05316644f, 0.06819144f, 
    -0.15204832f, 0.06505550f, 0.02783561f, 0.03033614f, 0.02790356f, -0.14051898f, 0.14639835f, -0.11341024f, 
    -0.10783079f, 0.06487510f, 0.10857528f, -0.01218418f, -0.00539061f, 0.02821028f, 0.01847775f, 0.06154663f, 
    0.16884473f, -0.11455964f, 0.04254950f, 0.06053014f, 0.12513801f, -0.13138238f, -0.04960313f, -0.05035333f, 
    -0.01453138f, -0.06684024f, 0.07811533f, 0.06606182f, -0.00811908f, 0.06854261f, -0.10291354f, -0.04932036f, 
    -0.10704105f, -0.07532079f, 0.06231847f, -0.17835490f, 0.58598202f, 0.24812001f, 0.19424939f, 0.21071626f, 
    -0.20788856f, 0.03851049f, 0.10658366f, 0.14071669f, -0.12241460f, 0.03996972f, -0.03521677f, -0.00534097f, 
    0.19604482f, 0.04404968f, 0.04545083f, -0.01931882f, 0.04700715f, 0.05106388f, -0.12953231f, 0.03247083f, 
    -0.18619421f, -0.52185190f, 0.03198374f, -0.14582542f, -0.15219015f, -0.03908678f, -0.01415514f, 0.12340233f, 
    0.22733447f, -0.03155141f, 0.12551522f, 0.01251365f, -0.05972631f, 0.09547145f, -0.03391918f, 0.03217099f, 
    -0.01541917f, -0.13028464f, 0.13719961f, -0.00978344f, -0.24391028f, -0.34429219f, -0.15327549f, 0.16819595f, 
    -0.03109007f, 0.13033900f, 0.16829102f, 0.16660416f, 0.06779937f, 0.14930876f, 0.04741894f, -0.00488087f, 
    0.02434135f, -0.00872153f, -0.12492043f, -0.00151078f, -0.02961122f, 0.05325929f, -0.04650619f, -0.03715360f, 
    0.04275307f, 0.09071766f, 0.42853215f, 0.23206252f, -0.10169934f, 0.09499714f, -0.19677867f, 0.03111727f, 
    0.22286159f, -0.01922981f, 0.15216960f, 0.00721368f, -0.00744937f, -0.01521720f, 0.06297525f, -0.06961583f, 
    0.09399828f, -0.15574123f, 0.17001165f, 0.12992260f, -0.06818855f, 0.08282893f, 0.23854072f, 0.43384323f, 
    0.01780760f, 0.07503988f, -0.03546437f, -0.05738926f, 0.09502408f, 0.12254868f, -0.04170512f, 0.10517463f, 
    0.08512027f, -0.06675829f, 0.02304600f, 0.00437398f, 0.14977886f, 0.13756624f, -0.01672691f, 0.07225112f, 
    0.00056330f, -0.25038058f, -0.27850625f, -0.06755366f, -0.22836450f, -0.08519984f, -0.06996044f, 0.04087413f, 
    0.04037888f, -0.07886637f, 0.02223072f, -0.03984005f, 0.08621799f, 0.03504138f, 0.01784661f, -0.04131425f, 
    -0.06515195f, 0.03532435f, -0.11294088f, -0.03029810f, 0.60427815f, 0.10821423f, 0.16260612f, 0.13065526f, 
    0.09348018f, -0.05103127f, 0.00637207f, -0.01755097f, -0.03449951f, -0.04878857f, -0.20347530f, -0.06641044f, 
    0.05562067f, -0.03399284f, -0.10491854f, 0.14183322f, -0.03309871f, 0.01530608f, 0.00377988f, -0.10680731f, 
    0.31294721f, -0.04840494f, -0.01212654f, -0.18820709f, -0.18075158f, -0.04338766f, -0.09532041f, -0.09035668f, 
    -0.19184396f, 0.02699755f, 0.18044232f, -0.02406280f, 0.22767833f, 0.05280271f, 0.04030866f, 0.13866253f, 
    0.17031038f, 0.03992996f, 0.04034099f, 0.13049366f, -0.37629083f, -0.12800832f, 0.31717435f, -0.27852669f, 
    -0.04224740f, -0.18481043f, -0.13045146f, -0.12346438f, -0.22060968f, 0.01184981f, 0.06335776f, -0.11550983f, 
    0.12866792f, -0.00612619f, 0.03330529f, 0.08882011f, 0.04250002f, 0.02083334f, 0.13669412f, -0.02522665f, 
    -0.06352864f, -0.15966220f, -0.10162885f, 0.21782456f, 0.24061631f, 0.16242379f, 0.17762494f, 0.17289339f, 
    0.15834823f, -0.03925551f, 0.03346441f, 0.05254709f, -0.04751589f, 0.06100599f, 0.12419931f, 0.10688990f, 
    -0.01116455f, -0.04569173f, -0.11158197f, -0.00463866f, -0.06304988f, -0.14336248f, -0.08875681f, -0.35213134f, 
    -0.09238813f, 0.24780191f, 0.03275808f, 0.02890748f, 0.08364581f, -0.15974690f, -0.11427967f, -0.04730734f, 
    0.13970396f, 0.03853906f, 0.15314126f, 0.06533462f, 0.18860553f, 0.25400761f, -0.00107217f, 0.23382367f, 
    -0.38501388f, -0.40878025f, -0.15675959f, -0.15447670f, 0.28495789f, -0.04433251f, 0.12519580f, 0.21009092f, 
    -0.33115166f, -0.06268615f, -0.06535263f, -0.05949849f, -0.08146659f, -0.09152158f, 0.05864860f, -0.02633467f, 
    -0.07371192f, 0.09752032f, -0.14206471f, 0.02194638f, -0.12818608f, -0.21967718f, -0.12026548f, -0.24815968f, 
    -0.21780735f, 0.00534292f, -0.24908741f, -0.11384260f, -0.03822874f, -0.06785665f, 0.10536309f, 0.01201623f, 
    0.04097166f, 0.13357057f, 0.18807018f, 0.06380148f, 0.05453455f, 0.14384051f, 0.13221359f, 0.00327422f, 
    -0.35914958f, -0.30576137f, -0.26124644f, -0.13537416f, -0.14789003f, -0.12004513f, -0.17047375f, -0.28676715f, 
    -0.15408246f, -0.12780252f, 0.13387421f, 0.06484551f, 0.05985612f, 0.12409559f, 0.11847767f, 0.21466440f, 
    0.23845418f, 0.06963914f, 0.10904041f, 0.06026598f, 0.21471888f, -0.11260515f, 0.40819573f, 0.04528914f, 
    0.24064717f, -0.02968830f, -0.01645776f, 0.10297341f, 0.09296523f, 0.02078766f, -0.18651214f, 0.09676504f, 
    0.04929849f, -0.02356700f, -0.09472350f, -0.00610279f, 0.01647484f, 0.11407097f, -0.06015390f, -0.02484349f, 
    -0.00346627f, -0.04329722f, -0.12249769f, -0.17207037f, -0.06929974f, 0.01703939f, -0.17341304f, -0.13975474f, 
    -0.06862485f, -0.05579714f, -0.03629983f, 0.06016399f, 0.16882752f, -0.04548668f, 0.04418207f, 0.05985636f, 
    0.16447790f, 0.12664904f, 0.01751483f, -0.11955467f, -0.53631127f, 0.46860304f, 0.33145452f, -0.11709090f, 
    0.43522215f, -0.02040148f, 0.10135567f, -0.11368151f, 0.14215685f, 0.12797131f, 0.08155029f, 0.07871048f, 
    0.20829485f, -0.00105809f, 0.17965011f, -0.00717287f, 0.11036561f, -0.04176106f, 0.19391580f, -0.07405884f, 
    0.22246483f, -0.16149478f, 0.25144282f, 0.09798574f, 0.17139244f, 0.09181860f, 0.18226849f, 0.07752243f, 
    -0.09073103f, 0.12657636f, 0.02600893f, -0.18328153f, 0.11353011f, 0.02583474f, 0.06154233f, 0.06983034f, 
    0.15625095f, 0.13809671f, 0.19369094f, 0.03290750f, -0.07096119f, -0.10374235f, 0.04082954f, 0.03797994f, 
    0.18328813f, 0.14292897f, 0.18507284f, -0.07598476f, 0.20203120f, 0.20999153f, 0.06825319f, -0.03093561f, 
    -0.10514077f, -0.03582675f, 0.03325458f, 0.11710788f, 0.13672094f, 0.00443955f, 0.17532258f, 0.12751164f, 
    -0.45466149f, -0.08188175f, 0.13996199f, 0.28358823f, 0.39051116f, -0.15326346f, 0.07879039f, -0.21325792f, 
    -0.00769923f, -0.12638797f, 0.00410998f, 0.07325488f, 0.05009299f, 0.04075445f, 0.04052178f, -0.00515955f, 
    0.08667069f, 0.01610300f, 0.11562204f, -0.07307792f, -0.25356811f, -0.08281445f, 0.02106324f, 0.26453641f, 
    0.13462709f, -0.01455643f, -0.02723614f, 0.02152668f, 0.14010760f, 0.11753050f, -0.03991797f, 0.08405223f, 
    0.02136301f, 0.13040771f, 0.06959050f, 0.03036374f, 0.12656845f, 0.01364618f, 0.12189190f, 0.08340228f, 
    0.11586894f, -0.00375228f, 0.27724573f, -0.01650002f, 0.18433791f, 0.02591290f, -0.09979823f, -0.08126411f, 
    0.09941368f, 0.13799395f, 0.02348240f, 0.11364058f, 0.07213422f, 0.02753229f, 0.02471635f, 0.08613137f, 
    -0.02796244f, 0.01334162f, 0.08160631f, 0.10704924f, -0.53813136f, 0.05361180f, -0.17102346f, -0.18492042f, 
    -0.31136048f, -0.08091300f, -0.18168153f, -0.26188809f, -0.12653726f, 0.00468376f, -0.00311784f, 0.14379437f, 
    -0.12253181f, 0.02652841f, -0.03810628f, -0.00211454f, 0.07479186f, 0.06576872f, 0.01832678f, -0.06921290f, 
    -0.19825491f, -0.14645967f, 0.09470454f, 0.05412595f, 0.05695549f, 0.04889876f, -0.03935649f, 0.00722123f, 
    0.00628169f, 0.03290472f, 0.10489375f, 0.09960477f, 0.02978812f, 0.06738808f, 0.08154814f, 0.04381453f, 
    0.03155051f, 0.11764419f, 0.00509863f, -0.08923391f, -0.08364037f, 0.03818751f, -0.14099479f, -0.03368645f, 
    0.04841027f, -0.10063690f, 0.01267516f, -0.08386275f, 0.03216456f, -0.08805621f, -0.05801731f, -0.15256092f, 
    0.04164313f, 0.08234923f, 0.04837842f, 0.18833090f, -0.11360127f, -0.05235027f, 0.21503939f, -0.04216233f, 
    -0.09791728f, 0.18986921f, 0.15796846f, -0.13336469f, -0.42891437f, 0.05857712f, 0.27314016f, 0.01329636f, 
    0.01621896f, 0.01486840f, 0.09961202f, 0.10937314f, -0.02643491f, 0.02488234f, 0.01017019f, 0.03811786f, 
    -0.02324910f, 0.02489284f, 0.10412244f, 0.08943017f, -0.27142727f, -0.04610753f, -0.13624761f, -0.50330812f, 
    -0.24964519f, 0.26887354f, 0.00965599f, -0.06846225f, -0.03109681f, 0.10896733f, -0.00318359f, 0.00430931f, 
    0.09183072f, 0.01093808f, 0.02491300f, -0.09450378f, -0.01376444f, 0.20270236f, 0.06827060f, 0.02389420f, 
    -0.42586276f, -0.29790333f, -0.38828304f, -0.03020955f, 0.25254717f, -0.00286960f, 0.01098964f, 0.12655437f, 
    -0.10269517f, 0.01919581f, -0.12737034f, -0.13054691f, -0.10013776f, -0.12758216f, -0.04436553f, 0.12835348f, 
    -0.06519580f, 0.10580504f, -0.04696185f, -0.05179260f, 0.09909683f, -0.20873575f, -0.05720666f, -0.18048100f, 
    -0.02120294f, -0.08331598f, -0.17368966f, -0.08674585f, -0.11672464f, -0.03002325f, 0.07169412f, 0.06871643f, 
    -0.02039641f, 0.03124579f, -0.04180130f, 0.07977583f, 0.02476324f, 0.10387467f, 0.05963016f, 0.03383603f, 
    -0.23337987f, 0.07417484f, -0.26846677f, -0.16092703f, 0.01884867f, -0.08861379f, -0.03446449f, -0.27196965f, 
    -0.03960864f, -0.14227355f, 0.18321344f, -0.15582147f, -0.06222682f, -0.13548613f, -0.00141387f, 0.11123069f, 
    -0.01811139f, -0.04974461f, 0.03234316f, -0.06845266f, -0.17147824f, 0.32132551f, 0.45216250f, 0.21024452f, 
    0.24451078f, -0.05728892f, -0.08206584f, 0.09261034f, 0.08162937f, 0.11804304f, 0.02079621f, 0.10355548f, 
    0.00920874f, 0.03795717f, 0.03248925f, -0.04331619f, 0.04778266f, 0.18211868f, -0.05574203f, -0.00067223f, 
    0.24793421f, 0.03964434f, -0.01039644f, -0.09262933f, 0.12317315f, -0.04206876f, -0.13187130f, -0.17974214f, 
    -0.03554976f, 0.01344844f, -0.06861026f, -0.04333628f, -0.00138815f, -0.00943321f, 0.06429043f, 0.04404771f, 
    0.07140792f, 0.20211831f, 0.08029357f, -0.04591971f, 0.07801341f, 0.44999847f, 0.06146612f, -0.09750822f, 
    0.16303886f, 0.00902574f, 0.07701553f, -0.27655953f, 0.14142852f, 0.25674936f, 0.12525445f, 0.16355820f, 
    0.10911473f, -0.05357897f, 0.08354069f, -0.03300520f, 0.04523601f, -0.01604869f, 0.13740252f, 0.13258447f, 
    0.12810169f, 0.18693015f, 0.16885036f, -0.25872692f, -0.11161316f, 0.00737810f, -0.04067532f, 0.12674668f, 
    0.09627413f, 0.07377624f, 0.05630051f, -0.16102573f, -0.03551214f, 0.12781160f, 0.04360293f, 0.03833140f, 
    0.15674740f, 0.03685327f, 0.04945274f, -0.01467190f, -0.02888150f, 0.25887725f, 0.16730490f, 0.02009455f, 
    -0.11805326f, -0.08928516f, 0.00016411f, -0.10897352f, 0.03698403f, 0.05571562f, 0.09251967f, -0.05941409f, 
    -0.01586636f, 0.05407174f, -0.01981346f, -0.00167537f, 0.10194571f, -0.07406335f, -0.20536773f, 0.15730089f, 
    -0.25647861f, -0.13117856f, 0.35997233f, 0.00206160f, -0.10565628f, 0.10910204f, 0.04312214f, -0.08985215f, 
    -0.03592089f, -0.04404425f, -0.01339151f, -0.06354291f, 0.00374410f, -0.03356744f, -0.10041132f, -0.01736683f, 
    0.07689159f, -0.04760347f, -0.05619817f, 0.01067516f, -0.31907421f, 0.05899066f, 0.25032732f, 0.16903061f, 
    -0.03670101f, 0.08137444f, 0.17489752f, 0.03512747f, 0.12955761f, -0.01999733f, 0.00997311f, -0.04849513f, 
    0.01445152f, 0.07544927f, 0.02435246f, 0.05083418f, 0.00511181f, -0.04662615f, -0.03656424f, 0.20646827f, 
    0.05885395f, 0.27672669f, 0.45637766f, 0.14255370f, 0.11973323f, -0.18233855f, -0.12250629f, 0.01115386f, 
    0.02389370f, 0.17771260f, 0.01272437f, 0.10282446f, 0.06698177f, 0.06817432f, 0.02105034f, -0.00579506f, 
    0.00641629f, -0.02406672f, -0.04542582f, 0.14216396f, -0.04691759f, 0.07836029f, -0.12207612f, -0.15508938f, 
    0.04142857f, -0.13993441f, -0.11861443f, -0.11846113f, -0.07676552f, 0.01198507f, 0.09487391f, -0.00554637f, 
    -0.09540844f, 0.06043730f, 0.06859855f, 0.02079598f, 0.09108563f, 0.17703579f, 0.26420265f, -0.10849175f, 
    0.09006936f, 0.14827611f, -0.00820939f, -0.05036608f, 0.04752274f, 0.00394512f, 0.14541127f, -0.01839085f, 
    -0.08299532f, -0.10182825f, -0.10577912f, 0.08421023f, 0.10883377f, 0.01254258f, 0.18128204f, 0.09690717f, 
    0.05122321f, -0.08540012f, 0.06618237f, -0.13689473f, -0.02222880f, 0.13671347f, 0.19448504f, 0.07205457f, 
    0.15684171f, 0.02225707f, 0.07029454f, -0.01408242f, -0.08555249f, -0.09087665f, 0.01269960f, -0.18369517f, 
    -0.05144507f, -0.01857580f, -0.11322903f, 0.15285927f, 0.17787589f, 0.21354882f, 0.03670988f, 0.09807923f, 
    -0.03372336f, -0.31079066f, -0.31824693f, -0.00383371f, -0.12120955f, 0.04256972f, -0.11115340f, 0.07356148f, 
    -0.05296187f, -0.22206363f, 0.12875462f, 0.05913716f, -0.02891599f, -0.00386766f, 0.07424586f, 0.18820378f, 
    0.06384682f, -0.04630885f, 0.02698786f, 0.03974878f, 0.19734214f, -0.21205810f, -0.06136371f, 0.23331767f, 
    0.07978295f, 0.21024045f, -0.03303844f, -0.00865400f, 0.28932497f, 0.14784177f, 0.03531123f, -0.02340317f, 
    0.07099796f, -0.15528953f, 0.13116334f, -0.03666343f, 0.10651846f, -0.06214699f, 0.51615441f, 0.06904405f, 
    0.12050822f, -0.03186136f, -0.23972133f, -0.09582739f, -0.17510608f, 0.09393746f, 0.26341048f, 0.27863333f, 
    0.16630973f, 0.05476601f, -0.09189170f, -0.04251864f, -0.06543059f, -0.11436711f, -0.06436671f, -0.04601485f, 
    -0.29748747f, 0.21413125f, 0.26449502f, 0.16415267f, 0.00713994f, 0.15495925f, 0.08251873f, -0.02318243f, 
    -0.14030731f, -0.01234540f, 0.08481222f, -0.07089785f, -0.04538433f, -0.06891102f, 0.10011504f, 0.04923034f, 
    0.12664014f, 0.20698307f, 0.03278928f, 0.07873735f, 0.02294508f, -0.05893864f, -0.03051027f, 0.01073981f, 
    -0.03392754f, 0.05721919f, 0.15310559f, -0.14738664f, 0.01591667f, -0.00056828f, -0.03108232f, -0.05837716f, 
    -0.13745381f, -0.05726028f, 0.08770674f, -0.12407647f, 0.16448560f, 0.13044919f, 0.06034581f, 0.03655865f, 
    0.05920706f, -0.08966187f, -0.03909351f, 0.07766131f, 0.22690697f, 0.10576038f, -0.15177046f, 0.30973622f, 
    0.13082574f, -0.07951263f, 0.03130312f, -0.02857574f, 0.05978612f, 0.25506076f, 0.22945040f, 0.26863021f, 
    0.21115434f, 0.03998062f, -0.06218309f, 0.05067436f, -0.04001368f, 0.02555252f, 0.11899187f, 0.01637748f, 
    0.01074774f, 0.12074229f, 0.12590207f, 0.16380534f, 0.14726721f, 0.00830444f, 0.02176140f, -0.11704068f, 
    -0.13009709f, -0.15934460f, 0.04706063f, -0.08596155f, 0.10434671f, 0.01129632f, 0.04519336f, 0.06740066f, 
    0.13526291f, -0.07700143f, 0.05717722f, 0.10283469f, -0.05289898f, 0.14762908f, 0.12784778f, 0.04549187f, 
    0.10471430f, 0.12953766f, 0.19013284f, 0.10123008f, 0.18476541f, 0.20960824f, 0.28078482f, 0.27104563f, 
    0.28194723f, 0.30758253f, 0.14197043f, 0.05897331f, 0.00562414f, -0.01217798f, 0.20344275f, 0.03679433f, 
    -0.21102628f, -0.10894628f, 0.33173519f, -0.07234699f, 0.26011556f, -0.04148486f, -0.19712323f, -0.14050993f, 
    0.06636765f, -0.05801705f, 0.13816251f, 0.24884506f, 0.05551776f, 0.04644185f, 0.09280822f, 0.00859156f, 
    0.03328745f, -0.00545345f, -0.17382593f, 0.05406991f, -0.21836004f, -0.02853998f, -0.04648397f, -0.09435959f, 
    -0.10969914f, -0.14297701f, -0.31741178f, -0.31874746f, 0.13396174f, -0.10364612f, 0.04104864f, 0.30295715f, 
    0.00654440f, 0.04454404f, 0.02557860f, -0.03336918f, 0.03677994f, 0.05153929f, 0.02752049f, -0.20150016f, 
    -0.36600044f, -0.26398122f, -0.19736163f, -0.09856912f, -0.15006807f, -0.19341706f, -0.17110293f, -0.11020730f, 
    0.23746428f, -0.05416656f, 0.02877364f, 0.04198788f, -0.00280780f, 0.11102431f, 0.12178296f, 0.08089121f, 
    -0.01680784f, 0.20029698f, 0.00881523f, 0.02061648f, -0.45485893f, -0.31050721f, -0.06161731f, 0.02622553f, 
    -0.11531255f, -0.05891577f, -0.12482416f, -0.02588769f, 0.04841417f, 0.00964727f, 0.02758831f, 0.07365851f, 
    0.06763323f, 0.03796095f, -0.00522343f, 0.06766076f, 0.02401448f, 0.07951039f, 0.05933955f, -0.06087412f, 
    0.09180746f, 0.13287726f, 0.19083023f, -0.04845158f, -0.17680670f, -0.08607682f, 0.01843537f, -0.18586296f, 
    -0.10941949f, 0.15519975f, 0.17084880f, 0.32601443f, 0.21797334f, 0.11661643f, 0.11733734f, -0.02290590f, 
    -0.00304764f, -0.09571018f, 0.03789692f, -0.04028925f, -0.03907098f, 0.08166382f, 0.01410736f, 0.16075011f, 
    0.14366788f, -0.02391655f, 0.04513891f, 0.05082950f, -0.13110553f, -0.12834293f, -0.06801124f, -0.05904742f, 
    -0.07596312f, -0.06673592f, -0.15109053f, 0.08879546f, 0.09079290f, 0.00808565f, -0.05681455f, 0.06335346f, 
    -0.15439305f, -0.07742178f, 0.09556932f, 0.11349641f, -0.12334318f, -0.01388410f, -0.02547928f, 0.08805500f, 
    -0.03189099f, -0.11340770f, -0.00630893f, 0.17198473f, -0.11170813f, -0.10245072f, -0.02247814f, -0.02628294f, 
    -0.01632419f, 0.17650452f, -0.08679031f, -0.05590094f, 0.02791202f, 0.12807687f, 0.13575873f, -0.02100676f, 
    0.19994378f, 0.02885623f, 0.01962679f, -0.01122586f, 0.01605504f, -0.15124536f, -0.02741308f, -0.00969049f, 
    0.07954864f, -0.10838729f, -0.02069170f, -0.04133587f, 0.07496432f, -0.19333176f, 0.04068048f, -0.06203283f, 
    0.26798233f, 0.29230872f, 0.19499089f, -0.11144305f, -0.22025765f, 0.07920075f, 0.02016337f, 0.10348205f, 
    -0.06116263f, 0.23607865f, 0.04268844f, 0.07529464f, 0.06582902f, 0.09230644f, -0.00804390f, -0.05488579f, 
    -0.04368286f, 0.00574901f, -0.01206844f, -0.07723173f, 0.00208870f, -0.15235241f, 0.14989311f, -0.19202484f, 
    0.06824542f, 0.23301475f, 0.02050889f, 0.07403809f, 0.12349819f, 0.22529770f, 0.03907619f, -0.07497824f, 
    0.08956262f, 0.00965378f, -0.08375469f, -0.11142757f, -0.00607018f, -0.13610899f, 0.32461184f, 0.12191272f, 
    -0.16743703f, 0.15024784f, -0.55585349f, 0.28354949f, -0.26286826f, 0.00735674f, -0.06543949f, 0.08818325f, 
    -0.07585084f, -0.00788578f, 0.04943864f, 0.05499850f, 0.05842301f, 0.01581065f, 0.01482545f, 0.18962091f, 
    0.02223463f, 0.18400291f, -0.00844001f, -0.09042223f, 0.00787907f, 0.10763983f, 0.09800377f, 0.07111191f, 
    -0.02232331f, -0.04734251f, -0.10066921f, -0.12981959f, -0.13122614f, -0.05582182f, 0.06375305f, -0.04954096f, 
    0.06424672f, 0.00810364f, -0.14861369f, -0.00979120f, -0.00793676f, 0.07461813f, -0.01685501f, 0.00670083f, 
    0.16376959f, 0.05878047f, 0.06069724f, -0.10404547f, 0.04528572f, -0.02843955f, -0.00478954f, -0.07489897f, 
    -0.03554498f, -0.06178332f, 0.13345301f, -0.06398242f, 0.01467510f, -0.14635569f, 0.04804009f, -0.03482373f, 
    -0.15017134f, -0.20358500f, 0.08062708f, -0.00130345f, 0.35242620f, 0.24282095f, -0.38778228f, 0.04686199f, 
    -0.29583308f, -0.02757450f, -0.14832172f, 0.07306822f, 0.15634477f, 0.10463641f, 0.06249114f, 0.12937094f, 
    0.00321292f, -0.06318169f, -0.07260148f, -0.00112607f, -0.02500587f, -0.05385229f, 0.00986766f, -0.07103897f, 
    0.26599053f, 0.06099693f, 0.17916985f, 0.01238444f, 0.07237468f, -0.06146969f, 0.02098797f, -0.07030005f, 
    0.00558352f, -0.12204156f, 0.11509641f, -0.11395048f, -0.04763770f, -0.02631277f, 0.09936497f, -0.04207643f, 
    0.01671801f, -0.04200086f, 0.03313041f, -0.01826058f, 0.46875641f, -0.41046628f, -0.28207886f, -0.12437725f, 
    -0.28751096f, 0.12013615f, -0.13499972f, 0.14861517f, -0.09799159f, 0.20343962f, 0.02941405f, 0.22033609f, 
    -0.03979314f, -0.00085255f, -0.04533873f, 0.05256635f, -0.04414400f, 0.01106585f, 0.09640789f, 0.13365373f, 
    -0.10417920f, 0.24538206f, 0.27755395f, -0.28292117f, -0.15552488f, 0.10185427f, -0.06145817f, 0.13531782f, 
    -0.03998378f, 0.08198623f, 0.16211301f, 0.06146018f, -0.05357797f, 0.15640403f, 0.03122362f, -0.01612584f, 
    0.00584038f, 0.16293108f, -0.15365900f, 0.11194076f, -0.01328044f, 0.13427559f, -0.02555084f, -0.12703007f, 
    -0.21964611f, 0.06008692f, -0.11570188f, 0.17391850f, 0.16381830f, 0.08269321f, -0.06057724f, -0.03077640f, 
    -0.05628810f, 0.03126794f, -0.00505766f, 0.00113503f, -0.00993566f, 0.02090753f, -0.00983140f, 0.12066325f, 
    0.26948330f, 0.13160963f, -0.07053571f, -0.23170231f, -0.21127161f, 0.08593089f, 0.02862106f, 0.23925222f, 
    0.16690619f, 0.14145191f, -0.00708267f, -0.03093034f, -0.04071225f, -0.00101413f, 0.02629737f, 0.00152192f, 
    -0.06487288f, 0.08787157f, 0.07067137f, 0.01565356f, 0.17009823f, 0.21031913f, 0.10575351f, -0.22460824f, 
    -0.11453930f, 0.13588671f, 0.18695949f, 0.14774571f, 0.07552977f, 0.06162617f, 0.04181400f, -0.09559482f, 
    0.00800500f, -0.00173096f, 0.06017238f, -0.03323115f, -0.03012048f, -0.10574546f, 0.19989133f, -0.03174689f, 
    0.28810811f, -0.03677491f, -0.18804343f, -0.27667341f, -0.35408095f, -0.07628632f, 0.03645759f, -0.06171068f, 
    0.07395604f, 0.05763616f, 0.06718946f, 0.02829335f, 0.00533345f, 0.02712426f, 0.02371660f, -0.07058427f, 
    0.02457544f, -0.02607811f, 0.07929064f, 0.04751508f, 0.16130036f, 0.06422902f, 0.05294480f, 0.16607265f, 
    0.05964644f, -0.01724750f, 0.02553127f, 0.00620602f, -0.05717547f, -0.00195855f, 0.11479297f, 0.01798481f, 
    -0.07149531f, 0.09881029f, -0.07555383f, 0.00910753f, 0.01427907f, 0.05988146f, 0.02114809f, -0.01142532f, 
    -0.18555801f, 0.10569569f, -0.20102389f, 0.25688463f, 0.11922507f, 0.12003304f, -0.12086934f, 0.04710369f, 
    -0.02841649f, 0.12744634f, 0.06932765f, 0.05078818f, -0.00844964f, -0.06072260f, -0.04061669f, 0.12100749f, 
    0.00375264f, 0.07946727f, -0.03169624f, 0.01187046f, -0.02631436f, -0.06223846f, -0.20312259f, 0.16618516f, 
    0.10815507f, -0.13969442f, 0.06789489f, -0.23847228f, -0.14749192f, 0.14529338f, 0.06040246f, 0.00692572f, 
    0.05449284f, 0.11371435f, -0.04455874f, 0.20432152f, -0.12999845f, 0.08115771f, 0.04423797f, 0.06150804f, 
    0.24084079f, -0.17175603f, 0.09571403f, 0.16835791f, 0.14031625f, -0.01617537f, 0.12825580f, 0.13353015f, 
    0.29286700f, 0.02823651f, -0.04426275f, 0.03443645f, 0.01027434f, -0.01520770f, -0.15032233f, 0.09234632f, 
    0.04853056f, 0.02896982f, 0.30589706f, 0.16682579f, 0.01895807f, -0.11115934f, 0.05050173f, 0.32109153f, 
    -0.19908328f, 0.00800716f, 0.09908403f, 0.40640381f, -0.21301906f, -0.01423666f, 0.12171020f, 0.02921075f, 
    -0.03253954f, -0.14380124f, 0.00969383f, 0.11918708f, 0.03671149f, 0.11078551f, 0.07507547f, 0.03958204f, 
    0.13676223f, -0.06801537f, -0.04477163f, -0.01270742f, 0.06218049f, 0.14092907f, 0.32721719f, -0.01833205f, 
    0.00489017f, 0.18811242f, -0.13223323f, -0.04325196f, -0.09182806f, -0.16189133f, 0.05118740f, 0.09498990f, 
    -0.01129605f, 0.10007156f, -0.14184317f, -0.02124575f, -0.02229661f, 0.05800357f, -0.34671295f, -0.02210522f, 
    0.20743775f, 0.04234215f, -0.03147387f, -0.08789322f, 0.11022277f, -0.06514854f, -0.07721078f, -0.00588574f, 
    0.00048527f, 0.05698586f, 0.03600827f, 0.00768952f, -0.10833485f, 0.07454284f, -0.19611378f, -0.01898925f, 
    -0.29490706f, 0.10384085f, -0.09902789f, -0.05558338f, 0.01385460f, 0.03699214f, 0.18619014f, 0.03933158f, 
    -0.05170785f, -0.04150243f, -0.10365616f, -0.09490315f, 0.02441010f, -0.08165990f, -0.06530743f, 0.05877547f, 
    -0.04163199f, -0.06922536f, -0.13554524f, -0.12687388f, -0.48335645f, 0.35670257f, -0.20850980f, -0.03786876f, 
    0.18968564f, 0.07191634f, 0.03622848f, 0.00070105f, 0.04664685f, 0.29890871f, -0.12883554f, 0.01709754f, 
    0.17903599f, 0.16364321f, 0.00260991f, -0.22433566f, -0.03060162f, 0.17185584f, -0.03492633f, 0.22955377f, 
    -0.18269259f, 0.15052143f, -0.04556599f, -0.02290613f, -0.00394224f, 0.10529603f, 0.07361429f, 0.04734185f, 
    -0.16198474f, -0.05110064f, -0.03644604f, -0.04423434f, 0.08235267f, 0.03687889f, -0.00025266f, 0.03847104f, 
    0.08822428f, 0.17746671f, -0.06994486f, 0.07963157f, -0.41023412f, -0.05690467f, 0.18944073f, -0.09531340f, 
    0.14899218f, 0.10151881f, 0.11097287f, 0.05340827f, 0.25378442f, -0.01391472f, 0.07621262f, 0.19988593f, 
    0.29924545f, 0.05099868f, 0.07856146f, 0.23838711f, -0.11303159f, 0.09201388f, 0.11856193f, 0.03267849f, 
    0.05712958f, 0.21006681f, 0.40824822f, 0.20441735f, 0.36371678f, -0.01968231f, -0.01313650f, 0.05059437f, 
    -0.07723637f, -0.00163353f, -0.15188541f, 0.00228512f, -0.09157623f, -0.19668317f, -0.10667873f, 0.19949655f, 
    -0.01771988f, -0.01036981f, 0.03903478f, -0.00044936f, 0.09886629f, 0.05505333f, 0.37290055f, 0.10843270f, 
    -0.14256652f, 0.05033688f, -0.07380978f, 0.02694160f, 0.02173757f, 0.06592987f, -0.10587221f, 0.05877709f, 
    -0.13095036f, -0.36227733f, -0.06131110f, 0.03920401f, 0.03820110f, -0.08006094f, -0.08571331f, -0.13041162f, 
    -0.56562740f, -0.13165277f, -0.08290967f, -0.10508066f, -0.05192348f, -0.00794848f, 0.00796686f, 0.05001941f, 
    0.07629687f, 0.09186185f, -0.19302583f, -0.04376262f, 0.02311909f, 0.12358832f, -0.05936437f, 0.07643418f, 
    0.06582509f, 0.16513079f, 0.02745608f, -0.15424560f, -0.25383687f, -0.21678935f, 0.13459182f, 0.13586858f, 
    -0.07529966f, 0.19027683f, 0.02143953f, 0.15930228f, 0.15602358f, 0.14446563f, 0.04043336f, -0.04174076f, 
    0.01495820f, -0.03838800f, -0.12403461f, -0.12803949f, -0.11191676f, -0.13917150f, 0.27840194f, 0.07582373f, 
    -0.24268359f, 0.21799617f, 0.41512990f, 0.15066026f, 0.15829518f, 0.09599563f, -0.10670539f, -0.15978363f, 
    -0.01539536f, 0.14758308f, -0.05093275f, 0.01764075f, -0.08415137f, -0.04462297f, -0.05386575f, -0.00085026f, 
    -0.15423344f, -0.13848864f, -0.08243043f, 0.05115369f, -0.19347373f, 0.01570599f, -0.19985014f, -0.24862288f, 
    0.07220641f, -0.05300368f, -0.00688979f, -0.05146118f, -0.02216618f, 0.02169246f, 0.00380347f, -0.02193047f, 
    0.02978467f, -0.08016090f, -0.00154872f, 0.03389500f, -0.01644298f, 0.09980594f, 0.03489907f, 0.02765667f, 
    -0.60394102f, -0.10891698f, -0.10661104f, 0.25948009f, 0.08436491f, 0.05442583f, 0.12738168f, -0.00346031f, 
    0.06253105f, -0.05684406f, 0.05308330f, 0.13357644f, -0.03893473f, 0.04446797f, 0.11379125f, 0.06058639f, 
    0.03896913f, 0.06926551f, -0.11810455f, -0.07661238f, 0.02215503f, -0.18919295f, -0.45861360f, -0.09034489f, 
    0.32300550f, 0.00331442f, 0.05907716f, 0.06854939f, 0.05561510f, -0.04490724f, -0.02731489f, 0.02457421f, 
    -0.04199858f, -0.10094035f, -0.14129108f, -0.04003190f, -0.03345717f, -0.08829536f, 0.10280233f, 0.07701589f, 
    0.10558165f, 0.41280892f, 0.32406506f, -0.05931134f, -0.23001696f, 0.04060441f, -0.15271628f, -0.00218383f, 
    0.00390052f, 0.32016814f, 0.02560695f, 0.12569845f, 0.09413452f, 0.09359717f, -0.01324692f, -0.05552830f, 
    0.04664177f, 0.09986793f, 0.00586203f, 0.03403633f, -0.19595759f, 0.11825882f, 0.05703341f, -0.25826237f, 
    0.01498078f, -0.03828156f, -0.04160753f, -0.12454055f, 0.10345150f, 0.11090326f, -0.03956044f, -0.09551157f, 
    0.04838038f, 0.04776058f, -0.09613501f, -0.02940765f, -0.09282615f, -0.06356697f, -0.03796591f, -0.01462156f, 
    -0.12605575f, 0.18920510f, -0.62612242f, 0.42538697f, -0.22899629f, 0.06483091f, 0.09884048f, 0.11115713f, 
    0.08005483f, 0.07832972f, -0.03042695f, -0.09230164f, -0.01943493f, -0.01371197f, -0.01720633f, 0.07032112f, 
    0.02831151f, -0.02796887f, 0.03023404f, -0.10749857f, -0.06409864f, -0.13644516f, -0.03469807f, 0.05586479f, 
    0.21197127f, -0.06167511f, -0.06890655f, -0.11255601f, -0.07166046f, -0.13947007f, 0.07657553f, 0.13931482f, 
    0.14957863f, 0.10411350f, -0.06215265f, 0.08576316f, 0.05786920f, -0.01922953f, -0.09004344f, 0.06081198f, 
    -0.00361866f, -0.15299074f, -0.16963150f, -0.14775321f, 0.15418972f, -0.05170475f, -0.03662525f, -0.20321289f, 
    -0.01935915f, -0.08374405f, 0.13890608f, 0.14180820f, 0.06608230f, 0.00130370f, 0.05154206f, 0.05641092f, 
    0.05506069f, 0.00412074f, 0.05088983f, -0.11024506f, -0.21723232f, 0.20066190f, 0.14543888f, 0.30859277f, 
    -0.28178480f, 0.02180181f, -0.09066294f, -0.15008502f, -0.14915027f, -0.21504611f, 0.16377911f, -0.08982877f, 
    0.01168602f, -0.04521638f, 0.15675026f, 0.14342533f, 0.08887805f, 0.12126656f, -0.00738821f, 0.04361240f, 
    0.06521431f, -0.07786723f, -0.07453149f, 0.03054841f, 0.31089655f, -0.27738276f, -0.00031799f, -0.21371865f, 
    0.02047991f, -0.18657134f, 0.02138672f, -0.02607256f, -0.02921018f, 0.01967163f, 0.15288037f, 0.02928378f, 
    -0.01491995f, 0.07352261f, 0.03321552f, 0.06409243f, 0.47040442f, -0.61110026f, -0.01756989f, 0.00820746f, 
    -0.48657548f, 0.02948706f, -0.16579282f, -0.08521123f, 0.02932033f, -0.01094078f, 0.00916709f, 0.08318398f, 
    0.01493317f, 0.03073939f, 0.10597060f, 0.00326790f, 0.02098129f, -0.06118235f, 0.05676318f, 0.07322031f, 
    0.05217207f, 0.12821530f, 0.08305174f, -0.39256358f, -0.28065243f, 0.03067521f, 0.00543322f, 0.05084558f, 
    0.04179285f, 0.16798161f, 0.09176005f, 0.05458539f, -0.09546399f, 0.10447898f, -0.03001787f, -0.10073804f, 
    0.06255603f, 0.00974761f, -0.13690019f, -0.03444389f, 0.14304860f, 0.19437252f, 0.29053482f, 0.05596654f, 
    -0.08263094f, 0.01149634f, 0.00846031f, 0.08910656f, 0.07122610f, 0.06848907f, -0.00835260f, -0.00170316f, 
    0.05572928f, -0.04514197f, 0.00336515f, -0.04067405f, -0.02262704f, -0.16479874f, -0.05147743f, -0.03355487f, 
    0.32328075f, 0.09907807f, 0.18317308f, -0.09721656f, -0.22627474f, 0.00168965f, 0.13900653f, 0.01533057f, 
    -0.00485136f, 0.13697650f, 0.06359221f, -0.05115873f, 0.03991144f, -0.05039111f, -0.00661639f, -0.04732946f, 
    0.07472669f, -0.00855276f, 0.00533173f, 0.13545868f, 0.16550602f, 0.24681984f, 0.28202602f, 0.01268498f, 
    -0.07538173f, 0.00942210f, 0.08315287f, 0.14598721f, 0.08646639f, 0.11373717f, 0.12464396f, -0.04217993f, 
    0.03765655f, 0.02139011f, 0.02724456f, 0.00814887f, 0.00347855f, -0.03225666f, -0.06500849f, -0.00845515f, 
    0.17268984f, -0.10485215f, -0.05440221f, 0.14507593f, -0.20579509f, -0.18718968f, -0.10754900f, -0.13945058f, 
    -0.08976076f, -0.18113363f, 0.03051054f, -0.06203848f, 0.10983304f, 0.01646812f, 0.07536687f, 0.05406863f, 
    0.07298769f, 0.06168996f, -0.01672644f, -0.04634612f, 0.28975752f, -0.35372150f, -0.15177879f, -0.16833170f, 
    0.15336846f, -0.06212153f, -0.01690915f, -0.00251149f, -0.02999201f, -0.01874707f, -0.02292842f, 0.05603861f, 
    -0.06742227f, 0.02527044f, 0.04011951f, 0.03208639f, 0.06702059f, 0.22700089f, 0.06542148f, 0.05514621f, 
    -0.23992050f, 0.01955673f, -0.21014448f, -0.03074449f, 0.20829274f, 0.12297811f, 0.15814814f, -0.16970143f, 
    -0.08675233f, 0.07392284f, 0.07494858f, -0.08072085f, 0.07458059f, 0.04436472f, 0.18715557f, 0.07497542f, 
    0.01670194f, -0.06022163f, 0.02544452f, 0.06753946f, 0.22276293f, -0.11058601f, -0.50666773f, 0.02957498f, 
    0.18164544f, -0.06893426f, 0.05747150f, 0.02514446f, -0.03460316f, -0.01704061f, 0.02869760f, -0.08054293f, 
    -0.13136575f, -0.00443848f, -0.00065024f, 0.12911849f, 0.14920145f, 0.38944671f, 0.00670454f, 0.22113824f, 
    -0.16153474f, -0.19252858f, -0.14848565f, 0.07570598f, 0.27948684f, -0.00474892f, -0.15926756f, -0.06837549f, 
    0.12329814f, 0.09381145f, -0.02353423f, 0.07818914f, 0.10728984f, 0.02853903f, 0.02959789f, 0.13825577f, 
    0.12330249f, 0.09025703f, 0.21495537f, 0.15821351f, -0.14358495f, -0.03025473f, -0.29415119f, 0.26495913f, 
    -0.07288247f, -0.02979294f, -0.03356872f, -0.10520457f, 0.08319725f, -0.00824719f, 0.00057324f, -0.01849084f, 
    0.13425435f, -0.01544133f, 0.00008548f, 0.12671715f, -0.04170804f, -0.04589903f, -0.19760752f, -0.01198008f, 
    0.50088394f, 0.22330950f, -0.03242210f, 0.04359693f, -0.18351628f, -0.00071272f, 0.19869833f, 0.12342883f, 
    -0.02628770f, 0.08282556f, -0.05818861f, -0.14052051f, -0.09619566f, -0.01664360f, -0.07278030f, -0.07233364f, 
    0.11275848f, -0.06550877f, -0.04469400f, 0.09760004f, -0.07559498f, 0.17298317f, 0.09272971f, -0.09595942f, 
    0.11077869f, 0.03703690f, 0.06012601f, -0.02623609f, 0.03145269f, -0.14835611f, 0.10449860f, 0.23035704f, 
    0.05786312f, 0.07842300f, 0.14119378f, 0.03745174f, -0.05163451f, -0.11490529f, -0.12774037f, -0.10912859f, 
    -0.01055490f, -0.03881337f, -0.06742631f, 0.09053922f, -0.11324286f, -0.02413360f, 0.03983942f, 0.09596829f, 
    0.10815540f, -0.04238259f, -0.16284621f, 0.06050862f, 0.17222077f, 0.11463434f, -0.08806772f, 0.19982296f, 
    0.10459454f, 0.01605725f, -0.19915365f, -0.04316941f, -0.13006076f, 0.16259784f, 0.48358735f, 0.30735791f, 
    0.02227810f, 0.12413558f, -0.05499078f, -0.27940300f, -0.08847915f, 0.05925438f, 0.01116885f, -0.08291887f, 
    0.17853795f, 0.07117836f, 0.08612234f, 0.09803016f, 0.08855460f, -0.01258439f, 0.08312628f, 0.12560551f, 
    -0.16919662f, 0.03330648f, -0.14714462f, 0.12758003f, 0.00828291f, -0.00400606f, 0.02372677f, -0.01537910f, 
    -0.03233917f, -0.02651506f, -0.05209971f, -0.11149198f, 0.20045432f, 0.14806080f, -0.06653532f, 0.16568784f, 
    0.07887009f, 0.05600673f, -0.05509067f, 0.16992299f, -0.32056242f, -0.12763111f, 0.54719794f, 0.18050261f, 
    -0.30004394f, -0.04274508f, 0.08248679f, -0.15589960f, 0.31459591f, -0.20747101f, -0.15958682f, 0.03535944f, 
    0.20507395f, 0.13305579f, 0.13304344f, 0.09222848f, 0.03696493f, -0.00879918f, -0.03014488f, 0.14571695f, 
    -0.07008445f, -0.10332003f, 0.14588276f, 0.14496626f, 0.00756581f, 0.01101231f, 0.05865474f, 0.07393739f, 
    0.12316225f, 0.04230758f, -0.02584381f, 0.02387154f, -0.04282449f, -0.07228340f, 0.02048183f, 0.01510400f, 
    -0.03131844f, -0.00147857f, 0.08102196f, 0.08136640f, -0.08340096f, -0.09895150f, 0.30135262f, 0.02948607f, 
    0.06305397f, 0.16458677f, -0.06397837f, 0.03056478f, 0.16256520f, 0.09318106f, 0.06231050f, 0.03440383f, 
    0.10979424f, -0.10337894f, 0.05845206f, 0.04134485f, -0.09537055f, -0.01406416f, -0.01436100f, -0.26175451f, 
    -0.37322196f, -0.15620601f, -0.00483359f, 0.25456455f, -0.04228561f, -0.20256932f, 0.01493116f, -0.25154218f, 
    0.02486534f, -0.08613372f, 0.03440681f, 0.10815857f, 0.22399583f, 0.11556683f, 0.01760179f, 0.18497832f, 
    0.19414991f, 0.18250261f, -0.04009148f, 0.09908400f, -0.23564681f, -0.21117216f, 0.02966579f, 0.30686906f, 
    -0.07121991f, -0.10092367f, -0.21070801f, -0.01803033f, -0.13136245f, 0.17206545f, 0.04709509f, 0.03686355f, 
    0.11772332f, -0.05905579f, -0.09295454f, 0.09263074f, 0.11783928f, 0.09150083f, 0.06134510f, -0.06386477f, 
    -0.19534531f, 0.10528640f, 0.28498697f, 0.27127531f, -0.02261053f, -0.03480950f, -0.18696451f, -0.29926229f, 
    -0.18960236f, 0.03744490f, 0.04686520f, -0.05283935f, 0.08851396f, -0.03195507f, 0.11857152f, -0.05667907f, 
    -0.08665621f, -0.10363570f, -0.14595856f, -0.10135680f, 0.15056342f, -0.15384679f, -0.18606964f, -0.24652453f, 
    -0.13347621f, -0.16105838f, -0.04731438f, 0.08678287f, 0.06686836f, -0.04340816f, -0.25340378f, 0.10829131f, 
    0.03943676f, -0.04309013f, -0.04935931f, 0.17066935f, 0.10208926f, 0.11730792f, -0.12214696f, 0.01494089f, 
    0.34516019f, 0.35993478f, -0.04885757f, -0.09839533f, 0.04485321f, 0.06183930f, 0.18086094f, 0.03753617f, 
    -0.03049438f, -0.06745859f, 0.02093297f, 0.14797799f, 0.04555329f, -0.01816596f, -0.04560824f, 0.16959196f, 
    0.00165605f, 0.01093566f, 0.17272402f, 0.09389477f, -0.25468156f, 0.29734853f, 0.31669283f, -0.22018284f, 
    -0.10293419f, 0.03698725f, -0.15514603f, -0.16352993f, -0.07552665f, 0.10630266f, 0.07845229f, -0.06467383f, 
    -0.05579749f, 0.30468524f, -0.02051811f, 0.26176476f, 0.09858223f, -0.05728211f, -0.05696152f, -0.10117551f, 
    -0.03195693f, -0.42264915f, -0.12186904f, -0.04150112f, -0.14168198f, 0.03784691f, 0.00123514f, 0.13818152f, 
    -0.03742586f, -0.00811660f, -0.05466086f, 0.02788940f, 0.03683396f, 0.02141239f, -0.03336817f, 0.07336312f, 
    0.13116203f, 0.11880614f, 0.01676991f, 0.19716461f, 0.38473123f, -0.14253132f, -0.34828779f, 0.20442423f, 
    -0.14697044f, 0.02860374f, -0.01004934f, -0.12461805f, 0.06086032f, -0.16423669f, -0.00068495f, 0.12870437f, 
    0.08408312f, -0.13221847f, 0.02634794f, -0.06228168f, 0.25971591f, -0.02832722f, -0.02031862f, 0.15706350f, 
    -0.39716694f, 0.21965308f, 0.34356967f, -0.10894745f, -0.23385856f, 0.04055477f, -0.10938370f, -0.24828085f, 
    -0.05767549f, -0.07771672f, -0.12060941f, -0.10469434f, -0.00931867f, 0.06974978f, -0.04162596f, 0.03638118f, 
    0.04024080f, -0.07196951f, -0.17658228f, -0.15437494f, -0.25385442f, 0.14886643f, -0.00534757f, -0.06726805f, 
    -0.13262637f, -0.10825028f, 0.08997066f, 0.08217690f, 0.00744418f, -0.18471265f, 0.02229664f, -0.06174232f, 
    0.05332804f, -0.00339816f, -0.05426877f, 0.00662283f, -0.06982692f, -0.06447200f, 0.05486819f, 0.11326349f, 
    -0.49624830f, -0.04707060f, 0.14522845f, -0.14773406f, -0.04646797f, -0.23702650f, -0.04631660f, -0.11137793f, 
    -0.12600519f, -0.13054284f, -0.13463779f, -0.03083573f, 0.05738189f, 0.12687828f, -0.07399315f, -0.07509800f, 
    -0.03766089f, -0.05306642f, 0.01274387f, -0.12211530f, 0.31970406f, 0.28602687f, -0.04648739f, 0.31950438f, 
    0.02380677f, 0.12521721f, 0.02190814f, -0.03568195f, 0.11351579f, -0.06049037f, -0.02494118f, -0.05011053f, 
    0.11985488f, 0.13534229f, 0.11944935f, 0.02241672f, -0.08277325f, 0.03448126f, -0.09047038f, 0.00883540f, 
    -0.08169492f, 0.07600681f, 0.16575095f, -0.08896513f, -0.03643714f, -0.06607240f, 0.10163649f, -0.09481604f, 
    0.02271906f, -0.20335788f, -0.01496587f, -0.03926210f, 0.19487806f, 0.05663791f, 0.21260075f, 0.02484450f, 
    -0.05314528f, 0.00568858f, -0.08039762f, -0.07979931f, -0.02850920f, 0.06440574f, 0.23081943f, -0.06631127f, 
    0.16726653f, 0.27142635f, 0.02002821f, 0.19687472f, -0.06166663f, 0.13115577f, 0.00029003f, 0.33238965f, 
    0.24323824f, 0.21809216f, 0.16140537f, 0.12621221f, 0.01547160f, 0.13031916f, 0.07347687f, 0.14642748f, 
    -0.15983167f, -0.06138127f, 0.16729562f, -0.28581396f, 0.21144910f, 0.20839810f, -0.01364983f, 0.13023284f, 
    0.04015583f, 0.03072242f, -0.09107289f, 0.08623216f, 0.16607445f, 0.04350354f, 0.00621712f, 0.02195898f, 
    0.05369833f, -0.03308228f, 0.18548693f, 0.17698348f, -0.05122130f, -0.42936459f, -0.35108012f, 0.02304695f, 
    -0.00567257f, 0.07166672f, -0.07790365f, 0.10965671f, 0.04390122f, -0.02589656f, -0.07225960f, 0.06099163f, 
    -0.07209699f, -0.19785859f, -0.10949118f, 0.01683478f, 0.00551305f, 0.04524385f, 0.06284259f, 0.20189670f, 
    -0.25539812f, -0.31061938f, -0.20319337f, -0.19787468f, -0.12660146f, -0.02719949f, -0.19304752f, 0.09001359f, 
    0.11470719f, 0.16266178f, -0.09679924f, -0.18847229f, -0.02388960f, 0.05101456f, 0.14568336f, 0.03129131f, 
    0.10721657f, 0.04472680f, 0.13530298f, -0.02606724f, -0.07149789f, -0.25628862f, -0.08315104f, -0.02096242f, 
    -0.10411193f, 0.11264494f, -0.04682326f, 0.07439113f, 0.20025553f, 0.09636270f, -0.02063816f, -0.13675073f, 
    -0.07399245f, 0.07190920f, 0.11410856f, 0.00914676f, 0.01508995f, 0.13821860f, 0.10623504f, 0.18083623f, 
    0.14433959f, -0.01768998f, -0.14984193f, 0.13202694f, 0.10757121f, 0.15746817f, 0.00324525f, -0.07002048f, 
    0.15584847f, -0.00011678f, 0.06750330f, 0.01623771f, -0.07607368f, -0.06201599f, -0.02891527f, -0.01999435f, 
    -0.15332489f, -0.06625831f, 0.04377102f, -0.01725566f, -0.34881675f, 0.03533935f, 0.06372066f, 0.02814435f, 
    0.00916372f, -0.03509722f, -0.12283518f, 0.03311761f, -0.16631401f, 0.02725093f, -0.16605036f, 0.09815161f, 
    0.00967027f, -0.09176391f, -0.07201315f, -0.06276459f, -0.09026895f, -0.04617377f, -0.05414149f, -0.00206716f, 
    0.30625433f, 0.38841525f, 0.01360438f, -0.25174463f, -0.00859179f, -0.04391284f, 0.04214534f, -0.10916279f, 
    -0.03757478f, -0.11727796f, -0.16765103f, 0.07081287f, 0.05294280f, -0.06595609f, 0.00644255f, -0.00542912f, 
    0.00615431f, -0.19034570f, 0.09252516f, 0.02024629f, -0.27291107f, 0.27536267f, 0.22316006f, -0.12751070f, 
    -0.16235942f, 0.08766062f, -0.03035631f, -0.13434063f, 0.10432978f, -0.05785343f, -0.00355145f, -0.05496505f, 
    -0.13919409f, 0.11634149f, -0.05845684f, -0.00535136f, 0.12574221f, 0.15289982f, -0.09955406f, -0.04962504f, 
    0.07843923f, -0.20442413f, -0.08643482f, -0.00248807f, 0.20219497f, 0.00187191f, 0.00361321f, -0.03852864f, 
    -0.06348095f, 0.11887179f, -0.10319492f, -0.04723432f, 0.03331170f, -0.11173221f, -0.01940097f, -0.02795368f, 
    0.06995266f, 0.05534987f, -0.03573464f, 0.01245872f, 0.31634924f, 0.05829785f, -0.20920202f, 0.17030343f, 
    0.04701910f, -0.00038001f, 0.06095907f, -0.21542725f, 0.10917417f, 0.02339761f, 0.11981063f, 0.02538940f, 
    -0.07363402f, 0.00536733f, -0.11158688f, -0.02971508f, -0.04045488f, 0.12100641f, -0.19205099f, -0.01675305f, 
    -0.28674248f, 0.42148703f, 0.87472755f, -0.23480621f, -0.16482574f, -0.09279151f, -0.09351254f, -0.31858799f, 
    0.34302151f, -0.19794902f, 0.02438158f, -0.06081067f, 0.04050449f, 0.01832471f, 0.03752169f, -0.03253012f, 
    0.00022971f, -0.03650771f, -0.01572875f, 0.00763701f, -0.06742351f, 0.20298114f, 0.07418005f, -0.01954894f, 
    -0.15036215f, -0.19300418f, -0.04827695f, 0.11420893f, -0.04051476f, -0.19400090f, 0.03184859f, -0.03193533f, 
    0.04416627f, 0.02009697f, -0.04387181f, -0.02384176f, 0.03029262f, -0.15063457f, 0.01429670f, 0.04787498f, 
    -0.19208893f, 0.05072257f, 0.13864873f, -0.06540835f, -0.06058905f, -0.17593336f, -0.00705920f, -0.00582348f, 
    -0.09456383f, -0.12395639f, -0.12209336f, 0.05919916f, 0.07328147f, 0.11778154f, -0.06177937f, -0.07551119f, 
    0.04405356f, 0.08221553f, -0.00254763f, -0.10597099f, 0.59016877f, 0.44834894f, -0.18346618f, 0.06139120f, 
    0.05392358f, 0.05445866f, 0.20688838f, 0.09393604f, 0.04075686f, -0.10741999f, 0.00811406f, -0.08714351f, 
    0.17708294f, 0.06006157f, 0.14570412f, 0.03844570f, 0.03498884f, 0.01562686f, -0.01560579f, -0.05559026f, 
    -0.14244953f, 0.00947621f, 0.11797266f, -0.16766141f, -0.07802284f, -0.02910783f, 0.02065775f, 0.09722423f, 
    0.04520733f, -0.21110752f, 0.15712927f, -0.02802749f, 0.08401661f, 0.13360079f, 0.04868891f, -0.01564463f, 
    -0.05755189f, -0.06271719f, -0.09202917f, -0.05893404f, 0.06647664f, 0.26372823f, 0.02077698f, 0.12937787f, 
    0.02730302f, 0.11576908f, 0.05480974f, 0.23000354f, -0.34368449f, 0.01756578f, -0.10783394f, 0.12728196f, 
    -0.04404141f, 0.04000010f, 0.01797955f, 0.02392837f, 0.10639092f, 0.12059034f, -0.16352215f, -0.01378154f, 
    -0.15387079f, 0.10591298f, -0.30453932f, -0.20034155f, 0.06007704f, 0.06529073f, 0.00294365f, 0.02263781f, 
    0.17255493f, 0.13742182f, 0.01587186f, 0.17061795f, 0.03187284f, -0.02208095f, -0.01869945f, 0.03394586f, 
    0.02370632f, -0.06411204f, 0.16821499f, 0.02699501f, 0.04088342f, -0.25841439f, -0.35317561f, 0.00413241f, 
    -0.02713975f, 0.04540501f, -0.04335568f, 0.18488604f, 0.05828725f, 0.15161745f, 0.00492367f, 0.12813890f, 
    -0.01333636f, 0.03528744f, -0.03584033f, -0.04510086f, -0.13030931f, 0.04790659f, 0.10076433f, 0.11921477f, 
    0.24744216f, 0.14087820f, -0.26980451f, -0.06137309f, 0.08074795f, 0.13432449f, 0.05688039f, 0.29953676f, 
    0.06845988f, 0.17172500f, -0.03049615f, -0.02565772f, -0.05469650f, 0.08725239f, 0.06838930f, 0.03813826f, 
    0.01020338f, -0.10464821f, 0.00442866f, 0.14298640f, 0.27389434f, -0.02209528f, -0.23004459f, -0.15922226f, 
    0.03296417f, 0.13954583f, 0.03423647f, 0.07454004f, -0.00811010f, -0.05614923f, -0.06482622f, -0.10092895f, 
    -0.06313454f, 0.00628585f, -0.00527828f, -0.07514154f, -0.02384347f, 0.12800175f, 0.06222759f, 0.03028772f, 
    -0.02787946f, -0.08810596f, -0.36114180f, -0.15908103f, 0.14675097f, 0.15066843f, 0.09819933f, 0.13127837f, 
    0.04388594f, -0.13242266f, 0.01619574f, 0.04209699f, -0.04580499f, -0.06532686f, 0.03561050f, 0.04257638f, 
    0.04177236f, 0.02940395f, 0.07617343f, -0.04965383f, -0.19849618f, -0.02701819f, 0.16923848f, 0.23032257f, 
    0.05479664f, -0.00312313f, -0.00571392f, 0.15424904f, -0.00960908f, -0.09349132f, -0.08130179f, -0.10411760f, 
    0.06800941f, -0.05946050f, -0.09465221f, 0.10282096f, 0.08007018f, -0.03656910f, -0.16340138f, -0.04324595f, 
    -0.08154655f, 0.02319246f, 0.06100773f, 0.04737088f, 0.20309196f, -0.02206906f, 0.03447498f, 0.19839905f, 
    0.07824565f, 0.16963702f, 0.05848560f, 0.09640214f, 0.14404832f, 0.19579504f, -0.44481316f, -0.05156972f, 
    -0.18296047f, -0.01253923f, -0.06210518f, -0.01734629f, -0.10627595f, -0.26905501f, -0.72377682f, -0.21654768f, 
    -0.06890602f, -0.04193701f, 0.00238859f, 0.02424617f, 0.12912990f, 0.07420006f, -0.09360790f, 0.06093920f, 
    -0.12661169f, 0.03492861f, 0.10095292f, -0.02400923f, -0.08997987f, 0.15258391f, -0.03563945f, 0.05975666f, 
    -0.09717243f, 0.19271052f, 0.05500851f, -0.05371421f, -0.40434152f, -0.04540583f, 0.00522696f, -0.07570149f, 
    -0.06471666f, -0.05299963f, 0.00619340f, -0.00134349f, 0.05761093f, 0.06045321f, -0.03695336f, -0.03417140f, 
    -0.01180096f, 0.08151032f, 0.44846642f, 0.32116753f, 0.05434813f, 0.30023724f, 0.11643718f, 0.17506070f, 
    0.01108816f, -0.22216633f, -0.12901540f, 0.02244616f, -0.05141490f, -0.10287056f, 0.15127394f, -0.15329657f, 
    0.12481951f, 0.03486444f, -0.09349918f, -0.05739710f, 0.00952796f, 0.00299566f, -0.23565297f, -0.25071833f, 
    0.20099911f, -0.06125534f, 0.44178692f, -0.31016004f, -0.47363111f, 0.07929242f, 0.13815407f, -0.10956601f, 
    0.13863949f, 0.01021738f, -0.07244385f, -0.03131337f, 0.07343537f, -0.00319276f, -0.04707086f, 0.05280051f, 
    0.08681333f, -0.09284577f, 0.00003423f, -0.02201632f, -0.01004010f, 0.09190744f, -0.02528578f, 0.01057328f, 
    0.09524358f, -0.06289571f, 0.10286829f, 0.12380854f, 0.12501447f, 0.09321083f, -0.03979165f, 0.01299053f, 
    0.03719131f, -0.04221319f, 0.07217321f, 0.00506374f, -0.00729042f, 0.03437948f, -0.06026303f, 0.02157966f, 
    -0.26747185f, 0.11544711f, -0.03675039f, 0.01890179f, -0.09851453f, -0.07260133f, 0.02765892f, 0.14224648f, 
    0.06027926f, 0.09314080f, -0.26828885f, -0.13674617f, -0.13207969f, 0.15506092f, 0.15034629f, -0.04267204f, 
    -0.07160717f, 0.11514393f, -0.01052105f, -0.05454538f, -0.46599552f, -0.44858021f, 0.10581208f, 0.13467495f, 
    0.14776811f, -0.10131507f, 0.18617634f, 0.20092064f, -0.02416140f, -0.00529258f, 0.23309073f, -0.01013399f, 
    0.08230951f, -0.04514273f, 0.16723204f, 0.09981428f, 0.16018948f, 0.12965354f, 0.07201551f, 0.06806684f, 
    -0.31533712f, -0.15489012f, -0.44869024f, -0.01780433f, 0.00089206f, -0.02494188f, -0.11398318f, 0.05757092f, 
    -0.05851934f, 0.07330860f, 0.09541969f, 0.13596624f, -0.10588431f, 0.24297993f, 0.09405404f, 0.01320303f, 
    0.15074725f, 0.15922470f, 0.11074463f, 0.02158429f, 0.53300136f, -0.06618496f, -0.06444655f, 0.11164042f, 
    -0.02909648f, -0.08889832f, 0.13630052f, 0.15812291f, 0.01612166f, 0.32310948f, 0.11609463f, -0.04799038f, 
    0.27036721f, -0.01219435f, -0.01422861f, 0.01144569f, 0.12884231f, 0.03469889f, 0.11406019f, -0.04918025f, 
    -0.01245501f, -0.15022585f, -0.16236170f, 0.05125460f, 0.23663265f, -0.06654285f, 0.07437550f, -0.49584830f, 
    0.16988747f, -0.13325028f, 0.10909716f, 0.10990631f, 0.09555320f, -0.08449784f, 0.04313622f, 0.01181694f, 
    -0.02513457f, -0.18417788f, 0.09859172f, -0.21206982f, 0.27819729f, 0.10140800f, 0.05809203f, 0.00642407f, 
    0.27513152f, -0.13279964f, 0.12588689f, -0.01433943f, -0.04565875f, -0.08432034f, -0.00681233f, 0.12818566f, 
    -0.04601901f, 0.03026265f, 0.08274175f, -0.10262828f, 0.02233382f, 0.04900701f, -0.08686555f, -0.01805038f, 
    0.31965455f, -0.26793987f, 0.19365592f, -0.03808153f, -0.23573244f, 0.12609357f, 0.05298300f, 0.24463487f, 
    0.07313347f, -0.06541737f, 0.06138593f, -0.17299382f, -0.13597521f, -0.01943143f, 0.03432310f, -0.11242295f, 
    0.03080534f, -0.44750461f, 0.10976598f, 0.05389198f, 0.25598541f, 0.07525443f, 0.13277341f, -0.00210633f, 
    -0.13027686f, 0.01606414f, -0.04304540f, 0.07335925f, -0.00997532f, -0.08989969f, 0.05062727f, -0.06350813f, 
    -0.06472468f, -0.10591319f, -0.00786013f, 0.03775621f, 0.05399869f, 0.12536278f, -0.04046663f, 0.10469969f, 
    0.24795395f, 0.07995135f, 0.07846630f, 0.23880769f, 0.06740789f, -0.08605585f, 0.08674568f, 0.28094080f, 
    0.02747065f, 0.07575102f, 0.01393964f, -0.16367447f, 0.08739644f, -0.05071911f, 0.05057464f, -0.05499398f, 
    -0.08174070f, 0.04545428f, -0.05171244f, -0.08785954f, -0.07981750f, -0.09569200f, -0.08451223f, -0.13125184f, 
    -0.09716871f, -0.08019362f, -0.01051297f, 0.00594113f, 0.03906149f, 0.10076612f, -0.20329808f, -0.01133781f, 
    -0.00049528f, -0.04911155f, -0.02323228f, -0.04412787f, -0.03094848f, -0.09286088f, 0.27833048f, 0.04835443f, 
    -0.16350441f, 0.05782899f, -0.01476017f, 0.10983027f, -0.22943969f, -0.10213668f, -0.15097077f, 0.09454694f, 
    -0.12662862f, -0.28137684f, 0.13178796f, -0.05639818f, 0.08037610f, -0.02037230f, -0.01352875f, -0.07416303f, 
    -0.19236487f, -0.27652627f, -0.11140561f, -0.28264919f, -0.12959713f, 0.05848444f, 0.03632239f, -0.03480722f, 
    -0.00179822f, 0.10220988f, 0.10377879f, 0.19538714f, -0.20531614f, -0.02277038f, 0.00728394f, -0.16784479f, 
    0.05782677f, -0.18825319f, -0.01682807f, 0.28112546f, 0.17406191f, 0.16437055f, -0.10596722f, 0.11367872f, 
    0.27261895f, 0.25711539f, 0.22544876f, -0.07199311f, 0.24990137f, -0.06446236f, 0.19000793f, 0.10472567f, 
    0.18731983f, 0.28252503f, 0.05349789f, 0.00593095f, -0.02056739f, -0.13614726f, -0.06613706f, 0.08920906f, 
    0.24273261f, 0.28518566f, 0.06684154f, 0.30994195f, 0.20531155f, -0.37537712f, 0.22853597f, -0.01087646f, 
    0.12989922f, -0.07905024f, 0.03692457f, 0.10347449f, -0.16003723f, -0.01668184f, 0.24675998f, 0.14751393f, 
    -0.02335364f, 0.10651226f, 0.00158056f, -0.01527619f, -0.12977597f, -0.25193137f, -0.34076840f, -0.07501565f, 
    -0.20715153f, 0.28554150f, -0.35442841f, 0.46805951f, 0.15429029f, 0.11647238f, 0.34496897f, 0.20979676f, 
    -0.26725823f, -0.00385832f, 0.16308098f, -0.22806010f, -0.07098679f, -0.25229800f, 0.03572769f, 0.05291436f, 
    0.04358206f, -0.01972919f, 0.11674085f, -0.07379946f, -0.13319647f, 0.26246995f, -0.08100408f, -0.00229334f, 
    0.10356217f, 0.11713008f, -0.34849802f, -0.24334465f, -0.25647062f, -0.57489550f, 0.10916470f, -0.06498378f, 
    -0.06062821f, 0.06541923f, 0.07464149f, -0.15325318f, -0.14752328f, -0.15163286f, -0.22410053f, -0.35820520f, 
    -0.07013695f, -0.14912793f, 0.18598171f, -0.27185309f, 0.15353841f, 0.08832949f, -0.11194198f, 0.01776358f, 
    -0.25541997f, -0.08970762f, 0.08538593f, -0.05462655f, 0.03858793f, 0.01222372f, 0.12389038f, 0.13852575f, 
    -0.20910260f, -0.10012404f, -0.04911045f, -0.26226956f, 0.33436832f, 0.08830767f, -0.03713097f, 0.32393667f, 
    0.12878415f, 0.05169512f, -0.06966504f, -0.12929174f, -0.06875709f, -0.12860782f, 0.09736308f, -0.03713189f, 
    0.14541182f, 0.13175201f, 0.03537311f, 0.02908973f, 0.26211935f, 0.07749815f, 0.20113651f, 0.17001028f, 
    -0.02142201f, 0.24048518f, 0.12002586f, -0.01950024f, 0.11335420f, -0.17085166f, -0.01564516f, -0.14876035f, 
    -0.03276974f, -0.22124371f, -0.06168666f, -0.01341719f, -0.07114374f, -0.01211150f, 0.08590827f, 0.11372305f, 
    0.13012758f, 0.13651775f, -0.02940396f, 0.34128252f, -0.17137976f, -0.34455952f, 0.03466267f, -0.23912300f, 
    0.03745622f, 0.20854399f, -0.23072182f, 0.20606120f, -0.04388100f, -0.22573869f, -0.02820867f, 0.19055749f, 
    -0.07600286f, 0.08923750f, 0.05430775f, 0.05488424f, -0.02995715f, 0.03755173f, 0.07279249f, 0.03932267f, 
    0.27816683f, 0.50689042f, 0.19053826f, -0.28044903f, -0.10553344f, 0.02912923f, -0.12781800f, 0.05563974f, 
    -0.16460711f, 0.06164526f, 0.05829978f, 0.09575028f, -0.03004331f, -0.16944003f, 0.01215684f, -0.22325219f, 
    -0.18115512f, -0.20920293f, -0.18313369f, -0.33666641f, 0.36949250f, 0.27990240f, 0.40284905f, -0.12613392f, 
    -0.15485057f, -0.09925987f, -0.12644151f, 0.01841983f, 0.08096264f, 0.02807928f, -0.00721431f, 0.19399434f, 
    0.01572778f, -0.11991394f, 0.10110055f, -0.09384094f, -0.42260230f, -0.37919500f, -0.18120331f, -0.49944052f, 
    0.24065773f, -0.02184444f, -0.14626178f, -0.11260976f, 0.07376403f, 0.03860319f, 0.33716562f, 0.03433870f, 
    0.00447417f, 0.19640087f, -0.02437546f, 0.03090069f, 0.04209366f, 0.09677770f, 0.07561295f, -0.06419910f, 
    0.28539503f, 0.27130166f, 0.10278000f, 0.22924449f, 0.31496719f, 0.01916972f, 0.02338260f, -0.07588205f, 
    -0.00271059f, 0.01660864f, 0.14149532f, 0.04120727f, -0.05132524f, 0.14517209f, 0.13371027f, 0.05251948f, 
    -0.11953230f, 0.07339804f, -0.03062344f, -0.02806677f, -0.08629040f, 0.00439298f, 0.13463292f, 0.00393765f, 
    0.27289826f, 0.32910219f, 0.16348734f, 0.19096999f, 0.14016455f, 0.00796516f, -0.22186154f, -0.08488130f, 
    -0.07001656f, -0.37214857f, 0.04704196f, 0.03322073f, -0.01564922f, 0.06399557f, 0.08733329f, -0.01439965f, 
    -0.15395266f, -0.05489954f, -0.10185780f, -0.20068352f, -0.22489549f, -0.01205930f, -0.04928467f, -0.05487781f, 
    0.02352560f, 0.28241271f, -0.25542292f, 0.15616515f, 0.12603585f, -0.13081348f, 0.04180634f, 0.16659282f, 
    0.00674911f, 0.19429687f, -0.00007224f, -0.02197685f, 0.30182827f, 0.18204507f, 0.10571966f, 0.16918828f, 
    -0.34758270f, -0.12808470f, -0.32925761f, -0.06488119f, -0.17354013f, 0.01642919f, -0.00598690f, -0.02046960f, 
    -0.02230536f, -0.03703129f, 0.08048239f, 0.04678267f, 0.16780055f, -0.13333587f, 0.05251882f, 0.04543199f, 
    -0.00520006f, -0.28964433f, -0.21087784f, 0.03222074f, -0.06512779f, -0.16685036f, -0.57739693f, -0.28787664f, 
    -0.20077284f, 0.05780295f, 0.02609766f, 0.01252899f, 0.00332052f, -0.11308023f, -0.04689141f, 0.08699924f, 
    0.02849267f, -0.04710327f, -0.03059469f, -0.00158562f, 0.07831112f, 0.22415581f, -0.16520637f, -0.00950564f, 
    -0.04733770f, 0.27430505f, 0.27014092f, 0.12701821f, 0.27565646f, -0.13730024f, 0.00738675f, -0.13746166f, 
    0.08307400f, 0.17050931f, -0.00909591f, -0.04994799f, 0.02507328f, 0.02231752f, 0.18735437f, -0.15771239f, 
    0.03426709f, 0.14044409f, 0.08387742f, 0.13389175f, -0.07415089f, 0.08050940f, 0.16482621f, 0.05502039f, 
    0.05079840f, -0.31093663f, -0.00836844f, 0.00761503f, -0.07424427f, 0.02337006f, 0.11967485f, 0.10393816f, 
    0.00023367f, 0.04680019f, -0.12478574f, 0.11585406f, -0.14721942f, -0.09515777f, -0.31254160f, -0.08457386f, 
    0.22367887f, 0.23631279f, -0.06601565f, 0.22230768f, -0.06646846f, -0.05825781f, 0.19938144f, -0.21812312f, 
    0.15504979f, 0.06879521f, 0.18918006f, 0.01332991f, 0.09088816f, 0.02122631f, 0.08492835f, -0.21343958f, 
    0.10918824f, -0.10064931f, 0.01407934f, 0.05778008f, -0.20936084f, -0.15513775f, -0.33687475f, -0.16992395f, 
    -0.03895070f, 0.11043879f, 0.01480879f, 0.09854928f, -0.05376307f, -0.09512030f, 0.05581419f, 0.16559210f, 
    0.11410029f, 0.00505544f, 0.02930521f, 0.09511211f, 0.03625430f, -0.13158801f, -0.21465051f, -0.19463064f, 
    -0.10447595f, -0.36989847f, -0.30279517f, -0.30095312f, -0.15747595f, 0.05588207f, 0.07873315f, 0.25939289f, 
    -0.05359120f, -0.07527513f, 0.07536645f, 0.08139674f, 0.10629442f, 0.16721463f, -0.09072798f, 0.25465336f, 
    0.09205964f, 0.13421218f, -0.16656004f, -0.14957836f, 0.28551811f, -0.00822247f, 0.16085684f, 0.06195502f, 
    -0.03937997f, 0.11124020f, 0.16782475f, 0.14146255f, 0.06744932f, 0.11906931f, -0.06795565f, 0.00706160f, 
    0.10468333f, 0.08095106f, 0.15785894f, 0.07458692f, 0.11924031f, -0.10491113f, 0.11886635f, 0.12240338f, 
    -0.22378466f, -0.10154059f, -0.31408349f, -0.31191000f, -0.20672108f, -0.02022891f, -0.02221969f, 0.11069979f, 
    0.04443923f, 0.07865740f, -0.01862331f, 0.13788936f, 0.06822488f, 0.07885507f, -0.09954080f, 0.07499341f, 
    0.08329336f, -0.09310259f, 0.03469147f, 0.09986074f, 0.06909390f, -0.18797766f, 0.02074853f, -0.07851858f, 
    -0.19593504f, -0.01461288f, 0.04661911f, 0.09277286f, -0.04791183f, -0.14682175f, -0.14621504f, -0.06154809f, 
    -0.03014847f, 0.08894932f, -0.01927959f, -0.10041030f, 0.03314532f, -0.05925877f, -0.13579905f, 0.10875976f, 
    0.15846780f, 0.31575826f, -0.06212367f, -0.09985589f, -0.24337949f, 0.07966220f, 0.19627053f, -0.00237156f, 
    0.08397193f, 0.07650943f, 0.06540687f, 0.03530050f, -0.04607948f, -0.10572435f, 0.03864179f, -0.11805171f, 
    -0.08324460f, -0.16806729f, -0.07046941f, -0.28697932f, 0.25024992f, 0.22824617f, 0.24855486f, 0.11733965f, 
    0.17631280f, 0.15082477f, 0.18271264f, 0.11626999f, 0.01908422f, 0.08543031f, 0.20710699f, 0.14768814f, 
    0.02943852f, 0.04089943f, 0.05497693f, 0.06053898f, -0.13637318f, -0.09698801f, -0.07569077f, -0.18723008f, 
    0.44220808f, 0.16737385f, 0.25357848f, 0.16055615f, 0.05461585f, 0.07872300f, 0.22033194f, 0.08865696f, 
    -0.06860191f, 0.17155655f, 0.10653692f, -0.04823713f, -0.00919123f, 0.12260009f, 0.13444781f, 0.01259735f, 
    0.09368016f, 0.07233279f, 0.09751626f, 0.26233953f, 0.39947158f, 0.14427356f, 0.16024528f, 0.25742927f, 
    0.12871081f, -0.03246203f, -0.01833541f, -0.00872765f, -0.09007387f, 0.04674103f, 0.08722004f, -0.01332690f, 
    -0.05418902f, 0.02092888f, 0.05351554f, 0.03196006f, -0.00970280f, 0.05179012f, 0.06198631f, 0.07263030f, 
    -0.03895533f, 0.10856389f, -0.13623469f, 0.19102074f, 0.09223051f, 0.02967265f, 0.02104580f, 0.21627793f, 
    -0.03831161f, -0.12082158f, -0.11822450f, -0.08955222f, 0.00218547f, 0.07348950f, 0.11535756f, 0.08166986f, 
    0.00953155f, -0.03235161f, -0.15472826f, -0.18081288f, 0.13844965f, -0.23055968f, -0.62370175f, -0.43248630f, 
    -0.31738472f, 0.06419375f, -0.03713161f, 0.15954825f, 0.00163777f, 0.00363042f, 0.06474862f, 0.07880549f, 
    0.04238166f, 0.01304913f, -0.02162772f, -0.01241113f, 0.19273642f, 0.17009176f, -0.03678603f, 0.10486346f, 
    -0.15430629f, -0.07829492f, 0.06959582f, 0.11099471f, 0.21925478f, -0.09845722f, 0.02554216f, -0.03673755f, 
    0.01170161f, 0.11263505f, 0.17920502f, -0.15306033f, 0.15755603f, 0.07487765f, -0.00624887f, -0.12030031f, 
    -0.04024309f, 0.01222438f, 0.06680533f, 0.07193711f, 0.17124759f, 0.01183968f, -0.05687198f, -0.08064216f, 
    0.08882286f, 0.00527527f, -0.05036794f, 0.03093024f, -0.00510797f, -0.02091782f, -0.00646409f, 0.00361767f, 
    -0.00742532f, 0.00819025f, 0.02785922f, -0.00794012f, 0.11167206f, -0.16376992f, 0.25319615f, -0.02656882f, 
    -0.18353374f, -0.05051874f, -0.12125611f, -0.17168891f, -0.23229289f, -0.06001485f, -0.02611913f, -0.22088045f, 
    -0.03114350f, -0.03665166f, -0.02241968f, 0.05908895f, 0.10366082f, -0.05554381f, 0.01198039f, -0.05549737f, 
    -0.04183627f, 0.08120233f, -0.01493419f, 0.06733382f, 0.11246299f, -0.12872012f, -0.04518956f, -0.09950683f, 
    -0.04264379f, -0.04345217f, 0.31145701f, 0.08042488f, -0.07270192f, 0.18251556f, -0.08324271f, -0.01647159f, 
    -0.07036677f, 0.04437564f, -0.02247244f, 0.16291958f, -0.08246587f, -0.02257438f, -0.23180446f, -0.14684229f, 
    0.16052060f, -0.02888318f, -0.16077560f, -0.02024740f, 0.22260275f, -0.22793649f, -0.03937114f, 0.02173907f, 
    -0.11865532f, 0.00514098f, -0.03553546f, -0.06625209f, -0.05150486f, 0.02332544f, -0.01595328f, 0.39610112f, 
    0.13388047f, -0.22938059f, 0.10061372f, -0.22382189f, 0.04303868f, -0.02918299f, 0.02063985f, 0.08295583f, 
    0.21901280f, 0.04180440f, -0.17297760f, 0.00577154f, -0.05416038f, 0.03362996f, 0.12353440f, 0.07481679f, 
    -0.06932265f, -0.01364504f, -0.08408862f, 0.02082764f, -0.06366986f, -0.04725331f, -0.00247323f, 0.08224645f, 
    0.18098116f, -0.02669112f, 0.06488713f, -0.00745338f, 0.09937555f, -0.03364686f, -0.03023265f, -0.07230887f, 
    0.00332399f, -0.00037380f, -0.08656923f, 0.01161595f, 0.03730809f, -0.04977776f, 0.04031822f, -0.01300050f, 
    -0.19111288f, -0.07243869f, 0.00649312f, -0.02374863f, -0.51904917f, -0.00908819f, 0.37162021f, 0.26931402f, 
    0.12489218f, -0.11196953f, -0.10508171f, -0.11079674f, -0.01255076f, 0.09720299f, 0.12461676f, -0.13465396f, 
    0.06726913f, 0.11956831f, 0.06660672f, 0.12776549f, 0.05513077f, 0.02456214f, 0.08281831f, 0.03154571f, 
    0.14568469f, 0.02787448f, -0.00905569f, -0.02323199f, 0.11732607f, -0.00206497f, 0.08673559f, -0.11762441f, 
    0.04432849f, 0.06036923f, 0.02837847f, 0.03785484f, 0.19355144f, -0.00461494f, 0.01216193f, 0.03534935f, 
    -0.12148046f, 0.00746473f, 0.03388620f, 0.08986941f, 0.33046812f, 0.43897381f, 0.03675007f, -0.12276366f, 
    -0.07518557f, 0.10020136f, -0.06119942f, -0.08870310f, 0.12305146f, 0.01503641f, 0.11941625f, 0.05706114f, 
    0.19157512f, -0.16305557f, -0.13899130f, 0.03401396f, 0.18498640f, -0.00436805f, -0.02280199f, 0.13864984f, 
    0.10541812f, 0.18006110f, 0.08117182f, -0.41411832f, -0.42828146f, 0.20858116f, 0.04597780f, 0.12855750f, 
    -0.05568195f, -0.16089858f, -0.03184493f, 0.09150263f, -0.05187344f, 0.03232815f, 0.02568837f, 0.08029775f, 
    -0.08548580f, -0.04902839f, 0.11578388f, -0.04224500f, -0.08088111f, 0.23624150f, 0.18013375f, -0.11630356f, 
    -0.14050417f, 0.02382033f, 0.29700756f, 0.06531820f, -0.03710805f, 0.12757054f, -0.01424070f, -0.16609734f, 
    0.00793417f, 0.08065429f, 0.07709354f, 0.06893132f, 0.00857544f, 0.05229019f, -0.01000106f, 0.06983560f, 
    0.08085305f, -0.43144870f, -0.10147423f, -0.16221207f, -0.40907454f, 0.09574238f, -0.26632705f, -0.47592747f, 
    0.19175701f, -0.07781290f, -0.01001262f, -0.00536238f, 0.11304559f, -0.04605263f, -0.17274253f, -0.16832870f, 
    0.07006208f, -0.23863839f, -0.10833406f, -0.08514497f, -0.32245204f, -0.17667203f, -0.05686574f, -0.09271984f, 
    -0.39906466f, -0.04463764f, -0.05089783f, -0.12020360f, -0.02795621f, 0.14883268f, -0.01937996f, -0.04613347f, 
    -0.02884332f, -0.01379926f, -0.00449289f, -0.02689103f, 0.05110430f, 0.09572461f, -0.20517749f, -0.10483545f, 
    -0.30390111f, 0.09352271f, 0.25748080f, 0.08704238f, 0.10721728f, 0.01685065f, -0.12944178f, -0.05710145f, 
    -0.03596576f, -0.01612330f, -0.20016971f, -0.05662167f, 0.09700751f, 0.18447924f, 0.05251247f, -0.00440145f, 
    -0.01918978f, 0.06867134f, 0.01005497f, 0.08597089f, 0.22894225f, 0.07370662f, 0.06989540f, -0.06491563f, 
    0.09311440f, -0.00299987f, -0.12144621f, -0.00877176f, 0.02901170f, 0.03429911f, 0.04275216f, 0.11923742f, 
    -0.05259674f, 0.04636464f, -0.00380116f, -0.08197370f, -0.02252324f, -0.09286329f, 0.13690707f, 0.19252296f, 
    -0.12115961f, 0.00095620f, -0.16474631f, 0.07470900f, 0.17969227f, 0.08868244f, 0.06351202f, -0.20995648f, 
    0.03596097f, 0.14261033f, 0.28994653f, 0.01115049f, 0.08392739f, 0.12109662f, 0.07228705f, 0.11130587f, 
    0.06822086f, -0.07896242f, 0.04316388f, -0.01878547f, 0.48864955f, 0.12436410f, -0.08460514f, 0.08983091f, 
    0.31874171f, 0.11130977f, 0.04648156f, 0.04016308f, 0.00257162f, -0.00211193f, 0.05125222f, 0.03349813f, 
    -0.03185772f, 0.01797069f, 0.09177358f, -0.02653598f, -0.11491603f, -0.25352472f, 0.02675857f, -0.06918645f, 
    -0.13529721f, 0.09362815f, 0.22445120f, 0.08476275f, -0.30990273f, 0.07174088f, -0.05721869f, -0.03019640f, 
    -0.01911299f, 0.04552529f, -0.02884576f, -0.01124744f, 0.00541129f, 0.14826317f, 0.00850369f, 0.06052615f, 
    0.02421551f, -0.05816440f, 0.00809803f, 0.01274803f, 0.03522193f, -0.14658462f, 0.12562868f, -0.32178512f, 
    -0.13214208f, -0.12783782f, 0.00526922f, -0.25357375f, 0.17112149f, 0.24736625f, -0.01377349f, 0.01321074f, 
    0.03819780f, -0.02419724f, -0.05330513f, -0.03583565f, -0.11961585f, -0.10865594f, 0.17728035f, 0.03731285f, 
    0.03920412f, 0.04179234f, -0.28191000f, 0.17420128f, 0.20643756f, 0.11214072f, 0.13736935f, 0.22246425f, 
    -0.01407206f, 0.22494158f, 0.02342876f, -0.10231847f, 0.01242215f, -0.06622902f, -0.01732521f, -0.00260317f, 
    -0.02278422f, -0.03525368f, -0.12489444f, -0.11836728f, 0.17713030f, 0.08704844f, -0.07780798f, 0.01726966f, 
    0.13138622f, 0.05899087f, -0.04966727f, 0.03580511f, 0.02871050f, -0.01408353f, 0.14441493f, 0.15452585f, 
    0.05603965f, 0.15552589f, 0.02905531f, 0.05398732f, -0.04232742f, 0.00881876f, -0.00378750f, 0.07019310f, 
    0.20089652f, 0.12876680f, 0.06284737f, -0.10918107f, 0.19603266f, 0.06918077f, -0.05979433f, 0.04696046f, 
    -0.11467952f, -0.02820339f, 0.20022084f, 0.16443318f, -0.01171074f, 0.00341298f, 0.07802419f, -0.02722963f, 
    -0.02813444f, -0.01752068f, -0.06832211f, -0.00200859f, -0.63359785f, 0.00235196f, 0.26732323f, 0.12759589f, 
    0.05139346f, -0.20621376f, -0.22055902f, -0.02945395f, 0.03649558f, 0.20771337f, 0.25905272f, 0.03078377f, 
    -0.07630701f, -0.03975034f, 0.12920769f, 0.05235091f, -0.04748501f, -0.00861468f, -0.05495598f, 0.06723469f, 
    0.41091818f, 0.23212002f, 0.24278551f, -0.07076494f, 0.34236920f, -0.06435344f, 0.08954049f, -0.08315013f, 
    0.01839392f, 0.07064027f, -0.03103690f, -0.06797557f, 0.10576614f, -0.04456708f, -0.05027593f, -0.11437728f, 
    0.02955180f, 0.01015658f, -0.02267367f, -0.01441804f, 0.41687045f, -0.01693239f, -0.02313213f, -0.21826144f, 
    0.04729686f, -0.02568318f, 0.01512284f, -0.05510336f, 0.21417490f, 0.16941330f, 0.47232440f, 0.01669187f, 
    0.22306243f, 0.03115016f, -0.02517018f, -0.14106692f, -0.06564447f, -0.07598872f, 0.06600007f, 0.04429337f, 
    -0.01481682f, -0.16409822f, 0.22895998f, -0.39188012f, -0.14881730f, 0.02690526f, -0.22621648f, 0.22814465f, 
    -0.01379024f, -0.20666777f, 0.12333546f, 0.10884713f, 0.02542796f, 0.05844285f, 0.04418487f, -0.08683314f, 
    -0.01958371f, 0.09113791f, -0.00306304f, -0.07522558f, -0.12919146f, 0.12576430f, 0.19546118f, 0.02682455f, 
    -0.10334401f, -0.05609326f, -0.11530431f, -0.26584455f, -0.03655196f, -0.00900619f, -0.00011857f, 0.04403042f, 
    -0.00389990f, 0.02825514f, 0.01017216f, -0.04510927f, 0.04825155f, -0.03680540f, 0.00185306f, 0.03851191f, 
    -0.16376068f, -0.23500007f, 0.39000896f, 0.09237465f, -0.12705016f, -0.08207976f, -0.11889996f, -0.19165386f, 
    0.13115168f, -0.20884512f, 0.02617312f, -0.05623168f, 0.02913943f, 0.03444271f, -0.01890662f, -0.08664846f, 
    0.02641151f, 0.20991933f, 0.12822478f, -0.10164813f, -0.09926510f, -0.01344268f, 0.33957851f, 0.34441197f, 
    -0.09957347f, -0.03587956f, -0.02632577f, 0.04107036f, 0.15058693f, 0.02450947f, 0.05615943f, 0.00201409f, 
    0.14566793f, 0.05562969f, 0.03149994f, -0.04386142f, 0.04449272f, 0.04091256f, 0.16895358f, 0.05840032f, 
    -0.20544179f, -0.03131758f, 0.01220737f, 0.05078636f, -0.00392821f, -0.18352817f, -0.09467211f, -0.11808049f, 
    0.13780734f, -0.11936975f, 0.11761373f, 0.08871341f, 0.02496166f, 0.07157065f, -0.04858928f, -0.02544065f, 
    -0.12561050f, -0.01394370f, -0.05606760f, -0.01757181f, 0.39258790f, 0.19076836f, 0.21999557f, -0.13781153f, 
    0.32629198f, 0.02633849f, -0.06641082f, 0.06943870f, -0.11390086f, 0.07295468f, 0.02226300f, 0.00789242f, 
    0.01814439f, 0.13040870f, 0.01751256f, -0.29203480f, -0.03570811f, 0.06218437f, -0.10263067f, -0.01287143f, 
    0.03907358f, 0.01161685f, 0.04288602f, -0.01355254f, -0.00345148f, -0.04096678f, -0.01981336f, -0.00407913f, 
    -0.05098997f, -0.05916370f, 0.03299293f, 0.01844458f, -0.03082910f, -0.03874506f, 0.01143234f, -0.03544917f, 
    0.01430738f, -0.02662490f, 0.01019177f, -0.01953606f, -0.02069859f, 0.00347857f, 0.02300891f, -0.04999831f, 
    0.01380119f, 0.01116060f, 0.02145507f, -0.04738115f, -0.00810239f, -0.04997690f, -0.02133787f, -0.05595009f, 
    0.03787683f, 0.02868811f, -0.04879424f, 0.01774257f, 0.00146318f, -0.03876847f, 0.01326299f, 0.04165357f, 
    0.03419574f, 0.03343256f, 0.02848419f, 0.00438703f, 0.00548992f, 0.00436029f, -0.03734902f, 0.04736817f, 
    -0.04162528f, -0.04877169f, -0.02509855f, 0.02671192f, 0.00631385f, -0.05434561f, -0.06008095f, 0.03399517f, 
    -0.02645342f, 0.03768475f, 0.00620906f, -0.00669080f, 0.02874929f, 0.02883912f, 0.00182347f, -0.04748799f, 
    -0.02093353f, 0.03374897f, 0.02332255f, 0.03580768f, -0.01018105f, -0.03973845f, 0.01158045f, 0.00759548f, 
    -0.00061700f, 0.01262661f, -0.01789005f, 0.00805152f, 0.03758592f, -0.06478491f, -0.05242551f, -0.03412258f, 
    0.03620895f, 0.05001176f, -0.00412669f, 0.00962743f, -0.01309055f, -0.02253806f, 0.03254637f, 0.04349696f, 
    -0.02056111f, 0.03723692f, -0.05112218f, -0.00284162f, -0.04615607f, 0.02915146f, -0.05770386f, -0.01334204f, 
    -0.03185364f, -0.03607985f, 0.03847772f, -0.04088453f, 0.03447317f, 0.02532780f, -0.03070484f, -0.05226562f, 
    -0.03273017f, 0.02849985f, -0.06151866f, 0.01914273f, -0.02035620f, -0.04534194f, 0.04382944f, 0.04430257f, 
    -0.02519688f, -0.00494932f, -0.03270468f, -0.01838226f, -0.00217339f, -0.04419263f, -0.04507138f, -0.04507904f, 
    -0.04071249f, -0.04051851f, 0.03958645f, -0.01062620f, -0.00771651f, 0.04099073f, -0.00015611f, -0.01266801f, 
    0.00205761f, -0.05197244f, 0.00798249f, -0.03305105f, 0.04253282f, 0.03174841f, -0.00670313f, -0.02433092f, 
    -0.00384096f, 0.03558170f, 0.04951628f, -0.00469887f, -0.04326997f, 0.04632757f, 0.01008815f, -0.02803645f, 
    -0.05027891f, -0.02750493f, 0.02301832f, 0.01730727f, -0.02428818f, -0.01726854f, -0.04280039f, -0.03962056f, 
    0.03182721f, -0.05028201f, -0.05755813f, -0.03213254f, -0.04651875f, -0.02284862f, -0.02732625f, -0.02674798f, 
    0.01524273f, -0.04864662f, -0.03719962f, 0.00877848f, 0.03009972f, 0.02821575f, -0.03389305f, -0.03694190f, 
    -0.02183523f, -0.04772281f, 0.00072567f, 0.04918082f, -0.05249491f, 0.01691580f, -0.05714599f, -0.01785709f, 
    -0.00118112f, -0.03610696f, -0.02689852f, 0.03760487f, 0.05031588f, -0.02981717f, -0.04667697f, 0.02893294f, 
    0.01396547f, -0.04974831f, 0.01430464f, -0.00926500f, -0.03140451f, 0.03573972f, -0.04458052f, -0.02808559f, 
    -0.04642559f, 0.03214885f, -0.01672699f, 0.00830845f, -0.05395208f, -0.05449532f, 0.02668607f, 0.00388499f, 
    0.02997685f, -0.03415007f, 0.02332746f, -0.02214984f, -0.05899085f, -0.05222088f, -0.01139172f, 0.00095727f, 
    -0.05527588f, 0.04416697f, 0.00855523f, -0.04857159f, -0.05276120f, 0.04723246f, 0.02098496f, 0.03056136f, 
    0.03529363f, 0.04496866f, 0.03903383f, 0.02508662f, -0.02985227f, -0.01860594f, 0.02092678f, -0.03741437f, 
    0.01170969f, 0.04905674f, -0.04216180f, -0.02266710f, 0.02156588f, -0.04262176f, 0.01443808f, -0.02000916f, 
    0.03902561f, 0.05336525f, 0.00045586f, 0.01601928f, 0.04139757f, 0.00487897f, -0.04279639f, -0.02716840f, 
    -0.05040944f, -0.04120646f, 0.02241835f, -0.04418803f, 0.03501346f, 0.00228375f, 0.01636556f, -0.00421148f, 
    -0.03592813f, -0.01099887f, -0.03492167f, -0.03275168f, -0.04091595f, 0.00996820f, -0.00124916f, 0.02659002f, 
    -0.04972353f, -0.03172082f, -0.01132422f, -0.00926676f, 0.02115771f, -0.03940623f, -0.03112024f, -0.00436417f, 
    0.04176725f, -0.05558011f, 0.02096275f, -0.02756330f, -0.01026572f, 0.03238040f, 0.03629563f, 0.00600358f, 
    -0.05750381f, -0.03097211f, 0.03383312f, -0.04735838f, -0.04272866f, 0.03355913f, -0.02502589f, 0.00214318f, 
    0.01916119f, 0.01774773f, -0.00543843f, -0.00928388f, -0.01386004f, 0.02672073f, 0.03008215f, 0.00614216f, 
    0.04081992f, -0.05574504f, -0.05512143f, -0.04494691f, -0.05558653f, 0.04820950f, 0.02153240f, 0.03890268f, 
    -0.03177413f, 0.00595625f, -0.04214733f, 0.01877585f, 0.02930992f, 0.06106843f, -0.04743985f, 0.01764023f, 
    0.03907952f, 0.03085216f, 0.02275202f, 0.00339722f, -0.05376553f, -0.01414804f, 0.00993563f, -0.03322449f, 
    -0.05728531f, 0.02734026f, -0.01386128f, 0.00242469f, -0.01413198f, 0.03337278f, 0.00622739f, -0.05796588f, 
    -0.06320158f, -0.04684001f, -0.01692289f, 0.06809865f, -0.05919455f, 0.05879794f, -0.02504297f, -0.12541457f, 
    -0.03806217f, 0.03688138f, 0.05508145f, -0.04337311f, 0.07169853f, -0.05321537f, 0.16889550f, 0.10790980f, 
    0.11360460f, -0.01981154f, -0.10561268f, 0.01890318f, -0.09106921f, 0.01343068f, 0.15707423f, 0.38030016f, 
    0.11515724f, 0.01269495f, 0.01250467f, -0.07740603f, -0.02711979f, 0.04517150f, 0.11013033f, 0.06089995f, 
    -0.02970929f, 0.01706661f, -0.10129163f, 0.09393004f, -0.03831042f, -0.16092911f, -0.06955939f, 0.02842658f, 
    0.03704937f, -0.04885908f, 0.10675567f, 0.22434391f, 0.15451916f, -0.01201451f, 0.12709309f, 0.13648178f, 
    0.24946873f, -0.16530293f, 0.12921938f, -0.05686696f, 0.05171589f, 0.13733777f, -0.06161182f, 0.12488077f, 
    0.09344123f, 0.02172210f, -0.04574598f, -0.01659187f, 0.16319533f, 0.06889787f, 0.02836437f, -0.06511163f, 
    -0.02145875f, 0.05150442f, 0.01920006f, -0.03772134f, -0.15977120f, -0.08513280f, -0.07195803f, 0.12883970f, 
    -0.00740982f, -0.12345539f, 0.14276834f, 0.05864892f, 0.03228275f, -0.00782197f, 0.19785517f, 0.30989414f, 
    0.05279819f, -0.13048464f, -0.03163994f, 0.16268700f, 0.45670897f, 0.06211684f, 0.00070861f, 0.16647252f, 
    0.05475357f, -0.00433440f, 0.03261040f, 0.03159941f, -0.08045733f, -0.10166795f, 0.00761054f, -0.09123515f, 
    0.00080228f, 0.24146493f, -0.19731294f, 0.04406115f, -0.02118048f, -0.07801466f, -0.12345643f, -0.06186404f, 
    -0.04573905f, 0.06318151f, 0.06947952f, -0.02908400f, -0.02371193f, 0.09025513f, -0.03790931f, 0.01727496f, 
    0.08168833f, 0.05201558f, 0.17752124f, 0.02921496f, 0.07127599f, 0.05830998f, -0.03673346f, -0.01305110f, 
    -0.08533705f, 0.01086494f, -0.15684576f, 0.06543810f, -0.06629248f, 0.10375376f, 0.03317576f, 0.05938194f, 
    -0.09238379f, 0.03998226f, 0.13663328f, -0.02712919f, -0.07439847f, 0.00676830f, -0.01229332f, 0.05012955f, 
    0.16144219f, 0.03559849f, -0.10569429f, -0.01135471f, -0.34591326f, -0.04767957f, -0.02695979f, -0.26420021f, 
    0.17149733f, -0.07157821f, -0.07850085f, -0.02659945f, 0.14395307f, 0.04512033f, -0.13121848f, 0.11021942f, 
    -0.07638559f, 0.12404691f, -0.04793678f, -0.13046938f, -0.13891698f, 0.06328605f, -0.01148920f, -0.04925510f, 
    0.05134615f, 0.12133513f, 0.09005213f, -0.01863060f, -0.10984854f, 0.11189709f, -0.01163105f, -0.01126913f, 
    -0.03844430f, 0.03570544f, 0.02513399f, -0.02292604f, 0.06478242f, 0.09325268f, -0.05342183f, -0.16804472f, 
    0.04556278f, 0.07507607f, 0.02661598f, 0.02776190f, -0.36138311f, -0.03270866f, 0.02341627f, -0.14577375f, 
    0.42485672f, -0.00809675f, 0.13218892f, -0.16506530f, 0.26633915f, -0.01723295f, 0.16005939f, -0.00415665f, 
    -0.05716829f, 0.04153971f, -0.02121073f, -0.05211907f, -0.05665470f, 0.01921166f, 0.11675911f, -0.02332245f, 
    0.11027971f, -0.07709271f, 0.08952131f, 0.31231445f, 0.28365216f, 0.01910863f, 0.13030489f, 0.06008325f, 
    -0.03149375f, 0.06697524f, -0.06348712f, -0.00854120f, -0.02537158f, -0.06823255f, -0.00146836f, -0.05556519f, 
    0.00877923f, 0.12058523f, -0.00602239f, 0.04902271f, 0.09481513f, 0.05534081f, 0.08806480f, 0.11318515f, 
    0.14403048f, 0.03320598f, 0.01327626f, -0.13301100f, -0.11279887f, -0.02035127f, -0.00940176f, -0.00804204f, 
    -0.05319341f, -0.09960029f, -0.00496862f, -0.07977195f, 0.04542495f, -0.05217926f, 0.07117506f, -0.00369311f, 
    -0.52117521f, 0.04614167f, 0.03312724f, 0.11290643f, 0.26451308f, -0.15803495f, -0.02113561f, -0.14977619f, 
    -0.15352274f, -0.05843940f, -0.07002110f, 0.11745004f, 0.06336083f, 0.10834717f, 0.10515391f, 0.10326598f, 
    0.05480727f, 0.59749526f, 0.00400068f, -0.14444527f, -0.12217693f, -0.05644847f, 0.09618549f, 0.12893334f, 
    0.15317489f, -0.00876468f, 0.09641669f, 0.10892379f, 0.01139833f, -0.00473373f, -0.06056529f, 0.05389505f, 
    0.02277875f, 0.11161385f, 0.03096765f, 0.05650720f, -0.04945109f, -0.00352299f, 0.29277679f, 0.17023347f, 
    -0.25304967f, 0.03629031f, 0.09761377f, -0.05225602f, 0.12396959f, 0.01080817f, -0.01311650f, -0.05450938f, 
    0.03012146f, 0.24266697f, 0.15212947f, 0.11998425f, -0.19650796f, -0.15470403f, 0.00232298f, 0.06481436f, 
    -0.00452631f, -0.00670488f, -0.04510603f, -0.00792832f, -0.21615343f, 0.09071978f, 0.11515597f, -0.11648075f, 
    0.02140531f, 0.01336968f, 0.02723833f, -0.15855940f, -0.03766519f, 0.00247528f, 0.18560588f, -0.14549261f, 
    0.00096916f, -0.00480214f, 0.00917497f, -0.03040955f, -0.01252392f, 0.04107142f, -0.20149066f, -0.04995650f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02879788f, 0.06669946f, -0.00257393f, -0.05497175f, 0.00264145f, 0.07071093f, 0.13809434f, 0.16960211f, 
    -0.05836122f, 0.09109824f, 0.08187414f, -0.07779862f, 0.14517722f, -0.02173976f, -0.06390103f, 0.18486822f, 
    0.20311858f, -0.03294620f, -0.05475043f, 0.04444561f, 0.22248450f, -0.13105890f, 0.08626083f, 0.01835663f, 
    -0.01458785f, 0.02430539f, 0.01232558f, 0.01847340f, -0.02980943f, 0.16625296f, 0.27658948f, -0.05724584f, 
    0.17971170f, 0.04265450f, 0.06691701f, -0.00429674f, 0.10175042f, -0.05569123f, 0.03634768f, 0.02819135f, 
    0.01069715f, 0.16292581f, -0.00712745f, 0.02539764f, -0.12664643f, 0.01713710f, 0.03050106f, 0.20334558f, 
    0.12366187f, 0.15780230f, 0.22665811f, 0.03955349f, 0.09317739f, 0.12495194f, 0.15714593f, 0.12068782f, 
    -0.05369366f, -0.00320508f, -0.08328953f, -0.10940266f, 0.12552036f, 0.15522796f, -0.01187776f, 0.06902124f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09777243f, 0.04888964f, 0.00382429f, 0.02677900f, 0.05865616f, 0.20454000f, -0.40554070f, -0.36569530f, 
    0.01317707f, -0.15238795f, -0.48371187f, 0.23928365f, -0.54627228f, 0.04934066f, 0.14337963f, -0.18056831f, 
    -0.13068971f, -0.01392675f, 0.05950343f, -0.21182434f, -0.26056150f, 0.16090406f, 0.31496784f, 0.24209858f, 
    0.10469060f, -0.05948909f, -0.03831089f, 0.02845863f, -0.04789127f, -0.48724544f, -0.25423607f, -0.10302729f, 
    -0.06916431f, 0.02133692f, 0.21338105f, 0.06829780f, 0.05700311f, -0.12963684f, -0.00658639f, -0.16162223f, 
    -0.10768636f, -0.00155310f, 0.08324005f, 0.01096885f, 0.24535027f, -0.05710300f, 0.31072029f, -0.52412373f, 
    -0.21789511f, 0.03739445f, -0.31604576f, 0.28917611f, -0.32409745f, 0.23118676f, -0.41557398f, -0.30350515f, 
    0.04789672f, 0.18886741f, 0.30541939f, 0.10031470f, 0.13091169f, -0.21535935f, -0.07343676f, -0.12471817f, 
    0.03211404f, 0.04331329f, -0.05798993f, -0.05405883f, 0.00683671f, 0.14580914f, 0.20254222f, 0.00257047f, 
    -0.07236029f, -0.01608510f, 0.30002731f, 0.10683055f, -0.71597415f, -0.11907095f, 0.13860168f, -0.09698994f, 
    -0.05800140f, 0.01105481f, 0.15163942f, -0.10420857f, 0.12667432f, -0.54172331f, 0.20203052f, -0.06586607f, 
    -0.55968660f, 0.10459044f, 0.01304854f, -0.04813435f, -0.06907511f, -0.22505851f, 0.18815725f, 0.09223636f, 
    0.27582681f, 0.09910245f, 0.25163686f, -0.06372311f, 0.07968371f, -0.05215645f, 0.10430079f, 0.04548571f, 
    0.01491396f, 0.17377400f, 0.03496940f, 0.09074851f, 0.16172461f, -0.05298176f, 0.11370711f, 0.36386785f, 
    -0.10673844f, 0.03106720f, -0.12199413f, 0.04965077f, -0.68645811f, 0.22165199f, -0.17594585f, -0.48364052f, 
    -0.00473993f, 0.07823191f, -0.93822914f, 0.12313315f, 0.11070694f, 0.05597733f, 0.02413666f, -0.13999337f, 
    -0.09124979f, -0.05802437f, 0.05163366f, -0.10777114f, 0.01347969f, 0.34422064f, 0.22343434f, 0.18627405f, 
    -0.04119811f, -0.40302610f, 0.15862839f, -0.00696037f, -0.12060735f, 0.07859319f, 0.08443829f, 0.05704695f, 
    -0.03979127f, -0.05825268f, -0.00348657f, -0.05413981f, -0.01026974f, -0.17579380f, 0.18358073f, -0.08502560f, 
    0.37048563f, 0.07673769f, -0.09540535f, -0.04385071f, -0.00158793f, -0.19412860f, -0.28654212f, -0.05190933f, 
    0.28489134f, 0.40936774f, -0.15691626f, 0.24598894f, -0.43852064f, 0.04622919f, 0.22822848f, -0.17927508f, 
    0.01443900f, -0.03246787f, -0.43532339f, 0.03319027f, -0.38433179f, -0.09219719f, -0.40999445f, 0.10671909f, 
    0.16544846f, 0.25066784f, -0.04016069f, -0.45059922f, -0.03262829f, -0.21211694f, -0.15234342f, 0.35154986f, 
    0.07442480f, 0.20364599f, -0.22858946f, -0.24264732f, 0.07960168f, 0.20396005f, 0.05458765f, -0.12278088f, 
    -0.06104820f, -0.23002686f, -0.08335127f, -0.05441923f, -0.01371928f, 0.22963892f, -0.23817544f, 0.13905384f, 
    -0.08569177f, 0.24093099f, 0.05501769f, 0.10915735f, 0.08416071f, -0.07393207f, -0.06113177f, -0.15134910f, 
    -0.61645263f, 0.04976448f, 0.19645904f, 0.11959410f, -0.24419262f, 0.21559256f, 0.11130402f, -0.02400306f, 
    0.28413820f, -0.02324941f, 0.04479326f, -0.04577876f, 0.06598768f, 0.01977812f, -0.31026626f, 0.09990676f, 
    -0.39391366f, -0.10117660f, -0.31935459f, 0.28904828f, -0.04103425f, -0.04808931f, 0.01855483f, 0.07768653f, 
    0.10495155f, -0.06091381f, 0.40167445f, 0.02571980f, 0.16705513f, -0.07725599f, -0.38841727f, -0.25495225f, 
    0.16829401f, -0.06623455f, -0.22108488f, -0.44893870f, -0.00718733f, -0.26603609f, -0.08384226f, 0.08694547f, 
    0.33170381f, -0.39703867f, 0.11628941f, 0.07296310f, -0.45828027f, -0.53595173f, 0.06480383f, 0.01644692f, 
    -0.07436060f, -0.06919295f, -0.01390372f, 0.01109337f, 0.04295068f, -0.09721076f, 0.27117467f, -0.55251682f, 
    0.05925346f, 0.02201018f, -0.10973813f, 0.08174786f, 0.13005187f, 0.00053400f, 0.20905437f, -0.31930006f, 
    0.22412176f, 0.05959967f, 0.09060539f, -0.25599530f, -0.04788174f, 0.14175293f, -0.63431191f, 0.12340579f, 
    0.02253556f, 0.07937840f, 0.03412832f, -0.13564277f, -0.10528825f, -0.14769015f, -0.21508388f, 0.08775349f, 
    -0.22992243f, -0.52031374f, -0.17367777f, 0.05229680f, -0.09998750f, 0.07684440f, 0.15848145f, 0.21243635f, 
    0.02091546f, -0.12022782f, -0.31456053f, 0.04461320f, 0.10260369f, 0.04535146f, -0.15044013f, -0.17856158f, 
    0.16147237f, 0.06961263f, -0.21732120f, -0.12735792f, 0.07162904f, 0.13523309f, 0.08073588f, -0.71957326f, 
    -0.44396299f, -0.11832871f, 0.21998011f, 0.14796734f, 0.00138659f, 0.19970037f, 0.02059182f, 0.07853620f, 
    0.02231673f, 0.13343138f, 0.10355984f, 0.11604852f, -0.08566602f, 0.07397592f, -0.15651041f, -0.21511176f, 
    0.02856265f, 0.12137479f, -0.48628607f, 0.12816645f, 0.18248633f, -0.07863985f, -0.20909181f, -0.28788975f, 
    0.19417679f, -0.02804586f, -0.35454690f, 0.00552295f, 0.35480878f, -0.53394854f, 0.00693239f, 0.28534338f, 
    -0.02894908f, 0.07745138f, -0.00190512f, -0.13114126f, 0.08693425f, 0.07457523f, 0.16685346f, -0.00567723f, 
    0.02491216f, -0.51123035f, -0.13719478f, -0.28498083f, 0.11300381f, 0.03256312f, -0.36806935f, -0.45597905f, 
    -0.02585700f, 0.12125833f, -0.00734570f, -0.01174474f, -0.11733694f, -0.08017468f, 0.20718916f, 0.03193953f, 
    -0.06976337f, 0.15300941f, -0.06752356f, 0.19432795f, 0.25805897f, 0.21876925f, -0.22540157f, -0.06731012f, 
    -0.21359640f, -0.04340869f, -0.25277466f, -0.11826725f, -0.03646521f, 0.19577482f, -0.11301288f, 0.11423571f, 
    -0.05482376f, -0.15315723f, -0.01761195f, 0.00440374f, -0.00993203f, -0.16174477f, 0.02570511f, 0.38214105f, 
    0.03563794f, -0.35166129f, -0.22154528f, -0.44200963f, 0.13611926f, 0.07542720f, -0.13880470f, 0.33146778f, 
    -0.37499708f, 0.09447210f, -0.02470287f, 0.05615839f, -0.57150233f, 0.31770584f, 0.29896834f, -0.58340967f, 
    0.10719643f, -0.01647979f, -0.05717122f, 0.09331432f, 0.04198806f, -0.13124056f, 0.02221153f, 0.03412550f, 
    -0.26388606f, -0.11248754f, 0.26953155f, -0.49087441f, -0.41265363f, -0.06681103f, 0.25274676f, 0.08757358f, 
    -0.06880196f, -0.42257619f, 0.10748699f, -0.10349166f, -0.20825161f, -0.05624331f, -0.21677935f, -0.23433957f, 
    -0.04707476f, 0.09751942f, 0.22684729f, -0.15820904f, 0.23729278f, -0.45711154f, -0.00570673f, -0.14412574f, 
    -0.36514664f, -0.06818172f, -0.04886541f, -0.38747007f, 0.18130535f, 0.17337631f, 0.05673303f, 0.08448771f, 
    0.03755298f, -0.21223634f, 0.06893998f, -0.11037248f, -0.04246200f, -0.64417547f, -0.08503506f, 0.03755335f, 
    -0.07035218f, 0.23357818f, 0.02722044f, -0.06735689f, 0.11308207f, -0.10459933f, 0.26561385f, -0.33644363f, 
    -0.11296251f, 0.02259160f, 0.15970145f, -0.24127653f, 0.04261664f, 0.31666347f, -0.47895724f, -0.24047349f, 
    0.19443995f, 0.04297554f, -0.02765773f, -0.09002905f, 0.01823060f, 0.21881285f, -0.29496717f, 0.00961521f, 
    0.10933128f, 0.54934317f, -0.30327803f, -0.08590501f, -0.08686796f, 0.11845996f, -0.24178348f, -0.05966453f, 
    -0.10453698f, -0.28506351f, 0.06563210f, 0.03959297f, -0.18172640f, 0.05585273f, 0.08826292f, 0.12226227f, 
    -0.25708047f, -0.74975908f, 0.12579069f, 0.22499499f, -0.04060993f, -0.35539016f, -0.38381833f, 0.26195374f, 
    0.14469571f, -0.00627286f, 0.22018026f, -0.58143944f, -0.18135603f, -0.09191302f, 0.03416903f, -0.21880914f, 
    -0.09163810f, -0.07366180f, 0.00578687f, -0.10388066f, -0.01775689f, -0.73159510f, -0.01522086f, 0.32040760f, 
    0.01209042f, 0.15657111f, -0.02932215f, -0.38050503f, -0.07186034f, 0.09726586f, -0.42121318f, 0.00356782f, 
    -0.11500608f, -0.07155295f, -0.15369312f, 0.30725485f, 0.20388427f, -0.46024597f, 0.14526618f, 0.00880008f, 
    -0.28906399f, -0.05278749f, -0.02996440f, 0.06855994f, -0.11581883f, 0.10890173f, 0.06906388f, -0.02285208f, 
    0.11005703f, -0.00235364f, -0.24077772f, 0.29774502f, 0.20129116f, 0.06878038f, 0.06996551f, -0.43287227f, 
    -0.08650470f, 0.02101359f, 0.22166143f, -0.02509359f, -0.00332804f, -0.01141032f, 0.17594893f, -0.31737778f, 
    0.13029794f, -0.30853382f, 0.12116636f, 0.01007264f, -0.48783693f, -0.39899960f, -0.38041106f, 0.38903159f, 
    0.39129600f, 0.06475960f, -0.42837363f, -0.44039276f, -0.27840093f, -0.19842188f, 0.09460370f, 0.03430755f, 
    -0.01465912f, 0.02290144f, -0.07076978f, 0.03737426f, 0.07147200f, -0.35262129f, 0.39231038f, -0.19439597f, 
    -0.11652814f, -0.45761287f, -0.39029816f, -0.32282045f, 0.21248312f, -0.01734046f, 0.19161345f, 0.02168491f, 
    0.21016489f, 0.05637845f, -0.50879049f, -0.38945621f, -0.34093395f, 0.03939238f, -0.62527567f, 0.04791744f, 
    -0.16198306f, 0.00542168f, -0.07376046f, -0.03588250f, -0.01767653f, 0.12389842f, 0.04650827f, -0.01729691f, 
    0.02743491f, 0.14845084f, 0.22309019f, -0.37670687f, -0.07280017f, 0.03001771f, -0.45875591f, 0.28267550f, 
    -0.08972179f, 0.12056286f, -0.22485499f, 0.02164560f, -0.25127813f, -0.10092224f, -0.31020272f, -0.07449217f, 
    -0.01490967f, -0.02711339f, 0.07303228f, 0.15548961f, 0.05814227f, 0.41303560f, 0.31679773f, 0.12895027f, 
    -0.03466836f, -0.17543784f, 0.39875817f, 0.13615116f, 0.18515043f, 0.18501191f, -0.00903372f, -0.26470560f, 
    0.01610086f, 0.14460704f, -0.06923858f, 0.08886578f, -0.09838941f, -0.38442755f, -0.26340187f, -0.04543966f, 
    -0.10840639f, 0.01985247f, 0.20717265f, 0.10406173f, -0.23034346f, 0.09941837f, 0.11939515f, -0.13600920f, 
    -0.08424911f, 0.04652257f, 0.23734856f, -0.02072066f, -0.15401924f, -0.13924977f, 0.25565064f, -0.61395228f, 
    0.34209496f, -0.04336293f, 0.08637803f, 0.02809236f, 0.05250454f, 0.15459743f, -0.18676659f, 0.02701527f, 
    0.35288790f, -0.19273135f, 0.24537912f, -0.08230188f, 0.29386070f, 0.06823488f, 0.17945673f, -0.09860215f, 
    0.02094112f, 0.35273010f, 0.00403131f, 0.00409789f, -0.24463326f, -0.07121005f, -0.16079827f, -0.33381683f, 
    0.40157226f, 0.15781175f, 0.03830573f, 0.04724419f, -0.00800359f, -0.28126067f, -0.06851404f, -0.14317532f, 
    -0.46342158f, -0.54217178f, -0.52367383f, -0.60922271f, -0.29156178f, -0.34349933f, 0.10400480f, 0.05492371f, 
    0.10249841f, -0.28149304f, -0.05802180f, -0.08903330f, -0.08569616f, 0.31594610f, -0.53690660f, -0.09326392f, 
    -0.00315530f, -0.04657160f, 0.37453443f, -0.41241106f, 0.27509347f, -0.01578611f, 0.10026898f, 0.13992217f, 
    0.00236326f, 0.03000566f, 0.16962110f, 0.07711608f, -0.38635311f, -0.37572530f, 0.16444106f, -0.26409608f, 
    -0.55609840f, 0.06088032f, -0.02364565f, -0.05585033f, -0.02153352f, 0.26667443f, 0.26205212f, -0.03282999f, 
    0.09734979f, -0.54517186f, -0.16809672f, 0.09126413f, -0.10357624f, -0.00729812f, -0.02473170f, 0.45012727f, 
    -0.02993784f, -0.06552663f, -0.18908218f, 0.10284330f, -0.31067249f, -0.08566668f, 0.18325625f, 0.13857412f, 
    -0.35704422f, -0.52278888f, -0.02614696f, -0.44555792f, 0.26069474f, -0.20835170f, 0.41135010f, -0.03440569f, 
    0.11954804f, 0.21922116f, -0.41321418f, 0.06767093f, -0.37356666f, -0.35288024f, -0.06834415f, -0.02511358f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16794562f, 0.02882793f, -0.10892693f, -0.19711472f, 0.03493611f, 0.19588430f, 0.15507178f, -0.02486443f, 
    0.05701610f, -0.04381381f, -0.02440693f, 0.12307607f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
