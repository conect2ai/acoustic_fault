#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.54964697f, -0.99282438f, 0.87249839f, -0.27196294f, -0.08919821f, 0.38706288f, 0.22536714f, -0.12159509f, 
    -0.04615805f, 0.00614946f, 0.26201314f, -0.09631816f, 0.50167835f, 0.30255428f, 0.03554077f, -0.11919475f, 
    0.67425489f, -0.83103645f, 0.31690812f, -0.24441427f, -0.68623823f, -0.11762573f, 0.13575105f, 0.26707098f, 
    -0.34730017f, -0.33402029f, -0.24881564f, -0.63225013f, -0.01359169f, 0.87218559f, 0.11304443f, -0.39457011f, 
    0.34501028f, 0.00578780f, -0.08475158f, -0.28407520f, 0.58027625f, 0.42348391f, 0.49504706f, -0.09795401f, 
    0.16830124f, 0.19746637f, -0.14917991f, -0.28301629f, 0.66790074f, 0.15051465f, -0.13623928f, 0.47669417f, 
    -0.25378194f, 0.56881362f, -0.64483559f, 0.15855686f, 0.29242039f, 0.52022088f, 1.19326818f, -0.10280545f, 
    -0.07529104f, -0.48889211f, -0.22438259f, -0.28668371f, -0.09106011f, 0.09628271f, -0.04451709f, -0.38778347f, 
    -0.08246324f, -0.20371808f, 0.39536047f, 0.37954476f, 0.00284752f, 0.40640911f, 0.44211501f, -0.01457597f, 
    0.38088879f, 0.04463762f, -0.65641290f, -0.47776818f, 0.06485158f, -0.14322747f, 0.25885981f, 0.34665367f, 
    0.52442396f, -0.52669907f, -0.08983640f, -0.45975962f, -0.22780150f, -0.24719511f, -0.48190334f, -0.23951247f, 
    -0.21912356f, -0.09728312f, 0.64992738f, 0.15341006f, 0.54975927f, 0.06488417f, 0.28299925f, 0.43637097f, 
    0.36917394f, 0.13157555f, 0.01942107f, -0.45084339f, -0.17057733f, 0.69575745f, -0.33209077f, 0.23978941f, 
    0.28160048f, 0.00631579f, 0.15744963f, 0.32026437f, -1.03070605f, 0.59114307f, -0.05684757f, 0.71416599f, 
    0.11103512f, 0.38441613f, -0.02367613f, -0.17054680f, -0.13765198f, -0.05098518f, 0.30783233f, 0.40775958f, 
    0.02227976f, 0.21685204f, -0.01589962f, -0.48683923f, -0.52402729f, -0.19325072f, -0.57015812f, 0.12300534f, 
    -0.24511613f, -0.50897509f, -0.28940266f, -0.42885363f, 0.60584599f, 0.36809584f, -0.03330565f, 0.30551583f, 
    -0.80195856f, -0.04079538f, -0.35305533f, 0.46270132f, -0.43804488f, 0.09794465f, -0.45084125f, -0.25457844f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20723894f, -0.31810826f, 0.08752196f, -0.06983893f, -0.17177631f, -0.16519356f, 0.11822304f, 0.48348927f, 
    0.25059232f, -0.00681873f, -0.17450783f, 0.03399706f, -0.19209626f, 0.32818830f, -0.35014552f, 0.27734405f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.17734584f, -0.18687537f, -0.50973171f, 0.04088262f, 0.17783412f, -0.08641578f, -0.02114369f, -0.25426179f, 
    0.13485524f, -0.10247521f, -0.13240029f, -0.35506237f, 0.07899795f, -0.15236218f, 0.12023124f, 0.06925216f, 
    0.04436653f, 0.15237673f, 0.04260673f, 0.13790034f, -0.12268103f, -0.03820871f, -0.03870206f, 0.02291467f, 
    -0.10067609f, 0.05519755f, -0.04854520f, 0.22813521f, 0.31391516f, 0.20103309f, -0.10150874f, 0.07168422f, 
    0.09612635f, 0.11381320f, 0.05736843f, -0.05670724f, 0.12041228f, -0.24435934f, -0.56862581f, 0.07518379f, 
    0.22945952f, 0.05683543f, -0.00903573f, -0.07994220f, 0.02806423f, 0.04547414f, -0.19566739f, 0.10172682f, 
    -0.17184852f, -0.11580399f, 0.02593426f, -0.07977419f, -0.26085341f, -0.20653909f, -0.15015841f, 0.35832196f, 
    0.00811597f, 0.14119568f, -0.14343601f, -0.20448849f, 0.09218628f, 0.11350697f, 0.05396740f, -0.30688921f, 
    -0.12630184f, -0.11099730f, 0.16550829f, 0.10243718f, 0.11817973f, -0.00111386f, -0.02930857f, 0.17445648f, 
    -0.00721531f, 0.36411154f, 0.05213035f, 0.02585340f, 0.08000202f, 0.02639636f, -0.08843047f, -0.08804072f, 
    -0.24148467f, 0.18174934f, -0.04560763f, 0.25864309f, 0.05038569f, 0.01316580f, -0.05269055f, 0.06236542f, 
    -0.01983550f, -0.12512241f, 0.10911986f, -0.29082048f, -0.11177826f, -0.03930962f, -0.02987188f, -0.14723732f, 
    0.15594216f, 0.06682268f, 0.11498588f, -0.03016921f, -0.13468984f, -0.15109405f, 0.11513892f, -0.20383343f, 
    -0.06106578f, -0.05642499f, 0.12979259f, -0.20498675f, 0.24525960f, -0.10879332f, -0.30491337f, -0.14889884f, 
    -0.00717860f, -0.00253863f, 0.02493184f, 0.01872053f, 0.40863353f, 0.27798522f, -0.11300393f, 0.09557206f, 
    0.08054178f, 0.10087261f, 0.08354811f, 0.10347739f, -0.02038237f, 0.00404617f, 0.39565101f, 0.26621369f, 
    -0.06640769f, 0.09174833f, 0.09993088f, -0.00001452f, 0.02724984f, 0.11708015f, -0.32966349f, -0.17319287f, 
    0.37688282f, 0.01703399f, -0.06833231f, 0.08343209f, -0.06867484f, 0.03434879f, 0.07360310f, 0.11088945f, 
    0.33963281f, 0.11139422f, -0.24766913f, 0.01474596f, 0.21324503f, 0.20019831f, -0.06562226f, 0.15079315f, 
    -0.13651739f, -0.11811773f, 0.07396770f, 0.53435069f, 0.14205956f, -0.04948315f, -0.15572055f, -0.05350998f, 
    0.00974431f, -0.18374258f, -0.04773386f, 0.03118714f, -0.17268378f, 0.02091647f, -0.03892253f, -0.07935455f, 
    -0.04006712f, -0.00014357f, 0.05283293f, 0.17851411f, 0.07476104f, 0.08180764f, 0.08710513f, 0.00292713f, 
    -0.15594688f, 0.05802223f, 0.15093453f, 0.14203477f, -0.01234504f, 0.11946155f, 0.09035395f, -0.02945940f, 
    0.03937472f, 0.12246923f, -0.03402698f, -0.09712007f, -0.10167622f, -0.31811425f, 0.06444762f, 0.32814777f, 
    0.12198097f, -0.03122367f, -0.13896190f, 0.09355904f, -0.07873606f, 0.18757378f, 0.15858650f, -0.33896297f, 
    -0.16074558f, -0.02626324f, -0.01493511f, 0.10704151f, 0.17019014f, -0.01742891f, 0.24013503f, 0.13023332f, 
    0.06234801f, -0.02724127f, -0.15647428f, 0.07518128f, 0.01109781f, 0.19627753f, -0.04064138f, 0.01129333f, 
    -0.41462421f, -0.48546794f, -0.34205747f, 0.05359044f, 0.01628951f, 0.04649052f, -0.03384982f, -0.04922002f, 
    0.25534454f, 0.46087193f, 0.04065136f, -0.30881631f, -0.08375526f, -0.06390440f, -0.24618047f, -0.10516787f, 
    0.15527198f, 0.03151672f, 0.12942654f, 0.19126017f, 0.14643477f, -0.25274077f, 0.08671946f, -0.28999576f, 
    -0.03727551f, -0.04139715f, 0.13064992f, 0.06330455f, 0.30928326f, -0.26156825f, 0.09711064f, -0.09099425f, 
    0.06661829f, 0.10791744f, -0.02447090f, -0.04034038f, 0.44418725f, 0.09921448f, -0.04645490f, -0.28965852f, 
    -0.04674641f, 0.03125118f, 0.01074952f, -0.21744546f, -0.08490251f, 0.05037195f, 0.05032763f, 0.03899045f, 
    0.00389757f, 0.06145164f, -0.08837342f, -0.12255946f, 0.02132936f, 0.19498524f, 0.68620449f, -0.02588309f, 
    0.01179811f, -0.10532036f, -0.12446810f, 0.01925298f, 0.05630120f, -0.16843349f, -0.08118679f, -0.32443571f, 
    -0.23321141f, -0.25325662f, -0.07978811f, 0.23274863f, 0.07810339f, -0.11969937f, -0.03038615f, 0.04455494f, 
    0.03561914f, 0.25157803f, 0.35140455f, 0.07504073f, 0.28373370f, 0.10022907f, 0.04242601f, 0.06768247f, 
    -0.03948855f, -0.13478988f, -0.09827691f, -0.20790836f, -0.04282938f, 0.29092178f, -0.06014668f, 0.13340530f, 
    -0.15788038f, -0.14784580f, 0.15415274f, -0.30361021f, 0.04381486f, 0.02425230f, -0.10093118f, 0.17975673f, 
    -0.04373648f, 0.09777413f, -0.01032217f, -0.17757383f, 0.46832064f, -0.17460063f, 0.07347080f, 0.12930998f, 
    0.06083327f, 0.01109832f, 0.11077826f, -0.01981561f, 0.17916441f, -0.06815792f, 0.11480268f, 0.03912676f, 
    -0.08418241f, 0.06366161f, 0.05704359f, -0.07738716f, 0.02532517f, 0.02651376f, 0.11062595f, -0.14159936f, 
    0.00674794f, 0.09994563f, 0.11609537f, -0.02413683f, -0.12933339f, -0.15196733f, 0.11756818f, -0.01998004f, 
    0.48221454f, -0.07148436f, -0.00943418f, 0.03966643f, 0.15953641f, -0.05836174f, -0.06162255f, 0.12612534f, 
    0.16337481f, -0.26621664f, 0.25302663f, 0.16127969f, 0.00585402f, 0.04309196f, 0.15000458f, 0.07404805f, 
    0.18433228f, -0.19348340f, 0.06893266f, 0.05497563f, 0.12720092f, 0.01533578f, -0.13046734f, 0.01661280f, 
    -0.06459559f, -0.08668528f, -0.17659678f, 0.00351257f, 0.15025164f, 0.09664690f, 0.12485287f, -0.05913872f, 
    -0.13720588f, 0.24727701f, 0.12106743f, 0.07032219f, 0.17161022f, 0.06375033f, -0.01177023f, 0.13402645f, 
    -0.11652587f, -0.02479056f, 0.08251326f, 0.19482598f, 0.22079435f, 0.04358378f, 0.05909049f, 0.10830073f, 
    0.10463724f, -0.07502212f, 0.02448725f, -0.10083698f, -0.17622051f, 0.21304063f, -0.19714871f, 0.15748504f, 
    -0.10751066f, -0.01469449f, 0.02274686f, -0.03250434f, 0.12801915f, 0.19093728f, 0.11262464f, 0.07522811f, 
    0.05516584f, -0.12830319f, 0.08262333f, -0.01140331f, -0.01799125f, 0.01190994f, 0.07511404f, -0.27391845f, 
    0.07709011f, -0.03828182f, 0.03541287f, -0.02275283f, 0.11221518f, -0.19013116f, -0.06423232f, 0.14390807f, 
    -0.08550959f, 0.25743222f, 0.16837730f, -0.07804526f, 0.12889381f, 0.19944900f, 0.00147760f, 0.00151465f, 
    -0.08446907f, -0.16070865f, 0.00011083f, -0.06880041f, 0.18912020f, 0.20454487f, 0.03276769f, 0.12887722f, 
    0.22692803f, -0.15185994f, 0.02919581f, -0.10223319f, -0.14220048f, 0.10246743f, 0.00661116f, 0.11344572f, 
    0.05556307f, 0.11498616f, -0.08805699f, -0.03479931f, 0.11938275f, -0.18732047f, -0.07088196f, 0.14547859f, 
    -0.12655815f, 0.21629874f, 0.18965237f, 0.27113062f, 0.13095577f, -0.30687112f, -0.13761759f, 0.23111676f, 
    -0.14513256f, 0.15676668f, 0.12958799f, -0.04866592f, 0.06483874f, 0.09555719f, 0.01977330f, -0.37624478f, 
    0.10069030f, -0.06928379f, -0.10970837f, 0.16735594f, 0.01009971f, -0.04178213f, -0.29884768f, -0.13062456f, 
    -0.11046182f, -0.08467051f, -0.23209316f, 0.01852287f, 0.04030026f, -0.11608592f, 0.06251320f, 0.25894237f, 
    0.33141288f, 0.12479055f, 0.19557340f, 0.05093162f, -0.27281058f, 0.07347546f, -0.08663481f, -0.08719565f, 
    0.19598819f, 0.32987243f, 0.19080624f, 0.06517797f, -0.02517984f, 0.19262435f, -0.18650462f, 0.04426240f, 
    -0.05143212f, -0.06977322f, 0.12140296f, 0.00077488f, 0.14838798f, -0.06636772f, -0.03891616f, 0.09989113f, 
    -0.10181643f, -0.00634518f, -0.08168024f, 0.11850651f, 0.02163210f, -0.10637590f, -0.06994036f, -0.00691163f, 
    0.01475170f, 0.13449809f, 0.05208322f, -0.01040071f, -0.05686127f, -0.34415194f, 0.06539478f, -0.04596458f, 
    0.05861017f, -0.03719841f, 0.17019714f, 0.27018511f, -0.05431448f, -0.10750286f, 0.02687118f, 0.04266664f, 
    0.03203357f, 0.10881320f, 0.00601192f, 0.13699098f, -0.09424761f, -0.06630776f, -0.00299002f, 0.06553759f, 
    0.06971002f, 0.14210671f, 0.07586005f, 0.01654412f, -0.02939886f, -0.01575878f, 0.01549709f, 0.02103955f, 
    -0.19395499f, -0.23603608f, -0.06754698f, 0.20026734f, 0.05381006f, 0.16223364f, 0.04606914f, -0.11817997f, 
    -0.30193418f, 0.21131985f, 0.21359307f, -0.02781977f, 0.05537805f, -0.07641816f, -0.06466123f, 0.16177872f, 
    0.13882743f, 0.13068031f, 0.04798105f, -0.03702528f, 0.18179257f, 0.05388300f, 0.22334990f, 0.24390930f, 
    -0.51779401f, -0.50915885f, -0.19867639f, -0.15941980f, 0.17313184f, 0.03684055f, -0.04637976f, 0.01903709f, 
    -0.02499415f, -0.01770167f, -0.68778843f, -0.38489020f, -0.05391705f, -0.28781781f, -0.03369455f, 0.09433214f, 
    0.03262082f, -0.12162487f, 0.35413009f, 0.11899805f, 0.29433286f, -0.00657919f, 0.11843602f, 0.30508733f, 
    0.15657504f, 0.02513081f, 0.06762230f, -0.01072377f, -0.23713659f, -0.04025194f, -0.04488403f, -0.20207657f, 
    -0.02087567f, 0.07993129f, 0.02582531f, -0.03598827f, 0.21955121f, -0.42092180f, 0.16350037f, 0.20267166f, 
    0.02321430f, 0.08143768f, 0.00095441f, -0.00680467f, -0.02732406f, 0.00434248f, -0.07767266f, 0.18476212f, 
    0.07874098f, -0.03727168f, -0.15049404f, 0.00747298f, 0.03798074f, -0.00778405f, -0.24236366f, 0.02802026f, 
    -0.36918360f, -0.05211473f, 0.03955043f, -0.11323291f, -0.07566689f, 0.04578347f, 0.15517844f, -0.01311820f, 
    -0.29499194f, -0.25763881f, -0.01544688f, 0.16030039f, 0.20404193f, 0.02419272f, -0.02859196f, -0.02498436f, 
    0.29421845f, 0.24557829f, -0.18800694f, 0.03452652f, -0.06282482f, 0.01631928f, 0.04956264f, -0.03215767f, 
    -0.04367512f, 0.24972765f, 0.26665097f, 0.11429543f, -0.09297629f, 0.00705520f, 0.10645933f, 0.02841430f, 
    -0.04934719f, -0.00159617f, 0.25412393f, -0.52350378f, -0.08022484f, 0.06402597f, -0.14166766f, -0.06702240f, 
    0.06395666f, -0.00931634f, 0.22435006f, -0.49528554f, -0.02358049f, -0.17249161f, -0.03484903f, 0.27208942f, 
    0.06379417f, 0.04446382f, 0.20187286f, 0.10464726f, -0.14349227f, 0.18027660f, -0.30535617f, -0.49498138f, 
    -0.24581924f, -0.04091697f, 0.05778633f, 0.10218538f, 0.05843463f, -0.53358549f, -0.20734641f, 0.03040387f, 
    0.09175142f, -0.08966149f, -0.06618232f, 0.06591147f, 0.00073093f, -0.21479796f, 0.15636800f, 0.37775552f, 
    0.09986686f, -0.06260227f, -0.08028030f, -0.18413138f, 0.02101739f, 0.13890289f, 0.07436772f, 0.42144513f, 
    -0.35348004f, -0.01914540f, 0.11305698f, 0.00807053f, 0.09287906f, 0.00084674f, 0.18350431f, 0.02274826f, 
    0.44611225f, 0.12550096f, -0.27047014f, 0.01415366f, 0.00410149f, 0.04718778f, -0.06566525f, -0.00964107f, 
    0.17305139f, -0.03206235f, -0.06087940f, 0.02760572f, -0.12721479f, -0.09394037f, -0.14542715f, -0.03445305f, 
    -0.02479639f, -0.16103187f, 0.12038550f, -0.01733254f, 0.05973138f, 0.00211425f, -0.04138277f, 0.09230863f, 
    0.08055246f, 0.05568247f, -0.07977768f, 0.13536344f, -0.06741158f, -0.44244200f, 0.06059629f, -0.12337935f, 
    -0.18762805f, -0.04689346f, -0.01041881f, 0.04386882f, -0.20944849f, 0.16079116f, -0.05207315f, -0.14650889f, 
    -0.09556110f, 0.06415530f, 0.00339447f, 0.12713063f, 0.04262933f, -0.06625387f, -0.83892095f, 0.03264232f, 
    -0.05526594f, 0.03830333f, -0.17653424f, 0.16929364f, 0.05143217f, 0.17358604f, -0.26164207f, -0.28553861f, 
    -0.26250172f, 0.07593864f, 0.05356922f, -0.16673838f, 0.06725614f, -0.03536513f, 0.07229198f, 0.04621053f, 
    0.11711843f, 0.38740331f, 0.13223879f, 0.07762437f, 0.20027184f, 0.15625022f, 0.08353805f, 0.25976822f, 
    0.10748488f, -0.06443227f, -0.27864698f, 0.09892080f, 0.23207176f, 0.01771411f, 0.08050579f, 0.12029989f, 
    0.06833740f, -0.21261837f, -0.01002140f, -0.00702541f, -0.11389299f, -0.10475911f, -0.06996443f, 0.04422905f, 
    -0.02915521f, 0.08144345f, -0.23504546f, -0.00111879f, 0.07350910f, -0.05574223f, -0.22598137f, -0.14159484f, 
    0.00039008f, -0.06215360f, -0.12047869f, 0.36883023f, -0.34924456f, -0.16877599f, 0.03805785f, 0.06802361f, 
    0.19355977f, -0.02647019f, -0.00695095f, 0.21305029f, -0.25488898f, -0.20820250f, -0.04820151f, -0.03261673f, 
    -0.21057290f, -0.19725773f, -0.10104786f, -0.21168017f, -0.17140217f, -0.00446800f, 0.08276032f, 0.19143021f, 
    0.12229732f, -0.02623843f, -0.00733301f, -0.07667186f, -0.01965304f, -0.11922991f, -0.45712847f, -0.15196763f, 
    -0.14278178f, -0.04320077f, -0.06907442f, -0.17157689f, 0.05121713f, 0.01183369f, 0.01648094f, 0.13593796f, 
    0.04679683f, 0.02251665f, 0.04870090f, 0.00608948f, 0.08994930f, 0.10288138f, 0.08518803f, 0.14473219f, 
    0.03674262f, -0.29296890f, -0.26632854f, 0.00889049f, -0.14198855f, 0.09091435f, 0.02635007f, -0.06253804f, 
    -0.04568277f, 0.12409246f, 0.24662346f, 0.14786552f, -0.04864454f, -0.00993742f, 0.00741108f, 0.15637268f, 
    0.21876667f, 0.15166502f, 0.02816766f, 0.23483911f, 0.25984320f, -0.05017347f, 0.02812904f, 0.02817411f, 
    -0.23850411f, 0.17333613f, 0.16861206f, 0.14761691f, 0.08616788f, -0.33661959f, 0.01407643f, -0.06547296f, 
    -0.11244643f, 0.12461414f, 0.14887640f, 0.02220165f, 0.35934147f, -0.16219065f, -0.03019716f, -0.20615122f, 
    0.06625863f, 0.26484302f, -0.14224486f, -0.01339780f, 0.03687239f, 0.05306137f, -0.26954958f, 0.13308571f, 
    0.07938130f, 0.16874714f, -0.05317304f, -0.05214611f, -0.06850630f, -0.05196464f, 0.17322886f, 0.04451458f, 
    -0.23323064f, 0.17550009f, 0.12136166f, -0.00196903f, 0.17880043f, -0.20874047f, -0.14488442f, -0.20272361f, 
    0.01956620f, 0.12124124f, -0.00525444f, -0.08229198f, -0.06129323f, 0.09846941f, 0.07536970f, 0.01148271f, 
    -0.01037825f, 0.07435901f, -0.06928343f, -0.00291043f, -0.00105069f, -0.06643602f, -0.09631294f, -0.03296057f, 
    -0.19686741f, 0.26095816f, -0.23295994f, -0.51107842f, -0.08918351f, 0.12163655f, -0.07058508f, -0.06896156f, 
    -0.08979203f, 0.09710309f, 0.29770821f, -0.14000262f, -0.16078457f, 0.15306368f, 0.07334662f, 0.08525403f, 
    0.13967974f, -0.06776106f, -0.07964101f, 0.03751975f, 0.04275382f, -0.22303581f, -0.16351630f, -0.20999537f, 
    0.06746424f, 0.07362273f, 0.15395036f, 0.01948914f, -0.12245344f, -0.05261973f, 0.23094326f, -0.04270112f, 
    -0.12447061f, 0.10893225f, -0.03510275f, 0.17174391f, 0.15660997f, -0.06403100f, 0.12926096f, 0.07809761f, 
    -0.13194123f, 0.05800754f, -0.06997920f, -0.03170625f, 0.32626808f, 0.20402110f, -0.17435090f, -0.10451971f, 
    -0.17755288f, 0.12410414f, 0.27878329f, -0.19688410f, 0.06874189f, 0.08001149f, -0.01915958f, -0.37910536f, 
    0.05709933f, -0.15506415f, -0.00432626f, 0.10870303f, -0.13912937f, 0.10940298f, -0.03217998f, 0.00000296f, 
    0.18958987f, -0.11896390f, -0.06231080f, 0.01523565f, 0.12503748f, 0.23999514f, -0.07799380f, -0.00629771f, 
    -0.00396167f, -0.10717780f, -0.04116541f, -0.12206503f, 0.11962933f, -0.09176774f, -0.05612234f, -0.03396874f, 
    0.16536410f, 0.19014338f, -0.10231330f, 0.10665779f, 0.14198698f, -0.11210973f, 0.02578139f, -0.08116951f, 
    0.12071053f, 0.07560363f, 0.12848713f, -0.14897709f, -0.20521326f, -0.26496115f, 0.00367510f, 0.25570294f, 
    0.05309927f, -0.25641403f, -0.12771110f, 0.02919782f, -0.00688015f, 0.07211579f, 0.08296552f, 0.04438740f, 
    0.09206051f, 0.08998213f, -0.03995402f, 0.09252544f, -0.11881875f, 0.28170267f, -0.45452821f, -0.16819139f, 
    -0.09694549f, 0.09747781f, -0.08953866f, 0.06598512f, 0.07344096f, 0.03147669f, 0.23001178f, -0.07012678f, 
    -0.32292959f, 0.12960863f, 0.07428434f, 0.01244506f, -0.12507115f, 0.06832925f, -0.04699884f, -0.16867268f, 
    0.12202567f, 0.42697221f, 0.09903738f, 0.16460097f, -0.04393282f, -0.08022665f, 0.03027522f, 0.20228617f, 
    0.12389754f, 0.21150215f, -0.05163643f, -0.05218957f, -0.08209079f, -0.08372403f, 0.05795449f, -0.02615017f, 
    -0.09037600f, -0.20683996f, -0.13613968f, -0.08375575f, 0.06067163f, 0.00553149f, 0.06022463f, -0.17144312f, 
    0.00448575f, 0.16820385f, 0.14858507f, 0.05519727f, 0.20277070f, 0.05948827f, 0.08431059f, -0.10811966f, 
    -0.01341492f, -0.04478694f, -0.09740550f, 0.17485957f, 0.07208204f, 0.01218714f, 0.04752935f, -0.03722673f, 
    -0.00953787f, 0.12763588f, 0.09060159f, -0.06866153f, -0.57272929f, -0.13351633f, 0.11002909f, 0.02972044f, 
    -0.05295981f, 0.12869523f, -0.05400101f, 0.02414325f, 0.08983105f, -0.10313403f, 0.07556573f, 0.05902798f, 
    -0.07705663f, -0.01054700f, 0.09202870f, 0.06481699f, -0.01560107f, 0.11108240f, -0.44941309f, -0.03558846f, 
    -0.14277922f, -0.01965894f, -0.02359078f, -0.04382700f, 0.13910498f, -0.10876188f, -0.12117898f, -0.26180983f, 
    -0.06902327f, 0.01345963f, 0.07271963f, 0.10823944f, -0.04163223f, 0.16697831f, 0.05904117f, -0.08768764f, 
    0.01696048f, -0.07237650f, -0.07164050f, 0.06843062f, 0.01649280f, 0.06134725f, -0.01481925f, -0.00599814f, 
    -0.01742569f, -0.03661789f, 0.01389912f, 0.07184550f, 0.03195395f, -0.04550707f, -0.07831758f, 0.04625987f, 
    -0.08574078f, -0.06972817f, 0.02408424f, 0.00685464f, -0.07538508f, 0.00830549f, -0.05329116f, -0.00876966f, 
    -0.04428216f, -0.06101050f, -0.04558868f, -0.04563491f, 0.07743561f, -0.01013638f, -0.06352028f, -0.00164197f, 
    -0.07059204f, -0.02541525f, -0.06739134f, -0.05309306f, 0.06962200f, -0.01227105f, 0.03095410f, -0.07053158f, 
    -0.00388664f, 0.01696019f, 0.00950658f, -0.06418268f, 0.06089344f, -0.04885598f, -0.05162798f, -0.00162378f, 
    0.05976800f, -0.03967925f, -0.03825794f, 0.02414958f, -0.03531081f, 0.02848062f, -0.03304834f, -0.08284196f, 
    -0.08891010f, -0.02382942f, 0.00339771f, 0.05782264f, -0.05979628f, 0.06810544f, -0.04419191f, 0.04922158f, 
    -0.06255602f, 0.00883126f, -0.08179935f, -0.06129062f, 0.06079229f, 0.03020774f, -0.03920593f, 0.04501066f, 
    0.01472550f, -0.01837706f, -0.06795317f, 0.00886632f, -0.01396793f, 0.04005563f, 0.01013093f, 0.01415808f, 
    -0.05372587f, -0.06125316f, 0.05533826f, -0.08406142f, -0.02406117f, -0.07122955f, -0.02209483f, 0.04782319f, 
    -0.01513307f, -0.02399089f, 0.02379858f, -0.06532132f, 0.04927825f, 0.00922860f, 0.05423110f, -0.03605216f, 
    0.01108723f, 0.01964484f, -0.04517249f, 0.02423124f, -0.05100325f, 0.06897281f, -0.03375657f, -0.05285225f, 
    0.07006864f, -0.08421394f, -0.01500956f, -0.06952786f, -0.02025886f, -0.01172082f, 0.05010102f, -0.05590626f, 
    0.01196533f, 0.03761649f, 0.01816208f, -0.00080191f, -0.01245043f, 0.04447133f, -0.06018618f, -0.06251857f, 
    0.01198198f, -0.07177973f, 0.02928143f, -0.03502614f, 0.02639075f, -0.04062232f, -0.04546093f, -0.08084292f, 
    -0.01556491f, -0.05474526f, -0.08385619f, -0.03084187f, -0.07672065f, 0.03466894f, -0.04311492f, 0.05568805f, 
    -0.02645203f, -0.01934096f, 0.01540637f, 0.04948783f, 0.03944476f, 0.06521693f, -0.05701334f, 0.00778067f, 
    0.07324907f, 0.28598925f, 0.15785520f, 0.10929292f, 0.19203894f, 0.09622095f, 0.08495691f, 0.22634749f, 
    0.08097865f, -0.13125138f, -0.14980449f, -0.20891353f, 0.30700141f, 0.43964469f, -0.08335283f, -0.14311849f, 
    -0.07248323f, -0.30196595f, 0.44762099f, 0.01107570f, 0.05064591f, -0.00896896f, 0.20633459f, -0.12459334f, 
    -0.12678249f, 0.00251423f, -0.27881652f, 0.08320075f, 0.26267663f, 0.18606807f, 0.06737981f, 0.12732248f, 
    0.04033538f, 0.07756113f, 0.10722499f, -0.19543669f, -0.11052984f, -0.15170109f, -0.14911316f, 0.15653829f, 
    0.14654550f, 0.00537468f, 0.04138777f, -0.02000187f, 0.07764000f, 0.11928215f, 0.06211351f, 0.01710935f, 
    0.01601944f, 0.09909809f, 0.08038784f, 0.15419203f, 0.21679908f, 0.27905217f, -0.29919425f, -0.16079877f, 
    0.23996575f, 0.19505619f, 0.05088600f, 0.14631891f, 0.05971201f, -0.12510687f, -0.03174729f, 0.01832467f, 
    -0.18361132f, 0.08678567f, 0.18061940f, 0.14925596f, -0.00846426f, 0.04237350f, 0.07410729f, 0.09163078f, 
    0.14841919f, 0.00088142f, 0.25458112f, -0.02276750f, 0.01722352f, 0.22140610f, 0.13948168f, 0.08155119f, 
    0.21536589f, 0.41935959f, 0.03289208f, 0.05882367f, 0.06497436f, 0.09293652f, -0.02872663f, -0.05763099f, 
    0.09699248f, -0.04099707f, -0.04945979f, -0.16022010f, -0.23187047f, 0.12698813f, 0.12017071f, 0.01495021f, 
    -0.14616881f, 0.03643737f, -0.03211915f, 0.10313953f, 0.00353314f, 0.05748867f, 0.10440556f, -0.09438521f, 
    -0.04857918f, 0.17269883f, 0.20348005f, 0.18548578f, 0.06814616f, -0.04953102f, -0.08904212f, 0.20756894f, 
    0.06376815f, -0.13198717f, -0.01664022f, -0.11555637f, -0.17675924f, -0.24227969f, -0.15955390f, -0.04205760f, 
    0.00191616f, 0.04732332f, 0.12134022f, -0.21824916f, -0.02173135f, -0.17437683f, -0.08068125f, -0.01847851f, 
    -0.10865452f, -0.16122450f, 0.02674017f, 0.02049695f, 0.12777850f, 0.20971271f, 0.22746338f, 0.08289729f, 
    0.13135178f, -0.02420847f, -0.11508520f, -0.05615416f, -0.06304822f, -0.21146221f, 0.15458138f, -0.07632229f, 
    0.03130871f, -0.08507022f, 0.03810094f, 0.01897843f, -0.06738655f, 0.01757159f, 0.02986825f, -0.05240871f, 
    0.00104585f, 0.05590085f, 0.06157966f, 0.04981201f, -0.06275450f, -0.05093492f, 0.02522975f, -0.08122196f, 
    -0.00937207f, 0.05208931f, 0.00462656f, 0.04649075f, -0.01102549f, -0.10130210f, 0.02988648f, 0.01393894f, 
    0.05438113f, -0.05054585f, -0.06403171f, 0.02418880f, -0.05744605f, 0.05223687f, 0.00765786f, 0.01906051f, 
    -0.03668160f, -0.01169203f, -0.02483308f, 0.05058411f, -0.00246141f, 0.02679581f, -0.01456098f, 0.02895827f, 
    0.06476791f, -0.02856167f, 0.00149469f, -0.06830444f, -0.06079225f, -0.08884129f, 0.03603006f, 0.07169388f, 
    0.04982900f, 0.02200173f, -0.06957767f, -0.08071823f, 0.01235420f, -0.01162490f, -0.06214823f, -0.07144818f, 
    -0.09111034f, -0.02738442f, -0.02390458f, -0.03145529f, 0.03082110f, -0.05980817f, 0.04055838f, -0.04866245f, 
    0.01916055f, 0.00304050f, 0.06466979f, -0.08161310f, -0.03685896f, -0.01400686f, 0.04770955f, 0.01204684f, 
    -0.10524318f, -0.03339402f, -0.05125427f, 0.00441607f, -0.01754333f, -0.04899158f, -0.06162804f, 0.04031112f, 
    -0.08615380f, 0.04397716f, 0.04872143f, 0.00409178f, -0.04022364f, 0.01245151f, 0.03408702f, -0.05424516f, 
    0.04444788f, -0.06805965f, -0.02344748f, 0.05910507f, -0.07656966f, -0.07946341f, -0.05436383f, -0.04545242f, 
    0.03588455f, -0.00435360f, -0.08619984f, -0.07778201f, 0.06436832f, -0.01677126f, 0.01120849f, -0.09291393f, 
    -0.00330550f, -0.07763720f, -0.06460176f, -0.00840992f, 0.03119058f, -0.03509975f, -0.01984409f, -0.06292392f, 
    -0.08505899f, -0.04030408f, 0.00076381f, 0.02033468f, -0.05305823f, -0.06749588f, -0.08890235f, 0.02634509f, 
    0.01779313f, -0.09509256f, 0.03805203f, -0.03677057f, 0.00778797f, -0.02552912f, -0.06500195f, -0.05358434f, 
    -0.04884433f, -0.04730423f, -0.04301094f, -0.02754396f, -0.05522640f, 0.00061086f, -0.05790838f, 0.03334447f, 
    -0.00724232f, -0.01059668f, 0.04959743f, -0.05451764f, 0.05720082f, 0.02518630f, -0.05342632f, -0.05996326f, 
    0.06011358f, 0.39598751f, 0.15041150f, 0.00809826f, 0.01849533f, 0.11814829f, -0.11997841f, -0.22012435f, 
    -0.05665434f, 0.06871548f, 0.04342472f, 0.00732784f, 0.23835818f, 0.20677252f, -0.07889006f, -0.22005305f, 
    0.21528307f, -0.09521098f, 0.09695432f, -0.12945944f, -0.00744068f, 0.08727171f, 0.01320268f, -0.07188842f, 
    -0.15968415f, -0.18217412f, -0.22284792f, -0.36868724f, 0.07400107f, 0.18066157f, -0.02469233f, -0.05247599f, 
    0.06616535f, -0.06837992f, 0.04217305f, -0.08842061f, -0.04080388f, 0.27353695f, 0.30601275f, -0.11604931f, 
    0.02206411f, -0.00072355f, -0.03918856f, -0.10775840f, 0.11112520f, 0.07689429f, 0.18705678f, 0.01367942f, 
    -0.18548411f, 0.07711304f, 0.01203309f, -0.01377857f, 0.19802488f, 0.12941532f, 0.32877469f, -0.28377825f, 
    -0.20356826f, 0.02206267f, 0.04549179f, 0.00081751f, -0.00735364f, 0.07828215f, 0.03145393f, 0.17614253f, 
    0.05130225f, 0.19590376f, 0.20017834f, 0.05686484f, 0.07719526f, 0.02628596f, 0.22590148f, 0.01818712f, 
    -0.12267265f, -0.18057002f, -0.15113325f, -0.02939306f, -0.04800964f, -0.02600528f, 0.17991048f, 0.10988353f, 
    0.17794389f, 0.03019774f, 0.26056886f, 0.16541301f, -0.05150462f, -0.02388223f, 0.10191408f, 0.13926135f, 
    0.11689554f, -0.04624967f, -0.01796511f, 0.01006162f, 0.28762895f, -0.09367225f, -0.06311318f, -0.03770593f, 
    -0.02652566f, -0.16175079f, 0.11386195f, -0.13552906f, -0.03287749f, 0.19643590f, 0.03351141f, 0.05385075f, 
    0.01695348f, -0.14063598f, 0.09577525f, 0.13297728f, -0.19894561f, -0.24875490f, 0.10662035f, 0.09628993f, 
    0.05687315f, 0.05857014f, -0.19199823f, -0.20658134f, -0.21888855f, -0.06976271f, 0.00666387f, -0.12241278f, 
    -0.10316535f, -0.13334902f, -0.06291471f, 0.02172064f, -0.00086977f, -0.15033428f, -0.20054299f, 0.08722471f, 
    0.12417913f, 0.09313358f, -0.21435514f, 0.06098668f, 0.16735405f, 0.25984669f, 0.03549390f, 0.04345930f, 
    -0.12632117f, 0.03089155f, -0.17494413f, -0.13319309f, -0.12540847f, -0.10298825f, 0.03979434f, -0.01170260f, 
    -0.08545075f, -0.09882555f, 0.00247295f, 0.01798994f, -0.06831952f, 0.05460568f, -0.00317663f, -0.04088469f, 
    -0.07271267f, -0.03529979f, -0.01185506f, -0.02823835f, -0.04268763f, 0.03149096f, -0.09773751f, 0.07457405f, 
    -0.00991836f, -0.03829247f, 0.00479867f, -0.03435814f, 0.05012896f, -0.05510889f, 0.00966589f, 0.06833144f, 
    -0.00429469f, -0.00925977f, 0.03181294f, -0.00472593f, 0.01373017f, 0.05246633f, -0.04395035f, -0.01422593f, 
    -0.04878607f, -0.00891216f, -0.02471544f, -0.03689519f, 0.04717257f, -0.01488906f, 0.05315858f, -0.02227846f, 
    0.00796761f, -0.08317577f, -0.04917957f, -0.03503934f, 0.04837715f, -0.10097257f, 0.01317360f, -0.00096623f, 
    0.01210544f, -0.07824855f, -0.02362363f, -0.06746577f, -0.06060965f, 0.04436932f, 0.05163688f, 0.03171436f, 
    -0.05009678f, -0.01850834f, -0.01193638f, 0.05474179f, -0.00712008f, -0.07235357f, -0.03227600f, -0.00315657f, 
    -0.06818656f, 0.04086135f, -0.07090505f, 0.06159730f, 0.03884888f, 0.06893546f, -0.05752268f, 0.03603429f, 
    -0.05857192f, -0.06360208f, -0.04941269f, 0.06368328f, 0.01490489f, 0.02402948f, -0.06187002f, -0.10358028f, 
    0.02211108f, 0.02909775f, -0.07156682f, -0.05962849f, -0.04143448f, 0.00896872f, -0.09606525f, -0.06464251f, 
    -0.04436431f, -0.00425236f, -0.07690185f, 0.00187198f, 0.05555256f, 0.02616276f, -0.08668403f, -0.06479318f, 
    0.04214488f, 0.01078996f, -0.09327465f, -0.06066444f, -0.08197564f, 0.03898538f, -0.03021930f, -0.04369917f, 
    -0.05194739f, -0.05070684f, -0.00145168f, -0.09459647f, -0.08889169f, 0.03703283f, -0.05305095f, 0.03284300f, 
    0.05055796f, -0.04816082f, -0.02184643f, -0.08518872f, -0.10312162f, -0.00442921f, 0.02859119f, 0.02998105f, 
    -0.09210829f, 0.04421546f, 0.05643148f, -0.01095642f, -0.07237905f, -0.00095700f, -0.00738619f, -0.01079934f, 
    -0.04576313f, 0.04622646f, 0.01641887f, -0.09145322f, -0.04812361f, -0.02666249f, 0.00282224f, -0.00714946f, 
    -0.01125921f, -0.09166581f, 0.05510249f, 0.04170145f, -0.02264730f, -0.03430707f, 0.04535505f, 0.06390858f, 
    -0.07507838f, -0.03029448f, -0.07222793f, 0.06249597f, 0.00441618f, 0.05023794f, -0.03087112f, 0.01242181f, 
    -0.01772390f, -0.02331923f, 0.02286652f, 0.01682129f, -0.07429224f, 0.06378022f, -0.05878297f, -0.07652648f, 
    -0.07960914f, 0.03790626f, -0.02725512f, 0.05826486f, 0.00415902f, 0.03479903f, 0.01554804f, 0.02262676f, 
    0.00782475f, -0.01082124f, -0.06865253f, 0.00037047f, 0.02645664f, 0.06858633f, -0.08248024f, -0.01577340f, 
    -0.02668571f, 0.04069215f, 0.02927992f, -0.09046698f, -0.02592874f, 0.01286148f, 0.02103358f, 0.03895041f, 
    -0.00206483f, -0.07335029f, 0.04087093f, 0.00528786f, -0.04319707f, 0.07146132f, 0.04222472f, -0.08416662f, 
    -0.00027705f, 0.05431938f, -0.02551683f, 0.01441377f, -0.02355228f, 0.07430371f, 0.01808205f, -0.08781876f, 
    -0.08029517f, 0.00396321f, 0.01582842f, 0.01836129f, -0.05566342f, -0.06211434f, 0.03679773f, 0.03302008f, 
    -0.08543685f, -0.04963120f, 0.04141459f, -0.05254193f, -0.08274300f, -0.05338177f, -0.01220181f, -0.01573369f, 
    -0.04245029f, 0.06679254f, -0.04308878f, -0.05349276f, 0.00350702f, 0.00315725f, -0.03558351f, 0.00464297f, 
    0.07487985f, -0.07287487f, -0.02041397f, -0.05271286f, 0.06831472f, -0.03490830f, 0.06657200f, -0.08004325f, 
    0.01608726f, -0.03158597f, 0.06852756f, -0.05043682f, -0.05910400f, -0.03381290f, -0.03732431f, 0.02060090f, 
    0.04245501f, -0.02581374f, 0.00674580f, -0.03686319f, -0.05449682f, 0.00737015f, -0.08923374f, -0.03792560f, 
    0.05262351f, -0.01247587f, -0.04475884f, 0.04875335f, 0.02029350f, 0.03774081f, -0.07497198f, -0.01914022f, 
    -0.07410055f, -0.05232271f, -0.05315900f, -0.03925164f, -0.03277104f, 0.06572302f, -0.00311512f, -0.02626888f, 
    -0.03645124f, 0.07476795f, -0.07417814f, -0.03237168f, 0.05833524f, 0.01877254f, 0.05378621f, -0.04124086f, 
    0.03352687f, 0.02281560f, -0.01321186f, -0.02529074f, -0.05601169f, 0.01948931f, 0.00514783f, -0.01427207f, 
    -0.04203428f, -0.00289630f, -0.01996944f, -0.09004523f, -0.02373776f, 0.02595232f, 0.05995134f, 0.01154184f, 
    -0.27000153f, -0.11234082f, -0.03919894f, -0.08702838f, 0.09698171f, -0.03267081f, -0.05574017f, 0.09792990f, 
    -0.20689042f, 0.03499785f, 0.30174950f, -0.04147317f, -0.25148502f, -0.25281802f, -0.26140249f, 0.06478020f, 
    -0.04438330f, 0.06175177f, -0.32124165f, -0.43664297f, -0.38496920f, -0.09646581f, 0.11964010f, 0.33741003f, 
    0.02963168f, 0.05672744f, 0.03806045f, 0.02650404f, -0.58536446f, 0.07266740f, -0.08543606f, -0.00719083f, 
    -0.11322378f, 0.03265315f, 0.06255065f, 0.07619543f, -0.06080936f, -0.06234051f, -0.22191577f, -0.13310741f, 
    -0.00629854f, -0.18374667f, 0.10624321f, 0.10735912f, -0.00917226f, -0.31861123f, -0.20261173f, 0.00835546f, 
    0.15216912f, 0.03977331f, 0.10738057f, 0.03174676f, -0.03005630f, -0.06418182f, 0.13114464f, -0.22436593f, 
    -0.20524056f, -0.02728373f, 0.12243023f, -0.06744718f, 0.07101446f, 0.02985910f, -0.07418804f, 0.11671899f, 
    0.15721959f, 0.16559346f, 0.14069256f, -0.02814043f, 0.01725947f, 0.00331886f, 0.18094288f, 0.01536857f, 
    0.34252739f, 0.35606381f, -0.19297926f, -0.05725536f, -0.09188487f, 0.04520288f, 0.08264977f, -0.05915732f, 
    -0.07194635f, -0.17572773f, -0.05410162f, -0.20363255f, -0.05331752f, -0.04319932f, -0.11653452f, -0.22161075f, 
    0.05050442f, 0.04420920f, 0.01708566f, -0.10441436f, 0.06941369f, 0.12115707f, 0.10102030f, -0.06829458f, 
    0.07112771f, 0.16107783f, -0.10688913f, -0.09827237f, 0.02804779f, 0.13492633f, -0.05213313f, -0.08957156f, 
    0.06578520f, 0.03914069f, 0.07260280f, -0.00565396f, 0.12438245f, 0.30794257f, 0.35081390f, -0.26839402f, 
    -0.28599498f, -0.12423938f, -0.00134950f, -0.00995644f, -0.06901375f, 0.16320252f, 0.27067181f, -0.06231885f, 
    0.15491399f, 0.18034203f, 0.07810824f, 0.00287407f, 0.13411665f, 0.19976293f, 0.05869755f, 0.19160913f, 
    -0.12095693f, -0.33525094f, -0.12154724f, -0.36012584f, -0.10907653f, -0.07107711f, 0.02366995f, -0.32170102f, 
    -0.24278599f, -0.15768760f, -0.01301881f, 0.12933123f, 0.05431813f, 0.13851367f, 0.01874987f, -0.01695630f, 
    0.49762151f, -0.10068010f, -0.05398189f, -0.05180053f, -0.14531118f, 0.18561947f, 0.00521102f, 0.03068218f, 
    -0.07024713f, -0.29937953f, -0.00602231f, -0.11880360f, 0.08081668f, -0.00222224f, -0.12214556f, 0.08470042f, 
    -0.07565769f, 0.29663125f, -0.22264552f, 0.16294608f, -0.26837188f, -0.12648356f, -0.07049002f, -0.09934177f, 
    0.03684241f, -0.09250481f, 0.21708143f, -0.10815556f, -0.46689224f, -0.05866235f, -0.06065799f, -0.01057501f, 
    0.01793132f, 0.00895212f, -0.07757819f, -0.03510677f, 0.36755282f, 0.08720168f, 0.44858485f, -0.14629671f, 
    0.21204750f, -0.10077749f, -0.06430235f, -0.02027455f, -0.09993411f, 0.09134550f, -0.20075446f, -0.16521779f, 
    0.03845029f, -0.01670591f, -0.03725222f, 0.13360271f, 0.14766921f, -0.02976054f, 0.71670431f, -0.06836636f, 
    -0.31482452f, 0.08433858f, 0.04130064f, -0.10508824f, 0.10057041f, 0.01923505f, 0.07341717f, -0.10958838f, 
    -0.01013778f, 0.09876356f, 0.05576387f, 0.10667578f, 0.16196476f, 0.16924803f, 0.09315202f, 0.07788586f, 
    -0.01769795f, 0.03036660f, -0.13279641f, 0.03887376f, 0.13340491f, 0.11113703f, -0.05754390f, 0.10205656f, 
    0.01516610f, -0.08137781f, 0.11416125f, 0.11123033f, -0.12920089f, -0.03205935f, 0.14850608f, 0.16822228f, 
    0.11022004f, 0.01283365f, 0.28910643f, 0.25823283f, 0.19289316f, -0.32505217f, -0.03724322f, -0.20844905f, 
    -0.07860122f, 0.02881593f, 0.03071641f, -0.03800813f, -0.15678044f, -0.37295470f, 0.00733420f, 0.00350917f, 
    -0.04568297f, 0.06309431f, -0.06061115f, -0.01687768f, -0.81095159f, 0.03743603f, -0.33403909f, -0.07782521f, 
    0.17203690f, -0.03036448f, 0.06081535f, -0.12179876f, -0.05262610f, 0.00634659f, 0.00510092f, 0.07734971f, 
    -0.16097875f, -0.07127114f, 0.01583954f, -0.00978527f, 0.08147732f, 0.08932889f, -0.02061515f, -0.05139156f, 
    -0.03631067f, -0.07238682f, -0.12720613f, -0.22572771f, -0.07128841f, 0.01820186f, -0.16042764f, -0.11374840f, 
    -0.20955652f, -0.20138887f, 0.08148092f, 0.12340725f, 0.03615000f, 0.11984488f, -0.07100784f, -0.00908039f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03429409f, 0.07838880f, 0.05484873f, 0.11085770f, -0.09055503f, 0.34588274f, -0.08223640f, 0.26030958f, 
    0.01087948f, 0.01851970f, -0.03604300f, 0.11291103f, -0.04313826f, -0.00435212f, 0.08221895f, 0.22366962f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10205831f, 0.06705888f, 0.04614750f, 0.25440681f, -0.21400735f, -0.15780386f, -0.12257209f, 0.03200485f, 
    0.10762908f, -0.00972471f, -0.07194150f, -0.18599607f, -0.07195690f, 0.13330871f, 0.27307886f, 0.27849630f, 
    0.16520683f, 0.25424105f, 0.24736965f, -0.17219490f, 0.39961341f, -0.26990947f, 0.05328698f, -0.33209792f, 
    0.23917595f, 0.04272403f, -0.23186797f, 0.20784569f, -0.14866185f, 0.08050128f, 0.20524336f, -0.24065480f, 
    -0.16425365f, -0.07563382f, 0.11224233f, -0.09389362f, 0.10213286f, -0.14151494f, -0.20501637f, 0.20790288f, 
    -0.13406244f, -0.16392685f, 0.07958531f, -0.01867313f, 0.13940093f, 0.20239335f, -0.20087664f, -0.25153428f, 
    0.12633005f, 0.29394370f, 0.18867618f, 0.11657643f, -0.42123824f, -0.22719419f, 0.01199775f, -0.46154609f, 
    -0.10505173f, 0.07672259f, -0.03633586f, 0.04713572f, -0.14376436f, -0.06400279f, -0.23462877f, -0.19958243f, 
    -0.22242266f, 0.14341146f, -0.21723799f, 0.27230814f, -0.27665439f, 0.01332802f, -0.09846289f, 0.22994523f, 
    -0.11825620f, 0.11661474f, 0.08939195f, 0.03906164f, -0.17511027f, -0.00358320f, -0.32032326f, 0.29793489f, 
    0.30101982f, -0.39122719f, 0.22215763f, 0.02568689f, 0.39426720f, 0.03343340f, -0.06189096f, -0.32884443f, 
    -0.02509947f, 0.03880183f, -0.00898037f, 0.09718285f, -0.12681228f, -0.11279720f, 0.06919293f, 0.02119350f, 
    0.25378770f, 0.02433237f, -0.16634972f, 0.13266876f, 0.05858627f, -0.14181747f, -0.38135731f, -0.39585343f, 
    -0.18898301f, 0.34384272f, -0.22992878f, 0.06333463f, 0.06461580f, 0.00996147f, -0.52539605f, 0.71388173f, 
    0.17240703f, -0.02629909f, -0.20084804f, -0.01493174f, -0.17060083f, 0.10024095f, -0.24157339f, -0.05196652f, 
    -0.10373217f, -0.08007464f, -0.08462778f, -0.15554985f, 0.13673970f, -0.07228285f, -0.23652080f, 0.05235398f, 
    0.30756399f, 0.26669127f, 0.26196036f, 0.31594869f, 0.14374468f, -0.43430057f, 0.02250862f, -0.20824580f, 
    0.23297741f, -0.20453686f, -0.20754535f, -0.26466155f, 0.22215635f, -0.15949626f, 0.17558280f, -0.48315635f, 
    -0.15851641f, 0.18438727f, -0.03352934f, 0.00962168f, 0.10381311f, 0.22689018f, -0.21865770f, -0.12681398f, 
    0.07712042f, -0.24701667f, -0.00696903f, -0.14742196f, 0.18060806f, -0.15140817f, -0.13984841f, 0.04052767f, 
    -0.22397231f, -0.19215760f, 0.03407434f, -0.18598378f, -0.12639958f, -0.25338578f, -0.17052850f, -0.14825800f, 
    -0.04037324f, -0.23161027f, 0.04315981f, 0.21196330f, 0.04280505f, -0.13011706f, -0.01404302f, -0.13357143f, 
    -0.58785307f, -0.03962307f, 0.18091592f, 0.11364264f, -0.51549423f, 0.08483624f, 0.03252710f, -0.11897262f, 
    -0.22229823f, 0.18598090f, 0.24926306f, 0.00090483f, -0.14446980f, 0.23203945f, -0.55658329f, 0.02331473f, 
    0.54494780f, -0.20689617f, 0.29422456f, -0.17030263f, 0.27150863f, -0.16853185f, -0.15062945f, -0.22719355f, 
    -0.18888539f, 0.11246604f, -0.11097728f, -0.07743813f, -0.10480613f, 0.02501974f, 0.03309622f, -0.31441835f, 
    -0.04362006f, 0.38654494f, -0.24819286f, 0.31665000f, -0.01153630f, 0.30492043f, -0.12299804f, -0.28311750f, 
    -0.22570276f, 0.31649587f, -0.17179954f, -0.15779993f, 0.01022962f, 0.16246641f, -0.44001392f, -0.12143850f, 
    0.33223569f, 0.36877796f, 0.08385710f, -0.04842863f, -0.59397918f, 0.48548397f, -0.00751581f, -0.15047222f, 
    -0.05179723f, -0.37490565f, -0.00425628f, 0.13414542f, -0.17150475f, 0.20615894f, 0.08546446f, 0.18108700f, 
    0.06303741f, 0.38304543f, -0.15177064f, -0.02614893f, 0.47715107f, 0.13258824f, 0.44742534f, -0.08308519f, 
    0.04455275f, -0.04407708f, -0.22969693f, 0.16697633f, 0.03627201f, -0.16985293f, 0.35272276f, 0.35093579f, 
    0.34540036f, -0.41743761f, -0.21246123f, 0.11422930f, 0.35853368f, 0.24684921f, -0.78432810f, -0.39311156f, 
    0.07809022f, -0.04277666f, 0.08617529f, -0.08260098f, 0.09509274f, 0.21022709f, -0.28257531f, 0.15348086f, 
    0.19333348f, 0.03733360f, -0.14843689f, 0.08244203f, 0.18882588f, -0.24686328f, 0.49625725f, -0.22977552f, 
    -0.23609148f, 0.16964851f, 0.10591781f, 0.03534443f, 0.20137826f, 0.20728090f, 0.13507992f, 0.01343404f, 
    -0.06658419f, -0.11155904f, -0.00487714f, 0.24738802f, 0.08017708f, 0.35082552f, -0.19642523f, -0.40506315f, 
    0.12278770f, 0.28904268f, -0.05959802f, 0.17875898f, -0.05111879f, 0.23998289f, -0.24938817f, -0.41108656f, 
    -0.42342976f, 0.27658248f, -0.13631634f, -0.13307147f, -0.12132355f, 0.03914166f, 0.03350053f, -0.16318406f, 
    -0.22917551f, -0.28502402f, 0.01054323f, 0.15281680f, 0.05945772f, -0.02623945f, 0.11002863f, 0.23556779f, 
    0.16980265f, 0.51658762f, 0.06803897f, -0.07310639f, 0.41025013f, -0.00509607f, 0.07926306f, -0.48560101f, 
    -0.05131186f, 0.13450301f, -0.15350318f, -0.17338532f, 0.09848883f, 0.11547362f, -0.11121286f, -0.32690832f, 
    0.09643001f, -0.02851635f, 0.04117012f, -0.26401702f, 0.64056355f, -0.20319560f, -0.24233332f, 0.04912072f, 
    -0.15530646f, 0.27373508f, 0.03271086f, -0.07330935f, 0.21283443f, 0.16167831f, 0.07890033f, -0.31159848f, 
    0.13001582f, -0.09785827f, 0.30403548f, -0.09739720f, 0.23009312f, -0.29564735f, -0.44932392f, -0.18226074f, 
    0.06127459f, 0.12755537f, -0.04052132f, -0.11870772f, 0.01616115f, -0.19096029f, 0.23880310f, -0.20086133f, 
    -0.16017294f, -0.02223521f, -0.18613201f, 0.04854980f, 0.02005547f, -0.17487040f, -0.06550777f, -0.10173738f, 
    0.23073339f, -0.15988997f, -0.01116633f, -0.02285987f, -0.06878242f, -0.21643761f, -0.04055971f, -0.03418186f, 
    0.10983100f, 0.14600864f, 0.19767840f, -0.19797212f, 0.62831414f, -0.09023152f, 0.23212548f, 0.25048283f, 
    0.20568906f, -0.24675411f, -0.13764708f, 0.25527126f, -0.05122850f, -0.07663184f, 0.43685526f, 0.24532646f, 
    -0.08037555f, -0.19879007f, 0.34829053f, 0.03089129f, 0.28079167f, -0.38235405f, -0.34147862f, -0.14219789f, 
    0.16242033f, -0.17618147f, -0.12756723f, 0.18014279f, -0.04100003f, -0.16577956f, 0.16639988f, 0.51788592f, 
    -0.04381790f, -0.20206399f, -0.18801697f, 0.31166920f, -0.33471397f, 0.49957299f, -0.34477073f, 0.26813102f, 
    -0.11678556f, 0.17361306f, -0.17838892f, -0.18309136f, 0.15395375f, 0.15915835f, -0.51908469f, 0.43169653f, 
    0.32256106f, -0.49675760f, 0.06229956f, -0.19185162f, 0.03230521f, 0.45249161f, -0.22704269f, 0.26587439f, 
    -0.12932760f, 0.03646389f, -0.13667001f, 0.20222431f, 0.08098074f, -0.24322636f, -0.54621840f, 0.66197908f, 
    0.12221436f, 0.08571719f, 0.05622536f, 0.21529448f, 0.01934920f, 0.25353959f, 0.05989120f, 0.04256468f, 
    -0.14674656f, -0.20869641f, -0.10570168f, -0.14238565f, -0.06242108f, -0.05864503f, 0.15659803f, 0.74081457f, 
    -0.16243881f, -0.22882053f, -0.18782964f, -0.16658646f, 0.07955009f, 0.19770473f, 0.22803304f, -0.02844360f, 
    -0.08774555f, -0.07339641f, -0.23650017f, 0.20272997f, -0.23976368f, -0.00927237f, -0.10276613f, -0.21738970f, 
    0.22539374f, 0.09317596f, -0.15743342f, 0.11107650f, 0.44732657f, 0.65813291f, 0.00225101f, -0.04118793f, 
    -0.05597638f, -0.12435909f, -0.00340483f, 0.06941430f, 0.00137390f, 0.02603524f, -0.42119402f, 0.11390708f, 
    0.05525817f, 0.32824230f, -0.04245440f, -0.15234874f, 0.40815276f, -0.11629010f, 0.24262650f, -0.25375417f, 
    -0.15330686f, 0.24606872f, 0.15726289f, -0.23440754f, -0.00366742f, -0.17348234f, 0.01960557f, -0.01974515f, 
    0.17037207f, -0.48158073f, 0.20218724f, 0.26553416f, -0.18429549f, 0.51959997f, 0.20690529f, 0.35275599f, 
    -0.17156103f, -0.16810872f, -0.00422467f, -0.62693173f, -0.20229203f, 0.06853813f, 0.03467366f, -0.45782864f, 
    0.03260778f, -0.14206992f, -0.05231319f, 0.27027029f, 0.05952481f, 0.44461861f, 0.14039207f, 0.01056432f, 
    0.06411289f, -0.09140565f, 0.02993633f, -0.20019136f, -0.12867859f, 0.03446177f, 0.46645737f, 0.61573666f, 
    0.19395444f, -0.08771217f, -0.10376862f, -0.22438531f, -0.15907498f, 0.13465545f, 0.22558914f, -0.22011155f, 
    0.15486005f, -0.17329000f, 0.13989173f, 0.17102796f, 0.14949366f, 0.08513390f, -0.10185304f, 0.16858530f, 
    -0.03832592f, -0.19963033f, 0.17796475f, 0.22380832f, -0.51596457f, 0.63380653f, -0.32730937f, 0.13225359f, 
    -0.22981858f, 0.01018079f, -0.20261976f, 0.17348285f, -0.12304880f, 0.07955141f, -0.11265747f, -0.32600227f, 
    -0.33610445f, -0.34532794f, 0.22810501f, -0.24419357f, 0.28223956f, 0.17658173f, -0.44132477f, -0.34699550f, 
    -0.23935227f, 0.19797300f, -0.13324526f, 0.17318283f, -0.05985453f, -0.02663283f, -0.09300335f, 0.42361531f, 
    0.47807422f, -0.34849510f, 0.30011934f, 0.07758155f, -0.01760497f, 0.34754398f, -0.00656795f, -0.31295004f, 
    -0.08596101f, 0.07967155f, 0.03748800f, 0.02207018f, -0.20885268f, -0.00462060f, 0.26284468f, -0.49403551f, 
    0.17989582f, -0.38574746f, 0.26392627f, -0.11439592f, 0.11096992f, 0.05076769f, -0.28444776f, 0.11235119f, 
    -0.13716808f, -0.02114666f, -0.21967986f, 0.21570686f, 0.22506005f, -0.12393701f, 0.55429322f, -0.28733501f, 
    -0.24306884f, 0.04054291f, 0.17481285f, -0.08619910f, -0.08568735f, -0.40396902f, -0.08283260f, 0.03139535f, 
    0.25773782f, 0.24926040f, 0.16466685f, -0.06769747f, -0.22192696f, 0.11069570f, -0.00251720f, 0.48211458f, 
    0.35919517f, -0.19626105f, -0.11084621f, 0.26847702f, -0.22441778f, 0.64920264f, -0.17182408f, 0.12645073f, 
    -0.10149594f, 0.01237241f, -0.16031726f, -0.68465805f, 0.20718805f, 0.10018202f, -0.48044255f, -0.17661953f, 
    0.06471557f, 0.30979964f, 0.28876302f, -0.09974710f, -0.60248226f, 0.13734113f, 0.02766794f, -0.31031922f, 
    0.22356786f, -0.21251982f, 0.03380353f, -0.23694365f, -0.22458729f, 0.15743925f, -0.01554706f, 0.52809423f, 
    -0.08137468f, -0.23577854f, -0.04154927f, -0.12235351f, -0.29300001f, 0.41387600f, 0.10509267f, 0.28011578f, 
    -0.02665094f, 0.32901528f, 0.04391624f, -0.06004639f, -0.02906504f, 0.01855159f, -0.18319108f, 0.11249092f, 
    -0.12860216f, -0.47942546f, 0.34853521f, 0.16692889f, 0.03501522f, -0.41117957f, -0.03096805f, 0.31830367f, 
    -0.08630434f, -0.30783188f, 0.21967080f, -0.42237437f, 0.21155354f, -0.08253817f, -0.00092799f, 0.45680574f, 
    0.39397541f, 0.43588746f, -0.38274613f, 0.00644640f, -0.07361655f, 0.63539958f, -0.07558852f, 0.06085521f, 
    0.02212812f, 0.21229461f, 0.01006116f, -0.17736624f, -0.09348868f, -0.24157748f, -0.11820334f, 0.15766539f, 
    0.36647695f, -0.38951218f, 0.13309078f, 0.47671098f, -0.02181771f, -0.26159069f, 0.11600245f, -0.08794942f, 
    0.10602046f, -0.34501013f, 0.14481077f, -0.30809519f, -0.11892579f, -0.03829961f, 0.39273873f, 0.27387190f, 
    -0.05470728f, -0.26955619f, 0.09332934f, 0.38226351f, 0.07599846f, 0.04469375f, 0.38688695f, 0.21839394f, 
    -0.02496442f, -0.26110357f, -0.04078535f, -0.37875104f, 0.22416106f, -0.20750068f, 0.42490712f, -0.44885194f, 
    0.34963304f, -0.44423008f, 0.13544773f, 0.00653629f, 0.28261170f, 0.16538735f, -0.53751105f, -0.31669205f, 
    -0.23130448f, 0.24184117f, 0.06159898f, 0.26142162f, -0.13788183f, -0.07881565f, -0.06855866f, 0.32481754f, 
    0.17284241f, 0.36649454f, -0.36640581f, 0.13151695f, -0.02153084f, 0.11773723f, 0.44729349f, 0.22309512f, 
    -0.00929650f, 0.19711618f, 0.01577735f, 0.19097607f, 0.09051681f, -0.10003161f, -0.14271045f, -0.26445994f, 
    0.31361845f, 0.00714677f, 0.00787316f, 0.22413974f, 0.11745673f, -0.38256177f, -0.22112709f, -0.37203187f, 
    -0.10446274f, 0.21729951f, 0.17651190f, 0.05173429f, -0.07349283f, 0.22408867f, -0.40808368f, 0.14709719f, 
    0.34712830f, 0.46031526f, -0.08286100f, 0.21291868f, -0.07227178f, -0.36216161f, 0.15066357f, -0.64127362f, 
    0.06438404f, 0.13872072f, -0.08462409f, -0.89191955f, 0.20690285f, 0.06941684f, 0.05351781f, -0.21117069f, 
    -0.07120527f, -0.12146027f, 0.19347532f, 0.23174033f, -0.35464838f, 0.21243571f, 0.24621964f, 0.22214970f, 
    -0.06419552f, 0.11718804f, -0.03537546f, -0.43791929f, -0.12205330f, -0.15506059f, -0.41615018f, 0.14806710f, 
    0.04303963f, -0.25802216f, -0.02482729f, 0.29854363f, -0.45261899f, 0.41940728f, -0.09582734f, -0.00979950f, 
    0.22202033f, 0.12879719f, -0.13157766f, -0.12530634f, -0.09565482f, -0.20798072f, -0.33746439f, 0.13715291f, 
    0.00755554f, 0.17119813f, -0.23034331f, 0.03244138f, -0.21685186f, 0.21183854f, -0.21534547f, 0.05925485f, 
    -0.17033529f, 0.01149288f, 0.06158125f, -0.20791629f, -0.07317954f, 0.08860934f, -0.04805332f, -0.10577133f, 
    -0.19452326f, -0.09847123f, -0.07682627f, 0.18379007f, -0.13463119f, -0.22964147f, -0.22128740f, -0.15594925f, 
    0.01454759f, -0.21814471f, -0.11202297f, 0.09015259f, 0.01490018f, 0.15008137f, 0.19410656f, -0.10219906f, 
    -0.04143663f, 0.24782425f, 0.32098392f, 0.37172714f, -0.01706397f, -0.35048011f, 0.04644459f, -0.11898183f, 
    0.18888029f, -0.31404537f, 0.03007484f, -0.26632014f, -0.22093116f, 0.00090860f, 0.15026227f, 0.52009666f, 
    -0.44502112f, -0.04603602f, -0.11057960f, 0.30258733f, -0.76235980f, -0.20844445f, -0.03507238f, 0.23432325f, 
    -0.12638173f, 0.40012702f, -0.18937203f, 0.28386256f, 0.23437226f, 0.20619409f, -0.21504810f, -0.30701989f, 
    -0.24043688f, 0.19099469f, -0.26705748f, 0.04516152f, 0.65774387f, 0.15534197f, -0.22104114f, 0.27681553f, 
    -0.18165851f, 0.08612173f, -0.05835384f, -0.12168801f, -0.21599276f, 0.01995701f, 0.10392480f, -0.45014122f, 
    -0.27863371f, -0.07566813f, 0.06692340f, -0.22127119f, -0.00097158f, 0.54144770f, -0.38996977f, 0.30213809f, 
    -0.14035605f, 0.21775883f, 0.16754240f, 0.23336647f, 0.02295507f, -0.15727463f, 0.04260634f, -0.21109581f, 
    0.15578389f, -0.26602611f, 0.02751820f, 0.25677326f, -0.41079080f, 0.41054907f, -0.14598462f, 0.34914082f, 
    -0.19583912f, -0.01621405f, 0.05599700f, -0.00084904f, 0.18536572f, -0.17992921f, -0.04818290f, 0.70543009f, 
    -0.26000023f, 0.18550378f, 0.03673470f, -0.10263510f, 0.49161008f, -0.05139267f, 0.35652989f, 0.15852158f, 
    0.01297266f, 0.03029615f, -0.21556139f, 0.07999668f, 0.15296042f, 0.18722679f, 0.07960842f, -0.06775061f, 
    0.08154634f, -0.03466135f, 0.14639968f, -0.19638890f, 0.38703519f, 0.62694895f, -0.02258911f, 0.10796494f, 
    -0.11349687f, 0.14510874f, 0.01394369f, -0.40767139f, 0.18801571f, -0.23083815f, 0.36475492f, -0.03203278f, 
    -0.00002113f, 0.12842774f, 0.23816399f, 0.11244126f, -0.10014579f, -0.23826440f, -0.43528467f, -0.07805785f, 
    0.12642558f, 0.05164474f, 0.12016392f, -0.12725565f, -0.22189952f, 0.11921331f, 0.14297689f, -0.32822955f, 
    0.04506528f, -0.41555557f, 0.32480896f, 0.15506083f, 0.02401366f, -0.18180479f, -0.27502233f, -0.16366142f, 
    -0.02001922f, 0.07571061f, -0.22023492f, 0.00862512f, -0.16284795f, 0.00690828f, -0.05399674f, -0.50649959f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10739534f, -0.26875153f, -0.20526782f, -0.23322695f, 0.43772653f, 0.20151757f, 0.07106484f, -0.11164331f, 
    -0.03912417f, -0.23907778f, 0.01328484f, -0.05899649f, 0.41091201f, 0.06900422f, 0.06044516f, -0.03197490f, 
    -0.00615090f, -0.52107084f, 0.49004531f, 0.07624586f, -0.08981308f, 0.18207511f, 0.27756745f, 0.06759873f, 
    -0.08960576f, -0.12462316f, 0.54432923f, -0.02134415f, -0.04749788f, -0.00099131f, -0.26515299f, -0.23516876f, 
    0.00514693f, 0.27275848f, -0.21469055f, 0.10981382f, 0.27902660f, -0.10256913f, 0.50714308f, -0.01950018f, 
    0.53643090f, 0.12568417f, 0.33108145f, 0.20111966f, -0.13735430f, 0.17625393f, 0.35150582f, 0.20230840f, 
    -0.35171533f, -0.08834857f, 0.26020929f, 0.23869999f, 0.30542365f, -0.10621271f, -0.15300263f, -0.10240500f, 
    -0.16311875f, -0.02996065f, 0.51182085f, -0.02046704f, 0.06017847f, 0.56678134f, 0.45323643f, 0.40489927f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04526618f, -0.07293899f, -0.02305883f, -0.08422486f, 0.06824938f, 0.07902252f, -0.03154816f, -0.12398219f, 
    -0.05404712f, 0.07892981f, -0.04585202f, 0.09882937f, -0.10312311f, -0.12619723f, 0.03029745f, -0.03057931f, 
    0.08707981f, -0.14652485f, -0.05815187f, 0.06055992f, 0.06449530f, 0.04582892f, -0.09332324f, -0.08886977f, 
    -0.06358376f, 0.01833437f, 0.02590288f, -0.08167928f, -0.07149485f, -0.05065365f, -0.00595188f, -0.12873222f, 
    -0.11589468f, 0.03663266f, 0.04532129f, -0.08610924f, -0.10538295f, 0.09385625f, -0.03679846f, -0.15239093f, 
    0.07745633f, 0.00672222f, -0.13712448f, 0.02988068f, -0.04892804f, -0.01256497f, -0.03410166f, 0.02240411f, 
    -0.08438310f, -0.13339595f, -0.07441385f, -0.01892214f, -0.12624620f, 0.12017255f, -0.00003399f, 0.02446943f, 
    -0.10580610f, -0.05476555f, -0.02982985f, 0.08776169f, -0.12498783f, -0.11926312f, -0.08875241f, -0.03389333f, 
    0.01093870f, 0.00441139f, -0.00809066f, -0.09258055f, -0.26239517f, 0.18843676f, -0.01396484f, -0.11183801f, 
    -0.05521246f, 0.03445081f, -0.08289024f, -0.51756698f, 0.04051526f, -0.46687251f, 0.09402202f, 0.06884117f, 
    -0.11931305f, -0.06405446f, 0.05375482f, 0.03929573f, -0.34175441f, 0.07415199f, 0.13954943f, 0.00625077f, 
    0.18997997f, 0.38414642f, -0.00976039f, 0.28490728f, 0.21125910f, -0.09850363f, 0.17118160f, -0.10734614f, 
    0.08181986f, 0.12633196f, -0.06473622f, 0.09732626f, 0.34532976f, 0.07018076f, 0.29307687f, 0.02346756f, 
    -0.31648457f, -0.19847988f, 0.02118804f, 0.21926148f, -0.20054452f, 0.03006339f, 0.17164879f, 0.25074062f, 
    -0.20008446f, -0.22061226f, -0.68471086f, -0.04845499f, -0.12995483f, -0.04801136f, -0.06966347f, 0.08285394f, 
    -0.61258256f, 0.08313996f, 0.06051499f, 0.21782401f, -0.00515619f, 0.17921655f, -0.02672392f, 0.01111914f, 
    0.08858021f, 0.00431775f, -0.01357877f, 0.08508192f, -0.05235896f, -0.03985099f, 0.52946049f, 0.04431818f, 
    -0.19370191f, -0.08510858f, -0.08985712f, 0.23613830f, -0.00895877f, 0.16978741f, -0.30009073f, -0.23971687f, 
    0.04478699f, -0.08964498f, 0.12478875f, -0.11482493f, -0.36442417f, -0.17070873f, 0.08739449f, 0.00705445f, 
    0.04748586f, 0.41383210f, 0.18907203f, 0.43163881f, 0.08082002f, -0.08615226f, -0.00523206f, -0.09085936f, 
    -0.51111919f, -0.05318590f, -0.06942862f, 0.16542307f, 0.47884744f, -0.07466616f, -0.16260426f, 0.23164494f, 
    -0.24147737f, 0.34857222f, 0.15631466f, 0.32440981f, -0.38630766f, -0.21782154f, -0.65252894f, 0.27382037f, 
    -0.15580417f, 0.16894133f, -0.49119145f, 0.15381940f, 0.12902012f, 0.06816985f, -0.14427589f, 0.15990710f, 
    0.09651139f, -0.22823949f, -0.01576021f, 0.20718655f, 0.11403552f, -0.07194705f, -0.03848286f, 0.05300537f, 
    -0.07202370f, -0.29766741f, -0.05312268f, -0.14378792f, 0.01281272f, 0.03018786f, 0.32090423f, 0.03246596f, 
    -0.32332307f, -0.08778483f, 0.08844119f, 0.02621752f, 0.20197073f, 0.22280984f, -0.21585882f, -0.13131242f, 
    0.14689593f, -0.24701370f, 0.15207757f, -0.07948464f, -0.42496511f, 0.05945971f, 0.12898442f, 0.01777400f, 
    -0.28754058f, 0.01508391f, 0.45013547f, 0.37217370f, -0.01768984f, -0.04379623f, 0.22812358f, -0.39154911f, 
    0.24321222f, -0.05892683f, 0.00221024f, 0.05235695f, 0.24302493f, 0.13122103f, 0.38966396f, -0.12522703f, 
    0.29533169f, -0.12592840f, 0.13609740f, -0.41363940f, 0.22987065f, -0.33964646f, -0.47967067f, 0.32341960f, 
    0.00830260f, 0.05957157f, -0.22538531f, 0.17950247f, 0.36758319f, -0.02942535f, 0.07269153f, -0.29568440f, 
    0.10296596f, -0.19302559f, 0.27186003f, 0.10492529f, -0.34022212f, 0.11774392f, -0.02382563f, 0.31674659f, 
    0.02640032f, -0.04227125f, 0.10993937f, -0.05472968f, 0.05807740f, -0.05604004f, -0.06027813f, -0.12058337f, 
    0.00148802f, -0.03530823f, -0.01627837f, -0.13340157f, 0.06763693f, 0.07741717f, -0.02367477f, 0.09568519f, 
    -0.11004770f, -0.01779838f, -0.02868090f, 0.00769106f, 0.02718813f, -0.00541970f, -0.03636443f, 0.02220133f, 
    -0.01521044f, 0.05213179f, -0.10417456f, -0.00618698f, -0.04249795f, -0.05307546f, 0.10876714f, -0.03367301f, 
    0.01340989f, -0.02962024f, 0.09904830f, 0.08434403f, -0.13736014f, -0.02718343f, -0.00358316f, -0.08901679f, 
    -0.06538965f, -0.01612887f, -0.14862414f, 0.09495366f, -0.13736990f, -0.02632300f, -0.01154706f, 0.01101315f, 
    0.03280538f, -0.11639647f, 0.03779207f, -0.02639663f, 0.11049198f, -0.04748538f, -0.08587965f, -0.13823879f, 
    -0.08857390f, -0.09294467f, 0.07260484f, -0.03655619f, 0.00568622f, 0.04022868f, 0.00740788f, 0.03993285f, 
    -0.06812429f, -0.08988116f, 0.02222151f, 0.08442353f, 0.13979118f, -0.31505644f, 0.07975335f, 0.02889737f, 
    0.00463638f, -0.05390733f, 0.01980235f, -0.05833264f, -0.14563313f, 0.20826320f, 0.09575531f, 0.20358489f, 
    -0.61975545f, -0.11290401f, 0.26153553f, 0.05928574f, 0.02423650f, -0.56028056f, -0.21379726f, 0.10432953f, 
    0.16646127f, 0.06315801f, 0.17807044f, -0.07484736f, 0.22778746f, 0.10571417f, 0.29518804f, -0.01381749f, 
    -0.50831133f, 0.09843594f, 0.06405705f, 0.17267101f, 0.05563778f, -0.19929297f, -0.11794280f, 0.06831104f, 
    -0.30192453f, 0.25968742f, -0.05438925f, -0.50026518f, 0.13374750f, -0.30005351f, -0.44556925f, -0.16570607f, 
    0.07360271f, -0.09154529f, -0.14886115f, 0.02621674f, 0.15302995f, -0.06289425f, 0.02410954f, 0.21357082f, 
    -0.02212504f, -0.01085926f, -0.02719591f, 0.03907147f, 0.11894991f, -0.01513000f, -0.07607181f, -0.24567673f, 
    0.02297375f, -0.20706667f, -0.09744453f, -0.18885969f, -0.16722193f, 0.25215316f, 0.19020557f, -0.11030802f, 
    -0.06717052f, -0.05731851f, -0.10509025f, -0.18885829f, 0.17247336f, -0.41985500f, -0.50003463f, -0.20874278f, 
    0.37147680f, -0.24188039f, -0.04827713f, -0.01969127f, -0.52465439f, -0.03529967f, 0.18669794f, -0.09621213f, 
    0.05344187f, 0.30069774f, 0.14973906f, 0.23799126f, 0.03060977f, 0.05051464f, 0.07375121f, -0.53624833f, 
    0.16131923f, 0.12090417f, 0.07926193f, 0.01649592f, 0.19170520f, 0.05932395f, 0.48126221f, 0.03050484f, 
    0.15307000f, -0.23656467f, -0.15532340f, 0.39382344f, -0.23454873f, 0.39690113f, -0.04957968f, 0.14434230f, 
    -0.66405529f, 0.13903563f, -0.37536284f, 0.13526301f, 0.08151206f, 0.12485036f, 0.00367571f, 0.02519130f, 
    -0.06890331f, -0.37936690f, -0.04535787f, 0.10031873f, -0.45948336f, -0.05763862f, -0.01382536f, 0.13919528f, 
    0.00344201f, 0.11286714f, 0.03284329f, -0.05912160f, -0.02049197f, -0.48516807f, -0.02976085f, -0.01022609f, 
    -0.11943261f, -0.00946575f, 0.04832396f, -0.11795459f, -0.11016247f, -0.41094118f, 0.12941994f, 0.13999365f, 
    0.09407437f, -0.11921995f, -0.58051234f, 0.09667520f, 0.04515694f, 0.42403212f, -0.11217541f, 0.07370280f, 
    0.09960201f, 0.01332999f, 0.22627716f, -0.14438409f, 0.06662350f, 0.12303287f, -0.29426619f, 0.03083136f, 
    0.22293727f, -0.00214870f, -0.02813981f, 0.03450990f, -0.03808247f, 0.00994988f, -0.39254034f, 0.13343430f, 
    -0.18213941f, -0.19805184f, 0.06352121f, 0.66088468f, 0.26151603f, -0.14323625f, 0.11734457f, -0.33374226f, 
    0.14522807f, 0.23446667f, -0.38781053f, -0.08835757f, -0.00226988f, 0.00046602f, -0.10639893f, 0.15985082f, 
    0.10079673f, 0.16726750f, 0.08843724f, -0.01463466f, -0.02151660f, 0.00914076f, 0.01640489f, -0.27712134f, 
    0.01330395f, -0.16826363f, -0.12394652f, -0.17739387f, 0.16668300f, 0.19137104f, 0.25366193f, 0.07890058f, 
    -0.36213949f, -0.00947097f, 0.08422507f, 0.05712209f, -0.05430038f, 0.46014336f, 0.18872574f, 0.08923616f, 
    0.14415020f, 0.06779847f, 0.12519613f, 0.04475462f, -0.04529620f, 0.07541484f, -0.26131874f, 0.07706934f, 
    -0.22955978f, -0.16745490f, 0.38515827f, 0.29147038f, 0.17801563f, 0.02537440f, 0.36644641f, 0.17431465f, 
    -0.16271719f, 0.15778179f, -0.08972183f, 0.06507157f, 0.00374428f, -0.00574101f, -0.35425320f, -0.14964019f, 
    0.12013577f, 0.18543476f, -0.00417504f, -0.25213689f, 0.44346997f, -0.40904489f, -0.39407814f, -0.01285683f, 
    0.00291084f, 0.15479344f, -0.22407858f, 0.15439498f, 0.27725902f, 0.11032663f, 0.11692800f, -0.10795119f, 
    -0.13615148f, 0.71592045f, 0.01534044f, 0.05486760f, 0.02220489f, 0.03957430f, -0.15563589f, -0.20062695f, 
    0.03526593f, -0.15763360f, -0.09922974f, 0.02470626f, 0.17107542f, -0.19878574f, -0.18903838f, -0.07559706f, 
    0.14686587f, 0.00369836f, 0.06658421f, 0.14694943f, -0.47600183f, -0.60270971f, 0.04186019f, -0.09365128f, 
    0.12220627f, -0.21076737f, -0.43622932f, -0.13474986f, -0.04228681f, -0.35899734f, -0.15776086f, -0.06465922f, 
    0.08141004f, 0.00761491f, 0.27413794f, -0.05488422f, 0.10285255f, -0.04199228f, -0.34811258f, -0.06484130f, 
    0.36804283f, 0.10782283f, 0.07990039f, 0.18372817f, 0.26104194f, -0.30843464f, -0.11884433f, 0.06151221f, 
    0.11991819f, 0.16380383f, 0.07247344f, 0.83469790f, -0.02998064f, 0.82334656f, 0.74319315f, -0.17693512f, 
    0.01504905f, -0.54552108f, 0.32470971f, 0.16202192f, -0.00087334f, -0.00299735f, 0.00837328f, 0.18512446f, 
    0.13193415f, -0.03809713f, 0.16647671f, 0.21688046f, 0.09306005f, 0.13679023f, 0.21994194f, -0.05094935f, 
    0.13691874f, -0.08428940f, 0.14977404f, 0.11694694f, 0.11402213f, -0.05875310f, -0.01519415f, 0.03644711f, 
    0.14488426f, 0.05926368f, 0.06791010f, -0.02617959f, 0.10924499f, -0.33808973f, -0.15925671f, 0.18197446f, 
    0.03753737f, 0.14381644f, -0.38937008f, -0.24646868f, -0.06274487f, 0.04425200f, -0.20850407f, -0.02478752f, 
    0.25966853f, 0.04728487f, 0.15444729f, 0.40393984f, 0.32547659f, -0.06579502f, 0.23923168f, 0.05996790f, 
    0.13143228f, 0.16188113f, 0.02342135f, -0.08825625f, -0.01066718f, -0.00336338f, -0.17559844f, 0.08128332f, 
    0.02352533f, -0.27830547f, 0.17279948f, 0.70594037f, 0.11241847f, 0.41386691f, 0.14174615f, -0.07386443f, 
    0.12640427f, -0.01434150f, -0.41035107f, 0.19862135f, -0.05055987f, -0.01249488f, 0.02212213f, 0.13185279f, 
    -0.07763872f, -0.05037377f, -0.11292339f, 0.25520054f, 0.18842947f, 0.11354071f, -0.08478813f, -0.27448222f, 
    0.02081114f, -0.14728700f, 0.07940656f, -0.07128304f, -0.10801728f, 0.07454439f, -0.06055787f, -0.00215791f, 
    -0.14951922f, 0.07880233f, 0.07536522f, 0.00901150f, -0.00630007f, -0.17090456f, -0.12061678f, 0.05274572f, 
    0.06756445f, -0.02424818f, -0.06349689f, -0.10650717f, -0.07368615f, 0.01476298f, -0.15911920f, -0.01697142f, 
    -0.05165467f, 0.05476265f, -0.03010078f, -0.06084821f, 0.08697104f, 0.06449786f, -0.09804338f, -0.16767517f, 
    -0.07751084f, -0.02515693f, -0.06111868f, -0.07791651f, -0.09636191f, -0.01982370f, -0.16210617f, 0.00396670f, 
    0.01309663f, -0.03012046f, -0.12872039f, -0.04721278f, 0.01795886f, -0.01707326f, 0.05767386f, -0.16211274f, 
    -0.10619330f, -0.15661582f, 0.11426303f, 0.02307074f, 0.08667015f, 0.06258564f, 0.00661281f, -0.12342279f, 
    0.09362641f, -0.12628587f, -0.02919427f, 0.00199790f, 0.09733046f, -0.10649239f, 0.07455743f, -0.01547253f, 
    -0.09817105f, -0.11302663f, -0.05319744f, -0.02386123f, -0.01736635f, 0.09525602f, -0.12127376f, 0.07980552f, 
    -0.09124198f, -0.03620125f, -0.03904517f, -0.07468912f, 0.00126955f, 0.06620173f, -0.13088603f, -0.03812449f, 
    0.05797758f, -0.05525678f, -0.08349236f, 0.02823000f, -0.04165547f, 0.05163013f, -0.01496081f, -0.06851444f, 
    0.07886770f, -0.14948404f, 0.09330174f, -0.02516936f, -0.02262419f, 0.03133555f, 0.05590228f, -0.11477009f, 
    -0.04497131f, -0.07259501f, 0.00213014f, -0.06460306f, -0.08425867f, 0.11348781f, -0.08309812f, -0.08182631f, 
    -0.09729302f, 0.09625750f, 0.02518759f, 0.04660575f, 0.02906911f, 0.01786603f, 0.03049676f, -0.05879351f, 
    -0.15133125f, -0.09718651f, -0.08556505f, 0.00159011f, -0.09246526f, -0.03670749f, -0.05685176f, -0.14455964f, 
    -0.08540779f, 0.02922897f, 0.00675626f, -0.04313257f, 0.08338834f, -0.09897304f, -0.08399347f, -0.05799935f, 
    0.15919185f, 0.10287685f, -0.01805289f, -0.22158426f, -0.08065077f, 0.05580023f, -0.29862440f, 0.01495224f, 
    0.21542852f, 0.11315639f, -0.04464440f, -0.26611966f, 0.09152946f, -0.28079760f, -0.08562267f, 0.10348772f, 
    -0.12597917f, -0.09203137f, 0.03981120f, -0.13681714f, 0.01728274f, -0.00725542f, 0.14485809f, 0.01353294f, 
    0.31258348f, 0.29721355f, -0.18580697f, -0.13898048f, 0.09401087f, -0.08532977f, -0.08210908f, -0.05608024f, 
    -0.05465920f, 0.15164861f, -0.03475453f, 0.09057014f, 0.19319467f, 0.19819130f, 0.48827595f, 0.09024854f, 
    -0.38992962f, 0.17097661f, -0.18406186f, -0.10767883f, -0.41309747f, 0.16432853f, 0.45274824f, 0.14120504f, 
    -0.35849684f, -0.20945156f, -0.52835530f, -0.05722225f, -0.26924565f, 0.03265166f, 0.12047081f, 0.21399117f, 
    -0.38310066f, 0.19109827f, -0.00487247f, -0.05970847f, 0.18458158f, 0.12268509f, 0.03232927f, 0.09618326f, 
    -0.06286115f, -0.44068494f, -0.02858735f, -0.13511476f, -0.17013767f, 0.28968990f, 0.08049640f, -0.07855585f, 
    0.06387972f, 0.06122847f, -0.11985214f, 0.00714619f, 0.29014471f, -0.22165902f, -0.22861154f, -0.55224830f, 
    0.28615439f, -0.47266519f, 0.27011746f, 0.02563608f, -0.06036462f, -0.19099531f, 0.19866902f, 0.03102893f, 
    -0.49614537f, -0.18698916f, 0.15515834f, 0.20065667f, -0.04799053f, 0.00896452f, 0.10818876f, -0.52780092f, 
    0.24921907f, 0.04852627f, -0.03024308f, 0.05852798f, 0.08777369f, 0.35191631f, 0.33269271f, -0.25308147f, 
    0.54671133f, -0.30635712f, -0.04030948f, 0.22413309f, -0.20687386f, 0.27124640f, 0.08332805f, 0.20803310f, 
    -0.51152879f, -0.17635822f, 0.27953914f, 0.14920050f, 0.15979575f, -0.02729113f, 0.06649122f, -0.11132305f, 
    -0.16840684f, -0.48059767f, 0.04859332f, -0.06708296f, -0.58614582f, 0.07539359f, -0.03795122f, 0.40007743f, 
    -0.12703016f, 0.07245336f, -0.01644780f, -0.00641259f, -0.08235073f, 0.06326431f, 0.06133835f, -0.05333951f, 
    -0.09236313f, -0.05184829f, -0.11921005f, 0.04561572f, -0.19686128f, -0.04782642f, -0.15453607f, -0.12196565f, 
    -0.10248005f, 0.03292465f, 0.01717388f, -0.11467701f, -0.05514476f, -0.07489532f, 0.06294671f, -0.00256734f, 
    -0.00728033f, 0.02683492f, -0.14632863f, -0.17206088f, -0.07979053f, -0.09555759f, 0.02739239f, -0.08038431f, 
    -0.18073489f, 0.03659948f, 0.10203861f, -0.12784190f, -0.11740696f, -0.07756633f, 0.07314926f, 0.01340029f, 
    -0.14608712f, 0.00920190f, -0.12073004f, -0.10135262f, 0.07551546f, 0.08461756f, -0.02891435f, -0.07076851f, 
    -0.00371589f, -0.05455178f, 0.05431324f, -0.01158602f, 0.09163790f, 0.02159111f, -0.07933566f, 0.04200862f, 
    0.06823079f, 0.06199645f, 0.05536285f, -0.14010020f, 0.06989977f, -0.08798018f, -0.14173020f, -0.12605116f, 
    -0.00019326f, -0.12405016f, 0.02827860f, -0.05814372f, -0.06110767f, 0.02044791f, -0.10063880f, -0.07467350f, 
    -0.15071456f, -0.12457749f, -0.08783400f, -0.22080036f, -0.05069138f, -0.14548354f, 0.50740927f, 0.05340300f, 
    -0.01661691f, -0.45023820f, 0.10550760f, 0.30964589f, -0.23702510f, 0.33735856f, -0.01372373f, 0.11233278f, 
    0.19379179f, 0.12576345f, 0.13201791f, 0.36598679f, 0.13670196f, -0.00359082f, 0.17321323f, -0.23271385f, 
    0.14352795f, 0.24589509f, -0.09659698f, -0.11262845f, 0.18342079f, 0.09518238f, 0.14494953f, -0.03019339f, 
    -0.01643712f, 0.25371554f, 0.16527115f, 0.10941136f, 0.11945748f, -0.02696043f, -0.06650789f, 0.16968378f, 
    -0.25181308f, -0.26415414f, -0.71810812f, -0.03458061f, 0.14446183f, -0.08698896f, -0.08630133f, 0.12398323f, 
    -0.58635455f, 0.24150771f, 0.10863205f, 0.11942434f, -0.03235554f, 0.12577029f, -0.10151909f, 0.06238585f, 
    0.07906632f, 0.37028795f, -0.09363827f, 0.08615297f, -0.23389308f, 0.09504846f, -0.10231198f, -0.02683130f, 
    0.18980375f, 0.08628143f, -0.09659187f, -0.16613840f, 0.41902217f, -0.12299319f, -0.34580535f, -0.30434114f, 
    -0.08130471f, -0.12119641f, 0.13931052f, -0.08100757f, -0.19641212f, 0.10806977f, 0.32178476f, -0.03188927f, 
    -0.05178718f, 0.15690787f, -0.25569746f, 0.06511740f, -0.06397977f, 0.11051522f, -0.09456793f, -0.08684569f, 
    -0.00088369f, 0.01641098f, -0.03297070f, 0.16925603f, -0.11602694f, 0.33181202f, 0.55775332f, -0.20883590f, 
    0.11719120f, -0.57866448f, -0.03302399f, -0.03008793f, -0.36307603f, 0.09459746f, 0.12703629f, 0.16913457f, 
    -0.03128184f, 0.11102404f, -0.05944035f, 0.05312297f, 0.03412270f, -0.02977833f, 0.10878647f, -0.18983877f, 
    0.08181114f, -0.63411295f, -0.00584214f, 0.09380564f, -0.21302095f, 0.06915982f, 0.19374077f, 0.35203204f, 
    -0.09222587f, 0.12467097f, -0.06614603f, -0.09903691f, -0.21624058f, 0.15631524f, 0.05098486f, -0.04086658f, 
    -0.18132913f, -0.00384569f, 0.02410167f, -0.09738833f, 0.10775641f, -0.16296658f, 0.20246860f, 0.03836796f, 
    0.11961379f, -0.23137556f, 0.20525435f, 0.22483814f, -0.02486725f, 0.30376449f, -0.03743448f, -0.00892410f, 
    0.18003128f, 0.10026211f, -0.06620996f, 0.12187020f, 0.03293177f, 0.05659993f, 0.28574619f, -0.02716267f, 
    -0.20627227f, 0.16027415f, -0.03654765f, 0.03624817f, 0.26910713f, 0.12987135f, 0.23234920f, -0.05051945f, 
    -0.12090820f, 0.17014146f, -0.03017880f, 0.05971305f, -0.07589354f, -0.15895304f, -0.52408564f, 0.10452764f, 
    -0.06295104f, -0.07654683f, -0.55761713f, -0.14489202f, -0.16869253f, -0.12052466f, -0.05824722f, 0.03260945f, 
    -0.44933489f, 0.25262094f, 0.08850174f, -0.03286715f, 0.10182085f, 0.18159574f, -0.02347917f, 0.25280803f, 
    -0.06419871f, 0.23569575f, -0.00325407f, -0.07933544f, -0.12134226f, 0.18620355f, -0.03694727f, -0.02950411f, 
    0.12699665f, 0.05206455f, -0.02848409f, -0.10197418f, 0.19041567f, 0.40851086f, -0.55010253f, -0.11911289f, 
    0.18636343f, 0.10841689f, 0.24644718f, -0.13485791f, 0.51416469f, 0.34686831f, 0.25587395f, 0.03339504f, 
    -0.16411221f, -0.40202570f, -0.11428116f, -0.13317618f, -0.50051004f, 0.10907036f, 0.13296472f, 0.36027595f, 
    0.06371961f, -0.14506587f, 0.04588589f, -0.08726339f, 0.14315400f, 0.07495952f, 0.19529784f, -0.01186407f, 
    0.20062684f, -0.53001899f, -0.13699710f, -0.75654840f, 0.02745966f, -0.20546433f, -0.15180850f, 0.16067810f, 
    0.18057504f, 0.13944679f, 0.40674591f, -0.03956281f, -0.11112077f, 0.06421532f, -0.03884446f, -0.66636425f, 
    -0.02617695f, 0.75042963f, 0.16031034f, -0.46301007f, 0.15693985f, 0.23949194f, 0.14384256f, 0.22992836f, 
    0.07824433f, 0.10211672f, -0.06170779f, 0.04799853f, 0.02815641f, 0.01469589f, -0.10817437f, 0.10355696f, 
    0.27424371f, -0.04772022f, -0.02617647f, -0.10722483f, 0.02673372f, 0.09904291f, 0.00490768f, 0.15569256f, 
    -0.12940283f, 0.13958931f, -0.06867044f, 0.03666300f, 0.52295071f, 0.20513748f, 0.18496497f, -0.10265133f, 
    0.02923778f, -0.22323553f, 0.00466185f, -0.23392951f, 0.06868898f, -0.02765878f, 0.16727541f, 0.36496362f, 
    0.45414454f, 0.13243669f, -0.03461568f, -0.12959602f, -0.05079069f, -0.10890552f, 0.06187418f, 0.01226124f, 
    0.03547747f, 0.31984964f, -0.15545499f, 0.12084202f, 0.17838393f, 0.56560552f, 0.86507338f, -0.06047253f, 
    -0.06494112f, -0.09968601f, 0.63206851f, -0.10079161f, -0.14934500f, 0.03383224f, 0.02216566f, 0.00509518f, 
    -0.09924991f, 0.65747666f, 0.02243076f, -0.20100443f, 0.17168270f, 0.21933758f, 0.10600140f, -0.07460787f, 
    0.02194144f, -0.01124883f, -0.00077563f, -0.26096010f, 0.06784105f, 0.18388885f, 0.29741982f, -0.02404301f, 
    -0.23119748f, -0.02183233f, -0.08716124f, -0.07055674f, 0.02529399f, 0.02807254f, -0.03806052f, -0.03297875f, 
    0.08205523f, -0.13135524f, 0.00754888f, 0.12627226f, -0.00155684f, 0.25986132f, 0.18627249f, 0.09999204f, 
    0.11821131f, 0.37385854f, 0.33201644f, 0.28672412f, -0.01414504f, -0.05215627f, -0.00371717f, -0.04057575f, 
    -0.40192717f, 0.07211436f, 0.03797594f, -0.22076157f, 0.53151530f, -0.13503674f, 0.11459122f, 0.08461265f, 
    -0.10997014f, 0.19022435f, 0.08656397f, 0.12025773f, -0.10708034f, -0.31700629f, -0.59298760f, 0.09097702f, 
    -0.31896973f, 0.20185815f, -0.55526137f, -0.00091218f, -0.11255980f, 0.06504714f, -0.12342096f, 0.04664669f, 
    -0.14624186f, 0.59766674f, 0.13442333f, 0.03514792f, -0.04053924f, 0.09701476f, 0.13083123f, -0.03714842f, 
    0.01670024f, -0.14252146f, 0.02751826f, -0.15032770f, -0.06569606f, 0.04233259f, -0.10218381f, -0.08035877f, 
    -0.09008403f, 0.11121728f, -0.07520460f, 0.04386530f, 0.04530954f, -0.09392947f, -0.10596412f, 0.04518535f, 
    -0.07091376f, -0.02530283f, 0.04366657f, 0.11571283f, 0.05864051f, 0.08969738f, -0.03462826f, 0.05915792f, 
    -0.08867422f, -0.09096439f, -0.14736299f, 0.02222223f, 0.07256029f, 0.00054225f, 0.04786299f, -0.15180193f, 
    -0.06416579f, -0.13057986f, 0.08965491f, -0.00086565f, -0.05857610f, 0.10979547f, -0.13792951f, -0.00575059f, 
    -0.08551911f, 0.10116053f, -0.11063199f, -0.11974648f, 0.04479021f, -0.02828419f, -0.12081173f, -0.03741312f, 
    -0.15101458f, -0.11460929f, 0.09503871f, 0.06893893f, -0.07189575f, -0.05178425f, 0.00567546f, 0.04946909f, 
    0.06901921f, 0.09842573f, 0.02265800f, -0.06964527f, -0.04902593f, -0.15570474f, -0.03430080f, -0.05307712f, 
    0.12667540f, -0.15672287f, -0.08091159f, -0.03000077f, 0.02031784f, 0.04861261f, -0.17501506f, -0.04445948f, 
    -0.02571671f, 0.00940970f, 0.09753042f, -0.09872471f, 0.04737531f, -0.36945230f, -0.19050165f, -0.04986154f, 
    -0.10156107f, -0.18302049f, -0.08801910f, 0.10794846f, 0.00264393f, 0.00920831f, 0.09447858f, -0.00742710f, 
    -0.11998972f, 0.03000727f, 0.09900111f, 0.04633213f, 0.14615682f, -0.01024780f, -0.05949466f, -0.12084947f, 
    0.44999635f, 0.00019652f, 0.04489467f, 0.13809024f, 0.18920891f, 0.12288390f, 0.20354317f, 0.09595019f, 
    0.22793622f, -0.26290524f, 0.22791640f, 0.56369758f, -0.24250180f, 0.31354114f, 0.68179321f, -0.10773242f, 
    -0.09872236f, -0.19037707f, -0.27984476f, 0.14531924f, 0.06742740f, 0.08913168f, 0.06184306f, 0.11193817f, 
    -0.06232503f, -0.50331861f, 0.20616956f, -0.02262134f, 0.06361742f, 0.07210580f, 0.00019979f, 0.12792559f, 
    0.06945333f, 0.06545114f, -0.04986589f, -0.11707474f, -0.08603653f, 0.19937739f, 0.33317873f, -0.08409925f, 
    0.00629874f, 0.01949207f, 0.04272234f, -0.20473129f, 0.30421472f, 0.29858771f, -0.09727564f, -0.09269363f, 
    0.28487879f, 0.18173729f, 0.28074628f, -0.20755394f, 0.36626238f, 0.50019765f, 0.26863801f, 0.07958612f, 
    -0.07268281f, -0.01397436f, 0.08952868f, 0.19858018f, -0.23423634f, -0.00751850f, 0.09085590f, 0.16982614f, 
    -0.27763849f, 0.03817409f, 0.10912807f, -0.12760231f, 0.22467464f, 0.18456829f, 0.23477684f, -0.11478796f, 
    -0.15280047f, -0.61860704f, 0.05145237f, -0.65024215f, 0.24453212f, -0.36125553f, -0.79067820f, 0.30771738f, 
    -0.07481542f, 0.36828464f, -0.26944971f, -0.11665078f, 0.15679474f, 0.02035850f, 0.03334118f, -0.58670056f, 
    0.01221329f, 0.93285096f, 0.00412298f, -0.15541449f, -0.06079917f, 0.05267880f, -0.00244252f, 0.27930164f, 
    0.06835817f, -0.14561240f, -0.02700118f, -0.23010384f, -0.22400376f, 0.25383329f, -0.09558336f, -0.08453263f, 
    0.16571115f, -0.11448643f, 0.08626474f, -0.38718173f, 0.03643025f, -0.45119298f, 0.00292377f, -0.04165279f, 
    0.21494463f, -0.22041886f, -0.07217292f, -0.09184629f, -0.28832138f, -0.15285808f, -0.05965888f, -0.09526733f, 
    0.09921654f, 0.21418963f, -0.00861143f, 0.39871186f, 0.15092352f, 0.02715898f, 0.20657912f, -0.45126477f, 
    0.53389066f, 0.14158884f, 0.06773853f, 0.21721894f, -0.10485350f, 0.12848441f, 0.46441790f, -0.24488275f, 
    0.16526729f, -0.17927590f, -0.06096543f, 0.35347068f, -0.10470679f, 0.56637883f, 0.54775274f, 0.16238475f, 
    -0.16142260f, -0.22079040f, -0.07133576f, -0.06254332f, 0.22590867f, 0.02585572f, -0.02524025f, 0.14968133f, 
    -0.22605085f, -0.58610439f, -0.07496665f, 0.23837431f, -0.11050458f, -0.02929607f, -0.00920182f, 0.13365063f, 
    0.03527108f, 0.00224434f, 0.06068688f, 0.10920784f, -0.09107815f, 0.08265673f, -0.32918268f, -0.04292704f, 
    0.31796882f, 0.05920187f, -0.10743268f, -0.07189848f, 0.11376408f, 0.00001628f, -0.02131491f, -0.22202687f, 
    -0.11318764f, 0.00230620f, 0.29439777f, -0.13172178f, 0.11605111f, 0.02311778f, -0.01447156f, 0.10501210f, 
    -0.13436462f, -0.38119504f, -0.15336661f, -0.26837480f, -0.07355441f, -0.04147302f, -0.04500646f, -0.18761466f, 
    0.56296653f, 0.12301278f, 0.01048265f, 0.21032919f, -0.18808779f, 0.29130787f, 0.23367229f, -0.34102032f, 
    0.26746267f, -0.00663094f, -0.00022890f, 0.24594474f, -0.17714554f, 0.35806674f, 1.06081975f, -0.16464940f, 
    0.09750601f, -0.15906987f, 0.34615698f, 0.12047046f, 0.27816036f, -0.04940455f, 0.07191706f, -0.02647686f, 
    0.11661914f, -0.34712371f, 0.07422005f, -0.07787033f, -0.02575170f, -0.00760251f, 0.14596963f, 0.17122781f, 
    -0.12387890f, -0.01999554f, -0.10503076f, -0.10979201f, -0.00592966f, -0.03745559f, -0.11686850f, 0.09410994f, 
    -0.04335637f, -0.08359405f, -0.08740665f, -0.04428829f, -0.04554496f, 0.06368107f, 0.04410419f, 0.04176514f, 
    0.11805230f, -0.14534684f, -0.01911773f, 0.08029881f, -0.09254798f, -0.05960764f, 0.08500157f, 0.00769025f, 
    -0.14495152f, -0.03576487f, -0.03763865f, 0.09005333f, -0.03008114f, 0.07391988f, 0.08179229f, -0.07720573f, 
    0.07869790f, -0.10703100f, -0.04147524f, 0.07494365f, -0.02308456f, 0.01270872f, -0.01760564f, 0.04156186f, 
    0.02334132f, -0.12072214f, 0.04268013f, 0.04864263f, -0.03428108f, -0.04239845f, 0.00646071f, -0.06307936f, 
    -0.06353372f, 0.00620788f, 0.06796186f, -0.13881987f, -0.14019716f, -0.07518800f, -0.02722351f, 0.09633391f, 
    -0.02590455f, -0.01140837f, -0.05021832f, -0.14661679f, -0.13328311f, -0.12285940f, 0.01304973f, -0.03878100f, 
    -0.12812200f, 0.20879930f, 0.07488903f, -0.18314359f, -0.53180546f, 0.30868727f, 0.05377223f, 0.11555931f, 
    0.43757048f, 0.05437325f, -0.08224231f, 0.03207332f, 0.03247326f, -0.02601044f, 0.00500094f, -0.10402099f, 
    0.17863701f, 0.27500317f, 0.07188627f, 0.12374101f, 0.39089760f, 0.26432881f, 0.19336508f, 0.05036996f, 
    0.20864078f, 0.40902588f, -0.49167386f, -0.21289055f, -0.04208941f, -0.01024629f, 0.20069902f, 0.22625597f, 
    0.25359836f, -0.07050556f, 0.06072824f, -0.22718008f, -0.07570357f, 0.06246398f, 0.04979845f, -0.15981019f, 
    -0.14412680f, 0.05226089f, -0.48862058f, 0.27976105f, -0.50881189f, 0.33116183f, 0.58648390f, 0.13568614f, 
    -0.04020217f, 0.06599066f, 0.69163704f, -0.03348086f, -0.42749056f, 0.08393805f, 0.05941792f, 0.32862756f, 
    0.17432484f, 0.34300107f, -0.40917936f, -0.27600542f, 0.07522372f, -0.03003889f, -0.02071708f, 0.21275330f, 
    0.20077297f, -0.15658890f, -0.03998218f, 0.08659040f, 0.00543249f, -0.05305521f, 0.34093440f, -0.05166726f, 
    0.12746181f, 0.00640908f, -0.05174001f, -0.04389454f, -0.29076767f, -0.96313035f, 0.06882006f, -0.12680033f, 
    -0.47867772f, -0.27190661f, -0.60536742f, -0.18168953f, -0.72132194f, 0.27971831f, 0.05840672f, -0.03148109f, 
    0.05455361f, 0.31749898f, 0.04250804f, 0.07030089f, 0.30220741f, -0.04891562f, -0.60968852f, -0.01861603f, 
    0.00925324f, 0.24360551f, -0.08484596f, 0.12685902f, 0.11109659f, -0.18457346f, 0.13654877f, 0.06764783f, 
    -0.57184660f, 0.31916559f, 0.13954383f, 0.58980560f, -0.09531223f, 0.63835764f, 0.26371053f, 0.05176905f, 
    -0.23467450f, -0.12101348f, -0.30383813f, 0.06527091f, 0.04340305f, 0.10947278f, 0.08271215f, 0.22025418f, 
    0.08672100f, -0.08180657f, 0.05523374f, 0.28131798f, -0.18668781f, -0.03465336f, 0.10653029f, -0.14953238f, 
    0.00056910f, -0.58637613f, 0.00044942f, -0.17398362f, 0.23340535f, -0.00990191f, 0.25018454f, -0.04315120f, 
    -0.06830383f, -0.06909512f, -0.01116992f, 0.15245977f, 0.07831693f, -0.43619186f, -0.24311239f, -0.12281941f, 
    -0.35873368f, -0.39820373f, -0.13245364f, -0.15584613f, -0.73107147f, 0.03887605f, -0.18468061f, 0.07637192f, 
    -0.12890966f, 0.14391994f, 0.35539451f, 0.41434807f, 0.24394779f, 0.04375640f, 0.02172229f, -0.57984394f, 
    -0.04484444f, 0.15542315f, -0.06113866f, -0.00236642f, 0.02031991f, -0.01083095f, -0.24638297f, 0.07014961f, 
    0.27512050f, 0.15717024f, 0.10223620f, 0.93869263f, -0.10387930f, 0.25571945f, -0.30548555f, 0.12595932f, 
    -0.18316416f, 0.06332158f, -0.63045937f, 0.13368358f, 0.26039067f, 0.05418500f, 0.10481782f, 0.08308581f, 
    -0.12951335f, -0.47648713f, -0.32837743f, 0.30102235f, -0.22617701f, -0.10576397f, 0.00084907f, -0.06569239f, 
    0.02267952f, -0.03314478f, -0.00610378f, 0.03987728f, 0.06481371f, -0.02630476f, 0.00235309f, 0.10118081f, 
    0.34812149f, -0.06566934f, -0.01745523f, 0.01402111f, 0.16112749f, -0.30186713f, -0.29409957f, -0.03388847f, 
    -0.16923083f, 0.23067227f, -0.21021324f, -0.16103983f, 0.11252162f, 0.00571829f, 0.22089490f, -0.00414126f, 
    0.10417133f, 0.30723420f, -0.26186720f, -0.33852828f, 0.04892179f, 0.01402870f, -0.08455260f, 0.09379084f, 
    0.01864070f, 0.13452855f, -0.05888481f, 0.00692212f, 0.06163746f, 0.00186387f, 0.09756096f, 0.15433706f, 
    -0.38870659f, -0.13869698f, -0.10366412f, 0.71165991f, -0.13685694f, 0.52217102f, 0.57314181f, 0.10854302f, 
    0.01697618f, 0.11661594f, 0.32914254f, 0.18010104f, -0.21206091f, 0.05436954f, -0.12912709f, 0.34012279f, 
    0.11261301f, -0.09228095f, -0.18737981f, -0.05969492f, 0.05193909f, 0.09979559f, 0.10851520f, 0.10611359f, 
    0.04260451f, -0.13282633f, 0.09230976f, -0.13136622f, -0.13984162f, 0.11003507f, 0.02048997f, 0.03651448f, 
    -0.04131874f, -0.12410262f, 0.00991522f, -0.10275007f, -0.05507490f, 0.03368847f, 0.08392305f, 0.04669550f, 
    0.08319101f, -0.10420499f, -0.09400181f, -0.00218565f, 0.07973675f, 0.09650053f, 0.02272741f, -0.02595931f, 
    -0.01987901f, 0.03186025f, -0.04643565f, 0.04544630f, -0.06902856f, 0.12005441f, 0.08360864f, -0.02282742f, 
    0.02273415f, -0.11724903f, -0.01751357f, 0.02388434f, -0.09217167f, -0.03981792f, -0.07270852f, 0.03491858f, 
    -0.04572833f, 0.09504962f, -0.09926562f, -0.04137674f, -0.13631415f, -0.10478587f, -0.05714904f, -0.12502694f, 
    0.05267112f, -0.14293440f, 0.08030023f, -0.02468509f, -0.01716666f, 0.11889824f, 0.11381787f, 0.08650551f, 
    -0.02342378f, 0.10476376f, -0.05255345f, -0.01562546f, -0.13647982f, -0.05752971f, -0.00436242f, 0.08114690f, 
    0.11045080f, 0.18870763f, -0.04237642f, 0.27827570f, 0.05973800f, 0.31435382f, 0.65868312f, 0.09562911f, 
    0.12750882f, 0.00789100f, 0.10372121f, 0.10990840f, 0.49877656f, 0.31575251f, 0.03959135f, -0.16463496f, 
    0.09358903f, -0.00840834f, 0.21308063f, 0.06512017f, 0.23184428f, 0.21194728f, 0.49911755f, 0.05497919f, 
    -0.22917736f, 0.27891976f, 0.02345807f, 0.10463174f, -0.02397528f, 0.00781883f, -0.17926906f, -0.08709372f, 
    -0.62157536f, -0.00071307f, -0.10258505f, 0.09663405f, 0.00360734f, 0.26930413f, 0.04722030f, 0.11567591f, 
    -0.35473901f, 0.31181011f, -0.06285642f, 0.07898328f, -0.07572613f, 0.12504551f, -0.71406376f, 0.31829137f, 
    -0.09220602f, 0.84052229f, 0.76228130f, 0.00224924f, 0.09218775f, -0.01907188f, -0.01230004f, 0.11929078f, 
    0.13494480f, -0.09486170f, -0.21174784f, -0.04964239f, -0.15834494f, -0.13020602f, 0.25729719f, 0.33600566f, 
    -0.12476869f, 0.07164910f, -0.08711992f, -0.20436528f, -0.10039256f, 0.24680789f, 0.23042573f, -0.11573450f, 
    0.20071155f, 0.05818324f, 0.06159807f, -0.13876005f, 0.19975391f, 0.02214841f, -0.39096102f, 0.26835027f, 
    0.11335577f, 0.20618550f, 0.19050129f, 0.06472175f, 0.26187021f, 0.30332074f, 0.11336637f, -0.05528115f, 
    0.30804765f, 0.42344892f, -0.48150086f, 0.15154132f, 0.13845377f, -0.10519792f, 0.26237437f, 0.43270746f, 
    -0.24394378f, -0.01815160f, -0.01733172f, -0.27018663f, 0.07579637f, 0.04375197f, 0.12179401f, -0.24683014f, 
    -0.22935066f, -0.30084383f, -0.37291157f, 0.02716889f, -0.40899399f, 0.04576796f, 0.09687638f, 0.08491921f, 
    -0.19077055f, 0.21086659f, 0.05461335f, 0.08065966f, -0.42911169f, -0.02246937f, 0.04312854f, -0.07032548f, 
    -0.61707157f, 0.60258907f, -0.30659780f, -0.25736964f, 0.34551021f, 0.15185955f, 0.07380953f, 0.23944025f, 
    0.20556714f, 0.06488459f, 0.08519025f, 0.17061926f, -0.02556284f, 0.02120625f, -0.05533446f, -0.06701706f, 
    0.19204137f, -0.07904775f, 0.10497607f, -0.16769089f, 0.15106994f, -0.23200920f, -0.06334147f, 0.18154156f, 
    -0.04801049f, 0.33372176f, -0.18708138f, -0.10736140f, -0.01876753f, -0.29090041f, -0.15038030f, 0.06244816f, 
    0.19256246f, -0.03733040f, -0.28466555f, 0.08465688f, 0.12942177f, -0.09702617f, 0.12058163f, 0.14252672f, 
    0.25309077f, 0.10623255f, 0.09394650f, 0.07478211f, -0.12325674f, 0.22005111f, 0.09949967f, -0.02556784f, 
    -0.14336842f, -0.32069725f, -0.04795890f, 0.75468051f, 0.13575384f, 0.64245784f, 0.52874768f, -0.01546300f, 
    0.00357167f, 0.18554887f, 0.04950543f, 0.21180810f, -0.20299113f, 0.02539480f, -0.04462345f, 0.28596175f, 
    -0.07583924f, -0.60048097f, -0.13489066f, 0.06067949f, -0.01141473f, -0.01424059f, 0.03520713f, -0.09874292f, 
    0.05129815f, 0.18908563f, -0.00347378f, 0.13278587f, -0.25899813f, 0.36067834f, -0.02087050f, -0.05248852f, 
    0.23044959f, -0.10504662f, 0.10513796f, -0.12616208f, 0.32788467f, 0.14267509f, 0.27203980f, 0.11423842f, 
    -0.01408517f, 0.16459304f, 0.16543874f, -0.15837821f, 0.37370223f, 0.14752805f, 0.31913632f, -0.09072571f, 
    0.24916238f, 0.04476389f, -0.43386200f, -0.22200610f, 0.10151330f, 0.09023455f, -0.04781653f, 0.17857324f, 
    0.09807830f, 0.08951995f, 0.12583910f, -0.10788798f, 0.07726726f, 0.32419559f, 0.35331306f, 0.02211154f, 
    -0.17405477f, 0.24861312f, -0.17503235f, -0.43129501f, 0.03477506f, 0.08179466f, 0.35218972f, 0.05132388f, 
    0.08326080f, 0.05983942f, 0.23190479f, -0.15405576f, -0.25807184f, 0.06808087f, 0.04253808f, 0.10774204f, 
    -0.19631052f, 0.10020376f, -0.01033406f, -0.22186416f, -0.02089273f, 0.22838506f, 0.21159329f, 0.33451995f, 
    -0.02056763f, 0.19333911f, -0.03999241f, -0.09148736f, 0.01066899f, 0.15784308f, 0.17517002f, 0.09371179f, 
    0.17524529f, -0.10354482f, -0.01161260f, 0.00845562f, 0.04317164f, 0.26824641f, 0.27109259f, 0.01845870f, 
    0.06351289f, 0.08204890f, 0.11489186f, 0.10712276f, 0.04843381f, 0.25038573f, 0.04483142f, 0.01212044f, 
    0.06060072f, 0.07357630f, -0.00108579f, 0.19029374f, 0.03185713f, -0.00526333f, 0.20154728f, 0.00356775f, 
    -0.25627497f, 0.09024400f, -0.08184890f, -0.02687820f, 0.07684828f, -0.07683609f, 0.08222732f, 0.08358332f, 
    -0.14473398f, 0.50650138f, -0.04826607f, -0.52908301f, -0.04388326f, -0.07678742f, -0.33052462f, 0.15731668f, 
    0.00494997f, 0.24060996f, -0.00822610f, -0.07403453f, -0.07632562f, -0.11714867f, -0.03389398f, 0.20261851f, 
    -0.26799721f, 0.55962348f, -0.00653373f, -0.02836802f, 0.01538259f, -0.06336798f, -0.05477904f, 0.01203289f, 
    -0.04137044f, 0.02670726f, 0.02163932f, -0.12567897f, -0.03798230f, -0.09967338f, 0.08668532f, -0.09771653f, 
    0.00044331f, -0.09353599f, 0.08125339f, 0.01451855f, -0.09301842f, 0.03251594f, -0.00531225f, -0.10870144f, 
    -0.01966101f, 0.01212180f, 0.03634769f, -0.08268081f, -0.06525388f, -0.09342331f, -0.06084241f, 0.10763285f, 
    -0.09308378f, 0.09075541f, -0.12925072f, -0.08125362f, 0.02337327f, -0.12090832f, -0.01423652f, -0.10061199f, 
    0.10463217f, 0.03684432f, 0.02982174f, 0.00195361f, 0.09409127f, -0.04019093f, -0.01562897f, -0.03093325f, 
    0.00019118f, -0.03909031f, 0.01473910f, -0.02641705f, 0.03612198f, 0.10632931f, -0.10559510f, -0.02311428f, 
    0.09394220f, -0.03329355f, -0.04366350f, 0.03469537f, -0.01897557f, -0.11312574f, 0.02797529f, -0.12739643f, 
    -0.00196945f, 0.03841430f, 0.05519037f, 0.03423230f, -0.08720289f, -0.01939400f, 0.08415330f, -0.04065771f, 
    0.04965548f, 0.11071004f, 0.06883974f, 0.09239735f, -0.08954462f, 0.14062195f, 0.33626354f, 0.03328368f, 
    0.13978268f, 0.05500402f, -0.00531110f, -0.02497203f, 0.27696958f, -0.10295998f, -0.15961146f, -0.00139341f, 
    -0.03209725f, 0.06244343f, 0.05849999f, 0.03313006f, -0.11369710f, 0.00960731f, 0.30748981f, 0.11247939f, 
    0.01530415f, 0.39778164f, 0.00014809f, 0.26136687f, -0.00352741f, 0.02691448f, -0.04254435f, -0.15050106f, 
    -0.42956230f, 0.17379446f, 0.05060150f, 0.00295763f, 0.01750449f, 0.18046318f, 0.28831080f, 0.11836299f, 
    -0.30966499f, -0.02866724f, -0.12893426f, -0.11740669f, -0.36084911f, -0.06858870f, -0.20044667f, 0.20889148f, 
    0.01033502f, 0.32079825f, -0.16731846f, -0.09106476f, -0.14996472f, 0.06319521f, 0.07162306f, 0.06305261f, 
    0.01075835f, 0.05694716f, 0.04844745f, 0.15695015f, 0.04391474f, -0.12233824f, 0.06488625f, 0.30502832f, 
    -0.00145201f, -0.00983526f, -0.14404126f, -0.07518826f, 0.01097021f, 0.19303708f, 0.15695828f, -0.02345696f, 
    0.10315600f, 0.02112903f, 0.08864354f, -0.05755365f, 0.16084862f, 0.49983525f, 0.10953663f, 0.09753950f, 
    0.32996577f, 0.04638239f, 0.33926782f, 0.16587929f, 0.11683998f, 0.11878928f, -0.10104907f, -0.00667356f, 
    0.09759134f, -0.05109479f, 0.05821246f, 0.20548454f, -0.02910438f, -0.10775718f, 0.29704532f, -0.06771541f, 
    -0.10106600f, 0.04275709f, 0.01873390f, 0.06383786f, -0.26100180f, 0.22444142f, 0.26889119f, 0.01823221f, 
    0.22115764f, -0.12781848f, 0.07848652f, -0.83937430f, 0.33889559f, -0.49835837f, -0.38428825f, -0.01281481f, 
    0.08254739f, 0.28772542f, 0.45953360f, -0.10512097f, 0.17654637f, -0.08393520f, 0.07316302f, -0.20541549f, 
    0.03582396f, 0.26935014f, 0.04285566f, 0.15708180f, -0.10463496f, 0.09590839f, 0.08147927f, 0.19365360f, 
    -0.06349920f, -0.02007538f, 0.01960180f, -0.16148865f, 0.03449268f, 0.07998097f, -0.09557860f, 0.11927944f, 
    -0.15030135f, 0.09817515f, 0.12136608f, 0.07065214f, -0.04224877f, 0.00189170f, -0.09933302f, -0.09609847f, 
    0.02599827f, -0.04890616f, -0.00231334f, 0.00148663f, 0.01687770f, -0.04784580f, 0.04510712f, 0.04879874f, 
    0.05303759f, -0.09564177f, 0.00202038f, -0.09111480f, -0.02580863f, -0.10052796f, -0.09644084f, -0.15949154f, 
    -0.14160421f, -0.13501024f, -0.04252575f, -0.11266994f, -0.04490430f, 0.03301367f, -0.12202854f, 0.00787097f, 
    0.03047806f, 0.06620728f, -0.04454604f, 0.03508348f, 0.04961563f, -0.07077799f, 0.00033773f, -0.15224482f, 
    0.09173597f, 0.01515813f, 0.00558415f, 0.05143274f, -0.13363287f, -0.04036120f, 0.08059581f, -0.03834915f, 
    0.11525445f, 0.05840930f, -0.05521656f, -0.01225838f, -0.10720216f, -0.03907611f, -0.12095622f, 0.00384802f, 
    -0.01420733f, -0.24880151f, -0.11266205f, -0.02667929f, 0.07568041f, -0.12851469f, 0.15593149f, -0.12209603f, 
    -0.18958886f, -0.05164117f, -0.00847441f, 0.43232015f, -0.11994160f, 0.58902645f, 0.39658299f, -0.27384138f, 
    -0.11456261f, -0.47075719f, 0.38173011f, 0.14136003f, -0.17916007f, 0.01158290f, 0.16240236f, -0.02781601f, 
    -0.11256533f, -0.20384447f, 0.58483660f, 0.16621347f, 0.02292927f, -0.05715217f, 0.07616445f, -0.22880869f, 
    -0.24167317f, 0.02251706f, -0.03714029f, 0.18566427f, 0.20685053f, 0.08477139f, -0.00929837f, -0.07264180f, 
    0.14112167f, 0.67523056f, 0.07038178f, -0.30694348f, 0.15988033f, -0.61872005f, -0.58320016f, 0.05323644f, 
    -0.08803245f, 0.03912337f, -0.59316725f, 0.07628334f, 0.27243504f, -0.02471823f, -0.02694793f, -0.07459481f, 
    0.01712815f, 0.39991391f, 0.23571026f, 0.11958652f, -0.16530186f, -0.03818164f, 0.21469846f, 0.29105869f, 
    -0.11930351f, 0.05934659f, -0.06248079f, -0.09423817f, 0.01143444f, -0.15330587f, 0.01935050f, -0.01091233f, 
    -0.02806048f, -0.08411370f, -0.00033140f, -0.03984829f, -0.07196386f, -0.10091673f, -0.07821947f, 0.02430467f, 
    0.07645692f, 0.04789563f, -0.02760120f, -0.09890388f, 0.06466952f, 0.00680514f, 0.05227148f, -0.02131572f, 
    0.02076889f, -0.10690863f, 0.01060493f, 0.02620871f, -0.03147767f, 0.04306836f, -0.14323764f, -0.01970349f, 
    0.05811189f, -0.03242763f, -0.11195174f, 0.06174064f, -0.01720935f, -0.11767703f, 0.00010071f, -0.16381183f, 
    0.03876970f, -0.02641073f, -0.08306979f, 0.03597584f, -0.06664538f, 0.04923090f, -0.13218942f, -0.00546356f, 
    -0.10533280f, -0.03530913f, -0.08630490f, -0.02136258f, 0.01151892f, 0.09393869f, 0.05422164f, 0.00557097f, 
    -0.12394501f, -0.10423702f, 0.00137473f, 0.03072835f, -0.09950379f, -0.04950823f, -0.12194785f, -0.06240654f, 
    -0.13572836f, 0.00359676f, 0.07137288f, -0.00822385f, 0.00212450f, -0.09141619f, -0.00790578f, -0.04224761f, 
    -0.09048596f, -0.05641165f, -0.07269947f, -0.06904002f, 0.07575134f, -0.09659474f, -0.03108555f, -0.06662582f, 
    -0.14990579f, 0.07634366f, -0.07608061f, -0.10703130f, 0.07037253f, -0.06453917f, -0.07263763f, -0.09909205f, 
    -0.11004078f, 0.03247545f, -0.09059803f, -0.01500588f, 0.03705782f, -0.11339258f, -0.08664640f, 0.05138750f, 
    -0.03568301f, -0.08638097f, 0.11505014f, -0.06524613f, 0.08912496f, -0.06005346f, 0.06403826f, 0.12334032f, 
    0.02895963f, 0.01671088f, 0.06082924f, -0.05792205f, 0.03014736f, 0.03369939f, -0.09936770f, -0.05980529f, 
    0.04154664f, -0.00922109f, -0.14349949f, -0.03092835f, -0.10275920f, 0.10071877f, -0.05311254f, 0.03437245f, 
    -0.00166606f, 0.04767689f, -0.14635228f, 0.09247413f, -0.07133533f, -0.05809765f, 0.00135517f, -0.10478021f, 
    0.15139899f, 0.12013704f, -0.03590185f, 0.16418177f, 0.01241373f, 0.18144730f, 0.20589371f, -0.05838943f, 
    0.11682948f, 0.04268213f, -0.05370313f, -0.18233728f, -0.03904549f, -0.24630280f, -0.13123839f, 0.21702482f, 
    0.03971068f, 0.22827032f, -0.08588035f, -0.06621407f, 0.11951939f, -0.10452548f, -0.14647932f, 0.07843268f, 
    0.06510787f, 0.07624136f, -0.00996698f, 0.13885389f, 0.29349908f, -0.05884236f, 0.06867409f, 0.21595506f, 
    -0.03409008f, -0.13891414f, -0.12044121f, -0.06547381f, -0.07020062f, 0.13807133f, -0.10060257f, 0.07720163f, 
    0.27711412f, 0.12980652f, -0.07432660f, 0.85516739f, 0.30411533f, 0.53134012f, -0.31826726f, 0.08222007f, 
    -0.03207560f, 0.21128161f, -0.12307757f, 0.15966725f, -0.07720617f, -0.10837811f, -0.07002349f, 0.25057581f, 
    -0.13798916f, -0.40213734f, -0.22723822f, 0.22598107f, -0.12950549f, -0.08102912f, 0.01911091f, -0.24748296f, 
    0.15708144f, -0.08340392f, -0.00075937f, 0.09497530f, 0.14474002f, -0.07924749f, 0.22096993f, 0.12340702f, 
    0.13390289f, 0.08475333f, -0.12200846f, 0.19561607f, 0.03686146f, 0.32063070f, -0.00532367f, -0.21544750f, 
    0.14230941f, -0.21562342f, 0.10663533f, -0.19268472f, -0.12558973f, -0.23709586f, -0.08860338f, -0.08295588f, 
    -0.31329826f, -0.16654074f, 0.28920639f, 0.21131502f, 0.09381877f, 0.00130913f, -0.14668933f, -0.23358850f, 
    0.17906675f, -0.00238386f, 0.11205151f, 0.25352815f, -0.12436318f, 0.19697775f, -0.13761264f, 0.08974908f, 
    0.38179114f, 0.11021686f, 0.15981720f, 0.07290015f, 0.27253410f, 0.06841269f, -0.15223145f, 0.10790668f, 
    -0.05920468f, 0.11570984f, 0.08923765f, 0.17711903f, 0.60090685f, 0.11254051f, -0.07451249f, 0.08256257f, 
    0.27673894f, -0.41797999f, -0.06191988f, 0.05580267f, -0.10751016f, 0.03392703f, 0.05130877f, -0.00358357f, 
    0.04488875f, -0.08475371f, 0.11486113f, 0.10024040f, -0.05865436f, 0.08544759f, 0.12060612f, 0.04114711f, 
    -0.20904592f, 0.06862976f, -0.05523954f, 0.32761917f, 0.03660913f, 0.12327199f, -0.06274885f, -0.26086468f, 
    -0.17479478f, -0.27357066f, 0.13601147f, 0.13411027f, -0.17012303f, -0.15384826f, -0.00991440f, -0.11356241f, 
    0.04678959f, 0.22581023f, 0.32933345f, 0.20824358f, 0.06106178f, -0.01537129f, -0.00470565f, -0.16553363f, 
    -0.12380356f, 0.15765500f, -0.10556204f, 0.29584494f, 0.20765941f, 0.17078279f, 0.09267437f, 0.02974961f, 
    -0.17514093f, 0.13734776f, 0.35588920f, 0.33494306f, -0.40292540f, -0.09944806f, 0.00572982f, 0.11646722f, 
    -0.21972698f, 0.00541904f, -0.50819761f, 0.19189891f, 0.39554062f, 0.07805537f, -0.08849608f, -0.03420067f, 
    0.17091389f, -0.50135046f, 0.17999639f, 0.19931777f, 0.07446101f, 0.01647833f, 0.08066600f, 0.02220010f, 
    -0.10390519f, -0.02634709f, -0.08276838f, 0.02083917f, -0.03804367f, -0.05691108f, -0.08163413f, -0.06931117f, 
    -0.13083851f, -0.12136382f, 0.10453323f, -0.08364846f, 0.08549590f, -0.02615704f, 0.01053305f, -0.02742084f, 
    0.01934966f, -0.01243401f, 0.03027265f, 0.02264920f, 0.08193912f, -0.04302366f, -0.12969770f, -0.10415532f, 
    -0.00917260f, -0.14291033f, -0.01801661f, -0.07714317f, -0.02448477f, 0.05386621f, -0.04886098f, -0.08923174f, 
    -0.10722068f, 0.06345969f, -0.08650319f, 0.02949088f, 0.03791063f, -0.01958972f, 0.00072991f, 0.08248179f, 
    -0.06961280f, -0.09698755f, -0.12327965f, 0.06686579f, -0.11013553f, -0.08750937f, 0.09203459f, -0.07351511f, 
    -0.08744878f, -0.02597721f, -0.02977222f, -0.08384692f, -0.02952574f, 0.07193984f, -0.11721832f, -0.02837716f, 
    0.06313817f, -0.09604417f, -0.01462614f, -0.09745153f, -0.14529520f, 0.00956924f, -0.12484379f, -0.09939838f, 
    -0.03210162f, 0.03544106f, 0.05687851f, 0.00291855f, -0.11820348f, 0.03194414f, -0.12477612f, 0.08159307f, 
    0.07736749f, -0.01185384f, 0.09676430f, -0.03132297f, -0.05956099f, 0.11032885f, 0.00554791f, 0.01320844f, 
    -0.02086718f, 0.05832763f, -0.07635877f, -0.10183583f, -0.03386001f, 0.04065426f, 0.03615893f, -0.00711218f, 
    -0.11160187f, -0.06448091f, -0.07065172f, 0.06980055f, 0.06753875f, -0.09462073f, 0.00433208f, -0.11207156f, 
    0.01457607f, -0.04881454f, -0.05075605f, -0.05828233f, -0.09716948f, -0.00989242f, 0.07276203f, -0.07366680f, 
    -0.00585257f, 0.07782991f, 0.01373069f, 0.00726703f, 0.02837295f, -0.09736635f, -0.06186773f, -0.10118929f, 
    -0.02601493f, -0.04498043f, 0.02271561f, -0.06850317f, 0.06181930f, 0.03639507f, 0.07390618f, -0.00625715f, 
    -0.02946362f, 0.01244867f, -0.06341841f, -0.06541714f, 0.04693510f, 0.02292304f, -0.03720312f, -0.09069503f, 
    0.13651384f, -0.48641887f, -0.05921991f, 0.04774052f, 0.03593058f, 0.02975624f, 0.09604776f, 0.05013812f, 
    0.03894316f, -0.11658905f, 0.03778802f, 0.04639562f, -0.03458701f, 0.23452803f, 0.42197114f, -0.09353603f, 
    0.26584312f, -0.12617780f, 0.09232692f, 0.05904935f, -0.10986613f, -0.08799788f, -0.09407040f, -0.01980056f, 
    -0.25053117f, -0.59975910f, 0.40964398f, 0.09283977f, 0.16120340f, -0.05518366f, 0.25403324f, -0.18332246f, 
    0.48691913f, 0.11805619f, -0.09359486f, 0.16670135f, -0.13812421f, -0.07242303f, -0.12898192f, -0.19676113f, 
    0.58457673f, 0.12683122f, 0.16439950f, -0.04898322f, 0.53615636f, 0.10210861f, -0.00573977f, 0.02514503f, 
    0.22159064f, -0.08550128f, 0.32679033f, 0.20192629f, 0.23137629f, -0.03741232f, -0.03743596f, -0.00477172f, 
    -0.13205662f, -0.01601569f, 0.06728189f, 0.13399047f, -0.30922952f, 0.10840770f, -0.02580014f, -0.14060463f, 
    -0.04995760f, 0.09061744f, 0.14955828f, 0.12096215f, -0.03113136f, 0.32418412f, 0.24314734f, -0.01199406f, 
    0.16096197f, -0.00777277f, 0.03163156f, -0.07312134f, 0.30339471f, 0.30856690f, 0.32534158f, 0.14523682f, 
    -0.07692281f, -0.01528748f, 0.57477045f, 0.15084073f, 0.17745422f, 0.29449904f, 0.36683401f, 0.10299766f, 
    0.06209133f, 0.06931746f, 0.14273541f, 0.00261850f, -0.06436264f, -0.02507421f, 0.13742478f, -0.06750277f, 
    -0.41768402f, 0.02770764f, 0.10610615f, 0.12756018f, 0.07003991f, 0.20520237f, 0.39010328f, -0.00518980f, 
    -0.23946314f, 0.29437035f, 0.02241000f, -0.53082651f, -0.10096025f, -0.38293532f, -0.36202171f, 0.17978996f, 
    -0.07424929f, 0.24058937f, 0.39636678f, -0.02641842f, 0.07615385f, -0.00737628f, 0.11871475f, -0.09507813f, 
    -0.21663401f, 0.42710412f, -0.04102213f, -0.12086441f, 0.11136758f, 0.11006705f, 0.17768672f, 0.48993862f, 
    0.05412729f, -0.24586259f, -0.03998419f, -0.21412136f, 0.14204073f, -0.05339492f, -0.25552437f, 0.01692325f, 
    0.04503448f, 0.06020568f, -0.10775346f, -0.06304999f, -0.09286089f, -0.23178463f, 0.03072089f, -0.00623699f, 
    0.04109380f, -0.27943411f, -0.02176294f, -0.06652784f, -0.52670169f, -0.20142861f, -0.30397257f, -0.03974792f, 
    0.03237818f, -0.06940693f, 0.19281833f, 0.09950686f, 0.11519740f, 0.10328783f, 0.10381794f, -0.26658228f, 
    0.91041470f, 0.25572595f, -0.00275783f, 0.13560165f, -0.12173405f, 0.00117789f, 0.19738530f, -0.02545871f, 
    0.69956517f, 0.03774777f, 0.27203912f, 0.37851220f, 0.08652726f, 0.08000952f, 0.87988013f, -0.20733321f, 
    -0.17068112f, -0.51323158f, 0.10406484f, 0.33279827f, 0.15515177f, -0.07156922f, 0.11319931f, 0.20037496f, 
    -0.02374842f, -0.03869517f, 0.03173343f, 0.32340175f, 0.15276216f, 0.13921724f, 0.16181882f, -0.08248113f, 
    -0.05463450f, -0.05848508f, 0.08045605f, 0.09611387f, 0.08917414f, 0.17434023f, 0.00661355f, -0.10033017f, 
    0.30006221f, -0.07025160f, -0.08489130f, 0.20997821f, 0.01449811f, 0.33986849f, 0.08893243f, -0.07839034f, 
    -0.06616519f, -0.03407329f, -0.09009455f, 0.18638727f, 0.20811823f, -0.04707030f, 0.17143491f, -0.11278298f, 
    -0.19789878f, 0.07156192f, -0.05441822f, -0.18511504f, -0.02373458f, 0.07833022f, 0.20218402f, 0.07874605f, 
    0.32562992f, 0.16686121f, 0.02689135f, -0.16320053f, -0.31267276f, 0.07923649f, -0.01052365f, -0.20386006f, 
    0.36864108f, 0.02816759f, -0.42329013f, 0.36866415f, -0.15562157f, 0.27641931f, 0.54248625f, -0.14051218f, 
    -0.05356589f, 0.15860012f, 1.18571210f, 0.13886517f, 0.11818704f, 0.02143122f, -0.08674035f, 0.26613230f, 
    -0.35649553f, 0.07035802f, -0.61855954f, -0.19898430f, -0.31725979f, -0.09634915f, -0.05412325f, -0.01564661f, 
    -0.02434187f, 0.02803843f, 0.07631810f, -0.05369478f, 0.04465759f, 0.00303882f, 0.03788529f, -0.03495918f, 
    0.05009443f, -0.08744000f, -0.04029645f, 0.05962719f, -0.05125335f, -0.11631092f, 0.02075471f, -0.04302971f, 
    0.12374230f, -0.04237667f, 0.09795500f, -0.09727682f, -0.10985772f, 0.09926753f, -0.09243300f, -0.04552814f, 
    -0.00489117f, -0.14139138f, 0.06539278f, -0.06703486f, 0.04336114f, 0.07477283f, 0.09102570f, -0.08185975f, 
    -0.05494728f, 0.02428236f, 0.10266760f, 0.05073238f, -0.05550043f, -0.05961788f, -0.04042530f, 0.06940708f, 
    -0.12367076f, 0.06969938f, -0.13078220f, -0.12251073f, -0.10110461f, -0.09632392f, -0.07250258f, -0.08127744f, 
    -0.04778486f, 0.08730589f, -0.06696911f, 0.01456750f, -0.14086743f, -0.00768256f, -0.02652858f, -0.08813772f, 
    0.05133162f, 0.01782753f, 0.08168291f, -0.08512127f, -0.06773095f, 0.03764582f, -0.08862229f, -0.04490601f, 
    0.06816450f, -0.05582371f, -0.10410888f, 0.10213949f, 0.21436909f, -0.08643662f, 0.32842875f, -0.08930126f, 
    -0.00574526f, 0.10852833f, 0.01489069f, 0.23296741f, 0.02401604f, 0.50386494f, 0.35200962f, -0.08474609f, 
    -0.26117700f, -0.36995834f, 0.21979973f, 0.10215751f, 0.30890685f, 0.21805280f, 0.22712675f, 0.06699499f, 
    -0.22082020f, 0.20140663f, 0.22630100f, -0.17800897f, 0.01490238f, 0.07386769f, -0.11160144f, 0.07899974f, 
    -0.36023492f, 0.01679750f, -0.04704525f, 0.09039426f, 0.18433082f, -0.12065764f, -0.09757084f, 0.07045300f, 
    -0.10102347f, 0.90135115f, -0.00289866f, -0.16671558f, 0.00693330f, -0.13965781f, -0.28711900f, 0.17131507f, 
    -0.25428954f, 0.08060386f, 0.37714222f, 0.12145212f, 0.16328752f, -0.09126142f, -0.06470360f, 0.09459409f, 
    0.04434743f, 0.59245640f, 0.07663945f, -0.03836305f, -0.00801511f, -0.00091077f, 0.17836294f, 0.13346851f, 
    0.14454260f, -0.06422335f, -0.01025981f, -0.18259272f, -0.00642938f, 0.18476748f, 0.01504436f, 0.08927818f, 
    -0.10991593f, -0.00311524f, 0.08315803f, -0.18492307f, 0.05151204f, -0.34243834f, 0.22168525f, 0.12100700f, 
    -0.15186937f, -0.52591336f, 0.11144705f, 0.31342858f, -0.28977948f, 0.33015779f, 0.03840830f, 0.00252628f, 
    0.18868598f, 0.45903367f, -0.00411940f, 0.25541994f, 0.17489552f, 0.02961537f, -0.12230817f, -0.12135161f, 
    -0.15752265f, 0.11505383f, 0.03785121f, 0.00016991f, 0.31698099f, -0.07292547f, 0.40673849f, 0.11167356f, 
    -0.37055269f, 0.19501282f, 0.06657676f, 0.35410398f, -0.32411689f, -0.08572618f, -0.09434168f, 0.25687411f, 
    -0.18351424f, -0.11122276f, -0.72359478f, 0.03351447f, 0.05427793f, -0.05381227f, -0.07184859f, 0.18646076f, 
    -0.41616434f, -0.00745890f, 0.17360149f, 0.01778048f, -0.00485487f, 0.18089615f, 0.04247390f, 0.17018870f, 
    0.16877715f, -0.17031550f, 0.10159099f, -0.00873055f, 0.00512175f, -0.04114795f, -0.25074598f, 0.00569904f, 
    0.09300008f, 0.01006389f, -0.10230532f, 0.02899275f, -0.10387217f, 0.22964221f, -0.13052353f, -0.03069325f, 
    -0.17452501f, 0.01971308f, 0.09789493f, -0.08087114f, -0.02601723f, -0.08318334f, -0.02985554f, 0.11595535f, 
    -0.09293691f, -0.45035779f, 0.27693883f, -0.00639888f, -0.08729266f, -0.08589531f, 0.00218491f, -0.03515150f, 
    0.50524831f, -0.04670355f, 0.11677230f, 0.19931738f, -0.13358890f, 0.16823037f, 0.22174132f, 0.00779085f, 
    0.42484811f, -0.68007642f, 0.29334331f, -0.00274322f, 0.37064400f, -0.02220035f, 0.22596022f, 0.05371709f, 
    0.19152212f, -0.23747265f, 0.15144911f, 0.07301474f, 0.27905461f, -0.02958797f, 0.08078374f, -0.24189657f, 
    0.11413044f, -0.49371085f, 0.10801773f, 0.11662113f, -0.09454405f, 0.19130695f, 0.19246694f, -0.07725932f, 
    -0.09817137f, 0.05098373f, -0.06954581f, 0.15865654f, 0.05023780f, 0.33520803f, 0.03022270f, 0.07130876f, 
    0.19208288f, 0.04993288f, -0.09089167f, 0.21558285f, 0.31815737f, -0.17533149f, -0.29007238f, -0.48529682f, 
    -0.14019804f, -0.55197245f, 0.35693699f, 0.08618074f, 0.11342476f, 0.05287763f, 0.28674915f, -0.03759737f, 
    -0.21780343f, 0.10690801f, -0.07236444f, 0.03917048f, -0.17344715f, -0.09315969f, -0.23605615f, -0.42247471f, 
    0.08255884f, -0.12121736f, 0.08050923f, 0.08148828f, 0.19442347f, 0.10774554f, 0.44290116f, 0.08042037f, 
    0.30918956f, 0.00128141f, 0.02583171f, 0.32804531f, -0.48376313f, 0.27170703f, 0.05022896f, 0.22722323f, 
    -0.48114666f, 0.19297875f, -0.03199001f, 0.03946646f, 0.22674029f, 0.03748979f, -0.03866859f, 0.13362998f, 
    0.04879792f, -0.34291682f, 0.08618798f, -0.04829464f, -0.21410446f, 0.07518229f, 0.24077974f, 0.67676556f, 
    0.16704129f, 0.04406041f, 0.00775824f, 0.01669399f, -0.29734787f, 0.25909784f, 0.02011111f, 0.04690644f, 
    0.29594800f, 0.00214864f, 0.12163402f, -0.10656788f, 0.00791554f, 0.05315335f, -0.25514778f, -0.06672788f, 
    0.18851832f, 0.21889091f, -0.02074934f, 0.04143054f, 0.12941810f, 0.03283237f, 0.00534578f, 0.08720931f, 
    -0.06314123f, 0.27776220f, -0.31748778f, -0.08985630f, 0.20335855f, 0.06197220f, 0.16835390f, 0.11511475f, 
    0.10385910f, 0.09776734f, -0.10092221f, -0.27235460f, -0.18913899f, 0.21046138f, -0.18640885f, -0.15550591f, 
    0.24330164f, 0.10678000f, -0.51983303f, 0.64873374f, -0.32050765f, 0.73545384f, 0.26765710f, 0.02759433f, 
    -0.45276728f, 0.20603538f, 0.99717289f, 0.15323831f, 0.02760746f, -0.04608665f, -0.00109822f, 0.64183968f, 
    -0.59621209f, -0.19174168f, -0.63969952f, -0.03315534f, -0.18372962f, 0.07541563f, 0.02014847f, 0.10622764f, 
    -0.04515243f, -0.02141673f, -0.04580877f, -0.00946248f, -0.03633829f, -0.11284348f, 0.19073884f, 0.09906028f, 
    -0.01440536f, -0.07043467f, -0.03789591f, -0.10218562f, -0.08791828f, 0.39891189f, 0.10963721f, 0.24796127f, 
    0.13711601f, 0.47841337f, -0.07080714f, -0.15822314f, 0.19126119f, 0.07193615f, -0.21863104f, 0.11571729f, 
    0.18332034f, -0.08580327f, 0.02419569f, 0.08884443f, 0.27695280f, -0.06964786f, 0.61604118f, 0.26627800f, 
    -0.07910465f, 0.15143596f, -0.12457961f, -0.01863418f, -0.15394402f, -0.11632586f, -0.11480922f, -0.00879925f, 
    -0.09316541f, 0.20340921f, 0.05117457f, -0.57181013f, 0.56100863f, -0.19796351f, -0.19672143f, 0.00346907f, 
    0.04857408f, 0.03328864f, -0.17119552f, 0.12121956f, 0.02437590f, 0.00614168f, -0.10231459f, -0.04611981f, 
    -0.22647458f, 0.58591616f, -0.08600000f, 0.14093360f, 0.03070005f, 0.13476393f, 0.08033339f, -0.28877392f, 
    0.17135994f, -0.28157055f, -0.08845521f, 0.05056600f, 0.26064724f, -0.17464755f, -0.08760234f, -0.02575067f, 
    0.03758958f, 0.02916992f, -0.12069318f, 0.35620299f, -0.14020084f, -0.03305854f, -0.41624689f, -0.32868585f, 
    -0.39716992f, -0.27190468f, 0.18681242f, -0.06151758f, -0.44686079f, -0.21229520f, -0.03701628f, 0.11176045f, 
    -0.20183551f, -0.12325703f, 0.42945918f, -0.08395945f, -0.01305906f, 0.07592021f, -0.35313663f, -0.35051206f, 
    0.37620500f, 0.17128541f, 0.07377794f, 0.30994895f, 0.04571493f, -0.05989798f, 0.15634803f, 0.18139376f, 
    0.53604347f, -0.10250305f, 0.12654780f, 0.73168987f, -0.08750098f, 0.12610343f, 0.51758230f, -0.02494620f, 
    -0.04987312f, -0.20002161f, 0.40085271f, 0.24628712f, 0.30479941f, 0.02179199f, 0.06681171f, 0.16165736f, 
    0.36248478f, -0.78309137f, 0.16315261f, 0.16709878f, -0.15829813f, 0.13317877f, 0.10671720f, 0.13746154f, 
    0.09369169f, -0.37447262f, 0.04554485f, -0.26821545f, -0.04569081f, 0.23526733f, 0.17854246f, -0.00558539f, 
    0.04862463f, -0.05279411f, -0.01882674f, -0.12887657f, 0.21923949f, -0.18283412f, -0.47976828f, -0.58175570f, 
    0.29124433f, -0.18736129f, 0.12660827f, 0.11594069f, -0.08429307f, 0.01673325f, 0.17152306f, -0.06063955f, 
    -0.35291427f, -0.15434043f, 0.14665224f, 0.25326833f, 0.04468715f, 0.00919877f, 0.11390353f, -0.23019852f, 
    0.25431061f, 0.08201164f, 0.00512506f, -0.03163769f, -0.06319433f, 0.26999822f, 0.34597054f, -0.31029522f, 
    0.45637873f, -0.17015690f, -0.10807609f, 0.25102249f, 0.04358394f, 0.06924514f, -0.07587275f, 0.25063482f, 
    -0.51359558f, 0.13306743f, 0.53596914f, 0.04872544f, 0.14149262f, -0.11194408f, 0.03687033f, -0.17569774f, 
    -0.10509137f, 0.01019273f, -0.12972286f, 0.06069401f, -0.49451903f, 0.11646244f, 0.11425629f, 0.12135047f, 
    -0.09793383f, 0.07111211f, 0.03790186f, -0.01687557f, 0.01483607f, 0.01656265f, 0.02363831f, -0.08965404f, 
    -0.02279814f, -0.00791420f, -0.02838567f, -0.14349271f, -0.02849231f, 0.13092539f, 0.04077222f, -0.08268120f, 
    -0.05825199f, -0.14217992f, 0.00251050f, -0.01014371f, 0.02530726f, -0.02094505f, 0.09594758f, 0.11062014f, 
    -0.12148070f, 0.11815015f, -0.08866991f, -0.08083721f, 0.09550228f, 0.07841684f, -0.13133009f, -0.07523146f, 
    -0.02707010f, 0.05108557f, 0.05668148f, 0.03814595f, -0.01914228f, -0.10985067f, 0.07218120f, -0.07529869f, 
    -0.00459943f, 0.08221374f, -0.06740016f, -0.11952070f, -0.06234889f, 0.06521519f, -0.11390489f, -0.10330506f, 
    0.09847628f, 0.07817458f, 0.12678003f, -0.15985370f, -0.11181130f, -0.04618807f, -0.02481604f, 0.02123575f, 
    -0.02989386f, 0.07784156f, 0.04097915f, -0.02282104f, -0.09644588f, -0.04355101f, 0.04563951f, -0.08874987f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03168926f, 0.05837052f, -0.03078993f, 0.11372696f, -0.11783348f, 0.32215130f, 0.06324239f, -0.25035390f, 
    0.05607598f, 0.30563909f, 0.10995035f, -0.05238486f, 0.02380972f, 0.06052303f, 0.21607918f, -0.13099763f, 
    0.51400179f, 0.00260798f, 0.15104730f, 0.06098332f, 0.21890265f, 0.04551973f, -0.14980119f, 0.22749971f, 
    0.00330342f, -0.09639687f, 0.19330177f, -0.03899227f, -0.30044425f, -0.00417221f, -0.01015908f, -0.35472864f, 
    -0.10345598f, -0.05208644f, 0.21131688f, -0.13419858f, 0.14862218f, 0.07742022f, -0.04198021f, -0.21910991f, 
    0.12781173f, 0.07303780f, 0.23057877f, -0.13129003f, -0.13699253f, -0.06526186f, 0.17315875f, 0.17897873f, 
    -0.08251864f, 0.12030635f, 0.18565512f, 0.23131604f, 0.40544537f, -0.09749193f, -0.10581240f, 0.15690932f, 
    0.19346139f, 0.27046445f, 0.26842931f, -0.21748701f, -0.06728341f, 0.20163685f, 0.10640439f, -0.10662454f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.14591560f, -0.14137098f, -0.35790619f, -0.34500277f, -0.01372293f, -0.18563138f, -0.00929165f, 0.01754261f, 
    0.03597387f, -0.14055263f, -0.10365624f, -0.14545038f, -0.04211644f, 0.00349498f, -0.14010303f, -0.02472476f, 
    -0.32549229f, 0.00091411f, 0.04316425f, 0.21911775f, 0.20447937f, 0.03177558f, -0.03755638f, -0.40410724f, 
    0.15399492f, -0.19380529f, -0.18545648f, -0.00918332f, 0.37804535f, -0.15082592f, -0.18429144f, 0.11494506f, 
    -0.02677314f, 0.10968248f, 0.39746407f, -0.04157093f, 0.20983720f, 0.11347587f, -0.13495402f, 0.10205673f, 
    0.11722296f, -0.02089414f, -0.37168247f, 0.08183484f, 0.01245899f, -0.21790127f, -0.61770928f, -0.56612843f, 
    0.10169408f, 0.00737391f, -0.36105052f, 0.04501690f, -0.00712268f, 0.14399789f, -0.00874838f, -0.09921481f, 
    -0.20488620f, -0.55090749f, -0.02083536f, 0.10600724f, 0.05697798f, -0.08307507f, 0.03909784f, -0.09692484f, 
    0.01987184f, 0.17229298f, 0.00300509f, 0.10668927f, -0.08857796f, 0.12353950f, -0.17124027f, -0.04435597f, 
    0.10794213f, 0.01386501f, -0.02749869f, -0.03386469f, 0.02871621f, -0.01159197f, -0.16508612f, -0.02548537f, 
    0.36117968f, -0.04542944f, 0.26675090f, 0.33242282f, 0.10353970f, 0.27231851f, -0.11218610f, -0.06793310f, 
    0.22125521f, -0.25016695f, -0.18602593f, -0.04916270f, -0.67975241f, 0.22745025f, -0.19165991f, -0.33195871f, 
    -0.02896133f, 0.05195667f, 0.14365996f, -0.27379474f, 0.05621929f, 0.14657918f, -0.10615866f, -0.05078073f, 
    0.07411275f, 0.04600995f, 0.17298804f, 0.05484974f, 0.01968741f, -0.17977051f, -0.08241563f, -0.01676841f, 
    0.06954625f, -0.00650133f, 0.13220102f, 0.10043070f, -0.07246761f, -0.63397580f, -0.06797369f, 0.24168545f, 
    0.22123355f, -0.14241607f, 0.09748445f, -0.97299415f, 0.09467566f, -0.30731872f, -0.21268833f, 0.13487510f, 
    0.04272181f, -0.30772749f, -0.31781062f, 0.05209560f, -0.05808605f, 0.11841126f, -0.02530793f, 0.18553987f, 
    -0.01050956f, 0.07461039f, 0.02032051f, -0.07875042f, -0.03115418f, -0.63858861f, 0.32568869f, -0.04342841f, 
    0.05817689f, -0.18350595f, -0.23621632f, -0.39875358f, 0.06247333f, -0.60572249f, -0.03932674f, 0.04376879f, 
    -0.74012429f, 0.14760183f, 0.26223698f, 0.06877652f, 0.05677814f, -0.61675835f, -0.09644903f, -0.40075260f, 
    0.05730320f, -0.56121767f, -0.45537218f, 0.01241266f, -0.05585555f, -0.04487192f, -0.05749410f, -0.59650475f, 
    0.02863629f, -0.06141202f, 0.09321973f, 0.04447271f, 0.00846300f, -0.03419181f, 0.12894766f, -0.14652105f, 
    0.03186419f, 0.08204630f, 0.37162030f, -0.20523514f, 0.35637984f, -0.06996081f, -0.11691777f, -0.38132021f, 
    -0.33596325f, 0.27243921f, 0.04404976f, -0.12540893f, 0.04635906f, 0.11362601f, 0.12673357f, 0.06593323f, 
    -0.02547028f, -0.85715276f, -0.44138291f, -0.04441406f, -0.01644277f, -1.67447817f, 0.03122537f, 0.08681027f, 
    -0.08969728f, -0.37841663f, -0.40929651f, 0.04763333f, -0.11695836f, -0.77749169f, 0.21807225f, 0.01735250f, 
    -0.47133553f, 0.17533216f, -0.36857283f, 0.22606567f, 0.14163403f, -0.71253061f, -0.04878840f, -0.15370321f, 
    0.12801766f, 0.06414819f, 0.17164201f, -0.04676198f, 0.12769316f, -0.17665951f, -0.15353511f, 0.05805130f, 
    0.06106129f, 0.18375055f, -0.17994165f, 0.05132613f, 0.07272557f, -0.01862152f, -0.01615619f, -0.07725430f, 
    0.21569394f, 0.07251902f, -0.04287701f, -0.06477394f, -0.04124244f, 0.06292367f, 0.14008538f, -0.30717659f, 
    0.08525074f, 0.01939602f, 0.17838088f, 0.03708405f, -0.11942729f, 0.27841777f, 0.11580664f, 0.01006734f, 
    -0.64037567f, 0.16257958f, 0.06662987f, 0.31948218f, 0.01433298f, -0.02352774f, 0.18864177f, -0.01675572f, 
    -0.08467666f, 0.33792165f, 0.07747271f, -0.11481974f, -0.11955865f, -0.25097167f, 0.23752043f, -0.06982746f, 
    -0.35375443f, -0.43037573f, 0.16197382f, -0.03778871f, 0.05274680f, 0.18092796f, 0.15112662f, 0.04756961f, 
    0.01539300f, 0.25253811f, 0.15523644f, -0.21600839f, -0.00974067f, -0.09534791f, -0.00617513f, 0.12202670f, 
    0.00509288f, 0.23762609f, 0.13146721f, 0.06258422f, 0.08539610f, -0.48144618f, 0.01534212f, 0.15964338f, 
    0.11083861f, 0.01914306f, 0.12019018f, 0.24041337f, 0.20667510f, -0.02957541f, 0.10437003f, 0.04132384f, 
    -0.05178189f, -0.04649120f, -0.51478314f, -0.03931791f, -0.01789276f, 0.15940128f, -0.14878911f, 0.11081050f, 
    0.10086583f, -0.02598117f, -0.33426020f, 0.00160369f, -0.67166239f, -0.09433839f, -0.06674991f, -0.35238644f, 
    0.16852161f, -0.05393935f, 0.12641118f, 0.19171603f, -0.02818490f, -0.84849507f, 0.00055152f, -0.00350917f, 
    -0.08299473f, 0.16816372f, 0.12189571f, 0.22934064f, 0.00673486f, -0.01596582f, 0.24240190f, 0.08423327f, 
    0.14424238f, -0.36471739f, 0.13124323f, 0.00100543f, -0.11376037f, -0.04364512f, 0.13512538f, -0.19048262f, 
    0.04025788f, 0.12481274f, 0.20941658f, 0.00279558f, -0.36900410f, 0.11207067f, 0.04087007f, -0.20553455f, 
    0.26389769f, 0.00392543f, -0.65125847f, 0.06371586f, 0.13769916f, -0.12216776f, 0.11660878f, -0.00516978f, 
    -0.11344407f, 0.14398138f, -0.18621911f, 0.02862499f, -0.03633330f, 0.10883012f, -0.00547316f, 0.08695928f, 
    0.19750631f, 0.06729404f, -0.01005587f, -0.13200016f, -0.03327403f, 0.02146617f, 0.02696568f, -0.03351624f, 
    -0.06993774f, 0.05718713f, -0.02299909f, -0.01262488f, -0.16278660f, -0.52107042f, -0.04432893f, -0.16278879f, 
    0.02976607f, -0.10838966f, -0.07597350f, -0.35919169f, 0.21205001f, -0.03234310f, 0.19755711f, -0.07861987f, 
    0.04669863f, 0.11269046f, -0.25187451f, -0.68060273f, 0.05007491f, -0.15437718f, -0.60401446f, 0.04372166f, 
    -0.36816016f, 0.30737624f, 0.20157017f, 0.09004939f, 0.04411001f, 0.13813698f, -0.90738583f, 0.01014343f, 
    0.04000548f, -0.84658480f, -0.39226997f, -0.29709625f, 0.19488375f, -0.34999087f, -0.15064068f, 0.26080707f, 
    -0.29382592f, 0.13143308f, 0.17379691f, -0.09152178f, -0.56113666f, 0.20422862f, 0.14484286f, 0.20887645f, 
    -0.10193063f, -0.94291466f, -0.84470886f, 0.17031571f, -0.28567678f, -0.48220330f, -0.11945684f, -0.59197229f, 
    -0.44159910f, -0.08979521f, -0.29599732f, -0.05701276f, -0.20483060f, -0.04137076f, 0.05738609f, -0.01378047f, 
    0.02129328f, 0.05615521f, 0.22467354f, -0.77502060f, 0.42301336f, -0.21712759f, -0.04678407f, -0.29762703f, 
    0.08295172f, 0.22041179f, -1.24651897f, -0.18981677f, 0.02266030f, 0.15573464f, -1.04529619f, 0.02426248f, 
    -0.13270140f, -0.27846262f, 0.18121545f, -0.96272939f, 0.05170701f, -0.07386541f, -0.54329389f, -0.17565225f, 
    -0.15848096f, -0.05163317f, 0.03076467f, 0.07406972f, 0.01888346f, 0.07904425f, -0.61512798f, 0.04162021f, 
    -0.55729520f, -0.32022503f, -0.21769232f, -0.59154165f, 0.16121522f, -0.19002753f, -0.12247336f, -0.10600606f, 
    -1.00723326f, -0.03249235f, 0.08342076f, 0.00891890f, 0.45536050f, -0.17779876f, -0.40605167f, 0.12463706f, 
    0.07155948f, 0.44228622f, -0.18290471f, 0.11208590f, 0.16601901f, 0.15880165f, -0.06931342f, -0.06557531f, 
    -0.18772468f, 0.07024339f, 0.22231777f, -0.11735504f, 0.06890675f, 0.11130122f, 0.10837061f, 0.01154709f, 
    -0.07423586f, -0.11770054f, -0.08362426f, 0.00997511f, -0.84667873f, 0.80391699f, -0.05366399f, 0.23980287f, 
    -0.55701989f, -0.64369982f, -0.16821782f, 0.45702404f, 0.04977357f, -0.07885992f, -0.57638967f, 0.05878557f, 
    0.13096891f, -0.24998057f, 0.20156232f, 0.27669439f, 0.11480001f, 0.26559961f, -1.31520462f, -0.10042533f, 
    0.34680882f, -0.17720616f, -0.07332885f, -0.09701166f, 0.07457320f, 0.22818118f, -0.63234735f, -0.02725291f, 
    -0.06883514f, -0.69718087f, -0.33294204f, -0.78888744f, -0.28670022f, 0.21095091f, -0.03250811f, -0.03155928f, 
    0.00754288f, -0.99169517f, -0.59273547f, 0.10614166f, -0.13288110f, -0.36106211f, -0.06574010f, -0.39513463f, 
    0.06754893f, -0.20393929f, -0.60585874f, -0.31394789f, -0.57761437f, -0.07097518f, -0.11388597f, -0.03811267f, 
    0.15541752f, 0.01832806f, 0.27804330f, -0.07655068f, -0.07039542f, -0.19751908f, 0.22031838f, 0.17843224f, 
    0.03756131f, -0.01031653f, 0.21485050f, -0.13154209f, 0.07373017f, 0.25477105f, 0.09578719f, 0.21081437f, 
    -0.05713029f, 0.25699875f, -0.54697645f, 0.44173458f, 0.22506988f, 0.21072547f, -0.67577982f, 0.03228955f, 
    -0.06396608f, 0.37308383f, -0.13939179f, 0.06199535f, 0.04018242f, 0.04404121f, 0.19946459f, -0.08871335f, 
    -0.61203718f, 0.20569795f, -0.00128848f, 0.03586065f, 0.06747158f, 0.29136321f, 0.19731338f, -0.05642106f, 
    0.10237107f, 0.20034650f, 0.16374652f, -0.46052897f, 0.15430540f, 0.09602387f, -0.07611386f, 0.15880607f, 
    -0.49408162f, 0.18837859f, 0.13615657f, 0.05696808f, -0.20797184f, 0.12916255f, -0.21295390f, 0.15802427f, 
    0.01203674f, -0.30628362f, -0.26235327f, 0.09697228f, 0.07323076f, -0.23743469f, 0.01809521f, 0.00922342f, 
    -0.27919331f, -0.04338617f, -0.48442405f, -0.04784494f, 0.11863244f, -0.09201040f, -0.17773578f, -0.08623769f, 
    0.04355508f, 0.12374530f, -0.27329585f, -0.31379926f, 0.15393972f, -0.10841556f, -0.10072307f, -0.27558300f, 
    0.14824837f, 0.10558181f, -0.04359473f, 0.10293253f, -0.31216425f, 0.05731513f, 0.19936855f, -0.00273592f, 
    0.07729077f, -0.36806741f, 0.01439536f, 0.20935158f, -0.07687853f, -0.29457241f, -0.20773488f, -0.46469426f, 
    -0.12438475f, -0.46642545f, -0.97830570f, 0.09396876f, -0.13257004f, 0.34060988f, 0.16011816f, 0.04362093f, 
    -0.19570589f, 0.33167484f, 0.01287121f, 0.02872953f, -0.45371884f, -0.09502135f, -0.00194152f, -0.00234690f, 
    -0.10211525f, -0.61062682f, 0.36306897f, -0.01379147f, 0.20156460f, -0.54139870f, -0.48220041f, -0.04201822f, 
    -0.02037917f, 0.15017393f, -0.46546367f, -0.53987026f, 0.05929289f, -0.12422901f, -0.10320010f, 0.08627797f, 
    0.12909935f, 0.02274918f, 0.30617487f, -0.07772009f, -0.01116226f, -0.88957494f, 0.10929504f, 0.18613747f, 
    -0.02245843f, -0.04522329f, -0.21587211f, 0.16185360f, -0.21644928f, -0.45174164f, 0.09420213f, 0.10941119f, 
    0.15360296f, 0.04739701f, 0.30472240f, -0.66006833f, -0.68786573f, 0.16655006f, -0.00281491f, -0.06727279f, 
    0.03019288f, -0.11627518f, 0.28189683f, 0.02893732f, -0.11209400f, -0.17326877f, 0.14152962f, 0.12971042f, 
    -0.15169322f, 0.17665131f, 0.01420134f, -0.05780728f, -0.03813719f, -0.32132581f, -0.06444509f, 0.06417443f, 
    -0.06393147f, -0.34949735f, -0.32974276f, -0.15156528f, -0.20191899f, 0.31363145f, 0.03846141f, 0.05565906f, 
    -0.81909424f, -0.25696769f, -0.56056970f, -0.10097043f, -0.60651726f, 0.15367199f, 0.57989228f, 0.12153256f, 
    -0.11496722f, 0.15858813f, -0.47870919f, -0.09885842f, -0.60504746f, -0.21230118f, -0.13363534f, -0.00294332f, 
    -0.48204944f, -0.04538053f, 0.08750480f, 0.02593912f, -0.02322207f, 0.11574581f, 0.08508416f, 0.06572928f, 
    0.02023105f, -0.05777596f, -0.15050909f, -0.35397974f, -0.22266796f, -0.24131390f, -0.01470307f, 0.19517961f, 
    0.10980922f, -0.09881976f, 0.13482934f, 0.09254782f, -0.33496022f, 0.17414704f, 0.00612349f, -0.03216501f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.27296454f, 0.32067949f, 0.01411039f, -0.04776538f, -0.10382285f, -0.17230181f, 0.02684821f, 0.04431638f, 
    0.00118344f, -0.06347506f, 0.12861912f, -0.24029186f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
