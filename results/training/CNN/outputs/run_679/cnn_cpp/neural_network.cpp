#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.05698133f, 0.15035917f, -0.42674643f, -0.25492713f, 0.20814793f, -0.08278207f, 1.13966107f, 0.29273713f, 
    0.09637766f, 0.53042537f, 0.14530180f, 0.07772345f, 0.05871460f, -0.36233237f, 0.01680184f, 0.25883853f, 
    0.18068928f, -0.00017400f, 0.17518140f, -0.12479698f, 0.07091506f, -0.00661421f, 0.08844736f, -0.07755675f, 
    0.00752988f, 0.60995215f, -0.46827134f, -0.44375086f, 0.47350952f, -0.08294925f, 0.54104757f, 0.67724431f, 
    0.18960331f, 0.56390387f, 0.19867548f, -0.13805650f, 0.20894203f, -0.25266442f, 0.04528312f, 0.31668535f, 
    0.10187133f, -0.26913923f, -0.15767924f, 0.15822943f, 0.21004693f, 0.02877820f, -0.24263795f, 0.16629688f, 
    0.07990319f, 0.10358860f, -0.63783211f, -0.07559516f, -0.02109462f, -0.17516483f, -0.31362140f, -0.06138290f, 
    -0.18857776f, 0.04487630f, -0.03707153f, -0.77688646f, -0.38109201f, 0.34334910f, -0.19785783f, 0.23087351f, 
    -0.22034518f, -0.17952305f, -0.06005846f, -0.45342886f, -0.02499454f, 0.16729282f, -0.01177429f, 0.20729172f, 
    0.22202852f, 0.17224079f, 0.19070050f, -0.22569434f, -1.06131065f, -0.68880892f, -0.28829232f, -0.36929429f, 
    -0.22683071f, 0.66336787f, 0.53468478f, -0.08885499f, 0.37233344f, -0.18161699f, -0.05161681f, -0.19106443f, 
    0.00909823f, -0.05631201f, -0.16782635f, -0.04724325f, 0.02108424f, -0.07791518f, -0.10459514f, -0.15321067f, 
    -0.04347595f, -0.04091216f, -0.05015361f, 0.07839968f, 0.86239964f, 0.07579350f, -0.63030875f, -0.28102604f, 
    -0.65323329f, -0.39274958f, 0.07295763f, 0.09891351f, 0.16969092f, -0.04634460f, -0.13921398f, -0.12145774f, 
    -0.10838167f, -0.49940154f, -0.35317332f, -0.04977156f, -0.03276552f, -0.36810237f, -0.24487844f, -0.15439221f, 
    -0.16226853f, -0.23641604f, 0.19295576f, -0.29203293f, 0.02253374f, 1.05681098f, 0.48373857f, 0.62027955f, 
    0.63574457f, 0.49970284f, 0.24751562f, -0.39740923f, -0.07620151f, 0.03701851f, -0.25423253f, -0.16328552f, 
    0.20730928f, -0.20472333f, -0.02681572f, 0.03898642f, 0.27883422f, 0.25620922f, 0.10680238f, 0.00112036f, 
    0.33706805f, -0.01341673f, 0.01399220f, 0.21275738f, -0.01791029f, 0.20040509f, 0.57092935f, 0.00833584f, 
    -0.20691268f, -0.18501125f, 0.02252908f, 0.37873793f, 0.13010395f, 0.30067694f, -0.22960843f, 0.34597555f, 
    -0.42025834f, -0.23319308f, 0.01654959f, -0.10516146f, -0.44278452f, 0.11406270f, 0.10942458f, 0.34361547f, 
    -0.00665949f, -0.06092918f, 0.18282680f, 0.44210929f, 0.21178256f, 0.26138186f, 0.01415250f, 0.08182089f, 
    -0.65255857f, -0.48657665f, -0.26007554f, -0.12100377f, 0.07326954f, -0.65070230f, -0.33429524f, 0.04084311f, 
    -0.42044395f, -0.44284049f, 0.16378878f, 0.42594442f, 0.11312979f, -0.16427073f, 0.21257800f, 0.09483650f, 
    0.21677099f, 0.05596039f, -0.12612785f, 0.07727059f, -0.11416223f, -0.18539225f, 0.06884660f, -0.15799296f, 
    0.85566783f, 0.64310545f, -0.60780001f, -0.33928728f, -0.57048488f, 0.27054688f, 0.33696467f, -0.56473804f, 
    0.08948138f, 0.06058387f, 0.24700598f, 0.09626643f, -0.22561330f, 0.20106946f, 0.01502677f, -0.06222091f, 
    0.17190363f, -0.15157405f, 0.08727650f, 0.12477058f, 0.07541680f, 0.33146974f, 0.01446773f, -0.01585221f, 
    0.16209933f, 0.65327811f, 0.67003590f, 0.43827659f, -0.48630264f, -0.03061188f, -0.47520334f, 0.33516431f, 
    0.26151007f, 0.14217815f, 0.38480520f, 0.02941144f, 0.07634902f, -0.02626996f, -0.20906326f, 0.04971736f, 
    0.23569727f, -0.17570999f, -0.20378932f, -0.04580690f, -0.41288355f, -0.26522434f, -0.22310582f, -0.12148307f, 
    -0.16296656f, -0.26157448f, 0.51193863f, -0.11780567f, -0.80501384f, -0.84849590f, 0.54174048f, 0.57928771f, 
    -0.33215296f, 0.21943006f, 0.26872408f, 0.28094706f, -0.26080796f, 0.12034032f, -0.12715407f, -0.08946986f, 
    -0.01413682f, -0.03333462f, -0.02717042f, 0.01637087f, 0.07369416f, 0.11012357f, 0.00264436f, -0.01082036f, 
    0.05430079f, 0.05229009f, -0.10113318f, 0.49189901f, -0.13479736f, 0.06830010f, 0.05119795f, 0.48981559f, 
    -0.54100209f, -0.95791936f, -0.43983009f, -0.44756621f, -0.27700105f, 0.00596186f, 0.52718192f, 0.17762765f, 
    -0.14353482f, 0.10275003f, 0.01126355f, -0.04076863f, -0.15409869f, -0.00332503f, -0.01913274f, -0.10761812f, 
    0.10799266f, -0.00598206f, -0.08923183f, 0.04394538f, 0.36548856f, 0.47192931f, 0.30312979f, 0.40489647f, 
    -0.26464888f, -0.77090067f, -0.81084555f, -0.21049091f, -0.07294065f, 0.04573279f, 0.34407783f, -0.14680681f, 
    0.13867722f, 0.41704085f, -0.24603370f, -0.15340082f, 0.11282309f, -0.12659042f, -0.09357366f, 0.09270391f, 
    0.12892872f, 0.23909041f, 0.37753704f, -0.06185260f, 0.01540935f, 0.89811713f, 0.69700986f, 0.31143835f, 
    -0.31621650f, -0.10523921f, -0.05160969f, 0.33662036f, -0.07808264f, -0.55919993f, -0.01240376f, -0.13342850f, 
    0.29450274f, 0.06163903f, 0.21542278f, -0.15219598f, -0.09242100f, -0.13433328f, 0.05995966f, 0.17441845f, 
    -0.00763505f, 0.04454419f, -0.07466109f, -0.05167878f, -0.21054603f, 0.27318990f, 0.06295390f, 0.24742359f, 
    0.60411441f, 0.77848101f, 0.50541914f, 0.18707317f, 0.23722768f, 0.31841442f, -0.06068856f, 0.44109821f, 
    0.17400548f, -0.04742309f, -0.20008612f, -0.17244883f, 0.02574712f, -0.35806665f, -0.14626071f, -0.23198454f, 
    -0.12487043f, -0.35762936f, 0.00539459f, -0.00746257f, 0.13736878f, 0.05028294f, -0.12499803f, -0.87385148f, 
    0.49475548f, -0.11955743f, 0.02343262f, -0.22695664f, 0.41736731f, 0.22117098f, -0.55380768f, 0.31078160f, 
    0.16342600f, 0.08805326f, -0.15758681f, -0.53025818f, -0.29536903f, -0.24517958f, 0.21247829f, 0.39753041f, 
    0.01311066f, -0.10595109f, -0.27288240f, -0.11965460f, 0.03777776f, 0.25327283f, 0.07765726f, 0.04309523f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02713283f, 0.17824788f, 0.08646975f, 0.00881208f, 0.15647535f, 0.26770768f, -0.22446427f, 0.26768196f, 
    0.41483918f, 0.05712328f, 0.20834643f, -0.08183238f, -0.00286919f, 0.27073649f, 0.23028249f, 0.07154484f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00007104f, 0.52703524f, 0.20420855f, 0.02319909f, -0.14930314f, 0.07859029f, 0.07376601f, 0.20292924f, 
    0.06052779f, -0.07519652f, -0.08737963f, -0.15537150f, 0.22942600f, -0.30514744f, 0.04074110f, -0.02606400f, 
    0.03243984f, -0.08615801f, -0.01030560f, 0.09417594f, -0.06073557f, 0.02687159f, 0.04603742f, 0.02387092f, 
    -0.18064010f, 0.14370984f, 0.03309353f, -0.47034526f, -0.08032601f, -0.12353063f, 0.01997295f, -0.11374068f, 
    0.16683534f, 0.00818689f, 0.03594871f, -0.12613508f, 0.00292414f, -0.04366206f, -0.03640043f, -0.14971972f, 
    -0.03521333f, -0.04347800f, 0.03894647f, 0.00493771f, 0.05681190f, 0.04184411f, 0.14983612f, 0.12033306f, 
    -0.04927726f, -0.02628408f, -0.07032256f, 0.01291024f, 0.08612814f, -0.16925240f, 0.08628698f, 0.00802765f, 
    0.01241653f, 0.11662475f, 0.03271132f, 0.12945931f, 0.34021530f, -0.06369917f, 0.00849047f, 0.45143902f, 
    -0.13127318f, 0.05060960f, -0.14321288f, -0.05169647f, -0.01791123f, -0.03923158f, 0.00682061f, -0.04837196f, 
    0.04418450f, 0.16196838f, -0.12163441f, -0.07667539f, 0.13365473f, 0.00714636f, 0.07857072f, -0.20596820f, 
    -0.04408934f, 0.03911999f, -0.07953312f, -0.01017255f, -0.19899987f, -0.07322988f, 0.09662692f, -0.23253000f, 
    -0.09341994f, -0.03088179f, 0.19138929f, 0.00823237f, -0.00229429f, 0.09491978f, -0.04003191f, -0.06368172f, 
    0.70951158f, -0.22894059f, -0.13520020f, -0.06494753f, -0.20904242f, 0.04316740f, -0.03603800f, -0.00381114f, 
    -0.02266847f, 0.00253079f, 0.05317295f, 0.00631061f, -0.33830819f, 0.53742808f, -0.41918609f, -0.00372295f, 
    -0.05400581f, -0.13552339f, 0.11294389f, -0.08768677f, -0.03887116f, -0.00834750f, -0.00418738f, -0.09083561f, 
    -0.21247736f, 0.07553235f, 0.04517691f, -0.32994691f, 0.05892874f, 0.02112611f, 0.20219512f, -0.04840225f, 
    -0.01308006f, 0.02189449f, -0.07267769f, 0.09091766f, 0.27984503f, 0.10043222f, 0.22491525f, 0.09237025f, 
    0.04034769f, 0.05605068f, 0.02579147f, 0.05036108f, 0.26581934f, 0.20116705f, 0.02938649f, -0.04864271f, 
    0.17630582f, -0.06607235f, -0.32535979f, -0.02613043f, 0.03058201f, 0.18627140f, 0.01657387f, 0.30502427f, 
    -0.04147425f, -0.04755292f, -0.06857089f, -0.13834292f, 0.35054773f, 0.39603549f, -0.21780118f, -0.14461105f, 
    -0.07695455f, -0.06117494f, -0.02723411f, -0.03182079f, 0.06716789f, 0.01703236f, -0.03189273f, 0.03229381f, 
    0.13707460f, -0.05452212f, -0.00168754f, 0.36815706f, 0.06901871f, -0.05274779f, 0.01942698f, 0.00117829f, 
    0.05842867f, 0.13268277f, 0.17802492f, 0.01968768f, 0.52697164f, -0.01513046f, 0.02679848f, -0.07739232f, 
    -0.08775943f, 0.09239821f, 0.00882051f, 0.03015976f, -0.03696899f, -0.09678914f, -0.07903333f, 0.02543684f, 
    0.30608660f, -0.33936721f, -0.13143726f, -0.08330215f, 0.11767640f, 0.02446268f, -0.05030731f, 0.02182558f, 
    0.09444784f, -0.01999921f, -0.01046103f, 0.02595296f, 0.12809284f, 0.15596068f, -0.01589812f, -0.07156803f, 
    0.01582677f, 0.03917965f, -0.00384055f, -0.06727694f, 0.02940768f, 0.10048504f, 0.01285199f, 0.18375508f, 
    -0.15995765f, -0.10477847f, -0.05642786f, -0.07613026f, 0.03817930f, -0.01613554f, 0.01943438f, 0.02917469f, 
    -0.10969111f, 0.19583584f, -0.07883395f, 0.14135396f, -0.23897447f, -0.28189060f, -0.18405783f, -0.05912141f, 
    0.11872096f, 0.03124643f, -0.00099872f, 0.21414599f, -0.07906965f, 0.07312283f, -0.02308526f, -0.13299149f, 
    0.08052558f, -0.18802269f, 0.09345288f, 0.02659050f, 0.10938149f, 0.08779754f, 0.11345246f, 0.08723284f, 
    0.07700771f, -0.16089624f, 0.07384490f, -0.02200599f, -0.09966998f, 0.25439847f, 0.25812367f, 0.24889292f, 
    -0.04048530f, 0.02111843f, 0.05146860f, -0.19934727f, -0.00878544f, 0.04474958f, -0.04738991f, 0.16077293f, 
    0.15499841f, 0.16170935f, 0.10159852f, 0.04408105f, -0.07389731f, -0.08862637f, -0.04600117f, 0.02093790f, 
    0.03789423f, -0.04617563f, 0.01316980f, 0.15745777f, -0.33131522f, -0.27607343f, -0.04609442f, 0.03488842f, 
    0.07783432f, 0.02631645f, 0.11869545f, 0.00696680f, 0.18853685f, 0.02114411f, 0.17264809f, 0.08203698f, 
    -0.16993047f, -0.00593445f, 0.17647913f, -0.21029620f, 0.10475347f, 0.18100344f, 0.08602291f, 0.10497247f, 
    -0.09698784f, -0.10504809f, 0.06098531f, -0.07036628f, 0.31150854f, 0.08338623f, 0.03777520f, 0.00677905f, 
    0.04504055f, 0.03203803f, -0.16415037f, -0.04957321f, -0.04692436f, 0.04130680f, 0.07671904f, -0.06766842f, 
    -0.13020678f, -0.15362835f, 0.29030916f, -0.20711020f, -0.08461305f, -0.02121390f, -0.01283941f, -0.04397858f, 
    0.09725861f, 0.01230903f, 0.03262407f, 0.09104191f, 0.06004150f, -0.00361371f, 0.29941925f, -0.09341706f, 
    -0.09937442f, 0.02031615f, 0.05436060f, -0.00383048f, -0.02949827f, -0.04390603f, 0.12329343f, 0.08577304f, 
    -0.32255623f, 0.15861061f, 0.36129311f, 0.16737814f, 0.01872563f, -0.08680274f, 0.15527032f, 0.00536377f, 
    0.06701241f, 0.01575329f, -0.01758754f, 0.10295002f, -0.18551731f, 0.26613507f, 0.23519512f, -0.13778998f, 
    0.06971592f, 0.14809704f, -0.05797629f, -0.00965250f, -0.04616266f, 0.04829753f, 0.07070391f, 0.14087085f, 
    0.14711931f, 0.22348191f, 0.26646158f, 0.24553841f, 0.04225903f, -0.06893296f, -0.06526117f, -0.06309801f, 
    -0.09153910f, -0.05976500f, 0.01229940f, 0.02444461f, -0.15642947f, -0.23384926f, 0.07907915f, 0.07753317f, 
    0.12795988f, 0.08390436f, -0.00689542f, -0.06575748f, 0.20253603f, 0.03318333f, -0.00524549f, -0.00051246f, 
    -0.23149684f, 0.10108931f, 0.16697240f, -0.13854000f, 0.05427848f, 0.07884232f, 0.03751361f, -0.05737972f, 
    -0.00537010f, 0.03837495f, 0.03281300f, 0.08814047f, -0.26105928f, 0.20334320f, 0.07526049f, 0.01168614f, 
    0.11453763f, 0.05234001f, 0.02396634f, -0.13980865f, -0.04036288f, 0.14598237f, -0.09564618f, 0.09918018f, 
    -0.02849872f, 0.05575818f, 0.17294908f, 0.26955411f, 0.17383443f, 0.08573942f, 0.10805733f, 0.28724930f, 
    -0.06982780f, 0.04421692f, -0.09422992f, 0.02308799f, -0.52021319f, 0.27569348f, 0.00552564f, 0.10246740f, 
    0.21701139f, 0.31961682f, 0.04289411f, 0.18385683f, -0.06053598f, -0.01256931f, -0.04584123f, -0.13758728f, 
    0.27035668f, 0.07095902f, -0.06172092f, -0.01699487f, -0.01613193f, 0.04201029f, -0.05685523f, 0.00190732f, 
    0.10548641f, -0.00426870f, -0.14010900f, -0.02074360f, 0.34443793f, -0.06882601f, 0.01823207f, 0.14792335f, 
    -0.01448682f, -0.10444803f, 0.05180580f, 0.01342675f, -0.02937060f, 0.01409888f, -0.00036945f, 0.29540524f, 
    0.29512379f, 0.01427909f, 0.05322630f, -0.17100081f, 0.05163996f, -0.08221806f, -0.00875965f, 0.23632325f, 
    0.22346711f, -0.05568729f, 0.03051452f, -0.10570358f, 0.18633689f, 0.07931880f, 0.17958757f, 0.24290124f, 
    0.05003263f, 0.02333771f, -0.19298498f, 0.04186695f, 0.04112716f, 0.10399772f, 0.34682855f, -0.00424481f, 
    -0.11313597f, 0.13381268f, -0.06363547f, 0.00077920f, -0.06939579f, -0.13369955f, -0.02494239f, -0.04925770f, 
    -0.05476635f, -0.09762408f, 0.05139682f, 0.08627275f, 0.41311336f, -0.18049332f, -0.01794937f, -0.20575890f, 
    -0.01534791f, -0.12980992f, -0.04330430f, -0.01740833f, -0.08177824f, 0.03584968f, 0.00488959f, 0.05233386f, 
    0.48803031f, -0.13105179f, 0.03432025f, 0.10908803f, 0.13606837f, -0.04985086f, -0.08588120f, -0.08526286f, 
    0.05179387f, 0.09884875f, -0.03408613f, -0.02224200f, -0.19170748f, -0.21486032f, -0.06043399f, 0.41559485f, 
    -0.09744872f, -0.13168512f, -0.04501043f, 0.07061222f, -0.12475477f, -0.03318001f, -0.00627700f, 0.12090517f, 
    0.26020393f, 0.02275399f, 0.03628531f, 0.10509621f, -0.06442180f, -0.11353187f, 0.00766600f, -0.02336036f, 
    0.04884876f, -0.06070285f, 0.11333719f, 0.08192437f, 0.26561803f, 0.01278076f, 0.11736839f, 0.15299106f, 
    -0.14085659f, 0.02383088f, 0.10427509f, 0.09393439f, 0.10675101f, 0.03751996f, 0.18293838f, 0.12177363f, 
    -0.00586684f, 0.04940784f, 0.09394135f, -0.00824377f, 0.00922700f, 0.09836474f, 0.06290685f, 0.01385871f, 
    0.08524202f, -0.11088967f, -0.09494861f, -0.10070913f, -0.17482772f, 0.18853210f, 0.13776712f, 0.14793326f, 
    0.08945364f, -0.03311492f, 0.13858789f, -0.05600030f, 0.19228072f, 0.04222849f, -0.03280684f, 0.00380061f, 
    0.23311977f, 0.22900175f, -0.00836221f, -0.05892200f, -0.01723571f, 0.13131361f, -0.09724554f, 0.15699069f, 
    0.03449602f, 0.00458888f, 0.18550122f, -0.12278944f, 0.30155766f, -0.12936614f, 0.07211255f, 0.03376953f, 
    -0.01459212f, 0.02913490f, 0.01566946f, 0.14104277f, -0.01735946f, 0.08262253f, -0.16177820f, 0.03336066f, 
    -0.09364284f, -0.09411965f, -0.20900269f, -0.31636381f, -0.13313635f, -0.26907098f, -0.08524587f, 0.06720025f, 
    -0.01492260f, 0.16760851f, -0.07542339f, -0.05698267f, 0.66100436f, -0.13496028f, 0.38611832f, 0.51394933f, 
    -0.15157342f, -0.14295322f, 0.08508268f, 0.15491986f, -0.04100718f, 0.09301692f, 0.14497119f, -0.00028557f, 
    0.41720989f, -0.16601461f, 0.04030887f, -0.05456716f, -0.11020345f, -0.20166990f, 0.13599047f, 0.11604469f, 
    -0.16911362f, 0.11524762f, 0.02173669f, 0.02799892f, -0.02440467f, 0.06746053f, 0.13120142f, 0.44354397f, 
    -0.06436919f, 0.10737153f, 0.05717073f, -0.04397826f, -0.06254302f, -0.21120456f, -0.01756635f, -0.13867037f, 
    0.05449095f, -0.11220751f, -0.03473082f, 0.12473141f, -0.10479484f, -0.05282493f, -0.14373830f, -0.00382356f, 
    0.08344231f, 0.01694903f, -0.13993734f, 0.15794954f, -0.11051545f, -0.13039987f, 0.13318788f, -0.01844045f, 
    -0.15719688f, -0.05066065f, 0.19656265f, 0.05768339f, -0.02626995f, 0.04378968f, -0.14162183f, -0.00734512f, 
    0.18885665f, -0.33493105f, -0.03668087f, -0.27028629f, -0.10345177f, -0.04553884f, 0.00983928f, -0.12270670f, 
    -0.09906163f, 0.09663143f, -0.07749856f, 0.04339008f, 0.04905849f, 0.06991073f, -0.04831795f, -0.00087597f, 
    -0.04246743f, 0.16171366f, 0.18484201f, 0.02088423f, -0.02973742f, -0.04340391f, 0.01258317f, -0.10327628f, 
    -0.13221994f, -0.14578556f, 0.14892258f, 0.13848613f, -0.02265596f, -0.07758225f, 0.01646348f, 0.01356798f, 
    -0.01209831f, 0.08509867f, 0.03998246f, -0.07098433f, -0.22186483f, -0.22687912f, 0.17622317f, 0.12585424f, 
    0.16879082f, 0.15472117f, -0.03407483f, -0.13047026f, -0.05916331f, -0.11172780f, -0.03276922f, -0.15556893f, 
    -0.48681748f, -0.04274624f, -0.03857284f, 0.08901185f, -0.03284321f, 0.27193823f, -0.00991096f, -0.10362190f, 
    -0.05738252f, -0.06829230f, -0.02978707f, -0.06513730f, 0.05152910f, 0.10297679f, 0.16463540f, -0.22735022f, 
    0.09729683f, -0.02862277f, 0.19521335f, -0.04780670f, -0.04213208f, 0.04313752f, -0.15163517f, -0.03034397f, 
    -0.11110245f, 0.07089159f, 0.09813055f, 0.27809936f, 0.10269034f, 0.20981400f, -0.04726190f, -0.03639999f, 
    0.03310313f, 0.10781437f, 0.11733451f, 0.08196963f, -0.22098468f, -0.03439468f, -0.32230955f, -0.03965597f, 
    0.07126576f, 0.02431322f, -0.01115514f, 0.10406961f, -0.09391314f, 0.09117305f, 0.14888875f, 0.03991420f, 
    0.06257900f, -0.06497773f, -0.07288994f, -0.01573437f, 0.02870822f, -0.02125663f, -0.03622870f, -0.02053921f, 
    -0.04485900f, -0.06424281f, -0.01267918f, 0.03531556f, 0.01315570f, 0.04972925f, 0.02012116f, -0.06034356f, 
    -0.06053469f, 0.01977482f, -0.02898906f, 0.04335014f, -0.00785303f, -0.07321711f, -0.00933025f, -0.02900863f, 
    -0.03017979f, 0.02664889f, 0.00732959f, 0.05661139f, -0.02646880f, -0.00452793f, -0.05810716f, -0.04823966f, 
    0.03206876f, 0.03690911f, -0.06097445f, 0.04137072f, -0.01445903f, 0.03805756f, 0.05278823f, -0.04316776f, 
    -0.04261911f, -0.04940687f, -0.01269158f, -0.00583522f, -0.04156718f, -0.04970134f, 0.03509268f, -0.02038526f, 
    -0.04802600f, 0.00242744f, 0.02832177f, -0.00115712f, -0.07087167f, -0.03431053f, -0.05965959f, 0.03584730f, 
    0.04069210f, -0.05343549f, 0.02749681f, 0.04733499f, -0.03703465f, -0.07325139f, 0.03268517f, 0.00447657f, 
    0.05059231f, -0.02989955f, -0.04860500f, -0.06639264f, -0.02657908f, -0.03387008f, -0.06805111f, 0.05099035f, 
    0.03699832f, 0.05297232f, 0.06012275f, 0.03352998f, 0.02472752f, -0.02757712f, 0.04421737f, 0.03975166f, 
    0.02598075f, 0.04319269f, -0.05889967f, -0.02925074f, -0.05515935f, 0.05614421f, 0.03323129f, -0.07248248f, 
    0.01282623f, -0.02500171f, -0.07082798f, -0.02567512f, 0.01422359f, -0.07294176f, 0.01145848f, -0.02516706f, 
    -0.00424646f, -0.01277240f, 0.04606208f, 0.01862036f, -0.05042032f, -0.03907922f, -0.04993401f, -0.03024768f, 
    0.05731824f, 0.06413197f, 0.04777468f, 0.02213883f, -0.07553355f, 0.06345706f, -0.02227686f, 0.05561506f, 
    -0.03536284f, -0.04745021f, -0.06296358f, 0.01785659f, 0.01999560f, -0.04645071f, -0.00834053f, -0.00668447f, 
    -0.00997093f, 0.02516294f, -0.03858032f, -0.01395807f, -0.02624082f, 0.02942947f, 0.00362667f, 0.04763170f, 
    0.06139011f, 0.02619108f, -0.00988411f, 0.01852070f, 0.01018848f, -0.07043256f, -0.07401337f, -0.07006884f, 
    -0.06787025f, -0.01117243f, -0.07689057f, 0.01236853f, -0.04590716f, -0.03941569f, 0.02229581f, 0.03613115f, 
    -0.03487720f, -0.00650615f, 0.04522471f, -0.06106453f, 0.01762815f, 0.03040401f, -0.07210383f, -0.03240379f, 
    -0.02590378f, 0.00748007f, 0.05781908f, -0.00735866f, -0.03277512f, -0.06139680f, -0.06094827f, -0.05067184f, 
    -0.04908505f, 0.06383049f, -0.01949569f, -0.06019866f, -0.05804632f, -0.05693065f, -0.07748022f, -0.03177723f, 
    0.01666281f, 0.03430155f, -0.03710407f, 0.02518811f, -0.01711823f, 0.06171155f, -0.05921519f, 0.05879918f, 
    -0.01418854f, -0.06433803f, -0.06744111f, 0.00943519f, -0.06319779f, 0.06653709f, -0.05632008f, 0.00036642f, 
    -0.05119083f, 0.00937021f, 0.05767291f, 0.02840890f, -0.03238200f, -0.04723601f, 0.03200109f, -0.01557062f, 
    0.23778348f, -0.36468098f, -0.22277747f, -0.01985485f, 0.09657905f, 0.00855671f, -0.09658218f, 0.03682816f, 
    -0.13238730f, -0.09307167f, -0.06477424f, -0.11443543f, -0.10099974f, -0.09150869f, 0.08498178f, -0.03119591f, 
    0.13798805f, 0.04666728f, 0.06298629f, 0.26755682f, 0.01752890f, -0.11009443f, 0.06424582f, -0.00036968f, 
    -0.02198966f, 0.15321116f, -0.07026328f, 0.09869519f, -0.18275392f, -0.08808415f, -0.14438356f, -0.07336918f, 
    0.10836160f, -0.06533977f, 0.17031270f, 0.01305025f, 0.37819678f, -0.26904389f, -0.16731068f, 0.02153204f, 
    -0.09534135f, -0.19839415f, 0.09492215f, 0.03176724f, 0.17266513f, -0.03354010f, 0.08516909f, 0.05830288f, 
    -0.25707561f, 0.22791241f, 0.22586960f, 0.21257366f, -0.03539826f, -0.08476758f, 0.11942571f, 0.07091426f, 
    0.01955658f, -0.00650250f, 0.21939345f, 0.04078174f, -0.07601345f, 0.30500501f, -0.06729145f, -0.37581557f, 
    0.07672842f, 0.06836109f, 0.08132192f, 0.12004660f, 0.10181042f, -0.00107282f, 0.12129009f, -0.32271108f, 
    -0.30610380f, 0.10136630f, -0.00265712f, 0.18517070f, 0.02385807f, 0.00895682f, -0.04223911f, -0.03660506f, 
    -0.23431478f, 0.01824634f, -0.03829932f, 0.14938855f, -0.06677729f, -0.06049537f, -0.16003777f, 0.12035244f, 
    0.08993314f, 0.04220286f, 0.12513451f, -0.01040026f, 0.04210993f, 0.01340667f, -0.27505642f, -0.03452327f, 
    0.17566854f, -0.03916019f, 0.34557325f, 0.07644233f, 0.10833954f, 0.02184000f, 0.02081461f, -0.08423478f, 
    0.00864151f, 0.10480060f, 0.03987827f, -0.04241526f, -0.08096877f, -0.08434834f, 0.33615443f, 0.01259246f, 
    0.10885239f, -0.03339094f, 0.24581975f, 0.17781408f, 0.21645667f, -0.08160991f, 0.08959688f, 0.04745205f, 
    -0.08261766f, -0.04758402f, 0.04359806f, 0.23882769f, 0.19962250f, -0.09424375f, 0.09309844f, 0.17404169f, 
    0.00320564f, -0.03481428f, 0.00348708f, 0.08250399f, 0.23629677f, 0.28720170f, 0.18126126f, -0.29338920f, 
    0.20507342f, 0.01511947f, 0.06781221f, -0.08271519f, -0.08873744f, 0.06936830f, 0.06220840f, -0.04246273f, 
    -0.02922613f, 0.24069829f, 0.13539836f, -0.03815752f, 0.13349794f, 0.09509543f, -0.05179327f, -0.03362475f, 
    0.00739328f, -0.04346014f, -0.12592830f, 0.00273228f, -0.09480742f, 0.06981090f, 0.21695596f, -0.13458033f, 
    -0.06493332f, 0.12202654f, 0.13910516f, 0.06128211f, 0.00890527f, 0.02931343f, -0.01435671f, -0.04627625f, 
    0.01956744f, 0.07203356f, -0.11330451f, -0.34221321f, 0.03171562f, 0.10177123f, 0.06617281f, -0.00083220f, 
    -0.05143307f, 0.08374324f, 0.17548692f, 0.22788103f, 0.04014809f, -0.35558277f, -0.05384385f, -0.00122821f, 
    0.03128936f, -0.04278507f, 0.01886962f, 0.12979643f, -0.14778101f, 0.18072894f, 0.16648020f, -0.15979213f, 
    -0.16093731f, -0.29504824f, -0.22176586f, 0.10216788f, -0.04595988f, -0.04857780f, 0.13862041f, 0.14981888f, 
    0.09847954f, 0.05806673f, 0.13057381f, -0.03178503f, 0.06632572f, -0.21213160f, 0.11650773f, 0.07745199f, 
    0.08254082f, -0.07592600f, -0.09256185f, -0.00198555f, 0.09759276f, 0.11755041f, -0.15465735f, 0.14838289f, 
    0.07893410f, -0.19929825f, -0.12247891f, -0.29236931f, -0.11321912f, -0.09603605f, 0.08927745f, -0.10004038f, 
    0.03352857f, 0.07909621f, 0.09595913f, 0.12985122f, -0.24142753f, -0.18826897f, -0.08008534f, -0.05029251f, 
    0.11046186f, -0.10529734f, 0.07513873f, -0.08561032f, -0.01786855f, 0.04084272f, 0.20347537f, 0.03871846f, 
    -0.02274058f, 0.06173796f, 0.10542192f, -0.01095267f, 0.18642445f, -0.02833542f, -0.03092406f, -0.02297466f, 
    -0.18522719f, -0.02895260f, 0.02113141f, -0.03497506f, 0.02202067f, 0.45327944f, 0.32904950f, -0.01842758f, 
    -0.04653192f, 0.02437780f, -0.06613482f, -0.00735481f, 0.09061657f, -0.08875880f, 0.05448936f, -0.09115050f, 
    0.12672234f, 0.07125609f, 0.11456418f, 0.05702617f, -0.10858485f, 0.03285732f, -0.28067780f, -0.09372567f, 
    0.07155021f, -0.15313615f, 0.04605564f, 0.07526632f, -0.08142440f, -0.13279350f, -0.10339064f, -0.03153019f, 
    -0.05799191f, 0.07698515f, 0.09791920f, 0.07716662f, 0.12088583f, -0.04664786f, 0.12256089f, -0.03778174f, 
    0.26817179f, 0.09920026f, -0.01648509f, 0.06911100f, 0.03072123f, 0.05846798f, -0.10833204f, 0.02085463f, 
    -0.11420417f, -0.02929235f, -0.05326821f, -0.07691485f, 0.00395109f, 0.30591613f, 0.19584236f, 0.13912307f, 
    0.10605816f, 0.08985654f, 0.05753702f, -0.02698057f, 0.04982029f, 0.11007607f, 0.11405638f, 0.16216773f, 
    -0.23416655f, -0.32533345f, 0.02226611f, -0.05413692f, 0.06708424f, -0.07372588f, 0.01713448f, 0.01891855f, 
    0.15905856f, -0.03404989f, 0.05853732f, 0.03878294f, -0.02083837f, -0.04229676f, 0.10790193f, -0.13663226f, 
    0.03204224f, -0.11107917f, 0.06186342f, 0.09286150f, 0.15654267f, 0.12681946f, 0.01780364f, 0.10262471f, 
    -0.18793498f, 0.15854064f, 0.14983992f, -0.21954902f, -0.05898610f, -0.16438247f, 0.11814425f, 0.01517817f, 
    -0.03554337f, 0.06675983f, -0.13961184f, 0.09663388f, 0.23762310f, 0.30897892f, 0.02888761f, 0.20263863f, 
    0.17156534f, 0.00671305f, -0.01576738f, -0.09517024f, 0.16471316f, 0.08261729f, 0.03524950f, 0.08680997f, 
    0.30999377f, 0.09024668f, 0.18529487f, 0.14372808f, -0.06035225f, -0.02948090f, -0.00752200f, 0.17537981f, 
    0.11187690f, 0.02793459f, 0.06116706f, 0.10211673f, -0.08336635f, -0.21905576f, -0.11722410f, -0.03793865f, 
    0.03491520f, 0.00743808f, 0.08444411f, -0.01353520f, 0.03502052f, 0.06563694f, 0.02991737f, 0.01526686f, 
    -0.36124012f, 0.24320231f, 0.03840941f, -0.08589435f, 0.07709589f, 0.05943666f, 0.17377122f, 0.08113152f, 
    0.10083394f, 0.16619851f, 0.04820259f, 0.04778776f, -0.18233785f, 0.38780063f, -0.05889764f, -0.04331940f, 
    0.01989643f, 0.00083137f, -0.03382396f, -0.22480623f, 0.03354342f, -0.00748947f, -0.07126447f, 0.00196755f, 
    0.04163567f, -0.00028310f, 0.05460525f, -0.01010269f, 0.06337950f, -0.07788573f, -0.00480353f, 0.24823505f, 
    -0.16121043f, 0.01516324f, -0.02251788f, -0.06961720f, -0.55079055f, 0.08772013f, 0.03591561f, 0.30242848f, 
    0.13783874f, 0.12924139f, 0.12380101f, 0.26358351f, -0.11663863f, 0.04739587f, -0.03245197f, -0.09211810f, 
    0.18721338f, -0.25135350f, 0.04435578f, -0.11868142f, 0.00342623f, 0.18477476f, 0.01717195f, -0.03297136f, 
    0.06780107f, 0.09547600f, -0.07605390f, -0.04466012f, 0.37159047f, -0.17802522f, 0.00291034f, 0.26654324f, 
    0.08222029f, 0.06764878f, 0.05128886f, -0.02397797f, -0.00162964f, -0.01460632f, 0.04986689f, 0.22220750f, 
    0.11834802f, -0.04724666f, -0.00610002f, -0.08921218f, 0.01020128f, -0.08324149f, 0.02323318f, 0.09067245f, 
    0.19368319f, 0.12737067f, 0.00586802f, 0.00770842f, -0.08469303f, -0.08967822f, 0.22299837f, 0.31403938f, 
    0.00939265f, 0.01718299f, -0.12493010f, 0.02408239f, 0.08009899f, 0.02857646f, 0.23546430f, 0.05148160f, 
    -0.23881277f, -0.14025892f, -0.05257071f, -0.07458165f, -0.05685079f, -0.06274042f, 0.17678045f, 0.11244813f, 
    0.02913031f, -0.04953934f, 0.04090073f, 0.07679803f, 0.33759624f, -0.26911694f, -0.08601109f, -0.23931304f, 
    -0.13659193f, 0.05854366f, 0.06606965f, -0.10593772f, -0.07149664f, 0.16737294f, 0.07271833f, 0.02973663f, 
    0.05744359f, -0.29223430f, -0.17596175f, 0.11049661f, 0.14199172f, -0.05655944f, -0.02716505f, -0.02130182f, 
    -0.01603357f, -0.09657917f, 0.03680546f, -0.00789494f, -0.30276319f, -0.20280574f, 0.28234002f, 0.50248098f, 
    -0.12953401f, -0.02662153f, -0.05384606f, 0.00923708f, -0.01505593f, -0.08880215f, -0.04333773f, 0.05346429f, 
    -0.01668060f, -0.35636508f, -0.03774103f, 0.39468595f, -0.22355078f, 0.00213104f, -0.09212559f, -0.16488911f, 
    0.04675467f, -0.06331579f, -0.04780484f, -0.01250620f, -0.04966108f, -0.14141770f, 0.20935258f, 0.04755405f, 
    -0.02481563f, 0.07563011f, 0.14515088f, -0.02017805f, 0.02018153f, -0.05795223f, 0.07892416f, 0.03248181f, 
    -0.00421498f, 0.08999860f, 0.07881714f, 0.18338118f, 0.05612497f, 0.15908724f, -0.08725183f, 0.08778039f, 
    0.10012638f, 0.04466332f, -0.05748386f, -0.00543715f, 0.19806261f, 0.14079784f, 0.10463707f, 0.02235680f, 
    -0.00045918f, 0.08355541f, 0.06096098f, 0.05460289f, 0.11922584f, 0.09668291f, -0.00873235f, 0.08847912f, 
    -0.01968817f, 0.03830647f, 0.04696143f, -0.07114328f, -0.03550849f, 0.06022272f, -0.06859220f, 0.02049448f, 
    -0.05163718f, -0.07566987f, -0.06811176f, 0.05409729f, -0.03078762f, -0.05949080f, -0.06325365f, -0.06780504f, 
    0.01714010f, -0.02114390f, -0.04290257f, -0.05291820f, -0.03039816f, 0.05793663f, 0.04782659f, 0.01302019f, 
    -0.01242381f, -0.02307132f, 0.04937517f, 0.02380720f, -0.05078466f, -0.02903603f, -0.06499787f, 0.02063239f, 
    0.05307952f, 0.00005611f, -0.03216237f, 0.01504016f, 0.01947075f, -0.06983602f, 0.01810523f, -0.04213355f, 
    -0.05815751f, 0.01857580f, -0.02491775f, 0.01978179f, -0.04318230f, 0.00904953f, 0.01862887f, -0.03000830f, 
    0.01294120f, 0.01462995f, 0.01028143f, -0.00802269f, 0.03590130f, -0.07695066f, 0.00377531f, -0.00199386f, 
    -0.03742321f, -0.03296097f, -0.05605519f, 0.02271854f, 0.06513168f, -0.04354221f, -0.05670387f, 0.05771682f, 
    0.02321123f, -0.04695822f, 0.04105140f, -0.05856258f, -0.05412922f, 0.04200691f, -0.03920314f, 0.02142919f, 
    -0.04338749f, -0.05238418f, -0.00346290f, -0.00925980f, -0.01979631f, -0.02916578f, 0.03168742f, 0.03897977f, 
    0.02823664f, -0.00260612f, 0.03738736f, -0.05157394f, -0.01778002f, -0.07196677f, 0.05861441f, 0.03733230f, 
    -0.04045746f, 0.05036515f, -0.06598634f, -0.06325614f, -0.05014971f, -0.03272895f, 0.04249806f, 0.03081186f, 
    -0.00372205f, 0.00698891f, 0.01146597f, 0.04147830f, 0.01621075f, 0.02625452f, 0.00577391f, 0.00544678f, 
    0.06013397f, -0.07210160f, -0.06787471f, 0.02286246f, -0.04250569f, -0.06490789f, 0.00942585f, -0.05788515f, 
    -0.00349694f, -0.03864289f, 0.05078372f, -0.01254041f, 0.03578249f, 0.02482974f, 0.02277720f, 0.01950753f, 
    -0.00951922f, -0.02110975f, -0.03347521f, 0.02669895f, 0.02654911f, 0.05341646f, 0.03884783f, -0.01476002f, 
    0.03067629f, -0.03799063f, 0.05992858f, -0.00988428f, 0.06238989f, -0.00503965f, 0.06797123f, -0.01489458f, 
    0.03109240f, -0.02560186f, -0.02647278f, -0.01993570f, -0.06232326f, -0.04197210f, 0.05013566f, 0.00565794f, 
    -0.06036283f, -0.05092469f, -0.05822915f, 0.00223679f, -0.05416814f, -0.03815586f, -0.05725316f, 0.04402200f, 
    -0.00859293f, -0.04983361f, 0.06220946f, 0.03848412f, 0.05434104f, -0.06458613f, -0.05461377f, -0.04139439f, 
    -0.04887482f, -0.04900274f, -0.02686955f, 0.02519031f, 0.02944369f, -0.05871727f, -0.00823213f, 0.04531722f, 
    0.04334345f, -0.06092677f, -0.06058457f, 0.04284883f, -0.04669595f, 0.01445898f, -0.02006881f, -0.03100542f, 
    -0.04814795f, -0.07265899f, -0.06874473f, -0.06174212f, 0.02610764f, -0.04710901f, -0.05332766f, 0.04354600f, 
    0.01956297f, 0.04900627f, 0.05936738f, 0.06244349f, -0.05650125f, -0.03371021f, -0.03867675f, -0.02925044f, 
    -0.31727922f, 0.04377439f, -0.02479108f, 0.10159892f, -0.16661422f, 0.08142609f, 0.05730717f, 0.02228851f, 
    0.09565104f, 0.11480840f, 0.02342047f, 0.11580095f, 0.31650111f, -0.36661351f, 0.22033381f, -0.00126789f, 
    -0.11171662f, 0.09855958f, -0.06544175f, -0.00026836f, 0.04938606f, 0.11852249f, -0.18255931f, 0.28039762f, 
    0.15398499f, -0.22931446f, -0.06843553f, -0.24980678f, 0.06744643f, 0.16227756f, 0.16272783f, -0.20687343f, 
    0.05327072f, 0.12116400f, -0.09980677f, -0.01315213f, 0.05565493f, 0.03755571f, 0.05113357f, -0.40472519f, 
    0.06548600f, 0.10281064f, -0.10036179f, -0.11098345f, 0.05846344f, -0.04392102f, 0.03295286f, 0.07980049f, 
    0.08102425f, -0.28159505f, -0.00994124f, -0.04990886f, 0.19256540f, -0.06757403f, -0.00668701f, -0.07752485f, 
    -0.00828119f, -0.20293218f, -0.21493563f, -0.07931948f, -0.10360253f, 0.02252562f, 0.19690186f, 0.00745079f, 
    0.02697050f, 0.01656470f, -0.06915942f, -0.00243311f, 0.06383541f, 0.07875728f, 0.13507926f, 0.24714312f, 
    0.07884174f, 0.00823479f, 0.19765018f, -0.02298889f, -0.03321518f, -0.06460388f, -0.06082805f, 0.07003822f, 
    0.37405124f, -0.09092647f, 0.17085356f, -0.04559840f, -0.03179274f, -0.04634424f, -0.14879909f, -0.27097538f, 
    -0.12064691f, 0.01345535f, 0.00971841f, 0.12775330f, -0.09413330f, -0.16510721f, 0.34861091f, -0.07259070f, 
    0.16205572f, -0.13856889f, -0.33256713f, 0.22406559f, -0.08992785f, -0.03984826f, -0.00570157f, 0.06178723f, 
    0.07232393f, 0.06681272f, -0.01528175f, -0.04639155f, -0.08801953f, 0.38859794f, -0.10614175f, 0.26646048f, 
    0.08771247f, 0.02216719f, -0.17194261f, -0.14698422f, -0.07952233f, -0.06249352f, -0.09003000f, 0.15007062f, 
    -0.14362477f, -0.24528284f, 0.20973834f, -0.39405161f, -0.10594300f, -0.04196625f, -0.00411981f, 0.02328109f, 
    0.01048251f, 0.13132149f, 0.07907276f, -0.02396593f, 0.13829662f, 0.01083422f, 0.04975249f, 0.00602673f, 
    0.08844622f, 0.05270455f, 0.01804093f, 0.05284590f, 0.03520906f, 0.03606160f, -0.07204828f, 0.01449379f, 
    -0.04686484f, 0.09905464f, -0.06404833f, -0.14140446f, 0.13916814f, -0.00729064f, 0.09077888f, 0.24787946f, 
    0.10307602f, 0.06206433f, -0.00177879f, 0.07924404f, -0.04427297f, 0.00085192f, -0.10284804f, 0.12127956f, 
    0.10042193f, -0.05039403f, -0.07399108f, -0.03803884f, 0.14184180f, -0.04418362f, 0.06284878f, 0.02986920f, 
    0.11498150f, 0.06098245f, 0.19309700f, 0.32315800f, 0.08102664f, 0.03757117f, -0.00895950f, 0.20735714f, 
    0.18847826f, 0.05114169f, -0.16337712f, -0.08569980f, -0.13765889f, 0.11069430f, -0.01944317f, 0.14279675f, 
    0.02171834f, 0.05973957f, 0.18032873f, -0.20978986f, 0.14002430f, -0.10778210f, -0.15031350f, 0.13471755f, 
    0.51763403f, -0.13985354f, 0.11316198f, -0.12051779f, 0.14815335f, 0.15825146f, -0.08428389f, 0.02834053f, 
    0.04360721f, -0.03293134f, 0.03616714f, 0.09687657f, -0.09385911f, 0.47812298f, -0.04847979f, 0.12674731f, 
    0.03924955f, 0.11606774f, 0.02308681f, -0.14107302f, -0.11926012f, -0.06523411f, 0.04509325f, -0.03762014f, 
    -0.21599245f, -0.17354624f, -0.14902793f, -0.01302238f, 0.14079063f, -0.00351236f, 0.02422791f, 0.08862128f, 
    -0.16226137f, 0.03725168f, -0.10511897f, 0.00859898f, -0.33776385f, -0.03434126f, 0.06174457f, 0.11613973f, 
    0.17778736f, 0.05167580f, -0.05064481f, 0.19056520f, 0.06759132f, 0.03735477f, 0.06585213f, 0.05631339f, 
    -0.02208040f, 0.01949650f, -0.02740223f, -0.13175005f, -0.06038609f, 0.02968498f, 0.04286828f, 0.08679442f, 
    -0.00892480f, 0.06813018f, 0.14145783f, -0.03660157f, 0.21610510f, 0.20549163f, 0.18429941f, 0.04995716f, 
    -0.07528065f, -0.01187127f, 0.00899140f, 0.07408096f, 0.07432614f, 0.14869265f, -0.00681578f, 0.01545904f, 
    0.13527203f, 0.16035312f, -0.01522590f, 0.07095194f, 0.08316679f, -0.08700934f, 0.03844204f, 0.04045395f, 
    -0.13061287f, 0.11296530f, -0.04068122f, 0.10924528f, -0.32662323f, -0.21741833f, 0.10985087f, 0.09759376f, 
    0.09979425f, 0.01444076f, 0.00831887f, -0.10927023f, 0.04720706f, 0.03557779f, -0.06751847f, 0.06064786f, 
    -0.38279256f, 0.17717668f, 0.22279267f, -0.23623289f, -0.04953522f, 0.10081001f, 0.06589866f, 0.08053901f, 
    -0.00171148f, -0.14158818f, 0.03585450f, 0.04534992f, 0.29937109f, -0.24754982f, 0.17319769f, -0.17852452f, 
    -0.11967569f, 0.04648889f, -0.05922723f, -0.01094517f, 0.14638382f, 0.16295615f, 0.01943799f, -0.14181657f, 
    0.19732058f, -0.04568699f, -0.02516153f, 0.02877629f, -0.01498042f, -0.03380389f, 0.02132596f, -0.03317282f, 
    -0.07393928f, -0.06946485f, -0.01981473f, 0.04174791f, -0.20079198f, -0.15331899f, 0.10644974f, -0.23231770f, 
    -0.06358928f, 0.05045398f, 0.09295017f, 0.00195294f, -0.21721019f, -0.09855594f, 0.14553189f, -0.03118180f, 
    -0.27785283f, 0.02832202f, 0.34449431f, 0.07522437f, -0.23174639f, -0.17326427f, 0.07124866f, -0.03191151f, 
    -0.06822374f, 0.00138629f, -0.00743958f, -0.02088871f, -0.07914461f, 0.10334983f, 0.26810044f, -0.19781055f, 
    -0.03711708f, 0.12586191f, -0.02353634f, 0.10261624f, -0.14497255f, 0.03265124f, -0.13423219f, 0.11821602f, 
    0.05723080f, 0.24713443f, 0.09948695f, 0.31029096f, 0.09051052f, -0.03785853f, -0.04838804f, 0.06629537f, 
    -0.07513594f, -0.00134358f, 0.05602495f, -0.00620692f, 0.14866468f, -0.13901493f, 0.14848037f, -0.00437907f, 
    0.04962393f, 0.11577205f, -0.02355811f, -0.03504940f, 0.08066314f, 0.08401544f, 0.00019170f, 0.01181255f, 
    -0.29146662f, 0.02956102f, -0.07321841f, 0.14713985f, -0.01990669f, -0.07773727f, 0.08358416f, -0.00877339f, 
    -0.08220272f, -0.02489544f, 0.13239068f, -0.05473400f, -0.24113041f, -0.01992380f, -0.08501008f, -0.09507611f, 
    0.04789050f, -0.01054654f, 0.17525426f, 0.10230800f, 0.08929658f, -0.00976147f, 0.04132510f, -0.01921522f, 
    0.45018986f, 0.12212882f, 0.02817810f, -0.08696337f, 0.11376863f, 0.09820564f, 0.01900001f, -0.02123767f, 
    0.01852740f, -0.12493040f, 0.22524068f, 0.11591496f, 0.06053066f, 0.21003351f, 0.11873390f, 0.09818874f, 
    -0.07478770f, 0.05363600f, 0.18792161f, -0.00209172f, 0.10216724f, -0.05425254f, -0.01910657f, 0.04595280f, 
    -0.29548529f, 0.02850868f, 0.18391088f, -0.00290362f, 0.08249812f, 0.12878355f, 0.13434258f, -0.07116394f, 
    -0.04481641f, 0.02619038f, 0.19683781f, -0.07955036f, -0.10992003f, -0.03656361f, -0.04052733f, -0.32001656f, 
    0.16114520f, 0.06105061f, -0.10510035f, 0.10809408f, 0.15549776f, 0.02422236f, 0.03752242f, -0.09978259f, 
    -0.20732847f, -0.17377546f, -0.07830720f, -0.03300719f, 0.02537705f, 0.05141732f, -0.04724972f, -0.05098126f, 
    -0.08279119f, 0.05100531f, 0.01746280f, 0.02160852f, 0.30733404f, 0.24497946f, 0.06518941f, 0.09720159f, 
    0.00812404f, -0.01399162f, 0.10253605f, 0.19243176f, -0.05621609f, -0.08520249f, -0.07742221f, -0.00627177f, 
    -0.33569938f, -0.00292445f, 0.07535951f, 0.21102557f, 0.15137920f, 0.03191961f, 0.04423899f, -0.05787818f, 
    0.19722332f, 0.15820128f, -0.00701113f, 0.02179718f, -0.29390672f, -0.29519165f, 0.06497520f, 0.03197941f, 
    -0.02616645f, 0.10795902f, 0.05297764f, -0.08282818f, 0.08475507f, 0.06395498f, 0.08840507f, 0.21549520f, 
    -0.03714456f, -0.20986639f, -0.33523878f, 0.34452057f, 0.11521176f, -0.02556410f, 0.12973075f, 0.14849456f, 
    -0.06172796f, 0.06482637f, 0.02901742f, -0.05296123f, -0.00479965f, -0.03667324f, 0.06164251f, 0.10704912f, 
    0.01418798f, -0.00576003f, -0.04196925f, -0.06055051f, -0.00413236f, 0.04825327f, -0.05751054f, 0.05982589f, 
    -0.01888038f, -0.19391705f, 0.12401928f, 0.16280714f, -0.00054383f, 0.08231635f, -0.04113035f, -0.18071063f, 
    0.01981660f, 0.14886843f, -0.06318783f, -0.03048344f, -0.25137097f, -0.32447124f, 0.10755544f, 0.09013379f, 
    0.09317117f, 0.04825363f, -0.09722675f, -0.09081604f, 0.21494699f, 0.01595148f, 0.00349376f, -0.11996713f, 
    -0.06321561f, -0.11789183f, -0.18817869f, -0.31317326f, 0.06730622f, -0.17961051f, -0.12215989f, -0.10217864f, 
    -0.05841810f, 0.03462014f, 0.10239185f, 0.18007597f, 0.11764968f, 0.11821115f, -0.05368597f, 0.06556927f, 
    -0.06569072f, -0.06408744f, 0.00691232f, 0.06685774f, -0.10176747f, 0.21074055f, 0.17305465f, 0.14523302f, 
    0.03083442f, 0.19920591f, -0.00856929f, -0.11965954f, 0.06749095f, -0.02683586f, 0.03819473f, 0.06955661f, 
    0.09892052f, 0.11115175f, 0.04011714f, 0.12155519f, -0.01329812f, -0.06509495f, -0.12172092f, 0.03631429f, 
    0.04517983f, 0.06358164f, 0.04107067f, -0.10951301f, 0.03403178f, -0.10177579f, 0.06246519f, -0.04475779f, 
    0.15928626f, 0.11419369f, -0.01093127f, -0.05534557f, 0.07592040f, -0.11939461f, 0.00646498f, 0.24085620f, 
    0.04458628f, 0.00276835f, 0.11962040f, -0.04934981f, 0.05747800f, -0.15168546f, 0.26087293f, 0.23077407f, 
    -0.03617922f, 0.06743447f, 0.12247875f, 0.09646694f, -0.01162373f, 0.13060947f, 0.12435602f, 0.14796752f, 
    0.12994148f, -0.20345753f, 0.14750972f, -0.14698982f, -0.03770921f, 0.07331470f, 0.05582397f, -0.06362422f, 
    -0.11473726f, 0.14148827f, 0.04536191f, -0.09294101f, 0.18592495f, -0.28009453f, -0.08064030f, 0.08688205f, 
    -0.16032130f, -0.14562842f, -0.13261038f, 0.00785002f, -0.02203763f, -0.10634260f, -0.00963903f, -0.04879856f, 
    -0.01493008f, -0.19010393f, -0.09569147f, 0.16343784f, -0.07700323f, 0.10745848f, -0.07736284f, -0.11242163f, 
    -0.05001360f, 0.17544441f, -0.01382292f, 0.04871504f, -0.00900406f, 0.06825040f, 0.20543584f, 0.16796803f, 
    0.04125145f, 0.08592482f, -0.04172207f, -0.03628002f, 0.04951781f, 0.06076695f, -0.10973844f, 0.03463565f, 
    -0.26005033f, -0.14591156f, 0.25546277f, -0.24444607f, -0.08982456f, -0.06711052f, 0.03990894f, 0.02196727f, 
    0.04056279f, 0.01276544f, 0.10191847f, 0.01798224f, -0.12582754f, -0.10022120f, -0.04636970f, -0.09149429f, 
    -0.17064580f, 0.06818462f, -0.02140384f, -0.05735827f, -0.02151488f, 0.08750258f, 0.09700499f, -0.01369701f, 
    -0.05096487f, -0.04507498f, -0.08300760f, 0.09553404f, 0.09336183f, -0.12623151f, 0.02888913f, 0.07905596f, 
    -0.07468945f, -0.07240370f, 0.04249860f, -0.05317210f, -0.07538106f, -0.32707596f, 0.05954336f, 0.16559412f, 
    -0.03233740f, 0.12987481f, 0.00142443f, 0.02719224f, 0.16126440f, 0.11438958f, -0.02658538f, -0.00415090f, 
    0.00234582f, -0.42240247f, -0.05935026f, 0.20423196f, -0.02518752f, 0.16318032f, -0.13117701f, -0.06452341f, 
    -0.01410807f, 0.12813458f, 0.00806791f, -0.10593120f, -0.09070691f, -0.02961819f, 0.11130415f, -0.13259710f, 
    0.04566015f, 0.02781889f, 0.03914839f, -0.03583091f, -0.08557231f, -0.05525265f, 0.01239279f, -0.00887834f, 
    -0.18109429f, 0.06905772f, -0.07886457f, 0.15400074f, 0.01035093f, 0.01901835f, -0.10829049f, 0.00260744f, 
    -0.08313714f, 0.09718525f, 0.14063627f, 0.11400688f, 0.29973999f, 0.15335299f, -0.00777065f, -0.17231242f, 
    0.07274236f, 0.09004796f, -0.12784964f, 0.23232882f, -0.03564684f, 0.11532636f, 0.14971893f, 0.10458582f, 
    0.10692564f, 0.15688664f, -0.01310787f, -0.11950086f, -0.14453988f, 0.05441261f, -0.03452825f, 0.01804081f, 
    -0.03343686f, 0.04439932f, 0.00774207f, 0.03261347f, 0.12168670f, -0.42879620f, 0.01160262f, 0.09538209f, 
    0.15841892f, 0.01811892f, 0.10924916f, 0.20422222f, 0.09569756f, 0.07661614f, -0.03337046f, 0.11283410f, 
    -0.32644096f, 0.18608701f, -0.06889820f, 0.11366863f, -0.15274514f, 0.16049942f, -0.01357678f, -0.03504076f, 
    0.15980034f, 0.05786681f, -0.13284102f, -0.06941672f, 0.34179750f, 0.03767393f, -0.21109673f, -0.12100352f, 
    -0.15278092f, -0.12005823f, 0.05013045f, -0.03400407f, 0.02472039f, -0.14629750f, -0.07675186f, -0.08524626f, 
    -0.30114156f, 0.24785158f, 0.24519438f, -0.16609414f, 0.07404269f, -0.04743059f, -0.13252690f, -0.00888358f, 
    0.06056278f, -0.06624093f, -0.04635036f, 0.08791497f, -0.11337228f, -0.25705886f, -0.22324005f, 0.08864574f, 
    0.15429662f, -0.10391203f, 0.09071358f, -0.07642268f, -0.07739700f, 0.08384286f, 0.09615045f, 0.23077260f, 
    -0.11485399f, -0.21186268f, 0.02042545f, 0.00319184f, 0.23898152f, -0.15164657f, 0.17156361f, 0.00625464f, 
    0.21125038f, -0.09882655f, 0.02627109f, -0.12644532f, 0.11119279f, 0.04068193f, -0.06297021f, -0.15880315f, 
    -0.00684259f, -0.09811837f, 0.07973424f, 0.04322216f, -0.10984003f, 0.13189426f, 0.19309282f, -0.04529214f, 
    0.31114918f, -0.39015773f, 0.16273811f, -0.20954619f, 0.06830081f, 0.06728573f, -0.05840993f, -0.06370874f, 
    0.11452448f, 0.14165258f, 0.09749553f, 0.10805646f, 0.09305576f, 0.13302726f, -0.08050048f, -0.13148454f, 
    0.07419888f, -0.07407641f, -0.17065318f, -0.17690001f, -0.02065641f, -0.14858952f, -0.02066408f, 0.10870448f, 
    0.07815573f, -0.04362990f, 0.33844796f, 0.01032811f, 0.08160810f, -0.08480561f, -0.08028048f, -0.00145089f, 
    -0.01248237f, 0.02293231f, 0.01677624f, 0.07024931f, 0.12355534f, 0.14813457f, -0.17118347f, 0.09304418f, 
    0.31613749f, -0.08821084f, 0.11396411f, 0.04503882f, 0.10654309f, 0.07496366f, 0.00550748f, -0.03838256f, 
    0.53951311f, 0.20093481f, -0.04752112f, 0.03426725f, 0.35633078f, 0.09504405f, 0.02584355f, 0.12046962f, 
    0.08790854f, 0.05072885f, 0.18238389f, 0.17539059f, -0.07792858f, 0.00027763f, -0.06218674f, -0.05923374f, 
    0.00900034f, 0.04071898f, 0.01161628f, 0.11956998f, 0.06501029f, 0.22178626f, 0.10080555f, 0.09219661f, 
    -0.22960997f, -0.09355751f, -0.24853937f, -0.30003974f, 0.19093111f, 0.08057477f, 0.06235422f, 0.06708147f, 
    0.13982765f, -0.02187262f, -0.02632164f, -0.07110164f, -0.26155654f, -0.22774753f, -0.03413207f, -0.04735694f, 
    -0.07519375f, -0.17790772f, 0.15697068f, -0.11620663f, -0.08877387f, -0.09715248f, -0.14678524f, -0.00349727f, 
    -0.21725968f, 0.14452918f, -0.06943987f, -0.13990480f, -0.03277197f, -0.00224259f, 0.01013095f, 0.09198370f, 
    0.04930487f, 0.02969925f, -0.09665472f, -0.05451216f, 0.22468178f, -0.21933797f, -0.06424347f, -0.00324968f, 
    0.06135422f, 0.09367745f, -0.04556343f, -0.03310922f, 0.01464054f, -0.02114757f, 0.02283216f, -0.01324157f, 
    -0.11920460f, 0.07588545f, 0.05911126f, -0.23471391f, -0.16860037f, -0.04737030f, 0.04593393f, -0.03331215f, 
    0.08950058f, -0.00069424f, 0.06545753f, -0.12202282f, 0.08145877f, -0.28219172f, -0.19974208f, -0.12717801f, 
    -0.17148842f, -0.23095801f, -0.02509909f, -0.03444406f, 0.02612676f, 0.09201881f, 0.15730029f, 0.16020446f, 
    0.17768204f, -0.24834555f, 0.07767811f, 0.03711218f, 0.00468056f, 0.00135999f, 0.06595986f, 0.02631406f, 
    -0.00980155f, -0.06705820f, 0.03429532f, -0.03157053f, 0.13274623f, 0.01551785f, 0.12389034f, 0.08853533f, 
    -0.04718240f, 0.05083785f, 0.13509704f, 0.11867797f, 0.17277467f, -0.11693633f, 0.08071884f, -0.16242781f, 
    -0.00096125f, 0.01933467f, 0.14172010f, 0.07910793f, 0.07941769f, 0.07374062f, -0.03689933f, 0.00904282f, 
    -0.04839200f, 0.11209536f, 0.03258042f, 0.11141439f, -0.01397354f, -0.15869620f, -0.01661700f, 0.05530459f, 
    -0.02447238f, -0.03727031f, 0.10822994f, -0.07816935f, 0.01791927f, 0.05675765f, -0.14374301f, 0.06108032f, 
    0.33888382f, -0.22342959f, 0.09132275f, 0.05522852f, -0.01245417f, -0.00290000f, -0.00375468f, 0.17696898f, 
    -0.15852077f, 0.04537347f, -0.06334831f, -0.13205791f, -0.35886717f, 0.30256760f, 0.12784520f, 0.01455213f, 
    -0.09284747f, -0.03570642f, 0.10348897f, 0.04184209f, 0.02651063f, 0.07031837f, 0.19114621f, -0.07592653f, 
    -0.15080084f, -0.34210503f, 0.06651524f, -0.28220102f, 0.06769693f, 0.01590463f, 0.21831881f, 0.08237091f, 
    0.04458917f, -0.02167870f, -0.01081297f, 0.03483742f, 0.28110677f, 0.10720813f, 0.35727510f, 0.14512415f, 
    0.15517972f, 0.12658510f, 0.11221326f, 0.07812396f, -0.01212071f, 0.04725393f, 0.06560320f, -0.00171628f, 
    -0.03887791f, -0.11175128f, -0.17431998f, 0.21309623f, 0.11365455f, 0.03109599f, 0.03896503f, 0.10567964f, 
    -0.05139195f, 0.06894471f, -0.08191906f, -0.00732050f, 0.11352861f, 0.20936967f, 0.27427894f, -0.20469229f, 
    -0.02225950f, 0.06981933f, 0.02736950f, 0.10038353f, -0.01374720f, 0.00769263f, 0.02329986f, -0.02312998f, 
    0.07131878f, 0.06978386f, 0.14856978f, 0.12351903f, -0.06137151f, 0.03718879f, 0.13327891f, 0.23373418f, 
    0.07377017f, 0.13503538f, 0.15760840f, 0.10149636f, 0.48446959f, -0.09679655f, 0.02987410f, -0.11336621f, 
    -0.09177330f, 0.09808575f, -0.06973004f, 0.09276414f, 0.08143377f, -0.03510430f, 0.06679631f, -0.15747720f, 
    0.01355837f, 0.00212341f, 0.04355606f, -0.05888226f, -0.06065080f, -0.07008073f, 0.05688863f, 0.00998030f, 
    -0.02827778f, -0.05795210f, 0.02646438f, -0.07929970f, 0.01178800f, -0.06062268f, -0.04636532f, 0.05410255f, 
    -0.01145606f, 0.05967834f, 0.04315626f, -0.04107993f, -0.01504242f, -0.03445126f, -0.04583459f, 0.01516947f, 
    0.01040718f, -0.01227808f, 0.01985686f, -0.06425131f, 0.04669104f, -0.05265765f, 0.04899071f, -0.00194166f, 
    -0.05610941f, -0.00646252f, 0.00106343f, 0.05843380f, 0.05943475f, -0.00426085f, 0.03716270f, -0.00023418f, 
    0.03289028f, -0.04808981f, 0.01859299f, 0.06003770f, -0.03991746f, 0.03967112f, -0.06308013f, -0.02361006f, 
    -0.05226416f, 0.04306479f, 0.03189839f, 0.03801351f, -0.02013420f, 0.01239861f, -0.06935356f, -0.01477492f, 
    -0.00813059f, 0.00095293f, 0.04590973f, 0.00030197f, -0.04797806f, -0.03160943f, 0.00911249f, -0.07995092f, 
    -0.03740157f, 0.03667018f, -0.06591821f, -0.06702820f, -0.05383812f, -0.05126962f, -0.04623600f, -0.07839744f, 
    -0.01259368f, -0.03467614f, 0.03441870f, -0.07347577f, 0.00032180f, -0.04658579f, 0.02965762f, -0.00882700f, 
    -0.07727968f, -0.03373515f, -0.01414139f, 0.00451722f, 0.01936892f, 0.03901586f, 0.02782341f, -0.04143308f, 
    -0.02931570f, -0.00510817f, -0.02815815f, 0.06352797f, -0.03935127f, 0.05160488f, 0.04114558f, -0.07590298f, 
    -0.07126518f, -0.02574751f, -0.00810384f, 0.05061498f, -0.05078504f, 0.01637675f, -0.05255292f, -0.01805876f, 
    0.02557358f, 0.04224272f, -0.00056649f, -0.06314306f, -0.04814854f, -0.02075677f, -0.01621426f, 0.04352467f, 
    0.01837890f, 0.05540010f, 0.06378850f, -0.06469566f, -0.06327748f, 0.01631315f, 0.06499496f, -0.02721392f, 
    -0.01378099f, 0.00717413f, -0.03997491f, -0.06374230f, -0.01983454f, -0.08032332f, -0.03971786f, -0.05757708f, 
    0.03139172f, 0.06312033f, -0.04801179f, -0.06777916f, 0.00027635f, -0.07731265f, -0.04782522f, 0.05376170f, 
    0.05438255f, -0.00674106f, 0.03304241f, -0.01239921f, -0.04701962f, 0.02160875f, 0.04142670f, 0.01637091f, 
    -0.05814049f, -0.07691224f, 0.00205233f, -0.04673836f, -0.07560533f, -0.00030651f, 0.00120292f, 0.03311323f, 
    0.01692135f, 0.03514056f, -0.06109271f, 0.02484793f, 0.03036084f, 0.00181666f, -0.01005869f, -0.00277375f, 
    -0.06179606f, 0.01246279f, -0.04001204f, -0.02568212f, -0.05724021f, -0.04567791f, -0.02252517f, 0.05427679f, 
    -0.05226666f, -0.05692433f, -0.05878734f, 0.03420202f, 0.04159571f, 0.00253202f, -0.05820150f, -0.02948696f, 
    0.01127377f, -0.03743482f, 0.05754507f, 0.00827519f, -0.03280842f, -0.03588584f, 0.00455202f, 0.01676833f, 
    0.06069807f, -0.01007042f, -0.01575449f, -0.02326827f, -0.01879136f, -0.06183241f, -0.02914908f, 0.00139011f, 
    0.15724388f, 0.52950513f, 0.06864166f, -0.26097795f, 0.06088898f, 0.07913336f, -0.09969717f, 0.07860954f, 
    0.11745019f, 0.04105453f, -0.04902050f, 0.02274836f, 0.33436641f, -0.10212089f, -0.03716700f, 0.04420800f, 
    0.01188424f, 0.02168700f, -0.02131950f, -0.10471405f, -0.00720120f, 0.15262602f, -0.10804837f, -0.14139524f, 
    -0.01100444f, 0.25448215f, 0.12573028f, 0.20346580f, 0.05579837f, 0.04233639f, 0.01762678f, 0.11991679f, 
    0.01469181f, 0.03967779f, -0.03711214f, -0.18911923f, 0.44615835f, 0.07292677f, 0.10493876f, 0.05687301f, 
    -0.02970298f, 0.04402829f, -0.02525118f, -0.00978898f, -0.01508085f, 0.06254033f, 0.05031392f, 0.02211612f, 
    0.33910367f, -0.15812048f, -0.06571677f, 0.06985351f, -0.06018189f, -0.08710052f, -0.05101640f, 0.04984884f, 
    -0.02067188f, 0.00623138f, -0.00483199f, 0.09191311f, 0.06086233f, -0.44039559f, -0.25003761f, 0.30337590f, 
    -0.00041630f, -0.10661259f, 0.06228027f, -0.00840762f, -0.02467461f, -0.09170341f, -0.02666879f, 0.18857825f, 
    0.05163002f, -0.11168994f, -0.03392313f, -0.06886764f, 0.16335228f, -0.10391234f, 0.12685686f, -0.06319486f, 
    0.03948045f, 0.03904707f, 0.07295673f, -0.12742268f, 0.24010706f, 0.01765217f, 0.10972403f, -0.01201114f, 
    -0.06865573f, 0.02939338f, -0.01157788f, -0.09963843f, -0.03450402f, 0.02470680f, -0.04405309f, 0.05351143f, 
    -0.00753868f, -0.29933172f, -0.06436156f, -0.18923377f, -0.05914551f, -0.03001802f, 0.13425240f, -0.01733488f, 
    -0.06734685f, 0.06102742f, 0.01499783f, 0.10383178f, -0.12188449f, -0.04902840f, -0.08179180f, -0.19017851f, 
    -0.11055171f, -0.09844679f, 0.07165795f, -0.08414957f, -0.03099383f, -0.04978837f, -0.02627391f, 0.02214014f, 
    0.27429274f, 0.17356975f, 0.22594281f, -0.22001596f, 0.10260854f, 0.08056641f, -0.06412261f, -0.06950536f, 
    -0.06113562f, 0.08617582f, 0.04943565f, -0.05082818f, 0.23325188f, 0.02350490f, -0.10122773f, 0.25419122f, 
    0.11497457f, 0.02874209f, 0.15669097f, 0.06446677f, -0.05723466f, 0.02240713f, -0.05004039f, -0.05864246f, 
    0.37981558f, -0.03595166f, -0.36338279f, -0.00979589f, 0.16137823f, 0.20573306f, -0.00088942f, 0.05456598f, 
    -0.09528735f, -0.18240172f, 0.09124763f, -0.14724372f, 0.00442336f, -0.05197231f, 0.01837166f, -0.07593460f, 
    -0.00764966f, -0.03753452f, 0.07256529f, 0.07599247f, -0.07160800f, -0.03452620f, 0.11341588f, -0.04477309f, 
    -0.34022471f, -0.06787130f, 0.04315898f, 0.08223084f, 0.02184269f, 0.09251630f, 0.03906512f, 0.01516775f, 
    -0.01688502f, 0.03296575f, 0.11374076f, -0.16704009f, 0.13443139f, 0.24341610f, -0.03568151f, -0.04788598f, 
    0.07178551f, 0.01770776f, 0.00865946f, 0.02237733f, 0.00044725f, -0.00014442f, 0.03658499f, 0.07898482f, 
    0.06607568f, 0.31841514f, 0.11442176f, -0.09258261f, -0.02619044f, -0.03453915f, 0.13548598f, 0.04122331f, 
    0.08699523f, 0.11193005f, -0.15444359f, 0.15524487f, 0.32051975f, 0.17718151f, -0.09614755f, -0.14692467f, 
    -0.14485142f, 0.05446750f, -0.03370525f, 0.07482071f, 0.04443219f, -0.16695610f, 0.14437273f, -0.00715037f, 
    0.16638763f, -0.01372784f, -0.03717120f, -0.06661742f, 0.14034677f, 0.26014844f, 0.11459051f, -0.03202505f, 
    -0.09929883f, 0.01048883f, -0.05188908f, -0.04576143f, 0.44840327f, -0.03388698f, -0.05300339f, -0.18351366f, 
    -0.19499314f, 0.01592343f, -0.02088993f, -0.08753477f, 0.06046515f, 0.03345000f, -0.03479224f, -0.01384384f, 
    -0.14959605f, -0.41796520f, 0.06539486f, -0.02655879f, 0.07638109f, 0.23878445f, 0.17206638f, -0.12743442f, 
    0.12024072f, -0.02960991f, -0.14357875f, -0.04601622f, -0.43529299f, -0.12674175f, 0.12643655f, -0.03124006f, 
    -0.05653698f, 0.00091986f, 0.09792749f, -0.07137086f, 0.20358977f, 0.11333159f, -0.06999216f, 0.13244167f, 
    -0.24439242f, 0.06794001f, 0.07868376f, -0.01136584f, 0.01684912f, 0.01798929f, 0.21399139f, 0.05172009f, 
    0.07211427f, -0.01954363f, 0.20817657f, 0.04662400f, -0.02209902f, -0.02674175f, -0.04344546f, -0.12290106f, 
    0.12621678f, 0.07051138f, 0.05241813f, -0.02627154f, -0.04336398f, -0.03662628f, 0.03346057f, 0.19490400f, 
    -0.39504164f, -0.22280587f, 0.06364091f, 0.11969862f, 0.06762629f, 0.03831486f, 0.21063533f, 0.08388790f, 
    0.17088276f, 0.11331959f, -0.01249599f, 0.02407849f, -0.35110506f, 0.07840215f, -0.05287673f, 0.07345890f, 
    -0.10745503f, 0.06296031f, -0.00729082f, -0.01057091f, -0.03707998f, -0.13433091f, -0.06785534f, -0.02478568f, 
    -0.04738928f, 0.01140554f, 0.08671735f, -0.24712446f, 0.00045931f, 0.11786757f, 0.26532462f, -0.05848099f, 
    0.06678765f, -0.04436312f, -0.04151204f, -0.04265938f, 0.41565710f, 0.11976598f, 0.31312898f, 0.18737713f, 
    -0.00190321f, 0.12939489f, 0.09982857f, -0.02060773f, -0.12650734f, -0.21471749f, 0.12255781f, -0.00678692f, 
    -0.20366430f, -0.00125471f, 0.00583040f, 0.28855699f, 0.13436486f, 0.10448667f, -0.01601836f, -0.09083762f, 
    0.03398174f, 0.04305829f, 0.07137405f, 0.07247440f, -0.51547182f, -0.05087176f, 0.23138462f, -0.18528385f, 
    -0.00367991f, 0.09639935f, 0.06744520f, 0.14179900f, -0.00604569f, -0.14892474f, 0.09850077f, -0.06018337f, 
    0.04014111f, -0.00881984f, 0.04716109f, 0.09449667f, -0.07820552f, 0.00623782f, -0.01875756f, 0.00163108f, 
    -0.03764630f, -0.02019158f, -0.05112351f, -0.00085669f, 0.38514322f, 0.24093141f, 0.10475827f, 0.08066601f, 
    0.05715736f, 0.09054753f, -0.08829036f, -0.01777318f, 0.09274921f, -0.02067672f, -0.03869201f, 0.12267062f, 
    0.13727145f, 0.11551346f, 0.05645390f, 0.15775351f, -0.11346225f, -0.05716737f, -0.03953622f, 0.03740109f, 
    -0.09499849f, -0.07404450f, 0.10784616f, -0.07541644f, -0.36523357f, 0.18594648f, 0.01796531f, 0.13467379f, 
    0.12797488f, -0.05690620f, 0.06297568f, 0.09023343f, -0.08993192f, 0.00870504f, -0.01117675f, -0.02368821f, 
    0.00180485f, 0.18405108f, -0.09412226f, 0.05286567f, 0.03819503f, -0.07183628f, -0.09075894f, 0.04676554f, 
    -0.01548883f, -0.08628004f, 0.05594509f, -0.08556312f, -0.06444854f, 0.28542373f, 0.14794102f, 0.33956492f, 
    -0.02889730f, -0.05615988f, 0.20075233f, 0.14464003f, -0.06345970f, 0.05356370f, -0.07363562f, -0.01999604f, 
    -0.27230176f, 0.27402011f, 0.06222581f, -0.11735450f, 0.01476115f, -0.00663016f, 0.01169843f, 0.03884432f, 
    0.06598227f, 0.12878300f, 0.12751846f, -0.05239322f, 0.13300134f, -0.00245410f, -0.09831488f, -0.03404020f, 
    0.07827020f, 0.00648416f, -0.03665468f, 0.00582538f, -0.04432204f, -0.03055074f, -0.00975010f, -0.04377995f, 
    -0.21540082f, -0.11841886f, -0.00996034f, 0.09527118f, 0.11207899f, 0.00094110f, 0.09519686f, 0.03165850f, 
    -0.03936825f, 0.13634080f, -0.10012816f, -0.05176593f, 0.21873589f, 0.14474621f, -0.04811468f, 0.08394336f, 
    0.01874908f, 0.12787293f, -0.10243954f, -0.01963393f, -0.03173710f, -0.07009106f, -0.16483334f, -0.05008525f, 
    -0.06644350f, -0.05011947f, 0.26270285f, 0.03625380f, 0.10513329f, -0.02705395f, 0.15759066f, -0.11144713f, 
    0.08896477f, 0.09827473f, 0.04949195f, 0.01056378f, 0.03599476f, -0.29999557f, -0.02033838f, -0.09973325f, 
    -0.03451860f, 0.00732335f, 0.15012988f, -0.04208863f, -0.03087245f, -0.05197234f, -0.02508285f, 0.04934031f, 
    0.07164669f, -0.06063139f, -0.19644660f, 0.43049920f, 0.14475918f, -0.00473920f, -0.04677602f, 0.03811053f, 
    0.00095085f, 0.02368524f, -0.02536015f, 0.07060974f, -0.14392018f, -0.01947639f, -0.30086583f, 0.03018042f, 
    0.15995038f, -0.08237711f, 0.02003484f, 0.00194226f, 0.06921140f, -0.05021956f, -0.00098135f, 0.04240592f, 
    0.33104545f, -0.05633179f, -0.17902519f, 0.07951315f, 0.00267907f, 0.06481425f, -0.11599818f, -0.04864410f, 
    0.12563325f, 0.05985047f, 0.03809516f, 0.01543257f, -0.03716520f, -0.22590089f, 0.04680163f, 0.05717213f, 
    -0.04165185f, -0.02933165f, 0.19067332f, -0.06090246f, 0.10458569f, 0.09164334f, -0.01421005f, -0.13830006f, 
    -0.07871730f, -0.05552339f, -0.17925215f, -0.15120041f, 0.03624452f, 0.01111464f, -0.01188093f, -0.02253641f, 
    0.01909586f, 0.17404181f, 0.09458279f, 0.06463934f, 0.24111101f, -0.05279915f, -0.09179427f, 0.04311787f, 
    -0.06946272f, -0.11825933f, -0.00658021f, 0.11419496f, -0.17503598f, 0.06638596f, 0.15112279f, 0.09864479f, 
    -0.61924845f, 0.02748839f, -0.03806702f, 0.01172820f, -0.06099606f, -0.11830661f, 0.02966318f, 0.06814709f, 
    -0.03413674f, 0.05486916f, -0.12330401f, -0.19565582f, -0.23407491f, 0.04339011f, -0.01966242f, -0.15860230f, 
    0.08191294f, -0.11640640f, 0.01635982f, -0.02212980f, 0.00848345f, -0.10504345f, 0.06011530f, -0.00760835f, 
    0.24379522f, 0.17349704f, 0.10919977f, -0.09026068f, -0.02383558f, 0.00974438f, -0.08101796f, 0.11608360f, 
    0.01847726f, -0.15483050f, 0.15217221f, 0.15903282f, -0.39484832f, -0.05513927f, -0.16834550f, -0.00956742f, 
    -0.03990564f, -0.01693010f, 0.11369705f, -0.08615898f, 0.02131589f, 0.12914798f, 0.12680432f, 0.12428219f, 
    -0.21617819f, -0.03541768f, 0.13488314f, 0.21577035f, 0.07139776f, 0.13346580f, 0.04565705f, -0.04775305f, 
    0.02801223f, 0.10497871f, -0.01264897f, 0.06827382f, 0.00346681f, 0.00742184f, 0.02344414f, -0.07467227f, 
    0.06479514f, 0.03109693f, 0.08963680f, 0.10241041f, 0.06862567f, -0.08181217f, -0.07946811f, -0.11908066f, 
    -0.21922272f, -0.07317729f, -0.10348523f, 0.04261203f, -0.02208290f, 0.23727483f, -0.07003533f, -0.02900841f, 
    -0.22922988f, 0.03487033f, -0.10369308f, 0.06682266f, 0.26825187f, 0.15619051f, -0.10520171f, 0.09360110f, 
    0.08337089f, -0.11436774f, -0.04308854f, 0.10676400f, 0.10374272f, 0.03738215f, -0.02695854f, 0.02143288f, 
    0.14003097f, -0.00828841f, 0.01394693f, 0.34142467f, -0.05646416f, 0.09259611f, -0.14647761f, 0.07199573f, 
    0.12983154f, 0.09993498f, -0.01138566f, -0.01831689f, -0.18940069f, -0.05708125f, 0.20697756f, 0.19894211f, 
    -0.09053587f, 0.18162446f, 0.12371643f, 0.10492557f, 0.04534135f, 0.17038536f, 0.04140193f, 0.04073806f, 
    -0.26955056f, -0.18388751f, -0.39317966f, 0.15853675f, 0.12453273f, -0.07487496f, 0.15445352f, 0.08513653f, 
    -0.02473929f, 0.05477761f, -0.04555108f, 0.00876362f, -0.01307802f, 0.07930225f, 0.21967457f, 0.33460402f, 
    -0.01532379f, -0.01300093f, 0.10038611f, -0.06378055f, 0.17488971f, 0.08339510f, -0.02436664f, 0.00673416f, 
    -0.01925002f, -0.37358397f, -0.19636820f, 0.29391530f, -0.11871343f, 0.13826853f, -0.04736670f, 0.03799780f, 
    0.10510459f, -0.01493594f, -0.08783477f, -0.05169079f, 0.10740370f, -0.11314816f, 0.16421634f, 0.29196277f, 
    -0.02927186f, 0.19926107f, -0.04949919f, 0.08215444f, 0.16197188f, -0.11844613f, 0.02182603f, -0.08898474f, 
    -0.03953940f, -0.13224719f, -0.07836179f, -0.12551253f, -0.05212808f, -0.03372948f, 0.08376157f, 0.19088921f, 
    0.12588513f, 0.03528130f, 0.14458862f, 0.14305395f, 0.45013377f, 0.06660241f, 0.06724128f, -0.12449168f, 
    -0.23708922f, -0.03091108f, 0.03468623f, 0.11097228f, -0.19062130f, 0.17111778f, 0.17958777f, -0.06406172f, 
    -0.07096960f, -0.06631638f, 0.05500501f, 0.01470034f, -0.06673065f, -0.02624422f, -0.02922644f, 0.04411899f, 
    0.02058524f, -0.03276781f, 0.03467187f, -0.05732442f, 0.00773652f, -0.02276416f, 0.01952642f, -0.05925843f, 
    0.03886616f, -0.07724760f, -0.02821077f, -0.05389068f, 0.05154531f, 0.01189910f, -0.00219139f, -0.05554346f, 
    -0.00241292f, -0.00704903f, -0.07120735f, 0.01659149f, -0.02070887f, 0.04015864f, -0.02302712f, -0.01506123f, 
    -0.04737887f, -0.01729863f, 0.04445680f, 0.04856941f, -0.02138940f, -0.02550594f, -0.03327587f, -0.02603410f, 
    0.04801346f, 0.00849235f, -0.03448118f, -0.04716194f, 0.02902985f, -0.04865096f, 0.03558356f, -0.06734624f, 
    -0.01164423f, -0.05139932f, -0.02884776f, 0.04411212f, -0.06087793f, 0.01524788f, 0.04337370f, 0.02626955f, 
    -0.07105201f, -0.00694552f, 0.04280947f, -0.05311096f, -0.01841483f, -0.04869445f, -0.06159076f, -0.02854763f, 
    -0.04765465f, -0.02877799f, 0.03208702f, -0.02746267f, 0.01811751f, -0.07149817f, -0.06429195f, -0.01406315f, 
    0.04714994f, -0.02602974f, 0.02044563f, -0.04463964f, 0.05337275f, 0.06354041f, -0.06615796f, 0.03472175f, 
    -0.05647865f, -0.02315570f, -0.02224467f, -0.01576133f, 0.05572219f, -0.04393330f, -0.02571155f, 0.01639903f, 
    0.00774898f, 0.06050355f, -0.03836151f, 0.02582604f, -0.04328127f, -0.06199269f, -0.00668165f, -0.07657173f, 
    -0.06070456f, 0.03652324f, 0.01825190f, -0.02205506f, -0.02152916f, -0.02564112f, 0.01333167f, 0.00480021f, 
    -0.02199166f, -0.03598573f, -0.02055880f, -0.06640434f, 0.02611876f, 0.03285645f, -0.04369952f, 0.02614097f, 
    0.03913015f, -0.06961831f, 0.02722031f, -0.07536492f, -0.02066501f, -0.02690109f, 0.03030528f, -0.07528745f, 
    -0.06134010f, 0.04851196f, -0.03302256f, 0.05719166f, 0.03343642f, -0.02246559f, 0.00647586f, -0.01557273f, 
    0.05263336f, 0.01912156f, -0.00133893f, 0.04060265f, -0.00946411f, -0.05814582f, -0.00667764f, -0.04385130f, 
    -0.02503800f, 0.03852906f, -0.04504704f, -0.04664414f, 0.01200183f, -0.05537704f, -0.06727986f, -0.02719314f, 
    -0.05380643f, 0.02685790f, 0.00665831f, -0.03005812f, -0.02971430f, 0.03861199f, 0.00719632f, 0.06059486f, 
    0.05677474f, 0.03986613f, 0.03788783f, 0.04352300f, -0.05100438f, 0.03520681f, 0.02762245f, 0.01360296f, 
    0.00155376f, -0.01554364f, -0.06689158f, -0.03645837f, -0.05951814f, 0.00885029f, -0.06242542f, -0.02876632f, 
    -0.02498180f, 0.04311045f, -0.07459170f, -0.01005937f, 0.01480698f, -0.00939772f, 0.05635604f, -0.00317108f, 
    0.03149470f, -0.06755780f, -0.01952609f, -0.06401610f, 0.01851559f, 0.05694149f, 0.03868810f, 0.01037356f, 
    -0.05014888f, -0.03207986f, 0.06540047f, -0.06639715f, 0.05378917f, 0.04886614f, -0.02999488f, 0.05913239f, 
    0.26626840f, -0.28438827f, -0.17785546f, -0.11208807f, 0.08232438f, 0.01452584f, 0.00938551f, -0.01921559f, 
    0.15572004f, 0.00344465f, 0.06155734f, 0.03323520f, 0.21269217f, -0.18068896f, 0.17012222f, -0.01006385f, 
    0.11955868f, 0.00785477f, -0.00149782f, -0.06058777f, 0.12081784f, 0.21493721f, -0.05469204f, 0.22492082f, 
    -0.26291263f, -0.07082279f, -0.03461202f, 0.17397164f, 0.03679804f, 0.12547405f, 0.18715419f, 0.02182235f, 
    0.01450246f, 0.08343599f, -0.16376217f, 0.07534711f, 0.07810946f, -0.18432955f, -0.27142447f, -0.15218316f, 
    0.02137428f, -0.02028057f, -0.06630323f, -0.05528641f, 0.04132132f, -0.00387950f, -0.08375794f, -0.09059120f, 
    0.08539221f, -0.11082084f, 0.12446747f, 0.02222948f, 0.13925533f, 0.00110003f, -0.04899704f, -0.01381541f, 
    0.01187502f, -0.14254160f, -0.08750004f, 0.09906206f, -0.18552606f, 0.01802523f, 0.07415970f, 0.04499254f, 
    0.05520974f, -0.06555965f, -0.01362113f, -0.09584672f, 0.03535276f, 0.13377288f, -0.05561722f, 0.31101361f, 
    0.07814594f, 0.08244223f, 0.26958695f, -0.07294467f, 0.01954761f, -0.03539712f, 0.06512361f, 0.08743696f, 
    0.26175281f, -0.13593820f, 0.15012389f, -0.13504070f, -0.19378659f, -0.10797497f, -0.04858397f, -0.07592933f, 
    0.02304601f, 0.04754593f, 0.10520924f, 0.13947468f, 0.15867451f, 0.05107168f, 0.26687860f, 0.07725661f, 
    0.05528771f, -0.14147805f, 0.01690163f, -0.07217648f, 0.09545753f, 0.12306818f, -0.04394626f, -0.00602346f, 
    -0.05953575f, 0.05133810f, 0.10767450f, -0.03141775f, 0.32365513f, 0.24055471f, -0.01576422f, 0.01766440f, 
    0.09528533f, 0.01422235f, -0.11146554f, -0.08063771f, -0.10822397f, -0.07367285f, -0.05843402f, 0.02668493f, 
    -0.04177528f, -0.18899274f, 0.39670148f, -0.30131203f, 0.01085250f, 0.00090375f, -0.00647947f, 0.00296099f, 
    0.16077511f, 0.08701727f, 0.12650873f, 0.02512696f, 0.14811718f, 0.11728738f, -0.02708677f, -0.13860911f, 
    -0.00725747f, -0.02026466f, 0.03654803f, 0.04145727f, -0.03514848f, 0.01995403f, 0.07353386f, 0.01873472f, 
    -0.03693958f, 0.28199825f, 0.21394262f, -0.04475632f, 0.23781057f, -0.13889328f, 0.27245504f, 0.10332246f, 
    -0.04069074f, 0.04680614f, 0.12968576f, 0.15198936f, 0.01412571f, 0.15814823f, 0.02993378f, -0.13017210f, 
    0.00939450f, -0.04345670f, -0.10919419f, 0.01803162f, -0.04105970f, 0.13020313f, 0.12062744f, 0.04297153f, 
    0.06614254f, 0.11391120f, 0.12145561f, 0.11128284f, 0.02273614f, 0.02475973f, 0.02477671f, 0.04812740f, 
    0.03976538f, -0.07395235f, -0.11501628f, -0.08368726f, -0.35461006f, -0.26005369f, -0.05936829f, 0.20867364f, 
    0.15609229f, 0.03994574f, 0.11848051f, -0.26333645f, 0.26335377f, -0.10965253f, -0.20277451f, 0.02036084f, 
    -0.35633960f, -0.15584813f, -0.07563612f, -0.40314463f, 0.12640199f, 0.02432940f, 0.05451220f, -0.06656801f, 
    0.02312314f, -0.00845295f, -0.01103861f, -0.08505076f, -0.15420936f, 0.00524007f, 0.01313905f, -0.10821919f, 
    0.18361515f, -0.06192627f, 0.01561675f, -0.07934184f, -0.07268724f, 0.12078892f, -0.13714316f, 0.01021178f, 
    -0.27656919f, 0.14262879f, 0.11058252f, 0.36331752f, -0.05616113f, 0.07899819f, -0.07801815f, 0.18927503f, 
    -0.06441338f, -0.04371824f, -0.08194567f, 0.09476271f, -0.54065800f, 0.05021255f, -0.62260592f, -0.11770105f, 
    0.07338255f, 0.12129905f, 0.05165448f, 0.08829898f, -0.00630464f, 0.01899643f, 0.01164443f, -0.09633959f, 
    0.14262310f, 0.02151826f, -0.09671336f, 0.10065316f, 0.02822934f, 0.08331431f, -0.16660133f, -0.00786032f, 
    -0.05094284f, -0.05917976f, -0.06946525f, 0.10269679f, 0.18284409f, -0.02768405f, 0.02862075f, 0.14458033f, 
    0.01948242f, -0.02669649f, 0.16703844f, -0.03253459f, -0.04531892f, 0.04638023f, 0.06951795f, 0.18600056f, 
    0.15679489f, 0.04364038f, 0.07301836f, -0.17379788f, 0.11366692f, -0.05565674f, -0.01561123f, 0.22060299f, 
    0.05176204f, -0.07172106f, -0.10206763f, -0.12629703f, 0.27514890f, -0.06031481f, -0.14435324f, 0.23828353f, 
    0.11620514f, -0.00428813f, -0.02995639f, -0.01938886f, 0.17592593f, 0.11634674f, 0.21470656f, -0.02495665f, 
    0.09714318f, -0.06782022f, -0.03254261f, 0.10645186f, 0.02718669f, 0.06127695f, 0.05080907f, -0.06082715f, 
    -0.09429969f, -0.01451993f, 0.04059817f, -0.00081789f, 0.41326344f, 0.03318244f, 0.15483262f, -0.13422117f, 
    -0.01513122f, -0.13042770f, 0.00376939f, -0.05496523f, 0.00921324f, 0.02383574f, 0.01144221f, 0.14223413f, 
    0.38546741f, -0.18794356f, -0.02140983f, -0.04772184f, 0.05666220f, -0.08953911f, -0.08491224f, -0.02692552f, 
    0.15254775f, 0.11672448f, 0.02103173f, -0.05343637f, 0.08823128f, 0.06409714f, -0.08350261f, 0.41593474f, 
    -0.03708297f, -0.26688051f, 0.02575659f, 0.08267123f, -0.11666147f, 0.02252594f, -0.08209876f, 0.15174589f, 
    0.54774630f, 0.27242407f, 0.08990278f, 0.18539871f, 0.07590149f, -0.10250925f, 0.07831442f, 0.13988270f, 
    0.01255567f, -0.19219874f, 0.11549393f, 0.15923986f, 0.30673295f, 0.05176580f, 0.11194705f, 0.20800890f, 
    -0.05074673f, 0.02366056f, 0.06460826f, 0.11115606f, 0.01504335f, 0.04887831f, 0.08404975f, 0.13300972f, 
    0.08404639f, -0.02955216f, 0.09986239f, -0.26441908f, -0.02768044f, 0.16313431f, 0.10823473f, 0.08218675f, 
    0.08502589f, -0.19167343f, -0.12722640f, -0.04850656f, -0.22303629f, -0.07173000f, 0.18711308f, 0.14043061f, 
    -0.06423108f, -0.04334201f, -0.00841788f, -0.07493944f, 0.02143288f, 0.01292663f, -0.16274202f, -0.24534808f, 
    0.04327055f, 0.01846799f, -0.07104100f, -0.03692756f, 0.06011516f, 0.02944081f, 0.00344945f, 0.02214603f, 
    0.05097229f, 0.05365900f, -0.06151256f, 0.02043361f, 0.00444768f, 0.02764638f, 0.05401279f, -0.00037128f, 
    -0.06626774f, 0.01388038f, -0.06417794f, -0.00595114f, -0.04910709f, -0.07778611f, 0.05655361f, -0.03744595f, 
    -0.05424796f, -0.07472344f, -0.06715467f, 0.01866724f, -0.02266694f, 0.00056174f, -0.04736134f, 0.01552904f, 
    0.03564247f, -0.05411779f, 0.01498502f, -0.07916477f, -0.02535132f, -0.07086605f, 0.06408242f, 0.02082297f, 
    -0.05539265f, -0.03134422f, 0.02910376f, 0.03895001f, -0.00020714f, -0.01934584f, 0.00319489f, -0.05401945f, 
    0.01228718f, 0.05075257f, 0.01402289f, -0.00396340f, 0.03101674f, 0.01531414f, -0.03427387f, 0.04046628f, 
    0.05824455f, -0.04612545f, -0.00151195f, -0.03404740f, -0.03286093f, -0.06035854f, 0.00069153f, -0.02487644f, 
    -0.06868654f, -0.05767940f, 0.05850043f, -0.05724380f, -0.00396438f, -0.07043592f, -0.06530862f, -0.04923771f, 
    -0.05217555f, -0.02246326f, -0.06569889f, -0.05190676f, 0.00456545f, -0.06366795f, -0.03437855f, -0.07692628f, 
    0.00927162f, -0.07639626f, 0.04290569f, -0.02807253f, -0.05097964f, 0.05276773f, -0.06640982f, 0.03394665f, 
    0.00172386f, -0.07564042f, -0.04195644f, 0.03542421f, 0.00503674f, 0.00342890f, 0.03991217f, 0.01036005f, 
    0.01669017f, -0.04306372f, 0.00750981f, 0.06022404f, -0.06410725f, -0.02813215f, 0.02149139f, 0.05607348f, 
    0.02056710f, -0.00509135f, -0.00979316f, 0.01676488f, 0.04367132f, -0.07984416f, 0.06361334f, -0.06842582f, 
    -0.04025941f, -0.02893895f, 0.05028911f, 0.05889870f, 0.05561301f, -0.03136369f, -0.03403236f, 0.03684679f, 
    -0.05902214f, -0.05551112f, 0.01488754f, -0.04036474f, -0.00120125f, -0.04388212f, -0.01963138f, 0.03028604f, 
    0.00275563f, -0.00253450f, 0.01082745f, 0.00925452f, 0.03370234f, -0.04810154f, 0.03516174f, 0.05116547f, 
    0.01409306f, 0.01173973f, 0.02924443f, 0.04493874f, -0.05602948f, -0.02020976f, 0.04420987f, 0.03918171f, 
    0.03972742f, 0.00792271f, 0.03976922f, 0.02018535f, 0.00132552f, 0.03906937f, -0.01003287f, 0.05470419f, 
    0.00139571f, -0.02775479f, -0.05307801f, -0.05501385f, -0.07015268f, -0.05239545f, 0.00986649f, 0.05452653f, 
    -0.00116943f, -0.07273352f, 0.01270108f, -0.02574099f, -0.02420343f, -0.01776678f, 0.03175792f, -0.06496257f, 
    0.00533268f, -0.01085104f, -0.03753467f, -0.06863119f, -0.03615078f, -0.00757072f, 0.02732691f, 0.01470805f, 
    0.00630381f, -0.04513099f, -0.06431576f, -0.06471670f, -0.00096811f, -0.01554666f, 0.01554851f, -0.07667608f, 
    -0.03086589f, -0.01897324f, 0.04014001f, -0.03015717f, 0.04283443f, 0.00387580f, -0.04321634f, -0.04935028f, 
    0.36086744f, -0.25022113f, 0.01409734f, 0.21440518f, -0.12720256f, -0.08453285f, -0.03924837f, -0.06675216f, 
    0.07176332f, -0.12075134f, 0.15553910f, 0.01706745f, -0.12603237f, 0.05899552f, -0.00416028f, 0.04736960f, 
    0.09760148f, -0.01646346f, 0.10223170f, 0.16718043f, 0.04315779f, 0.07733497f, -0.02064467f, 0.06786133f, 
    -0.21670206f, -0.09803817f, -0.08992355f, -0.12337694f, -0.08874308f, -0.01925462f, -0.01138293f, 0.06756077f, 
    0.04120041f, 0.00811981f, 0.04208506f, 0.19408228f, -0.12397463f, 0.04261833f, -0.00878953f, 0.11517272f, 
    -0.05626532f, -0.07862791f, -0.04027831f, 0.18695433f, 0.10093339f, -0.00009513f, -0.11998168f, -0.23254846f, 
    -0.16812770f, 0.35089082f, 0.02497210f, -0.05489422f, 0.01353071f, 0.06035627f, -0.04103206f, 0.11200586f, 
    -0.04462146f, 0.03305920f, -0.06501022f, 0.07561525f, -0.13125569f, -0.01176246f, 0.03762157f, 0.11855529f, 
    0.27572298f, 0.00901182f, 0.00515259f, -0.19633484f, -0.06123862f, 0.23855582f, -0.01807650f, 0.09089577f, 
    0.09318480f, 0.11714553f, -0.11651739f, 0.09174999f, -0.00574470f, 0.04823685f, 0.06466349f, 0.02733905f, 
    0.19212404f, -0.04908787f, 0.07096373f, -0.20039083f, -0.31725940f, 0.02900227f, -0.20149659f, -0.05566939f, 
    -0.01216618f, -0.05702669f, 0.02228474f, 0.13036589f, 0.01510544f, 0.09678965f, 0.20695111f, 0.03751488f, 
    0.12374359f, 0.10661128f, 0.00871518f, -0.13497554f, 0.06865673f, 0.12449038f, -0.01283644f, -0.19662809f, 
    0.09654019f, -0.03921081f, 0.12866980f, 0.11641594f, 0.55734199f, 0.00758873f, -0.25417972f, 0.05693192f, 
    0.24321884f, 0.11835861f, -0.24281463f, -0.07781921f, -0.15187977f, 0.14213790f, -0.11678764f, 0.06778169f, 
    -0.42814180f, 0.27300456f, -0.01394913f, 0.36276349f, -0.18087800f, -0.17144334f, -0.05469557f, -0.04827098f, 
    0.08530387f, -0.05622838f, 0.04871477f, 0.05130134f, -0.34229359f, 0.06308295f, -0.42566076f, -0.20340370f, 
    0.17769985f, -0.04494083f, 0.01228321f, 0.02264754f, 0.06743655f, 0.07419214f, -0.09334399f, -0.03804605f, 
    0.05231626f, 0.09045210f, 0.06290738f, -0.32058355f, 0.11075458f, 0.10993788f, 0.10718023f, 0.08301546f, 
    0.14707328f, 0.04953469f, -0.02129859f, 0.02718687f, 0.20322922f, -0.02220820f, -0.13116819f, 0.14618234f, 
    0.15184814f, 0.12263618f, 0.04815074f, -0.12030516f, -0.01252427f, 0.25033069f, 0.08085518f, -0.01519371f, 
    0.16042615f, 0.03212865f, -0.07121227f, 0.18197834f, 0.31326243f, 0.02251455f, -0.04971863f, -0.18375437f, 
    0.02231088f, 0.00558302f, -0.13108134f, -0.16478457f, -0.51153737f, -0.24257635f, 0.01084001f, 0.07431918f, 
    0.02446359f, 0.00028206f, 0.06712811f, -0.01929584f, 0.04664792f, -0.08975573f, -0.17042801f, 0.19989607f, 
    -0.11319116f, -0.40348724f, -0.22387047f, -0.04629893f, 0.32938921f, 0.15530103f, -0.10584138f, 0.00760858f, 
    -0.00533846f, -0.03969711f, -0.05383304f, 0.00790690f, 0.01561201f, -0.26185995f, -0.33073044f, -0.09248985f, 
    0.05646936f, 0.01421619f, 0.26028353f, -0.00432422f, -0.09159417f, 0.16765329f, 0.26440343f, -0.00684057f, 
    0.15905580f, 0.05299431f, 0.34567124f, 0.37775502f, 0.03384462f, -0.07239621f, -0.10188162f, 0.05963981f, 
    0.06756180f, 0.02600799f, 0.20214999f, 0.31230146f, 0.11690271f, -0.21764740f, 0.14565410f, 0.08051357f, 
    0.06891151f, 0.06796991f, 0.14845496f, 0.09593821f, 0.01682391f, -0.07945156f, 0.04840748f, -0.01729492f, 
    0.29266134f, 0.01324235f, 0.05248903f, 0.10337233f, 0.06848902f, 0.04232388f, -0.00033814f, 0.00128047f, 
    -0.05202074f, -0.02282782f, 0.05253556f, 0.14837980f, -0.14919397f, -0.24670649f, -0.15066175f, -0.18561380f, 
    -0.08124702f, -0.18640739f, -0.10700154f, -0.06597753f, -0.11318330f, 0.13716948f, 0.04785739f, 0.14089128f, 
    0.00593349f, -0.03666237f, -0.16496782f, 0.07620348f, -0.23938996f, -0.04701157f, 0.13873139f, 0.02470281f, 
    0.12980033f, 0.08986994f, 0.11341698f, 0.18842781f, 0.16773237f, 0.16757762f, 0.10994786f, 0.17981301f, 
    -0.05748247f, -0.05515419f, 0.07456163f, 0.11429758f, 0.04344942f, 0.03683880f, 0.07821459f, 0.10709976f, 
    -0.00508384f, 0.19662970f, 0.17779513f, -0.03254258f, 0.02372690f, -0.00415809f, -0.16260296f, -0.02632717f, 
    -0.09342302f, 0.16744442f, -0.06181107f, 0.24724798f, 0.06183983f, -0.28561234f, -0.04453729f, 0.09444594f, 
    0.23988885f, 0.12813766f, -0.21203239f, -0.02717800f, 0.19541727f, 0.15460390f, -0.03350703f, -0.04160418f, 
    -0.05473825f, 0.19946191f, -0.01566382f, 0.07464107f, -0.10084446f, 0.06040495f, 0.02518371f, 0.26636830f, 
    -0.06149434f, 0.01245352f, 0.15372013f, -0.09403104f, -0.02905807f, -0.03838669f, 0.16864046f, -0.06209318f, 
    -0.07069931f, 0.11904922f, -0.00930793f, -0.06975400f, 0.18316464f, 0.13738722f, 0.03511890f, 0.00884719f, 
    -0.37716699f, -0.16171317f, 0.23796777f, 0.23302776f, 0.13569650f, 0.16836806f, 0.19996938f, -0.01729315f, 
    -0.00016747f, 0.05998937f, 0.04665390f, -0.04781476f, 0.01296145f, -0.20966513f, -0.03743919f, -0.06997823f, 
    -0.06589073f, 0.09180748f, -0.14235553f, 0.11955477f, 0.07656860f, 0.07580464f, -0.01049282f, 0.08639859f, 
    -0.36180937f, -0.23028193f, -0.30916971f, -0.28331155f, -0.10528719f, 0.01038973f, -0.01691762f, -0.01543469f, 
    0.08551856f, -0.09328472f, 0.30898902f, 0.14353138f, -0.31271207f, 0.11506776f, -0.06801660f, 0.04124361f, 
    -0.20559485f, 0.01192260f, 0.09263894f, 0.03779548f, 0.11706917f, 0.05176429f, 0.19717307f, -0.10527167f, 
    -0.57059872f, -0.33078992f, -0.23281729f, 0.07526919f, 0.07823368f, -0.15531036f, 0.14465956f, 0.09189091f, 
    -0.00876729f, 0.08634917f, 0.10096915f, -0.01035141f, 0.06809079f, -0.14478615f, 0.21644327f, -0.16894446f, 
    -0.01687145f, -0.10828780f, 0.05757094f, 0.01064385f, 0.00684143f, -0.09779392f, -0.10830592f, 0.05688559f, 
    0.27519470f, -0.07649445f, -0.02241903f, 0.26215905f, -0.09892129f, -0.17080383f, -0.01263024f, -0.04490115f, 
    0.04045480f, 0.09554263f, 0.05104165f, 0.16195665f, 0.27463225f, -0.08388161f, -0.02932706f, -0.05558201f, 
    -0.05271702f, 0.02026706f, -0.06227877f, -0.19459017f, 0.03290903f, -0.00122278f, 0.15382096f, -0.01843278f, 
    0.27553061f, -0.01085511f, -0.05770307f, 0.22034959f, 0.03965367f, 0.05841809f, -0.02492888f, -0.00111633f, 
    -0.06284751f, 0.08490206f, -0.06670865f, 0.09515423f, -0.09131221f, 0.26310489f, 0.11128777f, -0.04495353f, 
    0.03920340f, 0.14464419f, 0.15732712f, -0.02704004f, -0.00450604f, -0.00948312f, -0.02785227f, -0.19053568f, 
    -0.09524811f, -0.11213315f, 0.05071514f, 0.03931194f, -0.20043515f, -0.08373827f, -0.04948952f, 0.06852674f, 
    0.13287359f, -0.19296862f, -0.09194849f, 0.06581701f, 0.45020548f, 0.13219340f, -0.19886464f, 0.10519708f, 
    -0.08652876f, -0.04864073f, -0.05482488f, 0.01250895f, 0.05908403f, -0.00379868f, 0.03556733f, -0.17290083f, 
    0.21041633f, 0.11039189f, -0.11656544f, 0.32634595f, 0.00274489f, -0.13588870f, -0.09386053f, 0.01885472f, 
    -0.13637590f, 0.00459514f, -0.09524695f, -0.12405779f, -0.00103657f, 0.10327552f, 0.09197639f, 0.45489293f, 
    0.06235381f, 0.10576256f, 0.17413606f, 0.10356044f, -0.10882396f, 0.12998714f, 0.07390969f, 0.23625959f, 
    -0.30819210f, -0.05172501f, -0.05286221f, 0.08505369f, 0.07111316f, 0.14073002f, -0.13406575f, 0.11552168f, 
    0.11561798f, 0.08574165f, 0.16094460f, -0.06026373f, 0.04511218f, 0.06471193f, -0.09850810f, 0.25362247f, 
    0.09185590f, 0.12760118f, -0.05088037f, -0.02478229f, 0.06763156f, -0.01088685f, -0.07825169f, 0.04691032f, 
    0.01958962f, 0.15097511f, -0.24350606f, -0.09641788f, 0.01253816f, 0.17230634f, 0.09107028f, -0.02319941f, 
    0.06263664f, -0.02874243f, -0.03631397f, 0.00889098f, 0.23882891f, -0.03951912f, 0.01128365f, 0.61133921f, 
    0.17134550f, -0.13728921f, 0.13778490f, 0.00064555f, 0.10075831f, -0.01569834f, 0.09898718f, -0.00818540f, 
    0.14866105f, -0.14424127f, 0.14980550f, -0.40756610f, 0.01529889f, 0.03808959f, 0.09599713f, 0.14184600f, 
    0.18403254f, -0.05681685f, 0.08203699f, 0.09379784f, -0.37850145f, 0.12369698f, 0.01006767f, -0.04137541f, 
    -0.14183031f, -0.10406406f, 0.11556377f, 0.01138074f, -0.03476848f, 0.05375510f, 0.16070165f, -0.04377905f, 
    0.08871623f, -0.25256801f, -0.04916686f, 0.11956113f, 0.01974585f, -0.09553378f, 0.01111407f, -0.01706849f, 
    -0.11403585f, -0.05053044f, 0.01801668f, -0.01995803f, -0.11086722f, 0.02062414f, 0.05101513f, -0.08769160f, 
    0.05856542f, -0.04303427f, 0.15940614f, 0.15292029f, 0.07917586f, -0.15118118f, 0.15641208f, 0.09925786f, 
    0.10549054f, 0.08008841f, 0.00452094f, 0.25004449f, 0.09527428f, 0.14066990f, -0.06628951f, -0.03811130f, 
    0.03972786f, -0.04797609f, 0.11633302f, 0.10955144f, 0.36089891f, 0.11320934f, -0.09677500f, -0.10685731f, 
    -0.13831279f, -0.11344556f, 0.10372185f, -0.01010751f, 0.07700720f, -0.03349758f, -0.02895303f, 0.03051808f, 
    -0.33435649f, 0.19569808f, 0.12845217f, 0.24498962f, 0.04084132f, 0.27358475f, 0.17452559f, -0.06092363f, 
    0.14668667f, -0.07601299f, 0.04284230f, 0.13063940f, -0.57150877f, 0.08637565f, -0.19550987f, -0.35040507f, 
    0.06994013f, 0.11429171f, 0.08033041f, -0.00445688f, -0.03486056f, 0.06372275f, -0.02636625f, 0.00209227f, 
    -0.43988952f, -0.04803472f, -0.03319606f, 0.03397790f, -0.09895035f, 0.14822058f, 0.21330029f, -0.01795029f, 
    -0.08400674f, -0.04281020f, 0.11218880f, 0.06819542f, 0.09804752f, 0.16095577f, -0.12778196f, 0.02388142f, 
    0.20115130f, 0.03336743f, 0.07723411f, 0.12296842f, 0.09801207f, 0.11089388f, -0.00336113f, 0.07959756f, 
    -0.30187339f, 0.18039644f, 0.22559282f, 0.19009238f, 0.18760757f, 0.24074890f, 0.13196476f, -0.03417637f, 
    0.08185776f, 0.09782314f, 0.04426119f, 0.08301370f, -0.09009220f, -0.13639848f, 0.08736459f, 0.24535075f, 
    0.10537420f, 0.00293457f, 0.04731026f, -0.02854365f, 0.09031117f, -0.05671413f, 0.07506757f, 0.12393790f, 
    -0.13009849f, 0.31265271f, 0.06366985f, 0.27848443f, -0.02179122f, 0.08757902f, 0.09197477f, 0.06423498f, 
    0.03722459f, 0.06420912f, 0.01329668f, 0.00951834f, 0.26982793f, 0.27584526f, 0.04796746f, -0.16112858f, 
    0.10666346f, 0.11290662f, -0.04666490f, -0.01785266f, -0.10793940f, -0.06292568f, 0.08618159f, -0.10178761f, 
    0.01965775f, 0.20763102f, 0.26483983f, -0.03432037f, 0.10296611f, 0.15328014f, 0.04178260f, -0.08693496f, 
    0.01721386f, 0.07418611f, 0.09241948f, 0.01555564f, -0.40708241f, -0.10258387f, -0.06571447f, 0.10055787f, 
    -0.02230182f, 0.11851802f, 0.02960277f, 0.00733923f, -0.03867770f, 0.07488821f, 0.03068844f, 0.02259480f, 
    -0.07428442f, -0.15410309f, -0.16491047f, -0.41296533f, 0.07560843f, -0.06519063f, -0.07628108f, -0.17479154f, 
    0.00569307f, 0.01171217f, 0.05046787f, 0.02301327f, 0.01004997f, -0.04158123f, 0.03700974f, 0.15550116f, 
    -0.00007120f, -0.04449761f, 0.04834497f, -0.04015573f, -0.08529964f, 0.06936999f, 0.15491802f, 0.05611217f, 
    0.48364946f, 0.07180987f, 0.13237639f, 0.30366752f, -0.06429430f, 0.03878352f, -0.05474068f, 0.15978311f, 
    -0.02248351f, -0.15261832f, -0.03560998f, 0.01975754f, -0.01941918f, 0.20101412f, -0.01065545f, 0.26986393f, 
    0.10657611f, -0.04645297f, 0.09544820f, 0.17664170f, 0.00633097f, 0.07366513f, 0.15853912f, -0.01613460f, 
    -0.10170130f, 0.03830066f, 0.07308447f, -0.25669551f, 0.05603302f, -0.13841714f, -0.03018966f, 0.00014114f, 
    0.15615125f, 0.09103559f, 0.18270324f, 0.07036800f, -0.24391152f, 0.03094514f, 0.13404809f, 0.18848871f, 
    0.09585092f, -0.15819414f, 0.14260507f, 0.27368098f, 0.21232039f, 0.16216542f, 0.12452403f, 0.19748797f, 
    -0.15260716f, 0.38759056f, -0.04333149f, 0.02192360f, 0.01037262f, 0.04454717f, 0.04609742f, 0.22810493f, 
    0.16615342f, 0.31440184f, 0.22836143f, 0.04357627f, 0.32147688f, 0.23339930f, 0.04259173f, 0.12628435f, 
    0.17896363f, 0.22554961f, -0.07445022f, 0.07772891f, -0.00742135f, 0.01112871f, 0.09554979f, -0.08905144f, 
    0.02585908f, 0.29898509f, -0.12508723f, 0.27630538f, 0.07677947f, 0.24201073f, -0.06725453f, -0.10839310f, 
    -0.11203242f, 0.02715537f, -0.04236176f, 0.18037462f, -0.32967672f, -0.05228464f, 0.11517648f, -0.02727983f, 
    0.03914415f, 0.04085187f, 0.02455942f, 0.15873618f, 0.14485069f, 0.12224676f, -0.07762722f, 0.02127258f, 
    0.38143656f, 0.28004038f, 0.20866032f, -0.06750960f, 0.04413266f, 0.08773568f, 0.10093565f, -0.05933172f, 
    0.10287404f, 0.03279149f, 0.00245584f, 0.03481474f, 0.00730477f, 0.22141199f, -0.07544912f, -0.14519906f, 
    0.09636237f, 0.14691511f, 0.08002160f, 0.02528268f, 0.23101971f, 0.17423424f, 0.14748468f, -0.11295883f, 
    -0.24966405f, 0.40004879f, -0.04089652f, 0.16559134f, 0.00295750f, 0.01228393f, 0.30599484f, 0.08257156f, 
    0.00912765f, -0.02918883f, 0.00201180f, 0.10786082f, -0.02051143f, 0.14785613f, 0.13720845f, -0.33572283f, 
    0.04538840f, 0.16137564f, -0.06593885f, -0.00431295f, 0.19069490f, 0.15301020f, 0.06019357f, 0.00210792f, 
    -0.13217297f, 0.04304957f, 0.01494633f, -0.22042997f, -0.10497431f, 0.16025689f, 0.13435021f, 0.15784530f, 
    0.09714356f, 0.03528630f, -0.08495359f, -0.08443837f, 0.32868609f, 0.38445908f, -0.16423218f, -0.22463141f, 
    0.12802882f, 0.08381343f, 0.10792761f, 0.02316583f, -0.02141467f, 0.09118389f, -0.09101138f, 0.01240443f, 
    0.20914441f, 0.10185974f, -0.10435680f, 0.20913751f, 0.23688769f, 0.01001031f, 0.01288583f, -0.15321901f, 
    -0.02401558f, 0.10064384f, 0.20562221f, 0.20066741f, 0.39175498f, -0.25095189f, 0.15183230f, 0.04848586f, 
    0.02166939f, 0.12154569f, -0.00257380f, 0.14818560f, 0.03711917f, -0.02846952f, -0.00183454f, 0.07515991f, 
    -0.35339558f, 0.28150436f, 0.16786431f, 0.28260723f, -0.20366272f, -0.07303419f, 0.16546407f, -0.03605822f, 
    0.01569960f, 0.10248492f, 0.03191124f, -0.05829914f, -0.02460041f, 0.15909797f, 0.06556516f, -0.04590005f, 
    0.03029636f, 0.03932479f, 0.01095878f, -0.06706192f, 0.00742459f, 0.01757619f, -0.01005400f, 0.00956942f, 
    0.23326229f, -0.03388099f, 0.06045252f, -0.02822629f, 0.10002980f, 0.22178133f, -0.01272742f, -0.05354833f, 
    -0.01929918f, -0.03464286f, 0.01522472f, 0.02037799f, -0.21606290f, 0.34501722f, 0.08779784f, -0.10629454f, 
    0.11816850f, 0.28079876f, -0.07903845f, -0.06383097f, -0.07059696f, 0.08543319f, 0.01034633f, -0.00307749f, 
    0.03107403f, 0.10219191f, -0.05737724f, -0.03145366f, 0.08141845f, 0.08718914f, -0.06862123f, -0.10280259f, 
    0.07572519f, 0.08025269f, -0.08989854f, -0.02381206f, 0.03268599f, -0.02517617f, 0.09150913f, -0.04626511f, 
    0.01147613f, 0.07694522f, 0.01358281f, -0.06341474f, -0.02410798f, 0.04575692f, 0.10296668f, 0.03866197f, 
    0.06399126f, -0.11643114f, -0.00270267f, -0.08895009f, -0.04604258f, 0.02552396f, 0.11930764f, 0.13790111f, 
    0.05292672f, -0.01050801f, -0.03105440f, -0.10753027f, 0.28149924f, 0.30137190f, 0.00664774f, -0.03987918f, 
    -0.12729053f, 0.00438420f, -0.12058263f, 0.10972409f, 0.00519265f, -0.05773815f, 0.20676453f, -0.03001946f, 
    -0.13377969f, 0.07204878f, -0.30320650f, 0.24531183f, -0.07227375f, -0.19285917f, -0.01225606f, 0.02050549f, 
    0.27840450f, -0.00401374f, -0.07566350f, 0.03773061f, 0.05320796f, 0.01643349f, -0.16995288f, 0.21741059f, 
    -0.05293161f, 0.11525864f, 0.07581821f, 0.05557497f, -0.22651777f, 0.10765156f, -0.10523521f, 0.17178273f, 
    0.08118515f, -0.07164398f, -0.15861315f, 0.07345438f, -0.02943302f, 0.03873416f, 0.00615173f, -0.00412948f, 
    0.07196683f, -0.03618547f, -0.10750083f, 0.00443802f, -0.21795011f, -0.07626544f, -0.27477863f, 0.30525744f, 
    -0.15512371f, -0.07934607f, -0.04108250f, -0.01544695f, 0.08828767f, -0.00103796f, -0.07456642f, 0.13137746f, 
    0.06383721f, -0.23215322f, -0.22420114f, -0.03347211f, -0.06915446f, -0.02880271f, -0.19268535f, 0.01729725f, 
    0.08367089f, 0.02285665f, 0.10300205f, 0.00309214f, 0.12742658f, -0.21024273f, -0.23533371f, 0.40576431f, 
    -0.02614821f, -0.06093155f, 0.00222530f, -0.07210334f, 0.13798924f, -0.10226095f, 0.18862957f, -0.07126619f, 
    0.06500063f, -0.06633146f, 0.02834775f, -0.00101247f, 0.12808044f, -0.02593232f, 0.03042566f, 0.11001061f, 
    0.11613807f, -0.07308079f, -0.17072393f, -0.12649821f, -0.02073674f, 0.28187075f, 0.08254226f, 0.10375628f, 
    -0.08740972f, -0.12147899f, 0.06875356f, 0.04200692f, -0.01301275f, 0.09810299f, -0.09272183f, 0.22826120f, 
    0.14868292f, -0.08731333f, 0.12486648f, 0.18902546f, 0.05340068f, -0.09898458f, 0.04772385f, 0.02394139f, 
    -0.16853945f, -0.10576825f, 0.01444934f, -0.10146411f, -0.28126714f, 0.22419335f, 0.03822937f, -0.05611349f, 
    0.06738012f, 0.03300015f, 0.17763068f, 0.14498045f, -0.02503134f, -0.13613869f, 0.13314582f, -0.08198514f, 
    0.24972387f, 0.11576586f, 0.09568037f, 0.24953231f, 0.07439793f, -0.05564319f, -0.02602932f, 0.08437792f, 
    0.08528177f, -0.03398827f, 0.08931223f, 0.14808922f, 0.38010651f, 0.26063129f, 0.15578310f, 0.02707682f, 
    -0.04144529f, 0.09049083f, 0.12665752f, 0.08415195f, 0.02065391f, 0.12475473f, -0.06343827f, 0.07138543f, 
    -0.06066506f, 0.41726494f, -0.09510447f, 0.15621731f, -0.04913068f, 0.17227989f, -0.06339449f, -0.00697517f, 
    0.14036922f, 0.21196115f, 0.19199902f, 0.01871075f, -0.06718631f, 0.00511707f, -0.20838319f, -0.18167095f, 
    0.08721943f, 0.12046553f, -0.02678724f, 0.04331188f, -0.00726079f, -0.02122360f, -0.04152482f, -0.12756121f, 
    -0.09699275f, -0.10230932f, -0.14785227f, 0.03276761f, -0.09298950f, 0.06196890f, 0.05843006f, -0.04183536f, 
    -0.17059782f, 0.00279421f, -0.06543029f, 0.04586716f, 0.30231926f, 0.38245282f, 0.00493465f, 0.14635998f, 
    -0.00186404f, 0.04286641f, -0.03651427f, 0.05463613f, -0.10583366f, 0.00865166f, -0.16366547f, -0.10831884f, 
    -0.23743811f, 0.28806755f, 0.03084059f, 0.22326520f, 0.14200667f, 0.06373452f, 0.13050517f, -0.16543256f, 
    0.18591943f, 0.06817073f, -0.07639008f, 0.07295695f, -0.11146751f, -0.23859233f, -0.06811177f, 0.14853966f, 
    0.08637332f, 0.08532660f, 0.13193659f, 0.01128580f, 0.07625733f, 0.05134111f, 0.05795729f, 0.06754896f, 
    0.02555950f, 0.45226437f, -0.12713207f, 0.35684574f, -0.01713006f, 0.05366866f, -0.01646035f, 0.03064562f, 
    -0.03801724f, 0.08798328f, -0.03708236f, -0.03790626f, 0.06945324f, 0.25878173f, -0.31313086f, -0.08805239f, 
    0.03399467f, 0.03987957f, 0.01412620f, -0.12932749f, 0.05036067f, 0.00345403f, 0.01083126f, -0.05664013f, 
    0.12206859f, 0.03638889f, -0.12587382f, -0.16188556f, 0.05645069f, 0.16585432f, 0.00808010f, -0.11522223f, 
    0.00328693f, -0.03812773f, -0.06905938f, -0.02595920f, -0.02009320f, -0.23684178f, -0.07318113f, 0.22497275f, 
    0.06002868f, 0.02424770f, 0.16815047f, 0.02281603f, -0.00168665f, 0.11102165f, -0.08879671f, -0.01327603f, 
    -0.12480586f, -0.06657479f, -0.19759324f, -0.29597268f, 0.14254765f, -0.06830332f, -0.01357242f, -0.07000037f, 
    -0.04583988f, 0.07967103f, 0.13855770f, 0.12822619f, 0.01230632f, 0.15184036f, 0.08570927f, 0.09002379f, 
    0.03985792f, -0.03704464f, -0.05866474f, 0.19570258f, -0.12782890f, 0.09522091f, 0.17567410f, 0.04524414f, 
    -0.22500378f, 0.22127695f, 0.04622768f, -0.47186115f, 0.19304492f, 0.10012051f, 0.04324261f, 0.02687517f, 
    0.16741285f, 0.09063540f, -0.15795043f, -0.08888733f, 0.04159597f, 0.12128955f, -0.14734389f, -0.19840662f, 
    -0.05489708f, 0.03632342f, -0.10639177f, -0.29891148f, -0.03592850f, -0.15298761f, -0.02046276f, 0.00123277f, 
    -0.03873268f, 0.14653577f, 0.05976485f, 0.12302933f, 0.10022770f, -0.03518832f, 0.02188952f, 0.17026849f, 
    -0.02186518f, -0.13351060f, 0.07488383f, 0.02513044f, -0.40086746f, 0.10367208f, -0.21577345f, -0.11363164f, 
    0.12301139f, 0.10683735f, 0.14390978f, 0.14643362f, 0.10386048f, 0.04067132f, 0.07661697f, -0.01435746f, 
    0.29343021f, -0.25505632f, -0.07934102f, -0.07643035f, -0.10474191f, 0.22197111f, 0.07352569f, 0.04539699f, 
    0.20419778f, 0.04763553f, 0.05795572f, -0.00164798f, 0.30604637f, -0.10087766f, 0.11442412f, 0.08747056f, 
    -0.15726918f, -0.13595980f, -0.01355682f, -0.21286497f, -0.00611248f, -0.05804373f, -0.01590024f, 0.08237898f, 
    0.22595988f, -0.04506087f, -0.03882189f, -0.34142476f, 0.01409513f, 0.00186888f, -0.03664998f, -0.01391074f, 
    -0.06788795f, 0.09426657f, -0.03678804f, -0.01566299f, 0.12523702f, -0.02587985f, 0.28222987f, 0.10808817f, 
    0.13737208f, -0.14666620f, -0.04943924f, 0.00547632f, 0.15283215f, 0.12375481f, 0.08104765f, 0.03471220f, 
    -0.18837087f, 0.04404890f, -0.06112280f, -0.13053311f, -0.07095421f, -0.07188005f, 0.13672438f, -0.09972212f, 
    0.00680063f, -0.02406721f, -0.03132258f, 0.05682771f, 0.09490537f, -0.25315276f, 0.04194086f, -0.11923581f, 
    -0.08040502f, -0.00064274f, -0.03182202f, 0.06859428f, 0.15787151f, 0.02855005f, 0.09204132f, -0.13458399f, 
    0.64175683f, 0.01943769f, -0.05540006f, -0.35051566f, 0.04406141f, -0.10213095f, 0.14094338f, -0.07498156f, 
    0.03906429f, 0.03261526f, -0.01941128f, 0.03481627f, 0.12161112f, -0.10731211f, 0.27653340f, 0.21552047f, 
    -0.19534054f, -0.07948324f, 0.14727695f, -0.01943107f, -0.04326413f, -0.05038542f, 0.07929549f, 0.02953926f, 
    0.14981134f, -0.21774523f, 0.06595604f, 0.23943482f, -0.02710869f, -0.16019909f, -0.07968394f, -0.07483275f, 
    0.04702588f, -0.02327024f, -0.08707625f, 0.02260035f, 0.12283194f, 0.04572029f, 0.17940378f, 0.03897440f, 
    -0.31216908f, 0.16242634f, -0.08881305f, 0.05725844f, -0.05307252f, -0.07205343f, -0.01262797f, 0.06472689f, 
    -0.05548278f, 0.01627189f, 0.15517409f, 0.10283447f, -0.04504016f, 0.03945038f, -0.09734608f, -0.09500524f, 
    -0.11879529f, -0.07152810f, 0.02259010f, 0.05657915f, 0.41590059f, 0.28582007f, 0.25416094f, 0.06996886f, 
    0.16503401f, 0.17314759f, -0.13985389f, 0.07070693f, 0.11789849f, 0.06298823f, 0.05320226f, -0.03384184f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00341314f, 0.08114769f, 0.01491931f, -0.06482877f, -0.00593904f, 0.01591226f, 0.09733719f, 0.02656490f, 
    -0.03000091f, 0.06934773f, -0.12473704f, 0.18862121f, -0.09428564f, 0.19882572f, 0.01568249f, -0.07736509f, 
    -0.07058258f, 0.00258580f, 0.01191411f, 0.13544539f, -0.06653020f, 0.04632962f, 0.01671319f, -0.06975442f, 
    -0.00324560f, 0.06381036f, 0.07721045f, 0.18222541f, 0.01591759f, -0.01135825f, 0.11392938f, 0.04916357f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10580695f, 0.28386784f, 0.06102199f, 0.52269310f, -0.16046442f, -0.24932146f, 0.27886173f, 0.16655467f, 
    -0.16649799f, 0.37201887f, 0.06771850f, -0.15233703f, 0.26399869f, 0.34460554f, 0.02701715f, 0.09299541f, 
    0.16740690f, 0.19637753f, 0.10190928f, -0.22972436f, 0.03988626f, 0.27773196f, -0.32258245f, 0.11105565f, 
    0.17380059f, -0.30753919f, -0.10675060f, -0.14202395f, -0.04130180f, 0.08612525f, -0.34962025f, -0.31902465f, 
    -0.33514336f, 0.44605872f, 0.10782176f, -0.32575482f, 0.04161251f, -0.02129957f, 0.33096090f, 0.18638675f, 
    -0.13405988f, 0.01983673f, 0.10445347f, 0.15060879f, -0.33017194f, -0.37970784f, -0.18515432f, 0.03560171f, 
    -0.74016750f, 0.15122558f, -0.22626492f, 0.48708913f, 0.14104845f, 0.19546770f, 0.32910174f, 0.05906440f, 
    0.32732424f, 0.02614586f, 0.22985359f, 0.20742737f, -0.10526083f, 0.07512784f, -0.18258052f, 0.15068799f, 
    -0.46798271f, 0.04505365f, 0.28905621f, -0.34528807f, 0.09002444f, 0.05491108f, -0.14844288f, 0.25512168f, 
    0.00132848f, -0.02221530f, -0.22706184f, 0.22893491f, -0.20520245f, 0.12765697f, -0.26522937f, 0.07817810f, 
    0.07803608f, 0.26931253f, 0.00051503f, -0.07323104f, 0.13083273f, 0.10122415f, 0.23689502f, 0.07076659f, 
    -0.05471697f, -0.00105959f, 0.36144435f, 0.22844447f, -0.19578609f, 0.22917515f, 0.24300358f, 0.17987157f, 
    0.43092799f, 0.14737989f, -0.04141106f, 0.04175451f, 0.02928671f, 0.17831945f, 0.25673121f, -0.33538160f, 
    -0.05371349f, -0.19083928f, -0.28102046f, -0.40549502f, -0.16000548f, 0.05341383f, 0.11859450f, -0.12873612f, 
    0.12333886f, -0.50716436f, -0.14224450f, 0.11624475f, 0.09292591f, 0.05498129f, 0.49242431f, -0.10236128f, 
    0.11194560f, -0.14143625f, 0.38129872f, 0.06533105f, 0.25322634f, -0.14619814f, 0.19968097f, -0.14346491f, 
    0.46016183f, -0.07716928f, 0.02498373f, -0.33147782f, -0.07788405f, -0.24696451f, 0.11236870f, 0.19341888f, 
    -0.04426384f, 0.32101136f, -0.45139626f, 0.23133512f, -0.07503083f, -0.01983996f, -0.02658498f, 0.03931056f, 
    -0.33026105f, -0.11916295f, -0.04272217f, 0.38746741f, -0.13413629f, 0.12147868f, -0.07537445f, -0.03812555f, 
    0.25474289f, 0.02787048f, 0.25801986f, 0.10227563f, 0.27647218f, 0.37307602f, -0.04423096f, -0.38976264f, 
    0.39334854f, 0.05788239f, -0.20302971f, 0.45091200f, -0.07055270f, 0.00065961f, 0.16722240f, -0.21839778f, 
    -0.10387615f, 0.43841147f, 0.08001617f, -0.05472403f, -0.24058007f, -0.21903811f, -0.03466005f, -0.08170483f, 
    -0.01164212f, 0.41297996f, 0.04129874f, -0.41866907f, 0.13046412f, 0.06144170f, -0.71812183f, 0.01243078f, 
    0.14705491f, -0.61784351f, -0.14186175f, 0.03819830f, 0.31207064f, 0.19641553f, 0.14349976f, -0.33838603f, 
    0.45540977f, 0.22255978f, 0.04438014f, 0.30485457f, 0.09050144f, -0.25096172f, -0.01471263f, 0.29870114f, 
    0.02193781f, 0.33277953f, -0.13392888f, -0.33804274f, 0.11933061f, -0.09971640f, 0.34822652f, -0.12212349f, 
    0.30911332f, 0.16748832f, -0.42563233f, 0.15301600f, -0.13750046f, 0.09266248f, 0.01947007f, -0.10861898f, 
    -0.25319180f, 0.19862150f, 0.24602523f, -0.17037509f, 0.03577751f, 0.07961326f, -0.15090901f, -0.05640965f, 
    0.49033445f, 0.24144588f, 0.18115287f, 0.29399741f, -0.14800023f, 0.32489532f, 0.24015926f, 0.18371594f, 
    0.04038863f, -0.24556278f, 0.47101128f, -0.28710264f, 0.10465814f, -0.36472929f, 0.39787981f, 0.04741781f, 
    -0.23247886f, -0.16630599f, -0.01528484f, 0.05257805f, 0.03995362f, -0.02271942f, -0.07552138f, -0.11693119f, 
    -0.25501555f, -0.28005365f, -0.13755450f, -0.10395289f, 0.35711247f, -0.27697781f, -0.10198931f, 0.24839790f, 
    -0.15380368f, -0.22160318f, 0.30957550f, 0.41016889f, 0.10971048f, -0.03221608f, -0.01441948f, 0.15462032f, 
    -0.06377115f, -0.34673446f, -0.07726918f, 0.26964605f, 0.28362462f, -0.21424218f, -0.19915959f, -0.03379432f, 
    -0.02874529f, -0.55506653f, 0.36304837f, 0.18440747f, 0.09328254f, -0.34085658f, 0.11831463f, -0.13463022f, 
    -0.05453057f, 0.24335580f, 0.25798035f, -0.12687427f, 0.12934187f, 0.19483249f, 0.38046050f, 0.14458022f, 
    -0.06451779f, -0.00025035f, -0.15164913f, 0.48380664f, 0.13858119f, 0.32143775f, -0.23654033f, 0.24325038f, 
    -0.03843061f, -0.33798647f, -0.21802466f, 0.31941813f, 0.53966093f, 0.17364246f, 0.44424936f, -0.01343089f, 
    0.33184925f, 0.41312385f, 0.32070458f, 0.41791815f, -0.01950688f, -0.19422318f, -0.06757693f, 0.14722882f, 
    -0.29691577f, 0.07627007f, 0.06785998f, 0.12564744f, 0.10922339f, -0.22904521f, 0.06529433f, 0.29636979f, 
    -0.14416274f, 0.24707489f, 0.05713179f, -0.54266769f, -0.03632656f, 0.23237495f, 0.42151985f, -0.22474460f, 
    0.08015012f, 0.28255808f, 0.24428257f, 0.07903610f, -0.18553489f, -0.07593641f, 0.25890619f, -0.18035948f, 
    -0.26796815f, -0.12128285f, -0.16280124f, 0.31144410f, -0.16094020f, 0.17991230f, 0.19249266f, 0.03997773f, 
    -0.16795550f, 0.04946660f, 0.04124622f, -0.02145053f, 0.15296306f, 0.12989122f, -0.09411849f, -0.03190130f, 
    0.01405201f, -0.18111339f, -0.08492818f, 0.07132809f, -0.06964042f, 0.12363394f, 0.00925796f, 0.07368109f, 
    0.01501193f, 0.16031799f, -0.06898114f, 0.14787513f, 0.09678685f, -0.06369648f, -0.17669031f, 0.04938523f, 
    -0.19619396f, 0.11389993f, 0.12307407f, -0.00460242f, -0.11343293f, 0.02292071f, 0.10006912f, -0.05753978f, 
    -0.04722604f, -0.09954430f, -0.12450759f, -0.08016558f, -0.16096741f, -0.08944855f, 0.00842799f, -0.06776284f, 
    -0.22927596f, 0.20432553f, 0.13325433f, -0.02362202f, -0.00608746f, -0.05864012f, -0.17027426f, 0.12386006f, 
    0.07696242f, -0.34645355f, 0.38452372f, 0.29140699f, 0.17805895f, -0.20935476f, -0.45386469f, 0.12357509f, 
    -0.11373756f, -0.23360625f, 0.34300348f, -0.19567312f, -0.15077898f, -0.05147652f, -0.24012785f, -0.13298407f, 
    0.58990306f, -0.01225667f, -0.19775657f, 0.04993298f, 0.27745646f, 0.16245802f, 0.35706452f, -0.13206498f, 
    0.22601408f, 0.10403984f, 0.16053227f, -0.27017617f, -0.00599549f, -0.20139958f, -0.23418507f, 0.29354414f, 
    -0.02460050f, -0.32190952f, 0.28973362f, 0.22661830f, 0.42060164f, -0.34652030f, -0.11204971f, -0.15697825f, 
    0.07609909f, 0.29216984f, -0.15857293f, 0.20120682f, -0.10645891f, -0.23977213f, 0.13044414f, 0.02499644f, 
    -0.39027530f, 0.11421933f, -0.54513043f, -0.04266679f, 0.06985603f, 0.02569407f, -0.04896017f, 0.63505757f, 
    0.36463633f, -0.02324592f, -0.03767934f, -0.30952665f, 0.16891064f, -0.13952971f, 0.07212459f, 0.01186870f, 
    0.09243390f, -0.24514182f, -0.03875739f, 0.21992058f, 0.31745496f, 0.36664334f, 0.10955604f, 0.10927784f, 
    0.08571338f, -0.25964135f, 0.26692781f, 0.25142238f, -0.12001557f, 0.01473673f, 0.17844668f, -0.08473326f, 
    -0.26730630f, 0.04766209f, -0.31734222f, -0.21549508f, 0.13500082f, 0.06701029f, -0.22488998f, 0.34982285f, 
    -0.14557587f, -0.20877792f, 0.09230287f, -0.53815424f, 0.05562366f, 0.26936856f, -0.04850002f, -0.04664542f, 
    -0.01550068f, 0.05438552f, -0.16746177f, 0.44598362f, -0.15976961f, 0.20033398f, -0.29026151f, 0.16667041f, 
    -0.00923788f, 0.11314628f, 0.35035253f, 0.18359268f, 0.10935969f, -0.00934459f, 0.22492251f, -0.06444356f, 
    0.18380234f, 0.03781904f, 0.43676180f, 0.45024019f, 0.06759074f, 0.38873196f, 0.43964356f, -0.28409013f, 
    0.05080216f, 0.02940830f, 0.29021958f, -0.52034938f, -0.02979036f, -0.08731262f, 0.22812521f, 0.22384642f, 
    -0.01968922f, 0.14299469f, -0.03546081f, 0.06866466f, -0.37503967f, 0.24139926f, 0.11505166f, -0.00020386f, 
    -0.21097676f, -0.44366738f, 0.24040113f, 0.27398905f, -0.04408588f, -0.00379194f, 0.45416275f, 0.12517390f, 
    0.28397766f, -0.33293393f, -0.08335473f, -0.17132810f, 0.12129530f, 0.26819649f, -0.17669538f, 0.01112712f, 
    0.00008216f, -0.13247144f, 0.03248636f, 0.00248470f, -0.06209249f, -0.10837241f, -0.11794848f, -0.01847496f, 
    -0.09406804f, -0.04806443f, -0.13979091f, -0.02770919f, -0.12760250f, -0.11613812f, -0.11694840f, -0.11218733f, 
    -0.07228690f, -0.07856420f, 0.06001383f, 0.10162047f, -0.03824805f, -0.13662842f, -0.05596093f, 0.02508462f, 
    -0.08291130f, 0.11964381f, 0.01355273f, -0.11353250f, -0.09297992f, -0.09007839f, -0.09541859f, 0.11544975f, 
    -0.06678364f, -0.09751134f, 0.05094850f, 0.14407127f, 0.03567492f, 0.39112818f, -0.11841156f, 0.21860555f, 
    -0.15884677f, -0.39348838f, -0.02647458f, 0.61374789f, 0.08975385f, 0.31946972f, 0.00656197f, -0.01813394f, 
    -0.15035801f, 0.07167941f, 0.56876254f, 0.46402481f, 0.03735115f, -0.19599728f, -0.04232360f, -0.16754711f, 
    0.04735704f, -0.13117905f, -0.11733801f, 0.37438864f, 0.10819305f, -0.21637343f, 0.40448746f, -0.11145756f, 
    -0.16377729f, 0.16078655f, -0.04168621f, 0.09858478f, -0.04478568f, 0.03281038f, -0.21949576f, -0.13717990f, 
    -0.03861304f, -0.39236894f, 0.34298241f, -0.17390794f, 0.01052965f, 0.31872356f, -0.39857200f, -0.14868873f, 
    0.07464170f, 0.07084825f, 0.12822932f, -0.40451232f, -0.03949375f, 0.29264760f, -0.16573751f, -0.12243185f, 
    0.52967268f, 0.31328124f, -0.25722674f, 0.30193248f, 0.22993760f, -0.34561771f, 0.16842896f, -0.15770972f, 
    -0.40836295f, 0.02138763f, 0.29152301f, 0.36664221f, -0.06904886f, -0.23981293f, 0.13652344f, 0.24186777f, 
    -0.08055646f, 0.18452053f, 0.25212187f, 0.14750434f, 0.23068349f, -0.34363592f, -0.37101460f, -0.11805239f, 
    0.01695172f, -0.34159827f, -0.04984576f, -0.13313323f, -0.14595982f, 0.01975472f, 0.37044910f, 0.05907054f, 
    0.38021803f, 0.12408254f, 0.11609656f, -0.15680306f, -0.00113648f, 0.38242459f, 0.03668422f, 0.22066213f, 
    0.35197109f, -0.12126950f, 0.10247897f, 0.47046044f, -0.07015924f, 0.22523643f, 0.15335137f, 0.06788848f, 
    -0.04397639f, 0.06194917f, -0.20457689f, -0.31082743f, 0.02810712f, 0.47277549f, -0.08528308f, -0.09976182f, 
    0.04138236f, -0.47442466f, 0.03391237f, -0.16621602f, -0.11207589f, 0.13063809f, 0.34699762f, -0.14867127f, 
    0.39149275f, 0.07983232f, 0.16020116f, -0.08706405f, 0.00510842f, -0.18724155f, -0.11768887f, -0.36624286f, 
    0.05016455f, 0.18936864f, -0.06026191f, 0.21781036f, 0.04915511f, 0.01716743f, 0.10551301f, 0.20791008f, 
    -0.17331985f, 0.04713905f, 0.36806241f, 0.07643054f, 0.08237770f, -0.56258386f, 0.17547533f, 0.13701804f, 
    -0.38380730f, 0.09777305f, -0.18617985f, -0.00463196f, -0.01508815f, -0.18812317f, -0.51930296f, 0.01593898f, 
    -0.13728489f, 0.05062601f, 0.05115355f, 0.13076484f, 0.34002396f, -0.20249498f, -0.09087072f, 0.21810150f, 
    -0.00894077f, 0.32054511f, 0.31729978f, 0.00250330f, -0.10174758f, -0.12681206f, -0.01361402f, 0.18401957f, 
    0.10600696f, 0.04227287f, 0.25008261f, -0.51221299f, -0.10867909f, 0.23791240f, 0.01056790f, 0.10436517f, 
    0.03985745f, -0.10462724f, -0.21574159f, -0.31909627f, 0.09086143f, 0.34935096f, 0.47930253f, -0.13006456f, 
    0.32948774f, -0.14947963f, -0.23935723f, -0.16100945f, 0.18853293f, -0.26243031f, -0.29612762f, 0.35597673f, 
    0.04607803f, -0.10512067f, -0.23183870f, -0.07032511f, 0.11501500f, -0.15153407f, 0.10798390f, -0.09331671f, 
    -0.11564387f, -0.17358798f, 0.10275947f, 0.04948277f, -0.07292003f, 0.06851155f, 0.01184090f, 0.12850003f, 
    0.03342419f, 0.12141081f, 0.03293214f, -0.08588804f, 0.16675167f, -0.19197135f, -0.02283878f, -0.16724391f, 
    -0.10134494f, -0.18773109f, -0.20380826f, 0.09055210f, 0.04229352f, -0.08614124f, -0.07608081f, -0.16791354f, 
    0.07973256f, 0.13757303f, 0.27940050f, 0.05890745f, 0.05769886f, -0.23720865f, -0.16197826f, 0.39737761f, 
    -0.13919523f, 0.14691493f, 0.18141113f, -0.19820997f, 0.19783197f, -0.00496609f, 0.30480367f, 0.07689970f, 
    0.29795921f, 0.30005923f, -0.01085330f, -0.07745487f, 0.02511394f, 0.22323202f, 0.40069714f, -0.02769192f, 
    -0.27175444f, -0.17634922f, -0.09811575f, -0.17384095f, -0.04325988f, 0.12435935f, -0.45590618f, 0.43741789f, 
    -0.05753808f, 0.11469002f, 0.18672025f, -0.28221846f, 0.05628201f, 0.07064498f, 0.14926189f, 0.15584572f, 
    0.14705254f, -0.15080376f, 0.36999723f, -0.17464589f, -0.27395827f, -0.30254176f, 0.24451238f, -0.09895284f, 
    0.00714740f, -0.08301621f, 0.19274500f, 0.14810614f, -0.16491945f, 0.04003211f, 0.48081484f, 0.08727370f, 
    -0.23457778f, -0.42345598f, 0.11492879f, -0.11244693f, 0.01493889f, 0.10323314f, 0.01933140f, 0.57244933f, 
    -0.18092740f, 0.34360275f, 0.07084019f, -0.23727167f, -0.01693366f, 0.39707851f, 0.16131988f, -0.13371582f, 
    -0.00266423f, 0.10908282f, 0.00165272f, 0.04101343f, -0.22162190f, 0.26654676f, 0.02039496f, 0.07501627f, 
    -0.13832921f, -0.01643294f, -0.21402262f, -0.31886256f, -0.13458999f, 0.55915225f, 0.23028754f, -0.02497673f, 
    0.23998484f, 0.03030097f, -0.12265123f, 0.31175125f, 0.12347127f, -0.41416970f, -0.08923284f, -0.07151651f, 
    0.20089182f, -0.10270822f, 0.31571645f, -0.50757813f, -0.03463230f, -0.20551357f, -0.18136333f, -0.08000176f, 
    -0.07523590f, 0.33829337f, -0.28225702f, 0.06560150f, -0.03067605f, 0.26075333f, -0.00977396f, -0.12575132f, 
    0.43555018f, 0.52886301f, -0.12144708f, 0.15396230f, -0.12741540f, 0.11920692f, 0.33409578f, 0.07061191f, 
    -0.33126885f, -0.08116896f, 0.15970671f, 0.28341776f, -0.00134609f, 0.34160301f, 0.27654457f, 0.25136250f, 
    -0.08153887f, -0.02939154f, -0.05606240f, -0.10980326f, 0.09911878f, 0.08556831f, 0.11927235f, 0.07888640f, 
    0.08798449f, -0.00424029f, -0.13641961f, -0.00254055f, -0.12261035f, -0.18942949f, 0.11907650f, 0.12301818f, 
    -0.12716734f, -0.10719425f, -0.03803117f, 0.12632035f, 0.14559242f, 0.09012527f, -0.01782064f, 0.01126077f, 
    -0.09749017f, 0.13167351f, -0.18295346f, -0.22872764f, -0.22535758f, -0.14029080f, -0.06128358f, -0.04720078f, 
    -0.08123908f, -0.04130134f, -0.06935605f, 0.10657659f, 0.04491276f, -0.04114243f, 0.11345852f, 0.12088123f, 
    0.08662113f, 0.04571998f, -0.10323920f, -0.00156314f, -0.04676389f, -0.12274287f, 0.06416722f, -0.16589056f, 
    -0.16571864f, -0.05015592f, 0.11154186f, 0.07506999f, -0.14786503f, -0.12114362f, 0.09030721f, 0.16176505f, 
    -0.13970754f, -0.19480671f, -0.02520160f, -0.14643186f, -0.06919852f, 0.12191916f, -0.05000525f, -0.13800023f, 
    -0.18283643f, 0.30017719f, -0.21308926f, 0.28806612f, 0.00574323f, 0.45765597f, 0.37059721f, -0.13549849f, 
    0.03920240f, 0.05391650f, 0.13034995f, 0.16868338f, 0.20010903f, -0.05914161f, 0.39896452f, 0.10252565f, 
    -0.24315776f, 0.09483504f, -0.26477662f, 0.15521455f, -0.14157148f, 0.25321844f, -0.27232584f, -0.07124086f, 
    -0.28901201f, 0.31029001f, 0.24307959f, 0.12742952f, 0.11422548f, -0.39428785f, -0.07200928f, -0.20406622f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.18500377f, 0.24527353f, 0.03300968f, 0.04287905f, 0.19499868f, 0.09819230f, -0.10028629f, 0.08810104f, 
    -0.02478702f, 0.00401554f, -0.07763192f, -0.17066662f, -0.03205922f, 0.02946990f, -0.01127792f, 0.01009983f, 
    0.03614355f, -0.11309370f, 0.18045354f, -0.11704118f, -0.19198498f, 0.04867682f, -0.01902849f, 0.08454096f, 
    -0.03719943f, -0.04405425f, 0.13333634f, -0.02158353f, 0.16042867f, -0.00530649f, -0.08052266f, 0.12558575f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.12887990f, -0.44124317f, -0.32211980f, -0.23491390f, -0.40855670f, -0.03392817f, -0.03522814f, 0.30403754f, 
    -0.58359021f, -0.03771458f, 0.02389927f, 0.06080999f, -0.16803132f, 0.58852309f, 0.48976141f, -0.32069352f, 
    -0.10069383f, 0.04962602f, -0.14978909f, 0.10771550f, -0.26471171f, -0.19564916f, 0.17325985f, 0.30409306f, 
    -0.07196519f, 0.28084329f, 0.18972908f, -0.03417784f, 0.01310584f, -0.15028718f, 0.08560815f, -0.15606390f, 
    0.39310405f, 0.12514506f, -0.51258504f, 0.10848365f, -0.18222693f, -0.14081329f, 0.31510177f, 0.09823003f, 
    0.45211849f, -0.06292282f, -0.07476945f, -0.12994570f, -0.63871539f, -0.54101837f, -0.08331843f, -0.41002944f, 
    -0.09722378f, -0.01844352f, -0.56277257f, -0.18228760f, 0.18317899f, 0.39624438f, -0.05587522f, 0.27015364f, 
    0.02103795f, 0.22970673f, -0.15253255f, 0.13313216f, -0.19396806f, -0.11223705f, -0.08575307f, 0.22444835f, 
    0.00286319f, -0.53763533f, -0.47308919f, 0.03521733f, -0.24121104f, 0.42331502f, -0.02915597f, 0.28993589f, 
    -0.41567665f, 0.11549878f, -0.25119323f, 0.15723847f, 0.09562745f, -0.48023927f, -0.42221054f, -0.12849292f, 
    -0.51999748f, 0.12226032f, 0.24310713f, 0.34770039f, -0.52933651f, 0.12563263f, 0.24088889f, -0.07658303f, 
    0.20230401f, -0.20906067f, -0.26803446f, -0.01232063f, -0.48568216f, 0.15178652f, 0.12564963f, 0.20004167f, 
    -0.25029284f, -0.76080996f, 0.05733371f, 0.10506666f, 0.12977728f, -0.59504312f, 0.43486112f, -0.20228083f, 
    -0.01433196f, 0.30774206f, -0.31891972f, -0.00593786f, -0.20739569f, 0.15437058f, 0.24534981f, -0.00708336f, 
    -0.46985307f, -0.03666627f, 0.20522186f, -0.38413331f, -0.22209723f, -0.39374194f, 0.10161320f, -0.68460858f, 
    -0.11306622f, 0.08411137f, -0.14557126f, -0.63616318f, 0.24228209f, 0.09102165f, -0.07942339f, -0.14400063f, 
    0.28392285f, 0.28866538f, -0.11141332f, -0.33274207f, 0.03107983f, 0.05560866f, -0.23624438f, 0.18640177f, 
    0.28114268f, 0.06607517f, 0.02091274f, -0.00565115f, -0.00169100f, 0.25606835f, 0.21310642f, -0.12261198f, 
    0.11587656f, 0.09282782f, 0.13422747f, -0.69459027f, 0.28304297f, -0.41873205f, 0.28082505f, -0.30125800f, 
    0.11884664f, -0.01772504f, 0.10988596f, -0.29818964f, -0.35879928f, 0.02498517f, 0.18038452f, 0.09621613f, 
    -0.12311839f, 0.47128984f, 0.31035194f, -0.01699659f, -0.06471502f, -0.56963539f, -0.01298486f, -0.02434806f, 
    -0.63658130f, -0.27463624f, 0.09599905f, -0.16910358f, -0.11242073f, -0.09581995f, -0.37040922f, 0.00584454f, 
    0.24683644f, -0.16079520f, -0.27926198f, 0.07473563f, 0.21741368f, -0.05475951f, -0.18111874f, 0.32883933f, 
    0.07460418f, 0.22532548f, 0.29874551f, -0.00363634f, 0.12655200f, -0.12156788f, -0.07200188f, -0.19619519f, 
    -0.58875954f, 0.26648113f, -0.15952697f, 0.22077402f, 0.19700986f, 0.14976652f, 0.02751346f, 0.10151599f, 
    -0.37963596f, -0.13245396f, 0.31139496f, -0.16186737f, -0.45034915f, -0.72624886f, -0.43028191f, 0.14337201f, 
    -0.13565102f, 0.16596688f, -0.10125378f, -0.55347544f, -0.35278964f, -0.37249801f, 0.29107863f, -0.39784914f, 
    0.14191128f, -0.44167536f, 0.04410980f, 0.08863647f, 0.05860845f, -0.13364708f, 0.00990539f, 0.38123047f, 
    0.12849490f, -0.23328657f, 0.38438722f, -0.21509668f, -0.37490183f, 0.20838626f, -0.33768034f, -0.40114373f, 
    0.42885301f, -0.03749800f, -0.52292556f, -0.15279107f, 0.36463061f, 0.04564825f, -0.42529505f, 0.16931804f, 
    -0.55223888f, -0.01078650f, 0.02662829f, 0.05708339f, 0.46884573f, -0.12546454f, -0.17673202f, -0.19197224f, 
    -0.01618326f, -0.08962156f, 0.02699407f, -0.56540442f, 0.12695606f, -0.16435423f, -0.13078442f, -0.47375470f, 
    0.20640698f, 0.09444571f, -0.27629775f, 0.03041497f, 0.48121408f, 0.44203475f, 0.17333364f, -0.11740013f, 
    -0.15418620f, -0.58797169f, -0.07248231f, -0.00184076f, 0.40015256f, -0.21871515f, 0.02422708f, -0.07788673f, 
    0.20349269f, -0.05126825f, -0.42124635f, 0.17215575f, 0.30883935f, 0.19839540f, 0.01397439f, 0.10854653f, 
    -0.05840065f, -0.24758421f, -0.56048030f, -0.13079345f, -0.13024800f, 0.14976443f, -0.14985016f, -0.42913917f, 
    -0.80187476f, 0.28984046f, -0.02128087f, 0.17009386f, -0.27324072f, -0.70692950f, -0.55805433f, 0.00803096f, 
    0.02029573f, -0.13181934f, 0.08457773f, -0.12215853f, 0.32185853f, -0.25871560f, -0.46927917f, 0.02675797f, 
    -0.17560276f, 0.13878287f, 0.15097435f, 0.47952348f, 0.14020891f, 0.10484043f, 0.03544998f, 0.10279599f, 
    0.10789619f, -0.67911094f, -0.04780373f, 0.20788346f, -0.41041633f, 0.12189328f, 0.09001243f, 0.19951051f, 
    0.32581896f, 0.06892379f, 0.26395383f, -0.52464932f, 0.04967146f, 0.20381463f, -0.32454222f, -0.75219733f, 
    -0.50602251f, 0.11686165f, 0.00986726f, 0.11494727f, -0.12520751f, -0.01821828f, -0.06715690f, 0.28556377f, 
    -0.08955109f, 0.06645401f, 0.29491645f, 0.12422587f, -0.25408509f, -0.15140785f, -0.53898644f, -0.48707142f, 
    -0.09615952f, -0.13591699f, -0.65236270f, 0.30519709f, 0.24212949f, -0.05184389f, 0.05725152f, 0.19075283f, 
    -0.36125734f, -0.38860294f, -0.07984933f, 0.43439105f, 0.20510879f, -0.30627066f, -0.42232606f, -0.05815459f, 
    0.08636711f, -0.07685111f, -0.02606417f, -0.08455678f, -0.08883711f, -0.52212954f, 0.52574992f, 0.22493094f, 
    0.51249456f, -0.10862031f, 0.20727482f, -0.31266159f, -0.20974125f, 0.43132606f, -0.87485349f, -0.15968519f, 
    0.01981743f, -0.33702838f, 0.04971914f, 0.01461873f, -0.03700219f, -0.09082559f, -0.13718575f, -0.23773253f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.18348421f, -0.16164510f, -0.20024966f, -0.01703305f, -0.00205510f, -0.07826836f, 0.06458148f, -0.14682811f, 
    -0.23165891f, -0.16316664f, 0.36962736f, -0.12596165f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
