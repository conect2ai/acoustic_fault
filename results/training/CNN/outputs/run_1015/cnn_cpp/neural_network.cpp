#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.51684695f, 1.24579036f, 0.43352741f, -1.03205287f, -0.42818984f, -0.24231397f, -0.17952505f, 0.05469805f, 
    -0.03719251f, -1.25080955f, 0.92111832f, -0.69272417f, 0.50070578f, -0.36774361f, 0.28574613f, -0.54463702f, 
    0.21504231f, -0.63812250f, 0.75219864f, -0.54271150f, -0.17100869f, 0.76763976f, -0.60414839f, 0.34162501f, 
    -0.38430575f, -0.25124729f, 0.30249369f, -0.47781163f, -0.46446583f, -0.70343983f, -0.60975277f, -0.49197048f, 
    0.19270156f, 0.57077104f, 0.10168670f, 0.36410630f, -0.55700094f, 0.36917657f, 0.54756463f, 0.40049234f, 
    0.44121167f, 0.27952269f, 0.37251112f, -0.23300381f, 0.36727586f, 0.74857080f, -0.48774216f, -0.40118274f, 
    0.43070886f, 0.58673918f, 0.64305747f, -0.05070551f, -0.47560015f, -0.68358862f, -0.36010921f, -0.16038471f, 
    -0.30006179f, -0.05124793f, -0.93950444f, -0.82808048f, -0.20115586f, -0.24259754f, -0.46229875f, 1.09787881f, 
    -0.66280115f, -0.09580065f, -0.37550858f, -0.14513381f, 0.48086974f, 0.08867145f, -0.17710903f, -0.10071365f, 
    0.12484539f, -0.68592978f, -0.34348896f, -0.68722773f, -0.40477455f, -0.64739621f, 0.23787177f, 0.41365781f, 
    0.38435128f, -0.88285822f, -0.62271768f, -0.86051697f, 0.48039365f, 0.47655261f, 0.35980359f, 0.58247256f, 
    0.44908467f, 0.33713445f, -1.07439721f, -0.68465132f, -0.06212081f, 0.32181507f, 0.52282560f, 0.57132405f, 
    0.15573667f, -0.21359675f, 0.02995724f, -0.37653866f, 1.05205357f, -0.95608163f, -0.24929328f, 1.28878403f, 
    -0.32543543f, -0.07210752f, -0.37386486f, -0.29511207f, 1.43855381f, -1.59121990f, -0.04242040f, 0.73808956f, 
    -0.42701936f, -0.26526800f, -0.13738510f, 0.38999394f, -0.39651659f, -0.43304509f, -0.73082018f, -0.96800965f, 
    0.27911508f, 0.14646982f, 0.55483496f, 0.55991548f, -0.48026931f, 0.31066349f, 0.26416233f, -0.53852010f, 
    0.78817767f, -0.77459031f, -0.05949151f, 0.65038747f, 0.09011808f, -0.07625782f, 0.02996370f, -1.04742157f, 
    -0.71130985f, -0.52946573f, 0.14248914f, -0.51141423f, 0.03104020f, -0.47656113f, -0.61976337f, -0.68707305f, 
    -0.85204130f, -0.64649868f, -0.30213994f, -0.48288572f, 0.18720402f, -0.04743756f, 0.15341240f, 0.34659469f, 
    0.00075819f, 0.64999467f, 1.27771783f, -0.21725120f, -0.78681165f, -0.81815332f, 0.33887091f, -0.14070596f, 
    0.09175335f, 0.12395123f, -0.54298967f, -0.58783543f, -0.23520292f, -0.29050034f, -0.72238052f, -0.72293723f, 
    0.32468489f, -0.24948356f, 0.51528269f, -0.10071997f, 0.16516845f, 0.68446928f, -0.44441360f, -0.36617506f, 
    0.52138478f, -0.12666261f, 0.00290734f, 0.75467163f, -0.38718188f, 0.02004499f, 0.20603819f, 0.01468734f, 
    0.49367395f, -0.63888514f, -0.76628214f, 0.57724774f, 0.75157481f, -0.68491817f, 0.80591768f, 0.63303578f, 
    -0.61705673f, -0.63807803f, -0.74009258f, 0.05912133f, -0.71926957f, -0.43698454f, 0.04464208f, 0.20526540f, 
    0.77571905f, -0.56059039f, -0.42435029f, -0.59584409f, 0.55510795f, 0.10280892f, 0.34649330f, 0.69162637f, 
    -0.67527294f, -0.21833180f, -0.83682930f, -0.56823725f, -0.46538293f, -0.43905750f, -0.56765234f, -0.08570407f, 
    -0.39991847f, 0.58236128f, -0.20283337f, -0.36402217f, -0.82280535f, -0.39225042f, 0.51347661f, 0.66132349f, 
    0.41664037f, -0.62060654f, -0.65932775f, 0.32153165f, -0.58764386f, -0.41129270f, 0.97839880f, -0.62839085f, 
    -0.64446491f, -0.13113442f, 0.33332497f, 0.30283287f, 0.25881100f, 0.23523818f, -0.69232982f, 0.42366117f, 
    -0.40327433f, 0.18268782f, -0.56615520f, 0.40184143f, 0.77456170f, 0.66414165f, 0.29605246f, 0.50938368f, 
    -0.00497848f, -0.27774030f, -0.40586320f, 0.32485077f, 0.84161556f, -0.90799123f, -1.19581532f, -0.08362498f, 
    0.75240493f, 0.75685817f, -0.43202525f, 0.11922953f, 0.03985373f, 0.50727147f, -0.22767264f, -0.13311274f, 
    0.59577817f, -0.46677476f, 0.18339263f, -0.36888304f, 0.67520815f, 0.09703106f, 0.48411974f, 0.29392576f, 
    -0.17767590f, 0.67175394f, 0.50691253f, 0.16210380f, -0.19557416f, 0.03345564f, 0.33192515f, 0.17121881f, 
    -0.20713469f, 0.51493943f, -0.01720727f, 0.42679965f, 0.54889899f, -0.03358378f, 0.26803440f, -0.16828184f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29232723f, -0.06485944f, 0.23912776f, 0.01411378f, -0.49696070f, 0.15836942f, -0.21544403f, 0.19697240f, 
    0.08925198f, 0.07695197f, 0.24423914f, 0.07586783f, 0.57362169f, 0.04233420f, 0.22427565f, -0.29748940f, 
    -0.24902841f, 0.16768107f, -0.07207770f, -0.01267048f, -0.23546408f, 0.03248902f, -0.09099133f, 0.37242153f, 
    -0.06950980f, 0.47669470f, 0.16219473f, -0.23602447f, 0.05682889f, -0.09042248f, -0.12203730f, -0.07744793f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25669301f, 0.38318357f, 0.28617427f, 0.14165659f, 0.11587815f, 0.09920815f, 0.07423338f, -0.08357390f, 
    -0.03568878f, 0.02384238f, 0.04994558f, -0.18272020f, 0.03153954f, 0.00645445f, -0.02483074f, -0.13452098f, 
    0.04520788f, -0.04536200f, 0.00567239f, 0.15163456f, 0.40169895f, -0.10832050f, -0.17856771f, 0.16554187f, 
    -0.25982401f, 0.12442090f, -0.04772481f, -0.04211769f, 0.12051015f, -0.06254862f, -0.01169519f, -0.01129984f, 
    0.05387573f, 0.04138888f, 0.18631425f, -0.01476370f, 0.11862932f, 0.12457053f, 0.10664216f, 0.31074435f, 
    -0.27457821f, 0.01600730f, -0.24387759f, -0.33227947f, -0.23874471f, -0.04598935f, 0.25482723f, -0.07772896f, 
    -0.22286814f, -0.16210423f, 0.02558245f, 0.02241252f, 0.11982040f, -0.07130444f, -0.00715079f, -0.09090769f, 
    0.08415153f, 0.08689597f, -0.13224487f, -0.17726816f, 0.27163357f, 0.19237129f, 0.06587722f, 0.05968856f, 
    0.24399421f, 0.20116583f, 0.07764240f, 0.07113474f, -0.06125932f, 0.00226412f, 0.00217358f, 0.07843138f, 
    0.06750438f, 0.02755140f, 0.06086640f, 0.08682311f, 0.02262561f, 0.02419408f, -0.09822012f, -0.06957261f, 
    -0.35694954f, -0.40608564f, -0.41528496f, -0.11787741f, 0.06704844f, 0.09545063f, -0.03657530f, -0.04052946f, 
    -0.01799489f, -0.14466839f, 0.01109932f, -0.05714008f, 0.12116127f, -0.05645891f, 0.04906508f, 0.17652038f, 
    0.06589989f, -0.15104423f, -0.13860387f, -0.22395249f, 0.00575731f, 0.12495878f, -0.01450344f, -0.16913360f, 
    -0.15985343f, 0.03991186f, -0.04203990f, 0.06836249f, 0.02756134f, 0.07842032f, -0.07448870f, 0.06431948f, 
    -0.03047870f, 0.14588343f, 0.02228925f, -0.02163875f, 0.00558669f, 0.12631349f, 0.09327528f, 0.07239792f, 
    0.07616121f, -0.06039818f, 0.08439171f, 0.00556892f, 0.18446739f, -0.03791961f, 0.18776141f, 0.04400397f, 
    0.19930933f, 0.23017931f, -0.04979178f, 0.01156528f, -0.00607584f, -0.01922697f, -0.04137601f, 0.01788876f, 
    0.10721717f, -0.06346212f, -0.04203238f, 0.21829046f, -0.75510472f, 0.03620281f, -0.02953769f, 0.02483212f, 
    -0.15946822f, -0.20556919f, 0.01241531f, -0.11381115f, -0.26221913f, -0.18046926f, -0.10295206f, 0.11214128f, 
    -0.05791818f, 0.04848971f, -0.09156863f, -0.02800054f, 0.00333680f, 0.03341311f, -0.05708591f, -0.09393940f, 
    0.27095884f, 0.14643604f, 0.07406204f, 0.11575902f, 0.02307845f, 0.07684431f, 0.15519725f, 0.15003157f, 
    0.03952319f, 0.19998460f, 0.11946163f, -0.00913474f, 0.08370054f, 0.02000827f, -0.00363320f, 0.08598438f, 
    -0.08129538f, -0.03219107f, -0.08904658f, 0.02624613f, 0.09970155f, -0.12562831f, 0.07810099f, 0.17256556f, 
    0.30973583f, 0.07725815f, -0.10713726f, 0.04597210f, 0.02739610f, -0.15780316f, 0.03901292f, 0.03715575f, 
    0.09267138f, 0.10952656f, 0.10583638f, 0.11507490f, 0.00814364f, -0.05786588f, -0.07576812f, -0.16157536f, 
    0.12079979f, 0.11818065f, 0.21883471f, 0.12500176f, 0.19426365f, 0.02115518f, 0.11254531f, 0.08543859f, 
    0.14302185f, -0.07556699f, -0.12124930f, -0.02977881f, 0.10272823f, -0.01126223f, 0.14967830f, -0.00756531f, 
    0.13236110f, 0.00015105f, 0.01390361f, 0.07939281f, 0.42805129f, -0.23963468f, -0.46005633f, -0.24291883f, 
    -0.30079794f, 0.23656900f, -0.09018426f, -0.18698744f, -0.11266408f, 0.25755021f, -0.10496750f, -0.12305052f, 
    0.10408918f, -0.10237501f, 0.03285467f, -0.14771409f, 0.09115651f, -0.19637200f, 0.17944568f, 0.11841379f, 
    -0.22135155f, 0.11270759f, 0.35703111f, -0.08737387f, 0.01914399f, -0.10551399f, 0.08776759f, 0.02887407f, 
    -0.21919261f, 0.00551260f, -0.10850768f, 0.03587231f, -0.00996615f, 0.16960163f, -0.08439466f, 0.18768664f, 
    0.03492307f, 0.00201265f, -0.00697132f, 0.09266214f, 0.32068694f, 0.15258892f, 0.26556715f, 0.15626186f, 
    0.29949898f, 0.04118213f, 0.06363788f, -0.00406630f, -0.04772423f, -0.22929269f, -0.02841029f, 0.07178599f, 
    0.09265977f, 0.01246857f, 0.12013237f, 0.01643066f, 0.07040395f, 0.03905353f, -0.06519359f, -0.09091084f, 
    -0.57293463f, -0.22666714f, -0.23151189f, 0.02103354f, -0.20139971f, -0.01840607f, 0.02462083f, -0.18229942f, 
    -0.27339435f, -0.13968466f, 0.09488984f, -0.05992568f, -0.03761217f, -0.06080592f, -0.10505512f, 0.10593151f, 
    0.00723566f, 0.10738639f, -0.14744504f, -0.06515857f, 0.15074673f, -0.02788857f, 0.22401614f, 0.19352949f, 
    0.16366665f, 0.07139561f, 0.11401442f, 0.25180969f, 0.10844880f, 0.04550513f, 0.11452529f, -0.02140795f, 
    0.03842887f, 0.09861519f, 0.14676565f, 0.04446974f, 0.14019530f, 0.02664655f, -0.09702582f, 0.24087636f, 
    0.31197479f, 0.16193163f, 0.08482120f, 0.18473873f, 0.40093341f, 0.14560336f, -0.05659783f, 0.14333069f, 
    0.03205999f, -0.00221104f, -0.03926283f, -0.06410264f, 0.01687232f, 0.13371499f, 0.10227432f, 0.12157101f, 
    0.03562796f, 0.08898222f, -0.21452858f, 0.02125381f, -0.65484530f, -0.11172603f, 0.36274189f, 0.07412338f, 
    0.08893538f, -0.20855193f, 0.16169593f, -0.21270812f, -0.19251385f, 0.03332517f, 0.03399342f, -0.04320979f, 
    -0.03001832f, 0.01344959f, 0.07823036f, -0.15498707f, 0.05786666f, -0.14815228f, -0.08688053f, -0.08339483f, 
    0.24972339f, 0.16734804f, -0.06038655f, 0.13507697f, 0.06589379f, 0.10008804f, 0.15226786f, 0.06830721f, 
    0.15376595f, 0.28110451f, 0.03584877f, -0.07342720f, -0.05381052f, -0.05460033f, -0.06112141f, 0.00778071f, 
    -0.04433494f, 0.00863274f, -0.12886196f, 0.01818853f, -0.23927192f, 0.15402032f, -0.06554436f, -0.05070002f, 
    -0.10387862f, -0.07698758f, -0.11908644f, -0.05403765f, -0.30687323f, -0.10355905f, 0.10018253f, -0.04833652f, 
    0.06272873f, -0.15821660f, -0.05336766f, 0.02785556f, -0.06938456f, -0.12014487f, -0.26278082f, -0.13277379f, 
    0.16909947f, 0.03223389f, -0.11930583f, -0.26891589f, -0.17721659f, 0.13278809f, 0.00808048f, 0.21706291f, 
    0.19244851f, 0.07824157f, -0.01675423f, -0.02826581f, -0.18395475f, 0.05394074f, 0.05773469f, -0.00715492f, 
    -0.41039249f, -0.01850599f, -0.20218766f, -0.25309479f, 0.27635750f, 0.24115932f, 0.15861657f, 0.07049681f, 
    0.12036726f, 0.12059227f, 0.12645404f, -0.04443216f, 0.03902704f, 0.08507141f, 0.02901122f, -0.05136037f, 
    -0.05343600f, -0.04774015f, -0.03892884f, -0.07408926f, 0.11099334f, 0.10489829f, 0.02261789f, 0.23735951f, 
    0.07527197f, 0.34881023f, 0.21932010f, -0.02730276f, 0.01825814f, 0.12261067f, 0.12027887f, -0.12443444f, 
    0.03561045f, 0.12322081f, 0.10542971f, -0.11011408f, 0.12221807f, -0.01156785f, -0.14141238f, -0.06759398f, 
    -0.20150539f, -0.12473325f, -0.19375525f, -0.09586895f, -0.05728229f, 0.13279319f, 0.23129141f, 0.04985344f, 
    0.10288663f, -0.05941449f, 0.01583303f, 0.02609864f, -0.08712327f, 0.13769743f, -0.07304169f, -0.02141446f, 
    0.04242487f, -0.06085012f, -0.03289067f, -0.01531351f, 0.10628413f, 0.04275275f, 0.03286899f, 0.17182039f, 
    0.32784534f, 0.32025427f, 0.02239910f, 0.03506009f, 0.00403980f, 0.25953776f, 0.21017718f, 0.00496147f, 
    -0.02321477f, 0.16730005f, 0.00278447f, -0.00266812f, -0.01609953f, 0.03663918f, -0.03533862f, -0.09759685f, 
    -0.29507574f, -0.22884214f, -0.23141408f, -0.04467256f, 0.00505617f, 0.21591188f, 0.01575947f, -0.02241665f, 
    0.00187186f, -0.07016760f, 0.00369837f, -0.00585496f, 0.03870101f, 0.01177525f, 0.10178400f, -0.02051348f, 
    0.04265728f, -0.06062127f, 0.01555690f, 0.00169900f, 0.14688866f, 0.15513092f, -0.05554983f, 0.12692966f, 
    -0.20200519f, -0.02105504f, -0.14115734f, -0.13754342f, -0.10861622f, 0.00517423f, 0.05404835f, 0.05805400f, 
    0.12929963f, 0.01016779f, 0.05664682f, 0.05035071f, -0.03364266f, -0.03926121f, 0.08276618f, 0.10335176f, 
    0.13761958f, 0.30956018f, -0.00325274f, -0.05861608f, -0.39989451f, -0.42755976f, -0.48504242f, -0.34325036f, 
    0.02827297f, 0.13495651f, -0.21919179f, -0.11541985f, 0.12731405f, 0.05492621f, 0.12185625f, 0.07993688f, 
    0.17295785f, -0.12284730f, 0.15765172f, 0.00729761f, 0.14758334f, -0.04063455f, 0.04165968f, 0.00721712f, 
    0.62671202f, 0.38431087f, 0.50771946f, 0.39420795f, 0.04242405f, -0.04941925f, 0.02630756f, 0.15110213f, 
    -0.15011621f, -0.03267084f, -0.08649130f, -0.03888717f, -0.01434349f, -0.01244483f, 0.15064086f, -0.07296082f, 
    0.05951610f, -0.08333366f, 0.04268565f, -0.02052994f, -0.09788878f, -0.21763632f, -0.19867596f, -0.20413497f, 
    -0.09635929f, -0.07213268f, 0.06170525f, 0.02763170f, -0.13044298f, -0.24303022f, 0.07822794f, 0.00489748f, 
    -0.17515433f, -0.04877117f, -0.05099717f, 0.17711383f, -0.16477992f, 0.07110950f, -0.09531069f, -0.28020355f, 
    -0.18513732f, -0.31564227f, -0.31412497f, -0.31682566f, -0.17420007f, 0.09381475f, -0.08394185f, -0.05230021f, 
    -0.02181122f, -0.13670990f, 0.08728075f, -0.04294183f, 0.13357121f, -0.05181096f, -0.06273630f, 0.00870146f, 
    -0.02436266f, -0.06666326f, -0.10054220f, -0.15802604f, -0.14073902f, -0.39774695f, -0.28899664f, -0.20719288f, 
    -0.02440172f, 0.04796049f, -0.07967766f, -0.01189096f, -0.06954020f, -0.03695515f, 0.05760705f, 0.04896608f, 
    -0.00850607f, 0.01880366f, -0.01899956f, 0.06331665f, 0.04585032f, -0.00887822f, 0.03784486f, 0.07861487f, 
    0.04946075f, -0.01374474f, -0.01565653f, 0.01476708f, 0.03658532f, -0.01541469f, -0.03863356f, -0.00197206f, 
    0.02098039f, -0.04476264f, -0.00662135f, -0.01888141f, -0.03166575f, -0.03506679f, 0.01988579f, 0.02715556f, 
    0.01113689f, -0.00349452f, -0.00022684f, -0.03250041f, -0.03011091f, 0.00503827f, 0.01866925f, 0.04525524f, 
    -0.03374816f, -0.02113586f, 0.02522786f, 0.01344181f, 0.01191360f, -0.02684326f, 0.03297380f, 0.01564898f, 
    -0.00592191f, 0.01786458f, -0.03541400f, -0.00709069f, -0.01073616f, -0.01111876f, -0.02657869f, -0.02798377f, 
    -0.01392991f, 0.02037265f, -0.02757829f, -0.02948367f, -0.03399478f, 0.00095073f, -0.03531161f, 0.00237963f, 
    0.02862189f, -0.01354177f, -0.00051894f, -0.01247060f, -0.00194931f, 0.00098035f, 0.03297700f, -0.01910237f, 
    -0.00828687f, 0.01697492f, 0.02475058f, 0.00367979f, -0.00207485f, 0.00347610f, -0.00224502f, -0.01285305f, 
    0.03892171f, 0.01499381f, -0.00474146f, -0.01224709f, -0.01109652f, -0.01421864f, 0.01789212f, 0.01859338f, 
    0.00535572f, -0.01856796f, -0.01418728f, 0.01075649f, -0.01231441f, 0.01657457f, -0.02065291f, -0.02593034f, 
    -0.00046347f, -0.02047030f, -0.01961704f, 0.02800570f, -0.02251558f, 0.02111860f, 0.02211636f, 0.01632408f, 
    -0.01507247f, 0.02032461f, 0.01537338f, 0.03132828f, 0.02842850f, -0.00106357f, -0.00977258f, -0.00548700f, 
    -0.03129346f, 0.00677072f, -0.02899492f, -0.00262435f, -0.02391394f, 0.02066605f, -0.02352465f, -0.02250169f, 
    -0.01203707f, -0.00964989f, 0.02446792f, -0.02969807f, -0.02903664f, -0.03837088f, 0.03740348f, 0.00489854f, 
    0.01089733f, -0.01844445f, 0.01826451f, -0.04117875f, -0.03939962f, -0.00902319f, -0.00759880f, 0.03058420f, 
    0.01149088f, 0.02715025f, 0.03287438f, 0.00065328f, -0.03960191f, -0.03184306f, -0.03896467f, 0.02494434f, 
    -0.02156422f, -0.02194075f, -0.02674171f, 0.03123192f, -0.01560789f, 0.00709114f, 0.01143501f, 0.01990127f, 
    0.02194135f, 0.01622541f, 0.01573390f, 0.01871680f, -0.03801239f, -0.02596706f, -0.03176836f, -0.01692090f, 
    0.01770034f, -0.03596751f, 0.00753981f, 0.00959449f, -0.00650842f, -0.02179098f, 0.00482221f, -0.04219056f, 
    -0.04251540f, 0.02154973f, -0.02467120f, 0.00668156f, 0.02345406f, -0.04243940f, -0.01198099f, 0.02144991f, 
    0.03765781f, 0.03075847f, -0.01596090f, 0.00435032f, -0.01778050f, 0.02795562f, -0.02143997f, 0.02802571f, 
    0.02755050f, 0.02605687f, -0.02464301f, -0.03008630f, -0.03813179f, -0.01224389f, -0.02054212f, 0.02282042f, 
    0.00235322f, -0.02364709f, -0.01567725f, 0.03156823f, 0.02307397f, -0.01202015f, -0.01011027f, -0.00641244f, 
    0.02150695f, -0.01603816f, 0.00911880f, -0.00612791f, -0.03027053f, -0.00761409f, -0.02865272f, 0.01435168f, 
    0.00837618f, -0.04266984f, -0.02224274f, 0.01733955f, 0.01247560f, 0.01113055f, 0.02831817f, 0.03328704f, 
    -0.02929433f, 0.00470577f, -0.02682298f, -0.04295936f, 0.01466999f, 0.00276932f, -0.02609988f, 0.00560786f, 
    0.00917188f, 0.01440667f, -0.02474802f, 0.02114212f, 0.00487828f, -0.04491805f, 0.02083389f, 0.02371805f, 
    -0.01393654f, -0.04052297f, -0.00976245f, -0.03807111f, -0.02672015f, -0.03993389f, 0.00973394f, -0.01326851f, 
    -0.01428084f, -0.04345030f, 0.00657233f, -0.03489381f, 0.00307337f, 0.00735841f, -0.02124912f, 0.00933645f, 
    -0.00622512f, -0.01944641f, -0.03088429f, -0.00008274f, -0.01369516f, 0.02540439f, 0.01433973f, -0.01610529f, 
    -0.02774549f, -0.00931828f, 0.01720834f, 0.01663089f, -0.03609193f, 0.01906149f, 0.02094661f, -0.01939678f, 
    0.00932869f, 0.02003112f, -0.03205603f, 0.02332155f, -0.04490615f, -0.01089661f, -0.00406379f, -0.02101314f, 
    -0.03574139f, 0.02032706f, -0.01221681f, 0.00438585f, -0.02735500f, -0.01037864f, 0.01257360f, 0.03153622f, 
    0.00780790f, 0.03059950f, -0.02593288f, -0.02734958f, -0.01481963f, 0.01847078f, 0.01005597f, 0.00979426f, 
    -0.01959458f, -0.01767384f, 0.02672983f, 0.00800109f, -0.03970905f, 0.03382333f, -0.01343524f, -0.01388502f, 
    -0.00738781f, 0.02202374f, 0.00366775f, -0.04648625f, -0.04627417f, -0.04528463f, 0.02089221f, 0.01794315f, 
    -0.01254233f, 0.02409803f, -0.03874233f, 0.00554494f, 0.01872752f, 0.02727173f, 0.00922058f, -0.02352945f, 
    0.01261146f, -0.04036723f, -0.00289952f, -0.00073109f, -0.01890191f, -0.00799713f, -0.02176034f, 0.02101116f, 
    0.04344646f, 0.03616573f, 0.00940606f, -0.03524677f, 0.02115319f, 0.00174381f, 0.00191518f, 0.01524293f, 
    0.00183010f, 0.00331051f, -0.00860952f, 0.00798642f, -0.00479073f, -0.00843681f, 0.01157480f, -0.00128052f, 
    0.01951740f, -0.01690955f, -0.00643048f, 0.01202144f, 0.03042936f, -0.00625694f, 0.03196526f, 0.03294113f, 
    0.00147887f, 0.01182328f, -0.04529669f, -0.03825175f, 0.03535548f, -0.00254733f, -0.02626610f, 0.01089729f, 
    -0.01730079f, 0.01733269f, -0.01164946f, 0.00392337f, 0.01962822f, 0.01006227f, -0.03099141f, 0.01533499f, 
    0.01055645f, -0.00570659f, -0.04488201f, -0.04383932f, -0.03143983f, -0.04627690f, 0.01997729f, -0.04195987f, 
    0.00967523f, 0.00685318f, -0.00707059f, -0.03463620f, 0.02317526f, -0.03184231f, 0.00661497f, 0.02539696f, 
    -0.02142610f, -0.00394003f, 0.01105410f, 0.03170554f, 0.02741729f, 0.02027860f, 0.01588505f, 0.02605020f, 
    0.01156154f, 0.00094761f, -0.02826571f, -0.02636312f, -0.03386543f, 0.00282083f, -0.04071996f, 0.01904428f, 
    -0.00141695f, 0.02065191f, -0.00544086f, -0.03245592f, 0.02188695f, -0.02517132f, -0.00139833f, -0.02015649f, 
    0.00088775f, -0.04713396f, 0.02887072f, -0.01588158f, 0.01767574f, -0.00132476f, -0.01537278f, -0.00924436f, 
    -0.01466778f, -0.01536386f, -0.01946692f, -0.02276141f, -0.02986253f, 0.00313774f, -0.00343465f, -0.01757259f, 
    0.01038961f, -0.02047883f, -0.03193692f, -0.02801626f, 0.02901199f, -0.00137003f, -0.04260065f, -0.03877376f, 
    0.01328822f, -0.04684877f, -0.03200942f, -0.02669963f, -0.01254309f, -0.02064017f, 0.01658608f, 0.01305147f, 
    -0.00516156f, 0.02067877f, 0.01913322f, 0.04164731f, 0.00776277f, -0.03105776f, -0.03911819f, 0.02510751f, 
    0.00805444f, -0.03436489f, 0.00365136f, 0.01084713f, 0.02465240f, 0.00270814f, 0.02021424f, -0.01313885f, 
    -0.00450439f, 0.02150059f, 0.01539425f, -0.01985247f, -0.01197994f, -0.03215748f, -0.04391252f, -0.01027224f, 
    0.02479855f, -0.03743580f, -0.00864802f, 0.02167212f, 0.02669954f, 0.01909490f, 0.03027115f, -0.03806069f, 
    -0.02625065f, 0.01255157f, -0.03093994f, 0.02494089f, -0.03821677f, 0.00948219f, -0.00341813f, -0.02868810f, 
    0.01078525f, -0.02066134f, -0.03212734f, 0.00187556f, 0.02445667f, -0.02819739f, 0.01001250f, -0.00109431f, 
    0.01863907f, 0.02538964f, 0.01579896f, -0.03699445f, -0.03681721f, -0.01949739f, -0.02874452f, 0.02105400f, 
    -0.02719080f, 0.02940311f, 0.03006770f, 0.01275754f, -0.03465348f, -0.03370750f, 0.02216043f, -0.00529424f, 
    -0.00476899f, -0.00156843f, -0.03645470f, -0.02322599f, 0.02449551f, 0.00990781f, 0.03023046f, 0.02844885f, 
    -0.01446837f, -0.04265963f, 0.02015249f, 0.02585871f, -0.00618488f, 0.00399604f, -0.03517313f, 0.02706080f, 
    -0.01657880f, -0.03634953f, -0.03900246f, 0.00988087f, 0.00776043f, -0.03096485f, -0.02477275f, 0.01473542f, 
    0.01130235f, -0.03313668f, -0.00509537f, -0.01488145f, 0.01421633f, -0.03553808f, -0.03648458f, 0.00336620f, 
    0.02201675f, 0.01785201f, -0.03454849f, -0.01634669f, -0.02699383f, -0.02668391f, 0.02845346f, -0.00169354f, 
    0.01027658f, 0.02353184f, -0.00486519f, 0.01213938f, -0.02935897f, 0.02658459f, -0.03703810f, -0.02325171f, 
    0.01126008f, -0.00404983f, 0.00958604f, 0.02887008f, 0.00445223f, 0.00352045f, -0.02928207f, 0.02502954f, 
    -0.01734788f, -0.03138727f, 0.01869334f, 0.00794203f, -0.01146273f, 0.01993608f, -0.01734655f, 0.01776249f, 
    0.02059414f, 0.01455099f, -0.04425096f, 0.01109305f, 0.01636473f, -0.03532589f, -0.01686322f, -0.02822308f, 
    -0.02094785f, -0.04370273f, 0.02644383f, -0.00547770f, 0.00752020f, -0.02954083f, -0.01227435f, 0.00010112f, 
    -0.03132742f, -0.01961889f, 0.01200119f, -0.00393809f, -0.02969605f, 0.01997172f, -0.00282025f, -0.04587720f, 
    0.01418326f, -0.02329506f, -0.00123538f, -0.00695626f, -0.01037187f, -0.00427644f, 0.00941785f, -0.02441218f, 
    0.01855435f, -0.04481816f, 0.02824985f, -0.00755895f, -0.00188653f, -0.02956671f, 0.01758560f, -0.00774780f, 
    -0.03777148f, -0.00385002f, -0.01811278f, 0.00434172f, -0.00604509f, 0.01717778f, 0.01384071f, 0.01956077f, 
    -0.04027269f, 0.00794845f, -0.01136514f, 0.02882224f, -0.03553886f, -0.00119375f, -0.00082310f, -0.00967546f, 
    -0.03379311f, -0.02624496f, 0.02191865f, 0.00431965f, 0.00260529f, 0.00021821f, 0.01798317f, 0.01583565f, 
    -0.02136514f, 0.01311683f, 0.01338297f, 0.03165787f, -0.00501673f, 0.02586098f, 0.03155297f, 0.02008643f, 
    -0.01725870f, -0.00852433f, -0.02288004f, -0.00904703f, 0.01274291f, -0.03296337f, 0.00240733f, 0.01404098f, 
    -0.02404547f, 0.02608038f, 0.01677104f, 0.02519718f, -0.00672351f, 0.02633433f, -0.02065488f, 0.00262433f, 
    -0.04149987f, -0.01887244f, -0.02409146f, -0.03046410f, 0.02322612f, -0.02922941f, -0.02507039f, -0.03020729f, 
    -0.32315898f, 0.14518766f, 0.23156635f, 0.05471826f, -0.06199488f, -0.06899592f, 0.10842881f, -0.06705423f, 
    0.03809804f, 0.01529038f, 0.03307791f, -0.04826344f, 0.04403824f, 0.02817025f, 0.00932663f, 0.03588995f, 
    0.00430474f, 0.22633809f, 0.02658808f, 0.02463745f, 0.18181147f, 0.33485299f, 0.04789623f, 0.00021138f, 
    0.08336592f, -0.00661252f, -0.04321945f, 0.11307994f, 0.05578631f, -0.03379295f, 0.11096388f, 0.08666161f, 
    0.03701812f, -0.03900911f, -0.08913373f, 0.00738519f, 0.08408348f, -0.01732444f, -0.12349044f, 0.15664275f, 
    -0.34008047f, 0.06066988f, 0.12897481f, -0.15042236f, 0.10021628f, 0.00593840f, 0.02107304f, -0.01055971f, 
    -0.06506962f, -0.07541275f, 0.07034791f, 0.06208723f, 0.02511853f, 0.08432580f, 0.20379315f, -0.05154319f, 
    -0.04852570f, 0.02989196f, 0.06014543f, -0.00428669f, 0.49223801f, 0.08451362f, -0.14168981f, -0.32555956f, 
    -0.07742618f, 0.08454967f, 0.11403239f, 0.04776052f, 0.02229541f, 0.01104098f, -0.12161958f, -0.04241824f, 
    -0.11813387f, -0.02969663f, -0.05222571f, -0.12184551f, 0.05827279f, 0.08222184f, 0.05278816f, -0.06235324f, 
    0.10061937f, 0.15070422f, -0.10476264f, -0.31267467f, -0.22435381f, -0.12244792f, -0.30472979f, -0.13992697f, 
    0.01571438f, 0.00541238f, 0.03886885f, -0.04574736f, 0.02859413f, -0.04490701f, -0.03226370f, -0.24575037f, 
    0.07918266f, -0.17986116f, 0.00390285f, 0.07413217f, -0.13668260f, -0.00978824f, 0.12501244f, -0.05147758f, 
    0.11818918f, -0.06332232f, -0.14214060f, 0.07001042f, -0.05723347f, 0.10485764f, 0.09214644f, 0.13026835f, 
    -0.00944704f, 0.17104988f, 0.10034037f, -0.07835869f, 0.07304952f, 0.09908098f, 0.11129263f, -0.06812621f, 
    0.11256645f, 0.08086039f, 0.26617029f, -0.41203019f, -0.11772569f, 0.14030857f, 0.12269222f, -0.11125614f, 
    0.13578402f, -0.08382805f, 0.17063335f, -0.10515131f, -0.05457916f, -0.10253129f, -0.04894568f, -0.00726633f, 
    0.04868516f, 0.17807570f, 0.10055350f, 0.04307778f, -0.02095006f, 0.19576815f, -0.05854810f, -0.08239569f, 
    -0.01771241f, 0.01942968f, -0.15042455f, 0.05457937f, -0.17513427f, 0.14759764f, 0.21409808f, 0.14615227f, 
    0.08081369f, 0.16484639f, -0.03660373f, 0.01526689f, 0.11255202f, 0.06842097f, -0.08286749f, 0.04589590f, 
    0.25377098f, -0.09565208f, -0.14842056f, -0.15775989f, -0.12224774f, 0.09441836f, 0.10240539f, 0.03530239f, 
    -0.03035219f, -0.09842418f, 0.02291131f, 0.05133855f, -0.01052979f, -0.03549790f, 0.07720517f, -0.04088511f, 
    -0.06437594f, 0.10173478f, 0.02726984f, 0.02598500f, 0.11919535f, 0.22498149f, -0.02109792f, -0.14020130f, 
    0.29934728f, -0.02742981f, -0.16276291f, 0.10530352f, 0.13306555f, 0.09347390f, 0.03601933f, -0.16544251f, 
    -0.07860604f, 0.01815598f, 0.04587469f, -0.10414960f, 0.05850820f, 0.00537257f, -0.04235963f, -0.03997077f, 
    0.12470974f, 0.16609231f, -0.23245083f, -0.30231711f, 0.29841685f, -0.00253435f, 0.05511299f, 0.16856758f, 
    0.24054638f, 0.08926272f, -0.00248299f, -0.06029111f, -0.04327465f, -0.00520714f, 0.07515526f, -0.11543653f, 
    0.04107859f, 0.02537029f, 0.02278349f, 0.00675250f, 0.32528421f, 0.39537054f, -0.06050017f, -0.03346382f, 
    -0.19512072f, -0.01480288f, -0.18237820f, 0.02630873f, 0.15395975f, -0.12587468f, 0.02070027f, -0.04295499f, 
    0.08150936f, 0.08201084f, 0.13016626f, -0.12100956f, -0.06846265f, -0.02550773f, 0.16255525f, -0.13367321f, 
    0.02888948f, -0.09168896f, 0.38202876f, -0.22131617f, 0.17014123f, -0.04000273f, 0.03784859f, 0.25393021f, 
    -0.14636533f, -0.18227422f, 0.09850262f, 0.15496062f, 0.09427398f, -0.07473958f, 0.05144569f, 0.04030947f, 
    -0.00348894f, 0.12831320f, -0.00585016f, -0.06184022f, 0.20804596f, 0.15259285f, -0.13366552f, -0.36032814f, 
    0.49714699f, 0.10184339f, 0.15566781f, 0.25766733f, 0.11624432f, -0.00735801f, -0.04368639f, -0.04828896f, 
    0.00685154f, -0.03495887f, 0.18054056f, -0.10361737f, 0.03410587f, -0.07436570f, 0.12253654f, -0.04667487f, 
    0.24698353f, 0.11414406f, -0.06423999f, 0.15695019f, -0.09590741f, -0.01765624f, -0.14243856f, -0.01581237f, 
    -0.25137636f, 0.14336368f, 0.06304295f, 0.13431343f, -0.06797527f, 0.08926164f, -0.01351210f, -0.00997655f, 
    0.02442070f, 0.00253653f, -0.03133693f, 0.04261797f, 0.17642422f, 0.00326147f, -0.02930645f, -0.35179844f, 
    -0.08663698f, 0.15078641f, 0.21188027f, 0.07112864f, -0.03682849f, 0.04665886f, 0.06943405f, -0.14515659f, 
    -0.11959512f, -0.00419445f, -0.05209412f, -0.03884896f, 0.01111208f, 0.05028368f, -0.06892854f, -0.07220177f, 
    0.51503718f, 0.06307203f, -0.01807731f, -0.22841246f, -0.14209048f, 0.26546404f, -0.00317133f, 0.20874985f, 
    0.04990296f, -0.00338711f, -0.02065826f, -0.10431419f, -0.09544197f, 0.04312902f, 0.06240353f, -0.00875474f, 
    -0.01284003f, 0.05802716f, 0.00153265f, 0.02834534f, -0.26211029f, -0.01248139f, -0.03129706f, -0.11412543f, 
    0.08760130f, -0.07275457f, -0.14020482f, -0.08263713f, -0.06073991f, 0.08799777f, 0.16069260f, 0.03986423f, 
    0.06681792f, -0.05850594f, 0.07005563f, 0.04811871f, -0.08336262f, 0.06841758f, -0.05853158f, -0.00672716f, 
    0.29328293f, -0.04400811f, 0.01969058f, -0.35863110f, -0.14802143f, 0.26812187f, 0.20569773f, -0.08146552f, 
    0.03055661f, -0.10584854f, 0.08647066f, -0.00752813f, 0.00574665f, 0.05177195f, -0.05907408f, -0.05098987f, 
    -0.02440759f, 0.11626399f, 0.18295217f, 0.10947226f, -0.13988036f, -0.09243231f, -0.19321626f, 0.18322688f, 
    0.06611556f, -0.07373702f, -0.17842612f, -0.03049924f, -0.09976376f, 0.04488637f, 0.02313171f, -0.06896941f, 
    0.02262010f, 0.07962286f, -0.02912850f, -0.02157558f, 0.02061141f, -0.00165329f, -0.17368534f, -0.03793841f, 
    0.18465923f, 0.11123051f, 0.05967208f, 0.11509254f, -0.27008542f, 0.07851226f, -0.15350509f, 0.04219243f, 
    0.10480112f, -0.18713687f, 0.08050710f, 0.00423386f, 0.08068068f, -0.20744812f, -0.03319333f, 0.23956019f, 
    -0.07799368f, -0.13222983f, 0.12696220f, 0.30501029f, -0.17533295f, 0.21572831f, 0.45932719f, -0.09650873f, 
    -0.06510241f, -0.08492908f, 0.17827848f, -0.10199607f, 0.12041328f, 0.10635383f, 0.06083178f, -0.05058298f, 
    0.06274113f, -0.04488729f, -0.05928222f, -0.06277640f, 0.08827190f, 0.15666246f, 0.03190293f, 0.01892874f, 
    -0.32224417f, -0.50649697f, 0.02598146f, -0.06664890f, -0.00080219f, 0.08526881f, 0.00979767f, -0.11164603f, 
    0.01807688f, -0.09474243f, 0.06967363f, 0.04894371f, 0.10835182f, -0.17935170f, 0.02630273f, 0.05478122f, 
    0.12613018f, 0.04382069f, -0.08594812f, -0.07666329f, -0.01384006f, -0.10121092f, 0.25866181f, -0.03500335f, 
    -0.11176429f, -0.00193986f, 0.13196360f, 0.04369728f, -0.13470130f, 0.00885043f, 0.12013807f, -0.03501758f, 
    -0.09230806f, -0.03650491f, -0.06852604f, -0.03267856f, 0.06350452f, 0.12970257f, 0.05367693f, 0.07329612f, 
    0.26143602f, -0.35280964f, -0.05602511f, -0.02259623f, -0.12317466f, -0.00930932f, 0.00566028f, -0.11559550f, 
    0.02255747f, -0.09162980f, 0.10384008f, 0.06663740f, -0.01281438f, -0.10769255f, 0.03124208f, -0.03671615f, 
    0.03070935f, -0.02426918f, -0.06993043f, 0.10078538f, 0.38188034f, -0.05526491f, -0.08209774f, -0.05643858f, 
    -0.03723184f, 0.14749353f, 0.14852755f, 0.00517029f, -0.04070919f, 0.09701388f, -0.05364319f, -0.03644296f, 
    0.07033996f, 0.02685720f, -0.11123523f, -0.05183903f, 0.00356578f, -0.04328759f, 0.06427984f, -0.06678578f, 
    -0.33655676f, 0.29911652f, 0.29199761f, -0.06887417f, 0.00046034f, -0.03398778f, -0.11944612f, -0.14068627f, 
    0.08285446f, 0.14667419f, -0.04051186f, -0.07049096f, -0.04903143f, -0.07418118f, 0.09742962f, 0.01220875f, 
    -0.01008653f, 0.01180767f, 0.04264180f, -0.12242673f, -0.19814174f, 0.10687546f, -0.08478904f, 0.07321341f, 
    -0.07500358f, -0.10631422f, -0.20980807f, -0.21321860f, -0.06548220f, -0.09010140f, -0.16786219f, -0.21108508f, 
    -0.00462254f, 0.07915911f, 0.06723920f, -0.11871944f, 0.07989945f, -0.14432146f, 0.06863196f, 0.07240283f, 
    -0.09751468f, 0.30838341f, -0.17489329f, -0.00835651f, 0.50671357f, 0.12926453f, -0.08467945f, 0.38846821f, 
    -0.06968766f, 0.27579442f, 0.00473639f, 0.22686821f, -0.06734093f, -0.04170945f, 0.07044762f, -0.01289963f, 
    0.08618120f, 0.03464831f, 0.20114619f, 0.08423577f, -0.39930832f, -0.09339783f, 0.14665198f, -0.10590354f, 
    0.00060588f, -0.35432827f, 0.02093535f, -0.09288555f, -0.07255063f, -0.07026784f, 0.14105320f, -0.00569928f, 
    0.00513232f, 0.08245751f, 0.07044475f, 0.16602850f, -0.19267094f, -0.10866696f, -0.06887426f, -0.08216713f, 
    -0.20936915f, 0.06344049f, -0.12534335f, 0.13142414f, -0.05384669f, -0.07266120f, -0.25468448f, 0.02570108f, 
    0.01071317f, -0.03382301f, 0.13032386f, -0.03481755f, -0.03042993f, 0.02494373f, 0.04936823f, -0.07387816f, 
    -0.03553459f, -0.02383328f, 0.04805519f, 0.16886458f, 0.11112823f, 0.04332715f, -0.09654120f, -0.03390288f, 
    -0.12179211f, -0.21758278f, -0.14459744f, -0.02089459f, -0.20943032f, 0.21574806f, -0.01977508f, 0.01599082f, 
    -0.03265136f, 0.08143284f, 0.08174042f, -0.02897268f, -0.00473307f, 0.10641546f, -0.03540726f, 0.05002783f, 
    -0.54665506f, 0.09994061f, -0.30664131f, 0.30753195f, -0.27330744f, 0.02279281f, 0.08554962f, 0.14027739f, 
    0.13061829f, 0.13771187f, 0.02309905f, 0.09895822f, -0.01043070f, -0.01957480f, -0.04799044f, 0.06159801f, 
    -0.01345521f, 0.16099964f, -0.00027394f, -0.13284655f, -0.56916475f, 0.39556670f, 0.26573178f, -0.25092813f, 
    0.09630764f, -0.13536802f, 0.07163704f, 0.21275781f, -0.02962063f, -0.03957522f, 0.14469396f, -0.00632029f, 
    -0.00186086f, -0.08648163f, -0.12541755f, -0.09093697f, -0.11602710f, -0.11433905f, -0.22481461f, -0.10263669f, 
    0.47272760f, -0.09707137f, 0.05600894f, 0.01453612f, 0.15760083f, 0.04579988f, -0.06415341f, -0.02606964f, 
    -0.04347556f, 0.02437057f, 0.14914046f, -0.02665609f, 0.06443781f, 0.15824232f, -0.05587333f, 0.00574389f, 
    -0.06323420f, -0.04968032f, 0.10430908f, 0.25586128f, -0.03129426f, 0.14778692f, 0.25856209f, 0.00901009f, 
    -0.38824135f, 0.13052669f, 0.02160086f, 0.00042407f, 0.04712838f, 0.02277947f, -0.03494370f, -0.07499550f, 
    -0.07454062f, 0.06401587f, -0.08130448f, -0.12251622f, 0.02783082f, -0.01929626f, -0.04297397f, -0.01293105f, 
    0.20433804f, 0.13060537f, 0.01273465f, 0.08712602f, -0.00440107f, -0.06589209f, -0.03775465f, -0.13758388f, 
    -0.04200266f, -0.07525425f, 0.07613586f, 0.01437966f, -0.11679272f, 0.12723701f, 0.03765658f, -0.10156585f, 
    -0.02478408f, 0.07183195f, -0.03692815f, 0.03725568f, 0.42564532f, -0.18358110f, 0.01563859f, -0.05634302f, 
    0.24719629f, -0.12572491f, -0.05847035f, -0.05240225f, -0.09777275f, -0.10613927f, 0.20089903f, 0.10052805f, 
    -0.00434468f, -0.10624716f, 0.00172413f, -0.04577079f, -0.00186159f, 0.03461035f, 0.13288933f, 0.02974154f, 
    0.07510346f, 0.29331055f, 0.34057727f, -0.06639794f, -0.22661239f, 0.14829861f, 0.01029482f, 0.02249678f, 
    0.06867932f, 0.02233943f, 0.08858060f, -0.04666642f, 0.04497701f, 0.18561277f, 0.05425240f, -0.06118369f, 
    0.02608063f, -0.05901673f, 0.10228346f, 0.02964271f, 0.48115605f, -0.31495556f, -0.24844524f, -0.41254154f, 
    0.10225281f, 0.08650848f, -0.07881526f, -0.02143843f, -0.12064301f, 0.17522803f, 0.17236207f, -0.05864916f, 
    0.04676068f, -0.03806641f, 0.19194134f, 0.09849460f, -0.05890369f, -0.02932684f, 0.19610241f, 0.14702891f, 
    0.03159380f, 0.25078651f, 0.41265696f, -0.14225684f, -0.14128803f, 0.01045784f, -0.00207520f, -0.05331602f, 
    0.00605846f, -0.06659275f, 0.02342542f, -0.07752231f, 0.00114921f, 0.04181757f, -0.07752294f, -0.05599672f, 
    0.02949844f, -0.07844871f, 0.05327850f, 0.14021219f, 0.24198636f, 0.07579413f, -0.03405418f, -0.17290397f, 
    -0.35354245f, -0.00380178f, 0.00754968f, -0.12968644f, -0.07192447f, 0.13027181f, 0.05806813f, -0.00525434f, 
    0.10311990f, 0.11060191f, 0.01812294f, -0.08834334f, -0.00729026f, 0.00380288f, -0.00279939f, 0.02913223f, 
    0.18951276f, 0.04393359f, -0.09143586f, 0.02528930f, -0.28850448f, -0.14348304f, -0.15963379f, -0.14668179f, 
    -0.01510976f, 0.05714507f, 0.18845268f, 0.04644103f, 0.00723600f, 0.12385618f, 0.02710993f, 0.04311453f, 
    -0.00771768f, 0.01167940f, 0.04868973f, -0.04747397f, -0.26030934f, 0.61769456f, 0.35325107f, -0.27547085f, 
    -0.11217847f, -0.17608148f, -0.04603823f, 0.17823395f, -0.14601433f, -0.07618499f, 0.25982288f, -0.03806271f, 
    -0.17965309f, 0.18493259f, -0.01597456f, 0.06300173f, 0.04671310f, 0.38245973f, -0.17620575f, -0.20004742f, 
    0.65061384f, -0.27006713f, 0.17707933f, -0.42918000f, 0.07632853f, 0.14387596f, 0.10088420f, -0.03783483f, 
    0.15080056f, 0.05470972f, 0.18957044f, -0.11269261f, 0.23735705f, -0.12074105f, 0.03059360f, -0.03182992f, 
    0.03633634f, -0.08196097f, 0.06067135f, 0.07256432f, 0.15468869f, 0.13092726f, -0.00561116f, -0.12750860f, 
    -0.48404726f, 0.02403699f, -0.06106752f, 0.03049869f, 0.06201281f, 0.05838585f, 0.01992220f, -0.04925973f, 
    -0.01175610f, 0.11272434f, -0.06925321f, -0.02076988f, -0.06595603f, 0.02335863f, 0.02946150f, 0.05118168f, 
    -0.09860451f, -0.17880411f, -0.25932246f, 0.15901472f, 0.11472644f, 0.04857399f, 0.00695975f, 0.08759047f, 
    0.01137978f, 0.13309188f, 0.02843519f, 0.08519597f, -0.03554466f, 0.07473467f, 0.13122395f, -0.13501114f, 
    0.01198682f, -0.07628150f, 0.07926556f, 0.06323610f, 0.03329960f, 0.22334310f, 0.31075442f, 0.13114952f, 
    -0.33261520f, 0.12466532f, 0.06179874f, 0.00652912f, 0.04756037f, 0.04244338f, 0.09467061f, -0.06391887f, 
    -0.04824133f, -0.03543942f, 0.13567519f, 0.03558850f, -0.01332358f, -0.03955747f, 0.00536771f, -0.07303654f, 
    -0.08651963f, 0.14356959f, 0.09949860f, 0.05290198f, -0.44739169f, 0.07193767f, 0.10437087f, 0.05556093f, 
    0.05726524f, 0.02682116f, 0.05619221f, -0.13360608f, -0.04298586f, 0.00209684f, -0.08432042f, -0.09049712f, 
    0.04062358f, 0.01133260f, 0.00943589f, -0.05585552f, 0.09142516f, 0.30635417f, -0.88287240f, 0.03785894f, 
    -0.22031079f, 0.08830068f, -0.16586308f, 0.20730785f, -0.30823264f, 0.10651093f, 0.10175813f, 0.05164072f, 
    -0.03533130f, -0.02952093f, -0.01030357f, 0.17362365f, 0.03189185f, -0.07191128f, 0.03218827f, 0.07787386f, 
    0.06391060f, 0.28355312f, 0.42452756f, -0.09095765f, -0.11350472f, 0.00819859f, 0.11523391f, 0.07403384f, 
    0.02812560f, -0.05828429f, 0.03762405f, -0.02715580f, 0.07516683f, 0.08167223f, 0.04997442f, 0.00261252f, 
    -0.04873244f, -0.07009896f, 0.26486906f, 0.18268251f, -0.23332684f, -0.00186633f, -0.27883729f, 0.27434230f, 
    -0.04015763f, 0.04360519f, 0.01119636f, 0.02462034f, -0.00069902f, 0.01823388f, 0.01988827f, 0.02340552f, 
    -0.11425102f, 0.08571732f, -0.06801205f, -0.02895618f, -0.06571517f, 0.08275146f, 0.09263917f, 0.08738936f, 
    -0.00842929f, -0.12910354f, 0.07762555f, 0.15810663f, 0.04253750f, -0.14046793f, 0.10413889f, -0.28929844f, 
    -0.18327540f, -0.15327333f, 0.18653770f, -0.10012858f, 0.24235037f, -0.17487636f, -0.20128413f, 0.15924393f, 
    0.09441712f, -0.13141973f, -0.00407600f, 0.27186009f, -0.39350557f, 0.07665723f, -0.21736924f, 0.17237715f, 
    -0.25883076f, 0.06495087f, 0.08105144f, 0.00220739f, 0.20816988f, 0.04812526f, -0.02913160f, -0.01667447f, 
    -0.03209243f, 0.04950286f, 0.02614933f, 0.04291262f, -0.01601893f, -0.07112479f, -0.03533261f, -0.21458878f, 
    -0.18912129f, -0.07753452f, -0.31287876f, 0.11412167f, -0.05613399f, 0.10169753f, 0.17279957f, 0.17434472f, 
    0.04554069f, 0.00486365f, -0.08899289f, 0.00037029f, -0.10882987f, -0.01828908f, -0.00123241f, -0.01290038f, 
    -0.03764873f, -0.01200123f, 0.06216543f, -0.05772726f, 0.23270196f, 0.16714977f, 0.20328292f, -0.10576884f, 
    -0.08317905f, 0.14812890f, 0.05535571f, 0.07356670f, 0.09611146f, 0.14562549f, 0.07532894f, 0.00482008f, 
    -0.00468444f, 0.05541984f, -0.00748171f, 0.04967755f, 0.04202609f, -0.04325273f, -0.16731913f, 0.14707421f, 
    -0.06498160f, 0.15614116f, 0.04629914f, 0.07614414f, -0.30713668f, -0.03606567f, -0.02775871f, 0.22864991f, 
    0.16198127f, 0.12074699f, 0.05431876f, -0.05915314f, 0.03855968f, -0.06353659f, -0.04726461f, -0.07019494f, 
    0.11350868f, -0.00506488f, 0.19419916f, 0.08801672f, -0.07939839f, -0.03150539f, 0.16683938f, 0.22328228f, 
    -0.18791513f, 0.11348800f, 0.00291925f, 0.05208416f, 0.00673088f, 0.19341630f, 0.05828606f, 0.03179664f, 
    -0.10993137f, 0.01363047f, 0.08065677f, 0.03672749f, -0.11058021f, 0.10264940f, 0.12039918f, 0.15998556f, 
    -0.00864676f, 0.23373039f, -0.23461920f, 0.14856935f, 0.38588783f, -0.03424336f, 0.00171412f, -0.06291384f, 
    -0.10724965f, -0.03114111f, -0.03225784f, -0.02612010f, 0.04978185f, -0.03628455f, -0.06476197f, -0.07525107f, 
    -0.11283007f, -0.39842886f, 0.09599847f, 0.08831426f, 0.08132967f, 0.08433279f, -0.06158673f, 0.30224916f, 
    0.13136537f, -0.04999573f, -0.04161461f, 0.01226888f, -0.11075497f, -0.01142207f, 0.06671689f, 0.01985016f, 
    -0.15001228f, 0.12288457f, -0.06328938f, -0.16029416f, -0.02127516f, 0.12032800f, -0.03162568f, -0.02155556f, 
    -0.04918021f, -0.39676204f, -0.42523360f, -0.27083167f, -0.41628680f, 0.23160553f, -0.20497712f, -0.02303929f, 
    -0.13091551f, 0.11488885f, 0.17754956f, 0.14752266f, 0.03065427f, 0.05754288f, -0.14704001f, -0.06422068f, 
    -0.05121572f, 0.09974389f, -0.04031257f, 0.06522799f, 0.13428868f, 0.01250052f, 0.06626967f, -0.06201161f, 
    0.00102150f, 0.00119398f, 0.00168015f, -0.10114343f, -0.13744082f, 0.02137746f, 0.06956521f, -0.07096940f, 
    0.42186436f, -0.02793716f, 0.04847599f, -0.00569495f, 0.05714610f, -0.18291977f, 0.03465899f, 0.15543918f, 
    0.22402085f, 0.13002905f, 0.00287628f, 0.09695936f, 0.07189624f, -0.04667914f, -0.08819801f, -0.02105079f, 
    -0.15611920f, -0.08899023f, 0.11306970f, 0.05372481f, 0.01422823f, 0.09444111f, 0.01153467f, -0.07949613f, 
    0.01172659f, 0.07665876f, 0.03301124f, 0.13026378f, 0.16569440f, 0.12589563f, -0.00764550f, 0.16105193f, 
    0.09876099f, -0.07160641f, -0.04649485f, -0.14767185f, -0.08504891f, -0.08901823f, 0.12081028f, 0.11275025f, 
    0.01565099f, 0.05844086f, 0.05044368f, 0.04904563f, -0.12460933f, 0.02838452f, 0.01934295f, -0.05790192f, 
    0.54978395f, -0.18900931f, -0.02437283f, -0.02990140f, 0.00252468f, -0.07167822f, 0.07727069f, 0.06627965f, 
    0.19205429f, 0.06200856f, 0.01957226f, -0.02607935f, 0.06502005f, -0.02479087f, 0.02047605f, -0.09905095f, 
    0.13022207f, -0.13102345f, 0.07398061f, -0.04773808f, 0.49257705f, -0.18462753f, -0.14584096f, -0.10278514f, 
    0.19982153f, 0.05127253f, -0.01049869f, -0.08910396f, -0.03053732f, -0.01907939f, -0.00932425f, 0.01802093f, 
    -0.01779720f, 0.00953424f, 0.13217625f, 0.22072746f, 0.16678305f, 0.22835010f, 0.12077793f, -0.16022478f, 
    0.04021524f, 0.02207568f, 0.14157975f, 0.15107243f, 0.09370215f, 0.15490653f, -0.01745589f, 0.11466786f, 
    0.03289962f, -0.01182226f, 0.04449787f, 0.00284536f, 0.02248993f, 0.13159154f, 0.11116926f, 0.02850052f, 
    0.02197564f, -0.06631398f, -0.05420532f, 0.03525871f, -0.01898314f, -0.38685587f, -0.23746541f, -0.24750772f, 
    0.05276077f, -0.10159603f, 0.04694055f, -0.16509096f, -0.12926538f, -0.00386396f, -0.03784298f, -0.09305522f, 
    -0.03851989f, -0.04732920f, -0.03460878f, -0.03078362f, -0.05353451f, -0.02735585f, -0.07537931f, -0.09874015f, 
    0.12727280f, 0.14345177f, 0.09060312f, -0.13844413f, -0.17536712f, 0.06378494f, 0.03086262f, 0.06784637f, 
    0.01654377f, 0.02035097f, -0.08226755f, -0.11723415f, -0.14345850f, -0.07567655f, 0.03081528f, 0.04991026f, 
    0.00741782f, -0.03115422f, 0.02325210f, -0.00949224f, -0.12955804f, 0.12213372f, 0.08174492f, 0.08946939f, 
    -0.18561740f, 0.03653353f, 0.12861414f, 0.07594711f, -0.03201383f, 0.05339281f, 0.11552074f, 0.06929960f, 
    0.14552927f, 0.15906923f, -0.15988702f, -0.03410906f, -0.05824998f, -0.14753336f, -0.05632376f, 0.11268034f, 
    0.07752156f, 0.02386221f, -0.18071893f, -0.07504995f, -0.09904368f, 0.00877411f, 0.05792168f, 0.03982218f, 
    0.00082635f, -0.06683204f, -0.06920956f, -0.08049306f, -0.05487864f, -0.09759770f, -0.03921678f, -0.02282730f, 
    -0.00415887f, 0.08666012f, 0.18722451f, 0.00118556f, 0.58281261f, 0.11701239f, 0.15754592f, -0.03799074f, 
    0.14287123f, 0.00299427f, 0.05735546f, 0.17824972f, 0.12386805f, -0.07670451f, 0.08426767f, 0.00816503f, 
    0.24355577f, 0.07038321f, -0.05025663f, -0.05981942f, -0.05072051f, 0.11919501f, 0.02722371f, 0.05754672f, 
    -0.17027041f, -0.22554140f, -0.31106389f, -0.13176949f, 0.17984882f, -0.12346326f, -0.02976415f, -0.08508599f, 
    -0.11790709f, 0.03108156f, -0.07636345f, -0.08715764f, -0.11505654f, -0.01034634f, 0.05134464f, -0.02439575f, 
    -0.00949044f, -0.00509416f, -0.07833660f, -0.05254986f, 0.05789653f, -0.03630873f, -0.28506631f, -0.15930782f, 
    -0.07351600f, -0.04130828f, 0.06947173f, 0.05718916f, -0.03059304f, 0.22884066f, 0.16240320f, -0.05182719f, 
    0.05949590f, -0.04674547f, -0.04040702f, -0.02876619f, 0.05717624f, -0.07808865f, -0.00075089f, -0.09393089f, 
    0.54337209f, 0.12765522f, -0.42928961f, -0.38437459f, -0.18452671f, -0.23975125f, -0.09229040f, 0.00949710f, 
    -0.00312403f, 0.22807081f, 0.01332119f, -0.11494960f, -0.02351669f, -0.01957736f, -0.07367762f, -0.07885911f, 
    -0.04968693f, -0.09272412f, 0.07595490f, -0.11477549f, -0.38244721f, -0.10716920f, 0.26377800f, 0.58036762f, 
    -0.06232506f, -0.08951186f, 0.15084060f, -0.01908668f, 0.11991701f, -0.08052385f, -0.17436120f, 0.33049625f, 
    0.34735572f, 0.10797466f, 0.05647563f, -0.09954131f, -0.04251175f, 0.00688426f, -0.11800493f, 0.04399488f, 
    0.24881881f, -0.29748103f, -0.12694567f, 0.15106270f, 0.30965930f, 0.15730187f, 0.02004811f, 0.26222312f, 
    0.11504308f, 0.00955386f, -0.05827332f, 0.01255137f, -0.00733057f, 0.15528639f, 0.20134175f, 0.01722420f, 
    0.07059626f, 0.02548043f, -0.12767430f, -0.03308529f, 0.41430685f, -0.20650327f, -0.60347497f, -0.40858158f, 
    0.07052019f, -0.12251173f, -0.04091986f, 0.04628054f, 0.21399774f, 0.03114899f, -0.09040768f, -0.06481598f, 
    -0.05882309f, -0.03443615f, -0.08516414f, 0.03419021f, -0.01063672f, -0.12484834f, -0.05343279f, -0.07821003f, 
    0.51510733f, 0.31850854f, 0.23317619f, -0.10961735f, 0.08195066f, -0.10216549f, -0.00704941f, -0.03539378f, 
    0.11192905f, 0.09480181f, 0.08398949f, -0.02722601f, 0.13917832f, -0.01690309f, 0.07654683f, -0.06515871f, 
    -0.04533828f, -0.02750232f, 0.06201278f, 0.03373414f, 0.25894535f, -0.05112479f, -0.46321502f, -0.58145100f, 
    0.03228727f, -0.14619656f, 0.17921908f, 0.00936814f, 0.07345547f, 0.05696044f, -0.13195266f, -0.10971405f, 
    -0.08601140f, -0.13700014f, 0.01344837f, 0.01421282f, -0.01527921f, 0.10224292f, 0.26381204f, 0.01132380f, 
    0.16731429f, -0.02867734f, -0.18326303f, -0.32621148f, 0.15168896f, -0.22545969f, 0.02800285f, -0.09149742f, 
    -0.21887526f, -0.05801786f, -0.08830588f, -0.09126911f, -0.04841543f, -0.05633035f, 0.04103383f, -0.02705784f, 
    -0.07555006f, -0.04174149f, 0.04180549f, -0.12022629f, 0.36617088f, 0.30478427f, 0.07234551f, 0.13617840f, 
    0.11565518f, -0.01886741f, -0.19299977f, -0.00793817f, 0.33223537f, -0.05647545f, 0.08564765f, 0.02828342f, 
    0.10957148f, -0.01832022f, 0.00599757f, -0.08229102f, -0.12655497f, 0.10337815f, 0.06875480f, 0.10543475f, 
    -0.12248530f, 0.00937707f, -0.23503831f, -0.12072879f, 0.22346611f, -0.17586718f, -0.05641893f, -0.10092744f, 
    -0.05461444f, 0.12350535f, -0.11296255f, -0.08869205f, -0.06198717f, 0.03253283f, -0.03228426f, -0.04136351f, 
    -0.01743351f, 0.01078171f, -0.03466772f, 0.05869225f, 0.20498469f, 0.16696385f, 0.04157389f, -0.01820289f, 
    0.01304604f, 0.08057622f, 0.14796393f, 0.03529365f, 0.02865615f, -0.04034584f, 0.11264893f, 0.07348875f, 
    0.07531513f, 0.12006211f, 0.15393892f, -0.03187734f, 0.03553575f, 0.04774272f, 0.04900001f, -0.03945090f, 
    -0.17211162f, 0.22857745f, -0.01653028f, -0.05287062f, -0.16119933f, -0.08565853f, 0.18743728f, 0.09694629f, 
    -0.01121490f, 0.10870990f, 0.05289224f, 0.05165141f, -0.03068059f, -0.08059173f, -0.09911663f, -0.16947888f, 
    0.15233853f, 0.03407779f, -0.15930925f, -0.02415149f, 0.30738866f, -0.10329139f, -0.08348589f, 0.06504110f, 
    -0.05273208f, -0.12333160f, 0.01442699f, 0.09008505f, 0.08914142f, 0.13446635f, -0.04382007f, 0.01616846f, 
    0.00027902f, -0.00604183f, -0.04335360f, -0.04284119f, 0.26276198f, -0.02915847f, 0.10807310f, 0.01164745f, 
    0.09919209f, -0.08170231f, 0.03462376f, 0.13060281f, -0.06230333f, 0.04264099f, 0.02898300f, 0.04217798f, 
    0.00613430f, -0.03328146f, 0.06523503f, 0.11757287f, 0.02405194f, 0.01349638f, 0.01710968f, -0.09999561f, 
    0.03168716f, -0.06201518f, 0.13130316f, -0.09190580f, 0.08491494f, -0.25701368f, -0.20916015f, -0.09351114f, 
    0.16123469f, 0.04004722f, 0.03985939f, 0.10720275f, 0.08354988f, -0.17534710f, -0.03367794f, -0.03447598f, 
    0.00454750f, 0.03168646f, -0.02186661f, 0.03846077f, 0.05415283f, 0.09961006f, 0.19295354f, -0.04270038f, 
    -0.05537932f, -0.28196368f, -0.13483629f, 0.12128496f, -0.03919381f, 0.10338771f, 0.06849205f, -0.01331929f, 
    -0.09165371f, 0.04022574f, -0.00467485f, 0.06629004f, -0.00596708f, -0.04375618f, -0.02027886f, -0.09060266f, 
    -0.03925663f, 0.06215411f, -0.08068305f, -0.07760739f, 0.20330417f, -0.01362797f, -0.08604122f, -0.20103437f, 
    0.28224626f, -0.07237295f, 0.05711864f, 0.00021288f, 0.13962489f, -0.07875844f, -0.10358923f, -0.06694959f, 
    0.05017868f, 0.03851591f, 0.04445997f, 0.05686318f, 0.11824466f, 0.04285061f, 0.24430063f, -0.06010012f, 
    0.00863186f, 0.08434064f, 0.19007635f, 0.03842444f, -0.10500872f, 0.02427671f, -0.02009517f, 0.05135043f, 
    -0.04974465f, -0.02614682f, 0.04270635f, 0.00651725f, 0.02142264f, -0.10913266f, 0.01502739f, -0.04097053f, 
    0.05803766f, -0.21464655f, -0.17125912f, 0.14225465f, 0.23487841f, 0.32070416f, 0.20955926f, 0.17087322f, 
    -0.16828014f, -0.03465181f, 0.07029594f, -0.04032516f, -0.01201174f, -0.00915281f, 0.06069617f, 0.09453789f, 
    0.01684874f, 0.04961856f, 0.03123706f, 0.12515512f, -0.00216236f, 0.00799241f, -0.09759177f, 0.00750887f, 
    -0.24431363f, -0.47403282f, -0.50241369f, -0.26922509f, 0.07377636f, -0.20482649f, 0.27891156f, -0.02900233f, 
    0.35127300f, 0.01960092f, -0.08545524f, 0.18448466f, 0.00197295f, 0.21982457f, -0.06981006f, -0.08355194f, 
    0.03862569f, 0.06820683f, 0.03204645f, -0.12509863f, -0.02731264f, 0.15324786f, 0.07943780f, 0.09939219f, 
    -0.07558692f, -0.04136818f, 0.09863013f, 0.03821361f, 0.03243886f, 0.03640655f, 0.06337747f, -0.08930340f, 
    -0.01011017f, 0.07451513f, 0.05231413f, -0.14973003f, 0.19290492f, -0.00509911f, -0.02784109f, 0.00268940f, 
    0.03795873f, 0.26879850f, 0.25472859f, 0.03457303f, -0.07135189f, 0.00821100f, 0.09380690f, 0.02627628f, 
    0.06817771f, -0.00659568f, 0.07664514f, 0.07079849f, 0.06596751f, 0.09511250f, 0.04961699f, 0.06240578f, 
    -0.00194034f, -0.03660618f, -0.12090950f, 0.02397700f, 0.07757350f, 0.32190964f, 0.19222109f, -0.03416348f, 
    -0.24393043f, 0.01694636f, 0.08871254f, 0.07606018f, -0.01148826f, 0.06515780f, 0.18097517f, 0.05251324f, 
    0.10601442f, 0.09305138f, 0.08691111f, -0.04261157f, -0.01496984f, -0.16173626f, -0.00885196f, 0.06517408f, 
    -0.01022044f, 0.02970212f, 0.04014060f, 0.02419098f, -0.01000814f, 0.02851950f, -0.01635645f, -0.04290749f, 
    -0.02914824f, -0.03060084f, -0.02825677f, -0.01165497f, -0.00263907f, -0.03663335f, 0.00331134f, -0.04388874f, 
    -0.02563644f, 0.01102997f, -0.02394916f, -0.04184239f, 0.00309990f, 0.01493991f, -0.01070771f, -0.03060990f, 
    0.01844072f, -0.02744057f, -0.00699332f, 0.00126292f, 0.01783348f, -0.02480008f, 0.02271425f, 0.01293963f, 
    0.02427017f, 0.00749965f, -0.04055768f, -0.03715051f, 0.03676752f, -0.02063564f, -0.00406885f, 0.00339641f, 
    -0.00855760f, 0.00055283f, -0.04079558f, -0.04446149f, 0.02010691f, 0.00562712f, -0.02895792f, -0.02899124f, 
    -0.00784738f, 0.02634820f, -0.03497572f, 0.02640839f, -0.02439867f, -0.04253717f, 0.01462949f, -0.02972384f, 
    -0.03904852f, -0.02057201f, 0.02743166f, 0.02132699f, 0.03287658f, -0.01930161f, 0.01925737f, -0.00007658f, 
    0.03033088f, -0.02336616f, 0.00993910f, -0.02149759f, -0.02687589f, -0.03520232f, -0.04233462f, 0.02050964f, 
    -0.01219582f, 0.02801052f, -0.00021473f, -0.00446531f, 0.00135323f, -0.03035674f, -0.00851325f, 0.01529454f, 
    -0.00497644f, -0.01521310f, -0.01140095f, -0.04304308f, 0.00756420f, -0.00179257f, -0.01942952f, -0.00049997f, 
    -0.02832473f, 0.02762373f, 0.02751011f, -0.01617233f, 0.02594657f, -0.04147384f, 0.01608490f, 0.02905274f, 
    0.02023307f, 0.02749825f, 0.03190450f, 0.01555659f, -0.03953164f, -0.01126023f, 0.02161745f, -0.02643208f, 
    -0.04132843f, -0.02745727f, -0.03079892f, 0.02567769f, 0.01195961f, 0.02990898f, -0.00693645f, 0.00111185f, 
    -0.03327087f, -0.01638221f, 0.00866775f, -0.01299043f, -0.00773018f, 0.00886609f, 0.02251832f, 0.01496146f, 
    -0.02280254f, 0.03428695f, 0.02820742f, -0.02764090f, 0.01989853f, 0.02171097f, -0.01046154f, 0.03352818f, 
    -0.04766368f, -0.04743978f, 0.00249332f, -0.02119947f, -0.00448356f, -0.03030567f, -0.03252741f, -0.02130418f, 
    -0.03741030f, 0.01684002f, 0.01578409f, -0.03273112f, 0.00554052f, 0.02023299f, 0.02382033f, -0.00976431f, 
    0.01457992f, 0.02951699f, 0.02029215f, -0.00462571f, -0.03439925f, 0.02223335f, -0.03396692f, 0.02534530f, 
    0.02335357f, 0.01856686f, 0.00032308f, -0.02212144f, -0.04450658f, 0.01987921f, -0.02343685f, -0.03384247f, 
    -0.00213784f, -0.01919489f, -0.00711265f, 0.01339428f, 0.00713032f, 0.00086729f, -0.02966737f, -0.01065209f, 
    -0.01642887f, -0.01625082f, -0.04048868f, 0.01474242f, 0.02079486f, 0.01189418f, -0.01542819f, -0.03424934f, 
    0.00481748f, 0.02897052f, 0.00392335f, -0.03245899f, -0.02266410f, 0.03337068f, 0.02909864f, 0.01704894f, 
    -0.00913301f, -0.02587117f, 0.03035282f, 0.00081100f, -0.01672395f, -0.02152934f, -0.03647927f, 0.02083817f, 
    -0.03507847f, -0.00558656f, 0.00709165f, -0.01561594f, 0.01275068f, 0.03393719f, -0.01092391f, 0.03613409f, 
    -0.03427400f, -0.01269079f, -0.03221501f, -0.00523907f, 0.00635771f, 0.01611755f, -0.01278248f, 0.01790901f, 
    0.00089372f, -0.04201999f, -0.04347857f, 0.03358175f, 0.01808228f, -0.04141512f, 0.01016808f, 0.01072168f, 
    -0.01434528f, 0.01660031f, 0.02193320f, -0.01674339f, 0.02226450f, 0.02476205f, -0.03512843f, -0.00563435f, 
    -0.02724587f, -0.00140272f, -0.01473626f, -0.03531169f, -0.02631057f, -0.02182022f, -0.03313977f, -0.01590240f, 
    0.02985149f, 0.00123119f, -0.03412931f, 0.00205853f, -0.03260928f, -0.01888306f, 0.01367313f, -0.03372958f, 
    -0.02980258f, 0.02842461f, -0.01774884f, 0.02952226f, 0.02448501f, -0.01876159f, -0.02295393f, -0.03960587f, 
    0.03174945f, -0.04226172f, 0.03091749f, -0.01464253f, 0.02052287f, -0.00316372f, -0.03025797f, 0.02777226f, 
    -0.00120692f, -0.00684262f, -0.00965500f, -0.03597305f, 0.00696702f, 0.04506634f, 0.00103356f, 0.00746188f, 
    0.00210789f, -0.00812430f, -0.02579482f, -0.03588764f, 0.02064910f, 0.03381265f, 0.02912561f, 0.01186256f, 
    0.03353183f, 0.03008534f, 0.00975253f, 0.02880169f, 0.02476474f, 0.00120033f, -0.04395255f, 0.02507479f, 
    -0.03534827f, -0.02187381f, -0.02501982f, -0.03914160f, -0.01759034f, -0.03197340f, -0.00053866f, 0.02317774f, 
    0.01364244f, 0.01593401f, -0.01425301f, -0.02306569f, 0.01020156f, 0.03035952f, -0.01864335f, 0.01734668f, 
    0.00815426f, -0.02968665f, 0.01106280f, -0.03093810f, -0.01212295f, 0.01557556f, 0.03188205f, -0.01104091f, 
    0.02745958f, -0.01675673f, 0.03310831f, 0.02442778f, -0.03547294f, 0.01970422f, 0.02457349f, 0.01228807f, 
    -0.03244846f, 0.01564663f, -0.03974966f, 0.04296937f, 0.00519809f, -0.02045162f, 0.01424838f, 0.02139724f, 
    0.02014598f, 0.00070677f, 0.01903363f, -0.03686328f, -0.04489879f, -0.02500556f, 0.01342315f, 0.02428333f, 
    0.02243241f, 0.02983645f, 0.01322434f, -0.03030006f, 0.03039641f, 0.02553759f, -0.03859686f, -0.03164027f, 
    -0.00907897f, -0.00372155f, 0.02670222f, 0.01914781f, -0.01311156f, -0.02824106f, 0.00358891f, -0.00809483f, 
    -0.01264490f, 0.01480103f, 0.00628693f, 0.01061362f, -0.00375625f, -0.04041939f, -0.01090596f, 0.02107917f, 
    0.01307402f, 0.01150184f, 0.00901711f, 0.02879464f, 0.02593987f, -0.01576877f, -0.03437063f, -0.02431980f, 
    0.04457466f, -0.01951326f, -0.02114894f, -0.01289247f, 0.02863484f, -0.00169261f, -0.01666738f, -0.00989064f, 
    -0.04493613f, 0.00629221f, -0.02187788f, 0.02830139f, -0.01443734f, -0.00096649f, -0.00759316f, -0.02098041f, 
    -0.03467342f, 0.01971274f, -0.03629552f, -0.02320265f, -0.01941553f, 0.01358229f, -0.03732045f, 0.00588460f, 
    -0.00864984f, -0.02589141f, 0.02353220f, 0.02192914f, -0.00312785f, -0.02197875f, -0.04223507f, -0.02073050f, 
    -0.00997665f, 0.00249507f, -0.03229844f, -0.02358564f, -0.00631703f, -0.02978123f, 0.01479255f, -0.04361096f, 
    0.02296815f, 0.02488882f, 0.02047505f, 0.03222305f, -0.00604736f, -0.01596916f, 0.02354553f, -0.02840763f, 
    -0.03446078f, 0.04428748f, -0.03944462f, -0.00771340f, -0.02066768f, -0.02634291f, 0.00406850f, 0.02912345f, 
    -0.02483322f, -0.00343569f, -0.01226969f, -0.01565571f, -0.04156106f, 0.00146605f, 0.01308264f, 0.02241658f, 
    -0.03083050f, 0.01745305f, 0.01671369f, 0.00605253f, 0.03385761f, 0.02002115f, 0.02738034f, -0.01339867f, 
    -0.02029662f, -0.00873281f, -0.01695219f, -0.03942765f, 0.02142261f, -0.01037131f, -0.03387581f, -0.02003540f, 
    -0.02497512f, 0.00053083f, 0.02541687f, -0.02066961f, 0.00150978f, 0.02035712f, 0.01409916f, -0.02008406f, 
    0.03009081f, 0.03476321f, 0.03058611f, -0.00321752f, 0.03079666f, -0.03415648f, 0.01416994f, -0.01518536f, 
    -0.02892695f, -0.02137102f, -0.00492268f, -0.02120750f, 0.01446179f, -0.01344134f, -0.03904284f, -0.00635849f, 
    -0.01980098f, -0.03355806f, -0.02411471f, 0.00978862f, -0.02381983f, -0.03211601f, -0.04222469f, 0.02198629f, 
    0.01479175f, 0.01268318f, 0.02391749f, -0.00030186f, 0.01850998f, 0.03073898f, -0.03695114f, -0.01453518f, 
    0.02932652f, 0.01654897f, -0.04557680f, -0.02775031f, -0.02005328f, -0.01129328f, 0.00860760f, 0.02657239f, 
    -0.04399434f, -0.04331023f, -0.01868080f, -0.00205225f, 0.00032131f, 0.00148737f, -0.00500942f, -0.00057801f, 
    0.01734029f, 0.03436045f, -0.02142785f, -0.02958054f, 0.01044489f, -0.03922082f, 0.02420131f, -0.01078212f, 
    -0.00799272f, -0.00667612f, -0.01972496f, 0.01080631f, -0.00683781f, 0.03475359f, -0.03165288f, 0.01150677f, 
    -0.01999290f, -0.00244385f, -0.00007769f, -0.02664327f, -0.00508589f, 0.00933833f, -0.00288970f, 0.00561701f, 
    0.03426545f, 0.01167811f, 0.02591625f, 0.01712628f, -0.00555958f, -0.00097617f, -0.00702092f, 0.01168787f, 
    0.01523509f, 0.02271300f, 0.02942670f, -0.03055707f, 0.01194113f, 0.02305211f, -0.00994747f, 0.00230028f, 
    -0.03458732f, 0.02896766f, -0.00435916f, 0.01480018f, -0.03306870f, -0.01326645f, -0.04009091f, 0.00958139f, 
    0.02324959f, 0.02536992f, -0.02826848f, -0.03003322f, 0.01199907f, 0.02047861f, -0.03580762f, 0.01261873f, 
    -0.02667332f, 0.02455276f, -0.02232071f, 0.01001188f, -0.01273404f, 0.02657943f, 0.00391214f, 0.03025507f, 
    0.02229792f, -0.03006104f, 0.01995252f, -0.01557922f, -0.03565554f, 0.00978390f, 0.01249063f, 0.04178092f, 
    -0.04259484f, 0.00616189f, -0.00028850f, 0.03043416f, -0.03925001f, 0.01483291f, 0.00219711f, 0.02843574f, 
    -0.02374274f, 0.04255902f, 0.03052242f, 0.02454743f, 0.04295601f, -0.01505901f, -0.01227811f, -0.03330735f, 
    -0.04133414f, -0.02227356f, -0.03478823f, -0.02652067f, 0.00717750f, -0.03183250f, -0.02765862f, -0.01451261f, 
    -0.04189114f, 0.02441099f, -0.03486977f, -0.04068957f, 0.02197325f, -0.02617326f, 0.01616274f, 0.03216306f, 
    0.02292897f, -0.04428802f, -0.01407501f, -0.04450560f, 0.02829406f, 0.04055547f, 0.03216984f, -0.03995337f, 
    -0.00841554f, 0.00069550f, 0.00162468f, -0.01547123f, -0.01805265f, -0.04129764f, -0.03470258f, -0.03130012f, 
    0.01210056f, 0.02732342f, 0.01679331f, -0.00490834f, 0.00995726f, -0.03971957f, -0.02261547f, -0.00816885f, 
    -0.01549865f, -0.00960888f, -0.01111501f, -0.01056231f, -0.01027065f, -0.03431895f, 0.00217722f, 0.01857386f, 
    -0.03090148f, 0.02554771f, 0.02205939f, 0.02520218f, -0.03362516f, 0.00532549f, 0.00664561f, 0.02807157f, 
    -0.00941976f, 0.01559882f, -0.01006040f, 0.00616989f, 0.01564036f, 0.02287192f, 0.01935778f, 0.02329598f, 
    -0.02564583f, -0.02954578f, -0.01605707f, -0.02546614f, -0.00636203f, 0.00219458f, 0.00258556f, -0.02803885f, 
    -0.02675967f, -0.04391552f, -0.01852746f, -0.01489704f, 0.01675538f, 0.01271503f, 0.00249326f, 0.00868542f, 
    0.00989551f, -0.00976178f, 0.03331544f, 0.01069845f, -0.02070119f, -0.01903346f, -0.01254808f, 0.03505163f, 
    -0.00475505f, -0.03671240f, -0.03786609f, -0.01264562f, -0.00096769f, -0.02088906f, -0.01794933f, 0.00987996f, 
    0.01414915f, -0.04304999f, 0.01958448f, -0.02356178f, 0.02475343f, -0.00214435f, 0.02083486f, -0.02534688f, 
    0.00261428f, 0.02004961f, 0.00835765f, -0.01193388f, 0.02825582f, -0.02700322f, 0.02708460f, -0.03054671f, 
    0.00875113f, 0.01162965f, 0.03232421f, 0.02683594f, -0.00496972f, -0.03829644f, -0.01196325f, 0.02275185f, 
    -0.01459606f, 0.00712647f, -0.01066835f, -0.02676382f, 0.00741009f, -0.02904571f, -0.04186552f, -0.01403633f, 
    0.02514298f, -0.03961535f, -0.04250687f, -0.03260838f, -0.02731129f, -0.03061907f, 0.02854235f, 0.00637689f, 
    -0.02370728f, -0.03765419f, -0.01719598f, 0.02495439f, 0.02289309f, 0.02906390f, 0.03269347f, -0.03432731f, 
    -0.02475750f, 0.00309237f, -0.00174832f, -0.03731367f, -0.00238961f, -0.04312778f, 0.02459017f, -0.00216643f, 
    -0.02835234f, -0.03560700f, -0.02268180f, 0.02244117f, -0.00651460f, 0.01863542f, 0.01046949f, -0.01639519f, 
    -0.01545766f, 0.01831198f, -0.00215714f, 0.00804153f, 0.00936836f, 0.01985960f, -0.01305265f, 0.01733420f, 
    0.01323027f, 0.02322039f, 0.00001431f, -0.03652268f, 0.01008837f, -0.03523377f, 0.00920665f, -0.04067254f, 
    0.00353692f, -0.02658993f, -0.03295672f, -0.00186582f, 0.00712357f, 0.01884551f, 0.01649903f, 0.02253020f, 
    -0.02136889f, -0.03624119f, 0.03293090f, -0.02748906f, 0.01292615f, -0.00054936f, -0.03194811f, 0.00720600f, 
    -0.03250664f, 0.02070596f, 0.00175512f, -0.02667181f, -0.03737774f, -0.03606252f, -0.03373276f, 0.00651577f, 
    -0.01836855f, 0.02303834f, 0.01906643f, 0.01342640f, -0.02671800f, 0.00159725f, -0.02191948f, -0.00122783f, 
    -0.03621956f, 0.02529069f, -0.03104928f, 0.03299189f, -0.04033483f, 0.03278221f, -0.03024041f, 0.00670348f, 
    -0.00376933f, 0.02307759f, -0.01813002f, 0.00662699f, 0.02430156f, 0.00446379f, -0.00975070f, 0.01941544f, 
    -0.01813451f, 0.03101106f, -0.03722081f, -0.01172968f, 0.00609643f, -0.00830064f, 0.00062596f, 0.01033041f, 
    0.01138870f, -0.02095992f, -0.00411075f, -0.04426219f, 0.02703153f, -0.03162976f, -0.01995456f, -0.02783090f, 
    -0.03360417f, -0.00318609f, 0.01877721f, -0.04365837f, -0.04035682f, -0.02281807f, -0.01679386f, -0.02678652f, 
    0.03250856f, 0.00359820f, 0.00804296f, -0.02881194f, -0.01094110f, 0.02752445f, 0.01036885f, 0.02723515f, 
    -0.03425932f, -0.03445397f, 0.00023742f, -0.03937536f, -0.00836120f, 0.01122659f, -0.04186163f, -0.02538208f, 
    0.02072561f, 0.01672512f, -0.03791504f, -0.00147845f, 0.02871183f, -0.00286116f, 0.00454905f, -0.00341806f, 
    -0.01422970f, -0.04092623f, 0.02623576f, -0.02502858f, 0.00173079f, -0.02966447f, 0.00314954f, -0.00270172f, 
    0.02803214f, -0.00245989f, -0.00199648f, -0.02458698f, -0.03332834f, -0.00365559f, 0.00635554f, -0.04201642f, 
    -0.02781513f, 0.01603254f, 0.00750738f, 0.00017292f, 0.02936736f, -0.02065421f, -0.02967443f, -0.02950020f, 
    -0.04050596f, 0.00686026f, -0.03906561f, -0.01714651f, 0.02744498f, 0.02698865f, -0.00996274f, -0.02030585f, 
    -0.01678783f, -0.02835003f, -0.01555592f, 0.01482188f, -0.01719248f, 0.01740408f, -0.01796211f, -0.00527186f, 
    -0.02538965f, -0.02917000f, 0.02591441f, 0.02823394f, 0.03353436f, 0.00766293f, 0.01881274f, 0.01557419f, 
    0.02938775f, -0.04183029f, 0.03208647f, -0.02955394f, 0.01467976f, -0.01062893f, -0.02292132f, -0.01886233f, 
    -0.01527441f, 0.01781336f, 0.01233090f, -0.03225519f, -0.02180889f, 0.03153279f, -0.01474487f, -0.04151389f, 
    -0.01837161f, 0.01993466f, 0.00503662f, -0.01959879f, -0.00536979f, -0.02222924f, 0.01741825f, 0.00404086f, 
    -0.01482127f, 0.03053762f, -0.00508449f, -0.02584763f, 0.00743452f, -0.03672216f, 0.02763226f, 0.03052762f, 
    -0.01933090f, -0.01301568f, -0.00914609f, -0.01695679f, -0.00383490f, -0.00667430f, 0.00660523f, -0.00521537f, 
    -0.00569968f, 0.01113260f, -0.00284749f, 0.01586904f, 0.02906438f, -0.03002699f, -0.04306063f, 0.01253033f, 
    -0.03055918f, -0.00956443f, 0.00924572f, 0.01283143f, -0.00581561f, 0.03864342f, 0.03661226f, 0.01780108f, 
    -0.01199242f, -0.00617744f, 0.02288920f, 0.00744516f, 0.01248524f, -0.03353058f, -0.00132448f, -0.01463786f, 
    0.03062505f, 0.00044369f, 0.02593089f, -0.01848510f, 0.00132457f, -0.02388373f, 0.01608346f, -0.02215345f, 
    -0.01623421f, 0.01683093f, -0.03074837f, -0.02980706f, 0.02278502f, 0.01804426f, -0.02478893f, -0.02714018f, 
    -0.02679133f, -0.02285790f, 0.00187498f, 0.02845242f, -0.03318484f, -0.02552761f, 0.00690155f, -0.01233636f, 
    0.03227797f, 0.02877522f, -0.01279630f, -0.04064319f, -0.02368226f, -0.01178356f, 0.00882919f, 0.01927854f, 
    0.00864650f, -0.02088248f, 0.00367918f, 0.02784477f, 0.02558515f, 0.00448988f, -0.00328538f, 0.02822434f, 
    -0.03411071f, -0.01182489f, -0.03555457f, -0.04487971f, -0.00785106f, -0.04178024f, -0.02854028f, -0.03686273f, 
    -0.00286107f, 0.01554588f, -0.01330489f, 0.02405455f, -0.02473393f, -0.04047222f, 0.03422441f, -0.04403422f, 
    -0.03149184f, 0.00253334f, -0.01391773f, -0.00149248f, -0.03452131f, 0.03036489f, -0.04039585f, -0.01679155f, 
    -0.04467452f, 0.01649320f, -0.00348879f, -0.03879549f, 0.01663357f, 0.00057820f, -0.00512819f, -0.02717662f, 
    0.00716313f, -0.02081099f, -0.01836521f, -0.02118989f, 0.00021786f, 0.03279999f, -0.02394039f, 0.01431110f, 
    0.00599026f, 0.03486695f, 0.03218020f, 0.00016590f, 0.01531765f, -0.01723338f, -0.03054998f, -0.03948778f, 
    -0.02850962f, -0.01908110f, -0.02311679f, -0.00945324f, 0.02335765f, -0.01999599f, -0.00839629f, -0.01430309f, 
    -0.04506285f, -0.00360595f, -0.01013924f, 0.02873057f, 0.02914479f, -0.03629182f, -0.03027182f, -0.02920756f, 
    -0.04092301f, 0.03282490f, -0.04214395f, -0.00412406f, -0.02698494f, 0.00344815f, -0.01151435f, -0.01314973f, 
    0.02445250f, -0.01734940f, 0.00236517f, 0.03149032f, -0.00392126f, 0.00977394f, 0.02453525f, -0.03750012f, 
    -0.03826163f, -0.01306458f, -0.03446154f, -0.01347605f, 0.01830265f, 0.01202649f, 0.01912743f, 0.02150857f, 
    -0.03994676f, -0.03631176f, 0.02637079f, -0.02155303f, 0.01352399f, 0.00012492f, -0.03110646f, -0.01273774f, 
    0.00156746f, -0.04436458f, -0.03168437f, 0.00308516f, -0.03036350f, -0.02560677f, -0.03215991f, -0.01085457f, 
    0.00115413f, -0.04380967f, -0.00488219f, 0.02523250f, 0.00129107f, 0.01045049f, -0.00166456f, -0.04063726f, 
    -0.02280739f, -0.03040484f, 0.03104539f, 0.02146365f, 0.01643919f, 0.00677872f, -0.00705727f, -0.02029010f, 
    -0.03441092f, -0.03864316f, 0.02916660f, 0.00688579f, -0.02216981f, -0.03336874f, -0.01184994f, -0.00593105f, 
    0.02835732f, 0.00755801f, 0.02812974f, -0.03833536f, 0.00830464f, 0.02998586f, -0.00981776f, -0.00657797f, 
    0.01387716f, -0.00745564f, -0.00439317f, 0.00910046f, -0.01797934f, 0.03013841f, 0.02952730f, 0.03450900f, 
    0.01010168f, 0.02033056f, -0.03299748f, -0.02115821f, 0.01341329f, 0.01671073f, 0.02335425f, -0.04285121f, 
    0.00104231f, 0.02664959f, -0.04242690f, -0.01648773f, -0.04362854f, -0.02720860f, 0.02450268f, -0.04193956f, 
    -0.00412567f, 0.02934796f, 0.01291790f, -0.02725398f, -0.01886960f, 0.02796636f, -0.01762790f, -0.00186078f, 
    -0.02706270f, -0.02004011f, -0.00103699f, 0.01803525f, 0.02929496f, -0.03330890f, 0.01501618f, 0.02943821f, 
    0.02410015f, 0.02397812f, -0.02992546f, 0.01354242f, -0.03582952f, -0.04384255f, -0.04007474f, -0.04298913f, 
    -0.04360866f, 0.03438983f, 0.00768567f, -0.04226231f, -0.04445368f, -0.04178775f, -0.00283497f, 0.01894959f, 
    -0.02243841f, 0.03929739f, -0.01250454f, -0.01276711f, 0.00955371f, 0.01030813f, 0.03226311f, 0.02765570f, 
    0.03487696f, 0.00971248f, -0.00937627f, -0.01899415f, 0.03300091f, -0.01067046f, -0.02273980f, 0.00409906f, 
    0.02250904f, -0.03494009f, -0.01857234f, -0.02853330f, -0.01634603f, 0.00324653f, -0.01723524f, 0.00087985f, 
    -0.02897454f, -0.00694484f, 0.01688159f, -0.01374625f, 0.03816553f, -0.02136682f, -0.02757628f, 0.00094595f, 
    -0.03215812f, 0.00748867f, -0.01981626f, 0.01585344f, -0.02490459f, 0.03395378f, 0.03164900f, -0.04348029f, 
    -0.04265842f, 0.00224865f, -0.01004504f, -0.01360998f, -0.03423442f, -0.01718265f, 0.02763036f, 0.01322264f, 
    -0.03747172f, -0.00573831f, -0.03195960f, -0.02258037f, -0.02193588f, 0.00082102f, -0.03924495f, 0.01622627f, 
    0.01614044f, 0.02226740f, -0.03525148f, -0.00046380f, -0.00876254f, 0.00273544f, 0.01648554f, -0.04398806f, 
    -0.02576203f, -0.02303917f, -0.04250476f, -0.01729480f, 0.00791036f, -0.02451733f, -0.00649026f, 0.00886770f, 
    -0.00337847f, -0.04015017f, 0.02088090f, -0.01662284f, -0.00893231f, -0.03524733f, 0.00634882f, -0.00794656f, 
    -0.21474409f, -0.12696835f, 0.07481587f, 0.21623635f, -0.10222945f, 0.13425557f, 0.05016169f, -0.02851138f, 
    0.19188876f, 0.18928245f, -0.01881608f, 0.04689512f, -0.08162723f, -0.10245926f, 0.03571091f, -0.04098958f, 
    -0.03922071f, 0.04184914f, -0.05640433f, 0.05372134f, -0.26742673f, 0.07202327f, 0.46198201f, 0.17458017f, 
    -0.25227830f, -0.02176385f, 0.02068237f, 0.12557493f, 0.20217453f, -0.20179331f, -0.07626704f, 0.04262745f, 
    0.03355697f, -0.00207153f, 0.09624514f, -0.06897487f, -0.16963260f, 0.04424261f, -0.11985334f, -0.05646853f, 
    0.38630697f, 0.11005564f, -0.17498995f, 0.26724496f, -0.12858245f, -0.11684752f, -0.03091446f, -0.07392015f, 
    -0.06035653f, 0.01815153f, 0.09663404f, -0.01571213f, 0.06011185f, -0.10787976f, -0.11926720f, -0.05012974f, 
    0.14869475f, -0.02716776f, 0.17148945f, 0.13982351f, -0.11607423f, 0.38914090f, 0.14338079f, 0.34381780f, 
    0.13267754f, 0.06409897f, 0.14318943f, 0.05294179f, 0.03043976f, -0.06204970f, 0.10093863f, 0.02240484f, 
    0.01873359f, 0.10570509f, 0.00692318f, 0.04686967f, 0.08359370f, -0.05245353f, -0.09021533f, 0.13535497f, 
    0.09002554f, -0.21518117f, -0.03536040f, -0.06248387f, 0.02707306f, -0.04368374f, -0.12138582f, -0.05705153f, 
    -0.16553290f, 0.02444516f, -0.09719236f, 0.03179404f, -0.00543232f, 0.17540050f, 0.12891580f, 0.06406869f, 
    -0.03626989f, 0.04404867f, -0.07743961f, -0.06871095f, 0.41180399f, -0.10017084f, 0.01569340f, -0.00259819f, 
    -0.10739709f, -0.04673637f, -0.10456700f, -0.15835984f, -0.02009884f, 0.00474975f, 0.13152167f, 0.05767030f, 
    -0.14611794f, -0.03440222f, 0.03132786f, 0.02079169f, -0.02364397f, 0.11322828f, 0.06901622f, -0.08586605f, 
    -0.05884506f, 0.24109939f, 0.15800558f, -0.03276342f, -0.21430536f, 0.27124530f, 0.05658840f, -0.06457844f, 
    0.01222477f, -0.05255543f, -0.03357746f, 0.05644409f, 0.01631312f, 0.07712749f, 0.05996080f, 0.02258443f, 
    -0.00115068f, -0.20532133f, -0.08193494f, 0.04583057f, 0.08722898f, 0.09444136f, -0.12247381f, -0.15561746f, 
    -0.08723007f, -0.11282629f, 0.14579685f, -0.14996956f, 0.11610968f, 0.20442384f, -0.04955423f, -0.01754511f, 
    -0.01375114f, -0.02250776f, 0.03626732f, 0.07450621f, -0.12960488f, -0.05967325f, 0.18362480f, -0.00706438f, 
    0.00000882f, 0.25333524f, 0.30573809f, 0.22612739f, 0.09024828f, 0.04527633f, 0.20579928f, -0.05906155f, 
    0.09209475f, 0.03782000f, -0.00348995f, 0.02368403f, 0.03003686f, 0.04558697f, -0.00406233f, -0.00592050f, 
    0.05586570f, -0.14077491f, -0.03602514f, 0.02761502f, 0.29103503f, 0.01689482f, 0.06160394f, 0.01546522f, 
    0.06096038f, -0.07056609f, 0.02240878f, 0.04474236f, 0.13569796f, -0.03121385f, 0.12383568f, 0.15268026f, 
    0.05592528f, 0.02477856f, 0.09195764f, -0.04422166f, 0.05898861f, 0.03614421f, 0.01134492f, 0.09481623f, 
    0.22035846f, -0.21231534f, 0.28123310f, 0.10621513f, 0.12287935f, -0.05462865f, -0.10471430f, 0.08246558f, 
    0.06497123f, 0.10540488f, 0.07049770f, 0.06320418f, -0.09411787f, -0.08220128f, 0.01160598f, 0.04091969f, 
    -0.01110951f, 0.10428768f, -0.07697227f, -0.03513417f, 0.07868459f, -0.08482175f, 0.42135113f, -0.17982990f, 
    -0.22936425f, 0.17224096f, -0.20692135f, 0.10278669f, -0.15233488f, 0.02561174f, 0.06359199f, -0.14669557f, 
    -0.25413641f, 0.17355859f, -0.02992229f, -0.05632447f, 0.03348576f, 0.16413119f, -0.29540724f, -0.07992206f, 
    0.46098319f, 0.47893867f, 0.00403409f, 0.01066925f, 0.00921660f, 0.03963032f, 0.19398040f, -0.20501259f, 
    0.23191012f, -0.07603051f, 0.06930996f, -0.04753655f, 0.09022551f, -0.13108291f, 0.05900042f, -0.08135844f, 
    0.04499868f, -0.20574792f, 0.17577505f, 0.13339783f, -0.09404074f, 0.25356805f, 0.20139194f, 0.37835854f, 
    0.12203801f, -0.11447632f, 0.07092977f, 0.27451628f, -0.06020222f, -0.10131009f, 0.09907054f, 0.00257605f, 
    0.01060183f, 0.00585799f, -0.02972710f, 0.01529568f, -0.00793901f, 0.01723177f, -0.02367879f, 0.03576543f, 
    -0.57653612f, -0.42807630f, 0.05061923f, -0.14786367f, 0.05797850f, -0.04634159f, -0.08632886f, 0.03476188f, 
    -0.00316781f, 0.21605186f, -0.03497126f, -0.04632378f, 0.05454058f, 0.05756595f, 0.06071833f, 0.12164476f, 
    -0.02659625f, 0.13850997f, 0.02049975f, 0.07908508f, -0.20256512f, 0.21159025f, 0.29716238f, 0.31497964f, 
    -0.03759255f, 0.02039680f, 0.11909225f, -0.00324321f, -0.06377431f, -0.14470860f, -0.02754620f, -0.00387094f, 
    -0.05956670f, -0.06221715f, 0.06109057f, 0.10240840f, 0.03670545f, -0.06048680f, -0.12578523f, -0.00238084f, 
    0.16366346f, 0.39003360f, 0.16940026f, 0.37308371f, 0.03561553f, -0.28275198f, 0.13791415f, -0.03468784f, 
    0.17918500f, 0.01372822f, -0.00305404f, 0.02340551f, 0.05436660f, -0.01523188f, -0.04425455f, 0.01367470f, 
    -0.01634428f, -0.05970035f, -0.06701887f, 0.01031448f, -0.32488069f, -0.47598386f, -0.17095780f, -0.18759887f, 
    -0.14463702f, -0.20253129f, -0.03825615f, -0.05264903f, -0.20299765f, 0.17312482f, -0.06556898f, -0.00893086f, 
    0.00191678f, 0.02616463f, 0.01051657f, 0.00801894f, -0.03484123f, -0.03374639f, -0.04863271f, 0.06092283f, 
    -0.07290734f, 0.36084989f, 0.30534953f, 0.30023032f, 0.10515819f, -0.05146445f, 0.09704842f, -0.02112382f, 
    0.09800407f, -0.11553194f, 0.01364847f, -0.00020404f, 0.08215509f, 0.05534916f, 0.02998696f, -0.01465242f, 
    0.00422461f, -0.16965353f, -0.03386918f, 0.08092517f, -0.41338098f, -0.27903321f, 0.04713721f, -0.02731979f, 
    0.08215384f, -0.04834291f, -0.13986123f, -0.01768652f, -0.11481867f, 0.10622232f, -0.09063720f, -0.05225799f, 
    0.01622149f, 0.05064165f, -0.05123671f, 0.07150587f, -0.09373221f, 0.07806124f, 0.08739694f, 0.09486906f, 
    0.24115592f, -0.04996095f, 0.14896899f, 0.03059429f, 0.00005374f, 0.12228376f, -0.20577581f, -0.10623571f, 
    0.02024897f, 0.04371595f, -0.00626478f, -0.05465900f, 0.16238739f, -0.18196264f, -0.09468659f, 0.11563159f, 
    0.00727586f, -0.17486627f, 0.04708475f, -0.03194436f, -0.19306186f, -0.02671580f, -0.17518567f, 0.03847395f, 
    -0.12324047f, 0.22992443f, -0.10345644f, -0.06847315f, 0.10615256f, 0.14836739f, -0.08703018f, 0.00202442f, 
    -0.13586193f, -0.00380546f, 0.02399435f, 0.12428010f, -0.05500708f, 0.02504647f, -0.08530102f, 0.04279678f, 
    -0.39581120f, -0.02309107f, -0.11706709f, -0.07283710f, 0.06463059f, -0.00910904f, -0.02525588f, -0.04171482f, 
    -0.04709150f, 0.13497050f, -0.11712107f, -0.06024633f, -0.00431204f, 0.17826784f, 0.01041203f, 0.00895537f, 
    -0.08144233f, -0.00641610f, 0.06492446f, -0.01591145f, -0.07037716f, 0.32990652f, 0.24067372f, 0.02484913f, 
    -0.16708021f, 0.12403590f, 0.24853693f, -0.04497166f, 0.12277069f, 0.15506256f, -0.01522859f, -0.03195604f, 
    0.05236203f, 0.00016451f, -0.02178153f, 0.06187228f, -0.01711329f, -0.16158703f, -0.14800128f, 0.12245216f, 
    -0.19371544f, 0.08431832f, 0.06153510f, 0.11324806f, -0.06872993f, 0.15257083f, 0.04238750f, 0.04971780f, 
    0.12814808f, 0.10309022f, -0.02239649f, 0.02702560f, 0.00558541f, 0.04478934f, -0.00074750f, -0.02557633f, 
    0.07202113f, -0.06910434f, -0.00659400f, 0.01136903f, -0.35247919f, 0.05250575f, 0.27254623f, 0.29322088f, 
    0.01258909f, -0.06010766f, 0.08909630f, 0.04000841f, -0.13240263f, 0.01689216f, 0.03394671f, 0.00172675f, 
    -0.05354656f, -0.05605398f, -0.01233634f, 0.15164973f, 0.03716140f, 0.06644232f, 0.07464051f, 0.17406861f, 
    0.16893049f, 0.03321443f, -0.14788829f, 0.20459244f, 0.14586172f, 0.00796223f, -0.02013815f, -0.11469185f, 
    -0.06104579f, -0.07227258f, -0.02910901f, 0.03432861f, 0.09174363f, -0.00451617f, 0.09485371f, -0.12596509f, 
    -0.12678517f, 0.00810199f, 0.19145805f, -0.00191546f, 0.05639706f, -0.34504080f, -0.21809727f, -0.09745933f, 
    0.06421602f, -0.09505404f, -0.11049363f, -0.08939987f, -0.11573040f, -0.07318310f, 0.11147694f, 0.04032758f, 
    -0.10212212f, -0.03920349f, 0.11145732f, 0.06137143f, 0.03118512f, 0.04226145f, -0.02756990f, 0.10041694f, 
    0.43211532f, 0.16710092f, 0.26876220f, 0.18141977f, -0.14459547f, 0.00371885f, 0.04176911f, -0.01796726f, 
    -0.03422184f, 0.16679984f, 0.12006242f, -0.10476272f, -0.11307839f, -0.10671998f, 0.00120642f, -0.02769675f, 
    0.05845378f, -0.17733459f, -0.04227065f, -0.07684195f, 0.05059541f, -0.03009090f, -0.24484076f, -0.03250210f, 
    -0.04973308f, -0.05764570f, -0.03589717f, -0.10714775f, -0.06884678f, 0.01624148f, -0.02251223f, -0.00305124f, 
    0.06843699f, -0.00138027f, 0.06582575f, 0.01679630f, 0.09963547f, -0.00917923f, 0.16399416f, 0.02408850f, 
    0.19642292f, -0.26238617f, -0.27191025f, -0.11581431f, -0.08962061f, -0.14139155f, -0.08316605f, -0.06971673f, 
    -0.13017736f, 0.00186114f, 0.08997577f, -0.00770423f, -0.01944907f, 0.01291659f, 0.09805144f, 0.11196364f, 
    0.17255686f, -0.03114041f, 0.03841203f, -0.04709771f, 0.21127784f, -0.38109431f, -0.14984374f, -0.07898209f, 
    0.03561839f, -0.05361398f, -0.19371676f, -0.09341583f, -0.03155056f, 0.03909412f, 0.07824874f, 0.01730437f, 
    -0.08603835f, 0.02457959f, 0.04953764f, 0.05493426f, -0.00696465f, 0.09453895f, 0.03494026f, 0.05437033f, 
    0.03132527f, -0.02346512f, -0.04297199f, 0.02111978f, 0.02457515f, -0.03961192f, 0.01260921f, 0.00456828f, 
    -0.02615141f, 0.01517318f, -0.03571166f, 0.01160610f, 0.02278063f, 0.01504010f, 0.01480137f, 0.01603800f, 
    -0.01549543f, -0.02495174f, -0.01226735f, -0.00002395f, 0.00717373f, 0.02624778f, -0.04321317f, 0.02378865f, 
    0.03058925f, 0.03095086f, 0.01479996f, -0.02314495f, -0.04405779f, 0.02424220f, -0.01842416f, 0.01216144f, 
    0.02749081f, 0.02667018f, 0.00917943f, -0.02981608f, 0.00049428f, 0.00480127f, 0.01101984f, 0.02279416f, 
    -0.04109666f, -0.00675044f, 0.00871005f, -0.04191022f, -0.00548411f, 0.00697184f, -0.03108504f, 0.00601194f, 
    -0.03440054f, 0.01803333f, 0.02151971f, 0.01133422f, 0.00270099f, -0.04338547f, 0.01483444f, -0.02447904f, 
    0.01804685f, -0.03334459f, 0.03133230f, -0.04400272f, -0.00800367f, -0.01110444f, 0.00528639f, 0.00988394f, 
    -0.03957862f, -0.01879244f, -0.00978602f, -0.00151928f, 0.01704994f, -0.04096839f, 0.01860787f, 0.00997960f, 
    -0.00177225f, -0.02883700f, -0.00900808f, -0.02930155f, 0.01210336f, -0.00627867f, -0.00382874f, 0.03180839f, 
    0.03066799f, 0.00661067f, 0.01677698f, -0.00222662f, -0.04532970f, 0.01504286f, 0.02300124f, -0.00043486f, 
    -0.03616246f, -0.03780673f, 0.00592117f, -0.01414931f, -0.00627153f, -0.03677577f, -0.01929061f, -0.03190352f, 
    -0.01102542f, -0.02975390f, 0.00230881f, -0.02735147f, -0.04264664f, -0.04416495f, 0.01394838f, -0.01849598f, 
    -0.04400485f, 0.02431331f, 0.00007513f, 0.00738512f, -0.03240660f, -0.04269763f, 0.03305701f, -0.03912796f, 
    -0.01518302f, -0.03700455f, -0.04399462f, -0.02691792f, 0.02491684f, 0.01230686f, 0.00926492f, -0.02258474f, 
    0.03625148f, -0.02688733f, -0.02560280f, -0.03033123f, -0.03342355f, -0.00700604f, -0.04152712f, 0.00899892f, 
    -0.03071873f, -0.01375948f, -0.03004435f, -0.03849771f, -0.01574805f, -0.02296854f, -0.01498985f, -0.02965725f, 
    -0.02222311f, 0.02014768f, -0.03802273f, -0.00202296f, -0.01943449f, 0.01919958f, -0.00264570f, 0.03120953f, 
    0.02922958f, -0.03210082f, -0.01110623f, -0.02133375f, -0.03754763f, 0.00954981f, -0.03145839f, 0.02318634f, 
    0.03055476f, -0.01030402f, 0.02757414f, 0.01580594f, 0.00009251f, 0.02992710f, -0.00822658f, -0.03029366f, 
    -0.03007719f, -0.02556009f, -0.01860147f, -0.00620203f, 0.00553012f, -0.01514449f, -0.01216726f, 0.02918356f, 
    -0.01039253f, -0.03181821f, 0.02095864f, -0.02190179f, -0.00962036f, -0.02611257f, -0.00102450f, -0.00356868f, 
    0.02366593f, -0.02523120f, -0.02348256f, -0.02359990f, -0.04402402f, -0.02672419f, -0.01220787f, -0.03350589f, 
    0.00022445f, 0.01164517f, 0.00096537f, 0.01844787f, -0.03212076f, -0.02455634f, -0.02937545f, -0.02635237f, 
    -0.03298274f, 0.03203129f, 0.01236882f, 0.02779176f, 0.03031020f, -0.02084976f, -0.02789286f, 0.01043089f, 
    -0.03998445f, 0.02275496f, -0.01395120f, -0.02835933f, -0.03763143f, 0.00812762f, -0.00980015f, 0.00030775f, 
    0.01266572f, 0.02455713f, -0.00259034f, -0.02293786f, 0.00849448f, -0.01352459f, -0.04510762f, -0.03358417f, 
    -0.04002505f, -0.00778298f, -0.04242830f, -0.00384318f, 0.00467372f, 0.01593123f, -0.02093147f, -0.00506650f, 
    0.02196345f, -0.00575044f, -0.03789134f, 0.02736844f, 0.02762525f, -0.02719455f, -0.00254091f, -0.02868323f, 
    0.01116493f, -0.04425217f, 0.01043812f, -0.01420825f, -0.00486944f, 0.02145121f, -0.03110079f, -0.02534270f, 
    0.01224487f, -0.03495441f, -0.02178962f, 0.00851347f, 0.00861930f, 0.01455243f, 0.02890838f, -0.04543781f, 
    -0.02394309f, -0.03305673f, -0.00282250f, 0.03226903f, -0.00201835f, 0.02227322f, 0.01876330f, 0.02775451f, 
    0.02556632f, 0.01546312f, -0.00648985f, 0.01968705f, 0.01782982f, 0.03171458f, -0.03311026f, -0.01080169f, 
    -0.02082399f, -0.00917261f, -0.01258522f, -0.00275878f, -0.00084564f, 0.02149647f, -0.02196945f, 0.02497828f, 
    -0.01230776f, -0.00638628f, -0.04302110f, 0.00496585f, 0.01070610f, 0.01983960f, -0.00413071f, 0.02859721f, 
    -0.04287074f, 0.02346146f, -0.03790493f, -0.03540076f, 0.00898650f, -0.00761002f, 0.00639565f, -0.02222109f, 
    -0.02472803f, -0.00959921f, 0.01599095f, -0.03722645f, 0.01141977f, -0.01410940f, 0.00665798f, -0.03183571f, 
    -0.03095016f, 0.01424289f, -0.04363073f, -0.02241003f, 0.01855963f, 0.02876243f, 0.03380211f, -0.01976605f, 
    -0.02596246f, -0.02723031f, -0.03834793f, 0.01499088f, 0.00167586f, -0.03164625f, -0.00816700f, -0.02179156f, 
    -0.02216733f, 0.01547338f, 0.01850301f, -0.02686493f, -0.02545118f, -0.02180172f, -0.01184759f, 0.00351331f, 
    -0.01653401f, -0.00989958f, -0.02187745f, 0.00888004f, 0.00841057f, 0.00209769f, 0.02713943f, -0.03382426f, 
    0.01773002f, -0.02805253f, 0.02624645f, 0.01064962f, -0.04098780f, -0.03719239f, -0.02497701f, 0.01575485f, 
    0.00882707f, -0.03504036f, -0.02806766f, -0.00687289f, -0.01049090f, 0.02339647f, 0.03176717f, 0.00105165f, 
    -0.01590400f, 0.00922802f, 0.01687134f, 0.02130152f, 0.02712465f, 0.00221571f, 0.03152410f, -0.02037965f, 
    -0.00827570f, -0.03069619f, 0.01730900f, -0.02808846f, -0.03636670f, 0.00580829f, -0.00820929f, 0.01934469f, 
    0.03749960f, -0.00891651f, -0.00409646f, -0.02783191f, 0.00209733f, 0.01324674f, 0.00388727f, -0.02303039f, 
    -0.00414978f, 0.02765733f, 0.03290033f, -0.00932600f, 0.01852068f, -0.04280883f, -0.00382443f, -0.02620878f, 
    0.02502399f, 0.01854573f, 0.02839697f, 0.02492289f, -0.02518843f, 0.00887819f, 0.01908036f, 0.00229682f, 
    0.00573461f, -0.03831645f, 0.01033662f, -0.04103578f, 0.02320095f, 0.00817946f, -0.00312159f, -0.02659081f, 
    -0.01123709f, -0.03624781f, 0.01267928f, 0.00610534f, 0.00901438f, -0.00093058f, -0.01025607f, 0.01908880f, 
    0.02610670f, -0.03684824f, -0.03395332f, -0.00176955f, 0.00421341f, -0.00919738f, -0.03118710f, -0.00420761f, 
    0.00132922f, 0.01788888f, -0.04492041f, 0.00654458f, -0.01522915f, -0.03981942f, 0.01985421f, 0.00706583f, 
    -0.01341404f, 0.00496977f, -0.03662190f, -0.04182589f, -0.02134382f, -0.01600634f, 0.00552730f, -0.02050375f, 
    -0.00918704f, 0.03219300f, -0.01559873f, -0.00770149f, 0.02153653f, 0.03986869f, -0.03297366f, 0.02643335f, 
    -0.01805196f, 0.00548052f, -0.01175013f, 0.00510712f, -0.01653671f, -0.01597147f, 0.03210996f, -0.03769701f, 
    0.00785202f, -0.01314518f, -0.01751256f, 0.00393137f, 0.02875243f, -0.02465842f, 0.00537099f, 0.01245957f, 
    -0.03568399f, -0.03367202f, -0.02776601f, 0.01623185f, 0.01490007f, -0.03961666f, -0.00424047f, -0.04027552f, 
    0.01590724f, -0.00280284f, -0.01943675f, 0.01989021f, -0.03972185f, 0.00231953f, 0.00614155f, -0.01815855f, 
    0.02171471f, -0.02017409f, -0.04550470f, 0.02769714f, 0.00313786f, 0.01911250f, 0.02392032f, -0.02927632f, 
    -0.01728197f, -0.02110767f, 0.02517723f, -0.02785097f, -0.03079104f, -0.03044427f, 0.01704154f, 0.01013383f, 
    -0.00061490f, 0.01945334f, -0.00067187f, 0.00214102f, -0.03822127f, 0.00772155f, 0.03197188f, 0.00255217f, 
    -0.02771515f, -0.03012007f, -0.03197471f, -0.00775598f, -0.00807662f, 0.02154511f, -0.03697993f, -0.03331760f, 
    0.02717235f, 0.03162959f, -0.00115065f, -0.02679837f, -0.03626594f, -0.03496459f, -0.00378813f, 0.01337912f, 
    -0.02455445f, 0.03268366f, 0.01224030f, 0.01837372f, -0.01791603f, -0.01563759f, -0.03172875f, -0.00434949f, 
    0.00235034f, -0.04536600f, 0.01085145f, 0.03049398f, -0.02396921f, 0.00096017f, 0.00793695f, -0.04528110f, 
    -0.00125287f, 0.02752068f, 0.00427141f, 0.02250335f, -0.00571489f, 0.00710381f, -0.03917586f, 0.00153099f, 
    -0.03599235f, -0.03430464f, 0.00982534f, -0.03709365f, -0.02153519f, 0.00638813f, -0.00127965f, -0.01979556f, 
    -0.02309701f, -0.03316310f, 0.02804226f, 0.03194159f, -0.01189292f, 0.02595366f, -0.03065919f, -0.02558661f, 
    -0.02018581f, 0.02687662f, 0.01096056f, -0.03668792f, -0.00692059f, 0.01616540f, 0.00370179f, 0.01000865f, 
    -0.03905039f, 0.02222701f, 0.03137868f, 0.00879688f, 0.00704858f, -0.02717286f, 0.01507306f, -0.03015722f, 
    -0.02870418f, -0.01851510f, -0.01677644f, -0.03846199f, -0.04263937f, 0.00961846f, -0.02787140f, -0.01007120f, 
    0.00832963f, 0.02478161f, 0.03241557f, -0.00874121f, -0.03414570f, -0.03992228f, 0.02087609f, -0.01641087f, 
    0.02392060f, -0.01160067f, -0.03646725f, -0.01891761f, -0.01175725f, -0.01177433f, 0.01689325f, 0.02714926f, 
    -0.02692544f, -0.03214031f, 0.00469138f, 0.01886031f, -0.03570749f, -0.01481616f, 0.00101851f, 0.01619121f, 
    -0.03044375f, -0.03538803f, -0.02568767f, 0.01219260f, -0.01801769f, 0.02593963f, -0.02443036f, -0.01488087f, 
    -0.01138848f, -0.03490200f, 0.03277262f, 0.02377523f, -0.00203854f, -0.02748915f, -0.02473901f, 0.00389481f, 
    0.02472996f, -0.00944684f, -0.03743632f, 0.01193399f, 0.00001116f, 0.00094338f, -0.01466514f, -0.00625400f, 
    -0.03854218f, 0.02569489f, -0.02243802f, -0.00875367f, -0.03354993f, 0.02600740f, -0.01036473f, 0.01375133f, 
    0.03101582f, 0.02759072f, -0.03037970f, -0.00971258f, 0.02371920f, -0.03162218f, 0.01514374f, 0.01094522f, 
    0.03085081f, -0.03616470f, 0.00103200f, -0.03159779f, -0.01068490f, 0.01105977f, -0.00936659f, -0.03896152f, 
    -0.02454850f, 0.03329351f, -0.02358965f, 0.01344786f, 0.02547894f, -0.00031821f, -0.02099790f, 0.03242572f, 
    0.01603339f, 0.00383706f, -0.04327899f, -0.00443002f, 0.00364478f, -0.01322385f, -0.02236663f, -0.01727451f, 
    0.01242479f, -0.03339435f, 0.02572902f, -0.02875941f, 0.01033402f, 0.02001937f, -0.02193903f, -0.03047687f, 
    -0.01198763f, 0.03140170f, 0.00330288f, -0.00781300f, 0.00513734f, -0.01431042f, -0.02188180f, 0.02146907f, 
    0.01232481f, -0.03136998f, -0.02324442f, -0.01682754f, -0.02941317f, 0.03146970f, -0.00413745f, 0.02724553f, 
    0.02313416f, -0.02028979f, -0.00136900f, 0.02328660f, 0.01091999f, 0.00237612f, 0.01513592f, -0.04332818f, 
    -0.01193918f, -0.00977482f, -0.00537472f, 0.02830363f, 0.00423402f, -0.01992756f, -0.00803040f, 0.00935499f, 
    0.01447212f, -0.00680367f, -0.02849255f, -0.02502757f, -0.00203815f, -0.00446118f, -0.03309002f, 0.00501049f, 
    -0.00217223f, 0.01360465f, 0.01454878f, 0.03100543f, 0.01498701f, 0.01683262f, 0.00847047f, 0.02894540f, 
    0.01296110f, 0.02791186f, -0.02482212f, 0.02093455f, 0.01358251f, 0.03267014f, -0.01910436f, -0.00105886f, 
    0.01551692f, -0.01391546f, -0.02207136f, -0.00903461f, 0.03851976f, 0.00488664f, -0.03726384f, -0.03913601f, 
    0.03000825f, 0.03471025f, 0.02769845f, 0.02807136f, -0.01583718f, -0.03621881f, 0.03564486f, 0.02051414f, 
    0.00507052f, -0.00807742f, 0.01116587f, 0.00893603f, -0.01011091f, 0.03345744f, -0.01605428f, 0.01254466f, 
    0.02476307f, -0.01834202f, -0.02290416f, -0.01960391f, -0.02502311f, 0.00609259f, -0.00476146f, -0.04204603f, 
    0.00563841f, -0.02908574f, -0.02356225f, -0.00025695f, -0.02801302f, -0.02152880f, 0.01547126f, -0.01607641f, 
    0.02625361f, -0.03630277f, -0.00468046f, -0.04365882f, 0.03468246f, -0.02327241f, -0.04015419f, 0.01604083f, 
    -0.03430242f, 0.03302983f, -0.00616135f, -0.02364592f, -0.01091042f, -0.03397266f, -0.01819898f, -0.00092072f, 
    0.02441421f, -0.01584233f, -0.04491034f, 0.00669928f, 0.03580202f, -0.02545788f, 0.01392762f, -0.04175013f, 
    -0.02950828f, -0.02754489f, 0.01333191f, 0.02926748f, 0.02208189f, 0.02032002f, -0.02355116f, -0.04430747f, 
    -0.01027492f, -0.00832961f, 0.01820279f, -0.00970611f, -0.03810696f, -0.02619658f, 0.01122708f, 0.02248743f, 
    -0.00949894f, -0.03525170f, -0.04206366f, 0.01776108f, -0.03586937f, -0.01881373f, -0.04333910f, -0.03600533f, 
    -0.04384822f, 0.00319445f, 0.00474144f, 0.04118304f, 0.02748251f, 0.02674922f, -0.03858890f, -0.02675723f, 
    0.01185903f, -0.00912931f, 0.02467595f, -0.01125541f, 0.00038941f, 0.01562907f, 0.01590811f, 0.02626590f, 
    0.01146364f, -0.02027602f, -0.00076642f, -0.00718878f, 0.01990512f, 0.01005970f, 0.02219298f, 0.00469704f, 
    -0.03687160f, 0.03083139f, -0.04442216f, 0.01613865f, -0.00999757f, -0.01218001f, -0.01767363f, -0.01331959f, 
    -0.03469138f, -0.02023692f, 0.03162909f, 0.02093893f, -0.00419909f, -0.02555551f, 0.01520692f, 0.00389040f, 
    -0.04016051f, -0.00789972f, 0.01865323f, 0.02361436f, 0.03290581f, -0.00366876f, -0.02905650f, 0.02935669f, 
    0.02864118f, 0.02900513f, 0.02907031f, 0.00231677f, -0.00309855f, -0.01322703f, 0.01436394f, -0.04425889f, 
    -0.04270846f, -0.02885789f, -0.02414683f, -0.00148425f, 0.01560161f, 0.01421335f, -0.04137799f, 0.02428993f, 
    -0.02364584f, 0.00200175f, -0.04492924f, 0.00298496f, -0.03334892f, -0.03792416f, 0.03196121f, -0.00466742f, 
    0.02301310f, -0.01966263f, 0.02278839f, -0.04473110f, -0.02519424f, -0.00105909f, -0.02443534f, -0.00285270f, 
    -0.01689622f, -0.03916957f, 0.02739828f, 0.00961360f, -0.01196071f, -0.01560208f, 0.03333974f, -0.03413107f, 
    -0.03628102f, 0.00310120f, -0.01451313f, -0.01813098f, 0.00995306f, -0.02775244f, 0.01668964f, 0.01676219f, 
    -0.03122175f, -0.00437224f, -0.03871690f, -0.03569457f, -0.03292674f, -0.02415267f, -0.03909639f, 0.02153462f, 
    0.00291843f, -0.01743345f, -0.02126481f, -0.02661776f, -0.03632300f, 0.02470976f, 0.02052359f, 0.02354657f, 
    -0.02050499f, -0.00514158f, -0.00911717f, -0.04146781f, 0.04196239f, -0.02524845f, -0.01112837f, 0.00760047f, 
    -0.03040736f, -0.02832275f, 0.01548087f, -0.01188075f, -0.00559278f, -0.04017397f, -0.00706795f, 0.00240595f, 
    0.02021096f, 0.02403007f, 0.01302271f, -0.02529891f, -0.04433024f, -0.01281685f, 0.03176074f, -0.02608063f, 
    0.03246994f, 0.01019353f, 0.01723880f, -0.03898375f, 0.02062399f, 0.02263088f, -0.00461166f, 0.02927117f, 
    -0.01688348f, 0.00243481f, -0.02462635f, 0.01588998f, -0.03058015f, 0.04434315f, -0.03448831f, 0.01093233f, 
    0.01375389f, -0.00734319f, -0.04512905f, -0.03410427f, 0.02307281f, -0.03426579f, -0.03166644f, 0.02961479f, 
    0.01771565f, 0.00006774f, -0.01699325f, 0.00238911f, 0.02559183f, -0.00729979f, -0.02484256f, -0.03291083f, 
    -0.03892060f, 0.00266906f, -0.00605947f, -0.02583127f, 0.03679589f, 0.01048583f, -0.02908524f, -0.02832354f, 
    0.01720971f, -0.01512837f, 0.02327266f, -0.03025059f, -0.01412223f, -0.00979774f, 0.03101708f, -0.01367800f, 
    0.03244635f, 0.03365486f, 0.04143829f, -0.01076564f, 0.02458347f, 0.00315544f, 0.02777602f, -0.02813905f, 
    -0.02402747f, 0.00815070f, 0.01920436f, 0.02076441f, -0.00662795f, -0.03100077f, -0.00661486f, 0.01103998f, 
    0.01556215f, 0.00088366f, -0.01099878f, 0.03252370f, -0.02293589f, 0.02759273f, 0.01100340f, -0.01486835f, 
    -0.04032245f, 0.03074366f, 0.00489866f, -0.01495016f, 0.01316654f, -0.00279649f, -0.03911585f, 0.00292214f, 
    -0.00180681f, 0.02773711f, 0.01338150f, 0.02336817f, -0.04510734f, 0.01068883f, -0.04175060f, -0.01237362f, 
    0.03456469f, 0.01977507f, -0.01750886f, -0.01127596f, -0.02716890f, -0.00595320f, -0.03791328f, -0.02011750f, 
    -0.03445879f, -0.03027517f, -0.00532203f, -0.00936952f, 0.00321718f, -0.02186511f, 0.00036506f, -0.02566250f, 
    0.04437796f, 0.01989493f, 0.01012106f, -0.02427286f, -0.01046005f, 0.02671058f, 0.02511316f, -0.04452751f, 
    -0.02657492f, -0.01827721f, 0.00541836f, 0.02789293f, -0.03932077f, 0.01226470f, -0.00711867f, -0.01560817f, 
    -0.04247106f, -0.02708781f, 0.03342414f, -0.01519485f, 0.00040547f, -0.02739267f, -0.00979672f, -0.01606546f, 
    -0.03319501f, -0.00593037f, -0.00204537f, 0.01765412f, -0.02790971f, 0.01353957f, -0.00013061f, -0.03774174f, 
    0.03151359f, -0.02446833f, -0.02899767f, -0.02888614f, -0.01399063f, -0.01685352f, 0.03038031f, -0.01416464f, 
    0.00722758f, 0.01581678f, -0.01022882f, 0.02340980f, -0.00551721f, -0.04023589f, -0.01656648f, -0.01124724f, 
    -0.01522694f, -0.00090516f, -0.02195104f, -0.00719822f, -0.00660814f, -0.03321039f, 0.01929110f, -0.00640214f, 
    -0.03109354f, 0.00808358f, 0.02984626f, 0.02342584f, -0.03482793f, 0.00904069f, -0.04482593f, -0.00122424f, 
    -0.02067257f, -0.00533479f, -0.04070348f, -0.03641341f, 0.02701268f, -0.03546066f, 0.01584044f, -0.02915377f, 
    0.00704174f, 0.03969445f, -0.00978287f, 0.01402834f, -0.00346877f, 0.02770379f, -0.01248073f, -0.03189313f, 
    0.00978941f, -0.02753463f, -0.02458432f, -0.03397693f, 0.01727337f, 0.03336584f, -0.02063005f, -0.01217309f, 
    -0.03327604f, 0.02878005f, -0.00438035f, -0.01928926f, 0.03171420f, 0.01519305f, -0.04515558f, -0.03136998f, 
    -0.01472773f, -0.00018546f, 0.02377212f, 0.01891374f, -0.03553871f, 0.00095743f, 0.01373283f, -0.01994284f, 
    0.03687919f, 0.01919724f, 0.03514832f, -0.04400928f, 0.02400531f, -0.01225588f, -0.04319650f, -0.00337588f, 
    -0.01207249f, -0.04185155f, 0.01723349f, -0.01044479f, -0.01388802f, -0.03853067f, -0.02972297f, -0.01596434f, 
    -0.00562078f, -0.03472371f, -0.00339848f, 0.02451508f, -0.03891006f, -0.02771173f, 0.00103484f, -0.04191533f, 
    -0.00204585f, -0.00817195f, -0.00381607f, -0.00620937f, 0.02675755f, 0.00655398f, -0.04124895f, -0.02068448f, 
    -0.01888316f, -0.01554766f, -0.02772965f, -0.01926994f, 0.02417140f, -0.00466123f, -0.02107381f, 0.01044867f, 
    -0.01005102f, -0.01458408f, -0.01691533f, 0.00601696f, -0.01896903f, 0.01304898f, -0.02104106f, 0.01346286f, 
    0.00743018f, 0.02046966f, -0.02657625f, -0.00816930f, 0.00867692f, 0.01855601f, -0.01495497f, 0.02201201f, 
    0.02251923f, -0.01810534f, -0.01936859f, -0.03419628f, -0.02042599f, 0.01281942f, 0.02917558f, 0.01298341f, 
    -0.01747603f, 0.01127599f, -0.01283107f, -0.00035884f, 0.00341100f, 0.03845561f, -0.00539673f, 0.01196953f, 
    0.02557848f, -0.00227037f, 0.01888413f, 0.01084777f, 0.01259867f, -0.03252007f, 0.00500031f, 0.02583134f, 
    0.02657734f, -0.00790042f, 0.00990592f, 0.04138611f, -0.04254978f, -0.01004750f, -0.02317658f, -0.01559387f, 
    0.00861286f, -0.01998018f, -0.03967712f, -0.00516072f, 0.03113258f, 0.02386802f, 0.00268639f, -0.00476573f, 
    0.04415621f, -0.03115027f, -0.02117073f, -0.01447202f, -0.01844659f, -0.04299276f, 0.01000641f, -0.02445191f, 
    -0.00446114f, 0.02295193f, -0.00921415f, 0.00400012f, 0.01387871f, -0.02816107f, 0.00354564f, 0.00817271f, 
    0.03002370f, -0.02473225f, -0.02959546f, 0.03250098f, 0.00009284f, 0.00230187f, -0.04046303f, -0.00715313f, 
    0.00956418f, 0.01774095f, 0.01768342f, -0.04098861f, 0.01404340f, -0.03224541f, -0.04178357f, -0.02851749f, 
    -0.01241894f, 0.00468531f, 0.01559128f, -0.01993087f, -0.02310590f, -0.03298727f, -0.03957233f, -0.01002320f, 
    -0.00107073f, -0.00500534f, -0.03441546f, -0.03521497f, -0.02898552f, -0.03344838f, -0.00194319f, -0.04070031f, 
    -0.03334664f, 0.02777751f, -0.03884765f, -0.00004956f, 0.02330498f, 0.00776778f, 0.02926141f, 0.00967699f, 
    0.00061738f, -0.02805385f, -0.00467956f, 0.00326004f, 0.00899562f, -0.01060436f, -0.00849985f, -0.02600112f, 
    0.03100332f, -0.01896620f, -0.03555936f, -0.00565566f, -0.00655631f, -0.01829848f, 0.02712476f, 0.00221602f, 
    -0.02253220f, -0.02963527f, -0.02403469f, -0.00379702f, -0.04301243f, 0.01917211f, 0.01576880f, -0.04646260f, 
    -0.02881042f, -0.02549119f, 0.02070947f, 0.01008020f, 0.01894759f, 0.00364657f, -0.00027612f, -0.00731528f, 
    -0.01777406f, -0.02256406f, -0.01285036f, -0.00512234f, -0.01962305f, 0.01013066f, -0.01275451f, -0.04471080f, 
    -0.02440368f, -0.04081350f, 0.01844809f, -0.02806565f, -0.00286357f, 0.00127094f, 0.02244555f, 0.00627346f, 
    -0.01211462f, -0.01532425f, -0.04155644f, -0.01971177f, 0.01052333f, 0.00596397f, -0.02523452f, -0.00030624f, 
    -0.03724683f, -0.00716251f, 0.03331609f, 0.02975743f, 0.02959057f, 0.00621888f, -0.02763622f, -0.02628507f, 
    -0.02132069f, -0.03911843f, -0.00773493f, 0.02613570f, -0.03102791f, 0.02865437f, -0.03588120f, -0.03000811f, 
    -0.00290130f, 0.01541829f, 0.00362230f, -0.02073469f, -0.00794701f, 0.01364371f, -0.01402394f, -0.04076007f, 
    -0.02178217f, 0.02746639f, -0.01097390f, 0.01673772f, -0.02234777f, 0.01415239f, 0.02957473f, -0.02036254f, 
    0.03263747f, -0.04330267f, -0.03086118f, -0.01192554f, 0.00335113f, 0.00733763f, -0.02962318f, -0.03679126f, 
    -0.00269955f, -0.03642729f, 0.03107146f, 0.00310708f, 0.03102169f, -0.02777213f, -0.01988840f, -0.01339160f, 
    0.00130562f, -0.04448286f, 0.00816772f, 0.02457277f, 0.00519358f, -0.00983794f, -0.03227538f, 0.01839320f, 
    -0.01052039f, -0.04282934f, 0.00596733f, -0.04259601f, -0.03645854f, -0.00920601f, 0.02427306f, -0.04384040f, 
    -0.03635655f, 0.01264244f, 0.02028940f, 0.00607366f, -0.01105248f, -0.00632417f, 0.00885351f, 0.02260265f, 
    -0.04438302f, 0.00481320f, -0.03735366f, -0.00455065f, -0.01541728f, -0.02202974f, 0.01458847f, 0.00972919f, 
    -0.04432217f, -0.00056437f, 0.00066651f, 0.00981128f, -0.03695993f, 0.01760303f, -0.01222816f, 0.00686520f, 
    0.01029094f, -0.03602000f, 0.02801782f, -0.03655092f, -0.01249929f, 0.02180784f, -0.01987673f, -0.02052020f, 
    -0.00461720f, -0.01293255f, -0.02615381f, -0.04212862f, 0.00228591f, -0.00633939f, -0.04132599f, -0.00096212f, 
    -0.03941190f, 0.01510462f, 0.00325475f, 0.00136219f, 0.00078176f, -0.02778202f, 0.00300224f, -0.01841902f, 
    0.00144896f, -0.01771400f, -0.03392305f, -0.02145635f, -0.00665963f, 0.02013961f, 0.00502521f, -0.00933704f, 
    -0.03684062f, 0.02112226f, -0.03207413f, 0.00883361f, -0.00598001f, -0.04672463f, 0.00412291f, -0.00056607f, 
    0.00220443f, 0.03101127f, 0.00444478f, -0.03818964f, 0.01206287f, -0.03886675f, -0.00923587f, -0.04191030f, 
    -0.01293004f, 0.00493171f, -0.02629747f, 0.02677619f, -0.00204333f, 0.02484640f, -0.02547868f, -0.02643687f, 
    -0.00756347f, -0.00074989f, -0.00191527f, -0.00786520f, 0.02025820f, 0.02227042f, -0.01246263f, -0.01353441f, 
    0.00420652f, -0.00793173f, 0.01523265f, 0.01033430f, -0.01856337f, 0.02220382f, 0.00851300f, 0.00791821f, 
    -0.04591856f, 0.01858506f, 0.00057117f, -0.01728109f, 0.00625733f, -0.01781496f, -0.01071403f, -0.04012125f, 
    0.01869378f, -0.03096306f, 0.01119553f, -0.02801235f, -0.03965508f, 0.02628935f, 0.00016150f, -0.00565723f, 
    -0.03090178f, -0.00172744f, 0.00020048f, -0.03296802f, 0.01742495f, -0.00748173f, -0.02348593f, -0.01844969f, 
    -0.00964767f, 0.01404787f, -0.02724701f, -0.01571312f, 0.02294689f, -0.00438152f, -0.03913954f, 0.03057858f, 
    0.01319907f, 0.02005578f, -0.00913805f, -0.04262353f, 0.01190525f, 0.02649781f, 0.01570756f, -0.00487721f, 
    -0.01418693f, -0.04493632f, -0.01334058f, 0.01979013f, 0.00226729f, 0.01001545f, -0.02892847f, 0.00081645f, 
    -0.02681466f, -0.03398973f, 0.01707157f, 0.02505438f, 0.00053865f, 0.00124257f, -0.00522637f, -0.04599752f, 
    -0.04081940f, -0.04171619f, -0.00614792f, -0.01829003f, -0.02414857f, -0.03888673f, -0.00438070f, -0.03825695f, 
    -0.00929841f, -0.01815440f, -0.04060722f, 0.01647973f, 0.01378970f, 0.00682061f, 0.00928441f, 0.00647500f, 
    0.01637044f, -0.01928806f, 0.02853576f, -0.02909818f, 0.00507927f, 0.01503410f, -0.00602808f, -0.00339081f, 
    -0.01156471f, -0.00775944f, -0.04016177f, -0.02205256f, -0.02438932f, 0.01954358f, 0.01371184f, -0.03328175f, 
    0.00659389f, 0.01480152f, 0.02829926f, 0.00368930f, -0.02291631f, -0.02127015f, 0.02555011f, -0.02004020f, 
    -0.04104856f, 0.00589072f, -0.00131211f, 0.01159060f, 0.01128371f, -0.00858393f, -0.04543560f, -0.03476699f, 
    -0.01213745f, -0.01252302f, -0.01728699f, -0.02196443f, -0.01525376f, 0.00781044f, -0.00534322f, 0.03046232f, 
    -0.01263278f, -0.02447148f, 0.02543943f, -0.01923919f, -0.03051240f, -0.04498544f, -0.02267591f, -0.00427263f, 
    0.02378893f, -0.03307328f, 0.02737693f, -0.02552695f, -0.00062294f, -0.04117735f, -0.01950657f, 0.00267934f, 
    -0.02788140f, -0.04592849f, -0.03543039f, -0.00892309f, -0.03826316f, -0.01330195f, -0.02917232f, 0.00943339f, 
    0.00664792f, -0.02880815f, 0.03007007f, -0.04657707f, -0.03567610f, 0.03216520f, -0.00376686f, -0.01242189f, 
    -0.03590710f, -0.00268014f, 0.03202814f, -0.02391787f, 0.01323702f, 0.00432746f, 0.01954131f, -0.01783020f, 
    -0.00870160f, -0.03483737f, -0.03688996f, -0.03323126f, 0.01794676f, -0.03855934f, -0.03767856f, 0.01042664f, 
    0.02350298f, -0.02923313f, 0.00859372f, -0.00212765f, 0.01095738f, -0.04047863f, 0.02030404f, 0.02566528f, 
    -0.02341650f, -0.03331737f, 0.01639190f, 0.02878551f, 0.02682807f, -0.01186100f, 0.00268241f, -0.01691346f, 
    0.01027767f, -0.03746902f, -0.00172867f, -0.03018848f, 0.00488252f, 0.01640991f, 0.01108917f, 0.00008979f, 
    -0.00907495f, 0.01390622f, 0.01633782f, 0.00372972f, -0.03788045f, -0.01728695f, 0.01152988f, -0.00795796f, 
    0.02862060f, 0.01490736f, -0.00285021f, -0.04069259f, 0.01014073f, 0.00041801f, -0.00502884f, 0.01256644f, 
    -0.00849840f, 0.02596663f, 0.02549935f, -0.02824970f, 0.02159992f, -0.03451594f, 0.02331486f, 0.00228423f, 
    0.02700365f, 0.01290625f, -0.00551820f, 0.02423805f, -0.02489726f, 0.02539369f, -0.02812839f, 0.03043716f, 
    0.00987054f, 0.01588844f, -0.00871104f, -0.00145946f, -0.04507501f, 0.02385191f, -0.00719163f, 0.00918798f, 
    0.00556821f, -0.02713059f, -0.01320784f, -0.04648473f, 0.00390835f, -0.02767831f, 0.02771316f, -0.04380820f, 
    -0.00578978f, 0.00381613f, -0.04632112f, -0.04489255f, 0.03031477f, -0.03874828f, -0.01133872f, 0.00492978f, 
    -0.02911167f, 0.03047738f, -0.00030918f, -0.00073113f, -0.03206878f, 0.02161912f, 0.02194017f, -0.01704257f, 
    0.00907940f, -0.00471202f, 0.02172150f, -0.02581471f, 0.03330166f, 0.00966682f, 0.00975311f, 0.02117305f, 
    0.02124631f, -0.00630118f, -0.01948742f, -0.00990598f, 0.00776666f, 0.01988638f, 0.00814347f, -0.04652314f, 
    0.01733934f, 0.02124053f, -0.01929273f, 0.00522820f, -0.04087660f, -0.00476393f, -0.00182559f, -0.04658586f, 
    -0.00336916f, -0.03145199f, -0.00403614f, -0.04034120f, 0.01881445f, -0.02329522f, 0.00628784f, 0.01098260f, 
    0.02712702f, 0.00510735f, 0.02313668f, -0.04226432f, -0.01860782f, -0.01766877f, 0.01817955f, -0.01088237f, 
    -0.00859580f, 0.02827855f, -0.03432882f, -0.03143778f, -0.03109358f, 0.03125366f, -0.04071966f, -0.00550564f, 
    -0.02516617f, 0.00975086f, -0.02378256f, 0.02275483f, 0.02017655f, 0.00145792f, -0.03525573f, 0.00335478f, 
    -0.00215772f, -0.02890242f, -0.01611325f, 0.00275237f, -0.00228992f, -0.02331647f, 0.00618763f, -0.00309184f, 
    -0.00377097f, 0.00142113f, -0.03154575f, 0.02933748f, -0.00012712f, -0.04107430f, 0.01573586f, -0.02955554f, 
    -0.00681902f, -0.01492551f, 0.01316547f, 0.00103313f, 0.02532428f, 0.02674567f, 0.01748697f, -0.03498536f, 
    0.00231175f, 0.02894735f, -0.03407529f, 0.00666943f, 0.01975231f, 0.02882173f, -0.03586733f, -0.00030611f, 
    -0.04342235f, -0.03943330f, -0.04363634f, 0.03095816f, -0.02151338f, -0.02101927f, 0.01663889f, -0.00321232f, 
    -0.00761810f, -0.02412118f, -0.03811143f, -0.01928399f, 0.01603918f, -0.01057443f, -0.01808283f, 0.00721053f, 
    0.03213461f, 0.02588456f, -0.00322739f, -0.02963013f, 0.03033863f, -0.03281737f, -0.03659059f, -0.02193622f, 
    -0.00791701f, 0.00320271f, -0.02380887f, -0.03296920f, -0.03124938f, -0.01361642f, 0.02213552f, -0.03644939f, 
    -0.04307276f, -0.03523019f, 0.00958492f, -0.03065925f, 0.00607304f, 0.00419742f, 0.02284002f, -0.00499535f, 
    -0.03917541f, -0.00099285f, -0.03784273f, -0.02282671f, -0.02594303f, 0.00085585f, -0.02352224f, 0.01488265f, 
    -0.00001909f, -0.00933193f, -0.00585660f, -0.01645170f, -0.00593351f, -0.01215745f, 0.00836943f, -0.00324077f, 
    -0.03433899f, -0.02619436f, -0.00304561f, -0.01501038f, -0.03139965f, -0.03873735f, -0.03303676f, -0.01654097f, 
    -0.01413682f, -0.00791672f, -0.04120320f, -0.04342479f, 0.00456204f, -0.00956163f, -0.00824221f, -0.00436997f, 
    0.00560839f, -0.00210156f, -0.01222416f, 0.02308090f, -0.01303148f, -0.03495771f, -0.02610959f, 0.00778381f, 
    -0.00943299f, 0.02718319f, 0.01482079f, -0.04320368f, 0.01115002f, -0.04658893f, 0.02384288f, -0.03285499f, 
    0.00487396f, -0.02673527f, -0.04157905f, 0.01331318f, 0.00708936f, -0.00133288f, -0.03261621f, -0.03684575f, 
    0.02416101f, -0.03433452f, -0.00123660f, -0.01793117f, 0.00378981f, 0.00368664f, 0.04353052f, -0.03763532f, 
    -0.02052358f, 0.01718396f, -0.03567564f, 0.00870649f, -0.01179345f, 0.02245646f, -0.01732320f, 0.01899903f, 
    -0.01387207f, 0.00425360f, -0.03398633f, 0.02820414f, -0.01900879f, 0.00431596f, 0.02211057f, -0.04172120f, 
    -0.04278521f, 0.00949849f, -0.03396677f, -0.03425425f, 0.01449368f, -0.01056421f, -0.02499120f, 0.02503780f, 
    -0.02541721f, 0.00815564f, -0.00971749f, 0.01767881f, -0.02138883f, -0.00048336f, 0.01532939f, -0.01556077f, 
    0.02261479f, -0.02075310f, 0.02202461f, -0.01554831f, 0.02046705f, -0.03843025f, -0.03906859f, -0.01927038f, 
    0.01520965f, -0.00463571f, 0.00020994f, -0.00353030f, 0.01824732f, 0.00245786f, 0.01025808f, 0.02963543f, 
    0.01827109f, -0.03698703f, 0.00349006f, -0.00414511f, -0.02200778f, -0.02214818f, 0.00376451f, 0.02570172f, 
    0.01815923f, -0.01332030f, -0.01673168f, -0.02010028f, 0.01541041f, -0.03556105f, -0.03148864f, 0.01174461f, 
    0.01142601f, -0.04171919f, 0.00262200f, 0.02588930f, 0.00828517f, -0.02675724f, -0.03768763f, 0.02187908f, 
    -0.01809575f, -0.03129962f, 0.02769389f, 0.00035415f, 0.01031099f, 0.01831678f, 0.00211040f, -0.02973869f, 
    0.02552064f, -0.01039017f, -0.03439767f, -0.00251585f, 0.02823794f, 0.02233938f, -0.01807241f, 0.03197575f, 
    -0.01789348f, 0.03780517f, -0.02200994f, -0.00668970f, -0.00703853f, 0.00129458f, -0.03950587f, 0.02190325f, 
    -0.01703748f, -0.04179389f, 0.01888210f, 0.00404718f, -0.04334877f, 0.01775851f, -0.00720150f, 0.02700884f, 
    -0.00726965f, 0.00648023f, 0.03019932f, -0.01971496f, 0.00386095f, -0.04259322f, -0.03141218f, -0.02929503f, 
    -0.02408902f, 0.02261547f, -0.03236503f, -0.01326233f, 0.02567117f, -0.03534669f, 0.00548641f, -0.00509351f, 
    0.02974296f, -0.02920924f, -0.03053650f, -0.04701230f, -0.01337333f, -0.01844640f, -0.03194406f, 0.00718645f, 
    -0.02986467f, 0.02908576f, 0.00216009f, -0.03657185f, -0.04509785f, 0.00160303f, -0.00125248f, -0.04215384f, 
    -0.02207352f, -0.00482961f, 0.00439807f, -0.00379559f, -0.00045107f, -0.01503613f, -0.01483624f, -0.00701638f, 
    -0.03560811f, -0.00427344f, 0.00352320f, -0.00566354f, -0.00633011f, -0.02813197f, -0.03609979f, 0.01210915f, 
    0.00263688f, -0.02193846f, -0.03043533f, -0.04170596f, -0.04127586f, -0.01577074f, -0.02762356f, 0.02636121f, 
    -0.00873130f, -0.02431675f, -0.03930097f, -0.01468479f, 0.02944446f, -0.01519796f, -0.02735477f, -0.01553938f, 
    0.02321688f, -0.00560478f, 0.00434357f, 0.02610861f, -0.02677659f, 0.02053439f, 0.00286260f, -0.04502171f, 
    -0.02378631f, -0.01769838f, 0.00210810f, -0.01667480f, 0.01948044f, 0.01129589f, 0.00271314f, 0.00339487f, 
    -0.01594265f, -0.04016429f, -0.02574038f, 0.00280898f, 0.00930796f, -0.02972637f, -0.03239990f, -0.01690099f, 
    0.00456736f, -0.00748486f, 0.04021776f, 0.01973031f, 0.02774439f, -0.00410691f, -0.02181224f, -0.01163690f, 
    0.00679987f, 0.00231013f, -0.04300448f, -0.04751140f, 0.02579156f, 0.02563091f, -0.00445366f, 0.00346951f, 
    -0.04137723f, 0.00815451f, -0.01269144f, -0.03934723f, 0.01770231f, -0.00549707f, -0.04370864f, 0.01429842f, 
    0.02424158f, 0.00315170f, 0.00935258f, -0.04642402f, -0.00772467f, 0.03123332f, -0.02117966f, -0.01063076f, 
    0.00092300f, 0.01713936f, -0.04478743f, 0.00822522f, -0.04512770f, 0.01386191f, 0.02706763f, -0.02669029f, 
    0.02117897f, 0.00298825f, 0.02003756f, 0.03088710f, 0.02378766f, 0.01069031f, -0.03469342f, -0.01636807f, 
    -0.03851985f, -0.00396813f, 0.02802361f, -0.02969790f, -0.00208582f, -0.00831250f, -0.03581966f, 0.02934828f, 
    -0.04124534f, -0.00638805f, 0.01140555f, 0.02524859f, -0.02049436f, -0.02141332f, 0.00539741f, -0.03748950f, 
    -0.00226312f, -0.02551233f, -0.03025736f, 0.00438031f, 0.00584970f, 0.02600340f, 0.02952576f, -0.01503107f, 
    -0.00901427f, -0.01171562f, 0.00404608f, 0.00212541f, -0.04355123f, 0.03716709f, -0.00926588f, -0.00812941f, 
    -0.02033808f, -0.02880284f, 0.00499057f, -0.01761789f, 0.00076498f, 0.01210612f, 0.02495264f, -0.03509078f, 
    0.00522716f, -0.00253056f, 0.01294994f, -0.01423897f, 0.03639782f, -0.02015801f, 0.01520455f, -0.00132770f, 
    -0.03697505f, 0.02750414f, 0.00390251f, 0.03263373f, -0.03809749f, 0.00026688f, 0.00950254f, -0.01986131f, 
    0.03041238f, -0.00190116f, 0.02891463f, -0.01455416f, 0.01353908f, -0.04373783f, -0.03765126f, -0.01664600f, 
    -0.04760119f, -0.01868938f, 0.01016411f, 0.00790263f, 0.01581266f, 0.02505992f, 0.01901063f, -0.00093872f, 
    -0.00607792f, -0.00449658f, -0.01054593f, 0.02338450f, -0.04253528f, 0.00198550f, 0.02204251f, 0.00753086f, 
    -0.00397670f, 0.03352341f, -0.01767020f, 0.01520971f, -0.03861355f, -0.00687025f, -0.01058779f, 0.02693164f, 
    -0.01392409f, 0.00851612f, 0.01549945f, -0.00904073f, -0.04124149f, -0.04154209f, -0.04121556f, -0.01413365f, 
    -0.02587160f, -0.01912352f, 0.01092376f, 0.00858233f, -0.01906401f, 0.02204941f, 0.02905915f, -0.03852994f, 
    0.02727009f, -0.00454404f, -0.03755189f, -0.02953407f, -0.02266491f, -0.00607872f, -0.01959830f, -0.01864948f, 
    -0.03121918f, 0.01477777f, -0.04304984f, -0.02663275f, 0.02287125f, 0.02427190f, 0.00113816f, -0.00201187f, 
    -0.03533984f, -0.04767508f, -0.00645036f, -0.03668916f, -0.01414832f, 0.02742625f, 0.01865664f, 0.02068019f, 
    -0.03088268f, 0.00386046f, -0.02366233f, 0.00458873f, 0.00462870f, -0.03672049f, -0.04494392f, 0.00259290f, 
    -0.02476157f, 0.00249466f, -0.04174346f, -0.03819615f, 0.02119877f, 0.02580457f, -0.03943149f, 0.01521028f, 
    0.01774271f, -0.04632433f, -0.01158581f, -0.03816456f, 0.01860254f, 0.01696119f, 0.00798169f, -0.02682074f, 
    -0.04049178f, -0.01576394f, 0.00425719f, -0.02509821f, -0.00640920f, -0.03851279f, 0.02591369f, 0.00251041f, 
    -0.01743256f, 0.01832202f, -0.03481762f, 0.01605155f, 0.01823633f, 0.01666334f, -0.01901309f, -0.03101778f, 
    0.01737046f, -0.00673637f, -0.02093622f, 0.02234687f, -0.02185478f, 0.02017302f, -0.03625980f, -0.00675213f, 
    0.00443024f, -0.00272744f, 0.01401740f, -0.01341634f, 0.00971487f, -0.03676964f, 0.00807109f, -0.02206868f, 
    0.00736050f, -0.03203965f, 0.00647637f, -0.02682847f, -0.00689842f, -0.04229330f, -0.03745841f, 0.02136086f, 
    0.01718567f, 0.00595210f, -0.01585975f, 0.02786523f, -0.00214651f, -0.03895111f, -0.01127562f, -0.01260615f, 
    -0.01553629f, -0.02702412f, -0.03337900f, -0.01674735f, -0.00594495f, -0.00186374f, 0.02018278f, 0.00272276f, 
    -0.04357408f, -0.04769766f, 0.00359719f, 0.01153657f, -0.02674836f, -0.00989402f, 0.00957745f, 0.02304123f, 
    -0.04835797f, 0.00200278f, -0.01965689f, 0.00940077f, -0.02806259f, 0.00644061f, -0.04285175f, 0.02174620f, 
    -0.01254026f, 0.01764531f, -0.00377395f, -0.03963146f, -0.01986628f, 0.01229510f, 0.00984318f, 0.00307638f, 
    -0.04658033f, -0.02645576f, -0.03780388f, -0.03679558f, -0.03899385f, 0.02809119f, -0.02447478f, 0.01179231f, 
    -0.02411353f, 0.02603987f, -0.03236337f, 0.02135423f, -0.01964568f, -0.01086542f, 0.00781897f, 0.01769932f, 
    -0.04094565f, 0.02681025f, -0.03126786f, -0.02929549f, 0.01088219f, 0.01558011f, 0.00026913f, 0.00012289f, 
    0.02184013f, -0.03676904f, 0.02562781f, -0.01390556f, -0.00301168f, 0.01409101f, -0.03430709f, -0.03276844f, 
    -0.03623633f, -0.02927706f, -0.02986740f, 0.01329936f, 0.02581366f, 0.02690616f, 0.01077387f, -0.04433624f, 
    0.00413044f, -0.02980948f, -0.03039107f, 0.01755651f, 0.03437220f, -0.00282140f, -0.03704206f, 0.02996833f, 
    0.01232916f, 0.02845712f, 0.03725028f, -0.04278942f, -0.03006731f, -0.04180782f, 0.00978848f, -0.02524072f, 
    -0.03558426f, -0.02977683f, -0.04120976f, 0.02561209f, 0.00645883f, 0.01776683f, -0.00611345f, 0.00204134f, 
    -0.01972907f, -0.01376573f, 0.02832038f, 0.02586989f, 0.02035093f, 0.00523051f, 0.01262609f, 0.01911753f, 
    -0.03420963f, 0.00177748f, 0.01912123f, -0.04017547f, -0.02440015f, -0.00771434f, -0.01995341f, 0.00521770f, 
    -0.04697685f, -0.00650793f, -0.03681028f, -0.02794670f, 0.02613456f, 0.02053859f, 0.01846838f, 0.01694277f, 
    -0.03594252f, -0.04282426f, 0.00452370f, -0.02179820f, -0.01562362f, -0.03349183f, 0.02490900f, -0.02404677f, 
    -0.04531997f, -0.03760849f, -0.01702130f, -0.00171979f, 0.02037110f, -0.01813847f, 0.02077718f, -0.03138848f, 
    -0.04800167f, -0.02490912f, -0.04151893f, -0.01730381f, 0.01349577f, -0.01126028f, -0.03569855f, 0.02254720f, 
    0.02836426f, 0.01212513f, 0.00739373f, 0.02129019f, -0.03730518f, -0.01577551f, -0.03898192f, -0.03498854f, 
    0.01697923f, -0.04455240f, 0.02472300f, -0.03058599f, 0.01768022f, -0.03811569f, 0.01017684f, 0.00093519f, 
    -0.15125781f, 0.11490894f, -0.19791672f, 0.12141336f, 0.20015797f, 0.08782242f, 0.19832812f, 0.28303012f, 
    -0.01706394f, 0.08090560f, 0.07223205f, -0.01038232f, -0.01386514f, -0.03068144f, 0.03006542f, 0.04634291f, 
    -0.00498096f, 0.23298596f, 0.12858029f, 0.00151406f, 0.75453860f, -0.09758334f, -0.06375293f, 0.16833362f, 
    0.12230876f, 0.01245685f, -0.08508831f, 0.19131172f, 0.06263755f, 0.29090434f, 0.04152906f, 0.00332843f, 
    -0.01659730f, 0.12233895f, 0.00508547f, 0.08123457f, 0.21970424f, 0.11412416f, 0.12063678f, 0.38343340f, 
    -0.42946234f, 0.19772460f, 0.23655544f, -0.21784434f, 0.07395002f, 0.04148122f, -0.01994670f, 0.05064584f, 
    0.04128632f, 0.01643182f, 0.02815630f, 0.11645012f, 0.07386456f, 0.23600690f, 0.20364736f, -0.11105179f, 
    -0.10818361f, 0.14542475f, -0.02408660f, -0.04900201f, 0.08070965f, 0.02382398f, 0.19294626f, -0.09461498f, 
    -0.15109639f, 0.10117153f, -0.06957056f, 0.02791639f, 0.09470285f, 0.00215573f, -0.01346562f, -0.13787012f, 
    -0.07445554f, -0.20439662f, -0.01564778f, -0.11406339f, -0.06199521f, -0.04635137f, 0.12844194f, -0.02304431f, 
    -0.11308539f, 0.01925784f, -0.01610635f, -0.13079281f, -0.06454472f, 0.14668946f, -0.06036281f, -0.16586898f, 
    0.01407801f, -0.01789454f, 0.20162483f, 0.05811764f, 0.10890465f, -0.09476316f, -0.08914749f, -0.21025454f, 
    -0.00138139f, -0.24216715f, -0.01407017f, -0.10921971f, -0.20727189f, 0.25525528f, 0.04910595f, -0.14373259f, 
    0.15737274f, 0.09406179f, -0.06030263f, 0.02509819f, 0.03902845f, 0.05218381f, -0.01991318f, 0.20454019f, 
    0.20571537f, 0.07860377f, 0.10752557f, -0.05612284f, 0.01100129f, 0.09055529f, 0.20444018f, 0.09259455f, 
    -0.09190559f, -0.27209195f, -0.04603279f, -0.15068056f, 0.18990701f, -0.06201468f, 0.20261152f, 0.09147823f, 
    0.11317226f, 0.19725947f, 0.07125276f, -0.11778250f, -0.13444123f, -0.06951857f, -0.13827689f, 0.01463837f, 
    0.05200185f, 0.19712321f, 0.17704491f, 0.22277725f, -0.45367053f, -0.16902615f, -0.10684565f, -0.09509341f, 
    0.04787117f, 0.11772455f, -0.09528587f, 0.07111686f, 0.05089312f, 0.01822454f, 0.04478164f, 0.20914404f, 
    0.11125202f, -0.07579759f, 0.16557300f, 0.12614840f, 0.21657355f, -0.07802060f, -0.00427824f, 0.01842250f, 
    -0.10675455f, -0.03581488f, 0.06992883f, -0.05233790f, -0.11824558f, 0.15318967f, 0.01691566f, 0.12585369f, 
    -0.01394927f, 0.05261610f, -0.02036690f, -0.04481390f, -0.11281355f, -0.17095216f, -0.11145583f, -0.06860537f, 
    -0.11193244f, 0.03348720f, 0.03223687f, 0.04578453f, -0.02246298f, 0.53525949f, 0.51883548f, 0.05351250f, 
    0.19831850f, -0.04708622f, -0.23003818f, -0.19166920f, -0.09051088f, 0.04629432f, -0.04012863f, -0.03433220f, 
    0.02917392f, -0.00843800f, -0.08627583f, -0.16470186f, -0.26086608f, -0.04620992f, -0.13184474f, -0.11579926f, 
    0.03577524f, 0.52267045f, 0.22876948f, 0.14141761f, 0.12611656f, 0.10389756f, 0.01021094f, -0.09120456f, 
    0.14154248f, 0.14337280f, -0.04010086f, 0.01878997f, 0.07320227f, 0.14423583f, 0.09938604f, -0.23831831f, 
    -0.01751927f, -0.00476053f, 0.07323960f, 0.09041681f, 0.61076617f, 0.26484293f, 0.02988918f, 0.04412958f, 
    -0.05757278f, -0.02034891f, -0.08608270f, 0.27178365f, 0.07848430f, 0.07320424f, -0.00194492f, -0.03757228f, 
    0.15765633f, 0.03234129f, 0.02150547f, -0.02170016f, 0.25101036f, 0.32053223f, 0.24604519f, 0.09189274f, 
    -0.61339676f, -0.09496050f, 0.44820455f, -0.07045725f, 0.02823592f, -0.08303562f, 0.06810280f, 0.25437376f, 
    0.01067775f, -0.09728676f, -0.01097275f, -0.01399038f, 0.17091168f, -0.05512969f, 0.10387886f, 0.20055585f, 
    -0.00236234f, 0.27377751f, -0.02866824f, 0.02790333f, 0.21057254f, 0.24649338f, 0.38327342f, 0.07484789f, 
    0.01070793f, 0.04259357f, -0.08618226f, -0.17159218f, 0.04757550f, 0.16911665f, -0.04695862f, -0.11318845f, 
    0.03006985f, 0.02039377f, 0.15350531f, -0.21513081f, -0.08386935f, 0.08214041f, 0.10054737f, -0.02081140f, 
    -0.06142505f, -0.16642860f, -0.28329986f, 0.13302572f, -0.06754150f, 0.18891114f, -0.00880590f, 0.08559082f, 
    0.00348066f, -0.11101145f, 0.05765378f, 0.10754285f, -0.04102448f, 0.08092579f, 0.00626644f, 0.07107311f, 
    0.11375124f, -0.16015705f, 0.00486270f, 0.04814696f, -0.08446575f, -0.30780369f, -0.20871179f, -0.13013920f, 
    -0.02283083f, 0.06174598f, 0.01017501f, -0.02060450f, -0.04855156f, 0.21975714f, -0.02269160f, -0.15551008f, 
    0.03961965f, 0.12157261f, 0.05345057f, 0.07653055f, 0.13397080f, 0.20567323f, 0.15406413f, 0.26316574f, 
    -0.04279911f, -0.12986434f, -0.00081073f, -0.02267258f, 0.01224087f, 0.34492180f, -0.16715717f, 0.09471489f, 
    -0.00286544f, 0.07753262f, -0.03739794f, -0.07564203f, -0.07617261f, -0.11249422f, -0.03575657f, -0.06525970f, 
    -0.06157215f, 0.00795037f, -0.00454174f, 0.01783024f, 0.09951200f, 0.19930743f, -0.40672094f, 0.11036251f, 
    0.30097693f, 0.04323987f, 0.16721703f, 0.19639674f, -0.06058453f, -0.03644586f, 0.04906471f, 0.07468690f, 
    -0.04034558f, -0.16979317f, 0.17237221f, 0.06272487f, 0.07087325f, 0.01615813f, -0.10407401f, -0.19487019f, 
    0.01174177f, -0.23442529f, -0.05266085f, -0.16264321f, -0.09144720f, 0.23996855f, 0.14333031f, -0.07285347f, 
    0.05982026f, 0.04373183f, 0.13925718f, -0.06714407f, -0.04894048f, -0.00685358f, -0.04505291f, -0.02137315f, 
    -0.18769537f, 0.04574910f, 0.24697044f, 0.01053069f, -0.10767285f, -0.06376605f, -0.31940308f, 0.18402903f, 
    0.03144184f, 0.03861456f, 0.09007351f, -0.07209545f, 0.14877306f, -0.05856578f, 0.08056325f, -0.12371593f, 
    0.01373001f, -0.01618136f, -0.04374048f, -0.00603430f, -0.00532170f, -0.13145186f, -0.05823120f, -0.22374214f, 
    -0.12333209f, -0.09401506f, -0.08504336f, -0.12113874f, 0.01212848f, 0.11227824f, 0.04956493f, -0.24755991f, 
    -0.05450214f, -0.03828698f, 0.02013182f, -0.02053430f, -0.11638880f, 0.15171731f, -0.07707211f, 0.05981521f, 
    -0.21273199f, -0.01597430f, -0.03979290f, 0.08075967f, 0.01823607f, 0.03449715f, 0.04336854f, 0.10010275f, 
    0.18162231f, -0.02472065f, 0.27315682f, 0.17105573f, -0.01750586f, 0.10722761f, 0.06097247f, -0.06395095f, 
    0.02668788f, 0.01201444f, -0.02758418f, 0.08330335f, 0.08804261f, 0.17163555f, 0.12892833f, 0.14744443f, 
    -0.05421389f, -0.28214076f, 0.02185646f, 0.07195019f, 0.11698569f, 0.22020675f, 0.17844211f, 0.08930914f, 
    0.07663666f, 0.00930775f, 0.10595300f, -0.00480784f, -0.03668041f, -0.10907925f, -0.04055114f, -0.03742766f, 
    -0.06580066f, 0.00433354f, -0.22129743f, -0.09480689f, -0.04928915f, -0.12258051f, -0.02476423f, 0.03757032f, 
    0.12131885f, -0.06570951f, 0.13603416f, 0.14706121f, 0.07350159f, 0.04990623f, 0.04728333f, -0.02633324f, 
    -0.05702752f, -0.01741223f, 0.05756862f, -0.00271869f, 0.09931513f, 0.20240277f, 0.14905141f, 0.28549281f, 
    0.11341892f, 0.14652103f, -0.01600456f, -0.16784805f, 0.01406006f, 0.02659181f, 0.12662515f, 0.20848358f, 
    0.01114091f, 0.07894091f, 0.21059084f, 0.00913263f, -0.11864805f, -0.21269430f, -0.07824627f, -0.11662485f, 
    -0.22219656f, -0.09352008f, 0.03217761f, -0.13654785f, 0.21367793f, -0.04410874f, -0.21227324f, -0.00977966f, 
    -0.13941255f, 0.02336740f, -0.04749298f, -0.02048137f, 0.11296079f, 0.07718335f, -0.02155346f, -0.06691311f, 
    0.05126541f, 0.15520690f, 0.08117306f, 0.06479070f, 0.15909074f, 0.13255456f, 0.16688368f, 0.22455809f, 
    -0.19486867f, 0.03503671f, 0.15072963f, 0.13137418f, 0.10631111f, -0.12202070f, 0.06281937f, -0.00150322f, 
    -0.02628104f, 0.12971398f, 0.09127960f, 0.00385822f, 0.05787781f, -0.09458604f, 0.08841129f, 0.27186045f, 
    0.24355319f, 0.10581577f, -0.00350496f, 0.21352127f, -0.20246324f, -0.13753229f, -0.02805756f, -0.13535762f, 
    0.05054405f, 0.02478213f, -0.07430357f, 0.02609391f, 0.00474797f, 0.08054496f, -0.05391585f, 0.00188412f, 
    0.06798533f, 0.09801339f, -0.02536617f, -0.09510165f, 0.10680161f, -0.03399125f, 0.03909062f, -0.06424532f, 
    -0.32288477f, 0.58159530f, -0.01121721f, -0.24950042f, 0.26112202f, 0.15690455f, -0.23323897f, 0.05234910f, 
    0.06996615f, 0.04771841f, -0.03877076f, 0.14688346f, 0.09852346f, -0.03911164f, 0.07584488f, -0.17245097f, 
    -0.00678612f, 0.16547406f, 0.06536416f, 0.09621349f, -0.23822002f, 0.06468442f, 0.05211369f, -0.12440807f, 
    0.07134405f, -0.16694084f, 0.03966989f, -0.01019264f, -0.12555738f, -0.09448769f, 0.08138169f, -0.00446732f, 
    0.03572803f, 0.02482566f, -0.14121346f, 0.26915637f, -0.27872530f, -0.11601082f, -0.22377872f, -0.21525034f, 
    0.02267314f, 0.08775007f, -0.05006446f, -0.12851091f, 0.01744620f, 0.08760763f, -0.07643856f, 0.08255160f, 
    -0.03535486f, 0.13886856f, 0.06765670f, 0.08108669f, -0.01192068f, 0.09680714f, -0.00039868f, -0.16199422f, 
    -0.07089929f, 0.04437609f, -0.01677013f, -0.08547423f, -0.00100725f, 0.10963866f, -0.15473878f, -0.05394576f, 
    0.08341173f, 0.12587641f, 0.07967917f, -0.00236955f, -0.06165913f, -0.06507791f, 0.06278675f, 0.17553893f, 
    0.09057833f, 0.08467215f, 0.04984925f, 0.02860209f, 0.00290613f, 0.03250584f, -0.01312408f, -0.14896974f, 
    0.31232023f, 0.12678672f, 0.34559086f, 0.31401893f, 0.11265688f, 0.20198587f, -0.13919820f, 0.17572476f, 
    0.05129749f, 0.10551082f, 0.01972077f, 0.04942373f, -0.05394953f, 0.02382312f, -0.06118394f, 0.14649498f, 
    0.00836945f, 0.18687141f, -0.05551006f, 0.02154938f, 0.29978636f, -0.09378678f, 0.04448616f, 0.06574412f, 
    0.10203063f, 0.12733994f, 0.01530916f, 0.05189062f, 0.06207877f, 0.20453924f, 0.03444342f, 0.00421038f, 
    0.09300224f, 0.24921967f, 0.08081250f, 0.14340885f, -0.09995785f, 0.05199231f, 0.11976458f, 0.07539249f, 
    -0.32604966f, -0.26037902f, 0.09778383f, 0.01314429f, -0.13250487f, 0.02180990f, 0.06010587f, -0.05522196f, 
    0.09896603f, 0.02521349f, 0.00120566f, 0.10146977f, -0.07409877f, 0.06395445f, 0.23835416f, 0.05285313f, 
    -0.08537067f, 0.09626773f, 0.02879287f, 0.08541845f, 0.20748976f, -0.13332824f, 0.15184653f, 0.18630642f, 
    0.00960884f, 0.06229451f, -0.10229237f, 0.02514306f, 0.09552855f, 0.23111391f, 0.01201569f, -0.04491234f, 
    -0.08885266f, -0.15417865f, -0.06921741f, -0.02093026f, 0.05565230f, -0.03304746f, 0.06791466f, 0.00334279f, 
    -0.30855700f, -0.10381486f, -0.09769182f, -0.04433865f, -0.04105902f, 0.03682940f, -0.00928744f, -0.07985415f, 
    -0.04705957f, -0.01901242f, 0.25789371f, 0.18935615f, 0.10088501f, 0.08206026f, 0.11132161f, -0.08830815f, 
    0.13477629f, -0.06877782f, -0.01296404f, -0.03034493f, -0.43934527f, -0.14229126f, -0.18068761f, -0.13006154f, 
    -0.01755975f, -0.06390425f, 0.02586399f, -0.16230309f, 0.00462636f, -0.12029230f, -0.14786831f, 0.14081416f, 
    0.13359548f, 0.14935340f, 0.20137459f, -0.10205877f, -0.04264865f, 0.11594837f, -0.00784579f, -0.08303680f, 
    -0.16253668f, -0.21563478f, 0.15192638f, 0.10376367f, 0.13891555f, -0.09887867f, -0.00308979f, 0.23018871f, 
    0.01812083f, 0.12226374f, 0.05595423f, 0.04551168f, 0.01853812f, 0.00183445f, -0.02595315f, 0.20057392f, 
    0.11000538f, 0.07159809f, 0.09817950f, -0.09645420f, 0.03296513f, -0.60666430f, 0.29291198f, -0.06619695f, 
    0.11944782f, 0.09597437f, 0.02489044f, -0.10611160f, 0.31156665f, -0.11653095f, -0.00734089f, 0.02771507f, 
    0.04287526f, -0.09211103f, 0.14484578f, 0.10052879f, 0.07159536f, -0.08638750f, 0.03874341f, 0.10852985f, 
    0.30082941f, -0.00713378f, 0.39419773f, 0.20190088f, 0.15763177f, 0.09877876f, -0.04089507f, 0.09432278f, 
    -0.00135112f, 0.22692209f, -0.05601910f, 0.05396765f, -0.01760575f, -0.08259794f, -0.04309286f, -0.01329691f, 
    0.04455651f, -0.05929585f, 0.04968291f, 0.12661044f, -0.15664354f, -0.01906434f, -0.01738178f, -0.02114148f, 
    -0.06515213f, -0.00314126f, 0.05382910f, 0.01091043f, -0.02368456f, 0.05608002f, 0.15618561f, -0.00270176f, 
    -0.00854927f, -0.14841197f, -0.14400117f, -0.03073774f, -0.04137439f, -0.02507933f, -0.03698823f, -0.01095349f, 
    -0.38324282f, 0.02450409f, -0.17087406f, 0.06588776f, -0.11285713f, 0.10541545f, 0.08665565f, 0.06541254f, 
    0.10413737f, 0.00013429f, 0.07105765f, 0.04051201f, 0.00236069f, 0.12177809f, -0.07797000f, -0.13542418f, 
    -0.04454427f, 0.06034799f, -0.10024167f, 0.01480088f, 0.53629333f, 0.92064261f, -0.53070712f, 0.33348644f, 
    0.41791022f, -0.04826049f, 0.02574655f, 0.00443011f, 0.08964442f, -0.04508240f, 0.10859349f, 0.00130502f, 
    -0.01708464f, -0.03967291f, 0.18229605f, -0.00674568f, -0.03612642f, 0.38744351f, 0.14643060f, 0.00823606f, 
    -0.09398609f, -0.06745734f, 0.22335368f, 0.25640672f, 0.06702589f, -0.02187570f, 0.11259766f, 0.02691534f, 
    0.23171073f, 0.09122991f, -0.03662917f, 0.01469751f, -0.02020660f, 0.03536999f, 0.00228737f, 0.22682083f, 
    0.05084480f, 0.01128345f, 0.25666499f, 0.11942165f, -0.21771577f, -0.23698071f, -0.01727257f, 0.02459557f, 
    -0.16605787f, 0.09649027f, 0.06044204f, -0.03628506f, 0.20639178f, 0.29025736f, 0.01578291f, -0.07979710f, 
    -0.07296232f, 0.04870947f, -0.13533318f, -0.07065947f, -0.09083503f, 0.03113459f, -0.02758602f, -0.01162639f, 
    0.22113578f, -0.11973196f, 0.04206033f, 0.13489057f, 0.00185966f, 0.23139995f, -0.06965345f, 0.06500006f, 
    0.21816565f, -0.16520524f, -0.04099895f, -0.04714766f, -0.02196515f, -0.05806754f, 0.05875941f, 0.07381264f, 
    0.07346388f, -0.03816551f, -0.06063219f, 0.13683067f, -0.35008633f, -0.30016044f, -0.03409949f, 0.06978837f, 
    0.05324255f, -0.07533824f, -0.08301118f, 0.02785031f, -0.00752849f, 0.02273700f, 0.02697616f, 0.01419611f, 
    0.09576841f, 0.22048832f, 0.11373571f, 0.22542329f, 0.23025772f, 0.09563813f, 0.11224376f, 0.15000248f, 
    -0.20190969f, -0.20303391f, 0.05590472f, 0.28623992f, 0.02885000f, 0.11874311f, -0.08805524f, -0.03956687f, 
    -0.03407112f, 0.10707605f, 0.01167869f, -0.05955082f, -0.06536571f, -0.12115338f, -0.06544706f, -0.04205422f, 
    0.07663354f, 0.06008851f, -0.00544895f, 0.04105582f, 0.50834656f, 0.06733617f, 0.02562428f, 0.23951283f, 
    0.09981858f, 0.04224973f, 0.24060550f, -0.07002261f, 0.16240947f, 0.02743479f, -0.07090177f, 0.05758149f, 
    0.00916667f, -0.12542814f, -0.03624744f, 0.14487635f, 0.05481027f, 0.14533253f, -0.08285581f, 0.13627695f, 
    0.15994503f, -0.02701030f, 0.22624251f, 0.08367388f, 0.05858908f, 0.05177191f, -0.03766701f, 0.07147107f, 
    -0.05526121f, 0.21295318f, 0.01874996f, 0.00752039f, 0.02848529f, -0.02559527f, -0.00368106f, 0.02919831f, 
    0.01213683f, -0.01949402f, 0.10926776f, 0.11470967f, 0.12555602f, 0.05567157f, 0.05421245f, 0.05527264f, 
    -0.18245016f, 0.16273837f, -0.00062796f, -0.18168640f, 0.07607875f, -0.08841968f, -0.14392370f, 0.05100511f, 
    0.10905462f, -0.00412734f, 0.16801833f, 0.12989506f, 0.11736291f, -0.00759913f, -0.07088452f, -0.03220627f, 
    0.12709494f, -0.07638988f, -0.11805459f, 0.09234676f, -0.09411719f, -0.13402316f, -0.08056444f, -0.22853892f, 
    0.03082248f, -0.06089763f, 0.06550781f, 0.07554099f, -0.14033650f, 0.00588198f, 0.03280689f, 0.16259912f, 
    -0.02564598f, 0.12776713f, 0.02131800f, -0.02747408f, 0.24986166f, 0.01822009f, 0.32849377f, 0.37823674f, 
    -0.08424912f, 0.01813563f, 0.00281635f, 0.21358863f, 0.07782484f, 0.12711576f, 0.02284636f, 0.07382755f, 
    -0.01133978f, -0.01555429f, -0.01214234f, 0.15856288f, 0.09198638f, 0.06300490f, -0.01602641f, 0.04227589f, 
    0.08532647f, 0.32928890f, 0.08105613f, 0.15628095f, -0.10487324f, 0.11400068f, -0.08663034f, 0.13242866f, 
    -0.14630151f, -0.17604892f, -0.07938706f, 0.00010671f, -0.02923495f, -0.10894526f, 0.15412492f, -0.02360858f, 
    0.04509966f, 0.07049492f, -0.12168642f, 0.14889650f, 0.33502927f, -0.02162530f, 0.21536900f, 0.22812279f, 
    0.16699329f, -0.00242576f, -0.03668341f, 0.10276512f, 0.23605248f, 0.06064151f, 0.03213647f, 0.07561951f, 
    0.08841302f, -0.00920808f, 0.05476645f, 0.09927106f, 0.10636371f, 0.01305781f, 0.14674947f, -0.01362056f, 
    0.14344177f, 0.19304205f, 0.17545526f, -0.06003948f, 0.08463189f, -0.08536298f, -0.25085014f, 0.08365337f, 
    -0.05489281f, 0.00744373f, 0.04106849f, -0.00381100f, -0.11469720f, -0.11174262f, 0.00399848f, -0.01923551f, 
    0.00974909f, -0.00821489f, 0.05756619f, -0.03396422f, 0.16354260f, -0.16675082f, 0.05781596f, -0.03894019f, 
    -0.07960621f, 0.14102629f, -0.01680430f, 0.09071466f, 0.19527784f, 0.03667078f, 0.06819852f, 0.02148712f, 
    0.11029909f, 0.18101422f, 0.15005937f, 0.10808714f, 0.22008255f, 0.04690785f, 0.07253497f, 0.16258049f, 
    0.05266719f, -0.17147380f, 0.26499009f, 0.31884184f, 0.18960272f, 0.01779709f, 0.01736742f, -0.03260485f, 
    -0.00346569f, 0.01543666f, -0.02573286f, 0.00801304f, -0.10617603f, -0.09429903f, -0.07695960f, 0.02079812f, 
    0.05961265f, -0.06473766f, -0.02901225f, 0.12769274f, -0.21612154f, -0.19456193f, 0.08894750f, -0.02918559f, 
    -0.08182204f, 0.05090345f, 0.04484307f, -0.01428241f, -0.03406569f, -0.02188415f, -0.08746610f, -0.15165082f, 
    -0.04505844f, -0.00522196f, 0.01014702f, 0.06545512f, 0.17371464f, 0.01505175f, 0.03142313f, -0.09531467f, 
    -0.67583621f, -0.52952427f, -0.22711793f, -0.23783252f, 0.10880143f, 0.15379672f, 0.07965983f, -0.11611106f, 
    0.14119381f, -0.15449300f, -0.21841197f, 0.02679184f, 0.24794710f, 0.09239689f, 0.11956915f, -0.08978233f, 
    -0.10465492f, 0.02391629f, -0.01677145f, 0.10270315f, -0.06349926f, -0.11988006f, -0.05984714f, 0.11313577f, 
    -0.04688234f, -0.07216834f, 0.07562738f, -0.08020120f, -0.03934608f, -0.05876549f, 0.19409734f, 0.08808695f, 
    0.15714078f, 0.11168379f, 0.08985564f, 0.17953280f, -0.02542637f, -0.01395375f, -0.10184366f, 0.01284872f, 
    -0.18609151f, -0.21215402f, -0.06092482f, -0.12134725f, -0.04612781f, -0.06423704f, 0.11022249f, -0.08126818f, 
    0.00378863f, 0.01122043f, 0.06015899f, 0.17385700f, 0.06550055f, 0.12649666f, 0.11838650f, 0.00381469f, 
    -0.00858142f, 0.18625154f, -0.06532583f, 0.00549959f, -0.28131625f, -0.09426554f, -0.12168005f, -0.08760808f, 
    0.06726954f, 0.06269507f, -0.04081630f, 0.02330428f, 0.05507924f, -0.11301430f, -0.07925168f, 0.12065244f, 
    0.02863118f, 0.17931426f, 0.23795889f, 0.06446162f, 0.09825550f, 0.04059543f, -0.02864666f, -0.07769548f, 
    0.02313923f, -0.01700500f, -0.00756588f, 0.01308953f, 0.00178670f, -0.02173874f, 0.00108066f, -0.03448387f, 
    0.03891673f, 0.00403085f, 0.00949512f, 0.03394592f, -0.03854607f, 0.01765900f, -0.02104287f, 0.01096928f, 
    0.00740510f, -0.01465648f, 0.01676392f, -0.02192676f, 0.02146691f, -0.02910717f, -0.00306421f, 0.01323184f, 
    0.00156542f, -0.00392429f, 0.00773973f, 0.01580124f, -0.00133879f, -0.00942419f, 0.01875895f, 0.02194471f, 
    0.03099113f, 0.00420151f, 0.02968609f, 0.00243918f, -0.03197052f, -0.01388993f, 0.02405734f, 0.01505051f, 
    0.00448503f, 0.00380880f, 0.02842441f, 0.00371285f, 0.01772397f, -0.01760321f, 0.01774427f, -0.03144368f, 
    0.02340577f, 0.01126299f, 0.02616355f, 0.01942645f, 0.00024989f, -0.01416774f, -0.00091483f, -0.04169983f, 
    0.01281512f, -0.03752917f, 0.02962991f, 0.03688733f, -0.02874803f, 0.03822529f, -0.04434293f, 0.01287208f, 
    0.00376816f, -0.02399687f, -0.01632744f, 0.03267661f, 0.02577632f, -0.02707723f, -0.01626397f, -0.02860644f, 
    0.02867730f, -0.00374811f, 0.02041699f, 0.02299476f, 0.00936531f, 0.02542187f, 0.02686422f, -0.01704434f, 
    -0.01318345f, 0.02717330f, -0.04348823f, 0.00813038f, -0.00821277f, -0.03066532f, 0.02441047f, -0.01404638f, 
    -0.01721410f, -0.00995382f, -0.03093966f, -0.03127519f, 0.00485474f, -0.01916633f, 0.03587128f, 0.00546432f, 
    0.02228016f, -0.01996429f, -0.01053267f, -0.01883097f, -0.03673970f, 0.02510318f, -0.01660711f, -0.02260363f, 
    0.02111656f, -0.00198271f, -0.02767452f, 0.03755928f, 0.01686738f, 0.01618262f, 0.02251966f, 0.02588643f, 
    -0.02409617f, -0.01759245f, 0.04525541f, 0.02658406f, -0.03982446f, -0.02856760f, -0.04311016f, -0.04080465f, 
    0.02466671f, 0.00725846f, -0.01438226f, 0.01806268f, -0.00480492f, 0.00842080f, 0.00128859f, 0.01625847f, 
    0.00608207f, -0.03652905f, -0.03576824f, -0.02041473f, -0.01992652f, 0.00858903f, -0.01537737f, -0.03009372f, 
    -0.00130411f, -0.00920697f, 0.00168201f, 0.01262857f, -0.01693598f, 0.01344386f, -0.04700531f, 0.00725000f, 
    -0.02788830f, -0.01243842f, 0.02459659f, 0.01934652f, 0.01415028f, -0.03633858f, -0.01966579f, 0.03246121f, 
    0.01569448f, -0.00511295f, -0.02423869f, 0.01579911f, -0.02778523f, -0.04335052f, 0.01600919f, -0.02166518f, 
    -0.00735910f, -0.03652544f, 0.00438948f, -0.00633461f, -0.03707483f, -0.00690651f, -0.02063424f, 0.01405703f, 
    -0.02964079f, 0.02076430f, -0.03725219f, -0.03664655f, -0.00470015f, 0.01458275f, -0.02694862f, 0.00538337f, 
    -0.03292081f, 0.02817726f, -0.00185458f, -0.01225118f, 0.02098469f, 0.01268201f, -0.02885754f, 0.02820041f, 
    0.00762573f, -0.02896358f, 0.00536319f, -0.02049664f, 0.00345125f, -0.02879402f, -0.04329748f, -0.02447785f, 
    -0.05139167f, -0.04039275f, 0.03380863f, -0.02204687f, -0.00056205f, 0.03402205f, 0.00351112f, -0.00021222f, 
    -0.01382844f, 0.03454218f, 0.01442161f, 0.03387299f, 0.02953309f, 0.00622827f, -0.00824895f, 0.01692182f, 
    0.01379663f, 0.00296970f, -0.02543108f, -0.00620243f, -0.00650409f, -0.00751719f, 0.00595621f, -0.01874535f, 
    0.00893740f, 0.01389912f, -0.00341611f, 0.03311572f, 0.02323614f, 0.03924209f, 0.01330811f, 0.02031950f, 
    0.02342896f, -0.02442998f, 0.01793235f, -0.01453132f, 0.00051212f, 0.03174331f, -0.03663899f, -0.03846094f, 
    -0.00851518f, 0.01964727f, -0.02363732f, 0.00422797f, 0.03692744f, -0.01753546f, 0.02408826f, 0.02365914f, 
    -0.02312395f, -0.01922926f, 0.00823291f, -0.02536847f, -0.01591068f, -0.04006307f, -0.01274829f, -0.01267258f, 
    -0.00509404f, -0.02066424f, 0.01509287f, -0.03496142f, 0.02728945f, -0.00245181f, 0.01350631f, 0.01249122f, 
    -0.01477620f, -0.02169695f, -0.02391862f, -0.01763841f, 0.01327101f, 0.01872666f, -0.02659975f, 0.00606091f, 
    -0.01739947f, 0.02349737f, 0.01816036f, 0.02751292f, 0.00561461f, 0.04233843f, -0.04136214f, 0.02745154f, 
    -0.04413123f, -0.03946828f, -0.03178212f, -0.01255978f, -0.02001538f, 0.01766247f, 0.01093003f, 0.02609337f, 
    -0.03411721f, -0.03060295f, -0.01179937f, -0.01022241f, 0.01501282f, -0.02905460f, -0.04433499f, 0.01948893f, 
    -0.03723899f, 0.01795644f, 0.00265109f, -0.00374993f, -0.02713231f, 0.00088543f, -0.00851251f, -0.01990603f, 
    0.02829485f, 0.01932206f, -0.00748002f, 0.02068054f, -0.01757583f, 0.03125761f, 0.03213987f, 0.02659909f, 
    0.00130584f, -0.00870216f, 0.01192648f, 0.04224886f, 0.03103779f, -0.00708410f, 0.03486750f, -0.01726948f, 
    -0.00833809f, 0.02775692f, -0.01716341f, -0.01334230f, -0.00158057f, 0.00943869f, -0.00799305f, -0.01933632f, 
    0.01866408f, 0.01494830f, 0.01532047f, 0.00055371f, 0.02615614f, 0.02330119f, -0.02960586f, 0.01222222f, 
    -0.02992678f, 0.03350499f, 0.01498318f, -0.00839429f, -0.02928113f, 0.02866596f, 0.01139519f, 0.01036370f, 
    -0.00093075f, -0.01009056f, -0.02729558f, 0.02785483f, 0.01707075f, -0.01457996f, -0.00463712f, -0.00556125f, 
    -0.04183450f, 0.02576776f, 0.00688505f, 0.01653422f, 0.01190479f, -0.03342688f, 0.01399983f, -0.01366499f, 
    -0.00785873f, 0.00070869f, 0.00853027f, -0.04155554f, -0.03173457f, -0.03975769f, -0.03555606f, -0.02833767f, 
    -0.01865703f, -0.02242059f, -0.03346401f, 0.01882487f, -0.01556371f, -0.02811111f, -0.00189824f, -0.03324667f, 
    -0.00708765f, -0.03902505f, 0.02017773f, -0.01650793f, -0.01178078f, 0.03136211f, 0.00948718f, -0.00849684f, 
    0.00394725f, -0.00090466f, 0.01806381f, 0.01849567f, 0.01915145f, 0.02920917f, -0.01045905f, -0.03332940f, 
    0.01231099f, -0.02605564f, 0.02518195f, -0.04447883f, -0.01590419f, -0.02704649f, -0.01242806f, 0.03482665f, 
    0.00834265f, -0.01481351f, 0.01239461f, 0.00876793f, 0.03396130f, 0.02085908f, -0.01401906f, -0.01042192f, 
    -0.00553713f, -0.02176179f, -0.03519997f, -0.00770062f, -0.01370273f, -0.03013654f, -0.01786321f, -0.00013796f, 
    -0.02256409f, 0.00018429f, -0.01231284f, -0.02680122f, -0.04807124f, -0.01538587f, -0.03491771f, 0.00112902f, 
    0.03744593f, -0.01452471f, -0.02503193f, -0.00733360f, -0.03084442f, -0.01915932f, -0.02595407f, -0.01035871f, 
    -0.04151951f, 0.03896537f, 0.02460082f, -0.00641877f, -0.02441605f, 0.00229048f, -0.03409627f, 0.03329577f, 
    0.00102364f, 0.01295744f, -0.03337855f, -0.02528904f, -0.02251212f, -0.02252650f, -0.00383175f, 0.02623211f, 
    0.00358540f, -0.03526368f, 0.01660825f, -0.00362423f, -0.00977756f, -0.00018020f, 0.03106860f, 0.03338430f, 
    -0.01993759f, -0.03695747f, -0.02108939f, -0.02675902f, -0.01015706f, 0.01155977f, -0.00607345f, 0.01101836f, 
    -0.03220738f, 0.02414985f, 0.02814565f, -0.02746062f, -0.01126137f, -0.00457355f, -0.00338832f, 0.03989620f, 
    0.02447815f, 0.00005131f, 0.03194270f, 0.01816127f, 0.00268322f, -0.03347424f, 0.01558853f, 0.02608762f, 
    0.01284811f, 0.03322039f, -0.03677705f, 0.02469555f, -0.03226967f, 0.03085016f, -0.03629700f, -0.04185810f, 
    -0.00890059f, -0.00462568f, -0.01412647f, 0.00727083f, -0.01050968f, -0.01638542f, -0.03747044f, -0.02286742f, 
    0.03744082f, -0.04461548f, -0.04764498f, -0.04693714f, -0.01226040f, 0.02651205f, -0.01790011f, -0.02330695f, 
    0.01809963f, 0.02975904f, 0.02839639f, -0.01263189f, 0.00741856f, 0.01657501f, 0.01966679f, -0.02153045f, 
    0.03011149f, 0.03604563f, -0.01428719f, 0.02319248f, 0.00919745f, -0.04053067f, -0.01460954f, -0.02030043f, 
    -0.01618238f, -0.00049418f, 0.03135502f, -0.00844208f, 0.03031959f, -0.00944877f, -0.02387847f, -0.01386208f, 
    0.01660006f, 0.00164233f, -0.01172255f, -0.02621090f, 0.02009827f, -0.04528186f, -0.00109605f, -0.03952007f, 
    0.01092793f, -0.03757376f, -0.03544590f, 0.03194273f, -0.00514081f, -0.04222955f, 0.00205671f, -0.02372326f, 
    -0.01275413f, -0.01803022f, 0.01840323f, -0.01060894f, -0.00778460f, -0.00105495f, 0.02047085f, -0.03795883f, 
    -0.03632584f, -0.02535894f, -0.00842286f, 0.02754489f, -0.02461755f, 0.00860623f, -0.03881974f, 0.00965659f, 
    -0.02463964f, -0.00997830f, -0.02367354f, 0.03175736f, -0.00017633f, 0.00098178f, 0.02022962f, -0.01284161f, 
    -0.01192206f, 0.03990778f, -0.01895849f, -0.02964306f, -0.00209202f, -0.03186269f, -0.02812044f, -0.02804903f, 
    -0.02227063f, -0.01730596f, -0.01034061f, 0.02781067f, 0.02652717f, 0.04349521f, 0.02641162f, -0.04022500f, 
    -0.02946186f, 0.02139851f, -0.01957816f, 0.03529509f, -0.03327108f, 0.00095144f, -0.02921340f, 0.02293035f, 
    -0.04053033f, -0.04314442f, 0.00998759f, -0.01328915f, -0.02206356f, -0.00917818f, -0.02411616f, -0.02983321f, 
    -0.00161528f, -0.01102183f, 0.02363155f, -0.00817676f, -0.01168559f, 0.01907888f, -0.04390959f, 0.01373449f, 
    -0.03911916f, -0.00134385f, -0.04830066f, -0.04019422f, -0.02960529f, 0.01074152f, 0.01831767f, -0.03663612f, 
    0.00676580f, -0.04113907f, -0.04559577f, 0.00989971f, -0.00736955f, 0.02964153f, -0.02210042f, -0.01312537f, 
    -0.00205259f, 0.00253061f, 0.01112464f, 0.00561872f, -0.04249424f, -0.00333652f, 0.01102346f, -0.00214144f, 
    0.00154929f, 0.02697193f, 0.00643353f, -0.01233421f, -0.00714011f, -0.00346485f, 0.00998518f, -0.02550079f, 
    -0.03764714f, -0.00071280f, 0.02400454f, -0.00722475f, -0.01950288f, 0.02908229f, -0.00173941f, -0.03758472f, 
    -0.28513202f, 0.19999856f, 0.13003001f, -0.10944960f, 0.14558417f, -0.03561547f, 0.16853137f, 0.04673087f, 
    -0.03057365f, 0.12593593f, -0.04151038f, -0.06921957f, 0.00135484f, 0.03115508f, -0.02391239f, -0.05244310f, 
    -0.06388817f, 0.20934527f, 0.24801525f, -0.00036883f, -0.52751303f, 0.07118024f, -0.11213711f, 0.00042380f, 
    -0.07550201f, -0.40663433f, -0.13536872f, 0.23299888f, -0.02636922f, -0.04159502f, -0.08847256f, -0.05905908f, 
    -0.01061076f, -0.00643722f, -0.07578097f, -0.26156449f, -0.13225909f, -0.25201401f, -0.26752385f, -0.09508071f, 
    0.24308999f, 0.11675435f, 0.22636144f, 0.00019151f, 0.14532682f, 0.05906014f, 0.05568460f, -0.07851976f, 
    0.07669980f, 0.04785008f, 0.02340465f, 0.18901508f, 0.08141407f, 0.10094040f, -0.12432506f, -0.10309655f, 
    -0.07110995f, 0.02269166f, -0.02921535f, 0.22371806f, 0.16944960f, 0.34623042f, 0.14562194f, -0.10064787f, 
    -0.06973889f, -0.00691258f, 0.18394431f, 0.16703461f, -0.07756280f, -0.02394903f, -0.07739174f, -0.05819463f, 
    -0.02302437f, 0.01219512f, -0.03331264f, -0.05261264f, -0.05497346f, -0.01914411f, -0.02163005f, 0.05890899f, 
    0.06310488f, -0.05138225f, 0.02456099f, 0.10983612f, 0.13210893f, -0.01678103f, -0.05840169f, -0.04430885f, 
    0.05361019f, 0.06161482f, -0.06574206f, -0.08643360f, -0.10620930f, -0.12870756f, -0.19915806f, -0.13222302f, 
    -0.10491201f, -0.02954588f, 0.02828033f, 0.05334699f, 0.30151772f, 0.02365680f, 0.12503535f, 0.00561584f, 
    0.10630319f, 0.05205427f, 0.04477923f, 0.04159172f, 0.06019439f, 0.03025362f, 0.26154184f, 0.04005653f, 
    -0.12404452f, -0.18529463f, -0.14018348f, -0.24097539f, -0.11517660f, -0.11771268f, 0.02859890f, -0.05332741f, 
    -0.45340717f, -0.21894827f, -0.42109221f, -0.29570717f, -0.25650671f, 0.33519337f, 0.26007342f, -0.04151618f, 
    0.17611748f, 0.17948784f, -0.03101446f, 0.00865417f, 0.01644950f, -0.06466243f, 0.03327111f, -0.07634434f, 
    -0.09011556f, 0.11801220f, 0.03954005f, 0.34603411f, 0.27500015f, 0.27714536f, 0.04523867f, -0.05645490f, 
    0.11236537f, 0.13609745f, -0.09038182f, -0.02044923f, 0.02836029f, 0.08580633f, 0.04491398f, 0.17445202f, 
    -0.12242708f, 0.16543864f, 0.01534933f, 0.01222835f, 0.11729842f, 0.00143283f, -0.09048162f, 0.09545720f, 
    0.22636619f, 0.33311531f, 0.05613509f, -0.27092525f, -0.00499411f, 0.06194670f, 0.16667402f, -0.12345479f, 
    -0.03357984f, 0.11232464f, -0.00224025f, -0.09343959f, 0.01762465f, -0.00369307f, -0.05334314f, -0.10609978f, 
    -0.05403079f, 0.07790038f, -0.00288498f, 0.09579189f, -0.07850634f, -0.03128573f, -0.07538405f, -0.01604893f, 
    0.08011407f, 0.01437956f, 0.05371901f, 0.06290489f, 0.07514942f, 0.00944844f, -0.08301941f, -0.00361319f, 
    -0.21589392f, -0.02343460f, -0.03792926f, -0.06789915f, 0.02480111f, 0.04971291f, 0.04146296f, 0.00525608f, 
    -0.27911898f, -0.34636730f, 0.08068910f, -0.10808358f, 0.22146747f, 0.02975113f, 0.02943425f, 0.20085829f, 
    0.14889486f, -0.06091225f, -0.06088682f, -0.04824264f, -0.02506638f, 0.00232921f, -0.11572144f, -0.06086585f, 
    0.03811422f, 0.06090194f, 0.05274287f, -0.01118193f, 0.09054402f, -0.09152089f, 0.19789517f, -0.56138694f, 
    -0.29465532f, -0.07898453f, -0.09729016f, 0.16020705f, -0.03632699f, -0.03621143f, -0.02431018f, 0.01828256f, 
    0.12588824f, 0.02572751f, -0.16163497f, -0.16244721f, -0.04558222f, -0.17347103f, 0.11513802f, -0.23462014f, 
    0.77015531f, 0.51225823f, -0.19895341f, -0.35307541f, -0.12221787f, -0.01877864f, 0.01890404f, -0.11806317f, 
    0.00656639f, -0.11751353f, 0.11047112f, -0.07199864f, 0.04783867f, -0.09893183f, -0.30828217f, -0.05413009f, 
    0.02001011f, 0.10233313f, -0.10012124f, 0.32034859f, -0.38018024f, -0.11654482f, -0.02900410f, -0.00564321f, 
    0.22511898f, -0.02283115f, 0.13368288f, 0.21515039f, -0.37444454f, -0.02008368f, -0.05954288f, -0.20645440f, 
    -0.00218656f, -0.10111605f, -0.08166346f, -0.07856120f, -0.00489445f, -0.00659549f, 0.03384093f, -0.02590009f, 
    -0.07358076f, 0.02614153f, 0.09483674f, 0.09837460f, 0.06837592f, 0.01940828f, -0.09955965f, 0.10833927f, 
    -0.08454388f, 0.19864717f, 0.02527254f, 0.11644084f, -0.02414421f, 0.12601848f, 0.12257369f, 0.05881754f, 
    0.07970420f, 0.13156927f, 0.04204918f, 0.01928660f, -0.13075571f, -0.19030517f, -0.11098581f, -0.07210255f, 
    0.10418192f, -0.05074497f, -0.12840934f, 0.04879833f, 0.05742700f, 0.25535333f, -0.07712764f, -0.06896059f, 
    0.03425413f, -0.05172701f, -0.04849197f, -0.10268735f, -0.05500283f, -0.00831665f, -0.15546481f, 0.09959096f, 
    0.03794610f, 0.03647352f, -0.18516369f, -0.29292408f, -0.37585905f, -0.25373411f, -0.02623118f, 0.02581598f, 
    -0.02650161f, -0.08346945f, -0.10043512f, -0.06356940f, -0.09994619f, -0.03453131f, -0.08683494f, -0.02218533f, 
    -0.00437373f, -0.01050001f, 0.07565849f, 0.08525578f, -0.04602616f, 0.06344305f, 0.26592666f, 0.01261942f, 
    0.31827581f, -0.05532108f, -0.13111494f, -0.01449359f, -0.14931700f, 0.03897779f, -0.00185463f, 0.03529002f, 
    0.05165198f, 0.06995019f, -0.01279942f, 0.13570191f, 0.02870798f, 0.02213238f, -0.03971389f, -0.16508420f, 
    -0.06718197f, 0.03155794f, -0.26285866f, -0.47653902f, -0.45531538f, 0.15970677f, 0.17615587f, -0.01691344f, 
    0.02490462f, 0.03282177f, -0.02507916f, -0.08030059f, -0.05071100f, -0.01329560f, -0.03141034f, -0.08309098f, 
    -0.01420362f, 0.08710952f, -0.15619797f, 0.11282510f, -0.13695931f, -0.03773985f, 0.14406759f, 0.11260207f, 
    0.15314569f, -0.10900250f, -0.09640356f, 0.09241062f, -0.02275460f, 0.16801363f, 0.04246370f, -0.06038622f, 
    -0.05046692f, 0.11660511f, -0.12672344f, -0.11985442f, -0.17999113f, 0.04345148f, -0.05301576f, -0.00710774f, 
    -0.10629321f, -0.15280464f, 0.18168840f, 0.02666505f, 0.11294705f, 0.21975833f, -0.22493684f, 0.04516771f, 
    0.10184955f, -0.09999181f, -0.03506140f, -0.16290611f, -0.02185835f, 0.16820265f, -0.17041247f, -0.00730421f, 
    0.01785208f, -0.07417967f, 0.08268860f, 0.13584793f, -0.15447104f, 0.16418162f, -0.06731388f, -0.23200057f, 
    0.12187468f, 0.06395689f, -0.02032263f, -0.10437948f, -0.04118903f, 0.03082884f, -0.01104408f, -0.11385203f, 
    -0.00899118f, -0.00347915f, 0.05469508f, -0.01750950f, -0.18021961f, -0.01863268f, 0.08778670f, 0.06976970f, 
    0.03749836f, -0.00635195f, 0.12113103f, -0.01555454f, 0.21023598f, -0.04080315f, 0.10901098f, -0.09848803f, 
    0.09136111f, 0.06711838f, 0.02133984f, -0.11947618f, -0.01295827f, 0.03665056f, -0.01248949f, -0.09810732f, 
    -0.01639974f, 0.20527118f, -0.09678282f, -0.24470007f, -0.18608811f, 0.26001385f, -0.17227286f, -0.29471463f, 
    -0.20507000f, 0.01019929f, 0.42208654f, 0.13057655f, 0.12696016f, 0.40228370f, -0.05764038f, -0.04237302f, 
    0.05309300f, 0.00454521f, -0.10064052f, -0.08152425f, -0.04593199f, 0.10765064f, -0.14128648f, 0.32732874f, 
    -0.04403245f, 0.12706546f, 0.04142342f, -0.19799791f, 0.02769175f, 0.02480597f, 0.21596634f, 0.10723475f, 
    0.11414064f, 0.10847807f, 0.02086639f, 0.07183520f, -0.10752394f, -0.01219570f, 0.02224602f, -0.11096679f, 
    0.00670095f, 0.00811869f, 0.18976685f, 0.09268180f, -0.32973391f, 0.08781150f, -0.09111074f, -0.26331758f, 
    -0.19324212f, -0.24217896f, -0.10920309f, 0.03828677f, -0.13864826f, 0.16247217f, -0.08119585f, 0.01484098f, 
    0.03464009f, -0.10845578f, -0.01525502f, -0.10032281f, -0.15697059f, -0.23032860f, 0.05001976f, 0.12347560f, 
    0.22027196f, 0.44153503f, 0.24860628f, 0.08587299f, 0.42294475f, -0.11400182f, -0.06896211f, 0.00029888f, 
    0.06537922f, 0.03987201f, 0.07773481f, 0.08078661f, 0.13495390f, 0.04401715f, 0.05116552f, 0.01369887f, 
    -0.07271569f, -0.08009227f, 0.15923694f, -0.23721603f, 0.06191659f, 0.00240512f, 0.05108147f, 0.17938131f, 
    0.24477690f, -0.03258101f, 0.00094743f, 0.05047119f, 0.05965146f, 0.04014746f, 0.10505749f, 0.09543710f, 
    0.04860784f, 0.04568559f, 0.16110493f, -0.16030701f, -0.30938652f, -0.21262996f, -0.03234275f, 0.00235438f, 
    0.62959522f, 0.07702901f, 0.14409760f, 0.07391637f, 0.22388339f, 0.16422009f, -0.14010410f, -0.00625532f, 
    -0.13648400f, -0.02673568f, 0.15323962f, -0.23708701f, -0.02408372f, -0.06982484f, -0.15166289f, -0.12048944f, 
    0.05226219f, -0.02654008f, -0.00889097f, -0.10403352f, 0.06394063f, -0.04630831f, 0.08709636f, 0.04519856f, 
    0.10211863f, 0.11204670f, -0.09017515f, 0.02727507f, 0.00669814f, -0.00983795f, -0.01099837f, 0.04706790f, 
    -0.05808165f, -0.04646343f, -0.11336038f, 0.03670298f, -0.10151169f, 0.03364661f, 0.02989634f, 0.06601086f, 
    0.05256291f, -0.06300939f, 0.06108154f, 0.14693028f, 0.12139805f, 0.03394454f, 0.00976310f, 0.02186020f, 
    0.02891123f, 0.08087240f, 0.00098784f, -0.05661170f, -0.02755110f, -0.02911747f, 0.03154604f, -0.16364937f, 
    -0.12021319f, -0.16930464f, 0.09161744f, 0.02990432f, 0.11822335f, -0.05267094f, 0.10563862f, 0.15641531f, 
    0.17772788f, 0.06583984f, 0.03389393f, 0.03384450f, -0.00469027f, 0.10415306f, 0.07283442f, -0.07891254f, 
    -0.07167193f, -0.06676602f, -0.01679821f, -0.25152874f, -0.14461742f, 0.01445859f, 0.01233260f, 0.02989646f, 
    0.16136937f, 0.29498938f, -0.53862470f, 0.47038534f, -0.02595793f, 0.14863485f, 0.16854887f, 0.15464884f, 
    -0.17099988f, 0.13860758f, 0.13426647f, -0.18462975f, 0.06264215f, -0.02646825f, -0.04480182f, 0.15130612f, 
    0.16673028f, 0.07296108f, 0.08981913f, 0.09602322f, 0.40261167f, -0.55726725f, -0.11350264f, 0.06197597f, 
    -0.23182981f, -0.07995519f, -0.22413525f, -0.00416086f, 0.01621226f, 0.01444918f, 0.29321009f, -0.09549783f, 
    -0.06936638f, 0.00547952f, 0.10631280f, 0.06263933f, 0.21052660f, 0.05398454f, -0.05525306f, 0.15920480f, 
    0.05884963f, -0.21550798f, -0.05191405f, 0.07712355f, -0.09632766f, 0.03711274f, -0.10837828f, 0.02475091f, 
    -0.04454343f, -0.01620123f, -0.09881326f, 0.04966076f, 0.06431365f, 0.09761406f, 0.02094822f, -0.09630597f, 
    -0.06327315f, 0.07781999f, -0.26146647f, -0.01231303f, 0.22778423f, 0.09308542f, 0.24484706f, 0.15280204f, 
    -0.01944130f, 0.12121982f, -0.14332011f, 0.02623738f, 0.03805280f, 0.05996248f, 0.04938318f, -0.04415789f, 
    -0.03274875f, -0.06917216f, -0.00232138f, 0.02702876f, -0.06008440f, -0.15296540f, 0.08034906f, -0.06247336f, 
    0.18619235f, 0.16539940f, -0.08890841f, -0.10991996f, -0.14431208f, -0.10766343f, 0.11772845f, 0.00362481f, 
    0.18704322f, -0.13116744f, 0.13504612f, 0.02836309f, 0.01544846f, -0.01247962f, 0.05322675f, 0.06201877f, 
    -0.16944003f, -0.30138984f, -0.12248649f, -0.20274283f, 0.02345796f, 0.03269874f, 0.17251232f, -0.13619345f, 
    0.04548165f, -0.07894305f, -0.21359423f, 0.01529399f, 0.01169584f, -0.05246965f, -0.00960895f, 0.11014824f, 
    -0.02504296f, -0.02680207f, 0.02306013f, 0.09162743f, 0.03951017f, 0.05737965f, 0.03789306f, 0.15113792f, 
    0.05056005f, -0.01112310f, 0.22784406f, 0.08734433f, 0.07369158f, -0.18696807f, 0.11983322f, -0.01864143f, 
    0.02514610f, 0.32859236f, -0.05195251f, -0.06555333f, -0.02234834f, 0.11124337f, -0.01959289f, 0.09074450f, 
    0.19072871f, 0.14202361f, 0.19478229f, 0.09443568f, -0.14224467f, -0.34796023f, -0.04105130f, -0.43957359f, 
    0.08797123f, 0.07546405f, -0.00333915f, 0.25443357f, -0.04257267f, -0.27060828f, -0.13170660f, -0.02484295f, 
    -0.02298326f, -0.07435825f, 0.17112583f, 0.10013977f, 0.04775696f, -0.27388117f, -0.08356879f, 0.02418034f, 
    0.09246287f, 0.13142781f, 0.30506855f, -0.00473984f, 0.12591042f, 0.05691136f, 0.03020524f, 0.03101777f, 
    0.03072885f, 0.17916462f, -0.02230175f, 0.02116616f, -0.03140243f, -0.15777762f, -0.06214761f, -0.12554707f, 
    0.03271731f, -0.07585790f, 0.03293735f, -0.16172166f, 0.81248426f, 0.14168416f, 0.20960689f, 0.26503614f, 
    -0.01536887f, -0.11983571f, -0.20777918f, -0.25307027f, -0.00324725f, -0.17783909f, 0.17592357f, -0.02331392f, 
    -0.05325994f, -0.01773664f, 0.09779204f, -0.03453336f, -0.16204797f, -0.00605527f, -0.02411862f, -0.12063474f, 
    0.36257029f, 0.08448510f, 0.16401434f, 0.21855293f, -0.01961805f, -0.14995268f, -0.16413927f, -0.09691277f, 
    0.03939823f, -0.06308892f, 0.16635031f, 0.00642831f, -0.04106382f, -0.09496146f, 0.01227266f, 0.04106491f, 
    -0.01859342f, -0.06825349f, -0.00130195f, 0.04645177f, 0.00298789f, -0.26951468f, 0.30377799f, -0.01432427f, 
    -0.23685220f, -0.03568858f, -0.34311086f, -0.01422066f, -0.15454686f, 0.15099581f, 0.10976495f, 0.10010682f, 
    0.01808940f, -0.03699178f, -0.02947104f, -0.00464046f, 0.31418261f, 0.10923455f, -0.24650563f, 0.18820764f, 
    0.26195216f, -0.63216949f, 0.37594205f, -0.20277405f, 0.12983088f, -0.02489505f, 0.03269669f, 0.02165599f, 
    0.10292981f, -0.03974378f, -0.02197824f, -0.11584628f, -0.02439472f, 0.11115293f, 0.02955242f, 0.01169193f, 
    0.10119043f, -0.13814025f, -0.14232911f, 0.08349486f, 0.69620389f, -0.07228085f, 0.32924664f, 0.17068020f, 
    -0.21889734f, -0.07114913f, -0.10382782f, -0.11219303f, 0.08606270f, -0.08643042f, 0.10147712f, 0.00518794f, 
    -0.11366975f, -0.01648423f, 0.10860489f, 0.02263201f, 0.00966402f, -0.05138088f, -0.01426021f, -0.01141421f, 
    -0.42530045f, -0.18570244f, -0.16887335f, -0.07372085f, -0.03256256f, -0.09602854f, 0.01748137f, 0.17112428f, 
    -0.02727504f, -0.28693521f, 0.06599449f, 0.05924222f, 0.06423320f, -0.04925790f, 0.01327398f, -0.03215850f, 
    -0.03512621f, -0.25733736f, -0.08011489f, 0.04101202f, -0.04217165f, -0.12604348f, -0.01132800f, 0.27401546f, 
    -0.04937453f, -0.04389504f, 0.01726700f, -0.10934038f, 0.05550247f, 0.11354665f, 0.04310086f, -0.04849869f, 
    0.01621910f, 0.21269317f, 0.26425105f, 0.13245182f, 0.25546864f, 0.07125103f, 0.12357102f, 0.26483417f, 
    0.20625113f, 0.10996919f, 0.11850696f, 0.17234306f, 0.07538127f, -0.06100935f, -0.18140666f, -0.05143312f, 
    -0.01271092f, 0.07900985f, 0.06005844f, 0.03480287f, -0.08882384f, -0.06145400f, -0.03214128f, -0.00665117f, 
    -0.03643160f, 0.09583625f, -0.06449643f, -0.02469471f, -0.50730485f, 0.48388156f, -0.78808761f, 0.21592993f, 
    -0.21780220f, 0.16860439f, 0.03237266f, 0.24966122f, -0.18701749f, -0.11904091f, 0.09403642f, -0.10880605f, 
    0.12242728f, -0.13977006f, 0.01543331f, 0.10947726f, 0.14218077f, -0.04580742f, -0.07763151f, -0.10200185f, 
    0.08063536f, 0.09980606f, 0.25538683f, 0.15004547f, -0.00549444f, -0.19015937f, 0.09195710f, 0.05317200f, 
    0.10347743f, 0.34347206f, 0.03546993f, 0.07039074f, -0.03768818f, -0.07778105f, 0.06439456f, 0.06368457f, 
    -0.04346506f, -0.04581159f, 0.15359223f, -0.20459707f, -0.46772039f, 0.21972884f, -0.55084282f, 0.23282194f, 
    -0.26830620f, 0.03412750f, 0.04938409f, 0.08387069f, -0.19337524f, -0.23854588f, -0.04770267f, -0.13814940f, 
    0.02108214f, -0.05077950f, -0.13042153f, -0.13053142f, -0.10640644f, -0.08322656f, 0.08932962f, -0.13780047f, 
    0.14337856f, 0.21321955f, 0.12894444f, -0.24745454f, 0.03623534f, -0.01271490f, 0.14282507f, 0.22523654f, 
    -0.08821668f, 0.00895032f, 0.14768627f, -0.03447653f, 0.00716449f, -0.02089936f, 0.04877157f, 0.02683710f, 
    -0.52059752f, 0.09152093f, -0.33680958f, -0.54926664f, 0.14337870f, 0.08077037f, -0.51367956f, 0.42928034f, 
    -0.12131101f, 0.10078819f, 0.08575594f, 0.09922958f, -0.10166031f, 0.09169195f, -0.00322627f, -0.04815498f, 
    -0.02252637f, 0.02691939f, -0.04594738f, 0.12216692f, 0.21464786f, 0.02650243f, 0.08781396f, 0.20131585f, 
    -0.33986011f, 0.16594049f, -0.40448460f, 0.36662370f, -0.00577705f, 0.07351098f, 0.19914541f, 0.06215993f, 
    0.06784704f, 0.16204357f, 0.09004524f, -0.04087191f, 0.07366364f, -0.14569913f, -0.14319079f, -0.04627987f, 
    -0.23227626f, -0.29571128f, -0.08317295f, -0.15638158f, 0.10107253f, 0.03325441f, 0.14953537f, -0.02115650f, 
    0.17015386f, 0.05272113f, 0.07835802f, 0.02380556f, 0.11643668f, 0.10586112f, -0.01466293f, -0.06800564f, 
    -0.09715822f, 0.01568026f, 0.05061114f, 0.04012692f, 0.16658092f, 0.08523183f, -0.03721583f, 0.17955644f, 
    0.21813259f, 0.30229983f, 0.18054686f, 0.29103726f, -0.02803721f, 0.12273183f, 0.09352224f, 0.12869258f, 
    -0.05376346f, 0.27017468f, 0.12740593f, 0.15314145f, 0.00613180f, -0.21921711f, -0.04694337f, -0.14747305f, 
    -0.25816905f, -0.19089127f, 0.01237578f, -0.39516100f, -0.39878407f, -0.04948266f, -0.15401925f, 0.17651990f, 
    -0.05137264f, -0.03870961f, -0.04595041f, -0.03206822f, 0.00213332f, 0.02818330f, 0.01898895f, 0.02982169f, 
    0.02494096f, 0.09292951f, 0.09467416f, 0.02463647f, 0.12790211f, 0.14538665f, 0.10064141f, 0.29768339f, 
    0.09940879f, 0.14055984f, -0.40570825f, 0.07916632f, 0.04699810f, 0.11179302f, 0.00639311f, 0.03719087f, 
    -0.18036868f, -0.09402838f, 0.01676149f, 0.05225977f, 0.04281759f, -0.14429826f, -0.09613172f, 0.16552116f, 
    0.25881964f, 0.02804303f, 0.00041944f, 0.36229390f, -0.03806550f, 0.08315291f, -0.07117415f, -0.02373640f, 
    -0.19627033f, -0.03526213f, -0.04770594f, 0.16826355f, 0.02926968f, 0.09478547f, 0.19684838f, 0.06578203f, 
    0.05895030f, -0.04748739f, 0.12474259f, 0.05937313f, 0.02051204f, 0.00114039f, -0.05775870f, 0.07520088f, 
    -0.28275150f, -0.35385960f, 0.41157863f, -0.04494859f, -0.31046730f, -0.10336982f, -0.20955469f, 0.13919233f, 
    -0.05021156f, -0.25637758f, 0.06477918f, -0.02025846f, -0.08760956f, 0.08034639f, 0.16486533f, 0.04347668f, 
    0.13371857f, -0.09207600f, -0.05878419f, -0.07574077f, 0.02278076f, 0.06783630f, 0.13354285f, -0.10240360f, 
    -0.03520259f, 0.18033196f, -0.17754257f, -0.00657180f, -0.03134285f, -0.08872951f, 0.09100822f, -0.02899257f, 
    -0.13606131f, 0.14864798f, -0.00180732f, -0.06733648f, -0.16869123f, -0.25464964f, -0.37144074f, -0.13154824f, 
    0.07520708f, 0.16303837f, 0.04027182f, -0.07069279f, -0.13705428f, -0.02678221f, -0.12520579f, 0.12360334f, 
    -0.05808387f, 0.02961792f, 0.07831614f, 0.07403704f, 0.16136561f, 0.16692866f, -0.03841851f, 0.06244522f, 
    -0.09735747f, -0.15280506f, -0.10519873f, -0.13718294f, 0.01476523f, 0.18762024f, -0.04629956f, -0.01720205f, 
    0.00018550f, -0.07207925f, -0.04397349f, -0.01173748f, 0.14744651f, -0.29414600f, 0.19757332f, 0.11836150f, 
    -0.04708529f, -0.08565727f, 0.00846201f, 0.01915514f, -0.08671612f, -0.19773665f, -0.00883151f, 0.04650860f, 
    0.02605825f, 0.00057761f, 0.01096968f, -0.03236590f, -0.03507511f, 0.01163773f, 0.02411203f, -0.03572328f, 
    -0.00824485f, -0.00670890f, -0.02375790f, 0.00654217f, 0.01553199f, 0.01629237f, 0.02630689f, -0.01727362f, 
    0.00049116f, -0.01000915f, -0.04018665f, -0.01593290f, 0.02925324f, -0.00019634f, -0.03675061f, 0.02074329f, 
    -0.03304200f, -0.01646525f, -0.01631459f, -0.01523830f, 0.00012558f, 0.03189689f, 0.01194283f, 0.03275210f, 
    0.01556669f, 0.00633474f, -0.03256562f, 0.02060344f, -0.02881787f, 0.01476612f, 0.02134938f, -0.02938617f, 
    0.03639610f, -0.01245410f, 0.03017442f, -0.02521407f, -0.02661702f, -0.03772108f, 0.00950760f, -0.03315463f, 
    0.01589030f, 0.00804844f, -0.02208596f, -0.02983916f, -0.03448006f, -0.01829132f, -0.01581759f, -0.01970548f, 
    -0.04182744f, -0.01595636f, -0.00671337f, -0.00048172f, -0.02918678f, 0.00675438f, -0.00541459f, 0.01990173f, 
    0.01330100f, 0.02815760f, 0.03379276f, -0.00997499f, 0.01601581f, 0.01800310f, -0.00289977f, 0.03033199f, 
    -0.02251408f, 0.02569958f, 0.00792579f, 0.02206414f, 0.01201862f, -0.00871728f, 0.02153753f, 0.00050284f, 
    -0.03276350f, 0.03887124f, 0.00716015f, 0.03007560f, 0.02726584f, -0.00850725f, 0.00646013f, -0.03972129f, 
    0.00717269f, 0.02368841f, -0.01443058f, 0.01872945f, -0.03765266f, -0.01606536f, 0.02583213f, -0.03125237f, 
    0.00128110f, -0.02951753f, 0.02406032f, 0.01421011f, -0.00036652f, 0.00844281f, 0.03443093f, -0.02003433f, 
    0.01019697f, -0.02659876f, 0.02559538f, -0.00768897f, -0.01399961f, 0.02268909f, -0.01449919f, -0.01493023f, 
    -0.00269816f, 0.01845088f, 0.01733570f, -0.02829048f, 0.01092663f, 0.00673500f, -0.02809615f, -0.03061848f, 
    -0.04414996f, 0.00455426f, -0.00566881f, -0.03893292f, 0.00580741f, 0.01248049f, 0.00255393f, -0.00773327f, 
    -0.02258130f, -0.02201147f, -0.04027890f, 0.01779750f, 0.02680327f, 0.00404115f, 0.00626220f, -0.00375778f, 
    0.03501849f, -0.00163020f, -0.01958892f, 0.02843664f, -0.00418989f, 0.02434403f, -0.01633349f, -0.01835496f, 
    -0.04186537f, -0.00141385f, -0.00220724f, -0.01293205f, -0.00870994f, -0.01179771f, -0.03852981f, -0.00933502f, 
    0.00443206f, -0.02850282f, -0.01009280f, 0.02588467f, -0.04279630f, -0.01865113f, 0.03107238f, 0.02319800f, 
    -0.04282705f, -0.02688199f, -0.04380891f, -0.03017354f, -0.00610844f, 0.02408469f, -0.00857436f, -0.03536141f, 
    -0.02759131f, -0.02221831f, -0.03042409f, 0.02466609f, -0.00614103f, -0.01869374f, -0.00571925f, 0.00151076f, 
    -0.00829341f, 0.01661324f, 0.00296122f, -0.03678108f, -0.00729936f, 0.01164863f, -0.03866982f, -0.00572782f, 
    -0.03134422f, 0.00113792f, -0.01670669f, -0.01069732f, 0.02694008f, 0.01433291f, -0.00634542f, -0.01847845f, 
    -0.00962584f, 0.01702912f, 0.01396377f, -0.01841867f, -0.00125987f, -0.01251813f, -0.01878305f, -0.02579186f, 
    0.00249375f, -0.02613166f, 0.00134182f, -0.02358954f, -0.01051406f, -0.00739639f, -0.04228006f, -0.03052400f, 
    -0.03069424f, 0.02786150f, 0.03034324f, -0.02341302f, -0.01608031f, -0.02383623f, 0.02029680f, -0.00564696f, 
    0.02716002f, 0.02866375f, 0.02576896f, -0.00329852f, -0.01600506f, -0.00466064f, 0.02617314f, -0.00996863f, 
    -0.01495086f, 0.00969463f, -0.01845644f, 0.01996257f, 0.03124986f, -0.02354194f, -0.00701089f, -0.02405304f, 
    -0.02527659f, -0.00804959f, -0.02753864f, 0.01983718f, -0.01628819f, -0.02654266f, -0.00191134f, 0.03357429f, 
    -0.02382079f, 0.03088574f, 0.03094180f, -0.01748563f, -0.00481200f, -0.02010985f, -0.04152375f, 0.02478619f, 
    0.02937560f, 0.02392320f, -0.01546783f, -0.04270222f, -0.03955805f, -0.01921305f, 0.02902270f, -0.04320535f, 
    0.00235866f, -0.01343923f, -0.01002735f, -0.03230368f, -0.01502198f, 0.03078289f, 0.01531356f, -0.00115167f, 
    -0.02553101f, 0.01101350f, 0.00516936f, -0.02120965f, -0.00310402f, -0.02552182f, -0.01774296f, -0.00352658f, 
    -0.02038500f, -0.01143083f, 0.03362629f, -0.02103122f, -0.02249041f, -0.01002025f, -0.03067166f, 0.02913904f, 
    0.01219558f, 0.01839714f, -0.03634841f, -0.04141263f, -0.01014503f, 0.03007861f, 0.03092009f, 0.01748776f, 
    -0.01185797f, -0.00875115f, 0.03168465f, 0.00947457f, 0.00388594f, -0.02249195f, -0.00477566f, 0.00259264f, 
    0.02420084f, 0.01622547f, 0.03245064f, 0.01442850f, 0.01226855f, 0.01798921f, 0.01588242f, -0.02494507f, 
    -0.01439375f, -0.03060780f, 0.02807279f, 0.01255327f, -0.00071228f, -0.04057290f, 0.00480064f, -0.01828837f, 
    0.00492003f, -0.01965707f, 0.00375363f, -0.01639519f, -0.01687061f, -0.01417199f, -0.01160737f, -0.01001026f, 
    0.01388989f, 0.00493437f, -0.01459290f, -0.01282871f, -0.02922412f, 0.02674894f, -0.03298419f, -0.02065786f, 
    -0.03863494f, -0.00198608f, 0.02037882f, 0.01472240f, 0.02563180f, 0.02926212f, -0.03538802f, -0.00175332f, 
    0.00139774f, -0.00356953f, -0.03098850f, -0.00198231f, 0.02567422f, 0.01713881f, 0.00601618f, -0.01630385f, 
    0.03255774f, -0.01903537f, -0.00940010f, 0.03340435f, -0.03346038f, 0.02110765f, -0.03713395f, -0.04445591f, 
    -0.00908670f, -0.01849256f, 0.03379670f, -0.02452517f, -0.03686675f, -0.03425328f, -0.01898250f, 0.03351292f, 
    -0.04297097f, 0.00601539f, 0.02360885f, 0.00526997f, -0.02274170f, 0.02381553f, 0.03008037f, 0.00293540f, 
    -0.03123246f, -0.01141112f, -0.03452175f, -0.01995048f, -0.01260123f, 0.02473746f, 0.02292906f, 0.01737581f, 
    0.00483198f, 0.02434366f, 0.00881856f, -0.04433918f, -0.02043849f, -0.00292077f, -0.03202460f, 0.01589987f, 
    0.00622334f, -0.00267677f, -0.03119143f, -0.04642480f, -0.00981965f, -0.03389882f, -0.04369343f, -0.03886947f, 
    -0.02874061f, -0.04276415f, 0.02491948f, -0.01398523f, -0.00974199f, 0.00719569f, -0.02162369f, -0.02387898f, 
    -0.02648015f, -0.03239058f, 0.01238571f, 0.01014666f, -0.02866287f, -0.02227814f, 0.01909737f, -0.02708857f, 
    0.04050685f, 0.02001272f, 0.00276500f, -0.00076900f, -0.03589033f, 0.02463062f, 0.01748746f, -0.03418478f, 
    -0.00508230f, -0.00933802f, -0.02062297f, -0.04282018f, -0.01897758f, -0.01435843f, -0.00768832f, 0.02745428f, 
    0.01670259f, 0.02595164f, -0.03241142f, -0.03701695f, 0.03063212f, 0.01456503f, 0.02526225f, -0.01616939f, 
    -0.00739136f, -0.03420779f, 0.02445189f, 0.02162032f, -0.01725564f, -0.04342168f, 0.01969740f, -0.01854479f, 
    0.01845846f, 0.00223628f, -0.01311459f, -0.03585916f, 0.03403807f, -0.03246400f, -0.03580606f, -0.03201450f, 
    0.01769670f, 0.00815953f, -0.00101901f, 0.02941962f, -0.02161664f, 0.01983463f, -0.02493072f, -0.01580478f, 
    -0.03727808f, -0.03763222f, 0.00609388f, 0.00732579f, 0.02440205f, -0.03788888f, 0.01009983f, -0.00921509f, 
    0.02921778f, 0.01700472f, -0.01258173f, 0.01540832f, 0.01296903f, 0.03148416f, 0.01952122f, -0.03578762f, 
    0.00937427f, -0.03244991f, -0.00815595f, 0.01131894f, -0.04305914f, 0.02218406f, -0.03657574f, 0.02643513f, 
    -0.00975932f, -0.02465647f, 0.02995255f, 0.01630868f, -0.01261177f, -0.03928638f, -0.00927456f, -0.00364883f, 
    -0.02749141f, -0.04416233f, -0.01808967f, -0.01657478f, -0.03183924f, 0.00227919f, -0.01397492f, 0.02112310f, 
    -0.02598484f, -0.03451278f, -0.04148412f, 0.03201259f, -0.00110947f, 0.01297378f, 0.01009902f, -0.04311889f, 
    0.00485152f, -0.01922085f, -0.03086048f, -0.03655879f, 0.01382952f, -0.02640774f, 0.01812955f, -0.01893097f, 
    -0.03623301f, 0.00812318f, 0.03043636f, -0.01739887f, -0.00571855f, -0.01514269f, -0.02696818f, -0.02848025f, 
    -0.03799834f, 0.01060565f, -0.03715784f, 0.00974060f, 0.03183220f, -0.03808631f, -0.00145846f, -0.01626400f, 
    0.01277789f, 0.00168325f, -0.02264235f, -0.03690980f, -0.00319648f, -0.01459101f, -0.02734989f, -0.02326650f, 
    0.01898078f, -0.01463427f, 0.00117153f, 0.01106349f, 0.01602162f, -0.04170061f, 0.02090028f, -0.03565668f, 
    -0.00107498f, -0.00329283f, -0.02829658f, 0.02625547f, -0.01306687f, -0.03720764f, -0.03943383f, -0.01884370f, 
    -0.00568380f, 0.01121716f, -0.01708429f, 0.00268041f, 0.00900418f, 0.02051652f, 0.02863210f, -0.03693845f, 
    -0.00236223f, 0.01865957f, -0.03089790f, 0.01345221f, 0.01910831f, -0.01095657f, -0.01276893f, -0.02542214f, 
    0.03536757f, 0.00480036f, -0.03090632f, 0.03628413f, -0.02245168f, -0.00917990f, -0.02666056f, 0.01782988f, 
    0.03242630f, -0.00280749f, -0.03286431f, 0.00715730f, 0.04245111f, 0.02129760f, 0.02788293f, -0.04370756f, 
    -0.03463108f, -0.00964867f, 0.01336869f, -0.01070660f, -0.01273068f, 0.00564455f, -0.04347958f, 0.02264132f, 
    -0.04156437f, -0.03741205f, -0.01445580f, -0.04097397f, -0.03141213f, -0.00059531f, -0.02364447f, 0.01607555f, 
    0.02805576f, 0.02070203f, -0.01261988f, -0.04396457f, -0.03756983f, 0.02178753f, -0.03063141f, -0.02287771f, 
    -0.00709488f, -0.03585699f, 0.00805835f, -0.02850397f, -0.00421531f, -0.00800122f, -0.00990263f, -0.03124903f, 
    -0.01150547f, -0.03293233f, 0.02547143f, -0.03608692f, -0.03487505f, -0.01444812f, 0.01594952f, 0.03082617f, 
    0.01434680f, 0.01738401f, -0.00264397f, 0.02863265f, -0.04072715f, -0.01728158f, 0.00065756f, -0.02218602f, 
    0.00554522f, -0.02603517f, 0.01032990f, -0.04332561f, 0.02947563f, -0.01088549f, -0.00087701f, 0.02943087f, 
    0.13995878f, -0.33571020f, 0.26231587f, 0.11242221f, -0.04084590f, 0.19434713f, -0.11994720f, -0.13179263f, 
    0.10456720f, 0.01828196f, 0.02088443f, 0.03853612f, -0.00096656f, 0.03545650f, 0.08368722f, -0.01653467f, 
    0.04991743f, 0.03717811f, -0.11804526f, 0.10025126f, -0.39136088f, -0.11408599f, 0.25108838f, 0.13293335f, 
    -0.01703698f, 0.18789306f, -0.16990569f, -0.15828404f, 0.21350342f, -0.13461006f, 0.09491107f, 0.03098695f, 
    -0.09279887f, 0.13020040f, 0.13059358f, 0.08441659f, -0.18718848f, -0.03115919f, 0.12079699f, -0.03530952f, 
    0.19491096f, 0.25150189f, 0.09998000f, -0.05419960f, -0.12662986f, 0.06868658f, -0.06371041f, 0.05530635f, 
    0.03499706f, -0.01775451f, 0.01854717f, 0.05533514f, 0.05296591f, -0.06550556f, 0.01731906f, 0.02566381f, 
    -0.07721700f, -0.01101727f, 0.04094630f, 0.04759953f, 0.07270497f, -0.12615563f, -0.16889675f, 0.18768655f, 
    0.07612492f, -0.17411536f, 0.12119909f, -0.02843291f, -0.10523006f, -0.01914332f, -0.00999771f, 0.09067401f, 
    0.03014349f, -0.01436692f, -0.09719747f, -0.01954764f, 0.09195055f, 0.02499402f, -0.06612233f, -0.00957641f, 
    0.02734884f, 0.08166679f, -0.12222156f, -0.28313604f, -0.22977503f, 0.01987239f, 0.02135337f, -0.01393925f, 
    -0.03493686f, 0.09139647f, 0.02348672f, 0.01578331f, -0.03967124f, 0.05888076f, -0.02817108f, 0.00819967f, 
    -0.10296595f, -0.03881998f, -0.03963377f, -0.11998625f, -0.18901764f, -0.01053323f, 0.09255917f, -0.07822084f, 
    -0.10593320f, -0.09075601f, 0.04523826f, 0.07590307f, -0.13285151f, 0.05030539f, 0.08901008f, 0.04449401f, 
    0.12948479f, 0.01916960f, 0.08790343f, 0.01764484f, -0.04080786f, -0.02746710f, 0.03254010f, -0.13627329f, 
    -0.26771820f, -0.11663399f, 0.38078764f, 0.16865268f, -0.16636205f, 0.07639295f, -0.12785788f, -0.17052977f, 
    0.06090148f, -0.31997767f, 0.06439048f, -0.06805465f, 0.03260460f, -0.06137425f, 0.11387111f, -0.05520935f, 
    0.03716527f, -0.01536601f, 0.01330238f, -0.02496240f, 0.67709804f, 0.35743010f, 0.17053226f, 0.12690644f, 
    0.03586842f, 0.01057556f, 0.24638976f, 0.09567522f, -0.08410623f, 0.05783722f, 0.10326810f, -0.11159794f, 
    0.19874927f, 0.20940877f, -0.10850223f, 0.07101054f, -0.02660330f, 0.07074268f, -0.04961412f, -0.02913617f, 
    -0.01024129f, -0.39444342f, 0.00176418f, 0.25260276f, 0.08829967f, -0.05626589f, 0.19894855f, -0.19738825f, 
    -0.09447283f, -0.16765928f, -0.01571391f, 0.08069317f, 0.00438963f, -0.02384358f, 0.01742131f, -0.03260779f, 
    0.05353627f, 0.04767326f, 0.06160889f, 0.07036074f, -0.18033756f, -0.18996078f, -0.10044120f, -0.09586170f, 
    -0.04681952f, -0.21901105f, -0.04968730f, 0.12490086f, 0.05851097f, 0.21245591f, 0.14073446f, -0.03031208f, 
    -0.02384366f, -0.04596503f, -0.05255583f, -0.05533927f, -0.02594254f, 0.01122862f, -0.05683033f, -0.15949088f, 
    -0.24320967f, -0.20688349f, -0.14595783f, -0.15819816f, 0.04899849f, -0.15573436f, -0.05859580f, 0.16742826f, 
    -0.02102813f, 0.24854280f, 0.15458132f, 0.10727134f, -0.06954125f, 0.00662714f, -0.03522761f, 0.00140513f, 
    -0.05583069f, 0.03025446f, -0.09673784f, -0.06737478f, -0.06583452f, 0.28401655f, -0.18338831f, 0.10716293f, 
    0.20729874f, 0.17857550f, 0.02480308f, -0.06225201f, 0.23200665f, -0.20346493f, 0.04830006f, 0.16090783f, 
    0.17064393f, -0.16824257f, 0.12924661f, 0.08946473f, -0.26725656f, 0.01737489f, 0.28250518f, 0.07988282f, 
    0.43445846f, 0.30699527f, 0.18047372f, 0.05721238f, -0.20066318f, 0.19392441f, 0.17190604f, 0.08397596f, 
    0.05372371f, -0.06463390f, 0.09538513f, -0.03477906f, 0.05032814f, 0.09171489f, 0.01388672f, 0.15311193f, 
    0.01784191f, 0.17065910f, 0.10200626f, -0.08024776f, -0.28817916f, -0.07659709f, -0.04400778f, -0.12182170f, 
    0.23591600f, -0.37026477f, -0.06681716f, 0.21969178f, 0.24029268f, 0.13458435f, 0.11081023f, 0.02723369f, 
    -0.00319213f, -0.09106085f, -0.10543578f, -0.08986953f, 0.04688758f, -0.06489953f, 0.06845871f, -0.08221898f, 
    0.63800830f, 0.26719251f, 0.06066806f, 0.13782452f, 0.05213910f, 0.00440757f, -0.05890132f, 0.02404569f, 
    -0.13567342f, 0.21625984f, 0.14675923f, 0.14170370f, 0.10859981f, -0.00820233f, -0.03487246f, -0.07456653f, 
    0.07193808f, 0.10293604f, -0.03619573f, 0.08149633f, -0.32521379f, -0.09229945f, 0.12476991f, 0.06322727f, 
    0.00993541f, -0.11399887f, -0.03327025f, -0.09797192f, -0.03027099f, -0.15628269f, 0.00429352f, -0.04859668f, 
    -0.05700176f, 0.07822802f, -0.01687305f, 0.03365511f, 0.12487354f, -0.07377479f, 0.01134663f, -0.07455654f, 
    0.23029819f, -0.15358087f, 0.10950323f, 0.28419393f, -0.00459609f, -0.18679260f, 0.07093991f, -0.05359316f, 
    -0.10301520f, 0.00445975f, 0.03602094f, -0.03165641f, -0.02157739f, 0.02834687f, -0.07573701f, -0.07453603f, 
    0.04210424f, 0.02151906f, -0.14142074f, -0.04652623f, 0.53901899f, -0.27921632f, 0.37472102f, -0.24348685f, 
    0.00495108f, 0.12211624f, 0.02260193f, -0.20444866f, 0.13772994f, 0.06513753f, 0.01230603f, -0.00379064f, 
    0.06250113f, 0.04617307f, -0.04671663f, -0.02286742f, -0.12770027f, 0.03468141f, 0.00185175f, 0.16649969f, 
    -0.13183831f, -0.17539918f, 0.18508317f, 0.30676702f, 0.02995117f, -0.04907393f, -0.06073797f, -0.15682301f, 
    -0.12169749f, -0.27351800f, 0.03213596f, -0.02675541f, 0.03871030f, -0.03476241f, -0.03884636f, -0.08010221f, 
    0.17901289f, 0.00930292f, -0.02521002f, 0.11636771f, 0.22275685f, 0.00308761f, -0.19706336f, -0.16420156f, 
    0.07098287f, 0.08641223f, 0.07740248f, -0.12816699f, -0.10637227f, 0.15043643f, -0.03460325f, 0.09166184f, 
    0.02423086f, 0.02182441f, 0.01503922f, -0.03728720f, -0.03975219f, 0.04800191f, -0.19966425f, 0.05707924f, 
    0.31844616f, 0.10176441f, -0.02674365f, 0.23732324f, -0.08197803f, 0.04367539f, -0.00225268f, 0.07226696f, 
    0.02966172f, -0.16234903f, 0.09363306f, 0.06401969f, 0.11688736f, -0.22093846f, 0.00035588f, 0.12230238f, 
    -0.03304540f, 0.08208589f, -0.01657522f, 0.02260614f, 0.03180799f, -0.14340842f, 0.20030166f, 0.14540428f, 
    -0.08858502f, 0.08326778f, -0.16330113f, -0.04578250f, 0.19712773f, -0.04807144f, -0.02191857f, 0.03079858f, 
    -0.03282006f, -0.07362189f, 0.03843433f, -0.03743552f, 0.13830940f, -0.04409842f, -0.08274963f, 0.04247845f, 
    -0.02751298f, -0.06739926f, 0.07411673f, 0.07745574f, -0.12306105f, 0.07759804f, -0.05634328f, -0.17001624f, 
    -0.04437093f, -0.04270303f, -0.04075423f, -0.02592581f, 0.05596995f, 0.03048748f, 0.07049367f, -0.13003725f, 
    0.02307963f, -0.10220539f, -0.06617858f, 0.09452231f, 0.10591230f, -0.06295687f, 0.21279064f, 0.18651116f, 
    0.01125911f, 0.00131756f, 0.06198614f, -0.03582544f, 0.01795345f, -0.08628536f, 0.06406009f, -0.02407165f, 
    0.01395721f, 0.16346921f, 0.06304440f, 0.09407412f, 0.04044801f, -0.03929215f, 0.02779332f, -0.01323503f, 
    -0.05420721f, -0.34604695f, -0.00284960f, 0.21168926f, -0.00985341f, 0.01546257f, 0.06524308f, -0.17082319f, 
    -0.07737543f, -0.17888112f, -0.02175008f, -0.03237608f, 0.05546962f, 0.00086578f, -0.09104150f, -0.09260067f, 
    0.03086828f, -0.12485088f, -0.03814356f, 0.06064624f, -0.02034337f, -0.13640067f, 0.03045775f, 0.13597614f, 
    0.23035134f, 0.11708312f, 0.10466059f, 0.00059212f, -0.11614309f, 0.10354106f, -0.00763539f, -0.01693198f, 
    0.04590774f, 0.15826678f, -0.02100472f, 0.04565616f, 0.06338221f, 0.00221408f, 0.02326867f, 0.06027614f, 
    0.28091425f, -0.07718365f, 0.02430410f, -0.09323599f, -0.13168734f, 0.08869901f, -0.08059613f, -0.11491507f, 
    0.09522644f, -0.00882221f, -0.02673003f, 0.06969708f, -0.01003834f, 0.12111269f, 0.05372144f, -0.05690479f, 
    -0.03306699f, 0.07756163f, 0.09813146f, -0.16600090f, 0.18690628f, 0.20094529f, 0.13177896f, -0.10491236f, 
    -0.02882648f, -0.06074123f, 0.05999941f, -0.18576807f, -0.07830332f, -0.04342739f, -0.15743984f, -0.03246787f, 
    0.01546459f, -0.17857650f, 0.03612026f, 0.02663855f, 0.09792308f, -0.08221626f, 0.01287659f, -0.10443468f, 
    -0.37533665f, -0.10505489f, 0.27151033f, -0.03457153f, 0.41577724f, -0.29153165f, 0.22626901f, 0.09400544f, 
    0.09826703f, 0.22772674f, 0.06064326f, 0.01124826f, 0.10603729f, -0.02728774f, -0.02162886f, -0.00964099f, 
    -0.02116713f, -0.06850138f, -0.05963473f, -0.03942095f, -0.05161245f, 0.10314791f, -0.19694497f, -0.15679750f, 
    -0.14561972f, -0.03927840f, -0.02044170f, 0.04624119f, 0.01752038f, 0.02059402f, 0.05038086f, 0.01001577f, 
    -0.01039320f, 0.06029537f, 0.16327286f, 0.05786070f, 0.07808056f, 0.05725861f, -0.05859034f, -0.09554394f, 
    -0.04532739f, 0.04603013f, -0.01273532f, -0.10219667f, -0.04104396f, -0.10152698f, 0.00747306f, -0.04916169f, 
    -0.00133010f, -0.06715227f, -0.07994965f, 0.11864793f, 0.01095024f, -0.09287839f, 0.21424013f, -0.04742976f, 
    -0.05793683f, -0.12793343f, -0.08960723f, -0.11601777f, 0.17203073f, 0.01711338f, -0.04579574f, 0.00342099f, 
    -0.25972265f, -0.10727888f, -0.06585392f, 0.02837235f, -0.04983903f, 0.18995868f, 0.02018605f, 0.07548222f, 
    -0.05403379f, 0.00866930f, 0.09663709f, -0.02944157f, 0.00251335f, 0.02820114f, -0.07536050f, 0.06407217f, 
    0.14753874f, -0.30872592f, -0.10936379f, -0.38229856f, 0.22867863f, 0.01247032f, 0.24775082f, 0.11461369f, 
    -0.08049383f, -0.12631682f, -0.05201611f, 0.03822356f, -0.04140922f, -0.02545534f, 0.04008558f, 0.15694401f, 
    -0.03053058f, -0.17247991f, 0.13881941f, -0.06583904f, 0.38520163f, 0.05425763f, -0.03082595f, 0.39311045f, 
    0.33453763f, 0.09037872f, 0.14555913f, 0.01793263f, -0.01918853f, 0.17386487f, -0.01957986f, 0.04427627f, 
    0.08235209f, -0.02615029f, 0.01640881f, 0.06162811f, 0.10682385f, 0.10070804f, 0.11192726f, -0.11645520f, 
    0.03019186f, 0.27764222f, 0.00935450f, 0.12507553f, 0.19899376f, -0.00702755f, -0.09888157f, 0.03224898f, 
    -0.00106053f, 0.00948743f, 0.03367405f, 0.05273455f, 0.01012024f, 0.10193374f, 0.11048524f, 0.08507064f, 
    0.17567997f, 0.06424610f, 0.04076278f, 0.14693588f, -0.45230985f, -0.12175529f, -0.15378363f, 0.12637194f, 
    0.15912117f, -0.14085284f, 0.13440476f, -0.01718512f, 0.06962562f, 0.09128094f, -0.03206349f, 0.06193045f, 
    0.02006980f, 0.02611924f, 0.03925635f, 0.04890282f, 0.01235914f, 0.00264624f, 0.06851160f, 0.11939139f, 
    -0.00140161f, -0.19464290f, 0.02709845f, -0.05844383f, -0.12123722f, -0.12547430f, -0.14418714f, -0.09352816f, 
    -0.19057204f, -0.06256251f, -0.04067244f, 0.05501182f, 0.09527595f, 0.03323522f, 0.10303685f, -0.14098309f, 
    0.02521700f, -0.02904001f, -0.05246896f, -0.05723334f, 0.08220159f, 0.22248510f, 0.39360455f, 0.04107601f, 
    0.00388642f, 0.06225433f, 0.04899937f, -0.08808073f, -0.11763775f, 0.01805713f, 0.10922009f, 0.00394362f, 
    0.15576692f, 0.00582307f, 0.01321890f, 0.03207412f, -0.02332635f, -0.17287396f, -0.14438032f, -0.18320565f, 
    -0.23134586f, -0.22144714f, -0.50542492f, 0.06884301f, 0.06420687f, 0.06062169f, -0.16405317f, -0.04331961f, 
    -0.10709319f, -0.24413632f, -0.01298308f, 0.02415267f, -0.01056043f, 0.00358093f, 0.21355841f, 0.01821849f, 
    -0.07855186f, 0.10138284f, -0.16949856f, -0.04476959f, 0.01363468f, 0.53061295f, 0.03467907f, 0.22729595f, 
    0.11089824f, -0.09219941f, 0.15088022f, -0.06119070f, -0.09691849f, 0.19046184f, 0.02144422f, 0.03035079f, 
    0.11631191f, 0.08199305f, -0.11256886f, 0.00940311f, 0.11494514f, 0.02839094f, 0.07600909f, -0.04911477f, 
    -0.28193620f, -0.11731873f, -0.38459206f, 0.05201643f, 0.06392274f, -0.02827000f, 0.09075212f, -0.04304143f, 
    0.15278666f, -0.03832547f, -0.00994924f, 0.00211430f, 0.01731696f, 0.04400416f, 0.02783900f, -0.00244906f, 
    0.03312415f, 0.12161811f, 0.07397473f, 0.06701218f, -0.22614416f, 0.02728286f, 0.17798463f, -0.12450997f, 
    0.07248231f, -0.01734805f, 0.04472016f, -0.06608696f, 0.06443965f, 0.01064681f, -0.02206591f, 0.15586963f, 
    -0.05152060f, -0.06230215f, 0.07233220f, -0.02120176f, -0.02806279f, -0.01224358f, 0.01901631f, -0.00992328f, 
    0.03471238f, 0.20252027f, 0.30182493f, 0.10353275f, 0.19640867f, 0.06044575f, 0.02720151f, -0.00327174f, 
    -0.02454533f, 0.01863464f, -0.06488688f, 0.25155073f, 0.06030881f, -0.05058697f, 0.09985315f, 0.04330451f, 
    -0.00332257f, -0.05896829f, 0.03914852f, -0.03868413f, 0.26850152f, -0.64799714f, 0.55569971f, -0.32797596f, 
    0.06599879f, -0.13206930f, 0.15803044f, 0.15909174f, -0.09380216f, -0.07321141f, 0.08207595f, 0.06906589f, 
    0.21104713f, 0.00043036f, 0.12623039f, 0.22801840f, -0.00432843f, -0.00863967f, -0.05469737f, 0.06149684f, 
    0.01604545f, 0.58607799f, -0.35891068f, 0.21445197f, 0.11436623f, 0.04539180f, 0.12975237f, 0.02339622f, 
    0.13119255f, 0.22556603f, 0.05871755f, 0.06401209f, 0.15299560f, 0.06966205f, 0.18892068f, -0.00113390f, 
    -0.01857561f, 0.17586909f, 0.06481320f, 0.07713319f, -0.49538523f, 0.17754939f, 0.04870693f, 0.29220948f, 
    0.36774397f, 0.05952130f, 0.01861412f, 0.06670409f, -0.09644530f, 0.18310782f, 0.13005307f, 0.10396046f, 
    -0.06844105f, -0.06637705f, 0.04148116f, 0.00825161f, 0.01848805f, -0.06289246f, -0.01240773f, 0.07587212f, 
    0.11879466f, 0.37779310f, -0.12978545f, -0.21019976f, -0.10804638f, -0.08465564f, 0.00826430f, -0.04167676f, 
    0.04247572f, 0.07028575f, 0.02531508f, 0.04864090f, 0.09016224f, -0.10829823f, -0.05096839f, 0.03933892f, 
    0.05205124f, 0.15266038f, 0.19722752f, -0.03120163f, -0.16381048f, 0.05101352f, -0.35757732f, 0.05254259f, 
    0.18944615f, -0.10181399f, -0.06032899f, 0.00684968f, 0.05033525f, 0.07918252f, -0.09471157f, 0.08351686f, 
    0.05140398f, -0.04866728f, 0.04192685f, -0.05306249f, -0.12469483f, 0.03836106f, 0.09306960f, -0.08884687f, 
    -0.34060955f, -0.18533263f, 0.00921842f, -0.09330405f, 0.18866836f, -0.24546942f, 0.09089378f, -0.11694990f, 
    0.18759197f, 0.06467874f, -0.13043123f, 0.09273081f, -0.05520229f, 0.01111303f, 0.05079724f, 0.03803306f, 
    0.01058452f, -0.00940409f, 0.17873165f, 0.00596028f, -0.32405958f, -0.29854622f, 0.12688735f, -0.19383451f, 
    0.18666364f, -0.13332200f, 0.05501437f, 0.21493533f, -0.01003932f, -0.18944447f, -0.11262430f, -0.07285024f, 
    -0.08454163f, -0.07618006f, -0.05439684f, -0.01624898f, 0.03796885f, 0.07722878f, 0.08027260f, -0.00468229f, 
    -0.41662955f, -0.32505524f, -0.37045899f, 0.12181051f, 0.12208737f, 0.02459623f, -0.03203234f, 0.01599624f, 
    0.08038500f, -0.17395362f, -0.05701235f, 0.06915919f, -0.03695128f, 0.06129322f, 0.10155667f, 0.00306262f, 
    0.07936414f, 0.09204078f, -0.02317664f, 0.15171519f, 0.03332760f, -0.17483856f, -0.14493051f, -0.07406964f, 
    -0.00754327f, -0.25547564f, -0.18886057f, 0.02698681f, -0.05670172f, -0.07852469f, -0.08193529f, 0.04066038f, 
    -0.10157833f, -0.06311292f, -0.00096127f, -0.07315978f, 0.16781013f, 0.00526292f, 0.17534442f, -0.03598349f, 
    -0.27987388f, -0.20016798f, -0.00080363f, -0.25181514f, -0.26077011f, -0.04359657f, -0.02360092f, -0.06102212f, 
    -0.01114600f, 0.11641821f, -0.04542562f, 0.08772893f, -0.10925739f, 0.22331867f, -0.00466735f, -0.22609322f, 
    0.48687041f, -0.01714692f, 0.20151673f, -0.06524991f, -0.00576616f, -0.27666879f, -0.19342808f, -0.27609372f, 
    0.22254084f, 0.21065557f, 0.13223030f, 0.08039343f, -0.14097567f, -0.08970171f, -0.07848971f, 0.08750616f, 
    0.01109009f, 0.04829447f, 0.11587189f, 0.13762595f, -0.14227226f, -0.04966773f, 0.04137078f, -0.09716928f, 
    0.14625098f, -0.25993153f, 0.02237841f, -0.24737905f, -0.01288450f, -0.07463664f, 0.00379539f, -0.04686305f, 
    0.07486202f, -0.09636537f, 0.03813488f, 0.00867504f, -0.04156501f, 0.08735938f, 0.02032100f, 0.00731916f, 
    0.10539371f, 0.21438335f, 0.11426907f, 0.02405108f, -0.16072792f, -0.10075229f, -0.49814191f, 0.12477196f, 
    0.00997585f, -0.03082045f, 0.17648752f, 0.13025787f, 0.04740296f, -0.03003713f, 0.07233807f, 0.00987789f, 
    0.01670682f, 0.03282499f, 0.07985573f, 0.00129786f, -0.04307899f, -0.05813131f, -0.18592940f, -0.12897846f, 
    -0.20825058f, -0.20557030f, -0.22881384f, -0.20150289f, 0.05894740f, -0.05672255f, 0.06278930f, 0.04314580f, 
    -0.04327780f, -0.01705971f, -0.02460482f, -0.02048327f, -0.00681408f, 0.06020201f, -0.02690573f, 0.01873025f, 
    0.09386893f, 0.17550080f, 0.10240784f, 0.23692924f, 0.00333699f, 0.26284778f, -0.26825863f, 0.07979964f, 
    0.13552015f, -0.06849296f, 0.03349157f, 0.07159369f, 0.20726784f, 0.09474155f, 0.02125445f, 0.08629654f, 
    -0.06750389f, 0.05757168f, 0.03186590f, 0.13418692f, 0.03883803f, -0.09344966f, 0.14040576f, -0.18981829f, 
    -0.08132660f, -0.07290582f, 0.18796894f, -0.12378673f, -0.00848914f, -0.01538503f, 0.09325297f, 0.04592536f, 
    -0.06935157f, -0.01852659f, 0.03201415f, -0.03284472f, 0.09348774f, 0.15478134f, 0.10559102f, 0.07857929f, 
    0.04441678f, 0.00327404f, 0.02532781f, -0.08591558f, -0.22250301f, -0.08452668f, -0.01233840f, -0.09799378f, 
    -0.12531960f, -0.16743146f, -0.08656425f, -0.09880033f, -0.18228738f, -0.12947954f, -0.04533674f, -0.12574820f, 
    -0.08194640f, -0.01475614f, -0.10940225f, 0.29974705f, 0.01025787f, -0.15936893f, -0.12726951f, -0.06924199f, 
    0.35366464f, 0.65348595f, 0.40874204f, -0.07654881f, 0.41158858f, -0.03462425f, 0.16625294f, -0.12050194f, 
    -0.01307353f, -0.03128227f, 0.27024883f, 0.09436114f, -0.01266275f, 0.11849359f, -0.06050242f, 0.03575252f, 
    -0.03141011f, -0.08880439f, 0.01839431f, -0.17120092f, -0.10356367f, 0.00468750f, -0.11212671f, -0.09915517f, 
    -0.07769246f, -0.02185375f, -0.09820132f, -0.05888416f, -0.01179319f, -0.01777485f, 0.10366268f, 0.01962377f, 
    -0.14159042f, 0.04809041f, 0.05343302f, -0.17724359f, 0.07602018f, 0.15613444f, 0.10239756f, 0.02925624f, 
    -0.15928043f, -0.09054455f, 0.08772862f, -0.03904893f, -0.02097454f, -0.03254849f, -0.10699610f, -0.07324287f, 
    -0.05524665f, -0.07948149f, 0.09674625f, 0.07978701f, 0.05519671f, 0.14481880f, 0.11973555f, -0.00910521f, 
    -0.04368127f, -0.08548786f, -0.04676888f, 0.01509576f, -0.15109408f, -0.05436847f, 0.13986924f, -0.10631358f, 
    -0.10052472f, -0.02764679f, -0.00856683f, -0.11011726f, -0.06867760f, 0.00614061f, 0.14185667f, -0.04325800f, 
    0.19673836f, 0.01862983f, 0.13148294f, -0.11780632f, 0.10116155f, -0.11115705f, 0.09608300f, -0.05033843f, 
    0.06869777f, 0.04765433f, 0.26974002f, 0.22022034f, 0.03397436f, -0.03538136f, 0.11395837f, 0.22385617f, 
    0.08443041f, 0.04987229f, -0.03732289f, 0.03045531f, -0.02665566f, 0.00351866f, 0.02977736f, 0.07326618f, 
    -0.03150528f, 0.15799947f, -0.07156987f, -0.00060173f, 0.42054364f, 0.11376902f, 0.02272325f, 0.04300393f, 
    0.22578515f, -0.00574317f, -0.00830276f, 0.07619232f, 0.15214732f, 0.00937581f, -0.01903720f, 0.05720283f, 
    0.13113390f, -0.01291956f, -0.14077143f, -0.08712564f, -0.08362656f, -0.01393242f, -0.14849848f, -0.14764465f, 
    -0.42774484f, -0.18535088f, 0.32211065f, 0.05963784f, -0.00904089f, 0.06936772f, 0.00473626f, -0.05957658f, 
    0.09117099f, 0.03416719f, 0.08197696f, 0.08341414f, -0.09927262f, 0.15391429f, 0.16276851f, -0.05643236f, 
    -0.06373278f, -0.02645884f, 0.08124201f, 0.14093259f, 0.31662196f, -0.01392718f, 0.03142087f, -0.04481112f, 
    0.05275485f, -0.04220743f, 0.05448880f, 0.01419411f, 0.06600584f, 0.09995563f, 0.00774763f, -0.12027474f, 
    -0.16978113f, -0.11847068f, -0.02514950f, -0.06928783f, 0.08710807f, -0.02260320f, 0.04805287f, -0.01389994f, 
    0.00799197f, 0.13399617f, 0.09624510f, -0.04619300f, -0.05573957f, 0.09515991f, -0.06099909f, -0.11468795f, 
    -0.02213689f, 0.03267650f, 0.13032185f, 0.06365141f, -0.10676076f, -0.05500084f, -0.00962172f, -0.04846889f, 
    0.14041196f, -0.05625650f, 0.02327282f, 0.02515381f, -0.33481541f, 0.03146979f, -0.20887010f, -0.14159942f, 
    0.10842785f, 0.03268401f, -0.02534138f, -0.10409252f, 0.04542559f, 0.04619040f, 0.00589789f, 0.14321859f, 
    -0.00120758f, 0.01852920f, 0.05286735f, -0.20624380f, 0.01618904f, -0.06136700f, 0.06498267f, -0.11210806f, 
    0.04081523f, 0.02979090f, 0.22712199f, -0.16465540f, 0.21909061f, 0.06555049f, 0.07815711f, 0.15033963f, 
    -0.03332945f, 0.10766529f, 0.06848092f, 0.02422341f, -0.03144046f, -0.05494404f, -0.04907919f, 0.05865048f, 
    0.01662886f, -0.03917583f, 0.05244874f, -0.17784776f, 0.06870633f, -0.45745108f, 0.12940019f, -0.46124372f, 
    0.19328459f, 0.03998024f, -0.17549539f, -0.08397552f, 0.20530522f, 0.03219295f, 0.10027154f, 0.00653761f, 
    -0.02660277f, -0.09768664f, 0.08919436f, -0.04950601f, -0.00890024f, -0.01973868f, 0.00159328f, 0.01146298f, 
    0.19767268f, 0.06476134f, 0.18957515f, 0.04116416f, 0.17222753f, 0.06790558f, 0.01817422f, 0.07408737f, 
    0.00914901f, 0.11061855f, -0.08922905f, -0.01561521f, -0.10004641f, -0.05568994f, 0.00837394f, -0.07096796f, 
    0.01368818f, -0.07463806f, 0.02656680f, 0.06230462f, -0.06422965f, 0.12960087f, -0.08999647f, -0.09344617f, 
    -0.01738467f, -0.05732119f, -0.09445473f, -0.01929632f, -0.10882840f, 0.21279599f, -0.01238352f, -0.01672487f, 
    -0.03057966f, -0.13035284f, -0.15398110f, 0.03126957f, 0.06430874f, -0.01704297f, -0.05640867f, 0.02640542f, 
    -0.14816883f, 0.08282071f, -0.23868665f, -0.25260663f, 0.00253490f, -0.07226039f, 0.01064485f, 0.02785940f, 
    0.03613214f, 0.16301614f, -0.06258107f, 0.04491570f, -0.03172099f, 0.06972694f, -0.09004047f, -0.11541686f, 
    -0.08208609f, -0.05547560f, -0.02523995f, -0.05430567f, 0.37054047f, 1.00677633f, -0.01195214f, 0.20041277f, 
    0.03333395f, -0.14303574f, -0.04165426f, 0.18811686f, 0.17305534f, -0.00093214f, 0.06223606f, 0.02083420f, 
    0.08699080f, 0.02024933f, -0.06074322f, -0.16707562f, -0.03158271f, 0.37861452f, -0.02841670f, -0.07760985f, 
    -0.07608282f, -0.02208972f, 0.20073164f, -0.00393235f, 0.31229147f, 0.05149012f, 0.09891640f, 0.09604476f, 
    0.08178984f, -0.01748494f, 0.00622816f, -0.00251216f, 0.00533039f, -0.11317600f, 0.01356974f, -0.00458738f, 
    -0.01300270f, -0.06912410f, -0.02094781f, 0.04353946f, -0.08869860f, -0.07981141f, -0.17564386f, -0.14116089f, 
    0.19324496f, -0.01572578f, 0.13491291f, -0.08582487f, 0.07512009f, 0.18614197f, -0.08224744f, -0.12707496f, 
    -0.06308339f, 0.09214200f, -0.05187142f, -0.06051143f, -0.08499444f, -0.00199858f, 0.09678449f, -0.05751628f, 
    0.13283774f, -0.22531603f, 0.15299851f, -0.14434414f, -0.21151520f, 0.05640640f, -0.15547474f, 0.08953451f, 
    0.22000352f, -0.03994619f, -0.10282091f, -0.02013934f, -0.07043853f, -0.02065950f, 0.11913220f, 0.00267738f, 
    -0.02348914f, -0.03892422f, 0.03303246f, -0.00098052f, -0.17704986f, -0.12509763f, -0.16355246f, -0.13311076f, 
    0.13632226f, -0.01215817f, 0.12264074f, 0.03813667f, -0.21711530f, 0.07378399f, -0.04819795f, -0.03984547f, 
    -0.00088814f, 0.04203797f, -0.06800416f, -0.02005445f, 0.04975686f, -0.00795261f, 0.04771743f, -0.10960289f, 
    0.14988545f, -0.04449933f, -0.08668753f, 0.07514809f, -0.00098059f, 0.03562598f, -0.00701114f, 0.02594904f, 
    -0.00719713f, 0.01876853f, 0.00451960f, -0.03708136f, -0.11832689f, -0.08604828f, 0.03405169f, -0.10193540f, 
    0.10496856f, 0.02461693f, -0.01556187f, 0.04869149f, 0.37614325f, 0.09340279f, -0.33902121f, -0.01812043f, 
    0.18870458f, -0.11384378f, 0.12913562f, 0.10341092f, 0.01903772f, 0.06064758f, -0.03998061f, 0.01192642f, 
    0.02667786f, -0.17224582f, 0.02693684f, 0.10412659f, -0.08926391f, 0.16664568f, -0.10176025f, 0.05445449f, 
    0.22883172f, 0.10716400f, 0.19206616f, -0.07620543f, 0.15332338f, 0.10509710f, 0.14726715f, -0.05010869f, 
    -0.04805204f, 0.03015503f, 0.03661023f, -0.02584015f, 0.01626226f, 0.05771535f, 0.08917469f, -0.02427305f, 
    -0.02625094f, -0.15436809f, 0.13687330f, 0.06710979f, -0.13290960f, -0.17775798f, 0.01434272f, 0.10519346f, 
    -0.23718981f, 0.00615177f, 0.00008464f, -0.10089973f, 0.19221820f, -0.04252572f, -0.16047783f, -0.09198075f, 
    0.01101863f, 0.04736486f, 0.19717766f, 0.09553444f, 0.01706685f, 0.03093573f, 0.02614906f, -0.07453106f, 
    0.10295732f, -0.04422791f, -0.05311013f, 0.11302188f, -0.16263981f, -0.03027419f, -0.15988104f, -0.16855837f, 
    -0.01121072f, -0.01599365f, 0.07008827f, 0.03533676f, 0.05494026f, -0.04342024f, 0.03277208f, 0.20973840f, 
    0.04353225f, -0.00099192f, 0.09658151f, 0.19200152f, 0.15328079f, 0.10482998f, 0.34431520f, 0.15016653f, 
    -0.06498361f, -0.07297390f, 0.10164405f, 0.05751242f, 0.12760687f, -0.00083985f, -0.04428270f, -0.04433353f, 
    -0.00208673f, -0.04067227f, -0.01086922f, 0.08147180f, 0.04488830f, -0.04809136f, -0.03073545f, -0.09480903f, 
    -0.15026668f, -0.02837582f, -0.00645957f, 0.21694085f, -0.11128609f, 0.05947687f, 0.03181295f, 0.16747278f, 
    0.02197997f, -0.09601922f, -0.14880560f, 0.04831982f, -0.04118416f, -0.01770633f, 0.21299665f, 0.01284033f, 
    0.10298895f, 0.06771166f, -0.08950805f, 0.07829247f, 0.25218773f, 0.04538165f, 0.20332478f, 0.09331667f, 
    0.16878688f, -0.05678214f, 0.18336324f, 0.01568890f, 0.12751694f, -0.03223071f, -0.01017252f, 0.00224171f, 
    0.00959278f, 0.00864084f, -0.01302163f, -0.05545064f, 0.00283553f, -0.04497754f, 0.00853025f, 0.03684878f, 
    0.02782198f, 0.16128762f, 0.12059324f, -0.14452706f, 0.10317051f, -0.14210965f, -0.09782594f, 0.18448730f, 
    -0.06648182f, 0.06086703f, -0.00191056f, 0.01643191f, -0.14922728f, -0.04711505f, 0.03271785f, 0.06463656f, 
    0.07203993f, 0.10764488f, -0.01288640f, 0.03011516f, 0.18292074f, -0.14813352f, 0.03040398f, -0.19795594f, 
    -0.06943744f, -0.00582005f, 0.05941125f, 0.08685043f, 0.09845181f, 0.04828755f, -0.02922317f, -0.04631103f, 
    0.01034456f, 0.02951762f, -0.00881915f, -0.04490950f, -0.13974369f, -0.08550674f, 0.11457574f, -0.00931992f, 
    -0.20229007f, 0.01950303f, 0.26548266f, 0.19576375f, 0.18230921f, -0.07353213f, -0.04869587f, -0.22624423f, 
    0.02187902f, 0.05567636f, 0.01347155f, -0.10549802f, 0.05222172f, -0.11596840f, -0.06709466f, -0.12175380f, 
    -0.02846793f, -0.23585585f, -0.07773340f, 0.06075722f, -0.16276485f, -0.09101083f, 0.05376384f, 0.14002001f, 
    -0.06627285f, -0.08320795f, 0.08061523f, -0.10003388f, -0.01302827f, 0.08836689f, -0.01284679f, -0.18162733f, 
    -0.07870895f, -0.02885098f, -0.01153179f, -0.16738297f, 0.04084143f, -0.04653870f, -0.01842883f, 0.00355535f, 
    -0.55918795f, -0.21222815f, -0.52158767f, -0.39620647f, 0.39742142f, 0.13162838f, 0.09000352f, -0.16566667f, 
    0.02786893f, 0.11191764f, 0.02539645f, 0.12496798f, 0.17528287f, 0.10955890f, -0.08566625f, -0.15458216f, 
    0.00041489f, 0.04438719f, 0.05039847f, 0.04950813f, -0.27078998f, -0.16018091f, 0.04224997f, 0.03727858f, 
    -0.02443303f, -0.07175397f, -0.00163744f, -0.06738374f, -0.14091602f, 0.03920837f, 0.13913564f, -0.00844720f, 
    0.16004613f, 0.05325729f, -0.00074302f, 0.18086347f, 0.04894546f, -0.07766008f, -0.03263250f, 0.04749659f, 
    -0.16862378f, 0.01416731f, -0.06514230f, 0.05864849f, -0.05577103f, 0.01781896f, 0.07355639f, -0.06711856f, 
    -0.13883312f, 0.11150766f, 0.05447327f, 0.00561574f, -0.03945169f, -0.03584591f, 0.02516337f, -0.05467337f, 
    0.05928621f, 0.10629814f, -0.03687687f, 0.02619093f, -0.10229255f, -0.00059503f, -0.00484513f, -0.03385244f, 
    -0.06207372f, 0.10052080f, -0.04941045f, -0.05924620f, 0.01217752f, 0.05734092f, -0.06130422f, -0.02244341f, 
    -0.07476413f, 0.04150043f, 0.10228883f, 0.00127878f, 0.01227015f, -0.00739424f, 0.02430946f, -0.12405845f, 
    0.00678132f, -0.19577713f, 0.00311795f, -0.27081689f, 0.06343434f, 0.04742934f, -0.01779104f, -0.02779209f, 
    0.09604979f, -0.04557628f, -0.09693425f, 0.06028343f, 0.03512311f, 0.06470834f, -0.06797021f, 0.10441776f, 
    0.02209749f, -0.13276422f, 0.03157386f, 0.10585568f, 0.06055870f, 0.06402200f, 0.19946311f, 0.17079554f, 
    0.08958564f, 0.01562416f, 0.15350263f, 0.12928316f, -0.05676785f, 0.09254450f, -0.11296968f, 0.09243413f, 
    0.14663255f, 0.09098480f, 0.02885589f, 0.14339001f, 0.21866639f, 0.00120973f, 0.17368282f, 0.02684362f, 
    0.03789976f, 0.22635663f, -0.12660040f, 0.39791980f, 0.14808790f, -0.04798358f, -0.08874347f, 0.08067492f, 
    0.14747986f, 0.05110841f, 0.05445902f, 0.08717041f, 0.14411619f, -0.00167220f, 0.06789359f, 0.11643878f, 
    0.06375825f, 0.08862498f, 0.13532875f, -0.01244112f, -0.22489277f, -0.13980858f, -0.20299481f, 0.04012834f, 
    0.00408175f, -0.03500400f, 0.03679192f, -0.04631412f, -0.00518444f, -0.03609057f, -0.05756472f, -0.01250672f, 
    0.03508037f, 0.04237685f, 0.05750949f, 0.08137919f, -0.09378403f, 0.04286397f, 0.00946440f, 0.07302865f, 
    -0.00187310f, -0.13074371f, -0.02555873f, -0.17544769f, -0.16800000f, -0.18471225f, -0.16336574f, 0.08221168f, 
    -0.04853710f, -0.11839876f, -0.14072339f, 0.00448057f, -0.01597649f, 0.15018247f, -0.00878078f, -0.09091449f, 
    -0.19447127f, 0.04055233f, 0.00598560f, -0.04115284f, 0.01185825f, 0.00360971f, 0.23950629f, 0.23419780f, 
    -0.06960702f, -0.04246107f, -0.04312725f, -0.02012675f, -0.09460647f, -0.04320801f, 0.04266299f, 0.09102476f, 
    0.14635919f, 0.10004938f, 0.01945356f, 0.09658244f, -0.09139823f, -0.03780788f, -0.00119862f, 0.00092265f, 
    -0.14485201f, -0.01517204f, -0.50614578f, -0.02524778f, -0.25184861f, 0.03995281f, -0.15186302f, -0.03637387f, 
    -0.14268485f, -0.17990750f, -0.04053790f, 0.01731978f, -0.01217116f, -0.06497856f, -0.06529854f, 0.04072578f, 
    -0.12351221f, 0.09948578f, -0.00365250f, -0.03943913f, 0.11863702f, 0.50500208f, 0.03167649f, 0.59033847f, 
    0.05522127f, -0.04347083f, 0.15770113f, 0.00221023f, 0.09234798f, 0.17169085f, 0.03165376f, 0.01169939f, 
    0.10908601f, 0.09969215f, -0.03281160f, 0.18487915f, 0.00156388f, 0.05820702f, 0.08907018f, 0.11927438f, 
    -0.24724890f, -0.23323750f, -0.44349250f, -0.02978072f, -0.19529915f, -0.10592854f, -0.02830641f, -0.06215964f, 
    0.02291407f, -0.18586309f, -0.06968044f, -0.01962668f, 0.02129041f, 0.03546895f, -0.02272507f, 0.12385044f, 
    0.01938010f, 0.08020389f, 0.24989845f, 0.13659015f, -0.04686103f, -0.16364025f, 0.12058556f, 0.03454489f, 
    0.02300066f, 0.00686366f, -0.00274169f, -0.04374560f, 0.09610704f, 0.03738996f, -0.03031016f, -0.00483140f, 
    -0.03227360f, -0.05103314f, 0.03736581f, -0.04154614f, -0.13158889f, -0.12177809f, 0.09053572f, -0.05123790f, 
    0.40377986f, 0.07075731f, 0.32637280f, 0.05230404f, 0.13808419f, 0.03186707f, -0.00183403f, -0.04141992f, 
    0.17567027f, 0.11374635f, 0.00636441f, 0.06353042f, 0.11115887f, 0.06599516f, 0.07451107f, 0.08571295f, 
    -0.06414724f, 0.04725192f, 0.02433765f, -0.03145826f, 0.07056220f, -0.77018607f, 0.59487957f, 0.26447934f, 
    0.39430740f, -0.00703818f, 0.13637243f, 0.13461189f, 0.03937259f, -0.17389320f, 0.08597254f, 0.13508269f, 
    0.05871946f, 0.08553822f, 0.16171648f, 0.22572739f, 0.05779394f, -0.11975132f, 0.05829757f, 0.08533056f, 
    -0.00873456f, 0.27046442f, -0.24548292f, 0.46965632f, -0.02135516f, 0.17047700f, 0.00742104f, 0.13138016f, 
    0.32659984f, 0.39989644f, 0.00750188f, 0.10765997f, 0.10293525f, 0.00423639f, 0.15589148f, 0.11397063f, 
    0.15648226f, -0.02095931f, 0.17227328f, 0.03426304f, 0.00255575f, -0.06420138f, 0.16374294f, 0.26146454f, 
    0.03518646f, 0.02731196f, -0.11035284f, 0.16902068f, 0.20089847f, 0.09592086f, -0.00440933f, 0.06794637f, 
    0.00107975f, -0.09906172f, 0.04465113f, -0.03679403f, -0.08677971f, -0.00258421f, -0.10777695f, 0.12571138f, 
    0.32077187f, 0.41512021f, 0.16965325f, 0.08738172f, 0.25626647f, -0.11186274f, 0.18467629f, 0.15960205f, 
    -0.00279598f, 0.09699422f, -0.03815850f, -0.02776034f, 0.04937997f, 0.03530690f, -0.08994134f, 0.10221807f, 
    0.08088931f, 0.15294382f, 0.04053068f, -0.03309533f, 0.09063119f, 0.10931334f, -0.10753622f, -0.04233814f, 
    -0.16677468f, -0.10933470f, -0.08938073f, -0.01138887f, 0.13822789f, 0.03084864f, -0.12873603f, -0.00465981f, 
    0.01117672f, -0.14117946f, -0.15817814f, 0.02043517f, -0.14588764f, 0.04556165f, 0.05400643f, -0.10589720f, 
    -0.04853028f, -0.04640605f, -0.02387100f, -0.20612775f, -0.10982737f, -0.10117730f, 0.06635072f, -0.13354576f, 
    0.21867676f, -0.01432488f, -0.15283661f, 0.07455219f, 0.08175595f, -0.08585854f, -0.01492320f, 0.04506168f, 
    -0.08782548f, -0.13285722f, 0.14026587f, -0.03737682f, -0.20555729f, -0.18700424f, 0.46357429f, 0.16236898f, 
    -0.15185305f, 0.00576684f, -0.14536706f, -0.04445595f, 0.20910956f, -0.10151511f, -0.22833814f, 0.00043542f, 
    -0.04273835f, 0.11534677f, -0.04992383f, -0.07175454f, -0.03113927f, 0.01122924f, 0.06383333f, -0.06121341f, 
    -0.28371435f, -0.27926281f, -0.28738260f, 0.03915604f, -0.09514174f, -0.07872694f, -0.15738393f, 0.02799670f, 
    -0.09165244f, -0.08423845f, -0.13570991f, 0.00224891f, 0.01999415f, -0.02513897f, -0.05268224f, 0.08822495f, 
    -0.04544240f, 0.15835182f, 0.05934758f, 0.00365714f, 0.29330307f, -0.13807732f, 0.23214874f, -0.07478195f, 
    0.05034002f, 0.00144766f, -0.13782005f, 0.16528665f, -0.10743625f, -0.11657395f, -0.07597218f, 0.02446767f, 
    -0.02685231f, 0.03727279f, -0.13171799f, -0.11145321f, 0.16040955f, 0.03930368f, 0.03352759f, 0.08540121f, 
    0.00590330f, -0.16822359f, 0.10151881f, 0.03335881f, 0.02485417f, -0.06218174f, 0.19393468f, -0.03279128f, 
    -0.10890094f, -0.05107478f, -0.12814362f, 0.10618920f, -0.03783583f, -0.12685017f, 0.04062381f, -0.25570890f, 
    0.38562569f, 0.00593776f, 0.16202617f, -0.14730956f, -0.17424105f, -0.14438757f, -0.02049197f, -0.23564138f, 
    0.16423458f, 0.03507487f, -0.12734653f, 0.00766886f, -0.06062872f, 0.04576574f, -0.01564300f, 0.05060026f, 
    0.08667801f, 0.00253468f, -0.05754191f, 0.10995664f, -0.10212816f, 0.00559750f, 0.05587482f, 0.05057193f, 
    0.10678134f, -0.25472561f, 0.12428175f, -0.26725078f, -0.14393501f, -0.04803838f, -0.11256215f, 0.01210464f, 
    -0.06989784f, -0.06971253f, 0.00283908f, 0.03340637f, 0.02784750f, 0.00097985f, -0.16253743f, -0.02279706f, 
    0.00001519f, 0.06279858f, 0.11791614f, 0.12079802f, -0.16639163f, -0.07969204f, -0.22630985f, 0.03416195f, 
    -0.19223316f, 0.17746137f, -0.13086842f, 0.03320400f, -0.05288820f, -0.08477250f, 0.00731879f, -0.02540053f, 
    0.02500090f, 0.01472254f, 0.02464406f, 0.24620225f, -0.07761322f, 0.04498414f, 0.08428052f, -0.11589919f, 
    -0.15327092f, -0.42817348f, -0.29117888f, 0.01219781f, -0.14007403f, -0.02018405f, -0.00667711f, -0.14217767f, 
    -0.02221820f, -0.15742455f, -0.02344063f, -0.00079584f, 0.07807155f, 0.10012147f, -0.04897419f, 0.03292453f, 
    0.00872519f, 0.03237085f, 0.26411694f, 0.19894533f, 0.12793873f, 0.08043196f, 0.10563055f, 0.28001493f, 
    0.27985597f, 0.10140785f, 0.08874142f, 0.05893686f, 0.05945079f, -0.00774340f, -0.03401958f, -0.06898466f, 
    -0.07211044f, 0.01914804f, -0.09569096f, 0.27039352f, 0.07745513f, 0.08986528f, -0.08939932f, -0.13752355f, 
    0.06986743f, 0.08882404f, 0.27567849f, 0.14078178f, -0.03579586f, -0.01590305f, -0.01162561f, 0.09162614f, 
    -0.14116772f, -0.04071732f, -0.07498200f, 0.01638777f, -0.02581410f, 0.10198633f, 0.13788059f, 0.10035039f, 
    -0.03532473f, 0.12524088f, 0.05939952f, 0.13955410f, -0.06626366f, 0.12888370f, 0.16969360f, -0.23292129f, 
    -0.30257455f, -0.13493863f, -0.19527256f, -0.04944719f, 0.01292615f, -0.21136427f, -0.15269391f, 0.00810756f, 
    -0.08417349f, 0.01390655f, -0.15982074f, 0.12173884f, -0.10878419f, -0.02049634f, -0.00747296f, -0.09995351f, 
    0.10627723f, 0.24043366f, 0.33983567f, 0.22738637f, -0.03739404f, -0.03413640f, 0.14968830f, 0.13960800f, 
    0.23292702f, 0.08534970f, 0.03001656f, 0.08555108f, -0.02805039f, -0.03579682f, 0.15187044f, 0.12548694f, 
    -0.07283234f, -0.07961818f, 0.07574328f, -0.01723683f, -0.19846159f, 0.02936197f, -0.03695611f, 0.23322739f, 
    -0.03553987f, -0.12911125f, -0.03576932f, -0.12139764f, 0.14015073f, 0.06261828f, -0.14585732f, 0.02714671f, 
    -0.06668554f, -0.13542621f, 0.13687283f, -0.24962103f, 0.03397544f, -0.01283822f, 0.18089290f, 0.01838464f, 
    -0.15540315f, 0.02192468f, 0.17942840f, -0.00493955f, -0.06661578f, -0.13564822f, -0.11077745f, 0.01738071f, 
    0.07065727f, -0.20512189f, -0.14845720f, -0.01024289f, 0.03324393f, 0.02636162f, 0.07687189f, 0.00789724f, 
    -0.13242052f, -0.04735270f, 0.11242906f, -0.06786753f, -0.05052303f, 0.06925258f, 0.23364563f, -0.11165372f, 
    -0.17544822f, -0.18113914f, -0.05046639f, 0.01630704f, -0.03511352f, -0.14178494f, 0.06650272f, 0.00770271f, 
    0.11001261f, 0.06216783f, -0.05527317f, -0.03495626f, -0.04051251f, -0.02981104f, -0.00290619f, 0.02472623f, 
    0.03297501f, 0.03661314f, 0.44834316f, 0.21777993f, -0.27670076f, 0.03168332f, -0.06246450f, -0.08696724f, 
    0.02488921f, 0.11216956f, -0.03463757f, 0.08071073f, -0.00112903f, -0.02388106f, 0.00207414f, 0.06657293f, 
    -0.07676732f, -0.02628658f, -0.10760561f, -0.13210483f, 0.06508563f, 0.35847589f, -0.05097887f, -0.19288132f, 
    -0.00285073f, 0.10126919f, 0.06624438f, 0.13971023f, -0.01441917f, -0.07984273f, -0.01306474f, -0.07912428f, 
    -0.05133836f, -0.06895930f, -0.00589051f, -0.00570967f, -0.16865227f, -0.07354324f, 0.02813596f, -0.11454079f, 
    0.12224589f, -0.10086308f, -0.02763182f, -0.07494242f, 0.10668430f, 0.13486883f, 0.01681444f, -0.03584781f, 
    -0.12027927f, -0.02544109f, 0.12702723f, 0.00026244f, 0.10217150f, 0.06585057f, 0.03434618f, 0.03230638f, 
    -0.00725631f, 0.09499099f, 0.07776759f, 0.23034731f, 0.17768519f, -0.34218445f, -0.33893538f, -0.03978842f, 
    0.01197324f, 0.10497904f, 0.14810048f, 0.02261235f, 0.03929759f, 0.12568606f, -0.13600834f, -0.04573600f, 
    0.01013904f, 0.03032100f, -0.01392754f, -0.01230481f, 0.10109687f, 0.07550474f, -0.09327520f, 0.12090532f, 
    0.13957182f, 0.20095053f, -0.14645067f, -0.09283786f, -0.20777924f, -0.07359084f, -0.09759879f, -0.05975918f, 
    -0.08713420f, -0.19051243f, 0.08632968f, 0.09526111f, 0.10808080f, -0.02950566f, 0.14240901f, 0.00211967f, 
    0.08570688f, 0.11838506f, 0.02454338f, 0.01555469f, 0.09169102f, -0.05287179f, 0.18227915f, 0.00704015f, 
    -0.00907974f, -0.04772165f, -0.03996596f, 0.02320410f, -0.12251009f, -0.14373389f, 0.06648367f, 0.05864960f, 
    -0.06926964f, -0.03156096f, 0.09602344f, -0.11315453f, -0.12241413f, -0.10105138f, 0.04768300f, -0.08295804f, 
    -0.11839844f, -0.01908301f, 0.36378756f, 0.06315835f, -0.05692809f, 0.06964895f, -0.09516993f, -0.03266136f, 
    0.12982914f, 0.09149813f, 0.00625239f, -0.01004586f, 0.00656722f, -0.06745061f, 0.09588721f, 0.02122753f, 
    0.05543211f, -0.13548738f, -0.07679968f, -0.23173602f, 0.29226512f, 0.07280515f, 0.23413762f, -0.02632717f, 
    0.16702762f, 0.09689803f, 0.00043517f, -0.11082087f, -0.26133436f, 0.19426598f, 0.12853914f, 0.11769588f, 
    0.02049812f, 0.09572212f, -0.06959590f, -0.06130346f, -0.07855999f, 0.09928490f, 0.05348173f, 0.06674980f, 
    0.18140647f, -0.29354313f, -0.13829561f, 0.18827920f, -0.07289344f, 0.04547241f, 0.08953279f, 0.00425689f, 
    0.05004127f, 0.16422732f, -0.00876865f, 0.00913753f, 0.07412245f, 0.04983201f, 0.02015461f, 0.02094592f, 
    0.07929116f, -0.03031649f, -0.06419538f, 0.28050286f, 0.20492567f, -0.41731331f, -0.31936759f, -0.16444783f, 
    -0.21309450f, 0.07569495f, 0.04730284f, 0.13088967f, 0.12116119f, 0.17112444f, 0.24417466f, 0.06512180f, 
    0.07045375f, -0.05479767f, -0.04725347f, 0.00189651f, 0.08965538f, 0.09180407f, 0.07486732f, 0.00710959f, 
    0.29087642f, -0.07200351f, -0.40684587f, -0.14215040f, -0.15416196f, -0.09546424f, -0.09707207f, -0.02662917f, 
    0.11679990f, -0.12891327f, 0.17340779f, 0.01249361f, -0.12316747f, -0.03290867f, 0.03276821f, -0.00419006f, 
    -0.04304446f, 0.02376135f, -0.00459852f, -0.06502172f, 0.22129907f, 0.54246444f, -0.09862686f, -0.11283419f, 
    -0.10162139f, -0.12052473f, -0.00275929f, 0.03717437f, -0.19954075f, -0.17548679f, 0.01089878f, -0.13262828f, 
    0.06676882f, -0.07383724f, 0.05107631f, 0.10076869f, -0.28743216f, 0.13136326f, 0.04737829f, -0.12636608f, 
    0.56575555f, -0.00372191f, 0.24422829f, -0.21494894f, 0.40698728f, 0.02899331f, -0.02131286f, -0.13920625f, 
    0.00319105f, 0.30897039f, 0.11414611f, 0.02316277f, 0.03698964f, 0.02236602f, -0.02555988f, 0.02534983f, 
    -0.01250618f, -0.07905512f, 0.17552365f, 0.01412762f, 0.03949325f, -0.52514505f, -0.51633751f, -0.23950991f, 
    0.07806057f, 0.03831226f, 0.06415495f, 0.14912328f, 0.13971148f, -0.02504569f, 0.08283252f, -0.01948303f, 
    -0.17597318f, 0.05358012f, -0.04966904f, -0.03773824f, -0.02982154f, -0.02594282f, -0.07715125f, -0.04182203f, 
    0.44709545f, 0.20266578f, 0.02081091f, 0.18113168f, -0.15756328f, 0.08912367f, -0.00275398f, -0.13623911f, 
    -0.10093900f, -0.03066770f, 0.07132126f, 0.11094236f, 0.02717776f, -0.02626672f, -0.00035325f, -0.10698603f, 
    0.00660495f, 0.22407459f, 0.05284088f, -0.00311146f, -0.10980703f, 0.06513549f, -0.04675181f, 0.06734078f, 
    0.01031313f, 0.04155951f, -0.06546631f, -0.04351974f, 0.19928418f, 0.05193102f, 0.04160111f, 0.00475327f, 
    -0.16044173f, -0.02264251f, 0.25988349f, 0.01723330f, -0.00509951f, 0.03567116f, -0.17057249f, -0.12346692f, 
    0.21740815f, -0.27572504f, -0.18930902f, -0.03858734f, -0.04339364f, 0.05109616f, 0.07193366f, -0.04414990f, 
    0.17337225f, 0.03878155f, -0.01622373f, -0.07123622f, -0.04441927f, 0.01631152f, -0.02103294f, 0.06967187f, 
    0.03766409f, 0.04919597f, -0.00807603f, 0.06272575f, -0.44327155f, 0.21929535f, 0.13601305f, 0.28924957f, 
    -0.05895493f, -0.02690508f, -0.11771750f, -0.10587475f, -0.20783851f, 0.01313603f, 0.01420657f, 0.02001793f, 
    -0.02247499f, 0.05762991f, -0.00372007f, 0.18250653f, -0.18873473f, 0.01649072f, 0.03297436f, 0.09486633f, 
    0.02208562f, -0.19040862f, -0.04879749f, 0.14315650f, -0.04012037f, 0.02714463f, 0.09536523f, 0.04932860f, 
    0.14477463f, 0.11182234f, -0.05353739f, 0.05805954f, -0.00039247f, 0.03478179f, 0.09462023f, 0.01384696f, 
    0.02768864f, -0.02792575f, 0.01361303f, 0.35515845f, -0.01572404f, 0.18212911f, -0.13610548f, 0.19582304f, 
    -0.28947935f, -0.02441262f, -0.18441814f, -0.02550170f, -0.09503939f, -0.06186000f, -0.02801442f, 0.12801328f, 
    0.03057878f, 0.02677815f, 0.00903605f, -0.01140656f, 0.06688200f, 0.28046310f, -0.03834117f, 0.13192202f, 
    0.17428060f, -0.07747731f, -0.14454669f, -0.08138676f, -0.31373927f, -0.23321743f, 0.07858651f, 0.00741090f, 
    0.05175301f, -0.06701118f, 0.05622959f, -0.01313506f, 0.05335072f, -0.11525661f, -0.03772611f, 0.03398032f, 
    0.22637424f, 0.02144661f, 0.16144328f, 0.17716306f, -0.07102113f, -0.06801181f, 0.40931961f, 0.14531995f, 
    -0.27287808f, 0.09632195f, -0.02562666f, -0.03056554f, 0.17821862f, 0.15563038f, -0.01442450f, 0.01236490f, 
    0.00291318f, -0.02487856f, 0.02795756f, 0.03414191f, -0.16236556f, -0.18412440f, -0.15897046f, -0.24135435f, 
    -0.04387024f, 0.05954035f, -0.00437075f, 0.13031287f, -0.19850454f, 0.07765109f, -0.08303603f, -0.01234059f, 
    0.04178290f, -0.10021251f, -0.04713037f, 0.01717975f, 0.03900055f, -0.02373885f, 0.04252066f, 0.01926723f, 
    0.08665879f, 0.13350108f, 0.12170533f, 0.11040356f, 0.17724051f, -0.04135539f, 0.09535010f, 0.24307556f, 
    -0.01062749f, 0.12278510f, 0.02165775f, 0.01440253f, -0.00556112f, 0.23256940f, 0.09599110f, 0.05902323f, 
    0.04937669f, 0.04787261f, -0.03622480f, 0.09402502f, 0.04665612f, -0.16752118f, -0.21268760f, -0.16636504f, 
    0.02468256f, -0.21950462f, -0.06187866f, 0.10318026f, -0.14415589f, 0.12564579f, -0.04039525f, -0.04567840f, 
    -0.01845881f, -0.06383956f, -0.04161502f, -0.06595971f, 0.08766687f, 0.00061628f, -0.07855162f, 0.02630750f, 
    0.11674789f, 0.01117504f, 0.10635082f, 0.29659560f, 0.14286762f, 0.11111438f, -0.14928797f, 0.19232486f, 
    -0.07562201f, 0.18689846f, 0.06528276f, 0.01986677f, 0.12419824f, 0.22003648f, 0.02661941f, 0.11885764f, 
    -0.08970952f, -0.07534701f, 0.05154571f, -0.01055398f, -0.13813548f, 0.08472075f, -0.07873891f, -0.03568904f, 
    -0.08995591f, 0.09387203f, 0.17596298f, -0.06297798f, 0.07533789f, 0.03629240f, -0.04230609f, -0.09111217f, 
    -0.03825485f, -0.03071155f, -0.01658219f, -0.01994611f, 0.05431209f, 0.03771349f, 0.01724125f, -0.15502721f, 
    -0.22434418f, -0.17932917f, 0.04757960f, -0.28904623f, -0.01928120f, 0.30455840f, 0.10093183f, 0.28822896f, 
    -0.18097278f, -0.14026387f, -0.05501346f, -0.08132349f, -0.03556716f, -0.10260037f, 0.02220852f, -0.08827965f, 
    0.03792980f, -0.04614061f, 0.02395933f, 0.14781362f, 0.06703158f, 0.12647021f, -0.01122052f, 0.01116136f, 
    0.11495557f, -0.49945876f, 0.11303078f, -0.14521016f, -0.06980330f, 0.05408300f, -0.05711152f, 0.27503076f, 
    -0.08697802f, 0.16184680f, -0.04416250f, 0.09581120f, 0.05714269f, 0.04445035f, 0.07300313f, -0.11628586f, 
    -0.11761547f, 0.05953474f, 0.05064896f, 0.00338702f, -0.05819357f, -0.07198516f, 0.04931019f, -0.05356637f, 
    -0.14848782f, -0.09324083f, 0.03431258f, -0.03311590f, -0.11259274f, 0.00595182f, 0.16781420f, 0.07756999f, 
    0.21047674f, 0.02905881f, 0.06618921f, -0.02730732f, 0.19283962f, 0.09032065f, 0.13312778f, 0.15977108f, 
    -0.17230648f, 0.11974011f, 0.07767134f, 0.12915841f, -0.09972228f, -0.10859683f, -0.07976605f, -0.03744308f, 
    -0.08675037f, -0.13163146f, 0.19969639f, -0.00728793f, 0.04393803f, 0.00605321f, 0.16626410f, 0.01840276f, 
    0.07988505f, 0.11891845f, 0.15219428f, 0.09359938f, 0.07119986f, 0.12217201f, 0.12717792f, 0.03356121f, 
    -0.17993091f, -0.12390534f, 0.01582570f, -0.04129479f, -0.07016405f, -0.14175096f, 0.10545004f, -0.00864856f, 
    0.00610944f, 0.06818241f, 0.16539009f, 0.00261410f, 0.04652298f, 0.09173722f, 0.11974330f, -0.06192339f, 
    -0.05320572f, -0.04086396f, -0.52224511f, 0.15203403f, 0.01136165f, 0.05794995f, -0.12211006f, 0.00264665f, 
    0.02314603f, 0.08617163f, -0.01360112f, 0.00907047f, 0.03162427f, 0.03418324f, -0.05006701f, -0.04370956f, 
    0.01962236f, -0.03319441f, 0.07544184f, 0.10503860f, -0.70473713f, -0.27753425f, 0.06953949f, -0.11264994f, 
    -0.04984940f, 0.27509591f, -0.13002408f, -0.30287650f, 0.01306009f, -0.01762380f, 0.09495357f, 0.00602127f, 
    0.09191141f, 0.07784158f, -0.03544394f, 0.08032068f, -0.06905495f, 0.26200542f, 0.34415218f, 0.08944385f, 
    0.29292080f, 0.29131442f, 0.01587932f, -0.04411540f, 0.01492403f, -0.03747132f, -0.02530192f, 0.22041672f, 
    0.06666914f, 0.01106112f, 0.12976240f, -0.12608454f, 0.04873095f, -0.06419341f, -0.04337505f, 0.10578120f, 
    -0.00515588f, 0.00805261f, -0.04213859f, -0.17714073f, -0.57587886f, -0.26050884f, 0.07580387f, -0.05067727f, 
    -0.41732681f, 0.14729501f, -0.05742451f, -0.02252217f, -0.06531101f, -0.10029582f, 0.07133261f, 0.11086721f, 
    0.12730263f, 0.01111379f, -0.03101810f, 0.06652538f, -0.01148282f, -0.03825575f, -0.04693145f, -0.13338231f, 
    -0.00808502f, 0.07940236f, 0.00965646f, -0.00248467f, 0.02706017f, 0.05842124f, 0.09287651f, -0.01716814f, 
    -0.04017572f, -0.05615535f, -0.01125152f, -0.10120942f, -0.01194016f, 0.02807021f, -0.02770889f, 0.11281221f, 
    -0.09387469f, -0.10126324f, -0.09296717f, -0.16817299f, 0.07376948f, 0.06621116f, -0.11361205f, 0.03465351f, 
    0.12496246f, -0.00191984f, 0.06181861f, 0.08942825f, 0.00047670f, -0.04730323f, -0.02117040f, -0.20355603f, 
    0.17248532f, 0.03804861f, 0.02948083f, 0.16003940f, -0.03043852f, -0.01947928f, 0.04750267f, 0.17975612f, 
    0.05827510f, -0.07743408f, 0.25339186f, 0.30924785f, 0.03338693f, -0.08023622f, -0.03350146f, -0.13838606f, 
    0.05580738f, -0.00423865f, 0.01493124f, 0.02710315f, 0.04234260f, 0.08064343f, -0.03215702f, -0.04340475f, 
    0.00149638f, -0.13961504f, 0.16360405f, 0.08704043f, 0.33382550f, 0.09223063f, 0.02531439f, 0.13593550f, 
    -0.08715355f, -0.01584526f, 0.06639621f, 0.28652248f, 0.03922698f, -0.11357472f, -0.05170537f, 0.01534889f, 
    0.16495292f, -0.00046293f, 0.05115805f, 0.19207355f, 0.05179761f, 0.02358140f, 0.21335205f, 0.01454489f, 
    -0.59901285f, -0.31082943f, 0.05703298f, -0.09963043f, -0.23248833f, -0.05595432f, -0.02592322f, -0.08432181f, 
    -0.13014166f, -0.16729529f, 0.06502184f, 0.06322530f, 0.01699062f, -0.01040887f, -0.02397205f, 0.04727346f, 
    -0.00706146f, -0.01317272f, 0.01193918f, -0.18153921f, -0.11314160f, 0.07063178f, 0.16314970f, 0.02610740f, 
    -0.19786133f, -0.04891415f, -0.16591954f, -0.14275655f, -0.13080454f, -0.12756625f, -0.14880157f, -0.13569778f, 
    0.24864350f, 0.12627570f, 0.11714305f, 0.02425901f, -0.06005875f, -0.11012073f, -0.03258587f, -0.09062465f, 
    -0.09566739f, 0.26354823f, 0.13452832f, 0.23742697f, -0.26796016f, -0.04055427f, -0.05830420f, -0.23537599f, 
    -0.23703183f, 0.17858422f, -0.08144518f, -0.05289808f, 0.21081233f, 0.07615584f, 0.11704423f, 0.08197942f, 
    0.01490964f, -0.07803856f, 0.07081415f, 0.12933944f, -0.51217049f, 0.08523600f, -0.41017908f, 0.39730394f, 
    0.26780894f, 0.17189808f, 0.05106182f, -0.05888419f, 0.07945564f, 0.13654110f, 0.01333076f, 0.20042525f, 
    -0.10356301f, 0.03272968f, 0.02494080f, 0.15689938f, 0.26871824f, 0.16538917f, 0.12196293f, 0.23036176f, 
    -0.06547784f, -0.09811426f, 0.14505100f, -0.07247857f, -0.43366995f, 0.25501299f, 0.31384730f, 0.19485582f, 
    0.10395908f, -0.10529593f, 0.08514867f, 0.11562978f, 0.05327741f, 0.07697035f, 0.25624427f, 0.14110430f, 
    0.10911186f, 0.29987359f, 0.05180383f, -0.16170236f, 0.09698207f, 0.12666810f, 0.41172534f, -0.14301927f, 
    -0.69095784f, -0.19134434f, -0.28108060f, -0.28539318f, 0.16130765f, 0.07986033f, -0.09472162f, 0.11793245f, 
    0.27261934f, 0.03276088f, 0.03446118f, 0.07483669f, -0.04161661f, 0.02305607f, 0.00141188f, 0.02329203f, 
    0.28179851f, 0.10207741f, -0.18154393f, 0.15003861f, 0.28483158f, 0.05755848f, 0.14490403f, 0.05839233f, 
    0.03948254f, 0.02240225f, -0.02409006f, -0.01021337f, -0.00732636f, -0.02210745f, -0.07597643f, -0.06158273f, 
    0.07677235f, -0.19011535f, -0.04825766f, 0.08556979f, 0.01013546f, -0.09209502f, 0.34092191f, 0.25418979f, 
    -0.16204667f, 0.08501411f, -0.13133898f, -0.18305196f, -0.09645166f, 0.08872329f, 0.00374802f, 0.00497683f, 
    0.06694221f, 0.05608334f, -0.17818594f, -0.04612699f, 0.07840698f, 0.02484407f, 0.14533442f, 0.01303542f, 
    -0.27958006f, -0.13464500f, 0.34850627f, 0.32722402f, -0.19675153f, 0.14021598f, -0.10143425f, -0.04774863f, 
    -0.25064486f, 0.06761187f, 0.05080841f, 0.05570456f, 0.18699497f, -0.01888253f, -0.07083740f, -0.03194328f, 
    -0.06056494f, 0.04686779f, -0.07144424f, -0.08417460f, 0.67821932f, 0.24843222f, -0.24681695f, -0.08142435f, 
    -0.03842113f, 0.10818795f, 0.11115012f, 0.04114881f, 0.23006713f, 0.12930393f, 0.11024435f, 0.02630116f, 
    -0.00977441f, 0.01249918f, -0.02064809f, 0.00134549f, 0.14861435f, -0.19567995f, 0.02944900f, 0.16363621f, 
    -0.08324280f, -0.01908897f, 0.29361561f, 0.20484744f, -0.05361354f, -0.08260179f, -0.08451771f, -0.03703731f, 
    -0.17407788f, -0.08354253f, 0.05712153f, 0.04517421f, 0.07770956f, -0.04918087f, -0.04496988f, 0.02935561f, 
    -0.00716345f, 0.02836815f, 0.04563339f, -0.23155883f, 0.13825972f, 0.18715829f, -0.16540956f, -0.04255421f, 
    0.22746384f, 0.15904655f, 0.31848499f, -0.06000748f, 0.05461953f, 0.01768840f, 0.05733476f, -0.03360861f, 
    -0.00200347f, 0.01082929f, -0.05543812f, 0.02886559f, -0.02469488f, -0.12265113f, -0.10459293f, 0.00060571f, 
    -0.09293708f, 0.22209713f, -0.08482510f, 0.11864638f, 0.24586210f, -0.11602543f, 0.08270767f, -0.10399448f, 
    -0.09629089f, -0.15123622f, -0.02102291f, 0.11608019f, 0.11491583f, 0.06467680f, 0.01061866f, 0.06967515f, 
    -0.28795376f, -0.04073825f, -0.29208013f, -0.03866336f, -0.06192433f, -0.02589297f, -0.47712994f, 0.27615488f, 
    -0.01557679f, -0.18202920f, 0.02517293f, 0.07263561f, 0.04528841f, 0.02184689f, 0.04431923f, 0.02871332f, 
    0.08283501f, 0.01743021f, -0.03706350f, -0.12790912f, 0.15480608f, 0.06422500f, 0.10334501f, 0.02007400f, 
    0.04223508f, 0.02966627f, -0.10509551f, 0.12762345f, 0.10627991f, 0.13370028f, 0.03422628f, 0.06061057f, 
    0.04068650f, 0.15825222f, -0.01746066f, 0.01304060f, 0.02511417f, -0.02247765f, -0.06776761f, 0.03786875f, 
    -0.10614223f, -0.29730022f, -0.02977995f, -0.02486604f, 0.10572509f, 0.06632306f, 0.08509043f, 0.00244088f, 
    0.16593364f, 0.11485224f, -0.07038277f, -0.00224464f, -0.02297432f, -0.08148320f, 0.02557885f, -0.01937006f, 
    -0.01324818f, -0.01205323f, 0.04288666f, 0.01606338f, 0.15570587f, 0.09797607f, 0.22136125f, 0.19658944f, 
    -0.21537560f, -0.07085224f, -0.02028420f, 0.16498204f, -0.02167598f, 0.20905177f, -0.02881401f, -0.01718759f, 
    0.11338685f, 0.06264985f, 0.10921756f, -0.13486561f, 0.08599871f, -0.00249986f, -0.01394386f, 0.02108911f, 
    -0.06842235f, -0.20793752f, -0.22145297f, -0.39428371f, -0.09437685f, -0.12401091f, 0.13025050f, 0.16662237f, 
    0.06535833f, 0.01107403f, 0.05472460f, 0.10600316f, -0.08088410f, -0.04138399f, 0.07678190f, -0.03334605f, 
    0.08069217f, 0.15240461f, 0.08675800f, -0.00785619f, 0.15484908f, 0.24913472f, 0.07212497f, 0.22791094f, 
    0.48687088f, -0.22702083f, -0.32592010f, -0.04703636f, -0.13176388f, 0.04034490f, 0.08344914f, 0.07993665f, 
    -0.03638999f, -0.07170071f, 0.01507145f, -0.02158422f, -0.00827390f, 0.02351034f, 0.03607025f, 0.25871480f, 
    0.29824165f, 0.18894576f, 0.17312165f, 0.39786467f, 0.36962104f, 0.16807650f, 0.04707942f, -0.03177928f, 
    0.22187085f, 0.05191974f, 0.06916478f, 0.06494828f, 0.00018828f, -0.01126470f, 0.05900477f, 0.04218885f, 
    -0.05887717f, 0.00367401f, -0.09186276f, -0.02377479f, 0.07135295f, 0.12912419f, 0.06984161f, 0.00831400f, 
    -0.24108759f, 0.12776451f, 0.04696698f, -0.08549280f, -0.33933407f, -0.12754449f, 0.01371892f, -0.05795173f, 
    0.26871157f, -0.05050180f, -0.11506280f, 0.09694526f, 0.03453598f, 0.01218007f, 0.05438388f, 0.06250145f, 
    -0.06588960f, 0.08680885f, -0.03286393f, 0.18298787f, 0.15740447f, 0.23015361f, 0.06474005f, -0.03610036f, 
    0.02584244f, 0.06416634f, 0.02501683f, 0.05871447f, -0.01004200f, -0.08899466f, -0.02429084f, -0.05644667f, 
    0.02333763f, -0.05022558f, -0.03600199f, 0.02872011f, -0.15242325f, -0.08545070f, -0.17563859f, -0.16037238f, 
    0.24278973f, 0.18549657f, 0.12779756f, -0.10092480f, 0.15496285f, 0.06053120f, -0.00638976f, 0.01218403f, 
    0.02944151f, -0.05883293f, 0.07497853f, 0.04680803f, -0.03323637f, -0.03885516f, -0.07014723f, 0.03321351f, 
    -0.10264422f, -0.02104202f, -0.12185401f, -0.09222541f, 0.23827584f, 0.17247327f, -0.08227892f, 0.05455827f, 
    0.17040637f, 0.03747201f, 0.01898972f, 0.02580727f, -0.01037420f, -0.04999844f, 0.02760376f, 0.05543839f, 
    -0.01336837f, 0.03725431f, -0.04707325f, 0.13636470f, -0.00387586f, 0.02402393f, -0.09542222f, 0.02239051f, 
    -0.03672212f, -0.04127545f, 0.01803677f, -0.04283462f, -0.01400848f, 0.01040760f, -0.02186365f, 0.00840853f, 
    -0.03129782f, -0.03025986f, -0.00025930f, -0.02085040f, 0.02897351f, 0.01665809f, -0.03150281f, 0.00545817f, 
    -0.00057616f, -0.01777321f, 0.00896015f, -0.03002297f, -0.01821335f, -0.00156858f, 0.01514346f, -0.00008775f, 
    -0.00335813f, -0.00387031f, 0.00419151f, -0.03815240f, 0.02622261f, 0.01453331f, 0.01111517f, 0.02122691f, 
    -0.03637550f, -0.02291994f, -0.04703751f, 0.02409350f, -0.03893359f, 0.01297758f, -0.04056466f, -0.02123838f, 
    -0.02577492f, -0.02087543f, -0.03485075f, 0.01772160f, 0.02798044f, -0.02168730f, 0.01745377f, -0.00255302f, 
    -0.00261427f, 0.00335677f, 0.02059510f, -0.00979852f, 0.02638991f, -0.03145886f, -0.00200470f, -0.03182521f, 
    -0.01966732f, -0.02664617f, -0.00034620f, 0.02931883f, 0.02336177f, 0.02384499f, -0.00833277f, -0.03198602f, 
    -0.00265235f, 0.00363966f, -0.03893570f, 0.00881915f, 0.00280366f, -0.02200575f, 0.02501605f, -0.04125446f, 
    -0.00042308f, 0.02402364f, 0.02126768f, 0.03010244f, 0.03111171f, 0.02635557f, -0.00841417f, 0.00550478f, 
    -0.02477364f, -0.03452748f, -0.03217469f, -0.04776151f, 0.00554759f, -0.02819604f, -0.01525255f, 0.02006502f, 
    -0.02436365f, -0.02845664f, 0.02810946f, 0.00394660f, -0.01583753f, -0.01571009f, 0.01887995f, 0.02764689f, 
    0.02495939f, -0.00547950f, -0.04551618f, 0.01526782f, -0.00775467f, -0.01590827f, 0.00978104f, 0.02949172f, 
    0.00010656f, -0.04338270f, -0.03154948f, -0.04310063f, 0.03039977f, 0.00684233f, 0.01339052f, 0.02133925f, 
    -0.01796516f, 0.01156886f, 0.01581153f, 0.01971728f, 0.01772675f, -0.02813636f, 0.01854582f, -0.03712736f, 
    0.01541667f, -0.01696482f, 0.01483896f, 0.01299073f, -0.03967230f, 0.00405510f, 0.02608176f, 0.01805696f, 
    -0.01774482f, -0.04379923f, -0.01535758f, 0.00571639f, -0.04035203f, -0.01252724f, 0.01698004f, 0.01301594f, 
    0.01215445f, 0.02064994f, -0.03283777f, -0.01805498f, -0.01867846f, 0.00142410f, 0.01280127f, -0.02844539f, 
    -0.02652209f, -0.03015196f, -0.00942355f, -0.00831387f, -0.02106728f, -0.04070345f, -0.01377777f, 0.00376330f, 
    -0.01995838f, -0.01037142f, -0.01100792f, -0.04071964f, -0.03745477f, -0.00704527f, -0.00684821f, -0.03607913f, 
    -0.01790222f, -0.01612692f, -0.02484401f, -0.02945423f, 0.03102005f, -0.01337646f, 0.01004165f, 0.01121199f, 
    0.02969121f, -0.03133335f, -0.02125469f, 0.03083696f, 0.01409585f, -0.01732186f, -0.00947076f, 0.00859541f, 
    -0.03634103f, 0.01441385f, -0.03724648f, 0.02657659f, 0.00372495f, 0.01044902f, 0.00002199f, -0.01530366f, 
    0.01124241f, 0.00500139f, -0.03161770f, -0.02772254f, 0.01721029f, -0.00639521f, -0.00393970f, -0.01544112f, 
    -0.03420972f, -0.00939734f, 0.01004596f, -0.00796640f, -0.03208908f, 0.01390103f, -0.03743302f, 0.00675109f, 
    0.01014004f, 0.02052979f, 0.00804633f, 0.00427084f, 0.01936024f, -0.03823601f, -0.04634795f, -0.00063780f, 
    0.02367751f, -0.00022403f, -0.02825191f, 0.00935241f, -0.00911554f, -0.04340618f, 0.02204998f, 0.00715198f, 
    0.02963531f, -0.00174103f, -0.03369812f, -0.03634467f, -0.01198480f, -0.04480130f, 0.00081738f, 0.01941151f, 
    -0.00746048f, -0.01657207f, -0.01743884f, 0.02243093f, 0.00276991f, -0.00757479f, -0.04223794f, -0.02489967f, 
    -0.00425810f, -0.03489687f, 0.03000453f, -0.04719892f, -0.01062356f, 0.00535239f, -0.04475277f, -0.00065908f, 
    -0.01021938f, 0.01965489f, 0.01120516f, -0.01347799f, 0.01368560f, -0.01953948f, -0.04364092f, 0.02742748f, 
    0.01910365f, -0.03969682f, -0.03801900f, -0.01410879f, -0.02721696f, 0.02198130f, 0.02701879f, -0.01959255f, 
    -0.00476025f, 0.00923557f, -0.02157251f, 0.02728960f, -0.01115873f, -0.03938819f, 0.01970149f, -0.01012049f, 
    0.03234981f, -0.02921374f, -0.00091592f, -0.04240766f, -0.01368641f, -0.01260097f, -0.00735346f, -0.04132289f, 
    0.01624361f, 0.02392639f, -0.02335067f, -0.00578192f, 0.03168155f, 0.02420577f, 0.01272110f, -0.02584635f, 
    0.00816481f, 0.01365567f, 0.00153067f, -0.02481548f, 0.02522278f, -0.02838920f, -0.04047722f, -0.02347924f, 
    -0.04494014f, 0.02781210f, -0.02887685f, 0.00880767f, 0.02383517f, 0.02619997f, -0.04097063f, -0.01364492f, 
    0.00820023f, -0.00230313f, -0.04076508f, -0.03125922f, -0.02478137f, 0.02358111f, 0.01553311f, 0.03875115f, 
    -0.02984215f, 0.00369075f, -0.04382002f, -0.02630577f, -0.01947908f, -0.02382034f, -0.02812436f, 0.01065402f, 
    -0.00750936f, -0.00416132f, -0.02984984f, -0.02584530f, 0.02139619f, -0.03298413f, -0.00758949f, -0.02787847f, 
    0.01070922f, -0.00753538f, 0.00271863f, -0.00652654f, -0.00065484f, -0.01281878f, 0.01363473f, 0.02289210f, 
    0.02827589f, -0.01616897f, -0.01887669f, -0.02025765f, 0.01251402f, -0.02587978f, 0.02124157f, 0.02088691f, 
    0.01773200f, -0.00148567f, -0.02036636f, 0.00203688f, 0.02554476f, -0.02082143f, -0.00598896f, -0.03412123f, 
    -0.04418788f, -0.03813093f, 0.00348643f, 0.01334086f, -0.00035727f, -0.02756618f, 0.02699828f, 0.02487957f, 
    -0.03119124f, 0.02176702f, -0.01629006f, -0.02323948f, 0.02851074f, -0.03373056f, 0.01729402f, 0.02188295f, 
    -0.02453282f, -0.03576029f, -0.02130180f, 0.00426953f, 0.01578571f, -0.00612434f, -0.04169384f, -0.03618670f, 
    0.02331711f, 0.02426865f, -0.02007838f, -0.01232447f, 0.01452092f, 0.00141136f, -0.00058567f, 0.00214432f, 
    -0.02928402f, 0.01678329f, 0.02804115f, 0.00353787f, 0.01386047f, -0.00755189f, 0.00316013f, -0.03060997f, 
    -0.00569984f, 0.01229365f, -0.03122915f, -0.02229324f, -0.03097151f, -0.00678195f, -0.04823587f, 0.00041103f, 
    -0.01659404f, 0.00158881f, 0.01634680f, -0.02520281f, -0.02001739f, 0.02864063f, 0.02791562f, 0.02449535f, 
    -0.01023515f, -0.00647451f, -0.02640389f, -0.04344238f, 0.01081855f, -0.00047881f, -0.01355588f, -0.04214894f, 
    -0.00358508f, -0.01946998f, -0.02946650f, 0.02989302f, 0.02848425f, -0.03892704f, -0.04049351f, 0.01900230f, 
    -0.04644634f, -0.00844840f, 0.01337369f, -0.00258906f, 0.00481453f, 0.02421375f, -0.01776015f, -0.04401269f, 
    0.00645544f, 0.02505630f, -0.01574912f, -0.02692069f, -0.02822221f, -0.02324721f, 0.00322090f, -0.04063572f, 
    -0.00751894f, -0.02490947f, -0.03474018f, -0.03616260f, -0.01193018f, -0.04628577f, -0.01129075f, 0.00077199f, 
    0.02814389f, -0.04064930f, 0.03188727f, 0.01977217f, -0.02636588f, -0.01882447f, 0.01108725f, -0.03885014f, 
    -0.02847076f, -0.03584664f, 0.01561906f, -0.01864476f, -0.03624593f, -0.02463722f, -0.00350118f, 0.01107536f, 
    -0.00247817f, -0.04433863f, -0.01755803f, 0.02136764f, -0.01179597f, -0.02586449f, -0.00640706f, -0.01706647f, 
    -0.01652480f, -0.03198786f, 0.02008744f, 0.02285408f, 0.00141427f, -0.03987796f, -0.01400848f, -0.03204263f, 
    -0.01313932f, 0.02401495f, -0.03121051f, -0.04215069f, -0.01330364f, -0.02521518f, -0.00955466f, -0.02208597f, 
    0.02266561f, -0.01196344f, -0.04450821f, 0.00557064f, -0.02603182f, 0.01061324f, -0.03855592f, -0.02677765f, 
    -0.02540695f, -0.01777719f, -0.02388560f, 0.02291139f, -0.01956472f, -0.00026268f, -0.04437615f, 0.02881213f, 
    0.01246010f, -0.00908120f, 0.00971487f, 0.01463530f, 0.00527021f, -0.02626570f, 0.00823670f, 0.00636451f, 
    -0.03596187f, -0.03812536f, 0.03005847f, -0.04509853f, 0.00570500f, -0.00980674f, 0.01938317f, 0.03003046f, 
    -0.01994343f, 0.00704144f, -0.03375435f, -0.03112849f, 0.02074591f, -0.00875718f, -0.00080555f, -0.01538756f, 
    -0.02343762f, 0.00108611f, -0.01387642f, 0.02772888f, 0.00520918f, -0.00431146f, -0.02045671f, -0.02607449f, 
    0.02615618f, -0.04229411f, 0.00741075f, -0.03620474f, -0.04111608f, -0.02102279f, 0.01176230f, -0.00233764f, 
    -0.04420819f, 0.02609482f, -0.01794050f, -0.00198506f, 0.00801607f, -0.03449313f, 0.00324176f, -0.04476035f, 
    0.01683916f, 0.00500723f, -0.02654947f, -0.04399427f, 0.00747763f, 0.02004812f, -0.00141881f, 0.00408219f, 
    0.01217983f, 0.00904134f, 0.00927608f, -0.01678820f, 0.01652404f, -0.04429647f, -0.03989636f, -0.03515878f, 
    -0.02094255f, 0.03262681f, -0.04073484f, -0.02928659f, -0.02674016f, 0.00844803f, 0.01826583f, -0.03780286f, 
    -0.02285258f, -0.00665191f, -0.00186170f, 0.02902460f, -0.00870693f, -0.00060859f, -0.04065917f, -0.03898352f, 
    0.00036287f, 0.01380506f, 0.02554058f, -0.01768410f, -0.00350847f, -0.01920477f, 0.02739961f, -0.04015987f, 
    -0.04542061f, -0.00632573f, -0.01010083f, -0.00717803f, 0.00389305f, 0.00066643f, -0.03049352f, -0.00144227f, 
    0.00928572f, 0.02452578f, -0.00425814f, 0.02659409f, -0.01719168f, -0.01039904f, -0.04007426f, -0.00534214f, 
    0.00073018f, -0.01391471f, 0.02999090f, 0.02099728f, -0.03484342f, -0.03508056f, -0.03247156f, -0.03208259f, 
    0.00949471f, -0.01251391f, 0.00419639f, -0.00963857f, 0.01605834f, -0.02980649f, -0.00569557f, -0.01979232f, 
    0.02723429f, 0.02908560f, -0.01110514f, 0.02251534f, -0.02854084f, 0.02961295f, 0.00283913f, -0.04087723f, 
    -0.00439380f, -0.01150382f, 0.01551796f, 0.00007497f, -0.04359472f, -0.02579894f, 0.01429342f, 0.02502623f, 
    -0.04425834f, -0.00507422f, -0.04588667f, 0.00663129f, 0.01820733f, -0.01768103f, -0.04262979f, -0.02019621f, 
    0.19461678f, -0.21327460f, -0.01397259f, -0.17006753f, 0.31634894f, -0.11726271f, 0.10879587f, 0.01192222f, 
    -0.00526232f, 0.02457139f, -0.03270899f, -0.02284409f, -0.04745815f, -0.00584138f, 0.07742532f, -0.05129678f, 
    0.03434585f, -0.09811665f, 0.15996899f, 0.07504033f, 0.28744489f, -0.09733696f, -0.02694139f, 0.16977453f, 
    0.05602941f, 0.26421031f, 0.12621219f, -0.05399779f, 0.17061034f, 0.04523708f, -0.04594886f, -0.07693297f, 
    0.13988496f, 0.09771520f, 0.09716485f, -0.02574372f, 0.02093208f, 0.14649019f, 0.25780967f, 0.07628973f, 
    0.31683609f, 0.41142657f, -0.00832517f, -0.03273501f, 0.03636169f, -0.06279192f, 0.04826432f, -0.02428452f, 
    0.05055625f, -0.03959334f, 0.08066564f, 0.01658544f, 0.17941424f, -0.06724598f, 0.04273045f, 0.06771114f, 
    0.14620008f, 0.03646870f, -0.06508831f, -0.03364071f, -0.32644522f, 0.01845169f, -0.01423597f, 0.24849005f, 
    0.30803803f, -0.00359508f, 0.11705000f, 0.01699647f, 0.04000929f, -0.00027069f, 0.02956010f, 0.09281577f, 
    0.04450126f, -0.01707415f, -0.00279798f, 0.01415735f, -0.07616299f, 0.01556973f, 0.01522709f, -0.03330602f, 
    0.03749188f, -0.14519213f, 0.04561969f, 0.02403707f, -0.05509743f, 0.06169704f, 0.03277219f, -0.00487497f, 
    -0.01630773f, 0.03883684f, -0.01218983f, 0.10443173f, 0.18227714f, -0.00493230f, 0.07705374f, -0.07261471f, 
    -0.11043659f, -0.06052937f, -0.12431935f, -0.13122423f, 0.32929617f, 0.21191816f, -0.01108660f, 0.04011080f, 
    -0.18071572f, 0.14882335f, 0.04553669f, 0.10898182f, 0.01147537f, 0.06252468f, 0.10264672f, -0.05490166f, 
    0.07980859f, -0.02019782f, -0.02446162f, 0.02055575f, -0.12559398f, -0.21408747f, -0.04442044f, -0.01053050f, 
    -0.06437739f, -0.10775892f, -0.24597505f, 0.32871416f, 0.29836300f, 0.00492254f, 0.00116014f, -0.02927534f, 
    0.05219480f, 0.02274291f, -0.17608759f, 0.02903489f, -0.03924058f, 0.00545535f, 0.14967087f, -0.07337933f, 
    0.00604182f, 0.13043262f, -0.09358809f, 0.11550493f, -0.05407759f, 0.51001191f, 0.10655315f, 0.27428159f, 
    -0.05219467f, -0.12985736f, 0.06349826f, 0.03664111f, 0.02086924f, -0.14481889f, -0.05350070f, 0.10105932f, 
    -0.00956707f, 0.02336100f, -0.05082921f, 0.06998043f, 0.07662334f, 0.10342924f, -0.02036248f, -0.03598117f, 
    -0.26253644f, 0.04833366f, -0.17820416f, 0.14667849f, 0.24935022f, 0.07620826f, 0.02681941f, 0.04796949f, 
    0.16020198f, 0.05192580f, 0.10143543f, 0.01541243f, -0.08111366f, -0.01022729f, 0.00725147f, 0.03188675f, 
    -0.10729221f, 0.09495150f, -0.02577333f, 0.03178632f, -0.22101593f, -0.04376246f, 0.04246083f, -0.08624031f, 
    0.04235113f, -0.04069841f, -0.08937597f, -0.02794367f, 0.04779452f, -0.00362836f, -0.18040422f, 0.07521510f, 
    -0.03438767f, 0.02466979f, 0.00215870f, 0.01902468f, -0.11361635f, -0.09449306f, -0.00957578f, -0.03292671f, 
    -0.19218108f, 0.17745961f, 0.32636908f, -0.07025061f, 0.09693833f, 0.18225369f, -0.05602669f, 0.02398621f, 
    -0.05491570f, 0.11039415f, -0.23940225f, 0.03093967f, 0.08112185f, -0.06020870f, 0.03975739f, -0.02066677f, 
    -0.00623683f, -0.06271792f, -0.02812624f, -0.01103105f, 0.13888772f, -0.60678780f, 0.07098953f, 0.04646817f, 
    -0.10781030f, 0.14168942f, 0.04688505f, -0.01443373f, 0.00596878f, 0.17568843f, -0.11874203f, 0.05643963f, 
    0.09095241f, 0.08286863f, -0.03872465f, 0.10705727f, 0.00988809f, -0.05638378f, 0.19780692f, 0.35273203f, 
    -0.37319359f, 0.55938137f, -0.22073348f, 0.24093390f, -0.00295533f, 0.05406164f, 0.15131383f, 0.06991356f, 
    -0.04244256f, -0.05625897f, -0.03966094f, 0.04206843f, 0.03758236f, 0.13941000f, -0.04164563f, 0.14175643f, 
    -0.03217871f, 0.22060432f, 0.06709996f, 0.13675031f, -0.38027984f, 0.29664657f, 0.20969756f, 0.24361831f, 
    0.23810357f, -0.08233251f, -0.09739606f, -0.11125065f, -0.09742244f, -0.05636445f, -0.02167796f, 0.07633838f, 
    0.08530890f, -0.07093871f, 0.02588599f, -0.01281135f, 0.01347730f, -0.02284808f, -0.00926385f, -0.00647514f, 
    -0.17375162f, -0.01175910f, 0.04928949f, -0.14028528f, 0.05449454f, -0.10279699f, 0.04613400f, -0.04117923f, 
    -0.06046676f, 0.06769271f, 0.00192432f, 0.01569638f, -0.05718848f, 0.01487872f, -0.01215236f, 0.18141304f, 
    0.00693568f, 0.19926928f, -0.03697005f, -0.04874127f, 0.03752152f, 0.07217368f, -0.08301087f, 0.12374037f, 
    0.33537740f, 0.04926234f, -0.06319085f, -0.03797227f, 0.06300039f, 0.15710950f, -0.09717924f, 0.05528548f, 
    0.04270400f, -0.03222973f, 0.03544266f, -0.03980850f, 0.15255454f, 0.16875474f, 0.17674242f, 0.19339062f, 
    -0.13682640f, 0.07092708f, 0.10515141f, 0.14318098f, 0.48460004f, -0.03843126f, 0.02012825f, -0.04208107f, 
    0.07707125f, 0.08921592f, -0.11110338f, 0.15315956f, 0.01709277f, 0.01235533f, -0.03614978f, 0.05922139f, 
    -0.11547285f, -0.03230591f, 0.06572711f, 0.03752366f, 0.10994014f, -0.23592025f, 0.45136312f, -0.08286959f, 
    0.28048384f, -0.07193343f, 0.01001956f, -0.01081667f, 0.06589276f, -0.10230341f, 0.05127757f, -0.03007794f, 
    -0.04426963f, -0.00170086f, -0.00620473f, -0.00042776f, 0.07611373f, 0.06617789f, 0.06592450f, -0.03778911f, 
    -0.18670608f, -0.02175632f, -0.23183089f, 0.29253620f, 0.24362999f, 0.03972966f, -0.05429485f, -0.04622662f, 
    0.07316365f, 0.00838602f, -0.02830827f, -0.02722332f, -0.04276956f, -0.07372735f, -0.02767448f, -0.01001512f, 
    -0.00169948f, 0.06823763f, -0.16372196f, -0.01422615f, -0.01810228f, -0.17411530f, 0.08284993f, -0.17072317f, 
    0.16623424f, 0.00247691f, 0.09695400f, -0.05363482f, -0.07159289f, 0.03544676f, 0.11267093f, 0.03513414f, 
    0.02648629f, -0.03092770f, 0.11288198f, 0.03451043f, -0.00592633f, 0.00015854f, -0.03936382f, -0.11201991f, 
    -0.27153379f, 0.00327927f, 0.14343323f, -0.21235372f, 0.10641835f, 0.17458916f, -0.07992835f, 0.09519008f, 
    0.07299151f, 0.14662345f, -0.10946833f, 0.15330523f, -0.09495798f, 0.28031868f, -0.05163607f, -0.14484106f, 
    -0.14266597f, -0.01687996f, -0.15950888f, -0.16009212f, 0.16683419f, -0.18668459f, -0.06290580f, -0.16279413f, 
    0.32655215f, -0.00150277f, 0.05564899f, 0.03326682f, -0.05915186f, -0.01505604f, 0.00148655f, -0.01420926f, 
    0.00255556f, -0.02158494f, 0.07454132f, 0.01715251f, 0.00118119f, 0.02762424f, 0.11486556f, 0.08884071f, 
    0.03059879f, -0.17711300f, 0.09856030f, -0.06577104f, 0.09719606f, 0.12362298f, 0.27330500f, -0.00196834f, 
    0.02663370f, 0.11331841f, 0.06630955f, -0.10904301f, 0.01309888f, 0.10817578f, 0.00544757f, -0.00235572f, 
    -0.07401700f, -0.01385526f, 0.02438113f, -0.02349132f, -0.30695644f, -0.02270740f, -0.24098600f, 0.18621629f, 
    0.20594454f, -0.14551544f, 0.04176000f, -0.01006047f, -0.01254821f, -0.01993413f, -0.10082620f, 0.00345615f, 
    -0.05615748f, -0.04652403f, 0.01534303f, -0.01720946f, 0.00880980f, 0.12466294f, -0.01468363f, -0.03488569f, 
    -0.42730746f, -0.22398216f, -0.06049386f, -0.08713981f, 0.17336294f, 0.23409636f, 0.31443635f, 0.10809191f, 
    0.07276288f, 0.11097730f, 0.07113241f, -0.02788158f, -0.07306954f, 0.10623701f, 0.01591959f, -0.02986617f, 
    -0.07205039f, -0.05424664f, 0.04889589f, -0.00617881f, -0.17312634f, 0.17185244f, -0.05987354f, -0.09164416f, 
    0.18275052f, -0.05954831f, 0.10278604f, -0.07160868f, 0.05737709f, 0.01090448f, -0.05789039f, 0.04811187f, 
    -0.01548907f, 0.03059804f, 0.05088279f, 0.15229663f, 0.15354380f, 0.13939238f, -0.00011923f, -0.05536942f, 
    0.44842449f, -0.09822811f, 0.15052484f, -0.07398152f, -0.04829894f, -0.14150409f, -0.00339887f, 0.08405325f, 
    0.06241532f, -0.07458902f, 0.01113537f, -0.00470180f, 0.06480204f, 0.08349331f, 0.04834768f, 0.16427554f, 
    0.08539747f, 0.31685254f, 0.08937071f, -0.08019897f, 0.30760685f, -0.01482135f, 0.00875766f, -0.01283393f, 
    0.11614077f, -0.07929757f, -0.01684742f, -0.01003421f, -0.02427468f, 0.02061615f, 0.09093145f, 0.09004038f, 
    0.12251569f, -0.04072923f, 0.02923248f, 0.19712932f, 0.03858496f, -0.11676372f, -0.06450618f, -0.08728781f, 
    0.59690171f, 0.89320731f, 0.28206924f, 0.17881726f, 0.03811780f, -0.01803753f, -0.00032935f, -0.01678365f, 
    0.15487798f, 0.06373748f, 0.03103553f, -0.15354665f, -0.08254355f, 0.01410470f, 0.09550387f, 0.02272710f, 
    -0.04535356f, 0.03621072f, -0.11725413f, -0.12905420f, 0.06991819f, -0.00547792f, -0.06656042f, -0.09175217f, 
    0.00308681f, 0.00079784f, -0.00665348f, 0.05097255f, -0.00982461f, -0.03140860f, 0.07891631f, 0.11955138f, 
    -0.14788772f, 0.01710134f, -0.05676613f, -0.07938771f, -0.04913662f, 0.17134695f, -0.04568899f, -0.15480059f, 
    0.20937623f, -0.00778489f, -0.05862915f, -0.07786401f, -0.00110081f, 0.11715043f, 0.03045690f, 0.03698092f, 
    0.02948891f, -0.05647000f, 0.11033660f, 0.06974178f, 0.07329302f, -0.00659189f, 0.06191898f, -0.06547177f, 
    -0.09238669f, -0.13659558f, -0.11684708f, -0.20251265f, 0.11577301f, -0.09858159f, 0.07236757f, -0.00164547f, 
    -0.03676717f, 0.09414515f, 0.00808558f, 0.01335402f, -0.03504376f, 0.06096639f, 0.07227951f, 0.03509653f, 
    0.04557036f, -0.00754173f, 0.02387336f, -0.06188645f, -0.09013436f, -0.09589568f, -0.11475631f, -0.08549707f, 
    -0.02876186f, -0.01756885f, 0.01141423f, -0.04460368f, -0.03672496f, -0.01483036f, -0.00074390f, 0.01116172f, 
    -0.04660150f, 0.01199679f, 0.01569618f, -0.04368273f, -0.04342043f, -0.02019149f, 0.03234993f, -0.02530423f, 
    -0.00636194f, -0.00790306f, 0.01220690f, -0.03930700f, 0.02742696f, -0.02094018f, -0.03393958f, -0.01684108f, 
    -0.03771574f, 0.02535436f, -0.00423677f, -0.01426973f, -0.01811828f, 0.01809817f, 0.00550979f, -0.00494122f, 
    -0.01485211f, -0.00841462f, 0.01238410f, 0.00132687f, -0.00548408f, -0.01171254f, 0.00279764f, -0.02488907f, 
    -0.02401664f, 0.02922311f, 0.00721499f, -0.03409390f, -0.02545318f, -0.02686595f, -0.04107773f, 0.01558854f, 
    0.03213654f, -0.01006587f, -0.01284686f, 0.02130762f, 0.00514673f, -0.00734910f, -0.03658457f, 0.02503949f, 
    0.02861578f, -0.03722394f, -0.02506680f, -0.03053536f, 0.01152689f, -0.00212108f, 0.01043919f, -0.02837221f, 
    0.03426692f, 0.00964850f, -0.00547644f, 0.00935049f, -0.03112964f, -0.01652806f, -0.00014915f, 0.01664352f, 
    -0.04189882f, 0.02732493f, -0.01800522f, -0.01587052f, 0.00985407f, 0.02770757f, -0.02906700f, 0.01886708f, 
    -0.04285141f, -0.02780837f, -0.00041298f, -0.03872805f, 0.02688631f, -0.00402489f, -0.02658815f, -0.02688493f, 
    -0.02347449f, -0.04805691f, 0.01723909f, 0.02721288f, 0.01050923f, 0.02496845f, -0.01858373f, 0.00988408f, 
    0.00239043f, -0.03971420f, -0.00883977f, 0.01142079f, -0.00085168f, -0.03213942f, -0.03773413f, 0.01449954f, 
    0.00195138f, -0.04427635f, -0.03507715f, 0.01029224f, -0.03279253f, -0.00123073f, -0.00136762f, -0.00171902f, 
    0.02208758f, -0.04110104f, -0.01399356f, -0.02679033f, 0.03286978f, 0.02358487f, 0.02985975f, -0.00759123f, 
    -0.00067956f, 0.01119023f, -0.03226586f, -0.03499918f, -0.01854990f, -0.00881146f, 0.01770092f, -0.03877934f, 
    -0.02125471f, -0.01295192f, -0.03036441f, -0.01604177f, -0.00904230f, 0.02517257f, 0.01032936f, -0.01667769f, 
    -0.00089350f, -0.01435021f, 0.01403751f, 0.01592997f, -0.00224780f, 0.01216445f, 0.00558143f, -0.02048345f, 
    0.00445812f, -0.03779324f, 0.02535839f, 0.02659262f, 0.02142360f, 0.02662374f, -0.00235635f, -0.00754992f, 
    -0.00378171f, 0.00720162f, -0.02921838f, -0.02362786f, -0.02014121f, -0.03167577f, 0.02860277f, -0.04080129f, 
    -0.02961709f, 0.02352837f, -0.03914598f, 0.00960964f, 0.00921376f, 0.00375305f, -0.00801845f, 0.00046033f, 
    -0.02635722f, -0.00203196f, -0.01238377f, -0.02762019f, -0.00709969f, -0.04062628f, -0.00680777f, 0.01816890f, 
    0.00074906f, 0.01370707f, -0.00273918f, 0.02713296f, -0.02228200f, -0.04347864f, -0.00279478f, -0.02706371f, 
    -0.00393374f, 0.01619478f, -0.01650175f, 0.02118381f, -0.01422277f, 0.00207652f, -0.02623268f, -0.03633412f, 
    0.01633156f, -0.02401032f, -0.03168326f, -0.00579524f, 0.00874985f, 0.02454900f, -0.02032067f, -0.02091822f, 
    0.02313751f, 0.01492005f, -0.01886935f, 0.01216321f, 0.02956987f, 0.02114258f, -0.02438190f, 0.02542636f, 
    -0.03319237f, 0.02119067f, -0.04415980f, 0.00693831f, -0.02073892f, 0.01887991f, -0.02752704f, 0.03133179f, 
    0.01004938f, 0.00687610f, -0.02659389f, -0.00484641f, -0.00808201f, -0.02924063f, -0.00847435f, -0.02867622f, 
    -0.01658460f, 0.00784669f, -0.04209425f, 0.03159602f, -0.01690063f, 0.00728131f, -0.02286674f, 0.01838983f, 
    -0.00064072f, -0.01950795f, -0.01933866f, -0.00161331f, 0.02603328f, -0.02337153f, -0.03579989f, 0.00151646f, 
    -0.03393314f, -0.00360523f, -0.02893545f, -0.01869924f, 0.01054184f, 0.01222883f, -0.00384860f, -0.00756632f, 
    -0.04033244f, -0.01936804f, -0.03618003f, -0.03359982f, 0.02632729f, 0.01002280f, 0.02778001f, -0.00282126f, 
    -0.03839670f, -0.02556822f, 0.02936320f, 0.02601488f, 0.01906401f, -0.04507425f, 0.01716042f, -0.00591495f, 
    -0.02699532f, 0.02694430f, 0.02390926f, 0.00628190f, 0.02727696f, -0.03402726f, -0.02264508f, -0.04316442f, 
    0.02942031f, -0.02743369f, -0.00040203f, -0.01714233f, 0.02433670f, -0.03449865f, -0.00560852f, 0.02247282f, 
    -0.04022084f, -0.02438217f, 0.02780076f, 0.01527165f, -0.04343064f, -0.03423165f, -0.02197689f, 0.00029330f, 
    0.00378588f, 0.00823889f, 0.01741651f, 0.00335988f, -0.02258965f, 0.00950401f, -0.00711737f, 0.00570418f, 
    -0.01641189f, 0.01523067f, 0.02451290f, 0.00431994f, -0.02360235f, -0.02550285f, -0.03520454f, 0.00133577f, 
    -0.01342745f, -0.01593747f, -0.00644905f, -0.02085260f, 0.00726031f, -0.00014829f, -0.02871891f, -0.03052441f, 
    -0.03804681f, -0.01498362f, -0.00068495f, -0.02888839f, -0.01138427f, 0.01724288f, -0.04253991f, -0.00855603f, 
    -0.01097700f, 0.00650811f, -0.01074753f, -0.00923419f, -0.00980396f, -0.03732417f, 0.02687436f, -0.01073534f, 
    -0.01377181f, -0.03448873f, 0.00129679f, -0.02067485f, 0.01678093f, -0.02810948f, 0.01417682f, -0.02550318f, 
    -0.03779550f, 0.00029779f, 0.02059593f, 0.00157903f, -0.01723992f, 0.02225043f, 0.01366476f, -0.04263441f, 
    -0.03048623f, 0.02509703f, -0.00278319f, -0.03812893f, 0.01910888f, -0.02233372f, 0.01322308f, -0.03383975f, 
    -0.00580202f, -0.02923677f, -0.04779631f, -0.02646872f, -0.02535507f, -0.03683612f, -0.02172287f, -0.03381525f, 
    0.02505799f, -0.00660208f, -0.01287026f, -0.02722026f, -0.02087583f, -0.01254133f, -0.04381165f, -0.00951899f, 
    0.02842262f, -0.01063602f, -0.01477749f, 0.01633136f, -0.01677774f, -0.00783211f, 0.02169504f, 0.00888382f, 
    -0.04275812f, 0.01751587f, 0.02339489f, -0.02699825f, -0.02915406f, 0.01895175f, 0.01674051f, -0.04660829f, 
    -0.03210822f, -0.04648577f, 0.02650253f, 0.02265770f, -0.03912134f, 0.01445907f, 0.00931122f, 0.00210147f, 
    -0.04582889f, 0.02155646f, 0.01214935f, -0.03826473f, 0.02118289f, -0.00962097f, -0.00992950f, -0.00048543f, 
    -0.00629038f, 0.00761617f, 0.01578349f, 0.00271839f, 0.01736492f, 0.01296117f, 0.01404511f, -0.02041716f, 
    -0.01926091f, 0.00990963f, -0.02526719f, 0.01440178f, 0.03672361f, -0.02048413f, 0.00696342f, -0.01873661f, 
    0.01729305f, -0.02368019f, 0.01470204f, -0.02598254f, -0.03138054f, 0.01464026f, -0.00636147f, 0.00825193f, 
    0.00324128f, -0.04195301f, 0.03164915f, -0.00708381f, -0.00148815f, 0.01124172f, 0.02126680f, -0.01270618f, 
    -0.01329046f, 0.03033075f, 0.01285344f, -0.03211362f, 0.01223309f, 0.01630445f, 0.02263329f, -0.01179079f, 
    0.00925498f, -0.00464620f, 0.00529174f, -0.01977445f, -0.04107769f, -0.00623393f, 0.00210825f, -0.00682702f, 
    -0.02045869f, -0.02344568f, -0.02959971f, 0.01105396f, 0.03164661f, 0.02222282f, -0.00400316f, 0.00251114f, 
    -0.01050463f, -0.00792695f, 0.02279202f, -0.03040515f, 0.01788703f, -0.01838142f, 0.02661215f, 0.01723290f, 
    0.02015924f, 0.02799243f, 0.00977550f, -0.00198448f, -0.03028810f, -0.03918783f, -0.01020051f, 0.01174826f, 
    -0.00153884f, -0.04316686f, 0.02211367f, -0.04057036f, 0.01931289f, -0.01065576f, 0.02235465f, 0.00894519f, 
    -0.00291500f, -0.01919361f, -0.02211116f, 0.02608191f, -0.02952876f, 0.00924892f, 0.01811499f, -0.01681370f, 
    -0.04473117f, -0.03919845f, -0.02200142f, 0.01941381f, -0.04314598f, -0.00054852f, -0.00502546f, -0.04137687f, 
    -0.02588071f, -0.03375769f, 0.01257211f, -0.04179276f, -0.00560080f, -0.00086685f, 0.02783116f, 0.02743063f, 
    0.00993852f, -0.04495510f, -0.02622240f, 0.01341269f, -0.00111906f, 0.03231050f, -0.04355955f, -0.01719962f, 
    0.01746036f, -0.00696547f, -0.04121665f, 0.00689000f, -0.01275245f, 0.00641593f, -0.01257646f, -0.01893971f, 
    -0.02817264f, -0.03074370f, 0.03214805f, 0.00903826f, -0.00943728f, 0.00914992f, -0.01600420f, 0.01463611f, 
    -0.02749700f, -0.01565189f, -0.01426689f, 0.03133570f, -0.02261927f, -0.00699220f, -0.04540701f, -0.04261222f, 
    -0.00011096f, -0.00960954f, 0.03283268f, -0.03170104f, 0.00636358f, 0.02211450f, -0.03088991f, -0.01936095f, 
    -0.03498741f, -0.00252292f, 0.00980427f, -0.00878561f, 0.02999265f, 0.01846994f, -0.02892802f, -0.01236673f, 
    0.01977916f, -0.01783543f, 0.00828063f, -0.00449014f, -0.02707312f, -0.01445725f, -0.00072229f, 0.01819480f, 
    -0.02243169f, 0.01163491f, -0.01510417f, -0.01071978f, 0.01081640f, 0.02783478f, -0.01303828f, -0.03445452f, 
    0.00176768f, 0.01283760f, -0.01138121f, -0.01158238f, 0.02153807f, -0.00712188f, -0.03648512f, 0.00705517f, 
    -0.03683749f, 0.00455672f, 0.00207542f, -0.01897340f, -0.03421803f, -0.04696041f, 0.01307421f, 0.00312344f, 
    -0.02063466f, -0.00444234f, 0.01807608f, 0.02460539f, 0.01528357f, 0.02615146f, -0.00030395f, -0.00229601f, 
    -0.01399979f, -0.02952955f, -0.02897181f, 0.01326534f, -0.02043022f, -0.01971726f, -0.02713084f, -0.02560686f, 
    0.02379286f, -0.01189700f, 0.02448321f, 0.01824929f, 0.00692530f, -0.03949029f, 0.00066779f, -0.03109712f, 
    -0.00951179f, 0.02173223f, -0.03653317f, -0.02580632f, -0.03606537f, -0.04151470f, 0.00183402f, 0.02522288f, 
    0.01100189f, 0.02394727f, 0.01917834f, -0.04679528f, -0.02784790f, 0.01223937f, -0.00576860f, 0.00692766f, 
    0.03121398f, -0.03474186f, -0.01939530f, -0.00102273f, 0.01632263f, 0.02156439f, -0.01371449f, -0.03886179f, 
    -0.02244875f, -0.02134727f, -0.01407542f, 0.02412808f, 0.00755664f, -0.01242001f, -0.04078405f, 0.00296495f, 
    0.07176824f, -0.05905237f, -0.03923343f, -0.17152695f, -0.18572718f, 0.19373463f, -0.10874064f, -0.20044950f, 
    0.03131610f, 0.07475931f, -0.07800143f, -0.08218444f, 0.02599760f, 0.00775196f, 0.03869242f, 0.11854474f, 
    0.04638215f, 0.06458373f, 0.08736401f, 0.05164107f, -0.85894656f, 0.30084795f, -0.16759209f, -0.12088208f, 
    -0.05079124f, 0.30926627f, -0.00034408f, -0.24243554f, -0.20626752f, 0.10738597f, 0.12690642f, -0.02491553f, 
    -0.06378514f, 0.20334876f, 0.17161383f, 0.20059003f, -0.04901975f, -0.04699248f, 0.06498988f, 0.05791134f, 
    0.54069388f, 0.13547309f, -0.02964303f, -0.13680752f, 0.00901131f, 0.03122627f, -0.01344881f, 0.05997893f, 
    -0.01030480f, -0.03220594f, 0.22035553f, 0.20065507f, 0.18527958f, 0.06358019f, -0.11216250f, 0.29632473f, 
    0.02911996f, 0.19195044f, -0.00576048f, 0.09613685f, -0.29275185f, -0.06305200f, -0.01537242f, 0.12071849f, 
    -0.13013488f, 0.17312969f, 0.00730397f, 0.05107565f, 0.00094779f, 0.09782042f, -0.08864493f, -0.08697992f, 
    0.03027644f, -0.03366395f, -0.06453735f, -0.07333412f, -0.06637676f, -0.06287087f, -0.13225082f, -0.01449424f, 
    -0.00405995f, 0.02769110f, 0.01382550f, 0.13410926f, 0.10192008f, -0.07808056f, -0.05243669f, -0.08843221f, 
    0.02036013f, -0.08300706f, 0.19911982f, 0.19114558f, 0.18470250f, -0.03096820f, 0.03221684f, -0.11310752f, 
    -0.12145245f, -0.08421600f, -0.00961955f, -0.05436854f, 0.36676198f, -0.03688585f, 0.22629358f, -0.03551148f, 
    0.14263596f, -0.09865361f, -0.00527984f, -0.09252400f, -0.07220540f, -0.05944899f, 0.15405983f, 0.00442183f, 
    0.14116119f, -0.05252520f, 0.04681085f, 0.07946594f, -0.01133197f, 0.01415284f, -0.08401540f, -0.04414725f, 
    -0.08548141f, -0.05537341f, 0.01440305f, 0.19850139f, -0.26698127f, -0.01302962f, -0.29117990f, -0.02335679f, 
    -0.00689163f, -0.29663822f, -0.08624270f, 0.00249289f, 0.07049852f, 0.04214247f, 0.20067394f, -0.02612363f, 
    0.09304288f, 0.16741252f, -0.03274979f, 0.00934387f, 0.56508112f, 0.26710990f, 0.08723501f, 0.30800271f, 
    0.04296899f, 0.02450778f, 0.12372824f, -0.03145441f, -0.20696203f, 0.15532547f, 0.16958600f, -0.02203445f, 
    0.02326168f, 0.08975718f, -0.04266036f, 0.04686066f, 0.08211108f, 0.02483514f, 0.05536344f, -0.00310807f, 
    0.14843878f, -0.10685448f, 0.01131430f, 0.10616328f, -0.15600254f, -0.06596751f, -0.04882499f, -0.02963599f, 
    -0.01166199f, -0.03937347f, -0.02213936f, -0.02994274f, 0.02662005f, -0.07884575f, 0.01218249f, -0.07075449f, 
    -0.04614487f, 0.09098575f, -0.02356689f, 0.04448670f, -0.22453402f, -0.18548599f, 0.07124777f, 0.03288919f, 
    -0.12893409f, -0.09235954f, -0.01959014f, 0.03473480f, 0.02773744f, 0.00147728f, 0.03386758f, 0.09902476f, 
    -0.03660947f, -0.01317299f, -0.06065007f, -0.08899597f, -0.09235226f, -0.03112001f, -0.09654634f, -0.02732684f, 
    -0.32568958f, -0.04659700f, 0.12922333f, 0.33581296f, -0.05085580f, -0.01295759f, -0.03048268f, 0.07305770f, 
    0.04975450f, -0.06218944f, 0.22240363f, -0.03684378f, 0.10222190f, -0.01553381f, 0.03841602f, 0.02511897f, 
    -0.04508771f, -0.00443657f, -0.09154523f, -0.02589074f, -0.31280103f, -0.08113609f, -0.32909462f, -0.59484458f, 
    0.36183548f, -0.16294952f, 0.01318675f, -0.24199192f, -0.12918192f, -0.04971382f, 0.07263479f, 0.20591600f, 
    0.08431166f, -0.02221594f, 0.07478847f, 0.58104759f, -0.02209280f, -0.39431781f, 0.49546370f, 0.05734901f, 
    0.74851012f, 0.17026493f, -0.14748737f, 0.02455029f, -0.35989347f, 0.06384965f, 0.25784889f, -0.04037610f, 
    0.07234573f, 0.20037329f, 0.17143551f, 0.06817345f, 0.07761147f, 0.21376951f, 0.12052268f, 0.17053232f, 
    0.26008639f, 0.37925926f, 0.20505659f, 0.10743389f, -0.41891453f, 0.04135518f, 0.09440329f, -0.00853660f, 
    -0.34924215f, 0.05711675f, -0.09838655f, 0.01641513f, -0.02665457f, -0.00200229f, -0.00569970f, -0.10280164f, 
    -0.02303136f, -0.13656935f, -0.11279455f, -0.04108708f, -0.07355041f, -0.05385380f, -0.14393261f, -0.00256633f, 
    0.25190136f, 0.40237185f, -0.22954361f, 0.28091213f, 0.20458160f, 0.07461882f, 0.14895660f, -0.05331402f, 
    -0.08442621f, 0.08124263f, 0.22043188f, -0.06949767f, 0.00979346f, -0.00321138f, -0.05906974f, 0.05220200f, 
    0.29231480f, 0.00612046f, 0.07041799f, 0.07798656f, -0.05303844f, 0.19792815f, 0.28634256f, 0.28627235f, 
    -0.20326257f, 0.00944620f, -0.27216426f, 0.06236271f, 0.04305822f, -0.11077723f, -0.00308229f, -0.06554653f, 
    0.02066554f, -0.03355058f, 0.10114440f, -0.05186243f, 0.07572895f, 0.06537995f, 0.05162976f, 0.09615909f, 
    -0.33501893f, -0.05298496f, 0.18959668f, 0.22668594f, -0.22036749f, -0.00007138f, 0.08621418f, -0.02095304f, 
    -0.06217094f, 0.04923707f, -0.03685056f, -0.26433006f, -0.05817179f, -0.07499830f, -0.08964533f, -0.05807549f, 
    0.01072382f, -0.02657134f, -0.09144452f, 0.00352278f, 0.08598235f, 0.06374289f, 0.30083126f, 0.11674893f, 
    0.05054783f, 0.26595807f, 0.04681483f, -0.03062877f, -0.03776683f, -0.00950984f, -0.05777868f, -0.01660769f, 
    -0.02911397f, 0.07035434f, -0.06219054f, 0.01546131f, 0.08582465f, -0.15079772f, 0.08945211f, 0.07297554f, 
    -0.04433920f, -0.04881611f, -0.10998035f, 0.15314625f, -0.23494719f, -0.06612955f, -0.16740108f, 0.22721329f, 
    0.01009637f, -0.07804918f, -0.09280154f, -0.04833265f, -0.02248184f, -0.13649891f, 0.02994141f, -0.07180835f, 
    0.05477006f, 0.23357786f, -0.21445727f, 0.02020758f, 0.16276947f, 0.17739461f, -0.07087851f, -0.01103433f, 
    0.01546000f, 0.11346498f, 0.01329318f, -0.02608853f, -0.11536268f, 0.03315868f, 0.00223367f, 0.07589512f, 
    -0.00804856f, -0.03710440f, 0.05194192f, 0.03537717f, 0.00817715f, -0.05897446f, -0.05525601f, 0.08060306f, 
    -0.10333177f, -0.12777859f, -0.06790908f, 0.10089724f, 0.13537413f, -0.09841643f, -0.14945717f, -0.06752963f, 
    0.03222537f, -0.02159632f, 0.17390245f, -0.01949030f, -0.19908105f, 0.23057838f, 0.05508503f, -0.03526876f, 
    0.04600261f, -0.05679162f, 0.04966598f, -0.02739129f, -0.13232358f, -0.11958445f, -0.11983602f, -0.17639200f, 
    -0.16609778f, 0.09561111f, -0.11422887f, -0.01625873f, 0.05439438f, 0.05214788f, -0.06639222f, -0.01539829f, 
    -0.02393353f, -0.03023841f, 0.07800693f, 0.05409505f, 0.04725952f, 0.13086022f, 0.01303316f, -0.16445905f, 
    0.17716132f, 0.18993871f, -0.07248380f, -0.05989837f, -0.03808788f, 0.11476547f, 0.01918074f, -0.24360493f, 
    -0.01943681f, -0.06637087f, -0.03377764f, -0.11876198f, 0.04991043f, -0.00030701f, 0.04741453f, -0.09124668f, 
    -0.11831488f, 0.02726756f, 0.04967351f, -0.03506672f, 0.27338809f, 0.07157773f, -0.11838654f, -0.04338421f, 
    -0.22021724f, 0.14680748f, -0.18258356f, 0.08022185f, -0.13564822f, 0.16108710f, 0.00652408f, 0.01172663f, 
    0.12522584f, -0.03079156f, 0.10545802f, 0.06338293f, 0.07157078f, 0.21634060f, -0.03366851f, -0.10752866f, 
    -0.04103110f, -0.05562942f, -0.06310147f, -0.06434435f, -0.12199375f, 0.04661022f, 0.02417747f, -0.12816520f, 
    0.04258628f, -0.05831201f, -0.09300131f, 0.12453374f, -0.09148706f, -0.01359009f, -0.03820081f, -0.04750570f, 
    -0.02249120f, -0.11394573f, 0.10434398f, 0.02526141f, 0.06946661f, 0.29985699f, -0.06285229f, 0.22019100f, 
    -0.03982401f, 0.27767086f, -0.07186579f, 0.13745783f, -0.03460855f, 0.17762546f, 0.10952897f, 0.00548296f, 
    0.10106839f, -0.07395283f, 0.11920643f, 0.07707195f, 0.16516644f, 0.05527828f, 0.01040403f, 0.11493725f, 
    0.40889952f, 0.01006077f, -0.12978531f, 0.02775225f, 0.12970264f, -0.03417076f, -0.01249262f, 0.02231101f, 
    0.06035585f, -0.03508113f, -0.02698070f, 0.04847604f, -0.04491399f, 0.10858574f, -0.00364559f, -0.06036508f, 
    -0.04996661f, 0.08993796f, 0.12612526f, -0.09162619f, 0.01727427f, 0.09655534f, 0.13311478f, 0.03554339f, 
    0.26174951f, -0.00576754f, -0.09433845f, -0.01888662f, -0.06610189f, -0.03519432f, -0.01259928f, 0.01864591f, 
    -0.00580118f, -0.01849421f, -0.01173077f, 0.22381671f, 0.06636775f, -0.08846620f, -0.07086580f, -0.04478015f, 
    0.74636620f, -0.10312383f, 0.45925248f, 0.14820236f, -0.20784472f, -0.10802935f, -0.05807817f, 0.02596594f, 
    0.04676276f, -0.01960140f, 0.03477747f, -0.08768956f, 0.13112295f, 0.07556060f, 0.05839275f, 0.05792708f, 
    -0.07338694f, -0.05401069f, -0.05104067f, 0.05550622f, 0.14582217f, 0.06575932f, 0.00774843f, -0.07919483f, 
    0.07882765f, 0.07751188f, -0.06233349f, -0.01004515f, -0.01509740f, -0.02833992f, 0.14190570f, 0.28992069f, 
    -0.14842069f, 0.07225920f, 0.14079131f, -0.08030732f, 0.00294326f, 0.07970402f, -0.00572233f, 0.00599638f, 
    0.03096494f, 0.02737432f, 0.16313700f, 0.02696011f, 0.14862280f, -0.03385801f, -0.02921542f, -0.02659488f, 
    0.03505622f, -0.09338377f, 0.15878601f, 0.27762944f, 0.17409098f, 0.09734868f, 0.13802896f, 0.02133745f, 
    -0.07247236f, -0.06550826f, -0.07701803f, -0.04046329f, 0.04331583f, 0.07360699f, 0.08350705f, 0.16074407f, 
    0.22554275f, -0.04873111f, 0.02203039f, -0.09164512f, -0.03810654f, -0.00034199f, 0.14964977f, 0.09747721f, 
    0.10113835f, 0.13420001f, 0.20453577f, -0.04701978f, 0.04103825f, -0.03772612f, -0.08180359f, -0.08601015f, 
    0.01183298f, -0.02189690f, -0.01554053f, -0.02785907f, 0.03231655f, -0.00309968f, -0.03948646f, 0.00063794f, 
    -0.01954383f, 0.02000948f, -0.03691011f, 0.03345363f, 0.03040281f, 0.00698072f, 0.01563238f, -0.00354893f, 
    -0.00819064f, 0.00723551f, 0.01023434f, 0.03330900f, 0.01575791f, -0.04201511f, 0.02663395f, 0.03494371f, 
    0.02380750f, 0.02500074f, 0.01252298f, -0.03231665f, 0.00538604f, 0.02229652f, 0.01842365f, 0.02977009f, 
    0.03217609f, 0.00746758f, 0.00863769f, -0.04246317f, -0.02031809f, -0.00873039f, 0.01852607f, -0.01369469f, 
    0.03248657f, 0.01593980f, -0.02609653f, 0.02571828f, 0.01488176f, -0.01041842f, 0.02993523f, -0.03273737f, 
    -0.00802119f, -0.00286877f, -0.02390258f, -0.03268434f, -0.00732829f, -0.03575794f, 0.01179855f, 0.00169582f, 
    -0.00494866f, 0.02779832f, -0.01162619f, -0.01641143f, 0.00883266f, -0.01247721f, -0.00444300f, 0.00819472f, 
    -0.03316968f, 0.02014447f, -0.00627694f, -0.03102025f, -0.03283883f, 0.00685399f, 0.02501856f, -0.04253900f, 
    -0.03260401f, 0.02180717f, -0.02972138f, -0.03095505f, 0.00291392f, -0.00314543f, 0.02008716f, -0.01130932f, 
    -0.01178344f, -0.03627674f, -0.04500834f, -0.01815743f, -0.00874300f, -0.03443630f, -0.03601716f, -0.00643469f, 
    -0.04217819f, 0.00011130f, -0.00357933f, -0.04286784f, 0.01384224f, 0.00305171f, 0.00277910f, -0.04231440f, 
    -0.00734538f, 0.02811126f, -0.02332259f, 0.02580075f, -0.03024092f, 0.03044722f, -0.02463694f, 0.00684291f, 
    0.03140385f, 0.01776303f, -0.00117728f, 0.00515180f, -0.01883402f, -0.00138612f, 0.01113244f, -0.00538696f, 
    -0.03311758f, -0.02817385f, -0.04257055f, -0.02371266f, 0.01339646f, -0.01062451f, -0.01033380f, 0.00936110f, 
    -0.03034606f, -0.00530484f, 0.02678735f, -0.00143950f, -0.00165698f, 0.02477324f, -0.03703501f, 0.00244012f, 
    0.01127901f, 0.01216547f, -0.04568410f, -0.02717240f, 0.01559015f, 0.02314840f, 0.02978318f, 0.00314522f, 
    -0.00410779f, 0.00034185f, -0.03991252f, -0.01230468f, -0.00830502f, 0.01591452f, -0.03013078f, -0.02304884f, 
    -0.03929750f, 0.01309303f, 0.01974980f, -0.02257294f, -0.00923001f, 0.02183519f, 0.03011089f, -0.01212122f, 
    -0.01628982f, -0.02833968f, -0.02182445f, -0.01324485f, -0.03196832f, 0.03146563f, -0.02773371f, -0.01061450f, 
    -0.00791432f, -0.02072010f, -0.00388954f, -0.00734306f, 0.02011829f, -0.00553724f, 0.03047923f, 0.03200058f, 
    0.01626400f, 0.02928125f, -0.02873329f, 0.01990362f, 0.01788216f, 0.00577327f, -0.00497538f, -0.03863020f, 
    -0.00201355f, -0.03457033f, -0.02721438f, 0.00627437f, 0.02114377f, 0.02788962f, -0.03970266f, -0.01041957f, 
    0.00073659f, -0.01521996f, -0.02820296f, -0.04368337f, -0.01505449f, -0.01597563f, 0.02149708f, -0.02896777f, 
    -0.02116875f, -0.01337791f, -0.03411834f, 0.00146151f, -0.02723067f, -0.00787717f, 0.03316601f, -0.02797834f, 
    0.01332260f, 0.00533531f, 0.01973463f, 0.03420686f, 0.00828548f, -0.03931033f, -0.03075657f, 0.00645508f, 
    -0.02444789f, -0.00877927f, 0.01721321f, 0.01796882f, 0.01323977f, -0.00989871f, 0.02715003f, -0.03085825f, 
    -0.02367357f, -0.00522217f, 0.02482163f, -0.02346056f, -0.00259499f, 0.02727419f, -0.01149345f, -0.00010226f, 
    -0.03022368f, -0.00565089f, -0.04376715f, 0.02470032f, -0.00433651f, 0.00129525f, -0.02416356f, -0.02005628f, 
    0.03009679f, 0.01557943f, -0.00422701f, -0.03794064f, 0.00267883f, -0.03435203f, -0.00365187f, 0.02207698f, 
    0.02683135f, 0.01074113f, -0.01493042f, -0.01306690f, -0.03097877f, -0.01903900f, 0.02219139f, -0.03886246f, 
    -0.03827660f, 0.03410283f, 0.01461780f, -0.02105635f, 0.01852441f, 0.02017973f, -0.02108089f, 0.01703015f, 
    0.01453604f, 0.01328676f, 0.01217685f, -0.01214885f, 0.00717255f, -0.03849394f, 0.01635886f, 0.01657897f, 
    -0.00325674f, 0.01666768f, 0.00439567f, 0.00831783f, -0.00687575f, -0.02744331f, 0.03402572f, -0.01879638f, 
    0.02942420f, -0.03856227f, -0.00463886f, -0.02885677f, -0.01329829f, 0.00428405f, -0.00129417f, 0.01183148f, 
    0.01604667f, 0.01374834f, 0.02611762f, 0.01203621f, 0.00493676f, 0.01775614f, 0.02949099f, -0.02119556f, 
    0.00347231f, -0.00347547f, 0.01694559f, 0.03234572f, -0.03206771f, -0.01389943f, 0.00387704f, -0.00806849f, 
    -0.01355377f, 0.03466825f, -0.03483579f, -0.03017247f, 0.02470944f, 0.01864170f, 0.02834710f, -0.02270089f, 
    0.02578893f, -0.02140345f, -0.04167112f, -0.03761430f, -0.02909500f, 0.02073683f, -0.03537841f, -0.02061336f, 
    0.02192942f, -0.01127508f, -0.04465992f, -0.00313644f, -0.03750561f, 0.00994399f, -0.04016275f, -0.03858420f, 
    -0.04119849f, -0.00186761f, -0.02840864f, -0.01349260f, -0.00965445f, 0.02449232f, -0.00206988f, -0.01854961f, 
    0.01639039f, -0.01229240f, -0.01624837f, -0.02200931f, -0.00696210f, 0.03055748f, -0.02370728f, 0.01418772f, 
    0.02404449f, -0.02542607f, -0.04158245f, 0.00562079f, -0.03734601f, 0.03258116f, -0.03489174f, 0.03420454f, 
    -0.04046068f, 0.02984434f, -0.02852318f, -0.00590161f, -0.03198459f, 0.03365117f, -0.00713311f, -0.02776437f, 
    0.01378194f, 0.00108034f, 0.03258213f, -0.00875425f, -0.00103126f, -0.00192305f, 0.02429065f, -0.00494116f, 
    0.00330498f, 0.01434773f, 0.01527517f, -0.02249961f, 0.00927488f, -0.02336518f, -0.02157332f, -0.04198907f, 
    -0.03629600f, -0.03509528f, -0.03549563f, 0.00451834f, 0.01697974f, 0.01224915f, -0.03801383f, -0.02096479f, 
    0.00660790f, 0.01884636f, 0.03277790f, -0.04339663f, 0.01964788f, 0.01018376f, 0.00099923f, -0.03081390f, 
    -0.03122003f, -0.03464054f, -0.02541734f, 0.02294140f, 0.00167319f, -0.00261272f, -0.00005560f, 0.02081951f, 
    -0.02299579f, -0.01575416f, 0.02087417f, 0.03112828f, -0.02001439f, -0.01821874f, 0.01639322f, -0.01022070f, 
    0.00698319f, -0.02514081f, 0.02996151f, 0.00240392f, 0.01272354f, 0.00274135f, 0.01762713f, -0.00893541f, 
    0.03355603f, -0.03330501f, 0.00720387f, -0.02332838f, 0.03268371f, -0.04228831f, -0.00603081f, -0.03156726f, 
    0.00163224f, -0.02391290f, -0.01916691f, -0.01182720f, 0.00155014f, 0.01309965f, -0.00547889f, 0.00424812f, 
    -0.02958588f, -0.03222608f, -0.03987495f, -0.02276922f, -0.00907875f, -0.00374470f, -0.02576898f, -0.04057908f, 
    -0.04007012f, -0.02558248f, 0.01129243f, -0.01497544f, -0.04359489f, -0.00887999f, 0.00124545f, -0.00753423f, 
    -0.00255845f, -0.00004359f, -0.02337190f, -0.00263557f, -0.00684896f, -0.01048620f, 0.01360829f, -0.00037607f, 
    -0.04402114f, -0.02511184f, -0.01192348f, -0.01427364f, -0.00348684f, 0.00922778f, -0.01086150f, -0.01251227f, 
    0.01399768f, -0.00410065f, -0.00924598f, -0.00791910f, -0.01672531f, 0.03550823f, 0.01112842f, -0.00926049f, 
    -0.04254268f, 0.02940775f, -0.00816879f, -0.01277236f, -0.04217065f, 0.02449166f, -0.04125277f, 0.00106921f, 
    -0.03416418f, 0.01371094f, 0.01199473f, -0.02897390f, 0.01582938f, 0.03301834f, 0.01047410f, -0.04223888f, 
    0.02668496f, 0.02988338f, 0.01510783f, -0.00265212f, 0.01274068f, 0.03568113f, -0.01427406f, 0.00436628f, 
    0.02489722f, -0.02827564f, 0.01918134f, 0.00801254f, -0.00192376f, 0.00680744f, -0.02308114f, -0.02346322f, 
    -0.04222221f, 0.00111251f, 0.01384896f, -0.04063702f, -0.01047035f, 0.00282883f, -0.02657505f, -0.00665670f, 
    0.03248758f, 0.01128629f, 0.03376272f, -0.02707105f, -0.02098114f, -0.02830576f, 0.01379998f, -0.01865473f, 
    0.02101481f, -0.00612255f, 0.00033053f, -0.01688291f, 0.01439086f, 0.02753188f, -0.01430900f, -0.02481496f, 
    -0.03380413f, 0.00359736f, 0.00081132f, -0.03564081f, 0.01832636f, -0.02594293f, -0.04375473f, -0.01961442f, 
    -0.03731681f, 0.01342679f, 0.00270889f, -0.03608107f, 0.01544750f, -0.01321877f, -0.02148079f, 0.02953244f, 
    -0.00008958f, -0.02637560f, -0.00067027f, 0.03372944f, -0.03705807f, 0.03084726f, 0.02775797f, -0.01490678f, 
    -0.02112802f, -0.00035764f, -0.00300366f, -0.04018959f, -0.04194296f, -0.00969836f, 0.01510963f, -0.00254947f, 
    0.01844478f, 0.02577224f, -0.02432876f, -0.00400959f, -0.02097395f, -0.00565905f, -0.03904982f, -0.03186210f, 
    -0.00970807f, 0.00686638f, 0.00992709f, -0.03929999f, -0.03822862f, -0.04217289f, 0.00416187f, -0.03684398f, 
    -0.03294405f, 0.02482170f, 0.00228982f, 0.03344641f, 0.00561861f, 0.00728583f, -0.00816601f, 0.02180510f, 
    0.02588498f, -0.01340268f, 0.00011879f, 0.02376151f, 0.00367819f, 0.02392286f, 0.01144813f, -0.00235355f, 
    -0.01536351f, -0.02102067f, 0.02861690f, 0.00057052f, 0.00904956f, 0.00799448f, -0.01550931f, 0.03115439f, 
    -0.01558686f, 0.03657164f, -0.02480188f, 0.00963710f, -0.03808725f, 0.00933580f, -0.04234555f, -0.00065788f, 
    -0.03860160f, 0.02922973f, -0.01204362f, -0.00666233f, 0.00261715f, 0.00429968f, -0.00519336f, -0.03093523f, 
    -0.00623950f, -0.01750669f, -0.02144176f, 0.01776688f, 0.01290403f, -0.00776783f, -0.00721873f, -0.01086199f, 
    0.02346684f, 0.02552215f, -0.02645193f, 0.03050170f, -0.03055665f, -0.02285073f, -0.02526396f, 0.03290196f, 
    -0.00428139f, -0.01487937f, 0.03297864f, -0.02263475f, -0.04423279f, -0.00723240f, -0.02250009f, -0.00495348f, 
    -0.01947153f, 0.03323414f, -0.03588741f, -0.03808578f, 0.03025741f, 0.00275805f, 0.00517065f, 0.02550769f, 
    0.04167029f, 0.21891174f, 0.40930328f, -0.31389645f, -0.04810774f, -0.08306684f, -0.04861940f, -0.17711769f, 
    0.11704817f, 0.03606951f, -0.10468060f, 0.00052918f, -0.01537264f, 0.04921835f, 0.02999319f, -0.00293118f, 
    0.00285114f, -0.06653967f, -0.02429355f, 0.03297007f, -0.17031109f, 0.55816013f, -0.05357580f, -0.33256045f, 
    -0.00196459f, 0.08654906f, 0.33980927f, 0.06812778f, -0.09360821f, -0.00402271f, -0.06461901f, -0.04134558f, 
    0.14122649f, 0.10362702f, 0.09902516f, 0.14201540f, 0.03942969f, 0.02763410f, 0.14951617f, 0.04736576f, 
    0.33990830f, -0.05692193f, -0.12862650f, -0.09478690f, 0.03888563f, -0.07503027f, 0.08669876f, -0.06112090f, 
    -0.09164317f, -0.12059804f, 0.01975475f, 0.03473814f, 0.05195810f, -0.11571962f, -0.03290100f, 0.16049789f, 
    0.09694319f, 0.06641731f, 0.04652339f, -0.12103220f, 0.21752988f, 0.16952349f, -0.04309555f, -0.18466400f, 
    0.10202881f, 0.25893751f, 0.21439958f, 0.11953146f, 0.04050812f, -0.03293255f, -0.05323856f, 0.02267924f, 
    0.07778379f, 0.05313971f, 0.02097092f, -0.04423129f, -0.08082604f, -0.01606688f, -0.07556970f, 0.00829806f, 
    -0.00501348f, 0.06079965f, -0.08578543f, -0.06401190f, -0.07055110f, -0.18514961f, -0.12040808f, -0.03655764f, 
    -0.12351776f, -0.15708798f, -0.03675861f, 0.05868749f, 0.03790333f, -0.08139775f, -0.05458161f, -0.13367498f, 
    -0.03344443f, -0.02505035f, -0.09751556f, -0.09988356f, 0.46524695f, -0.06205995f, -0.18269074f, 0.25841454f, 
    -0.10087201f, -0.05269403f, -0.02126602f, 0.05204407f, -0.10821580f, -0.04363937f, 0.02570243f, -0.03680680f, 
    -0.02630982f, 0.09431886f, -0.04396237f, -0.03348631f, -0.04862570f, 0.03859967f, -0.06589606f, -0.00867426f, 
    0.38853937f, 0.42691511f, 0.10487302f, -0.05218913f, 0.12133465f, 0.13943100f, 0.01253630f, 0.01020266f, 
    0.04422416f, 0.08550284f, 0.01066279f, -0.02149019f, 0.03271393f, -0.03772917f, 0.11001836f, -0.05495278f, 
    -0.11331960f, 0.08413121f, -0.10881994f, 0.05840974f, 0.00276297f, 0.24434772f, -0.00266568f, 0.40829101f, 
    -0.01862666f, -0.01815224f, -0.12196401f, -0.03870639f, -0.08185678f, -0.05380304f, -0.05110117f, 0.09654699f, 
    -0.10487765f, 0.09037021f, -0.08787380f, -0.02470015f, -0.01183905f, 0.18635376f, 0.05710543f, -0.04619606f, 
    0.16248199f, 0.27765614f, -0.10961666f, 0.00112014f, 0.00816616f, 0.11055044f, 0.00827602f, 0.20342182f, 
    0.11654002f, 0.10636649f, 0.02282125f, -0.05390047f, 0.00127174f, 0.08558407f, 0.04060765f, 0.01727335f, 
    -0.06321995f, 0.00646472f, 0.04927339f, 0.20007870f, -0.19381157f, -0.32527643f, -0.58348417f, -0.21216422f, 
    -0.19039886f, 0.06123663f, 0.02139539f, 0.04209552f, 0.02142825f, 0.02611159f, -0.07352853f, 0.05762570f, 
    -0.02247493f, 0.00545403f, -0.03131134f, -0.11440087f, 0.05094135f, -0.04083518f, 0.00013993f, -0.02681210f, 
    0.23001683f, 0.00934401f, -0.27026808f, -0.22275630f, -0.21761455f, 0.19029626f, 0.07194505f, 0.03177748f, 
    0.03524057f, -0.16225082f, -0.00098050f, -0.10792034f, 0.05918097f, 0.01173200f, 0.02199502f, 0.00681689f, 
    0.05227544f, -0.00919088f, 0.00834778f, -0.03835352f, -0.26971635f, -0.04397757f, -0.22847903f, 0.10594147f, 
    0.01582456f, -0.02459327f, 0.11912315f, -0.13285939f, -0.14798915f, 0.07782838f, -0.10467156f, 0.02396131f, 
    0.03612830f, 0.21776040f, 0.05167823f, 0.04590524f, -0.04771136f, -0.21086583f, 0.18841524f, 0.05479909f, 
    0.07473499f, 0.04838028f, -0.20485072f, 0.04327920f, 0.25979623f, 0.03220132f, -0.09118096f, 0.16669928f, 
    -0.08021209f, 0.23044989f, -0.02566983f, 0.18372825f, 0.05591861f, 0.06846168f, 0.04786053f, -0.01503773f, 
    0.05003682f, 0.11834708f, 0.03834296f, 0.14976771f, 0.26607412f, 0.01709171f, -0.41505423f, -0.26593670f, 
    -0.09610264f, 0.35288137f, 0.19205356f, 0.17276801f, -0.03753886f, -0.17000201f, -0.05474949f, 0.00272812f, 
    0.07712545f, -0.06498392f, 0.00010577f, -0.01700789f, 0.00557821f, 0.06215255f, -0.01578503f, -0.00983547f, 
    0.03318566f, 0.14407498f, 0.29705423f, 0.04961241f, 0.02381160f, 0.00007069f, 0.18454686f, -0.13447675f, 
    -0.17736323f, -0.13629261f, -0.02711383f, -0.06530909f, -0.10501333f, -0.04819732f, -0.04249132f, 0.14977609f, 
    0.07411624f, 0.06780855f, -0.08736996f, -0.21185613f, 0.51163501f, 0.44706631f, 0.25463223f, -0.24710977f, 
    0.14079168f, 0.35119095f, 0.13765690f, 0.16385147f, 0.14525145f, 0.03293585f, -0.01715863f, -0.01403896f, 
    -0.00126281f, -0.01937818f, 0.16331552f, 0.04016740f, -0.17057760f, 0.08673732f, 0.03150181f, 0.07636585f, 
    0.26994181f, 0.35929295f, -0.02106801f, -0.19503394f, 0.11010588f, 0.35510510f, 0.20362939f, 0.24145791f, 
    0.07606637f, -0.11766742f, -0.01352452f, -0.02590765f, 0.01816532f, 0.07132696f, 0.01705501f, 0.01103961f, 
    -0.06379156f, -0.06777944f, -0.00245333f, 0.11268241f, -0.14941108f, 0.09546947f, 0.67717016f, 0.12903608f, 
    -0.11639050f, 0.02236698f, -0.16722298f, -0.21090513f, 0.06767517f, -0.02682610f, -0.05361123f, 0.01211387f, 
    -0.13209373f, 0.14719953f, 0.00579289f, 0.08975809f, 0.09131823f, -0.12242795f, 0.10251252f, -0.05063413f, 
    0.26410231f, 0.33252972f, -0.01959686f, -0.15193172f, 0.16285925f, 0.20837139f, 0.03399420f, 0.16417393f, 
    0.09793195f, 0.13702060f, 0.00316069f, -0.06039718f, -0.05475292f, -0.05962919f, 0.00223959f, -0.01054537f, 
    -0.01971019f, 0.15047795f, -0.05880284f, 0.10583840f, 0.03540691f, 0.07360775f, 0.39178523f, -0.18906741f, 
    -0.15911239f, -0.00620578f, -0.06041966f, -0.07978998f, -0.16403866f, -0.13841102f, 0.18766138f, 0.07861359f, 
    -0.02191330f, 0.01562124f, -0.00295223f, 0.13248451f, 0.11862522f, 0.01048126f, -0.12640359f, -0.09189411f, 
    -0.21664791f, 0.09701856f, -0.06365786f, -0.08564641f, -0.07430389f, 0.00252841f, 0.07332402f, 0.11738162f, 
    0.01468986f, 0.04945987f, 0.00301507f, 0.22935764f, -0.15468426f, 0.05629324f, -0.10211687f, -0.12751926f, 
    0.19753423f, 0.00231735f, -0.03307577f, 0.07646044f, 0.05828099f, 0.24391218f, 0.33454114f, -0.30590385f, 
    0.05696414f, 0.00796615f, 0.02331204f, -0.02182304f, 0.06377454f, 0.11694030f, 0.00343674f, -0.03933132f, 
    0.01956302f, -0.01376839f, 0.03326062f, 0.02460064f, -0.12038236f, 0.06762629f, 0.03316450f, -0.06652880f, 
    0.15060274f, 0.16996056f, 0.23066123f, -0.16900513f, -0.08142111f, 0.02662205f, 0.02629522f, 0.04146508f, 
    0.03709829f, -0.05815836f, 0.02426213f, -0.06499010f, 0.01665724f, 0.06118209f, -0.00669778f, -0.00706921f, 
    -0.04187313f, 0.06953920f, 0.16870436f, 0.00256698f, 0.01398979f, 0.16272511f, 0.03922458f, -0.07323980f, 
    0.01651886f, 0.13167463f, -0.21774563f, -0.00084097f, -0.17541581f, 0.06297072f, -0.06970114f, -0.00040573f, 
    0.04938514f, -0.08225212f, 0.02820187f, 0.03663443f, -0.00589201f, 0.07163322f, 0.02852705f, -0.07755657f, 
    -0.02341393f, -0.09809171f, -0.04123453f, -0.04094790f, -0.06212014f, 0.17440596f, 0.13909185f, -0.01770718f, 
    0.17243654f, -0.02113787f, -0.04454604f, 0.13450029f, 0.05392235f, 0.14026496f, 0.04153648f, -0.02793526f, 
    0.00675120f, -0.00017256f, 0.05172502f, 0.29832250f, 0.28039870f, 0.25343528f, 0.29218242f, -0.15951042f, 
    0.02342851f, 0.26220229f, 0.06223732f, 0.01750935f, 0.07005618f, -0.03117381f, 0.06220923f, 0.04956921f, 
    -0.07955609f, -0.06211351f, 0.03433167f, 0.11536599f, -0.00451255f, 0.00393284f, -0.04845609f, -0.14837296f, 
    0.08932018f, 0.24118039f, 0.34312358f, -0.04588560f, 0.05873449f, -0.08298337f, -0.10225179f, -0.01321131f, 
    0.00698120f, -0.08820313f, -0.04546079f, -0.02977927f, -0.03548855f, 0.03636876f, -0.04652754f, -0.06685138f, 
    -0.17866522f, 0.16031432f, -0.06967575f, -0.17126228f, 0.31719336f, 0.16396487f, 0.10149316f, 0.18588607f, 
    0.06309685f, -0.10174666f, -0.09265341f, -0.04149074f, -0.06555767f, -0.18601166f, -0.08917139f, 0.03375627f, 
    0.07657305f, -0.04002391f, -0.09192819f, 0.07136543f, -0.00275594f, 0.01319819f, -0.10520364f, -0.15491763f, 
    0.98019832f, 0.12446407f, -0.47601786f, 0.38115650f, -0.38304403f, 0.27120191f, 0.04088393f, 0.31738597f, 
    0.03723004f, 0.14930442f, -0.05851144f, 0.05220947f, -0.08697999f, -0.01617269f, 0.13309036f, 0.14289060f, 
    -0.04087130f, 0.12824801f, 0.00990441f, 0.12760229f, 0.09916368f, -0.09376109f, 0.09027226f, -0.06686859f, 
    -0.01957416f, -0.11717327f, -0.01319334f, -0.05562608f, -0.02609506f, -0.13316870f, -0.03680808f, 0.12196381f, 
    -0.08636943f, -0.22130883f, -0.03013288f, -0.23303139f, 0.01418554f, 0.06399709f, 0.01415981f, -0.05447773f, 
    0.04140118f, -0.02658246f, 0.03769303f, 0.11166923f, -0.03225617f, -0.09404083f, -0.04697139f, -0.01263417f, 
    -0.05843961f, -0.16206567f, 0.05413526f, -0.07220351f, 0.02964562f, -0.04228821f, -0.06663355f, -0.07848638f, 
    0.00415839f, -0.09796397f, -0.08029015f, -0.10471535f, 0.03346199f, -0.00128800f, 0.08995976f, 0.07731877f, 
    -0.04895724f, -0.09210750f, 0.03241148f, -0.01793762f, -0.11655878f, -0.20921686f, -0.03848480f, -0.08000404f, 
    0.05831512f, 0.06607751f, -0.04878804f, -0.07877094f, -0.02579879f, -0.05534676f, -0.13313253f, -0.09972507f, 
    0.17199858f, 0.11821567f, -0.01391417f, 0.14752306f, -0.01932939f, 0.04891060f, -0.08972882f, -0.14908430f, 
    0.08162815f, 0.02451052f, -0.00706309f, -0.03544632f, -0.00988984f, 0.01763127f, -0.00304614f, 0.01310443f, 
    0.11387361f, -0.01994723f, -0.08956353f, 0.12153681f, -0.37115195f, 0.00647125f, 0.19307794f, -0.12399493f, 
    -0.20139578f, -0.04786034f, 0.19521914f, -0.01171959f, 0.09209438f, -0.18538041f, 0.00625067f, 0.03773342f, 
    0.05194641f, 0.02537169f, 0.12775266f, 0.11518630f, 0.07777465f, 0.04820674f, 0.00084738f, 0.06209514f, 
    0.47605693f, -0.14417417f, -0.05045225f, 0.29483953f, -0.12096637f, -0.10464943f, -0.10231228f, -0.02140138f, 
    0.08790065f, -0.06895062f, -0.08601455f, 0.07160086f, 0.07429597f, -0.08050283f, -0.09843223f, 0.09859052f, 
    0.05728517f, -0.08031750f, -0.00139515f, -0.10716861f, 0.05507944f, 0.23841831f, 0.12260957f, 0.02623765f, 
    0.08823461f, 0.03501035f, -0.02214333f, -0.03935182f, -0.05787191f, -0.05680614f, 0.00229672f, 0.03837001f, 
    0.00592216f, 0.02218635f, -0.04386364f, -0.03368644f, -0.04625051f, -0.03513874f, -0.01266353f, -0.01997236f, 
    0.12515289f, 0.03674284f, 0.01078416f, -0.02102287f, 0.02386604f, -0.07424766f, 0.06540583f, 0.02520694f, 
    -0.00152481f, 0.03066076f, -0.04930702f, -0.00590044f, -0.04084967f, 0.11620691f, 0.09242554f, -0.04237133f, 
    -0.12252715f, -0.00592095f, -0.08466072f, -0.11750037f, 0.22331204f, -0.12241261f, -0.09558488f, 0.20490272f, 
    -0.14154875f, -0.13426594f, -0.05475309f, -0.00903117f, -0.00281503f, 0.05186698f, -0.00892101f, 0.02190712f, 
    -0.08926154f, 0.07166371f, -0.04742764f, 0.02541373f, -0.01764868f, 0.04155293f, -0.04400953f, 0.04019260f, 
    0.26072398f, 0.35602364f, 0.09404700f, 0.15167212f, 0.03352934f, 0.07388292f, 0.06992137f, -0.00266223f, 
    -0.07234633f, 0.13118617f, -0.05064915f, 0.03222376f, 0.06102656f, 0.07450303f, 0.01609941f, 0.05925240f, 
    0.03961464f, -0.00626571f, -0.01777744f, 0.06181465f, 0.19589473f, -0.09799045f, 0.05430093f, 0.10827626f, 
    -0.03483294f, -0.12042141f, 0.03980918f, 0.08497564f, 0.16810231f, -0.17174733f, -0.16675207f, -0.05099751f, 
    -0.09033483f, 0.08169833f, -0.00645608f, 0.05407287f, -0.07531626f, 0.02126678f, 0.07175853f, 0.06177904f, 
    -0.04580243f, 0.29281166f, 0.13204975f, 0.03238318f, 0.14760205f, -0.02875555f, -0.01005119f, 0.01479542f, 
    -0.02471733f, 0.04379001f, -0.02041406f, 0.04838335f, -0.05274041f, 0.08903244f, -0.02085595f, -0.01206438f, 
    -0.01792313f, -0.03289964f, 0.06944814f, 0.00656705f, 0.18931730f, -0.20540011f, -0.49057356f, 0.00769214f, 
    -0.16639683f, -0.15608150f, -0.03144752f, -0.00537521f, 0.02041870f, 0.00618790f, -0.04480665f, 0.03570307f, 
    -0.07580242f, -0.02785718f, -0.01274345f, -0.05474613f, -0.01160140f, 0.01529624f, -0.00686652f, -0.00362611f, 
    0.12453987f, -0.31998950f, 0.08197910f, -0.09398419f, -0.25270125f, -0.14816497f, -0.03103816f, -0.00490323f, 
    -0.06291125f, 0.02526800f, 0.05416438f, -0.02403159f, -0.04392077f, -0.08595635f, -0.09218407f, 0.07303400f, 
    -0.03898224f, 0.04089978f, 0.02485011f, 0.00526196f, -0.56958961f, -0.31678805f, 0.29604053f, 0.33009827f, 
    0.04870302f, 0.02710665f, -0.05287473f, -0.08567332f, -0.09760048f, 0.08883928f, 0.04660927f, 0.12550169f, 
    -0.07419489f, 0.18068288f, -0.07543861f, -0.03793659f, 0.10669988f, -0.07013471f, -0.28505975f, 0.21296014f, 
    0.23408568f, -0.02290369f, -0.14021109f, 0.13686523f, 0.01277969f, 0.07145642f, -0.05127707f, 0.04528013f, 
    0.16567160f, 0.00810684f, -0.07104839f, 0.04795897f, -0.06076271f, 0.05263704f, 0.03065618f, -0.05189421f, 
    0.09082960f, -0.07843751f, -0.00392919f, 0.09902726f, 0.37335432f, 0.03396449f, -0.03619973f, 0.05190207f, 
    -0.30085161f, -0.11538535f, 0.00856535f, -0.02169575f, -0.03544170f, -0.08464471f, -0.02283376f, -0.01127403f, 
    -0.03417424f, -0.07714132f, -0.09483477f, 0.08298521f, 0.03556761f, 0.03078569f, -0.04516187f, 0.02799887f, 
    -0.21785475f, -0.11517190f, 0.43565053f, -0.07973634f, 0.16090795f, -0.09950327f, 0.16052271f, 0.10721036f, 
    0.04482296f, -0.03255321f, 0.00486707f, -0.10983405f, 0.04281785f, 0.05610729f, -0.03941716f, 0.18377505f, 
    -0.01450018f, 0.01856549f, -0.04611062f, -0.04718689f, 0.30595973f, 0.27842602f, 0.31936026f, 0.07879540f, 
    -0.03477819f, 0.09542484f, 0.12957397f, -0.02455377f, -0.02369934f, -0.00264966f, -0.02004105f, 0.03498417f, 
    -0.01561147f, -0.01482088f, 0.02291294f, 0.10088148f, 0.11084592f, -0.02884349f, 0.11937716f, 0.11125414f, 
    0.17168435f, 0.33551368f, 0.10716163f, 0.05992326f, 0.01047607f, -0.15010688f, 0.10716157f, -0.02036377f, 
    -0.10377262f, -0.04837371f, 0.02970264f, 0.03422030f, -0.01498379f, -0.09604833f, -0.04074007f, -0.03327048f, 
    -0.05528926f, -0.03464229f, -0.08443180f, -0.00416355f, 0.20127244f, -0.04667109f, 0.14489801f, 0.11124595f, 
    -0.26839381f, 0.03821728f, -0.04665985f, -0.07053501f, 0.07298534f, 0.02451574f, -0.09063340f, -0.00105766f, 
    0.04588724f, 0.12632750f, -0.07069994f, -0.04564994f, 0.13190500f, -0.02888484f, 0.09437998f, 0.09703114f, 
    0.12242641f, 0.39076927f, 0.21012850f, 0.15202747f, 0.19275714f, -0.09729469f, -0.03856608f, 0.02962769f, 
    -0.04001975f, 0.11030722f, -0.04682597f, -0.01544782f, -0.04057419f, -0.05829699f, -0.00393136f, 0.00578295f, 
    0.00049893f, 0.00939659f, -0.02498896f, -0.10529313f, -0.09292917f, 0.05559915f, 0.37373960f, -0.10706698f, 
    0.04512489f, 0.13199654f, 0.14414196f, 0.01539405f, -0.04290173f, 0.00772132f, 0.10356338f, 0.03008900f, 
    -0.02658738f, 0.04671450f, -0.02949395f, -0.05808979f, -0.01515311f, -0.09459912f, 0.00998131f, 0.03267533f, 
    -0.03347011f, 0.24311310f, 0.16220514f, 0.10905413f, 0.10337539f, 0.09867556f, -0.00055019f, 0.18354729f, 
    0.01128211f, 0.08952919f, 0.06330803f, 0.10561460f, 0.05260821f, -0.00614906f, -0.01095852f, -0.11105368f, 
    -0.09707778f, -0.02956271f, -0.20108661f, -0.30024171f, 0.14105536f, 0.14108524f, -0.16981356f, 0.07839997f, 
    0.01834330f, 0.04708857f, -0.10256052f, -0.08895775f, -0.00215208f, 0.06818677f, -0.03048708f, -0.02673682f, 
    -0.00953810f, -0.02429962f, 0.01269966f, 0.07574503f, 0.11219179f, 0.01120290f, -0.00249923f, 0.07785079f, 
    -0.17007148f, 0.19002093f, 0.00820750f, 0.06361191f, -0.06430668f, -0.05413739f, 0.00488851f, 0.05768356f, 
    -0.08623026f, 0.16714723f, -0.09867028f, -0.02778035f, 0.01394972f, 0.14033824f, 0.00437477f, -0.06877355f, 
    -0.12163418f, -0.06567181f, 0.08856780f, 0.07638323f, 0.05158072f, 0.23943686f, 0.18632378f, -0.11753660f, 
    0.01512489f, 0.07261726f, -0.11022379f, -0.10649108f, 0.01498678f, -0.02326764f, -0.09253182f, -0.04178973f, 
    0.00198128f, -0.03236907f, -0.01326932f, 0.09687487f, 0.02732383f, -0.02069855f, 0.06712455f, -0.02558255f, 
    -0.16733563f, 0.00492989f, 0.08200888f, 0.12107898f, 0.00475004f, 0.03441991f, 0.11119826f, 0.00655346f, 
    0.05481170f, 0.11269566f, 0.01065409f, 0.14771195f, 0.03274985f, 0.09072903f, -0.01257027f, -0.10421096f, 
    -0.02522209f, -0.04341864f, -0.06478161f, -0.10054220f, -0.21621990f, 0.02095368f, 0.35581669f, 0.00395529f, 
    0.15627544f, 0.08442610f, 0.04300017f, -0.00598919f, -0.09075987f, -0.07650071f, 0.02612787f, -0.03515276f, 
    0.00633238f, 0.03360202f, 0.01779077f, 0.08800339f, 0.02699155f, 0.03638422f, 0.07446335f, 0.03363195f, 
    0.39265281f, -0.00366638f, -0.19598144f, 0.18837065f, 0.08333770f, -0.03133070f, -0.04407794f, -0.05504055f, 
    -0.04466308f, -0.10747990f, -0.06554969f, 0.03550519f, -0.02152115f, -0.00485147f, -0.08242252f, -0.09180795f, 
    -0.02274691f, 0.08829147f, 0.01109059f, 0.13811728f, 0.51484162f, 0.09177892f, 0.07344077f, 0.11391523f, 
    0.11900850f, -0.07960045f, 0.01207117f, 0.01630404f, 0.01831124f, -0.01975477f, 0.02196724f, 0.17245491f, 
    0.04503189f, 0.06194264f, 0.07203858f, 0.00143314f, -0.01583292f, 0.04857878f, -0.08842129f, -0.06301251f, 
    0.22747892f, -0.33542234f, -0.07700159f, 0.26263282f, -0.49264246f, -0.08841502f, 0.15045920f, -0.00185863f, 
    0.13231649f, 0.04883135f, -0.00728685f, -0.07915035f, -0.09462360f, -0.00421410f, 0.07022096f, 0.10546792f, 
    0.12082255f, 0.04104005f, -0.04612716f, -0.02842132f, 0.14460008f, 0.07587007f, 0.00628080f, 0.14242208f, 
    0.00393934f, 0.05390990f, -0.06044216f, 0.10863057f, 0.09165584f, -0.04311710f, -0.07900447f, 0.02023845f, 
    -0.04507131f, -0.08018856f, 0.03756889f, -0.26752910f, 0.10105207f, -0.04612786f, -0.07546982f, -0.03789014f, 
    0.30651492f, 0.06666061f, 0.03950586f, 0.03761246f, -0.01796548f, -0.07563226f, 0.07096738f, -0.02598584f, 
    0.00245484f, -0.02670577f, -0.08394195f, 0.06873768f, 0.08107589f, 0.02642163f, 0.12045954f, -0.04334373f, 
    0.08860203f, -0.13487010f, -0.10930685f, -0.13632536f, 0.11441904f, 0.00690629f, 0.12598670f, 0.09024611f, 
    -0.02266707f, -0.12611093f, 0.00242854f, 0.06032711f, 0.05780608f, -0.05612289f, 0.08799724f, 0.09396553f, 
    0.01718445f, 0.04459972f, -0.07801383f, 0.00584294f, -0.02947381f, -0.08171304f, -0.14713766f, -0.02353871f, 
    -0.03218850f, -0.00647808f, -0.03330442f, -0.02092845f, 0.03272642f, -0.01110553f, -0.04002688f, -0.02240001f, 
    -0.00799813f, 0.02938563f, -0.01514700f, 0.00563965f, 0.02764911f, 0.00170168f, 0.01333359f, 0.00762908f, 
    0.00356112f, -0.00410500f, -0.00279483f, -0.03811505f, -0.03920746f, -0.02061913f, 0.00294708f, 0.00895867f, 
    -0.03827070f, 0.03353018f, 0.00720933f, -0.00435763f, -0.01731310f, 0.00382806f, -0.01451404f, 0.00102399f, 
    -0.04214904f, 0.02647644f, 0.00019684f, -0.04006345f, 0.01577729f, 0.00394116f, -0.02173845f, -0.01955874f, 
    0.00180677f, -0.01074976f, 0.00513353f, -0.03410326f, -0.02828794f, 0.01874527f, -0.02646141f, -0.01219418f, 
    -0.00923858f, 0.00370330f, 0.02917134f, -0.00225783f, 0.00513407f, -0.04505995f, 0.03369012f, 0.00462411f, 
    -0.01997265f, 0.02404038f, 0.01102493f, -0.02179648f, 0.00429791f, -0.01062683f, -0.03805071f, -0.04464837f, 
    0.02430377f, -0.04000605f, -0.03072360f, -0.02385145f, 0.02939808f, -0.00921544f, -0.00635235f, -0.01618694f, 
    -0.03580890f, -0.03563961f, -0.00501833f, 0.00594982f, -0.00296326f, -0.01181038f, -0.00362848f, 0.00643744f, 
    -0.00162028f, -0.03939798f, -0.04336835f, 0.00486918f, -0.04461271f, 0.01220909f, -0.03053746f, -0.00267097f, 
    -0.03225629f, 0.02902182f, 0.02789616f, -0.02108128f, -0.00118748f, -0.03547160f, 0.01034255f, -0.01215609f, 
    -0.00540126f, 0.00042639f, 0.01436557f, 0.01601329f, -0.04168568f, 0.02999803f, -0.03260973f, 0.01154321f, 
    0.01221405f, -0.03889422f, -0.01335296f, -0.01942638f, 0.01928603f, -0.03098838f, 0.01888531f, 0.03182893f, 
    -0.03681441f, -0.04155646f, -0.00484642f, -0.04103236f, 0.02982604f, 0.02101155f, -0.00263562f, -0.01232012f, 
    0.03377952f, 0.01946213f, -0.01561942f, 0.02407385f, 0.01232255f, -0.01962082f, 0.01337291f, 0.02380891f, 
    0.03074872f, 0.03360233f, 0.03670383f, -0.01276413f, -0.00167836f, -0.02261745f, -0.03278479f, -0.01213111f, 
    0.02740468f, -0.03424899f, -0.02206123f, -0.02325087f, -0.03073401f, -0.04175236f, -0.00815986f, -0.03896694f, 
    -0.00248578f, -0.03417977f, 0.02962413f, -0.01549949f, -0.03388825f, -0.00774385f, 0.01338720f, -0.03597995f, 
    0.00867642f, -0.01759891f, 0.00667153f, 0.02543007f, -0.00766015f, -0.01323566f, 0.02091009f, 0.00744596f, 
    -0.01979633f, -0.00754236f, -0.01648773f, -0.04132347f, 0.01202600f, -0.02045100f, -0.03863585f, 0.01986521f, 
    -0.00029460f, -0.01551973f, -0.02256072f, -0.03858733f, -0.00421873f, 0.01878288f, 0.01951715f, -0.00574811f, 
    0.01162321f, -0.03899188f, 0.02496908f, -0.02541660f, -0.00808680f, 0.02082774f, -0.02609210f, -0.01689794f, 
    -0.00385915f, 0.01847369f, -0.03444994f, -0.02243650f, -0.03257117f, -0.01358116f, 0.01072885f, 0.01225401f, 
    -0.01816652f, -0.03237184f, -0.04237227f, 0.00290867f, 0.03807313f, 0.03087640f, 0.03370060f, -0.02374523f, 
    0.00338785f, -0.02328895f, -0.03775197f, 0.02390422f, -0.04133027f, -0.04296432f, -0.00819953f, 0.00201874f, 
    -0.00391568f, -0.03745357f, -0.03005434f, 0.03383605f, 0.00852121f, -0.02046846f, 0.00384378f, -0.00565791f, 
    -0.00001496f, -0.02051676f, 0.01611278f, -0.02178286f, 0.02947362f, 0.00995054f, 0.02246631f, 0.03271166f, 
    -0.03579566f, 0.02838829f, 0.00935308f, 0.01054280f, 0.00854142f, 0.00624005f, 0.00442103f, 0.00761186f, 
    0.02377330f, 0.01160009f, -0.00153011f, -0.00908033f, -0.03656620f, -0.03938358f, -0.03609978f, -0.03889123f, 
    -0.00637111f, -0.03513378f, -0.02957202f, -0.04308505f, -0.02396875f, -0.01336893f, -0.02018402f, -0.03992127f, 
    -0.03361603f, -0.04176803f, -0.03462870f, 0.00707890f, 0.02317870f, -0.02183807f, -0.01095638f, 0.02331449f, 
    0.02524861f, 0.00112130f, 0.00586026f, 0.02193451f, -0.02936525f, -0.02940681f, -0.00673158f, 0.02231597f, 
    -0.01006057f, -0.00899462f, 0.01034582f, -0.03510669f, 0.01286024f, -0.03192487f, 0.02405319f, 0.01964336f, 
    0.00296923f, -0.02500861f, 0.02765970f, -0.04386324f, -0.01355264f, 0.02092850f, -0.03764889f, 0.02909225f, 
    0.03265326f, 0.00633563f, -0.01147191f, -0.01484204f, -0.01504260f, 0.02145494f, 0.01375657f, -0.01085325f, 
    -0.03326368f, -0.02677428f, 0.00948404f, -0.03996348f, 0.02688664f, -0.02589654f, -0.04000271f, -0.02051445f, 
    0.02035055f, 0.00893426f, 0.02541963f, -0.00226523f, -0.00277582f, 0.03251344f, -0.02089237f, -0.01988761f, 
    0.01860489f, -0.03552511f, -0.01237596f, 0.01783950f, -0.03264520f, 0.00563850f, -0.01584877f, -0.03609706f, 
    0.01399494f, -0.02956902f, -0.04485043f, -0.00143588f, -0.00779791f, -0.03370995f, -0.03513690f, -0.03353983f, 
    0.01096265f, 0.01442284f, -0.02129049f, -0.04080176f, -0.01974443f, -0.03572738f, 0.03140216f, -0.03851691f, 
    -0.00732505f, 0.00295175f, -0.03703552f, -0.00337158f, 0.00867745f, 0.00166841f, 0.02859268f, 0.01559012f, 
    0.02192928f, 0.03896684f, -0.00331549f, -0.01666852f, 0.00532563f, -0.00601533f, 0.00280787f, -0.03852220f, 
    0.01098192f, 0.02373326f, 0.03378701f, 0.02797263f, -0.03804683f, -0.00227936f, -0.02482620f, -0.02143727f, 
    0.02645990f, -0.02018247f, -0.03151044f, -0.02677745f, -0.03523746f, 0.01290484f, 0.02960054f, -0.04401701f, 
    -0.01996803f, -0.00417668f, 0.02002802f, -0.02145030f, 0.01086356f, 0.02956107f, -0.04427847f, -0.00872723f, 
    0.02664561f, 0.02632452f, -0.03493850f, -0.01907671f, -0.00821910f, -0.01956491f, 0.00057864f, 0.00380046f, 
    0.03368421f, 0.03902495f, -0.02478115f, 0.03314904f, -0.01390920f, -0.03157940f, 0.02648753f, 0.02571068f, 
    -0.00198981f, -0.00531031f, -0.03071164f, 0.00946001f, -0.04053279f, 0.01069041f, 0.02079284f, -0.01637347f, 
    0.01627279f, -0.00152266f, -0.00248886f, 0.01882735f, -0.02064077f, 0.00876284f, -0.03645810f, -0.03570390f, 
    0.01888075f, -0.04198419f, 0.00214166f, 0.01227373f, 0.00572067f, -0.02516508f, 0.01559076f, -0.03302532f, 
    -0.02990847f, 0.02480908f, 0.02195684f, 0.02160631f, 0.01651397f, -0.01996968f, -0.02040477f, 0.01961708f, 
    -0.03703525f, -0.03164183f, 0.03241144f, -0.00847356f, -0.03314535f, 0.00875426f, 0.01481473f, 0.02209103f, 
    0.00664071f, 0.02884865f, -0.01298769f, 0.02591181f, -0.01065982f, -0.04399474f, -0.03636770f, -0.03071576f, 
    -0.03375586f, -0.01929942f, -0.03866744f, -0.04380434f, -0.01301045f, 0.02350503f, 0.00856231f, -0.02431079f, 
    -0.01228932f, -0.00580895f, -0.00144900f, -0.01518365f, -0.00129280f, -0.02408289f, -0.00309008f, -0.02490892f, 
    -0.00364479f, 0.02741674f, 0.03012322f, -0.00563798f, 0.01126660f, -0.02657628f, -0.01556595f, -0.01757796f, 
    -0.00060976f, -0.02908153f, 0.00415175f, 0.02036744f, -0.03087408f, -0.02719730f, 0.02864100f, -0.03348637f, 
    -0.00498855f, -0.00865292f, 0.03306399f, 0.01650338f, -0.03939436f, 0.02011591f, 0.02447591f, 0.00476245f, 
    0.01536578f, -0.00550275f, 0.03250195f, -0.01373026f, 0.02096688f, -0.00903931f, -0.04328868f, -0.00448579f, 
    -0.01089268f, -0.00913420f, 0.03280378f, 0.02983859f, -0.02521022f, -0.01641196f, -0.01250360f, -0.01521265f, 
    -0.03251707f, 0.00303296f, 0.02438522f, -0.01241923f, -0.03493950f, -0.02451529f, -0.03906043f, -0.03612057f, 
    -0.03979433f, -0.04416914f, -0.02014819f, -0.02965820f, 0.02553730f, 0.00629306f, -0.00584267f, -0.02025005f, 
    0.02548923f, -0.01082216f, -0.00886663f, 0.02098646f, 0.03081566f, -0.01609725f, -0.01470452f, -0.02034693f, 
    -0.04028061f, 0.00045360f, 0.00905711f, 0.01713398f, 0.01562707f, 0.00846835f, -0.03506072f, 0.00275658f, 
    -0.03051813f, 0.02488233f, -0.02961473f, 0.01362820f, -0.00074037f, -0.03354571f, -0.01692371f, -0.02051776f, 
    0.00919651f, 0.02215914f, -0.00637245f, -0.01731031f, -0.00547167f, 0.01002444f, -0.03197856f, 0.00162348f, 
    0.01300199f, 0.01680342f, -0.04330835f, -0.02299619f, -0.02425148f, 0.01453141f, 0.00092003f, 0.00066296f, 
    0.03230930f, -0.02642182f, 0.00913680f, 0.01945511f, 0.01835681f, -0.02504102f, 0.00252532f, -0.00863631f, 
    0.01828047f, -0.02956045f, 0.00243658f, 0.03103691f, 0.02975194f, -0.02613536f, 0.00369036f, -0.03590231f, 
    -0.00965906f, -0.02429480f, -0.03795679f, 0.01676583f, 0.00114028f, -0.00902710f, -0.02143960f, 0.01539389f, 
    -0.03107717f, -0.04414696f, -0.00174847f, 0.00130305f, 0.01302470f, -0.03914027f, 0.02147294f, -0.02605448f, 
    0.01583663f, -0.01664342f, -0.03728196f, 0.00548106f, 0.01503275f, -0.00777840f, -0.03982038f, -0.03445213f, 
    0.02745405f, 0.02524255f, -0.03585833f, 0.02842779f, 0.03404732f, -0.00686506f, -0.01955277f, -0.01916830f, 
    -0.00258628f, -0.03243012f, 0.01699470f, 0.01557122f, 0.00562040f, -0.00811801f, -0.01952933f, -0.03075079f, 
    0.01713329f, -0.01670565f, -0.03986704f, 0.01074533f, -0.03499799f, -0.01593384f, 0.02278935f, 0.02388214f, 
    -0.02203084f, -0.02180074f, -0.04229171f, -0.01505867f, 0.02302776f, -0.00582727f, 0.01247486f, 0.00157527f, 
    0.01888385f, -0.01072698f, 0.00867706f, -0.00274755f, -0.04143719f, 0.01276123f, 0.01516468f, -0.01596899f, 
    -0.02211669f, 0.02162240f, 0.01621900f, -0.04119121f, -0.01406879f, -0.03977522f, 0.03155020f, -0.00210906f, 
    -0.00390200f, -0.00884470f, -0.03620059f, -0.00291713f, -0.02512875f, -0.01033030f, -0.01159865f, 0.01184143f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00119289f, 0.02729521f, -0.03411498f, 0.09015690f, 0.04141887f, 0.01853061f, -0.01029408f, 0.10408969f, 
    -0.03906647f, -0.04342047f, -0.02562417f, -0.03598664f, -0.01728064f, 0.05873870f, -0.04163300f, 0.06949363f, 
    -0.00060609f, 0.01632223f, 0.11822090f, 0.11447880f, 0.01815547f, 0.13937706f, 0.04144972f, 0.14647007f, 
    0.01019638f, 0.08819623f, 0.00142778f, 0.26730543f, 0.00972197f, -0.04744576f, 0.02991334f, 0.00127244f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.21606447f, -0.18308328f, 0.41618592f, 0.10694812f, -0.49020043f, 0.03952818f, 0.01841730f, 0.12522914f, 
    0.05735432f, 0.11776256f, -0.08343587f, -0.00620913f, 0.00338316f, -0.26262504f, 0.06189852f, 0.12485940f, 
    -0.04303489f, 0.11045102f, -0.47109562f, -0.65197694f, 0.02917327f, -0.02021801f, -0.33121139f, -0.33880749f, 
    -0.07473716f, -0.33145264f, 0.01484414f, -0.37070698f, -0.14822872f, 0.43997422f, 0.34927592f, 0.14801486f, 
    0.00955784f, -0.11518558f, -0.35345572f, 0.11953719f, 0.05610732f, 0.05378663f, -0.06860319f, 0.28856584f, 
    -0.15375714f, 0.16719183f, -0.15985595f, -0.08144671f, -0.66094488f, -0.26867816f, 0.05312464f, 0.07984047f, 
    -0.38951197f, 0.08031389f, 0.15185261f, 0.04351956f, -0.42472476f, -0.00897115f, 0.12117400f, -0.11669674f, 
    0.05891011f, 0.20591821f, -0.16346878f, 0.31597874f, -0.10039726f, 0.27366027f, 0.27936617f, -0.09053800f, 
    0.23055689f, -0.09198776f, 0.40250877f, -0.55746078f, -0.53557956f, -0.06109098f, -0.03959329f, 0.18561845f, 
    -0.05411968f, 0.04173891f, 0.00959018f, 0.00498118f, 0.16934387f, -0.24913447f, -0.07237200f, 0.06975835f, 
    -0.08099169f, 0.10177567f, 0.32913408f, 0.07560179f, -0.57345015f, 0.28531358f, -0.02600774f, -0.11841860f, 
    -0.07565708f, 0.08225984f, -0.01887931f, 0.16444010f, 0.12243338f, -0.52185041f, -0.42289919f, -0.10487208f, 
    0.33636037f, 0.07341395f, 0.14057183f, -0.85335052f, 0.05529691f, -0.12335384f, -0.05741767f, -0.18676448f, 
    -0.04557625f, -0.03282263f, 0.03854284f, 0.12533866f, 0.20131409f, 0.07444111f, -0.04401080f, -0.21913983f, 
    -0.22270127f, 0.02091747f, -0.27307552f, 0.05359256f, 0.15210487f, -0.21548252f, -0.05163073f, -0.39410546f, 
    -0.03612604f, 0.37734976f, -0.08132043f, -0.39291772f, -0.00667325f, 0.21647848f, -0.27618286f, -0.01574754f, 
    0.27607921f, 0.00027508f, -0.10566206f, -0.11313973f, 0.14792140f, -0.07780015f, -0.07427070f, 0.24984533f, 
    -0.00198726f, -0.00875890f, -0.10222127f, 0.04463010f, 0.02678718f, 0.19120353f, -0.12145276f, -0.01489460f, 
    0.41167822f, -0.08783845f, 0.08920071f, -0.32551932f, 0.21333648f, -0.66131246f, -0.21905814f, 0.02330260f, 
    0.13406478f, -0.06476489f, 0.01221115f, -0.35984850f, 0.01781119f, -0.51426727f, 0.18014145f, -0.08661075f, 
    -0.09101143f, 0.00944260f, 0.17312258f, 0.30004779f, -0.38421404f, -0.02253249f, -0.14700429f, 0.10290110f, 
    0.01533214f, 0.04052398f, -0.16292621f, -0.18215251f, -0.05937894f, 0.28918818f, 0.10121762f, 0.03631887f, 
    -0.45614770f, -0.00554252f, 0.14113037f, -0.20251971f, 0.35998425f, -0.29597190f, 0.17300104f, -0.04444045f, 
    -0.05299114f, -0.36386144f, -0.15274607f, 0.06723499f, 0.15285240f, -0.04375262f, -0.12302440f, -0.00014550f, 
    -0.67825717f, -0.15665530f, 0.14431536f, -0.08984281f, -0.04073396f, -0.02481624f, 0.04132944f, -0.36031225f, 
    -0.07309019f, 0.10643347f, -0.15131865f, 0.14319205f, 0.37539959f, -0.25899509f, -0.00759708f, -0.16595864f, 
    -0.28696558f, 0.10289383f, 0.18113063f, 0.32886723f, -0.07399787f, 0.11715908f, -0.80764598f, 0.17203443f, 
    -0.15186431f, 0.22119176f, 0.15795945f, 0.00588395f, -0.13807891f, -0.70646143f, -0.52280325f, -0.17558657f, 
    -0.59360552f, -0.11950310f, 0.47625417f, 0.24027209f, 0.19142084f, 0.11124501f, 0.06309772f, -0.26865783f, 
    0.09445756f, 0.07538874f, 0.13465430f, -0.03758154f, -0.10004432f, -0.23277244f, -0.03185814f, -0.13102849f, 
    0.45244601f, 0.15191780f, 0.20905295f, -0.27431598f, -0.05522993f, 0.10759595f, 0.20186102f, 0.09771487f, 
    -0.04300286f, -0.29201353f, -0.15757050f, -0.42937085f, -0.06695092f, -0.03097392f, 0.07660393f, -0.15679987f, 
    -0.38950580f, 0.05362150f, 0.15730651f, -0.19802579f, 0.36333382f, -0.13194850f, -0.02943006f, -0.53781009f, 
    -0.04521519f, -0.06534900f, -0.14047642f, -0.13304973f, -0.45998478f, 0.14409401f, -0.10422689f, -0.21992961f, 
    -0.48407024f, -0.16965598f, 0.17609484f, 0.42068255f, 0.09272807f, 0.25611225f, 0.31965536f, -0.50278527f, 
    -0.15772152f, -0.50370705f, 0.03224505f, 0.17685899f, -0.14567579f, 0.12856558f, -0.26073945f, -0.01772392f, 
    0.10343120f, -0.02359105f, -0.40972033f, 0.24612248f, -0.35265264f, 0.11040601f, 0.10172035f, -0.27791688f, 
    0.03715310f, 0.00726619f, -0.09850582f, 0.08142374f, 0.28937536f, 0.03019643f, -0.16543759f, -0.41635299f, 
    0.51697421f, -0.03082162f, -0.51427770f, -0.09847994f, -0.42585358f, -0.07940486f, -0.37358227f, 0.24002242f, 
    -0.05175401f, -0.23473831f, 0.03629529f, 0.28034836f, -0.03911102f, -0.37001950f, -0.17551123f, -0.05065349f, 
    -0.45296109f, 0.07153682f, -0.47985822f, 0.03889157f, -0.09004573f, -0.12413218f, -0.17294595f, 0.38134581f, 
    0.03517814f, 0.11199418f, -0.17055804f, 0.00211017f, -0.11091808f, 0.04283233f, -0.08584139f, -0.44858694f, 
    -0.32181919f, -0.09527662f, -0.22734822f, 0.33395979f, 0.21459170f, 0.41706288f, -0.01777132f, -0.50908518f, 
    -0.13756669f, 0.22038484f, 0.16284487f, -0.41611159f, -0.01518505f, -0.27525586f, 0.14431326f, -0.05353940f, 
    -0.14948504f, 0.16118205f, -0.57160717f, -0.58965456f, 0.10280935f, -0.12204017f, 0.11804165f, -0.50988901f, 
    0.05424063f, 0.05893727f, -0.04417296f, 0.01620382f, -0.14870134f, 0.31731755f, 0.04818137f, -0.55032587f, 
    -0.54671961f, -0.05026970f, 0.27787006f, -0.23093380f, -0.06617602f, 0.21262228f, -0.35210815f, 0.14117210f, 
    -0.10131140f, 0.03702427f, -0.00618839f, 0.15377545f, 0.00871485f, 0.07620921f, 0.37176672f, -0.09941103f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.51590002f, 0.01349353f, 0.14765683f, -0.10196585f, -0.08569475f, -0.01246637f, 0.01623430f, -0.10859958f, 
    0.21434617f, 0.14793168f, -0.09915522f, -0.03681559f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
