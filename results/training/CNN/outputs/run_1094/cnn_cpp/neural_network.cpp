#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.75319755f, -0.48541370f, -0.11642189f, 0.51461685f, 0.00435074f, -0.09206738f, -0.16663317f, -0.20013025f, 
    -0.48018268f, 0.29559422f, -0.34766418f, -0.02087622f, -0.42912102f, -0.58214015f, 0.68867844f, -0.36607218f, 
    -0.20240271f, 0.35126078f, -0.48982695f, -0.57599723f, -0.40262148f, 0.12804289f, 0.43195418f, -0.73935598f, 
    -0.31987867f, -0.13113132f, -0.18835600f, 1.10505641f, -0.58466995f, -0.22692052f, 0.37814170f, -0.15900716f, 
    0.16008432f, -0.07688629f, 0.04024418f, -0.20334348f, -0.06486013f, -0.19854853f, -0.12462399f, -0.49676603f, 
    -0.64373249f, -0.89041054f, -0.25105080f, -0.29507887f, 0.43024009f, -0.55434895f, -0.28434569f, -0.56730115f, 
    0.23238213f, 0.57636702f, 0.19793458f, 0.06740913f, 0.49391818f, 0.22427784f, -0.10126642f, -0.16446574f, 
    0.01526414f, 0.35626489f, -0.27638802f, -0.08490020f, -0.21688274f, 0.70815736f, -0.24193102f, -0.58156115f, 
    0.49760285f, -0.24901246f, -0.38303733f, -0.15792884f, 0.37542731f, 0.04423061f, 0.18979111f, 0.45491898f, 
    0.40811858f, 0.66449928f, 0.48938975f, -0.56781071f, 0.17218709f, -0.70339495f, 0.00578961f, 0.16957901f, 
    -0.06279912f, 0.47391647f, -0.37980381f, 0.04034294f, -0.47542152f, -0.37750432f, -0.48529640f, 0.53040725f, 
    0.45120662f, 0.32916188f, -0.72972667f, -0.44022959f, 0.01988514f, 0.03351694f, -0.49835092f, -0.38332182f, 
    0.14811027f, 0.41361323f, 0.08334980f, 0.08035856f, 0.05059842f, 0.27773294f, 0.64949030f, -0.17117389f, 
    -0.22569042f, 0.43884102f, -0.54948068f, 0.33543539f, 0.24566935f, 0.17314346f, -0.06811571f, 0.11518994f, 
    0.76937985f, -0.52545702f, 0.34891182f, -0.10730868f, 0.39251253f, 0.58059382f, 0.39540175f, 0.04696715f, 
    -0.38738677f, -0.26030925f, 0.33497581f, 0.64932340f, -0.05981010f, -0.00947850f, 0.48688886f, -0.18263467f, 
    0.25156659f, 0.45321634f, 0.40651137f, 0.04308616f, -0.53786778f, 0.03301942f, -0.48495734f, -0.61241037f, 
    0.17530280f, -0.41421285f, -0.06248378f, 0.24443777f, 0.78841668f, 0.06251570f, 0.09490299f, -0.23665352f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28505501f, 0.05983978f, -0.04770188f, 0.20253509f, 0.15072349f, 0.29143721f, -0.20306255f, 0.28082129f, 
    0.16807988f, -0.15333858f, -0.24777846f, -0.09615400f, -0.24705917f, 0.43167469f, 0.11276868f, 0.07315372f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.18430756f, -0.22242889f, -0.06224215f, -0.03620843f, 0.02943697f, -0.10200707f, 0.07341390f, -0.11104476f, 
    -0.03967910f, -0.41874522f, 0.31559986f, -0.29976246f, -0.10176475f, -0.25057083f, 0.08197936f, 0.00282557f, 
    -0.07795063f, 0.10904755f, 0.04282144f, 0.02262227f, 0.23270860f, 0.12615015f, -0.06552120f, -0.01070613f, 
    -0.02448659f, 0.02445984f, -0.08398319f, 0.08667132f, -0.33628327f, 0.26933101f, -0.13172148f, -0.06212590f, 
    0.28580004f, 0.00109096f, -0.05719725f, 0.02165066f, -0.24081089f, 0.24002111f, 0.47543895f, -0.16938986f, 
    -0.03383508f, -0.39698642f, 0.05476543f, 0.04150427f, 0.06578958f, 0.02621302f, -0.06643177f, -0.13044032f, 
    0.08614680f, 0.04732617f, -0.05115670f, 0.16225627f, -0.04719585f, 0.03518629f, 0.00568371f, 0.36303523f, 
    0.23708883f, -0.03141465f, -0.02511794f, -0.17049597f, -0.10396744f, 0.17374299f, 0.05146070f, 0.09185806f, 
    0.18769614f, -0.32677940f, 0.13787879f, 0.04321433f, 0.09614838f, 0.23716983f, -0.11777883f, -0.03125997f, 
    -0.21974114f, 0.24281974f, -0.03818505f, -0.17173035f, 0.13878408f, -0.09752786f, 0.08873577f, 0.04265698f, 
    -0.04665882f, -0.40293995f, -0.27444199f, 0.07442383f, -0.09989204f, 0.19375333f, 0.06886584f, 0.11145435f, 
    0.02960442f, 0.09266725f, 0.44545376f, -0.26717287f, 0.15373448f, -0.03202191f, -0.11779028f, -0.01689230f, 
    0.12069889f, -0.01087639f, -0.07185471f, -0.29520744f, -0.07672856f, 0.11159173f, 0.02846647f, 0.10607725f, 
    -0.36948979f, 0.22498283f, -0.06796480f, -0.00663792f, 0.16209404f, 0.26312312f, 0.19705777f, -0.02134240f, 
    -0.02749065f, 0.00158986f, 0.01835855f, -0.20377281f, 0.14502931f, -0.33088267f, 0.02455949f, 0.13204454f, 
    -0.02431573f, 0.02938533f, -0.12765655f, 0.01249799f, -0.00975443f, 0.14140227f, -0.02387627f, -0.22840828f, 
    0.07247638f, 0.06264371f, 0.09884957f, 0.05803388f, -0.01170834f, -0.12907839f, 0.01420727f, 0.15636797f, 
    0.38174385f, -0.40363595f, -0.10500159f, -0.10875171f, 0.09317270f, -0.12171783f, -0.04227226f, -0.01323666f, 
    0.20436989f, -0.01095954f, -0.37054417f, 0.05782855f, -0.10166692f, 0.09888250f, -0.02705828f, -0.06393334f, 
    -0.14884776f, 0.12919657f, 0.23395070f, -0.05298751f, 0.11640888f, -0.07413017f, -0.21348479f, 0.08186039f, 
    -0.05478993f, 0.08613442f, 0.18058994f, -0.06434411f, -0.19261305f, 0.03181127f, -0.07784287f, 0.00435981f, 
    -0.06202692f, 0.00829018f, -0.02576582f, -0.13778347f, -0.19926342f, 0.09105185f, 0.12110850f, -0.00797054f, 
    0.11663172f, 0.18888369f, -0.01618326f, -0.14569344f, 0.16005920f, 0.14868817f, 0.00809244f, 0.00390985f, 
    0.01068840f, 0.08863726f, 0.02258768f, 0.04859807f, 0.09904906f, -0.04633430f, -0.29451346f, -0.34048408f, 
    -0.07913567f, 0.10168196f, 0.04450515f, 0.03843448f, 0.08268055f, -0.05088657f, -0.01076940f, 0.27337310f, 
    0.17975417f, -0.15077314f, -0.04397008f, -0.24934997f, 0.00997649f, 0.01971045f, 0.20487159f, 0.27865085f, 
    -0.05806866f, -0.18405306f, 0.05808802f, 0.02552182f, 0.09746603f, 0.13404764f, 0.13636783f, 0.02721990f, 
    -0.55846012f, 0.10010069f, 0.14427358f, -0.07757930f, 0.13120511f, 0.05804982f, 0.05264327f, -0.12922710f, 
    -0.03595533f, 0.06834372f, -0.10688159f, -0.29176852f, -0.02760275f, 0.01830517f, 0.15354620f, 0.13548173f, 
    0.03303549f, 0.05976126f, 0.25274256f, 0.26333582f, -0.16458230f, 0.02245271f, -0.00727606f, -0.09407730f, 
    0.06759161f, 0.06858345f, 0.15942864f, -0.06638075f, 0.01405689f, 0.04972531f, -0.21115385f, -0.24677692f, 
    -0.08586705f, 0.03016881f, 0.04267390f, 0.04893900f, -0.37014732f, -0.07175404f, 0.03910516f, 0.02027034f, 
    -0.37602869f, 0.00734259f, 0.00216132f, 0.15096539f, 0.10868633f, -0.39862373f, -0.00448346f, -0.00856909f, 
    0.06212194f, 0.07567445f, -0.06254987f, 0.07060408f, 0.01245556f, 0.10145197f, -0.38438040f, -0.26258713f, 
    0.24985787f, 0.13527200f, 0.04329745f, -0.02585920f, 0.12676050f, -0.19207752f, -0.07417408f, 0.03709357f, 
    -0.31512782f, -0.00867990f, 0.07788147f, 0.11719061f, 0.12078860f, 0.03569626f, -0.19190688f, 0.03197989f, 
    -0.10589436f, 0.11672984f, 0.10041769f, -0.03303258f, 0.04548693f, 0.10779772f, 0.00058694f, 0.19368982f, 
    0.08517651f, 0.22581688f, -0.05335924f, 0.02042387f, 0.04111420f, 0.19713308f, -0.15510273f, 0.06432539f, 
    0.09878463f, 0.17953929f, -0.33018309f, -0.03127841f, 0.35654959f, 0.03415490f, 0.04425261f, -0.00447343f, 
    -0.04221014f, 0.10340022f, -0.04689703f, 0.55213863f, 0.22457154f, -0.04779874f, 0.07955693f, -0.03741489f, 
    0.05403170f, -0.09058637f, 0.06362133f, 0.06267480f, -0.37326694f, -0.02569358f, 0.21964352f, -0.06082252f, 
    -0.08008853f, -0.15222144f, 0.04569729f, -0.03735821f, 0.28120139f, -0.18220289f, 0.32693645f, 0.06508777f, 
    -0.19551766f, 0.14927612f, 0.05550597f, 0.23129772f, 0.08523898f, 0.00548087f, -0.28081626f, -0.09019693f, 
    0.19799750f, 0.11227422f, 0.13259789f, -0.04051026f, 0.00723827f, -0.15223283f, 0.22646262f, -0.04747979f, 
    -0.15141939f, -0.20370771f, 0.25651875f, 0.23141319f, 0.07221163f, -0.01504813f, 0.13563348f, 0.11345961f, 
    -0.38359222f, -0.39575145f, 0.05984982f, -0.00903558f, 0.05695852f, 0.06005305f, -0.18133929f, 0.06424491f, 
    0.06960126f, -0.24316639f, -0.22675487f, -0.14398949f, -0.04894364f, -0.05328873f, -0.15180419f, -0.07605394f, 
    -0.06917454f, -0.10968410f, -0.24608009f, 0.06870863f, 0.09135984f, -0.17511977f, 0.05537475f, -0.14603941f, 
    -0.10346383f, 0.15808743f, -0.01120314f, 0.00515690f, 0.06467723f, -0.05020539f, 0.06402358f, -0.39978394f, 
    -0.11892937f, 0.10404482f, -0.05771977f, 0.17420821f, -0.13072161f, -0.31081995f, 0.14772727f, -0.45286646f, 
    0.19594131f, -0.28373194f, 0.04005766f, 0.02988461f, 0.13049461f, 0.24648571f, 0.03159964f, -0.14264171f, 
    -0.15843885f, -0.16568230f, -0.07314922f, 0.25770107f, 0.04828582f, 0.05572141f, -0.13379987f, -0.06796978f, 
    0.00243878f, -0.17368120f, -0.06936296f, -0.11616389f, 0.14894828f, -0.01370340f, 0.01409010f, -0.59289348f, 
    0.15808366f, 0.00064063f, -0.03247694f, 0.07495520f, -0.03997661f, 0.06185025f, -0.11477604f, 0.01775713f, 
    -0.04016482f, 0.03123376f, 0.22939911f, -0.03877607f, -0.02971849f, 0.03150198f, -0.01368646f, -0.13847901f, 
    0.26531863f, -0.22184521f, 0.09361488f, -0.20465457f, 0.18570565f, -0.06356453f, -0.09433383f, 0.02916076f, 
    0.09709740f, -0.16689822f, -0.28263214f, 0.04885263f, 0.26903504f, -0.03536626f, -0.07898074f, -0.05095316f, 
    0.13050616f, -0.05592290f, 0.05409110f, 0.02082454f, -0.49720412f, -0.16877460f, 0.01071273f, -0.19240834f, 
    0.19640796f, 0.19863981f, 0.12557359f, 0.14912538f, 0.12941375f, 0.36768410f, 0.40745664f, -0.04428003f, 
    0.11638556f, -0.02875549f, 0.07458512f, -0.06976765f, 0.15466586f, -0.03273595f, -0.00395128f, 0.15088221f, 
    0.03416048f, 0.09197202f, -0.05018020f, 0.08615018f, 0.05490004f, 0.22809868f, -0.18783459f, 0.25912535f, 
    0.17621230f, -0.28808701f, 0.11843339f, -0.09419771f, -0.00489526f, -0.27037835f, 0.15812750f, 0.01884857f, 
    0.18054081f, -0.22515275f, -0.01177817f, -0.05532044f, 0.10930493f, -0.06917732f, 0.15889743f, -0.07246912f, 
    -0.04997226f, -0.37832958f, -0.12925497f, 0.13101965f, 0.11084473f, -0.22066814f, 0.02248460f, 0.02899254f, 
    -0.07308184f, 0.07721819f, 0.32405260f, 0.13689810f, -0.08790413f, 0.06200668f, -0.03625708f, 0.07066655f, 
    -0.06498281f, -0.21189956f, 0.01068820f, 0.04311392f, 0.50412965f, 0.16785210f, -0.01693065f, 0.04905093f, 
    -0.03746348f, -0.05212688f, -0.02446237f, -0.12806326f, -0.18215060f, -0.12736964f, 0.05544190f, -0.11590479f, 
    0.00226461f, 0.20233734f, 0.01641953f, 0.21006595f, -0.06475379f, 0.04816444f, -0.11274079f, -0.00999780f, 
    -0.18561015f, -0.01466050f, 0.14743379f, -0.00690150f, -0.10006677f, -0.05654735f, -0.09044538f, -0.61651278f, 
    0.17107399f, 0.04415856f, -0.02506592f, 0.15839489f, 0.15076491f, 0.07107265f, -0.20151538f, -0.19954631f, 
    -0.06040228f, -0.01442181f, -0.04663475f, -0.19847825f, 0.18165211f, 0.11246222f, 0.11463731f, -0.08023316f, 
    0.09496418f, -0.10927030f, -0.15102065f, -0.07012201f, 0.10582161f, 0.04395258f, -0.08209385f, 0.14996961f, 
    0.06438728f, 0.05912587f, 0.00522607f, 0.03769434f, 0.05935242f, 0.02456179f, 0.03164755f, 0.05454708f, 
    -0.01347368f, -0.04285565f, -0.07576262f, -0.00283232f, -0.03308276f, 0.04893370f, 0.03182549f, -0.05171374f, 
    -0.02797574f, 0.03035907f, 0.03376162f, -0.06081492f, -0.09123264f, -0.08670060f, 0.02406269f, -0.08215481f, 
    -0.01967749f, -0.02380066f, -0.04225671f, 0.04758051f, -0.04098187f, 0.04156201f, -0.05107670f, -0.00961511f, 
    -0.03477416f, 0.03431822f, 0.02210579f, 0.05318807f, -0.04578509f, 0.00042854f, -0.00058705f, 0.01322726f, 
    0.05730017f, -0.00392746f, 0.03096759f, -0.10229594f, 0.01028934f, -0.08608338f, 0.01603618f, -0.02954960f, 
    -0.01882212f, -0.07856359f, -0.07365721f, -0.04737097f, -0.04770960f, -0.06751072f, 0.02681459f, -0.04380586f, 
    0.02164673f, -0.08781711f, -0.03507418f, -0.03350246f, -0.01659434f, 0.02980266f, 0.04864306f, -0.05269252f, 
    0.03462517f, -0.03222426f, 0.04263649f, -0.02208409f, -0.00745536f, -0.05706543f, -0.05127190f, 0.01798286f, 
    0.03438925f, -0.09017910f, -0.00016887f, -0.06388865f, -0.04198303f, -0.07306909f, -0.05637347f, 0.03916468f, 
    -0.08109816f, -0.05285707f, 0.05813381f, -0.03557276f, 0.03494788f, 0.03241870f, -0.09783608f, 0.03108005f, 
    -0.05719926f, -0.01198815f, -0.00084026f, 0.00674888f, -0.01939702f, 0.05088694f, -0.05179408f, -0.05623749f, 
    -0.02872901f, 0.01183784f, 0.00546973f, 0.03902567f, -0.04327274f, -0.02619779f, 0.03157569f, -0.03465498f, 
    -0.07264839f, -0.08003694f, -0.00729970f, -0.04091524f, 0.02159879f, 0.02751352f, -0.08578065f, -0.03564499f, 
    -0.01084326f, 0.05289653f, -0.07011163f, -0.02339235f, 0.07468630f, -0.01699050f, 0.02117782f, -0.04435371f, 
    -0.02270545f, -0.06040767f, 0.03979607f, -0.06313729f, -0.06937239f, -0.04149602f, 0.06612822f, 0.05530160f, 
    -0.03445762f, -0.02141169f, -0.03516823f, 0.04674637f, -0.04319519f, 0.04013986f, 0.01839173f, -0.02147445f, 
    -0.06780034f, -0.09681138f, -0.08812018f, -0.02648281f, 0.00606108f, -0.00627757f, 0.05089794f, -0.07516075f, 
    0.09645300f, 0.15553974f, 0.44221619f, -0.09879824f, -0.10389841f, -0.03236923f, 0.01623902f, 0.01480506f, 
    -0.00148190f, -0.29748660f, -0.33565104f, -0.13827281f, -0.08093939f, 0.10871702f, 0.01969833f, 0.01597174f, 
    0.01516946f, 0.29579523f, 0.06239316f, -0.25465679f, 0.23537788f, -0.17240638f, -0.28387222f, -0.14008540f, 
    -0.01405988f, -0.09282696f, -0.07729714f, -0.21542457f, 0.31529328f, -0.04362071f, -0.27396265f, 0.17824233f, 
    0.02800298f, -0.08250012f, 0.03459027f, 0.02987131f, -0.23991454f, -0.55797708f, -0.26213744f, -0.08760209f, 
    -0.14212738f, -0.16715060f, 0.09369089f, 0.04390204f, 0.01941507f, -0.00021175f, 0.37087464f, 0.28798571f, 
    0.08981429f, -0.17748043f, 0.09360167f, 0.07782782f, 0.01543142f, 0.19115035f, -0.12775363f, -0.19149692f, 
    -0.39915216f, 0.10840181f, -0.14923288f, -0.13524681f, 0.05184903f, 0.00915363f, -0.08009630f, -0.15276952f, 
    0.01497587f, -0.29600793f, -0.03464304f, 0.00655340f, 0.08470493f, 0.21059796f, -0.05620189f, 0.24544539f, 
    -0.27638504f, -0.20276509f, 0.13611448f, 0.19755547f, 0.01845260f, -0.02429907f, 0.09149528f, 0.07144810f, 
    -0.06727762f, -0.15903050f, 0.04149150f, -0.31814829f, -0.18236338f, 0.15960135f, -0.06932699f, 0.06885894f, 
    0.09953471f, -0.04365417f, 0.02836742f, -0.08241593f, -0.17868604f, -0.09267756f, 0.06970786f, -0.09775666f, 
    -0.02689558f, -0.01894549f, -0.00108000f, -0.26745063f, -0.14565802f, 0.13722742f, 0.10714676f, -0.23419960f, 
    0.17274712f, 0.18214764f, -0.10860433f, -0.00414434f, -0.23286092f, -0.09134904f, -0.17030069f, 0.07153738f, 
    -0.25120533f, -0.03852652f, 0.09533189f, -0.07152936f, 0.00672801f, 0.02406559f, 0.02090437f, -0.19821022f, 
    0.12951733f, 0.15242943f, 0.18406518f, 0.33780167f, 0.09809726f, 0.17488348f, 0.02173547f, 0.07947817f, 
    -0.09055969f, -0.00973726f, -0.05545476f, -0.01847464f, -0.07819037f, -0.01746888f, 0.00943241f, -0.16557680f, 
    0.08717374f, 0.31262803f, -0.16440077f, -0.01309825f, 0.00318854f, 0.00528327f, -0.02490725f, 0.11408623f, 
    -0.32833475f, -0.05965099f, 0.06271427f, 0.02392793f, 0.06107511f, 0.00776328f, 0.15154086f, -0.21713142f, 
    -0.27090326f, 0.12710716f, -0.27207714f, 0.32784784f, -0.18934983f, 0.10880897f, -0.04070944f, 0.06264632f, 
    -0.10874427f, 0.02386491f, -0.24656349f, 0.10733432f, 0.03887198f, -0.10046266f, -0.04074473f, -0.05253327f, 
    0.11611590f, 0.16184254f, 0.15177046f, 0.35987154f, -0.54788983f, -0.52933782f, 0.17581268f, 0.02370066f, 
    0.06354015f, 0.06043482f, -0.17837937f, -0.15856312f, 0.00083529f, 0.26928177f, 0.10012741f, -0.08724035f, 
    0.16894978f, 0.04385712f, 0.14144601f, -0.08746418f, -0.11034098f, 0.30391386f, -0.00964764f, -0.03774285f, 
    -0.09967717f, -0.03991914f, 0.05599457f, 0.13607869f, 0.10117157f, 0.07148921f, 0.07599922f, 0.61771333f, 
    0.34664884f, 0.07398760f, 0.01960007f, 0.06138462f, -0.03937628f, 0.08388308f, -0.19744918f, 0.04140255f, 
    0.07672997f, 0.24329285f, -0.06407663f, -0.13755949f, 0.03349673f, 0.14602582f, -0.08015727f, 0.25616276f, 
    0.04096589f, -0.24237733f, -0.30239841f, 0.15658110f, 0.06040914f, -0.02173072f, -0.11486386f, 0.21406960f, 
    -0.03853795f, -0.00290451f, -0.13365270f, -0.11414760f, -0.21828857f, 0.01028404f, -0.01426057f, -0.05410585f, 
    0.21726246f, 0.27153665f, -0.14553951f, 0.14841522f, 0.35874400f, -0.16465577f, -0.00652860f, -0.07591933f, 
    0.02263828f, 0.06446674f, 0.02188649f, 0.00097332f, -0.14053579f, -0.02286329f, -0.11156598f, -0.07470983f, 
    -0.10963438f, -0.20101218f, -0.00664630f, -0.06369559f, 0.00444748f, 0.35564592f, -0.01777535f, -0.25635177f, 
    0.08989283f, -0.07454905f, 0.26774716f, 0.18958014f, 0.05681944f, -0.15888666f, -0.08598783f, 0.09286854f, 
    0.12347891f, 0.02377884f, 0.02816692f, -0.08933204f, -0.03861436f, 0.01271257f, 0.03568008f, -0.23393665f, 
    0.19817087f, -0.12542464f, -0.02015115f, -0.13699673f, 0.22167252f, -0.15857832f, -0.25907791f, -0.22198135f, 
    0.13103868f, 0.20540756f, -0.22091299f, -0.04365284f, -0.07170375f, 0.00607439f, -0.01871993f, -0.18020365f, 
    0.39816079f, 0.15552460f, 0.24862318f, -0.00514631f, -0.01563493f, 0.04527282f, -0.08814164f, 0.10045306f, 
    -0.10142787f, -0.15549976f, 0.26399240f, 0.11329062f, -0.03774391f, 0.21442813f, -0.07297977f, 0.12956133f, 
    0.09596013f, -0.01261630f, 0.48266515f, 0.07503667f, 0.22157265f, -0.09891684f, 0.04896379f, 0.18591855f, 
    0.08334574f, -0.05138285f, -0.09086439f, 0.35914126f, 0.11929552f, -0.28334990f, 0.15492196f, 0.03598220f, 
    -0.11038584f, 0.12387156f, 0.10352682f, -0.02634601f, 0.09635421f, 0.21951230f, 0.09537936f, -0.01108950f, 
    -0.13487922f, -0.14668553f, -0.07017388f, -0.11591668f, -0.00659000f, -0.14992459f, 0.14493944f, -0.38974461f, 
    0.13621581f, 0.05631529f, 0.05422049f, -0.03355254f, -0.00418756f, 0.12007020f, -0.08735898f, -0.24506034f, 
    0.12394498f, -0.11036596f, 0.06619908f, -0.00589789f, -0.08415905f, -0.02925883f, 0.03316035f, -0.25546041f, 
    -0.09515536f, 0.02277305f, -0.02379368f, -0.02091345f, 0.03800079f, -0.05697811f, 0.25338760f, 0.05271298f, 
    -0.25484192f, -0.13652444f, -0.13217326f, -0.10350547f, -0.10404789f, 0.01452960f, 0.04475189f, 0.10554041f, 
    0.11284139f, 0.22414552f, 0.01889336f, 0.19158904f, -0.14188218f, -0.00606026f, -0.27879336f, 0.00550202f, 
    -0.01225148f, 0.03610695f, 0.23586439f, 0.23124456f, 0.26472965f, -0.04262143f, -0.08662479f, 0.16489528f, 
    -0.02736761f, 0.09753879f, 0.09785884f, -0.19355254f, 0.02309834f, 0.02341941f, -0.04868342f, -0.08752262f, 
    -0.14501573f, 0.00910889f, 0.13603359f, -0.02021709f, -0.20368035f, -0.48019710f, -0.18664400f, -0.08023479f, 
    -0.05106394f, -0.05898556f, -0.04563254f, 0.16050468f, -0.01221045f, -0.37353903f, -0.01225958f, -0.07460569f, 
    -0.03399459f, 0.14744435f, 0.15989852f, -0.10121397f, 0.08538017f, 0.15688242f, 0.47032768f, -0.13224854f, 
    0.06510033f, 0.07598619f, 0.07597744f, -0.09020077f, 0.03884941f, -0.00304818f, -0.08260830f, -0.08605839f, 
    -0.26894823f, 0.07679860f, -0.00458749f, -0.01056558f, 0.09723962f, 0.05472513f, 0.14171207f, -0.01220326f, 
    -0.01454272f, 0.01848642f, -0.05600692f, -0.02367197f, -0.05164361f, -0.00806906f, 0.06720158f, -0.03510579f, 
    0.00110979f, -0.11386161f, 0.00182674f, 0.03955744f, -0.06504550f, -0.07265995f, 0.02707325f, -0.00039265f, 
    0.05573240f, 0.00238563f, -0.09853972f, -0.08702867f, 0.04933623f, 0.06282215f, -0.06673224f, -0.02853199f, 
    0.03518324f, 0.06053588f, -0.03470094f, -0.03916281f, -0.03910133f, 0.08002831f, -0.05846781f, 0.02860793f, 
    0.06600435f, 0.04045744f, 0.03736608f, -0.02388042f, 0.01524538f, -0.01235524f, -0.04985243f, -0.07383901f, 
    0.02947355f, 0.00259571f, -0.03873985f, -0.05970578f, 0.05207391f, 0.00388834f, 0.05431611f, -0.00144382f, 
    -0.04055390f, -0.06051832f, -0.08730178f, -0.07710488f, -0.10486474f, -0.06166906f, -0.08803075f, -0.05272127f, 
    0.04038738f, 0.02489188f, -0.05589065f, 0.03510625f, -0.04826303f, -0.11568791f, -0.10401620f, -0.06196520f, 
    -0.01822015f, -0.01222639f, -0.10374483f, -0.00722779f, 0.03211752f, -0.05333782f, 0.02142681f, 0.03665627f, 
    -0.05933046f, 0.02677781f, -0.03644659f, -0.00153695f, -0.03445652f, -0.02135089f, 0.03805702f, 0.02517745f, 
    -0.09262395f, -0.06513080f, -0.02746609f, -0.07069725f, -0.01616745f, -0.06145350f, -0.05640270f, -0.06228064f, 
    -0.05878674f, 0.04087291f, -0.05983257f, -0.08467695f, 0.01624719f, -0.07188229f, -0.05800604f, -0.04212000f, 
    0.01191415f, -0.03795465f, -0.03228133f, -0.02984237f, -0.08500370f, 0.06328359f, -0.04775565f, -0.06407240f, 
    0.03331383f, -0.08022063f, 0.04441456f, 0.06217627f, -0.06172622f, -0.01055166f, 0.04638114f, -0.04523154f, 
    0.00649320f, 0.02222114f, -0.06665524f, -0.05861722f, 0.03327127f, -0.05012384f, -0.05100912f, -0.05195837f, 
    -0.06672808f, -0.02879656f, 0.01757840f, -0.02095628f, 0.01374058f, -0.03487495f, -0.07471360f, -0.08060006f, 
    -0.03147598f, -0.09160079f, -0.06103602f, -0.10480732f, -0.07753844f, 0.00622797f, -0.02889374f, -0.07778258f, 
    0.00525769f, -0.03605264f, -0.06016697f, -0.06504993f, -0.07599951f, -0.06248406f, 0.00805548f, -0.09520627f, 
    0.08714187f, -0.46671543f, -0.05192986f, -0.15832265f, -0.07411429f, 0.23790558f, 0.03533186f, -0.15015887f, 
    0.06023385f, -0.04191096f, -0.29082766f, -0.00222670f, -0.10549397f, 0.03392430f, 0.11676269f, 0.03294609f, 
    0.12987901f, 0.00360860f, -0.02605038f, -0.46165788f, -0.42732948f, -0.10628028f, 0.18689436f, -0.25786823f, 
    -0.16206540f, -0.02525261f, 0.05467552f, -0.15894945f, 0.08449771f, -0.08122738f, -0.05994494f, 0.16157283f, 
    0.03295105f, 0.15128426f, 0.04196826f, 0.09642567f, -0.35223442f, -0.12270506f, 0.10789773f, 0.02243216f, 
    0.09474879f, -0.15032974f, 0.08098641f, -0.03655210f, -0.07913141f, -0.28546885f, -0.02051820f, -0.03690885f, 
    0.09583782f, 0.10526838f, 0.11560091f, -0.00780803f, 0.12298415f, -0.11964364f, -0.49937299f, -0.01290394f, 
    -0.27655998f, 0.07849938f, 0.10764540f, -0.16845657f, 0.27005163f, -0.08959974f, 0.05999904f, -0.30119759f, 
    -0.14969911f, -0.15045306f, 0.12548433f, 0.18747394f, 0.09286544f, 0.12077867f, 0.10382523f, 0.12409539f, 
    0.43483943f, 0.14716171f, 0.12172847f, 0.15613607f, -0.03849429f, 0.03671859f, 0.11567356f, 0.23971242f, 
    0.07375163f, -0.39986366f, -0.19494575f, -0.24255311f, -0.13582356f, -0.13258882f, -0.10126159f, -0.09232739f, 
    0.14308907f, 0.09597613f, -0.40817934f, -0.30859748f, 0.06341642f, -0.12552761f, 0.00112737f, -0.15639785f, 
    -0.07414141f, -0.22643015f, 0.00102467f, -0.07707471f, -0.03990328f, 0.21438117f, -0.20816547f, -0.01733598f, 
    -0.08823105f, 0.05173045f, 0.01617114f, -0.19057345f, -0.03307099f, 0.13347599f, -0.02342996f, -0.22078258f, 
    -0.17470421f, -0.13485684f, 0.04476547f, 0.08757725f, -0.19728258f, 0.48781320f, 0.17468619f, 0.17184271f, 
    -0.05789913f, 0.10628852f, -0.11704907f, 0.09927962f, 0.07396955f, 0.00582010f, -0.03112092f, 0.36590394f, 
    0.15408929f, -0.03307309f, -0.06427816f, 0.01660790f, -0.12052963f, -0.07341857f, 0.17326170f, -0.55601758f, 
    -0.22278430f, -0.23559596f, 0.18404174f, 0.05244409f, 0.10522068f, -0.09464628f, -0.24846046f, -0.04366019f, 
    -0.03939785f, -0.00200539f, 0.00569256f, -0.04751940f, 0.02681693f, -0.06480137f, 0.02351391f, -0.07650647f, 
    -0.08070347f, -0.02983029f, -0.06477599f, 0.03308180f, -0.07061569f, 0.02367744f, -0.05553548f, 0.02830319f, 
    -0.04908634f, 0.06375267f, -0.06698427f, -0.07501324f, -0.05912337f, -0.03376058f, -0.03593136f, -0.03598025f, 
    -0.06973311f, -0.02813912f, -0.05266739f, -0.00614294f, -0.05580404f, -0.08550630f, 0.04733616f, 0.00310611f, 
    0.02280864f, -0.06714771f, 0.04147720f, -0.01978450f, 0.07003817f, 0.07027445f, -0.02641544f, 0.02553079f, 
    -0.01858022f, 0.06099564f, -0.01944591f, -0.07846376f, -0.07279739f, -0.02307872f, -0.03417605f, -0.06512456f, 
    0.02181693f, -0.04615163f, -0.01038862f, -0.07427263f, 0.03887835f, 0.02534570f, -0.00767472f, 0.04798098f, 
    0.03876153f, -0.02817776f, -0.05354528f, 0.02068522f, -0.04533420f, -0.04402995f, 0.05290117f, 0.01220638f, 
    0.02228959f, 0.07426471f, -0.04116350f, -0.06384791f, 0.02718424f, -0.04456060f, 0.03294456f, 0.03146605f, 
    -0.07963329f, 0.01918663f, -0.02690194f, -0.08628479f, 0.07289060f, 0.05698051f, -0.08578758f, 0.03617644f, 
    0.00391619f, -0.07605749f, 0.01615568f, -0.04341307f, -0.04029995f, -0.04059955f, 0.03908480f, -0.01227015f, 
    0.00131697f, -0.01901934f, -0.04583709f, 0.05972629f, -0.07132041f, -0.04450895f, -0.02622777f, -0.07424177f, 
    -0.01393000f, -0.00771645f, 0.03750534f, 0.02198179f, -0.01007082f, -0.06043711f, -0.05813764f, 0.05718115f, 
    -0.08408876f, -0.09528074f, -0.03646205f, -0.06680719f, -0.00000852f, -0.08247181f, -0.06871784f, -0.08405466f, 
    0.03545193f, 0.04947961f, -0.05239203f, 0.01136493f, 0.04378376f, 0.05592906f, -0.07245402f, -0.09083212f, 
    0.02232586f, -0.05222824f, -0.07309046f, -0.04428461f, -0.04816411f, 0.04764508f, -0.03671806f, -0.06205605f, 
    0.03389642f, -0.00306759f, 0.04076662f, 0.03032156f, -0.02543602f, -0.00452020f, 0.03015782f, -0.05243536f, 
    0.04308560f, -0.00188402f, 0.05970645f, -0.07896889f, 0.05927066f, -0.00587860f, -0.05717798f, 0.06761301f, 
    -0.06408217f, -0.00510421f, 0.00782232f, -0.03970867f, 0.05579110f, -0.01257502f, -0.01936615f, 0.02263218f, 
    0.04440787f, 0.00903790f, -0.08216991f, -0.09618393f, 0.04629985f, -0.00760432f, 0.03591365f, 0.06610092f, 
    -0.07094457f, -0.00725112f, -0.04266338f, 0.01208894f, 0.03315905f, 0.00690762f, 0.01749727f, 0.03668283f, 
    -0.08446536f, 0.02545054f, -0.05643810f, -0.00195818f, -0.06132480f, 0.02561938f, 0.05484892f, 0.04118596f, 
    -0.04503638f, -0.06021250f, -0.02716185f, -0.01519470f, -0.03198554f, -0.03350610f, -0.03750228f, 0.00267920f, 
    -0.01694077f, 0.02227756f, 0.00157451f, -0.03924626f, -0.02044955f, -0.01666688f, 0.02786995f, -0.01527941f, 
    -0.08120296f, -0.07541705f, 0.06275184f, 0.01033764f, 0.03127049f, -0.02261642f, 0.06663335f, -0.05033855f, 
    0.06765553f, 0.03166331f, -0.01718028f, -0.05030690f, 0.05700488f, 0.04921307f, -0.04873898f, -0.06792177f, 
    -0.04177481f, -0.01777571f, -0.02039518f, 0.01164570f, -0.08737456f, 0.00334574f, 0.02217680f, -0.06418995f, 
    0.04973983f, -0.03391617f, 0.06620755f, 0.06477074f, -0.06123284f, -0.06436732f, -0.05423865f, 0.00460418f, 
    0.04462511f, 0.06636115f, 0.00696683f, 0.02770189f, 0.01784034f, 0.00484352f, -0.00011577f, -0.08441738f, 
    -0.05926491f, 0.04654958f, 0.02360974f, -0.07797405f, -0.05030664f, 0.04377020f, -0.03789404f, 0.01079011f, 
    -0.06710919f, -0.06359040f, -0.05768036f, 0.01216370f, -0.05632457f, 0.07042602f, -0.01857535f, -0.03844566f, 
    -0.01327023f, 0.05739211f, 0.01439017f, 0.01211924f, 0.05423772f, -0.00830327f, 0.00028629f, -0.03969385f, 
    0.06308121f, -0.07458831f, -0.05500814f, 0.07103126f, 0.06531623f, -0.04358085f, 0.01120368f, -0.03891820f, 
    -0.02829408f, 0.05223868f, -0.03229814f, -0.00950124f, 0.03616482f, -0.08009773f, -0.08632015f, -0.01747568f, 
    -0.05300109f, -0.07228883f, -0.04900242f, -0.01821089f, -0.06230981f, -0.08894690f, -0.09025163f, -0.07612707f, 
    -0.01764508f, 0.02997001f, -0.00592011f, 0.05844412f, 0.04119129f, 0.03670946f, 0.01169384f, 0.06948595f, 
    -0.16067055f, 0.05581266f, -0.11169052f, -0.07229265f, -0.03552642f, 0.17981794f, -0.00054741f, 0.13467005f, 
    0.28002399f, -0.09694187f, -0.09433773f, 0.08060937f, -0.02735003f, 0.23853891f, 0.06372370f, 0.11251099f, 
    0.09675852f, -0.01217673f, 0.25104135f, 0.04472484f, 0.01893792f, 0.00571255f, 0.02450255f, 0.09320070f, 
    -0.05579644f, 0.05533791f, 0.16022825f, -0.37099186f, 0.23592426f, 0.38707548f, -0.06395686f, 0.13778535f, 
    0.18851924f, 0.08451302f, 0.17247377f, -0.01492761f, 0.22163047f, 0.25023609f, 0.32054558f, 0.17725356f, 
    0.05315188f, -0.02673550f, -0.02232496f, 0.09607304f, -0.06440205f, -0.14018042f, -0.16945142f, 0.09930491f, 
    0.04772873f, 0.09602946f, 0.10036281f, -0.08062787f, -0.03209050f, -0.02267022f, -0.08704715f, 0.06692355f, 
    -0.22581065f, 0.01527240f, 0.06559530f, 0.05013526f, 0.01247416f, 0.07886369f, 0.06336203f, 0.06223791f, 
    0.02430177f, -0.17219588f, 0.06978828f, 0.05266095f, -0.21494697f, -0.15955082f, -0.01680056f, -0.26120633f, 
    0.36971027f, 0.28290713f, 0.31143597f, 0.05173750f, 0.11969028f, -0.17603864f, -0.12132502f, -0.02799894f, 
    0.11082092f, -0.14578995f, -0.26463252f, -0.06908420f, 0.13615625f, 0.19199170f, -0.15905227f, -0.17011656f, 
    -0.01239954f, -0.36223766f, 0.14388022f, -0.03694542f, -0.12970637f, 0.31566846f, 0.17941423f, 0.01007243f, 
    -0.03743589f, 0.14686377f, 0.10556109f, 0.10918175f, -0.05248651f, -0.16752407f, 0.15680882f, 0.25936097f, 
    0.05801494f, 0.26715383f, 0.04432242f, -0.38695508f, -0.02117872f, 0.23961750f, -0.36977881f, -0.02182067f, 
    0.02811516f, 0.23274042f, -0.24055564f, 0.22662783f, -0.19075896f, 0.08654087f, 0.32757673f, -0.12590821f, 
    -0.07844492f, -0.01490591f, -0.32230085f, 0.05785511f, 0.00649225f, 0.06236468f, -0.28653839f, 0.06180320f, 
    0.00372033f, -0.04420575f, -0.00239297f, 0.06687986f, 0.05215174f, 0.12462233f, 0.02993161f, 0.05906414f, 
    -0.34503195f, 0.12004933f, -0.17019016f, 0.13880490f, 0.26668814f, -0.09682313f, 0.00530787f, 0.02585406f, 
    0.00116734f, 0.11114690f, -0.01616067f, 0.12410619f, 0.21965514f, 0.03629655f, -0.03041211f, -0.15103768f, 
    0.01695101f, 0.10759187f, -0.10770369f, 0.37196764f, 0.03563218f, -0.02455336f, -0.01074995f, 0.07600380f, 
    0.04737904f, 0.09077230f, -0.27575254f, 0.09629942f, 0.22360595f, -0.05298343f, 0.01433049f, -0.15232070f, 
    0.02619106f, -0.09454948f, -0.13308433f, 0.01092970f, 0.09994102f, 0.23789747f, 0.00087173f, 0.02300675f, 
    0.11056387f, -0.09801893f, -0.00989781f, 0.01687080f, -0.60508746f, -0.12928683f, 0.04863137f, 0.07562952f, 
    0.06124752f, 0.05651653f, 0.11343205f, 0.01789594f, -0.17955576f, 0.01728326f, 0.17013986f, 0.12590422f, 
    -0.00063763f, -0.01182474f, -0.02251375f, -0.15513632f, -0.22583389f, 0.12760490f, -0.03316363f, 0.13120273f, 
    -0.10712628f, -0.04918545f, 0.21095876f, 0.08253217f, 0.16035910f, 0.13435146f, 0.22146682f, 0.09663841f, 
    0.23103160f, 0.25959730f, -0.05053017f, -0.09428308f, -0.16334133f, 0.17728104f, 0.21455142f, 0.01942763f, 
    0.01844129f, 0.05637379f, 0.10800415f, 0.02648837f, 0.11879885f, -0.17755483f, -0.18579224f, -0.05856799f, 
    0.18030924f, -0.32326201f, -0.16751651f, 0.01710538f, -0.00863792f, 0.18939151f, -0.09204519f, 0.23588793f, 
    0.10778855f, 0.12690723f, -0.10549451f, -0.13264480f, -0.20259273f, 0.03649255f, 0.10276880f, -0.14279437f, 
    0.06046614f, 0.04962383f, 0.06228593f, -0.02169845f, 0.05487166f, -0.21131466f, -0.02602382f, -0.16518317f, 
    0.21977103f, -0.03137003f, 0.17216420f, 0.16379830f, 0.10292367f, -0.25317216f, -0.04506204f, 0.14246528f, 
    -0.03961389f, -0.08164050f, -0.05470211f, 0.29671153f, 0.15441683f, 0.03501834f, 0.11310759f, -0.11680818f, 
    -0.12688938f, 0.09150089f, 0.07684813f, 0.02917106f, 0.11426508f, 0.15097117f, -0.31076899f, -0.25552905f, 
    -0.24622037f, -0.18970066f, -0.13909602f, 0.13391769f, 0.19239868f, -0.19796668f, 0.01829513f, 0.33071238f, 
    -0.03889395f, 0.20394389f, 0.04136118f, 0.13705155f, 0.01433014f, -0.06239745f, 0.00153627f, 0.06324680f, 
    -0.34059229f, -0.23258242f, -0.23826239f, -0.06592634f, -0.26970497f, 0.22761750f, 0.01181413f, -0.02896792f, 
    -0.07733539f, 0.08069143f, -0.13467447f, -0.08119534f, -0.08035978f, 0.18381992f, 0.05975997f, -0.09619962f, 
    -0.05926145f, -0.00046774f, -0.25196427f, -0.13425423f, -0.74039477f, 0.15661655f, -0.17197104f, 0.08784904f, 
    0.07936419f, -0.07376955f, 0.04582103f, 0.09831069f, 0.03640379f, 0.25570375f, -0.06173673f, 0.21664010f, 
    -0.15275376f, 0.07451931f, 0.16434808f, 0.02037926f, 0.10697177f, 0.09517082f, -0.00165173f, -0.04208254f, 
    0.01590406f, -0.23116837f, 0.06538229f, 0.07224359f, -0.08771638f, 0.07575021f, -0.13548559f, -0.11484226f, 
    -0.14775267f, -0.14357293f, -0.00496498f, 0.02026140f, -0.00886181f, 0.03215334f, -0.17354795f, 0.23584278f, 
    -0.43450406f, -0.03545206f, -0.14340201f, 0.18065143f, 0.27839494f, 0.14076148f, 0.24688035f, -0.13923146f, 
    -0.13623625f, 0.06946287f, -0.05593600f, 0.04269548f, 0.01707276f, -0.06742100f, -0.01384791f, -0.01043714f, 
    0.11950690f, -0.18026061f, 0.23966545f, 0.06104998f, 0.10608412f, 0.04371390f, 0.03298418f, 0.02149404f, 
    0.12208474f, -0.20182317f, 0.14122662f, 0.33037770f, 0.07084756f, 0.10230435f, 0.23229021f, 0.00031371f, 
    0.01684101f, 0.18417187f, -0.05869043f, 0.22704186f, -0.27934158f, -0.07774589f, -0.00072011f, 0.06305763f, 
    0.09088368f, 0.03829706f, 0.02754669f, -0.00803138f, 0.27710098f, -0.07557969f, 0.14841823f, 0.00862099f, 
    -0.15887263f, -0.01154738f, 0.07361754f, -0.01423047f, 0.21973810f, 0.33818191f, -0.12856251f, -0.06028302f, 
    0.00853263f, 0.07790830f, 0.07213866f, -0.10632013f, -0.09464465f, 0.07991776f, -0.12030386f, 0.28432745f, 
    0.08600904f, -0.03090541f, 0.01872769f, -0.01703531f, 0.11378583f, 0.10615119f, 0.27502528f, 0.25226438f, 
    0.07330200f, -0.03510531f, -0.06420077f, -0.12880272f, 0.09351162f, -0.02843643f, 0.01033766f, 0.14455405f, 
    0.11398407f, -0.23219721f, -0.20875849f, -0.12016997f, 0.10292850f, 0.08317063f, -0.02362839f, -0.02479804f, 
    -0.35508570f, -0.00120019f, -0.06413118f, 0.01594896f, -0.09705406f, -0.01814027f, -0.12364331f, -0.19605051f, 
    -0.24694492f, 0.16880596f, 0.07219613f, 0.06709661f, 0.07153305f, 0.23024535f, 0.04605170f, -0.05484118f, 
    0.09653888f, 0.02795315f, -0.03851902f, -0.16411078f, 0.13757698f, -0.11263894f, -0.04415650f, -0.13301829f, 
    -0.10945702f, -0.19870098f, 0.05237724f, -0.00265465f, 0.32234907f, 0.07771485f, 0.00218774f, 0.05533060f, 
    0.08546571f, -0.08053523f, -0.00925904f, -0.08192421f, 0.06903457f, 0.05233023f, -0.19088237f, 0.08837196f, 
    0.13202782f, 0.13903835f, 0.06346025f, 0.06482068f, -0.02223018f, 0.04008491f, 0.05977393f, 0.02020492f, 
    0.16967233f, -0.08967745f, -0.03252774f, 0.18244413f, -0.13504027f, 0.05152538f, 0.03034160f, 0.09218085f, 
    0.11768574f, -0.23516223f, -0.12964141f, -0.41613632f, 0.20154193f, -0.15005027f, 0.10378984f, -0.11984443f, 
    0.02696691f, 0.09101769f, -0.00951993f, 0.13522658f, -0.06852349f, 0.26142061f, 0.11018965f, 0.22634742f, 
    0.11456583f, -0.11851846f, 0.15414123f, 0.29530999f, 0.12138683f, 0.14794928f, 0.12107453f, 0.05454434f, 
    0.12600832f, -0.09557240f, -0.19353610f, -0.33927232f, 0.07096639f, 0.01268862f, 0.02625050f, 0.21898472f, 
    0.01736045f, 0.31655288f, -0.05312012f, 0.19248486f, -0.03886742f, -0.23837030f, 0.05084195f, -0.02185423f, 
    0.05995794f, 0.14124782f, -0.19367597f, -0.19069166f, -0.10172006f, 0.21607356f, 0.15287721f, 0.02902780f, 
    -0.04944744f, 0.30121577f, -0.01229808f, 0.07828590f, -0.00039484f, -0.16740760f, 0.01817436f, 0.24892165f, 
    0.08315495f, 0.15695827f, -0.15331049f, -0.07804349f, 0.17967950f, 0.17166330f, 0.08234386f, 0.21245790f, 
    0.10862345f, 0.00976857f, 0.10107722f, -0.07471820f, 0.08451752f, 0.11750703f, -0.15222494f, -0.04212805f, 
    0.04909407f, -0.01718946f, 0.08840717f, 0.02000385f, -0.10323124f, -0.01839945f, -0.21987671f, -0.19429052f, 
    0.05792793f, -0.00423310f, 0.08852858f, -0.16292107f, -0.00345384f, -0.19277029f, -0.17229345f, 0.09002063f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.01910593f, 0.12286201f, 0.23300403f, 0.21435720f, -0.07392503f, 0.40502447f, 0.16231519f, -0.03867263f, 
    -0.04122759f, 0.23026171f, -0.02023964f, -0.08208296f, 0.01939404f, 0.14541261f, -0.00549813f, 0.12051042f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.55573589f, 0.16084559f, 0.32068601f, 0.34816027f, -0.17092757f, -0.14103706f, -0.08944391f, 0.22565651f, 
    -0.17890939f, -0.02240819f, -0.23218220f, 0.20428832f, -0.24481486f, 0.09963110f, 0.09370686f, 0.00575815f, 
    0.73392534f, -0.24659379f, -0.16131139f, -0.08758654f, -0.02936628f, 0.01512961f, -0.19827949f, 0.03329952f, 
    0.07732706f, 0.00805774f, -0.18536018f, 0.07102238f, 0.23093718f, 0.09559331f, 0.01500028f, 0.01196728f, 
    -0.46280691f, -0.07129055f, 0.30510405f, 0.18494147f, -0.23974645f, 0.37817034f, 0.30889371f, 0.05238341f, 
    -0.21880949f, 0.41061589f, 0.02988733f, 0.09993330f, 0.05733910f, -0.42951080f, -0.03087096f, 0.14657116f, 
    0.48394075f, 0.14670865f, 0.05399797f, 0.49478212f, -0.22659940f, 0.10776123f, 0.37443599f, -0.18029225f, 
    -0.15501311f, 0.36632732f, 0.03543830f, -0.16055286f, -0.23362300f, 0.17421657f, -0.44166103f, 0.02559713f, 
    -0.39039496f, 0.09724288f, -0.13629143f, 0.48748115f, 0.16982558f, -0.16719052f, -0.05164290f, 0.28417152f, 
    -0.10852568f, -0.25665078f, 0.08277272f, 0.01444664f, 0.29870224f, -0.27827334f, 0.24759357f, -0.29513934f, 
    -0.04146061f, -0.13588797f, 0.52997398f, 0.11935025f, 0.07308868f, -0.27198198f, 0.12942265f, -0.04900545f, 
    -0.25774589f, 0.17150265f, -0.14002848f, 0.18853559f, -0.18873848f, 0.17161706f, -0.15500030f, 0.17686172f, 
    -0.18885714f, 0.53332078f, -0.06731733f, -0.34129313f, 0.06714096f, 0.11693212f, 0.37013420f, 0.20776002f, 
    0.06484657f, 0.33104491f, 0.10165786f, 0.18161921f, 0.07870509f, -0.35650292f, 0.04309443f, 0.15505190f, 
    -0.36496279f, 0.02801679f, 0.38734299f, 0.31006807f, -0.06556331f, 0.17456530f, 0.52416009f, 0.40379933f, 
    -0.00420801f, -0.49277487f, -0.06713536f, -0.08605248f, -0.29380679f, -0.20840189f, -0.26523668f, -0.22520320f, 
    -0.42815480f, -0.13054897f, 0.10613700f, 0.29452291f, -0.22004345f, 0.35044897f, -0.41956365f, -0.13175572f, 
    -0.12440772f, -0.05638285f, -0.01584053f, -0.12637632f, 0.52210855f, -0.02204680f, 0.01686692f, -0.45200008f, 
    0.20346150f, 0.06020128f, 0.44774649f, 0.00806590f, 0.05792611f, -0.17782608f, -0.20652960f, -0.08387782f, 
    0.06107648f, 0.43587181f, -0.04839480f, 0.24362497f, -0.13902768f, 0.26175809f, -0.15861812f, 0.25947309f, 
    -0.06625879f, 0.40314764f, 0.09183684f, -0.02675086f, -0.11260772f, -0.15022181f, 0.14651297f, 0.36022326f, 
    0.06489611f, 0.33848432f, -0.24646944f, -0.12877758f, 0.06505321f, -0.30148742f, 0.42450339f, -0.10671279f, 
    -0.31774852f, 0.08311055f, 0.04118298f, 0.25382677f, 0.23419559f, 0.14152169f, 0.47163263f, 0.15603632f, 
    0.16788393f, -0.32046580f, -0.16844833f, 0.11233159f, -0.34950313f, -0.00754899f, 0.13237117f, 0.19907491f, 
    -0.72484374f, 0.13284738f, 0.04051107f, 0.14063548f, 0.16566165f, 0.12584549f, -0.01275081f, 0.03934620f, 
    -0.12929305f, -0.01102302f, 0.15557377f, 0.10560310f, 0.28406954f, -0.03323805f, -0.13934109f, 0.08160415f, 
    0.30932376f, 0.16632713f, 0.23915407f, 0.16651346f, -0.16748649f, 0.18551305f, 0.34284091f, -0.40573704f, 
    -0.16830769f, -0.11618909f, -0.20839475f, -0.02788198f, 0.08054520f, 0.19824131f, -0.45669532f, -0.13464807f, 
    0.00376476f, 0.19138975f, 0.15469359f, 0.06065767f, 0.23037328f, 0.37911889f, 0.32019833f, -0.11571354f, 
    0.17566346f, -0.16783252f, 0.15572315f, 0.17503320f, -0.26433641f, 0.23401423f, -0.22249635f, 0.28064916f, 
    0.40134555f, 0.35662821f, -0.40219370f, 0.31267920f, 0.24014816f, -0.34435144f, -0.17325169f, -0.07924709f, 
    0.12730061f, -0.37643656f, 0.13324112f, 0.10945868f, 0.40448499f, -0.06560229f, -0.11376938f, -0.24887829f, 
    -0.21061502f, -0.10673238f, 0.03448027f, 0.25804955f, 0.08914975f, 0.38566896f, -0.12569405f, 0.41379470f, 
    -0.11075617f, -0.87079757f, 0.19211368f, -0.12469063f, -0.08487804f, 0.12352210f, -0.46758375f, -0.03402845f, 
    0.41707546f, -0.42018917f, 0.53089952f, -0.19761573f, 0.16074416f, 0.17260686f, -0.09108229f, 0.10506453f, 
    -0.19660635f, -0.23150072f, -0.18809395f, 0.04408991f, 0.05184501f, 0.14755195f, 0.25024021f, -0.30302882f, 
    -0.11158638f, 0.50175023f, 0.23279171f, -0.23178001f, 0.22975701f, -0.05582311f, -0.47785398f, 0.34755203f, 
    0.00170131f, 0.27996764f, 0.11822283f, 0.08128136f, -0.15603852f, -0.07444929f, -0.13587944f, 0.37559614f, 
    0.19728522f, 0.09299266f, -0.17422062f, 0.26321077f, -0.22316387f, -0.32834390f, 0.27028608f, 0.49390507f, 
    0.13256660f, -0.52746993f, -0.15109108f, 0.05678507f, -0.33313507f, 0.06227221f, 0.13597031f, 0.00243115f, 
    -0.38951203f, 0.10506061f, -0.33030462f, 0.14726661f, -0.17404594f, 0.46253949f, 0.25043935f, -0.29604018f, 
    0.17623022f, 0.24273783f, -0.25245005f, 0.22195712f, 0.21799335f, 0.10778071f, -0.02016885f, 0.01744886f, 
    -0.05823946f, 0.20779370f, 0.33818296f, 0.11696541f, -0.10771245f, 0.55821937f, -0.19903052f, -0.27386239f, 
    -0.14037278f, -0.35896090f, -0.22803643f, -0.21652794f, 0.40029323f, 0.10888390f, -0.37743443f, -0.33660468f, 
    -0.06588336f, 0.28234538f, 0.01617761f, -0.09543494f, -0.09623244f, -0.25450012f, -0.34989578f, 0.14117204f, 
    -0.14050452f, 0.50234824f, 0.10582677f, 0.17327899f, 0.00816920f, 0.01825190f, -0.09116284f, 0.14018364f, 
    -0.02687591f, 0.43904120f, -0.44894019f, -0.24886240f, 0.14775044f, 0.08886003f, -0.56895894f, 0.46044096f, 
    -0.21115780f, 0.27472359f, -0.06977758f, -0.06105628f, 0.21650603f, 0.04815192f, 0.05153247f, -0.23772903f, 
    0.14811184f, 0.21905833f, -0.04574050f, 0.43719915f, 0.01639862f, -0.25965846f, 0.40761653f, 0.31301826f, 
    -0.19897856f, 0.02537972f, 0.10303371f, -0.22404943f, 0.03452288f, 0.09354144f, -0.24533045f, -0.19111285f, 
    0.21695268f, -0.14011392f, 0.04093030f, -0.09019215f, -0.11905953f, 0.22463430f, -0.14705127f, 0.58471155f, 
    0.02490869f, 0.23272546f, 0.20466422f, 0.09447023f, -0.30800861f, -0.17191243f, 0.32104805f, -0.08035575f, 
    0.16739251f, 0.56955409f, -0.29891253f, 0.28245047f, 0.21612106f, 0.08522981f, 0.36767018f, -0.02210839f, 
    -0.19048430f, -0.08648259f, -0.08549115f, 0.21658517f, 0.17793544f, 0.18947846f, -0.04247249f, -0.39661306f, 
    -0.65446222f, -0.06434000f, 0.21028778f, 0.21920367f, 0.04805595f, 0.52881503f, 0.12838569f, -0.07952981f, 
    -0.19330977f, -0.32607636f, 0.10604939f, -0.00930864f, 0.03730986f, -0.00122134f, 0.18776153f, -0.00044839f, 
    0.23006283f, 0.38003805f, -0.16226003f, -0.05409596f, 0.16002607f, -0.32142514f, 0.31191039f, 0.16331841f, 
    -0.00284434f, 0.26498610f, 0.15162569f, 0.20604664f, -0.15577471f, 0.39276707f, -0.18240009f, 0.11067795f, 
    0.18756269f, 0.36833614f, -0.21042284f, -0.27334511f, -0.09849457f, -0.17528069f, -0.47936580f, 0.26574543f, 
    -0.12072083f, -0.10937108f, -0.10761571f, -0.03303691f, 0.33654451f, -0.16325672f, 0.25485298f, -0.01191121f, 
    0.00513784f, -0.74107379f, 0.67715257f, -0.25422263f, -0.17503935f, 0.43002272f, -0.18715751f, -0.15578485f, 
    -0.25126392f, -0.30821326f, -0.15914929f, -0.05826733f, 0.00318021f, 0.30347371f, 0.27209786f, -0.03366005f, 
    0.08216841f, -0.02256126f, 0.16438071f, 0.09243847f, -0.01306955f, 0.01212440f, -0.34232241f, -0.31557414f, 
    0.03428778f, 0.32582325f, -0.09165829f, -0.04952062f, 0.20219775f, 0.17258026f, -0.10362136f, 0.20631744f, 
    -0.29818264f, 0.62359571f, -0.19730096f, 0.19947629f, 0.22421065f, 0.20534281f, 0.35765988f, 0.10994998f, 
    -0.09998952f, 0.16004701f, -0.07130303f, 0.05902868f, -0.25966492f, -0.17783487f, -0.06523020f, 0.27569371f, 
    0.59080696f, 0.01514522f, -0.13467962f, 0.17917204f, -0.11891717f, -0.09980600f, 0.30511639f, -0.38064864f, 
    0.07888874f, -0.27838424f, -0.00634110f, -0.07166132f, 0.17138200f, 0.20585784f, 0.16008930f, -0.17399707f, 
    0.64952344f, -0.33120131f, 0.23775110f, 0.35959223f, 0.01159398f, -0.48516026f, -0.29002219f, -0.16136156f, 
    0.17974618f, -0.16833548f, -0.05983433f, 0.09301504f, -0.13656422f, 0.30478719f, 0.13346165f, 0.02931178f, 
    0.11776710f, -0.10672570f, -0.31068563f, -0.56707990f, -0.16325536f, -0.00347898f, -0.28287816f, -1.02522492f, 
    -0.16982037f, -0.00710253f, 0.24203041f, 0.01001632f, 0.06577831f, -0.19115788f, 0.36252421f, 0.11111455f, 
    0.11923305f, 0.28094339f, -0.43126196f, 0.38634777f, -0.15482913f, -0.08562233f, 0.22562125f, -0.29712397f, 
    0.20499361f, -0.27608064f, -0.02892318f, -0.17352529f, 0.29101580f, 0.07742491f, 0.24745369f, -0.19165593f, 
    0.61169899f, 0.17153177f, -0.05243408f, 0.11134355f, 0.17366749f, -0.19776231f, 0.41699091f, -0.03154793f, 
    0.03916388f, 0.28324768f, 0.13638550f, -0.08653722f, 0.06302025f, -0.22127520f, 0.19111288f, 0.09157136f, 
    0.35224026f, -0.19381191f, 0.29034334f, 0.30116534f, -0.18282610f, -0.39465424f, -0.45006955f, -0.01100879f, 
    -0.08083139f, 0.16276447f, -0.25194743f, 0.14845325f, -0.01958163f, 0.18900816f, -0.38849553f, 0.21944794f, 
    0.12325787f, -0.33399075f, 0.33449599f, -0.31853300f, 0.14852731f, 0.29274458f, 0.26681352f, -0.10615165f, 
    0.05534383f, 0.25252700f, 0.18668324f, 0.16681881f, 0.10185874f, -0.29072306f, -0.07209221f, 0.25135240f, 
    0.09213559f, -0.02383359f, 0.22695343f, -0.27113354f, -0.19215745f, 0.19941762f, 0.00938917f, 0.16971043f, 
    -0.21686438f, -0.34322909f, -0.03636807f, -0.20631745f, -0.17215191f, -0.03078716f, 0.03590452f, 0.01675330f, 
    -0.02539257f, 0.04495354f, -0.23808476f, 0.21756966f, -0.19510211f, 0.13143101f, 0.31164208f, 0.06935451f, 
    0.09163690f, 0.33168149f, 0.01977631f, -0.08146761f, -0.02252633f, -0.25539193f, 0.46147990f, -0.10608648f, 
    0.07124727f, -0.60127240f, -0.36145329f, -0.16202252f, -0.14825840f, 0.39482337f, -0.24589111f, -0.00058657f, 
    -0.22986768f, 0.03821950f, -0.21930376f, -0.13720411f, 0.26365119f, -0.08689661f, 0.15338549f, -0.23479198f, 
    -0.24439615f, 0.27305052f, -0.39802349f, 0.47720152f, 0.20425974f, -0.25259405f, 0.01109407f, -0.06418030f, 
    0.20806623f, -0.27739131f, 0.18807478f, 0.22371079f, 0.45346302f, -0.07020425f, 0.20489436f, -0.49664047f, 
    -0.10416237f, -0.40679407f, 0.51108903f, -0.16368429f, -0.19350658f, 0.21099767f, -0.09021226f, -0.09134132f, 
    0.18833284f, 0.24192353f, -0.00863149f, -0.03084019f, 0.38658014f, 0.22203034f, 0.34991485f, -0.23409839f, 
    -0.37926254f, 0.37365040f, 0.24046960f, 0.29708964f, -0.05554288f, 0.13643673f, 0.02535237f, 0.61601055f, 
    -0.09271273f, -0.37204665f, -0.10386417f, 0.23432073f, -0.36423883f, -0.06612063f, -0.02331251f, 0.15464520f, 
    0.40495992f, -0.19132358f, 0.34191564f, -0.01644251f, -0.07449663f, -0.31398728f, -0.08466782f, 0.08284567f, 
    0.09758532f, 0.54220867f, 0.01104818f, 0.15761147f, -0.15125234f, -0.14793023f, 0.13635203f, 0.13083391f, 
    -0.15117297f, -0.98133403f, -0.09077603f, -0.91052508f, -0.06468597f, -0.50272560f, 0.03828102f, -0.62466574f, 
    0.06055564f, -0.08729200f, 0.04141885f, 0.20755231f, 0.22108714f, -0.01633173f, 0.30104661f, 0.17405881f, 
    -0.20923458f, 0.27652684f, -0.17680293f, -0.08850192f, -0.09556095f, -0.34968409f, 0.18472663f, 0.43103680f, 
    0.20881742f, 0.19217101f, 0.05966671f, 0.22658452f, -0.37920517f, 0.26559153f, 0.15679795f, 0.26910475f, 
    -0.19585115f, 0.05329758f, 0.14841595f, -0.23363194f, 0.15741107f, -0.32263935f, -0.25196561f, 0.47933200f, 
    0.03312298f, 0.28522447f, -0.20023185f, 0.12759082f, -0.01746810f, -0.07008703f, 0.20459010f, 0.20306170f, 
    0.09857840f, 0.79924417f, 0.47365496f, 0.01762966f, -0.13343473f, 0.12629910f, 0.48128596f, 0.17320870f, 
    0.09520932f, -0.03258476f, 0.22084831f, -0.23956977f, -0.24117625f, 0.19968729f, -0.69292390f, 0.11848689f, 
    0.20436445f, 0.11794089f, 0.14434671f, -0.14681973f, -0.12168595f, 0.03729308f, -0.00889581f, 0.06391595f, 
    0.04543227f, -0.18599518f, -0.19101810f, 0.17309654f, -0.16292813f, -0.30158493f, -0.20084700f, 0.08196699f, 
    -0.11578991f, -0.40241012f, -0.04151578f, 0.47191611f, 0.25307694f, -0.07057706f, -0.40174571f, -0.20534813f, 
    0.19322148f, -0.01218686f, 0.20520197f, 0.21041252f, 0.38932964f, -0.10703648f, 0.22238378f, -0.04386041f, 
    0.29335216f, -0.30713367f, 0.42328376f, 0.05619673f, -0.18531060f, -0.16503848f, 0.07000636f, 0.07828155f, 
    0.19491737f, -0.14530119f, -0.06451856f, -0.00563423f, 0.07036565f, 0.30383208f, -0.36622626f, 0.25549027f, 
    -0.16749857f, 0.16963251f, 0.40058041f, -0.07238143f, -0.17477776f, -0.49323979f, -0.31717488f, 0.07378446f, 
    0.12737715f, 0.12154552f, -0.21249546f, -0.04939470f, 0.09129383f, 0.24786609f, -0.20960709f, 0.28286475f, 
    0.28682396f, 0.35528284f, -0.40833667f, -0.12345325f, -0.09001744f, 0.18318765f, -0.19321214f, 0.34060571f, 
    0.01675751f, -0.38875097f, -0.02047128f, -0.16438873f, -0.15241279f, 0.27413651f, -0.10622332f, 0.26248050f, 
    -0.42832893f, -0.10973410f, 0.23667839f, 0.31937167f, 0.19854707f, 0.21154030f, -0.46506324f, 0.06262764f, 
    -0.10328513f, -0.10012858f, 0.00672590f, 0.13953523f, 0.07691024f, 0.02806402f, 0.05033517f, 0.04538902f, 
    -0.34628934f, -0.34192306f, 0.41928965f, 0.03243901f, 0.23490413f, 0.17679822f, -0.10911898f, -0.14875464f, 
    0.16104662f, 0.32627982f, -0.11194040f, 0.25975192f, 0.23926093f, 0.28884462f, -0.36682057f, 0.26331130f, 
    0.03482403f, 0.32284844f, 0.11710775f, 0.04278461f, -0.16991004f, -0.46145344f, 0.24169540f, 0.10400824f, 
    0.08980448f, 0.36555117f, -0.14506447f, 0.10721947f, -0.12866439f, 0.09355787f, -0.12128087f, 0.09587700f, 
    -0.32023335f, -0.06574383f, 0.43579784f, -0.18136580f, -0.19198327f, 0.07904559f, 0.03499970f, -0.22520812f, 
    0.13514365f, -0.03512465f, -0.10307104f, 0.03179045f, 0.38700739f, 0.22167501f, -0.45099729f, 0.18928047f, 
    0.31105521f, -0.04266538f, -0.39948556f, 0.16942561f, -0.19793060f, -0.35123804f, -0.24287157f, 0.08801149f, 
    -0.13560745f, 0.56445140f, 0.21877129f, 0.09461398f, 0.32786950f, -0.26652485f, 0.00473479f, 0.18724814f, 
    0.29409108f, 0.28241089f, -0.56857198f, -0.02644428f, -0.09836648f, 0.53235561f, 0.26131600f, -0.07931434f, 
    0.02956761f, 0.18297416f, -0.24071237f, 0.22978690f, -0.05522576f, -0.21140514f, -0.00647896f, 0.23427574f, 
    0.37488869f, 0.33645540f, -0.46702296f, 0.24243003f, 0.06022310f, 0.25470591f, -0.17123468f, 0.17459346f, 
    -0.20045684f, 0.32257318f, -0.22147024f, -0.02760090f, 0.06023914f, 0.23021701f, -0.38915786f, -0.00780082f, 
    -0.57581991f, 0.31047425f, 0.30230132f, -0.07177698f, 0.14505140f, 0.02276764f, 0.14255129f, -0.18536919f, 
    -0.12285047f, -0.16816355f, 0.05969284f, 0.10190411f, 0.03766721f, 0.21236256f, -0.24961540f, 0.33925477f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.30329388f, 0.23928316f, -0.14869700f, 0.41468507f, 0.23985817f, 0.43081328f, 0.06263605f, -0.08919187f, 
    0.30085644f, 0.42067963f, -0.30546057f, -0.39842203f, 0.15396790f, 0.47879219f, 0.39769202f, -0.41354311f, 
    0.03985493f, 0.40624061f, 0.32891187f, -0.36708304f, -0.16813888f, -0.08039688f, 0.27621952f, -0.38680637f, 
    -0.01420622f, -0.13388465f, -0.18121250f, -0.14295378f, -0.18731160f, -0.17152275f, -0.25128105f, 0.42482996f, 
    0.11438589f, -0.05432890f, 0.12019361f, 0.31069073f, -0.05333305f, -0.33633256f, 0.42832941f, -0.40204912f, 
    0.21185511f, -0.05492751f, -0.01363287f, 0.18460292f, 0.16076058f, 0.08766329f, 0.28858361f, -0.41696709f, 
    -0.09169092f, -0.31802899f, 0.14571036f, -0.19337039f, 0.11395033f, 0.37667924f, 0.48585862f, 0.00744269f, 
    0.32590029f, 0.14241029f, -0.18521662f, 0.46562472f, 0.17980997f, 0.03046298f, 0.47930989f, 0.49088591f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06193037f, -0.27483156f, 0.20651034f, 0.15215373f, -0.11008693f, 0.10092799f, 0.07602164f, 0.33273500f, 
    -0.06550660f, 0.14735003f, 0.07185049f, -0.28180337f, 0.23816830f, 0.04595647f, 0.19113371f, -0.87596470f, 
    0.17915390f, 0.12899503f, 0.83240551f, 0.00703533f, -0.17097281f, -0.06267837f, 0.28995284f, -0.18166701f, 
    0.05352049f, -0.00714954f, -0.05779755f, 0.20012334f, -0.08900750f, 0.15862998f, -0.20328258f, 0.05888845f, 
    0.10259566f, -0.33894995f, -0.28003606f, 0.29210490f, -0.39249033f, -0.28599468f, 0.08135509f, -0.08468369f, 
    0.16173609f, -0.25745732f, -0.13359486f, -0.77356720f, -0.05257243f, 0.20842727f, 0.09801775f, 0.01770448f, 
    -0.06736417f, 0.23801030f, 0.32986906f, 0.08974303f, -0.26937911f, 0.00890493f, 0.14257431f, -0.12093169f, 
    0.27296039f, 0.19164516f, -0.03634398f, 0.35638881f, -0.18306188f, -0.56371593f, -0.00901587f, 0.43569240f, 
    -0.05171207f, -0.11481337f, 0.09388617f, -0.02758583f, 0.06070642f, 0.05796692f, -0.00966713f, 0.00942114f, 
    0.04611307f, -0.00239512f, 0.03843288f, -0.00012416f, -0.07034954f, 0.06689407f, -0.01890479f, 0.09984897f, 
    0.09131461f, -0.11315820f, 0.12255615f, -0.12056026f, -0.09869030f, -0.08590828f, -0.02344169f, -0.01815830f, 
    -0.01871866f, 0.07335763f, -0.02708319f, 0.02324685f, 0.10175128f, -0.10620844f, -0.10090995f, 0.07116365f, 
    0.02351035f, 0.08992983f, 0.08971600f, -0.01157188f, 0.00034209f, -0.01194191f, -0.12452576f, 0.03944722f, 
    -0.07076144f, 0.05562027f, -0.09060708f, -0.02110179f, -0.05165054f, 0.09170541f, 0.01768585f, 0.04290499f, 
    -0.06534421f, 0.02099396f, 0.02613908f, -0.03879343f, -0.02312244f, -0.05765335f, -0.09573314f, -0.08922519f, 
    -0.04693180f, -0.09836613f, -0.01052652f, 0.00006591f, -0.12039402f, -0.12456995f, -0.11789277f, -0.11029084f, 
    -0.00874715f, -0.07145816f, -0.01461354f, -0.01137716f, -0.11214413f, -0.04564901f, -0.04503487f, -0.05609064f, 
    -0.08899546f, -0.03507358f, 0.06750724f, 0.07583570f, -0.04767206f, -0.03572924f, -0.10449152f, -0.01404259f, 
    0.03927059f, 0.07803587f, -0.09152608f, -0.11727316f, -0.09912093f, -0.09841047f, 0.12175488f, -0.01461765f, 
    -0.07873629f, -0.14940612f, 0.11158286f, 0.06564084f, -0.03434036f, -0.11714789f, -0.03279412f, -0.10287333f, 
    -0.05351152f, -0.08962616f, 0.01185195f, 0.08073749f, -0.14985211f, 0.02923249f, -0.11912185f, 0.06279100f, 
    -0.06990436f, -0.14199071f, 0.00418111f, -0.10559385f, -0.12225977f, 0.05563454f, -0.04314935f, -0.09839571f, 
    0.00336672f, -0.11482727f, -0.00026430f, -0.04931997f, -0.08871467f, -0.08201410f, -0.08715689f, 0.06757477f, 
    -0.05343013f, 0.00544429f, 0.09669395f, -0.07902384f, 0.02204244f, -0.00589592f, 0.05955638f, -0.14319620f, 
    0.03317017f, 0.02604660f, -0.02177553f, -0.21852495f, 0.40284920f, 0.03862492f, 0.18709728f, -0.52527755f, 
    0.10758165f, -0.00969761f, 0.13403352f, -0.32288015f, 0.08152903f, -0.02310976f, -0.26523286f, 0.05002944f, 
    -0.57142830f, -0.05014275f, 0.36626920f, -0.41724968f, -0.15789159f, -0.64686579f, 0.45253864f, 0.13726859f, 
    -0.19866635f, 0.17603092f, 0.01681964f, -0.41660151f, 0.03816490f, 0.46447396f, -0.17133290f, 0.14347951f, 
    -0.07779564f, 0.09356403f, 0.30786356f, 0.09914956f, 0.16848268f, 0.00764969f, -0.08537624f, 0.01481870f, 
    -0.14594238f, 0.23791356f, 0.21457972f, 0.27564561f, 0.04601095f, -0.08673155f, 0.22195198f, -0.10089659f, 
    0.17001671f, 0.29390240f, -0.37325123f, -0.03569699f, 0.13882168f, -0.08855097f, 0.19651553f, -0.12316438f, 
    0.02736182f, -0.00317414f, 0.14700927f, -0.06108839f, 0.30012277f, -0.12332122f, -0.03711367f, 0.01601406f, 
    0.22519973f, 0.01975695f, -0.07511630f, 0.08808442f, -0.19583176f, 0.16242379f, -0.08205476f, -0.04581006f, 
    -0.37438369f, 0.29271635f, -0.15796541f, 0.02231252f, -0.22416873f, -0.13888383f, 0.07921621f, -0.46798134f, 
    0.04821267f, -0.09353051f, 0.30762088f, 0.26586187f, -0.30484465f, -0.63565171f, 0.40897873f, -0.48599276f, 
    0.00677243f, 0.19753650f, -0.35713521f, -0.28970420f, 0.11799593f, -0.15350898f, -0.33022481f, 0.16011845f, 
    -0.05372481f, -0.23992516f, 0.43429312f, -0.13499154f, -0.31706968f, 0.12243570f, 0.24337839f, 0.18386169f, 
    -0.01440851f, -0.16237399f, -0.53392750f, -0.24724112f, -0.12750222f, -0.01951856f, 0.29683566f, 0.01389145f, 
    0.11183572f, -0.01501722f, -0.08866614f, 0.03608255f, 0.03309092f, 0.13894409f, 0.22368985f, 0.14044234f, 
    0.06998488f, 0.14884013f, 0.09605674f, 0.03376493f, 0.37116235f, -0.17923643f, 0.12498754f, -0.03315581f, 
    -0.04162377f, 0.14042714f, -0.33584622f, 0.15790431f, 0.03610485f, -0.19390310f, -0.00475843f, 0.08188959f, 
    0.21574919f, -0.40649387f, 0.29106539f, -0.41891652f, -0.01579946f, 0.04322055f, -0.15202647f, 0.55880642f, 
    0.22386323f, -0.12944843f, 0.03486120f, 0.21913512f, -0.19253463f, 0.21067315f, 0.28041008f, 0.74872380f, 
    0.19336231f, 0.04582593f, 0.34603184f, -0.32438579f, 0.26951230f, 0.64492476f, -0.25362110f, -0.26961944f, 
    0.02789472f, 0.22206981f, -0.15582098f, -0.23613918f, 0.23249063f, 0.23610140f, 0.05455771f, -0.39696497f, 
    -0.08284729f, -0.08545530f, 0.12209195f, 0.38220468f, -0.32916045f, 0.07725929f, -0.50178933f, -0.09448406f, 
    -0.03233744f, -0.01464531f, 0.13894232f, -0.02350472f, -0.24086662f, -0.03518618f, -0.01756985f, 0.17771050f, 
    -0.32048577f, -0.39601204f, 0.08489598f, -0.42049801f, 0.34932727f, 0.10861942f, 0.22274375f, -0.37878737f, 
    -0.12479430f, -0.03412788f, -0.13855717f, 0.07206876f, 0.06803713f, -0.10145454f, 0.00242131f, -0.06884144f, 
    0.00467061f, -0.08170657f, -0.03831670f, -0.01287749f, -0.06697832f, 0.07257763f, 0.00419004f, -0.12456992f, 
    0.11449195f, -0.01824486f, 0.02239613f, -0.01609724f, -0.14162473f, 0.03951442f, 0.09188447f, 0.04094013f, 
    -0.03196459f, -0.06292542f, -0.13044709f, 0.05219647f, 0.03860706f, -0.07578273f, -0.09571418f, -0.09615140f, 
    -0.08063050f, -0.08424150f, 0.03911629f, -0.08378349f, -0.08383434f, 0.08652665f, 0.03107380f, -0.06245349f, 
    -0.00940022f, 0.06248847f, -0.02851334f, -0.00079294f, 0.07214881f, -0.04543583f, -0.07595053f, -0.08685015f, 
    -0.04489391f, 0.08254717f, 0.06750310f, -0.05262940f, -0.14865091f, 0.04047331f, -0.09945333f, -0.06038722f, 
    -0.00812121f, 0.03708274f, -0.07601972f, -0.11066528f, -0.08436662f, -0.04812460f, -0.10034532f, -0.08955550f, 
    0.02711042f, -0.07896842f, -0.13645011f, -0.09785889f, -0.05006480f, 0.07164064f, -0.10965549f, 0.10616784f, 
    -0.05162707f, -0.11192091f, 0.03513978f, 0.02316689f, -0.13770379f, 0.01032260f, -0.10409509f, -0.10944030f, 
    0.08982168f, 0.04152116f, -0.05261817f, 0.11653590f, -0.09896880f, 0.06085273f, -0.00028740f, 0.02809981f, 
    -0.11854407f, -0.07952869f, -0.09755271f, -0.15466604f, 0.01600400f, -0.08768941f, 0.05545456f, -0.11687957f, 
    -0.10799865f, -0.05983399f, -0.00255274f, 0.07121852f, -0.05129562f, -0.02272163f, -0.03707704f, -0.02226693f, 
    0.09678675f, -0.14930195f, 0.03923912f, -0.14431146f, 0.04494932f, 0.12205817f, 0.03000864f, -0.05233321f, 
    -0.04160174f, 0.08243216f, -0.11457786f, 0.08279081f, -0.04597660f, -0.14784445f, 0.00350335f, 0.03899707f, 
    -0.03596086f, -0.03402380f, -0.13403413f, -0.11036140f, -0.06842687f, 0.10262890f, -0.10647520f, -0.02643770f, 
    -0.02063985f, -0.03125910f, 0.05573780f, 0.34015602f, -0.07908553f, 0.31141785f, 0.06752836f, 0.03020935f, 
    -0.09105161f, 0.33619791f, -0.11176309f, -0.11368576f, -0.08164771f, 0.23262060f, 0.25745830f, -0.21271826f, 
    -0.19772932f, 0.09097122f, -0.39621857f, 0.09732498f, -0.02058701f, -0.35736316f, -0.11839713f, -0.52869177f, 
    0.15223607f, -0.08637337f, 0.07063001f, -0.24148320f, 0.14047450f, -0.33596358f, -0.25028709f, 0.02294632f, 
    0.11934488f, 0.22883217f, 0.25090247f, -0.10402636f, 0.07827621f, 0.27171302f, 0.10848638f, -0.02600467f, 
    0.08015277f, 0.14998190f, 0.27467245f, -0.15689614f, -0.06227545f, 0.01819182f, 0.22864406f, -0.14817904f, 
    0.13717955f, -0.15839528f, -0.02931733f, -0.02316967f, 0.01819491f, 0.08498405f, 0.14014445f, -0.12550636f, 
    -0.11308263f, 0.09866788f, 0.26475465f, -0.06188442f, 0.05303032f, -0.06934921f, 0.04050158f, 0.10988603f, 
    0.08386762f, 0.11252893f, -0.11096293f, -0.19427703f, -0.35571879f, -0.01905644f, -0.17140773f, -0.29432300f, 
    -0.48627880f, 0.08657137f, -0.08246469f, -0.33153585f, -0.11927570f, -0.05987229f, -0.28648728f, 0.02471931f, 
    0.03301337f, -0.06649757f, 0.23885578f, -0.57428259f, 0.01851051f, -0.62573016f, -0.02949798f, -0.62048823f, 
    -0.22049589f, -0.41721144f, -0.08029383f, -0.21062167f, 0.17296167f, 0.08858152f, 0.19075474f, -0.02558790f, 
    -0.43009135f, 0.18639755f, 0.37663168f, 0.15995252f, -0.05283578f, 0.07082895f, 0.08434083f, 0.08804896f, 
    -0.02097360f, -0.00316710f, -0.18331847f, -0.06746386f, 0.11375476f, -0.22522020f, -0.04949645f, 0.53727371f, 
    0.00904989f, 0.17478791f, 0.04035007f, -0.02972198f, 0.12585276f, 0.10082965f, 0.05495128f, -0.04744622f, 
    -0.04271160f, 0.08648772f, 0.14444286f, 0.09698142f, 0.07177770f, -0.12410214f, -0.26740894f, 0.09440856f, 
    0.12498639f, -0.13713023f, 0.00482077f, -0.08550629f, 0.34162423f, -0.01496861f, -0.20737110f, 0.26041862f, 
    0.07436769f, -0.28903764f, -0.19817753f, 0.04419579f, 0.05696681f, -0.17944281f, 0.12889451f, 0.27571991f, 
    0.55069888f, 0.02960418f, 0.11129149f, 0.27165914f, -0.41997367f, -0.07412086f, -0.23498178f, 0.29331341f, 
    0.26510438f, 0.39514545f, 0.05782922f, 0.35932451f, -0.04480283f, 0.39905369f, 0.07906234f, -0.32880771f, 
    -0.09408297f, -0.19293016f, -0.27967429f, -0.04426472f, -0.12436093f, -0.34309202f, 0.05235345f, 0.14820652f, 
    0.16270934f, -0.40082592f, -0.27301154f, 0.06036704f, -0.28067547f, 0.32060379f, -0.48403537f, -0.12528759f, 
    0.17435382f, 0.30639836f, -0.01100316f, -0.05404701f, -0.01962935f, -0.01858498f, 0.06125323f, 0.31737641f, 
    0.24325983f, -0.08442472f, -0.05235391f, -0.14642358f, -0.18084668f, -0.12250914f, 0.11532348f, -0.07038453f, 
    0.04674434f, 0.17958371f, 0.19922583f, 0.08848093f, 0.16396450f, 0.17069291f, -0.04334218f, -0.16566971f, 
    0.65646446f, 0.09891897f, 0.00423707f, 0.19149821f, 0.15985359f, 0.21974486f, -0.20392643f, 0.17048769f, 
    0.00219224f, 0.40294760f, -0.28772706f, -0.11542411f, -0.01529647f, 0.45228878f, -0.42581195f, 0.10132610f, 
    -0.11790537f, 0.28998917f, -0.04849063f, 0.06488577f, -0.30736527f, -0.01365126f, 0.18518902f, -0.00693940f, 
    -0.28112814f, -0.05042638f, 0.10839262f, 0.13224167f, -0.07834943f, 0.00836298f, 0.14243184f, 0.04764723f, 
    0.13919057f, -0.04405773f, -0.03296896f, 0.04505805f, 0.31687230f, -0.43002695f, 0.04815163f, 0.01505565f, 
    0.00149444f, -0.04198254f, -0.09458929f, 0.10048833f, 0.15920389f, -0.02556819f, 0.12317158f, -0.45656499f, 
    0.10025246f, 0.09610923f, -0.20362416f, 0.09735546f, -0.04838769f, -0.04995092f, 0.05860443f, -0.25530201f, 
    -0.07502911f, -0.06817511f, 0.02207972f, -0.12191606f, -0.89314806f, 0.03431615f, 0.13490745f, -0.04561456f, 
    -0.48106825f, 0.17179808f, 0.07025748f, -0.43208554f, -0.82533491f, 0.04440210f, -0.15707552f, -0.14984408f, 
    -0.07807320f, -0.01125229f, 0.34116843f, -0.00825374f, -0.12415000f, -0.08679017f, 0.29872966f, -0.37040460f, 
    -0.18900505f, 0.11881225f, -0.15869795f, -0.25767961f, -0.19269523f, 0.08982193f, 0.00554379f, 0.04920118f, 
    -0.00821607f, -0.17080341f, -0.03409320f, 0.27630386f, -0.38840085f, -0.02176647f, -0.46003559f, 0.15296015f, 
    0.00304769f, -0.05088067f, 0.14632608f, -0.83533448f, -0.01923705f, -0.12239884f, 0.19208494f, -0.02255006f, 
    -0.01749991f, 0.14067455f, -0.12077498f, -0.06514248f, -0.19124843f, -0.00600860f, -0.08240039f, -0.18597558f, 
    -0.42694706f, -0.05504142f, -0.09753454f, -0.11792915f, 0.09375697f, 0.09202749f, -0.26722145f, 0.00635536f, 
    -0.00879224f, -0.18710308f, 0.29777211f, -0.06636500f, 0.06343432f, 0.18659638f, 0.01152246f, 0.53331095f, 
    0.12668829f, 0.11157692f, -0.01140991f, 0.09012014f, 0.01379013f, -0.09706200f, -0.08809786f, -0.63652909f, 
    0.09100554f, 0.22347714f, -0.10594927f, 0.06892529f, -0.03120214f, -0.07721952f, -0.20936172f, -0.55879223f, 
    0.01871348f, 0.17662513f, -0.11181073f, 0.27542615f, -0.34033200f, -0.01476836f, 0.27011675f, 0.07725937f, 
    -0.02753692f, -0.12014331f, 0.04581795f, 0.10946078f, -0.12787436f, -0.09684640f, 0.13281186f, -0.01442336f, 
    0.07788252f, 0.14879537f, 0.21005510f, -0.33150628f, 0.18705124f, 0.19138835f, 0.23589239f, 0.16363443f, 
    -0.01991576f, 0.03666054f, -0.03243396f, -0.01806058f, 0.24966916f, 0.11719634f, 0.08146143f, -0.45684028f, 
    0.36771879f, 0.09595360f, -0.23619400f, 0.00206055f, -0.13347089f, -0.17699602f, -0.14275800f, 0.13465589f, 
    0.08839259f, 0.14937870f, -0.16512252f, -0.07082366f, -0.06477775f, 0.13525252f, -0.05882021f, -0.58462149f, 
    0.23207279f, 0.13682747f, -0.00784361f, 0.08309403f, 0.08059650f, 0.41054517f, 0.06630402f, -0.34571314f, 
    -0.08826904f, 0.19829026f, -0.13268276f, -0.39028686f, 0.08406737f, 0.35243782f, 0.09135552f, 0.34593225f, 
    -0.12107117f, -0.06124838f, 0.00116515f, 0.16071695f, 0.05021311f, 0.03962218f, 0.09551301f, 0.09686632f, 
    -0.05954085f, 0.23185901f, -0.00166719f, -0.01211210f, 0.14919665f, -0.03187035f, -0.08008402f, 0.05540456f, 
    -0.07410869f, -0.01349538f, -0.04758872f, -0.08534916f, 0.16725565f, -0.24015628f, 0.01879426f, -0.12381703f, 
    -0.13749602f, -0.18977021f, 0.07573861f, 0.03701071f, 0.09700530f, 0.08604077f, 0.03557414f, 0.09849745f, 
    -0.16100124f, 0.06128192f, -0.09351576f, 0.36272958f, 0.02045015f, 0.10132290f, 0.11981776f, 0.22420062f, 
    -0.15798923f, 0.07072103f, 0.01414913f, -0.07191070f, -0.15426199f, 0.01138885f, -0.03898660f, 0.00016777f, 
    -0.02432552f, -0.14294295f, -0.05146249f, -0.00886383f, -0.04981124f, -0.15249419f, -0.00641887f, 0.03805619f, 
    0.04486934f, 0.07749481f, 0.11597475f, -0.11359843f, -0.08402370f, 0.03255206f, -0.09706978f, -0.01660054f, 
    0.09212184f, 0.04316928f, -0.15563086f, 0.06213968f, -0.04920124f, 0.05533119f, 0.01091679f, 0.06582114f, 
    0.07306296f, -0.13906132f, -0.07923987f, 0.11736546f, -0.12697674f, -0.13764806f, -0.07983375f, -0.09106465f, 
    0.01319541f, -0.02854347f, -0.00719263f, -0.15907644f, -0.12848897f, 0.08333179f, -0.08368028f, 0.13703527f, 
    0.01381845f, -0.15018578f, 0.07135308f, -0.03646688f, -0.03042116f, -0.00863643f, 0.03349911f, -0.06703519f, 
    0.09294823f, 0.02245562f, 0.03627727f, 0.08172951f, 0.00867560f, -0.09448136f, 0.08417011f, -0.12749790f, 
    -0.02459351f, 0.03009284f, 0.00349642f, 0.06855827f, -0.15210368f, 0.14179100f, -0.09198088f, 0.30089182f, 
    0.08307569f, -0.00207747f, -0.20713915f, 0.02626705f, 0.18027066f, 0.21723467f, 0.17987606f, -0.67383587f, 
    0.33350661f, 0.15312774f, 0.31076592f, -0.03215778f, -0.06053426f, 0.24249741f, -0.14142883f, -0.39261216f, 
    -0.00321241f, -0.30704272f, -0.19446960f, 0.30791959f, -0.14928257f, 0.00978278f, 0.44981080f, -0.00495828f, 
    -0.24033643f, 0.06003965f, 0.05318198f, -0.03179339f, -0.04952513f, -0.16185245f, 0.14209980f, 0.14935604f, 
    -0.01591285f, -0.12382912f, -0.04191344f, -0.56860113f, 0.16714758f, 0.04909545f, -0.04908228f, 0.49475652f, 
    -0.08638546f, -0.10955040f, 0.15793739f, 0.12286670f, 0.11650322f, 0.28706893f, 0.17718108f, -0.09882748f, 
    0.24183396f, 0.19600245f, -0.15153918f, 0.49983162f, -0.37508562f, -0.03361961f, -0.07413392f, 0.42222780f, 
    -0.05688439f, 0.00310944f, -0.11826406f, 0.03319028f, -0.06777341f, -0.11290827f, 0.04347907f, -0.00846066f, 
    -0.06977443f, -0.04378760f, -0.06343777f, -0.03121451f, -0.09209915f, -0.14388582f, 0.02835828f, 0.08805843f, 
    -0.09578035f, -0.12384881f, 0.01062369f, -0.07380748f, 0.06202097f, 0.05773345f, 0.03458828f, 0.04196413f, 
    -0.02739642f, -0.10588268f, -0.11499164f, 0.08436970f, -0.11807144f, -0.05488341f, -0.09533202f, -0.05115449f, 
    0.03466972f, -0.10347249f, 0.01755531f, -0.02738928f, -0.04926283f, 0.00231456f, 0.09491876f, -0.15544859f, 
    0.03861001f, -0.09768455f, -0.03596032f, -0.05388144f, 0.00971812f, -0.00519041f, 0.04087885f, -0.00964585f, 
    0.04310974f, -0.12457740f, 0.00915382f, 0.02539684f, -0.00069194f, 0.04074539f, -0.01206812f, -0.13956140f, 
    -0.01422141f, 0.02232336f, 0.01417046f, -0.12595133f, 0.01078913f, 0.00654698f, -0.08749365f, 0.02545706f, 
    -0.07981709f, -0.07929759f, -0.05779607f, 0.07138608f, 0.06752744f, -0.13786587f, -0.10921315f, -0.06750930f, 
    -0.02580878f, 0.03966047f, -0.12821975f, -0.11598597f, 0.04416290f, -0.06703161f, -0.09063667f, -0.11071788f, 
    0.08938237f, -0.14944786f, 0.04037743f, -0.05297547f, -0.03050637f, -0.10159568f, 0.03264205f, -0.05459883f, 
    -0.15622185f, 0.02337299f, -0.09401815f, -0.12743393f, -0.02670383f, -0.04777545f, -0.06171433f, -0.02124122f, 
    -0.09135283f, 0.03442990f, 0.10354754f, 0.02640097f, -0.15955490f, 0.01312616f, -0.01184555f, -0.06316556f, 
    0.05283712f, 0.04830905f, -0.15819350f, -0.01452153f, -0.00691232f, -0.06600424f, 0.08157088f, 0.04951733f, 
    0.05616885f, -0.10328057f, -0.09195005f, 0.00237098f, -0.11256857f, 0.04098782f, -0.11201213f, -0.01664151f, 
    0.03528830f, -0.01944267f, 0.02295022f, -0.09228659f, -0.04002978f, -0.04401701f, 0.05844450f, -0.12081435f, 
    -0.14342952f, 0.00019535f, -0.05814862f, 0.05815277f, -0.02711743f, 0.00158410f, -0.00287265f, -0.08916983f, 
    -0.12052089f, 0.08177306f, 0.03646372f, 0.04133400f, -0.01342343f, -0.05041318f, -0.09132296f, -0.06338225f, 
    -0.01765698f, -0.16348261f, -0.03034745f, -0.10125928f, -0.12041239f, -0.09958096f, 0.01721309f, -0.15160908f, 
    0.03876872f, -0.01407749f, -0.03769300f, -0.12390235f, 0.08522963f, -0.17372501f, -0.11963933f, -0.07373717f, 
    0.01729044f, 0.00824351f, 0.03571594f, -0.10279988f, -0.10318051f, -0.05578576f, -0.09880437f, 0.09176033f, 
    -0.03174388f, 0.07986668f, 0.02935334f, 0.04151891f, 0.02888402f, -0.01596562f, 0.09285417f, -0.10904066f, 
    0.06783907f, 0.01218520f, -0.07281890f, 0.05582906f, 0.00492232f, 0.01456398f, -0.08771307f, -0.08274645f, 
    -0.09324952f, -0.12255105f, -0.03431305f, -0.12497591f, -0.03920518f, 0.03950428f, -0.03595771f, 0.05966912f, 
    0.07385872f, -0.06794562f, 0.05586661f, 0.06708169f, -0.18455261f, 0.06654983f, 0.09236519f, 0.06750351f, 
    -0.19802032f, 0.13182995f, -0.02045126f, -0.06817880f, 0.13934907f, 0.27312696f, -0.00770412f, -0.01029391f, 
    -0.19590068f, -0.15217991f, 0.24803869f, 0.16946748f, 0.05059414f, 0.14033119f, 0.30968973f, -0.24991867f, 
    0.08655270f, -0.31023222f, 0.21522802f, 0.07411405f, 0.22632724f, -0.14005150f, 0.08385491f, 0.04128289f, 
    -0.09114376f, 0.01551548f, -0.27894378f, 0.16249911f, 0.01098898f, 0.00884548f, 0.02086761f, -0.15786637f, 
    -0.05123619f, -0.22258119f, 0.05295645f, -0.04200064f, -0.01830421f, 0.03944244f, -0.16130809f, 0.08568766f, 
    0.05992186f, 0.13262548f, 0.36583075f, 0.07190731f, -0.13296051f, 0.05469857f, 0.13150428f, -0.02207337f, 
    -0.06223924f, 0.03012914f, 0.18140875f, 0.05833552f, -0.30736241f, -0.12089098f, 0.05036051f, 0.22687484f, 
    0.15822652f, 0.07307574f, 0.12760890f, 0.14234741f, 0.05775248f, -0.00393012f, 0.09716408f, 0.18560308f, 
    -0.40561840f, 0.00535526f, 0.06505839f, -0.14539959f, -0.14846824f, -0.14632460f, 0.02058610f, -0.18913205f, 
    0.07099629f, -0.00311777f, 0.26635996f, 0.18311660f, -0.00099806f, -0.53685933f, 0.01334448f, 0.00014197f, 
    0.15209156f, 0.00046739f, -0.14561747f, -0.07100888f, 0.14169891f, -0.09743513f, -0.08290135f, 0.10222735f, 
    0.18832877f, -0.07797136f, -0.04871822f, -0.10055467f, -0.10879666f, 0.18595834f, 0.10070647f, -0.08010595f, 
    0.09096705f, -0.06949142f, 0.28422755f, -0.18267977f, -0.12542443f, 0.12015745f, 0.20876904f, -0.26338267f, 
    0.00477537f, -0.02998266f, 0.06471996f, 0.02313702f, -0.21184528f, 0.02241804f, 0.15651712f, 0.05041206f, 
    0.00485954f, 0.03925947f, 0.14093676f, -0.11650261f, 0.18449505f, -0.15800773f, 0.10867187f, 0.04294819f, 
    -0.17197062f, 0.01915965f, -0.06573153f, 0.08920000f, -0.54485202f, 0.07561965f, 0.04461998f, -0.56680226f, 
    -0.10788005f, 0.14905955f, -0.27429989f, -0.07629047f, 0.15932265f, 0.39949241f, 0.08441790f, 0.02208604f, 
    -0.45112458f, -0.17866929f, 0.17740056f, -0.14883113f, 0.03338543f, 0.18993467f, 0.05420984f, 0.38841686f, 
    0.03759472f, -0.40833983f, 0.27939793f, -0.30880761f, 0.13687091f, -0.03070529f, -0.01916247f, 0.20027211f, 
    -0.07289760f, 0.09528941f, 0.04506755f, 0.07759351f, -0.00424459f, -0.00014599f, 0.23210168f, -0.16555013f, 
    -0.01068250f, -0.36148188f, 0.10014655f, -0.14741090f, 0.03980116f, -0.34625804f, -0.00588403f, 0.35613441f, 
    0.15619132f, 0.01937472f, 0.39026466f, 0.08227897f, 0.12022315f, 0.08578164f, 0.17866348f, 0.15351455f, 
    -0.02820575f, 0.19205783f, 0.19364667f, 0.39083803f, 0.01843584f, -0.13431759f, 0.18291105f, 0.17827255f, 
    0.10404830f, -0.16779050f, 0.31045622f, 0.14324848f, -0.17309064f, 0.14325139f, 0.11127751f, 0.09807093f, 
    0.18919197f, 0.19775553f, -0.02514604f, -0.00954082f, 0.30674911f, 0.19758686f, 0.17240849f, -0.74598634f, 
    0.15115699f, 0.01885161f, 0.27814230f, -0.20311628f, -0.02509082f, -0.10433454f, 0.28065729f, -0.19854490f, 
    -0.10434211f, -0.18415128f, -0.21377188f, 0.13135491f, -0.03359893f, -0.04933878f, -0.47220275f, 0.15510182f, 
    0.01437907f, -0.16119167f, -0.19638465f, -0.19875067f, -0.28323337f, -0.16575475f, -0.01610449f, -0.23762649f, 
    0.08115145f, -0.09536364f, -0.10130943f, -0.52477700f, 0.03664938f, 0.08472215f, 0.10403918f, 0.15409021f, 
    -0.19724874f, -0.06935622f, 0.17341119f, -0.14493683f, 0.05846319f, 0.13979237f, 0.26252136f, -0.00699809f, 
    0.09758367f, 0.11465268f, -0.12405375f, 0.29011407f, 0.06920164f, -0.49319109f, 0.04039477f, 0.35796458f, 
    0.23530549f, 0.24220924f, -0.02301132f, 0.38906765f, 0.20231614f, 0.20592612f, -0.14635155f, -0.24552713f, 
    -0.35804215f, 0.16531497f, 0.07892598f, -0.23299074f, -0.14009221f, 0.10930033f, 0.08756123f, 0.48429498f, 
    -0.25260609f, 0.10786606f, 0.20502615f, 0.09781732f, -0.10790307f, -0.43441203f, 0.36035925f, 0.02071053f, 
    0.24299230f, 0.17981678f, 0.22999711f, -0.43756139f, 0.35645607f, 0.07084414f, -0.17835304f, 0.01820036f, 
    0.11380182f, 0.07066733f, 0.49993610f, -0.10986310f, 0.16659629f, 0.13422889f, 0.36042267f, -0.21423462f, 
    -0.17582135f, 0.06849026f, -0.08467939f, 0.33913082f, -0.12628779f, 0.05563113f, 0.22932386f, -0.53166169f, 
    0.27002880f, -0.08386445f, 0.07537154f, 0.11423256f, -0.05436826f, 0.09445106f, 0.21925864f, 0.44325194f, 
    -0.15134561f, -0.05079288f, 0.43072096f, -0.05118357f, 0.29832533f, 0.03521162f, 0.09776023f, -0.07362992f, 
    -0.06605454f, -0.20561638f, -0.02293753f, -0.29664907f, 0.02999700f, -0.03288396f, -0.10448337f, -0.03549660f, 
    0.23655497f, 0.04802920f, 0.07963749f, 0.28139001f, 0.20579119f, -0.24039558f, -0.06206298f, 0.06126225f, 
    0.13524054f, -0.07343540f, 0.31880635f, 0.14935982f, 0.11650567f, 0.13782981f, 0.22997436f, 0.83254206f, 
    -0.10718295f, 0.11450090f, 0.10623981f, 0.19097772f, -0.16772588f, 0.25221828f, -0.07730621f, -0.09831010f, 
    0.09564466f, -0.10010260f, -0.37622571f, 0.03641871f, 0.08635924f, -0.25962669f, -0.09716172f, -0.08488802f, 
    -0.21874119f, 0.04392325f, 0.15405956f, -0.00748628f, 0.08495824f, 0.18210948f, -0.30531326f, -0.13038167f, 
    0.19135618f, 0.20464732f, 0.12904532f, -0.02754076f, 0.12565584f, -0.06039635f, 0.14286004f, 0.16125551f, 
    0.23604362f, 0.01338244f, -0.17480317f, -0.00092683f, -0.00026586f, -0.29166377f, 0.08605348f, 0.32534087f, 
    0.05937500f, 0.19470693f, 0.17100574f, -0.10089150f, 0.11787830f, 0.03743960f, 0.09632975f, -0.08147119f, 
    0.25382498f, 0.15822648f, 0.14923461f, 0.00935353f, 0.09751187f, 0.01896867f, 0.12009484f, -0.20619847f, 
    -0.03011408f, 0.36488968f, -0.22055934f, 0.05014471f, -0.01273228f, 0.06090844f, -0.23703122f, 0.03727564f, 
    0.06121215f, 0.35894611f, 0.05185586f, 0.07517937f, -0.16161452f, 0.00421445f, 0.19340636f, 0.17367382f, 
    0.09340899f, 0.01229977f, -0.13843842f, 0.07410979f, -0.05048963f, -0.06921621f, 0.07873093f, 0.05915568f, 
    -0.00702245f, 0.08928093f, 0.16984735f, -0.08037371f, 0.20012738f, 0.02823506f, 0.20796865f, -0.29543978f, 
    -0.21324492f, -0.19699970f, -0.15755290f, 0.05541339f, 0.12152760f, 0.06209432f, 0.07693315f, -0.20818660f, 
    0.05478045f, 0.05996454f, -0.21980898f, 0.16751690f, 0.08661723f, 0.07001742f, -0.03962773f, -0.00013128f, 
    0.00030838f, 0.02719305f, 0.17621943f, -0.01452964f, 0.21205787f, -0.00335278f, -0.25009063f, 0.05404799f, 
    0.74385250f, -0.08776174f, -0.42950514f, -0.47742409f, 0.40685609f, 0.29095003f, 0.04078598f, 0.30887133f, 
    0.35577720f, 0.14624718f, -0.34123382f, -0.03373942f, 0.38994449f, 0.89405918f, -0.12465172f, 0.03881364f, 
    0.04553824f, -0.18305896f, 0.21028140f, 0.49407420f, -0.28134978f, -0.02874532f, 0.26457119f, 0.08447143f, 
    -0.03577876f, -0.06401604f, -0.13938503f, 0.40823284f, 0.17722197f, -0.53245461f, 0.00336192f, 0.01964246f, 
    0.08044630f, -0.32967624f, 0.64868134f, 0.47064808f, 0.13413459f, 0.20798950f, -0.43461639f, 0.06029423f, 
    -0.62597173f, -0.49183676f, -0.03041239f, 0.02758357f, 0.44308889f, 0.03431040f, 0.06104160f, -0.02262197f, 
    0.33254856f, 0.27735981f, -0.54165167f, 0.26747605f, -0.16764627f, 0.08901934f, 0.22427025f, 0.12685555f, 
    -0.00153228f, 0.18762816f, 0.02549670f, -0.11682671f, 0.61005378f, 0.06537690f, -0.19228052f, -0.74149460f, 
    0.26358867f, 0.16262855f, -0.12363490f, -0.10988773f, 0.06030147f, -0.03955263f, -0.29284430f, -0.03499103f, 
    -0.40518367f, 0.13088910f, -0.03560266f, -0.83055741f, 0.04100301f, -0.09076094f, -0.10423692f, -0.12903182f, 
    -0.30004457f, 0.05234438f, -0.24154367f, -0.17053424f, -0.20499991f, 0.20588522f, 0.00648570f, 0.22016279f, 
    -0.10989339f, -0.00963372f, 0.61420637f, -0.26665688f, 0.13082302f, -0.00041294f, -0.01408623f, -0.14927813f, 
    -0.10496066f, 0.24042451f, 0.11487536f, 0.72231233f, 0.22537844f, -0.31728819f, 0.26581475f, -0.37280011f, 
    -0.05290544f, 0.04749997f, -0.55144507f, 0.08278919f, 0.48891172f, -0.01917668f, 0.13977347f, -0.38944817f, 
    0.29326010f, 0.09625333f, -0.21873251f, 0.04279736f, 0.54611182f, -0.08789863f, -0.04974557f, 0.03774600f, 
    0.28189260f, 0.08136560f, -0.07337591f, 0.43615431f, -0.40502414f, -0.36532059f, -0.13025989f, -0.10962534f, 
    -0.60774016f, 0.08667327f, -0.08925650f, 0.08384030f, 0.02581977f, -0.15687451f, 0.16133241f, -0.22803362f, 
    -0.57544249f, 0.02027058f, -0.03645451f, -0.42503837f, 0.01027939f, -0.51800174f, -0.33556205f, 0.00756998f, 
    -0.36980739f, 0.44493583f, -0.14926867f, 0.10858896f, -0.10218127f, 0.05532805f, 0.09041373f, 0.01504174f, 
    0.10297874f, -0.13064353f, 0.20584710f, 0.11391232f, 0.00061025f, 0.05329832f, -0.17954820f, 0.00306418f, 
    -0.12098336f, 0.09679111f, 0.20907511f, -0.14322291f, -0.03614704f, 0.00311231f, 0.07415494f, -0.20443383f, 
    0.06408468f, 0.12338937f, 0.15409145f, 0.10665072f, 0.20154478f, -0.29215726f, -0.33540392f, 0.28542975f, 
    0.03851203f, -0.08768037f, -0.08608752f, -0.43352833f, -0.21631847f, 0.07593379f, 0.27734166f, -0.30024514f, 
    0.00063239f, 0.00052178f, -0.01465640f, -0.10910457f, -0.13142329f, 0.01789950f, -0.10352756f, -0.06298339f, 
    0.02342634f, -0.10109476f, 0.06855971f, -0.11287986f, -0.14409378f, -0.08604951f, 0.05863910f, -0.08811857f, 
    0.06607120f, -0.08390626f, 0.02486118f, -0.07289066f, 0.07303922f, 0.01419848f, 0.00792419f, 0.05593816f, 
    -0.09818162f, 0.06205701f, -0.09240014f, 0.01151772f, -0.07878868f, -0.14171161f, -0.13194248f, -0.01445110f, 
    0.01909648f, -0.00942161f, 0.00345163f, 0.11037223f, -0.12710725f, -0.00267355f, 0.07504502f, -0.05714131f, 
    0.07703999f, 0.02496430f, -0.12018663f, 0.10779928f, -0.03033237f, -0.03364509f, -0.13213067f, -0.00064355f, 
    -0.07742316f, -0.03146164f, -0.08850335f, -0.00911598f, -0.05521650f, 0.00191857f, 0.08479756f, -0.12330984f, 
    -0.03018147f, -0.05234068f, -0.02236445f, -0.00154545f, -0.05136473f, 0.02453087f, -0.03336846f, -0.01211872f, 
    -0.14180180f, 0.05065412f, -0.13528390f, 0.09860469f, 0.10421512f, 0.08614654f, -0.03342658f, 0.00107705f, 
    -0.13696113f, -0.11745266f, 0.03918702f, -0.04573678f, -0.06352259f, -0.12980364f, -0.07815468f, -0.03698244f, 
    -0.11567661f, -0.08243378f, 0.06245818f, -0.05768931f, 0.14354837f, 0.08179018f, -0.10599969f, 0.05751716f, 
    -0.05331936f, 0.09780210f, 0.01887549f, -0.10384528f, -0.05105518f, -0.05558426f, 0.02923903f, -0.14609434f, 
    -0.02857561f, -0.10000370f, 0.02386823f, -0.04630953f, -0.11635262f, -0.11231606f, -0.13507412f, 0.00619249f, 
    -0.10618754f, -0.10772219f, -0.10609680f, 0.08922060f, -0.13689290f, 0.01764769f, -0.01367928f, 0.01147969f, 
    0.05917415f, 0.03711791f, 0.08105884f, 0.02885984f, -0.02364360f, -0.00089073f, 0.03450264f, -0.05405987f, 
    -0.12666725f, -0.09441362f, -0.03235025f, 0.01547133f, 0.10652365f, -0.11787970f, -0.08001833f, 0.11497823f, 
    0.13604075f, 0.20616029f, 0.08468541f, -0.28298029f, 0.19053079f, -0.02927084f, -0.01648171f, -0.61119407f, 
    0.15084067f, 0.17262922f, -0.00520640f, 0.10766410f, 0.24395117f, -0.35046795f, -0.11265311f, -0.25213271f, 
    -0.39952931f, 0.18151794f, 0.07841913f, -0.35497960f, 0.11449594f, -0.33071488f, -0.08557343f, -0.16144106f, 
    -0.38205126f, 0.14189290f, -0.18458171f, 0.01060298f, -0.11171605f, 0.22241037f, -0.01230072f, 0.27916276f, 
    -0.06201273f, -0.08867740f, 0.31610051f, -0.20726778f, 0.06952157f, -0.08884447f, 0.15587063f, -0.10112428f, 
    -0.17598164f, 0.19272912f, 0.08602301f, 0.18106884f, 0.27120203f, 0.05602169f, -0.03844049f, -0.13919160f, 
    -0.02591558f, 0.15275124f, -0.60717171f, 0.03022550f, 0.44744346f, 0.06091515f, 0.07551084f, -0.30450368f, 
    0.42037103f, 0.20147240f, -0.12233634f, 0.09823158f, 0.30231583f, -0.14321767f, -0.02626882f, -0.02578300f, 
    0.17505598f, 0.22839065f, -0.01858237f, -0.15221272f, 0.24097714f, -0.40288824f, 0.17552564f, -0.25208807f, 
    -0.02557274f, -0.22467345f, 0.00074984f, -0.28053278f, 0.08276953f, -0.11492147f, -0.27795774f, 0.20446168f, 
    -0.30942783f, 0.12338281f, 0.16559415f, -0.28307083f, 0.00506597f, 0.11981630f, -0.15299401f, 0.32545239f, 
    -0.14719442f, -0.03161863f, 0.06551287f, 0.10971314f, -0.14612994f, 0.39606842f, -0.13703330f, -0.10200749f, 
    -0.06182111f, 0.17413227f, -0.16002570f, -0.25286964f, 0.11037351f, 0.03920384f, -0.25842288f, -0.21114412f, 
    0.10393434f, 0.09083813f, 0.05850089f, 0.27199173f, 0.02727932f, 0.01987014f, -0.08230671f, -0.18303236f, 
    -0.05250406f, -0.10300466f, -0.09445316f, -0.03258869f, 0.12958291f, 0.10150701f, 0.08011740f, 0.17904957f, 
    -0.01086994f, -0.16985987f, -0.16450219f, -0.04655829f, 0.04352635f, 0.16434327f, -0.00044851f, -0.16682078f, 
    -0.55487448f, 0.05469048f, 0.15447028f, -0.03009905f, 0.11805156f, -0.16836390f, 0.04504332f, -0.27338362f, 
    -0.11414245f, -0.10917800f, 0.08386752f, 0.13283211f, 0.12568146f, 0.21657304f, 0.01629010f, -0.33676204f, 
    -0.42516783f, -0.11802365f, -0.38176423f, -0.22871122f, 0.26791218f, 0.07058039f, -0.03366921f, -0.17445977f, 
    0.21556531f, -0.32691181f, 0.22774638f, 0.09070083f, 0.16171929f, -0.21451594f, -0.13128397f, -0.09119231f, 
    0.06968231f, 0.07272581f, -0.54475737f, -0.21586263f, 0.19356820f, 0.00709649f, -0.15066999f, 0.04398790f, 
    -0.00423566f, 0.06781671f, -0.19695725f, 0.11178982f, 0.00053323f, -0.83204192f, -0.16618328f, -0.05194935f, 
    0.07993621f, -0.03718114f, 0.17143834f, -0.09082995f, -0.22719817f, 0.11258969f, -0.17649895f, -0.16492660f, 
    -0.27185312f, 0.10047184f, -0.01770732f, 0.24840319f, -0.26580212f, 0.10200348f, -0.30717912f, 0.19470733f, 
    0.26278681f, 0.36284825f, -0.20114735f, 0.26026440f, 0.29428855f, 0.02697251f, -0.31038126f, -0.19099508f, 
    -0.07991935f, 0.05362923f, 0.11263490f, -0.04176025f, -0.17078248f, -0.11042608f, -0.05987684f, 0.55633926f, 
    -0.15673605f, 0.21501720f, -0.08943039f, -0.02694579f, -0.16883525f, -0.13822961f, -0.11159177f, -0.13002922f, 
    0.27383110f, 0.12056378f, 0.20092349f, -0.19802500f, 0.24280533f, 0.02280522f, 0.18451796f, -0.04106542f, 
    0.01163577f, 0.29234415f, 0.60993969f, -0.48086399f, 0.22144198f, 0.19928701f, 0.08091430f, -0.37717953f, 
    -0.07405807f, -0.08496391f, -0.23217112f, 0.53863800f, 0.07593455f, 0.08647321f, 0.17422484f, -0.66374320f, 
    -0.05158488f, 0.01200552f, -0.16559638f, -0.03185825f, 0.26337522f, 0.06956267f, 0.14834799f, 0.30839425f, 
    -0.21862547f, -0.05932537f, 0.18846096f, -0.07261313f, 0.18633054f, -0.10979494f, 0.15048955f, -0.21998845f, 
    0.19060256f, 0.18292630f, -0.18600345f, 0.19839467f, 0.28655052f, 0.09042962f, -0.28834265f, 0.15546814f, 
    0.06415647f, -0.06452497f, -0.34487927f, -0.19499671f, 0.04987569f, 0.23213427f, 0.08548006f, 0.19651964f, 
    0.32077357f, 0.17916678f, -0.32993120f, 0.09473889f, -0.23009907f, 0.32598549f, -0.46072087f, -0.48910174f, 
    0.30181396f, -0.41116202f, 0.21025746f, 0.07791694f, 0.01055467f, -0.49704698f, 0.23336314f, 0.02840964f, 
    -0.12822495f, 0.15531947f, 0.47942421f, 0.76525027f, 0.18498726f, -0.24246445f, 0.24536011f, -0.76968729f, 
    0.12228444f, -0.44027880f, -0.22884366f, 0.13940863f, -0.05852185f, 0.27816841f, -0.15532537f, 0.27530256f, 
    -0.15818821f, -0.46568120f, 0.23242876f, -0.06874481f, 0.10269640f, 0.10130081f, 0.17254211f, 0.11877409f, 
    -0.02674690f, -0.05090619f, -0.04205900f, 0.15096173f, -0.39357972f, -0.48192436f, 0.11327112f, 0.17382583f, 
    0.15618402f, 0.10899154f, -0.09739102f, -0.04824185f, -0.14019243f, 0.21460527f, 0.12461589f, -0.70030206f, 
    0.36450964f, 0.11984780f, 0.04266972f, 0.18553683f, -0.03389064f, 0.22840568f, 0.14706632f, -0.34428784f, 
    -0.22813700f, 0.20276976f, -0.22414298f, -0.17767240f, 0.03536250f, 0.21744132f, -0.09541351f, 0.44073480f, 
    -0.13524726f, -0.03841306f, 0.22757781f, -0.11485240f, 0.16213119f, 0.10865126f, -0.04052242f, 0.07792807f, 
    -0.01265932f, 0.14045040f, -0.04576101f, 0.00467266f, -0.00159863f, -0.05381241f, 0.05586698f, -0.13400146f, 
    -0.06794154f, -0.08513973f, 0.03299119f, -0.13327117f, 0.25534070f, -0.34507111f, 0.17004931f, -0.21589687f, 
    -0.06674795f, 0.01385078f, 0.28884467f, 0.02979319f, -0.08154789f, 0.06934670f, 0.21939737f, -0.10473023f, 
    -0.16554108f, 0.10955023f, 0.01057903f, 0.17745131f, -0.10449068f, -0.04398901f, 0.14380433f, -0.03863627f, 
    0.16851082f, -0.02080855f, 0.00996961f, 0.09465369f, 0.46068549f, -0.01200833f, 0.11014374f, 0.50760400f, 
    0.06071131f, -0.18315248f, 0.26860952f, 0.15116994f, 0.12346675f, -0.12893017f, 0.04112646f, 0.15449896f, 
    0.17647913f, -0.01493450f, -0.18868354f, 0.03162148f, 0.05296292f, -0.02165762f, -0.17203023f, -0.09346237f, 
    0.19591403f, -0.05517789f, 0.14595969f, 0.32928759f, 0.04226960f, 0.10007040f, -0.27122030f, -0.10124382f, 
    0.31904802f, 0.07637402f, -0.17643702f, -0.05956831f, 0.31325415f, 0.18208107f, -0.01578730f, -0.00421461f, 
    0.04586548f, 0.33987141f, 0.40872270f, 0.61180425f, -0.09743825f, 0.31158572f, -0.17218907f, -0.23270243f, 
    0.10782843f, 0.01290267f, -0.04140656f, 0.06923076f, 0.16783170f, -0.00644784f, -0.12414987f, -0.22683923f, 
    0.04190518f, -0.17606747f, 0.20218427f, -0.18106346f, 0.21684849f, 0.11504319f, 0.12758414f, 0.15943046f, 
    0.12587500f, 0.00280599f, 0.10376823f, 0.08022177f, 0.19063303f, 0.00975129f, 0.12154120f, 0.20951340f, 
    -0.20210639f, -0.07080816f, 0.46395317f, -0.01022743f, -0.05216476f, -0.36885372f, -0.19174616f, 0.11279737f, 
    -0.03346213f, 0.06603168f, -0.05179833f, 0.10005657f, 0.09027970f, -0.27772498f, -0.20773549f, -0.23976117f, 
    0.03552466f, 0.48813587f, 0.09220832f, 0.09961194f, -0.02412007f, 0.20766543f, -0.22769754f, -0.15133534f, 
    0.13343351f, -0.11137789f, -0.18572752f, 0.29149333f, -0.02895003f, 0.13173766f, 0.06505775f, 0.06976923f, 
    0.03284064f, 0.35067719f, -0.23340568f, -0.00597324f, 0.13150083f, 0.14851123f, 0.17906201f, -0.14607166f, 
    0.02866586f, 0.21383181f, 0.03051913f, 0.00855820f, -0.04662043f, -0.01379122f, -0.16170149f, -0.10913407f, 
    0.03502764f, 0.02519132f, 0.17753603f, -0.13987352f, 0.03507005f, 0.05189247f, 0.02870077f, -0.10528928f, 
    0.15803286f, -0.35484669f, 0.19461116f, 0.33856937f, -0.04735660f, 0.20100662f, 0.03908765f, 0.41021213f, 
    -0.35986805f, 0.37998691f, 0.01816491f, -0.08837928f, 0.00689243f, 0.00236179f, 0.03860148f, -0.39056993f, 
    -0.14581347f, -0.17155465f, 0.58726686f, 0.04136028f, -0.02180673f, -0.35282528f, 0.47842744f, -0.75548494f, 
    0.05851674f, -0.01721026f, -0.17559645f, -0.18420254f, 0.10816548f, -0.36734995f, -0.30846587f, 0.10595031f, 
    0.06757563f, -0.19392601f, 0.24659495f, 0.24856502f, -0.17780975f, -0.14009026f, 0.13025483f, -0.09918622f, 
    -0.04727945f, -0.18168943f, -0.10277918f, -0.15052353f, -0.05681079f, 0.08399706f, 0.29362267f, 0.24452128f, 
    0.22007279f, 0.20696676f, 0.07760671f, -0.04387899f, -0.07382000f, 0.14523394f, 0.15065940f, -0.11444099f, 
    -0.02783602f, 0.22784759f, 0.39686325f, -0.00062666f, 0.17280385f, -0.39163685f, -0.07575734f, 0.17534967f, 
    0.21802281f, -0.26223418f, -0.24184741f, 0.10511716f, 0.15813522f, 0.07165373f, -0.66173989f, 0.31664595f, 
    0.14783902f, -0.05560840f, -0.45025632f, 0.05549368f, 0.17999025f, 0.05851021f, 0.31461740f, -0.36353797f, 
    0.53644222f, 0.15454660f, 0.03763484f, 0.23741339f, -0.03658352f, 0.38412708f, -0.30003914f, -0.34097177f, 
    0.01446677f, -0.30250129f, 0.09075326f, 0.22389889f, 0.11704178f, -0.33436459f, 0.11026942f, -0.16638573f, 
    -0.12352929f, 0.00212226f, 0.08663136f, 0.09382315f, 0.04551352f, -0.49548468f, 0.05924203f, -0.49338722f, 
    0.16761108f, -0.50906932f, -0.06828845f, 0.06133103f, -0.03496831f, 0.32115993f, -0.46958292f, -0.19470116f, 
    -0.01111607f, -0.26020563f, 0.22763085f, -0.00453354f, -0.09298004f, -0.01774503f, -0.07906795f, 0.24862374f, 
    0.17664453f, -0.11573867f, 0.18925957f, -0.08507273f, -0.92493135f, -0.36143160f, 0.12554255f, 0.20551622f, 
    -0.15024887f, 0.14554489f, 0.05326971f, 0.29917574f, -0.26831269f, 0.15464015f, 0.13305894f, -0.41842702f, 
    -0.21009101f, 0.08829787f, -0.18894029f, -0.29356113f, 0.19020885f, 0.27067643f, 0.03056843f, -0.39566341f, 
    -0.04109065f, -0.22440860f, 0.55393243f, -0.65107495f, 0.09744094f, -0.61216307f, 0.24422583f, -0.22027066f, 
    -0.26585948f, 0.03379756f, -0.18227886f, -0.20010214f, -0.24903996f, 0.00725740f, -0.21052378f, 0.14121972f, 
    -0.00273386f, -0.22430453f, -0.09159522f, -0.27369136f, -0.28522280f, 0.05064352f, 0.07835543f, 0.18481506f, 
    0.18239999f, 0.06102217f, -0.04490875f, -0.07541191f, -0.02738509f, -0.17880476f, 0.06289199f, -0.04805559f, 
    -0.06153664f, 0.04664673f, -0.32729661f, -0.02040854f, 0.14638717f, 0.10717043f, -0.03790564f, 0.11728845f, 
    0.04437022f, 0.25009152f, -0.06805442f, 0.31014654f, 0.47101191f, 0.12713675f, 0.34872511f, 0.06083154f, 
    0.08321089f, 0.11697200f, -0.18452427f, 0.18264535f, -0.09934364f, -0.00484309f, -0.38616976f, -0.10619459f, 
    -0.14712565f, 0.27664497f, -0.19781740f, 0.08061984f, -0.13632706f, 0.10179438f, 0.16522372f, -0.04788434f, 
    0.04526948f, 0.01380665f, 0.15936914f, 0.00586718f, -0.07137010f, -0.13921119f, 0.35404822f, -0.34561580f, 
    -0.01081470f, -0.21355301f, -0.07015418f, -0.16621421f, 0.07223164f, -0.21511105f, 0.08580474f, 0.16074334f, 
    -0.08935460f, -0.10901255f, 0.74445301f, -0.31090638f, 0.06140097f, -0.03468088f, 0.31051505f, -0.06776161f, 
    -0.18049370f, -0.22823943f, -0.41464472f, -0.01994059f, -0.08064938f, 0.01632484f, 0.28413215f, 0.38050497f, 
    0.09487137f, 0.00003981f, -0.04664156f, -0.13734695f, 0.08292279f, 0.07687501f, 0.22138250f, 0.09337399f, 
    0.09434590f, 0.18697280f, 0.01351109f, 0.02916997f, 0.15623257f, 0.06681532f, 0.14835186f, 0.00318198f, 
    0.07144362f, -0.20116156f, -0.17443590f, 0.24055737f, -0.22725347f, 0.28067961f, -0.60631996f, 0.36835515f, 
    -0.14415742f, 0.04720727f, -0.36557791f, 0.19291399f, -0.05208918f, 0.25352213f, 0.29733986f, -0.41700009f, 
    0.48468930f, 0.11274486f, 0.28214344f, 0.33780330f, -0.24152622f, -0.04176791f, 0.02256855f, -0.83352751f, 
    0.09920638f, -0.06181373f, -0.09975632f, 0.27698120f, 0.31127161f, -0.88588858f, 0.31264898f, -0.09105917f, 
    -0.03808116f, -0.16529138f, 0.17085850f, -0.39160350f, -0.31098342f, -0.24991074f, 0.08572574f, -0.20538913f, 
    0.07930570f, -0.28154069f, -0.13409270f, -0.51806796f, -0.19083014f, 0.53889704f, 0.04735215f, -0.40803853f, 
    0.28859219f, -0.04301879f, 0.39697191f, -0.03552178f, -0.27824429f, 0.18567690f, 0.02616793f, 0.34652385f, 
    0.08429724f, -0.04283661f, 0.24587730f, 0.10307837f, -0.81042618f, -0.15168633f, 0.05184339f, 0.31095183f, 
    0.09331214f, -0.05600767f, 0.09440625f, 0.30471849f, 0.21359441f, 0.07480621f, -0.47940379f, 0.14406101f, 
    0.40817750f, 0.10999266f, -0.43027616f, -0.26344740f, 0.20084070f, 0.41085368f, 0.06387050f, 0.12441598f, 
    0.18038633f, 0.16776635f, -0.43802333f, -0.13771760f, 0.14120367f, 0.47117546f, -0.30591488f, -0.62518543f, 
    -0.03065940f, -0.48922995f, 0.10994356f, 0.20066787f, -0.18625318f, -0.55946356f, -0.12119015f, 0.07562199f, 
    -0.13231261f, 0.24811146f, 0.37715599f, -0.00785409f, 0.29418954f, -0.07267395f, 0.25818783f, -0.05167862f, 
    0.00389542f, -0.32828817f, -0.19762960f, 0.15412708f, -0.02655358f, -0.06976078f, -0.16512412f, 0.31444454f, 
    -0.58215302f, -0.93292308f, 0.17233370f, 0.12660973f, 0.44401628f, 0.05890478f, 0.01231540f, -0.36527702f, 
    0.19587064f, 0.01303552f, -0.11047321f, 0.34754154f, -0.14448644f, 0.27345297f, 0.17023805f, 0.02825723f, 
    -0.03079053f, -0.04932688f, 0.09724842f, -0.22930428f, -0.27247638f, -0.04548471f, 0.10469055f, 0.15002860f, 
    0.05885390f, 0.11794029f, -0.12672170f, -0.04410525f, 0.05783914f, 0.21161386f, 0.03563318f, -0.12046767f, 
    0.01926284f, 0.03265019f, 0.71639585f, 0.21266681f, 0.08134148f, 0.14698687f, 0.37131575f, -0.10034762f, 
    -0.12186963f, -0.02675301f, 0.01759493f, 0.16789733f, 0.17155348f, -0.08708889f, 0.18512902f, 0.13684827f, 
    0.03104163f, -0.00980343f, -0.17133027f, 0.10209903f, -0.10012911f, -0.18304196f, 0.10648534f, 0.12950779f, 
    -0.12555660f, -0.25841209f, -0.19761795f, -0.32089731f, 0.09267107f, 0.10240161f, -0.03548943f, 0.25634089f, 
    0.08815105f, 0.07364354f, 0.36263800f, 0.07915556f, -0.24460477f, 0.18121383f, 0.18991181f, 0.03105245f, 
    0.00527388f, 0.13899319f, -0.04790961f, 0.37270465f, -0.23094691f, 0.01759623f, -0.09028857f, 0.14545637f, 
    0.12209043f, -0.36087376f, 0.02148308f, 0.04400028f, 0.49946678f, 0.00686909f, -0.09508029f, 0.13582717f, 
    0.20037040f, -0.36309561f, 0.15390088f, 0.36361539f, 0.29679555f, -0.24407859f, -0.05748769f, 0.18887308f, 
    0.41732267f, -0.30223745f, 0.02297429f, 0.08968305f, -0.04587484f, 0.17344457f, -0.15785006f, 0.29570988f, 
    0.30233595f, -0.20978981f, -0.02276016f, 0.44226909f, 0.04309838f, 0.24392097f, -0.38141468f, -0.22570768f, 
    0.42970806f, -0.11456677f, -0.34421340f, 0.48679897f, 0.34603691f, -0.32328495f, 0.03282505f, -0.31590620f, 
    -0.01299971f, 0.13837360f, -0.17745733f, 0.60333061f, -0.26161230f, 0.46286485f, -0.49150825f, 0.01594034f, 
    0.20753056f, 0.12636593f, 0.12070473f, 0.08444437f, 0.15372302f, -0.05655707f, 0.10508339f, 0.17991765f, 
    0.30540368f, -0.08293428f, -0.05050032f, -0.02318966f, 0.10410040f, -0.29017419f, -0.04686663f, 0.15762851f, 
    0.14334773f, -0.28273720f, -0.03524676f, 0.12761208f, -0.05312961f, 0.11197034f, 0.19927582f, -0.06323533f, 
    -0.15088192f, 0.17016286f, 0.14269255f, -0.10756932f, 0.21947932f, 0.13360229f, 0.02350391f, 0.06066095f, 
    0.08110458f, -0.42463896f, 0.77171540f, 0.13594234f, 0.02206402f, -0.20188756f, 0.56151742f, 0.23086010f, 
    0.21037240f, 0.14935194f, 0.17648171f, -0.29750830f, 0.14046216f, -0.32804525f, -0.78383517f, -0.10141075f, 
    0.43280566f, -0.39329585f, -0.59488100f, -0.02652123f, -0.02100284f, -0.19435267f, 0.27478975f, -0.21273802f, 
    -0.05779664f, -0.08481897f, -0.36315334f, -0.08501484f, -0.24189508f, 0.42193252f, -0.03218793f, 0.07054896f, 
    0.21646363f, 0.08964410f, 0.46705291f, -0.05543076f, -0.05968220f, -0.01741974f, 0.22423521f, 0.16236126f, 
    0.17796209f, -0.01556753f, 0.38675889f, 0.14952828f, 0.29947874f, 0.15330705f, 0.30680087f, 0.29283157f, 
    0.11419787f, -0.01968449f, 0.09208070f, 0.00676596f, -0.04876566f, -0.01762803f, 0.10855335f, -0.10915564f, 
    -0.12344795f, -0.08067673f, -0.12312929f, -0.07847752f, 0.07383002f, -0.10439998f, 0.04966769f, 0.10034801f, 
    0.01005946f, -0.05148013f, 0.04313879f, -0.05413191f, -0.02100034f, -0.02498752f, -0.01889613f, -0.02602401f, 
    -0.02121183f, -0.04573257f, -0.11169864f, -0.04151316f, -0.08180864f, -0.07184926f, 0.05247158f, -0.00991070f, 
    0.11484487f, 0.09963731f, -0.04088719f, 0.12163360f, 0.04468171f, -0.03972740f, -0.10940427f, -0.03658360f, 
    -0.03332599f, -0.03189854f, 0.11181948f, -0.05427441f, -0.07099406f, 0.04926604f, 0.01360050f, 0.03133287f, 
    -0.12260526f, 0.03226227f, -0.02284661f, -0.09250273f, -0.11185229f, -0.12332553f, 0.02032368f, -0.00979367f, 
    -0.07248402f, -0.11244456f, -0.04820684f, 0.11273862f, -0.05540942f, -0.07982747f, 0.07055266f, -0.04398473f, 
    0.12033530f, 0.03521169f, -0.02451636f, 0.23938498f, 0.19488457f, 0.00869010f, -0.29928595f, -0.24854130f, 
    0.15659399f, -0.08585756f, -0.22678109f, -0.21026652f, 0.04214897f, 0.31668046f, -0.00698972f, 0.11124095f, 
    0.01979575f, -0.01383995f, -0.58036041f, -0.01744039f, 0.07107137f, 0.37951988f, -0.26067424f, -0.56989896f, 
    0.09667291f, -0.67234445f, 0.25772044f, 0.23824994f, 0.06414016f, -0.18494637f, -0.35832754f, 0.12014527f, 
    0.10644539f, 0.24961388f, 0.32108709f, -0.18374363f, 0.47614238f, 0.07964037f, -0.02993811f, -0.04774666f, 
    -0.11685786f, -0.06724451f, 0.30532709f, 0.51754576f, -0.07793878f, 0.07459226f, -0.29101166f, -0.18761419f, 
    -0.22462875f, -0.46345851f, -0.03701651f, -0.02599387f, 0.34022394f, 0.04003359f, -0.00200928f, 0.03083169f, 
    0.10160629f, -0.01113441f, 0.03996214f, -0.00838881f, -0.02950922f, 0.35568795f, 0.07816812f, 0.02283144f, 
    0.11498964f, 0.23075961f, -0.14977525f, 0.01207497f, -0.08773520f, 0.00111199f, -0.23724033f, -0.23792458f, 
    0.07635196f, 0.28447738f, -0.45371842f, -0.64015692f, 0.00971982f, 0.33008137f, 0.13991529f, -0.04538738f, 
    0.04945527f, 0.20239365f, 0.59594399f, -0.16447563f, -0.07391863f, 0.39710063f, 0.40282944f, 0.18470895f, 
    -0.02989300f, -0.30935118f, -0.02748523f, -0.20923458f, 0.14485775f, 0.24649353f, 0.07997128f, 0.13797517f, 
    -0.31106481f, -0.06996875f, 0.21281041f, -0.16270408f, -0.18678708f, -0.35962909f, 0.18707000f, 0.02816724f, 
    0.07774220f, -0.75333756f, -0.38557044f, -0.22861457f, 0.16466342f, -0.20249636f, -0.18369034f, -0.24668525f, 
    -0.39167297f, 0.01654464f, 0.20182815f, -0.04743411f, -0.05887859f, 0.28660062f, 0.25175196f, 0.11637768f, 
    -0.04761246f, 0.10789040f, -0.09804323f, 0.41136354f, -0.12475505f, -0.29058331f, 0.11567613f, 0.20584552f, 
    0.06986128f, 0.01920288f, -0.03099759f, 0.27620205f, -0.09044553f, -0.01396848f, 0.03167363f, -0.13651128f, 
    -0.40344507f, 0.00928452f, 0.02639309f, -0.05152118f, 0.05437719f, 0.15619886f, 0.05856616f, 0.27775770f, 
    -0.09996071f, -0.06738538f, 0.37176204f, 0.19106157f, 0.16224295f, -0.27735034f, 0.16702187f, 0.29985049f, 
    0.25487214f, -0.11303862f, 0.17109960f, -0.11136051f, 0.24958862f, 0.22751758f, -0.26460451f, 0.03523557f, 
    0.17590389f, 0.00701212f, 0.17039061f, -0.27179143f, 0.04508991f, 0.06716973f, 0.01047722f, -0.00778242f, 
    0.03726020f, 0.03763548f, 0.06368209f, 0.24957776f, -0.13427098f, 0.19373524f, -0.05459329f, -0.09743378f, 
    0.26775208f, -0.03251000f, 0.01190934f, -0.06093197f, 0.04121907f, 0.06500717f, 0.09683373f, 0.50809771f, 
    -0.08423304f, 0.03971367f, 0.19379832f, -0.06620251f, 0.27638295f, 0.20151763f, 0.30973011f, 0.03306800f, 
    -0.08600385f, -0.04833381f, -0.06026751f, 0.31059247f, -0.22793350f, 0.16896707f, -0.11378117f, -0.04856068f, 
    0.14774452f, 0.18042715f, -0.14034350f, 0.03122937f, 0.04531986f, 0.46375114f, 0.11336923f, 0.11913934f, 
    -0.14702691f, -0.15644376f, -0.16169155f, 0.08673196f, 0.18142027f, 0.29867047f, 0.17228091f, -0.17556792f, 
    0.16543098f, -0.49844125f, 0.01695725f, -0.20820051f, 0.04432594f, -0.15134354f, -0.30162919f, 0.20584737f, 
    0.05130602f, 0.11918549f, 0.03774168f, 0.11365696f, -0.04260809f, -0.02570921f, 0.19020967f, -0.25030231f, 
    -0.21795574f, -0.22542858f, 0.29896307f, 0.00406745f, -0.06489993f, -0.15538187f, -0.04661079f, 0.48779866f, 
    -0.15646137f, -0.27865991f, 0.20223662f, -0.09864020f, -0.00300811f, 0.14737450f, 0.21062085f, -0.05709070f, 
    -0.04903194f, 0.14244546f, 0.05203876f, 0.31578889f, 0.11432332f, -0.25125489f, 0.11356788f, 0.11489820f, 
    0.14589098f, 0.04345050f, 0.27654347f, -0.04418295f, 0.46705419f, 0.03636331f, -0.02012594f, 0.39466283f, 
    0.05579472f, 0.02229656f, 0.26502511f, 0.14730029f, 0.17018059f, -0.11871070f, -0.13381632f, -0.06896999f, 
    0.04010407f, -0.08785155f, -0.07137359f, -0.01797050f, -0.17991221f, -0.35855937f, -0.12901641f, -0.49232039f, 
    0.06982988f, 0.21267834f, -0.24097697f, -0.10371763f, -0.03952694f, -0.00877233f, -0.00582590f, -0.10093789f, 
    0.08112074f, -0.09982790f, 0.08111031f, -0.36612958f, -0.15445122f, 0.13913076f, 0.02348190f, -0.00912817f, 
    0.02991363f, 0.24524306f, -0.22452869f, 0.19758864f, 0.10764877f, 0.03203503f, 0.23907357f, -0.23994726f, 
    0.02146330f, 0.09628310f, -0.20957544f, 0.06642146f, 0.19292469f, 0.03972767f, 0.07242353f, -0.11948013f, 
    0.24553570f, 0.09191076f, 0.08749709f, 0.00542665f, 0.35412744f, 0.02787261f, -0.08101583f, -0.14361766f, 
    0.28582826f, 0.12500472f, -0.38004205f, -0.02111810f, 0.10213027f, 0.15909149f, -0.22881387f, -0.25768051f, 
    0.00841432f, 0.20616806f, 0.03175930f, 0.08826147f, -0.27288428f, -0.14317819f, 0.00157791f, 0.02575976f, 
    0.13701320f, 0.27339828f, 0.14453276f, 0.18854979f, -0.52524984f, -0.16473810f, 0.17604627f, 0.46123293f, 
    -0.01349401f, 0.38498276f, 0.10531877f, -0.32366043f, 0.24069721f, 0.46145135f, -0.28357980f, 0.01709811f, 
    -0.21849409f, 0.21765287f, 0.55704588f, -0.32007322f, -0.06352805f, 0.14926450f, 0.08962860f, -0.28774595f, 
    0.06138571f, -0.08288939f, -0.60628629f, 0.04394659f, 0.00549203f, 0.03525797f, 0.27440041f, -0.77716470f, 
    0.22017841f, 0.23009597f, -0.08198974f, -0.05071398f, -0.11052970f, 0.17787755f, 0.13919210f, 0.42737982f, 
    -0.19693562f, -0.08350889f, 0.10673568f, -0.15233509f, 0.19994649f, -0.13550495f, 0.06555281f, -0.18434656f, 
    0.10855584f, 0.29168212f, -0.38237697f, 0.03580030f, 0.01353718f, 0.04540091f, -0.57640916f, -0.25627825f, 
    0.54254979f, 0.22340429f, -0.16668573f, -0.89313090f, 0.01176351f, 0.11809831f, -0.47285554f, 0.08554225f, 
    0.08027504f, 0.24328992f, 0.06383665f, -0.08418383f, -0.41089439f, 0.39716163f, 0.31586057f, 0.46245980f, 
    0.11251988f, -0.09386107f, -0.15772663f, -0.33053854f, -0.20860137f, 0.34663492f, 0.06702700f, 0.20838661f, 
    -0.91738963f, -0.15898393f, 0.51760679f, 0.44378355f, -0.15205985f, -0.43452162f, 0.35771975f, -0.05198801f, 
    0.07266244f, -0.58866912f, -0.32147357f, 0.08467215f, 0.07429906f, -0.25631765f, 0.07481255f, 0.44409597f, 
    -0.33552215f, 0.09688038f, -0.16222844f, -0.18183814f, 0.44977689f, 0.21209198f, 0.18372197f, 0.07545502f, 
    0.37498149f, 0.22433138f, -0.29540494f, 0.18851480f, 0.16162616f, -0.56883132f, 0.15283844f, -0.14178224f, 
    -0.05359832f, -0.10592528f, 0.13650829f, 0.15213697f, 0.34954461f, -0.11161967f, -0.10245601f, 0.21371694f, 
    0.50300151f, -0.22604832f, 0.16889110f, 0.08035845f, 0.05268252f, 0.00826145f, -0.12609397f, 0.18974884f, 
    0.02414840f, -0.17990540f, -0.72608936f, -0.16362558f, 0.22290553f, 0.27379897f, -0.47631666f, -0.42179975f, 
    0.20489317f, -0.14968482f, 0.26695547f, 0.03920719f, -0.15580228f, -0.14350422f, -0.52317899f, 0.11066423f, 
    0.03544342f, 0.14822966f, -0.09768172f, 0.08769424f, 0.33482629f, 0.14645436f, 0.00448069f, -0.00298112f, 
    0.00937021f, 0.21755801f, 0.21028636f, 0.34040767f, -0.14126204f, 0.13344118f, -0.02568698f, -0.28758657f, 
    -0.15593578f, -0.07138763f, 0.15298346f, -0.08553855f, 0.42832768f, 0.09129860f, 0.00613647f, -0.39425433f, 
    0.04630931f, -0.02194142f, 0.03279946f, -0.07878996f, 0.17736675f, 0.09826900f, 0.09771620f, -0.22007315f, 
    0.06820542f, 0.05024940f, 0.08831248f, 0.29795325f, 0.05139221f, 0.06456989f, 0.19838771f, -0.19378033f, 
    -0.27318987f, 0.12039278f, -0.11503956f, -0.17424621f, 0.12915455f, 0.11973768f, 0.14758754f, 0.26674762f, 
    -0.10148679f, -0.27674809f, 0.42915201f, 0.02647019f, 0.00425347f, -0.32024482f, 0.41244224f, 0.25831482f, 
    0.22313364f, -0.07780305f, 0.31946182f, -0.17030661f, 0.23573384f, 0.07489107f, -0.41114488f, 0.05490168f, 
    0.32352689f, -0.03342268f, -0.28963569f, 0.05012422f, 0.11314366f, 0.08695190f, 0.02094012f, 0.01912983f, 
    -0.01498719f, 0.08254230f, 0.17045482f, 0.23229288f, -0.17209998f, 0.21677813f, -0.04706062f, -0.04731128f, 
    0.12271902f, 0.00449668f, 0.22591144f, 0.06524333f, -0.26093164f, 0.17862998f, 0.20089768f, 0.51520008f, 
    -0.08650022f, -0.05322984f, 0.20888864f, 0.05040543f, 0.42260686f, 0.23363405f, 0.23106191f, 0.29236954f, 
    -0.05113649f, -0.07709449f, -0.05907948f, 0.05584604f, 0.06861689f, -0.04480689f, 0.02729642f, 0.01122582f, 
    0.08233541f, -0.06691083f, 0.09761287f, -0.07799295f, 0.00190361f, 0.07800385f, -0.11015238f, -0.09097947f, 
    -0.04822531f, -0.14095519f, 0.03704233f, -0.10389411f, -0.14420234f, 0.10432024f, 0.08778936f, 0.01691528f, 
    -0.09774075f, 0.09887723f, 0.01916660f, 0.02708307f, -0.00250122f, 0.01306996f, -0.09891515f, -0.14757188f, 
    -0.09375054f, 0.04088752f, -0.01493711f, 0.07143091f, -0.06716570f, -0.10621698f, -0.11862402f, -0.12513334f, 
    -0.11988522f, 0.02151922f, 0.05069923f, -0.04011448f, -0.02170565f, -0.04356670f, -0.02157178f, -0.06597974f, 
    -0.06524719f, -0.05772132f, -0.01049387f, 0.01040860f, 0.06859878f, -0.06641026f, -0.12324790f, 0.06238657f, 
    0.05817852f, -0.08921721f, -0.00598915f, -0.09319840f, 0.06144793f, 0.02654011f, -0.02135871f, 0.09358086f, 
    0.10931934f, 0.11877419f, -0.09320685f, -0.13115278f, 0.03608400f, 0.18859765f, -0.13754815f, 0.28631040f, 
    -0.32401225f, -0.06326981f, 0.08312772f, 0.23782967f, 0.00230828f, -0.09092892f, 0.13165838f, -0.09057061f, 
    0.48980528f, 0.29436380f, 0.27914962f, 0.34898993f, -0.83419842f, -0.35512874f, -0.41903725f, 0.17514367f, 
    0.07670594f, 0.51641852f, 0.06514458f, 0.09252954f, 0.12870860f, 0.12275550f, 0.13494942f, -0.25761452f, 
    -0.07198092f, -0.06003981f, 0.14251007f, 0.00308746f, -0.18959549f, -0.11980776f, 0.20597105f, -0.20296292f, 
    0.09571043f, -0.46840277f, -0.05348470f, -0.26080334f, -0.16846113f, 0.36859646f, -0.05764850f, -0.08731936f, 
    0.35305333f, 0.31765267f, 0.02569737f, -0.00945668f, -0.37487954f, 0.26614535f, 0.01769595f, 0.36628297f, 
    -0.07436951f, -0.11582618f, 0.03569892f, -0.08664653f, -0.27692193f, -0.64336264f, 0.08897948f, 0.04521126f, 
    0.18356851f, -0.02417550f, 0.02301151f, 0.16421679f, 0.05646098f, 0.26294154f, -0.02894540f, 0.14193085f, 
    -0.04347706f, 0.34035197f, -0.14927420f, -0.10383578f, -0.01973531f, 0.24292244f, 0.13543504f, -0.47701272f, 
    -0.04327485f, 0.07865639f, -0.13438590f, -0.00427484f, -0.05948620f, -0.14388348f, -0.21790065f, -0.55442619f, 
    0.08128010f, -0.20272148f, -0.17174847f, 0.02767043f, 0.00209424f, -0.16439992f, -0.18142322f, 0.16791244f, 
    0.00144107f, 0.04855641f, 0.33096328f, -0.05709841f, -0.00038696f, 0.04821006f, 0.05475239f, -0.20659995f, 
    0.06310506f, 0.04526009f, 0.18963124f, -0.21101719f, 0.07486166f, 0.04085249f, 0.16627321f, -0.03391729f, 
    0.20085998f, -0.08498669f, -0.01008464f, 0.01563877f, 0.08821478f, 0.20699358f, 0.07953305f, -0.06326713f, 
    -0.03773725f, 0.20487556f, 0.15468176f, 0.00625340f, 0.13625899f, -0.14280032f, 0.09097214f, 0.11295242f, 
    -0.13087344f, -0.05356993f, -0.06664198f, 0.03267214f, 0.03657487f, -0.11304204f, 0.03754440f, 0.04982366f, 
    -0.05452881f, -0.01305022f, -0.08075242f, 0.01537117f, -0.02629160f, -0.07211946f, 0.03416294f, 0.02537836f, 
    -0.05288775f, 0.01483578f, 0.11699439f, 0.07943010f, -0.06221069f, -0.02537858f, 0.05364186f, -0.02429523f, 
    0.07065006f, -0.04673225f, -0.14927699f, -0.10371960f, -0.10560871f, -0.04275997f, -0.10217962f, -0.10742345f, 
    -0.00105124f, -0.12743539f, -0.08917531f, 0.10393429f, -0.07544021f, -0.01448042f, -0.07140801f, 0.04852117f, 
    0.03134193f, -0.05544108f, 0.02805542f, -0.12486348f, 0.01797424f, -0.09426422f, -0.02102076f, 0.02151141f, 
    -0.01356132f, -0.04699553f, 0.07606112f, -0.01609120f, -0.05875236f, -0.09841728f, -0.12030944f, 0.05120790f, 
    0.01636586f, -0.06891990f, -0.07960933f, 0.07253369f, -0.10330970f, -0.01897295f, -0.02374948f, 0.07932244f, 
    0.14646645f, 0.07642845f, -0.13685808f, 0.26595783f, 0.02653149f, -0.07521602f, -0.41262472f, -0.15278317f, 
    0.03820218f, -0.01104572f, -0.17692490f, 0.00081298f, -0.12535691f, 0.17371403f, 0.34379449f, 0.72426200f, 
    -0.03316366f, 0.06124528f, -0.25978363f, 0.04030898f, 0.06350560f, 0.14039366f, -0.37224361f, -0.41263485f, 
    0.00373333f, -0.19474769f, 0.19923891f, 0.17393100f, -0.04541894f, -0.35785872f, 0.15221116f, -0.06348410f, 
    0.02902782f, 0.29452863f, 0.20799354f, -0.51983345f, 0.36075005f, 0.06422233f, 0.04446098f, -0.09942856f, 
    0.19064216f, -0.01816859f, 0.28416765f, 0.38960019f, -0.08022176f, 0.15835340f, -0.30889541f, -0.10606907f, 
    -0.10612811f, -0.36073971f, 0.08897257f, 0.13383952f, 0.06880248f, 0.13494007f, -0.17498338f, 0.23840065f, 
    0.06608681f, 0.02189736f, -0.18382762f, -0.06884330f, -0.37715423f, 0.20840628f, 0.14085813f, -0.03694042f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.40312597f, 0.06580232f, -0.13445877f, 0.17894539f, 0.24542321f, -0.35045952f, 0.06193647f, -0.14807110f, 
    0.42228368f, -0.05362758f, 0.14889447f, 0.03560535f, -0.04639142f, 0.22561096f, 0.18273361f, -0.07402755f, 
    0.05354109f, -0.00087669f, -0.02434429f, -0.04122582f, -0.00574455f, 0.11402776f, -0.13023111f, 0.35615632f, 
    0.07045680f, -0.04269969f, 0.37842724f, 0.25508693f, 0.16283588f, 0.05659261f, 0.02052543f, -0.10907920f, 
    0.05345098f, -0.00083933f, -0.15458179f, 0.04068514f, 0.23258990f, 0.22246663f, 0.10546163f, -0.26146397f, 
    0.11780696f, 0.17837784f, 0.28432134f, -0.02347561f, 0.16466057f, 0.39760363f, 0.02343850f, 0.19476810f, 
    0.11442641f, 0.06970321f, 0.14737153f, 0.24708797f, 0.00106821f, 0.09235792f, -0.05171329f, 0.19311409f, 
    0.09992386f, -0.04967089f, 0.31473985f, -0.05331005f, 0.24784897f, 0.49864608f, -0.04960473f, 0.00673661f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.05257981f, -0.04046762f, 0.02408666f, -0.58615106f, -0.26309741f, 0.51627088f, -0.01938634f, 0.07841524f, 
    -0.45366994f, -0.00414178f, 0.24303767f, -0.23849988f, -0.09582565f, -0.02075677f, -0.12832832f, -0.04452343f, 
    0.26154676f, 0.01417548f, -0.05153330f, 0.01158051f, -0.02361564f, 0.14932106f, -0.48937896f, 0.36892200f, 
    0.03851875f, 0.21518618f, -0.19343421f, -0.12866904f, -0.37079129f, -0.09266976f, -0.08083355f, 0.06836534f, 
    -0.23145095f, -0.17762865f, -0.07177105f, 0.07151033f, -0.01066098f, -0.40083337f, 0.06701181f, 0.20006894f, 
    -0.13705456f, -0.04322978f, -0.70196438f, -0.42650285f, -0.08333490f, -0.92739713f, -0.13547945f, 0.23347235f, 
    0.09196494f, 0.05755852f, -0.18474613f, 0.05978290f, 0.13516200f, -0.40496582f, 0.08217429f, 0.04978105f, 
    -0.26214024f, -0.05668928f, 0.07204288f, -0.02398688f, 0.16317093f, -0.47788060f, -0.03710028f, -0.02940464f, 
    0.28976223f, -0.08478655f, -0.05752759f, 0.12064448f, 0.28444245f, -0.91665745f, 0.08719388f, -0.02876667f, 
    0.07804234f, 0.08365826f, 0.34789988f, -0.26661384f, 0.45036575f, 0.16623454f, -0.27892315f, -0.01120786f, 
    0.17868808f, -0.06788944f, -0.10133015f, -0.06861851f, -0.04290348f, 0.22344892f, -0.44906193f, 0.09813334f, 
    0.05815187f, -0.05112705f, 0.03534589f, -0.65006763f, 0.09047130f, -0.16447552f, -0.10791775f, 0.05671839f, 
    -0.00968452f, 0.21822111f, 0.14540169f, -0.08476779f, -0.08084206f, -0.26754513f, -0.00366206f, 0.12589490f, 
    0.26788145f, 0.08732008f, 0.22643411f, -0.02030887f, 0.26070413f, -0.61457890f, 0.04544847f, 0.12375730f, 
    0.05361888f, 0.12177417f, -0.58522290f, -0.10272444f, -0.02746968f, -0.25208041f, 0.15887223f, 0.18009298f, 
    -0.45288742f, -0.46678540f, 0.02084321f, 0.07558072f, 0.51543194f, 0.09013782f, 0.10757611f, -0.27848724f, 
    0.23872992f, -0.04563838f, 0.04645048f, 0.24554457f, -0.34095490f, -0.65580666f, 0.02470410f, 0.05981598f, 
    -0.19138156f, -0.03785657f, 0.09422521f, 0.10555705f, -0.18266191f, 0.14148378f, 0.17287353f, 0.08582947f, 
    0.28566942f, 0.01634111f, -0.07353804f, -0.05472363f, -0.01631362f, -0.21427828f, -0.09055126f, 0.13445494f, 
    -0.72612953f, 0.01765510f, 0.07156388f, 0.37085474f, -0.67500639f, 0.11877357f, -0.09134380f, 0.11631884f, 
    -0.39320216f, -0.08501992f, -0.24676350f, -0.91755545f, 0.38808095f, -0.00879148f, -0.12815887f, 0.19998015f, 
    -0.22315086f, 0.34831300f, -0.01792769f, -0.13769384f, 0.32086802f, 0.33432031f, 0.09975617f, -0.23238783f, 
    -0.32376140f, 0.04557967f, -0.04480138f, 0.29842335f, -0.28714386f, -0.10675979f, -0.15184432f, -0.13602236f, 
    0.08144347f, -0.21130194f, -0.39350721f, 0.05029769f, -0.62908840f, 0.01261560f, -0.09087099f, 0.10564036f, 
    -0.23419529f, 0.00395712f, -0.05683343f, -0.34297720f, -0.56243992f, -0.08419830f, -0.10556912f, 0.07833953f, 
    -0.19334814f, -0.15775444f, 0.16580273f, -0.15386595f, -0.03858969f, -0.67528355f, 0.23946880f, -0.04067800f, 
    -0.27325368f, 0.11358011f, -0.09295814f, -0.03068014f, -0.09158535f, -0.00685778f, 0.12585649f, -0.23047772f, 
    0.09499333f, 0.22850507f, 0.07267773f, 0.12028020f, -0.25214687f, -0.01285880f, 0.07369409f, -0.03046685f, 
    -0.68795514f, -0.24903232f, -0.85041785f, 0.06917314f, -0.04561366f, 0.07313361f, 0.04428935f, 0.00782886f, 
    -0.40264207f, 0.02972881f, -0.96264803f, -0.11027029f, -0.15696184f, 0.00533189f, 0.00061025f, 0.18143654f, 
    0.06374872f, -0.12385270f, 0.11344268f, 0.23887366f, 0.12528788f, -0.17311160f, -0.01991516f, 0.13694505f, 
    0.52219963f, 0.00511656f, 0.19676423f, -0.11432306f, -0.03423195f, -0.18141337f, 0.06609987f, 0.08065967f, 
    -0.82389754f, -0.05583791f, 0.01791424f, -0.04583254f, -0.20478596f, -0.14817052f, -0.10561593f, -0.07821752f, 
    0.08649181f, 0.11515242f, 0.05725667f, 0.06884602f, 0.01156903f, 0.08092097f, -0.31881195f, -0.04604284f, 
    -0.29547924f, 0.07285349f, 0.02755374f, 0.03810290f, 0.03735568f, 0.05976877f, -0.25223574f, -0.83145511f, 
    0.08915403f, -0.27109617f, 0.10014276f, 0.13774778f, -0.55920273f, -0.11671302f, -0.01582756f, -0.02626264f, 
    0.08312638f, -0.05428203f, -0.06738137f, 0.16661760f, 0.23099771f, -0.33545366f, 0.11872024f, 0.15602237f, 
    -0.02142072f, 0.03734564f, -0.00823441f, -0.03854602f, 0.12975243f, 0.35922718f, -0.18303345f, 0.05275042f, 
    -0.06043096f, -0.07510249f, 0.17406382f, -0.71605551f, 0.00479956f, 0.06094744f, 0.16840328f, -0.22570406f, 
    -0.43912596f, 0.30471295f, 0.04047329f, 0.07784121f, -0.18191995f, -0.01177873f, 0.06267603f, 0.13485633f, 
    0.05695097f, 0.06174816f, 0.04895556f, 0.40038466f, -0.08685510f, -0.30042198f, 0.04384943f, 0.01231319f, 
    0.05532375f, 0.25179434f, 0.04391949f, -0.36016145f, -0.36285248f, 0.00985981f, -0.06564398f, -0.03224833f, 
    0.10283614f, -0.09806503f, 0.07215281f, 0.04865684f, 0.12493072f, 0.02115572f, 0.10150208f, -0.02192523f, 
    -0.02290048f, 0.05755543f, -0.16146439f, -0.05408735f, 0.12541571f, -0.09305773f, 0.07877249f, -0.15123208f, 
    0.22068422f, 0.43369454f, -0.07458664f, -0.08233558f, 0.19473399f, -0.12673698f, 0.09823627f, -0.08512539f, 
    0.24328171f, 0.23797946f, -0.60733742f, 0.03627611f, 0.31859967f, 0.12012210f, -0.01105448f, 0.13228405f, 
    0.04098450f, 0.12118755f, 0.09616661f, -0.07334171f, 0.06600925f, 0.12831186f, -0.00336920f, -0.19365828f, 
    -0.63453299f, 0.06646854f, -0.04738454f, 0.09819408f, 0.03366859f, 0.06750415f, -0.02308355f, 0.09485748f, 
    0.29178056f, -0.00627090f, 0.12006705f, -0.19084379f, -0.18730491f, -0.15260865f, -0.07297475f, 0.10926934f, 
    -0.28449777f, -0.11903259f, -0.58982146f, 0.38424268f, 0.01495216f, 0.22272454f, 0.16475584f, -0.05793205f, 
    0.41336530f, 0.12049662f, -0.09969302f, -0.05425269f, -0.03327034f, -0.53183085f, 0.22320989f, 0.14947379f, 
    -0.81029278f, 0.24774119f, 0.25968102f, 0.22158289f, 0.01088778f, -0.22530481f, -0.05899708f, -0.12229428f, 
    0.06097637f, -0.06932932f, 0.36632165f, -0.48978388f, -0.50888646f, 0.17638996f, -0.46343535f, -0.14685622f, 
    -0.18508263f, -1.10688448f, -0.28832945f, -0.34946784f, -0.54425746f, 0.04761708f, 0.25129625f, -0.60801035f, 
    -1.10535944f, -0.00746405f, -0.41717547f, 0.43202153f, -0.84361410f, 0.16307427f, -0.07517510f, -0.29844427f, 
    0.30390689f, -0.28420547f, -0.81710678f, -0.01777305f, -0.38898018f, 0.00376008f, -0.03892778f, -0.51791012f, 
    -0.67563891f, 0.03474095f, -0.12566341f, 0.13540876f, 0.02289496f, 0.41489604f, 0.04254733f, -0.05029831f, 
    0.19587502f, -0.27112374f, -0.38850328f, 0.21334329f, -0.37026510f, -0.03446523f, -0.03234733f, -0.05000217f, 
    -0.54563743f, 0.09300230f, -0.09982682f, -0.11659092f, -0.25374430f, 0.11333429f, -0.41037983f, -0.11997996f, 
    0.22975454f, -0.08890512f, 0.12922943f, -0.60709614f, 0.09126519f, 0.11997859f, 0.08698690f, 0.11072981f, 
    -0.01559103f, 0.03988358f, -0.24378034f, 0.33691916f, -0.98889220f, 0.09839357f, 0.04051527f, 0.19330522f, 
    0.02844030f, -0.33371568f, -0.44717425f, 0.07564348f, -0.58164459f, -1.06011486f, -0.44307721f, -0.52782851f, 
    -1.08564484f, -0.08247697f, -0.65558314f, -0.46941641f, -0.10402714f, -0.19583808f, 0.19507341f, 0.43650228f, 
    0.34337538f, 0.23443031f, -0.23645879f, 0.09181467f, -0.18012796f, 0.09386729f, -0.03519934f, -1.02319610f, 
    0.23506868f, -0.07390729f, 0.10791822f, 0.17692874f, 0.18188448f, -0.86151111f, 0.02424670f, -0.05365219f, 
    0.14682983f, -0.47205347f, -0.56726974f, -0.30086622f, -0.66271025f, -0.24624865f, -0.09380709f, 0.01932383f, 
    -0.11745701f, 0.03502283f, 0.10477093f, -0.14122465f, 0.20770030f, 0.13425939f, 0.33320874f, 0.17158896f, 
    0.06377008f, 0.19330852f, -0.06008332f, -0.77109241f, -0.22682922f, -0.05890763f, -0.09950474f, -0.01247946f, 
    -0.26714495f, -0.55922693f, -0.06256478f, -0.51138794f, -1.24193227f, 0.03230318f, -0.14548528f, -0.10511226f, 
    0.25423965f, -0.40503180f, 0.17489348f, 0.00108860f, -0.07520381f, -0.31843516f, 0.16847588f, -0.19867340f, 
    0.48964360f, -0.06239749f, -0.17923960f, -0.32282585f, 0.07629134f, 0.28460431f, -0.25474897f, -0.05593599f, 
    -0.42618412f, -0.17447014f, 0.37274054f, -0.00935423f, -0.11617187f, 0.13168764f, 0.09375865f, -0.31067470f, 
    -0.23587644f, 0.10459541f, -0.03550536f, -0.33169511f, -0.48339000f, -1.02057171f, 0.10859191f, 0.07899399f, 
    0.25080225f, -0.72618288f, -0.12891366f, 0.04986421f, 0.06522299f, 0.10605738f, 0.24695580f, 0.02336858f, 
    0.04106617f, -0.12020651f, -0.12219341f, -0.13472050f, -0.21577947f, -0.04100984f, -0.20270205f, 0.07684518f, 
    -0.53203028f, 0.13277452f, 0.27170441f, 0.39656439f, 0.19696730f, -0.45254287f, -0.04072883f, -0.06957812f, 
    -0.07365023f, 0.06806342f, -0.55510837f, -0.33325037f, 0.01586360f, 0.08882757f, 0.16372287f, -0.48805180f, 
    -0.58836520f, -0.04120612f, 0.14623427f, -0.43214804f, -0.42709491f, 0.27621642f, -0.22379112f, 0.39314255f, 
    -0.32253638f, 0.02345520f, 0.38003710f, -0.29260537f, -0.31152901f, 0.02276516f, 0.02802499f, -1.04463792f, 
    -0.03853830f, 0.50236213f, -0.06067260f, 0.01393952f, -1.11635411f, 0.17792040f, -0.01261610f, -0.01600922f, 
    -0.33872411f, -0.08137906f, -0.02396365f, -0.49072403f, 0.10861570f, 0.03285478f, -0.00880214f, 0.08972363f, 
    0.21275377f, -0.39893806f, -0.45834121f, -0.19476300f, -0.15133765f, -0.36415005f, 0.14386716f, -0.05131787f, 
    0.06324991f, -0.02649856f, -0.06748679f, 0.06231862f, 0.16294734f, 0.14408128f, 0.26948571f, -0.22260220f, 
    0.19853528f, -0.48279551f, -0.07955432f, -0.56266952f, -0.60128218f, -0.85934603f, -0.06018850f, -0.05511167f, 
    -0.80854851f, 0.32286471f, -0.36605883f, 0.25403255f, 0.01689292f, 0.08402151f, -0.38565207f, -0.50875926f, 
    -0.05150800f, -0.19183041f, -0.22135380f, 0.16034849f, 0.13278493f, -0.07852125f, -0.04558360f, -0.95428032f, 
    -0.25182295f, 0.11031823f, 0.19126046f, 0.19322167f, 0.13774979f, 0.21247111f, -0.70244867f, 0.33499321f, 
    -0.07267348f, -0.58980286f, -0.01623919f, -0.00565591f, 0.22417824f, 0.09634547f, -0.09812876f, 0.23059607f, 
    -0.14505078f, 0.04449292f, 0.11266735f, -0.07784805f, 0.30144146f, -1.66558313f, -0.09139832f, -0.03126090f, 
    -0.01912360f, 0.56404620f, -0.97995883f, 0.07739321f, 0.12450708f, -0.19569279f, 0.06531261f, -0.03923301f, 
    0.09560044f, 0.10510118f, 0.09249524f, -0.05492658f, -0.33224159f, -0.06360620f, 0.22561757f, 0.12087000f, 
    -0.10032207f, -0.19503699f, -0.07047764f, -0.16135138f, 0.15527682f, 0.31803629f, 0.06361617f, 0.05629769f, 
    0.02153378f, -0.04623653f, -0.42050418f, -0.01036698f, 0.08806746f, -0.09889047f, -0.46204507f, -0.22869177f, 
    0.12491246f, -0.30817413f, 0.31311062f, 0.33136356f, -0.63220215f, 0.09949400f, -0.03862851f, -0.31577715f, 
    -0.25743684f, 0.06879437f, -0.06384889f, 0.24061567f, -0.13418461f, 0.11487927f, 0.08603870f, 0.26048866f, 
    0.44333676f, -0.22539498f, -0.19124882f, 0.04635231f, -0.76184130f, 0.08359348f, 0.01230512f, -0.14505695f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.33629853f, 0.25711107f, -0.09930964f, 0.14988339f, -0.06550898f, -0.12742849f, -0.18504858f, -0.00444440f, 
    -0.09212349f, 0.21557246f, -0.02176699f, -0.10187590f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
