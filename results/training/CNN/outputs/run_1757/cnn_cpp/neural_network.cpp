#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.07055948f, 0.39449188f, 0.34392819f, 0.04905324f, -0.24766491f, 0.02801556f, 0.17761822f, 0.47673029f, 
    -0.11897457f, -0.36860240f, 0.51080948f, 0.18100889f, 0.00836907f, -0.40100333f, -0.35918823f, 0.34414324f, 
    -0.12055056f, 0.02406308f, -0.20268779f, 0.08880429f, 0.36278138f, -0.22716103f, -0.27322820f, 0.38312572f, 
    -0.01402589f, 0.41039702f, 0.29979512f, 0.04097777f, -0.15570770f, 0.22278501f, 0.22864681f, -0.01941632f, 
    0.14146774f, 0.15798292f, 0.33591637f, 0.09416969f, 0.14797412f, -0.20401135f, 0.29035369f, -0.01264151f, 
    0.15834956f, -0.06006986f, 0.01627386f, 0.21089417f, -0.27890530f, 0.07459383f, 0.26021791f, 0.28499699f, 
    -0.12860858f, 0.04533524f, -0.27713689f, -0.14758509f, -0.10071640f, -0.21278669f, -0.38015154f, -0.52796888f, 
    -0.50809151f, -0.33823836f, -0.52363235f, -0.44803587f, -0.35805097f, -0.01245879f, 0.49659345f, -0.44270155f, 
    -0.07588167f, -0.12014969f, -0.54498851f, -0.31897339f, 0.18478896f, -0.27300939f, 0.04148139f, -0.03680812f, 
    -0.40108269f, 0.05154238f, 0.44664833f, -1.09039032f, -0.69605881f, -0.56033850f, -0.30562031f, -0.47744700f, 
    1.05500269f, 0.19909135f, -0.02757577f, 0.09725385f, 0.56906813f, 0.05470445f, 0.02708733f, -0.00068583f, 
    -0.06292430f, -0.34308192f, -0.10844640f, -0.12551060f, -0.03242151f, -0.15127087f, -0.06627920f, -0.17017889f, 
    -0.01352065f, -0.04917115f, -0.12091494f, 0.03094478f, 0.69253349f, -0.25469616f, -0.31563494f, -0.18001598f, 
    0.19966903f, -0.18971567f, -0.05745913f, 0.46665314f, 0.36530089f, 0.03779253f, -0.29737884f, -0.40968052f, 
    -0.10525836f, -0.11560812f, 0.28256583f, -0.18998358f, 0.07486641f, 0.21068965f, 0.20849973f, -0.32844588f, 
    0.01845954f, -0.00224000f, -0.29215062f, 0.13837741f, -0.07210828f, 0.50748038f, 0.95222360f, 0.58553052f, 
    -0.20318767f, -0.57135415f, -0.73019701f, -0.30155590f, -0.12364205f, -0.19420862f, -0.18905832f, -0.01613421f, 
    -0.10687220f, 0.24312237f, 0.40820122f, -0.26243159f, -0.01639153f, -0.02803496f, -0.22312605f, 0.22878189f, 
    -0.14930280f, -0.04294527f, -0.00066119f, 0.10742126f, 0.16671044f, 0.25878444f, 0.54320300f, -0.13818702f, 
    -0.72038627f, -1.01546514f, -0.49520305f, -0.02671147f, -0.36339697f, -0.12181615f, -0.02223649f, -0.37509453f, 
    0.33574757f, 0.34618965f, 0.64336228f, 0.00168623f, -0.05663192f, 0.07254648f, 0.07413518f, -0.00202631f, 
    -0.33196270f, -0.00038128f, 0.00513341f, 0.14815193f, -0.10358618f, -0.11322673f, 0.02816917f, 0.38203669f, 
    -0.04969273f, 0.35809952f, -0.30228448f, 0.42224154f, -0.16333571f, 0.25714543f, -0.44876987f, -0.20914529f, 
    0.32038799f, 0.25044334f, -0.12828219f, 0.06501602f, -0.06567277f, 0.06621461f, 0.15536025f, -0.26775160f, 
    -0.21514656f, -0.03113090f, 0.23422101f, -0.26501906f, 0.28161892f, 0.06151534f, -0.00878789f, 0.03091451f, 
    -0.78866220f, -0.37866378f, -0.02195532f, 0.58584082f, 0.19755808f, -0.44717327f, -0.15558530f, -0.33338499f, 
    -0.26433393f, 0.27915046f, 0.25416887f, -0.47206929f, 0.39016503f, -0.22487296f, -0.06157046f, -0.03615629f, 
    -0.00220619f, 0.00839213f, 0.16039179f, 0.03561160f, 0.10729765f, 0.16281824f, 0.33605796f, 0.24461013f, 
    0.16816518f, -0.93271345f, -0.76833713f, 0.24508627f, 0.18697008f, 0.54794067f, 0.01011045f, -0.62328875f, 
    -0.59919143f, -0.42358139f, -0.33529344f, -0.13234663f, 0.32046390f, -0.41793314f, 0.13829914f, -0.58488566f, 
    -0.11059016f, -0.13033681f, -0.04968850f, 0.11575333f, 0.03684786f, -0.15706642f, -0.15227488f, -0.12084132f, 
    -0.22684614f, -0.34780622f, 0.92772013f, -0.48061299f, -0.38339016f, 0.29385072f, 0.14312409f, -0.09034739f, 
    0.37184721f, 0.04934371f, -0.51212817f, -0.18040116f, -0.07364483f, 0.31661081f, -0.12419663f, -0.37719241f, 
    0.35356882f, 0.03091713f, 0.37823433f, -0.18657957f, -0.11730288f, -0.04539346f, -0.02292918f, -0.28275996f, 
    0.05025019f, 0.33612084f, -0.22925103f, 0.12879692f, 0.68928444f, 0.12878782f, 0.31962964f, -0.20351750f, 
    0.33553615f, -0.54288769f, -0.59052509f, -0.09383865f, -0.26664394f, -0.07705449f, -0.08698068f, 0.09180406f, 
    -0.52931052f, -0.40924343f, 0.24041070f, 0.25709140f, 0.12090391f, 0.13602310f, -0.07954136f, 0.06278157f, 
    0.06051045f, -0.10791795f, 0.11998696f, 0.22299759f, 0.23762602f, 0.62210459f, 0.40041846f, 0.22820631f, 
    -0.23520808f, 0.08474137f, 0.11701646f, -0.12916633f, -0.16387130f, 0.02263928f, 0.08249281f, -0.34049526f, 
    -0.12848514f, 0.14749804f, -0.20654538f, -0.03825723f, 0.07323112f, -0.17561197f, 0.18831766f, -0.24392392f, 
    -0.07755741f, -0.14040184f, -0.49241802f, -0.36431661f, -0.48228991f, 0.73311138f, -0.04904957f, -0.22415818f, 
    -0.30986345f, -0.23835889f, 0.18327954f, -0.23070206f, 0.59457338f, -0.14385410f, -0.46551290f, 0.12167366f, 
    -0.37512040f, 0.30031329f, -0.25908720f, 0.03621723f, 0.22657746f, -0.11649930f, -0.43095648f, 0.05350412f, 
    0.42553136f, -0.15138064f, -0.32921705f, 0.22852455f, 0.06644823f, 0.35400552f, -0.88080847f, -0.46747482f, 
    -0.12368798f, 0.48447973f, 0.51422071f, 0.23825884f, 0.13520661f, 0.27091581f, 0.29013178f, 0.19375806f, 
    -0.17387192f, -0.14062551f, 0.17313166f, 0.19436619f, 0.03569451f, 0.00067619f, -0.17428097f, 0.07557074f, 
    -0.26307580f, -0.24666511f, 0.07847904f, -0.37476343f, 0.16177200f, -0.05862959f, -0.26204732f, -0.53057891f, 
    0.40913361f, 0.63092077f, -0.76028907f, -0.82557815f, 0.05858190f, 0.10936753f, 0.17871103f, -0.12654093f, 
    0.14613570f, -0.03562063f, 0.46289438f, 0.09098451f, 0.06706638f, 0.03270956f, -0.39828596f, -0.26601937f, 
    -0.04070811f, -0.33328393f, 0.02574394f, 0.26942271f, 0.27582249f, 0.04053565f, 0.24061970f, 0.06037161f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03539995f, -0.01122665f, 0.17523743f, 0.23847029f, 0.36746997f, 0.22810940f, 0.31009337f, 0.26414311f, 
    0.20412478f, 0.25672472f, 0.16261993f, 0.03615804f, -0.07244477f, 0.28340131f, 0.20858532f, -0.00499378f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02210828f, 0.11283000f, 0.01479375f, -0.13715665f, -0.03105040f, -0.11842543f, 0.07408264f, 0.03004880f, 
    0.04210610f, -0.03561006f, -0.17008300f, -0.17717889f, 0.02823746f, -0.09427249f, -0.00262340f, -0.21457167f, 
    -0.00691816f, 0.03758662f, 0.11201650f, 0.02940543f, -0.01943055f, -0.46450716f, -0.09240475f, -0.01684475f, 
    -0.15837151f, -0.08617096f, -0.26852402f, -0.18476939f, -0.03164960f, -0.09755248f, 0.14815937f, 0.07350381f, 
    -0.03769046f, 0.02608114f, 0.01981841f, 0.00537234f, 0.26880041f, 0.04632558f, 0.51582843f, 0.32557279f, 
    -0.19596405f, -0.12617935f, -0.04927061f, 0.21370544f, 0.02585791f, 0.03022294f, 0.10703372f, 0.25509661f, 
    -0.19025417f, -0.06959030f, -0.05362094f, -0.04685838f, 0.07602642f, 0.06655372f, 0.20705096f, -0.01142903f, 
    0.15288487f, 0.15845388f, 0.23786743f, 0.16645581f, -0.28474030f, -0.05082516f, -0.09747513f, -0.10385494f, 
    0.15970589f, 0.07980173f, -0.10241458f, -0.02427798f, 0.03380223f, -0.24360093f, -0.12505980f, -0.26474082f, 
    -0.01569041f, 0.32473028f, 0.10871956f, -0.05054926f, -0.08758163f, 0.05297569f, 0.19426584f, 0.04635835f, 
    -0.01974223f, 0.03942217f, -0.02527320f, -0.06858721f, 0.14975882f, -0.17965814f, 0.09703907f, 0.04171549f, 
    0.17020524f, 0.01850651f, -0.12308504f, 0.04907291f, 0.07357187f, -0.10782482f, 0.16678137f, 0.00490462f, 
    0.01618193f, -0.19000089f, -0.21609513f, 0.01436576f, -0.10599270f, -0.11858175f, -0.14178741f, -0.01987104f, 
    -0.24466565f, -0.22129692f, -0.27444708f, -0.21558902f, -0.09056740f, -0.23462129f, -0.06364857f, 0.11140066f, 
    -0.03255425f, 0.08679641f, -0.02256312f, 0.06259993f, 0.16034465f, 0.11574346f, 0.19076434f, 0.12565860f, 
    -0.07274725f, 0.01022351f, 0.20381503f, -0.12640047f, -0.01713171f, 0.11085307f, -0.11059935f, -0.10626289f, 
    0.07398219f, 0.06964608f, 0.00296360f, 0.07629020f, -0.08609159f, 0.02526502f, 0.19382875f, -0.16123424f, 
    0.04567038f, -0.01544544f, 0.10793427f, 0.15554810f, -0.01558947f, -0.02981819f, 0.05277314f, -0.29122153f, 
    0.09120545f, -0.12760545f, 0.04830337f, 0.00018735f, -0.05015639f, -0.06392563f, 0.03702039f, -0.07007178f, 
    0.13491601f, 0.24443553f, 0.15509069f, 0.35857040f, -0.39166835f, 0.42496264f, -0.01776475f, -0.10571906f, 
    0.20373666f, -0.10197341f, 0.03572410f, 0.15144303f, -0.18200868f, 0.03657781f, -0.00632635f, -0.12584297f, 
    0.26623666f, 0.08441153f, 0.09581114f, 0.15976399f, -0.18155137f, -0.03618268f, 0.05701261f, 0.21058339f, 
    0.08197931f, 0.14027908f, -0.00075857f, 0.18718557f, 0.09427977f, 0.31550309f, 0.09298760f, -0.00675025f, 
    0.15133429f, 0.02797924f, 0.03938698f, -0.07115567f, -0.02870376f, -0.02646183f, -0.09610036f, -0.04661602f, 
    0.07829876f, -0.16182254f, -0.24112312f, -0.09092375f, 0.05383760f, -0.01315927f, 0.02459777f, -0.08096623f, 
    0.21198061f, -0.02645415f, 0.01363908f, 0.05991534f, -0.01010886f, -0.15838982f, -0.21580748f, 0.11486028f, 
    -0.00551361f, -0.07340192f, -0.02358382f, -0.01119527f, 0.05967695f, 0.17616811f, 0.09649303f, 0.01557567f, 
    -0.21530963f, -0.21294706f, 0.11544909f, -0.04563038f, 0.02812745f, 0.15653677f, -0.04443676f, 0.00187534f, 
    -0.03868632f, 0.10124507f, 0.06695146f, 0.02424507f, -0.41453287f, 0.18450184f, 0.48885545f, 0.20673917f, 
    -0.15270130f, -0.12574951f, -0.07928968f, 0.12370239f, -0.05367512f, -0.07665080f, 0.05812133f, 0.01823332f, 
    0.06004786f, 0.20378701f, -0.25892407f, 0.00356219f, -0.02652955f, 0.10539340f, -0.05058544f, 0.12449460f, 
    0.16850248f, 0.06008247f, 0.05135946f, 0.02134477f, 0.09306479f, -0.28136802f, -0.33925334f, 0.00753525f, 
    -0.01501431f, 0.19695158f, 0.14910398f, 0.01440454f, -0.09975240f, 0.02515226f, -0.09832773f, -0.18146533f, 
    -0.06180547f, 0.35239264f, 0.32594451f, -0.06776168f, 0.01052264f, 0.15609810f, 0.02599902f, -0.00144239f, 
    0.05089046f, -0.04599902f, 0.02845407f, -0.03987838f, -0.00725367f, -0.25665599f, -0.10359927f, 0.26244268f, 
    -0.03266506f, 0.13177453f, 0.04402258f, 0.14989170f, 0.09298681f, 0.05737818f, -0.02325803f, 0.07496711f, 
    -0.39965352f, -0.23234703f, 0.08077618f, 0.22449000f, -0.06711701f, 0.13223264f, 0.13916959f, 0.15370739f, 
    -0.11352039f, 0.01703935f, -0.04561161f, 0.07734609f, -0.32404882f, -0.10883437f, 0.26324353f, 0.10650991f, 
    0.10246495f, 0.05015033f, 0.05359590f, -0.08813606f, 0.03726047f, 0.09390649f, 0.13490474f, 0.08080451f, 
    0.02167997f, 0.00933728f, 0.23509431f, -0.26966354f, 0.23409481f, 0.07895888f, -0.09806390f, -0.00682014f, 
    0.04361999f, -0.07072128f, 0.11201262f, 0.07000604f, 0.22928412f, -0.48895925f, -0.08398502f, -0.07268158f, 
    0.04138659f, 0.19369964f, 0.11043000f, -0.03778794f, 0.03634032f, -0.02360467f, -0.00289980f, -0.00759815f, 
    0.22569743f, -0.00930248f, -0.24835192f, -0.08815272f, 0.01661403f, 0.02320181f, 0.00872814f, -0.06924672f, 
    0.04045630f, -0.00363547f, -0.19095960f, 0.00887060f, 0.15010409f, 0.18911780f, 0.07073314f, -0.02346165f, 
    0.00654233f, 0.01918971f, -0.17514072f, 0.14836001f, 0.09789608f, -0.04937784f, 0.03081038f, 0.04148508f, 
    -0.08234904f, 0.15239173f, 0.23314251f, 0.14829586f, -0.03637901f, -0.01698494f, -0.00857928f, 0.03381199f, 
    0.13507633f, 0.03029326f, 0.08877078f, 0.07481238f, 0.25045368f, 0.09945317f, 0.24366674f, -0.18500875f, 
    0.09829890f, -0.15129085f, 0.03590403f, -0.15648116f, 0.09235318f, -0.03117656f, 0.02362943f, -0.01294983f, 
    0.06756165f, -0.05619381f, 0.20175901f, -0.14579967f, -0.21443464f, -0.11696681f, 0.01323869f, 0.02061281f, 
    -0.05748699f, 0.03283314f, 0.08246966f, -0.01111142f, 0.06691924f, -0.09143088f, -0.10094330f, -0.03550277f, 
    -0.04388665f, 0.04031371f, -0.03306309f, 0.00498271f, 0.00054107f, 0.07164435f, 0.05259436f, -0.09502256f, 
    0.00309506f, -0.22763841f, 0.25130495f, -0.07347134f, -0.08212505f, -0.08836241f, -0.14257295f, -0.02227842f, 
    0.07754259f, 0.08488810f, 0.04753657f, 0.03798363f, -0.16807428f, 0.28768659f, 0.03251550f, 0.13634962f, 
    -0.16048013f, -0.10810156f, 0.00261316f, -0.06663840f, -0.04462918f, -0.09213467f, -0.05791122f, 0.04659645f, 
    0.19526137f, 0.08927947f, -0.03700971f, 0.07041692f, -0.03179991f, 0.03195843f, -0.02563673f, 0.18829866f, 
    0.06173442f, 0.12431016f, 0.11742371f, 0.17500202f, 0.31403297f, -0.18003364f, 0.09207013f, -0.24848105f, 
    0.05341906f, 0.07014827f, 0.00769992f, -0.05561437f, -0.10814222f, 0.03152816f, -0.01385076f, -0.11413952f, 
    0.03629018f, -0.02079939f, 0.28299782f, -0.05856378f, 0.03033270f, -0.01252950f, 0.00129283f, 0.09742901f, 
    0.03139276f, 0.06131930f, -0.01562478f, -0.03910383f, 0.21015483f, 0.12379351f, 0.05612948f, 0.24637264f, 
    -0.12580241f, 0.15184522f, 0.14482394f, 0.01210225f, -0.06277771f, 0.08665136f, -0.05445161f, 0.03474977f, 
    -0.23999420f, -0.13014740f, 0.02626748f, 0.04077440f, -0.09222202f, 0.07003334f, 0.20373891f, 0.05213552f, 
    0.02339408f, -0.12471384f, -0.05824114f, 0.05511293f, -0.08314567f, -0.23954163f, 0.19859910f, 0.05486051f, 
    0.12068632f, -0.00437045f, 0.08948494f, -0.14502843f, -0.02293936f, 0.14018190f, 0.16895862f, 0.07823631f, 
    0.28974074f, 0.12732132f, 0.01272218f, 0.01356839f, -0.06939029f, 0.20083939f, 0.00656317f, 0.11720660f, 
    -0.07071526f, 0.01403014f, 0.08830917f, 0.00894337f, 0.05640369f, -0.35143527f, 0.00437195f, 0.04995313f, 
    -0.08343640f, 0.00134677f, 0.09992618f, -0.13208959f, -0.01576241f, -0.00058615f, -0.06586249f, -0.03898124f, 
    0.19936348f, 0.03795610f, -0.08474923f, -0.00075224f, 0.06366508f, -0.09928598f, -0.02706733f, -0.05506469f, 
    -0.00340075f, 0.09513421f, -0.01598509f, 0.05820983f, 0.28928035f, -0.04357116f, 0.37299347f, 0.07752853f, 
    -0.12250996f, 0.13650453f, -0.03557317f, 0.13618103f, 0.03873351f, -0.06327521f, -0.08164632f, 0.11506938f, 
    -0.34216237f, -0.12959582f, 0.02385465f, 0.16472468f, 0.03645618f, -0.15365912f, -0.00029890f, -0.02615524f, 
    0.00284175f, -0.02185504f, 0.05933634f, 0.06687110f, -0.16829984f, -0.08016552f, 0.13798340f, -0.27820349f, 
    -0.11341136f, 0.14649449f, 0.23964544f, -0.01301353f, -0.11030740f, 0.09069603f, -0.05814068f, 0.07312691f, 
    0.01101742f, -0.10216372f, -0.16879585f, -0.01417303f, 0.09759300f, -0.13011865f, -0.18511744f, -0.10412510f, 
    0.13834763f, -0.04611375f, -0.09306049f, 0.09100270f, -0.08985128f, -0.01901882f, -0.08984137f, 0.00983470f, 
    -0.12768795f, -0.23322882f, -0.13156502f, -0.13994275f, -0.04874548f, 0.02416511f, 0.00286854f, 0.04792025f, 
    -0.04036753f, -0.06500432f, -0.01259498f, 0.11116299f, 0.05930365f, 0.22078577f, -0.05871104f, 0.08397841f, 
    0.01385342f, 0.08535940f, 0.02123239f, 0.10018811f, -0.05427711f, 0.03853028f, 0.35821152f, 0.08315287f, 
    0.00693906f, 0.16575563f, 0.01246194f, 0.31840110f, -0.01992872f, 0.04964304f, -0.03506919f, -0.06632551f, 
    -0.30359012f, 0.35581973f, -0.05217825f, -0.07113094f, -0.03908244f, 0.06987771f, 0.03292801f, -0.05190425f, 
    0.12268336f, -0.00378910f, 0.03973322f, 0.01542101f, -0.31884155f, 0.00437131f, -0.24001445f, 0.00688359f, 
    -0.12798789f, 0.06289128f, -0.14323050f, -0.10064615f, -0.04507262f, 0.08719812f, -0.09497793f, -0.08607429f, 
    0.01064000f, 0.08592416f, -0.08989758f, 0.33451614f, 0.11565901f, 0.09299613f, 0.06419548f, 0.14689608f, 
    0.12637173f, -0.09383198f, -0.00399278f, 0.03731572f, -0.27564919f, -0.07139629f, 0.02784831f, -0.07341097f, 
    0.02009830f, -0.13001662f, 0.04823560f, 0.06678638f, 0.13819434f, 0.01166116f, -0.05282615f, 0.02185658f, 
    0.00453048f, -0.10887510f, 0.00024952f, 0.06191424f, 0.03054325f, 0.10317636f, -0.13523559f, 0.08861471f, 
    -0.00733306f, 0.11404128f, 0.08213530f, 0.20235252f, -0.06958041f, 0.32714507f, 0.06078155f, 0.05635445f, 
    0.07124365f, -0.00934296f, -0.09517475f, 0.11615643f, -0.06416689f, 0.00431492f, 0.03787652f, -0.09482907f, 
    -0.34094238f, 0.20134220f, 0.26686621f, 0.00456324f, 0.10397998f, -0.05491377f, -0.01220074f, -0.12349297f, 
    0.08976838f, 0.11236470f, 0.04777872f, 0.08444765f, 0.07894797f, -0.05233253f, 0.01850855f, -0.04329432f, 
    0.16593164f, -0.06144003f, 0.02209484f, -0.02893726f, 0.03336529f, -0.07576336f, 0.14121701f, 0.01403739f, 
    -0.05940754f, 0.02553389f, -0.07454409f, -0.09141058f, -0.09140493f, -0.07793226f, 0.02375246f, -0.01908994f, 
    0.01601335f, -0.04312534f, -0.17326981f, -0.03078090f, -0.21492241f, 0.16593638f, -0.16634327f, 0.20362850f, 
    0.16118339f, -0.05994222f, -0.16827723f, 0.05524276f, 0.21508978f, -0.00280493f, 0.19131443f, 0.05935136f, 
    0.11579830f, 0.10499676f, -0.04426808f, -0.15590295f, -0.04051885f, 0.02030889f, 0.08019517f, 0.14026484f, 
    0.06896346f, -0.05459466f, -0.10578882f, -0.18977252f, 0.55348009f, -0.09945306f, 0.13643843f, 0.15690830f, 
    0.03697420f, 0.09313442f, -0.07895696f, 0.20511478f, -0.03294450f, 0.09596477f, 0.07740799f, -0.03574260f, 
    -0.00982587f, 0.04918533f, -0.00625153f, -0.15094049f, 0.19969207f, -0.09339916f, -0.08352093f, -0.03205331f, 
    0.06508788f, 0.08788151f, 0.05347696f, -0.02042790f, -0.20365731f, -0.03918663f, 0.00847071f, -0.04504798f, 
    -0.12567905f, -0.07744912f, -0.18483944f, -0.12512319f, -0.04347065f, 0.10462799f, 0.07032466f, 0.00024519f, 
    0.01665002f, -0.06704897f, -0.03426177f, 0.15091078f, 0.16001730f, 0.21281980f, -0.07636342f, -0.16756092f, 
    -0.05095753f, 0.04094382f, 0.03879432f, -0.12339420f, -0.19152294f, -0.13926046f, 0.12327293f, 0.07364146f, 
    0.13370608f, 0.09047845f, 0.07384370f, 0.09601014f, 0.11153221f, 0.02204687f, 0.04433469f, 0.03896911f, 
    0.26239574f, 0.23078507f, 0.14479844f, 0.28909087f, -0.03988316f, -0.04240065f, -0.01999453f, -0.09543173f, 
    0.04255971f, 0.02151215f, -0.02826895f, -0.03384947f, 0.15897088f, 0.02089327f, 0.19276725f, -0.09656318f, 
    0.09195727f, -0.05074436f, -0.07999571f, -0.06874844f, -0.09661756f, -0.04436791f, 0.03508619f, 0.01491116f, 
    -0.18030964f, -0.10018444f, -0.17870347f, 0.20561816f, 0.06373484f, 0.16513599f, 0.05534377f, -0.09551442f, 
    0.00709601f, 0.03907058f, -0.04113097f, 0.10056543f, 0.04535477f, 0.25214756f, 0.07346046f, 0.02206377f, 
    -0.04218566f, -0.11305929f, -0.04514506f, -0.05351412f, 0.08506665f, -0.07447408f, -0.00998902f, -0.00270050f, 
    -0.01002914f, -0.09329350f, -0.02814114f, 0.06691062f, 0.18719739f, 0.09903102f, 0.01460839f, 0.10525712f, 
    -0.07756036f, 0.04623012f, 0.04505223f, -0.01248903f, -0.14953090f, 0.15670550f, -0.10687129f, 0.03871920f, 
    -0.08531492f, 0.03267650f, 0.02223194f, 0.08409611f, 0.08757229f, -0.06225436f, -0.00347928f, -0.01190570f, 
    -0.29325399f, 0.17194845f, -0.05473433f, 0.40689358f, -0.12686650f, -0.05429568f, 0.16034448f, -0.14468966f, 
    0.10013299f, 0.01894740f, 0.07970247f, 0.23058327f, -0.21859927f, 0.13124532f, 0.35013607f, 0.00624512f, 
    0.04400804f, -0.03207055f, -0.06691672f, -0.06884215f, -0.01966465f, 0.03823950f, -0.01037739f, 0.07733576f, 
    -0.20928074f, 0.13744940f, 0.19444568f, -0.09637924f, -0.15479797f, -0.00680164f, -0.06621087f, -0.03334855f, 
    -0.03889270f, -0.04592817f, 0.01201861f, -0.20063014f, 0.01257084f, 0.03434602f, -0.07655760f, 0.15880084f, 
    0.15600239f, 0.13137715f, 0.05951653f, -0.10642590f, 0.11035107f, 0.04572295f, 0.07635428f, 0.13498987f, 
    0.04212306f, 0.14415620f, -0.07453085f, -0.34866756f, 0.00802758f, -0.08012159f, 0.05085497f, 0.03502665f, 
    0.03833785f, -0.00283549f, -0.00069371f, -0.05633430f, 0.11996835f, -0.27819121f, -0.22252214f, 0.22254464f, 
    -0.00750067f, -0.02995032f, -0.04519080f, 0.12145925f, -0.05911530f, 0.08012921f, -0.05993194f, -0.15481192f, 
    -0.05364582f, -0.05387972f, -0.02997352f, -0.06860784f, -0.06728751f, 0.03736844f, 0.02661585f, -0.04609339f, 
    -0.07677168f, -0.05910493f, 0.02903118f, -0.07429671f, -0.07057972f, -0.01560376f, -0.01201313f, 0.02657470f, 
    -0.00837619f, 0.04271749f, 0.00108700f, 0.02096936f, -0.05588184f, 0.05127633f, 0.01074984f, -0.03217199f, 
    -0.03639138f, -0.04105468f, 0.02568801f, 0.05261923f, 0.06649253f, 0.02781699f, 0.00783885f, 0.03746871f, 
    0.00596299f, 0.00832651f, 0.01577166f, 0.02421132f, 0.04488463f, 0.03644333f, 0.05196767f, -0.03142060f, 
    0.06024441f, 0.06659840f, -0.06387400f, -0.04396874f, -0.03978013f, -0.05106595f, -0.03679015f, 0.05475030f, 
    -0.03358790f, -0.04033178f, -0.06498842f, -0.00772629f, 0.06260563f, -0.01194511f, -0.04212213f, -0.05447580f, 
    -0.07113684f, 0.01460929f, -0.02970354f, 0.05438624f, -0.03228829f, 0.03880009f, -0.04533499f, -0.06118302f, 
    -0.07163012f, 0.03227777f, -0.07276228f, -0.02267338f, -0.06966431f, -0.03035250f, -0.03421291f, -0.02702609f, 
    0.02340119f, 0.04699083f, 0.06367180f, 0.06694032f, 0.06564099f, -0.00004688f, -0.03723366f, 0.05038311f, 
    0.00397158f, -0.01948143f, -0.02143628f, 0.01146962f, -0.07623434f, 0.00749181f, -0.03607585f, 0.03597548f, 
    -0.02482257f, 0.05242290f, -0.04745108f, -0.01681579f, 0.00058316f, 0.04419478f, -0.04219803f, -0.03604582f, 
    0.03705524f, -0.03878893f, -0.04368059f, 0.05780007f, -0.03906232f, -0.05963790f, -0.06127353f, 0.04251757f, 
    0.05083904f, -0.06387619f, 0.03272564f, -0.07578231f, -0.07363369f, -0.04039370f, -0.06315860f, -0.05884619f, 
    -0.02482899f, 0.00212683f, -0.05272388f, 0.03495260f, 0.04975975f, -0.04524286f, 0.03267453f, -0.04852813f, 
    -0.03555863f, -0.05102995f, -0.04512919f, 0.05364374f, -0.03702270f, -0.03821178f, -0.02057783f, 0.00879339f, 
    0.06692354f, -0.05462252f, -0.00045542f, 0.01123751f, 0.06329270f, -0.04601639f, 0.00940974f, -0.02350525f, 
    0.00979385f, 0.02032516f, -0.02880924f, 0.02651825f, 0.01547994f, -0.06642675f, -0.07196676f, 0.04871007f, 
    -0.00152014f, 0.05594182f, 0.00932613f, -0.02426274f, -0.06582987f, 0.03281906f, -0.02140232f, 0.01698550f, 
    0.01064155f, -0.02935874f, 0.03278786f, -0.00585190f, -0.01689920f, 0.00602131f, -0.01982106f, -0.07536141f, 
    -0.06980032f, -0.04741614f, 0.01597190f, -0.05199032f, 0.04015698f, 0.00696458f, -0.02780528f, -0.06131059f, 
    -0.04332196f, 0.04251542f, 0.06508552f, -0.05380334f, 0.03926818f, 0.03890354f, 0.00997789f, -0.00533808f, 
    -0.05556295f, -0.06590692f, 0.00068705f, 0.00720481f, -0.02546596f, 0.04463434f, -0.05742239f, 0.04002850f, 
    -0.02279362f, 0.06296965f, 0.01509956f, -0.04244241f, 0.00662401f, -0.05206295f, -0.03342388f, -0.01330163f, 
    -0.18923354f, 0.01140834f, -0.10098017f, -0.10467871f, -0.08435041f, -0.12526070f, 0.11106115f, 0.16251980f, 
    0.01682165f, -0.03462271f, -0.08173797f, -0.12225612f, 0.02238858f, -0.21255742f, -0.06525479f, -0.24289793f, 
    0.01116134f, 0.01966380f, 0.15170398f, -0.01491936f, -0.13428047f, -0.40937835f, -0.00713750f, -0.09913562f, 
    -0.10135305f, 0.04499150f, -0.06159073f, 0.07658247f, -0.03696559f, -0.09366266f, 0.18136010f, 0.20992754f, 
    0.08645622f, 0.11017365f, 0.04106995f, -0.05913152f, 0.30221415f, -0.07211522f, 0.16264220f, 0.26646149f, 
    0.03173694f, -0.05143173f, -0.03229123f, 0.13911048f, 0.05092590f, 0.04874352f, 0.04655320f, 0.20269987f, 
    -0.12294164f, -0.06948201f, -0.14357473f, -0.21699817f, 0.02861859f, 0.00283950f, 0.18007541f, -0.03554052f, 
    0.00069102f, 0.04377955f, 0.05179563f, 0.12828012f, -0.26087970f, 0.18754183f, 0.04884961f, 0.13007525f, 
    0.14523457f, 0.08378775f, -0.11266457f, -0.06784306f, -0.04663984f, -0.12526110f, 0.07118420f, -0.22789249f, 
    -0.12928015f, 0.21383199f, 0.19693787f, 0.16733554f, -0.10021396f, -0.06723700f, 0.10743481f, -0.06667299f, 
    -0.10901339f, 0.10478175f, 0.05601592f, 0.00295937f, -0.11382824f, -0.17249985f, -0.02489139f, -0.21374759f, 
    0.13727282f, -0.01759465f, -0.11323545f, -0.04556567f, -0.02181822f, -0.26667821f, 0.02975113f, -0.08110835f, 
    0.02627448f, -0.08681687f, -0.18491638f, -0.09233013f, -0.05392601f, 0.03287553f, -0.09214658f, -0.03198766f, 
    -0.17661840f, -0.10000493f, -0.22353280f, -0.33973256f, -0.05797882f, -0.10739239f, 0.01871957f, 0.10057157f, 
    0.09662265f, 0.14984566f, -0.03366650f, 0.12706088f, 0.18204328f, 0.19589305f, 0.16294494f, 0.02953996f, 
    -0.16724272f, 0.20131989f, -0.00607925f, 0.07531393f, -0.08015116f, -0.13980149f, -0.04174175f, -0.19140306f, 
    -0.06299067f, 0.06405636f, -0.11938713f, 0.07845439f, 0.00301757f, 0.00895007f, 0.26028183f, 0.03811055f, 
    -0.01559515f, 0.04532792f, 0.09903807f, 0.26494917f, -0.09508502f, -0.06271256f, -0.18218614f, -0.18902265f, 
    -0.05917405f, -0.06380216f, 0.04081032f, 0.08282671f, 0.00762091f, 0.02455592f, -0.00631527f, -0.05287789f, 
    0.18063451f, 0.14776815f, 0.07363833f, 0.36034012f, -0.46487254f, 0.27422410f, -0.15333027f, -0.11530529f, 
    0.28353226f, -0.06616887f, 0.08550858f, -0.00437388f, -0.25465953f, 0.02961030f, 0.00360072f, -0.20439531f, 
    0.33481571f, 0.29817319f, 0.06298566f, 0.18756799f, -0.12093174f, 0.07461705f, -0.03332188f, 0.00501408f, 
    -0.07046038f, 0.07559923f, -0.00474843f, 0.08698905f, 0.00832187f, 0.44476578f, -0.08820856f, 0.15053643f, 
    0.16535276f, -0.12773149f, -0.00888889f, -0.06975130f, -0.12728436f, -0.09758233f, -0.10048653f, -0.03580740f, 
    0.00830502f, 0.07103101f, 0.02967300f, -0.06764290f, -0.02637524f, 0.03016538f, 0.05515523f, -0.04268069f, 
    -0.03865035f, -0.01686371f, -0.00924528f, 0.00199437f, -0.01638344f, -0.01175312f, 0.03033909f, -0.04408466f, 
    -0.05260761f, -0.00850775f, -0.05646166f, 0.01064351f, -0.05499875f, -0.02059901f, 0.01053968f, -0.05317468f, 
    0.03593347f, -0.00622778f, 0.03024282f, 0.00414678f, -0.01284834f, -0.04153546f, -0.07617087f, 0.00014957f, 
    0.02612291f, -0.07795576f, -0.03993572f, 0.02076466f, 0.04668632f, 0.04820759f, -0.00678147f, 0.02798639f, 
    0.03538897f, -0.02240214f, -0.05231397f, -0.05191720f, -0.00157548f, -0.02290458f, -0.03536616f, -0.04057293f, 
    0.04602304f, 0.03943211f, -0.07510731f, -0.03695702f, 0.02252672f, -0.00876388f, -0.01244182f, 0.05086910f, 
    0.04140360f, 0.01039821f, -0.06209565f, 0.00483395f, -0.04669884f, -0.01975951f, -0.03696154f, -0.07467324f, 
    -0.04500089f, 0.01018197f, -0.06007941f, 0.06083200f, -0.02610624f, 0.02900565f, 0.05340761f, -0.06400413f, 
    -0.04033196f, 0.00123169f, 0.03524129f, 0.05692427f, -0.02872766f, -0.02586530f, 0.05009154f, -0.06445622f, 
    -0.07035364f, -0.00828752f, -0.05524167f, 0.01555362f, -0.00811190f, -0.02164303f, -0.05850096f, 0.00355118f, 
    0.01413070f, -0.06338754f, -0.03074846f, 0.04220323f, 0.01385609f, 0.03509966f, 0.01766268f, -0.04896501f, 
    -0.07383984f, -0.04114208f, 0.04461151f, 0.01710950f, -0.01834425f, 0.00036053f, 0.02836267f, 0.00863525f, 
    0.03609120f, -0.07786380f, 0.04640033f, 0.02327578f, 0.03454600f, -0.06398259f, 0.02600626f, 0.02708341f, 
    -0.03289597f, 0.02364720f, 0.05296046f, -0.04942401f, -0.00775999f, 0.03524249f, -0.04875025f, -0.07650968f, 
    -0.05911337f, 0.03452014f, -0.00424427f, 0.06141964f, -0.03505088f, 0.01133604f, -0.01636328f, -0.07704443f, 
    -0.03870330f, 0.05077684f, -0.03283745f, 0.04584343f, 0.04587827f, 0.00628980f, -0.02101230f, -0.04343392f, 
    -0.06514137f, 0.00892710f, -0.02282447f, 0.04741735f, 0.01403087f, -0.01990635f, -0.04347091f, -0.02252338f, 
    -0.02272570f, -0.07002832f, -0.02191689f, 0.01959144f, -0.02098936f, -0.05479961f, -0.00142939f, -0.00020440f, 
    -0.03710474f, -0.03232447f, -0.07263201f, 0.04350200f, -0.06489131f, 0.01883823f, -0.02383956f, -0.04443781f, 
    -0.07544128f, -0.00544536f, 0.04076575f, 0.00660891f, -0.04305743f, -0.05268850f, 0.01875329f, -0.07343838f, 
    0.04071908f, -0.01045405f, -0.02092984f, 0.05294741f, -0.04670814f, 0.02734079f, -0.03300631f, -0.04520259f, 
    0.06327349f, -0.02384296f, -0.03980166f, 0.04635961f, -0.07047007f, -0.06509183f, -0.06825683f, 0.06082383f, 
    0.00922220f, 0.01842565f, 0.04368597f, 0.02905543f, -0.05274808f, -0.02897846f, 0.00755673f, -0.07004596f, 
    0.01673535f, 0.00182198f, 0.00768705f, -0.01619392f, 0.02925217f, 0.04604432f, -0.03898805f, -0.05507485f, 
    -0.03718210f, 0.00992709f, -0.06827746f, 0.04322398f, 0.05227908f, -0.04514102f, -0.04761183f, -0.04706073f, 
    0.00249478f, -0.02468810f, -0.06333315f, -0.02891885f, -0.02702943f, -0.04596233f, 0.02391777f, 0.04837408f, 
    0.01046116f, 0.01053176f, 0.05522314f, -0.04756741f, -0.06214000f, 0.01533573f, 0.02288388f, -0.05518109f, 
    -0.01121299f, -0.06112876f, -0.00144829f, 0.02199153f, 0.00652694f, 0.06111243f, -0.00791879f, -0.03532108f, 
    -0.01545509f, 0.02018222f, -0.01832825f, 0.06292927f, -0.02078289f, -0.02580420f, 0.02183513f, -0.06495549f, 
    -0.05921671f, -0.05890079f, 0.06485560f, -0.07203799f, 0.04968249f, 0.04905118f, -0.04398572f, -0.05374717f, 
    -0.01194643f, -0.04796259f, 0.03412892f, 0.02027606f, -0.06663371f, 0.04320518f, 0.02562046f, -0.07205527f, 
    -0.02191672f, 0.03443543f, -0.05457772f, -0.03178496f, -0.02174255f, 0.04360113f, 0.00009017f, 0.01430109f, 
    -0.01659831f, -0.06809520f, -0.00566491f, -0.01859024f, 0.00288511f, 0.02925327f, -0.00596283f, 0.01621562f, 
    -0.06729262f, 0.05683053f, -0.04541750f, 0.02235190f, -0.07145613f, 0.03762165f, 0.03812905f, 0.04809434f, 
    -0.03127792f, -0.06073467f, -0.02873265f, -0.04193608f, -0.04771880f, -0.02108089f, 0.01150430f, 0.05778465f, 
    0.05889349f, -0.03407143f, 0.03224160f, -0.06419914f, -0.02811934f, 0.06398825f, 0.03818773f, 0.06191260f, 
    -0.07445689f, 0.03321066f, -0.01374291f, -0.05101700f, 0.01485580f, 0.03935033f, -0.07011778f, -0.03458897f, 
    -0.00780541f, -0.04583474f, -0.04333139f, -0.03807988f, -0.07173578f, 0.02466759f, -0.06022133f, -0.02948637f, 
    0.03406571f, 0.01094109f, -0.06702557f, 0.02348340f, -0.05237419f, -0.02202843f, -0.07686586f, -0.06905904f, 
    -0.01162599f, 0.01950813f, -0.04531384f, 0.02034291f, -0.03250030f, -0.01960669f, 0.02387790f, 0.03378910f, 
    -0.04551035f, -0.06447198f, 0.02861194f, 0.01010816f, 0.04154794f, -0.00301695f, -0.06191968f, -0.02973872f, 
    0.02110904f, -0.03608577f, 0.01688967f, 0.03226980f, -0.01545281f, 0.02544659f, 0.02501533f, -0.03439589f, 
    -0.03024545f, 0.04113347f, 0.03446127f, -0.03098721f, -0.03643490f, 0.02148506f, 0.06515394f, 0.01377911f, 
    0.00503059f, -0.03226050f, 0.04839562f, -0.07241981f, -0.03629683f, 0.02772928f, -0.02408890f, -0.07740125f, 
    -0.00440285f, 0.04889309f, -0.03171850f, 0.00008922f, -0.03530283f, 0.02828062f, 0.03006555f, -0.05673301f, 
    -0.03316807f, -0.05294442f, 0.06552228f, -0.05668233f, -0.03032546f, -0.06079813f, -0.05447014f, -0.05886573f, 
    -0.00784307f, 0.03567795f, -0.07353676f, -0.02141297f, -0.05522087f, 0.02397020f, 0.04607923f, 0.04597814f, 
    -0.25114542f, -0.30882779f, -0.26364642f, 0.08245778f, 0.00243693f, 0.09954639f, 0.04977075f, -0.02012945f, 
    0.16962817f, -0.08897568f, 0.01739824f, 0.08952247f, -0.11641092f, -0.25034085f, -0.12017456f, -0.07672069f, 
    0.05895064f, -0.00209442f, 0.19454642f, 0.03382204f, 0.11824559f, 0.12754658f, 0.04925370f, 0.03549633f, 
    0.28485394f, 0.49102649f, 0.38484788f, 0.25407931f, -0.06364775f, 0.05521914f, 0.00113112f, 0.26453376f, 
    0.00452532f, 0.03398856f, -0.06314426f, -0.04323088f, 0.41405255f, 0.41199091f, 0.14811632f, 0.19679217f, 
    0.03265031f, 0.10937598f, 0.08027266f, -0.04748297f, -0.02796650f, -0.03871385f, 0.00848846f, 0.07967188f, 
    -0.09104157f, -0.02028690f, -0.27267784f, -0.21378091f, -0.07884303f, -0.02701825f, 0.02530801f, 0.00346812f, 
    -0.02486171f, -0.06069838f, -0.16055441f, -0.11082307f, -0.35185033f, -0.22118320f, -0.12186317f, -0.05457631f, 
    0.05719996f, -0.07570899f, -0.13604172f, 0.05201826f, 0.09145262f, 0.15903735f, 0.06594475f, 0.08646247f, 
    0.39511612f, 0.38756093f, 0.39402565f, 0.20998879f, -0.01461738f, -0.08138418f, 0.12342283f, 0.07101821f, 
    -0.00374618f, -0.05308426f, 0.01697867f, 0.03386772f, -0.31401718f, -0.27451962f, -0.20829926f, -0.17023647f, 
    0.03275937f, -0.02194071f, -0.08046921f, -0.02103149f, 0.09036805f, 0.09428405f, 0.04538850f, 0.05375002f, 
    -0.11053252f, 0.26640457f, 0.42551762f, 0.17660329f, -0.08257217f, 0.15064481f, 0.06817590f, 0.14986371f, 
    0.03338059f, 0.02589479f, 0.09541332f, 0.01546182f, 0.01899762f, 0.39015111f, 0.34325987f, 0.16556588f, 
    0.07404666f, 0.05796279f, -0.01797701f, 0.22265014f, -0.05548426f, -0.04122473f, -0.22884756f, -0.08106223f, 
    0.10612249f, -0.02791916f, -0.09882535f, -0.19590507f, 0.01016219f, -0.19388637f, -0.11986181f, -0.01052641f, 
    -0.18734974f, 0.11584470f, 0.13492961f, -0.00227347f, 0.17289652f, -0.18969631f, -0.12924257f, 0.01687230f, 
    -0.03698610f, 0.05211418f, 0.02285394f, 0.02445239f, 0.05141657f, -0.04174602f, 0.00700714f, -0.01632977f, 
    -0.22851826f, -0.24945606f, -0.23516111f, -0.11017366f, -0.03464025f, -0.02813681f, -0.02061679f, -0.06871818f, 
    0.15798369f, -0.09654438f, -0.02866196f, 0.07231901f, -0.01623657f, -0.03378043f, -0.29234892f, -0.00462082f, 
    -0.11529856f, -0.07271612f, 0.12792051f, -0.24895979f, 0.01407091f, 0.09974369f, -0.07343830f, 0.07896973f, 
    -0.25570905f, 0.08445408f, 0.11280052f, 0.14240390f, -0.02014786f, 0.04083326f, -0.05622590f, 0.01294285f, 
    -0.37702402f, -0.10582098f, 0.00551955f, -0.10213771f, 0.45568672f, 0.32006824f, 0.32694024f, 0.06735057f, 
    0.04275286f, 0.09405395f, 0.01787232f, 0.09852196f, -0.04455309f, -0.00003262f, 0.12443773f, 0.01665693f, 
    -0.01120014f, -0.07726035f, -0.00561085f, -0.11402173f, 0.10521860f, -0.07021693f, 0.12095654f, 0.03980952f, 
    -0.05091454f, 0.09829842f, 0.10742695f, 0.00506249f, 0.00196176f, -0.27493110f, -0.02234741f, 0.07123745f, 
    0.03376486f, 0.13428092f, -0.27362022f, -0.22078300f, -0.05942871f, -0.00680024f, -0.03879871f, -0.25240958f, 
    0.28418750f, 0.20452645f, -0.01143084f, 0.06052486f, 0.24271901f, -0.07686796f, -0.03336966f, 0.03191588f, 
    -0.07488293f, -0.10101217f, 0.00026357f, 0.00960065f, -0.04853967f, 0.06760857f, 0.08479855f, 0.10460573f, 
    0.17806311f, 0.09091799f, 0.19084498f, 0.13302781f, 0.03329876f, -0.08523796f, 0.15818323f, 0.00909259f, 
    0.19602533f, 0.03589534f, 0.30038583f, 0.27347234f, -0.01034179f, -0.05587723f, -0.02324360f, -0.05811381f, 
    -0.03184433f, 0.09086722f, 0.09280498f, -0.02209703f, 0.32867703f, -0.18557794f, 0.53056568f, -0.09241837f, 
    0.01479477f, -0.07802573f, -0.16723377f, -0.05685774f, -0.12079834f, -0.06445122f, -0.01946463f, -0.04846439f, 
    0.16032122f, 0.09624354f, 0.04342626f, 0.02332054f, 0.11245953f, 0.05516454f, 0.10519176f, -0.16624390f, 
    0.16955666f, 0.05264259f, 0.10059586f, 0.03248473f, -0.00448352f, 0.22820222f, 0.06139324f, 0.04982825f, 
    -0.05369985f, -0.18966518f, -0.10643969f, -0.04880110f, 0.01835833f, -0.11197444f, -0.14724970f, -0.04382068f, 
    0.00702593f, 0.21405615f, 0.05473751f, -0.14420521f, 0.15978238f, -0.01372599f, 0.10467885f, 0.03574355f, 
    0.01171572f, -0.10072672f, -0.19210999f, -0.34097731f, 0.04656688f, 0.19271135f, 0.12337495f, -0.01173504f, 
    0.03054743f, 0.03673360f, 0.09024206f, 0.05203565f, 0.01460277f, -0.03306794f, -0.04863305f, 0.13856131f, 
    0.28577694f, -0.06227048f, -0.25179267f, 0.30062529f, -0.13557956f, -0.18059087f, 0.16186489f, 0.01356544f, 
    -0.06097614f, 0.11307505f, 0.03321009f, -0.11708777f, -0.05963637f, 0.26330104f, 0.24751033f, -0.08083844f, 
    -0.01034093f, -0.01706623f, -0.17088336f, 0.26118416f, -0.08768293f, 0.13532557f, 0.05822439f, -0.11411443f, 
    -0.08630423f, -0.02035576f, 0.22283259f, -0.04284068f, 0.04398246f, -0.03654528f, -0.11786829f, 0.04043335f, 
    0.17516620f, -0.16574734f, 0.23808271f, -0.01049251f, 0.18997602f, -0.06058250f, -0.10525570f, -0.18023637f, 
    -0.05875027f, 0.17120306f, 0.12235213f, -0.04700822f, 0.03170618f, 0.08430170f, -0.20051140f, 0.03957606f, 
    -0.20450222f, -0.08182958f, -0.06575254f, 0.15977511f, 0.11215676f, 0.01742047f, -0.03702503f, -0.16513515f, 
    -0.13488016f, 0.03165361f, 0.11580595f, 0.07361749f, 0.12957709f, -0.01713925f, -0.27505609f, -0.07893097f, 
    0.04894364f, -0.01359376f, -0.03661277f, 0.01170819f, 0.00611184f, 0.03674055f, -0.27282974f, -0.24888103f, 
    -0.00574421f, 0.03484437f, -0.08765148f, -0.12044680f, 0.07157203f, 0.08067770f, 0.01491554f, 0.15310046f, 
    -0.14042060f, 0.10506199f, -0.05526247f, -0.03381775f, 0.11740704f, 0.11442772f, 0.01714415f, 0.06161277f, 
    0.09246877f, 0.11912500f, -0.00420576f, 0.01075306f, 0.01733871f, 0.02452141f, -0.08837336f, -0.02664949f, 
    0.15986042f, 0.15059721f, -0.17603683f, -0.22655958f, 0.14317970f, -0.19130921f, -0.01789948f, 0.01330863f, 
    -0.02541308f, -0.05512549f, -0.11199772f, 0.03360440f, 0.07899991f, -0.00818210f, 0.12561946f, -0.02467189f, 
    0.00235025f, -0.05560508f, 0.09585294f, 0.02326709f, 0.12547213f, -0.05212133f, 0.01652014f, 0.02512120f, 
    -0.39442158f, -0.24132338f, 0.00528951f, 0.04928465f, 0.02972676f, 0.10703662f, -0.05445721f, 0.12223116f, 
    -0.02137185f, -0.01548763f, -0.08016173f, -0.03996511f, 0.02107798f, -0.03301761f, -0.02703493f, 0.09191957f, 
    -0.00630906f, 0.07435711f, -0.13805178f, 0.19022189f, 0.03881292f, 0.07696242f, -0.13680419f, 0.06712759f, 
    0.25229266f, 0.17164014f, -0.08817758f, -0.23483422f, 0.08441626f, -0.06613735f, -0.10544799f, 0.10672767f, 
    0.08406273f, -0.00990062f, 0.04357093f, -0.03490619f, -0.09504870f, 0.00104242f, -0.04750224f, 0.06179292f, 
    0.11695288f, -0.00793053f, 0.01196568f, -0.01560073f, 0.02961883f, 0.04296513f, 0.00051537f, 0.02111491f, 
    0.06408415f, 0.08853336f, 0.03975846f, -0.07162338f, -0.02888508f, -0.16807082f, -0.13711584f, 0.03997553f, 
    0.05411654f, -0.05308964f, -0.09544615f, -0.01116220f, 0.33390257f, -0.10110003f, 0.06460007f, -0.05853449f, 
    0.07447597f, 0.07440812f, 0.02834270f, -0.04409252f, -0.10667882f, -0.05224437f, -0.05569238f, -0.05523145f, 
    0.04216205f, -0.16056560f, 0.01661953f, -0.05057996f, 0.03533386f, 0.17523898f, -0.03628393f, 0.02823406f, 
    0.10654376f, 0.00391432f, 0.16956857f, -0.17654280f, 0.20943429f, 0.23398007f, -0.09070868f, -0.10262910f, 
    0.03474154f, -0.00501440f, 0.21957524f, 0.20466235f, 0.00172600f, 0.08378608f, 0.03013978f, -0.08601829f, 
    -0.00855020f, -0.07056983f, -0.06198931f, -0.07690191f, 0.01413965f, -0.00405141f, -0.00651812f, 0.05198642f, 
    -0.06272576f, -0.03565370f, 0.06496362f, 0.19207713f, -0.01862925f, -0.00438895f, 0.12797515f, -0.16641049f, 
    -0.09314491f, -0.03912653f, -0.26657051f, 0.12897074f, 0.02368530f, 0.02258309f, -0.11455236f, 0.02036105f, 
    0.00474294f, -0.12487057f, 0.04328326f, 0.20359235f, -0.00019224f, 0.11299361f, 0.03964043f, 0.04618265f, 
    0.22830705f, 0.10741723f, 0.07808014f, 0.07300948f, -0.06845009f, -0.16803378f, 0.11319663f, -0.12140809f, 
    0.14432354f, 0.11226565f, 0.02448372f, -0.22368759f, 0.00831360f, -0.29530656f, -0.08317725f, -0.04476334f, 
    -0.01418651f, 0.06214493f, 0.07858579f, -0.04284824f, -0.10504713f, 0.00857281f, -0.07884058f, 0.17296939f, 
    -0.01311835f, 0.04302312f, -0.01775912f, -0.05486807f, -0.02897994f, -0.09595467f, -0.09506780f, -0.07775910f, 
    -0.11489200f, -0.06057102f, -0.07303464f, 0.06306502f, 0.16254234f, -0.03487476f, 0.01459193f, -0.13410269f, 
    -0.03056109f, -0.21023442f, 0.17424405f, -0.05515357f, -0.17835924f, -0.06108948f, -0.13111754f, 0.16164628f, 
    0.05515141f, 0.09961743f, 0.08154826f, 0.05924508f, -0.05947984f, -0.02468415f, -0.18590610f, 0.20591870f, 
    0.00075346f, 0.03640846f, -0.03850110f, 0.12987421f, -0.10740121f, -0.13527235f, -0.01889498f, -0.11140490f, 
    -0.29851449f, -0.17305037f, -0.29076990f, -0.14369012f, 0.08163678f, 0.06076415f, -0.12500711f, 0.08408922f, 
    -0.01791353f, 0.08782242f, 0.20001675f, 0.00154679f, -0.05365719f, 0.02275928f, 0.18746670f, 0.18530829f, 
    -0.11424808f, 0.01953686f, -0.13342291f, 0.20247832f, 0.04058453f, 0.10639850f, -0.03878925f, -0.01646570f, 
    -0.09953769f, -0.28825146f, 0.27573985f, 0.20652895f, 0.08595417f, 0.08796351f, 0.04852707f, 0.07530139f, 
    0.01784879f, 0.04259479f, -0.04035400f, -0.00899507f, -0.09825820f, 0.14912114f, -0.00946246f, 0.00144666f, 
    -0.09005887f, 0.12394897f, 0.06796129f, 0.01498326f, -0.01972025f, -0.01703975f, -0.06581636f, 0.00611828f, 
    0.13030389f, -0.04399611f, -0.06138901f, -0.02282657f, -0.13718882f, 0.02736960f, 0.03712701f, 0.04371220f, 
    -0.01535394f, -0.00823048f, 0.00476911f, 0.02765588f, 0.03955572f, -0.16196948f, 0.23037636f, 0.12569407f, 
    0.01796491f, -0.01269102f, -0.04531637f, -0.13416143f, -0.02605979f, 0.12984583f, 0.14595389f, 0.11874715f, 
    -0.00918477f, 0.21125087f, 0.02971367f, 0.10692767f, -0.09962150f, 0.12794666f, -0.02383975f, 0.10633896f, 
    -0.04698484f, -0.00281007f, 0.05331402f, -0.03461014f, 0.16198370f, -0.07403690f, 0.44550818f, 0.22606900f, 
    -0.14743797f, -0.05246739f, 0.10318238f, 0.12810019f, 0.05567008f, -0.03844748f, -0.03974305f, -0.11151534f, 
    0.06834066f, 0.08931239f, -0.05159919f, 0.03686442f, -0.09495556f, -0.11490253f, 0.09642549f, 0.01485216f, 
    0.26603508f, 0.25913772f, -0.11759768f, 0.05609061f, -0.05081719f, -0.04121650f, 0.18321860f, 0.05322013f, 
    -0.12572177f, 0.04168884f, -0.05640076f, 0.14711790f, 0.01544218f, 0.15091944f, 0.06263861f, 0.07189666f, 
    -0.03200473f, -0.00517092f, -0.24442722f, -0.04353875f, -0.04853415f, -0.06526934f, 0.05186276f, -0.04907629f, 
    0.06439995f, -0.00498311f, 0.08796302f, 0.02394355f, -0.12698869f, 0.16538642f, 0.13478181f, -0.03327008f, 
    -0.09934999f, -0.02885212f, 0.17178984f, -0.21258287f, 0.00508192f, 0.17518459f, 0.08089161f, -0.04366630f, 
    -0.15112160f, 0.08477235f, 0.11450520f, 0.00096303f, -0.00470424f, 0.11323646f, -0.09670319f, 0.09656313f, 
    0.05118832f, 0.01211136f, 0.14332630f, 0.19053796f, -0.17363004f, -0.02301526f, -0.01314019f, -0.08631478f, 
    -0.24315135f, -0.26287648f, -0.33425996f, -0.33662581f, -0.13441573f, 0.01320813f, -0.02722705f, 0.07980800f, 
    0.00550700f, 0.04460138f, -0.09090165f, 0.17849435f, 0.14427947f, 0.11004163f, -0.06270093f, 0.05313989f, 
    -0.02488433f, -0.11742590f, -0.07768012f, -0.07269814f, 0.22518398f, -0.10605816f, -0.16120367f, -0.14811845f, 
    0.22978570f, 0.17509599f, 0.10165019f, 0.12836032f, 0.06426609f, 0.04212569f, 0.06493854f, -0.07783382f, 
    0.17754091f, 0.07333686f, 0.32474518f, 0.37882203f, 0.01634565f, -0.00915317f, -0.01059775f, -0.27563906f, 
    -0.04220062f, 0.00065920f, -0.09252816f, -0.15560132f, 0.05744400f, 0.07741234f, 0.40318602f, -0.16936566f, 
    0.07627970f, -0.19132866f, -0.03684125f, 0.11077823f, 0.02962773f, -0.01976182f, 0.13707021f, 0.16507107f, 
    -0.05281935f, -0.16565554f, -0.12961699f, 0.07542913f, 0.13306180f, -0.03904372f, 0.12073680f, 0.04806664f, 
    -0.08838709f, 0.17727871f, -0.03216113f, 0.02925252f, 0.09491771f, 0.45450309f, 0.36538255f, -0.17563894f, 
    0.01853480f, -0.09490854f, -0.04652696f, -0.11470191f, 0.09983378f, 0.02306465f, -0.12175012f, -0.14071837f, 
    0.16739829f, 0.09867662f, 0.06471771f, -0.10304367f, 0.17791447f, -0.00576155f, -0.00616156f, 0.06362902f, 
    -0.04637319f, 0.02185262f, 0.11734077f, 0.01389756f, 0.14738695f, 0.20653576f, -0.15159406f, -0.00037025f, 
    0.05055381f, 0.02075484f, 0.09501253f, 0.14545149f, -0.01810406f, -0.06295525f, -0.05421584f, -0.03541748f, 
    -0.05704155f, 0.13270135f, 0.05152562f, 0.38384932f, -0.00938724f, -0.01018776f, 0.14598522f, 0.00109751f, 
    -0.07265660f, 0.09523705f, -0.02405198f, -0.03453524f, -0.22338875f, 0.33406389f, 0.15210842f, -0.03965551f, 
    -0.01049024f, 0.00438526f, -0.13217609f, 0.02731881f, -0.07974453f, 0.02804324f, -0.07069200f, 0.18372139f, 
    -0.12474617f, 0.19123824f, 0.30714473f, -0.05643523f, -0.26655772f, 0.01381372f, -0.15232860f, -0.07847507f, 
    -0.14440975f, -0.09758250f, 0.04167080f, -0.18434380f, 0.13808796f, -0.06551371f, -0.20305994f, 0.17755935f, 
    0.07889391f, 0.13000220f, 0.34232637f, -0.00479460f, 0.12209781f, 0.16072772f, -0.04865117f, 0.02078784f, 
    0.14485070f, 0.04762468f, -0.02524499f, -0.19333492f, -0.01874146f, 0.10015561f, -0.03132619f, -0.33270440f, 
    0.07122123f, -0.02853382f, 0.02240139f, -0.06520443f, 0.12571029f, -0.19831312f, -0.13888097f, 0.11916901f, 
    -0.04797381f, 0.07821069f, -0.01795029f, 0.18658078f, -0.01921759f, 0.15646125f, 0.02678937f, 0.00248352f, 
    0.08808144f, -0.00241616f, -0.19288309f, -0.02727885f, 0.03392211f, -0.03850143f, 0.15188785f, 0.22283877f, 
    -0.02128961f, -0.20895922f, 0.00709069f, 0.00658747f, 0.14892708f, -0.21133079f, -0.05514023f, 0.01993912f, 
    -0.04847640f, -0.03097892f, 0.11161087f, -0.12821475f, 0.00085566f, -0.13337328f, 0.04534072f, -0.17994486f, 
    0.10044613f, 0.34052724f, 0.26005310f, 0.11356379f, 0.07341619f, -0.02475429f, 0.03144938f, 0.21233362f, 
    0.04513963f, -0.01411995f, -0.02211099f, 0.03254674f, 0.47939637f, -0.06953531f, -0.20703159f, -0.16330001f, 
    0.14388496f, 0.11964677f, -0.03368829f, 0.32540098f, 0.18044429f, -0.06746036f, 0.05364602f, 0.05060939f, 
    -0.13629210f, -0.07719968f, -0.03423508f, -0.05632911f, 0.08377348f, 0.01929237f, -0.06313015f, -0.02590252f, 
    -0.04738225f, 0.10120353f, 0.11645970f, 0.03098020f, -0.31166485f, 0.01873072f, 0.10145711f, 0.29043597f, 
    -0.06263884f, 0.07714746f, -0.19267172f, 0.07876494f, 0.08134151f, 0.08155304f, -0.06041401f, -0.09120971f, 
    0.13015954f, -0.02486897f, 0.22669150f, 0.27111581f, 0.09281492f, 0.01628152f, 0.19393042f, -0.08905821f, 
    0.10249317f, 0.08629047f, 0.12069038f, -0.00578127f, -0.38407412f, -0.14762601f, -0.01107409f, -0.17184688f, 
    -0.04980462f, -0.08575306f, -0.09019300f, -0.04978413f, -0.05201056f, -0.11140496f, -0.11904503f, -0.11845940f, 
    -0.08702873f, 0.09524012f, 0.14554408f, 0.01426286f, -0.06009932f, -0.01600686f, 0.04297575f, -0.02097789f, 
    0.04211927f, -0.10007615f, -0.14042109f, -0.28871927f, -0.02555671f, -0.02954994f, 0.23156197f, -0.02624085f, 
    0.17854860f, 0.11180405f, -0.03373892f, 0.09417209f, 0.07985632f, 0.00300810f, 0.02330128f, 0.02416333f, 
    0.21757409f, 0.08376274f, -0.06103495f, -0.11046204f, -0.11556808f, -0.26494083f, -0.04811313f, -0.00991908f, 
    -0.07204948f, 0.24314438f, -0.07427862f, -0.16374235f, 0.36596945f, 0.10048158f, 0.28130424f, 0.04484535f, 
    0.07151738f, -0.03510216f, -0.00798447f, 0.43989113f, 0.02703633f, -0.09349692f, 0.07256149f, -0.17994267f, 
    0.25070405f, -0.05815241f, 0.06151577f, 0.20154850f, -0.07246140f, -0.12025364f, 0.07725143f, 0.01692671f, 
    0.33728373f, 0.08339962f, 0.17893873f, 0.25851661f, -0.03330282f, 0.11422399f, -0.29248145f, -0.22356999f, 
    -0.00378086f, -0.14863147f, 0.04531342f, -0.01591784f, -0.19147286f, 0.00134624f, -0.30776891f, -0.12963670f, 
    0.17678709f, -0.06049319f, -0.01207648f, 0.07039614f, -0.04148229f, 0.07481390f, 0.02606565f, -0.04981754f, 
    -0.01211728f, 0.04112848f, 0.06711087f, 0.01066746f, -0.04313796f, 0.23381458f, -0.10531722f, -0.03633263f, 
    0.12617873f, 0.11318557f, 0.10949873f, -0.15764582f, 0.07753285f, -0.09383778f, -0.05009577f, -0.15436912f, 
    -0.18846099f, 0.21866851f, -0.06370449f, -0.16584359f, 0.09714034f, 0.16491733f, 0.00411857f, 0.01198488f, 
    0.10220013f, 0.07460641f, -0.16177274f, -0.09094110f, 0.07508482f, -0.12181275f, -0.10473929f, -0.05235002f, 
    0.29532218f, 0.06248659f, 0.18830360f, 0.14069627f, -0.21092212f, -0.37876916f, -0.00923866f, -0.39865345f, 
    0.03484283f, 0.25686347f, 0.03981465f, -0.00150894f, 0.12634759f, -0.11701086f, 0.13503826f, 0.18569571f, 
    0.09612964f, 0.09433241f, -0.02710908f, 0.01151857f, 0.04563427f, 0.04109899f, 0.21794987f, 0.11643707f, 
    0.13970254f, 0.01331421f, -0.09060560f, -0.02349881f, 0.16086940f, 0.09528351f, 0.03482924f, 0.11698443f, 
    -0.20528455f, -0.10010664f, -0.21177037f, -0.32894108f, 0.00641419f, -0.15181619f, 0.21468715f, 0.11027003f, 
    -0.09056342f, -0.00293447f, -0.00669165f, 0.23307624f, -0.06737518f, 0.26082397f, -0.20142525f, 0.28907502f, 
    0.20980173f, 0.23191148f, 0.19922018f, -0.11089817f, -0.24745731f, -0.13269380f, -0.16020401f, -0.32492605f, 
    0.23384403f, 0.35129681f, 0.11062101f, 0.02175993f, -0.04427389f, -0.13272715f, -0.10976590f, 0.02035823f, 
    0.00350639f, 0.13815749f, -0.04316754f, 0.07211018f, -0.27448228f, -0.16063558f, -0.22183216f, 0.05568473f, 
    0.18861070f, -0.05604394f, -0.12448718f, -0.16171890f, -0.16887738f, -0.13983165f, 0.00806906f, -0.07230426f, 
    0.02036162f, 0.04565672f, 0.00100718f, -0.24633910f, 0.25392067f, 0.07661507f, -0.10154571f, -0.00414862f, 
    -0.07695130f, -0.17357722f, -0.24659920f, -0.45327854f, 0.19761983f, 0.07902170f, 0.05621257f, 0.12390720f, 
    0.10121850f, 0.14344931f, 0.02241379f, 0.01294099f, 0.13501203f, 0.09583639f, 0.11607405f, 0.13870393f, 
    -0.14684978f, -0.03032771f, -0.02125290f, -0.03072180f, 0.05604636f, -0.01433682f, -0.02097101f, -0.11104290f, 
    -0.05474797f, 0.04389454f, -0.16310225f, 0.03281648f, 0.03379018f, 0.06723470f, -0.00514890f, 0.11883835f, 
    -0.03211875f, 0.17916517f, 0.18408507f, 0.25588745f, 0.02069912f, -0.04473774f, -0.24919730f, -0.30979753f, 
    0.05519933f, -0.18432820f, -0.09758637f, 0.17597887f, -0.11720818f, 0.19394615f, 0.22476311f, -0.00441451f, 
    -0.00719141f, 0.11868895f, 0.16381831f, 0.30222023f, -0.25475907f, -0.05608691f, 0.11024272f, -0.19824409f, 
    0.20163012f, 0.04399847f, -0.04691963f, 0.13680200f, -0.15671793f, -0.06331319f, -0.07823254f, -0.15573098f, 
    0.31003815f, 0.39256313f, 0.12189373f, -0.00800880f, 0.02358984f, -0.08316471f, -0.16634564f, -0.08299562f, 
    -0.01071207f, 0.13631496f, 0.14105740f, 0.28080794f, -0.05335286f, 0.29775262f, -0.15540592f, 0.11981755f, 
    0.02991924f, 0.00045543f, 0.12563589f, -0.13846615f, 0.10113737f, -0.02873663f, -0.29734901f, -0.03042446f, 
    0.03997736f, -0.03453896f, -0.09767649f, 0.21608444f, 0.11520589f, 0.00832631f, -0.06495511f, -0.16451216f, 
    0.07748789f, -0.01084635f, 0.05902679f, -0.01231137f, 0.15029992f, 0.07307642f, 0.11760926f, 0.05266253f, 
    0.09551827f, -0.07453461f, -0.06116810f, -0.00816403f, 0.04384071f, 0.03567034f, 0.01735664f, 0.10417814f, 
    -0.03164423f, 0.19880186f, 0.04411098f, 0.11639895f, 0.02459922f, 0.10632420f, 0.09109481f, 0.05264810f, 
    0.04313862f, 0.00268258f, -0.01178305f, 0.08149611f, -0.13743387f, -0.12893468f, 0.01507938f, -0.41468376f, 
    -0.09795927f, 0.05530325f, -0.10334372f, 0.00940559f, 0.04185500f, 0.03703045f, 0.02043154f, 0.08103189f, 
    0.13259357f, -0.00970450f, -0.04654480f, -0.02429250f, -0.02716254f, 0.02974310f, 0.00503711f, -0.03596711f, 
    -0.05507874f, -0.08158080f, 0.05164681f, 0.06038157f, 0.00351530f, 0.26789790f, -0.27916220f, 0.23538730f, 
    0.04514134f, 0.00804640f, 0.14811684f, -0.02656424f, -0.01451738f, -0.00021047f, 0.01114283f, -0.03659869f, 
    0.00728704f, 0.27772966f, 0.13606884f, -0.14285590f, -0.00812520f, 0.03474128f, 0.05670176f, 0.02220963f, 
    0.03616085f, -0.01785478f, -0.02856078f, -0.02487069f, -0.14264023f, -0.16806176f, -0.02143910f, 0.16387093f, 
    0.13031127f, -0.12590219f, -0.00223041f, -0.06807134f, 0.02751093f, -0.03383577f, -0.07513656f, -0.01143510f, 
    -0.20724641f, -0.16665907f, 0.01139342f, -0.00119909f, 0.03187453f, 0.08737976f, 0.04361051f, 0.09162775f, 
    0.08841639f, 0.01498502f, 0.09380051f, 0.04564015f, -0.12466805f, 0.04772300f, 0.15330561f, -0.00681780f, 
    0.00491263f, 0.00721400f, -0.06390050f, 0.06397107f, -0.00510621f, -0.01739329f, 0.03226791f, -0.12505747f, 
    0.07913658f, -0.08128591f, 0.22847562f, -0.14604151f, 0.16289869f, 0.00646260f, 0.01585121f, 0.00648314f, 
    -0.04105834f, -0.06833877f, 0.23702788f, -0.19569016f, 0.22034478f, -0.09679446f, -0.17967562f, 0.08111709f, 
    0.10576446f, -0.05842785f, 0.08927323f, -0.22051078f, -0.03238178f, 0.01655263f, 0.03959001f, 0.09454055f, 
    0.14925723f, -0.04070688f, 0.03355530f, 0.06700141f, 0.01156962f, 0.06702143f, 0.06319307f, -0.01657893f, 
    0.07354793f, 0.05588539f, -0.00891658f, -0.10329197f, 0.04841068f, 0.11782696f, -0.15015258f, -0.00833709f, 
    0.14395729f, -0.11648072f, -0.01316222f, -0.11578898f, -0.11175364f, -0.09265034f, 0.08635404f, -0.00235112f, 
    0.16993648f, 0.09416883f, 0.25388309f, 0.04712355f, -0.01762544f, -0.08581926f, -0.13009629f, -0.02406530f, 
    -0.02581849f, 0.03866023f, 0.01708734f, -0.02497145f, -0.12498039f, 0.42177781f, -0.07774810f, -0.08941247f, 
    0.01695373f, -0.03492993f, -0.05417899f, -0.09207916f, 0.06186593f, 0.16501638f, 0.05503013f, 0.01932441f, 
    -0.03155548f, -0.00180032f, 0.01194803f, -0.09673935f, 0.03082745f, -0.06332434f, 0.01571289f, -0.07390808f, 
    -0.13451876f, -0.09592067f, 0.02766021f, -0.01042695f, -0.14358543f, 0.01881651f, 0.00771324f, -0.05607131f, 
    -0.08352360f, -0.05775167f, -0.07915326f, -0.05056352f, -0.13819782f, -0.10088761f, 0.01865435f, 0.05690540f, 
    0.07824431f, -0.06841580f, -0.22716968f, 0.06917034f, 0.08434790f, 0.01473661f, 0.04336743f, -0.14132714f, 
    -0.00628149f, 0.09250703f, -0.04895065f, 0.07250460f, -0.23799235f, -0.23560429f, 0.16714163f, -0.16268939f, 
    0.13853435f, 0.07248571f, 0.23993386f, 0.04170538f, 0.05102148f, 0.15788634f, 0.02139653f, 0.08975001f, 
    0.14066808f, -0.00493236f, 0.36132526f, 0.17258333f, -0.06105936f, 0.04561322f, 0.02068981f, -0.11959442f, 
    0.07669968f, -0.05686235f, 0.07968497f, 0.18378128f, 0.17284869f, -0.09380344f, 0.03822739f, -0.03731688f, 
    0.22507946f, 0.17905763f, 0.24475297f, 0.05501969f, -0.08126022f, -0.12011578f, -0.08672208f, 0.04684393f, 
    0.02762754f, 0.00708638f, -0.25425288f, -0.09589095f, -0.07235628f, 0.03084901f, -0.05769128f, 0.03697212f, 
    0.09058891f, 0.00167992f, -0.03951190f, -0.07124289f, 0.07338925f, 0.13651241f, 0.07840615f, 0.09557310f, 
    -0.00590413f, -0.07782310f, -0.12059694f, -0.01267373f, 0.02066332f, -0.01502423f, -0.01953678f, 0.04372379f, 
    0.02394416f, -0.02562806f, -0.10238470f, -0.16253789f, 0.19510229f, -0.06957809f, 0.14047390f, -0.01558667f, 
    -0.00224746f, 0.01497985f, -0.01522373f, -0.02292686f, 0.09068155f, 0.01277180f, -0.00459116f, -0.07281239f, 
    -0.02627587f, -0.09412206f, 0.03260187f, -0.03883367f, 0.12033736f, -0.00223198f, 0.06016575f, 0.00204462f, 
    -0.10099169f, -0.10722787f, 0.04042161f, 0.10972682f, -0.00508272f, -0.00737441f, 0.17651793f, 0.03026571f, 
    0.12643956f, -0.02870205f, -0.04321370f, 0.03861901f, -0.20450942f, 0.24884334f, 0.07415480f, -0.10046706f, 
    0.07184252f, -0.02726058f, 0.00040207f, 0.10270362f, -0.00611811f, -0.03970876f, 0.01233907f, 0.01698762f, 
    -0.13612166f, 0.00264597f, 0.04650915f, -0.03862377f, 0.03091041f, 0.03729960f, -0.02394054f, 0.07305741f, 
    -0.27371645f, -0.11992104f, 0.04064246f, -0.28596067f, 0.05148604f, 0.09435806f, 0.01825113f, 0.03808453f, 
    0.09390189f, 0.12915292f, 0.15356061f, 0.10536629f, 0.10745534f, -0.10303909f, 0.04148075f, 0.02574769f, 
    0.11034221f, -0.08512397f, -0.00388779f, -0.16378948f, -0.02475805f, -0.02149009f, -0.01645605f, -0.06888653f, 
    0.25448546f, 0.04683020f, 0.01903602f, -0.01600849f, -0.18231143f, -0.20693339f, -0.07140138f, 0.25832081f, 
    0.13165697f, 0.09988061f, 0.02198824f, 0.12425992f, 0.05286297f, -0.03835627f, -0.04005756f, -0.00361830f, 
    -0.02313143f, 0.06943253f, -0.02797191f, -0.01258852f, -0.02166634f, 0.06027184f, -0.06480157f, 0.01203887f, 
    -0.04459027f, -0.06810587f, 0.01106598f, 0.01774373f, 0.05324919f, -0.09693775f, -0.03761892f, -0.09937899f, 
    -0.12036899f, 0.00854154f, 0.02070381f, 0.01794101f, 0.06154235f, 0.03459866f, -0.00387331f, -0.12438642f, 
    -0.07058001f, 0.00266320f, 0.16636169f, -0.16957805f, 0.03617264f, -0.07301141f, -0.03759091f, 0.04272498f, 
    -0.05334947f, -0.06823239f, 0.01472006f, 0.07958216f, -0.11408890f, 0.04692755f, 0.14049348f, 0.05173455f, 
    -0.23155318f, -0.14785384f, -0.04192716f, 0.15770240f, 0.05884987f, -0.08322348f, 0.06697438f, 0.03646525f, 
    -0.07530683f, -0.14503917f, 0.08230275f, 0.19605216f, 0.02123076f, -0.00635252f, -0.03242981f, 0.14781377f, 
    0.08721092f, -0.01083290f, 0.22709799f, 0.06814525f, 0.00579861f, -0.13538730f, -0.10078548f, -0.06388451f, 
    0.04412285f, 0.07529398f, -0.00376077f, 0.16431758f, 0.04965489f, 0.00487223f, -0.06788140f, -0.05619338f, 
    -0.01175848f, 0.15861668f, 0.20789558f, -0.25231457f, 0.01463060f, 0.06202337f, -0.00146378f, 0.13255116f, 
    0.07808461f, -0.05719299f, -0.04752983f, -0.14546295f, 0.00960765f, 0.05857727f, 0.21853773f, 0.22138274f, 
    -0.02541185f, 0.21242854f, 0.06269494f, 0.01239625f, 0.07412161f, -0.06033396f, -0.13028570f, 0.08153442f, 
    -0.00565883f, -0.10720754f, 0.04859692f, -0.04117644f, -0.00560522f, -0.05219086f, 0.05761847f, 0.19286001f, 
    0.03916276f, -0.06767280f, 0.03289602f, 0.05389813f, -0.01612867f, -0.25935763f, 0.21103510f, 0.04416371f, 
    0.09007955f, -0.01855978f, 0.06942195f, -0.08402736f, -0.03261262f, 0.01390489f, 0.11077949f, -0.01549836f, 
    0.17799719f, -0.09221077f, 0.22188535f, -0.21028525f, 0.21997038f, 0.25313216f, -0.00534872f, 0.30286652f, 
    0.08534306f, -0.14332543f, 0.21692598f, -0.07221134f, 0.05453296f, -0.00590052f, 0.13500209f, 0.07783595f, 
    0.14720856f, -0.03135687f, 0.10295460f, -0.00490793f, -0.00377746f, -0.01378733f, 0.04634279f, -0.14976993f, 
    0.24271014f, 0.03367274f, -0.09432850f, -0.12551530f, -0.03750145f, -0.02461901f, -0.01081238f, 0.09095236f, 
    -0.08822523f, 0.10927742f, -0.03319404f, 0.07859798f, 0.03543893f, 0.01342665f, 0.21828592f, -0.15431534f, 
    -0.10479958f, 0.11342935f, -0.01665744f, 0.23861913f, -0.02100556f, 0.09237488f, 0.01460334f, 0.16356741f, 
    0.01625804f, -0.21169721f, 0.06862870f, 0.17266713f, 0.01791503f, -0.17994797f, -0.00372051f, 0.03891058f, 
    0.24396594f, 0.03444067f, 0.12436496f, 0.07136068f, -0.25667751f, -0.07238700f, 0.03686213f, -0.31466302f, 
    0.05096806f, 0.11498304f, 0.18357313f, -0.19563775f, 0.10182326f, -0.01136895f, -0.02879629f, 0.02132484f, 
    -0.00994097f, 0.21056867f, 0.05067707f, -0.30529612f, 0.05619964f, 0.02541148f, -0.02741414f, 0.24470960f, 
    -0.09590749f, 0.05592395f, 0.03232541f, -0.27602094f, 0.07179239f, -0.08727530f, -0.16639990f, -0.12881541f, 
    0.30038574f, 0.18168636f, -0.10766477f, 0.04587863f, -0.07495055f, -0.34405681f, -0.15922123f, -0.31818101f, 
    0.19137394f, 0.14205898f, 0.03907542f, 0.06439387f, -0.01809675f, -0.11252779f, 0.14477587f, 0.19490065f, 
    -0.09944919f, 0.09871901f, -0.04173879f, 0.03938946f, 0.20327714f, -0.00585662f, -0.06426571f, 0.11180449f, 
    0.18388675f, 0.11264323f, 0.00669538f, 0.05465655f, -0.09250253f, 0.06017006f, 0.04547966f, 0.10704608f, 
    -0.38115796f, -0.10942719f, -0.07938840f, -0.18308938f, -0.01575663f, -0.09071637f, 0.10147968f, 0.17735972f, 
    -0.10442413f, 0.07880083f, -0.12511602f, 0.25700063f, 0.06843448f, 0.11533741f, 0.31947502f, 0.18933003f, 
    0.08947778f, 0.25571486f, -0.14449643f, -0.00442003f, -0.23067376f, -0.09773586f, 0.01720833f, -0.32405987f, 
    0.05313186f, -0.11249571f, -0.00665988f, 0.20405601f, 0.11180992f, -0.00287806f, -0.03770840f, -0.03486925f, 
    -0.00120444f, 0.15873484f, -0.04250413f, -0.05868036f, -0.20609862f, 0.09083944f, -0.06123309f, -0.10820767f, 
    0.00787555f, 0.03109588f, -0.06086711f, -0.07398246f, -0.23639342f, -0.31541952f, 0.13634618f, -0.17873894f, 
    0.18555860f, 0.23476398f, -0.11370279f, -0.25228524f, 0.16954412f, -0.03999919f, -0.08962160f, -0.15657471f, 
    -0.21196102f, -0.24544659f, -0.18888326f, -0.45508525f, 0.22565506f, 0.02207968f, 0.10118772f, 0.05677626f, 
    -0.00347348f, 0.24292946f, 0.16459748f, 0.06295965f, -0.01759343f, 0.07763382f, 0.10786302f, 0.17480567f, 
    -0.14969113f, 0.31516084f, -0.31212699f, 0.29048470f, -0.09940052f, -0.13360292f, 0.03634010f, -0.04212684f, 
    -0.08193692f, 0.32693836f, -0.18755913f, 0.02012580f, 0.24225782f, 0.20576671f, 0.14954017f, 0.14015114f, 
    0.09481426f, 0.01018621f, 0.25397277f, 0.22192976f, -0.04912774f, 0.09056027f, -0.03140422f, -0.22964546f, 
    -0.06409484f, -0.02814596f, 0.14263324f, 0.16191180f, 0.02376342f, -0.09079593f, 0.03550077f, -0.04399833f, 
    0.32252577f, 0.23301309f, 0.28052786f, 0.28454003f, -0.22260569f, -0.06610620f, 0.17408861f, -0.05890709f, 
    0.17432360f, 0.02283485f, -0.16530952f, 0.03229128f, -0.21223523f, 0.01518340f, -0.09089374f, -0.11354632f, 
    -0.04364950f, 0.12032717f, -0.20350790f, -0.22833879f, -0.02898017f, 0.10899097f, 0.01070662f, -0.09020600f, 
    -0.13378197f, -0.03645102f, 0.09770629f, 0.25021651f, 0.09446432f, 0.08402912f, -0.00436283f, 0.15538032f, 
    -0.08592869f, -0.01718142f, 0.11664117f, -0.16240604f, -0.01535078f, -0.00574541f, -0.19033200f, -0.17460322f, 
    0.10592452f, -0.09037115f, -0.13201429f, -0.07984293f, 0.10547304f, -0.05186490f, -0.07729594f, -0.03436096f, 
    0.10357069f, -0.07078476f, -0.05486998f, -0.12529735f, -0.06048107f, -0.07296024f, -0.07946284f, -0.00684252f, 
    -0.01209790f, -0.03665014f, -0.02770270f, -0.05789308f, 0.12743452f, 0.05363481f, -0.03963681f, 0.05457972f, 
    -0.21070418f, -0.06214448f, -0.04234675f, -0.05791878f, 0.01550449f, 0.02868198f, 0.05980977f, 0.05756492f, 
    -0.01448193f, 0.03579074f, 0.01122542f, 0.07952776f, -0.34130076f, 0.00503232f, 0.42140624f, 0.16083801f, 
    -0.12887004f, -0.09304180f, -0.02176458f, 0.13804539f, -0.03311723f, 0.00063807f, 0.02277560f, 0.07493304f, 
    -0.01375352f, 0.10033458f, -0.28912693f, -0.25262260f, 0.03584247f, 0.07506432f, 0.06497646f, 0.05542466f, 
    0.13673136f, -0.03764914f, 0.07282154f, -0.02370194f, -0.12535250f, 0.08060542f, -0.42914614f, 0.06855302f, 
    -0.02646744f, 0.15799150f, -0.00298299f, 0.05126348f, -0.06229313f, -0.01571593f, -0.06095749f, -0.07692257f, 
    0.02045029f, 0.24310686f, 0.17105164f, 0.01061017f, -0.04476577f, 0.06713296f, 0.11889199f, 0.07257077f, 
    0.08824788f, -0.05344067f, -0.00491122f, -0.07704289f, -0.03925445f, -0.30056003f, -0.21645463f, 0.05135969f, 
    0.02134953f, -0.05087381f, 0.01333700f, 0.10824452f, 0.04513270f, -0.12886399f, -0.01236771f, 0.10379309f, 
    -0.05421428f, -0.16164303f, -0.05559301f, 0.16164930f, 0.05076906f, 0.08131002f, -0.03617725f, 0.21024354f, 
    -0.06246972f, -0.02995072f, -0.09523232f, 0.01654185f, -0.22656466f, -0.11021685f, 0.21966058f, 0.07053748f, 
    0.09894795f, -0.06568090f, 0.00262491f, -0.00450860f, 0.05067888f, 0.06413619f, 0.07412932f, 0.03612088f, 
    -0.11420418f, -0.12767027f, 0.11787065f, -0.30075410f, 0.12361744f, -0.02941799f, 0.02997696f, -0.04590796f, 
    0.12311923f, -0.00048793f, 0.00996860f, 0.05876277f, 0.28963089f, -0.26248813f, 0.03042219f, -0.05034244f, 
    0.10470071f, 0.08550121f, 0.12506132f, 0.04019960f, -0.01563337f, -0.04189658f, -0.01255733f, -0.12176498f, 
    0.12616698f, -0.04883454f, -0.19280824f, 0.05006425f, 0.00516266f, 0.02595537f, 0.04086647f, -0.07691546f, 
    0.01757904f, 0.15294202f, -0.06525995f, 0.04505085f, -0.22985071f, 0.23640259f, 0.05582671f, -0.08711611f, 
    0.00485145f, 0.03841176f, -0.22776477f, -0.03439431f, 0.07418624f, -0.06233582f, 0.05821060f, -0.00352112f, 
    0.10506930f, 0.14574623f, 0.16383700f, 0.08607960f, -0.05335342f, -0.05474393f, -0.00815239f, 0.07271497f, 
    0.12442237f, 0.05079124f, 0.00886823f, 0.05891373f, 0.00643298f, 0.31369239f, -0.10741217f, 0.12183846f, 
    0.22218104f, -0.05760818f, -0.03555366f, -0.00050301f, 0.10242640f, -0.02501464f, 0.03778277f, -0.11131507f, 
    -0.12990369f, 0.18429789f, -0.37757871f, 0.00661250f, 0.11943737f, 0.19171564f, 0.02821645f, 0.07238848f, 
    0.06023369f, 0.09171192f, -0.11741248f, -0.11060259f, -0.15818568f, -0.33382785f, -0.08561598f, -0.07823605f, 
    -0.05791748f, -0.11367920f, -0.10973675f, 0.03167009f, 0.07798865f, 0.04040895f, 0.04966367f, -0.16064852f, 
    -0.06810825f, 0.06848449f, 0.10442668f, -0.03597606f, 0.16056013f, -0.05269419f, 0.02025643f, 0.10560672f, 
    0.05730118f, 0.10402431f, -0.08657349f, 0.16747139f, -0.27689034f, -0.33103138f, 0.02957156f, -0.31198508f, 
    -0.03763886f, -0.09791671f, -0.05108671f, 0.08033858f, -0.02205168f, 0.00178667f, 0.01475840f, 0.05140347f, 
    -0.03657177f, -0.25665933f, -0.19282073f, -0.18073376f, -0.05610903f, -0.04530992f, 0.05006679f, 0.13837785f, 
    0.13927054f, -0.07375551f, 0.17058004f, 0.05191085f, -0.01240204f, 0.26806119f, -0.49631429f, 0.41214705f, 
    0.08269174f, 0.20200057f, 0.06001554f, -0.02433545f, -0.12710483f, 0.08473594f, -0.10173032f, 0.06876229f, 
    0.00797492f, 0.10901523f, 0.23648281f, -0.04628601f, -0.03130775f, 0.07519007f, 0.10709084f, 0.22259325f, 
    -0.09251831f, -0.19094604f, -0.12693155f, -0.05777274f, -0.41785949f, -0.02488648f, -0.02423053f, 0.01174613f, 
    0.24364303f, 0.10193327f, 0.05052798f, -0.01820115f, 0.04134787f, -0.05190355f, 0.02218704f, 0.11661581f, 
    0.07009164f, -0.18829401f, 0.16737887f, 0.21824628f, 0.18491651f, -0.03442981f, -0.17991424f, 0.11940122f, 
    -0.01199593f, 0.00052055f, -0.08330335f, -0.11218522f, 0.00576138f, 0.02631394f, 0.36224771f, 0.05990822f, 
    0.07885500f, 0.02395829f, 0.11756440f, 0.06136155f, 0.00432663f, 0.02476985f, 0.14122336f, -0.04150547f, 
    -0.20789117f, 0.05176691f, -0.16014160f, -0.23855570f, 0.30789578f, -0.06728815f, 0.07551380f, 0.05888986f, 
    -0.07180038f, 0.03960548f, 0.14511876f, -0.02590095f, 0.20322248f, -0.02989189f, 0.10071500f, 0.15829892f, 
    0.10254227f, -0.01947102f, 0.09199145f, 0.04131192f, 0.00816699f, -0.04934661f, 0.00996935f, -0.11271565f, 
    -0.09844409f, -0.16350821f, -0.06475613f, -0.08960012f, -0.17790204f, 0.14470878f, 0.20163882f, -0.01909140f, 
    0.14689630f, 0.11838640f, -0.13205671f, 0.02071366f, -0.06759823f, 0.13408127f, 0.03928186f, -0.12243612f, 
    0.18839993f, 0.00677903f, -0.08483118f, 0.14712150f, 0.02634769f, -0.00540712f, 0.16899858f, 0.22374533f, 
    0.19760694f, 0.08342540f, 0.05630422f, -0.09730735f, -0.08322176f, -0.21806271f, -0.16902015f, 0.14154103f, 
    0.18304105f, 0.02317952f, 0.10892917f, 0.09559311f, -0.27104247f, 0.14529462f, -0.18939355f, -0.01761915f, 
    -0.05086074f, -0.04037854f, 0.16736357f, -0.20244792f, 0.08634186f, 0.04556869f, -0.03888240f, -0.17185880f, 
    0.04766130f, 0.06214562f, 0.04869079f, -0.07384347f, 0.00923798f, -0.03083691f, 0.03365344f, -0.07290750f, 
    -0.06095788f, 0.02812978f, 0.04268264f, -0.01754739f, -0.00430618f, 0.01808039f, 0.00553872f, 0.05556287f, 
    -0.00784262f, -0.02442151f, -0.05395188f, 0.03107539f, 0.06054613f, -0.03564554f, 0.00785142f, -0.01340018f, 
    0.03000735f, -0.01865790f, -0.01706975f, 0.05520069f, 0.04932546f, -0.04501282f, -0.05757140f, 0.04106587f, 
    0.01914391f, 0.03194173f, -0.02576591f, -0.06896302f, 0.04725875f, 0.00038970f, 0.02114093f, -0.02424073f, 
    -0.07545350f, -0.01840658f, 0.04426583f, 0.01009990f, 0.03832979f, -0.06742015f, -0.06576876f, -0.02861527f, 
    0.00948135f, -0.00852896f, -0.05965250f, -0.00100499f, 0.00164331f, -0.04477690f, -0.00123663f, -0.05080820f, 
    -0.01792070f, -0.07515498f, -0.06135524f, -0.06587934f, -0.04998287f, 0.06458171f, 0.01656532f, -0.07661168f, 
    0.06174754f, 0.03495645f, -0.07485484f, 0.03933510f, 0.06044878f, 0.02196787f, -0.05753627f, 0.01460485f, 
    -0.01559866f, 0.01428170f, 0.04289017f, 0.05078319f, 0.01489575f, 0.03663513f, -0.06183910f, 0.03412930f, 
    -0.06994348f, -0.07540730f, -0.01526105f, -0.06224293f, -0.07701728f, -0.07011152f, -0.00287776f, 0.04572210f, 
    -0.03819219f, -0.06501330f, 0.04081438f, -0.05544175f, 0.03218128f, -0.04237101f, 0.05846126f, 0.06127304f, 
    -0.07256888f, -0.07478698f, -0.03554323f, 0.03809239f, -0.05894584f, 0.04257575f, 0.00810569f, -0.03738489f, 
    -0.06945356f, -0.03199018f, -0.02873089f, 0.02859225f, 0.00239042f, -0.07824796f, 0.03029539f, -0.03246744f, 
    -0.01752241f, 0.00140095f, 0.01236914f, 0.05390007f, -0.06543175f, -0.02081149f, -0.01660307f, 0.04082498f, 
    0.02164784f, -0.02610694f, -0.03535439f, -0.06594715f, -0.07223955f, -0.05913344f, -0.06685179f, -0.07525232f, 
    -0.04115051f, 0.00787388f, -0.06151459f, -0.01153309f, 0.00695675f, 0.06243411f, -0.00113919f, -0.01395375f, 
    -0.06060223f, -0.03917396f, 0.00535750f, 0.06190575f, -0.03862782f, -0.05976933f, -0.06908754f, 0.03081568f, 
    -0.03458311f, -0.01105783f, -0.04273405f, -0.01372241f, 0.06246826f, -0.07226408f, 0.02074889f, 0.04658234f, 
    0.00662831f, 0.05555559f, 0.00154547f, -0.03815307f, -0.05547820f, -0.05971374f, 0.01288647f, -0.01465653f, 
    0.04503861f, -0.03363260f, 0.00284860f, -0.02155011f, -0.05674498f, -0.03006190f, 0.00277350f, -0.05300132f, 
    0.05735712f, -0.05771254f, -0.01939004f, -0.05025317f, -0.04185848f, 0.05979082f, -0.00418398f, 0.05115202f, 
    0.02332427f, 0.06138454f, 0.01472518f, -0.05244216f, 0.03500758f, 0.04402161f, -0.05877365f, 0.02008438f, 
    0.04514515f, 0.02320464f, 0.01812203f, -0.02277267f, 0.01323557f, -0.04644419f, 0.00610326f, -0.03546535f, 
    -0.07411454f, -0.06352985f, -0.07502873f, -0.01718139f, 0.02738856f, -0.08489671f, 0.02852472f, 0.03064084f, 
    0.05121024f, -0.04423376f, -0.02184461f, -0.06575887f, -0.01949669f, 0.01706056f, -0.04185748f, -0.00165822f, 
    0.03856501f, 0.02726368f, 0.05768720f, -0.00277782f, -0.04659537f, 0.02023215f, 0.02696587f, 0.05852646f, 
    -0.03509828f, 0.02838131f, 0.00546158f, -0.00900143f, 0.04336038f, -0.01064551f, 0.04020786f, -0.05835025f, 
    -0.04359423f, -0.04339656f, 0.00459425f, -0.02132311f, -0.02818495f, -0.06182787f, 0.01363681f, -0.00937562f, 
    0.00474743f, 0.00928138f, 0.00666693f, -0.07581462f, 0.03729782f, 0.01603691f, 0.04751087f, 0.02559757f, 
    0.03040604f, -0.06965038f, 0.03296090f, -0.05600200f, -0.05155302f, -0.02490987f, 0.05640458f, -0.04083022f, 
    0.02209815f, 0.04269148f, -0.01197841f, 0.02411702f, 0.00734436f, 0.05047873f, -0.05572078f, -0.00667669f, 
    0.03609319f, -0.05360937f, 0.03931952f, -0.01025887f, -0.06066719f, 0.06017839f, -0.07367672f, 0.04092646f, 
    -0.01607173f, -0.03092065f, -0.01555247f, -0.08022586f, -0.00576139f, -0.00421194f, -0.00435910f, -0.05453810f, 
    0.03967309f, 0.05581765f, -0.01371404f, 0.06163519f, -0.07294095f, -0.04102108f, -0.07124290f, -0.00147496f, 
    -0.00326930f, -0.06450749f, -0.03254902f, -0.02339921f, -0.01453640f, 0.05909332f, 0.04951265f, 0.05383862f, 
    0.02891458f, -0.00500227f, 0.05246443f, -0.04258969f, -0.06772076f, -0.03433270f, -0.04247194f, -0.03059458f, 
    0.03853394f, -0.02349855f, -0.06936283f, 0.05955524f, -0.04041637f, 0.01841860f, -0.03426428f, -0.06550997f, 
    0.05057457f, -0.02657110f, -0.01166167f, -0.05254095f, 0.01494665f, -0.02372147f, -0.01868695f, 0.06466145f, 
    -0.02442557f, 0.03136413f, 0.03284314f, -0.04048760f, -0.06248393f, 0.03833061f, 0.04529988f, -0.06055395f, 
    -0.03478926f, -0.07213470f, -0.03155505f, 0.04759994f, -0.02633347f, -0.04737405f, 0.04901504f, -0.01814140f, 
    0.05813171f, -0.03117426f, -0.01682439f, 0.05459486f, 0.05594802f, -0.01754429f, 0.03771622f, -0.07937802f, 
    0.00036210f, -0.01295716f, -0.07177238f, 0.04042422f, -0.00732811f, -0.05837041f, -0.02098465f, 0.00670015f, 
    0.01394152f, -0.02472340f, 0.06323910f, 0.01820876f, -0.08106919f, -0.08044828f, 0.00899144f, 0.05573968f, 
    -0.02054884f, -0.07284494f, -0.04527083f, -0.05627218f, -0.01198893f, 0.01544124f, 0.04327784f, -0.07646814f, 
    0.01330512f, 0.04111430f, -0.05249463f, -0.01830364f, -0.04986077f, -0.00523800f, -0.05109676f, 0.04822888f, 
    -0.01044605f, -0.06992114f, -0.05175922f, 0.06740910f, -0.02809690f, 0.05023383f, -0.04182188f, -0.00826184f, 
    -0.07110646f, 0.03270239f, 0.05594265f, 0.05988759f, -0.06121292f, -0.04946571f, -0.07427264f, -0.02771081f, 
    -0.02078553f, 0.05473697f, -0.01951427f, 0.04255357f, -0.03341263f, 0.05150455f, 0.00222522f, -0.01052466f, 
    -0.06691226f, -0.01842823f, -0.05921914f, 0.00154931f, -0.00908179f, -0.05959979f, 0.04451060f, 0.04997250f, 
    -0.07839524f, -0.00897217f, -0.03819261f, 0.05261207f, 0.02610601f, 0.02065065f, 0.05564971f, -0.04489551f, 
    -0.00730590f, -0.06670516f, -0.04352772f, 0.03801176f, 0.04831610f, -0.03061030f, 0.06099511f, -0.00445899f, 
    -0.02138049f, -0.02894892f, 0.02256363f, -0.06053268f, -0.07361890f, -0.01629382f, 0.06138147f, 0.02462655f, 
    -0.07072262f, -0.08111655f, 0.00941439f, -0.00290342f, -0.04715804f, -0.06827553f, -0.05544830f, -0.03609635f, 
    0.00866733f, 0.00945215f, 0.01667057f, 0.02651972f, 0.00861148f, -0.07126582f, 0.00860393f, -0.02480400f, 
    0.02026239f, 0.05230935f, -0.02010423f, -0.02458972f, -0.04848745f, 0.02056610f, -0.06883036f, 0.00657343f, 
    -0.02136180f, -0.04486729f, -0.00567414f, 0.02418703f, 0.01796508f, 0.05898478f, 0.02266347f, 0.02845165f, 
    -0.02323870f, -0.00033746f, -0.05740903f, 0.04448512f, 0.05785514f, -0.03315498f, -0.06345790f, -0.01714803f, 
    -0.07389007f, 0.02252178f, 0.02436396f, -0.08095949f, 0.05438802f, -0.01064369f, -0.00626779f, 0.01820183f, 
    -0.07222097f, 0.02414581f, -0.01994226f, 0.03746187f, 0.05109373f, -0.06387926f, 0.02681519f, 0.01674793f, 
    -0.07074061f, -0.04862458f, 0.03838161f, -0.05115912f, -0.02314293f, -0.03635498f, 0.04296931f, -0.06507549f, 
    -0.07666250f, 0.01600216f, -0.04391219f, -0.01678412f, 0.02847608f, 0.04849046f, -0.01734067f, -0.02786774f, 
    0.04093131f, -0.06228942f, 0.01036751f, 0.00665374f, 0.04368458f, 0.01733753f, 0.03382251f, 0.05586084f, 
    -0.06453497f, -0.00673812f, -0.03822749f, -0.06240519f, -0.03531280f, -0.08145057f, -0.05969215f, -0.02156377f, 
    -0.05370873f, -0.03300016f, -0.06508613f, 0.00472872f, 0.02722992f, -0.07727713f, -0.05357008f, 0.02359965f, 
    -0.06348465f, -0.02303614f, -0.04171175f, -0.07697658f, -0.04101136f, -0.07616560f, -0.08398413f, 0.00137774f, 
    0.05219497f, -0.03043481f, -0.07042981f, 0.00132380f, -0.02719083f, -0.06396496f, 0.04876655f, 0.04243529f, 
    0.03272713f, -0.01213472f, 0.04137984f, 0.00610077f, 0.03745202f, 0.02105303f, 0.04376524f, 0.03072645f, 
    0.04128243f, -0.07558279f, -0.07158924f, 0.05295858f, -0.07372729f, -0.00756849f, 0.03624767f, 0.04772968f, 
    0.06252308f, 0.03829134f, -0.08324575f, -0.02298290f, -0.05821262f, -0.02421391f, -0.03193142f, 0.06010456f, 
    -0.00659383f, -0.04998612f, -0.07945372f, -0.01603210f, -0.07581299f, 0.04776873f, 0.00076847f, 0.04911103f, 
    -0.03102183f, 0.04418544f, -0.01189441f, -0.05701284f, 0.00087602f, 0.03717762f, 0.03525176f, 0.00090671f, 
    0.06762488f, 0.01868192f, 0.24663053f, -0.21929181f, -0.10945033f, -0.24386288f, -0.00545537f, 0.14166291f, 
    0.01597959f, -0.06800357f, 0.04763493f, -0.00865105f, -0.19374341f, 0.01453867f, -0.05108375f, -0.18893217f, 
    -0.27035818f, -0.08560838f, -0.13096033f, -0.09729736f, -0.07652269f, 0.03568337f, 0.07415273f, 0.04776655f, 
    -0.18092781f, -0.31799725f, 0.12098009f, 0.04497473f, 0.01304925f, 0.17663658f, -0.09677093f, -0.06726772f, 
    -0.05055419f, 0.05660529f, 0.05203724f, 0.05609785f, -0.20696844f, 0.09189644f, 0.13097301f, 0.35337189f, 
    0.03111305f, -0.01892525f, 0.03291484f, 0.01725243f, -0.00866445f, -0.00771191f, -0.01948449f, -0.02950624f, 
    0.06331465f, 0.27146414f, 0.01995879f, 0.18943723f, 0.03087269f, 0.06715812f, -0.03891991f, 0.05225726f, 
    0.02881010f, 0.11099380f, 0.05344961f, 0.07319889f, -0.00867465f, -0.21587402f, 0.26793540f, -0.12452693f, 
    -0.05314393f, 0.04892583f, -0.08151089f, -0.11098899f, -0.14802499f, 0.01697867f, -0.04298274f, 0.02027125f, 
    -0.21258137f, -0.19216487f, -0.05194835f, 0.30293560f, 0.02473042f, 0.09131330f, 0.02231504f, 0.05137265f, 
    0.06317087f, -0.06125274f, 0.04756403f, 0.00756706f, 0.20502944f, 0.26600164f, 0.15511525f, 0.04017580f, 
    -0.21234608f, 0.13788967f, 0.08543047f, 0.03517247f, 0.05214592f, -0.01500378f, 0.04035350f, 0.07699476f, 
    -0.14220469f, -0.20503660f, -0.19334014f, 0.24357909f, -0.01962880f, 0.02584617f, 0.09516418f, 0.02257811f, 
    0.00244856f, 0.01559597f, 0.13748547f, 0.10893246f, -0.14073876f, -0.11619562f, 0.02862622f, 0.13252111f, 
    0.02918509f, -0.08692933f, 0.06242740f, 0.02660147f, 0.14797078f, 0.08963659f, 0.04798091f, 0.16576129f, 
    -0.21085808f, 0.34533167f, 0.08349357f, 0.21309520f, -0.19732642f, 0.16024897f, -0.06360015f, -0.02480391f, 
    0.05837697f, -0.07884231f, -0.01554430f, 0.20431733f, -0.05709707f, -0.16412701f, 0.45495448f, 0.02489217f, 
    0.00402141f, -0.10621236f, -0.01096435f, -0.03289292f, -0.00279351f, -0.11023287f, 0.00656107f, 0.01286272f, 
    -0.07475147f, 0.21506765f, 0.01476859f, -0.14008237f, -0.03375082f, -0.05268291f, -0.09888559f, -0.11076444f, 
    -0.06135742f, 0.06160199f, -0.01804511f, -0.10480148f, -0.02869842f, 0.21895473f, 0.17852066f, 0.28382367f, 
    0.03884330f, 0.13837120f, 0.01278040f, 0.10437296f, 0.11891847f, -0.06464864f, 0.12192208f, 0.16680332f, 
    -0.06633750f, -0.00676868f, -0.20406500f, -0.26846999f, 0.03453204f, -0.01664022f, 0.03581597f, -0.00597678f, 
    0.04379693f, -0.06303593f, 0.01276258f, -0.10141921f, 0.05371852f, -0.09599312f, 0.07669484f, 0.15246956f, 
    -0.05793233f, 0.01824180f, -0.02603552f, 0.02753915f, -0.08488680f, -0.00260783f, 0.11799965f, -0.00584857f, 
    0.25710914f, 0.18120378f, 0.18311270f, 0.00296466f, 0.02776852f, 0.00281131f, -0.14872989f, -0.00030453f, 
    -0.02281908f, -0.19426867f, 0.10385642f, 0.13132304f, 0.04636910f, 0.16673626f, 0.04132928f, -0.01897914f, 
    0.02426591f, -0.04696268f, -0.08376423f, -0.03235172f, 0.01325053f, 0.11456335f, -0.03342509f, 0.00088851f, 
    0.10209110f, -0.07797445f, 0.22566515f, 0.02198328f, 0.00756903f, 0.15900853f, -0.08080158f, 0.02163218f, 
    -0.03568829f, -0.04143004f, 0.07151370f, 0.07206053f, 0.09032986f, 0.08743591f, 0.04535264f, 0.09435464f, 
    -0.11180902f, -0.01196981f, 0.13650467f, 0.19404270f, -0.08432677f, 0.02028915f, -0.08621428f, -0.17709482f, 
    -0.28607965f, 0.21196677f, -0.03945806f, -0.03938465f, 0.02094178f, 0.12399410f, -0.10443693f, 0.09919762f, 
    0.15581776f, -0.03547373f, 0.14103490f, 0.01447364f, -0.21905975f, -0.07507991f, -0.11458849f, 0.20115907f, 
    -0.14385867f, 0.07336631f, -0.21144629f, 0.02258590f, 0.03826546f, 0.12487476f, -0.04396309f, -0.02100325f, 
    0.18317978f, -0.24110571f, -0.01567138f, 0.20307849f, 0.22011796f, 0.06067213f, -0.06133037f, 0.09737864f, 
    0.09412185f, -0.08817648f, 0.01161124f, 0.03064409f, -0.15287545f, 0.07913684f, 0.17065355f, 0.08031621f, 
    -0.07533188f, 0.06395481f, -0.02139237f, -0.03501432f, 0.04990892f, 0.04043397f, -0.06288610f, 0.04930901f, 
    0.04633323f, -0.05735680f, -0.05059534f, 0.02665460f, -0.05657951f, -0.00192568f, -0.03607951f, -0.05087432f, 
    -0.08942267f, 0.10530698f, 0.06947331f, 0.06460067f, 0.12677388f, 0.04620378f, 0.27059782f, 0.05133699f, 
    0.06182886f, -0.05870725f, -0.00548830f, 0.05683613f, -0.13524282f, 0.02142098f, -0.03886891f, -0.00043415f, 
    0.01393643f, 0.26306462f, 0.31422743f, -0.06112214f, 0.03689981f, 0.07206546f, -0.08641848f, 0.05849702f, 
    0.03829301f, 0.10172540f, 0.28569272f, -0.04144297f, 0.31694084f, 0.07291536f, 0.14989853f, -0.00030245f, 
    0.15707880f, -0.03847684f, -0.05742950f, 0.03547943f, 0.00272952f, -0.04668882f, 0.09882883f, -0.07774615f, 
    0.14282884f, 0.11226063f, -0.02199724f, 0.11073397f, 0.01342505f, -0.08838007f, -0.00609365f, -0.05260141f, 
    0.14991753f, 0.11747892f, -0.10724100f, -0.03945618f, -0.17434669f, 0.11922396f, -0.03998322f, 0.20383051f, 
    -0.03628302f, -0.04326716f, -0.04474323f, 0.05547227f, 0.10849512f, 0.02514732f, -0.07120293f, 0.05155695f, 
    0.07572153f, -0.18847895f, -0.07570102f, -0.36296692f, -0.09334626f, 0.01526986f, -0.03090465f, 0.11525194f, 
    0.14623328f, -0.07809957f, -0.15176608f, -0.13769050f, 0.09208658f, -0.39982435f, 0.10824195f, 0.08809371f, 
    0.00650251f, 0.12966129f, -0.03927820f, -0.09190305f, -0.20458303f, -0.14428273f, 0.24729595f, -0.16833779f, 
    -0.14526697f, 0.04648187f, -0.00281686f, 0.13393566f, -0.03452884f, 0.01967660f, -0.10486442f, 0.00590091f, 
    0.00680349f, 0.03895107f, 0.02909143f, 0.03180971f, -0.24205667f, -0.00797224f, 0.04737382f, -0.20827733f, 
    -0.11463941f, -0.09073068f, -0.08312172f, -0.06967244f, 0.02513346f, 0.06540534f, -0.01719277f, 0.03898145f, 
    -0.14226776f, -0.15855080f, -0.00471692f, -0.02974989f, 0.05582898f, -0.02409733f, -0.07952312f, 0.15805806f, 
    -0.03817980f, 0.11731438f, -0.03099303f, 0.02770156f, 0.00210636f, -0.20776667f, -0.36497417f, -0.40481478f, 
    0.19460583f, 0.08469792f, -0.00023918f, -0.01121550f, -0.03842790f, 0.23608764f, 0.13300058f, 0.08419351f, 
    -0.04292419f, -0.15477410f, 0.13744381f, 0.11030157f, -0.01984625f, 0.01002912f, 0.03203727f, 0.00469822f, 
    0.02927612f, -0.03250241f, 0.09350133f, 0.05628701f, -0.14805631f, 0.04188105f, -0.09687620f, 0.14629887f, 
    0.16721599f, 0.00352784f, 0.16651087f, 0.13553259f, -0.02606993f, 0.00186135f, 0.06987618f, -0.04017183f, 
    -0.17792314f, -0.37347409f, -0.12780963f, 0.17627749f, 0.06048859f, 0.08379145f, 0.00189380f, 0.27428278f, 
    -0.09329530f, 0.03058992f, -0.06603266f, 0.02036052f, -0.16136129f, 0.10828624f, 0.08949894f, -0.15861918f, 
    -0.00011004f, -0.05337403f, 0.00121344f, -0.04115269f, 0.03427678f, -0.00776474f, -0.05950205f, -0.08463524f, 
    0.13663536f, -0.14917414f, -0.00804857f, -0.02584880f, 0.18215758f, 0.14730495f, -0.08179305f, 0.07689264f, 
    -0.00390246f, 0.01574796f, 0.11310539f, 0.10310363f, -0.10927674f, 0.08342054f, -0.03010825f, -0.22502835f, 
    -0.01043196f, 0.00404240f, -0.01180564f, 0.06505385f, -0.02471377f, -0.02125450f, 0.04861185f, 0.03147877f, 
    -0.40400720f, 0.16648385f, 0.14843799f, 0.03321039f, 0.13270859f, 0.09873189f, -0.12331764f, 0.10574149f, 
    0.07050731f, -0.01383717f, 0.12305082f, 0.01378564f, -0.25713065f, 0.02217560f, 0.10466658f, 0.07898635f, 
    0.31539536f, -0.09201936f, 0.04755751f, -0.20950268f, 0.00955092f, 0.08541968f, -0.06158728f, 0.04266435f, 
    -0.07827301f, 0.16270603f, 0.10826223f, -0.00498552f, -0.16344288f, -0.00664112f, 0.00821203f, 0.01544013f, 
    0.02079283f, 0.10826090f, 0.00937207f, -0.11490977f, -0.33848688f, -0.13080649f, 0.04321671f, 0.11622062f, 
    0.32258952f, 0.11675673f, 0.06833880f, 0.01049085f, -0.10670039f, -0.05313514f, 0.10763383f, 0.04790695f, 
    0.34327123f, 0.20466730f, -0.05237833f, -0.30442017f, -0.02037245f, -0.04258901f, -0.13242969f, -0.12609333f, 
    0.25473535f, 0.06701286f, 0.01436055f, 0.01292456f, 0.09825384f, 0.05757213f, 0.12957580f, 0.18615218f, 
    -0.04643320f, 0.06626490f, 0.40124774f, -0.02394451f, 0.00497057f, 0.15645021f, 0.17078762f, 0.11136629f, 
    0.01372374f, 0.06893592f, 0.19499674f, -0.21045998f, 0.00940454f, -0.08265375f, -0.02810770f, -0.04752755f, 
    -0.09680189f, 0.07010728f, 0.09702109f, 0.00127207f, -0.06420767f, 0.11011000f, -0.06679373f, -0.18139240f, 
    0.04198961f, -0.05847460f, -0.08750547f, 0.00412171f, -0.05453730f, 0.01244123f, 0.06684063f, 0.01239713f, 
    -0.09615487f, -0.08611920f, 0.00781226f, 0.17776182f, -0.01497031f, 0.04794083f, 0.07509838f, -0.06604916f, 
    0.00439056f, -0.03313742f, 0.05781960f, -0.03758472f, 0.08560272f, -0.16627738f, 0.14174305f, 0.06149067f, 
    0.18495390f, -0.05075669f, 0.04098844f, 0.05921685f, -0.09571099f, 0.14096381f, 0.01513411f, 0.02400771f, 
    0.06266321f, 0.01045949f, 0.02555400f, 0.05243957f, 0.05209283f, -0.05956851f, -0.00401839f, -0.14182298f, 
    0.00095573f, 0.07024178f, 0.03058981f, 0.00846690f, 0.03941149f, 0.03237720f, 0.17967990f, 0.04572751f, 
    0.02657472f, 0.03600006f, 0.07476703f, -0.08449182f, -0.02148524f, -0.02919208f, -0.01326432f, -0.06305999f, 
    -0.24692450f, -0.14957348f, -0.02969983f, 0.29127672f, 0.07642493f, 0.04729024f, 0.05302912f, -0.03204160f, 
    0.00514203f, 0.11545493f, 0.04905593f, 0.04420262f, 0.04276654f, -0.00939901f, -0.05378421f, -0.17884380f, 
    -0.04040551f, -0.02559039f, -0.11881209f, -0.04799575f, -0.01766629f, -0.07513480f, 0.11238114f, -0.14691480f, 
    0.11758942f, -0.10963537f, -0.12475312f, -0.00858517f, 0.13662846f, -0.05811873f, -0.05101569f, -0.03483473f, 
    -0.03435471f, 0.02607108f, -0.07266475f, -0.05818709f, -0.21571860f, -0.03331322f, -0.04400619f, 0.09463128f, 
    -0.04774978f, -0.00780968f, -0.02331224f, -0.01059391f, -0.00885650f, 0.03034209f, 0.12230757f, 0.08266201f, 
    -0.17397265f, 0.18177474f, -0.04168436f, 0.25809321f, -0.11184487f, -0.15051241f, 0.05441413f, -0.12071633f, 
    0.08537191f, 0.08357459f, 0.02122744f, 0.18313307f, -0.09393124f, -0.04441839f, 0.30906770f, -0.09226751f, 
    -0.08656667f, -0.01997744f, 0.02260245f, 0.07096603f, 0.00806514f, -0.00650768f, -0.00996403f, -0.03749742f, 
    -0.01491548f, 0.16376837f, 0.10868926f, -0.01016500f, -0.08972245f, -0.03962455f, -0.11826295f, 0.00578121f, 
    -0.00411595f, 0.05899769f, 0.13906150f, 0.00998816f, -0.02306100f, 0.10983727f, 0.02554705f, 0.07135520f, 
    0.15487529f, 0.10816317f, 0.16885398f, -0.00977323f, 0.02646120f, -0.08782855f, 0.08908408f, -0.08526316f, 
    0.10281700f, 0.08827579f, -0.19080277f, -0.28815585f, 0.00673321f, -0.00850177f, -0.03087042f, -0.02058696f, 
    -0.01942487f, 0.08218560f, -0.05284737f, -0.07405920f, 0.11693655f, 0.02368956f, -0.14545743f, 0.41573396f, 
    0.11150590f, -0.11152219f, -0.02179580f, 0.09880657f, 0.09224855f, 0.06515923f, 0.13213234f, 0.13448375f, 
    -0.03194173f, -0.01205061f, -0.07151466f, 0.01927959f, -0.07844144f, 0.03747519f, -0.08244723f, 0.04697394f, 
    -0.06311417f, 0.00897675f, 0.04845055f, -0.00907836f, -0.03042604f, -0.08062211f, -0.07351784f, -0.03856455f, 
    -0.06773592f, 0.04192043f, 0.04003458f, 0.02831934f, 0.03019265f, 0.02969533f, -0.05543199f, -0.04388686f, 
    0.01965097f, -0.00298397f, -0.03948557f, 0.03783400f, -0.07293401f, 0.04947821f, -0.06987368f, -0.03156008f, 
    -0.01960170f, -0.05813552f, 0.03424339f, -0.03349471f, 0.03388483f, -0.06293800f, -0.00838180f, -0.03637597f, 
    -0.06689716f, 0.02026516f, 0.01870186f, -0.03708146f, 0.05592318f, -0.03465262f, -0.01858487f, -0.01160622f, 
    0.00962204f, 0.01574913f, 0.04914765f, -0.01505997f, -0.01558545f, -0.05110066f, 0.02607804f, -0.07668401f, 
    -0.07850393f, -0.05735231f, -0.03817699f, -0.02993284f, -0.05824183f, 0.04243334f, -0.02634804f, -0.00611525f, 
    0.01935297f, -0.04821621f, -0.05739054f, 0.05704541f, 0.01928726f, -0.04135211f, -0.05963039f, -0.02233784f, 
    -0.04665178f, -0.03622470f, -0.01965092f, -0.02079854f, -0.01886378f, 0.02607821f, 0.00537715f, -0.05723727f, 
    0.04268942f, 0.02654387f, -0.07845791f, -0.06360684f, 0.03955897f, 0.00017153f, -0.02078814f, -0.00296129f, 
    -0.04468450f, -0.01945145f, -0.02316711f, -0.00363678f, -0.02150487f, -0.00812652f, -0.02205840f, -0.04948680f, 
    0.06355700f, -0.03371272f, -0.01608164f, 0.02944753f, 0.05440004f, -0.02164468f, -0.07737539f, 0.00295851f, 
    0.02542216f, 0.03324297f, -0.06908727f, -0.03184354f, 0.01558375f, -0.07413879f, -0.04926245f, -0.01914787f, 
    -0.00626860f, 0.03647161f, -0.05559805f, -0.03522707f, 0.04567103f, 0.00803431f, 0.03796202f, -0.00567792f, 
    0.06066725f, -0.00082682f, -0.02801375f, 0.01928726f, -0.04195119f, -0.01480692f, 0.04025201f, -0.06403534f, 
    -0.01352139f, -0.03161432f, -0.04459300f, 0.01595629f, -0.00926578f, 0.04410029f, 0.00201301f, 0.04823759f, 
    -0.00479377f, -0.03714988f, 0.01121777f, -0.04251689f, 0.00981841f, 0.03033670f, -0.02080181f, -0.00239318f, 
    0.03125226f, 0.02126908f, 0.05670386f, -0.00629453f, -0.08035986f, 0.02642976f, -0.06500845f, 0.00325242f, 
    -0.02353420f, 0.02823976f, -0.00118844f, -0.06890863f, 0.00702664f, -0.05759532f, 0.04984292f, -0.02305100f, 
    0.02532658f, 0.00780505f, -0.00993756f, -0.03563320f, -0.01682563f, -0.02559092f, 0.05631220f, -0.04924452f, 
    0.03883372f, -0.01162778f, -0.00009647f, -0.05201706f, 0.03923368f, -0.03326433f, -0.03776266f, -0.03724108f, 
    0.02998487f, -0.04368068f, 0.02022152f, -0.04233303f, -0.02403898f, -0.01866095f, -0.05104000f, -0.02061993f, 
    -0.07153768f, 0.02699692f, -0.04915703f, 0.00825174f, -0.03026159f, 0.00883162f, -0.04968837f, -0.01687154f, 
    -0.00165590f, -0.20953844f, -0.25051919f, 0.32474810f, -0.04386415f, 0.10312161f, 0.02141801f, -0.15633743f, 
    0.11284147f, -0.08555948f, -0.03606035f, 0.20684101f, 0.02360241f, -0.04166354f, 0.06752623f, 0.11545876f, 
    -0.13175859f, -0.20390803f, 0.05776228f, -0.17291673f, 0.06244917f, 0.20143291f, 0.05433085f, 0.13452372f, 
    -0.02098584f, 0.25368142f, 0.36922649f, 0.17095515f, 0.00364967f, 0.23364647f, 0.04139616f, 0.20583834f, 
    0.04351939f, -0.06503466f, -0.14648505f, -0.06957538f, 0.06841873f, -0.05459687f, -0.34386885f, -0.41228846f, 
    -0.18913457f, -0.07376123f, -0.30461407f, 0.05925377f, 0.07103501f, -0.05848999f, -0.15102281f, -0.12237743f, 
    0.26569545f, 0.12101536f, -0.04228136f, -0.05586523f, -0.12660289f, -0.09099580f, 0.00708279f, -0.03146214f, 
    0.11117584f, 0.01325071f, 0.04120643f, -0.02808912f, -0.15385933f, 0.05418113f, -0.44784531f, 0.30065897f, 
    -0.06867789f, 0.06631219f, 0.06696934f, 0.09134225f, -0.09274595f, 0.03925771f, -0.00702608f, 0.00573452f, 
    -0.00749818f, -0.04630006f, 0.32213178f, 0.15900476f, -0.00462202f, 0.20104580f, 0.10085042f, 0.16379938f, 
    0.00620542f, -0.19662139f, -0.05023216f, -0.12711491f, -0.14623080f, -0.08843880f, 0.07529776f, -0.08150455f, 
    0.00718846f, -0.04921071f, 0.08972285f, 0.02292809f, 0.22319825f, 0.10777361f, -0.10667888f, 0.05697887f, 
    -0.40690985f, -0.16275160f, 0.11321101f, 0.11555189f, -0.02298766f, 0.15461424f, 0.10028238f, 0.21538694f, 
    -0.00470444f, 0.00974140f, 0.14690205f, 0.12347843f, -0.06844098f, 0.20770399f, 0.44840088f, -0.01549950f, 
    0.23398119f, 0.07504060f, 0.04476445f, 0.13997205f, -0.03142225f, 0.02860606f, -0.13042587f, -0.15490709f, 
    0.21773602f, -0.09638080f, 0.12081385f, -0.32767120f, 0.29112685f, 0.08153711f, -0.02294838f, -0.02650416f, 
    -0.03099307f, 0.00635315f, 0.10016420f, -0.01945528f, 0.30503428f, -0.17505592f, -0.31760702f, 0.18093920f, 
    0.07309186f, 0.22463404f, 0.10050862f, -0.15703718f, 0.00412081f, -0.12750973f, 0.09616801f, 0.10262058f, 
    0.23819523f, 0.04811329f, -0.14532158f, 0.21696037f, -0.06647044f, -0.06262837f, 0.11586308f, -0.00519937f, 
    -0.03530321f, -0.08462830f, -0.24729085f, -0.07318390f, 0.26300398f, 0.08937910f, -0.25778618f, 0.03743698f, 
    -0.11679363f, -0.00223990f, 0.17509109f, 0.02158572f, -0.01440182f, 0.04448436f, -0.05538302f, 0.06109999f, 
    0.23481905f, 0.12367793f, 0.22580232f, 0.23170650f, -0.18455657f, -0.07398525f, -0.11657002f, -0.15532042f, 
    0.06410994f, -0.08199939f, -0.05673924f, -0.06129218f, -0.17783700f, 0.25291392f, 0.08473933f, -0.16316961f, 
    -0.07403165f, -0.00920077f, -0.02928173f, 0.25951213f, 0.08685495f, 0.05655125f, 0.13537240f, -0.06612834f, 
    -0.08399814f, 0.01503306f, 0.25406882f, 0.05054771f, -0.03995623f, 0.00224848f, -0.00208273f, -0.05071954f, 
    -0.02613586f, -0.11205452f, 0.14189325f, -0.01585243f, -0.11393587f, 0.05768227f, -0.02313356f, -0.17889620f, 
    0.08158652f, 0.03167690f, -0.06416286f, -0.04213328f, -0.00233019f, 0.11816528f, 0.00598386f, 0.21079871f, 
    0.11382829f, -0.02690256f, 0.01548916f, -0.04760309f, -0.19724938f, 0.00518880f, -0.04504597f, 0.01463498f, 
    0.02788508f, 0.04142369f, 0.08486319f, -0.08939415f, -0.13080208f, 0.08937528f, 0.06604357f, 0.39358732f, 
    -0.22354867f, -0.04893050f, 0.05095957f, -0.04924809f, -0.01633882f, 0.01041639f, 0.02914768f, 0.02006166f, 
    0.00069027f, 0.00223292f, 0.09347411f, 0.01815381f, 0.06089614f, -0.01386611f, -0.11040094f, -0.07165292f, 
    0.04096881f, -0.01218688f, -0.01179970f, 0.14816643f, -0.32535478f, 0.08556616f, 0.24098216f, 0.14632185f, 
    0.14304574f, -0.03300189f, -0.06598481f, 0.04545449f, 0.15240008f, -0.03915685f, 0.05895390f, -0.11720909f, 
    -0.00142844f, -0.11561900f, 0.18493249f, 0.02435251f, 0.07320660f, 0.13127011f, -0.03930968f, 0.04796278f, 
    0.04030847f, -0.01057284f, -0.01967767f, -0.10092136f, 0.36194035f, -0.01471495f, -0.00565501f, -0.03144961f, 
    -0.02905407f, 0.16530204f, -0.14358822f, 0.15505818f, 0.12391251f, 0.02011326f, 0.12574257f, 0.06280106f, 
    0.06940747f, -0.00436766f, -0.22598909f, -0.02271448f, -0.03822594f, -0.08146465f, 0.07621796f, 0.11826241f, 
    -0.05422202f, 0.11131474f, -0.07713561f, 0.11104299f, 0.13287885f, -0.13051437f, -0.00629173f, -0.02644830f, 
    -0.08700187f, -0.14753172f, -0.00066692f, -0.04649900f, 0.02009821f, 0.15472974f, -0.06017412f, 0.01724597f, 
    0.15981700f, -0.13855940f, 0.08965869f, -0.09290979f, -0.06941639f, 0.12629572f, -0.08091882f, 0.00472525f, 
    0.14026615f, -0.11347023f, 0.07130036f, 0.10725275f, -0.07491872f, 0.23712897f, 0.17627959f, 0.13744849f, 
    0.00134014f, -0.16442630f, 0.01038210f, 0.13453864f, -0.03025603f, 0.08017495f, -0.06275185f, -0.23140445f, 
    -0.19139436f, 0.10390471f, -0.12814949f, 0.07900605f, 0.06690725f, -0.06136936f, -0.32082826f, -0.19602239f, 
    -0.04638982f, 0.10596055f, -0.18325397f, -0.03851311f, -0.30457625f, 0.04982373f, 0.02265585f, 0.12170142f, 
    0.09651594f, 0.21165156f, -0.03287255f, 0.04039178f, -0.03188296f, -0.15005450f, 0.08613877f, 0.04859617f, 
    0.03461449f, -0.39668381f, 0.05733239f, 0.09008569f, -0.16777126f, -0.11005576f, -0.07934494f, -0.05988410f, 
    0.04682632f, 0.10192040f, -0.01637251f, -0.03500331f, -0.21715440f, 0.17759305f, 0.06979475f, 0.00848731f, 
    0.17082986f, 0.15524510f, -0.06518553f, 0.09859064f, 0.10940836f, -0.10372351f, 0.02449564f, -0.21443710f, 
    -0.18124080f, -0.19105683f, -0.49650979f, 0.05670599f, 0.25486538f, 0.06255759f, 0.02052337f, 0.13048038f, 
    0.02000909f, 0.03714456f, -0.12767453f, -0.11666532f, -0.31078029f, -0.52151185f, -0.15999848f, -0.22963995f, 
    -0.04246844f, -0.10645452f, 0.08230995f, -0.05361834f, 0.16599984f, -0.05360197f, 0.14064747f, -0.00963171f, 
    0.14790286f, 0.39075673f, 0.02986092f, 0.07695611f, 0.11775578f, 0.04056063f, 0.13014650f, 0.20527551f, 
    -0.06979828f, 0.04975965f, 0.04800209f, 0.04676208f, -0.13949829f, 0.06690568f, 0.12518474f, 0.17244877f, 
    -0.12942809f, 0.01138167f, -0.12482593f, 0.04773173f, 0.03248884f, -0.15776749f, 0.13262476f, 0.16585350f, 
    -0.00895355f, -0.23898147f, 0.00943309f, -0.10952269f, -0.01476009f, 0.09294546f, 0.05015886f, -0.04959020f, 
    0.11484241f, -0.06315048f, 0.10060987f, -0.00332788f, -0.34318998f, 0.15588614f, -0.21074013f, 0.29148895f, 
    0.14018176f, -0.09659445f, -0.19126575f, 0.10728974f, 0.09653163f, -0.01264630f, -0.10417071f, -0.11506818f, 
    0.10009338f, 0.32374591f, 0.31684825f, 0.00269230f, -0.06694806f, 0.19526102f, 0.12448221f, -0.04485923f, 
    0.08915860f, -0.06406872f, 0.16441667f, 0.00734593f, -0.34433290f, -0.36514592f, -0.26588106f, -0.13619480f, 
    0.07127101f, -0.20629339f, -0.18223906f, 0.04332175f, 0.16997938f, -0.14285481f, 0.05075777f, 0.11419254f, 
    -0.03429661f, 0.03016797f, 0.09076719f, 0.03647600f, 0.03989474f, 0.08719207f, 0.01596899f, 0.19935182f, 
    0.01515481f, -0.08328627f, -0.06315487f, -0.14230847f, 0.09870888f, 0.04818571f, 0.22538625f, 0.04556269f, 
    0.04120956f, 0.03306240f, 0.00856886f, 0.03560263f, 0.12475765f, 0.13653527f, -0.02303259f, 0.16160662f, 
    0.01121639f, -0.23571253f, -0.14494446f, -0.13689712f, 0.03623789f, -0.09465099f, -0.01396211f, -0.09096262f, 
    -0.03537843f, 0.01772613f, -0.07862713f, 0.08103269f, 0.33313584f, -0.04004903f, 0.13662520f, -0.04452167f, 
    0.08934715f, -0.02838125f, -0.08283682f, 0.26476967f, 0.03350752f, -0.06819061f, -0.00297710f, -0.11003499f, 
    -0.25986862f, -0.24575359f, -0.24154377f, 0.03703910f, 0.07741602f, -0.14589182f, -0.11892121f, -0.04208652f, 
    0.15090795f, 0.03726271f, 0.07981495f, 0.18837196f, -0.13104650f, 0.07729989f, -0.29216331f, -0.22236522f, 
    0.12474668f, 0.02087676f, 0.12306244f, -0.08599972f, -0.04862969f, 0.08360754f, -0.14673842f, 0.00516999f, 
    -0.15112683f, -0.06851120f, 0.18467696f, 0.32829580f, 0.02743939f, -0.13235638f, -0.14886229f, -0.08518261f, 
    -0.03718466f, -0.07859969f, 0.13655196f, 0.11682136f, 0.09212898f, 0.31410965f, -0.21638700f, -0.04743572f, 
    0.04387473f, -0.09150366f, 0.04522110f, 0.22784390f, 0.12521031f, 0.10796259f, -0.10748181f, -0.20829080f, 
    -0.01461329f, -0.07947543f, -0.13580108f, 0.12658665f, 0.00434382f, 0.18103592f, 0.03414977f, 0.02329553f, 
    0.11745466f, 0.04570488f, -0.19972910f, 0.15545240f, 0.01782598f, -0.04473506f, -0.05525583f, 0.06204319f, 
    0.07832443f, 0.00205832f, 0.14409673f, 0.04077891f, -0.06291757f, -0.00891666f, 0.10059055f, 0.09344615f, 
    0.06058676f, 0.12870553f, -0.19895543f, -0.16508006f, -0.00295723f, 0.05867001f, 0.06358764f, 0.08838988f, 
    -0.08196988f, -0.09843364f, -0.03529527f, -0.12112789f, 0.29537436f, 0.21565603f, 0.13192929f, 0.14904082f, 
    -0.04842743f, 0.03807359f, -0.05624097f, 0.18834229f, 0.09733416f, 0.12552339f, 0.04958037f, 0.04970706f, 
    -0.11699019f, 0.27806044f, 0.08116594f, -0.03192523f, -0.05126325f, 0.04325837f, 0.09504627f, -0.08499558f, 
    0.11711055f, 0.21955860f, 0.06655429f, -0.02959522f, -0.24643075f, -0.10646858f, -0.22234719f, -0.11341377f, 
    0.04460528f, -0.02910933f, -0.04984856f, 0.06455737f, 0.04210615f, -0.04108566f, -0.00940636f, -0.07124777f, 
    0.06850926f, 0.21703941f, -0.17142245f, -0.21974525f, 0.02851557f, -0.05282839f, 0.12749158f, 0.13644740f, 
    0.00822454f, -0.00302562f, 0.08018974f, -0.04851191f, 0.11194334f, -0.15190557f, -0.01299589f, 0.00936307f, 
    0.09186059f, 0.05990322f, -0.00387706f, 0.12461030f, 0.03848384f, 0.09601878f, -0.02671228f, -0.05987975f, 
    -0.12611395f, 0.09598917f, 0.08259482f, 0.16030669f, -0.10273688f, -0.00551090f, 0.03016786f, -0.00795630f, 
    0.00131521f, -0.14926310f, 0.03685660f, -0.03324180f, 0.14900196f, 0.04698139f, -0.08334631f, -0.09819505f, 
    0.11384058f, 0.14476952f, -0.06836226f, 0.23259963f, 0.03908680f, -0.06296312f, -0.11631121f, -0.05627228f, 
    0.05784320f, -0.20038925f, 0.13878292f, -0.37045154f, 0.15537992f, 0.04128417f, -0.01154771f, -0.03890077f, 
    0.04054794f, 0.06275249f, -0.04252276f, 0.03217648f, -0.01945661f, -0.04490933f, -0.39497817f, -0.13945965f, 
    0.12080547f, 0.25897613f, 0.05518928f, 0.10136055f, 0.05477953f, -0.00514485f, 0.14844127f, 0.02576323f, 
    -0.04328213f, -0.09018687f, -0.19755326f, -0.07802858f, 0.03744477f, -0.01403964f, 0.03838508f, 0.04771946f, 
    -0.05962456f, 0.02226718f, 0.01203920f, 0.14329113f, -0.04685885f, 0.14321947f, -0.19347896f, 0.02039031f, 
    0.01359805f, -0.04623690f, 0.20041534f, 0.00476835f, -0.04102230f, 0.25684091f, 0.00147687f, -0.11962723f, 
    0.10656699f, 0.15801986f, 0.33376059f, 0.30684739f, 0.00727108f, 0.11481705f, -0.03581890f, 0.02809458f, 
    -0.05121149f, 0.07463372f, 0.10250144f, 0.06594890f, 0.16849396f, -0.04782734f, 0.15422986f, -0.22574326f, 
    0.05582026f, -0.11510827f, 0.04409696f, 0.13817798f, 0.07730024f, -0.13673195f, -0.10758656f, -0.02200558f, 
    0.00466269f, -0.12591887f, -0.10169737f, 0.04225852f, -0.11787487f, -0.00646598f, -0.04517323f, -0.19260983f, 
    -0.02915957f, -0.02202978f, -0.05741095f, -0.06200205f, -0.13615766f, -0.04936366f, -0.15773907f, -0.03073265f, 
    0.04123225f, -0.07524344f, 0.04019593f, -0.06705751f, -0.00787267f, -0.11433687f, -0.12561220f, -0.05640041f, 
    0.17149098f, 0.06784692f, -0.00015844f, -0.18588561f, -0.05091466f, -0.00914778f, 0.13793249f, 0.01025057f, 
    0.07309477f, 0.09658258f, 0.12165975f, 0.04922379f, 0.04649217f, 0.28595802f, 0.23710836f, 0.35395059f, 
    -0.20071636f, 0.09880307f, 0.19022936f, -0.14683467f, -0.00963270f, -0.11216418f, 0.08677956f, 0.00928806f, 
    0.06855855f, -0.01309986f, 0.12118656f, -0.06131703f, 0.00979382f, -0.00345992f, -0.01850710f, -0.00394431f, 
    0.06882244f, -0.06391482f, -0.02741916f, 0.07944494f, 0.00294466f, -0.08573120f, -0.11990923f, -0.21729773f, 
    0.05871966f, 0.02014890f, -0.06564757f, -0.00725739f, 0.00288333f, -0.05747159f, 0.02180011f, 0.00755133f, 
    0.24879389f, 0.19068241f, 0.12286010f, -0.20647933f, 0.00472342f, 0.15204431f, -0.05939354f, 0.01265459f, 
    0.09236810f, 0.12603268f, 0.09985602f, -0.04388487f, 0.20531347f, 0.00489905f, -0.14487085f, 0.13621612f, 
    -0.03970093f, 0.04052912f, 0.03412002f, 0.01593688f, 0.00411152f, 0.02939149f, -0.07099549f, -0.03177166f, 
    -0.08049390f, 0.00448555f, -0.06419257f, -0.16108972f, -0.14197168f, -0.04962291f, 0.15513378f, 0.00191025f, 
    -0.01078517f, -0.01870069f, -0.00804191f, 0.01710457f, 0.21769468f, -0.12363778f, -0.11002989f, -0.06543221f, 
    0.05328296f, 0.05217507f, -0.00047971f, -0.01596205f, 0.14021119f, 0.02977226f, 0.06790336f, 0.09964878f, 
    0.28600886f, -0.25080860f, -0.01353272f, -0.06970876f, -0.00711902f, 0.01305812f, -0.07614908f, -0.06571107f, 
    0.14994247f, 0.08648308f, 0.05133636f, -0.02961016f, 0.09310852f, 0.14046313f, -0.28858346f, -0.04469969f, 
    -0.03668740f, 0.09467435f, 0.02754768f, 0.11558393f, 0.02858263f, 0.03251364f, -0.02203648f, -0.08441709f, 
    -0.04721669f, 0.03575820f, -0.00190091f, 0.00395658f, 0.08981229f, -0.06881040f, 0.01478812f, 0.00101147f, 
    -0.03982277f, -0.12161878f, 0.10770005f, 0.15194242f, 0.07638750f, -0.05594790f, 0.00498934f, -0.07437958f, 
    -0.15286586f, 0.19032615f, 0.08848950f, -0.02969639f, -0.07990615f, 0.03603113f, -0.00039888f, -0.06186204f, 
    -0.13542302f, -0.06135107f, 0.29732040f, 0.29798526f, -0.03033655f, -0.00081748f, -0.04955308f, -0.08538503f, 
    0.04858425f, 0.08357719f, 0.10362313f, 0.08352745f, -0.16320792f, -0.03935463f, 0.07224222f, -0.27725646f, 
    0.08185252f, 0.07404418f, 0.01338788f, 0.12252977f, 0.00684567f, -0.14290868f, 0.02179635f, 0.02440598f, 
    -0.02721915f, 0.14267921f, 0.12989058f, 0.07182047f, -0.19274323f, -0.03592280f, 0.03374518f, -0.06332105f, 
    0.11946890f, -0.07537876f, 0.04327171f, 0.22929905f, -0.02083089f, 0.04212408f, 0.12718281f, -0.08291310f, 
    -0.18179344f, -0.05573110f, 0.00624719f, -0.04701824f, 0.04157709f, 0.08040170f, 0.07701198f, 0.03218593f, 
    0.00219257f, 0.06839032f, 0.24568555f, 0.11825048f, -0.08711328f, 0.11996827f, -0.07831866f, 0.12250067f, 
    0.04365228f, 0.00159349f, -0.01095363f, -0.02872559f, 0.47084343f, 0.07133333f, -0.41546699f, -0.15862361f, 
    -0.11332909f, -0.09243942f, -0.15865751f, 0.19254127f, 0.21972278f, 0.09383032f, -0.05843711f, 0.01120328f, 
    0.10198216f, -0.03088135f, 0.20606318f, 0.18670745f, 0.01100342f, 0.07159948f, -0.07824663f, -0.17940304f, 
    0.04704887f, 0.11015568f, 0.07725064f, -0.04569355f, -0.24024612f, 0.06417672f, -0.06796654f, -0.03910944f, 
    0.02774376f, -0.11404938f, -0.12921953f, 0.20372321f, 0.01954018f, 0.00948666f, 0.00788066f, -0.06160644f, 
    -0.03109048f, -0.23547335f, 0.05979557f, -0.01154750f, 0.10922539f, 0.01702855f, 0.03487037f, 0.16983537f, 
    -0.04539739f, 0.04869805f, -0.02079748f, -0.04352548f, 0.10909494f, -0.01164026f, 0.17290084f, -0.10000065f, 
    -0.06863887f, 0.10453197f, 0.00534325f, 0.00156312f, 0.05254656f, 0.09274496f, 0.05652883f, -0.12817737f, 
    -0.06582186f, -0.08800052f, -0.00674546f, -0.07079541f, -0.12290374f, 0.02280933f, 0.06517133f, 0.06342386f, 
    -0.06064620f, 0.02216834f, 0.15699948f, 0.12171628f, 0.08362324f, -0.04551627f, 0.17440635f, -0.04077316f, 
    0.05602105f, 0.10202806f, 0.03268168f, 0.14345795f, 0.05968669f, -0.00884009f, -0.02591268f, 0.03017233f, 
    0.27480140f, 0.03020158f, 0.24712270f, -0.25440091f, -0.05617099f, 0.05338781f, -0.06292237f, 0.12757693f, 
    0.01682545f, -0.03405106f, -0.01392472f, -0.09265265f, -0.09303207f, 0.14927270f, 0.00950861f, -0.02389022f, 
    0.02051855f, -0.01580765f, -0.15945938f, -0.00744524f, -0.11908654f, -0.04069244f, -0.01375593f, 0.04975899f, 
    0.19834408f, 0.13814595f, -0.01769531f, -0.01780409f, -0.07291315f, -0.05951574f, -0.16815022f, -0.00005783f, 
    -0.13980579f, 0.02543884f, -0.15004097f, -0.04678433f, 0.08401941f, 0.02449801f, -0.15262280f, 0.05214411f, 
    0.01868345f, 0.10035107f, 0.45201084f, 0.10838754f, -0.08618371f, 0.12816006f, -0.08345832f, 0.04329694f, 
    0.27455103f, -0.24097396f, -0.19014876f, 0.07226337f, -0.10108095f, -0.03091298f, -0.10778929f, -0.13765873f, 
    0.11071611f, 0.10100897f, 0.02034487f, -0.05439586f, -0.19042610f, -0.10334166f, 0.06855232f, -0.27604985f, 
    -0.17320149f, 0.23898879f, 0.19089638f, 0.16155864f, 0.08575577f, -0.08529754f, 0.13195540f, 0.15902779f, 
    0.04061929f, -0.09030910f, -0.01424086f, -0.16057375f, 0.08480339f, -0.15578593f, 0.02811691f, 0.17954871f, 
    -0.03044407f, 0.05963894f, 0.03806210f, -0.06321226f, 0.02290557f, -0.14068693f, -0.03271020f, 0.04874224f, 
    0.09590165f, 0.07130904f, -0.05497422f, 0.08099928f, 0.16580831f, -0.05572439f, 0.07619587f, -0.09694073f, 
    -0.02648708f, 0.02620903f, 0.14465082f, -0.06400271f, -0.00221712f, -0.11934839f, 0.03763546f, 0.05044830f, 
    0.03129275f, 0.11533666f, -0.03811904f, -0.08348957f, -0.26608682f, 0.04623491f, 0.02132666f, 0.25479546f, 
    -0.00045645f, -0.02322906f, 0.01139376f, 0.04937321f, 0.02615004f, -0.12469103f, 0.04090430f, 0.03092393f, 
    -0.06257761f, -0.16463405f, -0.30532584f, -0.13566309f, 0.00933423f, 0.10825096f, -0.10019314f, 0.06074755f, 
    -0.03513599f, 0.10989931f, 0.06228725f, 0.01198225f, 0.16952948f, -0.00066774f, 0.22214237f, 0.21459073f, 
    0.07938915f, 0.23795420f, -0.06185818f, 0.06111520f, 0.02123647f, 0.00078079f, -0.03540215f, -0.15542729f, 
    -0.04783430f, 0.04790901f, 0.38558924f, 0.11713420f, 0.05301858f, -0.00905481f, 0.06024063f, -0.04491256f, 
    0.07730871f, 0.02789617f, 0.05614473f, -0.06260321f, -0.16210315f, -0.03235815f, -0.19989760f, 0.02647822f, 
    -0.05911408f, 0.13851772f, -0.06220075f, -0.02080733f, 0.03869237f, -0.03915941f, -0.15275054f, 0.04124965f, 
    0.06721201f, -0.02196501f, -0.13635837f, 0.04947909f, -0.04014784f, 0.05449973f, 0.06397922f, 0.13270715f, 
    -0.00223202f, -0.06302206f, -0.07369868f, -0.18961415f, -0.20808016f, -0.17383161f, 0.19950077f, 0.13513950f, 
    -0.01962970f, -0.04137845f, 0.00122535f, -0.18473442f, 0.00217526f, 0.03104544f, 0.08436956f, 0.11545871f, 
    0.07991316f, 0.20959514f, -0.20728008f, 0.17049806f, -0.02397016f, -0.02543841f, 0.02570871f, 0.12317135f, 
    -0.01278946f, 0.12306456f, -0.18890506f, 0.05827834f, 0.35989973f, -0.15358520f, 0.42926398f, 0.04652692f, 
    -0.04250438f, 0.08708550f, 0.10976779f, 0.12913914f, -0.01212230f, -0.10723488f, -0.09161329f, -0.10455701f, 
    0.14508952f, -0.04533356f, -0.02422884f, 0.09989748f, 0.09877761f, -0.01918188f, -0.00208474f, -0.10169238f, 
    0.17812531f, 0.05167218f, 0.02459709f, 0.05813461f, -0.11490033f, -0.04746976f, 0.26893848f, -0.06622919f, 
    -0.03351496f, 0.10132437f, -0.30594948f, 0.08849473f, -0.00362395f, -0.03156924f, -0.09696890f, 0.10326839f, 
    -0.18015200f, -0.11795702f, -0.05719028f, 0.07540555f, 0.11307957f, -0.10157105f, 0.06174684f, -0.00033239f, 
    -0.03020451f, -0.05136167f, 0.04653988f, 0.07912257f, -0.11616105f, 0.19701256f, -0.08320425f, 0.02831906f, 
    0.06908271f, -0.05614682f, 0.15790150f, -0.24117237f, 0.07033902f, 0.14834623f, -0.03601474f, -0.07786243f, 
    -0.00092103f, -0.01968753f, -0.01979165f, -0.06518761f, -0.01622354f, -0.01089046f, -0.04672527f, -0.04765438f, 
    -0.03870307f, 0.00867725f, -0.05554894f, 0.01009646f, -0.06856579f, -0.01987465f, 0.03129205f, 0.02917601f, 
    -0.01609451f, -0.00176495f, 0.03417489f, 0.02201037f, -0.05978841f, 0.00805808f, -0.00151631f, 0.05892515f, 
    0.02435871f, 0.03759943f, -0.02824275f, -0.03287734f, 0.06419788f, -0.05057409f, -0.03131679f, -0.07014550f, 
    -0.07721119f, 0.04193461f, 0.03351256f, -0.02157179f, -0.06305049f, -0.07254506f, 0.05468336f, -0.04539954f, 
    -0.00030047f, 0.04587042f, -0.02248972f, 0.06687471f, 0.05671055f, -0.04405610f, -0.05362258f, -0.07112943f, 
    0.01669687f, -0.03836912f, -0.06698835f, -0.07594679f, -0.05170187f, -0.01375945f, 0.04968496f, -0.00098942f, 
    -0.05638292f, -0.05216913f, 0.00455046f, -0.02046379f, 0.03097097f, -0.06518288f, -0.05447733f, -0.04225811f, 
    -0.05208028f, 0.02197180f, -0.07589702f, -0.04329950f, 0.02054681f, -0.06202198f, 0.05888470f, -0.01633363f, 
    -0.04267539f, 0.01928142f, -0.06075808f, 0.06904194f, -0.04100963f, 0.01283263f, 0.01773989f, -0.06406670f, 
    -0.07626179f, -0.05400989f, 0.02154406f, -0.07631554f, 0.00527850f, 0.00432854f, -0.06601527f, 0.00561675f, 
    -0.00854578f, -0.07442208f, -0.07307231f, 0.03130995f, -0.05216207f, 0.03872056f, -0.06069751f, -0.07213125f, 
    -0.04122788f, -0.02205671f, -0.02036756f, -0.06467120f, 0.02656143f, -0.02747451f, -0.01688484f, 0.05476359f, 
    -0.01521957f, 0.04549727f, -0.03005452f, -0.06965449f, -0.01854333f, 0.00242216f, 0.05060491f, 0.03477298f, 
    0.03424710f, -0.01709704f, -0.04040677f, 0.03605100f, -0.01562462f, -0.01210891f, 0.03247096f, 0.01859566f, 
    0.00235994f, -0.03384835f, 0.03345821f, 0.02240858f, 0.06178134f, -0.07331507f, -0.00964206f, -0.06993752f, 
    -0.01878098f, -0.00463933f, -0.02781043f, 0.00985056f, 0.05647250f, -0.07158451f, -0.00109617f, -0.03341094f, 
    0.06356290f, 0.01422711f, -0.04802501f, -0.05394719f, -0.02422496f, 0.00861475f, -0.01915644f, 0.01045865f, 
    0.06545591f, 0.04632973f, -0.03363199f, -0.07546400f, 0.00100992f, 0.06213603f, 0.05172594f, 0.00610545f, 
    -0.02016623f, 0.02968364f, -0.02491961f, 0.01456239f, 0.02206608f, 0.00953922f, 0.00101066f, -0.05721363f, 
    0.01836826f, 0.01650283f, -0.03568684f, -0.02153117f, -0.00088563f, 0.06036622f, -0.03182407f, -0.01150650f, 
    0.06597313f, -0.05237924f, 0.00472505f, -0.04301479f, 0.02768745f, -0.01687228f, -0.04216126f, -0.05296427f, 
    -0.04259378f, -0.03734994f, -0.01074246f, 0.00597332f, 0.01901772f, 0.06262067f, -0.03083153f, -0.05758889f, 
    -0.03300505f, -0.05938748f, 0.05620625f, 0.00267003f, -0.03480399f, -0.03549796f, -0.01591854f, 0.00978023f, 
    -0.03172987f, -0.00700502f, 0.25044322f, 0.25102803f, -0.21150878f, 0.06009669f, 0.04637438f, 0.12139533f, 
    0.08229565f, -0.10820572f, 0.04002695f, -0.05293102f, -0.03580541f, -0.00490223f, -0.00877976f, -0.06676297f, 
    -0.02263685f, -0.02061465f, 0.05364984f, -0.00107891f, 0.08846447f, 0.18604404f, 0.10174312f, 0.14028575f, 
    0.01409021f, -0.17086202f, 0.18052483f, -0.06885031f, -0.17927428f, -0.05435245f, -0.06576507f, 0.18385883f, 
    0.05518769f, 0.08701959f, 0.07483283f, -0.06442598f, 0.22622718f, 0.06584151f, -0.41032720f, 0.19680125f, 
    -0.14835000f, 0.03443236f, -0.11226506f, 0.03369732f, 0.09320049f, -0.05947020f, -0.05310696f, -0.09110253f, 
    0.05308637f, -0.00666647f, -0.00788798f, -0.04258817f, 0.01350818f, -0.06083470f, -0.04563747f, 0.00520819f, 
    -0.05966174f, 0.09515284f, 0.01674182f, -0.08643351f, -0.33198211f, 0.16824523f, 0.21247132f, 0.09212345f, 
    -0.06182253f, -0.00009752f, -0.13159598f, 0.14473020f, 0.04780310f, 0.13397008f, 0.00062389f, -0.00195194f, 
    -0.20214318f, -0.39644778f, 0.35308143f, 0.11954135f, 0.00270724f, -0.04716275f, 0.01045455f, 0.09195224f, 
    -0.09553496f, -0.00842974f, 0.10367540f, 0.00884242f, 0.17336620f, 0.17542602f, 0.09238239f, -0.13132545f, 
    -0.02789263f, 0.18662220f, 0.15362531f, 0.02910160f, 0.06880043f, 0.12288335f, -0.06198417f, 0.05595705f, 
    0.09655965f, -0.02063404f, -0.09252548f, -0.04134123f, -0.11624630f, -0.01067865f, -0.07551099f, -0.03151328f, 
    -0.02892482f, -0.11617977f, 0.12777095f, 0.03866909f, 0.05021206f, 0.01127885f, -0.00393572f, -0.20526068f, 
    0.12419270f, -0.00614972f, 0.05656034f, -0.00320752f, 0.09103053f, 0.04144425f, 0.04789355f, 0.09117533f, 
    0.01219718f, 0.19114855f, 0.20967247f, 0.09604426f, -0.13621354f, 0.12484102f, -0.08789496f, 0.10814513f, 
    0.00372630f, -0.03015821f, 0.00865682f, 0.00506835f, -0.03773669f, 0.07374864f, 0.14733297f, 0.22880660f, 
    -0.05430480f, 0.00415253f, 0.09674746f, -0.05838143f, -0.05208964f, -0.10886554f, -0.10086460f, -0.07960287f, 
    -0.02316490f, 0.11813454f, 0.01622881f, 0.00809525f, 0.00826821f, -0.07930345f, 0.04584598f, -0.13359232f, 
    0.05089331f, 0.02708382f, -0.09973643f, 0.06994580f, -0.31192833f, -0.04103248f, 0.04450450f, 0.19732289f, 
    -0.09976283f, 0.04263671f, 0.09710158f, 0.02167280f, -0.13124543f, 0.14821333f, -0.01011324f, 0.00894442f, 
    0.14967063f, -0.02138343f, 0.03788605f, 0.05584978f, -0.04598070f, -0.04576984f, -0.03444061f, -0.09392394f, 
    0.00349508f, -0.12939151f, 0.05975343f, -0.01744856f, -0.12016813f, 0.24547648f, 0.03927943f, -0.26322305f, 
    -0.08133762f, 0.09696238f, 0.11439207f, 0.08125207f, -0.09858893f, -0.01681152f, 0.16106187f, 0.01656631f, 
    0.11952577f, 0.09916223f, 0.14470571f, 0.23751985f, -0.02612868f, 0.03009062f, 0.08219055f, 0.01648087f, 
    0.08709871f, -0.02841144f, 0.04980191f, 0.05378809f, 0.13800599f, 0.03622366f, 0.05948758f, 0.13152355f, 
    0.01256563f, 0.04041504f, -0.09117629f, 0.02760195f, -0.02098410f, 0.01542704f, 0.00407277f, 0.03415987f, 
    -0.22369242f, 0.20565316f, 0.08338152f, -0.22286722f, -0.02989068f, 0.30849957f, 0.01412093f, 0.03429606f, 
    0.01257307f, 0.01486916f, -0.05881482f, -0.06322216f, 0.27928039f, -0.38824573f, -0.54007185f, -0.41635722f, 
    -0.22589728f, -0.08146952f, -0.21631883f, -0.05173990f, 0.14061265f, -0.08348840f, -0.01464101f, 0.04173739f, 
    0.13774784f, 0.17421395f, 0.19140686f, 0.07633754f, -0.07855543f, 0.10017654f, -0.00614140f, -0.05198328f, 
    -0.02909300f, 0.04680117f, 0.16761467f, 0.10046669f, -0.02376485f, 0.00263031f, -0.02900532f, 0.10752881f, 
    0.08242985f, -0.13855270f, -0.07938260f, -0.02329374f, -0.08758279f, -0.04827356f, 0.03408039f, -0.06636515f, 
    -0.22291154f, -0.31872535f, -0.12143189f, -0.35660818f, -0.03146773f, 0.06276070f, -0.03142848f, 0.04304233f, 
    0.06887190f, 0.03353390f, 0.07211100f, -0.11557856f, -0.02592552f, 0.11903495f, 0.07379667f, 0.15159264f, 
    -0.03648445f, -0.05491763f, -0.06604284f, 0.02707001f, 0.00387629f, -0.04807394f, -0.02403022f, 0.05987095f, 
    -0.14395697f, -0.14657876f, -0.06665888f, -0.03465820f, 0.06347989f, 0.17220613f, 0.28140882f, -0.13580810f, 
    -0.08382024f, 0.06192256f, 0.15298870f, 0.01643617f, -0.28581911f, -0.07856012f, -0.13230139f, -0.37217930f, 
    -0.02354002f, -0.08623847f, 0.01667451f, 0.03167031f, 0.04183772f, -0.02441812f, -0.08598742f, -0.06694254f, 
    0.16072288f, 0.01702045f, 0.14755099f, 0.17971060f, 0.11286212f, 0.08076631f, 0.04001363f, -0.05757070f, 
    0.06198053f, 0.12375135f, 0.12636070f, 0.01317334f, -0.05736026f, -0.09675770f, -0.08694562f, 0.14444102f, 
    0.21368338f, -0.09623449f, -0.09276873f, -0.01577464f, 0.05261818f, -0.02955839f, 0.05918071f, 0.03702357f, 
    0.21337834f, 0.08210902f, 0.08632307f, 0.18678683f, 0.03043197f, -0.08166599f, 0.10991960f, 0.04246572f, 
    0.21283098f, 0.05226795f, -0.03158643f, 0.18365540f, 0.07139498f, -0.01342839f, -0.13582951f, 0.00666538f, 
    -0.03586110f, -0.09069408f, 0.12385488f, -0.14916503f, 0.05284394f, 0.09772162f, -0.01837026f, -0.08473310f, 
    0.36364922f, 0.00196856f, 0.21675146f, 0.03387718f, -0.05140507f, 0.00978314f, 0.01488272f, -0.08380222f, 
    -0.05305281f, -0.20540118f, 0.01393083f, -0.11805720f, -0.02281079f, 0.07801574f, -0.17683502f, -0.27490711f, 
    -0.08122028f, -0.20656554f, -0.03588807f, 0.29925796f, -0.02441662f, 0.15509836f, 0.04921605f, -0.02941588f, 
    -0.07962160f, -0.16227372f, -0.05043210f, -0.20917295f, -0.00856229f, 0.03904041f, 0.21199088f, 0.13004337f, 
    0.14229827f, 0.08639918f, -0.03073972f, -0.00490014f, 0.12572531f, -0.14230965f, -0.02925430f, 0.11825000f, 
    -0.06975141f, 0.04919102f, 0.08201664f, -0.02295224f, -0.04164314f, 0.00842222f, 0.13827194f, -0.09679724f, 
    -0.34711334f, -0.20349230f, -0.20301899f, -0.33044577f, 0.04179068f, -0.10073623f, 0.18156981f, -0.11619855f, 
    0.00192995f, 0.09236933f, -0.01211158f, 0.06003778f, -0.02562574f, 0.37205568f, 0.39121053f, 0.23897156f, 
    -0.02436125f, -0.11972204f, -0.10958982f, 0.00982993f, -0.04629593f, 0.15396082f, 0.00522155f, 0.08172399f, 
    0.12703158f, 0.13012175f, -0.08986788f, 0.06528927f, 0.07031484f, -0.08331341f, 0.15063830f, 0.01256322f, 
    0.07120588f, 0.19641326f, 0.02358424f, 0.06891840f, 0.34877834f, -0.17830800f, -0.00938932f, -0.25570348f, 
    0.00231373f, 0.03389873f, 0.24711366f, -0.06055564f, -0.06428985f, -0.04928328f, -0.05233949f, 0.04040479f, 
    -0.09945508f, 0.28650072f, 0.09625028f, -0.33370155f, -0.13695742f, -0.06566859f, 0.16289905f, -0.08516151f, 
    0.04859686f, 0.05813179f, -0.06395754f, 0.03847326f, 0.29002130f, -0.09967279f, -0.02776864f, 0.11609640f, 
    0.06788763f, 0.11095200f, 0.07872145f, 0.04457940f, -0.09553462f, -0.02159581f, 0.09482099f, -0.12788381f, 
    -0.14811282f, -0.01639067f, 0.08828436f, 0.11452810f, -0.14379093f, -0.07662915f, -0.07864805f, -0.04311330f, 
    -0.04744374f, -0.13967465f, -0.07866296f, -0.05970125f, -0.31470826f, -0.26201442f, -0.19339509f, 0.06107688f, 
    -0.02548104f, 0.19718215f, -0.05040825f, -0.03341337f, -0.02113367f, -0.03126020f, 0.21188104f, 0.01001088f, 
    0.13671279f, -0.08966973f, -0.11916583f, -0.23437877f, 0.13127047f, -0.10417898f, 0.10842272f, 0.01679649f, 
    -0.18749675f, 0.17572217f, -0.30487031f, 0.03164549f, -0.13818362f, -0.28602734f, -0.27728158f, -0.12546487f, 
    -0.14172955f, 0.24188706f, 0.07475929f, -0.06534828f, 0.01460551f, -0.02197929f, -0.00735767f, 0.08954004f, 
    0.04605315f, -0.07735590f, -0.07960501f, -0.11735378f, 0.07384296f, -0.00656569f, 0.10421095f, 0.06891467f, 
    -0.06021252f, -0.12366388f, 0.13871925f, 0.13213618f, 0.22334388f, 0.00431993f, 0.10391393f, -0.17027767f, 
    0.01554917f, -0.09299918f, 0.14450043f, 0.18376662f, 0.11090739f, 0.14042234f, 0.05472481f, -0.01830691f, 
    -0.12437449f, 0.11395913f, 0.16871884f, 0.38082752f, 0.02361643f, 0.04446602f, 0.05803064f, 0.08079669f, 
    -0.08290426f, 0.17680816f, 0.03145095f, 0.06388868f, 0.15872250f, 0.24222085f, 0.14327493f, -0.08012371f, 
    -0.00590837f, -0.15231274f, 0.10693031f, -0.04608025f, 0.24028252f, -0.15566655f, -0.12721604f, 0.08253537f, 
    -0.05779963f, -0.12133373f, 0.02444756f, 0.14853559f, -0.01963775f, -0.07118264f, -0.20111309f, -0.01735574f, 
    0.13171454f, -0.06443030f, -0.09777713f, 0.02919697f, -0.32239622f, -0.06492088f, -0.14259689f, -0.03223607f, 
    -0.03610020f, -0.17409402f, -0.05904441f, -0.13688105f, 0.01840010f, 0.09013166f, 0.05398876f, 0.17360786f, 
    0.31765148f, 0.10151842f, 0.16365391f, 0.06943381f, 0.05278120f, 0.12124851f, 0.05554112f, 0.20710249f, 
    0.08402409f, 0.08024357f, -0.01473682f, -0.04318544f, 0.12650448f, 0.06781618f, -0.14761163f, 0.05889850f, 
    0.07178466f, 0.08939385f, 0.11078005f, -0.12423528f, -0.06061973f, 0.06685543f, -0.02929111f, -0.13325168f, 
    -0.19623061f, 0.14889795f, -0.11572071f, -0.06183271f, -0.07615071f, 0.04446770f, -0.17471091f, 0.15772212f, 
    0.17563461f, -0.01227836f, -0.03757128f, 0.02337477f, -0.43513665f, 0.11070896f, -0.05481227f, 0.23945586f, 
    -0.07986376f, 0.11391465f, -0.02973194f, -0.10928357f, 0.01325094f, 0.02497635f, -0.03075883f, 0.04207681f, 
    0.11168339f, -0.33884713f, -0.11658069f, 0.22614856f, 0.14405106f, 0.11406706f, -0.05526621f, 0.25985423f, 
    -0.14616194f, -0.07450892f, -0.04745308f, 0.05439923f, -0.31812102f, 0.10994469f, -0.12621820f, 0.08787358f, 
    -0.01648971f, -0.11969397f, 0.06223981f, 0.02008288f, -0.06317205f, 0.10747229f, -0.11233877f, 0.08539477f, 
    0.20357977f, 0.21059144f, 0.09251747f, 0.05017824f, 0.16647947f, 0.19914716f, 0.07100758f, 0.20354271f, 
    0.00298215f, 0.13205898f, 0.03782549f, 0.15413053f, 0.32256615f, 0.56152779f, -0.01191999f, -0.14680675f, 
    0.05621706f, 0.04269914f, 0.07148311f, 0.04137293f, -0.07158023f, 0.08668161f, -0.10913856f, -0.02518738f, 
    -0.34882620f, 0.04840061f, 0.06467856f, 0.09731102f, 0.14955555f, -0.04248853f, -0.02873976f, -0.00236199f, 
    -0.06037958f, 0.06214390f, 0.01561992f, 0.16378939f, 0.04275709f, 0.05312528f, -0.08669735f, 0.25773835f, 
    0.11013649f, 0.07312921f, 0.00654686f, -0.06160312f, -0.00901868f, 0.04027699f, 0.00261127f, -0.07982158f, 
    -0.26666531f, -0.04929489f, -0.05129680f, 0.05655121f, -0.00180247f, 0.05089402f, -0.04390075f, -0.19226693f, 
    -0.06112887f, -0.05540638f, -0.22615163f, -0.17735411f, -0.22622293f, -0.26535115f, -0.03631032f, 0.22692181f, 
    0.07313216f, 0.04830939f, 0.01632484f, 0.10675615f, 0.11188099f, -0.08802190f, 0.12820759f, 0.14328972f, 
    -0.05926758f, 0.12955505f, 0.11190961f, -0.10343681f, -0.04398625f, 0.04005175f, -0.12424712f, -0.03521666f, 
    0.00867194f, -0.01876216f, 0.08930305f, 0.09487775f, 0.23161454f, 0.00544466f, 0.11793937f, 0.23409389f, 
    -0.07630953f, 0.10102893f, -0.00975787f, 0.13687558f, -0.01225441f, 0.03613764f, -0.00771637f, -0.09848868f, 
    -0.14570960f, -0.03040496f, -0.24196981f, 0.25645623f, 0.07863959f, 0.11061914f, 0.11378619f, -0.17582147f, 
    0.14760257f, -0.06871190f, -0.01858827f, 0.06385454f, -0.07923391f, -0.12960224f, 0.15309018f, -0.01433207f, 
    -0.11246521f, -0.28429198f, -0.01415073f, -0.16382729f, 0.04906116f, 0.12322247f, 0.04350809f, 0.09619625f, 
    0.02818303f, 0.15404868f, -0.01780734f, 0.00551909f, 0.09894536f, 0.14013520f, 0.01428487f, 0.06056066f, 
    0.02833222f, -0.05668905f, -0.01858176f, 0.05209157f, 0.04733980f, -0.07864315f, 0.01194095f, -0.08054561f, 
    -0.17636821f, -0.01862654f, -0.11819106f, 0.14866254f, 0.17920995f, -0.03126454f, 0.08908998f, 0.07843544f, 
    0.12630577f, -0.16360691f, 0.19597876f, 0.12827983f, -0.04738476f, 0.04591597f, 0.02589323f, -0.16683498f, 
    0.00996741f, -0.09239430f, 0.23481987f, -0.01091486f, -0.38824958f, 0.10308929f, -0.33256117f, 0.08033448f, 
    -0.02762561f, -0.28827995f, -0.04593883f, 0.10653967f, -0.00499747f, 0.00488042f, -0.08062349f, 0.09669774f, 
    0.05045610f, 0.17083606f, 0.07136687f, -0.23446533f, 0.09728774f, 0.07616639f, 0.16766693f, 0.03752719f, 
    0.04133497f, -0.05227486f, -0.01610325f, -0.05925461f, 0.01451049f, -0.12220595f, 0.10460574f, -0.00964033f, 
    0.13451910f, -0.08908661f, 0.00927073f, -0.00555188f, 0.21528074f, 0.03681951f, -0.08272207f, 0.10157963f, 
    0.03595523f, -0.02963361f, 0.07373668f, -0.08300108f, 0.02221209f, -0.03649097f, 0.09988876f, 0.24211305f, 
    0.00379084f, -0.13965435f, 0.06327450f, 0.05521655f, 0.18417372f, 0.04699450f, 0.09242234f, -0.14789917f, 
    0.03572043f, -0.06269139f, 0.11661520f, 0.07906377f, -0.04938988f, 0.01475333f, 0.01074511f, -0.11219522f, 
    0.20333073f, -0.38001975f, 0.12440630f, -0.33946803f, 0.26119298f, 0.09812190f, 0.06192395f, 0.03155600f, 
    0.22936849f, -0.07180582f, 0.09443017f, -0.12917978f, -0.01992879f, 0.22916177f, -0.08618550f, -0.13728262f, 
    0.09149635f, -0.07286172f, -0.15480031f, 0.04125392f, -0.06464730f, -0.04907294f, 0.01297048f, 0.03110398f, 
    0.03825486f, 0.07123853f, 0.04222609f, -0.06740576f, -0.02469214f, -0.00945184f, -0.06404637f, 0.03547671f, 
    0.02604464f, -0.06901880f, 0.05485340f, -0.08719860f, 0.11357561f, 0.04470111f, -0.13950409f, -0.15187030f, 
    -0.04260772f, -0.04887282f, 0.25250682f, -0.00885565f, 0.10924340f, 0.09254814f, -0.02295465f, 0.18102345f, 
    0.19830486f, -0.16354886f, 0.18576479f, 0.20088516f, -0.11954980f, -0.18738508f, -0.17141086f, -0.12347008f, 
    0.19180524f, 0.06890065f, 0.04928223f, -0.05663464f, -0.26134837f, -0.05512120f, -0.20979713f, -0.20836559f, 
    -0.10227285f, 0.11945087f, 0.01370294f, 0.18043259f, 0.08206288f, 0.03430933f, -0.02143509f, -0.09754565f, 
    0.11427335f, -0.04460031f, 0.05547738f, -0.20166880f, -0.13045461f, -0.12895499f, 0.12725925f, -0.12209485f, 
    -0.05458975f, -0.13385172f, 0.15535380f, 0.11086679f, -0.09465869f, -0.07647280f, -0.04541847f, -0.06477872f, 
    -0.26267976f, 0.00178368f, -0.11242209f, -0.05833113f, -0.08578063f, 0.21114211f, 0.03185107f, 0.11133808f, 
    -0.09566370f, -0.10925400f, 0.24326290f, 0.19638187f, 0.03482576f, 0.15969312f, -0.23961999f, -0.09357776f, 
    -0.04629270f, 0.03183923f, 0.02742793f, -0.05016224f, 0.12483148f, 0.18711282f, 0.03815984f, 0.11235084f, 
    -0.02937122f, -0.02747469f, 0.03240163f, 0.18999113f, 0.13026698f, -0.03933369f, -0.05541794f, 0.00652662f, 
    0.28890103f, 0.23206906f, 0.21698076f, 0.39591894f, 0.01566638f, 0.02565723f, -0.06397142f, -0.08594540f, 
    0.01871509f, 0.12717921f, 0.09216689f, -0.11621454f, 0.07209690f, -0.31870294f, 0.28999013f, -0.37341088f, 
    -0.06115301f, -0.10655475f, -0.18764472f, -0.05827768f, -0.13714732f, 0.06051639f, 0.00493143f, 0.01238706f, 
    -0.10413221f, -0.09607834f, 0.11213411f, 0.03313382f, 0.03720072f, 0.05733926f, 0.05050045f, -0.04293863f, 
    0.13359874f, -0.02739019f, 0.00700888f, -0.06738435f, 0.23277079f, 0.19272837f, 0.22583294f, -0.07813051f, 
    -0.18499911f, -0.00541619f, -0.05295598f, 0.04577543f, 0.12167493f, 0.09714955f, -0.11336508f, -0.04422710f, 
    -0.31414267f, -0.16694725f, -0.09089354f, 0.18386745f, -0.12321152f, 0.12725382f, 0.18035379f, 0.08581090f, 
    0.00407147f, 0.00959366f, 0.16482572f, 0.13435091f, -0.16069365f, -0.05730934f, 0.08736711f, 0.11772752f, 
    0.10358834f, 0.05369231f, 0.07398207f, 0.10472610f, 0.02329512f, -0.08997319f, -0.05140316f, 0.02584184f, 
    0.32586223f, 0.09058475f, 0.17808177f, 0.05376793f, -0.13399354f, 0.11348537f, -0.03380210f, 0.02873177f, 
    -0.02987876f, -0.13510649f, 0.11952978f, 0.01771434f, -0.02939095f, -0.04980547f, 0.24872874f, -0.06315083f, 
    0.03981518f, -0.01492035f, -0.12135165f, -0.03213196f, 0.02236076f, -0.08333070f, -0.02276088f, 0.08248223f, 
    0.24762048f, 0.18898146f, 0.01832412f, -0.18305179f, 0.04712768f, -0.09897877f, -0.19910607f, -0.05579452f, 
    -0.17974360f, -0.06170116f, -0.12001020f, -0.23514159f, 0.34313846f, 0.15597151f, 0.02177902f, 0.15262923f, 
    -0.04757519f, 0.17017877f, 0.22145265f, 0.03410808f, 0.10425793f, 0.06007042f, -0.12313898f, 0.02169446f, 
    -0.20130968f, -0.21016152f, -0.05877486f, -0.03110744f, -0.04640821f, -0.13264656f, 0.02595713f, -0.03926130f, 
    0.02563041f, -0.00408388f, 0.04122714f, -0.10326862f, 0.04715385f, -0.16008884f, 0.00109648f, -0.33410114f, 
    -0.01464274f, 0.09422377f, 0.14315292f, 0.12232700f, -0.03948973f, -0.02451321f, 0.11925940f, -0.05431173f, 
    0.22671762f, -0.32376114f, 0.27815267f, -0.09601571f, -0.20567401f, -0.17473602f, 0.04586865f, -0.18797204f, 
    -0.04563912f, -0.06057152f, 0.10621600f, 0.16309495f, 0.15484907f, 0.00714473f, -0.16925937f, -0.29360926f, 
    -0.19410555f, 0.02810517f, -0.01988857f, -0.12992896f, -0.01794607f, 0.08527309f, -0.03621499f, 0.02424830f, 
    0.03044991f, -0.16500132f, 0.22333853f, 0.14614403f, -0.16940121f, 0.19512367f, -0.07153650f, -0.02603393f, 
    0.01940326f, 0.00520670f, -0.00251618f, -0.04777984f, 0.24403740f, 0.29435453f, 0.10832892f, 0.25150469f, 
    -0.12871937f, -0.16213886f, 0.02907699f, 0.09689792f, -0.00461262f, 0.01752036f, -0.05222028f, 0.03786225f, 
    0.08437687f, 0.41534418f, -0.00381651f, 0.10969350f, -0.02640748f, 0.11480450f, -0.16493697f, -0.10014357f, 
    0.00518032f, 0.09703970f, 0.01622646f, 0.05026424f, 0.17695729f, -0.38109744f, -0.03891927f, -0.44359094f, 
    -0.06127374f, -0.03138852f, -0.10484260f, 0.04627381f, -0.02856510f, 0.01208911f, 0.03975680f, -0.18146002f, 
    0.00156855f, 0.05155311f, 0.18252039f, 0.06622879f, 0.07889469f, 0.04160854f, -0.01822107f, 0.02982635f, 
    0.15359904f, 0.08516763f, -0.00395473f, 0.06822515f, 0.44547525f, -0.15545611f, -0.02487963f, -0.01623799f, 
    -0.22039053f, -0.03795736f, -0.11303944f, 0.13029577f, -0.00376927f, 0.11160468f, 0.08595473f, -0.08673285f, 
    -0.34510982f, 0.05913590f, -0.05455498f, 0.16872400f, -0.08526812f, 0.11506395f, 0.15690212f, -0.11092238f, 
    -0.11343598f, 0.00067426f, 0.10791560f, 0.14513522f, -0.13789076f, -0.14641750f, 0.10172814f, 0.24570784f, 
    0.08483139f, -0.04777563f, -0.16833441f, 0.00692943f, 0.10293110f, 0.05233327f, 0.04277296f, 0.01407790f, 
    0.26535296f, 0.10463427f, 0.28038931f, -0.15167858f, -0.21299148f, 0.17275463f, -0.14647776f, -0.16238798f, 
    0.02101492f, -0.08847588f, 0.19186839f, 0.08500132f, 0.04611922f, -0.10732116f, -0.07694519f, -0.15736455f, 
    0.05429341f, 0.08818672f, 0.07336060f, -0.04533644f, 0.01018936f, -0.08673056f, -0.02080348f, 0.01438916f, 
    0.29450271f, 0.19490494f, -0.15048787f, 0.01463249f, 0.02724288f, -0.27577320f, -0.16870625f, -0.11273087f, 
    -0.03765240f, 0.09415150f, -0.00132729f, 0.15080664f, 0.19243813f, 0.27673173f, 0.02401816f, 0.23279600f, 
    -0.04468286f, 0.08895063f, 0.19913842f, -0.02159541f, -0.11320943f, -0.04424772f, -0.08036129f, -0.16170228f, 
    -0.10426661f, -0.16822495f, -0.02621702f, -0.09371773f, 0.01468166f, -0.06301616f, 0.04091343f, -0.03700890f, 
    0.04388556f, 0.04406167f, -0.07317286f, -0.02994873f, 0.21572229f, -0.12668388f, 0.28515926f, -0.06849185f, 
    0.15100290f, 0.04031139f, 0.00006446f, 0.18594266f, -0.06158187f, -0.05078768f, 0.19315246f, -0.04734117f, 
    -0.07346233f, -0.04120630f, 0.07755029f, -0.22573477f, -0.10099610f, -0.04553213f, -0.00288981f, 0.23373941f, 
    0.05504648f, 0.03022755f, -0.08634917f, -0.21018596f, -0.19125809f, -0.05359920f, -0.11618083f, -0.19816776f, 
    -0.03170284f, -0.02161783f, 0.00032125f, -0.08019613f, -0.10478564f, -0.22078362f, -0.13655972f, -0.04116156f, 
    -0.20628530f, -0.01657552f, 0.00964104f, 0.15525712f, -0.02744098f, 0.00071403f, 0.08080868f, 0.02644630f, 
    0.01755645f, 0.04775267f, 0.04081688f, -0.10411415f, -0.01371954f, -0.14962476f, -0.04645959f, 0.18117966f, 
    0.09493239f, 0.07171140f, -0.12914819f, 0.12490385f, 0.15723561f, 0.06295493f, 0.02403011f, 0.09445661f, 
    0.25618213f, -0.01652934f, -0.02960166f, 0.03670919f, 0.05974763f, -0.03045427f, 0.18280986f, -0.05621445f, 
    -0.10867464f, 0.19767556f, -0.05392393f, -0.10176315f, -0.01289081f, 0.16024490f, 0.30835107f, -0.09519894f, 
    -0.02025761f, -0.09557731f, 0.09001680f, 0.07579263f, 0.03349792f, -0.00669049f, 0.03732106f, -0.06036780f, 
    -0.29030350f, -0.11242718f, 0.12226129f, 0.15374744f, 0.02224338f, -0.10449199f, 0.19702430f, -0.00718832f, 
    0.08100992f, 0.12406778f, 0.06908214f, 0.06961673f, 0.02015577f, -0.05065852f, -0.13955516f, -0.39519832f, 
    0.00060823f, -0.00261104f, -0.08861820f, 0.04289090f, 0.11401512f, -0.07604221f, -0.00518489f, -0.08381013f, 
    0.09403753f, -0.04357541f, -0.17680171f, 0.10186911f, 0.04691439f, -0.05110255f, -0.04665384f, -0.02600892f, 
    -0.01872948f, 0.00375500f, -0.01631898f, -0.03107164f, -0.22549990f, -0.03557203f, -0.14293380f, 0.13301535f, 
    0.00581689f, 0.01729950f, -0.12118935f, 0.08693932f, 0.23313713f, 0.18258922f, 0.18444374f, 0.11520354f, 
    -0.12855190f, 0.05544632f, -0.11455877f, 0.27078921f, -0.21426372f, -0.21567893f, 0.08507373f, -0.04335587f, 
    0.01206576f, 0.01178282f, -0.27049404f, 0.19033206f, -0.10433511f, -0.09434117f, 0.35162729f, 0.02753946f, 
    -0.20223720f, 0.07366649f, -0.00173223f, 0.18913013f, -0.05335707f, -0.05641432f, -0.03088065f, 0.06711525f, 
    -0.09613243f, 0.07798773f, 0.19217467f, -0.10843211f, 0.06995101f, 0.03311041f, -0.04033494f, -0.06258619f, 
    -0.04718582f, -0.01754585f, 0.00822096f, 0.14706786f, -0.16254613f, 0.01890885f, 0.00500352f, 0.03366130f, 
    0.19934624f, -0.06221712f, 0.05413197f, -0.13597909f, -0.06261220f, 0.09347983f, 0.03407839f, 0.03424425f, 
    0.25489974f, 0.24878842f, -0.14114657f, 0.02450295f, 0.13961567f, 0.07849337f, 0.05595689f, -0.05019497f, 
    -0.12517382f, 0.07661396f, 0.11242181f, -0.06613405f, 0.07207835f, 0.29295960f, -0.25829923f, 0.30349997f, 
    0.03182520f, -0.21095026f, 0.04250173f, 0.15961683f, 0.10621357f, 0.20917816f, -0.06868456f, 0.09266002f, 
    -0.14590529f, 0.00144757f, 0.02846725f, 0.01981451f, -0.05374213f, 0.05286789f, -0.01315516f, -0.14668809f, 
    -0.12419246f, 0.04416442f, -0.04259491f, 0.08344052f, -0.00665154f, 0.03149707f, 0.06988302f, -0.03804848f, 
    -0.14982589f, -0.10637958f, -0.15208511f, -0.17255433f, 0.00940989f, 0.09648515f, -0.00678166f, 0.04293062f, 
    -0.08959409f, -0.06712798f, -0.10060973f, 0.05313300f, 0.04817437f, 0.11880079f, 0.00724687f, -0.14628926f, 
    -0.04735244f, 0.06900624f, -0.01111732f, 0.05646430f, -0.01882108f, -0.03335305f, -0.05092318f, -0.09392826f, 
    -0.10808104f, -0.04983794f, -0.04866675f, 0.00276732f, 0.08019309f, -0.03070001f, 0.00486376f, 0.06473216f, 
    0.47446609f, -0.13311006f, 0.31415713f, 0.11281775f, -0.03549729f, -0.13759367f, -0.03474784f, -0.10501881f, 
    0.07661855f, 0.03909643f, 0.06288727f, -0.00760227f, 0.08369288f, 0.04928770f, -0.22472195f, -0.17717020f, 
    0.13932133f, -0.17996456f, 0.04332170f, -0.00416492f, -0.07181133f, -0.13212071f, 0.00184374f, 0.04406723f, 
    0.02208545f, 0.05875956f, 0.07849970f, -0.17644827f, 0.01969030f, 0.14269160f, 0.00375928f, 0.00224344f, 
    -0.01038418f, -0.03799618f, -0.03722361f, -0.11400602f, 0.32481799f, -0.09077855f, 0.12304153f, 0.01872100f, 
    -0.05979558f, -0.07777339f, -0.07970468f, -0.04754291f, 0.05561998f, 0.03312864f, -0.08231609f, -0.02400181f, 
    -0.20562631f, -0.15513571f, -0.11327849f, -0.09253829f, 0.00447343f, -0.05472837f, -0.01177680f, 0.00899597f, 
    -0.05946422f, -0.08343978f, -0.06582861f, -0.05307337f, -0.03903563f, -0.19301659f, 0.03908650f, 0.02231336f, 
    -0.01223029f, -0.00177516f, 0.01203817f, 0.17342478f, 0.07950819f, -0.04174502f, 0.07571344f, 0.03520221f, 
    0.25275329f, -0.24009819f, 0.06724484f, -0.14759733f, -0.03706090f, 0.09445070f, -0.06124054f, -0.03357130f, 
    0.17071678f, -0.17880596f, 0.07338802f, -0.08733087f, -0.11364852f, 0.09560308f, -0.13639505f, -0.12734890f, 
    -0.08486493f, -0.02300924f, -0.06631457f, -0.14256532f, -0.02293452f, 0.02041914f, -0.04762569f, -0.04135758f, 
    0.00604214f, 0.10720679f, 0.03613091f, -0.06707392f, -0.02287873f, -0.03863080f, -0.10899721f, 0.03297321f, 
    -0.11003754f, -0.06951306f, -0.00701951f, -0.20250908f, 0.19160564f, 0.04932637f, -0.08803908f, -0.04438557f, 
    -0.09537517f, 0.13256821f, 0.24443041f, -0.10243995f, -0.02136693f, 0.05463691f, 0.03431880f, 0.04549687f, 
    0.00083094f, -0.23696361f, -0.07193670f, -0.01839942f, 0.00219101f, -0.03041703f, -0.14748535f, -0.10266189f, 
    0.03443779f, 0.04693852f, -0.04358946f, -0.01288711f, -0.23880619f, -0.08271056f, -0.06738020f, -0.22544865f, 
    -0.12351764f, -0.02246674f, 0.00332017f, 0.18576096f, 0.16361798f, 0.14557803f, -0.04768753f, -0.06053248f, 
    0.05183036f, 0.05783168f, -0.37318197f, 0.00372354f, 0.08556329f, 0.16704683f, 0.03624648f, 0.15130121f, 
    0.14878047f, -0.03466263f, 0.02974501f, 0.04700482f, 0.01899320f, -0.17626597f, -0.03577068f, 0.09283555f, 
    -0.06279211f, -0.22929190f, -0.08796640f, -0.01018158f, 0.06705449f, -0.16167682f, -0.07758599f, -0.13409856f, 
    -0.10438775f, 0.18858373f, 0.00957919f, 0.13136831f, 0.15219662f, 0.05019715f, 0.11562393f, -0.03308780f, 
    0.03823789f, -0.04702563f, -0.08393444f, 0.03085368f, -0.03092117f, -0.23125312f, 0.26925388f, -0.23302524f, 
    -0.07858567f, -0.03119483f, -0.00151474f, 0.26797718f, 0.14402665f, -0.06307782f, -0.08375178f, 0.17811657f, 
    0.04007803f, -0.08200481f, 0.04020646f, -0.04423190f, 0.00947439f, 0.01619977f, -0.01182587f, -0.08581913f, 
    0.18622065f, 0.08388525f, 0.21454832f, -0.00736602f, -0.21706364f, 0.08119883f, -0.42253485f, 0.15706368f, 
    -0.06550012f, -0.01453769f, -0.04954656f, -0.01347253f, -0.06794509f, -0.08970029f, -0.22495055f, 0.05605319f, 
    0.11700784f, 0.28598210f, -0.04714365f, 0.08256508f, 0.05062872f, 0.02384018f, 0.15994424f, 0.08798491f, 
    0.07481561f, -0.22685155f, 0.02969382f, 0.03481198f, -0.42771196f, -0.17596798f, -0.06760678f, -0.05618577f, 
    0.20714496f, -0.17600608f, -0.07180136f, -0.09421242f, 0.07062008f, -0.06307675f, -0.11844055f, 0.13869014f, 
    -0.13750041f, -0.15522724f, 0.10934661f, 0.13434185f, 0.19717439f, 0.09671829f, 0.02531458f, 0.17217369f, 
    -0.09065099f, -0.13244119f, -0.22403362f, -0.15806489f, -0.07437161f, -0.00202486f, 0.27287439f, 0.08914841f, 
    0.09537186f, 0.12833859f, -0.04327141f, 0.12290189f, 0.06346742f, 0.03856639f, 0.14070478f, -0.10164721f, 
    -0.03563888f, -0.07845362f, -0.06091909f, -0.09527110f, 0.15195608f, -0.18577038f, 0.11276518f, -0.06618363f, 
    0.03367827f, 0.12409507f, 0.07490601f, 0.03881790f, 0.21972288f, -0.00942096f, 0.13888389f, -0.10061733f, 
    0.12083413f, -0.05748131f, 0.03744451f, 0.24171053f, -0.05138670f, -0.09858581f, 0.17141984f, -0.05599733f, 
    -0.01791723f, -0.11279626f, -0.01557193f, 0.09774420f, -0.17740129f, 0.09021376f, 0.04509298f, 0.04055434f, 
    0.10841728f, 0.03486204f, 0.00998129f, 0.09781153f, 0.01910509f, 0.29499763f, -0.18218276f, -0.05620240f, 
    0.01140639f, -0.08213332f, -0.01551823f, -0.11892641f, 0.02753994f, 0.04016137f, 0.02333712f, 0.15943561f, 
    0.40953118f, 0.17413169f, 0.15795560f, -0.17087655f, -0.12879159f, -0.04241915f, -0.09310772f, 0.15327337f, 
    0.17106436f, 0.13488035f, 0.08778180f, 0.00773501f, 0.05303023f, 0.05094678f, -0.23001906f, 0.14609177f, 
    0.07893340f, -0.08205056f, 0.01289469f, -0.04834651f, 0.09848695f, 0.01228544f, -0.10895655f, -0.22030625f, 
    -0.01714174f, 0.05290142f, 0.01396338f, -0.07371953f, 0.03525944f, 0.02619508f, -0.01116134f, -0.11796959f, 
    0.07331248f, 0.13610280f, 0.11594220f, -0.05255756f, -0.04235269f, 0.05884450f, -0.02018374f, -0.04402288f, 
    -0.03312646f, 0.08400434f, -0.11637352f, -0.10337077f, 0.01225612f, 0.14876004f, 0.17103012f, 0.16438714f, 
    -0.10710044f, -0.15754519f, 0.01403314f, 0.03367881f, 0.09642990f, 0.05508006f, -0.00267380f, -0.23305474f, 
    -0.00754041f, 0.02060821f, 0.02553618f, 0.12706020f, -0.49651462f, -0.08307882f, 0.03407158f, -0.13334832f, 
    0.07219555f, -0.01771127f, -0.00974786f, 0.00467400f, 0.05084238f, 0.07359304f, 0.02529129f, 0.10596737f, 
    0.44622087f, -0.03279313f, 0.10276904f, 0.22901835f, 0.06483740f, -0.03346413f, 0.03088428f, -0.09468973f, 
    0.19175905f, -0.04391202f, 0.18500467f, 0.14391188f, 0.30115515f, 0.07369454f, -0.13622949f, -0.19828171f, 
    0.29540655f, -0.03940807f, 0.30307192f, 0.05197762f, -0.03813519f, -0.07938820f, -0.04649376f, -0.02411793f, 
    -0.12803535f, 0.12788256f, 0.07335458f, -0.12243487f, -0.08034854f, 0.06044760f, 0.03550659f, 0.16499995f, 
    -0.03899820f, 0.01189593f, -0.08734601f, -0.08145082f, 0.36742958f, 0.01171736f, 0.12404213f, 0.22214293f, 
    -0.01363797f, 0.02909477f, 0.08538796f, -0.02032594f, 0.09737276f, 0.06074519f, 0.05618830f, 0.05681685f, 
    -0.16068965f, -0.19369672f, -0.13097334f, -0.00548435f, 0.17170060f, 0.06623812f, 0.08475121f, 0.13907321f, 
    -0.05751782f, 0.02959730f, -0.04951546f, 0.08603302f, -0.12392151f, -0.01444009f, 0.00638704f, 0.00427670f, 
    -0.03079538f, -0.01986973f, 0.17720203f, 0.06093366f, 0.04597157f, 0.13113903f, 0.16566375f, -0.02138780f, 
    0.02596395f, -0.12118886f, -0.00792619f, 0.01926282f, 0.13152890f, 0.16649525f, 0.11940208f, 0.03669058f, 
    0.19078402f, -0.21700530f, 0.04652531f, 0.10535439f, -0.18631271f, -0.17176349f, 0.07788677f, 0.13927083f, 
    -0.06879555f, 0.05413171f, 0.01956630f, -0.25903034f, 0.01588280f, -0.02729837f, -0.00036314f, 0.01186933f, 
    -0.05247789f, -0.01851324f, -0.02082416f, -0.16530643f, 0.03239963f, 0.03992820f, 0.04816730f, -0.01233257f, 
    -0.17994903f, 0.04965329f, 0.09176024f, -0.23508772f, 0.19984064f, -0.01704343f, 0.15900901f, -0.07499758f, 
    0.01079707f, 0.09514856f, 0.04780607f, 0.12150697f, 0.07303405f, 0.00576718f, 0.15227830f, -0.01416241f, 
    -0.10435864f, 0.04211852f, 0.07224002f, -0.01930130f, 0.00205055f, -0.11229425f, -0.04553987f, -0.04412773f, 
    0.13831940f, 0.02107232f, 0.11663651f, 0.03417845f, -0.21149562f, -0.04345975f, -0.04733506f, -0.06729669f, 
    -0.01249085f, -0.00318239f, 0.02140428f, 0.10726085f, 0.10655142f, 0.20329595f, -0.13183275f, -0.04699177f, 
    0.01882990f, -0.08247155f, -0.02981407f, 0.14856082f, -0.01414586f, 0.08329707f, -0.01496431f, -0.20361310f, 
    -0.08972206f, -0.06458572f, 0.06257913f, 0.08467231f, -0.04295424f, 0.06921487f, -0.02255222f, -0.03223313f, 
    0.01107400f, -0.06211367f, -0.07598675f, -0.12408517f, 0.06378636f, 0.09649115f, -0.04336858f, 0.15697172f, 
    0.00070492f, 0.01870026f, -0.10210370f, 0.03901149f, 0.03684099f, 0.08459870f, -0.07336186f, -0.16910091f, 
    0.00559789f, -0.06982014f, 0.19800042f, 0.12193684f, -0.07378116f, -0.04646399f, 0.13495883f, -0.14301299f, 
    -0.08795579f, -0.05946721f, 0.07132719f, 0.07111768f, 0.12092770f, 0.13719574f, 0.06117360f, 0.10655019f, 
    0.10590030f, 0.04499413f, 0.14193897f, -0.00363804f, 0.00051070f, 0.02653902f, -0.03403518f, -0.09465381f, 
    0.10134173f, -0.13728033f, 0.04816407f, 0.03054895f, -0.12176058f, 0.01329232f, -0.34645078f, -0.10975512f, 
    0.12886237f, -0.14868286f, -0.00452907f, -0.09353355f, 0.10110300f, -0.10041007f, -0.11608613f, 0.05468465f, 
    0.02823698f, 0.07263449f, -0.09430623f, -0.20692600f, 0.03380912f, 0.15180528f, 0.02163156f, 0.08163042f, 
    0.01601062f, -0.03643206f, -0.04921674f, -0.06131596f, 0.11053646f, -0.09761360f, 0.10574302f, 0.02859902f, 
    0.04932000f, -0.13442287f, 0.00842971f, -0.07164824f, 0.02741539f, 0.09186459f, 0.02800688f, 0.03404385f, 
    -0.04987505f, -0.14273795f, -0.06830902f, 0.01713792f, 0.14901145f, -0.05510755f, 0.04697457f, 0.06844682f, 
    0.06195731f, 0.03481254f, 0.02320563f, 0.13629131f, 0.12383670f, 0.05941236f, 0.10662015f, -0.05286396f, 
    -0.02425577f, -0.04791764f, 0.06414938f, 0.11752190f, 0.16462106f, 0.01036369f, 0.03190677f, -0.03755790f, 
    0.14943220f, -0.42464194f, 0.04817143f, -0.20385651f, -0.00354437f, 0.06551989f, 0.00318713f, 0.00794939f, 
    0.12781823f, -0.11512882f, 0.22979479f, -0.02721626f, -0.10809133f, 0.11902732f, -0.33747888f, -0.14259610f, 
    -0.01818309f, 0.06236994f, -0.08439803f, -0.21333572f, 0.02184093f, -0.02947700f, 0.08181010f, 0.09858853f, 
    0.08669700f, 0.09818137f, -0.00921673f, -0.10037018f, -0.11162411f, -0.08169877f, 0.03229690f, 0.04504588f, 
    -0.06944484f, -0.06985257f, 0.01703742f, -0.17913139f, 0.12801971f, 0.04602401f, -0.09467249f, -0.02321175f, 
    -0.00953334f, 0.01926783f, 0.05953880f, -0.12002178f, 0.05910995f, -0.05822181f, 0.03496433f, 0.02975313f, 
    0.12483971f, -0.19433190f, 0.13252681f, -0.07595875f, -0.01937330f, -0.02591465f, -0.10708687f, -0.11519102f, 
    0.22442891f, 0.04796445f, 0.04304855f, -0.12841469f, -0.24116820f, -0.23584609f, -0.17005098f, -0.19247390f, 
    0.07430439f, 0.10791046f, -0.14152813f, 0.18924846f, 0.12029079f, -0.02495050f, 0.02885609f, -0.06100432f, 
    0.11131916f, 0.08074239f, -0.03560350f, 0.14721650f, 0.02388770f, -0.00424603f, 0.10168505f, 0.11344055f, 
    -0.12396554f, -0.00732542f, -0.04641901f, 0.06919396f, 0.07379296f, 0.08718759f, 0.16227975f, 0.04231470f, 
    0.01981966f, 0.07526430f, 0.02789528f, -0.06498782f, 0.07076424f, 0.04196069f, 0.04974069f, -0.00082890f, 
    -0.05386398f, 0.04504858f, -0.11447256f, -0.17666599f, 0.03609155f, 0.05501588f, 0.05754310f, 0.08346435f, 
    0.07433306f, -0.05390019f, -0.07545795f, -0.01455194f, 0.08510930f, -0.35375455f, -0.48343164f, -0.29825225f, 
    -0.00508766f, -0.09391113f, -0.20744912f, 0.16612796f, 0.08624745f, -0.08370002f, 0.04704563f, 0.00119826f, 
    0.36887425f, -0.15205920f, 0.31854510f, 0.15632477f, 0.03944582f, -0.08922616f, 0.08798475f, -0.07831909f, 
    0.09251097f, -0.01972436f, 0.03140371f, 0.02367551f, 0.27289751f, 0.13273752f, 0.11604390f, 0.04870717f, 
    0.25494313f, 0.02714959f, 0.08591331f, 0.04859021f, -0.10846675f, -0.09051979f, -0.09752796f, -0.13910697f, 
    -0.13267015f, -0.05040661f, 0.28421754f, -0.16616686f, -0.10805773f, 0.00691106f, 0.09389432f, -0.01466257f, 
    0.09861118f, 0.05578205f, -0.04139482f, -0.06786506f, 0.03568734f, 0.07046445f, 0.10620119f, 0.11421186f, 
    0.12777084f, 0.01717391f, -0.06455781f, -0.08665921f, -0.00352455f, -0.01341008f, -0.04097723f, -0.06641465f, 
    -0.13544330f, -0.11581361f, -0.02662919f, -0.11637085f, 0.03758534f, 0.03979454f, -0.01681820f, -0.19346158f, 
    -0.00333520f, -0.12321184f, -0.08148292f, -0.20295265f, -0.26197538f, -0.32666647f, -0.01643938f, -0.15566935f, 
    0.13527945f, 0.03222338f, 0.17468870f, 0.08131168f, 0.06036318f, -0.04827570f, 0.07521562f, 0.12061316f, 
    0.30269778f, 0.06084518f, 0.09139127f, 0.06491823f, 0.04831095f, 0.03663619f, 0.04310032f, 0.14221741f, 
    -0.09440175f, 0.09506357f, 0.00203243f, -0.07366752f, 0.04331411f, -0.01917163f, 0.03301700f, 0.21642822f, 
    0.06100696f, 0.11935901f, 0.10060842f, -0.00865758f, -0.10038110f, 0.00705009f, -0.03157576f, 0.04823074f, 
    0.09506036f, -0.02749164f, 0.10905452f, 0.10810404f, -0.04168089f, 0.07074065f, 0.17431058f, 0.10290720f, 
    0.10738513f, 0.05182550f, 0.15754907f, 0.17940065f, 0.10208010f, -0.06361040f, 0.06425484f, -0.14727394f, 
    0.01395169f, 0.03011439f, 0.07944169f, 0.12591203f, -0.11285936f, 0.06838010f, -0.08269047f, -0.09024043f, 
    0.11238312f, -0.00640780f, 0.03296862f, 0.13387625f, 0.05218274f, 0.03542893f, -0.01510200f, -0.12418088f, 
    -0.03202817f, 0.00187750f, 0.06435514f, 0.00265212f, -0.34936875f, 0.25082260f, -0.21445836f, -0.29907310f, 
    -0.19478537f, -0.19919308f, 0.02463430f, 0.06785328f, 0.10459169f, 0.08820844f, -0.05944834f, -0.04516422f, 
    0.01750978f, 0.09737632f, -0.11751406f, -0.20711420f, 0.23627046f, -0.01748006f, 0.10207814f, 0.01244272f, 
    -0.03818158f, 0.03430656f, -0.12994549f, -0.16039059f, -0.03242272f, -0.18323439f, -0.09505611f, -0.04198889f, 
    0.13288899f, 0.06919189f, 0.01783644f, 0.09316570f, -0.03624341f, -0.23502706f, 0.06721002f, -0.34101075f, 
    -0.16725288f, -0.00609079f, 0.08822387f, 0.13519932f, -0.00031128f, -0.04015554f, 0.16061737f, 0.18265675f, 
    0.02583087f, 0.03968553f, -0.06360554f, 0.12391564f, -0.10281815f, -0.17190112f, 0.34304994f, 0.14359283f, 
    0.13032003f, -0.02818627f, -0.13850683f, 0.23590143f, 0.04123253f, 0.07899015f, 0.09325497f, 0.29896879f, 
    0.04288183f, -0.05572804f, -0.14896044f, -0.20919469f, 0.05289265f, -0.02084523f, 0.12811694f, 0.02743965f, 
    0.04689023f, 0.00167975f, 0.08424418f, 0.07261109f, -0.19443923f, 0.24137318f, -0.24235708f, 0.35737297f, 
    0.10375255f, 0.21386307f, 0.04618266f, -0.05494375f, -0.14367054f, 0.09717439f, -0.12915407f, -0.36970878f, 
    -0.17708315f, 0.25442815f, 0.14658146f, 0.07042180f, -0.11611771f, -0.03241289f, -0.01307813f, 0.05479167f, 
    -0.04848788f, 0.03104474f, 0.03561658f, -0.04559010f, -0.29626909f, -0.26168373f, -0.13056673f, -0.01344780f, 
    0.24296083f, -0.09363480f, -0.11393958f, 0.02246127f, 0.03722769f, -0.19351424f, -0.00536435f, 0.00707577f, 
    -0.02943653f, -0.14716166f, -0.13836376f, -0.02494520f, 0.12167715f, 0.00850177f, -0.13384630f, 0.12293396f, 
    -0.05862047f, -0.05555690f, -0.26787740f, -0.26636642f, -0.15833336f, -0.14128298f, 0.13022664f, 0.13947406f, 
    0.00055986f, 0.07306582f, 0.02309500f, 0.09534789f, 0.12880681f, 0.03543137f, 0.05685493f, 0.17507480f, 
    -0.17594822f, 0.16900207f, -0.08931251f, -0.00649482f, 0.00619488f, -0.13845466f, 0.05762048f, -0.08139754f, 
    0.02424750f, -0.01367971f, 0.00785999f, 0.13385203f, 0.15389858f, -0.12592624f, 0.33812582f, 0.02016903f, 
    0.04371506f, 0.07304598f, 0.22972672f, 0.18124129f, 0.02866880f, 0.05767405f, -0.10941765f, -0.27393386f, 
    0.06035983f, -0.14987895f, -0.00667389f, -0.00517128f, -0.01594641f, 0.15464798f, 0.08661570f, -0.13084652f, 
    0.12676035f, 0.23090011f, 0.08147535f, 0.06898091f, -0.30839127f, 0.30473617f, -0.01487808f, -0.19889401f, 
    0.16686739f, -0.00192667f, -0.10436163f, -0.11469457f, -0.06805318f, -0.00238644f, -0.03625393f, -0.02269504f, 
    0.15383269f, 0.24276537f, 0.09977151f, -0.10691290f, 0.01895403f, 0.01679956f, -0.01514750f, 0.05897512f, 
    -0.04379180f, 0.10448864f, 0.08823372f, 0.08625305f, -0.18343084f, 0.39028829f, -0.14184041f, 0.29010940f, 
    0.21846285f, -0.15691464f, -0.01639473f, -0.17537853f, -0.02084542f, 0.03012814f, -0.04862291f, -0.26210880f, 
    0.10805669f, -0.02950710f, 0.16143119f, -0.00629343f, -0.01645093f, -0.01682362f, 0.12746842f, -0.10693207f, 
    -0.00909245f, 0.21743691f, -0.00085683f, -0.19094987f, 0.18235171f, 0.10996144f, 0.00771745f, 0.01336788f, 
    -0.00207989f, 0.03948763f, 0.06666715f, 0.00222826f, 0.04225799f, 0.00238528f, -0.00081904f, -0.11162997f, 
    -0.17991033f, -0.03810481f, -0.14287931f, -0.07517391f, -0.11600526f, 0.00342491f, 0.28981608f, 0.02829784f, 
    -0.06980471f, -0.00993701f, -0.12982838f, 0.09107844f, 0.27391782f, -0.23801230f, -0.27292368f, -0.27508569f, 
    -0.21938421f, -0.25984445f, -0.12295122f, 0.07134972f, 0.08087613f, -0.00447730f, 0.03219860f, 0.10129223f, 
    0.25856239f, 0.06244914f, -0.02084534f, -0.00579177f, 0.00509900f, -0.02265496f, 0.13146326f, 0.06663327f, 
    -0.02000949f, 0.13698351f, 0.02572906f, 0.20191912f, 0.42435905f, 0.16604812f, -0.03444276f, -0.12668027f, 
    0.00119963f, -0.12628470f, 0.09652377f, -0.00386282f, -0.10360871f, -0.03626817f, -0.01681514f, -0.00696558f, 
    -0.19683367f, 0.08154849f, 0.12775543f, -0.25499585f, 0.07902873f, 0.00189487f, 0.15325160f, 0.02060211f, 
    -0.09684238f, -0.03479845f, -0.09681659f, -0.01005752f, 0.21431868f, 0.09333313f, 0.02470612f, 0.03469283f, 
    0.07564614f, -0.03571612f, 0.00305342f, 0.09635589f, -0.05252845f, -0.09160089f, 0.14629336f, -0.13442087f, 
    -0.08708431f, -0.11717526f, -0.06151998f, -0.05327997f, 0.01605983f, -0.03884553f, -0.09307588f, -0.07082771f, 
    -0.18862638f, -0.13856912f, -0.16547102f, -0.04186511f, -0.05898633f, -0.25997877f, -0.11322577f, 0.16620015f, 
    0.01292021f, 0.30631638f, 0.12204731f, 0.21101105f, 0.01541886f, 0.09930517f, 0.08312030f, 0.01395503f, 
    0.24833046f, -0.13212760f, 0.16957924f, -0.03604333f, 0.03425246f, 0.08463314f, 0.06012591f, 0.14344604f, 
    0.02407121f, 0.07470686f, -0.03694645f, -0.02601462f, 0.16795257f, -0.17064141f, 0.02716200f, 0.11984536f, 
    -0.11259583f, 0.00710174f, 0.25565138f, -0.13447562f, -0.11042132f, 0.02429583f, -0.10404043f, 0.03330749f, 
    0.09186656f, -0.06417968f, 0.04986079f, 0.03649135f, -0.08256938f, -0.01514407f, 0.15787759f, -0.00168958f, 
    0.30287579f, 0.25383422f, 0.15663575f, 0.21698774f, 0.17223786f, -0.10121677f, 0.03055737f, -0.01044004f, 
    0.04028628f, -0.16781761f, 0.15278913f, 0.18654852f, 0.12929323f, 0.04188078f, 0.00310610f, -0.12859076f, 
    0.20841792f, 0.08615571f, 0.06807165f, -0.01469866f, -0.04877505f, 0.04560536f, -0.02609261f, 0.00351762f, 
    0.01861445f, -0.06657627f, -0.06729484f, 0.34555131f, -0.19509692f, 0.21449986f, 0.00450105f, -0.19782424f, 
    -0.07419483f, -0.14659181f, 0.06824701f, -0.24875177f, 0.03899647f, 0.17828281f, -0.20971000f, 0.02499189f, 
    -0.02479274f, -0.00375035f, -0.05847104f, -0.05323620f, -0.08501855f, -0.03721109f, -0.06174217f, 0.06009949f, 
    -0.01827876f, 0.01653573f, -0.01447129f, -0.01402386f, 0.02664836f, -0.07495265f, -0.01812557f, -0.06967500f, 
    -0.04883730f, -0.00818828f, -0.02186130f, 0.01512920f, 0.03557909f, 0.00368536f, -0.03986430f, -0.05877039f, 
    0.04889816f, 0.02183214f, -0.08223608f, 0.05201833f, -0.02118132f, -0.08018064f, 0.01301334f, -0.01262185f, 
    0.06122041f, -0.05221377f, -0.07645228f, -0.03852755f, 0.01350664f, -0.04999535f, -0.08806800f, -0.05823200f, 
    -0.00589467f, 0.04914334f, -0.05892965f, -0.05281471f, -0.07277377f, -0.04545053f, -0.03397280f, -0.02470170f, 
    -0.05935954f, 0.02723147f, -0.01208769f, 0.01957917f, 0.01010817f, 0.01137888f, -0.05579804f, -0.04376338f, 
    -0.07988028f, -0.00020077f, 0.03242511f, -0.02165029f, 0.03555017f, 0.06045854f, -0.00900188f, -0.01069148f, 
    0.04573350f, -0.06548689f, 0.05417729f, -0.02876471f, -0.05463735f, 0.01812758f, 0.02549566f, -0.02065578f, 
    -0.06250639f, -0.06147592f, 0.02930836f, -0.04999871f, -0.01176880f, 0.04340452f, 0.01323654f, -0.05294739f, 
    -0.02622321f, 0.05583110f, 0.03694249f, 0.04929955f, -0.06246132f, -0.04594150f, 0.03603175f, 0.01824439f, 
    -0.03477051f, -0.04820015f, -0.04319450f, 0.03966933f, 0.03817235f, -0.05907667f, 0.02944325f, 0.05275378f, 
    -0.00247406f, 0.05883567f, -0.01042709f, -0.05672642f, -0.00303264f, -0.06135176f, -0.01971288f, -0.03965943f, 
    -0.03162285f, -0.07113589f, 0.04290605f, 0.01260679f, -0.04015987f, 0.02623554f, 0.04512987f, 0.00594464f, 
    0.03333647f, 0.00435625f, -0.06663018f, -0.01263393f, -0.06849771f, -0.07181755f, 0.04622279f, -0.05226325f, 
    -0.01828046f, -0.04849984f, 0.02220850f, 0.06512880f, -0.04483069f, -0.05775235f, 0.02425940f, 0.00742832f, 
    -0.07588404f, 0.00514202f, -0.01524403f, -0.01653813f, 0.02366389f, 0.05006356f, -0.06694779f, 0.00993998f, 
    0.05350421f, -0.02036111f, -0.05084795f, 0.03607158f, -0.06647068f, 0.06628515f, -0.04498570f, -0.02156854f, 
    -0.01586889f, 0.02944061f, 0.01441326f, -0.03627331f, 0.01288043f, 0.01940508f, 0.01789708f, -0.00864372f, 
    0.02594566f, 0.00498097f, 0.05409390f, -0.02525109f, -0.02485755f, 0.03801504f, 0.02628696f, -0.02957712f, 
    -0.06028715f, 0.05928403f, 0.00450860f, 0.01904924f, 0.06131414f, -0.04634124f, 0.05732208f, -0.02658306f, 
    -0.06385736f, 0.02518176f, -0.03093765f, 0.03413592f, -0.00624015f, 0.02137180f, -0.03665180f, -0.01905450f, 
    0.04752880f, -0.00773286f, 0.05607783f, 0.04823244f, -0.00787045f, -0.08637898f, -0.04231955f, 0.02343070f, 
    0.04627180f, 0.06630529f, 0.04529516f, -0.03310642f, -0.03851966f, -0.05227514f, 0.01100708f, -0.03408816f, 
    0.00986815f, 0.00518188f, 0.20685068f, -0.12211312f, 0.03520942f, -0.00213086f, -0.04724822f, 0.01279994f, 
    -0.01311941f, 0.14248672f, 0.04414205f, 0.03780976f, -0.10599019f, 0.05505722f, 0.00560293f, -0.03184654f, 
    -0.00295745f, 0.06124514f, 0.01782123f, -0.04878312f, 0.02586823f, 0.02124812f, 0.19309151f, 0.16296257f, 
    -0.17600749f, -0.20180118f, -0.08566636f, 0.19055989f, -0.05728758f, 0.19949184f, 0.04960565f, -0.04651198f, 
    -0.14302666f, -0.08291522f, 0.01990592f, -0.12359797f, -0.01621365f, -0.07964183f, 0.27237290f, 0.32792026f, 
    0.06287080f, -0.04808412f, 0.02414666f, 0.03536659f, -0.00508850f, 0.07238908f, 0.10602864f, 0.07781071f, 
    0.23171520f, 0.29456258f, 0.05178088f, 0.16198170f, 0.04997754f, -0.07925148f, 0.12993170f, -0.08721410f, 
    0.03525570f, 0.22891600f, 0.08630760f, 0.05482122f, 0.13759044f, -0.08146363f, 0.25085530f, -0.21220843f, 
    0.14775813f, 0.03742711f, -0.01619678f, -0.07140681f, -0.03689728f, -0.07601932f, 0.05422958f, -0.00219661f, 
    -0.35330150f, -0.19523579f, -0.05487416f, 0.20407261f, 0.07859527f, 0.06820384f, 0.12346166f, -0.00422073f, 
    -0.08764709f, 0.08568059f, -0.10406861f, 0.01957632f, 0.32607996f, 0.17580988f, 0.09823383f, -0.06708873f, 
    -0.01909412f, 0.05953265f, 0.01883585f, -0.01288522f, 0.03334284f, 0.06487546f, 0.13567100f, -0.02903766f, 
    -0.02310540f, -0.02304199f, -0.17614862f, 0.15603741f, 0.15898827f, 0.05487561f, -0.00642910f, -0.08157177f, 
    -0.11923559f, -0.07923393f, 0.11777288f, 0.00606557f, -0.27405113f, -0.02778506f, -0.26103720f, 0.13162309f, 
    -0.01909446f, 0.07231477f, 0.02800310f, 0.01504059f, 0.07749579f, -0.04430101f, 0.08448237f, 0.09779733f, 
    -0.14320362f, 0.16154024f, 0.06240282f, 0.25990763f, -0.19924922f, -0.02868119f, 0.02273494f, -0.04314164f, 
    0.17903405f, 0.00188405f, -0.03879431f, 0.20728464f, -0.34185234f, 0.04935092f, 0.43251413f, -0.14752801f, 
    -0.10933276f, -0.10598332f, -0.19105071f, -0.10837766f, -0.04029727f, 0.00788525f, -0.03441902f, -0.05118204f, 
    -0.21183580f, 0.04527910f, 0.01333246f, -0.19730288f, -0.08372114f, 0.00010092f, -0.13750164f, -0.09333633f, 
    -0.00339271f, 0.21577698f, 0.14285460f, 0.03808706f, -0.07350115f, 0.19331577f, 0.06274414f, 0.17197566f, 
    0.18702750f, 0.06051276f, 0.21844083f, -0.07484712f, -0.02918214f, 0.00336784f, 0.08594538f, -0.04101894f, 
    -0.05723227f, 0.12113356f, -0.11133695f, -0.20584597f, 0.04043768f, 0.09890784f, 0.12126492f, 0.02931547f, 
    -0.00168967f, 0.13416016f, 0.12732434f, -0.01690573f, 0.17656992f, 0.01639405f, -0.17056064f, 0.24112362f, 
    0.06160549f, 0.02763866f, -0.00333593f, 0.09701969f, -0.06891076f, 0.12840806f, -0.03301677f, 0.02328654f, 
    0.02455464f, -0.05904774f, -0.06046968f, 0.01375559f, -0.01050245f, 0.01939625f, -0.01700461f, 0.02653909f, 
    -0.05470205f, 0.03314484f, -0.02521632f, -0.06853043f, 0.01462488f, 0.05649048f, 0.00131010f, -0.04131453f, 
    -0.06407759f, -0.06495154f, -0.06529584f, 0.03416029f, -0.02109226f, -0.06954107f, 0.06886456f, 0.06917585f, 
    -0.05368789f, 0.05109751f, 0.06292950f, -0.06375912f, -0.06581691f, -0.02137736f, -0.02876202f, 0.05557854f, 
    -0.02158717f, 0.05231515f, -0.04295549f, 0.04785768f, 0.03808283f, -0.05053594f, -0.07607735f, 0.03338382f, 
    -0.02959154f, -0.06577142f, -0.05776712f, -0.06806019f, -0.01939478f, -0.07266147f, -0.01502421f, -0.00921539f, 
    -0.07606356f, -0.04046191f, -0.05334798f, -0.04596815f, 0.06597819f, 0.04402328f, -0.00508707f, 0.01268030f, 
    -0.04001578f, -0.01989373f, 0.03523513f, -0.00812828f, -0.01684193f, 0.05602494f, -0.03332255f, -0.00735626f, 
    -0.07455850f, 0.04445291f, 0.04062630f, -0.07635361f, 0.03552953f, -0.03197246f, -0.05866554f, 0.02460140f, 
    -0.05668267f, -0.03211584f, -0.04292211f, 0.01194101f, -0.06787558f, -0.05380567f, 0.03110905f, 0.05850798f, 
    0.01656990f, -0.02737299f, 0.06645502f, 0.02987000f, 0.03770995f, 0.01727247f, -0.06720083f, 0.03432351f, 
    -0.07215835f, -0.02511950f, -0.07358637f, -0.01229912f, -0.07758757f, -0.03734932f, 0.02698280f, 0.06985553f, 
    -0.01401731f, -0.03759474f, -0.06940114f, 0.04160671f, -0.06441972f, -0.03174682f, -0.07262223f, 0.02752103f, 
    -0.05325568f, 0.02841373f, -0.03408121f, -0.02510217f, 0.05260345f, -0.00857969f, -0.04636943f, -0.03893899f, 
    0.04897538f, 0.03069414f, 0.06517521f, -0.02178010f, 0.02452795f, 0.06480949f, 0.01145269f, 0.03240868f, 
    0.00404388f, -0.00899034f, 0.01694684f, -0.04954914f, -0.05739768f, -0.03750915f, 0.05354332f, -0.04840099f, 
    0.01580920f, -0.04127828f, 0.05365281f, 0.06042112f, -0.07340984f, -0.04373680f, -0.01039638f, -0.06882469f, 
    -0.02907418f, -0.02962707f, -0.04987330f, 0.02435170f, -0.05693601f, -0.03732348f, 0.01955523f, -0.06881189f, 
    -0.05599603f, 0.04993435f, 0.05554922f, -0.03464880f, 0.06387257f, -0.05373383f, -0.07042229f, 0.01853587f, 
    -0.01652593f, 0.01765955f, 0.04087873f, 0.04577444f, 0.00552797f, -0.07216808f, 0.04333281f, -0.02666925f, 
    0.03854638f, 0.05774717f, -0.01140685f, 0.00621143f, -0.04810309f, -0.05063761f, 0.01073465f, 0.05332522f, 
    -0.01168148f, -0.02175638f, -0.06240772f, -0.06227987f, 0.05317279f, -0.00586410f, -0.06951021f, -0.03634648f, 
    -0.03309733f, -0.03526753f, -0.06859963f, 0.01645033f, -0.05799251f, -0.06193672f, -0.00582850f, -0.04002481f, 
    -0.01227832f, -0.05571200f, -0.00104440f, -0.07372712f, 0.01992423f, -0.05666015f, 0.03487020f, -0.00455191f, 
    -0.18562523f, -0.06457786f, 0.11432198f, -0.04690059f, -0.04499369f, 0.02676261f, -0.09803729f, 0.07680179f, 
    0.04245011f, 0.01028445f, 0.01322216f, -0.16250969f, -0.19332157f, -0.04610562f, -0.14838822f, -0.15017556f, 
    0.06836314f, 0.01665497f, 0.02711278f, 0.02762463f, -0.01977960f, 0.17840971f, 0.11552571f, 0.06854129f, 
    -0.01046507f, -0.10288653f, 0.15486614f, -0.04948282f, -0.08908704f, 0.04370506f, 0.02397498f, 0.05187168f, 
    0.03039784f, 0.09189861f, 0.12498185f, 0.05352220f, -0.25883704f, -0.08377357f, -0.21872583f, 0.16814445f, 
    0.13084675f, 0.08515691f, -0.02123232f, 0.03068838f, 0.01599975f, 0.04213921f, 0.01871323f, 0.05151055f, 
    0.18252559f, -0.22515823f, -0.16686153f, -0.10428777f, 0.03743687f, -0.00457014f, -0.06660469f, 0.05692052f, 
    -0.04336434f, 0.03354696f, -0.06749079f, 0.04874625f, -0.04325415f, 0.30115622f, 0.26697543f, 0.22414902f, 
    0.10531867f, 0.08505023f, 0.09776775f, 0.10466847f, -0.02140016f, 0.03739544f, 0.03363209f, -0.00800739f, 
    -0.29441893f, -0.13793138f, 0.32610229f, 0.13568783f, 0.05985057f, 0.04915279f, 0.10454298f, 0.14250317f, 
    -0.11204419f, 0.05979649f, -0.07994187f, -0.01627244f, -0.02856944f, 0.12714440f, 0.06416102f, -0.08682963f, 
    0.01110881f, 0.11942728f, 0.05630834f, 0.05543710f, 0.10668654f, 0.00118529f, -0.04486957f, 0.07239610f, 
    0.21833734f, -0.07659857f, -0.17061421f, 0.08689304f, 0.16294587f, 0.04586728f, -0.10494974f, 0.17036051f, 
    -0.00525904f, 0.04776625f, 0.03784836f, -0.02485240f, -0.17742346f, 0.06131436f, -0.09100606f, -0.03017158f, 
    0.09820472f, -0.11160710f, 0.11579730f, -0.07216967f, 0.04873021f, 0.17984225f, 0.03765081f, 0.14319567f, 
    -0.30896485f, 0.29404706f, -0.03235728f, 0.19357254f, -0.03609945f, 0.11748119f, -0.06789631f, 0.09615114f, 
    -0.01900396f, -0.05514719f, -0.16214143f, 0.08087670f, -0.02264046f, -0.03154462f, 0.45101899f, 0.36185396f, 
    -0.11233577f, -0.02788287f, 0.01970682f, -0.08154313f, -0.10485476f, -0.04191816f, -0.14156264f, -0.09384832f, 
    -0.26968634f, -0.08700876f, 0.00691284f, 0.01464154f, -0.10378123f, -0.00721914f, 0.02102458f, -0.05948625f, 
    -0.10387792f, 0.07260028f, -0.04889777f, -0.03547699f, -0.25773495f, -0.08081308f, 0.18321230f, 0.07549415f, 
    0.08723076f, 0.05060677f, -0.25817388f, 0.08483537f, 0.04987244f, -0.05201240f, 0.16746491f, 0.10230213f, 
    -0.00169948f, 0.03999724f, -0.11411850f, -0.02095189f, -0.03389633f, -0.11921928f, 0.00786472f, -0.07447299f, 
    0.09783958f, -0.05050291f, 0.08222733f, 0.06193515f, -0.08787996f, 0.32440144f, -0.15664780f, 0.02301075f, 
    -0.14605217f, 0.02523411f, 0.14807323f, 0.02318897f, -0.03635155f, 0.11754199f, -0.02304352f, -0.05305172f, 
    -0.08802129f, 0.11463097f, -0.10347757f, 0.08150630f, -0.10820635f, 0.09529746f, -0.16561542f, -0.11273867f, 
    -0.02431924f, -0.02773827f, 0.01709653f, -0.14776406f, -0.05730081f, 0.00886367f, -0.06265467f, -0.16294749f, 
    -0.04336515f, -0.06485077f, -0.07026001f, -0.06489245f, 0.00168742f, 0.03239775f, -0.10156140f, -0.07842476f, 
    -0.25186053f, 0.05889779f, 0.04934748f, 0.14091316f, 0.07285399f, 0.05753675f, 0.01520965f, 0.21071203f, 
    -0.01793084f, 0.03015630f, 0.01852787f, -0.01378582f, -0.03624491f, -0.22764069f, -0.21262147f, -0.33248106f, 
    0.01223302f, -0.04551221f, -0.07625242f, 0.08557743f, -0.01090246f, 0.01296483f, -0.00049796f, 0.07266258f, 
    0.08093370f, -0.27939740f, -0.01743121f, 0.05663820f, -0.01281209f, -0.07085783f, -0.07382119f, 0.05604555f, 
    -0.03310570f, -0.05836271f, 0.21028766f, -0.00291446f, -0.08601006f, 0.18851718f, -0.11688853f, 0.22478995f, 
    -0.00199984f, 0.02070989f, 0.01151437f, 0.22391349f, 0.01419903f, 0.03592850f, 0.02748522f, -0.01948664f, 
    -0.26380524f, -0.02719736f, 0.27841631f, -0.09123784f, 0.10246426f, 0.05032950f, 0.16557907f, 0.10945081f, 
    -0.09542231f, 0.09558782f, -0.04425467f, 0.02551182f, -0.10619041f, -0.13463059f, 0.07707527f, -0.02988917f, 
    0.03320536f, -0.01131546f, 0.05289241f, -0.00511008f, 0.09290221f, 0.03516790f, -0.12472665f, -0.06221645f, 
    0.10388086f, -0.15534337f, -0.07352384f, 0.00550765f, -0.13198356f, -0.12904914f, -0.22246140f, 0.13336605f, 
    0.02386961f, -0.07297012f, 0.01656086f, 0.07893667f, -0.08386850f, -0.13921385f, 0.23782620f, 0.03233869f, 
    0.10721875f, 0.06597185f, 0.12841906f, 0.00709357f, 0.01439875f, 0.11499792f, 0.14818223f, -0.01937260f, 
    -0.14976113f, -0.00026017f, 0.08373556f, -0.09568902f, 0.11572100f, 0.12635680f, -0.00715261f, 0.19605692f, 
    0.06058941f, -0.13213691f, 0.25373799f, -0.11555137f, -0.08785591f, -0.11069720f, 0.10638782f, 0.13048775f, 
    0.04505157f, -0.04089931f, 0.20650683f, -0.10832520f, -0.01502693f, 0.00876975f, 0.01124676f, -0.00843857f, 
    0.02313082f, -0.00936652f, 0.01466726f, 0.03571857f, -0.00700829f, -0.04084993f, 0.09320559f, -0.01649471f, 
    0.08878133f, 0.25502485f, -0.05185800f, 0.07130106f, -0.14432605f, -0.08901053f, 0.04218744f, -0.07764603f, 
    -0.01013505f, 0.10344145f, 0.00363313f, -0.00050454f, -0.12477696f, 0.02307769f, 0.05888350f, -0.00302762f, 
    0.24333820f, -0.00735293f, 0.05444046f, 0.02986841f, 0.07131179f, -0.03008447f, -0.12416054f, -0.01803633f, 
    0.12955754f, -0.05192414f, 0.01540610f, 0.08659411f, -0.25380778f, 0.28307122f, -0.10358808f, -0.23603696f, 
    -0.04522962f, 0.03201670f, 0.12824111f, -0.12006415f, 0.14087923f, 0.15832457f, 0.21352658f, 0.03323168f, 
    0.06457788f, -0.11316066f, 0.07064025f, 0.00079084f, -0.18056113f, -0.02021216f, 0.05203944f, 0.10533660f, 
    -0.08006406f, -0.10135961f, 0.01875983f, 0.13736197f, 0.02179267f, -0.05448765f, 0.02144750f, 0.06351617f, 
    -0.08047331f, -0.03878505f, 0.00627118f, -0.07385018f, -0.15287907f, 0.00211465f, -0.01442459f, -0.13297902f, 
    0.10555749f, 0.18752669f, 0.48733523f, 0.17692712f, -0.02381792f, 0.01833095f, -0.04665367f, 0.21694165f, 
    0.04781867f, 0.10972627f, -0.00920365f, 0.02389347f, 0.10781225f, 0.34428909f, -0.39122897f, 0.06610483f, 
    0.09766769f, 0.02961691f, -0.16070585f, -0.01539061f, 0.14303774f, 0.04567511f, -0.03645556f, -0.02713680f, 
    0.24295911f, 0.02978284f, -0.06766564f, 0.12140940f, -0.01317415f, 0.09263657f, -0.15662257f, 0.13374646f, 
    -0.07756931f, 0.07120819f, -0.04228603f, -0.02940466f, 0.21924476f, -0.08388053f, 0.25776872f, -0.00032602f, 
    -0.01018324f, 0.04916905f, -0.19486623f, 0.02406761f, -0.11702142f, 0.00510026f, 0.03853130f, -0.01210916f, 
    -0.03715881f, -0.37604925f, 0.41653061f, 0.26070645f, 0.00428371f, -0.05716325f, 0.05279664f, -0.02079530f, 
    0.08766374f, 0.11482752f, -0.01199191f, 0.04406680f, 0.03263168f, 0.16783018f, 0.06394993f, -0.02317179f, 
    -0.19645789f, 0.11514609f, 0.09903590f, -0.03186976f, -0.05938087f, -0.00742054f, -0.06643958f, -0.03568830f, 
    -0.22422153f, 0.08757713f, -0.04909789f, -0.10356054f, -0.08774317f, 0.07345243f, 0.19088444f, -0.00724250f, 
    0.01299168f, -0.04186253f, -0.09209763f, -0.12815812f, -0.16395478f, 0.09164737f, 0.21277601f, 0.09943243f, 
    0.08700363f, -0.03628596f, 0.14544451f, -0.04687017f, -0.03386635f, 0.11029625f, -0.00815465f, 0.05509559f, 
    0.28862348f, 0.22927552f, -0.16325109f, 0.09286424f, -0.10944935f, -0.05871059f, -0.00720854f, 0.11443556f, 
    -0.22928585f, 0.03735210f, -0.07108276f, 0.03479678f, 0.23739070f, -0.23641320f, 0.14665650f, 0.13100316f, 
    -0.03368274f, 0.15556188f, -0.05477530f, -0.01925627f, -0.04680829f, -0.12932585f, -0.06568266f, -0.01492952f, 
    0.13767529f, 0.10362252f, 0.02717692f, 0.13598211f, 0.05888989f, -0.04156880f, 0.03619592f, -0.02109040f, 
    0.13936478f, -0.03962428f, 0.09491870f, 0.08032731f, 0.25756410f, -0.19649971f, 0.05153883f, 0.07435150f, 
    -0.16466375f, 0.09714254f, 0.02268224f, 0.11827470f, -0.12256481f, -0.14530982f, -0.20613782f, 0.04114972f, 
    -0.26618707f, -0.12353033f, -0.09186042f, 0.25758204f, 0.07380518f, -0.02329671f, -0.03286932f, -0.05766340f, 
    -0.14523931f, -0.02034263f, 0.05950046f, 0.09006254f, -0.03686027f, 0.23398294f, 0.14355163f, -0.27577397f, 
    -0.14463460f, 0.05661231f, 0.23315899f, 0.02666849f, -0.17035320f, -0.04209623f, 0.03349441f, -0.01102797f, 
    -0.17092429f, 0.03722446f, -0.38732731f, 0.25604457f, 0.18375315f, 0.21325904f, -0.12523608f, 0.00484290f, 
    0.10726908f, -0.02669911f, -0.06122811f, 0.03660856f, -0.32909805f, -0.18332405f, -0.08002239f, -0.01139047f, 
    -0.07891497f, -0.29532832f, -0.20166068f, -0.10890504f, 0.04807947f, 0.25153333f, 0.04429916f, 0.03784762f, 
    -0.08184543f, 0.00963854f, -0.00829660f, -0.09911677f, 0.19270313f, 0.11641730f, 0.01961933f, -0.05538253f, 
    0.11454041f, -0.01139827f, 0.06749292f, 0.04192979f, -0.48880029f, -0.08524198f, 0.11928930f, -0.26337317f, 
    -0.04770312f, 0.03624503f, 0.02859198f, 0.05797690f, -0.00223251f, -0.07186060f, 0.05928594f, 0.07903849f, 
    0.18255858f, -0.08423946f, 0.06498371f, 0.02921882f, -0.10458297f, 0.03067805f, 0.03471448f, -0.01723229f, 
    0.09757469f, -0.06006289f, 0.14545836f, 0.01433547f, -0.07612753f, 0.14168397f, -0.42456126f, 0.17380548f, 
    -0.05161332f, 0.07672074f, 0.17868742f, 0.12020069f, -0.02403901f, -0.01699521f, -0.13690455f, 0.11377969f, 
    -0.05855916f, 0.19907388f, 0.03775809f, -0.12532724f, 0.05217685f, 0.15415986f, 0.03187982f, 0.13522179f, 
    -0.18187521f, -0.15685146f, -0.04056137f, -0.05863187f, -0.14912093f, -0.06926955f, 0.15168241f, 0.23089537f, 
    0.19150726f, 0.07865439f, 0.17385583f, -0.01779701f, 0.14400610f, 0.09976789f, -0.07310848f, 0.17555885f, 
    -0.13958438f, -0.18813373f, 0.11528758f, 0.11057271f, 0.18269618f, 0.08110227f, 0.02479398f, 0.20060794f, 
    0.03611974f, -0.02042358f, 0.06214807f, 0.14563577f, 0.04089551f, 0.00171223f, 0.21955636f, -0.04617955f, 
    0.08527976f, -0.00795755f, 0.12803243f, -0.03489119f, -0.07679662f, -0.09200008f, 0.04121742f, -0.09560280f, 
    -0.15739872f, -0.18571116f, 0.09797358f, -0.16156098f, 0.35891792f, 0.17791565f, 0.00408937f, 0.11846758f, 
    0.13198054f, -0.10120490f, 0.18400924f, -0.02377727f, -0.12099703f, -0.07630356f, -0.12662955f, 0.09456722f, 
    0.09514351f, 0.02290072f, 0.07131257f, -0.06098230f, -0.01046535f, -0.00229497f, 0.00649854f, 0.05587550f, 
    -0.10899753f, -0.22666961f, -0.12221320f, -0.18399891f, -0.19092202f, 0.05287741f, 0.10738624f, 0.05653704f, 
    -0.17583553f, -0.11549448f, -0.18706490f, -0.24016899f, -0.01468732f, 0.06571098f, -0.03615505f, -0.12491723f, 
    0.03419174f, 0.02954281f, -0.04565942f, 0.09505938f, 0.07649378f, 0.09562030f, 0.18553244f, 0.22289462f, 
    0.23634936f, -0.06349761f, 0.19345455f, 0.06419353f, -0.09263770f, -0.16291557f, -0.16713570f, -0.04014925f, 
    0.28120217f, -0.06392212f, -0.00885102f, 0.04693686f, -0.13954978f, -0.08163124f, -0.03059382f, -0.10633458f, 
    0.03118326f, -0.04520456f, 0.02974934f, 0.08122309f, 0.13785642f, 0.12411902f, -0.06730334f, -0.03360703f, 
    0.07315319f, -0.00064507f, 0.12678052f, -0.12263258f, -0.08707264f, -0.17133872f, 0.00406901f, 0.09926036f, 
    -0.25171801f, -0.11094978f, -0.13935930f, -0.17109737f, 0.04236253f, -0.03117915f, -0.41104943f, -0.05858397f, 
    0.21000966f, 0.07349100f, -0.01703735f, -0.06080750f, -0.29931679f, -0.44732574f, -0.14625718f, -0.11103054f, 
    0.13918325f, 0.04726861f, -0.05291804f, 0.05635406f, 0.04737988f, 0.05296309f, 0.17848969f, 0.23680595f, 
    0.03764059f, 0.00002751f, 0.10626476f, 0.03085449f, 0.17282413f, 0.11166693f, 0.18429884f, 0.30287698f, 
    0.24435334f, 0.04511765f, -0.00870426f, -0.01426686f, 0.00728159f, 0.09733701f, 0.04616075f, 0.07977463f, 
    -0.22301100f, 0.09091634f, -0.04274015f, -0.30791986f, -0.03781891f, -0.05556579f, 0.08123373f, 0.00878633f, 
    -0.05765577f, -0.02889373f, -0.10541201f, 0.02641115f, -0.02826695f, -0.16698183f, 0.22933801f, -0.08104922f, 
    0.07119339f, 0.19193909f, -0.05645965f, -0.09297334f, -0.07546391f, -0.32908875f, -0.05600432f, -0.30184588f, 
    0.11154799f, -0.01992731f, -0.05635248f, 0.29661182f, -0.12538294f, 0.03019527f, -0.06102701f, -0.00750033f, 
    0.09606451f, 0.10132719f, 0.03056118f, 0.13025150f, -0.14485526f, -0.04393975f, -0.18613477f, -0.02011590f, 
    0.01086378f, -0.15123738f, -0.20019680f, -0.05191105f, -0.30987260f, -0.14987633f, -0.02408740f, -0.17415990f, 
    0.04828685f, 0.14497958f, -0.16017006f, -0.27376556f, 0.05279475f, 0.01351893f, 0.11159792f, -0.01333423f, 
    -0.23411378f, 0.09855915f, -0.21184060f, -0.27964202f, 0.14587490f, 0.06070441f, -0.07277026f, 0.17161499f, 
    0.10957578f, 0.12371969f, 0.00466799f, 0.10124603f, 0.00549382f, 0.14461444f, 0.09521125f, 0.06118152f, 
    -0.30244073f, 0.25644803f, -0.09417691f, 0.35928026f, -0.17442325f, -0.18522434f, 0.06793292f, -0.20075925f, 
    -0.05400359f, 0.30167615f, -0.13182180f, 0.20056675f, 0.11883748f, 0.18568948f, -0.04721848f, -0.11423498f, 
    0.12342010f, 0.01251212f, 0.25927886f, 0.41093740f, -0.09745962f, -0.14344206f, -0.06788789f, -0.10776962f, 
    -0.10031506f, 0.04284121f, 0.19833072f, 0.18746620f, -0.11020574f, -0.12004030f, 0.01478963f, -0.11654988f, 
    0.06367484f, 0.03604019f, 0.14787666f, 0.25097904f, -0.32165483f, -0.04435328f, -0.10590647f, -0.02819648f, 
    0.16387126f, 0.06219727f, -0.06591883f, -0.00318665f, -0.13197219f, -0.22081535f, -0.01931038f, -0.18370482f, 
    0.20909300f, 0.32250378f, 0.12613434f, -0.04797949f, -0.12200861f, 0.18133281f, 0.11016893f, -0.02813518f, 
    -0.02614178f, 0.06794532f, 0.05247293f, 0.00427781f, 0.21348110f, -0.04634850f, 0.08381290f, 0.35776061f, 
    0.01177551f, -0.07834375f, -0.05170288f, -0.05574268f, -0.10755993f, -0.14133066f, -0.01036809f, 0.00647280f, 
    -0.01821183f, 0.03866032f, 0.04365786f, -0.04897491f, -0.05271843f, 0.04237172f, -0.06418675f, 0.07185103f, 
    0.07272178f, -0.00791514f, 0.02751194f, -0.04640761f, -0.03930215f, -0.06218728f, -0.06842095f, 0.06044685f, 
    0.05287749f, 0.04718942f, -0.03121686f, -0.01771444f, -0.07210075f, 0.03047581f, 0.00937615f, 0.01944618f, 
    -0.07034634f, -0.05428191f, 0.06634754f, -0.06963124f, -0.05839444f, 0.03800381f, 0.02565564f, -0.07126499f, 
    0.06080818f, 0.04463358f, 0.02482418f, 0.02348263f, 0.04563459f, 0.07041243f, -0.00149702f, -0.03395655f, 
    0.02550703f, -0.07480229f, 0.04529122f, -0.02970185f, 0.00626387f, 0.01454101f, -0.01804252f, 0.00759085f, 
    -0.03045557f, -0.06796528f, 0.01861545f, -0.07786759f, 0.01835861f, -0.01186306f, -0.01957660f, -0.03200535f, 
    -0.05183886f, -0.07290241f, -0.03413690f, -0.00172136f, 0.02064205f, 0.01389861f, 0.04602791f, -0.03531119f, 
    -0.05425360f, -0.07028563f, -0.01585217f, -0.02539355f, 0.04487228f, -0.07323587f, -0.04826394f, 0.02254820f, 
    -0.06572678f, -0.06143753f, 0.02892756f, 0.06315415f, -0.06141314f, 0.01759466f, -0.07491643f, -0.02695242f, 
    -0.07132410f, -0.07325482f, -0.03538084f, -0.01564190f, 0.03239799f, 0.00925800f, -0.06445912f, -0.01215601f, 
    0.01322769f, -0.02311762f, -0.01678183f, -0.04612873f, 0.02859470f, 0.02065652f, -0.04957076f, 0.04153856f, 
    -0.04231443f, -0.03912507f, -0.00076081f, 0.00655106f, -0.05935301f, 0.04541326f, 0.04151703f, 0.06127825f, 
    0.02730822f, -0.06591862f, -0.00042217f, -0.06230978f, 0.00595504f, -0.00542008f, -0.04890325f, -0.01031305f, 
    -0.03768975f, -0.01295082f, -0.00372449f, -0.03281398f, -0.01954972f, 0.03826556f, 0.06381111f, -0.03507953f, 
    0.02625732f, 0.05471001f, -0.04080737f, 0.00457246f, -0.02039674f, -0.05605745f, -0.06523877f, -0.01956882f, 
    -0.06096319f, 0.04593858f, -0.00312326f, 0.00600883f, -0.00777163f, -0.06295364f, 0.02499198f, 0.05698385f, 
    -0.00778530f, 0.03264886f, -0.03059757f, 0.00947108f, 0.00703789f, -0.05271524f, -0.04526970f, 0.01708464f, 
    -0.03764401f, 0.04684905f, 0.02325728f, 0.00651806f, 0.00607090f, -0.03682148f, 0.04271112f, -0.01647445f, 
    0.01864686f, -0.06754974f, -0.01629053f, 0.07095996f, -0.07068015f, 0.00519499f, -0.03557076f, -0.06261805f, 
    0.00497686f, -0.05673099f, 0.01065142f, -0.05580597f, 0.04760263f, 0.06108873f, 0.05563507f, 0.00709946f, 
    0.04050839f, 0.04587807f, 0.00142863f, -0.06065947f, -0.00526804f, 0.04650810f, -0.03884881f, 0.00120377f, 
    0.06217501f, -0.01134293f, -0.04486617f, -0.03271762f, -0.02050356f, 0.06379724f, 0.00283393f, -0.04589259f, 
    -0.00176493f, -0.03011208f, 0.00278361f, -0.06693362f, -0.02489957f, 0.06101790f, 0.01195119f, 0.00012527f, 
    0.06212108f, 0.06458702f, 0.06329527f, -0.05621829f, -0.05053240f, 0.03430238f, 0.06209196f, -0.02615536f, 
    0.05400301f, -0.03686999f, 0.04416630f, -0.05594421f, -0.06361069f, -0.06537826f, -0.06767128f, -0.03067907f, 
    0.04542579f, -0.02294119f, 0.06654514f, -0.07137361f, -0.00360397f, -0.06581496f, -0.04732942f, 0.00309383f, 
    -0.03392331f, -0.01193660f, 0.02487580f, -0.00642478f, -0.05519185f, 0.06217763f, 0.06284308f, -0.04689544f, 
    0.03489265f, -0.02264474f, -0.06468074f, -0.02607709f, 0.04824567f, -0.05456566f, -0.05446447f, -0.07750387f, 
    0.03026083f, -0.05005544f, -0.05619359f, -0.05649478f, -0.05257223f, 0.03103636f, 0.03653746f, 0.01037844f, 
    -0.05882962f, -0.00974349f, -0.00091448f, -0.01631420f, -0.01056853f, -0.07047009f, -0.01038773f, 0.00291419f, 
    -0.05458563f, -0.06989759f, -0.04034904f, 0.04542629f, -0.02381710f, -0.02067257f, -0.01024687f, -0.07325393f, 
    0.05148315f, -0.01032945f, 0.04324317f, 0.01893705f, 0.03708664f, 0.01556747f, 0.02484829f, 0.00886979f, 
    0.06688192f, 0.01072144f, -0.00738037f, -0.06519029f, 0.00610284f, -0.07731526f, -0.00990305f, -0.05330386f, 
    -0.07206175f, -0.00529962f, -0.04690489f, -0.03276175f, -0.04288496f, -0.04932895f, -0.04778069f, -0.01160160f, 
    0.02717498f, 0.01903814f, -0.03260943f, 0.02159275f, -0.05497823f, 0.03194021f, 0.05745560f, -0.02361440f, 
    0.03986720f, -0.02212502f, -0.05236793f, -0.04695359f, -0.06624250f, -0.01880255f, 0.06893883f, -0.02864653f, 
    -0.07183821f, 0.06139429f, 0.04816716f, 0.04028893f, 0.05975024f, 0.00284187f, -0.04872614f, -0.00694705f, 
    -0.01787704f, -0.01249254f, 0.01228963f, -0.03661456f, -0.02738330f, -0.05062983f, 0.01971708f, 0.04408409f, 
    -0.07315724f, 0.04366925f, 0.05039202f, 0.04085691f, -0.03277221f, -0.06805634f, 0.04728556f, 0.04009835f, 
    -0.01473256f, -0.05279342f, -0.06855264f, 0.01274743f, -0.05952086f, 0.05431322f, 0.01662885f, -0.02424001f, 
    -0.00642935f, -0.01428891f, 0.02400044f, 0.02783843f, -0.05922099f, 0.04780282f, 0.05846179f, -0.04963578f, 
    0.01794267f, 0.04461577f, -0.00179205f, 0.06354951f, -0.04563049f, 0.05755429f, -0.07363921f, -0.05779678f, 
    0.01005470f, -0.00259884f, 0.06539623f, 0.01128987f, -0.06338663f, 0.00271146f, -0.03142503f, -0.03538235f, 
    -0.06818356f, 0.03086722f, -0.02244430f, -0.01453888f, -0.07366320f, -0.07456137f, 0.00700410f, -0.03166754f, 
    -0.02195030f, -0.05110760f, -0.00004408f, -0.00901084f, 0.03013437f, -0.02142932f, 0.06606930f, 0.01815455f, 
    -0.00981655f, -0.00783289f, -0.06958530f, 0.00714620f, 0.00339303f, -0.01700495f, 0.07103865f, 0.04832221f, 
    0.02645169f, 0.04514437f, -0.07723739f, -0.01724868f, -0.06888726f, -0.05024707f, 0.01841573f, -0.04121308f, 
    0.05117167f, 0.00496766f, -0.05226829f, -0.03057624f, -0.00246651f, 0.01840445f, -0.03458300f, 0.02154705f, 
    -0.07447432f, -0.01810995f, 0.00678269f, -0.01409859f, 0.03697669f, -0.04243275f, -0.04002808f, -0.06737716f, 
    -0.05082049f, -0.04262011f, -0.02272635f, 0.02855132f, 0.00234080f, 0.06272656f, 0.00700222f, -0.00603413f, 
    -0.03470778f, -0.04500630f, 0.00469745f, -0.04389192f, 0.03772456f, 0.01776322f, -0.02318945f, -0.01925935f, 
    0.04117250f, 0.05934320f, -0.02710302f, -0.00637210f, -0.06163069f, -0.05553182f, 0.06552663f, -0.05804572f, 
    -0.06335256f, -0.01576263f, -0.03902112f, 0.00107139f, -0.00478081f, -0.03460114f, 0.01669618f, 0.04857993f, 
    0.02476738f, -0.07363801f, 0.00297858f, 0.03776409f, 0.04914948f, -0.05161803f, -0.04699747f, -0.06630662f, 
    -0.07552787f, -0.00086519f, -0.01944144f, 0.01207100f, -0.00943774f, 0.00858228f, -0.02213351f, -0.01405999f, 
    -0.01892646f, 0.02935044f, -0.04948171f, 0.02117165f, -0.06071582f, 0.04373759f, 0.01026331f, -0.01057652f, 
    -0.00092939f, -0.00890151f, 0.02760800f, 0.02614624f, -0.02172813f, -0.05988713f, -0.03181262f, 0.00786615f, 
    -0.02030797f, 0.02823562f, 0.00476625f, 0.02464679f, 0.05582555f, -0.01588277f, -0.05066692f, -0.00625456f, 
    0.05264198f, -0.05917866f, 0.05535858f, -0.07632544f, 0.02339992f, -0.03764219f, -0.06541733f, -0.03920618f, 
    -0.02888133f, 0.04068464f, 0.00031609f, 0.00893584f, 0.00698733f, -0.05665143f, 0.02615047f, -0.03831406f, 
    0.05926533f, 0.03083484f, 0.00814614f, 0.04257701f, -0.03777653f, 0.05985240f, -0.01914624f, -0.07676710f, 
    -0.07827131f, -0.02996551f, -0.01285378f, -0.05684568f, -0.07002666f, -0.07088588f, -0.00547769f, -0.07390336f, 
    -0.02320816f, 0.03110463f, 0.00158634f, 0.02376983f, 0.02909960f, -0.07899226f, -0.03119612f, -0.03528342f, 
    -0.03215833f, 0.03019416f, 0.00072850f, -0.06083915f, 0.03806331f, 0.04716624f, -0.00609623f, 0.02270420f, 
    0.03905023f, -0.04724798f, 0.00053391f, -0.02049911f, -0.03429912f, -0.07121722f, -0.04565869f, -0.00578918f, 
    -0.04611881f, 0.00297387f, 0.05702377f, 0.05197294f, 0.03970921f, -0.03308604f, 0.00637803f, -0.01188270f, 
    -0.06825171f, -0.07906974f, -0.00446550f, 0.00877552f, -0.07519553f, 0.00158978f, 0.03845054f, 0.06179265f, 
    -0.05613798f, 0.04447997f, -0.06879123f, -0.03063726f, -0.05720116f, -0.06141196f, 0.04888990f, 0.04141041f, 
    -0.02861320f, -0.07191440f, 0.01612026f, -0.04693472f, 0.05443798f, -0.06920434f, 0.01790624f, -0.03220106f, 
    0.06105029f, 0.04545136f, 0.04137661f, 0.00421567f, -0.01053491f, 0.04483209f, -0.00047483f, 0.01680113f, 
    -0.02054456f, -0.01717449f, 0.05825747f, 0.03967012f, -0.02676069f, 0.03879059f, 0.00557253f, -0.07658932f, 
    -0.02822227f, 0.00898879f, 0.00774806f, -0.06688741f, -0.03266739f, -0.05533626f, -0.03904163f, -0.01017443f, 
    0.03070085f, -0.03512060f, -0.06169230f, -0.01256677f, -0.04676052f, 0.07052357f, 0.00241740f, 0.04868726f, 
    -0.05335728f, -0.01745215f, -0.07202129f, 0.04513771f, 0.05706055f, -0.00021841f, -0.01815875f, 0.02979169f, 
    -0.04364650f, -0.00568978f, -0.07030634f, 0.05047397f, 0.02806052f, -0.05975772f, -0.05583010f, -0.00529848f, 
    -0.05337294f, -0.02378673f, -0.04389723f, -0.00215149f, -0.04228261f, -0.05635564f, 0.01620736f, 0.00784022f, 
    0.05517775f, 0.00427051f, -0.02512005f, 0.02635833f, 0.03555677f, -0.01402767f, 0.02004760f, 0.06169408f, 
    -0.05149481f, 0.03506902f, 0.06258068f, -0.05201871f, 0.04373877f, -0.07662034f, -0.03711500f, -0.05201432f, 
    0.00483034f, -0.05309798f, 0.00083586f, -0.05726188f, -0.00718778f, -0.03133906f, 0.02838722f, -0.02556114f, 
    -0.04548674f, -0.00757319f, 0.05087872f, -0.06357706f, -0.04602793f, 0.02652043f, -0.06303557f, -0.06113055f, 
    0.05521613f, -0.07781807f, 0.06130064f, -0.05495675f, -0.03225838f, -0.00431496f, 0.00219930f, 0.03768505f, 
    0.06140133f, 0.06274147f, 0.05971237f, 0.00005166f, 0.03586678f, -0.00957704f, -0.01505618f, -0.01030442f, 
    -0.05469402f, -0.06424957f, 0.00662681f, -0.01986599f, -0.01371859f, -0.05602868f, 0.06053311f, 0.01879295f, 
    0.00908172f, 0.02987132f, 0.03107939f, 0.01248805f, -0.03033024f, -0.07893247f, -0.03761376f, -0.03608116f, 
    0.06658613f, 0.05156957f, 0.05633920f, -0.04584116f, -0.05520709f, -0.04895583f, -0.04483401f, -0.01216607f, 
    0.01241726f, 0.02876933f, 0.02454720f, 0.01191663f, 0.05497542f, -0.02480721f, -0.01658061f, 0.03865745f, 
    0.02283803f, -0.00600356f, -0.06989563f, 0.01164320f, -0.04187082f, 0.03619657f, -0.05885423f, 0.04607600f, 
    -0.02138342f, -0.01920425f, -0.07760920f, 0.00836552f, -0.02236065f, -0.05860822f, -0.05687765f, -0.03687411f, 
    -0.05730218f, 0.00548069f, 0.02993822f, -0.05354692f, 0.05698434f, -0.02198476f, -0.00549114f, -0.04176711f, 
    -0.06173469f, -0.06169949f, -0.02030671f, -0.04388829f, 0.04430668f, -0.01968862f, 0.00782942f, -0.06440330f, 
    0.05082269f, 0.02054800f, -0.03786208f, 0.02517632f, -0.06927284f, 0.02513165f, 0.01499551f, 0.05174837f, 
    -0.02244813f, 0.00653935f, -0.06041303f, -0.04209124f, 0.00745612f, -0.01027437f, 0.05486671f, 0.00285697f, 
    0.03570159f, -0.04009834f, -0.03185292f, -0.03596250f, 0.04916487f, 0.02455192f, 0.05346692f, -0.00496058f, 
    -0.04187877f, -0.00944115f, -0.05611083f, 0.05469679f, -0.05289137f, 0.02632594f, -0.04019730f, 0.04619147f, 
    0.02193602f, 0.04770923f, -0.03066001f, 0.02148420f, -0.02427470f, 0.04717311f, -0.01415803f, -0.02781133f, 
    0.30655396f, 0.02757231f, 0.30320796f, 0.02539180f, -0.33765894f, -0.19234446f, 0.12621459f, -0.03800792f, 
    -0.09680300f, -0.05029159f, 0.04281865f, -0.10650857f, 0.28424686f, 0.23767027f, -0.06777786f, 0.12943919f, 
    0.00494279f, 0.21396628f, 0.07285335f, 0.12138819f, -0.16513580f, -0.10808308f, -0.06990848f, -0.02381000f, 
    0.11894059f, -0.08087140f, 0.14880355f, -0.08743151f, -0.13372926f, -0.05270753f, -0.01645279f, 0.08880380f, 
    -0.12344695f, -0.05702964f, -0.04328533f, 0.07248797f, 0.20203054f, 0.26149455f, 0.06530166f, 0.15690528f, 
    -0.08114575f, -0.19549698f, 0.12332570f, -0.08480755f, -0.05443069f, 0.08771581f, -0.09954763f, -0.07053738f, 
    -0.22078374f, 0.35409105f, -0.10870306f, 0.08552961f, 0.07375282f, -0.02741649f, -0.19964531f, 0.23270167f, 
    0.01151248f, 0.11649658f, 0.04963391f, 0.17007089f, 0.31776071f, -0.34346941f, 0.28287545f, -0.34972861f, 
    -0.02044849f, 0.14811283f, -0.00961528f, -0.18200666f, -0.17175940f, 0.01159441f, -0.00864072f, -0.14283462f, 
    0.22425011f, -0.09207474f, -0.16249815f, 0.06749643f, -0.04658407f, -0.03227700f, -0.06546008f, -0.01451385f, 
    0.05754760f, -0.08052123f, -0.05704527f, -0.04434239f, 0.23715256f, 0.34269086f, 0.14545782f, 0.24244015f, 
    -0.18890360f, 0.09580138f, 0.09946487f, 0.13332771f, -0.20400386f, -0.05259143f, 0.09257425f, -0.04687294f, 
    -0.17197251f, 0.15129752f, 0.04230230f, -0.14291291f, -0.03234797f, 0.11378530f, 0.10087126f, -0.13814621f, 
    -0.14973244f, -0.08916594f, -0.09489659f, 0.00648524f, 0.01395287f, -0.04496538f, 0.04606870f, 0.17535530f, 
    0.02464217f, 0.09377654f, -0.01514182f, 0.04957575f, -0.05940825f, -0.04195325f, 0.03900660f, 0.04818915f, 
    0.17511196f, 0.38938177f, 0.02512976f, 0.14058641f, -0.21444054f, 0.03922979f, -0.01712149f, 0.03615728f, 
    -0.13154301f, 0.10904968f, 0.19129446f, 0.02795895f, 0.13415933f, -0.17100067f, -0.10104187f, 0.06062423f, 
    -0.06812751f, -0.00806962f, 0.15794611f, 0.02292566f, 0.01854349f, -0.04191411f, 0.03510566f, -0.12243088f, 
    0.18367010f, 0.01304884f, 0.00025567f, -0.00906965f, -0.02452258f, -0.06065701f, -0.06224556f, -0.13389482f, 
    0.03356874f, -0.00472980f, 0.06105723f, 0.07711968f, 0.23197067f, -0.04936240f, 0.30872840f, 0.27860171f, 
    0.02568885f, 0.02129478f, -0.02644717f, 0.23944089f, -0.13270916f, -0.09940650f, 0.03000292f, -0.16379347f, 
    -0.13560595f, 0.12517774f, -0.07510822f, -0.18085112f, -0.06941262f, 0.11822476f, 0.11878534f, 0.04270805f, 
    0.05196854f, 0.11281274f, 0.07693487f, 0.15893817f, 0.21435376f, -0.38522425f, 0.26572967f, -0.08281489f, 
    0.00276252f, 0.01282636f, 0.04667161f, -0.07963294f, -0.15650345f, -0.08069631f, -0.02421681f, 0.00735874f, 
    -0.11360250f, -0.16512328f, -0.08635175f, 0.12192124f, -0.03997302f, 0.07020171f, 0.05519486f, -0.09791852f, 
    0.18796411f, 0.02036407f, 0.02561756f, 0.07238627f, 0.04067646f, 0.05772951f, 0.01400847f, -0.04789338f, 
    -0.05027764f, -0.04136268f, 0.06638294f, -0.04722340f, -0.03884625f, 0.02027336f, 0.02406399f, 0.14596760f, 
    0.06781231f, -0.02996190f, -0.17087060f, 0.03098112f, -0.07223973f, 0.15345320f, 0.16693389f, -0.00027596f, 
    0.06525330f, -0.04574820f, -0.06986687f, -0.02097819f, 0.46837568f, 0.18345104f, 0.12601432f, 0.03649029f, 
    0.05529589f, 0.07260875f, -0.04836943f, -0.02683297f, -0.05872260f, 0.23445830f, 0.00470154f, 0.06507754f, 
    0.03123672f, 0.31667316f, 0.06303088f, -0.03055509f, -0.00074010f, -0.02909948f, 0.12109748f, -0.14308609f, 
    0.19057032f, 0.21454240f, 0.00623915f, 0.10734079f, -0.24432813f, -0.09538895f, -0.16026092f, -0.16894618f, 
    -0.06849878f, -0.01184479f, 0.28708234f, -0.08206405f, 0.00202547f, -0.08727959f, 0.13266717f, -0.02239376f, 
    0.04569954f, 0.23824580f, -0.17139421f, -0.14579330f, 0.03651786f, -0.02281424f, 0.03709113f, 0.16512279f, 
    -0.12649679f, -0.07933178f, 0.05004873f, 0.03218850f, 0.19826370f, -0.15958889f, 0.02646507f, -0.10192488f, 
    0.12750302f, 0.01978876f, 0.01715445f, 0.13507333f, -0.06684029f, 0.09638491f, 0.16430190f, -0.17987023f, 
    -0.02314546f, 0.03516029f, 0.01620565f, -0.02610699f, -0.11029520f, 0.13198677f, 0.00339077f, -0.05778110f, 
    -0.07330770f, -0.05962201f, 0.08074990f, 0.05625425f, -0.00971651f, 0.01689730f, -0.33373526f, -0.00133645f, 
    -0.03409686f, 0.22662838f, -0.02805862f, 0.22270648f, 0.01310767f, -0.03265713f, -0.11302394f, -0.08659519f, 
    0.05471812f, -0.26929051f, 0.08831726f, -0.28051862f, 0.04253992f, 0.02590462f, 0.00045101f, -0.03555713f, 
    -0.03389870f, -0.10561934f, -0.03687051f, 0.07371581f, -0.29626241f, -0.07044958f, -0.58199799f, -0.12583579f, 
    0.01312630f, 0.26253155f, 0.17884660f, 0.01114754f, -0.04116640f, -0.06234290f, 0.04526887f, 0.06159204f, 
    -0.04900770f, -0.02238348f, -0.09610353f, 0.00469490f, -0.01092543f, 0.03828989f, 0.01240899f, 0.03794358f, 
    -0.20092160f, -0.07384700f, -0.05102988f, -0.02703376f, 0.00952148f, 0.00604045f, -0.15425777f, 0.19981042f, 
    0.09846588f, -0.02804830f, 0.43394071f, -0.00619615f, -0.04090010f, 0.11461081f, 0.14725339f, -0.17458436f, 
    0.15912983f, 0.26925573f, 0.18903938f, 0.16833870f, -0.03963920f, 0.07186683f, -0.06399208f, 0.03862034f, 
    0.01370763f, 0.08303573f, 0.03621329f, 0.02535197f, 0.24329981f, -0.00946131f, 0.16923530f, -0.03789022f, 
    0.03474756f, -0.01845778f, -0.12943283f, 0.13053305f, 0.10821986f, -0.13209578f, 0.07799546f, 0.20847458f, 
    -0.08670665f, 0.11705223f, 0.00608279f, 0.02697888f, 0.01742563f, 0.15155628f, 0.14714843f, 0.14713110f, 
    0.11059964f, 0.17172793f, 0.24385858f, 0.16780652f, 0.04722502f, 0.01008184f, 0.03487486f, 0.07066301f, 
    0.06417989f, 0.11311560f, 0.19000785f, 0.12640984f, 0.02064088f, 0.11268613f, 0.05563452f, 0.00387538f, 
    -0.05070057f, -0.03692912f, -0.31230152f, -0.44545129f, -0.02480149f, -0.00224523f, 0.21085393f, 0.02908435f, 
    -0.20087838f, -0.17172162f, -0.22678065f, -0.00661821f, 0.21972960f, -0.01299974f, -0.24141623f, -0.05277684f, 
    -0.32038930f, -0.39633662f, -0.24204743f, -0.02815297f, 0.06528545f, -0.20141013f, 0.16665988f, 0.15927039f, 
    0.13971670f, -0.33786017f, 0.01306201f, -0.16169792f, 0.05606235f, -0.07478899f, 0.08649790f, -0.04622756f, 
    -0.16550289f, 0.09654728f, -0.14389421f, 0.02942423f, 0.19309400f, 0.23327382f, 0.14031278f, -0.00865758f, 
    0.34997261f, -0.03838701f, 0.07308830f, -0.12621045f, 0.02249761f, 0.03441577f, 0.04766903f, 0.14142114f, 
    -0.08413611f, 0.13527985f, 0.20969532f, -0.24682382f, 0.03536594f, -0.02773943f, 0.06427009f, 0.18814796f, 
    -0.06077431f, 0.01795023f, -0.01915107f, -0.02640384f, 0.04071393f, -0.07812411f, -0.07587170f, -0.18225275f, 
    0.05139568f, 0.04038956f, -0.03678056f, -0.00915287f, -0.03354245f, 0.06423675f, 0.00411029f, 0.01358093f, 
    0.00064462f, 0.06932084f, 0.06053022f, -0.00502387f, 0.13535601f, 0.12459461f, -0.06559433f, -0.21953961f, 
    -0.19779697f, -0.03668656f, -0.09842363f, -0.06746621f, -0.12824889f, -0.48924902f, -0.60733527f, -0.31504872f, 
    0.11168969f, -0.06849604f, -0.05333291f, 0.01367574f, -0.28531164f, -0.04759665f, -0.02770797f, 0.10035973f, 
    0.00684627f, -0.19800852f, -0.06676962f, 0.03260956f, 0.05036544f, -0.01417925f, -0.00628244f, 0.15093464f, 
    -0.00214001f, 0.11630068f, -0.12870474f, 0.13610879f, -0.01370907f, -0.11018357f, -0.00438289f, 0.11793477f, 
    0.06764274f, 0.10605394f, 0.02598098f, -0.01041149f, -0.13520122f, -0.18040502f, -0.02459503f, 0.06210304f, 
    -0.18089736f, -0.10630307f, -0.25834623f, -0.12847659f, -0.13892801f, -0.18356659f, 0.08744375f, 0.10986432f, 
    0.15263310f, -0.02164151f, 0.07262783f, 0.21114603f, -0.01408991f, 0.10184837f, 0.07402585f, -0.11664815f, 
    0.18973230f, -0.11806870f, -0.03691250f, -0.03206495f, 0.01752980f, -0.00580893f, -0.03752830f, 0.09557219f, 
    -0.10144570f, -0.12701324f, -0.09032684f, 0.09816749f, -0.10622657f, -0.06710400f, -0.01416438f, 0.04689690f, 
    0.06304988f, 0.10532265f, 0.21715899f, -0.09764159f, -0.03669919f, 0.13760220f, 0.19131972f, 0.08233769f, 
    0.08154064f, -0.00251884f, 0.08924929f, 0.04992041f, 0.11798444f, -0.07793307f, -0.22296681f, -0.07939567f, 
    -0.00761526f, -0.06171233f, -0.05556353f, -0.25341034f, -0.06656655f, -0.16872007f, -0.17570013f, 0.03626684f, 
    0.11758708f, 0.05178828f, 0.02773809f, -0.18324898f, -0.18178883f, -0.02570216f, -0.15258743f, -0.03948229f, 
    -0.14487876f, -0.11589038f, -0.17377137f, -0.10346428f, -0.02955890f, 0.00988134f, 0.09515525f, -0.09255642f, 
    -0.21695453f, -0.32737887f, 0.18190324f, -0.00846446f, 0.07330318f, -0.00471908f, -0.10404526f, -0.10989619f, 
    0.06537399f, 0.16873088f, 0.07308412f, 0.04234865f, -0.40685827f, 0.05416999f, 0.29035372f, 0.04446885f, 
    0.08581895f, -0.06250104f, 0.00625032f, -0.03637838f, -0.01387414f, 0.20377208f, 0.08363988f, 0.08933504f, 
    -0.03482750f, 0.16749552f, -0.19885996f, 0.16792823f, -0.05676446f, 0.02329464f, -0.04096071f, 0.06814833f, 
    0.03275205f, 0.04454879f, 0.00511989f, 0.02212799f, 0.19254781f, -0.18074965f, -0.03702588f, -0.11789969f, 
    -0.01314458f, 0.17184196f, 0.08241415f, -0.01618953f, -0.21429485f, 0.01593991f, 0.02614930f, 0.09643830f, 
    -0.28735822f, -0.06378888f, 0.04500103f, 0.14384624f, -0.01282022f, -0.02937095f, 0.05079691f, 0.13413578f, 
    -0.06703349f, -0.01854861f, -0.12457291f, -0.02088740f, -0.09476394f, 0.11666261f, 0.08855601f, 0.17360121f, 
    0.05411701f, 0.11053797f, 0.16336909f, 0.03409107f, 0.01084405f, -0.05308417f, -0.01024268f, 0.05991603f, 
    -0.07526746f, -0.18911327f, 0.03103285f, 0.11224423f, 0.10520560f, 0.12496006f, -0.10617309f, 0.19204853f, 
    -0.02810183f, 0.01468839f, 0.07094783f, 0.03615959f, -0.28499472f, 0.06213237f, 0.04978886f, 0.12686487f, 
    0.00729385f, 0.03556286f, 0.14293315f, -0.12134340f, 0.10607335f, 0.10455382f, 0.17871509f, 0.06388899f, 
    -0.45177087f, 0.32702836f, 0.04013942f, 0.09372173f, 0.21468024f, 0.07254572f, 0.01546850f, 0.18083978f, 
    0.02384503f, -0.00545397f, -0.01961098f, 0.05915316f, -0.12013961f, -0.42877361f, 0.18682133f, -0.00915269f, 
    -0.01131841f, 0.02230711f, 0.11790317f, -0.19430113f, -0.05861059f, -0.02352428f, 0.07574096f, -0.01996591f, 
    -0.00148112f, 0.11395810f, 0.12482671f, 0.00166418f, -0.12854789f, 0.00912038f, 0.08652837f, 0.01696106f, 
    -0.00284997f, 0.01534652f, -0.05064052f, -0.24386449f, 0.01582572f, 0.05075612f, 0.23421247f, 0.13729198f, 
    0.11425170f, 0.05756921f, -0.23042861f, 0.27729258f, 0.12862709f, -0.04090175f, 0.24625418f, 0.13490908f, 
    -0.14069372f, 0.24824390f, -0.05847340f, -0.17942269f, 0.01360702f, 0.02001639f, -0.01551537f, 0.16412842f, 
    0.14875986f, 0.00161418f, 0.11354107f, 0.00060458f, 0.22723472f, -0.04861365f, 0.20885462f, 0.07667101f, 
    -0.06952145f, -0.07261615f, 0.08355036f, -0.12591958f, -0.11666846f, 0.08294784f, 0.07125789f, 0.04748977f, 
    -0.05037325f, 0.00898959f, 0.00670013f, -0.01623285f, -0.04745467f, 0.03318319f, 0.03595926f, -0.03197322f, 
    -0.04113618f, -0.03546283f, -0.07145267f, -0.01956681f, -0.06083946f, 0.00466111f, 0.02699593f, -0.01998327f, 
    -0.06329361f, -0.02043278f, -0.04413057f, 0.03619532f, -0.04701571f, -0.01553767f, -0.04615160f, -0.01390074f, 
    0.02341497f, 0.06424766f, -0.00456887f, 0.06651570f, -0.02470693f, -0.04572919f, -0.04298351f, 0.04045548f, 
    -0.02218756f, -0.06725992f, 0.01264934f, -0.07082974f, -0.06030333f, 0.01216944f, -0.05785088f, -0.00175997f, 
    -0.00724726f, 0.03616399f, -0.01250476f, -0.06297087f, -0.03625116f, 0.07281646f, -0.03354835f, 0.04174665f, 
    -0.00741147f, 0.00713717f, 0.04353639f, -0.04195319f, -0.00658806f, -0.05310056f, 0.02915934f, 0.05203982f, 
    -0.03655024f, -0.05752720f, -0.06671517f, -0.06247812f, 0.02214972f, -0.03170596f, -0.01523457f, -0.07236382f, 
    -0.04930114f, 0.03218444f, 0.06287748f, -0.02693637f, 0.04374893f, -0.00714942f, 0.05443607f, -0.01422933f, 
    -0.07704514f, -0.05430928f, -0.07610374f, 0.03115166f, 0.01637841f, -0.04875375f, 0.01275513f, -0.01770578f, 
    -0.05371337f, -0.05362644f, 0.03712103f, 0.04084269f, 0.01562115f, -0.01419964f, -0.02925976f, 0.04084390f, 
    0.03952639f, 0.06199929f, 0.05226987f, -0.03170409f, 0.03079613f, 0.05547088f, 0.03964913f, -0.07760382f, 
    0.03371730f, 0.06247939f, -0.02647216f, 0.01686215f, 0.04362734f, 0.04934001f, -0.05465404f, -0.06642302f, 
    -0.04596598f, -0.01121727f, 0.01415595f, -0.07381859f, -0.05777309f, -0.02219647f, -0.05101475f, -0.03832517f, 
    0.06385846f, 0.00230393f, -0.01913177f, -0.07521345f, -0.05470305f, -0.03615791f, -0.01958690f, 0.05186747f, 
    -0.00895966f, -0.07231178f, 0.04945917f, -0.05966235f, -0.06460730f, 0.04591133f, 0.05892347f, -0.07693107f, 
    -0.03920087f, -0.00807806f, -0.04931150f, 0.00549330f, -0.06440853f, -0.00669638f, 0.02783661f, -0.00381181f, 
    -0.03350970f, 0.02480214f, -0.01625977f, -0.07708943f, -0.03207568f, -0.07386560f, -0.05255632f, 0.01022071f, 
    -0.04474761f, 0.01554693f, 0.03045161f, -0.03072855f, -0.05379347f, 0.03475561f, 0.05651531f, 0.05693733f, 
    -0.02355262f, 0.04420791f, -0.02656003f, -0.04694805f, -0.04212191f, 0.04187785f, 0.01558308f, -0.05269788f, 
    0.01825205f, 0.03279155f, -0.05917051f, 0.04569793f, 0.00071674f, 0.02783355f, 0.02499540f, 0.03298289f, 
    0.03029880f, 0.02255064f, -0.06192274f, 0.05774071f, 0.02799791f, -0.03440482f, -0.02780659f, -0.03393332f, 
    0.06179838f, 0.01963900f, -0.05679680f, 0.02307744f, 0.00940153f, -0.05934780f, -0.04790342f, 0.01282495f, 
    -0.04967364f, -0.01905776f, -0.00759946f, -0.07066641f, 0.01090291f, -0.05411427f, 0.01074754f, 0.03635993f, 
    -0.02462116f, -0.06412786f, 0.03976125f, 0.00661468f, 0.12254967f, -0.06627242f, -0.16747317f, 0.03412201f, 
    -0.04384869f, 0.02148297f, 0.05553585f, -0.04534918f, -0.05963577f, -0.08505098f, -0.05671418f, -0.00097025f, 
    -0.00187498f, -0.02264408f, -0.06750129f, 0.00555216f, 0.10876174f, 0.21472837f, 0.02310436f, 0.03309323f, 
    0.19246711f, 0.18544893f, 0.12259599f, -0.03919479f, 0.15294641f, -0.10273574f, 0.09105064f, 0.05759467f, 
    0.11682441f, 0.08753806f, 0.11029980f, 0.00750490f, -0.30605105f, -0.12460683f, -0.24310786f, -0.27632153f, 
    0.15876099f, 0.14990292f, 0.13595900f, -0.06710088f, 0.04653761f, -0.11720714f, -0.04476317f, 0.04313061f, 
    -0.17366606f, -0.22066288f, -0.05873578f, -0.02028848f, -0.00692397f, 0.00005533f, -0.04744692f, 0.11124272f, 
    -0.05274443f, -0.22276980f, 0.04281172f, 0.09781349f, 0.12123995f, 0.19555019f, 0.16252786f, 0.15578091f, 
    0.04978484f, -0.01884247f, -0.21815857f, 0.14114535f, 0.02760648f, 0.06888054f, -0.05600790f, 0.06899612f, 
    0.19694246f, -0.10891482f, -0.05828270f, 0.11202478f, 0.08753734f, 0.10896613f, 0.02097442f, 0.22736311f, 
    -0.02012071f, -0.07474779f, -0.06243820f, -0.09901349f, -0.32788923f, 0.17605400f, -0.04190193f, 0.09161622f, 
    -0.04005401f, -0.02234729f, 0.07249908f, -0.05638634f, 0.09814000f, -0.08313271f, -0.06333849f, 0.06060991f, 
    0.19488344f, 0.17065707f, 0.00050792f, 0.01803688f, 0.13740297f, 0.04730963f, -0.09663048f, 0.07469390f, 
    0.10299195f, 0.05087635f, 0.00714668f, -0.00457053f, 0.20453829f, 0.36726740f, 0.19828416f, -0.11809026f, 
    0.14014849f, 0.07506310f, 0.10958634f, -0.05776824f, -0.10728755f, 0.03501166f, -0.11641026f, -0.09091578f, 
    -0.32450774f, 0.14188038f, -0.06152881f, 0.23848954f, 0.02545729f, 0.19644009f, -0.03654974f, 0.08687325f, 
    -0.00679349f, -0.00780871f, 0.20719992f, -0.04560669f, 0.27006459f, 0.14021902f, 0.09610005f, 0.38376293f, 
    -0.01402274f, -0.21825188f, 0.04500641f, -0.11540294f, 0.03021262f, 0.05816957f, -0.07539111f, -0.02445988f, 
    -0.19775853f, -0.07295582f, 0.09934478f, 0.03556333f, 0.01402748f, -0.01298871f, 0.07243796f, 0.03395795f, 
    0.09416654f, -0.09322912f, -0.06826700f, -0.18016712f, -0.06698240f, -0.25850862f, 0.06919216f, 0.05847927f, 
    0.17255391f, -0.06519931f, -0.39556006f, 0.22686189f, 0.06988433f, 0.00213506f, 0.09051441f, 0.06009242f, 
    -0.09211228f, 0.01092531f, -0.12402195f, -0.14777164f, 0.05536512f, -0.07476973f, 0.02772704f, -0.02483474f, 
    0.15072268f, -0.10796316f, 0.09305593f, 0.16740657f, 0.02825472f, -0.06390534f, -0.01526857f, 0.07371687f, 
    -0.05488659f, 0.13578478f, -0.01891824f, -0.20198342f, -0.09426586f, 0.02901473f, -0.03761467f, -0.11657307f, 
    -0.05982728f, -0.07033874f, -0.01684542f, 0.05426473f, 0.06612018f, -0.06245263f, -0.06442811f, -0.03530949f, 
    -0.04931497f, -0.07753903f, -0.04944502f, -0.02193665f, 0.03333208f, -0.00054011f, -0.01674615f, 0.03891962f, 
    -0.05270620f, -0.06599268f, 0.01807100f, 0.02844394f, 0.00620011f, 0.00962829f, -0.00844744f, -0.02617681f, 
    0.00780020f, -0.06565861f, 0.05603121f, 0.00618918f, -0.01829556f, 0.05290312f, -0.01866908f, -0.05924245f, 
    -0.07251744f, 0.01813116f, -0.07674972f, -0.02270960f, 0.01088616f, 0.01350955f, 0.04103376f, -0.08304035f, 
    -0.00402832f, 0.06082682f, 0.05643973f, -0.03031649f, 0.03348044f, 0.05885386f, -0.03931060f, -0.02885975f, 
    -0.01916761f, 0.05514444f, -0.03911464f, 0.00230129f, 0.03867271f, 0.04188790f, 0.04132586f, -0.05169430f, 
    -0.02959339f, -0.01072204f, -0.01941827f, -0.03682493f, -0.01617333f, -0.01387479f, 0.01119623f, 0.01252216f, 
    0.07036928f, 0.02575871f, -0.02884301f, -0.05428233f, -0.07521538f, -0.02158126f, 0.04454356f, -0.02230392f, 
    0.04901787f, 0.02372686f, 0.04418524f, -0.07107688f, -0.05411503f, 0.04414560f, -0.00551031f, -0.01884003f, 
    -0.04816250f, -0.00868081f, 0.03209817f, -0.07392086f, 0.03460696f, -0.06369621f, -0.06722485f, -0.04097685f, 
    0.04538180f, -0.01112536f, 0.06084142f, -0.06091411f, -0.06170661f, 0.00661061f, 0.05683044f, 0.00970060f, 
    -0.07826532f, 0.02844619f, -0.02293370f, 0.05706507f, 0.03713898f, 0.04798522f, 0.03212109f, 0.00800918f, 
    -0.05422619f, 0.00722306f, -0.04259501f, 0.02628228f, 0.03221446f, -0.04733735f, -0.05628425f, -0.05747260f, 
    -0.03865211f, 0.02004481f, 0.04001941f, -0.01602992f, -0.05670552f, 0.00477170f, -0.04847506f, -0.03774483f, 
    -0.05972712f, 0.05492438f, 0.03407026f, -0.03841043f, -0.01672185f, -0.06550554f, -0.01539581f, -0.03637352f, 
    -0.06359936f, -0.00265586f, -0.00906258f, 0.02696111f, 0.01792229f, -0.07548645f, 0.00469377f, 0.03537125f, 
    -0.05486253f, -0.00307362f, 0.04303101f, 0.06248551f, -0.00331782f, 0.00036944f, -0.06530999f, -0.04937327f, 
    -0.02902767f, -0.02646033f, -0.04237001f, 0.01965337f, -0.05882884f, 0.00137425f, 0.05775670f, 0.02079476f, 
    -0.00214232f, -0.02159533f, 0.06859539f, -0.06992883f, 0.04661165f, -0.02728696f, -0.07215231f, 0.05007582f, 
    0.04267231f, 0.03420343f, -0.04917128f, -0.02320836f, 0.00855752f, -0.03235256f, 0.02438705f, -0.06995959f, 
    0.02560985f, 0.05721258f, -0.04879120f, -0.07300008f, -0.03820797f, 0.01450128f, 0.05020517f, 0.06364470f, 
    -0.07785048f, 0.00563786f, -0.03053963f, -0.05763077f, 0.04178628f, 0.04685955f, -0.07986642f, 0.05016777f, 
    -0.02962334f, -0.00420291f, 0.00547493f, 0.04074597f, -0.01750742f, -0.06367794f, 0.04320607f, 0.02764882f, 
    0.02736844f, 0.01856427f, 0.02491471f, 0.02832560f, -0.08063658f, 0.03590475f, -0.05234088f, 0.01593461f, 
    -0.00225537f, -0.03674112f, -0.03300258f, -0.00633826f, 0.02293029f, 0.06143718f, -0.06990183f, 0.04143456f, 
    0.02365443f, -0.01006596f, -0.05053306f, -0.04013120f, -0.04512627f, 0.03391923f, -0.01390155f, -0.06883138f, 
    -0.00251929f, -0.04256976f, 0.03414958f, -0.07470078f, -0.00860723f, 0.04040838f, -0.01829527f, -0.03049052f, 
    -0.04913159f, -0.02014320f, -0.06367487f, 0.04116108f, 0.05249793f, -0.04270302f, 0.01635243f, 0.02918317f, 
    -0.01355366f, -0.05443589f, 0.05391466f, -0.04975826f, -0.07953332f, 0.02950942f, -0.02263474f, 0.03323368f, 
    0.04327709f, 0.02643689f, 0.01308674f, -0.03306919f, 0.03565132f, 0.06270441f, -0.04348874f, -0.04604584f, 
    -0.01103503f, -0.01516059f, -0.02636014f, 0.03398488f, -0.07414994f, -0.01842946f, -0.06177907f, -0.05409798f, 
    -0.04593717f, -0.07980886f, -0.06353527f, 0.04843822f, 0.01674547f, -0.01363771f, 0.02151952f, -0.05791601f, 
    0.05752197f, 0.05861113f, -0.00535443f, 0.05081702f, 0.02070619f, 0.02326768f, 0.02379717f, 0.05589009f, 
    -0.05069426f, 0.01922658f, 0.02126619f, -0.06501863f, 0.03944594f, -0.05505980f, 0.06243962f, 0.04549475f, 
    -0.02926398f, -0.00915008f, -0.07926915f, -0.00680253f, -0.03524851f, -0.06789083f, -0.06318736f, -0.03669870f, 
    0.04821407f, 0.00233159f, -0.01835045f, 0.00709954f, -0.01850517f, 0.00374575f, 0.01776876f, -0.03346208f, 
    0.05644052f, 0.01956529f, -0.02663698f, 0.01533571f, -0.01578983f, -0.02361135f, -0.03788408f, 0.04918794f, 
    0.06379846f, -0.02607307f, -0.05530560f, -0.04264069f, -0.04295787f, -0.06229608f, -0.00431859f, -0.00202770f, 
    -0.01270748f, -0.04165927f, -0.03881369f, 0.05972218f, 0.01282409f, 0.04029297f, 0.03931664f, 0.03828193f, 
    -0.01009017f, -0.03202683f, -0.02086240f, -0.05492924f, 0.00289540f, -0.01079788f, -0.07058917f, -0.02855151f, 
    0.03331680f, -0.04683154f, -0.07624891f, -0.06143706f, -0.05439571f, 0.04721355f, -0.07355790f, -0.01362204f, 
    0.01444870f, -0.04178724f, 0.05293098f, 0.06007783f, -0.04936117f, -0.04905954f, 0.00185607f, 0.01621226f, 
    -0.07717105f, 0.04867405f, 0.03905205f, -0.00424680f, -0.06004849f, -0.04048397f, 0.02717084f, 0.02555907f, 
    -0.06332988f, -0.02995858f, 0.03916632f, -0.00448274f, -0.02047479f, 0.00887521f, 0.00065284f, 0.00740475f, 
    -0.01119788f, -0.07176084f, -0.00702756f, -0.01193776f, 0.03809769f, -0.05869904f, 0.01604374f, 0.02031950f, 
    -0.01198074f, -0.07159726f, -0.03632300f, 0.02914792f, -0.06416818f, -0.07476332f, -0.04215829f, 0.00227250f, 
    0.05263220f, 0.05336455f, -0.02307064f, 0.03776439f, -0.01272497f, -0.00809856f, -0.03012043f, 0.03464299f, 
    0.06664852f, -0.03996468f, -0.02376034f, -0.02620725f, -0.03958324f, 0.04374195f, -0.01047755f, 0.02130867f, 
    -0.07357439f, 0.03137110f, -0.02571632f, 0.04665949f, 0.00535198f, 0.05131929f, -0.01882916f, -0.01249388f, 
    -0.03886617f, 0.01363792f, -0.01587200f, -0.01473829f, 0.01869163f, -0.05735550f, 0.02232903f, -0.02690179f, 
    -0.03683905f, 0.01183316f, -0.07156628f, -0.08400788f, -0.04220174f, 0.03750016f, 0.05554489f, 0.01423216f, 
    0.00249541f, 0.00390460f, 0.05058048f, -0.06581286f, -0.04565468f, 0.04808722f, 0.05516390f, 0.01276413f, 
    -0.00926231f, -0.00788251f, 0.04039631f, -0.00945182f, 0.04489785f, -0.06713076f, -0.01072883f, -0.07500378f, 
    0.00349138f, 0.01897470f, 0.05337373f, 0.02786416f, 0.00518019f, -0.03580965f, -0.04657385f, 0.05874722f, 
    0.04029175f, -0.03248762f, 0.00318702f, -0.06663443f, -0.02189646f, -0.06744026f, -0.07892273f, 0.00298625f, 
    -0.05754567f, -0.05250298f, -0.00388326f, 0.02668024f, -0.03594659f, 0.00614379f, -0.08442300f, -0.02508907f, 
    0.02001544f, -0.01092268f, -0.04176755f, -0.03128624f, -0.01344694f, 0.03388459f, -0.06969981f, 0.02033377f, 
    0.05572066f, 0.05156649f, 0.01953848f, -0.05117682f, -0.02127273f, -0.04070489f, -0.05133023f, -0.00505874f, 
    0.05294588f, -0.05580855f, -0.07120045f, 0.01935774f, 0.03613868f, -0.06740266f, -0.05066350f, 0.03283997f, 
    -0.03922154f, 0.02110071f, -0.02007949f, 0.06187935f, -0.04492583f, 0.01814437f, 0.04225468f, -0.04473040f, 
    -0.05472943f, -0.05618582f, 0.00658241f, -0.05360029f, -0.07201368f, -0.01965578f, -0.04293241f, 0.01159828f, 
    -0.02003330f, 0.03135071f, -0.06236911f, -0.08728991f, 0.00250795f, -0.00972307f, -0.06027460f, -0.00620758f, 
    -0.02914683f, 0.03408358f, 0.05397223f, 0.02442755f, -0.05915802f, 0.04580399f, -0.04017961f, 0.02890980f, 
    0.02075644f, 0.04880857f, -0.07381928f, 0.05052807f, 0.03587328f, 0.04135425f, -0.07706634f, -0.05459134f, 
    -0.00333004f, -0.03564569f, -0.07439502f, -0.07285939f, 0.02896851f, -0.03791445f, -0.05009424f, 0.04424881f, 
    0.04008889f, 0.03936402f, -0.03708357f, -0.03113995f, -0.04690738f, 0.06770954f, -0.02961028f, -0.00033147f, 
    0.02669789f, -0.05973367f, -0.07356799f, -0.00899499f, 0.03004241f, -0.06455529f, 0.06331718f, -0.05901702f, 
    -0.03565798f, 0.04069043f, -0.00862465f, 0.02180871f, -0.08024288f, 0.02755783f, 0.04713985f, 0.05382740f, 
    0.03520334f, 0.06401265f, 0.01997900f, 0.03145830f, 0.05980847f, -0.01832760f, 0.02824260f, 0.06398348f, 
    -0.06047636f, -0.04998633f, 0.02695283f, -0.00239792f, -0.03096397f, 0.06170312f, -0.00912791f, -0.04312518f, 
    0.04843523f, 0.04315476f, 0.00810536f, -0.08070136f, 0.04358821f, -0.00650156f, -0.07054365f, -0.07197835f, 
    -0.05561448f, 0.04007946f, 0.03298978f, -0.06205171f, 0.06563096f, -0.04163097f, 0.01207663f, -0.05207671f, 
    -0.01770835f, 0.06018217f, -0.05308360f, -0.03938932f, -0.04691431f, 0.02474486f, -0.00525782f, 0.05441458f, 
    -0.00290247f, 0.02261835f, 0.00009981f, -0.06869428f, -0.06961305f, 0.05632225f, 0.00928448f, -0.05618095f, 
    -0.01995998f, -0.03147751f, 0.03171648f, 0.04701813f, -0.07761733f, -0.04003084f, -0.07860427f, 0.01909539f, 
    -0.03407808f, -0.05814496f, -0.04811314f, 0.04829657f, -0.07817478f, 0.05694441f, -0.04232947f, -0.06752990f, 
    0.03962567f, 0.04493760f, 0.00327790f, 0.03896122f, 0.02915964f, 0.01182195f, -0.00846853f, -0.06703835f, 
    -0.04472876f, -0.06423704f, 0.05666856f, 0.04011369f, -0.05444296f, 0.06331269f, -0.00217019f, 0.00265985f, 
    -0.03780498f, -0.04279854f, 0.05587349f, -0.00235087f, -0.03206468f, -0.04370084f, 0.00076642f, -0.05492903f, 
    0.06050903f, -0.01059643f, 0.03321713f, 0.02085171f, -0.01001055f, -0.05778923f, -0.04896866f, -0.06037115f, 
    -0.06134323f, -0.04138907f, -0.01236093f, 0.06247575f, -0.02383951f, 0.05410662f, -0.00344250f, -0.03480276f, 
    -0.07528203f, 0.01543281f, 0.04786782f, 0.04493627f, -0.01966006f, 0.02687458f, -0.04366352f, -0.04177036f, 
    0.03397249f, -0.01549163f, -0.07888445f, -0.00214571f, -0.03222108f, 0.05073099f, 0.02792322f, -0.02602354f, 
    0.04620350f, 0.02868591f, 0.05997889f, -0.03891076f, 0.03930731f, 0.00983453f, -0.07543695f, -0.00657217f, 
    0.01724648f, -0.01584368f, 0.02740250f, -0.00397513f, -0.00006464f, -0.02292559f, 0.02865262f, 0.01288796f, 
    -0.06321613f, 0.02929331f, 0.00746008f, 0.00074910f, -0.04962558f, -0.03410990f, 0.04126217f, 0.06789469f, 
    0.02437558f, 0.02237045f, -0.04663153f, -0.07370009f, -0.03388713f, -0.05444000f, -0.05533467f, 0.05168740f, 
    0.04859683f, -0.06873506f, 0.00865059f, -0.06937332f, -0.06493770f, 0.04827148f, -0.00187362f, -0.03880657f, 
    -0.06923808f, -0.05257645f, -0.06363106f, -0.01542094f, -0.03996741f, -0.06713767f, -0.05050061f, -0.06218754f, 
    0.06120955f, -0.05699246f, -0.05014077f, 0.02189357f, -0.05522233f, 0.02815748f, -0.03651337f, -0.00760743f, 
    -0.00021247f, -0.00743020f, -0.07539177f, 0.02667621f, 0.00226429f, 0.01753093f, -0.03140406f, 0.02692251f, 
    -0.06036904f, -0.00893791f, -0.07251090f, 0.00635779f, 0.01643750f, 0.05286513f, -0.04583339f, -0.03422032f, 
    0.02142186f, -0.00599632f, -0.03081826f, -0.01673842f, -0.05312992f, -0.06595819f, -0.06372513f, -0.05340817f, 
    -0.04800054f, -0.07170317f, 0.00416661f, 0.04196663f, -0.03026938f, -0.04693793f, -0.03140901f, 0.05109228f, 
    -0.04699876f, 0.01499647f, -0.04396025f, -0.01354221f, -0.03329068f, -0.05616550f, 0.00669741f, -0.02466638f, 
    0.19494642f, 0.13504227f, 0.04049512f, -0.12477285f, 0.05260996f, -0.02013113f, 0.01311036f, -0.01360500f, 
    -0.05297077f, -0.03997057f, -0.17446122f, -0.03088998f, 0.12157524f, 0.01123833f, 0.01085251f, -0.05159737f, 
    -0.02733364f, -0.03404984f, 0.01769174f, 0.02658264f, 0.06412722f, -0.12108007f, -0.04468795f, -0.00805037f, 
    -0.14210814f, -0.01277865f, 0.01997021f, -0.05203706f, -0.01059539f, 0.07701814f, 0.02784372f, -0.09400922f, 
    -0.05019713f, -0.05851000f, -0.09442179f, 0.08998465f, -0.13476580f, -0.02622109f, 0.27564487f, 0.24405332f, 
    -0.22453360f, -0.20702161f, -0.07475633f, 0.13872987f, 0.02173187f, -0.05020471f, 0.05425644f, 0.00420064f, 
    -0.08728930f, 0.08529571f, 0.09092129f, 0.16018973f, 0.08471113f, 0.07241865f, 0.00942664f, -0.03842672f, 
    0.07001872f, -0.03400977f, 0.08872247f, 0.01013284f, -0.01836319f, -0.09683768f, -0.14869970f, 0.01225567f, 
    -0.11292724f, 0.28279129f, 0.17690635f, 0.15028004f, 0.06129979f, -0.08281823f, -0.03123018f, -0.12010498f, 
    -0.07314157f, 0.22342633f, 0.21023588f, 0.00361791f, 0.08671114f, 0.10934986f, 0.03334556f, -0.04611495f, 
    0.22447027f, 0.06948774f, 0.03521760f, 0.03541077f, 0.21349578f, -0.17905220f, 0.12353205f, 0.08372353f, 
    0.06859731f, 0.11552379f, -0.00433022f, 0.07124893f, 0.10930605f, -0.06159076f, 0.08378900f, 0.02265579f, 
    -0.04770492f, -0.21991959f, -0.11380278f, 0.18693568f, -0.01746008f, -0.05465433f, 0.08180357f, 0.10217328f, 
    -0.05332033f, 0.06606049f, -0.03158344f, -0.02735036f, -0.19479194f, -0.32096386f, 0.22537343f, 0.16771960f, 
    0.01230012f, -0.13158026f, -0.08082303f, -0.04712367f, -0.02989091f, 0.04943880f, 0.29555866f, -0.00685990f, 
    0.23995019f, -0.08772366f, 0.29043895f, -0.17919759f, 0.11955032f, -0.02418863f, 0.03555650f, 0.13348563f, 
    0.04074286f, 0.08891232f, 0.09585024f, -0.12385904f, 0.06108078f, -0.23212573f, 0.26290044f, -0.23330997f, 
    0.15233399f, 0.15937719f, 0.03209061f, 0.16012266f, 0.09150535f, -0.03494724f, 0.05099027f, -0.05299492f, 
    0.38078821f, 0.07395127f, -0.04253805f, -0.03540115f, 0.09279332f, -0.05750531f, -0.01491342f, 0.04410199f, 
    -0.01744703f, -0.03100311f, -0.18499531f, 0.05847263f, -0.07094309f, 0.23378639f, -0.04096431f, -0.20060809f, 
    -0.07800511f, 0.02054733f, 0.09916084f, 0.04479462f, 0.05303118f, 0.00542030f, 0.01196889f, 0.04150557f, 
    0.22470155f, -0.18662472f, 0.06989857f, 0.12758018f, -0.06319842f, -0.04511461f, 0.01578070f, 0.04750007f, 
    0.11083786f, 0.03147687f, 0.00267742f, -0.03057274f, -0.14694265f, -0.00152113f, -0.07088099f, -0.00899871f, 
    0.23638804f, -0.10357238f, -0.07374106f, 0.17078349f, 0.18019699f, -0.12694742f, -0.01016116f, 0.10296169f, 
    0.04935674f, 0.07033065f, 0.06829350f, -0.11587041f, 0.07068619f, -0.04274631f, 0.18072452f, 0.04978247f, 
    -0.12633988f, -0.03656525f, 0.03266563f, 0.13452716f, -0.06977336f, 0.01050876f, 0.13321191f, 0.03528858f, 
    0.02127570f, 0.10403325f, -0.02035884f, 0.10217953f, -0.11583024f, -0.01692099f, 0.09293392f, 0.03254672f, 
    0.26062790f, 0.18528898f, -0.00175729f, 0.16793914f, 0.09484112f, 0.08492908f, -0.04558643f, 0.06663336f, 
    -0.00960313f, -0.07446907f, 0.02790929f, -0.05565016f, 0.10383029f, -0.09560843f, -0.30789044f, 0.11557202f, 
    0.05752669f, 0.04753397f, 0.12357367f, 0.12443628f, 0.17168248f, -0.19208050f, -0.00938111f, 0.02648749f, 
    0.19802627f, -0.20701793f, 0.35092643f, 0.09685429f, -0.02078325f, 0.11446877f, -0.02044574f, -0.00380290f, 
    0.00474477f, 0.12379245f, 0.18261985f, 0.07088732f, -0.04521841f, -0.09717863f, 0.36624146f, 0.02840092f, 
    0.15108903f, -0.06875163f, -0.23334984f, 0.04283267f, 0.02978467f, -0.13367526f, 0.04180263f, -0.03091363f, 
    0.05730906f, -0.30645558f, -0.11187670f, 0.12656631f, -0.11433142f, 0.02063347f, 0.12148757f, -0.10559535f, 
    -0.05019035f, 0.07593793f, 0.02037386f, 0.03465920f, 0.01111654f, 0.18489197f, 0.04794658f, -0.00584582f, 
    -0.10170263f, -0.01738381f, -0.04479767f, -0.07674064f, -0.02846765f, 0.03439575f, -0.06610862f, 0.03577137f, 
    0.10139955f, 0.21028692f, 0.04304735f, -0.04277198f, 0.17741543f, -0.00171881f, 0.12047845f, -0.12236495f, 
    0.01786443f, 0.07847095f, 0.03775743f, -0.15299310f, 0.24510986f, -0.02506264f, -0.00725143f, -0.15349758f, 
    -0.10073060f, -0.15001106f, 0.07818005f, 0.06625655f, 0.09873591f, 0.06012786f, -0.14491367f, 0.12743467f, 
    0.17618938f, 0.00705464f, -0.23706679f, 0.26254246f, -0.23708339f, -0.09474642f, 0.20512134f, -0.09086105f, 
    0.03505721f, 0.04493508f, -0.14333700f, 0.22801507f, 0.00521791f, 0.41106051f, 0.36447355f, 0.02626257f, 
    0.01520331f, -0.21587938f, -0.30635479f, 0.25410569f, -0.06807750f, 0.00558913f, 0.02900476f, -0.02298569f, 
    -0.18807168f, 0.03545379f, 0.09579641f, -0.00649653f, -0.06826600f, -0.02100202f, -0.05786180f, -0.07051174f, 
    0.17462696f, 0.06963427f, 0.16461538f, 0.03260766f, 0.14471582f, 0.00502536f, -0.01463388f, 0.08873528f, 
    -0.06381312f, 0.23625720f, 0.22074242f, -0.17154992f, 0.04253375f, 0.05236055f, 0.01177953f, -0.00267730f, 
    0.06362837f, -0.33929220f, -0.14475870f, -0.14709924f, -0.00038795f, -0.02237053f, 0.03790536f, -0.11122148f, 
    -0.09317971f, -0.02550937f, 0.02191986f, -0.06029931f, -0.23931278f, -0.26372069f, -0.18895259f, 0.17738183f, 
    0.00315220f, 0.02717176f, 0.07034474f, 0.19089885f, -0.01878100f, 0.08643225f, -0.09910139f, -0.09184143f, 
    -0.24027598f, 0.12291249f, -0.14495219f, 0.04755197f, 0.02791692f, 0.13237651f, -0.21396215f, 0.26219270f, 
    -0.03051555f, 0.05118861f, -0.05519011f, 0.00876749f, -0.30577612f, -0.21610972f, 0.01883155f, -0.17008738f, 
    -0.18428320f, -0.21826637f, -0.11078812f, -0.12675568f, -0.04560962f, -0.01910483f, 0.01341623f, 0.09428231f, 
    -0.19915698f, -0.04853259f, -0.11859559f, -0.09358492f, 0.22774604f, 0.01879377f, 0.00674731f, 0.24387567f, 
    0.00328871f, 0.10259864f, 0.09784602f, -0.18490259f, -0.01265551f, -0.17793809f, -0.13241468f, -0.15246056f, 
    0.00104832f, 0.11963803f, -0.09851228f, 0.06780394f, 0.12914491f, 0.01565156f, 0.13382232f, 0.02182176f, 
    0.06343932f, -0.21111602f, 0.14028335f, 0.06786233f, -0.00585594f, -0.00161797f, 0.09176506f, 0.04006981f, 
    0.03022846f, 0.05298893f, 0.24950105f, -0.01042259f, -0.31102297f, 0.25767177f, 0.12553382f, 0.36997622f, 
    0.32068217f, -0.04834469f, 0.01709430f, 0.22676466f, -0.06990761f, 0.07129195f, 0.01267174f, -0.02560431f, 
    -0.31857717f, -0.28992870f, -0.08502313f, 0.07703323f, 0.01464960f, 0.13551429f, 0.10303817f, 0.16600427f, 
    -0.22506520f, 0.05024450f, -0.01835255f, -0.02062915f, -0.13792853f, 0.16232909f, 0.04332291f, -0.16283648f, 
    0.08325604f, 0.08043493f, 0.11129065f, -0.20373946f, -0.09741376f, -0.05596790f, -0.01162264f, 0.08177975f, 
    0.15156388f, -0.14177071f, -0.04067744f, -0.10424560f, 0.10522089f, 0.12532863f, -0.07697631f, 0.16860944f, 
    0.05489514f, -0.01706206f, 0.00544393f, 0.01481401f, -0.03851696f, 0.04752856f, -0.13713969f, -0.21026815f, 
    0.16304041f, 0.04065682f, -0.01140344f, -0.02281089f, -0.01499023f, -0.00389731f, 0.00901294f, -0.05580084f, 
    -0.26390296f, -0.01808209f, -0.05615601f, 0.03711042f, 0.16590525f, 0.01302511f, 0.10281376f, -0.02032662f, 
    0.04177538f, 0.06680085f, -0.03223453f, 0.05534118f, -0.17538853f, 0.18430206f, 0.21043304f, 0.12554099f, 
    0.12504452f, 0.02362919f, -0.17896014f, 0.12745969f, -0.04650282f, -0.02295044f, 0.06107125f, -0.02602649f, 
    -0.23374382f, 0.02927121f, 0.03741127f, -0.01193313f, -0.05909347f, 0.04741602f, -0.00341974f, -0.01629500f, 
    -0.02183365f, -0.05227980f, 0.01557030f, -0.06773371f, -0.32081470f, 0.14674750f, -0.05613533f, -0.09797112f, 
    0.34475353f, 0.04170420f, -0.05792280f, -0.02494279f, -0.09519647f, 0.26656416f, 0.10837807f, 0.07594939f, 
    0.19925362f, 0.08190732f, -0.11941434f, 0.04888579f, -0.14740564f, -0.10991938f, -0.11705697f, -0.13432755f, 
    0.31135404f, 0.11799891f, 0.12946095f, 0.11638644f, -0.03296701f, 0.03163559f, -0.32693020f, 0.08279485f, 
    0.00567915f, -0.00827842f, 0.08614075f, 0.26949367f, 0.12774646f, 0.28394383f, -0.12214497f, 0.04756128f, 
    -0.07568275f, -0.05291725f, 0.00929056f, 0.02208988f, 0.00168089f, -0.06576622f, -0.04490585f, 0.04033992f, 
    -0.04169201f, 0.03200229f, 0.06149187f, 0.05265274f, -0.05117883f, -0.02604713f, 0.02152026f, 0.02869719f, 
    -0.02418884f, 0.06012263f, -0.02842814f, 0.03743408f, -0.07516351f, -0.04381662f, -0.02522046f, -0.04955857f, 
    -0.05785965f, -0.03149483f, -0.07664949f, -0.05047566f, -0.01226449f, -0.05273735f, 0.06012451f, 0.03676053f, 
    0.02291429f, -0.02863981f, 0.06416066f, -0.05428699f, 0.01618838f, -0.02839076f, 0.02303621f, -0.05653610f, 
    -0.07658336f, -0.02588030f, 0.05661045f, -0.04969750f, -0.04621238f, -0.07644308f, 0.04520771f, 0.01342296f, 
    -0.06823917f, 0.05700991f, 0.02587279f, -0.06902543f, 0.04460834f, -0.01988191f, 0.03053287f, 0.04074963f, 
    0.05028453f, -0.02116306f, 0.01198982f, -0.07196400f, -0.07730188f, 0.02288119f, -0.03924448f, 0.04514457f, 
    -0.04078560f, 0.04936635f, -0.00549521f, 0.04360873f, -0.03206372f, -0.05630943f, -0.03149995f, -0.05336279f, 
    -0.03467015f, -0.03538368f, 0.00671493f, 0.02526622f, -0.06629547f, -0.02933578f, 0.01545919f, -0.03839039f, 
    0.05225811f, -0.05318278f, -0.03042310f, -0.06821921f, -0.01692403f, 0.02018356f, -0.03685066f, -0.02632638f, 
    -0.01524282f, 0.02151712f, -0.05841439f, 0.03472112f, -0.02568442f, 0.05145949f, -0.02634988f, 0.02933688f, 
    -0.06951150f, 0.06118971f, 0.06090774f, 0.05105094f, -0.01771105f, 0.02253496f, 0.05249985f, 0.01772614f, 
    0.05169172f, -0.02996166f, -0.04253744f, 0.00579216f, -0.03283367f, -0.05297871f, -0.06522598f, -0.06058517f, 
    -0.06767193f, -0.03926928f, -0.06254556f, -0.05874173f, -0.06707284f, 0.03338182f, -0.01091557f, -0.04877640f, 
    0.02407696f, -0.02495807f, 0.06680673f, 0.04013638f, 0.03511277f, -0.00809875f, 0.01891284f, -0.04969683f, 
    0.06522002f, -0.00503274f, -0.05746085f, 0.01413871f, -0.02083241f, 0.06049316f, 0.00392340f, -0.02408988f, 
    0.00608862f, 0.00762392f, 0.01137170f, -0.01869850f, -0.05741556f, -0.00794914f, 0.02084995f, 0.03547312f, 
    0.02848623f, 0.03641962f, -0.03835959f, 0.02076847f, -0.05277537f, -0.00531591f, -0.06069949f, 0.00101161f, 
    -0.05750051f, 0.02868753f, 0.00081103f, -0.07155134f, -0.04815320f, -0.06749336f, 0.01761942f, -0.05108463f, 
    -0.05086374f, -0.04426404f, 0.01533487f, 0.03259790f, 0.03411249f, -0.00572006f, -0.01681423f, -0.03130681f, 
    -0.07253649f, -0.01706582f, 0.00612240f, 0.05201587f, 0.05047974f, -0.05689253f, 0.03919598f, -0.04528859f, 
    0.03797061f, -0.07307460f, -0.00433043f, -0.05451361f, -0.00741808f, -0.06395351f, -0.03755096f, 0.05699505f, 
    0.01717697f, -0.00762733f, 0.06613352f, -0.02856222f, -0.07310460f, -0.03843534f, -0.03142744f, -0.03670171f, 
    -0.04158230f, 0.01270327f, 0.02367390f, 0.12808903f, -0.03641278f, -0.07221654f, 0.09083040f, -0.12175217f, 
    0.01013288f, -0.12877227f, -0.04671945f, 0.14271095f, -0.04461529f, -0.00767304f, 0.03492724f, -0.03431250f, 
    0.01680851f, -0.01179127f, -0.09389924f, -0.09665177f, -0.08861084f, -0.04200358f, -0.08431716f, 0.16903709f, 
    0.20434485f, 0.15307648f, -0.00084942f, -0.01930080f, 0.02781016f, 0.21370216f, 0.02861134f, -0.03580760f, 
    0.08942336f, 0.02352484f, 0.09149010f, 0.07922615f, 0.15531661f, 0.15159407f, -0.00140929f, 0.02117923f, 
    -0.22393744f, 0.15936047f, 0.17986596f, 0.01692408f, 0.22318964f, -0.00132444f, -0.05403937f, 0.10312930f, 
    0.04393263f, -0.07091182f, 0.29894084f, 0.01608522f, -0.01981953f, -0.06224404f, 0.02710233f, -0.02240231f, 
    0.16187805f, -0.12276493f, 0.09518786f, 0.12734592f, -0.23300576f, 0.04079492f, -0.10171498f, -0.06336684f, 
    0.18455400f, -0.14981171f, -0.17207882f, -0.09719058f, -0.05340537f, -0.08178050f, 0.03918709f, 0.04393059f, 
    0.18888502f, 0.10727911f, -0.10288441f, -0.16000295f, 0.00155247f, 0.06755934f, -0.04143552f, -0.02833251f, 
    -0.00641048f, 0.00138120f, 0.06936993f, -0.04742262f, 0.08065701f, 0.04254864f, 0.04237393f, 0.09672991f, 
    0.08104094f, -0.04770787f, -0.07009220f, 0.02955901f, -0.07054377f, -0.03742763f, -0.03049341f, 0.03862103f, 
    -0.03483537f, 0.12509397f, 0.12924708f, -0.11130953f, 0.08515541f, 0.00573093f, 0.11069879f, 0.05011363f, 
    -0.03238192f, 0.09220029f, 0.07848364f, 0.08018689f, 0.22730547f, 0.11936607f, 0.01637933f, -0.13593365f, 
    0.03884348f, -0.05084968f, 0.12775388f, 0.16928779f, 0.23671575f, 0.04067875f, -0.13851526f, 0.04530505f, 
    0.19398668f, -0.26744193f, 0.01013455f, -0.08225072f, -0.08141372f, 0.05817109f, 0.12520987f, -0.03625684f, 
    0.07578009f, -0.01083228f, 0.04422901f, 0.00604142f, -0.00461794f, 0.30340427f, -0.24286284f, -0.02533442f, 
    0.03079398f, -0.10146452f, -0.28951630f, -0.03649245f, -0.02009320f, 0.03152392f, 0.06713253f, -0.00548633f, 
    -0.15676233f, -0.02779185f, -0.04181899f, 0.01114251f, 0.06122381f, -0.04453347f, -0.02787919f, -0.00846830f, 
    -0.03605107f, -0.01931106f, 0.03899766f, -0.06102226f, 0.10540867f, 0.04474855f, -0.13014792f, 0.01759138f, 
    -0.04726715f, 0.08808937f, 0.13436544f, -0.15689366f, -0.01014428f, 0.07594243f, 0.04486303f, -0.00272678f, 
    -0.03685275f, -0.29670197f, 0.13239826f, 0.15786710f, -0.00076086f, -0.05226555f, -0.03262008f, 0.04575260f, 
    0.06306916f, 0.00896611f, 0.02629894f, -0.11145723f, -0.15629549f, -0.20428926f, -0.10055295f, -0.16686840f, 
    -0.04594924f, 0.03405260f, -0.14138170f, 0.13501947f, 0.02079726f, 0.01542034f, -0.03414981f, -0.14691569f, 
    0.26047170f, 0.10145013f, 0.12316637f, -0.00418389f, -0.04046492f, 0.00763032f, 0.12413232f, -0.13038719f, 
    0.08655361f, 0.12219973f, 0.05864501f, 0.08314954f, 0.24759950f, 0.10207451f, 0.08148326f, 0.03604788f, 
    0.06885945f, -0.01147084f, -0.01180892f, 0.03137134f, 0.12924744f, 0.02670554f, -0.00860114f, -0.08460488f, 
    0.00966530f, -0.05864880f, 0.19418228f, 0.09902207f, -0.00029173f, 0.00017265f, -0.01357912f, 0.11523926f, 
    -0.07080016f, -0.07977474f, -0.24294737f, -0.04879746f, 0.42703617f, -0.09673741f, -0.55001271f, -0.60080343f, 
    -0.16324137f, -0.21664402f, -0.07616509f, 0.23256198f, -0.15553251f, -0.08401915f, -0.00554292f, 0.00351977f, 
    0.19507448f, 0.26086318f, 0.11005168f, 0.02331010f, 0.01598964f, 0.02180302f, -0.03763544f, 0.08365142f, 
    0.13330428f, 0.27293757f, 0.13628152f, 0.13262041f, 0.38307822f, 0.10504781f, -0.00724370f, 0.02140770f, 
    -0.18959062f, -0.06182831f, -0.03185457f, -0.15682861f, -0.02930105f, -0.07663365f, -0.07703903f, -0.06798708f, 
    -0.24635549f, -0.42886728f, -0.17963694f, -0.21344802f, 0.18210588f, 0.13321134f, 0.11629317f, 0.02015131f, 
    0.01361957f, -0.13592830f, 0.01752458f, -0.05174127f, 0.15578371f, 0.19668587f, -0.00417207f, 0.19226389f, 
    -0.03878529f, 0.01645704f, -0.03997974f, 0.09081047f, -0.10237389f, -0.05173401f, 0.10306947f, -0.08680850f, 
    -0.11674514f, -0.05651044f, 0.01685725f, -0.14585648f, 0.06524764f, 0.11532065f, 0.00577405f, -0.08436303f, 
    0.02357588f, -0.12801407f, -0.04265578f, -0.02554016f, -0.25471917f, -0.06155000f, 0.10516337f, 0.11563279f, 
    -0.00875399f, 0.22567981f, 0.09480876f, 0.29466131f, -0.07253542f, -0.20629686f, -0.08699409f, 0.03051702f, 
    0.34614596f, 0.09765305f, -0.07852972f, -0.00828595f, -0.03495100f, -0.08030148f, 0.12769532f, -0.08253111f, 
    -0.04220686f, 0.21376550f, 0.00879762f, 0.09797104f, 0.25602633f, -0.08240993f, 0.13729630f, 0.15729427f, 
    -0.19333667f, -0.01646498f, 0.10675572f, -0.15046106f, 0.04820307f, -0.04879605f, 0.07899702f, 0.05430938f, 
    0.19134589f, 0.10426751f, 0.12783214f, 0.28469607f, -0.09719232f, 0.01738597f, 0.16005573f, -0.06041351f, 
    0.42637846f, 0.14103694f, 0.10149115f, 0.05919537f, 0.33404896f, -0.07371244f, -0.02400587f, 0.28029922f, 
    -0.07937385f, -0.15101308f, 0.02017200f, -0.04965365f, 0.19771616f, 0.00295843f, -0.02742856f, -0.03561328f, 
    -0.07053167f, 0.25858432f, -0.02333514f, -0.30225146f, -0.04476699f, 0.04564213f, -0.02966055f, 0.06028355f, 
    -0.23578373f, -0.11364201f, -0.00133699f, 0.07416967f, 0.11840860f, -0.16157968f, -0.10043071f, -0.06628119f, 
    -0.06757564f, -0.02479554f, 0.00900269f, 0.04484823f, 0.10813030f, 0.16576569f, -0.07350279f, -0.05308514f, 
    0.12210442f, 0.03335313f, 0.19569558f, 0.11007851f, -0.15042999f, 0.04865956f, -0.05133609f, 0.01671529f, 
    0.10527056f, -0.08325493f, 0.00457355f, -0.04881665f, 0.08262201f, 0.08957127f, -0.00166687f, -0.13970651f, 
    0.00013028f, 0.00663222f, 0.14804044f, -0.03077049f, 0.15153649f, 0.08537193f, 0.03710487f, 0.08007503f, 
    -0.11520146f, -0.13070637f, 0.09710504f, 0.11474019f, -0.14956318f, 0.09668594f, 0.07449721f, 0.22329374f, 
    0.01417048f, -0.02696040f, 0.00370427f, -0.18194075f, 0.42422232f, 0.07622815f, -0.06884088f, 0.16372189f, 
    0.00399937f, -0.00866244f, -0.11626066f, 0.07675777f, -0.12296649f, 0.06539554f, -0.00217024f, -0.05464722f, 
    -0.03280421f, 0.25466540f, -0.26352555f, -0.05498471f, -0.01855657f, -0.00302526f, 0.04511470f, -0.06766135f, 
    -0.08073398f, 0.09311021f, -0.06719359f, -0.12855953f, -0.31252572f, 0.13383532f, -0.05699475f, 0.09757991f, 
    -0.08237690f, 0.15584102f, -0.09563132f, 0.13412346f, 0.11841806f, 0.10204130f, 0.00790690f, -0.04291884f, 
    -0.17705660f, -0.09150096f, 0.26625541f, 0.29766390f, -0.01788097f, -0.02398304f, 0.10271479f, -0.00197657f, 
    -0.07943261f, -0.00340290f, 0.06449670f, 0.05847977f, -0.04952689f, -0.14835611f, 0.00654898f, -0.14931116f, 
    -0.05464330f, 0.00606920f, 0.01437715f, 0.04441873f, 0.12735973f, 0.13479850f, 0.03181567f, -0.05124203f, 
    0.16288392f, -0.12018920f, -0.08210061f, 0.16325612f, -0.21030495f, 0.02446923f, -0.01732120f, -0.04186519f, 
    0.02708112f, 0.00772416f, 0.10671399f, -0.04212819f, -0.12714075f, -0.02497879f, -0.06669575f, 0.09118972f, 
    -0.03126242f, -0.00664401f, -0.15980120f, 0.09222320f, -0.02191255f, -0.07683026f, 0.02362246f, 0.11761384f, 
    -0.05520251f, 0.23349346f, 0.23905322f, -0.04003441f, -0.11009931f, -0.01507362f, -0.19611104f, 0.03003153f, 
    -0.02604508f, 0.05042383f, 0.08819783f, 0.10413185f, 0.05101428f, -0.29768255f, 0.12872769f, 0.03564957f, 
    0.10548037f, 0.17168322f, 0.14099810f, -0.04333683f, 0.01911616f, -0.01138478f, 0.01325573f, 0.05496844f, 
    0.14551136f, 0.14104408f, -0.08588915f, -0.05202815f, -0.09597856f, -0.04620243f, 0.01457172f, -0.16125856f, 
    0.20094214f, 0.32414916f, -0.04779671f, 0.20566522f, -0.38063166f, 0.15042637f, -0.19334686f, 0.09871183f, 
    0.11329542f, 0.00279895f, 0.12164739f, -0.10535520f, -0.05927021f, 0.02139783f, -0.07627691f, -0.12750755f, 
    0.21404436f, 0.22685474f, 0.03105169f, -0.06871898f, 0.01854220f, -0.08491210f, -0.13002548f, -0.15058370f, 
    -0.18099189f, 0.00714982f, -0.16262046f, -0.01050476f, 0.33032322f, 0.32972115f, 0.06097790f, 0.08314351f, 
    0.01561970f, 0.06466892f, 0.17179593f, 0.20599677f, -0.07610420f, -0.01386473f, 0.31299686f, 0.09759095f, 
    -0.17222743f, -0.16895415f, -0.06532405f, -0.03969532f, 0.01233332f, -0.13716525f, 0.02192062f, 0.02613598f, 
    0.16945066f, 0.17447433f, -0.14541143f, -0.11201051f, -0.02389228f, -0.05036237f, -0.06363948f, 0.12242807f, 
    -0.02248851f, -0.00691531f, -0.01712368f, -0.11970903f, -0.00196638f, -0.01670672f, 0.09603821f, 0.11843406f, 
    -0.03089901f, 0.06000530f, -0.32005841f, -0.07665908f, -0.07767808f, 0.09878927f, 0.20905228f, 0.09118693f, 
    0.00792651f, 0.04878887f, 0.18175316f, -0.17442763f, 0.30461040f, 0.27293020f, 0.41521657f, 0.34954795f, 
    0.06468423f, 0.09824978f, 0.00169456f, 0.02229744f, -0.10387189f, 0.04960584f, 0.13729672f, 0.09932631f, 
    0.01284536f, 0.13561091f, 0.10472243f, 0.11502172f, -0.04375461f, -0.10428098f, 0.11862583f, -0.20282894f, 
    0.08254868f, 0.14605905f, -0.06489322f, -0.02170569f, -0.20750557f, -0.18898712f, 0.07201292f, -0.28504750f, 
    0.09967870f, -0.07319830f, -0.03373300f, 0.01869687f, 0.03844849f, -0.20491788f, -0.00252418f, -0.13039348f, 
    -0.05723514f, 0.31883052f, -0.02175977f, 0.11465035f, 0.05155222f, 0.05428031f, 0.05764678f, 0.01300149f, 
    0.01109260f, 0.12744772f, 0.05931283f, 0.08707750f, 0.04074984f, -0.21721089f, 0.09576417f, -0.01908405f, 
    0.10346694f, -0.14610779f, -0.12463449f, 0.21621388f, 0.01075552f, 0.05713050f, 0.09680820f, -0.07410241f, 
    -0.07924253f, 0.10188506f, -0.20843682f, -0.13303225f, 0.00603490f, 0.10437833f, 0.12217064f, 0.05640224f, 
    -0.08311332f, -0.13316916f, -0.06861541f, -0.17802157f, -0.08731883f, 0.14524227f, -0.38256475f, -0.07127279f, 
    0.00330878f, 0.16919991f, -0.09817205f, 0.03348158f, -0.02113754f, 0.08038488f, 0.06721151f, 0.06020807f, 
    -0.05531065f, -0.17734556f, 0.17912821f, 0.17125654f, -0.07818456f, -0.20102830f, -0.11731538f, -0.13431765f, 
    0.06245660f, 0.08520101f, -0.00629149f, 0.07580531f, -0.24823201f, -0.00993244f, -0.02014956f, -0.21815345f, 
    0.05188161f, 0.06525824f, 0.03360870f, 0.20522656f, 0.00810485f, 0.03910205f, -0.13915905f, 0.02031985f, 
    -0.14755471f, -0.10449374f, 0.11764875f, -0.04671061f, -0.10780900f, -0.03569795f, -0.17294382f, -0.10124947f, 
    0.09597240f, 0.00883189f, 0.13733999f, 0.17187943f, -0.26246271f, 0.11505580f, -0.19675273f, 0.14058474f, 
    0.00511519f, 0.01832710f, 0.14198589f, 0.02511413f, -0.06856832f, -0.01609851f, 0.08217553f, -0.20842680f, 
    0.10779605f, 0.29559231f, 0.25922400f, 0.33567628f, -0.04012195f, 0.08547971f, -0.02472402f, -0.11552686f, 
    -0.08433151f, 0.07228682f, 0.03181005f, 0.09210929f, 0.51033038f, 0.22532204f, 0.02197091f, -0.04740952f, 
    0.04237683f, 0.01517063f, -0.07573816f, 0.03796118f, -0.04261631f, -0.13507622f, -0.10435103f, 0.09960232f, 
    -0.04926693f, 0.03549669f, 0.00453024f, -0.00088893f, 0.03072664f, -0.00792658f, -0.02074619f, 0.05470692f, 
    -0.05380806f, 0.00382295f, 0.00561036f, -0.09620757f, 0.04879525f, 0.04783051f, -0.01120213f, -0.06916659f, 
    0.00008622f, -0.06254137f, 0.03131958f, 0.00230505f, -0.07220136f, -0.02965515f, -0.05833886f, -0.03441347f, 
    -0.05918994f, 0.03761278f, -0.05609215f, -0.06949998f, -0.06033768f, 0.02699926f, 0.00588988f, -0.01389108f, 
    -0.08311437f, -0.04335093f, 0.01592189f, 0.01098832f, -0.07649216f, 0.04737626f, -0.05391862f, -0.00293713f, 
    0.03321850f, 0.01538316f, -0.03972105f, 0.02902794f, -0.07658169f, -0.01679772f, -0.04177078f, -0.07448732f, 
    -0.05465105f, -0.02708820f, 0.02842362f, -0.04093021f, -0.07610140f, 0.03694911f, -0.02081326f, -0.06074170f, 
    -0.04039026f, -0.06120502f, 0.03794564f, -0.05113625f, -0.00332882f, 0.05507152f, -0.08630436f, 0.00747596f, 
    0.02127230f, -0.07226511f, -0.09907693f, 0.02830156f, -0.01783248f, -0.00247142f, -0.00498256f, -0.05453509f, 
    -0.02996892f, 0.01096811f, -0.06074082f, -0.04119720f, -0.07902333f, -0.07159614f, 0.06068366f, -0.07725679f, 
    0.01020754f, -0.05484661f, 0.03479010f, 0.04070742f, -0.07724077f, -0.06767367f, -0.02391100f, -0.07074118f, 
    -0.04332358f, -0.07961985f, -0.08071493f, -0.01156996f, -0.07171743f, -0.04347096f, 0.05748005f, -0.03398190f, 
    -0.07347550f, -0.09115828f, -0.03223150f, -0.08324564f, -0.03329603f, 0.03614609f, -0.03193679f, -0.04468948f, 
    0.03938415f, 0.04181488f, -0.00406989f, -0.02248995f, 0.03507064f, 0.04432692f, -0.06539454f, -0.01537717f, 
    -0.02843620f, -0.03413357f, -0.09049354f, -0.02590678f, -0.05013353f, 0.03930485f, 0.00273183f, 0.02880046f, 
    0.03687942f, -0.09018973f, -0.07405303f, -0.05002805f, -0.06777955f, -0.06740640f, 0.04023002f, -0.01805960f, 
    -0.10371256f, 0.04011622f, -0.08676722f, -0.02776147f, 0.03726956f, -0.08863945f, -0.01825156f, -0.07657818f, 
    0.01032641f, -0.09629939f, -0.08254173f, -0.07105967f, -0.06556536f, 0.01145764f, -0.01489131f, 0.05162739f, 
    -0.06221315f, 0.01492417f, -0.06929648f, -0.02646946f, -0.05905125f, -0.05421076f, 0.01575285f, 0.01106047f, 
    0.04586825f, -0.08260708f, -0.01427064f, -0.03933564f, -0.06499141f, -0.06101941f, -0.07617789f, -0.07679508f, 
    -0.07164655f, 0.01838750f, 0.02511163f, 0.00440339f, -0.00227676f, 0.04051556f, -0.03580609f, -0.04669939f, 
    0.00204089f, 0.00524824f, -0.00113953f, 0.00032688f, -0.07661442f, -0.04288482f, -0.04151070f, 0.01170167f, 
    -0.02752404f, -0.10213403f, -0.08861285f, -0.04769892f, 0.02218088f, 0.00669452f, -0.00310389f, -0.10133353f, 
    -0.01671912f, 0.00672767f, -0.03182359f, -0.03326783f, 0.00463329f, -0.00482252f, 0.03092952f, 0.05303923f, 
    -0.07839680f, -0.03869121f, 0.03451005f, 0.05292775f, 0.03265149f, 0.01859454f, -0.01607567f, 0.00026377f, 
    0.02901799f, 0.03732949f, -0.00024105f, -0.00599775f, 0.04432020f, -0.02239832f, -0.01684212f, 0.00614244f, 
    0.01934145f, -0.01218336f, 0.06281651f, 0.06348459f, 0.06695887f, 0.05755017f, 0.00395531f, 0.02784152f, 
    -0.04560328f, -0.07942893f, 0.00333773f, 0.01151093f, -0.04536609f, -0.03995269f, -0.02846301f, 0.02733076f, 
    -0.05077359f, 0.01939483f, -0.08225603f, 0.02210534f, -0.01023342f, 0.03128224f, 0.00015312f, 0.01197111f, 
    -0.12434302f, -0.08021096f, -0.05839058f, -0.03686654f, -0.08300698f, -0.09788094f, -0.06220794f, -0.09310333f, 
    0.02349458f, -0.09932835f, -0.01701679f, 0.03958938f, -0.00822420f, 0.03067185f, 0.00095083f, -0.03053462f, 
    -0.16906004f, -0.04221785f, -0.06894435f, -0.01970028f, -0.07200877f, -0.09151044f, 0.00990780f, 0.04536786f, 
    0.06241826f, -0.05088662f, 0.04484203f, -0.02982859f, 0.05123627f, -0.02558715f, -0.05104861f, 0.01206078f, 
    -0.08831102f, -0.02138644f, 0.00666572f, -0.09765050f, -0.11387385f, -0.03325729f, -0.02636729f, 0.03601227f, 
    -0.08490302f, -0.08827747f, 0.03214284f, -0.12486833f, -0.05509659f, -0.03791193f, -0.07084166f, -0.00892157f, 
    -0.09753439f, 0.00315815f, -0.07113092f, 0.03364714f, -0.09430044f, -0.06598328f, -0.01229492f, -0.06732813f, 
    -0.06210186f, -0.09079887f, -0.07354782f, 0.00885713f, 0.01650545f, -0.03358414f, -0.09676489f, -0.02611520f, 
    -0.01967231f, -0.07645188f, -0.02625474f, -0.03592651f, -0.08499517f, -0.10325724f, -0.02328334f, 0.01425146f, 
    -0.03869569f, -0.04591875f, -0.04411406f, -0.05213243f, 0.02280202f, 0.00335258f, -0.04760651f, -0.01706082f, 
    -0.04526657f, -0.03031953f, 0.06606526f, -0.07609157f, -0.04379018f, -0.01228683f, -0.06789216f, 0.00281471f, 
    -0.08792870f, -0.07965878f, 0.01116768f, -0.07618700f, -0.13272820f, 0.00659700f, -0.02303514f, 0.10764411f, 
    -0.06549962f, -0.06152046f, -0.11401720f, -0.00379218f, -0.04491915f, -0.05453138f, -0.11762133f, -0.06917514f, 
    -0.10054206f, -0.05583205f, -0.03839152f, -0.04158187f, -0.08812515f, -0.03880445f, -0.14248677f, -0.14587434f, 
    -0.14956108f, -0.09528635f, -0.04733147f, -0.04380905f, -0.15587792f, 0.00904340f, -0.06383118f, -0.13036411f, 
    -0.09659608f, -0.09309310f, -0.06350611f, -0.00901291f, -0.08884710f, -0.02070508f, -0.08173733f, -0.05512115f, 
    -0.05311352f, -0.01738613f, -0.13816193f, -0.00531789f, -0.10967074f, -0.02730118f, -0.03514652f, 0.02233438f, 
    -0.06361614f, -0.02138162f, -0.10632356f, -0.12418496f, -0.08375941f, -0.04471024f, -0.06461237f, -0.07164658f, 
    -0.03348779f, -0.02125214f, -0.05693683f, 0.01953748f, 0.01592533f, -0.10772762f, -0.02642149f, -0.07885168f, 
    -0.04359256f, -0.04253846f, 0.12397146f, 0.09026591f, -0.02873875f, -0.08759777f, -0.18203045f, 0.08702449f, 
    0.09958158f, -0.06484902f, 0.11256427f, 0.06152807f, -0.29833257f, -0.00431737f, 0.02282126f, -0.16508274f, 
    -0.16077760f, -0.28251877f, -0.14022680f, -0.21138589f, -0.04838737f, 0.17666768f, 0.00581828f, 0.04275189f, 
    -0.02560390f, -0.17256851f, 0.08268730f, 0.25472838f, 0.14438696f, 0.15437634f, -0.04344091f, 0.03949006f, 
    0.06179373f, 0.02466823f, 0.08264937f, 0.06670073f, 0.00490836f, -0.06265689f, 0.04107611f, 0.11423659f, 
    0.09118783f, 0.13927133f, -0.01142769f, 0.21785448f, -0.00642363f, 0.14575984f, -0.07582285f, -0.00905822f, 
    -0.19359547f, 0.20435521f, -0.00832448f, 0.11198694f, -0.00858216f, -0.06863031f, -0.02491218f, -0.05494377f, 
    0.01944517f, 0.06924777f, 0.06097922f, -0.03902498f, -0.48466539f, 0.05305856f, 0.00404959f, 0.08374741f, 
    -0.10768518f, 0.04276842f, -0.12830119f, -0.06603239f, -0.03561829f, 0.08034262f, -0.00905392f, 0.08592167f, 
    -0.26398262f, -0.39726296f, -0.32038775f, 0.33277708f, 0.13601644f, 0.09823362f, 0.10944324f, 0.20399889f, 
    -0.08262972f, -0.13845141f, -0.00452035f, 0.08039532f, -0.20787920f, 0.21359383f, 0.11579859f, -0.01785217f, 
    -0.04333495f, -0.04331140f, 0.04641675f, 0.00935122f, 0.10241436f, 0.10072894f, -0.02621563f, 0.10905880f, 
    0.11792336f, -0.08460438f, 0.04757549f, 0.06629921f, 0.15068346f, 0.21541347f, 0.08195662f, 0.17369969f, 
    -0.00400595f, 0.07996128f, 0.14416859f, 0.17836779f, 0.00174879f, 0.30111739f, 0.03174312f, 0.02435980f, 
    0.03899652f, 0.06505457f, 0.02463286f, 0.13277070f, 0.04109465f, -0.03720443f, -0.10447416f, -0.05698533f, 
    -0.39107764f, 0.17519318f, 0.05877732f, 0.12390035f, -0.01307464f, -0.02719419f, -0.01460296f, -0.15638034f, 
    -0.02742495f, 0.09486377f, 0.01923064f, 0.14786416f, -0.15381628f, 0.17127615f, 0.15517677f, 0.03742315f, 
    0.07327240f, -0.03802655f, -0.10105108f, -0.03317320f, -0.11645158f, -0.10841401f, 0.09578413f, 0.00996545f, 
    -0.30445406f, 0.15619281f, 0.01258581f, -0.02404265f, -0.04339027f, -0.06659539f, -0.05522020f, -0.16020562f, 
    -0.03515964f, -0.07919061f, -0.09741449f, -0.06501422f, -0.21865050f, 0.02258118f, -0.03252654f, 0.31357738f, 
    0.14009827f, 0.07895694f, -0.03986700f, 0.01906116f, 0.06108631f, 0.03624570f, 0.12956792f, 0.16200095f, 
    0.18339233f, 0.20658314f, -0.08523404f, -0.31864452f, -0.02088146f, -0.01770633f, -0.00444997f, -0.02208365f, 
    0.04521584f, 0.08516236f, 0.00697427f, -0.07529432f, 0.29502666f, -0.29723051f, -0.12073328f, 0.21700305f, 
    -0.03177955f, 0.09004875f, -0.01984151f, 0.09453918f, -0.06647740f, -0.07466881f, 0.07493826f, -0.06829922f, 
    -0.23674443f, -0.22980906f, 0.14896202f, 0.00982994f, -0.19872808f, -0.05364434f, 0.02053067f, -0.07977649f, 
    -0.10688170f, -0.00228906f, 0.13074866f, 0.11168077f, -0.07116120f, -0.05662515f, -0.19348146f, -0.22775178f, 
    -0.06898794f, 0.10938533f, 0.02375660f, -0.09354737f, -0.02950550f, -0.08040683f, 0.02614156f, 0.00771232f, 
    0.26090008f, 0.16026750f, 0.20343162f, 0.11722959f, -0.13313501f, -0.11750267f, 0.14661668f, 0.24690980f, 
    -0.01110061f, 0.02692107f, 0.00039747f, -0.02301676f, 0.58991951f, 0.38708982f, -0.12742789f, 0.14411379f, 
    0.04487211f, 0.06731941f, 0.01009433f, -0.17577524f, 0.08198474f, 0.06265575f, -0.01369734f, -0.04168622f, 
    0.10041704f, 0.06277213f, -0.00943827f, 0.02279308f, 0.02285565f, -0.05646254f, 0.07495572f, -0.15776323f, 
    -0.02506265f, 0.01748251f, -0.15817930f, -0.00622621f, 0.06557330f, -0.04099708f, 0.05002726f, -0.28502920f, 
    0.05995784f, 0.06382567f, -0.04486001f, 0.06698089f, 0.04184670f, -0.01686718f, 0.04925326f, -0.04483438f, 
    0.23769216f, -0.01513832f, 0.25868928f, 0.06190491f, -0.02394110f, -0.14501113f, 0.00989760f, 0.04302301f, 
    -0.03378915f, 0.19118963f, 0.00061916f, 0.02521717f, 0.18007126f, -0.30507648f, -0.08969676f, -0.37253496f, 
    -0.17795759f, 0.03208907f, -0.05107496f, -0.07245817f, -0.09057415f, 0.07810514f, 0.07077009f, -0.18728298f, 
    -0.09978116f, 0.15556571f, 0.09789829f, -0.02640038f, -0.21103294f, -0.05802493f, 0.19954149f, -0.14252107f, 
    -0.02680578f, 0.03803285f, -0.05775981f, 0.00044387f, 0.10410653f, 0.01547710f, 0.06793253f, 0.20372747f, 
    -0.03590829f, 0.01051549f, 0.05523153f, 0.06721344f, -0.04362539f, 0.09518314f, 0.07523662f, 0.07244905f, 
    0.19327240f, -0.10833929f, -0.04748418f, -0.18251953f, -0.21994242f, 0.03999095f, -0.07929938f, -0.08663400f, 
    -0.00692579f, 0.00645119f, 0.02947927f, -0.06428829f, -0.05105260f, -0.00820596f, -0.23506932f, -0.02315737f, 
    0.00080367f, 0.14996947f, 0.05795999f, 0.02546630f, 0.02828259f, 0.02458588f, -0.00174012f, -0.02335868f, 
    -0.08591232f, -0.12780388f, -0.12976590f, 0.07477896f, -0.02598381f, -0.02647315f, -0.01815366f, -0.03660058f, 
    -0.08695696f, 0.08882912f, 0.09879132f, 0.29347402f, 0.12570687f, -0.06698282f, 0.01036646f, -0.12281554f, 
    -0.09952682f, -0.09695324f, 0.11844251f, 0.02049702f, -0.04518217f, -0.06064972f, -0.13668996f, -0.27718115f, 
    -0.34568185f, -0.18507744f, -0.12338120f, 0.02161889f, -0.06854510f, 0.06696749f, -0.05657080f, -0.07826006f, 
    -0.09274726f, 0.03742974f, -0.05153994f, -0.03286215f, -0.08600117f, 0.15201676f, 0.27260998f, 0.02645230f, 
    0.02104494f, 0.11397520f, 0.05688037f, 0.14610080f, -0.09953279f, -0.11448968f, 0.01127454f, 0.15508305f, 
    0.11047836f, -0.02020136f, 0.24756792f, 0.06579715f, 0.05070623f, -0.10556985f, -0.02101157f, -0.03377007f, 
    -0.03934542f, -0.08806844f, 0.01075800f, 0.07726788f, 0.07532535f, 0.00620014f, -0.00788841f, 0.10935165f, 
    0.05364740f, 0.05455819f, -0.02725286f, -0.11607219f, -0.05157552f, 0.04713735f, 0.04350305f, 0.12543683f, 
    0.22410722f, 0.03348929f, 0.02158670f, 0.10618658f, 0.16909100f, 0.20713638f, -0.05547041f, -0.06501822f, 
    -0.03266895f, -0.08643253f, 0.06255790f, -0.04593145f, 0.07664195f, 0.20941857f, 0.11678819f, 0.27255684f, 
    0.11623726f, 0.11896444f, 0.13934897f, 0.04270715f, -0.03021458f, 0.12183823f, 0.00874062f, -0.07159947f, 
    0.06958530f, 0.45671800f, 0.21513663f, 0.11213661f, -0.10998379f, -0.06565652f, -0.05440442f, -0.05664403f, 
    0.15362856f, 0.07168303f, -0.03175158f, -0.02352337f, 0.10440194f, -0.15211517f, 0.23166518f, -0.12532815f, 
    -0.04818529f, 0.04727483f, -0.08595283f, -0.16879319f, -0.12025320f, -0.12396776f, 0.05173298f, -0.03965504f, 
    0.15349269f, -0.08007167f, -0.41936100f, 0.19866069f, 0.04832711f, 0.13063139f, 0.03026063f, -0.05478719f, 
    0.01138398f, -0.00503272f, 0.02434345f, -0.01692845f, 0.20195332f, 0.27347925f, 0.16585632f, 0.08853050f, 
    -0.00834673f, -0.14642946f, -0.11771196f, 0.08959901f, -0.14912726f, 0.02468820f, 0.08976178f, -0.03101231f, 
    -0.12952968f, 0.14100483f, -0.01455669f, -0.08865456f, 0.13818367f, 0.15184188f, 0.17349014f, -0.02160504f, 
    -0.08068922f, -0.02229323f, 0.08095589f, 0.02031991f, 0.24091381f, 0.28346196f, -0.13282122f, 0.01886799f, 
    0.06056868f, 0.06083344f, 0.04184284f, 0.05758594f, 0.01415819f, 0.00008434f, -0.04599820f, 0.04598540f, 
    -0.05314405f, 0.01736555f, -0.02795200f, 0.29101515f, -0.08086857f, -0.14979956f, 0.10142933f, -0.11999593f, 
    -0.01219347f, 0.14753805f, -0.07014672f, 0.11245856f, -0.15471601f, 0.13294494f, 0.03319431f, 0.03261057f, 
    -0.01728669f, -0.02079107f, -0.12278778f, 0.01728414f, -0.07305683f, -0.00602389f, 0.01402139f, -0.00248767f, 
    -0.09753709f, 0.11111914f, 0.06336536f, 0.07281653f, -0.10073285f, -0.04892130f, -0.17273696f, -0.16907042f, 
    0.06604107f, -0.15660967f, 0.00447067f, 0.00678731f, 0.17698330f, 0.02748897f, 0.01918256f, 0.23744008f, 
    -0.00946014f, 0.01635333f, -0.02670919f, -0.06106057f, 0.07375782f, 0.00087361f, -0.01057400f, -0.01666229f, 
    -0.15931755f, 0.14018333f, 0.04369357f, -0.28176686f, -0.07071631f, 0.12308139f, 0.12524776f, -0.01480688f, 
    -0.03248048f, -0.02565940f, -0.06778508f, -0.10572031f, 0.35266060f, -0.36897901f, -0.01426927f, 0.15390323f, 
    0.05037079f, 0.09305877f, -0.21141994f, 0.22495531f, -0.04962264f, -0.02144163f, -0.13842215f, -0.08933157f, 
    -0.05397769f, -0.06265797f, 0.05531662f, -0.05867181f, -0.00105972f, -0.02175652f, 0.04700069f, -0.01152731f, 
    -0.03622473f, -0.01152361f, -0.00495623f, -0.08619911f, -0.00114114f, 0.02772124f, -0.07221571f, 0.04593283f, 
    -0.00855648f, 0.05094763f, -0.01106077f, -0.01062583f, -0.07353832f, 0.01513139f, 0.05492334f, 0.00326814f, 
    0.04840472f, 0.06099911f, -0.07707725f, -0.04671209f, -0.04906407f, 0.05077300f, -0.01275477f, 0.04154006f, 
    -0.03078254f, 0.05779560f, -0.05534019f, -0.01126021f, 0.00852195f, -0.01859350f, 0.05607330f, -0.05248203f, 
    -0.04034324f, -0.00106692f, -0.05480792f, -0.06502177f, 0.05548709f, -0.02427556f, 0.04955031f, -0.02804859f, 
    0.02476016f, 0.02005532f, 0.02967609f, 0.05781626f, -0.07629649f, 0.05458347f, -0.03188602f, -0.00229826f, 
    -0.00301303f, -0.03771184f, -0.00610544f, 0.00343533f, -0.01981711f, -0.05376798f, 0.05651319f, 0.03696985f, 
    -0.04814986f, -0.03682087f, 0.00759579f, -0.01193994f, 0.04374443f, -0.02117419f, 0.04510436f, -0.07315798f, 
    -0.04457628f, 0.02090874f, -0.01130079f, 0.02228048f, 0.00753995f, -0.00511322f, -0.05497488f, 0.05969129f, 
    0.02641337f, -0.02191656f, -0.04498714f, 0.01865622f, 0.03089569f, 0.00849153f, 0.01584957f, -0.04996831f, 
    -0.00576831f, 0.04949200f, 0.00688801f, 0.00557126f, -0.03207174f, 0.01155368f, -0.04466738f, 0.05060467f, 
    -0.07082015f, 0.05913830f, -0.07413743f, -0.02738891f, 0.04411095f, 0.05780206f, -0.04626800f, -0.02341174f, 
    -0.04102932f, 0.01170842f, 0.00691782f, 0.02950669f, -0.01945727f, 0.03608578f, -0.04517066f, 0.05004572f, 
    -0.03168323f, 0.03363201f, -0.02629103f, -0.03921489f, -0.02430026f, -0.07212727f, 0.04665967f, 0.04015214f, 
    -0.05360172f, 0.04949958f, 0.01083764f, -0.01757520f, -0.06039706f, -0.05096130f, 0.04538232f, -0.06299624f, 
    0.04359578f, -0.06916327f, 0.05054194f, -0.02965914f, 0.05481521f, 0.03693340f, 0.05014176f, -0.01381172f, 
    -0.03109934f, 0.01502854f, 0.04119853f, -0.07198789f, 0.00138642f, 0.02867136f, 0.01764736f, -0.06122140f, 
    -0.01462528f, -0.06600747f, 0.03513787f, -0.03780822f, -0.03642007f, -0.03789147f, -0.08117353f, 0.06118460f, 
    -0.01410902f, 0.04436404f, 0.00446553f, -0.02840655f, 0.00670472f, -0.07537963f, -0.05470521f, 0.03938094f, 
    -0.05695277f, -0.01859033f, -0.03134992f, 0.06985004f, -0.00900840f, -0.02190185f, -0.06517454f, -0.08097657f, 
    -0.01958890f, 0.04424686f, -0.02492569f, -0.07490317f, 0.01871292f, 0.00225315f, 0.00358943f, 0.01841069f, 
    -0.06305038f, -0.02631877f, -0.07089047f, 0.00371806f, 0.03834947f, 0.00952507f, -0.05896656f, 0.04995126f, 
    -0.02743942f, 0.04048924f, -0.02720787f, 0.05792004f, 0.07224034f, 0.00464722f, -0.06131560f, -0.07268570f, 
    -0.04515587f, -0.10683081f, 0.05376122f, -0.08585782f, -0.03394951f, 0.13321704f, -0.14355628f, -0.06758793f, 
    0.18514112f, 0.04083984f, -0.05735934f, 0.09346832f, 0.02234051f, -0.00228136f, -0.13541724f, -0.15675242f, 
    -0.06651420f, -0.06858880f, 0.07116531f, 0.00647024f, 0.17206156f, 0.01700011f, -0.04508483f, -0.02492265f, 
    -0.03974770f, -0.05561202f, -0.10347710f, -0.05172465f, -0.01665848f, -0.10524613f, -0.24989037f, -0.01752945f, 
    -0.01140518f, -0.09291890f, -0.07313941f, -0.08669131f, 0.47462541f, 0.35037351f, 0.11250747f, 0.26290113f, 
    0.12028017f, 0.01572857f, 0.08547883f, 0.13561405f, -0.35122249f, 0.09559487f, -0.13906167f, -0.22445089f, 
    -0.03290108f, 0.38394496f, -0.06272446f, -0.08282426f, -0.09701402f, -0.01395732f, -0.06601983f, -0.07890642f, 
    0.19166292f, 0.13451286f, -0.02695733f, -0.12664251f, -0.03481722f, -0.11742795f, 0.00786708f, -0.02638162f, 
    -0.05622647f, 0.12111368f, -0.10045398f, 0.02409710f, 0.10233985f, 0.13212965f, -0.05768682f, 0.06546785f, 
    0.10250125f, -0.02479726f, 0.03662083f, 0.24574034f, 0.31864586f, 0.19797696f, 0.10769641f, -0.23883696f, 
    -0.20507085f, 0.05129228f, 0.04092076f, 0.02276785f, 0.06614316f, -0.09388459f, -0.04716063f, -0.10542405f, 
    -0.10003349f, -0.01543890f, -0.09606673f, -0.01123809f, -0.00577874f, 0.10797032f, -0.04326732f, -0.09615652f, 
    0.17649689f, 0.04294068f, 0.09881173f, -0.00867915f, -0.18372911f, -0.06712759f, 0.01907910f, -0.06480843f, 
    0.11153995f, -0.10425668f, 0.01993173f, 0.00901277f, -0.12659585f, -0.02706948f, -0.16835414f, 0.10718493f, 
    -0.13444223f, -0.18604980f, -0.33491713f, -0.17907481f, -0.14013922f, -0.22169156f, -0.07134650f, 0.19700617f, 
    0.02769013f, 0.12141463f, -0.04494157f, -0.12524991f, -0.16337205f, -0.00124315f, -0.11208064f, -0.12845886f, 
    0.08392435f, 0.19670524f, 0.11353090f, -0.04826242f, -0.05992055f, -0.03222704f, 0.00746168f, 0.06894810f, 
    -0.14995767f, 0.03713289f, 0.08848922f, -0.02685915f, 0.08985452f, 0.08699715f, 0.00489040f, 0.02750796f, 
    -0.01029891f, 0.04201949f, -0.14728278f, -0.09470107f, -0.08156309f, -0.09135407f, -0.06568830f, -0.06823047f, 
    0.21315250f, 0.15953553f, 0.15954326f, 0.14062855f, -0.05584957f, 0.02798655f, -0.18661197f, 0.17178769f, 
    -0.07928249f, 0.13506931f, 0.11272129f, -0.25675595f, 0.05493696f, 0.14723761f, -0.06733191f, -0.07836508f, 
    -0.13369064f, -0.06584306f, -0.00205848f, -0.17686026f, 0.02382042f, -0.01741943f, 0.00966192f, 0.03568209f, 
    -0.09251335f, 0.08550933f, -0.21252348f, -0.00025147f, 0.50529683f, 0.17936625f, 0.30193207f, -0.04986455f, 
    0.13686448f, 0.02790829f, 0.21863469f, 0.31190619f, 0.02780282f, -0.14500751f, 0.10421319f, -0.00405695f, 
    -0.04130558f, 0.00612101f, -0.05107780f, -0.07863021f, 0.01891817f, -0.06377104f, 0.02242305f, 0.03634341f, 
    0.06418651f, 0.05117697f, 0.05594328f, -0.00870196f, -0.00296724f, -0.06200048f, -0.02520461f, -0.06404451f, 
    -0.06637605f, -0.03165719f, 0.04202586f, -0.01807239f, 0.01866801f, -0.05433974f, 0.05834993f, -0.06776027f, 
    0.04018931f, -0.03160045f, -0.07188269f, 0.00284206f, 0.04722493f, 0.00026772f, 0.01461067f, 0.00993462f, 
    -0.03992281f, 0.04690748f, 0.00814169f, -0.02047765f, -0.07151170f, -0.03009728f, 0.05191603f, -0.02973662f, 
    0.03097937f, 0.03433929f, -0.03385484f, -0.00787913f, -0.08100438f, 0.04992898f, -0.04098490f, -0.06636284f, 
    -0.04278632f, -0.02901183f, -0.06262051f, 0.03686934f, -0.03525328f, -0.07357900f, 0.02539844f, -0.01060470f, 
    -0.01701391f, -0.07714178f, -0.01603500f, -0.04265032f, 0.01918373f, -0.02638813f, -0.04405088f, -0.04549174f, 
    -0.06492676f, -0.02459307f, 0.00660154f, -0.06435770f, 0.03541188f, 0.04580908f, 0.01724513f, -0.06739280f, 
    0.00077124f, 0.04567791f, -0.06908881f, -0.06281946f, 0.03910858f, -0.07985760f, -0.03126311f, -0.07505342f, 
    -0.07650233f, -0.07431552f, 0.04408232f, -0.01103009f, -0.06527469f, -0.03657170f, -0.03818767f, 0.04061658f, 
    -0.04913893f, -0.06227893f, -0.00621536f, -0.00794319f, -0.04870214f, -0.03963106f, -0.00523129f, 0.00423375f, 
    0.01604861f, 0.00930193f, 0.02407701f, 0.05330487f, 0.00127260f, -0.07750224f, -0.06640784f, 0.02607816f, 
    0.05647514f, -0.01597973f, -0.03128891f, 0.03970120f, -0.00062076f, 0.00751100f, -0.04932161f, -0.04516615f, 
    0.03740023f, 0.05153344f, 0.03959111f, 0.03189116f, 0.00595219f, 0.05191228f, -0.02255875f, -0.01125284f, 
    -0.00392348f, 0.01719511f, -0.04529876f, -0.04209729f, -0.06530067f, -0.02739176f, -0.07564605f, 0.01327157f, 
    0.06346923f, -0.05587618f, -0.06094654f, -0.01640875f, -0.06064288f, 0.05092724f, -0.00260920f, -0.02200963f, 
    0.06631024f, -0.00189144f, 0.00225871f, -0.03591125f, -0.05913436f, 0.01804394f, -0.01501836f, -0.07785594f, 
    0.03109968f, 0.00783987f, 0.06128257f, -0.00486973f, -0.00390476f, -0.02770261f, -0.07912672f, -0.01797106f, 
    0.04392342f, -0.04485046f, -0.05497028f, -0.06796184f, 0.03141841f, -0.04365458f, 0.06667695f, -0.05525267f, 
    -0.07740897f, -0.02527629f, 0.04559579f, -0.02723888f, 0.06138057f, -0.03433906f, -0.00882872f, -0.05163790f, 
    0.05892773f, 0.02704668f, -0.00563220f, 0.05199863f, -0.05154730f, 0.01241705f, 0.02143097f, 0.02464259f, 
    -0.02694472f, 0.06373432f, 0.00102872f, 0.02040365f, 0.02200148f, -0.08256195f, 0.03861230f, -0.01698285f, 
    0.05524265f, -0.02266148f, 0.03090476f, 0.02312020f, -0.02822515f, -0.07187785f, -0.03788829f, 0.02375930f, 
    0.02413536f, -0.07587846f, -0.00564263f, 0.00636561f, 0.02756533f, -0.02427770f, -0.04643970f, 0.02001037f, 
    0.04618581f, -0.01339889f, 0.06353088f, -0.02175407f, -0.05334770f, -0.04728995f, -0.01500235f, 0.01250244f, 
    -0.05245945f, 0.01990676f, -0.01053518f, -0.01368566f, -0.03602631f, -0.00489917f, 0.00322394f, 0.05212139f, 
    0.04612375f, -0.05356306f, -0.06166318f, -0.00429557f, -0.02779134f, -0.01982547f, -0.00043344f, -0.07197709f, 
    -0.02706941f, 0.03318116f, 0.00465842f, -0.02099925f, 0.00243464f, 0.01654111f, 0.04720151f, -0.07594306f, 
    0.03469143f, 0.03774261f, 0.01526539f, -0.03765473f, -0.03666001f, -0.01912269f, -0.01651281f, -0.00510440f, 
    0.03690442f, -0.06516930f, -0.07861847f, 0.00402281f, -0.02112995f, 0.05721866f, 0.02543304f, -0.06609118f, 
    0.02045884f, -0.03773197f, 0.03820703f, 0.00823732f, -0.06223975f, 0.05706049f, -0.06468701f, 0.03039517f, 
    -0.05241588f, -0.01154253f, 0.04348647f, 0.00977838f, 0.01766539f, 0.03642437f, -0.03047143f, -0.05219226f, 
    0.01406171f, -0.06189331f, 0.05508798f, 0.00183774f, -0.02095811f, 0.01204684f, 0.03046826f, 0.01376040f, 
    -0.02258233f, 0.00953445f, -0.02180432f, -0.00167452f, -0.02078159f, -0.05063523f, -0.02276341f, 0.00134495f, 
    -0.05433109f, 0.02328598f, -0.04704368f, -0.02847866f, -0.02262558f, -0.02040850f, -0.05298140f, -0.06657752f, 
    0.05393977f, 0.06257901f, -0.01289172f, 0.05703098f, 0.03604198f, -0.07849557f, -0.03831066f, -0.06520046f, 
    -0.07041157f, 0.03974339f, -0.01932548f, 0.04835884f, -0.06130314f, -0.03507583f, -0.07530615f, 0.05781820f, 
    -0.02091775f, 0.03927965f, -0.04282582f, -0.00129272f, 0.04121894f, -0.04679301f, -0.04061726f, -0.01208603f, 
    -0.02584420f, -0.07616558f, -0.03548465f, -0.03278234f, -0.07808392f, 0.02772443f, 0.01188570f, -0.05634256f, 
    -0.03703810f, -0.05834332f, 0.04778346f, 0.04640505f, 0.00116909f, 0.04172297f, 0.02693749f, -0.01143191f, 
    -0.02820243f, -0.06711073f, 0.06129261f, -0.03557106f, 0.05991207f, 0.03560670f, -0.01310374f, -0.05039673f, 
    -0.04392599f, -0.07530174f, -0.05039294f, 0.02199564f, 0.01857853f, 0.06357236f, -0.03631392f, -0.06662162f, 
    -0.01920357f, -0.04866293f, -0.01302971f, -0.03653961f, -0.06275116f, 0.05634312f, 0.02106153f, -0.00453579f, 
    -0.03861820f, -0.02074202f, -0.01617513f, -0.05128821f, -0.00212931f, 0.04172227f, -0.02240539f, 0.06155200f, 
    -0.06044110f, 0.06479555f, -0.04547141f, -0.02583593f, 0.04296007f, -0.06460468f, 0.05452563f, 0.01461260f, 
    -0.00250952f, -0.02022996f, 0.03327654f, 0.01570183f, -0.02783719f, -0.01642200f, -0.04063513f, 0.02677042f, 
    -0.03329775f, 0.00739533f, -0.03420290f, -0.06086037f, -0.05956907f, 0.04632577f, 0.00351538f, 0.01102829f, 
    0.11364809f, -0.01246311f, 0.02242864f, 0.09809997f, 0.00340406f, 0.01827276f, 0.06828137f, -0.04703731f, 
    0.01641309f, 0.10033650f, -0.13406786f, -0.09474321f, 0.21404861f, 0.14318699f, 0.12018651f, 0.08949919f, 
    -0.02716374f, 0.03063399f, -0.00049666f, 0.00759320f, -0.00814655f, -0.07368881f, -0.05481441f, 0.01197149f, 
    -0.36738667f, -0.23550595f, -0.20441808f, 0.08635966f, 0.03266653f, 0.14087754f, 0.15473489f, 0.02122373f, 
    -0.07930540f, -0.06697489f, -0.08359773f, 0.06176554f, -0.00393396f, -0.39722162f, -0.15659186f, -0.38373196f, 
    -0.02973456f, -0.22382414f, -0.05439600f, 0.03730611f, -0.02529373f, 0.08526219f, -0.02052938f, 0.04580545f, 
    0.20677212f, 0.14774327f, -0.02122310f, -0.13933323f, -0.02380890f, -0.19707489f, 0.05602434f, -0.05713669f, 
    0.03343452f, 0.14964926f, 0.15386626f, 0.23855874f, 0.48278323f, 0.18737026f, -0.16618110f, -0.05253126f, 
    -0.05347831f, 0.10696317f, 0.23365335f, -0.08816480f, -0.14307852f, -0.10506508f, -0.12210267f, -0.03255041f, 
    -0.06082563f, 0.13218221f, -0.01061192f, -0.66141516f, 0.15139470f, 0.10445742f, 0.17655389f, 0.09608506f, 
    -0.07482660f, -0.12770009f, -0.06961193f, -0.19075507f, 0.19084990f, 0.17097688f, 0.12487664f, 0.13380714f, 
    0.18477510f, 0.08021143f, -0.05641253f, 0.01419355f, 0.02356480f, 0.02828339f, 0.17291529f, 0.02159482f, 
    -0.11488153f, -0.16939859f, 0.00864882f, -0.02982999f, -0.05300463f, -0.05656290f, -0.14276969f, -0.29290447f, 
    -0.20010595f, -0.16610010f, -0.08383628f, -0.05922941f, -0.29467514f, -0.39067411f, -0.07337622f, 0.08423656f, 
    0.09171239f, 0.26604423f, 0.16250651f, 0.16877946f, -0.04168120f, 0.08662298f, 0.12034276f, 0.01006633f, 
    0.18540794f, -0.09040918f, -0.01893930f, -0.08346342f, 0.17757653f, 0.03048014f, 0.14419957f, 0.03642958f, 
    0.02486356f, 0.14547941f, -0.01845420f, 0.16490884f, 0.10144968f, -0.12870304f, -0.15101962f, 0.07809437f, 
    -0.04010439f, 0.11557509f, 0.12863933f, -0.25524369f, -0.04463108f, -0.06485853f, -0.12280645f, -0.05879587f, 
    0.03263064f, -0.08551855f, 0.04311514f, 0.04087255f, -0.10846586f, -0.00207206f, 0.06997469f, 0.00263684f, 
    0.19468060f, 0.19906753f, 0.13107945f, 0.24295381f, 0.26022539f, -0.07565056f, 0.08466864f, 0.16900787f, 
    -0.00338111f, -0.11588157f, 0.06910075f, 0.06497216f, 0.09944523f, -0.07426459f, 0.08971912f, -0.13739781f, 
    0.24503917f, 0.21933752f, 0.08178767f, -0.12544023f, -0.09502625f, 0.07502059f, -0.08087365f, -0.03038607f, 
    -0.05705288f, -0.01355116f, -0.22461288f, 0.28045434f, -0.18369041f, 0.03969888f, -0.08998930f, -0.18848734f, 
    -0.04817972f, -0.09366813f, -0.11030088f, -0.09575534f, 0.11245041f, 0.10158815f, -0.21711887f, -0.06112904f, 
    -0.00715056f, 0.06968784f, -0.34815198f, -0.18241617f, 0.34408435f, -0.05081180f, -0.04049053f, 0.03803886f, 
    0.06741045f, 0.15399644f, -0.03460633f, -0.17103796f, -0.26877648f, -0.10841838f, -0.08382515f, 0.07734722f, 
    0.03385745f, -0.04464621f, -0.24846624f, 0.02914561f, 0.09628460f, 0.08913920f, 0.13644435f, -0.10427273f, 
    -0.16998971f, 0.00097039f, -0.09462333f, -0.00650441f, 0.22415446f, 0.12069865f, 0.04984012f, -0.15498167f, 
    0.03033131f, 0.04221302f, -0.04904490f, -0.03657066f, -0.54823750f, -0.19845760f, 0.46576849f, 0.16176033f, 
    0.01982681f, -0.10241722f, -0.01903325f, 0.00768438f, -0.03042432f, -0.09427991f, 0.11671648f, 0.15728532f, 
    0.08293219f, -0.20181565f, -0.06869768f, 0.03981346f, 0.06015400f, 0.07194299f, -0.04383674f, 0.08855206f, 
    0.01795405f, 0.04122556f, 0.28949553f, 0.06205765f, 0.11707068f, 0.08830591f, -0.12746663f, 0.05857233f, 
    0.08429899f, 0.06539339f, 0.00471011f, -0.04230881f, -0.06478009f, -0.14444599f, -0.08863882f, -0.01453987f, 
    -0.04279339f, 0.31278336f, 0.13230748f, -0.06704963f, 0.03511592f, 0.02763277f, 0.07043332f, 0.05596747f, 
    0.00927294f, -0.12886323f, -0.02844201f, -0.06395560f, -0.15597457f, -0.10442530f, -0.19153768f, 0.20793806f, 
    0.16459607f, 0.03078333f, -0.05604618f, 0.06259658f, 0.13424985f, -0.06271514f, -0.13524847f, 0.19831161f, 
    0.07340293f, -0.13230684f, -0.04764580f, 0.08929088f, 0.17436813f, -0.01178966f, 0.04499384f, 0.19843401f, 
    0.05177888f, -0.02533405f, -0.08831021f, -0.17878245f, -0.06938297f, -0.13214850f, 0.11051916f, -0.03696653f, 
    0.09272780f, -0.07011569f, 0.08268272f, -0.14284322f, 0.08162891f, 0.02662901f, 0.12530433f, 0.08567996f, 
    -0.20593059f, -0.04847860f, -0.09009708f, 0.07462734f, 0.19811738f, 0.02006855f, 0.12661062f, -0.03148665f, 
    0.13376917f, 0.04339994f, 0.01631203f, 0.13957374f, 0.06950381f, -0.11412434f, 0.23519303f, -0.12957901f, 
    0.00244308f, -0.16093661f, -0.10717749f, 0.06047813f, 0.00401774f, 0.00735584f, -0.05025361f, -0.18894652f, 
    -0.13187870f, -0.25781950f, -0.09505732f, -0.13382272f, -0.02462012f, 0.09239186f, -0.04853443f, 0.07238687f, 
    0.06932734f, 0.04358738f, -0.00506011f, -0.03538112f, -0.02099575f, 0.23234461f, 0.07940538f, -0.21942316f, 
    0.10965040f, 0.13240698f, -0.24607643f, 0.06424858f, 0.08838066f, -0.01237483f, 0.11905281f, 0.19806409f, 
    0.00691155f, -0.02742127f, 0.17103614f, 0.07663630f, -0.01107804f, -0.23780257f, -0.01470406f, 0.05517267f, 
    0.14298275f, 0.09691755f, 0.06590763f, 0.01081989f, -0.05060477f, 0.24590372f, -0.26003096f, 0.09449167f, 
    0.05657778f, -0.19351979f, 0.12715152f, -0.15326817f, 0.09677210f, 0.21148311f, -0.11260249f, -0.20652753f, 
    -0.06000723f, -0.04570499f, 0.09621781f, -0.41801909f, -0.07436085f, -0.13646123f, 0.00271265f, 0.31508061f, 
    -0.02747826f, 0.23956342f, -0.00269633f, -0.14778860f, -0.01332463f, 0.11138111f, -0.01507301f, -0.14378813f, 
    -0.17559837f, 0.02671426f, -0.27491581f, -0.24539423f, -0.16259564f, -0.10252090f, -0.01720613f, -0.14280929f, 
    -0.26009169f, -0.18855162f, -0.07702726f, -0.03446140f, -0.02947614f, 0.05710000f, 0.24150275f, 0.01332463f, 
    -0.00811939f, -0.01904519f, 0.14175574f, -0.05920967f, 0.02152733f, -0.05377925f, 0.26246694f, 0.24586450f, 
    0.05471615f, -0.05852532f, -0.14271511f, 0.16101183f, -0.01078988f, 0.08442926f, 0.18503655f, 0.03521419f, 
    0.29436120f, 0.01775957f, -0.04614327f, 0.18072456f, -0.02169147f, 0.03970997f, 0.22494006f, -0.18431079f, 
    0.10367705f, 0.22868897f, 0.09452181f, 0.04504926f, 0.40066940f, 0.09421863f, 0.58796448f, -0.28563431f, 
    -0.00403223f, -0.09800007f, 0.00289731f, 0.04323831f, -0.05620877f, -0.17779684f, 0.01865317f, -0.08165031f, 
    -0.28393370f, 0.12446493f, 0.03810572f, 0.14343739f, -0.05238610f, -0.03923229f, 0.16696876f, -0.00169233f, 
    -0.00346844f, 0.15677264f, -0.04892353f, 0.09699212f, 0.34470111f, 0.14843497f, 0.05374700f, -0.15644702f, 
    0.02056557f, -0.00722451f, -0.03907332f, 0.09562835f, -0.05283572f, -0.04795283f, 0.05331412f, -0.16496916f, 
    -0.03551501f, -0.07996880f, -0.38892007f, 0.03603720f, 0.01880044f, -0.06147117f, -0.06305743f, 0.00679990f, 
    -0.10499249f, -0.21666919f, 0.00840849f, -0.22972274f, -0.28264028f, 0.01707631f, -0.30568898f, 0.05587468f, 
    0.04896215f, 0.12098552f, 0.07333144f, 0.13764296f, 0.07039079f, 0.11891719f, 0.08146574f, 0.10144875f, 
    -0.19054484f, 0.17240366f, 0.01900400f, 0.45573905f, -0.07017712f, -0.12279114f, -0.00012675f, 0.03774530f, 
    -0.00225099f, 0.10970528f, -0.16042316f, 0.05888398f, -0.21088372f, -0.06893188f, 0.42344871f, -0.02976467f, 
    -0.10010395f, -0.07246871f, -0.07256718f, 0.06990823f, -0.12854806f, 0.03612424f, -0.24861354f, 0.12212831f, 
    -0.14933562f, -0.04399958f, 0.18763618f, -0.23475336f, -0.06037214f, 0.09385868f, 0.01924128f, 0.03333988f, 
    0.14902553f, 0.06272604f, 0.27142435f, 0.26769641f, -0.17048787f, 0.08994643f, 0.04771209f, 0.08344232f, 
    0.10404319f, 0.03884351f, 0.19240114f, -0.09501405f, -0.02633020f, 0.01936617f, -0.02454350f, 0.01391238f, 
    0.07033312f, 0.28751114f, -0.10224033f, 0.18702793f, 0.25197989f, 0.07686752f, 0.01831948f, 0.03025310f, 
    -0.13319613f, 0.16622142f, 0.10802460f, 0.06435627f, 0.24326621f, 0.23524615f, -0.13018265f, 0.13715078f, 
    -0.10263541f, -0.11180590f, -0.08314936f, -0.09400652f, -0.13804188f, -0.04448450f, -0.24464682f, 0.12881075f, 
    0.21685283f, -0.13011587f, 0.07997182f, -0.27642044f, 0.00709158f, -0.09155961f, 0.04146174f, -0.01162810f, 
    0.12182581f, 0.20334764f, 0.13252658f, -0.01871052f, -0.01139126f, 0.10105579f, -0.11141734f, 0.12509573f, 
    -0.01968751f, 0.13254312f, -0.10196060f, 0.02378830f, -0.02039238f, 0.08194929f, 0.09492869f, 0.01500971f, 
    -0.09699696f, -0.18379545f, 0.14844263f, 0.07666842f, 0.00575937f, 0.07778492f, -0.02303954f, -0.04198993f, 
    -0.09001122f, 0.10331184f, -0.08014597f, -0.01991301f, -0.29158920f, 0.11442902f, 0.15446688f, 0.02920883f, 
    0.16840194f, -0.05201056f, 0.01144389f, -0.05457058f, -0.07158112f, 0.12161203f, -0.00254151f, 0.08196457f, 
    0.26375851f, 0.24518441f, -0.19489186f, -0.00264944f, 0.02135268f, -0.03015206f, 0.06337857f, 0.05668526f, 
    -0.04010554f, 0.17718515f, -0.01111252f, 0.04040205f, 0.40983099f, -0.26618415f, 0.02180042f, -0.22909087f, 
    -0.09725751f, 0.17161037f, 0.12221443f, -0.12643872f, -0.06426183f, 0.04802053f, -0.04091910f, 0.05056790f, 
    -0.12888360f, -0.03662199f, 0.02157444f, 0.14284338f, 0.08171054f, -0.02591141f, 0.00546544f, -0.10583502f, 
    0.09965790f, -0.00777417f, -0.13819736f, -0.02732648f, 0.06952041f, 0.01708628f, -0.08918080f, 0.13948309f, 
    0.00239634f, 0.08176096f, 0.04777871f, 0.12700808f, -0.06706292f, -0.08314516f, 0.12681268f, -0.03562084f, 
    -0.20421712f, -0.07542796f, -0.04456653f, 0.21822260f, 0.01586016f, 0.09733713f, 0.03788334f, -0.01650719f, 
    -0.05764268f, 0.00391406f, -0.01844345f, -0.09508443f, -0.30705777f, -0.04977294f, -0.01260151f, 0.27188060f, 
    -0.04402598f, -0.00662992f, 0.05333419f, -0.00861382f, -0.02992007f, 0.05952729f, 0.12097964f, 0.12675087f, 
    -0.11496077f, 0.22265570f, -0.15864180f, 0.21541554f, 0.03718224f, -0.07270503f, 0.12193939f, 0.03793639f, 
    -0.00351304f, 0.04322689f, 0.03120941f, 0.08838159f, 0.06471928f, -0.46796745f, 0.13274059f, -0.00663120f, 
    -0.16464217f, 0.01144248f, 0.09832747f, -0.15033536f, -0.04071106f, -0.05413382f, -0.02182039f, 0.04318276f, 
    0.13713399f, 0.00815762f, 0.02186361f, -0.04793569f, -0.10351806f, 0.09411754f, -0.08226448f, -0.09368419f, 
    0.04231942f, 0.01795168f, 0.02250494f, -0.11802278f, 0.32872346f, -0.05765951f, 0.24717496f, 0.16536269f, 
    0.08921273f, 0.09168871f, -0.16316254f, 0.07706138f, 0.02658982f, -0.15966491f, 0.13370304f, 0.02151958f, 
    -0.33380488f, 0.19160123f, -0.10397764f, -0.14682865f, 0.09795494f, -0.02627265f, -0.00612414f, 0.01290674f, 
    -0.04358131f, 0.05014585f, 0.04523610f, 0.03308274f, 0.15160179f, 0.09799672f, 0.10776383f, 0.20045690f, 
    0.08350240f, -0.19460562f, 0.06731305f, -0.04997653f, -0.01348189f, 0.19899455f, 0.08674157f, 0.04984381f, 
    0.01224118f, -0.03185051f, 0.00697458f, 0.02038959f, 0.06955715f, -0.10395034f, 0.08859099f, 0.08407551f, 
    0.08508216f, 0.00801044f, 0.07436043f, 0.10394586f, -0.00338515f, -0.08065080f, 0.03659731f, 0.05724008f, 
    -0.03307725f, 0.09965806f, -0.05772396f, 0.06973565f, -0.04397151f, 0.12638614f, 0.12316081f, 0.13391678f, 
    0.25580496f, 0.11406282f, 0.13609859f, 0.23088546f, 0.07368030f, 0.02746943f, 0.07646193f, 0.08135433f, 
    0.04642833f, 0.09701537f, 0.02455261f, -0.02288910f, -0.01110392f, 0.11861013f, -0.20775467f, 0.01208514f, 
    0.13223790f, 0.24672718f, 0.16639790f, -0.10533173f, 0.20858802f, 0.12855043f, 0.02369737f, 0.03883279f, 
    0.09736459f, -0.04479334f, 0.10765567f, -0.03504497f, -0.05940497f, -0.04912049f, -0.07061058f, 0.03519613f, 
    0.11458101f, -0.00022935f, -0.03598296f, 0.06613522f, 0.12508443f, 0.00834092f, 0.21440771f, -0.04943853f, 
    0.13044922f, -0.12776151f, -0.12932098f, -0.10732402f, -0.02105559f, -0.10275914f, -0.01546050f, 0.08537563f, 
    0.14120151f, -0.11636543f, -0.13582672f, 0.16293749f, 0.08032691f, 0.12958466f, -0.00901902f, -0.03789717f, 
    -0.04847047f, 0.07500796f, -0.03958641f, -0.07852945f, -0.02773392f, 0.12198328f, -0.07050754f, 0.06526681f, 
    -0.01486772f, -0.04469208f, 0.07834231f, 0.07355004f, -0.09490442f, -0.00180577f, 0.00302958f, 0.07251916f, 
    -0.01570255f, 0.25394204f, 0.06684007f, -0.00573802f, 0.20726532f, 0.08311728f, 0.20588216f, -0.01907672f, 
    -0.08101852f, -0.00584064f, 0.03694203f, -0.01088791f, 0.20086244f, 0.41286847f, -0.02545024f, -0.13119763f, 
    -0.01342306f, -0.02057471f, 0.13038968f, 0.04906212f, 0.11712049f, 0.10028752f, -0.17672314f, 0.04996411f, 
    0.00564669f, 0.05667961f, -0.21120833f, 0.16633207f, -0.04075904f, -0.13123569f, 0.17058997f, -0.17917207f, 
    -0.05862988f, 0.02012675f, 0.00640090f, 0.16078781f, 0.06545093f, 0.33220246f, 0.03334760f, 0.21287566f, 
    -0.07719991f, -0.19285044f, -0.23651868f, -0.10650040f, -0.11318036f, -0.03995063f, -0.07776758f, -0.00974861f, 
    -0.17066975f, -0.10898617f, 0.02621706f, -0.05209302f, 0.01643931f, 0.06090400f, -0.10026917f, -0.07210620f, 
    0.09049840f, -0.07181576f, 0.00421963f, -0.09175408f, 0.23512177f, -0.02635076f, 0.06152752f, 0.16953491f, 
    0.08812514f, -0.04833568f, -0.10126963f, -0.19226076f, 0.09154797f, 0.01983396f, 0.08442102f, 0.05569865f, 
    -0.20188496f, -0.07097448f, -0.06495352f, -0.05329003f, 0.00445821f, -0.02332126f, 0.10506928f, -0.00360263f, 
    -0.07256781f, -0.14863768f, -0.03625251f, 0.06010783f, 0.11589830f, -0.15263128f, 0.01345986f, 0.04762585f, 
    -0.01464608f, 0.10109129f, -0.19722416f, 0.07151788f, -0.10407088f, 0.08749487f, -0.17981423f, -0.11266800f, 
    -0.21351978f, -0.04038987f, -0.08650617f, -0.10177556f, -0.06396095f, -0.08631255f, 0.04082149f, -0.09826441f, 
    -0.04734492f, 0.01163494f, 0.25127497f, 0.05243042f, -0.13442475f, -0.15005475f, -0.07218610f, 0.00496574f, 
    -0.09553465f, -0.04137322f, -0.06613948f, -0.01669060f, -0.04308360f, -0.03491563f, 0.09893236f, 0.14576635f, 
    0.24858482f, 0.25845468f, -0.02245610f, 0.14396031f, 0.15503813f, 0.09165547f, 0.07517926f, -0.04565343f, 
    0.12771767f, 0.04525583f, 0.00876461f, 0.08131150f, 0.14401525f, 0.05349076f, -0.12871052f, -0.14458546f, 
    -0.08827502f, 0.16927287f, 0.04001849f, -0.06736946f, 0.17861474f, -0.12000470f, -0.01644572f, 0.20603512f, 
    0.16961509f, -0.38467804f, 0.23175509f, -0.01398034f, 0.10125320f, -0.03800531f, -0.07743751f, -0.04627317f, 
    0.00720497f, -0.09741069f, 0.10304619f, 0.15121168f, 0.07063664f, 0.01754043f, 0.02525586f, -0.04869096f, 
    0.22608918f, -0.29014334f, -0.19310178f, -0.30608821f, 0.02117486f, -0.11179443f, 0.00019153f, 0.10699300f, 
    0.32546654f, 0.14864562f, 0.02995889f, -0.15920569f, -0.09918389f, 0.25340289f, 0.11293802f, -0.03544611f, 
    -0.14748874f, -0.02764285f, 0.01981601f, 0.01831039f, -0.07886878f, -0.05569294f, -0.20857289f, -0.07281095f, 
    0.04305131f, -0.14988650f, -0.02957150f, -0.01268374f, -0.02070672f, -0.02265559f, -0.03441983f, 0.11776411f, 
    0.01101470f, 0.14914814f, 0.15084913f, -0.05008654f, 0.16089362f, 0.04350035f, 0.08969731f, 0.07207625f, 
    0.13006523f, 0.17815533f, 0.11646011f, 0.16961643f, 0.33459798f, 0.30104303f, 0.10814191f, -0.10948736f, 
    -0.08587259f, -0.03489628f, 0.11894546f, 0.20252234f, 0.28464919f, 0.11900034f, -0.07183070f, -0.03777151f, 
    0.16478945f, -0.24402836f, -0.28029764f, -0.06690022f, -0.16133539f, -0.10618718f, 0.10799754f, -0.13753685f, 
    0.02275329f, -0.14373633f, 0.03917316f, 0.07599079f, 0.07549295f, 0.38435563f, -0.09548398f, 0.06647813f, 
    -0.13641714f, -0.33657926f, -0.30093348f, -0.12344228f, -0.04261131f, 0.07286961f, 0.03618601f, 0.12320320f, 
    -0.28174484f, -0.16983369f, -0.06752373f, -0.07530174f, 0.12322741f, 0.00887739f, 0.01235257f, -0.02155275f, 
    -0.24588592f, -0.12569389f, 0.02934347f, -0.36699954f, 0.22664024f, -0.00402384f, 0.04426708f, -0.02265478f, 
    0.13648695f, 0.12217881f, 0.10208241f, -0.24606210f, -0.04590876f, -0.02068126f, 0.15062824f, 0.16622473f, 
    -0.20771268f, -0.28228745f, -0.01749107f, 0.00168510f, 0.07323353f, 0.01629355f, 0.05211037f, -0.02011034f, 
    0.09848137f, 0.08810975f, 0.09041343f, 0.00114819f, -0.31361601f, -0.07390117f, -0.03146895f, -0.01445921f, 
    0.00988780f, 0.07762703f, -0.23823750f, -0.05404079f, -0.08646023f, 0.24664424f, 0.07010476f, 0.02690803f, 
    -0.06349294f, 0.04420674f, -0.05848791f, -0.01362443f, -0.04058819f, 0.02308041f, 0.00860431f, -0.06119672f, 
    0.02740386f, -0.07023022f, 0.02249300f, 0.05312238f, 0.03604459f, -0.00489156f, -0.01410941f, -0.07060958f, 
    -0.06897690f, -0.02312045f, 0.01938746f, 0.01105979f, -0.06283686f, 0.04555356f, 0.04205564f, 0.03906620f, 
    0.01286408f, -0.02482859f, 0.05070479f, 0.05531133f, -0.05538987f, 0.05169148f, -0.03818800f, -0.07583106f, 
    -0.02950013f, -0.07077335f, 0.05473219f, -0.04714709f, 0.01940664f, -0.03919880f, 0.02498675f, -0.00389705f, 
    0.00170911f, 0.02977719f, -0.03665293f, 0.04220156f, -0.01133317f, -0.07693693f, -0.02104235f, 0.05695200f, 
    0.04807976f, -0.03140381f, 0.05948921f, -0.00739429f, 0.02606648f, 0.05820477f, 0.01605568f, -0.02685104f, 
    0.04349461f, -0.08191332f, 0.03342201f, -0.05087674f, 0.00437780f, 0.01127250f, -0.06502496f, -0.01361718f, 
    -0.07984606f, -0.03052301f, 0.04703353f, -0.02097600f, -0.05534440f, 0.04267744f, -0.05741582f, -0.04731226f, 
    -0.02161415f, -0.00118785f, -0.01210532f, 0.00550949f, 0.05313196f, 0.02863044f, -0.00115226f, 0.03271969f, 
    0.02092663f, 0.05185981f, 0.03661522f, -0.01988866f, -0.04348248f, 0.02727817f, -0.01418444f, 0.04333774f, 
    -0.08095562f, -0.01994032f, 0.01232310f, -0.02157187f, -0.02893482f, 0.01787140f, -0.04561804f, 0.03182410f, 
    -0.08102565f, -0.04241422f, 0.01884152f, 0.02767241f, 0.00795172f, -0.02873797f, 0.05136663f, -0.02995708f, 
    -0.01104083f, 0.02387318f, 0.01171409f, -0.04894819f, -0.08001399f, 0.03791362f, 0.05513848f, 0.00134323f, 
    -0.04975549f, -0.02084899f, 0.00489097f, 0.00764448f, 0.04130295f, -0.07377595f, 0.03276860f, 0.01774954f, 
    0.05220237f, -0.06313996f, 0.01129141f, -0.03412960f, -0.01738905f, -0.06815105f, -0.08112723f, 0.02173804f, 
    0.05741683f, -0.04199213f, -0.01283531f, -0.02105569f, -0.00389765f, 0.01376853f, -0.05540605f, -0.03394492f, 
    -0.01835587f, 0.00859384f, -0.06775124f, 0.00102809f, 0.05538720f, 0.01475738f, 0.05825814f, -0.03818825f, 
    0.03687189f, -0.02371479f, -0.02343119f, 0.02677124f, 0.05625218f, -0.07563286f, -0.07178465f, -0.04480815f, 
    -0.05605525f, 0.03220750f, 0.02854187f, -0.07510829f, -0.01280856f, -0.06169391f, -0.03005900f, -0.04237411f, 
    -0.05427180f, -0.02593587f, -0.02988378f, -0.00451838f, 0.01233023f, -0.07896242f, 0.00395355f, 0.01406446f, 
    0.04263479f, 0.02383307f, -0.03218827f, -0.04542378f, 0.00637173f, -0.07319219f, -0.03610405f, -0.03483440f, 
    0.03045460f, 0.01273197f, -0.04205463f, 0.03704517f, 0.03885361f, 0.04253178f, 0.05198183f, -0.05921638f, 
    0.00267988f, -0.01698642f, -0.02048590f, -0.07677396f, -0.07412349f, -0.07044131f, 0.06123868f, -0.03069025f, 
    0.02959718f, -0.08233628f, 0.06410518f, -0.23912916f, -0.01484295f, 0.01373298f, -0.04247104f, 0.09043833f, 
    0.08699250f, 0.04567920f, -0.00339285f, 0.02699875f, 0.04218025f, -0.12403648f, -0.12894684f, 0.00255569f, 
    0.00868708f, 0.06011143f, 0.02303863f, 0.03258316f, 0.03510707f, -0.04855822f, -0.09270313f, -0.12142988f, 
    0.04034066f, -0.01572393f, 0.11671311f, -0.14394814f, -0.09220714f, 0.01042844f, -0.00623516f, 0.04298451f, 
    0.11967044f, 0.03949258f, -0.01993816f, -0.04228756f, 0.02195503f, 0.31048241f, 0.27109569f, 0.41788942f, 
    -0.13937046f, 0.01503683f, 0.04656094f, -0.10759477f, -0.05296996f, -0.04726917f, 0.09501538f, -0.07158630f, 
    -0.15873447f, 0.09123818f, -0.29796091f, -0.08207826f, -0.02150321f, 0.08066516f, 0.00475973f, 0.12507340f, 
    0.04100262f, 0.16692607f, -0.08987869f, -0.01694664f, 0.09027348f, -0.13508542f, 0.16438708f, -0.11869553f, 
    -0.07988274f, 0.06790832f, -0.00573308f, 0.01511004f, 0.01226256f, 0.06993027f, 0.00012614f, -0.08979438f, 
    -0.00594582f, 0.11506081f, 0.28726169f, -0.01949163f, 0.06090919f, 0.06107210f, -0.05889451f, -0.09650613f, 
    0.15583380f, 0.16045748f, -0.05030240f, -0.05733017f, 0.08704001f, -0.07029638f, -0.14794874f, 0.06896648f, 
    -0.04823465f, 0.09889059f, 0.04152895f, 0.12592833f, -0.16999266f, 0.07651535f, -0.02812812f, -0.04975725f, 
    -0.10109059f, -0.03912074f, -0.05614261f, 0.12928443f, -0.13420188f, 0.00916495f, 0.18717256f, -0.08490075f, 
    -0.03651240f, -0.14188498f, 0.05846699f, -0.05712369f, -0.07988503f, -0.09553415f, 0.06150284f, 0.08051655f, 
    -0.03612947f, -0.05719217f, -0.09115916f, -0.21657068f, 0.02418398f, 0.14830491f, 0.16186349f, 0.09015726f, 
    0.18089414f, 0.11039021f, 0.02094329f, -0.05809985f, -0.08443659f, -0.07856467f, -0.04720971f, 0.03955268f, 
    -0.00458633f, 0.17579590f, -0.07370029f, -0.00535210f, 0.17947251f, -0.14266562f, 0.20292276f, -0.01199787f, 
    -0.02460511f, 0.12741618f, 0.06367102f, 0.16756818f, -0.03399217f, -0.10256039f, 0.04263664f, -0.10835551f, 
    0.04587438f, 0.03151914f, -0.07008629f, -0.03301270f, 0.02845382f, -0.05518095f, -0.02226836f, -0.08749363f, 
    0.05933844f, 0.01909803f, -0.06551608f, 0.16674624f, -0.01036910f, 0.09331596f, 0.20314959f, 0.00405141f, 
    -0.05232950f, -0.01859282f, -0.10617135f, 0.11357158f, -0.04358198f, 0.10945786f, -0.07848475f, -0.08092989f, 
    -0.25015292f, 0.05385043f, -0.01435023f, 0.16356541f, -0.03197451f, 0.08119307f, 0.02790102f, 0.10110661f, 
    -0.06363781f, 0.08667599f, 0.13637052f, 0.03318402f, 0.11934510f, 0.09857515f, 0.21289325f, -0.11354190f, 
    0.07593045f, -0.13280685f, 0.11949267f, -0.14180580f, -0.06034353f, -0.15326965f, -0.02937334f, -0.10732808f, 
    -0.17075621f, 0.00762317f, -0.03560368f, -0.13042113f, -0.26789102f, -0.08170939f, 0.10567948f, 0.12195667f, 
    -0.30244941f, -0.16961382f, -0.05073757f, 0.07156454f, -0.04951685f, -0.10070491f, -0.08159474f, -0.21590772f, 
    0.06396255f, 0.09174585f, 0.25894469f, 0.20743988f, 0.06919269f, -0.22134192f, -0.08501747f, 0.07530511f, 
    0.01583997f, 0.07768571f, 0.16198638f, -0.11720870f, 0.10265432f, 0.01426186f, 0.16744748f, 0.09253973f, 
    0.01457439f, 0.06577991f, 0.05232350f, 0.01627088f, 0.15922423f, 0.22861487f, -0.00290271f, 0.17814176f, 
    -0.14078644f, -0.20928617f, -0.04898435f, -0.06285659f, -0.10292419f, 0.03355138f, -0.09509668f, -0.09755750f, 
    -0.24674796f, -0.18262687f, -0.13350421f, -0.45284781f, 0.05773865f, 0.05159719f, -0.04196876f, 0.07247235f, 
    -0.07957464f, -0.04028634f, -0.10938022f, 0.03993500f, -0.06760748f, -0.01130040f, -0.04596414f, 0.22232871f, 
    0.20471080f, 0.10887322f, -0.00786037f, 0.00657950f, -0.02398198f, -0.13711414f, -0.12673521f, -0.13478328f, 
    0.14481807f, -0.02787961f, 0.04667766f, 0.08750873f, -0.00782311f, -0.05540888f, -0.04056439f, 0.05268324f, 
    0.27076012f, 0.19546109f, 0.06485048f, -0.05227592f, 0.05940251f, -0.41807804f, -0.41858974f, -0.20700045f, 
    -0.18393432f, 0.13984968f, -0.19540896f, -0.02596156f, -0.29094806f, -0.08991919f, 0.00262586f, -0.02646207f, 
    -0.10000910f, -0.08519974f, 0.03480237f, -0.10242570f, 0.12346320f, 0.12071250f, 0.07595307f, -0.13301146f, 
    0.02622920f, 0.07106819f, 0.00928577f, -0.09935092f, 0.23528910f, -0.09149976f, 0.13595361f, 0.07794978f, 
    0.12192978f, 0.03331987f, -0.02347067f, -0.02286382f, 0.03124348f, 0.14037696f, 0.06744839f, 0.02974080f, 
    0.04587340f, -0.07294923f, -0.17558102f, -0.29810619f, -0.10564043f, 0.14382949f, -0.16536680f, 0.00286900f, 
    -0.13081543f, 0.12280441f, 0.01188296f, -0.01839780f, 0.29508504f, 0.09297029f, 0.03514826f, -0.03969472f, 
    0.14723960f, 0.02234512f, 0.03848319f, 0.11090738f, -0.01339330f, -0.05321291f, -0.04146243f, -0.09242800f, 
    0.40775931f, 0.05153654f, -0.20347254f, 0.06757498f, 0.02829516f, -0.21663003f, -0.00339663f, -0.23790860f, 
    -0.02431400f, -0.11243547f, 0.09929387f, 0.24223991f, -0.13769285f, -0.01873681f, 0.03398484f, -0.05491151f, 
    -0.02161565f, -0.04102274f, -0.20217685f, 0.03204453f, -0.02122114f, 0.01913161f, -0.23897606f, -0.04056980f, 
    0.52360213f, -0.15680009f, -0.05649423f, 0.10631948f, -0.24889746f, -0.12969415f, 0.20365480f, 0.01373372f, 
    0.23099110f, 0.10689043f, -0.03467342f, -0.04369316f, -0.23748060f, 0.04310045f, 0.11319418f, -0.00634645f, 
    0.08913394f, 0.13842626f, 0.15576810f, 0.03198047f, 0.12908307f, -0.19592942f, -0.07962617f, -0.03506010f, 
    -0.07884479f, -0.08502887f, 0.16898648f, -0.08811984f, -0.14801133f, -0.07323862f, 0.00960399f, -0.06938665f, 
    -0.04946620f, 0.03030570f, -0.00397521f, 0.09391221f, 0.04131830f, -0.11341824f, -0.21665257f, -0.22721623f, 
    0.09453532f, 0.12847662f, 0.01730325f, -0.02798802f, 0.04050999f, -0.01929045f, 0.06468048f, -0.01195513f, 
    0.11448482f, 0.18165269f, 0.27746263f, 0.29836780f, -0.13380946f, -0.05566300f, -0.03860370f, 0.10554557f, 
    -0.09450296f, -0.00040552f, 0.00408059f, 0.04216289f, 0.48407194f, 0.34714419f, 0.02833107f, 0.24487264f, 
    0.03886008f, 0.08921592f, 0.05732256f, -0.14562412f, -0.01884884f, -0.03353968f, 0.03858749f, 0.02568148f, 
    0.15043965f, -0.00367765f, -0.08294304f, -0.12800823f, -0.00859588f, -0.04290066f, -0.05486591f, -0.12325633f, 
    -0.10673018f, -0.01338446f, -0.14050293f, -0.04627002f, -0.13075903f, -0.20219116f, 0.00644094f, -0.05348877f, 
    0.03795355f, 0.04851879f, -0.06592710f, -0.06796019f, 0.00152597f, -0.06236054f, 0.00536706f, -0.02774630f, 
    0.29598081f, -0.03515971f, 0.32429615f, 0.15203780f, -0.00747445f, 0.03676620f, 0.01549850f, 0.06354887f, 
    0.01277946f, 0.19640711f, 0.01458475f, -0.04291735f, 0.00545820f, -0.36046246f, -0.36476511f, -0.34017676f, 
    -0.19730547f, -0.03549823f, -0.15556060f, -0.11231986f, -0.03742630f, -0.04464988f, -0.02523257f, -0.19016124f, 
    0.02821857f, 0.14628260f, 0.13709067f, 0.00142706f, -0.08737972f, 0.06964675f, 0.10286842f, -0.06893114f, 
    -0.06272879f, 0.00773164f, 0.01281587f, 0.00968078f, 0.11716598f, -0.03312722f, 0.13909590f, 0.27242726f, 
    -0.07591267f, -0.11951540f, -0.06866724f, 0.04080662f, -0.06954384f, 0.06408888f, 0.00822117f, 0.04921330f, 
    0.25424290f, -0.08817805f, -0.25453892f, -0.21688068f, -0.24452204f, -0.05495241f, -0.02228188f, -0.13729854f, 
    -0.08125882f, -0.00884266f, 0.14172250f, -0.05105657f, 0.08522059f, 0.03592404f, 0.03550948f, 0.02827712f, 
    -0.09791919f, 0.10501625f, 0.00823684f, -0.03665021f, 0.02460512f, -0.02476086f, 0.00154333f, -0.04408722f, 
    -0.00889988f, -0.04543794f, -0.17922115f, -0.03154786f, 0.05942564f, -0.12562634f, -0.07903822f, -0.01912384f, 
    0.01749841f, 0.03671034f, 0.02588459f, 0.21478333f, 0.12896556f, -0.07516041f, 0.02535214f, -0.07225113f, 
    -0.05407549f, 0.02278995f, 0.13878427f, -0.12146380f, -0.09826977f, -0.02760040f, -0.20422278f, -0.19713846f, 
    -0.36444303f, -0.31077734f, -0.14328915f, -0.05348328f, 0.01208652f, 0.05707376f, 0.00226324f, -0.02408581f, 
    -0.08402884f, 0.05224003f, -0.00204676f, 0.00268966f, -0.06299108f, 0.31641302f, 0.24152881f, 0.18434490f, 
    0.03756462f, 0.02522397f, 0.05679958f, 0.11774802f, 0.06406982f, -0.01740398f, 0.14424314f, 0.11143970f, 
    -0.04187795f, 0.04614669f, -0.01615336f, -0.03961776f, -0.00945497f, 0.04370937f, -0.04431245f, -0.07105868f, 
    -0.02826575f, 0.04780200f, -0.05640110f, 0.05193545f, -0.04568163f, -0.05316225f, -0.07372102f, 0.01266731f, 
    -0.03501865f, -0.01880274f, -0.07387839f, -0.07554919f, 0.05876086f, -0.04863755f, -0.02021449f, 0.00019226f, 
    0.03516421f, -0.04852936f, -0.06294274f, 0.02359085f, -0.00410776f, 0.05282557f, -0.05844029f, -0.00827076f, 
    -0.05738550f, 0.01434099f, -0.04942728f, 0.04264949f, -0.04078940f, -0.01471463f, -0.00255984f, 0.05812763f, 
    -0.07462026f, 0.03567278f, -0.05967898f, -0.02734377f, -0.04003799f, -0.03844694f, 0.03396229f, -0.05714823f, 
    0.00066487f, -0.00689708f, 0.05209659f, 0.04865297f, -0.05251349f, -0.04732187f, 0.04778147f, 0.03071748f, 
    -0.02892315f, -0.02903846f, -0.04124842f, -0.02990732f, -0.03146694f, -0.05056109f, 0.03290561f, -0.04723182f, 
    -0.03905774f, -0.05034737f, -0.02609037f, -0.07514482f, -0.07102133f, -0.04909650f, -0.06101226f, -0.07468271f, 
    -0.07379445f, -0.02499435f, 0.05403676f, -0.06943166f, 0.06205632f, 0.06497121f, -0.04771120f, -0.06391852f, 
    0.00074211f, -0.06821900f, 0.01507670f, 0.03141861f, 0.00596823f, 0.01046743f, -0.00111349f, -0.02574563f, 
    0.06375962f, -0.01725412f, -0.08007637f, -0.01492528f, 0.03867509f, 0.04627832f, -0.03204883f, -0.05138351f, 
    -0.03698038f, 0.05166936f, 0.06351451f, 0.07204763f, 0.05879117f, -0.06321032f, 0.02712000f, -0.06824160f, 
    -0.05795072f, -0.06903584f, 0.03809502f, -0.00190216f, -0.01808771f, -0.00412562f, -0.04925133f, -0.01075171f, 
    -0.06177402f, 0.05365074f, -0.05158525f, -0.02762606f, -0.01487437f, -0.07785276f, -0.01165310f, 0.00966896f, 
    -0.02572558f, -0.02384608f, 0.02158464f, 0.04655077f, -0.07633396f, -0.03688175f, 0.06092981f, 0.04160721f, 
    -0.03871021f, -0.00047567f, -0.01210298f, -0.03292526f, -0.01110190f, -0.08099946f, -0.05876451f, -0.05779486f, 
    0.00930857f, -0.02327400f, -0.05167111f, 0.05789700f, -0.05650990f, 0.03098712f, 0.05835720f, -0.01999422f, 
    0.05863704f, -0.03517127f, 0.00992717f, 0.03565277f, -0.01548245f, 0.03549942f, -0.07165151f, -0.06799417f, 
    0.01890232f, 0.04473945f, 0.02605598f, 0.05956677f, 0.04422897f, 0.04286113f, -0.05934501f, -0.01542203f, 
    -0.00973232f, -0.03642417f, -0.06480860f, -0.05088619f, 0.03313282f, 0.04216674f, 0.04824035f, 0.01282090f, 
    0.04641578f, 0.05427160f, -0.01132890f, -0.07175124f, 0.00649380f, -0.03723803f, -0.05696507f, 0.01172381f, 
    0.00724110f, -0.03175275f, 0.02477249f, -0.05141447f, 0.03021267f, 0.05955808f, 0.04723375f, -0.03839994f, 
    -0.01866582f, 0.04370081f, -0.05720621f, 0.00402860f, -0.02090488f, 0.05161477f, -0.07136329f, 0.00435697f, 
    -0.02552763f, -0.08118165f, -0.00439712f, -0.25355425f, 0.00731525f, -0.00882179f, 0.03710087f, 0.06183147f, 
    0.04367640f, 0.08035911f, -0.11773114f, -0.07997814f, -0.03597207f, -0.12203018f, -0.17201850f, 0.02578263f, 
    -0.02262419f, -0.01588200f, -0.07690968f, -0.05572342f, 0.00852523f, -0.15287024f, -0.11708536f, -0.13441139f, 
    -0.26021683f, -0.06290320f, 0.00554316f, -0.20114844f, 0.07698278f, -0.05509208f, 0.02407912f, -0.11776496f, 
    0.00100820f, 0.03588127f, 0.04351311f, 0.12883389f, -0.45754731f, 0.02478598f, 0.34096739f, 0.20715530f, 
    0.00505022f, -0.16247725f, -0.02852217f, 0.01751654f, 0.01746213f, -0.08997305f, 0.17299840f, 0.09489045f, 
    0.13814560f, -0.13909476f, -0.10810654f, 0.14666350f, 0.09352993f, -0.02717724f, 0.15693352f, 0.02129413f, 
    -0.14441687f, 0.10593870f, 0.12040197f, 0.12693450f, 0.33166650f, -0.06442803f, -0.08704247f, -0.10632239f, 
    0.00407244f, 0.10039648f, 0.27937734f, 0.05451542f, 0.00329785f, 0.01228462f, -0.07308918f, 0.00575425f, 
    -0.22022092f, 0.37130439f, 0.38483194f, -0.29545808f, -0.05225532f, -0.04795950f, 0.08580317f, -0.00834549f, 
    0.14450173f, 0.15862721f, 0.02191032f, -0.07891168f, 0.17935187f, -0.13856006f, -0.02092810f, 0.12976825f, 
    0.07509042f, 0.11248340f, 0.06452478f, 0.12102375f, 0.05364877f, -0.05319349f, -0.00916439f, 0.00087659f, 
    -0.06473386f, -0.15316899f, -0.08837180f, 0.04937857f, 0.06942032f, 0.05460885f, -0.04383658f, 0.21909790f, 
    -0.03300862f, -0.11255374f, -0.07317549f, -0.01216424f, -0.28265116f, -0.32179573f, 0.10845371f, 0.14210406f, 
    -0.05784406f, -0.02186290f, 0.07162479f, -0.13927314f, 0.05523467f, 0.19269529f, 0.27523196f, 0.10541768f, 
    0.11366307f, -0.05026939f, -0.02248765f, 0.02968011f, 0.09730849f, 0.13025482f, 0.07103997f, 0.14828728f, 
    0.01375525f, -0.02920130f, -0.09085187f, -0.01624760f, -0.08829007f, -0.32988724f, 0.27537379f, -0.10464148f, 
    0.11707475f, 0.26223707f, 0.15940526f, 0.04488296f, 0.09011783f, 0.13875008f, -0.03897999f, -0.04174542f, 
    0.19242790f, 0.04713672f, 0.05046012f, -0.04709755f, 0.06789950f, 0.12345196f, 0.13348424f, 0.06947383f, 
    -0.08307992f, -0.05993527f, -0.02734639f, 0.08103552f, 0.02721945f, 0.05740229f, 0.30725208f, -0.23208596f, 
    0.00319386f, 0.07577765f, -0.04703235f, 0.29278475f, 0.04302191f, -0.03559396f, 0.09502947f, 0.10404190f, 
    -0.08950175f, 0.07328276f, 0.18709530f, 0.26175275f, 0.02409335f, -0.06227390f, -0.00331473f, 0.01296056f, 
    0.11526211f, 0.12595485f, 0.13540852f, 0.21355633f, -0.10305507f, 0.27195385f, -0.16560799f, -0.01642346f, 
    0.05489131f, -0.12519026f, 0.14050880f, -0.21226880f, 0.20044477f, 0.05776461f, -0.17677549f, 0.03460715f, 
    0.10488408f, 0.05292113f, 0.13937418f, 0.15188676f, -0.02967706f, -0.07458845f, -0.00046166f, -0.06319521f, 
    -0.06605163f, -0.00491864f, 0.01136201f, -0.02546678f, 0.01868139f, 0.13626494f, 0.07713354f, 0.17753798f, 
    0.08618808f, 0.02129375f, -0.03934812f, -0.09204937f, -0.07926255f, -0.05761390f, -0.09016879f, 0.05105820f, 
    -0.13866292f, -0.62096083f, -0.22855547f, -0.36444452f, 0.13900232f, 0.10185361f, -0.01420234f, -0.12423082f, 
    0.01715653f, 0.04117021f, 0.01899800f, 0.13727514f, -0.58220017f, -0.30309492f, -0.23296036f, -0.21131282f, 
    0.09999347f, -0.09531148f, 0.17658187f, 0.03759453f, 0.02086938f, 0.14982316f, 0.11340627f, 0.01276048f, 
    0.27614897f, 0.33323771f, 0.18062483f, 0.09642778f, -0.06996343f, -0.11350793f, 0.01488250f, 0.10723399f, 
    0.20784952f, 0.15192389f, -0.12343517f, 0.24827053f, 0.46834752f, 0.02800396f, -0.05806942f, -0.05011996f, 
    0.13857414f, 0.20284596f, 0.23663899f, -0.04586546f, -0.06736171f, -0.07624682f, -0.05466859f, -0.01504410f, 
    0.24555425f, -0.04218143f, -0.17111005f, -0.44765127f, 0.06834276f, 0.08955964f, 0.10426067f, 0.07321971f, 
    0.15755090f, -0.04195637f, -0.01116169f, -0.13498336f, 0.16871591f, 0.12928548f, 0.08185557f, 0.25941634f, 
    0.04011919f, -0.03861151f, -0.03639256f, 0.00656806f, -0.11981462f, -0.03214045f, 0.08372033f, 0.08585897f, 
    -0.26226926f, -0.08538492f, -0.04893954f, -0.23014189f, 0.18054955f, 0.16586360f, 0.04919621f, -0.22336939f, 
    -0.07418171f, -0.05744705f, -0.05665202f, -0.11705683f, -0.35806689f, -0.34878603f, -0.28554603f, -0.15468837f, 
    0.02728545f, 0.12377847f, 0.10341355f, -0.01509252f, 0.23219454f, 0.10070704f, 0.15512858f, 0.04584830f, 
    0.17361534f, 0.04703295f, 0.04141288f, 0.13485047f, 0.04014386f, 0.03164558f, 0.14997670f, 0.05708409f, 
    0.00482769f, 0.05224306f, -0.03941558f, 0.17160542f, 0.25450987f, -0.13429250f, -0.18621972f, 0.39637008f, 
    0.13844250f, 0.19533022f, 0.12417487f, -0.13729173f, -0.06510631f, -0.05424029f, -0.09530688f, -0.07573377f, 
    0.18875024f, 0.09991668f, 0.10277896f, 0.15181251f, -0.12858479f, -0.01138683f, 0.12855922f, -0.05331729f, 
    0.09327203f, 0.09900342f, 0.15049580f, 0.08766698f, 0.29311034f, 0.01505757f, 0.07513623f, 0.04412779f, 
    0.04788060f, 0.16883479f, -0.16879918f, 0.15441748f, 0.10536703f, -0.08753203f, 0.05164904f, -0.09338439f, 
    0.02781817f, 0.14336030f, 0.08650889f, -0.04477767f, -0.02115349f, -0.03448779f, -0.06967360f, -0.03024896f, 
    -0.18641719f, -0.15669118f, -0.12605819f, 0.01701823f, -0.16553052f, -0.38018519f, -0.03043468f, -0.19969012f, 
    -0.11935242f, -0.00995507f, -0.11744667f, 0.21044412f, 0.02117589f, -0.03006948f, -0.11090865f, -0.03285169f, 
    0.03905474f, -0.02163683f, -0.02778528f, -0.05541021f, 0.03969090f, -0.03382573f, -0.02466011f, -0.06970312f, 
    0.01410284f, 0.02650957f, 0.05294134f, -0.03365451f, -0.00226311f, -0.04735440f, 0.00980923f, -0.07041328f, 
    0.01418224f, -0.05339549f, -0.04769846f, 0.00708424f, -0.03561319f, 0.03014915f, -0.04353657f, -0.05308779f, 
    -0.01138193f, 0.00787255f, -0.00866565f, 0.03447432f, 0.01256767f, -0.01301012f, -0.05854223f, 0.01487027f, 
    0.00232058f, -0.06613187f, 0.03587499f, -0.06013225f, 0.00535193f, 0.02489249f, -0.01220868f, -0.06352182f, 
    0.04620555f, -0.07332418f, -0.06289126f, 0.01991302f, -0.00361952f, 0.05581905f, 0.02519529f, 0.02609200f, 
    -0.06495651f, -0.04162103f, -0.03014967f, -0.07026238f, 0.05117688f, -0.06033346f, -0.00729388f, 0.02551266f, 
    0.02909617f, -0.03720703f, -0.03470691f, 0.03397708f, 0.03320750f, -0.05709783f, -0.03631504f, 0.00502283f, 
    0.03073201f, 0.00958115f, 0.04970112f, 0.00429168f, -0.02391429f, -0.04711231f, 0.05644082f, 0.00730266f, 
    -0.00285363f, -0.03727436f, -0.00843094f, 0.01684514f, -0.03927264f, 0.00133863f, -0.04601402f, -0.00494344f, 
    0.04455409f, 0.00079440f, 0.06157316f, -0.04033870f, -0.06717990f, -0.07056459f, 0.05114496f, -0.07562169f, 
    -0.02069899f, 0.05651975f, 0.01425261f, -0.07126505f, -0.03016970f, 0.04377113f, -0.01648410f, -0.06449310f, 
    -0.02764889f, 0.03827725f, -0.00963795f, 0.00929792f, -0.02374527f, -0.00440550f, 0.01108019f, 0.04252408f, 
    0.00683618f, -0.02387127f, -0.05383416f, -0.03644960f, -0.07245108f, 0.00725563f, -0.06713904f, -0.04595647f, 
    0.01694986f, 0.02196890f, -0.02376423f, -0.00353988f, 0.00448591f, -0.06614090f, -0.02996614f, -0.04351507f, 
    0.04269816f, -0.07635501f, 0.04145756f, 0.06250741f, -0.05747686f, -0.04711075f, -0.01180949f, 0.05492008f, 
    0.02516120f, -0.05522555f, -0.07549647f, 0.02409612f, 0.05718317f, 0.00895215f, 0.02497019f, -0.05506405f, 
    -0.06074797f, 0.04836082f, -0.03360794f, -0.04626175f, 0.04077355f, -0.00065457f, 0.02993115f, -0.00093624f, 
    0.02782640f, -0.06390759f, 0.00925743f, -0.04707586f, -0.04410946f, -0.00755487f, -0.02270159f, 0.02634183f, 
    -0.03264171f, 0.00572769f, 0.03041195f, -0.02021153f, -0.01686564f, 0.03780276f, -0.03669839f, -0.01103447f, 
    -0.01594728f, -0.05412649f, 0.05399128f, -0.04206380f, 0.01508524f, -0.06377531f, 0.06526700f, 0.03179206f, 
    -0.03064073f, 0.01484088f, 0.02378124f, -0.07151010f, -0.03352461f, 0.00840608f, 0.00027019f, 0.06131836f, 
    0.04036110f, 0.02229320f, 0.00919386f, 0.04357457f, -0.04883721f, -0.07481563f, 0.03742611f, -0.02714952f, 
    0.06239529f, -0.06133098f, 0.00956498f, 0.04382863f, -0.01110143f, -0.00043550f, -0.05716808f, 0.02222066f, 
    0.00561858f, -0.10244635f, -0.16906396f, -0.06815013f, 0.11015134f, 0.06203922f, -0.06441960f, 0.04136124f, 
    0.11207318f, -0.06608965f, -0.04446585f, -0.04240328f, 0.03298684f, -0.06428413f, -0.10054486f, 0.25750127f, 
    0.01698898f, 0.03034503f, 0.02049653f, -0.04215277f, -0.07674348f, 0.08370893f, 0.03804582f, -0.19131292f, 
    -0.00144639f, -0.13957407f, 0.10173541f, -0.20897417f, 0.20412906f, -0.06578495f, 0.01099046f, -0.09947639f, 
    0.06029261f, 0.06418860f, 0.05775761f, 0.13456492f, -0.57901657f, 0.23095495f, 0.41793719f, -0.04449978f, 
    0.03122850f, -0.08531689f, -0.00594049f, -0.08359545f, 0.00121132f, -0.03581800f, 0.14442594f, 0.06038213f, 
    -0.13318947f, 0.26720372f, -0.06727962f, 0.17245977f, -0.12862945f, 0.05249234f, -0.10109260f, 0.19946538f, 
    0.19374192f, 0.03491624f, 0.05960418f, 0.02736847f, 0.28679854f, -0.17929761f, -0.09338743f, -0.17889123f, 
    0.01952643f, 0.14196242f, 0.09402158f, -0.00563802f, -0.15731412f, 0.05152244f, -0.11547305f, -0.08150805f, 
    0.17041837f, 0.09097715f, -0.05250430f, -0.14121532f, -0.00261242f, 0.04031193f, -0.00837606f, -0.01538362f, 
    0.06205539f, -0.07141045f, -0.10548288f, 0.00051316f, -0.07791989f, 0.17000464f, 0.06225872f, 0.38333914f, 
    -0.01047616f, 0.06997737f, 0.21558018f, 0.18082440f, -0.06871466f, -0.04938750f, -0.17606844f, 0.14512835f, 
    -0.26029533f, 0.01916096f, 0.06152107f, 0.01076245f, 0.00390399f, 0.04153212f, 0.05844064f, 0.16721879f, 
    -0.11954562f, -0.12230431f, -0.07193502f, -0.06381732f, -0.01437033f, 0.07836240f, 0.04970424f, -0.09148029f, 
    0.17221048f, 0.01824419f, 0.15647419f, -0.09722435f, 0.02145262f, 0.05093326f, 0.15346627f, 0.04964915f, 
    -0.17591846f, 0.22096395f, 0.01548376f, 0.14617585f, 0.29150024f, 0.12764236f, 0.09596537f, 0.12992610f, 
    -0.10907065f, 0.02449600f, 0.04714689f, 0.03520104f, -0.00799934f, -0.33795241f, -0.12133861f, 0.00519295f, 
    0.12026247f, 0.02929577f, 0.05156298f, -0.06576928f, 0.03808736f, -0.07071738f, 0.06758086f, -0.13988020f, 
    0.09563453f, -0.03391168f, -0.01893949f, -0.04980654f, -0.04741360f, -0.07779379f, 0.05833329f, 0.01392985f, 
    0.03280606f, -0.00431360f, -0.02464763f, -0.15983230f, 0.10869872f, -0.21463345f, 0.17092620f, 0.07201250f, 
    -0.09512924f, 0.15003482f, -0.22224084f, 0.31866726f, 0.17425999f, 0.00560316f, 0.05328410f, 0.11759031f, 
    -0.23054875f, 0.16513778f, 0.20008826f, 0.14094274f, 0.07629190f, -0.12478346f, 0.00514012f, 0.13786660f, 
    0.03650807f, -0.02129589f, 0.18033054f, 0.08275720f, 0.38006267f, -0.25538054f, 0.22515599f, -0.24848737f, 
    -0.06392200f, -0.03506336f, 0.22101784f, -0.14722104f, -0.06163336f, 0.03356352f, -0.11912919f, -0.01051540f, 
    -0.05692584f, -0.17414770f, 0.19656655f, 0.22475845f, -0.15388837f, -0.00620524f, 0.06940986f, -0.07477663f, 
    -0.13749951f, -0.08380485f, 0.02852727f, 0.04735913f, -0.02493626f, 0.03998937f, 0.01622699f, -0.08611935f, 
    0.05385714f, 0.02802186f, 0.07968227f, -0.12916027f, 0.10657485f, -0.04365730f, -0.03927097f, 0.09382296f, 
    0.12047739f, 0.17593826f, 0.19138995f, 0.01704435f, -0.12554815f, 0.08245955f, 0.01517316f, 0.06171082f, 
    0.06362417f, 0.00665993f, 0.05759735f, -0.07388915f, 0.24372157f, 0.23020947f, -0.16319117f, 0.05289730f, 
    -0.16165662f, 0.01510182f, -0.05795714f, -0.03436257f, -0.01179901f, -0.08232343f, 0.00238416f, 0.03670518f, 
    0.27820772f, 0.00787673f, 0.05960383f, -0.07438648f, 0.05334224f, -0.00515669f, 0.01857921f, 0.03910079f, 
    -0.03828952f, -0.08026385f, -0.03962960f, -0.02584266f, -0.16142239f, -0.00142545f, -0.05094092f, 0.09343158f, 
    0.15178652f, -0.01762209f, -0.00448189f, 0.07542334f, -0.06952766f, -0.05430377f, 0.02585610f, -0.11351169f, 
    0.14800039f, 0.10719550f, 0.29006878f, -0.04376010f, -0.04586450f, 0.08633614f, -0.03576272f, 0.04592530f, 
    0.07073392f, 0.03915048f, -0.01487757f, -0.05705216f, 0.21964251f, -0.18108873f, -0.02808500f, -0.10055341f, 
    -0.00399243f, 0.08668710f, -0.09275363f, 0.01361644f, 0.04719581f, -0.02198191f, -0.03442568f, -0.02726869f, 
    -0.14284636f, 0.01068884f, -0.05625421f, -0.05372478f, -0.14409964f, 0.10453906f, 0.11341827f, -0.02172908f, 
    0.00031315f, 0.01561600f, -0.01548771f, 0.02244009f, 0.14004409f, -0.07394519f, 0.02479404f, 0.07097491f, 
    0.02866882f, -0.05931619f, 0.00352633f, 0.01063487f, -0.01215834f, -0.02525181f, -0.00485921f, 0.06598298f, 
    0.43887734f, -0.25552350f, 0.13925986f, -0.25234997f, -0.17977431f, 0.01548215f, -0.06643560f, -0.00564838f, 
    0.01959244f, -0.13006341f, 0.09083071f, -0.04639423f, 0.12045866f, 0.01801510f, -0.21106145f, 0.14250897f, 
    0.10561439f, 0.05488612f, 0.03043981f, 0.02454475f, -0.02558437f, -0.06963822f, -0.04093472f, -0.05619470f, 
    0.16272430f, 0.09229401f, -0.10963400f, 0.15073848f, 0.14319664f, -0.05046579f, -0.04171371f, -0.15126778f, 
    -0.01329153f, 0.11882388f, 0.05722457f, 0.19098593f, 0.12465602f, -0.04643813f, 0.02268115f, 0.02134045f, 
    -0.05119758f, 0.03205870f, 0.11888962f, -0.05559443f, -0.02253478f, -0.12196241f, -0.16302831f, -0.08504421f, 
    -0.07250554f, -0.22510901f, 0.09796279f, 0.36214989f, -0.10806418f, -0.03822976f, -0.06687637f, -0.12352698f, 
    -0.02974396f, -0.06301335f, 0.04392568f, 0.06275761f, -0.16195552f, 0.27650839f, 0.08698513f, -0.21385337f, 
    -0.06566120f, 0.07071238f, 0.02066818f, 0.25692222f, -0.03583799f, -0.12262168f, 0.03879417f, 0.04452199f, 
    0.03516190f, 0.06673836f, -0.12879720f, -0.23664175f, -0.02857863f, -0.09433948f, -0.05460488f, -0.02309325f, 
    -0.08090358f, -0.02191615f, -0.03242049f, -0.14130861f, 0.00999416f, -0.11596453f, -0.04574753f, -0.04096138f, 
    0.03887665f, 0.07624789f, -0.01888977f, 0.07229315f, 0.15025876f, 0.08593749f, 0.07828090f, -0.08150932f, 
    -0.04622446f, 0.01084030f, 0.22964217f, -0.08386675f, 0.01356604f, -0.03697832f, -0.01857796f, 0.02781767f, 
    -0.03240684f, 0.10169808f, 0.01026625f, 0.07290803f, -0.29227665f, 0.05140341f, 0.13598694f, 0.05516017f, 
    -0.16350982f, -0.05405672f, -0.00191691f, 0.04834937f, -0.02745171f, -0.06931336f, 0.05519757f, 0.13660119f, 
    -0.07326986f, -0.24444644f, -0.20145661f, -0.07787977f, 0.12141133f, 0.08077043f, -0.09950903f, 0.16146606f, 
    0.04818195f, -0.02966911f, 0.09338536f, 0.17885374f, 0.11649411f, 0.07521019f, -0.21030925f, 0.18854360f, 
    0.19334680f, 0.12530428f, 0.00403413f, 0.12066813f, -0.11798017f, -0.05269896f, -0.05865256f, -0.01378849f, 
    0.03691725f, 0.04947224f, 0.31281456f, -0.13751395f, 0.07260216f, 0.07332364f, 0.09890651f, 0.05561546f, 
    0.01840140f, -0.14747208f, -0.09821948f, -0.10579886f, -0.04259086f, -0.16021155f, -0.18398120f, 0.06643865f, 
    -0.04835708f, 0.23684290f, 0.00921982f, -0.02312059f, -0.00745716f, -0.05717180f, -0.11311971f, 0.14429016f, 
    0.00227252f, -0.24421823f, 0.04473983f, 0.15128669f, -0.04358269f, -0.03232341f, -0.03250036f, 0.08173830f, 
    0.05460418f, 0.00028438f, -0.14730571f, -0.07707584f, -0.05192616f, -0.17166236f, 0.36990100f, 0.05955341f, 
    0.02487692f, 0.03912100f, 0.08998253f, -0.08253611f, 0.02567526f, 0.07519856f, 0.12312131f, 0.12468010f, 
    0.11202789f, -0.04555063f, 0.01245730f, -0.29299670f, 0.11098956f, 0.17478395f, -0.00965199f, 0.06344137f, 
    -0.06558648f, 0.01967448f, 0.16627701f, 0.02898715f, 0.29116505f, -0.16323200f, 0.09228913f, 0.02857261f, 
    0.02396928f, -0.06706354f, 0.09818508f, 0.02530133f, -0.05446440f, 0.00426619f, -0.05400519f, -0.12848827f, 
    0.16707590f, -0.11453321f, -0.16478488f, -0.10793152f, 0.01705838f, 0.00489432f, 0.01947908f, -0.02912540f, 
    -0.04071492f, 0.04183355f, 0.03378312f, -0.02024554f, -0.00848032f, 0.20033585f, 0.16043974f, -0.14515552f, 
    -0.05718189f, 0.08809812f, -0.17805287f, 0.09498720f, -0.06688046f, 0.01066443f, -0.02852537f, 0.04112421f, 
    -0.05055052f, -0.33403057f, -0.06919426f, 0.17065085f, -0.05268284f, -0.09568085f, 0.01188148f, 0.07560930f, 
    0.22336191f, 0.02469783f, 0.07626075f, 0.14910343f, -0.32169893f, 0.10276585f, 0.04315660f, -0.17133702f, 
    0.20740399f, -0.06302669f, 0.18815680f, -0.28551161f, 0.16342694f, 0.01867837f, 0.09602906f, -0.03763664f, 
    -0.01092474f, 0.05230684f, -0.01668318f, -0.01537149f, -0.02734940f, -0.01910003f, -0.06367005f, 0.02129705f, 
    0.02523832f, -0.02699078f, 0.04568513f, -0.02493380f, -0.03499303f, 0.05692228f, -0.03196289f, 0.01807622f, 
    0.03968263f, 0.01991795f, 0.04340506f, -0.04194782f, -0.04476933f, -0.02164849f, -0.06050893f, 0.02537228f, 
    -0.04211219f, 0.06111469f, -0.06922834f, 0.00130528f, 0.05346362f, 0.00006732f, 0.05360223f, -0.06263381f, 
    0.01847334f, 0.04733516f, -0.01813768f, 0.06597137f, -0.01346394f, -0.05113697f, 0.05811764f, -0.04102578f, 
    0.00966877f, -0.05829237f, -0.01020608f, -0.04655355f, -0.01016086f, -0.06397425f, -0.05827408f, -0.00367755f, 
    0.02902794f, -0.02768065f, 0.00876794f, 0.03423861f, -0.07487087f, -0.01804070f, 0.05808884f, 0.00361297f, 
    -0.05000363f, 0.06721822f, -0.03191000f, -0.05848420f, -0.01737042f, 0.02034286f, -0.07931530f, 0.05499600f, 
    -0.07244956f, 0.05240755f, -0.03108573f, 0.04721154f, -0.06208402f, -0.06227731f, -0.06624642f, 0.01084755f, 
    -0.06300233f, 0.06019506f, 0.04739058f, 0.05034554f, -0.02642452f, -0.02132810f, -0.07099136f, -0.02677415f, 
    -0.06256125f, -0.01388954f, -0.02510870f, -0.04577539f, 0.00626590f, 0.06573730f, 0.01027181f, -0.02525107f, 
    -0.05997280f, -0.06808086f, -0.00048596f, 0.00669781f, 0.02470468f, 0.04508116f, -0.03690646f, -0.04710156f, 
    0.03046825f, 0.05113037f, -0.07892264f, 0.01328688f, -0.04376479f, -0.01512698f, 0.02919363f, -0.06908150f, 
    -0.03366446f, 0.01258679f, 0.00721764f, 0.03763407f, -0.06496008f, -0.00116626f, 0.04291525f, 0.04469535f, 
    -0.01555357f, -0.04000109f, 0.00273918f, -0.06538669f, -0.06188201f, 0.04592421f, -0.05112920f, 0.01630656f, 
    -0.04626168f, -0.00866790f, 0.02703193f, -0.06323590f, -0.05474013f, 0.02339220f, 0.02135371f, -0.03715379f, 
    -0.01569224f, -0.01494526f, -0.02169618f, 0.00283873f, -0.02218581f, -0.02154691f, -0.02880468f, -0.03675093f, 
    0.01664257f, -0.00662532f, 0.03252796f, 0.00629795f, -0.02774294f, 0.05554233f, -0.00421543f, 0.00330176f, 
    -0.00788700f, 0.03476894f, -0.03063315f, 0.06494427f, -0.04604251f, 0.01733412f, -0.04126883f, -0.02697611f, 
    0.03687705f, 0.01218676f, -0.06304241f, 0.04158406f, -0.02047277f, -0.04564039f, -0.01190263f, -0.07286941f, 
    -0.02547709f, 0.06250983f, -0.01550559f, 0.03695293f, -0.07959855f, -0.04376127f, 0.01799104f, 0.00513989f, 
    -0.04033902f, 0.06057854f, 0.01553120f, 0.05383979f, -0.00277076f, 0.01925344f, -0.07156584f, -0.05388762f, 
    0.03426913f, -0.04770277f, 0.02109810f, -0.07447092f, 0.01691070f, 0.00975993f, -0.01758493f, -0.02311458f, 
    0.02158020f, -0.04727938f, 0.05966858f, -0.04398093f, 0.06130839f, -0.06690259f, 0.05154207f, 0.06779507f, 
    -0.02901410f, -0.06453481f, 0.03059461f, -0.06822835f, -0.05615159f, 0.00479276f, -0.05509421f, -0.05975279f, 
    -0.05856813f, -0.06706071f, 0.01296077f, -0.02191669f, -0.06672252f, 0.01855667f, -0.04671565f, 0.01452272f, 
    -0.10755276f, 0.02119794f, -0.00099907f, -0.08044133f, 0.01355450f, -0.07751037f, 0.01867612f, -0.06678713f, 
    -0.01537481f, -0.08189060f, -0.03316066f, 0.01873431f, -0.06507922f, 0.00387553f, -0.01033838f, -0.04655240f, 
    -0.08719044f, -0.06096669f, -0.06048958f, -0.06517461f, -0.01954085f, -0.09079947f, -0.01939488f, -0.07958379f, 
    0.02544619f, -0.07133204f, 0.02283870f, 0.02041738f, -0.01425220f, -0.07343226f, -0.00193877f, 0.02898826f, 
    -0.09310707f, -0.01838752f, -0.03686905f, -0.07683652f, -0.07282739f, 0.02736139f, -0.00679948f, -0.06339878f, 
    -0.05202119f, -0.03995562f, -0.00351878f, -0.06989200f, 0.00480294f, 0.01172841f, 0.00480163f, -0.00763821f, 
    -0.00445194f, -0.07849478f, -0.00971427f, 0.02052422f, -0.00354719f, -0.08911922f, 0.02689084f, -0.05774544f, 
    -0.02768931f, -0.04865405f, -0.00516213f, -0.03611409f, -0.00186314f, -0.01697058f, -0.02774705f, -0.03245332f, 
    -0.01311072f, 0.01798015f, -0.09463052f, -0.07310688f, 0.01319259f, -0.01448994f, 0.03426930f, 0.00479426f, 
    -0.02029361f, -0.00891562f, -0.07537270f, -0.04271191f, -0.03631800f, -0.00703662f, -0.01517091f, -0.02260425f, 
    -0.02557597f, -0.03141185f, 0.03864551f, -0.01239414f, -0.07949544f, 0.03479107f, 0.01661603f, -0.06979033f, 
    -0.07294314f, -0.06111383f, -0.08673299f, 0.01316566f, 0.00349639f, -0.03349607f, 0.04540099f, -0.02860793f, 
    -0.02195019f, 0.06528061f, 0.03142201f, 0.05544421f, -0.01115032f, -0.00403199f, 0.02487288f, 0.05915485f, 
    -0.00502790f, -0.08699297f, 0.04954735f, 0.04551895f, -0.08540703f, -0.08251443f, -0.06620999f, -0.00425173f, 
    -0.03358824f, -0.07161867f, -0.08898295f, 0.01299358f, -0.06235574f, -0.04408289f, 0.00355858f, -0.05790146f, 
    -0.05609390f, 0.01813968f, -0.06879742f, -0.05621510f, 0.03871564f, -0.07947072f, -0.09172373f, -0.05541733f, 
    -0.01524776f, 0.02323197f, -0.02469883f, 0.03124684f, 0.02096890f, -0.03131438f, 0.00822981f, -0.04669429f, 
    -0.00942421f, -0.07071163f, -0.03800997f, -0.00243860f, -0.07341786f, -0.05029008f, -0.03582523f, -0.07697482f, 
    0.01431075f, -0.07444191f, 0.02580382f, -0.04754512f, 0.04420621f, -0.03228611f, -0.04841161f, 0.01943703f, 
    -0.07241160f, 0.02979766f, -0.06896880f, -0.06417363f, -0.00448217f, -0.00113379f, 0.00995689f, -0.05367460f, 
    -0.08324292f, 0.04232601f, -0.06743624f, -0.01069049f, 0.01778695f, -0.02237364f, -0.01355434f, -0.09494285f, 
    -0.09500495f, -0.00918628f, 0.02141313f, -0.00967592f, 0.01164822f, 0.02905753f, -0.00538455f, -0.10403727f, 
    0.00498177f, -0.06175211f, -0.02930475f, -0.07067043f, -0.03326284f, -0.01349288f, -0.05605878f, -0.05012855f, 
    0.05184793f, 0.00118226f, 0.01509277f, -0.02000827f, 0.01016165f, -0.00524475f, 0.00249351f, -0.04562216f, 
    0.01727475f, 0.00429161f, -0.03203646f, 0.05980155f, 0.04181886f, -0.01530484f, -0.06881405f, -0.00429553f, 
    0.05366457f, -0.02190895f, -0.00007521f, -0.07576144f, -0.06739315f, 0.00718074f, -0.04732356f, 0.04543142f, 
    -0.07161631f, -0.00101178f, 0.01626625f, 0.02134291f, -0.06560773f, -0.06144788f, -0.06109012f, 0.03035294f, 
    -0.06011100f, -0.04545345f, -0.07017696f, 0.04211320f, -0.05805214f, 0.05044852f, 0.00745674f, 0.04345335f, 
    -0.05937504f, 0.04392835f, 0.01486433f, -0.01756466f, -0.07935087f, -0.01824220f, -0.05642222f, -0.08148640f, 
    -0.01137808f, 0.04455893f, 0.04210721f, 0.04333536f, 0.00762504f, 0.04418417f, 0.05170197f, 0.01871530f, 
    -0.02893693f, 0.06065960f, -0.07526997f, 0.01375883f, 0.03062325f, 0.03772134f, -0.05321599f, 0.02121888f, 
    -0.03475840f, 0.05495039f, -0.02471063f, 0.06100167f, -0.08180907f, 0.03332663f, -0.05581715f, -0.04441240f, 
    0.04040893f, 0.04252421f, -0.04659673f, 0.04549284f, 0.03124965f, 0.05826365f, 0.04932849f, -0.06247346f, 
    -0.01518912f, -0.05215481f, 0.01110646f, 0.03164409f, -0.05616374f, -0.03091830f, 0.02456884f, -0.04525251f, 
    0.04466660f, -0.04490851f, 0.04510894f, -0.07515446f, 0.04391044f, -0.02626262f, 0.01781609f, 0.06201999f, 
    -0.06992265f, 0.04400294f, 0.05322430f, 0.01769447f, -0.06239053f, -0.06907803f, 0.00457165f, -0.04327126f, 
    0.05444903f, 0.00203950f, 0.02998794f, 0.05096743f, -0.06745584f, -0.05987540f, -0.06803770f, 0.04169676f, 
    -0.02073176f, -0.02881445f, -0.01507507f, -0.01866560f, 0.02499269f, 0.03972878f, -0.03246325f, -0.00589535f, 
    -0.05850568f, 0.01775420f, -0.00830898f, -0.02701870f, 0.05697808f, 0.03210012f, 0.01979952f, -0.02097882f, 
    -0.06555934f, 0.00878092f, 0.04052826f, -0.07800104f, -0.06881873f, 0.02117026f, -0.05556069f, 0.02671601f, 
    0.01974799f, 0.05988193f, 0.03155247f, -0.00955465f, 0.03758461f, 0.05730662f, -0.01663021f, 0.05968049f, 
    -0.02337602f, -0.03794097f, -0.02125412f, -0.02459461f, 0.02504362f, -0.01775841f, -0.07399210f, -0.08100233f, 
    -0.04346149f, -0.03843268f, 0.04939854f, 0.04198502f, 0.03211862f, -0.06655268f, 0.04788220f, 0.04805662f, 
    0.00510823f, 0.05052694f, -0.07941580f, -0.00797357f, 0.00700346f, -0.02742970f, -0.06682102f, -0.06732515f, 
    -0.05283806f, -0.05076718f, -0.06141149f, -0.05123623f, 0.00966053f, -0.03844627f, -0.04582680f, 0.01943500f, 
    0.05789662f, -0.06134542f, -0.04940824f, -0.08208622f, 0.04585372f, -0.02583906f, 0.02992237f, -0.04336406f, 
    0.10968616f, 0.06413789f, 0.02674523f, 0.06086519f, 0.03396604f, -0.02788785f, -0.13137425f, -0.08322188f, 
    0.09799296f, -0.05504540f, 0.00042174f, 0.13962245f, -0.06047973f, 0.01951502f, 0.13286343f, 0.01447020f, 
    -0.12887439f, -0.08749008f, -0.25441971f, -0.19631450f, -0.10206619f, 0.04871532f, 0.04381948f, 0.13887978f, 
    0.04212886f, 0.02283385f, -0.05528421f, 0.29557109f, 0.16065912f, 0.19902268f, -0.10559545f, -0.01321760f, 
    0.02865913f, -0.09239987f, -0.05798784f, -0.00112963f, 0.05464438f, -0.06217287f, -0.05957185f, -0.17202383f, 
    0.14745994f, 0.10306366f, 0.09403367f, 0.11561682f, 0.12719850f, 0.08625748f, 0.04857594f, 0.01219211f, 
    0.04118176f, 0.32008156f, 0.26977399f, 0.32203573f, 0.02255175f, 0.05315112f, -0.06184114f, -0.21262704f, 
    -0.05717283f, 0.01117562f, 0.00759307f, -0.01686911f, -0.04146085f, -0.10402004f, 0.08045322f, -0.03162501f, 
    -0.02345432f, -0.08783326f, 0.03970261f, 0.04260693f, -0.01794900f, 0.01566767f, -0.05439330f, 0.06951318f, 
    -0.07275866f, -0.25800225f, -0.32647073f, 0.27305186f, 0.17751099f, 0.13839434f, 0.07562132f, -0.04549635f, 
    -0.01757216f, 0.08604713f, 0.06447368f, 0.13093065f, -0.10035639f, 0.24832880f, 0.15838943f, -0.03947352f, 
    0.00501294f, -0.19621226f, -0.02196106f, -0.04634524f, 0.00372094f, -0.03509186f, -0.09336925f, -0.02807036f, 
    0.03200800f, -0.02167388f, -0.00799703f, -0.02640865f, 0.24745469f, 0.09012364f, 0.08501731f, 0.00937754f, 
    0.01233602f, 0.09864194f, 0.17145994f, 0.03203771f, 0.06058617f, 0.29841098f, -0.01727773f, -0.02465463f, 
    -0.05793651f, 0.03215494f, 0.04750321f, 0.16815108f, -0.08034158f, -0.01820917f, -0.06403144f, -0.04646403f, 
    -0.15364490f, 0.22948571f, 0.04108488f, 0.32364312f, -0.03501303f, -0.07110077f, 0.17511287f, -0.08338208f, 
    0.04392824f, 0.13165960f, 0.02308493f, 0.13945824f, -0.26206866f, 0.18900402f, 0.19775902f, -0.00620996f, 
    0.11300189f, -0.01688777f, -0.12284312f, -0.01319895f, -0.09048720f, 0.03638288f, 0.02386519f, 0.13667950f, 
    -0.12220030f, 0.15360822f, 0.23342492f, 0.00588412f, -0.21970361f, -0.01724025f, -0.04385121f, -0.08687917f, 
    -0.00813462f, -0.16660607f, -0.08887674f, -0.22800799f, 0.01868099f, 0.01023414f, -0.27318621f, 0.22983858f, 
    0.04707479f, 0.17113309f, 0.09456795f, -0.05060016f, 0.18546055f, 0.14115582f, 0.08640434f, 0.06750498f, 
    0.08227868f, 0.06988293f, -0.16892956f, -0.41571844f, 0.03325880f, 0.06396290f, 0.00666356f, -0.12380431f, 
    0.08434950f, 0.03911462f, -0.04532392f, -0.05823738f, 0.19556530f, -0.28360116f, -0.19256024f, 0.25763085f, 
    -0.02712872f, 0.05964672f, -0.05220288f, 0.16598071f, -0.00388427f, 0.13505431f, 0.15213916f, -0.11744799f, 
    0.01655687f, -0.02101745f, 0.02453726f, 0.00391312f, 0.00592722f, 0.03503559f, -0.06873363f, -0.04971615f, 
    -0.03079911f, 0.05348961f, -0.02671926f, 0.04823023f, 0.03771394f, -0.07033680f, 0.04249868f, -0.06513415f, 
    0.03310370f, -0.04286933f, 0.04459052f, 0.01857299f, 0.02334849f, -0.02086535f, -0.03266453f, -0.05921523f, 
    -0.01848847f, -0.05032321f, -0.02306659f, 0.02457205f, -0.05031477f, -0.06471031f, 0.02806872f, -0.06088769f, 
    -0.06672358f, -0.04793055f, 0.05908760f, -0.00224339f, 0.04624053f, 0.02361822f, -0.03733978f, -0.02317345f, 
    0.05605454f, -0.04577515f, 0.00610163f, 0.04052747f, 0.03977790f, -0.02523469f, 0.01553554f, -0.03967189f, 
    -0.08008555f, 0.01003424f, 0.00389403f, -0.04789934f, -0.06627005f, -0.00329894f, -0.02593381f, -0.03897787f, 
    0.04918539f, -0.03636311f, 0.05226465f, -0.00982405f, 0.03634150f, -0.04283089f, 0.05911802f, -0.02169843f, 
    -0.00810842f, -0.02069235f, -0.00834033f, -0.07960949f, -0.01423919f, 0.04988152f, 0.02338370f, 0.00530125f, 
    -0.01861855f, -0.05383716f, 0.05916472f, 0.05454588f, 0.04709426f, 0.01024463f, -0.06244959f, -0.01368039f, 
    0.03378090f, -0.07128046f, -0.01224903f, -0.04046789f, 0.01387385f, -0.06032462f, -0.03982820f, 0.01115340f, 
    -0.01515380f, -0.02283194f, 0.04172624f, -0.06688941f, -0.07931802f, -0.05005375f, 0.02714030f, 0.00394719f, 
    0.00583957f, 0.00828542f, -0.07225031f, -0.04320600f, -0.05705790f, -0.01525765f, -0.03850502f, -0.00291720f, 
    0.05792400f, 0.01512491f, -0.05841202f, -0.06753546f, -0.00570282f, -0.01180446f, -0.00852052f, -0.05413168f, 
    0.02157200f, -0.01454407f, -0.04057648f, 0.02150653f, -0.04572931f, -0.07404075f, -0.03124144f, -0.00251066f, 
    -0.06009406f, 0.02554942f, 0.03590455f, -0.00702797f, -0.04181464f, 0.03918879f, -0.02755761f, -0.01526645f, 
    0.03526653f, 0.04425698f, 0.05517520f, -0.02118794f, -0.07212742f, 0.00905177f, -0.03274493f, -0.00728619f, 
    -0.07764006f, -0.03091889f, 0.04789296f, -0.08416544f, 0.02416240f, -0.03961226f, -0.02345848f, 0.00307627f, 
    -0.04910903f, -0.00172137f, -0.06302667f, 0.02686854f, 0.04626399f, 0.04906633f, -0.07635874f, 0.04971689f, 
    -0.08034563f, -0.03189478f, -0.05558901f, 0.04027718f, 0.03692571f, 0.05719968f, -0.00812097f, 0.05764457f, 
    -0.01167853f, 0.06176155f, 0.05135760f, -0.02353371f, 0.05925233f, 0.04228989f, 0.03054453f, -0.03781803f, 
    0.05141556f, -0.02417241f, -0.03142986f, -0.03282795f, 0.01704769f, 0.03049704f, 0.01569274f, -0.05932276f, 
    0.05393058f, -0.02438448f, -0.02422890f, 0.00586213f, 0.00497164f, -0.01547908f, 0.05655460f, -0.05155198f, 
    -0.05444184f, -0.05860849f, -0.04914279f, -0.01202973f, -0.03810079f, -0.06448446f, -0.01879611f, -0.02897112f, 
    -0.26914266f, -0.23724371f, -0.12139436f, 0.25875750f, 0.09557679f, 0.11369524f, 0.02330665f, -0.13278171f, 
    0.11410037f, 0.04475677f, -0.04613905f, 0.01680773f, -0.03811276f, -0.15635175f, -0.15909863f, 0.04920430f, 
    0.11528948f, 0.01809566f, 0.08065549f, -0.05550893f, 0.15196924f, 0.09478924f, 0.06464084f, -0.00109018f, 
    0.26005486f, 0.43255869f, -0.07479990f, 0.01440049f, 0.02832294f, 0.04469581f, 0.18226005f, 0.20840465f, 
    0.03508820f, 0.01866173f, 0.01173735f, -0.01590896f, 0.12347971f, 0.09280746f, -0.14753982f, -0.16684553f, 
    0.03853125f, 0.05657188f, -0.18040226f, -0.04268030f, 0.03510994f, -0.14888537f, -0.01925253f, 0.03431688f, 
    0.25390550f, -0.29730839f, 0.02762544f, -0.10592577f, -0.08151381f, -0.15386361f, -0.01135969f, -0.09376527f, 
    0.02391884f, -0.07416763f, -0.14920406f, 0.01457340f, -0.09262265f, 0.33408341f, -0.30617967f, 0.15571615f, 
    0.21784553f, -0.04211241f, 0.07537242f, 0.09697287f, 0.14606255f, 0.04828114f, -0.07313661f, 0.09621563f, 
    0.25089505f, 0.34794107f, 0.43952861f, -0.24793743f, 0.02734613f, 0.01650322f, -0.01046643f, 0.04742203f, 
    -0.00642398f, 0.00146778f, 0.06485587f, -0.02563069f, -0.03979659f, -0.17585394f, -0.13627645f, -0.03206686f, 
    0.08342742f, 0.02779352f, 0.01252353f, 0.03444618f, -0.06762620f, -0.03262646f, -0.08290610f, 0.01232863f, 
    -0.06811861f, 0.07627510f, 0.05130371f, -0.09533862f, 0.07600266f, 0.09217795f, 0.08178188f, 0.19075415f, 
    0.19338600f, -0.07298323f, -0.03112524f, 0.05129541f, 0.19265789f, 0.24016406f, 0.16369298f, -0.15862502f, 
    0.16696493f, -0.02728697f, 0.08484548f, 0.03641789f, 0.00818391f, 0.09736660f, -0.04547353f, 0.05003214f, 
    0.01497371f, -0.32500902f, -0.05706077f, -0.18763424f, 0.13784499f, -0.07870963f, 0.05059270f, 0.00694091f, 
    -0.09703285f, -0.07651632f, 0.01568626f, -0.03495301f, 0.09988621f, -0.10081868f, -0.23523486f, 0.17130937f, 
    0.03118295f, 0.15284678f, 0.15369020f, -0.00040163f, 0.08480550f, -0.07488777f, -0.10094534f, 0.01206731f, 
    -0.15097828f, -0.22071575f, -0.10898047f, 0.07959969f, 0.01105557f, 0.03289713f, 0.13695395f, 0.08464831f, 
    -0.01487130f, -0.03671612f, -0.00206938f, 0.08678733f, -0.04382196f, -0.23851171f, -0.13253444f, -0.14482321f, 
    0.11756625f, -0.03212535f, -0.04075775f, 0.02396693f, -0.09954272f, -0.10283472f, 0.01138562f, 0.01811817f, 
    -0.08387506f, 0.11521537f, 0.16190888f, 0.36269194f, 0.08071787f, -0.11055983f, -0.11826844f, -0.13418572f, 
    -0.07694279f, -0.03980734f, -0.05402391f, 0.07258306f, -0.14513063f, 0.39146346f, -0.08837776f, -0.14861421f, 
    -0.03472376f, 0.06782003f, 0.06820154f, 0.17910270f, 0.15350375f, 0.14600758f, -0.14674614f, -0.02278356f, 
    0.09641023f, 0.23255996f, 0.03168377f, 0.27353528f, -0.03292756f, -0.03004786f, 0.05164785f, -0.10562699f, 
    -0.04669209f, -0.02499836f, 0.05737272f, 0.04803448f, 0.08353843f, 0.05159707f, 0.07917496f, 0.02154104f, 
    -0.00257699f, 0.02768528f, -0.04159524f, 0.03111605f, 0.00581314f, -0.08921621f, 0.02259589f, -0.06157422f, 
    -0.20825920f, -0.09452985f, -0.10111993f, -0.16113436f, 0.02671128f, 0.12454282f, 0.08407385f, 0.14113981f, 
    0.04521032f, 0.11592599f, -0.08365281f, 0.11505993f, 0.02807591f, -0.46291158f, -0.57136762f, -0.52770841f, 
    -0.11948665f, -0.02418825f, -0.07861049f, -0.01755062f, 0.06523023f, 0.04324942f, 0.04426397f, -0.05785618f, 
    0.26837403f, 0.08395800f, 0.29184482f, 0.00788385f, -0.10239858f, -0.04854180f, 0.00871847f, -0.06885645f, 
    0.06691717f, -0.09769373f, 0.04965691f, 0.17029536f, 0.07579204f, 0.12316293f, -0.09713261f, 0.19923109f, 
    0.17558242f, 0.13345096f, 0.11336781f, -0.00189913f, -0.12854263f, -0.00230942f, -0.02894537f, -0.10093831f, 
    -0.02614745f, -0.23155120f, -0.21637303f, -0.44738242f, -0.00510657f, 0.12312667f, 0.03339181f, 0.08884820f, 
    -0.01814875f, -0.05092070f, 0.02339251f, -0.03488929f, 0.18078610f, 0.20194225f, 0.11747713f, 0.21793877f, 
    0.07825466f, -0.00054918f, 0.02242136f, -0.04289497f, -0.00255225f, 0.00405948f, 0.00810361f, -0.06075409f, 
    -0.08685039f, -0.03815366f, -0.01990056f, -0.10509294f, 0.17719312f, 0.09481400f, 0.09255715f, -0.06719356f, 
    -0.00778760f, -0.04937719f, 0.06473258f, -0.00713254f, -0.19422530f, -0.24411435f, -0.11598169f, -0.16751304f, 
    0.02819651f, -0.01847721f, 0.09174077f, 0.04771063f, 0.11894061f, 0.04144385f, 0.00979397f, -0.14682920f, 
    0.19032449f, 0.03277174f, -0.01296952f, 0.10115872f, 0.02840280f, 0.10395731f, 0.04028482f, 0.10971077f, 
    0.09172546f, 0.00794689f, -0.00080046f, -0.03592047f, -0.00317152f, -0.00855528f, -0.18192765f, 0.30976617f, 
    0.21325746f, 0.10995855f, 0.01036203f, -0.07895053f, 0.01220830f, 0.01031399f, -0.02483656f, 0.07631596f, 
    0.18087851f, 0.12353653f, 0.15494680f, 0.25145626f, 0.02574347f, -0.00071846f, 0.02722346f, 0.04754952f, 
    0.13865440f, 0.06774030f, 0.11388218f, 0.06968582f, 0.05487402f, -0.06784911f, -0.14289834f, 0.05076559f, 
    0.18472335f, 0.06294113f, 0.11590650f, -0.05763161f, 0.00211444f, -0.08046242f, 0.06498339f, -0.05348630f, 
    0.22680952f, 0.10995718f, 0.12429994f, -0.06430887f, -0.00941296f, -0.01791727f, -0.06131005f, -0.11834014f, 
    0.07529092f, -0.06302094f, -0.05148347f, 0.02384382f, -0.24945851f, 0.03768489f, -0.00934470f, -0.04123401f, 
    -0.15039296f, -0.01922180f, 0.08301704f, 0.09777890f, -0.03546344f, 0.09150387f, 0.04926108f, 0.07927763f, 
    0.08972184f, 0.00278604f, 0.01373092f, -0.13034390f, 0.09529261f, -0.05703105f, 0.12828775f, -0.06488562f, 
    0.01250844f, 0.06674988f, -0.04988007f, 0.06831146f, 0.10453526f, -0.11216346f, 0.00760757f, 0.05542271f, 
    -0.01292836f, 0.09733600f, 0.01035547f, 0.03997683f, 0.04249702f, -0.06965511f, 0.05195178f, -0.02392476f, 
    -0.07273238f, 0.01923792f, 0.02664834f, 0.15759605f, 0.07727639f, 0.13119507f, -0.04032399f, -0.02151563f, 
    -0.11115682f, 0.04931480f, -0.02921203f, -0.02634622f, -0.03092841f, 0.05660810f, 0.13296586f, 0.05412155f, 
    -0.02149059f, -0.01016265f, -0.09974676f, 0.08813924f, 0.00218394f, -0.12342823f, 0.02033370f, 0.08970241f, 
    0.45963055f, 0.01467435f, 0.17287993f, 0.08466924f, -0.04108594f, -0.03541468f, -0.01131033f, -0.15817158f, 
    -0.03734994f, 0.14819071f, 0.10415227f, 0.04154866f, 0.18859684f, -0.04429426f, -0.00747627f, -0.06503955f, 
    0.12198302f, -0.00806038f, 0.00733403f, -0.05164770f, -0.02205588f, -0.15786543f, -0.00971979f, -0.00145939f, 
    -0.05305290f, 0.08810095f, 0.22980507f, 0.03427904f, -0.06317144f, 0.05166078f, 0.20116691f, -0.19665286f, 
    0.11976030f, 0.06331918f, 0.03427250f, 0.04362658f, 0.10067227f, -0.13058014f, -0.00951554f, -0.09110263f, 
    -0.03397268f, -0.03603858f, -0.15985237f, 0.00022860f, 0.03184826f, -0.05401412f, 0.08323731f, -0.10858715f, 
    -0.14055997f, -0.07079971f, -0.12934013f, 0.03356625f, 0.03086565f, 0.11368563f, 0.19675876f, 0.02842503f, 
    0.02181930f, -0.05589945f, -0.05572144f, -0.05524927f, -0.29468229f, -0.07175892f, 0.17711155f, 0.19771101f, 
    -0.07959376f, -0.08609062f, 0.06460544f, 0.14739902f, 0.09559532f, 0.05720073f, 0.17150454f, -0.02176475f, 
    0.18318684f, -0.09718335f, -0.01429051f, 0.04204659f, -0.01664091f, -0.15305813f, 0.07811207f, 0.01155748f, 
    0.01452740f, -0.00167678f, -0.02333927f, 0.06096610f, 0.00952046f, -0.16149816f, 0.24221893f, -0.18217373f, 
    -0.06301482f, 0.06561755f, -0.09124784f, 0.01329579f, -0.02910593f, -0.05648203f, -0.12407913f, 0.07424018f, 
    0.16378517f, -0.05434034f, -0.06767327f, -0.10165098f, -0.04363551f, -0.05610196f, -0.05228850f, 0.05604839f, 
    0.03860448f, -0.03015609f, 0.09821895f, -0.06916143f, 0.26537669f, 0.19034865f, 0.02234798f, -0.00020021f, 
    -0.03982393f, 0.03923232f, 0.32614914f, -0.16425106f, -0.01624646f, -0.11934344f, 0.03145925f, -0.07729154f, 
    -0.12165263f, -0.09538327f, 0.03653068f, -0.04829692f, -0.04770215f, -0.07986748f, -0.00603399f, -0.04639918f, 
    -0.09399767f, 0.02587005f, 0.06864996f, -0.01367909f, -0.06449299f, 0.20383148f, -0.20067982f, 0.06773870f, 
    0.05763854f, -0.09470900f, -0.06450386f, 0.17438413f, 0.05880727f, 0.16306455f, -0.00932276f, 0.07961750f, 
    -0.35083246f, -0.15248834f, -0.18609643f, 0.39449558f, 0.03104667f, 0.22732097f, -0.07343923f, -0.15968397f, 
    -0.02475886f, 0.06696337f, -0.04650060f, -0.09039546f, -0.10437982f, -0.08323525f, -0.01028531f, 0.13723990f, 
    0.02167870f, -0.02964036f, -0.03789165f, -0.16601172f, 0.01708833f, 0.02861683f, -0.00972029f, -0.14215824f, 
    0.18018121f, 0.30985680f, 0.03028431f, -0.06796524f, 0.12156975f, -0.05302168f, 0.14500725f, 0.13419573f, 
    0.07100525f, -0.03967563f, 0.04125299f, 0.09303724f, 0.16316196f, -0.09049278f, -0.31516603f, -0.28719541f, 
    0.14862342f, 0.17438954f, 0.06364375f, -0.07911116f, 0.09753178f, 0.07508422f, 0.07703767f, 0.01361708f, 
    0.04085922f, -0.21719241f, 0.13640070f, -0.05543012f, -0.05886450f, -0.05656575f, -0.04538551f, -0.03140145f, 
    0.09236635f, -0.10442055f, 0.07561549f, 0.03327098f, -0.03235391f, 0.20671329f, -0.28540415f, 0.30875847f, 
    0.09466513f, 0.00257117f, 0.16757296f, 0.11046886f, 0.09643354f, 0.09419759f, -0.09736864f, 0.09283896f, 
    0.35396948f, 0.09268659f, 0.00270550f, -0.17235279f, 0.00612144f, -0.02069132f, -0.05472361f, 0.14797495f, 
    -0.07341173f, 0.06791723f, -0.01323164f, 0.01160498f, -0.31954536f, -0.03247073f, -0.06895903f, 0.01445805f, 
    0.13336539f, -0.06942667f, -0.02463945f, -0.16954854f, -0.10354269f, -0.05820737f, -0.07859977f, -0.13087259f, 
    0.12239320f, 0.13255160f, 0.13733512f, -0.34751487f, 0.05630819f, -0.02761788f, -0.10032218f, 0.00033727f, 
    0.09502178f, -0.11141995f, -0.07389690f, -0.07909387f, 0.29974169f, 0.19138408f, 0.06077075f, -0.09848635f, 
    0.12388044f, 0.05632409f, 0.20033933f, 0.03096005f, -0.00470716f, -0.01951070f, -0.01513241f, -0.01321718f, 
    0.08831745f, -0.34109864f, -0.13927287f, -0.13819380f, 0.27651361f, 0.02050921f, -0.05001467f, 0.13919988f, 
    0.02812044f, 0.04130139f, -0.01994996f, -0.21055317f, 0.13092150f, 0.25568146f, -0.47188154f, 0.19472849f, 
    0.00463247f, 0.15666619f, 0.09324822f, -0.02767250f, 0.05481866f, 0.01496059f, -0.09465460f, -0.14542297f, 
    -0.12496766f, -0.12787454f, -0.07362183f, 0.14840282f, -0.09153572f, 0.08141235f, 0.23387024f, 0.13456288f, 
    -0.05240344f, 0.03866967f, -0.04264717f, 0.03829541f, 0.05811957f, -0.30613348f, -0.13190426f, -0.11662804f, 
    0.08464151f, -0.05897460f, -0.02913250f, 0.13892810f, 0.05151686f, -0.00982420f, -0.05329131f, 0.05740606f, 
    0.03235580f, 0.00522830f, 0.15594475f, 0.21715587f, 0.03495226f, 0.00490214f, -0.17801166f, -0.05547108f, 
    0.13918617f, 0.08681659f, 0.12193336f, 0.23365314f, -0.16867289f, -0.00179942f, 0.05046044f, -0.24705319f, 
    -0.03860484f, 0.02912046f, 0.08457936f, -0.00566894f, 0.11831233f, 0.02634029f, -0.14585724f, 0.08863386f, 
    -0.05109534f, 0.05152420f, 0.02951307f, -0.06557621f, -0.02243472f, 0.03894269f, -0.05901776f, -0.00430493f, 
    0.03447007f, -0.06783961f, -0.03876640f, 0.00357988f, 0.00887307f, -0.01962249f, 0.02551007f, -0.00792143f, 
    -0.04114040f, -0.02053848f, 0.03165244f, -0.02821650f, -0.02068069f, -0.00562647f, 0.01967382f, 0.01663130f, 
    -0.04074685f, -0.06031673f, 0.02869664f, 0.06413411f, 0.01743593f, 0.04136407f, -0.02559741f, -0.05550240f, 
    -0.06908356f, 0.05460935f, -0.04517194f, 0.03321538f, -0.02392934f, 0.03537315f, -0.06844984f, 0.00362379f, 
    0.00195342f, -0.04549864f, 0.00714679f, 0.03239031f, -0.05839855f, -0.01113344f, 0.02681828f, 0.03287857f, 
    -0.02273993f, -0.02150232f, 0.03193077f, -0.04267045f, 0.01295181f, 0.05691570f, -0.05986605f, -0.00582893f, 
    -0.07521585f, -0.07258518f, -0.03945976f, -0.06293887f, 0.04343519f, -0.00968232f, -0.06511664f, -0.06020795f, 
    -0.04160278f, 0.05426660f, -0.07613720f, -0.06521983f, 0.03652640f, 0.02267302f, 0.00027707f, -0.05873433f, 
    -0.00554104f, 0.02463858f, 0.00400062f, -0.05968954f, 0.01832698f, -0.03274208f, -0.02883715f, 0.02664318f, 
    0.05400863f, -0.05912190f, -0.03582424f, -0.00891036f, -0.07122488f, -0.06909969f, -0.03224324f, 0.03064193f, 
    -0.03442845f, -0.02495111f, -0.01863825f, 0.01667071f, -0.06553545f, -0.05480655f, -0.04422961f, -0.00460342f, 
    -0.05048624f, -0.07353369f, 0.03273826f, 0.04132541f, -0.01791173f, 0.00651704f, -0.01737141f, 0.02773496f, 
    -0.04293072f, -0.05488129f, 0.04916874f, -0.00334392f, -0.00684897f, 0.06659624f, -0.02538014f, 0.06261439f, 
    -0.06203001f, 0.00592970f, -0.07030653f, -0.05274042f, -0.04823226f, -0.06688585f, 0.04076780f, 0.04240899f, 
    0.01004529f, 0.05627305f, 0.03434183f, -0.00102580f, -0.01467270f, -0.01842172f, -0.06235968f, 0.06684283f, 
    -0.05380647f, 0.02423698f, 0.03908491f, 0.05312536f, -0.00956337f, -0.07110567f, -0.03665305f, 0.03395028f, 
    -0.02230103f, 0.05726989f, -0.02375454f, 0.06048312f, 0.02663265f, 0.00925053f, 0.00500696f, -0.04280365f, 
    -0.06470556f, -0.04393061f, 0.00229436f, -0.06334211f, 0.04801902f, -0.00903375f, -0.00231539f, -0.01078709f, 
    0.03704591f, 0.02481984f, -0.01601552f, -0.05952606f, 0.06603811f, 0.06178782f, -0.00503212f, 0.05869583f, 
    0.05834435f, -0.03104802f, -0.04490474f, -0.03057136f, 0.01481466f, 0.05374473f, -0.00104588f, 0.02102757f, 
    0.02290222f, -0.04373250f, -0.03015898f, 0.00712673f, 0.05037357f, -0.05713282f, 0.01468795f, -0.06696803f, 
    -0.06008149f, -0.06428386f, -0.03957279f, -0.07476614f, 0.05373266f, 0.02366843f, -0.06199170f, -0.02195589f, 
    0.04269816f, 0.01292236f, 0.03657294f, -0.03140076f, -0.07563562f, -0.04766249f, -0.04870519f, -0.05313381f, 
    0.07971875f, -0.09521639f, 0.19739389f, -0.03031727f, -0.05412592f, 0.00046321f, -0.08818325f, -0.12663731f, 
    -0.01307359f, -0.03228287f, 0.14260292f, 0.04194888f, -0.04507649f, 0.13890263f, 0.01712972f, 0.03932303f, 
    -0.20058221f, -0.11360395f, -0.17735097f, -0.08191048f, -0.07542453f, 0.18773267f, -0.08602226f, 0.03923990f, 
    0.16408372f, -0.32977471f, 0.00620023f, 0.09649169f, 0.08672566f, 0.03842806f, -0.01314747f, -0.06264243f, 
    0.04851165f, -0.03624485f, 0.00226062f, 0.08921678f, -0.03637898f, 0.08782926f, -0.05172376f, 0.08138998f, 
    0.11613126f, 0.07466535f, 0.22073141f, -0.02736856f, 0.05911316f, 0.21188882f, 0.04196652f, 0.04970884f, 
    0.08119454f, 0.36085525f, 0.14680064f, 0.19838466f, -0.03602702f, -0.11460318f, -0.02800397f, 0.01301358f, 
    0.12124711f, 0.09322451f, -0.03132641f, -0.01280618f, 0.40727985f, -0.15748885f, 0.13134836f, -0.35006002f, 
    0.02273239f, 0.05017693f, 0.16430649f, -0.02095048f, -0.09577886f, 0.02187353f, -0.07984105f, 0.08891629f, 
    -0.04896466f, -0.24924918f, -0.27187133f, 0.08666193f, 0.11629771f, 0.09561217f, -0.08580591f, 0.10496428f, 
    -0.08578042f, 0.08899799f, -0.10893890f, 0.02111741f, 0.27040249f, 0.29691762f, 0.16358387f, 0.23170649f, 
    -0.06475293f, -0.09084827f, 0.08895838f, -0.02144811f, -0.15846136f, 0.06298376f, 0.02276186f, -0.05029955f, 
    0.00363706f, -0.03282579f, -0.01444353f, -0.08805258f, 0.08206953f, 0.08903894f, 0.00938295f, -0.01943392f, 
    0.04150064f, -0.03388569f, -0.00057021f, -0.01564870f, 0.14668569f, 0.18738079f, -0.08818382f, -0.03597533f, 
    -0.01096939f, 0.07644180f, 0.14521047f, -0.04575285f, 0.04753356f, -0.05693774f, -0.01503395f, 0.05111630f, 
    -0.09246758f, 0.19029017f, 0.08421519f, 0.31572106f, 0.00749096f, 0.19272844f, 0.07893854f, 0.05409038f, 
    -0.00978659f, -0.07049490f, 0.12720841f, 0.10979819f, -0.39512399f, 0.05605913f, -0.03036560f, 0.01021147f, 
    -0.08587487f, 0.06133353f, 0.09778938f, -0.21228063f, -0.09422320f, 0.01555255f, -0.03376362f, -0.00934009f, 
    -0.07574148f, 0.05668583f, 0.04152800f, -0.07888401f, -0.13720080f, -0.05371739f, -0.12745021f, -0.11935779f, 
    -0.19107075f, -0.17182374f, 0.00430806f, -0.28440624f, 0.20542373f, -0.17080642f, 0.23989008f, 0.20625298f, 
    0.06229031f, 0.15662460f, 0.08284184f, 0.25911525f, 0.11456313f, 0.08769005f, 0.19698194f, 0.00552626f, 
    -0.14470720f, 0.05775023f, -0.16796748f, -0.32390112f, -0.02474109f, -0.05042259f, -0.01797756f, -0.06875455f, 
    0.12076360f, 0.08743569f, 0.07852393f, 0.00539750f, 0.10948487f, -0.58925378f, 0.06225407f, -0.09829132f, 
    -0.10127480f, 0.18765856f, 0.06033456f, 0.09029015f, -0.12011682f, -0.00082459f, -0.03765272f, 0.07027134f, 
    -0.01825636f, -0.01459882f, -0.23649171f, -0.07656338f, 0.13620049f, 0.05653384f, -0.01220071f, -0.15376636f, 
    -0.03160915f, 0.00987393f, -0.03318051f, -0.02214218f, 0.06393642f, -0.04815957f, -0.01482926f, -0.02656594f, 
    0.05418469f, 0.00247730f, -0.02652962f, 0.02817334f, -0.00162979f, -0.01663029f, -0.04494495f, -0.05003412f, 
    0.36096337f, 0.33167920f, -0.03617984f, 0.03792854f, 0.12127721f, -0.11854407f, 0.13193430f, 0.01452756f, 
    0.00199324f, 0.00096409f, -0.09829967f, 0.17581536f, 0.11995918f, 0.07675865f, -0.04603764f, -0.22461720f, 
    0.06644717f, 0.16782889f, 0.18745427f, 0.03444098f, 0.06070610f, 0.00460009f, 0.13712399f, 0.12689283f, 
    -0.00033749f, -0.25661567f, 0.14209528f, 0.02386659f, 0.00749400f, -0.06904563f, -0.04525140f, 0.00226516f, 
    0.14328958f, -0.14363496f, -0.05181161f, 0.09008624f, 0.05852782f, 0.04978672f, -0.16520357f, -0.08204743f, 
    0.00584937f, -0.20638168f, -0.14443411f, -0.18348794f, -0.01849546f, 0.03460380f, 0.01241350f, 0.04230981f, 
    0.55587196f, 0.30991700f, -0.00203447f, -0.14920156f, 0.08392806f, 0.13248515f, 0.06209022f, -0.01406138f, 
    0.04829086f, -0.02263007f, -0.03996357f, 0.03599800f, -0.09271505f, -0.07313936f, -0.15360026f, 0.07883722f, 
    -0.03091938f, -0.02800302f, -0.05800062f, -0.06719596f, 0.01377654f, 0.02792902f, 0.02685506f, -0.10450685f, 
    0.05955216f, 0.20219779f, 0.14626338f, -0.02019305f, 0.04240173f, -0.20125857f, -0.01909400f, -0.05142343f, 
    0.03796010f, -0.07166218f, -0.09962574f, -0.04930846f, 0.43029219f, 0.16637924f, 0.28241998f, -0.02101397f, 
    -0.02898814f, -0.06962995f, 0.10986113f, 0.13428763f, 0.07910044f, -0.06600966f, -0.09853435f, 0.13206232f, 
    0.19470243f, -0.24698663f, -0.24804097f, -0.07677447f, -0.02932738f, -0.00828025f, -0.00461216f, -0.01543617f, 
    -0.07878596f, -0.09829707f, 0.15234657f, -0.07093874f, 0.23748976f, 0.30589366f, -0.24968503f, 0.00064481f, 
    -0.15680063f, -0.17037590f, -0.01217655f, 0.02076751f, 0.03027613f, -0.00361817f, -0.02541629f, -0.04619947f, 
    -0.07845877f, -0.20677064f, -0.05310048f, -0.04954643f, -0.02534024f, 0.02368209f, -0.03360532f, 0.05994139f, 
    0.18120599f, 0.09822269f, 0.28188911f, 0.02951512f, 0.25064093f, 0.00214960f, -0.09055930f, -0.11945799f, 
    -0.04213421f, 0.10130055f, 0.07503182f, -0.16516741f, 0.09330709f, -0.04060518f, -0.11437040f, -0.00661639f, 
    -0.18286680f, -0.32541889f, 0.01319131f, -0.04842906f, -0.05053842f, -0.00604675f, 0.03477230f, 0.08477667f, 
    -0.04330470f, 0.06382457f, -0.10519461f, 0.02326702f, -0.15719999f, -0.03845670f, 0.06231270f, 0.01405992f, 
    -0.02948075f, 0.10357893f, 0.06372566f, -0.07080080f, -0.05212253f, -0.02956613f, -0.09946368f, -0.10450697f, 
    -0.10490716f, -0.08174038f, 0.02863450f, 0.02165070f, -0.15230739f, -0.06570283f, 0.06539910f, -0.05589836f, 
    0.00247961f, 0.00077752f, 0.01241890f, 0.12805484f, 0.05908819f, 0.04518198f, 0.02877619f, 0.00454289f, 
    -0.08000726f, 0.03649414f, -0.00377161f, -0.09204860f, -0.07270049f, 0.00477940f, 0.04238452f, 0.02669287f, 
    0.19031097f, 0.02153965f, 0.02578584f, -0.17935088f, 0.00549326f, 0.06389584f, 0.02547345f, -0.05491497f, 
    0.03548109f, 0.00739552f, 0.05646708f, -0.03774670f, 0.13290811f, 0.27863729f, -0.03807172f, 0.35816243f, 
    -0.05670445f, 0.13991989f, 0.06517577f, -0.00959565f, 0.11631484f, 0.13083979f, -0.00078811f, -0.03919170f, 
    0.26873216f, 0.27918765f, 0.06205234f, 0.21445078f, -0.10291327f, -0.10919634f, -0.03336174f, -0.03668711f, 
    0.06815145f, 0.06544299f, 0.04140188f, 0.13695981f, 0.03187777f, -0.12469494f, 0.05339309f, -0.35941309f, 
    0.11071195f, -0.07918488f, -0.05592788f, 0.04409507f, -0.07839169f, -0.07672390f, -0.01660403f, -0.06058978f, 
    0.06771091f, 0.08477151f, 0.10023592f, -0.18431240f, -0.01111053f, -0.03345979f, 0.02798558f, -0.01006914f, 
    0.09161080f, 0.09847083f, -0.09448976f, -0.09486637f, 0.30205685f, 0.04203100f, 0.20586278f, 0.15682589f, 
    -0.03692444f, -0.01827497f, -0.05217895f, 0.04296501f, -0.08874441f, 0.08597574f, -0.02665746f, 0.02835481f, 
    -0.24116515f, 0.06767490f, -0.06029182f, -0.05468614f, -0.12725188f, 0.03694816f, 0.15282764f, -0.11475447f, 
    -0.01899072f, -0.07298958f, -0.04237261f, -0.00957387f, 0.06557707f, 0.08639031f, -0.14867717f, -0.06279252f, 
    0.09625365f, 0.07457693f, 0.03646312f, 0.06868789f, 0.03793366f, 0.06369852f, 0.01711495f, 0.01473782f, 
    0.20472193f, -0.06473724f, 0.08755782f, -0.03876696f, -0.13643456f, 0.18140908f, -0.15390411f, -0.03007322f, 
    -0.04763377f, -0.04306418f, 0.01975871f, 0.00175140f, -0.30912730f, -0.00974664f, -0.26977643f, 0.11163890f, 
    -0.09099064f, 0.07288533f, -0.11165665f, -0.03688240f, -0.04233142f, -0.07225425f, 0.03342836f, -0.03580773f, 
    0.03282054f, -0.02072544f, -0.04022307f, 0.02319955f, -0.07313383f, -0.08494159f, -0.02138890f, -0.06367498f, 
    -0.00142926f, -0.02180585f, 0.02072840f, 0.06751018f, 0.17635877f, -0.14991413f, 0.07845731f, 0.16269048f, 
    -0.05232166f, 0.01459030f, 0.16320886f, 0.11868804f, 0.06662118f, -0.03227834f, 0.05213084f, -0.07027403f, 
    -0.15859486f, -0.12754096f, 0.18032740f, 0.34152758f, -0.00301164f, -0.06760587f, -0.05999973f, -0.01637583f, 
    -0.08800488f, 0.05190079f, 0.08230475f, -0.02121220f, 0.10631701f, -0.06229499f, 0.19082531f, -0.46546635f, 
    -0.18001311f, 0.01844741f, -0.02316449f, 0.21569438f, -0.07268967f, 0.00808227f, -0.14836071f, 0.11005718f, 
    0.03113047f, -0.06890646f, 0.01244116f, -0.02151989f, -0.01392867f, 0.00774173f, 0.02607312f, -0.04160559f, 
    0.07071812f, -0.03386977f, 0.05204494f, -0.02885584f, -0.05577760f, 0.04612239f, -0.06773899f, -0.01516229f, 
    -0.00027035f, -0.06691230f, 0.02177561f, 0.02378221f, 0.01356277f, 0.04886368f, 0.07078487f, 0.05741679f, 
    -0.01863523f, 0.00186865f, -0.06872676f, -0.05593349f, -0.03162409f, 0.04520384f, -0.05670889f, -0.03170313f, 
    0.02798134f, -0.06416524f, -0.06051698f, -0.00992070f, 0.06351050f, -0.04484111f, 0.01710382f, 0.01493463f, 
    0.06726118f, 0.00967687f, 0.04877167f, 0.02237578f, 0.07046699f, -0.01739192f, -0.03612773f, 0.06067422f, 
    -0.02441334f, -0.01599213f, 0.07156156f, 0.01451415f, -0.02853247f, -0.05670796f, -0.06952716f, 0.06221981f, 
    0.03783206f, -0.04729645f, 0.01073393f, -0.00518408f, 0.02486270f, 0.04970555f, -0.02203095f, -0.03931184f, 
    -0.05886177f, 0.01815315f, -0.02380330f, 0.03022816f, -0.05546079f, -0.04869477f, -0.07134829f, -0.04799146f, 
    0.06839731f, 0.04348072f, -0.06262334f, 0.02584887f, 0.02322464f, -0.02896482f, -0.00056096f, 0.01555511f, 
    -0.05242620f, 0.02044774f, -0.05562750f, -0.05116619f, -0.00782071f, 0.02327552f, 0.02557779f, -0.00007082f, 
    0.03962562f, 0.02331725f, 0.01239415f, -0.05081684f, 0.02533663f, 0.04081023f, -0.05421895f, -0.04583902f, 
    0.07075574f, 0.00822709f, -0.06967683f, 0.05094992f, -0.01381427f, -0.04371413f, -0.00682680f, -0.03015472f, 
    -0.01621054f, -0.06285462f, -0.05329563f, 0.06285516f, 0.04785815f, -0.06214619f, 0.06301077f, -0.06394735f, 
    -0.02064667f, -0.01095055f, -0.00320415f, 0.02719437f, -0.05635575f, -0.05560407f, 0.02068893f, 0.03231366f, 
    0.02758499f, -0.00435099f, -0.02366403f, -0.02557562f, -0.00803358f, -0.04959191f, 0.02504964f, -0.05840322f, 
    -0.02977144f, -0.06051591f, -0.05577685f, -0.02794294f, 0.02059995f, 0.00370306f, -0.03717166f, -0.03619651f, 
    -0.00722060f, 0.03503840f, -0.06463794f, 0.06427161f, -0.02428849f, 0.03911073f, -0.05365984f, -0.03769610f, 
    -0.00958642f, 0.05608412f, 0.02072159f, -0.01362454f, -0.04628739f, -0.04773785f, -0.01878830f, -0.01766721f, 
    -0.05102399f, -0.06891135f, 0.02106153f, -0.03384813f, 0.06508248f, -0.02043513f, 0.00125209f, -0.02595007f, 
    -0.04326589f, 0.00731551f, -0.03592394f, 0.06263319f, -0.06743726f, -0.06994104f, 0.00110711f, -0.04544256f, 
    -0.06351007f, -0.06055813f, -0.06961221f, -0.03226058f, 0.06343313f, -0.05635370f, -0.05121413f, 0.04345112f, 
    -0.02835850f, 0.00090173f, 0.02620603f, -0.01828774f, -0.05698362f, 0.03981620f, -0.06501554f, -0.00850945f, 
    0.03908148f, -0.07075714f, -0.04935288f, -0.02479958f, -0.03215015f, 0.02372260f, -0.05124123f, -0.01814358f, 
    -0.08675236f, 0.03364355f, -0.22587661f, 0.18140250f, 0.11900729f, 0.20335007f, -0.06523263f, -0.16900915f, 
    -0.00865720f, -0.14417943f, -0.07724547f, 0.02571050f, -0.21387523f, -0.16235414f, -0.00041277f, 0.08907072f, 
    -0.02077472f, -0.20920859f, -0.10593328f, 0.12088691f, 0.13162796f, 0.12867083f, 0.00766875f, -0.12373825f, 
    0.13376544f, 0.19537854f, 0.16092741f, 0.01403081f, 0.17356162f, 0.00027364f, -0.03987181f, -0.10850491f, 
    -0.00858150f, -0.01233439f, -0.00513548f, 0.12032793f, -0.04581214f, 0.04373906f, -0.08468098f, -0.25868076f, 
    -0.09419366f, 0.02832120f, 0.08473888f, -0.01866311f, 0.16965717f, 0.00666621f, -0.12173966f, -0.00108189f, 
    -0.18234649f, -0.23894615f, -0.01799512f, -0.10579553f, -0.04673947f, -0.02421842f, -0.22294584f, 0.12731026f, 
    0.19925150f, -0.07665993f, 0.18245441f, 0.08775427f, -0.07299895f, 0.10592554f, -0.44658238f, 0.09721449f, 
    -0.00329769f, 0.04826326f, 0.05795777f, 0.13335519f, 0.03411452f, 0.11974666f, 0.00262108f, 0.11870128f, 
    0.30890658f, -0.00921257f, -0.03768701f, -0.12334803f, 0.03828447f, 0.14036162f, 0.02029466f, 0.14515881f, 
    -0.02632288f, -0.19506615f, -0.04242458f, 0.03103028f, -0.35391009f, 0.13853006f, -0.04564202f, 0.34550321f, 
    0.14603484f, 0.06116976f, 0.11689453f, -0.05836643f, 0.03714411f, 0.05609754f, -0.14844608f, 0.11095333f, 
    -0.03166318f, 0.01139712f, 0.24946129f, -0.05906838f, 0.06885343f, -0.14486024f, -0.05540390f, 0.22021741f, 
    0.05668856f, 0.01193995f, -0.10554048f, 0.09516915f, 0.27516308f, 0.08459785f, 0.29268253f, -0.12492557f, 
    0.03963914f, -0.02014772f, 0.17846406f, -0.02638809f, -0.15458730f, -0.10133583f, -0.06581684f, -0.15944794f, 
    0.00966044f, -0.26751834f, -0.07050937f, -0.28752935f, 0.23019986f, 0.18205228f, 0.03668103f, 0.06232673f, 
    -0.03402001f, 0.04125351f, 0.15324835f, -0.05614071f, 0.20476474f, 0.21046412f, -0.29438338f, -0.00065917f, 
    0.07586122f, -0.10104590f, 0.07966547f, -0.01367279f, 0.05590269f, -0.00802400f, 0.14167547f, -0.07867122f, 
    -0.25330016f, -0.20664339f, -0.30237794f, -0.05434318f, -0.10028440f, 0.02848973f, 0.08599225f, 0.07648746f, 
    -0.07240613f, -0.08248716f, -0.13232657f, -0.23125346f, 0.14620014f, -0.10726377f, 0.02768546f, -0.10965578f, 
    -0.11784045f, 0.04982904f, -0.06188425f, 0.24971128f, 0.17088768f, 0.11046740f, 0.08554532f, 0.25141811f, 
    0.03421916f, -0.29709840f, 0.18649244f, -0.03898092f, -0.04459999f, -0.18296409f, -0.03648752f, 0.11496946f, 
    0.32364160f, 0.06132128f, 0.02870472f, -0.00979302f, -0.24293998f, -0.24526487f, 0.09347464f, -0.19304650f, 
    -0.04473287f, 0.09299378f, 0.13751569f, 0.05365242f, 0.00202995f, 0.05917616f, -0.01415881f, -0.12452690f, 
    -0.04074012f, -0.02601474f, 0.03136086f, -0.04439753f, 0.06409088f, 0.05914937f, 0.06356199f, 0.03691854f, 
    -0.00669505f, 0.05295743f, -0.00904845f, -0.01503901f, -0.04601474f, -0.06892351f, -0.05841815f, 0.04917975f, 
    -0.05854928f, -0.04687848f, -0.02303336f, -0.01807563f, -0.03191168f, -0.03017179f, -0.06988910f, -0.03334824f, 
    -0.05399908f, -0.04020064f, -0.00102936f, 0.03291570f, 0.01218883f, -0.04887953f, -0.00724681f, -0.02016683f, 
    -0.01050752f, -0.04733042f, -0.02052188f, -0.00317685f, 0.05208332f, 0.03635956f, 0.04504539f, -0.05533179f, 
    -0.03654448f, -0.05860979f, -0.04037588f, -0.02331500f, 0.05568375f, 0.00511639f, -0.00764465f, 0.02918975f, 
    0.04824628f, 0.05001260f, -0.07306518f, -0.01031560f, -0.02916999f, -0.06711884f, 0.00498461f, -0.05832503f, 
    -0.03277597f, 0.04118973f, -0.01932518f, 0.03885580f, 0.05025564f, -0.02665251f, -0.03848177f, -0.01132896f, 
    0.00312010f, -0.06440097f, -0.02962349f, 0.06737743f, -0.06602129f, -0.01832302f, 0.03531210f, 0.02325197f, 
    -0.00239676f, -0.07227734f, -0.04281941f, -0.00962803f, -0.06694814f, -0.06759782f, -0.02601793f, -0.03583392f, 
    0.01087212f, -0.02624820f, 0.03590537f, -0.06808521f, 0.00369219f, -0.04468792f, 0.03666429f, 0.02922664f, 
    -0.03061362f, -0.02121233f, -0.05608366f, -0.05712840f, -0.01768828f, -0.00696524f, 0.03455647f, 0.01858873f, 
    0.01223234f, 0.02344146f, 0.05017987f, 0.04918005f, -0.00577349f, -0.05976350f, 0.00534011f, -0.00868407f, 
    -0.02880182f, -0.00172884f, -0.02214475f, -0.05972520f, -0.05421487f, 0.00492704f, -0.05254259f, -0.05538276f, 
    -0.06651856f, -0.02860189f, 0.04773319f, 0.02126168f, 0.03064489f, -0.06978253f, 0.03573433f, 0.05647143f, 
    0.03670467f, -0.04877776f, -0.03781760f, -0.02649932f, -0.06951407f, 0.03690546f, -0.07377909f, -0.03818945f, 
    -0.05014202f, -0.01108724f, -0.03619696f, -0.07856101f, 0.02912267f, 0.02370913f, -0.06798597f, -0.03885759f, 
    -0.01502460f, -0.04666753f, 0.03006496f, -0.00510334f, -0.04629824f, -0.04282911f, 0.06404810f, 0.03976735f, 
    -0.03834677f, -0.00250694f, 0.04821559f, 0.03304459f, -0.06954870f, -0.05553218f, 0.01905654f, 0.01046019f, 
    -0.06004900f, -0.06331045f, -0.07323789f, -0.02383307f, -0.04064970f, 0.00335618f, -0.06928933f, 0.04911788f, 
    0.01262711f, 0.06311608f, -0.05709096f, 0.02586017f, 0.02102247f, -0.01190705f, -0.05656047f, -0.04969095f, 
    0.05669620f, -0.05610992f, -0.05338503f, 0.02087293f, -0.00163159f, 0.05255121f, -0.05753651f, 0.01078990f, 
    -0.00300294f, 0.01826132f, -0.00137827f, 0.00519270f, 0.00348062f, 0.05873888f, 0.06359636f, -0.02521500f, 
    -0.06093002f, -0.06043053f, 0.02408927f, 0.04635338f, -0.03070846f, 0.00742006f, 0.06068259f, -0.00036340f, 
    -0.24085243f, -0.13544813f, -0.28539231f, 0.28422925f, 0.13761179f, 0.21226905f, 0.00314175f, -0.15410323f, 
    0.08724951f, 0.04542562f, -0.08250130f, 0.07466544f, 0.01938272f, -0.13802069f, -0.01447768f, 0.01267083f, 
    -0.02785756f, -0.09205663f, -0.00863433f, -0.03604332f, 0.14833589f, 0.08414283f, 0.00777011f, 0.08568981f, 
    0.11564460f, 0.32111135f, 0.00876088f, 0.10880720f, 0.13138875f, 0.17670178f, -0.00353845f, -0.01291578f, 
    -0.05499670f, -0.03385564f, 0.00655307f, 0.10448044f, 0.05281163f, -0.06098653f, -0.00301663f, -0.23671435f, 
    -0.07088869f, -0.01192012f, 0.01323081f, -0.07836631f, 0.19419065f, -0.07634754f, 0.05105160f, 0.03453702f, 
    0.24688971f, -0.17880863f, 0.12989739f, 0.12487817f, -0.10237520f, -0.12773979f, -0.07944942f, -0.07694244f, 
    0.04228103f, -0.03951333f, 0.13634424f, 0.01653641f, -0.24163045f, -0.00532911f, -0.43109852f, 0.09096115f, 
    0.02994923f, -0.02530303f, 0.07981141f, 0.04875683f, 0.01043271f, 0.01691056f, -0.09599309f, 0.12831908f, 
    0.23054506f, 0.14143303f, 0.02815095f, -0.16920206f, 0.07963580f, 0.21535970f, 0.05862683f, 0.02147665f, 
    -0.09666860f, -0.21141659f, 0.08416817f, -0.11289130f, -0.19935270f, -0.17532192f, 0.08369532f, -0.03460962f, 
    0.07498928f, -0.05970172f, -0.00950544f, -0.11663693f, 0.18066727f, 0.04675307f, -0.08772513f, 0.09627045f, 
    -0.10721190f, 0.08460787f, 0.17629611f, -0.11070171f, -0.01571965f, -0.07383066f, 0.07866345f, 0.24057059f, 
    0.15380268f, -0.05785313f, -0.03983843f, 0.08614801f, 0.15676737f, 0.15254657f, 0.26358414f, -0.03717586f, 
    0.06592179f, -0.00666913f, 0.13411905f, 0.15997867f, 0.02037550f, -0.11246053f, -0.01617477f, -0.10639682f, 
    0.22526990f, -0.39443541f, 0.04020480f, -0.22054991f, 0.31250635f, 0.11758902f, 0.12512904f, 0.01351273f, 
    0.10891277f, -0.02853218f, 0.14454342f, -0.16012613f, -0.02134997f, 0.10544311f, -0.35696605f, -0.05491200f, 
    0.10528510f, 0.07430483f, -0.03290319f, -0.03525393f, 0.04568268f, -0.07123457f, 0.10197916f, -0.10290239f, 
    -0.19955483f, -0.17961338f, -0.13342725f, -0.12129536f, 0.00660135f, 0.03462278f, 0.07145918f, 0.02878058f, 
    -0.14577542f, -0.16970046f, -0.10080649f, -0.22338890f, 0.22582667f, -0.15159424f, -0.17016412f, -0.13383768f, 
    -0.09836878f, 0.02981568f, 0.15138891f, -0.03228136f, 0.07206015f, 0.00983639f, 0.01032076f, 0.22936989f, 
    0.07707066f, -0.16823168f, 0.17718191f, 0.24299113f, -0.04349545f, -0.18536273f, -0.17747205f, -0.04072268f, 
    0.04432749f, 0.01780243f, 0.06515935f, 0.01106900f, -0.03632540f, -0.06519610f, -0.12912035f, -0.19538631f, 
    -0.05593270f, 0.02728244f, 0.07538722f, 0.19532983f, 0.10497776f, 0.11220226f, -0.13197155f, 0.03250597f, 
    0.03476259f, -0.00215009f, 0.08490573f, 0.08471467f, -0.19376695f, 0.09202905f, -0.03389944f, -0.02582044f, 
    -0.11096586f, 0.00181301f, -0.04688492f, -0.15975685f, 0.16323142f, 0.07735816f, -0.17687137f, -0.00582210f, 
    0.09707092f, 0.13849369f, 0.32137480f, 0.20259793f, -0.19324687f, -0.32633421f, -0.05434215f, -0.20579708f, 
    0.07907658f, 0.02058721f, 0.05736804f, -0.26466551f, -0.00470903f, -0.19369739f, 0.13357329f, 0.07374749f, 
    0.14353989f, 0.01112655f, 0.00043178f, 0.11843815f, 0.11352920f, 0.24731004f, 0.03761659f, 0.18132205f, 
    0.03695758f, -0.03490733f, 0.06654811f, -0.01321574f, -0.04057781f, 0.14270180f, 0.00757284f, 0.14696939f, 
    -0.20706691f, 0.00838540f, -0.20257138f, -0.17153521f, -0.03816191f, -0.06973553f, 0.10720081f, 0.26589847f, 
    0.11670960f, 0.02866452f, 0.03288618f, 0.21076182f, 0.18144892f, -0.11947280f, 0.02152009f, 0.01206996f, 
    0.10629819f, 0.32720408f, 0.11441422f, 0.00322676f, -0.03260035f, -0.06675383f, -0.10927914f, -0.20557515f, 
    0.26639464f, 0.15379682f, 0.07268500f, -0.04691179f, -0.08886145f, -0.11678153f, -0.16247170f, 0.01672107f, 
    -0.00245218f, 0.14771058f, -0.06189875f, 0.02566922f, 0.03205771f, -0.00259132f, -0.07287356f, 0.16548139f, 
    0.06344829f, 0.09803879f, 0.08504500f, -0.04038668f, -0.32641625f, -0.13688934f, 0.07549658f, -0.00136077f, 
    -0.00633455f, 0.07959035f, -0.02406977f, -0.18409313f, 0.01820257f, 0.00719415f, 0.00933143f, -0.11746240f, 
    -0.13587533f, -0.25542971f, -0.26504481f, -0.21893001f, 0.07998584f, -0.09325022f, -0.02232457f, 0.15712504f, 
    0.10531490f, 0.11967794f, -0.02189976f, -0.07761290f, 0.04488547f, 0.09695927f, 0.12846823f, 0.10058457f, 
    -0.05396307f, 0.09289620f, -0.07582345f, -0.08609965f, -0.03687621f, 0.15262207f, -0.09797250f, 0.02595848f, 
    -0.03748630f, 0.07815740f, -0.03534773f, 0.06271736f, 0.05923555f, -0.23328312f, -0.24491507f, 0.23522463f, 
    0.03676011f, 0.13616858f, 0.11728611f, 0.02203821f, 0.01579204f, -0.07919929f, -0.19967388f, -0.20780139f, 
    0.11793258f, -0.24339409f, -0.20761578f, 0.11779835f, 0.03312241f, -0.06156161f, 0.17269361f, -0.05396156f, 
    0.18378700f, 0.20839360f, 0.10608071f, 0.28908890f, -0.13231073f, -0.15793599f, 0.35531011f, -0.13158801f, 
    0.09981892f, 0.06104596f, -0.20513161f, 0.28889939f, -0.02096961f, -0.08255517f, 0.02004190f, -0.21786803f, 
    0.05650593f, 0.25750002f, 0.02622809f, 0.12620689f, -0.00245819f, 0.06341261f, 0.03063879f, 0.00363394f, 
    0.06380567f, 0.12439632f, 0.15644525f, 0.19629207f, 0.06040901f, 0.13875249f, 0.25210378f, -0.05476072f, 
    -0.07838740f, -0.00646826f, 0.29545239f, -0.10173404f, -0.09964827f, -0.21941446f, -0.11565781f, 0.21366729f, 
    0.10990413f, -0.14162332f, 0.12506880f, -0.00869275f, -0.13618477f, -0.02631911f, 0.06269520f, -0.06586247f, 
    -0.01225470f, 0.05112662f, 0.09720381f, 0.07730577f, 0.03816401f, -0.01474016f, 0.01151437f, 0.03570689f, 
    -0.06433941f, 0.07060390f, -0.02087371f, -0.03183955f, -0.04986796f, 0.04703255f, 0.02995807f, -0.00781893f, 
    0.30408752f, -0.01593698f, 0.19451635f, 0.22619124f, 0.03255338f, 0.11707588f, 0.00043080f, -0.06218396f, 
    -0.05130243f, 0.07399652f, -0.00385667f, -0.08702302f, 0.26368102f, 0.42920053f, -0.16466177f, 0.22216359f, 
    0.09659350f, 0.05031781f, 0.08384941f, -0.08373667f, 0.07440994f, 0.10849238f, -0.07195706f, -0.13872084f, 
    0.22748700f, 0.35780910f, 0.11897331f, 0.01764680f, -0.11368311f, -0.13437261f, -0.12215658f, 0.05050717f, 
    -0.00358257f, 0.09077977f, -0.09853581f, 0.03412776f, 0.32649568f, -0.17185040f, 0.23404896f, -0.21397144f, 
    0.01944267f, -0.00354545f, -0.02873561f, -0.10711911f, -0.06108068f, -0.10514015f, 0.05532549f, 0.02448484f, 
    0.20388104f, -0.22344226f, -0.01372020f, 0.20351900f, 0.11675458f, 0.05817550f, -0.08435126f, 0.02730876f, 
    0.06051991f, 0.02163463f, -0.00079353f, -0.01747272f, 0.21576421f, 0.28083634f, -0.03060029f, 0.14468494f, 
    -0.06530333f, -0.02365736f, -0.01463026f, -0.01799166f, -0.11449867f, 0.08144674f, 0.01835435f, -0.04754078f, 
    -0.18445212f, 0.10732379f, 0.06977392f, -0.06032878f, 0.11686165f, 0.09640641f, 0.20767203f, -0.13477001f, 
    -0.08849581f, -0.05716309f, -0.03274622f, 0.00186259f, 0.25221068f, 0.28392684f, -0.14212823f, 0.10778736f, 
    -0.00155928f, 0.04046934f, 0.14074202f, -0.00735153f, 0.01085148f, 0.04170660f, -0.07095632f, 0.05539351f, 
    0.10394895f, 0.08839095f, -0.02220632f, 0.16956742f, -0.18687640f, -0.00012720f, 0.06269038f, -0.08243110f, 
    -0.07978509f, 0.13917990f, -0.01061821f, 0.17723761f, 0.05326553f, 0.00781206f, -0.00234776f, 0.12201047f, 
    0.00271484f, 0.07547561f, -0.05641267f, -0.08753797f, -0.08609124f, 0.03934528f, -0.00364316f, 0.01441102f, 
    0.03737581f, 0.09119317f, 0.06353179f, 0.06506512f, -0.11416095f, -0.05502166f, -0.08401061f, -0.07231914f, 
    0.04273545f, -0.10049507f, 0.10432373f, -0.07982875f, 0.23742314f, -0.22020935f, 0.02622424f, 0.20217793f, 
    0.00117949f, 0.04692723f, 0.00615692f, 0.06245869f, 0.04226748f, -0.09575292f, -0.05415413f, -0.13343230f, 
    -0.16263081f, 0.03299315f, -0.03236247f, -0.13930336f, 0.03563305f, -0.04496908f, 0.05347795f, -0.07503363f, 
    -0.08053293f, -0.07527874f, -0.03374732f, 0.03800208f, 0.13156787f, -0.32414442f, 0.15641525f, -0.09913296f, 
    -0.08400559f, 0.11187617f, -0.01343334f, 0.22734232f, -0.03111382f, 0.02391443f, -0.08045278f, -0.07646131f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03423192f, 0.19087833f, 0.06719624f, 0.04767814f, 0.14088850f, -0.03461424f, -0.12204050f, -0.05347994f, 
    0.03024991f, -0.12601364f, 0.06607944f, -0.07584756f, 0.03448211f, 0.06049642f, -0.11014091f, -0.10997400f, 
    0.09275664f, 0.10933244f, 0.14941160f, -0.10109546f, 0.05145781f, 0.09022517f, -0.02616621f, 0.05151804f, 
    -0.03367801f, 0.10887874f, -0.03425343f, 0.01041815f, -0.00195622f, 0.05943593f, 0.03233987f, 0.23492643f, 
    0.07810929f, 0.04223123f, 0.03865835f, -0.00816667f, 0.01088957f, -0.00884682f, 0.08312290f, 0.08217898f, 
    0.11944022f, 0.04096389f, 0.12548280f, 0.19007094f, 0.08382607f, 0.05825664f, 0.17345643f, 0.06176668f, 
    0.23464072f, 0.11887591f, 0.01716876f, 0.02272744f, 0.01462664f, -0.06492196f, 0.09733732f, 0.06317396f, 
    0.03349884f, 0.00720163f, -0.06437331f, 0.20307784f, -0.11047711f, -0.02439476f, -0.03037931f, -0.01824719f, 
    -0.02768996f, -0.04955193f, 0.05005847f, 0.08974244f, 0.12369484f, 0.01376714f, 0.06643059f, -0.02052937f, 
    -0.04986305f, 0.05195380f, -0.02872059f, 0.12352225f, 0.09747513f, 0.12590580f, -0.04839757f, 0.18491900f, 
    0.07044085f, -0.06977301f, 0.02301184f, 0.00673212f, -0.01897173f, 0.17434765f, -0.13621868f, 0.07557749f, 
    -0.01950826f, -0.09218433f, -0.03998002f, -0.01553113f, 0.11592710f, 0.15172289f, 0.16598530f, 0.14885215f, 
    0.02296327f, 0.12346799f, -0.02748299f, -0.03804483f, -0.11484226f, -0.12914783f, 0.01780880f, 0.06280768f, 
    0.17112553f, -0.06629214f, 0.13286912f, -0.00228835f, 0.07601041f, 0.05821072f, 0.02392286f, 0.00383211f, 
    0.02718546f, -0.06866680f, -0.01882438f, -0.02122971f, 0.12506799f, -0.02304959f, 0.02737805f, 0.12670064f, 
    -0.02832784f, 0.20170717f, 0.03964424f, 0.01493423f, -0.03137539f, 0.09971326f, -0.03721097f, 0.13286103f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.01802910f, -0.35125878f, -0.17940761f, -0.02661148f, -0.16778114f, -0.05356568f, -0.08767261f, 0.02507307f, 
    -0.03834632f, 0.11115073f, 0.13298632f, 0.22817303f, -0.24946342f, 0.10656794f, 0.10553986f, 0.18358494f, 
    -0.02248910f, -0.01715279f, -0.08714277f, 0.18955593f, -0.24227951f, -0.21583541f, -0.03870035f, 0.07935223f, 
    0.07571188f, -0.44993594f, 0.01561058f, -0.29350361f, -0.27386838f, -0.05959422f, -0.12597987f, -0.10844396f, 
    0.00191994f, 0.11574674f, 0.12054260f, -0.06862924f, -0.22202331f, 0.07772096f, -0.04755988f, -0.10576285f, 
    -0.02594947f, 0.08698791f, 0.01759834f, -0.30061412f, -0.26462689f, -0.41421077f, -0.15139490f, 0.00287972f, 
    -0.25223872f, 0.01058967f, -0.23677549f, -0.22539206f, -0.16367078f, -0.03717673f, -0.26147345f, -0.07425559f, 
    -0.33806112f, -0.28354937f, -0.04452755f, -0.18454520f, 0.21509226f, 0.06254447f, 0.03272138f, -0.02109855f, 
    0.01073463f, 0.21403123f, 0.09826875f, -0.26155749f, -0.36720392f, -0.05561175f, 0.11513836f, 0.00541196f, 
    0.01550494f, -0.08730653f, 0.02568960f, -0.30148762f, 0.07966927f, -0.31121162f, -0.00143429f, 0.12107828f, 
    -0.40796998f, -0.22889738f, 0.08441742f, -0.07222342f, 0.00116329f, -0.08763578f, 0.12909476f, 0.15530188f, 
    0.02138210f, 0.05016421f, -0.06824815f, 0.01496676f, -0.09327144f, -0.36489230f, -0.52772886f, -0.37821341f, 
    0.10128923f, 0.13331567f, -0.07158387f, -0.02079546f, -0.01916480f, 0.01447891f, -0.10124974f, -0.40741929f, 
    0.01154012f, -0.09248155f, 0.05680214f, -0.00605100f, -0.42939645f, 0.03160477f, 0.07411031f, -0.01778880f, 
    0.02233980f, -0.06583487f, 0.08546220f, -0.11426120f, -0.23720874f, 0.41845670f, 0.02282165f, 0.08549713f, 
    0.21141697f, 0.10794129f, -0.01026751f, 0.20366989f, -0.08125474f, 0.13961431f, 0.23779030f, 0.11605006f, 
    -0.44386527f, -0.05608073f, 0.05452482f, -0.00701389f, 0.04967908f, 0.01355232f, -0.45969033f, -0.08304252f, 
    0.00335577f, 0.12758622f, 0.07504375f, -0.08295667f, -0.28849638f, 0.11619613f, -0.03884606f, -0.76297748f, 
    0.01144692f, 0.06654650f, 0.02792536f, -0.63817823f, -0.13191859f, -0.68518853f, 0.05317713f, -0.03419716f, 
    -0.07737398f, 0.02963291f, -0.05027123f, -0.22799097f, -0.02398921f, 0.02673966f, 0.11012717f, 0.12869613f, 
    -0.02548925f, 0.04939620f, 0.09466826f, 0.01976772f, -0.18055053f, 0.03753141f, -0.06616180f, 0.09361971f, 
    0.07485385f, -0.06889611f, 0.07296328f, 0.23525661f, 0.42365929f, -0.06342398f, 0.13093902f, -0.13905115f, 
    0.02794090f, 0.10778264f, 0.19514255f, -0.62819833f, 0.22364335f, 0.04946341f, 0.02362590f, -0.01248126f, 
    -0.21581908f, -0.18464014f, 0.13624862f, -0.14563775f, -0.13753308f, -0.00650061f, 0.00139441f, -0.02997548f, 
    0.00339394f, 0.12006107f, 0.11691782f, 0.00897436f, -0.25504169f, -0.03255802f, -0.17316799f, -0.05664759f, 
    -0.01220948f, -0.02613194f, -0.00375436f, 0.01813157f, 0.09193811f, -0.47753891f, 0.04084964f, 0.13288255f, 
    0.24592011f, -0.08964279f, 0.05250974f, -0.07428920f, -0.00313027f, -0.08797024f, 0.35700005f, 0.14614774f, 
    -0.06732436f, -0.03122548f, 0.01555837f, 0.03490853f, 0.38738856f, -0.31418878f, -0.02344038f, -0.03092525f, 
    0.10256782f, 0.21470366f, 0.02959320f, -0.02209337f, -0.42274177f, 0.29979578f, 0.04776611f, -0.10227400f, 
    0.38781825f, -0.06318216f, -0.16979350f, 0.28648114f, -0.20127556f, 0.00992108f, -0.07236435f, 0.00115238f, 
    0.07825930f, 0.00331007f, -0.01585090f, 0.12618330f, 0.15218876f, -0.07932000f, 0.03603877f, 0.07278048f, 
    0.10498758f, 0.14651689f, 0.02292218f, 0.01300977f, 0.00377144f, 0.13940129f, -0.38424578f, 0.19708647f, 
    0.30277893f, 0.12648945f, -0.03638942f, 0.09213587f, 0.17206818f, 0.07096247f, 0.10375591f, 0.04883612f, 
    0.00335407f, 0.00185066f, 0.24431840f, 0.09328538f, -0.17748958f, 0.03548703f, -0.01671306f, -0.21073191f, 
    -0.07285512f, -0.01420065f, 0.03148768f, -0.19281493f, 0.13082179f, -0.28549993f, -0.03492832f, -0.06499955f, 
    -0.05840965f, 0.14879742f, -0.08180194f, -0.29019091f, -0.02699452f, -0.00266909f, -0.33583686f, 0.19320415f, 
    0.17055309f, 0.16956967f, 0.05011526f, -0.13387404f, -0.07228076f, -0.04494029f, 0.00436934f, -0.09407096f, 
    0.12775496f, -0.26423371f, 0.08775827f, 0.17192170f, 0.21475381f, 0.07682028f, -0.04544706f, 0.11869448f, 
    -0.02516145f, -0.02133164f, -0.21811138f, 0.07018095f, -0.21217549f, -0.02756769f, 0.18323451f, -0.05314809f, 
    -0.12504897f, -0.21943006f, -0.18810032f, -0.06453357f, -0.00467875f, 0.06037506f, 0.00271305f, 0.05400204f, 
    0.07872142f, -0.02136874f, 0.09999985f, -0.03434887f, 0.03981545f, -0.03670411f, -0.16759585f, -0.03519337f, 
    -0.01168860f, -0.03238131f, 0.03537459f, 0.18483707f, 0.03377198f, 0.13410856f, -0.06066245f, 0.05743922f, 
    -0.35011321f, -0.00300780f, 0.37580639f, -0.00273581f, -0.04151316f, -0.01672890f, -0.38886395f, 0.14842694f, 
    -0.04522954f, 0.04142025f, 0.07295299f, -0.01301409f, -0.53023916f, 0.30566978f, 0.29264307f, -0.06886905f, 
    -0.03241013f, -0.17027783f, 0.01409853f, 0.12058886f, -0.46450838f, -0.46761858f, 0.04183060f, 0.06947701f, 
    -0.67607111f, -0.05565174f, 0.12667583f, -0.14828783f, -0.05098315f, 0.03559953f, -0.02240068f, -0.05537539f, 
    0.01531656f, -0.06601138f, -0.29396960f, -0.41772887f, 0.07766420f, -0.67050451f, -0.02387134f, -0.11682034f, 
    -0.18961713f, 0.17177907f, -0.08261538f, -0.31990373f, -0.08013164f, -0.20354250f, -0.23984364f, -0.09296402f, 
    -0.14848037f, -0.13194267f, -0.30740908f, 0.11748555f, 0.20442583f, -0.08088958f, 0.18794510f, -0.00401656f, 
    0.00777659f, 0.10502564f, 0.10950667f, -0.26830858f, -0.08100975f, 0.09986292f, 0.07319935f, 0.13736571f, 
    0.01745520f, -0.10836004f, -0.48739955f, 0.19082323f, -0.00835811f, -0.04861050f, -0.00011142f, -0.05207345f, 
    -0.07939395f, 0.00641930f, -0.08366649f, 0.25008973f, 0.26489893f, -0.05991893f, -0.13346706f, -0.25704134f, 
    0.05605832f, -0.17733404f, -0.13918100f, -0.37385592f, 0.08105482f, 0.06982652f, -0.09277368f, -0.20327073f, 
    -0.43712032f, 0.09677128f, -0.53282380f, -0.22861147f, -0.19103101f, 0.32484636f, -0.30100423f, 0.08352653f, 
    -0.18538243f, -0.33086929f, -0.08909940f, 0.20485300f, -0.11991242f, 0.02462914f, 0.15239279f, -0.03279421f, 
    0.16649455f, -0.15669410f, 0.06359325f, -0.34916836f, 0.24560753f, 0.07727297f, 0.00393899f, 0.04407050f, 
    0.01275170f, -0.06679199f, -0.07053775f, -0.33561191f, 0.04993832f, -0.09295601f, 0.13378961f, 0.05476549f, 
    -0.01885486f, -0.02342011f, 0.04673209f, -0.34995097f, 0.02364907f, 0.20288463f, -0.07204922f, -0.17417578f, 
    0.15803365f, 0.16213068f, 0.15955701f, -0.01324824f, -0.03854294f, 0.10175873f, 0.03120865f, 0.14374426f, 
    -0.04533709f, 0.23898415f, -0.04697434f, 0.01403025f, -0.37056354f, 0.03696549f, 0.28984198f, 0.19201940f, 
    0.13390480f, -0.09005103f, 0.01155005f, -0.03017914f, -0.32934847f, 0.07258572f, 0.05671957f, -0.15951675f, 
    -0.26230371f, -0.08452317f, -0.06500791f, -0.24264711f, -0.49805701f, -0.08048902f, 0.05274252f, -0.01253525f, 
    0.15442351f, 0.00760246f, -0.00451539f, -0.09497013f, 0.03946918f, -0.08642629f, 0.07146813f, -0.08799490f, 
    -0.04193209f, -0.22653092f, -0.07142115f, -0.28417599f, -0.08765120f, -0.17225079f, -0.03710213f, 0.06987848f, 
    0.15053940f, 0.10179652f, 0.05595857f, 0.02463013f, -0.35952029f, 0.01820313f, 0.13631682f, -0.01589968f, 
    -0.06266757f, 0.08418037f, -0.07122578f, 0.06721799f, 0.25946125f, -0.50838059f, 0.16269235f, 0.13484414f, 
    0.03019923f, -0.15257359f, 0.08567726f, 0.16311252f, 0.20505005f, 0.04930951f, -0.02512111f, 0.06822374f, 
    -0.09167212f, -0.07443039f, 0.14182076f, -0.31257623f, -0.09724849f, -0.06105419f, 0.05951809f, 0.22615829f, 
    0.16385573f, -0.08176757f, 0.13000935f, -0.08721182f, 0.27288064f, -0.00051264f, 0.08853523f, 0.07883715f, 
    -0.10731092f, -0.00826962f, -0.13771072f, -0.18476219f, 0.07010201f, -0.13621378f, -0.15644450f, 0.04051733f, 
    -0.25039279f, -0.15624531f, -0.40019354f, 0.19326288f, -0.06044786f, -0.06151953f, -0.19955939f, 0.07474516f, 
    0.01757670f, -0.03764732f, 0.11523991f, -0.32269710f, 0.15892659f, -0.04198250f, 0.02524588f, 0.07906381f, 
    -0.01742091f, 0.11663996f, -0.24110825f, -0.02771854f, -0.21364491f, 0.06993424f, 0.02898449f, 0.00856153f, 
    -0.00887709f, -0.05761729f, 0.05166251f, 0.13952936f, 0.01559573f, -0.60328078f, 0.04230602f, -0.01570562f, 
    0.21407990f, 0.07338428f, -0.11957870f, -0.05126190f, -0.02453839f, -0.18550633f, 0.10758211f, -0.06707149f, 
    0.01803480f, 0.08245185f, -0.00478017f, -0.01133333f, -0.03793488f, 0.00640964f, -0.53362072f, -0.10368063f, 
    -0.07523482f, -0.13193394f, 0.02346889f, 0.18127657f, 0.48506799f, 0.19656499f, -0.07330083f, -0.03706338f, 
    -0.23765969f, -0.04237398f, -0.06971850f, 0.18525615f, 0.28267765f, -0.05107460f, -0.06742633f, 0.05203316f, 
    -0.33726096f, 0.03430473f, 0.00806317f, -0.03661138f, -0.03374958f, -0.05731148f, -0.04441966f, -0.38525143f, 
    0.03038099f, -0.13002378f, -0.01050149f, 0.05122570f, 0.00084314f, -0.09683572f, 0.18605061f, -0.02044039f, 
    -0.48361358f, 0.09746876f, -0.05550472f, 0.09165402f, 0.03544071f, -0.08783700f, -0.41218045f, -0.07217961f, 
    0.04681925f, 0.02842287f, 0.02169142f, 0.05181542f, -0.07314587f, -0.08226773f, -0.03005871f, -0.11568429f, 
    0.11966075f, 0.07163262f, 0.11714264f, -0.33925340f, 0.13481683f, 0.38007542f, 0.03829292f, -0.01750636f, 
    -0.03019655f, -0.07810090f, 0.08554538f, 0.09639311f, -0.12528536f, -0.01425555f, 0.26044846f, -0.16387582f, 
    0.16262022f, -0.11326101f, -0.03238729f, -0.11782581f, 0.00244529f, 0.03225277f, -0.06306559f, 0.12720348f, 
    -0.22642559f, 0.05048590f, 0.21960576f, -0.07182714f, -0.26814681f, -0.25666702f, 0.02667809f, 0.23513296f, 
    0.09394990f, 0.13674502f, 0.11528720f, 0.06738850f, -0.43546233f, 0.07273305f, -0.23785564f, -0.09099375f, 
    0.01848769f, 0.00353319f, -0.01874854f, 0.43381563f, -0.37791064f, 0.06393505f, 0.04294291f, 0.07604115f, 
    -0.05139596f, -0.39827856f, -0.18843995f, -0.39391813f, 0.02332610f, -0.08091747f, 0.18401816f, -0.04739314f, 
    0.03648432f, 0.05030802f, -0.01272890f, 0.03437407f, 0.03015282f, 0.29166943f, 0.02505252f, 0.11390118f, 
    -0.25004157f, -0.26056796f, -0.27677789f, -0.11112873f, -0.12181673f, 0.02541304f, -0.15349260f, -0.01285189f, 
    0.01207918f, -0.27466628f, -0.01414440f, 0.06017916f, -0.32596096f, 0.31432495f, -0.72335118f, -0.04196277f, 
    0.06288634f, 0.15347515f, -0.04953703f, -0.17624390f, -0.04157269f, -0.09124506f, -0.03073732f, -0.03242904f, 
    0.11071507f, -0.04724249f, 0.14986365f, -0.07888554f, 0.22806875f, -0.08157083f, -0.00787831f, 0.04565026f, 
    0.04599470f, 0.04829451f, 0.10362395f, 0.13243656f, 0.02150024f, 0.17894265f, -0.01839523f, -0.09714328f, 
    0.12107483f, -0.14707880f, -0.00075275f, 0.34536025f, -0.00611811f, 0.29297179f, -0.29174322f, -0.04147249f, 
    0.24341020f, 0.28515223f, 0.13711469f, 0.05456978f, -0.02043803f, -0.05594936f, -0.08087799f, -0.06106655f, 
    -0.08548034f, -0.63114661f, -0.29981601f, 0.08468905f, -0.13830958f, -0.42368290f, -0.41826668f, 0.06792064f, 
    0.07128046f, 0.10349032f, 0.06430588f, -0.16241559f, 0.23808785f, 0.08929656f, -0.02147879f, -0.05854733f, 
    -0.04402675f, 0.07619480f, -0.10233010f, -0.11572194f, 0.11907049f, -0.03637135f, -0.40697199f, -0.15844153f, 
    -0.69494003f, -0.00659203f, 0.09237835f, -0.32070741f, -0.08958181f, -0.07256383f, -0.37756518f, -0.16322285f, 
    0.23491040f, -0.46976918f, -0.23426664f, -0.12440024f, 0.24337184f, -0.08535545f, 0.07169860f, 0.09106250f, 
    0.18674289f, 0.08476678f, -0.07349244f, 0.14346798f, 0.10678434f, 0.04829751f, 0.08384103f, -0.07400048f, 
    -0.19938348f, -0.05749559f, -0.47063556f, 0.08336923f, 0.05283308f, 0.03164406f, -0.05606461f, 0.03723345f, 
    -0.02251545f, 0.30156535f, 0.16880777f, -0.18657942f, 0.28331318f, 0.02338354f, -0.30826482f, -0.01632444f, 
    -0.07209707f, 0.08536349f, -0.05121722f, 0.23112082f, -0.27830616f, -0.33162564f, -0.02370618f, -0.23434331f, 
    -0.06615814f, -0.17478311f, -0.05154676f, -0.01234849f, -0.13622478f, -0.22223462f, -0.27129099f, -0.01551778f, 
    0.01671232f, 0.00125874f, -0.00650882f, -0.00919648f, 0.15175888f, 0.28683671f, 0.04154360f, 0.28675783f, 
    -0.37141412f, -0.34576041f, 0.02276943f, 0.05939166f, 0.01310079f, -0.46189618f, 0.02719236f, 0.23913541f, 
    0.12128923f, -0.06476073f, 0.18683042f, -0.31932524f, 0.24197590f, -0.02427272f, 0.00232772f, -0.04500394f, 
    -0.25368103f, -0.05863797f, -0.38524947f, -0.00682916f, 0.08107319f, -0.30433568f, -0.06802248f, 0.14106162f, 
    -0.18391468f, -0.04404016f, -0.00681744f, -0.11287287f, 0.07502187f, -0.44559753f, 0.26351485f, -0.14275047f, 
    0.15089448f, -0.36397639f, -0.19532204f, 0.04647120f, -0.01726665f, -0.02818712f, 0.21815565f, -0.05113461f, 
    -0.00133452f, -0.49938488f, -0.10408051f, -0.06718586f, 0.10637614f, 0.19002795f, 0.34310970f, -0.00474983f, 
    0.00987941f, 0.01663016f, 0.03784102f, 0.16062880f, -0.15063339f, 0.30626607f, -0.01532385f, 0.04295744f, 
    0.04411311f, -0.02829695f, 0.13269436f, 0.20076419f, 0.14134493f, -0.06072850f, 0.17324996f, -0.27091974f, 
    -0.22218637f, 0.01644195f, -0.45405462f, 0.27009150f, -0.12651581f, -0.07686123f, 0.07812214f, 0.09824548f, 
    -0.24132533f, -0.29614103f, 0.16759674f, 0.05987553f, -0.00366183f, 0.13055457f, 0.09045533f, 0.36842883f, 
    -0.09862260f, 0.07539314f, 0.11664475f, 0.15581186f, 0.05355506f, -0.07112195f, -0.02632147f, -0.08060000f, 
    -0.16283424f, 0.17358562f, -0.07362108f, -0.13434812f, -0.21988170f, 0.02436312f, -0.07486609f, 0.05666589f, 
    -0.00488205f, -0.27492568f, 0.07868566f, -0.23496097f, -0.16356097f, -0.07139668f, -0.16612157f, 0.07665678f, 
    0.02815402f, 0.04596988f, -0.03555644f, 0.10695218f, 0.12333085f, 0.22580306f, -0.04586756f, 0.02016332f, 
    0.11975808f, 0.24196976f, -0.36357197f, -0.04521129f, -0.06878520f, 0.05665915f, -0.26346833f, -0.12020791f, 
    -0.01002860f, 0.16910270f, -0.04041164f, -0.07203681f, 0.01255250f, -0.13400173f, -0.07991596f, -0.18527259f, 
    -0.18461987f, -0.48207885f, -0.03852519f, -0.29370710f, 0.02405490f, -0.11074675f, -0.04534321f, -0.32825401f, 
    -0.29893410f, -0.06379315f, -0.47887304f, -0.13540111f, -0.00290447f, 0.06834141f, -0.06229636f, -0.01585985f, 
    0.18849815f, 0.03146270f, -0.42754057f, 0.13074900f, 0.07723580f, -0.05146570f, -0.08001547f, -0.17446324f, 
    -0.16755733f, -0.20282060f, 0.04428165f, -0.10755831f, -0.05308842f, 0.09058226f, -0.35649362f, -0.20627102f, 
    -0.09481490f, -0.58656174f, -0.17637458f, 0.03967632f, 0.24728948f, -0.08913124f, -0.14757270f, 0.00582427f, 
    -0.06078331f, -0.56127161f, -0.31249717f, -0.07629913f, 0.10340292f, 0.31553733f, -0.61383629f, -0.21528864f, 
    -0.20575324f, 0.18504047f, -0.02828949f, -0.15869761f, -0.18609557f, -0.21425547f, -0.07590818f, 0.04063757f, 
    -0.08955896f, 0.22063802f, -0.04629708f, 0.30163977f, 0.17107725f, -0.04610329f, -0.36749455f, 0.42052817f, 
    -0.42865583f, -0.18877648f, 0.09004390f, 0.04117798f, -0.23368548f, -0.06268309f, 0.24312676f, -0.23932505f, 
    -0.21043424f, 0.28271160f, 0.08242717f, -0.11103787f, -0.44660744f, 0.20166315f, 0.09954767f, -0.54145551f, 
    0.17103453f, 0.15339698f, -0.05407472f, -0.16051435f, -0.04640876f, 0.06127621f, 0.19720629f, -0.02970445f, 
    0.38301149f, 0.03919097f, -0.36325744f, 0.17885479f, -0.20504823f, -0.06489337f, -0.04946351f, 0.01181385f, 
    0.07474464f, -0.38280839f, 0.09696510f, 0.06313466f, 0.08093217f, 0.06979033f, 0.13395512f, 0.01057077f, 
    -0.03991364f, 0.03111107f, -0.02846851f, -0.18385550f, 0.12070488f, 0.44318852f, 0.05939813f, 0.10309593f, 
    -0.21479917f, -0.02391937f, -0.09476312f, -0.00980977f, 0.01244101f, 0.30170083f, -0.16119589f, 0.14249350f, 
    0.08454635f, -0.15665090f, -0.05525594f, -0.04412051f, -0.10971881f, 0.00937476f, -0.01584450f, -0.16519965f, 
    0.10846345f, 0.15110306f, -0.05398913f, -0.30860072f, -0.22528917f, -0.35653347f, 0.03845152f, -0.10449101f, 
    -0.03707126f, -0.07781445f, -0.39213860f, -0.00866773f, -0.09384291f, -0.05415896f, -0.00306290f, -0.08453392f, 
    0.17964293f, 0.04809123f, -0.13725832f, 0.05854760f, -0.20447356f, -0.06875565f, 0.03018431f, 0.22863437f, 
    -0.16647522f, 0.02171424f, -0.01881012f, -0.00558572f, 0.02490462f, -0.15971406f, -0.63947111f, 0.04557481f, 
    0.18915378f, 0.03678716f, -0.03206342f, -0.23265688f, -0.38218766f, -0.07744551f, 0.22963324f, 0.02719045f, 
    -0.04163382f, 0.01412291f, -0.13195333f, -0.07779247f, -0.15994778f, -0.25718790f, 0.02890985f, 0.18962626f, 
    0.17553183f, -0.17326634f, 0.07530755f, -0.08031037f, 0.09237203f, 0.10445229f, 0.05052123f, 0.01622441f, 
    0.02026841f, -0.29236972f, -0.57590562f, -0.05484664f, -0.16226143f, 0.02414212f, 0.15984830f, 0.03036538f, 
    0.27977943f, 0.13603082f, 0.13469742f, 0.03678880f, -0.01465229f, 0.04328794f, 0.14243960f, 0.07042167f, 
    0.14774907f, -0.29335636f, 0.20663218f, -0.18822007f, -0.24635288f, 0.15568256f, 0.07480920f, 0.00100245f, 
    0.05159252f, -0.02820526f, 0.18942271f, 0.13918808f, 0.17618974f, -0.08823133f, -0.12729602f, 0.08208750f, 
    0.09142723f, 0.18992187f, -0.01292067f, 0.10379533f, -0.23014347f, 0.02513787f, -0.07330127f, -0.03198038f, 
    0.01189748f, -0.51980460f, 0.20130932f, 0.46836418f, -0.17666483f, 0.00408882f, -0.14447160f, -0.00081166f, 
    0.03820451f, 0.03283205f, -0.04191924f, -0.02599343f, -0.27214134f, 0.07478808f, 0.00199294f, -0.04195469f, 
    -0.21529819f, 0.09619661f, 0.15413781f, 0.02246549f, -0.00314853f, -0.57525414f, 0.10306423f, -0.47600713f, 
    -0.02973220f, -0.20492335f, -0.05694656f, 0.04780211f, 0.10423062f, 0.09122268f, 0.15014718f, -0.17335171f, 
    -0.29754716f, 0.01645031f, 0.03748132f, -0.05710560f, 0.04207101f, -0.16485196f, 0.00082066f, 0.17311229f, 
    -0.17920554f, 0.01753722f, -0.16535108f, 0.22931920f, 0.12935291f, 0.07269705f, 0.02141479f, 0.03942151f, 
    -0.58750522f, 0.04913363f, 0.36486807f, 0.05983786f, 0.07047331f, 0.32288918f, -0.05744547f, -0.43964073f, 
    0.00340158f, 0.08612096f, -0.08730325f, -0.16260798f, 0.04577387f, 0.13017543f, 0.10924360f, -0.34617668f, 
    -0.38209382f, 0.25505358f, 0.21847731f, 0.23361893f, -0.07441229f, -0.02331662f, -0.39442948f, 0.07027537f, 
    -0.04923987f, 0.13511318f, -0.56902403f, -0.33021045f, 0.20660262f, -0.06849948f, -0.15867388f, -0.54238361f, 
    -0.09007252f, -0.26935446f, 0.02778339f, -0.35565689f, -0.05660655f, -0.04090603f, 0.01451239f, 0.00766499f, 
    -0.00826194f, 0.26070654f, 0.15805764f, 0.16680993f, -0.20173915f, -0.03720874f, 0.30259493f, -0.16804045f, 
    -0.45822155f, 0.04977755f, -0.09908677f, 0.15496059f, -0.18119942f, -0.00082393f, 0.20676595f, -0.52100170f, 
    0.09511133f, 0.19736411f, -0.29100004f, 0.22514720f, 0.31786248f, -0.17561331f, -0.14561664f, -0.35625389f, 
    -0.03773650f, -0.10708646f, -0.50754797f, -0.45680940f, -0.12423171f, 0.02342102f, -0.05787878f, -0.05224876f, 
    0.06158331f, 0.04703163f, 0.25007826f, 0.03873346f, -0.27825254f, -0.02786323f, -0.00271108f, 0.02446676f, 
    -0.04832939f, 0.43207985f, 0.23810920f, -0.33532643f, 0.33497179f, -0.00123131f, 0.01820847f, -0.05316539f, 
    0.04742078f, -0.04685957f, 0.04835508f, -0.23835409f, -0.44269112f, -0.14034303f, -0.03463986f, -0.13666311f, 
    -0.03831443f, 0.20797889f, -0.15229858f, -0.09895957f, 0.03143591f, 0.21945862f, 0.05991840f, 0.09651660f, 
    -0.06143444f, 0.18694690f, -0.01646405f, -0.04986473f, -0.05125874f, -0.47166449f, -0.25266606f, 0.15721861f, 
    -0.02490232f, -0.36192837f, -0.08154333f, 0.12448927f, 0.10062899f, -0.11773396f, -0.05257118f, -0.20192149f, 
    -0.32058698f, 0.01545595f, 0.27409652f, -0.02767764f, -0.07805333f, 0.00620922f, 0.07860525f, 0.00323812f, 
    0.02802473f, 0.01730319f, -0.21187125f, -0.23707609f, -0.25389135f, -0.17950082f, -0.03742669f, 0.23932751f, 
    -0.45715404f, 0.21072561f, 0.00835122f, 0.10455617f, 0.01224789f, -0.17314777f, 0.08076919f, 0.18384194f, 
    -0.33395141f, -0.23829667f, 0.36452594f, -0.70653784f, 0.06427454f, -0.07651619f, -0.28034556f, 0.04750558f, 
    -0.05154739f, -0.22857276f, 0.38156101f, 0.01555095f, 0.32490879f, 0.08510132f, -0.03995941f, -0.09887196f, 
    -0.34279504f, 0.04447872f, 0.18329366f, 0.40575829f, -0.39734751f, -0.05213084f, 0.01952883f, 0.00547606f, 
    0.04410082f, 0.21417500f, -0.29043299f, -0.05261495f, 0.03639784f, 0.03187756f, -0.45946875f, -0.07775021f, 
    -0.15577440f, -0.40685782f, -0.03540135f, -0.04478303f, 0.30009863f, 0.00527265f, 0.10016740f, -0.22337578f, 
    0.15168914f, -0.35113069f, -0.28057286f, 0.17156717f, -0.21878718f, 0.11149836f, 0.01907440f, -0.40205693f, 
    0.11173693f, -0.33055630f, 0.15735944f, -0.16381402f, 0.09250800f, 0.03104764f, 0.07920188f, 0.02881939f, 
    0.22890271f, 0.00238920f, 0.41527805f, -0.36698288f, -0.36886489f, 0.06247067f, -0.07306468f, 0.06975116f, 
    0.01992490f, 0.28472888f, -0.44210061f, 0.04801233f, 0.15507001f, 0.04032992f, 0.03668272f, 0.04267483f, 
    0.07335819f, 0.05306894f, -0.09079167f, -0.10386357f, 0.23230654f, -0.03734500f, -0.04597838f, -0.22641651f, 
    0.05320607f, -0.32909688f, -0.51471788f, -0.09917630f, -0.08532632f, -0.25443622f, 0.11352798f, -0.03602048f, 
    0.03312876f, -0.25398523f, -0.00743930f, 0.05185968f, -0.02765952f, 0.07041815f, 0.19515017f, 0.22348025f, 
    0.05009472f, -0.16103461f, -0.02615880f, 0.19822711f, -0.12788008f, -0.01397771f, -0.08546279f, 0.21334186f, 
    -0.00442066f, -0.04146954f, 0.14079131f, -0.08134847f, 0.31563956f, -0.04236206f, -0.05417376f, 0.02752247f, 
    -0.07738595f, -0.02183795f, -0.13398406f, -0.03237724f, 0.13060157f, -0.11246222f, -0.00828127f, 0.16221568f, 
    0.08323786f, 0.06555432f, 0.02404762f, 0.02928384f, 0.02282956f, -0.51239794f, 0.09221177f, 0.18169670f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.10510872f, 0.10480207f, 0.14479823f, 0.00415089f, -0.12844056f, 0.01259028f, 0.03028306f, -0.07199667f, 
    0.17606172f, 0.03440271f, -0.03133900f, 0.06322020f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
