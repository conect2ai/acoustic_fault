#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.53739697f, 0.27436453f, 0.38096219f, 0.22143666f, 0.54045975f, 0.59758079f, 0.41755319f, -0.41693228f, 
    -0.10292649f, 0.59078866f, 0.40192267f, 0.38874796f, 0.00880360f, 0.35067290f, 0.31210488f, 0.19950204f, 
    0.09059574f, -0.40183121f, 0.61860949f, 0.27327442f, -0.48542488f, -0.55224419f, 0.11489083f, 0.35436210f, 
    0.09963993f, -0.01955969f, 0.07295591f, 0.34731847f, -0.68929279f, -0.43409359f, 0.37346002f, -0.05076462f, 
    0.81231546f, 0.00875729f, -0.33154106f, -0.37282357f, -0.49505073f, -0.19735231f, -0.24081624f, 0.37884215f, 
    -0.07362561f, -0.67791241f, 0.25725579f, 0.24104823f, 0.25634992f, -0.33834362f, 0.00423708f, 0.36149001f, 
    -0.62708306f, -0.47433472f, -0.66695541f, 0.69964474f, -0.01051177f, -0.07853146f, 0.69110131f, -0.64398193f, 
    0.47629017f, -0.22250812f, 0.30588484f, -0.05922987f, 0.02614756f, 0.21256956f, 0.08960798f, 0.19083616f, 
    0.19662935f, 0.34996000f, 0.36465281f, -0.08592187f, 0.06506939f, 0.13013926f, 0.57662058f, -0.48381430f, 
    0.61201143f, -0.06981984f, 0.09891724f, -0.40704033f, -0.14724086f, -0.06616578f, 0.19417499f, 0.06385834f, 
    0.35143363f, -0.76108325f, -0.43966365f, -0.35654512f, 0.33508676f, 0.89600754f, -0.24747677f, 0.08941501f, 
    -0.11940843f, -0.01041417f, 0.16616102f, 0.40623403f, 0.06148982f, 0.33412120f, 0.19728689f, -0.42306030f, 
    -0.10117204f, 0.35737008f, 0.40417549f, -0.48062339f, 0.57649022f, -0.17360355f, 0.01072440f, -0.07035136f, 
    -0.17638324f, 0.23190866f, 0.36626616f, 0.01195651f, -0.13553789f, -0.10988233f, 0.14389279f, -0.54023409f, 
    -0.19487031f, 0.05137299f, -0.42583477f, 0.76075721f, -0.28947645f, -0.19496512f, -0.25988504f, 0.22843347f, 
    -0.30987215f, -0.73229235f, -0.41423520f, -0.03970281f, 0.38639426f, 0.02605166f, 0.52165824f, 0.36567348f, 
    -0.39431906f, -0.06174360f, -0.16943982f, 0.23983377f, -0.05486516f, 0.60785526f, -0.62861133f, -0.66795814f, 
    -0.09450780f, 0.78157318f, -0.19385062f, 0.48968166f, -0.38685849f, -0.26380095f, 0.35322928f, 0.26302859f, 
    0.00535921f, -0.11366592f, -0.53504336f, -0.45811868f, -0.11796165f, -0.30712777f, -0.20321673f, 0.39350542f, 
    -0.21556589f, 0.53744477f, 0.72706842f, -0.63037699f, 0.13638613f, -0.43068483f, -0.56284982f, -0.29829407f, 
    0.17098196f, 0.02664875f, -0.58839774f, -0.15006876f, 0.12744330f, 0.49163130f, 0.13841368f, 0.30383870f, 
    0.44661164f, 0.08203308f, -0.10909918f, -0.36453155f, -0.54881054f, -0.32775864f, 0.83198088f, 0.06734063f, 
    -0.48062870f, -0.19972746f, -0.49715865f, -0.11449044f, 0.32972768f, -0.25345263f, 0.08669221f, -0.15663882f, 
    -0.09669365f, -0.27167770f, 0.16763812f, 0.28354183f, 0.59893656f, 0.27776876f, -0.41872951f, 0.37480935f, 
    -0.09619980f, -0.43076670f, 0.47962224f, -0.12464191f, -0.29571974f, 0.29626158f, -0.55466342f, 0.16968782f, 
    0.59046984f, 0.28327477f, 0.03434238f, 0.32358229f, -0.41395766f, -0.50493640f, -0.03951044f, -0.57781261f, 
    0.26473755f, 0.27514362f, 0.17096113f, 0.08132395f, -0.12034719f, -0.06685067f, 0.40645254f, -0.49489310f, 
    0.01675307f, 0.31103930f, 0.37792194f, -0.75267887f, 0.20220530f, 0.46271083f, -0.10727779f, -0.05302720f, 
    0.48583308f, -0.59326535f, 0.36271155f, -0.41941756f, 0.09844458f, 0.10758534f, 0.18651985f, 0.12790224f, 
    0.01683182f, 0.51185220f, -0.49449575f, -0.21054545f, 0.12841177f, 0.80557179f, -0.53682327f, -0.39979914f, 
    -0.17791505f, 0.25290403f, -0.59628159f, 1.14957714f, -0.61624575f, -0.82166106f, -0.14885952f, -0.15407695f, 
    -0.05205834f, -0.00741756f, 0.21544659f, -0.09337153f, -0.23063815f, 0.13616194f, -0.51729488f, -0.46271762f, 
    -0.17079069f, -0.33382270f, -0.05851771f, 0.58809888f, 0.47734767f, -0.29820764f, 0.50602514f, -0.26099169f, 
    -0.23801205f, -0.14575329f, -0.33230883f, -0.33798736f, -0.20350449f, -0.63976032f, 0.23032820f, 0.47463891f, 
    0.43702033f, 0.28563702f, -0.63399011f, -0.57092190f, 0.16540493f, 0.00982440f, 0.02796457f, -0.19756192f, 
    0.36676803f, 0.48364896f, -0.37445334f, -0.36929354f, 0.41438541f, -0.17049572f, -0.41891065f, 0.65189594f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.29629549f, -0.26524401f, 0.02506210f, -0.04222748f, 0.11726785f, 0.08457962f, 0.22737728f, -0.26168865f, 
    -0.00849439f, -0.05068456f, -0.34290919f, -0.15006290f, -0.23036346f, -0.08676244f, -0.03182201f, -0.18356785f, 
    -0.27684367f, 0.04015845f, -0.23883753f, -0.24582560f, -0.17180732f, 0.31827557f, 0.07732601f, 0.34740788f, 
    0.04967567f, 0.17401533f, -0.14606750f, -0.23447631f, 0.02476897f, 0.03306502f, -0.04905568f, -0.01164024f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03890351f, -0.09024192f, -0.04392000f, -0.04023853f, 0.02071157f, -0.15489765f, -0.00075067f, -0.08374666f, 
    -0.01261811f, -0.22290161f, -0.07480406f, -0.18212140f, -0.17329709f, -0.02246191f, -0.13076632f, -0.03934184f, 
    0.05413128f, 0.09061427f, 0.14020473f, -0.04403302f, -0.15777461f, 0.10958780f, -0.03445079f, 0.11223055f, 
    0.09583072f, 0.10029276f, 0.04157255f, 0.04145141f, -0.09258274f, 0.08122765f, -0.08258663f, -0.21179008f, 
    0.02751444f, -0.00768474f, -0.13726065f, -0.08834718f, -0.32558313f, -0.02996697f, 0.04813641f, 0.14775664f, 
    0.09518804f, 0.02581814f, 0.10926326f, 0.07651041f, 0.07759873f, -0.10458967f, -0.17579415f, -0.29835579f, 
    0.10521927f, 0.01802602f, -0.02033515f, 0.17480761f, 0.11548223f, 0.14224771f, 0.23590159f, 0.00508874f, 
    0.00981283f, 0.03252687f, 0.03982491f, 0.03057534f, 0.04428723f, 0.03146547f, 0.14785258f, -0.20187540f, 
    -0.15327132f, -0.15507892f, -0.05437879f, -0.15343423f, -0.15944433f, -0.00287150f, 0.15634724f, -0.00775749f, 
    0.03638756f, -0.14420506f, -0.28505632f, -0.00517892f, 0.01521161f, -0.01908973f, 0.12972999f, 0.16828014f, 
    0.04431160f, -0.15269744f, -0.00758022f, 0.20382053f, 0.05238164f, -0.14369531f, 0.01271728f, -0.12575965f, 
    -0.06721333f, 0.02275373f, -0.17296505f, -0.23546572f, -0.09154975f, 0.00840502f, -0.02648706f, -0.02380404f, 
    -0.00646454f, 0.14206676f, 0.02070488f, -0.23497277f, 0.08608818f, -0.10561543f, -0.08679070f, -0.13161498f, 
    0.05077023f, 0.12928250f, 0.14031459f, 0.04217415f, -0.13448133f, -0.19553435f, -0.18894435f, -0.07721923f, 
    -0.07608986f, -0.00184568f, 0.12200536f, -0.11894903f, 0.18931046f, -0.18631013f, -0.15085147f, -0.26693663f, 
    -0.03502413f, 0.01675635f, 0.04420538f, 0.14566629f, -0.08458979f, 0.03911021f, 0.14479639f, -0.20142131f, 
    -0.14368926f, 0.05017533f, 0.03078720f, 0.10883021f, 0.14101566f, -0.03691844f, 0.05953247f, -0.09752614f, 
    -0.34618816f, 0.09047756f, 0.06857342f, -0.05660662f, 0.02855773f, 0.14625457f, -0.00691404f, 0.17390235f, 
    -0.17843549f, -0.01611927f, -0.14552419f, -0.18103799f, -0.07350986f, 0.03054406f, 0.02773219f, -0.01888775f, 
    0.06759848f, 0.02029407f, -0.12440474f, -0.17162855f, 0.17704134f, 0.24690779f, 0.10551219f, 0.11310134f, 
    0.01740240f, 0.01656824f, -0.12156074f, -0.06842092f, -0.01988254f, 0.09711171f, 0.11362533f, -0.06628893f, 
    -0.07633694f, -0.04424861f, 0.11213348f, -0.13943736f, -0.14409132f, 0.04971281f, -0.18796328f, -0.23392630f, 
    -0.18240373f, -0.04667188f, -0.06134829f, -0.12153044f, 0.07164890f, -0.17745057f, -0.14592606f, -0.10397406f, 
    -0.02842131f, -0.00913152f, 0.22298442f, 0.01083035f, 0.13782571f, 0.07239699f, 0.13239481f, 0.17280906f, 
    0.07975767f, -0.02023324f, 0.22177175f, 0.12438164f, -0.15414882f, 0.08013975f, 0.00788706f, 0.11032121f, 
    0.12226514f, -0.08078218f, -0.07737745f, 0.08289836f, 0.03973882f, -0.01951267f, -0.08123603f, 0.01309385f, 
    -0.02894564f, 0.19551453f, 0.12382740f, 0.10393886f, 0.14891762f, 0.10108423f, 0.09579761f, 0.03394280f, 
    0.01920418f, -0.12034631f, -0.16791619f, -0.09770805f, -0.02359277f, 0.07772060f, 0.11049447f, 0.09149046f, 
    0.08425411f, -0.00886076f, 0.11984856f, 0.13689885f, 0.11764528f, 0.05152514f, 0.03133693f, 0.06008886f, 
    0.01996471f, 0.19970837f, 0.03153198f, -0.21626076f, -0.09809095f, -0.12190766f, 0.03785155f, -0.11573000f, 
    0.00218316f, 0.12550217f, -0.08636463f, -0.02489045f, -0.01363474f, -0.20617031f, 0.22574954f, -0.02729652f, 
    -0.00241108f, -0.14393200f, 0.11110509f, -0.02236173f, -0.13479234f, 0.20919238f, -0.01266280f, -0.06294136f, 
    -0.02496049f, 0.01667839f, 0.09839796f, 0.06449125f, 0.19665168f, -0.18981987f, -0.10912550f, -0.04983469f, 
    -0.02021239f, 0.08690335f, 0.06470523f, -0.00912402f, -0.01588500f, 0.07520575f, -0.23040468f, -0.26333073f, 
    -0.24900593f, 0.04648326f, 0.09225722f, -0.01363237f, 0.13551039f, 0.01255608f, 0.08257978f, 0.04782731f, 
    -0.14540511f, 0.03596469f, -0.00778312f, 0.04764979f, 0.15027040f, 0.04936341f, 0.12515171f, 0.01536597f, 
    -0.08918275f, -0.21619412f, 0.05685036f, -0.16794623f, -0.26402345f, -0.12953861f, 0.02453481f, 0.11275474f, 
    0.08625183f, 0.04029946f, -0.17684036f, -0.07715357f, 0.00351681f, -0.13307519f, -0.18983479f, -0.09950601f, 
    0.20126106f, 0.03136445f, -0.16782422f, -0.09201294f, 0.08753264f, 0.22973904f, -0.23797406f, 0.13337927f, 
    -0.14334178f, -0.09675622f, 0.08291869f, 0.33059067f, 0.02102123f, 0.01251405f, -0.04364033f, -0.04094293f, 
    -0.14389451f, 0.04614797f, -0.15495242f, -0.17415404f, 0.15317474f, 0.18362314f, 0.13429937f, -0.02848421f, 
    0.04069776f, 0.03123298f, -0.12899435f, 0.00010800f, 0.14797777f, -0.15125918f, 0.14800423f, -0.04075843f, 
    -0.09276941f, -0.08459949f, 0.11873849f, 0.00319489f, 0.03984869f, 0.09819628f, -0.13619955f, -0.25285980f, 
    0.03985512f, -0.07118034f, -0.03371010f, 0.18287842f, 0.04853551f, 0.04071371f, 0.11443779f, -0.23134509f, 
    -0.10556856f, -0.05934319f, -0.17533615f, 0.08504703f, 0.00270732f, -0.14848818f, 0.19598970f, -0.11782587f, 
    -0.10427910f, -0.01957064f, 0.02339957f, -0.00345756f, -0.04027146f, -0.05242693f, -0.07276525f, 0.05775299f, 
    0.15477008f, 0.15662624f, -0.03031465f, -0.03659614f, 0.08646011f, 0.06508952f, -0.03675360f, 0.04578250f, 
    0.07518294f, -0.08403609f, -0.15075006f, -0.31770971f, -0.33839881f, -0.01875263f, -0.11412244f, -0.08644119f, 
    -0.01030915f, -0.08091731f, 0.14666098f, -0.08225713f, 0.19544414f, 0.14663267f, -0.06163303f, -0.10115222f, 
    0.11578210f, 0.03941476f, 0.08444194f, 0.20696433f, -0.03435057f, 0.01604708f, 0.08523788f, 0.17542776f, 
    -0.03393011f, 0.09830913f, 0.00606947f, 0.08558153f, 0.10378084f, 0.03223739f, 0.20042868f, 0.06683576f, 
    -0.08087079f, -0.03172851f, 0.03891075f, -0.00264483f, 0.07346145f, 0.13118970f, -0.12381051f, 0.16563305f, 
    0.09232516f, -0.05191405f, 0.08289781f, -0.05604924f, -0.12758942f, 0.01246325f, -0.08055432f, 0.01648171f, 
    -0.06404528f, -0.12593512f, -0.08502641f, 0.01387119f, 0.18474360f, -0.06726728f, 0.12029632f, 0.12693408f, 
    -0.06490462f, 0.12648509f, 0.10796506f, 0.09908400f, 0.04461903f, -0.05063658f, -0.01722312f, 0.03503312f, 
    -0.04421487f, -0.03476614f, -0.06608543f, -0.30576909f, -0.07529276f, 0.00037520f, -0.03161571f, -0.04726207f, 
    0.08854600f, 0.02736560f, -0.16827734f, -0.36255637f, -0.10810222f, -0.02822928f, 0.13040306f, 0.03872152f, 
    0.11570015f, -0.01829840f, 0.05625955f, 0.25672516f, 0.12407239f, 0.01349535f, -0.00714656f, 0.13896471f, 
    -0.08953669f, 0.06936233f, -0.01479456f, -0.20343202f, -0.02661129f, 0.13227145f, 0.01619320f, -0.09404271f, 
    0.07773409f, -0.21022044f, 0.02383202f, -0.02059869f, 0.12560104f, 0.05889426f, 0.10125633f, 0.07529647f, 
    0.09810483f, 0.05459156f, 0.08798883f, 0.00072638f, 0.07158205f, 0.01948964f, -0.49803624f, -0.07157166f, 
    0.07718541f, -0.01433383f, 0.01432998f, -0.12573563f, 0.18230021f, 0.01661482f, -0.09910268f, -0.19490276f, 
    -0.01914853f, 0.16914980f, 0.01494479f, -0.02079796f, 0.09383341f, -0.09138174f, -0.02048937f, -0.10955211f, 
    -0.06065553f, -0.21188721f, 0.10702876f, 0.07371486f, -0.08064390f, -0.05599555f, -0.06238709f, 0.11018568f, 
    0.01353076f, -0.45238653f, -0.25375339f, -0.08305568f, 0.02404448f, -0.01529300f, 0.14968434f, -0.02441522f, 
    0.07640009f, 0.21784934f, 0.28313830f, -0.00048773f, 0.05686173f, 0.06897031f, 0.02352260f, -0.03075609f, 
    -0.07450344f, -0.05447591f, 0.00407466f, 0.12885050f, 0.02466574f, -0.05704132f, 0.01310742f, -0.02672980f, 
    0.00668074f, 0.08143951f, 0.03416311f, -0.12802885f, -0.02493362f, 0.05614195f, 0.10036590f, -0.01393281f, 
    0.06521405f, 0.01571251f, -0.09046421f, 0.02805382f, 0.10885711f, -0.07408801f, 0.20222978f, -0.03741176f, 
    -0.04321850f, -0.02428349f, 0.02077338f, 0.12417916f, -0.16751821f, -0.04131686f, -0.17674792f, -0.15185262f, 
    -0.54949349f, -0.16554916f, -0.16028616f, -0.09787767f, 0.01537194f, 0.03100010f, -0.00902651f, -0.14056483f, 
    -0.27129492f, 0.12085213f, -0.03891836f, -0.07072967f, 0.02331220f, 0.05765818f, 0.16678767f, 0.07793439f, 
    -0.15491496f, 0.12882726f, 0.12487128f, -0.07393398f, -0.06842296f, -0.09587475f, 0.03184741f, 0.07552968f, 
    0.09103923f, -0.31682643f, -0.11353957f, -0.00308306f, -0.01553451f, 0.00819656f, -0.09876374f, 0.13171138f, 
    0.14965305f, -0.03093505f, -0.05652017f, 0.02977048f, -0.25587738f, -0.00830200f, 0.06814644f, -0.05047019f, 
    0.01997086f, -0.00005070f, 0.03189126f, -0.46261886f, 0.22169816f, 0.00248059f, 0.00722770f, -0.08511747f, 
    0.16232492f, -0.04970726f, 0.04071710f, -0.12674534f, -0.03292924f, -0.00766768f, 0.10944434f, -0.03887330f, 
    -0.14723808f, -0.06070284f, 0.00548164f, 0.18692899f, 0.15936796f, 0.06518334f, -0.22054464f, 0.18506807f, 
    0.00987049f, 0.05958886f, -0.03172651f, 0.17614752f, -0.03102110f, 0.09630749f, -0.27122220f, -0.17481108f, 
    -0.28831187f, 0.04512524f, -0.00759032f, 0.07803971f, 0.10961328f, -0.05028712f, -0.04314497f, -0.24055873f, 
    0.01347877f, 0.20999262f, -0.01557612f, -0.12307748f, -0.02341168f, 0.04962821f, 0.17349237f, -0.22468522f, 
    -0.11862118f, -0.03364756f, -0.00813403f, -0.11028580f, 0.15783666f, 0.07985110f, -0.01891256f, -0.14318284f, 
    -0.33749121f, -0.36908782f, 0.02089095f, 0.53200728f, -0.19779184f, -0.17189191f, -0.05302386f, 0.02566741f, 
    -0.01302564f, -0.00976544f, -0.05643804f, -0.14743841f, -0.17184079f, -0.07562692f, 0.08140209f, 0.03350681f, 
    0.10832396f, -0.06006833f, 0.02768340f, 0.17126848f, -0.24906799f, -0.10018644f, 0.08007205f, 0.12892331f, 
    -0.05716665f, -0.05550553f, 0.17356069f, -0.04762920f, -0.03410828f, 0.21940626f, 0.19697893f, -0.31379399f, 
    0.04754621f, -0.06943050f, -0.06924457f, 0.13494852f, -0.08121627f, 0.01113334f, 0.10328770f, 0.10829432f, 
    -0.02636855f, -0.01661211f, -0.03836692f, 0.10292846f, -0.00180073f, -0.02271804f, 0.04518958f, -0.00848549f, 
    -0.15914038f, -0.00084784f, 0.24568202f, -0.01263708f, 0.09327412f, 0.15928338f, -0.19110987f, -0.20036370f, 
    0.05852524f, -0.20588404f, 0.01120545f, -0.03187027f, -0.06996366f, -0.12058631f, -0.09740923f, 0.18278004f, 
    -0.16955401f, 0.29252169f, 0.04719908f, -0.10221560f, -0.14455312f, -0.04846679f, 0.07444651f, 0.03909655f, 
    -0.05219879f, 0.09058565f, 0.12362112f, 0.09271651f, -0.02170607f, 0.08687886f, -0.01350100f, 0.07101303f, 
    -0.14042811f, 0.06139842f, 0.03528295f, 0.19196169f, 0.26840657f, -0.12636691f, 0.00132777f, -0.13424788f, 
    0.23948403f, 0.04066948f, -0.00270780f, -0.31080067f, -0.21112482f, 0.28351483f, -0.09681372f, -0.18015890f, 
    -0.00305427f, 0.06022057f, -0.13421392f, 0.05599017f, -0.07873660f, 0.12317746f, -0.22177963f, 0.03554314f, 
    -0.02766528f, -0.08888855f, 0.02811397f, -0.00369259f, 0.06270027f, -0.00543935f, 0.02810352f, 0.03194119f, 
    0.01035764f, 0.17920427f, 0.13729030f, 0.10674198f, 0.00030373f, 0.11940099f, -0.35078713f, -0.12479009f, 
    0.04737866f, -0.09412713f, 0.14097552f, -0.00336563f, -0.18017280f, 0.01931968f, 0.16565371f, -0.07992144f, 
    0.16563004f, 0.09468094f, -0.04410490f, 0.07474779f, 0.01533053f, -0.01743795f, 0.05843394f, 0.00090256f, 
    -0.22885813f, -0.31777143f, 0.03223877f, 0.03216476f, 0.03166123f, -0.02269545f, -0.04130424f, 0.02899971f, 
    0.08643922f, 0.14656581f, 0.10149549f, 0.20725971f, -0.03261652f, 0.00567843f, -0.11859680f, 0.06372096f, 
    0.12570539f, 0.10924642f, -0.30469310f, -0.03626240f, 0.16811323f, 0.00508051f, 0.04459180f, -0.11516698f, 
    0.11660638f, -0.14152078f, -0.01521416f, -0.24313962f, 0.25343654f, -0.33916974f, 0.04958913f, -0.11002051f, 
    0.07919677f, -0.12727568f, -0.06293806f, 0.07564928f, 0.01331735f, 0.18850742f, 0.00284354f, -0.11370929f, 
    0.02907625f, -0.05007970f, 0.06854086f, 0.04378427f, -0.01484674f, 0.01033874f, -0.01591780f, 0.15901612f, 
    0.10459229f, 0.11125012f, -0.05106630f, 0.18597911f, 0.11695509f, 0.18039531f, -0.10037083f, -0.29782057f, 
    0.15950942f, -0.00049834f, 0.13890885f, -0.03052807f, -0.00806676f, -0.11413307f, -0.04555111f, -0.00451739f, 
    -0.19725168f, 0.10090028f, -0.04105251f, 0.08669962f, -0.25696111f, -0.14157921f, -0.02151915f, 0.09059178f, 
    0.11538450f, 0.09284052f, 0.00465534f, -0.19667053f, -0.27285933f, -0.25057167f, -0.12891224f, -0.04994647f, 
    -0.04210571f, 0.09304684f, -0.00409851f, 0.01480256f, -0.01574540f, -0.09984864f, -0.16320111f, 0.11387388f, 
    0.02080083f, -0.02182087f, 0.01932716f, -0.09952367f, -0.10856387f, 0.06980798f, -0.12522979f, 0.12173536f, 
    -0.09009876f, 0.15614404f, 0.05431724f, 0.17030087f, 0.14302638f, -0.23828936f, 0.02101245f, -0.25360295f, 
    -0.20188965f, 0.00042003f, 0.02174675f, -0.01447793f, 0.08718078f, -0.00264648f, -0.09965901f, -0.12444089f, 
    0.15154071f, -0.12107334f, 0.04662058f, -0.14942677f, -0.01817815f, -0.52598238f, -0.18992060f, 0.08182269f, 
    -0.05508829f, 0.12618719f, 0.06583607f, 0.00781320f, -0.07315712f, 0.06833471f, 0.08351362f, 0.10877720f, 
    0.04668644f, 0.03229082f, 0.05456669f, 0.13555425f, 0.01629071f, 0.04783554f, 0.10278843f, 0.06392189f, 
    0.03845964f, 0.12093392f, 0.03321642f, -0.03827705f, -0.28707010f, -0.04851247f, -0.08567522f, -0.04077588f, 
    -0.01120102f, 0.09734251f, 0.17338686f, 0.06049401f, 0.08699577f, 0.02113850f, -0.00730752f, 0.02268158f, 
    0.11771967f, 0.22254552f, -0.10584285f, -0.32612300f, -0.01860512f, -0.06788190f, -0.15272136f, -0.00541390f, 
    0.12283894f, -0.10442191f, 0.07190218f, 0.07917535f, -0.10680208f, 0.01810276f, 0.06049736f, -0.19305985f, 
    0.19146296f, 0.03953195f, -0.08141007f, 0.06111867f, 0.04522670f, 0.07664441f, 0.02418870f, 0.28342465f, 
    -0.06537343f, -0.12394343f, 0.08146928f, -0.00814536f, -0.20922852f, -0.12149186f, 0.15401182f, -0.03908710f, 
    0.08167437f, -0.01518640f, 0.02589244f, 0.03377422f, -0.09117668f, -0.39810199f, -0.08452881f, 0.23333083f, 
    0.04160774f, 0.09914216f, -0.02972067f, 0.01507917f, -0.10758380f, -0.05815220f, 0.14331180f, -0.04475706f, 
    0.14805174f, 0.09900402f, 0.02116708f, -0.01012895f, 0.09093846f, 0.07961809f, 0.03215378f, -0.18529955f, 
    0.19021128f, 0.02331400f, 0.01401201f, 0.02399052f, -0.03933052f, -0.01233599f, -0.08790305f, -0.13517848f, 
    -0.04822818f, -0.05285677f, -0.00168629f, -0.05808028f, 0.07306036f, 0.00147871f, 0.03742889f, 0.11825272f, 
    0.03156099f, 0.01018645f, -0.29102457f, 0.18427463f, -0.02117760f, 0.09048547f, 0.17709275f, -0.13186190f, 
    0.01656608f, 0.08261534f, 0.13009180f, 0.08005960f, -0.03344747f, 0.01922915f, -0.06103715f, -0.14386886f, 
    0.03694942f, -0.02581823f, -0.10608181f, -0.00590189f, -0.12555355f, 0.03473284f, 0.00769624f, 0.02954263f, 
    -0.14878708f, -0.00635214f, 0.01459072f, 0.04624724f, -0.00375057f, 0.04136652f, 0.04421184f, 0.05779479f, 
    0.15315768f, -0.01537673f, -0.03532722f, -0.13723144f, 0.18762499f, -0.00896781f, 0.03206019f, 0.03189361f, 
    0.04696659f, -0.02060302f, 0.10190791f, 0.02433990f, 0.07354629f, -0.10539527f, -0.11663610f, 0.12308365f, 
    0.03395193f, 0.02663812f, -0.06046103f, -0.28596076f, -0.01747234f, -0.14174035f, -0.04859615f, -0.02619861f, 
    0.10617793f, 0.27270478f, 0.00394618f, 0.02241224f, -0.03800370f, -0.06283201f, -0.00943947f, -0.00725354f, 
    -0.06946638f, 0.09698840f, -0.13400532f, 0.10838874f, -0.10024396f, -0.07782665f, -0.11473328f, 0.04318588f, 
    -0.05583465f, 0.13999727f, 0.17964186f, -0.12233282f, -0.00095991f, 0.00857216f, 0.07287246f, 0.02871771f, 
    0.02627927f, -0.10010032f, -0.13899077f, -0.17034039f, 0.15164663f, 0.03871519f, 0.16277526f, 0.00710965f, 
    0.04733784f, -0.02917127f, -0.06793622f, -0.02787267f, -0.36273113f, 0.09007470f, -0.09569854f, 0.14905712f, 
    0.10110500f, -0.06239345f, 0.12729494f, 0.09239771f, 0.07149762f, -0.08730337f, -0.13816829f, -0.03363103f, 
    0.09339512f, 0.03417307f, -0.04452972f, -0.11140731f, -0.01115955f, -0.18956892f, 0.10322788f, -0.10409760f, 
    0.10748141f, 0.15440507f, 0.15440175f, -0.12084281f, -0.13779262f, -0.14647019f, -0.24273781f, -0.26318827f, 
    0.08429138f, 0.01262978f, 0.05918750f, -0.00111506f, 0.02160503f, 0.20916930f, 0.15323111f, -0.32712314f, 
    -0.00325938f, -0.03010958f, 0.11186906f, -0.09586314f, -0.13809818f, 0.02945177f, 0.12925439f, -0.12458254f, 
    -0.11749231f, 0.06930349f, 0.04606802f, -0.07170672f, -0.06058215f, -0.12846166f, -0.04140017f, 0.01982360f, 
    0.11049408f, -0.03544060f, -0.09402478f, 0.18977721f, 0.05589141f, 0.11327989f, 0.05447283f, -0.01052784f, 
    -0.26973805f, 0.06319527f, -0.16081680f, 0.07473691f, 0.16741981f, 0.00022157f, -0.01993170f, 0.03151496f, 
    0.02274713f, -0.08522651f, 0.28279543f, 0.22982323f, 0.06545635f, 0.12765452f, -0.07477336f, 0.05774215f, 
    -0.26705509f, 0.10331822f, 0.20933469f, -0.16774830f, 0.17847124f, -0.04216860f, 0.04054398f, -0.08853688f, 
    0.00537274f, 0.08351441f, 0.07236009f, 0.07927723f, 0.01364800f, -0.12405727f, 0.02201753f, 0.19170110f, 
    -0.00032416f, -0.07569491f, 0.10941707f, -0.12181719f, -0.09948184f, -0.02815843f, -0.17070565f, 0.00922002f, 
    -0.10117621f, -0.08183467f, 0.05400908f, 0.02723859f, -0.03402065f, -0.00410127f, 0.01922912f, -0.04123802f, 
    0.02330132f, 0.10606115f, 0.04161949f, 0.04218401f, 0.12522162f, -0.05006488f, -0.16846715f, -0.00972385f, 
    -0.19541238f, -0.00430936f, 0.04037876f, 0.01247376f, 0.05581799f, 0.05493359f, -0.13440417f, -0.03833690f, 
    0.22814989f, 0.06307201f, -0.01491971f, 0.14198132f, -0.05320423f, 0.04584680f, -0.04596400f, -0.04894814f, 
    -0.07804317f, 0.00515910f, -0.06064854f, -0.04442607f, 0.06083355f, 0.19168279f, -0.01599287f, 0.10641398f, 
    -0.11011984f, -0.18772328f, 0.05586544f, 0.19991277f, -0.07812110f, 0.16332144f, -0.09809835f, -0.30574483f, 
    0.10217361f, -0.20472407f, -0.38672394f, -0.04494576f, 0.15840493f, -0.19085710f, -0.12832206f, -0.01187930f, 
    -0.14613192f, 0.02634166f, 0.01544502f, -0.18675563f, -0.10523356f, 0.00987555f, -0.10013351f, 0.02928409f, 
    -0.01790065f, 0.02354457f, 0.08951194f, -0.09989026f, 0.03111210f, 0.05915881f, 0.11935300f, -0.07345822f, 
    0.11770944f, -0.06636980f, -0.06094748f, -0.02306371f, -0.02333185f, -0.18344805f, 0.30451414f, 0.07479241f, 
    0.16878790f, -0.04704134f, -0.10454211f, 0.03211077f, 0.13328399f, -0.01673764f, -0.01668500f, -0.01572514f, 
    0.05056121f, -0.25675821f, -0.04802892f, 0.17756613f, -0.09430256f, 0.13277325f, 0.01003220f, -0.03813786f, 
    -0.46366194f, -0.12663712f, -0.26769501f, 0.13670318f, -0.02595309f, -0.02644606f, 0.00163448f, -0.26417884f, 
    0.09506061f, -0.12679106f, -0.05273267f, -0.03311130f, 0.03682747f, -0.22936998f, -0.06756522f, -0.06735841f, 
    -0.05239324f, 0.03403353f, -0.08440735f, 0.16165049f, 0.21317549f, 0.25946525f, 0.05266976f, 0.19386826f, 
    -0.03083488f, 0.02430458f, -0.05165878f, 0.04415385f, -0.04097575f, 0.11143363f, 0.03889539f, 0.04662760f, 
    0.08775695f, 0.04502810f, -0.14724904f, -0.17910956f, 0.12126967f, -0.12714109f, -0.00778738f, -0.09227018f, 
    -0.03083437f, 0.19214033f, -0.09525064f, 0.09451086f, 0.10110748f, 0.00336792f, -0.07694858f, 0.03571108f, 
    0.07494845f, 0.08215048f, 0.17757443f, -0.20471068f, 0.07073662f, 0.15472987f, -0.03658984f, 0.15736154f, 
    -0.00600571f, -0.12991604f, -0.07436558f, 0.08287179f, 0.08007526f, 0.05711770f, -0.02359085f, 0.10569189f, 
    -0.07336000f, -0.11539624f, 0.15976715f, 0.14689906f, 0.13236430f, -0.05463556f, -0.02985725f, -0.01992182f, 
    -0.02509399f, -0.05326591f, -0.03951991f, 0.05959122f, -0.04232613f, 0.19172618f, -0.05974104f, 0.11943927f, 
    -0.05601945f, 0.09569456f, 0.12102509f, -0.00909002f, -0.10584903f, 0.10031333f, 0.12284497f, 0.09366524f, 
    0.08360541f, 0.03106778f, 0.00060878f, -0.03951844f, 0.09794953f, 0.04333932f, -0.09949031f, -0.11781711f, 
    -0.03734551f, -0.04645617f, 0.14872527f, -0.20098385f, 0.15607603f, -0.02415995f, -0.04551623f, 0.06378034f, 
    0.07011264f, 0.09403627f, 0.01477928f, -0.17700082f, -0.11603790f, 0.06165343f, -0.03136966f, -0.06618552f, 
    0.20183608f, 0.05881064f, -0.06384052f, -0.07374486f, -0.08115265f, -0.27171740f, -0.16397297f, -0.05425829f, 
    0.06947414f, -0.13903725f, -0.03846928f, 0.08912195f, -0.24357131f, 0.09984796f, 0.13626613f, -0.27441591f, 
    0.01604606f, -0.07774869f, 0.04917184f, 0.18522388f, -0.09796607f, 0.01396165f, 0.15204735f, -0.13044316f, 
    0.06934267f, -0.03738209f, 0.11423395f, 0.01191029f, 0.15061237f, -0.01989675f, -0.08823834f, -0.15775594f, 
    -0.08761634f, -0.02626129f, 0.08290424f, 0.21992104f, -0.07963672f, -0.01212335f, 0.05278193f, 0.01367762f, 
    -0.13256656f, 0.08957198f, -0.06481807f, -0.02045792f, 0.18696781f, 0.08453398f, 0.04017843f, -0.02339640f, 
    -0.07565732f, -0.02030496f, -0.01538135f, 0.04361965f, -0.09884743f, -0.15028146f, -0.19418222f, -0.05903408f, 
    -0.02570710f, -0.00826509f, -0.11072052f, -0.31659019f, 0.02323730f, 0.05367739f, -0.19718255f, -0.07797911f, 
    -0.14455643f, 0.00615635f, 0.05261154f, -0.01098747f, 0.00302625f, 0.05497942f, 0.25117391f, 0.04041637f, 
    0.04760065f, -0.09785801f, 0.12238620f, 0.01138947f, 0.13574119f, 0.11606096f, 0.11354075f, 0.03189985f, 
    0.01909472f, 0.03772603f, 0.04519979f, 0.07063055f, 0.06556147f, 0.11767479f, -0.02284970f, -0.05965897f, 
    0.04886011f, 0.19635375f, -0.10868699f, -0.07846148f, -0.01224426f, -0.03480820f, -0.04186042f, -0.00678066f, 
    -0.14616294f, 0.12010815f, 0.01247987f, -0.00851171f, 0.05145022f, -0.01317602f, 0.13494617f, 0.23479213f, 
    0.05396007f, 0.09498768f, -0.04332677f, -0.12163664f, -0.03728328f, -0.12708613f, -0.10955597f, 0.05680151f, 
    -0.10600902f, -0.04718721f, -0.02789117f, 0.01787516f, 0.15191300f, -0.03087977f, -0.11275826f, -0.02406100f, 
    0.23742425f, 0.01576601f, 0.06654769f, 0.06299417f, 0.05514907f, 0.09587906f, 0.01864272f, -0.16336063f, 
    0.17987937f, 0.22302881f, 0.11775150f, 0.05871057f, 0.10268034f, -0.07315113f, 0.23007998f, 0.16114533f, 
    0.03711497f, -0.07817873f, 0.00247044f, -0.17583866f, 0.04293085f, 0.20762932f, -0.04324710f, 0.10522030f, 
    0.12581137f, 0.01615146f, 0.01081142f, 0.08117948f, 0.03095648f, 0.08904753f, -0.08893707f, 0.08709841f, 
    0.05238052f, 0.00980597f, -0.00831823f, -0.06928898f, 0.09069566f, 0.01733060f, 0.06323873f, 0.15248817f, 
    -0.10897812f, 0.18234316f, -0.11895952f, -0.08144782f, 0.07429234f, 0.12754917f, -0.22872266f, 0.00261289f, 
    0.19149587f, 0.23054755f, -0.06746633f, -0.04129950f, 0.00071842f, -0.08030114f, 0.04438578f, 0.04442114f, 
    0.13429150f, -0.05900680f, -0.27037320f, -0.06983071f, -0.03940616f, 0.00425097f, 0.06120447f, 0.00754633f, 
    -0.08695897f, -0.05260060f, 0.06194238f, -0.10329781f, -0.06093217f, 0.06400716f, 0.02072721f, -0.03892532f, 
    -0.10884338f, -0.08819531f, 0.04941496f, -0.06226720f, 0.09093664f, -0.00769918f, -0.11340205f, -0.08918074f, 
    0.06161994f, -0.09899116f, -0.17310174f, -0.06247408f, -0.01400576f, 0.09033816f, -0.02852609f, 0.13243790f, 
    0.12120298f, 0.06746269f, 0.16880371f, 0.24132934f, 0.04047336f, 0.07501955f, 0.05153716f, -0.05814687f, 
    0.02642121f, -0.02822408f, -0.00234158f, -0.15533684f, 0.14292650f, -0.11051702f, -0.00806480f, 0.04240343f, 
    0.09388182f, -0.00117447f, 0.06089452f, 0.16984032f, -0.10159614f, -0.03803219f, -0.37070930f, 0.04688228f, 
    0.02462070f, 0.20091306f, -0.01256003f, -0.13051093f, 0.04908967f, -0.08251069f, -0.12582277f, -0.08056372f, 
    -0.06376767f, 0.04070679f, 0.24597555f, 0.00539866f, 0.05127104f, 0.03265066f, 0.11741396f, 0.01019708f, 
    0.12806144f, 0.00842042f, -0.06420425f, 0.00099699f, -0.07126543f, -0.13520253f, -0.04578354f, 0.01773302f, 
    0.07715272f, -0.02841045f, 0.02776457f, 0.19032001f, -0.06293385f, -0.02397603f, -0.10234147f, -0.13004924f, 
    -0.03730856f, -0.01128709f, -0.02142113f, -0.02571240f, -0.06839390f, -0.25356564f, -0.06609081f, 0.11019911f, 
    0.00662205f, 0.04168070f, 0.02106698f, 0.02675576f, 0.05476325f, -0.11813264f, -0.06821281f, -0.08672822f, 
    -0.07448749f, -0.03699860f, 0.11928866f, -0.03895376f, 0.07620215f, -0.21207789f, -0.11190973f, -0.19068381f, 
    0.09410305f, 0.00821282f, 0.06731289f, -0.12699613f, -0.12888098f, -0.12219203f, -0.16633047f, -0.02347160f, 
    0.19521737f, 0.03214028f, -0.00983599f, -0.01512126f, 0.17251933f, 0.03486289f, -0.04125354f, 0.04993197f, 
    0.08970243f, 0.28066570f, 0.02189794f, 0.05882398f, -0.00542212f, 0.04578757f, -0.01107015f, 0.05063037f, 
    0.00246650f, -0.19170192f, -0.14706016f, 0.04047560f, 0.06248909f, -0.03414090f, 0.07925669f, -0.08604932f, 
    -0.19811817f, -0.15080133f, -0.02951499f, -0.01574816f, -0.13918133f, -0.17095362f, -0.13412482f, 0.00226059f, 
    -0.01934329f, -0.00545800f, 0.21279214f, 0.05352657f, 0.14471838f, 0.00259017f, 0.01095450f, 0.08688649f, 
    -0.18553448f, -0.02168047f, 0.08945610f, -0.15142439f, -0.02096063f, 0.01916164f, 0.14088012f, -0.00995300f, 
    -0.01408557f, -0.16819146f, -0.13456008f, -0.13775106f, 0.09405956f, 0.07557400f, 0.10846317f, -0.07637548f, 
    -0.03602567f, -0.04905143f, 0.06488498f, 0.08891211f, -0.02827527f, -0.21553063f, -0.08980239f, -0.15383586f, 
    0.09137424f, -0.08216308f, 0.03199707f, -0.05822504f, 0.12346575f, 0.01425377f, 0.08945408f, 0.21073969f, 
    0.22335577f, -0.08197692f, 0.09029867f, 0.04235125f, -0.08915142f, 0.02762500f, 0.12343874f, -0.13512017f, 
    0.01423666f, 0.03545954f, -0.02663753f, 0.02360915f, -0.17834167f, -0.08579047f, -0.15513644f, -0.12046107f, 
    -0.15138768f, 0.10842695f, 0.07887685f, 0.08678591f, 0.06299768f, -0.05863563f, -0.05651582f, 0.02589669f, 
    0.15928151f, -0.09863587f, 0.05327294f, 0.21788122f, 0.07443339f, 0.02101520f, 0.03138963f, -0.08498681f, 
    -0.00060939f, -0.26435310f, -0.02547277f, -0.04398892f, -0.05163445f, 0.00614110f, 0.00486588f, -0.07697984f, 
    0.01164374f, 0.01300593f, 0.03009514f, -0.01215199f, 0.12785289f, 0.01356389f, -0.00567199f, -0.11282399f, 
    -0.05830251f, -0.01215307f, 0.08719271f, 0.09469061f, 0.05764319f, -0.31250146f, 0.03837737f, 0.13032913f, 
    0.03312116f, -0.06741910f, 0.16578291f, 0.00347299f, 0.10571715f, -0.20800342f, -0.20568714f, -0.21339692f, 
    0.09622536f, 0.00411446f, 0.00159493f, 0.02942905f, 0.05354405f, -0.03836804f, 0.04006464f, 0.15843959f, 
    0.08726595f, 0.06716212f, -0.07912342f, 0.07552754f, -0.10211842f, 0.04839705f, -0.04941249f, 0.31498736f, 
    0.11173992f, -0.02791608f, 0.05452776f, 0.00109110f, 0.17447528f, 0.02713530f, 0.12365594f, -0.01227497f, 
    -0.12853664f, -0.08321013f, -0.01927117f, -0.06577279f, -0.03038838f, -0.10580769f, 0.14925091f, -0.00485302f, 
    -0.04866792f, 0.13267636f, 0.04373375f, -0.06613859f, -0.06683501f, 0.05991537f, 0.16801305f, 0.15887956f, 
    0.12356624f, -0.04593622f, -0.01468252f, -0.10367431f, -0.17889771f, 0.07717132f, 0.09744281f, -0.00702425f, 
    -0.03519109f, -0.06647112f, 0.00442625f, -0.07504135f, 0.01823682f, 0.22282512f, -0.03954640f, -0.02324749f, 
    -0.12822385f, -0.09358802f, -0.25297895f, -0.20620130f, -0.08427031f, -0.13319562f, -0.05247191f, 0.05634332f, 
    -0.04550948f, -0.13401867f, 0.11422899f, 0.01220805f, 0.09577291f, 0.19294944f, 0.21444677f, 0.21534799f, 
    0.04050839f, 0.06566896f, -0.05875632f, -0.04154651f, 0.13920702f, 0.06172173f, -0.12583952f, -0.03917002f, 
    -0.02475780f, -0.04358947f, 0.06428265f, -0.00038390f, -0.01981195f, -0.06668570f, -0.24823621f, 0.05957885f, 
    0.16228750f, 0.19582286f, 0.18949337f, 0.15412380f, 0.19680589f, -0.07168909f, 0.04696698f, 0.00984109f, 
    0.11702506f, 0.07469511f, 0.13532783f, -0.04113181f, 0.01408628f, -0.11734598f, -0.10935385f, 0.12833552f, 
    0.07215410f, 0.07505838f, 0.05487215f, 0.08607540f, -0.02934318f, 0.07465900f, -0.03079747f, 0.04877703f, 
    0.05218974f, 0.09849968f, -0.03450743f, -0.06153879f, 0.12023527f, -0.02513131f, -0.03205196f, 0.00820743f, 
    -0.15186588f, -0.20451668f, -0.07595579f, -0.05105829f, -0.06045614f, 0.06514805f, 0.01751042f, 0.02500481f, 
    -0.01684563f, 0.02885343f, 0.06625082f, 0.10972845f, 0.06501645f, -0.05297280f, 0.08165615f, -0.04123943f, 
    -0.03019378f, -0.11346906f, 0.22476265f, 0.12360480f, 0.00121672f, -0.08788893f, -0.00413108f, -0.04817057f, 
    0.03750131f, 0.02903049f, 0.07101635f, -0.17966163f, -0.13647997f, -0.28891420f, -0.17476600f, -0.05734139f, 
    0.06830605f, -0.00335793f, -0.13629723f, 0.05970019f, 0.03737989f, 0.07838971f, -0.00542788f, 0.17914471f, 
    0.06543628f, 0.22548404f, 0.00709061f, 0.11101156f, -0.12367004f, -0.01035013f, 0.08943509f, -0.05088652f, 
    0.18321089f, -0.16216764f, 0.17469567f, 0.19034277f, -0.04446841f, 0.11147178f, 0.02739523f, 0.05419533f, 
    0.02210255f, 0.11172839f, -0.01896407f, -0.04352330f, 0.15908228f, 0.03761768f, -0.00529289f, -0.02389698f, 
    -0.04255550f, 0.10827439f, -0.10943778f, -0.04598350f, -0.42837447f, -0.13889255f, -0.29355547f, -0.00307732f, 
    -0.01704264f, 0.08718006f, 0.08987328f, 0.21303363f, -0.12421021f, -0.05741762f, 0.10532536f, 0.01328154f, 
    0.08019385f, -0.07802505f, -0.09610537f, 0.08133690f, 0.20204602f, 0.22213469f, -0.09021283f, 0.06134154f, 
    0.00024273f, 0.15489802f, 0.10642389f, -0.03889656f, 0.02840249f, 0.16609682f, 0.11053491f, 0.12301259f, 
    -0.14004402f, 0.07783010f, -0.18742906f, 0.08086570f, 0.01102658f, 0.12084748f, -0.39406997f, -0.16377640f, 
    -0.31246471f, -0.03148894f, -0.17682952f, -0.08320566f, 0.06853338f, 0.23376618f, -0.07518798f, -0.16062310f, 
    0.05592431f, -0.07089404f, 0.08235154f, 0.01249549f, 0.04577942f, -0.03885259f, -0.01715182f, 0.10567564f, 
    -0.33961436f, -0.14415294f, -0.03784820f, -0.03368567f, 0.05764305f, -0.18324307f, -0.04645440f, 0.08501809f, 
    0.09768379f, 0.38328260f, -0.04300356f, -0.30877680f, 0.07084816f, -0.00571722f, 0.16715094f, -0.14260583f, 
    -0.02889378f, -0.03916613f, -0.22821787f, -0.13138777f, -0.16582578f, 0.09299151f, -0.19670412f, -0.00853624f, 
    0.16652243f, 0.07150058f, -0.02190535f, -0.01504529f, -0.09647963f, -0.15526837f, 0.08451474f, -0.18152083f, 
    -0.02719902f, 0.11869135f, 0.15816462f, -0.08830909f, 0.12600127f, -0.02682897f, 0.02222168f, 0.00772005f, 
    -0.02905167f, -0.00922189f, -0.01330691f, 0.02701867f, -0.08756727f, 0.33148843f, 0.11503255f, 0.11458398f, 
    -0.09786984f, -0.16696213f, -0.05006077f, 0.01413268f, -0.01605022f, -0.01473345f, -0.31438854f, -0.12016933f, 
    0.13456264f, -0.07660635f, -0.03797691f, -0.13316366f, -0.01256112f, -0.02248170f, 0.21949475f, -0.17272899f, 
    0.19570203f, -0.26839229f, -0.27020675f, -0.27858430f, 0.11215766f, 0.08544268f, -0.02970910f, 0.02884778f, 
    0.24330109f, 0.10288816f, 0.02047247f, 0.10594665f, 0.01997082f, 0.13800512f, 0.00501535f, 0.09079868f, 
    0.04528831f, -0.05070591f, -0.00308272f, 0.03275841f, -0.19925329f, -0.12673986f, -0.19087882f, 0.03407101f, 
    -0.03914403f, -0.14855158f, 0.28911483f, 0.21121874f, -0.30314282f, 0.18794039f, 0.04793600f, 0.00370739f, 
    -0.01159800f, 0.00752978f, 0.10052463f, 0.30450198f, 0.15419713f, -0.18795455f, -0.03331276f, 0.05509381f, 
    0.05335463f, -0.12310858f, 0.09199363f, 0.03941568f, -0.14542244f, 0.01456292f, -0.13575843f, -0.01516726f, 
    -0.00205827f, -0.10403401f, 0.13295017f, 0.19478579f, 0.07572547f, -0.24097109f, -0.11389446f, -0.01866788f, 
    0.12952231f, 0.07591283f, -0.09021147f, 0.09487246f, 0.02493407f, -0.09420011f, 0.33859932f, -0.09481665f, 
    -0.06005894f, -0.06846590f, 0.06277817f, -0.01496083f, 0.03461460f, -0.00191456f, -0.19820078f, 0.15635446f, 
    0.15104297f, -0.06770926f, -0.01455002f, -0.01634341f, 0.08315829f, 0.02878512f, -0.11477520f, 0.07832066f, 
    -0.08880925f, -0.25080439f, -0.11681252f, -0.07418627f, -0.16083899f, -0.08585545f, 0.06966819f, 0.07635023f, 
    0.08740880f, 0.01249859f, -0.20062603f, -0.25551447f, 0.00546753f, -0.17853491f, 0.04274584f, 0.02491093f, 
    0.20222872f, 0.11098295f, 0.28301796f, 0.25774211f, -0.12573998f, -0.12453806f, -0.10240766f, 0.02959415f, 
    -0.00022299f, 0.06641211f, 0.10753263f, 0.17951530f, 0.26720271f, 0.15760334f, -0.23101169f, -0.27910843f, 
    0.04689356f, 0.01706020f, 0.03695620f, 0.01370472f, 0.15558991f, 0.21522824f, -0.04106906f, 0.09435704f, 
    -0.12428536f, 0.09801142f, 0.08779927f, 0.01266147f, 0.00843696f, 0.08645058f, 0.06615373f, 0.04408116f, 
    -0.00663490f, 0.15008904f, 0.07248245f, 0.02334992f, -0.09133670f, -0.00511717f, -0.45746645f, -0.16501373f, 
    0.23553133f, -0.25226665f, 0.09892944f, -0.06234588f, 0.04641045f, -0.06575388f, 0.08190279f, -0.00465110f, 
    -0.34403142f, 0.26572815f, -0.06164313f, -0.09698554f, -0.28773132f, 0.15619391f, 0.10363273f, -0.00624147f, 
    -0.06647407f, -0.27929682f, -0.33873740f, 0.12595980f, -0.04832800f, -0.21197268f, 0.06503344f, -0.13381004f, 
    0.07867891f, -0.07443953f, -0.11369257f, -0.20160481f, -0.17402017f, -0.04321782f, -0.18774307f, 0.14780177f, 
    0.02106151f, 0.06749176f, 0.03540844f, 0.02261383f, 0.09263732f, 0.03009259f, -0.06652230f, -0.12132508f, 
    -0.11838184f, 0.01246186f, 0.15191165f, 0.05930318f, 0.10338338f, 0.10180724f, -0.18209207f, -0.00420805f, 
    0.17065716f, 0.11759067f, 0.06083542f, -0.10733917f, -0.03377296f, -0.00373402f, 0.17653328f, -0.00257821f, 
    0.13812459f, 0.06188740f, -0.01165592f, 0.17789802f, 0.03127865f, -0.11582720f, -0.13729891f, -0.19566503f, 
    -0.12289011f, 0.04291637f, 0.06861230f, -0.07346781f, 0.22260259f, 0.15426360f, 0.25275606f, -0.04559376f, 
    -0.05500422f, 0.00723342f, 0.09591682f, 0.11241937f, 0.16546524f, 0.04984573f, 0.25633579f, -0.01208573f, 
    -0.02948875f, -0.12561308f, -0.05305102f, -0.08143310f, -0.18071650f, 0.24261680f, 0.01559948f, -0.03577950f, 
    0.03384178f, -0.14347865f, -0.17411585f, 0.12449662f, -0.10947970f, 0.06754915f, 0.09135034f, 0.06633274f, 
    0.07170122f, 0.06597225f, 0.08181272f, 0.20973316f, -0.06974293f, 0.08194116f, -0.03513946f, 0.13701695f, 
    -0.08644447f, 0.06220719f, -0.29351237f, -0.08847140f, -0.05336105f, 0.02552619f, -0.12736136f, -0.18386817f, 
    0.14924660f, -0.04777233f, 0.02087574f, -0.19631489f, -0.24447440f, -0.20209138f, -0.02440325f, 0.03387203f, 
    0.04767583f, 0.13394067f, 0.00271867f, -0.14368245f, -0.04416027f, -0.10905656f, -0.19436474f, -0.20600289f, 
    -0.01361101f, 0.01550413f, 0.07916486f, -0.04509737f, 0.08749107f, -0.07563579f, -0.26233032f, -0.18790700f, 
    -0.08263585f, 0.01563641f, -0.02076725f, 0.01028204f, 0.12570488f, 0.07254107f, 0.23472565f, 0.10407883f, 
    0.00290775f, -0.10486916f, 0.11658650f, -0.22856243f, 0.15449193f, 0.04793429f, 0.18482369f, 0.09684305f, 
    -0.11599530f, -0.45481965f, -0.07805705f, -0.10525682f, 0.00054962f, 0.07209969f, 0.09270360f, -0.01410388f, 
    -0.06568572f, -0.04253862f, -0.05736047f, -0.02478539f, -0.04768103f, -0.16671091f, -0.02436016f, 0.04932581f, 
    0.07592161f, -0.17886493f, -0.06156373f, 0.15908927f, 0.05630573f, -0.08429459f, -0.07174405f, 0.00782339f, 
    0.10393463f, 0.05088292f, -0.03932653f, -0.23880318f, -0.15511066f, -0.04039202f, -0.03399806f, -0.15619722f, 
    0.02559096f, 0.02668288f, 0.08453351f, -0.01084500f, 0.13182637f, 0.32523108f, -0.04150321f, -0.01575760f, 
    -0.07855098f, 0.06539629f, 0.17987891f, -0.05526975f, -0.07817280f, -0.40201840f, -0.10423236f, 0.08263577f, 
    -0.23288296f, 0.03585299f, 0.14595635f, 0.01668167f, 0.00268344f, 0.10525474f, 0.20959832f, 0.02227149f, 
    -0.03628983f, 0.13701048f, 0.09239629f, 0.12073359f, 0.13599946f, 0.01992014f, -0.01805859f, 0.04384851f, 
    -0.04553017f, 0.07396825f, 0.05995195f, -0.00798559f, 0.03157476f, -0.07623365f, 0.10092687f, 0.29305330f, 
    0.23352374f, 0.10692858f, 0.16211866f, 0.13759218f, 0.14290437f, 0.17140171f, 0.08564149f, 0.10663031f, 
    0.01314287f, -0.04396272f, -0.09027176f, -0.09878382f, -0.12373033f, 0.05879816f, 0.12387443f, -0.00799987f, 
    0.07207704f, 0.05462517f, -0.01997690f, 0.12691654f, 0.12200029f, 0.26157925f, 0.07387895f, 0.01495623f, 
    -0.04653477f, 0.08178265f, 0.06969801f, 0.07279804f, 0.11784836f, 0.00233002f, -0.06145108f, -0.01815817f, 
    0.02200720f, 0.15521735f, -0.02894300f, 0.35921380f, -0.07033838f, -0.14183535f, 0.07141548f, -0.04985083f, 
    -0.14600778f, -0.15383738f, 0.10112169f, -0.11319508f, -0.06761685f, -0.18256432f, 0.09350436f, 0.12692165f, 
    0.03929792f, -0.03245718f, -0.08718386f, 0.04665699f, 0.16485666f, -0.09879265f, 0.02160833f, 0.06983208f, 
    -0.06414046f, -0.02239905f, 0.01121713f, 0.02768128f, 0.05411595f, 0.08870559f, -0.33267614f, -0.15292692f, 
    -0.12769151f, -0.05628664f, -0.09355705f, -0.02777998f, -0.01746227f, 0.18215512f, -0.04155042f, 0.13177551f, 
    -0.03673239f, -0.24527515f, -0.05442997f, -0.05477886f, 0.04944800f, -0.06063640f, 0.25155422f, -0.04061814f, 
    -0.00649113f, 0.00824476f, -0.08757639f, -0.12514170f, 0.00007284f, 0.06763422f, 0.13206816f, -0.02963200f, 
    0.11535513f, 0.02530018f, 0.06279325f, 0.02097407f, -0.19396469f, -0.15697573f, -0.05706170f, 0.05765725f, 
    -0.18855858f, 0.14363059f, 0.15686415f, 0.21162388f, -0.02462911f, 0.09210829f, -0.11798355f, 0.07024205f, 
    0.10354988f, 0.17304611f, -0.00370325f, -0.18140645f, 0.13850504f, -0.01801590f, -0.01286756f, 0.07712545f, 
    0.01498344f, 0.08650015f, -0.01628387f, 0.08951306f, 0.27948236f, -0.13836056f, 0.40755430f, -0.05433703f, 
    0.04546919f, -0.08014467f, 0.06535386f, 0.02203531f, 0.09123641f, -0.50850254f, -0.44296476f, -0.17113145f, 
    0.08540045f, 0.20342429f, 0.00157886f, 0.07628410f, -0.01910387f, -0.05249268f, 0.16296606f, -0.00283551f, 
    -0.03905183f, 0.10528383f, 0.03812928f, 0.11206433f, 0.04178136f, -0.11709233f, -0.03756968f, 0.10926647f, 
    0.06617994f, 0.11407482f, -0.15530849f, -0.20314595f, -0.09684708f, -0.13563213f, 0.00441430f, 0.06360674f, 
    -0.09751884f, 0.07464428f, -0.07210344f, 0.15677132f, -0.03142017f, 0.00156894f, -0.04052936f, -0.13609883f, 
    -0.09064383f, -0.00531587f, -0.01278183f, 0.39096022f, -0.14704075f, -0.00472473f, -0.04845278f, -0.05210350f, 
    -0.01083922f, 0.06686311f, 0.01643448f, 0.06062459f, 0.05491957f, 0.00642815f, -0.16628017f, -0.06230278f, 
    -0.16899383f, 0.05626349f, -0.02837444f, 0.28754807f, -0.21679835f, 0.09586021f, -0.09386954f, -0.13319479f, 
    0.01731745f, 0.11090350f, -0.16295214f, 0.11085513f, -0.27567858f, -0.54457134f, -0.41455886f, 0.02512403f, 
    -0.15386520f, -0.12612803f, 0.04848622f, -0.03141666f, 0.01110898f, -0.53235430f, -0.75746417f, -0.29077291f, 
    -0.04674097f, -0.09611441f, -0.16623913f, 0.05747097f, -0.02713863f, 0.00772589f, 0.19045767f, -0.00449658f, 
    -0.01532661f, -0.00817767f, -0.06505816f, 0.07910141f, 0.01620279f, -0.01629674f, 0.19717623f, 0.31188169f, 
    0.16754004f, -0.00464378f, -0.00043426f, 0.07630149f, 0.17182936f, 0.06208771f, 0.09423805f, -0.09632219f, 
    -0.47636324f, -0.52168435f, -0.39737666f, -0.04921681f, -0.05918342f, -0.14562616f, -0.09303457f, -0.08913600f, 
    0.06425713f, -0.18312599f, -0.23189631f, 0.18371646f, 0.03060221f, 0.01683632f, -0.02369236f, -0.00669140f, 
    0.07741511f, 0.08096792f, 0.12850049f, 0.01874706f, 0.01675660f, -0.17976932f, -0.17194897f, -0.06937648f, 
    0.09200003f, -0.00057063f, -0.04379817f, -0.25603458f, -0.13557717f, 0.43692756f, -0.07872093f, -0.06042816f, 
    -0.15670596f, 0.05739301f, 0.02913238f, 0.12063228f, -0.26153880f, -0.05019116f, -0.28351930f, -0.11723872f, 
    -0.09352107f, -0.04253381f, -0.09344139f, -0.03085615f, -0.04640279f, 0.11958852f, 0.15335670f, -0.07490942f, 
    -0.00569164f, 0.10888717f, -0.00250759f, -0.00632040f, -0.12195404f, 0.10826686f, 0.00799283f, 0.08677087f, 
    -0.06848472f, -0.00747686f, -0.02499295f, -0.10073254f, -0.00003649f, 0.00158956f, 0.03143800f, 0.16727439f, 
    0.03422805f, 0.10524103f, 0.10786173f, 0.03289158f, 0.08292741f, 0.05050210f, 0.02677703f, 0.17128885f, 
    0.16307241f, -0.07802314f, -0.06694730f, -0.13486174f, -0.03839250f, -0.01291670f, 0.03889082f, -0.03142347f, 
    0.12413882f, 0.26121387f, 0.04583185f, -0.03807128f, -0.03738661f, -0.00787703f, 0.06804445f, 0.12910175f, 
    -0.03377007f, 0.08438046f, 0.05673908f, -0.38534600f, 0.00451618f, 0.09979996f, -0.07490725f, -0.09201648f, 
    0.01858086f, -0.01236938f, 0.02560952f, 0.03273552f, 0.37162998f, -0.64749795f, 0.07803756f, -0.08387385f, 
    -0.20743121f, 0.10410516f, 0.03846413f, 0.04982309f, -0.06593289f, -0.44813976f, -0.24592134f, 0.11552162f, 
    0.05574927f, -0.03928784f, -0.02545508f, -0.04942495f, -0.01926287f, -0.06136193f, -0.21219003f, -0.21923894f, 
    -0.10391666f, -0.01600099f, -0.03413467f, 0.03757643f, 0.07403760f, 0.11434563f, -0.05660532f, -0.23793076f, 
    0.11818660f, 0.04936497f, 0.08372735f, -0.11831077f, 0.11277767f, 0.06818803f, 0.09954810f, 0.11307624f, 
    0.11317382f, -0.07814396f, -0.03854208f, 0.08328330f, -0.03566954f, -0.12082373f, -0.01498919f, -0.00175806f, 
    -0.02148061f, -0.11746813f, -0.20974305f, 0.00722739f, 0.06524436f, 0.06736289f, -0.05906488f, -0.07047340f, 
    -0.03209068f, -0.24040072f, -0.21237949f, -0.11295139f, -0.11259869f, -0.09374189f, -0.02752825f, 0.06669599f, 
    0.12490973f, -0.11696998f, -0.43624079f, -0.06683528f, 0.00744616f, -0.00756422f, -0.03898251f, -0.00952410f, 
    -0.01402814f, -0.11287187f, -0.03502317f, 0.06065647f, 0.23253936f, 0.19916406f, 0.15228401f, -0.08685193f, 
    0.03754314f, -0.13194157f, -0.20546415f, -0.07964540f, 0.13647288f, 0.04443837f, 0.21823469f, -0.04426483f, 
    -0.00374620f, -0.02620892f, 0.06094925f, 0.13832651f, 0.01069933f, 0.07929117f, -0.02103842f, 0.40589562f, 
    0.06624646f, 0.12005573f, 0.02501152f, 0.12794945f, 0.06622078f, 0.18023606f, -0.29229000f, -0.05759467f, 
    -0.27488148f, -0.20225467f, 0.07829949f, 0.02302146f, 0.14374863f, -0.01918015f, -0.03283255f, -0.07868600f, 
    0.01385463f, 0.02840188f, -0.09126887f, 0.03696476f, 0.00039490f, 0.11458306f, 0.04075970f, -0.21244936f, 
    -0.29490522f, 0.01353770f, -0.01255557f, 0.06266610f, 0.06041701f, -0.01167887f, 0.06430182f, -0.05902714f, 
    0.07890619f, -0.21317379f, 0.13600940f, 0.46672961f, 0.15810254f, 0.06462473f, -0.08024271f, -0.05047915f, 
    -0.04914546f, -0.20611779f, 0.02328944f, 0.03219402f, -0.23117898f, -0.05080927f, -0.07295841f, -0.16839549f, 
    -0.02743292f, 0.09182675f, 0.04444091f, 0.22863674f, 0.03915260f, -0.03382874f, 0.00635556f, 0.09202204f, 
    -0.03662333f, -0.11121927f, 0.08351815f, 0.05048760f, 0.28231305f, 0.13978101f, 0.25655308f, -0.06739799f, 
    0.07500973f, -0.03986058f, 0.19581059f, 0.03617785f, -0.03341950f, 0.10641000f, 0.07301126f, 0.40599856f, 
    0.02984285f, 0.11492039f, -0.01667034f, 0.16329701f, -0.06528341f, 0.12846142f, -0.21154042f, 0.17364940f, 
    -0.05625263f, -0.00011307f, 0.09945990f, 0.07391675f, 0.00668966f, 0.14349112f, -0.04421744f, 0.13861291f, 
    0.12402565f, -0.11381046f, -0.19619112f, 0.11205776f, -0.27171040f, -0.05506423f, 0.03479364f, 0.02795417f, 
    -0.03130122f, 0.07598865f, 0.23945934f, 0.03083089f, -0.00952544f, -0.08752541f, 0.07232644f, 0.10055206f, 
    -0.01611842f, -0.19335599f, 0.06784360f, 0.24555591f, 0.04402115f, -0.00250130f, 0.13521975f, -0.04207494f, 
    0.14451040f, 0.00066927f, -0.02323455f, -0.09444231f, 0.05234205f, -0.03242058f, 0.15823923f, -0.00790447f, 
    0.08055227f, 0.01843280f, 0.02507949f, -0.12094168f, 0.08079017f, 0.30457029f, 0.07887862f, -0.09176478f, 
    -0.10765862f, -0.01273921f, -0.18332590f, -0.12210833f, -0.00979966f, -0.07022671f, 0.01367667f, 0.26494893f, 
    0.14785640f, -0.08958010f, 0.09506129f, 0.13114211f, 0.16718706f, -0.07159816f, 0.04122864f, -0.24155045f, 
    -0.03001899f, 0.06086721f, 0.11566600f, 0.03811629f, 0.03264247f, 0.04756245f, -0.03548014f, -0.19085176f, 
    -0.29659721f, 0.03870056f, 0.05913050f, -0.02152834f, 0.05486387f, -0.08873515f, -0.08739495f, 0.10883661f, 
    -0.02220537f, 0.04403971f, -0.00853559f, 0.07378459f, 0.03867857f, -0.17051086f, -0.03483929f, -0.11080199f, 
    -0.00471171f, -0.01694981f, -0.26493052f, -0.06223720f, -0.11829770f, -0.13120976f, -0.08029491f, -0.03596910f, 
    0.08399706f, -0.10531185f, 0.08296775f, 0.05641739f, 0.08571292f, 0.03952754f, 0.00555351f, 0.09323180f, 
    0.17983982f, 0.04563731f, 0.00641291f, 0.01959423f, 0.28661186f, -0.01419634f, -0.01257998f, -0.20955345f, 
    -0.07609165f, -0.03618777f, -0.14023946f, -0.07097773f, 0.16075887f, 0.04207085f, 0.02858792f, 0.02845644f, 
    -0.05372228f, -0.15059091f, 0.12991565f, 0.07430851f, 0.08682226f, -0.02919996f, 0.27323276f, 0.02347121f, 
    -0.02080690f, -0.08016694f, 0.18780419f, -0.04260127f, 0.07769690f, 0.17191666f, -0.07139521f, 0.04353754f, 
    0.18108237f, 0.06684981f, 0.06577602f, 0.04606930f, 0.01932698f, -0.02492272f, -0.28825882f, -0.03280095f, 
    0.20466897f, 0.08680553f, 0.03042424f, 0.05007252f, 0.01135700f, 0.01031879f, -0.02297620f, 0.02275548f, 
    0.15619458f, -0.16006671f, 0.09700174f, -0.08630546f, -0.30090013f, 0.00583063f, 0.07928454f, 0.04305146f, 
    -0.02745395f, -0.31991366f, 0.07199252f, 0.06000585f, 0.00915082f, 0.11216466f, 0.10248965f, 0.04937593f, 
    -0.03680835f, -0.08504598f, -0.39541447f, -0.23359343f, -0.09877983f, 0.02339088f, 0.02603732f, 0.07230893f, 
    -0.02044033f, 0.01383221f, -0.02363234f, -0.09673506f, 0.06470521f, -0.18061924f, -0.01492992f, -0.01884764f, 
    0.02448889f, 0.03733415f, -0.09373204f, 0.00703994f, 0.13411939f, 0.32403028f, -0.02701236f, 0.09034681f, 
    0.01685074f, 0.11287907f, 0.27012491f, 0.12035366f, 0.01643712f, -0.01041058f, -0.07012449f, 0.12825072f, 
    -0.03152758f, -0.08153383f, 0.05245382f, 0.02894755f, 0.03298568f, 0.02181447f, 0.07711778f, -0.27009296f, 
    -0.06105319f, 0.12450924f, 0.09940857f, 0.00176438f, -0.15140845f, -0.12078763f, -0.27559304f, 0.18142879f, 
    0.35158983f, -0.03373473f, -0.07029516f, 0.03792356f, -0.13182101f, 0.08619972f, 0.17450383f, -0.02241132f, 
    -0.19112907f, 0.07817801f, -0.07902370f, -0.00929891f, -0.01476612f, 0.02886369f, 0.09747816f, 0.20417644f, 
    -0.14009194f, -0.01152309f, 0.18038884f, -0.01793746f, -0.02380623f, 0.04976460f, -0.20617855f, -0.06938773f, 
    -0.04872531f, -0.12035550f, 0.17762724f, 0.22117998f, 0.09081636f, 0.05643643f, 0.08866119f, -0.04430400f, 
    0.07823487f, 0.11755212f, 0.04047671f, -0.13901086f, -0.01626957f, 0.01259732f, -0.11416511f, -0.08505040f, 
    -0.12211713f, 0.00975744f, 0.00343312f, -0.11130358f, -0.07099430f, 0.08888993f, 0.05202880f, 0.03052621f, 
    -0.02624025f, -0.11765877f, -0.26833642f, -0.06506782f, -0.24004039f, 0.03404548f, 0.21347837f, 0.08641265f, 
    0.09441735f, -0.10399606f, -0.25126609f, 0.03832436f, -0.01326969f, -0.17912996f, 0.08064876f, 0.06888130f, 
    0.19677716f, -0.01107010f, -0.01099850f, -0.14362119f, -0.07042163f, -0.11697558f, 0.04336860f, -0.06019259f, 
    0.10345992f, 0.06017327f, -0.16011293f, 0.01186300f, 0.09111895f, 0.08074704f, 0.11131510f, 0.03305354f, 
    0.14619470f, 0.15699750f, -0.09467503f, -0.08413876f, 0.02088195f, -0.16899087f, -0.01252038f, 0.11638746f, 
    0.10189057f, 0.01012590f, 0.20029220f, 0.17365673f, -0.04775478f, -0.17321424f, -0.14162464f, -0.06961879f, 
    0.01588844f, 0.11002730f, -0.05428428f, 0.15560676f, 0.02980085f, 0.10793319f, -0.16687305f, 0.04785507f, 
    -0.13795844f, 0.25468335f, 0.00064935f, 0.12827893f, 0.00309546f, 0.02780044f, -0.01439060f, 0.06337349f, 
    -0.10305483f, -0.04544526f, -0.19952662f, -0.21724571f, 0.15661481f, -0.37276515f, 0.07967476f, 0.12663136f, 
    -0.16102406f, 0.10037521f, 0.22756819f, 0.06892409f, -0.23622547f, -0.02742948f, 0.04988763f, -0.02113252f, 
    -0.19907990f, 0.03081038f, -0.15495895f, -0.36490023f, -0.04779879f, -0.17316031f, -0.11883237f, 0.15580086f, 
    0.12161756f, -0.11668821f, 0.06532454f, 0.13360994f, 0.16934070f, 0.07110511f, 0.24503934f, -0.11371159f, 
    -0.00725300f, -0.00300889f, 0.03173336f, 0.06462772f, 0.16374259f, 0.09860082f, -0.11654287f, 0.17734547f, 
    0.12909220f, 0.08481669f, 0.00427900f, 0.01759863f, 0.16000850f, 0.04796865f, 0.02263291f, 0.25348464f, 
    -0.09869754f, -0.30614462f, -0.03718146f, -0.04897173f, 0.00693961f, -0.03456969f, 0.00624494f, -0.03629043f, 
    0.05675245f, 0.17031379f, -0.07983916f, 0.21487923f, 0.13866378f, 0.08339947f, 0.18885663f, -0.11053496f, 
    0.00272370f, 0.09987186f, -0.09874190f, 0.21192239f, 0.04098444f, -0.04891891f, -0.12579530f, 0.05898674f, 
    -0.03631869f, 0.23081601f, 0.32808307f, -0.14336184f, 0.23716880f, 0.57679313f, 0.02903191f, -0.07662205f, 
    -0.15451725f, 0.00784616f, -0.02206718f, -0.01774843f, 0.09287443f, -0.00164616f, 0.12370808f, 0.13130589f, 
    0.13163376f, 0.00677328f, -0.04520233f, -0.11739355f, -0.06406686f, 0.05875271f, 0.04491652f, 0.09182669f, 
    -0.01005128f, 0.05972720f, 0.07338282f, -0.04691495f, -0.02022918f, 0.05280053f, -0.02801857f, -0.13128874f, 
    -0.02532638f, -0.06558295f, 0.16710362f, 0.01553238f, -0.09665225f, 0.00027276f, -0.08310561f, -0.05497995f, 
    -0.36367634f, 0.10397735f, 0.11376294f, -0.01793106f, -0.07497871f, -0.00893089f, -0.07194831f, -0.00291431f, 
    -0.10660724f, 0.01799976f, -0.07206755f, 0.09541404f, -0.00282533f, -0.07371992f, -0.02215325f, 0.15719956f, 
    0.20652026f, 0.12410638f, 0.07172091f, -0.04560002f, 0.02232668f, -0.03272840f, 0.00050367f, -0.10091776f, 
    -0.08511366f, 0.03529704f, 0.38605866f, 0.15321288f, -0.10692764f, -0.02751650f, -0.12806620f, 0.08032533f, 
    -0.04920982f, 0.10283028f, -0.00123479f, -0.15418673f, 0.15228379f, 0.04869517f, -0.00049407f, -0.17187873f, 
    -0.09733664f, 0.16396153f, -0.06988157f, 0.20108682f, -0.46051982f, -0.07970922f, 0.24565578f, 0.01420994f, 
    0.07776172f, -0.01448398f, 0.02494589f, 0.03579289f, 0.01306551f, -0.14913461f, -0.46516725f, -0.24405766f, 
    0.02065580f, 0.03545070f, -0.10268296f, -0.03245620f, -0.01210273f, -0.04050415f, 0.34379971f, 0.08350207f, 
    -0.15058289f, 0.01979535f, 0.05393451f, 0.13834225f, -0.00898685f, -0.05482700f, -0.14913025f, 0.09907983f, 
    -0.03744780f, -0.06900609f, -0.04828987f, 0.04780512f, -0.12020901f, -0.00105211f, -0.11582445f, 0.03097080f, 
    0.46225998f, 0.14179529f, -0.06125420f, 0.00122436f, -0.10113763f, -0.02559537f, -0.11736692f, 0.06723977f, 
    -0.08122298f, -0.30469486f, -0.21655948f, 0.01829503f, -0.10752110f, 0.13452074f, 0.19721141f, -0.16276766f, 
    0.04541178f, 0.14485708f, -0.06004407f, -0.04626299f, -0.04127585f, -0.03001060f, 0.01196315f, -0.01126631f, 
    -0.07859231f, -0.12762778f, -0.05185622f, -0.31203094f, -0.23536985f, -0.05774442f, -0.11329199f, -0.10699702f, 
    -0.06123914f, 0.11169950f, -0.01947627f, -0.13911621f, 0.07861970f, 0.18733357f, -0.26836073f, -0.02509686f, 
    -0.03663313f, -0.01439894f, -0.07384197f, -0.02617850f, -0.04167290f, -0.34255114f, -0.49262589f, -0.52507639f, 
    -0.07832824f, -0.04593966f, -0.11999283f, 0.05341531f, -0.04839163f, -0.02850726f, 0.25549373f, -0.05698344f, 
    -0.05046549f, 0.07222336f, -0.05112042f, 0.01681292f, 0.07402137f, -0.02878208f, 0.12122114f, -0.33561844f, 
    -0.27856228f, -0.01448027f, -0.09425379f, -0.09069475f, 0.08385478f, 0.13103797f, -0.05048556f, -0.06374726f, 
    -0.03863983f, -0.04370483f, -0.10526117f, -0.11675817f, 0.04199000f, -0.07675124f, 0.02005121f, 0.00551847f, 
    -0.00869708f, -0.12942116f, -0.19616467f, -0.16640903f, -0.07217947f, -0.04168602f, 0.10708015f, 0.09415326f, 
    -0.02243076f, 0.01515947f, -0.26759651f, -0.10162356f, 0.04290086f, 0.03213601f, -0.03065052f, 0.13015324f, 
    0.01441575f, 0.10188502f, 0.18374790f, 0.00331628f, -0.51665229f, -0.21798189f, -0.24688722f, -0.11925709f, 
    -0.11601076f, 0.03728083f, -0.01642051f, 0.07750742f, 0.12904289f, -0.09685484f, -0.13030414f, -0.08167812f, 
    -0.12951525f, -0.13431895f, -0.09713783f, -0.08448330f, -0.08485451f, 0.10210057f, 0.14810257f, 0.25969121f, 
    -0.06445853f, 0.06337080f, 0.09052535f, 0.03174356f, -0.02313753f, 0.02642388f, -0.22422197f, 0.12504566f, 
    0.02567736f, -0.01359079f, 0.10215593f, -0.04211213f, -0.10520316f, 0.09976853f, 0.10753047f, 0.00518613f, 
    0.05093399f, 0.01489340f, 0.10442769f, 0.12956218f, 0.03841635f, 0.22850507f, -0.01602107f, 0.24623191f, 
    0.32627788f, 0.08052005f, -0.08556493f, -0.08881404f, -0.04803701f, 0.01891404f, 0.02539768f, 0.10452202f, 
    -0.01810166f, -0.28562889f, 0.10110094f, 0.06813823f, 0.04120219f, 0.07752826f, 0.07342628f, 0.08089817f, 
    -0.14022462f, -0.06758724f, 0.28936788f, -0.32220110f, -0.36192462f, -0.09421222f, -0.05590478f, 0.00052976f, 
    0.08680881f, -0.04831066f, 0.13400629f, 0.05139706f, 0.11748776f, -0.85194838f, 0.08168601f, -0.00548705f, 
    -0.08974482f, 0.09941515f, 0.00568476f, -0.01739846f, -0.27539584f, 0.11154096f, 0.06079892f, 0.12372392f, 
    0.05677501f, -0.10838532f, -0.00783980f, -0.05416227f, -0.00272326f, 0.03217006f, 0.06255087f, -0.18592319f, 
    -0.10529468f, 0.01344854f, 0.01725776f, 0.08712716f, 0.11899083f, 0.17011295f, 0.17160855f, -0.13966002f, 
    0.01066139f, -0.16924801f, 0.17826258f, 0.04698549f, 0.11175091f, -0.03503022f, 0.06721824f, 0.20818308f, 
    0.08198530f, 0.16512834f, -0.11316108f, 0.17032798f, 0.09958285f, -0.04989683f, 0.03789827f, -0.03926252f, 
    0.25636056f, 0.24651839f, -0.05310940f, -0.00401557f, 0.01358568f, -0.02841216f, -0.11479458f, -0.07794521f, 
    -0.06253430f, 0.21699199f, 0.16221517f, 0.06965317f, -0.13087314f, 0.00073827f, -0.06345874f, 0.11768393f, 
    0.04587212f, -0.00344231f, 0.16707024f, 0.16157432f, -0.09482928f, -0.16762672f, 0.03128655f, 0.03851468f, 
    0.24341020f, -0.02709701f, 0.04809611f, -0.21348540f, -0.37952241f, -0.64845514f, 0.11444935f, 0.12334606f, 
    0.00084030f, 0.01115154f, 0.07054441f, -0.05591314f, -0.45787865f, -0.07285987f, -0.37397495f, 0.03375786f, 
    -0.19930264f, 0.06268079f, -0.01126751f, -0.05024520f, 0.02165172f, -0.67707199f, -0.04033150f, 0.09360111f, 
    0.14225692f, -0.00866004f, -0.12012435f, -0.15530705f, -0.03331437f, 0.01526268f, 0.16024514f, 0.13491204f, 
    -0.02064628f, -0.01294831f, 0.12366939f, 0.04692443f, 0.19626424f, 0.05665934f, -0.10708505f, 0.08333805f, 
    0.21683834f, 0.11721721f, -0.06925099f, -0.03100014f, -0.07479548f, 0.00393699f, 0.09282447f, -0.10940526f, 
    -0.03244542f, 0.05565199f, -0.09639725f, -0.01759676f, 0.03578050f, 0.05228206f, 0.16033238f, -0.17021488f, 
    -0.03919657f, -0.24407691f, -0.63413447f, -0.60259628f, -0.48162356f, -0.03160346f, -0.14935829f, -0.00065948f, 
    0.01465000f, -0.16653609f, 0.08374424f, 0.05012765f, 0.02086866f, -0.06827620f, -0.00572823f, 0.06255376f, 
    -0.00206748f, 0.04267408f, -0.04089541f, -0.27989173f, -0.09091993f, -0.05820572f, 0.11044396f, 0.14766552f, 
    0.13421178f, -0.20429879f, -0.11666670f, 0.17453490f, -0.56394166f, -0.21610124f, 0.29892543f, -0.34781578f, 
    0.08271493f, -0.09925280f, 0.07038304f, 0.03276094f, 0.06810267f, -0.87021148f, 0.18156332f, 0.13933417f, 
    -0.04554620f, -0.09107227f, -0.10995217f, -0.08243757f, -0.09672116f, 0.00411165f, 0.16746734f, 0.17522493f, 
    -0.04864401f, -0.07468505f, 0.06208559f, -0.13489966f, 0.22102714f, 0.11576996f, 0.08917771f, -0.02181784f, 
    -0.01782705f, -0.15415640f, -0.16291520f, 0.02405647f, 0.07388684f, 0.02919836f, -0.04774892f, 0.15598054f, 
    -0.46140656f, -0.57928705f, -0.10396939f, 0.00598299f, 0.08602539f, -0.05732089f, -0.01700864f, -0.02695578f, 
    -0.01917982f, 0.13546872f, 0.21292315f, -0.03379053f, 0.07218415f, 0.12698588f, 0.15906416f, -0.00933707f, 
    0.03565768f, 0.02386443f, 0.20277752f, 0.01707122f, -0.18049335f, 0.00477284f, -0.04128048f, -0.05297383f, 
    0.00079097f, -0.11159004f, -0.09511507f, -0.42480308f, -0.52242333f, -0.23764572f, -0.13135511f, -0.04015285f, 
    0.05901835f, 0.03094731f, -0.03063422f, -0.01675129f, -0.20788316f, -0.03823242f, -0.14863651f, 0.03678492f, 
    0.05884276f, 0.00225894f, 0.04004029f, -0.17446558f, 0.09234854f, 0.08969320f, 0.05428309f, 0.04940594f, 
    0.17141749f, 0.06709917f, 0.09473456f, 0.16612238f, -0.02774119f, 0.11686113f, -0.12190858f, 0.14222275f, 
    0.03802041f, 0.15092002f, -0.06340171f, -0.10781670f, 0.08308738f, 0.01532111f, 0.14089134f, 0.16727737f, 
    0.18826167f, 0.04596389f, 0.05181791f, 0.03125758f, 0.09420834f, 0.01162628f, 0.18357480f, 0.02987411f, 
    0.03990326f, 0.02020148f, -0.05040372f, -0.15851739f, 0.00464248f, -0.04962940f, 0.12155334f, -0.05940643f, 
    -0.05304280f, -0.02080677f, -0.07880010f, -0.28605863f, -0.04504251f, 0.08927725f, 0.16119429f, -0.07693674f, 
    0.12513562f, 0.08552042f, -0.33420214f, 0.06955321f, -0.43070564f, 0.04326984f, -0.18078566f, 0.22575614f, 
    0.03762053f, 0.09678096f, -0.25136259f, 0.34399557f, 0.02612149f, -0.49443772f, -0.00460475f, 0.25866067f, 
    0.05686701f, 0.21956210f, -0.13876718f, -0.01998908f, -0.52099377f, -0.10297971f, -0.18222395f, 0.06293676f, 
    -0.03617577f, -0.07845775f, -0.10494634f, -0.17077504f, 0.08208897f, -0.36309373f, -0.16360523f, 0.19928594f, 
    0.03808111f, 0.11800237f, 0.09438682f, -0.05797655f, 0.02485349f, 0.06310580f, 0.03458657f, -0.03613904f, 
    -0.06151991f, -0.01886111f, -0.08274661f, -0.18547484f, -0.03358869f, 0.08108603f, 0.08094577f, 0.04283762f, 
    -0.03008500f, -0.01355462f, 0.00425189f, -0.02312549f, -0.17798363f, 0.08569224f, -0.03999009f, 0.04907922f, 
    -0.04680087f, 0.04009887f, 0.09463046f, -0.13068616f, 0.12479572f, -0.09574184f, 0.07463865f, 0.04404802f, 
    0.05351081f, 0.22273888f, 0.22277230f, -0.00671146f, -0.05753905f, 0.03685834f, 0.03431435f, -0.03979328f, 
    -0.09849213f, -0.17781122f, 0.19604564f, 0.07019939f, -0.16244297f, 0.05826125f, 0.08210091f, -0.01022155f, 
    -0.16807410f, -0.05314329f, -0.00704073f, 0.02631184f, 0.02725736f, 0.04779063f, -0.15689628f, 0.04588815f, 
    0.03263986f, 0.02570322f, 0.11802267f, 0.18955722f, 0.10872193f, 0.11567087f, 0.04365370f, -0.04938826f, 
    0.17525177f, -0.00117729f, -0.06204126f, 0.10213131f, -0.00996489f, 0.01340174f, 0.02192633f, -0.17071652f, 
    0.00458134f, -0.11808849f, -0.09449470f, 0.07891186f, -0.01314605f, 0.03031100f, 0.17299323f, 0.04850214f, 
    -0.07116440f, 0.08767946f, 0.12917377f, 0.07315549f, 0.16703697f, -0.07013141f, -0.11039251f, 0.17928147f, 
    -0.07860656f, -0.05514346f, 0.04349552f, 0.08027378f, 0.03811872f, 0.12153183f, 0.03105992f, -0.19226824f, 
    0.12114736f, 0.16015249f, -0.04037668f, 0.18012311f, 0.09253927f, -0.21660905f, -0.13325967f, -0.09814826f, 
    -0.04303008f, -0.19586186f, 0.07275130f, -0.05534787f, -0.18077594f, 0.12982248f, -0.01567114f, 0.00817115f, 
    -0.07494677f, 0.29444742f, 0.07010636f, -0.03222353f, 0.08802139f, -0.01115443f, -0.07619285f, -0.00992160f, 
    0.01291661f, -0.01504409f, -0.24371479f, -0.16277717f, -0.07487372f, 0.01286203f, -0.00974717f, -0.06799513f, 
    -0.08076387f, 0.12913400f, -0.03289444f, -0.22947018f, 0.16013598f, 0.00836775f, 0.01319529f, -0.19505729f, 
    -0.02747058f, -0.01392206f, -0.06460220f, -0.15253676f, 0.04789220f, 0.17968559f, 0.19826940f, -0.09596889f, 
    -0.12444802f, -0.04586255f, -0.14881414f, -0.01188334f, -0.12343015f, 0.03190896f, 0.24654905f, -0.20317408f, 
    -0.01409704f, 0.03019810f, -0.02164339f, 0.04990099f, 0.01076386f, 0.04809538f, 0.01824305f, -0.13720125f, 
    -0.34644926f, -0.23000957f, 0.03339782f, -0.09838549f, -0.13014273f, -0.03136984f, -0.03880445f, -0.20405196f, 
    0.14313023f, -0.03965297f, 0.10349210f, -0.02050884f, -0.17407982f, -0.07943479f, -0.09132343f, -0.08414353f, 
    0.07442177f, 0.27163601f, -0.13478683f, 0.04310156f, 0.13022360f, -0.09694149f, -0.03985456f, 0.03584179f, 
    0.05537808f, -0.00401831f, -0.12424423f, 0.03027359f, 0.14143717f, -0.05075770f, 0.07333568f, -0.01700444f, 
    0.05712970f, -0.11079063f, 0.06641173f, -0.07823628f, -0.07675366f, 0.04725368f, -0.20282967f, -0.08937613f, 
    0.07407029f, -0.06262524f, 0.07821494f, 0.19838206f, 0.02395954f, 0.10155924f, -0.11314224f, -0.01418398f, 
    0.00003385f, -0.25472358f, -0.11334726f, -0.20777884f, -0.34516025f, 0.05927632f, 0.07217103f, 0.11970562f, 
    0.07349914f, 0.03327203f, 0.10024469f, 0.04369678f, -0.03813525f, 0.01188227f, -0.11564817f, 0.08047105f, 
    0.21385239f, -0.08268283f, -0.00700414f, 0.06491499f, 0.06731483f, -0.04103299f, -0.09661897f, -0.13278139f, 
    -0.00071057f, -0.12241637f, -0.05521351f, 0.11367663f, 0.01167071f, 0.13782592f, 0.00753124f, 0.09322154f, 
    0.12081554f, 0.15157111f, 0.02272731f, 0.08235763f, 0.13809967f, 0.03342092f, -0.05642577f, -0.14925070f, 
    -0.01860058f, -0.08891422f, 0.11603140f, 0.07587296f, 0.14188322f, -0.02744140f, -0.11596058f, 0.10791738f, 
    0.01328949f, -0.32680753f, -0.08557039f, -0.16328819f, 0.01547163f, -0.15617551f, -0.06587881f, -0.01778338f, 
    0.05504948f, 0.09568927f, 0.18352251f, -0.09838621f, -0.13555324f, -0.02830507f, 0.05957366f, -0.16359681f, 
    0.02342568f, -0.12107265f, 0.15406655f, -0.02764849f, -0.05821952f, 0.15855472f, 0.11328443f, -0.04419022f, 
    0.11281701f, -0.05024392f, -0.06420270f, -0.13580878f, -0.09570628f, -0.00676129f, -0.03363556f, 0.02145944f, 
    0.09395274f, -0.12092103f, 0.18653660f, 0.06888915f, 0.03146256f, 0.08076328f, 0.35218164f, 0.05093940f, 
    -0.00926900f, 0.09291690f, 0.08068857f, 0.05061640f, 0.00865704f, 0.11502559f, -0.04937360f, 0.13090561f, 
    -0.09110940f, -0.03178496f, 0.02766388f, 0.05365875f, 0.01849016f, 0.01425011f, -0.03957343f, -0.08169554f, 
    0.07739273f, 0.05719144f, -0.33745593f, -0.08218870f, -0.14134347f, -0.06659542f, -0.05353224f, 0.00739110f, 
    0.00809564f, 0.06250963f, 0.27898106f, -0.06784151f, -0.20582010f, -0.14251639f, -0.11823792f, -0.08096088f, 
    0.01925173f, 0.22989646f, 0.10353426f, 0.07136465f, 0.06087012f, 0.02560742f, 0.07398363f, -0.21889772f, 
    0.01936970f, -0.00356451f, -0.05838207f, -0.31750682f, -0.43459073f, 0.08438310f, -0.03607660f, 0.09490231f, 
    -0.03091618f, 0.03220094f, -0.14282742f, 0.26419383f, -0.08778654f, -0.06148489f, -0.22005449f, 0.01757571f, 
    -0.03371080f, 0.08730147f, -0.04869283f, -0.00636378f, 0.08922280f, -0.03492553f, 0.01705313f, 0.38527432f, 
    -0.26999700f, 0.12968694f, -0.12026592f, -0.00124564f, 0.09807670f, 0.02019834f, 0.27248511f, 0.12151146f, 
    -0.06454282f, -0.02302946f, 0.01037289f, 0.00023848f, 0.05243070f, -0.03222573f, -0.12552972f, 0.07666332f, 
    0.26807377f, -0.07674147f, -0.04373020f, -0.22855179f, -0.05096088f, -0.12444992f, 0.06443255f, -0.06378777f, 
    0.31431189f, 0.07599485f, 0.09818247f, -0.05747986f, -0.10296131f, -0.10946454f, 0.00029791f, 0.05263941f, 
    -0.03906950f, -0.10033396f, -0.53432846f, -0.54064435f, -0.17294365f, 0.09057725f, 0.16002913f, -0.03965922f, 
    0.01706247f, 0.06513675f, 0.02056989f, 0.11176988f, 0.01385811f, -0.16289653f, -0.05668432f, 0.04312555f, 
    -0.04957393f, -0.14478852f, -0.05039707f, -0.12837690f, -0.18111911f, -0.25858322f, -0.15053436f, -0.00193150f, 
    -0.06540664f, -0.01033219f, 0.17145169f, -0.09147093f, 0.09449456f, -0.14431915f, 0.05126038f, 0.11249839f, 
    -0.16361158f, -0.16654427f, 0.00286561f, -0.00819104f, 0.01123269f, 0.11950538f, 0.08339466f, 0.10680839f, 
    -0.19265760f, -0.12347218f, -0.14981076f, 0.11291598f, 0.06656136f, 0.11598710f, 0.05486107f, 0.18481369f, 
    0.02731096f, -0.02176732f, -0.08724331f, -0.11520332f, -0.11556511f, 0.05535880f, 0.08293845f, -0.02450072f, 
    -0.26378003f, -0.30187708f, -0.08655597f, -0.07443865f, -0.03740111f, 0.03244626f, -0.02266507f, -0.20345832f, 
    0.17536218f, -0.13087486f, -0.35189676f, -0.24405575f, -0.03094206f, -0.16929987f, -0.01949254f, -0.00217135f, 
    -0.02596476f, -0.19629526f, 0.07066589f, -0.01613249f, 0.01760354f, 0.03311259f, 0.04735853f, 0.06803624f, 
    0.09683192f, 0.13264233f, -0.10739692f, -0.16438854f, -0.35496655f, -0.07655377f, 0.05175660f, 0.03479902f, 
    0.08824812f, 0.11280056f, 0.00994306f, -0.33179417f, -0.28876042f, -0.49503738f, -0.24963565f, -0.02169903f, 
    0.07611876f, -0.04448068f, 0.02217364f, 0.04925260f, -0.00265520f, -0.00767820f, -0.12936023f, -0.20147154f, 
    -0.04619542f, -0.06984439f, 0.13658494f, 0.07672045f, -0.03733322f, 0.11495274f, 0.03368666f, 0.16025575f, 
    0.10420822f, 0.07793063f, 0.03075206f, -0.02458238f, 0.02175300f, 0.10972181f, 0.04564184f, -0.00873969f, 
    0.03641702f, -0.00098309f, 0.05200920f, 0.02947782f, 0.02228106f, 0.09016046f, 0.36362138f, 0.21882454f, 
    0.15159349f, -0.05788393f, 0.16165222f, -0.03634080f, -0.02372209f, 0.24265741f, 0.12553911f, 0.05330251f, 
    0.30680272f, 0.03877475f, 0.12823030f, -0.00057032f, -0.02774243f, -0.12905952f, -0.01455097f, 0.06558497f, 
    0.10665856f, 0.13437591f, -0.16482380f, -0.17438969f, 0.06466383f, 0.17382184f, 0.12630254f, 0.15550354f, 
    -0.06414940f, -0.13897581f, -0.04395729f, 0.16981040f, -0.34214246f, -0.09190536f, -0.01677189f, 0.06790599f, 
    0.08237666f, -0.02818506f, -0.03072373f, -0.31015888f, -0.58781719f, -0.68930715f, 0.15879272f, 0.10569032f, 
    0.10683515f, -0.03330499f, -0.01578894f, 0.08646177f, -0.19212714f, -0.17424610f, -0.00992282f, 0.08893315f, 
    0.06434797f, 0.03472539f, 0.03174802f, 0.02773160f, 0.02053076f, -0.00364706f, -0.04941605f, -0.09373025f, 
    -0.16248983f, -0.02072649f, -0.01789276f, 0.16239704f, 0.00598816f, 0.12583758f, 0.23088180f, 0.22877473f, 
    0.01863128f, -0.00578014f, -0.19284377f, -0.24502064f, 0.11171842f, 0.01404824f, 0.06534051f, 0.37942997f, 
    0.05308466f, 0.28164855f, 0.06709558f, 0.03261157f, 0.00919376f, 0.03482588f, 0.14985467f, 0.08178071f, 
    0.08156805f, -0.15655820f, -0.25867781f, 0.01180764f, -0.07377324f, 0.01966079f, 0.03138221f, 0.12962854f, 
    0.14353207f, 0.07990093f, 0.02084445f, 0.11353171f, 0.14458188f, -0.01557167f, -0.01357526f, 0.04899247f, 
    0.03095552f, 0.05838782f, -0.09535355f, 0.02438633f, -0.42063877f, 0.12298874f, -0.06552900f, 0.03488080f, 
    -0.00018436f, -0.00096897f, -0.12342519f, -0.05067258f, -0.01893646f, -0.24643795f, -0.12137224f, 0.04198062f, 
    0.08446140f, -0.01121074f, 0.06299628f, 0.10824095f, 0.20440406f, 0.06589081f, 0.21936393f, -0.01294412f, 
    0.03392134f, 0.03540439f, 0.06782101f, 0.12176786f, -0.12533221f, 0.22305025f, 0.16168721f, 0.06526705f, 
    -0.03429371f, -0.12587054f, -0.03378906f, -0.10566950f, -0.05090292f, 0.02129103f, -0.07328571f, -0.07198867f, 
    -0.21381588f, -0.01305532f, 0.03533084f, -0.16646399f, 0.09872451f, -0.14650276f, 0.07055963f, -0.01125143f, 
    -0.08212008f, -0.11945888f, 0.17169307f, -0.01878822f, 0.01576983f, -0.05945113f, -0.13121974f, 0.13978368f, 
    -0.14197621f, 0.10630240f, -0.14734782f, 0.14992231f, -0.00429446f, -0.00253376f, -0.01467197f, 0.03789138f, 
    -0.15767908f, -0.06767853f, -0.25071239f, 0.08357956f, 0.14047608f, 0.00621970f, -0.03380679f, -0.03973968f, 
    0.03099729f, 0.08203538f, 0.00012298f, -0.10653429f, -0.18164413f, 0.11902937f, 0.13244759f, 0.19216725f, 
    -0.15287657f, -0.20697205f, -0.28477997f, 0.25196970f, 0.06128532f, -0.12796688f, -0.08152533f, -0.23023887f, 
    0.14761119f, 0.03070671f, -0.02955084f, -0.12759086f, 0.03886900f, 0.08454280f, 0.08333939f, -0.05619073f, 
    -0.08621525f, 0.06916385f, 0.20167108f, -0.10350101f, -0.03729476f, 0.21973963f, 0.25633976f, 0.22892690f, 
    -0.01046520f, 0.10526934f, 0.08290959f, 0.06353269f, -0.03277224f, 0.00421540f, -0.13678126f, 0.16195102f, 
    -0.11415523f, 0.04645835f, -0.10654133f, -0.02899838f, 0.21269071f, -0.05282588f, -0.02898243f, -0.00537049f, 
    -0.13885044f, -0.07373358f, -0.05807564f, -0.14541750f, 0.16923846f, -0.19596827f, -0.01062974f, -0.16254131f, 
    0.03862674f, -0.00175004f, 0.02868290f, 0.06533610f, 0.06203748f, 0.13347043f, 0.10759116f, 0.01293130f, 
    -0.04090827f, 0.36441484f, 0.11546002f, -0.08894306f, 0.03399441f, -0.03632659f, 0.03243841f, 0.03221719f, 
    -0.05393873f, -0.00454515f, 0.17007202f, -0.12396663f, -0.05165290f, 0.06927931f, 0.02826997f, 0.05618734f, 
    0.03003903f, -0.00605185f, 0.03843098f, -0.19223279f, 0.01990145f, -0.01715306f, -0.09582561f, 0.07498638f, 
    -0.02255163f, -0.06316338f, -0.05319043f, 0.10502131f, 0.00461339f, 0.19848046f, 0.03711259f, 0.01379910f, 
    0.04207082f, 0.15548672f, -0.14267839f, -0.16700175f, -0.35175043f, -0.06150366f, 0.03580036f, -0.18260956f, 
    0.14857544f, 0.18648189f, -0.00117576f, 0.00799966f, 0.12508082f, -0.09296101f, 0.02278465f, 0.09372131f, 
    -0.24426600f, 0.05291770f, -0.04047384f, -0.01219029f, 0.01637146f, 0.15851463f, 0.16934162f, -0.06115457f, 
    -0.07645609f, -0.04325376f, 0.08191413f, -0.03706775f, -0.00967365f, 0.05899317f, -0.00286254f, 0.08312300f, 
    0.04213883f, -0.10771829f, -0.42934370f, 0.03719825f, -0.00152903f, 0.05554949f, 0.00612843f, -0.02405292f, 
    -0.06190473f, -0.05372481f, -0.06216477f, -0.27896389f, 0.03681825f, 0.06528904f, 0.05222797f, 0.09262598f, 
    -0.01690913f, -0.23801251f, -0.19124371f, 0.04819654f, 0.07308844f, -0.06684871f, 0.01279143f, 0.08774770f, 
    0.00591278f, -0.04902678f, 0.03579751f, -0.19307286f, 0.16296209f, 0.21215944f, 0.13807482f, 0.08317818f, 
    -0.17828706f, -0.03174146f, -0.05976757f, -0.01542000f, 0.16746214f, 0.20769514f, 0.15863512f, -0.12296210f, 
    0.00575212f, 0.03610905f, 0.13329253f, 0.04934542f, -0.16287391f, 0.08848500f, 0.16475718f, 0.07323623f, 
    0.05448508f, -0.00847417f, 0.15948546f, 0.06567319f, -0.01395142f, -0.07436156f, 0.18882072f, 0.00149834f, 
    -0.00577985f, 0.02811134f, -0.09554861f, 0.15345612f, -0.00968696f, 0.02893856f, -0.02260908f, 0.06005811f, 
    -0.09461535f, -0.24955848f, 0.00498880f, 0.10184968f, -0.07465361f, 0.00803810f, 0.14773822f, 0.09238085f, 
    -0.06485337f, 0.11852192f, -0.05008940f, -0.00974901f, 0.00446623f, 0.05408116f, -0.21604715f, -0.01249197f, 
    0.18479174f, 0.02408798f, -0.02445382f, 0.10535865f, -0.03807253f, -0.08847655f, -0.11891906f, -0.10226327f, 
    -0.12064444f, 0.08460020f, 0.30918762f, -0.07392772f, 0.05353897f, 0.06379297f, -0.08655988f, 0.17878439f, 
    -0.14527047f, 0.03796897f, -0.01763537f, -0.00356813f, 0.05834272f, -0.07247732f, 0.04437821f, 0.03747189f, 
    -0.17241904f, -0.04108854f, -0.16424917f, -0.06098167f, 0.10982084f, 0.07260378f, 0.02500357f, -0.23613876f, 
    -0.04399622f, 0.00249577f, 0.03001730f, 0.06724183f, 0.05663558f, -0.03672091f, -0.11935562f, 0.13154735f, 
    -0.08450545f, 0.02528122f, 0.16824539f, -0.01282766f, 0.02276262f, 0.12930919f, 0.13616650f, 0.12438104f, 
    -0.01719858f, 0.06127878f, 0.03976494f, 0.13039544f, -0.02139352f, -0.03884238f, -0.03122407f, -0.00821114f, 
    0.09444719f, 0.01671041f, -0.05141217f, -0.00127089f, -0.11966106f, -0.04568351f, -0.04811721f, -0.00948329f, 
    0.24159467f, 0.03971191f, 0.17761339f, 0.03450548f, 0.09745912f, 0.16203833f, -0.02677666f, 0.09388693f, 
    0.05205279f, 0.14860074f, 0.08278867f, -0.12747850f, -0.06115432f, -0.00910650f, -0.06577747f, -0.01855084f, 
    -0.06943262f, 0.02419700f, 0.05016017f, -0.12140431f, -0.05402713f, -0.07325023f, 0.06035577f, -0.04351255f, 
    0.19748513f, -0.04458237f, -0.00350657f, -0.12650119f, -0.13820131f, 0.03753413f, -0.11682289f, 0.09531815f, 
    0.11294626f, 0.04890078f, -0.06780879f, -0.01248107f, 0.27347422f, -0.06959035f, -0.08055661f, 0.13438679f, 
    0.00476892f, -0.04539674f, 0.05720517f, -0.10671586f, 0.11544836f, 0.09672073f, -0.06018645f, 0.12184740f, 
    -0.12868449f, -0.07919600f, 0.00056300f, 0.00901065f, -0.08905248f, 0.05815141f, 0.13209116f, -0.03021868f, 
    0.02986125f, -0.01553762f, -0.06259830f, -0.11379044f, -0.08363750f, 0.01159535f, 0.06538253f, -0.18838976f, 
    -0.07230187f, -0.01061889f, 0.01736659f, 0.26711512f, -0.01162962f, 0.15891296f, -0.11770661f, -0.14762999f, 
    0.16028273f, 0.04498356f, -0.30254093f, 0.00930857f, -0.11448020f, -0.09281123f, -0.00047316f, -0.09519672f, 
    0.08972940f, 0.08214601f, -0.60664564f, -0.07697988f, -0.10015354f, 0.05842739f, -0.11269658f, 0.15290789f, 
    0.02023564f, -0.10373618f, -0.01276830f, 0.05097961f, -0.00297091f, -0.09384980f, -0.03582547f, -0.13138023f, 
    -0.03917481f, 0.07375220f, 0.05264620f, 0.03260779f, 0.04969253f, -0.07184935f, -0.04293962f, 0.09482352f, 
    -0.07382841f, -0.06673380f, 0.03466260f, 0.03420748f, 0.08373109f, -0.07150415f, -0.21763663f, -0.02083399f, 
    0.04943253f, 0.04270487f, 0.07483823f, 0.02534233f, 0.13104698f, 0.08493887f, -0.00780403f, 0.12224252f, 
    0.08996413f, -0.03599824f, 0.09252936f, -0.04871210f, 0.09398942f, -0.03706215f, -0.09711069f, 0.05775276f, 
    -0.02884275f, -0.03571398f, 0.07929117f, -0.06267569f, -0.17152999f, -0.09233055f, 0.12047280f, 0.04979709f, 
    0.06435665f, 0.17266317f, -0.01669434f, 0.10306680f, 0.01692506f, 0.09955882f, -0.17750026f, 0.12362649f, 
    0.13485049f, 0.01460089f, 0.08800249f, -0.01055394f, -0.07920448f, 0.02438489f, -0.08846238f, 0.17070599f, 
    0.07625768f, -0.08157195f, 0.02696511f, 0.05124331f, 0.03137150f, -0.03601499f, -0.06637397f, 0.06701444f, 
    0.06411170f, -0.15797295f, 0.06640301f, -0.17124991f, -0.12111875f, -0.01830763f, -0.12430190f, 0.04931815f, 
    -0.12507212f, 0.00134884f, 0.11644856f, 0.03936507f, -0.24006137f, -0.31810179f, 0.06313457f, 0.09492356f, 
    0.07094873f, 0.01018770f, 0.01290658f, -0.03977105f, 0.06175685f, -0.04567403f, -0.08291930f, -0.01146368f, 
    -0.05661473f, -0.03339066f, 0.01691769f, 0.02028673f, 0.13381396f, 0.02465667f, -0.15296152f, -0.13670868f, 
    0.06147551f, -0.07017656f, -0.03969572f, -0.13552278f, 0.05336362f, -0.09058068f, 0.20474978f, -0.20937273f, 
    0.26819065f, -0.06744112f, 0.06877698f, -0.02711879f, 0.02784339f, 0.01984161f, 0.01472060f, 0.04571342f, 
    -0.08851132f, 0.19609471f, 0.09454722f, -0.07491465f, -0.05994704f, -0.03599329f, 0.10913133f, 0.02281967f, 
    -0.07640219f, 0.00450480f, 0.20157257f, 0.00188378f, 0.09772523f, -0.12561586f, -0.09798426f, -0.11407031f, 
    -0.16597265f, 0.01560262f, 0.01301527f, 0.15289070f, 0.08976915f, 0.00768859f, -0.01801424f, -0.02417549f, 
    -0.14980593f, 0.00201122f, -0.20599368f, -0.05694908f, -0.06457899f, 0.08168459f, -0.05918686f, -0.19575821f, 
    -0.13603902f, -0.05802628f, 0.03801781f, 0.07200234f, -0.31295702f, -0.13785312f, 0.00308323f, 0.17626756f, 
    -0.09027279f, -0.12407649f, -0.01038085f, -0.21073735f, 0.11243482f, 0.19522746f, 0.06832752f, 0.04730278f, 
    -0.01323104f, 0.09720204f, 0.04239942f, 0.02660584f, 0.11545464f, -0.00182394f, 0.12813805f, 0.00231374f, 
    0.04679463f, -0.04788468f, 0.04972546f, -0.02791368f, 0.09546659f, -0.07507680f, -0.04702782f, -0.10726443f, 
    0.07613921f, 0.14584982f, 0.02354901f, 0.01393700f, -0.04979924f, 0.08677033f, 0.14909135f, -0.00430739f, 
    0.05719202f, 0.14834523f, 0.00540554f, -0.10600161f, 0.00199135f, 0.07861200f, 0.00892412f, 0.02612946f, 
    -0.20766847f, -0.09968426f, 0.11134381f, -0.07740631f, 0.16389598f, -0.04768532f, -0.04849333f, -0.00268955f, 
    0.08235436f, 0.30753732f, -0.10986168f, -0.05777115f, 0.03752334f, -0.10467428f, 0.03882263f, 0.02814177f, 
    -0.00788858f, 0.03388280f, 0.02176872f, 0.04843665f, 0.10159857f, -0.23979954f, -0.06743760f, -0.00125848f, 
    0.13117823f, 0.11672331f, 0.09021795f, -0.01290018f, 0.00112978f, 0.19767568f, -0.09444484f, -0.03837301f, 
    0.01085491f, 0.09215254f, 0.27848148f, 0.19311146f, -0.14694366f, 0.16892333f, 0.25175321f, 0.06044027f, 
    0.16655922f, 0.04791384f, -0.07103511f, 0.04630957f, 0.08678637f, 0.02650959f, 0.18110296f, 0.08161252f, 
    -0.05048163f, 0.06289559f, 0.09755489f, 0.00321584f, -0.00976644f, -0.15462482f, -0.01507913f, 0.04599074f, 
    -0.03915724f, 0.11337461f, 0.06388763f, -0.13906972f, -0.01207238f, -0.14113517f, 0.02446283f, 0.06428588f, 
    0.01014883f, 0.23952469f, 0.00006328f, -0.21448995f, 0.08084761f, 0.16932043f, 0.06229385f, -0.10758144f, 
    -0.04637290f, 0.30614540f, 0.13390318f, -0.06162290f, 0.15433703f, 0.03629926f, 0.00104682f, 0.13395114f, 
    -0.00878683f, -0.01635021f, 0.08489884f, -0.34083235f, -0.05134777f, -0.00196256f, 0.00344933f, -0.07669396f, 
    -0.21551096f, -0.04956416f, 0.07667341f, 0.00861337f, 0.07184090f, -0.06955076f, -0.07750665f, -0.19166337f, 
    0.04743123f, 0.01012862f, 0.04356997f, 0.26293868f, -0.05754869f, -0.31247386f, -0.08582879f, 0.03603756f, 
    -0.03270032f, -0.01632689f, -0.12899333f, 0.00736550f, 0.04288791f, -0.04090625f, -0.00793206f, -0.07412100f, 
    0.10306183f, -0.00228353f, -0.04766053f, 0.09911323f, 0.08143026f, 0.01950845f, -0.12350816f, 0.06338885f, 
    0.01747566f, 0.12270714f, -0.00316815f, -0.07221074f, -0.01868626f, 0.02752183f, -0.14973481f, -0.07445791f, 
    0.09489521f, -0.01022712f, 0.09305104f, 0.12727758f, -0.31808761f, -0.29087293f, -0.25627813f, -0.13422295f, 
    0.14745547f, 0.15298228f, -0.08283911f, -0.14898758f, 0.04690948f, -0.09722115f, -0.00520854f, -0.15229829f, 
    -0.07130536f, -0.00758008f, 0.16359383f, 0.05385807f, 0.01606770f, -0.10904508f, -0.02318239f, 0.12576982f, 
    0.08879812f, 0.09805147f, 0.00867300f, 0.05754698f, -0.10788926f, -0.21306461f, -0.04946070f, 0.10071389f, 
    0.08072340f, 0.11641590f, 0.18729101f, 0.24183720f, 0.04021314f, 0.01531237f, 0.03481810f, -0.01620574f, 
    0.01915023f, 0.03800376f, -0.04194335f, -0.13203850f, -0.01719591f, -0.27196428f, -0.07815062f, 0.11373348f, 
    -0.04422653f, 0.08153629f, -0.04429581f, -0.11906850f, 0.02141930f, 0.05146176f, 0.08013439f, 0.00017182f, 
    0.06126984f, 0.01032298f, 0.05370979f, -0.05278565f, 0.13452744f, -0.08024508f, 0.19853438f, 0.00374259f, 
    0.09885489f, 0.05632722f, 0.04017396f, 0.07062891f, 0.00765065f, -0.22646815f, -0.13710402f, -0.01010968f, 
    0.02307958f, -0.03086563f, -0.01599225f, 0.00759593f, -0.01233686f, 0.02957458f, -0.05930126f, -0.04988800f, 
    -0.18084987f, 0.19787940f, -0.04997525f, 0.04704280f, -0.05620366f, -0.07020945f, -0.06564394f, 0.12236949f, 
    -0.00154922f, 0.00873047f, -0.03240984f, 0.02145806f, -0.06330911f, -0.00243433f, -0.05920403f, 0.00796093f, 
    0.00602261f, -0.06725347f, 0.00104763f, -0.00371715f, -0.06721007f, -0.06367992f, -0.00182911f, -0.06204569f, 
    -0.06427896f, 0.01948961f, -0.01889591f, -0.00740380f, -0.03706675f, -0.01645191f, 0.00299324f, -0.04475108f, 
    -0.06404759f, -0.03374455f, 0.01769818f, 0.02528220f, -0.04297428f, -0.02976085f, -0.02747849f, -0.02760551f, 
    -0.05731966f, -0.04721455f, -0.01016909f, -0.04655527f, -0.03768377f, -0.05411867f, 0.00899265f, -0.05034547f, 
    -0.06733602f, 0.03599137f, -0.01283602f, 0.04612085f, 0.02766401f, 0.00581773f, 0.00189826f, -0.00088781f, 
    -0.01242477f, 0.04431935f, 0.02731330f, -0.05733469f, -0.03784323f, -0.00971635f, -0.04015690f, 0.03931016f, 
    -0.00874658f, 0.04846280f, 0.05066933f, -0.05662641f, -0.00489846f, 0.05012413f, -0.01313217f, -0.05378316f, 
    0.01591639f, 0.00992031f, 0.04808238f, 0.04555871f, -0.02268380f, -0.05505945f, 0.02214462f, 0.02116792f, 
    0.01997366f, 0.03473731f, -0.01056919f, -0.03030204f, 0.04477423f, 0.03011395f, -0.05038553f, 0.03120824f, 
    0.01192997f, 0.00457552f, 0.01295906f, 0.03922696f, 0.02388177f, 0.00285627f, -0.00813649f, 0.00987211f, 
    0.02249364f, 0.00700876f, -0.02337468f, 0.03152755f, -0.03307976f, -0.04029897f, -0.00803588f, -0.03716158f, 
    -0.05682944f, -0.03316502f, 0.00162290f, -0.03180916f, -0.06481200f, 0.04978954f, -0.03720821f, -0.04016769f, 
    -0.04439321f, 0.03801650f, -0.04018323f, -0.01048469f, -0.06161097f, -0.04656370f, -0.00917582f, 0.03514386f, 
    -0.00663748f, 0.02754214f, -0.00088073f, 0.01065524f, -0.02815445f, -0.02967083f, 0.02076193f, -0.02246662f, 
    -0.03584971f, 0.01889407f, 0.05028673f, -0.05340423f, 0.03717981f, 0.04466875f, -0.03677963f, 0.01654088f, 
    0.03404014f, -0.00250110f, 0.02526524f, 0.04152753f, -0.02722357f, -0.00935020f, -0.04105890f, -0.00754821f, 
    -0.01616930f, -0.01351207f, 0.01565677f, 0.01039764f, 0.01631539f, 0.00804805f, -0.03547142f, 0.00684963f, 
    -0.06034181f, 0.01925136f, 0.00998709f, -0.01505416f, -0.02099664f, 0.04232242f, -0.03813328f, 0.03276861f, 
    -0.02234381f, 0.01992172f, 0.02824850f, -0.06556218f, 0.00433421f, -0.03077670f, -0.00864363f, -0.02140811f, 
    -0.06169919f, -0.01372465f, 0.03724558f, -0.00797599f, 0.03918932f, -0.00110238f, 0.01993174f, 0.02727996f, 
    -0.03503250f, 0.00127143f, -0.01049109f, -0.00502457f, -0.03331180f, -0.02871037f, 0.00473700f, -0.06931821f, 
    0.00991096f, -0.04272896f, 0.02228229f, 0.00012453f, -0.04930809f, 0.00807248f, -0.03863418f, -0.00734092f, 
    0.04001860f, 0.03967782f, 0.05048945f, -0.00241480f, 0.01086753f, -0.04381802f, -0.04835024f, -0.00986690f, 
    -0.05258092f, 0.00015075f, 0.00178754f, -0.02046907f, -0.04854631f, 0.05345594f, -0.05946267f, 0.02270983f, 
    0.03791865f, 0.04835038f, 0.02257071f, -0.05698525f, 0.00762485f, -0.05660143f, -0.03634939f, 0.00395099f, 
    -0.05937124f, 0.04875191f, -0.01772124f, 0.01937969f, -0.01042130f, 0.00133953f, -0.03974925f, -0.03995190f, 
    0.03492991f, 0.03117867f, -0.02486514f, -0.00929456f, -0.05680707f, -0.02715829f, 0.05112885f, -0.02024210f, 
    -0.01284260f, -0.05840332f, -0.03969136f, -0.01366269f, -0.06070232f, 0.02837299f, -0.05073541f, -0.00290751f, 
    0.01330818f, -0.02660576f, 0.04565019f, 0.01121145f, -0.00051691f, 0.04462453f, -0.04020552f, 0.00415475f, 
    -0.03942626f, -0.03493741f, 0.01427006f, -0.00441466f, 0.02536384f, -0.05929479f, -0.02341415f, 0.04495795f, 
    0.04487871f, -0.03905363f, 0.02043762f, 0.01980921f, -0.03076678f, 0.04948166f, 0.00802281f, 0.04906090f, 
    -0.01347659f, -0.02431901f, -0.00096943f, -0.01122277f, 0.01857011f, -0.06231523f, -0.00471114f, -0.03398153f, 
    -0.00345135f, -0.04026346f, -0.01427375f, -0.03669953f, -0.02753331f, -0.06455205f, -0.01742216f, -0.06130484f, 
    0.00070651f, 0.00851791f, -0.04440420f, -0.00695168f, 0.04623364f, 0.00877318f, -0.06636506f, -0.06612865f, 
    -0.06996944f, -0.05999674f, -0.00941562f, -0.02229106f, -0.05428250f, -0.01779363f, -0.03220922f, -0.03266174f, 
    -0.03855874f, -0.00724226f, -0.05248684f, -0.16705942f, 0.02845040f, -0.02633695f, 0.10228884f, 0.00493894f, 
    -0.05126427f, -0.01570381f, -0.03389481f, -0.12269846f, -0.05676526f, -0.01177725f, 0.03594411f, 0.08512304f, 
    0.02590648f, -0.04456368f, 0.42461553f, -0.07218351f, -0.13387701f, 0.04147074f, -0.09208646f, -0.22707306f, 
    0.03439793f, -0.01985243f, 0.05026616f, -0.14832625f, -0.39036036f, -0.07214423f, 0.10826006f, 0.03492989f, 
    0.08986007f, -0.14415015f, 0.01388630f, 0.19484597f, -0.14052336f, -0.26651499f, 0.16038387f, 0.02394700f, 
    0.14022990f, -0.04776943f, 0.05906318f, 0.03211657f, -0.03632610f, 0.11308338f, -0.08025808f, -0.06630871f, 
    0.03733837f, -0.12111883f, 0.02714851f, 0.06003423f, 0.02275210f, -0.03159024f, 0.15712447f, -0.17426836f, 
    -0.14447437f, 0.18639278f, -0.03025724f, 0.06554430f, 0.14252095f, -0.04409549f, 0.05969353f, -0.04451691f, 
    -0.05964534f, -0.10544682f, -0.08766256f, 0.04139280f, -0.05104862f, 0.13071273f, 0.09352364f, 0.01646555f, 
    0.12086572f, -0.04419551f, -0.09684385f, -0.04371621f, 0.01319706f, 0.03424092f, 0.00447472f, 0.02437376f, 
    -0.01614113f, -0.62182134f, -0.00949354f, -0.16804193f, -0.11772799f, 0.01476519f, 0.18286404f, -0.01055743f, 
    0.01591674f, -0.00319722f, 0.01857990f, -0.01205443f, 0.06677445f, -0.18282047f, -0.05119897f, 0.03516712f, 
    0.08897424f, 0.06463712f, 0.10074559f, -0.14356022f, -0.15130283f, -0.04416752f, -0.03633004f, 0.01027579f, 
    -0.02311457f, 0.21931103f, 0.08662710f, 0.02674702f, 0.08680613f, -0.10854629f, 0.21112312f, -0.01247434f, 
    -0.13485706f, 0.02543719f, -0.00548538f, -0.01074277f, -0.05430689f, 0.04141176f, -0.17512946f, 0.22463588f, 
    -0.01230413f, -0.03627932f, -0.01507397f, 0.01868762f, -0.04547928f, -0.04723930f, 0.14609934f, -0.22479995f, 
    0.03608943f, 0.00386994f, -0.09007221f, -0.09436726f, 0.03412910f, -0.06199793f, 0.13776872f, -0.09352939f, 
    -0.38121846f, -0.02238654f, 0.07358821f, -0.11027323f, -0.12145602f, 0.05976896f, 0.01743156f, -0.02012776f, 
    0.00828878f, -0.03664963f, 0.17143171f, 0.03654827f, -0.09229384f, 0.14512704f, -0.00477236f, -0.04006580f, 
    -0.09142269f, 0.48338789f, 0.19674756f, 0.13136335f, 0.00128265f, 0.08157195f, 0.11125682f, 0.04772073f, 
    0.01542768f, -0.13779032f, -0.05666823f, 0.05083656f, -0.07251754f, 0.01058555f, 0.10699902f, -0.00359853f, 
    0.11518428f, 0.03728272f, 0.10670716f, -0.25131711f, -0.03934586f, -0.13412701f, -0.08822266f, 0.02511257f, 
    0.00674977f, -0.03518590f, 0.09656298f, -0.19842744f, -0.06558872f, -0.16105512f, 0.08022875f, -0.12619390f, 
    -0.13438553f, -0.20630297f, 0.12586409f, -0.03915178f, 0.09771152f, 0.24295093f, -0.11430425f, -0.00679954f, 
    -0.01790065f, 0.02383890f, 0.15882587f, 0.01273579f, 0.06173161f, 0.05146104f, 0.06932428f, -0.01236209f, 
    -0.02833080f, -0.01311226f, -0.00692323f, 0.05769391f, -0.14473064f, -0.05934993f, -0.18902706f, 0.07334583f, 
    0.05218910f, 0.14195423f, 0.07507279f, 0.03930322f, -0.07050780f, 0.25360957f, -0.09226817f, -0.03675289f, 
    0.02016844f, -0.02980568f, -0.07103837f, 0.09827108f, -0.08552518f, -0.00572161f, 0.03173522f, 0.08089699f, 
    0.10147107f, -0.01472283f, 0.00026760f, 0.00173593f, 0.03488613f, 0.01711950f, -0.00492559f, -0.00010853f, 
    0.07352729f, 0.06165845f, -0.22630481f, -0.07361703f, 0.22063306f, 0.00380505f, 0.00203984f, 0.07846447f, 
    0.14042842f, -0.06790576f, 0.00253609f, 0.04800802f, -0.15526840f, 0.01580431f, -0.01417767f, 0.07924296f, 
    -0.01240164f, -0.01989221f, -0.03895613f, -0.13915215f, -0.06744356f, 0.12435725f, 0.15763471f, -0.05050539f, 
    0.00193942f, -0.02727088f, -0.02137681f, -0.00399429f, 0.06438689f, 0.13601683f, 0.05368525f, 0.24697085f, 
    0.01869585f, -0.03958455f, 0.13067068f, 0.20868240f, 0.05042681f, 0.04145185f, 0.09824410f, 0.00309939f, 
    0.21020214f, -0.07295110f, 0.04156974f, -0.04134120f, 0.02788292f, 0.02203130f, -0.11102837f, 0.01168453f, 
    -0.13998994f, 0.16609758f, 0.05714104f, 0.00019528f, 0.10080004f, -0.01345466f, 0.06513966f, -0.00027944f, 
    -0.03962363f, 0.00208470f, -0.00339707f, 0.12690729f, 0.12234314f, 0.01602913f, 0.00415930f, -0.23152947f, 
    -0.01567470f, 0.03760023f, 0.14420052f, -0.00595239f, 0.10935447f, 0.03506803f, 0.00625331f, 0.05535937f, 
    -0.08527471f, 0.02116939f, -0.18966627f, 0.03572571f, 0.11328795f, -0.00168697f, 0.05790235f, -0.11450008f, 
    0.02255154f, -0.02360558f, -0.07353560f, -0.07743258f, -0.00389595f, -0.04364466f, 0.11976325f, 0.13364230f, 
    0.10016149f, 0.12952049f, 0.27239561f, 0.19546862f, 0.10580461f, -0.16639198f, -0.18295024f, 0.08655807f, 
    -0.00070351f, 0.10857852f, 0.06728441f, 0.06681765f, -0.07142895f, 0.21621643f, 0.01752073f, -0.17424430f, 
    0.16942465f, 0.12583292f, -0.00689424f, -0.05545162f, 0.17055883f, -0.04772603f, 0.00351522f, 0.12963690f, 
    0.05668429f, 0.03282245f, -0.10140409f, -0.11539457f, 0.16801938f, 0.05841403f, -0.05698402f, 0.06434388f, 
    0.07442141f, -0.06224088f, 0.01648427f, -0.01702897f, -0.00606497f, -0.03850761f, -0.11859446f, -0.02233460f, 
    -0.12529136f, 0.10058419f, -0.01834097f, -0.01210446f, -0.02817079f, -0.11799520f, 0.06365427f, 0.01906668f, 
    -0.07251259f, -0.08421460f, -0.23211473f, -0.17934871f, -0.00054321f, 0.17210226f, 0.22103287f, 0.04412940f, 
    0.07076131f, 0.09759947f, 0.03425562f, 0.05055840f, -0.09448889f, 0.06121043f, -0.03903141f, 0.10001904f, 
    -0.22402868f, -0.20925876f, -0.25920159f, 0.02048458f, 0.07495391f, -0.06997864f, 0.07851692f, -0.04328185f, 
    0.01472671f, -0.21635453f, -0.18739964f, -0.15981659f, 0.03857420f, 0.11733158f, 0.00322691f, 0.06355130f, 
    0.08675864f, 0.05519592f, -0.04022507f, -0.04956137f, -0.05551735f, 0.20887379f, 0.09984224f, 0.01119528f, 
    0.20405674f, 0.04422029f, 0.02008745f, -0.08654170f, 0.03185800f, -0.12862591f, -0.12003776f, 0.12209317f, 
    -0.04546083f, -0.03078668f, -0.08139923f, 0.04223488f, 0.12439567f, 0.04875001f, 0.05028564f, 0.09111241f, 
    0.00472481f, -0.29299033f, 0.07893139f, 0.13216540f, 0.09972393f, -0.17717364f, 0.06780963f, -0.18825278f, 
    0.16705827f, 0.03906486f, -0.04728237f, 0.19006032f, 0.03131213f, -0.10050495f, -0.03137492f, 0.05294673f, 
    0.04728726f, 0.09628271f, 0.10906303f, 0.24758142f, 0.10086326f, -0.11927302f, 0.01534077f, 0.04032076f, 
    0.03606319f, 0.00598260f, -0.01104495f, -0.06095960f, -0.04709459f, 0.04101455f, 0.02241862f, 0.01317672f, 
    -0.02254855f, -0.23800573f, -0.22635040f, -0.02431920f, -0.12272366f, -0.15747082f, 0.12723626f, 0.05339935f, 
    0.21058659f, -0.09985957f, 0.15301803f, 0.25003979f, -0.08328315f, -0.03894774f, -0.11276460f, 0.05836898f, 
    0.00811385f, 0.02600320f, -0.24336956f, -0.30915385f, -0.36727196f, 0.01852677f, 0.00996981f, -0.12094646f, 
    -0.09228146f, 0.01026759f, -0.07161368f, 0.16243353f, 0.04973031f, -0.05679593f, 0.01393457f, -0.01276204f, 
    -0.24701136f, 0.10388567f, 0.15089847f, 0.12410446f, 0.07724645f, -0.01047721f, -0.02141572f, 0.00611420f, 
    0.07085472f, -0.30682051f, -0.04875708f, 0.08369359f, -0.12709767f, -0.00358730f, 0.00675014f, -0.00086154f, 
    -0.05120652f, 0.09624350f, -0.07726552f, -0.05558711f, 0.09853290f, 0.05141916f, 0.13103999f, -0.12403567f, 
    -0.05948063f, -0.11095637f, 0.06427564f, -0.09773508f, 0.01204752f, -0.02784947f, -0.02236823f, -0.01939104f, 
    -0.22039402f, -0.24043503f, 0.12465528f, -0.11056947f, -0.16382435f, 0.07595517f, 0.07906095f, 0.05736615f, 
    0.00463518f, 0.08485112f, 0.20842034f, -0.11846797f, 0.16514029f, 0.13409707f, 0.05901999f, -0.02503746f, 
    0.00771872f, -0.08921036f, 0.13772036f, 0.16697654f, 0.04741054f, 0.06584840f, -0.08920258f, 0.13972525f, 
    0.12659006f, 0.00804548f, 0.07163490f, 0.00650949f, -0.16358890f, 0.19593705f, 0.13155870f, 0.06745972f, 
    0.03098874f, -0.00592076f, 0.03997277f, 0.00698471f, 0.04566239f, 0.19649798f, 0.23373774f, 0.21383151f, 
    -0.17423208f, -0.06597562f, 0.00199168f, 0.08590969f, 0.00286333f, 0.11451433f, -0.01445756f, 0.03464159f, 
    0.06651357f, -0.08373462f, -0.10094151f, 0.02337928f, -0.05815520f, 0.19919309f, -0.12507153f, -0.07040372f, 
    -0.15232550f, -0.21464323f, -0.19765447f, 0.16768247f, 0.12086021f, 0.09593695f, -0.11261930f, 0.16903439f, 
    -0.02054060f, -0.09029111f, -0.14676829f, -0.29377255f, -0.14059077f, 0.03194830f, 0.06943417f, 0.02384141f, 
    0.04330439f, -0.02805853f, 0.19416367f, -0.07642186f, 0.06372397f, 0.05867309f, 0.01257525f, 0.10931694f, 
    -0.01145528f, -0.08463428f, 0.16879310f, -0.10625760f, 0.09995959f, 0.11579428f, 0.10294428f, -0.00318890f, 
    0.11954000f, -0.20133995f, -0.06390093f, -0.09828274f, -0.02502074f, 0.05284417f, -0.01079974f, -0.14870073f, 
    -0.06600637f, -0.08304007f, -0.01481447f, 0.09267036f, -0.01906813f, -0.16188008f, -0.05722758f, -0.07361849f, 
    0.02517236f, 0.01667190f, 0.07102013f, -0.00397746f, 0.12649810f, 0.05195734f, 0.02536388f, 0.09611481f, 
    0.07837337f, -0.06565138f, -0.09190734f, 0.08824518f, -0.12707298f, 0.09538581f, 0.19960381f, -0.10943332f, 
    -0.13465181f, -0.25994161f, -0.00587874f, 0.09256857f, 0.01246663f, 0.00749866f, -0.00287105f, -0.01388761f, 
    -0.00596870f, -0.05250836f, 0.05670197f, 0.06907873f, -0.01902517f, 0.08329427f, 0.10219119f, 0.11776115f, 
    -0.01061498f, -0.05478675f, 0.17852756f, 0.25298819f, -0.08215870f, -0.02836329f, 0.22679310f, -0.17698726f, 
    -0.02284363f, -0.06959861f, -0.09810425f, -0.02997222f, -0.03128275f, 0.04875600f, 0.02984836f, 0.02647501f, 
    0.12402047f, 0.21072567f, 0.04364250f, -0.13209233f, 0.05888202f, -0.00157397f, -0.01554098f, -0.05079931f, 
    -0.16023944f, 0.05220494f, 0.13700148f, -0.03856065f, 0.05476543f, -0.24518912f, -0.04739395f, -0.01573152f, 
    0.07638318f, 0.06403508f, 0.11359249f, -0.06716640f, -0.03045458f, -0.15819302f, -0.09761304f, -0.28512946f, 
    0.11196143f, -0.03965833f, 0.09740072f, 0.02533523f, 0.05765846f, -0.06615894f, -0.01008654f, 0.07295569f, 
    -0.03792404f, 0.05784869f, 0.13447352f, 0.05402696f, -0.05859927f, -0.15604003f, 0.11451951f, 0.14227194f, 
    0.05792466f, -0.03647532f, -0.04341822f, -0.00109308f, 0.08653972f, 0.14517778f, 0.15400925f, 0.22142154f, 
    -0.13215174f, 0.06400408f, -0.09553050f, -0.09032533f, -0.04809035f, -0.03019487f, 0.00347226f, 0.00270486f, 
    0.03824163f, 0.08921164f, 0.12131421f, -0.00184213f, 0.18146953f, 0.16138507f, 0.13034938f, 0.11521306f, 
    -0.09538090f, 0.05427378f, -0.00111672f, 0.01068070f, -0.16149041f, 0.04511844f, 0.14129329f, 0.20239623f, 
    0.00671458f, 0.08141561f, 0.00116888f, -0.07597802f, 0.08634528f, 0.08078231f, -0.02289507f, -0.12279151f, 
    -0.00299043f, -0.05904640f, -0.26634979f, -0.20723155f, -0.15926611f, -0.07479395f, -0.03350350f, -0.04278888f, 
    -0.06049374f, -0.14152427f, 0.06124229f, 0.13944419f, -0.04947481f, 0.03293452f, 0.04948543f, 0.17636229f, 
    0.06101708f, -0.09310315f, -0.11027135f, -0.06226631f, -0.07052872f, 0.01992277f, -0.09251796f, -0.21009880f, 
    0.15972932f, 0.02479831f, -0.01437248f, -0.01512339f, -0.07559854f, -0.13557684f, -0.08503613f, -0.02740522f, 
    -0.06380019f, 0.14688046f, 0.14327136f, -0.01208736f, 0.17604364f, -0.11866726f, 0.05668133f, 0.04239498f, 
    0.05457777f, -0.22476238f, 0.02553670f, 0.00783367f, 0.02840617f, -0.10965662f, 0.04124130f, -0.00702692f, 
    0.12226287f, -0.06392849f, 0.13845031f, 0.09172984f, -0.06264801f, 0.10469989f, -0.04895673f, 0.00185440f, 
    0.16431607f, 0.14029004f, 0.01783806f, 0.01911419f, 0.09229422f, -0.02704006f, -0.04970455f, 0.11744325f, 
    -0.05250902f, -0.02002439f, -0.00012006f, 0.02501590f, 0.15437232f, 0.01619661f, 0.12386033f, -0.01261760f, 
    0.14332376f, -0.05066302f, -0.10820442f, 0.20750265f, -0.04489489f, -0.01985471f, 0.11602551f, -0.18100795f, 
    -0.12189803f, -0.03579397f, 0.08474762f, 0.13578101f, -0.00911645f, -0.16058448f, -0.00432823f, 0.10544454f, 
    -0.07153750f, 0.05140942f, 0.06614225f, -0.07183715f, -0.15881875f, -0.33523104f, -0.13077340f, 0.14676932f, 
    0.00232953f, 0.06898176f, 0.01529893f, 0.05093089f, -0.02592692f, 0.06933855f, -0.15260273f, 0.10418221f, 
    -0.02361921f, 0.28633493f, -0.00469376f, 0.03608936f, -0.07966559f, 0.04759235f, -0.02729489f, 0.03442439f, 
    -0.28532875f, -0.11311939f, 0.01583462f, 0.13324761f, -0.06246009f, -0.21592551f, -0.02247749f, -0.05560943f, 
    -0.07440536f, -0.29437751f, -0.08376350f, -0.35127556f, 0.06131851f, 0.04465319f, -0.14281130f, -0.06358876f, 
    -0.04158963f, -0.04143259f, -0.05298557f, 0.02690227f, -0.22845708f, -0.07953709f, 0.02550365f, 0.20332824f, 
    0.11764837f, -0.02991782f, 0.00025102f, 0.33220068f, 0.00754902f, -0.19355585f, 0.08628734f, 0.05328208f, 
    -0.18646061f, 0.09695727f, 0.08015821f, -0.15273419f, 0.12303457f, 0.10195822f, -0.00214792f, 0.03322170f, 
    0.00014839f, 0.16747282f, -0.06674675f, -0.04278049f, 0.06225482f, 0.10173362f, 0.21051781f, 0.01787541f, 
    -0.07696792f, -0.02829881f, -0.03230356f, -0.10999371f, 0.15168574f, 0.09670009f, -0.24171861f, -0.01249771f, 
    -0.14295517f, 0.11015092f, 0.09109323f, -0.04801768f, -0.09774603f, 0.08647165f, 0.08676720f, -0.26590195f, 
    -0.05079652f, -0.18317164f, 0.16482875f, 0.09617234f, -0.08452415f, -0.18371016f, -0.05427630f, -0.08685020f, 
    -0.11615732f, 0.00426363f, -0.03835207f, 0.05630311f, 0.05497401f, 0.07977147f, 0.00807789f, 0.10055456f, 
    0.15182766f, 0.05152491f, 0.00814809f, -0.15698846f, 0.14322659f, 0.12008686f, 0.17229781f, 0.06533335f, 
    0.02761563f, 0.04851946f, -0.09042980f, -0.16141906f, -0.25659329f, 0.10688218f, 0.07039928f, 0.04302021f, 
    -0.04168332f, 0.00466818f, -0.04622274f, -0.10612821f, 0.11365495f, 0.12971155f, -0.15386344f, -0.07319610f, 
    0.07927399f, -0.17515159f, 0.16306156f, 0.05005226f, 0.19952919f, -0.01737627f, 0.19668218f, 0.10912448f, 
    -0.00041494f, -0.00895984f, 0.02032268f, 0.08763768f, 0.09706745f, 0.23558579f, 0.04650741f, 0.08086643f, 
    0.12951794f, -0.07190187f, 0.04194295f, -0.02875240f, -0.04291712f, -0.05762399f, -0.19950938f, 0.01852216f, 
    -0.01155119f, 0.04891169f, 0.06901755f, -0.24759863f, 0.04637317f, -0.01691184f, -0.09821854f, 0.02485324f, 
    -0.13324848f, 0.09992804f, 0.04210592f, 0.03037648f, 0.08233532f, 0.01352110f, 0.23149523f, -0.10668503f, 
    0.20294195f, -0.00808705f, 0.09529091f, 0.14327180f, 0.03507217f, 0.01982618f, 0.02091397f, -0.08801597f, 
    0.02553501f, -0.11403602f, 0.03494862f, 0.06195208f, -0.07697356f, 0.05818862f, 0.10230091f, 0.20314182f, 
    0.02301650f, -0.04159013f, -0.10108294f, 0.14880869f, -0.20211539f, 0.18549664f, 0.03119154f, -0.25696367f, 
    -0.08865047f, 0.02624762f, 0.03726818f, 0.22796661f, 0.10825848f, -0.22057474f, 0.08987544f, -0.00575801f, 
    0.06708544f, -0.02311199f, -0.18948853f, 0.01587671f, 0.07519621f, 0.09133733f, 0.02956897f, 0.03810267f, 
    0.14390004f, 0.01642590f, 0.03228539f, -0.01921450f, -0.01881698f, 0.15649931f, -0.02829901f, -0.07394117f, 
    0.01180306f, -0.11994471f, -0.14356212f, 0.08064094f, -0.01797297f, -0.06370089f, -0.02627437f, 0.05296974f, 
    0.10486857f, -0.05527993f, -0.05065014f, -0.06397708f, -0.06867106f, -0.20578076f, -0.08411304f, -0.30449140f, 
    0.21976618f, 0.16166395f, -0.04390105f, -0.00321169f, 0.04451245f, -0.17955068f, -0.08492064f, -0.03595664f, 
    0.09095361f, -0.27464461f, -0.19141439f, 0.07359260f, 0.02195409f, -0.09418846f, -0.02109756f, -0.05116592f, 
    0.05593239f, -0.07091045f, -0.06996988f, -0.07288525f, -0.00743206f, -0.04672378f, -0.12113754f, -0.02979038f, 
    0.15546064f, 0.07526834f, 0.10831158f, 0.17330644f, -0.07151350f, 0.19355108f, 0.08105519f, 0.18843618f, 
    -0.05184121f, -0.11010592f, -0.10483713f, -0.11991771f, 0.12964521f, 0.07079996f, 0.14569871f, 0.05429585f, 
    0.09825095f, 0.01256810f, -0.19954376f, -0.16260915f, 0.11573780f, 0.05249286f, 0.04959277f, -0.05108797f, 
    -0.09759008f, -0.04712610f, -0.00484350f, 0.03627799f, 0.02319717f, 0.20206024f, 0.14437093f, -0.04985457f, 
    -0.08317439f, 0.03097823f, 0.09937663f, -0.10625000f, -0.08815435f, -0.28443125f, -0.37708026f, -0.11562552f, 
    0.03814052f, -0.00413678f, 0.07888339f, 0.06609011f, 0.13953641f, 0.06646347f, -0.07715695f, 0.27122751f, 
    -0.23340255f, 0.10474819f, 0.09240308f, 0.18019612f, -0.02312392f, 0.04752536f, 0.09712725f, -0.03550909f, 
    -0.00630287f, 0.19369173f, -0.04937328f, -0.08155622f, -0.06461298f, -0.12088835f, -0.14985503f, -0.15537697f, 
    -0.00998766f, -0.08554271f, 0.13534482f, 0.12935527f, -0.05950974f, -0.20519172f, -0.02727213f, 0.06346806f, 
    0.06146728f, -0.02952899f, -0.38479471f, -0.21991374f, -0.06052599f, -0.00733055f, -0.04173797f, 0.02020629f, 
    0.01515413f, 0.09180307f, -0.01948136f, -0.08489030f, -0.00660282f, -0.12628852f, 0.01545781f, -0.02396117f, 
    0.15003969f, -0.01699458f, -0.08239734f, 0.18000577f, 0.20067655f, -0.11339662f, -0.00495209f, -0.02867675f, 
    0.02110991f, -0.09369768f, 0.05696795f, 0.10662249f, -0.01738395f, 0.00635469f, -0.12513481f, 0.13098511f, 
    -0.04337344f, 0.16108009f, -0.12611613f, 0.09809390f, 0.03977134f, 0.13202158f, -0.24667419f, -0.04072364f, 
    -0.05866918f, -0.09860126f, 0.03847907f, 0.25553659f, 0.04855008f, 0.05770952f, -0.15921198f, -0.11222532f, 
    0.17577058f, 0.17852280f, -0.03444763f, -0.08543231f, 0.01444596f, 0.04406601f, 0.15249467f, -0.05966067f, 
    -0.32822895f, 0.19188224f, 0.06402250f, -0.07509717f, 0.09496499f, 0.16389169f, -0.09811276f, 0.09782964f, 
    0.03353063f, 0.30221042f, 0.10571663f, -0.05806758f, -0.02226671f, -0.19870436f, -0.11819208f, 0.07503854f, 
    0.03282446f, 0.07902683f, -0.00495737f, 0.08361870f, -0.15502813f, 0.07461862f, -0.10870408f, -0.04319516f, 
    0.04517053f, -0.04311815f, 0.04105536f, 0.14231750f, 0.05955983f, -0.31363815f, -0.11496881f, 0.20467643f, 
    0.07182672f, 0.21858458f, 0.15841420f, 0.05716877f, 0.01725440f, 0.34383145f, 0.36491987f, -0.05822864f, 
    -0.11271934f, -0.01939933f, 0.05731839f, 0.19253431f, -0.06254368f, 0.08444846f, 0.15641093f, 0.19354668f, 
    -0.07851399f, 0.09815561f, -0.14911090f, 0.07637132f, 0.03339393f, 0.00723549f, -0.32456762f, 0.15973647f, 
    0.27858335f, 0.00499831f, -0.13766894f, -0.02057648f, -0.00053793f, 0.12881298f, 0.05959572f, 0.11005154f, 
    0.03882137f, -0.11354215f, 0.15559295f, -0.03189482f, -0.05779020f, 0.07802067f, 0.06889419f, -0.16455327f, 
    -0.02294113f, 0.17497225f, 0.15845953f, -0.10463683f, -0.26166460f, 0.05102267f, 0.02053034f, 0.01697832f, 
    -0.02003639f, -0.19751130f, 0.21139829f, 0.09321278f, -0.07051726f, -0.03252831f, -0.05865274f, -0.21253097f, 
    0.18506342f, -0.05358758f, 0.18864927f, 0.14699528f, -0.02271392f, -0.17375812f, 0.05616141f, -0.09340248f, 
    0.04207496f, -0.03311644f, -0.12812874f, 0.11086337f, -0.22654416f, -0.37848693f, -0.13932678f, -0.04968483f, 
    -0.15303954f, 0.09020774f, 0.05081807f, -0.11631616f, -0.12957397f, 0.04254635f, 0.10054591f, 0.09747011f, 
    0.08477271f, 0.15167573f, 0.10666361f, -0.03816820f, 0.03089543f, -0.30406934f, -0.03639143f, 0.06732569f, 
    -0.14982899f, 0.06565694f, 0.18944056f, -0.04647354f, 0.09736206f, -0.04160649f, -0.16650327f, -0.03743548f, 
    -0.29310539f, -0.02131294f, -0.04262662f, -0.00607853f, 0.05759927f, 0.06895115f, 0.02689918f, 0.04905123f, 
    0.13923846f, -0.16083618f, -0.04318579f, 0.00353133f, 0.00942570f, -0.05363781f, 0.09916972f, 0.08665369f, 
    -0.20240566f, 0.18572448f, -0.11252327f, 0.07605637f, -0.10781249f, -0.08114310f, 0.06184803f, -0.01764637f, 
    0.07153919f, 0.07784489f, 0.08004926f, -0.10394984f, -0.05471513f, 0.03316836f, 0.01354899f, 0.04130244f, 
    0.02094277f, -0.00991089f, 0.11618638f, 0.06037645f, 0.15109485f, -0.10769248f, -0.01968992f, -0.25512442f, 
    -0.09531828f, 0.05099499f, -0.14744416f, -0.11389632f, -0.19696420f, 0.16990805f, -0.17559236f, 0.03336920f, 
    0.21378301f, -0.03354234f, 0.04322879f, 0.10198694f, 0.06683019f, 0.03301483f, 0.09402795f, -0.01555142f, 
    -0.10095816f, 0.08889197f, 0.08445942f, 0.05468076f, -0.11431593f, -0.04120173f, 0.01962456f, 0.14503257f, 
    -0.01505435f, 0.08059845f, -0.04652017f, 0.08989483f, -0.11892093f, -0.07348190f, -0.25278285f, 0.01726992f, 
    0.11550172f, -0.04511521f, 0.04994898f, -0.16454740f, 0.05838532f, 0.13428286f, 0.04399396f, -0.43232194f, 
    0.38455135f, -0.10971852f, -0.01475888f, -0.13157304f, -0.08545681f, 0.05620568f, 0.05329730f, -0.02862765f, 
    -0.01826573f, 0.03901948f, 0.19324295f, -0.07147008f, -0.03700244f, -0.19836423f, -0.03636544f, 0.19240549f, 
    0.08994233f, 0.23336709f, 0.08193253f, 0.16008088f, -0.05206558f, -0.17024323f, 0.00496351f, -0.04622330f, 
    0.17458384f, -0.05114856f, -0.04701532f, -0.07529047f, 0.12674382f, 0.10260285f, -0.00162479f, 0.09224223f, 
    -0.09184759f, -0.03671834f, -0.05338520f, 0.07341830f, 0.10074683f, 0.17062341f, -0.07364348f, -0.09198581f, 
    -0.06809649f, -0.11113392f, 0.02453034f, 0.14906766f, 0.04337112f, -0.03166466f, 0.19508632f, -0.22307251f, 
    -0.14515859f, -0.23719391f, -0.02688641f, -0.04578601f, -0.08716540f, -0.17806210f, -0.09465533f, 0.01371656f, 
    -0.03069995f, 0.04291316f, -0.26771307f, -0.03116999f, -0.14106362f, -0.07574539f, 0.15182199f, -0.09023748f, 
    0.00593058f, 0.06092636f, 0.04937211f, 0.11711981f, 0.05081836f, 0.12074600f, -0.18301822f, 0.20557579f, 
    0.10007730f, 0.09209438f, 0.00382503f, 0.02037574f, -0.04136410f, 0.05152800f, 0.07073063f, -0.09694464f, 
    0.15318230f, 0.23768063f, -0.05915151f, 0.12485196f, 0.01953624f, -0.06339533f, -0.07065149f, -0.01393090f, 
    -0.05689926f, -0.05844830f, -0.17081818f, 0.04620067f, -0.01178234f, 0.10554459f, -0.21031894f, 0.02012851f, 
    0.11877739f, 0.09205873f, 0.18468548f, 0.06990591f, -0.01214922f, 0.20504202f, -0.13220245f, 0.01555313f, 
    0.10070769f, -0.11784285f, 0.04471144f, -0.18589780f, -0.09057271f, 0.01134701f, 0.01823469f, -0.07638873f, 
    0.03534376f, 0.08833896f, -0.13703039f, -0.22718467f, -0.28878012f, 0.00135155f, 0.16461858f, -0.21585158f, 
    -0.12975162f, 0.01008343f, 0.03375537f, 0.04807100f, 0.11088727f, -0.12143996f, 0.05464436f, 0.06080071f, 
    -0.17993906f, -0.10017700f, -0.28373656f, -0.04550407f, -0.00777080f, 0.05393737f, -0.00859371f, -0.05857477f, 
    0.42112088f, 0.02201705f, -0.06816206f, 0.08033928f, -0.03389524f, 0.03256624f, 0.11559458f, -0.45166102f, 
    -0.25374609f, 0.13414943f, -0.01489351f, 0.04458893f, -0.20552126f, 0.01581369f, 0.00299859f, -0.11340965f, 
    0.07755551f, -0.08039758f, -0.02480862f, -0.11013311f, -0.27996427f, -0.08962426f, 0.08282767f, 0.03418785f, 
    0.14458004f, 0.16212513f, 0.04194989f, 0.20414144f, 0.16923706f, -0.18205650f, 0.03933072f, 0.02247089f, 
    0.06285879f, 0.06541032f, -0.05692490f, 0.12655821f, 0.19842808f, -0.03698015f, -0.00337853f, -0.04689481f, 
    -0.06201677f, 0.00497640f, -0.04357594f, 0.25863782f, 0.02040506f, -0.04922815f, -0.13140085f, 0.21752411f, 
    -0.10131976f, 0.00371582f, 0.12339890f, 0.07220444f, -0.03098574f, 0.04609305f, 0.09586703f, 0.15704177f, 
    0.00519542f, -0.13618563f, -0.04825361f, -0.01973300f, -0.23502675f, -0.26782209f, 0.17608272f, 0.06444580f, 
    -0.11249346f, -0.02217340f, 0.02158712f, -0.09005017f, 0.16983071f, -0.04599657f, -0.14855087f, 0.03807921f, 
    0.13918491f, -0.06609326f, 0.06235368f, -0.02543536f, -0.00810970f, -0.12198413f, -0.08697508f, -0.31515899f, 
    0.06528050f, -0.12893081f, 0.02754318f, 0.01288872f, 0.03363918f, 0.05646706f, 0.09204036f, 0.10457370f, 
    -0.05714704f, 0.22634189f, -0.04749531f, 0.11607843f, 0.02569526f, -0.08835734f, 0.07401817f, -0.01433292f, 
    -0.02519351f, -0.17320059f, 0.09118366f, 0.04281928f, -0.03380325f, -0.12401793f, 0.13816653f, 0.04737071f, 
    -0.11785277f, -0.17234406f, -0.13740796f, -0.01846587f, 0.25371701f, -0.22616969f, 0.04576733f, -0.27127516f, 
    -0.06399205f, 0.20056698f, 0.07228024f, -0.19544846f, -0.44464687f, 0.49351498f, -0.05133442f, -0.04054011f, 
    0.37823203f, -0.06427018f, 0.03064074f, 0.04690133f, -0.25994402f, -0.02123147f, 0.09919808f, -0.03814805f, 
    0.02121093f, -0.10318366f, 0.10035332f, -0.07359673f, -0.13151775f, 0.06788646f, -0.14393611f, -0.10617516f, 
    -0.10493618f, -0.00033618f, 0.02137361f, 0.09501557f, 0.18521637f, 0.13025555f, 0.36769739f, 0.23812671f, 
    -0.08698448f, 0.23635772f, -0.04829096f, -0.07190782f, 0.00109538f, -0.01893513f, -0.03209339f, -0.30303019f, 
    0.32459459f, -0.26025864f, -0.00082512f, -0.20232001f, 0.02809343f, 0.02125648f, 0.03105868f, 0.00306759f, 
    -0.02716346f, -0.00027375f, -0.01714933f, -0.04471412f, -0.05271040f, 0.02400279f, -0.00059542f, -0.03763583f, 
    -0.04515624f, -0.04590607f, -0.06290366f, 0.00361106f, 0.00174217f, 0.02529728f, 0.02895621f, 0.02242996f, 
    0.03750835f, -0.03089517f, 0.02088338f, 0.03171184f, -0.03305625f, -0.01636199f, -0.06137661f, 0.04736026f, 
    -0.06347531f, 0.03567700f, -0.02314472f, 0.00881963f, 0.03401966f, 0.01531579f, 0.02528687f, -0.01017199f, 
    -0.04930959f, 0.01977585f, 0.01567073f, 0.00501892f, -0.02246267f, -0.06657681f, 0.02642779f, -0.01133501f, 
    -0.06179442f, 0.01017658f, 0.04311308f, -0.06219337f, 0.04714923f, -0.06231963f, -0.03885829f, 0.03519817f, 
    0.04746206f, 0.02030245f, -0.03940471f, -0.05673487f, 0.04478810f, -0.04316405f, -0.01117797f, -0.00928262f, 
    -0.03687049f, -0.05081807f, 0.01440322f, 0.04267503f, -0.03567427f, -0.02601705f, -0.04809732f, 0.02841727f, 
    -0.02455425f, -0.02000784f, -0.03202705f, -0.00478046f, -0.03278456f, 0.03994335f, -0.01471778f, 0.00840701f, 
    0.03555449f, 0.03392261f, 0.01991580f, -0.04083414f, -0.03268039f, 0.01492940f, -0.02975921f, -0.00708735f, 
    0.04621937f, 0.01351478f, -0.01888700f, -0.06334548f, -0.02970152f, -0.02442101f, -0.05287439f, 0.03145529f, 
    -0.04676130f, -0.07543632f, -0.06486208f, -0.02229797f, 0.03988117f, -0.02026126f, -0.00604567f, 0.03423689f, 
    -0.01953138f, -0.03485676f, 0.04606028f, -0.02552870f, 0.01320356f, 0.02590109f, -0.06572996f, -0.01073706f, 
    -0.04435059f, -0.05641542f, -0.03357723f, 0.00454729f, 0.00377705f, 0.01321331f, 0.04175418f, -0.02745119f, 
    0.00955994f, -0.02988810f, -0.04052208f, -0.01805939f, 0.00997837f, -0.00424209f, -0.06403328f, 0.02744685f, 
    -0.03406701f, 0.02334518f, -0.04711412f, -0.07069737f, 0.01477725f, 0.03193733f, -0.00934384f, -0.02682098f, 
    -0.03258774f, 0.01177001f, -0.00655837f, 0.01425127f, -0.01605314f, -0.05780515f, -0.03460810f, 0.01706867f, 
    -0.04560349f, -0.01639699f, -0.05671563f, 0.01234788f, -0.04843865f, 0.00403995f, -0.02295854f, 0.00098842f, 
    0.01112384f, -0.03922605f, 0.02182505f, 0.00097603f, -0.00892702f, -0.01308465f, -0.03775593f, 0.03412334f, 
    -0.04842320f, -0.04557209f, 0.05750927f, -0.03132502f, -0.02660347f, -0.03648137f, -0.00601514f, -0.00955411f, 
    0.00474195f, -0.02173775f, 0.01718976f, 0.02335387f, -0.06235714f, -0.06826112f, 0.03535027f, 0.03943350f, 
    0.02015072f, -0.04309811f, -0.03595293f, 0.00426340f, 0.01529664f, 0.01841020f, 0.01806643f, 0.02825741f, 
    -0.03293717f, -0.01303923f, 0.00254360f, -0.01598733f, 0.01742060f, -0.00898112f, 0.01373678f, -0.06245496f, 
    -0.03391977f, -0.02877768f, -0.00595779f, -0.01275139f, 0.03179052f, -0.03274158f, 0.01878198f, -0.01213729f, 
    -0.04943171f, 0.00096011f, -0.02881395f, 0.03241620f, -0.00388141f, 0.02718175f, 0.02538770f, 0.01479707f, 
    -0.05914928f, -0.03027987f, 0.00471434f, 0.02246391f, -0.02414718f, -0.04147477f, -0.03343005f, -0.01150201f, 
    0.01546101f, -0.01176144f, 0.03388215f, 0.01524347f, -0.04950002f, -0.03323429f, -0.04299889f, -0.02140397f, 
    0.03237801f, -0.01720556f, 0.04996540f, 0.03008123f, -0.00730191f, 0.01856293f, -0.05802392f, -0.01196119f, 
    -0.01108356f, 0.05061858f, -0.02490105f, 0.02444201f, 0.01706942f, -0.01625401f, 0.02509679f, 0.01916273f, 
    -0.01952350f, 0.00290789f, -0.07282549f, 0.04425577f, -0.02120915f, 0.02032127f, -0.06701442f, 0.01272393f, 
    -0.01197113f, -0.00507654f, 0.04519808f, -0.06767079f, -0.01457415f, -0.00342200f, 0.03131305f, 0.00853685f, 
    -0.01395780f, 0.02086038f, -0.01729185f, 0.00067804f, -0.02919831f, 0.02175111f, -0.00802010f, 0.04087507f, 
    -0.05567054f, 0.01633083f, -0.04235408f, -0.01272352f, 0.00121456f, -0.00283038f, 0.04176039f, 0.03519650f, 
    0.02702816f, -0.04549558f, -0.02429669f, -0.05127689f, 0.04154468f, -0.02827681f, -0.03868122f, -0.03973113f, 
    0.02165100f, 0.01098298f, -0.06081910f, -0.04058167f, 0.00388245f, 0.01815836f, 0.03460734f, 0.04300909f, 
    0.00134099f, -0.03562677f, 0.01332257f, 0.01216955f, -0.06137781f, -0.02875551f, -0.01976371f, 0.00539731f, 
    0.22441077f, 0.05638425f, 0.04969873f, -0.30406135f, -0.17617823f, -0.03859297f, 0.09241287f, 0.16249830f, 
    -0.03763203f, -0.09246678f, -0.05448180f, -0.12227066f, 0.16664705f, -0.00967656f, -0.10056541f, 0.02397435f, 
    0.03223575f, 0.03302690f, 0.13049921f, -0.07363338f, -0.30910957f, -0.06346187f, 0.05590378f, -0.14672235f, 
    0.08208477f, 0.05648118f, -0.00825766f, -0.06064358f, 0.11773981f, -0.17865875f, -0.04031118f, 0.25977477f, 
    0.20880027f, 0.05062318f, 0.21175064f, 0.05061825f, -0.39462513f, 0.35305303f, -0.18583092f, 0.11581764f, 
    -0.09044354f, 0.05821587f, 0.05952918f, 0.02464572f, 0.02559037f, -0.18329135f, -0.42337906f, 0.29559696f, 
    0.11530839f, -0.01265450f, -0.13802424f, 0.03065540f, -0.03032579f, 0.09626407f, -0.11553998f, -0.05777605f, 
    -0.04114140f, 0.08508518f, 0.08605802f, -0.11152202f, 0.00263155f, -0.03920812f, -0.04477884f, -0.01917190f, 
    0.10995112f, -0.05687410f, 0.08152045f, -0.16225736f, -0.14391908f, 0.08232586f, 0.05714485f, 0.01756576f, 
    -0.00711847f, -0.04085114f, -0.21323828f, 0.07970138f, 0.08792637f, -0.10129116f, 0.07353751f, 0.07966855f, 
    -0.08301014f, -0.14194188f, 0.37497690f, 0.14197698f, 0.08357504f, -0.20823857f, 0.12306925f, 0.01952052f, 
    0.11269114f, 0.05574410f, 0.03325066f, 0.01013388f, -0.01526965f, -0.04000558f, 0.01020336f, 0.02657274f, 
    0.05378069f, 0.06763334f, 0.05007210f, 0.06336427f, -0.08775534f, -0.18844408f, -0.05469127f, -0.03233111f, 
    0.05396769f, -0.02204898f, 0.04001425f, -0.05840277f, -0.43396521f, -0.43281946f, 0.01209540f, -0.28653672f, 
    0.05399743f, -0.11921687f, -0.15786533f, 0.00614071f, -0.01224604f, -0.27670676f, -0.27051902f, 0.06720255f, 
    -0.16717137f, -0.05404545f, -0.14887844f, -0.03592911f, -0.06185912f, 0.05587147f, -0.01038775f, 0.16511847f, 
    -0.22418831f, 0.06239901f, 0.04059076f, 0.01618507f, 0.11429271f, -0.01961303f, 0.01464519f, -0.03828479f, 
    -0.19041628f, -0.14964841f, -0.20173933f, -0.02730595f, -0.03013403f, 0.02585405f, -0.07280705f, 0.01204144f, 
    -0.42449483f, 0.30518624f, -0.29013953f, -0.22460344f, -0.08232442f, -0.11088350f, -0.07558369f, 0.05054581f, 
    -0.03357232f, -0.10455345f, 0.13028166f, -0.16444667f, 0.04707279f, 0.10229457f, -0.02508375f, -0.01313442f, 
    -0.05354253f, -0.06134887f, 0.17029762f, 0.08361040f, -0.04046252f, -0.21457063f, -0.35179543f, -0.09501194f, 
    0.13189290f, 0.02274287f, -0.03175693f, -0.06476933f, 0.03509847f, -0.18250012f, 0.00947911f, -0.11607153f, 
    0.12589885f, 0.02308059f, 0.02743827f, -0.05452932f, -0.05632348f, 0.02665021f, -0.12476841f, 0.03860781f, 
    0.04855202f, 0.00738330f, -0.07220580f, 0.00466784f, -0.05766701f, 0.08002910f, -0.05731218f, 0.02897321f, 
    0.07901642f, 0.21126291f, -0.01260233f, -0.06167029f, 0.03172603f, 0.09156439f, 0.18606427f, -0.02549436f, 
    0.23158379f, 0.02216822f, -0.09073918f, -0.09135740f, 0.22137469f, 0.25115272f, 0.13328439f, 0.02761543f, 
    0.12915149f, 0.11133390f, 0.02116649f, -0.12376065f, -0.02284945f, -0.00592723f, 0.17842801f, 0.00196819f, 
    -0.02027242f, -0.14668459f, 0.02504749f, 0.02337611f, 0.08608597f, -0.21733963f, -0.00029363f, 0.12599689f, 
    0.04283438f, 0.20558909f, -0.05107442f, -0.00631882f, -0.17833778f, 0.00873392f, 0.06277443f, -0.07205322f, 
    0.11434296f, 0.06410797f, -0.42485815f, 0.12034823f, -0.11015616f, -0.04158587f, -0.12678026f, -0.00654156f, 
    0.04675914f, 0.05751357f, -0.07635252f, -0.02354621f, 0.25002933f, -0.88398325f, -0.21092571f, 0.16893160f, 
    -0.10035051f, -0.05918064f, 0.12068356f, -0.19920395f, 0.14963664f, 0.17899619f, -0.27338979f, -0.05002390f, 
    0.03289702f, 0.05945457f, 0.00966896f, 0.01100964f, -0.11765514f, -0.43170583f, -0.27425817f, -0.01770526f, 
    -0.01295490f, 0.12490370f, 0.04689005f, 0.04123629f, 0.08621186f, 0.14484830f, -0.12607467f, -0.06733327f, 
    0.01587978f, 0.06846125f, 0.05549640f, -0.07458948f, 0.19399092f, -0.01237031f, 0.06038156f, -0.10121769f, 
    -0.32723182f, 0.09365126f, -0.02100029f, 0.07674579f, -0.15558550f, -0.09572414f, 0.05582168f, 0.04707719f, 
    0.05331942f, -0.03421950f, -0.12817229f, -0.26972136f, -0.18621223f, -0.00059750f, 0.00876178f, -0.07393517f, 
    0.14466545f, -0.19805115f, -0.15799452f, -0.26434243f, 0.00327887f, 0.03710838f, 0.04615474f, 0.00330028f, 
    -0.08915645f, 0.14611422f, 0.05721553f, -0.30188823f, -0.36443281f, -0.04653500f, 0.03149700f, -0.02899898f, 
    0.01083192f, 0.00088847f, 0.06766081f, -0.00870455f, -0.19774510f, 0.00012244f, -0.00734984f, -0.18864578f, 
    0.26079583f, 0.13047694f, -0.05823186f, 0.06017900f, 0.21219587f, 0.22114450f, 0.26056632f, -0.07587275f, 
    -0.06121799f, -0.01982351f, 0.07268526f, 0.00624797f, 0.14213954f, -0.00239941f, 0.06746984f, 0.12762445f, 
    -0.02093740f, -0.05063346f, 0.03974050f, -0.04045181f, 0.16679712f, -0.00997968f, -0.23866685f, -0.38391218f, 
    -0.37272596f, -0.07313139f, -0.06575017f, 0.09129600f, -0.00171307f, 0.08788636f, -0.02122658f, -0.00742692f, 
    0.14995144f, -0.15278029f, 0.17897512f, -0.10236989f, 0.12607221f, -0.02526462f, -0.01360816f, -0.03613314f, 
    -0.04039552f, -0.25734386f, -0.15355189f, -0.00583568f, 0.03652397f, -0.04363230f, -0.01318072f, 0.11837992f, 
    -0.02233507f, -0.06831320f, 0.05863994f, 0.00186001f, -0.05226667f, -0.09210988f, -0.03292029f, 0.05783001f, 
    -0.08768225f, 0.13439390f, 0.07736848f, -0.18421155f, -0.15822665f, 0.20634007f, 0.04485875f, 0.14372043f, 
    0.20078704f, -0.07736109f, 0.14332691f, 0.01892221f, 0.03456744f, -0.24248184f, -0.08163185f, -0.10011347f, 
    0.11182844f, 0.05578663f, 0.17977397f, -0.04512141f, 0.05140405f, 0.26896155f, 0.12917262f, -0.09001131f, 
    0.10932421f, 0.11251488f, -0.13685665f, 0.10074753f, -0.00516202f, 0.11263428f, 0.23546599f, 0.19168507f, 
    -0.10186597f, -0.06249101f, 0.09632159f, -0.04816727f, 0.05042635f, -0.01094433f, -0.05705865f, -0.47395045f, 
    -0.32661578f, -0.19149080f, 0.03174874f, -0.05879270f, -0.16878366f, 0.11149214f, -0.14317988f, -0.05438010f, 
    -0.05958715f, 0.26656353f, 0.12574115f, -0.04279999f, 0.15293306f, 0.00536521f, 0.13918589f, 0.13940832f, 
    0.11768196f, 0.20817606f, 0.08859438f, 0.03377781f, 0.00095261f, -0.03862829f, -0.04674949f, -0.03700195f, 
    -0.05879225f, 0.13130215f, -0.11341489f, -0.37078276f, 0.11010706f, 0.06874836f, -0.19320934f, 0.03071089f, 
    0.04906163f, 0.12058070f, 0.00425474f, -0.04565663f, -0.04489380f, -0.16909800f, 0.06987346f, -0.10356639f, 
    0.15343069f, 0.00460910f, -0.11054926f, -0.03644658f, -0.06118950f, 0.13898100f, -0.06559224f, 0.07343739f, 
    0.03366653f, 0.12054373f, 0.01744614f, 0.04013387f, 0.07051516f, 0.09099074f, -0.10353968f, 0.01296060f, 
    0.08215661f, -0.01790542f, 0.08981051f, 0.19403942f, 0.03794308f, -0.00569798f, -0.06211863f, 0.04444446f, 
    -0.09767146f, 0.03807706f, 0.04080972f, -0.06965947f, 0.03393390f, 0.04109320f, -0.89099330f, -0.61325228f, 
    -0.19864361f, -0.10101838f, -0.05870711f, -0.11418437f, 0.16803911f, -0.01139508f, -0.00786772f, -0.33843252f, 
    -0.20189825f, 0.07589076f, -0.07051256f, -0.06072958f, -0.04367313f, -0.05619420f, -0.05075220f, -0.08215547f, 
    -0.25844604f, -0.18513966f, -0.09042706f, -0.08118456f, -0.03145314f, -0.15312923f, 0.05873421f, -0.05602575f, 
    0.18444967f, -0.06175166f, -0.15450293f, -0.30447158f, -0.03182427f, -0.14645667f, -0.11955721f, 0.23648816f, 
    -0.13793686f, -0.00481112f, -0.05376314f, 0.04293017f, 0.12071174f, 0.08428682f, 0.12130139f, -0.13866022f, 
    0.05798293f, -0.08383679f, -0.13354613f, 0.24881555f, -0.07705596f, -0.15487936f, 0.06943317f, -0.00702284f, 
    0.00896931f, -0.12247194f, 0.05567319f, -0.08084999f, 0.20732206f, 0.09677546f, 0.12517498f, 0.03739334f, 
    -0.03662477f, 0.05499403f, -0.01239521f, 0.05871414f, -0.00186163f, 0.02591536f, -0.01540892f, 0.08798352f, 
    0.07057013f, 0.08145633f, -0.07379047f, 0.07152136f, 0.00899908f, 0.00503934f, -0.04819612f, -0.60179377f, 
    -0.49329960f, 0.03394382f, -0.02993309f, 0.04030159f, 0.04769159f, 0.10359854f, 0.07202790f, -0.58793151f, 
    -0.29186127f, 0.01198368f, 0.03639665f, 0.04929567f, -0.04132738f, 0.03341455f, 0.01857303f, -0.04822201f, 
    -0.39146045f, -0.06882314f, 0.02761896f, -0.23316284f, -0.23155670f, -0.08394860f, 0.03333649f, -0.03518263f, 
    0.02229001f, 0.10166579f, -0.16452459f, 0.04261965f, 0.00526951f, -0.04751017f, -0.08011805f, 0.01888252f, 
    0.08067058f, 0.12387988f, 0.13121882f, -0.21384689f, -0.44776440f, -0.06194146f, -0.08860873f, 0.16752328f, 
    0.05046758f, 0.06365985f, 0.07696199f, 0.52131432f, -0.36393014f, -0.03611006f, -0.17611964f, 0.06114228f, 
    0.01588658f, 0.17263365f, 0.06363517f, 0.05252248f, 0.05464111f, 0.05848321f, 0.22458805f, -0.04024322f, 
    0.05857201f, 0.11934754f, 0.04438823f, -0.11444585f, 0.06755757f, 0.04156813f, 0.13703321f, 0.26666763f, 
    -0.02860582f, 0.01537328f, -0.15118900f, -0.12452891f, 0.03054925f, 0.05474526f, 0.16333899f, -0.21991387f, 
    -0.35303295f, -0.15857254f, 0.07056511f, -0.03817758f, 0.00169526f, 0.00313419f, 0.07537379f, -0.16771641f, 
    -0.17670245f, 0.07922629f, 0.08839523f, -0.07501357f, 0.02802726f, 0.03205825f, -0.12945002f, 0.05704733f, 
    0.06958652f, 0.02778384f, -0.02744859f, -0.08480990f, 0.08603494f, -0.21939611f, 0.11613096f, -0.09337381f, 
    0.15276349f, 0.15813202f, -0.24657765f, -0.16467458f, 0.03490601f, -0.02790168f, 0.15271503f, 0.16541581f, 
    0.14226590f, 0.08352144f, -0.23416270f, -0.14406899f, -0.22068810f, 0.11531933f, -0.04678168f, 0.01788487f, 
    0.21109807f, -0.03681775f, -0.00316427f, -0.04984282f, -0.24859957f, -0.03555999f, -0.01790694f, -0.01467591f, 
    -0.11799868f, -0.00590440f, 0.21554527f, -0.32971525f, -0.11732502f, -0.00854779f, 0.01628646f, -0.02503193f, 
    0.13935255f, -0.17583589f, 0.08055726f, 0.01033103f, 0.03234847f, 0.11445270f, 0.06919128f, 0.18379234f, 
    -0.17621182f, 0.03947952f, -0.09814430f, -0.01576806f, -0.01677931f, 0.14202575f, 0.18729393f, -0.33254588f, 
    0.07369213f, -0.04200387f, -0.03410678f, 0.00651152f, -0.05554531f, 0.11607149f, -0.07821781f, -0.42509624f, 
    -0.22033769f, 0.10582966f, -0.09109792f, -0.06903172f, 0.13263670f, 0.08999400f, 0.11325606f, 0.07408148f, 
    -0.05666429f, 0.07515123f, 0.08366947f, -0.02841721f, 0.16292781f, 0.10684679f, 0.01398363f, -0.05233092f, 
    -0.01336455f, 0.08242287f, -0.04708428f, -0.46672842f, 0.02045383f, -0.10673255f, -0.06004593f, 0.05704796f, 
    0.08953866f, -0.04288589f, -0.29900095f, -0.33633375f, -0.34584963f, 0.05473509f, -0.06535170f, 0.11228207f, 
    -0.05196538f, 0.05949899f, 0.03204435f, 0.21367753f, -0.08245424f, 0.12189238f, -0.00379102f, 0.01388958f, 
    0.09680776f, 0.19007540f, 0.03743783f, 0.18602000f, 0.18247385f, 0.19051750f, 0.13429652f, -0.11433039f, 
    0.03428193f, -0.20004448f, 0.01949340f, -0.03442112f, -0.02702362f, -0.03404297f, 0.01475066f, 0.16294752f, 
    0.02497831f, 0.14873284f, 0.06160749f, 0.13779885f, 0.09909870f, -0.08053820f, -0.47640365f, -0.08438654f, 
    0.04253657f, 0.04103777f, -0.03868941f, -0.03193080f, 0.12238071f, 0.07273613f, -0.08001681f, -0.44324490f, 
    -0.03738952f, 0.14028139f, -0.01118517f, 0.05160301f, -0.06601452f, -0.04845618f, 0.05956743f, -0.06191977f, 
    0.15756723f, -0.24322741f, -0.14743336f, -0.07597572f, 0.05805065f, -0.08990684f, 0.10375126f, 0.09268410f, 
    0.03013564f, -0.46344516f, -0.31431526f, -0.32352686f, 0.09710915f, -0.13992485f, -0.03873648f, 0.02170052f, 
    -0.02826989f, 0.02199867f, -0.04212090f, 0.06958064f, -0.00764818f, -0.09530000f, 0.14259866f, 0.10063115f, 
    0.05880586f, 0.03089894f, 0.03627673f, 0.34476900f, 0.15980960f, -0.01610695f, -0.06189727f, -0.12982793f, 
    0.03108400f, 0.17419195f, -0.01032362f, -0.16558318f, 0.14661723f, 0.02024786f, 0.07428434f, 0.00706463f, 
    0.02545973f, -0.00299925f, -0.00020356f, 0.00817593f, 0.01000147f, -0.20157412f, 0.20033143f, 0.16141590f, 
    0.04682667f, -0.00003611f, 0.04957782f, 0.08175116f, 0.11209532f, -0.06562588f, -0.06580214f, -0.27196771f, 
    -0.13926651f, 0.05506026f, -0.11113998f, -0.10270216f, -0.02458805f, 0.08489496f, 0.04173918f, -0.28065360f, 
    -0.35795823f, 0.11032996f, 0.07465573f, 0.05218382f, 0.05776480f, 0.07782110f, 0.13887675f, -0.11664774f, 
    -0.01160306f, 0.08341501f, 0.00044747f, 0.11453918f, -0.03015235f, 0.10906095f, -0.10401848f, -0.11332037f, 
    -0.00489805f, -0.16952845f, 0.16859113f, 0.03639137f, 0.08978072f, -0.04449848f, -0.00720820f, 0.04475906f, 
    -0.02645092f, 0.08552264f, 0.24081551f, -0.13820712f, 0.03474379f, -0.06303035f, 0.08535090f, -0.11314515f, 
    0.14438722f, 0.01402995f, -0.07877190f, -0.05604956f, -0.36124393f, -0.04751461f, -0.21265563f, 0.11608054f, 
    0.06085893f, 0.17816719f, 0.09853453f, 0.09968773f, -0.11073508f, 0.07174272f, -0.05879699f, 0.16164826f, 
    0.02800803f, 0.04675471f, 0.06041098f, -0.08140978f, -0.19017245f, 0.00677540f, -0.18822634f, 0.28791618f, 
    0.12518194f, 0.03075474f, 0.05443582f, -0.07088194f, -0.03091617f, -0.02416985f, 0.02339424f, 0.07355875f, 
    0.00797137f, 0.03355250f, 0.00062848f, -0.10045134f, 0.10008346f, -0.08450234f, 0.03265252f, -0.07679933f, 
    0.25943255f, -0.03223339f, 0.04084666f, -0.05932877f, -0.00029083f, -0.05430357f, -0.11408017f, -0.04525743f, 
    0.07513716f, -0.01137987f, 0.00343237f, 0.01444380f, -0.01458175f, -0.11871707f, -0.01012607f, -0.11329706f, 
    -0.08741145f, -0.08699437f, -0.03676092f, -0.29490513f, 0.15808485f, -0.23873027f, 0.06900140f, 0.00741736f, 
    0.11742124f, -0.05725157f, 0.11079694f, 0.08667108f, -0.05934335f, -0.10700079f, 0.08610260f, 0.01807812f, 
    -0.21421991f, -0.11403362f, 0.06987882f, -0.04578261f, 0.09859092f, -0.04816217f, 0.05583756f, -0.03509624f, 
    0.08203597f, -0.07964239f, 0.15682951f, -0.06841154f, 0.15637045f, -0.10946456f, 0.08822127f, 0.05545179f, 
    0.13681735f, -0.01398669f, -0.03713463f, -0.10462267f, 0.12016094f, 0.11574085f, 0.08443626f, 0.28552973f, 
    0.12242587f, 0.09318377f, -0.09843561f, 0.00392947f, -0.03932330f, -0.01929615f, -0.04625120f, 0.19878206f, 
    0.03227670f, 0.00580010f, 0.09749205f, -0.04710957f, 0.17864943f, -0.03637785f, -0.07974730f, 0.08593623f, 
    0.00816000f, -0.03936972f, -0.07971270f, 0.03640614f, 0.05347728f, 0.00412114f, -0.07001551f, -0.07434482f, 
    0.25150523f, -0.15133756f, -0.11342052f, 0.17448159f, 0.03974726f, -0.00642295f, -0.01402461f, -0.19303191f, 
    0.04779062f, 0.45396873f, 0.15458407f, 0.10239885f, -0.00529674f, 0.04161384f, -0.04563042f, 0.02179032f, 
    -0.00294832f, 0.01089523f, 0.01298814f, 0.01171794f, -0.25850397f, 0.15348420f, -0.07320874f, 0.04083831f, 
    -0.02370675f, -0.26029041f, -0.13086277f, -0.15719630f, -0.13987327f, -0.19423905f, 0.13656305f, -0.10343511f, 
    0.06779056f, 0.06682885f, 0.07361532f, -0.06954141f, -0.03851537f, -0.02862191f, -0.03347827f, -0.20187774f, 
    0.10857683f, 0.05427702f, -0.21815252f, -0.33437845f, -0.06573029f, 0.15389127f, -0.11047856f, 0.08104406f, 
    0.07750479f, 0.11702561f, -0.08741639f, 0.10553133f, 0.05530332f, 0.09230604f, 0.09272737f, 0.00590150f, 
    0.16082300f, 0.08210372f, -0.08576090f, 0.05308546f, 0.06122801f, 0.13119239f, 0.12789690f, -0.09400836f, 
    0.19841309f, -0.08071902f, 0.21316969f, -0.06917300f, -0.04804304f, 0.17701192f, 0.05397948f, -0.07936756f, 
    0.15253223f, -0.06966926f, 0.13233334f, 0.08530379f, -0.08716550f, 0.01917198f, -0.11569550f, 0.15119731f, 
    -0.06408527f, 0.08942120f, -0.11896399f, -0.12608771f, 0.10906244f, -0.03039341f, -0.07372886f, -0.09866393f, 
    -0.00082783f, -0.05459096f, -0.30717021f, 0.17372788f, -0.20715477f, 0.21123023f, -0.13137121f, 0.14044365f, 
    0.12179633f, 0.03410853f, -0.03017993f, -0.35621059f, -0.11387447f, 0.07529347f, -0.00952464f, 0.18231079f, 
    0.08458711f, -0.02858558f, -0.00913573f, -0.04100069f, -0.03786842f, -0.11450856f, 0.00195647f, -0.09800447f, 
    0.15762778f, 0.06322351f, -0.03728450f, -0.00912959f, -0.12088890f, 0.08914833f, -0.05355040f, 0.21849178f, 
    0.08272330f, 0.14372309f, -0.08300961f, -0.02591748f, -0.03028006f, 0.05956137f, 0.22058159f, 0.21643835f, 
    0.12695231f, 0.00380501f, -0.10537294f, -0.04428407f, -0.02469586f, -0.13871759f, -0.00373745f, 0.15107523f, 
    -0.10074265f, 0.18022738f, 0.00693891f, -0.04191321f, 0.02394587f, 0.01371460f, -0.01824013f, -0.00479589f, 
    -0.17964996f, -0.27282348f, -0.24967757f, -0.00476322f, 0.20149845f, -0.27677125f, -0.08555151f, 0.03282677f, 
    -0.03165651f, -0.49148434f, -0.06224503f, 0.22523120f, -0.16054358f, -0.25553972f, -0.02578368f, 0.05794979f, 
    0.02021426f, 0.01205121f, 0.33693102f, -0.15047009f, -0.29924634f, -0.02552412f, -0.03895886f, 0.03109464f, 
    0.16108325f, -0.05585014f, 0.04969602f, -0.00426285f, 0.14808440f, -0.05781191f, 0.13118745f, 0.02417387f, 
    0.06480046f, -0.00866538f, 0.14960608f, 0.04896291f, -0.15291262f, -0.20780058f, 0.11803316f, 0.03568725f, 
    -0.07932125f, -0.07459480f, -0.00835194f, 0.00867736f, 0.12329315f, 0.15685396f, -0.15757862f, 0.04670695f, 
    0.05931670f, -0.08135579f, 0.11300865f, -0.09627482f, -0.02810240f, -0.03209667f, -0.19536844f, -0.16287482f, 
    -0.38476399f, 0.01229528f, -0.11228089f, 0.00750431f, 0.02191119f, 0.11340699f, 0.07211863f, -0.09328580f, 
    -0.21267611f, 0.00702470f, -0.08811116f, 0.08457801f, -0.29525185f, -0.00122719f, -0.02139421f, 0.17709458f, 
    -0.53886890f, 0.03473293f, -0.41242933f, -0.00807150f, 0.09063898f, -0.03156897f, 0.00084201f, 0.01909809f, 
    -0.03305642f, -0.57845092f, 0.12352800f, 0.24669240f, -0.02915923f, 0.02873262f, 0.05966018f, 0.05856408f, 
    0.05117020f, 0.00373725f, 0.12021761f, -0.32940897f, -0.42323577f, -0.15204510f, 0.12693560f, -0.08649095f, 
    -0.02493442f, 0.12850419f, -0.00625164f, 0.42029834f, -0.24935479f, -0.35714221f, -0.14721900f, -0.06524871f, 
    -0.07515571f, -0.06044381f, 0.02796524f, 0.09246027f, 0.05591441f, -0.12431172f, -0.02857436f, -0.13430868f, 
    -0.06592316f, -0.02355814f, 0.07735436f, -0.22628343f, 0.18426014f, 0.01506271f, -0.09851664f, 0.09985036f, 
    0.02167302f, 0.07699479f, 0.01037718f, 0.07560055f, -0.14454149f, -0.03300162f, 0.26356944f, -0.08517747f, 
    -0.26968759f, 0.00007251f, -0.31647891f, -0.11773469f, 0.14369237f, -0.07043855f, 0.23101519f, 0.18164247f, 
    -0.35519770f, -0.17870341f, -0.15780930f, -0.19232343f, 0.04536231f, -0.23076959f, 0.08754391f, 0.02018747f, 
    -0.08068565f, -0.00386863f, 0.14663190f, 0.03125218f, -0.03357474f, -0.03824216f, 0.05977290f, -0.19044228f, 
    0.02272508f, 0.40657109f, 0.18446346f, 0.25693524f, -0.08598846f, 0.05898054f, -0.00337748f, -0.01686843f, 
    0.05417188f, 0.06238799f, -0.03681421f, -0.12543635f, 0.05087677f, 0.29427245f, -0.25015625f, -0.00466530f, 
    0.13727327f, 0.01674843f, 0.11268914f, -0.34947893f, 0.13359618f, 0.16987076f, 0.04092725f, -0.00105756f, 
    -0.14199309f, 0.12062420f, 0.00382078f, -0.00267138f, -0.40960556f, -0.03981482f, -0.12007488f, -0.18352029f, 
    0.00792026f, -0.11946438f, -0.07504886f, 0.10085990f, -0.18839747f, 0.23728907f, -0.12945233f, -0.14866614f, 
    0.05646449f, -0.02585795f, 0.02987472f, 0.06857707f, 0.13857192f, 0.05212497f, 0.14041460f, 0.16762324f, 
    -0.09629797f, 0.11254428f, 0.01822715f, -0.09439107f, -0.04113088f, 0.05384696f, -0.00685432f, 0.11495556f, 
    0.05609810f, 0.17428702f, 0.02299856f, 0.02832715f, 0.05731127f, -0.03158727f, -0.01258669f, 0.22268741f, 
    -0.21305342f, -0.45754388f, -0.39262697f, -0.05782019f, -0.10470178f, -0.09048057f, 0.05001148f, 0.15093745f, 
    -0.04255597f, 0.13144837f, -0.18884122f, -0.08094676f, -0.21153177f, 0.08842299f, -0.03071266f, 0.04586785f, 
    0.09154666f, 0.08578379f, -0.31848189f, 0.06224873f, 0.03801335f, 0.10341760f, 0.07664931f, -0.08340774f, 
    0.03365091f, 0.06335177f, 0.17223921f, -0.03478337f, 0.16934793f, 0.18114731f, -0.01131042f, 0.08695101f, 
    -0.06718289f, 0.01573362f, -0.00721110f, -0.04004141f, 0.09054755f, -0.01703387f, 0.14959495f, -0.15380050f, 
    -0.00275360f, -0.00263647f, 0.01128923f, 0.02524056f, -0.00955531f, 0.06240760f, 0.04941013f, 0.08303690f, 
    -0.01302761f, -0.06293084f, 0.06767757f, 0.05477404f, -0.00415147f, 0.03441795f, -0.27511814f, -0.15643452f, 
    0.07016051f, -0.16773526f, 0.10731002f, -0.12287164f, 0.16215622f, 0.13030900f, 0.00556401f, 0.12892982f, 
    -0.31604075f, -0.27532649f, -0.20036924f, 0.08161522f, -0.12954521f, -0.02907350f, 0.22531316f, -0.06414165f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.20255716f, 0.02617857f, 0.14401774f, 0.05212669f, 0.13356651f, 0.01227647f, 0.12909056f, -0.04588217f, 
    0.18692549f, 0.07105412f, 0.03529535f, 0.05708571f, 0.14205711f, 0.14838526f, 0.13565449f, 0.18890080f, 
    -0.02304184f, -0.02071296f, -0.08074088f, 0.04060877f, 0.11835511f, -0.06095841f, 0.05306099f, -0.03546347f, 
    -0.01095812f, -0.06172113f, 0.01405923f, 0.19471627f, -0.01232110f, 0.10630509f, 0.00629823f, 0.13690077f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06319197f, -0.26724371f, 0.04384053f, -0.58631694f, -0.25191626f, -0.04944997f, 0.06965148f, -0.01019768f, 
    0.32016078f, 0.40478700f, 0.10699329f, -0.04675492f, 0.34662911f, -0.19298624f, -0.02839474f, 0.22726561f, 
    0.00866995f, -0.25232181f, -0.03174407f, -0.00399776f, -0.01279017f, 0.11993738f, 0.20624161f, 0.02481076f, 
    -0.13079181f, -0.24584918f, -0.00928627f, -0.28463444f, -0.17577887f, -0.20089772f, -0.17736046f, 0.49254495f, 
    0.16126557f, 0.10277401f, -0.01989993f, 0.00835959f, 0.09585156f, 0.06071608f, 0.26193252f, -0.03841478f, 
    0.09536409f, 0.18243101f, -0.11046290f, -0.10480222f, 0.11310862f, 0.13481766f, -0.00717758f, 0.49904406f, 
    0.01779807f, 0.05556139f, -0.06078374f, -0.11634588f, 0.09789938f, -0.18588127f, -0.01421863f, 0.35681438f, 
    -0.24612992f, -0.27232325f, 0.09470740f, -0.08932974f, -0.01173361f, 0.32021484f, 0.08384322f, 0.16749820f, 
    0.28160399f, -0.30477485f, 0.40569955f, 0.14208946f, -0.19953005f, -0.23002443f, -0.06503672f, -0.30103567f, 
    0.27444375f, -0.11404835f, 0.01979785f, 0.05090822f, -0.02604041f, -0.18858945f, 0.17236573f, 0.03830616f, 
    -0.29885563f, -0.19377114f, 0.00815004f, -0.07536325f, 0.13627645f, -0.00450305f, 0.18438329f, -0.19218761f, 
    -0.10728475f, 0.00857611f, -0.09587777f, 0.19970487f, 0.07401850f, -0.18192472f, 0.21951990f, -0.50566703f, 
    0.16686705f, 0.03706176f, -0.33817631f, 0.06463480f, 0.15463644f, 0.04541361f, -0.09557354f, 0.21810794f, 
    0.06161440f, 0.14599739f, 0.10962704f, 0.29490659f, -0.01110444f, -0.08646902f, -0.26126635f, -0.03993385f, 
    0.08560075f, -0.03640465f, 0.16630416f, 0.09499098f, 0.10133085f, -0.02802047f, 0.02696634f, 0.24756521f, 
    -0.09107859f, -0.43087456f, 0.13442011f, -0.01383025f, -0.27666557f, 0.22266670f, -0.14038794f, -0.16526401f, 
    -0.01445964f, 0.44502470f, 0.04459787f, 0.04416081f, 0.18063155f, 0.06285892f, 0.13101776f, 0.24672027f, 
    0.23467401f, -0.41416997f, 0.17959076f, -0.02021451f, -0.07042073f, 0.14901432f, -0.12958299f, -0.35498452f, 
    -0.18363801f, -0.05740383f, 0.04365215f, 0.09233337f, 0.07745222f, -0.37677801f, 0.20525891f, 0.01268724f, 
    0.09613215f, -0.21876948f, 0.12823997f, 0.05269319f, 0.09182771f, 0.19932820f, -0.57995731f, 0.05441231f, 
    0.16221212f, -0.14664069f, 0.05625521f, -0.22574523f, -0.15190642f, 0.04499494f, 0.03614695f, -0.37683946f, 
    0.21709554f, 0.10939872f, -0.00892193f, -0.09068663f, 0.20037904f, -0.19206294f, 0.19298519f, 0.22622781f, 
    -0.02646290f, -0.20883782f, 0.14774314f, 0.09829403f, 0.29579931f, -0.12659059f, 0.23796527f, -0.09402378f, 
    -0.32670939f, 0.26420549f, 0.10681805f, -0.28678808f, 0.35409659f, 0.21074747f, 0.04954545f, 0.23645434f, 
    -0.08006372f, -0.17925392f, 0.13143617f, -0.37552255f, -0.20295887f, -0.07387757f, -0.35652623f, 0.31832698f, 
    -0.05135589f, -0.33014661f, -0.18217455f, 0.28839567f, -0.16698621f, -0.53585774f, 0.28051174f, 0.23765157f, 
    0.27538720f, -0.33674434f, 0.12831274f, 0.10572100f, 0.11553241f, 0.06038940f, -0.06824717f, 0.07068382f, 
    0.01173684f, 0.19678554f, 0.05169339f, 0.10072388f, -0.02839713f, 0.03432303f, 0.33866683f, 0.20622373f, 
    0.35228959f, 0.04937093f, 0.15475929f, 0.01553625f, -0.13200003f, -0.22146484f, 0.30473739f, -0.10340517f, 
    0.42048794f, 0.13226721f, -0.20194548f, 0.14186548f, 0.14677539f, -0.12162034f, -0.04600635f, -0.14137313f, 
    -0.25594202f, -0.24009407f, 0.02888912f, -0.15946539f, 0.17021252f, -0.20534524f, 0.20148768f, 0.12193011f, 
    -0.13611631f, -0.24928463f, 0.02514961f, -0.00142179f, 0.01763866f, 0.05680586f, -0.34238541f, 0.17937988f, 
    -0.16338494f, -0.06704594f, 0.23239501f, -0.24691284f, 0.08164652f, 0.05731393f, -0.02501432f, 0.20659435f, 
    -0.22095846f, -0.36181748f, 0.03360854f, 0.22457708f, -0.58056027f, -0.38987452f, 0.18776491f, -0.22598860f, 
    0.33879063f, -0.15953439f, -0.08024061f, 0.11322715f, 0.31372461f, 0.13716705f, 0.01106750f, -0.09862798f, 
    0.23417158f, 0.21187770f, 0.12744665f, 0.18058693f, -0.10623062f, -0.10787987f, 0.00126564f, 0.45071319f, 
    0.14970799f, -0.10603265f, -0.24891466f, -0.03560674f, -0.09076204f, 0.21203177f, 0.05795785f, 0.49331245f, 
    0.05578111f, -0.07328267f, 0.08532534f, 0.00763211f, -0.11889934f, -0.09029478f, 0.25134858f, 0.43130097f, 
    0.29201970f, 0.15900314f, -0.27252474f, 0.14233254f, 0.15400763f, -0.17512040f, -0.08629275f, 0.00556652f, 
    -0.26610678f, 0.12507202f, -0.06949727f, -0.21241927f, -0.18691728f, 0.04054870f, 0.03720701f, 0.01177073f, 
    0.38895980f, -0.27385831f, -0.06877147f, -0.32441247f, -0.24191199f, 0.04779676f, -0.01579670f, -0.06466675f, 
    0.19907889f, -0.28663555f, -0.22704047f, 0.18364142f, 0.07305920f, -0.12960979f, 0.30388290f, -0.09948736f, 
    0.28461406f, -0.17994399f, -0.16407907f, -0.10492898f, 0.25326926f, 0.01845084f, -0.02503047f, 0.06628115f, 
    -0.33300310f, -0.04771949f, -0.07723606f, 0.30669567f, -0.19749638f, 0.02089579f, 0.24170135f, 0.36132565f, 
    -0.05624555f, 0.18497139f, -0.25052020f, 0.03634835f, 0.07490803f, -0.01774173f, 0.21950446f, 0.17666890f, 
    0.31498194f, -0.18665448f, 0.10122284f, 0.04491450f, -0.03292621f, -0.04553961f, 0.02345361f, 0.31737509f, 
    0.01412116f, 0.16713485f, -0.12379838f, 0.09026969f, -0.16700555f, -0.27683106f, 0.15693437f, 0.01286037f, 
    0.18752035f, 0.04951188f, 0.13534015f, -0.36341643f, -0.18825786f, 0.18862559f, -0.02277941f, -0.20238106f, 
    0.25097075f, -0.20511457f, -0.04655112f, -0.20657496f, -0.00970747f, -0.00485642f, -0.15427263f, 0.29169971f, 
    -0.00300172f, 0.01293898f, -0.02053356f, -0.04336169f, 0.03834603f, -0.41604954f, 0.09565526f, -0.24701601f, 
    0.25178614f, -0.02471263f, 0.01429073f, -0.04237752f, 0.17313962f, 0.27358806f, -0.07636337f, 0.20188601f, 
    -0.22100393f, -0.20605966f, 0.10402622f, 0.16098833f, -0.27348092f, -0.07869796f, 0.22945799f, 0.09553533f, 
    0.03408607f, 0.08937530f, -0.09170635f, 0.03543926f, 0.09461672f, 0.15660198f, 0.06585694f, -0.27892330f, 
    0.16540490f, 0.02109603f, 0.02245246f, -0.16619085f, 0.31468043f, 0.23076397f, 0.13263375f, 0.61580563f, 
    0.14153025f, 0.15829410f, -0.02695113f, 0.10640326f, -0.05626730f, -0.23856454f, 0.19016521f, 0.17084721f, 
    -0.20667028f, 0.00473191f, 0.05179248f, -0.23624825f, 0.14688599f, 0.17603068f, -0.02593039f, 0.13135983f, 
    -0.19400796f, -0.13006128f, -0.03528573f, -0.07713751f, -0.14725325f, 0.15058571f, -0.09077071f, 0.34933278f, 
    -0.09645817f, -0.02885858f, -0.29963413f, 0.01031355f, 0.03931587f, 0.23508692f, -0.05387547f, -0.17254020f, 
    0.00301170f, -0.00815517f, 0.00370168f, 0.16494209f, -0.10853466f, -0.16835997f, 0.17068416f, 0.18301901f, 
    0.10390889f, 0.12307303f, -0.11503750f, 0.17050511f, 0.05455359f, -0.21303891f, 0.05725754f, -0.21039771f, 
    0.35030112f, -0.11016330f, 0.42496011f, -0.41881552f, 0.01978654f, -0.30007204f, -0.01508019f, -0.11117343f, 
    0.21798795f, 0.23526224f, 0.21349452f, 0.05765251f, 0.23806590f, -0.29221493f, 0.13188003f, -0.23067771f, 
    -0.05486144f, -0.49888372f, -0.17817400f, 0.00593954f, 0.16951430f, 0.03276538f, 0.31314155f, -0.04320613f, 
    -0.21761331f, -0.37674901f, 0.05320748f, 0.20865738f, -0.15232150f, -0.27775830f, 0.01207426f, 0.54686105f, 
    0.36780900f, 0.15165697f, 0.45392206f, 0.11144195f, -0.43890339f, -0.22695760f, 0.32790303f, -0.32440355f, 
    0.24068987f, -0.31511900f, 0.01896042f, -0.00710247f, 0.20498571f, 0.44286549f, 0.13520926f, 0.10977306f, 
    0.03587874f, -0.06764929f, -0.20769528f, -0.01466182f, 0.21998721f, -0.12599862f, 0.04757017f, -0.12247202f, 
    -0.10308058f, -0.04269529f, 0.09356695f, 0.42077675f, 0.18736288f, 0.20083937f, -0.01447746f, 0.02977183f, 
    -0.07819169f, 0.08702672f, -0.11242607f, -0.00464466f, 0.25177401f, -0.08905544f, -0.08654977f, -0.03318462f, 
    0.17056997f, 0.07590603f, 0.07930540f, -0.04788979f, -0.22681986f, -0.14905971f, 0.08323040f, 0.10397888f, 
    -0.11752452f, -0.20544654f, -0.12682781f, -0.04957384f, -0.00189262f, -0.08425582f, 0.05485122f, -0.23263274f, 
    -0.18639801f, 0.10070146f, -0.08193921f, -0.08618816f, -0.14041972f, -0.19822505f, -0.11660030f, 0.06008242f, 
    -0.30133784f, 0.15336320f, 0.23657794f, 0.06610983f, 0.11074388f, -0.11937779f, 0.08354334f, -0.17870100f, 
    0.05178335f, -0.23588446f, 0.27972484f, -0.04654307f, 0.00449340f, 0.02780417f, 0.05324915f, -0.01033112f, 
    0.04575425f, 0.15517692f, -0.05331471f, -0.08086474f, 0.09852097f, -0.28173938f, -0.12383834f, -0.03276438f, 
    0.21490596f, 0.14773767f, 0.14861456f, -0.12387396f, 0.09175700f, 0.19035718f, -0.05823744f, -0.16421546f, 
    0.31775057f, 0.08988155f, 0.27064320f, 0.02050207f, -0.20391560f, 0.03899585f, 0.14810102f, -0.13728391f, 
    0.06977183f, -0.20826522f, -0.07653908f, -0.09533106f, -0.08190843f, -0.37935945f, 0.21212843f, 0.10379215f, 
    -0.09045639f, -0.04008602f, 0.01659262f, -0.02498866f, 0.12039794f, -0.03688997f, 0.08613662f, 0.07480581f, 
    -0.27312621f, -0.24119121f, 0.06505428f, 0.31068987f, 0.46471196f, 0.43388358f, 0.21334331f, -0.25403935f, 
    0.00186465f, 0.05733865f, 0.05517168f, -0.17282106f, -0.10736588f, 0.02916878f, 0.24829927f, -0.31767541f, 
    0.17823881f, -0.08681516f, 0.19269380f, 0.01892326f, 0.00408754f, -0.36761546f, -0.15479347f, 0.08180737f, 
    -0.02004224f, 0.10628616f, 0.13696863f, -0.12333971f, 0.29050514f, -0.16017003f, 0.25387627f, 0.09999885f, 
    0.19608964f, -0.02351804f, -0.00661700f, -0.28884077f, -0.26768872f, -0.24888855f, -0.09098250f, 0.39926115f, 
    -0.18062191f, 0.05015137f, 0.23607698f, 0.18949169f, -0.01821006f, -0.33400860f, 0.09232063f, -0.08384245f, 
    0.21371579f, 0.32345361f, 0.24777475f, 0.12128907f, 0.05700386f, 0.20536168f, -0.08529296f, -0.33848569f, 
    -0.15737061f, 0.01755823f, -0.25576392f, -0.00234870f, -0.18127105f, 0.03439560f, -0.12522520f, -0.01616304f, 
    0.01618361f, -0.21162969f, 0.16928217f, 0.39995563f, 0.16292621f, 0.20789295f, 0.18476915f, -0.32802203f, 
    -0.17427450f, 0.06339320f, 0.19774520f, 0.05432184f, -0.00001066f, 0.05025219f, 0.22139010f, -0.24772520f, 
    0.14083076f, 0.02440214f, 0.11482032f, -0.15129298f, 0.10780950f, -0.07053916f, -0.19612700f, 0.09093340f, 
    -0.03936600f, 0.06552239f, 0.01101512f, 0.01942405f, 0.07872198f, -0.23241158f, 0.14454614f, 0.09385681f, 
    -0.04555498f, -0.06317417f, 0.06696998f, 0.00266048f, 0.02049329f, -0.09785448f, -0.10197124f, 0.14111598f, 
    -0.15616001f, -0.27251297f, 0.16109672f, -0.05909972f, 0.08290977f, 0.03425252f, -0.15923658f, 0.03254006f, 
    -0.00991316f, -0.03179000f, 0.19643418f, -0.11474282f, 0.21064037f, 0.00413913f, 0.18618204f, 0.29231876f, 
    0.22674923f, 0.06939373f, -0.07160618f, -0.12470367f, 0.10305014f, 0.01073160f, 0.00205085f, -0.16822067f, 
    -0.01766506f, 0.20651177f, 0.15240119f, -0.03115933f, 0.20624319f, 0.02775492f, 0.18404721f, 0.08042111f, 
    -0.09017725f, 0.14768694f, 0.17168519f, 0.06579484f, 0.01116071f, 0.06795400f, 0.24179268f, 0.01413805f, 
    0.00642890f, -0.08411067f, -0.10868915f, 0.03827113f, -0.07033026f, -0.04848220f, 0.13769758f, -0.28744280f, 
    -0.02270868f, -0.05546152f, 0.14570819f, -0.00432775f, 0.13430777f, -0.27466366f, -0.03837632f, 0.25950739f, 
    0.38461331f, -0.09367354f, -0.07381782f, -0.17410001f, -0.12351908f, 0.23685622f, -0.04567827f, -0.01701220f, 
    -0.06331491f, 0.21904361f, 0.19251350f, -0.02741708f, -0.18548065f, -0.19866514f, -0.03785539f, 0.11279673f, 
    -0.10546505f, -0.49875072f, 0.13814847f, 0.23331486f, -0.24644446f, -0.02518111f, -0.03562049f, -0.16059008f, 
    -0.03249729f, 0.05339931f, 0.09678882f, 0.10285001f, -0.04406813f, 0.14470895f, -0.06630572f, -0.01835564f, 
    0.37523210f, 0.17028250f, 0.13892253f, -0.16569082f, 0.03308563f, 0.27280337f, 0.05455545f, -0.28808510f, 
    -0.09961790f, -0.21127497f, -0.41926372f, -0.19955765f, 0.08608507f, -0.06717700f, 0.10349153f, 0.35250401f, 
    0.18528996f, -0.15199377f, 0.28610227f, 0.13516758f, 0.04300089f, -0.23417027f, -0.05648414f, 0.31318918f, 
    -0.03859036f, 0.16447830f, -0.47852409f, 0.16616137f, 0.18356729f, 0.09531458f, 0.13882962f, -0.14383838f, 
    0.14738083f, 0.29487455f, 0.01451525f, -0.58464521f, -0.23297043f, -0.27926558f, -0.13830267f, 0.00724405f, 
    0.03252519f, 0.07510034f, -0.05583404f, -0.14520983f, -0.25468832f, 0.16275285f, 0.18118294f, 0.27735126f, 
    0.03989893f, -0.03849588f, 0.27391982f, -0.22323178f, 0.05565681f, -0.09464847f, 0.10600615f, 0.37385595f, 
    0.15075760f, 0.06612080f, -0.12733305f, -0.00213927f, -0.09135241f, 0.06314094f, -0.00278219f, 0.40256011f, 
    -0.22699240f, -0.35470885f, 0.07111296f, -0.48588639f, 0.43031013f, 0.32455045f, -0.09219046f, -0.25569025f, 
    0.35041368f, 0.23010747f, -0.24373479f, -0.11264789f, 0.11805297f, 0.10707724f, 0.28415409f, -0.08833317f, 
    0.24036404f, 0.21791419f, 0.03460756f, 0.17778823f, 0.05225597f, 0.21122687f, -0.19539356f, 0.14924683f, 
    0.01547425f, -0.16075297f, 0.14555721f, 0.15965760f, 0.00958304f, -0.20234622f, 0.15659381f, 0.09476453f, 
    -0.20021500f, -0.47865853f, -0.09224053f, -0.29606855f, -0.47459054f, 0.16177797f, -0.19251420f, 0.18488999f, 
    0.06776439f, 0.34670734f, -0.04038068f, -0.18344972f, 0.39190939f, 0.16920477f, -0.09760576f, 0.24988092f, 
    0.11387231f, -0.28156877f, 0.01227611f, 0.00355029f, -0.11422762f, 0.09626354f, 0.15171032f, -0.17662744f, 
    -0.20155898f, -0.03886223f, 0.13291973f, 0.17596675f, -0.05988025f, -0.01134256f, -0.09156356f, 0.14146706f, 
    0.05345246f, -0.10110861f, -0.07471994f, -0.14719935f, -0.01264599f, 0.19797269f, -0.10709916f, -0.20632200f, 
    -0.00612987f, -0.24885042f, 0.05491338f, -0.12828727f, -0.25703171f, -0.02054601f, 0.04803520f, -0.20987830f, 
    -0.12550406f, 0.06653973f, 0.16347072f, 0.17928144f, 0.15604283f, -0.46052873f, 0.15332592f, 0.23626602f, 
    0.15734936f, 0.07883827f, -0.00551723f, -0.04206560f, 0.24548081f, 0.15469235f, 0.27153751f, -0.08017851f, 
    -0.18008213f, 0.27428052f, 0.16578335f, -0.21285760f, 0.33968407f, -0.09211063f, -0.20871669f, 0.17432511f, 
    -0.03655665f, -0.30628318f, -0.11121113f, -0.17131467f, -0.16556889f, -0.01593165f, -0.06943507f, 0.22205426f, 
    0.02335129f, 0.00483150f, -0.18003082f, 0.19665685f, 0.32576427f, -0.42192289f, 0.21285449f, 0.10668837f, 
    0.04092870f, 0.10718174f, 0.16699389f, 0.03551531f, 0.03789321f, 0.29144108f, 0.23173742f, 0.03447963f, 
    -0.24035500f, 0.03627770f, 0.15356094f, -0.21953416f, 0.02805856f, 0.08147965f, -0.04289248f, -0.16699649f, 
    0.24208343f, -0.14254838f, -0.11463595f, 0.00669259f, 0.09524130f, 0.05475289f, 0.02780652f, -0.19456896f, 
    0.43688628f, -0.24197415f, -0.01127783f, 0.12140571f, -0.16228618f, 0.00117579f, 0.04202921f, 0.52537787f, 
    -0.18785764f, -0.22515394f, -0.02708977f, 0.04847009f, -0.03118860f, -0.06507635f, 0.23800723f, 0.18648140f, 
    0.14424936f, -0.06734288f, -0.15556586f, -0.09979866f, -0.54296881f, -0.18735914f, 0.05897050f, 0.06567151f, 
    0.20167696f, 0.02115848f, 0.41837698f, 0.04991709f, -0.01986453f, 0.15489466f, -0.07505764f, -0.38726595f, 
    -0.11778419f, -0.42894486f, 0.08213931f, -0.04202483f, -0.01863942f, -0.28152564f, 0.20490196f, 0.48369375f, 
    0.04429533f, -0.19441508f, 0.15885672f, 0.10660920f, 0.12034769f, -0.18651988f, 0.18036680f, 0.09835221f, 
    -0.06072380f, 0.07891253f, 0.00553166f, -0.13766739f, 0.21059880f, -0.00598811f, 0.07978296f, 0.24877498f, 
    0.04312786f, 0.28358030f, -0.07970846f, 0.11413724f, -0.12036031f, 0.02291265f, 0.29146162f, -0.02441014f, 
    -0.00892169f, 0.19038399f, 0.14726725f, 0.20746738f, 0.16391985f, 0.18751822f, -0.15600148f, 0.58270413f, 
    -0.03417438f, -0.04553947f, 0.15382405f, -0.03393605f, -0.06543782f, -0.24188855f, 0.18702690f, 0.12311260f, 
    0.22104834f, -0.24120258f, 0.13137734f, -0.36349195f, -0.16750295f, 0.24466202f, -0.20310396f, 0.00808462f, 
    -0.01484604f, 0.24764404f, -0.10357498f, -0.08767755f, -0.24602154f, -0.04116910f, 0.21907882f, -0.07761803f, 
    0.21451820f, -0.06537341f, -0.04398082f, 0.02993960f, -0.01859098f, 0.25894368f, -0.21427600f, 0.39512229f, 
    -0.06871034f, -0.15634596f, -0.22015171f, 0.17250612f, -0.01953856f, 0.00089239f, 0.10350689f, 0.07813693f, 
    0.51395732f, -0.26500702f, -0.11799443f, -0.41889817f, -0.07005410f, 0.06678328f, -0.02456078f, -0.19949052f, 
    0.18130149f, 0.05087626f, 0.15008435f, -0.11753054f, 0.00697749f, -0.14888421f, -0.02344993f, -0.27225426f, 
    0.10156764f, 0.21573937f, 0.25344610f, 0.06346753f, 0.28991419f, 0.11367749f, 0.04659303f, 0.09563600f, 
    0.14923501f, 0.02361883f, 0.08052711f, -0.11154729f, -0.03005094f, -0.00989453f, 0.08421575f, -0.22681722f, 
    -0.30770120f, -0.37319964f, -0.10421769f, -0.10707407f, 0.14645016f, -0.02843398f, -0.20561805f, 0.24089970f, 
    0.10154186f, 0.07082969f, 0.17994145f, -0.21412279f, -0.19875126f, 0.19239712f, -0.15630394f, 0.00696185f, 
    0.05660117f, 0.04083233f, -0.07032257f, -0.13607293f, -0.09470928f, -0.18779680f, -0.04540893f, 0.08149272f, 
    0.07556596f, -0.14227697f, -0.09106032f, 0.10644479f, 0.03180792f, -0.12601647f, -0.08997502f, -0.02052418f, 
    -0.08936162f, 0.17489035f, 0.02406815f, -0.11709532f, -0.19306396f, -0.08025354f, -0.23170565f, 0.00750458f, 
    0.16606849f, -0.34335533f, -0.04432138f, -0.04840243f, -0.23600827f, -0.14905332f, -0.13940281f, -0.04991283f, 
    0.14213963f, 0.29780179f, 0.03243605f, 0.03805052f, 0.38368094f, 0.14837578f, -0.06559436f, -0.13739063f, 
    -0.11503837f, -0.11716387f, 0.05361960f, -0.08398312f, 0.20857216f, 0.15318424f, -0.02980044f, 0.30812603f, 
    -0.13113886f, -0.17313106f, 0.07611243f, 0.22490090f, -0.31268463f, -0.42300856f, 0.07113652f, -0.41874641f, 
    -0.16206822f, 0.25377795f, -0.14571667f, -0.01878141f, 0.01061172f, 0.30300742f, 0.27356830f, -0.43446770f, 
    0.29748517f, 0.09929145f, -0.07654951f, 0.34383464f, -0.31712255f, 0.04052948f, -0.17648125f, 0.36402071f, 
    0.21282656f, -0.08458476f, -0.12805262f, -0.03645219f, 0.07192020f, -0.17606126f, 0.21806175f, 0.17438689f, 
    0.18145274f, -0.14751533f, 0.01818897f, -0.30288568f, -0.19391501f, 0.06266533f, -0.25264502f, 0.43819052f, 
    0.02340047f, -0.11624078f, 0.02641491f, -0.00128296f, -0.07972609f, -0.30019799f, 0.01462442f, 0.12517439f, 
    0.01226023f, 0.06462225f, -0.25091127f, 0.25688425f, 0.02309416f, -0.30855015f, 0.04076893f, -0.19821419f, 
    -0.10166995f, 0.06041231f, -0.03224745f, -0.00909602f, 0.19896768f, 0.12158923f, -0.00726729f, 0.07518809f, 
    0.38461339f, 0.20031971f, 0.07628143f, -0.18762060f, -0.36730868f, -0.02055898f, -0.01513635f, 0.08274143f, 
    0.11185832f, 0.13967916f, 0.34572488f, 0.21502174f, 0.00588443f, -0.21110226f, 0.17084420f, -0.09284673f, 
    0.03951777f, 0.01516121f, 0.04980816f, 0.12030634f, -0.33708420f, 0.25145069f, 0.13948181f, -0.23080823f, 
    0.07195397f, 0.09988768f, 0.05893819f, 0.10269225f, -0.09436215f, -0.10196009f, -0.13578008f, -0.30743656f, 
    0.22023192f, -0.01689535f, 0.07867512f, 0.43968657f, 0.36302081f, -0.07659941f, 0.07280384f, -0.08957503f, 
    -0.10693840f, 0.01581533f, 0.08604780f, 0.12553476f, 0.30140477f, -0.26372951f, 0.14410938f, 0.00106056f, 
    0.40934187f, 0.20295213f, 0.08123636f, 0.16129066f, 0.02181953f, 0.04654140f, 0.09536905f, -0.20898587f, 
    -0.28138617f, 0.07203544f, -0.27141830f, -0.00711078f, -0.17469220f, 0.21987829f, 0.16305514f, -0.23551476f, 
    -0.08247915f, 0.00656061f, -0.01600788f, -0.01865553f, -0.36415356f, -0.16985789f, -0.16080947f, 0.06500302f, 
    0.19284019f, -0.14277132f, -0.01914387f, 0.04870424f, -0.10303710f, -0.19984277f, 0.17806210f, -0.21571127f, 
    0.09290001f, 0.03040672f, -0.23052019f, 0.01439476f, 0.49175715f, -0.20881779f, 0.19533706f, 0.09522399f, 
    -0.00305181f, 0.13513105f, -0.13323025f, 0.09491446f, 0.22179876f, 0.17433473f, -0.04781801f, 0.08814320f, 
    -0.05421105f, -0.05236048f, -0.03673492f, -0.13141279f, 0.13771109f, 0.13519579f, -0.11748739f, 0.13698269f, 
    -0.04285857f, 0.10433124f, 0.23319945f, 0.19814910f, -0.26074103f, 0.04914265f, 0.25074255f, -0.06693782f, 
    -0.24603908f, -0.18186505f, 0.11224436f, 0.13308479f, -0.02658117f, 0.15824538f, -0.06686728f, 0.49015576f, 
    0.18346862f, 0.05415650f, 0.05530936f, 0.07435714f, 0.02884510f, -0.02069177f, -0.10204280f, 0.34851328f, 
    0.38429895f, -0.17151339f, 0.06262062f, -0.18396951f, 0.18129539f, -0.10174545f, -0.08514262f, -0.07240011f, 
    0.12566178f, -0.00208936f, -0.30233267f, 0.17856914f, 0.16182849f, -0.04945533f, -0.13010901f, 0.17424133f, 
    0.29254225f, -0.23266344f, -0.05426484f, 0.17963412f, 0.23484419f, -0.06869296f, 0.14167196f, -0.05288759f, 
    -0.21168448f, 0.18482621f, -0.25302705f, -0.07994720f, 0.14124073f, 0.15187180f, 0.00007234f, 0.07049230f, 
    -0.08479519f, 0.08506418f, -0.09561540f, -0.16643170f, -0.54425585f, -0.25703293f, 0.10665455f, 0.08845446f, 
    0.01627816f, 0.00933640f, -0.13411728f, -0.01295405f, 0.27801844f, 0.12376042f, -0.02054956f, 0.05618687f, 
    0.22889882f, 0.22609049f, -0.05440317f, 0.06637100f, -0.29949850f, -0.08093186f, -0.22059417f, -0.05574983f, 
    -0.04690940f, 0.13709912f, -0.01728678f, 0.04792663f, -0.08011725f, -0.01259367f, 0.12994556f, 0.21046825f, 
    0.16090819f, 0.05081089f, 0.07606785f, -0.25808826f, -0.44909909f, -0.14696172f, -0.05679137f, 0.23229405f, 
    0.07984990f, -0.26637122f, 0.25673848f, -0.17798527f, -0.06411879f, -0.32992435f, -0.04266666f, 0.10475925f, 
    0.30648541f, -0.06489950f, -0.17193645f, 0.01062530f, 0.19546503f, 0.21108118f, 0.16485502f, -0.09412646f, 
    0.21311110f, 0.04868907f, -0.44652402f, -0.14804097f, -0.09447682f, 0.31837770f, -0.26124015f, -0.43543893f, 
    -0.25937235f, 0.15750572f, -0.05785921f, 0.14756696f, -0.33234212f, -0.07342516f, 0.36014456f, 0.20569649f, 
    -0.25676224f, -0.24091382f, -0.00665901f, -0.36987400f, 0.19007839f, -0.24279055f, 0.08052854f, 0.00984581f, 
    -0.01824589f, 0.25925550f, 0.19666409f, 0.30036753f, -0.39097989f, -0.09120375f, 0.11137718f, 0.09134229f, 
    0.27462757f, -0.07069490f, -0.34220728f, -0.10406066f, 0.20544355f, -0.12022392f, -0.03546323f, 0.04890331f, 
    -0.05459364f, 0.36217245f, 0.15330574f, -0.23002577f, -0.10164679f, -0.05192280f, 0.10228515f, 0.51406842f, 
    0.15901572f, -0.10860698f, 0.09489438f, -0.19806321f, 0.24877763f, -0.17793870f, -0.08297993f, 0.10941737f, 
    0.26779041f, -0.27912229f, 0.14695551f, 0.13015154f, -0.47318763f, -0.51497513f, -0.10293414f, 0.11347014f, 
    -0.01497292f, -0.09804922f, -0.17377423f, 0.09384467f, 0.07958168f, 0.04903163f, 0.08267444f, -0.10775793f, 
    0.21103895f, -0.13928334f, 0.17083819f, -0.10647759f, -0.47514576f, -0.35350236f, 0.15813668f, 0.03705853f, 
    -0.22555450f, 0.17163265f, 0.06010314f, -0.12697497f, 0.10777450f, -0.03776323f, -0.11136433f, 0.39000303f, 
    -0.10000172f, -0.29416063f, 0.07151478f, 0.04094502f, -0.45120072f, -0.01987907f, -0.04975063f, 0.18284108f, 
    0.10133484f, -0.16752177f, -0.16650262f, 0.12314211f, 0.08083780f, 0.25784385f, -0.43696529f, 0.18625095f, 
    0.08021294f, -0.05066999f, 0.08821702f, 0.29018056f, 0.25023589f, 0.28620040f, 0.30118930f, -0.35516819f, 
    -0.11072301f, -0.16157542f, -0.22073583f, 0.19163346f, -0.04578427f, -0.07844298f, -0.02284275f, -0.27566323f, 
    -0.16010359f, 0.14894412f, -0.12203506f, -0.00266454f, 0.08728767f, 0.36658874f, 0.17025386f, 0.06713881f, 
    0.17071934f, -0.09240016f, -0.05242168f, 0.10646051f, -0.21396817f, 0.27602729f, 0.02545703f, 0.26925018f, 
    -0.25166622f, -0.01000441f, 0.03847127f, 0.37345609f, 0.06684198f, -0.10753565f, 0.25668889f, 0.09236988f, 
    0.09111543f, 0.08029169f, -0.05094450f, 0.15205055f, -0.06731080f, 0.05874034f, 0.10064740f, 0.19863939f, 
    -0.27274576f, -0.11878966f, 0.09576920f, -0.20334630f, 0.02381828f, 0.38929495f, 0.05531717f, 0.05608791f, 
    0.28512111f, 0.09775910f, -0.00064363f, 0.06002590f, -0.12205429f, -0.01367394f, -0.22892220f, 0.13628043f, 
    0.02275831f, -0.08551829f, -0.04505232f, 0.02095598f, 0.46638486f, 0.44093841f, 0.21396807f, -0.01642098f, 
    0.07852872f, 0.07339664f, -0.12798476f, -0.11912905f, 0.20821507f, 0.01131633f, -0.13982809f, 0.35665500f, 
    -0.18819927f, -0.35419115f, -0.11447816f, 0.01560705f, -0.26057774f, -0.14325775f, -0.20451628f, 0.11550795f, 
    0.19888513f, 0.15422261f, 0.22090578f, -0.14747190f, 0.06432378f, 0.12057971f, -0.04171614f, 0.13790427f, 
    0.24608505f, -0.17874417f, 0.14934926f, -0.07656848f, -0.01919903f, 0.41325524f, -0.07798595f, 0.13717608f, 
    -0.27316839f, 0.24770218f, -0.22987017f, 0.21552275f, -0.08365370f, 0.11618913f, -0.05991931f, 0.16810437f, 
    -0.07210769f, 0.15685053f, 0.06963947f, -0.01437653f, -0.33019540f, 0.31771478f, -0.12974171f, 0.02714302f, 
    0.10957619f, -0.05509877f, 0.17494209f, 0.00682837f, 0.03646018f, -0.07529913f, -0.11875021f, 0.26792145f, 
    0.10694320f, -0.07482161f, -0.00254022f, 0.02791999f, 0.19539189f, 0.47574785f, 0.29875085f, 0.22199062f, 
    -0.31403628f, 0.26000383f, -0.08653936f, -0.00285899f, 0.39607024f, -0.04673329f, 0.11481440f, 0.29589728f, 
    -0.11347099f, -0.27552652f, 0.28083757f, 0.22085054f, -0.31731492f, -0.17226350f, -0.07278368f, -0.44853747f, 
    0.07421202f, 0.00397404f, 0.17831661f, 0.13036788f, -0.24266241f, -0.03572530f, -0.15107100f, 0.22970888f, 
    0.13107473f, 0.04871816f, 0.01625656f, -0.39748433f, -0.04928607f, 0.19711997f, -0.29362184f, 0.05823700f, 
    0.33530766f, -0.04793910f, -0.16555430f, -0.27864739f, -0.11214956f, -0.01747028f, 0.24176566f, -0.06358448f, 
    0.16070531f, 0.14228985f, 0.04039795f, -0.06661271f, -0.14299862f, -0.18445317f, -0.07649811f, 0.10698405f, 
    -0.04308629f, -0.27002242f, 0.20134819f, 0.01951051f, 0.20138218f, -0.14503863f, 0.28579730f, 0.29438236f, 
    -0.15107140f, -0.48058787f, -0.02092544f, -0.15880719f, -0.09392887f, -0.15907782f, -0.25192520f, 0.42070496f, 
    -0.00654681f, 0.13863342f, 0.04235349f, 0.10410398f, 0.19187944f, 0.22973791f, 0.14981394f, -0.05518717f, 
    0.29527727f, -0.21182737f, 0.06891093f, -0.02362546f, -0.55946213f, 0.00271947f, -0.16761714f, -0.52520335f, 
    -0.06624852f, 0.11706884f, -0.24807577f, 0.01969052f, -0.23300079f, -0.15610464f, -0.07970703f, 0.04701225f, 
    -0.23365891f, -0.06026056f, -0.16130309f, -0.07517384f, 0.07206560f, 0.27720368f, -0.24213009f, -0.09854090f, 
    0.01145252f, -0.23086639f, 0.30331638f, -0.26473951f, 0.34598646f, 0.01519833f, -0.22754216f, -0.08245309f, 
    0.21149571f, -0.19350043f, 0.11113509f, 0.22414008f, -0.41108525f, -0.20743290f, -0.03529494f, -0.36080021f, 
    0.19666459f, -0.31625047f, 0.09704317f, -0.03247544f, 0.24188116f, 0.01785110f, -0.09385777f, -0.00947526f, 
    0.03010018f, 0.05876625f, -0.14240611f, -0.09113647f, 0.09557872f, -0.01184043f, -0.14182712f, 0.24835642f, 
    0.24928768f, -0.03898153f, 0.09319406f, -0.16001971f, -0.52732706f, -0.22517474f, 0.04198359f, -0.21916601f, 
    0.05247062f, -0.29310471f, -0.08878860f, -0.02960708f, 0.02124783f, -0.34877691f, 0.24145664f, -0.01534947f, 
    0.14474620f, -0.16908713f, -0.03382168f, -0.15917774f, 0.29873773f, 0.12642753f, 0.12983042f, 0.08712562f, 
    -0.02776786f, 0.14368843f, -0.13986166f, 0.28055432f, 0.05165488f, -0.04620218f, 0.28238332f, 0.18248133f, 
    -0.06843144f, -0.24259375f, -0.19123064f, 0.09586406f, 0.03036416f, -0.15771487f, -0.00875539f, -0.42435843f, 
    -0.15924388f, 0.03043485f, -0.24056660f, 0.32500908f, 0.45064798f, 0.02997330f, 0.33114308f, 0.20188288f, 
    0.14892180f, 0.00566956f, -0.22231385f, -0.03829882f, -0.03057712f, 0.01642731f, 0.01632444f, 0.18777449f, 
    0.11852751f, 0.30944356f, -0.15831624f, -0.24108410f, -0.26304513f, 0.03201671f, 0.11024419f, -0.15515803f, 
    0.01983292f, -0.14207132f, 0.25899196f, 0.20709802f, 0.02005539f, -0.19041257f, 0.11998913f, -0.22175916f, 
    -0.02804066f, 0.14592245f, 0.30495262f, 0.16829190f, -0.50478917f, 0.10791261f, 0.09761342f, -0.12257354f, 
    0.16671559f, -0.18600395f, -0.19472317f, -0.03823589f, 0.07982799f, -0.05879248f, 0.20080665f, -0.25676560f, 
    0.10462561f, 0.30716595f, 0.15811628f, 0.01162157f, -0.05868674f, 0.03203861f, -0.10589090f, 0.35985506f, 
    -0.14516850f, -0.15986562f, 0.04467318f, 0.03070475f, -0.16115029f, 0.02312139f, 0.03031596f, 0.00063504f, 
    -0.01204209f, -0.22284715f, 0.05318787f, 0.15335451f, 0.17580122f, -0.14662987f, 0.23304249f, -0.52740157f, 
    0.03658374f, 0.11184776f, 0.01509399f, 0.11256097f, 0.03761499f, 0.19462928f, -0.11350584f, -0.18318152f, 
    0.20259035f, -0.04559055f, 0.11006425f, 0.24537325f, 0.25514224f, 0.16035758f, 0.01816096f, -0.14605241f, 
    -0.11008789f, -0.04512905f, 0.03583121f, 0.08442858f, -0.07268806f, 0.05112204f, -0.00864587f, -0.00880519f, 
    -0.05175738f, 0.16011183f, 0.07105765f, 0.14465022f, -0.39189073f, -0.03100846f, -0.10385056f, -0.10576493f, 
    0.10817221f, 0.13380192f, -0.07091983f, -0.10245864f, 0.10947525f, 0.13453330f, -0.21066660f, -0.17366533f, 
    0.14686525f, -0.18126015f, 0.16254650f, 0.16037677f, -0.08212333f, -0.18936628f, 0.10322561f, 0.11791662f, 
    -0.02122594f, -0.02405800f, 0.54866111f, 0.01937363f, -0.05225132f, 0.06473179f, -0.10741016f, -0.33372095f, 
    -0.11468483f, -0.17835851f, 0.03276481f, -0.02620798f, -0.26572990f, 0.21188737f, -0.04453418f, -0.00769522f, 
    0.02541627f, 0.01741688f, -0.07676379f, -0.09954706f, 0.11120987f, 0.16612230f, -0.00893179f, -0.20508792f, 
    -0.10230368f, 0.13490798f, -0.17714006f, 0.33940843f, 0.20354520f, 0.03594855f, 0.22359513f, 0.05300898f, 
    0.13973790f, -0.49654317f, 0.03163476f, -0.13491081f, -0.27883098f, -0.21546310f, 0.11102764f, -0.13172179f, 
    0.31163448f, 0.31290191f, 0.04756512f, 0.13566466f, 0.46061254f, 0.33391929f, 0.23334879f, 0.21044815f, 
    -0.07192489f, -0.08513264f, -0.45965809f, 0.00558609f, 0.14449079f, 0.21034062f, 0.02877060f, -0.36328658f, 
    -0.10934559f, 0.08235560f, -0.03301531f, 0.06321388f, -0.38903642f, -0.35681653f, 0.06727775f, -0.03925072f, 
    -0.07072382f, 0.20979215f, 0.02581793f, -0.00075864f, 0.06578995f, -0.05238015f, -0.11685526f, 0.19508445f, 
    -0.08654801f, -0.15952072f, -0.17633586f, -0.13832287f, -0.53261703f, 0.11777031f, -0.12489814f, 0.12400233f, 
    0.36552477f, 0.07171129f, 0.05036290f, -0.17524992f, 0.14169800f, 0.10090744f, -0.00704779f, 0.34735402f, 
    0.20112331f, -0.14430858f, -0.10505924f, 0.12640934f, -0.14849843f, 0.27334860f, 0.31959578f, 0.21194492f, 
    0.21354550f, -0.08677058f, 0.12781923f, -0.25794876f, 0.17132305f, 0.10964429f, -0.11175410f, -0.12529349f, 
    -0.00656151f, -0.26920429f, 0.15671809f, -0.11984219f, -0.24284309f, 0.03245878f, -0.05018849f, 0.15035562f, 
    0.10397177f, -0.24694586f, 0.09429049f, 0.03672071f, 0.27536142f, -0.13785775f, -0.01519083f, -0.09465975f, 
    -0.21388577f, -0.21208197f, 0.12396386f, 0.16576944f, -0.02919722f, 0.25957361f, 0.28406447f, 0.48706737f, 
    -0.30125156f, -0.24555053f, 0.13528991f, -0.29884335f, -0.44248822f, -0.26151192f, -0.27615657f, 0.38840613f, 
    -0.17268936f, -0.09076465f, 0.24394231f, 0.29429784f, 0.20025116f, -0.30587021f, 0.06387275f, 0.37189397f, 
    0.19630544f, 0.08900290f, 0.07485347f, 0.02101970f, -0.00680611f, 0.20422554f, 0.08251335f, 0.03473355f, 
    0.36220598f, 0.25295159f, 0.03233696f, -0.17237507f, 0.11782472f, -0.13338223f, 0.01140145f, -0.17019740f, 
    0.32540795f, -0.07898770f, 0.14248548f, -0.11826231f, -0.10491987f, 0.20112880f, 0.03757870f, -0.02234858f, 
    0.14386803f, -0.30010036f, 0.20783578f, -0.00246918f, -0.21036085f, -0.10773372f, -0.02800024f, 0.34704411f, 
    -0.09252442f, -0.00678501f, -0.14440663f, 0.09759456f, 0.22007704f, -0.18760365f, 0.29417875f, 0.07352947f, 
    0.06680659f, 0.21268967f, 0.16959861f, -0.27577370f, -0.28355342f, -0.11898809f, -0.11697841f, 0.31037295f, 
    -0.14641540f, 0.27906770f, -0.22956188f, 0.10297924f, -0.04132549f, 0.00109112f, 0.08258148f, 0.35543105f, 
    0.16721654f, -0.00656810f, 0.03914491f, 0.04917733f, -0.20555554f, 0.33524901f, 0.21202169f, 0.36421669f, 
    0.25524336f, 0.07901075f, -0.12141258f, -0.04918040f, -0.19313642f, -0.20959932f, -0.17814638f, 0.30750093f, 
    -0.21689725f, 0.08668682f, 0.05667631f, -0.30400804f, -0.23964606f, 0.30792829f, 0.08216427f, 0.23250712f, 
    -0.01363975f, 0.25108805f, -0.24835014f, -0.23880890f, 0.24248749f, -0.03599632f, -0.01841470f, 0.30703455f, 
    0.31040439f, -0.23346697f, -0.03668184f, 0.01773611f, 0.37512961f, 0.15741000f, 0.16090234f, 0.18600534f, 
    -0.07031891f, 0.15513834f, -0.26223025f, 0.08209409f, 0.03065471f, 0.03521408f, 0.06715135f, 0.05341235f, 
    -0.25931507f, 0.02379259f, -0.04742832f, -0.14321941f, -0.02606127f, 0.15166427f, -0.04507639f, -0.44935039f, 
    -0.00887609f, -0.21236968f, -0.13881570f, 0.12032599f, -0.05638304f, 0.17716604f, -0.16139150f, -0.00382578f, 
    0.06018627f, -0.02364569f, -0.19658458f, -0.17587784f, -0.17030233f, -0.05471513f, 0.21941054f, -0.14594167f, 
    0.20549901f, -0.06861835f, -0.11431332f, -0.04012814f, 0.08674378f, -0.06069217f, 0.14117964f, -0.04373386f, 
    0.22827736f, -0.08229136f, -0.13223425f, -0.15574741f, -0.09558262f, -0.07655603f, -0.30985093f, 0.03980316f, 
    0.17782548f, -0.17094357f, 0.19175047f, -0.02454613f, -0.25695693f, -0.08234774f, -0.02039566f, -0.13864185f, 
    0.11447784f, 0.00092696f, 0.17849790f, 0.13327566f, -0.30077913f, -0.11578452f, 0.07113630f, 0.36759710f, 
    -0.07093462f, 0.00125973f, -0.21009330f, -0.11134967f, 0.20731282f, -0.04713079f, -0.00370059f, 0.17470203f, 
    0.07256451f, -0.03565381f, -0.02756730f, -0.07863085f, -0.16105658f, -0.17523336f, -0.04618764f, 0.28886065f, 
    -0.17116895f, 0.06418264f, 0.14739834f, -0.15517119f, -0.19012880f, 0.00142984f, -0.13888529f, 0.08983067f, 
    0.17757699f, 0.09534716f, -0.17968884f, -0.12623562f, 0.06745812f, -0.13050902f, -0.16229181f, 0.11559914f, 
    -0.15628642f, -0.17641160f, 0.07228703f, -0.15641958f, -0.05183589f, -0.01277184f, -0.20238985f, -0.04329691f, 
    -0.17724693f, -0.14390452f, -0.04149066f, 0.07411553f, -0.08710197f, 0.06486964f, -0.10563479f, 0.00306954f, 
    -0.36418554f, -0.22791903f, 0.14455383f, -0.29566365f, 0.05230630f, -0.44499794f, -0.34101462f, 0.02858788f, 
    0.17112304f, 0.44430512f, 0.22246286f, 0.18837759f, -0.58874774f, -0.01000687f, 0.05074765f, 0.10051141f, 
    0.00214391f, -0.39035544f, -0.24161164f, -0.00368909f, 0.00277061f, 0.31663680f, -0.18257757f, -0.12247346f, 
    0.00648842f, 0.02244733f, 0.02410402f, 0.21127583f, 0.21874413f, -0.17832005f, 0.25502220f, 0.13646486f, 
    0.18963285f, 0.12972316f, -0.18953808f, -0.12058586f, 0.08861420f, 0.20221275f, -0.01168751f, 0.12008437f, 
    0.30219200f, 0.06471138f, 0.02292266f, -0.09159052f, 0.09529553f, 0.02480084f, -0.10118063f, 0.09121685f, 
    -0.33531961f, 0.17470637f, 0.09449239f, -0.02644543f, -0.19583535f, -0.06771548f, 0.17779075f, -0.17939281f, 
    0.18849091f, -0.07397529f, -0.04802267f, -0.02760686f, -0.00467967f, 0.00716811f, -0.23841415f, -0.26730582f, 
    -0.41420656f, 0.04601627f, -0.13128191f, 0.10344397f, 0.30288112f, -0.11134174f, -0.01986181f, 0.23691310f, 
    -0.03732741f, 0.22984551f, 0.19582547f, -0.13772719f, -0.29084992f, 0.16983697f, -0.11324700f, 0.23617445f, 
    0.05054393f, -0.02837369f, -0.16835931f, 0.05924402f, 0.02210529f, 0.10238672f, -0.06832523f, 0.02070643f, 
    0.24711604f, 0.04403202f, -0.04761967f, -0.02993122f, -0.00110676f, 0.00201966f, 0.07607890f, -0.11015216f, 
    0.22362247f, 0.24147871f, 0.31537801f, -0.15652950f, -0.38739046f, -0.10105174f, -0.06226133f, -0.03534591f, 
    0.02722876f, -0.49209836f, 0.08405481f, -0.21639779f, -0.07632119f, 0.00834701f, -0.01147134f, -0.11009232f, 
    0.06747044f, 0.13193952f, 0.03008503f, -0.12855102f, 0.23782188f, -0.10696951f, 0.18062063f, 0.16719848f, 
    -0.12522849f, 0.04243575f, 0.02025953f, 0.01759024f, 0.37543362f, 0.21164860f, 0.17871574f, -0.19337715f, 
    0.11006044f, 0.31999490f, 0.38320467f, -0.05122422f, -0.20337628f, -0.00119074f, 0.29982707f, -0.40828705f, 
    0.23972626f, 0.20966874f, 0.27644050f, -0.02654845f, 0.11665779f, -0.15551053f, 0.02679732f, 0.13135117f, 
    -0.32139006f, 0.06272084f, -0.01886221f, 0.11889528f, -0.13375154f, -0.06927976f, 0.09007851f, 0.06605102f, 
    -0.00490280f, -0.12672959f, 0.06640748f, -0.17269777f, 0.25895250f, -0.04115665f, -0.12033056f, -0.20989253f, 
    0.14403962f, 0.04490450f, 0.33868888f, 0.01942084f, 0.02375513f, -0.26144463f, 0.21282692f, -0.32425696f, 
    0.19184029f, 0.31704214f, 0.14658956f, 0.18984050f, 0.47572035f, -0.04023982f, 0.00975650f, -0.19245686f, 
    0.04642223f, -0.03590487f, -0.30236280f, 0.01799052f, 0.18500447f, -0.16761085f, 0.10258140f, -0.00063135f, 
    -0.25593343f, 0.11585021f, -0.08539204f, -0.05134273f, 0.27746689f, 0.06571794f, -0.28710315f, 0.14115411f, 
    0.13059580f, 0.10459831f, -0.00626450f, 0.07895194f, -0.38353136f, -0.24329981f, 0.07482054f, -0.24206322f, 
    0.10558001f, 0.10002343f, 0.26704860f, 0.11811992f, 0.37445760f, 0.20110324f, 0.05184730f, 0.34686485f, 
    -0.23572153f, -0.07344922f, -0.11007340f, 0.08223034f, -0.00825395f, -0.13105738f, 0.14112009f, 0.32810396f, 
    0.40197662f, -0.29084992f, 0.18349345f, -0.02725432f, -0.09006000f, -0.25222459f, -0.19722410f, -0.13195558f, 
    -0.36136544f, 0.03956848f, -0.17530024f, -0.09322842f, 0.15827732f, 0.03159810f, 0.24752805f, 0.23216304f, 
    -0.19145830f, 0.08022967f, -0.05559620f, 0.08171318f, -0.07913085f, -0.29923362f, 0.26584098f, -0.19625919f, 
    -0.17412907f, 0.15341282f, -0.01087662f, 0.15272655f, -0.27262548f, 0.18651593f, 0.14869300f, 0.27785474f, 
    -0.23946446f, 0.07058247f, -0.07922170f, -0.16745047f, 0.16006073f, -0.01456164f, 0.04245178f, -0.37591431f, 
    -0.18409473f, -0.17367031f, 0.50066817f, -0.17749472f, 0.06986790f, -0.26327354f, -0.09472540f, -0.30455795f, 
    0.13703494f, 0.48871440f, 0.35354921f, -0.12920323f, -0.04253295f, 0.37150198f, -0.16747552f, 0.02706305f, 
    0.11908513f, -0.10110921f, -0.19524027f, 0.01557851f, -0.14343010f, -0.00232601f, -0.16636419f, -0.04013651f, 
    -0.06399658f, -0.27278239f, 0.14590152f, 0.05753347f, 0.20454513f, -0.14689592f, 0.18352337f, 0.31158167f, 
    0.01101849f, 0.13914637f, -0.27372149f, 0.19315627f, 0.19649348f, -0.06006094f, 0.09564364f, -0.04435067f, 
    0.17520098f, 0.39181510f, 0.16061594f, 0.14683548f, 0.19712463f, -0.01741686f, -0.24468672f, -0.16969706f, 
    0.25942758f, 0.02182649f, -0.05912715f, -0.10678587f, -0.00149022f, 0.07858446f, 0.18743967f, 0.18475419f, 
    0.19241647f, -0.22643711f, -0.03597772f, -0.21132551f, 0.09623944f, 0.15990776f, -0.37621447f, 0.23279685f, 
    -0.21115623f, 0.04864388f, 0.20655507f, -0.43878955f, -0.16509540f, 0.21555468f, -0.16532931f, -0.22489956f, 
    -0.29788029f, 0.07046910f, -0.15728071f, -0.00634094f, -0.28578457f, 0.21219404f, 0.00264186f, -0.40867692f, 
    0.12652583f, -0.09924334f, -0.15040234f, 0.15523335f, 0.15759696f, -0.30608752f, 0.09512588f, 0.02432137f, 
    -0.04535303f, 0.15278761f, 0.04106266f, -0.29530334f, -0.19269964f, 0.10413063f, -0.27594516f, 0.07796344f, 
    -0.20039438f, 0.19660252f, -0.32242307f, 0.01160114f, 0.14307994f, 0.15376019f, 0.02349024f, 0.42862195f, 
    -0.05327285f, 0.04091573f, 0.13891454f, -0.03821767f, -0.06619731f, 0.15411709f, -0.14591320f, 0.33594987f, 
    0.07153752f, -0.19584779f, 0.20317370f, -0.01994062f, -0.06697693f, -0.08858464f, 0.09109888f, 0.43380255f, 
    -0.26439512f, 0.01654286f, 0.03389272f, 0.01595490f, -0.08183151f, 0.34526899f, -0.03145510f, 0.09346577f, 
    -0.05131324f, -0.30282497f, 0.02726759f, -0.18084688f, 0.03338642f, -0.54604954f, -0.03582952f, -0.16757104f, 
    0.20443803f, 0.27428654f, 0.05791075f, 0.33296409f, 0.00446151f, -0.35531095f, -0.12492280f, 0.12194350f, 
    -0.10076111f, -0.51144654f, -0.08946214f, -0.11351371f, 0.21679807f, 0.20005377f, 0.20768310f, 0.07473635f, 
    0.24726100f, -0.04056888f, 0.10807415f, -0.17622413f, -0.44240552f, -0.06825455f, -0.08185118f, 0.38017058f, 
    0.02886446f, 0.10590816f, 0.24597904f, -0.03065779f, -0.15028518f, 0.17761858f, 0.13094190f, -0.26981589f, 
    0.13677929f, 0.15515995f, 0.20866294f, -0.26071084f, 0.38142422f, 0.28542006f, 0.02200793f, 0.61134404f, 
    0.09746434f, 0.09896797f, -0.14913808f, 0.04707836f, 0.05696373f, 0.05709094f, 0.07618566f, 0.04278487f, 
    -0.24056192f, -0.10649596f, 0.05220127f, -0.10804100f, -0.05456639f, 0.16176516f, 0.03883738f, -0.05152261f, 
    0.08180546f, 0.07900264f, -0.12543140f, -0.03360596f, -0.03344737f, 0.08843387f, 0.12984820f, -0.12008563f, 
    0.09876551f, -0.01400089f, -0.19286118f, -0.11610205f, 0.00833141f, -0.07859026f, -0.10591947f, -0.09974153f, 
    0.16329783f, 0.17582475f, 0.05976452f, -0.08247620f, -0.11491261f, -0.01712957f, -0.09566607f, 0.07641697f, 
    -0.12629947f, 0.14461796f, -0.08919278f, -0.13309942f, 0.15237489f, 0.44353250f, -0.04174558f, 0.23878114f, 
    0.08284434f, 0.06433314f, -0.19654351f, 0.12271012f, -0.25202212f, 0.15028228f, 0.06417149f, 0.34661046f, 
    0.04642447f, -0.08464041f, -0.07141196f, 0.23122856f, 0.38215098f, -0.01448260f, -0.12010750f, -0.23676915f, 
    -0.27429637f, 0.14599758f, -0.02534947f, 0.15537284f, 0.12620904f, 0.20832111f, 0.15484281f, -0.03849952f, 
    -0.13910262f, -0.09913579f, 0.14802152f, 0.13617252f, 0.08630025f, -0.35945687f, -0.21926388f, -0.22632623f, 
    -0.02467351f, 0.24738716f, 0.05915595f, -0.04452023f, 0.32767749f, 0.08727537f, 0.03505546f, 0.23357457f, 
    0.13994327f, -0.08823515f, 0.05851046f, 0.22672346f, -0.31252971f, -0.17528492f, -0.31112698f, -0.66003042f, 
    0.03347723f, 0.06012317f, 0.08088154f, -0.00029832f, -0.17101955f, 0.16550171f, 0.21451962f, -0.03002285f, 
    0.11807837f, -0.23872727f, -0.08588272f, 0.11225835f, -0.04525696f, 0.12842663f, -0.04277218f, 0.12636872f, 
    0.18653475f, -0.11045276f, 0.23140660f, -0.02897911f, -0.01459161f, -0.14909679f, -0.18634653f, -0.04590912f, 
    0.17551583f, -0.06452191f, -0.00620049f, 0.00353670f, 0.34785607f, 0.11826778f, 0.30968451f, -0.47459909f, 
    0.14970347f, -0.00797027f, -0.08797921f, 0.16623832f, 0.03397093f, 0.21094336f, -0.19765384f, -0.24958906f, 
    -0.16698149f, 0.20095135f, -0.07980212f, 0.32518953f, 0.07111023f, -0.15431763f, 0.15202734f, -0.04099999f, 
    0.24179681f, 0.19352190f, 0.11069560f, -0.07540748f, 0.20088151f, -0.05999356f, 0.05923994f, 0.18811597f, 
    0.02387624f, -0.31605548f, -0.28202322f, 0.30137956f, -0.11464307f, 0.10146131f, -0.13571584f, -0.34900853f, 
    0.20734029f, -0.07818209f, -0.18259901f, -0.13744505f, 0.15518239f, 0.01187188f, -0.02203203f, 0.05246287f, 
    -0.03903766f, 0.02834128f, 0.00347581f, 0.30719975f, 0.03543986f, 0.41351971f, 0.17086525f, 0.53260839f, 
    0.05232126f, 0.12007663f, 0.34934130f, 0.09172912f, 0.04395325f, -0.12633926f, -0.02898681f, -0.14498831f, 
    -0.10116310f, -0.08752229f, 0.33007914f, 0.15355313f, -0.09706066f, 0.22570334f, -0.02941045f, -0.19714245f, 
    -0.09493249f, 0.09036172f, 0.12615161f, 0.02879974f, -0.16672811f, -0.20531434f, 0.11115421f, -0.15370677f, 
    0.21085140f, 0.29493123f, -0.15791072f, 0.09301457f, 0.35826555f, -0.02027852f, -0.04206317f, -0.30316371f, 
    -0.07554516f, 0.10459225f, 0.38323453f, 0.18880415f, -0.18602809f, -0.14396687f, 0.19247116f, -0.35837847f, 
    -0.26149869f, -0.11617148f, -0.18981664f, 0.03756047f, -0.39698082f, 0.05456880f, -0.14669274f, -0.06493530f, 
    0.37273967f, 0.03899055f, 0.19302520f, -0.01575013f, 0.17266083f, -0.08980317f, 0.03538083f, 0.16298991f, 
    0.17667007f, -0.08023347f, 0.05065349f, 0.29043075f, 0.30075625f, 0.20439723f, 0.25112084f, 0.31835690f, 
    -0.14594606f, 0.26812527f, 0.06233687f, -0.04248774f, -0.04933169f, 0.05881235f, 0.13005307f, -0.13591152f, 
    -0.16912493f, 0.00507643f, 0.17547181f, -0.09238251f, -0.18462032f, 0.43295375f, -0.14057249f, 0.22589657f, 
    -0.15248570f, -0.05150600f, 0.17228742f, 0.10743169f, 0.15554169f, 0.02500410f, 0.06527989f, 0.23965813f, 
    0.07236471f, -0.23579803f, 0.17615229f, 0.18220095f, 0.47795695f, 0.25150335f, -0.13221127f, -0.15960826f, 
    -0.00030707f, 0.09213471f, -0.19239765f, 0.01825533f, 0.03055266f, 0.06028203f, 0.09274630f, 0.09296029f, 
    0.15823737f, -0.01662615f, 0.13303062f, -0.05264505f, -0.03078154f, 0.23536424f, -0.05769085f, 0.42091605f, 
    -0.28919265f, 0.06421113f, -0.01657031f, -0.13046961f, 0.00079073f, -0.18572626f, 0.06077162f, 0.02540278f, 
    0.07874830f, -0.12492576f, -0.13111496f, -0.17638591f, 0.09434839f, 0.32718977f, -0.00211367f, -0.32609224f, 
    -0.06650944f, -0.00256335f, 0.07123183f, 0.07843484f, 0.06025213f, -0.14198732f, -0.18533719f, 0.06494094f, 
    -0.08300972f, -0.13033716f, -0.16276146f, 0.01140577f, -0.00406295f, 0.38167164f, -0.03109853f, -0.13495743f, 
    0.35788035f, -0.13456841f, -0.01846864f, 0.02863970f, 0.00683920f, 0.21601528f, -0.10013746f, 0.14446233f, 
    0.09526397f, 0.06813437f, 0.09751584f, 0.21832699f, 0.24990496f, 0.23754969f, 0.27617916f, 0.18178099f, 
    -0.24635519f, 0.10507564f, -0.07008067f, -0.16771372f, -0.09152269f, -0.25599638f, -0.35126129f, 0.40088442f, 
    0.00830359f, -0.30956340f, 0.28531998f, 0.08542778f, 0.16655084f, -0.13949648f, 0.22787350f, 0.26974294f, 
    0.22904529f, 0.20044850f, -0.38374627f, -0.13861887f, 0.00220513f, 0.26109335f, -0.00509301f, -0.11961742f, 
    -0.03668878f, 0.19095650f, 0.08516045f, -0.30292359f, 0.22897865f, -0.13959956f, -0.01771193f, 0.04863647f, 
    0.07772045f, -0.14893574f, -0.06294995f, -0.06518177f, -0.06466347f, -0.16118364f, 0.05251760f, 0.00544950f, 
    0.03245978f, 0.06747946f, 0.05182580f, -0.17247988f, -0.09529088f, -0.08148703f, -0.00194698f, 0.12434564f, 
    -0.17154214f, -0.17018297f, 0.07528692f, -0.11668076f, -0.14075848f, 0.01610932f, -0.17294887f, -0.15358728f, 
    0.13938802f, -0.06711135f, -0.12890504f, -0.00466780f, -0.16407707f, -0.13226032f, -0.15691432f, -0.08938131f, 
    -0.08776664f, -0.14534636f, -0.06391070f, -0.05315294f, 0.02050662f, -0.05341209f, -0.01962602f, 0.45534602f, 
    -0.29990631f, -0.02189104f, 0.05619728f, 0.09190420f, -0.69198287f, -0.05608781f, -0.04453026f, 0.42239085f, 
    0.33243442f, -0.10258673f, 0.16168003f, -0.03921142f, 0.04307026f, -0.03262242f, -0.10338227f, 0.43224275f, 
    0.27274925f, -0.07697240f, -0.13047014f, 0.34566498f, 0.26950949f, 0.15320434f, 0.37767759f, 0.12814230f, 
    -0.11223730f, 0.07747014f, -0.00949667f, -0.17619716f, 0.08528304f, 0.07230604f, 0.10420082f, -0.10438413f, 
    -0.00665146f, 0.05598864f, -0.18754049f, 0.07929604f, 0.08947885f, -0.17465417f, -0.07824954f, -0.06406491f, 
    -0.15319614f, -0.09452188f, -0.13077514f, -0.06719550f, -0.03279890f, -0.15906823f, -0.11787021f, -0.17387509f, 
    -0.19474711f, -0.11158229f, -0.14638060f, -0.08834384f, -0.10483799f, -0.16556209f, -0.17367238f, 0.02329470f, 
    0.06662621f, 0.16976124f, 0.21613544f, 0.01652834f, -0.22291648f, 0.01718037f, -0.12866074f, -0.19315961f, 
    -0.19627675f, 0.08770851f, -0.17759033f, -0.02313390f, 0.13535379f, 0.05151450f, 0.19178033f, -0.38529691f, 
    0.17246780f, -0.01012034f, 0.11911802f, -0.04748001f, 0.11813033f, 0.25134957f, 0.14350088f, -0.08927055f, 
    -0.25821373f, -0.09780812f, -0.09284067f, 0.13022636f, 0.52863866f, 0.35640591f, 0.29268488f, 0.20981602f, 
    0.02781967f, 0.29954353f, -0.13898979f, -0.05699710f, 0.19972947f, -0.07988904f, 0.12942353f, 0.07715242f, 
    0.13640508f, -0.28050661f, 0.24435306f, -0.01591824f, 0.12758955f, -0.05311562f, -0.15031743f, 0.29498956f, 
    -0.12330683f, 0.14290452f, 0.01716966f, -0.12426441f, -0.08773375f, -0.03290635f, 0.06961820f, 0.13545713f, 
    -0.12217547f, -0.28400677f, -0.01490920f, -0.32931402f, 0.01885404f, 0.06736594f, -0.11908387f, -0.22107129f, 
    -0.33179009f, 0.12936088f, -0.06821632f, -0.11449836f, 0.44653568f, 0.09572942f, 0.20952302f, 0.23288852f, 
    0.08671807f, 0.21208455f, 0.08755478f, 0.01669725f, -0.46612221f, -0.07024334f, 0.11100518f, -0.50270969f, 
    0.24025923f, 0.02025882f, -0.02797710f, 0.15013877f, -0.05885705f, 0.07306651f, -0.11806387f, 0.02599718f, 
    -0.16741855f, -0.12653613f, -0.01401835f, -0.08651458f, -0.00554955f, 0.15680523f, -0.18391307f, 0.08919007f, 
    0.07899957f, -0.02644448f, -0.11223607f, 0.18019025f, -0.25559139f, -0.06759164f, -0.04825420f, -0.08371050f, 
    0.10363855f, 0.05683884f, 0.21200949f, 0.07653667f, 0.23507044f, 0.25471020f, 0.07126189f, -0.12149830f, 
    -0.00072379f, 0.07677551f, -0.08025762f, 0.06984711f, 0.08775770f, -0.06246088f, -0.02365672f, 0.20205238f, 
    0.21682476f, 0.12477444f, -0.17661087f, -0.10633101f, -0.35556105f, -0.20394522f, -0.03134754f, 0.13578090f, 
    -0.11146431f, -0.14340144f, 0.03211169f, 0.15281813f, 0.27863657f, -0.10379671f, -0.12435109f, -0.15140778f, 
    0.21086885f, 0.24569039f, 0.33558720f, 0.23794788f, -0.13032474f, -0.06736691f, 0.07484764f, -0.37880251f, 
    0.03443751f, 0.10468557f, 0.10305835f, 0.08374994f, -0.21567069f, 0.07055791f, 0.08598308f, -0.03731463f, 
    0.12390810f, 0.02293341f, 0.00498132f, -0.14457107f, -0.33869171f, -0.34588540f, -0.22371452f, 0.30084997f, 
    -0.20327795f, 0.13209422f, 0.07330795f, 0.19076692f, 0.04941015f, 0.03384388f, 0.06216250f, -0.07067360f, 
    -0.15527768f, 0.01748283f, 0.16663921f, 0.13312845f, -0.14794432f, -0.00880871f, -0.07489821f, 0.03147892f, 
    0.09275170f, -0.06812018f, -0.13024256f, 0.06136907f, 0.06111391f, -0.01785750f, -0.03761257f, -0.17758238f, 
    0.28762454f, 0.21798697f, 0.06245462f, 0.26458287f, 0.32764068f, 0.20973916f, -0.15151916f, -0.24899293f, 
    0.14196609f, 0.21710698f, -0.00938201f, -0.03377818f, -0.11935380f, 0.01057543f, 0.00696821f, -0.28107506f, 
    0.29032847f, 0.07987668f, -0.00543684f, -0.04779399f, 0.20629741f, 0.28073841f, 0.06880167f, 0.04588926f, 
    -0.24012707f, -0.00186073f, -0.01494761f, 0.01250969f, 0.08773690f, -0.10402212f, 0.05237618f, -0.08013796f, 
    -0.25007433f, -0.01217251f, 0.13587682f, 0.05015618f, 0.03230643f, 0.16084839f, 0.15896444f, -0.12308478f, 
    -0.05669899f, 0.16687290f, 0.06060423f, 0.19382814f, 0.17518212f, -0.18913491f, 0.10548128f, -0.07527211f, 
    0.25350073f, 0.01444621f, 0.25527281f, 0.18368085f, 0.20189975f, 0.05898717f, 0.21919921f, 0.09398526f, 
    0.06567878f, 0.28733170f, -0.39064398f, -0.13181870f, -0.13765781f, -0.18260483f, -0.22022770f, -0.31626931f, 
    -0.11382792f, 0.44110748f, 0.03889536f, -0.16740566f, 0.12304143f, 0.09535738f, 0.03119503f, 0.04037841f, 
    0.12682563f, -0.00406373f, 0.03318213f, -0.07219168f, 0.04180128f, -0.06972642f, -0.00618104f, 0.21335751f, 
    -0.07711560f, -0.20317054f, -0.06497782f, 0.15177734f, -0.00654974f, -0.03272676f, 0.21051097f, -0.43914673f, 
    0.18871176f, -0.04336320f, 0.03086458f, -0.09364884f, 0.11643482f, 0.26323581f, -0.06543342f, -0.26824573f, 
    -0.15727232f, -0.02507895f, -0.08565714f, 0.08843670f, 0.07596825f, 0.27731740f, 0.06143075f, -0.00276985f, 
    0.24040970f, -0.01630202f, 0.35131374f, 0.03610837f, 0.19019085f, -0.07313532f, 0.01547633f, -0.11090569f, 
    0.20811790f, 0.27756077f, 0.10220941f, -0.24373330f, 0.03925071f, 0.16543505f, -0.19796939f, -0.07024204f, 
    -0.00690444f, -0.07269188f, 0.01771903f, -0.07323181f, 0.12676302f, 0.17751057f, -0.08400506f, -0.11137154f, 
    -0.41537672f, -0.30324581f, 0.08126995f, 0.08755474f, 0.19325562f, 0.02915654f, 0.03944435f, 0.01220298f, 
    -0.02931253f, 0.22501372f, -0.05100506f, 0.02624208f, 0.10871404f, 0.10425212f, 0.12394264f, 0.20113249f, 
    0.02771268f, 0.05446782f, 0.13722342f, -0.02683756f, -0.12723173f, -0.06058342f, -0.19222391f, 0.28432298f, 
    -0.13086683f, -0.00843061f, 0.14992748f, -0.15376748f, -0.21253774f, -0.12395559f, -0.01639648f, 0.00871271f, 
    0.09954064f, -0.02345894f, -0.13540521f, -0.03886668f, -0.03970509f, 0.27694499f, -0.16581960f, -0.46462861f, 
    -0.18109992f, 0.07169222f, -0.11605127f, 0.12650667f, 0.00185282f, 0.19727394f, -0.10803040f, 0.24424943f, 
    0.18930401f, -0.07458536f, 0.36349395f, -0.05901887f, -0.26748422f, 0.28227541f, -0.24600038f, 0.34831253f, 
    -0.18779311f, 0.11453596f, 0.01460903f, 0.00607626f, -0.13660775f, -0.03824283f, -0.01454444f, 0.22503181f, 
    0.21659914f, -0.30968928f, 0.06602695f, -0.07292449f, -0.24248841f, -0.04196061f, 0.05490980f, -0.18333089f, 
    0.00301338f, 0.15052609f, -0.19812247f, 0.10046415f, 0.14934237f, -0.15752736f, -0.09642269f, -0.16088778f, 
    -0.09815197f, -0.11018106f, -0.18232743f, 0.21743837f, 0.09556720f, -0.06433610f, -0.03320476f, 0.13886282f, 
    -0.13454807f, 0.10018630f, 0.12068852f, -0.01144443f, -0.17648605f, -0.17477842f, -0.02808508f, -0.14084458f, 
    -0.33561805f, -0.14027862f, 0.05329697f, -0.01744529f, -0.09063206f, -0.10101049f, -0.17163642f, -0.27826628f, 
    -0.11225142f, 0.12845168f, -0.06421790f, 0.05370720f, -0.08528552f, -0.03659280f, -0.01966366f, 0.07768521f, 
    -0.17567933f, -0.01896850f, 0.09095296f, -0.14241067f, -0.05750890f, -0.07730974f, -0.04732611f, -0.16159984f, 
    -0.07214519f, -0.04763367f, -0.05834949f, 0.15707740f, -0.04681285f, 0.00264319f, 0.13337876f, -0.16783015f, 
    0.05434688f, -0.13003016f, -0.13518928f, -0.13580030f, 0.11592294f, -0.03330724f, -0.14737262f, -0.17260548f, 
    0.05053654f, 0.18160604f, 0.22715580f, 0.06947937f, -0.19224672f, 0.10912094f, -0.01722428f, 0.08670605f, 
    -0.34604964f, 0.05284224f, -0.14800940f, -0.15170005f, -0.23871480f, 0.09279598f, 0.20473211f, -0.16716242f, 
    0.39974684f, -0.17278095f, 0.02260273f, 0.09299683f, -0.07011932f, 0.16699304f, 0.11950990f, -0.00213987f, 
    0.09437053f, 0.04343941f, -0.04423414f, 0.33191013f, 0.65424621f, 0.40944225f, 0.03828713f, -0.12532738f, 
    -0.20881169f, -0.02393979f, 0.30395719f, -0.24512085f, -0.39523941f, -0.20899110f, 0.11746708f, 0.09286967f, 
    -0.20027192f, -0.20727628f, 0.35979193f, 0.02973855f, -0.20243464f, -0.19852829f, 0.18140407f, 0.48306814f, 
    0.00608193f, 0.02055587f, 0.06689308f, -0.16703853f, 0.32198966f, 0.11843076f, 0.07592541f, -0.12630597f, 
    0.46433404f, -0.05158702f, 0.17917702f, 0.05675009f, 0.17262265f, -0.29147995f, 0.18974234f, -0.11062320f, 
    -0.20416848f, 0.11615559f, 0.07559203f, 0.10288042f, -0.06480712f, -0.12580016f, 0.15350512f, 0.29115564f, 
    -0.06842075f, -0.04123537f, 0.16886698f, 0.10031679f, -0.33574837f, 0.35696143f, -0.18160519f, 0.35735279f, 
    -0.06573844f, -0.08323859f, 0.15955056f, -0.16495311f, -0.03001494f, 0.01947785f, -0.15015468f, 0.11754005f, 
    0.39778632f, -0.04535972f, 0.09009077f, -0.20333818f, -0.42055181f, -0.34120581f, 0.19426568f, 0.32882106f, 
    0.22502893f, -0.04583836f, -0.08317283f, -0.07368635f, -0.37436166f, 0.01079721f, 0.29233900f, -0.22090372f, 
    0.14070360f, -0.16989134f, -0.03254307f, 0.18705557f, 0.38223535f, -0.27177224f, 0.04828642f, 0.28780422f, 
    0.02633739f, 0.05119284f, 0.03230526f, 0.00451371f, 0.26808986f, -0.16047275f, 0.29361847f, 0.05832973f, 
    -0.04326356f, 0.01354082f, 0.07400670f, -0.39948946f, -0.08910719f, -0.00684848f, -0.14501813f, 0.19047698f, 
    -0.02969859f, -0.23624854f, 0.10797100f, -0.04732227f, 0.00577505f, 0.01946229f, 0.18417612f, 0.04246918f, 
    0.11713704f, 0.24639772f, -0.02532688f, 0.21849501f, -0.23906568f, -0.29309645f, -0.02224410f, -0.39783004f, 
    0.00267281f, -0.15075448f, 0.20495293f, 0.00047704f, 0.11373269f, 0.29560831f, -0.00561628f, -0.34536105f, 
    0.09239694f, 0.00177133f, 0.05832062f, 0.21610223f, -0.28846240f, -0.32039797f, 0.06905778f, 0.19394749f, 
    0.09869609f, -0.15434545f, -0.01369784f, 0.09589154f, -0.07605575f, -0.18762685f, -0.02273713f, 0.02870217f, 
    0.16516009f, -0.16312741f, 0.07788517f, 0.30300844f, -0.39504865f, -0.33011550f, -0.28629419f, -0.44742993f, 
    0.05173174f, 0.00290194f, 0.17221446f, -0.04024074f, 0.15458916f, -0.00784983f, 0.18493675f, -0.00186447f, 
    0.44735444f, -0.10449727f, 0.08902367f, -0.17537685f, -0.18231255f, -0.42095602f, 0.03132360f, 0.20848615f, 
    -0.19161656f, 0.24395575f, 0.22586326f, -0.09510250f, -0.16905475f, -0.19138649f, 0.02602792f, 0.28755802f, 
    -0.03357159f, -0.32044616f, 0.19050384f, -0.07607149f, -0.07499673f, -0.06910831f, 0.08394292f, -0.16547608f, 
    -0.02309202f, 0.18137042f, 0.22472300f, 0.12791122f, 0.11916248f, -0.07254568f, 0.08869738f, 0.15435793f, 
    0.27049738f, -0.20649907f, 0.02655299f, -0.30170649f, 0.37058088f, 0.34296834f, -0.21724540f, -0.11200739f, 
    -0.17490065f, -0.07030147f, -0.33449268f, 0.04946658f, 0.08083855f, -0.24192284f, 0.01739797f, 0.23629205f, 
    0.27609375f, 0.10972103f, -0.06805519f, 0.25948673f, 0.03930285f, 0.10600930f, -0.07583249f, -0.10730425f, 
    -0.02759695f, -0.09339896f, -0.07329891f, 0.09735316f, 0.00832790f, 0.23945597f, -0.12797494f, -0.04239841f, 
    -0.07605800f, -0.12584946f, 0.01907547f, -0.08280949f, -0.44928104f, -0.10938253f, 0.11347228f, 0.07656598f, 
    -0.12421617f, -0.15905815f, -0.10889795f, -0.14141449f, 0.00389346f, -0.09241049f, -0.19735847f, -0.02931657f, 
    -0.12195826f, 0.05990873f, -0.09839458f, -0.14645678f, 0.10378903f, -0.16898149f, 0.15469755f, -0.12117191f, 
    -0.08880069f, -0.06775402f, -0.06492572f, -0.03116298f, 0.10315046f, -0.02007724f, -0.19658220f, -0.05244759f, 
    0.11665782f, 0.02592186f, 0.04867391f, 0.08098035f, -0.01394440f, -0.13863152f, -0.16818000f, -0.06080444f, 
    0.28172570f, 0.03247236f, 0.02651938f, 0.10103089f, 0.03594506f, -0.16285953f, 0.18691716f, -0.21469659f, 
    0.29103735f, -0.22353384f, 0.06596609f, 0.13355263f, 0.33249688f, -0.42755610f, 0.05676458f, 0.05025779f, 
    -0.10671473f, -0.17943758f, -0.01633361f, -0.10760209f, 0.26105598f, 0.10949480f, 0.07288069f, -0.15544289f, 
    0.30999970f, 0.15922065f, 0.13257244f, -0.19242737f, -0.31493989f, -0.30157277f, 0.05457802f, 0.23992524f, 
    0.02151861f, -0.03066169f, -0.19253647f, 0.01598662f, 0.06889588f, -0.16099288f, -0.08081680f, -0.13731202f, 
    0.14536826f, -0.17358597f, -0.18026471f, 0.12147762f, 0.48044628f, -0.05027489f, 0.34827748f, 0.06862944f, 
    -0.09505218f, 0.22453931f, 0.10800176f, -0.03435861f, -0.02662832f, 0.09256034f, -0.14704625f, -0.31506675f, 
    -0.09926632f, 0.26604772f, 0.11387798f, -0.21684116f, -0.00957042f, 0.18368088f, -0.25347266f, 0.09280097f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.20771056f, -0.09343245f, 0.02618498f, -0.08924484f, 0.19518857f, 0.19924636f, 0.18313694f, 0.15244195f, 
    -0.02537305f, -0.05284311f, 0.23566851f, -0.06609014f, 0.07271522f, 0.00001048f, 0.10862435f, 0.20358455f, 
    0.26947293f, -0.16170688f, 0.00280287f, 0.18727864f, 0.06237770f, 0.01366594f, 0.03909061f, -0.11148845f, 
    0.06761886f, 0.04427787f, 0.15837342f, -0.17287740f, 0.38281104f, 0.07619950f, -0.14984019f, 0.10150489f, 
    0.07078871f, 0.01476682f, -0.09805035f, -0.03378254f, 0.13632393f, -0.07451171f, 0.04093206f, 0.18649177f, 
    0.12526624f, 0.22365922f, 0.16604544f, -0.02901017f, -0.21327081f, 0.18408890f, 0.16005619f, 0.15012659f, 
    -0.08913582f, 0.23089445f, 0.13171127f, 0.09791303f, 0.16603024f, -0.06150519f, 0.03291835f, 0.01013610f, 
    -0.02260048f, -0.06543916f, 0.16565579f, 0.22196420f, 0.27401400f, 0.05630713f, -0.08394568f, -0.06206682f, 
    0.22541331f, 0.08073428f, -0.15440494f, 0.01718669f, -0.05173033f, 0.20879048f, 0.27209714f, 0.27249047f, 
    0.04580647f, 0.06739773f, -0.17137134f, 0.19638188f, -0.05146515f, -0.04028078f, 0.08052877f, -0.01956610f, 
    0.18006697f, -0.05076613f, 0.07830716f, 0.02149932f, -0.07713951f, 0.06063016f, -0.16370872f, -0.06157429f, 
    0.26432809f, 0.22764735f, -0.22863936f, 0.02892147f, 0.12979002f, 0.03469606f, 0.04967286f, 0.10820169f, 
    0.12364510f, 0.07839768f, -0.16166614f, 0.01409094f, -0.15138198f, -0.01265152f, 0.11154966f, -0.04087800f, 
    0.04220679f, 0.21349043f, -0.15051825f, 0.09259907f, -0.02403769f, 0.06872722f, 0.24459380f, 0.25313506f, 
    0.19272295f, 0.17085940f, 0.10855954f, -0.07991384f, -0.17928243f, 0.00393782f, -0.10139067f, -0.24074793f, 
    0.28137743f, 0.11695456f, -0.06338130f, -0.08525099f, -0.13713096f, 0.09619077f, 0.12326062f, 0.20047277f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.35882920f, -0.10089155f, 0.07955650f, 0.19090077f, 0.06564226f, -0.29711086f, 0.12161598f, -0.20887858f, 
    -0.01831909f, 0.01667924f, -0.31018236f, -0.01304523f, 0.07576254f, -0.26287884f, -0.27046576f, -0.73065722f, 
    -0.34409684f, -0.29474473f, -0.00999495f, 0.13606586f, -0.32260042f, 0.09537396f, -0.06672356f, -0.16741237f, 
    0.05277150f, 0.16570017f, -0.13218260f, 0.13546526f, -0.16788106f, 0.17402476f, -0.21344402f, 0.05999260f, 
    -0.18675333f, -0.29633799f, 0.03666386f, -0.17455256f, -0.32179821f, -0.04646383f, -0.04087097f, -0.07391912f, 
    -0.00305456f, 0.06197345f, -0.07100957f, -0.16582526f, 0.00150662f, -0.29824907f, 0.01807460f, -0.05342139f, 
    -0.13884857f, -0.14751963f, 0.21009123f, 0.04078624f, 0.10388295f, 0.15628445f, 0.16163287f, 0.15022536f, 
    -0.28481570f, -0.21561739f, 0.01128270f, -0.27203056f, -0.30341190f, -0.50149053f, 0.08436482f, 0.02507030f, 
    -0.17893535f, -0.15820134f, 0.14406213f, -0.09810292f, 0.10008404f, -0.43054971f, 0.00661857f, 0.26737484f, 
    -0.03209952f, -0.43170583f, 0.05305157f, -0.08782013f, -0.05172079f, 0.07408091f, 0.07241633f, -0.10123297f, 
    -0.53657800f, -0.36773831f, 0.07709646f, -0.64366812f, 0.04640479f, -0.22037959f, 0.11088721f, -0.36956248f, 
    -0.37743595f, 0.04602257f, 0.04658965f, 0.18387631f, -0.21463056f, 0.06735297f, -0.06747815f, 0.07160603f, 
    0.13778138f, 0.04375803f, 0.02247624f, 0.10940259f, -0.01629427f, 0.15879123f, -0.07189593f, 0.06400299f, 
    0.04981376f, 0.16331458f, -0.28566408f, -0.22797151f, 0.10164155f, -0.08958819f, -0.23455982f, 0.02553057f, 
    -0.05561471f, 0.19532493f, 0.10342145f, 0.03665921f, -0.06203008f, 0.18800856f, -0.06362164f, -0.02570129f, 
    -0.46651396f, -0.09902295f, -0.04090530f, 0.12666368f, -0.06161393f, 0.02769904f, -0.32536304f, -0.23037991f, 
    -0.26145643f, 0.13173413f, -0.23219019f, 0.11404717f, 0.34715313f, 0.01674704f, -0.56190532f, 0.08058219f, 
    -0.18559887f, 0.07738072f, -0.14311551f, 0.14294992f, -0.07508403f, 0.14075361f, -0.01210460f, -0.24480475f, 
    0.14937429f, 0.00503818f, 0.08400371f, 0.06737980f, -0.10828014f, 0.11876085f, 0.01772935f, -0.04022498f, 
    0.08839291f, -0.05922294f, -0.32905084f, 0.08284917f, 0.29808751f, 0.18764840f, -0.25223318f, -0.17798699f, 
    0.01603092f, -0.08711883f, 0.16112229f, -0.10814425f, 0.18809883f, -0.02111900f, 0.11846607f, 0.09259170f, 
    -0.27403495f, -0.01587288f, -0.00258325f, -0.02451014f, -0.02032689f, 0.00854656f, 0.03841586f, 0.01168182f, 
    -0.22967674f, -0.20168395f, -0.06923595f, 0.14130473f, 0.08326422f, -0.01926977f, 0.06645440f, 0.18004641f, 
    -0.03839473f, 0.44143766f, -0.08838525f, -0.41624540f, 0.24733938f, -0.00717804f, -0.04627607f, -0.06312623f, 
    -0.04687115f, 0.12702847f, -0.01948922f, 0.05276562f, -0.77038056f, 0.01754919f, 0.22449660f, 0.25319618f, 
    -0.01090871f, -0.10370333f, 0.05652335f, -0.69230080f, 0.03829120f, -0.03070606f, 0.04448805f, 0.01106421f, 
    0.16397129f, -0.00106935f, 0.02344112f, 0.05137228f, 0.14845479f, -0.24558443f, 0.07883374f, -0.43851534f, 
    0.14450657f, 0.08322695f, -0.04606928f, 0.09564950f, 0.00959534f, 0.09226155f, 0.04317343f, -0.06600991f, 
    0.09954675f, 0.08773071f, -0.05001493f, -0.30600321f, 0.01377213f, -0.19379096f, 0.04684526f, -0.01067416f, 
    0.18677182f, 0.13103320f, 0.01918828f, 0.05683684f, -0.03798191f, 0.10963184f, 0.28650281f, -0.02333617f, 
    0.07643086f, 0.05422970f, 0.08813316f, -0.05124846f, 0.01213642f, 0.01748475f, -0.79812354f, -0.10520650f, 
    -0.00223435f, -0.24843691f, -0.15025187f, 0.06237490f, -0.06051709f, 0.07762717f, -0.13554645f, 0.00982884f, 
    0.38779512f, -0.05079038f, -0.04814154f, -0.02816218f, -0.43689197f, 0.13395615f, 0.00659582f, 0.19181399f, 
    0.00392759f, -0.17805664f, 0.07645340f, -0.34085155f, 0.07644412f, -0.03017408f, 0.02921833f, 0.34606680f, 
    -0.12096392f, 0.11574880f, -0.22276808f, -0.01183222f, 0.15121695f, 0.00590632f, 0.05366059f, -0.02322002f, 
    -0.27136561f, -0.38170344f, -0.13400161f, -0.32877371f, 0.33293051f, -0.18736765f, 0.04200472f, 0.06636750f, 
    0.04243634f, -0.02979527f, -0.22258547f, -0.36592099f, 0.22851805f, 0.01036870f, -0.17318507f, 0.15965421f, 
    0.05445752f, 0.03181094f, 0.12403440f, -0.01421268f, -0.26505303f, -0.12632728f, 0.15126625f, 0.06440699f, 
    0.36275017f, 0.14428699f, -0.18197666f, -0.06510871f, -0.10688394f, -0.37868932f, -0.06554871f, -0.38008821f, 
    0.22175455f, -0.12736352f, 0.25627932f, -0.09441067f, -0.38626322f, 0.09025878f, 0.02471849f, 0.06606457f, 
    0.06525081f, 0.01635425f, -0.07510549f, 0.16309033f, -0.68498248f, -0.10588904f, -0.22661971f, -0.27456069f, 
    -0.04040262f, -0.04040736f, -0.01356150f, 0.41432431f, 0.01813383f, -0.11950152f, -0.44141549f, 0.05975901f, 
    0.21085638f, -0.36398619f, 0.22180803f, 0.30594507f, 0.03825418f, -0.25047529f, -0.10204060f, 0.26618370f, 
    -0.06216186f, 0.15404297f, 0.04103782f, 0.09659848f, 0.06444158f, 0.07343695f, -0.08460942f, 0.06785046f, 
    -0.09634488f, -0.12003196f, -0.11605386f, -0.53306001f, 0.03801341f, -0.28010336f, -0.05502792f, 0.11597388f, 
    -0.25639471f, 0.12246339f, -0.12988584f, 0.20570976f, 0.00641505f, -0.02688955f, -0.16379419f, 0.00883859f, 
    0.12354120f, 0.00712720f, -0.22119452f, 0.01157119f, 0.05763119f, 0.00533680f, -0.59107941f, -0.28311548f, 
    -0.01598133f, 0.27237895f, 0.08245662f, -0.35116726f, -0.02717484f, -0.07586475f, 0.05944299f, 0.01141089f, 
    0.16002569f, -0.25364637f, -0.27820599f, 0.09073485f, -0.01343180f, -0.40611967f, 0.13881320f, -0.24040671f, 
    0.20618238f, 0.18836381f, -0.03177760f, -0.06371991f, 0.16838130f, -0.27828282f, -0.18911119f, 0.04707355f, 
    -0.49182859f, -0.04969309f, -0.09548049f, -0.52499419f, 0.02804621f, -0.22320172f, -0.15379210f, 0.04644712f, 
    -0.04584661f, -0.01013067f, 0.33888975f, 0.00162450f, 0.01766962f, 0.11546854f, -0.08142782f, 0.07779263f, 
    0.06933791f, -0.23499207f, -0.14251581f, -0.32932356f, -0.14057459f, -0.19960518f, -0.48556915f, -0.00693042f, 
    0.19071333f, -0.23090938f, 0.10430001f, -0.20612016f, -0.03357415f, 0.24839830f, 0.22139214f, 0.04134390f, 
    0.22368909f, 0.17002754f, 0.03244545f, -0.69466805f, -0.09279508f, 0.06928769f, 0.02618067f, 0.17641769f, 
    0.04476969f, -0.21708596f, 0.13604441f, -0.08775905f, -0.37640747f, -0.00576456f, -0.01908222f, 0.07615079f, 
    -0.28344667f, -0.43546414f, 0.05206857f, -0.00627033f, 0.08774195f, 0.06484877f, 0.03877503f, 0.00778310f, 
    -0.08155164f, -0.01614553f, 0.02484330f, 0.22198254f, 0.34393629f, 0.06904878f, -0.22462194f, -0.49852020f, 
    -0.26917064f, -0.14963636f, -0.40414351f, 0.05396256f, 0.03869512f, -0.17932256f, 0.08557798f, 0.22596338f, 
    -0.33423185f, -0.09241337f, 0.39920220f, 0.04059025f, -0.08940125f, 0.04423608f, -0.27563214f, -0.14788723f, 
    -0.16729032f, -0.15445098f, 0.01644119f, 0.13705087f, 0.04218047f, 0.10423987f, 0.04671923f, -0.21488707f, 
    0.00672370f, 0.12241268f, 0.08703982f, 0.25182381f, -0.14660695f, -0.18267229f, -0.03158075f, 0.03676660f, 
    -0.10260183f, -0.10574083f, 0.18028100f, -0.18223661f, 0.00823892f, -0.18550670f, -0.02408954f, 0.22321427f, 
    -0.23120482f, 0.09438558f, 0.20172656f, -0.03021468f, 0.23897319f, -0.05138046f, -0.02982232f, -0.04531207f, 
    -0.12450632f, -0.23242997f, -0.23181739f, -0.19847742f, -0.03940774f, -0.06867972f, 0.02741264f, -0.41351062f, 
    0.16251686f, -0.03945874f, -0.25221503f, -0.19092458f, -0.09433557f, -0.03830231f, 0.07704698f, -0.05216951f, 
    0.01288496f, -0.17749645f, 0.14835729f, -0.08190859f, -0.10971734f, 0.09597241f, -0.00665424f, 0.18484676f, 
    0.00046134f, 0.06925017f, -0.12952273f, 0.09430357f, -0.54098725f, 0.01243199f, 0.20406410f, -0.04450035f, 
    -0.33150405f, 0.09146748f, -0.12804875f, -0.31295502f, 0.18702893f, -0.05317134f, -0.18640341f, -0.10696789f, 
    -0.12995647f, 0.16372262f, -0.24676727f, -0.09013131f, 0.07309350f, -0.26840505f, -0.20318317f, -0.40718254f, 
    0.16885731f, -0.11454028f, 0.02123033f, -0.03229406f, 0.12774786f, -0.03787780f, 0.06693180f, 0.04637303f, 
    -0.32186338f, -0.11284995f, 0.12128955f, 0.00565814f, -0.18798038f, 0.26162153f, 0.08524203f, -0.03199845f, 
    0.17271133f, -0.71187866f, -0.06200552f, 0.01534030f, 0.09652396f, -0.11933272f, -0.12442454f, -0.20770770f, 
    -0.19122756f, -0.06604391f, -0.04183380f, 0.18601604f, -0.04384085f, 0.00803415f, 0.14504230f, -0.08187783f, 
    0.19532980f, -0.09922265f, -0.29227883f, 0.33653846f, 0.00791778f, -0.30841812f, -0.02412244f, -0.13761181f, 
    -0.02800931f, -0.01081649f, 0.06656403f, -0.08075555f, 0.08699501f, -0.01758324f, 0.32889491f, 0.11332768f, 
    0.13545302f, -0.06373053f, 0.09483715f, 0.12500812f, -0.06224436f, 0.04662585f, -0.00913737f, 0.13779660f, 
    -0.01835190f, -0.05323796f, -0.01295786f, -0.00032433f, 0.20306595f, -0.05383792f, 0.10450484f, 0.06927222f, 
    0.01609752f, -0.04484737f, -0.06646301f, 0.01782881f, 0.01808137f, 0.19374633f, 0.33214888f, -0.00844981f, 
    -0.27546459f, -0.11581560f, -0.01091370f, 0.08693589f, -0.32224852f, 0.05022774f, -0.12998757f, 0.06092244f, 
    0.13957466f, 0.10183694f, -0.11844112f, -0.05718620f, 0.08217723f, 0.12272511f, 0.08336042f, 0.16609167f, 
    0.06849330f, 0.02672404f, 0.15740086f, -0.12731290f, 0.07565065f, 0.07236637f, -0.35446376f, 0.12056339f, 
    0.08394395f, -0.13158976f, -0.08656982f, 0.06816964f, 0.14346482f, -0.49572995f, 0.00464713f, 0.01214210f, 
    0.13953647f, -0.09401727f, -0.53150797f, 0.05730451f, 0.12397472f, -0.07742488f, 0.15666580f, 0.10273101f, 
    0.02971442f, 0.18568861f, 0.06515232f, -0.12408530f, 0.01567643f, -0.15532391f, -0.19336477f, 0.12544151f, 
    -0.00652185f, -0.12436163f, -0.36968538f, 0.03880477f, 0.14966273f, -0.06711990f, -0.04133417f, -0.61754894f, 
    -0.04107453f, -0.12442403f, -0.10570821f, 0.18015701f, 0.05897984f, 0.03662723f, 0.10407545f, -0.11357118f, 
    0.30127466f, -0.28283098f, 0.01636733f, 0.25405926f, 0.30438554f, -0.01591430f, -0.05838811f, -0.03458364f, 
    -0.00872707f, -0.69756854f, 0.15028092f, 0.15585190f, -0.14317904f, 0.09353025f, -0.03571841f, -0.24034260f, 
    -0.16066471f, 0.06266395f, -0.07426058f, -0.42534110f, -0.23057647f, -0.12110215f, 0.16852103f, -0.12008648f, 
    0.07178424f, 0.01729171f, 0.21087246f, -0.26881582f, -0.00205984f, -0.19318017f, 0.08157058f, 0.04168850f, 
    0.06397503f, 0.07234497f, -0.06668950f, -0.05420234f, -0.14718126f, 0.12574723f, -0.25487292f, 0.25174582f, 
    0.09474704f, -0.03754234f, 0.09496552f, -0.37486646f, -0.09245099f, 0.13059208f, 0.00005698f, 0.19424249f, 
    -0.07769678f, -0.03111456f, 0.02376771f, -0.20386973f, -0.08240420f, -0.02145588f, -0.35189164f, -0.00014971f, 
    -0.04554389f, -0.13042375f, -0.13311860f, 0.05680850f, -0.01822261f, 0.12871079f, -0.07448214f, 0.06404906f, 
    0.21069233f, -0.13424546f, 0.06899491f, 0.05745389f, -0.11144241f, 0.04249994f, -0.04503819f, 0.03785671f, 
    0.17778209f, -0.13150385f, 0.17819370f, -0.09930235f, -0.22671188f, 0.05979316f, -0.26824653f, 0.14240445f, 
    -0.60765773f, -0.21925455f, 0.14195934f, -0.31850454f, 0.11509129f, -0.06509966f, -0.02771162f, 0.28937909f, 
    0.15860260f, -0.05392355f, -0.17586364f, 0.06076187f, -0.17831311f, 0.32108834f, -0.11831892f, -0.02749681f, 
    -0.14088914f, -0.11039117f, -0.24897423f, -0.24477820f, -0.21839988f, -0.40501148f, 0.08321314f, 0.22616318f, 
    0.05238815f, -0.34376886f, -0.38480052f, -0.37741578f, 0.04747147f, 0.03477259f, 0.36535752f, -0.72907221f, 
    0.13625762f, -0.05767072f, 0.16898605f, 0.19091751f, -0.17648584f, 0.17936493f, -0.07979785f, 0.21603136f, 
    -0.53723884f, -0.33797041f, -0.34313464f, 0.03978266f, -0.11487866f, -0.18976778f, -0.32169989f, -0.10433242f, 
    -0.25521174f, -0.26343480f, -0.62826329f, 0.16618977f, 0.07947539f, -0.19836411f, 0.11381771f, -0.02878599f, 
    -0.00854317f, 0.30945429f, -0.38603592f, -0.65002370f, -0.05657060f, -0.29674456f, -0.29997605f, 0.18871686f, 
    -0.01710997f, 0.00153398f, -0.00838480f, 0.02335529f, -0.09906065f, -0.21080148f, -0.16246353f, 0.04686859f, 
    0.29226807f, 0.31045774f, 0.09037262f, 0.15577041f, -0.06856176f, -0.31018886f, -0.19227329f, 0.15577079f, 
    0.06568688f, -0.08728576f, 0.13987917f, -0.43150708f, 0.21524711f, -0.28498781f, -0.10595745f, -0.31308380f, 
    -0.18369131f, -0.07154903f, 0.00333354f, 0.01385804f, -0.10372476f, -0.71220315f, 0.02815078f, 0.15437029f, 
    -0.24659641f, -0.20998420f, 0.10650062f, 0.00986129f, -0.14555551f, 0.10442155f, 0.02646443f, 0.05179050f, 
    0.06807468f, -0.19680382f, -0.31641206f, 0.00227663f, -0.06615501f, -0.10559681f, -0.36841983f, -0.41039404f, 
    0.05181566f, 0.03101375f, -0.27886876f, -0.23872851f, 0.14248855f, -0.01923236f, 0.10299218f, 0.13544904f, 
    -0.45503494f, 0.13007754f, 0.00596411f, -0.12775552f, -0.12549010f, -0.15660559f, -0.09112734f, -0.09150550f, 
    -0.09955935f, -0.15420751f, -0.29535320f, -0.06797311f, -0.33150187f, 0.06853764f, -0.08330347f, -0.46968475f, 
    0.06129670f, 0.01178679f, 0.04032556f, -0.16752921f, -0.12596242f, 0.26897857f, 0.01035910f, 0.01422494f, 
    -0.13791488f, -0.18305986f, 0.00707290f, -0.11691084f, -0.08246961f, -0.34555537f, -0.22357614f, -0.36096966f, 
    0.07891438f, -0.09767798f, 0.03530626f, 0.24840115f, -0.53074414f, -0.04730190f, 0.04198850f, -0.12050712f, 
    -0.29543057f, 0.13564935f, 0.03211897f, -0.13081659f, 0.11825005f, -0.11624562f, 0.09801740f, -0.21424966f, 
    0.11639947f, -0.47539544f, 0.25416291f, 0.10008266f, 0.05718227f, -0.41313168f, 0.15681712f, -0.17916368f, 
    -0.12474878f, -0.35061947f, -0.26593670f, -0.20224994f, -0.19151014f, 0.17076693f, -0.14466706f, 0.09913047f, 
    0.17283140f, -0.11535027f, 0.18509072f, 0.06690328f, 0.07422993f, -0.17175001f, 0.02795556f, -0.39084515f, 
    -0.33858055f, 0.12110671f, -0.10133265f, 0.41802934f, -0.03486534f, 0.21702696f, -0.25675327f, 0.05255265f, 
    -0.64138699f, 0.15598036f, 0.17757867f, 0.37148944f, -0.13484845f, -0.33457980f, 0.01853172f, 0.02295254f, 
    0.15299681f, -0.11546439f, -0.07829604f, -0.43645990f, -0.02242293f, -0.40385154f, 0.05752564f, 0.17097288f, 
    0.16028269f, 0.07115702f, 0.09311515f, -0.07805379f, 0.05057049f, 0.31817481f, -0.05127532f, -0.07360949f, 
    -0.30221224f, -0.08206539f, 0.04581073f, 0.05620462f, 0.06580940f, 0.08153073f, -0.17594269f, -0.32840696f, 
    0.14546566f, -0.03698735f, 0.23949863f, 0.08214564f, 0.07278901f, -0.00503234f, 0.23269717f, 0.27907294f, 
    -0.44367421f, -0.08361511f, -0.26717314f, -0.21304405f, 0.08030355f, -0.07171919f, -0.11208681f, -0.30154666f, 
    0.33711272f, 0.08826821f, 0.10701906f, -0.05424206f, -0.46584857f, 0.15091749f, -0.35819411f, 0.05888871f, 
    -0.54832804f, 0.11380462f, -0.14942890f, 0.12180448f, 0.07444839f, 0.15551931f, 0.08500105f, 0.12674910f, 
    0.01944785f, -0.05752658f, -0.03847645f, 0.14292018f, 0.19018571f, -0.19230253f, 0.13263448f, 0.08969645f, 
    -0.16063848f, -0.33881781f, 0.25080720f, 0.40999582f, 0.21783629f, 0.02292656f, 0.10485990f, 0.13455899f, 
    0.17513776f, 0.17052138f, 0.17978713f, 0.39332262f, 0.14079657f, -0.05928039f, 0.15664749f, 0.08360402f, 
    -0.38010144f, -0.23759253f, -0.07415951f, 0.01119062f, 0.07910834f, -0.07903277f, 0.01227799f, -0.41287264f, 
    -0.54442447f, 0.07539883f, -0.20319784f, -0.26174256f, -0.08198323f, -0.20903061f, -0.23353042f, -0.42481384f, 
    0.20329505f, -0.00398537f, -0.12813379f, -0.10308113f, -0.33374679f, -0.36893550f, -0.18225554f, -0.06967540f, 
    -0.01504452f, 0.04074174f, -0.19551259f, 0.07696199f, 0.02949644f, 0.20294869f, -0.08114089f, 0.13386007f, 
    -0.03803551f, 0.12196340f, -0.01401985f, -0.23257665f, 0.07587449f, -0.06591363f, 0.01916366f, 0.23024802f, 
    -0.08379415f, 0.26724097f, -0.16288869f, 0.03110621f, -0.18456547f, 0.12113732f, -0.00063506f, -0.08659809f, 
    0.25023109f, -0.00495762f, -0.08827717f, -0.41478884f, -0.09767159f, -0.90446436f, -0.02510916f, -0.23908381f, 
    0.08879495f, 0.09944517f, -0.46449807f, -0.08168754f, -0.01895735f, -0.08014072f, -0.06020329f, -0.20306128f, 
    0.28897843f, -0.31312764f, -0.00399105f, -0.18132885f, -0.19198640f, 0.07320750f, -0.32098386f, -0.32504922f, 
    0.11627001f, 0.10291349f, 0.26503527f, -0.04079242f, -0.06870042f, -0.23808056f, 0.30947489f, -0.02365399f, 
    0.21803996f, -0.11204410f, -0.12224129f, -0.24210389f, -0.15951051f, 0.02561494f, 0.06177182f, -0.10358842f, 
    -0.27548996f, -0.13591495f, 0.16140801f, -0.30221999f, -0.25270212f, 0.00666793f, 0.25436229f, -0.05517681f, 
    0.14145309f, 0.08387526f, 0.27132493f, -0.20750123f, 0.16552144f, -0.11037134f, -0.10134330f, 0.05731282f, 
    0.23331958f, -0.05218172f, -0.06955798f, 0.25930387f, -0.18217359f, 0.08104727f, -0.08062110f, 0.05851397f, 
    -0.25898498f, 0.00088741f, -0.22838099f, -0.35650632f, -0.35354561f, 0.11536917f, -0.12514414f, -0.04193204f, 
    0.08777480f, 0.19932097f, -0.57772583f, -0.49315056f, -0.25476825f, 0.00604371f, -0.07924932f, -0.51524484f, 
    -0.01863872f, 0.22756489f, -0.09139416f, 0.00512390f, -0.14407478f, 0.08128026f, -0.23879257f, 0.27858698f, 
    -0.19924888f, 0.14749415f, 0.25963151f, -0.06134060f, 0.02730956f, -0.02552398f, -0.17993493f, -0.50390315f, 
    -0.24425225f, -0.25013825f, 0.07760449f, 0.25025809f, -0.06121724f, 0.00678099f, 0.06346488f, 0.01487989f, 
    0.26687175f, 0.03482518f, 0.10508838f, 0.28041822f, -0.28949010f, 0.14765899f, -0.18880564f, 0.04341470f, 
    0.08135688f, 0.07006675f, 0.01690328f, 0.07981907f, -0.12837417f, -0.09526001f, 0.33579645f, -0.18281849f, 
    -0.14139716f, -0.34466705f, -0.57716030f, -0.18473653f, -0.59972370f, 0.12221056f, -0.38098335f, -0.08227807f, 
    0.00545939f, -0.05658034f, -0.28619704f, -0.05769044f, 0.16426475f, 0.22075754f, -0.06767318f, 0.11345706f, 
    -0.27229038f, -0.07969328f, 0.11078975f, -0.02624022f, -0.07049337f, 0.07656918f, 0.07081483f, 0.13070694f, 
    -0.21478772f, -0.62467581f, -0.07585728f, -0.17929737f, -0.02356854f, 0.05752171f, -0.00949512f, 0.19096325f, 
    0.05142787f, -0.25827360f, -0.27716559f, -0.07355163f, -0.04715728f, 0.14556234f, 0.01588904f, -0.26641548f, 
    -0.06625315f, 0.00269312f, 0.01019577f, -0.32607400f, -0.05984104f, 0.02562922f, 0.04823373f, -0.05853087f, 
    -0.30361265f, -0.30441254f, 0.05852107f, 0.04174791f, 0.11606147f, -0.17788036f, -0.40525290f, 0.14732462f, 
    -0.04640053f, -0.52974623f, -0.34958118f, 0.11336795f, -0.26869062f, -0.22476289f, -0.25775230f, -0.07438434f, 
    0.05496166f, -0.07946054f, 0.04565091f, -0.13967159f, 0.20741571f, 0.09704056f, 0.08639839f, -0.42921883f, 
    0.18765666f, 0.17845473f, -0.28710780f, -0.28231302f, 0.19394372f, 0.01736302f, -0.09392355f, -0.17144226f, 
    0.12440512f, -0.01633593f, 0.26956767f, 0.22851017f, -0.08601375f, -0.00702814f, -0.04014233f, 0.22052932f, 
    0.32664192f, 0.26214117f, 0.07741610f, -0.11042931f, 0.20386058f, 0.04982138f, 0.19119845f, -0.49190164f, 
    -0.18437237f, 0.14421149f, -0.21050352f, -0.20150679f, -0.31207356f, -0.19760998f, -0.11144669f, -0.01220732f, 
    0.12415231f, -0.11699743f, 0.05728475f, -0.03730499f, -0.22356930f, 0.20470974f, 0.00511107f, 0.03449015f, 
    -0.08820489f, -0.35884124f, -0.03631827f, -0.36382788f, -0.13093193f, 0.17574811f, -0.44259670f, -0.28133762f, 
    -0.23280467f, 0.03659924f, -0.07783338f, -0.35180646f, 0.05100378f, -0.12169731f, -0.09069390f, 0.20608336f, 
    0.10637787f, 0.28498521f, -0.21637525f, -0.31079227f, 0.06336164f, -0.00789324f, -0.19961567f, 0.19325185f, 
    -0.23175368f, -0.14335418f, -0.17514774f, 0.05295408f, -0.11856570f, -0.11559308f, 0.33642507f, 0.18779062f, 
    0.05752484f, -0.00436543f, -0.14343399f, -0.66391516f, 0.06751731f, -0.18346049f, 0.01405423f, -0.33251008f, 
    0.02000533f, -0.35782230f, 0.12611441f, 0.25391236f, 0.05689932f, -0.03188848f, -0.09612359f, -0.12956505f, 
    -0.23814513f, 0.08944245f, 0.09563560f, -0.09899324f, -0.04996667f, -0.16214986f, 0.10522925f, 0.21693194f, 
    0.11715404f, 0.06521109f, 0.34088624f, -0.02218331f, 0.00604241f, -0.04760451f, 0.17899232f, 0.02047649f, 
    0.04277118f, -0.08632409f, 0.03221839f, -0.43460822f, -0.08294830f, 0.15024258f, 0.12554380f, -0.10285416f, 
    -0.04948582f, 0.10980526f, 0.02875796f, 0.25442660f, -0.28808755f, 0.09509722f, -0.03088902f, -0.20155074f, 
    -0.02268692f, 0.06855811f, 0.08022604f, -0.10087498f, 0.11203673f, -0.31541523f, -0.03996665f, 0.10767441f, 
    -0.21953288f, -0.11417414f, 0.60969311f, -0.07754616f, -0.34375018f, -0.16253844f, 0.22083806f, 0.06989252f, 
    0.12718248f, 0.08062179f, 0.02200903f, -0.20935711f, -0.27320638f, 0.07779600f, -0.30211335f, 0.03138455f, 
    0.22521417f, -0.13136828f, 0.12512764f, 0.05438695f, -0.05893913f, 0.19767185f, 0.06044417f, -0.00418695f, 
    0.35448545f, 0.04285615f, -0.21038151f, -0.26781633f, -0.17721453f, -0.08539902f, -0.21690521f, -0.45777535f, 
    -0.25400317f, -0.35113761f, -0.09792123f, -0.00673102f, 0.30381715f, 0.17961027f, -0.18115598f, -0.08645666f, 
    -0.12856564f, 0.19087614f, -0.23491518f, -0.26312211f, 0.28021276f, 0.17013286f, -0.00371244f, 0.13954158f, 
    0.13877887f, 0.12764342f, -0.04937125f, -0.14330095f, 0.00303517f, 0.00190476f, -0.13346876f, -0.05318042f, 
    0.16681641f, -0.06232001f, -0.13875364f, -0.37303653f, -0.12496366f, 0.09621758f, -0.15695861f, 0.13516948f, 
    0.02423372f, -0.06665044f, -0.17825091f, -0.18940102f, -0.05530086f, -0.11598647f, 0.06320555f, -0.36910200f, 
    -0.38710293f, 0.05588860f, -0.21478012f, 0.45779136f, -0.03735690f, -0.24903621f, -0.01344880f, -0.35707867f, 
    0.00991760f, -0.18865311f, 0.04995871f, -0.11347361f, 0.08077938f, 0.02441702f, 0.28472969f, -0.23088649f, 
    -0.41879225f, -0.04599764f, -0.19743876f, -0.14089170f, -0.07333437f, -0.35672417f, 0.05100255f, -0.05225693f, 
    0.24250433f, -0.14160648f, -0.01828875f, -0.07988748f, 0.02934567f, -0.08014154f, 0.15084814f, 0.18642963f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09647964f, 0.19435124f, 0.03529116f, 0.03756212f, -0.03217483f, -0.04086767f, -0.08419591f, -0.14995943f, 
    -0.00051486f, 0.16234134f, 0.03890289f, 0.02895235f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
