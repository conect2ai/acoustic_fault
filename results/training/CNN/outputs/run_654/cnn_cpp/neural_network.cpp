#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.26430622f, 1.07273746f, 1.33952475f, 0.65212339f, -0.66332710f, 0.37099734f, 0.05759589f, -0.46048668f, 
    0.14951214f, -0.53852445f, 0.94431311f, -0.11741941f, -1.07425690f, -0.70706475f, -0.85159612f, -0.31472492f, 
    0.44079810f, -0.45279303f, -1.18200922f, -0.36702815f, 0.56381851f, -1.49047709f, -0.22810715f, -0.65892476f, 
    0.19171558f, 0.19723512f, 0.46453619f, 1.33807862f, -0.29822960f, -1.08070719f, -0.02694861f, -0.22634667f, 
    0.08825771f, -0.31556645f, -0.39096746f, 0.28698698f, 0.82804084f, 1.37925720f, 1.18862796f, -1.07148695f, 
    0.46155450f, -0.45759329f, 0.41323125f, 0.11205483f, -0.16341610f, -1.85281682f, 1.23696005f, 0.40554225f, 
    -0.21193680f, 1.31793332f, -0.09276752f, -0.31858429f, 0.22642018f, 0.31279519f, -0.75808316f, -1.30484998f, 
    -0.99491870f, -0.45280072f, -0.56744611f, 0.37925082f, 0.16028817f, -0.23648097f, -0.10616208f, 1.48381162f, 
    0.77353317f, -0.16739921f, -0.48330036f, -0.94323248f, -0.88717842f, 0.32448685f, 0.13773397f, 0.33577856f, 
    -0.66096765f, -0.98555672f, -0.69793010f, 0.54111600f, 1.16469586f, 1.22702956f, -0.25550830f, -0.09886133f, 
    0.15928712f, 1.08776796f, 0.68293774f, -0.19043694f, 1.02198458f, 0.92654836f, -0.28475124f, -0.21437779f, 
    -0.34441653f, -0.16457847f, 0.98624575f, -1.23247957f, -0.59948725f, 0.78383696f, 0.69519728f, 0.03445994f, 
    -0.19198225f, 0.50338048f, -0.41773579f, -0.85793406f, -0.83358234f, -0.20587206f, -0.24356687f, 0.84851176f, 
    -0.26054394f, -0.15206926f, 0.15898712f, -0.78003263f, 0.24404413f, -1.12055612f, -0.44170687f, 0.83145744f, 
    -1.17828214f, 0.08215060f, -0.55812913f, -0.51986724f, -0.06732687f, -0.85114557f, 0.98827213f, -1.19071388f, 
    0.34560636f, -0.76754802f, -0.49931151f, 0.31698489f, -0.24030484f, 0.66380239f, 0.23068754f, 0.60513437f, 
    -0.74229765f, 0.77098209f, -0.11420360f, 0.90497029f, 0.71969855f, -0.12203029f, -0.12038368f, -0.71971053f, 
    -1.00542688f, -0.67662388f, 0.59303975f, 0.83130771f, -0.25295252f, -0.38220668f, -0.17441511f, 0.03509071f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07401720f, 0.01115108f, 0.14936343f, 0.16848105f, 0.26887047f, 0.36102179f, 0.38500005f, 0.00743217f, 
    0.32056177f, 0.35462442f, -0.14156088f, 0.29301587f, 0.29070383f, 0.18485309f, 0.25094685f, 0.35840115f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01905430f, -0.23609211f, 0.02437764f, 0.04443935f, 0.13692734f, 0.01763650f, -0.02577388f, 0.05097251f, 
    -0.12135873f, -0.01673270f, 0.08444060f, 0.00137005f, -0.00308393f, 0.06358737f, 0.02373244f, 0.01420662f, 
    -0.06381243f, -0.00646835f, 0.05740530f, -0.01444525f, -0.23406701f, -0.18510446f, -0.29140201f, -0.22436684f, 
    0.17590617f, 0.23954980f, -0.19794162f, -0.14014494f, -0.04432987f, 0.12526336f, 0.03280294f, 0.06258217f, 
    0.20482060f, -0.17089903f, -0.20270754f, -0.01741501f, 0.05684198f, -0.12568253f, 0.02773578f, 0.02247684f, 
    0.29911682f, -0.15037292f, 0.01261867f, -0.01277365f, -0.10760032f, 0.00183414f, 0.06786615f, -0.01976146f, 
    -0.04947468f, -0.02518282f, -0.01626891f, 0.10051082f, -0.03293528f, 0.04784359f, -0.06474999f, -0.06772678f, 
    0.06822155f, 0.13787594f, -0.06148300f, -0.02869675f, -0.20650929f, -0.13234751f, 0.26332554f, -0.01259205f, 
    0.45761913f, 0.04073407f, 0.19207427f, -0.04600718f, 0.07956016f, 0.16132760f, 0.01003406f, -0.00674075f, 
    -0.12219147f, 0.01061731f, -0.07407857f, 0.00014336f, -0.02399842f, -0.09219740f, 0.01550619f, -0.00438706f, 
    0.60320348f, 0.03275528f, -0.35336420f, -0.31849289f, -0.12026923f, 0.10473718f, 0.02109659f, -0.03353488f, 
    0.04521263f, -0.14715683f, -0.04600639f, -0.01131340f, -0.07271212f, 0.19443145f, -0.10055902f, 0.00323971f, 
    0.03322912f, 0.08125160f, -0.07504089f, -0.04037168f, 0.09579940f, -0.24724150f, -0.04258557f, 0.15476304f, 
    0.02898329f, 0.05861268f, 0.03140292f, -0.11996191f, 0.00262871f, 0.09334108f, -0.01215124f, 0.00781318f, 
    0.12845230f, -0.05058863f, -0.00212828f, 0.06286234f, -0.01734493f, 0.13839006f, 0.08496050f, 0.05974642f, 
    0.24551620f, 0.13258909f, 0.42757916f, -0.08602456f, -0.08023399f, -0.14986467f, -0.01916507f, -0.07342802f, 
    -0.12603945f, -0.02284044f, -0.07706065f, -0.15151234f, 0.00723944f, 0.03267198f, -0.01237014f, 0.00397395f, 
    -0.10011622f, -0.03948049f, 0.02894882f, 0.01838533f, 0.03879452f, 0.35722134f, -0.37415263f, -0.16801143f, 
    0.28225720f, 0.17747556f, -0.01199728f, -0.02169004f, 0.11837854f, 0.04170791f, -0.04973035f, 0.14652023f, 
    0.10264666f, 0.04728527f, -0.07102465f, 0.22483106f, -0.00156627f, -0.02773031f, -0.03728643f, -0.00996916f, 
    0.62426621f, -0.08352015f, 0.27557987f, 0.02201315f, -0.12317603f, -0.16674265f, -0.00844365f, -0.15198217f, 
    -0.06995439f, -0.10114936f, 0.09765995f, -0.01543368f, -0.07170853f, 0.01111847f, -0.09045610f, -0.11170051f, 
    0.08964593f, 0.02668640f, -0.10043770f, 0.07945620f, 0.09518825f, -0.11820030f, 0.13503025f, -0.05612367f, 
    0.01319539f, -0.11346056f, 0.08919629f, 0.01833025f, -0.14346255f, -0.13694245f, -0.08225407f, 0.06415539f, 
    -0.05773988f, 0.00484808f, -0.05627714f, 0.00040970f, -0.15590870f, -0.10377812f, 0.10978059f, -0.03172190f, 
    0.51469696f, -0.37450895f, 0.26277015f, -0.20041661f, 0.29520971f, -0.01201020f, 0.10756789f, -0.07272084f, 
    0.14561345f, 0.10417642f, 0.01760576f, -0.01112361f, 0.04192501f, -0.02202164f, -0.03450302f, 0.08418047f, 
    0.23256817f, 0.15389696f, 0.12961689f, 0.04464783f, 0.34689030f, 0.03042329f, 0.07220439f, 0.11468301f, 
    -0.01002999f, -0.02531685f, 0.08472785f, 0.10992547f, -0.06761800f, 0.05107034f, 0.00539497f, 0.02405066f, 
    -0.01615434f, -0.13898087f, 0.00072549f, 0.13738328f, -0.08560796f, -0.09781388f, -0.01298699f, 0.11017761f, 
    0.29651108f, 0.21753131f, 0.23408976f, -0.08421936f, 0.02082707f, -0.10229416f, 0.14121331f, 0.15980041f, 
    0.07788250f, 0.04278857f, -0.03534817f, -0.02245086f, 0.09181924f, 0.04765173f, -0.08238485f, -0.14942113f, 
    0.16859864f, -0.04092200f, -0.00469958f, -0.12254374f, -0.19675893f, 0.28250617f, -0.04323206f, 0.07337706f, 
    0.24667023f, 0.03869498f, -0.12226827f, -0.00015584f, 0.05457626f, 0.05709585f, 0.02378764f, 0.01111270f, 
    0.07855964f, 0.04763102f, 0.08779769f, 0.06944154f, -0.06400377f, 0.03406365f, 0.01224355f, -0.19707252f, 
    0.02522434f, -0.10167076f, 0.21166573f, -0.07442310f, 0.13052478f, -0.04189501f, -0.02265116f, -0.07161935f, 
    0.02280375f, 0.01977163f, 0.15348633f, 0.07600948f, 0.02595681f, -0.10152844f, 0.12093978f, -0.04234308f, 
    0.00593475f, -0.00733572f, 0.10211778f, 0.03777202f, 0.65223897f, 0.14094506f, 0.36230993f, 0.13098833f, 
    -0.01216215f, -0.02436136f, 0.14621723f, 0.06391729f, -0.06690580f, -0.14818119f, -0.11464776f, -0.00477835f, 
    0.01781793f, 0.00876979f, -0.02297519f, 0.02863145f, 0.10354951f, -0.02998366f, -0.12034026f, -0.02841810f, 
    -0.28812575f, -0.36648503f, -0.24012809f, 0.07034647f, -0.67149329f, 0.01170198f, 0.04644432f, 0.12015837f, 
    0.08850554f, -0.08639300f, -0.01658691f, -0.01858829f, 0.00116862f, -0.08460683f, -0.06319049f, 0.06956635f, 
    0.05761207f, -0.09014119f, 0.17671582f, -0.10991298f, 0.34732676f, -0.04330325f, 0.31471375f, 0.51763904f, 
    0.28485423f, -0.24139690f, 0.11691238f, 0.00588661f, 0.13236855f, 0.02716509f, -0.07970869f, -0.06744472f, 
    -0.11113889f, 0.09115887f, 0.06951362f, -0.00183405f, 0.11668625f, 0.11956538f, 0.11103249f, 0.06261918f, 
    0.08148417f, 0.28738573f, 0.04915763f, 0.20867704f, 0.47204757f, 0.13736296f, -0.01720653f, -0.10953543f, 
    -0.03965454f, -0.02226332f, -0.00138662f, -0.00557496f, 0.16571866f, -0.06226347f, -0.03976510f, 0.00264662f, 
    0.00348244f, 0.17348698f, 0.17462893f, 0.06774162f, 0.18690249f, 0.44938365f, 0.06454233f, 0.18740983f, 
    0.48499885f, 0.11757159f, 0.15516701f, -0.06499565f, 0.03137166f, 0.19050336f, -0.06624338f, 0.05723617f, 
    0.21102706f, 0.02201996f, 0.07275014f, 0.19653337f, 0.04489727f, 0.15291730f, -0.09520635f, 0.17114462f, 
    -0.08922873f, -0.14326064f, 0.38102910f, -0.08745453f, -0.42710793f, -0.23599711f, -0.00995449f, 0.00797133f, 
    0.08014348f, 0.01135824f, -0.18529193f, -0.11917291f, 0.04934974f, -0.07798961f, 0.09827959f, -0.02992569f, 
    -0.09656432f, -0.09105074f, 0.08889831f, 0.14874828f, 0.35005036f, -0.29576990f, 0.49360475f, 0.14823532f, 
    -0.41816056f, 0.13316876f, -0.07273425f, 0.13455814f, 0.11770283f, -0.20904338f, 0.01408110f, -0.00705378f, 
    -0.07958911f, 0.12253315f, -0.10590060f, -0.05011344f, -0.00392686f, -0.04777290f, 0.02249559f, -0.03996443f, 
    -0.08060981f, -0.08859359f, -0.46254975f, 0.04618784f, 0.37088433f, 0.08945127f, 0.14677161f, 0.00252783f, 
    -0.11846559f, 0.01492777f, 0.07625016f, 0.22789207f, 0.11524901f, -0.10047594f, 0.07576874f, 0.11961596f, 
    0.03375486f, 0.09271803f, 0.14363095f, 0.15600009f, -0.02709109f, 0.35330799f, 0.06032610f, 0.09139159f, 
    0.17954268f, 0.02407406f, 0.05946531f, -0.11184798f, 0.04815918f, 0.16576236f, -0.09965891f, -0.16501456f, 
    -0.14063202f, 0.04866014f, 0.01832289f, -0.04737676f, 0.03738082f, 0.19306593f, -0.01222981f, 0.11500278f, 
    -0.16169022f, -0.05994280f, -0.06672618f, -0.17048274f, -0.13784555f, 0.15122215f, 0.08241048f, 0.09015860f, 
    -0.05087379f, -0.08399404f, 0.00659459f, 0.11518544f, -0.03216608f, -0.00784041f, 0.00920224f, -0.01461606f, 
    -0.11934513f, 0.07968399f, -0.04770096f, -0.05222717f, -0.66942722f, 0.19438949f, -0.16216855f, -0.04818662f, 
    -0.16906773f, -0.02326780f, -0.00696162f, 0.12705638f, 0.02939897f, 0.03276389f, -0.00300994f, 0.01645214f, 
    0.03663092f, 0.14453198f, -0.01170791f, 0.28134900f, 0.00770497f, 0.06633595f, -0.29263619f, 0.13200112f, 
    -0.47884709f, 0.11206593f, -0.11190622f, 0.24199079f, 0.22222295f, 0.12321509f, 0.11532640f, 0.10660077f, 
    0.18102540f, 0.07328650f, -0.04596403f, 0.19067059f, -0.01567914f, -0.03835040f, 0.22947349f, -0.12574843f, 
    -0.01609450f, 0.12876004f, -0.14310990f, -0.19878235f, -0.13562770f, 0.36339080f, 0.10935331f, 0.01993273f, 
    0.24800849f, 0.21100263f, 0.15622386f, 0.05013028f, 0.04928434f, -0.16206993f, 0.05406842f, -0.08357891f, 
    0.17881064f, -0.10323772f, -0.04983833f, 0.04513692f, -0.08586711f, 0.04281770f, 0.16381286f, -0.07414423f, 
    0.45916232f, 0.13615470f, -0.48403069f, 0.14627045f, 0.20470724f, 0.09644356f, -0.05139559f, -0.13403566f, 
    0.05182625f, 0.20433949f, -0.11634020f, 0.12829672f, 0.01438608f, 0.01123471f, -0.00752551f, 0.21356495f, 
    0.03124835f, 0.20878780f, -0.01130145f, 0.10676388f, 0.21521436f, -0.06485636f, 0.27830371f, 0.29802191f, 
    -0.10217433f, -0.22416145f, 0.12262972f, 0.02848393f, -0.00632628f, 0.07640910f, -0.10431559f, 0.02958658f, 
    -0.02824423f, 0.15639128f, -0.17196351f, 0.02849084f, 0.08765750f, 0.14159718f, -0.09857661f, 0.14516629f, 
    -0.10447511f, 0.01636647f, 0.06190294f, -0.16340107f, -0.31319916f, 0.10198618f, 0.01843907f, -0.02386927f, 
    0.11034060f, -0.01320246f, -0.10293933f, 0.03783354f, -0.03507397f, -0.00597478f, -0.07600930f, 0.09720289f, 
    -0.08397691f, -0.05984640f, 0.04171259f, -0.21611527f, -0.20681852f, 0.17007728f, -0.21258217f, -0.01664134f, 
    0.29260692f, 0.14399496f, 0.15861420f, 0.05289037f, -0.02378942f, 0.10543583f, -0.02476369f, 0.07847512f, 
    0.20923755f, -0.05398343f, 0.10982472f, 0.10287710f, 0.07108932f, 0.07233079f, 0.07365071f, 0.01001482f, 
    0.38791743f, 0.41478708f, 0.14012869f, 0.08326080f, -0.08361834f, 0.19384021f, 0.10816783f, 0.08818971f, 
    -0.01704504f, 0.08289546f, -0.24417013f, 0.13419928f, 0.07063088f, -0.08905246f, -0.08782019f, 0.21169874f, 
    -0.05667273f, 0.01694157f, -0.00496608f, -0.01008014f, 0.02850302f, -0.09559196f, 0.05279285f, -0.08449587f, 
    -0.08171535f, 0.13038976f, 0.07596910f, 0.14522463f, 0.01068220f, 0.02470540f, -0.09413475f, -0.13566293f, 
    0.13430533f, 0.22099847f, -0.00789177f, 0.01817744f, -0.10476612f, -0.00401331f, -0.19815595f, 0.02408338f, 
    0.20804957f, -0.18347588f, 0.20452617f, 0.04641511f, -0.24255314f, 0.14539739f, -0.04253727f, 0.01435144f, 
    -0.13556632f, 0.05488255f, 0.03276136f, -0.08840383f, 0.01229726f, 0.15483022f, 0.01314918f, -0.09717688f, 
    0.06892189f, -0.19676033f, -0.14247206f, -0.11184331f, 0.45160875f, -0.24276039f, -0.14569493f, -0.33910140f, 
    -0.29350448f, -0.17531039f, -0.02436571f, -0.00288352f, -0.04122516f, 0.03911991f, -0.02406404f, -0.05454052f, 
    -0.04405167f, -0.05001242f, -0.11279637f, -0.06894692f, -0.14761923f, 0.15030190f, -0.01814738f, -0.07999744f, 
    -0.48762190f, 0.04320111f, 0.22416660f, 0.25921699f, -0.04856677f, 0.05605804f, 0.04982695f, 0.15411854f, 
    -0.05266285f, 0.01841415f, 0.11035793f, -0.06887345f, -0.01750820f, 0.07112032f, -0.18387128f, 0.08456090f, 
    0.07795932f, -0.03231840f, -0.04886374f, -0.04953364f, -0.38774946f, 0.05006262f, -0.16938160f, -0.09478036f, 
    -0.09688172f, 0.11320575f, 0.08267772f, 0.11133388f, 0.07257842f, 0.01832324f, -0.01958474f, 0.03359245f, 
    -0.10698415f, 0.08621348f, -0.08848044f, 0.00103697f, -0.02376147f, 0.04345093f, -0.06065945f, -0.09733390f, 
    0.19190145f, 0.03401521f, -0.00101149f, 0.14369103f, 0.33366251f, 0.12813844f, 0.10689789f, 0.10363380f, 
    0.17283277f, 0.16303310f, -0.03321186f, 0.01462486f, 0.00511540f, 0.03532580f, -0.07690779f, 0.06140837f, 
    0.19440992f, 0.10638678f, -0.04306040f, -0.12720394f, -0.06828883f, -0.40426341f, 0.11997205f, 0.19386953f, 
    -0.23336448f, -0.11866742f, -0.06772447f, 0.11077917f, -0.15057322f, 0.00830693f, -0.15126875f, -0.01278135f, 
    0.08724060f, -0.01025907f, -0.01157854f, -0.15820202f, -0.06360510f, -0.15160353f, -0.13133672f, 0.05525786f, 
    0.06233257f, -0.27092659f, -0.03616756f, 0.11526725f, 0.20088813f, -0.08640030f, 0.04926522f, 0.11233402f, 
    -0.15039539f, 0.15569904f, -0.01737883f, 0.10578907f, 0.01790540f, -0.00125227f, 0.00179428f, 0.08780952f, 
    0.09238631f, 0.03318816f, 0.02548620f, -0.08365893f, 0.04430204f, 0.14543943f, -0.01417069f, 0.00368970f, 
    0.07428605f, 0.01007595f, -0.15900452f, -0.18738341f, 0.07416114f, 0.01417277f, -0.03096252f, 0.02812474f, 
    0.15279585f, -0.01087472f, 0.20066863f, -0.08917281f, 0.14298460f, 0.01670819f, 0.05208813f, 0.00623225f, 
    0.26742041f, -0.30552125f, 0.13456030f, 0.00293993f, 0.12184431f, 0.08285920f, 0.07445136f, -0.15004939f, 
    0.01129534f, -0.10442439f, 0.06236962f, -0.09475945f, -0.05809046f, 0.09166887f, -0.01425940f, 0.12250021f, 
    -0.16218723f, 0.00312798f, -0.04727922f, 0.05744680f, 0.30411014f, -0.14608212f, -0.21743704f, 0.06363686f, 
    0.21455044f, 0.11342690f, 0.01325302f, -0.03950433f, 0.04274649f, 0.20508553f, -0.02812477f, 0.01553417f, 
    0.09040507f, 0.07160638f, 0.00548812f, 0.07602887f, 0.24846680f, 0.00043823f, -0.03062181f, 0.04447102f, 
    -0.42955992f, 0.19888870f, -0.09145050f, -0.20317307f, 0.25436929f, -0.21693633f, 0.18566155f, -0.00189204f, 
    -0.08807444f, 0.01891427f, 0.17013916f, -0.04051140f, -0.02081914f, -0.20544375f, 0.05146441f, -0.00949964f, 
    0.00198672f, -0.12117515f, 0.23375838f, 0.05551098f, -0.14659408f, 0.13841105f, 0.11377815f, -0.00146452f, 
    0.16205394f, 0.18662795f, -0.10590866f, 0.04122796f, -0.01493080f, 0.05111805f, -0.06686097f, -0.00727781f, 
    -0.12126457f, -0.08327647f, 0.04323116f, -0.07753641f, 0.12343097f, -0.19728655f, 0.02864582f, 0.20824952f, 
    -0.05647338f, 0.22447069f, -0.15458123f, 0.16412599f, -0.00850863f, -0.08613380f, -0.09026567f, -0.06245648f, 
    -0.01365247f, -0.01490820f, 0.14069104f, 0.04365829f, 0.00537400f, -0.13781010f, -0.02163373f, -0.01299028f, 
    0.22957194f, -0.08943137f, -0.08748627f, 0.11529996f, 0.05296014f, -0.10532743f, -0.23815465f, 0.09778333f, 
    0.25062466f, 0.11137741f, 0.11168055f, -0.13313863f, 0.17596610f, 0.19111629f, 0.01804984f, 0.10717130f, 
    -0.05130632f, -0.03585754f, 0.02734167f, 0.07650119f, 0.03723851f, 0.00399595f, 0.14140154f, -0.00276340f, 
    -0.23078568f, 0.20214452f, -0.14164299f, 0.00452718f, -0.09532797f, 0.02262052f, 0.08541731f, 0.02439699f, 
    -0.01532602f, -0.13517500f, 0.02816771f, -0.03218440f, -0.02458186f, 0.03595914f, -0.18253636f, 0.06242539f, 
    0.19258529f, -0.07682894f, -0.21182650f, -0.19165193f, 0.03456151f, -0.15702903f, 0.25442776f, -0.15651505f, 
    0.00170239f, -0.18814164f, 0.12560946f, 0.00215705f, -0.03178140f, 0.06897953f, -0.11549485f, 0.08868825f, 
    0.09265276f, -0.03517336f, -0.16055723f, -0.07071974f, 0.07613523f, 0.06643261f, 0.09992947f, -0.02117658f, 
    0.30444941f, -0.08929510f, -0.05174961f, 0.07141852f, -0.10154520f, -0.13681686f, 0.09048175f, -0.08788226f, 
    -0.05050866f, 0.01717290f, 0.00445014f, -0.00383356f, 0.15421452f, -0.22540307f, -0.06714224f, 0.09127983f, 
    -0.09696286f, 0.07519306f, 0.19113789f, 0.00234845f, -0.27519318f, 0.02575886f, 0.12151960f, 0.19340236f, 
    -0.12918140f, -0.05608125f, 0.02942231f, 0.02825891f, 0.05653267f, 0.08742641f, -0.13192421f, -0.08856624f, 
    0.15059504f, 0.08994467f, 0.15029457f, 0.12124206f, -0.01074556f, 0.15859333f, -0.10200503f, 0.17393695f, 
    -0.34248516f, 0.02644966f, 0.18967426f, -0.14978276f, -0.17797583f, 0.09432852f, 0.17051883f, -0.23789135f, 
    -0.02325054f, -0.11872169f, -0.13310222f, -0.12689063f, -0.04860865f, -0.15437859f, -0.01075021f, -0.00612002f, 
    -0.12595996f, -0.04108038f, 0.05731402f, -0.06312075f, 1.00508535f, -0.46468782f, 0.10243084f, 0.07731497f, 
    0.15321092f, 0.06275971f, -0.10794169f, 0.09772269f, 0.07402050f, -0.01758778f, 0.07244567f, -0.05690821f, 
    -0.03514051f, -0.08172598f, 0.09194128f, 0.02560109f, 0.00690643f, -0.18412930f, -0.00420550f, 0.08616531f, 
    0.05243636f, -0.36478528f, -0.17338288f, 0.16378400f, -0.11562671f, -0.09488765f, 0.18193513f, -0.15767771f, 
    -0.02438623f, 0.00745083f, 0.00814711f, -0.00504770f, 0.05547201f, -0.00392113f, 0.18899204f, -0.02729454f, 
    -0.13316289f, 0.18637155f, -0.02923939f, 0.07266686f, -0.19797899f, 0.15306175f, 0.28527641f, -0.22432457f, 
    -0.40281543f, 0.01300797f, 0.01386112f, 0.19507211f, -0.00786239f, 0.11391885f, -0.08691163f, -0.08823093f, 
    -0.06806119f, -0.11916754f, -0.01126004f, -0.01091976f, 0.01948188f, 0.08969312f, 0.10623043f, -0.10824063f, 
    0.24079590f, 0.05245521f, -0.03247681f, 0.12905733f, 0.03253882f, 0.27068618f, 0.00886413f, -0.08439165f, 
    0.10244516f, 0.12279961f, 0.06372317f, -0.04790708f, 0.00975402f, 0.07558542f, 0.02820493f, 0.15740849f, 
    -0.05715613f, -0.05033190f, -0.07230983f, 0.07185272f, -0.30037576f, 0.14323521f, 0.09883032f, 0.00209280f, 
    0.44192973f, 0.16018227f, 0.02551298f, 0.01417170f, 0.10381453f, -0.06052817f, 0.01798567f, 0.06099051f, 
    -0.03049242f, 0.10931745f, -0.02270767f, 0.22486432f, -0.01085427f, 0.10647564f, -0.29671475f, 0.11122175f, 
    -0.04132623f, 0.54789054f, -0.18404393f, 0.21258382f, -0.02938752f, 0.04807916f, 0.01719757f, 0.06276808f, 
    0.13910554f, 0.02861680f, 0.04594080f, 0.00451059f, 0.20904362f, -0.13164818f, 0.13508303f, 0.12829909f, 
    -0.05911608f, 0.03791454f, -0.16595761f, -0.02192791f, 0.08633115f, -0.31464502f, -0.11445028f, 0.18656746f, 
    0.15514681f, 0.20007344f, 0.09513976f, -0.10330713f, -0.06133950f, 0.10779782f, -0.00242723f, 0.00169835f, 
    0.09858364f, -0.06777905f, 0.00709261f, -0.11050088f, 0.01019847f, -0.08747759f, 0.26910990f, 0.02470508f, 
    -0.11842869f, 0.12615232f, 0.15062769f, -0.04828767f, -0.03962429f, 0.22381793f, 0.00784483f, -0.16964883f, 
    -0.08660144f, 0.07007166f, -0.10025980f, -0.08065975f, -0.07852267f, 0.11582036f, 0.15788616f, 0.15303759f, 
    0.01944708f, 0.04921808f, -0.08898044f, 0.07837720f, -0.01998362f, -0.03132346f, 0.06610710f, -0.19692169f, 
    -0.35957840f, 0.00006884f, 0.01150280f, 0.05816550f, 0.08939639f, 0.00062597f, -0.03311270f, -0.04562243f, 
    -0.01799383f, 0.04786552f, 0.00645024f, -0.00859294f, -0.00506870f, 0.27411315f, 0.08256641f, 0.08447531f, 
    0.04038839f, 0.18885089f, 0.15705360f, -0.10668661f, -0.06941554f, -0.01124653f, 0.07529514f, 0.04296554f, 
    0.21909866f, -0.06361534f, 0.02677413f, -0.00376725f, -0.01417082f, 0.17117997f, 0.21377751f, 0.02817539f, 
    0.07245266f, 0.04903268f, -0.10918359f, -0.17561436f, -0.05236803f, -0.37852314f, -0.10725228f, 0.11282227f, 
    0.17543118f, 0.09840267f, -0.08959586f, -0.15285333f, -0.09676084f, 0.16894567f, 0.03166938f, -0.03586338f, 
    0.06375363f, 0.06438891f, -0.06976295f, -0.09910961f, -0.05587301f, 0.14115657f, 0.14111799f, -0.04854164f, 
    -0.01155017f, -0.04984669f, 0.04743882f, -0.04407809f, 0.01104541f, 0.05683256f, -0.02974811f, -0.04972175f, 
    -0.04453111f, -0.02296383f, 0.01618894f, -0.02741833f, 0.01582035f, -0.02266174f, -0.03091166f, 0.03337241f, 
    -0.00259550f, 0.05069779f, -0.01613829f, -0.01137720f, -0.03349193f, -0.02461063f, -0.04959372f, -0.00633319f, 
    0.00186608f, 0.00793641f, -0.02791277f, -0.01054888f, 0.04256129f, -0.01571512f, 0.00765434f, 0.03633971f, 
    -0.04265682f, -0.02493087f, -0.03052060f, -0.00157734f, -0.02224971f, -0.02084212f, 0.04083832f, -0.01356355f, 
    0.01039113f, 0.00851350f, -0.01984110f, 0.02435210f, 0.01972429f, 0.02709353f, -0.01240753f, -0.03050780f, 
    -0.00629715f, -0.00072114f, 0.02250260f, -0.03005939f, 0.02317280f, 0.00660836f, -0.03537269f, -0.00246417f, 
    -0.03624533f, 0.04244345f, -0.02579481f, -0.01543391f, -0.00890433f, 0.02129006f, -0.04284418f, -0.03617897f, 
    0.04482254f, 0.02606460f, 0.00518265f, 0.00001047f, -0.01866528f, -0.01945864f, 0.03630700f, 0.02209641f, 
    -0.01964950f, 0.00933638f, 0.02033342f, -0.01842398f, 0.02428202f, -0.02862538f, -0.03873823f, 0.00569580f, 
    -0.05254335f, 0.01819894f, -0.05524275f, 0.04278443f, 0.01135390f, 0.00545916f, -0.01965436f, -0.06123681f, 
    0.01319437f, 0.03724450f, -0.05811871f, -0.03642941f, 0.04625488f, -0.00018094f, 0.00912931f, 0.03153984f, 
    -0.05235096f, 0.03541318f, -0.00055711f, 0.01382954f, 0.02696246f, 0.03087363f, 0.00680609f, -0.05610346f, 
    -0.01583333f, 0.03186270f, -0.01194478f, 0.02558715f, -0.03805269f, -0.05055504f, -0.01995221f, -0.03031483f, 
    -0.04377686f, -0.02742413f, 0.00523277f, -0.01713149f, 0.02257212f, -0.05328187f, 0.00379635f, -0.02707032f, 
    -0.01025210f, -0.02194290f, -0.04403729f, 0.03788615f, 0.03488760f, -0.03706104f, 0.02974598f, -0.02787435f, 
    -0.01693973f, 0.02746949f, 0.00436859f, -0.03955249f, -0.05141086f, -0.00935714f, 0.03005231f, -0.03962252f, 
    0.03575032f, 0.02578519f, 0.02797881f, 0.03253299f, 0.03783434f, -0.05664164f, -0.00315444f, 0.02342641f, 
    -0.06250558f, -0.00198367f, 0.04205306f, 0.01651378f, -0.04430724f, 0.03390221f, -0.01532049f, -0.00938692f, 
    0.00378775f, 0.04937904f, -0.00001429f, 0.01073730f, -0.03326821f, -0.00080685f, -0.05893800f, 0.04141682f, 
    0.00159644f, 0.02329097f, -0.05180967f, 0.00127351f, 0.02363066f, -0.04347347f, 0.01455693f, 0.02232162f, 
    0.02371967f, -0.00033502f, 0.02562045f, -0.01169612f, -0.03967064f, 0.02819653f, -0.03963143f, -0.04608297f, 
    0.04959388f, 0.00360711f, 0.02239908f, 0.00992908f, -0.06202477f, -0.03098418f, -0.01316150f, -0.04499430f, 
    0.03116967f, -0.02817161f, 0.02865277f, 0.03541072f, 0.03095437f, 0.03095958f, 0.01583304f, 0.03590776f, 
    -0.02735931f, -0.04951825f, -0.05536951f, -0.03346550f, -0.01342165f, -0.02969605f, -0.00125810f, 0.01249268f, 
    -0.05632870f, -0.03992929f, 0.04078352f, -0.00969841f, 0.02355570f, 0.02008415f, -0.04728913f, -0.04378344f, 
    -0.04504145f, -0.00896433f, -0.05660624f, 0.00833010f, -0.06053653f, 0.01215069f, -0.04594634f, 0.03155673f, 
    -0.03605701f, -0.04381558f, -0.01873794f, -0.02470793f, -0.06049040f, -0.06232154f, -0.05569264f, -0.01512562f, 
    0.03250717f, 0.02797153f, 0.00688548f, -0.04325319f, 0.01276595f, 0.03876268f, -0.04045656f, 0.02499190f, 
    -0.03432367f, 0.03063037f, -0.01841195f, 0.03540120f, 0.03535527f, -0.03567299f, -0.03735928f, -0.00673522f, 
    -0.02744590f, -0.02865390f, -0.02184825f, -0.01253549f, -0.01817595f, 0.00787022f, 0.00757002f, 0.01729716f, 
    -0.03742339f, 0.01249116f, -0.02047295f, -0.01912706f, -0.01659711f, -0.05487125f, -0.05025122f, 0.00287831f, 
    0.04202930f, -0.04453186f, 0.02238179f, 0.04880666f, 0.02032937f, -0.00470468f, -0.00030425f, -0.06233639f, 
    0.00319390f, 0.04066945f, -0.04456233f, -0.00086433f, 0.04812720f, -0.02043273f, -0.03500586f, 0.03048587f, 
    -0.00185412f, 0.03471527f, -0.01540154f, -0.00736758f, -0.01514057f, 0.01114188f, -0.04789571f, -0.00561434f, 
    0.01183791f, -0.02613642f, 0.02940920f, -0.04355408f, -0.06005206f, 0.03217488f, -0.00747172f, -0.02697117f, 
    0.01398317f, 0.00220482f, 0.05452789f, -0.03551206f, -0.05521138f, -0.01024798f, -0.01920399f, -0.05347031f, 
    0.04165815f, -0.05582472f, 0.03937524f, -0.01033270f, -0.03491938f, -0.02862269f, -0.06165042f, 0.03896496f, 
    0.04372712f, 0.01175994f, 0.02353441f, -0.01313877f, -0.04011022f, 0.01684855f, 0.01674372f, -0.03087910f, 
    -0.01059411f, -0.06232608f, -0.02826695f, -0.04028841f, 0.04590728f, -0.05162572f, -0.02644403f, -0.00796948f, 
    -0.04523883f, -0.05841685f, -0.05195443f, -0.00922459f, 0.00363951f, -0.02467563f, -0.05937530f, 0.02232068f, 
    -0.02806087f, 0.02051201f, 0.02741085f, -0.00917480f, 0.01535118f, 0.02150334f, -0.05237707f, -0.05666671f, 
    -0.04746689f, 0.02816021f, 0.01424204f, 0.04449667f, 0.01416845f, 0.02829708f, -0.03530568f, -0.03001560f, 
    -0.05844854f, 0.00051433f, -0.05328979f, -0.02099033f, 0.01500248f, 0.03584800f, -0.03174942f, -0.04446252f, 
    0.04056786f, 0.04161404f, 0.03986269f, -0.05495077f, -0.05789457f, -0.05406343f, 0.03926938f, -0.01805085f, 
    0.01542148f, -0.02447754f, -0.05253678f, 0.00453477f, 0.01987731f, 0.00177981f, -0.02609981f, -0.05099046f, 
    0.02028421f, 0.03903373f, 0.04749915f, 0.00405106f, -0.03663471f, -0.04570383f, -0.01950506f, 0.03865480f, 
    -0.02743686f, -0.00203509f, -0.01218008f, -0.04663402f, 0.00133993f, 0.03949766f, 0.04026971f, -0.02513433f, 
    0.02765263f, 0.03493271f, -0.00321520f, -0.00000212f, -0.03734530f, -0.05837752f, -0.02176524f, -0.05548764f, 
    0.04023284f, 0.04786457f, 0.03220552f, -0.03692034f, -0.05552033f, -0.03966529f, 0.02386148f, 0.04728306f, 
    0.02909863f, 0.02741298f, 0.03696390f, -0.01260716f, -0.00512334f, 0.01671887f, -0.03672356f, 0.03685141f, 
    -0.04675771f, 0.01524577f, 0.02553740f, -0.00076273f, 0.02698741f, -0.05265882f, 0.00008146f, 0.00665891f, 
    0.01077103f, 0.01754704f, 0.03171303f, -0.03659828f, -0.03677957f, -0.01900300f, -0.04784086f, -0.04761561f, 
    -0.00289230f, -0.04732665f, -0.02639585f, -0.01571671f, 0.03879727f, -0.05876462f, -0.01635228f, -0.05813564f, 
    -0.04473869f, -0.04240264f, 0.00337634f, 0.04645393f, 0.01887339f, -0.04325704f, -0.00601514f, 0.04397118f, 
    0.02596958f, 0.00051659f, 0.04483161f, -0.02034870f, 0.02768260f, 0.00937756f, -0.01070210f, 0.00208427f, 
    -0.03245677f, -0.04710491f, -0.00865361f, -0.05138950f, -0.00289297f, -0.02664846f, -0.02004903f, -0.01812687f, 
    -0.01897255f, 0.00552332f, 0.05156278f, -0.01236847f, 0.04518958f, -0.02267286f, -0.01344020f, -0.02312261f, 
    -0.00922144f, 0.03267568f, -0.00430519f, 0.03674490f, 0.02265497f, 0.02133657f, 0.04099854f, -0.04550533f, 
    -0.01173602f, -0.05786475f, 0.00700072f, -0.05313116f, 0.03523310f, -0.01522887f, -0.02441603f, 0.00234810f, 
    0.02748029f, -0.03740409f, 0.00433199f, -0.04877066f, 0.03057804f, -0.02934845f, 0.00036325f, 0.04275890f, 
    0.00909191f, 0.01429226f, -0.06165200f, -0.04867309f, 0.02499774f, -0.03118744f, 0.04982688f, 0.04698608f, 
    -0.05942056f, -0.02089603f, -0.03382591f, -0.02676821f, 0.02441424f, -0.05477151f, 0.00352954f, -0.00332561f, 
    -0.04689799f, 0.04626935f, -0.03854706f, 0.02530973f, -0.03290295f, -0.00005981f, -0.00040789f, -0.01271440f, 
    0.01604290f, -0.05179752f, -0.03759439f, -0.04565914f, 0.02476736f, 0.02223893f, 0.02120894f, 0.04904888f, 
    -0.02372207f, 0.00609658f, -0.01074449f, -0.03870535f, -0.03737317f, 0.03972149f, 0.02945813f, 0.02803037f, 
    0.00970521f, 0.04362829f, -0.01975707f, -0.04937298f, 0.01386423f, -0.03983956f, -0.02486406f, -0.00003194f, 
    -0.03677673f, -0.00306526f, 0.00568800f, 0.00036298f, -0.05881727f, 0.04454947f, -0.02135311f, 0.02983356f, 
    0.02363875f, -0.05045726f, -0.06021696f, 0.04721891f, 0.03547623f, 0.02177809f, 0.02618917f, -0.03380754f, 
    0.03576865f, -0.05672455f, 0.04891305f, 0.02745510f, -0.05105273f, -0.02739155f, -0.04749687f, -0.03930663f, 
    0.02689181f, -0.00959184f, -0.01907916f, 0.03012195f, 0.05755394f, -0.01989070f, -0.01400195f, -0.05819710f, 
    -0.05389456f, -0.04329391f, -0.01784042f, 0.02559287f, -0.00115991f, 0.00084381f, 0.00534684f, 0.02849670f, 
    -0.02219312f, -0.04769624f, 0.04441803f, -0.03870629f, 0.00538482f, -0.03093497f, -0.00144143f, -0.01998028f, 
    -0.01584656f, -0.04660490f, -0.03696032f, -0.04156917f, -0.03476479f, -0.02234496f, 0.02521255f, 0.01965126f, 
    0.00420391f, 0.00416946f, 0.01612744f, 0.04737310f, -0.04306023f, 0.02931942f, 0.00453841f, 0.04431826f, 
    0.02338956f, -0.03294893f, 0.03826504f, -0.00596391f, 0.03247021f, -0.02764118f, 0.04995298f, 0.03234949f, 
    0.02447723f, 0.00782226f, -0.06282955f, -0.05136007f, -0.01403469f, -0.00701274f, -0.02019416f, 0.01663809f, 
    -0.03825688f, -0.02029719f, -0.01481234f, -0.00930140f, -0.00937910f, -0.02346207f, 0.04172440f, 0.04649900f, 
    -0.04625171f, -0.01486336f, 0.00578217f, 0.02931684f, 0.01296849f, 0.04520025f, -0.02928436f, -0.06016772f, 
    -0.04119785f, -0.02593200f, 0.00019187f, 0.03689286f, 0.01380495f, -0.05004608f, -0.01670048f, 0.03857777f, 
    0.74137294f, 0.51188463f, 0.00391808f, -0.08652543f, 0.26714587f, -0.22456297f, 0.06158667f, -0.06740130f, 
    0.14309646f, 0.02878978f, -0.07908228f, 0.11282203f, 0.05305739f, 0.06137369f, -0.07206979f, 0.06393763f, 
    -0.04222638f, -0.07517292f, -0.04520746f, 0.03589543f, -0.28566656f, -0.22043720f, -0.00958000f, -0.04574051f, 
    -0.13248985f, -0.06632616f, -0.00502478f, 0.00947179f, -0.06410584f, -0.08427087f, 0.13540661f, 0.03898094f, 
    0.12758946f, 0.05756364f, -0.05348856f, -0.05144379f, -0.10985935f, 0.11405045f, 0.12265481f, -0.03614592f, 
    -0.22802217f, -0.56958371f, -0.06175550f, 0.07672139f, 0.08501287f, -0.01556733f, 0.03438212f, -0.06831394f, 
    0.00988833f, -0.00021302f, 0.21680447f, -0.05830631f, -0.08300231f, 0.08980848f, 0.06353559f, -0.17238612f, 
    -0.05124597f, -0.03520285f, 0.20128269f, -0.12761046f, 0.41694555f, 0.41814348f, -0.25989288f, 0.00803671f, 
    -0.41363418f, -0.03112147f, -0.03506364f, -0.00407908f, 0.17431249f, -0.07025022f, -0.11157940f, 0.10051063f, 
    0.17351545f, -0.03406883f, 0.05825467f, 0.02674861f, 0.17975433f, 0.12382054f, 0.00411832f, -0.01833162f, 
    0.41936019f, 0.08800087f, 0.25763255f, 0.22851025f, 0.23889607f, -0.08798845f, -0.10239519f, 0.12372460f, 
    0.06511032f, -0.04469380f, 0.04748489f, -0.01439871f, 0.03583157f, -0.14370410f, -0.08597477f, -0.03091796f, 
    0.08341655f, -0.11385894f, 0.11338785f, -0.07539469f, 0.61229742f, 0.04041669f, 0.21326225f, -0.13577837f, 
    -0.20601967f, 0.14117952f, -0.04002651f, 0.09887434f, -0.05583494f, -0.10779633f, -0.03920336f, 0.00191844f, 
    -0.03551423f, 0.09072416f, -0.03323108f, 0.02682181f, 0.14908789f, -0.14735265f, -0.16500013f, -0.12102107f, 
    -0.03424046f, 0.16030210f, -0.02374416f, 0.27033472f, 0.14531359f, 0.10806939f, 0.08099183f, -0.04272765f, 
    0.29743448f, 0.08382093f, 0.05976335f, 0.09972870f, 0.07583293f, -0.07458016f, -0.05523654f, 0.03464874f, 
    -0.01250994f, 0.09964730f, 0.28092131f, -0.02342829f, -0.03677530f, 0.14637458f, -0.21597260f, 0.08045251f, 
    -0.08792000f, -0.32189655f, -0.04442491f, -0.05139816f, -0.09805034f, -0.03614978f, 0.02014146f, 0.00033049f, 
    0.04360541f, -0.11023308f, -0.01987188f, -0.20460677f, 0.10759138f, 0.18536930f, 0.14254503f, 0.09360093f, 
    -0.40168220f, 0.07589866f, 0.12959722f, 0.20636851f, 0.33559933f, 0.25769562f, 0.10228477f, 0.04634214f, 
    0.10453616f, 0.28854698f, 0.03734160f, 0.00920730f, 0.07334389f, 0.13286266f, 0.06027632f, 0.11073730f, 
    -0.04616325f, -0.04418404f, 0.06023543f, -0.15502496f, 0.40468147f, 0.46053097f, 0.24457419f, 0.02023005f, 
    0.23589571f, 0.06796721f, -0.03496322f, 0.01573889f, 0.09131574f, 0.14808720f, 0.05367607f, -0.00552831f, 
    -0.07537382f, 0.01401883f, -0.02660469f, -0.05739660f, 0.09667802f, -0.02471124f, -0.07321651f, -0.09796102f, 
    -0.19712636f, 0.27310222f, 0.26267099f, 0.09972374f, 0.10819452f, -0.05403499f, -0.00891930f, 0.13325745f, 
    -0.19739601f, -0.09128111f, 0.01220734f, 0.16554587f, -0.09213948f, -0.03123112f, 0.08383541f, 0.11789250f, 
    -0.05622344f, -0.06002497f, -0.08211457f, 0.05335660f, -0.14871384f, 0.04939434f, 0.26376274f, -0.18475123f, 
    -0.03816768f, 0.04724188f, 0.10906073f, -0.01522926f, 0.01348676f, -0.01355690f, -0.09922535f, 0.04677537f, 
    0.04511658f, 0.20181511f, 0.06143678f, -0.13610438f, 0.16694495f, 0.15262069f, -0.01082375f, -0.11648100f, 
    0.09338901f, -0.05781420f, 0.09602784f, 0.05310604f, -0.01557805f, -0.00502399f, 0.07858190f, -0.09485435f, 
    -0.01800158f, -0.19737966f, 0.02150533f, -0.03369561f, -0.09871757f, 0.09562014f, 0.05928217f, -0.01893777f, 
    0.00362021f, 0.12226932f, -0.16946036f, 0.06799971f, -0.17154704f, -0.18306163f, 0.17544134f, -0.08126821f, 
    -0.21118817f, 0.16151974f, -0.14023592f, -0.14078943f, 0.06543876f, -0.23208953f, 0.03981693f, -0.04421490f, 
    0.06801015f, -0.01424170f, 0.01046976f, -0.00772100f, -0.14950953f, 0.22152589f, -0.00351487f, -0.01592523f, 
    -0.14172235f, -0.01797100f, -0.04033799f, 0.15090774f, -0.13047777f, 0.03076579f, 0.06472398f, -0.06743202f, 
    -0.04767922f, 0.01438967f, -0.06978047f, -0.06051141f, 0.14440770f, 0.07989984f, -0.03419341f, -0.06481359f, 
    -0.24004912f, -0.12557350f, -0.05850374f, -0.15168342f, -0.32556280f, 0.03112914f, 0.33278367f, -0.06843489f, 
    0.21892947f, 0.25047562f, 0.16645011f, -0.04369081f, 0.03752150f, 0.06742249f, -0.05820866f, 0.01163620f, 
    0.02952494f, 0.14874139f, 0.00207682f, -0.01839353f, -0.03216609f, 0.03795838f, 0.12716582f, 0.07607771f, 
    -0.00695596f, -0.00413267f, -0.03686152f, 0.03371297f, -0.05975899f, 0.02198582f, -0.05011477f, -0.00180333f, 
    0.04088259f, -0.05402603f, -0.05029432f, 0.01640539f, -0.05659635f, -0.00440331f, -0.03867668f, -0.02241270f, 
    0.01270436f, 0.00385503f, 0.02111681f, -0.01714174f, -0.00533644f, 0.02202623f, 0.03863983f, -0.03926910f, 
    0.03994261f, 0.01983586f, 0.03297092f, 0.05178465f, 0.00984220f, 0.04941536f, -0.02546399f, -0.02519918f, 
    0.03871985f, -0.03810373f, -0.00446380f, -0.00642357f, 0.05393881f, -0.05270278f, -0.02108283f, 0.02464198f, 
    -0.02199774f, -0.05182545f, 0.01702988f, -0.05376643f, 0.00230397f, 0.04432955f, 0.01465026f, 0.02611597f, 
    0.04225267f, -0.03945762f, 0.03311487f, -0.01718763f, 0.03020834f, -0.03435533f, 0.02155274f, 0.03182840f, 
    0.02055670f, 0.02415469f, 0.01873199f, 0.02281766f, -0.01100667f, 0.03452774f, -0.05114536f, 0.03250521f, 
    0.01724648f, -0.04985607f, -0.04080031f, 0.04295225f, 0.00943033f, -0.04310567f, -0.02520088f, 0.03954547f, 
    0.03456144f, -0.05934028f, -0.03094872f, 0.04730126f, 0.03178436f, -0.04811073f, -0.03578936f, 0.04247492f, 
    -0.05283489f, 0.00686941f, 0.03622675f, 0.03991396f, 0.03233691f, 0.03332765f, -0.01041566f, 0.03798831f, 
    0.03910608f, -0.02379249f, -0.04549411f, -0.06099403f, -0.05228061f, -0.06140315f, -0.06512462f, 0.04696811f, 
    0.03413616f, 0.01287714f, -0.03696361f, -0.01229478f, 0.02398630f, 0.01640590f, 0.00617655f, 0.01644549f, 
    -0.03707017f, 0.00408596f, 0.04639085f, -0.00997124f, 0.02636911f, -0.00083421f, -0.00046311f, -0.02202391f, 
    0.03007212f, 0.01736548f, -0.02247197f, 0.04796164f, -0.01343291f, -0.03746403f, -0.03970898f, -0.00569634f, 
    0.04155870f, 0.02128315f, -0.04843909f, -0.03341650f, -0.04099175f, -0.01471646f, -0.04004725f, -0.03053637f, 
    -0.04780875f, -0.04952700f, -0.03786011f, -0.04610610f, -0.01488450f, -0.04253543f, -0.01109044f, -0.04962308f, 
    -0.03046074f, 0.00743225f, -0.03783750f, -0.05592499f, -0.01461026f, 0.03148270f, 0.05092270f, 0.03649725f, 
    0.01005352f, -0.02895406f, -0.00386794f, -0.01370694f, -0.02884082f, 0.03803909f, -0.02101630f, -0.02833192f, 
    0.03229084f, 0.02063038f, -0.01144539f, -0.04924157f, -0.04847010f, 0.03057454f, -0.03877649f, -0.02733821f, 
    0.00828328f, -0.00586765f, -0.02120110f, -0.01972885f, -0.04440991f, -0.04715058f, -0.05255540f, -0.00000209f, 
    0.02316502f, -0.03372570f, -0.05133239f, 0.03697302f, -0.02351802f, -0.02105417f, 0.03933611f, 0.02064092f, 
    0.00533084f, -0.05606720f, 0.02851518f, 0.00218335f, 0.04698677f, 0.03599231f, 0.01835763f, -0.05052423f, 
    0.05318211f, 0.04108347f, 0.03018679f, -0.01564164f, 0.02908976f, 0.02913259f, 0.00192293f, 0.04143532f, 
    0.01243603f, -0.00319593f, 0.00315897f, 0.03569435f, 0.01351917f, -0.04530369f, 0.01595498f, -0.01531819f, 
    -0.04064692f, 0.00368966f, 0.01501126f, -0.05458829f, -0.05202677f, -0.01545524f, -0.02828634f, 0.02199780f, 
    -0.06027333f, -0.04730415f, -0.00472155f, -0.02736167f, 0.04808545f, -0.04139132f, -0.05194937f, 0.01763620f, 
    -0.02126736f, 0.00105465f, 0.01643095f, 0.01074612f, 0.02209564f, 0.03363613f, 0.01494081f, -0.01700210f, 
    -0.04883119f, -0.02830516f, -0.04617595f, 0.02329569f, 0.02395293f, 0.03116126f, -0.02669453f, 0.03530036f, 
    -0.00245098f, -0.05077838f, -0.04318407f, 0.04684900f, 0.00989279f, -0.03135440f, 0.04579926f, 0.04746113f, 
    -0.00455893f, 0.01746078f, 0.02782899f, -0.05557312f, 0.02101572f, -0.03651180f, -0.01983000f, 0.04170163f, 
    -0.01493933f, -0.02137303f, -0.00236279f, -0.03947757f, -0.04439332f, -0.05893618f, 0.01219701f, 0.04448262f, 
    0.01482039f, 0.02688977f, 0.03675857f, -0.00855636f, -0.06074531f, 0.04104214f, -0.02395941f, 0.02552637f, 
    0.00587474f, 0.03054585f, -0.04975708f, 0.01872533f, -0.01474927f, -0.03860615f, -0.04796364f, -0.02964322f, 
    0.03326735f, -0.04478811f, 0.02920754f, 0.04825912f, -0.03543444f, -0.01871368f, -0.06012642f, 0.03548058f, 
    -0.02597249f, -0.04556948f, -0.04914241f, 0.02866618f, 0.02362609f, -0.01806807f, 0.01349451f, -0.05733029f, 
    -0.05943463f, 0.02351568f, 0.02619778f, 0.04227538f, 0.00235291f, -0.02807810f, -0.05850092f, -0.01739644f, 
    -0.01691299f, 0.01443809f, 0.04720945f, 0.01009739f, -0.04315526f, 0.04546572f, -0.04412350f, 0.01037224f, 
    -0.06349378f, -0.06400232f, -0.06221617f, -0.05034084f, -0.02224602f, -0.03563639f, -0.05133452f, 0.03355294f, 
    -0.03291595f, -0.02058469f, 0.03459731f, -0.00254304f, 0.02723078f, -0.00309930f, 0.03138162f, -0.04862844f, 
    -0.04475344f, 0.04827859f, -0.05491996f, -0.05468212f, 0.02517273f, -0.04611615f, -0.03552505f, -0.03092346f, 
    -0.00870570f, 0.04511395f, -0.05483300f, 0.02104977f, 0.04424764f, -0.03410863f, 0.00755889f, -0.03489093f, 
    0.04421007f, 0.00120213f, 0.03528190f, -0.04830960f, 0.03249957f, -0.04513755f, -0.01456388f, 0.04370365f, 
    -0.01573933f, 0.03849892f, 0.04773102f, 0.02930430f, -0.05517786f, -0.00213372f, 0.00463709f, 0.00018941f, 
    0.01069625f, 0.01364992f, -0.02310761f, 0.02516974f, -0.00112299f, 0.00601191f, -0.00689521f, -0.02604464f, 
    0.00812544f, 0.03099878f, 0.04447784f, -0.04139998f, -0.01203564f, 0.02252385f, 0.03053383f, -0.05820388f, 
    0.03471913f, 0.02455370f, 0.00066630f, 0.03316269f, -0.05222862f, -0.01902287f, 0.04476502f, -0.05396990f, 
    0.01439089f, -0.02238588f, 0.00021101f, -0.00634549f, -0.02093089f, 0.03245747f, -0.02960280f, 0.03778312f, 
    0.00412732f, -0.02056090f, 0.00411877f, -0.01561523f, 0.03085628f, -0.01209575f, 0.02950462f, -0.03361229f, 
    0.03834441f, -0.06368528f, -0.02163203f, 0.00163580f, 0.04879464f, -0.04955754f, 0.05011679f, -0.03544116f, 
    0.02053007f, 0.03215399f, 0.00819233f, -0.04768375f, 0.00345093f, 0.05374754f, -0.03489766f, 0.00549036f, 
    -0.05050484f, -0.01385302f, -0.03771644f, -0.06120973f, 0.03769630f, -0.04465562f, 0.00749563f, 0.02491757f, 
    -0.05068231f, -0.05540613f, 0.03845751f, -0.05237263f, -0.00456136f, 0.04700002f, -0.05522628f, 0.01202859f, 
    0.02169430f, -0.03802342f, 0.01033789f, -0.00874671f, -0.05480366f, -0.00941747f, 0.02092959f, -0.05848699f, 
    0.00851598f, -0.04291339f, -0.03015340f, -0.01096154f, -0.02328084f, -0.00720294f, -0.02408464f, -0.00785280f, 
    -0.02192130f, 0.01664770f, -0.03958559f, -0.02080995f, 0.01799801f, 0.01235365f, -0.04911753f, 0.00331357f, 
    -0.03030609f, -0.02254925f, -0.02526360f, -0.02956251f, -0.00451903f, 0.03882370f, -0.01174000f, -0.00311821f, 
    0.04289124f, -0.05032332f, -0.01421100f, 0.00610401f, -0.02849812f, -0.00632223f, -0.01246306f, -0.02283924f, 
    0.02837265f, 0.04204189f, -0.05580827f, -0.04746201f, 0.01070483f, 0.01635942f, 0.03138454f, -0.01390854f, 
    -0.02340854f, -0.02701742f, 0.02201145f, -0.04031859f, 0.04085356f, -0.01318380f, 0.00137042f, -0.04373584f, 
    -0.06437679f, -0.01219229f, -0.01928203f, 0.04001624f, 0.01500139f, -0.04322149f, 0.03791295f, 0.00467171f, 
    -0.01976448f, -0.02019678f, -0.03580042f, -0.05278258f, -0.06091370f, 0.01765619f, -0.05936294f, -0.04911069f, 
    -0.02156883f, -0.03224756f, -0.01977479f, 0.03630902f, 0.04926839f, -0.05801015f, 0.00062434f, 0.02702425f, 
    0.00228234f, 0.02916260f, -0.02109611f, 0.02690406f, 0.02082780f, -0.04791956f, 0.00056062f, 0.02619773f, 
    0.04632461f, -0.01190216f, -0.00998911f, -0.02955053f, -0.03698912f, 0.02433019f, 0.00782068f, -0.02505795f, 
    0.02050402f, -0.03095324f, -0.00548880f, -0.02938234f, -0.06150745f, -0.00519493f, -0.04542764f, -0.01760439f, 
    0.05036391f, 0.00581246f, 0.02104494f, -0.02616412f, 0.02205566f, 0.02751946f, 0.02643002f, 0.01685334f, 
    -0.01059751f, 0.03887840f, -0.01375490f, 0.00266059f, -0.01234452f, 0.01312005f, -0.06669232f, 0.04429772f, 
    -0.01680935f, -0.02709476f, 0.02407295f, -0.00882088f, -0.00479757f, -0.00615187f, -0.05899191f, 0.04780871f, 
    0.01931862f, -0.05785269f, -0.02652643f, -0.03828850f, -0.01386989f, 0.03334243f, 0.04425180f, 0.00371263f, 
    0.01580785f, 0.04415023f, 0.02173788f, 0.01592582f, -0.00591711f, 0.02900974f, -0.04427121f, 0.00312439f, 
    -0.00166525f, 0.03751645f, -0.05871698f, -0.01343311f, -0.04582680f, -0.01722250f, -0.01612794f, 0.03171697f, 
    -0.01328150f, -0.01069487f, 0.02189923f, -0.04688683f, -0.00432028f, -0.05135659f, 0.00833127f, -0.00845472f, 
    -0.03580378f, -0.01785695f, -0.01830334f, -0.06612305f, 0.01225914f, 0.01484568f, -0.06049158f, 0.01814578f, 
    0.02604893f, 0.02234402f, -0.02765822f, 0.02608389f, -0.02845869f, 0.04415355f, -0.01281987f, 0.02365085f, 
    -0.03863768f, -0.04071234f, -0.00708076f, -0.04466289f, -0.01466809f, 0.01086447f, -0.00123163f, -0.01244550f, 
    0.00653278f, -0.02392576f, -0.04449992f, 0.04565113f, 0.02007481f, 0.03571828f, 0.01708144f, -0.03604691f, 
    0.04397213f, -0.03998732f, -0.02663007f, -0.05255784f, 0.00313402f, -0.03608557f, 0.03951080f, -0.04088740f, 
    0.00268184f, 0.03917619f, -0.04503570f, -0.02041902f, -0.06076328f, -0.02260575f, -0.03052315f, -0.01195789f, 
    -0.00873355f, 0.03312032f, -0.02771491f, 0.03263364f, -0.05972013f, 0.02334418f, 0.01224095f, -0.02419592f, 
    0.59954429f, -0.06560434f, -0.01051609f, 0.05676216f, 0.07950439f, -0.21776719f, 0.08792325f, 0.05111680f, 
    0.15970618f, -0.01454815f, 0.19248019f, 0.02908991f, 0.11297507f, 0.07246861f, -0.06264272f, 0.06951065f, 
    0.05584025f, -0.11439928f, 0.12477580f, -0.10230300f, -0.23100241f, 0.10948248f, -0.11461692f, -0.16052900f, 
    0.01349372f, 0.09468606f, 0.22630668f, 0.20077693f, 0.01890265f, -0.03937920f, 0.16179809f, -0.05755861f, 
    0.08485228f, -0.03095900f, -0.06039223f, 0.21273045f, -0.05031689f, 0.20504001f, 0.28149530f, 0.20250644f, 
    -0.66607076f, 0.32179856f, 0.05686444f, -0.01030007f, 0.15353778f, -0.08146373f, 0.01807644f, 0.19477704f, 
    -0.15052085f, -0.08598708f, 0.03513622f, -0.07467452f, -0.19588549f, -0.04700284f, -0.06083407f, 0.01794011f, 
    -0.02521289f, -0.05850981f, 0.14336853f, -0.03951448f, 0.17856550f, 0.22285651f, -0.10579722f, -0.06067039f, 
    0.00934055f, 0.12147439f, -0.01740208f, -0.02234613f, 0.03939539f, 0.01509956f, 0.16662747f, 0.06597405f, 
    -0.04185141f, 0.08659922f, -0.00985736f, -0.01508610f, 0.19722298f, 0.06685511f, 0.01434307f, 0.10819259f, 
    0.34558070f, 0.44629747f, 0.02864560f, 0.32775444f, 0.12608968f, 0.09321371f, -0.00329275f, 0.17795804f, 
    0.05133905f, -0.00032697f, 0.17157088f, 0.19814828f, 0.03094026f, 0.05056233f, -0.10356180f, -0.02497712f, 
    -0.00948088f, -0.14103985f, -0.04679527f, -0.00977406f, -0.03924086f, 0.37630966f, -0.00584594f, 0.04964371f, 
    0.19616564f, -0.08598476f, 0.06397396f, 0.05795982f, 0.18221281f, -0.03116386f, -0.11968261f, 0.03437855f, 
    -0.01609921f, 0.10417637f, -0.02446219f, -0.00356050f, 0.06633078f, -0.03406519f, 0.07957181f, -0.03400178f, 
    0.08259581f, 0.24898227f, -0.13103566f, -0.38028273f, 0.08611742f, -0.13471258f, -0.21690892f, 0.17186941f, 
    -0.06783364f, 0.05178931f, -0.01070814f, -0.09226856f, 0.08808445f, -0.06112886f, 0.19188058f, 0.00046707f, 
    0.12756038f, 0.01916679f, 0.25433204f, 0.16680515f, 0.51096272f, 0.30927470f, -0.28073686f, 0.14034505f, 
    -0.12376947f, 0.13955225f, 0.14068837f, -0.09781729f, 0.03334204f, 0.00703607f, 0.12870513f, 0.15872733f, 
    -0.15653023f, -0.02301009f, -0.00935882f, -0.09848054f, -0.00295604f, 0.24853766f, 0.01656460f, 0.01594163f, 
    -0.25302556f, -0.58642322f, -0.08338357f, 0.03971481f, -0.12623486f, 0.15866393f, -0.08392004f, 0.00561030f, 
    -0.07171983f, 0.20184770f, -0.02806814f, -0.06366813f, 0.03691331f, 0.10360997f, 0.06845342f, -0.04567903f, 
    0.09381408f, -0.16266443f, -0.06589536f, -0.08223496f, -0.10759731f, -0.19201136f, -0.17795955f, 0.32433599f, 
    -0.24027577f, -0.02495503f, 0.15535344f, -0.02636126f, 0.08218154f, 0.14187308f, -0.20688474f, -0.08725480f, 
    0.03644954f, 0.02246732f, -0.00422318f, 0.00327347f, 0.11732267f, -0.00148890f, -0.15545504f, -0.00904143f, 
    0.10442764f, -0.43539605f, -0.11744198f, -0.06671003f, -0.08625767f, 0.17808174f, 0.03454413f, 0.05410820f, 
    0.11284095f, 0.02072554f, -0.02146930f, 0.06981224f, 0.02702795f, 0.17730424f, -0.04856752f, -0.01920350f, 
    -0.05291538f, -0.06300826f, -0.24990571f, 0.06966133f, -0.21991922f, -0.02779561f, -0.07082352f, 0.06526612f, 
    0.05820256f, -0.25798789f, -0.04110854f, 0.04913808f, 0.01508522f, -0.14061774f, -0.00867355f, 0.09374192f, 
    0.23473865f, 0.07087174f, 0.28530774f, 0.17014818f, 0.03359710f, 0.13712855f, 0.02403443f, 0.06960217f, 
    0.11080921f, -0.00587005f, -0.06012884f, -0.36979768f, 0.07672948f, -0.22094819f, 0.05066216f, 0.03899477f, 
    0.08464624f, -0.04322638f, -0.03072630f, -0.11223932f, 0.10652136f, 0.07213234f, -0.03771290f, -0.00858997f, 
    0.15686889f, 0.16317755f, 0.12981097f, 0.09304219f, 0.34566569f, 0.01800140f, -0.06225679f, -0.04808090f, 
    0.14878958f, -0.03847211f, 0.14773165f, -0.03147724f, 0.00047807f, -0.16773026f, 0.04830881f, -0.03273511f, 
    -0.07097723f, 0.14747575f, 0.01769322f, -0.07905058f, -0.02969770f, 0.14163469f, 0.12396900f, -0.01311405f, 
    -0.17189300f, -0.35493058f, -0.10564854f, 0.24931039f, 0.12204365f, 0.01728562f, 0.10905083f, 0.05249289f, 
    0.07234004f, 0.06219517f, 0.00296388f, 0.01673111f, 0.29981315f, -0.07200301f, -0.06963422f, -0.15467590f, 
    -0.04956879f, -0.20096874f, -0.04513038f, -0.10224404f, 0.02417538f, -0.22686543f, -0.11885527f, -0.06698620f, 
    0.08126285f, -0.15012735f, -0.11879810f, -0.02449624f, 0.07696022f, -0.07044824f, 0.01811318f, 0.00512813f, 
    0.02930390f, 0.21588618f, 0.13343012f, 0.03923128f, 0.00366838f, 0.01206140f, 0.03745812f, 0.19158165f, 
    0.29902324f, -0.15486254f, -0.29052234f, -0.40174338f, 0.07058211f, 0.14705990f, 0.18732792f, -0.14181983f, 
    0.01529409f, -0.03377613f, 0.04831926f, 0.04954883f, -0.04239352f, 0.11545913f, -0.05136668f, 0.07080084f, 
    0.08680307f, 0.00283607f, -0.00477887f, -0.06357786f, 0.04567527f, 0.24911620f, -0.09800524f, 0.01850422f, 
    0.05065275f, 0.16859552f, 0.13297616f, 0.06528204f, 0.05091585f, -0.14158896f, 0.17667760f, 0.09150255f, 
    0.11069476f, -0.14315759f, -0.02994748f, 0.19692640f, 0.07672568f, -0.06578703f, -0.07149281f, 0.11968139f, 
    0.08751940f, 0.37635711f, 0.10177537f, -0.11603086f, 0.25651762f, -0.12073352f, 0.03547366f, 0.20203875f, 
    -0.13297530f, -0.04243693f, 0.09059611f, -0.15568273f, -0.14722002f, -0.05736159f, -0.11063907f, 0.04751256f, 
    0.07465814f, -0.03939876f, 0.19912198f, 0.01639749f, -0.13496336f, 0.41291454f, -0.04070384f, 0.04038459f, 
    -0.06593433f, 0.22487910f, 0.17136849f, 0.03604192f, -0.06367005f, -0.05690351f, 0.13753189f, 0.01689290f, 
    0.06043939f, 0.01041730f, 0.10927323f, 0.03222434f, 0.16762577f, 0.02129485f, 0.05524633f, -0.05776018f, 
    -0.16558547f, -0.17664000f, -0.12198170f, -0.01818174f, -0.14452855f, 0.33426151f, 0.12486593f, 0.02039221f, 
    -0.01528873f, -0.01990800f, 0.08495296f, 0.16173983f, -0.05884453f, 0.12196894f, -0.11466414f, 0.18054946f, 
    0.03621713f, -0.07083947f, -0.09165150f, -0.01460719f, 0.03809521f, 0.19593202f, -0.31075236f, 0.09160052f, 
    0.00187422f, 0.06332729f, 0.05521228f, -0.05182689f, 0.15816511f, 0.18272826f, -0.10719347f, 0.13874744f, 
    0.03791571f, 0.10585681f, 0.02140186f, 0.16320311f, 0.14128704f, -0.08264278f, -0.13946013f, 0.08770268f, 
    0.32632113f, 0.25223762f, 0.25858444f, -0.20104650f, 0.28290829f, 0.07551534f, -0.16034001f, 0.09216133f, 
    -0.11539240f, -0.00094795f, 0.08220811f, -0.03277196f, 0.03360074f, -0.11326355f, 0.05261831f, 0.02642663f, 
    0.08046166f, 0.02646171f, 0.12399945f, 0.17528349f, -0.19054775f, 0.20027050f, -0.27370548f, -0.04556626f, 
    -0.19119693f, 0.20089678f, 0.15862031f, -0.04661641f, -0.15381229f, -0.09451111f, 0.14244761f, 0.23856685f, 
    -0.00671468f, 0.05127587f, -0.09633663f, -0.02067627f, 0.00115105f, 0.16222490f, -0.12016252f, 0.09588080f, 
    0.21531135f, -0.51649439f, 0.25192618f, 0.23367240f, 0.24608199f, -0.06238780f, -0.18098336f, 0.01131194f, 
    0.04758374f, 0.32609531f, -0.05560312f, -0.02669471f, 0.00871561f, 0.06540454f, 0.08935501f, -0.16109836f, 
    0.05029245f, -0.00560469f, -0.11301113f, -0.12574613f, -0.39313301f, -0.13430099f, -0.32398245f, -0.05432807f, 
    -0.58892572f, 0.16320726f, 0.18115357f, 0.10479341f, -0.08817116f, 0.16843764f, -0.00483932f, -0.05498595f, 
    0.06811918f, -0.04240873f, 0.05544193f, -0.05450099f, 0.01872362f, 0.11323786f, -0.05843721f, -0.12231182f, 
    -0.20699154f, -0.11738592f, 0.08678473f, 0.04438581f, 0.08930861f, -0.05551646f, -0.02766507f, 0.14310287f, 
    0.17728718f, 0.09455138f, 0.01463363f, 0.02738632f, -0.03632723f, 0.04672756f, 0.00640344f, -0.05549359f, 
    -0.14526863f, -0.00625038f, -0.03019653f, 0.03841357f, 0.26893622f, 0.03939776f, 0.19507228f, 0.20652747f, 
    0.21721931f, -0.17689547f, -0.14090526f, -0.08536600f, -0.05747871f, -0.07916845f, -0.03552419f, 0.04395889f, 
    0.15663810f, 0.12907335f, 0.07706224f, -0.01739207f, 0.01268993f, 0.00461180f, -0.03128218f, -0.06099389f, 
    0.11023989f, 0.29934746f, 0.01222883f, -0.11492315f, 0.20415196f, -0.18104112f, -0.07074793f, 0.12220229f, 
    0.08661397f, -0.12739581f, -0.04966154f, -0.11817265f, -0.04186113f, -0.02266140f, -0.10150747f, -0.00353235f, 
    0.01133282f, -0.01216996f, 0.03715026f, 0.10059413f, 0.18654305f, 0.28589770f, -0.06740914f, -0.11225430f, 
    0.05431001f, 0.16392015f, 0.04197014f, -0.11030750f, 0.07366297f, -0.14814533f, -0.01084423f, 0.08117452f, 
    0.01550682f, 0.10162967f, 0.11839673f, -0.06548561f, 0.05662712f, 0.13999982f, 0.12365997f, -0.02934007f, 
    -0.14909196f, -0.30690750f, -0.09245974f, 0.16901538f, 0.12418798f, 0.05695444f, 0.09427512f, 0.13144585f, 
    0.06468762f, 0.12743305f, 0.06460777f, 0.01748556f, 0.21925098f, -0.06446193f, -0.04240905f, -0.09594334f, 
    -0.05462324f, 0.02025151f, 0.01362951f, 0.03738923f, 0.34054974f, -0.06883799f, 0.39864713f, 0.24740347f, 
    0.36054823f, -0.18799247f, -0.21144144f, 0.02013530f, 0.10182850f, 0.05133671f, -0.09600312f, -0.04025707f, 
    -0.00235610f, 0.05281677f, -0.10725871f, -0.05914529f, -0.13857368f, -0.01875805f, -0.01323496f, 0.12031908f, 
    -0.16432695f, 0.01362022f, 0.00745480f, 0.00573830f, -0.29631448f, 0.20402326f, 0.00854847f, -0.13064988f, 
    0.09777514f, 0.08569637f, 0.05368192f, 0.09135284f, -0.02771209f, -0.15002780f, 0.13405219f, -0.12090462f, 
    -0.07267585f, 0.16599211f, 0.05803775f, 0.01286380f, 0.12581980f, 0.13645224f, 0.25643936f, 0.25014517f, 
    -0.06474216f, -0.09741619f, -0.13514739f, -0.03493097f, 0.10002185f, -0.18810889f, 0.05096942f, -0.02483398f, 
    -0.03843561f, 0.10842062f, 0.09175168f, 0.07886831f, 0.02540095f, -0.05594390f, -0.06660701f, -0.01662838f, 
    0.52333146f, 0.02592099f, -0.02096184f, -0.21588190f, 0.28408191f, 0.16074450f, -0.01411043f, 0.09670617f, 
    -0.01358908f, -0.08112775f, 0.07027993f, 0.11189666f, 0.11957208f, -0.02972467f, 0.13111001f, 0.06551698f, 
    0.00267597f, 0.05765303f, -0.11990774f, 0.14744104f, -0.10636984f, 0.21956459f, -0.39276436f, -0.02469947f, 
    0.01550062f, 0.07084949f, 0.04742961f, 0.08936319f, -0.10916351f, -0.02680997f, 0.16096225f, 0.04911107f, 
    0.20782074f, 0.03535653f, 0.00182918f, 0.08811422f, 0.04265485f, -0.04527609f, 0.16388324f, 0.12567760f, 
    -0.24960609f, -0.03238932f, 0.29367694f, 0.15710871f, -0.48203513f, 0.16061866f, 0.03581754f, 0.01489523f, 
    0.00644877f, 0.08731904f, 0.00952644f, 0.01306496f, 0.00741662f, 0.04655937f, 0.16337991f, 0.15669644f, 
    -0.11937378f, -0.06774204f, 0.08160096f, -0.03573224f, -0.13948953f, -0.23843628f, -0.00562013f, 0.41516703f, 
    -0.13983260f, 0.15686120f, -0.09281982f, 0.07542418f, -0.10840782f, 0.04477653f, 0.04574019f, 0.04819793f, 
    -0.06728236f, 0.01087970f, 0.02493127f, 0.03679228f, 0.09433938f, 0.09343170f, -0.02489872f, 0.06301231f, 
    -0.54321098f, 0.13071939f, -0.02869981f, -0.33685976f, 0.37226713f, 0.15653819f, 0.03268651f, 0.10766499f, 
    0.00382737f, -0.03549053f, 0.05288071f, 0.21564129f, -0.02269547f, -0.02531840f, -0.05788674f, -0.01361128f, 
    0.02488529f, -0.05965452f, -0.06172176f, 0.16899925f, -0.42246681f, 0.15479840f, -0.15147771f, 0.10336944f, 
    -0.29409152f, 0.00244088f, 0.02783057f, -0.04499537f, -0.02349763f, 0.04396824f, -0.00443703f, 0.05701568f, 
    0.02535070f, 0.12296073f, -0.00386570f, -0.10758997f, 0.06094761f, 0.01473972f, 0.05328868f, 0.14225851f, 
    -0.25433829f, -0.10926990f, 0.07376167f, -0.11154073f, 0.46090898f, -0.07234625f, -0.03103609f, 0.14211562f, 
    0.06470389f, 0.05326150f, 0.04066129f, -0.01612339f, 0.03077702f, 0.05797753f, -0.01722479f, -0.11231990f, 
    0.06851345f, 0.01296388f, 0.05979049f, -0.02731972f, -0.02671183f, 0.19491467f, -0.12624410f, 0.09065370f, 
    -0.28571177f, 0.22576714f, 0.09391392f, 0.03505936f, -0.00153881f, 0.08725771f, 0.11527310f, -0.02283232f, 
    0.15881352f, -0.05603088f, 0.13543531f, 0.01501484f, 0.00750013f, 0.02994095f, 0.01387338f, -0.07902093f, 
    -0.48707390f, 0.25680909f, 0.04754966f, 0.01570862f, 0.40070766f, -0.06021224f, 0.03469211f, 0.07612706f, 
    -0.00840892f, -0.13354102f, 0.06448218f, 0.03329727f, -0.05457531f, -0.04778381f, 0.03257562f, -0.15673602f, 
    -0.05055697f, -0.05838267f, 0.09750697f, -0.10119278f, 0.11186307f, 0.16957872f, -0.02159293f, -0.05980943f, 
    0.06109800f, 0.07579736f, 0.12268890f, 0.01771506f, -0.05493679f, -0.12394524f, 0.10647752f, -0.08847413f, 
    -0.01841592f, -0.02334403f, -0.05632765f, -0.06388766f, -0.02486646f, 0.01653545f, -0.10080657f, -0.05260382f, 
    -0.19476265f, -0.04550157f, -0.13711050f, -0.14634374f, 0.35110494f, -0.01196412f, -0.10630786f, 0.07081167f, 
    -0.02700450f, 0.02204385f, 0.00178828f, 0.03892246f, 0.10704353f, -0.07154630f, 0.00670724f, -0.10972820f, 
    -0.06872746f, 0.12290962f, 0.02145422f, 0.03936522f, -0.14387295f, -0.06444304f, 0.17584033f, 0.19568451f, 
    -0.17594261f, -0.00542483f, 0.05140390f, -0.08231370f, -0.01994194f, 0.03729800f, -0.05760814f, 0.12508731f, 
    0.01531681f, 0.05086510f, -0.14618152f, -0.13835676f, 0.19297087f, -0.18605034f, 0.08347817f, 0.23715037f, 
    -0.04151461f, 0.16709808f, -0.18042342f, 0.14161561f, -0.01350719f, 0.15610661f, -0.02247659f, -0.13500662f, 
    0.05330789f, 0.16041198f, -0.02164537f, 0.05511514f, 0.03225215f, -0.03754289f, 0.00574423f, 0.19092965f, 
    -0.01391073f, 0.00580607f, 0.07259345f, -0.09366046f, -0.24256390f, 0.06261008f, 0.08159459f, -0.17223325f, 
    0.36660883f, -0.06086444f, 0.24353138f, -0.00530655f, -0.05042490f, -0.07379735f, 0.03934880f, -0.03922639f, 
    0.06647275f, -0.02311819f, 0.12316165f, 0.01716311f, 0.12064555f, -0.06197564f, -0.06813361f, 0.02627320f, 
    -0.37135240f, -0.09089741f, -0.07306346f, -0.05469833f, 0.03999581f, -0.16754976f, -0.10197758f, 0.03623030f, 
    -0.01074474f, 0.16464488f, 0.02764013f, -0.04267972f, 0.03100784f, 0.01234702f, 0.17377780f, -0.01375234f, 
    -0.07982965f, -0.00566840f, 0.05067383f, 0.10913462f, 0.39663893f, 0.26600036f, 0.23577538f, 0.61356610f, 
    0.13976845f, -0.05188232f, 0.01578252f, -0.06848961f, -0.05377181f, -0.01735091f, -0.09058254f, 0.01181990f, 
    -0.25466764f, 0.09513030f, 0.01687217f, -0.05726080f, 0.03822637f, 0.11604421f, 0.18236619f, -0.02590785f, 
    0.07983340f, 0.24237208f, -0.10504843f, 0.21131770f, 0.06744480f, 0.15824309f, 0.02205916f, -0.05455778f, 
    0.13080889f, 0.07337780f, -0.02732460f, -0.07318453f, 0.00498950f, 0.05328884f, -0.02469498f, 0.05970627f, 
    0.13202307f, 0.06689002f, 0.14538386f, 0.14134218f, 0.27472982f, -0.05217003f, -0.04666973f, 0.14798433f, 
    0.20165764f, 0.16245322f, -0.02209187f, 0.21482047f, -0.00245725f, -0.06785421f, -0.05603593f, 0.20932429f, 
    0.10487391f, -0.00452037f, -0.00478623f, 0.08561023f, 0.07150082f, -0.06412210f, -0.00566383f, 0.02925981f, 
    0.08891264f, -0.00310305f, -0.08385444f, -0.09212612f, 0.11158711f, -0.28471905f, -0.12294024f, -0.01417233f, 
    -0.00588581f, 0.12810670f, 0.09967310f, 0.03131075f, -0.07122912f, 0.01842751f, 0.22746255f, 0.00104395f, 
    0.01895407f, -0.01289702f, -0.02808660f, 0.15896082f, -0.39106277f, 0.48255458f, 0.19436446f, -0.08398300f, 
    -0.09438185f, 0.07845958f, -0.00121451f, -0.00670948f, 0.15849437f, -0.05784080f, 0.05710431f, 0.11375614f, 
    0.04630969f, 0.06596263f, 0.04979169f, 0.06913755f, -0.03480053f, -0.01501646f, 0.00491879f, -0.11470093f, 
    0.06825130f, 0.05027170f, -0.27231318f, 0.10890394f, -0.13207689f, 0.09830377f, -0.05624737f, 0.01212340f, 
    0.09932558f, -0.06654308f, 0.07866058f, 0.06770409f, 0.00923279f, 0.00219188f, -0.08798482f, 0.02749216f, 
    -0.09504824f, -0.08268102f, 0.15479645f, 0.10998538f, 0.25459996f, -0.10528966f, 0.23892061f, 0.21263316f, 
    0.51023304f, -0.00675048f, -0.06270308f, -0.03478846f, 0.09842428f, 0.02383325f, 0.04615092f, 0.04996394f, 
    0.07412987f, 0.07003630f, -0.07292036f, 0.07688123f, 0.00150508f, 0.01962935f, 0.00101423f, -0.00432723f, 
    -0.15774000f, 0.25589928f, -0.10355605f, -0.12027864f, -0.10764575f, 0.08243865f, 0.05679539f, 0.05158925f, 
    0.12453432f, -0.13277391f, 0.02865059f, 0.10735262f, 0.02230716f, -0.05195024f, -0.00928209f, 0.00810933f, 
    0.05338004f, -0.00867930f, -0.06113263f, 0.01852573f, -0.05628019f, -0.33692363f, -0.12393062f, -0.29413682f, 
    -0.17666130f, -0.04801414f, -0.16785271f, 0.20304552f, 0.08926785f, 0.08073483f, 0.13153434f, -0.00998421f, 
    -0.02265568f, 0.11040939f, -0.02863169f, 0.01074047f, 0.03536756f, 0.01873597f, -0.13595709f, -0.06144514f, 
    -0.30806729f, -0.01278465f, 0.00296772f, -0.02965124f, -0.09074299f, -0.01012659f, -0.03477578f, 0.05366658f, 
    -0.10803787f, 0.11965751f, -0.04752864f, 0.09666175f, -0.07483148f, -0.04319308f, 0.00527061f, -0.04003050f, 
    0.00036107f, 0.06203301f, -0.00078747f, -0.03602657f, -0.14049062f, 0.41719520f, 0.28890198f, -0.14637347f, 
    -0.27396467f, -0.01083914f, -0.06506413f, -0.04401658f, 0.21025223f, -0.18952438f, -0.13141951f, 0.04132950f, 
    0.00467369f, 0.03471730f, -0.13774115f, 0.01742323f, -0.05881086f, 0.08761192f, -0.01060951f, -0.04165942f, 
    0.37766927f, -0.30908546f, -0.17842126f, 0.50671065f, -0.14255990f, 0.17181312f, -0.02415838f, 0.06128487f, 
    0.06823847f, 0.02613185f, -0.07085763f, 0.08563005f, -0.08845458f, 0.05622239f, 0.04350317f, 0.05350897f, 
    -0.11787082f, 0.10936458f, -0.09161241f, 0.04839367f, 0.51732564f, 0.04211178f, 0.09879012f, 0.31106195f, 
    0.01673195f, -0.09321156f, 0.04455733f, -0.00800925f, 0.05636729f, 0.05254214f, 0.11495224f, 0.09111246f, 
    -0.03116081f, 0.00624342f, 0.07040686f, 0.11254209f, -0.11542317f, 0.05453576f, -0.21327107f, -0.00812258f, 
    0.08488715f, -0.24685553f, -0.07590373f, -0.07260185f, -0.15359698f, 0.19859447f, 0.06684350f, 0.10332318f, 
    -0.05829955f, 0.13389821f, -0.11345024f, 0.02453423f, -0.05182679f, 0.01708054f, -0.17017503f, 0.12003526f, 
    -0.13015252f, 0.18411545f, -0.00289673f, -0.06107119f, 0.07002413f, 0.45859116f, 0.05631578f, -0.03441128f, 
    -0.22005048f, -0.02121646f, 0.06288956f, 0.08285141f, 0.07315502f, -0.18151127f, 0.00623016f, -0.02232256f, 
    -0.02429715f, 0.00262700f, -0.05813866f, 0.04545533f, 0.10402894f, 0.03552950f, -0.04012306f, 0.04018293f, 
    0.11173172f, -0.08684614f, 0.07192343f, 0.16461873f, 0.11900814f, 0.22980548f, 0.33187291f, 0.02492791f, 
    -0.05308997f, -0.05275668f, 0.00770616f, -0.01120777f, -0.12377644f, -0.03196674f, 0.05971871f, 0.00521215f, 
    0.21169461f, 0.12281534f, -0.03319681f, 0.05906309f, 0.27465868f, 0.03906424f, -0.33977914f, -0.10248666f, 
    -0.23353371f, 0.02633895f, -0.02573855f, -0.01275072f, 0.03459321f, -0.10786910f, 0.09486409f, -0.13194470f, 
    -0.04992633f, 0.05431361f, 0.19303903f, -0.11139219f, 0.02522533f, -0.17170286f, -0.32502624f, -0.08259342f, 
    0.25361857f, 0.32209355f, 0.03414959f, 0.12396633f, -0.23838218f, -0.07934207f, 0.02758845f, -0.04537893f, 
    0.13841482f, 0.15357277f, -0.07823089f, 0.04144727f, 0.17471386f, 0.19304150f, 0.13914110f, 0.00580751f, 
    0.02236773f, -0.06674462f, -0.16871220f, 0.10531379f, -0.15946151f, -0.10059716f, 0.13272071f, -0.13559538f, 
    -0.27639529f, -0.07667156f, -0.27991086f, -0.03999078f, 0.06262431f, 0.11533427f, 0.07289539f, -0.01043458f, 
    -0.21030353f, 0.00690895f, 0.11368421f, -0.12312087f, -0.10869680f, 0.02707674f, -0.02743911f, 0.01318541f, 
    0.45194191f, -0.02138295f, -0.27432635f, 0.04587033f, 0.38131666f, 0.03383461f, 0.26377758f, 0.07017840f, 
    -0.07204251f, 0.05346221f, 0.07452463f, -0.04792910f, 0.11816993f, 0.18836811f, 0.11432471f, 0.01699041f, 
    0.03238621f, 0.15332916f, -0.02836789f, 0.08737691f, -0.67001420f, 0.13612248f, -0.30811059f, -0.21658947f, 
    -0.10211204f, -0.11793222f, 0.18138938f, -0.06409512f, -0.08224714f, 0.03819494f, 0.03330103f, -0.00942015f, 
    0.21202067f, 0.03382711f, -0.03848552f, 0.02367409f, -0.09407175f, 0.00410921f, 0.12944144f, 0.03474489f, 
    0.07739694f, 0.05690509f, 0.09820144f, 0.38939315f, -0.17397207f, -0.08190179f, 0.05217388f, -0.01372974f, 
    0.02260406f, 0.05422936f, 0.05292932f, 0.19481128f, -0.01083592f, 0.12820621f, 0.09873250f, -0.05088311f, 
    0.10378273f, 0.09571601f, -0.24160738f, -0.16466302f, 0.30847931f, -0.20348723f, 0.08724371f, -0.05922224f, 
    0.33175299f, 0.11577521f, -0.23143144f, 0.25156692f, -0.08712225f, -0.11265186f, -0.05345813f, -0.07129074f, 
    0.00462662f, 0.00693999f, 0.17196813f, 0.03646479f, -0.03164580f, -0.28227711f, -0.09218898f, 0.03025099f, 
    0.17262739f, 0.43602955f, -0.00373672f, 0.20692585f, 0.06017092f, -0.07235250f, -0.06494977f, 0.05211226f, 
    0.05949806f, -0.01255056f, -0.01696482f, 0.00866800f, -0.04004660f, -0.22168490f, 0.01637459f, 0.02314791f, 
    -0.05372724f, 0.12250390f, 0.13206172f, 0.17635663f, 0.54620552f, -0.22227938f, 0.32436556f, -0.16467841f, 
    0.11792799f, 0.12637609f, 0.03991691f, 0.03573407f, -0.07428739f, 0.04038357f, -0.02335708f, 0.08468869f, 
    0.00774892f, -0.00259563f, 0.00218214f, -0.06120935f, 0.09151856f, -0.03152940f, 0.31975201f, -0.06192851f, 
    0.22284925f, -0.02320135f, 0.17668749f, 0.04640035f, -0.20786178f, 0.13407718f, 0.02105314f, -0.15305521f, 
    -0.00027039f, 0.09592255f, 0.09293326f, -0.16655868f, 0.00229708f, 0.10624032f, -0.05248614f, 0.13553922f, 
    0.19755028f, -0.06952196f, 0.19368930f, -0.11620585f, 0.18527158f, 0.04745280f, -0.34853759f, 0.14646742f, 
    0.12045122f, -0.02315859f, -0.19088228f, 0.12108549f, -0.07132220f, 0.10395203f, 0.13833223f, -0.03633239f, 
    -0.01371288f, -0.05129397f, 0.05616908f, 0.05394566f, 0.07735588f, -0.02229088f, -0.13005188f, 0.01206431f, 
    -0.28438619f, 0.10710509f, 0.14789109f, 0.06404535f, -0.07960539f, -0.08070888f, -0.05491194f, -0.04412153f, 
    0.15040697f, 0.15437706f, 0.27836844f, 0.08883189f, 0.20869443f, -0.09071042f, -0.00394872f, -0.11809871f, 
    -0.02765785f, -0.27138299f, 0.18228926f, -0.08636070f, -0.42801592f, -0.06153793f, -0.16001914f, -0.13137229f, 
    0.07708992f, 0.17222048f, 0.16284840f, 0.32782251f, -0.09370083f, 0.17189312f, 0.13219754f, -0.01024386f, 
    0.10281862f, -0.15112294f, -0.01714631f, 0.06226650f, 0.12554047f, -0.17288953f, 0.11256676f, 0.04694612f, 
    0.20850749f, 0.39313865f, 0.37308666f, -0.09460028f, 0.09824687f, 0.00990445f, -0.13581996f, -0.06669290f, 
    0.04339683f, 0.07924779f, 0.10748552f, -0.09097394f, -0.19151859f, 0.03162982f, 0.00520902f, 0.03042884f, 
    0.20952183f, -0.02020900f, 0.06130881f, 0.24728239f, 0.05673473f, -0.02352552f, -0.15958251f, 0.17745228f, 
    -0.04261722f, 0.08154006f, -0.02492536f, 0.02777237f, 0.05273974f, 0.09705359f, 0.07045310f, -0.01644429f, 
    0.01416109f, -0.17533562f, -0.02406741f, 0.01114921f, -0.03545190f, -0.09682079f, -0.06494082f, -0.12218042f, 
    -0.01003477f, -0.03474438f, -0.00555384f, -0.03449433f, -0.04263646f, -0.03554317f, -0.03549220f, 0.02171111f, 
    -0.02436763f, -0.04552298f, -0.05580166f, -0.00483565f, 0.00131703f, 0.05013036f, -0.02568574f, -0.01551534f, 
    -0.00628488f, 0.04225881f, 0.01370847f, -0.01193210f, -0.02653127f, -0.01089754f, 0.04973135f, 0.05845254f, 
    0.03999616f, 0.04328107f, 0.00866174f, -0.05602657f, -0.00346856f, 0.03122816f, -0.05223661f, 0.01526946f, 
    -0.05000852f, -0.02305544f, 0.03097181f, 0.01006900f, 0.04543256f, -0.04764009f, 0.03124245f, 0.00775672f, 
    -0.00416009f, -0.01281034f, -0.05747448f, -0.02125221f, -0.00353562f, 0.04240603f, 0.04613773f, 0.00294192f, 
    0.00230329f, -0.00435940f, -0.03434419f, -0.01040378f, -0.03468103f, -0.04851959f, -0.01944962f, 0.03315017f, 
    0.03589823f, -0.01493329f, -0.05695574f, -0.02055605f, -0.01833053f, 0.03694548f, 0.04163134f, 0.03487916f, 
    -0.00000372f, -0.01840254f, 0.03450491f, -0.04568446f, -0.03308238f, -0.01885708f, -0.04855588f, 0.00364055f, 
    -0.01955510f, 0.04521543f, -0.05417461f, -0.02808445f, -0.03185005f, 0.02552330f, 0.03266747f, 0.02014286f, 
    0.03173438f, -0.03602521f, 0.01507239f, -0.00744946f, -0.04327505f, 0.01252503f, 0.04089336f, -0.05312269f, 
    -0.04449280f, 0.02136671f, 0.04455379f, 0.01520150f, 0.02311603f, 0.02140794f, 0.04150233f, -0.00372005f, 
    -0.01462906f, -0.03593584f, -0.03028968f, 0.01819923f, -0.03447774f, -0.03241919f, -0.02091147f, -0.05444908f, 
    -0.03873446f, 0.04832182f, 0.02637625f, -0.03632482f, 0.01143458f, 0.02695396f, 0.02343743f, 0.03696435f, 
    -0.04593984f, 0.03195179f, 0.03571867f, -0.05110561f, 0.03951787f, -0.04909758f, 0.04926233f, -0.00056911f, 
    -0.02122279f, -0.00100498f, -0.00136636f, -0.03207076f, 0.02315666f, -0.01593022f, -0.02654434f, 0.04560682f, 
    -0.02581241f, -0.01926496f, -0.01044713f, 0.03472469f, -0.02388043f, 0.02605715f, 0.03315534f, -0.05507325f, 
    0.00385910f, -0.04565754f, 0.01422529f, -0.03354296f, 0.02398445f, -0.00442472f, 0.00431143f, -0.03114017f, 
    0.00315204f, -0.00940109f, 0.00927464f, 0.02770658f, 0.00934322f, -0.04015154f, 0.02190048f, -0.04415667f, 
    0.00491195f, -0.02715919f, -0.04975815f, -0.00489349f, 0.04366390f, 0.02795192f, -0.03238914f, -0.06355880f, 
    -0.02276749f, 0.01348652f, 0.04599954f, 0.05156280f, 0.00748654f, -0.02731523f, 0.03065016f, -0.01286274f, 
    0.04691314f, 0.01764602f, -0.03488837f, -0.05490146f, -0.04206061f, 0.03348566f, -0.00517652f, 0.04018402f, 
    -0.03164849f, -0.02674675f, 0.04183664f, -0.01040443f, -0.06037338f, 0.02401815f, 0.02066656f, -0.03014765f, 
    -0.00672108f, 0.04023381f, -0.01646555f, -0.04542682f, 0.00562162f, -0.06091153f, 0.03145732f, -0.00705881f, 
    -0.00818578f, -0.00507478f, -0.01780098f, -0.03815613f, 0.01690759f, -0.04139781f, 0.01053473f, -0.00253653f, 
    -0.03764762f, 0.05042325f, 0.00905366f, 0.05663896f, 0.00386237f, 0.05098974f, 0.04733676f, 0.00631315f, 
    -0.02970956f, -0.05286063f, -0.00225209f, -0.05397449f, -0.00374383f, -0.05544911f, 0.00178660f, 0.02518339f, 
    -0.01036241f, -0.02652237f, 0.03072218f, -0.02393378f, -0.05116272f, -0.02431019f, -0.03806055f, -0.01788552f, 
    -0.01000916f, 0.03179599f, -0.03737536f, -0.01931942f, 0.00729305f, 0.01549590f, -0.01178621f, -0.02000535f, 
    0.02327782f, 0.02553499f, -0.04109084f, 0.03315117f, -0.01709514f, 0.02526015f, -0.01938209f, -0.06156161f, 
    -0.03588417f, 0.04268173f, -0.02873380f, -0.03324407f, -0.03442848f, -0.05275677f, 0.04689768f, 0.00117725f, 
    -0.03912591f, -0.05173424f, 0.02816390f, -0.03665741f, -0.01598567f, -0.01565005f, -0.03746166f, -0.02007831f, 
    0.02669717f, 0.00640884f, 0.04193467f, 0.02612032f, 0.02041855f, -0.03478186f, 0.03880936f, -0.01754297f, 
    -0.03992230f, -0.04445952f, -0.02980516f, 0.04020668f, -0.02977254f, -0.04483781f, -0.05734858f, 0.02903076f, 
    -0.00733874f, -0.02937318f, 0.03421722f, -0.03743409f, -0.03707290f, -0.00903564f, -0.03979245f, -0.02713567f, 
    -0.03273375f, -0.02246868f, 0.00401697f, 0.01810038f, 0.02839825f, -0.00919445f, 0.03758049f, -0.05078546f, 
    0.02487427f, 0.01449630f, -0.04765039f, 0.03777503f, -0.03510334f, 0.03077736f, -0.00481160f, -0.05327136f, 
    -0.03350303f, -0.03688554f, 0.03753462f, -0.06102905f, -0.05351311f, 0.01846304f, 0.02344366f, 0.01738714f, 
    0.04374420f, -0.05404811f, 0.03726555f, -0.00139560f, -0.01391914f, -0.05497361f, -0.01180201f, 0.04545733f, 
    -0.01058903f, 0.01738821f, 0.02464360f, 0.02839883f, 0.02541413f, -0.02290401f, -0.03096457f, -0.04015608f, 
    -0.13933572f, 0.05058598f, -0.15413536f, -0.18632682f, 0.30487806f, 0.03665809f, 0.01789187f, -0.23182711f, 
    -0.04236393f, -0.08356947f, -0.08219627f, 0.09641043f, -0.03177466f, -0.01100389f, -0.10274383f, 0.01769840f, 
    -0.04623026f, -0.07619253f, -0.07919877f, 0.03520631f, 0.09070715f, 0.05518297f, 0.04273822f, 0.16772853f, 
    0.13345440f, 0.06236661f, 0.05962337f, -0.06169480f, -0.07114082f, -0.05483854f, 0.05735324f, 0.12121044f, 
    -0.01720860f, -0.02928135f, 0.08371358f, -0.09473146f, 0.03486925f, -0.00368913f, 0.03389850f, -0.03828368f, 
    -0.02046200f, -0.12179512f, 0.19408068f, 0.09192129f, -0.14151624f, -0.01939029f, 0.04435887f, 0.05319071f, 
    0.08247156f, -0.01746891f, -0.00005112f, -0.03902694f, -0.02109063f, -0.09904532f, -0.10704206f, 0.08049973f, 
    0.03526453f, 0.03094191f, 0.14172891f, 0.07172234f, 0.09542505f, 0.33892867f, 0.23082159f, 0.18811686f, 
    -0.33782274f, -0.11840087f, -0.04793794f, 0.08988415f, 0.11118549f, -0.06146445f, -0.09132196f, 0.06113159f, 
    0.10259439f, 0.01055110f, 0.18541172f, -0.04201082f, 0.01583020f, 0.11273710f, 0.04171452f, 0.03556533f, 
    -0.47055811f, -0.45362940f, -0.22580138f, -0.06670918f, 0.36773375f, -0.01852793f, -0.03227725f, -0.08761810f, 
    -0.11538886f, -0.07305960f, -0.02289159f, 0.02203877f, 0.04204734f, -0.17569798f, 0.03673182f, -0.01770382f, 
    0.13342701f, 0.02428841f, 0.09716661f, 0.07808166f, 0.38008043f, 0.36129007f, 0.01814016f, -0.11882136f, 
    -0.13953252f, 0.07791068f, -0.01832316f, 0.00916651f, -0.03703769f, -0.00287561f, 0.05278068f, 0.02550161f, 
    -0.03924561f, -0.02287512f, 0.06829664f, 0.01950147f, 0.08575290f, -0.24215622f, -0.04504558f, 0.02653636f, 
    0.13350031f, -0.06550014f, 0.17258255f, 0.42779481f, 0.02843980f, 0.01509084f, 0.12754048f, -0.10460626f, 
    0.14576848f, 0.01362050f, -0.01350865f, 0.13837007f, -0.02956538f, -0.02963279f, 0.03495212f, 0.00151404f, 
    0.04566838f, 0.18283768f, 0.02450261f, -0.12031409f, -0.26619840f, -0.27612436f, 0.10796589f, -0.01224067f, 
    0.07333720f, -0.10583834f, 0.13472536f, -0.01874466f, -0.00005199f, -0.02249308f, 0.05837371f, 0.04506359f, 
    0.07522104f, -0.07324129f, -0.04892257f, -0.00820489f, 0.08071090f, 0.14069301f, 0.06818806f, 0.00063574f, 
    0.10639764f, 0.24672912f, 0.19141670f, 0.11869400f, 0.26086932f, -0.00845877f, -0.00116010f, 0.10697802f, 
    0.04468974f, 0.13726047f, -0.10483210f, 0.00384022f, -0.04645885f, -0.08427402f, -0.03495200f, 0.09943049f, 
    -0.07855715f, 0.15206528f, 0.12690416f, -0.02817781f, -0.04795623f, 0.07106909f, -0.06598295f, -0.06943116f, 
    0.03132796f, 0.05310756f, -0.10516429f, 0.01178787f, -0.01427267f, -0.05013064f, 0.10216485f, -0.06310751f, 
    -0.03262053f, -0.05047031f, -0.01607001f, -0.01711693f, -0.05590072f, 0.13727964f, -0.00467910f, -0.02675595f, 
    -0.16252731f, 0.61868739f, 0.12170319f, 0.19183534f, -0.06629675f, -0.29871413f, -0.04796150f, 0.07181454f, 
    -0.08343432f, 0.08788922f, 0.05029326f, 0.06873299f, 0.07896382f, -0.02022658f, 0.12701209f, 0.06691227f, 
    -0.05589631f, -0.04724811f, 0.13185245f, 0.05953109f, -0.03907904f, 0.14442568f, 0.48693722f, -0.02944557f, 
    0.10233890f, -0.02426967f, -0.04790035f, -0.11528169f, 0.02358501f, 0.10942181f, 0.02026138f, 0.08895863f, 
    -0.00246584f, 0.23281379f, -0.06129787f, -0.17670234f, 0.08751301f, 0.03350434f, 0.19147012f, 0.01278593f, 
    0.00536576f, 0.13718861f, 0.16898920f, 0.43611047f, -0.11500259f, 0.19759107f, 0.01375766f, -0.09300973f, 
    -0.04851054f, -0.17527321f, -0.11180019f, -0.03488038f, -0.18449956f, 0.09154417f, 0.06687731f, 0.05951790f, 
    -0.05327760f, -0.05977436f, -0.11554383f, 0.05561567f, 0.11388157f, 0.24378401f, -0.04643850f, -0.16887595f, 
    -0.30556977f, 0.17158106f, 0.02524920f, -0.06803755f, 0.13816544f, -0.03753576f, 0.06679574f, 0.07035905f, 
    0.11853203f, 0.03178119f, 0.09155636f, 0.08431869f, -0.12031120f, 0.15851480f, -0.04028625f, 0.05082525f, 
    0.02917985f, 0.22552021f, -0.12843548f, -0.01811515f, -0.08729135f, -0.03045452f, 0.08515583f, 0.14177920f, 
    -0.13243237f, -0.02196344f, -0.07031931f, -0.05379495f, -0.02362605f, 0.20838420f, 0.04244600f, 0.04801184f, 
    -0.05806129f, 0.16578658f, -0.04255688f, -0.00897361f, -0.18874173f, 0.08227786f, 0.29966995f, 0.17177187f, 
    0.10140749f, 0.08657575f, -0.16348734f, 0.00259211f, 0.21068844f, 0.09177720f, -0.00566008f, 0.00314602f, 
    -0.00289624f, 0.04704009f, -0.09715801f, -0.09096944f, -0.05841350f, 0.11085960f, 0.04919595f, -0.03847594f, 
    -0.05797105f, 0.04005608f, -0.00863519f, -0.04167254f, 0.03119752f, -0.00040682f, -0.04935172f, 0.01988352f, 
    0.00378885f, 0.01210565f, -0.00488342f, -0.04635373f, 0.04460680f, 0.03717911f, -0.00929111f, -0.05925126f, 
    0.04102877f, -0.04011836f, -0.06027220f, 0.04409482f, 0.00658232f, 0.01626976f, -0.04218691f, -0.03946219f, 
    -0.02305257f, 0.01396276f, -0.03534456f, -0.03710069f, -0.02456777f, -0.05901235f, 0.00711992f, -0.00147649f, 
    -0.03320796f, -0.00882162f, -0.03435903f, -0.04213898f, 0.01615256f, 0.01908205f, -0.05508834f, -0.06350317f, 
    0.00626641f, -0.02430845f, -0.03593379f, 0.03256451f, -0.05331849f, 0.01025637f, -0.04927064f, -0.04806874f, 
    -0.03526184f, -0.04840461f, -0.06691600f, 0.04870096f, 0.00371158f, -0.03238049f, 0.00427792f, 0.03317527f, 
    -0.01795929f, -0.05862955f, -0.00210156f, -0.04510034f, -0.05495435f, 0.04625945f, -0.04266303f, 0.04987856f, 
    -0.05642912f, -0.05946429f, 0.03143520f, -0.03201785f, -0.01880626f, -0.04388273f, 0.00398632f, -0.00812015f, 
    -0.02126699f, -0.02688581f, -0.04465786f, -0.05075582f, -0.04155267f, -0.03795719f, 0.04044689f, -0.00134760f, 
    0.01515686f, 0.03815070f, -0.04593914f, 0.02540395f, -0.02870047f, -0.05449383f, 0.02879412f, -0.04038264f, 
    0.01870952f, 0.01895242f, -0.00251917f, -0.03376137f, 0.02311098f, -0.04202585f, -0.00516334f, -0.05377924f, 
    -0.04254521f, -0.02513228f, 0.01266223f, -0.03606772f, -0.05317827f, 0.03965325f, 0.01919427f, 0.00586087f, 
    0.01475555f, 0.03463475f, -0.00370221f, 0.05234547f, -0.02180050f, -0.01169268f, -0.03596401f, -0.02977399f, 
    -0.04998710f, 0.05472606f, -0.02184374f, -0.05923311f, -0.03307246f, 0.00625664f, 0.03388170f, 0.01062269f, 
    0.02402086f, -0.02968920f, 0.01485052f, -0.01465160f, 0.01759834f, 0.04343780f, -0.02432935f, 0.03614734f, 
    0.02578978f, 0.00825815f, -0.06119559f, 0.05275030f, -0.06480648f, 0.04119802f, -0.03084739f, -0.02413115f, 
    -0.05964250f, 0.00582776f, 0.03627412f, -0.04228252f, -0.05427654f, -0.00702987f, -0.00054493f, -0.01045473f, 
    -0.01664882f, 0.04138352f, -0.00154441f, -0.03434049f, 0.03953874f, 0.01630044f, 0.03071454f, 0.00315871f, 
    0.02152243f, -0.02578148f, 0.00483821f, 0.01009549f, -0.03478198f, -0.02847565f, -0.00092689f, 0.00869589f, 
    -0.02133019f, 0.00631192f, 0.00276458f, 0.03568980f, -0.02570387f, -0.00292870f, 0.05452829f, -0.03539715f, 
    0.04605715f, 0.03792774f, -0.05330098f, 0.04006218f, -0.04913105f, 0.00891004f, 0.01046848f, -0.00900743f, 
    0.05874486f, -0.02196825f, -0.03339337f, -0.01787748f, -0.03239134f, 0.01433832f, 0.01198279f, -0.01608047f, 
    -0.03436467f, -0.03638168f, -0.02262190f, 0.02062530f, -0.01610109f, 0.04103958f, -0.05120466f, 0.03589663f, 
    -0.02060292f, 0.05078111f, 0.05150361f, 0.01156634f, -0.00307992f, -0.01545591f, 0.05331676f, 0.00426224f, 
    -0.02784542f, -0.04392404f, -0.01575019f, 0.02654737f, 0.03620269f, -0.05681199f, -0.04824549f, 0.02537363f, 
    -0.00119679f, -0.02094735f, 0.03787742f, -0.04029505f, 0.04495135f, -0.04088273f, -0.02438797f, 0.03479081f, 
    0.00301834f, 0.04683195f, -0.01732053f, -0.02415812f, 0.03434164f, -0.03395908f, -0.05987069f, -0.02766359f, 
    0.03961091f, 0.02147012f, -0.00373813f, -0.00590799f, -0.03184687f, 0.01656995f, -0.00542439f, 0.01840037f, 
    -0.02433605f, -0.05747972f, 0.03110348f, -0.03252906f, -0.01292172f, 0.01710608f, 0.04367699f, 0.02155086f, 
    -0.01354953f, 0.01788773f, -0.02619359f, -0.03990361f, 0.04908304f, -0.02145721f, 0.01974065f, -0.02771486f, 
    0.03127544f, -0.02891163f, -0.02365429f, 0.03840882f, -0.06084976f, -0.00831832f, -0.02557781f, 0.04706544f, 
    -0.00486640f, 0.00014423f, 0.01174745f, 0.02375955f, 0.02226138f, 0.03438143f, 0.00358068f, -0.03628042f, 
    -0.01302565f, -0.06139205f, -0.01121579f, 0.03791353f, -0.01135104f, 0.05062709f, -0.03245860f, -0.01674268f, 
    -0.00474095f, -0.04640195f, -0.00043636f, 0.01517537f, -0.04616439f, -0.04459168f, 0.00644164f, 0.03708604f, 
    0.01183400f, 0.01585428f, -0.05472324f, -0.01776457f, -0.06425446f, 0.04410712f, 0.00584607f, 0.00924793f, 
    -0.06329835f, -0.05896482f, -0.01979975f, 0.00157330f, 0.02295481f, 0.00652306f, -0.02210939f, -0.02533335f, 
    -0.03515362f, 0.03953255f, 0.00828156f, -0.04261590f, -0.03707378f, 0.03636152f, -0.03687191f, -0.04053765f, 
    0.03824538f, 0.05466579f, -0.01599660f, 0.00402589f, 0.02725477f, 0.01696409f, 0.01212395f, -0.00620146f, 
    0.02421968f, 0.03372468f, 0.05190162f, -0.02927099f, 0.00419397f, -0.02821695f, -0.04112105f, 0.02766238f, 
    -0.16106530f, -0.09633946f, 0.23194152f, 0.35638371f, 0.07933616f, 0.26120719f, -0.08978423f, -0.00564165f, 
    0.01497791f, 0.02922509f, -0.03091843f, 0.08852946f, -0.03581100f, -0.03325442f, 0.10810716f, -0.04406579f, 
    -0.01214794f, 0.31085479f, 0.18058015f, -0.01649649f, 0.32789037f, 0.39316738f, 0.02177795f, 0.19052164f, 
    0.10684375f, 0.06064155f, -0.05335728f, -0.01013754f, 0.02031173f, -0.04930028f, 0.05911755f, -0.11731687f, 
    -0.10369839f, 0.19318692f, 0.30477720f, -0.08247884f, -0.05340281f, 0.02457140f, -0.05271854f, -0.05396556f, 
    -0.17366336f, 0.23818806f, 0.23184755f, -0.03508493f, -0.17592195f, 0.17458917f, -0.10660806f, 0.03667927f, 
    0.12071855f, 0.03031718f, -0.00856223f, 0.06615358f, 0.17180856f, 0.17735147f, 0.20596054f, 0.05084987f, 
    0.06365210f, -0.05338312f, -0.40950423f, 0.15333484f, 0.12736958f, -0.22342537f, 0.08068036f, -0.18886003f, 
    -0.15110977f, -0.12743555f, -0.10544259f, 0.03209952f, -0.05123200f, -0.00788137f, 0.13344164f, 0.05015086f, 
    -0.08333783f, -0.09138505f, -0.04244339f, -0.05676469f, -0.18078513f, -0.07165509f, 0.04947610f, -0.01802688f, 
    -0.18659459f, -0.02175005f, -0.03024716f, 0.39421514f, 0.36353925f, -0.05217734f, -0.05320939f, -0.01870232f, 
    -0.00824020f, 0.13202682f, 0.06802331f, 0.04770750f, 0.18049075f, 0.10756344f, 0.20134924f, 0.09425079f, 
    0.09481339f, 0.06042068f, 0.08048137f, 0.07042477f, -0.91948521f, 0.41183731f, -0.08798684f, 0.05200034f, 
    -0.00060945f, -0.01832022f, -0.00439672f, -0.06774285f, 0.02189286f, 0.02393992f, 0.16512381f, 0.03423945f, 
    0.01202028f, -0.00189287f, -0.06327975f, -0.04446789f, -0.03038109f, 0.04946436f, 0.22473060f, 0.02277629f, 
    -0.44901949f, -0.09159296f, -0.06135220f, -0.02397841f, -0.08737603f, 0.06447439f, 0.07303541f, 0.08843574f, 
    0.14930744f, 0.07243402f, -0.09010753f, 0.14480466f, -0.13215426f, 0.12725362f, -0.05455809f, 0.01209259f, 
    0.16885768f, 0.04968874f, -0.23235805f, -0.10166607f, 0.05050990f, -0.36494917f, 0.17479052f, 0.22952971f, 
    0.22862396f, -0.05758778f, -0.13608900f, 0.09933128f, -0.01545438f, -0.10770147f, 0.03208297f, -0.10772595f, 
    -0.00675442f, 0.17697321f, 0.09256715f, 0.01669932f, 0.03361330f, -0.24650037f, 0.03209570f, -0.07094558f, 
    -0.27672809f, 0.25314376f, -0.24047507f, -0.15655869f, -0.07748815f, -0.10420805f, 0.07865369f, 0.25591859f, 
    0.00187606f, -0.12996988f, -0.01117769f, 0.09681077f, 0.02818702f, -0.14316887f, 0.07324245f, 0.14829628f, 
    -0.00316021f, 0.09974635f, 0.14010745f, 0.08189657f, 0.47983304f, 0.07472327f, -0.14942238f, 0.17052963f, 
    0.16748129f, -0.07375591f, -0.03809084f, -0.10044295f, -0.05119129f, -0.12651686f, 0.08274049f, 0.04372505f, 
    0.11593740f, 0.01120114f, 0.12434497f, 0.00325913f, 0.05619822f, -0.05842765f, 0.39377195f, 0.05177968f, 
    0.05868691f, 0.18031853f, -0.13186397f, -0.06315763f, -0.20976436f, -0.09654649f, 0.00885291f, -0.27652985f, 
    -0.17869742f, -0.08586633f, 0.11100401f, -0.02606907f, -0.00074289f, 0.14731455f, -0.00342294f, 0.04066127f, 
    0.16910629f, -0.00983379f, 0.24389875f, 0.01558160f, -0.20390606f, 0.04394461f, -0.25229144f, -0.06081758f, 
    -0.10329059f, 0.13252920f, -0.04875810f, 0.08090279f, 0.09554740f, 0.06185711f, 0.13368370f, -0.03135078f, 
    -0.10636322f, -0.00574964f, 0.01614433f, 0.03984438f, 0.03107156f, -0.05618478f, -0.07231290f, -0.01351646f, 
    -0.41046825f, -0.07650209f, -0.03300261f, 0.11660358f, 0.03287170f, 0.02729701f, 0.07357379f, 0.10676987f, 
    0.03148496f, 0.04801209f, 0.18304621f, 0.21185057f, 0.05901506f, -0.19308053f, 0.10643256f, -0.10517521f, 
    -0.14016998f, -0.11076384f, 0.17962177f, -0.05872639f, 0.01598946f, 0.03340149f, -0.10108021f, 0.07388711f, 
    0.01389184f, 0.03957295f, 0.03619287f, 0.13217527f, -0.09485748f, 0.15961802f, 0.11007672f, 0.06107283f, 
    -0.00619720f, -0.07016195f, -0.00145214f, 0.02160705f, 0.15686545f, -0.36661446f, 0.00738084f, 0.18599483f, 
    0.20992948f, 0.44457403f, -0.17620210f, 0.05365687f, -0.05513872f, 0.02498184f, -0.08361337f, -0.12557131f, 
    -0.00242860f, 0.01532828f, 0.08547240f, -0.07033847f, -0.09567186f, 0.02038138f, -0.03836874f, 0.15685269f, 
    0.20761259f, -0.01512762f, 0.09508166f, 0.17185549f, -0.36286685f, 0.05080905f, -0.33584619f, -0.17280093f, 
    -0.26656425f, 0.06607798f, 0.12397540f, 0.15196909f, 0.11706676f, 0.06127326f, 0.03830931f, 0.07247783f, 
    -0.02021778f, -0.13251658f, 0.08149461f, 0.12078964f, 0.09152774f, -0.02321912f, -0.07101242f, -0.06165209f, 
    -0.01858594f, 0.02659290f, 0.00602435f, -0.03470593f, -0.05684189f, 0.01380963f, 0.03285570f, 0.03715189f, 
    -0.04209613f, -0.01268149f, -0.04783850f, -0.05223909f, 0.00970898f, 0.03889158f, 0.04226508f, -0.05185636f, 
    -0.05397375f, 0.04650968f, 0.01452392f, 0.03500194f, -0.01952580f, 0.01943335f, -0.06013240f, -0.00996298f, 
    0.02845999f, 0.04272470f, -0.03534836f, -0.03660464f, -0.01155988f, 0.02179881f, 0.02268603f, 0.03584607f, 
    0.00670087f, -0.03068027f, 0.04021777f, 0.03306324f, -0.02063557f, -0.03655223f, -0.01396685f, -0.06033202f, 
    -0.02826572f, -0.05644390f, 0.03162782f, -0.02144906f, 0.01038831f, -0.04183312f, -0.05150516f, 0.01113333f, 
    -0.04901791f, 0.01027360f, 0.00683329f, 0.02937621f, 0.03431166f, 0.02992325f, -0.03454128f, 0.00281917f, 
    -0.00612461f, 0.02351443f, -0.03147665f, 0.04554997f, 0.02220037f, 0.03245617f, 0.04069703f, 0.04251915f, 
    -0.02372188f, -0.02422456f, -0.03273279f, -0.02602848f, -0.00459631f, 0.04645044f, -0.03780919f, -0.03842505f, 
    0.04140701f, 0.04442833f, 0.01063889f, -0.01472266f, 0.04724722f, -0.02980069f, 0.02469530f, 0.00122828f, 
    0.00765722f, 0.02533155f, -0.02837776f, -0.04653471f, 0.01656549f, -0.04897469f, -0.04929955f, 0.01598076f, 
    -0.02865574f, 0.02060586f, -0.00851013f, 0.02923823f, -0.01545546f, -0.01408968f, -0.04255298f, -0.03973654f, 
    -0.02388670f, -0.04210000f, 0.04217242f, -0.02037295f, -0.02070449f, -0.02688354f, -0.03144609f, 0.02095516f, 
    -0.04606131f, -0.04487704f, -0.01966220f, 0.04446400f, -0.04956643f, -0.00353126f, -0.04140155f, -0.03624908f, 
    0.03387799f, -0.01310140f, 0.00765840f, 0.04488388f, -0.02482786f, 0.04151163f, -0.02637183f, -0.03922188f, 
    0.04551996f, -0.01065728f, -0.03041115f, 0.01045388f, 0.03734289f, -0.02436082f, 0.03514223f, -0.05215328f, 
    -0.04775847f, 0.01413915f, 0.04033139f, -0.00205702f, -0.04518529f, -0.04723680f, -0.00360122f, -0.00023420f, 
    0.01775814f, 0.01601304f, 0.00372875f, 0.00861300f, -0.05259267f, 0.00238594f, -0.00633332f, 0.04203825f, 
    0.01399219f, -0.04543891f, 0.03924582f, 0.04007716f, -0.01601789f, 0.04284994f, -0.03899749f, 0.02982211f, 
    0.02874676f, -0.01842283f, -0.04885445f, 0.04237887f, 0.02673421f, -0.02071455f, -0.01714584f, -0.02098593f, 
    -0.02124463f, -0.01018592f, -0.04132125f, 0.01492353f, -0.00764750f, 0.02298925f, 0.02656120f, 0.04570383f, 
    -0.00789437f, -0.00043463f, -0.05544332f, -0.04304671f, 0.00267551f, 0.00670997f, -0.04148266f, -0.02161721f, 
    -0.06005706f, -0.04692551f, 0.00795161f, 0.04739521f, 0.02265849f, 0.04427009f, 0.00504943f, 0.02392283f, 
    0.01563610f, -0.04661952f, -0.04601112f, -0.00913099f, -0.05214768f, -0.02436041f, 0.04745753f, 0.03725401f, 
    0.03365664f, -0.05875012f, 0.04781578f, -0.03250958f, -0.00204561f, 0.03357124f, -0.01403885f, -0.02485377f, 
    0.02639050f, 0.02284364f, 0.04495939f, 0.02091265f, -0.01190081f, -0.02463114f, -0.06355269f, 0.00210592f, 
    0.03711902f, -0.03829630f, -0.00547991f, 0.02227644f, 0.04555073f, -0.01864455f, 0.04852475f, 0.01155521f, 
    0.02603561f, -0.05024921f, 0.02943102f, 0.01305097f, -0.00227546f, 0.01322981f, -0.03473907f, 0.02048599f, 
    -0.02935470f, -0.02929316f, -0.06111022f, -0.04982591f, -0.00679528f, 0.04040888f, -0.00014894f, -0.02239899f, 
    -0.02557869f, 0.04510262f, 0.02117066f, 0.02091381f, -0.06111538f, 0.02372710f, -0.04647092f, -0.01344853f, 
    0.03419017f, -0.02912097f, -0.04513365f, 0.04175638f, -0.03364769f, -0.05669926f, 0.02567648f, 0.03895823f, 
    0.04331176f, -0.03319567f, 0.00936048f, 0.01071922f, -0.03799459f, -0.00917050f, -0.03198834f, -0.04935604f, 
    -0.05492499f, -0.00295952f, -0.02288503f, -0.04529401f, 0.03272954f, -0.03871787f, 0.03669254f, -0.01724021f, 
    -0.05821681f, -0.02850769f, 0.02507622f, -0.00554361f, -0.05080619f, -0.01558861f, -0.01883499f, -0.03089846f, 
    -0.05126719f, -0.01916831f, 0.01622948f, 0.00111780f, -0.04123945f, 0.03592654f, 0.03188824f, 0.01892630f, 
    0.03192950f, -0.04119002f, -0.05111114f, -0.04619779f, 0.02786731f, -0.01907151f, -0.03272214f, -0.06037447f, 
    0.01907066f, -0.02647735f, 0.01712202f, -0.00642216f, -0.01809410f, 0.03810554f, 0.01626031f, -0.04793405f, 
    -0.01737449f, -0.05502822f, 0.01696652f, 0.02727187f, 0.01968981f, -0.03023111f, 0.01364784f, -0.01966400f, 
    0.04268427f, -0.01281945f, 0.01027995f, -0.00205640f, -0.02441056f, -0.05365576f, 0.04253167f, -0.03650466f, 
    0.02160642f, -0.00074713f, -0.01211006f, -0.03441880f, 0.04992056f, -0.00210349f, -0.02400614f, -0.04719493f, 
    -0.02588493f, 0.02099739f, 0.00603191f, 0.03260045f, -0.00627270f, -0.01716281f, -0.02940081f, -0.04866194f, 
    0.04588136f, -0.05993319f, -0.01810819f, -0.05466759f, -0.03826652f, -0.00412364f, -0.02105105f, 0.03472913f, 
    -0.03061840f, 0.04891907f, 0.03646457f, 0.02546103f, -0.04897162f, -0.00178568f, 0.04335869f, -0.04189434f, 
    0.04527964f, 0.02432984f, 0.03371693f, -0.02043243f, -0.03765740f, 0.03583695f, 0.01817149f, 0.06379639f, 
    0.00279497f, 0.02313212f, -0.01388921f, -0.02567613f, -0.03744052f, -0.01163656f, 0.02121950f, 0.03589919f, 
    0.02268778f, 0.00107678f, -0.02780598f, 0.03708696f, -0.04309162f, 0.04347732f, 0.02333729f, 0.00250479f, 
    -0.02776416f, 0.00056490f, -0.02236898f, 0.02225438f, 0.01334653f, 0.04284487f, -0.02809717f, -0.03383192f, 
    0.02209022f, -0.04957198f, -0.01174606f, -0.01013083f, 0.03940388f, 0.00387906f, -0.00830918f, -0.00277067f, 
    -0.03847072f, -0.04648030f, -0.02234841f, 0.01883214f, -0.05252535f, 0.04427627f, 0.01740855f, -0.01075819f, 
    0.00539454f, -0.02892541f, -0.04939802f, -0.01722786f, -0.05866302f, -0.01217597f, 0.04491217f, -0.00669160f, 
    -0.02067840f, -0.04407468f, -0.00853231f, -0.00869097f, -0.02554419f, -0.00224729f, 0.01615513f, -0.03401230f, 
    0.02847698f, 0.04142184f, 0.03603428f, -0.04882142f, 0.01910500f, -0.01389164f, 0.04700671f, 0.01479829f, 
    0.00278280f, -0.03387641f, -0.01184663f, 0.02036046f, 0.01044941f, -0.01527617f, -0.05851672f, 0.03353373f, 
    -0.00174776f, 0.03428907f, -0.04433338f, -0.01783697f, 0.04443926f, 0.00086097f, -0.02754175f, -0.03730028f, 
    -0.06139877f, 0.04438312f, -0.01740523f, -0.00766889f, 0.03685565f, 0.01467303f, 0.05048667f, 0.00961543f, 
    -0.03438498f, 0.00436919f, 0.00798863f, 0.02441383f, -0.02573763f, -0.00219093f, 0.04668288f, 0.03161622f, 
    -0.03411184f, 0.00580945f, 0.00278048f, -0.05050020f, 0.02434421f, -0.02032566f, -0.00528979f, -0.01852156f, 
    0.01988970f, 0.01438044f, -0.04492502f, -0.04020286f, 0.02468270f, -0.00438786f, -0.03516721f, 0.02872022f, 
    -0.00558283f, -0.05258094f, -0.00169322f, -0.00827543f, -0.04036949f, -0.02868580f, 0.02370114f, 0.01187806f, 
    -0.05206251f, -0.01765131f, 0.04963372f, 0.02732944f, -0.00528895f, -0.01404102f, 0.04511946f, 0.01785843f, 
    0.02714658f, -0.03690631f, -0.04273418f, 0.03607530f, -0.00765663f, -0.02584104f, -0.02530855f, -0.00475787f, 
    0.01645198f, -0.05263668f, 0.04197788f, 0.01687118f, 0.01890369f, -0.02853964f, -0.04160600f, 0.00209318f, 
    -0.04451157f, 0.03131264f, 0.03491941f, -0.00556789f, -0.02728789f, -0.00664412f, -0.05774769f, -0.03682515f, 
    -0.00947809f, 0.02491398f, -0.03654745f, 0.01222820f, -0.05370891f, -0.05088073f, 0.05081740f, -0.02888827f, 
    -0.01882768f, 0.02607593f, -0.03802660f, 0.02186293f, 0.02053842f, 0.02255277f, -0.04428711f, -0.01064613f, 
    -0.00447363f, 0.02581486f, 0.01712950f, 0.00951564f, 0.04796369f, -0.02607334f, 0.04679615f, -0.06141347f, 
    -0.03799577f, -0.03504737f, -0.03426082f, -0.03089004f, -0.03807973f, -0.03255081f, 0.00080889f, -0.01680718f, 
    -0.02028763f, -0.00579396f, -0.03709805f, 0.00951540f, 0.00667485f, 0.03085701f, 0.02854585f, -0.01183663f, 
    -0.01661055f, 0.03098990f, 0.02252183f, -0.01162525f, -0.02221934f, -0.02169746f, 0.04248935f, 0.03678842f, 
    -0.04064098f, -0.00127873f, -0.04456659f, -0.05493588f, 0.02767731f, -0.05160759f, 0.02987965f, 0.03884046f, 
    -0.05912936f, -0.01596451f, -0.03034440f, 0.01002044f, -0.05025778f, 0.01669215f, -0.02143976f, -0.04749706f, 
    0.02499254f, -0.03449050f, 0.01592004f, -0.01221449f, 0.03255925f, -0.02416213f, -0.03776202f, -0.00588284f, 
    0.01697659f, -0.00115894f, 0.00311420f, -0.04064477f, -0.01323221f, -0.00670285f, 0.00640318f, -0.01129194f, 
    0.04720379f, 0.01960004f, -0.05082955f, -0.05288944f, -0.06106380f, -0.00322152f, -0.02613923f, -0.03433166f, 
    0.02324964f, -0.03994174f, 0.00904023f, 0.01945201f, -0.04985753f, -0.05648810f, -0.04275653f, 0.03969628f, 
    0.02448414f, 0.04157729f, 0.02914562f, -0.02376020f, -0.01237630f, -0.05024350f, -0.02197875f, -0.00413746f, 
    0.03813211f, -0.01198767f, -0.00699480f, -0.02470846f, 0.04512105f, 0.02410416f, 0.01754954f, -0.02825129f, 
    -0.03532415f, 0.02033741f, -0.01496197f, -0.02260704f, -0.04899983f, -0.02493936f, 0.04366143f, -0.05933674f, 
    -0.04965724f, 0.01161359f, -0.06040220f, -0.00593274f, -0.02323180f, 0.02962154f, 0.03842243f, -0.03911861f, 
    -0.03168621f, 0.04882693f, -0.02428323f, 0.02190064f, 0.04488883f, 0.02919644f, 0.03823364f, -0.01813863f, 
    -0.03703460f, -0.04856917f, -0.03873793f, -0.04269122f, -0.02771270f, -0.02008827f, -0.03835409f, -0.00047509f, 
    -0.00407550f, -0.01233016f, -0.00942143f, 0.00501762f, -0.04581506f, -0.04826961f, -0.00940443f, -0.05642671f, 
    0.02298151f, 0.03117757f, -0.04637419f, -0.02801231f, 0.01958778f, -0.06092828f, -0.00942570f, 0.04488562f, 
    -0.04957210f, -0.01284674f, 0.01012089f, -0.04132319f, 0.02315750f, -0.00749395f, -0.00742871f, -0.02370881f, 
    -0.03356676f, -0.05673908f, -0.03848993f, -0.05362574f, -0.05895767f, 0.02405236f, 0.04022817f, -0.01429515f, 
    -0.03112557f, -0.03294738f, 0.03947112f, -0.04892544f, 0.03800993f, -0.04281107f, 0.01889659f, -0.04803234f, 
    -0.02459599f, 0.01527645f, -0.01472264f, 0.00023822f, -0.04253576f, 0.00571980f, -0.04621488f, 0.00998641f, 
    -0.00846831f, -0.04531099f, -0.05564414f, 0.04312921f, 0.03408062f, 0.01166323f, 0.03842697f, 0.00324997f, 
    -0.03593522f, 0.01937091f, 0.03924574f, 0.02243885f, -0.00284222f, 0.00430378f, 0.04187961f, 0.04173149f, 
    -0.04300587f, -0.04664584f, -0.00639107f, -0.02983037f, -0.02986842f, -0.02253094f, -0.02249362f, 0.03091913f, 
    -0.03888050f, 0.01251369f, 0.04977255f, 0.04476158f, -0.00900454f, -0.04261991f, 0.02486782f, -0.02264935f, 
    -0.04394137f, -0.05869414f, 0.01512864f, 0.03329667f, -0.03435625f, -0.03691189f, -0.00247929f, -0.01127491f, 
    -0.01274441f, -0.01348631f, 0.01163156f, -0.00563195f, 0.04837331f, -0.05177876f, -0.04342296f, 0.03369837f, 
    -0.02782240f, -0.02573898f, -0.03145081f, 0.00630273f, -0.05745390f, 0.02838271f, -0.02932374f, 0.02024918f, 
    0.03998388f, 0.03770334f, -0.01205005f, 0.01059635f, 0.02966155f, 0.00683881f, 0.00695177f, -0.05241969f, 
    -0.06229292f, 0.03228528f, 0.04491719f, 0.03079894f, -0.06003051f, -0.01248834f, 0.01469650f, -0.04936693f, 
    -0.02680501f, 0.01340400f, 0.02792134f, -0.00931382f, -0.02166595f, -0.01602355f, -0.04706358f, -0.03686263f, 
    -0.01145073f, 0.04780284f, -0.02829376f, -0.04918946f, 0.00629651f, -0.05426611f, 0.05284675f, 0.00279800f, 
    -0.01064059f, -0.05132059f, 0.04201959f, 0.01605102f, 0.02996310f, -0.00382282f, -0.04651115f, -0.00408562f, 
    0.03929574f, -0.02752276f, 0.03401613f, 0.04564271f, -0.03734560f, -0.03761714f, 0.00833058f, 0.00375709f, 
    -0.05553507f, -0.02476015f, 0.03110702f, 0.00221837f, 0.00932975f, -0.05738102f, -0.01222811f, -0.05892759f, 
    -0.01642884f, 0.03730017f, -0.00153547f, -0.01725658f, -0.04868729f, -0.01046752f, 0.00910354f, 0.04303380f, 
    0.02234119f, -0.04229698f, 0.03002560f, 0.02819263f, 0.01154590f, -0.02027993f, 0.04006627f, -0.03964315f, 
    -0.00273780f, -0.05632084f, -0.02012163f, -0.00039453f, 0.01428122f, -0.02902443f, -0.05190419f, -0.06366520f, 
    -0.05875972f, -0.05980811f, 0.03694886f, -0.03781934f, 0.02340582f, -0.04226491f, 0.02890668f, 0.04926758f, 
    -0.01412030f, -0.04025276f, -0.03035953f, 0.02262764f, 0.00229226f, 0.04219563f, 0.03906479f, -0.01842010f, 
    -0.02898295f, -0.04479564f, 0.02164659f, -0.02682946f, -0.01897748f, 0.04272685f, -0.05492547f, -0.01371967f, 
    0.02028484f, -0.00700945f, -0.04229428f, 0.00462882f, 0.02515553f, -0.06192801f, 0.04257747f, -0.05915373f, 
    -0.00802483f, 0.02408777f, 0.04205802f, -0.02461203f, 0.04812523f, -0.00258950f, -0.01850143f, -0.00095958f, 
    -0.04740098f, -0.01803298f, -0.04476598f, 0.03016879f, 0.04786059f, 0.02144286f, 0.04872182f, 0.04841170f, 
    0.01025410f, 0.00411006f, -0.06261158f, 0.01853700f, -0.03245798f, -0.02121264f, -0.01998156f, -0.02626691f, 
    -0.01253514f, -0.04738530f, 0.02138580f, 0.01432967f, -0.00657200f, 0.00960283f, 0.01308246f, -0.00216519f, 
    0.01281699f, 0.01786348f, -0.00581495f, -0.04188649f, 0.01640606f, 0.02148092f, 0.01342371f, 0.02439342f, 
    -0.05106826f, -0.05179720f, -0.03390307f, -0.01721076f, 0.02577654f, -0.04459944f, -0.04655726f, -0.00299539f, 
    0.04355640f, 0.03293604f, 0.01813470f, 0.02981663f, -0.05988255f, 0.04737746f, -0.03830543f, 0.01019798f, 
    -0.03744737f, 0.01493137f, 0.04333682f, -0.05878811f, -0.05354742f, -0.01069398f, -0.02388647f, 0.03099366f, 
    0.03929697f, -0.05401807f, 0.04827505f, -0.01353093f, 0.04678420f, -0.04678065f, 0.04562183f, -0.05312337f, 
    0.03600789f, -0.01642528f, 0.01203502f, 0.03083364f, 0.02860616f, 0.00189723f, 0.02005960f, -0.05926515f, 
    -0.00360664f, -0.04968185f, -0.04648769f, -0.02093377f, 0.04379898f, -0.05145356f, -0.01200406f, 0.02316266f, 
    -0.01088329f, -0.05750405f, -0.00506419f, -0.03086069f, -0.01569316f, 0.00817507f, -0.02682187f, 0.04930442f, 
    -0.03646247f, -0.01278721f, 0.31181803f, 0.44740191f, -0.11594022f, -0.07775748f, -0.12931569f, 0.04614113f, 
    -0.11977473f, -0.04053872f, 0.05288150f, 0.08745790f, 0.04441834f, 0.00076317f, 0.09928031f, -0.08823196f, 
    0.05326939f, 0.05681505f, -0.01156932f, -0.04123293f, -0.03327485f, 0.03253748f, -0.06607427f, -0.11671716f, 
    0.27475008f, 0.14446288f, -0.17946380f, -0.05900417f, 0.01055178f, 0.03833355f, 0.07460428f, -0.00046437f, 
    -0.11292565f, 0.04790772f, 0.03940565f, -0.05545836f, 0.06281696f, -0.10507199f, 0.17830420f, -0.09963857f, 
    0.50088704f, -0.10422322f, -0.18459924f, -0.20672543f, 0.01800436f, 0.16646555f, -0.03239662f, -0.02098104f, 
    -0.02178008f, -0.17897972f, 0.04041342f, 0.20172451f, -0.01262881f, 0.08456235f, 0.15890262f, 0.05592152f, 
    -0.10648315f, 0.01189529f, -0.08209636f, 0.02065778f, -0.31551722f, -0.15490218f, 0.07470500f, 0.05454956f, 
    0.33958951f, 0.09760239f, 0.04876094f, -0.09861957f, 0.06084539f, 0.01021033f, 0.02120234f, 0.04034231f, 
    -0.02254467f, 0.02934241f, -0.15877974f, 0.11147150f, -0.16798660f, -0.02872789f, 0.05480769f, 0.04968670f, 
    0.54691094f, 0.35183600f, -0.00996755f, 0.09147324f, 0.00680878f, -0.00769624f, 0.12211816f, -0.10552786f, 
    -0.02288491f, -0.06299881f, -0.13154145f, -0.07699563f, -0.03816805f, 0.04855205f, 0.06202028f, 0.03985575f, 
    -0.00305246f, 0.11339732f, 0.08288962f, -0.07473214f, 0.20453592f, -0.34565911f, 0.19918624f, 0.17495976f, 
    -0.03485177f, 0.05658967f, -0.04831200f, -0.08356643f, -0.09030444f, 0.02601617f, 0.00039658f, 0.14753902f, 
    0.00876396f, -0.10729194f, -0.07341132f, -0.04085137f, 0.03250797f, 0.05036446f, 0.07271438f, 0.13658983f, 
    -0.50510556f, -0.08751183f, 0.04049407f, -0.29177654f, -0.11014502f, 0.06825057f, 0.04717706f, 0.05336746f, 
    -0.19391324f, -0.06264485f, 0.09150039f, 0.01261021f, -0.07744809f, 0.07648694f, -0.06131692f, -0.00010009f, 
    -0.10729802f, -0.10801098f, -0.00851292f, 0.03320661f, 0.01789813f, 0.48826495f, -0.27965200f, -0.07376759f, 
    0.31980342f, 0.10344275f, 0.02245026f, -0.01200179f, 0.11454961f, -0.05037781f, -0.02489079f, -0.02471252f, 
    0.04841604f, 0.17509812f, -0.02949064f, 0.21456765f, -0.04455936f, -0.07681891f, 0.07822596f, 0.01279875f, 
    -0.05103419f, 0.03287308f, 0.04897081f, -0.29754066f, 0.03022747f, -0.02174760f, 0.06596779f, -0.00482997f, 
    0.08199015f, -0.16408831f, 0.12948431f, -0.01989177f, -0.03842402f, 0.05067798f, -0.06323120f, -0.05577844f, 
    0.03636907f, -0.03800873f, 0.08465386f, 0.13812552f, 0.30679694f, 0.05632951f, 0.25685254f, 0.08627176f, 
    0.11102467f, -0.19422001f, 0.03471486f, 0.05824113f, -0.06398575f, -0.10610959f, -0.05241883f, 0.10120013f, 
    -0.01523593f, -0.01616675f, 0.01887595f, 0.06228869f, -0.06765715f, -0.03889401f, 0.03844769f, -0.04782345f, 
    0.09529625f, 0.00215412f, 0.06747364f, -0.20843969f, 0.40523830f, 0.02545300f, -0.00587344f, -0.10010756f, 
    0.21938248f, -0.03686538f, 0.00493315f, 0.00205741f, 0.12542784f, 0.03244700f, 0.06658418f, -0.11395320f, 
    0.04962739f, 0.09836639f, 0.01079632f, -0.09437617f, 0.11846051f, -0.01699186f, -0.18989328f, -0.10223143f, 
    -0.05888546f, 0.23735985f, 0.23034592f, 0.07450697f, -0.01875481f, -0.08095961f, 0.01862223f, -0.05470956f, 
    -0.10204171f, -0.07926555f, 0.00135511f, 0.06173556f, -0.27282140f, -0.00807881f, -0.10279062f, 0.03863631f, 
    0.00502265f, -0.14009641f, 0.00860844f, -0.13914591f, 0.09654049f, 0.13409844f, 0.03546903f, 0.00856318f, 
    0.01069111f, 0.09405132f, -0.07175709f, 0.06502558f, 0.11723565f, 0.01274938f, 0.08294699f, -0.05589244f, 
    0.02533486f, 0.13531676f, -0.02037207f, -0.26360559f, -0.22557893f, 0.01367080f, -0.00984196f, 0.15111314f, 
    0.05123370f, -0.12808873f, -0.11577533f, -0.13597265f, -0.03420152f, 0.12626496f, -0.06327396f, -0.04028188f, 
    -0.04798358f, -0.05628510f, -0.14562653f, 0.04709630f, -0.06530565f, -0.03764804f, 0.06441589f, -0.09078504f, 
    -0.07935248f, 0.13316783f, 0.03487567f, -0.00294533f, 0.00120925f, 0.02096730f, -0.06550755f, -0.05702955f, 
    0.11757667f, 0.11637585f, -0.08038724f, 0.13293749f, -0.03620316f, -0.10458305f, 0.04964552f, 0.02703090f, 
    -0.09420030f, 0.00310272f, 0.08565253f, -0.14978483f, 0.02840343f, 0.00339158f, 0.07550372f, -0.25686988f, 
    -0.01135479f, 0.03017991f, 0.28618467f, 0.13837630f, -0.15739672f, -0.15957090f, -0.03279749f, 0.00355648f, 
    0.03838851f, -0.04601178f, 0.09806560f, -0.01802187f, 0.05990880f, -0.06752957f, -0.16343647f, 0.04561034f, 
    0.02738716f, -0.03474279f, 0.01036771f, 0.03511935f, -0.05226710f, -0.05501618f, 0.00792399f, 0.03058005f, 
    -0.04875244f, 0.00472996f, -0.00168699f, -0.05941304f, -0.05991290f, -0.02392411f, -0.00544154f, -0.05553800f, 
    0.02586867f, 0.04332195f, -0.02478807f, -0.04506592f, -0.00429485f, -0.01142653f, -0.00356620f, -0.05171948f, 
    -0.05316991f, -0.04105229f, 0.02300692f, -0.04870911f, 0.00703901f, -0.03892989f, -0.00560830f, -0.04426347f, 
    -0.02745977f, -0.05508920f, 0.03145789f, -0.03515522f, 0.03935606f, 0.03718900f, 0.03063183f, -0.04342384f, 
    -0.00656945f, 0.00607945f, -0.02213733f, -0.04989371f, -0.02416636f, 0.02265453f, 0.00407692f, 0.01583206f, 
    -0.04580216f, 0.00438661f, -0.05696810f, -0.01293853f, 0.01376363f, 0.04468521f, 0.03494686f, 0.02545581f, 
    -0.05480366f, -0.05582320f, -0.02666113f, -0.00793217f, -0.04866277f, -0.05299995f, 0.00288091f, -0.01918456f, 
    0.02629642f, -0.02234071f, -0.05484018f, -0.04432787f, -0.01346267f, 0.01257158f, -0.02013604f, -0.02388684f, 
    -0.00360598f, 0.00379760f, -0.01127028f, 0.01343739f, -0.04640285f, -0.04770295f, 0.01698485f, -0.01873424f, 
    -0.04310553f, -0.02717223f, -0.00628069f, 0.04358972f, -0.01940373f, 0.02163025f, -0.05011344f, 0.03598740f, 
    0.02972153f, 0.02275331f, -0.04793600f, 0.04274051f, -0.02377224f, 0.04766296f, 0.03382658f, -0.01084144f, 
    -0.04981407f, -0.05714268f, 0.03364720f, -0.04003889f, 0.00762335f, -0.05377584f, -0.04478067f, 0.01290582f, 
    0.02801890f, -0.05746616f, -0.01783067f, 0.03156973f, 0.04830119f, -0.02364507f, 0.00736385f, 0.04139033f, 
    0.01361097f, -0.00318593f, -0.05174271f, -0.01842941f, -0.04102802f, 0.04804554f, -0.03404213f, 0.04251196f, 
    -0.03061298f, -0.02848732f, -0.01299239f, 0.01044239f, -0.02238899f, -0.02710119f, 0.02681074f, -0.04643752f, 
    -0.02046710f, 0.02257823f, -0.03104014f, -0.05414992f, 0.00079541f, -0.05909917f, 0.04904974f, -0.01241707f, 
    -0.03116028f, -0.02804980f, -0.02342799f, -0.03731078f, 0.01585094f, 0.02537409f, -0.01151939f, -0.02372151f, 
    -0.04256108f, -0.04158540f, -0.00906788f, -0.02800059f, 0.02485542f, -0.03188336f, 0.03829966f, -0.01035499f, 
    0.01187277f, -0.04528891f, 0.04158560f, -0.02016473f, 0.00581004f, 0.04930444f, 0.03851738f, -0.02469628f, 
    -0.01471964f, 0.00478195f, 0.01470945f, -0.05047768f, -0.02069107f, -0.03871407f, -0.06104293f, 0.01871850f, 
    -0.05871690f, -0.01849818f, 0.02407922f, 0.02626262f, 0.04188613f, -0.05837891f, -0.04634219f, 0.00733933f, 
    -0.02950189f, -0.03013425f, 0.00557064f, -0.03417400f, -0.05405927f, -0.04829716f, -0.02408588f, -0.02634297f, 
    -0.01990720f, -0.04724457f, 0.04809162f, 0.01848825f, 0.03523154f, -0.03789324f, 0.02487787f, -0.03194423f, 
    -0.00075563f, -0.06092310f, 0.04749480f, -0.01333750f, -0.04807656f, -0.00682125f, -0.03392275f, -0.06219663f, 
    -0.05717424f, 0.03824998f, -0.00185172f, 0.04094345f, -0.06152049f, 0.00210052f, -0.03542179f, 0.03516773f, 
    0.00493041f, 0.03523925f, -0.03363679f, -0.04488172f, 0.00486012f, 0.00005751f, 0.03556041f, -0.04962128f, 
    -0.00603479f, 0.02698489f, -0.03802124f, 0.03449942f, 0.04252373f, -0.03398233f, -0.01187305f, -0.00243171f, 
    0.04403558f, -0.04551372f, 0.02585942f, 0.00516365f, -0.01655795f, -0.01041160f, 0.02171080f, -0.06027193f, 
    0.01679977f, -0.04963106f, -0.04638091f, -0.00441538f, -0.06273775f, -0.04394107f, -0.00150691f, -0.05712731f, 
    -0.02003006f, -0.03479688f, -0.03285771f, 0.02397796f, -0.04189554f, -0.05305737f, 0.03474393f, 0.02213455f, 
    -0.04287197f, -0.03677976f, -0.01125598f, -0.04362411f, -0.02047715f, -0.05997930f, 0.03151541f, -0.04826164f, 
    -0.02589138f, 0.01331855f, 0.04765021f, 0.02876563f, -0.04075079f, 0.00872854f, 0.02251691f, 0.00455322f, 
    0.01015591f, -0.05493993f, 0.04242308f, -0.00500131f, -0.05638603f, -0.01787080f, -0.00478732f, -0.02723578f, 
    0.03452441f, 0.04425970f, -0.03419875f, 0.00828492f, 0.00638276f, 0.04567527f, 0.04431153f, 0.02786443f, 
    -0.00663507f, -0.02897454f, 0.01692101f, 0.00959747f, -0.01321455f, 0.01494515f, -0.05101169f, -0.00173548f, 
    0.03564015f, 0.04707619f, -0.05527156f, -0.00985372f, 0.04050052f, 0.01985149f, 0.00770857f, -0.01665413f, 
    -0.02843200f, -0.03448023f, -0.03258402f, -0.01793910f, -0.04627540f, 0.00318418f, -0.05417747f, 0.01041121f, 
    0.04003154f, 0.04415631f, -0.00102413f, -0.03294538f, -0.05103526f, -0.03837823f, -0.03214463f, -0.02512162f, 
    -0.01001098f, -0.03861518f, -0.00144227f, -0.03840483f, 0.02448206f, -0.04305020f, -0.05661550f, 0.04850164f, 
    -0.04179469f, -0.04647420f, 0.00931663f, -0.00983071f, -0.04749237f, 0.04831585f, 0.05074332f, -0.04156696f, 
    -0.02743203f, -0.01166438f, -0.02920388f, -0.03397373f, 0.04883362f, -0.04960867f, 0.02686542f, 0.02790260f, 
    -0.02883388f, 0.02202621f, -0.04792966f, 0.01632825f, -0.04873269f, 0.02631659f, 0.02851697f, -0.02297274f, 
    0.01454940f, -0.01985951f, 0.04473298f, -0.04086396f, -0.04873927f, 0.02240511f, -0.04981347f, -0.03338631f, 
    0.02973503f, -0.02206022f, 0.00514500f, -0.02317320f, 0.03292469f, -0.02921967f, -0.05050300f, 0.01120460f, 
    0.01978531f, 0.03364804f, -0.00500416f, -0.04954340f, -0.01160664f, -0.04034625f, -0.04567427f, 0.02934701f, 
    -0.02828621f, -0.04604629f, -0.03343118f, -0.01145938f, 0.05235098f, 0.03242858f, 0.02147299f, -0.00683571f, 
    -0.02695289f, 0.03062728f, -0.01258814f, 0.04378761f, 0.00859254f, 0.00990308f, -0.01269091f, -0.02129696f, 
    -0.00452357f, 0.01414699f, -0.05167938f, 0.04305254f, -0.00596644f, 0.01469200f, -0.05424671f, 0.03794566f, 
    0.01677281f, -0.03258244f, 0.03865223f, 0.02133173f, -0.03898043f, -0.03235323f, 0.03490733f, -0.04807967f, 
    0.03309872f, 0.01901096f, 0.01019749f, -0.05484315f, -0.05211382f, 0.01648084f, 0.01616700f, 0.05204232f, 
    0.00987089f, -0.04499974f, 0.01917160f, -0.05169041f, 0.02581231f, -0.01902967f, 0.03401190f, -0.05406518f, 
    0.02061519f, 0.02273045f, 0.04302350f, -0.03705764f, 0.00059179f, -0.04684139f, 0.02229523f, -0.05655656f, 
    -0.03384644f, -0.04915381f, 0.02781321f, 0.04251592f, -0.01262790f, 0.00689189f, -0.02722209f, 0.01406828f, 
    0.00319153f, -0.03747191f, -0.05587456f, -0.01974207f, 0.05062762f, -0.05797506f, -0.05751990f, 0.01894969f, 
    -0.03956421f, -0.02346167f, 0.05248139f, -0.04310552f, 0.01560538f, -0.00586650f, 0.02036260f, -0.03124478f, 
    0.00253746f, -0.04161360f, 0.01466791f, -0.00154557f, -0.02463092f, -0.00821902f, 0.04220361f, 0.05072550f, 
    -0.02310157f, -0.05744728f, -0.03519103f, -0.01056504f, -0.02571719f, -0.03745525f, 0.02608198f, -0.05578416f, 
    -0.05146490f, 0.02529461f, -0.04798257f, 0.01946455f, -0.01139345f, -0.05406762f, -0.00241158f, 0.00673099f, 
    0.01590442f, -0.01508529f, -0.03123313f, -0.01017097f, -0.00844076f, -0.02639391f, 0.03550882f, 0.01075068f, 
    -0.00181657f, 0.02976491f, -0.05053146f, -0.00569528f, 0.03934954f, -0.01583900f, -0.03913166f, 0.04797345f, 
    0.02330821f, 0.02228571f, -0.03707827f, 0.03298364f, -0.00457539f, -0.05218825f, -0.03165574f, 0.00325987f, 
    0.00121593f, -0.01092642f, -0.01652105f, -0.05879888f, 0.01161098f, -0.00762681f, -0.02630504f, 0.00766082f, 
    -0.02813646f, -0.01833557f, -0.05468876f, 0.04821783f, -0.05015953f, 0.00505171f, -0.04084509f, -0.01367523f, 
    0.03335838f, -0.03339876f, 0.01465536f, 0.00625229f, -0.00063578f, 0.04764377f, -0.05077966f, -0.03125970f, 
    -0.00589147f, -0.02669212f, -0.02646408f, 0.04381658f, 0.02805581f, 0.02307859f, 0.01955208f, 0.00525636f, 
    -0.00337458f, 0.04116469f, 0.00547775f, 0.04704744f, -0.04578230f, 0.00133329f, 0.00112106f, -0.03489542f, 
    -0.00199922f, -0.02188722f, -0.04134869f, -0.02026222f, -0.00226658f, 0.02921971f, 0.03843340f, -0.01470782f, 
    0.04942916f, 0.02840111f, 0.05082516f, 0.04502748f, -0.05302031f, -0.04762553f, 0.00568722f, 0.03341116f, 
    0.01720993f, 0.04162246f, -0.01167756f, -0.04293892f, 0.02167032f, 0.01521737f, -0.02033985f, -0.04729698f, 
    -0.04201322f, 0.03640305f, -0.05067687f, 0.01231770f, -0.04861969f, -0.02912677f, -0.04982729f, -0.00308308f, 
    0.00130135f, 0.00607402f, -0.03999522f, 0.01911485f, -0.00217319f, 0.01845234f, 0.02076589f, -0.01308381f, 
    -0.04468627f, -0.03062395f, 0.03106914f, -0.01432462f, -0.01032552f, 0.02017189f, 0.00359573f, 0.00645860f, 
    -0.00737728f, 0.03673422f, 0.00780956f, -0.03264634f, 0.03104266f, -0.00624416f, -0.00030754f, -0.04532586f, 
    -0.02107558f, 0.00780809f, -0.04395023f, -0.04278931f, 0.01561238f, -0.05307493f, 0.01238257f, -0.02275368f, 
    0.02048128f, -0.05326911f, 0.04890480f, -0.00976678f, 0.03069171f, 0.01537077f, 0.04503521f, -0.00639874f, 
    0.03772298f, 0.02889698f, 0.01794133f, 0.01165383f, -0.05324643f, 0.01715101f, -0.00299686f, -0.00890312f, 
    0.01051236f, -0.05356498f, -0.03025577f, 0.00669441f, 0.00491329f, -0.03853168f, 0.02145300f, 0.02179780f, 
    0.00874155f, -0.01966555f, -0.01186460f, -0.04213461f, 0.01751475f, -0.00869201f, -0.05607750f, -0.02746399f, 
    0.01867929f, -0.04218736f, 0.01661320f, -0.01081735f, -0.04400697f, -0.01264367f, -0.04414477f, -0.03756601f, 
    -0.36862653f, -0.10549918f, 0.04835301f, -0.21375330f, -0.11488311f, -0.02371920f, -0.31736392f, 0.03817074f, 
    -0.07273781f, 0.03827104f, -0.08764534f, -0.15059420f, 0.05588231f, -0.04508332f, 0.03174670f, 0.12183925f, 
    -0.06191193f, 0.07783499f, 0.07535461f, 0.01181786f, 0.10077933f, -0.25087228f, 0.29388198f, 0.09282785f, 
    0.29120651f, -0.20102540f, -0.07125771f, -0.04267883f, 0.07577080f, 0.23087086f, -0.06144695f, 0.09720719f, 
    -0.11051182f, 0.04489788f, 0.09289981f, -0.10201762f, -0.07499780f, -0.03315018f, 0.02611342f, 0.07774648f, 
    -0.42476708f, -0.21645866f, 0.37363371f, 0.08963981f, 0.15627514f, 0.23474814f, -0.02020190f, 0.00217637f, 
    0.14591959f, 0.10576821f, 0.03932554f, 0.07022345f, 0.25352684f, 0.13380286f, -0.02708909f, -0.00124727f, 
    0.00416075f, 0.01025278f, -0.09277581f, 0.17578320f, 0.15663272f, 0.00706340f, 0.42079112f, 0.15410426f, 
    0.49061063f, -0.09511088f, 0.23449987f, -0.11761135f, -0.03187708f, -0.06278496f, -0.13599654f, -0.06123779f, 
    0.18349798f, -0.06109148f, 0.16562134f, 0.04463054f, -0.02425917f, -0.03815577f, -0.12464779f, 0.02806922f, 
    -0.03450393f, -0.26451123f, 0.12402168f, -0.18683119f, -0.06662313f, -0.25691757f, -0.15627709f, -0.12386640f, 
    0.04326161f, 0.13469270f, 0.02520920f, 0.00760225f, 0.06694660f, 0.07436182f, 0.10311707f, 0.00545201f, 
    0.19947907f, 0.11216498f, 0.02817428f, 0.13069598f, -0.14235008f, -0.16306424f, 0.34951842f, -0.01767106f, 
    0.18794778f, -0.06498860f, 0.06093664f, -0.00281295f, 0.08313356f, 0.04775846f, 0.11332899f, -0.07300261f, 
    -0.01191105f, -0.09092765f, -0.02254916f, 0.00111737f, 0.05675196f, 0.00243530f, -0.02513043f, 0.04337327f, 
    0.06716065f, -0.06032358f, 0.13140799f, 0.33232459f, 0.18807785f, 0.09792782f, 0.06915068f, 0.00323558f, 
    0.17317340f, 0.01763869f, -0.10881011f, -0.13323015f, -0.05198172f, 0.00346274f, 0.05492035f, 0.05052323f, 
    0.04606651f, -0.02385927f, -0.08079343f, -0.09542400f, 0.13659485f, -0.21542287f, 0.33900714f, 0.04302471f, 
    0.13149115f, -0.16047251f, 0.05743036f, -0.09098524f, 0.12684026f, 0.01183694f, 0.02347893f, -0.15761109f, 
    -0.02121753f, 0.09590077f, 0.07343005f, 0.00423859f, 0.07478911f, -0.08783296f, 0.01308482f, -0.18703245f, 
    0.20816866f, 0.21362852f, -0.22509830f, -0.26675567f, -0.36165750f, 0.12536733f, 0.17435627f, -0.03227858f, 
    -0.06983048f, -0.11165308f, -0.00660965f, 0.21154551f, 0.01939754f, 0.04299951f, -0.09233528f, 0.12334995f, 
    0.02842698f, 0.06604275f, -0.02683055f, 0.08986756f, -0.40207633f, 0.51428598f, -0.10714238f, -0.00970667f, 
    0.32182094f, -0.19086792f, 0.00070592f, -0.13763386f, -0.06370533f, -0.31367022f, 0.15232775f, 0.08008426f, 
    -0.09427185f, 0.02757818f, 0.03928358f, 0.15047854f, 0.14194132f, 0.02535947f, 0.04800742f, 0.14722040f, 
    0.31564829f, 0.06153372f, -0.29202980f, 0.15051217f, -0.21200123f, 0.07032923f, 0.17549632f, -0.09574705f, 
    -0.07302967f, 0.01486363f, 0.02078730f, 0.17377026f, 0.07865641f, 0.02384892f, -0.01514895f, 0.00348462f, 
    0.16531965f, 0.14592859f, -0.01913615f, 0.04718895f, -0.36872095f, 0.04525257f, 0.19939010f, 0.27759990f, 
    -0.10969570f, 0.23828712f, 0.11543294f, 0.17187634f, 0.09431010f, 0.11737214f, -0.08843311f, 0.12728225f, 
    -0.09032692f, 0.04101282f, -0.14798304f, -0.03605843f, 0.02447552f, -0.08638643f, 0.06562870f, 0.06319405f, 
    0.71624082f, 0.13343576f, -0.00253276f, 0.14228621f, -0.02026456f, 0.21881007f, 0.10883220f, 0.10997776f, 
    -0.05071593f, 0.00821815f, -0.00054047f, 0.04931387f, -0.06935669f, 0.03427853f, 0.10096041f, 0.13152575f, 
    -0.11840454f, -0.05409176f, 0.03893409f, 0.00985496f, 0.08094326f, -0.35387090f, 0.06458535f, 0.07472058f, 
    0.10485453f, 0.00984387f, 0.01772476f, 0.14187849f, 0.12406379f, 0.06181164f, 0.15095790f, 0.01611272f, 
    0.04579972f, 0.02455670f, 0.10604143f, 0.01735595f, 0.02599348f, 0.02989195f, -0.05104519f, -0.10178833f, 
    0.13772257f, -0.03026842f, 0.01066943f, -0.19598144f, -0.11627297f, -0.10605105f, 0.12947252f, -0.05222581f, 
    -0.09064657f, -0.08919156f, -0.01983643f, 0.04858423f, -0.15454416f, 0.05676483f, 0.02971686f, -0.10856299f, 
    0.03750176f, 0.17150928f, 0.00307221f, 0.19775148f, -0.14856961f, 0.33775991f, -0.14408530f, 0.22801375f, 
    -0.44265425f, 0.26725626f, -0.00225275f, 0.10322979f, 0.04488995f, 0.00354516f, -0.11984173f, 0.17403585f, 
    -0.01747803f, -0.00234935f, -0.13657281f, 0.05643190f, 0.05081115f, -0.00482302f, 0.00702356f, -0.15921663f, 
    0.02819417f, -0.05764760f, 0.03097281f, 0.04478370f, -0.01214016f, -0.01378940f, 0.00496678f, 0.02119781f, 
    -0.03030060f, -0.03965574f, -0.01675962f, -0.01049260f, -0.02207672f, 0.00200202f, -0.04257659f, -0.01950938f, 
    -0.03400597f, -0.03547664f, -0.01325663f, 0.04373593f, 0.01875832f, 0.01132059f, -0.03246769f, 0.00937479f, 
    0.01350575f, -0.02235076f, -0.00626761f, -0.03281481f, -0.01858008f, -0.02939148f, 0.00610533f, 0.03607606f, 
    0.02732123f, -0.01325204f, -0.06095211f, 0.03292273f, 0.02845054f, -0.01871497f, -0.04824068f, 0.02735903f, 
    0.00856087f, 0.01068992f, 0.04636787f, -0.00506053f, -0.00330354f, 0.03331331f, 0.01592029f, -0.00136806f, 
    0.04447249f, 0.04337966f, 0.00815827f, 0.00132562f, -0.05352925f, -0.00230689f, 0.03520975f, 0.00452802f, 
    -0.05106014f, -0.05697383f, 0.05937284f, 0.03206439f, -0.01931590f, 0.03584759f, -0.05158417f, 0.04407792f, 
    0.04709416f, -0.00730127f, -0.01036592f, 0.00230386f, -0.00980761f, -0.05047782f, 0.03209373f, -0.03727771f, 
    -0.00076137f, -0.02657850f, -0.02973158f, -0.01691340f, 0.02072508f, -0.00428863f, 0.03417657f, 0.05188667f, 
    -0.04557812f, -0.02898885f, -0.00288405f, 0.00798195f, -0.02205072f, -0.02807429f, -0.02577955f, -0.02790484f, 
    0.00031903f, 0.02964124f, -0.03791068f, -0.05400380f, 0.01789745f, 0.02266893f, 0.00662547f, -0.00100769f, 
    0.00481826f, -0.00947922f, -0.06295929f, 0.03390381f, -0.02057196f, -0.04758409f, -0.03942465f, 0.05770572f, 
    -0.05657224f, -0.01623178f, -0.03958867f, 0.00644109f, 0.00018573f, -0.06386884f, 0.04088826f, -0.03968928f, 
    0.01361918f, -0.02058810f, 0.02024331f, 0.04127190f, -0.03142674f, -0.00243479f, 0.00900604f, 0.02659021f, 
    0.03314275f, -0.01369813f, -0.02314328f, -0.05589613f, 0.05162343f, -0.03940023f, 0.04184480f, -0.05183123f, 
    -0.03087410f, -0.05523956f, 0.04526671f, -0.01248411f, -0.04945580f, -0.04076208f, -0.05442376f, -0.01966642f, 
    0.03041457f, 0.00945874f, 0.00380322f, 0.04452483f, 0.03737029f, 0.04752079f, 0.03035769f, -0.03628051f, 
    -0.00694293f, 0.02429947f, -0.02442701f, -0.02219854f, 0.03521642f, 0.00963382f, 0.02679223f, -0.04710988f, 
    0.03293787f, 0.04320327f, -0.06067875f, 0.01985524f, -0.05594102f, -0.00445920f, -0.02957607f, -0.05314286f, 
    0.01119808f, 0.00608245f, 0.03175545f, -0.04155734f, 0.01466971f, -0.02378341f, 0.00343119f, 0.00776461f, 
    0.02251627f, 0.03835368f, 0.04829240f, 0.00948376f, 0.02949250f, -0.02006716f, -0.00296384f, -0.01141452f, 
    0.03789492f, 0.02745941f, 0.00873668f, 0.00834068f, 0.01419287f, -0.04213535f, 0.02642534f, 0.00368279f, 
    -0.01725808f, -0.02478758f, -0.05947721f, -0.01803365f, 0.04003905f, 0.03602573f, -0.05667765f, -0.00711465f, 
    -0.04632872f, -0.04139059f, -0.03024773f, -0.01431050f, -0.01705348f, 0.02801996f, 0.01451281f, -0.03404634f, 
    -0.05602622f, 0.03864633f, -0.02668497f, -0.02573957f, 0.01521906f, -0.06592619f, -0.03903526f, -0.00586061f, 
    -0.03728980f, 0.04473830f, 0.03848103f, -0.04809744f, 0.01789407f, -0.04568413f, 0.03588485f, -0.00257056f, 
    -0.04093777f, -0.03514538f, 0.04145934f, -0.02029699f, -0.03389804f, -0.05100114f, 0.04316844f, -0.03377252f, 
    -0.04466861f, -0.04663385f, 0.02440739f, 0.02048499f, -0.04372667f, 0.01166252f, -0.04003571f, 0.04350707f, 
    0.04206472f, -0.00733217f, -0.05546015f, -0.05978515f, -0.02289142f, -0.04630670f, 0.04460658f, 0.03820388f, 
    -0.00797548f, 0.01856563f, 0.00287029f, -0.05369026f, 0.02191465f, -0.00411387f, 0.01027482f, 0.03321818f, 
    -0.01023613f, 0.01808584f, 0.02974096f, 0.02808033f, 0.01577414f, 0.03562025f, -0.02800213f, -0.01726115f, 
    0.03321521f, -0.02248244f, -0.01501940f, -0.00440925f, -0.02953935f, -0.04458537f, -0.00989140f, -0.04119626f, 
    0.02982638f, -0.01244908f, 0.00236981f, 0.01247788f, -0.06041133f, -0.03140925f, 0.00112147f, -0.04274411f, 
    -0.00112769f, -0.01439280f, 0.03892379f, -0.03308143f, 0.00690088f, 0.03430981f, -0.00650203f, -0.00375860f, 
    -0.05960626f, 0.01314516f, -0.04180445f, -0.04260538f, -0.03319996f, -0.01338133f, 0.01191072f, -0.03337602f, 
    -0.05671990f, 0.03275971f, -0.00933548f, 0.00036625f, -0.06151989f, 0.04055112f, -0.01391195f, 0.00805089f, 
    0.04443307f, 0.01616894f, -0.01035611f, 0.01766998f, -0.01405149f, -0.03554554f, 0.00433972f, -0.03431534f, 
    -0.00817906f, -0.04747623f, 0.01219457f, -0.04623852f, -0.00152725f, -0.05952188f, 0.04166611f, 0.03730714f, 
    0.00234359f, -0.00256848f, 0.03962168f, -0.03877785f, 0.00330323f, 0.04071048f, -0.03477844f, -0.02638261f, 
    0.00725955f, 0.00722936f, -0.02822316f, 0.01297023f, -0.00833926f, 0.04169817f, -0.02226157f, -0.05547113f, 
    0.04879197f, 0.00573425f, -0.00607475f, 0.04078704f, -0.03939159f, -0.00939701f, 0.02237229f, -0.00993701f, 
    -0.03342137f, -0.00513089f, 0.02541144f, -0.04198076f, -0.04110722f, 0.01089354f, 0.03618504f, -0.04384548f, 
    -0.00179978f, -0.00262294f, -0.04294546f, -0.04869499f, -0.04809090f, -0.05301170f, 0.03721848f, -0.04152767f, 
    0.03759504f, -0.05410839f, -0.03662159f, 0.04939914f, -0.02438559f, 0.04087859f, 0.03608128f, 0.00819393f, 
    -0.04681697f, -0.02569128f, -0.05738100f, -0.03694298f, -0.00845445f, 0.01540028f, -0.00929159f, -0.01853369f, 
    0.00188904f, 0.04513977f, 0.03785716f, -0.03091968f, -0.02210872f, -0.01585241f, -0.03325009f, -0.00932671f, 
    0.01163510f, -0.01372671f, 0.02368166f, -0.00591393f, -0.00240030f, -0.02306310f, -0.00125111f, -0.00429008f, 
    0.02697721f, 0.02675186f, -0.06272370f, -0.03355952f, -0.01940852f, -0.00907656f, 0.00441491f, -0.04045550f, 
    -0.06004575f, 0.01177191f, -0.05103189f, 0.00028941f, 0.01396546f, -0.02451250f, 0.04362164f, -0.01442627f, 
    -0.04065697f, 0.05579681f, -0.02963130f, 0.00577072f, 0.03579545f, -0.06802198f, -0.05061678f, -0.06448242f, 
    -0.01144101f, 0.05133868f, -0.00336683f, -0.01915040f, 0.02061630f, 0.03777443f, -0.02880008f, -0.01724065f, 
    -0.05501724f, 0.01704018f, 0.04360812f, -0.00292990f, 0.02643483f, -0.03138561f, 0.02320738f, 0.01655233f, 
    -0.02532303f, 0.02418845f, 0.00292530f, -0.03636759f, 0.02547420f, 0.00996999f, 0.01037654f, 0.01969483f, 
    -0.00741617f, -0.03597383f, 0.03339817f, 0.01752273f, -0.00779099f, -0.02613437f, 0.00389631f, -0.01602757f, 
    -0.04534246f, 0.02349390f, -0.00423190f, 0.04634538f, 0.00132564f, -0.05337675f, 0.03175348f, -0.04082039f, 
    0.03082385f, -0.03904349f, -0.01345048f, -0.04929763f, -0.04796126f, 0.01740739f, -0.04987744f, 0.02019140f, 
    0.01976498f, 0.00442290f, -0.02248222f, -0.05195851f, 0.01128161f, -0.03318054f, -0.02070719f, 0.01736229f, 
    0.03223481f, 0.04760362f, 0.02329936f, 0.02955646f, 0.02818600f, -0.05824521f, -0.00714847f, 0.04905589f, 
    -0.02463096f, -0.02010046f, 0.04138694f, 0.03912738f, -0.06595878f, -0.04283009f, 0.02427818f, 0.00086716f, 
    0.02583930f, 0.01003093f, -0.01044237f, -0.00426690f, 0.03293049f, 0.03068532f, -0.03154952f, -0.04603997f, 
    0.00869492f, 0.02512903f, -0.03087731f, -0.00211084f, -0.04709724f, -0.05221935f, -0.03771834f, 0.03930289f, 
    0.04722317f, 0.03007674f, -0.02182201f, 0.03580015f, 0.02123349f, -0.01945622f, 0.01910097f, 0.00971353f, 
    -0.02280791f, 0.02695997f, -0.03433325f, 0.01437065f, -0.05202860f, -0.00389585f, 0.03338539f, -0.00530318f, 
    -0.02843187f, -0.05305694f, 0.01383512f, 0.02181346f, 0.04615841f, -0.02136605f, 0.01228046f, 0.03823798f, 
    0.03982606f, -0.01196269f, -0.00592953f, 0.03491639f, -0.04859971f, -0.00798719f, 0.01373585f, -0.03587047f, 
    0.00693098f, 0.03925722f, 0.02550504f, -0.04529355f, 0.01735091f, -0.05819743f, 0.00018894f, -0.00066621f, 
    0.02523259f, 0.04822540f, 0.03810322f, 0.01752315f, 0.02096069f, -0.02673782f, 0.03093266f, 0.00021268f, 
    -0.02419586f, -0.00045295f, -0.01642802f, -0.01752068f, -0.01296974f, -0.04858033f, 0.03529071f, -0.06158724f, 
    -0.00439143f, -0.04110738f, -0.03004088f, -0.02706015f, 0.00857571f, 0.00421311f, 0.02929864f, -0.05455955f, 
    0.04949534f, -0.04993025f, -0.04593291f, -0.05090940f, 0.04406274f, -0.03627126f, -0.03041637f, 0.02514030f, 
    -0.03737755f, -0.04967573f, -0.00603649f, 0.05144170f, 0.02788159f, -0.00848799f, 0.03946535f, 0.02043667f, 
    -0.04725821f, 0.04981410f, 0.03135346f, -0.02600299f, -0.04031964f, -0.02224475f, -0.02548350f, 0.03853788f, 
    0.01212677f, -0.02026843f, -0.04924615f, 0.02408122f, 0.03739837f, 0.00829101f, -0.00268902f, -0.02816680f, 
    -0.04930520f, -0.00231101f, -0.01992507f, -0.00452879f, 0.04382790f, 0.02236083f, -0.03616413f, -0.04388568f, 
    -0.04087134f, -0.05863595f, -0.03547866f, -0.05866925f, 0.00359034f, -0.00703812f, 0.00923743f, -0.05248710f, 
    -0.05889245f, -0.01510897f, -0.04626758f, 0.02241749f, -0.02955425f, -0.02357614f, -0.00761702f, -0.02739700f, 
    0.04487409f, -0.00760760f, 0.01838746f, -0.04543378f, -0.01298263f, -0.01277305f, 0.05644348f, -0.01063231f, 
    -0.00356617f, 0.04686715f, 0.03772627f, -0.04510973f, 0.00940494f, -0.04382464f, -0.00042587f, -0.05814414f, 
    -0.00910810f, -0.06001356f, -0.00574785f, 0.03003817f, 0.00128554f, -0.04322243f, 0.01794599f, -0.02624041f, 
    -0.26036581f, 0.47446644f, 0.04810563f, -0.04102522f, 0.26291960f, -0.18007457f, -0.16924380f, 0.18489672f, 
    -0.10445334f, 0.06171627f, -0.05902966f, -0.03903812f, 0.21986130f, 0.10343277f, -0.00283202f, -0.03415539f, 
    -0.05703092f, -0.06564001f, -0.12252141f, 0.10226460f, -0.24961454f, 0.00910185f, 0.25376105f, -0.12468067f, 
    0.04198704f, 0.20012674f, 0.21396495f, 0.18779697f, -0.21368735f, 0.14416617f, -0.13844718f, 0.16689223f, 
    0.13301508f, -0.09949298f, -0.23113960f, 0.02543393f, 0.01273563f, 0.04578853f, 0.10359714f, 0.02127567f, 
    0.41252670f, -0.05652358f, -0.10033539f, -0.08382378f, -0.32731533f, 0.01700411f, 0.08337738f, 0.08074044f, 
    0.00454626f, 0.03061773f, 0.02286836f, 0.02871128f, -0.20812702f, -0.08718423f, -0.14651017f, 0.11684053f, 
    0.12679431f, -0.03813406f, 0.13976187f, -0.12076351f, -0.12538126f, -0.68448287f, -0.05408909f, 0.00847183f, 
    0.07575504f, 0.12311776f, 0.09403891f, 0.14611901f, 0.11920412f, -0.03223045f, -0.09029891f, -0.12286372f, 
    -0.03959402f, 0.06282321f, -0.17329280f, 0.02301576f, 0.00611629f, -0.08844643f, 0.13004324f, -0.14508006f, 
    -0.42865956f, 0.47264934f, 0.20169018f, -0.10814672f, 0.01428868f, 0.11333362f, -0.11978312f, -0.00686169f, 
    0.09439805f, -0.08609280f, 0.03826407f, 0.00120626f, -0.11962531f, 0.04154659f, -0.09174416f, -0.01113403f, 
    0.01295865f, 0.08134503f, 0.01383773f, -0.08822215f, 0.54268718f, -0.02801081f, -0.18649773f, -0.12449721f, 
    0.45271611f, -0.07383268f, -0.00623141f, 0.04980962f, 0.04964432f, 0.11641704f, 0.03380864f, 0.02011249f, 
    0.02228407f, -0.11300226f, 0.16346291f, 0.02192762f, 0.02504972f, 0.16481087f, -0.06305818f, 0.03156590f, 
    0.22128609f, -0.15611883f, 0.01959406f, -0.10392040f, -0.27108821f, -0.00745445f, -0.04882836f, -0.07231517f, 
    0.09641667f, 0.04417929f, 0.01765931f, -0.19303940f, 0.03220910f, 0.06316707f, 0.04414656f, 0.00779851f, 
    -0.17601888f, -0.07850407f, 0.10178177f, 0.13903791f, -0.10552306f, -0.12779315f, 0.24245045f, -0.15742101f, 
    -0.27004457f, 0.12067286f, 0.05203059f, 0.17888668f, 0.07526769f, 0.05272132f, 0.12475359f, 0.12132291f, 
    0.08614887f, 0.02750968f, -0.04593307f, 0.04176182f, -0.05964022f, 0.04276056f, 0.02679368f, -0.10616434f, 
    0.32971954f, -0.02010055f, -0.02934621f, -0.03097916f, -0.00440951f, -0.05523339f, -0.02997417f, -0.18384229f, 
    0.11467031f, -0.01219694f, 0.18110941f, -0.02871683f, 0.03949671f, 0.21556838f, 0.06513587f, -0.02915627f, 
    0.06692955f, -0.10265273f, -0.06555539f, 0.04206699f, -0.04718591f, -0.31859228f, 0.04394308f, 0.04741210f, 
    0.27934042f, -0.03162323f, -0.05976974f, -0.00965764f, 0.20932077f, 0.02274911f, 0.03028112f, 0.03553532f, 
    0.01886454f, -0.05836191f, 0.02202366f, -0.02464870f, -0.05380415f, 0.14517541f, -0.00485996f, 0.15633757f, 
    0.56240404f, -0.24516629f, -0.02694124f, -0.26909271f, 0.15868787f, -0.11278507f, 0.00169542f, 0.11883757f, 
    0.05185269f, -0.05240584f, -0.05322389f, -0.11766550f, 0.03123109f, -0.02442466f, -0.11848116f, 0.18017784f, 
    -0.07203345f, 0.01812350f, -0.03614796f, 0.19934469f, 0.42002711f, -0.32726780f, -0.10879461f, 0.05050270f, 
    -0.17384510f, -0.11727519f, 0.00426902f, -0.15169972f, 0.01693530f, 0.16006508f, 0.00800194f, 0.02299549f, 
    -0.00208199f, 0.00841486f, -0.06308106f, 0.09356239f, -0.08377104f, 0.11040904f, 0.04409203f, 0.09182853f, 
    -0.21442062f, -0.10443408f, 0.25657663f, -0.23261721f, -0.15108065f, 0.11005571f, 0.11615017f, 0.00402193f, 
    -0.17634383f, -0.02188791f, -0.08365025f, -0.09715733f, -0.12959382f, 0.09970449f, 0.13799442f, 0.07971747f, 
    0.08660413f, 0.02309661f, 0.00389278f, 0.05359218f, 0.33560380f, 0.06935352f, -0.03264872f, -0.00540869f, 
    0.16842201f, 0.02538327f, -0.01779649f, -0.01044839f, 0.02629241f, -0.01612596f, 0.00440522f, 0.05632475f, 
    -0.06063142f, 0.09784029f, 0.17354776f, 0.09189831f, 0.05808891f, 0.25281227f, 0.08870084f, -0.03142281f, 
    0.03588220f, -0.36215100f, -0.07090094f, 0.02945464f, 0.24283707f, -0.12620525f, 0.03410355f, 0.13494335f, 
    0.04250255f, -0.05389724f, 0.05431736f, -0.00282851f, 0.16714156f, 0.02650655f, 0.17690584f, -0.13785192f, 
    0.06725957f, 0.16350184f, 0.01778566f, 0.01001525f, 0.61186564f, -0.18195546f, -0.01041445f, 0.05368960f, 
    -0.20090957f, -0.15705051f, -0.13805628f, -0.18998723f, 0.02251676f, 0.00207905f, 0.11877701f, 0.10751331f, 
    -0.11317558f, 0.08578591f, -0.05991754f, 0.05028263f, -0.03585236f, 0.03352298f, 0.03675759f, 0.06262306f, 
    0.18778990f, 0.58742774f, 0.28537506f, 0.35396796f, 0.23698431f, -0.25132087f, -0.10887082f, 0.13463886f, 
    -0.11997275f, 0.11860301f, -0.18152976f, 0.04747022f, 0.04780138f, 0.01385136f, 0.12305529f, -0.01244001f, 
    -0.10222636f, -0.03398449f, -0.02500806f, 0.13092363f, -0.21448734f, -0.06074680f, 0.03959825f, 0.18248260f, 
    -0.01906316f, 0.10273796f, -0.05663022f, 0.06781600f, -0.11157762f, 0.05016134f, -0.22076720f, 0.00654443f, 
    -0.00678621f, 0.14947127f, -0.08740191f, -0.11127134f, -0.11198436f, 0.11593498f, 0.13244253f, -0.05464265f, 
    0.18853608f, -0.46177679f, -0.19629757f, 0.02854911f, -0.19913246f, 0.09391084f, 0.00565445f, -0.12333467f, 
    0.07735429f, 0.04901680f, 0.05632369f, -0.01131532f, -0.10836478f, 0.21861018f, 0.09865569f, -0.14431044f, 
    0.08157404f, -0.11692965f, -0.04635388f, -0.07429277f, 0.33948681f, -0.61777604f, -0.22757091f, -0.12529626f, 
    -0.00373423f, -0.00988512f, -0.07982219f, 0.10904080f, 0.02959424f, -0.04169786f, 0.00542062f, 0.06337588f, 
    -0.13413981f, -0.06050341f, -0.24585441f, -0.05474910f, -0.02230460f, -0.02344561f, 0.10218520f, -0.10117810f, 
    0.25261611f, 0.62176651f, 0.19299963f, 0.12979659f, 0.16200070f, -0.24479838f, -0.27774611f, 0.13415836f, 
    0.08369225f, 0.04047443f, 0.13132063f, -0.04987097f, -0.05516546f, 0.07027786f, 0.03565163f, -0.01888490f, 
    0.08663625f, 0.08012402f, -0.03025506f, -0.05502556f, -0.31746501f, 0.09199832f, 0.03137922f, -0.11962111f, 
    0.13676205f, -0.03576855f, 0.08288834f, 0.13872738f, -0.13525195f, -0.03857128f, 0.00178011f, 0.01123484f, 
    0.01199650f, -0.09306353f, -0.03481354f, 0.04862371f, -0.02481922f, 0.24504516f, -0.01373505f, -0.11244988f, 
    -0.23391083f, 0.04048475f, -0.16493934f, 0.00610783f, -0.12189857f, 0.17913282f, 0.03202162f, 0.06405604f, 
    0.16332194f, 0.13133340f, 0.03250720f, -0.10688513f, 0.03407459f, 0.02284132f, -0.17438719f, 0.07630767f, 
    0.00214345f, -0.10741603f, 0.08966235f, 0.08972669f, 0.18639231f, -0.15241560f, 0.11805314f, 0.19378594f, 
    0.13445552f, -0.06611205f, -0.21649128f, 0.06696901f, 0.10507151f, 0.00545031f, -0.02634985f, -0.03627611f, 
    0.21653463f, 0.10631621f, 0.01738266f, -0.01400999f, 0.00184011f, -0.08335256f, 0.10196830f, -0.01175078f, 
    -0.27410236f, 0.14448036f, -0.09231944f, -0.15554465f, -0.07964671f, -0.11334357f, 0.15137802f, -0.00147978f, 
    0.08691885f, -0.13007669f, 0.11393064f, -0.01962192f, 0.02342366f, 0.10082854f, 0.01984968f, 0.11330050f, 
    0.08051905f, -0.09171278f, 0.00638198f, 0.03569857f, 0.64856297f, -0.15188308f, 0.28809884f, -0.08655503f, 
    0.32751283f, -0.16933987f, -0.18005496f, -0.02910992f, 0.13854389f, 0.07445662f, -0.03875784f, 0.02098347f, 
    0.01062584f, -0.00220806f, 0.13634604f, -0.10532692f, 0.02597696f, -0.01566380f, 0.06185056f, -0.02766310f, 
    0.35482606f, -0.48417497f, 0.11581978f, -0.34452453f, 0.15731326f, 0.05630612f, -0.02015758f, -0.04202782f, 
    -0.08930543f, -0.13206546f, -0.00270207f, -0.07558626f, -0.06881025f, 0.09389817f, -0.22293821f, 0.12255623f, 
    0.10472661f, -0.08040450f, -0.05316392f, 0.10008052f, 0.26406592f, -0.04495563f, -0.17152773f, -0.15109360f, 
    -0.23843697f, 0.13354506f, 0.21242861f, -0.02246902f, 0.14541586f, 0.07143208f, -0.07018207f, -0.02574920f, 
    0.01614640f, -0.08951922f, -0.02931415f, 0.04199466f, -0.05289320f, 0.11024900f, -0.16995920f, 0.08514755f, 
    -0.35046071f, -0.29603913f, 0.11462415f, -0.02493755f, -0.05217505f, 0.02543403f, 0.15693712f, 0.12437981f, 
    -0.02627004f, 0.09406164f, 0.11645355f, 0.00544651f, 0.09591462f, 0.00198030f, 0.09314646f, -0.12898479f, 
    0.04654193f, -0.00785369f, 0.02376739f, -0.02429248f, -0.05491788f, -0.04909369f, 0.08668481f, 0.23354028f, 
    0.28469971f, 0.02835506f, -0.09967381f, 0.08921498f, -0.05813133f, 0.09318434f, 0.08379930f, 0.00040718f, 
    -0.10892303f, -0.02280663f, 0.12542997f, 0.05348894f, -0.00978003f, -0.17482843f, 0.02096033f, -0.00477887f, 
    -0.02493351f, -0.13289747f, -0.06571046f, 0.05490033f, 0.11954190f, 0.02599124f, 0.04321217f, -0.10063522f, 
    -0.14258492f, 0.08763977f, 0.15648447f, 0.03187285f, 0.03725564f, -0.01043993f, -0.05417323f, 0.04136854f, 
    -0.05890712f, -0.07392253f, 0.00657104f, 0.07628568f, 0.19327886f, 0.03910571f, -0.14127000f, -0.16664600f, 
    -0.16914137f, 0.05035935f, 0.18865420f, 0.05039997f, 0.09040558f, -0.07505055f, 0.07927108f, -0.02421401f, 
    -0.07162096f, 0.01473587f, 0.02472684f, 0.05861902f, 0.12920804f, -0.01456766f, -0.03825404f, 0.10021549f, 
    -0.02871883f, -0.04513546f, 0.01365280f, -0.02821926f, -0.00873559f, 0.03890801f, -0.01292894f, -0.01371945f, 
    0.01042430f, -0.05024770f, 0.03765652f, 0.00642642f, -0.03757546f, 0.03888671f, -0.01312469f, 0.01267735f, 
    0.03995188f, -0.01487102f, 0.04536565f, 0.03845003f, -0.00605567f, -0.05695946f, -0.02770896f, 0.00087803f, 
    0.02695334f, 0.02036092f, -0.05909437f, 0.04415264f, -0.02079509f, 0.01460717f, -0.05213992f, 0.03998204f, 
    -0.00679342f, -0.01890844f, 0.00450769f, -0.02397553f, 0.01134117f, 0.01692495f, -0.03205078f, -0.03308894f, 
    -0.03514123f, -0.00969366f, 0.04915740f, -0.03534388f, -0.05375714f, -0.01765783f, 0.04115773f, 0.00015749f, 
    -0.05904899f, 0.00348216f, -0.00591377f, 0.02442338f, 0.02676881f, -0.00657145f, -0.01980293f, 0.02164970f, 
    -0.00505151f, 0.04961993f, 0.01018447f, -0.00564507f, -0.01986754f, -0.05871114f, 0.02896428f, -0.01728567f, 
    0.03185300f, 0.00329418f, 0.00389702f, -0.05013853f, 0.00522061f, 0.00181421f, -0.00867110f, -0.00151353f, 
    -0.01732519f, -0.02156713f, 0.01215252f, 0.03667623f, -0.01261756f, 0.01311834f, -0.04605367f, -0.03497909f, 
    -0.02571969f, -0.03548279f, -0.04855607f, 0.00993405f, -0.00427978f, -0.02644366f, 0.02448110f, 0.02050203f, 
    -0.02755661f, -0.00740213f, -0.05526396f, -0.04080896f, -0.04049652f, -0.02966301f, -0.02813820f, -0.03774621f, 
    -0.00483749f, -0.05053537f, -0.04479119f, -0.03764937f, -0.00875756f, 0.01507581f, 0.01699297f, 0.03121219f, 
    -0.01746927f, -0.02038694f, 0.02393735f, 0.00428904f, -0.00523333f, -0.04628645f, -0.05366949f, 0.03615635f, 
    -0.01603289f, 0.00208042f, 0.00794640f, 0.01995140f, -0.04342597f, 0.02983316f, 0.01719673f, 0.00274469f, 
    -0.00346695f, -0.00696976f, -0.00231217f, 0.00564461f, -0.05366207f, -0.02198318f, -0.02790658f, -0.02992251f, 
    0.03734491f, 0.01703298f, 0.04279601f, 0.01510068f, 0.04292994f, -0.02962540f, 0.04586405f, 0.00917678f, 
    -0.00138821f, -0.04609041f, -0.05341399f, -0.01047768f, 0.02061940f, 0.01562648f, -0.04741948f, 0.00172307f, 
    -0.05855728f, 0.00255783f, -0.04794342f, 0.04958038f, -0.05044847f, 0.00765401f, 0.01352206f, 0.00643381f, 
    0.03761125f, 0.04537128f, -0.04449304f, -0.00512933f, -0.00325951f, 0.02043114f, 0.00737883f, -0.05053646f, 
    -0.03129189f, 0.00994349f, -0.05578551f, -0.05069321f, -0.02653365f, 0.00240906f, -0.06098742f, 0.02273325f, 
    -0.00852559f, 0.04320435f, -0.02065131f, -0.04961257f, 0.02797023f, -0.04984426f, -0.00760327f, -0.05138183f, 
    0.02758240f, -0.04917738f, 0.01331565f, -0.03596449f, -0.05858715f, -0.03392968f, -0.00681321f, -0.01056342f, 
    0.03665018f, 0.03543689f, 0.04075092f, 0.00456917f, 0.05050309f, -0.03351057f, 0.03860562f, -0.04410612f, 
    0.02996910f, -0.04884483f, -0.04174343f, 0.00134581f, -0.00745394f, -0.03441898f, 0.01334404f, 0.01276950f, 
    0.02785285f, -0.03705564f, -0.04523413f, -0.02138799f, -0.02071149f, -0.02386830f, 0.00169146f, 0.00737433f, 
    -0.03269633f, -0.01302596f, 0.00222287f, 0.04704196f, -0.00397015f, 0.02975552f, 0.01265514f, -0.01879520f, 
    0.03537705f, 0.02555260f, -0.03283620f, -0.04423951f, -0.04111731f, 0.01868212f, 0.04991200f, -0.04641408f, 
    -0.00678276f, 0.00818288f, 0.01037522f, -0.01505344f, 0.03881014f, 0.00704678f, -0.00279522f, 0.03437851f, 
    0.01096777f, -0.05428068f, -0.00320709f, -0.03621285f, -0.05832537f, 0.00846203f, 0.04229370f, -0.03362067f, 
    -0.05900036f, -0.00765397f, -0.03260347f, -0.01965505f, -0.01138140f, 0.01536281f, 0.00885228f, -0.02704268f, 
    0.03720460f, 0.00068178f, -0.03153735f, -0.02945380f, -0.04262671f, -0.00965102f, 0.03183006f, -0.03904826f, 
    0.02705360f, 0.02133489f, -0.03555007f, -0.02773376f, -0.04156646f, -0.00927927f, -0.05348827f, 0.03582764f, 
    -0.02895405f, -0.04337494f, -0.04249452f, -0.02041949f, -0.01128133f, 0.03673524f, -0.00406466f, 0.04087301f, 
    -0.05002826f, 0.02622354f, 0.01437687f, 0.02809005f, 0.02488161f, -0.04452720f, -0.00470947f, 0.00326379f, 
    -0.00743822f, 0.00583712f, -0.04744716f, 0.00634133f, -0.03582982f, -0.00274029f, -0.01651588f, -0.05041260f, 
    0.03180491f, 0.00771484f, -0.01105841f, 0.00701838f, 0.02067712f, -0.00374302f, 0.04551644f, 0.00293438f, 
    -0.00914548f, -0.03818856f, -0.00032569f, -0.00245737f, -0.03171781f, -0.02288385f, -0.00682941f, 0.01021022f, 
    -0.02559131f, 0.03315639f, -0.04073213f, 0.02156217f, -0.05938108f, -0.02870492f, -0.04608054f, -0.02745257f, 
    0.03332362f, -0.02563091f, 0.03266133f, 0.03259160f, -0.00933797f, 0.01476590f, -0.02745862f, -0.02845036f, 
    -0.05504562f, -0.02793891f, 0.02310529f, -0.05289577f, 0.04601019f, 0.03300850f, 0.03820136f, -0.01159486f, 
    -0.05410866f, 0.03086731f, 0.04428781f, -0.03438710f, 0.03307667f, 0.04815725f, -0.05872954f, -0.04382123f, 
    -0.00941343f, -0.00433000f, -0.05650093f, -0.04625360f, -0.04936748f, -0.01209118f, -0.01258248f, -0.03452005f, 
    -0.00090422f, -0.04135111f, 0.01885906f, 0.01772309f, -0.01750528f, 0.01867659f, -0.00351354f, -0.01068432f, 
    0.03065795f, 0.03575505f, 0.01949551f, -0.00283838f, 0.00442198f, 0.03333652f, -0.04697732f, 0.04690050f, 
    0.01056306f, 0.03417497f, -0.01719431f, 0.01878666f, 0.02663944f, -0.01161659f, 0.05011908f, -0.01906078f, 
    -0.01886671f, -0.02485145f, -0.02143201f, -0.03601141f, -0.01386113f, -0.05864630f, 0.00010517f, 0.04601148f, 
    0.03739394f, -0.01118118f, -0.03318075f, -0.05088845f, -0.04895171f, -0.02410461f, -0.05460688f, 0.02676891f, 
    -0.00874455f, 0.03359419f, -0.04300788f, -0.02599014f, -0.00105328f, 0.00371286f, 0.04278629f, 0.01761217f, 
    -0.01901949f, -0.04763376f, 0.00966887f, -0.00716591f, -0.00766750f, -0.03909457f, -0.05700628f, -0.02817610f, 
    -0.02223008f, 0.00625488f, -0.04321510f, 0.02400939f, -0.04899140f, 0.02866560f, -0.02242150f, -0.04145411f, 
    0.05401741f, -0.03377209f, 0.00095877f, -0.01221594f, 0.03227161f, 0.03378504f, -0.04117539f, -0.02993204f, 
    -0.01641738f, 0.00019662f, -0.02688942f, 0.01973341f, -0.01023713f, 0.04460851f, -0.03786974f, -0.01245855f, 
    -0.03681520f, 0.02119561f, -0.05216756f, -0.00047572f, 0.03641437f, -0.04839411f, -0.01573840f, -0.00321248f, 
    -0.04846318f, -0.00164758f, -0.01548260f, -0.00103311f, -0.04373020f, -0.05213053f, -0.01563637f, -0.01714157f, 
    -0.02946096f, -0.04738735f, -0.02828456f, 0.04049505f, -0.00170642f, -0.04253372f, 0.02152537f, -0.03280701f, 
    0.00800409f, 0.00468859f, 0.05220906f, -0.06126153f, -0.04290582f, 0.02130569f, 0.00495586f, 0.04034429f, 
    0.00450814f, 0.00797333f, -0.02194689f, 0.00610110f, -0.00621469f, -0.03849067f, -0.04419279f, 0.05019553f, 
    -0.03477788f, 0.05191317f, -0.04230987f, 0.03215170f, -0.05306130f, -0.01520853f, 0.02335092f, 0.02756473f, 
    -0.02620447f, 0.00042620f, -0.02631379f, 0.02056730f, -0.04558333f, -0.00298919f, -0.00828278f, 0.04114112f, 
    -0.00008948f, 0.02572237f, 0.02611088f, -0.02081357f, 0.05498924f, -0.03652036f, 0.00324344f, 0.01996127f, 
    -0.00931590f, 0.00596672f, 0.03624110f, 0.00059585f, -0.01552967f, -0.02758836f, 0.05083797f, -0.06015284f, 
    -0.02315993f, 0.03062531f, 0.00353436f, 0.01860113f, -0.04459838f, -0.05150881f, -0.02295516f, -0.04570431f, 
    0.01981069f, -0.01279713f, -0.03938521f, -0.02001371f, 0.03647402f, -0.03505283f, 0.02857851f, 0.04190936f, 
    -0.05896603f, -0.02169812f, 0.02897318f, -0.00649438f, -0.01536868f, 0.00112617f, 0.04096190f, -0.00841170f, 
    -0.00185916f, 0.02441588f, 0.01873978f, 0.02015748f, -0.04349763f, 0.03038945f, -0.02112464f, -0.04969381f, 
    0.04328976f, -0.04154767f, -0.05070331f, -0.04429679f, -0.04518037f, -0.02752705f, 0.02697680f, 0.03450148f, 
    -0.02761036f, -0.02756262f, 0.00017752f, -0.00952397f, -0.02413635f, -0.02635054f, -0.02435202f, 0.05202625f, 
    -0.05164859f, 0.01182269f, -0.04050206f, 0.02746568f, 0.02651828f, 0.00430790f, 0.01340926f, -0.04088976f, 
    0.03262632f, -0.02030090f, -0.03666389f, 0.01712138f, -0.03885017f, 0.02921654f, -0.02038436f, 0.01232486f, 
    -0.01615867f, -0.05756730f, -0.05982936f, 0.02710385f, 0.00674739f, -0.05311557f, -0.06092187f, -0.04081397f, 
    0.04188840f, -0.01570622f, 0.05554462f, -0.05014801f, -0.04752705f, 0.01217519f, -0.01438115f, 0.01915316f, 
    -0.03507747f, 0.04387826f, -0.06172424f, 0.04270976f, 0.01978916f, 0.04997677f, -0.04284426f, 0.00864338f, 
    0.01545052f, -0.01311654f, -0.00257633f, 0.02396737f, 0.04568150f, 0.01588274f, -0.01904435f, -0.05694174f, 
    0.03101960f, -0.04120179f, 0.02247347f, 0.02452501f, -0.01559895f, 0.00888990f, -0.04527885f, -0.00703205f, 
    0.03559243f, -0.03843457f, 0.02042366f, 0.02919086f, -0.02094348f, -0.02393282f, 0.02847930f, -0.05879374f, 
    -0.00002050f, -0.04126516f, -0.01995022f, 0.03910585f, -0.03880243f, -0.02302141f, 0.05236288f, -0.05014816f, 
    0.01044434f, -0.01956528f, 0.03360086f, -0.02269742f, -0.00182040f, -0.04352914f, 0.04466078f, 0.00002771f, 
    -0.05842090f, 0.02325725f, -0.02365046f, 0.04268758f, -0.06011668f, 0.02776006f, 0.04767435f, -0.04536291f, 
    -0.03118319f, 0.02180029f, -0.01024007f, -0.00928042f, -0.04392362f, -0.05213052f, -0.03255621f, 0.04861626f, 
    -0.03252617f, 0.07315537f, 0.13404825f, -0.27942711f, -0.33435437f, -0.02830433f, 0.16105030f, -0.03376090f, 
    -0.14459386f, 0.02277057f, 0.01775870f, -0.09502240f, 0.07764765f, 0.07195272f, -0.03264642f, 0.00489857f, 
    0.17553808f, -0.01019552f, -0.13444738f, 0.00728817f, -0.03061437f, -0.39458948f, 0.14743027f, -0.14203742f, 
    -0.33832827f, -0.28266898f, -0.10978014f, 0.14537624f, 0.08016771f, 0.00139734f, 0.05284648f, 0.01277860f, 
    0.10806143f, -0.09777696f, 0.01817307f, 0.02130384f, 0.05837328f, -0.19153696f, -0.28716278f, -0.02470696f, 
    0.27382675f, -0.10197447f, -0.22615424f, -0.08777956f, 0.25937301f, -0.04756547f, 0.11652178f, 0.03940107f, 
    0.11432113f, 0.20699760f, -0.01258902f, 0.10556173f, 0.19748740f, -0.01490844f, 0.01095098f, 0.09532183f, 
    0.00919100f, 0.05875229f, 0.00839399f, 0.00632823f, -0.54371136f, -0.08017018f, -0.03051850f, 0.13152163f, 
    0.18583046f, 0.17096221f, 0.00865719f, -0.02896013f, -0.09373234f, -0.08744027f, -0.06396227f, -0.04282779f, 
    0.09002893f, 0.08260581f, 0.28432363f, 0.01760985f, 0.04385269f, 0.10836955f, -0.08298466f, 0.06796462f, 
    0.51677525f, 0.04245184f, 0.40733948f, -0.26031643f, -0.43093100f, 0.01327409f, 0.08420179f, -0.13067098f, 
    -0.01754131f, 0.01206106f, 0.04148650f, 0.05170003f, 0.07900142f, 0.17111890f, 0.00742893f, 0.02021303f, 
    -0.03493866f, 0.20608191f, -0.06227537f, 0.04246902f, 0.31073847f, -0.75255722f, -0.18956710f, -0.10197321f, 
    0.28255376f, -0.11437029f, 0.10062939f, 0.08852060f, 0.02003345f, 0.08521655f, 0.01985404f, -0.02506980f, 
    0.25710401f, -0.01543255f, 0.14797951f, 0.01302625f, -0.01726709f, 0.08045810f, -0.18138346f, 0.08818012f, 
    0.08670130f, -0.04689704f, -0.15954344f, 0.05646836f, 0.05325547f, -0.05722276f, 0.12740460f, 0.10416903f, 
    0.08946855f, 0.06223293f, 0.01265645f, -0.07366833f, 0.10641114f, 0.07473589f, 0.09570580f, 0.11981759f, 
    -0.04400501f, -0.04071216f, -0.03003412f, 0.09528872f, -0.11301874f, 0.20659344f, 0.34983242f, -0.15173434f, 
    -0.34552982f, 0.07612794f, -0.03821113f, 0.07679643f, -0.15226293f, -0.03935211f, -0.05828025f, -0.00764860f, 
    -0.09695801f, -0.03230077f, 0.20962298f, 0.02299829f, 0.03183750f, -0.07731175f, -0.09364980f, -0.07614827f, 
    0.19029640f, 0.28960413f, -0.13434280f, 0.19461697f, -0.06026927f, 0.19948426f, 0.00062924f, -0.16207172f, 
    0.09707342f, 0.12060614f, 0.12693220f, -0.02892725f, 0.01724586f, 0.00981125f, -0.03750003f, -0.02608399f, 
    -0.02662195f, 0.04442210f, -0.18864316f, 0.06552023f, -0.27783391f, 0.19035125f, 0.30067009f, -0.15642881f, 
    0.12047993f, 0.30661944f, 0.30314842f, 0.02845596f, -0.00041274f, 0.05724371f, 0.08901474f, 0.18275562f, 
    0.04832816f, -0.04808575f, 0.09352845f, 0.17013997f, 0.10020784f, 0.11165717f, -0.02469721f, 0.05403841f, 
    -0.06345386f, -0.12021706f, -0.06732912f, 0.11031514f, 0.00236558f, 0.33932090f, 0.10299098f, 0.09069753f, 
    0.09955110f, 0.08796864f, 0.02700654f, -0.03118030f, 0.11641181f, -0.13432297f, 0.04307209f, 0.02974620f, 
    0.02412545f, 0.11101770f, -0.03350068f, -0.12944305f, 0.15262228f, -0.29858208f, -0.30393305f, 0.22793111f, 
    0.14235528f, 0.08690994f, -0.07684209f, 0.09953069f, -0.07912619f, 0.08662108f, -0.00828684f, 0.00472756f, 
    -0.03868852f, -0.09160659f, -0.00394459f, 0.04501203f, 0.04155087f, 0.01914536f, 0.00135388f, -0.03444202f, 
    0.06668768f, -0.05923551f, 0.05092436f, -0.22926171f, 0.01853052f, 0.13251209f, -0.13351186f, 0.03425783f, 
    -0.02885633f, 0.08727493f, 0.15353070f, -0.11755976f, 0.06222996f, 0.11788291f, 0.08227095f, 0.17855735f, 
    0.02569222f, -0.10228137f, 0.01410536f, 0.01865353f, -0.39818472f, -0.61827195f, -0.04325413f, -0.04980926f, 
    0.12605575f, -0.10682687f, 0.19995353f, 0.29781774f, 0.03362657f, -0.00256111f, -0.05981559f, -0.05767102f, 
    -0.03169240f, 0.00231890f, -0.06266826f, 0.08869720f, 0.22898450f, 0.08642034f, 0.13221495f, -0.09390049f, 
    0.02453938f, -0.15677314f, 0.32724932f, -0.16805175f, 0.17111801f, 0.05335446f, 0.09056667f, 0.07917509f, 
    0.11924168f, 0.11669505f, 0.03766901f, 0.09905723f, -0.01437030f, -0.05923213f, 0.06278468f, -0.05177048f, 
    0.17755871f, 0.12074926f, 0.00339977f, 0.09025721f, 0.24438864f, -0.22543770f, -0.16825342f, 0.25608182f, 
    0.04340475f, 0.12739921f, -0.07506890f, 0.04603499f, -0.09217288f, 0.05335880f, -0.01558021f, 0.07701247f, 
    -0.01046253f, -0.01077925f, -0.08690427f, -0.02414938f, -0.09301350f, 0.01150511f, -0.07515480f, -0.12218344f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09532232f, 0.00344197f, 0.12774040f, -0.03486565f, 0.02329771f, -0.01853506f, -0.03915496f, -0.01064849f, 
    -0.00475681f, 0.03588697f, 0.08905154f, 0.10721488f, 0.04259797f, 0.06844224f, -0.00832811f, -0.02331270f, 
    0.04227347f, 0.17672281f, -0.01188711f, -0.05693582f, -0.01555095f, -0.05262971f, 0.01884174f, -0.05788906f, 
    -0.01006402f, 0.02874871f, -0.00139039f, -0.05093802f, 0.02350582f, -0.03682321f, -0.02727279f, 0.07577265f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08337800f, 0.01226914f, -0.71762472f, 0.04449657f, -0.07419286f, 0.01621096f, 0.15359029f, 0.15025893f, 
    -0.15991470f, -0.23119347f, -0.63840151f, -0.55414546f, 0.33895153f, -0.30589291f, -0.06560233f, 0.06477090f, 
    -0.06952748f, -0.04332066f, 0.05053386f, -0.04422712f, 0.16246404f, 0.27750236f, 0.07496308f, -0.04585324f, 
    0.39278737f, 0.06957649f, 0.09075068f, 0.32897088f, 0.36627281f, -0.02533427f, 0.00459054f, -0.14461973f, 
    0.18245837f, -0.32126093f, 0.56132740f, -0.54649979f, -0.05521959f, -0.03713803f, -0.09103052f, 0.03603923f, 
    0.08672412f, 0.05833871f, -0.20176880f, -0.53855771f, -0.20911267f, 0.37069601f, -0.01410833f, -0.41861182f, 
    0.05820007f, 0.22017738f, 0.07378292f, 0.06677391f, 0.14465067f, -0.12810920f, -0.05581685f, -0.08801889f, 
    0.11515073f, -0.03721048f, -0.02553443f, 0.16869521f, 0.44889686f, -0.10737068f, 0.00481023f, 0.07005109f, 
    0.17708695f, -0.16740468f, 0.11596910f, 0.41125014f, -0.07182375f, -0.00051907f, 0.11895248f, 0.00222026f, 
    0.15966210f, -0.29569602f, 0.09186649f, -0.18538935f, -0.19381069f, 0.26583037f, -0.16399591f, 0.24884292f, 
    -0.14462204f, -0.42017743f, 0.06174397f, -0.10415336f, -0.00341739f, 0.07289742f, -0.09686621f, 0.05942028f, 
    -1.01794815f, -0.00534670f, 0.13777557f, 0.47617361f, 0.08620712f, 0.16525839f, -0.03653774f, -0.00215618f, 
    -0.19275837f, 0.32133943f, 0.02887505f, -0.08393846f, 0.05988575f, -0.08031394f, -0.48764041f, 0.01523277f, 
    -0.05680171f, 0.35840547f, 0.21860071f, -0.48607913f, 0.25996858f, -0.05848962f, -0.15015520f, 0.28607970f, 
    -0.16822527f, 0.28969410f, 0.03477676f, 0.05945783f, -0.01103388f, -0.92049354f, 0.15297128f, 0.08039469f, 
    0.21534379f, 0.13350743f, 0.03415262f, -0.15696631f, -0.80274993f, 0.08686212f, 0.12080371f, -1.00787914f, 
    -0.84171915f, 0.08977576f, 0.35541931f, -0.12424113f, 0.12575498f, 0.02785215f, 0.48321262f, -0.04552902f, 
    -0.12967093f, -0.01267368f, 0.04065228f, 0.33928633f, 0.07774803f, -0.24897967f, 0.15693450f, 0.24309492f, 
    0.16439959f, 0.10967683f, 0.14066823f, 0.11921899f, 0.15947443f, -0.72378165f, -0.00536974f, -0.13249737f, 
    -0.02657494f, 0.12173854f, -0.00568612f, -0.21103334f, 0.01355082f, 0.13852187f, 0.11379927f, -0.20088729f, 
    -0.16291842f, 0.30074060f, 0.01828989f, -0.13933243f, 0.14584985f, -0.01452271f, -0.14247186f, -0.12510362f, 
    -0.05620661f, -0.30144405f, -0.47901222f, 0.46703485f, 0.07465564f, 0.23522666f, 0.17047814f, -0.37364948f, 
    0.16847830f, 0.41686964f, -0.04494157f, 0.13834569f, -0.16430138f, 0.40416351f, -0.15161481f, -0.12249603f, 
    0.04904535f, 0.03773981f, 0.14373346f, -0.46076715f, 0.11908678f, 0.06805704f, -0.14493254f, -0.03125194f, 
    0.07816415f, 0.15352820f, 0.12704800f, -0.01057572f, -0.13373302f, -0.08973539f, 0.00108185f, -0.07294711f, 
    0.12727761f, 0.33074275f, 0.17422161f, 0.45638493f, -0.22641826f, -0.69350290f, 0.12473950f, -0.56398290f, 
    -0.07279672f, -0.27808675f, 0.08948523f, -0.03299195f, -0.12771693f, 0.41267940f, -0.15654330f, -0.17779256f, 
    -0.20697086f, 0.17964540f, 0.14541474f, 0.36563537f, 0.15995856f, 0.06201157f, -0.07757523f, -0.09172636f, 
    0.49903974f, 0.26478261f, -0.03262564f, -0.31103879f, -0.14950562f, -0.08203659f, 0.28322026f, -0.09039225f, 
    -0.15167791f, -0.51455861f, 0.26161677f, 0.11871328f, -0.00124289f, -0.38661718f, -0.10960136f, 0.30662048f, 
    -0.03228677f, -0.54653823f, -0.12050876f, -0.08635210f, -0.16105738f, 0.14122219f, -0.08297173f, -0.01990855f, 
    0.23003954f, 0.08266342f, 0.12536742f, -0.63617688f, -0.58105677f, -0.03321718f, 0.16387667f, -0.48095405f, 
    0.24598134f, -0.61395818f, -0.31738874f, -0.04053667f, 0.06769120f, 0.08876065f, 0.13768108f, -0.05096862f, 
    -0.16466108f, 0.01782597f, 0.13509373f, 0.18553397f, -0.71194357f, 0.35991400f, -0.09478268f, 0.33211401f, 
    0.03604402f, 0.40482065f, 0.06051453f, -0.04408924f, 0.10207795f, 0.44778413f, 0.09977099f, -0.14399260f, 
    -0.21640760f, 0.05845475f, -0.07939853f, -0.27826393f, -0.32705808f, -0.12825474f, 0.14812128f, -0.37326080f, 
    -0.10970820f, 0.24945907f, -0.20238110f, 0.48163396f, 0.14350466f, -0.14197598f, 0.05418116f, -0.02016455f, 
    0.10286091f, -0.05786228f, 0.01221144f, -0.07457258f, -0.33044982f, -0.11144871f, -0.13100795f, -0.04255098f, 
    -0.11201282f, -0.47661003f, 0.16779464f, 0.16496311f, -0.03841383f, -0.23362640f, -0.03253248f, 0.16263735f, 
    0.27010602f, -0.01152620f, -0.16926362f, -0.00362332f, -0.69088137f, -0.00318323f, -0.04764716f, 0.51498812f, 
    0.07112754f, -0.09245360f, -0.06814557f, -0.33853677f, 0.04166207f, -0.10769276f, -1.27893972f, -0.03300352f, 
    0.15393771f, -0.55760282f, 0.35655829f, 0.48555928f, 0.27301168f, 0.02059770f, 0.10464508f, 0.09592982f, 
    0.12448507f, 0.22060744f, -0.13396133f, -0.09198216f, 0.08248094f, -0.44935808f, -0.13157225f, -0.15675052f, 
    0.21450150f, 0.15557380f, 0.06269918f, 0.38341647f, -0.32441589f, -0.01432312f, -0.00501806f, 0.17521375f, 
    0.21055990f, 0.12781550f, -0.85455483f, -0.93908852f, -0.00770561f, 0.09848192f, 0.03350015f, -0.16022977f, 
    0.09073268f, 0.52988982f, 0.38933718f, 0.00094461f, 0.27312362f, 0.12457892f, 0.16891712f, -0.38983554f, 
    -0.08258101f, -0.29848048f, 0.06807823f, -0.11376283f, -0.03194283f, -0.00668081f, -0.16764550f, -0.15559940f, 
    -0.24433871f, -0.00126635f, 0.13024330f, -0.51838350f, -0.19646974f, 0.05082964f, -0.13655227f, 0.08594393f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06954139f, 0.06836478f, 0.03744757f, 0.21975917f, 0.07005513f, -0.05473832f, 0.04700121f, -0.24379158f, 
    0.19023889f, 0.02298423f, -0.00343218f, 0.18042001f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
