#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.02936469f, 0.15864176f, 0.43046251f, 0.20775481f, 0.28426659f, -1.08207071f, -1.25582111f, -0.75325507f, 
    -1.04988170f, -0.85974485f, -0.22268103f, 0.80816805f, 0.22044985f, 0.07150634f, -0.33051732f, -0.18940307f, 
    0.20306924f, 0.23660603f, 0.02488081f, 0.85612214f, 0.42070553f, 0.11657772f, -0.30382755f, 0.09033854f, 
    -0.16283454f, -1.88590360f, 1.84268773f, -0.16852812f, -0.78351867f, -0.38470170f, 0.69601595f, 0.04241237f, 
    -0.36182234f, 0.95483029f, -0.35945609f, -0.26254973f, -0.27675408f, -0.04668727f, 0.26545560f, 0.06726713f, 
    -0.12440465f, -0.17768298f, -0.01618618f, 0.00487888f, -0.19613698f, -0.10817935f, -0.15120111f, -0.02892328f, 
    0.34160379f, 0.33221763f, -0.05784094f, -0.47265670f, 0.39941621f, -0.76994526f, -0.10149967f, 0.72766471f, 
    -0.84154230f, 0.08101478f, -0.17510739f, -0.90397203f, -0.24609078f, -0.55592811f, 0.02886420f, 0.54245371f, 
    0.37089851f, 0.39343858f, 0.68450391f, 0.05432566f, -0.02979662f, -0.23829597f, 0.58180559f, 0.40939143f, 
    0.19954774f, -0.03932709f, 0.53487945f, -0.38899985f, -1.35706186f, 0.53849912f, 1.07419205f, -0.53765339f, 
    -0.02113286f, 1.02657151f, 0.13445619f, 0.02298415f, -0.31267926f, 0.30253828f, 0.37139407f, 0.40727633f, 
    -0.10740621f, -0.28988409f, -0.82352626f, -0.06749512f, 0.26932791f, 0.47151062f, -0.59954685f, -0.06773388f, 
    0.02645954f, 0.16187926f, 0.50940526f, -0.19542113f, -0.18212762f, -1.25751948f, 0.24637404f, 1.33873844f, 
    0.91759437f, -1.23285222f, -0.14444149f, 0.52569771f, -0.24193084f, 0.25354463f, 0.53514075f, -0.03438257f, 
    0.13989788f, 0.44523886f, 0.79661107f, 0.60084116f, 0.60977036f, 0.26093498f, -0.02381578f, 0.26238087f, 
    0.15782930f, 0.05155398f, -0.08744689f, -0.20728706f, 0.01202524f, -0.52764094f, 0.25875697f, -0.46211669f, 
    -0.79632217f, -0.30551738f, 0.42066392f, -0.56574100f, -1.26422369f, -0.74950290f, -1.01841211f, -0.61447209f, 
    0.06142851f, -0.52907008f, 0.16007987f, -0.68551582f, -0.15382576f, -0.23499306f, -0.52069998f, -0.60275203f, 
    0.02379588f, 0.00527030f, 0.36933014f, 0.18508142f, -0.05350501f, -0.18453026f, 1.18570518f, 1.21316147f, 
    1.25271165f, 1.20854926f, 0.32674462f, 0.12734582f, -0.20228472f, -0.43423644f, -0.83606887f, 0.29143900f, 
    0.29076210f, 0.49538019f, -0.26687884f, 0.37095314f, 0.05216731f, 0.00612716f, 0.06400990f, 0.40529931f, 
    0.32010567f, 0.16308346f, 0.06717769f, -0.01128119f, -0.17005515f, 0.16805644f, 0.39885917f, -0.98931545f, 
    0.68528783f, 1.38980329f, 0.60316849f, 0.54218245f, 0.50072247f, 0.51760882f, 0.67257851f, 0.37159374f, 
    -0.22348449f, -0.83864129f, -0.47211456f, 0.38389263f, 0.56959432f, -0.24467500f, -0.08763914f, 0.16228293f, 
    0.05221310f, -0.04246107f, 0.15381263f, -0.17394124f, -0.17199692f, -0.28026170f, 0.08530637f, -0.01587247f, 
    -0.40174553f, -1.09796810f, -0.93113559f, -0.48674908f, -0.37727141f, 0.89265758f, 1.23634732f, -0.28386721f, 
    0.53629792f, 1.02296603f, -0.40465841f, -0.32341442f, -0.11567185f, -0.12705196f, 0.02601087f, -0.56365961f, 
    0.13540201f, 0.36700872f, 0.10995122f, -0.18391281f, -0.00951599f, -0.33145511f, -0.14662603f, -0.04805474f, 
    0.37041748f, 1.62371874f, -0.66640377f, -0.89778429f, -1.17206597f, 0.06421603f, 0.72098416f, -1.05372381f, 
    0.70912570f, 0.70012254f, 0.18062027f, -0.30000085f, -0.00877813f, -0.27044627f, -0.16293074f, -0.28237915f, 
    0.14542243f, 0.09056588f, 0.11197698f, 0.10995038f, 0.07041311f, -0.16503413f, 0.00437273f, -0.16560948f, 
    -0.14758295f, -0.41762295f, 1.08620071f, 1.08585036f, 0.00970014f, 1.45969641f, 1.36976182f, 1.27617979f, 
    0.47963971f, -0.97610992f, 0.26531437f, 0.07720549f, -0.44584769f, 0.06777532f, -0.03033483f, 0.50736195f, 
    -0.30676633f, -0.26475444f, 0.31062758f, 0.34436756f, 0.13699052f, -0.25216758f, -0.02159613f, 0.19485715f, 
    -0.36511552f, -0.18280303f, 0.33707744f, 0.05561918f, -0.57071745f, -0.74801719f, -0.44150561f, 0.13961148f, 
    -1.04579425f, -0.76148629f, 0.21411727f, 0.48175922f, -0.79205531f, -1.12766945f, -0.28064236f, 0.41530734f, 
    -0.63203305f, -0.92536175f, -0.23045222f, -0.00824920f, 0.13427362f, -0.09374679f, -0.51731849f, 0.42524314f, 
    0.20681994f, -0.00359702f, 0.13731943f, -0.17251521f, -0.67675531f, -1.17030668f, -1.33975291f, -0.92443436f, 
    -0.61663568f, -0.81629509f, -0.12315001f, 0.58597791f, -0.54925144f, 0.36939842f, 0.69824743f, 0.38364479f, 
    0.17982098f, 0.48346540f, 0.49852565f, -0.12289968f, 0.09358532f, 0.18830258f, -0.00342568f, 0.32175401f, 
    -0.11056768f, -0.07031416f, -0.53179508f, -0.10323510f, -0.31882748f, 0.99576038f, 1.08155835f, 1.27810931f, 
    0.24960364f, 0.09650127f, -1.02383327f, -0.71201032f, -0.11728022f, -0.18902326f, 0.50388408f, 0.21948460f, 
    0.12646417f, -0.18590395f, 0.49849394f, 0.13153534f, 0.08177337f, -0.43393266f, -0.05621084f, -0.27887866f, 
    0.31059295f, 0.00532118f, 0.57635379f, 0.35022491f, 0.27022928f, 0.28947046f, -0.47114566f, 1.49844480f, 
    0.20807782f, -0.48604789f, 0.89855713f, -0.63416594f, 1.23051310f, 0.69932789f, -0.37637639f, 0.71949524f, 
    -0.76965749f, 0.35125053f, 0.18255471f, -0.46505982f, -0.00411924f, -0.06472898f, -0.28240949f, -0.29279366f, 
    0.12364145f, -0.28020766f, 0.00896166f, 0.03358560f, -0.21604297f, 0.13241301f, 0.45939842f, -0.79337752f, 
    0.17963248f, -1.66159332f, -0.77435541f, 0.68005300f, -0.60398579f, 0.87191862f, 0.92449033f, 0.38298321f, 
    0.41421282f, 0.21086347f, -0.58276260f, 0.31239754f, -0.33812281f, 0.37453783f, -0.12102325f, -0.18393756f, 
    -0.37200758f, -0.29833317f, -0.42006153f, 0.16874550f, 0.18710251f, -0.11839246f, 0.44041654f, -0.12445454f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.59903198f, 0.12033343f, 0.49462935f, 0.27023375f, 0.66920477f, 0.20279863f, 0.24669968f, 0.30704099f, 
    0.27935678f, -0.10529122f, 0.22767936f, 0.26316112f, 0.62386477f, 0.12794881f, 0.44423810f, 0.23936991f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04559017f, -0.05821589f, 0.24148841f, -0.16248961f, -0.02429214f, -0.02262654f, -0.13834201f, 0.05274761f, 
    0.07436929f, -0.19913885f, -0.28946579f, -0.07005323f, 0.73074830f, 0.27045697f, 0.02832026f, -0.23353210f, 
    -0.13800816f, -0.30740249f, 0.15968688f, -0.12949821f, -0.04040232f, -0.07727124f, -0.04038418f, 0.04157574f, 
    -0.06304739f, -0.01096903f, 0.10630421f, -0.28480032f, -0.03414543f, 0.06479907f, 0.21321419f, 0.08153144f, 
    0.09748996f, 0.18305947f, -0.08808816f, -0.02021657f, -0.29483786f, 0.17400189f, -0.40662533f, 0.23632222f, 
    0.00828994f, 0.00938639f, 0.08943161f, -0.23008847f, -0.07895273f, 0.08743611f, -0.14420293f, 0.00085040f, 
    0.13083072f, -0.10959316f, -0.58447790f, 0.48639503f, 0.13373564f, 0.03443046f, -0.02367142f, -0.11603665f, 
    -0.01787547f, -0.11443299f, -0.05530146f, 0.03155156f, -0.97030902f, -0.16949230f, 0.27060395f, -0.22688636f, 
    0.08780345f, 0.04566870f, 0.08069509f, -0.07304808f, -0.00959448f, 0.07903109f, -0.17052743f, -0.00695370f, 
    0.16235289f, 0.21938473f, -0.05968415f, 0.04121903f, -0.52159703f, -0.13362414f, 0.04756540f, 0.09439233f, 
    0.07324188f, 0.07559653f, -0.19162682f, -0.00541389f, -0.30567485f, 0.02665365f, -0.13147449f, 0.41677210f, 
    -0.10887201f, -0.03484362f, 0.17638159f, 0.11339241f, 0.07952681f, -0.25198296f, -0.01093283f, 0.04995227f, 
    0.29442355f, 0.03321993f, 0.09439335f, -0.44927904f, 0.15795343f, -0.07342337f, 0.06310891f, 0.03817753f, 
    0.09885876f, 0.10598048f, -0.04233914f, 0.11271195f, 0.72394270f, -0.30959475f, 0.38284791f, -0.62181842f, 
    0.03217827f, 0.26256201f, 0.16817601f, 0.01231236f, -0.26321667f, -0.00831827f, -0.11149061f, 0.11733724f, 
    0.13234690f, -0.21922393f, 0.22787975f, 0.53087729f, -0.27797660f, -0.11862618f, 0.09650580f, 0.05806480f, 
    -0.11135148f, 0.14346012f, 0.01646641f, -0.05389787f, -0.38987547f, 0.37655282f, -0.06311402f, 0.15021172f, 
    0.20828657f, 0.08175886f, -0.03693268f, -0.08878939f, -0.01196573f, -0.02477083f, -0.04997944f, -0.09692234f, 
    -0.63346547f, -0.39659700f, -0.32409433f, -0.02508887f, -0.04615214f, -0.05134679f, -0.01094338f, 0.08820892f, 
    -0.01428503f, -0.14043035f, -0.12862925f, 0.17211039f, 0.22221532f, -0.00537245f, -0.21082401f, -0.02723550f, 
    -0.04052350f, 0.05302399f, -0.19251004f, 0.13141571f, -0.10523801f, -0.02607754f, -0.02510690f, 0.12983897f, 
    0.00326285f, 0.07700400f, 0.10188702f, -0.42944717f, -0.13172719f, 0.03879244f, -0.10041263f, -0.25932288f, 
    0.11451372f, -0.02888778f, -0.19617350f, -0.09897569f, -0.24464573f, 0.49682337f, 0.02753973f, -0.39482814f, 
    0.13861459f, -0.05492838f, -0.24436752f, -0.07147060f, -0.03353805f, 0.24173853f, -0.03464419f, -0.06652921f, 
    -0.42812216f, -0.32681137f, -0.30553669f, -0.34569094f, 0.07279531f, -0.02692035f, -0.10146911f, 0.05218995f, 
    -0.12959267f, 0.13320461f, 0.18902726f, -0.08445191f, -1.07724929f, -0.10785375f, 0.02981356f, -0.37553385f, 
    -0.01213264f, 0.10786279f, -0.00344144f, -0.05171977f, 0.00206957f, 0.08745713f, -0.02504974f, -0.16958448f, 
    -0.43499181f, 0.29294467f, 0.07535997f, 0.10827862f, -0.13321669f, -0.02840636f, 0.15516999f, -0.01624143f, 
    0.20252870f, 0.14407103f, -0.03548837f, 0.21857892f, -0.33207342f, -0.28094172f, -0.35933074f, 0.40043971f, 
    -0.11686804f, -0.02911374f, -0.08440418f, 0.09646510f, 0.08676246f, -0.39923751f, -0.03196609f, 0.00689276f, 
    -0.28602475f, -0.00806115f, -0.06881216f, 0.16149889f, -0.11278591f, 0.03026695f, -0.21216856f, 0.21677300f, 
    -0.06165924f, -0.00842607f, 0.10807235f, 0.10938578f, 0.25052193f, -0.12183253f, -0.13384998f, -0.29306692f, 
    0.02344996f, -0.14095770f, 0.14424777f, 0.14962330f, -0.18644136f, 0.05166071f, -0.21207279f, -0.24865380f, 
    0.21690048f, 0.07036072f, 0.18283084f, 0.37149471f, -0.20579849f, -0.09745294f, 0.04592685f, 0.01276184f, 
    0.03387907f, 0.05048811f, 0.02237673f, 0.00569701f, 0.08684111f, 0.21199697f, -0.18834686f, 0.17488857f, 
    -0.06561005f, 0.01462817f, -0.01277895f, -0.21287413f, -0.10779834f, 0.10156124f, 0.06885322f, -0.09755761f, 
    0.22090989f, -0.34761786f, -0.13891773f, -0.20999354f, 0.11250016f, -0.10518433f, -0.31715032f, 0.22843392f, 
    0.07477614f, 0.11586514f, -0.05819875f, 0.01457372f, 0.26800209f, -0.60033053f, 0.18001148f, -0.31475887f, 
    0.16653307f, 0.09060301f, -0.07477136f, -0.09457453f, 0.07061068f, 0.07419631f, 0.12923740f, -0.16599658f, 
    0.49485239f, -0.16502866f, 0.04451587f, 0.08031860f, -0.15016161f, 0.06057515f, -0.07203874f, 0.02548750f, 
    0.03194075f, -0.04723122f, 0.10723010f, -0.14007449f, -0.23600595f, -0.37944540f, -0.04202319f, -0.51493227f, 
    0.08393519f, -0.08703879f, 0.08982416f, 0.17794335f, 0.02564296f, -0.36030200f, -0.21312085f, 0.11139754f, 
    0.44293344f, -0.12555243f, 0.07241032f, 0.07432392f, 0.07391082f, 0.03393714f, 0.23484531f, 0.35035217f, 
    -0.06857771f, -0.08847230f, 0.11613493f, 0.04571507f, -0.11617969f, -0.17157941f, 0.27055031f, 0.08336861f, 
    -0.02006857f, -0.08055509f, 0.19165646f, 0.03001184f, -0.02257448f, -0.01518791f, -0.03031553f, -0.06854346f, 
    0.10733085f, 0.48900184f, 0.03885524f, -0.20065509f, 0.16952963f, 0.09186003f, -0.01638412f, 0.03563234f, 
    0.13096276f, 0.01945565f, 0.13353130f, -0.07640112f, 0.65702212f, -0.08799659f, -0.01719825f, -0.28294215f, 
    0.11539038f, 0.08286034f, -0.27286068f, 0.13391961f, 0.09632744f, -0.17719015f, -0.16127855f, 0.03058815f, 
    -0.10652532f, 0.23679900f, -0.49097818f, 0.05382479f, -0.00244183f, -0.02647354f, -0.05544167f, -0.16874245f, 
    -0.06383237f, -0.12745386f, -0.09052043f, -0.12735896f, 0.25599170f, 0.37954277f, -0.61219680f, -0.21686751f, 
    0.07629259f, 0.13977171f, 0.14633812f, -0.17699474f, -0.31486416f, 0.08436075f, -0.02891353f, 0.12997700f, 
    -0.63295388f, -0.11505315f, -0.36893207f, -0.16335042f, 0.02744864f, -0.21590151f, -0.19578904f, -0.07923662f, 
    -0.00931340f, -0.32598644f, -0.11314306f, 0.06896140f, 0.33063290f, -0.36821705f, 0.06681721f, 0.03241354f, 
    -0.21370377f, 0.04101827f, -0.03693474f, -0.08771127f, -0.03586901f, 0.23538548f, -0.08296682f, -0.09270526f, 
    0.82253158f, -0.33049911f, -0.41343778f, 0.11088295f, -0.00642127f, 0.10083752f, 0.00399419f, -0.18503396f, 
    -0.09989222f, -0.20782535f, -0.10334332f, -0.12494390f, -0.44282803f, -0.01590590f, -0.43145227f, -0.60959262f, 
    0.21714227f, 0.02924188f, -0.06666696f, -0.06984470f, 0.03215745f, 0.17683607f, -0.02299890f, -0.08562332f, 
    0.04306503f, 0.19742577f, -0.10442843f, -0.00521525f, 0.03338649f, 0.19741932f, 0.07808104f, -0.02438107f, 
    0.00205854f, 0.04650735f, -0.07416885f, -0.09725311f, 0.14789014f, -0.05857849f, -0.14538053f, 0.10888939f, 
    -0.28150374f, 0.11896744f, 0.09128904f, -0.07680523f, 0.16907857f, 0.16733888f, 0.06463999f, 0.04804919f, 
    0.53143084f, 0.04419797f, 0.37129235f, 0.41207016f, -0.23309605f, -0.17565624f, 0.05171406f, 0.03890433f, 
    0.02048515f, -0.10144050f, -0.08862159f, -0.00846838f, -0.65245277f, 0.31936198f, -0.10496223f, 0.29315281f, 
    0.15685795f, 0.00987274f, 0.17839685f, 0.17546064f, -0.08247109f, -0.03176335f, -0.10736071f, -0.11429580f, 
    0.26355824f, -0.75045359f, 0.13787745f, -0.16137771f, 0.14292377f, -0.05688491f, 0.04492283f, -0.14517982f, 
    0.03604918f, 0.10517038f, -0.10181318f, 0.05726071f, -0.21724977f, 0.15508336f, -0.49343407f, 0.01495188f, 
    0.00101492f, 0.10238502f, -0.02950633f, -0.12968761f, 0.05917519f, 0.04094736f, -0.01728027f, 0.03547018f, 
    0.43741456f, -0.03824766f, 0.22123656f, 0.15645747f, -0.37485775f, -0.08339874f, 0.12781443f, 0.14112148f, 
    -0.09222323f, -0.09741009f, 0.00527796f, -0.13486743f, -0.33792880f, 0.37271985f, -0.24236871f, -0.25011134f, 
    -0.10578149f, 0.18382438f, -0.01269815f, -0.01942758f, -0.09705231f, -0.00486272f, 0.06358158f, -0.04027236f, 
    0.52470940f, -0.12137497f, -0.07587937f, -0.10693072f, 0.06291775f, -0.03088212f, 0.03471685f, -0.17146139f, 
    0.05081015f, -0.05054213f, 0.03641510f, -0.03666472f, 0.23732728f, 0.05552640f, -0.11624530f, 0.31470418f, 
    -0.16338135f, 0.04995666f, -0.16892380f, -0.11296064f, 0.07154731f, -0.05922968f, 0.03027047f, 0.02949367f, 
    0.19694792f, 0.33339518f, 0.24679963f, 0.28897068f, 0.10801185f, 0.10402507f, -0.07848766f, 0.07073129f, 
    0.15947199f, -0.04781950f, -0.10238756f, -0.09477507f, 0.68842310f, 0.64822060f, 0.16815995f, -0.22758950f, 
    -0.06374934f, 0.06848673f, 0.08212611f, 0.17994344f, -0.05350417f, -0.14388050f, 0.00696503f, 0.06103295f, 
    0.21917111f, 0.01188578f, 0.15979594f, 0.14659810f, -0.14676408f, 0.04115847f, -0.02100813f, -0.03134324f, 
    -0.24967524f, 0.16355707f, -0.02802991f, -0.08457819f, -0.01584591f, 0.28669885f, 0.13656712f, -0.08747396f, 
    -0.18192402f, 0.11639811f, 0.15529692f, 0.04914051f, 0.01068476f, 0.08813440f, -0.14654666f, -0.04874253f, 
    -0.44463614f, 0.05597253f, 0.14169185f, 0.05853659f, 0.02373493f, 0.11306389f, 0.14160597f, -0.19081791f, 
    -0.07422296f, -0.14621034f, -0.12765972f, -0.17687665f, 0.58837092f, 0.17624630f, 0.11596589f, 0.20103790f, 
    -0.05066219f, -0.31367198f, -0.09903546f, 0.15369269f, -0.05301537f, 0.11708430f, 0.01215738f, -0.19368927f, 
    -0.58784020f, -1.03989434f, -0.35731539f, 0.38019773f, 0.00045875f, -0.02901105f, 0.01761036f, -0.10769062f, 
    -0.10029124f, -0.21854270f, 0.04704184f, -0.00942996f, -0.34335831f, -0.15642928f, 0.08091332f, -0.26605511f, 
    -0.01263130f, -0.22559047f, 0.13107610f, 0.08039511f, 0.13502224f, 0.01235854f, -0.17066428f, 0.08571649f, 
    0.05929859f, -0.00276614f, -0.18183270f, -0.21439499f, -0.47297576f, -0.21018693f, 0.04538966f, -0.12242190f, 
    -0.12973562f, -0.17496039f, 0.02210348f, 0.01186285f, -0.32461917f, 0.06654923f, 0.09995157f, 0.22228621f, 
    -0.28752157f, 0.14714900f, 0.09058867f, -0.03031654f, -0.02869845f, 0.11737376f, -0.05311126f, 0.10029233f, 
    0.41859636f, -0.46994427f, -0.29580954f, 0.19323601f, -0.15806450f, 0.09765671f, 0.02708288f, 0.04471745f, 
    -0.08328015f, -0.20442040f, -0.05412021f, 0.11970168f, 0.37866911f, 0.06519020f, 0.10069931f, 0.16947520f, 
    -0.01672262f, -0.30091444f, -0.06440365f, 0.04063692f, 0.02119717f, 0.23103027f, -0.09529137f, 0.10986044f, 
    0.29938659f, -0.31965715f, -0.06810006f, -0.24011107f, -0.27641198f, -0.23620744f, -0.09917567f, 0.01626913f, 
    0.05204288f, -0.04049630f, -0.06467553f, 0.19860433f, -0.46859765f, -0.57580388f, -0.49604711f, 0.24721722f, 
    -0.00762948f, 0.11005483f, 0.06832255f, -0.00128844f, -0.15913604f, -0.10066251f, 0.00144434f, -0.18980005f, 
    -1.01819384f, 0.11328554f, 0.03141132f, -0.26245743f, 0.05329978f, 0.01143963f, 0.01289775f, 0.19871910f, 
    0.04356902f, 0.09587033f, -0.04885862f, 0.15420885f, -0.12343080f, 0.21926850f, -0.16597249f, 0.21050335f, 
    -0.05344063f, -0.29464015f, 0.18330301f, -0.18799114f, -0.14276309f, 0.13828076f, -0.01825323f, 0.00284854f, 
    -0.31310964f, -0.33669996f, 0.21758166f, 0.15554455f, -0.04961518f, 0.04566076f, 0.01602312f, -0.16167025f, 
    0.00035492f, -0.11323073f, 0.08568721f, 0.00615289f, 0.74611002f, 0.14799684f, -0.01464581f, -0.33188856f, 
    0.13694842f, -0.07894708f, 0.19516580f, 0.05495639f, 0.10871836f, -0.09573567f, -0.05885798f, 0.07555704f, 
    0.17335850f, 0.11946242f, 0.13629693f, -0.20203072f, 0.06810482f, -0.01115577f, 0.00858863f, 0.09956526f, 
    -0.21404764f, -0.07838111f, 0.00163583f, -0.12548937f, -0.66329783f, 0.06912517f, 0.01068955f, -0.45538595f, 
    0.23329212f, -0.05490829f, -0.18371993f, 0.10866296f, -0.19441457f, 0.09354393f, 0.03507627f, 0.00350411f, 
    -0.46143481f, -0.05866688f, 0.01540093f, -0.02106464f, 0.16035168f, -0.06113597f, 0.04264504f, 0.07146886f, 
    0.29924577f, 0.13427237f, -0.30754003f, -0.16694106f, -0.02483081f, -0.11933693f, 0.14287336f, -0.26964319f, 
    -0.11546461f, -0.04092422f, 0.06735620f, 0.36998621f, 0.10369685f, -0.01206539f, 0.11885060f, -0.06390725f, 
    -0.37503061f, -0.01335303f, 0.32240498f, -0.02786643f, -0.02260188f, 0.07427540f, -0.11725617f, 0.09283578f, 
    0.22279510f, -0.13885829f, -0.05071261f, -0.01325264f, 0.11090180f, 0.51895571f, -0.34328720f, -0.22041553f, 
    0.10502637f, 0.00543500f, 0.05578574f, 0.21421854f, -0.18865496f, -0.11842760f, -0.01039242f, 0.02071495f, 
    -1.03308308f, 0.01280291f, 0.11762313f, 0.52030402f, 0.12335175f, -0.10652123f, 0.13831156f, 0.10414646f, 
    -0.10655319f, 0.06583535f, 0.17773524f, -0.02072207f, -0.47833607f, -0.16754392f, -0.22620551f, 0.17028615f, 
    0.01038061f, 0.03290722f, 0.02670063f, -0.13584623f, -0.01781292f, 0.03643411f, 0.02675863f, -0.03608406f, 
    0.15657668f, 0.20487761f, -0.28270841f, -0.03759250f, 0.01859035f, 0.10807054f, 0.06004686f, 0.11172920f, 
    -0.06063545f, -0.04244044f, 0.06435716f, 0.02783101f, 0.19059949f, -0.17194687f, -0.23375136f, 0.05766229f, 
    -0.12491889f, -0.08573052f, -0.01273010f, 0.14883088f, -0.19638318f, 0.09760665f, 0.02277094f, -0.06780258f, 
    0.05294600f, 0.14503045f, 0.07038028f, 0.20903204f, 0.13119005f, 0.09645510f, 0.05934169f, 0.20089780f, 
    -0.07022443f, 0.15529230f, -0.03135491f, -0.13682659f, -0.51524180f, -0.33693200f, 0.25068280f, 0.22406000f, 
    -0.29566893f, -0.25506842f, -0.08848184f, -0.19772382f, 0.03763886f, 0.13388874f, -0.00170811f, -0.17077892f, 
    -0.21577950f, 0.17261641f, 0.12857898f, 0.08811677f, -0.13535370f, -0.25448930f, 0.07851707f, -0.14886928f, 
    -0.11909264f, -0.22627677f, -0.18404286f, -0.03202762f, 0.06238750f, -0.10253998f, -0.34096077f, 0.05472562f, 
    0.01666321f, 0.20537709f, 0.15088832f, -0.00972997f, -0.08905492f, -0.07819854f, 0.08831360f, 0.10334748f, 
    0.22080185f, -0.18923175f, -0.05261417f, 0.23161739f, -0.11764612f, -0.14814124f, 0.08521000f, 0.02167033f, 
    -0.25618744f, 0.07214213f, 0.15852720f, 0.45221680f, -0.42708775f, -0.68319517f, 0.38575020f, 0.50574702f, 
    -0.12960486f, 0.01191824f, 0.03319892f, -0.26982078f, -0.00497153f, -0.09305928f, 0.11002070f, -0.08160748f, 
    -0.15690616f, -0.26105595f, 0.07698653f, 0.28839651f, 0.25744379f, -0.06443377f, 0.11444615f, 0.11167746f, 
    0.37971288f, 0.19299105f, 0.16871579f, 0.13693494f, -0.43241721f, 0.30720565f, -0.00265951f, 0.00852949f, 
    -0.00475267f, -0.01448996f, -0.06307270f, 0.13509163f, -0.14575163f, -0.21490285f, 0.23491763f, -0.12574691f, 
    -0.17381907f, -0.06483667f, -0.10084666f, -0.51404124f, 0.17636839f, -0.02697440f, -0.01106427f, -0.02287610f, 
    0.10102031f, 0.03308640f, 0.16088220f, 0.13726458f, -0.06204966f, 0.23932610f, 0.07965251f, 0.29351324f, 
    0.00995784f, 0.24457504f, 0.01254835f, -0.10619374f, -0.05342107f, 0.03130949f, -0.09747716f, -0.12326283f, 
    0.22868554f, 0.12002615f, 0.06877650f, 0.06359994f, -0.03565898f, 0.27135819f, 0.18394616f, -0.03111595f, 
    -0.14637844f, 0.05205537f, 0.18394326f, 0.15500867f, -0.29145727f, 0.00507772f, 0.43900716f, 0.25215617f, 
    0.09990645f, 0.00765855f, -0.09964251f, -0.18521193f, -0.01722675f, -0.09819746f, -0.01026819f, -0.22508599f, 
    -0.39707834f, 0.06564567f, -0.55384284f, -0.34166521f, 0.11771888f, 0.22246936f, 0.02957993f, -0.04201465f, 
    -0.01408374f, -0.36855805f, 0.09866809f, -0.27110562f, 0.15762636f, -0.12972516f, -0.07811292f, -0.19225593f, 
    -0.03402079f, -0.20992853f, -0.31081483f, -0.37800127f, -0.01101164f, -0.17684069f, -0.02024656f, -0.00973782f, 
    -0.07993321f, -0.00862882f, 0.32217383f, -0.18098129f, -0.05903808f, 0.11998135f, 0.19863385f, -0.10610367f, 
    0.02475869f, -0.05843536f, 0.06777593f, 0.02433124f, 0.12182993f, -0.45391449f, 0.19925269f, 0.04997755f, 
    0.26978725f, 0.25485188f, 0.01900157f, 0.12881373f, 0.15750882f, -0.22656128f, 0.03777117f, -0.34817249f, 
    -0.90408057f, -0.28767446f, -0.31339487f, 0.11375840f, 0.34566358f, -0.16425809f, -0.36808184f, -0.01298318f, 
    -0.00584628f, 0.18736884f, 0.04997133f, 0.19947475f, 0.14580405f, 0.26446319f, 0.09861718f, 0.17747881f, 
    -0.27234489f, -0.04826518f, 0.05056072f, 0.05845812f, -0.05390065f, 0.01677028f, 0.02554596f, -0.08164446f, 
    0.05059573f, -0.27597147f, 0.17493740f, 0.14020573f, -0.05262111f, 0.16770022f, 0.01594325f, -0.02674066f, 
    -0.04021684f, -0.06738585f, 0.15347512f, 0.04472263f, -0.63915795f, -0.01643594f, -0.13150957f, -0.37241882f, 
    -0.02376912f, -0.10062603f, 0.15613970f, -0.03456977f, 0.17458649f, -0.18496123f, -0.17056812f, -0.16747738f, 
    0.21076982f, 0.04378597f, -0.19062045f, -0.28194416f, 0.19387949f, 0.34799185f, 0.07363552f, -0.00400890f, 
    -0.03308586f, -0.44816127f, 0.09381010f, -0.10447386f, 0.22214741f, -0.24123192f, 0.06693590f, 0.30210707f, 
    0.05117762f, 0.05495102f, -0.07456461f, -0.02067314f, -0.12547359f, 0.06716961f, -0.17132644f, 0.08781376f, 
    0.07929540f, 0.05371622f, -0.14398037f, 0.03149227f, -0.09744246f, -0.08791908f, -0.25935826f, -0.18889053f, 
    -0.20857804f, 0.03721930f, -0.00126393f, -0.52343512f, 0.79969656f, -0.51873255f, 0.44621402f, -0.14609730f, 
    0.02382101f, 0.07267242f, 0.17579697f, -0.03335440f, 0.24287286f, 0.27744329f, -0.15856034f, 0.25251645f, 
    0.44655630f, 0.13894771f, 0.42188880f, -0.17600289f, -0.17270553f, 0.10625039f, 0.33621171f, 0.05127357f, 
    0.00788792f, 0.07812396f, 0.00519865f, -0.15456748f, 0.28514561f, -0.29044178f, -0.54908293f, -0.04022181f, 
    0.03945693f, 0.00781725f, -0.13892733f, -0.00599876f, 0.13909304f, 0.00340023f, 0.11891194f, 0.27615565f, 
    0.20510888f, 0.31935841f, 0.28552008f, -0.50787175f, -0.04637158f, -0.21928416f, 0.01100513f, 0.07939793f, 
    0.01771701f, 0.13497782f, -0.16527654f, -0.14122635f, 0.45075068f, -0.28413031f, 0.21143027f, -0.21431313f, 
    -0.21820952f, 0.04945973f, 0.15866861f, 0.17259599f, 0.07179300f, 0.17171130f, -0.18743540f, -0.08136448f, 
    -0.10643110f, -0.24267997f, -0.40226784f, -0.41905850f, -0.13346468f, -0.00037423f, -0.19565740f, -0.15862367f, 
    -0.14762881f, 0.29439691f, 0.18596224f, 0.23089767f, -0.34278679f, -0.24698398f, -0.28054389f, 0.11600986f, 
    0.04664411f, -0.01423135f, 0.30059925f, 0.22561067f, 0.09961046f, -0.17619991f, -0.01397759f, 0.18045959f, 
    -0.29013067f, 0.14651512f, 0.17331469f, -0.32963899f, -0.26957205f, -0.02123670f, 0.10484822f, 0.06822128f, 
    0.02242596f, -0.11304156f, -0.18022627f, -0.16098359f, -0.25020671f, 0.07735657f, -0.15459280f, -0.26738381f, 
    -0.22721735f, -0.14125219f, 0.05811604f, -0.13991597f, -0.03238117f, 0.28054962f, -0.02421442f, 0.14857946f, 
    -0.69924742f, 0.21287143f, -0.42950442f, -0.07768286f, -0.09180309f, 0.11206914f, 0.23816605f, 0.09148584f, 
    0.13545324f, -0.13268779f, 0.05856622f, -0.23830549f, -0.38179982f, 0.35383570f, 0.07614409f, 0.11742153f, 
    -0.04444221f, -0.00279303f, -0.03212551f, 0.21793422f, -0.17531717f, -0.13906147f, -0.11541092f, 0.05474670f, 
    -0.66460586f, 0.01086389f, 0.06979273f, 0.23818503f, -0.06008942f, -0.13191655f, 0.18827137f, -0.05205917f, 
    -0.05105440f, -0.14683494f, -0.12927325f, 0.18635949f, -0.65123594f, -0.25715482f, 0.28920251f, 0.09484124f, 
    0.12738602f, -0.04319212f, 0.07878304f, -0.00986422f, -0.04828661f, -0.16209656f, 0.23506679f, 0.11458580f, 
    0.13748643f, -0.12806047f, 0.04933173f, 0.31747580f, -0.09599166f, -0.18885264f, -0.26207024f, -0.13121384f, 
    -0.12658179f, -0.04706993f, -0.04914174f, -0.17701361f, -0.27238527f, 0.38460010f, 0.04189001f, 0.28584710f, 
    0.30658194f, -0.14234647f, 0.06900501f, 0.00799760f, -0.10192985f, 0.04093173f, -0.08587874f, -0.16032395f, 
    -0.09094981f, 0.29889882f, -0.00569395f, 0.32037127f, 0.04358494f, -0.13724653f, -0.17857553f, -0.01839705f, 
    -0.06042404f, -0.13535383f, -0.07126290f, 0.04234037f, 0.44298276f, 0.02890751f, 0.31353363f, -0.21883635f, 
    0.01852057f, -0.06727636f, 0.04264825f, -0.10262325f, -0.15393801f, 0.18068217f, -0.31224954f, -0.16013011f, 
    0.43791622f, -0.16202980f, -0.04275036f, -0.48718983f, -0.25013945f, 0.05744302f, -0.00016484f, -0.15464339f, 
    -0.17365800f, 0.05029823f, 0.02761465f, 0.04117105f, 0.13095517f, 0.29943258f, -0.03417259f, 0.61008525f, 
    0.13575864f, -0.02181561f, -0.10844999f, -0.18824781f, -0.13851582f, -0.16028865f, -0.01483611f, -0.04917064f, 
    -0.41700241f, -0.14807369f, -0.25995010f, -0.20627093f, 0.02134070f, -0.05912019f, 0.11660251f, -0.08382348f, 
    -0.14445466f, -0.09783673f, -0.06873949f, -0.04707940f, -0.10911454f, -0.43079981f, 0.15745904f, -0.20909427f, 
    -0.06014698f, 0.06312297f, -0.13170174f, -0.21171810f, 0.07696489f, -0.03088883f, 0.02859952f, 0.03188252f, 
    -0.39134973f, 0.47753280f, 0.29352191f, 0.19467737f, 0.16031139f, 0.14827360f, 0.21539742f, 0.03860050f, 
    -0.10463730f, 0.02480005f, 0.10432816f, -0.23628721f, 0.26375553f, 0.37773761f, -0.28584996f, 0.07231899f, 
    -0.10028074f, 0.04108822f, -0.05484405f, 0.03122958f, -0.19612487f, 0.08144867f, -0.06454605f, -0.18340096f, 
    -0.74904823f, 0.68446290f, 0.03867232f, -0.15109055f, -0.10619710f, -0.03580023f, -0.10788454f, -0.13524738f, 
    -0.15634678f, 0.05430795f, 0.03628711f, -0.04017620f, 0.40276393f, 0.16018322f, 0.25598523f, 0.29760319f, 
    0.03648981f, -0.05786740f, -0.12805186f, -0.21002898f, -0.16539508f, 0.06140095f, 0.06224429f, -0.15256438f, 
    0.15607917f, 0.15693834f, 0.20238230f, 0.11350948f, -0.11949975f, -0.25318149f, -0.12932867f, -0.26965177f, 
    0.10881754f, 0.10932522f, -0.16089861f, -0.11990786f, 0.10632555f, -0.35898259f, -0.52321714f, -0.34196556f, 
    0.06138740f, 0.02621672f, -0.14415006f, -0.13256042f, -0.31269628f, 0.12584226f, 0.20443080f, 0.00672576f, 
    0.35312784f, -0.48328352f, 0.02236001f, 0.02554190f, -0.10332389f, -0.13241567f, -0.16708589f, -0.14003953f, 
    0.04916223f, -0.17024997f, -0.15837972f, -0.09255847f, -0.18900162f, -0.12804376f, 0.20180231f, 0.19969201f, 
    0.07116999f, -0.05311419f, -0.01964547f, 0.06902418f, -0.09449617f, -0.05183203f, -0.04636387f, -0.02212446f, 
    -0.19840230f, -0.20832238f, -0.45386729f, -0.62774515f, -0.21350880f, -0.30929551f, 0.10292383f, 0.02760908f, 
    0.31415859f, 0.12892887f, 0.03152338f, 0.00235070f, -0.12775795f, 0.03182872f, -0.33166596f, -0.30270690f, 
    0.04714061f, -0.00684330f, -0.53582013f, -0.05845405f, 0.25247976f, -0.08290877f, 0.10914112f, -0.01615817f, 
    -0.18946834f, -0.08169501f, 0.00128235f, -0.52889812f, -0.14206623f, 0.06888027f, -0.23661444f, -0.02038623f, 
    0.07818920f, 0.31737217f, 0.00329329f, 0.18542968f, 0.15642519f, -0.46993062f, 0.24571562f, -0.16491115f, 
    -0.18381117f, 0.05533958f, 0.01783700f, 0.03889337f, -0.12545623f, -0.22932516f, 0.05958586f, 0.15469259f, 
    -0.08981115f, -0.28762129f, 0.13352738f, -0.04777185f, 0.03335536f, -0.07429121f, 0.05424951f, 0.06778119f, 
    0.00445420f, 0.12683487f, 0.06390716f, 0.15693493f, -0.10797139f, -0.05899948f, -0.22651172f, -0.40201318f, 
    -0.00765335f, -0.02363057f, -0.14810938f, 0.01006955f, 0.20412709f, 0.02816548f, -0.26168889f, -0.22099243f, 
    0.01882484f, -0.29957849f, -0.21165115f, 0.38361442f, 0.17734064f, 0.03969323f, -0.11055349f, -0.05505582f, 
    -0.12504399f, 0.02574921f, 0.21050607f, 0.17616287f, 0.33040738f, -0.40423569f, 0.14347172f, 0.12872972f, 
    -0.02191137f, -0.19765916f, -0.21793421f, -0.07538591f, -0.08761109f, -0.02327414f, 0.11050553f, -0.07025465f, 
    -0.01647936f, 0.21356308f, 0.36671242f, 0.15203042f, -0.27538264f, 0.15469833f, -0.28288421f, -0.05268562f, 
    0.01951962f, -0.05382498f, -0.23042569f, -0.22443520f, -0.34999529f, 0.61486369f, 0.04572422f, 0.10542986f, 
    -0.26211637f, 0.08931702f, -0.14544049f, -0.09179425f, 0.10907345f, 0.06597520f, 0.18831600f, 0.17565179f, 
    0.31238025f, -0.08185072f, 0.00435722f, 0.38716012f, 0.17810950f, -0.02072007f, -0.19673979f, -0.19555527f, 
    0.35776964f, -0.07103162f, 0.28656495f, 0.03160551f, -0.55890834f, -0.31099999f, 0.17975555f, -0.43812367f, 
    -0.16933958f, -0.04382258f, -0.18852776f, 0.34185562f, 0.08611841f, -0.32239568f, 0.20523198f, -0.09486814f, 
    -0.29071385f, 0.21172062f, 0.21117558f, -0.25285834f, 0.16648172f, 0.10365083f, -0.21992980f, -0.04617006f, 
    0.08229768f, -0.00140897f, 0.12853205f, 0.21708590f, -0.03553990f, -0.56368226f, -0.30311477f, 0.02511251f, 
    0.22632858f, 0.01886106f, 0.03874418f, -0.02467493f, 0.20547660f, 0.10687248f, 0.04543346f, 0.05335774f, 
    0.46951064f, 0.30082169f, -0.28708488f, 0.21133691f, -0.14324836f, -0.01977914f, -0.16890302f, -0.25841677f, 
    -0.24206227f, -0.10918757f, -0.04229009f, 0.00271795f, -0.05182857f, 0.27039549f, 0.17711657f, 0.17144275f, 
    -0.10395690f, -0.00114282f, -0.04164018f, -0.10546261f, 0.09114402f, -0.04658390f, -0.32069284f, -0.25807020f, 
    -0.11136332f, 0.09044373f, -0.05233069f, -0.38255137f, 0.03957660f, 0.04827723f, 0.03534567f, 0.09397155f, 
    0.01756414f, 0.24868658f, -0.19878817f, -0.07140982f, -0.42749009f, -0.89938694f, 0.21377406f, -0.12932707f, 
    -0.21439125f, 0.11358133f, 0.00888470f, 0.11242877f, 0.05268446f, -0.27694878f, 0.15676372f, -0.00262373f, 
    0.33764201f, -0.11363586f, -0.28099179f, -0.16656537f, 0.23266554f, 0.17956540f, -0.10445572f, -0.10521391f, 
    -0.39969489f, -0.42408815f, -0.20487235f, 0.02965677f, 0.12635002f, -0.10165966f, 0.12394912f, -0.02697277f, 
    0.07894003f, 0.06968515f, -0.16527387f, -0.15158880f, -0.03878823f, 0.04765834f, -0.02273474f, -0.03214619f, 
    0.13316031f, -0.04430469f, -0.13094416f, -0.05241059f, -0.14021225f, -0.07547773f, -0.01320155f, -0.06285553f, 
    0.06385742f, -0.07012913f, 0.16768749f, 0.02425174f, -0.31179556f, -0.13191187f, 0.01712329f, 0.07305752f, 
    0.05274116f, 0.12181594f, -0.15798679f, -0.20524518f, 0.12680514f, -0.16212076f, 0.20310943f, 0.12549707f, 
    -0.29373229f, 0.22119157f, -0.08173162f, -0.45677200f, 0.19115737f, 0.00445564f, -0.27789590f, 0.00822620f, 
    -0.07448675f, -0.06081511f, 0.10746100f, -0.25788984f, 0.41423029f, -0.10362994f, -0.17508887f, -0.18785359f, 
    0.16649042f, 0.25093058f, 0.05657573f, 0.11251320f, 0.03012575f, 0.04536225f, 0.08333036f, 0.33353531f, 
    -0.46103930f, -0.37325615f, 0.17594586f, -0.03813506f, 0.31006762f, -0.01319336f, -0.02941005f, 0.02843588f, 
    0.20865394f, -0.00125165f, -0.01699368f, 0.11553922f, 0.53345454f, 0.58250010f, 0.23234950f, 0.27512199f, 
    -0.13775542f, 0.00977768f, 0.00483982f, 0.53319633f, 0.15496878f, 0.14933577f, 0.08761008f, 0.07223166f, 
    -0.60547870f, 0.70583248f, -0.28744084f, -0.29286680f, 0.28611612f, -0.03301642f, -0.01800244f, 0.06941891f, 
    -0.06524748f, 0.04702534f, -0.32353333f, 0.02696781f, 0.03711957f, -0.01252875f, -0.00083179f, 0.12672417f, 
    -0.14517674f, -0.05394105f, -0.17806441f, -0.05886389f, -0.06540185f, 0.15523016f, -0.02330782f, 0.13378459f, 
    -0.43434569f, -0.62886727f, 0.14176035f, 0.00970347f, -0.10785425f, 0.05209726f, -0.03817531f, -0.26834509f, 
    0.12060490f, -0.07719135f, -0.10178784f, -0.28959602f, 0.06064271f, -0.21284197f, 0.42070660f, -0.60562867f, 
    0.15545015f, 0.15024389f, 0.00331770f, -0.19999261f, -0.16630352f, -0.21206154f, 0.00668534f, -0.00035823f, 
    0.75260788f, -0.81922203f, 0.08703769f, -0.10114594f, 0.07873331f, -0.07003272f, 0.05717155f, 0.01961689f, 
    -0.04179719f, 0.09431376f, 0.10847379f, 0.11388770f, 0.57380587f, -0.69950688f, 0.24252918f, 0.12356867f, 
    0.01713077f, -0.07654839f, -0.11630754f, 0.26885551f, -0.21870841f, 0.16882400f, 0.12110402f, 0.00656892f, 
    0.49299189f, 0.21037690f, 0.11784767f, -0.04239088f, -0.10974910f, -0.06100499f, 0.10474866f, 0.23803240f, 
    0.05736188f, 0.16399416f, 0.28848058f, 0.11373377f, -0.44125688f, -0.03324610f, -0.32036874f, 0.02237178f, 
    0.28583694f, 0.13075529f, -0.14324866f, 0.02094618f, -0.00597484f, 0.21382137f, -0.15559356f, -0.20350397f, 
    -0.00569644f, -0.14393695f, -0.06014554f, -0.03978949f, 0.04736778f, 0.00349822f, -0.00979756f, -0.11580928f, 
    0.06789944f, 0.12026116f, 0.28188977f, 0.17041616f, 0.54893363f, 0.35645398f, 0.15313949f, 0.25291333f, 
    0.04291183f, 0.00445761f, -0.01820534f, -0.09008169f, -0.06003180f, -0.02463267f, 0.07523323f, 0.04329364f, 
    -0.15035547f, 0.12311679f, -0.19617635f, 0.12879063f, -0.03454975f, -0.23790967f, -0.08755280f, 0.19808759f, 
    -0.18423209f, 0.22469714f, 0.15167181f, 0.22122994f, -0.06450061f, -0.03564264f, 0.08252268f, 0.05289847f, 
    0.06587342f, -0.09299854f, -0.00122557f, -0.46507424f, 0.02467168f, -0.10283435f, -0.06638766f, -0.25011352f, 
    -1.34015679f, -0.31762299f, -0.07196107f, -0.36307856f, 0.11804189f, -0.01229168f, -0.08194859f, -0.04344248f, 
    -0.02813945f, 0.17691827f, -0.01474362f, 0.06830563f, -0.60938609f, 0.10350795f, -0.54355752f, -0.39073640f, 
    0.20779292f, -0.00721167f, -0.27468038f, -0.03183541f, -0.01790095f, -0.09911667f, 0.04648005f, -0.14012216f, 
    0.61861622f, 0.19506726f, -0.15863714f, 0.04499108f, -0.22322401f, -0.01032939f, 0.14625397f, -0.04167776f, 
    0.06237060f, 0.02938911f, -0.10518935f, -0.33439124f, -0.71656114f, -0.57960206f, 0.09307577f, -0.04039538f, 
    0.12467846f, -0.02559930f, 0.03325244f, -0.09801177f, 0.00633144f, -0.20561929f, -0.20370060f, -0.24951476f, 
    -1.08399868f, -0.34350210f, -0.15544412f, -0.34666505f, 0.08873799f, -0.19380237f, -0.01926220f, -0.00435639f, 
    -0.11395207f, -0.09989894f, 0.15421268f, 0.04201312f, 0.05265885f, -0.08998147f, 0.25121340f, 0.07232745f, 
    -0.00353906f, 0.15647711f, 0.09833563f, 0.16876295f, -0.07833876f, -0.13148148f, 0.11352611f, -0.07818224f, 
    0.36159784f, 0.30764553f, 0.05922628f, -0.33947089f, -0.22152421f, 0.02121903f, 0.02154045f, -0.11209185f, 
    -0.05603867f, -0.17508186f, 0.09034951f, 0.11512544f, -0.61688143f, 0.33341059f, 0.15143253f, -0.19879952f, 
    0.22689390f, 0.02743089f, 0.12143570f, 0.03844385f, 0.22524434f, 0.20360950f, 0.00515263f, 0.22762962f, 
    -0.33217195f, 0.35962385f, -0.20007892f, 0.02981653f, -0.03606263f, 0.23092271f, -0.25040787f, 0.03315412f, 
    0.29264101f, 0.26113930f, -0.01067617f, -0.06493121f, 0.52050143f, -0.25541762f, 0.03772435f, 0.13293312f, 
    -0.26702788f, -0.03477077f, 0.09881156f, -0.02013224f, 0.12384635f, 0.07887004f, -0.19118688f, 0.08399492f, 
    -0.13536555f, 0.16609660f, -0.21559736f, 0.48710734f, 0.06959073f, 0.06263880f, 0.04720018f, 0.01819029f, 
    0.16920084f, 0.05480316f, -0.23033190f, -0.25368676f, -0.07412006f, -0.14681621f, -0.26133341f, 0.28980994f, 
    -0.11125673f, 0.11883175f, -0.18038347f, 0.20140037f, 0.05637521f, 0.22413136f, -0.11263629f, 0.28319210f, 
    0.04580254f, -0.34575203f, 0.05365152f, 0.01818202f, -0.31661725f, 0.09259186f, 0.03122526f, 0.02604361f, 
    -0.13271834f, -0.19224149f, 0.04848238f, -0.04188041f, -0.36939800f, 0.13177350f, -0.04713107f, -0.19988732f, 
    0.18809617f, 0.05688120f, -0.00360254f, -0.06833379f, 0.14179863f, 0.14828160f, -0.12035200f, -0.04361608f, 
    -0.51992100f, 0.58958900f, 0.08050558f, -0.08780241f, -0.02865319f, 0.15709472f, -0.04623326f, 0.14332294f, 
    -0.06209314f, -0.21698803f, -0.07306661f, -0.04936372f, -0.05860211f, -0.18420441f, -0.26031518f, -0.00037283f, 
    -0.07766511f, 0.03008005f, -0.05487561f, -0.25547606f, 0.00686102f, -0.03724566f, -0.04362974f, 0.19304518f, 
    0.81652248f, -0.05000322f, -0.39610985f, -0.17390376f, 0.21150887f, -0.25895947f, -0.13335931f, -0.15316233f, 
    0.02767074f, -0.13300233f, -0.02215234f, 0.12780133f, -0.96241623f, -0.14663406f, 0.28185996f, -0.48378465f, 
    -0.02523343f, 0.05772971f, -0.09401423f, 0.11494990f, -0.18778621f, -0.06888180f, 0.12068032f, 0.02516173f, 
    0.03482038f, -0.29790959f, 0.02982489f, 0.15910043f, -0.18523674f, 0.05681346f, 0.19262941f, 0.14826690f, 
    -0.17302874f, 0.00540352f, -0.04969173f, -0.18811817f, 0.11270495f, 0.12209209f, -0.37009111f, 0.23533891f, 
    0.28289735f, -0.30279112f, -0.16821370f, -0.00601086f, -0.17103773f, 0.16139132f, -0.02859945f, -0.02292934f, 
    0.06905404f, -0.45455277f, 0.03700126f, -0.08884905f, 0.07735456f, 0.13857496f, -0.03869021f, -0.07482301f, 
    0.07313680f, 0.04241843f, -0.01952527f, -0.03075007f, -0.27910134f, 0.58256835f, -0.19165295f, -0.13101557f, 
    -0.19556119f, -0.17480385f, 0.11306419f, -0.54444569f, 0.08157974f, 0.12089156f, 0.23347194f, -0.07616438f, 
    -0.10165720f, 0.44826755f, -0.03111027f, -0.02007528f, -0.10649768f, 0.24677128f, 0.08762549f, -0.46341881f, 
    0.06129401f, 0.12459124f, -0.08958378f, -0.26651812f, 0.88919145f, 0.14227408f, -0.41999242f, -0.16844419f, 
    0.17160276f, -0.12566991f, -0.13947497f, 0.27452514f, 0.10655399f, 0.02842086f, -0.00359041f, 0.09633469f, 
    -0.49226582f, 0.24605136f, -0.39594018f, 0.13962677f, -0.01036168f, -0.19555095f, 0.13138705f, 0.24285270f, 
    -0.01846318f, 0.09515134f, 0.01376228f, -0.13077593f, -0.37968138f, 0.08928044f, 0.05535000f, 0.14512707f, 
    -0.06170714f, 0.06563453f, 0.08792298f, -0.16224444f, -0.02771122f, 0.03260998f, 0.18414153f, 0.03356439f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17651230f, 0.13410543f, -0.07956769f, 0.00696329f, 0.00006539f, -0.00492592f, -0.01231789f, -0.14121866f, 
    -0.10198585f, -0.00685528f, 0.24609663f, 0.01731305f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
