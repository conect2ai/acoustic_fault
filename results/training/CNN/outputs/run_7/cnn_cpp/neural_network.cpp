#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.95446062f, 0.75956953f, 1.01175487f, 0.31150177f, -0.58930743f, 0.01175551f, 0.60909015f, 0.62337780f, 
    -0.57684213f, 1.26473510f, 1.38861740f, 0.04499601f, -0.35441059f, -0.46871576f, -0.74349463f, 0.16484651f, 
    -0.41638526f, 0.36899084f, 0.98470485f, 1.09522104f, 0.78335142f, 0.10069627f, 0.04083228f, 0.78601599f, 
    -0.30611345f, 0.19462727f, 0.20047116f, 0.92487985f, -1.02142048f, 0.79423231f, 0.49695444f, 0.26986772f, 
    0.82693607f, -0.29679093f, -0.35076940f, -0.68549889f, -0.03989328f, 0.93288821f, -1.15499711f, 0.09719359f, 
    -0.92885405f, -0.89479506f, 0.23750177f, 0.63967526f, -0.03554581f, -0.90344965f, 0.69776189f, 0.74325371f, 
    0.87909460f, 0.82293022f, 0.67529571f, 0.37177095f, -0.00372899f, -0.28667399f, -1.07972252f, -0.95472115f, 
    -0.18565425f, 0.48512000f, 0.17397062f, 0.60595465f, -0.48716530f, -0.20051749f, 0.18548159f, -0.54727507f, 
    1.09865165f, 1.08235955f, -1.05923057f, 0.56951058f, 0.18304279f, 0.04920124f, 0.17139673f, 0.01522224f, 
    -0.44012672f, -1.25383079f, -0.81839406f, 0.48234689f, 0.90008152f, 0.63596690f, -0.10220721f, 0.53660721f, 
    -0.40274298f, 1.08441842f, -0.85173422f, 0.87802958f, -0.89481646f, -0.77476943f, -0.75397068f, 0.21072595f, 
    0.00762757f, 0.19015279f, 0.89156395f, 0.61265367f, 0.05228703f, -0.38847557f, -1.06032789f, 0.65867299f, 
    0.54909676f, 0.17815761f, 0.14020933f, -0.46651787f, -0.83673483f, -0.25734526f, -0.79560864f, -0.63410270f, 
    -0.93948096f, -0.56467807f, 0.13633610f, -0.66686815f, -0.38252494f, -0.47711933f, 0.96860743f, -0.77924234f, 
    0.01429474f, 0.83307105f, 0.40491021f, -0.10696930f, -0.37025672f, -0.77530640f, -0.70878530f, -0.69638979f, 
    -0.52494305f, 1.18735206f, 0.12015458f, -0.00492692f, -0.42042035f, -0.03283809f, 0.96447772f, -1.06174958f, 
    -0.76505798f, 0.03460140f, -0.44223997f, 0.14454035f, -0.53917778f, 0.49534908f, 0.53718859f, -0.58562428f, 
    -0.98534757f, -1.05766475f, -0.61648715f, -0.36946863f, 0.09126072f, -0.01536702f, 0.07259303f, -0.15380867f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02883897f, 0.02283357f, 0.16206065f, 0.31679717f, 0.13333714f, 0.19172388f, -0.01551382f, 0.02675808f, 
    0.11274159f, 0.08294997f, 0.18869673f, 0.27492869f, 0.26287109f, 0.18468247f, 0.02732483f, 0.08983250f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26631996f, -0.28750211f, 0.10058513f, -0.29392079f, -0.02196239f, 0.20702082f, 0.15054634f, 0.06975842f, 
    -0.05437189f, 0.01545751f, 0.05822851f, 0.04877255f, 0.12532398f, 0.06955800f, 0.02299810f, 0.12970197f, 
    -0.01306579f, 0.00584391f, 0.04594137f, -0.00722932f, -0.23362939f, -0.09545601f, -0.06033985f, -0.01460465f, 
    0.03572585f, 0.10013113f, 0.14822404f, -0.06702449f, -0.02596806f, -0.09435173f, -0.05167167f, 0.10204804f, 
    0.00767688f, -0.02932757f, -0.00627200f, -0.02920335f, -0.02304309f, 0.13997112f, -0.03530832f, 0.01903763f, 
    -0.18762651f, -0.27275553f, -0.05297263f, -0.10308755f, -0.16357104f, 0.29639941f, 0.07512024f, -0.04883858f, 
    -0.10406327f, -0.06871911f, 0.09117581f, 0.00744136f, 0.02381986f, -0.04941311f, -0.10508928f, -0.09150792f, 
    -0.01267356f, 0.07809268f, -0.02385377f, 0.10759101f, -0.21402261f, 0.14445147f, -0.11034055f, -0.13657773f, 
    0.02675378f, 0.01054549f, -0.02793756f, -0.02340961f, -0.04368413f, 0.04798041f, 0.04581748f, 0.02009149f, 
    -0.03371537f, 0.00100133f, -0.04618455f, -0.07850368f, -0.00568488f, 0.02978464f, -0.01010836f, -0.02384833f, 
    -0.08210737f, 0.20336394f, -0.21185870f, -0.13896003f, -0.04060481f, 0.23049642f, -0.01721399f, -0.01111055f, 
    -0.05211432f, -0.05990474f, 0.04671568f, 0.04600370f, 0.17632379f, -0.12035805f, -0.09417853f, 0.06568807f, 
    -0.06289310f, 0.00594363f, 0.12007354f, 0.06977052f, 0.19203790f, 0.16793635f, -0.14004126f, -0.19889955f, 
    0.05731037f, -0.05318549f, 0.07500742f, -0.01837640f, 0.11968700f, -0.05939309f, -0.11456902f, 0.10942349f, 
    -0.00557007f, 0.06664875f, -0.06174027f, 0.00669474f, 0.02610882f, 0.07431372f, -0.07910784f, 0.07665086f, 
    0.13774854f, 0.02166850f, 0.22121713f, 0.14689487f, 0.42377797f, -0.07263105f, -0.15897179f, 0.08897617f, 
    0.07819220f, 0.00598783f, 0.04991030f, -0.13485903f, 0.01320088f, -0.00045272f, 0.03271554f, -0.08580973f, 
    -0.15986538f, 0.05931982f, -0.10099293f, 0.07991596f, 0.47653511f, -0.07213038f, -0.04509144f, 0.11080938f, 
    0.10696550f, -0.01318076f, 0.08446423f, -0.01460718f, 0.11908150f, -0.10440907f, 0.06626672f, 0.02182128f, 
    0.00016578f, -0.03584835f, -0.02369604f, 0.07634293f, 0.07119654f, -0.04042663f, 0.05496503f, 0.11804932f, 
    0.03223405f, -0.02912574f, 0.31862918f, 0.19682766f, 0.14948991f, -0.08104954f, -0.05391484f, 0.13077164f, 
    0.16282141f, 0.06877714f, -0.06034917f, -0.07531760f, 0.01963905f, -0.01147645f, -0.02538184f, -0.09573215f, 
    -0.04975749f, 0.06012140f, 0.09941009f, -0.04795726f, -0.26430827f, 0.36899602f, -0.11946222f, -0.38484764f, 
    0.24813183f, 0.09855814f, 0.01465451f, -0.11148435f, -0.01617431f, -0.10397098f, 0.04944967f, 0.05856330f, 
    -0.03251953f, -0.15752085f, -0.02280540f, 0.00638596f, 0.15521675f, 0.01441262f, -0.06870658f, 0.00866949f, 
    -0.27376723f, 0.28272220f, -0.15924029f, -0.07598018f, 0.05522031f, 0.18247165f, 0.00402187f, 0.11180060f, 
    0.05386649f, 0.01366489f, 0.09488531f, 0.01472437f, -0.09159467f, 0.03537679f, 0.04053743f, -0.00368873f, 
    -0.03136466f, 0.08911353f, 0.00432909f, -0.07759488f, 0.15867288f, 0.06379370f, 0.09679481f, -0.24575743f, 
    -0.01003096f, -0.09680785f, 0.09671550f, -0.05441618f, -0.01706052f, -0.14153181f, 0.11343107f, -0.04266031f, 
    -0.06665149f, 0.02659247f, -0.02296909f, 0.14220256f, -0.02222334f, -0.05765368f, 0.12976502f, 0.03090884f, 
    0.05921936f, 0.19800813f, 0.04844806f, -0.10131337f, 0.30640560f, 0.08467309f, 0.13497403f, 0.03374912f, 
    -0.04481958f, 0.04121871f, 0.02294875f, 0.03760977f, -0.06207639f, 0.06050052f, 0.05913910f, 0.01554709f, 
    0.08073639f, 0.00884886f, -0.07508045f, -0.04134406f, 0.20592450f, -0.11556764f, 0.28368196f, 0.21556763f, 
    0.13251837f, -0.02600699f, -0.08838540f, -0.03827593f, 0.14985237f, 0.04814863f, -0.01876533f, -0.02309818f, 
    0.03129059f, -0.00203978f, -0.01575850f, -0.05917317f, 0.04111362f, -0.00566555f, 0.04379879f, -0.04498002f, 
    -0.25436869f, 0.36101556f, -0.13089964f, -0.01506494f, -0.09862695f, 0.02296183f, 0.00657607f, 0.12545162f, 
    0.08767770f, 0.03880029f, 0.14278218f, -0.00461056f, -0.11803824f, 0.06773640f, 0.13243689f, 0.10801095f, 
    0.12332368f, 0.01736722f, 0.00177794f, 0.08601125f, 0.33319989f, -0.03536409f, 0.25821865f, -0.10357347f, 
    -0.12262297f, -0.00555016f, 0.12004195f, -0.02742576f, -0.16993386f, -0.11887617f, 0.07884304f, 0.06351095f, 
    0.01593420f, 0.08679335f, 0.07995204f, 0.06909402f, -0.06565783f, -0.03504608f, 0.08605000f, -0.07408017f, 
    0.46839923f, 0.21989813f, 0.06651010f, 0.00074231f, -0.16522515f, -0.09772393f, -0.06671054f, 0.06237075f, 
    0.01340001f, -0.02680422f, 0.03051803f, 0.01194238f, 0.02689063f, -0.07905678f, -0.18824640f, 0.00540468f, 
    -0.02155215f, -0.09816756f, -0.00246947f, -0.03469715f, 0.50116473f, 0.14641222f, -0.06755275f, -0.05589679f, 
    -0.11259159f, 0.03577902f, -0.01316872f, 0.06880943f, 0.02205959f, -0.01731109f, 0.06162504f, 0.10329231f, 
    -0.09640566f, -0.01504386f, -0.04683561f, 0.04317036f, 0.12812403f, 0.12641685f, -0.12274113f, -0.01477303f, 
    0.19996174f, 0.31548852f, 0.02626063f, 0.25914878f, 0.10641404f, 0.04556818f, -0.03848609f, 0.01492852f, 
    0.02731753f, 0.03217495f, -0.00121921f, 0.15830538f, -0.00315979f, -0.07824153f, 0.11338532f, -0.04931612f, 
    -0.01018979f, -0.12571202f, -0.04850753f, -0.13634153f, 0.27677047f, -0.29577374f, 0.02884348f, 0.02223302f, 
    0.13897878f, 0.20007305f, -0.00451843f, 0.05408046f, 0.07108963f, 0.11379185f, 0.06053422f, 0.11277822f, 
    0.06463428f, 0.15498175f, 0.03717658f, -0.01781477f, 0.10822093f, 0.03223154f, 0.06058208f, 0.03283481f, 
    0.02362770f, -0.24448341f, -0.03792463f, -0.15145014f, 0.06819481f, 0.22356941f, 0.10779420f, 0.01717274f, 
    0.00328334f, 0.01287842f, 0.16579057f, 0.09017895f, -0.02964691f, 0.04781161f, -0.01859342f, 0.17662685f, 
    -0.08411313f, 0.17011300f, 0.02722546f, 0.07944568f, -0.07179752f, -0.23658438f, 0.00067966f, -0.04482188f, 
    0.15663943f, -0.20082802f, 0.08527528f, -0.06628249f, 0.16789535f, 0.15122697f, -0.07989621f, 0.10988914f, 
    0.13082699f, 0.09272841f, 0.16093209f, 0.06503319f, -0.04115219f, -0.13951653f, -0.05225316f, 0.02043591f, 
    0.24137594f, -0.02710032f, -0.02223228f, -0.04766330f, -0.20421398f, -0.23604512f, -0.05903353f, -0.05582358f, 
    -0.12183160f, 0.11724720f, 0.01646223f, 0.00938993f, -0.04892846f, 0.26877016f, 0.11795442f, 0.02410054f, 
    -0.07280723f, -0.09024081f, -0.04787696f, -0.04135604f, -0.03710559f, 0.31920171f, -0.15041862f, -0.28238806f, 
    0.33436149f, 0.00801771f, 0.13746133f, 0.01115350f, -0.04758948f, 0.01392969f, -0.05440337f, -0.00958106f, 
    0.08430139f, -0.15727602f, -0.02141874f, 0.04908439f, -0.12948428f, -0.05001578f, 0.06214049f, 0.03728900f, 
    0.27042043f, -0.39019710f, -0.10753472f, 0.08504326f, -0.15163006f, -0.01521888f, -0.00311197f, -0.07360544f, 
    0.09230933f, 0.13331385f, -0.03797689f, -0.01233631f, 0.07094087f, 0.00115117f, -0.09110877f, 0.00690584f, 
    0.00800585f, -0.08816972f, -0.16112335f, 0.11346879f, 0.18552496f, 0.13179298f, -0.07817434f, -0.34736434f, 
    -0.14720750f, 0.17085998f, 0.06895261f, 0.07724737f, 0.03387775f, -0.05155599f, 0.03312911f, 0.10451511f, 
    -0.02649074f, -0.07312880f, 0.03817241f, 0.04598885f, -0.02382609f, -0.10560586f, 0.15805241f, 0.00798928f, 
    0.32463729f, -0.02152013f, 0.20877591f, -0.03546510f, 0.11152759f, 0.15581405f, 0.01693956f, 0.20981191f, 
    0.12553895f, -0.03676107f, 0.12574799f, 0.14720546f, 0.06884400f, 0.08375239f, -0.03587037f, 0.01256908f, 
    -0.07083780f, -0.05233597f, 0.02565610f, -0.10554217f, -0.10772222f, -0.07251587f, -0.14138779f, -0.30553597f, 
    -0.18563406f, -0.25004625f, -0.01598625f, 0.07466828f, -0.09404903f, 0.02495919f, 0.04576548f, -0.00692267f, 
    -0.07492892f, 0.05321532f, -0.10636529f, 0.20515534f, -0.02651285f, 0.20714782f, 0.12142638f, -0.03066180f, 
    -0.12494843f, 0.17226565f, -0.07160500f, 0.15586154f, -0.17750482f, -0.02039960f, -0.03945477f, -0.01286940f, 
    0.05349544f, -0.05400775f, 0.05521186f, -0.05374181f, 0.00357249f, -0.00322647f, 0.01013186f, 0.10690305f, 
    -0.05687181f, 0.08599994f, 0.12276082f, -0.03353008f, 0.36525372f, -0.19927815f, -0.23842494f, 0.09955271f, 
    -0.09708753f, -0.04195931f, 0.07260165f, -0.12263389f, -0.04130557f, 0.10687973f, -0.07433121f, 0.03918646f, 
    -0.06235189f, 0.00449864f, 0.27088395f, 0.07673103f, 0.03445467f, 0.06572104f, 0.01934318f, 0.11509797f, 
    0.09974436f, -0.32949924f, 0.15584615f, -0.04446051f, 0.10181368f, 0.19420461f, 0.07576078f, 0.15041576f, 
    -0.01294364f, -0.00908998f, 0.04297215f, -0.09116686f, -0.10221414f, 0.00743194f, 0.06790121f, 0.13831115f, 
    -0.06946206f, 0.13136387f, -0.04419237f, 0.07221485f, 0.10334299f, 0.06913789f, -0.15041427f, 0.11202451f, 
    -0.01339937f, -0.27717337f, -0.09562558f, 0.10004817f, -0.09767217f, -0.05967239f, -0.06059712f, -0.08425315f, 
    0.22086552f, 0.16902556f, 0.12808096f, -0.03620295f, 0.04673148f, -0.06103093f, 0.04782513f, 0.00299602f, 
    0.41614598f, -0.26107129f, 0.13969295f, -0.32918432f, -0.03674353f, -0.06164162f, -0.08197170f, -0.06268763f, 
    -0.09695557f, 0.06302775f, 0.11128348f, -0.06116737f, 0.01437721f, -0.03794502f, 0.06261445f, 0.00728378f, 
    -0.15204261f, -0.18433826f, 0.03383595f, -0.03123605f, -0.07764136f, -0.02889858f, 0.11174498f, -0.04564806f, 
    0.19166879f, -0.23794590f, 0.09186281f, -0.30312017f, -0.06441639f, -0.04537807f, 0.10467680f, 0.03133023f, 
    0.15411845f, -0.09804742f, 0.01866728f, 0.09794398f, 0.03019113f, 0.02584948f, -0.08514885f, -0.01907363f, 
    0.45760092f, -0.15704876f, -0.13970484f, -0.41384703f, 0.01533154f, -0.00710932f, -0.11245755f, -0.29680106f, 
    -0.22676399f, -0.02790887f, -0.04332323f, -0.07629056f, 0.03869350f, 0.03930244f, -0.01615138f, -0.00892797f, 
    0.16610259f, -0.30200717f, -0.11457051f, 0.17451228f, 0.47181171f, -0.07673541f, -0.19277823f, -0.18408889f, 
    -0.41173816f, -0.09706154f, 0.06571050f, 0.04869353f, -0.10271695f, 0.03358079f, 0.00510568f, -0.03100792f, 
    0.12964132f, 0.13643090f, -0.01290671f, 0.21274123f, 0.05140076f, -0.01478863f, -0.00382993f, -0.01861481f, 
    -0.23247704f, -0.03989283f, 0.02469070f, -0.28271586f, 0.20303382f, 0.07294416f, -0.08408543f, -0.01145911f, 
    -0.09421921f, 0.04070685f, -0.00700173f, 0.12036159f, 0.03079815f, 0.03460775f, -0.03348470f, 0.06377644f, 
    0.00801640f, 0.12461402f, 0.10115743f, 0.00901897f, -0.01960596f, 0.16360950f, 0.07676205f, -0.29672384f, 
    0.25489765f, 0.02571416f, 0.02651021f, 0.08131135f, 0.04814251f, -0.00920223f, -0.10267788f, -0.00605132f, 
    0.08565659f, 0.24135548f, 0.08004868f, -0.01741020f, 0.05260864f, -0.38978225f, -0.08820505f, -0.04258728f, 
    -0.07941730f, 0.38453349f, -0.00595217f, 0.05074631f, -0.01407351f, 0.17134312f, 0.04526585f, 0.06111263f, 
    0.24582484f, 0.05192077f, -0.03963011f, -0.06958304f, 0.07742678f, 0.04192270f, 0.10436672f, 0.09419224f, 
    0.04192818f, 0.16937031f, 0.03307592f, 0.09498576f, 0.01101315f, -0.27162492f, 0.29391599f, 0.15702721f, 
    0.31682086f, -0.02616752f, 0.05048783f, -0.12230761f, -0.00826442f, -0.01001645f, -0.05854369f, -0.14337185f, 
    0.15550984f, -0.07547596f, -0.01496694f, 0.06188035f, -0.07312586f, -0.04700532f, -0.03778161f, -0.00486642f, 
    -0.20904693f, 0.14829746f, -0.05134559f, 0.19960117f, -0.12125746f, 0.19708033f, 0.06602486f, 0.15209809f, 
    0.16373727f, 0.23597030f, 0.06372600f, 0.03996993f, 0.07548097f, 0.11533041f, -0.12232781f, -0.01865045f, 
    0.00412828f, 0.00344178f, -0.01198551f, -0.09541435f, 0.34370279f, -0.37882152f, -0.26360708f, 0.01035514f, 
    -0.15522189f, 0.04039722f, -0.09308989f, -0.18437581f, -0.21364670f, -0.01541086f, -0.10357073f, 0.05616844f, 
    -0.00022414f, 0.02243886f, 0.01867020f, -0.08051384f, 0.12370164f, 0.02250752f, 0.12666135f, 0.06987202f, 
    0.12811190f, -0.07581681f, 0.04059515f, -0.07839130f, -0.08709420f, -0.10667218f, 0.02857542f, -0.06152456f, 
    -0.16080667f, -0.00711248f, 0.09350187f, 0.02783836f, 0.04453213f, -0.09520923f, 0.07707993f, -0.10502904f, 
    0.07097066f, -0.05371899f, 0.02447461f, -0.23490755f, -0.01252736f, -0.43143347f, 0.33704129f, 0.20575242f, 
    -0.07038364f, -0.08668885f, 0.10306722f, 0.02947312f, -0.13714568f, 0.11901826f, 0.11900063f, 0.02023230f, 
    -0.18789719f, -0.10326140f, 0.03447570f, 0.07031585f, 0.15526886f, 0.01897656f, -0.01699141f, 0.05186646f, 
    -0.09990240f, 0.14039543f, -0.01390619f, 0.18900497f, 0.18481816f, -0.09413320f, 0.06930856f, -0.10217349f, 
    -0.09064635f, 0.15014905f, 0.06825528f, 0.15045558f, 0.13453884f, 0.01867796f, -0.02779569f, -0.01811456f, 
    0.10337327f, -0.09290399f, 0.09338272f, 0.05553211f, 0.07268248f, 0.33950639f, 0.25648642f, 0.18947017f, 
    -0.03360509f, -0.03236952f, 0.00546889f, -0.03449970f, 0.03604513f, 0.10272305f, -0.29001966f, 0.00218808f, 
    -0.05011579f, 0.03470142f, -0.11040071f, -0.03085441f, 0.19368561f, 0.09585638f, 0.06244211f, -0.10411854f, 
    0.08225569f, 0.13699943f, -0.25872397f, 0.12575714f, -0.26010716f, 0.11701570f, 0.07568027f, -0.05249703f, 
    0.00290108f, 0.00318783f, 0.00352952f, 0.04934867f, -0.11159423f, 0.01636755f, 0.23189825f, 0.06404016f, 
    0.11557255f, -0.02434403f, -0.16799031f, 0.09264663f, 0.28851056f, -0.17663607f, -0.01238129f, 0.32755521f, 
    -0.11826704f, -0.07770403f, 0.04615923f, -0.01946954f, 0.00344713f, 0.09404664f, -0.05954572f, -0.10305253f, 
    0.12534633f, -0.00975009f, 0.09393716f, 0.07300559f, 0.05390129f, 0.06258351f, 0.08993832f, 0.00586925f, 
    0.59616077f, 0.50177944f, 0.10149916f, 0.24350652f, 0.12063560f, -0.16203718f, 0.06556483f, 0.07111323f, 
    0.10730457f, 0.01814710f, 0.02265826f, -0.01774259f, -0.02058235f, 0.08091753f, 0.01577814f, -0.04425355f, 
    0.06619123f, 0.10181192f, 0.02339401f, 0.04289420f, 0.44751444f, 0.54036760f, 0.05039144f, 0.18582714f, 
    0.24017921f, -0.15383156f, -0.11280118f, -0.00393925f, 0.01357938f, 0.07563166f, 0.04473139f, -0.02915054f, 
    0.12700376f, -0.05552925f, -0.01212958f, 0.16930506f, 0.12188469f, 0.06509791f, 0.08094811f, 0.11594272f, 
    0.22668961f, 0.42010945f, 0.17706960f, 0.07426907f, 0.16850017f, 0.00632370f, 0.06221210f, -0.00573980f, 
    -0.05821913f, 0.06778846f, -0.05483450f, 0.11610024f, -0.04093815f, 0.03271224f, 0.03242312f, 0.01081470f, 
    0.06433166f, -0.10183781f, -0.03351697f, 0.02851074f, 0.17041700f, 0.13794917f, 0.09185531f, 0.12180471f, 
    -0.02186275f, -0.08397604f, -0.03844991f, 0.07598460f, -0.04195236f, -0.01117545f, -0.06813311f, -0.01972671f, 
    0.01074479f, 0.08342053f, 0.08475672f, 0.02420817f, -0.00245711f, 0.01018894f, -0.03810322f, -0.01590621f, 
    -0.14163190f, -0.31431764f, 0.30104285f, 0.06487593f, -0.14617757f, -0.03375204f, 0.06009546f, -0.01596559f, 
    -0.04178154f, 0.11577954f, -0.02422133f, 0.03103469f, -0.17707661f, 0.03928742f, 0.04915056f, 0.08249585f, 
    -0.03135505f, 0.10478725f, 0.07693566f, -0.04526747f, 0.10157522f, -0.11063282f, 0.33603746f, 0.12519488f, 
    0.05023160f, 0.08874401f, 0.01600770f, 0.07919572f, -0.12198688f, 0.04715389f, 0.00342653f, -0.02629972f, 
    0.17488156f, 0.09712400f, 0.11327618f, -0.05040749f, -0.06513609f, -0.10251592f, 0.01059234f, -0.12051488f, 
    -0.55859786f, -0.22301663f, 0.02550614f, -0.17110357f, -0.37766108f, 0.23196362f, 0.30068946f, -0.09463696f, 
    0.09295207f, -0.01389352f, -0.03961974f, -0.05101071f, -0.09125114f, -0.03522035f, -0.01454988f, 0.09187482f, 
    0.02329347f, 0.00399301f, 0.07338849f, -0.00942862f, 0.20534344f, -0.07123505f, 0.03385411f, 0.38099936f, 
    0.02376861f, -0.07341169f, 0.05671860f, -0.09008165f, 0.08771461f, 0.06608951f, 0.11591135f, 0.13233817f, 
    0.08351299f, -0.01595602f, 0.05991282f, -0.09623223f, 0.07027198f, 0.06206291f, 0.15877409f, -0.11607875f, 
    -0.37449551f, 0.09124231f, -0.29046631f, -0.34057534f, -0.23277631f, 0.17436355f, 0.17380682f, -0.00858485f, 
    0.06971266f, -0.14372748f, 0.00865730f, -0.13770580f, 0.00358370f, -0.02985335f, 0.04238368f, 0.12001947f, 
    0.05465617f, -0.07510983f, -0.13223328f, 0.03187147f, 0.38014176f, -0.13180557f, 0.20438874f, 0.12003545f, 
    0.07947683f, -0.13769224f, -0.17227106f, -0.01693383f, 0.11710958f, 0.02093591f, -0.13322961f, -0.15360861f, 
    0.06953844f, 0.16815782f, 0.11392700f, 0.04800288f, -0.00720977f, 0.05272959f, 0.20082343f, 0.04845625f, 
    0.36916244f, 0.17201543f, 0.09722683f, -0.05481379f, -0.07739308f, 0.05006930f, 0.03339574f, -0.08680219f, 
    0.12407067f, -0.05720303f, -0.01300482f, -0.03238831f, 0.18251432f, -0.04238571f, -0.11938827f, -0.04301878f, 
    0.04071061f, -0.09630603f, -0.00459913f, 0.01884576f, -0.36179706f, -0.39495322f, -0.18498398f, -0.02466902f, 
    -0.01256689f, 0.16550082f, -0.10573752f, 0.00939778f, -0.00487609f, -0.04819264f, 0.02355992f, 0.07300182f, 
    -0.09523568f, -0.05221362f, 0.11401815f, -0.03629675f, 0.05515044f, 0.25482759f, -0.01541231f, -0.09675557f, 
    -0.00264072f, 0.01185104f, -0.11806487f, 0.26991364f, -0.26413724f, -0.07138151f, -0.09069747f, 0.06372033f, 
    0.11932057f, -0.04756701f, 0.18152735f, 0.07743479f, 0.17909488f, 0.04535888f, 0.05009301f, 0.08712535f, 
    -0.00528286f, 0.01037256f, 0.04669875f, 0.13861905f, -0.42293757f, 0.29977879f, -0.05156595f, -0.23377590f, 
    -0.10765057f, 0.19288766f, 0.17759429f, 0.08314806f, -0.04823317f, -0.18185206f, -0.00919458f, -0.08468324f, 
    -0.04329620f, 0.06191243f, 0.01421617f, 0.09413252f, -0.12099069f, 0.02140352f, 0.03472779f, 0.09253767f, 
    -0.09519868f, -0.63197905f, 0.01174149f, -0.09837526f, 0.02418794f, 0.10100085f, 0.03642655f, 0.06677962f, 
    0.07130418f, 0.06421147f, 0.05374203f, 0.08885332f, 0.15403074f, -0.10487913f, 0.05135260f, -0.02804188f, 
    -0.01003619f, 0.06515700f, 0.02716956f, 0.00939435f, -0.73050010f, -0.17111990f, -0.24126481f, -0.12152013f, 
    -0.12249783f, 0.08822131f, -0.06764365f, 0.13264707f, 0.02735574f, -0.10561329f, 0.02018040f, -0.00258652f, 
    -0.13067773f, -0.04583658f, -0.06385647f, 0.12615509f, 0.01691701f, 0.11398510f, 0.13011791f, 0.20320936f, 
    0.03142206f, 0.01295056f, 0.14458701f, 0.23955706f, 0.46590939f, 0.02000264f, 0.22016482f, 0.07346489f, 
    0.05297045f, -0.04118505f, -0.03194406f, -0.00098028f, 0.08688737f, -0.06456617f, 0.17133331f, -0.15464929f, 
    0.03475630f, 0.04119950f, -0.03583397f, -0.13018836f, 0.17039101f, -0.23686750f, -0.22148681f, 0.15716964f, 
    0.48196882f, -0.04998124f, -0.06661094f, 0.12813878f, -0.09074492f, 0.07709040f, -0.03352472f, -0.12076845f, 
    0.05942916f, 0.00042585f, 0.03202788f, -0.06939868f, -0.03728537f, -0.07633958f, 0.13970168f, 0.09017333f, 
    0.64617395f, -0.01023887f, 0.09761391f, 0.00954316f, 0.34195077f, -0.07462507f, -0.08326176f, 0.17465994f, 
    0.06286681f, 0.00152923f, -0.04895590f, 0.00811660f, 0.01885846f, 0.02670676f, -0.10031836f, 0.09110919f, 
    -0.11704228f, 0.24812695f, 0.04712726f, 0.05780971f, 0.00351451f, 0.50901425f, 0.02992980f, 0.02444532f, 
    -0.12232222f, -0.10850281f, 0.06290080f, -0.06397082f, -0.04721287f, -0.05208920f, 0.19960257f, 0.04418134f, 
    -0.10119142f, -0.13017139f, -0.06177714f, -0.02700028f, -0.00944240f, 0.05215006f, 0.04498512f, -0.00714966f, 
    -0.30825746f, 0.07844591f, 0.07092297f, -0.11686067f, -0.29027328f, -0.13031858f, -0.04960218f, -0.01547033f, 
    -0.03599356f, 0.11170308f, -0.08477037f, -0.07517085f, -0.05004837f, -0.02288022f, 0.05744641f, -0.10113757f, 
    -0.02160483f, -0.07576276f, 0.06389610f, -0.12821043f, 0.05857671f, 0.48655644f, 0.27349359f, 0.08723150f, 
    0.06357869f, 0.02063041f, -0.25339633f, 0.09801330f, 0.01760805f, -0.09937964f, 0.11766011f, -0.18482025f, 
    0.03202865f, 0.04783241f, -0.07297868f, 0.11383843f, -0.13693738f, -0.08396829f, 0.21102406f, 0.03813107f, 
    -0.23378968f, 0.00750619f, -0.09660604f, -0.02079613f, 0.17985892f, 0.18479282f, 0.05752280f, -0.04965013f, 
    0.03085246f, 0.13592762f, 0.06998357f, -0.05877517f, 0.07501566f, -0.15472695f, 0.08758581f, 0.07888523f, 
    0.08235034f, 0.05581586f, 0.16930494f, 0.09030961f, 0.29098493f, 0.12795942f, -0.17404342f, 0.08911273f, 
    -0.31577832f, -0.05134828f, 0.02978376f, 0.02813584f, 0.02770925f, -0.19556890f, 0.03070368f, 0.03601104f, 
    0.05988185f, 0.16891816f, 0.00096530f, -0.10553344f, 0.05168157f, -0.10621712f, -0.03959262f, -0.05496193f, 
    -0.41900814f, 0.34257343f, -0.09308887f, 0.13283056f, 0.04679771f, 0.07082872f, -0.01069759f, 0.09134456f, 
    -0.04448840f, 0.06626292f, 0.09533081f, 0.04235034f, 0.03911148f, 0.03317963f, 0.16356771f, 0.21027713f, 
    0.01116581f, -0.01630084f, 0.16335259f, 0.07534304f, -0.03966179f, -0.09891130f, -0.13282466f, 0.27909610f, 
    0.04762216f, -0.14924470f, 0.14425251f, 0.07029203f, 0.00565978f, -0.11946056f, 0.16335985f, -0.13593033f, 
    -0.07611274f, -0.07472622f, -0.00485535f, 0.03843038f, 0.11797970f, 0.12072969f, -0.03404278f, -0.14231358f, 
    0.33056086f, 0.15024503f, -0.09964546f, 0.09429582f, -0.19642670f, -0.18640086f, -0.04619660f, -0.02453927f, 
    -0.04057971f, 0.06093841f, 0.05397769f, -0.01920627f, -0.01943461f, 0.00330239f, -0.01050980f, -0.11044893f, 
    -0.03445830f, 0.01202340f, 0.01672943f, 0.00655561f, -0.16796899f, 0.09808326f, 0.17680667f, 0.24167807f, 
    -0.12410329f, 0.12025012f, 0.06566165f, -0.09440406f, 0.10217094f, -0.03581848f, 0.03921130f, 0.03948065f, 
    0.20639522f, 0.15655443f, 0.16802227f, -0.30363303f, 0.10643245f, 0.17908201f, -0.10749128f, -0.07671325f, 
    0.15524773f, -0.16367146f, 0.09368397f, -0.05225300f, -0.14708070f, 0.04003459f, -0.01885182f, 0.06159202f, 
    -0.07578059f, -0.03562145f, -0.00053727f, 0.00895195f, -0.05604148f, -0.07286619f, 0.02394574f, 0.03530587f, 
    -0.06095882f, -0.20908812f, -0.15840478f, 0.02245278f, -0.46015441f, 0.12482236f, -0.02822923f, -0.12922947f, 
    0.24624507f, 0.09054331f, -0.08651263f, 0.03033992f, 0.00644345f, 0.11827146f, 0.22069351f, 0.04369359f, 
    -0.04396040f, 0.06256085f, 0.01418927f, -0.00263443f, -0.10038337f, -0.08009069f, 0.13194887f, -0.11221208f, 
    -0.00494277f, 0.31104502f, 0.01822704f, 0.03680022f, -0.38030881f, -0.16012008f, 0.01365835f, -0.02469492f, 
    -0.03304421f, 0.09241170f, -0.03586426f, 0.08425371f, 0.15927860f, 0.12890145f, -0.04400519f, -0.05805851f, 
    -0.08616462f, -0.01673207f, 0.14169402f, -0.00061737f, -0.20384048f, -0.13894369f, 0.02342904f, 0.30037525f, 
    -0.12447947f, 0.04930400f, 0.18413958f, -0.10183329f, 0.08878977f, 0.16084775f, 0.03416141f, 0.20657597f, 
    -0.07054120f, -0.01529648f, -0.00833979f, 0.05408442f, 0.14944299f, 0.22217995f, -0.12946245f, -0.02848060f, 
    -0.02280794f, -0.03398363f, 0.02351470f, -0.05585311f, 0.02072702f, -0.04426450f, -0.03016922f, 0.04257251f, 
    -0.05054433f, -0.00982629f, 0.01306025f, -0.00711280f, -0.05168388f, 0.00803166f, -0.04107367f, -0.01032407f, 
    -0.02133789f, 0.02912246f, 0.02786562f, 0.04845680f, -0.05911110f, -0.02834123f, -0.05832357f, 0.02382653f, 
    -0.00629353f, 0.04028829f, 0.02242043f, 0.02022763f, -0.00017150f, 0.03434396f, -0.03467657f, -0.02858883f, 
    0.04696384f, 0.04321752f, -0.05850192f, 0.03730563f, 0.00920632f, 0.01299840f, -0.02515755f, 0.02202812f, 
    0.02052278f, -0.02366795f, 0.04028795f, -0.01808931f, 0.03369994f, -0.00565865f, -0.04077107f, -0.02772974f, 
    -0.02910829f, -0.05380388f, 0.00163189f, -0.03889449f, 0.03937138f, -0.05830611f, -0.05759510f, 0.03470692f, 
    -0.02116871f, 0.03217383f, -0.05631640f, -0.03522434f, -0.05877952f, -0.01929750f, 0.04645414f, -0.00822538f, 
    -0.00497262f, 0.02109722f, -0.03051437f, -0.02179110f, 0.03248069f, -0.00970978f, 0.03475462f, 0.01026263f, 
    -0.04878352f, 0.04180215f, -0.03108733f, -0.04851090f, -0.05019412f, -0.00908716f, -0.05249580f, -0.02564050f, 
    -0.03528050f, -0.02081580f, 0.04250008f, -0.02232582f, 0.01618782f, -0.02087335f, 0.01796297f, -0.00857205f, 
    0.00092322f, 0.00117853f, 0.00870698f, -0.04139197f, -0.03129873f, -0.04830963f, -0.06187161f, 0.02959283f, 
    -0.01960834f, 0.03354831f, -0.02045844f, -0.01074468f, 0.01980439f, 0.01108506f, -0.01100523f, -0.02932300f, 
    0.03439761f, 0.02502978f, -0.01956645f, -0.02379055f, 0.03022676f, -0.02852347f, 0.00896931f, 0.00793137f, 
    0.00139495f, 0.00085689f, 0.04149796f, -0.01799515f, 0.03209675f, -0.01922310f, -0.03369621f, -0.03521198f, 
    -0.01349061f, -0.02770702f, -0.06135676f, 0.04789545f, -0.05606341f, -0.02286517f, -0.01010444f, -0.05421654f, 
    -0.01029824f, -0.04495646f, 0.01221463f, -0.05160638f, -0.05113691f, -0.00207977f, 0.05092446f, 0.03513728f, 
    0.01699467f, 0.04302105f, -0.01456941f, -0.00064477f, -0.04507972f, 0.00904097f, -0.02884576f, -0.02973136f, 
    -0.04478555f, -0.02181490f, 0.02314620f, 0.02727816f, -0.01186287f, 0.01807413f, 0.03204080f, 0.00748378f, 
    0.00415417f, -0.03182890f, 0.02843704f, -0.04971371f, 0.01971731f, 0.02611294f, -0.04160955f, -0.00968887f, 
    0.04501726f, -0.02320967f, 0.04543810f, 0.00412727f, -0.04832484f, 0.04419276f, 0.04617944f, -0.03110399f, 
    0.01828401f, 0.04234072f, 0.00274732f, -0.03936452f, -0.00782089f, 0.01343875f, -0.02133863f, -0.04318608f, 
    0.01830847f, -0.05411861f, 0.02101152f, 0.04331015f, 0.00164161f, -0.04768237f, -0.02836759f, -0.03278868f, 
    0.03963701f, -0.01399020f, -0.01682488f, -0.00768189f, -0.01862589f, -0.00267582f, 0.03880905f, 0.03908283f, 
    0.00196108f, -0.03297205f, -0.02324697f, -0.00571903f, 0.03620560f, -0.06079536f, -0.01301422f, -0.03642949f, 
    0.03318826f, -0.02815144f, 0.01254279f, -0.00992279f, 0.04867469f, 0.02201574f, -0.00360004f, 0.00576316f, 
    -0.04870845f, -0.01052367f, -0.01097266f, 0.02973836f, 0.03455482f, 0.02993801f, 0.00132431f, 0.00804311f, 
    0.03116809f, -0.04545650f, -0.03915972f, 0.04699232f, -0.04410640f, -0.05378638f, 0.00866760f, 0.03739912f, 
    -0.05617837f, 0.00912423f, 0.01465260f, -0.02038649f, -0.01424542f, 0.04061260f, 0.02894720f, -0.04361505f, 
    -0.04317585f, -0.00705282f, 0.00441998f, 0.03207330f, -0.00184047f, -0.02640551f, -0.03795789f, 0.03512041f, 
    -0.02326494f, 0.01307595f, -0.03405278f, -0.03277148f, 0.02134824f, -0.00729147f, 0.00538664f, 0.00769227f, 
    -0.00688088f, -0.05170931f, -0.05764429f, -0.01086907f, 0.04004185f, 0.00223702f, -0.05054667f, -0.00736347f, 
    -0.04414014f, 0.02888604f, 0.02761893f, -0.04751924f, -0.01397464f, -0.05349572f, -0.05232663f, -0.00037542f, 
    -0.03437445f, -0.03974284f, -0.05764846f, -0.04472546f, -0.04384891f, -0.06004173f, 0.02704779f, -0.02915500f, 
    -0.05237887f, -0.01203251f, -0.05009496f, -0.00978281f, -0.05890682f, 0.01332426f, -0.03719278f, 0.04500689f, 
    -0.03993351f, -0.01296241f, 0.03185392f, -0.02416958f, 0.03046517f, -0.02890483f, -0.02877945f, 0.02347400f, 
    -0.05350237f, 0.00628996f, -0.01042684f, 0.02349480f, -0.04109592f, 0.01426004f, 0.02253278f, -0.03020508f, 
    -0.05000795f, 0.02785392f, -0.04153488f, -0.02957142f, -0.02481431f, 0.04572869f, -0.02687466f, -0.02208621f, 
    -0.02553472f, 0.02656320f, 0.04528462f, -0.02027379f, -0.01299488f, 0.01411642f, -0.00314763f, -0.03724939f, 
    0.01431446f, -0.00704230f, -0.00098706f, 0.01651973f, 0.04187070f, 0.03009551f, 0.03051772f, 0.04471161f, 
    -0.06408529f, 0.03092775f, -0.01865890f, -0.00872584f, 0.00071214f, 0.03432239f, 0.01188810f, -0.01267377f, 
    0.00095193f, -0.04570810f, -0.03780358f, -0.01427607f, -0.06000036f, -0.03351758f, -0.03254991f, 0.03056349f, 
    -0.03530501f, -0.00431269f, -0.03287995f, 0.04266613f, -0.04712970f, 0.03229892f, 0.04162135f, 0.01477272f, 
    -0.02169982f, 0.02940687f, -0.05631021f, -0.01666944f, 0.01334047f, 0.00671325f, -0.01233462f, -0.00640859f, 
    0.01914067f, -0.00416231f, -0.00387164f, 0.01306609f, 0.01198884f, -0.02378078f, -0.04638268f, 0.02421164f, 
    -0.00808607f, 0.01379272f, 0.02211784f, 0.03549811f, 0.02598997f, -0.01128485f, -0.03845003f, 0.01935451f, 
    -0.00120247f, 0.00560959f, 0.01513744f, 0.00657899f, -0.01448535f, -0.03569990f, 0.03156655f, -0.02264519f, 
    -0.01232305f, 0.00901097f, -0.00338380f, 0.01478545f, 0.04737423f, -0.03035530f, -0.05404148f, 0.02395881f, 
    -0.04582921f, 0.03682833f, -0.05183823f, 0.02697530f, -0.00934413f, -0.02945293f, -0.04607620f, -0.05911110f, 
    0.01197055f, 0.04227910f, -0.05910846f, 0.02973052f, 0.02744012f, -0.05128938f, -0.01507096f, 0.02374689f, 
    -0.03067522f, 0.00409505f, -0.05485340f, -0.03463545f, -0.03579128f, 0.03686069f, -0.00807689f, -0.01124176f, 
    0.04282961f, -0.05163748f, -0.03947684f, -0.04529902f, 0.03980007f, -0.03259946f, -0.02891166f, 0.02802884f, 
    0.03485323f, -0.03212288f, -0.03571690f, 0.01642925f, 0.04191137f, 0.00377009f, -0.00888428f, 0.03357614f, 
    -0.06033919f, 0.01280290f, -0.04001318f, -0.05801088f, 0.00453885f, -0.05348510f, 0.01736718f, -0.02341451f, 
    0.03842779f, -0.03690448f, 0.04404704f, -0.05523562f, -0.06369391f, 0.01855501f, -0.05214518f, 0.02067630f, 
    -0.00562163f, -0.01965689f, -0.01460898f, -0.04317830f, 0.00603389f, 0.03801490f, 0.04875179f, 0.00410268f, 
    -0.03512434f, 0.01181018f, 0.02047182f, 0.03455453f, 0.00003827f, 0.03599317f, -0.03004288f, -0.05676373f, 
    -0.00919109f, -0.03878486f, -0.02197144f, 0.00453185f, 0.01540484f, 0.03713496f, -0.03367204f, 0.04570897f, 
    0.00509399f, -0.02262572f, -0.00244705f, 0.04825906f, -0.01112142f, 0.02273617f, 0.00463757f, -0.04828480f, 
    -0.05723564f, 0.00103247f, 0.02240602f, -0.05684353f, -0.01469926f, 0.03312823f, 0.03408705f, 0.04471183f, 
    -0.06273409f, -0.06038348f, 0.00923186f, -0.04714203f, 0.03030556f, 0.03982582f, -0.00100323f, 0.02788467f, 
    0.01934380f, 0.03023853f, -0.01949303f, -0.00997249f, -0.03612104f, -0.02067535f, -0.00890164f, -0.02279388f, 
    -0.05652679f, -0.05543609f, -0.01987644f, 0.02005374f, -0.05287244f, 0.03805022f, -0.04139916f, -0.03897538f, 
    -0.01657369f, -0.01769344f, -0.01228694f, -0.02394213f, -0.05201668f, 0.04404868f, -0.02358463f, -0.00925821f, 
    -0.05472679f, 0.03099027f, 0.04319979f, 0.00463008f, -0.03662884f, 0.02567552f, -0.02185646f, -0.03417549f, 
    -0.01030470f, -0.01346933f, -0.06068413f, 0.01176478f, 0.02375167f, 0.03880490f, -0.03005808f, -0.01005120f, 
    0.02714778f, 0.02508882f, 0.01318178f, 0.00353664f, -0.00761132f, 0.01170474f, 0.04000516f, 0.04278680f, 
    -0.05375161f, -0.05573482f, 0.02187717f, -0.05040785f, -0.00702813f, -0.04916828f, -0.01064108f, 0.02992076f, 
    0.01969562f, -0.00372583f, -0.02061319f, -0.01727526f, -0.01854467f, 0.03588835f, 0.02392098f, 0.04545659f, 
    -0.01215755f, -0.03396865f, -0.00422014f, -0.02888382f, -0.02415174f, 0.04082068f, -0.03738931f, 0.04240795f, 
    -0.02909742f, 0.00178440f, 0.01286377f, -0.03384670f, -0.05399406f, 0.02066390f, -0.03802502f, -0.04614152f, 
    0.03317260f, -0.04323279f, -0.01226105f, -0.02015154f, -0.03969049f, 0.04536757f, 0.01977159f, -0.05568958f, 
    -0.05808616f, -0.04209012f, -0.03086574f, -0.00639565f, -0.06416714f, -0.05429064f, 0.01010497f, 0.03853701f, 
    -0.01582196f, -0.02160545f, -0.02078616f, 0.03963423f, -0.03319805f, -0.02542598f, -0.05743438f, 0.00424002f, 
    0.02786128f, -0.02121415f, -0.01565264f, -0.06347643f, -0.04557285f, -0.02295652f, 0.00538228f, 0.01118988f, 
    -0.02300631f, -0.02231256f, -0.05147610f, -0.01880604f, 0.04097183f, -0.03882795f, 0.03786854f, -0.02376411f, 
    0.01491461f, 0.03258405f, -0.00659885f, 0.00424789f, -0.03388319f, -0.00609800f, -0.05096630f, -0.02817892f, 
    0.02536932f, 0.03500644f, -0.02778954f, -0.00877327f, -0.01985671f, 0.04790233f, -0.05065010f, 0.01012947f, 
    -0.00299964f, -0.00634279f, 0.01668883f, -0.05854487f, -0.05337580f, -0.03555442f, 0.03156871f, -0.02021410f, 
    0.01381141f, 0.00369799f, -0.05636305f, 0.01359721f, 0.02689520f, -0.03660885f, 0.04216736f, 0.02036757f, 
    -0.02738693f, 0.02614073f, 0.00670497f, -0.03131253f, 0.03715905f, -0.02395961f, -0.01224862f, 0.03963636f, 
    0.01745715f, 0.04504563f, -0.03630181f, -0.00150672f, 0.01144950f, -0.02484038f, -0.05049251f, -0.02983516f, 
    0.04726946f, -0.04866585f, -0.01148040f, 0.02438558f, -0.03844714f, 0.03591584f, 0.00190041f, 0.02646397f, 
    0.01640536f, -0.04325665f, -0.04416958f, 0.02087266f, -0.03847975f, 0.01904804f, 0.04405284f, -0.06169532f, 
    0.02066775f, -0.04738938f, -0.04594484f, -0.04396755f, -0.00990415f, 0.01865734f, 0.01354696f, 0.03361451f, 
    0.01120620f, 0.03728925f, 0.02361301f, 0.00701774f, 0.02551648f, -0.00486119f, 0.04059486f, -0.06239892f, 
    -0.02281354f, 0.02197172f, -0.01893346f, 0.03713418f, -0.03617204f, 0.02251413f, -0.01440498f, 0.01979811f, 
    -0.01300792f, 0.03378841f, -0.04089247f, 0.02156434f, -0.03479213f, -0.04817029f, -0.00182440f, 0.01952047f, 
    -0.04537281f, 0.02626993f, 0.01998411f, -0.00040216f, -0.04266296f, 0.03860451f, -0.03062784f, -0.04296452f, 
    -0.02866867f, 0.00350841f, 0.00708398f, 0.00500167f, 0.02824269f, 0.01549498f, -0.01139756f, 0.01776527f, 
    0.04515045f, -0.00148877f, 0.00187775f, 0.02550211f, -0.02346560f, -0.04996039f, 0.00473754f, -0.00413339f, 
    -0.01345696f, -0.06401438f, -0.02164016f, 0.01860260f, -0.01043548f, -0.02771735f, 0.03623607f, 0.02891414f, 
    -0.00246397f, 0.01958003f, 0.04552151f, -0.03254307f, -0.02769855f, -0.00191645f, -0.04138038f, -0.03617369f, 
    -0.03987128f, -0.01287419f, -0.05144304f, -0.03745674f, -0.05560934f, 0.01294492f, 0.00544298f, -0.04558488f, 
    -0.04236711f, 0.03993198f, -0.02570137f, -0.00446416f, -0.01998644f, -0.05317578f, 0.02927436f, -0.03453023f, 
    0.00243285f, -0.01179748f, -0.02429850f, 0.01079699f, 0.00650379f, 0.02272504f, 0.05206632f, -0.03356608f, 
    -0.07001238f, -0.00246732f, 0.04165045f, 0.00729356f, -0.02690078f, -0.05690407f, 0.03878677f, -0.00921505f, 
    -0.05502491f, -0.02088483f, -0.04216950f, -0.04892435f, -0.03226739f, 0.02120095f, -0.03428031f, 0.03134275f, 
    -0.05860789f, 0.03341760f, -0.00272759f, -0.02501958f, -0.02416378f, -0.03461738f, 0.01680452f, -0.00697578f, 
    0.01214560f, -0.04959185f, 0.00350711f, 0.04111331f, -0.02788623f, 0.00467505f, -0.03109947f, -0.05919472f, 
    0.03476655f, -0.02137550f, -0.03764310f, -0.04186766f, -0.04877897f, 0.02002282f, -0.05507895f, 0.04741850f, 
    -0.03710081f, 0.00467760f, 0.02805902f, 0.01853092f, -0.04352166f, -0.00094811f, 0.00368375f, 0.01387903f, 
    -0.04160983f, -0.02905855f, 0.02116960f, -0.02501040f, -0.05886167f, -0.05276235f, 0.00733834f, 0.02319543f, 
    -0.00940379f, 0.03115832f, 0.03044887f, 0.04172614f, 0.04017733f, -0.06067063f, 0.03359057f, 0.00119854f, 
    -0.00881440f, -0.00228374f, 0.00719498f, 0.00458308f, -0.02065337f, -0.01230180f, -0.02476341f, -0.05994273f, 
    0.01563408f, -0.04228419f, -0.01201158f, 0.02919802f, 0.04154475f, -0.01740963f, -0.00643263f, -0.05506668f, 
    -0.05380844f, -0.01223943f, -0.02295537f, 0.03136846f, 0.00296658f, -0.06099850f, -0.00031208f, 0.02608823f, 
    -0.00543370f, -0.04939486f, -0.04963861f, 0.03459102f, -0.00700876f, 0.02159889f, -0.02169175f, -0.05427744f, 
    0.00140179f, -0.04639906f, 0.03142357f, 0.02278409f, -0.06058818f, -0.00968326f, 0.02853524f, -0.02377709f, 
    -0.03181305f, -0.00332607f, 0.03639053f, -0.03359872f, -0.05717198f, -0.05321930f, -0.00374809f, -0.02027168f, 
    -0.03542266f, 0.01938165f, 0.03181765f, -0.03671108f, 0.01241128f, 0.02325349f, -0.05449730f, 0.01418473f, 
    -0.05425477f, 0.00907716f, -0.00987635f, -0.05413488f, -0.03371911f, -0.00488950f, -0.05878911f, -0.02938568f, 
    -0.01194019f, -0.01767306f, 0.02475131f, -0.03981736f, 0.03571410f, 0.02730185f, 0.04142583f, 0.01683792f, 
    0.04430422f, 0.02792025f, -0.05004520f, 0.01493189f, -0.02340643f, 0.03220995f, -0.05014648f, 0.04236421f, 
    0.01105549f, 0.04652039f, 0.01147723f, 0.00075874f, -0.00733460f, 0.02248813f, -0.04477859f, 0.00252021f, 
    0.02946667f, -0.04273919f, 0.03309486f, -0.01246871f, -0.02062015f, -0.01530603f, 0.01352329f, -0.03635994f, 
    -0.03755490f, -0.05739282f, -0.04520808f, -0.05678170f, 0.00642958f, 0.02383107f, -0.01256143f, -0.03283702f, 
    -0.06423425f, -0.01602771f, -0.00262100f, 0.02766697f, -0.03302388f, -0.02410437f, 0.03602435f, -0.01747098f, 
    -0.05871576f, 0.02785318f, -0.05192379f, -0.02078558f, -0.04072816f, 0.02281213f, -0.05056580f, -0.05383347f, 
    0.02665344f, -0.01427129f, -0.04042767f, -0.05050740f, -0.03715312f, 0.00374693f, -0.02000060f, -0.03860397f, 
    -0.04271998f, -0.05540222f, -0.04875504f, -0.02066183f, 0.03494823f, -0.05206130f, -0.04799584f, -0.01963644f, 
    0.02942858f, -0.00434087f, -0.03427882f, -0.04057145f, -0.02553423f, -0.01276973f, -0.00823245f, -0.04308204f, 
    0.02205269f, -0.03079895f, -0.01972427f, -0.04204763f, -0.06015719f, -0.00246372f, -0.01330813f, -0.01083500f, 
    -0.03004560f, -0.05420208f, -0.05605195f, -0.06675655f, 0.03099645f, -0.03038202f, -0.02590931f, -0.00649686f, 
    -0.05301284f, -0.01782764f, 0.04514660f, 0.00981980f, 0.00024560f, 0.00559792f, -0.06398101f, 0.00252825f, 
    -0.00947659f, 0.01476142f, 0.00452224f, -0.02832021f, 0.01589772f, 0.03966269f, 0.00866148f, -0.01910924f, 
    -0.05074871f, 0.04402605f, -0.05320607f, 0.00823261f, 0.04197982f, 0.00287935f, -0.05856486f, 0.00151959f, 
    -0.02728467f, -0.05520628f, -0.01984442f, -0.03260655f, 0.01720459f, -0.04822729f, -0.03522157f, -0.01927614f, 
    -0.00414315f, 0.01918474f, 0.03073082f, -0.01409492f, 0.01188475f, -0.00879641f, 0.00337237f, -0.00021443f, 
    -0.00744194f, 0.03593845f, -0.03777831f, -0.04209205f, 0.03247330f, -0.00487302f, 0.04333815f, 0.00464819f, 
    -0.03518693f, 0.03856124f, -0.02616181f, -0.00426589f, -0.02314636f, -0.03881950f, -0.02683988f, -0.04252226f, 
    0.03117459f, -0.01099727f, -0.03971415f, -0.04744154f, 0.00395984f, 0.01521015f, -0.03096733f, -0.04177582f, 
    0.03275941f, 0.03524854f, -0.00650253f, -0.03543744f, -0.02484142f, 0.04379386f, 0.03876949f, 0.04130200f, 
    -0.03816745f, -0.04127610f, 0.03161610f, -0.00543154f, 0.02680305f, -0.02156958f, -0.01565374f, -0.02118106f, 
    -0.04696009f, -0.03571431f, -0.05367005f, 0.01524810f, 0.00629434f, 0.00962941f, 0.04238947f, -0.00474938f, 
    -0.04979496f, 0.00084479f, 0.03708052f, 0.02275548f, 0.01305369f, -0.00468864f, 0.03686527f, 0.00059569f, 
    0.01423185f, -0.01576737f, 0.00753268f, 0.03639311f, -0.00815077f, -0.06006726f, -0.06456444f, 0.00429074f, 
    -0.02641559f, 0.00895797f, 0.01503026f, 0.03825989f, -0.01869362f, -0.04489275f, -0.05326748f, 0.02909914f, 
    -0.05140513f, 0.00816281f, 0.01089376f, 0.03719821f, -0.06139550f, -0.05995182f, 0.02318574f, 0.00327392f, 
    -0.05713046f, 0.02003563f, -0.02963746f, -0.03525045f, -0.02370224f, 0.01051226f, 0.02422095f, -0.04928339f, 
    -0.03624297f, -0.04322424f, -0.02999054f, 0.03734962f, -0.01412877f, -0.03951849f, -0.05928270f, -0.04725572f, 
    -0.02086921f, 0.03643892f, 0.03163790f, -0.00867379f, -0.04496433f, -0.03481407f, -0.06246256f, -0.00832995f, 
    -0.04474494f, -0.03565399f, 0.03488603f, -0.01606037f, -0.00377516f, -0.04622821f, 0.01685253f, 0.01650645f, 
    0.01874875f, -0.06588153f, 0.01440419f, -0.01230474f, -0.03038949f, 0.03605564f, -0.02808540f, 0.03745394f, 
    -0.00655732f, -0.01674106f, -0.02680564f, -0.01707744f, -0.01799616f, -0.00219553f, 0.00426017f, 0.01357272f, 
    0.01663363f, 0.04142762f, 0.03258080f, 0.01012612f, -0.06209142f, -0.00265402f, -0.05420345f, -0.02504353f, 
    0.02315263f, -0.00644975f, -0.05284354f, 0.02535634f, 0.01472704f, 0.02042749f, 0.03726223f, -0.04767843f, 
    0.01322753f, 0.02044441f, 0.01377154f, -0.05537197f, -0.01867321f, -0.06457387f, -0.04987479f, 0.00847886f, 
    -0.03162347f, -0.00581113f, -0.04948381f, -0.05200309f, -0.05250623f, -0.01100807f, 0.04548455f, 0.03912632f, 
    0.04059235f, -0.04474012f, 0.03325795f, 0.03371390f, -0.05523607f, -0.04766933f, -0.02005257f, -0.00666110f, 
    -0.03029015f, 0.02831167f, -0.00892133f, 0.00354758f, 0.01678347f, 0.03792352f, 0.02577125f, 0.02631842f, 
    0.04459434f, -0.02080742f, 0.03164262f, -0.00141280f, -0.00119047f, 0.03770326f, -0.06246922f, -0.06071254f, 
    0.02967472f, -0.03228980f, 0.02262992f, 0.02162793f, 0.02242874f, 0.01536242f, 0.04397861f, -0.03292878f, 
    -0.02131623f, 0.00643853f, -0.00386130f, -0.03747166f, -0.03081808f, 0.00465807f, -0.03343139f, -0.01705262f, 
    -0.06684661f, -0.04434453f, 0.00084270f, -0.00750770f, 0.01187816f, -0.05867430f, 0.03756031f, -0.06557644f, 
    -0.00977502f, -0.03641151f, -0.06087319f, -0.01997546f, -0.04738116f, 0.01907896f, 0.01993882f, -0.00069363f, 
    -0.01338631f, 0.03585633f, -0.00879971f, -0.04767198f, -0.01356041f, 0.02052137f, -0.02078937f, -0.02827845f, 
    -0.02212700f, 0.03308536f, -0.02864820f, 0.03901758f, -0.05839781f, -0.05286582f, 0.02787498f, -0.00042391f, 
    -0.01577829f, 0.02292625f, -0.03705142f, 0.03258345f, 0.01534357f, 0.04666192f, 0.00203113f, 0.04910807f, 
    -0.04534672f, 0.03158057f, 0.04244982f, -0.05888685f, -0.06501605f, 0.01085920f, 0.00245992f, 0.01115640f, 
    0.06672498f, -0.48480439f, -0.04716308f, 0.09468573f, 0.13681929f, -0.12784189f, 0.04311446f, 0.01068435f, 
    0.03962526f, 0.15828343f, 0.22345988f, -0.07110463f, 0.04002139f, -0.01223545f, 0.16375870f, 0.12657523f, 
    -0.19678250f, -0.03990691f, -0.02123101f, -0.04854197f, 0.33143502f, 0.13213286f, 0.00007814f, 0.01059492f, 
    0.19596840f, -0.16649711f, 0.07047608f, 0.07132653f, -0.02768858f, 0.13154610f, 0.03774178f, 0.06380321f, 
    -0.08255123f, 0.04550442f, 0.02020575f, 0.05433257f, 0.09168071f, -0.07284969f, 0.04571125f, 0.16723992f, 
    0.31775069f, -0.23299603f, 0.01943519f, -0.35340488f, -0.12704086f, -0.13337676f, -0.02711949f, 0.13406065f, 
    0.04749389f, 0.04365396f, 0.13928828f, -0.01903134f, -0.03838281f, -0.05739795f, 0.10522278f, 0.13003801f, 
    -0.01093527f, -0.03148291f, -0.07779206f, 0.13897444f, -0.48575002f, -0.08862545f, -0.00175411f, -0.20690730f, 
    -0.35867906f, 0.01239737f, 0.17542997f, 0.05896689f, 0.03788571f, 0.09911373f, -0.06138024f, -0.00872222f, 
    -0.00251815f, -0.06855541f, -0.08029395f, 0.16263981f, 0.02558392f, -0.19237304f, -0.13294038f, 0.11367760f, 
    0.23932469f, 0.05071055f, 0.13404097f, 0.31124762f, -0.06272799f, -0.09638447f, 0.09175611f, 0.11357162f, 
    -0.07820117f, 0.04897815f, -0.06578390f, 0.04288165f, -0.09672579f, 0.05561519f, 0.10064049f, -0.00684021f, 
    0.11863894f, 0.19564468f, -0.05965408f, -0.05252431f, -0.11917792f, 0.13136297f, 0.06159669f, -0.12428688f, 
    -0.02074976f, 0.00854188f, 0.04406482f, 0.24206237f, 0.00230643f, -0.02319140f, -0.01137348f, 0.10575266f, 
    0.07579502f, -0.01357678f, -0.08970048f, -0.08737721f, -0.00916404f, -0.15267445f, -0.05834103f, -0.08998748f, 
    -0.18991032f, 0.12842956f, -0.32212237f, -0.09363173f, 0.10482841f, -0.10074919f, 0.08694843f, -0.10047287f, 
    0.11676078f, -0.09292732f, 0.00899370f, -0.07071204f, 0.08319636f, 0.05618358f, 0.03966811f, -0.04350394f, 
    -0.10401185f, 0.04683287f, 0.01277881f, 0.00276467f, -0.34542236f, 0.42911038f, -0.18190260f, 0.25037271f, 
    0.11547884f, -0.15637010f, -0.06829931f, 0.13372962f, 0.16305856f, 0.05520148f, 0.00740594f, 0.09601855f, 
    -0.08287247f, 0.01397939f, 0.09529301f, -0.00321061f, 0.00341161f, -0.16238369f, -0.03693167f, -0.07727580f, 
    -0.55407685f, 0.31228468f, -0.20450042f, -0.04531973f, -0.13391571f, 0.21233748f, -0.10099563f, 0.10820215f, 
    -0.11524650f, 0.06451828f, -0.03331195f, 0.04045314f, 0.19972858f, -0.04789071f, -0.00266642f, 0.01977145f, 
    -0.12695692f, -0.09343481f, 0.00234859f, -0.10482259f, 0.08928788f, -0.15981568f, 0.13592482f, 0.42769602f, 
    0.32695550f, 0.14091635f, -0.04965714f, 0.04885669f, 0.04414663f, 0.18201664f, 0.09675804f, -0.07007074f, 
    -0.10791758f, -0.05898201f, -0.03139315f, -0.02121514f, 0.04483045f, 0.19462185f, 0.11795931f, 0.08463130f, 
    0.42875138f, -0.30568922f, -0.03416236f, 0.11450557f, 0.20972380f, -0.08161852f, -0.00996086f, -0.00742302f, 
    -0.09191671f, -0.01205622f, -0.00011629f, 0.01198462f, -0.00358272f, -0.12940611f, 0.12654041f, -0.01308505f, 
    0.08378232f, -0.00312889f, -0.03420867f, 0.08513223f, -0.00964623f, 0.03393395f, 0.01899951f, 0.41948664f, 
    0.12407283f, 0.13450824f, -0.12873727f, 0.02603303f, 0.16541192f, 0.03074143f, 0.01510403f, -0.01848869f, 
    0.00519553f, 0.02765730f, 0.18899366f, 0.03475881f, -0.03585285f, 0.04422712f, 0.12911271f, 0.03806727f, 
    -0.27016968f, 0.14419764f, 0.00702864f, -0.00146213f, 0.10858279f, -0.10222884f, 0.09630039f, 0.12561257f, 
    0.12812148f, -0.00475968f, 0.03138862f, -0.05817354f, -0.03317697f, -0.03205605f, 0.00901847f, -0.11973101f, 
    0.07349988f, -0.26887003f, 0.05793849f, -0.08628286f, -0.44716272f, 0.44781348f, 0.10299072f, 0.02084036f, 
    -0.07600120f, 0.09009574f, -0.11331477f, 0.08903953f, -0.01124574f, -0.04983300f, 0.00420206f, -0.02370672f, 
    0.04619503f, 0.16484809f, -0.04396994f, 0.11117664f, -0.00770336f, 0.09035587f, 0.22176571f, -0.17168145f, 
    0.16481270f, 0.32509249f, -0.07079761f, 0.13424489f, -0.24049345f, 0.10131235f, -0.16633816f, -0.02791393f, 
    -0.06614551f, 0.13142000f, -0.08795473f, 0.17873853f, 0.00920087f, 0.12109669f, -0.03045318f, -0.08131773f, 
    0.02791045f, 0.07146189f, -0.15745279f, -0.11831933f, 0.03333727f, 0.07882533f, -0.56736350f, 0.13570385f, 
    0.01061510f, 0.08516496f, -0.17461786f, 0.06112844f, 0.18139139f, 0.04463023f, -0.03049534f, -0.02494765f, 
    0.06438089f, -0.15147237f, 0.00841615f, 0.09349876f, -0.08638798f, 0.17561300f, 0.30192956f, -0.02572643f, 
    0.46130234f, 0.24876325f, -0.01975146f, -0.21808833f, -0.15254052f, 0.17918128f, 0.11214916f, 0.15268096f, 
    0.04415159f, -0.06884837f, 0.09347533f, 0.08515634f, 0.00069223f, 0.08531930f, 0.12128117f, 0.12191065f, 
    0.19997761f, 0.02532395f, 0.03678608f, -0.01210160f, 0.09931149f, 0.40945166f, -0.30759174f, -0.15300913f, 
    -0.14731348f, 0.27809706f, 0.03625184f, -0.03047301f, 0.02571345f, -0.01644729f, -0.02334565f, 0.11017134f, 
    0.02131458f, 0.03055220f, 0.06004651f, 0.24659170f, -0.08297424f, 0.16131166f, -0.02073916f, 0.05979525f, 
    -0.31327799f, 0.11593615f, -0.11719837f, -0.21890204f, -0.27723250f, 0.25190696f, 0.06449024f, 0.07095378f, 
    -0.12697296f, 0.02386899f, -0.00081044f, -0.00883669f, -0.05989543f, -0.00198770f, 0.13252617f, -0.12032027f, 
    -0.04746036f, -0.03374527f, -0.04928505f, 0.04187219f, -0.28160053f, 0.09861285f, -0.13134384f, -0.06398749f, 
    0.10910690f, -0.02419039f, -0.09643094f, 0.10802378f, 0.12553918f, 0.09276605f, -0.24412857f, -0.06217886f, 
    0.01729379f, 0.13641831f, 0.14605470f, -0.02338844f, -0.07662726f, -0.05090734f, -0.06103346f, -0.09532622f, 
    -0.09709000f, -0.03743455f, 0.05443866f, 0.02504220f, -0.23722494f, 0.19212827f, 0.05446741f, -0.03536685f, 
    -0.01034424f, 0.07875164f, 0.08494072f, 0.11238856f, -0.05271504f, -0.04652230f, -0.11041351f, 0.16601983f, 
    0.03459360f, -0.10083059f, 0.07187741f, -0.02390676f, 0.17183085f, -0.27313221f, -0.00349866f, -0.16252354f, 
    -0.00425237f, 0.13971880f, 0.06320940f, -0.09760277f, 0.06225013f, 0.01220758f, 0.03128010f, -0.03043102f, 
    -0.03756860f, -0.10176048f, 0.12473231f, -0.08063040f, -0.08235048f, 0.11066839f, -0.15225108f, -0.08653197f, 
    0.01041462f, -0.09719680f, 0.27662697f, -0.02446576f, 0.22220631f, -0.13602751f, -0.07811882f, -0.04278624f, 
    0.00222609f, -0.00456121f, 0.04175426f, 0.01802783f, -0.06313440f, -0.02976955f, -0.09053534f, -0.12753533f, 
    -0.04922469f, -0.00715194f, -0.14489244f, 0.01471279f, 0.76828873f, -0.18562074f, -0.13509537f, 0.14299689f, 
    -0.11607713f, -0.06490918f, 0.10523921f, -0.11445437f, -0.00714785f, 0.04712481f, 0.07526648f, 0.10161014f, 
    -0.01090178f, -0.04743794f, 0.07796544f, 0.08013690f, 0.05932095f, 0.04555279f, 0.09943833f, 0.01397746f, 
    0.12477845f, 0.07376330f, 0.08008964f, -0.08147969f, 0.07633767f, -0.16925591f, 0.01630194f, -0.10403841f, 
    0.16382873f, -0.16187608f, 0.08045097f, -0.16145232f, -0.10251281f, -0.03704520f, 0.06323219f, -0.12001643f, 
    -0.00041940f, -0.06223901f, 0.00938649f, -0.00416556f, 0.03773946f, 0.40759328f, -0.16548754f, -0.41916776f, 
    0.24573223f, 0.06221711f, -0.06993414f, -0.07848687f, 0.13476655f, 0.02197472f, -0.21614332f, -0.13535947f, 
    0.03703660f, -0.02190828f, 0.16685337f, 0.18997577f, 0.10252658f, 0.05367830f, 0.06968682f, -0.04162809f, 
    -0.05172456f, 0.38551995f, -0.05017020f, -0.23329192f, -0.11413749f, 0.22648674f, 0.04444191f, 0.14997718f, 
    0.11882254f, 0.12928255f, 0.03509326f, 0.00152769f, 0.01675423f, -0.08252243f, -0.06385339f, -0.00448034f, 
    -0.01723592f, -0.03820266f, -0.03079151f, 0.00827344f, -0.19732955f, -0.23870116f, -0.22138253f, -0.25992334f, 
    0.06973666f, -0.16685545f, -0.10036259f, 0.02597079f, -0.04165668f, -0.21182178f, 0.10018572f, 0.14841847f, 
    0.04327894f, 0.02718654f, -0.06614115f, 0.13471626f, -0.05117039f, 0.03693388f, -0.04670610f, -0.10936621f, 
    0.11433525f, 0.05395364f, -0.09187981f, -0.00213236f, 0.03357262f, -0.07021613f, 0.14357735f, 0.15685679f, 
    0.07920807f, 0.03277337f, 0.17806955f, -0.00787348f, 0.09707750f, 0.01332619f, 0.08998641f, 0.03396918f, 
    0.03297263f, 0.12111244f, -0.02798244f, -0.02861492f, 0.27057633f, 0.22666006f, 0.06673551f, 0.04911130f, 
    0.09456956f, -0.06150538f, 0.01936665f, -0.09014960f, -0.09509746f, -0.09636319f, 0.01073044f, -0.06452178f, 
    0.08668688f, 0.06675943f, 0.00319048f, 0.02039682f, -0.08212964f, -0.01930302f, -0.13121204f, 0.08771315f, 
    -0.18545359f, -0.27083302f, -0.09304091f, -0.06225725f, 0.19300878f, -0.00653133f, -0.18989861f, 0.19784483f, 
    0.06001844f, 0.14995535f, 0.11784573f, 0.01916045f, -0.12602784f, 0.07341786f, 0.05108489f, 0.02743637f, 
    0.27213520f, 0.10874148f, -0.04705586f, 0.07135909f, -0.05426872f, -0.12491383f, -0.03560686f, -0.16244662f, 
    -0.20521607f, -0.15474384f, -0.02003087f, -0.03951679f, -0.12971389f, -0.28261030f, 0.13161269f, 0.12043691f, 
    0.09414180f, 0.08134734f, 0.04745306f, 0.04326507f, -0.03329911f, -0.05959160f, 0.10955966f, 0.22357340f, 
    0.04355213f, -0.03184763f, -0.01022323f, 0.04621783f, 0.00290104f, -0.04324321f, 0.03772003f, 0.00326695f, 
    -0.04319721f, -0.05540866f, 0.02097032f, -0.05233059f, -0.01959459f, 0.00957990f, 0.02136781f, 0.00211623f, 
    -0.05976363f, -0.05786329f, 0.03080069f, -0.04012972f, 0.00770830f, -0.05907623f, -0.04220145f, -0.05625425f, 
    0.00025370f, -0.03301282f, 0.00846265f, -0.00393530f, -0.05852286f, 0.01571060f, -0.02058582f, 0.03633539f, 
    0.00266450f, -0.06284756f, 0.02535835f, 0.04349596f, 0.03192350f, -0.00364102f, -0.00509727f, -0.04374245f, 
    0.03324244f, 0.01632368f, 0.01307137f, -0.02566865f, -0.00093221f, -0.00028625f, 0.04128516f, 0.04466219f, 
    -0.04470931f, -0.02513767f, 0.03665153f, -0.01984120f, -0.03060077f, 0.01488220f, 0.00497733f, 0.01352802f, 
    0.01471165f, -0.00744007f, -0.05560615f, -0.00994733f, -0.04566561f, -0.05373538f, 0.03107481f, -0.05238564f, 
    0.01126659f, 0.00530873f, 0.02533511f, -0.00388891f, 0.00264977f, 0.00300483f, 0.01397089f, -0.02964200f, 
    0.01941631f, 0.02400884f, -0.02054117f, -0.00961503f, -0.03449386f, 0.00320859f, 0.02650939f, 0.02698297f, 
    -0.02840356f, 0.04512239f, -0.03323232f, 0.03853627f, -0.05968262f, 0.00560631f, -0.03790172f, -0.06462855f, 
    0.01108953f, -0.04802931f, -0.05530905f, -0.05710965f, 0.01605002f, -0.05895152f, -0.00800762f, -0.00998631f, 
    -0.01635678f, -0.01807146f, -0.05040556f, 0.01980805f, 0.00413975f, 0.04109978f, -0.00687068f, 0.02680837f, 
    0.03843830f, -0.03475027f, -0.05890856f, 0.01164219f, 0.02937640f, 0.01746196f, 0.02947422f, 0.04618718f, 
    -0.01041409f, -0.00115088f, -0.00401731f, -0.06093383f, -0.05620543f, 0.00770848f, -0.00382139f, -0.04215861f, 
    0.02102225f, -0.02007553f, -0.01649396f, -0.01924048f, -0.02724765f, 0.01208469f, -0.02888438f, 0.03558702f, 
    0.03858780f, -0.03372460f, -0.00408843f, -0.04097316f, -0.01519892f, -0.02278069f, 0.01313968f, 0.03796247f, 
    0.04763258f, -0.00077743f, -0.02621087f, 0.00121127f, -0.05731860f, -0.02080384f, 0.01777299f, -0.04506133f, 
    0.03607963f, 0.02141584f, -0.04984048f, 0.01563350f, 0.03919413f, 0.03509057f, -0.02864500f, 0.03966823f, 
    -0.03367146f, -0.02838027f, -0.05512997f, -0.06365932f, -0.00980711f, -0.01153141f, 0.04582253f, 0.04347564f, 
    -0.02875389f, -0.06327727f, 0.03278738f, 0.00034548f, 0.02089377f, 0.00732529f, -0.00603111f, -0.05743120f, 
    -0.02737623f, 0.03139644f, -0.01387269f, 0.00078279f, -0.01944534f, -0.03696200f, -0.05392880f, -0.01131744f, 
    0.03263894f, -0.02626606f, -0.00059117f, -0.01505004f, 0.02249812f, 0.02036953f, 0.00269204f, -0.05647847f, 
    -0.05083783f, -0.04623614f, 0.02856430f, 0.04488890f, -0.03259851f, -0.00519690f, -0.00668352f, 0.04184740f, 
    0.03203509f, 0.03798022f, -0.00133988f, -0.04765931f, 0.02078362f, 0.03164821f, 0.02089493f, 0.00954808f, 
    -0.00625076f, -0.02738473f, -0.06503374f, 0.04164752f, -0.04125334f, 0.00159376f, 0.03630873f, 0.01723529f, 
    -0.06095509f, -0.03112640f, -0.04333137f, -0.05432192f, 0.00093403f, 0.02211103f, 0.02954188f, 0.00100667f, 
    0.02741520f, 0.04600822f, -0.01221943f, -0.01601249f, -0.00778581f, -0.01741326f, 0.01176600f, 0.01903310f, 
    0.01532878f, 0.00281880f, -0.02244812f, 0.02013208f, 0.01033053f, 0.00840706f, -0.02436051f, 0.03357892f, 
    -0.00670407f, -0.00903630f, -0.01538793f, -0.03187679f, 0.01882436f, -0.05794369f, -0.02223248f, -0.01303188f, 
    -0.03688912f, 0.04282004f, -0.03365295f, -0.01339179f, -0.03212244f, -0.04523185f, -0.02574859f, -0.03937429f, 
    -0.03083770f, 0.03549965f, -0.04443602f, -0.00612913f, -0.02506415f, 0.01786452f, 0.03380178f, -0.03218750f, 
    0.03622936f, -0.04623370f, 0.02263256f, -0.06519638f, -0.00462081f, -0.04138333f, 0.04170524f, 0.02089947f, 
    0.00770572f, -0.02170218f, -0.04680448f, -0.04785041f, 0.02283869f, 0.04001115f, -0.06433986f, -0.04938499f, 
    -0.00273227f, -0.00084330f, -0.04326698f, -0.02242376f, -0.05534682f, -0.04913810f, 0.00240859f, -0.05045062f, 
    -0.01339155f, -0.01602742f, -0.04435859f, -0.00600509f, -0.03985558f, -0.04216572f, -0.05595407f, -0.00671871f, 
    -0.05509091f, 0.02771473f, -0.02146490f, 0.01408940f, 0.01894221f, 0.00292758f, -0.04444986f, 0.03377426f, 
    -0.04058983f, 0.00247248f, -0.00469416f, -0.01866312f, 0.04633902f, -0.05038140f, 0.03574266f, 0.00235205f, 
    -0.03342853f, 0.00888072f, -0.05639226f, 0.04063566f, 0.03648158f, 0.02868152f, 0.03203983f, 0.00653999f, 
    -0.01188564f, 0.04600935f, -0.01191872f, 0.00645537f, 0.01910352f, -0.03345009f, -0.02939633f, 0.02381411f, 
    0.33342567f, 0.30659041f, 0.24296957f, 0.12164218f, -0.26145136f, -0.02680192f, -0.11892422f, -0.02219953f, 
    0.04295940f, -0.03792757f, -0.05660158f, -0.02242035f, 0.05551610f, -0.08311784f, -0.02189090f, -0.13738123f, 
    0.09355587f, -0.06855027f, -0.10952578f, 0.12590763f, 0.28695548f, 0.24085641f, -0.01281506f, 0.11482377f, 
    -0.30883172f, -0.09993600f, -0.16882147f, 0.01281081f, 0.11137106f, 0.03972785f, -0.11495707f, 0.02790976f, 
    -0.06617951f, 0.09543141f, 0.00444397f, -0.15417489f, 0.04759094f, -0.12176766f, -0.04385923f, 0.00818689f, 
    0.15583493f, 0.43224669f, 0.21003833f, 0.30950886f, -0.12205990f, -0.10256295f, 0.01526106f, 0.12617853f, 
    0.11516541f, 0.09417575f, 0.01511456f, -0.00642867f, -0.01855407f, -0.10907236f, 0.00405688f, -0.00782278f, 
    -0.03901673f, -0.01858862f, -0.05073914f, -0.17099635f, 0.21234877f, -0.18808834f, 0.00355763f, 0.15662190f, 
    0.24356146f, 0.10612654f, -0.02242040f, 0.12094464f, 0.01991955f, 0.09982152f, 0.03447451f, 0.06274316f, 
    0.09849954f, 0.18660262f, -0.12850519f, 0.06400049f, -0.10684739f, 0.07210699f, 0.01290879f, -0.04151772f, 
    -0.37436745f, -0.19869560f, -0.06373402f, 0.08661013f, 0.12896702f, -0.03310797f, 0.06448887f, -0.05833799f, 
    0.09058835f, -0.01767024f, 0.05178377f, 0.06469267f, 0.08132106f, 0.01858587f, -0.04194086f, -0.08539610f, 
    -0.15024631f, -0.07395799f, -0.13120516f, -0.03039648f, -0.32473639f, -0.19482523f, -0.03642090f, 0.08367728f, 
    -0.09699304f, 0.02275338f, 0.16531070f, -0.10728417f, -0.03403961f, 0.08392514f, -0.03293977f, 0.05873551f, 
    -0.01228569f, -0.07216333f, -0.00101430f, 0.03505175f, -0.00595574f, 0.12865029f, -0.16724105f, -0.01899504f, 
    -0.02567271f, 0.09803928f, -0.01951485f, 0.24629129f, -0.01267520f, 0.17932054f, 0.12159034f, 0.19476146f, 
    -0.24472351f, 0.03882204f, -0.05696998f, 0.18038189f, 0.06196405f, 0.22853652f, 0.02688296f, 0.04572763f, 
    -0.02509565f, -0.17275390f, 0.06443670f, -0.06060414f, 0.31008098f, -0.22159660f, 0.20645703f, -0.17873278f, 
    -0.12404447f, 0.02343579f, -0.02274837f, -0.04266236f, 0.00905935f, 0.01652739f, 0.05545801f, -0.06946620f, 
    -0.02843341f, 0.10899592f, -0.07624668f, -0.08361096f, -0.01305984f, 0.05308710f, -0.08200347f, -0.06649319f, 
    0.11883873f, -0.16589746f, 0.00605226f, 0.12580311f, 0.08221596f, 0.19028674f, 0.27717718f, -0.07831774f, 
    -0.08163190f, -0.02511831f, 0.01961941f, 0.13572526f, 0.02167375f, 0.00892890f, -0.12137368f, 0.07186829f, 
    -0.04745634f, -0.02719549f, -0.11092859f, -0.04500663f, 0.17479399f, 0.04389304f, -0.12232269f, -0.06788717f, 
    0.30523732f, -0.18057710f, -0.17233722f, 0.07468131f, 0.00154631f, -0.03423166f, -0.04146050f, -0.01847200f, 
    0.10810548f, 0.13517848f, 0.16922216f, 0.07153814f, -0.08649306f, -0.15223166f, -0.11471449f, 0.11637904f, 
    -0.04480934f, 0.18549600f, 0.15780857f, 0.09822956f, -0.05773938f, -0.01180103f, -0.02055365f, 0.00645606f, 
    0.08661062f, 0.09382947f, -0.06049652f, -0.02477914f, 0.07003797f, 0.00984002f, 0.02681719f, 0.05975631f, 
    -0.01684125f, -0.02422318f, -0.02122704f, 0.08552967f, -0.08874980f, 0.12388867f, -0.23674838f, -0.32404020f, 
    0.37355372f, -0.07804319f, 0.06022010f, 0.07002158f, -0.03262950f, 0.07025950f, -0.13337849f, 0.00717336f, 
    0.05123298f, 0.05639432f, -0.04599479f, 0.01825074f, 0.01477655f, 0.00321178f, 0.17208044f, 0.09658471f, 
    0.04315934f, 0.01769942f, -0.16979994f, -0.02847496f, -0.04619745f, 0.00291010f, 0.06699295f, -0.07188816f, 
    0.05582942f, 0.06340117f, -0.00604095f, -0.03832184f, -0.12582503f, -0.02500294f, -0.03175151f, -0.00670747f, 
    -0.03181753f, 0.09920232f, -0.01660441f, -0.04738636f, 0.09207642f, -0.31974611f, -0.19879620f, -0.04136626f, 
    0.16199614f, 0.12334113f, 0.19582762f, 0.03499397f, -0.05276888f, 0.01343097f, -0.15955535f, 0.05123386f, 
    0.09291944f, -0.08619919f, 0.05398488f, -0.01978025f, 0.05684490f, 0.00741490f, -0.12799385f, 0.06572974f, 
    0.10721914f, -0.17565653f, 0.15543653f, 0.07791211f, 0.34479043f, -0.03602733f, 0.01659217f, 0.02384599f, 
    0.11553479f, -0.02700765f, -0.13588932f, -0.11216370f, -0.01553963f, -0.16814442f, -0.08528550f, 0.15966222f, 
    -0.04842056f, 0.15699865f, -0.04313542f, -0.17959517f, 0.01040822f, 0.31357530f, 0.16140549f, 0.10860919f, 
    0.48057938f, -0.00735649f, 0.13769001f, 0.04972633f, -0.05055554f, -0.00395859f, -0.09606347f, 0.06766376f, 
    0.14725424f, -0.02805634f, 0.02420933f, 0.03840575f, 0.06152404f, -0.00325992f, -0.03320338f, -0.04076207f, 
    -0.31666273f, 0.17325018f, 0.02363852f, 0.12451876f, -0.05142925f, -0.01182650f, 0.03849240f, -0.04113492f, 
    0.00503785f, 0.13249277f, 0.14732440f, -0.04698832f, -0.01705312f, 0.16583206f, -0.12768126f, 0.06595619f, 
    -0.04692035f, -0.08559034f, 0.02299885f, 0.01411266f, 0.23305658f, -0.04586733f, 0.07300861f, 0.04078680f, 
    0.09984311f, 0.09366810f, -0.02094207f, 0.17294638f, 0.05272663f, 0.01745140f, 0.09141569f, 0.07986413f, 
    -0.00941927f, 0.14155859f, 0.06332844f, 0.00088764f, 0.07372628f, -0.08881346f, 0.04015907f, -0.04268545f, 
    0.07968881f, 0.20226038f, -0.08639873f, 0.03887175f, 0.34262502f, -0.00199638f, 0.00681840f, -0.05191772f, 
    -0.00015036f, 0.15429531f, 0.08158136f, 0.05912959f, 0.07449614f, 0.06113187f, 0.04691032f, 0.01412306f, 
    0.06945369f, -0.02051769f, -0.00708433f, -0.03357897f, -0.05930704f, -0.08762541f, 0.24776059f, 0.04505812f, 
    0.07376077f, 0.19846348f, 0.04056205f, 0.06790770f, 0.02430531f, 0.23451276f, 0.09917720f, 0.05087268f, 
    0.06542179f, -0.04824516f, 0.03607469f, -0.12375130f, 0.20610410f, 0.01536372f, 0.09860079f, 0.02881198f, 
    0.20953463f, -0.23552607f, -0.08302525f, -0.15735725f, 0.05514492f, 0.11489166f, 0.04454460f, 0.07282484f, 
    0.00415996f, 0.01891980f, 0.08107145f, 0.14307542f, 0.05482305f, 0.07025760f, 0.18132941f, 0.10204018f, 
    0.13658492f, -0.05539414f, 0.06037326f, 0.10098650f, 0.31292558f, 0.00749551f, -0.03852457f, 0.05861948f, 
    0.28636870f, -0.01724631f, 0.19403256f, 0.05981190f, 0.05464968f, 0.12376487f, -0.11361291f, 0.08216891f, 
    0.04101973f, -0.00047899f, 0.14810380f, 0.05234376f, 0.03595146f, 0.09408442f, 0.03848648f, 0.11187812f, 
    0.08710160f, 0.12399787f, -0.10523770f, 0.01325686f, -0.15158881f, -0.22650811f, -0.03107681f, -0.11258652f, 
    0.01622319f, 0.00379167f, 0.14241776f, 0.05514255f, -0.13750899f, 0.08910281f, 0.02138689f, -0.00039436f, 
    0.00252479f, -0.00231305f, 0.09450421f, 0.04907247f, -0.54734278f, 0.55091727f, -0.43059212f, -0.25236943f, 
    0.31480911f, 0.05426572f, -0.00586518f, 0.16751917f, -0.03754769f, 0.01875253f, -0.03234243f, 0.05571146f, 
    0.03163482f, -0.00164885f, 0.03218150f, 0.14601728f, 0.00075912f, 0.07986701f, -0.13321233f, 0.12619072f, 
    0.37759569f, 0.08778612f, 0.05951724f, -0.04901141f, -0.05734593f, -0.07235391f, -0.07536394f, 0.06230827f, 
    0.10570151f, 0.12772194f, -0.00346102f, 0.11252935f, 0.02411683f, 0.09069878f, -0.05804246f, 0.09083954f, 
    0.15855093f, -0.01809365f, 0.02775751f, 0.11736667f, -0.18179101f, -0.18408416f, 0.26640943f, -0.04047369f, 
    -0.39010227f, 0.19187742f, 0.05894203f, 0.07361841f, -0.10803344f, -0.03060770f, 0.10668605f, 0.11376764f, 
    0.08703548f, -0.04192825f, 0.06428795f, 0.07729694f, 0.02255374f, -0.07329378f, 0.03162437f, 0.02671735f, 
    -0.06388155f, -0.17023288f, 0.23966624f, 0.00743660f, 0.34538743f, 0.01303839f, 0.01170300f, -0.00531293f, 
    -0.01146750f, -0.03482638f, 0.11967976f, 0.08489606f, 0.05618225f, 0.16358608f, 0.07189967f, 0.13930678f, 
    -0.02273370f, 0.00266076f, 0.03122505f, 0.06300965f, 0.00799925f, -0.07790278f, -0.00328324f, 0.01919441f, 
    -0.17260997f, 0.06320623f, -0.04589417f, 0.08832657f, 0.12502639f, 0.15582865f, -0.06365833f, -0.04630065f, 
    0.09432065f, 0.06417764f, -0.08221526f, 0.04697684f, -0.01675401f, -0.01988464f, -0.02119673f, 0.11095517f, 
    -0.36900893f, 0.00224358f, -0.05718785f, -0.04889032f, -0.11710948f, -0.04701311f, -0.01413978f, -0.02906190f, 
    -0.01121880f, -0.04989322f, -0.11392553f, 0.02484778f, 0.00855751f, 0.08970258f, -0.00280877f, 0.04381729f, 
    0.00054176f, 0.06711535f, 0.04997214f, 0.04191867f, 0.29117262f, -0.05856606f, -0.10165892f, -0.07644043f, 
    0.01382816f, -0.04212372f, 0.04968699f, -0.14546792f, 0.13218990f, 0.10445749f, 0.04570566f, 0.08144369f, 
    -0.02064181f, -0.00019828f, 0.15597229f, 0.01935295f, 0.11293405f, 0.05927822f, -0.05097945f, 0.13148105f, 
    0.04944786f, -0.23955327f, 0.14886455f, -0.19574673f, 0.03689954f, 0.11950752f, 0.00518421f, 0.13454281f, 
    -0.02977724f, -0.09680865f, 0.07316891f, 0.00956371f, -0.01133212f, 0.03347247f, -0.06354325f, 0.04426731f, 
    0.05119813f, 0.07563493f, -0.00281852f, 0.03115962f, 0.07976597f, 0.04568121f, -0.08152501f, -0.00716307f, 
    -0.05580062f, 0.02475534f, -0.15291703f, 0.14980048f, 0.21423820f, 0.06894253f, -0.06141748f, -0.12183082f, 
    0.14822766f, 0.12223368f, -0.15322790f, -0.06679285f, -0.00303144f, -0.00911470f, -0.01612911f, 0.00117319f, 
    0.01332123f, 0.01994946f, 0.03506512f, 0.03283474f, -0.03086121f, -0.04701126f, -0.01893123f, 0.00054610f, 
    -0.01435087f, -0.05014365f, 0.03730814f, -0.04005330f, 0.00248911f, -0.03862780f, -0.03956771f, -0.04974735f, 
    0.03137248f, 0.01351509f, 0.03760268f, 0.00794874f, -0.02640984f, 0.00929870f, 0.01338397f, 0.03873189f, 
    -0.07003220f, -0.03252826f, 0.00563252f, -0.03982963f, 0.03400984f, -0.01750327f, -0.00649450f, -0.00315359f, 
    -0.04004069f, 0.01908139f, 0.01972881f, -0.04785852f, 0.01827118f, -0.00718923f, -0.01998118f, -0.00290965f, 
    -0.01362612f, -0.02973390f, 0.01586073f, -0.00652965f, 0.02732782f, 0.04818422f, 0.02582827f, -0.06632008f, 
    0.02565747f, 0.01505708f, -0.02918630f, -0.06639393f, 0.01642702f, 0.03285943f, -0.02812519f, 0.01079426f, 
    0.02741521f, -0.01032719f, 0.01218774f, -0.03840439f, -0.05663151f, 0.01584080f, -0.03107129f, 0.03787993f, 
    -0.04863213f, -0.02828001f, -0.02624568f, -0.03548036f, -0.00247329f, -0.00434373f, -0.00289666f, -0.03943790f, 
    0.02893085f, -0.04038236f, 0.02934546f, -0.04198469f, 0.03374385f, 0.00423267f, 0.00490145f, -0.02045781f, 
    -0.03533838f, -0.03868423f, 0.02521762f, 0.03821768f, -0.03894027f, -0.01480895f, 0.04064942f, -0.00496442f, 
    -0.03611292f, 0.04759936f, -0.05036957f, -0.06205935f, 0.02815587f, 0.02497353f, -0.05899109f, -0.03116046f, 
    0.00806610f, -0.02891861f, -0.02242517f, -0.02044030f, -0.03964859f, 0.03647961f, 0.03450811f, -0.00336704f, 
    0.02055060f, -0.03779254f, 0.04070574f, -0.03119250f, -0.03456901f, -0.00143706f, 0.02421631f, -0.02730750f, 
    0.00776697f, -0.02615579f, -0.03684067f, -0.03873115f, 0.02572145f, -0.00583841f, -0.03743697f, -0.06430510f, 
    0.01219349f, 0.01727257f, -0.00189675f, 0.02407007f, 0.04403219f, -0.03105844f, -0.02806915f, -0.01200977f, 
    -0.01571229f, -0.03423809f, 0.00332992f, -0.00981581f, -0.06909987f, 0.05485040f, -0.05499534f, 0.01189294f, 
    -0.03158506f, -0.03170904f, 0.01619087f, 0.01028059f, 0.02518383f, 0.01845801f, 0.02522528f, 0.02193532f, 
    0.01570517f, -0.03273540f, -0.02298270f, 0.00224692f, -0.02171824f, 0.00383058f, -0.02923796f, -0.00057545f, 
    0.02316162f, -0.04845288f, -0.01672172f, 0.02168676f, -0.06052945f, -0.02886640f, 0.03915871f, -0.06286640f, 
    -0.05412204f, 0.01472634f, -0.01177136f, -0.04029355f, 0.01991934f, -0.01668220f, 0.01428328f, 0.01516758f, 
    -0.00247686f, 0.03083189f, -0.01223727f, -0.05451935f, -0.01985346f, -0.01082510f, -0.03472434f, 0.01041284f, 
    -0.05027990f, -0.00853561f, -0.02017303f, 0.02977365f, 0.00034989f, -0.02464174f, 0.00222565f, 0.03870865f, 
    0.02998971f, -0.00043403f, -0.03943249f, 0.02837382f, -0.03365812f, -0.03793697f, -0.02495094f, -0.06229041f, 
    0.04342533f, -0.06286642f, 0.02662186f, -0.04536922f, 0.01667305f, 0.03841921f, 0.00860135f, -0.01868622f, 
    -0.03871843f, -0.03170398f, 0.00739389f, 0.01366299f, 0.01361935f, -0.01193434f, -0.03690257f, -0.00620410f, 
    -0.06974959f, 0.01886571f, -0.06012715f, -0.01072319f, -0.01797033f, 0.00024720f, -0.00385823f, -0.02170311f, 
    -0.01900891f, 0.00884784f, 0.00151673f, -0.00382190f, 0.03480561f, -0.06171836f, -0.01554378f, 0.01132124f, 
    -0.01547363f, 0.03515526f, -0.00678659f, 0.05940053f, -0.00178149f, 0.02658788f, -0.03483123f, -0.03588229f, 
    -0.00274813f, 0.04017386f, -0.04219738f, 0.02189169f, 0.00770680f, 0.03557584f, 0.05750290f, 0.03220046f, 
    -0.03636567f, 0.00290387f, 0.02795910f, -0.05496446f, -0.03095507f, -0.04568998f, -0.05238451f, 0.00756791f, 
    -0.05080799f, -0.01845510f, -0.02035103f, 0.03297292f, -0.00792398f, -0.06515639f, -0.00118355f, 0.00981973f, 
    0.04056427f, -0.03588623f, -0.03671446f, 0.00538819f, -0.05113773f, 0.03567027f, -0.04566330f, -0.02645051f, 
    -0.01110712f, 0.01479262f, -0.00688141f, 0.03104934f, 0.01882357f, 0.03282281f, 0.02481015f, 0.02143564f, 
    0.01569081f, -0.05410471f, -0.02604183f, -0.02117258f, -0.01473949f, 0.00187292f, 0.01170846f, 0.01358701f, 
    -0.02459253f, -0.02924605f, -0.06122233f, -0.04099350f, -0.04590210f, 0.00466441f, -0.01997690f, -0.01087909f, 
    -0.04689917f, 0.03030233f, -0.01073259f, -0.02482643f, -0.02862470f, -0.00941317f, -0.02053708f, -0.00517713f, 
    -0.06914407f, -0.01470371f, 0.03205443f, 0.03298556f, 0.04344152f, -0.01345511f, -0.02387520f, 0.05506651f, 
    0.07600706f, 0.04479541f, 0.04324603f, -0.02395552f, -0.01038449f, -0.05287426f, -0.01409763f, -0.06086364f, 
    -0.01858323f, 0.06708847f, -0.06616281f, 0.03694116f, 0.02932356f, -0.04339473f, -0.02490045f, 0.04051705f, 
    -0.27944323f, 0.29143661f, 0.18442145f, 0.05095371f, -0.02903532f, 0.01918616f, -0.02055922f, -0.08809805f, 
    -0.08034310f, 0.11511829f, -0.06450330f, 0.02374853f, 0.08586499f, 0.12044118f, 0.05499054f, -0.03756079f, 
    0.12534651f, 0.09171697f, -0.11878423f, 0.02903519f, -0.29869136f, -0.16314189f, 0.32843778f, 0.16664915f, 
    -0.04098421f, -0.16291091f, -0.09797332f, -0.04373549f, -0.03913525f, 0.06707581f, 0.11446521f, -0.06565190f, 
    0.06175350f, 0.17723079f, 0.14881849f, -0.11105943f, -0.03340920f, -0.20448320f, 0.03299927f, -0.01911374f, 
    0.12071624f, 0.01177194f, 0.17837654f, 0.17647980f, 0.13234805f, -0.06251343f, 0.06479652f, -0.07262037f, 
    -0.03956579f, 0.06150634f, 0.02811533f, 0.01984022f, 0.05984563f, 0.05523447f, -0.15041687f, 0.10690958f, 
    0.07566833f, 0.19658431f, 0.20266400f, -0.08930841f, 0.21674450f, 0.24172291f, 0.06867892f, 0.13956635f, 
    0.04952938f, 0.05475371f, 0.05704371f, 0.00734196f, -0.16596875f, -0.01427155f, 0.21900281f, -0.03569844f, 
    0.02392154f, 0.07351683f, -0.01503410f, 0.02480382f, 0.02834888f, 0.07524376f, 0.01896468f, 0.01194811f, 
    -0.18892056f, -0.04672092f, 0.01745220f, -0.12956311f, -0.09117248f, -0.15588915f, -0.02439481f, -0.02142125f, 
    0.01881896f, -0.05817160f, -0.11476598f, -0.06078742f, 0.05156384f, 0.07492767f, 0.00515839f, -0.08272141f, 
    0.08973313f, -0.29080257f, 0.01460804f, 0.06659267f, -0.02006051f, 0.26286751f, -0.08958231f, 0.12475182f, 
    0.04270328f, 0.19066902f, 0.03526888f, 0.05929134f, -0.07571246f, 0.06059517f, 0.14928634f, 0.01136956f, 
    -0.12546057f, -0.02123131f, 0.04539287f, 0.05741976f, 0.09479444f, 0.28928015f, 0.09737549f, 0.00240279f, 
    -0.44386125f, 0.03944032f, -0.16203704f, -0.02095025f, 0.02218376f, 0.26342890f, 0.18708496f, 0.17004369f, 
    0.01661657f, 0.05972846f, -0.03389035f, 0.03446764f, -0.08847088f, -0.08113521f, -0.03037684f, 0.07837757f, 
    0.17063414f, 0.03353127f, 0.11307483f, 0.01189147f, -0.26374540f, -0.36156663f, 0.20011088f, -0.14571753f, 
    -0.12474414f, 0.04258756f, -0.05095822f, -0.01776546f, -0.05351348f, 0.16230270f, 0.13404743f, 0.09871375f, 
    0.00584498f, 0.06922963f, 0.04451050f, -0.00669287f, -0.04518615f, 0.16708224f, -0.10823347f, -0.04305791f, 
    -0.34826988f, 0.22620577f, -0.11865878f, -0.00915534f, 0.04141160f, 0.12408934f, 0.25432810f, 0.08285943f, 
    0.01046029f, 0.01288361f, 0.03874059f, 0.04247987f, -0.24793951f, 0.11905212f, 0.08462245f, 0.09876888f, 
    0.08323337f, 0.06679071f, 0.07249382f, 0.01632531f, -0.20833246f, -0.29973373f, 0.33154207f, 0.13996270f, 
    -0.23470071f, -0.20764092f, -0.20618744f, -0.00227253f, -0.10463930f, -0.04749477f, 0.08649414f, 0.09530957f, 
    0.11874989f, 0.21152893f, 0.14415473f, 0.09553987f, 0.00269151f, -0.10479572f, -0.21967776f, -0.01892572f, 
    -0.30900779f, 0.02271662f, 0.09386708f, 0.01419900f, -0.11505534f, -0.11482954f, 0.02817787f, -0.21908492f, 
    -0.15530989f, 0.04880727f, -0.00845609f, 0.03864257f, 0.01112222f, 0.22484851f, -0.03461912f, 0.08233254f, 
    0.11629909f, 0.05941622f, -0.00675814f, 0.04787047f, 0.08832677f, 0.14176869f, 0.06729535f, 0.06233377f, 
    0.20718293f, 0.19422720f, 0.13694540f, 0.03994406f, 0.05614034f, 0.13195686f, -0.17087230f, 0.13408735f, 
    0.12378540f, 0.09546518f, 0.13997410f, -0.17286897f, 0.09933509f, -0.11881163f, -0.07346592f, 0.12531023f, 
    0.00754201f, -0.13413344f, -0.05826192f, -0.19778401f, -0.00069090f, -0.02203696f, -0.04567489f, -0.07213109f, 
    -0.01246154f, 0.15074746f, -0.06936095f, 0.07124973f, -0.00755495f, 0.03939510f, -0.00593742f, 0.00430323f, 
    0.02408425f, 0.15378669f, -0.14008842f, 0.13113622f, -0.30191866f, -0.18975699f, -0.17447613f, -0.19404790f, 
    0.13613684f, 0.03105998f, 0.15460627f, 0.07191024f, 0.07711923f, 0.12435683f, 0.07608835f, -0.03860779f, 
    0.02586837f, -0.01461526f, -0.07501040f, -0.04870751f, -0.01960964f, -0.07845757f, -0.18681796f, -0.03707499f, 
    -0.30361483f, -0.04172689f, -0.03933822f, 0.04001854f, 0.01018339f, -0.16138558f, 0.09821672f, 0.03021219f, 
    -0.04857460f, 0.08961554f, -0.01968382f, -0.00570883f, 0.11479808f, -0.09347857f, -0.08766911f, -0.06206943f, 
    -0.00174552f, -0.06879958f, 0.08908164f, 0.03432797f, -0.54513264f, 0.02141137f, 0.18714191f, -0.02531705f, 
    0.22450998f, 0.33727205f, 0.24692062f, 0.02070434f, 0.20859659f, 0.21660315f, -0.03777713f, 0.21998055f, 
    -0.10568797f, -0.01812743f, -0.09775664f, 0.06416059f, 0.11143093f, 0.01959280f, -0.16624127f, 0.18308213f, 
    -0.43415815f, 0.33502275f, 0.07461482f, -0.08414607f, 0.03696294f, -0.21312644f, -0.06923822f, 0.06189020f, 
    0.04468587f, -0.10704388f, 0.12109062f, 0.03118573f, 0.01780525f, -0.09260677f, -0.16523275f, 0.08255403f, 
    -0.01096330f, -0.09262459f, 0.03069800f, 0.10831170f, -0.36112237f, 0.31396711f, 0.28386307f, -0.17602605f, 
    -0.15963209f, -0.02850260f, -0.01116034f, 0.10508212f, 0.09522282f, -0.06962019f, -0.00518529f, 0.06974366f, 
    0.06441130f, -0.12512660f, -0.21357107f, 0.05354154f, -0.00708028f, 0.25498983f, -0.01919328f, 0.02579594f, 
    -0.53310215f, 0.30142379f, 0.05054307f, -0.02705973f, -0.10137802f, -0.10560955f, -0.07444327f, 0.12860154f, 
    0.16886346f, -0.07872888f, -0.13117036f, 0.05174034f, -0.03408397f, 0.06912614f, 0.05071799f, -0.01317830f, 
    0.13404520f, -0.22352821f, -0.11468615f, -0.09496269f, 0.20925649f, -0.06405603f, 0.03673715f, -0.02581778f, 
    0.15860319f, 0.03606722f, 0.01500569f, 0.08111476f, 0.23064533f, 0.07045502f, -0.08656993f, -0.08150794f, 
    0.00580260f, -0.02406280f, 0.05989051f, 0.08286764f, -0.02177793f, -0.23334602f, 0.01990954f, 0.07703897f, 
    -0.05197694f, -0.29416525f, 0.18110465f, 0.00914105f, 0.17796279f, 0.03674119f, -0.06744787f, -0.13038933f, 
    -0.04770411f, 0.09713901f, -0.09452883f, 0.03450425f, -0.10965790f, -0.03302456f, -0.00475455f, -0.04924823f, 
    0.04660112f, 0.41445380f, 0.04812190f, -0.09147732f, 0.56696874f, -0.18319166f, 0.11162920f, 0.07165145f, 
    0.03753035f, 0.00246617f, 0.00132034f, 0.06769176f, 0.03023503f, 0.04672921f, 0.07193484f, -0.05471482f, 
    -0.00707518f, 0.10585103f, 0.04206500f, -0.02600734f, -0.08703913f, -0.21359858f, -0.03916007f, -0.12285151f, 
    0.22709204f, -0.07761203f, -0.11252829f, 0.11329084f, 0.05408442f, 0.09417018f, 0.08503660f, -0.19234495f, 
    0.13353854f, 0.14371851f, 0.06416801f, 0.06088398f, -0.13959961f, 0.18568170f, 0.04413445f, 0.08598141f, 
    0.14674719f, -0.04554968f, 0.04857378f, -0.10343096f, 0.17332938f, -0.00907797f, 0.11953590f, 0.04613190f, 
    -0.05621447f, 0.22333837f, -0.00306362f, 0.08929965f, -0.18152490f, -0.00209794f, -0.09620313f, -0.06364868f, 
    0.01272437f, -0.14459631f, -0.02373078f, 0.00691003f, 0.06208129f, -0.06086799f, 0.02281759f, -0.10656159f, 
    0.51340866f, -0.20243353f, 0.24772500f, -0.10421660f, 0.19552618f, -0.04928296f, 0.10505646f, -0.09592355f, 
    0.12860133f, 0.06873631f, 0.02711446f, 0.09116875f, 0.11888790f, 0.07450428f, -0.05785421f, -0.05293581f, 
    0.02717020f, 0.00332923f, -0.10958612f, 0.01454213f, 0.27738306f, 0.13213339f, 0.03296913f, 0.09909523f, 
    -0.33156899f, -0.08524610f, 0.07058049f, 0.00359867f, -0.00252013f, 0.11749692f, -0.20964295f, 0.06098112f, 
    -0.06027010f, -0.05032481f, -0.06129922f, 0.03753653f, -0.24410124f, 0.06011806f, 0.26642403f, -0.08836348f, 
    -0.11183707f, -0.07811526f, 0.14300577f, -0.09017630f, -0.07872196f, -0.15262260f, 0.06528210f, 0.15063551f, 
    0.05135922f, -0.10202116f, -0.15940520f, -0.00643264f, 0.15411520f, -0.13189673f, 0.01644312f, -0.05240754f, 
    -0.04196549f, -0.00053909f, -0.10033971f, -0.05004400f, -0.02399704f, -0.40019947f, 0.04111755f, 0.15188028f, 
    -0.03625702f, 0.06494661f, 0.10871927f, -0.06593697f, -0.08368810f, 0.08542637f, 0.03990986f, 0.00152922f, 
    -0.11164447f, -0.15809165f, -0.09367790f, 0.18783019f, -0.02117050f, 0.10497992f, 0.16123819f, 0.07255418f, 
    0.46718061f, -0.18082048f, -0.03833510f, 0.29673287f, -0.21773908f, -0.09795631f, -0.02015242f, 0.04476049f, 
    0.04183927f, -0.05976696f, 0.12963431f, -0.05723752f, 0.14122325f, -0.01271710f, -0.04982522f, 0.07822820f, 
    0.07596448f, -0.08293901f, 0.34471419f, 0.02775467f, 0.37577844f, 0.16403201f, 0.18519962f, -0.06678963f, 
    0.10675167f, 0.04225654f, 0.19010523f, -0.07680006f, 0.06993771f, -0.07020512f, -0.07057035f, -0.04062612f, 
    0.03096247f, 0.22193992f, 0.03367604f, 0.03970389f, 0.09005748f, 0.19164485f, 0.04092076f, 0.12791887f, 
    0.26924995f, -0.15741974f, 0.20124279f, -0.07313235f, 0.10776950f, 0.04942593f, 0.24241476f, -0.00730209f, 
    -0.00912500f, -0.03905330f, -0.12563004f, -0.08351846f, -0.13162042f, -0.02574252f, 0.04325329f, 0.03526460f, 
    0.02635524f, 0.21161440f, 0.02798304f, -0.06462558f, 0.41519782f, -0.15920578f, -0.00697623f, 0.17332405f, 
    0.07810951f, -0.07727792f, -0.00058893f, 0.03399308f, 0.03000865f, -0.01447586f, 0.00580573f, -0.15874758f, 
    0.09427852f, -0.11829214f, 0.02745263f, -0.05987223f, -0.07607307f, -0.01566900f, 0.21631785f, 0.03580260f, 
    0.39438424f, -0.21314377f, 0.22835580f, -0.11328582f, 0.01820652f, 0.06363691f, 0.15567692f, 0.06202827f, 
    -0.06965866f, 0.15047616f, -0.11077317f, 0.04916989f, 0.02709299f, -0.09197501f, 0.22632198f, 0.08434188f, 
    0.07849123f, 0.06841404f, -0.01112822f, 0.02674982f, 0.07370227f, -0.01001812f, 0.16440032f, 0.05637858f, 
    0.06789225f, -0.04866022f, 0.04874780f, -0.05130889f, -0.01911639f, 0.14380157f, -0.05907784f, -0.01615922f, 
    -0.04288775f, 0.02890603f, 0.02416295f, -0.03324894f, 0.00423156f, -0.06910728f, -0.03096861f, 0.12008177f, 
    0.16654299f, -0.27710515f, 0.18753007f, -0.18803312f, -0.27382654f, 0.03626403f, 0.06597098f, 0.05189031f, 
    0.01682114f, 0.05025022f, 0.03969218f, -0.01075291f, -0.04571347f, -0.10035629f, -0.04882519f, 0.12706600f, 
    -0.08149772f, 0.07637534f, 0.01644310f, 0.19535851f, -0.06165683f, 0.20842525f, -0.17636001f, -0.10829513f, 
    -0.26730567f, -0.07037795f, 0.03155263f, 0.06703126f, 0.03409427f, -0.14719075f, -0.03303038f, -0.02098247f, 
    -0.00501726f, 0.00225642f, -0.08855839f, 0.17056952f, -0.02185931f, -0.09430286f, -0.08752433f, -0.01278868f, 
    -0.18413486f, 0.11965316f, 0.17896220f, 0.18289235f, -0.02905607f, -0.11934739f, -0.01122669f, 0.11776930f, 
    0.00477948f, 0.06870884f, -0.06468799f, -0.11445525f, -0.02338369f, 0.01750081f, -0.01620498f, -0.01392441f, 
    -0.00109952f, -0.10619170f, 0.04102525f, -0.14596571f, -0.30488348f, 0.09776362f, 0.15504615f, -0.06504656f, 
    -0.15754792f, 0.16087294f, -0.00481750f, 0.05286526f, -0.02209206f, -0.17040488f, 0.03454537f, 0.01605802f, 
    0.04643605f, 0.02791495f, -0.05216462f, 0.01573975f, 0.02793846f, -0.01066170f, 0.02765785f, -0.05657468f, 
    -0.22741352f, 0.10691956f, -0.16306709f, 0.05746258f, 0.18222800f, 0.21474282f, 0.14754903f, 0.13134938f, 
    0.10743493f, -0.04564913f, -0.00130796f, -0.06128098f, 0.15153730f, -0.07725192f, -0.06711315f, -0.05419304f, 
    -0.01194705f, 0.04936004f, 0.02524543f, 0.06031670f, 0.38826248f, -0.29331294f, 0.18770036f, 0.33307672f, 
    -0.27869526f, -0.20475554f, 0.04193986f, -0.05131371f, 0.09766233f, 0.05142252f, 0.09804298f, 0.02171327f, 
    -0.02155840f, 0.09039009f, 0.11204089f, -0.04542509f, -0.03474142f, -0.01429456f, 0.03927444f, -0.00508509f, 
    -0.62378347f, 0.26575109f, -0.20721796f, 0.09366129f, 0.05827092f, 0.20224923f, 0.01841896f, 0.03279193f, 
    -0.13125516f, -0.10868226f, 0.09226064f, 0.03090702f, 0.02431682f, -0.08028232f, 0.00738467f, 0.01035901f, 
    -0.04796347f, -0.00843404f, 0.11282746f, -0.10361807f, 0.09754337f, 0.01387854f, -0.12771940f, 0.13318643f, 
    0.27825704f, -0.08251597f, -0.13526292f, 0.00910070f, 0.10878024f, 0.00098223f, 0.02303741f, -0.10846464f, 
    0.04423689f, 0.08151037f, 0.05582520f, -0.04675073f, 0.06030685f, 0.12916209f, -0.04583468f, -0.00746291f, 
    0.12433523f, 0.07048788f, -0.03378415f, 0.01341679f, -0.17014492f, 0.02620488f, -0.09260003f, -0.06110095f, 
    -0.06520549f, 0.15311334f, -0.04519933f, -0.09092343f, -0.09905789f, -0.08175410f, 0.04167538f, 0.01461673f, 
    0.07061120f, 0.01376803f, -0.03295482f, 0.04753816f, 0.04370375f, -0.00668357f, -0.05803939f, 0.29369146f, 
    0.26935613f, -0.02782461f, 0.00935551f, 0.01935026f, 0.05066738f, -0.11740074f, 0.09273577f, 0.07495636f, 
    0.05548194f, 0.06179920f, 0.19564062f, -0.09389131f, 0.11754322f, -0.01807075f, 0.08625173f, 0.02629570f, 
    0.06991131f, 0.18256098f, -0.06091259f, -0.02160757f, 0.13385074f, -0.06040490f, 0.09199013f, 0.02516060f, 
    0.11030269f, 0.15704991f, 0.07978416f, 0.07364431f, -0.02345553f, -0.05265267f, 0.02415792f, -0.00337762f, 
    0.00728865f, -0.08225895f, -0.05293201f, 0.02890384f, -0.39554557f, 0.20895392f, 0.05779796f, 0.08082084f, 
    -0.00201526f, 0.16071510f, -0.12163354f, -0.02007698f, 0.01096476f, -0.05140859f, 0.00253317f, -0.02040778f, 
    0.09605470f, -0.06118042f, -0.17279722f, -0.02939558f, -0.02854944f, -0.11132983f, 0.01635769f, -0.18074864f, 
    -0.10139503f, 0.22443399f, -0.20416972f, 0.17874014f, -0.09841280f, -0.05417215f, -0.08900157f, -0.00925513f, 
    0.07746724f, 0.16405663f, -0.07417387f, 0.14194234f, 0.02883144f, 0.01236875f, 0.06984478f, -0.04662586f, 
    0.04658125f, -0.06692357f, 0.01407869f, 0.04549693f, -0.18265519f, -0.09584592f, -0.22878157f, 0.10932362f, 
    0.10320391f, 0.10223237f, 0.15785253f, -0.04373530f, 0.00369048f, -0.05054962f, 0.03781706f, 0.21090601f, 
    -0.05214207f, -0.00856148f, 0.00544546f, 0.14689417f, -0.01943851f, 0.11047157f, 0.03425307f, -0.02592100f, 
    0.15973242f, -0.36001635f, -0.15978031f, -0.15009427f, -0.16288589f, 0.04650667f, -0.05273418f, 0.03158092f, 
    -0.05225257f, 0.01035163f, -0.06751558f, -0.02799629f, -0.01282252f, -0.04595521f, 0.03865569f, -0.02548636f, 
    -0.10511237f, 0.01728441f, 0.08987628f, 0.06779707f, -0.04994984f, -0.20924976f, 0.04330813f, -0.15553083f, 
    0.24279581f, -0.07396687f, 0.15752999f, -0.17333399f, 0.18081214f, -0.02348870f, 0.15017302f, -0.04370546f, 
    -0.03358957f, 0.00752852f, 0.00661672f, 0.06650218f, 0.06090244f, 0.04528316f, -0.03951709f, -0.09782168f, 
    0.35058391f, -0.32204756f, -0.20383160f, -0.27920496f, 0.13734730f, 0.15921891f, -0.07960840f, -0.16962647f, 
    -0.04903686f, -0.02812799f, 0.02419386f, -0.09110033f, -0.02307861f, -0.07164819f, 0.02148844f, 0.03769178f, 
    0.14196685f, -0.04688966f, -0.04099205f, 0.17522678f, 0.40541190f, -0.35613841f, -0.15629806f, -0.05667486f, 
    -0.27734643f, -0.08672702f, 0.07555855f, 0.10578663f, -0.09111702f, 0.00620042f, -0.02085966f, 0.07690956f, 
    0.10319046f, -0.09897329f, -0.14716339f, 0.16513881f, 0.05923976f, 0.10588948f, 0.11713040f, 0.12227121f, 
    0.21833013f, 0.30227149f, -0.06483398f, 0.00264472f, 0.57131869f, 0.00985237f, 0.00378607f, 0.02038842f, 
    -0.04137680f, -0.02870815f, 0.02303573f, 0.12563670f, 0.09375022f, -0.00192497f, -0.01996057f, -0.01737445f, 
    0.03545872f, -0.01651764f, 0.08524094f, -0.05269019f, -0.38194886f, 0.05569487f, 0.15008378f, -0.19902450f, 
    0.03724434f, 0.09366792f, 0.10537902f, 0.06721154f, -0.16791345f, 0.01826063f, -0.04589838f, 0.09467924f, 
    -0.05458346f, 0.02003642f, 0.06250028f, -0.04465245f, 0.14046380f, -0.02290641f, 0.10957488f, -0.02034344f, 
    0.23615922f, 0.29622063f, 0.16906372f, 0.18949877f, -0.38909975f, 0.02398985f, -0.03189266f, 0.14353037f, 
    0.04262513f, -0.17160170f, -0.06695485f, -0.00907081f, 0.08677944f, -0.07582878f, 0.00303939f, -0.00396693f, 
    -0.00222523f, 0.08182736f, 0.01032257f, 0.11747389f, -0.39378288f, -0.06207925f, 0.32681254f, -0.07603251f, 
    0.61766773f, 0.06283548f, 0.09923315f, -0.12776878f, 0.05868943f, 0.14423414f, 0.01346545f, -0.08204815f, 
    0.07530081f, 0.02169011f, 0.00761037f, 0.12296519f, 0.06976437f, 0.04080411f, -0.01301601f, 0.18035506f, 
    0.21711421f, -0.05654508f, -0.00614991f, 0.06003328f, -0.34001949f, 0.07507636f, 0.00853168f, 0.06815690f, 
    0.02731992f, 0.14167590f, -0.06168701f, 0.12918596f, 0.03479989f, 0.01371502f, -0.15318450f, -0.05937731f, 
    -0.03690915f, 0.04058110f, -0.03982776f, 0.07897986f, 0.25930253f, -0.06473414f, -0.11450530f, 0.09205928f, 
    0.04393656f, 0.12112336f, 0.00265654f, -0.02941215f, -0.03086068f, 0.09551253f, -0.08621445f, 0.13590211f, 
    0.09468142f, 0.07154035f, 0.01213242f, -0.09210446f, 0.04031257f, 0.03436301f, 0.05513684f, 0.08808798f, 
    0.15965796f, -0.15065371f, 0.00191780f, 0.05186496f, 0.25563234f, 0.06083654f, 0.02616577f, -0.08062783f, 
    0.06518863f, -0.01836806f, 0.07022437f, 0.01419479f, 0.00282161f, -0.04034291f, 0.01126447f, -0.05104281f, 
    0.11390954f, -0.02745315f, 0.01063984f, 0.00900680f, 0.13189493f, -0.15587918f, 0.30526760f, 0.18912880f, 
    0.07991675f, -0.09069438f, -0.06774063f, 0.10325327f, -0.05012950f, 0.10244296f, 0.10282660f, -0.25713256f, 
    -0.18772782f, -0.04765499f, -0.11656498f, 0.29232651f, 0.06847575f, -0.01974594f, -0.04998816f, 0.12747233f, 
    -0.29576042f, 0.29968795f, 0.18422678f, 0.09473463f, 0.36378604f, 0.06489762f, -0.00128686f, -0.06442925f, 
    -0.03732825f, 0.12614474f, 0.05314871f, 0.07119914f, 0.02712663f, 0.07275117f, 0.05231389f, -0.03341893f, 
    0.04671047f, 0.06861679f, -0.02551150f, 0.10971253f, 0.22446400f, 0.31033838f, 0.20504329f, 0.16964370f, 
    -0.28243345f, -0.00867832f, -0.01015764f, 0.01412926f, -0.02416944f, 0.19132268f, -0.11743698f, 0.11194625f, 
    -0.21345569f, -0.11297928f, 0.05406624f, -0.02828238f, 0.08982435f, 0.10463574f, 0.05358008f, -0.08337437f, 
    0.11202823f, 0.12528284f, 0.05708389f, 0.21707603f, -0.00450874f, 0.19862790f, 0.11216452f, -0.03474782f, 
    0.15666613f, -0.02448050f, 0.08797133f, 0.02639016f, 0.05267797f, 0.03887306f, 0.15419278f, 0.04750072f, 
    -0.10481358f, -0.10882411f, -0.13282347f, 0.12124119f, 0.20492810f, -0.01581296f, 0.24620646f, 0.12060226f, 
    -0.10782147f, -0.19789815f, -0.01152686f, -0.00665720f, 0.00657883f, 0.06986616f, -0.11455170f, -0.25116965f, 
    -0.06301069f, 0.11143611f, 0.05511578f, 0.02700022f, -0.07880447f, -0.13059534f, 0.03729428f, -0.07002945f, 
    0.35393989f, 0.06319726f, -0.10995682f, 0.08094498f, -0.01456606f, 0.01204337f, 0.10196815f, 0.10190029f, 
    -0.03351220f, -0.19980197f, -0.22077826f, 0.11801371f, -0.03731773f, -0.12179367f, 0.04208581f, -0.01470296f, 
    0.07423095f, -0.00491554f, 0.05273964f, -0.08072715f, 0.01147623f, -0.05742781f, -0.24355568f, -0.04348477f, 
    -0.02926660f, 0.11925241f, 0.10778666f, 0.00259957f, 0.01797411f, -0.06617057f, -0.07109217f, 0.00510162f, 
    -0.06128110f, -0.09289133f, -0.06753896f, -0.02120758f, 0.02760694f, 0.04537868f, -0.03475523f, -0.11090506f, 
    0.11011770f, -0.09316973f, -0.14893399f, 0.16220769f, -0.24514034f, 0.01023807f, 0.19272505f, 0.16065262f, 
    -0.00080697f, -0.22722788f, -0.08964167f, 0.00725032f, -0.03925294f, 0.02994633f, 0.03481347f, 0.00103220f, 
    -0.07979856f, -0.04415640f, 0.03967037f, -0.10810073f, 0.47471523f, -0.13148120f, -0.24246913f, 0.03741873f, 
    0.15535869f, -0.05991717f, 0.08442536f, -0.05028686f, -0.01257727f, -0.09989939f, -0.00144099f, 0.01436825f, 
    0.01303257f, 0.06663368f, -0.14457166f, -0.05741923f, 0.04915889f, 0.05902318f, -0.01094857f, 0.10019498f, 
    -0.19856881f, 0.30703828f, -0.12632877f, -0.00686155f, 0.05231676f, 0.08337084f, 0.01106370f, -0.15405062f, 
    0.06245383f, -0.03929325f, -0.03754673f, 0.01633769f, 0.01707433f, -0.04078055f, -0.20451848f, -0.04084405f, 
    -0.09867664f, 0.05368864f, 0.13528277f, 0.13406129f, -0.36333805f, -0.14868374f, 0.00144395f, -0.01317371f, 
    -0.18588482f, -0.12515725f, -0.10573629f, -0.21266118f, 0.02349367f, -0.10327986f, 0.12928429f, -0.03588545f, 
    -0.07662423f, -0.01647063f, -0.00339239f, 0.05716249f, -0.01143050f, -0.10083380f, 0.06802474f, -0.04324622f, 
    0.22855578f, -0.04892116f, 0.16592517f, 0.15691134f, -0.03289448f, -0.01446616f, -0.17245844f, 0.20046370f, 
    -0.18665406f, 0.25949728f, -0.09619836f, -0.08551154f, 0.18792804f, 0.12569974f, 0.05610193f, -0.08845147f, 
    -0.00103814f, -0.06473678f, -0.11479854f, -0.11842270f, 0.53156972f, -0.32543278f, 0.26165375f, -0.06264950f, 
    -0.04001632f, 0.08768495f, 0.02592247f, -0.09018977f, -0.01539435f, -0.22089456f, 0.05997853f, -0.21073994f, 
    0.19354591f, 0.12486085f, -0.08148070f, 0.09331339f, 0.05125651f, 0.01125191f, 0.07388881f, -0.06671502f, 
    0.26232845f, -0.30080089f, 0.10503619f, 0.07945773f, -0.04892924f, -0.05246735f, 0.05822195f, -0.09258293f, 
    0.02919567f, 0.03482854f, 0.01773008f, 0.02560658f, 0.04889141f, 0.06360553f, 0.18323660f, -0.06911849f, 
    -0.00850637f, -0.03716305f, -0.06845422f, 0.00157244f, 0.07064401f, 0.32092732f, -0.30137482f, -0.19931805f, 
    0.23328695f, 0.04892645f, 0.11519232f, -0.01694847f, -0.05142041f, -0.09668763f, -0.07496811f, -0.07487088f, 
    -0.01358084f, -0.00799117f, -0.00431671f, -0.02289582f, 0.08946422f, 0.03899492f, 0.07005329f, 0.01907331f, 
    0.22335656f, 0.13571154f, -0.20668727f, 0.05537994f, -0.20057240f, 0.06079087f, 0.05431096f, 0.12682407f, 
    0.15436962f, 0.07106996f, 0.01194660f, -0.09216850f, -0.01888122f, 0.04064399f, -0.11357020f, -0.07309707f, 
    0.06448738f, -0.13915962f, 0.07668719f, -0.04593378f, -0.14825639f, 0.29122671f, 0.11070721f, -0.22317030f, 
    0.01525900f, -0.22784406f, 0.01051203f, -0.01122623f, -0.10906808f, 0.03352732f, -0.05607857f, -0.02925341f, 
    -0.05863274f, -0.01957191f, -0.06557509f, 0.11389283f, 0.09582038f, 0.22286642f, 0.14215612f, 0.03083931f, 
    0.27549776f, 0.04776523f, 0.22502561f, 0.03989237f, 0.07004042f, 0.25848842f, 0.08383135f, -0.04375204f, 
    -0.08288966f, 0.04582885f, 0.07793691f, -0.11344165f, 0.07296041f, 0.00532775f, -0.01125323f, 0.12705296f, 
    0.01944056f, -0.01872982f, 0.13100252f, -0.11642217f, 0.13686390f, -0.16860476f, 0.06253369f, 0.22407429f, 
    -0.01976457f, 0.03376793f, -0.04300091f, 0.03725555f, -0.04339501f, 0.15730225f, -0.07926413f, -0.00950276f, 
    0.02713048f, -0.02824909f, 0.01480705f, 0.05554922f, -0.06451597f, -0.01609371f, 0.16261703f, 0.09234612f, 
    0.04015281f, 0.20686057f, -0.01809324f, 0.08071201f, 0.07437735f, 0.05671489f, 0.03926244f, -0.04991293f, 
    0.17168449f, -0.00803513f, 0.01582659f, -0.01210035f, -0.06894436f, 0.12959456f, 0.06693785f, 0.09959508f, 
    -0.12630640f, 0.12199066f, 0.02524320f, 0.19189948f, 0.06077420f, -0.01165073f, 0.29502314f, 0.10004599f, 
    -0.02550261f, -0.22187872f, 0.06499585f, -0.03850473f, -0.23608634f, 0.00552756f, -0.01351160f, 0.03775669f, 
    -0.04103058f, -0.04637700f, 0.29268065f, -0.03944579f, 0.05180497f, 0.12897488f, -0.08686887f, -0.06589222f, 
    0.02465293f, -0.00970663f, -0.01557483f, 0.05402541f, -0.05105992f, -0.05542890f, 0.00971145f, -0.01240100f, 
    -0.04834301f, 0.02131774f, -0.03472815f, 0.04529527f, -0.05818668f, -0.02134095f, 0.02174000f, 0.02748761f, 
    0.03364827f, -0.04992529f, -0.02669812f, 0.01643767f, 0.03329957f, -0.02266258f, -0.04970833f, -0.03487736f, 
    -0.04206432f, -0.01986421f, -0.00509210f, 0.04322491f, 0.03602887f, -0.04404939f, 0.00538024f, -0.01788388f, 
    0.04320493f, -0.00728422f, -0.00204254f, -0.04030476f, -0.06188950f, 0.01348412f, -0.02484528f, -0.05638647f, 
    -0.02835602f, -0.05153340f, -0.03917699f, 0.05343781f, -0.01389810f, -0.00791301f, -0.02534212f, 0.04122546f, 
    0.02377197f, 0.00727740f, -0.02038557f, 0.04638138f, -0.01873140f, 0.00562979f, -0.01930400f, 0.03565253f, 
    -0.06281335f, 0.01316216f, -0.05768243f, 0.00943319f, -0.02710997f, -0.04927249f, 0.04176445f, -0.02568202f, 
    0.03206998f, -0.02936870f, -0.00901721f, 0.03605520f, 0.04530780f, 0.04048080f, -0.02881425f, 0.00854111f, 
    -0.00612723f, 0.00916185f, 0.02283784f, -0.03869859f, 0.04274573f, -0.03222953f, -0.00655910f, 0.03361623f, 
    -0.04284444f, 0.01620863f, 0.03925850f, 0.03050552f, -0.04186089f, 0.00366322f, 0.01888153f, -0.05234161f, 
    0.00775586f, -0.04099042f, -0.01151592f, -0.01322779f, 0.00271923f, -0.00342852f, -0.01102533f, -0.00002814f, 
    0.02211878f, 0.04432035f, -0.03573838f, 0.02061260f, -0.03656773f, 0.02327940f, 0.02261276f, -0.04378785f, 
    -0.01307887f, -0.04719181f, 0.00211998f, -0.06286710f, -0.02172932f, -0.00373754f, -0.00278780f, 0.03378617f, 
    0.00978698f, -0.04558158f, -0.02871545f, 0.00106046f, -0.00369056f, -0.01556072f, 0.04003849f, 0.03666128f, 
    -0.04127499f, -0.03673782f, -0.00434939f, 0.01837443f, 0.04208083f, -0.02382754f, 0.03325897f, -0.02432533f, 
    -0.04745802f, -0.04830475f, 0.01377875f, -0.03711508f, -0.05219115f, 0.02811188f, 0.04340432f, -0.00575239f, 
    0.01005266f, 0.04696396f, -0.05796284f, -0.02661985f, 0.02210806f, 0.00781796f, 0.00300398f, 0.05925057f, 
    -0.05669610f, -0.05758923f, -0.04531425f, -0.05125692f, 0.02830614f, 0.02460000f, -0.04865108f, -0.04701216f, 
    -0.03967379f, 0.01820429f, -0.04028519f, 0.02180609f, 0.03181180f, -0.06311817f, 0.03790328f, 0.03767690f, 
    0.01363990f, -0.03481718f, 0.05295012f, -0.03204137f, 0.02937778f, -0.01397903f, 0.01119330f, -0.00393456f, 
    0.00461753f, 0.03507496f, 0.02631641f, -0.05627427f, 0.04113445f, -0.03431050f, 0.00445005f, -0.01345991f, 
    0.04440602f, -0.02485328f, -0.05165954f, 0.04490622f, -0.03605279f, 0.01818426f, -0.02314342f, -0.04046781f, 
    -0.04280091f, 0.00989088f, -0.01003928f, 0.00694730f, -0.04930792f, -0.00155835f, -0.02920076f, 0.01042022f, 
    0.03609315f, 0.03745345f, -0.01676118f, -0.01551289f, -0.00057529f, -0.04038908f, 0.02505676f, 0.01424818f, 
    0.04518735f, -0.05851847f, -0.01749464f, -0.03921683f, 0.02572356f, 0.00020741f, -0.00725512f, 0.03755328f, 
    -0.02768952f, -0.02270472f, -0.01903586f, 0.03841002f, -0.03217037f, -0.06042273f, -0.03725970f, 0.01527222f, 
    -0.05883623f, -0.02504065f, 0.02749406f, -0.02176179f, -0.03683174f, 0.03373485f, -0.04681072f, -0.00812866f, 
    -0.03054196f, -0.04800782f, 0.02938217f, -0.04392922f, 0.04356163f, 0.00492506f, 0.03336059f, -0.05884410f, 
    0.04725949f, 0.00969737f, -0.02010826f, 0.01616552f, -0.00440998f, 0.01380122f, -0.03086729f, 0.04140112f, 
    0.03882427f, -0.00844632f, -0.03063611f, -0.02483512f, -0.02111192f, -0.02351397f, 0.02718723f, 0.03027209f, 
    0.00216017f, 0.02697795f, -0.02345609f, -0.05159032f, -0.00093731f, -0.02894173f, 0.01142110f, -0.02791463f, 
    0.02270534f, -0.05836413f, -0.06382079f, -0.02419939f, -0.02577614f, 0.04828673f, -0.03463222f, -0.00187395f, 
    -0.05901280f, -0.02254391f, 0.00426127f, -0.01585051f, -0.04076895f, 0.02082944f, -0.01957237f, 0.04602719f, 
    0.01178272f, 0.03445082f, -0.03914814f, -0.03656296f, -0.03651820f, -0.02280681f, -0.00956875f, -0.01054625f, 
    -0.00582543f, -0.02746944f, -0.05113162f, -0.00472964f, 0.02368068f, -0.00125759f, -0.00886965f, 0.00704380f, 
    -0.04278200f, 0.00729816f, -0.02821206f, -0.04402265f, 0.02652323f, -0.00890416f, -0.04372159f, 0.01404687f, 
    0.02699200f, -0.01007231f, -0.00484716f, -0.03090810f, -0.03415985f, 0.05348919f, 0.04169146f, -0.00564109f, 
    0.01187740f, 0.03269019f, 0.00298100f, 0.00869701f, 0.02728566f, 0.00955683f, 0.02433578f, -0.02107583f, 
    -0.00083786f, 0.04326656f, -0.02297883f, -0.02222266f, 0.02906790f, -0.03569029f, 0.00933880f, 0.04562966f, 
    0.03708403f, 0.01732242f, 0.00572667f, 0.03761402f, 0.02036728f, 0.01765080f, -0.01439982f, 0.02871474f, 
    -0.00757728f, -0.02688641f, -0.02134964f, -0.05543853f, -0.01893423f, -0.01311439f, -0.01633214f, -0.05542869f, 
    -0.01938846f, 0.02594477f, -0.03152064f, 0.03490120f, 0.00889096f, -0.04407824f, -0.03361401f, -0.03879929f, 
    -0.01437798f, -0.00590454f, -0.05424610f, -0.02571133f, -0.01792963f, -0.05807601f, 0.00189210f, 0.00661095f, 
    0.00259185f, -0.03109147f, 0.03524774f, -0.04931422f, -0.05733988f, 0.02797760f, -0.05899796f, 0.03436035f, 
    0.04733053f, 0.04538021f, -0.00707783f, -0.02136710f, 0.02289230f, 0.01551616f, 0.01030830f, -0.04763720f, 
    -0.02410104f, -0.03450380f, -0.04844540f, -0.02771522f, 0.02505601f, -0.00286608f, -0.04515369f, -0.02686909f, 
    0.01772912f, 0.03358964f, 0.02761202f, -0.02580773f, -0.01192876f, 0.03704147f, 0.03527526f, -0.01579267f, 
    -0.05245107f, 0.03692054f, -0.01424599f, -0.04013743f, -0.02444028f, 0.04039242f, -0.01007168f, 0.01792921f, 
    0.04479917f, 0.03541807f, 0.02108515f, 0.03639859f, -0.03371146f, -0.05224191f, -0.01778801f, -0.05567887f, 
    -0.01685443f, -0.02192054f, 0.04549112f, -0.05231696f, -0.02098132f, -0.05201446f, 0.04684756f, 0.01761288f, 
    -0.04862217f, -0.04351075f, 0.03501334f, 0.03500137f, -0.01562678f, -0.04104418f, -0.04343496f, 0.00915676f, 
    -0.03787864f, 0.01940440f, -0.02414345f, 0.02053896f, 0.03035142f, -0.00554968f, -0.02733451f, 0.04559828f, 
    -0.02896479f, 0.03226465f, -0.06296384f, 0.00787092f, 0.00757864f, -0.01914560f, -0.00589560f, -0.04579393f, 
    0.00247706f, 0.03303491f, -0.00767920f, -0.05915778f, -0.03292732f, -0.05832708f, 0.04708380f, -0.00980784f, 
    0.01580059f, 0.04430897f, -0.00521515f, -0.00537212f, -0.00992245f, 0.03033938f, 0.04506650f, 0.03324906f, 
    -0.00041791f, -0.05677525f, 0.02745544f, -0.05712994f, -0.00340995f, -0.05170064f, -0.02399482f, -0.01405449f, 
    0.00801433f, -0.05559877f, -0.00651272f, -0.01353616f, -0.02634291f, -0.04017027f, -0.00357606f, -0.01971461f, 
    0.02433015f, -0.02575827f, -0.05035247f, -0.05327560f, -0.01784614f, -0.05969921f, 0.00480687f, 0.02944199f, 
    0.04507980f, 0.00090640f, 0.03747682f, 0.02196277f, 0.03269312f, -0.01963666f, 0.01030131f, -0.04698319f, 
    -0.03476366f, -0.01567853f, -0.00619809f, -0.04150809f, -0.02522302f, -0.01425392f, -0.05470333f, -0.06232455f, 
    -0.04330335f, -0.01551705f, 0.00233020f, -0.03305788f, -0.02226591f, -0.05388921f, 0.04346050f, -0.01946473f, 
    0.03084099f, 0.01548309f, 0.04183068f, -0.02020407f, 0.00907751f, -0.03609877f, 0.01055147f, -0.05867057f, 
    -0.01623318f, -0.04757315f, -0.04754816f, -0.05636846f, -0.04379397f, -0.05956198f, -0.03800510f, 0.04768157f, 
    0.04200263f, 0.02557648f, 0.02842920f, -0.02164617f, -0.01984279f, 0.01811540f, 0.00086331f, 0.00115361f, 
    -0.01658591f, 0.04099084f, -0.04105150f, 0.01149857f, 0.02593581f, -0.02930217f, -0.04523943f, -0.02486204f, 
    -0.01642466f, 0.00462899f, 0.00918461f, -0.03097426f, -0.00886076f, 0.00990260f, -0.02564059f, -0.00084716f, 
    -0.03827012f, 0.04536065f, 0.04644272f, -0.04940896f, -0.02955453f, -0.00514191f, 0.02950100f, 0.00478488f, 
    -0.04163633f, 0.00971398f, 0.01721860f, 0.01275344f, 0.00256987f, 0.01591145f, -0.03347264f, -0.05904233f, 
    -0.03054461f, 0.01694902f, -0.05140506f, -0.02792002f, 0.01362436f, -0.04845174f, -0.00634040f, 0.02724810f, 
    -0.03382281f, -0.05626849f, 0.00909031f, -0.05440051f, -0.05102834f, -0.06177057f, -0.00024710f, 0.00276870f, 
    0.03138294f, -0.01389468f, 0.02659187f, -0.02793230f, -0.00161508f, 0.02725950f, -0.02772165f, -0.02653949f, 
    0.02460453f, -0.01534417f, -0.04814482f, 0.00690787f, 0.02980956f, 0.01314701f, 0.00185732f, 0.03633124f, 
    -0.03578539f, -0.04709895f, 0.00436260f, -0.03711613f, -0.02035942f, 0.01914584f, -0.05610097f, -0.05112318f, 
    0.02817249f, -0.02769171f, -0.03857394f, -0.02923419f, 0.00805668f, 0.03223757f, 0.03931065f, 0.01057074f, 
    -0.03965259f, 0.00528695f, -0.03822415f, -0.05702016f, 0.01978992f, 0.00774205f, 0.00797542f, -0.02293166f, 
    -0.03430652f, 0.02875160f, -0.03699471f, 0.02224577f, 0.00454533f, 0.03901447f, -0.05180895f, -0.04078203f, 
    -0.01243961f, -0.01313143f, 0.02454795f, -0.02768616f, -0.04645279f, 0.00846152f, 0.00213280f, -0.00427953f, 
    -0.05109129f, -0.02057971f, 0.02668621f, -0.01589872f, 0.04750537f, -0.01899955f, -0.03492412f, 0.03819300f, 
    -0.02767006f, 0.03361392f, 0.01495203f, -0.00629685f, -0.01853123f, -0.02486341f, -0.03308312f, 0.01107466f, 
    -0.56672835f, -0.12146134f, -0.25160861f, 0.10780443f, -0.01910393f, 0.05678283f, -0.04525149f, -0.02637649f, 
    -0.00894163f, -0.04486423f, -0.07460273f, 0.14988489f, -0.02693934f, 0.00312064f, 0.14751154f, 0.00695976f, 
    0.09940504f, 0.15930808f, -0.07517466f, 0.03329744f, -0.32031053f, 0.08979113f, 0.02595934f, 0.03862953f, 
    -0.06212293f, 0.15777682f, 0.07013373f, -0.01651654f, -0.04371722f, 0.00874925f, 0.04210746f, -0.01577681f, 
    0.11690711f, 0.20943061f, 0.00380399f, 0.06647816f, -0.06900034f, -0.12548473f, 0.02271722f, 0.00541541f, 
    -0.38630763f, -0.19017714f, -0.04116573f, -0.11310099f, -0.26626033f, -0.10281568f, -0.01810708f, 0.06995840f, 
    -0.03628317f, 0.03275618f, -0.01975419f, -0.05582507f, 0.00422993f, 0.09868673f, 0.07483992f, 0.09080689f, 
    -0.09431721f, 0.01649439f, 0.04004296f, 0.09155212f, -0.41835696f, -0.06210560f, -0.00621093f, -0.01489011f, 
    0.05905525f, -0.05706721f, 0.05094666f, 0.02720284f, 0.03191417f, -0.01193378f, -0.14343624f, 0.04239516f, 
    0.06743068f, 0.02119970f, 0.16455233f, -0.08681528f, -0.14140001f, -0.04365829f, 0.01558085f, 0.01883145f, 
    0.37187988f, 0.33543524f, 0.18081574f, 0.36631197f, 0.02459677f, -0.05584720f, -0.01217454f, 0.01874038f, 
    0.10550182f, 0.01700250f, -0.06494706f, -0.08266060f, -0.03254260f, 0.07403524f, 0.06043576f, -0.06208609f, 
    0.20406406f, 0.09916303f, -0.02833676f, 0.04499687f, -0.14860074f, -0.11633515f, 0.00502360f, 0.00511619f, 
    -0.38720632f, 0.16720912f, -0.08575697f, 0.06333743f, -0.01917319f, -0.11256347f, 0.13470086f, 0.00039188f, 
    -0.06072008f, -0.08401317f, -0.05936920f, -0.01061924f, 0.04084126f, 0.15116389f, 0.00303156f, 0.00401090f, 
    0.05939492f, -0.01355641f, -0.04713805f, 0.01647788f, 0.08969335f, 0.00147517f, 0.14598036f, 0.18229961f, 
    0.12302347f, -0.05292656f, -0.14094037f, 0.05045350f, 0.10221912f, -0.18905638f, -0.12589416f, 0.04008092f, 
    0.09086481f, 0.06260557f, 0.08258602f, 0.01229618f, -0.05038466f, -0.08956716f, 0.17331529f, 0.20130119f, 
    -0.39351243f, 0.03428390f, -0.01283086f, -0.07019760f, 0.14345539f, 0.18963180f, 0.09074926f, 0.16653711f, 
    -0.02542133f, 0.17823306f, 0.03902911f, -0.05829399f, 0.12947248f, -0.02823744f, 0.16219404f, 0.05102290f, 
    0.08869383f, 0.14141713f, -0.05362513f, -0.17534854f, 0.06441062f, -0.01880956f, 0.05064418f, 0.04496158f, 
    0.06125413f, -0.25071794f, 0.03378107f, -0.04228845f, -0.04185263f, -0.11893713f, 0.12513694f, -0.05440899f, 
    0.09732075f, 0.04861338f, 0.09620074f, -0.05226752f, 0.00465730f, 0.30560938f, 0.19747774f, 0.50716871f, 
    0.42171776f, -0.07158598f, 0.00847205f, 0.14741789f, 0.12147768f, 0.19023480f, -0.00567400f, -0.04902559f, 
    0.07329669f, 0.16903037f, 0.02515526f, 0.12547684f, 0.05018154f, 0.05110436f, -0.01348792f, -0.06542546f, 
    -0.16689512f, -0.06979188f, -0.24495378f, 0.07711877f, 0.07425801f, 0.01450602f, 0.19351117f, -0.03095725f, 
    0.03395689f, 0.02169117f, -0.09910020f, -0.06109399f, 0.01478449f, -0.07156348f, 0.07195052f, 0.07615604f, 
    0.09467684f, 0.07489291f, -0.01462689f, 0.17648509f, 0.17891303f, 0.30623379f, 0.05727254f, 0.42683780f, 
    0.40951282f, 0.31005380f, 0.03140946f, -0.02942165f, 0.05061831f, 0.05672012f, -0.05691720f, 0.12812948f, 
    0.08207297f, -0.03778093f, 0.14506416f, -0.01107386f, 0.02796757f, 0.02934669f, 0.12932190f, 0.08386356f, 
    0.26072767f, -0.01289888f, 0.05290229f, -0.04281567f, 0.08114240f, 0.12048209f, 0.14478961f, 0.04270955f, 
    0.02053111f, 0.11852757f, -0.10376963f, 0.07145026f, 0.12817355f, 0.00672081f, -0.00948483f, -0.10482805f, 
    0.17830421f, -0.03190130f, 0.10739249f, 0.03601256f, -0.16560622f, 0.17282100f, 0.00677423f, -0.01175311f, 
    0.15850195f, 0.15649299f, -0.03234409f, 0.31505942f, 0.06562085f, -0.13630946f, 0.14940378f, 0.08989086f, 
    0.04836924f, 0.01207348f, -0.10903747f, 0.03573728f, 0.00845617f, -0.07812790f, 0.07159321f, 0.01123694f, 
    0.12796347f, 0.17734136f, -0.09252918f, 0.14277542f, 0.27461988f, -0.16101813f, -0.12674081f, -0.02078075f, 
    0.04673211f, 0.12504782f, -0.00222886f, 0.00447579f, 0.04183368f, -0.04429912f, 0.03614855f, -0.15179162f, 
    0.04283616f, 0.06182722f, 0.08175231f, 0.12496693f, -0.03592446f, 0.02748754f, 0.06827727f, -0.15678231f, 
    0.22081654f, 0.27388111f, 0.07869717f, -0.00936238f, 0.02979313f, 0.00390044f, 0.03907338f, 0.15422672f, 
    -0.02385396f, -0.23316708f, -0.00962668f, 0.03767101f, 0.05705312f, 0.10326804f, 0.02729455f, 0.12685625f, 
    0.31232831f, 0.14980049f, -0.02186129f, 0.08471548f, -0.06311916f, 0.16744816f, 0.00369011f, -0.02141334f, 
    0.03882726f, 0.00874237f, -0.16946743f, 0.01877410f, 0.02505604f, 0.07395672f, 0.08085623f, -0.13363329f, 
    0.19635713f, 0.04228483f, 0.07266837f, 0.00489996f, 0.14406064f, -0.13265018f, -0.10471176f, 0.01459372f, 
    0.14934395f, 0.05921119f, -0.07227323f, -0.06704549f, 0.06018707f, 0.04801096f, 0.00089679f, -0.13484637f, 
    0.04546288f, 0.19414094f, 0.13755748f, -0.04781447f, -0.03959026f, -0.07912747f, -0.02182010f, -0.05911283f, 
    0.21564645f, -0.03444045f, -0.00979868f, 0.15584907f, 0.15771252f, 0.22134386f, 0.08291826f, -0.08016318f, 
    -0.09287793f, 0.00534533f, 0.02514090f, -0.07935530f, -0.04237873f, 0.16659988f, -0.05979404f, 0.05904131f, 
    -0.08560676f, 0.24139807f, 0.04774742f, 0.01293833f, 0.25400117f, -0.00782163f, -0.06014520f, 0.15686381f, 
    0.11423003f, -0.02227376f, -0.02623146f, -0.07182150f, -0.04736040f, 0.01528399f, 0.16391212f, 0.07190681f, 
    -0.02379704f, 0.03339868f, -0.06279279f, -0.04183440f, -0.02089300f, 0.27865049f, 0.16717437f, -0.03720397f, 
    -0.12588887f, 0.19508275f, -0.10486032f, -0.14665796f, 0.10709527f, 0.13031361f, -0.05381776f, 0.14389461f, 
    0.02094791f, -0.00861681f, 0.04932889f, 0.10791508f, 0.08181001f, -0.02002345f, -0.07030620f, 0.15558927f, 
    0.05951905f, -0.48441043f, 0.08212788f, 0.05137191f, -0.51259249f, -0.02120672f, 0.11993487f, -0.02450163f, 
    -0.02095651f, 0.08344842f, 0.10904958f, -0.25467065f, -0.09548987f, 0.05555394f, 0.07752329f, 0.00481087f, 
    -0.02173117f, -0.01273560f, 0.04707214f, 0.03945869f, 0.01632820f, 0.33480117f, 0.00427831f, 0.13449536f, 
    0.02286711f, 0.19188705f, 0.27492732f, 0.04625082f, -0.29080546f, 0.00643518f, 0.00549831f, 0.22964042f, 
    -0.20329191f, -0.00561847f, -0.02356401f, 0.08062264f, -0.09383824f, -0.20189176f, -0.03157327f, 0.03551357f, 
    -0.07296098f, -0.01327050f, -0.01533870f, 0.10575102f, 0.05915304f, -0.14320303f, -0.03712104f, -0.19733991f, 
    0.05448652f, -0.00299167f, 0.16097529f, -0.29476589f, 0.10536339f, 0.08963754f, 0.13344985f, 0.05788594f, 
    0.10870357f, 0.10937803f, -0.00356844f, -0.01930749f, -0.04478667f, 0.16761725f, -0.04257672f, 0.15373400f, 
    0.35449404f, -0.07164016f, -0.08332952f, -0.02374311f, -0.23320772f, -0.01168551f, 0.14347585f, -0.05313093f, 
    -0.05794118f, -0.13412590f, 0.02704450f, -0.03978305f, -0.20580211f, 0.04962912f, -0.09300578f, 0.15103672f, 
    0.02097829f, 0.02631363f, 0.03521298f, 0.11878180f, -0.09896038f, 0.07014169f, -0.05249543f, -0.17946376f, 
    0.07249547f, 0.01063343f, -0.04989035f, 0.02569654f, 0.09072346f, -0.04792248f, 0.03558502f, 0.05260515f, 
    0.21640369f, 0.22882809f, 0.14518774f, 0.03318935f, 0.12009092f, -0.22382700f, -0.22234212f, -0.07637170f, 
    -0.13328342f, 0.28910974f, 0.07205503f, -0.06095972f, 0.13419889f, 0.25468329f, -0.01979587f, -0.05973034f, 
    0.10765520f, 0.03244715f, 0.10693373f, -0.10434797f, 0.04405883f, 0.16599230f, -0.07281392f, 0.19150552f, 
    0.06210012f, 0.07026276f, 0.07521880f, 0.08082812f, 0.04363954f, 0.12087398f, -0.04488061f, -0.27723154f, 
    -0.04785082f, -0.04516686f, -0.07756264f, 0.10184880f, -0.03323782f, 0.04781801f, -0.09976955f, -0.02621161f, 
    0.10852589f, 0.13181663f, -0.07583751f, -0.10346103f, 0.09657563f, -0.04140114f, -0.28456193f, -0.06566887f, 
    -0.34106594f, 0.17995995f, -0.02955395f, -0.12302773f, 0.02784043f, 0.10405682f, 0.08247108f, -0.13527051f, 
    0.03434457f, 0.09267672f, -0.06126520f, 0.11777309f, -0.01425353f, 0.11168212f, 0.02611599f, 0.09371746f, 
    -0.09108927f, 0.27177665f, -0.16276534f, 0.07136562f, 0.30971467f, -0.21432099f, -0.28339428f, 0.03400070f, 
    -0.10750452f, -0.07499008f, 0.05003257f, 0.05156437f, 0.02516097f, 0.09320518f, 0.06861769f, 0.22106926f, 
    -0.06367806f, -0.23669498f, -0.01756714f, -0.05124484f, -0.11408695f, -0.13873647f, -0.19349545f, 0.01515645f, 
    -0.14913076f, -0.34750739f, 0.04571483f, 0.06171502f, 0.20652229f, 0.09092321f, -0.02420859f, 0.13722974f, 
    0.04381119f, 0.12189181f, 0.15926743f, -0.03107100f, 0.12577704f, -0.07064074f, 0.02525734f, 0.06354984f, 
    -0.00724262f, -0.06850685f, 0.11673196f, 0.06350312f, -0.25804922f, -0.06242865f, 0.35061103f, -0.09866935f, 
    -0.09212785f, 0.05894928f, 0.14049858f, -0.07094564f, -0.15755686f, 0.04786585f, -0.02258854f, 0.11674742f, 
    -0.07273202f, 0.24564295f, 0.00804051f, 0.02811025f, 0.12977320f, -0.05291970f, -0.31416801f, -0.00145997f, 
    0.26889211f, 0.07644475f, -0.00072228f, -0.23351438f, 0.01949422f, 0.07648411f, 0.03888661f, -0.07180139f, 
    -0.06131976f, 0.09211364f, 0.20662323f, 0.05900115f, 0.00031572f, -0.06518781f, 0.00420074f, 0.15035982f, 
    -0.01801172f, 0.02461923f, 0.02273084f, 0.01431103f, -0.26017997f, 0.27028468f, 0.00139632f, 0.18874419f, 
    -0.49822459f, -0.06277102f, 0.22794084f, -0.10563965f, 0.05733556f, -0.03927763f, 0.08500507f, 0.09995415f, 
    -0.06214182f, -0.13624094f, -0.00583913f, -0.03685595f, 0.04826254f, 0.06769083f, 0.12618451f, 0.00597987f, 
    -0.04733374f, 0.11245251f, 0.05682332f, 0.09775503f, -0.26480111f, 0.02658151f, 0.17382099f, -0.12032449f, 
    0.01966334f, 0.06682347f, 0.04474211f, 0.02243398f, 0.09460741f, -0.12814815f, -0.00254924f, -0.12856755f, 
    0.05945784f, -0.18947214f, 0.08308814f, -0.09494217f, -0.14197789f, 0.03084245f, 0.05982567f, -0.14300136f, 
    0.21153037f, 0.15368114f, 0.00385452f, 0.03876660f, 0.06480260f, -0.05616739f, -0.07848857f, -0.09554622f, 
    0.02412229f, 0.12046453f, 0.05690294f, 0.13169771f, -0.01157710f, -0.07427638f, -0.05466880f, -0.04055849f, 
    -0.08672249f, 0.06325769f, 0.00092896f, 0.07001147f, -0.22372851f, -0.05973992f, 0.11434662f, -0.22266322f, 
    0.02270262f, -0.12131302f, 0.03497533f, -0.09994607f, -0.04504353f, 0.17331092f, 0.06516021f, -0.06741504f, 
    -0.04896055f, 0.26873037f, -0.03256546f, 0.11916702f, 0.40206072f, -0.01571265f, -0.26659900f, 0.28781804f, 
    0.08239460f, -0.06893910f, 0.07955267f, 0.06334841f, 0.14008896f, 0.03384304f, -0.05572527f, 0.07348365f, 
    0.07969764f, 0.03876773f, -0.03009709f, -0.05674460f, 0.11908235f, -0.09056783f, -0.11262274f, -0.10944445f, 
    -0.21960777f, -0.38002563f, 0.17432506f, -0.14875084f, 0.46968877f, 0.13927303f, 0.03507936f, 0.02562904f, 
    0.07744146f, 0.08152252f, -0.03166252f, -0.04696950f, 0.11931761f, 0.14946645f, 0.00876336f, -0.02327773f, 
    0.01240183f, 0.11438727f, -0.06913338f, -0.07377537f, 0.45695576f, -0.32439461f, 0.53313100f, 0.18212014f, 
    0.10047806f, 0.03397233f, -0.11645145f, 0.15967430f, -0.01682133f, 0.07219457f, -0.07338090f, 0.14938146f, 
    -0.09486744f, -0.15682307f, 0.01124059f, 0.03640589f, 0.01451745f, -0.08495379f, 0.05336419f, -0.12897573f, 
    -0.52667832f, 0.08019663f, 0.16418386f, 0.17400339f, 0.36999762f, 0.05137390f, 0.02085611f, 0.06098039f, 
    0.00919458f, 0.09660508f, -0.03978704f, 0.02661465f, 0.00785197f, 0.03384756f, 0.10584159f, -0.12573208f, 
    -0.09698818f, -0.04313729f, -0.00897217f, -0.06757011f, 0.00676936f, -0.06257856f, -0.16010082f, -0.10344414f, 
    0.15253495f, -0.04101096f, -0.05503022f, -0.11583813f, -0.14916883f, -0.01656893f, 0.01455967f, -0.06515801f, 
    0.00706927f, 0.03882673f, -0.06007842f, -0.07940032f, 0.06369445f, 0.16302367f, -0.01535436f, 0.12164786f, 
    -0.08517122f, 0.11586197f, -0.21667466f, -0.02654330f, -0.26972771f, -0.05043478f, 0.07469615f, 0.05992271f, 
    -0.04680036f, 0.08183011f, 0.03568728f, 0.02903288f, -0.03363556f, 0.03543232f, 0.11374106f, -0.08458986f, 
    0.07361276f, -0.02190931f, -0.00780154f, -0.05905965f, -0.09800927f, 0.02648649f, -0.13662536f, -0.22690117f, 
    0.17639995f, -0.03080498f, 0.12322546f, -0.06434559f, 0.04992653f, -0.14545280f, 0.16355036f, 0.13285883f, 
    -0.14749424f, -0.05867210f, 0.07772905f, 0.13466111f, -0.12682468f, 0.03629940f, 0.25668028f, 0.06907357f, 
    0.49924228f, -0.20883816f, 0.14012654f, -0.07508814f, 0.23140340f, 0.02640504f, 0.05423974f, 0.08714416f, 
    0.01756959f, 0.09659100f, 0.07368840f, -0.01237724f, 0.03851428f, -0.00746910f, 0.08733337f, 0.01872287f, 
    0.11554831f, 0.06225864f, 0.01501318f, -0.03384566f, -0.38906124f, -0.12585379f, 0.34396183f, 0.08810708f, 
    0.12236207f, 0.08576486f, -0.12490064f, 0.04585198f, -0.12417513f, -0.16996108f, -0.07576705f, -0.15714182f, 
    0.21078163f, 0.14542061f, -0.04991733f, 0.08644976f, 0.09499144f, 0.01902036f, 0.19700864f, 0.00588430f, 
    -0.01588687f, 0.55839670f, -0.17285170f, -0.05328161f, -0.03718468f, -0.05635398f, -0.01299699f, -0.02894263f, 
    -0.05132201f, -0.06349184f, 0.09554017f, 0.06405371f, -0.14405194f, 0.01561683f, 0.03987452f, -0.07033965f, 
    0.20623167f, 0.09629541f, -0.05052319f, 0.01201096f, -0.00640571f, 0.25492978f, 0.04991137f, -0.21919018f, 
    0.29444271f, 0.09515744f, 0.05991840f, 0.01891677f, -0.02134699f, -0.10692710f, 0.06857798f, 0.01995698f, 
    -0.02349687f, -0.05459636f, 0.00571790f, 0.00017967f, 0.01190966f, 0.00887769f, 0.19686456f, 0.04875002f, 
    -0.12793671f, -0.11267969f, -0.40496135f, 0.20566356f, 0.33168796f, 0.06443292f, 0.08407804f, -0.06919884f, 
    0.02090693f, -0.09320898f, 0.15216801f, -0.06372664f, -0.06241950f, 0.22208886f, -0.14340051f, 0.03336121f, 
    -0.11826922f, 0.00836833f, -0.06967326f, -0.02420774f, 0.25230211f, 0.02309876f, -0.36336574f, 0.09359149f, 
    0.13314311f, 0.15009576f, 0.00755563f, 0.03064889f, 0.07114774f, -0.13434051f, 0.08656623f, 0.09856359f, 
    0.21219333f, 0.04716701f, 0.04378853f, -0.03015462f, 0.09773443f, -0.04359537f, 0.20364748f, -0.01675879f, 
    0.23898581f, 0.11658838f, -0.21896176f, -0.04250510f, 0.15004469f, -0.02199197f, -0.02223138f, -0.01788529f, 
    0.03782334f, -0.01516085f, 0.16597222f, -0.02525591f, 0.08480900f, 0.03894845f, -0.00427990f, -0.04790933f, 
    -0.02715615f, -0.01399338f, 0.02001671f, 0.04740792f, -0.62751985f, 0.08438386f, 0.14035442f, -0.15483482f, 
    -0.09957843f, -0.03925199f, 0.00015992f, -0.14129689f, -0.08912803f, 0.05710506f, 0.00792032f, 0.06767999f, 
    0.00156478f, -0.04630856f, 0.07249887f, -0.12256847f, 0.06595532f, 0.03691031f, -0.10484082f, -0.08422746f, 
    0.24554016f, 0.23643200f, -0.23383681f, 0.05250501f, -0.03701075f, 0.05783467f, -0.06256860f, -0.06659933f, 
    0.05152934f, -0.07784764f, 0.03940830f, 0.14952426f, -0.00222697f, -0.04313342f, 0.25326705f, 0.03048427f, 
    0.04429298f, 0.15152785f, 0.03389829f, -0.01009535f, 0.31035075f, 0.21525320f, -0.03782268f, 0.14375290f, 
    0.13383484f, -0.07216369f, 0.00924922f, 0.13294864f, 0.02173723f, 0.03194346f, -0.10555206f, 0.14995284f, 
    0.04227288f, -0.01745971f, -0.04364764f, -0.01102100f, 0.04802742f, -0.01366359f, -0.01837266f, 0.02055186f, 
    -0.12660713f, -0.07283251f, 0.34961006f, -0.03087633f, 0.22723740f, -0.14414962f, -0.00015910f, -0.10960072f, 
    0.06728940f, -0.03644414f, 0.13796000f, -0.07333224f, 0.00429417f, -0.06874460f, 0.00078120f, -0.18685570f, 
    -0.00489387f, 0.09802184f, -0.01249608f, 0.03989879f, -0.06839518f, 0.49683523f, -0.27240098f, 0.03152870f, 
    0.13066843f, 0.09631024f, -0.00493265f, 0.20974971f, -0.04997092f, -0.03447672f, -0.05310208f, 0.04977041f, 
    -0.10475149f, 0.05001844f, -0.03216773f, 0.08657862f, 0.03359039f, -0.11223120f, -0.04174371f, -0.06718314f, 
    0.03806981f, 0.01674206f, 0.40896243f, 0.12140078f, 0.22596574f, -0.06055611f, -0.13264813f, 0.06384356f, 
    -0.06034514f, 0.10497725f, -0.12485465f, 0.13920431f, 0.03990617f, 0.02357491f, -0.12177637f, 0.05107290f, 
    0.05757734f, 0.05191537f, 0.09259604f, -0.01271370f, -0.21806297f, 0.09297148f, -0.08254815f, 0.23897201f, 
    0.46897346f, 0.07571167f, -0.00291412f, -0.06558529f, -0.11358888f, -0.01092866f, 0.18901475f, 0.06968528f, 
    0.00353614f, -0.13191797f, -0.21558458f, 0.10111459f, 0.09289949f, 0.11430600f, 0.01651637f, 0.07089478f, 
    -0.03411882f, 0.05562665f, -0.32250276f, 0.09192336f, 0.20334342f, 0.06333152f, 0.00769412f, -0.12218840f, 
    -0.01152266f, -0.07441305f, 0.04363473f, 0.14729612f, 0.03563970f, -0.01117558f, 0.05093489f, 0.04454890f, 
    -0.05748570f, 0.06643575f, 0.05214618f, 0.09094097f, -0.10708211f, 0.12880288f, 0.08518723f, -0.02759712f, 
    -0.01733646f, 0.19140129f, 0.07894095f, -0.03817321f, -0.00310080f, -0.02955948f, 0.03269349f, -0.03361340f, 
    0.06176205f, -0.03362709f, 0.04467824f, -0.00403724f, -0.13302565f, 0.05961344f, -0.02255078f, 0.05207204f, 
    -0.15500817f, -0.25045240f, 0.23862344f, -0.05633539f, 0.16321275f, 0.01277625f, 0.06337965f, -0.04477425f, 
    -0.15406370f, -0.13715418f, -0.10151174f, -0.07699100f, -0.13558000f, 0.00007585f, 0.06690074f, -0.10940420f, 
    -0.01449583f, -0.05583206f, -0.04278979f, -0.03852207f, -0.19678062f, 0.20437084f, 0.28858548f, -0.05455183f, 
    -0.01651141f, 0.03622432f, -0.01036265f, 0.06420855f, -0.06388962f, -0.03239719f, -0.00765110f, -0.14662401f, 
    0.07296231f, 0.12768871f, 0.15563039f, 0.20141372f, 0.04604914f, 0.13461652f, 0.10637926f, -0.00791715f, 
    0.17134665f, 0.35458213f, 0.09631615f, -0.11606611f, -0.15075031f, -0.03025355f, -0.05526267f, -0.04860210f, 
    0.01867964f, -0.14341331f, 0.07647248f, 0.14106527f, -0.04761402f, 0.17927922f, -0.14032064f, -0.02890246f, 
    0.06437062f, 0.02016768f, -0.02747452f, -0.10955625f, 0.21163933f, 0.36841208f, 0.30821756f, -0.20339221f, 
    0.06803587f, 0.12341955f, -0.05397252f, 0.05047447f, 0.07688572f, 0.02906819f, 0.00034426f, -0.02408103f, 
    0.05587008f, -0.08043675f, -0.20790525f, 0.06510564f, 0.10897548f, 0.12669007f, 0.21792951f, -0.10969069f, 
    0.05426539f, 0.26319748f, 0.46992591f, 0.00166797f, 0.12696575f, -0.07609867f, 0.09062999f, 0.08079616f, 
    0.02611561f, 0.03593972f, -0.03952849f, -0.05687873f, 0.16588047f, 0.02911645f, 0.03441896f, 0.00128557f, 
    0.05006677f, -0.07852111f, 0.02469792f, 0.04322819f, 0.09297140f, -0.15371180f, 0.37380630f, -0.01564749f, 
    0.25812623f, -0.08365888f, -0.23628958f, 0.17434630f, -0.05192951f, 0.12920129f, -0.04134471f, -0.12718548f, 
    0.03041197f, -0.02227391f, 0.06757392f, -0.05330585f, -0.00580183f, 0.03306747f, -0.02554115f, 0.04659108f, 
    0.45068407f, 0.18720445f, 0.29708502f, 0.03801725f, 0.44520372f, 0.03055099f, -0.02966580f, 0.11118232f, 
    0.01624031f, -0.00096635f, -0.06567503f, 0.06423625f, -0.06244638f, 0.11343630f, -0.15183561f, 0.13163258f, 
    0.04254728f, 0.05450897f, -0.00431663f, -0.04623337f, 0.54339761f, 0.29442406f, 0.01586459f, 0.15689754f, 
    -0.07734656f, 0.09774935f, 0.07031910f, 0.10674974f, 0.00207311f, 0.04703241f, 0.21644622f, -0.07623122f, 
    -0.00830383f, -0.05336935f, -0.04227632f, 0.03413612f, 0.15834022f, 0.05444647f, 0.07844549f, 0.06286425f, 
    -0.52537376f, -0.36699709f, 0.18288428f, -0.35934252f, 0.01716774f, -0.04661167f, -0.00624637f, 0.16340108f, 
    -0.09021083f, 0.27367443f, -0.04530706f, 0.04191500f, 0.08404665f, -0.01287054f, -0.00039633f, 0.01894255f, 
    0.00467850f, -0.24218877f, 0.04778598f, -0.09629446f, 0.16732539f, 0.19809215f, 0.26718989f, 0.02382424f, 
    0.28728980f, 0.18750258f, -0.00105274f, 0.03193799f, -0.04126609f, 0.01241158f, 0.08128186f, -0.10755821f, 
    0.02048034f, 0.08094969f, 0.13464695f, 0.06075040f, -0.15763372f, -0.01696862f, 0.09601109f, 0.01379674f, 
    -0.10273256f, 0.22194773f, -0.21686959f, 0.14600186f, -0.20239656f, 0.27686745f, -0.02149675f, -0.10512986f, 
    0.06830593f, 0.16286890f, 0.13486975f, 0.06332711f, -0.12682496f, 0.02728758f, 0.14310175f, 0.16872069f, 
    0.09743124f, -0.00453849f, 0.23494868f, -0.01055404f, 0.05741664f, -0.12081755f, -0.23164941f, -0.14640167f, 
    -0.08928577f, -0.05074107f, 0.11512876f, 0.02727837f, -0.15710418f, -0.09699075f, 0.07790285f, -0.04688921f, 
    0.12900613f, 0.04720138f, 0.02335795f, -0.04910996f, -0.13387433f, -0.01760343f, -0.08895259f, 0.03354944f, 
    0.04409110f, 0.18368243f, -0.12633266f, 0.08624852f, -0.10355833f, 0.11108364f, 0.05016974f, 0.02057125f, 
    0.09764548f, 0.04469988f, 0.10631505f, 0.07525453f, -0.05103930f, 0.10140645f, 0.00227237f, 0.19406465f, 
    0.03342407f, 0.01602230f, 0.00008147f, 0.04621975f, -0.02300432f, -0.37208745f, 0.04900529f, -0.07439374f, 
    -0.71455830f, -0.07811981f, 0.00898255f, 0.07560233f, -0.02195055f, -0.09218475f, 0.01214275f, -0.02576034f, 
    -0.00082770f, -0.00873499f, 0.09987874f, -0.03085578f, 0.04785769f, -0.08085614f, 0.06873009f, -0.06603947f, 
    -0.10099042f, 0.09249946f, 0.35410297f, 0.01628680f, -0.13587274f, -0.08938989f, -0.16492291f, 0.01016060f, 
    0.00181012f, -0.02209362f, 0.06994189f, -0.03013920f, 0.03455417f, 0.08896479f, -0.03853583f, 0.03138618f, 
    -0.08085147f, -0.00359998f, -0.00547106f, -0.04510199f, 0.07445238f, -0.25181565f, 0.06829990f, 0.11935025f, 
    -0.31845042f, 0.01088482f, 0.09631730f, 0.14290430f, 0.07466998f, 0.06556839f, 0.00548921f, 0.03833493f, 
    0.16952023f, 0.10654297f, 0.07095587f, -0.16503291f, 0.16436920f, -0.10887527f, -0.15333341f, 0.01479694f, 
    -0.09580714f, 0.05323648f, -0.10320958f, -0.01867290f, -0.27548340f, -0.16774303f, -0.13565712f, -0.03081475f, 
    -0.00315305f, 0.01414176f, 0.06856523f, 0.08365773f, 0.06412057f, -0.04781559f, -0.04998729f, 0.07171631f, 
    -0.11832435f, -0.04893436f, -0.08943218f, 0.08506692f, 0.16384649f, -0.03034740f, -0.21207894f, -0.08461768f, 
    0.09382633f, 0.00074133f, 0.08895767f, -0.17410742f, 0.09413628f, 0.20441277f, 0.03713035f, 0.12931821f, 
    -0.10399548f, 0.00889779f, 0.03215011f, -0.12261316f, -0.08997709f, -0.01453101f, -0.17503497f, -0.07182450f, 
    -0.07501045f, -0.43776962f, 0.10714132f, -0.00211246f, -0.21723659f, -0.06425455f, 0.23156270f, 0.09399968f, 
    -0.08780170f, 0.05942881f, -0.10966311f, -0.04689591f, 0.10920224f, -0.04138899f, 0.02461320f, 0.05613030f, 
    -0.14649832f, -0.06438467f, 0.05106731f, -0.02492919f, -0.05355690f, -0.26073694f, -0.08661398f, 0.37212467f, 
    -0.27484804f, -0.03052926f, 0.17157239f, -0.01883285f, 0.22764960f, 0.24406886f, -0.06992397f, 0.00731560f, 
    0.04579893f, 0.21834297f, 0.06072223f, 0.00923407f, 0.01660012f, 0.01296147f, -0.13548633f, 0.00959536f, 
    -0.10694764f, -0.21425012f, 0.33822358f, -0.12803324f, -0.03877678f, 0.15238230f, 0.02517486f, 0.04720562f, 
    -0.12360539f, 0.00727796f, -0.05312647f, -0.03232697f, 0.28247368f, -0.07378215f, 0.07845922f, 0.09324005f, 
    -0.01137764f, -0.07616244f, -0.08783636f, 0.07273996f, -0.11935996f, -0.49141771f, 0.12568012f, 0.05984759f, 
    -0.10686297f, 0.05253601f, 0.02450900f, 0.11980966f, -0.09026087f, 0.04733044f, -0.15278976f, 0.04936540f, 
    -0.11464459f, 0.08799642f, 0.13485977f, -0.12719491f, 0.00633640f, -0.00190207f, -0.21321653f, 0.05893626f, 
    -0.06270602f, -0.20210944f, 0.17454389f, 0.06343016f, 0.03282237f, 0.20211013f, 0.03445020f, 0.08463603f, 
    -0.05597679f, -0.00222715f, 0.04209171f, 0.03282338f, 0.17530699f, 0.01084620f, -0.01736867f, -0.04109992f, 
    -0.13545600f, 0.01907114f, -0.09986591f, -0.09130538f, -0.13422531f, 0.15354034f, -0.00131090f, -0.05069195f, 
    0.00871062f, 0.22868320f, 0.08605741f, 0.06091162f, 0.12607665f, 0.10937241f, 0.17126726f, 0.04467566f, 
    0.07846171f, 0.05031790f, 0.01959861f, -0.08146236f, 0.14271009f, 0.02586810f, 0.10370139f, 0.13984114f, 
    -0.14300217f, -0.02516023f, -0.24070035f, -0.38337067f, -0.15291916f, 0.16341439f, 0.07872000f, 0.06685603f, 
    0.01385448f, -0.00595068f, -0.00603228f, -0.00912463f, 0.13323896f, -0.18232089f, -0.02559605f, 0.02976285f, 
    -0.00216541f, -0.07762209f, 0.02581885f, 0.18534516f, 0.03141354f, 0.25248221f, -0.31514326f, -0.28062466f, 
    0.06672461f, -0.01125230f, 0.08786532f, -0.14373232f, 0.27459839f, 0.08595754f, -0.01909672f, 0.15646999f, 
    0.07986712f, 0.12615217f, -0.08441416f, 0.05216593f, -0.07609357f, 0.03424910f, -0.10893989f, 0.06798487f, 
    0.37026539f, 0.14847973f, -0.19817106f, 0.30082625f, 0.40482053f, -0.19823125f, -0.41571739f, 0.05640924f, 
    0.03277943f, 0.27100912f, 0.10326827f, -0.04318179f, -0.08360133f, 0.11603213f, 0.03388000f, 0.07784924f, 
    0.08108386f, -0.13801235f, 0.09978304f, 0.10770872f, 0.17469116f, 0.13843662f, -0.39760917f, -0.27977258f, 
    -0.07919786f, 0.00113486f, 0.09603316f, 0.18502189f, 0.04742783f, 0.05692054f, -0.00098639f, -0.00631293f, 
    0.07140711f, 0.07203287f, 0.01181599f, 0.01941914f, -0.04738436f, -0.12067743f, -0.13897650f, 0.14502735f, 
    0.25793916f, -0.13137908f, 0.16383766f, 0.49052086f, 0.17788135f, 0.00409528f, -0.18372056f, 0.00399519f, 
    0.05613662f, 0.23213743f, -0.03645492f, -0.00505340f, 0.05172914f, 0.02212492f, -0.03638529f, 0.05717397f, 
    -0.05015041f, 0.04022893f, 0.05200833f, 0.06264491f, -0.65322465f, 0.08566110f, 0.08762113f, -0.21506810f, 
    -0.21921135f, 0.11663704f, 0.23372132f, 0.01845675f, -0.05729490f, -0.12507790f, 0.22985087f, 0.04054084f, 
    -0.00830288f, -0.06896555f, 0.03520404f, 0.00372137f, 0.07508034f, -0.06556150f, -0.12732205f, 0.08807642f, 
    -0.41175354f, -0.01106254f, 0.11343136f, 0.18391776f, 0.04682430f, 0.03203724f, -0.14002840f, 0.17847086f, 
    -0.00951565f, 0.09590457f, 0.06937700f, 0.00471841f, -0.05630011f, 0.13558888f, 0.15037492f, 0.03881901f, 
    -0.06945934f, 0.18792333f, 0.10034414f, -0.07595168f, 0.11059441f, 0.14453438f, -0.10596501f, -0.08328179f, 
    -0.16349456f, -0.29858875f, 0.08697761f, -0.05709439f, 0.04549828f, -0.10961854f, 0.03299754f, -0.00456965f, 
    0.07852963f, 0.14611356f, -0.11307657f, 0.05435871f, 0.05237618f, 0.03192578f, 0.09751137f, 0.12229830f, 
    0.01797353f, 0.07699973f, -0.10283761f, -0.28409690f, 0.12237939f, 0.02397189f, 0.10462975f, 0.00776633f, 
    -0.04542247f, 0.04402604f, -0.09752326f, 0.13611160f, -0.04874218f, 0.03291371f, 0.03613191f, 0.13388273f, 
    -0.03343129f, 0.01941069f, -0.02028019f, -0.05353362f, 0.36677858f, -0.59766489f, -0.20534259f, 0.36648199f, 
    0.23692745f, -0.16909514f, -0.26030383f, -0.16240431f, 0.11517816f, 0.28659028f, 0.00561898f, 0.04664139f, 
    0.02928479f, -0.08029645f, 0.13942632f, -0.05003988f, 0.10749626f, 0.05877969f, -0.09801438f, -0.07325539f, 
    -0.32026827f, 0.19355081f, -0.14562497f, -0.01691673f, -0.04581794f, -0.04139929f, 0.12246872f, 0.03511260f, 
    0.06662624f, 0.14706884f, -0.05268302f, -0.17050545f, -0.07754290f, -0.02729095f, -0.07431605f, 0.15534993f, 
    0.05360269f, 0.05206319f, 0.06158433f, 0.01422178f, 0.45836663f, -0.20997956f, -0.12472748f, 0.28551635f, 
    -0.05349645f, -0.07069362f, 0.10682712f, -0.11398427f, -0.00344383f, 0.12487023f, -0.04237837f, 0.13974009f, 
    0.12056412f, 0.12417086f, -0.00495359f, 0.08880680f, 0.09039453f, 0.03733181f, 0.07046223f, 0.00175671f, 
    -0.17721573f, 0.06937034f, 0.06540903f, -0.17309886f, -0.02369393f, 0.05275236f, -0.01223702f, -0.04033029f, 
    -0.03009684f, 0.01320047f, 0.02923978f, 0.09969669f, -0.05463527f, -0.23563755f, -0.03790354f, 0.10912060f, 
    -0.02861321f, 0.01368474f, 0.00039302f, -0.02192704f, -0.54778057f, -0.05644021f, 0.24463043f, 0.01969798f, 
    -0.37066916f, -0.01283515f, 0.26941442f, -0.10345412f, -0.02290530f, 0.08935128f, 0.07112011f, 0.05531679f, 
    -0.08356073f, -0.09642934f, -0.04159990f, 0.03704442f, -0.06043588f, 0.09148467f, 0.01876052f, -0.01728307f, 
    -0.29893804f, -0.15860073f, 0.05309154f, 0.14938869f, -0.27897412f, -0.10592737f, 0.10938560f, -0.09789947f, 
    0.03516084f, -0.12641907f, -0.00713488f, -0.00337992f, -0.01151957f, -0.02884138f, 0.10453786f, -0.07090802f, 
    0.08313406f, -0.25731623f, 0.00781342f, -0.10686368f, 0.42037526f, -0.01785754f, -0.05739757f, -0.07768563f, 
    0.17550939f, 0.08854800f, 0.08375077f, 0.01099827f, 0.07638387f, -0.11440217f, -0.03856277f, -0.11491666f, 
    0.11895531f, 0.05385260f, 0.14454436f, 0.22332707f, 0.02657094f, -0.11452261f, -0.03850041f, 0.02841775f, 
    0.22674809f, 0.16839457f, 0.16120596f, 0.14957549f, -0.14728951f, -0.07887790f, 0.21528243f, -0.13955118f, 
    0.11326245f, -0.03525513f, -0.03198123f, -0.26248768f, -0.06333919f, 0.11177329f, 0.00316145f, 0.00491892f, 
    0.01853550f, 0.33113214f, 0.05359430f, 0.24182075f, 0.10406005f, -0.12525459f, -0.33469605f, 0.07055176f, 
    -0.10909045f, -0.06423586f, -0.12685864f, -0.04578413f, 0.21320122f, 0.13905925f, 0.10036829f, -0.07992605f, 
    -0.01123560f, 0.11210473f, 0.00170439f, -0.04244106f, 0.15199609f, -0.12117358f, 0.11163234f, -0.02480538f, 
    0.17681724f, -0.53028208f, -0.17949851f, -0.18255317f, 0.19276983f, -0.01684499f, -0.12555839f, 0.04139968f, 
    0.13325433f, 0.19438231f, -0.15114377f, -0.01581826f, 0.11647773f, 0.04797547f, 0.09229797f, 0.02046081f, 
    0.08170109f, 0.18723042f, -0.13371055f, -0.00916285f, -0.03797114f, -0.25325868f, 0.67410159f, 0.00267132f, 
    0.17922579f, 0.15866560f, -0.14829060f, 0.04209269f, 0.07099070f, 0.03430985f, -0.00023790f, -0.00920823f, 
    -0.08318949f, -0.05875852f, 0.04058948f, -0.01085674f, -0.04130382f, -0.05223776f, 0.04914346f, 0.00793764f, 
    -0.29154322f, -0.14272697f, -0.10177344f, 0.03255128f, 0.06739805f, 0.01049385f, -0.03836532f, -0.05753788f, 
    0.05800444f, 0.07675671f, 0.05018314f, -0.04127681f, 0.07253642f, -0.01779047f, 0.27736700f, -0.21384892f, 
    -0.08311375f, -0.00138150f, 0.05172379f, 0.03552588f, -0.02891623f, -0.03139601f, 0.15985249f, 0.03470107f, 
    -0.31638074f, 0.01564280f, 0.14473265f, 0.09388899f, -0.10578907f, 0.18290918f, -0.09995114f, -0.02309910f, 
    -0.08248077f, -0.00709597f, 0.01852050f, 0.03969907f, -0.06177786f, 0.20412901f, 0.12479433f, 0.03124809f, 
    0.23012632f, -0.27184051f, -0.09663931f, 0.00559179f, -0.23189169f, -0.12477898f, 0.12443290f, 0.19981818f, 
    -0.07247198f, 0.04934334f, 0.06957899f, -0.02305945f, -0.10013014f, -0.01796843f, 0.02296371f, 0.03481969f, 
    0.13918027f, -0.04021446f, -0.00612075f, -0.06774754f, -0.06235974f, 0.10290137f, 0.10840412f, 0.14957012f, 
    -0.06853811f, -0.06590325f, 0.08193748f, -0.03482387f, -0.09733359f, 0.02336239f, 0.03739027f, 0.01857618f, 
    -0.15043344f, 0.01681795f, 0.10755192f, 0.12035055f, -0.01269807f, 0.07492551f, 0.25234252f, 0.10911988f, 
    0.67117286f, -0.12304562f, 0.20812929f, 0.10060169f, 0.11396179f, 0.20502047f, -0.04992670f, 0.15183482f, 
    -0.00124572f, 0.07604793f, 0.03059016f, 0.00475710f, 0.10086093f, -0.04869994f, 0.03242069f, 0.03401690f, 
    0.20296417f, 0.02119614f, 0.20205313f, 0.10249249f, -0.28425100f, -0.21937867f, 0.04455294f, 0.15757906f, 
    0.03995862f, -0.06135504f, -0.15229964f, 0.18388115f, -0.08995663f, -0.03993616f, -0.04577289f, -0.11644648f, 
    0.08195143f, 0.15610278f, -0.06832050f, 0.08140735f, 0.16231239f, 0.06822976f, 0.24232824f, 0.05208484f, 
    -0.05620606f, 0.53537929f, -0.24959034f, 0.18967512f, 0.03866003f, 0.05094002f, 0.14699027f, -0.05196514f, 
    0.03032082f, -0.14459036f, -0.06029655f, 0.03775290f, -0.01977845f, 0.02254152f, 0.13714039f, 0.03973003f, 
    0.03805468f, 0.08852357f, 0.04579075f, 0.19747482f, -0.23531325f, -0.04628676f, -0.13503142f, -0.00746817f, 
    0.08316023f, -0.04657933f, -0.18043043f, 0.03081491f, 0.01483197f, -0.08487137f, -0.06064031f, -0.04369271f, 
    0.03523212f, -0.13216282f, 0.15013975f, -0.16788098f, 0.00027493f, 0.01678115f, 0.06259079f, 0.17214817f, 
    0.11266855f, 0.09463771f, -0.25104704f, 0.34599304f, 0.04261929f, 0.09985570f, -0.11319976f, -0.10629441f, 
    0.05627260f, 0.04792346f, 0.04266465f, 0.07970647f, -0.13074753f, 0.08385325f, 0.11388606f, 0.08068291f, 
    0.02183140f, 0.11698602f, -0.07410613f, -0.12597694f, 0.43403625f, 0.18774490f, -0.27706707f, 0.11540959f, 
    -0.14227487f, 0.15621130f, 0.06916931f, -0.03847903f, 0.02098183f, 0.14256999f, 0.00821262f, -0.00498095f, 
    0.03883910f, 0.14558606f, 0.09523553f, 0.08060092f, -0.02979087f, -0.18543835f, 0.06893185f, 0.05761963f, 
    0.04199529f, 0.01070548f, 0.01877423f, 0.21753842f, -0.18019287f, -0.15150152f, -0.05003188f, 0.05704432f, 
    0.02136526f, 0.08838294f, 0.10700250f, 0.00418108f, -0.02053332f, -0.07586233f, 0.20351307f, -0.01682103f, 
    -0.16460630f, 0.05362275f, 0.04826284f, -0.06307250f, -0.43690792f, -0.17495391f, 0.11454941f, 0.04030873f, 
    0.15380268f, 0.04822525f, -0.08896744f, -0.03398965f, -0.04760944f, 0.01450937f, -0.10971277f, 0.05380573f, 
    0.06862736f, 0.15818329f, 0.11295695f, -0.10997955f, -0.01467642f, 0.06318218f, -0.01151793f, 0.01585084f, 
    0.43056732f, 0.14545655f, -0.11132327f, 0.43318164f, -0.19848910f, 0.03112669f, 0.17306514f, 0.03804303f, 
    0.08801121f, -0.03774828f, 0.03673049f, -0.06088425f, -0.15303947f, 0.17264357f, 0.13854823f, 0.03027020f, 
    0.04504772f, 0.10387145f, -0.14493082f, 0.14861108f, -0.34530139f, -0.22329602f, -0.19894540f, 0.11610623f, 
    -0.26814127f, -0.13434863f, -0.03361956f, -0.10052720f, 0.08907501f, 0.06150551f, 0.03750991f, 0.04665804f, 
    0.00250699f, -0.12886342f, 0.05483542f, 0.02691339f, 0.06317303f, 0.10819781f, -0.05275666f, -0.01082125f, 
    -0.01198408f, -0.34749019f, -0.07987940f, -0.25499010f, 0.00118639f, -0.21497357f, 0.00512178f, 0.12785062f, 
    -0.16490901f, -0.04416811f, -0.05126833f, 0.04171130f, 0.14233992f, 0.00441618f, -0.00676291f, -0.02200822f, 
    -0.03425078f, 0.00563059f, -0.09252159f, 0.00983574f, -0.19313045f, 0.34814134f, -0.04081291f, 0.01202943f, 
    -0.21991859f, -0.03381996f, -0.20589557f, 0.07050513f, 0.13485955f, 0.03088676f, 0.00327783f, 0.20381638f, 
    0.01956590f, 0.15090634f, 0.05557381f, 0.01310479f, -0.05605519f, 0.01988930f, 0.12196543f, -0.08329646f, 
    -0.23430590f, -0.00517836f, -0.29671386f, -0.18132187f, 0.03743789f, 0.03336002f, -0.05748936f, 0.00672299f, 
    -0.08532568f, -0.08243372f, 0.01861415f, -0.00362537f, -0.05304654f, -0.09849194f, 0.15685731f, 0.00728070f, 
    0.03487327f, -0.05696644f, -0.02136646f, -0.00638647f, -0.08974875f, 0.07866795f, 0.09771037f, 0.23673600f, 
    0.58430386f, 0.11069005f, -0.05905676f, 0.08667953f, 0.08303417f, 0.20147268f, 0.12890643f, 0.01619847f, 
    0.07853336f, 0.11465519f, 0.04354789f, 0.06403749f, 0.02296792f, 0.07498377f, -0.08302103f, -0.03120823f, 
    0.36275065f, -0.05869742f, -0.17901696f, 0.14342467f, 0.06564346f, 0.07715052f, 0.12352737f, -0.04725916f, 
    0.01987179f, 0.07062874f, 0.10584340f, 0.03631986f, 0.03352275f, 0.00202844f, 0.03933082f, 0.10801729f, 
    0.07842030f, 0.05351216f, 0.02536792f, 0.07249441f, -0.09504786f, 0.48515430f, -0.19409297f, -0.09034650f, 
    0.19371697f, 0.09549135f, -0.02336399f, -0.00423479f, 0.10414166f, -0.04107864f, -0.06276294f, 0.07825702f, 
    0.13893902f, -0.01360277f, 0.00826724f, -0.03357111f, -0.00011198f, 0.12290772f, 0.16834868f, -0.00250821f, 
    0.00029781f, -0.03827555f, 0.11083488f, -0.07423262f, 0.02131793f, 0.08315568f, 0.04192745f, 0.03763071f, 
    0.02180305f, -0.02919623f, -0.05583972f, 0.01586764f, -0.04375867f, -0.01769682f, 0.06737471f, -0.02632495f, 
    0.05318367f, 0.10142197f, -0.04193085f, -0.02633088f, -0.50160396f, -0.09165620f, -0.26321757f, 0.03905258f, 
    -0.01058308f, 0.05875599f, -0.08430296f, 0.24865337f, -0.11822198f, -0.16576812f, 0.05343581f, -0.11024977f, 
    0.12649904f, -0.01515157f, 0.08232176f, 0.18539807f, 0.02476960f, -0.08247979f, 0.16273925f, 0.16034073f, 
    0.16445947f, 0.11045692f, -0.15569389f, 0.04097265f, 0.17525443f, -0.00457447f, -0.27601346f, -0.01996538f, 
    0.09755401f, 0.01173836f, 0.06999180f, 0.01399581f, 0.05868058f, 0.06412361f, -0.14150208f, 0.01952219f, 
    0.04977993f, -0.01627948f, -0.06717990f, 0.09523039f, -0.39423281f, 0.40481231f, -0.26275378f, -0.27497470f, 
    0.27032909f, 0.12879883f, -0.16708322f, 0.01642486f, -0.02878087f, -0.04652315f, 0.01586527f, 0.13870402f, 
    -0.01255134f, -0.07140959f, 0.02011169f, -0.04541520f, 0.14031319f, 0.09006508f, -0.07245661f, 0.06205453f, 
    -0.05758848f, -0.04437665f, -0.03354519f, -0.03560680f, -0.01869917f, -0.06052168f, 0.00353958f, -0.00593452f, 
    -0.02478823f, -0.04060172f, -0.03419949f, -0.01148741f, 0.04120763f, 0.03818170f, 0.04588196f, -0.00485378f, 
    0.00091481f, -0.05589181f, 0.02962293f, -0.03996992f, -0.00924172f, 0.03888425f, -0.02655602f, 0.02361160f, 
    0.03486692f, -0.05307458f, -0.00197939f, 0.00213225f, -0.03284593f, -0.04003504f, -0.05581882f, -0.03016227f, 
    0.02706755f, 0.01645446f, 0.00045715f, -0.02959316f, -0.00443344f, 0.00054136f, 0.04987886f, 0.03163848f, 
    -0.04280630f, -0.03788735f, -0.05044582f, -0.02363367f, 0.02233115f, -0.05720682f, -0.01677869f, 0.01017320f, 
    -0.01248561f, -0.02955543f, -0.00916536f, -0.03392524f, -0.05023701f, 0.04391607f, -0.05036381f, -0.05524414f, 
    -0.03309892f, 0.03372560f, -0.04664590f, -0.03925974f, 0.00565944f, 0.01788183f, -0.00370741f, 0.04860969f, 
    -0.05897390f, -0.03268929f, 0.01116924f, 0.04332525f, -0.04094388f, 0.03704362f, 0.01117555f, 0.01669554f, 
    -0.01988783f, -0.02769529f, -0.01179428f, 0.01505672f, 0.00407196f, 0.00425971f, 0.02966660f, -0.02239010f, 
    -0.01491042f, -0.02880875f, 0.03043425f, -0.02538269f, 0.04967341f, -0.05069001f, -0.00092756f, -0.04422305f, 
    -0.02362232f, 0.02392072f, -0.00098585f, -0.04873661f, -0.01202806f, -0.04624073f, -0.02407252f, 0.02713633f, 
    0.01213126f, 0.03555690f, 0.01875662f, -0.05368403f, -0.03800041f, -0.05137295f, 0.04869837f, 0.01679380f, 
    0.02379514f, 0.01450880f, -0.05641161f, -0.00591402f, 0.02062285f, -0.00506162f, -0.03428566f, 0.03393491f, 
    -0.02678722f, -0.00936961f, -0.05352183f, 0.02720451f, -0.05332551f, 0.00023006f, 0.03310529f, -0.05060707f, 
    -0.04187670f, -0.01550059f, -0.03249886f, -0.01324941f, -0.05166266f, 0.00786088f, -0.00078470f, 0.04393758f, 
    0.00002917f, 0.04522095f, -0.01769708f, -0.01633519f, 0.00268074f, -0.02681306f, -0.05121772f, 0.03636789f, 
    -0.00566265f, -0.01583921f, 0.03255273f, -0.04429033f, -0.04203608f, -0.01516809f, -0.04172057f, 0.02879328f, 
    0.03496782f, -0.03804113f, 0.02127290f, 0.04397025f, -0.01269980f, -0.04060875f, 0.01069525f, 0.03452677f, 
    0.04273697f, -0.03648993f, 0.04112596f, 0.04457225f, -0.04225210f, -0.00211391f, -0.03365250f, 0.05365418f, 
    0.01322762f, -0.03105349f, 0.00247678f, -0.02523563f, -0.02854159f, -0.03952647f, -0.05695435f, -0.03087439f, 
    -0.05290711f, 0.03855444f, 0.04779746f, -0.00369054f, -0.03356452f, -0.04613826f, -0.04335004f, 0.00832955f, 
    0.01683715f, -0.02672593f, 0.00328732f, 0.01310192f, -0.03139574f, -0.05947117f, -0.01746261f, -0.05747316f, 
    -0.05041261f, 0.03096721f, 0.02573845f, 0.04773775f, -0.05079449f, 0.03350168f, 0.04882835f, 0.01635113f, 
    -0.03990670f, -0.01834355f, -0.03283120f, 0.02508036f, -0.00461982f, 0.04746510f, -0.02061178f, 0.04470794f, 
    0.01957827f, -0.04957335f, -0.02622276f, -0.05703063f, 0.04029883f, 0.03360757f, -0.05660167f, 0.00496506f, 
    0.00003810f, 0.02647238f, -0.05556488f, 0.03954735f, -0.05860625f, 0.04615011f, 0.00139296f, 0.01595938f, 
    0.02331361f, 0.00458842f, 0.04496547f, -0.01108030f, -0.04219413f, -0.00939659f, 0.04747120f, 0.02708023f, 
    0.04953650f, -0.04404105f, -0.00981499f, 0.01159624f, -0.02428690f, -0.03025779f, -0.00950529f, 0.00268591f, 
    -0.04230868f, -0.05058416f, -0.06120344f, -0.05391037f, 0.03799984f, -0.01983014f, 0.00766492f, 0.00465638f, 
    -0.00267238f, 0.02481474f, 0.00246578f, 0.02375488f, 0.00605572f, 0.03060693f, 0.04245856f, -0.02209975f, 
    0.03846518f, -0.04455353f, -0.03809375f, -0.02079958f, 0.00163101f, -0.03999337f, 0.01570925f, 0.00889483f, 
    0.02395036f, -0.05919332f, 0.02427688f, -0.04692591f, -0.02796247f, -0.05601933f, -0.04970315f, -0.02646521f, 
    0.04867261f, 0.00102465f, -0.00976945f, -0.00602385f, 0.00154612f, -0.01442435f, 0.00158528f, 0.03894766f, 
    -0.04206518f, -0.03963446f, -0.04583797f, -0.01268778f, 0.02052669f, -0.01068529f, 0.00312355f, 0.00404695f, 
    -0.04945488f, -0.03228517f, -0.03819291f, -0.01302829f, -0.01960733f, -0.02748429f, -0.06078351f, -0.01653624f, 
    -0.01079670f, -0.00389758f, -0.05424104f, -0.01516270f, -0.03157892f, -0.03884932f, -0.04945329f, 0.03850333f, 
    0.02956275f, -0.04372758f, -0.04209609f, -0.02084137f, 0.01725444f, -0.05708398f, 0.01239649f, 0.01602705f, 
    -0.02315005f, -0.02824133f, 0.02395873f, 0.02938825f, -0.04826451f, -0.05881532f, 0.03561868f, -0.01150095f, 
    0.04136587f, -0.02326266f, 0.03582570f, -0.06099337f, -0.03475071f, 0.04405328f, -0.03599972f, 0.01548804f, 
    -0.00510515f, 0.04644376f, -0.03979817f, -0.01689528f, 0.01145868f, 0.01670071f, -0.02401380f, -0.01218093f, 
    0.03863524f, -0.03607808f, 0.02281099f, 0.02558866f, -0.03904230f, 0.03679230f, -0.01293141f, -0.05765181f, 
    0.01118391f, -0.01651046f, 0.00655416f, 0.03509809f, -0.05589662f, 0.03013267f, 0.00187253f, 0.01386204f, 
    0.03722675f, 0.01031302f, 0.03963713f, 0.03845748f, 0.04140013f, -0.03960028f, -0.00132874f, -0.01159810f, 
    0.04167333f, 0.01279870f, 0.03526963f, -0.04904632f, -0.01785597f, -0.02838383f, -0.05012359f, -0.06732642f, 
    0.04729137f, -0.05072852f, -0.05062342f, -0.05521149f, -0.05101313f, -0.02855392f, 0.01164692f, 0.04363480f, 
    -0.00608535f, -0.00849731f, -0.04954559f, 0.04404456f, -0.01811110f, 0.04903514f, 0.02335002f, 0.04274550f, 
    -0.02817162f, -0.05232058f, 0.03922386f, 0.03060909f, -0.00282532f, 0.03779591f, -0.01167420f, -0.05805992f, 
    -0.01350587f, -0.06116480f, -0.06388384f, 0.02283158f, 0.01463234f, -0.01616887f, -0.01445776f, -0.01166793f, 
    -0.04876592f, -0.04551677f, 0.01276253f, -0.05325893f, -0.01076271f, 0.02508877f, -0.02391193f, -0.05387902f, 
    -0.06458656f, 0.02666965f, -0.02643471f, 0.02610633f, -0.04042699f, 0.03774261f, 0.01481126f, -0.05212121f, 
    -0.05687148f, -0.03682479f, -0.05669048f, -0.03731034f, -0.03342125f, 0.02486421f, 0.04008044f, 0.02750081f, 
    0.01459702f, 0.04091648f, 0.00899794f, -0.02957483f, -0.02857357f, 0.02819480f, -0.02048692f, -0.03527632f, 
    -0.00408074f, -0.05120803f, -0.03215967f, -0.05430545f, 0.02955667f, 0.03698508f, 0.01770312f, -0.01817084f, 
    -0.05314635f, -0.01963623f, 0.02690425f, 0.01469234f, -0.02856826f, -0.01401843f, -0.04351907f, -0.00102529f, 
    0.01443405f, -0.02249835f, 0.00451743f, 0.04201686f, 0.02930792f, -0.00722689f, 0.02085962f, -0.02755550f, 
    0.03380887f, 0.03017207f, -0.01740422f, -0.02520858f, -0.03258210f, 0.01538026f, -0.00547296f, -0.01376907f, 
    0.02144124f, 0.05040554f, -0.03190337f, 0.02019328f, -0.04002042f, -0.04911972f, -0.04363550f, 0.03006788f, 
    0.00150354f, -0.04895599f, 0.04183669f, -0.05214243f, -0.04971870f, -0.01461782f, -0.03731064f, -0.01249267f, 
    -0.02601756f, -0.06351954f, 0.02394419f, -0.04909692f, 0.03094292f, 0.04217367f, -0.02486918f, 0.00432017f, 
    0.01476625f, 0.01161800f, -0.01174321f, -0.04976476f, 0.01247110f, -0.05747896f, 0.02792906f, 0.01658537f, 
    -0.03554328f, 0.01814020f, -0.02210810f, -0.04219886f, -0.01697685f, 0.04783154f, -0.06378864f, 0.02382529f, 
    -0.06260255f, -0.04497657f, 0.03190561f, 0.03004625f, 0.03056115f, 0.01641132f, -0.02977272f, -0.01588865f, 
    0.01780964f, -0.04615172f, 0.03127090f, -0.00931839f, -0.01717040f, 0.03824172f, -0.02268396f, 0.00531682f, 
    0.03022259f, 0.01463330f, 0.01971028f, 0.00459830f, -0.05336773f, -0.05095112f, 0.02295843f, -0.05203750f, 
    -0.05626918f, 0.03441559f, 0.04361394f, -0.05811886f, 0.02702908f, 0.00819190f, 0.01570652f, 0.03434922f, 
    -0.06510915f, -0.02746698f, 0.01207140f, 0.00605382f, -0.05034188f, 0.01694768f, 0.02538678f, 0.00447833f, 
    0.03578695f, -0.02065411f, 0.00024439f, -0.00655381f, 0.01005987f, -0.03061163f, 0.02411827f, -0.00146986f, 
    -0.01313163f, -0.03985448f, -0.01877589f, -0.05575472f, -0.01226939f, -0.05264827f, 0.02124382f, 0.00895987f, 
    -0.05572383f, -0.01099051f, 0.00600451f, 0.00044138f, 0.01765260f, -0.02225005f, -0.02699188f, 0.01741952f, 
    -0.00793464f, 0.01741615f, 0.04587199f, 0.02196619f, -0.03663211f, -0.06252287f, -0.01181010f, -0.01139098f, 
    0.00602640f, 0.02936275f, 0.00564418f, -0.04991077f, -0.02205689f, -0.06355204f, 0.04370552f, -0.01803851f, 
    -0.04225015f, -0.05076089f, 0.00410835f, -0.01452647f, -0.01154194f, 0.03463724f, -0.05818951f, 0.03110402f, 
    -0.02276956f, 0.04144597f, -0.04949918f, 0.01527176f, -0.04490872f, -0.02640763f, -0.02921513f, 0.01053150f, 
    -0.02562334f, 0.03497787f, 0.03586956f, -0.01065910f, 0.01459884f, 0.00266109f, -0.04479675f, -0.00114822f, 
    0.02686580f, 0.03002176f, -0.03343777f, -0.04922637f, -0.03055999f, 0.02012484f, -0.04517382f, -0.00302188f, 
    -0.01411646f, -0.05793401f, -0.02935116f, 0.01855110f, -0.00761308f, -0.05998561f, -0.00021365f, 0.00199316f, 
    0.01918957f, -0.06803447f, -0.01765778f, -0.04231149f, -0.02720481f, -0.02245501f, -0.05348260f, 0.01520901f, 
    -0.03270475f, 0.02688658f, -0.02079576f, 0.04238640f, -0.02695085f, -0.04371135f, 0.02529099f, 0.02265315f, 
    -0.03786204f, 0.04084755f, 0.02637763f, 0.01744344f, -0.00326660f, 0.00685519f, -0.06216559f, 0.00411985f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00577686f, 0.09183581f, -0.00923988f, -0.01830468f, -0.06178889f, -0.01750969f, -0.01367815f, -0.01108250f, 
    -0.06605826f, -0.05419289f, -0.00653028f, -0.04857269f, 0.11789722f, 0.03783472f, 0.01825717f, 0.07962854f, 
    -0.06299193f, -0.03009479f, 0.01474982f, -0.06422795f, -0.00317382f, 0.00169811f, 0.09616011f, 0.06193767f, 
    -0.02149905f, -0.08487055f, 0.08806057f, 0.09794277f, -0.00520398f, 0.02943947f, 0.00506548f, 0.00002103f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.53246897f, 0.12665886f, 0.71907616f, 0.45318300f, 0.03100073f, 0.03704986f, -0.10705473f, 0.02638388f, 
    -0.02059213f, 0.24374279f, -0.07793013f, 0.06439237f, -0.22753529f, 0.19519880f, -0.13718170f, -0.00936152f, 
    0.30849841f, -0.09605108f, 0.16855337f, -0.69610262f, -0.11380594f, -0.02066338f, -0.15625262f, -0.10799295f, 
    -0.46581614f, -0.04774959f, 0.29687285f, -0.95830172f, -0.31462198f, -0.38659525f, -0.13364066f, -0.14194492f, 
    -0.28490251f, 0.33338884f, -0.12892938f, 0.00684390f, 0.07331990f, 0.04070114f, 0.01109703f, 0.09500081f, 
    0.13814893f, -0.20254739f, -0.44120654f, -0.06117008f, 0.35079494f, 0.26480055f, -0.06141759f, 0.24910715f, 
    -0.09807956f, -0.35936633f, -0.05478239f, 0.06308316f, 0.05749995f, 0.15300386f, -0.21006680f, 0.27992868f, 
    -0.69042611f, 0.00372841f, 0.30921426f, 0.29372332f, -0.72974932f, -0.12508409f, -0.09523330f, 0.16345093f, 
    0.38588011f, 0.18967707f, -0.20273282f, -0.07525995f, 0.19346084f, -0.05164470f, 0.11601490f, -0.02978893f, 
    0.06398767f, -0.14788614f, 0.47167942f, 0.06778026f, -0.28038058f, 0.10062420f, -0.05744153f, -0.50458652f, 
    0.39616740f, -0.21273018f, -0.69329768f, -0.04383165f, 0.12721367f, -0.01501751f, -0.15526079f, -0.21890193f, 
    -0.19739297f, 0.08433705f, 0.23542021f, 0.51694804f, -0.41644862f, -0.42645410f, -0.01847187f, -0.03193383f, 
    -0.14377302f, 0.06682875f, -0.02671355f, -0.42679846f, 0.21751727f, -0.08974589f, 0.16325286f, -0.14904886f, 
    0.14375348f, 0.45395833f, -0.81018323f, -0.17560585f, -0.52795070f, -0.02125205f, -0.01321995f, -0.57944787f, 
    -0.11179549f, -0.09878691f, 0.15093285f, 0.38674888f, 0.08686294f, -0.04599380f, 0.24492759f, -0.14313625f, 
    -0.44718790f, 0.31163147f, -0.60363859f, -0.15999117f, 0.37575895f, 0.38677669f, -0.07501848f, -0.03733190f, 
    -0.13459823f, -0.23863181f, 0.09613702f, -0.13646674f, 0.20613396f, -0.00713832f, -0.06339473f, 0.02786327f, 
    -0.15883017f, 0.38024169f, -0.66033614f, -0.02711644f, -0.09562035f, 0.05693620f, 0.13038148f, 0.28417888f, 
    -0.10123551f, 0.15704523f, -0.30446646f, -0.53153753f, 0.07836579f, 0.11888985f, 0.02567106f, -0.44465885f, 
    0.49206743f, 0.23669459f, -0.02989926f, 0.10087972f, 0.21432547f, 0.03850301f, -0.08482438f, -0.15019576f, 
    -0.36298743f, -0.23919609f, -0.69869769f, 0.32438260f, 0.37496480f, -0.15406160f, 0.14036258f, 0.15734281f, 
    0.05018011f, 0.11073562f, 0.16852793f, -0.09184517f, 0.16648498f, -0.15235879f, -0.00302650f, 0.39984813f, 
    -0.31675264f, 0.42938557f, -0.41452411f, -0.07470944f, -0.10859415f, -0.13385560f, 0.26231357f, 0.21296957f, 
    -0.20473060f, -0.20859054f, 0.10229357f, -0.28451607f, -0.24136494f, 0.25857604f, 0.01692478f, -0.05266570f, 
    -0.46229276f, 0.31751615f, -0.88492388f, 0.23389879f, -0.37785503f, 0.09383862f, 0.02444894f, 0.09654893f, 
    -0.18457773f, -0.32393977f, 0.08057950f, 0.10153861f, 0.33612767f, 0.07076117f, -0.06699939f, 0.01849441f, 
    0.40806106f, -0.53303969f, -0.47711915f, 0.07826016f, 0.08339287f, 0.11699805f, 0.10793091f, -0.14652760f, 
    0.42158285f, -0.06643177f, -0.29981610f, -0.41957581f, 0.45315012f, 0.32452360f, -0.09210116f, -0.15299803f, 
    0.33680117f, -0.49786690f, 0.28741679f, -0.60133380f, -0.13139160f, -0.16545214f, 0.16505013f, 0.01741492f, 
    -0.06463024f, -0.28331104f, 0.07288469f, -0.05818366f, 0.24273194f, -0.36926761f, 0.02575663f, -0.04794221f, 
    0.29141840f, 0.13906260f, 0.07131413f, 0.36739293f, -0.02354926f, -0.16956411f, 0.28115198f, -0.05228012f, 
    0.36311552f, 0.25305039f, -0.37437636f, -0.24763900f, -0.09556746f, -0.42886257f, -0.08771370f, 0.05272890f, 
    0.40416014f, 0.05435519f, -0.08131841f, 0.04284328f, 0.28287539f, 0.16730253f, 0.13858166f, 0.04506888f, 
    -0.10052159f, -0.82548195f, 0.12423674f, -0.13767464f, -0.36750010f, 0.03728338f, 0.10125107f, 0.16324426f, 
    -0.58422786f, -0.46879399f, -0.16152397f, 0.17626694f, -0.03451049f, -0.10894436f, -0.36084044f, 0.26714629f, 
    0.38907725f, 0.43007448f, -0.04760033f, -0.16355164f, -0.03602694f, -0.08050701f, 0.15535788f, 0.14981434f, 
    0.08223135f, 0.19735301f, 0.50761402f, -0.04709584f, -0.08125697f, -0.11054711f, -0.05113691f, -0.03901048f, 
    0.15482175f, -0.32489419f, -0.01463202f, 0.01317296f, 0.15659794f, -0.26865441f, 0.03091118f, 0.10877974f, 
    0.01641284f, 0.24530178f, 0.03843942f, 0.49235913f, -0.13605104f, 0.07478582f, -0.19594496f, 0.07100355f, 
    0.24696569f, -0.87036932f, 0.20452672f, 0.22616316f, 0.57716757f, -0.39836749f, -0.13363467f, 0.09267455f, 
    0.22355802f, -0.09223812f, -0.21637000f, -0.80134219f, -0.70160931f, -0.07761763f, 0.09420034f, -0.11125802f, 
    -0.00135781f, -0.18558216f, -0.05622478f, -0.00149553f, -0.27007249f, 0.34211218f, -0.11748774f, 0.39776799f, 
    -0.12037084f, -0.33532903f, 0.14283438f, -0.40799975f, -0.15302502f, -0.13251410f, 0.33816534f, 0.38339025f, 
    -0.50932753f, -0.02301864f, -0.10905433f, 0.38768587f, 0.01300501f, -0.02929985f, 0.08249963f, -0.13771886f, 
    0.25632095f, 0.27801579f, 0.11555253f, 0.13436061f, -0.35995308f, -0.01152076f, -0.14402501f, 0.08896728f, 
    -0.08836018f, 0.39174446f, 0.36759022f, -0.14305845f, 0.27630484f, -0.08771072f, -0.15412569f, -0.50433946f, 
    -0.56192100f, 0.30384478f, -0.00339053f, 0.02866940f, -0.01999210f, -0.06618844f, -0.08905336f, 0.08026925f, 
    0.21249938f, 0.17249651f, -0.55787492f, -0.14923446f, -0.54462445f, 0.30616787f, 0.02669692f, -0.10916370f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18037017f, 0.18890420f, -0.01977897f, 0.12560202f, 0.00290323f, -0.02277181f, -0.10989493f, -0.17257893f, 
    -0.07497429f, 0.11332182f, 0.17822328f, -0.15520036f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
