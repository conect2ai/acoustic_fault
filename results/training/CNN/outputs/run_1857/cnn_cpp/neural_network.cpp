#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.17680648f, 0.19866996f, -0.63898253f, -0.91395956f, -1.03712952f, 0.56597811f, -0.17963569f, -0.06549054f, 
    0.24194105f, 0.30316520f, 0.17119507f, 0.33556572f, 0.44259855f, 0.47211573f, 0.28019267f, -0.06335097f, 
    0.13385159f, -0.19659548f, -0.10497359f, 0.06079054f, 0.11732381f, -0.22474296f, -0.35300520f, -0.01637987f, 
    -0.35348272f, 1.84675348f, -1.18747711f, -0.62650430f, -0.65974170f, -0.90469521f, 0.96247399f, -0.17898835f, 
    0.13719845f, 0.58683211f, 0.32725278f, -0.25019678f, 0.06529641f, -0.08862875f, 0.07730621f, 0.27053240f, 
    -0.30594477f, 0.17653133f, 0.34295771f, -0.08223235f, -0.31178632f, 0.07660051f, -0.19381243f, -0.05121264f, 
    0.20626050f, 0.28918979f, 0.06767708f, -0.21493545f, 0.26167527f, 0.71899068f, -1.25297391f, -0.20405112f, 
    -0.24411035f, -0.00393414f, -0.08918224f, -0.34920073f, 0.58929199f, -0.07961801f, 0.33485600f, 0.31036896f, 
    0.24618790f, -0.01323510f, 0.36769450f, -0.37141201f, -0.27935573f, -0.37337354f, 0.56591725f, 0.09915984f, 
    0.14349401f, 0.18715069f, 0.11172243f, -1.34817517f, -1.15842438f, 0.07232974f, 0.43880948f, -0.05040065f, 
    -1.33268237f, -1.34466326f, 0.25129837f, -0.20694923f, -0.71755219f, 0.36476731f, 0.10543339f, 0.02358779f, 
    -0.21780811f, 0.13261014f, -0.08720347f, -0.20796968f, -0.25167540f, -0.72032499f, -0.83751035f, -0.25207195f, 
    0.56688035f, -0.41420519f, -0.48646563f, 0.52408195f, 0.50689745f, 0.75819665f, -0.36592934f, -0.58503622f, 
    -0.27563456f, 0.10152121f, 0.06451565f, 0.05755359f, -0.31434038f, -0.47896972f, 0.54441267f, -0.25202432f, 
    0.02259299f, -0.02773330f, -0.06895449f, 0.32867533f, 0.06659800f, -0.17920248f, -0.11052912f, -0.27766734f, 
    -0.55754375f, -0.30427426f, -0.47098404f, -0.49177620f, -0.58742392f, -2.04845095f, -0.79385954f, -0.88889587f, 
    -0.15008011f, 0.52275550f, 0.47072071f, -0.18040901f, 0.26204327f, 0.72990328f, 0.72989517f, 0.43305370f, 
    0.30850446f, -0.25909340f, 0.33920872f, -0.47875997f, -0.02969549f, -0.03677089f, -0.50301242f, 0.27824414f, 
    -0.28316894f, 0.20022474f, 0.08309978f, 0.10694474f, -0.04794477f, 0.02544290f, -0.82448143f, -0.82583016f, 
    -1.13433385f, -0.76203597f, -0.17682244f, -0.08295560f, -0.73430961f, -0.68998164f, -0.79043806f, -0.57209635f, 
    -0.61350465f, -0.55408025f, -0.22094335f, 0.32792726f, -0.16096459f, 0.06436089f, 0.13789283f, 0.20596424f, 
    -0.22681481f, -0.36264908f, -0.23568296f, 0.16778912f, 0.35791928f, 0.23075329f, -0.02045772f, 0.84640449f, 
    1.05688202f, -0.64377725f, 0.19285190f, 0.01195489f, -0.85017490f, -0.80226588f, -0.10206864f, 0.74231708f, 
    0.10159609f, 0.08981087f, -0.38779339f, -0.08444320f, 0.12923820f, -0.23880932f, -0.02709491f, 0.37333012f, 
    0.23024942f, -0.23867588f, -0.27128252f, 0.00854003f, 0.18188567f, -0.08608697f, -0.12609889f, -0.06518381f, 
    0.01977185f, -0.13202153f, 0.17570682f, 0.40647042f, 0.00059169f, -0.00326917f, -0.17379119f, 0.23358481f, 
    0.28883794f, 0.33887017f, 0.03682270f, 0.74485654f, 0.13174406f, -0.29592514f, -0.48073697f, -0.06943921f, 
    0.27890125f, -0.10909088f, -0.31859806f, 0.06419875f, -0.25569788f, 0.40048355f, 0.37792590f, -0.07490361f, 
    -0.14052834f, 1.03358495f, 1.10477424f, -0.17974392f, -0.88703507f, -0.41820517f, -0.54859561f, -0.86328369f, 
    0.17577522f, -0.96240026f, -1.70511925f, -0.16618840f, 0.08595757f, 0.80338418f, -0.47541401f, -0.06002448f, 
    0.29239064f, 0.00385219f, 0.28732574f, -0.06105577f, 0.03177043f, -0.14552559f, 0.12395126f, -0.23644608f, 
    -0.17511737f, 0.48900118f, 1.44959354f, 0.77173042f, 0.24210358f, -0.30359682f, -0.19830275f, 0.04106433f, 
    0.31351781f, 0.12765220f, -0.70657110f, -0.40109253f, -0.36236852f, 0.15611838f, -0.16504988f, -0.34390077f, 
    -0.11577086f, -0.15404885f, 0.16289625f, 0.13040178f, -0.19932808f, -0.26071966f, -0.16032125f, -0.27452564f, 
    -0.41564700f, -0.32244819f, -0.35165998f, 0.92942065f, -0.76169986f, -1.12442565f, -0.06901639f, 0.60725552f, 
    0.94745320f, 0.90404302f, 0.57231247f, -0.16893962f, -0.64087039f, -0.26774898f, 0.09216648f, -0.02030847f, 
    -0.54945683f, -0.03155221f, -0.23555347f, -0.19470517f, 0.02371627f, -0.20537402f, -0.47097999f, 0.48962167f, 
    -0.00767211f, -0.26249585f, 0.01631958f, 0.20221825f, 0.71807563f, 0.85947829f, 0.66221148f, 0.23974131f, 
    -0.14964916f, -0.12822242f, -0.36300525f, -0.22560434f, 0.15232350f, -0.21303324f, -0.02980251f, 0.17638691f, 
    -0.19137919f, -0.37210208f, 0.37052026f, 0.24284019f, 0.40767255f, -0.25929627f, 0.22568344f, 0.06083713f, 
    -0.02896232f, 0.16750626f, 0.13982497f, -0.06785509f, 0.38836232f, -1.38035524f, -0.12963566f, -0.73950505f, 
    -1.71161294f, -1.90976858f, 0.24625915f, -0.25410342f, 0.24589242f, 0.59692782f, 0.91565001f, -0.48669130f, 
    -0.08691595f, -0.34092292f, -0.79798484f, -0.47573397f, 0.15367438f, 0.03378974f, -0.16288336f, -0.09309355f, 
    0.25793070f, -0.07527246f, -0.19685814f, -0.03884372f, 0.12477263f, 0.24027711f, -1.02087879f, -0.26943570f, 
    0.23998637f, 0.91129857f, 0.42400792f, -0.14041524f, 0.24010582f, -0.59311652f, 0.56246513f, 0.90017092f, 
    0.25261670f, -0.06790718f, -0.37121201f, -0.45827207f, 0.16715582f, -0.15480958f, -0.11096024f, -0.15418312f, 
    -0.04393519f, 0.25068772f, 0.05422438f, -0.35925484f, -0.00239925f, 0.13981919f, -0.03035603f, 0.52261966f, 
    -0.44027808f, -0.79793674f, -0.48744413f, -0.67206353f, -0.55456370f, -0.07414094f, 0.69578969f, 0.61146140f, 
    0.08172397f, 0.15082572f, -0.00320400f, -0.38218442f, -0.79336429f, -0.00754503f, -0.03638927f, -0.11608523f, 
    -0.65490174f, -0.35499731f, -0.38937953f, -0.78181726f, -0.14910161f, -0.40097916f, -0.78205848f, -0.87612247f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.11123724f, 0.70948339f, 0.25119597f, 0.29595616f, -0.07192857f, 0.31250858f, -0.66946566f, 0.75772095f, 
    0.71241754f, 0.67960632f, 0.31523141f, 0.79665905f, 0.06859194f, 0.02329567f, 0.70215255f, -0.11310044f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25413826f, -0.12130464f, -0.03240435f, 0.13691720f, 0.09188534f, 0.18739401f, 0.10995362f, 0.17570141f, 
    -0.12290778f, -0.05463469f, 0.05737298f, 0.08412290f, -0.21527636f, -0.57818729f, -0.66865849f, -0.04629810f, 
    -0.01152103f, -0.01543639f, -0.16581932f, -0.34803015f, -0.07951030f, -0.13228945f, -0.01242146f, 0.11484132f, 
    0.06170986f, -0.13136305f, 0.20646682f, -0.11367647f, -0.17407295f, 0.14456679f, -0.05971850f, -0.06662696f, 
    -0.13285266f, -0.09044042f, -0.19028266f, -0.04747822f, 0.39881915f, 0.29755831f, 0.33721215f, -0.41967165f, 
    -0.03019578f, 0.09576890f, 0.02377064f, -0.25643113f, -0.01466772f, -0.17967978f, -0.15115668f, -0.19820453f, 
    0.05835949f, -0.05283838f, -0.18585081f, 0.23300594f, 0.01701433f, 0.01243581f, -0.24269280f, 0.01313858f, 
    -0.19800830f, 0.18969458f, -0.12756184f, 0.02348996f, 0.66022205f, 0.52976286f, 0.46098119f, -0.21891852f, 
    0.10314389f, 0.27498719f, 0.22641891f, -0.05378721f, -0.00956410f, 0.00384539f, -0.19980456f, -0.11546859f, 
    0.61883515f, 0.18378246f, -0.07280879f, -0.26440665f, 0.12867758f, 0.32017770f, 0.15843357f, 0.01985245f, 
    -0.02270349f, -0.06343149f, 0.10334731f, 0.10445063f, -0.76818579f, -0.03764334f, 0.07258974f, -0.15148860f, 
    0.00783811f, 0.04290056f, -0.05305285f, 0.00405477f, -0.04597410f, -0.00597487f, -0.03507522f, -0.04378404f, 
    -0.16937803f, -0.14771320f, 0.02287401f, -0.14776956f, -0.08163936f, -0.02158551f, 0.02937217f, -0.11183730f, 
    -0.20380394f, -0.19973201f, 0.05019680f, -0.04409339f, 0.52975309f, -0.19590133f, -0.58609456f, 0.00733209f, 
    0.10940047f, -0.15049320f, -0.11318786f, 0.00330597f, 0.18031594f, 0.11598837f, -0.02913390f, -0.06320754f, 
    -0.88006914f, -0.92631257f, -0.48332977f, 0.36042473f, 0.02887339f, 0.16542503f, -0.00304011f, 0.00923018f, 
    -0.08905152f, 0.00873315f, 0.00792848f, 0.01451355f, -0.12573621f, -1.01036644f, -1.71664476f, -0.02723919f, 
    0.01245796f, 0.03683909f, 0.11669130f, -0.06071065f, -0.12241843f, -0.22786629f, -0.42785335f, -0.21473691f, 
    0.09678058f, 0.03882572f, 0.08606910f, 0.06878599f, -0.07795385f, -0.03814346f, -0.08319216f, 0.01871407f, 
    -0.07066398f, 0.03446469f, 0.05425520f, 0.02832239f, 0.04049061f, 0.06924251f, 0.08355168f, -0.21407318f, 
    0.15617202f, 0.41569042f, -0.06476709f, 0.06167540f, 0.07101547f, 0.08168560f, 0.00281338f, -0.00067096f, 
    0.34852046f, 0.31920704f, 0.21864997f, -0.35407972f, -0.11843425f, -0.02993875f, 0.05350596f, 0.07938553f, 
    -0.11195131f, -0.09711870f, -0.18463519f, -0.04600720f, 0.18840496f, -0.00849643f, -0.09885591f, 0.06664180f, 
    -0.01456992f, -0.08894654f, 0.04497423f, -0.09710714f, -0.23923868f, -0.03662368f, 0.10594870f, 0.41723838f, 
    -0.18611853f, -0.15405264f, 0.00367602f, -0.05063098f, 0.12463574f, -0.02030282f, -0.06994648f, -0.13766459f, 
    -0.03355299f, -0.00741136f, 0.06878074f, -0.00995203f, 1.04925668f, 0.08929351f, -0.18348037f, -0.34161422f, 
    0.01226934f, 0.10346512f, 0.06394561f, -0.09882775f, -0.02785915f, 0.06464200f, 0.11705481f, -0.30317998f, 
    -0.36231008f, -0.06710938f, 0.00864512f, -0.20190904f, -0.05314794f, -0.07049356f, 0.25794211f, 0.02210270f, 
    -0.18585077f, -0.10250355f, 0.17250797f, 0.05070739f, -0.82728380f, 0.34697413f, -0.20471035f, -0.12155163f, 
    -0.06672075f, 0.21412320f, 0.12461600f, 0.14294218f, -0.04343024f, 0.24795473f, -0.05132082f, -0.01923898f, 
    -0.08337195f, -0.21581595f, 0.01038031f, -0.14233455f, 0.11024938f, -0.11065650f, -0.18914582f, 0.06637501f, 
    -0.29371130f, -0.43065161f, -0.61047351f, -0.08550368f, -0.65937984f, -0.53817612f, -0.56657046f, 0.10216711f, 
    0.02577034f, 0.08277564f, 0.12376440f, -0.03340308f, -0.20336837f, 0.00680237f, 0.02250456f, 0.11178566f, 
    0.15799083f, 0.20944881f, 0.55836290f, 0.40764356f, 0.18210202f, -0.13315228f, 0.16088881f, 0.07621156f, 
    -0.00010536f, 0.04841808f, 0.00421035f, -0.10684366f, -0.36024016f, -0.03372498f, 0.33990699f, -0.08825202f, 
    0.09197259f, -0.11565962f, -0.04606751f, -0.10591862f, 0.04766216f, 0.05617192f, -0.02533704f, 0.07042863f, 
    0.08742200f, 0.09191276f, 0.15698647f, 0.00789485f, 0.12314568f, 0.11422900f, 0.01795703f, 0.12792648f, 
    -0.15321232f, 0.04503712f, -0.25142083f, 0.24263057f, 0.45360428f, -0.39379057f, -0.43023965f, -0.19905524f, 
    -0.48184177f, -0.15322773f, -0.09343473f, -0.33895320f, -0.18949926f, 0.01157406f, -0.03422036f, 0.19688292f, 
    0.59121805f, -0.04183633f, 0.20346513f, -0.23414856f, -0.00592188f, -0.07607068f, -0.11325268f, -0.00614265f, 
    -0.00901224f, 0.09185529f, -0.10824640f, 0.15544102f, 0.85840178f, -0.16166739f, 0.22823577f, 0.64773554f, 
    -0.09877355f, -0.05153810f, -0.01144667f, 0.08040383f, 0.11699580f, 0.22414555f, -0.11845788f, -0.15824938f, 
    0.15433939f, 0.09177247f, -0.00413108f, 0.06197346f, 0.04949475f, -0.03309368f, -0.00673814f, -0.07323820f, 
    -0.02248104f, 0.06226061f, -0.03458392f, -0.07324160f, 0.25679314f, 0.41786894f, -0.03648308f, -0.29234630f, 
    -0.16982245f, 0.20412396f, -0.15006346f, -0.10195374f, -0.01574406f, -0.04290844f, -0.08200470f, -0.10715454f, 
    0.27238053f, 0.28948128f, -0.03265813f, 0.16081038f, -0.06717752f, 0.10757449f, -0.08064193f, -0.01519858f, 
    0.08921678f, 0.17851475f, -0.03271029f, 0.28471553f, -0.12648986f, -0.16605440f, 0.06492290f, 0.05544026f, 
    0.00731279f, 0.14200991f, -0.06378389f, -0.03358470f, -0.16167441f, -0.14827129f, -0.56167150f, -0.22176200f, 
    0.13991502f, 0.06330227f, 0.07713500f, 0.11703452f, -0.04965613f, -0.01641320f, 0.12571110f, -0.17134808f, 
    0.17359465f, 0.26546505f, -0.04306332f, 0.12983243f, -0.78564590f, 1.09615874f, 0.49875256f, -0.13367999f, 
    -0.06567767f, 0.20461226f, -0.12548321f, -0.28776249f, -0.00571538f, 0.15827180f, -0.11274113f, 0.21475755f, 
    -0.28997210f, -0.27793306f, -0.08399475f, 0.12874833f, -0.13778165f, -0.17491271f, 0.08643885f, -0.38893020f, 
    0.10729825f, -0.10350168f, -0.06053606f, 0.07294060f, -0.52663302f, 0.02572919f, -0.82920325f, 0.17436363f, 
    0.00852059f, 0.01254005f, -0.22520642f, 0.06033935f, 0.00744025f, -0.01785615f, -0.10401213f, 0.00970031f, 
    -0.05476518f, -0.02076436f, 0.02729823f, -0.19242221f, 0.01381253f, -0.06036092f, -0.03367889f, -0.32702488f, 
    0.10563630f, 0.00151504f, 0.16289967f, 0.52375877f, -0.09153602f, 0.11160429f, -0.01211034f, 0.47564390f, 
    -0.03730206f, 0.02254277f, -0.06993498f, 0.17928234f, 0.16516781f, -0.27223665f, -0.04393025f, 0.15497334f, 
    -1.18463504f, -0.99511707f, 0.18985878f, -0.29922247f, -0.06394503f, 0.11084576f, -0.01155381f, -0.12965381f, 
    -0.01620052f, -0.00681284f, -0.00177754f, -0.09639446f, -0.49522966f, -0.19186218f, 0.41257092f, 0.20681025f, 
    0.11362199f, 0.01529378f, -0.01117892f, -0.04862913f, -0.00292734f, 0.01880500f, -0.02667931f, 0.11611634f, 
    -0.05276405f, -0.06985397f, -0.09903283f, 0.13940522f, -0.00224947f, -0.00440957f, 0.12935989f, 0.08155461f, 
    0.13986880f, -0.11236975f, -0.01916421f, 0.05824606f, -0.87709916f, -0.46625695f, -0.03658095f, -0.48256704f, 
    -0.00464723f, 0.00730745f, -0.10573569f, -0.38414267f, 0.14570996f, -0.04286280f, 0.07800038f, -0.11392873f, 
    -0.25620231f, -0.06509931f, 0.22933395f, -0.94090438f, -0.01587161f, -0.04728654f, -0.20577843f, 0.01242622f, 
    0.06560037f, -0.09490791f, -0.01344540f, 0.04978216f, -0.02679384f, 0.12047284f, 0.34387138f, 0.01521489f, 
    -0.06009660f, -0.17240897f, 0.05018697f, 0.02672345f, 0.03971514f, -0.07196311f, 0.00469874f, -0.19738092f, 
    -0.25662857f, -0.14241992f, 0.07077428f, -0.14025211f, -0.15495859f, -0.05629828f, -0.08126853f, 0.12066706f, 
    0.01240881f, -0.10490106f, -0.07916191f, -0.03620824f, 0.25727952f, 1.07963645f, 0.35029304f, 0.67203748f, 
    -0.15695924f, 0.03185664f, 0.06210832f, -0.14242032f, -0.07823407f, 0.00521716f, -0.06467694f, 0.06916012f, 
    0.23837885f, -0.17761090f, -0.13815928f, 0.00032375f, 0.12421393f, 0.04582711f, -0.06056419f, 0.15094836f, 
    -0.30377594f, -0.03428170f, -0.19950044f, 0.19648151f, -0.27937496f, 0.25988302f, 0.07154466f, 0.19858009f, 
    -0.10380466f, -0.01056692f, 0.10231898f, -0.21492481f, 0.11372939f, 0.22995171f, -0.23919539f, 0.42252344f, 
    -0.15631358f, -0.28731236f, 0.12164969f, 0.46771818f, 0.06908722f, 0.27012581f, 0.01807490f, 0.11125868f, 
    -0.12551762f, 0.00267955f, -0.29205817f, -0.03185115f, -1.09569538f, -0.09156132f, 0.31869465f, 0.21991831f, 
    0.05569166f, 0.04747642f, 0.13680346f, -0.34621182f, -0.14022858f, 0.03147819f, -0.02862579f, -0.00568054f, 
    0.19242167f, -0.19753057f, 0.24481204f, 0.51071322f, 0.14609432f, -0.18405324f, 0.06150048f, -0.03133503f, 
    0.32515118f, 0.18243174f, -0.04010582f, -0.04138221f, 0.17686684f, -0.13190371f, -0.23441367f, -0.06514487f, 
    -0.10142407f, -0.20921990f, -0.07779808f, 0.15067209f, -0.13859096f, 0.11403509f, -0.02181458f, 0.12661953f, 
    0.05915344f, -0.11634541f, 0.23442738f, 0.14110869f, -0.11619679f, 0.02154176f, -0.02209841f, 0.04009707f, 
    0.05696894f, 0.16192001f, 0.01558759f, 0.09170925f, 0.24155527f, -0.25805965f, -0.29355219f, -0.29355264f, 
    0.30543163f, 0.02095482f, 0.03013765f, -0.07366328f, -0.25853637f, 0.09442079f, 0.01651422f, 0.02025570f, 
    0.05782095f, -0.24125539f, -0.19456860f, 0.34616685f, 0.01244829f, -0.10528567f, -0.15502232f, 0.05648179f, 
    -0.02185866f, -0.01085780f, -0.10093287f, -0.01631899f, -0.51616096f, -0.50408876f, 0.03691804f, -0.19386929f, 
    -0.62177432f, 0.08597837f, -0.59926617f, 0.05346771f, -0.19744009f, -0.07772218f, -0.02446830f, -0.08516902f, 
    0.05290397f, -0.31196967f, 0.05846656f, -0.57167745f, -0.13794556f, -0.04288176f, 0.05545856f, 0.19673395f, 
    -0.00385566f, 0.36449456f, -0.45016637f, 0.02238210f, -0.15597895f, -0.31432939f, 0.44336873f, 0.42603981f, 
    0.25681177f, 0.08976142f, -0.04895600f, 0.01553769f, 0.02934280f, -0.02585734f, -0.01501967f, -0.26241037f, 
    -0.22277460f, -0.04488833f, 0.63899940f, 0.18268892f, -0.25934422f, -0.04739274f, 0.11295732f, 0.02028820f, 
    0.27067566f, 0.10945532f, 0.01064279f, 0.11819147f, 0.33204433f, 1.33554327f, -0.18289565f, 0.01374034f, 
    0.54459643f, 0.06337679f, 0.27236652f, -0.20062436f, -0.44518787f, -0.11043349f, 0.05546719f, 0.04480423f, 
    -0.27629536f, -0.25340390f, -0.23348355f, -0.35838059f, -0.08911684f, 0.09929835f, -0.59120154f, -0.28287712f, 
    -0.13968769f, 0.10015956f, 0.00071966f, -0.17328146f, 0.59381407f, -0.22940157f, -0.08732001f, 0.40515527f, 
    0.21752545f, -0.10472688f, 0.01563274f, -0.17152597f, 0.11278027f, 0.14049546f, 0.06183131f, 0.36983097f, 
    -0.31034932f, 0.08468265f, -0.19697808f, -1.09244537f, 0.15854216f, -0.00059194f, -0.06695089f, -0.13248640f, 
    -0.02586648f, 0.14781302f, -0.14241350f, -0.21447612f, -0.15068287f, -0.07705242f, -0.05785687f, 0.19813797f, 
    -0.07959121f, 0.03052176f, -0.03070051f, -0.04032012f, -0.11534101f, 0.34118262f, -0.35822287f, -0.01738956f, 
    0.12565617f, 0.25820270f, 0.19220647f, 0.21758793f, 0.03757347f, -0.13083793f, -0.09069715f, 0.04001355f, 
    0.16648459f, -0.05782150f, -0.08116415f, 0.11722050f, -0.10548547f, -0.02842352f, 0.06519675f, -0.02040400f, 
    -0.17235306f, -0.14989465f, -0.12396163f, 0.10617646f, -0.31302395f, 0.00275550f, -0.25373718f, 0.13248856f, 
    0.14986892f, 0.14763257f, 0.18945397f, 0.09467504f, 0.07777641f, 0.00118395f, -0.15866910f, 0.14996462f, 
    -0.08703741f, 0.11826120f, -0.17787555f, -0.11225999f, 0.23374863f, 0.08873370f, 0.42021182f, 0.13256304f, 
    -0.07761676f, -0.07318213f, -0.03787915f, -0.20837064f, 0.00232840f, -0.15353352f, 0.08176879f, 0.00985385f, 
    0.03904088f, 0.18796058f, -0.16826127f, 0.16237795f, 0.11818954f, -0.09132954f, 0.08089162f, -0.08527230f, 
    0.03221451f, -0.18122511f, 0.14398786f, 0.22949877f, 0.33651531f, 0.23489283f, -0.24370065f, 0.24428676f, 
    -0.28518406f, -0.02884974f, -0.12041119f, 0.09244691f, 0.18872978f, -0.03851970f, -0.28186429f, 0.03184993f, 
    -0.13725287f, 0.08446908f, 0.28420666f, 0.11844634f, -0.19313869f, 0.12404756f, -0.10295631f, 0.10707445f, 
    -0.00931667f, 0.03933221f, -0.01690177f, 0.03907757f, -0.09752262f, -0.18069491f, -0.33478639f, 0.17493522f, 
    -0.08960763f, -0.13238704f, 0.08343276f, 0.07888106f, -0.05382004f, -0.13596687f, 0.01803206f, 0.02086823f, 
    0.19949046f, -0.07264247f, -0.22802031f, -0.20686148f, -0.01526921f, 0.06411247f, 0.05857990f, -0.14021729f, 
    -0.13388351f, -0.05590512f, -0.13455833f, -0.39332545f, 0.09087293f, 0.57137108f, 0.21068113f, -0.09732352f, 
    0.10308370f, -0.00552878f, 0.24415798f, 0.14303374f, 0.01027187f, -0.14783737f, -0.06557228f, -0.24112853f, 
    0.26889190f, 0.30231369f, -0.92554426f, 0.09348475f, 0.12758188f, -0.03585399f, 0.01911704f, -0.22622052f, 
    0.04522464f, 0.19421279f, 0.17217344f, 0.04268692f, -0.25195208f, -0.96871740f, -0.04433719f, -0.25107759f, 
    0.12248021f, 0.18512526f, -0.30553147f, 0.06200258f, 0.04193386f, -0.25318715f, -0.10969638f, -0.23769364f, 
    0.05110284f, 0.08758888f, 0.12020306f, 0.24431758f, 0.22268221f, 0.07773737f, 0.19478087f, 0.04866093f, 
    0.09421017f, 0.07477106f, -0.02307358f, -0.01935533f, -0.24398930f, -0.01436406f, 0.13692252f, 0.25841627f, 
    -0.09423891f, -0.10639625f, -0.08779019f, -0.02570078f, -0.07550578f, -0.06045518f, 0.03449323f, 0.01391609f, 
    0.23405007f, -0.33106208f, -0.48081872f, 0.07795180f, -0.00692051f, -0.00172182f, 0.06865351f, -0.08322642f, 
    -0.56661475f, -0.24762852f, -0.31425643f, 0.08172984f, 0.00010661f, 0.03202211f, -0.02924042f, -0.08088891f, 
    0.05082579f, -0.01410590f, 0.08915839f, 0.04568022f, 0.28114548f, -0.19240983f, 0.16619824f, 0.40057144f, 
    -0.05820975f, -0.11108505f, -0.16766217f, -0.25601673f, 0.06886340f, -0.00582712f, 0.07214896f, 0.07385512f, 
    -0.10023119f, -0.05509350f, 0.09681771f, -0.22701196f, -0.01261115f, -0.67105508f, -0.19830392f, -0.35318345f, 
    0.01077149f, 0.02666280f, -0.18364543f, 0.04262032f, 0.27480203f, -0.22928211f, 0.11038373f, -0.16959493f, 
    0.24224815f, -0.02539932f, -0.42423144f, -0.07696147f, -0.06943265f, 0.17112842f, -0.29344150f, 0.14723273f, 
    -0.09725904f, 0.14518769f, -0.09477486f, -0.06997356f, 0.17893995f, -0.05572730f, 0.32396179f, 0.35240176f, 
    0.27542594f, 0.09654897f, 0.15903400f, 0.02548621f, 0.18286325f, -0.03205675f, -0.08678310f, 0.00138019f, 
    0.04224681f, 0.10494532f, -0.15180174f, -0.29355198f, -0.12695451f, 0.14766410f, -0.05385853f, -0.11785097f, 
    0.02828365f, -0.34188864f, -0.13994671f, -0.19308421f, -0.95675623f, -0.30465412f, 0.21903163f, -0.21477169f, 
    -0.09695748f, -0.06465778f, 0.01167324f, -0.09404223f, 0.18795249f, -0.15569641f, 0.20101909f, 0.00040104f, 
    0.05528210f, 0.23633549f, 0.17763962f, -0.32277155f, 0.17742208f, -0.12402873f, 0.09866528f, -0.06890397f, 
    0.05958062f, 0.09889903f, 0.01930034f, 0.10709582f, 0.83769649f, 0.11416534f, -0.14088556f, 0.08057576f, 
    0.00850412f, 0.14751646f, -0.02189508f, 0.08081059f, -0.01130060f, 0.14856994f, 0.13751535f, 0.00782346f, 
    -0.13028008f, -0.18922243f, -0.09096376f, 0.32219461f, 0.09223998f, -0.21785484f, -0.12883283f, -0.05916275f, 
    0.27337593f, -0.17354774f, 0.54280704f, 0.03783849f, 0.05714442f, 0.26887822f, -0.42454937f, 0.07573259f, 
    0.16993605f, 0.20249122f, -0.06547228f, 0.02736812f, -0.09917242f, -0.02883663f, 0.10461035f, 0.08886036f, 
    -0.13936043f, -0.33919674f, -0.28740808f, 0.31068146f, 0.05119243f, 0.13598877f, 0.01948290f, 0.05453606f, 
    0.21162838f, -0.19435208f, 0.10694268f, -0.58270466f, -0.31034887f, 0.16685361f, -0.19138305f, -0.44926926f, 
    -0.08014905f, -0.06326275f, 0.14846179f, -0.02645759f, 0.06520122f, 0.00555536f, 0.18170437f, 0.09725153f, 
    -0.31275284f, -0.21328431f, -0.00323390f, 0.09653156f, 0.20173730f, -0.08293229f, -0.19394170f, 0.10632961f, 
    0.08639116f, 0.00883016f, 0.03642362f, 0.13760722f, -0.19186121f, -0.09319074f, -0.06530166f, -0.19194180f, 
    0.10159536f, 0.09195853f, 0.04800971f, 0.03476314f, -0.12693204f, -0.05919867f, 0.00589961f, 0.13434663f, 
    -0.52039856f, -0.32461643f, 0.37858284f, 0.49251249f, 0.08272548f, -0.13578033f, 0.00995129f, 0.23780750f, 
    0.25122356f, -0.06442563f, 0.10528302f, 0.00140730f, 0.36932921f, -0.27990368f, 0.00265036f, -0.04735757f, 
    0.07833737f, -0.03846475f, -0.03645301f, 0.07747151f, -0.09225391f, -0.65533578f, -0.20049195f, -0.73134309f, 
    0.30618855f, 0.32735491f, 0.08501443f, -0.10061205f, -0.07780033f, -0.25151268f, -0.18717213f, -0.00497040f, 
    -0.10837795f, -0.33781394f, 0.08953398f, 0.16371240f, 0.40994594f, 0.90040660f, -0.32008103f, 0.22846715f, 
    0.02729717f, -0.14276305f, 0.40241644f, 0.33649355f, 0.24763967f, 0.03360558f, 0.13507782f, 0.18338229f, 
    0.29658654f, 0.19748522f, -0.11083635f, -0.34130406f, -0.17869288f, -0.16015388f, 0.05563524f, -0.51567638f, 
    0.11404467f, -0.21490759f, 0.08839411f, -0.08785099f, -1.74093330f, -1.28599572f, -0.54017240f, -0.64067996f, 
    -0.35145304f, -0.36480913f, -0.00492090f, -0.49078065f, -0.22332381f, -0.07738759f, 0.07611295f, -0.02791706f, 
    0.08484995f, 0.05438069f, -0.15161027f, -0.19104868f, 0.01773991f, -0.02690624f, 0.19277099f, 0.19384280f, 
    0.08952607f, 0.31646669f, 0.28093478f, -0.31461498f, -0.74511492f, 0.33182323f, 0.76805007f, 0.07071112f, 
    -0.28624433f, -0.29933453f, -0.04664459f, 0.01297679f, -0.04459066f, 0.22538544f, 0.21818636f, -0.12525080f, 
    -0.77315956f, -0.90698993f, -1.19763553f, -0.34133959f, -0.17746830f, -0.20625468f, -0.32645616f, -0.34615108f, 
    -0.03068131f, 0.04090456f, -0.04275066f, 0.06055962f, 0.31091177f, 0.03921671f, -0.38484645f, -0.27935129f, 
    -0.06489178f, 0.05453852f, 0.16467863f, 0.13334939f, -0.07367787f, 0.05062914f, -0.05033347f, -0.08663574f, 
    0.07787953f, -0.10914742f, -0.16425428f, 0.08369943f, -0.12870777f, -0.00364696f, -0.11262827f, 0.18362078f, 
    -0.16113058f, -0.01886085f, -0.09341894f, -0.35904956f, -0.05023838f, -0.46121824f, -0.16191238f, -0.73593718f, 
    0.04614052f, -0.03438457f, 0.18587857f, -0.42979154f, 0.07985858f, 0.02253953f, -0.10019142f, 0.09815035f, 
    0.19056064f, -0.26196954f, 0.04080514f, -0.29240680f, -0.01830054f, 0.03561491f, 0.13506995f, -0.00007802f, 
    -0.05911161f, -0.06203396f, -0.07557149f, 0.08375943f, -0.58944505f, 0.06887864f, 0.26508036f, -0.33294451f, 
    0.10395146f, -0.10085158f, -0.12865138f, -0.04859298f, 0.03744045f, 0.13253574f, 0.02982975f, 0.15897235f, 
    0.16212767f, -0.12117203f, -0.08514217f, -0.04888648f, -0.17501804f, 0.11237235f, 0.18535359f, -0.11651388f, 
    -0.04844362f, -0.21220464f, -0.00628599f, -0.02500333f, -1.10948086f, -0.52379501f, 0.06886897f, 0.98133194f, 
    0.14893407f, -0.08273104f, 0.09474492f, 0.11798035f, -0.03922850f, 0.06955142f, 0.09212752f, -0.09116599f, 
    0.28918236f, -0.03470704f, 0.04402941f, 0.23985712f, 0.02819752f, -0.01930037f, 0.02056307f, 0.11542016f, 
    0.19371164f, 0.09439403f, 0.12602137f, -0.16316669f, 0.19977684f, 0.55716890f, -0.50803292f, -0.15272316f, 
    -0.11561633f, 0.06978477f, -0.00207431f, 0.16613214f, 0.03922773f, 0.21028660f, 0.54727709f, 0.16381197f, 
    0.12214793f, -0.00713466f, -0.05205208f, -0.10346358f, -0.00316277f, -0.04080559f, -0.00802683f, 0.07385743f, 
    0.12326019f, -0.09396098f, 0.17451702f, 0.19055600f, -0.22306210f, -0.91150510f, 0.17988029f, -0.35961756f, 
    -0.34808874f, 0.05796653f, 0.11621780f, -0.06575719f, -0.04636630f, 0.02168991f, -0.04925641f, -0.17102349f, 
    -0.12845115f, 0.05468981f, 0.07585750f, 0.29250389f, 0.17669241f, -0.13433617f, 0.02805696f, 0.04273931f, 
    -0.10918847f, 0.13321204f, 0.05756082f, 0.12891522f, 0.07776990f, -0.50464547f, -0.25624508f, 0.99634576f, 
    0.05688694f, -0.04345515f, 0.00957783f, 0.05707934f, -0.03017467f, -0.07883077f, -0.09200730f, -0.02894646f, 
    -0.01203022f, 0.25086087f, 0.03824883f, 0.07016873f, -0.08997292f, 0.04713307f, 0.24963659f, 0.07116643f, 
    0.08496578f, 0.06292772f, 0.08452842f, -0.16969033f, 1.18926549f, -0.30951962f, -0.37572688f, -0.43267065f, 
    0.00461620f, -0.00543136f, -0.17284100f, -0.02099516f, -0.01839319f, -0.19687273f, -0.25644931f, -0.00811513f, 
    -0.63819438f, -0.55083030f, 0.10883118f, 0.26273656f, 0.09025952f, -0.00192420f, 0.02988715f, 0.19595607f, 
    -0.00332466f, -0.02059903f, -0.10073598f, -0.16262573f, -0.06662166f, -0.13838220f, 0.27886045f, -0.10151985f, 
    -0.02551098f, -0.02278799f, -0.00396530f, -0.16209371f, 0.17043039f, -0.22882058f, 0.01718335f, 0.06051691f, 
    0.02941520f, 0.02503487f, 0.13851881f, -0.10105392f, -0.09585888f, -0.07586579f, -0.07567739f, -0.12224029f, 
    0.00686515f, -0.12531205f, -0.07993003f, -0.21172181f, -1.48410261f, 1.07522321f, -0.22466472f, 0.16569191f, 
    -0.03990262f, -0.30388257f, 0.16152225f, 0.16122873f, 0.05521103f, 0.04884852f, 0.02045856f, -0.01247616f, 
    -0.01109206f, 0.39572328f, -0.04289530f, 0.11748376f, 0.05786169f, -0.07926036f, 0.08370167f, 0.02874920f, 
    0.00044058f, -0.06273616f, 0.16616647f, 0.01970697f, 0.22145699f, 0.06796495f, 0.09706926f, -0.41395789f, 
    0.14027199f, -0.04368881f, 0.21330851f, 0.06849349f, -0.03237411f, -0.16228312f, 0.02523918f, -0.36394483f, 
    -0.02348729f, 0.19162455f, 0.04013241f, -0.13997811f, -0.01697636f, -0.01548958f, -0.01691027f, -0.02762408f, 
    0.03525357f, 0.09722017f, 0.02613513f, 0.04242828f, -0.65782785f, -0.95329452f, -0.67116100f, -0.72638279f, 
    0.01922689f, 0.06878676f, 0.01314905f, 0.13821813f, 0.16603811f, 0.00277699f, -0.07784593f, -0.01051696f, 
    0.48209018f, -0.17992117f, 0.05670991f, -0.50998259f, -0.01332355f, 0.18410283f, -0.07664736f, -0.03159470f, 
    -0.02760860f, 0.02567132f, -0.07196563f, -0.40780362f, -0.28446010f, -0.29823622f, -0.14111392f, 0.41970658f, 
    -0.06688815f, -0.10818905f, 0.02719802f, -0.08989467f, 0.25278828f, 0.07999033f, 0.00105889f, -0.10493440f, 
    -0.31987622f, -0.22642824f, -0.03922886f, -0.04186830f, -0.07063419f, 0.17111112f, 0.01828950f, -0.02802141f, 
    -0.25089931f, 0.02603752f, -0.15140925f, -0.16870883f, 0.07253166f, -0.64667279f, 0.20159581f, 0.58926278f, 
    0.26808083f, 0.02230275f, 0.21349128f, -0.18061544f, 0.26781997f, 0.08765306f, -0.12679273f, 0.35034779f, 
    -0.23371753f, -0.20642926f, -0.15302902f, -0.17746742f, -0.02185676f, -0.01741962f, 0.04314261f, 0.02720566f, 
    -0.02712957f, 0.16520728f, 0.14499284f, 0.08531313f, 0.41381976f, -0.54420167f, -1.36777294f, -0.64882433f, 
    0.28962556f, 0.08812779f, -0.16647498f, 0.25524890f, 0.21325597f, 0.11850558f, 0.07442214f, 0.09763656f, 
    -0.43885705f, 0.23331061f, 0.01262107f, 0.06618658f, 0.00621602f, 0.25313717f, -0.10885627f, -0.00172513f, 
    -0.35597616f, -0.17695490f, 0.04352347f, -0.71876520f, 0.02433756f, -0.72073799f, -1.25841820f, -0.30355608f, 
    -0.05084116f, 0.17200996f, 0.42433360f, 0.00289994f, 0.11662193f, -0.09971184f, -0.08283484f, -0.12971854f, 
    -0.06921118f, -0.07326081f, -0.52302027f, -0.50015050f, 0.05731823f, -0.15869354f, -0.09362135f, -0.38771877f, 
    0.09694602f, -0.01560553f, -0.05439717f, 0.06872796f, -0.55891186f, 0.51990420f, -0.02772052f, 0.17505777f, 
    0.27391431f, -0.08506214f, 0.09916136f, -0.05246186f, -0.05797885f, -0.04179559f, 0.14792189f, 0.09528027f, 
    -0.17174378f, 0.12421639f, -0.04028488f, 0.05537398f, 0.02590193f, -0.08585933f, 0.00016699f, -0.04967520f, 
    0.12918274f, 0.18139245f, -0.01276147f, 0.32570440f, -0.35338646f, 0.17540891f, 0.21797347f, 0.51789671f, 
    -0.09079599f, 0.16714169f, -0.04146052f, 0.20693870f, 0.00415700f, -0.07875381f, -0.01351147f, 0.25391594f, 
    -0.99615401f, 0.07509318f, 0.17989655f, 0.37489647f, -0.11937150f, 0.01746107f, -0.35760206f, -0.00928728f, 
    -0.28534925f, -0.29774919f, -0.31137535f, -0.09014276f, -0.29423639f, -0.33774263f, -0.08652470f, -0.21378666f, 
    -0.41917783f, 0.01092063f, 0.08926554f, -0.08394909f, 0.14247450f, 0.24894428f, 0.23013940f, 0.42789435f, 
    -0.43752289f, 0.07417103f, 0.20982760f, -0.00484602f, -0.03645284f, -0.21243830f, -0.11074276f, -0.07398954f, 
    0.02493818f, 0.11139593f, 0.08471032f, 0.14753394f, -0.46959499f, -0.80618465f, -0.78237772f, 0.85190630f, 
    0.24584554f, 0.18468791f, 0.01511600f, 0.02465894f, 0.00095228f, -0.12121681f, 0.07843538f, -0.05496801f, 
    0.51754516f, 0.09593600f, -0.14707042f, -0.49389395f, 0.01572145f, -0.18764082f, 0.00662754f, -0.06473213f, 
    0.17656080f, -0.10993179f, 0.35649723f, -0.04021543f, -0.10164441f, -0.06231183f, 0.06896065f, 0.11493111f, 
    0.00433724f, 0.05724326f, -0.02558259f, 0.01051768f, -0.07869227f, -0.02702462f, -0.45685086f, -0.78388739f, 
    -0.08927049f, 0.58778012f, 0.24892409f, -0.41179600f, -0.42096683f, -0.07409208f, 0.03138968f, -0.26160169f, 
    0.06525510f, 0.04915382f, 0.27240834f, 0.07419841f, 0.30876514f, -0.50554508f, 0.70132422f, -0.77584398f, 
    -0.12615351f, -0.35833052f, -0.32137293f, -0.27234539f, -0.33582988f, -0.07813343f, -0.03123384f, 0.05125704f, 
    0.43168679f, 0.58007669f, -0.23780912f, -0.05714294f, -0.14594892f, 0.09760175f, -0.26114807f, 0.10320726f, 
    0.01872656f, -0.02768918f, 0.03196597f, -0.11905757f, -0.23210232f, 0.11169820f, -0.43792865f, 0.30718192f, 
    0.11548927f, -0.18532884f, -0.04504841f, 0.00802840f, 0.16365513f, -0.06229775f, 0.06022434f, -0.17118299f, 
    0.02877707f, 0.10302605f, 0.11821116f, -0.27867159f, -0.09538006f, 0.06213733f, 0.27006936f, -0.01239526f, 
    0.14823560f, 0.25863203f, 0.18500192f, 0.09567442f, 0.22621085f, -0.05260962f, 0.44687223f, 0.71335429f, 
    0.06293172f, -0.30347908f, -0.62282944f, -0.40914646f, 0.09976739f, -0.17527872f, -0.20252374f, 0.14013401f, 
    -0.36870956f, -0.35187542f, 0.12262820f, 0.25533649f, -0.22813904f, 0.09791698f, -0.09044902f, 0.18983211f, 
    0.03492258f, 0.02204731f, 0.04809150f, 0.04375732f, -0.05688645f, 0.23154730f, -1.03931761f, 0.32472464f, 
    0.07825898f, 0.06153340f, 0.17556979f, -0.34484309f, 0.04636801f, -0.01208310f, -0.08945358f, -0.01746511f, 
    -0.01516671f, -0.09520587f, 0.10759695f, 0.36034033f, 0.23790726f, 0.29255357f, -0.01015557f, -0.10251906f, 
    0.31004202f, -0.02303470f, -0.15294549f, -0.08469714f, -0.27492973f, 0.59220397f, -0.71254724f, -0.13964456f, 
    -0.05769770f, -0.31259221f, 0.29904395f, 0.20856568f, -0.06905434f, -0.16272973f, -0.17427424f, -0.14000663f, 
    0.05237832f, 0.02909394f, -0.02286404f, -0.39631277f, 0.09665768f, 0.16896197f, 0.26740375f, 0.21018918f, 
    0.09958964f, 0.04086697f, 0.06211805f, 0.17081007f, 0.24543388f, -0.28464752f, 0.44496331f, -0.16192622f, 
    0.25454819f, -0.16354695f, -0.18710627f, 0.18951339f, -0.26788789f, 0.02254962f, -0.07033376f, -0.00784840f, 
    -0.16042937f, -0.11452430f, -0.44117612f, 0.17332877f, 0.17491108f, 0.21951489f, 0.34350744f, 0.19868229f, 
    0.09451037f, -0.17982325f, 0.14539906f, 0.07240828f, -0.09622166f, -0.08197645f, 0.39984441f, -1.01136458f, 
    -0.19140613f, -0.34045151f, 0.19675227f, -0.08322906f, -0.00603556f, 0.07938106f, 0.11755794f, 0.01620581f, 
    -0.40873885f, -0.50630170f, 0.31200466f, 0.45086136f, -0.22191614f, 0.26699361f, -0.23125349f, -0.18077293f, 
    0.03168778f, -0.07324561f, 0.06047573f, -0.21496391f, -0.10324474f, 0.02224031f, 0.43445423f, -0.21495110f, 
    0.18712302f, -0.12407598f, 0.04643517f, -0.15990500f, 0.02713605f, 0.17317604f, 0.19033737f, -0.03178530f, 
    -0.04841735f, -0.02880200f, -0.06102182f, 0.29380682f, 0.34415451f, -0.04088668f, 0.19986853f, -0.14265403f, 
    -0.16371922f, 0.05138458f, -0.00019404f, -0.38108686f, -0.45477921f, 0.77867156f, -0.64109689f, 0.51244599f, 
    0.13609178f, 0.17335641f, -0.01333078f, 0.53803688f, -0.10998917f, 0.08170293f, 0.03787170f, -0.19930257f, 
    -0.41455990f, -0.08481628f, 0.18237485f, 0.00787946f, 0.13429520f, 0.48017648f, -0.03918515f, -0.06064014f, 
    -0.17066264f, 0.00843902f, 0.15696582f, 0.40370983f, -0.27630025f, -0.08979630f, 0.29469118f, 0.18707617f, 
    -0.03122143f, 0.30732557f, 0.06524306f, 0.19410826f, -0.22554235f, 0.18290269f, 0.00204640f, 0.06612175f, 
    0.31858215f, -0.28293598f, -0.28724587f, 0.51220632f, 0.17591593f, -0.09886715f, 0.09272676f, -0.03808346f, 
    -0.30404142f, -0.33906922f, -0.68868631f, -0.33150631f, 0.08603593f, 0.45997730f, -0.00591950f, -0.43755975f, 
    -0.00645714f, -0.11517502f, -0.20630425f, -0.01817598f, -0.19373138f, 0.08408658f, -0.16450986f, -0.04445545f, 
    -0.33716714f, -0.07986169f, -1.05187464f, 0.40122864f, -0.00935227f, -0.10473371f, 0.07092709f, -0.07051837f, 
    -0.00186310f, 0.26726958f, -0.05519072f, 0.17361422f, -0.31447250f, 0.32386491f, -1.23242795f, 0.13592426f, 
    -0.16191652f, -0.08952256f, 0.32683814f, 0.06703387f, -0.16426378f, -0.00102270f, -0.04130490f, 0.14091143f, 
    -0.31389228f, 0.35751143f, -0.11039186f, -0.21248171f, -0.14410874f, 0.17395888f, 0.05610640f, -0.18242578f, 
    -0.18281043f, -0.13477907f, 0.35385910f, 0.24298272f, -0.19869949f, -0.79343247f, 0.21583398f, 0.15636842f, 
    0.13405545f, 0.10418680f, -0.13406657f, 0.28648022f, -0.04831277f, 0.05539850f, 0.08615167f, -0.00347785f, 
    -0.02612248f, 0.18348232f, -0.00320685f, -0.09032334f, -0.30924001f, -0.31367663f, -0.03244116f, 0.20863566f, 
    -0.23459801f, -0.24666598f, -0.24319404f, -0.33354473f, 0.11219662f, 0.50037009f, 0.04107080f, 0.36672565f, 
    0.03206212f, 0.00463179f, -0.09360613f, 0.20131598f, 0.21445115f, -0.08119822f, 0.13225509f, 0.43530944f, 
    0.18875739f, -0.54276425f, -0.43626595f, -0.86378789f, -0.33538964f, -0.13508108f, 0.10469902f, -0.34234622f, 
    0.08838692f, 0.35786828f, 0.26906675f, -0.01168390f, 0.06027820f, -0.36131257f, 0.23054713f, -0.03156711f, 
    -0.07528259f, 0.11756589f, -0.05728605f, 0.08937932f, 0.20168038f, -0.06469702f, 0.03686463f, -0.44187531f, 
    -0.85073864f, 0.22950839f, 0.10803984f, -0.15466478f, 0.01001503f, 0.20076489f, -0.33184370f, -0.05761343f, 
    -0.01171304f, -0.08097003f, 0.13086759f, -0.15780938f, -0.33643726f, 0.24197723f, 0.06421176f, -0.14946051f, 
    0.11658790f, -0.07869442f, -0.18221639f, 0.07940935f, -0.18330209f, -0.30632120f, -0.50471467f, -0.72296548f, 
    -0.38023782f, -0.19845542f, 0.21261941f, 0.13751799f, -0.22953025f, -0.05648310f, 0.05310163f, -0.08484869f, 
    0.32148206f, 0.21191138f, -0.28924018f, 0.04123295f, -0.71962774f, -0.26775599f, 0.46863303f, 0.77291930f, 
    0.01157100f, 0.01445718f, 0.15850525f, 0.30987859f, -0.21551546f, -0.26693135f, -0.07756755f, 0.13922994f, 
    -0.19884342f, 0.09707905f, 0.26168910f, 0.42817035f, -0.08321317f, -0.26053458f, 0.52374798f, -0.06875572f, 
    0.05615748f, -0.19682541f, -0.25008699f, -0.09912215f, -0.38496050f, -0.68791938f, 0.13929935f, 0.15697461f, 
    0.08074918f, -0.03711452f, -0.26864558f, -0.06141723f, 0.17454349f, -0.07272203f, 0.20820865f, 0.06755070f, 
    -0.08757918f, 0.03572191f, 0.10414822f, -0.04829998f, -0.11194919f, 0.02186583f, -0.13263218f, 0.09708625f, 
    0.11513620f, 0.32063830f, 0.18297972f, 0.26737764f, -0.61163026f, 0.01814137f, -0.21513677f, 0.26991928f, 
    0.19830590f, -0.25516289f, -0.04920485f, -0.04525497f, 0.00283593f, 0.00650512f, 0.13286085f, -0.15209240f, 
    -0.00530559f, -0.23255761f, -0.03656361f, -0.32657111f, -0.32435146f, -0.31225401f, -0.04004121f, -0.11862852f, 
    0.00016306f, 0.03448640f, -0.04841579f, -0.14785610f, 0.92969036f, -0.28543782f, 0.30048153f, 0.09985198f, 
    0.06877540f, 0.15487872f, -0.19464973f, 0.13536628f, -0.19122332f, -0.06415094f, -0.11891305f, -0.24755032f, 
    -0.08004615f, 0.23937258f, 0.00182966f, -0.02935727f, -0.03576544f, 0.20639035f, 0.20100243f, 0.11506580f, 
    -0.17995244f, 0.14624131f, 0.14088337f, -0.23809466f, 0.46080336f, -0.13088757f, 1.00017309f, -0.07154537f, 
    0.02135566f, 0.06393179f, -0.58980823f, 0.09535195f, -0.06786548f, 0.16459508f, -0.14671552f, -0.08719069f, 
    0.19043075f, 0.25959381f, 0.07733650f, -0.01648881f, -0.22395529f, -0.03431978f, -0.12164861f, 0.09660413f, 
    -0.15590006f, 0.08805326f, 0.11029660f, -0.05447653f, -1.04140282f, 0.05015875f, -0.42657882f, 0.40397656f, 
    -0.01638453f, 0.17682330f, -0.15711448f, -0.04692069f, -0.34052461f, -0.03142645f, 0.16274101f, -0.14852078f, 
    0.46309173f, 0.18743156f, 0.02179652f, -0.01317501f, -0.15006711f, 0.11767035f, -0.08672810f, -0.10657722f, 
    -0.15698621f, -0.09591554f, -0.24874444f, -0.09007972f, -0.10588836f, 0.55507815f, 0.02332695f, -1.19537127f, 
    -0.04838420f, -0.41237381f, 0.17135923f, 0.15833904f, -0.00664343f, 0.12132606f, 0.03752666f, -0.02342846f, 
    -0.65192169f, 0.04084348f, -0.59358495f, 0.08782481f, 0.18348762f, -0.35510632f, 0.29053614f, -0.09211813f, 
    0.26830310f, 0.15763262f, 0.23300958f, -0.01772670f, -0.16689369f, -0.16123140f, -0.03713985f, -0.27137473f, 
    0.11809569f, -0.02031312f, -0.05334416f, 0.08773606f, -0.05294351f, 0.31757727f, 0.38227770f, 0.14924039f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.39379540f, 0.10192624f, 0.15840954f, -0.21163426f, -0.23278013f, 0.12854421f, 0.08810525f, -0.30695426f, 
    0.27273515f, -0.01639613f, 0.03736169f, 0.04231447f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
