#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.19781238f, 0.55010778f, 0.28463352f, 0.21392597f, -0.06616179f, 0.34210110f, -0.14990006f, -0.14510490f, 
    -0.00862072f, -0.19475099f, 0.05884903f, -0.38177767f, 0.07564379f, -0.02952253f, -0.06314112f, -0.09357375f, 
    0.17205994f, -0.30437997f, -0.05751878f, -0.05133720f, -0.37464982f, -0.06658097f, -0.32765201f, -0.43111563f, 
    -0.49062011f, -0.08186635f, 0.02084885f, -0.28074747f, 0.54945189f, 0.30796185f, 0.07334427f, -0.04158252f, 
    -0.31815383f, -0.10989153f, 0.50305074f, 0.24767314f, 0.16373824f, -0.18468086f, -0.16223638f, 0.03166326f, 
    0.25318298f, 0.14620021f, -0.07352307f, 0.01505896f, -0.19566466f, -0.17808683f, -0.17153667f, 0.19497509f, 
    0.00904464f, -0.42589551f, -0.73887742f, -0.35448441f, -0.47613969f, -0.46302882f, -0.45260945f, 0.11263736f, 
    0.08306552f, -0.10341290f, 0.05482398f, 0.48133135f, -0.02466597f, -0.33072382f, -0.27716386f, -0.20837873f, 
    -0.32665926f, 0.07878760f, 0.17876084f, -0.02016163f, -0.12374103f, -0.15889189f, -0.16666465f, -0.22838037f, 
    -0.03032739f, -0.06816474f, -0.10065384f, -0.71176732f, 0.83940536f, -0.24537568f, -0.24471864f, -0.21305510f, 
    -0.48500383f, 0.30801237f, 0.30694160f, 0.08444875f, 0.26602855f, -0.31927267f, -0.11047088f, -0.24567091f, 
    0.05522816f, 0.33785665f, 0.40003720f, -0.16708431f, 0.05756481f, -0.17876114f, 0.16278179f, -0.10914847f, 
    0.01085760f, -0.13141008f, -0.23655747f, -0.18482451f, -0.93257231f, 0.04901084f, -0.43816799f, -0.63593799f, 
    -0.51304722f, 0.21001372f, 0.13311325f, 0.26516548f, 0.16266055f, 0.53695381f, 0.14491560f, 0.28855398f, 
    -0.07025948f, 0.22981559f, 0.14119528f, -0.18139663f, 0.15754227f, -0.17517745f, -0.10376713f, -0.18008021f, 
    0.02923484f, -0.15135320f, -0.00833064f, -0.03845430f, -0.07769149f, 0.33876058f, 0.22787768f, -0.19398382f, 
    0.09297603f, 0.23241410f, 0.20291024f, -0.13885504f, -0.05424593f, -0.04512131f, -0.23483822f, -0.14270361f, 
    0.05294405f, 0.19186969f, -0.22567670f, 0.20874710f, 0.03675441f, -0.33405483f, 0.11479834f, 0.05427640f, 
    -0.11851728f, -0.17525056f, 0.29180792f, 0.28223377f, 0.20851670f, 0.33998460f, 0.23626544f, -0.27373698f, 
    -0.23425987f, -0.22377104f, -0.45105752f, -0.16115506f, -0.38262284f, -0.55153424f, -0.44560391f, -0.52551240f, 
    0.24360684f, -0.10246515f, -0.07134735f, 0.28492916f, 0.04636827f, 0.16918957f, -0.12546775f, 0.12627068f, 
    -0.00420450f, 0.16382712f, -0.13907599f, -0.17906874f, -0.25527111f, -0.12428501f, 0.08836718f, -0.33590093f, 
    0.30412835f, 0.23196210f, -0.16002123f, 0.42256796f, -0.54563993f, -0.37179685f, 0.62845027f, 0.14977075f, 
    0.28679836f, -0.19482872f, -0.16756040f, -0.05226722f, 0.20768432f, -0.15246427f, 0.17662701f, 0.14398961f, 
    -0.44703808f, -0.08525310f, 0.19237201f, -0.01131441f, -0.05711443f, -0.08797666f, 0.21431720f, 0.01827655f, 
    -0.34603143f, -0.40537509f, 0.11483875f, 0.77549404f, -0.17774872f, 0.01120247f, -0.87733644f, -0.57383871f, 
    -0.19352378f, 0.22599451f, -0.14711113f, 0.40204763f, 0.02101540f, -0.14046334f, 0.40445790f, -0.25153336f, 
    -0.03924864f, -0.01352661f, -0.15475567f, 0.11314303f, 0.03302276f, -0.04795954f, -0.13946189f, 0.09103037f, 
    -0.11472248f, 0.87035537f, -0.81968057f, 0.05028863f, 0.34420967f, -0.81127024f, -0.37974882f, 0.09323942f, 
    0.25923461f, 0.01390829f, -0.41261175f, -0.07611260f, -0.31973940f, -0.23979449f, 0.61540389f, -0.56150514f, 
    0.03013931f, -0.07870647f, -0.06009150f, -0.07486801f, -0.15438198f, -0.16276233f, -0.00930342f, -0.00201080f, 
    0.04040135f, -0.11259650f, 0.19447143f, -0.19816153f, -0.55312079f, -0.34453586f, -0.25517383f, 0.19476822f, 
    0.24718556f, 0.25067425f, 0.13736096f, -0.52403957f, -0.02830640f, 0.14480561f, 0.05900205f, 0.01054570f, 
    -0.48647520f, -0.36800584f, 0.08733669f, 0.09260393f, -0.52172083f, -0.23644422f, 0.12053513f, 0.12818891f, 
    -0.23935777f, 0.21798444f, 0.43497264f, -0.44654143f, -0.46482784f, -0.53502375f, -0.00669244f, 0.39366457f, 
    0.52399182f, -0.13681020f, 0.30491969f, 0.53918785f, 0.78415728f, 0.06839205f, -0.12153246f, -0.14440915f, 
    -0.02756402f, 0.33735624f, -0.49981576f, 0.06566381f, 0.08149598f, 0.07913806f, -0.20302111f, 0.21906051f, 
    0.19309476f, 0.18025799f, -0.18933760f, 0.03136288f, -0.50540018f, -0.17603314f, 0.29058203f, 0.71558726f, 
    0.09823771f, -0.27728885f, 0.19180304f, -0.01644818f, -0.21938653f, -0.09519859f, 0.34139413f, -0.31881329f, 
    -0.17919977f, 0.56683189f, 0.06856760f, -0.00903946f, 0.29813781f, -0.01404181f, -0.01268845f, -0.49097422f, 
    -0.03170145f, 0.20137644f, -0.20874611f, 0.17958136f, 0.21360563f, -0.08255357f, -0.16602749f, -0.06544479f, 
    0.19489416f, 0.51287836f, 0.39601153f, 0.37658405f, -0.41218588f, -0.29993218f, 0.39843535f, -0.19913822f, 
    -0.15209769f, 0.02527930f, 0.12043761f, 0.31066200f, -0.01958882f, -0.11701387f, -0.25412011f, 0.15225770f, 
    0.03723233f, -0.18285239f, -0.19554365f, 0.16854170f, 0.30870256f, -0.16717343f, -0.64476430f, -0.26363930f, 
    0.18648508f, -0.27902472f, -0.37163401f, 0.18490379f, -0.19335771f, -0.37311056f, -0.29720631f, -0.08437780f, 
    0.04370481f, -0.00324653f, 0.19753863f, -0.08701109f, -0.01153273f, 0.19357191f, -0.27377760f, 0.05238193f, 
    -0.09091819f, -0.20591168f, 0.20821391f, 0.35945469f, 0.19801782f, 0.06281619f, 0.35944679f, -0.45774916f, 
    -0.65532905f, 0.44925416f, 0.43388566f, 0.57869780f, 0.74551761f, 0.35019416f, -0.62317121f, -0.43278551f, 
    0.12463073f, 0.09908038f, -0.00888913f, -0.05709187f, -0.26384118f, -0.31634167f, -0.30724916f, 0.03463364f, 
    -0.08984774f, -0.01714726f, 0.23447813f, 0.29185635f, 0.01905288f, -0.32423982f, 0.07332705f, 0.01837172f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02210070f, 0.12562414f, -0.09628599f, 0.23683169f, 0.13706626f, 0.16583391f, -0.00457119f, 0.15210967f, 
    0.14418213f, 0.20636962f, -0.06719758f, -0.05905494f, 0.10271408f, -0.15218179f, -0.23201682f, 0.04885557f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02101417f, 0.05084487f, -0.01335583f, -0.01242628f, -0.04242777f, 0.03401905f, -0.06504491f, -0.01428242f, 
    0.03772632f, -0.02197611f, -0.03549518f, 0.01971577f, -0.04542619f, -0.05929876f, -0.04152034f, 0.00657380f, 
    0.02799063f, -0.02785272f, -0.06302748f, -0.02630431f, -0.07331158f, -0.03630741f, -0.06976087f, -0.06907180f, 
    -0.03094369f, 0.01515992f, -0.03072123f, -0.05160894f, 0.00503617f, -0.03324375f, 0.00504418f, 0.03957036f, 
    0.01842013f, -0.05277361f, -0.00394169f, -0.04117427f, 0.02435681f, -0.03119627f, 0.03115558f, -0.04111093f, 
    0.06460353f, -0.06232950f, -0.02471709f, 0.05229896f, -0.04010050f, -0.02110485f, 0.02243221f, -0.00208746f, 
    -0.04389051f, -0.03336284f, 0.02954660f, 0.02811464f, -0.01534104f, -0.02388518f, -0.00772073f, -0.06151804f, 
    0.01555545f, -0.05796160f, -0.00210892f, -0.07418080f, 0.05535550f, -0.07221272f, 0.00193498f, -0.04342025f, 
    -0.05562622f, 0.01338160f, -0.03691192f, 0.00786691f, -0.06289578f, 0.05288316f, -0.01781516f, -0.01259788f, 
    0.03877481f, 0.01963310f, -0.00703478f, -0.01334159f, -0.02854555f, 0.03210137f, 0.04165507f, -0.01834252f, 
    -0.01469001f, -0.02858902f, -0.01491936f, -0.02201502f, -0.03084740f, 0.01497355f, 0.04463033f, 0.01382690f, 
    0.01719883f, 0.04811960f, 0.03601611f, 0.01622629f, -0.04840521f, -0.02961186f, -0.00388497f, -0.07735364f, 
    0.05405969f, -0.00144384f, -0.07244418f, 0.02509160f, 0.04580029f, 0.02538520f, -0.00442752f, 0.03747718f, 
    -0.00454460f, 0.05261697f, 0.03734549f, -0.03607709f, -0.06866362f, -0.07237322f, -0.02176445f, 0.03407483f, 
    0.03494874f, -0.02907648f, 0.01934860f, -0.05675139f, 0.01169369f, -0.07123485f, -0.00878564f, -0.03690821f, 
    -0.02795533f, 0.05378708f, 0.00698937f, 0.01662098f, 0.04553555f, -0.04262923f, 0.05850484f, -0.03853520f, 
    0.05073982f, -0.01183717f, 0.06048350f, 0.06395680f, 0.01031407f, 0.03922878f, 0.04767837f, 0.05346085f, 
    -0.00730524f, 0.01075310f, 0.04466136f, -0.00059203f, -0.01564161f, -0.03259806f, -0.06704058f, -0.04811300f, 
    -0.05838308f, 0.00900544f, 0.01291466f, 0.05787823f, 0.04825428f, -0.02269900f, 0.04910430f, -0.07716671f, 
    0.00680335f, -0.04441407f, 0.01893508f, 0.05831290f, 0.05315423f, -0.06680074f, -0.03016558f, 0.00766695f, 
    0.05586676f, 0.03687571f, -0.02116868f, 0.02317963f, 0.05360658f, -0.01095587f, -0.04000179f, -0.06815077f, 
    0.02735676f, -0.07258515f, -0.06236648f, -0.07533474f, 0.00856136f, -0.03851768f, 0.03605801f, 0.02497442f, 
    -0.00378771f, -0.03568245f, -0.04903021f, 0.02634413f, 0.04603085f, -0.04270723f, 0.04560434f, -0.04227355f, 
    0.01263136f, 0.00756047f, -0.04787108f, 0.04495924f, -0.01774124f, 0.01346418f, 0.04739951f, 0.00231365f, 
    -0.17453146f, -0.34799364f, -0.20008872f, 0.02104938f, 0.08017278f, -0.00792504f, 0.02949879f, -0.03300050f, 
    -0.12658077f, -0.09558328f, -0.20712858f, -0.01614317f, -0.19057330f, 0.10362190f, -0.04771223f, -0.09110400f, 
    -0.05884095f, -0.10436900f, 0.05752712f, 0.06435122f, -0.13195060f, -0.05142349f, 0.00667915f, -0.07497605f, 
    -0.11635642f, -0.00253121f, -0.09921365f, -0.14038706f, 0.00706935f, 0.12063631f, 0.12539171f, 0.13676637f, 
    0.03736296f, -0.21512604f, -0.04191586f, -0.14021599f, -0.40931952f, 0.22935569f, 0.06524543f, -0.07191168f, 
    0.05691772f, -0.05152800f, 0.09281487f, 0.22143701f, 0.07783286f, -0.08057140f, -0.20125328f, 0.08477904f, 
    -0.02254884f, 0.03296759f, -0.10522745f, -0.11400661f, 0.09659161f, 0.05738497f, 0.12478895f, 0.23430201f, 
    0.12727283f, -0.09341718f, 0.11433086f, -0.06939290f, -0.01665986f, 0.05627679f, 0.01260671f, 0.01588332f, 
    -0.04103336f, -0.01740058f, -0.03320769f, 0.02377520f, 0.10407002f, 0.04044076f, 0.07612660f, 0.20215178f, 
    0.33586422f, 0.31911463f, 0.21176629f, 0.14033285f, 0.15677674f, 0.01861512f, -0.02651721f, 0.03435934f, 
    -0.06390893f, 0.00453314f, -0.04678872f, -0.01120220f, -0.34196728f, -0.02063847f, 0.20936546f, -0.27146482f, 
    -0.03572160f, -0.05698623f, -0.01399891f, 0.06158199f, 0.11793809f, -0.00717777f, -0.03786585f, 0.07964475f, 
    0.16191316f, 0.26696816f, 0.17371297f, 0.04777754f, 0.02866331f, 0.16501424f, -0.04694080f, 0.08713141f, 
    -0.13363710f, 0.08431180f, 0.09089664f, 0.03728421f, 0.29615799f, 0.31931299f, 0.10164739f, -0.06488112f, 
    -0.05284049f, 0.27847821f, -0.01562150f, 0.07357089f, -0.15047017f, 0.29109633f, -0.12435403f, -0.12897427f, 
    -0.02073766f, -0.07585303f, 0.11138710f, 0.07433982f, 0.05759245f, 0.08405188f, -0.03991836f, -0.12247933f, 
    0.06756695f, -0.13845013f, 0.25198478f, -0.26731384f, -0.23514032f, -0.08002418f, -0.34836936f, -0.23843129f, 
    -0.00582120f, 0.09566375f, 0.07281832f, -0.00700813f, 0.20984316f, 0.01095365f, 0.03792849f, -0.07020491f, 
    0.16619997f, -0.08956958f, 0.10487685f, -0.18409120f, 0.10228513f, -0.11396374f, 0.06483685f, 0.03763041f, 
    0.08396550f, 0.03173796f, -0.03909477f, 0.12378356f, -0.20287903f, -0.00049711f, -0.05934200f, -0.04719053f, 
    -0.13344884f, 0.03062153f, -0.06706124f, 0.13790987f, -0.07896695f, 0.06178732f, -0.19549581f, 0.21607320f, 
    0.31167281f, 0.35893261f, 0.14143436f, -0.01662386f, 0.05749992f, -0.05289543f, 0.23308674f, 0.03062558f, 
    0.00281620f, 0.07055095f, 0.08895520f, 0.08921614f, 0.19159637f, -0.23316157f, -0.06114008f, 0.04773787f, 
    -0.09708014f, -0.17027649f, 0.08990710f, -0.04749950f, -0.08301757f, 0.02798451f, 0.06297377f, 0.10704870f, 
    0.01498720f, -0.20739636f, -0.15124111f, 0.03318674f, -0.04016627f, -0.08622359f, 0.03154802f, -0.05666359f, 
    0.13317338f, 0.04078272f, 0.06870060f, 0.15918252f, -0.10048756f, -0.39326274f, -0.11386866f, -0.08404478f, 
    0.12922467f, -0.22839838f, -0.05426500f, -0.06324255f, -0.06745355f, 0.02387668f, 0.14589949f, 0.21543445f, 
    -0.24901558f, 0.01150129f, 0.05272540f, -0.00200580f, -0.03280884f, 0.08706807f, 0.15645018f, 0.09004258f, 
    0.12763715f, -0.01749102f, 0.12400810f, 0.17135492f, 0.09618741f, 0.13263327f, -0.23150575f, -0.09710191f, 
    -0.06067288f, -0.06415705f, 0.06040404f, 0.07992200f, 0.20426843f, 0.13749592f, 0.07537791f, 0.09602150f, 
    0.35001269f, 0.26127720f, 0.20603628f, 0.24262236f, -0.12915292f, -0.11412624f, 0.02441923f, 0.04425258f, 
    0.04388563f, 0.02390523f, 0.08984378f, 0.07275171f, -0.17019604f, -0.15729569f, -0.13138226f, 0.00601278f, 
    0.15950511f, -0.03335490f, 0.08284942f, 0.05888021f, -0.08740386f, -0.23950782f, -0.05087414f, -0.08775026f, 
    0.07615691f, 0.18303020f, 0.08347608f, 0.03267796f, 0.11573152f, 0.32160673f, -0.08195802f, 0.05842374f, 
    0.13411631f, 0.08680631f, 0.07064912f, 0.13112900f, -0.35882944f, -0.11212637f, -0.26008159f, -0.08022710f, 
    -0.16381189f, 0.03750902f, -0.05023126f, 0.11191071f, 0.09713866f, 0.03528960f, -0.03538512f, -0.02537822f, 
    0.14716034f, 0.02509601f, 0.31079859f, -0.07930724f, 0.09844724f, 0.11263770f, -0.11668053f, -0.05610242f, 
    -0.01475627f, 0.02429775f, -0.09189907f, -0.01741539f, -0.11417106f, 0.03755843f, -0.02293383f, -0.25986889f, 
    0.03712251f, 0.17003076f, 0.03714429f, -0.18796931f, -0.01531576f, 0.02743892f, 0.17924458f, 0.20250598f, 
    -0.08117238f, 0.04607667f, 0.04502237f, 0.05894300f, 0.04559673f, 0.04732390f, -0.11419100f, -0.03211042f, 
    -0.08968104f, -0.18443570f, -0.01850445f, -0.17931078f, 0.40572020f, -0.18695913f, 0.29993904f, 0.04887293f, 
    -0.23518826f, -0.10164073f, -0.22067495f, -0.01060941f, 0.24575846f, -0.11748999f, -0.11255123f, 0.03619307f, 
    0.11241020f, -0.22464938f, 0.13673159f, -0.12750323f, 0.04045888f, -0.01343740f, -0.16098626f, -0.04312841f, 
    -0.10567817f, -0.02511059f, -0.03251516f, 0.10885184f, 0.16590609f, -0.16178203f, 0.25105181f, -0.07262211f, 
    -0.10724568f, -0.27428746f, -0.06584501f, 0.11589862f, 0.01708005f, 0.09451222f, 0.13309038f, 0.15347241f, 
    0.03797907f, 0.16890839f, 0.00506218f, -0.02426996f, 0.23249006f, 0.06136357f, 0.16259538f, -0.05231507f, 
    0.03700076f, -0.21440655f, -0.17917316f, 0.04790734f, 0.40614030f, 0.01399705f, 0.44841659f, -0.04968306f, 
    0.15274437f, -0.01543380f, -0.09275683f, -0.00167977f, 0.07285517f, 0.08456490f, -0.09424948f, 0.06642707f, 
    0.02719367f, 0.11460344f, -0.01001913f, 0.17287870f, -0.01087820f, 0.04515856f, -0.06452234f, 0.09083161f, 
    -0.08507814f, 0.00713403f, 0.23209901f, 0.22059605f, -0.07529557f, 0.11877108f, -0.14695990f, 0.22545950f, 
    -0.00590812f, 0.10216734f, -0.11471175f, 0.13907692f, 0.14192034f, 0.18702140f, 0.15835880f, 0.00952691f, 
    -0.13837104f, 0.08434097f, 0.10334914f, -0.09280237f, 0.07076197f, 0.02970889f, 0.09624186f, -0.10838725f, 
    -0.10230955f, 0.19227540f, 0.19085315f, 0.02371914f, -0.01461725f, 0.01109289f, -0.09845770f, 0.09410808f, 
    -0.08520078f, 0.14081515f, 0.10268320f, 0.24961805f, 0.22296906f, 0.07252095f, 0.24626108f, 0.12862925f, 
    -0.42014048f, 0.20010540f, 0.12602134f, -0.22839925f, -0.20233712f, -0.10192006f, -0.08187661f, 0.03807022f, 
    0.06214070f, 0.12224564f, -0.01221471f, -0.03877800f, 0.10608061f, -0.00656475f, -0.03723484f, 0.03880472f, 
    0.13126390f, -0.03229824f, 0.01224441f, 0.19783925f, -0.14256263f, -0.09964513f, -0.11867804f, -0.16513592f, 
    -0.07340499f, -0.14664283f, 0.01462898f, -0.10818243f, 0.02586369f, -0.34292594f, 0.02626270f, -0.03100621f, 
    0.14249782f, 0.01843737f, 0.02046769f, 0.14988634f, 0.29254994f, 0.08720586f, 0.21825278f, 0.08892347f, 
    0.04213832f, 0.03925433f, 0.14708014f, 0.08194168f, -0.03003696f, 0.01792679f, 0.18406186f, -0.05293069f, 
    -0.34730935f, 0.02533275f, -0.53174508f, 0.17384639f, -0.04998937f, -0.02626998f, 0.00630734f, 0.00062084f, 
    0.02587216f, -0.04076155f, -0.06431663f, 0.09454013f, 0.15608591f, -0.08035098f, 0.11396599f, 0.09970613f, 
    -0.04627643f, -0.19970979f, 0.18307935f, 0.21999517f, 0.02938562f, -0.05097671f, -0.00781857f, 0.16618997f, 
    -0.04366986f, -0.31139398f, 0.00148014f, -0.33984131f, 0.01285188f, -0.19345514f, 0.08541705f, 0.28046656f, 
    -0.16317882f, 0.18341888f, -0.14852962f, -0.03518774f, -0.31584445f, 0.30667144f, -0.03785170f, 0.27755871f, 
    -0.05773220f, 0.01217390f, -0.03412576f, -0.00119098f, -0.06625182f, -0.05779512f, 0.18136416f, 0.02262442f, 
    -0.19768746f, -0.12495383f, 0.08499021f, 0.08090853f, 0.17852308f, 0.11311011f, 0.03751794f, 0.07345217f, 
    0.16451965f, 0.05875558f, 0.08736367f, -0.16114628f, -0.18129002f, 0.12599622f, -0.12575629f, 0.16080150f, 
    0.06610940f, 0.01019043f, -0.09264439f, 0.04830744f, -0.04070185f, -0.01366921f, 0.06346612f, 0.15269215f, 
    -0.26013887f, -0.26771697f, -0.19140510f, -0.20030287f, -0.23444894f, -0.23174763f, -0.09252347f, -0.15085489f, 
    -0.15387581f, -0.08656977f, -0.13119631f, -0.20405549f, -0.31698877f, 0.12294658f, -0.04003926f, 0.28378794f, 
    -0.05528112f, 0.22434562f, 0.02125514f, -0.14814164f, 0.07602285f, -0.07351537f, 0.18060714f, 0.13865623f, 
    0.00822195f, 0.05885436f, 0.12598899f, 0.07999706f, -0.03435241f, 0.04074463f, -0.11609003f, 0.02264027f, 
    0.00417074f, 0.01378327f, 0.19316687f, 0.02100581f, -0.07416738f, 0.16310129f, -0.12432513f, 0.12429249f, 
    0.06097426f, 0.03643935f, 0.06339889f, 0.09730131f, 0.04889901f, 0.15197191f, -0.00705040f, 0.08720885f, 
    0.09292708f, 0.11730125f, 0.04510619f, -0.10300808f, -0.01799856f, 0.06672343f, -0.05878662f, -0.15144795f, 
    -0.10886596f, 0.04173926f, 0.14939255f, 0.09266376f, -0.09418750f, -0.13861419f, -0.16559716f, 0.14488287f, 
    0.01235968f, 0.01807630f, -0.08633578f, 0.01372797f, 0.04518319f, 0.04638512f, 0.07154138f, 0.05261493f, 
    -0.50531316f, -0.24785247f, -0.39501020f, -0.24832979f, -0.03900827f, 0.01394923f, 0.00314317f, 0.07479772f, 
    -0.01847651f, 0.00854685f, -0.06094563f, -0.16645248f, 0.11385260f, 0.05862191f, -0.04564841f, 0.06153023f, 
    0.05840799f, 0.14155526f, -0.11564210f, -0.01295991f, -0.13422485f, -0.02131980f, -0.13221690f, -0.12477898f, 
    0.07255326f, 0.02142894f, 0.17612456f, -0.06012560f, 0.00342328f, -0.02385568f, -0.05015607f, -0.05043839f, 
    0.05886284f, -0.12240364f, 0.04264095f, 0.02873165f, 0.31335610f, 0.02910217f, 0.35981071f, 0.20451093f, 
    0.12614329f, -0.07612726f, 0.02659389f, 0.13564286f, -0.00139618f, 0.11540697f, -0.03728879f, 0.04870090f, 
    0.00734082f, 0.15864570f, -0.15826604f, 0.09415870f, -0.00522783f, -0.23655307f, 0.08204816f, 0.12665856f, 
    0.06567355f, 0.03960377f, -0.04256649f, 0.04321420f, 0.34380087f, -0.35874006f, 0.23982224f, 0.24429041f, 
    -0.09525291f, -0.04909032f, 0.06897868f, -0.01354899f, 0.01423365f, -0.21701394f, 0.16122916f, -0.07349173f, 
    0.04570644f, -0.07593437f, -0.06644424f, -0.09801214f, 0.06296617f, 0.04433904f, 0.12138961f, 0.18451761f, 
    -0.01150974f, 0.09384697f, 0.03231988f, 0.08163248f, -0.30670059f, -0.11650332f, -0.18296841f, 0.00058360f, 
    -0.00339739f, 0.05979307f, 0.08155251f, 0.11847270f, -0.07504243f, 0.08859040f, 0.11630941f, -0.02054168f, 
    -0.00422880f, 0.05217468f, -0.00322119f, 0.19314107f, 0.09096297f, 0.05559101f, 0.09700853f, 0.05999349f, 
    0.13485837f, 0.01831231f, 0.13998483f, -0.06638604f, -0.06135134f, 0.08163147f, -0.14759576f, 0.04877725f, 
    -0.04843294f, -0.00953528f, 0.02805282f, 0.00012385f, 0.06180673f, 0.09101881f, 0.08786143f, 0.01318636f, 
    -0.18111122f, 0.01611600f, -0.06762707f, 0.02013190f, -0.01088335f, -0.03247903f, 0.00831403f, -0.05336576f, 
    -0.08043761f, -0.06676420f, -0.09946411f, -0.17994313f, -0.05844507f, 0.63106823f, -0.36275789f, 0.08752377f, 
    -0.08665899f, 0.20676994f, 0.00726548f, 0.09195782f, 0.15226395f, -0.04354620f, 0.07762779f, 0.10571629f, 
    -0.09065777f, -0.09249306f, -0.12590784f, -0.12317967f, -0.03144195f, -0.01140747f, 0.06985598f, -0.05925677f, 
    0.07905196f, -0.00016923f, -0.11189696f, -0.14172743f, -0.10160816f, -0.13068928f, -0.12276579f, -0.28790092f, 
    -0.01264564f, -0.06603606f, 0.00964140f, -0.05717894f, 0.12182400f, 0.07891361f, 0.09416062f, -0.02234966f, 
    -0.33853668f, -0.16074483f, -0.11969525f, -0.11201176f, -0.10772554f, -0.07018053f, 0.12737764f, 0.08595559f, 
    -0.06955264f, -0.19567172f, -0.05036947f, -0.04865016f, 0.37887648f, 0.21956253f, 0.01820027f, -0.02894182f, 
    -0.08634992f, -0.11168636f, -0.00030929f, 0.08123068f, -0.02458994f, 0.06140950f, 0.03429661f, 0.04012010f, 
    -0.14352566f, 0.18151182f, 0.05861968f, 0.28216958f, -0.01275861f, 0.09034216f, 0.12032688f, 0.17154253f, 
    0.17380804f, -0.03501927f, -0.13155723f, -0.04047723f, -0.23414306f, -0.09078746f, -0.03615564f, -0.20538731f, 
    -0.05843034f, 0.11008394f, -0.09498670f, -0.02324435f, 0.29005310f, 0.14988831f, 0.08177307f, 0.19180265f, 
    -0.08075977f, -0.00080750f, 0.00418677f, 0.12825133f, 0.05366848f, 0.16802546f, -0.05494546f, -0.09345873f, 
    -0.08871844f, -0.16183455f, 0.01451143f, -0.00855883f, 0.21837294f, 0.18507136f, -0.06750216f, 0.09028335f, 
    0.03877471f, -0.11387827f, -0.01781929f, -0.12716560f, 0.04953692f, 0.01477610f, 0.11714780f, -0.00820827f, 
    0.26508453f, -0.21223328f, 0.07180360f, 0.15948464f, 0.16198018f, 0.15433352f, 0.19994466f, -0.08124615f, 
    0.05105015f, 0.04362399f, 0.16067231f, -0.06955972f, 0.08389838f, 0.21150735f, -0.06731155f, 0.14540492f, 
    0.18104380f, -0.00137348f, -0.04259869f, 0.11600988f, 0.24622136f, 0.12308069f, 0.11705345f, -0.11394300f, 
    -0.21361746f, 0.04782090f, 0.04835883f, 0.01473791f, -0.02136086f, 0.06496991f, -0.10737604f, -0.09479854f, 
    0.17317459f, -0.03237150f, 0.11462061f, 0.14144109f, -0.24153402f, -0.28813463f, 0.02373899f, -0.06812043f, 
    -0.12627235f, -0.12009833f, 0.04934891f, -0.12061359f, 0.14073819f, 0.19037463f, 0.11380091f, 0.27834737f, 
    0.26935834f, 0.20922525f, 0.01048068f, -0.10012545f, 0.04158684f, -0.07478686f, -0.10791266f, 0.05253700f, 
    0.13434026f, 0.06886438f, 0.16549355f, 0.13746068f, -0.21621108f, -0.09686289f, -0.11765953f, -0.15499598f, 
    -0.08313260f, -0.05743224f, 0.08326451f, 0.02140045f, 0.16938488f, -0.08161833f, -0.00558520f, 0.20535095f, 
    -0.07796492f, -0.13854176f, 0.04123769f, -0.19976629f, 0.14898814f, 0.00108381f, 0.00569573f, -0.10656986f, 
    0.02083429f, -0.01448541f, -0.08489063f, -0.03570214f, -0.20193557f, -0.03028854f, 0.04596070f, 0.00818663f, 
    -0.14496073f, -0.14851773f, -0.09879293f, 0.09233265f, 0.05149053f, -0.12444949f, 0.09286582f, 0.03856916f, 
    0.15523694f, 0.03111369f, -0.04471577f, 0.01721068f, -0.03816114f, 0.01040087f, -0.00533605f, -0.00210258f, 
    0.27065083f, 0.21392009f, 0.27160147f, 0.30734181f, 0.04521373f, -0.21139458f, -0.22287369f, 0.00036312f, 
    -0.01099316f, 0.11593211f, -0.06329246f, 0.01431087f, 0.19770828f, 0.07195214f, 0.08273084f, 0.13767372f, 
    -0.29687467f, -0.05045328f, 0.18010943f, 0.21718554f, -0.08888489f, -0.04519427f, 0.11552278f, -0.03596233f, 
    -0.00426105f, 0.07398659f, 0.08320646f, 0.20411138f, 0.33365560f, -0.04645292f, -0.21367158f, -0.02270256f, 
    0.11560232f, -0.07878508f, 0.16966875f, 0.11768752f, 0.09227537f, 0.17358324f, 0.21232492f, 0.16913417f, 
    0.08563099f, 0.33502385f, 0.25944564f, 0.30460730f, -0.02141581f, -0.18156376f, 0.12622690f, -0.08650085f, 
    -0.00344896f, -0.03233724f, -0.02617273f, 0.10978900f, 0.09610976f, -0.02639707f, 0.02828670f, -0.21722350f, 
    0.18788040f, -0.06914617f, -0.26733726f, -0.05052469f, -0.20369884f, -0.39214405f, -0.13887526f, -0.36454758f, 
    -0.31990305f, 0.00132476f, 0.26336777f, 0.11212036f, -0.01265590f, -0.04395304f, 0.17678542f, 0.10195213f, 
    0.11930060f, 0.05083655f, 0.02740147f, -0.04046544f, 0.13309915f, -0.05286173f, -0.17921647f, -0.06311785f, 
    -0.00850313f, 0.06677964f, -0.11347135f, 0.10525378f, 0.05215994f, 0.15225534f, 0.09735582f, -0.11433215f, 
    -0.05161395f, -0.35163885f, -0.03829850f, 0.31859389f, 0.05026719f, -0.11110055f, 0.05346021f, 0.03892657f, 
    0.08597618f, -0.13607906f, -0.09803323f, 0.06549305f, -0.45856664f, 0.09827523f, -0.03149037f, 0.14267659f, 
    -0.02814851f, 0.01319284f, 0.19469492f, 0.19680345f, -0.05494358f, 0.05098516f, 0.14093786f, 0.10334434f, 
    -0.18231514f, -0.03681547f, 0.33978495f, 0.02847623f, -0.05645134f, -0.11594986f, -0.04018501f, 0.04052950f, 
    -0.21781339f, 0.07536577f, -0.14336653f, -0.12005845f, 0.11612771f, 0.09347238f, 0.08166169f, 0.06982680f, 
    -0.00403372f, -0.21484317f, -0.11092904f, -0.04988169f, 0.11683086f, -0.14356895f, -0.10341365f, 0.01911356f, 
    0.04276164f, -0.01439380f, -0.25280708f, 0.14848913f, 0.13697769f, -0.10045538f, -0.07791346f, 0.03098339f, 
    -0.03801189f, -0.03019716f, 0.04512715f, -0.26797339f, -0.13140865f, -0.06805180f, -0.22416100f, 0.05529374f, 
    0.18774463f, 0.03686550f, -0.15725175f, 0.00543904f, 0.04790829f, 0.01770997f, 0.01311823f, 0.02640314f, 
    -0.14387253f, -0.15790857f, 0.05569269f, 0.13850692f, -0.10922081f, -0.10544787f, 0.04438865f, 0.00281266f, 
    -0.06071126f, -0.15987751f, -0.20388024f, -0.26005405f, -0.33723533f, -0.00535366f, 0.34804827f, 0.04450275f, 
    0.14502387f, 0.18219240f, -0.06799125f, -0.05261211f, -0.05678828f, 0.03187384f, -0.04927571f, 0.00306075f, 
    0.01590904f, -0.02333854f, -0.04084529f, -0.02156952f, -0.07496487f, 0.03859168f, -0.04520662f, 0.03561288f, 
    -0.04247401f, 0.03985253f, -0.07841650f, 0.02378689f, -0.06131893f, 0.03574869f, -0.02287688f, 0.01998700f, 
    0.00793334f, 0.00608534f, -0.06280891f, -0.06986503f, -0.01584061f, 0.02417376f, -0.01314836f, 0.01741277f, 
    0.04566672f, -0.02072299f, -0.04050114f, -0.02611491f, -0.04900429f, -0.06868636f, 0.01305196f, 0.03435320f, 
    0.01394315f, 0.05508497f, -0.04625078f, 0.05291392f, -0.01016549f, 0.00411155f, -0.00437579f, 0.05322425f, 
    -0.03235566f, 0.04786300f, -0.03212342f, -0.05794967f, -0.02438326f, -0.03522065f, -0.07122051f, -0.00188344f, 
    -0.03550684f, -0.03677645f, -0.04078896f, -0.01641047f, -0.01952645f, -0.07146159f, 0.03266304f, 0.04692220f, 
    -0.06105752f, -0.01769171f, 0.05716957f, 0.05220131f, 0.06107058f, -0.01070314f, -0.03474377f, -0.00689825f, 
    -0.01457532f, -0.06089883f, -0.06596608f, -0.02531241f, 0.00589406f, 0.05352726f, 0.03072211f, -0.07855485f, 
    -0.05112555f, 0.01823844f, 0.03491195f, 0.04287984f, 0.02736399f, 0.02383924f, -0.04675503f, 0.00478266f, 
    -0.08571014f, 0.05489518f, -0.03400208f, 0.06312338f, -0.06211361f, 0.05107740f, -0.02007368f, 0.06212431f, 
    -0.04221521f, -0.01809789f, 0.04555731f, 0.01365263f, 0.03988554f, 0.00953564f, 0.05424850f, 0.02675637f, 
    0.03022522f, 0.01926813f, -0.05147287f, 0.03234420f, 0.03951184f, -0.00079742f, 0.03019307f, 0.05873024f, 
    -0.03355774f, -0.06954794f, 0.05392269f, -0.07480493f, -0.07837903f, 0.05905633f, -0.05671890f, -0.07741907f, 
    0.04528378f, -0.07593912f, -0.02535219f, -0.03886526f, -0.03027903f, -0.02375188f, 0.02032920f, 0.03958930f, 
    -0.07938932f, 0.03236311f, 0.03311934f, 0.03070576f, -0.07191997f, -0.04034265f, -0.04988347f, 0.03910828f, 
    0.05582688f, -0.04742559f, -0.00610384f, -0.04079859f, 0.02896602f, -0.01978898f, 0.04081770f, -0.04502192f, 
    -0.03694045f, 0.04794096f, 0.02465459f, 0.03275052f, 0.05790986f, -0.05813249f, 0.04526752f, -0.03705728f, 
    0.05039561f, -0.06602173f, -0.08370552f, -0.03142834f, -0.04775352f, 0.03304981f, -0.01035307f, -0.05334277f, 
    -0.06942368f, -0.03728249f, -0.01200561f, -0.02603970f, 0.05971885f, -0.01316107f, -0.06336091f, 0.05239869f, 
    0.01233177f, -0.07763299f, 0.02288995f, 0.01733316f, -0.04155545f, -0.05940084f, -0.07651465f, -0.01616799f, 
    -0.04930319f, 0.03522300f, -0.05034449f, -0.04982463f, -0.01717954f, 0.01123668f, -0.00960968f, 0.01427338f, 
    -0.02492861f, 0.04277098f, -0.03108496f, 0.00917925f, -0.01036793f, -0.03413413f, 0.05415209f, -0.02237219f, 
    -0.04962146f, -0.02007081f, -0.02332910f, 0.06370653f, -0.01379769f, -0.01119770f, -0.00072043f, 0.00035588f, 
    -0.03517735f, -0.06810563f, -0.06344274f, 0.02755291f, 0.00181695f, -0.00319316f, -0.04550366f, -0.05808774f, 
    -0.03127785f, -0.06877317f, 0.01160750f, -0.05299913f, 0.04453090f, -0.04655282f, 0.01619326f, 0.02486177f, 
    0.03110007f, -0.05175996f, -0.02004979f, 0.03309852f, 0.05398622f, 0.01967017f, 0.04867370f, -0.02805472f, 
    -0.01451685f, -0.07864638f, -0.06253492f, 0.04838170f, 0.02251309f, -0.06532533f, -0.05446937f, 0.00787138f, 
    0.05255967f, -0.01350818f, -0.03295556f, 0.04046829f, -0.04888764f, 0.02308169f, -0.05043959f, -0.00201247f, 
    0.02860938f, -0.05103095f, -0.04637284f, 0.00942065f, -0.00412138f, -0.04732852f, 0.03216263f, -0.00693927f, 
    0.03538325f, -0.02001780f, 0.03452291f, -0.06123738f, 0.04360197f, -0.03490159f, -0.05505957f, -0.02296614f, 
    -0.05780240f, -0.04847178f, -0.07962242f, -0.06354319f, 0.00452574f, 0.04400050f, -0.06507737f, 0.00299210f, 
    0.00051100f, -0.02684810f, -0.02567166f, 0.05873327f, -0.05242357f, -0.07943617f, 0.03992598f, 0.01289771f, 
    0.04790653f, 0.00259849f, -0.06043857f, -0.07861551f, 0.03549635f, -0.08069644f, 0.01246371f, -0.05766935f, 
    -0.06319012f, 0.01012984f, -0.03600818f, 0.03232150f, 0.06783314f, -0.01140016f, 0.03778124f, 0.05740139f, 
    -0.07201347f, -0.07793519f, -0.04127187f, -0.03033135f, 0.01444762f, 0.02114809f, 0.03818518f, -0.05996796f, 
    -0.00733868f, 0.02986474f, -0.06960102f, 0.02150399f, 0.00478549f, -0.02547339f, -0.01346596f, -0.02918359f, 
    -0.02023480f, 0.02166976f, -0.03522378f, 0.03963857f, -0.08812184f, -0.03748396f, -0.01469896f, -0.02982406f, 
    -0.01267503f, -0.06037837f, -0.00206937f, 0.04644924f, 0.03576907f, 0.05682250f, 0.01731296f, -0.05282236f, 
    -0.06781417f, -0.07039453f, -0.08354899f, 0.05599273f, -0.04708833f, -0.01650527f, 0.04592182f, -0.05610104f, 
    -0.01525316f, 0.01003207f, 0.00367701f, -0.01742242f, -0.03816083f, -0.00872286f, -0.08323111f, 0.01965749f, 
    -0.06798296f, 0.03149582f, 0.00973558f, -0.04228185f, 0.05042313f, 0.01852854f, -0.08347344f, -0.00401711f, 
    -0.03766093f, 0.04636342f, -0.02230855f, -0.07487769f, -0.04179700f, -0.05764972f, -0.05452509f, -0.00791097f, 
    -0.05434035f, -0.00055397f, 0.02251513f, -0.04673807f, -0.00327873f, 0.03780933f, -0.03074926f, 0.02459504f, 
    0.04974338f, -0.08541011f, -0.04537969f, 0.01155773f, -0.02995564f, 0.04301525f, 0.03578085f, -0.03703675f, 
    0.03526255f, 0.00142089f, -0.00161959f, 0.02365895f, 0.02941493f, 0.02565204f, 0.00019294f, 0.03372433f, 
    -0.05049592f, -0.07719991f, 0.05562245f, -0.06422701f, -0.03905533f, -0.02632090f, -0.03081176f, 0.05017845f, 
    -0.06529889f, -0.08269209f, -0.05655789f, -0.03624902f, 0.01224079f, 0.02840859f, 0.05036573f, 0.01238657f, 
    -0.04213009f, 0.04458123f, 0.01558842f, 0.01531989f, 0.02228020f, -0.07009928f, -0.03118839f, 0.00846594f, 
    -0.07422523f, -0.06671845f, 0.04078780f, -0.00656880f, -0.06569643f, -0.04582488f, -0.05895028f, 0.05609282f, 
    0.04906580f, -0.07134756f, 0.02524233f, 0.02921580f, -0.05894465f, -0.07251739f, 0.04353626f, 0.06259999f, 
    -0.00633772f, 0.05988221f, 0.05801727f, -0.04216722f, 0.03270470f, -0.06118400f, 0.02192329f, -0.05084029f, 
    0.00551764f, 0.05790699f, 0.06082652f, 0.05854590f, 0.02854726f, -0.05059742f, -0.04871231f, -0.06256872f, 
    0.04570479f, -0.06466895f, 0.01636905f, -0.00487005f, 0.04324092f, -0.04626441f, 0.02493089f, -0.04247863f, 
    -0.06975642f, -0.00039470f, -0.07100952f, -0.01797841f, -0.05811534f, -0.04486593f, -0.03507151f, 0.05392999f, 
    -0.02424375f, -0.00660700f, -0.04354276f, -0.07404966f, 0.04470107f, 0.04265907f, 0.06411548f, 0.02158278f, 
    -0.04184544f, -0.07205522f, -0.02809704f, -0.00396863f, 0.00420469f, -0.02626827f, 0.05840520f, 0.05124871f, 
    0.02498099f, -0.01618167f, 0.04634909f, -0.00994896f, -0.00545829f, -0.07067703f, -0.01753460f, -0.01636190f, 
    0.01868634f, 0.01037711f, 0.05322798f, -0.05471579f, 0.01231857f, -0.05790162f, 0.02903735f, -0.05103232f, 
    0.00227673f, 0.06231016f, -0.00985742f, 0.03993970f, -0.03278621f, -0.01391855f, -0.04770954f, -0.05738580f, 
    0.00843781f, 0.00482460f, -0.06716871f, -0.07554328f, 0.06500380f, 0.05584409f, -0.02481024f, -0.06727389f, 
    -0.02754997f, -0.03027765f, 0.04419776f, -0.03144970f, -0.04201792f, -0.07027071f, 0.02419744f, -0.06224230f, 
    -0.06052326f, 0.05180409f, -0.06159127f, 0.00270818f, 0.00518712f, -0.01773077f, -0.06388962f, 0.03843639f, 
    0.03407415f, -0.06369881f, 0.05141297f, -0.02508362f, 0.02081648f, -0.07529861f, -0.04822601f, 0.02155393f, 
    0.01941278f, -0.03889591f, -0.01719148f, -0.01172215f, -0.06872445f, -0.01324306f, 0.02108948f, -0.06271848f, 
    -0.05818697f, 0.00606793f, -0.01100691f, 0.00318987f, 0.05638349f, -0.01033070f, 0.02491911f, 0.04530121f, 
    0.01020735f, -0.07231888f, -0.07431205f, 0.01761384f, -0.03417178f, -0.01763500f, 0.04931010f, -0.07490514f, 
    0.02555776f, -0.05808212f, -0.05711612f, 0.04253299f, 0.04734328f, -0.00688561f, 0.04176814f, -0.02099791f, 
    -0.07366252f, -0.06813431f, -0.05988651f, -0.03418723f, -0.03971125f, -0.01752725f, -0.03410269f, -0.04926890f, 
    -0.03659020f, 0.05031658f, -0.07488722f, 0.04608607f, -0.03284029f, -0.07270985f, 0.06504636f, -0.04480003f, 
    -0.01019621f, 0.00851493f, -0.04563110f, 0.00724840f, 0.05528387f, 0.00501265f, -0.07562611f, 0.02262399f, 
    0.01899680f, 0.04158409f, -0.05301674f, -0.07551660f, 0.00109405f, 0.04644049f, 0.02339721f, -0.05385722f, 
    -0.22248766f, 0.16477351f, 0.19670250f, 0.02176000f, -0.12633707f, 0.00085910f, -0.14134979f, -0.04622741f, 
    -0.06184535f, 0.00061764f, -0.07491125f, -0.32747906f, -0.12418874f, 0.06349460f, 0.09263089f, -0.17314351f, 
    -0.12024104f, -0.07063188f, 0.06090160f, -0.10867184f, 0.04383703f, 0.03192063f, -0.02889473f, 0.00984224f, 
    0.19167590f, 0.02806953f, -0.02897994f, 0.19334072f, 0.13253303f, 0.05512721f, -0.11654016f, 0.00471062f, 
    0.11757398f, -0.03896801f, -0.06122233f, 0.03715288f, 0.51016229f, -0.04512086f, 0.28730053f, 0.02375680f, 
    0.00585155f, 0.04442542f, -0.05925870f, -0.06896295f, -0.08493301f, -0.00539355f, -0.07499700f, -0.06979833f, 
    0.23227531f, -0.15426560f, -0.09552804f, 0.08424134f, 0.08364084f, 0.13729534f, -0.02290879f, 0.06740246f, 
    -0.01986328f, -0.03463529f, -0.02710822f, 0.04464088f, -0.34554476f, -0.12503728f, -0.12955716f, -0.05671114f, 
    -0.01288615f, -0.00012916f, 0.00689656f, -0.13830087f, 0.01456542f, 0.21377926f, 0.10668073f, 0.10466209f, 
    -0.16948587f, -0.17759244f, -0.10655764f, 0.11778465f, 0.02230406f, 0.08854032f, -0.05205595f, -0.05786941f, 
    -0.00073512f, -0.06862077f, -0.07783116f, 0.09732983f, 0.21279956f, 0.12677835f, 0.03644998f, 0.04522974f, 
    -0.09109819f, -0.10767482f, 0.10081162f, -0.07478594f, 0.03510027f, -0.00746318f, -0.06709236f, 0.00198959f, 
    -0.10693666f, 0.09792071f, -0.22140813f, 0.13128448f, 0.05347520f, 0.15664989f, 0.04100005f, 0.11989127f, 
    0.01906285f, 0.09194537f, -0.03150622f, 0.04237187f, -0.20472664f, 0.05110249f, 0.09888931f, -0.03047349f, 
    0.02435718f, 0.23338220f, -0.09978294f, -0.14375859f, 0.10037117f, -0.05818086f, 0.20297652f, -0.00261909f, 
    0.02987272f, 0.11174004f, 0.02939043f, 0.32479611f, -0.02469606f, 0.14480431f, 0.31705165f, 0.07661889f, 
    0.11046598f, 0.08998261f, -0.02711816f, 0.29965481f, -0.24353357f, 0.06778416f, -0.03426073f, -0.20532595f, 
    -0.16848835f, -0.06443669f, -0.13447115f, -0.11205623f, 0.05487061f, 0.20532081f, 0.09907131f, 0.18509594f, 
    0.00164557f, 0.27691677f, -0.23747075f, -0.18361627f, -0.31311858f, -0.09052242f, -0.00950854f, 0.16936398f, 
    0.00880753f, 0.04843277f, 0.17196199f, 0.12148860f, 0.01573375f, 0.08353068f, 0.06491379f, -0.28830823f, 
    -0.25340846f, -0.12536654f, 0.00445535f, -0.21555609f, 0.00163014f, -0.00088909f, 0.13423888f, -0.11563765f, 
    0.08629610f, -0.07313034f, 0.06604331f, 0.23102146f, 0.20685320f, 0.19284524f, 0.06782016f, 0.28348202f, 
    -0.07486064f, 0.10569189f, 0.08176753f, 0.21990888f, 0.23576641f, 0.20330147f, -0.27650422f, -0.16332838f, 
    -0.06051017f, -0.24825741f, -0.08202040f, 0.09151716f, 0.02942527f, -0.07653787f, 0.10852102f, 0.10847921f, 
    -0.07962151f, 0.00065904f, 0.05309270f, -0.08022340f, 0.00007869f, -0.04907737f, -0.07010139f, 0.06230564f, 
    -0.06607898f, 0.00526217f, 0.01519692f, -0.03333139f, 0.02977269f, -0.02056555f, -0.02915680f, 0.05995812f, 
    -0.02972708f, -0.00022758f, -0.00846802f, 0.00478428f, -0.02919137f, 0.03805772f, -0.03776186f, -0.07392859f, 
    -0.04765467f, -0.00396653f, -0.02356641f, 0.02481877f, -0.01350850f, -0.06004185f, 0.00438921f, 0.01904128f, 
    0.05954634f, -0.07705430f, 0.04096754f, 0.03316531f, -0.01213464f, -0.02125720f, 0.05541906f, -0.05246495f, 
    0.04385877f, 0.05782228f, 0.03543185f, -0.03228971f, -0.02354928f, -0.03503994f, 0.05749255f, 0.05113751f, 
    0.03265978f, 0.04933751f, -0.06400569f, 0.03649920f, -0.05906005f, -0.06521343f, 0.05659978f, -0.07297568f, 
    -0.05255789f, 0.02888965f, -0.03880951f, -0.06496965f, -0.01963168f, -0.00126433f, -0.00421534f, 0.06148351f, 
    0.05966304f, -0.03064157f, -0.04231607f, 0.05879076f, 0.03844431f, -0.02928629f, -0.03234993f, -0.02693344f, 
    -0.04808884f, -0.04293550f, 0.04976322f, -0.07288388f, 0.01477566f, 0.01856119f, 0.02226873f, -0.05115123f, 
    0.02181662f, -0.03486115f, -0.07559680f, 0.04537157f, -0.00990416f, 0.06023942f, 0.02914779f, 0.03989177f, 
    -0.00107227f, 0.06534450f, -0.04029983f, 0.05222073f, 0.05634760f, -0.02538475f, -0.06220583f, -0.00843896f, 
    -0.07514437f, 0.01539547f, 0.02669663f, 0.00849457f, -0.02077664f, -0.05750578f, -0.06876919f, 0.06268026f, 
    -0.03345773f, -0.04791481f, -0.02642639f, -0.01873600f, 0.03266916f, 0.00591723f, 0.00095868f, 0.03477222f, 
    -0.07115451f, 0.06027049f, -0.01503026f, 0.02078212f, -0.05013054f, 0.03377516f, 0.00699205f, -0.06582779f, 
    0.05050387f, -0.01941867f, -0.03980713f, 0.04839005f, -0.06034609f, 0.03933367f, 0.00895282f, -0.05391447f, 
    -0.01173660f, 0.05143280f, -0.06111827f, -0.02683185f, 0.03946167f, 0.02336550f, 0.06452747f, -0.05167745f, 
    -0.02791660f, 0.02102627f, -0.06386600f, 0.03559744f, 0.02239846f, 0.02420129f, -0.05550263f, 0.01487087f, 
    0.06648768f, -0.01631298f, -0.05620085f, -0.01802510f, 0.03246767f, -0.06956613f, -0.07241727f, -0.03897350f, 
    0.03182312f, -0.03997685f, -0.02600465f, -0.04024842f, -0.07162148f, -0.07610608f, -0.04558604f, 0.04165505f, 
    0.06719959f, 0.04137064f, 0.03551101f, -0.04803253f, -0.01480089f, 0.01770895f, -0.04080440f, 0.05894677f, 
    -0.00394241f, 0.06016428f, -0.06268018f, -0.00709361f, 0.05467714f, -0.05497038f, -0.00032398f, -0.05334478f, 
    -0.04077754f, -0.01572523f, -0.02556308f, 0.04596145f, 0.06888886f, -0.04214793f, 0.01881885f, 0.04481696f, 
    -0.04543109f, -0.06770573f, -0.07474849f, 0.05089271f, -0.00731105f, -0.03304784f, -0.06144931f, 0.02227427f, 
    0.04346630f, 0.14194849f, 0.14624925f, -0.06916550f, 0.00597602f, -0.03739058f, 0.03284990f, -0.06514856f, 
    -0.01483634f, -0.10683738f, 0.15466617f, -0.11598068f, 0.18972462f, -0.05778437f, 0.05721850f, -0.01542352f, 
    0.06691987f, 0.13365681f, 0.04366830f, -0.06634136f, 0.15987872f, -0.12156659f, 0.00915557f, -0.01459485f, 
    -0.07204658f, -0.05636905f, -0.00413904f, 0.01593892f, 0.03438489f, -0.07246932f, -0.06024074f, 0.04414547f, 
    -0.04791568f, 0.06105517f, -0.02850638f, 0.03931712f, 0.39629233f, 0.04430821f, 0.08534503f, 0.04706328f, 
    -0.04931463f, 0.00682548f, 0.03588693f, -0.17006336f, 0.04846893f, 0.13895884f, 0.18726708f, 0.13274659f, 
    0.27113342f, 0.06782961f, 0.06681604f, 0.00628711f, -0.07528678f, -0.01623206f, -0.16088629f, -0.20089674f, 
    -0.08419792f, -0.06557932f, 0.19159125f, 0.28102702f, -0.16888468f, -0.03167405f, -0.03899892f, -0.20526475f, 
    0.01386086f, 0.06172769f, 0.09853820f, -0.02237173f, 0.10031115f, 0.04461074f, 0.00440510f, -0.01417378f, 
    -0.35918641f, -0.31459340f, -0.02133829f, -0.01286852f, -0.11335459f, 0.15263501f, 0.16290107f, 0.00701145f, 
    -0.06281459f, -0.00242509f, 0.02374437f, -0.09645947f, 0.10548980f, 0.01507355f, -0.19962551f, 0.03584362f, 
    0.03047732f, -0.05575575f, 0.03331848f, -0.15734431f, -0.04068794f, 0.07347389f, 0.07380992f, 0.01848213f, 
    0.04200299f, -0.30577123f, 0.04254660f, 0.14507969f, -0.00911047f, 0.05239974f, 0.00173681f, -0.03370592f, 
    0.21749656f, 0.02342800f, 0.13847879f, 0.00340771f, -0.11664672f, -0.06261538f, -0.08340082f, 0.18802850f, 
    0.12144326f, 0.03357846f, 0.05312822f, 0.05561506f, 0.06762636f, -0.05632318f, 0.01931593f, -0.06786085f, 
    -0.14278977f, 0.04529410f, 0.00441743f, -0.02353489f, 0.01028190f, 0.12434206f, -0.01875281f, 0.21798033f, 
    -0.10828092f, 0.13551860f, 0.01467795f, 0.14937498f, 0.32321718f, -0.17752588f, 0.21951044f, -0.03169693f, 
    0.04366861f, -0.12539931f, -0.05960779f, -0.13473409f, -0.07352666f, 0.10707739f, 0.11564013f, 0.09710310f, 
    0.03812660f, 0.11838831f, -0.17657061f, -0.09586520f, 0.11182295f, 0.17805620f, 0.08524649f, -0.05273341f, 
    0.01032845f, 0.22476907f, 0.18910351f, 0.04402262f, 0.16524263f, 0.03262066f, 0.00089368f, -0.09910503f, 
    -0.02397128f, 0.06111448f, -0.03525226f, -0.16055705f, 0.14000188f, -0.05010530f, -0.00310205f, -0.01103107f, 
    -0.22306196f, -0.33848265f, -0.14409931f, -0.24408358f, -0.09297535f, 0.07924154f, -0.13067515f, 0.17717968f, 
    0.05145220f, 0.03081304f, -0.05085755f, 0.03561366f, -0.06523319f, 0.17868412f, 0.00398024f, -0.29540589f, 
    0.15321660f, 0.08723635f, -0.02010180f, 0.03933958f, -0.02407375f, 0.02527023f, -0.00880847f, -0.01518372f, 
    0.06109134f, 0.22973609f, -0.07690731f, 0.09344555f, -0.05939066f, -0.06051724f, -0.22348055f, -0.17124097f, 
    -0.15770788f, -0.09338470f, -0.14298025f, -0.33337605f, -0.09509489f, 0.05330086f, 0.10635390f, 0.13517593f, 
    -0.01873608f, -0.06384812f, -0.03554361f, -0.07713041f, -0.00993952f, 0.00796719f, -0.01062509f, -0.13000971f, 
    0.33611161f, 0.26001871f, 0.02548498f, 0.01645240f, 0.05936365f, 0.04530682f, -0.14388166f, -0.03282513f, 
    0.00562215f, -0.00470306f, -0.12561888f, -0.24995038f, -0.23659754f, 0.13000797f, 0.26675215f, -0.02971680f, 
    0.01463754f, 0.04642968f, -0.15166950f, -0.04517539f, 0.16388825f, 0.02501006f, -0.14574595f, -0.09778276f, 
    -0.11039504f, -0.11006438f, -0.05212832f, -0.40570784f, -0.02738411f, -0.04767117f, -0.14868684f, -0.00665971f, 
    -0.17395121f, 0.07182001f, 0.10296686f, 0.00656307f, 0.14531878f, -0.06247555f, -0.02878555f, -0.01120788f, 
    -0.07477299f, 0.06925632f, 0.04383339f, -0.08761293f, 0.04947304f, 0.22901912f, 0.12733242f, 0.23671536f, 
    -0.02846801f, -0.09187891f, 0.01461188f, 0.08667596f, 0.13369530f, -0.07748087f, -0.03267116f, -0.02179407f, 
    -0.10489042f, -0.05944794f, -0.03277752f, -0.13669698f, -0.02743255f, 0.08518428f, -0.06235704f, 0.23307136f, 
    -0.03512358f, -0.02726203f, 0.07958711f, -0.06885402f, -0.00990784f, 0.06315874f, -0.06035514f, 0.07570339f, 
    -0.20619923f, 0.07976376f, -0.07985478f, -0.04887860f, 0.11265436f, 0.09036548f, 0.04244977f, 0.13422918f, 
    0.10352857f, 0.02068982f, 0.13992383f, -0.08641692f, 0.36427405f, 0.30901626f, 0.00092724f, 0.08485965f, 
    0.03465173f, 0.07151554f, -0.15162188f, 0.04014617f, -0.00117973f, -0.19655861f, 0.12274875f, -0.00868628f, 
    0.19452222f, 0.09520628f, -0.01684633f, -0.05723391f, 0.00646938f, 0.00556072f, 0.15724768f, -0.01465013f, 
    0.15123533f, 0.04831525f, 0.05693949f, 0.19204403f, -0.13571376f, 0.20349233f, -0.24621689f, -0.02910169f, 
    -0.15475316f, -0.05376204f, -0.13230167f, 0.01382700f, -0.16035238f, 0.09028698f, 0.03163514f, 0.08953022f, 
    -0.18868721f, -0.13521244f, -0.11042649f, -0.17562225f, -0.16800648f, 0.08595522f, 0.16197173f, -0.00712370f, 
    0.24823666f, -0.01813697f, -0.03039493f, 0.03546459f, -0.04014393f, 0.13242514f, 0.12970459f, -0.00788905f, 
    0.06933934f, -0.24712773f, -0.08754855f, -0.28048426f, 0.09878520f, 0.10152343f, 0.03371800f, -0.14873435f, 
    -0.16511552f, -0.09848715f, 0.10082297f, 0.18256995f, 0.07166407f, 0.16342527f, 0.06846918f, 0.20438509f, 
    -0.18209116f, -0.11153869f, 0.08429698f, 0.04643714f, 0.22495334f, -0.19951464f, -0.06625287f, 0.16863874f, 
    -0.07640399f, -0.05960520f, -0.11711697f, 0.10089103f, 0.18174833f, -0.09102987f, -0.01665200f, -0.07285687f, 
    -0.07098361f, 0.00263102f, -0.04785639f, -0.01475120f, -0.04403141f, -0.03922134f, -0.00272547f, -0.05225518f, 
    -0.04708065f, -0.02661045f, -0.09567857f, -0.07401720f, 0.03364181f, 0.01377518f, 0.02836925f, -0.08147877f, 
    0.00446119f, -0.09090175f, -0.06533317f, 0.03886607f, -0.08586328f, -0.06913869f, -0.07554748f, -0.06530114f, 
    -0.05898926f, -0.02911622f, 0.00356300f, -0.02605230f, -0.06969237f, 0.03999745f, 0.01395994f, -0.09139620f, 
    -0.03459326f, -0.05185057f, 0.02869229f, -0.00459365f, 0.02961787f, -0.01835957f, -0.00895526f, -0.02484483f, 
    -0.04585890f, -0.03606754f, 0.00478255f, -0.01554903f, -0.06674128f, -0.00887152f, -0.07702976f, -0.06784949f, 
    0.03739672f, -0.02478154f, -0.00048555f, -0.06099449f, -0.07079873f, -0.08435606f, -0.07345863f, 0.02285436f, 
    0.03232584f, 0.06731101f, -0.07322551f, 0.02303774f, -0.04312352f, 0.04058512f, -0.00792219f, 0.06140670f, 
    0.05846501f, 0.02998741f, 0.01194084f, -0.01741800f, -0.04564437f, -0.03043907f, -0.00777411f, -0.05694648f, 
    -0.04614253f, -0.09006330f, -0.05192047f, -0.06109096f, -0.00432145f, 0.02348868f, -0.02338182f, 0.00695262f, 
    0.05420472f, 0.04110952f, 0.01707001f, -0.02074535f, 0.03507913f, 0.01422625f, -0.06257490f, 0.03332245f, 
    -0.05138096f, -0.00568158f, 0.04595286f, 0.03406995f, -0.06679888f, 0.02385378f, 0.01269670f, -0.05484908f, 
    0.00410799f, -0.02044395f, 0.02402514f, -0.07103348f, 0.03407018f, 0.00664377f, -0.04487614f, 0.01345917f, 
    -0.02156699f, 0.00892074f, -0.03844999f, 0.01044640f, -0.02818635f, 0.02436120f, -0.01404026f, -0.08592732f, 
    -0.05083100f, -0.01755067f, 0.00726726f, 0.02808104f, -0.01336832f, -0.02873640f, 0.00416534f, -0.02944974f, 
    0.01678844f, -0.03500882f, -0.10299331f, -0.08423015f, 0.02261026f, 0.01263152f, 0.05202239f, -0.03794693f, 
    -0.03782592f, 0.04567142f, 0.04783636f, 0.02031606f, -0.02873548f, -0.04111355f, -0.06723257f, -0.00940738f, 
    -0.03037459f, -0.03099114f, -0.03937850f, -0.06268283f, 0.03205317f, -0.00937388f, -0.01872635f, 0.00503974f, 
    -0.01605556f, -0.02137446f, 0.03647711f, 0.01333209f, -0.03860289f, 0.00470928f, -0.00207184f, -0.01493510f, 
    -0.08072082f, -0.02045543f, -0.01383155f, 0.00571662f, 0.01201902f, -0.00621527f, 0.03275227f, 0.00706433f, 
    -0.10401129f, 0.04260890f, -0.06733906f, -0.03600168f, -0.00851998f, -0.06582554f, -0.04134683f, 0.02726392f, 
    -0.05533197f, -0.08564437f, -0.06800050f, 0.04362767f, -0.01148902f, -0.05532564f, -0.08169841f, -0.04212162f, 
    0.01851021f, -0.06363734f, -0.05893388f, 0.03021693f, -0.06637985f, 0.04015656f, 0.02134060f, 0.06426273f, 
    -0.02771646f, -0.00753863f, -0.00697747f, -0.02958845f, -0.01671753f, 0.04017032f, -0.03445349f, -0.04925954f, 
    -0.05549660f, -0.00848156f, -0.01083544f, -0.01903699f, -0.01499167f, 0.02189621f, -0.00608808f, -0.02217172f, 
    0.00948952f, -0.04362638f, -0.05546053f, 0.01016981f, -0.03001466f, 0.03213250f, 0.01228788f, -0.02102681f, 
    -0.07763167f, -0.02601424f, 0.05365358f, -0.05919232f, -0.01109208f, -0.01083676f, -0.06751323f, -0.06924365f, 
    0.05923326f, 0.00573168f, 0.03203195f, -0.08009285f, -0.01572808f, -0.06795579f, -0.03796522f, -0.04238849f, 
    -0.04304517f, 0.06157806f, -0.00411384f, 0.06521900f, -0.07655609f, -0.07077932f, -0.01252891f, -0.03218329f, 
    -0.04603723f, 0.00687497f, -0.00625297f, -0.06219148f, -0.05394547f, -0.05527639f, 0.00498164f, -0.04233042f, 
    -0.05740270f, 0.03456338f, 0.03621075f, -0.02508454f, -0.01615961f, -0.01972741f, -0.07292208f, 0.00320255f, 
    0.01470918f, -0.03723977f, 0.01883706f, -0.03870772f, 0.02195400f, -0.02746456f, 0.06252646f, 0.04820464f, 
    -0.01893567f, 0.00671585f, -0.06022285f, 0.03835657f, 0.00420992f, 0.02345519f, -0.05006217f, 0.00745137f, 
    -0.07757217f, 0.01709531f, -0.05132962f, -0.06340691f, 0.01069531f, -0.02791727f, -0.00406747f, 0.03264457f, 
    -0.06075202f, -0.05599653f, 0.02232551f, 0.06518269f, -0.04631281f, 0.02605153f, -0.01849474f, 0.05072559f, 
    -0.07511458f, -0.07927641f, -0.03273184f, 0.03539758f, 0.01091083f, -0.04426825f, 0.04829842f, 0.05636855f, 
    -0.04075092f, 0.00166345f, 0.05626720f, 0.06337210f, 0.00616366f, -0.04414251f, -0.02548507f, -0.03415342f, 
    -0.02900271f, 0.01945296f, 0.05442265f, -0.00177191f, -0.07036255f, -0.00066832f, -0.03253537f, -0.06812638f, 
    -0.04962964f, 0.03192344f, -0.07250773f, -0.01057222f, 0.04961232f, 0.05882820f, 0.04058151f, 0.00212130f, 
    -0.01072932f, -0.02817448f, 0.03840464f, 0.02433938f, 0.00889068f, -0.01887611f, -0.03682070f, 0.02128863f, 
    -0.01068880f, -0.07678045f, 0.01119168f, 0.00791135f, -0.02052961f, 0.05497155f, 0.01465286f, 0.02103462f, 
    0.03481705f, -0.01756335f, -0.04739975f, 0.03644294f, 0.01101144f, -0.04466388f, -0.01891361f, 0.02918828f, 
    -0.06938975f, -0.06263284f, -0.00807198f, -0.07867011f, -0.00177688f, 0.04671438f, -0.05552046f, -0.07529727f, 
    -0.02875577f, -0.00909385f, -0.00776327f, 0.06233755f, -0.05622318f, 0.00094274f, 0.04213445f, -0.05062373f, 
    -0.01176995f, 0.03504686f, -0.02122273f, 0.01240253f, 0.02174623f, 0.00769813f, -0.05572659f, -0.04281261f, 
    0.06415153f, -0.04155460f, -0.01428537f, 0.05631687f, 0.01689792f, 0.03581326f, 0.01536037f, -0.03370687f, 
    -0.01947275f, 0.01882089f, 0.00845218f, -0.00649278f, 0.06250801f, -0.05021697f, -0.06433249f, -0.03849008f, 
    0.06307435f, -0.03037707f, 0.03808459f, 0.05140886f, 0.05360233f, -0.01460885f, 0.01741977f, 0.00684656f, 
    0.00227947f, -0.02761832f, 0.00876359f, -0.05903095f, 0.00237789f, -0.02558987f, 0.00686309f, -0.04971803f, 
    -0.00920174f, -0.02163460f, 0.04049641f, 0.05950953f, 0.03649716f, -0.04392501f, 0.00610159f, -0.02243734f, 
    0.04529536f, 0.05919706f, -0.04606363f, -0.02801212f, 0.01736896f, -0.08602414f, -0.03022695f, -0.08001759f, 
    -0.00821126f, 0.00243092f, -0.00213979f, -0.02709163f, -0.04215724f, -0.00516663f, -0.00636356f, -0.04752636f, 
    0.02196221f, 0.01083053f, -0.01748143f, -0.01103157f, -0.00263838f, -0.02366638f, 0.05116710f, -0.04935498f, 
    0.00463022f, -0.07992709f, -0.04160912f, -0.07743347f, -0.04033980f, -0.07550567f, -0.08440176f, 0.03779929f, 
    0.01041549f, -0.03553046f, -0.02250451f, 0.05712774f, -0.07303543f, -0.04848606f, 0.02103465f, 0.01452509f, 
    0.04469992f, -0.00062252f, 0.01028763f, -0.05082171f, -0.00904867f, 0.01903785f, 0.04165316f, 0.04908745f, 
    0.05028968f, 0.04842823f, 0.01043703f, -0.06691716f, -0.04057207f, 0.02578386f, -0.05890125f, -0.00098622f, 
    -0.01427700f, -0.05149271f, 0.00518352f, -0.01866327f, 0.00946817f, 0.01001361f, -0.01116080f, -0.02515123f, 
    -0.05741291f, -0.00044053f, 0.02057203f, -0.02987269f, -0.02987099f, 0.01598418f, -0.01195016f, -0.03974690f, 
    -0.01261516f, -0.07941668f, -0.00888269f, 0.03182539f, -0.01507916f, -0.06877232f, -0.08490086f, -0.00670574f, 
    0.02067340f, -0.05962357f, -0.00177412f, -0.00879608f, 0.03245331f, 0.01435815f, -0.02548021f, -0.02444716f, 
    -0.04538699f, -0.00806808f, -0.05911723f, -0.01035843f, -0.04466949f, 0.02636724f, -0.06325751f, -0.06027571f, 
    -0.04349057f, -0.06574482f, -0.06162627f, -0.01116144f, -0.05950501f, -0.00713233f, -0.04724012f, 0.03903021f, 
    -0.00700922f, 0.03417821f, 0.04372596f, 0.04944407f, -0.01116801f, -0.04950114f, 0.01299440f, -0.01166868f, 
    -0.02522495f, -0.01026031f, -0.01347869f, -0.05872547f, 0.05757889f, -0.06393065f, 0.05079849f, 0.01655278f, 
    -0.05153847f, -0.01985559f, -0.01114560f, 0.02102318f, -0.04831272f, 0.01730087f, -0.07916871f, 0.00283591f, 
    -0.07880334f, 0.05668396f, 0.03042416f, -0.07072314f, -0.07198937f, -0.06888928f, 0.02789411f, 0.04305597f, 
    -0.00478376f, 0.04128172f, 0.03486224f, -0.04361694f, -0.01821624f, -0.02686779f, -0.07137989f, -0.02082347f, 
    -0.01919919f, 0.02501666f, 0.00461012f, 0.03459052f, -0.07215738f, -0.01562285f, -0.00938328f, 0.05443433f, 
    -0.07921381f, 0.04337656f, 0.01434948f, -0.06292593f, -0.05706364f, 0.03594215f, -0.02344629f, -0.07468306f, 
    -0.06321148f, -0.03396749f, -0.02838242f, -0.01223906f, -0.07001593f, -0.07357986f, -0.02670815f, 0.01834773f, 
    0.00619330f, -0.02029371f, 0.00347984f, -0.05516249f, -0.01070849f, 0.03088781f, -0.01019456f, -0.04259251f, 
    -0.27948463f, 0.02750361f, -0.18722409f, -0.15442537f, 0.01310557f, -0.14281836f, -0.20214036f, 0.00713368f, 
    -0.18165864f, 0.00356808f, 0.01663937f, 0.09480749f, -0.08259777f, -0.34264797f, -0.01726014f, 0.10011153f, 
    -0.04553416f, -0.20264506f, 0.11614507f, 0.01929628f, -0.05551003f, 0.07867237f, 0.11200912f, 0.02344653f, 
    0.41699630f, 0.37133706f, 0.24335021f, 0.20078599f, 0.10140695f, 0.03099988f, 0.02218046f, 0.12714885f, 
    -0.01647124f, 0.15472147f, -0.00670272f, 0.13450029f, -0.28726763f, -0.15369643f, -0.01230563f, 0.12654655f, 
    0.25241071f, 0.26374316f, -0.15939035f, 0.00695099f, 0.17732862f, 0.23080112f, 0.14434184f, 0.05498470f, 
    0.32460105f, -0.06786588f, 0.04040401f, 0.12533164f, -0.02377728f, 0.07382064f, -0.02127539f, 0.00878936f, 
    -0.02774651f, 0.05556629f, 0.09027897f, 0.08438049f, -0.15671694f, -0.24765994f, -0.09486221f, 0.02261786f, 
    0.10497695f, 0.10267741f, 0.16098058f, 0.09791403f, -0.16378921f, 0.02755014f, -0.15454590f, -0.09195836f, 
    0.06462840f, 0.04459773f, 0.15281808f, -0.12203149f, 0.08000040f, 0.02074625f, 0.03408413f, 0.04954241f, 
    0.16639248f, 0.07437459f, -0.01989715f, 0.10778604f, -0.25929907f, -0.41987225f, -0.50090003f, 0.10418285f, 
    0.03054390f, 0.05522377f, -0.08895680f, 0.04680298f, 0.13368252f, -0.02122510f, -0.06292754f, 0.08193786f, 
    0.06111042f, 0.19576755f, 0.14914189f, -0.10053955f, 0.01516263f, -0.18400311f, 0.17381360f, 0.10496731f, 
    -0.03935651f, 0.01326808f, 0.02986726f, 0.04362949f, 0.10437774f, -0.18404864f, 0.21080838f, -0.06435415f, 
    -0.03462803f, 0.08122289f, 0.13330321f, -0.20177458f, -0.04188001f, -0.16939987f, 0.12525846f, 0.29255837f, 
    0.22297372f, 0.18200743f, 0.04802677f, -0.05339700f, -0.02638031f, 0.05568816f, 0.18028437f, 0.07273358f, 
    -0.07984968f, -0.02095206f, -0.15104023f, -0.15935044f, -0.12574771f, -0.20663531f, -0.01277587f, 0.12246533f, 
    0.07860828f, 0.01639529f, 0.08826701f, 0.02659339f, 0.10447690f, 0.00791143f, -0.16199638f, -0.03054520f, 
    -0.47850388f, -0.32264879f, -0.26047605f, 0.01269550f, 0.13711248f, -0.14071615f, 0.11480805f, 0.00139865f, 
    0.01390858f, 0.00420589f, -0.03010121f, -0.02441346f, 0.05970275f, -0.59433377f, -0.10961757f, -0.26394269f, 
    0.15588425f, -0.25225222f, 0.01206161f, -0.06261902f, -0.02969295f, 0.09115372f, 0.14706878f, -0.16971238f, 
    0.04866294f, 0.30054572f, 0.06133249f, 0.26055238f, 0.03778685f, -0.03322167f, -0.00070508f, 0.12831022f, 
    0.11763525f, -0.16099077f, -0.08767561f, -0.01991061f, 0.13692373f, -0.13547669f, -0.13462828f, -0.13162881f, 
    0.07076716f, -0.05568482f, 0.02113001f, 0.14256100f, 0.00059910f, 0.08718616f, -0.04664410f, 0.11659735f, 
    0.10781367f, 0.11376380f, -0.03024798f, -0.00215269f, -0.12152274f, -0.13833742f, -0.08225475f, -0.08662771f, 
    0.15791960f, 0.00132621f, -0.03299430f, -0.08491416f, -0.26914564f, 0.17710252f, -0.01688899f, -0.02933403f, 
    -0.08410030f, 0.00925877f, 0.03280459f, 0.05215048f, 0.06140218f, -0.07703139f, 0.06137333f, -0.00830934f, 
    -0.19173676f, -0.02256824f, -0.07834896f, -0.04606826f, -0.16223824f, -0.01551365f, 0.00096001f, 0.09347576f, 
    -0.00415629f, -0.11608998f, -0.02750215f, -0.28064126f, 0.41934878f, 0.10057954f, 0.16734368f, -0.12605177f, 
    -0.01025016f, 0.03339180f, 0.10524978f, 0.16347983f, 0.00522625f, -0.01836381f, -0.15410405f, 0.02952107f, 
    0.17221208f, 0.05274946f, 0.11494782f, -0.19463953f, 0.05495380f, 0.05407970f, 0.02230193f, 0.22306997f, 
    -0.02229936f, 0.06229769f, -0.11741892f, -0.10172401f, -0.07905892f, 0.04782138f, 0.00375427f, -0.00904797f, 
    -0.19105598f, -0.00146321f, 0.07490705f, -0.04326211f, -0.00327021f, 0.06543323f, 0.13965406f, 0.01485584f, 
    -0.24731001f, -0.09768125f, -0.22537048f, 0.02525747f, 0.08306884f, -0.01960913f, -0.04671041f, -0.00841543f, 
    0.05808903f, -0.03786357f, -0.00093166f, 0.07365138f, 0.32853186f, 0.20021366f, 0.45439214f, -0.06791916f, 
    -0.15852244f, 0.17376859f, -0.02888326f, -0.05205587f, -0.14778429f, 0.07557714f, 0.10515434f, 0.00535049f, 
    -0.48217243f, -0.05818247f, -0.15753500f, 0.24272282f, 0.11057388f, 0.28382024f, -0.13199811f, 0.04172774f, 
    0.01162037f, 0.10895856f, 0.22891660f, 0.05351115f, -0.10924505f, 0.48876026f, 0.00577738f, -0.02377234f, 
    -0.01973323f, 0.29387686f, -0.05031237f, 0.04299489f, 0.03297373f, 0.23124489f, -0.01783766f, 0.05345621f, 
    -0.05645300f, -0.00931000f, -0.00343748f, 0.01365071f, -0.10370868f, 0.03688785f, 0.11381000f, -0.03257303f, 
    0.18768227f, -0.02695415f, 0.07514904f, 0.02150413f, -0.41305754f, 0.30458793f, -0.26168787f, -0.01775122f, 
    -0.26475275f, -0.13258451f, -0.05451723f, 0.01043785f, -0.00306970f, 0.17252970f, -0.04258874f, 0.06109678f, 
    -0.10314644f, 0.30918381f, -0.00458346f, -0.12203816f, -0.12388732f, -0.01171557f, -0.09252102f, 0.04521952f, 
    0.08040657f, 0.18424065f, 0.10872584f, 0.11762137f, -0.27247125f, 0.32774356f, 0.06191267f, -0.13952458f, 
    -0.10054468f, -0.03800568f, -0.17007981f, -0.06539131f, -0.01223041f, 0.11031388f, -0.03005905f, -0.00650393f, 
    -0.14158510f, -0.26099068f, 0.12446602f, -0.02814155f, -0.06759592f, -0.00329647f, 0.06912981f, -0.05451571f, 
    -0.16306297f, -0.13741393f, 0.10937385f, 0.02674126f, 0.12877454f, -0.13030079f, -0.02436567f, 0.09019033f, 
    0.12716010f, -0.21177991f, -0.00463205f, -0.01691513f, 0.19655612f, -0.00133291f, -0.01355342f, -0.05464104f, 
    -0.02922749f, 0.04135074f, 0.11116125f, -0.16902006f, -0.09855998f, -0.07159717f, -0.08140954f, -0.06025965f, 
    0.17393069f, 0.19660735f, 0.06047307f, -0.04034154f, 0.02735347f, 0.02906289f, -0.10258616f, -0.20722371f, 
    0.00936909f, 0.09085286f, 0.03426990f, -0.05706996f, 0.15985687f, -0.02136251f, 0.07891846f, 0.11234260f, 
    -0.20755012f, -0.11506196f, 0.02913081f, 0.14230159f, -0.11595859f, -0.09663209f, 0.10390332f, 0.03511607f, 
    -0.01031639f, -0.00978486f, -0.10242149f, -0.05756328f, 0.67489552f, 0.01071946f, 0.03238280f, 0.02051832f, 
    0.12068316f, -0.01126610f, 0.21752164f, 0.10316880f, -0.05832849f, 0.02387671f, 0.12083355f, 0.03956240f, 
    0.15085779f, 0.04798125f, 0.04330699f, 0.22230867f, 0.03099871f, 0.00475395f, -0.00792482f, 0.07566797f, 
    0.01901205f, 0.04911675f, -0.09763703f, 0.09949639f, -0.20823121f, -0.02639678f, -0.00122308f, -0.14032067f, 
    -0.00657905f, -0.10736940f, -0.17311433f, -0.01940976f, -0.02270866f, 0.08456194f, 0.10782085f, 0.01774191f, 
    -0.34484431f, -0.19890408f, 0.11985871f, 0.14487383f, 0.11425975f, 0.08074364f, 0.00814848f, -0.07174514f, 
    -0.05490551f, -0.14815599f, 0.06279717f, -0.00080817f, 0.42875057f, 0.17267954f, 0.01655211f, -0.04148824f, 
    -0.00907362f, -0.01944839f, 0.03714981f, 0.05566737f, 0.14432524f, 0.01802349f, 0.09212768f, 0.01160642f, 
    -0.14095493f, -0.23442625f, -0.13014971f, 0.28624591f, 0.17638069f, 0.09219949f, 0.07660664f, 0.01747359f, 
    0.12715894f, 0.02996362f, 0.04673367f, -0.01876696f, -0.20987754f, 0.08085105f, 0.06773446f, 0.11488579f, 
    -0.00527021f, 0.13173991f, 0.12583297f, -0.06846707f, 0.16933015f, -0.03313161f, 0.06816916f, 0.08205124f, 
    -0.25775173f, 0.04419430f, 0.17819121f, 0.09492873f, -0.00874729f, -0.02744016f, 0.09808369f, -0.05189847f, 
    0.04747690f, 0.15048572f, -0.10439816f, 0.06465248f, -0.20796286f, -0.13014865f, -0.11710388f, -0.07960988f, 
    -0.10081600f, -0.08425206f, -0.01449377f, 0.03582920f, 0.02071033f, 0.15560123f, 0.08861521f, 0.13075896f, 
    0.10055064f, 0.33759522f, -0.14652246f, -0.10015809f, -0.05807802f, -0.11740868f, -0.12858938f, 0.05194747f, 
    0.07555214f, 0.09810600f, 0.16999270f, 0.10575972f, -0.21118636f, 0.07132009f, -0.16905485f, -0.07235446f, 
    -0.13817921f, 0.08700066f, 0.03283487f, -0.05847814f, 0.05883439f, -0.01299259f, -0.03335643f, 0.02105471f, 
    -0.17287703f, -0.24165919f, -0.00739490f, 0.07375547f, 0.09849126f, -0.06858192f, 0.09091592f, -0.05409626f, 
    -0.14480503f, 0.08690830f, -0.07895920f, -0.13828389f, -0.04318288f, 0.29380959f, -0.08298951f, -0.01871134f, 
    -0.02612484f, -0.05460416f, 0.08438194f, -0.03385118f, 0.03671075f, -0.05307681f, 0.11453474f, 0.04326520f, 
    0.01856403f, 0.02950427f, -0.03805603f, -0.07838832f, 0.02253740f, -0.05655730f, -0.02436194f, -0.04282521f, 
    -0.07481212f, -0.02153095f, -0.05120085f, -0.07656377f, -0.06257033f, -0.04133634f, 0.01249716f, -0.06257852f, 
    -0.07654769f, -0.03614875f, 0.02388131f, 0.04123272f, 0.00028489f, -0.06573361f, -0.02415616f, -0.08203784f, 
    -0.04929259f, -0.06431343f, -0.07307893f, -0.09746106f, -0.08181298f, 0.01689183f, -0.10748103f, -0.10977634f, 
    -0.02377451f, -0.09176686f, -0.01464777f, -0.00320270f, 0.01342973f, -0.11180680f, -0.09631789f, -0.00238573f, 
    -0.06776635f, 0.01942550f, 0.02896966f, -0.05774926f, -0.02956323f, -0.08458117f, 0.01328162f, -0.10716072f, 
    -0.07733817f, -0.05947024f, -0.09493627f, -0.08405025f, -0.05326864f, 0.02585916f, -0.04388232f, 0.03455831f, 
    -0.06870526f, -0.07127687f, -0.06732677f, 0.02343430f, 0.07457988f, -0.00781841f, 0.07451339f, 0.03639075f, 
    -0.07476529f, -0.07803698f, -0.02376001f, 0.02334192f, 0.03117984f, -0.01053890f, -0.05959445f, 0.08877599f, 
    0.01874161f, 0.01634793f, -0.04133663f, 0.00236578f, -0.07104669f, 0.00552329f, -0.00775321f, -0.08302756f, 
    -0.08936334f, 0.02985253f, 0.01777558f, 0.04521947f, -0.06154386f, -0.07647562f, -0.00614698f, 0.02008572f, 
    -0.03653880f, 0.00629979f, 0.06853588f, 0.01835892f, -0.05321931f, -0.07694179f, -0.03373742f, 0.01511806f, 
    -0.03411995f, -0.02947688f, 0.02211994f, -0.03118792f, 0.01655772f, 0.01565427f, -0.03269913f, -0.00262823f, 
    -0.02089032f, -0.00561213f, 0.04267161f, -0.00299061f, -0.06495447f, -0.10910226f, -0.11851134f, -0.08865068f, 
    -0.03653914f, 0.01558424f, -0.03819672f, -0.00587331f, -0.03975284f, -0.09293879f, -0.05184850f, 0.00315272f, 
    0.00196986f, -0.00011999f, -0.03016287f, -0.00529673f, -0.02462912f, -0.08266580f, 0.03511471f, 0.01329346f, 
    -0.03068209f, -0.04139462f, 0.01838565f, -0.09771563f, 0.02402393f, 0.03427964f, -0.08939546f, -0.00371374f, 
    0.05398241f, -0.06367739f, 0.01263287f, 0.00761145f, 0.02064197f, 0.05898320f, -0.02235482f, 0.00373255f, 
    -0.04384637f, -0.07720853f, 0.03327205f, -0.06230026f, -0.09644341f, -0.07699081f, -0.04066278f, 0.01051836f, 
    -0.04482651f, -0.06833669f, -0.05514824f, 0.02697038f, 0.04757475f, 0.06103327f, 0.00556344f, -0.01493824f, 
    0.01111551f, 0.04083674f, 0.00270130f, -0.04767130f, -0.04121807f, -0.06371617f, 0.07600019f, 0.03591833f, 
    -0.10213377f, -0.00997972f, -0.05658394f, -0.05681174f, -0.11880269f, -0.05675064f, -0.02557426f, -0.07895262f, 
    -0.05609311f, 0.00018503f, -0.04217501f, 0.00048386f, -0.07401612f, -0.05685246f, -0.10545847f, 0.00184908f, 
    -0.02418796f, -0.01153775f, -0.10272881f, -0.09042536f, 0.02519426f, 0.04116103f, 0.00289892f, -0.09955516f, 
    -0.02966462f, -0.06826157f, 0.12415118f, 0.02151427f, 0.06056105f, 0.00227464f, 0.10748230f, 0.00639074f, 
    -0.02410488f, -0.13427027f, -0.10387913f, -0.18731907f, 0.09385000f, -0.20326453f, 0.12544423f, -0.21469088f, 
    0.03704291f, -0.00898720f, 0.02146912f, -0.00490141f, 0.14195046f, -0.03400463f, 0.05217519f, 0.02072550f, 
    -0.00056480f, -0.14075360f, 0.01478328f, -0.00386156f, 0.14617240f, 0.02238537f, -0.01483823f, 0.10952855f, 
    0.02215642f, -0.14703907f, -0.03791974f, 0.06773894f, 0.09991331f, 0.20422690f, -0.09949616f, 0.02661176f, 
    -0.07723936f, -0.20088309f, 0.02189640f, -0.18182051f, -0.10106730f, -0.07491159f, -0.03071756f, -0.09208104f, 
    -0.08080317f, -0.20045078f, -0.07488109f, 0.04573821f, 0.12038000f, -0.11900064f, -0.00628888f, -0.06899422f, 
    -0.04916257f, -0.06669492f, 0.11572368f, -0.06498921f, -0.03955343f, -0.20784236f, -0.10742677f, -0.08272908f, 
    0.04046931f, 0.07065623f, -0.07953270f, -0.15347268f, 0.24718194f, 0.12229604f, 0.08143484f, 0.18147615f, 
    0.12766372f, 0.02107311f, 0.05931835f, 0.11123599f, -0.10752229f, 0.19695970f, 0.14830595f, 0.10695185f, 
    -0.00600279f, -0.05915258f, 0.02129484f, -0.03143938f, -0.25929335f, 0.21618983f, -0.24989901f, 0.19721086f, 
    0.19928806f, -0.15862405f, 0.00618388f, -0.33156979f, 0.05228564f, 0.07095571f, 0.03295930f, 0.07360211f, 
    0.52070510f, -0.09307203f, 0.26703140f, -0.15912482f, 0.08914673f, 0.01825928f, 0.07433746f, -0.08345269f, 
    0.07945064f, 0.08461846f, 0.09399379f, 0.05673329f, 0.24134678f, -0.21352145f, -0.29828462f, 0.15590258f, 
    0.15484308f, -0.07090241f, -0.17088866f, 0.13370040f, 0.10258181f, 0.14022359f, -0.15206224f, -0.25284499f, 
    0.01703208f, 0.23457967f, -0.00025468f, 0.12532160f, 0.01474140f, 0.10552093f, -0.04330852f, 0.06246272f, 
    0.16096102f, 0.13781367f, 0.12706177f, 0.21836939f, 0.44955197f, -0.43350607f, 0.31748894f, -0.20174788f, 
    -0.00340283f, -0.22105232f, -0.03060981f, -0.25802076f, 0.00673097f, 0.04908747f, 0.25769579f, 0.10583153f, 
    0.28147754f, -0.10011821f, -0.06360235f, -0.20314687f, -0.01867760f, 0.16864504f, 0.11032165f, -0.01712087f, 
    -0.09887580f, 0.04514448f, 0.22444333f, 0.19474605f, 0.14962187f, -0.28195933f, 0.23166603f, -0.12758084f, 
    -0.18080731f, 0.04226185f, -0.16175552f, -0.10580977f, 0.16896322f, 0.05592105f, -0.08036926f, -0.01167213f, 
    -0.09401341f, -0.01111423f, 0.09005586f, -0.10830142f, 0.04780918f, 0.20897572f, -0.12340888f, 0.09966497f, 
    0.15853073f, 0.17871062f, 0.00017265f, 0.18217593f, -0.21704270f, -0.01992074f, 0.35397732f, -0.22634111f, 
    0.05808996f, -0.01200177f, -0.03615867f, 0.15817899f, 0.07823312f, 0.04791830f, 0.07437873f, 0.01088686f, 
    -0.07825925f, -0.06740559f, -0.02803880f, -0.04168458f, -0.09208168f, 0.00655581f, -0.04654865f, -0.02365780f, 
    -0.06378753f, -0.02779819f, -0.08460280f, -0.07257309f, -0.07774933f, -0.08691528f, -0.00350212f, 0.02544162f, 
    -0.03265260f, -0.09478160f, -0.08108378f, -0.05798151f, -0.10036741f, -0.03888123f, -0.05705064f, -0.06609603f, 
    0.01802346f, -0.07633427f, 0.04116184f, -0.00254813f, 0.01070053f, 0.03355886f, -0.09723398f, -0.02369117f, 
    -0.09550290f, 0.03848164f, -0.06700564f, -0.02599758f, -0.06064207f, -0.05937939f, -0.02889386f, 0.00105686f, 
    -0.06352369f, -0.06602744f, 0.01236553f, 0.00916357f, -0.10049799f, 0.02037374f, -0.03352650f, 0.01360801f, 
    -0.00533795f, -0.07514729f, -0.08624355f, 0.00120940f, -0.08903917f, -0.05043843f, -0.07857183f, 0.00074448f, 
    0.02326674f, -0.05386481f, -0.07735711f, 0.03221947f, -0.01377963f, -0.09163912f, -0.04379220f, 0.00489732f, 
    -0.01582479f, 0.04045531f, -0.09724419f, 0.00315315f, -0.06321386f, 0.03704668f, -0.04369988f, -0.08866785f, 
    -0.00834291f, 0.01330626f, -0.06984918f, -0.03684217f, -0.06275716f, -0.04831512f, -0.05569797f, -0.06907725f, 
    0.02557012f, -0.08307812f, -0.03245394f, 0.03411039f, -0.00483572f, -0.08980219f, 0.01619644f, -0.08443977f, 
    0.01436737f, -0.08434557f, -0.05349744f, -0.05192040f, -0.05348273f, 0.00864089f, -0.05434070f, -0.06853190f, 
    -0.05981218f, 0.01054631f, -0.08330848f, -0.04755099f, 0.00474849f, 0.01451804f, -0.06820477f, -0.08204366f, 
    -0.06050677f, -0.09573776f, -0.05387705f, -0.00912968f, 0.06691141f, -0.06297940f, -0.00715278f, 0.03133776f, 
    -0.05676041f, 0.02378314f, 0.02405386f, 0.01850358f, -0.07814782f, -0.03420731f, 0.00276129f, 0.02438796f, 
    -0.03392695f, -0.02219651f, -0.07967228f, -0.07618347f, -0.09742150f, -0.10068892f, -0.07183681f, -0.01653923f, 
    -0.04975313f, -0.03613922f, -0.05615348f, -0.06212791f, 0.01009414f, -0.04750309f, -0.02480278f, 0.00050957f, 
    -0.09610774f, -0.03051776f, -0.05331394f, 0.00127168f, 0.04155635f, -0.05640665f, -0.09648921f, 0.01447371f, 
    -0.03703375f, -0.06761261f, -0.04832289f, 0.04072629f, 0.00890598f, -0.05424332f, -0.07658711f, -0.04084943f, 
    -0.06969348f, 0.01593746f, 0.00081728f, 0.03038043f, -0.00295857f, -0.02830227f, 0.03274468f, -0.08111770f, 
    -0.03897827f, -0.05012420f, -0.03497519f, -0.09570557f, -0.02563888f, -0.03360308f, -0.04625011f, 0.00658704f, 
    -0.01873934f, -0.04597084f, -0.08683163f, 0.03409039f, -0.00757199f, -0.00452540f, -0.07006543f, -0.06831650f, 
    -0.09630563f, 0.01026048f, 0.03791306f, -0.00194779f, -0.00636725f, -0.01269901f, -0.04873606f, -0.01413297f, 
    0.00443100f, -0.03264681f, -0.00552247f, 0.03094349f, 0.02382540f, -0.01634848f, -0.06768992f, -0.04097773f, 
    0.03290632f, -0.02952527f, 0.04503246f, -0.03937552f, -0.05428644f, -0.05720974f, 0.04947277f, 0.00377958f, 
    -0.07461081f, 0.05259543f, -0.06144653f, 0.00428650f, 0.01656228f, -0.04988381f, -0.00819133f, -0.03826782f, 
    0.03924773f, 0.02902457f, 0.06198050f, -0.00587241f, 0.04049962f, 0.03428321f, -0.05647714f, 0.04283855f, 
    -0.00649222f, 0.03890320f, 0.04304004f, 0.01595992f, 0.00484995f, 0.04983413f, 0.02960509f, 0.05911477f, 
    -0.03053751f, 0.00453439f, 0.03244679f, 0.05029757f, 0.02474804f, 0.05367710f, -0.02843585f, -0.04248131f, 
    0.01620395f, -0.03783981f, -0.05674001f, -0.01370131f, 0.00004848f, 0.02096498f, -0.00700161f, 0.00928015f, 
    -0.00041823f, -0.07639717f, 0.01450122f, -0.04301659f, -0.00129270f, -0.07757495f, 0.01520938f, -0.01791103f, 
    -0.03684182f, 0.04572790f, -0.03069534f, -0.06464680f, 0.03400536f, -0.01192599f, -0.04076741f, 0.02090310f, 
    -0.02867815f, -0.05347066f, -0.02176660f, -0.03679238f, 0.04546744f, 0.05273068f, 0.02704236f, -0.07901225f, 
    0.02617930f, -0.03614749f, -0.01757015f, 0.01807976f, 0.05774946f, 0.04742493f, -0.01319034f, -0.05328576f, 
    -0.04261505f, -0.04252305f, 0.04985551f, 0.04545303f, 0.03203762f, -0.02415373f, -0.00717664f, -0.06678902f, 
    -0.04635851f, 0.01012078f, -0.01537257f, -0.07824726f, -0.01512374f, -0.05083780f, -0.00583032f, -0.06389701f, 
    0.03547488f, -0.08109929f, 0.02390201f, -0.01535168f, -0.01872241f, 0.04721669f, -0.00305432f, -0.00332576f, 
    -0.00647617f, 0.05891452f, 0.03363134f, 0.00183595f, 0.04367047f, -0.02646471f, -0.05657740f, -0.00103004f, 
    -0.06283358f, 0.04535912f, 0.01506039f, 0.03793140f, -0.05150375f, -0.00084462f, -0.07247353f, -0.01791487f, 
    -0.04265621f, -0.04412404f, 0.01819870f, -0.07388202f, -0.00580714f, -0.01191692f, -0.07255443f, 0.01156486f, 
    -0.05794343f, 0.00963456f, -0.00829242f, -0.03702220f, 0.00648481f, 0.06302711f, 0.03910474f, -0.06792223f, 
    -0.05618469f, -0.03405807f, 0.03670847f, 0.00454070f, -0.03577952f, -0.05277839f, 0.01875035f, 0.03286744f, 
    -0.06372224f, 0.02643345f, -0.02775891f, 0.04565142f, -0.06177678f, 0.05130285f, 0.01119726f, -0.06753023f, 
    -0.05965368f, -0.01460846f, -0.07277991f, -0.02556493f, -0.06397400f, 0.03017711f, 0.02111450f, 0.04898823f, 
    -0.06923196f, -0.06829563f, 0.06414925f, -0.04681174f, -0.01890783f, -0.01674535f, 0.02326900f, -0.02593417f, 
    -0.05325494f, -0.05931049f, 0.04448526f, -0.04762902f, 0.00015590f, -0.02689128f, -0.01474244f, -0.05300517f, 
    -0.07028590f, -0.07720761f, -0.04431965f, -0.01429035f, -0.03379080f, 0.03510931f, -0.02004616f, 0.03738921f, 
    -0.04174801f, -0.06246645f, -0.05452014f, -0.01168394f, -0.05938104f, 0.05359113f, 0.03017111f, -0.04072256f, 
    0.08667962f, -0.00059663f, 0.16114463f, 0.07796556f, 0.07514478f, 0.08313839f, 0.00619636f, 0.01665251f, 
    0.18809012f, 0.02431574f, 0.05081806f, 0.10268408f, 0.01699574f, 0.16333908f, 0.06750727f, 0.16626124f, 
    0.03409797f, -0.18596885f, -0.02253764f, 0.14654243f, -0.05784198f, -0.11244178f, 0.09622106f, 0.06281650f, 
    0.00712022f, 0.08503183f, -0.18718921f, -0.27332827f, -0.03947335f, 0.03299338f, -0.01271413f, 0.03300171f, 
    -0.10405611f, -0.09524295f, 0.09986941f, 0.08684868f, -0.38198856f, -0.06300899f, -0.01584976f, 0.10392040f, 
    -0.04468869f, -0.11045729f, -0.12374982f, 0.15605412f, 0.11523514f, -0.03747370f, 0.03529012f, -0.02763446f, 
    -0.62208045f, -0.20409268f, -0.33842817f, -0.25980097f, 0.02782398f, 0.04176471f, 0.09581624f, 0.08718252f, 
    0.14494514f, -0.00612252f, -0.00916244f, -0.10266636f, 0.11595868f, 0.01913334f, -0.01277560f, 0.14754130f, 
    -0.12146432f, 0.06809425f, -0.10913709f, -0.02946344f, -0.00456886f, -0.00377117f, -0.09303161f, 0.01080281f, 
    0.27368879f, 0.19286034f, 0.09196804f, -0.10003462f, 0.14891201f, 0.03016998f, -0.06502879f, 0.03238583f, 
    0.01603626f, -0.08861937f, 0.11961989f, 0.01656846f, 0.13981287f, 0.11342973f, 0.39842859f, 0.24024616f, 
    0.09334905f, -0.08571825f, -0.10989092f, 0.03391238f, -0.05316357f, 0.05119332f, -0.07042741f, 0.12867582f, 
    0.30986387f, 0.14530566f, 0.08287112f, -0.11302317f, 0.06707498f, -0.06239510f, -0.03585970f, 0.03785482f, 
    0.10405239f, 0.04373763f, 0.03633007f, 0.02852770f, 0.70043051f, -0.17631131f, 0.31319511f, 0.11907426f, 
    0.02618961f, 0.00618176f, 0.02439274f, 0.19566581f, 0.04064230f, -0.00262713f, -0.09481025f, -0.05627608f, 
    -0.05999199f, -0.03770730f, -0.10179756f, -0.16432300f, 0.12775217f, 0.01329430f, -0.15747081f, 0.02122901f, 
    0.17736681f, -0.19647205f, 0.13741128f, -0.02550868f, -0.24333544f, -0.32962763f, -0.07455879f, 0.06659831f, 
    -0.08344575f, 0.02971007f, 0.01042567f, -0.02287955f, 0.00373773f, 0.02851600f, 0.11683553f, 0.01983681f, 
    0.25447613f, -0.08395544f, 0.22144151f, -0.03022745f, 0.16799629f, -0.16134001f, 0.07334496f, -0.19410326f, 
    -0.02151788f, -0.12478150f, 0.01913647f, 0.03186681f, 0.00554976f, 0.11406226f, -0.08451086f, 0.14090796f, 
    -0.01642644f, -0.17003086f, 0.03436282f, 0.03963024f, -0.00260147f, -0.00889823f, -0.22682391f, 0.18640755f, 
    0.00149976f, 0.07344516f, -0.05792613f, -0.33283731f, 0.18080007f, 0.05026343f, 0.05552389f, -0.14672129f, 
    -0.02939658f, -0.06434342f, -0.00217213f, -0.12437814f, 0.07005198f, 0.28618115f, -0.11862294f, 0.14694318f, 
    0.00077743f, -0.06049828f, 0.18144622f, 0.03109787f, 0.06712661f, -0.00818289f, 0.05930449f, -0.05525975f, 
    -0.52370089f, -0.13104971f, -0.18332334f, -0.10776302f, -0.02407159f, 0.03465429f, -0.03215124f, -0.04491493f, 
    -0.27178666f, -0.13316196f, 0.09916759f, -0.11445692f, -0.26035920f, 0.04401480f, -0.06372750f, -0.19827968f, 
    -0.02366709f, 0.01479225f, 0.04342731f, 0.01017714f, -0.10165904f, 0.20650281f, 0.02354013f, -0.27936906f, 
    0.51858932f, 0.10580356f, 0.05681499f, 0.09863783f, 0.20799562f, -0.01094444f, -0.01215319f, 0.10524447f, 
    0.00371937f, -0.04739159f, -0.06031413f, -0.03863076f, -0.24420656f, -0.00536131f, 0.23621678f, 0.05494118f, 
    0.05651369f, 0.08268218f, 0.02042305f, -0.03674582f, -0.00241549f, 0.05458454f, -0.07610980f, 0.09131595f, 
    -0.06537458f, -0.33407149f, -0.11957733f, -0.26155823f, -0.00528956f, 0.02547193f, -0.00396288f, 0.14904311f, 
    -0.00977421f, 0.02319187f, -0.11872949f, -0.32596251f, 0.10048911f, -0.01206063f, -0.03484539f, 0.03827853f, 
    -0.04696751f, 0.01605240f, 0.03026797f, -0.00118152f, -0.03258334f, 0.20673314f, 0.16571294f, 0.21369600f, 
    0.18000567f, 0.08315197f, 0.07806764f, 0.17525573f, -0.18059349f, -0.20842989f, 0.16422981f, 0.07074329f, 
    -0.10254110f, -0.02209549f, -0.02177894f, 0.12429005f, -0.21583146f, -0.07118139f, 0.13408951f, -0.01486418f, 
    0.04673981f, -0.06249803f, 0.00883189f, -0.07324876f, 0.11121392f, 0.08448318f, 0.11414986f, 0.13352478f, 
    -0.11154941f, 0.34890446f, -0.10506260f, -0.00280671f, -0.11308449f, 0.00885746f, 0.02399919f, 0.24559061f, 
    -0.11396735f, -0.04761612f, 0.01301046f, 0.00895544f, 0.25475734f, 0.16602416f, 0.07191904f, 0.15676618f, 
    -0.10458641f, 0.00721116f, 0.09910446f, -0.04799392f, -0.11283875f, -0.05887752f, 0.01169650f, -0.13693736f, 
    0.29578075f, 0.21460478f, 0.17463867f, 0.23635863f, 0.12005425f, 0.10206793f, 0.37586832f, 0.11706945f, 
    -0.14954142f, 0.12445547f, 0.16750023f, 0.19692071f, -0.25502953f, 0.05326276f, -0.19618899f, -0.18387166f, 
    -0.02940365f, 0.08717767f, 0.00111581f, 0.09722078f, 0.02356771f, 0.08558317f, 0.12580581f, -0.10098109f, 
    -0.28180212f, 0.09965336f, 0.02121218f, -0.18818519f, -0.16952410f, 0.05557340f, 0.08309806f, 0.05730878f, 
    0.11902405f, 0.10971245f, 0.03586107f, 0.13344505f, -0.21119837f, 0.00248531f, -0.12507868f, -0.13331543f, 
    -0.05054662f, 0.01036392f, -0.03066712f, -0.05543358f, 0.06761227f, 0.19970457f, 0.09329961f, -0.14395158f, 
    0.26975983f, 0.26367071f, 0.30260623f, 0.28640407f, -0.10730170f, 0.05272124f, 0.01235353f, 0.23620848f, 
    -0.10356560f, -0.01842553f, 0.07180134f, 0.11082825f, -0.37801191f, 0.00692287f, -0.29961538f, -0.10270934f, 
    -0.15335447f, -0.03665131f, -0.05764217f, -0.08819595f, 0.12664859f, 0.22920741f, 0.25244889f, 0.18283698f, 
    -0.06027772f, 0.10769141f, 0.18633883f, 0.01272054f, -0.09047834f, -0.08962408f, -0.22337660f, -0.07808056f, 
    0.04128799f, 0.16113082f, 0.12589933f, 0.24504714f, -0.03436942f, -0.19014606f, 0.11291098f, 0.16996209f, 
    0.03033913f, 0.08577578f, 0.02196795f, -0.32747424f, 0.03024197f, 0.11342952f, 0.00616917f, 0.26438215f, 
    0.26824614f, 0.08848588f, 0.11594342f, 0.22893676f, 0.19323905f, 0.00029994f, -0.01622338f, -0.05999950f, 
    0.09706432f, 0.14725141f, 0.07926399f, 0.15417325f, 0.33605823f, -0.15800308f, -0.03048066f, 0.04774893f, 
    0.11530672f, 0.11074683f, 0.07010105f, -0.09994046f, 0.05499968f, 0.07572226f, 0.02932501f, 0.02906338f, 
    0.61049950f, 0.07202674f, 0.16215345f, 0.26327443f, -0.06239425f, 0.00268381f, -0.02553677f, -0.24537586f, 
    -0.06551155f, 0.02266184f, 0.02714109f, 0.13222584f, -0.12787804f, -0.02794235f, -0.04699195f, -0.00853181f, 
    0.03648576f, -0.09380977f, -0.04233188f, 0.08148141f, -0.38730767f, -0.27779955f, -0.07845632f, -0.51292437f, 
    -0.01442439f, -0.08125848f, -0.06562064f, 0.04761232f, -0.05862680f, -0.05813273f, 0.04524023f, 0.02198656f, 
    0.26915300f, 0.21661213f, 0.03670759f, 0.00142073f, -0.01428614f, -0.06240905f, -0.06554592f, -0.04022942f, 
    0.02029941f, 0.09204746f, -0.13214527f, 0.18312468f, 0.09806242f, -0.05342959f, 0.00396150f, -0.06741220f, 
    0.00450336f, 0.26606074f, 0.13021655f, 0.07100632f, 0.08200715f, 0.03939555f, 0.04793109f, -0.03870148f, 
    -0.07986438f, 0.02190398f, -0.14697105f, 0.02805551f, -0.49123552f, -0.16334575f, 0.18063030f, -0.09829243f, 
    -0.08925063f, 0.19517411f, 0.18395241f, -0.18604565f, -0.09922649f, 0.10862531f, -0.00944458f, 0.12157454f, 
    0.13354655f, 0.08126107f, -0.01035366f, 0.22354905f, -0.03593525f, 0.07566168f, 0.03975330f, -0.00072388f, 
    -0.11480311f, 0.00995352f, -0.14887640f, -0.09774049f, 0.13570507f, 0.08746632f, 0.11345094f, 0.02814118f, 
    0.02278000f, 0.03114011f, -0.09045666f, -0.18100683f, 0.04226639f, -0.03267475f, -0.00284195f, 0.03326227f, 
    -0.30025744f, 0.14873680f, -0.09739536f, 0.24181975f, -0.00229148f, -0.09703790f, -0.03535282f, 0.21567258f, 
    -0.14297622f, -0.03261279f, -0.10075021f, -0.08764936f, 0.13640007f, 0.12994440f, 0.08997497f, -0.03621742f, 
    0.04189376f, -0.01424791f, 0.07716583f, -0.05794973f, -0.02286294f, 0.13926606f, 0.15198770f, -0.10027757f, 
    0.16855375f, 0.09918492f, 0.00921737f, 0.35770330f, 0.00937607f, 0.14548007f, -0.04248952f, 0.07666368f, 
    -0.04606619f, -0.11090387f, -0.01626672f, 0.10310680f, 0.19777118f, 0.31471279f, -0.14374033f, -0.22273834f, 
    0.13228634f, -0.19534726f, -0.10250667f, 0.01827810f, -0.03193932f, -0.01390049f, -0.06573029f, 0.00223186f, 
    0.04573040f, 0.05539440f, -0.07839935f, 0.02391854f, -0.01547578f, -0.02590182f, -0.04972219f, 0.04020565f, 
    0.03391655f, -0.05888023f, 0.04855927f, -0.00946878f, 0.03804771f, -0.06310044f, 0.05530603f, -0.02544178f, 
    0.04634854f, -0.07264269f, -0.04844890f, -0.04130958f, 0.04124691f, 0.01924282f, -0.05825866f, -0.01045332f, 
    -0.05674814f, -0.07180385f, -0.07680417f, -0.01125905f, -0.04051910f, -0.01393932f, -0.08013310f, -0.06851149f, 
    0.03026854f, 0.04986685f, -0.07425582f, -0.06856277f, -0.00145982f, -0.05219704f, 0.00805528f, -0.04437818f, 
    -0.01530257f, -0.07899226f, -0.07010336f, -0.00026481f, 0.04859234f, 0.05049311f, 0.01758813f, -0.08030757f, 
    0.04642724f, -0.02244664f, -0.01557179f, -0.03189392f, -0.04236525f, -0.07702965f, -0.07269780f, 0.03306480f, 
    -0.01666409f, -0.06412334f, 0.04021685f, 0.01042015f, -0.04028999f, 0.00689425f, 0.04378848f, 0.02889782f, 
    0.00215930f, -0.05999462f, 0.00315666f, 0.01884308f, -0.02087448f, -0.04621420f, -0.03670886f, 0.01735230f, 
    -0.04345490f, 0.03085850f, 0.05378475f, 0.00972376f, 0.03081205f, 0.01908514f, -0.03995828f, -0.03955689f, 
    0.05696056f, 0.06088378f, 0.00923637f, 0.00919596f, -0.02276664f, -0.03332482f, -0.02587260f, -0.01857703f, 
    -0.05908598f, -0.04063589f, 0.04647000f, 0.01956178f, -0.02211417f, -0.06099810f, -0.05693227f, -0.03912023f, 
    -0.06656348f, 0.02233420f, -0.01774922f, -0.07979520f, 0.00620141f, -0.06689111f, -0.00851566f, 0.06269927f, 
    0.04482400f, 0.05388076f, 0.04129148f, 0.05116325f, 0.00951184f, -0.02574836f, -0.06452750f, 0.00771400f, 
    -0.03126686f, -0.04814689f, 0.01827105f, -0.00749152f, 0.03765595f, 0.03498007f, -0.06191126f, -0.06545465f, 
    -0.01792456f, -0.05098078f, -0.03814149f, 0.03103682f, -0.00030104f, 0.02270605f, 0.04020644f, -0.00644630f, 
    -0.04210473f, -0.04430247f, 0.04136312f, 0.04026673f, 0.02666188f, -0.04486454f, 0.00104960f, -0.04622598f, 
    0.02294267f, -0.05333130f, 0.01498254f, -0.03460356f, -0.00816319f, -0.04630711f, 0.00701792f, -0.01825449f, 
    0.02213750f, 0.01472022f, -0.04592973f, -0.04815376f, -0.06594977f, 0.00641615f, -0.00617273f, 0.04018106f, 
    -0.02324916f, 0.00334226f, -0.00611366f, -0.05114825f, 0.02026319f, -0.02814849f, -0.07961165f, 0.00658374f, 
    -0.03498431f, -0.05160449f, 0.01688027f, 0.03406122f, -0.04853949f, -0.02988308f, 0.05618361f, 0.03983746f, 
    -0.06024004f, 0.00058381f, 0.02835758f, 0.01464063f, -0.01660419f, 0.00055134f, -0.07176498f, -0.02623107f, 
    0.05435307f, -0.03741867f, 0.05995024f, -0.06215950f, -0.02211668f, -0.06641776f, 0.05903044f, -0.01387748f, 
    0.03977366f, 0.02058863f, 0.04215191f, -0.06048134f, 0.06480017f, -0.02256399f, -0.02058533f, -0.03385142f, 
    0.10969189f, 0.16874963f, 0.00505088f, 0.01523503f, -0.01335953f, -0.04969831f, -0.13282444f, -0.08031572f, 
    -0.06091162f, -0.02286963f, 0.00568928f, 0.05660369f, -0.13459283f, 0.09172715f, -0.02350168f, 0.07483041f, 
    -0.10643501f, -0.11058919f, -0.06370698f, -0.00978612f, 0.14864194f, -0.02871437f, -0.04507227f, -0.03562650f, 
    0.14915092f, 0.27428010f, 0.00324837f, -0.11255393f, -0.01993686f, 0.09392349f, -0.09650089f, 0.07461724f, 
    0.08581900f, -0.13774246f, -0.12231079f, -0.20340337f, -0.35717127f, 0.17879312f, 0.22100547f, -0.00003284f, 
    0.02822457f, 0.06106801f, -0.27335942f, 0.02313551f, 0.19287075f, 0.11119554f, -0.05549107f, 0.03933411f, 
    -0.26465970f, 0.09457741f, -0.04710230f, -0.40735081f, -0.07037988f, 0.07592858f, 0.04082151f, -0.00916003f, 
    -0.00802688f, 0.03464817f, 0.10373292f, -0.11208786f, 0.05216239f, -0.09440614f, -0.02732508f, 0.00467507f, 
    -0.14288878f, 0.07792942f, 0.06845536f, -0.05332990f, 0.08090104f, 0.06187495f, 0.04068962f, 0.08160223f, 
    0.06326240f, 0.01366565f, -0.00209298f, -0.13970712f, 0.01522494f, -0.19646536f, -0.03512089f, -0.02062007f, 
    -0.02249397f, -0.11937840f, -0.05580491f, 0.09601167f, 0.06907205f, 0.18764070f, 0.14002295f, 0.19350031f, 
    0.04085330f, 0.01213860f, 0.03644852f, -0.02271410f, -0.03843113f, 0.09858744f, -0.01115114f, 0.18313000f, 
    -0.19400176f, 0.09605168f, -0.10426238f, -0.10971198f, -0.01582783f, -0.00965360f, 0.15136881f, 0.29243267f, 
    0.07715753f, -0.03635198f, 0.25650764f, 0.08276478f, 0.50120127f, 0.26701757f, 0.11234182f, 0.03125868f, 
    0.02034909f, 0.13036223f, -0.01733276f, 0.15832923f, -0.07153149f, -0.11407315f, 0.10928310f, 0.05606270f, 
    0.12983660f, 0.04933089f, -0.03707916f, -0.08217377f, -0.00949273f, 0.12697208f, 0.20179787f, 0.06860194f, 
    0.13897637f, -0.00740903f, 0.18863133f, 0.06778143f, -0.44020903f, 0.14254321f, -0.23807961f, 0.00569426f, 
    -0.08054473f, -0.18492621f, -0.04792854f, -0.09191465f, 0.00704900f, 0.08019941f, 0.02589297f, -0.02561453f, 
    -0.19528258f, -0.12315483f, -0.10211428f, -0.04566743f, -0.00558602f, 0.02978312f, 0.11353144f, -0.01939915f, 
    0.26207036f, 0.10464860f, 0.06647807f, -0.13208574f, -0.00556017f, -0.05571220f, 0.04032030f, -0.18753991f, 
    -0.09204255f, -0.06283199f, -0.12229338f, -0.13230579f, 0.14987072f, 0.11937094f, -0.05997619f, -0.14529748f, 
    -0.16746238f, 0.01830990f, 0.12872988f, 0.05289831f, -0.13703904f, 0.05727511f, 0.06553857f, 0.14463027f, 
    -0.02522119f, -0.04593994f, 0.15973647f, -0.01906663f, 0.26409051f, -0.43139371f, -0.20487687f, 0.18341018f, 
    -0.20023859f, -0.12181408f, -0.08241828f, 0.03359325f, 0.29937491f, -0.05506347f, 0.07645927f, -0.02725179f, 
    0.00467334f, 0.08535879f, 0.15866148f, -0.04116955f, -0.01835530f, -0.05095167f, -0.23775300f, -0.13143349f, 
    -0.03545565f, -0.14380288f, -0.11501671f, -0.17995083f, -0.10166455f, 0.12487841f, -0.05321869f, 0.15914999f, 
    -0.11887997f, -0.07755238f, -0.05735741f, -0.26320320f, 0.07404608f, -0.09720919f, 0.01772255f, 0.16801964f, 
    0.28007478f, 0.30704579f, -0.03947360f, 0.09223502f, 0.06113407f, 0.06866771f, -0.10549621f, 0.00858108f, 
    0.04101022f, -0.10979343f, 0.01838472f, -0.04511354f, 0.23786610f, -0.06582156f, -0.01944701f, 0.27122143f, 
    0.07244778f, 0.05173265f, -0.05011471f, -0.06767695f, 0.04083106f, 0.00781274f, -0.01907153f, 0.18979339f, 
    0.15746219f, -0.11668506f, -0.20279196f, 0.00376444f, 0.05706023f, 0.00870655f, 0.00531905f, 0.05455058f, 
    0.03308835f, -0.06420495f, -0.13853294f, 0.06299043f, -0.00249727f, 0.03828673f, -0.05279643f, -0.14456123f, 
    -0.09956065f, 0.36347830f, -0.12386126f, 0.04425907f, -0.03072863f, 0.11146372f, 0.05749145f, -0.18331197f, 
    -0.00121418f, 0.05583665f, 0.13724822f, -0.04020616f, -0.06436668f, -0.00319777f, -0.19777422f, 0.11121006f, 
    -0.07580297f, 0.01343450f, -0.07455621f, 0.00765719f, 0.43651131f, -0.16479421f, 0.28398699f, 0.25638998f, 
    0.17073415f, -0.00992696f, -0.13723014f, 0.03429557f, -0.07330914f, 0.06051598f, -0.18222642f, 0.12590870f, 
    0.04653612f, 0.40843028f, 0.07705262f, 0.15623719f, 0.09504709f, 0.02914008f, 0.10134736f, 0.06699901f, 
    0.06202931f, 0.22549157f, -0.08700798f, -0.08794195f, 0.18128334f, -0.01739050f, 0.46881494f, 0.41788974f, 
    -0.01947178f, 0.17284176f, 0.07712561f, 0.09323831f, -0.00441900f, -0.03485130f, 0.10237143f, 0.05255503f, 
    0.17188144f, 0.19932650f, 0.01967153f, 0.00900119f, 0.02375328f, 0.18838204f, 0.07735812f, 0.04544312f, 
    -0.01183206f, -0.01855921f, -0.00529778f, -0.13793391f, -0.28167003f, -0.28272748f, -0.13943601f, 0.03647272f, 
    -0.11480540f, 0.09818377f, 0.11947753f, -0.05068986f, 0.02573216f, 0.09817268f, 0.13801016f, 0.01947057f, 
    0.15565453f, 0.34177348f, 0.13049328f, 0.29776490f, 0.07676991f, -0.05023095f, -0.04025549f, 0.02551532f, 
    0.11076415f, -0.09659301f, 0.15553857f, 0.09099439f, -0.03712289f, 0.27569655f, -0.21260163f, -0.07859477f, 
    0.09127833f, -0.08586217f, 0.14369315f, -0.07815064f, 0.09917253f, 0.10403208f, -0.13576019f, -0.12188705f, 
    0.15304311f, 0.02212476f, 0.13833544f, 0.22225966f, 0.02321494f, 0.02004745f, -0.09805965f, 0.04214294f, 
    -0.03804703f, -0.03030905f, -0.03493277f, -0.06577858f, -0.27329555f, 0.79951465f, -0.44325653f, -0.05307658f, 
    -0.07027170f, -0.11025690f, 0.13873363f, 0.16682026f, 0.10190608f, -0.13721785f, -0.14653419f, -0.11717965f, 
    0.33311096f, 0.01126470f, 0.09327549f, 0.11908866f, -0.06289076f, -0.04350498f, 0.17178482f, -0.09133788f, 
    0.20139889f, 0.09103648f, 0.11599945f, 0.00768214f, 0.24637721f, 0.04955920f, 0.06512376f, -0.06991369f, 
    0.00342541f, -0.05612319f, -0.04403855f, 0.02889612f, 0.15338583f, 0.01097792f, 0.05662607f, -0.01341720f, 
    -0.50672334f, -0.15377334f, -0.00778643f, -0.16804402f, -0.09066342f, 0.03088965f, 0.14717031f, 0.06777964f, 
    -0.06387876f, -0.09271511f, 0.06917082f, -0.04704201f, 0.37611496f, 0.03015541f, -0.06490510f, -0.04801378f, 
    -0.18743870f, 0.00924914f, 0.14475526f, 0.11047507f, 0.01210759f, -0.02536153f, 0.13344063f, 0.07471459f, 
    -0.10560816f, 0.11386843f, 0.04202713f, -0.06343870f, 0.03822799f, -0.10960815f, 0.00654454f, -0.05620388f, 
    0.10623588f, 0.02358666f, 0.20312287f, 0.11166117f, -0.09490148f, 0.00982350f, -0.01637415f, -0.05008844f, 
    0.04719052f, 0.03438135f, 0.02415376f, 0.12335632f, 0.19723062f, 0.06618834f, -0.05444697f, 0.05141913f, 
    -0.13842714f, -0.01479228f, 0.12638105f, 0.06537630f, 0.04508002f, 0.05602913f, 0.01445369f, -0.02874018f, 
    -0.01383938f, -0.11485768f, 0.01640913f, -0.05365618f, 0.31639448f, 0.14268044f, 0.05632551f, -0.10694100f, 
    0.04658570f, 0.07171001f, -0.02450828f, -0.00957734f, 0.00674257f, -0.01110646f, 0.09164135f, -0.14528890f, 
    -0.02172628f, -0.30478612f, 0.10269418f, 0.25416970f, 0.07986652f, 0.04117991f, 0.07299434f, -0.13899943f, 
    0.17922273f, -0.01471721f, 0.17882250f, -0.04243962f, 0.06632546f, 0.16711485f, -0.09281814f, 0.17647839f, 
    0.11464877f, 0.06503423f, 0.06602834f, 0.22228700f, 0.09400696f, 0.09130646f, -0.13365431f, 0.05568222f, 
    -0.22817613f, -0.11648802f, 0.14323081f, -0.11869451f, -0.01650389f, -0.14400128f, -0.04157322f, -0.10553880f, 
    -0.00949242f, -0.00293918f, 0.00687210f, 0.05883320f, 0.14840314f, 0.03206217f, -0.00967002f, -0.04102438f, 
    0.00148878f, -0.13064477f, -0.02937433f, -0.07638439f, 0.03595641f, 0.00871702f, -0.02544055f, 0.16369626f, 
    0.25826171f, 0.02397431f, 0.11090807f, -0.11908013f, 0.17914920f, 0.05416382f, -0.05970626f, 0.02373379f, 
    0.08111199f, 0.10164510f, 0.06905214f, 0.04439726f, 0.03684431f, 0.05346451f, 0.07240025f, -0.02403011f, 
    -0.04879288f, 0.12038189f, 0.03917169f, -0.06283018f, 0.19912721f, -0.05596992f, -0.08589524f, 0.17403597f, 
    -0.15821771f, -0.29148698f, -0.09841178f, -0.33735427f, 0.00930028f, -0.11892300f, -0.00081650f, -0.14488652f, 
    -0.07253030f, 0.00375113f, -0.02707145f, -0.08768798f, -0.00189468f, -0.10504594f, 0.24090539f, 0.13053958f, 
    0.07808900f, 0.00588901f, 0.09809736f, -0.14718050f, 0.04483610f, -0.01951915f, -0.03505341f, 0.04938338f, 
    -0.24613585f, -0.25262690f, -0.21469593f, 0.01735630f, 0.12518770f, 0.11820409f, -0.08203387f, -0.03568310f, 
    -0.07253751f, -0.10750166f, -0.03958974f, 0.06263642f, -0.03342409f, -0.34937024f, 0.11439604f, 0.03091068f, 
    0.10002171f, -0.13406025f, -0.16731770f, -0.07194576f, -0.01928664f, -0.01272817f, -0.07899735f, 0.15910931f, 
    0.10540047f, 0.13722421f, 0.03665861f, 0.05360242f, 0.11260224f, 0.09867024f, -0.06273033f, 0.02767751f, 
    0.07603178f, -0.00517542f, -0.03063947f, 0.07308567f, -0.24008675f, 0.09499683f, -0.11923659f, 0.04036838f, 
    -0.02820564f, -0.00315645f, -0.14035241f, -0.13057077f, 0.26368168f, 0.09402953f, 0.00012632f, 0.13060500f, 
    0.06095981f, -0.00567908f, 0.04210126f, -0.11918578f, -0.13237967f, -0.07144007f, 0.05655075f, -0.05312177f, 
    -0.05616624f, -0.01624785f, 0.09070089f, 0.15097962f, -0.06907098f, -0.19973236f, -0.18011284f, -0.03607873f, 
    -0.06145328f, 0.08755175f, 0.05838653f, -0.03582338f, -0.04948667f, 0.00364703f, -0.07696356f, 0.06348978f, 
    0.30250213f, 0.23575036f, 0.13138324f, 0.03854505f, 0.04274235f, 0.20128830f, 0.09376273f, 0.12137569f, 
    0.01781740f, 0.11031861f, 0.05868916f, -0.01355351f, -0.53304774f, -0.21212855f, -0.15342280f, 0.11614639f, 
    0.06001340f, -0.01531259f, -0.05408281f, -0.15127830f, 0.03374290f, 0.13932669f, -0.14146377f, 0.08863132f, 
    0.36787677f, 0.20212510f, 0.24323484f, -0.25081053f, -0.03161040f, 0.07664464f, -0.00428378f, 0.03336499f, 
    0.01599719f, 0.12036859f, 0.13796601f, -0.05547146f, 0.26778567f, 0.07851762f, -0.08458228f, 0.09753653f, 
    0.03494320f, 0.02152460f, 0.06748567f, 0.20748308f, -0.04915611f, 0.12371006f, 0.00142671f, 0.05567510f, 
    0.26211974f, 0.25535083f, 0.01946832f, 0.02561580f, 0.11103389f, 0.08096983f, 0.03632687f, 0.12866457f, 
    0.05137221f, -0.08459003f, 0.01901679f, -0.07427429f, 0.05235640f, -0.16508555f, 0.10269870f, 0.19338332f, 
    -0.17029598f, -0.22512935f, -0.16527915f, -0.14909700f, 0.01915311f, -0.12070356f, 0.03026679f, -0.07935885f, 
    -0.12432089f, -0.34471053f, 0.21208686f, 0.03227673f, 0.06782339f, 0.08176158f, -0.06531416f, 0.08400398f, 
    0.05168021f, -0.05249957f, 0.12568259f, 0.08220472f, 0.14715688f, -0.12063365f, 0.12896651f, -0.13184690f, 
    -0.00276744f, -0.28254554f, -0.29852480f, -0.24187379f, -0.01607163f, 0.17341068f, -0.04250173f, -0.08615825f, 
    0.19700682f, 0.41303447f, 0.11732585f, 0.15837340f, 0.06740705f, 0.17200464f, 0.10601266f, 0.18082452f, 
    0.01885363f, -0.20112072f, 0.05187020f, 0.09696338f, -0.12178313f, -0.19495910f, 0.19894288f, -0.15690993f, 
    0.04726480f, -0.07466820f, -0.11333603f, 0.06817558f, 0.14061989f, 0.01312558f, -0.01327097f, -0.00560448f, 
    -0.09573168f, -0.01884614f, -0.23783602f, 0.05419479f, 0.03137844f, -0.07134407f, -0.15900148f, -0.14730825f, 
    0.05634779f, -0.02919721f, -0.06469454f, 0.04389983f, -0.14634411f, -0.28795508f, 0.07170580f, 0.12568283f, 
    -0.10376607f, 0.07250296f, -0.16764930f, -0.25409630f, 0.01671358f, 0.01939602f, -0.00301193f, 0.11246945f, 
    0.05688555f, 0.38930699f, 0.09948364f, 0.05425874f, 0.02388344f, -0.08952933f, -0.04696814f, -0.00638399f, 
    0.10018174f, 0.00707202f, 0.05030852f, 0.06670485f, -0.21679015f, 0.24316128f, -0.07813797f, -0.00871504f, 
    -0.01201288f, -0.01358747f, 0.00618734f, -0.12171331f, 0.26550251f, 0.13618994f, -0.07883813f, 0.11993158f, 
    0.12218527f, 0.30636355f, 0.11918786f, -0.20308477f, -0.03295722f, -0.10643536f, -0.05939096f, -0.15876418f, 
    0.02304750f, 0.07275923f, 0.16593775f, 0.07010697f, 0.09941820f, -0.02292063f, 0.03757519f, -0.01234556f, 
    0.04752199f, 0.05785543f, 0.00240859f, 0.02600928f, 0.00016086f, 0.02631701f, -0.05467537f, -0.12618844f, 
    -0.07821196f, 0.15515083f, 0.14998588f, -0.16478606f, -0.10520070f, -0.06828901f, -0.07610285f, 0.00922979f, 
    0.01700018f, 0.08381106f, 0.00617354f, -0.04386782f, -0.25986552f, -0.15714486f, -0.01073967f, 0.15724920f, 
    0.01845820f, -0.04524239f, 0.05609805f, -0.14616741f, 0.00436686f, -0.05311806f, -0.11279818f, 0.10448467f, 
    0.11916061f, 0.22950271f, 0.11212049f, -0.27401820f, 0.05506470f, -0.00377717f, 0.14305912f, 0.09447722f, 
    -0.07166944f, 0.02152110f, 0.05629788f, 0.01699327f, 0.00753940f, 0.16568753f, -0.02320987f, 0.21967237f, 
    0.03879901f, 0.08407710f, -0.08897644f, 0.30348000f, -0.03098501f, -0.08007806f, 0.12494461f, 0.07093315f, 
    0.37663573f, 0.22040908f, 0.10107131f, -0.21988861f, 0.03231733f, 0.14358832f, 0.05273218f, 0.00203451f, 
    -0.02629179f, -0.17576753f, -0.00514160f, -0.14860158f, -0.04656556f, 0.16607569f, 0.15671772f, 0.31741813f, 
    0.06937220f, -0.05174310f, -0.04464284f, -0.10481755f, 0.08786444f, 0.01301257f, 0.06121619f, 0.02669607f, 
    -0.14745569f, -0.06592567f, -0.00900761f, 0.33520111f, 0.20559435f, 0.19151442f, 0.01570445f, 0.19867855f, 
    0.03680550f, -0.09785183f, 0.17923240f, 0.15520194f, -0.12437274f, -0.10852737f, 0.01952747f, -0.12676720f, 
    0.07156271f, -0.12712356f, -0.07347433f, -0.11344151f, 0.06493429f, 0.20948273f, 0.08367011f, -0.11016619f, 
    0.06545608f, 0.32960686f, 0.11098257f, 0.25826308f, -0.25949419f, 0.07708966f, 0.10132729f, 0.11023863f, 
    0.09931253f, -0.16793001f, 0.01547960f, 0.02570747f, -0.20750695f, -0.21400279f, -0.06771655f, 0.08287114f, 
    -0.09228197f, 0.10190450f, -0.12318568f, 0.07722623f, 0.05836106f, -0.00150110f, -0.08119200f, -0.00483983f, 
    -0.02291584f, 0.08395689f, 0.00195753f, -0.12107617f, -0.08998253f, -0.13956197f, 0.07081024f, 0.00035953f, 
    0.24338335f, 0.29510939f, 0.09921746f, 0.13854843f, 0.14468367f, 0.14109257f, 0.07048821f, -0.20164481f, 
    0.01458724f, 0.15694417f, 0.12899777f, 0.01719633f, 0.02679151f, 0.10054845f, 0.06716409f, -0.01626784f, 
    0.02319769f, -0.65920037f, -0.29934317f, 0.03312470f, -0.10719770f, 0.08283061f, 0.10493114f, 0.11858014f, 
    -0.10624450f, -0.25953817f, -0.22086124f, -0.10650001f, 0.01726657f, -0.07104715f, 0.06060087f, -0.02753996f, 
    -0.13755378f, 0.12031232f, 0.05661280f, 0.07625471f, -0.13230099f, -0.06016040f, 0.01161614f, 0.13284482f, 
    0.00470858f, -0.39106739f, -0.25931874f, -0.17671464f, -0.11071790f, 0.12241960f, 0.04223990f, 0.10436956f, 
    0.11613372f, -0.07829741f, 0.04221372f, -0.06440304f, 0.17086744f, 0.21674643f, 0.15024553f, 0.01475007f, 
    -0.07274092f, -0.23365504f, 0.15208878f, -0.04543222f, 0.00585726f, 0.04335286f, 0.13950956f, 0.03241921f, 
    -0.03864261f, 0.07526553f, 0.19426203f, 0.13750312f, 0.09701260f, 0.07758118f, 0.03732698f, 0.12874800f, 
    -0.00273085f, -0.09889280f, -0.04887601f, -0.05332843f, 0.22859186f, 0.24503247f, 0.13876194f, 0.02258939f, 
    -0.15051140f, -0.08511688f, -0.02651087f, -0.03936077f, 0.16523126f, 0.08365492f, 0.09591961f, 0.09433057f, 
    -0.10159037f, -0.31786016f, 0.08049577f, -0.10069553f, -0.05420621f, 0.03411034f, 0.00557269f, 0.01697992f, 
    -0.25091481f, -0.00307346f, 0.11368947f, -0.16415346f, -0.05508292f, -0.00190416f, -0.02890485f, -0.13330792f, 
    0.15522052f, 0.20406298f, 0.10715257f, -0.20050497f, -0.06372169f, -0.02284148f, -0.00375953f, -0.04764278f, 
    -0.57457858f, -0.58919036f, -0.33811980f, 0.23446053f, 0.09461091f, 0.19231038f, 0.14339256f, -0.07414510f, 
    0.10308930f, -0.09415647f, 0.11767210f, -0.03755162f, 0.24765211f, 0.00081249f, -0.04009815f, -0.28203413f, 
    0.05171010f, -0.01234629f, -0.09683047f, 0.10286385f, -0.13932353f, -0.06632599f, 0.03810602f, 0.09152094f, 
    0.17953967f, 0.12685594f, 0.00286493f, -0.14379224f, -0.19106229f, 0.23107719f, 0.02620407f, -0.06428582f, 
    0.12547915f, 0.11792041f, 0.01258024f, -0.02173876f, 0.17249082f, -0.05808977f, -0.02207224f, 0.01731903f, 
    -0.06127926f, 0.04995165f, 0.05884553f, -0.01402770f, 0.05950924f, 0.18593022f, 0.08678243f, -0.12591864f, 
    -0.20288350f, -0.55042934f, -0.40634686f, -0.36716050f, 0.18252517f, 0.11990675f, -0.22398221f, -0.05923244f, 
    -0.16048664f, -0.05472641f, 0.03169457f, -0.07003061f, 0.79307002f, 0.26465702f, 0.00446606f, -0.15763305f, 
    -0.02936713f, 0.20907967f, -0.04233995f, 0.08391808f, 0.33896741f, 0.29998267f, -0.00719421f, -0.02651085f, 
    0.17183444f, 0.30920270f, -0.05773431f, 0.01457462f, -0.14275251f, -0.06809468f, -0.22074439f, -0.00241616f, 
    -0.00382650f, 0.14624792f, 0.14566432f, 0.12281440f, -0.17914593f, 0.03748678f, -0.13379596f, 0.20975061f, 
    -0.09449196f, 0.13595553f, 0.05532555f, -0.13722248f, 0.00826121f, 0.12744811f, 0.07228203f, 0.00314111f, 
    0.10034262f, 0.07745473f, 0.09704045f, 0.27526349f, -0.04871690f, -0.10757433f, -0.05778162f, 0.03011273f, 
    0.04818055f, 0.28826138f, -0.07738750f, 0.15401103f, 0.24854280f, -0.01848298f, -0.03974425f, 0.01305262f, 
    0.15759428f, 0.03845714f, 0.15120423f, 0.05626032f, -0.02150516f, 0.18431291f, -0.00096145f, 0.11730320f, 
    0.36748829f, 0.22894724f, 0.12657313f, -0.06363043f, -0.06074822f, -0.10089251f, 0.01183578f, -0.13051130f, 
    -0.11473665f, 0.12297460f, -0.10053654f, 0.06727097f, 0.17626145f, -0.01618423f, 0.10994948f, 0.08519452f, 
    0.07349514f, -0.04886786f, -0.00209958f, 0.06980252f, -0.22238198f, -0.06784160f, -0.06942071f, -0.24605750f, 
    -0.13283186f, -0.06539405f, 0.10603793f, 0.08685467f, -0.07674526f, -0.20153677f, -0.06224586f, 0.07059256f, 
    0.21919762f, 0.14875838f, -0.07325313f, -0.06613935f, 0.22025017f, -0.17104211f, -0.02043045f, -0.20257865f, 
    -0.18765272f, 0.17605595f, 0.04797034f, 0.13823569f, -0.01705574f, 0.07974858f, -0.01813118f, -0.07874184f, 
    -0.34322324f, 0.13051270f, -0.19141470f, 0.21760146f, 0.00009904f, -0.08737608f, 0.03400382f, 0.05026180f, 
    -0.14996380f, 0.04487437f, -0.00279536f, 0.06891474f, -0.44599304f, 0.14760265f, 0.11446283f, 0.07498232f, 
    -0.05549759f, -0.02145344f, 0.08095376f, -0.01927471f, -0.12298474f, -0.09161386f, 0.09263710f, 0.21008076f, 
    0.11261613f, 0.00988670f, 0.18059248f, 0.02241841f, 0.02519892f, -0.05389227f, 0.09796567f, 0.07275537f, 
    -0.16219169f, 0.09470139f, -0.17315416f, -0.15955983f, -0.01437209f, 0.55336469f, -0.03776710f, 0.13252994f, 
    0.10969806f, 0.14391845f, 0.02713273f, 0.21140890f, -0.02030655f, -0.16185257f, -0.05418224f, 0.02504862f, 
    -0.30610690f, 0.03023097f, -0.17260200f, 0.35092244f, 0.03750233f, 0.13362180f, -0.02606745f, 0.16234459f, 
    -0.01706234f, 0.06492627f, -0.08196542f, -0.12971711f, -0.16163428f, 0.14412510f, -0.11096600f, 0.04918261f, 
    0.22599638f, 0.10198243f, 0.01935936f, -0.08037820f, -0.02543101f, -0.00087776f, 0.17031857f, -0.08907761f, 
    0.14859611f, 0.00138389f, 0.09494072f, 0.35869461f, -0.18517046f, -0.06542428f, 0.00946532f, 0.10994389f, 
    -0.02436303f, -0.08445670f, -0.03251699f, -0.02043796f, -0.12265014f, 0.08922350f, -0.16815916f, 0.17334768f, 
    0.05351696f, 0.09840075f, 0.05829173f, -0.11483318f, -0.07375321f, 0.11893345f, -0.06556151f, 0.09343816f, 
    0.27311951f, -0.14932752f, -0.03167913f, 0.16322935f, 0.06473768f, 0.07193292f, 0.10769001f, 0.06433313f, 
    0.07693505f, -0.03713910f, 0.20871837f, 0.14214943f, 0.23176393f, -0.09303198f, 0.06016166f, -0.08377574f, 
    0.13516542f, -0.01248315f, -0.12025831f, 0.16511831f, 0.09952379f, 0.13434629f, 0.08202755f, 0.00494578f, 
    -0.41661692f, -0.10734444f, 0.04198631f, -0.18576287f, -0.03448458f, 0.01429245f, 0.13071688f, 0.13402370f, 
    0.04550103f, 0.06576216f, 0.12014136f, 0.08399002f, -0.23746581f, 0.06633975f, -0.19009942f, 0.05168108f, 
    -0.04554773f, -0.03746969f, -0.04487037f, 0.04257348f, 0.17920153f, 0.01602232f, 0.06958186f, 0.09149168f, 
    -0.30575556f, 0.20410164f, -0.05029604f, -0.13520403f, -0.11844718f, -0.09371444f, -0.03909055f, -0.05018909f, 
    0.09006009f, 0.01278086f, 0.26359701f, 0.04399050f, 0.15021273f, -0.00540823f, -0.01783526f, 0.03207225f, 
    0.25446755f, 0.02095932f, 0.02025712f, -0.00374412f, 0.03933595f, -0.08918086f, -0.12802300f, 0.05782215f, 
    0.17581820f, 0.23022379f, 0.14569992f, -0.04505466f, -0.00119452f, 0.00363563f, 0.17655943f, 0.01756523f, 
    -0.06541909f, -0.05875941f, 0.02366102f, -0.03905988f, -0.18481001f, 0.17597666f, -0.03933639f, 0.12107152f, 
    0.01730666f, -0.11155337f, 0.02884092f, -0.07562125f, 0.04763678f, 0.05137169f, 0.13213132f, -0.03145528f, 
    0.20108610f, -0.29716495f, 0.29642540f, -0.05848834f, -0.01884959f, -0.07727098f, 0.04663407f, 0.05833664f, 
    0.04081677f, -0.00878220f, 0.07677993f, 0.02987471f, 0.39088735f, 0.02073009f, -0.25566256f, 0.08339909f, 
    0.11661609f, -0.01484422f, 0.18979724f, 0.27472106f, 0.05935371f, 0.03072097f, -0.06480347f, -0.06091860f, 
    -0.17193316f, -0.09555302f, 0.06256451f, -0.23273140f, 0.01471765f, -0.12075412f, -0.02358187f, 0.13310483f, 
    0.06456757f, 0.02222781f, 0.00953857f, -0.08704849f, 0.29914293f, -0.11350295f, 0.19262919f, 0.08826974f, 
    0.07368501f, -0.11646154f, -0.09208006f, -0.06760242f, 0.07588034f, -0.02462881f, 0.03375990f, 0.02039770f, 
    0.12879388f, -0.27213585f, 0.06231544f, -0.14227204f, 0.26793975f, 0.19233017f, 0.09846683f, 0.05442541f, 
    -0.02632360f, 0.07962988f, 0.10130733f, -0.04676178f, 0.06629621f, -0.15696530f, 0.01494814f, 0.15463369f, 
    -0.09068412f, -0.02646401f, -0.11350337f, 0.03328982f, 0.08663906f, 0.09097008f, -0.00232267f, 0.07928064f, 
    -0.25541443f, 0.01177553f, -0.07853664f, -0.26682359f, -0.10573103f, -0.05627281f, 0.08378942f, -0.12096354f, 
    -0.01222637f, -0.03819721f, -0.12249976f, -0.18862340f, -0.08347837f, -0.39074752f, 0.47761789f, 0.18767752f, 
    -0.01674484f, 0.17974228f, -0.00883990f, 0.01120999f, 0.09818468f, 0.08782405f, 0.00757484f, 0.06363083f, 
    0.16035408f, -0.16050923f, -0.09780568f, 0.21041505f, 0.06146133f, 0.02660927f, 0.08278222f, 0.00209997f, 
    0.13969678f, -0.18571822f, -0.05537138f, -0.00588397f, -0.02490437f, -0.20093112f, 0.08496788f, 0.11851364f, 
    0.13238966f, -0.21484190f, -0.13859190f, -0.06174025f, -0.01413686f, -0.08614951f, 0.11643185f, 0.23844510f, 
    -0.26466814f, 0.17787677f, 0.05177952f, -0.12910466f, -0.01933109f, -0.07273421f, 0.08339474f, 0.04381251f, 
    0.07788359f, -0.23504816f, 0.04475757f, 0.02843202f, -0.32439116f, 0.15243478f, -0.14170226f, 0.13203484f, 
    -0.04819475f, -0.17307904f, -0.12890837f, -0.04055883f, 0.22717544f, -0.03059572f, -0.00079564f, 0.11892487f, 
    -0.31803086f, 0.24697602f, -0.18843938f, -0.20934096f, -0.08402295f, -0.10565901f, 0.04751231f, 0.03282313f, 
    0.01196288f, 0.03951311f, 0.17001173f, -0.01482862f, 0.21797022f, -0.09434712f, -0.10605318f, 0.03738147f, 
    0.04507725f, 0.26939380f, -0.05594906f, -0.00850959f, 0.19282253f, -0.12252364f, -0.16753381f, -0.04484846f, 
    0.25858149f, 0.40557835f, 0.28356907f, -0.10579222f, -0.04450861f, 0.10466922f, 0.00929207f, 0.09547274f, 
    -0.14865112f, 0.00134432f, -0.05112428f, 0.08929040f, -0.15178627f, -0.02206846f, 0.19129135f, 0.36411381f, 
    0.00414458f, -0.09723688f, -0.01925831f, -0.08093408f, -0.12762570f, 0.04449646f, -0.14918604f, 0.12597784f, 
    0.34010649f, 0.13444200f, 0.25474146f, -0.08703376f, -0.05168431f, 0.00499487f, 0.00332915f, 0.08133029f, 
    0.02472015f, 0.03714915f, -0.00689549f, -0.02734588f, 0.54928410f, 0.18234062f, -0.08236173f, 0.29632768f, 
    0.06001918f, 0.06845508f, -0.05036016f, 0.44472870f, -0.01870184f, 0.04187096f, -0.02371941f, -0.02816831f, 
    -0.03019592f, 0.12427349f, -0.01282787f, -0.14036652f, 0.02071115f, 0.19219349f, -0.11157925f, -0.05227045f, 
    0.06477050f, -0.09692319f, 0.15055078f, -0.07166986f, -0.11146000f, -0.12153671f, 0.00063272f, 0.10836307f, 
    -0.15723777f, -0.15298867f, -0.00855243f, -0.13382339f, -0.00652777f, -0.01960080f, 0.08950748f, -0.02692966f, 
    0.23162387f, -0.16227812f, 0.19240654f, 0.11599097f, 0.20358177f, 0.08886718f, -0.06074138f, -0.06329991f, 
    0.02172498f, -0.15265673f, 0.09826480f, 0.02107799f, -0.05583339f, -0.09898399f, -0.06298566f, 0.01881196f, 
    -0.05911308f, -0.20594406f, -0.20457627f, -0.02229460f, 0.10391964f, 0.18161741f, -0.06227310f, 0.03846756f, 
    -0.03346210f, 0.20249908f, 0.16029370f, -0.16228485f, -0.07185084f, 0.09536354f, 0.22876051f, -0.00318435f, 
    0.09656391f, -0.05961404f, 0.03696794f, -0.03790661f, -0.15079723f, -0.12943330f, 0.12879336f, 0.29746491f, 
    -0.08419796f, -0.00220016f, -0.11661859f, 0.12736028f, 0.14003028f, 0.08089173f, -0.06471864f, 0.07965366f, 
    0.32393533f, 0.01530220f, -0.24460474f, 0.22431177f, -0.07137296f, 0.04328271f, -0.06474903f, -0.18309836f, 
    0.11393508f, 0.06193226f, -0.00126593f, 0.11657143f, -0.14139262f, -0.08707189f, -0.02130910f, -0.03380131f, 
    -0.00601574f, 0.00195411f, -0.05002606f, -0.01684775f, -0.00568565f, 0.02127424f, -0.00143620f, 0.00875183f, 
    -0.20679626f, -0.13250598f, -0.10568937f, -0.00107906f, -0.05517424f, -0.04806999f, -0.02342593f, 0.02085831f, 
    0.06375618f, -0.00780664f, -0.05437193f, -0.03553020f, 0.07878841f, 0.18984002f, -0.10222901f, -0.23836891f, 
    -0.09315436f, -0.03372919f, 0.15291277f, 0.17783567f, -0.04121722f, -0.08890325f, -0.16595852f, 0.14028740f, 
    -0.00405046f, 0.18549347f, 0.00487521f, -0.08961564f, 0.05385637f, -0.06051594f, 0.11893514f, -0.00935675f, 
    0.02103971f, -0.07313580f, 0.00564334f, -0.04333039f, 0.05651179f, -0.01058034f, -0.08583723f, -0.02112818f, 
    0.11231878f, 0.06910896f, -0.01737390f, 0.11103506f, 0.01727354f, -0.02865786f, 0.09367651f, -0.10559992f, 
    0.03345066f, 0.13828516f, 0.17326818f, 0.22822019f, 0.01274585f, -0.11378752f, -0.14565474f, 0.07361824f, 
    0.02326465f, 0.02672095f, -0.12553972f, -0.08378549f, 0.20987652f, -0.04376329f, 0.18984713f, -0.28474429f, 
    -0.15861782f, 0.11698746f, -0.03736895f, -0.06827425f, 0.04644877f, -0.01203954f, -0.03992300f, -0.24916966f, 
    -0.14805743f, 0.03088479f, 0.01842421f, 0.16455689f, -0.08080155f, 0.10380173f, 0.05255941f, 0.03483723f, 
    -0.18782970f, 0.07384479f, 0.05723354f, 0.03835714f, -0.19215743f, 0.29431447f, -0.03322428f, 0.09303235f, 
    0.01783709f, 0.06713842f, 0.08350419f, 0.31517565f, -0.06763796f, 0.10174459f, -0.03366214f, 0.05210276f, 
    0.12234855f, 0.06565647f, 0.30973870f, 0.09818883f, 0.06792232f, 0.07313616f, 0.15926036f, 0.09316762f, 
    -0.03627139f, -0.08273684f, 0.03842726f, 0.02321020f, 0.10333643f, 0.24991630f, -0.18904355f, 0.09155161f, 
    -0.10154990f, -0.02974458f, 0.09149317f, 0.11357865f, -0.01862581f, -0.06666099f, 0.03873555f, -0.00914170f, 
    0.20522945f, -0.07870451f, 0.01199773f, 0.04816095f, 0.12212799f, 0.18373002f, -0.02823467f, 0.14384073f, 
    -0.04598654f, -0.00213750f, -0.06009583f, -0.12525865f, -0.31604972f, 0.15610443f, -0.01720626f, -0.12544218f, 
    0.09747666f, 0.04053995f, -0.14133866f, 0.00852994f, 0.00243764f, 0.14295785f, -0.08966800f, 0.04439103f, 
    0.16208848f, 0.07853261f, 0.19871926f, 0.24141274f, -0.14025272f, -0.09309565f, 0.15924741f, -0.00505014f, 
    -0.01444987f, 0.01350888f, 0.20261435f, 0.03946986f, -0.31982732f, -0.32721525f, 0.15892068f, 0.27804962f, 
    0.03789598f, 0.07899672f, -0.09500967f, -0.11721480f, 0.00449284f, -0.03745896f, -0.10000826f, 0.04454353f, 
    -0.13636149f, 0.20561247f, 0.27976671f, -0.08406334f, 0.01456162f, 0.02661707f, -0.01317028f, -0.05254270f, 
    -0.09475245f, 0.06167420f, -0.04092956f, -0.23564224f, 0.03531506f, 0.14463359f, 0.10666742f, 0.25392273f, 
    -0.00541940f, 0.08609857f, 0.04608117f, 0.09664194f, -0.11471042f, 0.01430254f, -0.05420456f, -0.06950997f, 
    0.39275372f, 0.16307214f, 0.00058096f, 0.14236236f, 0.01740899f, 0.04852149f, -0.03638825f, -0.08507858f, 
    -0.19285671f, 0.07238848f, 0.04417573f, -0.01358535f, -0.35570636f, -0.08208504f, 0.29536331f, 0.04479531f, 
    0.18870194f, 0.16315413f, -0.21262042f, -0.18359841f, -0.02582059f, 0.13876398f, -0.06508826f, -0.14201184f, 
    0.00826759f, -0.13888961f, 0.09129620f, 0.09224874f, 0.17324606f, 0.10235751f, -0.03153297f, -0.08301422f, 
    -0.18782754f, 0.04580217f, -0.02944366f, -0.01686273f, 0.11320741f, -0.01919493f, 0.01836591f, 0.17026049f, 
    0.08089864f, 0.09096998f, 0.05155559f, -0.06281787f, 0.00156389f, 0.12150818f, -0.02310763f, 0.04912608f, 
    0.00342965f, -0.20619792f, -0.02823773f, -0.14967960f, 0.06386536f, 0.04180751f, -0.05062201f, -0.00733996f, 
    -0.02505689f, -0.06277347f, 0.08421602f, -0.07617056f, -0.10886726f, -0.03282277f, -0.15778533f, 0.01815426f, 
    0.07910830f, -0.05589462f, -0.03809259f, 0.16940667f, -0.01393212f, -0.03925265f, -0.08437750f, 0.20608982f, 
    0.02238531f, 0.01762154f, -0.19210772f, -0.23162228f, 0.09510820f, -0.01161999f, 0.07103334f, 0.10090518f, 
    -0.12932433f, -0.01608549f, -0.11839843f, -0.03660349f, 0.18366714f, -0.30912241f, 0.09329294f, -0.22092474f, 
    0.00078296f, 0.03923716f, -0.00285082f, -0.37206072f, -0.13909289f, -0.22777252f, 0.04619790f, 0.11821420f, 
    0.17876211f, 0.15006703f, -0.10101832f, -0.04593002f, -0.03313414f, -0.07087521f, 0.02913507f, -0.01982334f, 
    -0.10208406f, 0.14733750f, 0.04211123f, 0.01936379f, -0.11659106f, 0.07013965f, 0.00246750f, 0.08378004f, 
    0.23754665f, 0.12185147f, 0.15666267f, 0.12450067f, 0.06110191f, -0.08284305f, -0.05761335f, -0.01433323f, 
    -0.22833681f, -0.08011755f, -0.20142831f, 0.11053783f, -0.10929687f, -0.11142293f, 0.10240918f, -0.00643287f, 
    0.19706853f, -0.07063040f, -0.00071940f, -0.05726872f, 0.07380997f, -0.01339799f, -0.00437459f, 0.00006853f, 
    0.14344931f, -0.07837347f, 0.09939805f, 0.03068809f, 0.08290190f, -0.10211442f, 0.06462483f, -0.15086085f, 
    -0.01719942f, 0.14780445f, 0.00158460f, 0.15750876f, 0.05667400f, 0.14060682f, 0.03235772f, 0.16018158f, 
    -0.13723007f, 0.02984066f, 0.03446516f, 0.05751774f, 0.42278573f, 0.00849715f, -0.30130669f, -0.02018761f, 
    0.12188781f, 0.04685849f, 0.06476309f, 0.00604077f, 0.02416896f, -0.11956633f, -0.05822487f, -0.01607201f, 
    -0.07040674f, 0.06047954f, -0.02888043f, 0.08894390f, -0.17398924f, 0.00234918f, -0.05022439f, -0.08105944f, 
    -0.36461857f, -0.21353163f, -0.09996416f, -0.05207335f, -0.21671833f, 0.08301245f, 0.28587857f, 0.02199519f, 
    -0.00671097f, 0.09802806f, -0.11391404f, -0.10589194f, 0.10432158f, 0.00000616f, 0.02565978f, -0.04725257f, 
    0.48632517f, 0.05480325f, -0.03231461f, 0.10257614f, 0.16734371f, 0.09202068f, -0.17762153f, -0.00772874f, 
    0.15088995f, 0.01531247f, -0.00859139f, -0.28012809f, -0.37141868f, 0.22268341f, 0.24921605f, -0.21221526f, 
    -0.06406512f, 0.02416957f, -0.13344289f, -0.09940445f, 0.05595415f, 0.10724165f, -0.14853176f, 0.03579732f, 
    -0.01797984f, -0.04407904f, 0.02162223f, -0.33609745f, -0.06333321f, 0.02641554f, -0.08547690f, -0.17652382f, 
    0.00167180f, 0.03160907f, 0.14212961f, -0.03454250f, -0.00690297f, -0.09567492f, -0.05960974f, 0.07584558f, 
    0.06041775f, 0.08033294f, 0.14963788f, 0.01086003f, -0.07346548f, 0.16079454f, -0.01513544f, 0.01724094f, 
    0.27575889f, 0.07048728f, -0.11259729f, -0.02107630f, -0.02312168f, -0.08829582f, -0.01107307f, 0.05036386f, 
    0.08447000f, 0.03565786f, -0.13038287f, -0.12254824f, -0.36849177f, 0.13651845f, 0.11602859f, -0.09807654f, 
    0.05998088f, -0.03207839f, 0.07168387f, -0.14803785f, 0.00327168f, 0.00981365f, 0.10845996f, 0.07144967f, 
    -0.05843201f, 0.32822734f, -0.01484991f, -0.09227204f, 0.00980419f, 0.13026223f, 0.01257955f, 0.30506361f, 
    -0.01532377f, -0.01610788f, 0.15128873f, 0.09943724f, 0.44383609f, 0.21044120f, -0.05543952f, -0.13687411f, 
    0.21884476f, 0.12442580f, 0.05295439f, 0.29638964f, -0.06208567f, -0.09148405f, -0.09708396f, 0.09634875f, 
    0.28620958f, 0.00635663f, -0.07216910f, 0.06757533f, 0.04906905f, 0.15119253f, 0.29656041f, 0.01061410f, 
    0.10024074f, -0.05858831f, -0.06951534f, -0.07812781f, -0.11782522f, 0.37345278f, -0.17788824f, 0.04431060f, 
    -0.17295696f, -0.05816272f, -0.19832247f, -0.08774120f, -0.09177775f, 0.01253437f, -0.00596278f, 0.07891259f, 
    -0.43576899f, -0.19163838f, -0.06358325f, -0.16811098f, -0.13292968f, 0.16653091f, 0.22004609f, 0.01334319f, 
    -0.02733706f, 0.07352661f, 0.00730925f, -0.07972564f, 0.07469702f, 0.09198376f, 0.27003655f, -0.10931589f, 
    -0.15766801f, -0.03687240f, -0.15756586f, -0.33041948f, 0.12892315f, -0.00272156f, 0.13698921f, -0.00697662f, 
    0.11874747f, 0.00280050f, 0.09480893f, 0.15104116f, -0.11549246f, 0.09965928f, -0.03271051f, 0.25564742f, 
    -0.08775012f, 0.01156478f, 0.17622671f, 0.02739786f, 0.38105130f, -0.54186201f, -0.05428729f, 0.16659002f, 
    -0.17450961f, -0.02033791f, -0.00374584f, 0.00237997f, 0.20169930f, -0.05305927f, 0.01123787f, 0.14944085f, 
    0.01936782f, -0.04273471f, 0.02036364f, 0.05448458f, -0.15990049f, -0.01030892f, 0.10722229f, -0.04081641f, 
    -0.03005761f, 0.00099129f, -0.01028108f, 0.05315777f, 0.11478420f, 0.16372189f, 0.06777879f, -0.23743452f, 
    -0.16877568f, 0.16381603f, 0.05716887f, -0.19647855f, 0.10747232f, 0.08702521f, 0.06054225f, 0.01622031f, 
    0.01000615f, -0.49046481f, -0.19562967f, -0.08656674f, -0.02730276f, -0.17453481f, -0.01778492f, 0.18433453f, 
    0.23783633f, 0.10105882f, 0.00647056f, 0.00137660f, -0.12634894f, 0.02840710f, 0.02996317f, 0.01034995f, 
    0.05176784f, -0.11864213f, 0.19721553f, -0.16041513f, -0.01403506f, -0.00754435f, 0.03151133f, 0.07361784f, 
    0.27570292f, -0.28487316f, -0.14334306f, -0.14082351f, -0.03074720f, 0.08341470f, 0.07656906f, 0.08765529f, 
    0.17484789f, 0.01751528f, -0.06806332f, 0.07036452f, -0.05179679f, 0.07468212f, 0.01915749f, -0.18063141f, 
    0.13429743f, -0.16270432f, 0.05828517f, -0.11838578f, -0.13072164f, -0.09353155f, 0.13288413f, -0.02924114f, 
    0.04272601f, -0.00396043f, -0.00928611f, 0.09728051f, -0.25703743f, 0.02963222f, 0.31455833f, 0.23354855f, 
    0.05184178f, 0.05230618f, 0.08490993f, -0.08226968f, -0.14071898f, 0.04693539f, -0.10004129f, 0.02881180f, 
    0.15144797f, -0.17657118f, -0.00059111f, -0.23657951f, 0.22221190f, -0.02157250f, -0.01867193f, 0.02861450f, 
    0.15975724f, -0.27493727f, 0.45473179f, 0.12245218f, 0.02828572f, -0.08886663f, 0.08082703f, 0.08787884f, 
    0.07846881f, 0.17468816f, 0.00355052f, 0.11922768f, -0.41923627f, -0.19187467f, -0.42616645f, 0.08523066f, 
    0.15045139f, 0.04126403f, 0.18124574f, 0.11509632f, -0.11291689f, 0.09732125f, -0.20963924f, 0.00814264f, 
    -0.21462052f, 0.15562952f, -0.07653921f, 0.16694358f, -0.11116078f, 0.07374290f, 0.12660149f, 0.09307796f, 
    -0.00504509f, -0.04453271f, 0.10304944f, 0.05493319f, 0.38261443f, -0.26679963f, -0.04003130f, -0.42352518f, 
    0.02654056f, 0.13241288f, -0.07444787f, -0.37051326f, 0.11845046f, 0.20636557f, 0.21913356f, 0.10645269f, 
    0.07706337f, -0.04699892f, -0.11940182f, -0.36580822f, -0.11583294f, 0.19837904f, 0.01186802f, 0.01087558f, 
    -0.08907012f, -0.10431958f, -0.10071109f, -0.18014595f, 0.12081136f, 0.04410302f, 0.01779684f, -0.13807283f, 
    -0.14838891f, 0.02338304f, 0.06630451f, -0.05504579f, -0.10126256f, 0.04639770f, 0.18559551f, 0.09921858f, 
    -0.15788838f, -0.17950341f, -0.06317087f, -0.05159965f, 0.00809432f, 0.16390957f, -0.01800480f, 0.24970749f, 
    0.07611907f, 0.19053228f, 0.03846419f, 0.13098484f, -0.09561919f, 0.04707322f, 0.30217785f, -0.13809104f, 
    -0.12808898f, -0.01192361f, -0.01924210f, 0.00604134f, 0.03007765f, -0.02138039f, 0.05730494f, 0.00383121f, 
    -0.05313410f, -0.04547967f, 0.03057395f, 0.01239848f, -0.06963268f, 0.04073190f, -0.07181059f, 0.05088205f, 
    0.06486110f, -0.04641769f, -0.02844355f, 0.04631938f, 0.03582181f, -0.00803369f, 0.00153048f, -0.05266523f, 
    -0.05987762f, 0.00559463f, 0.04368979f, -0.00744158f, 0.00552732f, 0.02050361f, 0.00925593f, -0.03154441f, 
    -0.02318672f, 0.03125768f, -0.07462119f, 0.02164915f, -0.00989160f, 0.00167760f, -0.02304468f, 0.05222546f, 
    -0.01821420f, -0.06117019f, 0.05631745f, 0.03375649f, 0.00562576f, 0.05246546f, 0.04590343f, 0.03995055f, 
    0.05175326f, -0.06648666f, -0.06010835f, -0.02804699f, -0.01391605f, -0.00101550f, -0.01396706f, -0.04353525f, 
    0.05199617f, 0.06183474f, 0.00603134f, 0.00076997f, 0.00717510f, 0.05017800f, -0.02729361f, -0.07270592f, 
    -0.05791140f, 0.01233671f, -0.04930624f, -0.04085154f, -0.06260253f, -0.07073246f, -0.02997860f, 0.02623980f, 
    -0.03237160f, -0.05887322f, 0.00597607f, 0.03198728f, -0.05991468f, 0.06757875f, 0.00184725f, -0.03737381f, 
    -0.05401579f, -0.04617770f, 0.06696892f, -0.04988184f, -0.02667073f, -0.07643463f, 0.01921214f, -0.03736265f, 
    -0.06301846f, 0.04718956f, -0.04737766f, -0.00574049f, 0.00764441f, 0.01658492f, 0.01040167f, -0.01068442f, 
    -0.00065068f, 0.02492980f, -0.03800903f, 0.04658819f, -0.04514040f, 0.03412268f, 0.00685064f, 0.01528052f, 
    -0.02112058f, -0.00093139f, -0.07274351f, -0.00715341f, -0.07122502f, -0.02687842f, 0.06826141f, -0.05401037f, 
    -0.01023161f, -0.04065945f, 0.01260012f, -0.00447908f, -0.04247120f, 0.02483258f, -0.06268217f, -0.06924678f, 
    -0.05362947f, -0.04115538f, -0.03912138f, -0.05707622f, -0.01862786f, -0.06424092f, 0.08059053f, 0.04285915f, 
    0.03600889f, 0.06801930f, -0.05708711f, -0.05300886f, 0.04399805f, -0.02474266f, -0.05424186f, -0.00674689f, 
    -0.01717159f, -0.04720324f, -0.02683537f, 0.06573071f, -0.01420318f, 0.05504278f, -0.07273784f, -0.03539021f, 
    -0.02051324f, -0.04634769f, 0.04795967f, -0.06386323f, 0.04911133f, 0.01669388f, -0.04143972f, -0.04651197f, 
    0.01159431f, 0.04492691f, 0.01682845f, -0.00644576f, 0.05462814f, 0.01537549f, -0.04199308f, -0.05425840f, 
    0.02150772f, -0.02837980f, -0.03699744f, 0.02539211f, 0.02906686f, -0.02664198f, 0.05029780f, 0.04101378f, 
    -0.00403982f, -0.05458300f, -0.04230445f, -0.03841651f, 0.00127977f, 0.04130493f, 0.01451799f, 0.01392585f, 
    0.01666481f, 0.02998351f, 0.03040868f, -0.03967845f, 0.01980861f, -0.07149128f, -0.02992390f, 0.03436154f, 
    0.05271265f, -0.03982655f, 0.02322790f, -0.00966017f, 0.00164426f, -0.06841861f, -0.04191829f, -0.07270154f, 
    0.04763915f, -0.02460519f, -0.03036221f, -0.01099546f, -0.02215703f, 0.00848810f, 0.06393858f, 0.02186936f, 
    -0.02134734f, -0.10742109f, 0.04071471f, 0.04322748f, -0.09371819f, 0.02206285f, -0.09882282f, 0.05233566f, 
    -0.07504961f, 0.10979008f, 0.04238816f, 0.08726651f, -0.03060911f, 0.02432829f, 0.03692800f, 0.11833100f, 
    -0.04442425f, 0.07804056f, 0.00167171f, -0.02803802f, -0.10276617f, 0.14704192f, -0.02817065f, 0.06197842f, 
    0.44293422f, 0.08835260f, 0.01077691f, 0.00151499f, 0.25808874f, 0.07665209f, -0.09748972f, 0.07691261f, 
    0.01319424f, -0.06159865f, -0.03787202f, 0.15318243f, -0.38733566f, -0.08975846f, 0.13841671f, 0.02228196f, 
    0.08272427f, 0.16325434f, -0.00562996f, -0.07017735f, 0.06293145f, 0.05986135f, -0.02234190f, -0.02798894f, 
    0.15802503f, -0.25283909f, -0.04807398f, -0.15172373f, -0.01752464f, -0.06027383f, -0.03080661f, -0.03770963f, 
    -0.06927408f, 0.06981982f, -0.05954012f, -0.13492011f, 0.06934427f, 0.12378549f, 0.02045160f, 0.17454544f, 
    0.05854663f, -0.04491094f, 0.06608766f, -0.02042821f, -0.15841116f, -0.13427649f, -0.03815788f, -0.15087159f, 
    0.25929654f, 0.02565320f, -0.02151486f, -0.12368875f, 0.02133714f, -0.00873276f, 0.08929284f, 0.04649280f, 
    0.13332175f, 0.13473500f, 0.03337857f, -0.06696102f, -0.26784977f, 0.00028467f, 0.14686324f, 0.01284406f, 
    0.01262599f, -0.06464899f, 0.03947941f, 0.03585406f, 0.04126717f, -0.01497362f, 0.05399499f, 0.00334893f, 
    -0.04021139f, 0.34308815f, 0.04356814f, -0.15153997f, 0.00487661f, 0.07248084f, -0.04885695f, 0.03676113f, 
    -0.15496603f, -0.07539458f, -0.06040902f, -0.17005764f, -0.00944323f, -0.26306978f, 0.06462493f, -0.11585904f, 
    -0.08865748f, -0.05316605f, 0.14957251f, 0.12918989f, -0.19118765f, -0.08848912f, -0.01563228f, 0.05999719f, 
    0.24647745f, -0.06038706f, -0.19863482f, 0.07784065f, 0.04736773f, 0.06582339f, 0.02460980f, 0.00346978f, 
    -0.10457050f, -0.06507901f, -0.07287579f, -0.01331743f, 0.10984822f, 0.25981516f, 0.07192919f, -0.07528930f, 
    0.05777584f, 0.12617195f, 0.03822980f, 0.01677267f, -0.05985151f, 0.01934088f, -0.09111185f, -0.15873504f, 
    -0.18777950f, -0.07854711f, 0.09018936f, 0.05482619f, 0.03377750f, 0.03242133f, 0.15878452f, 0.01178891f, 
    -0.01423379f, -0.03061491f, -0.06507090f, -0.08919236f, 0.06210031f, 0.08985072f, 0.02540280f, 0.01492025f, 
    0.05929097f, 0.05706438f, -0.08247906f, -0.06184145f, -0.13893861f, 0.15918815f, 0.07315467f, -0.10687395f, 
    0.32644606f, 0.25446397f, 0.02924386f, 0.11837283f, -0.08884443f, 0.10034391f, -0.07014991f, 0.04225928f, 
    0.01298726f, -0.10668647f, 0.03652553f, -0.04724710f, 0.18771164f, 0.19437239f, 0.03808248f, 0.10498189f, 
    -0.07273556f, -0.00569119f, 0.01470862f, -0.00349804f, -0.01173101f, 0.10505529f, -0.13376606f, 0.03866239f, 
    -0.09649047f, 0.22442570f, 0.28958914f, -0.05185121f, -0.03181851f, -0.00082118f, -0.15762573f, 0.01027509f, 
    -0.00307176f, -0.02948384f, 0.08339070f, -0.00556362f, 0.01019993f, 0.27489766f, -0.13279171f, 0.06446277f, 
    -0.12142080f, -0.04989723f, 0.01463974f, 0.01125414f, 0.03867691f, -0.05099794f, 0.04424010f, 0.11173533f, 
    0.26447994f, 0.10832890f, -0.05520992f, 0.03632595f, 0.06746651f, 0.14741106f, -0.16456273f, -0.09287313f, 
    -0.02519618f, -0.02139937f, 0.10325548f, 0.07432487f, 0.29993498f, -0.15895492f, 0.14021899f, 0.09160081f, 
    0.06775887f, 0.13760850f, -0.09333093f, 0.07109386f, 0.02179220f, 0.03666461f, 0.19410060f, 0.07175007f, 
    -0.22437498f, -0.23638831f, -0.16151784f, 0.01333768f, 0.12660040f, 0.08018457f, 0.00678280f, 0.08757474f, 
    -0.07905313f, 0.08263479f, -0.06484271f, -0.01132303f, -0.07292703f, 0.01370473f, -0.00518620f, -0.05724522f, 
    -0.17083037f, 0.10244784f, -0.09968574f, -0.09509213f, -0.10373078f, 0.06923736f, -0.04508314f, -0.12568690f, 
    0.01787452f, -0.22178182f, -0.09625650f, -0.01224225f, 0.07487938f, 0.05527006f, -0.09293867f, 0.00263713f, 
    0.01567188f, 0.00036946f, 0.05425813f, 0.07182405f, 0.53944308f, 0.08582252f, 0.24840343f, 0.17534976f, 
    0.06047551f, 0.00063538f, 0.02010656f, 0.09971853f, 0.05798626f, 0.07999764f, -0.00746467f, -0.03663425f, 
    0.11921783f, 0.04926160f, -0.25811529f, 0.00694567f, 0.14734052f, -0.11072370f, 0.13603552f, 0.06738109f, 
    0.04709516f, 0.08388162f, 0.02232278f, 0.06998009f, 0.09287041f, -0.28513977f, 0.27560443f, 0.18604720f, 
    -0.07924772f, 0.04172437f, 0.08493621f, -0.04523468f, 0.03027123f, -0.21359058f, 0.16982438f, 0.11915660f, 
    -0.04784873f, -0.03139663f, -0.04003653f, 0.02930865f, 0.07021192f, 0.10598928f, 0.13183008f, 0.14990358f, 
    0.05802393f, 0.22402558f, -0.11252852f, 0.18713096f, -0.40090194f, -0.16271074f, -0.17962943f, 0.00973814f, 
    -0.08127605f, 0.11757009f, 0.03542023f, -0.13926665f, 0.02512853f, 0.08194849f, 0.19567768f, 0.08558550f, 
    -0.06725043f, 0.36091226f, -0.21319661f, 0.11489649f, -0.08049964f, -0.12363936f, 0.07073024f, -0.02066989f, 
    0.10283748f, -0.01265392f, 0.22149082f, 0.09418532f, -0.03657151f, 0.17164207f, -0.37757093f, -0.04684707f, 
    -0.09136929f, 0.00706799f, 0.06852342f, -0.12650478f, 0.11761189f, -0.03310376f, -0.02773205f, -0.12136571f, 
    -0.09038565f, -0.14447846f, -0.01472295f, 0.07563360f, 0.13668591f, 0.07096677f, -0.08672602f, -0.01793431f, 
    -0.12875946f, 0.04236645f, -0.06022660f, -0.11720511f, 0.01696343f, 0.60828245f, -0.49239850f, 0.05049270f, 
    -0.04970876f, -0.08543457f, 0.13944669f, 0.06864244f, 0.04149357f, -0.09251383f, 0.19748838f, 0.06680368f, 
    0.07902914f, -0.13594742f, -0.06503771f, -0.08854376f, -0.00059586f, -0.06240553f, 0.16972709f, -0.07212313f, 
    0.06469149f, -0.00678109f, 0.05377876f, 0.08799071f, 0.03051743f, -0.12135056f, -0.19267911f, -0.20811623f, 
    0.06542943f, 0.00721692f, 0.02193062f, 0.05445364f, 0.18381058f, 0.06317610f, 0.19456607f, 0.01895277f, 
    -0.47207794f, -0.23606101f, -0.06864013f, -0.03109597f, -0.09246270f, -0.00625289f, 0.25081542f, 0.11262693f, 
    -0.00050427f, -0.06763095f, 0.06685247f, -0.03078540f, 0.25147197f, 0.11795570f, -0.14311126f, -0.04915293f, 
    -0.09028000f, -0.09631744f, 0.13346551f, 0.18357603f, -0.00564931f, -0.09002864f, 0.22885004f, 0.10265484f, 
    -0.21057850f, 0.20931001f, 0.09118798f, 0.14809653f, 0.07433720f, -0.05166523f, 0.07027865f, 0.06661639f, 
    0.19454263f, 0.02222248f, 0.01229544f, -0.05482225f, -0.11904715f, -0.14553109f, -0.10092419f, -0.21021162f, 
    0.16728435f, 0.05145171f, -0.15719019f, 0.08435747f, 0.13903157f, 0.02650640f, -0.03221993f, 0.10373278f, 
    -0.09520777f, 0.00894422f, 0.10585058f, 0.08988090f, 0.11708870f, 0.20517026f, 0.11852570f, 0.00044217f, 
    -0.09301282f, -0.10463593f, 0.00431554f, -0.00163975f, 0.31418854f, 0.00938395f, 0.00851869f, -0.15209100f, 
    0.07871356f, -0.06038776f, -0.05109736f, 0.04236556f, 0.14199205f, 0.05275281f, 0.10453968f, -0.02877617f, 
    0.17980477f, -0.35551867f, 0.01389507f, 0.13634945f, 0.08227680f, 0.01044589f, 0.12412404f, -0.09592789f, 
    0.11678234f, -0.05436366f, 0.10683004f, 0.01463466f, -0.01863695f, 0.07740811f, -0.05089345f, 0.25174904f, 
    0.07970841f, -0.05167763f, 0.07364997f, 0.16065608f, 0.07325301f, 0.20748042f, 0.00912099f, -0.07089213f, 
    -0.28764617f, -0.10313469f, 0.07601060f, 0.01591176f, 0.02686647f, -0.06415918f, -0.14268500f, -0.11790060f, 
    0.03618446f, 0.03941543f, 0.15251322f, 0.07780647f, 0.05381056f, -0.22991849f, -0.07257710f, -0.01960296f, 
    -0.02869147f, -0.12643085f, 0.04503472f, -0.09319718f, 0.14212431f, 0.09904597f, 0.09295086f, 0.19490938f, 
    0.32362446f, 0.04001346f, 0.04568509f, -0.08094086f, 0.03670166f, 0.01392352f, -0.11176578f, -0.01190238f, 
    0.10897891f, 0.08496311f, -0.02782975f, 0.07908663f, -0.08993205f, -0.10433113f, -0.10851100f, -0.01687558f, 
    0.00323454f, 0.06501359f, 0.06296588f, 0.03102321f, 0.11864758f, -0.10696985f, -0.01133543f, 0.32299241f, 
    -0.16690277f, -0.17535141f, -0.09987663f, -0.24166293f, 0.03348717f, -0.17988001f, 0.04042560f, -0.11742486f, 
    -0.02020430f, 0.09053400f, -0.07812648f, -0.12237901f, -0.35388529f, -0.06541074f, 0.25302920f, 0.05632875f, 
    -0.02307351f, -0.04126344f, -0.00553635f, -0.15328194f, -0.07629023f, 0.02984458f, 0.17111121f, -0.08429082f, 
    -0.06551664f, 0.03242827f, 0.03523127f, -0.02562082f, 0.04656831f, -0.07842898f, -0.08200923f, 0.05183419f, 
    0.02066574f, -0.04543017f, -0.04618052f, -0.07641502f, 0.02006212f, -0.04178714f, -0.03908136f, 0.00743208f, 
    0.00526182f, -0.03584820f, -0.04845501f, -0.07018396f, -0.07130408f, 0.04643230f, 0.00209114f, -0.02869854f, 
    -0.03246240f, -0.06797550f, 0.01779237f, -0.06443436f, -0.06359651f, -0.04759324f, 0.00121802f, 0.04699162f, 
    -0.02110069f, 0.00810815f, 0.01144468f, -0.04076442f, 0.01924673f, -0.04990385f, -0.02403242f, -0.06295722f, 
    -0.07127561f, 0.06122128f, -0.00603983f, 0.04608921f, 0.06171377f, 0.00588648f, -0.07604517f, 0.05987092f, 
    0.01925782f, 0.00981180f, 0.04753110f, 0.02311945f, 0.02967761f, -0.01277337f, -0.04108649f, -0.01592720f, 
    -0.01485542f, 0.03568175f, -0.07118162f, -0.02530007f, -0.00547431f, 0.02646612f, -0.01567301f, 0.01157960f, 
    0.05171762f, -0.06505209f, -0.02764094f, -0.06436428f, -0.03626267f, -0.07862286f, -0.06350508f, 0.02026976f, 
    -0.06805161f, 0.01884946f, -0.05457354f, -0.07984120f, -0.04777581f, 0.05135911f, 0.05885297f, -0.03378620f, 
    0.03242771f, 0.05169886f, -0.00248457f, 0.04119797f, -0.07860098f, -0.02238819f, 0.00077094f, -0.03139018f, 
    -0.06040630f, 0.02641139f, -0.03027300f, 0.05823018f, -0.06491067f, 0.03519006f, -0.06562523f, 0.03993948f, 
    0.01940141f, -0.03451961f, 0.02536800f, 0.02443338f, 0.02085857f, 0.01444712f, 0.01864536f, 0.02315698f, 
    -0.00507849f, 0.03585888f, -0.04957554f, -0.07378291f, -0.06366565f, 0.03189360f, -0.04947130f, 0.01073806f, 
    -0.06632076f, 0.02700134f, -0.05174109f, 0.01163356f, 0.03156517f, 0.02942291f, -0.03248297f, 0.01845392f, 
    0.02595712f, 0.00554457f, -0.08110779f, 0.01591293f, 0.02965441f, -0.06311058f, -0.06890757f, 0.04862278f, 
    -0.00751836f, 0.00885534f, 0.01995807f, 0.04654086f, -0.07648525f, -0.02729350f, -0.08156228f, 0.00859229f, 
    -0.03767291f, -0.00604051f, 0.04553083f, -0.01675170f, 0.01283494f, -0.02791270f, -0.06703403f, -0.00208560f, 
    0.00198582f, 0.02233053f, 0.06240125f, -0.05588310f, 0.03234930f, 0.00773033f, -0.06968818f, -0.02120117f, 
    -0.01557118f, 0.03627819f, 0.00806673f, -0.01801270f, 0.05501529f, 0.04104986f, -0.00944941f, 0.03591414f, 
    0.00430143f, 0.00365156f, 0.05529609f, -0.07158523f, -0.07705607f, 0.05292239f, -0.03288123f, -0.04347233f, 
    0.05672597f, 0.03091370f, 0.05948013f, 0.01154959f, -0.00402107f, 0.05636423f, -0.01818146f, 0.02562000f, 
    -0.06722917f, 0.06224781f, -0.07275041f, -0.03779190f, -0.01572599f, -0.07719892f, 0.02778696f, -0.04148349f, 
    0.03448465f, -0.05610739f, -0.06399842f, -0.05774133f, -0.01795158f, 0.03480195f, -0.01648431f, 0.01979258f, 
    0.02403394f, 0.24407630f, 0.03101237f, -0.19292177f, -0.01788443f, -0.07457604f, -0.08497456f, -0.10750561f, 
    -0.10446291f, -0.10149924f, -0.15425038f, -0.18261956f, -0.04345364f, 0.08603897f, -0.11602737f, 0.00513453f, 
    -0.04995070f, -0.09065460f, 0.16424648f, -0.00885468f, 0.08685219f, -0.12092307f, -0.04409351f, -0.05356762f, 
    0.08159293f, 0.08977675f, -0.05595326f, 0.00639133f, -0.20802993f, -0.02047837f, -0.13845411f, -0.01985719f, 
    -0.11273502f, -0.14253661f, -0.09694918f, -0.18421328f, 0.40653759f, -0.08887013f, 0.17111191f, -0.01016471f, 
    0.00585707f, 0.11657448f, -0.03734205f, 0.05032871f, 0.00732319f, 0.11523718f, -0.03947064f, 0.17588300f, 
    0.23942572f, -0.02909223f, 0.00642755f, -0.00411721f, -0.02336553f, 0.09153435f, 0.02138470f, 0.00777546f, 
    -0.03977273f, 0.09357290f, -0.16884106f, 0.04944549f, -0.23569734f, -0.08999795f, -0.00042985f, -0.13118754f, 
    -0.09778395f, 0.14674078f, 0.03880083f, 0.00245748f, -0.02933853f, 0.19983619f, 0.22749794f, 0.17020150f, 
    -0.32513788f, -0.18627580f, -0.21834445f, -0.16103259f, -0.00766152f, 0.04631909f, 0.00577681f, -0.05443370f, 
    0.00073319f, -0.02937597f, -0.11362471f, 0.01221190f, 0.34105948f, 0.08823586f, 0.22888468f, 0.10226850f, 
    0.02300628f, -0.02536884f, 0.03955191f, -0.11823743f, -0.03053599f, 0.01852965f, -0.05842383f, 0.13533860f, 
    -0.18091869f, -0.11682435f, -0.12752357f, 0.14766449f, 0.12775663f, 0.02273086f, -0.00498875f, -0.01860107f, 
    0.18804236f, 0.03402275f, 0.07439552f, 0.06795200f, -0.00002806f, 0.28638932f, 0.14292902f, 0.00958821f, 
    -0.00145235f, 0.28251672f, -0.07136568f, -0.13808510f, 0.09384792f, -0.08744547f, 0.15184264f, 0.05915668f, 
    -0.01924696f, 0.02633530f, 0.01192995f, -0.05732496f, -0.13986671f, 0.12858406f, 0.20424125f, 0.02658552f, 
    0.24204953f, 0.06902312f, 0.02680517f, 0.20458774f, -0.23956048f, -0.14175653f, -0.06274478f, -0.02684474f, 
    -0.14659941f, -0.05295667f, -0.09951278f, 0.00564598f, 0.11515534f, 0.05471233f, 0.14168531f, 0.11502411f, 
    -0.14706890f, 0.28803951f, -0.10924967f, -0.07399236f, -0.26583320f, -0.02418084f, -0.03197949f, -0.08895564f, 
    0.05596302f, 0.19166152f, 0.15220995f, 0.07260512f, -0.02653176f, 0.11125434f, -0.06606889f, -0.08877400f, 
    0.00703950f, -0.00484062f, 0.09636160f, 0.00834491f, 0.05022454f, 0.11957574f, 0.06170630f, 0.02971726f, 
    -0.26122114f, -0.23735142f, -0.03467527f, 0.02744726f, 0.05571784f, 0.07314769f, 0.03976922f, 0.16131520f, 
    -0.03674662f, 0.09262224f, 0.01692145f, 0.05322217f, 0.30685881f, 0.25687832f, -0.25487170f, -0.06218847f, 
    0.00223836f, -0.07734067f, 0.08717823f, 0.07271313f, 0.18481970f, -0.03352749f, 0.12831347f, -0.17897932f, 
    0.13981079f, 0.06870592f, -0.04211760f, 0.02245188f, -0.05416047f, -0.03018503f, 0.06691734f, 0.01478894f, 
    0.02677387f, -0.01171242f, 0.11014060f, 0.20926927f, 0.14542140f, 0.02788977f, -0.02668083f, 0.09034197f, 
    0.04750058f, 0.07209431f, 0.09547478f, 0.13479008f, 0.07899798f, 0.06901433f, 0.06823195f, -0.10031791f, 
    -0.04365104f, 0.07590777f, 0.24550129f, 0.20409043f, -0.07337771f, 0.01465248f, 0.04445539f, 0.11879812f, 
    -0.08171672f, 0.02558829f, -0.01600759f, -0.09195545f, 0.29515699f, -0.02353966f, -0.02096049f, 0.11727118f, 
    -0.01409863f, 0.15810393f, 0.09259743f, 0.08481853f, 0.02955291f, 0.13111633f, 0.25752485f, 0.02020224f, 
    0.20859647f, 0.15978342f, 0.27744460f, 0.19782987f, -0.17716546f, -0.06004760f, -0.10928085f, -0.07129770f, 
    0.06917229f, 0.04127293f, 0.03628080f, 0.20407724f, 0.02738840f, 0.09679265f, 0.05504809f, -0.12722859f, 
    -0.03925793f, -0.02573770f, 0.10517133f, 0.09272683f, -0.15107842f, -0.04603711f, -0.07529105f, -0.02600422f, 
    -0.44055134f, -0.22017394f, -0.30881608f, -0.10449146f, 0.15067016f, -0.03655538f, 0.03014125f, -0.00951709f, 
    0.07649215f, -0.03971968f, 0.01900931f, 0.10163508f, -0.01723439f, 0.02742266f, -0.00273907f, 0.13526727f, 
    -0.13127619f, 0.06353023f, 0.04704204f, 0.04421660f, -0.15004230f, 0.16129339f, 0.04461856f, -0.13536288f, 
    -0.66810846f, -0.39325500f, -0.02708079f, 0.29627162f, 0.04107334f, 0.03763910f, -0.09433240f, -0.02130771f, 
    0.04076438f, -0.16098028f, 0.07182951f, 0.02032205f, -0.18767044f, 0.18617089f, 0.03739653f, -0.23705076f, 
    -0.06914777f, 0.02430542f, 0.35069129f, -0.36671203f, 0.06652796f, -0.04402739f, -0.03492863f, 0.11093333f, 
    -0.13085930f, 0.02951872f, -0.03111411f, -0.22420408f, -0.07024778f, -0.13200541f, 0.31444135f, 0.18503383f, 
    -0.08173985f, 0.00506360f, -0.25517711f, -0.08025423f, 0.02491965f, 0.04554696f, 0.05465918f, 0.03994572f, 
    -0.09846260f, -0.08918370f, -0.13407034f, 0.10920303f, 0.03210319f, -0.04651175f, -0.02798954f, -0.01927723f, 
    -0.20147933f, 0.02659716f, -0.01124424f, -0.04479194f, -0.03533257f, 0.11683208f, 0.08363333f, -0.08489056f, 
    -0.15545182f, 0.18429734f, -0.01783674f, -0.15614918f, 0.11525761f, 0.04201647f, 0.02730239f, 0.14918235f, 
    -0.04349642f, 0.03562616f, -0.06636409f, 0.08106032f, 0.08202512f, -0.07806191f, 0.18712656f, -0.09374866f, 
    -0.38535613f, -0.29721954f, 0.01490536f, -0.26652506f, -0.10470340f, -0.24381538f, -0.05234553f, 0.07479119f, 
    -0.13764323f, 0.00341717f, -0.13468699f, -0.11660822f, 0.37575299f, 0.12102291f, 0.23926972f, 0.07138974f, 
    0.10433486f, 0.07333713f, 0.00938707f, 0.07739641f, 0.23036416f, 0.21552368f, 0.04384848f, -0.14007695f, 
    0.11684709f, 0.07190165f, 0.10693452f, 0.18772972f, -0.08236954f, -0.01546075f, -0.29395962f, -0.11389020f, 
    0.14672764f, 0.18076669f, 0.11476360f, 0.33717185f, -0.02514244f, -0.04519841f, -0.00198341f, -0.01308886f, 
    -0.06497427f, -0.07626488f, -0.15551010f, -0.30354947f, 0.16684768f, 0.04801400f, 0.00638105f, 0.21257289f, 
    0.08893968f, -0.02500894f, -0.06225470f, 0.19932416f, 0.11160336f, -0.00443541f, -0.04510602f, 0.06707234f, 
    0.08639585f, 0.07772283f, 0.10608982f, 0.19433187f, 0.18991895f, -0.12505110f, -0.21665838f, -0.00273457f, 
    0.02033021f, -0.02351944f, 0.11908825f, 0.01310730f, 0.02199650f, 0.01903338f, 0.01584452f, 0.15901732f, 
    0.35625488f, -0.13987954f, -0.13504200f, -0.01998861f, -0.08836269f, -0.11313917f, 0.02763282f, -0.20215113f, 
    0.11119304f, -0.07023010f, -0.11680697f, 0.13387690f, 0.06092280f, 0.09259182f, 0.05093234f, -0.05033237f, 
    -0.08823183f, -0.03165359f, -0.09396229f, -0.06195805f, -0.36527941f, -0.29318720f, -0.21838595f, -0.68518639f, 
    0.05414347f, 0.14232443f, 0.13584992f, 0.15914153f, -0.04528710f, -0.03073073f, 0.03337428f, 0.16303897f, 
    0.22286586f, 0.25215822f, -0.11017327f, -0.03158157f, 0.12188146f, -0.07147409f, 0.24991754f, -0.10142169f, 
    -0.12588596f, -0.03224702f, -0.28132114f, 0.13443108f, 0.00508077f, 0.00454651f, -0.14225487f, -0.20900048f, 
    0.05404362f, 0.29835740f, 0.30399659f, 0.11910348f, -0.08783506f, -0.01288773f, 0.04161495f, -0.07630149f, 
    -0.06544976f, 0.00135080f, -0.10758187f, 0.01708811f, -0.38236618f, -0.08181086f, 0.24071212f, 0.08114780f, 
    -0.06289652f, 0.08929230f, 0.10652213f, 0.11470546f, -0.15896159f, 0.08743019f, -0.04504177f, 0.06465643f, 
    0.09296598f, -0.01271878f, 0.05267289f, 0.24947360f, 0.09977889f, 0.08408500f, 0.01919930f, 0.13579942f, 
    -0.08897962f, -0.20203899f, -0.05657248f, -0.30893603f, 0.30169463f, -0.03824225f, -0.11910053f, -0.11406208f, 
    -0.11698356f, 0.03297706f, -0.02441420f, -0.13343759f, 0.05330029f, -0.11145952f, -0.00692744f, -0.01129956f, 
    -0.01313597f, 0.18927820f, 0.05651931f, 0.19795686f, 0.13764398f, -0.06276577f, -0.14025570f, 0.00522837f, 
    -0.25769302f, -0.08343490f, -0.12773269f, 0.00089960f, 0.08316768f, 0.21070978f, -0.04486939f, -0.08692666f, 
    -0.08704897f, -0.09175970f, 0.00594148f, 0.04652352f, -0.04224486f, 0.12364461f, 0.04108888f, 0.04834244f, 
    0.24849339f, 0.09964211f, 0.02583326f, 0.19915080f, 0.02875082f, 0.08414959f, -0.09695724f, 0.08935025f, 
    0.02734387f, -0.01299104f, -0.00927016f, -0.03910410f, -0.06683143f, 0.43243322f, 0.05839377f, -0.22583161f, 
    0.02654248f, -0.12989199f, 0.12057614f, 0.06739532f, 0.00222716f, 0.00830152f, -0.14431861f, -0.00366776f, 
    0.29889920f, 0.10909685f, -0.19697678f, 0.00825834f, 0.09229952f, 0.00561078f, 0.00286712f, -0.01670967f, 
    -0.09923528f, -0.03860126f, -0.07742165f, -0.01094759f, -0.06102651f, -0.05534781f, -0.15894131f, 0.18386504f, 
    -0.13847250f, -0.18635294f, -0.04641410f, 0.15100563f, -0.05761682f, 0.03449285f, 0.13473439f, -0.16768140f, 
    -0.24057259f, 0.20171618f, 0.03789798f, -0.07609977f, -0.24971642f, -0.08250429f, 0.06199861f, -0.02176421f, 
    0.10597530f, 0.01088403f, -0.08384171f, -0.14129364f, -0.19581178f, -0.01223800f, 0.04906274f, 0.08400291f, 
    0.12135058f, 0.01185834f, -0.22588475f, 0.26372844f, 0.07560158f, 0.09328063f, 0.06413478f, 0.01189334f, 
    -0.21706942f, 0.29600969f, 0.14038533f, -0.14596742f, -0.08070168f, -0.04304083f, -0.00028942f, 0.05098134f, 
    0.12420137f, 0.03585751f, -0.02240042f, -0.03524666f, 0.09571988f, -0.09122793f, -0.08056219f, 0.08481779f, 
    -0.15187767f, 0.07750477f, 0.07283269f, 0.17888454f, 0.09094834f, 0.03601792f, -0.05187662f, 0.17597675f, 
    -0.00122748f, 0.09075516f, 0.11282577f, -0.00870614f, 0.07071378f, -0.03730166f, -0.02066543f, -0.06609739f, 
    0.06719984f, -0.04908313f, 0.09249683f, 0.10762930f, 0.02309690f, -0.05756720f, 0.03051973f, 0.07452968f, 
    0.03525127f, 0.15803215f, -0.06086686f, 0.08043537f, -0.01173625f, 0.04260950f, -0.02428180f, 0.10426166f, 
    -0.29538420f, -0.09322966f, -0.07502897f, 0.06925070f, -0.12795921f, -0.01058002f, 0.10378927f, 0.11267661f, 
    0.06235116f, -0.00240560f, 0.08987724f, 0.01381248f, 0.23435172f, 0.31208858f, 0.22770333f, 0.09749808f, 
    0.00814278f, 0.06880831f, -0.04258319f, -0.06403204f, 0.09847545f, -0.17746828f, 0.18443237f, 0.03728286f, 
    -0.12189605f, 0.00324313f, 0.21592474f, -0.21239115f, -0.06490319f, -0.00952477f, 0.13806868f, 0.06441088f, 
    0.11829978f, -0.07642788f, -0.00784153f, -0.18259709f, -0.53667229f, 0.13525109f, -0.27089193f, 0.19550215f, 
    -0.23307849f, -0.05331370f, -0.05916507f, 0.00432155f, 0.08500905f, -0.00897041f, -0.18357262f, 0.05907759f, 
    -0.18096551f, -0.24265915f, 0.04576420f, -0.01304823f, -0.05177619f, -0.20173348f, -0.00210424f, 0.08290403f, 
    0.06492147f, 0.05556665f, -0.04612093f, -0.10911827f, -0.10260449f, -0.00413331f, -0.07871457f, 0.16445886f, 
    -0.09550915f, -0.11331490f, 0.00176616f, 0.07985131f, -0.11167430f, -0.04944675f, -0.00670457f, 0.17244925f, 
    -0.16193095f, 0.08036944f, 0.13772997f, -0.02264741f, 0.03545498f, -0.09147839f, 0.36078858f, -0.04534958f, 
    0.15967116f, -0.01380384f, 0.08899397f, -0.09556699f, 0.09969725f, -0.42745218f, -0.12102254f, 0.25851494f, 
    -0.10995917f, -0.05053188f, -0.02437115f, 0.00858808f, 0.09756673f, 0.01887255f, 0.13477799f, 0.07874013f, 
    -0.06603353f, -0.18913573f, 0.13917413f, 0.20381208f, -0.07140619f, 0.05151242f, 0.19523717f, 0.07160396f, 
    -0.06001547f, -0.11989031f, 0.04780871f, -0.00272670f, 0.15993327f, -0.10357685f, 0.16608027f, 0.08388758f, 
    0.10267849f, -0.09893860f, -0.06443019f, 0.00114792f, -0.08164003f, -0.07669479f, -0.05121939f, 0.10551133f, 
    0.10153997f, 0.04644566f, -0.06713584f, -0.08641513f, 0.21831784f, 0.23944362f, 0.06729438f, 0.02084652f, 
    0.00773660f, -0.02028951f, 0.09497440f, 0.18941380f, -0.40943545f, 0.04621872f, -0.03581596f, -0.03617801f, 
    0.06272311f, -0.08479563f, -0.13518600f, -0.16670783f, 0.13363910f, -0.02736262f, 0.02537106f, -0.02849765f, 
    -0.06905715f, -0.18465233f, -0.06277914f, -0.00985075f, 0.05500799f, 0.11135446f, -0.01752087f, -0.07014614f, 
    0.05709225f, 0.00978689f, 0.06910178f, 0.00024313f, -0.08422058f, -0.06722993f, -0.07538717f, -0.05939300f, 
    0.07577485f, 0.04828739f, -0.02526650f, -0.14204931f, -0.08070041f, -0.08691855f, -0.23941588f, -0.05217582f, 
    0.39831987f, 0.20452547f, -0.05249511f, -0.01983721f, 0.10178010f, 0.15874235f, 0.07238594f, 0.13128483f, 
    -0.07245778f, 0.09698920f, 0.10482055f, -0.05780551f, -0.35990852f, 0.02931700f, -0.04844352f, 0.27708060f, 
    0.13396358f, -0.22463559f, 0.01876825f, -0.15791851f, 0.07876784f, 0.03932089f, 0.04176560f, 0.01188431f, 
    0.41868189f, 0.22364517f, 0.27536467f, -0.26612845f, 0.02867393f, 0.08491151f, 0.00102491f, -0.07268826f, 
    0.06060546f, -0.02079903f, -0.01827987f, 0.00305642f, 0.35774961f, -0.25973865f, -0.08727352f, -0.04877979f, 
    0.17020546f, -0.07984501f, -0.04212371f, 0.26938376f, -0.02476037f, -0.00873266f, -0.02311519f, -0.00560634f, 
    0.20270623f, 0.03500890f, -0.19023313f, 0.05561338f, 0.06359123f, 0.01087896f, -0.14932618f, 0.04151526f, 
    -0.05825359f, 0.02438414f, 0.01078709f, -0.03044763f, 0.41263145f, -0.25836387f, 0.22441974f, 0.03931617f, 
    -0.01405257f, 0.03328595f, -0.19581385f, -0.31723556f, 0.01108412f, 0.00461518f, 0.11106948f, -0.03020402f, 
    0.13870496f, -0.36025617f, 0.24164258f, -0.27899548f, 0.08699650f, 0.07832648f, 0.05260948f, -0.07609910f, 
    -0.17025289f, -0.17639509f, -0.11637553f, -0.02200225f, 0.27864006f, -0.13197854f, 0.15173727f, -0.04892777f, 
    -0.01305213f, -0.19614992f, -0.11037452f, -0.14334568f, 0.01654263f, 0.10413954f, 0.00179811f, 0.04717230f, 
    0.26159319f, 0.27121744f, 0.02449286f, -0.13799877f, 0.09508922f, 0.13678791f, -0.02634441f, 0.02598399f, 
    0.00930550f, 0.01920648f, -0.15724097f, 0.02714633f, 0.23998836f, -0.00260913f, 0.31663460f, -0.14167038f, 
    -0.01286792f, -0.02452740f, -0.07098208f, 0.15408379f, 0.11211757f, -0.01525904f, -0.06301387f, 0.04121942f, 
    -0.00340369f, -0.01512063f, -0.00932957f, -0.01794524f, -0.09633421f, -0.03778511f, -0.06752867f, 0.02452344f, 
    -0.08652142f, -0.00633782f, -0.04734392f, 0.01633923f, 0.00865708f, -0.01670795f, -0.02452986f, -0.00466746f, 
    -0.09075099f, -0.06372476f, -0.03454708f, 0.01017680f, -0.02330042f, 0.01616111f, -0.04542323f, -0.02560494f, 
    -0.06662685f, 0.04139571f, -0.05294627f, -0.05119649f, -0.00172170f, -0.08158006f, -0.09549373f, -0.01403029f, 
    0.00770968f, -0.01896080f, 0.01165166f, -0.06906145f, -0.07177585f, -0.02283666f, 0.02576268f, -0.07976042f, 
    -0.02670741f, 0.03757761f, -0.01922672f, -0.02596644f, -0.06726617f, -0.05825155f, -0.06365153f, 0.01894383f, 
    0.03428452f, 0.01994230f, 0.01311184f, -0.03856864f, -0.04443378f, -0.00511060f, 0.00264165f, 0.00880369f, 
    -0.01614206f, 0.01257679f, -0.04447690f, -0.06113739f, -0.07274196f, 0.02488911f, 0.00064229f, -0.05845059f, 
    -0.02099686f, 0.00747490f, 0.04078804f, -0.04376251f, -0.02219413f, -0.01630844f, -0.02326510f, 0.02186302f, 
    0.01648274f, 0.06601326f, -0.00093175f, 0.01433162f, -0.00044460f, -0.06218169f, -0.10321500f, -0.07335524f, 
    -0.01042068f, 0.02595967f, -0.00588259f, -0.04397335f, 0.00371332f, -0.05180037f, -0.06601180f, -0.08820445f, 
    -0.07387619f, -0.02256394f, -0.10257163f, -0.03055472f, -0.10047244f, 0.00653908f, -0.06387882f, -0.00980184f, 
    -0.04932297f, 0.04013563f, -0.01043574f, -0.03907157f, -0.01842093f, 0.01210964f, 0.00494272f, -0.10164835f, 
    -0.07091474f, -0.00737580f, -0.09317783f, -0.04391061f, -0.06903121f, -0.08918259f, 0.02800832f, -0.00073986f, 
    0.02371444f, -0.06005611f, -0.04824961f, 0.02018611f, -0.03667163f, 0.01615669f, -0.02739977f, -0.08764376f, 
    -0.01462640f, -0.04513461f, -0.05791758f, 0.06460475f, -0.04948597f, 0.01556966f, -0.08573218f, -0.08757271f, 
    -0.01737142f, -0.01650795f, -0.07797595f, -0.00381230f, -0.01513560f, -0.10402113f, -0.04768062f, -0.07141240f, 
    -0.05922205f, 0.03365530f, -0.05505560f, 0.03016509f, -0.04710687f, 0.01284682f, -0.03428280f, -0.03631052f, 
    0.00684190f, -0.08472370f, -0.09810746f, -0.06685938f, -0.02545017f, -0.04581251f, -0.02149629f, -0.05088680f, 
    -0.04321689f, -0.02389620f, -0.07948761f, -0.09341819f, 0.02440944f, -0.03252130f, -0.08853289f, -0.09689426f, 
    0.02038381f, 0.03564157f, 0.00598542f, -0.08774545f, 0.00265478f, -0.06421247f, -0.02137876f, -0.04717560f, 
    -0.03645252f, -0.06797072f, -0.07020505f, -0.01310433f, -0.08230411f, 0.01244177f, -0.03032257f, -0.04468656f, 
    -0.07870819f, -0.07044467f, 0.02464865f, 0.01341899f, -0.02894176f, 0.03294139f, -0.05698385f, -0.07531311f, 
    0.03448745f, 0.00392474f, -0.05901854f, 0.02349527f, 0.01220570f, -0.01253012f, -0.08452329f, -0.00616625f, 
    0.02547644f, 0.12109927f, 0.05891626f, 0.15981969f, 0.03251746f, 0.07106642f, 0.05291037f, -0.06057002f, 
    -0.16205876f, -0.10374637f, -0.09057608f, -0.10612071f, -0.08971378f, 0.15180281f, -0.05012732f, 0.08087301f, 
    -0.07074121f, 0.03117272f, 0.03807588f, -0.00961387f, -0.02224425f, 0.08151037f, 0.04041177f, -0.19572151f, 
    0.02209420f, -0.11325864f, -0.11648346f, -0.15894285f, 0.03865101f, 0.09022202f, -0.04460607f, -0.03624911f, 
    0.00138276f, 0.10073461f, -0.10374223f, -0.27492237f, 0.01639491f, 0.08764096f, 0.23665276f, -0.21011236f, 
    -0.11534683f, -0.01777953f, 0.16314586f, 0.22688359f, 0.11484906f, 0.11800132f, 0.02279354f, 0.05606461f, 
    -0.08505272f, 0.18570419f, 0.06744613f, -0.14181845f, -0.05827105f, -0.09979503f, -0.15049590f, -0.06835450f, 
    -0.12874053f, 0.10839312f, -0.01889919f, -0.06743483f, 0.01021878f, -0.07926738f, -0.10939652f, 0.09178021f, 
    0.15640591f, 0.05778623f, 0.06106735f, 0.01638114f, 0.04065143f, 0.13070507f, 0.06261835f, 0.03854541f, 
    0.03356465f, -0.17238161f, -0.20714493f, -0.00577719f, 0.15236314f, -0.30985719f, -0.17887971f, -0.18551263f, 
    -0.04234479f, 0.01223124f, -0.00452505f, -0.06530549f, 0.14015675f, 0.31710032f, 0.33197388f, -0.20378712f, 
    -0.06256844f, 0.10930078f, 0.08811953f, 0.07246081f, -0.08733084f, -0.11710634f, 0.05477940f, -0.01393636f, 
    -0.22746956f, 0.04513937f, -0.47560090f, 0.03790114f, 0.09139059f, 0.13315317f, 0.01529780f, -0.02634055f, 
    -0.05006525f, 0.05497759f, 0.04840891f, -0.01615522f, 0.00769216f, 0.23658423f, -0.05697109f, -0.14514443f, 
    0.10842232f, -0.00891917f, 0.01739716f, 0.10860822f, 0.19531901f, 0.05080343f, 0.05500911f, 0.08533649f, 
    0.02015482f, -0.20433289f, -0.04713208f, 0.12858504f, 0.01107925f, -0.00123987f, 0.05488462f, 0.02410576f, 
    0.07604498f, 0.05790337f, 0.14255971f, 0.07068752f, -0.24254462f, 0.38391617f, -0.08559044f, 0.13875367f, 
    -0.01405371f, 0.00992635f, -0.05824670f, -0.06503819f, -0.07036845f, 0.12514013f, 0.09569813f, 0.17876826f, 
    -0.02227253f, 0.00479333f, -0.08867636f, -0.11990262f, -0.12152504f, 0.15560386f, 0.13050543f, 0.07902288f, 
    0.06223725f, -0.02388178f, 0.03910511f, 0.09530868f, -0.10791811f, 0.16921394f, 0.17288414f, 0.12706196f, 
    -0.00632742f, 0.01771832f, -0.02560455f, -0.02507334f, 0.02487763f, -0.05048733f, 0.12982346f, 0.15225863f, 
    -0.12523425f, -0.19893529f, 0.03933671f, -0.07195303f, -0.10236587f, -0.12049204f, 0.03621198f, -0.11853901f, 
    -0.09832892f, -0.01692575f, 0.11006913f, -0.01186747f, 0.21486275f, -0.12053432f, -0.14050974f, 0.14486150f, 
    -0.17908639f, 0.09762394f, -0.06136462f, -0.10144126f, -0.07115366f, -0.15507355f, 0.26831841f, 0.11420425f, 
    -0.08331355f, 0.00570949f, 0.17341752f, -0.14072619f, -0.06395625f, -0.09202006f, -0.01119699f, -0.02894830f, 
    0.10658020f, 0.01947248f, 0.03396394f, -0.09389290f, -0.00239437f, 0.09735530f, -0.04188894f, -0.11035120f, 
    -0.00989883f, 0.03363768f, 0.02650666f, 0.02471594f, 0.14565516f, 0.03279250f, -0.03538120f, 0.02998792f, 
    -0.21690284f, -0.05868713f, 0.06270821f, 0.06705725f, 0.02160313f, 0.04798910f, 0.06543826f, 0.01458942f, 
    0.01194278f, -0.04008012f, 0.01835246f, 0.05275186f, 0.49792969f, 0.03854524f, 0.08036795f, 0.13185032f, 
    0.14634196f, -0.08731901f, 0.10593718f, -0.02215548f, -0.06063478f, -0.04737879f, 0.09142105f, -0.02982489f, 
    0.06198120f, -0.06126932f, 0.10664166f, 0.24298784f, 0.10098518f, -0.05119095f, 0.02707493f, 0.08941402f, 
    0.10212865f, 0.00816732f, -0.03413455f, 0.02534250f, -0.25491247f, -0.09353099f, -0.09219100f, -0.21455026f, 
    -0.12520556f, -0.15127079f, -0.09750776f, -0.09890369f, 0.09242494f, 0.01259451f, 0.08495285f, 0.08842120f, 
    -0.29418036f, -0.18835337f, -0.05814756f, -0.00766047f, 0.03844263f, 0.21446536f, -0.03804246f, -0.04747996f, 
    0.03449792f, -0.11143689f, 0.10249043f, 0.09219955f, 0.25803128f, 0.08277532f, -0.10445612f, 0.11048365f, 
    -0.06520204f, -0.19380195f, 0.11679523f, -0.01122622f, 0.04346006f, 0.13760607f, 0.06769349f, 0.05925772f, 
    -0.03878791f, -0.29362136f, 0.05257260f, 0.22254483f, 0.12039829f, 0.07321384f, -0.05058008f, -0.02955071f, 
    0.13807729f, -0.08926032f, 0.01557306f, 0.05714589f, -0.11645425f, 0.01636683f, 0.04434710f, 0.17550492f, 
    0.01618419f, 0.14976494f, 0.08797238f, -0.24937908f, 0.16343626f, 0.08861308f, 0.07771376f, -0.06153579f, 
    -0.20810410f, 0.16269781f, 0.06116251f, 0.00971422f, 0.02533266f, 0.07064666f, 0.03504451f, -0.09872992f, 
    0.08001520f, 0.03606243f, 0.01888102f, 0.25997016f, -0.10834533f, -0.23732066f, 0.05142999f, -0.27873069f, 
    -0.19453788f, -0.26904854f, -0.06996451f, -0.06057182f, 0.06986418f, 0.15344711f, 0.11574984f, 0.19337258f, 
    0.10096494f, 0.21501267f, -0.11797738f, -0.11983982f, -0.10175341f, -0.13350379f, 0.07110102f, 0.03365852f, 
    0.07811377f, 0.05368932f, 0.14875336f, 0.20067972f, -0.09704205f, 0.02884430f, -0.17133377f, -0.08497465f, 
    -0.25763091f, 0.07614235f, -0.04401924f, -0.00464449f, 0.16839103f, 0.00957711f, 0.00524554f, -0.05030823f, 
    -0.21262766f, -0.28933215f, 0.01403083f, -0.04726785f, 0.14368775f, -0.04156705f, -0.02068161f, 0.07258204f, 
    -0.09619794f, -0.05579019f, -0.19551440f, -0.09709311f, 0.08220388f, 0.42820960f, -0.04825167f, -0.11297988f, 
    0.03465063f, -0.09838204f, -0.13527863f, 0.12250135f, 0.04041600f, 0.00705573f, 0.13620152f, -0.06050150f, 
    -0.10146765f, 0.09556676f, 0.15059884f, 0.07258120f, -0.12362909f, -0.05395292f, -0.14431331f, -0.14923897f, 
    -0.03322477f, -0.00708131f, -0.10863431f, -0.32748157f, 0.00558121f, 0.18303800f, 0.06660528f, -0.20175014f, 
    -0.03640607f, -0.07159957f, 0.03879280f, -0.07079199f, 0.07619876f, -0.07627828f, -0.11457836f, -0.06096420f, 
    -0.15275584f, -0.19185838f, -0.06812054f, 0.11460531f, 0.09944227f, -0.02254914f, 0.00389731f, 0.07062063f, 
    -0.06173803f, -0.07198763f, 0.06354452f, -0.06853643f, 0.53015345f, 0.06302227f, 0.08613951f, -0.09669484f, 
    -0.20981357f, -0.03316336f, 0.08956634f, 0.09534496f, -0.11872346f, -0.09995669f, -0.03862521f, 0.00583949f, 
    -0.22540705f, -0.02428688f, -0.13283642f, -0.11692596f, -0.00612145f, -0.00176444f, -0.04390596f, 0.04282048f, 
    -0.06244827f, 0.01209749f, -0.19694027f, -0.06525034f, -0.03320605f, 0.06096115f, -0.11961789f, -0.11872776f, 
    0.02122124f, 0.13257116f, -0.17211144f, 0.02926342f, 0.26383203f, 0.18463753f, 0.17806561f, 0.10874437f, 
    -0.04657519f, -0.05623659f, 0.05955835f, 0.22893175f, -0.02387048f, 0.02074065f, 0.02284942f, -0.08667582f, 
    -0.24410343f, -0.17675889f, -0.07154378f, -0.10875168f, 0.56439018f, 0.09811389f, 0.29439110f, -0.09783398f, 
    0.07081230f, -0.04718405f, -0.06851891f, 0.03905117f, 0.06374163f, 0.00662727f, 0.08516815f, -0.10363209f, 
    0.16609728f, -0.05275569f, -0.23069674f, 0.16573662f, 0.20975436f, 0.07663298f, 0.17935434f, 0.08648074f, 
    0.10133319f, -0.06004345f, -0.00152697f, 0.01888738f, 0.02372173f, 0.16432737f, 0.09560306f, 0.31795216f, 
    -0.04069597f, 0.05042857f, -0.00027892f, 0.20025140f, 0.14404589f, 0.08371343f, 0.03276853f, -0.07897766f, 
    0.02291159f, 0.00206381f, 0.20124462f, 0.17677131f, 0.07654589f, 0.09026198f, 0.03885969f, 0.04829976f, 
    0.07889559f, 0.14321509f, 0.09085794f, 0.28514209f, -0.06069854f, 0.03470816f, -0.06088517f, -0.13249291f, 
    -0.07224891f, -0.17420217f, 0.01305392f, -0.06348677f, 0.02407993f, 0.11642330f, 0.05250591f, 0.11006223f, 
    0.40355936f, 0.36264709f, -0.09513666f, -0.02710256f, -0.02144591f, -0.08432173f, -0.05077497f, 0.02241159f, 
    0.23117898f, 0.08065054f, 0.03924964f, 0.03009395f, -0.09173111f, 0.28180450f, 0.07940622f, -0.05009351f, 
    -0.07167812f, 0.07505570f, -0.08081564f, -0.10865082f, 0.10786507f, -0.24844034f, -0.18973629f, 0.03674824f, 
    -0.01808116f, -0.08300140f, 0.07934098f, 0.05514046f, 0.13985306f, -0.09470531f, 0.02046936f, -0.04607966f, 
    0.00692664f, 0.15905142f, 0.07044013f, -0.00575311f, -0.29839244f, 0.21695431f, -0.17841360f, 0.12895361f, 
    -0.02878954f, -0.12113391f, -0.02294623f, -0.12706365f, -0.09350438f, -0.12469219f, 0.12219450f, 0.01120513f, 
    0.02992547f, -0.02757037f, -0.00520068f, -0.08023067f, 0.04774098f, -0.06228186f, 0.01567771f, -0.07301616f, 
    -0.04860226f, 0.03349921f, 0.05468399f, 0.04412129f, -0.06053323f, -0.03620993f, -0.06902257f, 0.00761459f, 
    -0.01194610f, -0.00163388f, -0.00819963f, 0.05915401f, 0.01455278f, 0.05335555f, -0.01716472f, -0.02551041f, 
    0.04609561f, 0.04534812f, -0.06840071f, -0.05422424f, 0.06055333f, 0.05926921f, -0.07630517f, -0.00903504f, 
    -0.02319002f, -0.06418639f, 0.04340568f, 0.04440872f, -0.03086433f, -0.00106157f, 0.01615728f, 0.03594344f, 
    0.02664997f, -0.03695321f, 0.00968002f, 0.03648108f, 0.05342627f, 0.04167563f, 0.00297125f, -0.03487268f, 
    -0.06272495f, 0.02323103f, -0.00866625f, -0.03499370f, -0.04812166f, 0.06174824f, 0.00720175f, 0.01588685f, 
    0.05692521f, -0.07928126f, -0.01941502f, -0.03168436f, 0.02990232f, -0.03847525f, -0.07562843f, -0.05343791f, 
    -0.03421418f, -0.05715971f, -0.00861591f, -0.07922003f, 0.03106229f, -0.04983660f, -0.03048777f, -0.04541041f, 
    -0.04484009f, -0.02865134f, -0.05688164f, -0.02931336f, 0.00349080f, -0.00433595f, 0.01322086f, -0.05774312f, 
    -0.07379942f, -0.05986105f, -0.05697910f, 0.06249858f, -0.07571191f, -0.01409686f, 0.00269165f, -0.00749972f, 
    0.03894372f, -0.04035691f, -0.06711314f, -0.04736849f, -0.03601952f, 0.00808442f, -0.00463864f, 0.03843699f, 
    0.05481792f, 0.00693806f, 0.03324487f, -0.01354204f, -0.05086121f, 0.03450540f, -0.04192660f, -0.00174335f, 
    -0.07135668f, -0.02877121f, 0.05810243f, -0.07197628f, 0.02882132f, -0.05546908f, 0.01692325f, -0.01672296f, 
    -0.05849617f, -0.04856074f, -0.03403646f, -0.06203561f, -0.04323221f, -0.06168417f, -0.05809565f, 0.04912011f, 
    -0.02258661f, -0.01278738f, 0.02013822f, 0.02983552f, -0.00042785f, -0.04647044f, -0.04887114f, 0.00149118f, 
    -0.01457952f, -0.06948919f, 0.00434171f, 0.04319695f, 0.04706975f, -0.04067443f, 0.04091981f, -0.06521237f, 
    0.01430480f, 0.06062279f, 0.00912449f, 0.02257587f, 0.02332485f, -0.01811329f, -0.01218666f, -0.02087470f, 
    -0.05600044f, 0.00969220f, -0.07968802f, -0.06691501f, 0.01282058f, 0.02641524f, -0.07009330f, -0.03059228f, 
    -0.01736494f, -0.01669960f, -0.01574082f, -0.05769110f, 0.01422790f, -0.02761400f, 0.05812821f, -0.07579491f, 
    0.01476692f, -0.02179549f, 0.03827262f, -0.00777182f, 0.02046124f, -0.03902682f, -0.02122490f, -0.06209056f, 
    -0.07112728f, 0.04144311f, 0.02898735f, -0.01302205f, 0.01929424f, 0.06044574f, -0.04202510f, -0.01053811f, 
    0.02429170f, 0.04876215f, 0.05712410f, 0.02786678f, -0.05716401f, -0.00547742f, -0.01076127f, 0.02456244f, 
    0.01025509f, 0.05138499f, -0.05680509f, 0.05422696f, 0.04042817f, 0.01656391f, -0.01299377f, 0.00845998f, 
    0.32809368f, 0.16517934f, 0.22523127f, 0.29514834f, -0.01721560f, -0.00859445f, -0.04415277f, -0.01545921f, 
    0.03932275f, -0.03116835f, 0.04856646f, 0.00894179f, 0.09004454f, 0.17137964f, 0.14391769f, 0.01520700f, 
    0.01070243f, 0.04245151f, 0.02749395f, -0.19676878f, 0.12414089f, 0.29410583f, 0.00787960f, 0.27243391f, 
    -0.04242836f, -0.64371866f, -0.32239628f, -0.16254534f, 0.00262980f, -0.11588958f, -0.25531214f, -0.00952240f, 
    0.22614060f, 0.01731709f, -0.06788711f, -0.01769975f, -0.26338568f, 0.12571523f, 0.00253546f, -0.09772015f, 
    -0.00018851f, -0.06907981f, -0.15299019f, -0.29584396f, -0.02881948f, 0.07851719f, 0.03226580f, 0.01161900f, 
    -0.18800630f, -0.18675914f, -0.38230574f, -0.43954197f, -0.20465882f, -0.02632624f, 0.03244623f, 0.03142623f, 
    0.10301223f, -0.06296051f, -0.06661558f, -0.02675966f, 0.11492781f, 0.12478109f, 0.11404517f, 0.26852807f, 
    -0.02320546f, -0.17809202f, -0.03153957f, -0.18587810f, -0.03182469f, -0.06632587f, -0.01065630f, -0.07342783f, 
    0.02824241f, -0.21755184f, -0.07295026f, -0.20700046f, 0.08263551f, 0.20007572f, 0.09413131f, 0.23851210f, 
    0.10438486f, 0.08552307f, 0.01528351f, -0.17975788f, -0.01503065f, 0.28964928f, 0.19325566f, 0.28849065f, 
    -0.03587958f, -0.15576085f, 0.04629830f, -0.12953939f, 0.19083545f, 0.03210815f, 0.00655380f, 0.14675504f, 
    -0.17913522f, 0.07725080f, 0.15507719f, -0.32297346f, 0.05153615f, 0.04667790f, 0.06807065f, 0.05778878f, 
    -0.24109931f, 0.14498685f, -0.09989642f, -0.10807735f, 0.22045495f, -0.14115721f, -0.40659267f, 0.14665647f, 
    0.11373515f, 0.09361695f, -0.02010111f, 0.16883391f, -0.04125334f, -0.15898854f, 0.01600775f, -0.09952104f, 
    -0.08867510f, -0.26884985f, -0.41895798f, 0.26376474f, -0.03120540f, 0.18099262f, 0.10119830f, -0.02130486f, 
    0.09014004f, -0.21371514f, -0.11407842f, -0.04108249f, 0.18029745f, 0.10459855f, 0.15894340f, -0.17608351f, 
    -0.18502645f, -0.14535041f, -0.16847889f, -0.16185275f, -0.04974452f, -0.09605867f, 0.02007721f, 0.22219279f, 
    0.02890928f, -0.10572253f, 0.01912085f, 0.06456970f, -0.15004618f, 0.06982297f, 0.07918494f, 0.05491592f, 
    -0.00242542f, -0.11005551f, -0.07121950f, 0.06699212f, 0.24998470f, 0.15096653f, 0.15860216f, 0.00819580f, 
    -0.11226815f, -0.07631362f, -0.07916459f, -0.14851852f, -0.01676264f, 0.11786184f, 0.18321185f, -0.07446743f, 
    -0.24612379f, -0.05093962f, -0.06310737f, -0.07691181f, 0.07292970f, 0.33231729f, 0.04574322f, 0.12650561f, 
    -0.15306515f, -0.11642323f, -0.10938121f, -0.09613159f, 0.17905059f, 0.38424298f, 0.22432570f, 0.13225992f, 
    -0.23599423f, 0.01981508f, -0.12596086f, -0.09519848f, 0.06097485f, 0.03421833f, 0.08053546f, -0.03185509f, 
    0.18646224f, 0.14164789f, -0.23172605f, 0.10662254f, -0.03569797f, -0.03196674f, -0.02692977f, -0.12904754f, 
    0.18348208f, -0.09556818f, -0.14089407f, 0.01469352f, -0.24783973f, -0.23312522f, -0.07417845f, -0.08161197f, 
    -0.12354977f, -0.02178158f, -0.02676396f, 0.00554628f, 0.00502559f, -0.00564515f, 0.08312567f, 0.10494956f, 
    -0.23713444f, -0.00863065f, 0.15285000f, 0.21849333f, -0.01626272f, -0.17991194f, -0.05409564f, 0.04834715f, 
    -0.00274499f, 0.09452443f, 0.00968092f, 0.01271048f, 0.63131720f, 0.11755165f, -0.20581752f, -0.03659249f, 
    0.00760153f, -0.03451321f, 0.23592842f, 0.09160163f, 0.01531708f, 0.01680478f, -0.05896013f, 0.15414186f, 
    0.25309324f, 0.33171853f, 0.17334811f, 0.21242940f, 0.01078935f, -0.11329187f, 0.02949948f, 0.03857821f, 
    -0.07670487f, 0.06335758f, -0.06736050f, 0.10696868f, -0.10873336f, -0.17094572f, -0.06540877f, -0.11166642f, 
    -0.09175577f, -0.03594892f, 0.04814519f, 0.05973227f, 0.13055798f, 0.03275144f, 0.19900572f, -0.03933270f, 
    -0.18011031f, 0.09766207f, 0.13012722f, 0.23907146f, 0.01145819f, 0.02891606f, -0.01966782f, 0.03411216f, 
    0.09246676f, 0.04348416f, -0.05164828f, 0.06190725f, 0.05708124f, -0.35018629f, -0.16885085f, -0.18552974f, 
    -0.12208314f, 0.04342978f, -0.10669811f, -0.09631829f, -0.08972362f, 0.09476299f, 0.00175479f, -0.15299150f, 
    -0.19484860f, -0.03220298f, 0.00248232f, 0.17966093f, -0.02295676f, 0.08291741f, 0.04612476f, -0.04989190f, 
    -0.14593537f, 0.07463614f, -0.00623680f, 0.08436419f, -0.29268694f, 0.28317004f, 0.00108306f, 0.08252104f, 
    -0.04998657f, 0.07781442f, -0.01078659f, 0.02983414f, 0.04786507f, 0.03637356f, 0.19549443f, 0.00158526f, 
    0.09493612f, 0.10706802f, 0.31767157f, 0.04913588f, -0.00853687f, 0.03084931f, 0.21873078f, -0.01169283f, 
    0.07259379f, -0.04657229f, -0.10895240f, -0.12679733f, -0.16398078f, 0.23986268f, 0.04281569f, 0.10942999f, 
    -0.13901119f, -0.09992427f, 0.00220721f, -0.00380719f, -0.00309490f, -0.02768695f, -0.01362964f, 0.04652997f, 
    -0.02228707f, 0.02819312f, -0.12247157f, 0.21143189f, 0.07364880f, -0.05262583f, -0.24264655f, 0.14493939f, 
    -0.10389043f, 0.07398602f, 0.24726596f, 0.04056177f, -0.47255179f, -0.02388013f, -0.01990235f, -0.24611504f, 
    -0.04709432f, 0.01133262f, -0.08232542f, 0.00758427f, -0.05346142f, 0.13908455f, -0.02723296f, 0.01079255f, 
    0.09703211f, -0.01906271f, 0.17687045f, 0.17589454f, -0.05105259f, -0.04322290f, 0.17804183f, 0.10795582f, 
    0.10363934f, 0.10114182f, 0.16799437f, 0.09025276f, -0.50944090f, -0.23716804f, 0.02302750f, 0.09946173f, 
    0.19643131f, -0.01106741f, -0.18887483f, -0.01437280f, -0.09854395f, -0.00917342f, -0.14925107f, 0.12933886f, 
    0.27750057f, 0.03665090f, -0.07002506f, 0.23535544f, -0.07862008f, 0.01803879f, -0.05196171f, -0.18209498f, 
    0.07704642f, 0.11388984f, -0.01683491f, 0.10784864f, -0.10236393f, -0.01642923f, -0.20471942f, -0.19824068f, 
    -0.19865157f, 0.03843146f, -0.20802522f, -0.14900196f, 0.01050484f, 0.03303105f, 0.09178949f, -0.01215451f, 
    -0.06555755f, -0.05552520f, 0.01549512f, 0.15240389f, -0.01022315f, -0.05987720f, 0.09518470f, 0.04133876f, 
    -0.05096140f, 0.12302425f, 0.06716716f, 0.11777675f, 0.13617387f, -0.08660416f, -0.23250124f, -0.13587256f, 
    -0.01647609f, -0.12056087f, 0.01248007f, 0.03719002f, -0.16670138f, -0.06787805f, 0.06329859f, 0.22181430f, 
    0.09496187f, 0.08559311f, 0.02235135f, 0.14911501f, 0.03942160f, -0.07741806f, 0.06324134f, -0.29246962f, 
    -0.01594516f, -0.03242765f, -0.14189109f, 0.10928353f, 0.04052088f, -0.03011177f, 0.13467436f, -0.13413885f, 
    0.16011888f, -0.11202122f, -0.19165134f, -0.00090140f, -0.02277990f, -0.23817120f, -0.01363216f, -0.45376679f, 
    -0.03348915f, 0.06309906f, 0.20366757f, 0.17637834f, 0.05713471f, 0.03870157f, 0.15410836f, 0.26890603f, 
    0.18533678f, 0.04701254f, -0.09665964f, 0.00643676f, 0.32141265f, 0.00550950f, -0.07499414f, -0.63574928f, 
    -0.16374515f, -0.00814633f, -0.16245714f, -0.05526438f, -0.03215255f, -0.08743287f, 0.08934945f, -0.13565247f, 
    -0.04196651f, -0.06356663f, 0.08365356f, 0.24571876f, 0.05279922f, 0.05813074f, 0.16718414f, -0.07754857f, 
    0.03086501f, 0.14744949f, -0.05148240f, 0.16963342f, -0.28867334f, 0.05093100f, 0.04322679f, 0.20863946f, 
    0.14763640f, 0.02637924f, 0.10921081f, 0.19186617f, -0.03737390f, 0.05460058f, -0.04938866f, 0.10387909f, 
    -0.07161191f, -0.13429371f, 0.25609192f, 0.21398766f, 0.17771871f, 0.02958927f, 0.12167691f, 0.13672294f, 
    -0.06699002f, 0.06107657f, 0.05523738f, -0.07989969f, 0.12670596f, 0.19987655f, -0.16255823f, -0.07725342f, 
    0.25059772f, 0.14308482f, -0.13000028f, -0.29404590f, -0.07907057f, -0.17439845f, -0.06252266f, 0.01573985f, 
    0.21669565f, 0.27117172f, -0.26804554f, 0.20262891f, 0.01804795f, -0.09228801f, -0.16688295f, -0.12004621f, 
    -0.10025685f, 0.18472645f, -0.21050422f, -0.17066541f, -0.40682977f, 0.04750933f, -0.08588145f, -0.24967921f, 
    -0.00215536f, 0.25724897f, -0.29684389f, -0.18158418f, 0.02412760f, -0.04588039f, -0.08630488f, 0.22654358f, 
    -0.02527146f, -0.01847951f, -0.04697794f, 0.14376563f, -0.12000909f, 0.13031600f, 0.27660248f, 0.10127118f, 
    0.02661004f, 0.18286812f, -0.03323018f, 0.00698750f, -0.50267655f, -0.09730093f, 0.11025073f, 0.28600189f, 
    0.09438829f, 0.16541773f, 0.06487653f, -0.15386672f, -0.09940734f, -0.01794499f, -0.15317155f, 0.01517629f, 
    -0.34089434f, -0.01567478f, 0.17172551f, -0.20626932f, 0.01612375f, -0.10946476f, -0.09973354f, 0.01787672f, 
    -0.21828270f, -0.08632079f, -0.02085344f, -0.10556299f, 0.00953060f, 0.05310021f, 0.08584040f, -0.02004294f, 
    -0.02320509f, -0.08543369f, 0.04917707f, -0.05587624f, 0.05344093f, -0.06740857f, 0.00744986f, 0.01646211f, 
    0.37480703f, 0.14676318f, -0.10746143f, -0.02075036f, 0.20260812f, 0.20401728f, -0.01965195f, -0.02319051f, 
    -0.08458433f, -0.00216657f, 0.03423708f, 0.05124851f, -0.09376405f, -0.12390553f, 0.23167777f, 0.12575039f, 
    0.04218425f, 0.07387962f, -0.16000919f, -0.04661701f, -0.00343749f, 0.08552554f, 0.09918337f, -0.03738162f, 
    -0.13006844f, -0.31067604f, -0.14881457f, 0.10510667f, 0.02786083f, 0.11426996f, -0.03289483f, -0.02602170f, 
    0.00178850f, -0.06269300f, -0.01323254f, -0.02364596f, -0.16816786f, -0.05636367f, -0.16885450f, -0.06546628f, 
    -0.17566037f, 0.16612545f, 0.00847720f, -0.08699673f, -0.03284331f, 0.10371897f, -0.06514287f, -0.01733736f, 
    0.16435099f, -0.06910396f, -0.03890285f, -0.03082569f, 0.07327785f, 0.08086090f, -0.02126639f, 0.01035035f, 
    -0.00449726f, -0.00781654f, -0.08324626f, 0.04354349f, -0.00101947f, 0.02320965f, 0.03243236f, 0.26335981f, 
    0.19177328f, -0.17088760f, -0.03004684f, -0.04021549f, 0.08426446f, 0.04631008f, -0.16369954f, 0.21469769f, 
    0.31037399f, 0.09978438f, 0.05646401f, -0.04951293f, 0.10772429f, -0.05440351f, 0.20906350f, 0.16675973f, 
    0.12822130f, 0.06732130f, -0.06116107f, 0.02407146f, 0.29674965f, -0.17936201f, 0.25149113f, 0.08720323f, 
    -0.01869034f, 0.08699199f, -0.12102473f, -0.10136903f, -0.05468103f, -0.21333508f, 0.00965973f, 0.04144957f, 
    0.12347654f, 0.20467360f, -0.06485284f, 0.05066950f, 0.08700527f, 0.19213051f, 0.10895437f, -0.08341467f, 
    -0.00320710f, 0.13577831f, -0.05572261f, 0.23717175f, -0.19734116f, -0.46663636f, -0.03978867f, -0.14098671f, 
    0.10429505f, 0.12664539f, 0.05881732f, -0.01196866f, 0.03757124f, 0.05674938f, 0.09558346f, 0.07485695f, 
    -0.04093114f, 0.01883185f, -0.01053722f, -0.08006524f, -0.05531076f, -0.10676792f, 0.18248469f, -0.11857675f, 
    0.07528450f, -0.13368993f, 0.07710245f, 0.07226130f, 0.04460692f, -0.14143616f, -0.24745294f, -0.10904382f, 
    -0.12680781f, -0.05875809f, 0.14646526f, -0.06591065f, 0.02000018f, -0.03161389f, 0.11393391f, -0.08584298f, 
    0.11616940f, 0.07356428f, 0.04229595f, 0.19311710f, 0.11126322f, 0.13513614f, -0.08142696f, 0.04958139f, 
    -0.01896717f, 0.01556705f, -0.04682720f, 0.01533677f, 0.16360414f, 0.49238211f, -0.41606167f, -0.23063357f, 
    -0.09767842f, -0.10358535f, 0.06653442f, 0.14392050f, 0.11782079f, 0.00104877f, 0.11825740f, 0.09025680f, 
    0.02235475f, -0.09599047f, -0.10352933f, -0.00912234f, 0.00873242f, -0.05981849f, -0.00840104f, 0.03390132f, 
    0.13511091f, -0.07373469f, -0.01102416f, 0.13300790f, 0.03263330f, -0.33998412f, 0.07172544f, 0.10093714f, 
    0.03695252f, -0.01099169f, -0.12723042f, -0.03320212f, 0.05875583f, 0.07298467f, 0.11449873f, 0.18094140f, 
    -0.39742675f, 0.15552157f, 0.18145746f, 0.05245548f, -0.04037816f, 0.00383416f, 0.10580236f, 0.15552568f, 
    -0.03261666f, -0.06019801f, -0.03038229f, 0.09996738f, -0.04290385f, 0.16397730f, -0.28547946f, 0.02996701f, 
    0.05383274f, -0.01572949f, 0.10649618f, -0.03719933f, 0.10355560f, 0.08245740f, 0.03797905f, 0.17166394f, 
    0.12225841f, 0.36745384f, 0.22561868f, 0.29272857f, 0.01201547f, -0.12805067f, 0.09595614f, 0.03241229f, 
    0.06545991f, 0.05272200f, 0.18747683f, 0.07761890f, 0.03718266f, -0.24756931f, -0.03421462f, -0.08866127f, 
    0.06996152f, 0.09914189f, 0.02148993f, -0.11992025f, 0.04998119f, -0.18325478f, 0.01800075f, 0.01005344f, 
    -0.09050634f, 0.15553455f, 0.23980054f, -0.04396864f, 0.02294289f, 0.13734484f, -0.07220016f, -0.03054661f, 
    -0.12293875f, 0.10225365f, 0.01651506f, -0.06888604f, -0.38291281f, -0.10812891f, -0.32504204f, 0.14712228f, 
    -0.02343803f, -0.00131302f, -0.06086617f, -0.17573287f, 0.05885514f, -0.04887021f, -0.10073751f, -0.01911235f, 
    0.21527894f, -0.12749065f, 0.36883080f, -0.13241592f, 0.00615647f, 0.08570144f, -0.08088738f, -0.04407381f, 
    -0.06293257f, 0.01138434f, -0.05853152f, -0.04839636f, -0.05658702f, 0.06496448f, -0.21435855f, 0.16488512f, 
    0.10421038f, 0.09972039f, 0.02096899f, 0.12547338f, 0.02030690f, -0.06668612f, 0.05772501f, 0.01531134f, 
    0.03289153f, 0.18694431f, 0.12170180f, -0.20584658f, -0.03415891f, 0.02499790f, -0.25973144f, -0.10275322f, 
    0.06880874f, 0.07246821f, 0.15259098f, 0.04129896f, 0.23014431f, -0.19245404f, 0.23910476f, 0.10885538f, 
    0.03339009f, 0.00863365f, 0.08209791f, 0.00952127f, 0.14688769f, -0.00294300f, -0.01227309f, -0.01670752f, 
    0.15372972f, -0.25146723f, -0.03124745f, 0.15833227f, 0.28566009f, 0.14159340f, -0.04554009f, 0.01784437f, 
    -0.09592517f, -0.06275812f, 0.20239867f, 0.14505245f, -0.04595848f, -0.35182744f, 0.02331637f, -0.05388600f, 
    0.02430169f, 0.00399043f, -0.06706530f, 0.04541943f, 0.07394688f, 0.08954152f, -0.04082771f, 0.04203168f, 
    0.07146047f, 0.06534195f, 0.03463515f, -0.11552407f, 0.02757977f, 0.08952767f, 0.01248580f, 0.07699454f, 
    0.04647409f, -0.10673496f, -0.03912358f, 0.05342684f, -0.10966971f, -0.15886876f, 0.43574375f, 0.03108658f, 
    0.02938690f, 0.14780226f, -0.19661796f, 0.14478193f, -0.00211210f, 0.03035164f, -0.11810183f, -0.05125508f, 
    -0.20506001f, 0.18341520f, 0.30327541f, -0.12134889f, -0.16706575f, 0.00600606f, -0.17265943f, 0.02884456f, 
    0.06562926f, 0.17070039f, 0.19122338f, -0.18455656f, -0.07884672f, 0.17469229f, -0.08201765f, -0.17088956f, 
    -0.01885728f, 0.07024588f, 0.02001563f, -0.01674202f, 0.11364380f, 0.09751565f, -0.12291933f, 0.01560548f, 
    0.14513364f, -0.14700435f, -0.03663850f, 0.24459010f, 0.17513697f, 0.08899748f, -0.08222771f, -0.00123646f, 
    -0.01223900f, 0.04806065f, -0.02863589f, 0.07989286f, 0.50098616f, -0.11497813f, 0.00296116f, -0.16985437f, 
    0.08489273f, 0.05650515f, 0.11930119f, -0.03758579f, -0.19508047f, 0.06515225f, 0.09999683f, -0.06846894f, 
    0.03363790f, -0.35357448f, -0.20271508f, 0.04149688f, 0.10727724f, 0.05679145f, -0.02628609f, -0.00516479f, 
    -0.06564266f, 0.04690013f, -0.10089698f, 0.05662733f, -0.00440671f, 0.15434723f, -0.00462089f, -0.09818916f, 
    0.00652095f, -0.06435171f, -0.06988592f, 0.01739141f, -0.06310173f, 0.05516251f, 0.11070425f, -0.15067691f, 
    -0.03506678f, -0.25073436f, -0.02627474f, 0.22326311f, -0.06988929f, -0.01473085f, 0.02579510f, 0.03650191f, 
    -0.02264072f, -0.07371472f, 0.01701185f, -0.06911417f, 0.73082197f, 0.15982099f, 0.11611648f, -0.45495918f, 
    -0.05374483f, -0.04466669f, -0.01797865f, 0.10731038f, 0.10134208f, 0.05961597f, 0.07503701f, -0.15991871f, 
    -0.05111514f, 0.08627622f, -0.30486163f, 0.18765454f, 0.22230570f, -0.06966341f, 0.07902472f, 0.09414690f, 
    0.04278601f, 0.04114477f, -0.01287125f, 0.09437235f, -0.24002555f, -0.26115668f, 0.08609782f, 0.23921487f, 
    -0.01291717f, -0.15801419f, 0.00483218f, -0.00668294f, -0.03128657f, -0.01956829f, -0.00715093f, -0.00309026f, 
    0.10833676f, -0.13063654f, 0.02797436f, 0.33181518f, 0.17648092f, 0.00171379f, 0.11617306f, 0.14644192f, 
    -0.10707075f, 0.19348648f, -0.06383938f, 0.14135218f, 0.14483990f, 0.14188443f, -0.19014624f, -0.24371953f, 
    0.16153505f, 0.13424438f, -0.00054814f, -0.07982640f, 0.00400464f, 0.05386065f, 0.06599548f, 0.04955891f, 
    -0.00400028f, 0.42003232f, -0.20127814f, 0.09879676f, 0.03263889f, -0.10133411f, 0.02771134f, 0.03697439f, 
    0.05492810f, -0.02097718f, 0.07630614f, -0.05282493f, -0.03953826f, 0.12830971f, -0.21765575f, -0.17541988f, 
    0.14450301f, 0.03812165f, 0.01236686f, -0.10760213f, 0.12811702f, -0.12657042f, 0.06743383f, 0.01060234f, 
    0.15721177f, -0.02716418f, 0.04114406f, 0.32969579f, 0.01391138f, -0.08417007f, -0.12576967f, 0.04481827f, 
    -0.08697083f, 0.04732098f, -0.05976362f, 0.05894198f, -0.22707869f, 0.51401126f, -0.46001628f, -0.17841403f, 
    0.05014648f, -0.00453102f, 0.07355024f, -0.17924401f, -0.14123064f, -0.11459747f, 0.02945629f, -0.02085208f, 
    0.23476617f, -0.04291992f, -0.11150888f, 0.10992154f, -0.00114112f, 0.01625923f, 0.05796309f, 0.05734747f, 
    0.00984208f, 0.02658403f, 0.04970025f, 0.29945731f, 0.15271698f, -0.14028542f, -0.11932138f, 0.10219580f, 
    0.10861268f, -0.13313122f, -0.07529835f, 0.12162202f, 0.07591346f, 0.19338357f, 0.13734320f, 0.02809663f, 
    -0.38559318f, -0.07714696f, 0.13749455f, -0.10878893f, -0.12784608f, 0.02029398f, 0.25657192f, -0.02420561f, 
    0.01383975f, 0.12394256f, 0.03627610f, 0.12050302f, -0.27519000f, 0.04406298f, -0.17814673f, 0.00855707f, 
    0.10224584f, -0.07660478f, -0.06956596f, 0.05374752f, 0.30575714f, 0.10980864f, 0.17180037f, 0.04587562f, 
    -0.00304292f, 0.33557549f, 0.30823579f, 0.23438665f, -0.07236185f, -0.04501308f, -0.02489005f, -0.15357476f, 
    0.11101127f, -0.03876852f, 0.27152073f, 0.11611225f, -0.03727087f, -0.18945721f, 0.05277319f, -0.00628791f, 
    0.29959962f, -0.06636146f, 0.11211054f, 0.11798823f, -0.06132112f, -0.17656106f, -0.20988287f, -0.02635012f, 
    0.08299357f, 0.14329694f, 0.12060130f, -0.09263983f, 0.11513411f, 0.17135532f, 0.02909812f, -0.08840839f, 
    -0.05956512f, -0.02743023f, 0.02142853f, -0.01971579f, -0.31688136f, -0.07509743f, -0.19692914f, 0.23848748f, 
    -0.00838223f, -0.02274542f, 0.11248324f, -0.04702480f, -0.02599117f, -0.00543543f, 0.01277444f, -0.00008255f, 
    0.11130194f, -0.24088652f, 0.13893102f, -0.04176690f, 0.01399231f, -0.01354963f, 0.01843999f, -0.07168381f, 
    0.09712997f, -0.15828569f, -0.00689793f, 0.01124326f, 0.12927034f, -0.17406511f, -0.21585195f, -0.12724578f, 
    0.09165160f, 0.05251948f, 0.09538858f, -0.13372219f, 0.06392679f, -0.16078058f, 0.07333322f, 0.07368851f, 
    -0.21308523f, -0.00128472f, 0.00805218f, -0.29048046f, 0.07984819f, -0.02820884f, -0.01493312f, -0.01965726f, 
    0.02154425f, 0.00594283f, -0.06861198f, -0.20764725f, 0.07296683f, -0.00363817f, 0.27798367f, 0.13158427f, 
    -0.02100310f, -0.01883750f, -0.06755666f, -0.03676037f, 0.15095907f, -0.04187455f, -0.02924360f, 0.02057835f, 
    0.03870951f, -0.35498419f, 0.07811814f, -0.08182488f, 0.23002768f, 0.08371236f, 0.04191716f, -0.04990358f, 
    -0.02837013f, -0.05708865f, -0.04472985f, 0.02188353f, 0.08280228f, -0.23855679f, 0.09688806f, 0.14411063f, 
    -0.00013305f, 0.00159402f, -0.10329953f, 0.09877585f, 0.02435420f, 0.14866872f, 0.23378098f, 0.12141954f, 
    -0.13513084f, 0.11475669f, -0.05121315f, -0.24942134f, -0.03326288f, -0.15828146f, 0.08487825f, -0.09408487f, 
    0.05576957f, 0.01274273f, -0.08406236f, -0.18564509f, 0.19683591f, -0.33709559f, 0.46872520f, 0.20121507f, 
    0.06199092f, 0.16887289f, 0.00274374f, -0.01103535f, 0.04562984f, 0.12030190f, 0.08383012f, 0.01695691f, 
    -0.05972866f, 0.10024182f, -0.15921366f, -0.10146559f, 0.05422428f, -0.05670973f, 0.01204481f, 0.03224771f, 
    -0.05752659f, 0.13908613f, -0.06933624f, -0.20980574f, -0.06688681f, 0.09563179f, 0.09495904f, -0.04354309f, 
    0.02556069f, -0.02309849f, -0.01098725f, 0.08625728f, -0.03763128f, 0.10143229f, -0.10284765f, -0.18363802f, 
    0.19638504f, 0.21265388f, -0.02352304f, -0.06861594f, -0.03069786f, -0.00179812f, -0.01360781f, 0.18414329f, 
    0.02038839f, -0.08416041f, -0.17300102f, -0.11635262f, -0.52701455f, 0.02814239f, 0.32872161f, 0.04941498f, 
    0.02196738f, 0.09045407f, -0.30771735f, 0.10530518f, -0.00065105f, 0.05542667f, -0.25550613f, -0.11196354f, 
    -0.13566095f, -0.29957774f, -0.12213849f, -0.20388703f, -0.00130669f, 0.10255562f, -0.02971633f, 0.17452064f, 
    -0.03242125f, 0.03419568f, 0.07528411f, -0.28110242f, 0.09517018f, 0.13825011f, 0.05649966f, 0.06422929f, 
    -0.13454938f, -0.01318586f, 0.03971369f, -0.07675460f, 0.05010338f, 0.06101721f, 0.04366434f, 0.09619786f, 
    0.08050901f, 0.13519540f, -0.11609618f, -0.12761821f, 0.17131050f, 0.02361466f, -0.04212111f, -0.01444578f, 
    -0.11150026f, -0.06282924f, -0.15354410f, 0.00209942f, -0.18772826f, 0.29921085f, 0.13759074f, 0.20872110f, 
    -0.02043601f, 0.05191725f, -0.06495859f, -0.07434027f, 0.09784319f, 0.04882387f, -0.00809497f, 0.09579618f, 
    -0.06243924f, 0.13519862f, 0.00636537f, -0.19459115f, -0.03551603f, 0.14540185f, 0.07834128f, 0.19352262f, 
    0.04222459f, -0.02729064f, 0.18658556f, -0.05373624f, 0.35213017f, 0.16752593f, 0.02717204f, -0.17636469f, 
    -0.03215984f, 0.18818180f, -0.07132433f, -0.17160678f, -0.03247077f, -0.06024822f, -0.10163843f, -0.09348357f, 
    0.12099943f, 0.03464789f, -0.15393086f, 0.12478451f, 0.00364790f, 0.20159125f, 0.09299926f, -0.13360612f, 
    0.17913394f, -0.08320295f, 0.25754407f, 0.08724061f, -0.01185491f, 0.13048592f, -0.02540832f, -0.08404858f, 
    -0.06073111f, -0.07644028f, -0.07159204f, 0.02752416f, -0.13751504f, 0.07116038f, -0.14337647f, -0.02084428f, 
    -0.01707498f, 0.08130631f, 0.09098901f, -0.13303153f, -0.17251854f, -0.01087229f, 0.09112605f, 0.09843872f, 
    0.00707615f, 0.08670927f, -0.04257739f, 0.06466582f, 0.05472705f, -0.05825378f, 0.18202440f, -0.08147456f, 
    -0.05835170f, -0.01010827f, 0.00042529f, -0.00535680f, 0.00495104f, 0.13163060f, 0.09646897f, 0.00872124f, 
    -0.00661330f, 0.15116504f, 0.10739910f, -0.01441226f, 0.04442698f, 0.12230994f, 0.13270362f, 0.26162353f, 
    -0.08032621f, 0.06096007f, 0.14706789f, 0.08436011f, 0.67222279f, -0.32609057f, 0.03793995f, 0.01451908f, 
    -0.09159957f, -0.14520080f, -0.07967056f, 0.18508178f, 0.13297266f, 0.16648269f, -0.00629233f, -0.01732635f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06681296f, 0.00972690f, 0.00438623f, 0.25997445f, 0.12640882f, 0.29080003f, 0.13143225f, -0.06108719f, 
    0.01925716f, -0.00259391f, 0.08833344f, -0.06169515f, 0.03541707f, 0.17386189f, 0.02766212f, -0.04121016f, 
    -0.06280341f, -0.00993018f, 0.21819530f, 0.18159561f, -0.09538600f, -0.00172728f, -0.07507384f, 0.05716136f, 
    -0.00511310f, 0.07326811f, -0.06808832f, -0.01544476f, 0.28011736f, 0.07434201f, 0.20054741f, -0.03190617f, 
    0.12209535f, 0.17513826f, -0.05206398f, 0.22603129f, 0.17456844f, 0.05753750f, -0.05998407f, 0.17185970f, 
    -0.10990635f, -0.01431900f, -0.07653397f, 0.01782916f, 0.19595817f, -0.06460889f, 0.13443981f, 0.03550312f, 
    -0.16222166f, 0.25077984f, -0.05995176f, -0.03153391f, 0.13902795f, 0.08448432f, 0.11539612f, -0.04527131f, 
    0.13182802f, 0.17436053f, -0.00476571f, 0.06790076f, 0.15674211f, -0.16013224f, 0.23239681f, 0.07137807f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03611299f, -0.11290096f, -0.17820166f, -0.13001554f, 0.07308318f, -0.16665252f, -0.00006994f, 0.00994113f, 
    -0.00763604f, -0.06882212f, -0.20207833f, -0.06517662f, -0.11068483f, 0.14350607f, 0.12467681f, -0.02008499f, 
    -0.06337649f, -0.01850935f, -0.17709425f, -0.05940098f, -0.06789179f, -0.17243235f, -0.03345741f, -0.10350797f, 
    0.05890035f, -0.39227417f, -0.19791210f, 0.12428528f, -0.09223582f, 0.01916141f, 0.02232765f, 0.10492630f, 
    -0.00798157f, 0.07855968f, 0.20407222f, 0.04828266f, 0.01412142f, 0.11038280f, 0.19102240f, -0.00751276f, 
    -0.17277321f, 0.05933414f, 0.06319427f, -0.21696295f, -0.14613667f, -0.05831717f, -0.24612641f, -0.04676310f, 
    -0.33848333f, -0.27601787f, -0.21984661f, -0.09370100f, 0.12298950f, -0.16071182f, 0.13225034f, -0.09178804f, 
    -0.02579425f, -0.21045420f, -0.10597849f, -0.03875012f, 0.08170028f, 0.09864466f, -0.06173887f, 0.20489199f, 
    0.04149119f, -0.06005171f, -0.09179079f, 0.11079337f, 0.03397024f, 0.13608316f, 0.08907825f, 0.01906918f, 
    0.03971102f, -0.09805456f, -0.08655716f, 0.11247303f, 0.24302977f, -0.18980724f, 0.10198040f, 0.03945887f, 
    0.11664771f, -0.38659278f, -0.21414632f, 0.13770074f, 0.08839360f, 0.11208917f, -0.08020347f, -0.06736445f, 
    -0.00913848f, 0.00697302f, -0.09910346f, 0.12388270f, 0.09343174f, -0.44885296f, 0.16775315f, -0.40562186f, 
    -0.21121241f, 0.43307349f, -0.14205594f, 0.15250847f, -0.03479293f, -0.07375960f, -0.02560307f, 0.20973651f, 
    0.11331446f, -0.01084534f, -0.08739104f, 0.07257144f, 0.25513250f, -0.06900495f, 0.08284540f, 0.19479360f, 
    -0.27828017f, 0.09029308f, -0.08082844f, -0.07084778f, 0.13808127f, 0.13193400f, 0.01457766f, -0.09586455f, 
    0.11114594f, -0.12847985f, 0.14942198f, -0.10730844f, -0.12662239f, -0.01078601f, 0.22892356f, 0.00439797f, 
    0.06741147f, 0.08091059f, 0.18679406f, -0.01950497f, 0.00986013f, -0.13515121f, -0.14842184f, 0.08949058f, 
    -0.09962509f, 0.00695896f, 0.23540306f, -0.08037389f, -0.18271337f, 0.06190200f, 0.01932034f, 0.02719278f, 
    -0.05854057f, 0.19368102f, -0.05242548f, -0.15600587f, 0.04569455f, -0.10517586f, -0.11689423f, -0.10583431f, 
    -0.00154752f, 0.22947463f, 0.17018421f, -0.00495027f, -0.00872245f, -0.09536353f, -0.12295083f, 0.12467738f, 
    0.04061479f, 0.26388469f, 0.20390478f, -0.04453897f, -0.13850179f, 0.06337197f, 0.20161678f, 0.43933019f, 
    0.13746184f, 0.06424509f, 0.27671868f, 0.12884411f, -0.16516802f, -0.12394387f, -0.01166287f, 0.12632336f, 
    0.12259811f, -0.00026251f, 0.06812162f, 0.08078351f, 0.01161309f, -0.13246916f, -0.07700799f, -0.09835662f, 
    0.34565377f, 0.03869279f, -0.04829440f, 0.16331263f, -0.11994130f, 0.14082845f, 0.06099711f, 0.22051416f, 
    -0.10732878f, -0.03838260f, -0.17846851f, 0.28889674f, 0.13246708f, 0.02841109f, 0.01151499f, -0.03890493f, 
    -0.08724679f, -0.01572362f, -0.02063953f, 0.06385559f, 0.01195817f, 0.25427383f, 0.04596853f, -0.06781764f, 
    0.09552144f, 0.20526019f, -0.05673004f, 0.09780173f, 0.07079223f, -0.09002288f, 0.07779814f, -0.07779464f, 
    0.11229282f, 0.02649277f, -0.18139987f, -0.08529519f, 0.29667157f, 0.04815399f, -0.00992178f, -0.03859027f, 
    0.23759440f, -0.13324201f, 0.16928320f, 0.10293949f, 0.13185379f, -0.10998363f, -0.05292713f, 0.29446733f, 
    -0.37976670f, 0.09186935f, -0.01376352f, 0.11604260f, -0.09029770f, 0.08717203f, 0.18447059f, -0.05336510f, 
    -0.12291743f, 0.29286554f, 0.04889413f, -0.07920711f, 0.08706133f, -0.10675539f, -0.20922720f, 0.02305482f, 
    0.00621101f, -0.13113657f, -0.32513133f, 0.10001173f, 0.12614918f, -0.25779596f, 0.16460736f, 0.02358774f, 
    -0.10490230f, -0.11447203f, -0.10465229f, -0.05856926f, -0.05434274f, 0.01921011f, 0.05876251f, 0.01791308f, 
    -0.02796533f, 0.05068358f, -0.06082296f, 0.08327410f, 0.03521312f, -0.09729540f, -0.02150093f, -0.11331521f, 
    0.10717492f, 0.06588948f, 0.06199880f, -0.11908624f, 0.10789017f, -0.11398198f, -0.04209089f, -0.05237641f, 
    0.05424140f, -0.08638576f, -0.07873026f, -0.11527664f, -0.02802995f, 0.06439580f, -0.03326556f, -0.08664034f, 
    0.06836294f, -0.01916472f, -0.07396396f, -0.11165548f, 0.08709250f, 0.10111088f, -0.09747340f, 0.02020183f, 
    0.06732719f, -0.00748621f, -0.07091138f, -0.10641719f, -0.10613851f, 0.09089815f, 0.04636338f, -0.05942319f, 
    -0.08365829f, -0.04547049f, 0.04385212f, -0.09333684f, 0.00729589f, 0.06848719f, -0.08364715f, 0.06969044f, 
    0.08511707f, 0.01784481f, -0.04055595f, -0.09455357f, -0.11193842f, -0.05641497f, 0.00694658f, -0.07853511f, 
    -0.12389372f, -0.45640025f, -0.09794259f, 0.27327755f, 0.03872394f, 0.00683431f, 0.32505304f, 0.03900323f, 
    -0.10171458f, -0.12320825f, -0.27672124f, -0.09782840f, 0.28511670f, -0.26115721f, 0.14318372f, 0.05011332f, 
    -0.08156355f, -0.03307011f, -0.15067831f, 0.16142067f, -0.07848302f, 0.06449392f, 0.06239826f, 0.03376747f, 
    -0.03953172f, -0.08057993f, -0.07226641f, -0.05176064f, 0.08693496f, -0.03786180f, 0.19002739f, -0.07481969f, 
    -0.03574309f, 0.29263309f, 0.20818792f, 0.24566025f, 0.01933422f, -0.07083557f, -0.18751416f, -0.30815634f, 
    0.00999681f, -0.01496560f, -0.01052722f, 0.11846628f, 0.21660818f, -0.09588241f, -0.09807631f, 0.17079388f, 
    -0.02152281f, -0.09276126f, -0.12883906f, 0.06384128f, -0.00830713f, 0.22991624f, -0.24813725f, 0.07437190f, 
    -0.15324688f, -0.11324324f, 0.08953355f, -0.16813059f, 0.19375440f, -0.03995764f, 0.16026036f, -0.07941949f, 
    0.07076982f, -0.03265325f, 0.05473424f, -0.02656819f, 0.24107140f, 0.02423394f, -0.07327290f, -0.05146961f, 
    -0.01537030f, 0.12457433f, -0.11518613f, -0.09713913f, 0.03617042f, 0.09056219f, -0.09014886f, 0.12203375f, 
    -0.00180461f, 0.13503994f, 0.13915250f, -0.02545103f, -0.08667181f, -0.25910765f, 0.07603070f, -0.07414079f, 
    0.33952108f, 0.01156710f, 0.10946259f, -0.04577360f, 0.22137609f, 0.37252802f, -0.07308590f, 0.22860922f, 
    0.25476786f, -0.25482497f, 0.07718014f, -0.07069323f, 0.23715667f, -0.08443111f, -0.16513924f, -0.03454651f, 
    -0.40063158f, -0.03811008f, 0.24649429f, 0.29015487f, -0.10937791f, 0.01110779f, 0.04686292f, -0.03913449f, 
    0.23400299f, 0.07482469f, -0.02518811f, -0.04888454f, -0.28389010f, 0.00459273f, -0.12533253f, -0.04272736f, 
    -0.00050374f, 0.06617245f, -0.35074747f, 0.17253008f, 0.09181346f, -0.22313799f, -0.03311058f, -0.00884845f, 
    -0.02374133f, 0.15122880f, 0.04322758f, -0.02061957f, 0.04046142f, 0.02079015f, 0.05132931f, 0.11035028f, 
    -0.00652859f, -0.09549357f, -0.14599979f, 0.02456218f, -0.17414632f, -0.04271865f, -0.03251704f, -0.06222624f, 
    -0.05514544f, 0.13806643f, -0.03650350f, -0.33429384f, -0.02471595f, 0.08955783f, 0.12454142f, -0.08488206f, 
    0.09468524f, 0.22543645f, -0.04373826f, -0.02229083f, 0.11815576f, -0.06546889f, -0.00797346f, 0.16616990f, 
    0.23307940f, 0.00170946f, 0.06457324f, 0.21410044f, 0.13011387f, 0.02447405f, -0.07442325f, 0.43379986f, 
    0.23709613f, 0.07543589f, 0.27862674f, -0.13276613f, -0.07226472f, -0.11002322f, -0.35966071f, -0.16717796f, 
    0.09597374f, -0.14001104f, 0.30253044f, 0.09358711f, 0.04017913f, -0.17572699f, -0.18535259f, -0.07858714f, 
    0.40141469f, -0.01492196f, 0.09553941f, 0.03870707f, 0.12508948f, -0.19215219f, 0.07846118f, 0.10210934f, 
    -0.05822979f, 0.11050701f, 0.12865837f, -0.20927948f, 0.19406176f, 0.32977372f, -0.11520033f, -0.00481223f, 
    -0.05381001f, -0.12238954f, 0.22678110f, 0.10021864f, -0.11735035f, 0.01899747f, -0.05135453f, 0.03166472f, 
    0.01332303f, -0.05296583f, -0.03279396f, 0.16581169f, -0.10052755f, 0.20030376f, -0.01390647f, -0.11681499f, 
    0.03515239f, 0.04425336f, -0.20743524f, -0.05061822f, -0.01490577f, 0.32416025f, 0.00656340f, 0.05845344f, 
    0.17988329f, -0.01333200f, -0.20654158f, 0.02693187f, 0.19460736f, 0.03543048f, -0.09761914f, -0.20549306f, 
    -0.11196650f, 0.07731307f, -0.31739208f, 0.25301099f, 0.16876940f, 0.03934655f, 0.18882564f, -0.31855804f, 
    -0.15641557f, 0.04323244f, -0.17185967f, 0.03176538f, -0.07345608f, 0.10102438f, 0.33565924f, -0.10181868f, 
    0.03444447f, 0.24190894f, -0.10889921f, 0.20817730f, 0.02013831f, -0.01825405f, -0.03857756f, -0.04352842f, 
    -0.11977772f, 0.08585356f, -0.10532765f, -0.07178901f, -0.05656687f, -0.12127752f, 0.00753719f, 0.00253823f, 
    0.08641157f, -0.11677130f, -0.11151316f, 0.02967916f, -0.05348262f, 0.02920435f, 0.12155549f, 0.05240248f, 
    0.02395226f, 0.08532196f, 0.10223921f, -0.09407690f, -0.04751015f, -0.14676031f, 0.05236155f, -0.04396113f, 
    -0.13079546f, 0.05578148f, 0.04610647f, 0.11463133f, -0.05946729f, -0.10152557f, 0.03363026f, -0.06857048f, 
    0.01176907f, 0.00004194f, -0.12037940f, 0.05095396f, -0.14370483f, -0.01718106f, -0.13223800f, -0.07435228f, 
    -0.07528883f, 0.07014757f, -0.16119340f, -0.04958816f, 0.07361505f, -0.05778499f, -0.02085095f, 0.05501378f, 
    0.08590316f, -0.12395872f, -0.07312492f, 0.08987185f, 0.03172361f, -0.03896184f, 0.07624979f, 0.11884800f, 
    -0.02504884f, -0.06281798f, -0.10314044f, -0.07229569f, -0.09084622f, -0.14292853f, -0.08665420f, 0.00706881f, 
    0.04325247f, -0.23247284f, -0.10135492f, 0.33165342f, 0.03961915f, 0.08732097f, 0.10941064f, 0.07535468f, 
    0.02226355f, 0.06241914f, 0.18519789f, -0.00443582f, 0.10638999f, 0.26480451f, -0.03507032f, 0.06023876f, 
    0.10231782f, -0.02446331f, 0.02865260f, 0.13014308f, -0.05418099f, -0.06603024f, -0.08524404f, 0.04253606f, 
    -0.27510196f, 0.03102606f, 0.12993950f, 0.10500789f, 0.08452775f, 0.12143826f, -0.11414114f, -0.13916624f, 
    0.10897955f, -0.21433206f, 0.27487218f, -0.03851284f, -0.02301118f, 0.07804286f, 0.08667795f, -0.01914115f, 
    -0.45727870f, 0.04988784f, 0.01402233f, 0.40368214f, -0.00410147f, 0.01223929f, 0.10561740f, 0.08799268f, 
    -0.15746741f, 0.05746234f, -0.33128682f, -0.06429246f, 0.09150513f, 0.19790068f, -0.00798648f, -0.05265368f, 
    -0.13116738f, 0.20346586f, -0.09910954f, 0.10622836f, 0.06439463f, -0.01307794f, 0.12889110f, -0.22481422f, 
    0.06870003f, 0.12851672f, -0.08341750f, -0.07321971f, -0.04022570f, 0.12548928f, 0.07010216f, -0.04023466f, 
    0.07984087f, 0.10917414f, 0.03720061f, 0.10021666f, 0.02027843f, -0.07096837f, 0.03053012f, 0.09395565f, 
    0.07917453f, -0.18981802f, 0.27816272f, 0.20739330f, 0.09193298f, -0.20305435f, -0.02830609f, -0.12115739f, 
    -0.12486061f, -0.01064405f, 0.23256004f, -0.07261031f, -0.18360175f, 0.15808241f, 0.09973682f, -0.20119764f, 
    -0.10242327f, -0.12620331f, 0.22465491f, -0.10136285f, -0.05454621f, 0.21969384f, -0.09745638f, -0.06043136f, 
    0.29110095f, -0.06301428f, 0.09536138f, 0.16118589f, 0.09658815f, 0.05679755f, 0.06870949f, 0.03336447f, 
    0.23425558f, -0.18255390f, -0.27731383f, -0.02423370f, 0.11615897f, 0.03666462f, 0.45343029f, -0.12833683f, 
    -0.40417314f, 0.18072358f, 0.37500933f, -0.17592131f, 0.00844854f, 0.52492940f, -0.07357080f, 0.03222744f, 
    -0.01237029f, -0.01270329f, -0.29393089f, 0.53703803f, 0.16719832f, 0.14354044f, 0.05326994f, 0.10931518f, 
    -0.08233207f, 0.09799680f, -0.05582896f, 0.07649180f, -0.10154654f, -0.02809269f, -0.12440622f, -0.03694944f, 
    -0.02956126f, -0.43673447f, 0.22790615f, 0.16830836f, -0.02487053f, -0.33239868f, -0.07220122f, 0.05218745f, 
    0.10955229f, 0.14512748f, -0.08528258f, 0.00901581f, 0.20270073f, -0.03520756f, 0.15279424f, -0.41525817f, 
    0.03148574f, 0.01991160f, 0.06257485f, 0.17215699f, -0.12691575f, 0.08584835f, -0.16035832f, 0.10671087f, 
    -0.12182460f, -0.07840510f, -0.00926382f, 0.25443077f, 0.04738802f, -0.00341355f, -0.03834187f, 0.08788272f, 
    -0.06225854f, -0.00120220f, -0.36423093f, 0.01430055f, 0.18259341f, 0.04204388f, 0.16984722f, 0.01507651f, 
    -0.04862905f, 0.09185328f, 0.24231553f, -0.26590922f, -0.14393561f, 0.22680052f, 0.02547083f, -0.17078461f, 
    0.06122610f, 0.07312366f, 0.00490153f, -0.03844137f, 0.03038145f, -0.09376849f, -0.15032287f, 0.07545895f, 
    0.01579737f, 0.09956291f, -0.10254186f, -0.05742806f, -0.18725997f, 0.03351823f, -0.02754523f, -0.10790934f, 
    -0.08266237f, 0.04700410f, 0.01560426f, -0.04093659f, 0.04764412f, -0.02644013f, 0.11798644f, 0.12003694f, 
    -0.05353933f, 0.10726757f, 0.02504734f, 0.07022257f, -0.02921001f, -0.19357467f, -0.01561508f, -0.20116453f, 
    -0.07547760f, -0.01491126f, -0.31209385f, -0.12480472f, -0.00552635f, -0.00133433f, -0.05140525f, -0.05838613f, 
    0.09804136f, -0.07815521f, -0.31593889f, 0.10195851f, -0.11122712f, 0.08699614f, -0.17397757f, -0.00600283f, 
    -0.12413941f, 0.06229391f, -0.09126413f, 0.11130423f, 0.05384169f, -0.01401649f, -0.14700627f, 0.01054110f, 
    -0.22493652f, 0.14005968f, 0.03991309f, -0.15309384f, -0.07501452f, 0.08126553f, -0.05596179f, 0.07203116f, 
    0.01983416f, 0.20436326f, 0.02504207f, -0.39669815f, 0.03784605f, 0.21330272f, 0.22145896f, -0.03159882f, 
    0.07228656f, -0.11409175f, -0.02682779f, 0.02939416f, -0.07806208f, -0.17400353f, -0.07449646f, 0.01719555f, 
    -0.01949291f, -0.05984227f, 0.07775022f, 0.23630358f, -0.05671321f, 0.16271244f, 0.06964616f, 0.03891420f, 
    0.00681042f, 0.13756308f, -0.19098136f, 0.03940548f, -0.07804286f, -0.02958556f, 0.21563165f, 0.09202743f, 
    -0.01411252f, -0.46780393f, -0.10563177f, 0.11320703f, 0.21671678f, 0.12080358f, -0.46214232f, -0.07492404f, 
    0.01698745f, 0.07720533f, -0.19914947f, -0.20546925f, 0.45457768f, -0.05423670f, -0.09069249f, -0.59668767f, 
    0.05675832f, 0.21250130f, -0.16633669f, -0.00565512f, -0.18138668f, 0.15228796f, 0.33137220f, -0.02867478f, 
    0.01787378f, 0.23178624f, 0.28712234f, -0.06323481f, 0.09610786f, -0.29491991f, 0.03379579f, -0.02810556f, 
    -0.04444858f, 0.17589992f, -0.09473639f, 0.05218374f, -0.31900913f, 0.16625455f, 0.10271902f, -0.12656252f, 
    0.00297999f, -0.04901838f, -0.01201613f, 0.10654973f, 0.22375467f, 0.18584022f, 0.10696013f, -0.03757626f, 
    0.08658698f, -0.28660762f, 0.34789380f, -0.07018853f, -0.04748563f, 0.25268793f, 0.11044288f, 0.03564566f, 
    -0.22940861f, 0.00953184f, -0.15188390f, -0.04525913f, 0.08931013f, -0.14625646f, 0.15840745f, 0.11263990f, 
    0.11858356f, -0.37837398f, 0.00071889f, 0.07542875f, 0.17730671f, 0.14126018f, -0.28456035f, 0.24761383f, 
    0.19162336f, 0.10454964f, -0.09199646f, -0.15635335f, 0.21208067f, -0.07883734f, 0.03505186f, 0.01206562f, 
    -0.15271521f, -0.08589514f, 0.04355909f, -0.10213235f, 0.22535521f, 0.08870725f, 0.03195857f, -0.01173320f, 
    -0.42505327f, 0.15537713f, 0.01414288f, -0.13463458f, 0.11660261f, -0.29291835f, -0.08578901f, 0.02660705f, 
    -0.01442225f, -0.01798878f, -0.00722652f, 0.22191504f, 0.09009871f, -0.10309155f, 0.21724567f, -0.06607248f, 
    -0.01345349f, 0.00885796f, -0.07791010f, 0.08999376f, -0.03925573f, -0.08967675f, -0.05891384f, 0.08016473f, 
    -0.05410115f, 0.07748757f, 0.10505021f, 0.04167014f, 0.10243796f, 0.02921254f, 0.08467221f, -0.08407206f, 
    -0.09505194f, 0.12382617f, 0.26392943f, 0.02504803f, -0.06539104f, 0.18465641f, -0.06562660f, 0.12720461f, 
    0.15080723f, -0.19705974f, 0.25870514f, 0.10063662f, 0.15234473f, 0.13400711f, -0.06096547f, -0.20647500f, 
    -0.37285069f, 0.02973890f, 0.06066585f, 0.15636565f, -0.04621919f, -0.02364550f, -0.10121995f, -0.09393974f, 
    0.31272706f, 0.01022650f, -0.21859369f, -0.07819960f, -0.11998626f, 0.05161672f, 0.04037153f, -0.12070891f, 
    -0.25066051f, 0.24185500f, 0.28799894f, -0.10038959f, 0.09395143f, 0.11423350f, -0.03259618f, -0.28802940f, 
    -0.09528197f, 0.06691459f, -0.16950315f, 0.32692072f, 0.35005707f, -0.01524672f, 0.00377443f, 0.07388102f, 
    0.05459742f, 0.08864039f, -0.20219302f, 0.01880915f, 0.05850950f, -0.18415530f, -0.07469074f, 0.02915338f, 
    -0.02671766f, -0.39467525f, 0.12040507f, -0.02909404f, 0.13460661f, -0.09962909f, -0.10471303f, 0.08818628f, 
    0.23319948f, -0.06598913f, -0.16076216f, 0.08128830f, 0.02958227f, -0.16144022f, 0.23839474f, -0.38881460f, 
    -0.23254319f, 0.45443523f, -0.00936413f, 0.29346088f, 0.03557510f, 0.00981566f, -0.13409865f, 0.07748681f, 
    0.27398866f, 0.08489360f, 0.04486041f, 0.23037384f, 0.22991808f, 0.00870505f, -0.11873007f, 0.23532510f, 
    0.14044927f, -0.08224148f, -0.15509604f, 0.04598364f, -0.05317986f, 0.08926669f, 0.08008950f, 0.10663231f, 
    0.48127019f, -0.24485265f, 0.20328680f, -0.07314236f, -0.18020199f, 0.16820529f, 0.02632353f, -0.05934733f, 
    0.07906956f, -0.00107165f, -0.00757481f, 0.17300546f, 0.15739824f, -0.00454166f, -0.02145486f, 0.00641832f, 
    -0.08533600f, 0.09059304f, -0.13669868f, 0.01347600f, -0.01018641f, 0.33088613f, 0.05290581f, 0.07128877f, 
    0.04619692f, 0.18025114f, 0.01817310f, -0.17787495f, 0.12667894f, -0.14071651f, -0.04470208f, -0.10164027f, 
    0.18961141f, 0.06334562f, -0.18291841f, -0.01434004f, 0.25682035f, -0.10236988f, 0.10742562f, 0.29987663f, 
    0.05016360f, -0.16871440f, -0.01640620f, 0.28445941f, 0.22232628f, 0.17919150f, -0.07790224f, 0.31851575f, 
    -0.40328962f, 0.07508640f, -0.08543257f, -0.18340571f, -0.02533282f, -0.03572417f, -0.09541538f, 0.21105351f, 
    -0.12063967f, 0.30673957f, 0.10930099f, 0.04053704f, 0.13653882f, -0.08619979f, -0.27477628f, -0.10434646f, 
    0.15742967f, 0.09682639f, -0.11132174f, -0.07931016f, 0.12982455f, -0.41685051f, 0.27901942f, 0.04956378f, 
    -0.04921560f, 0.01225011f, 0.06925041f, 0.22002469f, 0.19940995f, 0.01004905f, 0.08261424f, 0.11368399f, 
    -0.04610723f, 0.01534696f, -0.07028899f, -0.04569382f, -0.13995194f, -0.00939437f, 0.09850818f, 0.08489386f, 
    0.03265448f, -0.21414892f, -0.08345072f, -0.02597175f, 0.03379473f, -0.30041233f, 0.09823985f, -0.01069904f, 
    -0.03071473f, 0.15082002f, -0.10089856f, -0.06731453f, -0.07397014f, -0.32799044f, 0.04025036f, -0.02534251f, 
    0.12314002f, 0.23500738f, -0.02273413f, -0.00034816f, 0.13853370f, -0.02892899f, -0.04290982f, 0.29836360f, 
    0.05378700f, 0.11589701f, 0.02373446f, -0.17065999f, -0.05642287f, 0.02256802f, -0.17994224f, -0.10987861f, 
    -0.13602471f, -0.30560899f, 0.03435926f, 0.08667513f, 0.05902198f, -0.07894457f, -0.03115728f, 0.06084921f, 
    0.18499869f, -0.03906420f, -0.06862948f, -0.29523617f, -0.03545564f, 0.12044129f, 0.10770443f, 0.04101211f, 
    -0.08830363f, -0.06627981f, -0.19175258f, 0.10567015f, 0.15949185f, 0.09718288f, -0.00793219f, -0.10578991f, 
    0.07515547f, 0.08771846f, -0.01583134f, -0.01175825f, 0.12640268f, -0.06000388f, -0.05716238f, -0.08263288f, 
    -0.09454755f, -0.60600358f, 0.21329147f, 0.22636445f, -0.01203214f, 0.07794885f, -0.03889514f, -0.09651364f, 
    0.25366163f, -0.16350636f, -0.17291346f, 0.10661292f, 0.07191315f, 0.24676752f, 0.26195815f, -0.48319542f, 
    -0.32314712f, 0.34891188f, -0.06169342f, 0.10460525f, -0.07971128f, 0.14042637f, -0.04637513f, -0.25212345f, 
    0.28052968f, 0.12501404f, -0.06416486f, 0.07548448f, 0.23114640f, -0.07705969f, 0.02742318f, 0.09934020f, 
    0.19672015f, -0.08433662f, -0.07915445f, -0.09154000f, -0.00494490f, 0.17789495f, 0.28079733f, -0.07362486f, 
    0.03184022f, -0.19808158f, 0.07466346f, 0.00124885f, -0.17271076f, 0.29929045f, -0.14992712f, 0.05710620f, 
    -0.04575874f, -0.02235741f, -0.24132895f, 0.11332934f, 0.11177141f, 0.14381632f, 0.11873405f, -0.08679637f, 
    -0.08121206f, -0.03380114f, -0.03638721f, 0.09119543f, 0.27399811f, 0.17195348f, -0.02110824f, -0.05595528f, 
    0.10030803f, -0.17330235f, -0.02359363f, 0.13666813f, -0.08952687f, 0.29212242f, -0.09344919f, 0.12053292f, 
    -0.06832380f, 0.18623088f, -0.31902358f, 0.08498804f, 0.14099883f, 0.02152831f, 0.06184833f, 0.05311840f, 
    0.14164434f, 0.03339297f, -0.10073814f, 0.24547495f, 0.20536283f, 0.26004571f, -0.26042157f, 0.00585109f, 
    0.39644757f, 0.11672031f, 0.01637626f, -0.18854578f, 0.22849444f, -0.08488651f, 0.04116467f, -0.05059760f, 
    -0.20513085f, -0.09981155f, -0.02953545f, -0.04598973f, 0.19250493f, 0.23291051f, 0.42888141f, 0.05617719f, 
    0.10749275f, 0.00058449f, 0.21509846f, 0.05591011f, 0.02240776f, -0.01839639f, 0.05214901f, -0.13614063f, 
    -0.11090704f, 0.14651516f, 0.13413301f, -0.07962925f, -0.00090925f, -0.00583743f, 0.13340217f, 0.02042252f, 
    -0.04708786f, 0.09860574f, -0.18154030f, -0.00044093f, -0.11280204f, -0.36038145f, -0.12365417f, -0.12445512f, 
    -0.06033089f, -0.03601037f, -0.30367562f, -0.15286553f, -0.02422626f, 0.14173964f, -0.11676846f, -0.01249806f, 
    0.29781985f, -0.04149538f, 0.10199624f, 0.10714313f, -0.20714843f, 0.16880128f, 0.06437869f, 0.23058017f, 
    0.02511684f, -0.20519477f, -0.04196775f, 0.10050071f, 0.26933736f, 0.21849912f, -0.65143186f, -0.05941397f, 
    0.56910324f, 0.07772353f, 0.05905066f, 0.06870372f, 0.05046195f, 0.09442326f, -0.53881961f, -0.21675470f, 
    0.40119582f, -0.15897079f, 0.39049587f, 0.05791687f, -0.45801660f, -0.14453740f, 0.13064252f, 0.07431941f, 
    0.16576974f, 0.00369619f, 0.62774938f, 0.06217105f, 0.08549247f, 0.08905922f, -0.02025807f, -0.41122001f, 
    0.03248566f, 0.09666079f, 0.05213120f, -0.04492680f, -0.07020372f, 0.23454423f, -0.18879575f, 0.09350302f, 
    -0.07789532f, -0.05577384f, -0.02932421f, 0.11753625f, 0.13972832f, 0.10647258f, 0.05007712f, 0.04340435f, 
    0.05598753f, -0.22066814f, 0.08407144f, -0.00253110f, 0.04094747f, 0.28290471f, -0.06620795f, -0.11134215f, 
    0.07853380f, -0.03624478f, -0.31693754f, 0.05349600f, 0.16402912f, -0.08128214f, 0.10692579f, 0.04281640f, 
    -0.04981071f, -0.17078188f, -0.22651005f, 0.19225086f, 0.16999872f, 0.04076035f, -0.09632573f, 0.08378778f, 
    0.37381995f, -0.01629721f, -0.07301252f, -0.14240250f, 0.14241363f, -0.01406324f, 0.01915306f, 0.04006276f, 
    -0.10299052f, 0.07436841f, 0.24943818f, 0.06404322f, 0.09521694f, -0.05760830f, 0.25101525f, -0.01008584f, 
    0.11351745f, 0.03192822f, -0.11205883f, -0.06962323f, 0.06605957f, -0.35344574f, 0.11755013f, 0.13533147f, 
    0.06893343f, -0.08759870f, 0.33462432f, -0.20283543f, 0.05939098f, -0.07999985f, 0.00089115f, 0.10831331f, 
    -0.01453078f, -0.10539219f, 0.04575815f, -0.04665544f, -0.12173477f, -0.39904410f, -0.06946438f, 0.02147674f, 
    0.10393139f, -0.07766157f, -0.24999325f, 0.06843017f, -0.08459870f, -0.14152636f, 0.09113489f, -0.08661562f, 
    -0.01149796f, -0.09184484f, 0.47263822f, 0.09694456f, -0.23477097f, 0.19355020f, -0.07674747f, 0.17883223f, 
    0.10716551f, 0.04293888f, 0.15706308f, -0.03051995f, -0.05738453f, 0.03450970f, -0.11177309f, -0.02960422f, 
    0.41346249f, 0.04129580f, 0.19356683f, 0.05908368f, -0.16217522f, -0.11255273f, -0.10536058f, 0.08038628f, 
    0.46228606f, -0.43635502f, 0.33583757f, -0.08947163f, -0.38757673f, -0.04974954f, -0.34248322f, -0.11485641f, 
    0.01225558f, -0.07153048f, 0.33891487f, -0.03793902f, 0.04560741f, 0.23875733f, 0.04882154f, -0.24317966f, 
    0.05708210f, 0.05592538f, 0.03550539f, -0.06175609f, -0.11630227f, -0.06719273f, 0.06209601f, -0.10561720f, 
    0.03943913f, 0.07091812f, 0.11877926f, -0.09584787f, 0.26358086f, -0.18251245f, 0.00762480f, 0.06369919f, 
    -0.01382805f, -0.15789978f, 0.19632985f, 0.13415851f, 0.01680388f, 0.27042311f, 0.03387822f, -0.02038063f, 
    -0.28968427f, 0.06850103f, 0.09612275f, -0.08804844f, -0.18387449f, 0.00930592f, 0.00313711f, 0.09601818f, 
    0.08503130f, 0.04753568f, 0.07395303f, -0.13831386f, -0.17769322f, 0.18462998f, -0.10201866f, 0.09525208f, 
    0.27041534f, -0.06417072f, 0.18014184f, -0.21695784f, -0.06052592f, -0.05638912f, 0.06011241f, 0.18054135f, 
    0.04147809f, -0.39099279f, 0.11988205f, 0.05806671f, -0.17743655f, 0.18893041f, 0.05998809f, -0.08177721f, 
    0.06629772f, 0.10817123f, 0.19127716f, -0.06418029f, 0.06541125f, 0.26248711f, -0.23610009f, -0.16806367f, 
    0.05941193f, 0.06250782f, 0.00419238f, 0.06953853f, -0.04844809f, -0.06877163f, -0.11208453f, 0.12201767f, 
    0.04211106f, -0.07455550f, -0.01978985f, -0.03242296f, 0.09326833f, -0.00853235f, 0.01932372f, -0.00382598f, 
    -0.03286336f, 0.09589227f, -0.04407094f, -0.11762484f, -0.10796293f, -0.02604596f, 0.06755732f, -0.10012100f, 
    0.05779669f, -0.14978157f, 0.07157578f, 0.07005146f, 0.02222540f, -0.10393813f, -0.00952654f, -0.05228745f, 
    -0.11028060f, -0.03732064f, -0.13537936f, -0.11781509f, -0.05529580f, -0.03352416f, -0.06140218f, -0.01066288f, 
    -0.10228608f, 0.07344799f, 0.01342952f, -0.09005098f, 0.00485784f, 0.11837699f, 0.03476046f, -0.03273970f, 
    0.02799931f, -0.00082735f, -0.03508568f, -0.00781346f, -0.01331426f, -0.08006841f, -0.11373401f, -0.05875362f, 
    -0.03118236f, -0.04104634f, 0.07042444f, -0.03908842f, -0.00919012f, -0.12880386f, -0.07135706f, -0.02121662f, 
    -0.05821927f, 0.23656948f, 0.26426166f, -0.29320028f, 0.09961529f, 0.17220193f, -0.28605810f, -0.05798427f, 
    0.00361157f, -0.09355528f, -0.09659673f, 0.06170667f, -0.07497600f, -0.12419359f, 0.04298212f, 0.06983802f, 
    0.11811563f, 0.03066986f, -0.14896873f, -0.12083015f, -0.08137364f, 0.12935375f, 0.11336967f, -0.10410550f, 
    0.20787574f, -0.09290385f, -0.10864971f, -0.09247029f, -0.09647495f, 0.14216672f, -0.01265357f, 0.06285448f, 
    0.03705264f, 0.08481972f, -0.42590949f, 0.09539568f, 0.10775519f, -0.09647879f, -0.11011183f, -0.12121091f, 
    0.37579203f, 0.02664898f, -0.08672474f, 0.04493883f, 0.18273801f, -0.02719589f, -0.05053428f, -0.10589371f, 
    0.03756725f, -0.20199510f, 0.36701727f, 0.10844507f, -0.17508383f, 0.12688959f, -0.08151111f, 0.05106735f, 
    0.20478259f, -0.01354470f, -0.28775293f, 0.21844898f, 0.12826832f, -0.27706599f, 0.16869029f, -0.09906870f, 
    -0.05790464f, 0.16629486f, -0.32512194f, 0.18060900f, 0.38932899f, -0.01003949f, -0.20199105f, 0.02712342f, 
    -0.01187541f, 0.09794076f, 0.19240049f, 0.11761407f, -0.11035766f, 0.23046148f, 0.10214078f, -0.11282691f, 
    -0.03622843f, 0.16490291f, 0.02062543f, 0.07682727f, 0.06071854f, 0.02233928f, -0.10437135f, 0.11928369f, 
    0.17362481f, 0.42664963f, -0.23852387f, 0.00453109f, 0.24205440f, 0.25692764f, 0.00892077f, 0.13429771f, 
    0.04722330f, 0.02652205f, -0.00427999f, -0.06228224f, 0.17639947f, -0.02956065f, -0.03481116f, 0.35204867f, 
    -0.06276334f, -0.09335098f, -0.05768158f, 0.36420625f, 0.00205521f, -0.03835023f, 0.09610250f, -0.23827703f, 
    -0.01768092f, -0.09063623f, -0.04153888f, 0.06839713f, -0.05081965f, -0.00920508f, 0.28179714f, 0.00661410f, 
    0.35318905f, -0.09909161f, 0.10515250f, 0.04265286f, -0.15451425f, 0.33609033f, -0.31661561f, -0.05067231f, 
    0.05674198f, 0.03818546f, -0.12230366f, -0.12579203f, 0.03954017f, 0.00890019f, -0.12736471f, -0.11864045f, 
    0.06778394f, -0.07353099f, 0.04752588f, 0.02771934f, 0.07389849f, -0.07005382f, -0.09020229f, -0.01372286f, 
    0.09261885f, 0.10591622f, 0.02576671f, -0.07061399f, 0.08276659f, 0.02243817f, -0.00428280f, 0.11515440f, 
    -0.02482781f, 0.01108870f, 0.03324702f, -0.10529192f, -0.04045259f, -0.12975934f, -0.11952667f, 0.03863145f, 
    -0.12886165f, 0.07852122f, 0.06251324f, -0.07754122f, -0.00685983f, 0.05347764f, -0.24593514f, -0.13184185f, 
    -0.13766758f, 0.09986944f, -0.02319167f, 0.01569081f, 0.08012317f, 0.09899496f, -0.13394095f, -0.10192663f, 
    0.03010096f, -0.09682474f, 0.02160438f, -0.00770691f, -0.14477676f, 0.04566843f, 0.05781756f, -0.12678289f, 
    0.07859249f, 0.03479451f, -0.01019821f, -0.02874694f, -0.07134202f, -0.10023621f, -0.11794487f, -0.06489796f, 
    -0.09704730f, -0.11502656f, 0.02508456f, -0.05559866f, -0.11215512f, -0.02754322f, -0.00619547f, 0.10239180f, 
    0.01205476f, 0.08272842f, -0.13911787f, -0.03718787f, 0.07533360f, -0.07240909f, 0.08446102f, -0.12337172f, 
    -0.00065571f, 0.01710779f, 0.00413521f, -0.07775880f, -0.00704815f, -0.10011670f, 0.01489173f, -0.13038801f, 
    0.09376539f, 0.07555967f, 0.00209939f, -0.01732592f, 0.11687525f, -0.08522476f, 0.07535034f, 0.01610962f, 
    0.00841789f, -0.07256836f, -0.03133857f, -0.03309558f, -0.12634332f, -0.05375406f, -0.09700347f, -0.03286384f, 
    -0.12051159f, -0.02712730f, -0.06525141f, 0.02870743f, -0.03248679f, 0.11516111f, -0.12195217f, 0.00549147f, 
    -0.00622470f, -0.07729318f, 0.09953570f, -0.11422447f, -0.09992752f, -0.09327544f, 0.10297629f, 0.05646798f, 
    -0.06204383f, 0.02176315f, -0.11175214f, -0.08738954f, -0.02339589f, 0.06679789f, 0.05684799f, 0.01802420f, 
    -0.06429340f, 0.18552269f, 0.28483844f, 0.20037803f, 0.19391648f, 0.05127272f, 0.36452302f, -0.02959465f, 
    0.12714672f, -0.04403132f, -0.22267520f, -0.03842619f, -0.04382471f, -0.15219729f, 0.13049060f, -0.10872918f, 
    0.11584012f, 0.01138547f, 0.16003437f, -0.09528292f, 0.06754085f, 0.02588077f, -0.11647850f, 0.04799357f, 
    0.12678158f, -0.10261027f, -0.09168021f, -0.06585164f, 0.05444436f, 0.02889936f, 0.21065240f, 0.11660758f, 
    0.07891881f, -0.42816406f, 0.03797982f, 0.16853356f, 0.28311867f, 0.37701479f, -0.23015636f, -0.33069205f, 
    -0.29185256f, -0.10230514f, -0.14096826f, -0.19764116f, 0.24620403f, -0.09734308f, -0.11116028f, 0.00709915f, 
    0.13496618f, -0.00379115f, 0.08325465f, 0.03577774f, -0.01267033f, 0.01571579f, -0.07500628f, -0.03512552f, 
    -0.13134189f, 0.32061341f, 0.42588094f, -0.13945860f, 0.30582097f, -0.13682528f, 0.33454639f, -0.13946374f, 
    0.01444217f, -0.24337319f, 0.28096291f, -0.03635697f, -0.21739970f, 0.15738851f, 0.54810476f, 0.06712034f, 
    -0.00211373f, 0.10186671f, -0.06727765f, -0.04561676f, 0.14166687f, -0.42639306f, 0.01260265f, 0.03253121f, 
    0.00492709f, 0.07337525f, -0.06059838f, 0.29535270f, 0.02792370f, 0.19514506f, -0.05525538f, 0.00330725f, 
    -0.50004840f, -0.11388770f, 0.20853981f, -0.11467847f, -0.14894658f, -0.24331571f, 0.17143150f, -0.07472351f, 
    -0.00490785f, -0.00651152f, 0.20803958f, 0.24866319f, 0.00006689f, 0.01376903f, -0.30646992f, -0.12247559f, 
    0.27662528f, -0.05663413f, -0.30442944f, -0.25228316f, 0.32430366f, 0.12187786f, -0.20605618f, 0.17404956f, 
    0.17192356f, -0.10310800f, -0.12049375f, 0.05867135f, -0.09736661f, 0.21566167f, -0.24423943f, -0.02840350f, 
    -0.29234740f, 0.26422158f, 0.42633921f, -0.12892470f, 0.28782725f, -0.05043738f, 0.34576523f, -0.20518272f, 
    0.05810096f, -0.12508920f, 0.22205716f, -0.03905165f, 0.18625095f, 0.18975362f, 0.17750444f, 0.13155475f, 
    0.09356242f, 0.03586213f, -0.12959629f, 0.02023170f, -0.01952370f, -0.19782916f, -0.04154035f, -0.01737641f, 
    0.11866243f, 0.11370647f, 0.21375450f, 0.16501389f, -0.00596326f, -0.27626061f, 0.05840138f, -0.02460622f, 
    0.23369512f, -0.14166406f, -0.06232044f, -0.10966057f, 0.10952405f, 0.11737849f, 0.03392353f, -0.06252312f, 
    -0.11272928f, 0.08703048f, 0.00054202f, 0.02636786f, 0.02204651f, -0.02698400f, 0.14305513f, -0.30659598f, 
    -0.22024189f, -0.06478754f, 0.02144050f, 0.16576977f, 0.04219869f, 0.07861883f, 0.10597067f, 0.19917282f, 
    0.08511750f, 0.02164191f, -0.23906967f, -0.02351403f, -0.08940611f, 0.16670944f, -0.02086602f, -0.04898230f, 
    -0.25547567f, -0.13798867f, -0.26723510f, -0.01671085f, -0.02667673f, -0.06426980f, -0.08244359f, 0.10816776f, 
    -0.03168239f, -0.14216770f, 0.30819738f, -0.20407030f, 0.00488399f, -0.21120059f, 0.30306175f, -0.03320419f, 
    0.04169938f, 0.03305505f, 0.21042287f, 0.11138617f, 0.12876761f, -0.07345738f, -0.03819249f, 0.12232127f, 
    0.07429606f, 0.42457187f, -0.13118082f, 0.15083766f, 0.02412864f, 0.02519815f, 0.05696936f, 0.03949631f, 
    -0.28434512f, 0.01183194f, 0.33226278f, 0.07964662f, -0.03512199f, -0.02918990f, -0.14484514f, 0.00533747f, 
    -0.09908074f, 0.15043892f, 0.22552258f, -0.05590499f, 0.01906791f, -0.02932667f, -0.01138006f, -0.03588956f, 
    0.12065654f, 0.08095446f, 0.15103196f, 0.05705334f, -0.15838198f, -0.07670651f, -0.05123369f, 0.13540424f, 
    0.26961944f, 0.09244674f, 0.05087131f, -0.01795438f, -0.17301987f, 0.22602773f, -0.20241204f, 0.09133501f, 
    0.19859271f, 0.16493346f, 0.25042242f, 0.11024562f, 0.09863593f, 0.12494570f, 0.14378522f, -0.20806873f, 
    -0.03758975f, -0.17225690f, 0.16481973f, 0.05415320f, 0.04180545f, 0.35347331f, 0.39454511f, -0.09192714f, 
    0.00794076f, -0.07348801f, 0.01138767f, -0.10448594f, 0.34889546f, -0.18605667f, -0.07449875f, 0.07128399f, 
    0.07279968f, -0.07247628f, -0.17391756f, 0.32917714f, -0.09313045f, 0.34245831f, 0.01020753f, -0.03906929f, 
    0.05797427f, -0.16687360f, -0.02747704f, -0.09316451f, -0.14512381f, 0.07050417f, 0.25635353f, 0.01975394f, 
    0.11881134f, -0.07142156f, -0.06490916f, 0.21118613f, 0.06337798f, -0.00763470f, 0.06577053f, -0.41288182f, 
    0.02848917f, 0.11849682f, -0.17343938f, -0.01855089f, 0.26986247f, -0.03877566f, -0.00007455f, 0.03621238f, 
    -0.07158410f, 0.04199347f, 0.12955074f, -0.01673563f, -0.00916330f, 0.30132002f, 0.11385537f, -0.05307172f, 
    -0.31787491f, 0.13690506f, 0.06088577f, -0.08458807f, 0.22343962f, -0.04278819f, 0.16924129f, -0.11510045f, 
    0.04909321f, 0.11236952f, -0.25205413f, 0.07750147f, 0.10618025f, 0.12163434f, -0.04198662f, -0.04915079f, 
    -0.05341003f, 0.07276796f, -0.13461247f, -0.07099716f, -0.11631821f, -0.16860683f, -0.03414403f, 0.11661066f, 
    0.08752608f, 0.00341646f, -0.15253612f, -0.15444389f, 0.05832456f, -0.00411590f, 0.12456469f, 0.01194666f, 
    -0.09181541f, 0.04539093f, -0.20156769f, 0.10168634f, -0.04315906f, 0.02480093f, -0.15812038f, -0.07869928f, 
    0.11850885f, -0.06638969f, 0.19643629f, -0.05163919f, -0.21854559f, 0.21402763f, 0.05721849f, -0.11686586f, 
    -0.06600998f, 0.06686021f, -0.00484832f, -0.12870257f, 0.06662130f, 0.01607885f, -0.12648161f, -0.11099869f, 
    -0.01433017f, -0.15061271f, -0.06259736f, -0.00274842f, -0.21299446f, -0.08691446f, 0.08859530f, 0.09401222f, 
    -0.03939676f, -0.05304253f, -0.19974722f, -0.08258504f, 0.13282646f, -0.02156999f, 0.01357621f, -0.11962688f, 
    0.03339838f, -0.14610137f, -0.12317850f, 0.32866612f, 0.26699671f, 0.05709191f, 0.24589688f, -0.01063835f, 
    0.01186444f, -0.09894131f, -0.18952367f, 0.02735191f, 0.02827306f, -0.08565020f, 0.06787238f, 0.09545326f, 
    0.09223846f, -0.03150153f, 0.08115313f, 0.23545894f, 0.11126666f, -0.35762450f, 0.10070325f, 0.10346050f, 
    0.09569457f, -0.32485694f, 0.05190986f, -0.01590316f, 0.07812320f, 0.03104125f, 0.19377445f, -0.43757468f, 
    0.09389626f, 0.09665210f, 0.11548583f, 0.09874815f, -0.05532449f, 0.01430867f, -0.28702682f, -0.40757030f, 
    -0.42604381f, -0.10878894f, -0.27517521f, 0.18935145f, 0.14282589f, -0.08070450f, 0.11405982f, 0.21629007f, 
    -0.00923178f, 0.07435394f, -0.34090379f, 0.07000453f, -0.13133465f, 0.10719284f, 0.09870013f, -0.05742744f, 
    -0.28002265f, -0.03157958f, -0.16931090f, 0.06001347f, -0.00951115f, -0.09852576f, 0.17794110f, -0.20168717f, 
    -0.02917705f, 0.09154455f, 0.21413447f, -0.20369650f, -0.15643834f, 0.31399408f, 0.01253182f, 0.03874683f, 
    -0.02344716f, -0.02012442f, 0.38765290f, -0.04214618f, -0.11678606f, -0.01243587f, -0.12781017f, -0.07773220f, 
    0.04791581f, -0.14337979f, 0.45177481f, 0.32482266f, 0.05668001f, 0.01269488f, 0.01308257f, -0.05202577f, 
    -0.10569644f, 0.01484826f, -0.00718336f, -0.07151680f, 0.24108821f, 0.06933599f, 0.01493565f, -0.04420344f, 
    0.01548817f, -0.04698346f, -0.06494705f, -0.01005062f, 0.00467859f, 0.07223492f, -0.18690282f, 0.08509307f, 
    -0.27550536f, -0.09893677f, -0.30047974f, 0.09476522f, 0.16375083f, -0.03318658f, 0.09103451f, -0.07611697f, 
    -0.01848448f, 0.12724094f, -0.34540436f, -0.04154000f, -0.03155115f, 0.29715779f, 0.14696443f, 0.08407731f, 
    -0.23321642f, 0.24729122f, -0.15949950f, -0.00098122f, 0.12151560f, -0.22585337f, 0.03425935f, 0.07576440f, 
    0.03866750f, 0.13995574f, -0.22581482f, 0.04023485f, 0.21599786f, 0.11477626f, 0.00668966f, -0.11061635f, 
    0.02654883f, -0.01599177f, 0.26648933f, -0.05128545f, -0.10646103f, 0.18297131f, -0.01183257f, 0.01336485f, 
    0.06069691f, -0.05660624f, 0.01570509f, 0.20610416f, -0.09238446f, -0.07043463f, 0.10095299f, 0.13475169f, 
    0.09596679f, 0.25091109f, -0.05315815f, -0.07959905f, 0.10216770f, 0.31597531f, 0.01935067f, -0.10343274f, 
    -0.05167386f, 0.00734354f, 0.15191756f, -0.16172647f, 0.10681390f, 0.11525577f, -0.19485654f, 0.10119367f, 
    -0.08767866f, 0.05904138f, -0.11216549f, 0.38927230f, 0.10214814f, 0.03461730f, 0.00751657f, -0.14952283f, 
    0.04501250f, -0.00111315f, -0.23183215f, 0.02791666f, 0.04972532f, -0.08685046f, 0.33008122f, 0.00100362f, 
    0.17069127f, 0.05532968f, 0.27061263f, 0.22022308f, -0.09690440f, 0.50885653f, -0.13823147f, -0.15153159f, 
    0.07079139f, 0.29467449f, -0.09713253f, 0.15248436f, 0.31483638f, 0.04689890f, -0.14080504f, -0.05479852f, 
    -0.10157811f, -0.07191560f, -0.25742692f, 0.05723979f, -0.04174930f, -0.02528108f, -0.09075152f, 0.10705312f, 
    -0.04538915f, 0.20664428f, -0.23544069f, -0.21797808f, -0.03042579f, -0.07548513f, 0.11706512f, -0.06820847f, 
    0.36999580f, 0.19109133f, 0.12918225f, -0.02567112f, 0.21770483f, 0.28985840f, -0.08318009f, 0.08762906f, 
    0.09429459f, 0.05173508f, -0.09250873f, 0.01799598f, 0.20459948f, -0.02302481f, 0.07874570f, 0.13354304f, 
    0.07313227f, 0.11610413f, 0.11620412f, 0.06858316f, 0.05866424f, 0.03162650f, -0.09232967f, -0.05681328f, 
    0.17078756f, 0.05058828f, 0.32244003f, 0.08879178f, -0.18113081f, 0.02049319f, -0.16926275f, 0.09368429f, 
    0.41028032f, -0.20726466f, -0.17046462f, 0.04902182f, 0.11135491f, -0.13996281f, -0.01418070f, 0.05490492f, 
    0.09110505f, 0.18183053f, 0.02739983f, -0.03653190f, 0.17481072f, 0.05902569f, 0.16016151f, -0.08374847f, 
    -0.07823181f, 0.02835505f, -0.10499170f, 0.12074110f, 0.02998562f, -0.30227545f, -0.06065967f, -0.00192286f, 
    -0.01145106f, 0.22019087f, -0.28321648f, -0.16275705f, -0.04811858f, 0.04815577f, 0.03086041f, -0.06456723f, 
    -0.04442859f, 0.23796932f, 0.09901934f, -0.10837754f, -0.06036804f, 0.07800346f, -0.12688446f, 0.09928580f, 
    0.24248457f, -0.01211280f, 0.23693283f, 0.08713297f, 0.12899639f, 0.17173550f, 0.05543120f, -0.17397562f, 
    -0.04382670f, 0.10317297f, 0.18713810f, 0.00136847f, 0.05493424f, 0.02031647f, -0.26433530f, -0.13219082f, 
    0.22599676f, -0.18612827f, -0.04807282f, 0.04611720f, -0.14894594f, -0.20890699f, 0.06913232f, -0.08753610f, 
    -0.04897355f, 0.26306334f, 0.36328864f, 0.08435110f, 0.15965310f, 0.39364740f, -0.09397688f, -0.11526164f, 
    -0.07661449f, -0.05037189f, 0.03621282f, 0.15677963f, -0.12662943f, 0.15986140f, 0.07906587f, 0.11804448f, 
    -0.04297535f, 0.02893291f, 0.12680438f, -0.02598073f, -0.01574637f, 0.13266455f, 0.04225774f, 0.09689213f, 
    -0.10443947f, -0.45446226f, 0.41600925f, 0.18327408f, 0.10682501f, -0.14916390f, 0.07708383f, 0.11809240f, 
    0.02098063f, 0.02478997f, -0.10725015f, 0.07783771f, 0.16263913f, 0.02613662f, 0.21837898f, -0.04301825f, 
    0.11234971f, -0.39677620f, 0.10918602f, -0.06183327f, 0.11483446f, 0.22978161f, -0.24899200f, 0.10619223f, 
    -0.06844691f, -0.09898835f, 0.06595877f, -0.00619186f, 0.09318141f, 0.05070080f, 0.04904094f, -0.05598799f, 
    0.01177668f, -0.06297274f, -0.18026207f, 0.07509588f, 0.17093600f, -0.00602806f, 0.28496715f, -0.05324123f, 
    -0.42094526f, 0.23414119f, -0.02222322f, -0.12653057f, 0.03212259f, 0.00896691f, -0.13351212f, -0.10088065f, 
    0.04349241f, -0.03129375f, 0.00966133f, -0.05869021f, 0.10128244f, -0.09479412f, 0.20524654f, 0.10748847f, 
    -0.10265586f, -0.04953843f, -0.19890839f, 0.09573434f, 0.04382916f, -0.19277340f, -0.10994002f, 0.07218894f, 
    -0.10998074f, 0.40905076f, -0.53239030f, -0.14076161f, 0.05876039f, 0.21960932f, 0.01183567f, -0.05003413f, 
    -0.41756970f, 0.25126672f, 0.24779725f, 0.06307550f, 0.06130665f, -0.02123902f, -0.15518202f, 0.20230459f, 
    0.27244046f, -0.04825011f, 0.18366241f, 0.07888389f, -0.05501268f, 0.06253698f, -0.03119202f, 0.06754439f, 
    0.17399000f, -0.07456741f, 0.19552244f, -0.02344064f, -0.14133990f, 0.11200206f, -0.37078267f, -0.11855858f, 
    0.00306182f, -0.33665770f, 0.19106945f, -0.07322405f, -0.08154389f, -0.21979991f, -0.09757608f, 0.10646476f, 
    0.01301845f, -0.03208946f, 0.08870213f, 0.14917716f, 0.15495662f, 0.28231698f, 0.16012479f, -0.01258197f, 
    -0.12467730f, -0.03708498f, -0.02384130f, -0.05364641f, 0.04000208f, -0.07417409f, 0.15169267f, -0.07897525f, 
    0.01484540f, -0.01390751f, 0.09016044f, 0.02525406f, -0.37847763f, 0.00662759f, 0.02806585f, 0.06636235f, 
    -0.00485634f, 0.19957334f, 0.01612088f, 0.01280744f, 0.02787980f, -0.07069196f, -0.09681308f, 0.04495533f, 
    -0.19668695f, -0.02318512f, -0.22323713f, -0.12046936f, 0.24180052f, 0.08202238f, -0.33386311f, -0.05101980f, 
    0.16264686f, -0.20455229f, 0.15426083f, -0.11905063f, 0.04079284f, 0.14982684f, 0.02446268f, 0.12601642f, 
    -0.10026351f, 0.10262325f, 0.01347716f, 0.19432408f, -0.33889267f, -0.05425952f, -0.14343017f, -0.05119114f, 
    -0.14337514f, 0.17937180f, -0.18997087f, -0.07353114f, -0.25665429f, -0.08903521f, -0.04610944f, -0.03640340f, 
    -0.14418101f, 0.26921681f, -0.17645642f, 0.13525167f, 0.00441009f, -0.05839743f, 0.07740479f, -0.07635522f, 
    0.00648485f, -0.01471237f, 0.33621779f, 0.01831016f, 0.17436464f, -0.06073806f, 0.28190687f, -0.04679292f, 
    -0.12928766f, 0.08830172f, -0.17914675f, 0.00150609f, -0.09646942f, -0.04431809f, -0.05769304f, -0.05861197f, 
    0.08525386f, 0.24115522f, 0.11068983f, -0.09150237f, 0.10163970f, -0.08266704f, -0.11689192f, -0.11063658f, 
    0.21836983f, -0.08371492f, 0.21207152f, -0.09142886f, 0.18857498f, 0.12766881f, -0.00357257f, 0.05899049f, 
    0.19226685f, -0.04119065f, 0.12051582f, -0.04724879f, 0.23078328f, 0.13358755f, 0.06803561f, -0.08485252f, 
    -0.43890923f, 0.08420819f, 0.02119946f, -0.02204322f, -0.05803620f, -0.05112556f, 0.06041598f, 0.20144090f, 
    0.06127460f, 0.12109223f, -0.14907192f, 0.00439337f, 0.13306868f, 0.02727453f, -0.09630166f, -0.04555547f, 
    -0.03248436f, 0.12306586f, 0.00716859f, -0.19367905f, 0.20499372f, -0.30790690f, 0.13253811f, 0.10241859f, 
    -0.10829300f, -0.02446725f, 0.00647633f, -0.26694220f, 0.12926833f, -0.04022012f, -0.04083826f, -0.09927615f, 
    -0.09240110f, 0.08971974f, 0.17800885f, -0.01603392f, 0.12646231f, -0.00112526f, -0.02405674f, -0.08184693f, 
    0.00375940f, 0.07730336f, -0.21277523f, -0.06459397f, 0.04609405f, 0.35368976f, 0.07515568f, -0.00580535f, 
    0.03040369f, 0.04752062f, 0.17265473f, 0.03998250f, -0.11830080f, 0.01249018f, -0.04905116f, 0.19213291f, 
    -0.06549994f, 0.09033237f, -0.14608718f, 0.07401509f, 0.03042799f, -0.00177522f, 0.04876983f, 0.01450015f, 
    0.26667297f, 0.02858618f, 0.11207656f, 0.23245278f, -0.05266723f, 0.06622450f, 0.01228418f, -0.03542414f, 
    0.02153730f, -0.38694063f, 0.30043808f, 0.03842751f, -0.26953498f, 0.18704221f, 0.10790215f, -0.07353108f, 
    0.42803681f, -0.02780604f, -0.11746787f, 0.25930995f, 0.03787533f, 0.24252348f, -0.04503847f, -0.00481390f, 
    -0.07860036f, 0.14671417f, -0.02627667f, -0.06982955f, -0.02656701f, -0.12002015f, 0.00330515f, -0.00886542f, 
    0.00333487f, 0.04990640f, -0.14782527f, -0.09954308f, 0.01717606f, 0.04550793f, 0.02586090f, 0.08030916f, 
    -0.08559003f, 0.20211311f, 0.08142343f, -0.05710242f, 0.10838791f, -0.00571654f, 0.03483988f, -0.03847552f, 
    -0.20611906f, 0.20676509f, 0.19214161f, 0.01224820f, 0.21614015f, 0.26704404f, 0.00719393f, 0.17678630f, 
    0.27948529f, 0.05187868f, 0.29428187f, 0.03171537f, 0.09084043f, 0.14428042f, -0.05309032f, 0.23382245f, 
    -0.29421964f, -0.03551152f, 0.06096644f, -0.22731949f, -0.16052699f, -0.07618947f, 0.11753459f, -0.04747515f, 
    0.12321150f, 0.09716037f, -0.16521709f, 0.10444636f, 0.17772184f, -0.12288397f, -0.15241639f, -0.05760750f, 
    -0.14386684f, 0.24716811f, 0.01349319f, -0.06280360f, 0.07547845f, -0.30524543f, -0.03383598f, -0.01499171f, 
    -0.11031091f, 0.26776496f, 0.08796583f, -0.17533015f, 0.12907313f, 0.02650471f, -0.35963657f, -0.04257475f, 
    0.09622507f, 0.11967126f, 0.38958165f, -0.12294187f, -0.20445703f, 0.40908951f, -0.09967693f, 0.07260424f, 
    -0.02673714f, 0.03677037f, 0.31346929f, -0.04765675f, -0.13581313f, 0.14209269f, 0.11578907f, 0.06163822f, 
    0.26663303f, 0.17529508f, 0.09575528f, 0.04915877f, 0.11857409f, 0.07744224f, -0.13447942f, 0.16662867f, 
    -0.05264792f, -0.00419972f, -0.19494730f, -0.06599759f, 0.13956645f, -0.15726110f, -0.00603830f, 0.43493772f, 
    0.03565838f, 0.03834045f, 0.13653408f, 0.09900415f, -0.16683319f, -0.03137228f, 0.18218303f, 0.10348485f, 
    -0.10209876f, 0.02379074f, 0.30528498f, 0.08968383f, -0.04127127f, 0.13618462f, 0.03070857f, -0.11610880f, 
    0.43457800f, -0.14075592f, -0.46148416f, 0.05743274f, 0.05587029f, -0.24620195f, -0.15074840f, 0.27881074f, 
    0.03038697f, -0.17840514f, -0.29658014f, -0.04602097f, 0.34834304f, -0.26859456f, -0.06603675f, -0.04087405f, 
    0.10049068f, 0.10761932f, -0.24141151f, -0.10126893f, -0.01605952f, -0.03394029f, -0.12525816f, -0.09591842f, 
    -0.06965072f, -0.45500454f, 0.00081251f, 0.01281516f, 0.12225589f, 0.06285862f, -0.04219462f, -0.02323964f, 
    0.35937136f, -0.28944990f, -0.06371462f, -0.10377798f, -0.11024973f, -0.06047216f, 0.23804837f, -0.07409360f, 
    -0.31047818f, 0.32939413f, -0.00201621f, 0.11073568f, -0.07257885f, 0.19469686f, 0.04894842f, -0.15025039f, 
    0.24059996f, -0.10793044f, 0.14057976f, 0.18273595f, -0.03561566f, -0.09286621f, 0.04959910f, -0.02287640f, 
    0.26493126f, -0.18179387f, -0.09572606f, -0.00486615f, 0.05429713f, -0.08122044f, 0.08019701f, -0.03358715f, 
    0.23426987f, -0.21335775f, 0.25229049f, -0.25037044f, -0.17419656f, 0.24500610f, -0.05289872f, 0.18607701f, 
    0.02797443f, -0.02536602f, 0.13110569f, 0.36592114f, 0.08319090f, 0.08207485f, 0.05603725f, -0.12794587f, 
    0.00404154f, 0.02639064f, -0.04299858f, -0.06212512f, 0.03068640f, -0.20359237f, -0.06585948f, 0.04204410f, 
    -0.01850127f, 0.04913631f, -0.27587298f, 0.08774737f, -0.02226640f, 0.17567800f, 0.00487016f, -0.05931153f, 
    0.20928554f, -0.08586838f, -0.07186357f, -0.08929363f, -0.03945251f, -0.00587378f, -0.03240396f, 0.07445576f, 
    0.06367914f, -0.56607866f, 0.01694416f, 0.01329546f, 0.12297870f, -0.25097084f, 0.19085048f, -0.10549932f, 
    -0.43643287f, 0.06907901f, 0.01708715f, 0.32454029f, 0.11140981f, 0.02346328f, -0.02657065f, 0.10944813f, 
    -0.10647775f, -0.01157192f, 0.18322662f, 0.10053498f, 0.05702867f, 0.12284709f, 0.05147528f, 0.06518430f, 
    -0.00180661f, -0.19907463f, -0.23510927f, 0.12503703f, -0.03101029f, 0.02795890f, 0.20751424f, -0.18612112f, 
    -0.11497825f, 0.26808703f, -0.08822686f, -0.24366753f, -0.03064470f, 0.38502678f, -0.36649862f, -0.07485147f, 
    0.01920168f, -0.07082181f, 0.24004200f, 0.10434479f, -0.06910472f, -0.06705469f, -0.10242157f, 0.04883091f, 
    0.09800784f, -0.00553091f, 0.09978595f, 0.24409424f, -0.04520767f, -0.03441411f, -0.12189135f, 0.08177271f, 
    0.02627410f, 0.09451731f, -0.74238521f, -0.03219439f, -0.10822953f, -0.10613643f, 0.19111878f, -0.37307039f, 
    -0.18105887f, 0.18957807f, -0.18378696f, -0.03796484f, -0.11335983f, 0.09490275f, 0.07163058f, -0.40321490f, 
    0.14008637f, 0.07128252f, -0.04546640f, 0.24524136f, 0.20576695f, -0.02535808f, -0.02206296f, -0.15960790f, 
    -0.57360601f, -0.05980632f, 0.11436776f, 0.04437826f, 0.14401506f, 0.09352201f, 0.39031896f, 0.10137977f, 
    -0.11056536f, -0.07227927f, -0.56408089f, 0.24794325f, 0.11773290f, 0.16447285f, -0.05623513f, 0.04366288f, 
    -0.10742404f, -0.01894268f, -0.09084491f, -0.05764704f, -0.13637549f, -0.05285915f, 0.09227731f, -0.10204549f, 
    0.03014883f, 0.01845738f, 0.06112901f, -0.09240102f, 0.03381819f, 0.18297935f, 0.11548336f, -0.08588406f, 
    -0.07000459f, -0.14319405f, -0.16953228f, -0.07619061f, 0.12002914f, -0.07352214f, -0.11655626f, -0.04046067f, 
    -0.16317721f, 0.14899649f, -0.07600340f, -0.08461103f, 0.00870583f, -0.14712006f, 0.02653111f, -0.23244125f, 
    -0.10704290f, 0.06491496f, 0.10112886f, -0.09339682f, -0.17853697f, -0.16524757f, 0.05379511f, -0.14117126f, 
    -0.12411250f, 0.05638673f, 0.08298237f, 0.09065321f, -0.06086115f, -0.10631526f, 0.00191515f, -0.03342045f, 
    0.03003813f, -0.09281795f, -0.01546999f, -0.04564438f, -0.00155267f, 0.00344967f, -0.23009740f, 0.09045541f, 
    0.16855109f, -0.06897131f, 0.03052049f, 0.06158403f, -0.06310805f, 0.14208630f, 0.06331275f, -0.04175081f, 
    -0.11673421f, 0.12557170f, 0.08884250f, 0.04553966f, -0.09569329f, 0.08338223f, 0.07664699f, -0.06139132f, 
    0.06411000f, -0.04283090f, -0.16663140f, -0.00924081f, 0.10145789f, 0.04907383f, -0.03232148f, 0.07297894f, 
    0.06843506f, 0.10271081f, -0.06888381f, -0.14189175f, 0.08676727f, -0.04343628f, -0.10914223f, -0.01355779f, 
    0.10405523f, -0.01247663f, 0.08889618f, 0.04238866f, -0.07225156f, -0.11566938f, -0.13099536f, 0.08846880f, 
    0.08517974f, -0.10764041f, -0.06194158f, -0.14236447f, -0.08287296f, -0.22211309f, -0.04278915f, 0.01451266f, 
    -0.08575600f, -0.03841798f, -0.04315254f, -0.01887171f, 0.03892589f, 0.04901856f, -0.04552021f, -0.08576407f, 
    -0.03582053f, 0.04994554f, 0.20520045f, -0.06888408f, 0.10655677f, -0.16433646f, -0.17439851f, -0.01428533f, 
    0.02565248f, -0.20238641f, -0.00052903f, 0.00301366f, 0.10743924f, -0.05600778f, -0.11767424f, 0.12861532f, 
    0.04814057f, -0.08513283f, -0.09961507f, -0.05393752f, 0.05411276f, 0.01634391f, -0.12378606f, 0.00977558f, 
    -0.00816102f, -0.00230260f, 0.05220367f, -0.12015212f, 0.04421544f, -0.11514434f, 0.11938263f, 0.04822636f, 
    0.09975526f, 0.01391808f, 0.00993998f, 0.00739079f, -0.08437855f, 0.03819500f, 0.00676551f, 0.03795636f, 
    -0.04375404f, 0.05056432f, -0.01415736f, -0.03829865f, -0.05867737f, -0.07225197f, -0.15881391f, -0.01697654f, 
    -0.02920629f, -0.06392114f, -0.10463940f, -0.11152441f, -0.05853115f, -0.07817899f, 0.00316640f, -0.13617189f, 
    0.01219646f, -0.02734432f, -0.16593961f, -0.12298818f, -0.07040832f, 0.10473715f, 0.02748145f, 0.03962627f, 
    -0.00664173f, -0.16869840f, 0.07214853f, 0.01855257f, -0.01434065f, -0.03594075f, -0.02340194f, 0.10195438f, 
    -0.10506065f, 0.05852478f, -0.10678578f, -0.04324878f, -0.08521894f, 0.01562653f, 0.06281647f, -0.14678499f, 
    -0.00428848f, -0.06083912f, -0.04030660f, 0.21983269f, 0.10651767f, 0.10454758f, -0.03391423f, -0.03346100f, 
    0.09001771f, 0.02793506f, 0.33397764f, 0.05768365f, 0.02320548f, 0.15978409f, 0.02601233f, 0.02616045f, 
    0.04451249f, -0.06806357f, 0.19777097f, 0.24632861f, -0.09889688f, -0.06541462f, -0.03047566f, 0.02788219f, 
    -0.15362257f, 0.15021214f, 0.00551357f, 0.10272244f, 0.07722615f, 0.24350643f, -0.09194724f, -0.13005242f, 
    -0.00593313f, 0.12528060f, 0.21868567f, -0.15117727f, -0.13971883f, 0.08777165f, -0.10371353f, 0.10832267f, 
    0.16348925f, -0.12186414f, 0.00516244f, 0.29571503f, 0.01550720f, -0.00297979f, 0.06355318f, 0.03198324f, 
    -0.06938060f, -0.12865610f, -0.24748573f, -0.11711787f, 0.04680630f, 0.25050661f, 0.34877944f, 0.02808996f, 
    0.06015477f, 0.22681944f, 0.09731341f, 0.01641420f, -0.08725612f, 0.50142819f, -0.17513499f, -0.06755644f, 
    -0.04352075f, -0.11174216f, -0.18897256f, 0.36892462f, 0.31321841f, 0.06132165f, -0.10996097f, -0.02176405f, 
    -0.07048301f, 0.11503317f, 0.05632188f, -0.05145101f, 0.08291770f, 0.35722053f, 0.04784419f, -0.04487792f, 
    0.04554155f, 0.01826828f, 0.06930639f, -0.01023812f, -0.03334012f, -0.02325811f, -0.10805202f, 0.09810925f, 
    0.04160178f, 0.18758449f, -0.08214595f, 0.07984873f, 0.10134050f, 0.17651451f, -0.14857146f, 0.07235934f, 
    0.10988601f, 0.08365317f, -0.04257935f, -0.09897372f, 0.04162386f, 0.00560059f, -0.06285635f, 0.05716854f, 
    -0.33193037f, -0.11938436f, -0.13129568f, 0.35344875f, -0.12820770f, 0.02382744f, 0.06811596f, 0.06076834f, 
    -0.02484756f, -0.18264546f, 0.02205998f, 0.04490000f, -0.01312327f, 0.06575974f, 0.04941219f, -0.08442607f, 
    0.27242151f, -0.04370895f, -0.34297737f, 0.10884037f, 0.08126378f, 0.25398430f, -0.21723056f, -0.18282838f, 
    -0.09011228f, -0.08593138f, 0.03092850f, -0.00903714f, 0.05546635f, -0.05881857f, -0.08351219f, -0.04642805f, 
    -0.12596576f, 0.07237892f, 0.04179033f, -0.03558173f, -0.13061237f, 0.09133559f, 0.10500905f, -0.02334303f, 
    0.00108752f, 0.03850647f, -0.00438082f, 0.03810311f, 0.11353482f, -0.09407787f, 0.00553845f, -0.06376232f, 
    0.00220009f, -0.13882838f, -0.05785038f, 0.00966090f, -0.13498572f, -0.13704167f, -0.05556631f, -0.12446501f, 
    -0.00330252f, -0.05772515f, -0.06170448f, 0.05421003f, 0.09444935f, -0.06163085f, 0.00315742f, -0.00757812f, 
    -0.12450337f, -0.10255875f, -0.11671262f, -0.09360864f, -0.07067002f, 0.07879613f, -0.01545402f, -0.10098838f, 
    -0.13090542f, -0.07355681f, 0.06908956f, 0.02543374f, -0.12982722f, -0.03086796f, 0.03336704f, 0.02260730f, 
    -0.07663269f, -0.14612126f, 0.11203150f, 0.02454521f, -0.03392421f, 0.01031923f, 0.08462963f, 0.05237426f, 
    -0.04438225f, -0.10435823f, -0.20189214f, -0.24667121f, 0.03916638f, 0.04934721f, -0.04651570f, -0.06983435f, 
    0.02503708f, -0.08915300f, 0.45706591f, -0.02153687f, 0.29388300f, 0.13683464f, 0.04619297f, 0.05349519f, 
    0.08226822f, -0.06248647f, 0.20683511f, 0.32311231f, -0.05690532f, 0.30191204f, 0.08098331f, -0.02785349f, 
    -0.27590942f, 0.23240134f, 0.11135119f, 0.04251218f, 0.21290641f, 0.21161273f, -0.09799186f, -0.07378132f, 
    0.04978501f, 0.20632505f, -0.03201350f, -0.19420478f, -0.06800228f, 0.04859746f, -0.06305329f, 0.14234346f, 
    0.25849292f, -0.09953991f, -0.08366993f, 0.20271568f, -0.11793739f, -0.08958859f, 0.19898537f, 0.01327206f, 
    0.09499703f, -0.15994975f, -0.19501598f, 0.07227496f, 0.01140381f, 0.22695424f, 0.22616419f, -0.09590100f, 
    0.28518668f, 0.04973027f, -0.19521351f, 0.15584119f, -0.00978301f, 0.33345020f, -0.17184757f, 0.09302490f, 
    -0.11571433f, 0.01009027f, -0.00031799f, 0.06396034f, -0.06820039f, -0.13003942f, -0.08119069f, 0.06040361f, 
    -0.12836130f, 0.08707771f, 0.06128779f, -0.00818650f, 0.10787898f, -0.15042908f, -0.02548642f, -0.08541392f, 
    -0.10089442f, -0.00539606f, -0.01830634f, -0.07521255f, 0.02079939f, -0.12335811f, 0.01323308f, 0.11153328f, 
    -0.07730701f, -0.01272536f, 0.01872535f, 0.07739077f, -0.01948044f, -0.12639974f, 0.00364598f, -0.00256564f, 
    -0.00624985f, -0.10641813f, -0.14872068f, -0.00322452f, 0.00956600f, -0.03877286f, -0.05086090f, 0.01408681f, 
    0.03720443f, -0.12447275f, -0.15681913f, -0.03671779f, -0.08248231f, 0.00573937f, 0.04526858f, -0.03019106f, 
    0.08389727f, -0.12705371f, 0.01070553f, -0.08985254f, -0.02498128f, 0.07758992f, 0.06727365f, -0.07637499f, 
    -0.08130250f, -0.04012471f, -0.15920211f, 0.05978339f, 0.00964283f, -0.02593550f, -0.08489279f, 0.04755718f, 
    -0.06089538f, -0.05348567f, 0.04493749f, -0.18731633f, 0.00885559f, 0.09973186f, -0.30655822f, 0.05364591f, 
    -0.02666172f, 0.00620994f, 0.07390142f, -0.06479892f, 0.11403585f, 0.04124356f, 0.03877795f, 0.08820040f, 
    0.03851864f, 0.03429574f, -0.30983701f, -0.20222139f, 0.07244527f, 0.30534464f, -0.01503389f, 0.08484922f, 
    0.21194708f, 0.16039656f, -0.09835448f, -0.10605581f, 0.12970445f, 0.14000721f, -0.05744455f, 0.19558831f, 
    -0.08767661f, 0.14572360f, -0.33980358f, 0.08737042f, 0.19773279f, -0.23268159f, -0.14971027f, 0.25020093f, 
    0.23259471f, -0.03435105f, 0.02786205f, 0.19983912f, 0.00582110f, -0.01582167f, 0.03149157f, -0.03140191f, 
    -0.09510397f, -0.24207029f, 0.47471932f, 0.11384948f, -0.21872211f, 0.13472907f, -0.20153038f, -0.04684725f, 
    0.34367204f, -0.18968971f, -0.44421995f, 0.24345776f, 0.06513659f, -0.09879469f, 0.12222195f, 0.07253822f, 
    -0.03746234f, -0.28920493f, -0.10727141f, -0.03126709f, 0.11396776f, 0.02475602f, 0.22767372f, 0.03953526f, 
    0.10735475f, 0.09479350f, 0.21376905f, 0.04964070f, 0.30600458f, -0.14174944f, -0.12170400f, -0.04962481f, 
    -0.11646959f, 0.11873367f, 0.09867658f, 0.14295180f, 0.10094871f, -0.01689466f, 0.05948442f, 0.12174755f, 
    -0.19889511f, 0.05888109f, 0.17351305f, 0.05298712f, -0.18149430f, 0.09740379f, 0.04425716f, -0.08170162f, 
    0.02368790f, 0.11385234f, 0.13689812f, -0.22617491f, -0.05299137f, -0.20497717f, 0.03085048f, -0.25588992f, 
    0.30984747f, -0.01199258f, 0.01802848f, 0.17232923f, -0.00242981f, -0.00110157f, 0.16489656f, 0.21489856f, 
    0.16222939f, -0.53572243f, -0.02885472f, -0.03800095f, -0.15700695f, 0.36522830f, 0.05472546f, 0.05150045f, 
    -0.18307349f, 0.09045126f, -0.07815383f, 0.13607621f, -0.02547929f, 0.58935392f, -0.19213428f, -0.21736553f, 
    -0.07958345f, -0.14097717f, -0.08967697f, -0.36188495f, -0.05782986f, 0.00204440f, 0.02567065f, 0.06418958f, 
    0.11788797f, -0.06775349f, 0.08690944f, 0.01287460f, 0.10898052f, 0.37367243f, 0.06587189f, -0.12508717f, 
    -0.07335099f, 0.12448701f, 0.14890550f, 0.10725462f, -0.03266971f, 0.08663059f, 0.10630821f, -0.11951219f, 
    -0.20770641f, 0.01298539f, -0.01022157f, -0.09490345f, 0.25580615f, 0.15003701f, 0.09166231f, 0.06237338f, 
    0.09648061f, 0.16592419f, 0.03983188f, -0.01032484f, 0.17745535f, -0.03466264f, -0.00449354f, 0.18414551f, 
    -0.22360753f, -0.07705831f, 0.01718110f, -0.04517865f, -0.26411071f, 0.00798343f, 0.16728126f, 0.10979863f, 
    0.05386706f, 0.01102463f, -0.14530866f, 0.08170617f, -0.14659573f, 0.21815281f, -0.22572790f, -0.05606152f, 
    0.01206875f, 0.01737152f, -0.48549923f, 0.04522103f, 0.09502505f, -0.31056151f, -0.00511708f, 0.14429492f, 
    0.12258554f, 0.05894855f, 0.28041387f, -0.15299109f, -0.18766417f, 0.08922147f, -0.09190227f, 0.00289892f, 
    -0.12768766f, -0.00602719f, 0.28012952f, 0.12197171f, -0.02342593f, 0.17277759f, -0.04287917f, -0.03247927f, 
    -0.05392966f, 0.06196779f, 0.17048061f, 0.10323337f, -0.05160150f, 0.05833288f, -0.06102245f, 0.08709633f, 
    -0.15791632f, -0.09280270f, 0.04960940f, -0.05721264f, 0.12850736f, -0.20950636f, 0.15717110f, -0.01917618f, 
    0.04863835f, 0.28221235f, -0.00985017f, 0.06163067f, 0.06051708f, 0.07898480f, 0.00967260f, 0.27041903f, 
    0.07386687f, 0.07405879f, -0.04528971f, -0.15624659f, -0.04627125f, -0.10474221f, 0.02979434f, 0.01341557f, 
    -0.12246113f, 0.08995289f, 0.13956197f, -0.14336319f, 0.12487876f, 0.18198481f, -0.04693302f, 0.10869436f, 
    0.20951678f, 0.02226267f, -0.01588145f, -0.11514586f, 0.04607499f, -0.23439528f, 0.25075036f, 0.26495138f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07209749f, 0.02237106f, -0.03141124f, 0.16657980f, 0.11278194f, 0.25459266f, 0.14356089f, 0.05408882f, 
    0.06697477f, -0.13596620f, 0.20586710f, 0.04249354f, 0.19658294f, 0.04999116f, 0.05848078f, 0.13737926f, 
    0.15538070f, 0.03196419f, 0.31346408f, 0.26363289f, -0.22129820f, 0.06168315f, -0.05046253f, 0.03120439f, 
    -0.04870836f, -0.00939964f, -0.03138930f, 0.13017735f, 0.13898692f, -0.06731007f, 0.00047500f, 0.21330632f, 
    0.18435237f, -0.09169674f, -0.00399067f, 0.18442643f, -0.04843055f, 0.10436288f, 0.27922741f, 0.03011285f, 
    0.03932769f, -0.12251702f, 0.17588222f, 0.04493511f, -0.10467403f, 0.06648023f, 0.02922152f, 0.02794513f, 
    0.04911504f, -0.11174385f, -0.10831694f, -0.15596668f, 0.15602282f, -0.14236507f, -0.11227550f, 0.06396603f, 
    0.00904458f, -0.11522935f, 0.03026934f, -0.11920369f, 0.15181968f, -0.00477747f, 0.16375574f, 0.07052744f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.16076639f, -0.23272480f, 0.26877058f, -0.02945133f, 0.00819997f, -0.16131829f, 0.16663189f, 0.23234724f, 
    -0.22336641f, -0.10598688f, -0.21951868f, -0.23834747f, -0.13117956f, -0.13926423f, -0.63306558f, -0.25356972f, 
    0.01179894f, -0.50417423f, -0.02521917f, -0.20974839f, -0.48587295f, -0.54611152f, 0.09860903f, -0.18362203f, 
    0.26461756f, -0.02542110f, -0.02327555f, 0.19451027f, -0.00878904f, -0.05070573f, -0.02546497f, -0.02955435f, 
    -0.51080525f, 0.16786882f, 0.05826350f, -0.47838026f, -0.13232444f, -0.16330680f, -0.32850680f, -0.08399443f, 
    0.26722491f, 0.06727105f, -0.15957743f, 0.18656033f, -0.21687789f, 0.05026942f, 0.09292249f, 0.09028678f, 
    0.11549998f, -0.08620191f, 0.13295497f, 0.21731327f, 0.07760897f, 0.07778570f, 0.04160104f, -0.21236806f, 
    -0.03844047f, 0.02399972f, -0.20486622f, -0.09449448f, 0.25209007f, -0.23686308f, -0.15113798f, 0.06297614f, 
    -0.27398759f, 0.11925648f, 0.22508326f, 0.10402445f, 0.01168160f, 0.04812268f, 0.08071437f, 0.00398121f, 
    0.00994778f, -0.03139320f, 0.04978221f, -0.41192672f, 0.09024689f, -0.10893533f, -0.41657883f, -0.22953780f, 
    -0.00555817f, 0.27484417f, 0.17925335f, 0.24009569f, -0.04814961f, 0.00029013f, -0.82335955f, -0.06313721f, 
    -0.83731931f, -0.06843182f, -0.08273681f, -0.13302889f, 0.19342501f, -0.00872710f, 0.09496704f, -0.24127802f, 
    -0.26561773f, -0.05887637f, 0.03873545f, -0.24419774f, -0.31459323f, -0.07835254f, -0.11404325f, 0.09513635f, 
    0.10501867f, -0.00132031f, -0.19016120f, 0.13522144f, 0.14927593f, 0.00197935f, 0.09031709f, 0.21378949f, 
    0.05820820f, 0.08318085f, -0.04948214f, -0.34268776f, -0.00972574f, -0.00138432f, -0.02096592f, 0.10179436f, 
    0.21500313f, -0.00747648f, 0.16936190f, -0.11403380f, 0.10924982f, -0.23846099f, 0.13938111f, 0.11059763f, 
    0.25118107f, -0.23573729f, -0.08105206f, -0.02109367f, 0.09484027f, 0.10491436f, 0.23684351f, -0.68265462f, 
    0.08460191f, 0.01673329f, 0.26867849f, 0.07684108f, -0.37356552f, -0.08271694f, -0.20735455f, -0.02818437f, 
    0.14857097f, -0.73394907f, -0.13455871f, -0.12363438f, -0.47499704f, -0.16296667f, -0.66395080f, -0.21698508f, 
    0.05465274f, 0.00432863f, -0.08013435f, -0.09139828f, -0.41963401f, 0.02076824f, -0.11622843f, 0.05365716f, 
    0.07884546f, 0.08396874f, 0.17071375f, 0.18399931f, -0.01338683f, 0.16150041f, 0.23765180f, -0.21662952f, 
    -0.18135813f, -0.11674334f, 0.03652826f, -0.01213162f, -0.21610534f, 0.14711286f, -0.10977136f, 0.17616114f, 
    -0.18864107f, 0.01910895f, 0.12154791f, 0.01033280f, 0.09614019f, -0.26394838f, -0.03538060f, -0.05728680f, 
    0.12476188f, 0.00266532f, 0.15821445f, -0.00565911f, -0.17053162f, 0.32606208f, 0.29092669f, 0.05823030f, 
    -0.56563127f, -0.47797439f, 0.09945271f, -0.46582881f, 0.01307990f, -0.29340625f, -0.09847637f, -0.21614689f, 
    0.00125824f, -0.00410460f, -0.02643712f, 0.34738088f, -0.31224346f, -0.09751936f, -0.00259744f, -0.23801741f, 
    0.13347501f, -0.18819660f, -0.46460712f, -0.15616377f, -0.11218008f, -0.06033168f, 0.06627149f, -0.12709729f, 
    0.13916983f, 0.25188902f, 0.04095914f, -0.06658050f, 0.06181637f, 0.05286186f, -0.02956466f, 0.01409016f, 
    -0.05410295f, -0.24080373f, 0.12268297f, 0.07425696f, -0.09375907f, -0.46992180f, -0.14475621f, 0.14682449f, 
    -0.11421674f, 0.18816225f, -0.08431341f, 0.11181680f, -0.17359298f, -0.08654580f, 0.20900337f, -0.13764648f, 
    -0.16251801f, -0.52556437f, 0.02024986f, 0.21017273f, 0.03062163f, 0.00309606f, -0.13280587f, 0.21796954f, 
    0.07611481f, 0.02476591f, 0.15288328f, 0.12436896f, -0.16706765f, 0.38771272f, -0.28812978f, -0.09273860f, 
    -0.05928617f, 0.07188506f, 0.08672302f, -0.17620121f, 0.00041484f, -0.77034515f, -0.00974760f, 0.11198680f, 
    0.02151995f, 0.08793668f, -0.17624593f, 0.08666435f, -0.26823485f, 0.02447487f, 0.28205407f, -0.24800298f, 
    0.14275108f, 0.20315383f, 0.00852364f, -0.02462489f, 0.27394494f, -0.21277875f, 0.11370515f, -0.13294494f, 
    0.16030075f, -0.08630136f, -0.10143402f, 0.04930029f, -0.06025327f, -0.02004230f, 0.01106767f, 0.24221568f, 
    0.05236499f, 0.03843321f, 0.13729443f, -0.04274430f, 0.13691655f, -0.21576166f, 0.00522114f, 0.04136207f, 
    0.03611889f, 0.16243422f, -0.12509130f, 0.11912552f, 0.04237102f, 0.11513513f, -0.17955697f, 0.14135477f, 
    -0.16199125f, 0.17959969f, -0.18043363f, 0.12447666f, -0.19152787f, -0.06612584f, -0.07647669f, -0.13271263f, 
    -0.23215985f, -0.00221383f, -0.29109147f, -0.04672483f, -0.39548907f, -0.30738708f, -0.17582358f, 0.12075831f, 
    -0.27120215f, -0.20068561f, -0.09792119f, -0.03670096f, -0.09131745f, -0.21952130f, 0.13816474f, -0.04856238f, 
    0.19566883f, 0.04938614f, -0.13894574f, -0.30762440f, -0.46989641f, -0.00653101f, 0.47589552f, 0.02930335f, 
    -0.06330083f, -0.13130650f, 0.10044736f, -0.47176433f, -0.10281920f, 0.10552333f, 0.14301370f, 0.18034549f, 
    -0.16046037f, -0.06804370f, 0.05750955f, 0.35693613f, 0.05361702f, -0.07189167f, 0.08751135f, 0.14422011f, 
    -0.54060459f, 0.10332830f, -0.21349469f, 0.15522495f, -0.06033796f, -0.33879679f, 0.10773006f, -0.03081500f, 
    0.12245230f, -0.09156631f, -0.01102304f, -0.13003388f, -0.23156035f, 0.02198531f, 0.11788645f, -0.04492272f, 
    0.07374421f, 0.10486951f, 0.05325200f, 0.02950328f, -0.09511708f, -0.06363288f, 0.02028320f, -0.18591520f, 
    0.08547480f, -0.05541480f, -0.05365499f, -0.02545594f, 0.27090108f, -0.40795633f, 0.09924468f, 0.13008575f, 
    -0.20004062f, 0.15774372f, -0.02725849f, 0.07041319f, -0.09407512f, 0.07820147f, -0.55492604f, -0.75039327f, 
    -0.39525411f, -0.07375444f, 0.15249258f, 0.08780906f, 0.21512187f, -0.03534000f, -0.04353192f, 0.01643526f, 
    -0.10170756f, 0.06022357f, 0.11299929f, -0.04821028f, -0.00763460f, 0.05394910f, -0.54370737f, 0.01869718f, 
    -0.24539024f, -0.08974316f, -0.03397074f, -0.09165715f, -0.39429539f, 0.09631160f, 0.01177897f, 0.19248578f, 
    0.35864425f, 0.21247269f, -0.00293076f, 0.24689548f, -0.16490839f, 0.23915413f, 0.09459554f, -0.29710996f, 
    -0.48899201f, -0.58077037f, 0.05460299f, -0.39672568f, -0.23533912f, 0.06636525f, -0.49600115f, -0.41735715f, 
    -0.32140613f, -0.21352953f, 0.18007740f, -0.27269819f, -0.16198885f, -0.05745284f, -0.09852049f, -0.01662902f, 
    -0.05915106f, -0.05244484f, -0.30274075f, 0.06419717f, -0.20493603f, -0.11364022f, -0.11178661f, 0.05452911f, 
    0.11647788f, 0.06656729f, -0.02117161f, -0.25315395f, 0.10505801f, 0.13874765f, -0.33793667f, 0.00205938f, 
    -0.33560649f, -0.00367077f, -0.34709525f, 0.15764858f, -0.38311422f, -0.02386939f, 0.05982441f, -0.03478489f, 
    -0.32837150f, 0.19073509f, -0.33207318f, -0.39471790f, 0.24588327f, 0.05451799f, 0.32362834f, -0.05572515f, 
    0.32272297f, 0.26352224f, -0.04292588f, 0.21022230f, -0.34351137f, -0.10539261f, -0.09584618f, -0.32800138f, 
    0.10885175f, 0.14411524f, 0.08263350f, -0.01476220f, -0.21481429f, -0.09287771f, -0.14269817f, -0.27267617f, 
    -0.14747003f, -0.19707856f, -0.23671126f, -0.07590141f, -0.23625006f, -0.27417892f, 0.19639239f, -0.31682962f, 
    -0.18336512f, 0.19206142f, -0.29640871f, 0.07661906f, 0.01288310f, -0.14304872f, -0.01747045f, -0.12728365f, 
    -0.15112919f, -0.02646113f, 0.18453668f, -0.15700066f, 0.21153557f, 0.21313733f, 0.16531678f, 0.02486051f, 
    -0.66911101f, 0.13352953f, -0.05895901f, 0.04393703f, 0.03957280f, -0.03230282f, -0.55252445f, -0.99451905f, 
    0.21100798f, -0.03678709f, 0.07319739f, 0.00898102f, 0.14615963f, 0.10940813f, -0.20851724f, -0.06995994f, 
    -0.59578627f, -0.00079764f, -0.35898376f, -0.03113618f, 0.18028019f, 0.10070633f, -0.18190113f, 0.02728830f, 
    -0.09725084f, -0.30460313f, -0.01926861f, 0.17296928f, 0.16141506f, -0.06950795f, 0.07254267f, -0.60507911f, 
    -0.10938408f, -0.09386770f, -0.30197233f, 0.02923766f, -0.26474938f, 0.02595351f, 0.20644364f, 0.21174729f, 
    -0.01626549f, -0.23762637f, -0.12228135f, -0.67658877f, -0.13141811f, -0.54808658f, 0.06361711f, -0.38984856f, 
    0.03458829f, -0.24318685f, 0.05984407f, 0.22400795f, -0.05820357f, -0.11597454f, -0.08004929f, 0.20861344f, 
    0.16612847f, 0.00186061f, 0.28200877f, -0.11651508f, 0.20760807f, 0.04041926f, -0.13221891f, 0.06311298f, 
    -0.73709130f, 0.18074638f, -0.31580311f, 0.08042622f, 0.04954593f, 0.10452507f, -0.23928516f, 0.28434619f, 
    -0.26600006f, -0.12399156f, -0.02249304f, -0.34013438f, -0.26566368f, -0.08355626f, 0.03123589f, 0.20973063f, 
    -0.05417833f, -0.18598443f, 0.18947476f, 0.11297462f, -0.33661717f, 0.18427262f, 0.11105572f, 0.12655941f, 
    -0.12763037f, 0.05100911f, 0.06061566f, -0.09088714f, -0.31001779f, -0.12750484f, 0.10013634f, 0.20721833f, 
    0.24231517f, -0.38843018f, -0.04051012f, 0.24701183f, -0.13108225f, -0.19024266f, -0.26116827f, -0.45453820f, 
    -0.11374068f, 0.08093136f, -0.10652366f, 0.36517012f, -0.52005994f, -0.03578703f, -0.02304353f, 0.05638592f, 
    -0.45417342f, -0.19871052f, 0.11460727f, 0.04319829f, -0.10692253f, 0.03111349f, -0.01029002f, -0.49557728f, 
    -0.11251134f, -0.03967277f, -0.30982327f, 0.06104378f, -0.00277906f, -0.22893591f, -0.09548956f, 0.07387239f, 
    -0.34719151f, -0.35159457f, 0.04429494f, -0.11895843f, -0.04693240f, -0.18630068f, -0.07304245f, -0.04082387f, 
    -0.02818747f, 0.07909047f, 0.07381895f, 0.56483185f, 0.29599625f, -0.09434541f, 0.22400491f, 0.38979623f, 
    0.05543413f, -0.51869488f, -0.05458311f, 0.14159136f, 0.04568737f, 0.10164192f, -0.26237598f, 0.01628896f, 
    -0.26214623f, 0.22682200f, -0.11083259f, -0.53046638f, 0.00035844f, -0.05682420f, -0.07160667f, 0.06682643f, 
    -0.09299741f, -0.45964158f, -0.41835096f, -0.24199860f, -0.02143112f, -0.30258048f, 0.19484003f, 0.08254027f, 
    -0.23634483f, -0.03874769f, 0.35429871f, -0.27544126f, -0.25785998f, -0.03438342f, -0.36610463f, 0.30918673f, 
    -0.01216440f, -0.52390265f, -0.47520405f, -0.18227424f, -0.20517837f, -0.16258886f, -0.03084633f, 0.26044935f, 
    0.05232729f, 0.03493153f, 0.17304699f, 0.01269767f, -0.53717136f, -0.12416802f, 0.01472757f, 0.08160613f, 
    -0.28415072f, -0.11953604f, -0.50499958f, 0.11829293f, -0.07056904f, 0.09732646f, 0.25639242f, -0.16616188f, 
    -0.01832610f, -0.05392266f, 0.12197000f, 0.15232198f, 0.32531905f, -0.12919754f, -0.00681182f, -0.24171788f, 
    0.11405349f, 0.15216365f, -0.05457714f, -0.33814836f, 0.14957902f, 0.05972936f, 0.36170036f, -0.20088217f, 
    -0.23415726f, -0.40743950f, 0.00474686f, -0.33462185f, 0.17583208f, 0.03781218f, 0.07532936f, 0.09699146f, 
    -0.27025118f, 0.06663667f, -0.36184964f, -0.02113033f, 0.20645496f, 0.28901649f, -0.24971956f, 0.20597285f, 
    0.14194830f, 0.05909195f, 0.02817849f, -0.08735663f, -0.50176102f, -0.09102710f, -0.35500479f, 0.13557357f, 
    -0.35906824f, -0.03237853f, 0.14308611f, -0.28095883f, -0.07927881f, -0.05498358f, -0.09222161f, 0.12011121f, 
    0.23661514f, -0.08876944f, -0.12026680f, -0.06059010f, -0.46824971f, 0.00464069f, -0.17305413f, -0.63749379f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.20773427f, 0.15479733f, 0.21894093f, -0.19183891f, 0.02455389f, -0.02163994f, 0.09112884f, -0.05313580f, 
    0.11577844f, 0.12678279f, -0.06320731f, -0.14369221f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
