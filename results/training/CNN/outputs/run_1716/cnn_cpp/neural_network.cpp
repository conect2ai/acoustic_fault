#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.64471197f, -0.28064352f, -0.46944928f, -0.44582251f, -0.29266062f, 0.52598357f, 0.16138028f, -0.13558237f, 
    0.05894473f, 0.07270938f, -0.36907578f, -0.38897848f, -0.07568032f, -0.25530067f, -0.09410841f, -0.10129452f, 
    -0.18615893f, -0.12375809f, -0.17643915f, -0.06074588f, 0.08136673f, 0.08388622f, 0.17323899f, 0.04507129f, 
    -0.12802725f, -0.38220730f, 0.68039048f, 0.93168044f, -0.74095166f, -0.49403328f, -0.67804617f, -0.15551320f, 
    0.11373583f, -0.15188165f, -0.18728447f, 0.18756799f, -0.24598770f, -0.06647914f, 0.22415096f, -0.06260113f, 
    0.02638951f, -0.17242077f, 0.30115053f, 0.19353855f, 0.16998243f, 0.02195234f, -0.09583265f, -0.33746281f, 
    -0.13050357f, -0.41999027f, 0.48706818f, 0.45327753f, 0.39367494f, -0.13886228f, -0.05232676f, -0.01341754f, 
    0.31228849f, 0.02597864f, 0.13749233f, -0.47924489f, 0.00123414f, 0.23510617f, -0.02163940f, -0.00777632f, 
    -0.04013201f, -0.09908214f, 0.01134851f, 0.13027413f, 0.12659934f, 0.10656767f, 0.27423343f, 0.03204717f, 
    -0.18060203f, -0.06517354f, -0.20520690f, 0.09887771f, -0.68996024f, -0.85732156f, 0.34008208f, 0.66498744f, 
    -0.07568255f, 0.45914954f, -0.25893578f, -0.46308333f, -0.79352218f, 0.16099320f, -0.58431506f, 0.08861682f, 
    -0.14066328f, -0.14235498f, -0.34470856f, -0.26988018f, 0.38303313f, 0.05391447f, -0.25215197f, 0.05208121f, 
    0.04353246f, 0.09873156f, -0.34212860f, 0.15128753f, -0.00783017f, 0.17867179f, 0.46792117f, 0.37944576f, 
    0.02862876f, -0.55041176f, -0.53699327f, 0.23498240f, 0.70830476f, -0.07724015f, -0.11853916f, -0.41794205f, 
    0.52008551f, -0.22901399f, -0.12656768f, -0.09134500f, 0.14682712f, -0.02078191f, 0.11871400f, 0.15263176f, 
    -0.31894317f, -0.25498372f, 0.09786681f, 0.26444024f, 0.18183151f, 0.69428211f, -0.62091058f, -0.17943990f, 
    0.14729124f, -0.58304554f, 0.09646560f, -0.00944604f, -0.31137702f, 0.07629002f, -0.14716074f, 0.26139867f, 
    -0.34985092f, 0.00748451f, -0.04206373f, -0.15961581f, -0.29657814f, 0.12724872f, -0.12881175f, 0.01611321f, 
    -0.36501187f, -0.44099256f, -0.28575599f, -0.16411008f, -0.52389568f, -0.47541720f, 0.14623706f, -0.43013036f, 
    0.18644455f, 0.47461680f, 0.01482409f, -0.45651525f, -0.56940264f, -0.35680497f, 0.10433923f, 0.62840182f, 
    0.26212889f, -0.04207146f, 0.01278064f, -0.10702293f, 0.33989793f, -0.26268613f, -0.03644437f, -0.24373040f, 
    0.26261657f, -0.22663531f, 0.27712288f, -0.16210255f, 0.32614258f, -0.01305545f, 0.17522842f, 0.49665263f, 
    0.05967037f, 0.56974465f, 0.32590428f, 0.46190637f, -0.23728420f, -0.09692200f, 0.14782120f, 0.11414571f, 
    0.18934229f, 0.04238087f, 0.09896216f, -0.00626356f, 0.15946639f, 0.11731046f, -0.06720421f, -0.03373675f, 
    -0.00486114f, 0.14735760f, -0.00220231f, 0.00340038f, 0.17626405f, 0.03166824f, 0.00780390f, 0.15955405f, 
    -0.98296696f, 0.15089057f, 0.83313394f, 0.13268039f, -0.39836562f, -0.68254584f, -0.01314793f, -0.40998203f, 
    0.29931620f, 0.25139868f, 0.07165411f, 0.37907264f, -0.50237733f, 0.38735512f, -0.12139970f, 0.16892783f, 
    -0.30737945f, 0.20367430f, -0.07904088f, -0.18985376f, 0.43147272f, 0.15950717f, -0.00803913f, 0.11397082f, 
    -0.13559806f, -0.47388002f, -0.68415034f, 0.18484935f, 0.29407117f, 0.28911999f, 0.38759729f, 0.26995352f, 
    0.12821285f, -0.19578864f, -0.14859805f, 0.39782116f, 0.16152008f, -0.10155147f, -0.43153191f, -0.13561623f, 
    0.10409480f, 0.35106769f, 0.11764132f, -0.16944841f, 0.12087908f, -0.21240194f, -0.07907033f, -0.20752519f, 
    -0.19822970f, 0.37158433f, -0.24660261f, -0.20707266f, 0.34027162f, 0.68094116f, -0.00236592f, -0.36850929f, 
    -0.23508453f, 0.02022874f, 0.11032433f, 0.13998964f, 0.21288629f, -0.19065784f, -0.30660102f, 0.62889659f, 
    -0.27614608f, -0.35600004f, -0.13165824f, 0.04278099f, 0.25227511f, 0.17144334f, 0.09233975f, -0.28949550f, 
    -0.08956444f, -0.04761837f, 0.04610875f, -0.36815065f, -0.24159837f, -0.65013379f, -0.62185800f, -0.29229954f, 
    0.24612267f, 0.05537447f, -0.15534513f, -0.18926384f, -0.13895790f, 0.32396296f, 0.39235890f, 0.51342672f, 
    -0.11185397f, 0.00778363f, -0.04067844f, 0.00029866f, -0.07013943f, -0.16284899f, -0.15840122f, 0.49949291f, 
    -0.29007411f, -0.30010527f, -0.26844269f, -0.22223186f, 0.12585650f, -0.75434572f, -0.43608636f, -0.32131121f, 
    0.20209470f, 0.33297005f, 0.32679600f, -0.33906966f, -0.66194528f, -0.18606545f, 0.13384070f, 0.00799386f, 
    0.55074495f, 0.03491902f, 0.27668718f, -0.24472633f, -0.45312920f, 0.06914830f, -0.17481613f, 0.20576814f, 
    0.16687225f, -0.43450740f, -0.21386130f, 0.38677046f, 0.21724513f, -1.28429639f, 0.09415644f, -0.08105285f, 
    -1.00299215f, -0.40666729f, 0.28540239f, 0.27058944f, 0.48758832f, 0.63845438f, 0.53723609f, -0.01803423f, 
    -0.02179270f, 0.15662454f, -0.22411527f, -0.01073699f, 0.09991103f, 0.00026743f, 0.06176823f, 0.14040132f, 
    0.10496797f, -0.01507030f, 0.03197063f, 0.19861168f, -0.10997394f, -0.26430643f, -0.78118640f, -0.67107409f, 
    -0.26838791f, 0.81681305f, 0.49483138f, 0.25044426f, 0.27832469f, -0.16201641f, 0.04578929f, 0.54104429f, 
    0.02726552f, -0.28071225f, -0.46992368f, 0.08128077f, -0.07975192f, -0.06335769f, 0.23613329f, 0.03729058f, 
    0.03179849f, 0.05929438f, 0.13143191f, -0.29123923f, -0.16203196f, 0.07561726f, -0.39366812f, -0.55546248f, 
    -0.79293227f, -0.24726002f, 0.36584970f, 0.28775382f, -0.12704058f, 0.20433323f, -0.10779998f, -0.61524057f, 
    -0.41353455f, -0.14774524f, -0.10567032f, -0.38638058f, 0.28440598f, -0.40923789f, 0.25608152f, 0.14096139f, 
    0.12882176f, 0.07810140f, 0.29743850f, -0.11098832f, -0.02721381f, 0.16920537f, 0.15726681f, -0.08746674f, 
    0.16711986f, 0.52330291f, 0.07111531f, 0.00834755f, -0.20058386f, 0.23350348f, 0.06934551f, -0.46523041f, 
    -0.47580349f, -0.10398621f, 0.43975034f, -0.24920216f, -0.11113936f, -0.11126462f, -0.10803854f, 0.19926631f, 
    0.16373451f, 0.06325787f, 0.22566880f, -0.42502445f, -0.14486201f, -0.14218430f, 0.19984227f, -0.10797732f, 
    0.47077575f, -0.48569584f, -0.38724291f, -0.46654451f, -0.64855617f, -0.35970035f, 0.28001451f, 0.09512767f, 
    -0.02507519f, 0.44527125f, 0.20634383f, -0.53843063f, -0.58940953f, -0.40782183f, 0.04108504f, -0.03364402f, 
    0.40853918f, 0.04168167f, -0.01195080f, 0.23387332f, 0.00892282f, -0.25765049f, -0.07965640f, -0.14291020f, 
    -0.24241009f, -0.44832277f, -0.36264041f, 0.06086883f, -0.54321027f, -0.58123451f, -0.46195015f, 0.18298480f, 
    -0.06916661f, 0.07792112f, 0.31376791f, -0.35446599f, 0.22402857f, -0.17322829f, -0.09403447f, -0.18800583f, 
    -0.03436690f, 0.19438238f, 0.19507110f, -0.27292308f, -0.14937618f, -0.14117788f, -0.04671630f, 0.28846222f, 
    0.33777341f, -0.04710521f, 0.25880536f, 0.08334590f, 0.25410092f, 0.12442712f, 0.07979692f, 0.16861510f, 
    0.00040112f, 0.10244752f, 0.01533259f, 0.19460371f, -0.02009490f, 0.16294365f, 0.09959167f, -0.11351499f, 
    0.22113168f, 0.02950348f, 0.33129868f, -0.26820874f, -0.22765595f, -0.10458276f, -0.46891224f, 0.20865981f, 
    0.21320267f, 0.15794566f, 0.13469332f, -0.06557120f, -0.47568238f, -0.81038207f, -0.04845085f, 0.08547977f, 
    0.70303810f, 0.17761557f, -0.20096497f, 0.38948157f, -0.54821724f, 0.08977482f, -0.41649035f, -0.28514257f, 
    -0.36098191f, 0.17264612f, -0.38981003f, 0.16651735f, -0.30302602f, -0.19932847f, 0.00473624f, 0.05983882f, 
    0.10210900f, -0.05131277f, -0.02868047f, -0.48906285f, -0.02962960f, -0.70116425f, 0.03792599f, 0.25632167f, 
    0.40277353f, -0.15278122f, -0.20240690f, 0.18262453f, -0.07305513f, 0.28527996f, -0.26607341f, 0.15809421f, 
    -0.05460615f, -0.40059081f, 0.81874603f, -0.48857689f, -0.34424430f, 0.16065900f, 0.04519451f, -0.05876569f, 
    0.41509178f, 0.01101455f, -0.01117966f, 0.30238083f, -0.16186890f, -0.13098711f, 0.57826406f, -0.39998478f, 
    -0.51836920f, 0.19230115f, 0.32867494f, -0.22079551f, 0.15530737f, 0.47050321f, 0.12104423f, 0.07258874f, 
    -0.10290710f, 0.73476988f, -0.52159530f, -0.55934632f, 0.02191833f, 0.07967906f, 0.01237274f, 0.26213616f, 
    -0.29289314f, -0.13266714f, 0.02227828f, -0.09862509f, -0.27958664f, -0.08946230f, 0.43871748f, -0.52263480f, 
    0.23128222f, 0.38793415f, -0.21288735f, 0.00442220f, -0.00192903f, 0.70184880f, -0.35202605f, -0.26601174f, 
    -0.42882141f, -0.38951939f, 0.28397715f, 0.14735544f, 0.19860478f, -0.02905665f, -0.31740010f, -0.25067252f, 
    -0.30943972f, 0.08988923f, 0.24077678f, 0.26891980f, -0.02717190f, 0.10905855f, -0.14204660f, -0.07919426f, 
    -0.28393498f, -0.26991600f, 0.40473109f, 0.00048517f, -0.31606960f, -0.12427095f, -0.35265929f, -0.33920452f, 
    -0.30126598f, 0.26838031f, 0.14392735f, 0.14772081f, -0.14712839f, -0.15264215f, 0.31650713f, 0.18387212f, 
    0.02065914f, 0.10376296f, 0.17189501f, -0.26635057f, 0.12836261f, -0.25414276f, -0.33906844f, -0.41732395f, 
    -0.25639635f, 0.49920431f, -0.22213313f, -0.03940523f, 0.29825625f, -0.00166023f, 0.23721534f, 0.46667284f, 
    0.10590257f, -0.02096874f, -0.09295571f, -0.20910709f, 0.09433581f, -0.22302611f, -0.26167780f, -0.09050648f, 
    0.22295606f, -0.20784575f, 0.27852178f, -0.00616942f, -0.40799221f, -0.15303682f, -0.20586054f, 0.35857883f, 
    0.33473182f, -0.14429122f, -0.21566977f, -0.19437861f, -0.00035945f, 0.05284975f, -0.15951152f, -0.59979820f, 
    -0.40759322f, -0.37316254f, -0.61895645f, -0.59973770f, -0.16158044f, -0.01829381f, 0.65245128f, -0.38291633f, 
    0.38016185f, -0.16695155f, -0.09801174f, -0.06328066f, 0.04825793f, -0.40051103f, 0.34480622f, -0.00125322f, 
    0.18081400f, 0.06346394f, 0.28790581f, 0.31295851f, -0.63537621f, -0.57748997f, -0.30370089f, 0.21652129f, 
    0.32944772f, 0.26766011f, 0.17242441f, 0.29962799f, 0.02917747f, 0.17521279f, 0.20556724f, 0.21044536f, 
    -0.15078233f, 0.33980966f, -0.03062293f, -0.16909002f, -0.31049168f, -0.36353672f, 0.05769815f, 0.15263511f, 
    -0.14792174f, -0.14191110f, 0.14834528f, -0.20342596f, 0.79444432f, -0.26087439f, -0.69370449f, -0.75639731f, 
    0.25370994f, 0.04957781f, -0.27473259f, -0.24472241f, 0.23265806f, 0.53390181f, 0.26558000f, 0.07007825f, 
    0.19945206f, -0.18618955f, -0.11410502f, 0.09359637f, -0.05632336f, 0.21761709f, -0.30111298f, -0.01224651f, 
    -0.06025984f, -0.32198232f, -0.08360230f, 0.35112277f, -0.06655945f, 0.26086813f, 0.17967874f, 0.14424083f, 
    0.16238983f, 0.23395419f, 0.28771237f, 0.12797652f, 0.24359226f, -0.20973872f, -0.05836771f, 0.22911112f, 
    0.19238877f, 0.06950163f, -0.01680032f, -0.03210057f, -0.13113759f, -0.00616088f, 0.20120211f, -0.14320245f, 
    0.19928795f, -0.04520929f, -0.13097647f, -0.24218233f, -0.12231095f, -0.18711571f, -0.50651199f, -0.47871721f, 
    -0.34331313f, -0.25953421f, -0.41381851f, 0.06288388f, 0.54278958f, -0.16600537f, 0.54758227f, -0.08400061f, 
    0.40303040f, 0.56606793f, -0.05403861f, -0.05542051f, -0.37772873f, -0.45721462f, 0.28254065f, 0.03835761f, 
    -0.11806788f, -0.30866617f, 0.17371731f, 0.21394289f, -0.02952267f, -0.02926827f, 0.47409633f, -0.23983856f, 
    0.76818740f, -0.48183680f, -0.60595065f, 0.24974984f, -0.27981460f, -0.02000881f, 0.56094521f, 0.04640852f, 
    -0.07122096f, -0.14551729f, 0.12313218f, 0.18862367f, 0.19111361f, -0.27335319f, -0.09623997f, 0.10355120f, 
    -0.47470999f, -0.14896584f, -0.09247822f, 0.19455421f, -0.38139829f, 0.18150966f, 0.41357836f, 0.11327068f, 
    -0.17416188f, -0.40728769f, -0.38072714f, -0.25855666f, -0.59634924f, 0.52465397f, -0.04149032f, -0.26766944f, 
    0.30887127f, -0.30162841f, 0.19858171f, -0.38242987f, 0.29916224f, 0.21811171f, -0.07795263f, 0.22342247f, 
    0.16660517f, -0.06936245f, -0.21126108f, 0.16288191f, -0.30997705f, 0.13193493f, 0.03759258f, 0.06124873f, 
    0.25027937f, -0.50956076f, 0.27925932f, 0.31469125f, 0.11169548f, -0.47408286f, 0.08538996f, 0.06776636f, 
    0.05107458f, 0.15324572f, 0.21335872f, -0.26151612f, -0.00845718f, 0.29611862f, -0.06742329f, -0.13254482f, 
    -0.07676549f, -0.14834121f, 0.05411289f, -0.13834096f, -0.23665792f, 0.14042856f, 0.14737454f, 0.24602798f, 
    0.10993443f, 0.39370170f, 0.63771909f, -0.75942934f, -0.41474524f, -0.63601172f, -0.03131543f, 0.22809234f, 
    0.21485844f, 0.00229826f, 0.41521153f, 0.30947024f, -0.19483180f, -0.09134586f, 0.05721852f, 0.09502646f, 
    0.21135682f, -0.03981949f, -0.05828905f, 0.02426876f, 0.17113525f, -0.33827439f, -0.21428530f, -0.22100443f, 
    -0.20795879f, -0.10595282f, -0.11021839f, 0.01899698f, -0.16224848f, -0.18814684f, -0.51286250f, -0.64833641f, 
    0.40742174f, -0.39040172f, -0.37247053f, 0.12862924f, 0.23665139f, -0.02169099f, 0.14939110f, 0.14007922f, 
    0.31821197f, 0.14126229f, -0.42804220f, -0.10428635f, -0.11490463f, -0.14154351f, -0.20205532f, -0.18274443f, 
    0.22023772f, 0.01354570f, 0.17115682f, -0.32008657f, 0.74571741f, 1.09149861f, 0.13480289f, -0.33427987f, 
    -0.37312204f, -0.52931422f, -0.50179845f, 0.22128481f, -0.27125487f, -0.65204036f, -0.01399440f, 0.10144877f, 
    0.11316954f, 0.01069655f, -0.10192537f, -0.08122108f, 0.01974968f, 0.19716331f, 0.09904734f, -0.10561389f, 
    0.05732109f, -0.15174067f, -0.42414638f, -0.32567167f, 0.05720644f, 0.84820491f, 0.59991950f, -0.25702846f, 
    -0.21302816f, -0.61044079f, -0.06750862f, 0.15777163f, -0.02920601f, 0.10014909f, -0.42633536f, -0.05379352f, 
    -0.30232427f, 0.13423684f, 0.00903806f, -0.03026714f, -0.33759311f, 0.25330615f, 0.16189018f, -0.12879814f, 
    -0.24222693f, -0.04817102f, -0.11839928f, -0.50486225f, -0.36006093f, -0.51467329f, -0.50439787f, -0.97849363f, 
    0.30842522f, 0.69130629f, 0.45970926f, 0.80786556f, -0.70228469f, -0.01530521f, -0.08317982f, -0.32198957f, 
    -0.43474796f, -0.07251770f, 0.11077949f, -0.17648353f, -0.34745178f, 0.20805471f, 0.05046261f, -0.14025162f, 
    -0.04734849f, 0.28454474f, -0.39564532f, -0.14651018f, 0.01172833f, 0.16556802f, 0.03272498f, -0.33715355f, 
    0.35950780f, 0.10917397f, -0.22224168f, -0.27586085f, -0.03719840f, 0.36920816f, 0.15495302f, 0.01162492f, 
    -0.36907807f, -0.24824098f, 0.37217188f, -0.15598093f, 0.34876814f, -0.30410033f, -0.25051820f, -0.20591131f, 
    -0.29250500f, 0.30091208f, 0.02638679f, 0.18033870f, 0.15298849f, -0.08007031f, 0.21849146f, 0.12360064f, 
    -0.05998246f, -0.22824520f, -0.31586045f, 0.39939234f, -0.30839521f, -0.52396387f, -0.60746533f, -0.63270319f, 
    -0.59554595f, -0.34899876f, 0.49234265f, 0.73229498f, -0.06748788f, -0.13990481f, 0.03324859f, -0.44401169f, 
    0.37441888f, -0.08973125f, 0.04548731f, -0.02849928f, 0.30792472f, -0.14440918f, 0.03064529f, -0.14157391f, 
    -0.19380534f, 0.29287359f, -0.08339712f, 0.28268978f, 0.15869290f, 0.13600557f, -0.20212145f, 0.03139667f, 
    0.11363324f, 0.10160566f, 0.26219150f, 0.03118446f, 0.11573311f, -0.01043869f, -0.25438458f, -0.13190737f, 
    0.32909110f, 0.04394504f, -0.06208781f, -0.17681876f, -0.38412306f, -0.40248385f, 0.22415110f, -0.29837713f, 
    -0.25479111f, -0.41323698f, 0.63273603f, 0.06963154f, 0.47293812f, -0.45346975f, -0.18950383f, -0.20276007f, 
    -0.04496432f, -0.35812134f, -0.06509495f, 0.05785490f, -0.04535066f, 0.24808176f, -0.09565452f, -0.01185817f, 
    0.40954760f, 0.40918595f, -0.11724040f, -0.26207617f, -0.20810035f, 0.10832582f, -0.13180962f, 0.15446880f, 
    0.19463000f, 0.14462647f, 0.27956340f, -0.57918823f, -0.46028191f, -0.42452243f, -0.50762331f, -0.25796622f, 
    0.69425511f, 0.23119305f, -0.43940175f, -0.29058015f, 0.92533529f, 0.11215758f, -0.46549097f, -0.34951329f, 
    -0.15958391f, -0.04797002f, -0.14515042f, -0.03766451f, 0.12819742f, -0.15918894f, 0.00736348f, 0.01539624f, 
    0.03398079f, 0.30247378f, 0.18793401f, -0.09155422f, -0.22588092f, -0.02745424f, -0.32505172f, -0.79484510f, 
    -0.77556896f, 0.82623821f, -0.13799848f, -0.00120162f, 0.33255959f, 0.63901448f, -0.00586338f, 0.03258990f, 
    -0.12495228f, 0.00939532f, -0.23805061f, -0.14487047f, -0.18839920f, 0.03797783f, 0.30685055f, 0.10487387f, 
    0.08076387f, -0.24117742f, 0.39845002f, -0.33267272f, -0.11264107f, 0.73093975f, 0.01956756f, 0.04981708f, 
    0.22225755f, 0.35472760f, -0.29089698f, 0.04664806f, -0.44760665f, -0.32179627f, -0.08759157f, -0.17583451f, 
    0.09161653f, 0.18554606f, 0.13460013f, 0.16166794f, -0.07754062f, -0.34055057f, 0.19319548f, 0.34842202f, 
    -0.08922250f, 0.11025571f, -0.07992138f, 0.07745764f, 0.11867890f, 0.02924894f, -0.44365248f, -0.42120895f, 
    0.58623850f, -0.15306570f, 0.04279805f, -0.40164602f, -0.54375112f, -0.35595950f, -0.34276128f, -0.19653003f, 
    -0.07123920f, -0.09485503f, -0.21654341f, -0.44053954f, 0.21960571f, 0.01326153f, 0.21696900f, 0.15058497f, 
    -0.00415570f, -0.00924255f, -0.13474463f, 0.13417673f, -0.01584503f, 0.00760805f, 0.24686670f, -0.66062713f, 
    0.28433424f, 0.71824640f, -0.91548407f, -0.54763561f, 0.27815127f, 0.22621997f, -0.13897499f, 0.03001623f, 
    -0.04303421f, -0.13059880f, 0.29903764f, -0.09221087f, 0.14046717f, -0.22308701f, -0.19076876f, -0.27451736f, 
    0.18202259f, 0.00557820f, -0.30853716f, -0.22798763f, 0.32469103f, 0.20785847f, -0.24936046f, 0.20879517f, 
    0.67662501f, -0.41437325f, 0.19464229f, -0.08584066f, 0.11803894f, -0.35102931f, 0.25419044f, 0.32292616f, 
    -0.13370681f, -0.03532219f, 0.10381733f, -0.16133568f, -0.30399293f, -0.10103375f, 0.48951089f, -0.06152610f, 
    -0.15921421f, 0.04604566f, 0.24566385f, -0.18342726f, 0.18288681f, 0.15209235f, 0.14815202f, -0.23522584f, 
    -0.42981911f, -0.20494735f, -0.71199381f, -0.56838155f, -0.01295883f, 0.04383712f, -0.49323955f, -0.36705229f, 
    -0.13687894f, -0.04013719f, 0.22432166f, -0.11061948f, 0.12313647f, 0.06025033f, 0.14902961f, -0.49657065f, 
    -0.02284409f, -0.06950048f, -0.14464048f, -0.01861680f, -0.01981523f, -0.25949374f, -0.15946035f, 0.04369842f, 
    -0.40719756f, -0.00862525f, 0.07923494f, 0.36375099f, 0.28746462f, 0.28853762f, 0.10877435f, -0.35578510f, 
    0.17576240f, -0.36787149f, 0.12073389f, 0.25811988f, 0.12128522f, 0.11702490f, -0.05471761f, -0.14954256f, 
    -0.19440198f, -0.07527283f, -0.14067520f, 0.29649243f, 0.20142059f, -0.19728544f, 0.04379141f, -0.11365008f, 
    0.22341989f, 0.09432609f, -0.16102707f, 0.34215206f, 0.56916910f, 0.48868442f, -0.41168955f, -0.35430843f, 
    -0.01846777f, -0.08280746f, -0.18534663f, 0.22213539f, -0.06847861f, 0.07757624f, 0.28628570f, -0.37636399f, 
    0.38773429f, -0.16088715f, 0.18192264f, 0.29119927f, 0.13212308f, -0.15319416f, -0.03340570f, -0.21634418f, 
    -0.19662926f, -0.10951300f, 0.00898953f, -0.18592101f, 0.56952262f, 0.55052686f, -0.21202457f, 0.10166360f, 
    -0.41306871f, -0.11496296f, 0.03796613f, 0.14610730f, 0.09981163f, 0.37044027f, 0.12896578f, 0.12478314f, 
    -0.05293874f, -0.34825009f, -0.18759377f, 0.25198373f, 0.15239252f, -0.26815376f, 0.02550037f, -0.21047623f, 
    -0.45758852f, -0.08807845f, -0.07609518f, -0.00120708f, -0.38896871f, 0.50816405f, -0.28900856f, -0.54906750f, 
    -0.29982591f, -0.36105114f, -0.09554474f, -0.53391141f, -0.13135149f, -0.70729995f, -0.84024805f, 0.28548646f, 
    0.09970308f, 0.44140592f, 0.14331441f, -0.03323350f, 0.13493459f, -0.13381635f, -0.30310890f, -0.09527215f, 
    -0.17340909f, -0.23320431f, 0.15624982f, 0.21948212f, -0.17498328f, -0.30641872f, -0.32872641f, -0.66079348f, 
    -0.52311981f, -0.53673053f, -0.75709563f, 0.44408089f, 0.33986726f, 0.15507303f, -0.14355384f, 0.16743739f, 
    -0.20945461f, -0.19997494f, -0.04140112f, 0.22712484f, -0.15680026f, -0.13816532f, -0.33276320f, 0.03499389f, 
    -0.22905393f, -0.36494502f, -0.50975955f, -0.27407214f, -0.19945216f, 0.11844497f, -0.11770009f, -0.29186630f, 
    -0.31269759f, -0.50743574f, -0.01768746f, 0.36781061f, -0.34719634f, -0.42383844f, -0.60769594f, -0.40340719f, 
    -0.04149866f, -0.16394487f, -0.28681111f, 0.30741414f, -0.18609951f, -0.30669305f, -0.06646895f, -0.12589945f, 
    -0.35020849f, -0.43717074f, -0.29258335f, -0.00542173f, -0.13153686f, -0.09814316f, -0.02975387f, 0.05833197f, 
    0.25777775f, 0.83623010f, 0.51323807f, -0.82272381f, -0.45709640f, -0.35905921f, 0.03571753f, 0.44227734f, 
    -0.18402936f, 0.04670134f, -0.41651964f, 0.12981173f, 0.72379249f, -0.37915286f, -0.25680658f, 0.19961539f, 
    -0.07475889f, -0.33064371f, 0.05683166f, 0.31521145f, 0.07033147f, 0.27547845f, 0.04244309f, -0.20400800f, 
    0.00238301f, -0.49982253f, -0.49523398f, 0.43198189f, 0.07006418f, -0.27842310f, 0.46699035f, 0.09811189f, 
    -0.59332883f, -0.59588736f, -0.48445287f, -0.26198593f, 0.10449885f, -0.37143224f, -0.61824644f, -0.31366929f, 
    -0.20590694f, -0.24855852f, 0.19593291f, 0.47134554f, 0.18770759f, -0.14257982f, -0.17097691f, -0.11821184f, 
    -0.19809482f, -0.36628953f, -0.87751257f, -0.49205765f, 0.06493514f, -0.53939682f, -0.16417375f, 0.72058117f, 
    -0.07281074f, -0.07357597f, -0.07345951f, 0.59218645f, 0.21752104f, -0.18067567f, -0.06814124f, 0.14152563f, 
    0.06023195f, -0.23488693f, -0.12300869f, 0.05861441f, 0.01041011f, -0.36019859f, 0.01758438f, -0.08160598f, 
    0.20536315f, -0.06794977f, 0.05315273f, 0.28918636f, 0.59769613f, -0.17991602f, -0.44828102f, 0.08168680f, 
    0.06494202f, -0.06604437f, -0.13034119f, -0.10663363f, -0.42603734f, -0.18653539f, 0.19577254f, -0.20041069f, 
    0.12181855f, -0.03501357f, 0.01070853f, -0.03222414f, 0.19666338f, 0.10860949f, -0.27173403f, -0.03062296f, 
    -0.00478122f, 0.32042125f, 0.19000924f, -0.04047147f, -0.75793016f, -0.71208614f, -0.38532755f, 0.69695348f, 
    0.76995301f, 0.16532981f, -0.25202265f, -0.48505625f, 0.00736593f, 0.50996649f, 0.05291953f, -0.20188706f, 
    -0.05617757f, -0.16605231f, 0.03637830f, -0.09359993f, -0.26698869f, -0.03758672f, 0.33452049f, -0.15678199f, 
    0.38362357f, -0.22147720f, 0.08140995f, -0.04627851f, 0.34480616f, -0.62934911f, -0.58016676f, -0.45760062f, 
    -0.07363243f, 0.38004515f, 0.38135493f, 0.31821385f, 0.12500225f, 0.10276470f, 0.23202576f, 0.26486996f, 
    0.13115926f, -0.37676302f, -0.07853700f, 0.47321296f, -0.44029352f, -0.13890910f, -0.08107431f, -0.05827350f, 
    -0.37681809f, 0.26775697f, 0.22470900f, 0.18878518f, 0.05126503f, 0.34038898f, -0.30119318f, 0.22330673f, 
    0.08018630f, 0.37150311f, -0.21746787f, -0.40827075f, -0.30277485f, 0.16759564f, -0.20687866f, -0.21683834f, 
    0.32537830f, -0.20579743f, 0.44380534f, -0.21987119f, 0.10153604f, -0.27064133f, 0.00752387f, -0.01229664f, 
    -0.00183088f, -0.01972150f, 0.09950458f, 0.04173450f, -0.05378048f, 0.45172524f, 0.04396589f, 0.53840172f, 
    0.65101963f, -0.17729934f, -0.14742041f, -0.26673907f, 0.68722755f, -0.42262781f, -0.33924592f, -0.03983595f, 
    -0.55487603f, -0.01834243f, 0.19677183f, 0.43431836f, -0.30695057f, -0.32196847f, 0.16269593f, 0.37686601f, 
    -0.20117758f, -0.05489865f, -0.10571983f, -0.37962818f, 0.34363061f, 0.00079852f, 0.05532217f, 0.26203501f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03722084f, -0.11544813f, -0.16625664f, 0.09185463f, 0.09579518f, 0.13080637f, 0.23836727f, -0.25871226f, 
    0.15464479f, -0.13284978f, 0.20763193f, -0.25368047f, 0.26055053f, 0.05825157f, 0.19696173f, -0.29150128f, 
    0.15961348f, -0.08035708f, -0.20813441f, -0.09509696f, 0.01674797f, 0.28318211f, 0.37213537f, 0.17830521f, 
    -0.21502271f, 0.10726632f, -0.27314183f, 0.04566624f, 0.08524668f, -0.34003669f, 0.13095176f, 0.10356884f, 
    0.05891194f, 0.10446852f, 0.03269118f, 0.25855628f, 0.27231321f, 0.08707037f, 0.01741160f, 0.24991499f, 
    0.18897310f, 0.05213506f, -0.09043111f, -0.11522748f, -0.02606537f, 0.03558816f, 0.02180745f, -0.05040694f, 
    0.21721891f, 0.00145861f, 0.12419307f, 0.10115413f, 0.27915823f, -0.18005182f, -0.01779990f, 0.11124058f, 
    0.17452592f, -0.29047740f, 0.35245267f, 0.07642114f, 0.15334022f, 0.09763798f, 0.11715771f, 0.14825866f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01614843f, 0.00910547f, -0.03065015f, 0.02087946f, -0.02813281f, -0.00769900f, -0.03770570f, -0.02334582f, 
    0.01506222f, -0.01105763f, 0.00630764f, -0.00518525f, -0.00016599f, 0.00618997f, 0.02681461f, 0.00146068f, 
    -0.03998103f, 0.00319120f, 0.01222770f, -0.02819986f, 0.00397471f, -0.00874249f, 0.01068573f, 0.01251248f, 
    -0.02450148f, 0.01682545f, -0.01950073f, -0.03230305f, 0.00096948f, -0.03138623f, 0.00321011f, -0.03139488f, 
    -0.01578046f, 0.01018316f, -0.03875789f, -0.01940599f, -0.00067493f, -0.03848534f, 0.00666962f, -0.02031505f, 
    -0.02716083f, -0.03448965f, 0.02003263f, -0.03639323f, 0.00188604f, -0.03576546f, -0.02834823f, -0.01889531f, 
    0.02288333f, 0.01757254f, 0.01170213f, -0.02595160f, 0.00003218f, -0.00742227f, -0.00272388f, -0.03661857f, 
    -0.03313139f, -0.03087171f, 0.00161773f, -0.03894090f, 0.01572071f, 0.00736208f, 0.02453471f, 0.00050906f, 
    0.02446820f, -0.03550663f, -0.01145570f, -0.00422393f, 0.01464995f, 0.01870780f, -0.01425884f, -0.03146344f, 
    -0.00776143f, -0.01522714f, -0.02640604f, 0.02124176f, 0.01644460f, 0.01388538f, 0.02051208f, 0.02270228f, 
    0.01653652f, -0.01289764f, 0.02868925f, 0.02295125f, 0.01587222f, 0.00729990f, 0.01724659f, 0.02277130f, 
    0.02358633f, 0.00251336f, 0.00437628f, -0.03582432f, -0.01865468f, -0.01535475f, -0.01345226f, 0.01323397f, 
    0.01361342f, -0.01602636f, -0.00395266f, 0.00622039f, 0.01805720f, -0.02536180f, 0.02483849f, -0.00581063f, 
    -0.03646544f, -0.03152448f, -0.00863338f, -0.00095377f, 0.01197214f, 0.02107173f, -0.00823349f, -0.02304089f, 
    0.01183479f, 0.00472379f, -0.02535179f, -0.00965873f, -0.01736218f, -0.00707487f, -0.01879658f, -0.00565433f, 
    0.00570393f, 0.02188941f, 0.01148123f, 0.01603509f, 0.02719005f, 0.02605334f, -0.03982495f, -0.03451753f, 
    -0.01657451f, 0.00076947f, 0.02425565f, -0.00240323f, 0.03453025f, -0.00264311f, 0.02708284f, 0.02690139f, 
    -0.01906424f, -0.01927381f, -0.00635554f, 0.02329956f, 0.00769735f, -0.02161393f, -0.00071331f, -0.00086069f, 
    0.02216892f, 0.01172838f, -0.03218107f, 0.00326155f, -0.03043610f, -0.03330674f, -0.02328051f, 0.02075118f, 
    0.00002011f, 0.01501984f, -0.04181093f, 0.00334584f, -0.00971855f, -0.00337138f, -0.01210332f, 0.01729232f, 
    0.02475175f, -0.03216881f, -0.02065428f, -0.03851026f, 0.02420459f, 0.00542679f, 0.02133089f, 0.00384418f, 
    -0.02705244f, -0.00643697f, -0.03299449f, 0.01638705f, -0.03693787f, -0.02537993f, 0.00963701f, 0.01497568f, 
    -0.03495772f, -0.00238636f, -0.01135037f, 0.00429263f, -0.03910946f, -0.00900716f, 0.01033624f, -0.02317774f, 
    0.02011259f, 0.01272644f, 0.01279373f, -0.02826411f, 0.01296474f, -0.03715158f, -0.03939591f, -0.03302761f, 
    -0.01445813f, -0.02216806f, -0.00205200f, 0.00353171f, 0.02193396f, 0.01101069f, -0.02575852f, 0.01329572f, 
    -0.00224035f, 0.01761165f, -0.03183657f, 0.01412194f, -0.01835056f, 0.02244795f, 0.00828889f, -0.00077547f, 
    0.02071585f, 0.01558340f, 0.02364012f, 0.02333429f, 0.00687975f, -0.02126002f, -0.03755045f, 0.02247148f, 
    0.01269265f, -0.01010564f, -0.02142587f, -0.03946134f, 0.00598966f, -0.02672529f, -0.04008418f, 0.01465293f, 
    0.01644043f, -0.03778667f, 0.02251972f, -0.04190426f, -0.01455791f, 0.00600914f, 0.02640403f, -0.00488401f, 
    0.02498995f, -0.04156359f, -0.00039961f, -0.01567756f, -0.00196052f, -0.02943941f, -0.03846944f, -0.03145285f, 
    -0.00330206f, -0.02952650f, -0.03229975f, -0.01615173f, -0.03878206f, -0.01860445f, -0.02734652f, -0.04077161f, 
    0.01615079f, -0.00288221f, 0.00179927f, -0.03963568f, 0.00223464f, -0.02679742f, -0.03715515f, -0.01214858f, 
    -0.00237272f, 0.01179918f, 0.01814512f, 0.02894545f, -0.02352412f, -0.04125715f, 0.00740296f, -0.01894518f, 
    -0.03837609f, -0.04033010f, -0.03263281f, 0.00608240f, -0.01744817f, -0.01037670f, -0.01960578f, -0.00530709f, 
    -0.03549398f, 0.02259008f, -0.04080893f, 0.01181509f, -0.03434943f, -0.01177958f, -0.03457665f, -0.02131199f, 
    -0.00110278f, -0.00933222f, -0.02570614f, 0.00633265f, -0.03843354f, -0.03290601f, -0.00444249f, 0.01784303f, 
    0.00154818f, 0.00925342f, 0.02529497f, 0.00115634f, -0.00290410f, 0.01328294f, 0.01478397f, 0.03299623f, 
    0.00953565f, 0.00487584f, -0.02960644f, -0.00747744f, -0.02977570f, -0.03254510f, -0.03509596f, -0.02852793f, 
    -0.01730284f, -0.00337489f, -0.02328143f, 0.02350095f, -0.01825712f, -0.00113560f, 0.02848006f, -0.02591902f, 
    -0.01676556f, -0.03423589f, -0.00257037f, -0.00569530f, 0.02946647f, 0.00129884f, 0.04198835f, -0.01227971f, 
    -0.03975512f, 0.01104885f, -0.00686153f, 0.02025922f, -0.03407912f, 0.01328884f, 0.00968570f, -0.00682677f, 
    -0.02976877f, -0.00851112f, -0.00661915f, -0.01272438f, -0.01334378f, 0.00747401f, 0.01415232f, 0.02755948f, 
    -0.03009644f, -0.01299472f, 0.00607029f, -0.02623482f, 0.01649786f, -0.03738763f, -0.00691661f, 0.02014064f, 
    -0.00885746f, 0.02586593f, -0.01757156f, 0.00695679f, -0.01714031f, 0.01257339f, -0.03698846f, -0.02876713f, 
    -0.00362028f, -0.02860698f, 0.01860284f, 0.00093537f, -0.02617238f, -0.01711464f, 0.01022049f, -0.01445521f, 
    -0.03877070f, 0.01989963f, -0.00217440f, -0.03459267f, -0.01688830f, 0.00398755f, 0.01802765f, -0.01394098f, 
    -0.03101508f, 0.02920197f, -0.03065620f, 0.01452660f, -0.01791780f, -0.02204258f, -0.01480547f, 0.02356709f, 
    -0.03997303f, -0.02405100f, 0.00917125f, -0.00115019f, -0.01993438f, 0.01368904f, -0.01965804f, -0.03427190f, 
    -0.02227159f, 0.01135697f, -0.02141886f, -0.03528850f, -0.01851709f, 0.01710469f, -0.03629620f, -0.02758982f, 
    0.01214436f, -0.02074912f, -0.03305407f, 0.02567854f, -0.01769535f, -0.02983813f, -0.02512321f, 0.00708674f, 
    0.00873031f, -0.02261815f, -0.02663159f, 0.00506551f, -0.01004416f, 0.01349472f, -0.04161663f, 0.00828344f, 
    0.00152031f, -0.00037356f, -0.01876763f, 0.00154504f, -0.00695315f, 0.00985255f, -0.03768723f, -0.01749806f, 
    0.01511762f, -0.00473468f, 0.00629881f, 0.00354212f, 0.00500295f, -0.03021014f, -0.02718500f, 0.01249732f, 
    -0.03953180f, -0.00455319f, -0.01657232f, -0.03994296f, -0.03058443f, -0.00585125f, 0.00658207f, 0.02806528f, 
    0.00043692f, -0.00757279f, -0.03952321f, -0.02612982f, 0.00549512f, 0.00449308f, -0.02410587f, 0.02145437f, 
    0.01476809f, -0.01916488f, 0.02168596f, -0.00755168f, -0.01164306f, 0.00550986f, 0.01371935f, 0.00695773f, 
    -0.03837596f, 0.00184173f, -0.00866903f, 0.00094674f, -0.01805256f, 0.00908755f, 0.00920561f, -0.01149988f, 
    -0.04157082f, -0.04019972f, 0.01662951f, -0.02429493f, 0.00253282f, -0.03896400f, -0.03012942f, -0.02751725f, 
    -0.02925107f, 0.03007625f, -0.00100086f, 0.00156651f, 0.01969314f, 0.02039780f, -0.03670173f, -0.03810557f, 
    0.02752675f, -0.02596547f, -0.02996577f, 0.02209477f, -0.00381701f, -0.03945319f, 0.02310990f, -0.03681256f, 
    0.00635295f, 0.01426609f, 0.01815881f, 0.01126786f, -0.02001218f, 0.02054170f, 0.00312789f, -0.03747881f, 
    -0.02213490f, 0.00574258f, 0.02291538f, -0.02567875f, -0.00506497f, -0.03322948f, -0.01756465f, -0.01749305f, 
    0.02440341f, -0.00873464f, 0.01637219f, 0.01321021f, 0.00176673f, 0.01181725f, 0.00886870f, -0.04177151f, 
    0.00486894f, 0.01473696f, -0.01974169f, -0.01557188f, -0.02369822f, 0.01444324f, 0.02702833f, -0.00967041f, 
    -0.01221275f, 0.00807281f, -0.00294764f, -0.01120045f, -0.03051110f, -0.03726336f, -0.02188168f, 0.02403629f, 
    0.01136568f, -0.02258585f, 0.02160946f, -0.02640474f, -0.00047698f, 0.00678656f, -0.02377536f, 0.00702222f, 
    -0.01011097f, -0.02874768f, 0.02343880f, -0.04201302f, 0.02276161f, -0.01136946f, 0.02200259f, -0.00659758f, 
    0.00110073f, -0.02907179f, 0.00327485f, 0.03602594f, -0.00965810f, -0.02952245f, -0.03894746f, -0.03317539f, 
    -0.01427337f, 0.01254341f, -0.00577752f, -0.02025012f, 0.02009148f, 0.02564698f, 0.00098113f, 0.02305322f, 
    -0.01997093f, 0.00111289f, 0.00157968f, -0.03382042f, 0.02515190f, -0.00387625f, 0.00568454f, -0.04170252f, 
    0.01213374f, -0.02669387f, 0.01118018f, -0.03917057f, 0.01804563f, -0.03180891f, 0.00020364f, -0.01096818f, 
    -0.02870458f, -0.03726565f, -0.03333108f, -0.02466762f, 0.00465636f, -0.00741917f, 0.00772701f, 0.02025913f, 
    -0.00390145f, -0.00821393f, -0.01878178f, 0.00776583f, -0.03191953f, -0.01257365f, 0.00701698f, 0.00550392f, 
    -0.01399002f, 0.01133246f, -0.02168205f, -0.01967344f, 0.02861894f, -0.00731683f, -0.00172243f, -0.00253842f, 
    -0.03289575f, -0.00275060f, -0.02805720f, -0.02409325f, 0.00503768f, 0.00706164f, -0.00028043f, 0.01372789f, 
    -0.03357689f, -0.01546873f, -0.01520210f, -0.01786125f, 0.01142249f, 0.02540630f, -0.03170130f, 0.02038535f, 
    -0.02633516f, 0.02655074f, -0.01964974f, 0.00011226f, 0.02468512f, 0.02486329f, -0.04120396f, -0.01289780f, 
    0.00666280f, 0.02449893f, 0.01961844f, -0.03645393f, 0.01816641f, 0.02546783f, 0.00122983f, -0.01698143f, 
    0.00280537f, -0.03402151f, -0.03573804f, 0.02196047f, 0.02756324f, -0.00746484f, 0.01099523f, 0.01522873f, 
    0.01639536f, -0.00145704f, 0.00814161f, 0.02831144f, -0.02180699f, -0.01833493f, 0.00797665f, 0.00465098f, 
    -0.02694287f, 0.01479819f, -0.00810799f, -0.00073226f, 0.01954797f, -0.02938652f, -0.01653187f, -0.04131404f, 
    -0.00824460f, -0.03673653f, -0.04084165f, -0.02368716f, -0.02325949f, -0.03397739f, -0.01169488f, 0.01597249f, 
    -0.00518029f, 0.02273734f, -0.01165417f, -0.03002328f, -0.04063751f, 0.00696034f, 0.01246374f, -0.00182861f, 
    -0.03918078f, -0.02256192f, -0.01104753f, 0.00938502f, 0.02075268f, -0.02835719f, -0.03280646f, -0.00739312f, 
    0.00661522f, -0.03742703f, -0.00215551f, 0.00084142f, 0.00713769f, -0.02885279f, 0.02909845f, -0.01064875f, 
    -0.00153123f, 0.02024979f, 0.01749240f, -0.01660302f, -0.03901482f, 0.00936556f, 0.01243045f, 0.00083018f, 
    0.02413640f, -0.02894492f, -0.01774223f, 0.00923873f, 0.02485293f, 0.02941938f, 0.01025129f, -0.02280888f, 
    0.02654368f, -0.00502122f, -0.00787497f, 0.02183537f, -0.01625622f, 0.01912910f, -0.01014842f, 0.01941114f, 
    -0.03660259f, -0.03397715f, 0.00232389f, -0.02517011f, 0.00871716f, -0.01932355f, 0.02729095f, 0.00907831f, 
    -0.01919928f, -0.01299790f, -0.03703832f, 0.02777641f, 0.02126250f, -0.00221808f, -0.00412080f, 0.01133559f, 
    -0.03889763f, 0.02444495f, -0.01474700f, 0.02257401f, -0.03141918f, 0.01643943f, 0.00881700f, -0.01227606f, 
    0.00751049f, -0.00431812f, -0.00476472f, -0.01660552f, -0.00144375f, 0.02974861f, -0.02694237f, -0.02400596f, 
    -0.00742890f, -0.00599059f, -0.00806032f, -0.02291429f, 0.01602962f, -0.01655082f, 0.02253686f, 0.02990838f, 
    -0.01420809f, 0.00613160f, -0.01174807f, -0.01343953f, -0.02899258f, -0.03679212f, -0.00877237f, -0.01889331f, 
    -0.00375759f, 0.01882570f, -0.02820132f, 0.02160664f, 0.03975730f, -0.01759455f, -0.00819603f, -0.00535743f, 
    -0.00511192f, 0.01196776f, 0.01197097f, -0.01375722f, 0.02767993f, 0.00071958f, -0.00753668f, 0.02851704f, 
    -0.18938851f, 0.15529989f, 0.30972716f, 0.04075450f, -0.07582800f, -0.03787974f, 0.08763837f, 0.18146038f, 
    -0.08570985f, -0.09508161f, -0.06578900f, -0.15937293f, -0.27681118f, 0.13848783f, -0.36815435f, -0.19964015f, 
    0.10713308f, -0.01993150f, -0.11591245f, 0.01003099f, -0.13738430f, -0.04697312f, -0.00208774f, 0.04142618f, 
    0.03191161f, 0.07177459f, -0.00275508f, -0.04575665f, -0.06710511f, -0.07839975f, -0.00250964f, 0.07143613f, 
    0.03617503f, -0.03381664f, 0.04932136f, 0.00995619f, -0.07880862f, 0.08032856f, 0.55070174f, -0.18206191f, 
    0.05333934f, -0.09753746f, 0.31601447f, 0.26275405f, 0.10517979f, -0.04896201f, -0.03795172f, -0.08132063f, 
    -0.30054381f, 0.12465772f, -0.28822547f, 0.17568010f, 0.04530337f, 0.13026029f, 0.03242935f, -0.19535498f, 
    -0.05715024f, 0.08168456f, 0.06463964f, -0.08675470f, 0.28206736f, 0.09729987f, 0.10224457f, -0.05490274f, 
    -0.02127493f, -0.09792906f, 0.05438191f, -0.06215550f, 0.06165073f, -0.03201175f, 0.11677636f, -0.02383627f, 
    0.00598734f, -0.31830952f, 0.09051106f, -0.01864259f, 0.19135214f, 0.31824386f, -0.05671349f, -0.02586735f, 
    0.08973582f, -0.01124203f, 0.01090959f, -0.01983105f, -0.02693751f, -0.05863945f, 0.05572407f, 0.01853096f, 
    -0.05136395f, -0.02705825f, -0.04805854f, 0.00241193f, -0.04062219f, 0.03827101f, -0.00476256f, -0.05191243f, 
    0.22685033f, -0.35992673f, -0.07165574f, 0.15056570f, 0.11291574f, -0.05930180f, -0.04464345f, 0.32175955f, 
    0.02767546f, -0.02578224f, -0.02028392f, 0.09454791f, 0.09618890f, 0.02443488f, -0.00890043f, 0.01350980f, 
    0.12154591f, 0.05633983f, -0.10298687f, 0.11616126f, 0.09577307f, -0.01489178f, -0.17648163f, 0.29285011f, 
    0.25270197f, 0.17034291f, -0.30949542f, -0.16907600f, 0.14404990f, 0.18485425f, 0.11937983f, 0.11928604f, 
    0.00671766f, 0.13556354f, 0.07194146f, -0.12224217f, -0.27272320f, -0.17200153f, 0.16928853f, -0.22469148f, 
    -0.11687865f, -0.15437990f, 0.04686318f, 0.04982936f, 0.01183329f, -0.11772486f, -0.02985552f, 0.04133166f, 
    -0.05570623f, -0.48930898f, 0.52356231f, -0.23769239f, -0.15580022f, 0.19096556f, 0.12308558f, 0.21361582f, 
    0.10974424f, 0.17277962f, 0.08548575f, 0.00537250f, 0.16997178f, 0.38856789f, -0.07534882f, 0.00764751f, 
    -0.14814691f, -0.13901404f, -0.15955745f, -0.06946583f, -0.08555575f, -0.17029925f, -0.02495017f, 0.02991945f, 
    0.51180297f, -0.26764268f, 0.18462053f, -0.08751339f, 0.00864548f, -0.11468030f, -0.04631045f, 0.04071612f, 
    0.19776036f, -0.08054894f, -0.02410547f, 0.01958772f, -0.31700695f, -0.20535630f, 0.39269429f, -0.04954101f, 
    -0.07253892f, -0.08775207f, 0.04295336f, 0.22892442f, -0.01472572f, -0.03885007f, -0.04302957f, -0.02013035f, 
    -0.02993068f, 0.02684410f, 0.03124022f, -0.44172791f, 0.10446285f, 0.02720294f, -0.02911954f, 0.12422884f, 
    0.01882145f, -0.01713952f, 0.09645609f, 0.06609140f, -0.26109949f, 0.10528919f, 0.23204766f, 0.06624585f, 
    0.13077818f, -0.08540743f, 0.06288385f, -0.07556010f, -0.01312967f, -0.12191711f, -0.07650696f, -0.15098296f, 
    -0.46101308f, 0.20010047f, 0.05628249f, -0.18733165f, 0.01114754f, 0.06806917f, 0.21490200f, -0.01441723f, 
    -0.06171950f, -0.05411011f, -0.14894468f, -0.03088284f, 0.05179362f, 0.00276490f, 0.01722624f, 0.03785695f, 
    -0.05250141f, -0.05909909f, 0.05905954f, 0.04519708f, 0.00893267f, -0.08478177f, -0.10881046f, 0.03659545f, 
    0.04257667f, -0.00329149f, 0.11416179f, 0.24112144f, 0.06398342f, -0.07978078f, -0.10383166f, 0.15571861f, 
    0.08661111f, 0.02925664f, -0.04536337f, 0.01059208f, 0.06580426f, 0.13082679f, -0.28604737f, 0.04915025f, 
    0.00834221f, -0.24883689f, 0.32013577f, 0.21534720f, -0.08776702f, 0.11694030f, 0.10721114f, 0.03980243f, 
    0.41847971f, -0.18338415f, 0.19765987f, -0.01055368f, 0.03173738f, 0.02412944f, 0.05119258f, -0.06477773f, 
    0.37754849f, 0.09638521f, -0.13474995f, 0.40133762f, 0.26754010f, 0.10769828f, 0.01454510f, -0.04381934f, 
    -0.12644300f, 0.03185981f, 0.15696687f, 0.08761636f, -0.01520208f, 0.11742990f, 0.11874563f, 0.09370696f, 
    -0.11006382f, -0.20173098f, 0.00071228f, -0.22476260f, 0.00231731f, 0.15941527f, -0.04962751f, -0.00539222f, 
    0.02790590f, 0.01299304f, -0.11361316f, -0.18563147f, 0.39761323f, 0.03541455f, 0.04632029f, -0.12024489f, 
    -0.02258618f, 0.00420402f, 0.07743932f, -0.04163700f, 0.05259404f, -0.03677589f, 0.24014269f, -0.04668676f, 
    -0.34521306f, -0.21282670f, -0.13768962f, 0.08330132f, -0.03664587f, 0.04643350f, 0.00601216f, -0.07841688f, 
    -0.04767560f, -0.05818022f, -0.01507888f, -0.06917123f, 0.20429663f, -0.20736992f, 0.14287509f, -0.00425463f, 
    -0.04074239f, -0.07508841f, 0.01976238f, -0.02925518f, -0.03056022f, 0.07193217f, -0.02903490f, 0.31935188f, 
    -0.07832729f, -0.05852195f, 0.38294441f, -0.18538570f, -0.13705868f, -0.10844296f, 0.03605982f, 0.00437875f, 
    0.30922100f, 0.28711280f, -0.03702156f, 0.07242870f, 0.04250902f, 0.08782157f, 0.01204761f, 0.00056553f, 
    -0.01775825f, -0.01542523f, -0.00230720f, -0.02039854f, 0.13498105f, -0.07114638f, -0.00816889f, 0.02113415f, 
    0.17890635f, -0.05156694f, -0.25336376f, -0.12202800f, -0.17912662f, -0.05216010f, -0.28142500f, 0.10947999f, 
    -0.14621963f, -0.04301112f, 0.21879396f, 0.11838497f, -0.09778583f, 0.16243421f, -0.22738537f, 0.22130418f, 
    -0.09108228f, 0.04900176f, 0.23026754f, -0.16553298f, 0.18782929f, -0.12366950f, -0.03769118f, 0.06189191f, 
    -0.13357757f, 0.02310003f, 0.14890030f, -0.12316959f, -0.02862852f, 0.08042742f, 0.19889069f, -0.00209194f, 
    0.00847654f, -0.01463785f, -0.00160749f, -0.02871769f, 0.00529430f, 0.09504220f, -0.12787457f, 0.00458366f, 
    -0.05223626f, 0.14648053f, -0.04423434f, 0.07122106f, 0.00791370f, -0.11201235f, 0.18598558f, -0.03794158f, 
    0.14426035f, -0.02805008f, 0.11358631f, -0.03934097f, -0.03989910f, 0.03334234f, 0.00924791f, -0.06502413f, 
    0.07424587f, -0.01283640f, 0.10489054f, 0.00988668f, -0.01464692f, 0.11592671f, 0.23981230f, -0.04206301f, 
    -0.14358753f, -0.05918022f, 0.07323845f, 0.19488733f, 0.03825097f, -0.02516003f, 0.09072978f, -0.16464476f, 
    -0.31051606f, 0.30170172f, -0.30462864f, -0.14653005f, 0.00388720f, -0.03330093f, -0.00625752f, -0.03385484f, 
    0.01473975f, -0.03981889f, 0.07545281f, 0.02308069f, -0.05431497f, 0.15069315f, -0.04734144f, -0.27176628f, 
    -0.04258784f, -0.00561466f, 0.08050358f, -0.11105816f, 0.06418081f, -0.07946031f, 0.14478813f, -0.08165845f, 
    0.26288345f, -0.03235189f, -0.17839384f, -0.00379372f, 0.12558417f, -0.02063148f, -0.09111676f, -0.01704504f, 
    0.17900304f, 0.22707306f, -0.15727097f, -0.11768802f, 0.00410589f, 0.11558864f, -0.16753732f, 0.02727147f, 
    -0.06067637f, -0.06709653f, 0.20771049f, 0.00186014f, -0.03251916f, 0.07299940f, 0.07643303f, 0.15877512f, 
    -0.25594276f, -0.16272733f, 0.10916695f, -0.02233796f, 0.07553354f, -0.02366041f, -0.00520763f, 0.01151580f, 
    -0.03770434f, -0.05534181f, -0.05712425f, 0.04943053f, 0.15087743f, -0.03186530f, 0.04972424f, 0.14768058f, 
    0.04095782f, 0.01086822f, 0.00057349f, -0.03381221f, 0.33875737f, -0.07150894f, -0.12295073f, 0.01464314f, 
    -0.18587629f, -0.02970686f, -0.00849939f, -0.05221797f, 0.05580035f, 0.06025087f, -0.15206397f, 0.00524536f, 
    0.03095275f, -0.08163680f, -0.03295525f, 0.03174503f, -0.13926251f, -0.21290350f, 0.51239979f, 0.02888101f, 
    -0.11744071f, -0.02569819f, 0.00645186f, 0.39423567f, -0.06163904f, -0.00919349f, -0.16021138f, -0.14179447f, 
    -0.07038499f, 0.28060871f, 0.24786964f, -0.24065858f, -0.05337992f, -0.09224983f, -0.03028013f, 0.07497851f, 
    -0.03929734f, 0.01263002f, -0.00024040f, 0.01422912f, -0.19982959f, -0.00378413f, 0.00991337f, -0.09930800f, 
    -0.03536201f, 0.13161248f, -0.01560416f, -0.02301854f, 0.01807011f, -0.03342644f, 0.03836232f, -0.03851806f, 
    -0.30323869f, -0.08707084f, 0.12481460f, 0.26668864f, 0.21034674f, 0.02091510f, -0.07682123f, 0.24986067f, 
    -0.01710361f, 0.04451111f, -0.06791832f, -0.02695732f, -0.29975367f, 0.34888035f, -0.03337760f, -0.04616079f, 
    0.07928826f, 0.04479926f, 0.04946822f, 0.18222851f, 0.00739163f, -0.01516950f, 0.32466906f, 0.04270837f, 
    0.37697709f, 0.07984672f, 0.10621528f, 0.12452131f, -0.01387896f, -0.03028433f, -0.03870840f, -0.03236975f, 
    0.11401711f, 0.04685986f, -0.03367827f, -0.01592534f, 0.14442022f, 0.00526642f, 0.17669778f, 0.36227202f, 
    -0.06986503f, 0.14287752f, 0.07773381f, 0.09701633f, 0.04808582f, -0.20546678f, 0.01232574f, -0.09667650f, 
    -0.02566849f, -0.07329964f, 0.13523817f, -0.08714674f, 0.04871611f, 0.04681031f, -0.02240609f, 0.00049273f, 
    -0.02932265f, -0.01648651f, 0.10868727f, -0.02013909f, -0.08284248f, 0.00499871f, -0.00070090f, -0.09797371f, 
    0.14172600f, 0.00043151f, 0.06991339f, -0.00413528f, 0.07310450f, -0.05173546f, 0.29621470f, 0.12430925f, 
    0.09572577f, 0.11699830f, 0.08625703f, 0.02929800f, 0.03499011f, 0.03521710f, -0.01185352f, -0.08272468f, 
    0.35065970f, 0.01267067f, -0.07710224f, -0.08356328f, -0.33733380f, 0.27825919f, 0.06477076f, -0.10132494f, 
    0.00732867f, 0.07948260f, 0.07674606f, -0.35173538f, -0.11207563f, -0.16186547f, -0.02255799f, -0.04843885f, 
    0.35265684f, 0.22724669f, 0.20531268f, 0.00823628f, -0.29357511f, -0.19568790f, -0.01888821f, 0.10907473f, 
    0.04863621f, -0.01001638f, -0.01147110f, -0.05438446f, -0.17023142f, -0.13773194f, 0.32158804f, 0.19148934f, 
    0.16225301f, 0.20087671f, 0.13733926f, 0.13636059f, -0.02627981f, -0.17342123f, -0.06248191f, -0.07463371f, 
    0.09786693f, 0.11542083f, -0.47481433f, 0.27674195f, -0.02604313f, 0.26545289f, -0.07741664f, 0.04296010f, 
    0.04552443f, 0.00172625f, 0.13409741f, -0.01815042f, -0.12549838f, 0.07634827f, 0.24503796f, -0.44395769f, 
    -0.08016474f, -0.00467600f, -0.12883955f, 0.35603917f, -0.05552435f, -0.09755235f, -0.02300619f, -0.13478480f, 
    0.18155706f, -0.04713269f, 0.23840384f, 0.02857162f, -0.08652571f, -0.06601954f, -0.16624412f, 0.36152929f, 
    0.05368652f, -0.03234024f, 0.00227927f, -0.04897213f, -0.24797052f, 0.13565585f, 0.04098002f, -0.15490068f, 
    -0.01191774f, -0.13609952f, 0.17796753f, -0.05142216f, -0.03021426f, -0.08277773f, 0.11538969f, 0.00537264f, 
    0.43669242f, -0.54699075f, 0.28660852f, 0.05269634f, -0.11682609f, 0.27589750f, 0.09713577f, 0.37269804f, 
    0.01209532f, 0.04149611f, 0.02399300f, -0.04057312f, 0.34424728f, -0.08799372f, 0.14859824f, -0.03469649f, 
    -0.10481390f, -0.06695656f, -0.02492944f, 0.09516918f, -0.19257331f, 0.15585461f, -0.10696820f, -0.07631958f, 
    -0.19814038f, 0.06794886f, -0.23069417f, 0.03974550f, -0.01564613f, -0.00564922f, -0.00872746f, -0.01997578f, 
    -0.03116599f, -0.01106757f, 0.03866513f, 0.08633373f, -0.21142790f, 0.23301429f, 0.02888074f, -0.32595798f, 
    0.41589886f, 0.05202689f, 0.04047550f, 0.32103911f, 0.00883381f, -0.09256165f, 0.10066980f, 0.00082945f, 
    -0.11301995f, -0.00539125f, 0.04175606f, 0.06205142f, 0.03378797f, 0.02665582f, 0.00742724f, -0.05521121f, 
    -0.02283377f, -0.02307220f, -0.08869825f, -0.11368592f, 0.22520794f, -0.05651919f, 0.02352889f, 0.01117777f, 
    0.11137425f, 0.07448284f, -0.00162514f, -0.07904821f, 0.08035281f, -0.09259912f, -0.01907482f, 0.13511285f, 
    0.09159400f, 0.04607323f, 0.02550210f, -0.05600457f, -0.01764703f, -0.02117432f, -0.00537141f, -0.10481836f, 
    -0.06820782f, -0.10482478f, -0.01879819f, -0.02191911f, -0.04238200f, -0.25848794f, -0.03373891f, 0.18922602f, 
    0.06038216f, 0.20149054f, -0.11359358f, -0.01942800f, 0.06563157f, -0.02442974f, 0.11713558f, -0.08448441f, 
    0.05692455f, 0.07899569f, 0.39836547f, 0.09008856f, -0.16226563f, 0.00025374f, -0.06970622f, 0.10959373f, 
    -0.11872389f, 0.01972264f, 0.00436341f, -0.16338634f, -0.16045907f, 0.07353059f, -0.06355351f, 0.04900767f, 
    0.06636781f, 0.00911319f, 0.00418842f, 0.11888074f, 0.07742389f, 0.07834246f, 0.05257089f, 0.23160835f, 
    -0.12163501f, 0.43607485f, -0.03276814f, -0.04774520f, 0.17103642f, -0.05519992f, -0.04494804f, 0.06902869f, 
    -0.11499424f, -0.04468172f, 0.02752840f, -0.04198365f, 0.11598621f, 0.10397527f, -0.03646268f, 0.09231194f, 
    0.00624795f, -0.04805629f, 0.01805122f, 0.09093593f, -0.07746262f, 0.01154871f, -0.03981765f, -0.09188901f, 
    -0.07821421f, 0.05502084f, 0.19642834f, -0.10618726f, -0.01878494f, 0.11206499f, 0.07719462f, -0.00571693f, 
    -0.02956483f, -0.04652497f, 0.12642834f, 0.16452716f, -0.09281693f, -0.12658195f, 0.07310490f, 0.09388164f, 
    -0.11749959f, 0.13033186f, 0.13734372f, -0.00309635f, -0.15315610f, 0.14717999f, 0.16227606f, -0.01062996f, 
    -0.13064647f, 0.27669403f, 0.34855330f, 0.19070059f, -0.04376148f, 0.02071386f, -0.12074078f, 0.02489980f, 
    0.08488113f, 0.03567628f, -0.02628184f, -0.00075075f, 0.17860107f, -0.13974236f, -0.07467046f, 0.04572661f, 
    -0.22998454f, -0.27404213f, 0.01079605f, 0.06850681f, 0.08583170f, -0.01274299f, -0.09782353f, -0.04798215f, 
    0.19449730f, 0.07956047f, -0.17696294f, 0.16956553f, -0.06884785f, -0.08814602f, -0.09942764f, -0.01979450f, 
    0.03446795f, 0.01339849f, -0.05782815f, -0.02241439f, -0.04964636f, 0.15531868f, 0.19189486f, -0.02605768f, 
    0.04476975f, -0.12857771f, 0.10193385f, 0.07548718f, -0.04860566f, 0.09294674f, 0.08751779f, -0.11459155f, 
    -0.26365644f, -0.08444931f, -0.05572962f, 0.23478486f, 0.01744842f, 0.05765730f, -0.02946068f, 0.02263877f, 
    0.11138550f, 0.14720732f, 0.04832060f, 0.17153573f, 0.05862008f, -0.04338650f, 0.14169291f, -0.15299135f, 
    0.00809223f, 0.13174011f, -0.03987730f, -0.01535431f, -0.11906144f, -0.00623001f, 0.01228497f, 0.01657560f, 
    0.04052191f, -0.06332018f, 0.19285710f, 0.21521267f, 0.11070437f, -0.12600259f, 0.01362067f, 0.05813767f, 
    -0.07639673f, 0.01710674f, -0.04812818f, -0.04672584f, -0.07371723f, 0.12510175f, 0.08330297f, -0.05128862f, 
    0.12231828f, -0.01483714f, 0.00931045f, -0.00531795f, 0.06979769f, 0.12464052f, -0.01761858f, 0.04871158f, 
    0.07351326f, 0.03693226f, 0.02955077f, -0.07753257f, -0.10957415f, 0.01437278f, -0.02602957f, 0.03535834f, 
    -0.03566369f, -0.15389392f, -0.18078846f, -0.11495924f, 0.02522989f, 0.01320386f, -0.07139491f, 0.00663477f, 
    0.01624098f, 0.06179247f, -0.01119811f, 0.00687991f, -0.14861344f, -0.06571271f, -0.07245769f, 0.20719768f, 
    0.05326333f, -0.07734778f, 0.36410335f, 0.08326004f, -0.12387284f, 0.17472154f, -0.01809942f, -0.14569101f, 
    0.11732215f, -0.05804003f, 0.05894458f, 0.07917417f, 0.01175987f, 0.02427625f, 0.23956943f, 0.09866474f, 
    -0.06770325f, 0.08043769f, 0.18139295f, -0.06239171f, -0.03506565f, 0.10961135f, 0.03095751f, 0.03778797f, 
    -0.09315410f, 0.15487748f, -0.05890649f, 0.22855020f, -0.09848368f, 0.21792729f, -0.09816764f, 0.04518792f, 
    0.06820887f, -0.02877949f, 0.04253597f, -0.06484627f, 0.19388963f, -0.00287954f, -0.07021687f, -0.04685054f, 
    -0.01668106f, 0.00621591f, 0.12485297f, -0.06407274f, 0.01543192f, 0.11306410f, -0.15384923f, -0.11771587f, 
    0.08987887f, 0.11514091f, -0.21327907f, -0.21078640f, 0.04935050f, -0.05695326f, -0.06840204f, 0.05964719f, 
    0.01658949f, -0.03243921f, -0.09824106f, 0.02480123f, -0.18720128f, -0.07982872f, -0.02781735f, 0.08104756f, 
    -0.07241727f, -0.01333263f, -0.08298329f, -0.06017408f, 0.05349146f, -0.05065173f, -0.15297084f, 0.13991292f, 
    0.04707342f, 0.03580152f, 0.14889815f, -0.21586923f, -0.08947664f, -0.11782450f, -0.08188340f, -0.03307762f, 
    -0.04871867f, -0.02589148f, -0.01076723f, 0.02907736f, -0.13202830f, 0.06193865f, 0.03781410f, 0.01451695f, 
    -0.13664742f, -0.04651384f, 0.00642959f, 0.08755282f, -0.02325614f, -0.06541577f, -0.06227278f, 0.15215158f, 
    -0.13708130f, 0.20911086f, -0.24860643f, 0.14019254f, 0.05888703f, 0.12742883f, 0.08798066f, 0.10715201f, 
    0.01823598f, -0.01412475f, 0.05157984f, -0.02966390f, -0.04520935f, -0.08750220f, -0.15948054f, -0.06176615f, 
    -0.10277570f, -0.01721676f, -0.04297881f, -0.02111807f, -0.03697116f, 0.05332115f, -0.03927080f, 0.03338379f, 
    0.16127998f, 0.34260729f, 0.13664271f, -0.01492516f, -0.08081946f, 0.02537729f, 0.09077075f, -0.00684805f, 
    -0.09866970f, -0.17319840f, 0.04470043f, -0.04710418f, 0.16682914f, -0.20370366f, 0.19743502f, -0.19220547f, 
    -0.07996226f, 0.27100673f, -0.11721960f, 0.27234218f, -0.11819518f, 0.00051789f, -0.02481579f, 0.03811553f, 
    0.07334033f, 0.17180242f, 0.27006817f, 0.22749610f, 0.08184817f, -0.02779491f, 0.05219360f, -0.05472375f, 
    -0.14869870f, 0.02759318f, -0.01124312f, -0.10934130f, -0.03434793f, 0.00977273f, 0.07391652f, -0.10004822f, 
    0.09103010f, 0.00206446f, 0.06219695f, -0.02071912f, -0.12439020f, -0.15948604f, -0.00274984f, -0.17474712f, 
    -0.32398796f, 0.24834140f, -0.00712854f, -0.14549199f, 0.04298360f, -0.00415890f, -0.05452676f, 0.09037048f, 
    -0.01574926f, 0.02027001f, 0.08060254f, 0.05370232f, 0.07731670f, 0.15514101f, -0.11510119f, 0.09120668f, 
    -0.06093802f, -0.07418730f, 0.08235181f, -0.06081256f, 0.06091895f, 0.12518105f, -0.11239841f, 0.06305914f, 
    0.07559609f, -0.19717823f, 0.23126508f, -0.10149451f, 0.10585063f, 0.01642902f, -0.09592722f, -0.06365041f, 
    -0.08975644f, 0.02082780f, -0.01947115f, -0.07197238f, -0.17313015f, -0.03075661f, 0.12860069f, -0.03217380f, 
    0.10635466f, -0.05939120f, -0.03214850f, 0.01308039f, -0.00173027f, 0.12285493f, 0.07482629f, 0.18938372f, 
    0.09141291f, -0.19790569f, -0.03187062f, 0.37798917f, 0.07415733f, 0.06173638f, 0.21276323f, -0.04611418f, 
    0.03607592f, 0.08517469f, 0.16757894f, 0.04355372f, 0.19405954f, -0.04656651f, 0.17425229f, -0.17120241f, 
    0.04004772f, 0.16132301f, 0.01409301f, 0.12306898f, -0.03788410f, -0.08249032f, -0.07297599f, -0.16889076f, 
    -0.03150148f, 0.02579877f, 0.07397380f, -0.12285136f, 0.02124928f, -0.04076641f, -0.00496399f, 0.06725665f, 
    0.08676029f, 0.04265557f, 0.01427361f, -0.02463039f, -0.11258774f, -0.07186848f, -0.06459768f, -0.13880718f, 
    -0.09331854f, -0.03873903f, -0.09650176f, 0.00940583f, -0.02108910f, 0.05949682f, 0.14595369f, 0.21602152f, 
    0.18198481f, -0.03936421f, 0.05731238f, 0.06538022f, -0.04453265f, 0.12901241f, 0.09575380f, 0.07951753f, 
    -0.24909569f, 0.11492101f, 0.06268795f, 0.00305445f, -0.10381469f, 0.32605729f, 0.00379609f, 0.17418243f, 
    0.02188061f, -0.00598279f, 0.00979990f, -0.08649433f, -0.09917714f, 0.08302029f, -0.08259862f, -0.12854636f, 
    -0.06021114f, 0.46668446f, -0.03945455f, 0.29492927f, 0.11043670f, -0.05636337f, 0.12948944f, 0.09218596f, 
    0.06831161f, 0.01419135f, -0.04187059f, -0.13808113f, 0.27721727f, 0.08114548f, -0.00108517f, -0.00520203f, 
    -0.03413674f, 0.09782290f, 0.02629258f, 0.09263059f, -0.07373114f, 0.02034900f, 0.01743932f, -0.13543195f, 
    -0.05173896f, 0.07862338f, -0.12623687f, -0.17369552f, -0.11985216f, 0.06978753f, 0.12396356f, -0.14181435f, 
    -0.10526615f, -0.02541644f, -0.02116604f, -0.03784500f, 0.35290572f, 0.03794510f, -0.05265769f, -0.08144957f, 
    0.04150054f, -0.02775388f, 0.16661949f, -0.00349938f, -0.11304321f, -0.23081306f, -0.13512389f, 0.19255480f, 
    0.03876946f, 0.14927717f, -0.00826399f, 0.11776128f, -0.02208548f, 0.01749950f, 0.14740221f, 0.05918199f, 
    0.06208225f, 0.04930775f, -0.02190597f, 0.17514609f, 0.04163845f, 0.09167115f, -0.00716366f, -0.13202409f, 
    0.11013247f, -0.01693438f, 0.12508871f, -0.05414953f, -0.13326843f, 0.12360043f, 0.09122182f, -0.05320421f, 
    0.12360631f, 0.06991241f, 0.20259759f, 0.23065177f, 0.02798921f, -0.11746179f, -0.03725489f, -0.12580021f, 
    -0.08153275f, -0.00678490f, 0.02689658f, -0.06493233f, 0.07822583f, -0.04372963f, 0.21214654f, -0.02580888f, 
    0.08487242f, 0.04706835f, 0.03499600f, -0.11008484f, -0.08609186f, -0.03636899f, 0.09605069f, 0.08831210f, 
    -0.06190506f, -0.14236301f, -0.03549001f, -0.10546749f, -0.05224481f, -0.03216511f, -0.07593111f, -0.10137904f, 
    -0.04002215f, 0.06516297f, 0.14004536f, 0.20273778f, 0.04001995f, -0.21367098f, 0.07999781f, -0.06418610f, 
    -0.08767603f, -0.08827508f, -0.00846193f, 0.08376474f, 0.03357366f, 0.02937453f, 0.03557514f, 0.09438858f, 
    -0.02262436f, 0.32088685f, 0.16832371f, -0.01116050f, -0.02724020f, -0.10367387f, -0.03946081f, 0.03484434f, 
    0.04059913f, 0.01655766f, 0.01433127f, 0.06921596f, 0.09879200f, 0.03999995f, -0.05139831f, -0.03923731f, 
    0.04686166f, 0.03241462f, 0.04328590f, -0.00174224f, -0.02023689f, 0.03405553f, 0.06338529f, 0.09917983f, 
    0.24097517f, -0.28350911f, 0.66846967f, -0.33629343f, -0.03912951f, 0.02130716f, -0.10107222f, 0.02494158f, 
    -0.19537173f, -0.09833410f, -0.07905951f, -0.06017890f, 0.17963631f, -0.10967485f, -0.18586153f, -0.03097383f, 
    0.14015803f, 0.02947021f, 0.11709061f, -0.03114204f, 0.04348329f, -0.05151560f, -0.14364542f, -0.02892854f, 
    -0.03716478f, 0.39264563f, 0.09642727f, 0.25410965f, 0.02217900f, -0.08764979f, 0.12424718f, -0.01150110f, 
    -0.03250302f, -0.02236274f, 0.05012190f, -0.02167385f, 0.28784946f, -0.14200111f, 0.08940977f, -0.10290893f, 
    0.07550548f, 0.13896383f, -0.02600210f, 0.02378128f, -0.13011089f, -0.01592276f, 0.00978004f, -0.01624327f, 
    -0.26562801f, 0.15224430f, -0.34763914f, 0.26171780f, 0.13544090f, -0.00656141f, 0.05020376f, -0.19054650f, 
    -0.08625840f, -0.04436250f, -0.00401965f, -0.12136929f, -0.28202185f, 0.13417299f, -0.08795135f, 0.19238491f, 
    -0.04967611f, -0.01064612f, 0.01626155f, 0.03841010f, -0.07741515f, -0.09100494f, -0.03939652f, 0.00170648f, 
    0.01385633f, 0.03102358f, 0.28257775f, -0.10123232f, 0.04074519f, -0.02315347f, 0.06918464f, 0.04301021f, 
    -0.04939162f, -0.13150747f, -0.00482000f, -0.02684017f, 0.08088771f, -0.09279834f, 0.25372368f, 0.00906679f, 
    -0.10245356f, 0.05139566f, -0.08677198f, 0.04729974f, -0.05960197f, 0.05904223f, 0.06314997f, -0.05542422f, 
    0.00880977f, -0.03178098f, -0.02051870f, -0.01951700f, -0.01039435f, 0.01715931f, -0.00679191f, -0.02868595f, 
    0.01799229f, 0.00827048f, -0.03862283f, 0.01225570f, 0.01410405f, -0.00899738f, -0.00817712f, -0.01458242f, 
    0.02107699f, 0.00811644f, 0.02683498f, 0.01355106f, -0.01478866f, 0.01065318f, -0.00964210f, 0.00906592f, 
    0.00119409f, -0.03136221f, -0.03176200f, -0.04137668f, -0.03226721f, 0.00172656f, -0.02437860f, -0.03917421f, 
    0.02847481f, 0.00790053f, -0.04131639f, -0.01853329f, -0.01688576f, -0.03796000f, -0.03445963f, -0.02981024f, 
    -0.01827576f, -0.00772612f, -0.00043549f, 0.00211393f, 0.00800087f, 0.01718416f, -0.02355092f, -0.00156636f, 
    -0.00998476f, 0.02439845f, 0.01584624f, 0.00429152f, 0.00672713f, -0.02015559f, -0.04147115f, -0.00244857f, 
    -0.00845214f, -0.01787901f, 0.01645588f, 0.01311523f, 0.00286800f, -0.02689408f, -0.03832069f, 0.02674547f, 
    -0.01088383f, -0.00738603f, 0.00475463f, 0.01286801f, -0.00806892f, -0.02011405f, 0.00128755f, 0.02831167f, 
    0.00472920f, 0.01388638f, 0.02687868f, 0.01456257f, -0.03856791f, -0.01047221f, 0.02102544f, -0.03250447f, 
    -0.00497751f, -0.03503725f, 0.00261202f, 0.02502988f, 0.02228789f, 0.01731593f, -0.00337284f, -0.02359077f, 
    -0.00572165f, -0.03296440f, -0.02262884f, -0.03972941f, -0.02338435f, 0.01147311f, -0.01089666f, -0.02379502f, 
    0.01583305f, -0.00198595f, -0.02488101f, -0.01900293f, 0.01664723f, 0.01327860f, -0.03745454f, 0.02770962f, 
    -0.03130834f, 0.00834929f, -0.00298242f, -0.01644730f, -0.00426246f, -0.01446726f, -0.01908076f, 0.02579878f, 
    -0.01064926f, -0.00629740f, -0.03894132f, 0.00558696f, -0.00164587f, -0.02581458f, 0.02039197f, -0.01138082f, 
    0.00422302f, -0.00048787f, -0.01950656f, -0.01545332f, -0.00352430f, -0.00070176f, 0.01902595f, 0.01674404f, 
    0.01519147f, -0.01511452f, -0.02919320f, 0.01758025f, 0.02382634f, -0.00742885f, -0.03298181f, -0.01262129f, 
    -0.01553852f, -0.04085862f, 0.00617960f, 0.01567602f, 0.01609275f, -0.02144381f, -0.01831930f, -0.01837504f, 
    0.01852715f, -0.01926727f, -0.01232156f, -0.04221524f, 0.00510277f, 0.01193317f, -0.00260724f, -0.01311976f, 
    -0.01473584f, 0.01467567f, -0.01234986f, -0.02618607f, 0.02611931f, 0.01320701f, 0.01303100f, -0.00740005f, 
    0.02853451f, -0.00419691f, 0.01383262f, 0.00081803f, -0.00179510f, 0.01479687f, 0.00379005f, -0.03866329f, 
    0.01567211f, 0.02723228f, 0.02520450f, -0.01502157f, -0.03223206f, -0.00839596f, -0.00856232f, 0.02012800f, 
    -0.03527345f, 0.02577475f, 0.01044509f, 0.00994879f, -0.00023931f, -0.02042887f, 0.02116277f, -0.04007674f, 
    0.00873819f, -0.00880680f, -0.01218309f, -0.00013872f, 0.01433419f, 0.02585893f, -0.03470171f, -0.01626565f, 
    -0.03434388f, 0.01589580f, -0.03617739f, -0.00792630f, 0.02717976f, -0.01490606f, 0.02197403f, 0.00311878f, 
    0.02632061f, -0.01756207f, -0.00482397f, -0.00693101f, 0.01327684f, 0.00031186f, -0.01579431f, 0.00760483f, 
    -0.00169466f, -0.01347564f, 0.01740741f, -0.03144622f, -0.03221487f, 0.00172341f, -0.02109878f, 0.01815922f, 
    -0.03956192f, 0.01046423f, -0.03275368f, -0.02634856f, -0.01259673f, 0.02571549f, 0.01944514f, 0.01213706f, 
    -0.02412020f, -0.01700989f, -0.02442227f, 0.01181598f, -0.02621745f, -0.02252166f, -0.00740941f, -0.01685541f, 
    0.00450518f, 0.01194333f, -0.01936405f, -0.03964246f, 0.02678165f, -0.03186323f, 0.00707872f, 0.01660617f, 
    0.02635380f, -0.02112438f, -0.03693850f, -0.02072209f, 0.02893617f, 0.00878464f, 0.00548708f, 0.01550702f, 
    -0.02296109f, -0.02018961f, 0.01219137f, -0.03619511f, 0.01931496f, -0.01911223f, 0.01167361f, -0.03431335f, 
    -0.00708869f, -0.00756068f, -0.04265148f, -0.00749831f, -0.01435929f, -0.01869152f, -0.00845995f, 0.01563839f, 
    0.02938349f, -0.00896074f, 0.02502013f, 0.02920346f, -0.02337782f, -0.04169657f, -0.01913721f, 0.01187408f, 
    -0.01483905f, 0.02595912f, -0.02221685f, 0.01609171f, 0.02185466f, 0.00194912f, -0.02347454f, -0.00032779f, 
    0.01640061f, 0.00421069f, -0.03301478f, -0.01704340f, -0.02625984f, -0.02416600f, -0.03558346f, -0.00710515f, 
    -0.00310144f, 0.00791359f, -0.03450262f, 0.02196537f, 0.00461927f, -0.00166131f, -0.03171405f, -0.03886802f, 
    0.02018910f, 0.00394694f, 0.02347133f, -0.03484541f, -0.00663867f, -0.03739890f, 0.02256807f, 0.00583560f, 
    -0.00334633f, -0.03652482f, 0.02352681f, 0.01981411f, -0.00131546f, -0.03530476f, -0.03705734f, -0.03428171f, 
    0.00358113f, 0.02531014f, -0.00845319f, 0.02806433f, -0.04130694f, 0.01954427f, 0.01046389f, -0.00456614f, 
    0.00750388f, -0.01867278f, -0.03624027f, 0.01218989f, 0.00284511f, -0.02597318f, -0.00844020f, -0.03570224f, 
    -0.03808190f, -0.00805698f, -0.03779497f, -0.00118150f, -0.02210923f, 0.02451728f, -0.01616787f, 0.02895417f, 
    0.02877039f, -0.01940133f, -0.01160016f, -0.00936737f, -0.03160178f, -0.03500763f, -0.03914693f, -0.03364143f, 
    -0.03952797f, 0.02738677f, 0.00881545f, -0.03739751f, -0.01790570f, -0.03514227f, -0.03306672f, -0.00450928f, 
    0.02308306f, 0.00565137f, -0.04049369f, 0.02272805f, 0.00843446f, -0.03083434f, 0.01868988f, -0.03519196f, 
    -0.01569454f, -0.00111557f, -0.03721157f, 0.00639516f, 0.00266042f, -0.04193754f, -0.02979217f, -0.01213530f, 
    0.00552257f, -0.01113190f, 0.00653761f, -0.02482002f, -0.02390399f, 0.00951325f, -0.01235123f, -0.02479228f, 
    0.02644504f, -0.01193535f, -0.02041822f, 0.00358999f, 0.02893203f, 0.00967714f, -0.01736965f, -0.03843590f, 
    0.00431306f, 0.00893617f, -0.00626370f, -0.01951697f, -0.02580136f, 0.01593125f, 0.02016717f, 0.02259510f, 
    0.02741811f, 0.01497293f, -0.02108529f, -0.02112850f, 0.01830464f, 0.01932148f, 0.00866131f, -0.01072445f, 
    0.00395222f, 0.02403815f, -0.03489270f, -0.04058208f, -0.03237442f, -0.04105003f, 0.00032083f, 0.01676904f, 
    -0.03226676f, 0.01170756f, 0.01717317f, 0.00803130f, 0.01304670f, -0.03543787f, -0.01649239f, 0.00097213f, 
    -0.03565838f, -0.02739921f, -0.00666710f, -0.01022260f, -0.01260494f, -0.01745692f, -0.01070271f, -0.01095160f, 
    0.00146212f, -0.00605590f, -0.03811466f, -0.03262863f, 0.01730127f, -0.03779608f, -0.02425675f, 0.01402960f, 
    -0.00050085f, -0.01891741f, -0.00889789f, -0.03864339f, -0.02344733f, -0.03247022f, -0.03350624f, 0.00885845f, 
    -0.03456246f, 0.00964684f, 0.01045794f, -0.00024752f, -0.02879318f, 0.01745735f, -0.00648888f, -0.03873232f, 
    -0.03842336f, -0.03209084f, -0.03284899f, 0.02453351f, -0.02691615f, -0.03354499f, 0.00979597f, -0.02753329f, 
    -0.02842394f, 0.01678506f, 0.00465784f, 0.01250123f, -0.00401869f, 0.01514853f, 0.01403665f, -0.00628297f, 
    -0.02180903f, -0.03307864f, 0.01918269f, -0.00997025f, -0.03792633f, -0.02095599f, -0.04230274f, 0.02667560f, 
    -0.01704096f, -0.03714081f, 0.00908187f, -0.03046556f, 0.02333494f, -0.03958536f, 0.01245274f, -0.01218401f, 
    -0.02439977f, 0.02833783f, -0.01968935f, -0.01983637f, -0.01538653f, -0.03453631f, -0.02077514f, 0.02487849f, 
    0.01002550f, 0.02716588f, 0.00618396f, 0.00897814f, 0.00124084f, -0.01365102f, -0.01165716f, 0.02886852f, 
    -0.03727195f, -0.01793547f, -0.03545202f, 0.02590290f, 0.01442384f, 0.01337493f, -0.00094143f, -0.00375489f, 
    0.00335734f, -0.01463025f, -0.00214112f, -0.00592273f, -0.01377180f, 0.00030923f, 0.00315670f, -0.03334227f, 
    0.01512888f, -0.02955778f, -0.01036495f, -0.02045230f, 0.01659791f, -0.02205459f, -0.00609223f, -0.02633281f, 
    -0.00247837f, 0.02231565f, -0.01878413f, 0.02051393f, 0.01900667f, -0.00614355f, -0.01153804f, -0.01332912f, 
    0.00982698f, -0.03646617f, -0.03556793f, 0.00515484f, 0.01323058f, -0.00126275f, 0.02353683f, 0.01740567f, 
    -0.00203456f, -0.01488781f, -0.04118757f, -0.01388275f, -0.00978207f, 0.02310701f, 0.00162733f, 0.01167187f, 
    0.00740654f, -0.03640497f, -0.03052889f, -0.02082702f, 0.02027068f, -0.02145952f, -0.03049058f, 0.01537796f, 
    -0.01230328f, 0.00141807f, -0.01408599f, -0.02591234f, -0.02305386f, -0.03250131f, -0.03228649f, -0.00433775f, 
    0.00971742f, -0.01671438f, 0.01661754f, -0.01542349f, 0.01021300f, 0.00067259f, 0.02357970f, -0.00962298f, 
    -0.03825990f, 0.01106855f, -0.00160772f, -0.00786925f, 0.00453071f, -0.01894900f, 0.02309204f, -0.00854418f, 
    -0.02012888f, -0.02145853f, 0.00959032f, -0.01095762f, -0.04118066f, -0.00308208f, 0.02260852f, -0.01425293f, 
    -0.01712299f, -0.00158257f, 0.01733904f, -0.04268583f, -0.02487521f, 0.00599511f, -0.04091923f, -0.02467961f, 
    -0.03677172f, 0.01656619f, -0.00220610f, -0.01916475f, -0.01572469f, -0.02062785f, -0.00657996f, -0.01569295f, 
    -0.00240188f, -0.03239186f, 0.00610394f, 0.02254920f, 0.00737075f, -0.01247687f, -0.01081349f, -0.02762156f, 
    -0.02157407f, 0.00850643f, -0.01967490f, 0.00630242f, 0.02897375f, -0.00008727f, 0.02063943f, -0.03527736f, 
    -0.00550441f, 0.01880819f, -0.02189786f, -0.00400547f, -0.00013939f, 0.00487317f, -0.01256039f, 0.01838859f, 
    0.00685676f, 0.02233749f, 0.01671517f, -0.01847910f, 0.01354630f, -0.00272850f, -0.00774467f, 0.00730515f, 
    -0.04193501f, 0.02007458f, 0.01195513f, 0.00458385f, -0.02845407f, 0.02557519f, 0.00823831f, 0.02728640f, 
    0.01267728f, 0.02690536f, -0.01613193f, 0.02586507f, -0.03173955f, -0.01992740f, 0.02840997f, -0.01822855f, 
    0.00686015f, 0.00839448f, 0.02482267f, -0.02728502f, 0.01778718f, 0.00773670f, -0.03919913f, -0.00269143f, 
    -0.03011922f, -0.03081464f, 0.01953883f, 0.01832507f, 0.01955748f, -0.00055212f, -0.02342241f, 0.02162646f, 
    0.01889358f, 0.01562310f, 0.00712323f, -0.02409496f, 0.01618186f, 0.01328364f, 0.01593340f, -0.00950535f, 
    -0.03324180f, -0.01436630f, -0.03579175f, -0.00184874f, -0.04207691f, 0.00838324f, -0.01995173f, -0.01119427f, 
    -0.01767462f, -0.02235180f, -0.00438539f, -0.03055520f, -0.02827455f, -0.01904274f, 0.02191978f, -0.04121305f, 
    -0.03735618f, 0.01482334f, -0.01318075f, -0.02186859f, -0.00813924f, -0.02930845f, 0.02425660f, -0.03491100f, 
    -0.00194525f, 0.02515696f, -0.00021778f, -0.02479353f, -0.03452653f, -0.03575090f, -0.01996162f, -0.02811108f, 
    -0.04194047f, 0.02499934f, 0.02812272f, -0.01718974f, -0.00160617f, 0.01282845f, -0.00290542f, 0.02225096f, 
    0.01886620f, 0.01154088f, 0.01612525f, 0.01748783f, 0.00384483f, 0.01314559f, -0.00159665f, -0.02347911f, 
    0.02590332f, -0.02849951f, -0.04182013f, -0.02811243f, -0.01011228f, -0.00023561f, 0.01865326f, -0.02605990f, 
    -0.00452101f, 0.02988051f, -0.01805607f, -0.01843476f, -0.00855077f, -0.00913209f, -0.02138978f, -0.03457781f, 
    -0.01107345f, 0.01562544f, -0.01815802f, -0.01685889f, 0.01609069f, -0.01630712f, 0.00571745f, -0.01911880f, 
    -0.00692055f, 0.00522256f, -0.02160669f, 0.01589623f, -0.02432457f, -0.01016644f, -0.04194074f, -0.03397275f, 
    -0.03357388f, 0.02387611f, 0.02692641f, -0.03960333f, -0.00921375f, 0.00981356f, -0.00789843f, 0.01254662f, 
    -0.03121429f, -0.03674145f, -0.03153532f, 0.00363963f, 0.01677626f, -0.02894684f, -0.00778807f, 0.02302376f, 
    0.15849692f, 0.10631771f, 0.12204657f, 0.05793944f, 0.07279289f, -0.00001368f, 0.00226539f, 0.19211204f, 
    -0.03514571f, -0.02848751f, -0.08498801f, -0.07837714f, 0.08024531f, -0.08664886f, -0.06751695f, -0.26507351f, 
    -0.08935295f, 0.07857190f, 0.00912830f, -0.11808970f, 0.04976122f, -0.01003552f, -0.06360752f, 0.04262272f, 
    0.09860819f, 0.00545239f, 0.00023212f, 0.06896746f, -0.07823445f, -0.15972500f, 0.02069468f, 0.03880353f, 
    0.10926975f, 0.02734974f, 0.06838492f, 0.02911839f, -0.19049983f, 0.12313833f, 0.16962938f, 0.11064082f, 
    0.09829169f, -0.03551758f, 0.01039235f, 0.14622280f, 0.04156526f, -0.04973313f, 0.03827859f, -0.07892133f, 
    -0.33656660f, 0.11007284f, -0.10432059f, 0.00533502f, -0.12978373f, 0.00626318f, 0.06285665f, -0.11361643f, 
    -0.02527755f, 0.13881204f, -0.05015654f, 0.00639791f, 0.02853617f, 0.18390980f, 0.02399362f, 0.03537041f, 
    -0.07838925f, -0.05394592f, -0.09423409f, -0.09182277f, 0.02668371f, 0.07849453f, 0.04404834f, -0.01732234f, 
    -0.45226932f, -0.15527491f, -0.03813107f, 0.00562256f, 0.06642856f, 0.21658176f, -0.01320104f, -0.01321548f, 
    0.04009486f, -0.04557935f, -0.00987820f, -0.01770272f, -0.10028320f, -0.12602359f, -0.00767187f, 0.06585229f, 
    -0.14923561f, -0.07471967f, -0.05196099f, -0.09428471f, 0.04516463f, 0.05055650f, 0.06120983f, 0.02583006f, 
    -0.18575992f, 0.10397007f, 0.00010381f, -0.17524894f, 0.01021542f, 0.12353322f, -0.13076134f, 0.16287567f, 
    0.08915070f, -0.06361229f, 0.08359171f, 0.11046927f, 0.04530063f, -0.03054659f, 0.07009474f, 0.10518391f, 
    0.10235856f, 0.04961886f, -0.15445353f, 0.10231521f, 0.02865059f, -0.09248669f, -0.08949071f, 0.01133991f, 
    -0.38043708f, 0.30444387f, -0.26966763f, -0.18599105f, -0.08249540f, 0.07768671f, 0.01471079f, 0.11817122f, 
    0.01559503f, -0.00750306f, 0.00751382f, 0.01299085f, -0.25622305f, -0.16866526f, 0.15108643f, 0.12168153f, 
    0.11814180f, 0.05045828f, -0.11282546f, 0.05873913f, 0.04224758f, 0.04893510f, 0.02521633f, 0.05549372f, 
    -0.18952157f, -0.01828747f, 0.18626729f, 0.11152337f, 0.13026519f, 0.15806238f, 0.11899079f, -0.03228153f, 
    0.12961599f, 0.09562103f, 0.13726066f, -0.05457092f, 0.63847053f, 0.28937182f, 0.09887736f, 0.01992540f, 
    0.03749527f, -0.17036851f, -0.15810356f, -0.16574433f, -0.06070526f, 0.02952169f, -0.06009277f, 0.18199787f, 
    0.28023091f, 0.11742985f, 0.25457829f, -0.13315381f, -0.05813051f, 0.17014171f, -0.15070082f, 0.04404644f, 
    0.03252338f, -0.18327250f, -0.04305729f, -0.18282591f, -0.35198179f, 0.05242770f, 0.07446486f, 0.18298489f, 
    -0.04391352f, 0.06026730f, -0.08439188f, 0.07235672f, 0.02796352f, -0.00122704f, -0.02917940f, -0.13053729f, 
    0.25202221f, -0.23015863f, 0.00388268f, -0.03130463f, -0.03045538f, 0.06146267f, -0.12996323f, -0.15202294f, 
    -0.02289527f, 0.08438449f, -0.05106088f, 0.14865774f, 0.04080516f, 0.15952481f, -0.07739248f, 0.24736342f, 
    0.04041939f, -0.03012340f, -0.08727813f, -0.03106677f, 0.02456192f, -0.08873574f, -0.05526099f, -0.05467620f, 
    0.05226352f, 0.14462860f, 0.00648876f, 0.05053259f, -0.07721733f, 0.00498215f, 0.10119821f, -0.01528829f, 
    0.00026733f, -0.02367626f, -0.00222783f, 0.01208715f, 0.07192412f, -0.04753242f, 0.03868998f, 0.16229159f, 
    -0.06714188f, -0.10329289f, 0.02851069f, 0.00644256f, -0.02719262f, -0.09253470f, -0.00442276f, 0.02301268f, 
    -0.19103996f, -0.02241035f, -0.18270472f, 0.17806119f, 0.04626020f, 0.05319084f, -0.04303112f, 0.12356272f, 
    0.06419883f, 0.12089524f, -0.02120013f, -0.09516145f, -0.23250535f, 0.34108752f, -0.17972821f, -0.08524825f, 
    -0.00589784f, 0.02459577f, 0.15089113f, 0.01781344f, -0.13003828f, -0.01257654f, 0.01854643f, 0.01023331f, 
    0.43568444f, 0.16229801f, 0.25747418f, -0.21639647f, -0.00435682f, 0.03274028f, -0.04755002f, -0.06873917f, 
    0.02303137f, 0.11508254f, -0.01519365f, 0.01871611f, 0.22320437f, 0.03963621f, 0.33180276f, -0.09190139f, 
    0.10940461f, -0.08542062f, -0.01925780f, 0.20981969f, -0.07305904f, -0.02816010f, 0.13720907f, 0.02435691f, 
    -0.16500287f, -0.15607220f, 0.00930916f, -0.08872816f, 0.05068732f, 0.09137469f, 0.03958801f, -0.19109252f, 
    0.01577610f, -0.04178654f, 0.13697442f, -0.00225201f, 0.26689860f, 0.02766532f, 0.33838192f, 0.19270846f, 
    -0.01414401f, 0.03237484f, -0.01232127f, -0.02292049f, -0.02665862f, 0.11968780f, 0.05717737f, 0.02036003f, 
    -0.19008487f, -0.06079303f, 0.06191391f, 0.15987223f, -0.15760832f, 0.13481233f, 0.00416952f, 0.06855097f, 
    -0.08689131f, -0.04100919f, 0.01251298f, 0.01068441f, 0.36508822f, 0.17073599f, 0.03697126f, -0.06239489f, 
    -0.06961704f, -0.03058176f, -0.02480078f, -0.08163364f, 0.02854152f, 0.05502974f, -0.01990278f, -0.04539157f, 
    0.08793406f, 0.14821716f, 0.00560262f, -0.08831196f, -0.04156426f, -0.07413710f, -0.08957803f, -0.02292582f, 
    0.23192802f, 0.15312159f, 0.11280590f, -0.02735974f, 0.03636021f, -0.03337835f, 0.12119368f, 0.06234526f, 
    -0.07802643f, -0.05477206f, -0.03650470f, -0.01101283f, 0.23485942f, 0.09235807f, 0.10134602f, 0.04340179f, 
    0.13474734f, 0.16175236f, 0.01209909f, -0.05815761f, 0.02039365f, -0.10658337f, -0.11576222f, 0.11339638f, 
    0.05944834f, 0.14162117f, -0.04151665f, 0.04521080f, -0.03247236f, 0.06565111f, -0.03319800f, 0.16096945f, 
    0.01281059f, -0.13189512f, 0.21736908f, -0.19768842f, 0.12656344f, -0.08130829f, 0.04862635f, 0.03758202f, 
    -0.03069318f, 0.11457466f, 0.01092584f, 0.01261550f, -0.08718576f, 0.07167565f, 0.09108187f, 0.05374033f, 
    -0.05838146f, 0.06598005f, 0.06001192f, -0.12099957f, 0.03844666f, 0.11934029f, 0.18134850f, 0.07334379f, 
    -0.01903510f, 0.10502588f, 0.02359851f, -0.03139630f, -0.01191017f, -0.02710891f, 0.10965390f, 0.12690499f, 
    0.11983509f, 0.11465739f, 0.00653489f, -0.05671352f, 0.01125131f, -0.04583493f, -0.02641898f, -0.12615630f, 
    0.10412854f, 0.05512718f, -0.03283942f, 0.03686130f, -0.02152501f, 0.17895673f, 0.03519925f, 0.03064228f, 
    -0.02544062f, 0.01869002f, -0.04718292f, 0.08103384f, 0.00501908f, -0.14663823f, 0.10326515f, -0.04415319f, 
    -0.04434595f, -0.10086104f, 0.01135958f, -0.02516793f, -0.03573893f, 0.01075166f, 0.25525561f, -0.04678524f, 
    0.02112874f, 0.00391823f, -0.01157224f, 0.11415666f, 0.23293790f, 0.06231227f, 0.11187890f, -0.08804219f, 
    -0.12617476f, -0.09552249f, 0.02234866f, -0.08542471f, -0.09935058f, -0.04902053f, -0.11507346f, 0.08131491f, 
    -0.46910104f, 0.31390107f, -0.18525566f, -0.05525575f, -0.11692967f, 0.26178440f, -0.00635072f, 0.14315972f, 
    0.04098823f, -0.00570979f, -0.01913969f, -0.13111576f, 0.07001264f, -0.00841569f, 0.08966771f, 0.03607916f, 
    0.12859634f, -0.08630909f, 0.11735079f, -0.01936419f, -0.00212574f, 0.03039675f, 0.03698371f, 0.17406468f, 
    -0.27009612f, -0.08841953f, -0.05408157f, 0.05651115f, 0.07975332f, 0.03404215f, 0.05956382f, 0.03687617f, 
    -0.06163480f, 0.00818659f, -0.02384626f, 0.03091498f, 0.10761556f, 0.03266443f, 0.12634714f, 0.16162941f, 
    -0.06205245f, -0.04716013f, 0.01768557f, 0.02682669f, 0.03503982f, 0.18699083f, -0.00719622f, 0.09709985f, 
    0.15265059f, -0.06055511f, -0.08202010f, -0.15577511f, 0.04824913f, -0.02382785f, 0.05801707f, 0.05640601f, 
    -0.02677476f, -0.00072912f, -0.01971408f, -0.03547477f, 0.43528602f, -0.11812432f, 0.20215581f, -0.07567905f, 
    0.08230180f, -0.18009676f, -0.06264808f, 0.09253436f, -0.06066802f, -0.08567770f, -0.07818467f, -0.12208170f, 
    0.32050413f, 0.30335447f, 0.15381509f, -0.24996424f, 0.02832464f, -0.08191323f, 0.02940142f, -0.05804472f, 
    -0.09108359f, -0.00824227f, -0.05509340f, 0.08065879f, -0.26250920f, -0.01005068f, -0.00894494f, 0.00771408f, 
    0.08608286f, -0.00487844f, -0.09399379f, 0.00043597f, -0.00812727f, -0.08946071f, 0.11861733f, -0.00374568f, 
    -0.25378305f, -0.08240864f, -0.13150291f, 0.18673664f, 0.04220804f, 0.07322082f, -0.10107962f, 0.12494216f, 
    -0.08629026f, 0.01742955f, -0.01414433f, 0.02562413f, 0.29434037f, 0.09471800f, 0.12318431f, 0.13007757f, 
    0.02799114f, -0.00066792f, -0.14192483f, 0.07851586f, -0.08386129f, -0.07885604f, -0.05594525f, -0.04188809f, 
    0.20300718f, 0.13005194f, -0.01050826f, -0.00910267f, -0.07920456f, -0.03317581f, -0.11133100f, 0.07643130f, 
    -0.08743253f, -0.05412776f, 0.02333255f, 0.00623202f, -0.25589985f, 0.08760130f, -0.03014392f, 0.21232475f, 
    0.03349490f, 0.21283926f, 0.00436718f, 0.04502469f, -0.00495823f, 0.00920539f, 0.02032804f, 0.10222931f, 
    -0.06259996f, -0.17845990f, 0.15083656f, -0.05712118f, -0.10695852f, 0.08233681f, -0.01883943f, -0.01895045f, 
    0.09253379f, -0.01836948f, 0.10180660f, -0.04220159f, 0.13221923f, 0.11442739f, -0.05831172f, -0.04238024f, 
    -0.02344059f, -0.08442553f, -0.00996614f, 0.04020524f, 0.22870702f, 0.17210624f, 0.00666349f, 0.05478616f, 
    0.05475149f, 0.08435347f, 0.13676992f, -0.02092790f, -0.03587800f, 0.02431557f, 0.00807498f, 0.04834377f, 
    0.09526547f, 0.12048860f, -0.07585429f, -0.03803620f, -0.14648192f, -0.08029941f, -0.06546516f, 0.18485369f, 
    0.12310963f, 0.12478081f, 0.09709404f, 0.07367548f, 0.06332063f, -0.04510920f, -0.01095110f, -0.09307539f, 
    0.14714111f, 0.07016166f, 0.14445961f, 0.14096007f, 0.02551210f, -0.02967232f, 0.00679954f, 0.02915022f, 
    0.13912730f, 0.15941609f, 0.00628631f, -0.04187679f, -0.21459970f, -0.13166809f, -0.12832448f, 0.25348368f, 
    0.16559480f, 0.17954312f, 0.27610686f, 0.13136159f, -0.04306047f, -0.01150747f, -0.04933012f, -0.07716658f, 
    0.40217951f, 0.04003209f, -0.16421764f, 0.07208497f, -0.14382444f, -0.11585025f, 0.11049887f, 0.03438033f, 
    0.06763142f, -0.05487610f, -0.07535256f, 0.00902917f, -0.16397886f, -0.11550375f, 0.14170189f, -0.07296895f, 
    -0.00346509f, 0.05024362f, -0.17114869f, 0.15531012f, 0.03984948f, -0.11065081f, 0.17326552f, -0.04065848f, 
    0.48165748f, -0.07051753f, 0.10487147f, -0.03625868f, 0.02947561f, -0.10362519f, -0.05992616f, 0.12410264f, 
    -0.05095161f, 0.05541993f, 0.05841444f, 0.01055326f, 0.17345828f, -0.10017003f, 0.13244426f, 0.07794172f, 
    -0.05201878f, -0.10038301f, 0.17761169f, -0.01354573f, -0.10927896f, -0.05402581f, -0.05068881f, -0.02659937f, 
    -0.22418383f, 0.09897370f, 0.11088663f, 0.08155974f, 0.08710556f, 0.29847598f, 0.07009514f, 0.11463229f, 
    0.05108616f, -0.08466312f, -0.05796031f, -0.05054168f, 0.35545701f, 0.16575877f, 0.31188208f, 0.03901995f, 
    -0.00511705f, -0.10520708f, -0.01197789f, 0.01525058f, -0.00406766f, 0.10385931f, 0.00910713f, 0.01344823f, 
    -0.34337699f, -0.08125489f, -0.14436193f, 0.01372951f, 0.18810636f, 0.03991641f, 0.02788748f, 0.00483126f, 
    -0.10775407f, -0.04060081f, -0.02235080f, 0.13242616f, 0.15423697f, -0.11480679f, -0.21318862f, 0.00513906f, 
    0.14093423f, -0.11756267f, 0.05180835f, -0.05042355f, -0.13527650f, -0.09655625f, -0.01458572f, 0.00304779f, 
    -0.01379222f, -0.01954752f, -0.02555832f, 0.02799656f, -0.00412914f, 0.01266245f, -0.02346685f, -0.01198336f, 
    -0.03204256f, -0.01208441f, -0.00788291f, -0.01834836f, -0.03659275f, 0.02209280f, -0.02394076f, 0.01619658f, 
    -0.02157170f, -0.03832986f, 0.00635496f, -0.01723075f, 0.01449061f, -0.01192203f, 0.01452324f, -0.00044853f, 
    0.02228886f, -0.01284393f, -0.02463274f, 0.02756177f, -0.02190294f, -0.02158362f, -0.02389603f, 0.00464837f, 
    -0.01500017f, -0.02480621f, 0.00608008f, -0.03964104f, 0.02159768f, -0.00397939f, -0.03920346f, -0.02595410f, 
    -0.03825725f, 0.02645464f, -0.03041826f, -0.02868814f, -0.02255659f, -0.02234763f, -0.02535992f, -0.00348968f, 
    0.03974086f, 0.00316696f, 0.02921388f, 0.02519955f, -0.00018335f, 0.00375189f, -0.01725132f, -0.02759121f, 
    0.02347022f, -0.03112417f, 0.02860220f, -0.01714304f, 0.01639763f, 0.01552626f, 0.03344042f, 0.01207966f, 
    -0.01788376f, 0.01987443f, 0.02774618f, 0.01314751f, 0.02656573f, -0.00064452f, -0.00780576f, -0.00006701f, 
    -0.00169865f, -0.02454269f, -0.03014860f, -0.01580590f, -0.00874434f, 0.03278120f, -0.03296315f, 0.01466641f, 
    -0.03772842f, -0.01448792f, 0.01007498f, -0.00938038f, 0.02960674f, -0.01893263f, 0.02758517f, -0.02037950f, 
    0.02242561f, -0.03281392f, 0.00602243f, 0.01534181f, -0.00312686f, 0.00223925f, 0.02747726f, 0.01366501f, 
    0.00638075f, 0.02651628f, -0.03597900f, -0.03539898f, 0.02614507f, 0.01446455f, -0.00973255f, 0.00630658f, 
    0.02785820f, -0.00542500f, 0.00055522f, 0.00071517f, -0.03343205f, 0.03110327f, 0.00604742f, 0.00651826f, 
    -0.01993406f, -0.02741833f, -0.02639342f, 0.00769498f, 0.00065557f, 0.01180989f, 0.02051379f, -0.01427482f, 
    0.02433366f, -0.01700581f, -0.02033881f, 0.01864561f, 0.02910542f, -0.00891289f, 0.03217968f, -0.02104504f, 
    0.01036347f, -0.02408182f, -0.03139792f, -0.00019906f, -0.02294945f, -0.01859938f, -0.00391000f, -0.02887735f, 
    0.00840672f, -0.04346240f, 0.01270638f, -0.00366904f, -0.00164165f, 0.02009566f, -0.00121787f, -0.03920790f, 
    -0.01990503f, -0.02297899f, 0.02869596f, 0.01166860f, 0.02108747f, -0.03243066f, 0.02490381f, 0.03734328f, 
    0.02530530f, 0.00038185f, -0.01531332f, -0.02032887f, -0.03094450f, 0.01066076f, -0.00578977f, -0.03901230f, 
    -0.01585014f, -0.03402857f, 0.00526952f, 0.01957492f, 0.02047855f, -0.00736580f, -0.00067260f, -0.03584993f, 
    -0.01861395f, 0.00620532f, -0.03177053f, -0.02680739f, -0.02951033f, -0.02005943f, 0.00014399f, 0.03192554f, 
    -0.01972702f, 0.01122540f, -0.00892490f, 0.03510630f, -0.00352356f, 0.03190109f, -0.02597432f, 0.02385031f, 
    -0.03160943f, 0.01392307f, -0.02584036f, -0.03777254f, 0.01706442f, 0.00952573f, 0.01766275f, -0.02043564f, 
    0.00254801f, 0.02901580f, -0.01879861f, 0.00291667f, 0.00580915f, -0.03426531f, -0.02384474f, -0.03383123f, 
    -0.02131770f, -0.03432692f, -0.02004917f, 0.01537325f, 0.00982388f, 0.01152115f, 0.00466533f, -0.01752659f, 
    -0.02872266f, -0.03699341f, 0.00468290f, 0.00355648f, 0.00385502f, -0.00465508f, -0.01220912f, 0.01859010f, 
    -0.03933800f, 0.01011055f, 0.00767524f, -0.03369571f, -0.01250959f, -0.00334678f, -0.03078396f, 0.02907633f, 
    0.03322165f, -0.01449764f, -0.01971154f, -0.02690393f, -0.02745117f, -0.01429410f, -0.01903308f, -0.02209317f, 
    -0.02579274f, -0.03673207f, -0.00608335f, 0.00949873f, -0.00727056f, -0.03244000f, 0.01246778f, -0.00710384f, 
    -0.04070739f, -0.03032368f, 0.03138313f, 0.00658775f, -0.02809444f, 0.02544773f, -0.00086718f, 0.00794936f, 
    -0.00493011f, -0.00918862f, -0.00601419f, -0.01059378f, -0.00474485f, 0.02539054f, 0.00796626f, -0.00626404f, 
    0.02196924f, 0.00991563f, 0.03324504f, -0.03546357f, 0.03545030f, -0.00721025f, -0.02322287f, -0.02492546f, 
    -0.01111376f, 0.01667134f, -0.00963671f, 0.00794976f, -0.01028202f, -0.00774516f, -0.00882620f, -0.00622224f, 
    0.00006653f, -0.02613445f, 0.00846074f, -0.00467511f, 0.02093619f, 0.01301525f, -0.01049413f, 0.02535629f, 
    -0.01769025f, -0.03157479f, 0.00147265f, -0.00962088f, -0.01435066f, 0.00361882f, -0.02279169f, 0.03239011f, 
    0.00678315f, 0.02146274f, 0.01145135f, -0.03142372f, -0.02143433f, -0.03652209f, 0.02020394f, 0.02938593f, 
    -0.02706718f, -0.03661595f, -0.01036060f, -0.00879563f, 0.01811059f, 0.01300529f, 0.02036123f, -0.01745816f, 
    -0.00932342f, 0.01190446f, -0.02676408f, 0.00733929f, 0.01670814f, 0.01298900f, 0.02089204f, 0.02256214f, 
    -0.01578383f, 0.01254604f, -0.02560829f, -0.00611775f, 0.01920340f, -0.03065066f, -0.02621332f, 0.00715176f, 
    0.01231528f, 0.02927959f, -0.03594625f, -0.02494435f, 0.00040202f, 0.02802899f, -0.02429627f, -0.02062765f, 
    0.01657461f, -0.01672107f, -0.03856611f, 0.01999922f, -0.02013514f, -0.01878639f, 0.00182769f, -0.01987794f, 
    -0.00166423f, -0.02485777f, 0.00542298f, -0.00971853f, -0.02078131f, 0.02179240f, 0.01661180f, -0.00138145f, 
    0.00335455f, 0.00321613f, -0.01757153f, -0.02731062f, 0.01817063f, 0.00645345f, -0.03457134f, 0.02573983f, 
    -0.01350380f, -0.03722318f, 0.00281599f, 0.00367308f, 0.00719575f, 0.03201991f, -0.00982108f, 0.01616828f, 
    -0.02519795f, 0.01396812f, 0.02842681f, -0.02256363f, 0.02349073f, -0.00396710f, -0.03862711f, -0.01621399f, 
    0.03208565f, -0.01578073f, 0.01453148f, -0.00082543f, 0.02393587f, -0.01768432f, -0.03178356f, -0.04082017f, 
    0.00424297f, 0.00193461f, 0.01509493f, -0.00832160f, 0.01253889f, -0.03522625f, 0.01476109f, -0.01022576f, 
    -0.03222654f, -0.00081432f, -0.02048577f, -0.02645751f, 0.01693017f, 0.00311339f, 0.01894753f, -0.01289726f, 
    -0.01947772f, -0.00828251f, 0.02709904f, -0.03779642f, -0.00140792f, -0.01957920f, 0.01225013f, -0.02408720f, 
    0.01096994f, 0.00986995f, 0.02060222f, -0.03394496f, 0.01060506f, 0.02804492f, -0.03343342f, -0.00780348f, 
    -0.00224435f, -0.00153275f, -0.01909570f, 0.01629115f, 0.02794879f, -0.03066550f, -0.01623653f, 0.00796763f, 
    -0.01046446f, 0.00798539f, -0.00778453f, -0.02855995f, -0.03137450f, -0.02150463f, -0.03220512f, 0.02296256f, 
    0.01874863f, 0.02414031f, -0.01344821f, 0.01684740f, -0.00553243f, -0.01505826f, 0.00890087f, 0.03098829f, 
    -0.00284940f, 0.03188629f, -0.01399569f, 0.03314807f, 0.00495526f, -0.01869389f, 0.02448069f, -0.01945311f, 
    -0.01258028f, -0.02024362f, -0.00428394f, -0.02724626f, 0.00971924f, 0.01554589f, -0.01247944f, 0.02622048f, 
    0.00952072f, -0.03053846f, -0.00325004f, 0.02418171f, -0.01202482f, 0.00303531f, -0.01004681f, 0.01839540f, 
    -0.00087053f, -0.01050081f, -0.02358012f, -0.00602700f, -0.00514969f, -0.02932454f, -0.00282526f, -0.00287954f, 
    0.01622630f, 0.02246659f, -0.01736584f, 0.01803035f, -0.01310157f, 0.03046141f, 0.02191217f, -0.00170856f, 
    -0.00277173f, -0.02680571f, 0.02102995f, -0.03878989f, -0.02275286f, -0.03015167f, 0.00067689f, -0.01996954f, 
    -0.03526438f, -0.04074404f, -0.02383332f, -0.00349030f, 0.02998501f, 0.01959962f, 0.02684977f, -0.03753469f, 
    0.01753259f, -0.02204598f, -0.02566583f, -0.00303006f, -0.01209781f, -0.01203960f, 0.02168168f, 0.00713451f, 
    0.02378633f, -0.01521335f, -0.01179443f, 0.00830329f, 0.02036843f, -0.01844788f, 0.00907473f, 0.02837313f, 
    0.01845100f, -0.01540604f, 0.02557528f, 0.03243366f, -0.01852670f, -0.01652299f, 0.01667561f, -0.00474845f, 
    -0.03855639f, -0.03124424f, -0.01054587f, -0.00289552f, 0.00451327f, -0.04174569f, -0.02238876f, 0.02506617f, 
    0.01404496f, -0.03128425f, -0.01913229f, -0.00641225f, -0.02252015f, -0.01266192f, 0.01141387f, -0.00134519f, 
    -0.01008491f, 0.02821363f, 0.01459683f, 0.03900220f, -0.03687992f, -0.01483657f, 0.01027482f, -0.01427848f, 
    -0.00696759f, -0.00134828f, -0.02491665f, 0.01479753f, -0.00074560f, 0.02474960f, -0.00931166f, -0.02147740f, 
    0.00415954f, -0.00372565f, -0.03426678f, 0.00693575f, 0.02474898f, 0.00320251f, -0.02492871f, -0.02733762f, 
    0.01879141f, -0.01174568f, 0.02351306f, -0.01277762f, 0.01438271f, -0.02741087f, 0.02771818f, -0.01877577f, 
    0.03432383f, -0.00731954f, 0.02198200f, -0.02200923f, -0.02294943f, -0.03694798f, -0.00043496f, -0.02332323f, 
    0.00320567f, -0.01871090f, 0.01520472f, 0.00935503f, 0.01593239f, -0.00547186f, 0.02716722f, -0.00784335f, 
    0.02997050f, 0.00141842f, 0.02357726f, -0.03002658f, 0.00716175f, -0.03082751f, 0.01985671f, 0.03408495f, 
    0.02020935f, -0.02685560f, -0.04141496f, 0.02244437f, -0.02478174f, 0.02348217f, -0.00028330f, -0.03061552f, 
    -0.03365566f, -0.03309492f, 0.01167237f, -0.02762637f, 0.02990359f, -0.00585834f, 0.01698478f, -0.00514958f, 
    0.03236437f, 0.00535162f, 0.03306695f, 0.03556551f, -0.00307442f, -0.02301140f, 0.02469126f, 0.01697575f, 
    0.02488102f, -0.02563809f, 0.01033012f, 0.02581283f, 0.01292091f, 0.02977344f, 0.02842906f, -0.00767985f, 
    0.00435145f, 0.01206680f, -0.01803187f, -0.00458508f, -0.02990641f, 0.02366257f, -0.02495139f, -0.01592137f, 
    -0.01274505f, 0.02748479f, 0.01272968f, -0.01851243f, -0.03385780f, 0.02626972f, 0.00038882f, -0.01795720f, 
    0.00500828f, 0.02446470f, -0.02007118f, -0.03597671f, -0.03202272f, -0.04350552f, 0.02082878f, -0.00147413f, 
    -0.02676513f, -0.01345898f, -0.02634700f, -0.03221813f, 0.00903954f, -0.02739866f, 0.03364828f, 0.00441523f, 
    -0.04157170f, 0.01548262f, -0.00303586f, -0.02277556f, -0.00309641f, -0.02101126f, -0.01184549f, 0.03163159f, 
    0.02791861f, 0.00295042f, 0.01827287f, 0.00494643f, 0.01851209f, -0.01984742f, 0.02579447f, -0.00743879f, 
    -0.03269878f, 0.02292878f, 0.00758991f, -0.03888631f, 0.02780194f, -0.00370479f, 0.00753793f, -0.01238167f, 
    -0.00308551f, -0.01131605f, -0.01996851f, 0.01670894f, -0.00801349f, 0.02198160f, 0.01704230f, -0.00851065f, 
    -0.02822065f, 0.01395307f, 0.00190079f, -0.01706894f, -0.02639931f, 0.02302378f, -0.01830361f, -0.01280327f, 
    0.00212711f, -0.00670850f, 0.01771478f, 0.01820427f, 0.03209360f, -0.00244369f, -0.01857026f, 0.00150200f, 
    -0.02850285f, -0.02187854f, -0.02936575f, -0.02246709f, 0.01462337f, 0.01873450f, -0.01829009f, 0.01967704f, 
    0.01964275f, -0.01979773f, 0.02313270f, -0.00995790f, 0.01941327f, 0.00349584f, -0.03435600f, -0.01745534f, 
    0.00944707f, -0.00513825f, 0.03661323f, -0.00857681f, -0.03730652f, -0.03368229f, 0.02242251f, 0.00043194f, 
    0.02612427f, -0.03622225f, -0.00658658f, -0.01452251f, 0.00736588f, -0.01229485f, -0.00569895f, -0.02937846f, 
    0.03582796f, -0.03165800f, 0.01185344f, 0.00329235f, -0.01978865f, -0.02490430f, -0.00864793f, -0.00165904f, 
    -0.00358235f, 0.00232316f, 0.02488722f, 0.02130943f, 0.00421621f, 0.02781918f, -0.00688526f, -0.00617840f, 
    0.01572794f, 0.02555937f, -0.00897894f, -0.01116224f, 0.03249668f, -0.00711088f, 0.00482447f, 0.00359370f, 
    -0.03240770f, -0.02212521f, 0.02085231f, 0.01265735f, 0.02105075f, 0.01322321f, -0.01947694f, -0.01348449f, 
    -0.03330626f, 0.03057877f, 0.02217215f, 0.03322903f, -0.01873343f, 0.00160735f, -0.03694334f, 0.02449843f, 
    -0.03633377f, 0.02664978f, -0.02849733f, -0.02174572f, 0.00441087f, 0.00645158f, 0.01743480f, -0.00142838f, 
    0.02702878f, -0.01394031f, 0.02807725f, -0.01032749f, 0.00694475f, 0.01858227f, -0.01263006f, -0.02597232f, 
    -0.02736960f, 0.00619293f, 0.02043711f, 0.01747959f, -0.03606002f, -0.01907623f, -0.01768147f, -0.01458687f, 
    0.02261750f, -0.02916853f, 0.02021286f, 0.03045121f, -0.00655923f, -0.03350910f, 0.03168804f, -0.00438004f, 
    -0.03533902f, -0.01623879f, -0.03386618f, 0.02321007f, 0.01945308f, 0.02306306f, -0.03130013f, 0.01058968f, 
    0.00351500f, -0.00859662f, -0.03485645f, -0.01795942f, -0.01508315f, -0.03831441f, -0.03902594f, 0.02371023f, 
    0.02857803f, -0.03005076f, -0.01020924f, -0.03219382f, 0.02839318f, 0.01823020f, 0.01398691f, -0.01148125f, 
    -0.01475259f, -0.04149448f, 0.01148687f, -0.01549818f, -0.00345531f, 0.02199059f, 0.02427057f, -0.01306750f, 
    0.00584774f, -0.01825599f, 0.00074890f, -0.03229759f, 0.01497137f, -0.00701581f, -0.02096571f, -0.04212352f, 
    -0.03473180f, 0.00104714f, 0.02518359f, -0.02782299f, 0.02484778f, -0.00904036f, -0.01515711f, -0.00420851f, 
    -0.00386662f, 0.01898003f, 0.01987249f, 0.02488782f, 0.01442170f, 0.00470388f, 0.01991436f, -0.03483369f, 
    -0.04012910f, 0.02187864f, -0.00309437f, -0.02519404f, 0.01225238f, 0.01863895f, 0.00607497f, -0.00474714f, 
    -0.01867043f, -0.00877178f, -0.02573448f, -0.01950971f, -0.02597236f, 0.02636367f, -0.02129754f, 0.00923691f, 
    0.02313974f, 0.01851798f, 0.00720921f, -0.02884489f, 0.03031565f, -0.02453722f, -0.02951921f, -0.03446195f, 
    0.02306929f, -0.01568950f, 0.01835155f, 0.00030837f, -0.01539044f, -0.01942761f, 0.02033771f, 0.02645411f, 
    -0.02690008f, -0.01993169f, -0.01524463f, -0.00909759f, -0.02729593f, -0.00916559f, -0.02575439f, 0.00514008f, 
    -0.01257546f, 0.01088458f, -0.04178400f, -0.03832763f, 0.03123445f, -0.02266685f, 0.00291434f, -0.02939796f, 
    -0.03285848f, -0.04307217f, -0.03525746f, -0.01437222f, 0.01402832f, 0.02615825f, 0.00290149f, -0.00633761f, 
    0.01582712f, -0.02359151f, -0.01487940f, -0.01401451f, -0.02234588f, -0.01946044f, 0.00647369f, -0.02993714f, 
    0.01625699f, -0.01758115f, -0.00346469f, 0.03487257f, 0.02675418f, -0.04351508f, -0.02614741f, -0.02781334f, 
    0.03486546f, -0.01181322f, 0.02263086f, 0.00500463f, 0.02026277f, 0.00032484f, -0.02340689f, 0.01618644f, 
    -0.01938917f, -0.02317138f, -0.03993928f, 0.00169223f, 0.00471696f, 0.01950442f, -0.02962829f, 0.00300750f, 
    0.01409629f, 0.02930455f, -0.02280162f, -0.03389494f, 0.02798686f, -0.01864441f, 0.02670609f, -0.03923422f, 
    0.01979896f, -0.01525312f, -0.02850307f, -0.00258367f, -0.01939376f, 0.01667617f, -0.02913054f, 0.01674431f, 
    0.01936528f, 0.02041763f, -0.00914600f, -0.01742877f, -0.00934708f, -0.04171640f, -0.01489653f, -0.00231995f, 
    -0.03894464f, 0.00701456f, -0.03145485f, 0.00234346f, -0.03005711f, -0.02224762f, -0.02495496f, -0.03220194f, 
    0.02422142f, -0.00920482f, 0.03170687f, -0.00338510f, 0.02229723f, -0.01973783f, -0.03264022f, -0.02496917f, 
    0.03073109f, 0.02581940f, -0.02145875f, 0.01340634f, 0.00561829f, -0.02635222f, -0.02524598f, 0.00957716f, 
    0.01768471f, 0.00827117f, -0.03106552f, 0.01246950f, 0.00770010f, -0.01109754f, 0.02235246f, 0.02861590f, 
    -0.01426347f, 0.01107634f, -0.00291762f, -0.03790777f, -0.03458804f, -0.00951734f, -0.00919121f, 0.00275576f, 
    0.01767352f, -0.03832052f, 0.01530283f, 0.01359637f, -0.01737486f, -0.02241202f, 0.01290337f, -0.02483568f, 
    0.00409422f, 0.02485958f, -0.02212876f, -0.01361085f, -0.03917043f, -0.00286297f, 0.01299794f, 0.01424961f, 
    -0.03546804f, 0.02954222f, -0.02281534f, -0.01607553f, 0.00424228f, 0.01174988f, 0.01171845f, -0.00456756f, 
    -0.01768667f, 0.01306594f, 0.02173098f, 0.01024568f, 0.02545540f, 0.01244456f, -0.03529924f, 0.02646562f, 
    -0.03438501f, 0.02479448f, -0.03259117f, 0.01495115f, 0.02124372f, 0.00528263f, -0.02131328f, -0.03585654f, 
    -0.03567461f, -0.02140655f, -0.00609507f, -0.01358703f, 0.00091910f, -0.03127354f, 0.01786225f, -0.00976228f, 
    0.02746737f, 0.01188680f, -0.02642649f, -0.00626676f, 0.02105143f, 0.00645259f, -0.00988845f, -0.00718408f, 
    0.02936589f, -0.04138523f, 0.02049209f, -0.03667268f, -0.00861698f, 0.02237620f, -0.03268162f, -0.02525957f, 
    0.02769213f, 0.02809921f, -0.00922175f, 0.01414059f, 0.00881088f, -0.00635755f, 0.01482860f, -0.04106429f, 
    0.02145838f, 0.01342586f, 0.01406109f, -0.03709879f, 0.01964655f, -0.01019889f, -0.03224540f, 0.00252904f, 
    0.02308797f, -0.00239776f, 0.00010663f, 0.02231909f, -0.00514204f, -0.02446809f, 0.00500977f, 0.00861030f, 
    -0.03191667f, -0.00728171f, 0.02008850f, -0.01502852f, -0.04334638f, 0.01145821f, -0.02936975f, -0.02156540f, 
    0.02202360f, -0.03314328f, 0.01927966f, 0.01892654f, -0.02450931f, -0.03278574f, -0.01722421f, -0.01043095f, 
    -0.02754917f, 0.00276921f, -0.02558797f, -0.04301488f, 0.00067180f, -0.02765250f, -0.03432645f, 0.01329099f, 
    -0.01333112f, -0.01656580f, 0.01024023f, -0.00030405f, -0.02497329f, 0.01654799f, 0.00419581f, 0.00291656f, 
    -0.03015028f, 0.03417426f, 0.00467969f, -0.00926802f, 0.02328148f, 0.01125488f, 0.00739624f, 0.01162280f, 
    -0.01650596f, -0.03060965f, 0.03385035f, -0.04384587f, -0.03567815f, -0.00530362f, -0.02638234f, 0.00574508f, 
    -0.00533840f, 0.00854416f, -0.00648051f, 0.00630682f, 0.01674700f, 0.01060657f, 0.01594590f, 0.00873298f, 
    -0.00708941f, 0.02420866f, -0.00535009f, -0.00134273f, -0.00627594f, 0.00721526f, -0.03641221f, -0.03528230f, 
    -0.00030445f, -0.00174924f, 0.03234591f, 0.02098604f, 0.02028595f, -0.02949262f, -0.02036831f, -0.01906678f, 
    -0.02534689f, 0.01583874f, -0.01840447f, -0.03485285f, -0.00857070f, -0.02636379f, -0.01645785f, 0.01237645f, 
    0.01795859f, 0.01408680f, 0.03290323f, -0.01011782f, 0.02492012f, -0.01835157f, -0.02426030f, -0.03884455f, 
    -0.02680194f, -0.03203081f, 0.00417727f, -0.02580296f, -0.03626050f, -0.02135743f, 0.00561743f, 0.02582093f, 
    0.03228270f, -0.01827740f, -0.03221716f, 0.02844548f, -0.01102074f, -0.00305608f, 0.00061787f, 0.00883802f, 
    -0.04104234f, -0.02829487f, -0.02031165f, 0.01617623f, -0.02591348f, -0.04253901f, 0.00292114f, -0.01174791f, 
    -0.01651186f, -0.02302144f, -0.02623819f, 0.00325211f, -0.00414151f, -0.03080563f, -0.02788398f, 0.03256962f, 
    -0.02006432f, -0.02266833f, -0.00235930f, -0.03408393f, -0.01270628f, 0.00221249f, -0.01934775f, 0.01507138f, 
    0.03771653f, 0.01594269f, 0.02360699f, -0.02625353f, -0.00762736f, -0.03055940f, 0.00509529f, -0.03124361f, 
    -0.02260608f, -0.03317129f, 0.02948356f, -0.01576982f, -0.01417143f, -0.00890813f, -0.00754269f, -0.02697220f, 
    -0.00456645f, 0.01079997f, -0.00704153f, -0.02166593f, 0.01831992f, 0.00303253f, -0.02284016f, -0.02457730f, 
    0.01146383f, -0.00828343f, -0.03670167f, -0.01108635f, -0.02013718f, -0.02914834f, -0.01824788f, 0.02062272f, 
    -0.02180923f, 0.01554053f, 0.01984282f, -0.00922307f, -0.01007490f, 0.01836617f, -0.01355411f, 0.00487225f, 
    -0.01625811f, 0.02919109f, -0.03306046f, -0.03757193f, 0.00279166f, -0.02033652f, 0.00172264f, 0.02565198f, 
    0.01336686f, 0.00081565f, 0.00602669f, 0.01941679f, -0.01325238f, 0.01174014f, -0.01513394f, 0.01703476f, 
    -0.00984968f, 0.00031310f, 0.01762671f, 0.00985470f, 0.01555072f, 0.00153022f, -0.04807572f, 0.01999163f, 
    0.00485598f, 0.03069786f, 0.02978109f, -0.01210594f, -0.01390501f, -0.02991177f, -0.01216695f, -0.01919222f, 
    0.02042097f, 0.00094149f, 0.02312277f, -0.02217050f, -0.02711300f, 0.00691063f, -0.02929230f, -0.03409750f, 
    0.00857785f, 0.02431624f, -0.02703382f, 0.02545747f, -0.01885873f, 0.00310881f, 0.00297520f, -0.00660921f, 
    -0.03576400f, -0.03926399f, -0.02645271f, 0.00819031f, -0.01287023f, 0.02741518f, -0.01389046f, -0.02640583f, 
    0.00164206f, -0.00625253f, -0.03902514f, 0.00642147f, -0.00651388f, 0.00269975f, 0.02375187f, 0.02483984f, 
    -0.02949617f, -0.02263455f, -0.00465696f, -0.03416441f, 0.00035036f, -0.00521426f, -0.03871325f, 0.00379896f, 
    0.01397939f, -0.02985761f, 0.02159996f, 0.03303468f, 0.01926539f, -0.00744206f, 0.01027098f, 0.02269175f, 
    -0.03121297f, 0.03193320f, 0.01882909f, -0.02134923f, -0.03790691f, -0.03181772f, -0.00241132f, 0.00961721f, 
    -0.00891269f, -0.01260501f, -0.02732787f, -0.01715524f, 0.01536814f, -0.02199764f, 0.01837783f, -0.00449122f, 
    0.02210008f, 0.00001450f, -0.03966334f, 0.02639939f, -0.02654790f, 0.01644348f, 0.00241282f, -0.02388955f, 
    0.01423372f, -0.00171545f, 0.02350175f, 0.03026245f, -0.03227525f, -0.01280941f, 0.00460712f, -0.03385137f, 
    0.02849303f, -0.01702699f, -0.01236764f, -0.03770351f, -0.03184741f, -0.00592238f, 0.02330346f, 0.01719234f, 
    -0.00057206f, -0.02190982f, -0.01797585f, -0.01753595f, 0.00716943f, -0.03151725f, 0.01268269f, -0.02799110f, 
    0.02880063f, 0.01136963f, -0.03103434f, -0.02417088f, -0.02424832f, -0.02477550f, -0.01939086f, -0.03389391f, 
    -0.03674912f, 0.02374405f, -0.01716326f, -0.03957926f, 0.01142989f, 0.02589322f, 0.02802633f, -0.01367522f, 
    -0.02655738f, -0.01404353f, -0.00681999f, -0.03956201f, 0.00657074f, 0.02496533f, -0.03263965f, 0.02356439f, 
    0.00873163f, 0.01816370f, 0.00779230f, -0.00873501f, 0.01506612f, -0.01305739f, -0.01484111f, 0.02832385f, 
    0.01512453f, -0.00864415f, 0.02765500f, -0.01106944f, 0.00454598f, 0.00896387f, -0.01225987f, -0.03785003f, 
    0.00634812f, -0.00413265f, 0.00564875f, -0.02734238f, 0.02164904f, -0.00520192f, 0.00327521f, -0.03193193f, 
    -0.03842578f, -0.02921808f, -0.02208649f, 0.03046449f, 0.03927475f, -0.03621495f, 0.02033663f, -0.01513242f, 
    0.00867771f, -0.04269961f, 0.01632458f, -0.02163631f, 0.00139302f, -0.02173643f, 0.01051150f, 0.02778927f, 
    -0.00754924f, -0.03353688f, -0.03891357f, 0.00173166f, -0.01826921f, 0.02811944f, -0.03225437f, -0.00586656f, 
    -0.02714616f, 0.00873048f, -0.04128609f, -0.00882845f, 0.00638221f, -0.02474182f, 0.02174190f, -0.03483093f, 
    0.00993047f, -0.03898063f, 0.01984969f, 0.02377721f, -0.00848562f, -0.03321347f, 0.00336538f, -0.01448539f, 
    -0.02936511f, 0.02649050f, -0.03241656f, -0.00469529f, 0.03022392f, 0.00713091f, -0.02990601f, -0.00887849f, 
    -0.00380079f, -0.01403227f, 0.02692352f, 0.02537376f, 0.01242873f, 0.01265663f, 0.00288818f, -0.01221016f, 
    -0.03945892f, 0.02729173f, 0.00417699f, -0.03860319f, 0.02311086f, 0.02885372f, 0.02486039f, 0.01876433f, 
    -0.00467444f, -0.02899146f, 0.01442519f, -0.00727925f, 0.01436547f, 0.01291176f, 0.01961241f, -0.04040952f, 
    -0.00666591f, 0.02389880f, -0.02659050f, -0.01322216f, 0.02273683f, -0.03363279f, 0.00071705f, 0.00992145f, 
    -0.02018191f, -0.00418751f, 0.00864156f, -0.02907817f, 0.02174656f, -0.03631644f, -0.02108810f, -0.01280582f, 
    -0.00259262f, 0.00030323f, 0.03186714f, 0.00261462f, 0.03112209f, 0.01602959f, -0.01443942f, -0.03321015f, 
    -0.03737960f, 0.01921355f, -0.03100832f, 0.00840685f, 0.00890807f, -0.00708250f, 0.00796829f, 0.02895571f, 
    -0.04092501f, 0.02941533f, 0.00035157f, -0.01100296f, -0.00578577f, -0.02745786f, -0.01716561f, 0.00596709f, 
    -0.02564361f, -0.03957552f, -0.00234951f, -0.03198352f, -0.01757280f, -0.00024246f, 0.00254507f, -0.02869451f, 
    -0.01235739f, 0.02681053f, 0.02095869f, 0.00451388f, -0.01402930f, -0.00496657f, 0.02355945f, 0.00827451f, 
    -0.00275587f, 0.00704699f, -0.02333827f, -0.03109636f, 0.02826862f, 0.00579697f, -0.03522682f, -0.02799058f, 
    -0.01874786f, 0.02122890f, 0.00978806f, -0.02369539f, 0.02420826f, -0.00671684f, -0.01647004f, -0.03657575f, 
    -0.01629892f, 0.02079375f, -0.03586720f, -0.01877081f, 0.00987552f, 0.02479144f, -0.02385889f, 0.01719090f, 
    0.00432799f, -0.02578954f, 0.01364729f, -0.00426303f, -0.02718517f, -0.03808124f, 0.02071762f, 0.02776060f, 
    0.01679205f, -0.00435117f, -0.01436913f, -0.02289386f, 0.01333231f, 0.01765413f, -0.00233301f, -0.00131277f, 
    -0.01704087f, 0.01498136f, -0.00190232f, -0.03123657f, 0.02968556f, -0.00328849f, -0.01265303f, 0.00792881f, 
    0.01339724f, -0.01029430f, 0.02916125f, 0.02076825f, -0.01258016f, -0.01983591f, 0.01780225f, 0.02047881f, 
    0.00858626f, -0.03034318f, 0.02022450f, -0.00690230f, -0.04029126f, -0.01326285f, 0.01013275f, -0.03139170f, 
    0.00218505f, -0.01298928f, -0.01418742f, -0.03535986f, -0.01086011f, 0.00267195f, -0.01544592f, 0.02711867f, 
    -0.01221443f, 0.01428663f, -0.03634476f, -0.03235461f, -0.02948902f, -0.02571821f, -0.01945488f, -0.00917839f, 
    0.00235649f, -0.02742800f, -0.03674309f, 0.00250774f, -0.03573181f, 0.01525003f, -0.03493053f, -0.00327802f, 
    0.01207950f, -0.00693392f, -0.00846452f, -0.02998406f, -0.03522871f, 0.00130409f, -0.04080167f, -0.01724542f, 
    0.01924571f, -0.02750780f, -0.03283463f, -0.01908161f, -0.03886486f, -0.01116145f, -0.00301877f, 0.01721671f, 
    -0.03770046f, -0.00082696f, 0.00034052f, -0.00025794f, -0.04215953f, 0.02801709f, 0.00178632f, 0.02306732f, 
    -0.03152337f, 0.01055683f, 0.02641852f, 0.00870546f, 0.01414053f, -0.01864374f, -0.00542962f, -0.00512002f, 
    -0.03538826f, -0.01655913f, 0.02557521f, -0.00003035f, 0.00945178f, 0.02297404f, -0.01927935f, -0.01419675f, 
    -0.03893407f, -0.00291574f, -0.00258786f, -0.01381933f, 0.01883647f, 0.01942932f, 0.01299584f, 0.01219982f, 
    0.00623660f, 0.01337339f, -0.00400283f, 0.00884627f, -0.03249753f, -0.02155459f, -0.02482419f, 0.01121597f, 
    -0.02797041f, -0.01049002f, -0.03555735f, 0.02035043f, 0.01472514f, 0.02252295f, -0.00824674f, -0.03943418f, 
    -0.02104081f, -0.01601919f, -0.03441632f, -0.02415602f, 0.01881486f, 0.00220089f, -0.00292227f, -0.02292331f, 
    -0.02070058f, -0.00349874f, 0.01751582f, 0.02373428f, -0.01859588f, -0.01158671f, -0.02753730f, -0.03562943f, 
    0.00600654f, 0.02844828f, -0.02990012f, 0.00363958f, 0.01765013f, 0.02026455f, -0.00932248f, 0.01817007f, 
    -0.00625100f, 0.02895065f, -0.01775617f, -0.00712445f, -0.02093871f, -0.02189348f, 0.01400017f, -0.01173430f, 
    -0.02592785f, -0.02710285f, 0.01702672f, 0.02945176f, -0.03445494f, -0.03435335f, -0.00669833f, -0.00004073f, 
    -0.02795278f, -0.03050056f, -0.01971528f, -0.03713986f, 0.03318487f, -0.03236132f, -0.03508559f, -0.02992992f, 
    0.00374465f, 0.01002527f, 0.01631805f, 0.01352453f, -0.03982547f, 0.00609026f, -0.02768346f, -0.00833925f, 
    -0.03039021f, -0.00298291f, 0.00119481f, -0.02911688f, 0.00771063f, -0.01483321f, -0.00568095f, 0.01439116f, 
    0.00806912f, 0.00117607f, -0.01884039f, 0.02027714f, -0.01808213f, -0.01984123f, -0.01989543f, 0.00808024f, 
    -0.04080863f, -0.01982930f, 0.01356749f, 0.00696477f, -0.01937468f, -0.00340466f, 0.00685682f, 0.01732298f, 
    -0.01751909f, 0.00449932f, -0.01301255f, -0.00564109f, -0.00839636f, 0.01501854f, 0.02567595f, 0.00687518f, 
    -0.01244292f, 0.00709718f, -0.03469774f, 0.01877769f, -0.02786936f, -0.01416619f, 0.00508273f, 0.00348423f, 
    -0.03151303f, -0.02801266f, -0.04136161f, -0.03426867f, -0.03638443f, -0.02516413f, 0.02104189f, -0.02705507f, 
    0.00570578f, 0.02894935f, -0.03083350f, -0.03754108f, -0.02792479f, 0.02057282f, 0.01233760f, -0.00301681f, 
    0.01353949f, -0.00440472f, -0.02168762f, -0.02044889f, -0.03448315f, 0.02825306f, 0.01042320f, -0.01797149f, 
    -0.03299208f, -0.01759359f, 0.01276885f, -0.02162367f, -0.04031212f, 0.00681413f, 0.00777909f, -0.03345795f, 
    0.00458302f, 0.01354109f, -0.00286106f, -0.01719847f, 0.02035640f, 0.02291706f, 0.01518236f, -0.04018869f, 
    0.00224925f, -0.00464270f, -0.02258842f, -0.03836121f, -0.00880814f, -0.02396355f, 0.01465219f, -0.02343149f, 
    -0.03404826f, -0.02714395f, 0.01355354f, -0.00700402f, -0.02296467f, -0.02705229f, 0.01110099f, 0.00008423f, 
    -0.00691918f, 0.02736337f, -0.03097453f, 0.00046263f, 0.01790636f, 0.01355411f, 0.00641383f, -0.03279283f, 
    -0.03049510f, -0.03477507f, 0.00206081f, -0.01295865f, 0.00082266f, 0.03451608f, 0.01987796f, -0.01511075f, 
    -0.03275540f, 0.02128380f, 0.00877537f, 0.02148219f, 0.01110191f, -0.00809682f, 0.01830402f, 0.03039753f, 
    -0.01214651f, 0.02662908f, -0.03021926f, -0.01735107f, -0.00983926f, -0.00324490f, -0.03312333f, 0.00944122f, 
    0.02599439f, -0.00993184f, -0.02932811f, -0.01594349f, -0.02838925f, -0.03126206f, 0.02696524f, -0.02853822f, 
    -0.00229161f, 0.02257344f, 0.01157369f, -0.01964569f, -0.00365442f, -0.03661093f, -0.03066226f, -0.00362449f, 
    0.01166739f, 0.01914329f, 0.01772057f, 0.02310598f, -0.02027023f, -0.01760370f, -0.03492313f, -0.00989493f, 
    0.02767731f, 0.01696204f, -0.00904969f, 0.00039498f, -0.02160064f, -0.00242646f, 0.02379151f, -0.02572393f, 
    0.03311881f, -0.03902945f, -0.01012965f, -0.02439497f, 0.01847275f, -0.03114716f, -0.03479645f, -0.00396067f, 
    0.00519265f, -0.01376852f, 0.01095778f, -0.02652565f, -0.02439632f, -0.03171426f, -0.03587625f, -0.00120569f, 
    -0.00622570f, 0.00613700f, -0.02988348f, -0.03553009f, 0.00664769f, -0.01593599f, -0.03479083f, -0.03993701f, 
    -0.00245977f, 0.00827345f, -0.02820854f, -0.03925572f, -0.04215621f, 0.02074793f, 0.00475876f, -0.04204207f, 
    -0.00897512f, -0.02180581f, -0.02966449f, 0.00666913f, -0.02712351f, 0.00517904f, 0.01649724f, -0.02337845f, 
    0.02761448f, -0.01020463f, -0.02061002f, 0.02170529f, -0.01399230f, 0.00628482f, 0.00409347f, -0.00656698f, 
    -0.02018081f, -0.01013830f, 0.00543104f, 0.00660424f, 0.00467117f, -0.00233075f, 0.01497259f, 0.01574335f, 
    -0.00388742f, -0.00247968f, 0.01534518f, -0.00573094f, -0.01613521f, -0.02901053f, 0.01876799f, -0.00728156f, 
    0.02308842f, -0.00613839f, 0.02759251f, 0.00792268f, 0.02579387f, -0.01593228f, -0.03895875f, 0.02525930f, 
    -0.00794597f, 0.01241895f, 0.02616707f, -0.01388976f, -0.02865314f, -0.04061751f, -0.02005293f, 0.00809234f, 
    -0.00968396f, 0.01049093f, -0.00040583f, -0.00429529f, 0.00451245f, -0.00118941f, -0.01513410f, -0.03351250f, 
    -0.01855600f, 0.00230656f, 0.02246911f, -0.01343307f, 0.00708578f, -0.00992483f, -0.01933347f, 0.02616085f, 
    0.01531843f, 0.02459644f, -0.04156148f, 0.01060738f, 0.00890284f, 0.00318198f, 0.02571124f, -0.03884254f, 
    -0.02168195f, -0.01933110f, 0.01287160f, 0.02069092f, 0.02148843f, -0.02218208f, 0.01428473f, -0.01486743f, 
    0.03511098f, -0.03296380f, -0.00904871f, -0.00935945f, 0.02131179f, 0.02776806f, 0.00048240f, -0.01595631f, 
    -0.02256613f, -0.00898604f, -0.01321789f, -0.01254156f, -0.03284982f, 0.01862899f, 0.02693925f, -0.01339909f, 
    -0.03956833f, 0.01391383f, -0.00330575f, 0.00839065f, -0.03481715f, -0.02513356f, 0.02582263f, -0.02721873f, 
    -0.01013337f, 0.01624652f, 0.00110244f, -0.02474526f, 0.00583225f, 0.01246513f, -0.00476731f, -0.00157461f, 
    -0.00648202f, 0.01717568f, -0.01299812f, -0.02598099f, -0.00707320f, -0.04053897f, -0.01069838f, 0.02810829f, 
    -0.02727123f, -0.03152345f, -0.02008822f, 0.02803705f, -0.02874342f, -0.01584908f, -0.01892410f, -0.03460009f, 
    -0.02356186f, -0.02665501f, -0.03444326f, -0.03725145f, 0.00057248f, -0.01606605f, 0.00104373f, -0.02552510f, 
    0.01941396f, 0.02078168f, -0.03472389f, 0.00226331f, -0.01530402f, -0.01436432f, -0.02430548f, -0.01446947f, 
    -0.00122857f, -0.00444209f, -0.00641027f, 0.02329080f, 0.00145248f, -0.03372909f, -0.02141412f, 0.02906876f, 
    -0.03068985f, -0.00764606f, 0.01251614f, 0.00197258f, -0.03048939f, 0.01118273f, 0.02199580f, -0.00848728f, 
    0.01710984f, 0.00149280f, -0.04084706f, 0.01531852f, -0.02011803f, -0.01112669f, 0.02266992f, -0.00838044f, 
    -0.03787238f, -0.04147396f, -0.01211127f, 0.02052953f, 0.01485192f, 0.00244221f, -0.03919834f, -0.02457736f, 
    -0.01325601f, 0.01545372f, -0.01835600f, 0.00431508f, 0.00045151f, 0.03179648f, 0.01471539f, 0.02313532f, 
    0.01236578f, -0.02831969f, 0.01171155f, -0.01486327f, -0.03714293f, -0.04192004f, -0.02776059f, -0.00943486f, 
    -0.02583591f, -0.00388560f, -0.00992604f, -0.00218487f, -0.03438970f, 0.02868658f, -0.04114009f, -0.01960203f, 
    0.00207284f, -0.01028143f, -0.00560936f, -0.02573809f, -0.03656360f, 0.01125307f, 0.02325948f, -0.01668502f, 
    -0.00468932f, 0.02093097f, -0.04045120f, 0.00429045f, -0.02525579f, 0.02492169f, 0.00489725f, -0.02165717f, 
    0.00825254f, 0.02168428f, 0.00473370f, 0.02871866f, -0.00749971f, -0.02750576f, -0.03825284f, 0.01762585f, 
    -0.01380696f, -0.01457083f, -0.02709374f, -0.00188098f, -0.03742452f, -0.00501206f, 0.00600941f, -0.01202863f, 
    -0.00858364f, -0.01584671f, 0.00181461f, -0.03803936f, -0.02466847f, 0.00451039f, -0.03555384f, -0.00610159f, 
    -0.03593564f, -0.02861475f, -0.02764446f, -0.00859546f, -0.00681294f, 0.00632993f, -0.03876222f, -0.00052596f, 
    -0.01521227f, -0.03838310f, -0.00699482f, 0.00875914f, 0.00337191f, -0.02930119f, 0.02689809f, -0.03594140f, 
    0.01033143f, -0.02826368f, -0.01631868f, 0.01606186f, 0.00207171f, 0.00471266f, -0.00075134f, 0.00149695f, 
    -0.03669809f, 0.02430188f, -0.00644396f, 0.01913674f, -0.03248616f, 0.00658330f, 0.02494229f, -0.00196725f, 
    -0.02362284f, 0.02264078f, -0.04160123f, -0.04096141f, -0.03970780f, -0.02002806f, -0.02715341f, -0.03591311f, 
    0.02078537f, -0.02602274f, 0.01050241f, -0.02642406f, 0.00546500f, -0.02336347f, -0.02539379f, -0.00373481f, 
    -0.02101358f, 0.01514114f, -0.03020084f, 0.02401864f, -0.02786279f, -0.02548416f, -0.01756554f, 0.00802747f, 
    -0.03657403f, -0.01214256f, -0.00958636f, -0.02484909f, 0.00814410f, 0.00799846f, 0.00219220f, -0.02000661f, 
    -0.01561527f, -0.02529402f, -0.02693967f, 0.00965343f, 0.00282099f, -0.03203944f, 0.03550632f, -0.03414014f, 
    0.00634076f, 0.02276263f, 0.01568113f, 0.01442515f, 0.01930314f, 0.02250170f, 0.01036063f, -0.01136348f, 
    0.02725649f, -0.03060479f, -0.01572312f, -0.01331034f, -0.02500927f, -0.01301652f, -0.00274358f, 0.00324457f, 
    -0.04201350f, 0.01087505f, -0.01069286f, -0.02796367f, -0.03215246f, 0.02586747f, 0.00304765f, 0.02964886f, 
    0.12021937f, 0.09768967f, 0.03723409f, -0.00896045f, -0.00794453f, 0.09261041f, 0.13693503f, -0.07203771f, 
    0.03004036f, 0.01322290f, -0.00232828f, 0.17006494f, -0.02244849f, 0.01342089f, 0.11508995f, -0.01808498f, 
    -0.06271180f, 0.04306902f, -0.04917679f, 0.08670980f, -0.04560991f, 0.17337929f, 0.07701989f, -0.19204414f, 
    -0.19781221f, -0.07920892f, -0.03324644f, 0.09362692f, -0.06645098f, -0.06535975f, -0.13450438f, 0.00400527f, 
    -0.11724216f, 0.01335698f, -0.06330448f, -0.01003454f, 0.37460345f, 0.26741982f, -0.30311766f, 0.02733606f, 
    -0.08804906f, -0.02611738f, 0.26312432f, 0.00676562f, 0.02280530f, 0.02452832f, -0.14058863f, 0.14889367f, 
    -0.09512938f, 0.18754648f, 0.15404075f, 0.07675686f, -0.02201828f, -0.05065147f, -0.05591002f, -0.08824186f, 
    0.05661179f, 0.03128805f, -0.00411802f, 0.07502042f, -0.11560317f, -0.06922043f, -0.10356252f, -0.00889837f, 
    -0.02641028f, 0.01965972f, -0.08467434f, -0.07046863f, -0.07088196f, -0.06261510f, -0.04240406f, -0.33672076f, 
    -0.05989479f, 0.15285999f, 0.21133205f, -0.19453336f, -0.33185080f, 0.12171365f, -0.01588184f, 0.06329916f, 
    0.08466439f, 0.06372567f, -0.01335978f, 0.00354198f, -0.26075032f, -0.07165731f, 0.01525475f, 0.04555877f, 
    -0.03955682f, -0.07039763f, -0.08637303f, -0.07116751f, -0.08859712f, 0.04033946f, 0.02278696f, 0.00204714f, 
    0.31957874f, 0.02405197f, 0.18562177f, -0.28038877f, 0.12805155f, 0.14670515f, -0.08097445f, 0.32966891f, 
    -0.07937744f, 0.03293021f, 0.01687117f, 0.03142402f, 0.07671095f, 0.09978087f, -0.12677012f, -0.12775654f, 
    0.06317687f, -0.31892636f, 0.14174666f, 0.12607710f, -0.01995127f, 0.01522149f, -0.03368187f, 0.08118361f, 
    0.10616565f, 0.27417779f, 0.03942191f, -0.23616618f, 0.12730020f, -0.04064722f, 0.03068307f, 0.06126398f, 
    0.06119033f, 0.04981048f, -0.10245977f, -0.09991197f, 0.17791466f, -0.02111844f, -0.35003570f, 0.00585811f, 
    0.21619956f, 0.13168363f, 0.14658573f, 0.05191258f, -0.21576594f, -0.12066475f, -0.12067921f, -0.09960804f, 
    0.30111822f, 0.22091627f, -0.12081499f, -0.14165089f, 0.17183600f, 0.23971473f, -0.01990512f, 0.06274813f, 
    0.22455634f, -0.04775388f, -0.02796919f, -0.04720373f, -0.03137880f, -0.13052480f, -0.06836431f, 0.12568036f, 
    0.10063734f, 0.19434133f, 0.02618129f, 0.15808146f, 0.00151867f, -0.01451748f, -0.08030868f, -0.11753124f, 
    -0.06282176f, 0.24509318f, 0.10596602f, -0.21423370f, 0.05267654f, -0.02070502f, 0.04017106f, 0.06513180f, 
    -0.05917822f, -0.05122406f, -0.04823795f, -0.25219065f, 0.29691091f, 0.17703189f, -0.39554459f, -0.27633816f, 
    0.23534027f, 0.06047232f, 0.22120322f, -0.16433582f, -0.02241767f, 0.06956570f, -0.01418061f, 0.07394399f, 
    -0.01367284f, 0.07920719f, -0.24276903f, -0.05642679f, 0.03642021f, -0.03211904f, -0.10310124f, -0.00145151f, 
    0.07063351f, -0.11105627f, 0.16770853f, 0.09389006f, 0.12996012f, -0.12772189f, -0.08142789f, -0.03141915f, 
    -0.00769527f, 0.08269546f, 0.10603110f, 0.05441542f, -0.06197212f, -0.01351648f, -0.08316101f, -0.20613869f, 
    0.07985452f, -0.10418347f, -0.18553928f, 0.01229535f, 0.06125170f, 0.16334914f, -0.02180888f, -0.03826980f, 
    -0.02024976f, 0.00132926f, -0.04355129f, 0.16294773f, -0.19585428f, -0.06538588f, 0.00142839f, -0.08744486f, 
    -0.00469267f, -0.04804225f, -0.05425754f, -0.05943182f, -0.07874826f, 0.13450143f, 0.16458347f, 0.09414928f, 
    0.27586192f, 0.25272176f, -0.14397720f, -0.02162790f, -0.13858576f, -0.16978920f, 0.26809171f, 0.28133002f, 
    -0.06338292f, -0.04712917f, -0.20518634f, -0.15686560f, 0.01032300f, 0.20460990f, -0.05525885f, -0.07095059f, 
    0.03737355f, -0.07105759f, 0.10946680f, 0.14647606f, 0.10619151f, 0.21579720f, -0.14629790f, 0.03558793f, 
    -0.05204734f, 0.01463271f, 0.04963647f, -0.07955025f, -0.00756136f, -0.12530378f, 0.13436258f, -0.08535263f, 
    0.14699192f, -0.02882779f, 0.09229732f, 0.27904916f, 0.03128759f, 0.07308018f, 0.17518260f, 0.06383080f, 
    -0.01033632f, 0.05920109f, 0.06524693f, 0.05386044f, -0.11870753f, -0.01284830f, 0.07138305f, -0.11011340f, 
    -0.00297028f, 0.01764316f, 0.02458072f, 0.00664647f, -0.02749403f, -0.08999241f, -0.03911555f, 0.23340441f, 
    -0.01388461f, -0.11825953f, -0.07422987f, -0.18616286f, 0.02695187f, 0.17930667f, 0.18472150f, 0.01537508f, 
    -0.06794796f, -0.02899405f, -0.03165775f, -0.00070246f, 0.08796329f, -0.04140386f, 0.20320860f, 0.23559175f, 
    0.22863603f, 0.11115289f, -0.11037812f, -0.16355033f, 0.28462371f, 0.27887982f, -0.01206238f, -0.01440594f, 
    0.01503946f, 0.06419816f, 0.01588672f, 0.05298417f, 0.02076622f, 0.04146126f, -0.22472271f, 0.07860813f, 
    -0.00147289f, 0.03777437f, 0.00814358f, 0.05713210f, -0.01336297f, 0.06917074f, -0.04621731f, -0.15379198f, 
    0.03453104f, 0.11564039f, -0.32836452f, 0.04672384f, -0.05875380f, -0.02665755f, 0.18771090f, 0.08518638f, 
    0.04917745f, -0.20098971f, 0.06305081f, 0.17912854f, -0.06872769f, -0.13039154f, -0.07994549f, 0.07814372f, 
    -0.02204620f, -0.07991659f, -0.05971526f, -0.02588267f, -0.31664836f, -0.28088704f, 0.02131507f, -0.04541369f, 
    -0.17231077f, 0.08462913f, -0.08560435f, -0.07590532f, 0.04779230f, 0.01566401f, 0.10581160f, 0.05203206f, 
    0.08731727f, -0.01729764f, 0.09906255f, 0.01354632f, -0.00308930f, 0.04053204f, -0.06807518f, 0.07077813f, 
    0.00414546f, -0.03150845f, 0.15968335f, -0.20183517f, -0.04795069f, 0.10680915f, 0.04889240f, 0.11914340f, 
    0.07737029f, -0.04308897f, -0.17945315f, 0.06054589f, 0.06837014f, 0.20982137f, 0.00536230f, 0.00539927f, 
    -0.10206859f, -0.00924609f, 0.00220529f, 0.15097985f, -0.03604938f, -0.07357599f, 0.19066766f, -0.01815884f, 
    0.01933519f, -0.13718657f, -0.15225266f, 0.00228175f, -0.07401053f, 0.08277196f, 0.16955847f, 0.39467943f, 
    -0.12596735f, -0.06869116f, -0.09012251f, 0.06708564f, 0.04884700f, 0.06252784f, 0.07190581f, 0.06296582f, 
    0.15097024f, 0.06691642f, 0.09622270f, -0.06351442f, 0.15974006f, -0.15529422f, -0.07426114f, 0.00269235f, 
    0.06910251f, 0.13508756f, 0.07465624f, -0.00887484f, 0.01714687f, -0.13687368f, -0.00749855f, -0.11644147f, 
    -0.12091663f, -0.20982188f, -0.06037853f, 0.32483482f, 0.05792905f, 0.14013958f, 0.03668983f, 0.00820109f, 
    -0.06086262f, 0.10952112f, -0.00655746f, 0.03013795f, -0.06280706f, -0.22975466f, -0.18306564f, 0.20804808f, 
    -0.04409757f, 0.16581576f, 0.05186774f, -0.07401995f, 0.01063248f, 0.08588795f, -0.16983457f, -0.11815552f, 
    0.30369264f, 0.46981972f, -0.15993765f, -0.00034450f, -0.15662287f, -0.19872628f, 0.17650867f, -0.15141836f, 
    0.06834895f, -0.10754058f, -0.01795278f, 0.01637176f, -0.12448873f, -0.10372659f, 0.14413133f, 0.15131761f, 
    -0.13203999f, -0.03542632f, -0.10183634f, -0.04834266f, -0.06875656f, 0.12108550f, 0.10341913f, -0.00099937f, 
    0.17808381f, 0.18315867f, -0.06963774f, -0.12971775f, 0.15415627f, 0.25567234f, -0.05478290f, 0.07332316f, 
    0.01234133f, 0.10935276f, 0.07399888f, -0.02032530f, -0.22116332f, -0.07816258f, -0.02547695f, 0.08050899f, 
    -0.02467888f, -0.01024842f, 0.04857842f, 0.04669479f, -0.15423024f, -0.09818072f, -0.14168122f, -0.19496103f, 
    -0.38953477f, 0.00660682f, 0.05126628f, -0.09659556f, -0.20305486f, -0.26615629f, -0.31681323f, -0.09991798f, 
    0.10727680f, -0.07653909f, 0.11749583f, 0.05257886f, -0.04091637f, -0.10833662f, 0.05835235f, 0.05710483f, 
    0.17562056f, 0.15789039f, 0.05861267f, 0.03453156f, 0.12311543f, -0.03176035f, 0.03634238f, 0.20711909f, 
    0.01411274f, -0.20525023f, -0.01768751f, 0.18864372f, -0.02693408f, 0.13377473f, -0.05238708f, 0.22988270f, 
    0.00779959f, -0.04694256f, 0.16319911f, 0.01784681f, -0.30235267f, -0.15399244f, 0.00071179f, -0.05996028f, 
    -0.12726216f, -0.13858220f, -0.08147657f, -0.02906989f, -0.03196043f, -0.01799607f, 0.02444097f, -0.04959262f, 
    0.11762459f, 0.05509720f, -0.05770620f, -0.22848709f, 0.16423377f, 0.11746343f, 0.05756573f, 0.17863408f, 
    0.06230209f, 0.00294010f, 0.02626180f, 0.10165209f, 0.25231335f, 0.10236277f, 0.05786121f, 0.08490438f, 
    0.00513957f, 0.20588070f, -0.14297643f, 0.19127949f, 0.12297719f, 0.09282653f, 0.17101955f, -0.06178486f, 
    -0.33436701f, -0.08027419f, 0.20758812f, 0.13453813f, -0.03859155f, -0.14897251f, -0.08212706f, 0.01385504f, 
    -0.15836607f, 0.04894553f, -0.02569407f, -0.04196286f, 0.13625675f, 0.13485000f, -0.07405184f, -0.05961593f, 
    0.06289177f, 0.11893606f, -0.06853965f, 0.07646879f, -0.04044256f, -0.11086605f, -0.22939157f, -0.02230549f, 
    -0.24335194f, 0.18845801f, 0.09364154f, -0.05821823f, -0.00845025f, -0.07293544f, -0.05893360f, 0.16200007f, 
    -0.08154014f, 0.01271057f, 0.01674784f, 0.06525040f, -0.29243180f, 0.01490398f, -0.07534710f, 0.00784018f, 
    -0.02089200f, -0.01555891f, -0.16563997f, 0.06476606f, -0.10813176f, -0.06879377f, -0.10906241f, -0.11895783f, 
    -0.15781356f, -0.00302696f, -0.11251119f, 0.05663113f, -0.01338206f, 0.01265780f, 0.00171728f, 0.03490302f, 
    0.01115131f, -0.14215077f, -0.20603511f, -0.09908133f, 0.10221470f, -0.09380873f, -0.31944764f, 0.02998191f, 
    0.20583762f, 0.10187574f, 0.09158042f, -0.13623463f, -0.05784106f, -0.01337072f, -0.11040334f, -0.03134612f, 
    0.12440147f, -0.00904712f, -0.03752147f, 0.06995118f, 0.17439343f, 0.20988901f, -0.12375074f, -0.09874234f, 
    0.16043718f, -0.00327480f, -0.02875398f, -0.04972550f, 0.21962598f, 0.21526714f, -0.03834000f, -0.12917285f, 
    0.14334206f, 0.14208481f, 0.15886530f, 0.07281983f, 0.00988676f, -0.00081431f, -0.11593278f, 0.07137990f, 
    -0.44402230f, -0.06743149f, -0.05775741f, 0.45259845f, -0.05186728f, -0.01047026f, -0.15728809f, 0.06389003f, 
    -0.06098096f, 0.05658863f, 0.03914765f, 0.22975308f, 0.22486649f, 0.28173888f, -0.00134571f, -0.06564303f, 
    0.07853222f, 0.07350588f, 0.08133405f, -0.07199969f, -0.05636807f, 0.01413503f, -0.11704127f, -0.22939268f, 
    0.04471530f, -0.06957487f, 0.03077285f, -0.17997712f, 0.04577592f, 0.23980618f, 0.07515640f, 0.01445036f, 
    0.08567902f, -0.08030703f, -0.07483527f, 0.01035653f, -0.17986390f, -0.05439060f, 0.03885779f, 0.00462846f, 
    -0.01213341f, -0.00198525f, -0.09798800f, -0.08023383f, 0.07096996f, 0.01995943f, -0.00795148f, 0.16738667f, 
    0.12405217f, 0.43205264f, 0.12628983f, -0.47732866f, 0.10321791f, 0.10158748f, 0.21132442f, 0.09806836f, 
    0.14982891f, 0.03437063f, -0.03213163f, 0.12404297f, -0.24177703f, 0.19411632f, -0.02075643f, -0.13297464f, 
    -0.07605345f, 0.06981083f, 0.10303187f, -0.06632438f, 0.09991607f, 0.09454088f, -0.09648214f, -0.01926151f, 
    0.02471796f, -0.18482484f, 0.10075718f, -0.02182557f, -0.05450997f, 0.13758941f, 0.13302034f, 0.03112197f, 
    -0.02829257f, 0.08511379f, 0.07752008f, 0.05915631f, -0.01638466f, 0.09791689f, -0.37929243f, 0.12286430f, 
    0.10038706f, 0.03364103f, -0.17358088f, -0.06178262f, 0.08922490f, -0.02187779f, 0.04310042f, 0.12171223f, 
    -0.03622434f, 0.01096353f, -0.01271566f, -0.03184196f, -0.01764159f, 0.02472380f, 0.00232726f, 0.02570523f, 
    0.00573264f, 0.01007523f, -0.03521717f, 0.00692162f, -0.00907765f, 0.00930952f, 0.02929349f, -0.03815632f, 
    0.02179873f, -0.03928915f, -0.02157701f, 0.00376915f, -0.02960778f, -0.03713917f, -0.00522450f, 0.00319397f, 
    -0.00718379f, -0.00661802f, 0.02143584f, -0.03556653f, 0.02425621f, 0.00440635f, 0.02127096f, 0.00265158f, 
    -0.01011212f, 0.02825576f, -0.02149696f, -0.00726382f, -0.00170190f, 0.02516355f, -0.02321681f, -0.04037932f, 
    -0.01344441f, -0.00064283f, 0.02251671f, -0.02451058f, 0.02007038f, -0.01258088f, -0.03409350f, -0.03783343f, 
    0.00799075f, -0.00378623f, -0.03975486f, 0.01949184f, -0.03947654f, 0.00664837f, 0.01738441f, 0.02333398f, 
    -0.02377245f, 0.00846117f, -0.02318537f, 0.02411028f, 0.01607168f, -0.00312034f, -0.00499087f, -0.02777076f, 
    0.02352983f, -0.01623193f, -0.02552464f, -0.03955755f, 0.02492393f, -0.00909191f, 0.01091905f, 0.02341853f, 
    -0.01132341f, 0.02241432f, -0.02222527f, -0.01723321f, 0.00805830f, 0.00632485f, -0.03686241f, -0.03413428f, 
    -0.03428226f, -0.01253814f, -0.03857443f, 0.00250593f, -0.03975151f, -0.00334027f, -0.00376223f, -0.02764586f, 
    0.02318819f, -0.03934937f, 0.01021587f, -0.01837565f, -0.01143672f, -0.01977251f, 0.00608677f, -0.00962575f, 
    0.00713876f, -0.03082263f, -0.00939458f, -0.02227443f, -0.02869074f, -0.02982835f, -0.01206966f, -0.03458835f, 
    0.00536961f, 0.00918745f, 0.01024514f, -0.03957079f, 0.00507366f, -0.02111244f, -0.01986432f, -0.03384418f, 
    -0.03890424f, -0.03431869f, 0.00636987f, -0.01104979f, -0.03556498f, 0.02659293f, -0.03050854f, -0.03268420f, 
    -0.02790689f, -0.02192882f, 0.00048601f, -0.04193844f, -0.02346902f, 0.00840778f, 0.01199548f, -0.03103131f, 
    -0.01180845f, 0.02210441f, -0.03280436f, -0.02377356f, -0.03670914f, -0.02891334f, -0.03413878f, -0.02138105f, 
    -0.01564335f, -0.02347602f, -0.02564340f, -0.01490183f, 0.00507219f, 0.02956637f, -0.03198991f, -0.01636321f, 
    -0.02588348f, 0.00973943f, -0.00663635f, 0.02650131f, 0.01009466f, 0.02373303f, -0.01792256f, 0.00669759f, 
    0.01933058f, -0.00576671f, 0.00235506f, -0.03741536f, -0.01543678f, -0.01941773f, 0.02256608f, 0.02349235f, 
    -0.02733698f, -0.01016891f, -0.03777226f, 0.02843776f, 0.02679915f, 0.01369945f, -0.00973233f, -0.03451748f, 
    0.01978320f, -0.03296578f, -0.03444494f, 0.02883271f, -0.00545382f, 0.02091529f, -0.01932249f, 0.00719048f, 
    0.02091785f, 0.02553702f, -0.02333177f, -0.01365851f, -0.02515686f, 0.01095106f, 0.01656759f, -0.02213226f, 
    -0.03412193f, -0.02574988f, 0.00198331f, 0.01268351f, -0.01639125f, -0.01738534f, -0.03009234f, -0.01626487f, 
    0.00838348f, -0.03308792f, -0.02877513f, 0.01998557f, 0.02610490f, -0.01060244f, 0.01710198f, 0.01549125f, 
    0.02505187f, 0.01372280f, 0.01101279f, -0.02480407f, -0.00695742f, -0.00763982f, 0.00111304f, -0.01953183f, 
    0.02519640f, -0.04197623f, -0.03012444f, -0.02024673f, -0.04104811f, -0.00757071f, -0.02566246f, -0.01024915f, 
    -0.02606663f, -0.03140494f, 0.02044522f, 0.00219312f, -0.00400351f, -0.00169135f, -0.00198545f, 0.00063510f, 
    0.01966567f, -0.00357644f, 0.00052767f, -0.01364666f, 0.00051940f, -0.02052478f, -0.02896746f, 0.00629876f, 
    -0.02298439f, 0.02606310f, -0.00948257f, -0.02645173f, 0.00142217f, 0.00569001f, 0.01129285f, -0.03922885f, 
    -0.01780624f, -0.02898433f, -0.00911769f, 0.00387847f, 0.01784742f, -0.01425778f, 0.01732121f, -0.03581109f, 
    -0.02093239f, 0.01353090f, 0.00363806f, 0.00398136f, 0.02924486f, 0.01656623f, 0.00386914f, -0.03133250f, 
    -0.01795940f, -0.00037130f, -0.01116466f, -0.03719159f, -0.04157333f, -0.00248494f, -0.03215623f, 0.01869414f, 
    -0.02081050f, -0.01059240f, -0.01458473f, 0.01227719f, -0.00828558f, -0.03863890f, 0.01432883f, 0.01094231f, 
    0.01956079f, -0.01900766f, -0.03696734f, 0.01097010f, -0.01049821f, -0.01586497f, 0.00577563f, 0.00019405f, 
    0.00763665f, 0.01990171f, 0.01166425f, -0.00009364f, 0.00916923f, 0.02207293f, 0.01260451f, -0.02774985f, 
    0.00026254f, -0.01952207f, 0.00905290f, 0.01312248f, -0.00425506f, 0.00270317f, -0.02565159f, 0.02049431f, 
    -0.02163285f, -0.02608719f, 0.02481986f, -0.00988536f, 0.00325690f, -0.01178726f, -0.01567956f, -0.00966059f, 
    0.01878817f, 0.01677781f, -0.01883933f, -0.04006547f, 0.02489567f, 0.00357413f, 0.00409596f, 0.02716893f, 
    0.00430370f, 0.02676774f, -0.03999156f, -0.03552650f, 0.00529929f, -0.03752533f, -0.03671113f, -0.00862884f, 
    0.00839401f, 0.02433451f, 0.00230630f, 0.02172679f, -0.00433737f, -0.01717992f, -0.02515774f, -0.02810317f, 
    0.02973330f, -0.00206276f, -0.01233552f, 0.02223201f, -0.03825263f, -0.03287746f, -0.02841191f, -0.03567671f, 
    -0.03561886f, -0.02067940f, -0.01492194f, -0.04034090f, -0.02908707f, -0.03888435f, 0.01850085f, -0.01749159f, 
    0.01581523f, -0.01947839f, 0.00197831f, 0.02235720f, -0.00239825f, 0.01852721f, 0.00495779f, 0.00564964f, 
    0.01524721f, -0.01829834f, -0.02014401f, 0.01457164f, -0.01338187f, 0.00932573f, -0.03327357f, -0.00268470f, 
    0.00198549f, 0.01203971f, 0.02901195f, -0.03418452f, -0.01700965f, -0.01835521f, -0.02128377f, 0.02703486f, 
    -0.03556484f, 0.02576951f, 0.02763448f, -0.03362941f, -0.01391374f, -0.03428460f, 0.01623195f, -0.01589225f, 
    -0.00340843f, -0.02037193f, 0.00248843f, -0.01790987f, 0.01779867f, -0.01515074f, -0.03446049f, 0.00798372f, 
    0.01973162f, 0.01162560f, -0.00346181f, 0.02634865f, -0.00374250f, 0.01004944f, -0.02353552f, -0.03601561f, 
    -0.00068798f, -0.01893642f, -0.02917637f, 0.02976810f, 0.01711432f, 0.02409175f, 0.01606515f, -0.01617751f, 
    -0.01022417f, -0.04068976f, -0.01169953f, -0.02997457f, 0.02224590f, -0.02635091f, -0.00684790f, 0.00126803f, 
    0.00909629f, -0.03636966f, -0.01936930f, 0.01561479f, -0.01445396f, 0.01171984f, 0.00347445f, -0.00098338f, 
    0.02314342f, -0.03569257f, -0.00452006f, -0.02151852f, -0.03486931f, 0.01908093f, 0.00999826f, 0.00403043f, 
    0.01602261f, -0.00117069f, 0.01398186f, 0.02742076f, 0.01980969f, 0.01057116f, -0.00679901f, 0.00979243f, 
    -0.00726478f, -0.01689243f, -0.02441602f, -0.03526852f, -0.01547595f, 0.01891877f, -0.03013374f, -0.01652479f, 
    -0.01475900f, -0.00062910f, -0.03659162f, -0.00744886f, -0.01274288f, -0.01063658f, 0.01515105f, -0.01464876f, 
    0.01687627f, 0.00126442f, -0.01443121f, 0.01751998f, 0.00171533f, 0.02452590f, 0.00569840f, -0.01260204f, 
    0.03216083f, -0.02389771f, 0.00772276f, 0.00673747f, -0.02913052f, 0.01645887f, 0.01989261f, 0.01054743f, 
    -0.00671758f, 0.01908540f, -0.00605677f, -0.01253804f, 0.02222463f, 0.01831837f, -0.00226663f, -0.01882748f, 
    -0.02322612f, 0.02875076f, -0.00105414f, 0.00248658f, 0.01623127f, 0.02427777f, -0.00908419f, 0.01706073f, 
    0.02926303f, -0.03807680f, 0.01461908f, -0.02551669f, -0.03047968f, 0.00774571f, 0.01237035f, -0.00410338f, 
    -0.00222149f, -0.00195006f, -0.02703493f, -0.03135263f, -0.03591240f, -0.03026946f, -0.02656187f, -0.03934895f, 
    -0.03880125f, -0.03572836f, -0.02176149f, 0.01402492f, -0.00955645f, 0.02636452f, -0.03798651f, -0.00458163f, 
    -0.02466848f, -0.00333320f, 0.01992795f, 0.01556380f, 0.00597555f, -0.01954466f, 0.02998641f, 0.02229032f, 
    -0.00545232f, 0.01153965f, -0.00216800f, -0.00345712f, -0.01832366f, -0.01849291f, -0.01428668f, -0.00637919f, 
    -0.00130370f, 0.00301721f, 0.02448591f, 0.00135406f, 0.01957845f, 0.00742976f, -0.01376354f, 0.01631660f, 
    0.01583255f, -0.01051925f, -0.01532469f, -0.03432846f, -0.01753184f, -0.01805534f, -0.00423340f, -0.02387828f, 
    0.01718575f, -0.03792593f, -0.03666829f, -0.02134848f, 0.02500680f, 0.02568118f, -0.00031087f, -0.03182825f, 
    0.00033598f, -0.02128374f, -0.01584498f, 0.02609920f, 0.00167051f, 0.01376993f, -0.01153846f, -0.03184549f, 
    -0.03322060f, 0.01861869f, -0.00405526f, 0.00670687f, 0.01744424f, -0.04041365f, 0.00938711f, -0.01434598f, 
    0.02978181f, -0.02812817f, 0.00737416f, -0.00548553f, -0.03185897f, -0.02589776f, 0.01200405f, -0.02719187f, 
    -0.04202890f, -0.02076605f, 0.02622021f, -0.00982424f, 0.01928163f, 0.01658557f, 0.02656378f, -0.00477442f, 
    -0.00973141f, -0.03280208f, -0.02792703f, 0.01200267f, -0.03738229f, -0.02946773f, -0.03981135f, -0.00947932f, 
    -0.00829262f, -0.03761213f, -0.02105264f, 0.01801394f, -0.04141626f, -0.00020986f, -0.02597533f, -0.01237637f, 
    0.01959031f, -0.00215827f, -0.01619856f, 0.01192463f, -0.02798610f, 0.02850444f, -0.00637178f, -0.00750218f, 
    -0.02821004f, 0.02777210f, 0.02014312f, 0.02479256f, 0.02393216f, -0.03850246f, 0.01838765f, -0.03150892f, 
    0.02257074f, -0.03946786f, 0.01832004f, -0.02253013f, -0.03451300f, 0.02385918f, -0.03889692f, -0.03272449f, 
    -0.01955373f, 0.00766368f, 0.01029736f, -0.02826072f, 0.00041813f, -0.02081548f, 0.02350352f, 0.00958484f, 
    0.01026297f, -0.03131208f, 0.00032017f, 0.02428602f, 0.00902271f, -0.03482954f, -0.00785747f, -0.00999608f, 
    -0.00441486f, -0.02171066f, -0.00268866f, -0.03270580f, -0.03079733f, -0.02369902f, -0.00984707f, -0.00682544f, 
    0.01569382f, 0.01498448f, 0.01404080f, -0.00302616f, -0.00518319f, 0.02562989f, 0.02295754f, -0.01199504f, 
    -0.03054012f, -0.00735860f, -0.00958166f, 0.02658073f, -0.01029470f, -0.01455437f, -0.00093715f, 0.02381568f, 
    0.00304471f, -0.01097951f, -0.03153768f, -0.04106772f, -0.00233614f, 0.00984395f, -0.02460221f, 0.00009651f, 
    -0.01128580f, -0.04143284f, 0.02090967f, -0.00125466f, -0.03706526f, 0.02928108f, -0.00428338f, 0.00234444f, 
    0.02198441f, 0.01284639f, -0.00960247f, 0.00227954f, -0.01581064f, 0.00867054f, -0.01168156f, -0.02453424f, 
    -0.00742812f, 0.01732516f, -0.01082320f, -0.03063489f, 0.02155458f, -0.00007593f, -0.02473957f, -0.03794822f, 
    -0.03233882f, 0.01761595f, -0.00797984f, -0.01336859f, -0.01455764f, -0.01613357f, -0.03082177f, 0.01426881f, 
    0.02435485f, 0.01300824f, -0.00627795f, 0.00698999f, 0.01906777f, 0.00774356f, 0.00290365f, -0.04141403f, 
    -0.03585378f, -0.01482234f, -0.01191872f, -0.02955384f, -0.00106609f, -0.01808835f, 0.02682036f, -0.01429608f, 
    -0.00577497f, -0.00230524f, -0.00150829f, -0.01947703f, -0.01772297f, -0.01628183f, -0.01383080f, 0.00162616f, 
    0.00685646f, -0.01502439f, -0.01750685f, -0.02875105f, -0.00474784f, 0.02099483f, -0.02240199f, -0.02181887f, 
    -0.02917062f, 0.01151936f, 0.02859142f, -0.00706250f, -0.00698852f, -0.01892687f, -0.03825292f, -0.02151220f, 
    -0.01841662f, 0.01312369f, -0.03451126f, -0.00008515f, -0.00407001f, 0.01658817f, 0.02307630f, -0.00047598f, 
    -0.03672250f, 0.02980142f, -0.02381274f, 0.02929240f, 0.00018221f, -0.02253782f, -0.02196048f, -0.00395748f, 
    0.01343377f, 0.02725627f, -0.03853981f, -0.03214817f, 0.02116440f, -0.02587375f, -0.01860791f, -0.01059490f, 
    -0.01316485f, -0.01038129f, -0.01431239f, -0.00455981f, -0.02632735f, 0.02895069f, -0.03094945f, -0.02148350f, 
    0.00941662f, -0.02062610f, -0.02371760f, 0.00999120f, 0.00506915f, 0.02079985f, -0.01041822f, -0.02119379f, 
    0.00821454f, -0.03667376f, 0.00930722f, 0.00310399f, -0.01956702f, -0.04003673f, -0.01557431f, -0.00000788f, 
    -0.02293074f, 0.01180286f, 0.01019899f, -0.02730821f, -0.00458262f, 0.01863801f, 0.02370429f, 0.02791046f, 
    -0.02091770f, 0.00143924f, -0.00535156f, -0.01967528f, 0.01574005f, -0.02813308f, -0.00419299f, -0.01065695f, 
    0.03058096f, -0.00842859f, 0.02258726f, -0.00175204f, -0.01218104f, 0.00971622f, -0.02186024f, -0.04086142f, 
    -0.03326340f, 0.01283858f, -0.02942991f, -0.02122879f, 0.02356203f, -0.00357025f, -0.03136214f, 0.02809841f, 
    -0.04038262f, 0.00492579f, -0.01572333f, -0.01115099f, -0.03237334f, -0.00371673f, 0.00921009f, -0.00356698f, 
    0.02648463f, -0.00105797f, 0.02491145f, 0.00137637f, 0.01052571f, 0.01392699f, -0.00537448f, -0.00619662f, 
    0.01937499f, 0.01914239f, 0.02822299f, -0.00243859f, -0.01019825f, -0.02928426f, -0.02224728f, -0.03102440f, 
    -0.02514576f, 0.01518261f, -0.03709206f, -0.03983458f, -0.00810690f, 0.00484806f, -0.00711766f, -0.03610436f, 
    0.02886625f, 0.01385320f, -0.00808840f, 0.01278186f, -0.04132881f, -0.00301909f, 0.01015034f, 0.01621981f, 
    0.01369134f, -0.01746519f, -0.02834766f, -0.02676745f, 0.00346005f, -0.01597262f, 0.00626179f, 0.00954638f, 
    -0.03785249f, 0.01392388f, -0.01692123f, 0.01453779f, -0.01874997f, -0.02797409f, 0.00717923f, -0.02256276f, 
    -0.03684376f, -0.00323936f, -0.03132651f, -0.02341424f, -0.02046314f, 0.02607172f, -0.01650178f, -0.02623930f, 
    -0.00713615f, 0.01577822f, 0.01223905f, 0.01327596f, -0.00171385f, -0.01657749f, -0.00029016f, -0.03252095f, 
    0.00830933f, -0.00330314f, 0.02336314f, 0.02235635f, 0.00880373f, -0.02438392f, -0.00658561f, 0.00230602f, 
    -0.00654482f, 0.00690903f, -0.02682860f, -0.00673012f, -0.01046484f, -0.00138198f, 0.00411439f, -0.02043113f, 
    0.00563582f, -0.02404660f, -0.00516011f, -0.01505061f, -0.00658071f, 0.03006466f, -0.00926841f, 0.00740283f, 
    -0.00911011f, 0.02185252f, -0.01949787f, -0.01799339f, -0.01870200f, -0.01824176f, 0.00764839f, 0.02367100f, 
    0.01010501f, -0.01841704f, 0.00311660f, -0.02031987f, -0.02246015f, 0.02914889f, 0.02211746f, 0.01641064f, 
    -0.03547161f, -0.00605973f, -0.01691327f, 0.01570871f, 0.01041208f, 0.02945367f, 0.02147819f, 0.00016004f, 
    0.02788461f, -0.03396331f, -0.02623446f, -0.01642159f, 0.02735393f, -0.01481051f, -0.03088672f, -0.02640602f, 
    0.00382910f, -0.00425074f, -0.00149310f, -0.02073718f, -0.02572235f, -0.00498973f, 0.02264582f, -0.00803324f, 
    -0.02969393f, -0.02457767f, -0.03938920f, 0.00755320f, -0.01252151f, -0.00685768f, -0.02866008f, 0.02060090f, 
    -0.03603164f, 0.01787722f, -0.00961896f, -0.00324786f, 0.01948690f, 0.00402300f, -0.00924752f, 0.01068655f, 
    -0.02541001f, 0.02811948f, 0.02578388f, -0.00811053f, -0.00202863f, 0.02441771f, 0.01318728f, -0.03216950f, 
    -0.00390349f, -0.02844757f, -0.03136366f, -0.03374387f, -0.03013449f, -0.01133285f, 0.02998429f, -0.01936526f, 
    0.01169337f, -0.01303084f, 0.00852876f, 0.01423228f, -0.03819963f, 0.02822189f, 0.01323394f, 0.02539320f, 
    0.00762748f, -0.01580431f, 0.02394925f, 0.00620790f, -0.02411532f, -0.04070919f, 0.01568302f, -0.00668728f, 
    0.00296865f, -0.02399343f, -0.00718263f, 0.00983220f, -0.03501875f, -0.00720024f, 0.00303040f, -0.02592116f, 
    -0.01612915f, -0.03719758f, 0.00563049f, -0.00529139f, -0.04136742f, 0.02297768f, -0.01262713f, -0.03136930f, 
    0.02678963f, -0.01791329f, 0.02509836f, -0.01460669f, -0.00441331f, -0.02395198f, -0.00746298f, -0.02625657f, 
    -0.04100767f, -0.00721325f, -0.00919259f, 0.00594830f, -0.03669735f, 0.02052187f, -0.02356785f, 0.02993367f, 
    0.02595470f, 0.00327526f, -0.02461736f, -0.01003051f, -0.00794642f, 0.00004114f, -0.03536833f, -0.01200190f, 
    -0.01895254f, -0.01813859f, 0.00526098f, 0.02626988f, -0.04020057f, 0.01501213f, -0.03099067f, 0.02103630f, 
    -0.03750841f, -0.03916712f, -0.01669415f, 0.01617997f, 0.02543369f, 0.02031563f, 0.02235722f, -0.01172760f, 
    0.02176013f, 0.00117890f, 0.01043622f, -0.00241200f, -0.00543268f, -0.00897060f, -0.02971003f, -0.02758617f, 
    0.02777046f, 0.01065365f, -0.03003116f, 0.02528664f, -0.02900794f, -0.01164186f, -0.02806428f, -0.02496704f, 
    -0.00476520f, -0.03109432f, 0.00405316f, -0.00634900f, -0.02982802f, -0.00587020f, 0.02442915f, -0.00713396f, 
    0.02284344f, 0.01744242f, -0.00115785f, -0.00868615f, 0.01385168f, -0.00632674f, 0.01172422f, -0.03751853f, 
    0.01615794f, -0.03208374f, 0.02460293f, -0.02099456f, 0.00787761f, -0.01427613f, 0.01787508f, 0.02564385f, 
    -0.01168055f, -0.03057380f, -0.04187353f, -0.01123485f, 0.02559118f, -0.00243754f, -0.00617960f, -0.01141587f, 
    -0.00036254f, -0.02049778f, -0.03728313f, -0.01650900f, 0.02008031f, -0.03530528f, 0.01226260f, 0.00567644f, 
    -0.01774434f, -0.01941141f, 0.02498328f, -0.01469660f, -0.00105410f, -0.00834641f, -0.04021372f, 0.01611021f, 
    0.01071913f, 0.01405700f, 0.01328050f, -0.01749039f, 0.01046676f, -0.02906245f, -0.01107407f, 0.02660656f, 
    -0.03134551f, -0.00577045f, -0.02910785f, 0.02727190f, -0.00776136f, 0.00286411f, -0.03537653f, 0.00129926f, 
    0.01030763f, 0.02323841f, 0.02191286f, -0.00075676f, -0.02401029f, 0.00506361f, 0.00679853f, -0.02483976f, 
    -0.00067917f, -0.03629856f, -0.02190535f, -0.03252326f, -0.02261068f, -0.03235802f, -0.00823495f, 0.02104763f, 
    0.01916417f, -0.02196619f, -0.00970397f, -0.02155322f, -0.00897241f, 0.02974650f, -0.02151185f, -0.02980191f, 
    -0.03619445f, 0.02588551f, 0.01945001f, 0.01508752f, -0.02846785f, 0.00303304f, -0.03502375f, -0.02544411f, 
    -0.02794361f, -0.01843240f, -0.03137942f, -0.00326433f, -0.01724113f, -0.00582462f, -0.04009514f, -0.01602090f, 
    -0.03905220f, -0.00428158f, -0.02513998f, -0.01704793f, -0.03174236f, -0.03802354f, 0.02473744f, 0.00477353f, 
    0.00723585f, -0.00019952f, -0.03088941f, 0.00569032f, 0.01520629f, -0.03557476f, 0.00375647f, -0.02333851f, 
    -0.01939408f, 0.00744967f, 0.00578050f, 0.01531925f, 0.00649796f, -0.00674478f, -0.02614343f, -0.01386937f, 
    -0.03300940f, 0.01656157f, -0.01370379f, -0.02710775f, 0.00518510f, -0.03856324f, -0.04072781f, 0.01742301f, 
    0.01297120f, -0.01206308f, -0.03608974f, 0.00401196f, -0.02464258f, 0.01384126f, 0.01900679f, 0.02382116f, 
    0.01585147f, -0.01832561f, -0.03791369f, 0.02520561f, 0.01750544f, -0.01377016f, -0.02735499f, 0.02884489f, 
    -0.02299389f, -0.02420982f, -0.03790636f, -0.02547153f, 0.00965079f, -0.03448271f, -0.03994067f, 0.01074147f, 
    -0.00826204f, 0.00177206f, -0.03178174f, -0.03880140f, -0.03778961f, 0.00122859f, -0.04012622f, 0.01699128f, 
    0.00031698f, -0.01639883f, 0.02267937f, -0.03844858f, -0.02311552f, 0.00202757f, -0.03758110f, 0.01403358f, 
    0.02432921f, -0.00513946f, 0.01656842f, 0.00999092f, 0.02666064f, 0.01466008f, -0.00746712f, 0.01438056f, 
    -0.03363795f, -0.01017222f, 0.00699804f, -0.00622233f, -0.00306297f, 0.02743755f, -0.00410789f, -0.03553702f, 
    -0.02667974f, -0.00693793f, -0.01671650f, -0.03243075f, 0.00167238f, 0.00035812f, 0.02817140f, -0.02789792f, 
    -0.00672348f, 0.02823870f, 0.00677522f, 0.02293593f, -0.03665920f, -0.02501632f, -0.03041497f, -0.03726556f, 
    0.02970020f, -0.02623517f, 0.00870747f, -0.01300865f, -0.01389904f, 0.00422943f, 0.02675455f, -0.01629721f, 
    0.00556420f, -0.02580588f, -0.03313778f, 0.00357607f, 0.01624798f, -0.02511244f, -0.00422734f, 0.01999890f, 
    -0.03123521f, 0.01385120f, -0.02993048f, -0.00393899f, 0.02287031f, 0.00538472f, 0.01423489f, -0.02026573f, 
    -0.02464878f, 0.00302629f, -0.04196863f, -0.01695456f, -0.00333087f, -0.02322317f, -0.01830105f, -0.02370205f, 
    -0.02327388f, -0.01354443f, 0.00125248f, 0.01012339f, 0.00869393f, 0.01734095f, -0.02366798f, -0.00799832f, 
    -0.00445235f, -0.01658225f, -0.00505055f, -0.00364258f, -0.02528839f, -0.01840104f, 0.00076814f, -0.04204667f, 
    -0.02821565f, -0.00358645f, -0.01033911f, 0.01240876f, 0.00955462f, -0.00360081f, 0.01411627f, -0.03458532f, 
    0.00938311f, 0.00712081f, -0.04007821f, 0.00683166f, 0.00875377f, -0.03695736f, -0.01829151f, -0.00610942f, 
    0.01050365f, -0.00817618f, -0.02229545f, -0.02725626f, -0.02277431f, -0.02260647f, -0.00374611f, 0.02086251f, 
    0.01688651f, -0.01506627f, -0.00988896f, -0.02449146f, -0.02889837f, -0.03136308f, -0.03989191f, -0.02359804f, 
    -0.00473457f, -0.00300789f, 0.00417942f, 0.00308556f, -0.00548975f, -0.00703886f, 0.01752990f, -0.02880462f, 
    -0.00075830f, -0.02331738f, -0.00538796f, -0.00919199f, -0.02938023f, -0.01175791f, -0.03945953f, 0.00218794f, 
    0.01382015f, -0.03192008f, -0.03069475f, 0.01582029f, 0.00111473f, 0.02080570f, -0.00582700f, -0.03841884f, 
    -0.01702384f, -0.02237140f, 0.01810754f, -0.02030544f, 0.02071403f, 0.00350134f, -0.01160812f, 0.02002585f, 
    0.02577899f, 0.00899852f, -0.02309412f, -0.02929859f, 0.00422212f, 0.00517861f, -0.02218925f, 0.01196610f, 
    -0.00130243f, -0.02840788f, -0.01999564f, 0.00061934f, -0.00919047f, -0.01457445f, -0.00148546f, 0.01723377f, 
    -0.03302248f, -0.01544290f, 0.01416633f, 0.00012291f, -0.02296068f, -0.01194784f, 0.02025894f, 0.02594450f, 
    -0.01831067f, -0.02852041f, 0.00686985f, 0.00435569f, -0.03204242f, 0.00688518f, -0.02498838f, -0.00966848f, 
    -0.02453731f, -0.00244965f, 0.00233071f, -0.02758088f, -0.03929885f, -0.00276962f, 0.02668674f, -0.01416238f, 
    -0.03105157f, 0.00027057f, 0.00082736f, -0.00846474f, -0.01955278f, -0.01802518f, -0.00026221f, -0.01118880f, 
    -0.00760357f, 0.00047206f, -0.01653128f, -0.00173054f, -0.02313637f, -0.00805794f, 0.01571816f, -0.00985172f, 
    0.01492010f, -0.01832886f, 0.00115520f, -0.03022672f, -0.02540878f, 0.00889004f, -0.01388472f, -0.02281602f, 
    -0.02948180f, -0.00846673f, -0.02411202f, 0.00061226f, 0.02423614f, -0.02321326f, 0.02611357f, 0.00877452f, 
    -0.02886147f, -0.03343773f, 0.00916466f, -0.01891423f, 0.02948924f, 0.01243223f, -0.03811788f, 0.02224768f, 
    -0.04021661f, 0.00535837f, -0.01958440f, -0.00190442f, -0.01143584f, -0.03370295f, 0.02365717f, -0.03207117f, 
    0.02689457f, -0.00624823f, 0.00114830f, -0.01061488f, -0.02417749f, -0.00115236f, 0.00590422f, 0.02492252f, 
    0.00400053f, 0.01369144f, 0.02141901f, -0.00715918f, 0.01894240f, -0.00285383f, -0.02644295f, 0.00056013f, 
    0.00692931f, -0.03418265f, -0.02440691f, 0.02377451f, 0.00394497f, -0.02832511f, 0.00368601f, -0.03769654f, 
    -0.01572155f, 0.01883888f, -0.04019225f, -0.01949909f, 0.00198648f, 0.00322553f, -0.01423498f, 0.02608400f, 
    -0.02643766f, 0.00146732f, -0.00942714f, -0.02364268f, -0.02275258f, -0.00386949f, 0.00842719f, 0.02672757f, 
    -0.01944024f, -0.00196400f, 0.02477711f, -0.02896541f, -0.01171492f, -0.03738043f, -0.00266317f, 0.02833245f, 
    -0.02310232f, -0.00866158f, 0.00170644f, 0.00764608f, -0.00037360f, -0.01278715f, -0.03049447f, 0.00518056f, 
    -0.01107584f, -0.03198797f, 0.00392872f, 0.00595143f, 0.02214637f, -0.02372726f, 0.01755643f, -0.04556558f, 
    0.01031301f, -0.03963590f, -0.02471385f, 0.01776539f, 0.01148907f, 0.03962225f, 0.01551978f, 0.02348203f, 
    0.01256205f, -0.03903001f, -0.03760535f, 0.00519198f, -0.01676214f, -0.04145275f, -0.03308910f, 0.02837341f, 
    0.01502158f, -0.01893986f, -0.00222680f, 0.02576701f, 0.02591779f, 0.02703082f, 0.01917436f, 0.02695700f, 
    0.01855114f, -0.00855787f, 0.02259737f, 0.03365804f, -0.02584218f, -0.01915763f, -0.00859752f, 0.03056115f, 
    0.00704016f, -0.01894279f, 0.00671188f, 0.00517951f, 0.01111509f, -0.03820185f, -0.00851991f, 0.02038835f, 
    -0.02143978f, -0.02570134f, 0.04353518f, -0.02502798f, -0.00790878f, -0.03853920f, -0.01695377f, 0.02400362f, 
    0.02409997f, 0.02454817f, -0.01219226f, 0.01901629f, -0.00538260f, -0.00239231f, 0.00820296f, -0.02536490f, 
    -0.02992215f, -0.03609158f, -0.00074314f, -0.01268814f, 0.01098986f, -0.02689136f, -0.02624083f, -0.01590916f, 
    -0.01328554f, -0.02290829f, 0.03735312f, -0.01203796f, -0.01109973f, 0.00540721f, -0.03167205f, -0.00771450f, 
    -0.03240819f, -0.01381007f, 0.00841797f, -0.00603371f, -0.00473948f, 0.01948670f, 0.02812175f, -0.01448486f, 
    -0.00169051f, 0.02186278f, -0.00329047f, 0.00394603f, 0.00470593f, 0.00736247f, 0.02458144f, -0.01797478f, 
    0.00758403f, -0.01798323f, -0.01546415f, -0.01500875f, -0.03239787f, -0.03678609f, -0.00918926f, -0.01912304f, 
    0.02949906f, 0.02099354f, 0.00339256f, 0.03228061f, 0.01288335f, 0.01682017f, 0.00904695f, -0.01990103f, 
    0.01145475f, 0.02952803f, -0.03014570f, 0.02128257f, 0.00847954f, -0.03614359f, 0.02748569f, -0.02825714f, 
    -0.01414123f, -0.02559645f, 0.00939178f, -0.03082779f, 0.01186299f, -0.02863405f, -0.02950501f, -0.00500630f, 
    0.01000323f, 0.02162293f, -0.00895721f, 0.01886268f, 0.01789964f, 0.00897218f, 0.01833205f, 0.03379569f, 
    -0.03646631f, -0.02602007f, 0.01547067f, 0.01395455f, -0.00049646f, -0.04610521f, 0.01306306f, 0.00798287f, 
    -0.03211253f, 0.01660092f, -0.02309527f, -0.01281114f, -0.04208086f, 0.00631446f, 0.02254427f, -0.03576039f, 
    -0.04273498f, 0.02311514f, -0.04356826f, -0.03194633f, -0.00635830f, 0.00323177f, -0.01993971f, 0.01590470f, 
    -0.00452303f, -0.00081622f, 0.03397805f, 0.01555850f, -0.02077459f, -0.00064929f, 0.00316798f, 0.01321078f, 
    0.03598492f, -0.03310008f, -0.03422064f, -0.01071712f, -0.01457434f, -0.00321534f, -0.02726335f, 0.02303170f, 
    -0.03626824f, -0.02194168f, -0.00165313f, 0.00042674f, 0.04660937f, 0.02889918f, 0.00163095f, -0.01801427f, 
    0.03998372f, 0.02358194f, 0.03885045f, -0.03007735f, -0.00016896f, -0.02909907f, -0.03644456f, -0.03381389f, 
    -0.00564859f, -0.01679223f, 0.00460548f, 0.00692729f, 0.01954409f, -0.03439664f, 0.00170040f, -0.01084722f, 
    0.00097744f, -0.01429330f, 0.02072428f, -0.00353313f, -0.03851888f, 0.02639635f, -0.00755688f, -0.04061688f, 
    0.01030240f, -0.01288406f, -0.03662214f, -0.01490705f, -0.01063535f, 0.02448254f, -0.03512019f, -0.01240752f, 
    0.02039503f, 0.02664038f, 0.00060160f, -0.00247763f, 0.02688063f, -0.00765931f, -0.04082747f, -0.00675465f, 
    -0.02579337f, 0.00916488f, -0.00625221f, -0.01316860f, 0.00517230f, 0.02715208f, -0.00494707f, -0.01846494f, 
    -0.03792004f, 0.02333227f, 0.02147798f, -0.02557946f, -0.01070482f, -0.02062762f, -0.02034838f, 0.01017792f, 
    -0.00385004f, -0.02535484f, 0.00413077f, 0.01964631f, 0.00877368f, -0.01572335f, -0.03574235f, 0.02469312f, 
    -0.00810301f, -0.00845295f, 0.00273688f, 0.01405805f, -0.01705219f, -0.02275145f, -0.00054594f, 0.00992551f, 
    -0.02041590f, 0.02629332f, 0.02887668f, -0.02089672f, 0.00101568f, -0.02119582f, 0.01422234f, -0.01484182f, 
    -0.00034399f, 0.00022701f, 0.00585085f, -0.00582692f, -0.00839083f, 0.02554029f, 0.01583197f, 0.01626399f, 
    -0.01026285f, 0.00327940f, 0.02934612f, 0.01712375f, 0.01092197f, 0.00317702f, -0.02607366f, 0.00652360f, 
    0.00965373f, -0.03822006f, -0.03479577f, -0.01648039f, -0.02322017f, -0.02727921f, -0.01547125f, -0.00318481f, 
    0.02047592f, -0.01330226f, -0.00576226f, -0.03754618f, -0.02503876f, -0.00708159f, 0.01755724f, 0.02104132f, 
    -0.02494980f, -0.02814490f, -0.03174817f, 0.00628460f, -0.01152004f, -0.00175458f, 0.01056079f, 0.02668565f, 
    -0.02439237f, -0.03068088f, -0.00481149f, -0.03367786f, -0.02086639f, 0.00224532f, -0.01319123f, -0.01147049f, 
    0.00726668f, 0.00523281f, 0.02024517f, -0.01814077f, 0.02242134f, 0.00101712f, -0.03278809f, -0.01543109f, 
    0.00617467f, 0.01320456f, -0.00028980f, -0.01050065f, -0.01142942f, 0.01820979f, -0.03015037f, -0.01229792f, 
    -0.00142451f, -0.02598222f, -0.03435089f, 0.00318508f, -0.01883820f, 0.01449245f, -0.01351289f, -0.00089432f, 
    0.01270668f, 0.03164393f, 0.02485211f, -0.03349637f, -0.03423871f, 0.01657818f, -0.01280252f, 0.03123728f, 
    0.02547985f, -0.02921807f, -0.00945389f, -0.02920759f, -0.03294316f, -0.00040182f, 0.01274495f, -0.00026156f, 
    0.02465910f, -0.00201063f, -0.03165304f, -0.03065637f, -0.03271605f, 0.02900724f, -0.02441833f, -0.01171525f, 
    -0.01456125f, 0.03276619f, -0.01596859f, 0.02988238f, -0.01218614f, -0.00153787f, 0.02691866f, 0.00826546f, 
    -0.01407967f, 0.02092886f, -0.01208838f, -0.00123713f, -0.01957594f, -0.00963713f, 0.00086694f, -0.00878008f, 
    -0.02395571f, 0.03147520f, 0.01399285f, -0.01679147f, -0.00731493f, 0.02037508f, 0.02990231f, -0.03782845f, 
    -0.01047057f, -0.02054893f, 0.02791267f, 0.02250772f, 0.00731116f, -0.01562834f, -0.00215071f, -0.02638641f, 
    0.00083827f, 0.01744949f, -0.02722483f, 0.03030883f, -0.01342297f, -0.01840476f, 0.01906450f, -0.00004990f, 
    -0.00225252f, -0.00308930f, -0.00150975f, -0.01191129f, -0.03582533f, -0.01256260f, 0.04352809f, 0.02427669f, 
    0.02873203f, -0.02353347f, 0.00681562f, 0.03366416f, 0.02923211f, -0.00464558f, 0.00169127f, 0.01852124f, 
    -0.01208616f, -0.01853273f, -0.02203941f, -0.03757073f, -0.01609475f, -0.00162494f, 0.00074212f, -0.00227807f, 
    -0.00166558f, -0.02769767f, 0.00946552f, 0.02381521f, -0.00758008f, -0.04511523f, -0.00997498f, -0.04247114f, 
    -0.02890331f, 0.00353122f, -0.00207504f, 0.02306432f, -0.02409450f, -0.02525896f, -0.02403671f, 0.02473276f, 
    -0.00871959f, 0.01475670f, 0.02015308f, -0.00366412f, -0.02642049f, -0.00256218f, 0.02394527f, -0.01376556f, 
    -0.01455057f, -0.02234379f, -0.02265674f, -0.01431167f, -0.04732423f, 0.00373584f, 0.00082283f, 0.00933217f, 
    0.03143863f, 0.02593599f, -0.00997894f, -0.01335809f, 0.01955619f, 0.01686520f, 0.00626350f, -0.02255655f, 
    0.01385398f, -0.03385697f, 0.01047151f, 0.02186383f, -0.00633392f, -0.03557994f, 0.02801717f, 0.02172465f, 
    -0.02220504f, 0.02409604f, 0.02367521f, 0.00377596f, 0.00344776f, -0.02286244f, 0.01234102f, 0.00241751f, 
    -0.01633395f, -0.00731931f, 0.00588138f, -0.00839822f, 0.00734010f, -0.00181329f, 0.01434516f, 0.02963106f, 
    -0.02344222f, 0.01732616f, 0.01539122f, -0.00045087f, 0.00092230f, -0.04015038f, 0.01296359f, 0.03958765f, 
    -0.03400899f, 0.00311473f, -0.02844731f, 0.00785545f, -0.02260249f, -0.01366269f, 0.01071391f, -0.03551034f, 
    -0.00467332f, 0.01384729f, -0.00569764f, -0.00106382f, -0.00174392f, -0.00536481f, -0.01936254f, -0.03099229f, 
    0.02180334f, 0.02135418f, 0.01837643f, 0.00292052f, 0.02615252f, 0.00703673f, 0.00505927f, 0.01955890f, 
    0.01117701f, -0.03517439f, -0.02896496f, -0.00060134f, -0.00748205f, -0.00881474f, -0.03559725f, -0.01013594f, 
    -0.00524045f, -0.02859885f, -0.00715139f, 0.02347804f, -0.00452023f, -0.01075139f, -0.04174295f, -0.02167339f, 
    -0.01269241f, 0.00139959f, -0.03791652f, -0.01839328f, -0.01135628f, -0.02668710f, 0.00066892f, -0.00191129f, 
    -0.00696955f, 0.00299005f, -0.04128451f, -0.02781909f, 0.00676478f, 0.03455603f, 0.01025426f, -0.02037041f, 
    0.02099774f, 0.00762773f, 0.03504723f, 0.02146953f, 0.01245624f, -0.03692862f, 0.02072565f, 0.00595301f, 
    0.03249091f, -0.00915785f, -0.02818765f, -0.03097307f, -0.03417172f, -0.01257585f, 0.00858809f, -0.01888716f, 
    0.00963686f, -0.02652297f, -0.01957970f, 0.02641372f, -0.00708457f, -0.04474736f, 0.00977347f, 0.00927175f, 
    -0.03798122f, -0.02328227f, -0.02058770f, 0.00126941f, -0.00579309f, -0.02176423f, 0.02939459f, 0.00450210f, 
    -0.01888682f, 0.00589944f, -0.01867769f, -0.01825765f, 0.02506233f, 0.01182026f, 0.02891269f, -0.02958499f, 
    -0.01486417f, -0.03457237f, 0.00556821f, -0.03179963f, 0.01064158f, -0.02257983f, -0.00247164f, -0.00025853f, 
    0.01098471f, -0.02304912f, 0.04189644f, 0.02458123f, 0.01787252f, -0.04069944f, 0.01340858f, -0.02565194f, 
    -0.01705317f, -0.02988196f, -0.03448483f, 0.01412123f, -0.00350782f, 0.01509749f, 0.01881135f, -0.02256968f, 
    0.00102219f, 0.03305947f, 0.01116688f, 0.00507252f, -0.04342103f, -0.00956338f, -0.02164488f, -0.03153618f, 
    0.00338584f, -0.01391036f, -0.03644178f, -0.00767683f, -0.02366913f, -0.01717811f, -0.03722118f, -0.04127080f, 
    -0.02077884f, -0.00595154f, -0.00595310f, -0.01690910f, -0.01395492f, 0.00695081f, -0.00984204f, 0.00502543f, 
    -0.01730892f, -0.03263170f, 0.01218066f, -0.00875782f, 0.01335361f, -0.00949759f, -0.01630114f, -0.02702263f, 
    0.00581000f, 0.00949263f, -0.02019867f, -0.02295950f, 0.03355259f, 0.02025989f, -0.01393761f, -0.01096619f, 
    -0.03762936f, 0.00630653f, -0.02119136f, -0.02179888f, 0.02810406f, 0.03164851f, -0.01238702f, -0.03599215f, 
    -0.01218612f, -0.00844791f, -0.01951328f, 0.01148513f, -0.02195960f, -0.04986408f, -0.04256217f, -0.00786653f, 
    0.00616566f, -0.03631281f, 0.00443578f, -0.00114033f, -0.01804731f, 0.03331795f, -0.02301329f, -0.00818928f, 
    -0.03081280f, 0.01417141f, 0.02933342f, 0.03214848f, 0.03392702f, 0.02815870f, -0.00756110f, -0.04428975f, 
    0.02160889f, -0.00164408f, 0.02850085f, 0.01387375f, -0.01926364f, 0.01312933f, 0.00432437f, -0.00084858f, 
    -0.01623913f, -0.00000395f, -0.01050613f, 0.02075375f, -0.03263514f, -0.00518639f, -0.01827592f, 0.01369719f, 
    -0.02890433f, -0.04368683f, 0.00891370f, 0.00766607f, -0.01887636f, -0.01149054f, 0.02139836f, 0.01973368f, 
    -0.03095372f, 0.02191420f, -0.02026922f, 0.00744672f, -0.00683504f, 0.00106627f, -0.03456683f, 0.03219096f, 
    -0.00496862f, -0.00758481f, 0.03050160f, -0.03783223f, 0.01584315f, -0.02289264f, 0.04684325f, 0.00806199f, 
    0.00333645f, -0.01902226f, 0.01278017f, 0.03221228f, -0.02533930f, -0.03221944f, 0.01553260f, 0.02424497f, 
    0.01692711f, 0.00682089f, 0.03502233f, 0.00763137f, 0.02677510f, -0.01786875f, 0.00894723f, -0.03939848f, 
    -0.02306587f, -0.01442018f, -0.02706667f, -0.01249593f, -0.00495269f, 0.01843305f, -0.01513504f, -0.00275098f, 
    -0.02206287f, -0.02967284f, -0.02110621f, -0.00711651f, -0.03432271f, -0.01282423f, -0.03631629f, -0.02185783f, 
    0.01464469f, 0.00442472f, 0.03192097f, -0.01307464f, 0.00687510f, -0.03936184f, 0.02697087f, -0.04067778f, 
    -0.02820667f, -0.02404092f, -0.01233322f, 0.01895885f, 0.02550064f, -0.01568095f, -0.00601941f, -0.03068419f, 
    0.02961135f, -0.02999095f, 0.02706188f, -0.01441390f, -0.02337564f, -0.01123394f, -0.00288039f, 0.01199431f, 
    0.02103725f, 0.00491639f, -0.01105970f, -0.03404566f, 0.00934304f, -0.02412525f, -0.01407845f, 0.01912483f, 
    -0.03203208f, -0.00223041f, 0.01900945f, 0.03615672f, 0.02254364f, -0.03899979f, 0.01671943f, -0.00230195f, 
    -0.00849184f, -0.02320627f, -0.01805254f, -0.00501134f, -0.02098809f, 0.01963674f, 0.01760926f, 0.02168134f, 
    0.00144649f, -0.01564544f, 0.00609843f, 0.00332876f, 0.02815840f, -0.01518046f, 0.01673261f, -0.03229828f, 
    0.02849820f, -0.03630698f, -0.00148865f, -0.02096028f, -0.03609314f, 0.00210894f, -0.00363707f, -0.01076575f, 
    -0.03419773f, -0.02606277f, -0.03706581f, -0.02832168f, -0.04065750f, -0.01806625f, -0.03832516f, 0.02691156f, 
    -0.00692923f, -0.00256465f, -0.03894509f, -0.03354668f, -0.03123685f, -0.01116796f, -0.01452417f, -0.03688472f, 
    0.02445058f, -0.03083469f, -0.02817047f, -0.00888815f, -0.01006341f, -0.00929186f, -0.01943714f, 0.02178987f, 
    0.00256945f, 0.01293390f, -0.03248036f, -0.02266972f, -0.03662870f, -0.01524476f, 0.03456163f, 0.01321104f, 
    0.02055450f, -0.03202760f, -0.02164799f, 0.01512904f, -0.02117209f, -0.03686361f, -0.00357712f, 0.00151011f, 
    0.01053490f, 0.02133107f, -0.01836331f, 0.02411199f, -0.03479620f, -0.03632742f, 0.02586622f, -0.01871381f, 
    -0.00944540f, -0.02563928f, -0.01644034f, 0.00117219f, -0.03464612f, 0.01916464f, -0.03788485f, -0.02537513f, 
    -0.03698595f, -0.01166044f, 0.02519646f, 0.01152684f, -0.00820855f, -0.03493733f, -0.00980109f, -0.00335147f, 
    -0.02150217f, -0.03246975f, -0.02046140f, 0.02134831f, -0.00393685f, 0.02827430f, -0.01764615f, 0.02583021f, 
    0.02187573f, -0.00784919f, 0.02746489f, -0.00274339f, 0.00737686f, -0.02455959f, -0.03917700f, -0.01018421f, 
    -0.00644343f, 0.00138295f, -0.00346285f, -0.00358315f, 0.00918488f, -0.03424702f, -0.03226285f, -0.00801138f, 
    -0.02610515f, 0.01975109f, 0.01492872f, -0.01467657f, -0.00822897f, 0.02586741f, -0.01757323f, 0.01693738f, 
    -0.02076619f, -0.02165873f, -0.02921023f, 0.02678246f, 0.00580723f, -0.00252482f, -0.02144863f, -0.00076163f, 
    -0.02120212f, -0.00449871f, 0.00672693f, -0.00864577f, -0.04169064f, 0.02942397f, 0.02103473f, -0.02675947f, 
    0.02151311f, 0.02988199f, 0.02448955f, -0.03893777f, -0.02114734f, 0.02130730f, 0.02272112f, -0.03349382f, 
    0.01972649f, -0.01735417f, 0.01017809f, -0.02305010f, 0.01047007f, 0.00909411f, -0.01896473f, 0.01644204f, 
    0.02412905f, -0.02279187f, -0.01006310f, -0.02644585f, -0.00802990f, -0.02444157f, -0.00984666f, -0.00449462f, 
    -0.00173468f, 0.02913381f, -0.02063400f, 0.01578475f, 0.01246657f, -0.02209698f, 0.00833850f, 0.00278150f, 
    -0.02378336f, -0.02962619f, 0.00086557f, -0.00330090f, 0.00155836f, -0.02805372f, 0.00798819f, -0.04178567f, 
    0.00971005f, -0.01923222f, -0.01233576f, -0.01254324f, -0.03217413f, -0.02118141f, -0.02519332f, -0.01768494f, 
    -0.01306939f, -0.00833459f, -0.02453166f, 0.01692244f, -0.03305993f, -0.01775609f, 0.01900980f, -0.02918779f, 
    -0.00001650f, -0.02310375f, -0.03715660f, -0.01507336f, -0.03013144f, -0.03820949f, -0.00769370f, 0.02260524f, 
    0.02694695f, -0.00496107f, 0.02348808f, -0.02506552f, -0.01127393f, -0.01665186f, -0.00555940f, -0.00766788f, 
    0.02471878f, -0.01048959f, -0.01621877f, -0.02170906f, -0.03541410f, 0.01065770f, 0.01578068f, -0.00250982f, 
    -0.03692279f, -0.01281895f, -0.02999114f, -0.02542204f, -0.02171756f, -0.03564115f, -0.01801360f, -0.00752687f, 
    0.00873467f, -0.01849748f, 0.00592505f, 0.01957693f, 0.01652151f, 0.02548766f, -0.02395541f, -0.01014724f, 
    0.01466810f, 0.02078399f, -0.01464171f, -0.02371360f, -0.02042373f, -0.02460210f, -0.00751416f, 0.02697169f, 
    -0.01285064f, 0.00206934f, 0.01405005f, 0.00242975f, -0.00508279f, -0.01407673f, -0.03117904f, 0.02648617f, 
    0.00325750f, 0.02183577f, 0.02598189f, -0.01404687f, -0.00462992f, -0.01498010f, 0.01786846f, -0.01474181f, 
    -0.03859593f, -0.01994802f, 0.00438989f, -0.01651928f, 0.01155738f, -0.00192680f, 0.00968320f, -0.03725222f, 
    -0.03800816f, -0.02412910f, -0.01598115f, 0.01460624f, -0.02008918f, -0.01445563f, 0.04171467f, 0.01746868f, 
    -0.01250774f, 0.01023351f, -0.00856819f, 0.00510723f, 0.01720166f, -0.00856610f, 0.01993627f, -0.01616258f, 
    0.00380116f, 0.01178983f, -0.00226990f, 0.00514953f, 0.01717525f, 0.01570119f, -0.04094121f, -0.02060109f, 
    0.01128196f, -0.02167499f, 0.00474340f, -0.01449260f, -0.00544434f, 0.00871106f, 0.00076947f, -0.02420907f, 
    -0.02663923f, 0.00745089f, -0.01427202f, -0.01930891f, -0.01354446f, -0.02766607f, 0.01476251f, -0.03964610f, 
    0.01633576f, 0.01082626f, 0.00098057f, 0.00663468f, 0.02728247f, 0.00116152f, -0.01974423f, -0.00307065f, 
    -0.03198165f, -0.03469829f, 0.02164771f, -0.01768623f, -0.01214747f, -0.01229673f, 0.02068941f, 0.02092803f, 
    -0.02257295f, -0.03408188f, -0.02349289f, 0.01317785f, 0.01763869f, -0.00658497f, 0.00741495f, 0.02766711f, 
    -0.02801483f, -0.01166300f, -0.00990991f, -0.03146544f, 0.00650179f, 0.00180345f, -0.01560324f, 0.00007946f, 
    -0.02609226f, 0.01042592f, -0.01929608f, 0.00556285f, -0.02967158f, 0.02354909f, -0.00787180f, -0.03991215f, 
    -0.03006769f, 0.02883284f, 0.00256207f, 0.00518588f, -0.02096646f, -0.02225894f, -0.00088907f, 0.01098302f, 
    0.00903008f, -0.03041420f, -0.02348680f, 0.00556295f, -0.01548781f, -0.01618236f, 0.00077399f, -0.03263892f, 
    0.02794539f, 0.02367442f, -0.03333448f, -0.01132832f, 0.01367224f, -0.01441059f, -0.03330055f, 0.00992284f, 
    -0.02120680f, -0.02343502f, -0.00910399f, -0.00882031f, -0.03139782f, -0.02522337f, 0.00774270f, 0.01871866f, 
    -0.00550707f, 0.02625588f, -0.02170468f, -0.00381792f, 0.01154918f, 0.00582190f, 0.01480534f, -0.04068001f, 
    -0.00090541f, -0.02856545f, 0.02980893f, -0.02834038f, 0.00365254f, 0.02318015f, -0.00154588f, 0.01051396f, 
    -0.00319716f, -0.00447973f, 0.02951938f, 0.01840728f, 0.00304421f, 0.01298284f, -0.00461385f, 0.01624477f, 
    0.01354303f, -0.00360341f, -0.03230509f, -0.03411571f, -0.03687625f, -0.04142870f, -0.03131884f, 0.01647798f, 
    0.00866283f, -0.02003264f, -0.02444841f, 0.02476408f, -0.03019247f, -0.03647928f, -0.03952510f, 0.02972081f, 
    0.02520381f, 0.01090783f, 0.02823894f, -0.01100080f, -0.01962832f, -0.00332465f, -0.02734927f, 0.02517418f, 
    0.01636602f, 0.01309210f, -0.02754316f, -0.00629857f, -0.00592456f, 0.00666474f, -0.02489993f, -0.01181095f, 
    0.00357805f, -0.02263211f, -0.03064092f, 0.02315201f, 0.00664421f, 0.02781406f, 0.02299790f, -0.00295627f, 
    -0.03067610f, -0.01607194f, -0.02832744f, -0.02612909f, 0.01183414f, -0.01748913f, 0.02669314f, 0.00037255f, 
    0.02129537f, 0.01695871f, -0.01990788f, 0.01894416f, -0.01219313f, 0.02950398f, -0.03954096f, -0.01091457f, 
    -0.01712375f, -0.02070136f, -0.01149822f, 0.02394195f, 0.02096453f, 0.02010172f, -0.02274752f, 0.01050071f, 
    0.02458251f, 0.01053935f, -0.02040137f, -0.03491953f, 0.01864733f, 0.00563967f, -0.00330112f, -0.00358246f, 
    -0.02292881f, -0.03439713f, 0.02644327f, -0.01472015f, -0.00943454f, 0.00214540f, -0.00263343f, 0.01191040f, 
    0.02171879f, -0.00927298f, 0.01023612f, 0.02985188f, -0.03791577f, -0.03008169f, -0.02755816f, -0.02651557f, 
    -0.02491855f, -0.00691997f, 0.00871371f, -0.00777152f, 0.00867705f, -0.03201419f, -0.00550237f, 0.00084403f, 
    0.01682574f, -0.01156006f, -0.00174423f, -0.01957810f, 0.02625986f, -0.02831446f, -0.01868582f, -0.02100722f, 
    -0.03969680f, -0.04116940f, -0.02878265f, 0.02619066f, -0.00925513f, -0.02555247f, -0.00929184f, -0.03229680f, 
    -0.03571295f, -0.00861985f, 0.00137476f, 0.01177893f, 0.01728358f, -0.00661477f, -0.00143429f, -0.01972851f, 
    -0.03609569f, -0.02792989f, -0.03019149f, 0.01081885f, -0.02637977f, -0.00344947f, -0.01632165f, 0.00585990f, 
    -0.02358160f, 0.00678345f, 0.00726240f, 0.01979186f, -0.00265182f, 0.00794825f, 0.02028686f, 0.00492488f, 
    0.02580453f, -0.01934645f, 0.00834324f, -0.03851768f, -0.03225676f, -0.00600823f, -0.01932414f, 0.00498704f, 
    0.00875718f, 0.02036578f, -0.02995362f, -0.04041816f, -0.03725904f, -0.02042748f, 0.02184172f, 0.00151760f, 
    0.02882714f, -0.00191101f, -0.02918853f, -0.00491709f, 0.02868044f, 0.01157749f, -0.01666046f, -0.00213761f, 
    0.02014302f, 0.01441653f, 0.01815961f, 0.01405874f, -0.03990024f, 0.02202556f, -0.02915321f, 0.00074227f, 
    0.01406255f, -0.01821568f, 0.01301016f, 0.00737402f, -0.00772694f, 0.02020247f, 0.01994392f, -0.00671299f, 
    0.00287830f, -0.02723408f, -0.02856229f, -0.00023083f, -0.01689069f, -0.00714242f, -0.03436201f, 0.02617120f, 
    -0.00950671f, -0.01926960f, -0.01493051f, 0.00020693f, -0.00876380f, 0.00709676f, -0.01352558f, -0.00943565f, 
    -0.03862258f, -0.03390930f, -0.00641859f, -0.00249981f, 0.02410429f, 0.02767823f, -0.00948091f, -0.02043346f, 
    -0.03132481f, -0.01651658f, -0.00579890f, -0.00829398f, 0.00065467f, -0.00440344f, 0.00203377f, -0.04058482f, 
    0.02566596f, 0.01924909f, -0.03236454f, 0.00392887f, -0.01689856f, -0.00763337f, -0.02536651f, -0.03416326f, 
    -0.01628394f, 0.00150369f, -0.02861098f, 0.01464457f, 0.02565639f, -0.02911101f, 0.01359626f, 0.00169350f, 
    0.02974508f, -0.01693283f, -0.03679509f, -0.02281571f, -0.00706693f, -0.02197859f, -0.04191996f, -0.03150294f, 
    -0.03933802f, -0.02135777f, 0.02338072f, 0.00092896f, -0.02520495f, 0.00448089f, -0.00030419f, -0.00962471f, 
    0.00671538f, -0.04060512f, -0.01039612f, -0.03135594f, -0.01731184f, 0.01853011f, -0.00423664f, -0.01135926f, 
    0.02030957f, -0.01138663f, -0.02403357f, 0.01600570f, -0.01209837f, -0.03791051f, 0.01691171f, -0.01010944f, 
    -0.02725727f, -0.02231061f, 0.00329121f, -0.00905024f, -0.01522259f, -0.01179844f, -0.04061015f, -0.00125191f, 
    -0.04033776f, 0.02489321f, -0.00707720f, -0.04148208f, -0.01341467f, -0.00411863f, -0.01080382f, -0.03325970f, 
    0.00515937f, -0.00738690f, -0.03395358f, 0.02154666f, 0.02427251f, 0.00579405f, -0.03164834f, 0.02594773f, 
    -0.00694881f, 0.01017699f, -0.01930214f, -0.03887833f, 0.01977313f, 0.00708370f, 0.02266124f, -0.00084448f, 
    -0.02204733f, 0.01091250f, 0.00810537f, -0.01483056f, 0.01083738f, -0.00290937f, -0.03415239f, 0.00240636f, 
    0.00673072f, 0.02354621f, -0.00401463f, 0.02634232f, 0.01770979f, 0.00032977f, 0.00430847f, -0.00358471f, 
    0.00442542f, 0.02285943f, 0.02236423f, 0.02240122f, -0.01229163f, 0.02765193f, -0.04206069f, 0.01861853f, 
    -0.01039197f, 0.00854837f, -0.04154494f, -0.02225734f, -0.02113540f, -0.00860525f, 0.02560260f, -0.02301663f, 
    -0.03328324f, -0.01677595f, -0.01064072f, -0.01172131f, -0.03992911f, 0.00812403f, -0.02225140f, -0.00021827f, 
    -0.03355623f, -0.00112818f, -0.00868530f, 0.01866029f, 0.01806005f, 0.00625593f, -0.00745465f, -0.03714925f, 
    -0.03832525f, 0.00112316f, 0.00154169f, -0.02148234f, -0.01438023f, -0.03172853f, -0.00865276f, -0.03266631f, 
    0.00677160f, -0.00653227f, 0.03421353f, -0.03056353f, -0.03800458f, 0.00942628f, -0.01388229f, 0.02326689f, 
    -0.04035713f, -0.02796479f, -0.00083876f, 0.00084979f, -0.01551519f, 0.02555857f, -0.00680562f, -0.03058158f, 
    -0.02322385f, 0.03827286f, 0.00755038f, -0.00396302f, 0.02547615f, -0.00178603f, -0.03121947f, 0.01580141f, 
    -0.01385676f, -0.00785031f, 0.03619716f, 0.01463963f, -0.02416136f, 0.02350228f, -0.00314799f, 0.02639204f, 
    0.01848911f, -0.04591042f, -0.00259639f, -0.01426434f, -0.02527325f, 0.01683012f, -0.02547955f, -0.03252663f, 
    0.00252933f, -0.00520660f, -0.01746126f, 0.01896589f, -0.01080692f, -0.01834761f, 0.01184470f, -0.01674553f, 
    -0.00623317f, -0.00942793f, 0.01459374f, -0.00310135f, -0.03545786f, -0.02535403f, -0.04387347f, -0.02690182f, 
    0.00435888f, -0.02119263f, -0.03029360f, -0.03657902f, -0.03652256f, -0.03878663f, -0.01925395f, -0.03425599f, 
    -0.03000105f, -0.03332168f, -0.00022228f, -0.02826651f, -0.03485413f, 0.02246566f, 0.01057768f, 0.02637220f, 
    0.01689106f, -0.01261553f, 0.00510441f, 0.02453610f, -0.00518067f, -0.02464633f, 0.03667310f, 0.00787261f, 
    -0.00303081f, -0.01184172f, 0.01359668f, -0.03852024f, 0.01642297f, 0.03133498f, 0.00847478f, 0.00132937f, 
    -0.01487077f, -0.04134779f, -0.00284960f, -0.02729207f, 0.00758973f, 0.00261918f, -0.01148465f, 0.01028908f, 
    -0.04166115f, -0.02149783f, 0.02287633f, 0.01142924f, 0.03416439f, -0.03201381f, 0.03954181f, -0.01698859f, 
    0.01863280f, -0.01740806f, -0.04076763f, -0.04225029f, 0.02468232f, 0.01964022f, -0.01670848f, 0.00853568f, 
    0.02337183f, 0.01077248f, -0.03037241f, -0.01352667f, -0.04176110f, 0.01247886f, 0.02532397f, 0.02167367f, 
    0.01683376f, -0.00851304f, -0.01847165f, -0.03697943f, -0.02027623f, -0.03413117f, -0.00047396f, -0.04294405f, 
    -0.00539275f, -0.01426195f, -0.03703471f, 0.01683980f, 0.01195771f, -0.03725259f, -0.03129232f, 0.02639587f, 
    0.02072070f, 0.00167661f, -0.02028570f, 0.00447349f, -0.03670774f, -0.00818990f, 0.01026800f, 0.00038948f, 
    0.03241352f, 0.00156010f, -0.00447643f, -0.00721586f, -0.00278259f, 0.00861545f, -0.00794755f, 0.00672515f, 
    0.02345110f, 0.02259294f, -0.03128267f, -0.00310241f, -0.02625491f, 0.00213161f, -0.01510517f, -0.02806108f, 
    0.00834058f, -0.02927024f, 0.00812802f, 0.02949195f, -0.00854027f, -0.01503893f, -0.00859435f, 0.03112767f, 
    0.00480770f, 0.01251808f, -0.02223709f, -0.00932400f, -0.00513850f, -0.03142471f, -0.03429717f, 0.03185820f, 
    0.01074023f, -0.04080513f, 0.00534237f, -0.00064047f, -0.03900963f, -0.02114619f, -0.01234532f, 0.02208447f, 
    0.02234211f, -0.03278804f, -0.00335695f, 0.00552821f, 0.01332582f, -0.01515148f, -0.03906643f, 0.00431215f, 
    -0.00508407f, 0.01281154f, -0.04092143f, -0.00554372f, -0.03056461f, 0.00689490f, -0.00050387f, 0.00242607f, 
    -0.04112812f, -0.04070636f, -0.00292745f, -0.00155824f, -0.00409155f, 0.02401815f, -0.01849827f, 0.00232941f, 
    -0.01014965f, -0.03966376f, 0.01880159f, -0.01355781f, -0.04506046f, 0.01183887f, 0.03351219f, -0.03322235f, 
    -0.03576282f, -0.03104723f, -0.03022150f, -0.00479849f, -0.03490512f, -0.02707909f, 0.02332037f, -0.03433551f, 
    -0.03892667f, -0.01896031f, -0.00561412f, -0.02680680f, 0.02259965f, -0.03043012f, 0.02101487f, 0.01247689f, 
    -0.02342934f, 0.00526057f, -0.01853568f, -0.04033090f, -0.03377669f, -0.00031868f, 0.01778745f, 0.00685716f, 
    0.00510060f, 0.00323711f, -0.03116068f, -0.03972472f, 0.00169656f, 0.01296487f, -0.01588306f, -0.02111408f, 
    -0.02574156f, 0.02221695f, -0.01911198f, -0.01063116f, -0.01337542f, -0.00221420f, -0.03592860f, 0.01622397f, 
    0.03033871f, -0.00459951f, -0.00724485f, -0.01571389f, -0.02260673f, -0.02177097f, -0.02974871f, -0.02995305f, 
    -0.01159527f, 0.00719570f, -0.02099915f, -0.00661702f, 0.00062306f, -0.04736504f, 0.00701733f, -0.00728720f, 
    0.00514718f, -0.04285964f, -0.00079688f, 0.00769631f, 0.01123696f, -0.02560167f, -0.00218144f, -0.01247177f, 
    0.01149820f, -0.03464469f, -0.04173001f, -0.00661232f, 0.02049838f, -0.02919682f, -0.03101295f, -0.00404323f, 
    -0.01687189f, -0.03912314f, -0.00100402f, 0.01044345f, 0.02973368f, -0.00421273f, -0.03649032f, -0.03134274f, 
    0.00347933f, -0.03454178f, -0.00944448f, -0.01977704f, 0.00709226f, -0.04143713f, -0.02092364f, -0.04088003f, 
    -0.02162055f, -0.03068262f, -0.02681075f, 0.02252722f, 0.01786441f, 0.02160953f, -0.01977275f, -0.01135146f, 
    0.00763989f, 0.02221357f, 0.01553496f, -0.02349047f, -0.03573034f, 0.03375695f, 0.00695096f, -0.03145754f, 
    0.01098849f, -0.03005574f, -0.02825492f, 0.00822994f, -0.03872971f, 0.00306997f, -0.01287151f, 0.01643297f, 
    -0.01403462f, -0.01864803f, -0.01223446f, 0.00010502f, 0.02113062f, -0.00668458f, -0.00038174f, -0.00585718f, 
    -0.03994160f, 0.02083151f, -0.03080132f, 0.00846684f, 0.02363466f, -0.00350762f, 0.03045056f, -0.03248019f, 
    0.01084172f, 0.01765615f, -0.04171451f, -0.00505057f, -0.00090089f, -0.00660481f, 0.02294091f, 0.02609955f, 
    -0.02863508f, -0.02604478f, -0.01538393f, -0.02458607f, -0.04107921f, 0.02534189f, -0.01341248f, -0.03386139f, 
    -0.02831737f, -0.03340682f, 0.02584901f, 0.01998987f, 0.02256866f, 0.02633069f, 0.01523857f, -0.00327632f, 
    -0.02036314f, 0.01256036f, 0.02419951f, 0.00667102f, -0.00100682f, -0.03024360f, -0.00659129f, -0.01560047f, 
    -0.01482739f, 0.01572871f, 0.00333610f, 0.02289720f, -0.03333154f, -0.02690158f, 0.03532534f, -0.01681047f, 
    0.02495089f, -0.00257471f, -0.03711968f, -0.00841273f, 0.01784753f, -0.02380218f, -0.01839511f, 0.03347906f, 
    -0.01406333f, -0.02962481f, 0.02666439f, 0.00702695f, -0.03090390f, 0.03222730f, 0.00757194f, 0.02614981f, 
    -0.01918485f, -0.03353412f, -0.00430644f, 0.01922334f, 0.02465593f, 0.01485705f, -0.03773780f, 0.01694412f, 
    -0.01084506f, -0.03460554f, 0.00822969f, 0.01143759f, -0.02371979f, 0.00016076f, -0.01846244f, 0.02528461f, 
    -0.00188146f, -0.02484991f, 0.02085906f, -0.02379678f, -0.00898308f, -0.02674388f, 0.01059173f, 0.01388234f, 
    0.01432836f, 0.02484792f, 0.02768475f, -0.04585977f, -0.02013754f, 0.02360832f, -0.01849345f, -0.02948637f, 
    0.01014635f, 0.00303073f, 0.00554523f, 0.02528805f, -0.02426635f, 0.00835523f, 0.01867439f, 0.01372697f, 
    0.02219702f, -0.01681258f, 0.00659544f, 0.01453448f, -0.04060200f, -0.02199484f, -0.02720723f, -0.03720310f, 
    0.01494431f, -0.01291803f, -0.03348303f, -0.00139074f, 0.00523425f, -0.02815830f, 0.03713312f, -0.03797337f, 
    -0.01627226f, -0.02001033f, 0.01383822f, -0.00061971f, 0.01178122f, -0.01839467f, -0.01178533f, -0.04009466f, 
    -0.02418643f, -0.02344658f, 0.01314320f, 0.00848292f, -0.00696799f, -0.00610726f, 0.01103928f, -0.01396712f, 
    0.00883770f, -0.03343482f, 0.00519285f, -0.00508713f, 0.01779960f, -0.00284766f, 0.01173987f, -0.04517395f, 
    0.02163054f, -0.02132280f, 0.01656695f, -0.03155081f, -0.00745234f, 0.01072886f, 0.03228416f, -0.02443590f, 
    0.03051700f, -0.03596683f, 0.01425577f, -0.01411834f, -0.03704489f, 0.01874437f, 0.01113518f, -0.04098548f, 
    -0.00107034f, -0.02983468f, -0.01596745f, 0.03303973f, -0.04152259f, -0.01350333f, 0.00413701f, 0.00330662f, 
    -0.01951066f, 0.00093545f, 0.02460608f, -0.00101193f, -0.03968662f, 0.00595632f, 0.01667769f, -0.03830548f, 
    -0.01970240f, -0.01473277f, -0.03488621f, -0.03030981f, -0.00087709f, -0.03274411f, -0.00222747f, 0.00642087f, 
    -0.03364621f, -0.01493789f, 0.01259233f, 0.00280187f, 0.00889347f, -0.04116121f, 0.00174097f, -0.02706486f, 
    -0.00230409f, -0.02378735f, -0.01125451f, -0.03298464f, 0.03357991f, -0.01147435f, 0.03676997f, 0.00023818f, 
    -0.00894105f, 0.00098190f, 0.00915619f, -0.03334638f, -0.02069510f, -0.02747163f, 0.02237765f, -0.00695586f, 
    -0.01294042f, 0.01795913f, -0.02939115f, -0.00245088f, -0.00300224f, 0.00592215f, 0.00727220f, -0.03793580f, 
    0.01607089f, 0.03185108f, 0.00522023f, 0.01258572f, -0.00465848f, -0.02039754f, -0.03205596f, 0.01376878f, 
    0.00810790f, -0.00788449f, 0.00280259f, 0.00068151f, 0.01631312f, 0.00012298f, -0.00939252f, -0.00273022f, 
    0.00689575f, 0.01724087f, -0.00211397f, -0.03842876f, -0.00012774f, 0.01558749f, -0.02914194f, -0.02918020f, 
    -0.01640721f, 0.01306464f, -0.02894372f, 0.01504688f, 0.01801141f, 0.02648576f, 0.02320010f, -0.02124900f, 
    -0.02157615f, 0.01707837f, -0.00624934f, -0.02590822f, -0.02659227f, 0.00299670f, -0.02088608f, -0.04219877f, 
    0.01814339f, -0.04216113f, -0.02244700f, -0.02936537f, -0.03312400f, 0.01828320f, 0.02842382f, -0.00170132f, 
    0.03431046f, -0.04039401f, -0.02536300f, 0.02576572f, 0.03867180f, 0.02942798f, 0.02986086f, 0.03125472f, 
    -0.00999308f, 0.01634812f, 0.01610157f, -0.01465854f, 0.02378165f, -0.03499840f, 0.00814339f, -0.02257606f, 
    -0.01872589f, -0.02396510f, -0.03170609f, 0.03216150f, -0.03902237f, -0.02391310f, 0.04111954f, -0.01591371f, 
    -0.00338545f, -0.00414867f, -0.04315927f, 0.01177774f, -0.03641886f, 0.02770316f, 0.02359984f, 0.01145036f, 
    0.00242377f, 0.01173553f, -0.03574903f, -0.02446667f, -0.00859257f, -0.01462915f, -0.03166448f, -0.00580356f, 
    -0.03184775f, -0.03405948f, 0.02381286f, 0.02160554f, 0.00931380f, 0.00892140f, 0.02377880f, -0.00836353f, 
    -0.03388894f, -0.01907421f, -0.02814340f, -0.03166695f, -0.01131546f, -0.01161012f, -0.01486691f, 0.02429615f, 
    0.00721290f, -0.02068289f, -0.01627031f, -0.01080065f, 0.01240346f, 0.02789904f, -0.03287883f, -0.00591850f, 
    0.02518060f, -0.01349073f, 0.01953159f, -0.01600357f, 0.02213475f, 0.03134540f, -0.00484972f, 0.00289661f, 
    -0.03659227f, -0.00888566f, -0.00175862f, 0.01140708f, -0.04138490f, -0.04015407f, 0.00688623f, 0.01399961f, 
    0.02118895f, 0.02661021f, 0.00242045f, -0.03400088f, -0.03219758f, -0.00230713f, -0.01573072f, 0.01569173f, 
    0.01273501f, 0.01082546f, 0.02579224f, -0.00744127f, 0.00970982f, -0.03073742f, 0.02507248f, 0.00528610f, 
    -0.02566552f, 0.01586429f, 0.01735208f, -0.03700323f, -0.00067701f, -0.02082548f, 0.00130794f, -0.03231559f, 
    0.01404577f, -0.01376300f, 0.02031195f, 0.01776100f, -0.03628483f, -0.02053645f, 0.03629272f, -0.02183725f, 
    -0.01976703f, 0.01606786f, -0.02913356f, -0.03565325f, 0.00859226f, -0.01511678f, -0.03667702f, 0.03110461f, 
    -0.02396389f, 0.01786952f, -0.03117125f, -0.02805911f, 0.00014967f, -0.00654716f, -0.03688937f, 0.01268651f, 
    -0.00064134f, -0.04084108f, -0.00203375f, 0.00942622f, -0.03163142f, -0.03854794f, -0.03115028f, 0.01016905f, 
    0.02093069f, -0.03050755f, -0.01663087f, -0.00997318f, -0.02388905f, -0.03749007f, 0.01853223f, 0.02086017f, 
    0.02601157f, 0.02263695f, 0.02209271f, -0.02453017f, 0.00177865f, -0.02636103f, -0.02967223f, 0.03525072f, 
    -0.01615581f, -0.01221127f, 0.02617951f, -0.00448140f, -0.03477418f, 0.01987605f, -0.02307722f, 0.00222906f, 
    0.01382340f, -0.00893942f, -0.00056048f, -0.00346162f, -0.00138444f, 0.01725933f, -0.01999549f, -0.03069614f, 
    0.00188157f, -0.03339183f, 0.02762567f, 0.01544513f, -0.00365174f, 0.03495387f, -0.01434074f, 0.02310854f, 
    -0.03241743f, 0.01239880f, -0.01194300f, -0.02112057f, 0.02068939f, 0.02216731f, 0.02512188f, -0.03100603f, 
    -0.00221028f, -0.00810269f, 0.01813969f, -0.02361196f, -0.00714205f, -0.00110081f, -0.00212509f, -0.01547340f, 
    -0.03873845f, 0.02381457f, 0.00272663f, 0.01625810f, 0.01030669f, -0.01736420f, 0.01521245f, -0.03606303f, 
    0.01887698f, 0.02280077f, -0.00289108f, -0.03428632f, 0.00453533f, 0.01213335f, 0.01639992f, -0.03172858f, 
    0.01616829f, 0.02028343f, -0.02404323f, 0.03025959f, 0.00143313f, -0.01794833f, -0.02028116f, -0.02861148f, 
    -0.01327145f, -0.02970235f, 0.02641882f, -0.01377576f, 0.01445418f, 0.00498429f, 0.00709317f, 0.02474325f, 
    0.02974436f, 0.02995172f, -0.04068050f, 0.00547575f, 0.00841206f, 0.00696880f, -0.02151317f, -0.00504079f, 
    -0.01721648f, 0.02628788f, -0.01760503f, -0.02808654f, 0.01716685f, 0.01907630f, -0.02317003f, -0.00441618f, 
    0.02163180f, -0.03528073f, -0.03807191f, -0.02575130f, -0.03428587f, -0.02445691f, -0.01342162f, -0.00880265f, 
    -0.02692994f, -0.02459192f, -0.03890291f, 0.02591300f, 0.03051299f, 0.00220559f, -0.03477392f, -0.00269381f, 
    -0.03147404f, -0.02397334f, -0.04123894f, -0.00626110f, -0.03125852f, -0.03595593f, -0.03528718f, 0.02254203f, 
    -0.03369707f, -0.02954602f, 0.02351102f, 0.00651590f, 0.02904199f, -0.01501494f, -0.03453270f, 0.02654783f, 
    -0.01312314f, 0.02312689f, -0.01069802f, -0.02466864f, -0.01951143f, 0.00941526f, 0.01881120f, 0.00849181f, 
    0.02414251f, -0.03934748f, 0.01668863f, -0.02796905f, 0.01115371f, 0.02982609f, -0.02879195f, 0.00327098f, 
    0.02514741f, -0.02793541f, -0.02783618f, 0.00262836f, -0.02731132f, 0.03276429f, 0.00240088f, 0.01534011f, 
    0.02773397f, -0.03493809f, -0.01535427f, -0.01550279f, -0.00642464f, -0.03452891f, 0.00795886f, 0.01619862f, 
    -0.01191863f, 0.02207356f, -0.02751131f, 0.01698866f, 0.00546361f, -0.01137329f, -0.00195249f, 0.00835639f, 
    0.00670547f, -0.02539716f, -0.00633875f, -0.03770130f, 0.00222158f, -0.02796466f, 0.03477751f, -0.01799030f, 
    -0.02474286f, -0.03765996f, -0.02222036f, -0.02631653f, 0.01789996f, 0.01429111f, -0.00400056f, 0.00031021f, 
    0.00901980f, -0.01082312f, 0.00200380f, -0.02175300f, 0.01527414f, -0.03702549f, -0.04033035f, -0.03596446f, 
    -0.00205546f, -0.02284503f, -0.00822370f, -0.01906600f, -0.00711141f, 0.01729308f, 0.01837189f, -0.00616123f, 
    -0.01271276f, -0.00785795f, 0.02533182f, -0.03115379f, 0.00811600f, 0.02620259f, 0.01407330f, 0.00071905f, 
    0.00075583f, -0.01117195f, -0.00953968f, 0.02654404f, 0.01361348f, 0.02889204f, 0.01453425f, 0.02289977f, 
    0.00584152f, -0.03456498f, -0.01236957f, 0.01698346f, 0.00166656f, 0.00450322f, -0.02344417f, -0.03906687f, 
    -0.02227041f, 0.01352486f, 0.02992809f, 0.01466741f, 0.02447201f, -0.04001655f, -0.02275945f, -0.02980799f, 
    -0.00937780f, -0.01271831f, -0.00745378f, 0.02215987f, -0.03780589f, 0.00237830f, -0.00552429f, -0.02512858f, 
    -0.00164837f, -0.02830497f, -0.00716425f, -0.00914587f, 0.01648672f, -0.03875654f, -0.00429003f, -0.03829652f, 
    0.01091822f, 0.01490945f, 0.01451151f, 0.01594505f, -0.03514684f, 0.00119154f, -0.02212978f, 0.02315958f, 
    0.03513169f, 0.01459809f, 0.01265790f, 0.00964890f, 0.02750937f, -0.02370099f, -0.02418559f, -0.03133741f, 
    0.01818103f, -0.00327028f, 0.01919392f, -0.03555477f, 0.00339818f, -0.01738260f, -0.01243069f, 0.02885797f, 
    -0.00698545f, -0.02131609f, -0.02662877f, 0.00417314f, 0.00721251f, -0.01546745f, -0.01535584f, 0.00661078f, 
    -0.00013662f, -0.01283254f, 0.02714413f, 0.01167745f, -0.02740368f, -0.03504817f, 0.00216420f, -0.02653796f, 
    -0.02941374f, 0.02790413f, -0.00956233f, -0.00171513f, -0.03320394f, 0.02623686f, -0.00114354f, 0.02259209f, 
    0.01686192f, -0.01932655f, -0.04014461f, 0.03005055f, 0.02451151f, -0.03280000f, 0.00075020f, -0.04015477f, 
    -0.02418995f, -0.01577009f, 0.03115836f, 0.02347616f, -0.02700042f, 0.03380920f, -0.02011695f, -0.00334347f, 
    -0.02914250f, -0.03428139f, -0.03358313f, -0.00237715f, 0.00179453f, 0.01244383f, 0.02089407f, -0.01888291f, 
    0.02049220f, 0.00485873f, -0.00986927f, 0.02709361f, 0.01182277f, 0.02953934f, -0.02508808f, -0.04054728f, 
    -0.01231710f, 0.02729090f, 0.03523411f, 0.01748991f, 0.00482993f, -0.01341597f, -0.01431192f, 0.01727781f, 
    -0.02367153f, -0.01408430f, 0.03395287f, 0.01775071f, 0.00396566f, 0.02088545f, -0.00531315f, -0.01646271f, 
    0.00024256f, 0.00441015f, 0.00485020f, 0.01562381f, -0.01940679f, 0.01904588f, 0.02858937f, 0.01279626f, 
    0.02862965f, 0.00322716f, -0.02473715f, -0.00045186f, -0.01786965f, -0.00372697f, -0.03873848f, 0.02689907f, 
    0.02090976f, 0.02829802f, 0.00912376f, -0.00495541f, -0.00125928f, 0.02639930f, 0.00629633f, -0.02569209f, 
    0.00043238f, -0.03925586f, 0.00750732f, -0.03195957f, 0.01653637f, -0.00963701f, 0.01968226f, -0.02110545f, 
    0.01780546f, 0.02052583f, -0.03216379f, -0.00218770f, 0.02294904f, -0.03419235f, 0.01457009f, -0.04042891f, 
    -0.03747427f, -0.01511230f, -0.03770879f, 0.02573908f, -0.00821575f, 0.00593593f, 0.02587008f, -0.03415487f, 
    0.01885178f, 0.02724524f, -0.03544866f, -0.01725528f, 0.01141909f, 0.01693573f, 0.01871912f, -0.01789791f, 
    0.02899516f, 0.02174008f, -0.00097147f, -0.02668961f, 0.01111015f, -0.01861887f, -0.00677323f, 0.02274267f, 
    -0.02073094f, -0.03218168f, -0.03861896f, -0.00743017f, -0.03714864f, -0.04019744f, 0.00195536f, -0.01913776f, 
    -0.02927498f, -0.03878862f, -0.02654744f, 0.02552585f, -0.02335042f, -0.03323983f, -0.01943902f, -0.01491836f, 
    -0.01985322f, 0.02585865f, -0.02328339f, 0.01152914f, -0.01390849f, -0.03260941f, 0.00634953f, -0.01225315f, 
    -0.00564907f, 0.01292990f, -0.02873318f, 0.00165917f, 0.02561744f, -0.01246073f, -0.03365032f, 0.00807090f, 
    -0.03073592f, -0.00465393f, -0.02868789f, -0.02233960f, -0.02195114f, -0.01142448f, -0.03623458f, -0.01324411f, 
    0.00300364f, -0.01788225f, 0.00033251f, -0.03343229f, -0.00252476f, 0.01445757f, -0.02623340f, -0.01310502f, 
    0.00208884f, -0.02558320f, -0.01639792f, -0.02591736f, 0.02009458f, 0.03091554f, 0.02282697f, 0.00162618f, 
    -0.01137092f, -0.00226164f, 0.00880156f, -0.02179115f, 0.02407129f, 0.01744789f, 0.01241680f, -0.01278100f, 
    -0.03106417f, -0.02397714f, -0.02129759f, -0.02519106f, 0.01383247f, 0.00705468f, -0.01810490f, 0.00675147f, 
    -0.00679130f, 0.02557342f, -0.03300692f, -0.00627425f, -0.03602921f, -0.01978986f, 0.02975548f, 0.02856840f, 
    -0.02049325f, -0.03923099f, -0.03627181f, -0.03419624f, -0.02219193f, 0.01800073f, 0.02576744f, 0.01180868f, 
    0.01303196f, -0.01572972f, -0.03542458f, -0.00240845f, -0.01877107f, 0.01131841f, 0.02250237f, -0.03038558f, 
    0.00910028f, 0.00272385f, 0.01031740f, -0.03494484f, -0.01652479f, 0.00982396f, 0.00473694f, -0.01248563f, 
    -0.00353655f, 0.02362401f, -0.02219030f, -0.02983129f, 0.00518150f, -0.03931362f, -0.02631485f, 0.02642613f, 
    -0.00675756f, 0.00536934f, -0.01733993f, 0.00689688f, -0.02598946f, 0.00281000f, 0.02224469f, 0.02640358f, 
    0.01148203f, -0.00235038f, 0.00026035f, -0.03006885f, 0.02196299f, 0.02297312f, 0.00560696f, -0.02237703f, 
    -0.03096820f, -0.03175582f, 0.00049155f, 0.01899629f, -0.02404169f, 0.00502727f, -0.02718753f, -0.00548613f, 
    -0.01212644f, -0.02514511f, -0.03308960f, -0.02640012f, 0.01620760f, 0.02528696f, -0.01472090f, -0.00738853f, 
    -0.01063968f, 0.01191100f, -0.00042677f, 0.00613834f, 0.00900938f, -0.01759841f, 0.02804515f, -0.01748484f, 
    -0.00296310f, 0.00860463f, 0.01160459f, -0.03989315f, -0.02863164f, -0.00507614f, -0.03642471f, -0.02368152f, 
    -0.00247647f, -0.00549941f, -0.02503751f, 0.01578970f, -0.01296336f, -0.01498377f, 0.03550547f, -0.01850184f, 
    -0.03348812f, -0.01585468f, -0.00083934f, 0.01991397f, 0.02167667f, 0.00919053f, -0.03160175f, -0.02894490f, 
    -0.00879450f, -0.02048876f, -0.00602832f, 0.01116999f, -0.00178638f, 0.01581623f, 0.03369099f, 0.03450685f, 
    -0.00577293f, -0.02903874f, 0.01291906f, -0.02609546f, 0.01645223f, -0.01147117f, -0.02829128f, -0.03484330f, 
    -0.02857495f, 0.01713835f, 0.00390124f, -0.03079298f, 0.00448647f, -0.00099868f, -0.02907678f, 0.01862569f, 
    0.01896114f, -0.01685821f, 0.00465548f, -0.01634288f, 0.00078594f, 0.02989141f, -0.01345113f, 0.00107114f, 
    -0.03179298f, -0.00767130f, -0.00624028f, -0.03414702f, -0.03080826f, -0.02603868f, -0.04092028f, -0.01247683f, 
    0.01252653f, -0.00171920f, -0.03809910f, -0.00881634f, 0.02709278f, 0.02374502f, 0.00442262f, -0.01533165f, 
    0.01211433f, -0.00899554f, -0.00921772f, 0.01033762f, -0.00729604f, -0.01020810f, -0.03548256f, 0.02764135f, 
    -0.02759876f, 0.02948304f, -0.00061598f, 0.02358835f, 0.02452419f, -0.02978735f, -0.01703002f, 0.02742426f, 
    -0.02590771f, -0.00653054f, -0.02997462f, 0.00814773f, 0.01248407f, 0.00172370f, -0.02672781f, 0.02123255f, 
    -0.01013386f, 0.01796268f, 0.02088418f, 0.00746098f, -0.02578887f, 0.01529503f, -0.00235620f, -0.01548547f, 
    -0.02562218f, 0.02501150f, 0.00240362f, 0.00107445f, -0.02611214f, -0.00096326f, -0.00405013f, -0.00908505f, 
    0.02448153f, -0.02139408f, 0.00546690f, 0.02220246f, -0.02572825f, -0.01447721f, -0.01051392f, -0.01804594f, 
    -0.00467337f, 0.01346007f, 0.00472731f, -0.02930313f, 0.02132881f, 0.01611124f, 0.00037171f, -0.03527796f, 
    -0.02457935f, -0.00946414f, 0.00029992f, 0.00682521f, 0.01195537f, -0.00355471f, 0.00071132f, 0.00270443f, 
    0.00773802f, -0.02018098f, 0.01829451f, -0.03188959f, 0.01356564f, 0.00977235f, -0.03105383f, 0.02158776f, 
    0.02031085f, -0.03552319f, 0.00975196f, -0.02084989f, -0.02348553f, -0.02008254f, -0.00660435f, -0.03376232f, 
    -0.00685409f, 0.01205961f, -0.01742104f, -0.02037187f, -0.02763400f, -0.01304527f, -0.01222669f, -0.04078152f, 
    -0.02537961f, -0.01349760f, -0.01168843f, 0.02335968f, -0.00948689f, -0.01124066f, 0.02141100f, -0.02565258f, 
    -0.02010401f, -0.02210840f, -0.00973352f, -0.01069409f, -0.00402621f, 0.02834824f, 0.02679272f, -0.00822131f, 
    0.00081420f, 0.02611096f, 0.02404513f, 0.02864469f, -0.02109152f, 0.02981745f, -0.00335687f, -0.03604563f, 
    0.00250733f, 0.03023557f, -0.01924708f, -0.02350603f, 0.02979882f, 0.02210426f, -0.03813499f, -0.01186466f, 
    -0.03837468f, 0.00331073f, -0.00007665f, 0.02656983f, -0.00658923f, 0.02548813f, -0.02013510f, -0.02181504f, 
    0.00079982f, -0.03036172f, 0.00711506f, -0.00260902f, -0.01631137f, 0.02214065f, -0.03197116f, 0.02575465f, 
    -0.00677642f, -0.01314321f, -0.03755186f, 0.00909681f, 0.00789442f, 0.01972432f, 0.00082777f, -0.00431201f, 
    -0.01974483f, -0.00837933f, -0.03594751f, 0.03467027f, -0.01943913f, -0.03762815f, 0.00572071f, -0.04026261f, 
    -0.08348122f, 0.01122960f, -0.01200303f, -0.01888936f, 0.10210863f, 0.06679641f, 0.07333872f, 0.01706779f, 
    -0.03074730f, 0.04801022f, 0.03510639f, 0.00805875f, -0.04833322f, -0.13772133f, 0.06610402f, 0.17880085f, 
    -0.00226634f, -0.13849340f, 0.09910977f, 0.10343225f, -0.16869451f, 0.09163848f, -0.12232599f, -0.09990284f, 
    -0.21332297f, -0.13428995f, -0.01663379f, -0.16148591f, -0.08281498f, -0.09040254f, -0.05862774f, -0.09289689f, 
    -0.04205284f, -0.02440818f, -0.23913068f, -0.22148761f, -0.08237521f, 0.36757469f, -0.31826842f, 0.37355325f, 
    -0.14595744f, 0.14482115f, 0.02721344f, -0.04548670f, -0.05951187f, 0.05191587f, 0.16163760f, 0.17064103f, 
    0.22619343f, -0.02638787f, -0.06278228f, 0.15874836f, -0.15166536f, -0.03978425f, -0.04768436f, -0.05819459f, 
    -0.07320122f, -0.05199661f, 0.03942758f, 0.04317122f, 0.06106716f, 0.17376329f, -0.15301904f, 0.07484295f, 
    0.03568148f, 0.07092121f, 0.04845075f, 0.15799509f, -0.17512526f, -0.23748095f, -0.24750204f, -0.57740700f, 
    0.11223669f, 0.05037021f, -0.15257807f, 0.15721390f, -0.02274198f, 0.06011960f, 0.08242480f, 0.18642657f, 
    -0.05264337f, 0.18138285f, 0.06700373f, 0.07101332f, -0.31311712f, -0.17793208f, -0.12661162f, -0.16947649f, 
    -0.15073739f, -0.07550915f, -0.07262228f, -0.14560220f, -0.11659092f, -0.04179086f, -0.10494901f, -0.14972475f, 
    0.13549106f, 0.05188515f, 0.21664202f, 0.03800249f, 0.13975084f, -0.01222500f, 0.02935046f, 0.06798161f, 
    -0.12875846f, 0.11669039f, 0.04885183f, 0.04250544f, -0.21894680f, -0.09613805f, 0.04500590f, -0.07600871f, 
    0.24035373f, 0.08525789f, -0.00342727f, 0.06926043f, -0.16906542f, -0.08750626f, 0.17322521f, 0.10475413f, 
    0.18966663f, 0.03261337f, 0.06632011f, 0.27041715f, 0.11911383f, 0.04802296f, 0.06602712f, -0.05998902f, 
    -0.00654249f, 0.18858343f, -0.09606534f, -0.11688785f, -0.07504324f, -0.02849518f, 0.13228865f, 0.10675094f, 
    -0.00410803f, -0.08634905f, -0.02966415f, 0.05923273f, -0.22346111f, -0.17244095f, -0.07270665f, -0.19868603f, 
    0.04196023f, 0.29803565f, 0.17612876f, 0.06228007f, -0.01213409f, 0.17005230f, -0.19956410f, 0.24588154f, 
    0.15851611f, -0.06514142f, 0.06274059f, 0.15066604f, 0.01327089f, -0.17327473f, -0.10414003f, -0.06559008f, 
    -0.01057801f, -0.31552714f, -0.10332026f, 0.08433731f, 0.01309508f, 0.02106696f, -0.04451120f, -0.01537506f, 
    -0.44953471f, 0.11131065f, -0.10701279f, -0.20132069f, 0.09795187f, 0.00891875f, -0.12952738f, 0.03334954f, 
    -0.12557618f, -0.09267215f, 0.02855730f, -0.27823609f, -0.27798909f, 0.38688713f, -0.03464058f, 0.18195538f, 
    0.07654018f, 0.03151863f, -0.08378960f, -0.04091193f, -0.05933031f, 0.07093537f, 0.00953532f, 0.00098150f, 
    0.01389180f, -0.10841177f, -0.07730184f, 0.07896569f, 0.05216548f, 0.14265433f, 0.13342398f, 0.08729213f, 
    0.14088976f, 0.00264075f, 0.01293072f, 0.09704442f, 0.06490921f, -0.03238882f, -0.13449576f, -0.20740266f, 
    0.01043117f, -0.18956013f, 0.05395614f, -0.06765931f, -0.14562143f, 0.02269484f, -0.19157006f, -0.19793975f, 
    0.00823219f, 0.02918131f, -0.03656898f, 0.18506970f, 0.03081560f, 0.00544923f, 0.19007887f, 0.12983988f, 
    0.04852292f, 0.09331419f, 0.02441184f, 0.10759086f, -0.07552132f, -0.02684001f, -0.02992475f, -0.22813191f, 
    -0.04173548f, -0.04960489f, -0.09986472f, -0.05285047f, 0.00616478f, 0.21719271f, 0.22752710f, 0.13085943f, 
    -0.09260547f, 0.26176259f, 0.17444432f, 0.10965687f, -0.01403236f, -0.08477712f, 0.14870286f, 0.06244835f, 
    -0.06093433f, 0.00355213f, -0.07631142f, -0.07029291f, 0.09330764f, 0.19088891f, 0.11826875f, 0.16546486f, 
    0.01966134f, 0.08248129f, 0.13057967f, 0.14085582f, 0.21313334f, 0.31958383f, 0.12322421f, 0.08575905f, 
    -0.31532606f, 0.09036203f, 0.05500435f, 0.07750697f, 0.17499393f, -0.02236682f, -0.13947332f, 0.02827198f, 
    0.12193399f, -0.09875485f, 0.26126981f, 0.21113667f, 0.04519611f, 0.09971539f, 0.21552409f, 0.08233978f, 
    -0.03400536f, 0.07719065f, 0.08019407f, 0.13466080f, 0.17191385f, 0.03743888f, 0.10287949f, 0.13655998f, 
    -0.16368011f, -0.08641377f, -0.15753528f, 0.03363663f, -0.09840128f, -0.16567343f, 0.08498236f, 0.12725376f, 
    -0.26354501f, -0.16577974f, -0.12678489f, -0.12066419f, -0.04731483f, 0.15813017f, 0.08685190f, -0.11378040f, 
    -0.13674757f, -0.00677819f, -0.09584752f, -0.05679473f, 0.04192073f, 0.01092664f, -0.02355037f, 0.10685917f, 
    0.03128681f, 0.03109477f, 0.33284673f, 0.12786320f, 0.18462229f, 0.06595129f, -0.17970873f, -0.03391407f, 
    0.01654394f, 0.09091809f, 0.05270553f, 0.16727261f, -0.17153354f, 0.35086989f, -0.06776140f, -0.16176546f, 
    -0.02501807f, -0.02540044f, -0.21534993f, 0.05225737f, 0.02229674f, 0.00514107f, 0.10376950f, 0.01271200f, 
    -0.16875252f, -0.04031287f, -0.34628624f, 0.06836578f, -0.14406277f, 0.11516241f, -0.05333116f, 0.28842792f, 
    0.10573807f, -0.14870644f, -0.05865868f, 0.07590348f, -0.12034771f, -0.15227182f, -0.03422587f, -0.06188332f, 
    -0.07302831f, -0.18750124f, -0.17736997f, -0.18250352f, -0.05055063f, 0.07537600f, -0.01630210f, -0.29356954f, 
    -0.09509400f, 0.04730975f, 0.33502257f, 0.21010312f, -0.09058495f, -0.06191840f, 0.05963812f, 0.06515128f, 
    0.02950213f, 0.04430671f, 0.18617883f, -0.03153453f, 0.05866913f, 0.13413873f, 0.13086736f, -0.20511714f, 
    -0.13256925f, -0.07194667f, -0.08671540f, -0.07058387f, 0.04846056f, 0.23813999f, -0.03971716f, 0.06280226f, 
    -0.14013027f, 0.06144881f, 0.09701782f, 0.17811762f, 0.17857400f, 0.09348702f, 0.04868781f, -0.01675616f, 
    0.00306667f, 0.03684941f, -0.04458928f, 0.09818316f, -0.07440672f, -0.17558725f, 0.12087312f, 0.07125365f, 
    -0.10805627f, -0.16950417f, -0.15766546f, -0.00920283f, 0.09266029f, -0.11296473f, 0.19392747f, 0.32334563f, 
    -0.06561189f, 0.15362288f, -0.14175417f, -0.27119648f, -0.07913810f, -0.16392262f, -0.05443042f, 0.23075424f, 
    0.16337743f, -0.06446336f, 0.00968705f, -0.07073119f, 0.01806050f, 0.08185717f, 0.06772862f, 0.11143564f, 
    0.09062389f, 0.01923432f, 0.07694469f, 0.09348112f, 0.00455322f, 0.13434310f, 0.00113381f, -0.13303667f, 
    0.09027143f, -0.30740717f, 0.02982836f, 0.12645435f, 0.06099348f, 0.22748755f, 0.09555265f, 0.14704382f, 
    -0.16652498f, -0.02642616f, 0.02407612f, -0.08415852f, 0.27471304f, 0.10641456f, -0.26327029f, 0.07750044f, 
    -0.02745188f, -0.02072129f, 0.12283642f, 0.09833020f, -0.09909724f, -0.14275786f, -0.11525837f, -0.41259536f, 
    -0.22495329f, -0.04565893f, 0.13530105f, 0.37792185f, 0.02225949f, 0.01952049f, -0.12285943f, -0.14391267f, 
    -0.03827140f, -0.15112561f, 0.01027792f, 0.18309346f, 0.09233380f, 0.17275073f, 0.20067370f, 0.00740944f, 
    -0.07677254f, 0.14086433f, 0.03162886f, -0.02914475f, 0.20091337f, 0.18598759f, 0.21582070f, 0.10945801f, 
    -0.01819863f, -0.15383960f, 0.25064534f, 0.09180061f, 0.11024830f, 0.23559542f, 0.00556382f, -0.00372534f, 
    -0.12745085f, 0.00313268f, 0.13303643f, -0.04384224f, 0.10834561f, 0.08939917f, -0.06843591f, -0.14384089f, 
    -0.07086507f, -0.06875638f, -0.04495785f, -0.04458366f, -0.11560152f, -0.17906241f, -0.03762627f, -0.16507669f, 
    -0.33171695f, -0.02944495f, -0.14294496f, -0.23290926f, 0.09215467f, -0.01009801f, 0.18178183f, 0.20846896f, 
    0.03733496f, 0.03862035f, 0.13980627f, 0.06393731f, -0.39379907f, 0.05788474f, -0.01996254f, 0.14117685f, 
    0.08854511f, 0.08966356f, 0.15660992f, 0.04609300f, -0.01572492f, 0.01513602f, 0.07684828f, 0.00914287f, 
    -0.00859531f, -0.02865548f, -0.09082296f, 0.19518706f, 0.00719024f, -0.21379820f, 0.06455465f, 0.06865509f, 
    0.00122538f, 0.02996901f, 0.00119721f, 0.01577416f, -0.31218940f, -0.44124439f, -0.16617474f, -0.19873488f, 
    0.02318161f, 0.05816402f, 0.05985338f, 0.04755836f, 0.01211701f, -0.02295595f, -0.00341652f, 0.02554074f, 
    0.03130208f, -0.00545425f, 0.17353657f, 0.27007455f, 0.12181552f, 0.00393596f, 0.15772919f, 0.17614301f, 
    -0.00173422f, 0.02566258f, 0.11204553f, 0.06034343f, 0.14916782f, 0.11757897f, 0.14404629f, 0.10146958f, 
    -0.06171035f, -0.05481106f, 0.24908361f, 0.06207210f, 0.22995210f, 0.09867312f, 0.13407175f, 0.15663294f, 
    -0.05589465f, 0.15363155f, 0.05096735f, 0.02989918f, -0.00940442f, -0.04061849f, 0.04705276f, 0.17718942f, 
    -0.13271311f, 0.10698670f, -0.07521448f, -0.14224167f, -0.11161597f, 0.08987329f, 0.08848486f, 0.18595296f, 
    0.08027709f, -0.06270079f, -0.09191378f, 0.15559536f, 0.03792290f, -0.07422344f, -0.21269584f, -0.13228044f, 
    -0.02082109f, 0.07660289f, 0.08770358f, 0.01992947f, -0.03754829f, -0.11600516f, -0.03632846f, 0.07655413f, 
    0.02130881f, 0.05929554f, -0.07058249f, -0.04314301f, -0.14381947f, -0.09161973f, 0.05212797f, 0.00307860f, 
    -0.14112099f, -0.01478680f, -0.09456991f, -0.06349514f, -0.09282983f, 0.02325479f, 0.06297214f, -0.01939382f, 
    0.24462421f, 0.00682104f, -0.18472116f, -0.15587790f, -0.08016691f, -0.01713851f, -0.05966979f, 0.06696801f, 
    0.10828742f, -0.11669730f, -0.10956417f, -0.15036678f, -0.13504495f, -0.12387565f, 0.10243103f, 0.31316432f, 
    0.13451333f, 0.02392235f, -0.09460335f, -0.01139500f, -0.06864312f, -0.09488160f, -0.15022390f, 0.03301776f, 
    -0.13811813f, 0.10305119f, 0.00972421f, -0.06043712f, 0.01566622f, 0.03140737f, -0.13876303f, -0.04710347f, 
    0.07654582f, -0.09406703f, -0.24576935f, -0.22777438f, -0.10325404f, 0.08288030f, 0.16086718f, 0.04614488f, 
    -0.07295755f, 0.03774093f, 0.09036350f, 0.05765950f, 0.09803184f, 0.07685174f, 0.03801684f, 0.13675016f, 
    0.31349304f, -0.01989979f, 0.19762242f, 0.10471004f, -0.05057986f, -0.08409678f, -0.00143268f, 0.07929809f, 
    -0.01162445f, 0.03502362f, 0.00886221f, 0.11050944f, -0.05040502f, -0.14053009f, 0.18525444f, 0.15803975f, 
    0.07184156f, 0.01532872f, 0.03073029f, -0.11164987f, -0.03901435f, 0.02582890f, -0.04379763f, -0.18038027f, 
    -0.21749258f, 0.10421833f, 0.00919933f, 0.06318872f, 0.04487837f, -0.07471678f, 0.15011083f, 0.08472382f, 
    0.01538105f, 0.09952123f, 0.06269331f, 0.02943986f, -0.11135035f, -0.01893993f, 0.25682795f, -0.28926483f, 
    0.09355659f, 0.01507872f, 0.00409898f, 0.11259583f, 0.10776352f, 0.13246821f, 0.14265101f, 0.23428626f, 
    -0.53730661f, -0.10276980f, -0.06670019f, 0.17203131f, 0.03674213f, 0.12647663f, 0.11380678f, 0.17600349f, 
    0.08086756f, 0.01064981f, 0.08682327f, 0.10636483f, -0.10701761f, 0.25706691f, 0.03698149f, -0.14574511f, 
    -0.26644993f, -0.07288813f, -0.00368610f, 0.00590854f, 0.21474446f, 0.17127883f, 0.24702738f, 0.12399010f, 
    0.07205651f, -0.14331093f, 0.21551685f, 0.06712194f, -0.10324756f, 0.24094491f, 0.17586944f, 0.09011578f, 
    0.07834966f, 0.06569794f, 0.20339568f, 0.16958392f, 0.11500879f, 0.00882893f, 0.08719634f, 0.01181195f, 
    0.18051581f, 0.12009419f, 0.09318925f, 0.08462451f, 0.10221681f, -0.06476042f, 0.14069192f, 0.05641150f, 
    -0.07930322f, -0.23154023f, -0.13232259f, 0.15942615f, 0.08559213f, -0.01909385f, 0.02143720f, -0.03310882f, 
    -0.02312007f, -0.04137075f, -0.00075831f, 0.20069019f, 0.07951416f, 0.24052256f, -0.05208116f, 0.22904941f, 
    -0.03303846f, -0.02075340f, 0.02237194f, -0.00943924f, 0.09548146f, 0.06422821f, 0.01998080f, 0.00570718f, 
    -0.36940014f, -0.22160015f, -0.16747855f, -0.15822592f, 0.16162786f, 0.14049181f, 0.06364939f, -0.07833699f, 
    0.13570391f, -0.07392839f, -0.11448186f, -0.02398112f, 0.08883227f, 0.08454034f, -0.19117510f, 0.07258778f, 
    -0.00732187f, 0.06355444f, -0.19134665f, 0.03962187f, -0.11549632f, -0.04544651f, -0.09632561f, 0.02458995f, 
    -0.07978992f, -0.21109568f, -0.35644704f, 0.19346544f, -0.17742732f, 0.00015460f, 0.00045075f, 0.10135960f, 
    -0.10125661f, -0.12486394f, 0.04466088f, -0.16783112f, -0.05312681f, 0.06808293f, 0.07985840f, 0.15018959f, 
    0.04621587f, 0.06825109f, 0.02202627f, 0.07502929f, 0.22467491f, 0.17022561f, 0.04384059f, 0.09336458f, 
    0.27540061f, -0.22696023f, -0.01193975f, 0.11585838f, 0.05966478f, -0.03831014f, 0.00439346f, -0.09371605f, 
    -0.17298102f, -0.00863182f, -0.05488718f, 0.01996042f, -0.38113692f, -0.36731628f, -0.25666735f, 0.05955517f, 
    0.11135396f, 0.06654209f, 0.00603462f, -0.04156297f, 0.00168554f, -0.06843645f, 0.01876998f, 0.07253189f, 
    0.25605148f, 0.38273767f, -0.23495357f, 0.07978317f, 0.01995974f, 0.01912047f, 0.03678817f, -0.33863392f, 
    0.03062667f, 0.06042830f, -0.05887412f, -0.10570639f, -0.08858885f, 0.24971506f, 0.13728657f, 0.04775338f, 
    0.15773545f, 0.12977141f, -0.16196698f, 0.01056768f, -0.30060905f, -0.01120985f, -0.04473998f, -0.16033846f, 
    0.20183638f, -0.22393185f, -0.13197164f, 0.23901014f, 0.04707806f, 0.03817747f, -0.06942393f, -0.13577512f, 
    -0.15120442f, 0.14124280f, -0.05084591f, 0.07924139f, 0.05257193f, 0.17224318f, 0.13963865f, 0.19717874f, 
    0.13731812f, -0.03004174f, 0.00206636f, 0.06559131f, 0.09862575f, 0.12424867f, 0.00507016f, 0.10638495f, 
    0.18120633f, 0.07321098f, -0.21862400f, -0.12945846f, -0.00193378f, 0.01596131f, 0.06111424f, -0.06430562f, 
    -0.08433730f, 0.05905811f, -0.11604039f, -0.02879419f, 0.25805053f, 0.03786535f, 0.11434888f, 0.40049016f, 
    0.06809887f, -0.17785347f, -0.07390165f, 0.03513188f, -0.07680421f, -0.00518368f, 0.11949313f, 0.09098414f, 
    -0.18274878f, -0.05644077f, 0.14190057f, -0.01336848f, 0.03479566f, 0.01486068f, -0.05120799f, -0.06506030f, 
    -0.07243487f, 0.00416549f, 0.13678731f, 0.14206249f, -0.25531787f, 0.06521221f, -0.24497879f, 0.09054019f, 
    -0.14291413f, 0.03364227f, -0.11496177f, 0.00279277f, -0.01156014f, 0.00636506f, 0.03227073f, 0.14082001f, 
    -0.05163936f, 0.17159511f, 0.12549250f, 0.29636756f, 0.09001188f, 0.03948220f, 0.03949594f, 0.01858227f, 
    -0.00325775f, 0.00634449f, -0.05826894f, -0.31094742f, -0.04685504f, -0.30921239f, -0.13142535f, 0.07721585f, 
    -0.05108649f, 0.05335394f, 0.01635677f, 0.11614701f, -0.01185760f, -0.03577729f, 0.17360954f, 0.34253204f, 
    0.06674755f, -0.19190684f, -0.09170894f, 0.21101177f, 0.03827247f, -0.05137417f, 0.05298914f, 0.25731027f, 
    0.09703866f, -0.09525400f, -0.03468699f, -0.04212131f, -0.16748029f, -0.12032428f, -0.12602969f, 0.01406985f, 
    0.22713932f, -0.04003175f, -0.08334859f, -0.09791987f, 0.03516814f, -0.08005681f, -0.01975247f, -0.05790125f, 
    -0.02763013f, 0.07989350f, 0.00383487f, 0.04986945f, -0.00381323f, 0.06303293f, 0.00125676f, 0.00592123f, 
    0.03432134f, 0.00392663f, 0.10839620f, 0.17703012f, 0.06964792f, -0.08038800f, -0.00970528f, -0.13244422f, 
    -0.09281731f, 0.10261191f, -0.13840711f, 0.01903576f, -0.01829131f, 0.11095145f, -0.00721802f, -0.05683110f, 
    -0.09801454f, -0.00322488f, -0.01770619f, -0.16281663f, 0.05236351f, -0.11896891f, -0.01040741f, 0.17637494f, 
    -0.00646825f, 0.14768519f, 0.07013057f, -0.07822991f, 0.00491136f, 0.12036390f, -0.13341038f, -0.00671911f, 
    0.09287640f, 0.03246564f, -0.07592938f, 0.00861211f, -0.01041671f, -0.04239688f, -0.07018727f, -0.07574281f, 
    0.10056865f, -0.06856361f, -0.00032726f, 0.22122000f, -0.03311031f, 0.05588634f, -0.06899298f, 0.03141949f, 
    0.11295851f, 0.08129476f, 0.02303927f, 0.19860815f, -0.36068341f, 0.20583135f, -0.06278167f, -0.21273908f, 
    0.08650465f, 0.05173836f, 0.00837833f, -0.05462264f, -0.00466814f, -0.02997096f, -0.12192696f, -0.02269289f, 
    0.05554926f, -0.04412090f, 0.01418417f, 0.10760368f, 0.27931046f, -0.02800762f, 0.18660896f, 0.25327054f, 
    0.01911379f, 0.00558697f, -0.08345466f, 0.05689620f, 0.15452954f, 0.25073090f, 0.27537739f, 0.06879298f, 
    0.05059978f, -0.07601589f, -0.08603317f, -0.05385898f, 0.08391485f, 0.04696960f, -0.02060020f, 0.10723616f, 
    0.02866387f, 0.07890257f, 0.09337049f, -0.06047812f, -0.03393921f, 0.00643216f, -0.01599788f, -0.16180326f, 
    -0.15123025f, 0.00712206f, -0.08565035f, -0.00445900f, -0.25669885f, -0.33564568f, -0.18137814f, -0.09521130f, 
    0.21009530f, 0.06269185f, -0.05059078f, -0.00575975f, 0.20820595f, 0.22287317f, 0.03146958f, 0.12684114f, 
    0.19594552f, 0.12077868f, 0.41875044f, 0.35462782f, 0.10160088f, -0.05923291f, 0.08572644f, 0.01840129f, 
    -0.07776887f, 0.05572923f, 0.05495034f, 0.01886938f, 0.00125651f, 0.45161468f, -0.05894372f, 0.05358397f, 
    -0.07835603f, -0.20847110f, -0.20521691f, -0.27008301f, -0.09913471f, -0.08777177f, -0.21658042f, -0.16363108f, 
    -0.16076961f, -0.13672416f, -0.15765309f, 0.06832945f, -0.12672123f, 0.04293472f, -0.10472571f, 0.02399819f, 
    0.00412615f, -0.07693020f, -0.13572763f, -0.08646439f, 0.12760565f, 0.05998437f, -0.24337387f, 0.08089858f, 
    0.02745511f, -0.13409844f, -0.19939110f, -0.14155865f, -0.15540215f, -0.20466265f, -0.25106674f, -0.07659467f, 
    -0.13333248f, 0.16661608f, 0.13134706f, 0.08464792f, 0.02007721f, -0.02174089f, -0.05885812f, 0.03748859f, 
    0.06450167f, -0.01651763f, 0.01388604f, 0.16197595f, 0.09123809f, 0.15002713f, 0.12592222f, 0.05427141f, 
    -0.00253116f, 0.05025487f, 0.02921258f, -0.00257201f, 0.15191990f, -0.05850407f, -0.10648891f, 0.02648450f, 
    -0.11853567f, 0.20865068f, 0.10635392f, 0.40337643f, 0.03233721f, 0.26368120f, 0.13249595f, 0.03479004f, 
    0.15718906f, -0.10266090f, -0.00272889f, -0.16942832f, -0.24328735f, 0.23759089f, -0.04184283f, 0.06952554f, 
    0.01036394f, 0.05191012f, 0.11302973f, -0.04887801f, 0.32683682f, 0.04747691f, 0.07635677f, 0.07318749f, 
    -0.25582907f, 0.27975708f, -0.00798514f, -0.13512824f, -0.09507409f, -0.06386269f, -0.20751128f, -0.00900782f, 
    -0.17201762f, -0.04873681f, 0.03502669f, 0.11503571f, 0.09452906f, 0.13242325f, -0.04890135f, 0.02662978f, 
    0.04247632f, 0.00563679f, -0.01381462f, -0.06206815f, -0.02031577f, 0.00646591f, -0.08974151f, -0.25886294f, 
    0.12598142f, 0.00434704f, 0.16065651f, 0.09586385f, 0.17669205f, 0.10395497f, 0.06647231f, 0.04933988f, 
    0.01729947f, 0.12267613f, 0.08325122f, -0.01225049f, -0.01844739f, -0.24061646f, -0.21460734f, -0.17212684f, 
    -0.04624664f, -0.03510755f, -0.05884455f, -0.00340196f, 0.18797453f, 0.13951853f, 0.14989142f, 0.17697629f, 
    -0.34330353f, 0.02364949f, -0.09310461f, -0.00720677f, 0.08343959f, 0.15388224f, 0.00085656f, 0.09228589f, 
    -0.02173998f, -0.32519454f, -0.10477508f, -0.16883692f, -0.38581637f, -0.29247910f, 0.04444734f, 0.22654803f, 
    0.07253633f, -0.02035457f, 0.01035193f, -0.05382217f, -0.02977017f, -0.08158398f, -0.03853057f, 0.17366475f, 
    0.12103965f, -0.15697676f, 0.16721071f, 0.36435384f, 0.09244706f, -0.17629035f, -0.02085296f, -0.03393724f, 
    0.05236458f, -0.05236879f, 0.02350977f, 0.18258396f, -0.18469122f, -0.51014602f, 0.01860599f, 0.19109505f, 
    0.16253196f, 0.07375901f, 0.33296138f, -0.11197860f, 0.02060753f, -0.06825910f, -0.24756265f, -0.02231668f, 
    -0.04742733f, -0.08993630f, 0.06301597f, 0.17242974f, 0.04557931f, 0.14865360f, 0.09646448f, 0.17074285f, 
    -0.03635589f, 0.00507631f, -0.02271913f, -0.05173628f, 0.17675799f, 0.17182638f, 0.00172876f, 0.12566981f, 
    -0.01246834f, -0.13003382f, 0.01492076f, -0.08353073f, -0.06101574f, -0.02364722f, 0.04697525f, -0.00955436f, 
    -0.27965263f, -0.22206703f, -0.06622951f, -0.10745384f, 0.11508504f, 0.01771644f, 0.16596967f, -0.00633796f, 
    0.01837613f, -0.06367825f, -0.12505268f, 0.12287284f, -0.03122925f, -0.09709610f, 0.12263418f, 0.01786005f, 
    0.05215896f, 0.01308223f, -0.01718510f, 0.11788580f, 0.01519599f, 0.07517183f, -0.00072543f, 0.08075897f, 
    -0.09359323f, -0.13178653f, -0.15697189f, 0.28145912f, -0.02193023f, 0.03380630f, 0.05827311f, -0.13871607f, 
    -0.02451325f, -0.05353390f, -0.12939037f, 0.09683890f, -0.16369168f, 0.17555703f, -0.43628448f, -0.06452638f, 
    -0.13141418f, 0.00135914f, -0.18057998f, -0.14830865f, -0.00865385f, 0.08791179f, 0.22016621f, 0.01518477f, 
    -0.07857978f, -0.10597804f, -0.26636755f, -0.12999651f, -0.06251705f, 0.03683218f, -0.05873231f, -0.02841772f, 
    0.12701757f, 0.17168012f, 0.04580939f, 0.14112017f, -0.08635456f, 0.04615178f, 0.10912985f, 0.20655783f, 
    0.02411170f, -0.02764121f, 0.04872965f, 0.09580769f, 0.14690590f, -0.06403875f, 0.10876586f, -0.06580953f, 
    -0.25003946f, 0.02459899f, 0.13496280f, 0.31125391f, -0.04780686f, -0.00379577f, 0.04380003f, -0.02252116f, 
    0.05087443f, 0.01262510f, 0.07782941f, 0.20980638f, 0.11628989f, 0.03282003f, -0.03453837f, -0.02869995f, 
    -0.03037046f, 0.00981943f, -0.05028320f, 0.15681674f, 0.03355600f, 0.06064839f, -0.01763690f, 0.02762050f, 
    -0.23620178f, 0.47163284f, -0.42991281f, -0.00436375f, -0.05949736f, -0.01202836f, -0.12902108f, -0.16880558f, 
    0.04098268f, -0.11169744f, 0.07533150f, 0.08582303f, -0.20223145f, -0.01435415f, 0.13156070f, 0.35399944f, 
    0.16195738f, -0.00127745f, 0.05177690f, 0.03002341f, 0.01215047f, 0.00123561f, -0.07395817f, 0.06409838f, 
    -0.09379854f, -0.00094956f, 0.18827006f, 0.32624927f, 0.08180519f, -0.09400047f, -0.01423272f, -0.00615846f, 
    0.04470302f, 0.03597889f, -0.04165328f, 0.02540991f, -0.19542003f, -0.01597136f, 0.16683923f, 0.11040378f, 
    0.09753914f, -0.05271563f, -0.11240849f, 0.00981282f, 0.09736939f, -0.16403663f, -0.08090855f, -0.12707162f, 
    -0.20878230f, -0.08754491f, 0.06536496f, 0.03233255f, 0.06327341f, -0.05396835f, -0.18947750f, -0.11798854f, 
    -0.27592301f, 0.05701793f, 0.00651938f, -0.00867801f, 0.21527256f, 0.11529339f, 0.31634590f, 0.13918562f, 
    0.03029804f, -0.16097270f, 0.01366329f, -0.07277998f, 0.00209739f, 0.00313361f, 0.03687082f, -0.04232997f, 
    0.22374696f, 0.04793870f, -0.17161947f, 0.00567058f, 0.07437913f, 0.03883436f, 0.06538972f, 0.08963521f, 
    0.02187488f, -0.04129587f, -0.05229260f, -0.31042337f, -0.14338847f, 0.03380764f, 0.22958925f, -0.05944866f, 
    0.12907575f, 0.11430272f, -0.03246159f, 0.16566935f, 0.10650016f, -0.05746465f, -0.13187887f, -0.14555763f, 
    0.00866667f, -0.00717331f, -0.02883205f, 0.02883871f, -0.01761205f, -0.00990497f, -0.01659782f, -0.03133807f, 
    -0.00133466f, 0.02641035f, -0.02403590f, 0.02015225f, 0.03288429f, -0.03755173f, 0.03413237f, 0.01640503f, 
    0.00529124f, -0.00047469f, 0.01261072f, -0.01539143f, 0.00124091f, -0.00748011f, -0.02547568f, -0.01401647f, 
    -0.03379905f, -0.00559656f, -0.02129963f, -0.02799628f, -0.03260541f, -0.01629070f, -0.00545938f, 0.02202805f, 
    0.01248732f, 0.01803773f, -0.01531945f, -0.00686415f, 0.02223510f, -0.04018461f, 0.02716421f, -0.00565373f, 
    0.00441913f, 0.03251088f, -0.03920613f, -0.02960642f, 0.00312696f, -0.02402808f, -0.00082405f, -0.03264157f, 
    0.01936404f, 0.02294735f, 0.01288026f, -0.02271356f, -0.01286143f, -0.01592639f, -0.00753963f, 0.03474331f, 
    0.01625872f, 0.00608259f, 0.02420772f, 0.00104921f, 0.02085871f, -0.00527882f, 0.02354842f, -0.00162864f, 
    0.01518044f, 0.03170368f, 0.00724604f, 0.01976416f, 0.02646339f, 0.02690176f, -0.03659178f, 0.02318077f, 
    0.02682695f, 0.01118825f, 0.02764045f, 0.02153964f, -0.01470866f, 0.03008296f, 0.00732827f, 0.00647009f, 
    0.01642791f, 0.00987115f, -0.01605234f, 0.01892279f, -0.04719809f, 0.01897672f, -0.03075245f, -0.00833684f, 
    0.02662884f, -0.02227199f, -0.02711816f, 0.00361735f, -0.02626934f, -0.01831812f, -0.02702920f, -0.01736783f, 
    0.01998086f, 0.00500181f, -0.00803068f, -0.03215339f, -0.03964217f, -0.04059580f, 0.00876398f, -0.02087955f, 
    -0.00859938f, 0.02491921f, 0.00991745f, -0.01281896f, 0.01156840f, -0.00586196f, 0.00565930f, 0.03457060f, 
    0.01519247f, -0.01809128f, 0.00113630f, -0.02222663f, -0.01088161f, 0.02296636f, -0.02755564f, -0.02126020f, 
    0.00723081f, 0.02474845f, 0.01922413f, -0.02482621f, 0.02775177f, -0.00015036f, -0.00119667f, 0.00416822f, 
    0.02052595f, -0.01414523f, 0.00437307f, -0.02167593f, 0.03062855f, 0.03306931f, 0.02664129f, 0.00662160f, 
    0.01566111f, 0.00397300f, 0.00319153f, -0.03294400f, 0.02631610f, 0.02880882f, 0.02588814f, -0.02859895f, 
    -0.00325810f, 0.02683154f, -0.02190027f, 0.01629016f, 0.01903106f, -0.01263061f, -0.00717211f, -0.02215911f, 
    0.03010773f, -0.03491746f, 0.00511508f, -0.03244057f, -0.00397353f, -0.03525542f, 0.02732087f, -0.01099152f, 
    0.00545635f, -0.01901560f, -0.02416816f, 0.01636868f, 0.01847877f, -0.03394424f, -0.01767246f, -0.02956169f, 
    -0.03240283f, -0.03474766f, -0.03299697f, -0.00518617f, -0.01800609f, 0.00725855f, -0.02523234f, -0.00294924f, 
    0.01284247f, -0.00619504f, -0.02723842f, -0.01288687f, 0.01950417f, -0.01545191f, 0.00474419f, -0.02313573f, 
    -0.00365514f, 0.01059292f, 0.00863034f, 0.02040171f, -0.00970153f, 0.00016936f, 0.02915698f, 0.03308272f, 
    0.00347336f, -0.01355156f, -0.03067457f, 0.02201277f, 0.01406527f, -0.01393574f, 0.00618186f, 0.00792602f, 
    0.00011765f, 0.02123808f, -0.01020246f, 0.01808803f, -0.02413127f, 0.00803852f, -0.00932365f, 0.03535897f, 
    -0.01454828f, -0.01240598f, 0.03005251f, -0.01138929f, 0.02289505f, -0.00618881f, -0.00908063f, -0.00150848f, 
    -0.00116499f, 0.01492913f, 0.01606545f, 0.01123681f, 0.00820352f, 0.01486932f, -0.02146666f, 0.01249275f, 
    -0.03595361f, -0.03164220f, -0.04001505f, -0.01308942f, -0.02286386f, -0.01094066f, 0.01459327f, 0.00996672f, 
    -0.03718124f, -0.02843178f, -0.01475974f, -0.03264226f, -0.02711774f, -0.00235846f, 0.02903527f, 0.00797188f, 
    0.00678515f, -0.02823309f, -0.01140852f, -0.01893372f, 0.01846665f, 0.02390869f, -0.01466543f, 0.01221812f, 
    -0.02207885f, 0.03006604f, -0.01931693f, 0.03247347f, 0.00323208f, 0.01968721f, 0.01161720f, 0.01824862f, 
    -0.01915765f, -0.03914962f, 0.01790347f, 0.02554995f, -0.02615333f, -0.03610134f, -0.01701552f, 0.02535624f, 
    0.01826775f, -0.00408598f, 0.00777194f, 0.02860050f, -0.00745851f, 0.00848102f, -0.00737130f, 0.02613720f, 
    -0.03369486f, -0.01954095f, -0.00011432f, 0.02534976f, -0.01028067f, -0.04477799f, -0.00574690f, -0.03115260f, 
    -0.03568307f, -0.01102964f, 0.02616100f, -0.02366566f, 0.00327650f, -0.00993806f, -0.02187660f, -0.00945296f, 
    -0.00914501f, -0.00261911f, 0.01535332f, 0.02474553f, 0.01560152f, 0.01568676f, 0.02172912f, -0.03365489f, 
    -0.03644947f, 0.01886353f, 0.00391298f, 0.00641051f, -0.00257784f, 0.01002026f, -0.00378208f, -0.01432338f, 
    -0.01399789f, -0.01994757f, 0.00223618f, -0.00070788f, 0.02716446f, -0.02950272f, 0.01850342f, -0.03445603f, 
    -0.01569283f, -0.03680911f, 0.02944041f, 0.01401066f, 0.01982559f, 0.02775530f, 0.00798073f, -0.03403172f, 
    0.00137977f, 0.03423984f, -0.00288815f, -0.02791054f, -0.00208793f, 0.02777686f, -0.01378707f, 0.01844330f, 
    -0.01777831f, -0.02423817f, -0.01610663f, 0.01885861f, -0.03813668f, 0.01345354f, 0.00024585f, 0.01150142f, 
    -0.02886907f, -0.01495657f, 0.01501773f, 0.02825886f, 0.01570708f, -0.04681423f, 0.02664004f, -0.02742805f, 
    -0.01913615f, -0.00232583f, 0.00810677f, -0.02682495f, 0.00243363f, 0.02634083f, -0.02079988f, 0.02909923f, 
    -0.03032452f, 0.03105934f, -0.00011977f, -0.03202213f, -0.01637042f, 0.01938128f, 0.00971929f, -0.04288279f, 
    -0.01599218f, 0.00103263f, -0.02163693f, 0.00503231f, 0.00032627f, -0.00011820f, -0.01504178f, 0.02818926f, 
    -0.02489970f, 0.01063428f, 0.01030383f, -0.04035084f, -0.01146195f, 0.00018584f, -0.02103750f, -0.02749063f, 
    0.02075184f, -0.03860315f, 0.01900555f, -0.02529366f, 0.01431456f, 0.00172322f, -0.02563952f, -0.02446854f, 
    0.03563302f, -0.01572902f, -0.02323814f, 0.02312875f, 0.03737941f, -0.01777740f, 0.02686624f, -0.02392845f, 
    0.00528774f, -0.02554750f, 0.02978222f, -0.00579429f, 0.01332611f, -0.00717478f, -0.00503857f, -0.00504404f, 
    -0.01674100f, 0.01770558f, 0.03087409f, 0.01600536f, -0.03783971f, -0.03900293f, -0.00643016f, -0.01899959f, 
    0.00956621f, 0.02031022f, 0.02129360f, 0.00568040f, 0.02232589f, -0.00525454f, 0.00224888f, -0.01477923f, 
    0.01532577f, 0.02289630f, -0.03663379f, -0.03467549f, 0.03275280f, 0.03114738f, 0.03127389f, -0.02879875f, 
    -0.02898245f, -0.00868953f, -0.03607879f, 0.00560829f, 0.00013354f, -0.02884629f, -0.00105638f, 0.00662784f, 
    0.00193611f, 0.00673929f, 0.01162249f, -0.02016101f, -0.00060658f, -0.00649263f, -0.00743038f, -0.01477157f, 
    -0.01890877f, -0.02457926f, 0.01156980f, -0.02309209f, -0.03231321f, -0.02208494f, -0.02708045f, 0.01521070f, 
    -0.02865652f, 0.01717546f, -0.00174846f, -0.03655665f, 0.00470179f, -0.00830576f, 0.01074464f, 0.01796428f, 
    -0.01919395f, -0.03382481f, 0.01137655f, -0.00313440f, 0.01344399f, -0.04454611f, 0.02499558f, 0.02250113f, 
    -0.04623312f, 0.02033060f, -0.00568758f, -0.02337894f, -0.01882705f, -0.01241456f, -0.03203232f, 0.02800279f, 
    0.02483449f, 0.01917395f, -0.04277200f, -0.01797044f, -0.03108191f, -0.02613842f, -0.03580010f, -0.00728913f, 
    0.01840388f, 0.00003062f, -0.00178649f, -0.00791094f, -0.00662693f, -0.00548672f, 0.00736587f, -0.02437834f, 
    0.01900491f, -0.01561277f, -0.01633215f, -0.02472440f, -0.01178714f, 0.01578095f, 0.02314541f, -0.02765525f, 
    0.00951915f, -0.00544374f, -0.01335565f, 0.03169483f, -0.04253909f, -0.02477593f, -0.02581903f, -0.01838059f, 
    -0.00051849f, -0.00191038f, -0.01787591f, 0.01282042f, -0.01750347f, 0.01684448f, 0.02478340f, 0.02619061f, 
    -0.02072726f, -0.04497202f, 0.00407631f, 0.02769932f, -0.03984344f, -0.01368115f, -0.00431265f, 0.01693524f, 
    0.02181577f, 0.03240759f, -0.03345975f, -0.00844069f, 0.01645403f, -0.02436294f, -0.01924928f, -0.02600327f, 
    -0.01334618f, -0.03412142f, -0.02496656f, 0.03465391f, 0.00890990f, -0.00583301f, 0.01992115f, 0.02346558f, 
    0.03397216f, 0.01015279f, -0.03803543f, -0.02385032f, -0.01429099f, 0.02053207f, -0.00356687f, -0.02678710f, 
    -0.02642490f, 0.02105122f, -0.03580130f, 0.03226296f, -0.03307155f, 0.00204623f, -0.01965089f, 0.00620105f, 
    0.01227119f, -0.01038691f, -0.02885532f, -0.01186041f, 0.00363370f, 0.01615276f, 0.02598293f, 0.02107151f, 
    0.01828762f, -0.00634276f, 0.02383630f, -0.00138958f, -0.01160246f, -0.03570129f, 0.01763720f, -0.02304927f, 
    0.01508487f, -0.02963116f, 0.02137046f, -0.00544177f, -0.02169389f, 0.02675468f, -0.02062880f, 0.02193437f, 
    -0.00799555f, -0.00006945f, -0.04386808f, 0.00523487f, -0.02992687f, 0.01439105f, 0.00095571f, -0.02952539f, 
    0.00872214f, -0.03640095f, -0.01113702f, -0.02790230f, -0.02984684f, 0.01932052f, -0.03186574f, 0.00647640f, 
    -0.02383599f, 0.00525392f, -0.00068196f, -0.01200338f, -0.01748583f, 0.02320033f, 0.00625863f, 0.02037766f, 
    0.02014807f, 0.02857945f, 0.00800354f, 0.01176998f, -0.02672879f, -0.01237878f, 0.01570523f, -0.02206063f, 
    0.01501517f, -0.02876281f, 0.02995577f, -0.02236789f, 0.00137621f, -0.04128109f, -0.03835386f, 0.01903933f, 
    0.02296232f, -0.02305373f, -0.01290523f, -0.01567175f, -0.02649606f, -0.00244479f, 0.01158612f, 0.01034376f, 
    -0.01021729f, 0.00592739f, 0.01940637f, -0.01263786f, -0.03229143f, 0.01216445f, -0.02765474f, -0.01678774f, 
    -0.02903275f, -0.01933916f, -0.03495840f, -0.01976879f, -0.01109455f, -0.01963698f, 0.02941578f, -0.03903448f, 
    -0.01501687f, -0.02046720f, -0.00207136f, 0.00636742f, 0.00232417f, -0.02377580f, -0.01005548f, 0.01686627f, 
    -0.01919729f, -0.01895550f, 0.03829822f, 0.03428641f, 0.00747074f, -0.04084594f, 0.02679267f, 0.01812600f, 
    0.00638632f, -0.03530224f, 0.00531318f, 0.00168717f, -0.03118890f, 0.00170661f, -0.02397591f, -0.00338757f, 
    -0.02263934f, 0.02798949f, 0.03039354f, -0.03786974f, 0.00262010f, -0.02597478f, 0.00800062f, -0.00542384f, 
    0.01698991f, -0.00108947f, -0.01500554f, 0.01268709f, -0.00828939f, -0.00991791f, -0.03716740f, -0.01492166f, 
    0.03581645f, -0.01906653f, -0.03991674f, -0.01971995f, -0.04095411f, 0.02534374f, 0.01060506f, -0.01704250f, 
    0.00827264f, -0.01707980f, -0.04006965f, 0.01853232f, -0.02827408f, 0.00984249f, 0.01322055f, 0.02445051f, 
    0.01935692f, -0.00407232f, -0.01612092f, 0.00784901f, 0.01420109f, 0.03961633f, -0.03265827f, 0.02388749f, 
    -0.00557199f, 0.00068608f, 0.00859673f, -0.01554001f, -0.00650181f, -0.04237211f, 0.02133376f, 0.02592963f, 
    0.00504543f, -0.02716896f, 0.02221634f, 0.00125741f, -0.02654118f, -0.01238718f, 0.02229246f, -0.02096858f, 
    0.00714266f, 0.03984235f, 0.02086322f, -0.02947845f, 0.02538505f, -0.01183623f, -0.00365767f, -0.02014378f, 
    0.02880461f, -0.03435066f, -0.00369861f, 0.02407352f, 0.00245396f, 0.01254534f, 0.00843828f, -0.02718096f, 
    0.01701417f, -0.00222167f, 0.02467371f, -0.02124951f, -0.00530262f, 0.00866552f, 0.02825603f, -0.01751909f, 
    -0.01266388f, 0.03079947f, 0.03492451f, -0.03898919f, -0.03200288f, 0.02183191f, -0.01043676f, -0.02388664f, 
    0.01138094f, 0.00139604f, -0.00058699f, -0.00835360f, 0.01009611f, 0.00073368f, -0.03563645f, 0.00395963f, 
    -0.00558676f, -0.03477708f, 0.01253026f, 0.00942351f, -0.00222127f, 0.03140284f, 0.02609332f, -0.00352906f, 
    -0.34090281f, 0.09409302f, 0.20264731f, 0.15365744f, -0.14811800f, -0.16374545f, -0.06802143f, 0.08813000f, 
    -0.01890061f, 0.01235400f, -0.01622872f, -0.07600112f, -0.05808161f, -0.07421800f, -0.04099172f, -0.20097393f, 
    0.31553787f, 0.01644991f, -0.04194801f, 0.00537766f, 0.00594386f, -0.02804096f, -0.03301807f, 0.11118641f, 
    -0.08462095f, -0.07003972f, -0.01084066f, -0.15608396f, -0.08609253f, 0.00074310f, -0.05518787f, -0.00032033f, 
    -0.18006195f, -0.15810812f, -0.03981624f, 0.00734173f, -0.20256901f, -0.25161806f, 0.07097332f, -0.09054258f, 
    0.00500966f, 0.02223821f, -0.07390503f, -0.12126230f, 0.08779877f, 0.05680855f, 0.08723178f, 0.06687361f, 
    -0.01211791f, 0.06285387f, -0.22014987f, 0.19471261f, 0.02369046f, 0.02179909f, 0.04195927f, 0.13413543f, 
    -0.10476507f, -0.03918433f, -0.04766161f, -0.01508076f, 0.03572385f, 0.12354972f, 0.06951909f, 0.02842296f, 
    0.12978038f, 0.02437989f, 0.03037998f, 0.01221218f, 0.08532772f, 0.06432556f, 0.15650488f, 0.13660462f, 
    0.41529462f, 0.09964123f, -0.23782524f, 0.16085882f, 0.21019629f, 0.09994213f, 0.11280999f, 0.09037483f, 
    -0.01193913f, -0.05861450f, 0.09028543f, -0.04858052f, -0.04953705f, 0.03856907f, -0.16955078f, -0.02933727f, 
    -0.04780267f, -0.08973737f, -0.01488399f, -0.02418831f, -0.11489053f, -0.18491477f, -0.09778371f, -0.12129728f, 
    0.03001116f, -0.09454336f, -0.31758001f, 0.16686732f, 0.15415476f, 0.01900075f, 0.02371158f, 0.14793104f, 
    0.03027446f, -0.00584023f, -0.04452989f, 0.01505225f, -0.22707942f, -0.15261418f, -0.12934011f, 0.03120612f, 
    0.14812410f, 0.05986411f, -0.07695485f, 0.12189928f, 0.13313296f, 0.08451565f, 0.13397345f, -0.01610094f, 
    0.20459570f, 0.11292041f, -0.09248059f, 0.38487443f, 0.13052844f, 0.21382210f, 0.07700245f, 0.07611392f, 
    -0.04502745f, 0.00054063f, 0.16877200f, 0.07753707f, -0.05413559f, 0.16129036f, 0.20692565f, -0.14339080f, 
    -0.27359298f, -0.15491787f, -0.10212573f, -0.15312196f, 0.02545468f, 0.03934008f, -0.04878227f, -0.03321208f, 
    0.14709938f, -0.27715695f, 0.10061241f, -0.00950140f, -0.25386441f, -0.05961172f, 0.07518327f, -0.03565687f, 
    0.01451707f, -0.08221712f, 0.06104926f, 0.01094145f, -0.53314912f, 0.49444309f, 0.18272285f, 0.17574066f, 
    -0.06928505f, -0.07015359f, 0.09074783f, -0.08182954f, 0.09664076f, 0.23544633f, 0.15156212f, 0.15614428f, 
    -0.08240123f, -0.08301433f, 0.13965410f, 0.34327218f, 0.06179873f, -0.03406408f, 0.09151679f, 0.10897111f, 
    0.34297252f, 0.11494090f, 0.21737459f, 0.25892889f, -0.17851125f, -0.31520030f, 0.28905585f, -0.08180931f, 
    -0.26282108f, -0.07668197f, -0.14023465f, 0.03929037f, 0.05318899f, -0.08691796f, 0.08598722f, -0.02262024f, 
    -0.21226847f, -0.23296300f, 0.15351386f, -0.17563239f, 0.19691058f, 0.13998802f, 0.14096263f, 0.03078127f, 
    0.01241124f, 0.02756573f, -0.00823188f, -0.08134881f, -0.09966280f, 0.07872596f, 0.17840366f, 0.20611690f, 
    0.08154231f, 0.04121207f, 0.02406581f, 0.12707953f, 0.18140872f, 0.06657800f, 0.16886668f, -0.10247266f, 
    -0.24691197f, 0.02450036f, 0.06334180f, -0.07556233f, 0.02098519f, -0.06927205f, -0.12562725f, -0.02858762f, 
    -0.07034991f, -0.01709816f, 0.00986251f, -0.08032012f, -0.07284977f, -0.15051302f, -0.16673844f, 0.01812931f, 
    0.00512599f, -0.02178567f, -0.01259359f, -0.02727320f, 0.01960008f, 0.04114674f, -0.05026133f, 0.04707647f, 
    -0.09369436f, -0.27544123f, 0.16241215f, 0.23303194f, 0.09222716f, 0.15340863f, 0.00194546f, -0.02839594f, 
    0.14117591f, 0.15421735f, 0.19828363f, 0.10347432f, -0.11961607f, -0.22527659f, -0.08080123f, 0.24380828f, 
    0.20077951f, 0.21974273f, 0.07373648f, 0.09556994f, 0.30946198f, -0.08609562f, 0.26589850f, 0.14922132f, 
    0.08228153f, 0.23054945f, 0.05694783f, 0.14938144f, 0.04092802f, 0.04602463f, 0.03467363f, 0.04412176f, 
    0.34326789f, 0.09949506f, 0.14108646f, 0.14569820f, 0.01235927f, -0.27766392f, -0.20063309f, -0.21430267f, 
    0.02401826f, 0.14345308f, 0.07088382f, -0.02074400f, 0.11421949f, 0.07162741f, 0.08348640f, 0.14217836f, 
    0.04189351f, -0.04195133f, -0.08698417f, -0.13195340f, -0.11622147f, 0.05677495f, 0.01894067f, 0.04259528f, 
    -0.11044049f, 0.09369780f, -0.14032006f, -0.00354998f, -0.25224495f, -0.19944336f, 0.01546990f, -0.12065982f, 
    -0.09572607f, -0.04945393f, -0.06280782f, -0.01027166f, -0.07277490f, 0.07855827f, -0.02666533f, 0.03785653f, 
    -0.26778513f, -0.36056238f, -0.27182516f, -0.35830313f, -0.27664730f, -0.25753897f, -0.01159678f, -0.27533451f, 
    -0.01666841f, -0.04443387f, -0.06597196f, 0.02453858f, -0.00589594f, 0.11708090f, 0.37268808f, 0.00557899f, 
    -0.09924041f, -0.07831678f, -0.03306162f, 0.03093913f, 0.17429432f, 0.09074035f, 0.17111291f, 0.19031887f, 
    0.24958017f, 0.01340547f, 0.11301357f, 0.01527802f, 0.16867761f, -0.17640243f, -0.03642552f, 0.20985825f, 
    0.10714631f, 0.25605470f, -0.01918695f, 0.13073771f, -0.17479390f, -0.07541297f, -0.03616315f, -0.11938690f, 
    -0.09666874f, -0.03219462f, -0.07292079f, -0.04959861f, 0.03585736f, 0.06866822f, -0.12617998f, 0.10418120f, 
    -0.24381794f, 0.36248666f, 0.31137198f, 0.13534273f, 0.00337390f, 0.00554271f, -0.11956460f, 0.12267584f, 
    -0.01248967f, 0.03146781f, -0.19141613f, 0.12379475f, -0.04373259f, -0.08818663f, 0.16006514f, -0.09566651f, 
    -0.02555811f, -0.07655738f, -0.10645222f, 0.07035875f, 0.09752916f, 0.15209164f, 0.03122937f, 0.02302521f, 
    -0.02115052f, 0.15191235f, 0.27100551f, 0.17833565f, 0.06491050f, -0.17323907f, 0.17148699f, -0.01189492f, 
    0.00167262f, -0.12202859f, -0.05650113f, -0.07275243f, -0.26254049f, -0.17102177f, -0.18026066f, 0.04382781f, 
    -0.11758158f, -0.00163163f, -0.01039649f, -0.00199479f, 0.08992916f, 0.03288323f, -0.05686754f, -0.10000106f, 
    0.10639826f, 0.14125459f, 0.06018081f, -0.04884722f, 0.02819721f, -0.01485000f, -0.04097367f, -0.00287263f, 
    0.02531621f, 0.10551209f, 0.20338088f, 0.16658743f, 0.11908212f, 0.25374144f, 0.02006615f, 0.03426430f, 
    -0.04713842f, -0.12335255f, 0.05705727f, 0.02773793f, -0.07110472f, -0.04491844f, -0.05720011f, 0.18290909f, 
    -0.11920109f, -0.05756457f, 0.22547629f, -0.22205728f, 0.28361762f, 0.19347659f, 0.03879939f, -0.08195145f, 
    0.00680042f, -0.04703047f, 0.01071741f, 0.06527855f, -0.05298908f, 0.15377530f, 0.06479253f, -0.16548583f, 
    0.11561907f, 0.01292209f, -0.02342532f, -0.05307642f, -0.15672730f, 0.14680071f, 0.06954310f, 0.30375096f, 
    -0.05571838f, 0.01722721f, -0.39182562f, 0.28427058f, 0.28721356f, 0.03376086f, -0.05999226f, 0.20640786f, 
    0.23959990f, 0.19641815f, 0.12944451f, 0.09512111f, -0.08759513f, -0.11237428f, -0.02748999f, -0.14431185f, 
    0.08215670f, -0.02458055f, -0.10144305f, 0.13284157f, 0.13180049f, -0.01397126f, 0.03372265f, 0.09596133f, 
    -0.06795324f, -0.12029244f, -0.18198492f, -0.16073219f, -0.13792209f, -0.01072511f, 0.04313765f, -0.15127970f, 
    -0.01255733f, -0.03719282f, -0.07532092f, 0.03026640f, 0.06199708f, 0.12480460f, -0.08535283f, -0.00488085f, 
    -0.03084475f, -0.02461979f, -0.02575352f, 0.02971056f, 0.27512065f, 0.35871354f, 0.26497033f, 0.17379673f, 
    0.21008071f, -0.15707685f, -0.07354585f, -0.06017759f, 0.16413122f, 0.13739273f, 0.01790679f, 0.08167934f, 
    0.03452989f, -0.02757977f, -0.00019268f, -0.03429314f, -0.31625414f, 0.04830752f, 0.29573125f, 0.15183748f, 
    -0.15471137f, -0.04286447f, -0.00294963f, -0.05049177f, -0.05300611f, 0.02808361f, 0.02905704f, -0.01653257f, 
    -0.05803514f, 0.54098308f, 0.32504806f, 0.19626629f, -0.04054878f, -0.07217763f, 0.04461426f, -0.13990414f, 
    0.13421799f, 0.20760007f, 0.03153996f, 0.16734655f, 0.11224558f, -0.10428891f, -0.17026253f, -0.00405143f, 
    0.17847669f, 0.17276961f, 0.06733643f, -0.10780942f, -0.06644395f, -0.10109910f, -0.10609731f, 0.04281252f, 
    -0.16077901f, -0.14908287f, -0.19592370f, -0.21903835f, -0.16806477f, -0.07963316f, -0.12042549f, -0.16014796f, 
    -0.00825368f, -0.00272473f, -0.00799650f, 0.10281262f, -0.25622097f, 0.14367720f, -0.09787954f, -0.15507159f, 
    0.09872380f, -0.19481166f, -0.01208367f, 0.08731891f, 0.07097922f, 0.02133661f, -0.19496936f, 0.25401279f, 
    0.24358542f, -0.09027050f, -0.03088391f, 0.07995825f, 0.04024804f, 0.16779405f, 0.03821035f, -0.10506836f, 
    0.12707242f, -0.06871502f, 0.07031392f, 0.10737452f, -0.03069903f, -0.06971663f, -0.06383319f, -0.04253749f, 
    -0.21280168f, -0.18947200f, -0.06443569f, -0.15354408f, 0.06031709f, 0.05481774f, 0.04041472f, 0.00103473f, 
    0.03488975f, -0.07803384f, 0.04457060f, 0.18140253f, -0.02261313f, 0.00436986f, -0.00113530f, 0.00403085f, 
    -0.12394950f, 0.02170020f, -0.01868396f, -0.07378339f, -0.04838891f, -0.12655397f, -0.01542734f, -0.07236101f, 
    0.01144836f, -0.07102142f, 0.06722846f, 0.04030348f, 0.17342748f, 0.15021428f, 0.15237202f, 0.11423886f, 
    0.00530011f, 0.01464650f, -0.01054998f, -0.09720145f, -0.04407052f, -0.04193950f, -0.00845638f, 0.00357841f, 
    0.20328158f, 0.38294140f, 0.25386387f, 0.08988767f, -0.25389558f, -0.16543815f, -0.04529050f, -0.32906091f, 
    -0.33331883f, -0.08285790f, -0.20822322f, -0.23431389f, 0.05400749f, -0.02414138f, 0.02287035f, 0.00463991f, 
    -0.03136375f, 0.31024259f, 0.29756027f, -0.00601514f, -0.12774347f, -0.04224392f, 0.13810503f, 0.04459859f, 
    -0.10821238f, 0.01833557f, 0.08732216f, 0.07175511f, -0.13518973f, -0.28860715f, -0.22360069f, -0.20696461f, 
    -0.15388268f, -0.03325200f, -0.03207921f, -0.10623644f, 0.07833444f, 0.18439503f, 0.02741669f, 0.00224833f, 
    0.35354912f, 0.01363248f, 0.31075463f, -0.31339628f, 0.02942152f, 0.02198694f, -0.01179154f, -0.01310544f, 
    -0.08591940f, 0.03901475f, -0.00021534f, 0.03873042f, -0.09741583f, -0.18303542f, -0.15974210f, -0.18237402f, 
    -0.09236704f, 0.03422586f, -0.16676465f, -0.10322429f, 0.12671830f, 0.06781486f, 0.06382053f, 0.17546393f, 
    -0.38556248f, 0.34769458f, 0.33343175f, 0.35243839f, 0.00019472f, -0.02331429f, 0.06685132f, 0.08306741f, 
    0.10514894f, 0.08871368f, 0.11609434f, 0.17046864f, -0.05293645f, -0.21568394f, -0.03059326f, -0.26352438f, 
    0.12225851f, 0.12261907f, 0.08424310f, -0.03495022f, 0.00452546f, 0.04207951f, -0.00102111f, 0.07968176f, 
    -0.29969576f, -0.26858774f, -0.07626309f, 0.55411512f, 0.06288954f, -0.29672366f, 0.10370685f, 0.12019973f, 
    -0.03261258f, 0.10047342f, 0.20171928f, 0.05136045f, -0.47501323f, -0.12890841f, 0.34882045f, 0.31861725f, 
    -0.03623569f, -0.05916791f, -0.11593167f, 0.07601950f, -0.00460631f, -0.04649599f, 0.07178255f, 0.18336546f, 
    0.13986748f, 0.04628350f, -0.20657608f, -0.18777497f, 0.08540221f, -0.03717062f, 0.13201076f, 0.00533894f, 
    0.04208254f, 0.00224526f, 0.04065294f, -0.06496280f, -0.15066402f, -0.26461092f, 0.05012679f, -0.16247876f, 
    0.09853166f, 0.08740862f, 0.03159695f, 0.19868003f, 0.12491179f, 0.09378539f, -0.12026097f, -0.03410581f, 
    0.05352191f, -0.26911351f, 0.00837348f, -0.01014569f, 0.11636733f, 0.05178029f, 0.00357947f, -0.03423471f, 
    -0.00734634f, 0.04791272f, -0.01272614f, 0.09266250f, 0.28856507f, -0.35216570f, 0.30179870f, 0.07363153f, 
    -0.02785478f, 0.27665070f, 0.06531522f, 0.06783863f, 0.16346748f, 0.03226914f, 0.15809487f, -0.02637650f, 
    -0.00489928f, 0.03682958f, 0.05589302f, -0.14424236f, -0.10010882f, -0.23870078f, -0.16472745f, -0.28478006f, 
    -0.27896523f, -0.02697568f, -0.11845547f, -0.10560208f, 0.00512041f, 0.19096538f, -0.08614705f, 0.33510581f, 
    -0.04291388f, -0.11594640f, -0.02347370f, -0.15784276f, 0.08664656f, 0.02424108f, 0.00783425f, -0.03672126f, 
    0.42818373f, 0.03488748f, 0.38323644f, -0.25422123f, -0.10156547f, -0.12985514f, -0.11107573f, 0.04906188f, 
    -0.01181789f, 0.15218316f, -0.06296963f, -0.07659550f, -0.35718372f, 0.03433401f, 0.02147309f, 0.06973104f, 
    -0.11041844f, -0.07535797f, 0.00863653f, -0.19212914f, 0.07561897f, 0.15773021f, 0.15591083f, 0.27186295f, 
    0.19774841f, -0.05796788f, -0.08038938f, 0.10830934f, -0.06619274f, -0.06597732f, 0.11607470f, 0.01666240f, 
    -0.05619274f, -0.06930456f, -0.00776574f, 0.01731375f, 0.13504136f, -0.02565863f, -0.04357393f, -0.27067676f, 
    -0.16556372f, -0.21989274f, -0.10328620f, -0.08228265f, -0.14592783f, -0.19985074f, -0.10219346f, -0.15419255f, 
    0.30915073f, -0.23172283f, 0.09382951f, 0.20463489f, 0.09687938f, -0.02305639f, 0.07075664f, -0.06635185f, 
    0.05530609f, 0.07094530f, 0.13249692f, -0.04816921f, -0.23736519f, 0.38552544f, -0.00788605f, -0.42581254f, 
    0.00851737f, -0.13668244f, 0.18208882f, -0.01153157f, -0.13628201f, 0.10854951f, 0.03338682f, -0.17723233f, 
    0.07698008f, 0.14347313f, 0.13243157f, 0.03270854f, -0.08260185f, 0.00962213f, -0.09679323f, -0.00967687f, 
    0.03436618f, -0.06751544f, 0.04536042f, 0.13827388f, -0.14669226f, -0.10404744f, -0.14556342f, 0.22730510f, 
    0.09506290f, 0.08011580f, 0.11139948f, -0.08766155f, -0.03609512f, 0.07930000f, -0.09454289f, -0.00552490f, 
    -0.48882523f, 0.25000301f, -0.10439268f, 0.26314694f, 0.13788180f, -0.14740472f, 0.17984322f, 0.05834869f, 
    -0.02332100f, 0.07256685f, -0.11884917f, -0.10685733f, 0.97562826f, -0.09520508f, 0.09384701f, 0.26507419f, 
    0.10794468f, 0.28815764f, 0.12064794f, 0.10825314f, -0.04821376f, 0.03870167f, 0.05060116f, 0.08847070f, 
    0.09566971f, 0.24756873f, -0.27125794f, -0.46633410f, 0.13878116f, 0.06944754f, 0.22551443f, -0.02075908f, 
    -0.00396711f, 0.24259931f, 0.10141895f, 0.02783774f, -0.02112395f, -0.03801937f, -0.31987399f, -0.03177042f, 
    0.05199155f, 0.03228460f, 0.01186242f, -0.12653397f, -0.02903964f, -0.05100231f, -0.08171486f, -0.08277547f, 
    -0.15644398f, 0.10113779f, 0.29331532f, 0.07718047f, -0.06156982f, -0.00072009f, -0.15454775f, -0.08538773f, 
    -0.15936980f, -0.03528858f, 0.04100834f, -0.02350809f, 0.28666785f, -0.15497686f, -0.02249767f, 0.01292737f, 
    0.10597446f, 0.26658627f, 0.13926411f, 0.15793897f, 0.01776919f, -0.04564587f, 0.04787492f, 0.10423347f, 
    0.01277662f, -0.27446502f, 0.01458340f, 0.21440600f, -0.05431382f, 0.14523736f, -0.14496925f, 0.02143327f, 
    0.12877832f, -0.06059599f, -0.01539566f, -0.06949072f, 0.08223147f, 0.06380505f, 0.02978870f, -0.25579724f, 
    -0.07145711f, -0.06117016f, -0.07309499f, 0.26837784f, -0.20793311f, -0.21820216f, -0.04542675f, -0.07918333f, 
    0.21408242f, 0.03684696f, -0.21454711f, -0.19431452f, 0.10754936f, -0.04590810f, 0.12895772f, -0.01019032f, 
    0.02961469f, -0.05451953f, 0.15306723f, 0.16523591f, 0.08772330f, 0.26482561f, 0.28727254f, -0.22314931f, 
    0.01947334f, 0.10957845f, -0.06789649f, -0.13243103f, -0.05946952f, -0.07076500f, 0.05195754f, -0.11180659f, 
    -0.05180360f, 0.01977241f, -0.22984755f, 0.08859202f, 0.02416947f, -0.08107907f, 0.19433503f, 0.05666873f, 
    -0.02705263f, 0.28760776f, 0.05708423f, 0.04801034f, -0.07725219f, 0.17924619f, -0.10249884f, 0.17151998f, 
    -0.01144282f, 0.08669138f, 0.08878688f, -0.10448912f, -0.22945616f, -0.01769682f, -0.12810928f, 0.08266803f, 
    -0.05609526f, -0.17482892f, -0.18165402f, 0.09359418f, 0.15856348f, 0.09727938f, 0.13827117f, -0.04786171f, 
    0.23482120f, 0.08409505f, 0.06652527f, 0.07324490f, -0.09524803f, 0.27857623f, 0.08491231f, -0.08372224f, 
    0.03803801f, -0.09058848f, -0.02784923f, -0.07855774f, -0.07428835f, 0.23841591f, -0.00092632f, 0.02881181f, 
    -0.01637129f, -0.07835518f, -0.14480996f, 0.11035535f, 0.03486165f, -0.04654083f, -0.14992252f, -0.15904973f, 
    -0.13338357f, -0.05811046f, -0.18664162f, -0.06739708f, -0.27343574f, 0.20258468f, -0.23023237f, -0.09514232f, 
    -0.10162542f, -0.05627847f, 0.04593512f, 0.11890937f, -0.02961122f, 0.05989704f, 0.02232220f, 0.07817830f, 
    -0.21353118f, -0.00300129f, -0.35735700f, 0.28082237f, 0.09180126f, -0.00758599f, 0.13454983f, 0.04171380f, 
    0.03512876f, 0.30245268f, 0.07472429f, -0.20843990f, -0.10495581f, 0.05857885f, -0.14859344f, -0.21136588f, 
    -0.19710608f, -0.19956355f, -0.09923784f, -0.15196745f, -0.16965127f, 0.04972277f, -0.20551275f, -0.07337409f, 
    -0.03298649f, -0.13212425f, 0.07543317f, 0.33456564f, 0.02103593f, 0.01063354f, 0.08693842f, -0.08896331f, 
    0.05465547f, 0.15202795f, -0.04955700f, -0.05880474f, 0.26199535f, -0.14097810f, 0.04378537f, -0.07699300f, 
    0.11731264f, 0.07909765f, -0.03159509f, 0.35391605f, -0.06384201f, 0.10960262f, 0.03253465f, 0.11210953f, 
    -0.17797583f, -0.12772906f, 0.26282972f, 0.27136168f, 0.01785218f, -0.05292187f, -0.14021066f, 0.02648168f, 
    0.03909501f, -0.05055652f, -0.29732355f, 0.02713587f, 0.13489270f, 0.09751283f, -0.02161805f, -0.13147804f, 
    0.20339213f, -0.14266151f, -0.08721422f, -0.17570397f, -0.18225858f, 0.14704825f, -0.03010428f, -0.04432396f, 
    -0.23932320f, 0.07428097f, -0.26361480f, 0.06275657f, -0.00122505f, 0.18297426f, 0.18628469f, 0.17485125f, 
    -0.00170117f, 0.05706692f, -0.05394083f, 0.18296443f, -0.11363488f, -0.14185686f, 0.01548013f, 0.19929065f, 
    0.07791106f, -0.02850764f, 0.02677610f, 0.06451257f, 0.07648804f, 0.08277641f, -0.13029028f, 0.05995493f, 
    0.07065170f, -0.28460383f, 0.43591604f, -0.00417340f, 0.07832701f, 0.12473577f, -0.08433516f, 0.05768307f, 
    0.15502602f, 0.14540140f, 0.07065483f, 0.05315197f, -0.04470395f, -0.08092849f, 0.23003212f, 0.23156326f, 
    -0.09092540f, 0.01782519f, -0.02499522f, 0.03374903f, 0.08215791f, 0.29847693f, 0.12091618f, 0.18056059f, 
    0.07282776f, 0.38703904f, 0.18409227f, 0.13557923f, 0.18688367f, -0.09693946f, -0.03451683f, -0.02627301f, 
    -0.07782224f, 0.02786954f, 0.10570928f, 0.12731104f, 0.08981900f, 0.06642052f, 0.03083297f, 0.17495275f, 
    0.03988606f, 0.00399810f, -0.04877438f, -0.14786375f, -0.20262539f, -0.01879715f, -0.05320830f, -0.15852463f, 
    -0.26451221f, -0.33250669f, -0.29757220f, 0.16144644f, -0.01897776f, 0.17747818f, 0.09681548f, -0.24406257f, 
    0.11952353f, -0.09375499f, -0.03825214f, 0.10795923f, -0.02378040f, 0.05395308f, -0.05499711f, -0.30772507f, 
    -0.11212905f, -0.00425943f, -0.11689697f, 0.02636989f, -0.07506393f, 0.17972946f, 0.14641899f, -0.04596635f, 
    0.03329762f, -0.14225811f, 0.09562683f, 0.07186080f, -0.16225384f, -0.04497748f, 0.18580125f, -0.12204711f, 
    -0.26910684f, -0.00877430f, -0.00254776f, -0.09759428f, -0.01350528f, -0.12525862f, -0.13518308f, 0.07941132f, 
    0.23391126f, -0.00573508f, 0.03417191f, 0.02093107f, -0.06751075f, 0.01660364f, 0.03010929f, -0.02272524f, 
    0.10336430f, -0.16516715f, 0.03129683f, 0.51027924f, 0.04741573f, 0.24857485f, 0.06865101f, 0.10304264f, 
    0.02703083f, 0.04085898f, 0.07283038f, 0.05289764f, -0.18075547f, -0.10227813f, 0.02550458f, 0.15194435f, 
    0.01672358f, -0.08821974f, 0.07169209f, -0.10036332f, -0.15784001f, -0.01184079f, -0.03552959f, 0.10408773f, 
    -0.05193162f, -0.10877538f, -0.07614373f, 0.07558513f, -0.09009778f, 0.07821117f, -0.09854482f, -0.04316435f, 
    -0.03072503f, -0.11969089f, -0.22313577f, -0.06151952f, 0.27693275f, -0.19448599f, 0.19114926f, 0.39808697f, 
    0.06105679f, 0.14165178f, -0.14879937f, -0.13972750f, -0.05358281f, 0.03393389f, 0.04609463f, 0.09675466f, 
    -0.12921993f, 0.27934054f, -0.00362066f, 0.10603077f, -0.12088820f, 0.10637847f, -0.03241018f, -0.11699466f, 
    0.06945419f, 0.05432121f, 0.13799743f, 0.22857931f, -0.03476762f, -0.20803520f, -0.27193195f, 0.01619118f, 
    -0.02484528f, 0.08518002f, 0.13765121f, -0.03802380f, -0.01540537f, 0.07465179f, -0.03061868f, -0.06500517f, 
    0.13412434f, 0.20711471f, 0.15844606f, -0.17555615f, -0.03677257f, -0.12317542f, -0.13772726f, -0.05812757f, 
    -0.12956534f, -0.03375307f, -0.15963104f, 0.06338159f, 0.09423988f, -0.17596522f, 0.41554159f, -0.05109997f, 
    -0.13202567f, 0.12413633f, -0.07690727f, 0.12664779f, 0.04460833f, -0.07981365f, 0.10364152f, -0.06569880f, 
    -0.05310215f, 0.07944812f, -0.01267514f, -0.08763443f, -0.11266915f, -0.02350050f, -0.04156195f, -0.01736479f, 
    -0.03305927f, 0.14749749f, 0.09189749f, 0.03142980f, -0.30240896f, -0.16119990f, -0.01243662f, 0.10403511f, 
    0.08809357f, 0.07132640f, -0.04250519f, -0.07956659f, 0.02828691f, -0.05188546f, -0.00259636f, -0.01391385f, 
    -0.32595944f, -0.04308499f, 0.05103927f, 0.00652614f, 0.00947927f, -0.03174547f, 0.08475222f, 0.01670037f, 
    0.03038407f, 0.12120967f, 0.07889295f, 0.13226488f, -0.01685181f, -0.15283753f, -0.17758694f, 0.06917505f, 
    -0.00392271f, -0.10463537f, -0.11838784f, -0.04453715f, -0.10218223f, 0.01832599f, -0.06749081f, 0.00110115f, 
    0.27974060f, 0.09132808f, 0.43777826f, 0.12487222f, -0.03467635f, 0.16351148f, -0.20462535f, 0.04715804f, 
    -0.17390412f, 0.02832156f, 0.15414199f, 0.04971438f, -0.08557653f, -0.05092282f, -0.20365529f, 0.16087517f, 
    0.05974042f, 0.12823965f, 0.23175241f, -0.10102858f, -0.01183897f, -0.00657174f, -0.08685904f, 0.05343010f, 
    0.14872974f, -0.12050728f, 0.07203468f, 0.06374388f, 0.06526971f, 0.04659441f, 0.00348141f, 0.04314278f, 
    0.00312495f, 0.03156005f, 0.02635600f, 0.00424389f, -0.02918394f, -0.03150106f, 0.43508744f, 0.18636522f, 
    0.10641382f, 0.14412807f, -0.07591224f, -0.06867639f, -0.05773453f, -0.13846335f, -0.02368280f, -0.05510636f, 
    0.39890340f, 0.20477583f, -0.24660513f, -0.08187167f, 0.12760201f, -0.09122813f, 0.17411608f, -0.07935525f, 
    0.03552663f, 0.03125772f, 0.18601111f, 0.00204961f, -0.23698677f, -0.00621446f, -0.21123087f, -0.19632301f, 
    0.01043536f, -0.04116051f, 0.14109462f, 0.04282513f, 0.02947124f, 0.05581911f, 0.11879575f, 0.10327494f, 
    0.14575399f, -0.04678559f, 0.11149164f, 0.08893621f, 0.05958678f, -0.07924271f, 0.01321455f, -0.17136474f, 
    -0.06870931f, -0.03829253f, -0.04932294f, -0.03619748f, -0.34851769f, 0.04658504f, 0.69192392f, -0.06112568f, 
    -0.03673749f, -0.04634887f, -0.06898820f, -0.17345943f, -0.02800817f, 0.07793377f, -0.04781671f, 0.07649461f, 
    -0.16134749f, -0.09116240f, -0.05113921f, -0.19233285f, 0.07872020f, 0.04288211f, -0.10120056f, -0.12699771f, 
    0.05373840f, -0.07616832f, 0.04273788f, 0.04126692f, -0.23773809f, 0.24967968f, -0.05891005f, 0.19372082f, 
    0.02473579f, -0.03941812f, 0.09959088f, 0.01209232f, 0.12494630f, 0.01792534f, -0.01863790f, 0.18395308f, 
    -0.05351742f, -0.13375857f, -0.18639678f, -0.00000493f, 0.18019091f, 0.20949982f, 0.11709702f, -0.01006831f, 
    0.14385867f, -0.01818852f, -0.02932443f, 0.00866017f, -0.04018765f, -0.06691409f, 0.12126732f, -0.07057308f, 
    -0.03298955f, 0.01311896f, 0.01452842f, 0.13304083f, -0.07305522f, 0.01055355f, -0.00618405f, -0.09771702f, 
    0.05616169f, -0.35319784f, -0.17248933f, 0.01748527f, -0.00514873f, 0.04139482f, -0.03935999f, 0.16995107f, 
    0.00617733f, -0.15698206f, -0.04355966f, -0.11855935f, 0.11630333f, -0.09539588f, 0.09524325f, 0.08707430f, 
    0.03131541f, 0.08423368f, 0.11682641f, 0.12220410f, 0.23049532f, 0.13782467f, 0.15711696f, 0.36706415f, 
    -0.02724816f, -0.15092894f, 0.13625740f, 0.19770050f, 0.03422135f, -0.07289980f, 0.14135446f, 0.02442899f, 
    -0.04910645f, -0.08682632f, -0.18944173f, -0.06713852f, -0.04991108f, -0.19065051f, -0.10242211f, -0.12010677f, 
    0.17231254f, 0.12412414f, 0.11891609f, 0.09426453f, 0.02973695f, -0.07475570f, -0.16982494f, -0.10441854f, 
    -0.24622577f, 0.10610064f, 0.07035919f, 0.44296488f, -0.05331545f, -0.01886143f, 0.11700109f, -0.23336154f, 
    0.12770560f, 0.01333917f, -0.31296000f, -0.08810475f, -0.12444875f, 0.00077323f, 0.07004924f, 0.02155914f, 
    0.19016999f, 0.21933971f, 0.07080876f, 0.02542001f, -0.17731810f, 0.04878656f, -0.04367226f, -0.10728592f, 
    0.01026026f, -0.39018920f, 0.17630072f, 0.40534604f, 0.15487088f, 0.00848124f, 0.01561885f, -0.03724738f, 
    -0.04967603f, 0.05459340f, -0.09458924f, 0.08507229f, 0.04049716f, 0.33799711f, 0.19688965f, -0.09456276f, 
    0.04156653f, -0.03128883f, -0.00092442f, 0.00360826f, 0.23595706f, 0.14284025f, -0.00483382f, 0.04481199f, 
    0.03854834f, 0.21354870f, 0.16588120f, -0.11122581f, 0.05457342f, -0.08328706f, -0.03888072f, 0.01054564f, 
    -0.15620820f, 0.01794790f, -0.26376617f, 0.01422571f, -0.23514324f, -0.08276390f, -0.07783572f, -0.02450254f, 
    0.07560825f, 0.04167270f, 0.03741458f, 0.14721321f, 0.01295681f, -0.07882362f, 0.10569967f, 0.05721242f, 
    -0.00905476f, -0.17354111f, -0.00731602f, 0.23831198f, 0.03288739f, -0.04199606f, 0.01175930f, 0.03313711f, 
    0.00420463f, 0.21680181f, 0.12234529f, 0.25171974f, -0.00745248f, 0.02628911f, 0.21340275f, 0.18327498f, 
    0.00476358f, -0.10642107f, -0.01730318f, 0.13117082f, 0.03692112f, 0.01139770f, 0.12500113f, 0.01477848f, 
    0.08804379f, 0.13183305f, -0.20554006f, 0.00200272f, 0.09807196f, 0.02941210f, 0.07803830f, 0.28921038f, 
    -0.09360745f, -0.09414854f, -0.06452644f, -0.09295539f, -0.10030436f, -0.08861718f, 0.09104617f, -0.27347255f, 
    -0.04117897f, -0.01835286f, 0.10114974f, 0.09963495f, 0.03585709f, -0.02335003f, 0.12182743f, 0.42561513f, 
    -0.02225245f, 0.06145606f, 0.04879060f, -0.13436492f, 0.03373771f, -0.09970001f, 0.08188828f, 0.07155719f, 
    0.04859402f, -0.15052536f, -0.02710145f, -0.11303764f, -0.03097615f, -0.01917296f, -0.07615571f, -0.11737569f, 
    0.04990035f, -0.00655915f, -0.07329688f, -0.01678605f, 0.04620282f, -0.03287454f, 0.01247850f, -0.15987243f, 
    -0.09982513f, 0.04349812f, 0.28964725f, -0.08638505f, 0.05178866f, 0.06271341f, -0.00026227f, 0.03037003f, 
    0.06896529f, 0.06067419f, 0.15499550f, 0.20008303f, 0.03991186f, -0.26477435f, 0.13819696f, 0.28905725f, 
    0.12202081f, 0.01120941f, -0.16579974f, -0.03799846f, 0.07005901f, 0.06248716f, -0.08911277f, -0.08997198f, 
    -0.23503038f, -0.29276237f, -0.17385285f, 0.15315904f, 0.15711309f, -0.14375703f, -0.07609180f, 0.15637890f, 
    -0.06321839f, -0.01951509f, 0.03479523f, -0.13511121f, -0.22396024f, 0.06231573f, -0.13025153f, 0.20870727f, 
    0.17716061f, -0.07467054f, -0.15523635f, -0.16959983f, 0.00503522f, -0.02760003f, -0.26033521f, -0.11364038f, 
    0.05874893f, 0.00654291f, 0.06019259f, 0.11518388f, -0.02446168f, 0.08306117f, 0.00458622f, -0.00697037f, 
    0.11640456f, 0.20009585f, 0.22095153f, 0.33876342f, 0.04048819f, 0.00504662f, -0.23544586f, 0.08079517f, 
    0.05718299f, -0.00675144f, 0.00915047f, 0.01791464f, -0.05294449f, -0.01896920f, -0.00729388f, -0.25443003f, 
    0.05401532f, 0.08270093f, 0.06310144f, 0.15336511f, 0.25156280f, -0.10100263f, 0.17990352f, 0.05264349f, 
    0.03609365f, -0.00485893f, -0.11234453f, -0.05331870f, 0.01279894f, -0.05657337f, -0.01338222f, 0.03554681f, 
    0.04428988f, -0.11219612f, -0.07450843f, -0.01482045f, -0.00222470f, -0.03534042f, 0.08065124f, 0.14221981f, 
    -0.08136401f, -0.06273034f, 0.37212828f, -0.02833996f, -0.11442459f, 0.15785755f, -0.04450830f, -0.04651729f, 
    -0.23436424f, 0.01100579f, -0.06981681f, -0.10557070f, 0.04060438f, 0.03582322f, -0.16930971f, -0.11138418f, 
    0.12269720f, 0.16306032f, 0.00859156f, 0.04624285f, 0.03622014f, 0.12674604f, 0.16115852f, 0.24054337f, 
    0.25379300f, -0.09668435f, 0.28735843f, 0.12069415f, 0.06704364f, 0.07718201f, -0.02808356f, -0.02258026f, 
    0.07924189f, -0.00026411f, 0.07230390f, -0.07839400f, 0.05669568f, 0.28686288f, -0.13846438f, -0.06920788f, 
    0.01923996f, -0.06448294f, -0.30287740f, -0.01316656f, -0.14104730f, 0.08085302f, -0.21187954f, -0.21972658f, 
    0.04092058f, 0.11536986f, 0.07277595f, -0.06292551f, -0.01820079f, 0.09263744f, -0.09649982f, 0.03847542f, 
    0.04531055f, -0.17024408f, -0.06652861f, -0.06084917f, -0.17179169f, -0.12891448f, -0.37280101f, -0.20777178f, 
    -0.06730058f, -0.01074229f, -0.02925970f, 0.00844542f, 0.03615484f, 0.01914715f, -0.25949565f, -0.27183402f, 
    -0.03693324f, -0.08852577f, 0.06074764f, -0.01402937f, -0.08207490f, -0.01732672f, 0.03620469f, 0.12225297f, 
    0.08582496f, -0.02445352f, 0.03586277f, 0.04843220f, 0.07728888f, 0.14460175f, 0.21502937f, -0.09535111f, 
    -0.09234217f, -0.11205640f, 0.00118223f, 0.02403826f, 0.23268312f, -0.01232409f, 0.02640769f, -0.07276382f, 
    0.16014381f, 0.29678220f, -0.08132681f, 0.05089785f, 0.04554549f, 0.02735807f, -0.01654439f, 0.02259883f, 
    0.07564692f, 0.04774887f, 0.02412699f, -0.06853499f, 0.16317755f, 0.11474792f, -0.05106894f, -0.11602664f, 
    0.05681738f, 0.07945959f, 0.12354486f, 0.01834982f, 0.41958064f, 0.00419045f, 0.18933390f, -0.04909014f, 
    -0.00547875f, -0.41756839f, 0.35446808f, 0.13017608f, 0.13182949f, -0.00788395f, -0.14295898f, 0.10628033f, 
    -0.04085154f, -0.00031803f, 0.02056147f, -0.04066526f, -0.07900704f, 0.09167557f, -0.20642284f, -0.02795728f, 
    0.08866437f, 0.01582135f, -0.13583602f, -0.10465831f, -0.05112291f, -0.00403910f, -0.18620168f, -0.15404736f, 
    0.15330267f, 0.06452168f, 0.30591026f, 0.13133757f, 0.12436187f, 0.06179313f, 0.05367969f, 0.07200421f, 
    0.07136889f, -0.00182873f, 0.05242553f, -0.06020623f, 0.14052965f, -0.18602683f, -0.11271869f, 0.02623948f, 
    -0.03739338f, 0.05801362f, -0.03164747f, -0.05515824f, 0.27488756f, 0.06212709f, 0.24868943f, 0.14883620f, 
    -0.16128366f, 0.18711954f, -0.08751272f, 0.06724460f, -0.10557433f, 0.33936897f, 0.20719545f, 0.02016315f, 
    -0.01371486f, -0.12683646f, -0.23240151f, -0.01475462f, -0.23467450f, -0.06115318f, 0.01385883f, -0.17564248f, 
    -0.16598311f, 0.13529718f, -0.14749013f, 0.00633584f, 0.00843816f, 0.01965151f, -0.02351428f, 0.03782437f, 
    0.01016309f, -0.23212047f, 0.00169114f, -0.19752859f, -0.03156082f, 0.05796207f, 0.02744334f, -0.04386424f, 
    0.06358418f, -0.06231179f, 0.09807923f, 0.10863339f, 0.21845278f, -0.08563723f, 0.01812846f, -0.01394201f, 
    0.11212900f, 0.06424323f, 0.32209390f, -0.00886712f, 0.00573907f, -0.00181355f, -0.12321837f, -0.06631985f, 
    0.03635251f, -0.00302552f, 0.30742103f, 0.21404247f, 0.03458978f, 0.00789533f, 0.17070867f, 0.09767742f, 
    -0.01784706f, -0.05762704f, 0.04847541f, -0.09739362f, -0.36184219f, 0.03826022f, -0.12383757f, -0.35752761f, 
    -0.05574553f, -0.00113278f, 0.11954608f, -0.16015384f, 0.15794800f, 0.00643415f, 0.11851512f, -0.02453709f, 
    -0.00299383f, -0.17707570f, -0.12659296f, 0.01901036f, 0.10269815f, -0.04892035f, 0.05221220f, -0.04785471f, 
    0.14902018f, 0.08782782f, -0.10053374f, 0.03188603f, 0.10436371f, -0.08585250f, 0.31128615f, 0.00860903f, 
    -0.00399271f, -0.04766803f, -0.00592828f, 0.10345995f, 0.14651482f, 0.14891906f, 0.14644305f, 0.10415878f, 
    -0.12639047f, -0.18008715f, -0.22633693f, 0.18971568f, 0.07280609f, 0.01312290f, 0.02520861f, 0.03506830f, 
    0.00770086f, -0.04862176f, -0.12660953f, -0.04786597f, 0.05569160f, -0.13697068f, -0.13423254f, -0.04738963f, 
    -0.11926463f, 0.13408025f, 0.03606544f, -0.15530139f, 0.02118851f, 0.05958861f, 0.26927012f, 0.06357537f, 
    0.33039019f, -0.12212247f, -0.10575112f, -0.00127759f, -0.01595789f, -0.04076003f, -0.05537730f, -0.00100308f, 
    0.12594451f, 0.10805197f, 0.17747679f, 0.17284226f, 0.16438818f, 0.35210240f, 0.24583650f, -0.01221485f, 
    -0.00070037f, -0.09738787f, 0.15380023f, 0.04773230f, 0.01972510f, -0.04912788f, 0.03049688f, -0.02800237f, 
    -0.05321399f, 0.03386116f, -0.07804598f, -0.20281021f, -0.06412279f, -0.02076541f, 0.02029376f, 0.16990213f, 
    -0.02299257f, 0.04375342f, 0.11975149f, 0.29093733f, -0.03590690f, 0.08587135f, 0.26738387f, 0.03258561f, 
    -0.03481647f, -0.05531795f, -0.10035010f, 0.12083561f, 0.07202329f, -0.04228261f, 0.03494593f, 0.01823656f, 
    -0.13268891f, -0.02000483f, -0.18555903f, -0.07269005f, 0.10793569f, 0.21586521f, -0.02259404f, -0.09596444f, 
    0.14413516f, 0.03950330f, 0.01478519f, -0.02228680f, -0.16484851f, -0.06064411f, 0.14158151f, 0.14630923f, 
    0.03006659f, -0.00046171f, 0.15223698f, 0.14914316f, -0.01711327f, 0.13211259f, 0.01184003f, 0.10990035f, 
    -0.13426875f, 0.03569231f, 0.07467830f, 0.08298141f, -0.04045685f, 0.00532603f, -0.00494937f, -0.00520511f, 
    0.15868333f, -0.03881297f, 0.00714597f, 0.02890163f, 0.04715187f, 0.26994798f, -0.16892678f, -0.02542943f, 
    0.11859857f, 0.06473643f, -0.01539294f, 0.06518944f, -0.01239049f, -0.02956338f, -0.04695030f, -0.16484846f, 
    0.01215257f, -0.20011090f, 0.49253368f, 0.20613267f, 0.00300583f, -0.07095304f, 0.01172638f, 0.09831305f, 
    0.00613603f, -0.01578888f, -0.12107266f, -0.09050883f, 0.15223271f, -0.11839777f, -0.00130679f, -0.01735623f, 
    0.03015245f, -0.13237375f, -0.05938157f, -0.08398028f, 0.01839521f, -0.10454725f, 0.01330044f, -0.07381918f, 
    0.05098059f, 0.18910345f, -0.01078745f, 0.08423503f, 0.01855887f, 0.08233359f, 0.07370209f, 0.12382825f, 
    0.00016512f, -0.11954135f, -0.14149992f, -0.21238413f, 0.18230839f, 0.21316776f, 0.17360567f, -0.12348018f, 
    0.08864267f, 0.21963209f, 0.09321745f, 0.14649226f, -0.00170220f, -0.17372929f, -0.00228673f, -0.08053768f, 
    -0.18519159f, 0.03116972f, -0.06201180f, -0.15443072f, -0.09992287f, 0.04398509f, -0.01736158f, 0.00531695f, 
    -0.02008296f, 0.05142060f, -0.08707408f, 0.03333840f, 0.00251955f, -0.10523582f, -0.04214700f, 0.09567926f, 
    0.16283356f, 0.01417125f, -0.03142396f, -0.09202610f, -0.00747550f, -0.08619447f, -0.11306659f, -0.00415758f, 
    0.17840475f, 0.03500356f, 0.07975730f, 0.13123202f, 0.02547368f, -0.02921159f, -0.06608077f, -0.12368045f, 
    0.03176518f, -0.05783563f, 0.02329483f, 0.00296970f, -0.23363437f, -0.20913151f, 0.06396098f, -0.08210415f, 
    0.07043256f, 0.05789811f, -0.02777323f, -0.06599358f, -0.01575957f, 0.05770284f, -0.03412664f, 0.04508472f, 
    0.11374221f, 0.23131433f, 0.45217511f, 0.06234888f, -0.09282209f, -0.01377414f, -0.03211629f, 0.03615157f, 
    -0.04811776f, 0.00388839f, 0.00403987f, 0.05629778f, 0.15267438f, 0.05968364f, -0.03898928f, -0.10504255f, 
    0.03757773f, 0.10515509f, 0.00113456f, 0.09901927f, 0.04763053f, -0.11511776f, -0.10004283f, -0.06671602f, 
    -0.03437144f, 0.30277285f, -0.09403236f, 0.12480822f, 0.06679770f, -0.00394482f, 0.10910486f, 0.15415986f, 
    -0.11840080f, 0.00730828f, -0.04539140f, -0.03767533f, 0.17948681f, 0.21493332f, 0.13892804f, 0.19123277f, 
    0.00972281f, -0.00831655f, -0.05294774f, 0.00681219f, -0.00400071f, -0.06335364f, -0.05510036f, 0.02191643f, 
    -0.52868789f, -0.16776310f, 0.49802065f, 0.03280055f, 0.03785782f, 0.03285705f, 0.06858185f, 0.21430399f, 
    -0.01849131f, -0.03031116f, 0.15265422f, -0.09013534f, -0.01398522f, -0.12539743f, -0.03524524f, 0.07175392f, 
    0.03959365f, 0.10370151f, 0.14211243f, -0.17146572f, -0.13430624f, -0.11403337f, -0.07527196f, 0.02607586f, 
    -0.04010100f, -0.05457589f, 0.39092714f, -0.03036913f, 0.01885097f, -0.09085968f, 0.15045002f, 0.07311131f, 
    0.12061255f, -0.02946270f, 0.05862543f, 0.09684152f, -0.04488158f, -0.01300666f, 0.01052854f, -0.11187561f, 
    -0.09789537f, 0.04425735f, 0.16822699f, -0.10994270f, 0.09595218f, -0.00776901f, -0.09439927f, -0.01871621f, 
    -0.01244227f, 0.07051645f, 0.04439098f, 0.06774152f, 0.04477459f, 0.06379523f, 0.19624083f, -0.00587241f, 
    0.27192810f, 0.10539840f, -0.06904090f, 0.03450324f, -0.74506623f, -0.15565559f, -0.10685474f, -0.15153033f, 
    -0.06372987f, -0.01821514f, -0.11775788f, 0.22913243f, -0.20003854f, -0.08149373f, -0.15201749f, -0.05537304f, 
    0.00527039f, -0.02320021f, 0.00487930f, 0.05258131f, -0.08769514f, 0.07871719f, 0.03948895f, 0.09003952f, 
    0.09118448f, 0.00986833f, -0.10616767f, 0.02820408f, -0.02631786f, 0.08578779f, 0.42286369f, 0.00401030f, 
    -0.01117296f, -0.03286510f, 0.01313713f, -0.18238576f, -0.01332084f, -0.07212733f, -0.01451434f, -0.04142877f, 
    0.26716140f, 0.07619356f, -0.17245913f, 0.03880212f, 0.14220108f, -0.14573416f, 0.02023443f, 0.07846963f, 
    -0.05669935f, 0.04717372f, -0.08932427f, 0.06337471f, -0.24202311f, 0.12979828f, 0.06073404f, -0.10298354f, 
    -0.05416914f, 0.00746052f, -0.19214940f, -0.09522098f, -0.07078543f, -0.07851704f, -0.15793383f, 0.10900177f, 
    -0.01192458f, 0.22942348f, 0.04817320f, -0.07188722f, 0.13851334f, -0.11371561f, 0.01309738f, 0.13627535f, 
    -0.06797837f, -0.04333194f, 0.00409646f, -0.12186376f, 0.18865505f, 0.05991220f, 0.16230685f, 0.08685382f, 
    -0.01180604f, -0.01532715f, -0.02845593f, 0.07551857f, -0.01358791f, -0.01131575f, -0.03101051f, -0.09031469f, 
    -0.15891409f, -0.23060319f, 0.19319981f, -0.18254022f, -0.04335066f, 0.04742338f, 0.08429928f, -0.09553869f, 
    0.01529729f, 0.14632563f, -0.03020528f, 0.01001718f, -0.11540464f, -0.11406468f, 0.28511968f, -0.06868940f, 
    0.08877774f, 0.23972860f, -0.04740905f, -0.00289861f, 0.01471752f, -0.01962390f, 0.05896852f, 0.00641803f, 
    0.34478623f, 0.24189813f, -0.12924722f, 0.06014929f, -0.04045892f, 0.06488585f, 0.05450263f, 0.00103031f, 
    0.11629308f, 0.07364284f, 0.04531445f, 0.29397485f, -0.20526578f, -0.27236897f, 0.05765418f, 0.34187859f, 
    0.06851847f, -0.06796746f, -0.01181727f, 0.08472610f, 0.08192252f, -0.05556834f, -0.01883540f, 0.18000425f, 
    -0.11743009f, 0.03722379f, -0.00983299f, -0.04422098f, 0.00231739f, -0.00047376f, 0.18639489f, 0.01384650f, 
    -0.05582634f, -0.00795658f, 0.16952981f, 0.05413866f, 0.56046218f, 0.07256755f, 0.17600948f, 0.27462599f, 
    -0.07625297f, -0.05837702f, -0.02280754f, 0.04266281f, -0.00027106f, 0.16276383f, -0.07953998f, 0.05401533f, 
    -0.05077303f, 0.13095014f, 0.26114339f, 0.15189128f, -0.05852494f, -0.13359642f, -0.11055747f, -0.01044614f, 
    -0.08454715f, 0.06836125f, -0.03038499f, 0.07082862f, 0.09555271f, -0.08364895f, -0.10138740f, -0.08088268f, 
    -0.06230062f, -0.01407054f, 0.03371195f, 0.00841071f, 0.09484144f, 0.01015853f, 0.17276523f, -0.06707281f, 
    0.12214357f, -0.11570733f, -0.18630646f, -0.02044267f, 0.05983438f, 0.23041761f, 0.09432160f, 0.21304241f, 
    0.40535191f, -0.07614399f, -0.05005640f, -0.26523840f, 0.12066616f, 0.03692689f, -0.01863673f, 0.10032995f, 
    0.02901035f, -0.06788336f, -0.03551317f, -0.05908844f, 0.11576582f, 0.12500556f, 0.00221415f, 0.00780160f, 
    -0.26636910f, -0.17551506f, 0.05971318f, 0.02323941f, -0.18767963f, -0.00688911f, 0.13798442f, -0.15268964f, 
    -0.08180372f, 0.14698601f, -0.04213507f, -0.14586268f, -0.09144509f, 0.01176491f, 0.11225124f, 0.02804799f, 
    0.02077069f, 0.12077086f, -0.10868200f, 0.21374288f, -0.02482758f, 0.15128829f, 0.01545554f, -0.15135758f, 
    -0.05897262f, 0.16536982f, 0.01822160f, -0.13412215f, 0.24659939f, -0.09129760f, 0.06903419f, -0.11960537f, 
    -0.03142515f, -0.11230183f, -0.02035913f, -0.09270243f, -0.03993888f, 0.13791811f, 0.14544947f, 0.12219129f, 
    -0.02904110f, -0.07467449f, 0.11557271f, -0.03448806f, 0.00756958f, -0.12872332f, -0.00799711f, -0.06749212f, 
    0.08562979f, -0.03337272f, -0.12626055f, -0.10941762f, -0.04535024f, 0.02869304f, 0.01859951f, 0.03292035f, 
    0.09868088f, 0.05698677f, 0.03815310f, 0.07441562f, -0.13330528f, 0.07017995f, -0.01750839f, -0.02382293f, 
    0.10951693f, 0.11748454f, -0.05583037f, -0.08864506f, 0.08267729f, 0.06935728f, -0.01145708f, -0.05002493f, 
    0.46022189f, 0.00616287f, -0.04443875f, -0.23899205f, 0.07086948f, 0.07362083f, 0.18892668f, -0.00605654f, 
    0.02278681f, 0.00226947f, 0.00696954f, 0.09228703f, 0.43907577f, -0.03550203f, 0.03865615f, -0.12518695f, 
    0.04354723f, -0.04585781f, -0.07108685f, 0.11504129f, 0.03185607f, -0.18917187f, 0.10884469f, -0.06393674f, 
    0.32019052f, -0.56630307f, 0.29198930f, 0.04162510f, -0.12744561f, 0.12986615f, -0.02530178f, 0.09295747f, 
    0.18519917f, 0.09107489f, 0.08271114f, -0.00776535f, -0.08833944f, 0.07492606f, 0.12307373f, 0.09688976f, 
    0.13787892f, -0.10203156f, 0.10187838f, -0.11598512f, -0.03743131f, -0.02762083f, -0.06529554f, 0.09259187f, 
    -0.13802849f, -0.01909200f, 0.27103794f, 0.14857551f, 0.00524888f, -0.10438352f, -0.10095393f, -0.12024838f, 
    -0.07749103f, -0.06222896f, 0.07014349f, 0.00471243f, 0.16970423f, 0.01943334f, 0.01675053f, -0.02879205f, 
    -0.03158496f, 0.01203961f, -0.05034639f, 0.04748603f, 0.01842424f, 0.13618849f, 0.14042681f, 0.24775068f, 
    0.32340288f, -0.02253420f, -0.14136776f, 0.12597255f, 0.12648882f, 0.07371912f, 0.07674266f, -0.07316422f, 
    -0.12956031f, 0.00028558f, -0.01368459f, -0.06368396f, 0.00462390f, 0.27142912f, -0.14380871f, -0.06862339f, 
    -0.13297087f, -0.05829428f, 0.06824891f, 0.11144472f, -0.11844911f, 0.02819177f, 0.04017273f, -0.14241366f, 
    -0.19583482f, 0.21205570f, -0.15832053f, -0.09757957f, -0.02977372f, -0.03585635f, -0.26593742f, -0.00462403f, 
    -0.11374627f, -0.09291387f, 0.03999703f, -0.04365297f, 0.14451174f, 0.07213168f, -0.06349932f, 0.16058478f, 
    -0.09800619f, -0.15933692f, -0.03007820f, -0.07419177f, -0.03379791f, -0.08781868f, -0.03511708f, 0.08816069f, 
    0.02442412f, 0.17126034f, 0.11862098f, 0.02640887f, 0.08011375f, -0.02593342f, 0.05978300f, -0.13991250f, 
    -0.09687865f, -0.03827982f, 0.04612251f, -0.01478128f, -0.40030479f, -0.13795391f, 0.06131621f, -0.03277360f, 
    -0.02531826f, 0.04886040f, 0.33819479f, -0.17087635f, 0.14792234f, 0.03714364f, -0.04781363f, 0.04216644f, 
    0.43646052f, 0.24713039f, 0.12047129f, 0.06222743f, 0.05687766f, -0.02514903f, 0.02296609f, 0.03235789f, 
    -0.04036813f, 0.00400606f, 0.08210173f, -0.06984938f, -0.00484712f, 0.03898144f, 0.10429741f, 0.01112849f, 
    -0.07834688f, 0.12254637f, -0.02131094f, -0.08806746f, 0.14592497f, 0.11407807f, 0.00749581f, 0.02486111f, 
    0.24159437f, 0.15847990f, 0.10916214f, 0.16595614f, -0.05489359f, -0.06812845f, -0.02368315f, -0.03651721f, 
    0.04083955f, 0.09465186f, -0.02324409f, 0.00408990f, 0.14263713f, -0.03915733f, 0.04251826f, 0.03036339f, 
    0.05781791f, 0.07669777f, -0.10632438f, -0.01705032f, 0.11481140f, 0.18159369f, -0.02190033f, -0.03239090f, 
    0.27008703f, -0.15772359f, 0.00418079f, -0.00270922f, 0.01663562f, 0.03031894f, 0.03850976f, 0.03823472f, 
    0.06176629f, 0.10617169f, 0.11668358f, 0.10405304f, 0.20910171f, 0.28215194f, 0.32567433f, 0.02568858f, 
    -0.06048300f, -0.11298060f, -0.18811975f, -0.01394128f, 0.05650982f, -0.02007436f, -0.01601077f, 0.12925012f, 
    0.03495773f, 0.03312841f, -0.01389433f, -0.15968229f, -0.04131674f, 0.01277922f, 0.07087595f, -0.08574785f, 
    0.05834833f, 0.12462680f, 0.04917656f, 0.04467364f, -0.11073225f, 0.01672733f, 0.08022751f, 0.01429592f, 
    0.02028358f, -0.00336130f, -0.03670768f, -0.02966578f, 0.02246538f, 0.03190732f, 0.03758686f, 0.20846087f, 
    0.65590388f, -0.29128590f, 0.22709608f, 0.05686388f, -0.00816041f, -0.04759229f, 0.01266482f, -0.09479594f, 
    -0.05047103f, -0.05625935f, -0.08882388f, -0.10818766f, 0.05112142f, -0.18421970f, -0.05594582f, 0.01346321f, 
    0.01321036f, -0.07016233f, -0.04498175f, -0.11102520f, -0.09965554f, 0.04889895f, 0.02759196f, 0.04859221f, 
    -0.27942017f, 0.17570376f, -0.11923483f, 0.02715743f, -0.05746563f, -0.02260565f, 0.03986593f, 0.13868000f, 
    0.10502181f, 0.06103247f, 0.07265108f, -0.18874447f, 0.21142660f, 0.02653041f, -0.00133498f, -0.03437291f, 
    0.10233936f, 0.14035106f, -0.06759609f, 0.11872245f, -0.14642854f, 0.03871472f, 0.03388241f, -0.04404329f, 
    -0.33612138f, 0.08072705f, 0.07424392f, 0.16065603f, -0.04410277f, -0.00743318f, -0.03154729f, 0.14592731f, 
    0.01512002f, -0.03255854f, -0.09515870f, -0.02895408f, -0.16993833f, 0.13247477f, 0.04405649f, -0.03205858f, 
    -0.19998120f, -0.04034417f, -0.06300397f, 0.04489960f, 0.17129119f, 0.13885409f, 0.08837183f, -0.08137270f, 
    -0.14573753f, 0.19894569f, 0.11542322f, -0.03858970f, -0.03352702f, 0.16628750f, 0.05363233f, 0.09280581f, 
    -0.14349900f, -0.02642182f, -0.06521901f, 0.08653910f, 0.61618298f, -0.03606362f, -0.16476284f, -0.02736468f, 
    0.09797443f, 0.01451168f, 0.00273242f, -0.11464455f, -0.12756152f, 0.00658903f, 0.08442811f, 0.03486767f, 
    0.16005686f, 0.16146021f, 0.01238962f, -0.01815371f, 0.07385039f, 0.12700611f, 0.08776546f, -0.00935253f, 
    0.01224571f, 0.02450469f, 0.06017755f, 0.01544281f, -0.27045614f, 0.22753614f, 0.10134672f, -0.12755071f, 
    0.00339244f, 0.00450958f, 0.13653229f, 0.27750406f, -0.11945982f, -0.01663684f, 0.06816784f, -0.09727526f, 
    -0.07274397f, 0.02665908f, -0.04566161f, 0.04920950f, -0.09996188f, 0.06877845f, -0.09110004f, 0.16416997f, 
    -0.09208703f, -0.01279956f, -0.05372205f, 0.03494829f, 0.39088038f, 0.21565269f, 0.01826149f, -0.28425375f, 
    0.01340486f, -0.02547617f, 0.40502557f, 0.16936173f, -0.03075486f, 0.11508352f, -0.11235388f, 0.13928480f, 
    0.34707811f, 0.09325238f, 0.20878132f, 0.16921777f, 0.28608093f, -0.09782282f, -0.04827859f, -0.22070539f, 
    0.12882194f, -0.08893787f, -0.08571914f, 0.00876188f, 0.21427867f, -0.12586245f, 0.16286421f, -0.02419007f, 
    0.07237301f, 0.00464008f, 0.04027887f, 0.03681539f, -0.06447452f, -0.13346267f, 0.02694644f, -0.14017032f, 
    0.25847089f, 0.22345372f, 0.23104237f, -0.10071365f, 0.06567691f, 0.12687731f, -0.06383161f, -0.10866073f, 
    0.04807872f, -0.02166195f, 0.00494006f, 0.09496051f, 0.19193210f, 0.18912645f, 0.18688765f, 0.05332754f, 
    0.04295629f, -0.03164703f, -0.11952309f, -0.13460793f, -0.09195853f, -0.01270648f, 0.02226320f, 0.08215141f, 
    0.19871941f, 0.09940825f, -0.03699104f, -0.13386543f, 0.05871053f, 0.08682466f, 0.13449514f, 0.36941871f, 
    -0.12145946f, -0.00453555f, -0.11063719f, -0.15869699f, -0.00472118f, 0.02015096f, -0.26773870f, -0.18611796f, 
    0.08181410f, -0.03993128f, 0.09463499f, 0.08791562f, 0.31236368f, -0.01467096f, 0.04410854f, 0.18292476f, 
    0.35318962f, 0.04155765f, 0.16403939f, -0.06440601f, 0.13922310f, -0.10948005f, 0.18378277f, -0.03490508f, 
    0.03981795f, -0.14434692f, -0.05212079f, -0.10040917f, 0.03624056f, 0.04299232f, -0.24077617f, -0.13180344f, 
    0.06363411f, 0.14616190f, 0.08948997f, 0.09434955f, -0.05071546f, 0.00824996f, 0.09401990f, -0.13614796f, 
    0.12709539f, -0.14366876f, -0.10205792f, -0.15656061f, 0.03467719f, 0.04327730f, 0.20514409f, 0.07771672f, 
    0.08600108f, 0.03085149f, -0.08580084f, -0.10267044f, -0.53036255f, -0.21496345f, -0.36170763f, -0.28458571f, 
    -0.10334627f, 0.15934518f, 0.07890392f, -0.00688875f, 0.13936602f, 0.01640159f, 0.03708484f, -0.13351808f, 
    0.04640832f, 0.06884775f, -0.12484574f, 0.10840894f, -0.01122920f, -0.11862008f, 0.04163460f, -0.13277060f, 
    0.08220111f, -0.01867318f, 0.08595143f, -0.02264725f, 0.39054245f, 0.01877813f, -0.04705105f, -0.11300046f, 
    0.18426551f, 0.05301753f, 0.28970107f, 0.15293390f, -0.01877935f, -0.14413171f, -0.11458189f, -0.04494975f, 
    -0.13658482f, 0.29976222f, 0.02654180f, -0.05448350f, -0.03784054f, 0.02226469f, -0.07581624f, -0.11281851f, 
    0.09494801f, -0.04631263f, 0.18919727f, -0.09519370f, 0.25728399f, 0.02405368f, 0.11016298f, -0.00776823f, 
    0.13373064f, 0.06130264f, 0.15922484f, -0.04659821f, -0.02673449f, -0.03664327f, 0.07298396f, -0.01221380f, 
    0.02588994f, 0.01681942f, 0.13889347f, -0.06277413f, 0.05939547f, 0.20353350f, -0.09378272f, -0.02339826f, 
    -0.24506289f, -0.11607160f, -0.09939773f, -0.00057639f, -0.08435790f, 0.02810716f, -0.01303773f, 0.09444264f, 
    -0.03697859f, 0.04499530f, -0.04871134f, -0.08899707f, 0.00116044f, 0.15366066f, 0.15421657f, 0.14723411f, 
    0.24872252f, 0.18333176f, -0.06858329f, 0.05642421f, 0.19465278f, 0.00948771f, 0.12590531f, 0.11761881f, 
    0.04519224f, 0.01219191f, -0.09531435f, -0.01808982f, 0.04372559f, -0.21562631f, -0.18359609f, 0.13012017f, 
    0.15968800f, -0.03613226f, 0.12009920f, 0.24365699f, 0.13162664f, -0.03179408f, 0.02304108f, 0.06165063f, 
    0.21486336f, -0.10340234f, -0.02253403f, 0.19177876f, 0.10566220f, -0.11193907f, 0.03334755f, -0.05668216f, 
    0.13809595f, 0.07262765f, 0.02093438f, 0.28786319f, 0.11947122f, 0.09035342f, -0.17349172f, -0.11048499f, 
    -0.02372480f, -0.00803382f, 0.05484376f, 0.05879494f, 0.01311735f, -0.08352441f, 0.06386614f, 0.14490224f, 
    -0.01110233f, 0.14126618f, 0.11632216f, -0.09705810f, 0.14272960f, 0.06491509f, -0.00857460f, 0.23059165f, 
    -0.03690200f, -0.03287344f, 0.06461308f, -0.21415390f, 0.34036693f, 0.16544113f, 0.09710784f, 0.35602185f, 
    -0.04585299f, -0.18107565f, -0.02307241f, -0.05439061f, -0.07358113f, -0.01647162f, 0.12886402f, 0.17192157f, 
    0.19165209f, 0.15170488f, -0.15828350f, -0.03938065f, 0.10306893f, 0.26152486f, 0.20213778f, 0.10923170f, 
    -0.00165100f, -0.07095277f, -0.03869484f, -0.10094872f, 0.17475715f, -0.50199085f, -0.06845549f, -0.00043934f, 
    -0.10155533f, -0.04775919f, 0.03444931f, -0.14982989f, 0.07520317f, 0.14722843f, -0.05080578f, -0.06483810f, 
    0.04670867f, -0.20764671f, 0.34916598f, -0.25939223f, -0.01652040f, 0.04617039f, 0.15464893f, -0.13028520f, 
    -0.10444336f, 0.00439629f, 0.09092019f, 0.18809959f, -0.03878857f, 0.01868965f, 0.05022940f, -0.04906738f, 
    -0.09211442f, -0.03728676f, -0.03893056f, -0.03154482f, 0.07108470f, 0.04005123f, 0.07697900f, 0.08363438f, 
    -0.17650050f, -0.22039975f, -0.38177469f, -0.18554395f, -0.01931408f, 0.02710872f, -0.02262427f, 0.28095615f, 
    0.01104954f, 0.05481507f, 0.05382612f, -0.12368048f, -0.04702755f, -0.01978544f, -0.10457273f, -0.02847582f, 
    0.02368244f, 0.02760038f, 0.11194541f, -0.15250747f, 0.03997910f, 0.02963388f, 0.13952635f, 0.16231820f, 
    0.12758292f, -0.02382074f, -0.17064863f, -0.18789674f, 0.00988300f, 0.19832036f, 0.00507465f, 0.17180501f, 
    -0.13527258f, -0.16090399f, -0.14751476f, -0.07254091f, -0.08198549f, -0.08475361f, -0.05054164f, 0.06391655f, 
    -0.00338831f, -0.07045072f, -0.12674788f, 0.05161421f, 0.06582467f, 0.14352572f, 0.04307916f, 0.11941808f, 
    0.07644279f, -0.45147362f, -0.05669067f, 0.02225063f, -0.12513311f, -0.04312318f, -0.04060721f, -0.30048540f, 
    0.00383492f, -0.04903709f, 0.04839971f, -0.12523241f, 0.07072903f, -0.25759330f, -0.01510302f, -0.14733018f, 
    0.06637122f, 0.12274088f, 0.02689532f, 0.10812870f, 0.01955252f, 0.13026026f, 0.00300442f, -0.05962675f, 
    -0.14752372f, 0.09017729f, 0.08557785f, 0.18768054f, 0.02759476f, -0.03058921f, -0.12532727f, 0.08320930f, 
    -0.13669787f, -0.05593602f, -0.04514728f, -0.03453765f, -0.13287400f, -0.20318840f, -0.08257958f, 0.05025847f, 
    -0.02832218f, 0.13328609f, -0.06165329f, 0.09993383f, -0.01746847f, -0.12167894f, -0.08387160f, -0.09406725f, 
    0.13809773f, 0.35149375f, -0.02387939f, -0.15994111f, 0.11373935f, -0.07128137f, 0.15736562f, -0.13671893f, 
    0.18006197f, -0.02880281f, -0.11717238f, -0.11307435f, -0.12033989f, -0.04053419f, -0.21483383f, -0.01944891f, 
    -0.07998191f, 0.08139692f, 0.09586138f, 0.05109497f, 0.05857616f, -0.00581827f, 0.01810261f, 0.08133220f, 
    0.30354285f, 0.31675145f, -0.13811284f, -0.02941019f, -0.04110941f, -0.09563933f, 0.09956877f, 0.21258818f, 
    -0.00946338f, 0.03851378f, -0.11333550f, -0.00315369f, -0.16648370f, 0.06363840f, -0.01112693f, 0.19445018f, 
    -0.04959727f, 0.04973634f, -0.00444961f, -0.15364827f, 0.05712258f, -0.03866880f, -0.09173330f, -0.00190262f, 
    -0.19578871f, 0.05738001f, -0.06805938f, -0.05014900f, 0.22132121f, -0.00309430f, -0.17327526f, -0.00784878f, 
    0.10387764f, -0.01808674f, 0.05832783f, 0.12855981f, 0.13947822f, 0.00276095f, -0.03034657f, -0.10935511f, 
    0.09285728f, 0.22812450f, 0.08051778f, -0.09686761f, 0.06170272f, -0.03643533f, -0.02225541f, 0.12005752f, 
    -0.03113049f, -0.30398890f, -0.03652070f, -0.32800570f, -0.11298761f, 0.16877075f, -0.06867338f, -0.09427053f, 
    -0.08973021f, 0.09226764f, 0.15812127f, -0.05649058f, 0.18135758f, 0.23991428f, 0.07455440f, -0.10094468f, 
    0.09434447f, -0.03127300f, -0.03433736f, -0.08002530f, -0.04908256f, 0.04894062f, -0.00148082f, 0.02763410f, 
    0.29125375f, 0.16613455f, 0.14000565f, -0.20983590f, 0.04991361f, -0.06075345f, -0.03745215f, 0.23846735f, 
    0.01095639f, -0.04370062f, -0.00709322f, -0.04072871f, -0.28308633f, 0.01110916f, -0.13986860f, -0.06480125f, 
    0.07363178f, 0.19893746f, 0.05063539f, 0.21373197f, 0.16925740f, 0.33726799f, 0.05966320f, -0.08989958f, 
    0.15842843f, -0.12933372f, 0.24945255f, 0.10876943f, 0.01168361f, 0.06145471f, -0.09939568f, -0.10699224f, 
    -0.07645215f, -0.04224160f, -0.00885132f, -0.04639836f, 0.28062132f, 0.04541574f, 0.00998306f, -0.07940954f, 
    0.20509955f, 0.07322776f, 0.10059044f, 0.13483082f, 0.11670853f, -0.19392002f, -0.02097210f, -0.01403410f, 
    0.11983175f, 0.28640270f, 0.07179192f, 0.20069547f, -0.02204785f, -0.03165283f, -0.08003179f, 0.08589841f, 
    -0.13525234f, -0.06570755f, 0.03838282f, 0.02793943f, -0.33141360f, 0.00182108f, 0.00432621f, 0.00788557f, 
    0.01417895f, -0.00870106f, 0.01229491f, 0.05730188f, 0.15803772f, 0.01839837f, 0.03750629f, 0.00213625f, 
    -0.14955692f, 0.02764065f, 0.06585647f, 0.14948966f, -0.06020339f, -0.06630163f, -0.03754111f, -0.03501664f, 
    -0.03713997f, -0.08230425f, -0.10088073f, 0.00282823f, 0.23182191f, 0.05341997f, -0.23405832f, -0.24091233f, 
    -0.00021449f, 0.14845361f, 0.18974453f, 0.11335576f, -0.04524495f, 0.14970219f, -0.02753195f, -0.02792399f, 
    0.23497453f, -0.22386838f, -0.21041624f, 0.00618025f, 0.14385983f, 0.15525086f, 0.05541773f, 0.01351582f, 
    0.00496949f, -0.10509774f, 0.00687814f, -0.06826641f, 0.19832599f, 0.21761982f, 0.11514260f, -0.05094097f, 
    0.16147551f, 0.10429445f, 0.10040493f, 0.09787761f, 0.12602466f, -0.06878284f, 0.02129211f, -0.01960231f, 
    -0.41408914f, 0.16232240f, -0.00257194f, 0.31076989f, 0.08585901f, -0.04090276f, -0.06693424f, -0.02515196f, 
    -0.00030839f, 0.04470562f, 0.10199660f, 0.15355077f, 0.29429865f, 0.40808791f, -0.05983359f, -0.21197665f, 
    -0.08451149f, 0.10054760f, 0.11768409f, 0.13501121f, -0.03954058f, 0.09276898f, 0.03678106f, 0.02674490f, 
    -0.06880933f, -0.15609342f, -0.17244166f, -0.23013094f, 0.07041141f, 0.18101142f, -0.11120019f, -0.08098582f, 
    0.15133938f, 0.00937363f, -0.00729959f, 0.01141013f, -0.13493386f, 0.12184599f, -0.19448303f, 0.00714894f, 
    -0.04291050f, 0.03257082f, 0.09272102f, 0.13218991f, 0.09913463f, 0.04648208f, -0.02731069f, -0.01748271f, 
    0.12492388f, 0.28565040f, 0.09937089f, -0.23694326f, 0.02640433f, -0.03943305f, 0.13363138f, -0.02782352f, 
    0.01171183f, -0.03307746f, 0.06024009f, 0.08464227f, -0.02238261f, -0.13201994f, -0.17840889f, 0.01960070f, 
    -0.02941101f, 0.04661536f, -0.07851537f, -0.07063669f, 0.03356020f, 0.05377615f, 0.02779554f, -0.04346629f, 
    0.22057162f, 0.03268834f, -0.05734545f, -0.05912325f, 0.11856413f, 0.01923639f, -0.00180138f, 0.07847436f, 
    0.08588815f, 0.00275114f, -0.01472415f, -0.05997385f, 0.03594882f, 0.17924926f, -0.22748026f, 0.39931068f, 
    0.08280060f, 0.09694363f, -0.09003847f, 0.26059604f, 0.08383097f, 0.10842638f, -0.03747271f, -0.02230237f, 
    -0.01479921f, -0.04330194f, 0.02481628f, -0.00793018f, 0.02497174f, 0.00149666f, 0.00848312f, 0.00750748f, 
    0.00710280f, 0.01594050f, -0.01721201f, 0.00704223f, -0.01790425f, -0.00802896f, -0.01454306f, 0.01677465f, 
    0.02271765f, -0.00314875f, 0.01501592f, -0.03807770f, -0.02744994f, -0.02285239f, 0.00030812f, -0.01473604f, 
    -0.00816251f, 0.02113501f, -0.02108213f, -0.01042495f, -0.02870858f, -0.01323019f, 0.00379577f, 0.00621231f, 
    -0.01351302f, -0.00774235f, -0.00752940f, -0.00604196f, -0.00194586f, 0.00457636f, 0.01554320f, 0.00034948f, 
    -0.03140672f, -0.04380174f, -0.02053851f, -0.00215475f, 0.02384590f, 0.01377197f, -0.01246988f, 0.01986438f, 
    -0.04008907f, 0.00512215f, 0.01564771f, -0.01277758f, -0.01245837f, -0.01329104f, 0.00177330f, 0.02225863f, 
    0.01136145f, -0.01894119f, 0.00074137f, -0.02491198f, 0.02767131f, 0.00838452f, -0.01381035f, 0.01946011f, 
    -0.00190299f, -0.03616090f, 0.01933637f, -0.00472124f, -0.01505648f, 0.01565189f, -0.03751538f, 0.00233097f, 
    -0.00845964f, -0.00191829f, 0.02010005f, -0.02571154f, 0.01176714f, 0.00337731f, -0.03454689f, -0.00876212f, 
    0.01670471f, 0.00157437f, 0.01680486f, -0.03823920f, -0.02179369f, 0.01985553f, 0.00798734f, -0.01653770f, 
    -0.01519576f, -0.03003673f, 0.01630804f, -0.00218307f, -0.00084891f, 0.00916647f, -0.01569072f, -0.01085690f, 
    -0.03864406f, -0.00410452f, -0.03339390f, -0.01272252f, -0.03294945f, 0.01471290f, -0.03465046f, -0.03536713f, 
    -0.02997906f, 0.00167374f, -0.00160720f, -0.01088353f, 0.02160224f, -0.02737924f, 0.00997627f, -0.00081269f, 
    -0.03257105f, -0.03510791f, -0.02280431f, -0.03673048f, 0.00156639f, 0.02488583f, -0.02205126f, 0.01823574f, 
    0.02663547f, 0.00819288f, 0.01145736f, -0.04239119f, -0.04388861f, 0.01173278f, 0.01436960f, 0.00188753f, 
    -0.03359353f, 0.01869475f, -0.02314035f, -0.03751284f, 0.01942724f, -0.03226525f, 0.01999500f, -0.02395212f, 
    0.00818417f, -0.01036766f, 0.00051763f, -0.03898131f, 0.01503883f, 0.02119180f, -0.01556898f, 0.01017238f, 
    0.00748345f, 0.01223128f, 0.01757411f, -0.04197516f, -0.01216717f, -0.02267152f, -0.00081765f, 0.01558601f, 
    -0.03807275f, -0.00249554f, 0.00871734f, -0.01456172f, -0.03100379f, 0.02272956f, 0.02542366f, 0.02633096f, 
    0.00585805f, -0.02592581f, -0.00296109f, -0.01005310f, -0.02133010f, 0.01406729f, 0.00303336f, -0.03018514f, 
    0.00297459f, -0.01023099f, -0.02151896f, 0.02275552f, -0.01452770f, -0.00837963f, 0.01024286f, -0.02318295f, 
    -0.02911430f, -0.03632981f, 0.01525111f, -0.01520233f, -0.02581598f, 0.01911253f, -0.03322490f, -0.04044419f, 
    0.00183299f, 0.00523323f, 0.01918223f, -0.00276576f, -0.02473063f, 0.02839835f, 0.00281417f, -0.04141857f, 
    -0.00728365f, -0.01232062f, -0.04344735f, 0.01468310f, -0.01590359f, 0.00892519f, -0.01623545f, -0.03150686f, 
    -0.02708476f, 0.00029761f, -0.01203448f, -0.01347900f, 0.02119544f, -0.02462657f, 0.02115384f, -0.00551253f, 
    -0.03723710f, -0.01090775f, -0.00003776f, -0.01000020f, 0.01773474f, -0.01951176f, -0.00922676f, -0.02476122f, 
    -0.00205238f, -0.00444115f, 0.01297254f, 0.00290758f, 0.02632600f, 0.00024376f, 0.02412620f, 0.00691307f, 
    -0.00390269f, -0.01480552f, -0.00684019f, 0.02703065f, -0.03131534f, -0.04060868f, 0.01110910f, -0.03421014f, 
    0.00337247f, -0.00315885f, -0.00816204f, 0.01166916f, 0.00825980f, -0.02907758f, 0.01274561f, 0.01766518f, 
    0.00317535f, -0.03555264f, 0.01904067f, 0.02626277f, -0.01268847f, -0.03049205f, 0.02612656f, -0.04155184f, 
    0.00856064f, -0.01000790f, -0.04056377f, 0.01183846f, -0.01851471f, 0.02474765f, -0.02547735f, 0.00339085f, 
    -0.03702029f, -0.03798908f, 0.02405841f, -0.00901833f, -0.00470155f, 0.00000023f, -0.02587288f, 0.02542467f, 
    0.03167967f, 0.01837057f, 0.02740073f, -0.02830407f, -0.00507881f, -0.00985017f, -0.00132382f, -0.01936778f, 
    -0.01744573f, -0.02389615f, -0.02728111f, 0.00158845f, 0.01602409f, 0.00366030f, 0.02376222f, 0.02354032f, 
    -0.00919699f, -0.02273288f, -0.03052777f, -0.02657808f, 0.02271322f, 0.00519902f, -0.00863843f, 0.00458775f, 
    0.02286525f, -0.02405970f, -0.01706612f, 0.00960408f, 0.00154201f, -0.04277913f, 0.01111030f, 0.01705711f, 
    -0.00858208f, -0.01027798f, -0.00861482f, -0.03847106f, -0.02077429f, 0.00997699f, 0.01321002f, -0.02834117f, 
    -0.03421766f, -0.03697779f, -0.00443152f, 0.01218718f, -0.00047784f, -0.02648359f, 0.02585697f, 0.00658065f, 
    -0.00151235f, -0.00995514f, 0.01901052f, -0.02735912f, 0.00608330f, -0.02677433f, 0.01596827f, -0.03306899f, 
    0.02273698f, -0.01011639f, -0.01308684f, 0.00277986f, -0.02538643f, 0.00613446f, -0.03247475f, -0.04055640f, 
    -0.00626212f, -0.03606988f, -0.03311661f, 0.00219312f, -0.01821470f, 0.02485348f, -0.03928103f, 0.01065935f, 
    -0.02373728f, -0.04432315f, 0.01685910f, -0.04102489f, -0.00362971f, 0.02530103f, -0.00064974f, -0.00488172f, 
    -0.03162172f, 0.02311973f, 0.02276229f, -0.04365584f, -0.02205442f, -0.01270099f, -0.01452350f, 0.00327178f, 
    0.01802480f, 0.02718724f, 0.00200666f, 0.00045898f, -0.03100369f, -0.03803409f, 0.00794574f, -0.01227067f, 
    0.02374733f, -0.02939598f, -0.03513283f, -0.01415079f, -0.03329366f, 0.02225627f, -0.01118400f, 0.01736017f, 
    0.00337189f, 0.01259705f, -0.02244203f, -0.02574172f, 0.00221609f, 0.00793702f, -0.03146448f, 0.00794474f, 
    0.01672007f, -0.00738545f, -0.00729009f, 0.02400303f, -0.01303275f, -0.00001735f, -0.02189403f, -0.01417636f, 
    -0.04146482f, 0.01226833f, -0.00615639f, -0.02749180f, -0.03180266f, -0.01879722f, 0.00471524f, -0.03504914f, 
    -0.01801247f, 0.00515223f, -0.04232087f, -0.04029055f, -0.01788508f, -0.00237988f, -0.00938600f, -0.03627208f, 
    0.00171205f, -0.00473277f, -0.03283985f, 0.01141324f, -0.01409377f, -0.04301587f, -0.03356662f, 0.00007665f, 
    0.00671735f, 0.02516184f, -0.01068788f, -0.01426895f, -0.04408624f, 0.02187206f, 0.02127698f, -0.01580775f, 
    -0.00823212f, 0.01468883f, 0.01977565f, -0.03075947f, -0.04116821f, 0.02057953f, -0.02027892f, -0.04101170f, 
    0.01514744f, -0.02152778f, 0.02741317f, 0.01931138f, -0.00693430f, -0.00430249f, 0.02107265f, -0.02084394f, 
    -0.03997629f, -0.03682835f, -0.03209549f, 0.00812786f, -0.03005624f, 0.02485969f, -0.02340044f, -0.03933233f, 
    -0.01059070f, -0.01820954f, 0.01027766f, -0.02323283f, -0.02143112f, -0.03091919f, -0.00250995f, -0.03257127f, 
    -0.03790502f, -0.01424876f, -0.04222845f, 0.00619373f, 0.02156917f, 0.01318126f, -0.00948160f, -0.02582859f, 
    -0.03364637f, -0.02258362f, -0.03595560f, 0.00579433f, 0.01697486f, -0.02017673f, -0.00804508f, -0.03442355f, 
    -0.02013426f, -0.02789446f, -0.03005212f, -0.02553046f, -0.02431191f, 0.00644012f, -0.02011655f, -0.02073988f, 
    -0.03667200f, 0.01659531f, -0.04192766f, 0.01604968f, -0.00555890f, -0.03469219f, -0.01044105f, -0.04227357f, 
    0.02374083f, 0.02433992f, 0.02746774f, -0.01596127f, -0.03071207f, -0.02816182f, 0.01780891f, -0.04133707f, 
    -0.02453456f, 0.00732263f, -0.02745981f, 0.01654062f, 0.01957583f, 0.03051623f, -0.02414008f, -0.03450787f, 
    -0.03349479f, 0.00778477f, 0.01446182f, -0.04237198f, -0.03187462f, -0.02214362f, -0.02592486f, 0.02089378f, 
    0.01768746f, 0.00465898f, -0.02061903f, -0.01038893f, -0.00191357f, 0.00670358f, -0.00607434f, 0.01948917f, 
    -0.01788649f, -0.02981608f, 0.00606180f, 0.00176048f, 0.00670082f, 0.00165127f, -0.00818464f, 0.01483418f, 
    0.02111378f, 0.02116829f, -0.00486014f, -0.00158863f, -0.03000089f, 0.00414502f, -0.03387869f, -0.00801100f, 
    0.00448078f, -0.02206852f, -0.01040595f, -0.02483319f, -0.02536811f, 0.00423075f, 0.02605336f, 0.00078744f, 
    -0.02702220f, 0.00745504f, -0.02157352f, 0.00005814f, -0.03567699f, -0.04252999f, 0.00239256f, -0.02325138f, 
    0.00976734f, -0.00837097f, -0.02976563f, 0.01486440f, -0.04264975f, -0.04122538f, -0.00846541f, -0.02935101f, 
    -0.02649373f, -0.02093384f, -0.02299869f, -0.00061917f, 0.02299180f, 0.00919242f, 0.01756494f, -0.02341563f, 
    0.01016627f, -0.02091403f, -0.02600238f, -0.02350384f, 0.00740542f, 0.01525012f, -0.02476982f, 0.00225328f, 
    -0.01871265f, -0.03579750f, 0.01669421f, 0.02262140f, -0.01142354f, -0.03794605f, -0.01548617f, -0.02652535f, 
    -0.03388728f, -0.02339781f, 0.01396587f, -0.01990511f, -0.01026720f, 0.01797731f, 0.01493125f, 0.01992536f, 
    -0.00592332f, -0.02703164f, -0.01850955f, -0.03306678f, 0.00679099f, -0.02541790f, -0.02380097f, 0.00880525f, 
    0.01335763f, -0.04319556f, 0.01285205f, 0.00389104f, -0.00025076f, 0.01664165f, -0.02348246f, 0.01100115f, 
    -0.01279005f, 0.00013685f, -0.02281934f, -0.02826599f, -0.04376511f, 0.01579803f, -0.03685003f, -0.02397421f, 
    -0.00849706f, 0.01071371f, 0.00950031f, 0.00205619f, -0.03538375f, -0.00195505f, 0.00452293f, -0.02373650f, 
    -0.02619276f, 0.01770865f, -0.02803817f, -0.01466014f, -0.03060135f, 0.00117653f, 0.01810026f, -0.04162049f, 
    -0.00400638f, -0.00713801f, 0.00313890f, 0.02469668f, -0.00815261f, 0.00189097f, 0.02100302f, -0.00146496f, 
    0.02638677f, -0.02016859f, -0.03676227f, -0.00162294f, 0.01961538f, 0.00303126f, 0.00045728f, -0.01299280f, 
    0.00463103f, 0.00848343f, 0.02406828f, -0.02398588f, 0.01936930f, 0.00553755f, -0.01029768f, -0.02484535f, 
    0.02615681f, 0.01224958f, 0.00992264f, -0.03500130f, 0.00894737f, 0.02332545f, 0.01823112f, -0.04146742f, 
    -0.04169113f, 0.02193884f, -0.02247704f, -0.01634030f, -0.01008483f, -0.04137515f, -0.01396423f, -0.02933877f, 
    0.01101365f, 0.00689222f, -0.01815469f, 0.01917607f, 0.00632658f, 0.00186209f, -0.03229348f, -0.02219407f, 
    -0.02165501f, 0.01814669f, -0.02626726f, 0.02412815f, -0.02446283f, -0.04036681f, 0.00381283f, 0.02006685f, 
    -0.00678303f, -0.04254992f, -0.00695650f, -0.00890310f, -0.02704437f, -0.02607571f, 0.01350906f, -0.02784932f, 
    0.01567067f, 0.01151683f, -0.01564080f, 0.01174136f, -0.02166830f, 0.02674885f, -0.00607353f, 0.02455471f, 
    -0.04361771f, -0.00236433f, 0.00338538f, -0.04000948f, 0.00237415f, 0.01646706f, -0.00977069f, 0.01769697f, 
    -0.03806440f, -0.00585910f, -0.02713604f, -0.01951893f, -0.02832730f, 0.02761872f, -0.01883573f, -0.00783331f, 
    0.02296465f, 0.00510435f, 0.01892463f, -0.04193575f, 0.00028704f, 0.00620742f, -0.00033614f, -0.04359223f, 
    -0.02639641f, 0.00426696f, -0.02458186f, 0.00620939f, 0.01795546f, 0.00848739f, -0.01514830f, -0.02201527f, 
    -0.00780002f, 0.01185941f, -0.03509803f, 0.02124708f, -0.03037796f, 0.01545960f, -0.02854819f, -0.01667933f, 
    0.00307195f, 0.02050079f, -0.03602967f, -0.01388437f, 0.00415944f, 0.02322981f, 0.01320665f, 0.01891509f, 
    0.02229942f, 0.00851379f, 0.02121454f, -0.03542900f, 0.00908338f, -0.02837270f, -0.03723217f, -0.03458403f, 
    -0.03129683f, -0.03484976f, -0.02007282f, 0.02737307f, -0.00943972f, -0.02446257f, -0.00320742f, -0.03492977f, 
    -0.03174559f, 0.01634253f, 0.02158840f, 0.02010678f, -0.02940658f, 0.00329663f, 0.02048310f, -0.01641557f, 
    0.19200458f, 0.20720038f, 0.25700641f, 0.27308175f, 0.09978100f, 0.06130172f, 0.03375851f, 0.07665880f, 
    -0.04696125f, -0.07933443f, -0.02212190f, 0.03487039f, 0.21948721f, 0.21359162f, 0.06654587f, 0.03855406f, 
    0.22276765f, 0.17641290f, -0.09529340f, -0.09658170f, 0.16536291f, -0.01605712f, 0.15055662f, 0.00154094f, 
    0.02008245f, -0.03309409f, -0.33883435f, -0.25448158f, 0.03025821f, -0.06673769f, -0.01116243f, 0.10853189f, 
    0.10681868f, 0.01269908f, 0.15880485f, 0.03866456f, 0.13990684f, 0.00381961f, 0.36436981f, -0.06845427f, 
    0.09695048f, -0.08116713f, -0.06802855f, 0.15575512f, 0.04356765f, -0.19644317f, -0.02308836f, -0.25600332f, 
    -0.40194982f, -0.45336422f, 0.03687198f, -0.24658941f, -0.14505893f, 0.06411670f, 0.03638813f, -0.06891443f, 
    0.03751426f, 0.06381015f, 0.05672922f, -0.13254167f, -0.14378041f, 0.02746624f, 0.20772153f, 0.09292012f, 
    -0.06556012f, -0.10745645f, -0.02639955f, -0.08187952f, 0.15878080f, 0.12218191f, 0.17983258f, 0.42378515f, 
    -0.47684577f, 0.16797397f, 0.05424687f, 0.02916753f, 0.09553449f, -0.10586599f, -0.09943573f, -0.12156007f, 
    -0.11306094f, -0.07675700f, -0.10185751f, -0.15906118f, -0.28772262f, -0.23803422f, -0.09581603f, 0.09098028f, 
    0.02388808f, 0.06587097f, 0.06115244f, 0.04229306f, 0.05888862f, -0.00141589f, 0.01434171f, 0.10993455f, 
    0.13132237f, 0.27177355f, -0.21567442f, -0.00657018f, -0.00065123f, 0.00247063f, -0.10217202f, 0.06444222f, 
    0.06852428f, -0.15487778f, 0.05610348f, 0.13131964f, -0.02068527f, 0.04001105f, -0.07283054f, 0.08637109f, 
    -0.12803626f, -0.07321621f, -0.12666540f, -0.22044513f, 0.11495136f, 0.11874242f, -0.14029871f, -0.13260283f, 
    -0.25624353f, 0.09150517f, -0.18992572f, -0.03817335f, -0.14652953f, -0.05345195f, -0.19210374f, -0.12041941f, 
    -0.17878076f, -0.04645957f, 0.05259621f, 0.01125673f, 0.19181265f, -0.08587091f, 0.05466623f, 0.37615612f, 
    0.08476706f, 0.00808508f, -0.04597475f, 0.14912073f, 0.25816920f, 0.15084131f, 0.07943054f, 0.17078061f, 
    0.24408227f, -0.10641671f, 0.00547240f, 0.18588701f, 0.00857799f, 0.01238110f, 0.03771428f, -0.03868087f, 
    -0.04866507f, 0.00093847f, 0.02751532f, -0.19130662f, 0.54223382f, 0.44595805f, 0.21903634f, 0.25321054f, 
    0.08652637f, -0.01139795f, 0.09625790f, 0.01312874f, -0.00719003f, 0.03335835f, 0.04766968f, 0.09120444f, 
    0.08580805f, -0.10187222f, 0.02702579f, 0.04154630f, -0.09432150f, -0.02210061f, 0.07092724f, -0.04786471f, 
    0.10724583f, 0.14106050f, -0.01984362f, 0.14645872f, 0.07733957f, -0.11471626f, 0.27527133f, 0.22583053f, 
    -0.02937653f, 0.05033794f, 0.02830732f, -0.02776365f, 0.01912819f, -0.02159786f, 0.00619272f, -0.00777267f, 
    -0.30567858f, -0.05462809f, 0.17148629f, 0.26919121f, 0.02790455f, 0.06788442f, -0.15458250f, -0.08701941f, 
    -0.06694469f, -0.00556390f, 0.08611602f, -0.08254822f, 0.07155953f, 0.24298792f, 0.25165248f, 0.36834270f, 
    0.04671632f, 0.09666489f, 0.17282371f, 0.08730251f, 0.09566619f, 0.09748287f, 0.04910207f, 0.23944895f, 
    0.25219569f, 0.22894022f, 0.28446725f, 0.29043177f, -0.01018821f, 0.00518911f, 0.03516883f, -0.12093181f, 
    0.01501039f, -0.05138092f, -0.10579765f, 0.02573291f, -0.16316931f, -0.16608185f, -0.24370517f, 0.13751383f, 
    -0.00768199f, 0.01738436f, 0.07948397f, 0.06342887f, -0.05967965f, -0.10648590f, -0.09280342f, 0.14758638f, 
    -0.03227664f, 0.01413486f, 0.13769792f, 0.12968890f, -0.00426280f, 0.04845374f, -0.20826657f, -0.14385238f, 
    0.02177713f, -0.08201935f, 0.14465486f, 0.04521301f, -0.03292812f, -0.11732303f, -0.33159110f, -0.11824166f, 
    -0.15560973f, -0.16702595f, -0.05752701f, -0.31595850f, -0.14023219f, -0.10977154f, -0.11464388f, -0.01810070f, 
    0.17484128f, -0.04312853f, 0.07036452f, -0.20363815f, -0.14695682f, 0.07511842f, -0.02319685f, 0.03855111f, 
    0.03495239f, 0.18983382f, -0.30551806f, -0.23514977f, 0.45593864f, 0.15907609f, -0.00286365f, -0.28370854f, 
    0.10261305f, -0.25864735f, 0.11304459f, 0.05241454f, -0.15749431f, 0.00453434f, -0.09185566f, -0.17851092f, 
    0.16034356f, 0.20166139f, 0.04317825f, 0.09652504f, 0.22968821f, 0.24383786f, -0.05455254f, -0.19380347f, 
    0.13033627f, 0.10630240f, 0.10041700f, 0.21269725f, -0.14929079f, -0.17636004f, -0.26224357f, 0.00700598f, 
    -0.02015980f, -0.00299325f, 0.12536740f, -0.04814367f, -0.04097226f, 0.03236616f, -0.01637994f, 0.05748642f, 
    0.08436434f, 0.22755995f, 0.11070453f, 0.12327469f, -0.11203009f, 0.12028010f, 0.27643916f, 0.35905960f, 
    -0.06842222f, -0.05634885f, -0.05248487f, -0.13180913f, 0.06402634f, -0.21031398f, -0.03707065f, 0.17031480f, 
    -0.08277871f, -0.04812783f, 0.08443598f, 0.01536477f, -0.02902921f, 0.12555209f, -0.15012644f, 0.02078457f, 
    -0.07696778f, 0.08155847f, 0.03253521f, 0.01209246f, -0.12317231f, -0.09144074f, 0.00555593f, -0.20401727f, 
    -0.09059180f, 0.15536010f, 0.05797616f, 0.03395217f, -0.11112119f, -0.10973716f, -0.22624671f, -0.14112850f, 
    0.00951897f, -0.01391506f, 0.04998397f, 0.07804769f, 0.05586197f, 0.02055450f, 0.12881149f, 0.18635271f, 
    0.44113654f, 0.30431178f, -0.20804928f, -0.03058343f, 0.16938202f, 0.08905581f, -0.11381147f, 0.03363233f, 
    0.04212475f, -0.06192857f, -0.15055825f, 0.00490750f, 0.05232828f, -0.23685202f, -0.27815390f, 0.18290727f, 
    -0.08137968f, 0.00018774f, 0.05689651f, -0.03239999f, -0.00949630f, -0.14122064f, -0.07687566f, -0.21953936f, 
    0.24439985f, 0.04426106f, 0.20000386f, 0.19530837f, -0.14091524f, -0.06858149f, -0.00764100f, 0.00657356f, 
    0.00063688f, 0.11801459f, 0.00427255f, -0.07034926f, 0.16305465f, 0.05592251f, -0.11473307f, -0.20727015f, 
    0.15433589f, 0.08914781f, -0.02959402f, 0.01301265f, -0.08135957f, -0.06688524f, 0.01617881f, -0.26834205f, 
    -0.17816034f, -0.00934236f, 0.12905182f, 0.14595519f, 0.00816127f, 0.06221460f, -0.00548348f, -0.17352082f, 
    -0.08042885f, -0.01020772f, 0.06058023f, 0.13234469f, 0.09136125f, 0.19775479f, 0.05678026f, 0.26283389f, 
    -0.00542678f, -0.03505848f, 0.03171691f, -0.00830106f, 0.10648789f, -0.09965463f, -0.11087094f, 0.10417052f, 
    -0.07383420f, 0.07263672f, 0.34631428f, -0.01355418f, -0.08604953f, 0.06649773f, -0.22309966f, -0.05427144f, 
    0.07162657f, -0.09088694f, -0.01457091f, 0.03338168f, -0.28194737f, -0.11038400f, 0.16614372f, -0.04768377f, 
    -0.08422967f, -0.05430616f, -0.24054548f, -0.10547289f, 0.05573689f, 0.08263449f, 0.05151794f, 0.33799398f, 
    -0.30383891f, 0.11718475f, -0.13124968f, -0.06236383f, -0.07232330f, 0.01161860f, 0.07919044f, 0.02193752f, 
    -0.07155067f, 0.08793153f, -0.01161717f, -0.00139606f, 0.21650144f, -0.04187525f, -0.11118578f, -0.11093847f, 
    -0.00530048f, -0.05671970f, -0.14404696f, 0.14457808f, -0.17722008f, -0.18352102f, -0.15271938f, -0.10816909f, 
    0.07976493f, 0.21115522f, 0.06302101f, 0.11805362f, 0.10193606f, -0.03844032f, 0.06220919f, 0.08981082f, 
    0.14429832f, 0.03419025f, -0.12743382f, 0.10289167f, -0.20351686f, -0.23510766f, -0.00649012f, 0.05339792f, 
    -0.02086916f, 0.04474264f, -0.09785867f, -0.06259765f, -0.08096176f, 0.05270883f, 0.02367524f, 0.35864320f, 
    -0.04625168f, -0.11263212f, -0.06847975f, 0.06302156f, -0.08512325f, 0.12999047f, -0.08224726f, -0.04943558f, 
    -0.21455584f, 0.02232218f, -0.26494130f, -0.07604317f, 0.40969387f, 0.28047812f, 0.33661738f, 0.14690332f, 
    0.02835542f, 0.00102874f, -0.01466991f, -0.14964235f, 0.00770602f, -0.05825269f, -0.07932819f, -0.01228499f, 
    0.18830955f, 0.56311882f, 0.13035063f, 0.18869081f, 0.03955736f, 0.09059918f, 0.05226854f, 0.15111887f, 
    0.07310534f, -0.10856915f, -0.04209960f, 0.01793934f, -0.10554053f, 0.20352903f, 0.06019078f, -0.05483068f, 
    0.03116720f, 0.14569455f, -0.13397472f, 0.06501648f, -0.04560979f, -0.04895903f, 0.08671385f, -0.09273277f, 
    -0.03137607f, 0.10795538f, -0.06438346f, 0.14017238f, -0.14326513f, 0.06993305f, -0.14618893f, -0.03295741f, 
    -0.02727710f, 0.02537631f, -0.12316174f, -0.06869277f, 0.56415707f, 0.28868046f, -0.06419090f, 0.36562985f, 
    0.07476240f, -0.07700058f, -0.21480879f, -0.02942346f, -0.22241715f, -0.09910873f, -0.02520540f, 0.04263877f, 
    -0.22450191f, -0.04944680f, -0.40024012f, -0.10167803f, 0.03438890f, -0.05056198f, -0.01859246f, -0.23061238f, 
    0.06818679f, -0.06883587f, -0.11713269f, 0.12371945f, 0.06485227f, 0.04898703f, -0.11623301f, 0.22206339f, 
    0.03186417f, 0.17327788f, 0.14367248f, -0.06050345f, -0.05859081f, 0.02881914f, 0.12604213f, 0.07237469f, 
    -0.32250997f, -0.22874685f, 0.02948023f, 0.01985064f, 0.07443848f, 0.01163329f, -0.03277353f, -0.04066613f, 
    -0.00476113f, -0.11919595f, 0.05736559f, -0.06205859f, -0.10304278f, -0.05263990f, -0.12218769f, -0.15349784f, 
    0.03668576f, -0.11930545f, 0.06822747f, -0.08571438f, 0.01501375f, -0.05799284f, 0.01493160f, 0.17428289f, 
    -0.27562922f, -0.20875891f, -0.02436307f, -0.03633726f, 0.00175118f, -0.01296879f, -0.00470459f, -0.12735231f, 
    -0.07294682f, 0.06805765f, 0.00370553f, 0.24113327f, 0.13680921f, 0.03834152f, 0.21402852f, 0.10127675f, 
    0.05709840f, 0.06545307f, 0.18598573f, 0.08259934f, 0.06691225f, -0.01458544f, 0.16708045f, -0.03834063f, 
    0.26466733f, 0.23788564f, 0.36986038f, 0.34388116f, 0.05390690f, -0.05617792f, 0.16516481f, 0.16138677f, 
    0.11357762f, 0.04566184f, 0.14272852f, 0.05500093f, 0.15407822f, 0.05748852f, 0.02350225f, 0.25353837f, 
    0.11129997f, 0.09788455f, 0.03546289f, 0.08237793f, -0.11818200f, -0.14094998f, -0.01244362f, -0.04895872f, 
    0.17696650f, -0.18929443f, 0.00031390f, -0.35858983f, 0.02407317f, 0.07652398f, -0.22272301f, 0.04897951f, 
    0.09025015f, -0.11399113f, -0.04687238f, -0.11053953f, 0.02324802f, 0.14099656f, 0.05176242f, 0.16389881f, 
    0.00619819f, 0.02886805f, 0.09612482f, 0.32103890f, 0.04230068f, -0.05125981f, -0.05444882f, 0.03350257f, 
    0.41788551f, 0.29302061f, 0.17965931f, 0.27836683f, 0.02576511f, -0.04667126f, -0.04025931f, -0.04571707f, 
    0.01449153f, -0.19046503f, -0.00576490f, 0.05091078f, 0.03001833f, -0.11878627f, -0.06561788f, 0.21526006f, 
    -0.08734636f, 0.12195276f, 0.08341035f, -0.13341832f, -0.12535805f, -0.20964915f, -0.06117071f, -0.13861734f, 
    -0.03784143f, 0.23725981f, 0.06424277f, 0.03582622f, -0.03114758f, 0.07265346f, -0.27042639f, -0.14164135f, 
    -0.02888387f, -0.08959416f, -0.14600122f, -0.16481453f, 0.10194879f, 0.15908770f, -0.09289572f, 0.08388094f, 
    0.08928106f, 0.01964060f, -0.02934839f, 0.03103278f, -0.09604124f, -0.14150763f, -0.23758639f, -0.09312112f, 
    -0.16590877f, 0.23603089f, 0.07196720f, 0.03876062f, 0.14976504f, -0.06977520f, -0.09106091f, 0.07094543f, 
    -0.10455677f, -0.03907696f, -0.07756758f, -0.14617671f, -0.03755409f, -0.13562764f, 0.17642798f, -0.03751809f, 
    -0.12950854f, 0.05102929f, -0.13370699f, -0.11541004f, -0.07959490f, 0.01225579f, 0.00136192f, -0.06790010f, 
    0.42636389f, 0.22538823f, 0.07192446f, -0.00986169f, -0.00650287f, 0.08012969f, -0.00608944f, -0.01955116f, 
    -0.05573385f, -0.04526654f, -0.00112068f, 0.05513985f, 0.05670141f, 0.03755669f, -0.04752066f, -0.12649503f, 
    0.02826765f, 0.18113016f, 0.13696143f, -0.02936015f, 0.07908713f, -0.06946555f, 0.10466003f, 0.05215742f, 
    -0.03513703f, -0.18906088f, -0.21230809f, -0.09173846f, -0.03177889f, -0.00802790f, 0.07653971f, -0.01391352f, 
    0.00157241f, 0.01669618f, 0.07648366f, -0.01296295f, 0.09762903f, -0.14687136f, 0.25070512f, -0.11684227f, 
    0.17035474f, -0.11797746f, 0.00738952f, 0.06898546f, 0.05505076f, -0.09668048f, -0.13964653f, 0.05457500f, 
    -0.45608470f, -0.25004771f, -0.01974839f, -0.12104186f, 0.19813994f, -0.01506597f, 0.03119513f, -0.07599901f, 
    0.04729433f, 0.00762037f, 0.00372993f, -0.05421097f, 0.02459139f, -0.12475407f, 0.07170758f, -0.07802035f, 
    -0.04671790f, -0.12524824f, -0.08828316f, -0.02505502f, 0.03899378f, 0.09443862f, 0.11354677f, 0.28347036f, 
    -0.11826817f, 0.04935474f, 0.00245303f, -0.14970875f, 0.03618567f, -0.04270416f, 0.05073882f, -0.20983724f, 
    -0.04396783f, -0.00432312f, 0.00828162f, -0.10117022f, -0.06722778f, -0.35609779f, -0.20274375f, -0.06836236f, 
    0.14636947f, 0.15109220f, 0.01297579f, -0.04236884f, -0.00968296f, -0.02621842f, -0.03924385f, -0.08741757f, 
    -0.37616971f, 0.19562195f, -0.01136570f, -0.15514706f, -0.08594475f, 0.05956229f, 0.04959748f, 0.09028444f, 
    -0.00529677f, -0.02109108f, -0.00427465f, 0.00965849f, -0.05331509f, -0.05210198f, -0.07369625f, 0.04855568f, 
    -0.03149439f, -0.09782133f, 0.11034808f, -0.10925540f, 0.10352135f, -0.06138086f, -0.03883930f, -0.04226614f, 
    -0.46953455f, -0.05002796f, -0.19574346f, -0.30277762f, -0.06431568f, -0.02788853f, -0.07655510f, -0.02293505f, 
    0.02198015f, -0.07942256f, -0.10563213f, -0.00659564f, 0.03833726f, 0.06464523f, -0.06844941f, -0.00076228f, 
    -0.02002539f, 0.17889541f, 0.00963227f, -0.08170284f, 0.01391836f, 0.10685038f, 0.03938335f, 0.04778713f, 
    0.04360021f, 0.16548565f, -0.02679714f, 0.19635938f, 0.05232526f, -0.04252244f, 0.01890904f, -0.09922569f, 
    0.06213117f, -0.05985800f, 0.07517715f, -0.06175286f, 0.04889261f, -0.05102881f, 0.15118776f, -0.10218945f, 
    0.01041407f, 0.15125600f, 0.02994310f, -0.17182057f, 0.11096830f, 0.08785272f, 0.00112450f, 0.01690059f, 
    0.19158037f, 0.04822047f, 0.03986107f, 0.18496290f, -0.05781086f, 0.04403254f, -0.01381503f, -0.09647830f, 
    0.00595866f, 0.06829586f, -0.02636928f, 0.01145640f, 0.26926729f, -0.10952330f, 0.12034921f, -0.00118032f, 
    0.11485320f, 0.05834134f, 0.15700339f, 0.13523047f, 0.00092567f, -0.07765486f, 0.04237737f, -0.06153172f, 
    -0.06901006f, -0.31588838f, -0.23278415f, 0.02080339f, -0.15229425f, 0.02025257f, -0.06013744f, -0.16010237f, 
    -0.08990844f, 0.12813362f, -0.05666136f, 0.00135020f, 0.28423136f, 0.24308209f, 0.03833849f, 0.12727755f, 
    0.05758493f, 0.26833257f, -0.01872312f, 0.00498376f, -0.00390651f, 0.04461929f, -0.03053492f, 0.00983946f, 
    0.25520846f, 0.12449487f, 0.06808050f, -0.09935524f, -0.00731071f, 0.03911305f, -0.09157107f, -0.00757107f, 
    -0.12112491f, 0.08735152f, 0.03518145f, -0.09603276f, -0.18181396f, -0.03480699f, -0.01713966f, -0.01415360f, 
    0.00167171f, 0.03116231f, 0.11143242f, 0.00942420f, -0.11817095f, -0.07637396f, -0.01332439f, -0.05126543f, 
    0.18630776f, 0.01474053f, -0.07673193f, 0.06111553f, -0.03028842f, 0.04200654f, 0.00962172f, -0.03395420f, 
    -0.05556412f, -0.02406705f, 0.02001952f, 0.01529239f, -0.47270542f, -0.16991384f, -0.16649504f, -0.14124122f, 
    0.00821843f, -0.00197204f, -0.06952044f, -0.01779080f, -0.28142217f, -0.23934411f, -0.09195903f, -0.04940378f, 
    0.23740229f, 0.09046537f, 0.05370130f, -0.05932274f, -0.18366931f, 0.00499167f, -0.00345085f, -0.13086255f, 
    -0.04513871f, 0.16033301f, -0.06615414f, -0.15584418f, -0.11158887f, -0.14740507f, 0.17016067f, -0.08746772f, 
    -0.02470998f, 0.12228063f, 0.02449033f, 0.04897951f, -0.06099082f, -0.14839469f, 0.05116195f, 0.04384710f, 
    0.07791979f, 0.18515779f, 0.11684310f, -0.12003186f, 0.14270675f, 0.10587379f, 0.04114636f, -0.04456158f, 
    0.07453670f, 0.03300558f, 0.09806789f, 0.00151591f, -0.15593562f, -0.34686860f, -0.00475008f, 0.31142777f, 
    0.02776895f, -0.01921079f, 0.02409830f, 0.07672216f, -0.09544852f, 0.02234722f, -0.06449957f, 0.14076236f, 
    0.14891848f, 0.21895288f, 0.02458248f, 0.02788894f, -0.28071034f, 0.02295658f, 0.12947926f, 0.04777789f, 
    0.00651366f, -0.07242177f, 0.00648008f, -0.04923525f, -0.07509534f, -0.20182864f, -0.08672935f, 0.10120315f, 
    0.03483736f, -0.03315376f, -0.04720676f, -0.14868371f, -0.13897429f, 0.07937098f, -0.00234770f, 0.02312385f, 
    0.24222226f, -0.06426019f, 0.23976260f, -0.07222430f, 0.01818224f, -0.13349260f, -0.04182163f, -0.15015195f, 
    -0.03307491f, 0.21749601f, 0.06676131f, 0.01832118f, -0.01229324f, -0.08442377f, 0.00042757f, -0.08122882f, 
    -0.01159043f, 0.06111598f, 0.05541264f, -0.02341056f, 0.03625650f, -0.01329777f, -0.02066764f, 0.02076366f, 
    0.04121632f, 0.08830182f, -0.11990637f, -0.08077587f, 0.05351159f, 0.01951207f, -0.01999012f, -0.07453058f, 
    -0.03217545f, 0.08551535f, -0.15420948f, -0.09230193f, -0.23266858f, -0.24632537f, -0.01501076f, 0.00539159f, 
    0.14787333f, 0.04302062f, 0.00458025f, 0.03445319f, -0.03731369f, -0.17693037f, 0.18249995f, 0.17647251f, 
    0.28433552f, 0.08409687f, -0.07870421f, -0.20622730f, -0.04736333f, 0.02364379f, 0.07053654f, 0.02725824f, 
    -0.01396851f, 0.03380157f, 0.11651127f, -0.18427192f, -0.25627789f, -0.07912829f, -0.05500343f, -0.07565341f, 
    -0.00063787f, 0.12983352f, 0.16388863f, -0.00360268f, 0.00797094f, 0.08987831f, -0.01284866f, 0.00123070f, 
    -0.02258219f, -0.16825095f, -0.01021234f, 0.14603800f, 0.03862474f, -0.06755157f, -0.04923323f, -0.24244067f, 
    -0.01694880f, 0.11820286f, -0.03853594f, 0.03319373f, 0.16363201f, 0.05758729f, 0.07443978f, -0.03584078f, 
    -0.04152556f, -0.02883062f, -0.14043495f, -0.06482301f, -0.08788422f, -0.05173063f, -0.02995519f, 0.09361901f, 
    0.05347209f, 0.01518762f, -0.13885021f, -0.17714272f, -0.06679443f, -0.24871199f, 0.04516691f, 0.04981190f, 
    0.06691483f, 0.04466553f, -0.11385395f, 0.02529474f, 0.08545845f, -0.28341725f, 0.00700509f, -0.02499902f, 
    -0.12495537f, -0.11691412f, -0.18600030f, 0.02616628f, 0.00580865f, 0.10297956f, -0.04686352f, 0.29181027f, 
    -0.11977227f, -0.07440505f, -0.09612854f, -0.14206466f, 0.00013594f, 0.05891559f, 0.16486111f, 0.11993377f, 
    0.03387532f, 0.04902752f, -0.00135731f, -0.08212895f, -0.16769344f, -0.26209655f, -0.02690604f, -0.06116872f, 
    -0.00541152f, -0.04654632f, 0.01925157f, 0.09332813f, -0.06752196f, -0.27905881f, -0.01992217f, 0.05018446f, 
    0.11078089f, 0.29230708f, -0.03697579f, 0.04675021f, -0.18872215f, -0.23596746f, 0.03890980f, 0.03989133f, 
    -0.01603222f, -0.05848841f, -0.08127451f, 0.05895245f, -0.40091664f, -0.01988927f, 0.10703173f, 0.05323198f, 
    0.02530043f, 0.01991202f, 0.01214008f, 0.04830331f, -0.12476586f, 0.05635568f, 0.01038665f, 0.04396047f, 
    0.52128315f, -0.08897600f, -0.17138633f, -0.06637286f, -0.01544837f, -0.03160641f, 0.02546114f, -0.14976685f, 
    -0.14285499f, 0.07810795f, -0.00014594f, -0.15319438f, 0.71557164f, 0.25276551f, 0.04977955f, -0.07899980f, 
    0.06444845f, 0.01489015f, -0.02398953f, -0.11041483f, 0.01487306f, -0.03271167f, -0.10746215f, 0.01892585f, 
    0.20571727f, 0.11477479f, 0.08989449f, -0.25852931f, -0.04893178f, 0.15128273f, -0.06925566f, -0.09407951f, 
    0.01867979f, 0.10812691f, -0.05865494f, -0.00068491f, 0.30203980f, 0.27993390f, -0.20450900f, -0.11030747f, 
    0.07795113f, 0.03303041f, -0.08167123f, -0.13328555f, -0.05952293f, -0.05927081f, -0.00252853f, -0.02049436f, 
    0.15392610f, 0.17100731f, -0.02535636f, -0.12305801f, -0.00776383f, -0.06875990f, -0.04303349f, -0.12616186f, 
    0.02233461f, -0.06308839f, -0.09172457f, -0.04047730f, -0.02522509f, -0.08360992f, 0.09218274f, 0.05912986f, 
    0.10870929f, 0.08376651f, -0.11589163f, -0.02813761f, -0.11447039f, 0.03021820f, -0.10424232f, 0.01054109f, 
    -0.17386401f, -0.40317169f, -0.22578636f, -0.18794253f, -0.13604715f, 0.01284749f, -0.04261765f, -0.15054139f, 
    0.03000011f, -0.19760509f, 0.05904585f, 0.06840378f, -0.00479581f, 0.16781922f, 0.01229720f, 0.02026124f, 
    0.07521550f, 0.02744372f, 0.06275050f, -0.10973123f, -0.11645162f, 0.00127119f, 0.02966286f, 0.03015824f, 
    -0.30355299f, -0.50084823f, -0.28358176f, -0.09929790f, -0.03733667f, 0.12780377f, -0.01273224f, -0.03961407f, 
    -0.00227099f, -0.01349691f, -0.07092995f, -0.07515909f, 0.02530783f, -0.04209889f, -0.17943114f, -0.18140861f, 
    0.02785026f, -0.04279540f, 0.09471092f, 0.07577372f, 0.12216981f, -0.03505336f, -0.16067615f, -0.10989656f, 
    -0.46403039f, -0.13170895f, 0.06837475f, 0.01984903f, -0.02268462f, -0.03817670f, -0.05057512f, -0.04174333f, 
    -0.11155937f, 0.10305853f, 0.08727494f, 0.03801433f, 0.33245492f, 0.13707270f, 0.03635612f, 0.00066742f, 
    -0.14732032f, -0.06115613f, 0.00552263f, 0.13551626f, -0.03090634f, 0.10592061f, 0.03593595f, 0.01228634f, 
    0.31786680f, -0.01452798f, 0.02747719f, 0.14278695f, 0.10123257f, -0.00786179f, -0.05219687f, 0.03424582f, 
    0.07253046f, 0.12290818f, 0.13099925f, 0.07025434f, 0.03891199f, 0.11626500f, -0.07732426f, 0.10220736f, 
    -0.01935144f, -0.06126812f, 0.13544571f, 0.05448911f, -0.10287783f, -0.04038661f, -0.03912719f, -0.06830210f, 
    -0.29451674f, -0.19268823f, -0.01223449f, -0.02865800f, -0.00648099f, -0.09303438f, 0.02060638f, 0.01030556f, 
    -0.00423827f, -0.07717181f, -0.05882538f, 0.00881204f, 0.25272694f, 0.16419069f, -0.08129039f, 0.01101067f, 
    -0.06626809f, 0.13754791f, 0.03985457f, 0.08073831f, 0.04135660f, -0.07827183f, 0.02992668f, 0.16735949f, 
    0.26663524f, 0.06729615f, -0.02412704f, -0.08383007f, -0.05723924f, -0.00436027f, -0.19833870f, -0.12950923f, 
    -0.12059339f, 0.02415218f, 0.01223698f, 0.01501203f, 0.17324133f, -0.12476576f, -0.29502606f, 0.13392732f, 
    -0.14232896f, 0.04775842f, 0.15752496f, -0.02387718f, -0.08698751f, 0.00491179f, -0.07447493f, -0.05740383f, 
    0.29240781f, 0.30656531f, 0.10646171f, -0.07282009f, 0.05126999f, 0.03506982f, 0.03492636f, -0.16666576f, 
    0.03151207f, -0.07807851f, -0.09517191f, -0.01074828f, 0.07968425f, 0.10975678f, -0.06548149f, 0.20714052f, 
    0.12037013f, 0.05864419f, -0.07674059f, -0.08458161f, -0.15700619f, -0.06135121f, 0.01863720f, -0.05321312f, 
    -0.08555506f, 0.09316124f, -0.03973330f, -0.06221651f, 0.08484563f, -0.13488083f, -0.11559664f, -0.03865440f, 
    -0.06838392f, -0.01654292f, -0.11668696f, 0.04469769f, 0.04595296f, -0.20789924f, -0.35532832f, 0.22139227f, 
    -0.05540654f, 0.00363862f, -0.04197857f, -0.03207885f, -0.15934987f, 0.02605745f, -0.01211890f, -0.06357320f, 
    -0.04055133f, -0.04607840f, -0.04391707f, -0.03486457f, 0.00094555f, 0.00708450f, -0.03960047f, -0.00392160f, 
    -0.03709183f, 0.00968133f, -0.01469832f, 0.01490252f, -0.01806475f, -0.01008388f, -0.00669669f, -0.00154531f, 
    -0.02736335f, -0.01246455f, -0.02544836f, 0.02347193f, -0.03871147f, -0.01562349f, 0.01291328f, -0.04789940f, 
    -0.02256298f, -0.03993588f, -0.02710993f, -0.04205347f, -0.03923976f, -0.02639557f, -0.02133004f, -0.00909313f, 
    0.00098414f, -0.03286234f, -0.00049651f, -0.01833784f, -0.02248419f, -0.03120100f, -0.03987681f, -0.03801999f, 
    0.01518223f, -0.04421816f, -0.01602714f, -0.03345354f, -0.02197453f, -0.02184879f, -0.02690738f, -0.00570244f, 
    0.00322870f, 0.01391801f, 0.01116700f, -0.03971229f, 0.00566610f, -0.00284054f, -0.04805699f, -0.00038641f, 
    -0.04736892f, -0.03044640f, -0.01491764f, -0.03551514f, 0.00042355f, 0.01524569f, -0.02805700f, -0.01316942f, 
    0.00419776f, -0.02642356f, 0.02379322f, 0.00097126f, -0.01473188f, -0.00795098f, -0.00446446f, -0.01374891f, 
    -0.02070310f, 0.01507472f, -0.02506368f, 0.01247371f, -0.01914528f, 0.00446531f, -0.04516109f, -0.04672040f, 
    -0.03447955f, -0.01219933f, -0.03544217f, -0.02534175f, 0.01415800f, 0.00047722f, 0.01525333f, 0.00859853f, 
    0.00197875f, -0.01356958f, -0.03463309f, -0.04831420f, 0.01649274f, -0.01037124f, -0.04455251f, -0.02256414f, 
    0.02020496f, 0.02087016f, -0.00757064f, -0.02931583f, 0.00773161f, -0.02774453f, -0.02524378f, -0.01541368f, 
    0.01030931f, 0.01807382f, -0.04269914f, 0.02100549f, -0.01094662f, -0.02032281f, -0.03100314f, -0.02323929f, 
    -0.02835807f, -0.00795845f, -0.01496947f, -0.01669994f, 0.01459715f, -0.01222345f, -0.04146711f, 0.01589780f, 
    -0.02259909f, -0.03603387f, -0.02230326f, -0.03526161f, 0.01226622f, 0.01602234f, 0.01445776f, -0.00201771f, 
    -0.04246575f, -0.04465231f, -0.04670582f, -0.04487650f, -0.03866344f, -0.00308210f, 0.00683950f, -0.00427624f, 
    -0.02991292f, -0.04317929f, 0.00969923f, 0.01550545f, -0.01558673f, -0.02448892f, -0.03723229f, 0.00992489f, 
    0.01632443f, -0.01644631f, -0.01847770f, 0.00341514f, -0.00802103f, -0.04294302f, 0.00659787f, 0.00444874f, 
    0.01845624f, -0.04240181f, 0.01845150f, -0.01659370f, -0.01674798f, -0.02089440f, 0.01274050f, -0.03402966f, 
    -0.00819613f, 0.00884450f, -0.04469320f, -0.04759597f, -0.04000758f, 0.00232714f, -0.01306974f, 0.01901719f, 
    -0.03938053f, -0.02072155f, 0.01711225f, -0.01354801f, -0.03450416f, -0.03229266f, -0.01584394f, -0.04196215f, 
    -0.04444425f, 0.01931213f, 0.01102653f, 0.01160219f, -0.01458150f, -0.02033307f, -0.01329889f, -0.03640312f, 
    0.01815043f, 0.02200085f, 0.01324945f, -0.01777159f, -0.03515771f, -0.01933636f, -0.02539506f, -0.04539936f, 
    -0.00707987f, -0.03828164f, -0.03311833f, -0.00415178f, -0.03286698f, -0.02969076f, -0.04649983f, 0.02212801f, 
    -0.03126055f, -0.00691399f, -0.03043282f, -0.01342984f, -0.03412028f, 0.01988956f, -0.04178399f, 0.00397815f, 
    -0.03091396f, -0.01308084f, 0.01722737f, 0.00385574f, -0.02983493f, -0.03266776f, -0.03556989f, 0.02227113f, 
    -0.02937771f, 0.01820681f, 0.01808664f, -0.01719107f, 0.00143367f, 0.02020808f, -0.02262102f, -0.04418698f, 
    -0.01878301f, -0.01811153f, -0.02328238f, 0.02185496f, -0.04055053f, 0.01384853f, -0.00782361f, -0.03048400f, 
    -0.03417443f, -0.03985314f, 0.00958176f, -0.00344837f, -0.01948338f, 0.00316578f, 0.01731567f, 0.00876623f, 
    -0.01141651f, -0.00002845f, -0.02001307f, 0.00866903f, 0.00731317f, -0.01385126f, -0.02835179f, -0.04178087f, 
    -0.00796055f, -0.00097525f, 0.01091986f, -0.04725571f, -0.02056833f, -0.01432734f, -0.04896028f, 0.00932124f, 
    -0.03816863f, -0.01974602f, 0.01757649f, 0.01556962f, -0.00135099f, 0.00806235f, -0.02279412f, -0.00281235f, 
    0.01041015f, 0.00259803f, -0.02212821f, -0.03720272f, 0.01713821f, -0.01042536f, -0.03228356f, -0.03069904f, 
    -0.00898649f, -0.01589253f, -0.04276560f, -0.04067633f, 0.00872884f, 0.01060761f, 0.02193691f, -0.03488806f, 
    -0.02664493f, -0.04357267f, -0.00504939f, -0.04960600f, 0.01006251f, 0.00144746f, -0.00506704f, -0.03710566f, 
    -0.02078542f, -0.00697536f, -0.03923717f, -0.02817646f, 0.02198915f, 0.00978438f, 0.02624362f, 0.02408050f, 
    -0.00760213f, -0.03049975f, -0.00149182f, -0.01269568f, -0.00337492f, 0.00703025f, -0.00701385f, -0.04146072f, 
    0.01517355f, 0.01598294f, 0.01222924f, -0.00058623f, -0.03654357f, -0.00953898f, -0.04628108f, -0.03111466f, 
    -0.03270490f, -0.04169834f, 0.00409488f, -0.02818640f, -0.04867820f, -0.04008292f, 0.01896570f, -0.02651021f, 
    -0.00666863f, -0.01363813f, -0.02623402f, -0.01187497f, -0.01248477f, -0.00917924f, -0.02467396f, -0.04524496f, 
    0.00274923f, -0.01608196f, -0.04190769f, -0.01905424f, -0.03426464f, -0.04403250f, -0.04548421f, 0.02085051f, 
    0.00330963f, 0.00395330f, -0.02143598f, 0.02605383f, 0.01086187f, -0.02970074f, 0.01582818f, -0.04506218f, 
    -0.03840842f, 0.00635726f, -0.00217033f, -0.02260180f, -0.02829141f, 0.00307160f, 0.01263009f, -0.00564480f, 
    -0.03522228f, -0.02841106f, -0.02444954f, 0.02953649f, -0.03539343f, -0.02834617f, -0.04842198f, 0.00791575f, 
    -0.00629980f, -0.00361968f, -0.01085042f, -0.03147252f, -0.01783701f, -0.00320228f, 0.00426684f, 0.00696340f, 
    -0.02110772f, 0.00325398f, -0.03550613f, -0.03402662f, -0.04382393f, -0.04363837f, 0.01331528f, 0.01233910f, 
    -0.02146045f, 0.00257118f, -0.02531341f, -0.01868432f, 0.01257526f, 0.01242689f, 0.01613090f, -0.03443531f, 
    0.01287401f, -0.02765128f, 0.01499405f, -0.01516219f, 0.01250041f, -0.03757296f, -0.02984158f, 0.00824589f, 
    -0.02837631f, -0.01845613f, -0.00198950f, 0.01925535f, -0.01744012f, 0.01040285f, 0.00120257f, -0.04757759f, 
    -0.03012243f, -0.02251074f, -0.03491120f, 0.01848758f, 0.01972549f, -0.01750646f, -0.00031193f, 0.00583013f, 
    -0.04710554f, -0.02137756f, -0.03886331f, -0.02202476f, -0.01996227f, -0.03741777f, -0.00385234f, -0.01866974f, 
    -0.03704661f, -0.04055997f, -0.00940679f, 0.01824714f, -0.03131690f, -0.03428347f, -0.04550008f, -0.04684740f, 
    0.01319739f, -0.03055023f, -0.03774367f, 0.00025280f, -0.00150744f, -0.02558088f, -0.04524421f, 0.00918981f, 
    -0.02757613f, -0.02713672f, 0.00846103f, -0.01253173f, -0.01668880f, -0.04523114f, -0.00800614f, 0.01413190f, 
    -0.02101233f, -0.00096658f, 0.00449647f, 0.01702979f, -0.03657803f, -0.03612291f, -0.04238682f, -0.03804439f, 
    -0.03331741f, -0.00457241f, -0.02747374f, -0.02997302f, -0.03742761f, -0.03007063f, -0.01409527f, -0.02337156f, 
    -0.00809316f, 0.01387384f, 0.01454362f, 0.01332350f, 0.01950018f, 0.01049454f, -0.04793021f, 0.01268489f, 
    -0.02305062f, -0.01174160f, -0.01139970f, 0.00554847f, 0.01191136f, -0.04482678f, -0.04859531f, -0.03753184f, 
    -0.03753748f, -0.01474114f, 0.00423935f, -0.03803571f, 0.00581430f, -0.04651909f, -0.01899239f, 0.00454799f, 
    -0.03792642f, -0.01852573f, -0.02859745f, -0.03373017f, -0.00665463f, 0.02063751f, 0.01884086f, 0.01643400f, 
    0.00292833f, 0.02077664f, 0.00481385f, 0.00577754f, -0.03567618f, -0.04408516f, 0.02190280f, 0.02157867f, 
    -0.01399783f, -0.01726420f, 0.02301324f, -0.04302111f, 0.02403942f, -0.02360159f, -0.02743058f, -0.02772151f, 
    -0.02736370f, -0.02550091f, 0.00739647f, 0.01287786f, -0.03354875f, 0.01583083f, -0.03671331f, -0.02946527f, 
    -0.04506426f, 0.00372679f, 0.01153349f, 0.00781988f, -0.04045670f, -0.01975002f, 0.01034835f, -0.03603311f, 
    -0.04497458f, -0.03000994f, -0.04627136f, -0.01162347f, -0.04126424f, 0.01896115f, -0.01407641f, 0.00710582f, 
    -0.02452365f, -0.00038037f, 0.00146627f, -0.02492281f, -0.00683095f, -0.04615472f, -0.04040277f, -0.02125051f, 
    -0.04789084f, -0.04898737f, -0.01440485f, 0.00789477f, 0.00846113f, -0.04650537f, -0.02382586f, 0.00841790f, 
    -0.00115303f, -0.01673557f, -0.02303695f, -0.03451302f, -0.03262727f, -0.03711899f, -0.02290887f, -0.04404276f, 
    -0.03535146f, -0.01778461f, -0.03032834f, -0.02047815f, -0.00691184f, -0.03266363f, -0.04672930f, -0.00815791f, 
    -0.00597999f, -0.02369315f, -0.03006667f, -0.03237357f, 0.00506292f, -0.02011760f, 0.00975430f, -0.02583242f, 
    0.01149933f, -0.02784458f, -0.03223364f, -0.01149373f, -0.01368609f, -0.02698247f, -0.02234426f, -0.00636373f, 
    0.01119209f, 0.00174245f, -0.04270811f, -0.02048346f, 0.01215787f, -0.03284632f, -0.01432883f, 0.01112526f, 
    0.02001113f, -0.03648363f, 0.00471412f, 0.01009224f, -0.01467465f, -0.00326226f, -0.00419948f, -0.03367640f, 
    0.01599989f, 0.01361381f, -0.01247569f, 0.01511661f, 0.00534575f, 0.01009671f, -0.02194340f, -0.04406779f, 
    0.00452725f, 0.00123896f, 0.00074274f, -0.00315919f, -0.04298678f, -0.01029721f, -0.03026685f, -0.02030365f, 
    -0.02893337f, 0.01900727f, -0.03142227f, -0.03079452f, 0.01856887f, -0.02593797f, -0.00157295f, -0.01953765f, 
    0.02030147f, -0.01826803f, -0.02112248f, -0.03568363f, 0.01839915f, 0.00638109f, -0.02313457f, -0.03344042f, 
    -0.01546283f, -0.00468908f, 0.02250738f, 0.01745250f, -0.04352358f, -0.02910271f, -0.02068404f, 0.02107221f, 
    -0.04424550f, -0.02525122f, -0.03812769f, -0.03322314f, 0.01479325f, 0.00126048f, 0.01571278f, 0.00740380f, 
    -0.01858107f, -0.02711417f, 0.00270848f, -0.03272481f, -0.01568953f, 0.00054538f, 0.00324518f, 0.00342305f, 
    0.01369592f, -0.01225837f, -0.04418643f, -0.03166795f, -0.00648451f, -0.04092575f, -0.00787966f, -0.01712783f, 
    -0.00480700f, -0.02794034f, -0.00192166f, -0.01547573f, -0.01184298f, -0.01667954f, -0.01406565f, -0.02516724f, 
    -0.03249595f, -0.03812490f, -0.03371711f, -0.03449695f, -0.02462539f, -0.01731343f, -0.03231332f, -0.02140122f, 
    0.00456759f, -0.01095755f, -0.02491921f, -0.04511018f, -0.04848840f, -0.04308641f, -0.02418620f, 0.01001855f, 
    0.00702068f, 0.01445967f, -0.02088827f, 0.01309234f, -0.02697258f, 0.00116191f, -0.00186510f, 0.02162394f, 
    -0.02024433f, -0.03826253f, -0.01979373f, 0.02071024f, -0.03452349f, -0.03460168f, -0.00133622f, -0.00317315f, 
    0.00587480f, -0.02380789f, -0.02045958f, 0.01560163f, -0.02296444f, -0.01396020f, -0.04900678f, 0.01290734f, 
    -0.04043823f, -0.03885769f, -0.03398850f, -0.03741184f, -0.04616968f, -0.03853283f, -0.00586553f, 0.01566858f, 
    0.01247387f, 0.00804249f, -0.00445271f, 0.01271761f, 0.01119843f, 0.01825378f, -0.02689502f, 0.01483398f, 
    -0.04260466f, 0.01726979f, 0.02006425f, -0.00407631f, 0.01634096f, -0.04316085f, 0.01435248f, -0.04681111f, 
    0.02057436f, -0.02500122f, 0.01346570f, 0.01588727f, -0.04287601f, 0.02055768f, -0.02166982f, 0.00587275f, 
    -0.03333005f, 0.01422845f, -0.02189277f, -0.01718885f, -0.00717875f, -0.04333811f, -0.04668717f, -0.02040796f, 
    -0.00761279f, -0.03124152f, 0.01430113f, -0.00105745f, -0.03397278f, -0.03039492f, 0.00689461f, -0.01481284f, 
    -0.02537467f, -0.00897066f, -0.00964243f, 0.02012096f, 0.00518660f, 0.01354816f, -0.02833428f, -0.03335607f, 
    0.01179431f, -0.03634920f, 0.00307515f, -0.01247634f, -0.03162415f, 0.01666610f, 0.02499175f, -0.01945007f, 
    0.15743168f, -0.08074918f, -0.01420601f, 0.04732060f, 0.16501477f, -0.02488552f, 0.03062835f, 0.09766441f, 
    0.04608875f, 0.01943448f, 0.08649081f, 0.02181387f, 0.06639607f, -0.10577823f, 0.07751437f, -0.02214812f, 
    -0.00152052f, -0.05045897f, 0.24089035f, 0.17011760f, -0.09235425f, -0.01854219f, 0.13243574f, -0.02067544f, 
    -0.08898707f, 0.08276246f, 0.08181608f, -0.07623303f, -0.16948934f, -0.03667770f, 0.04901819f, 0.07535794f, 
    0.00472434f, 0.15286529f, 0.03787703f, -0.03248180f, 0.00687604f, 0.24879284f, -0.02662575f, 0.25187775f, 
    0.04174159f, 0.06529633f, -0.03060268f, 0.03120072f, 0.00012982f, 0.04571559f, 0.20529716f, 0.03881238f, 
    0.39557904f, 0.08876275f, -0.18197100f, -0.14937595f, 0.12099826f, -0.02251308f, -0.03493889f, -0.22424661f, 
    0.11371166f, 0.05342501f, -0.02672708f, -0.04856372f, 0.00682434f, -0.00311135f, 0.10502136f, 0.23079297f, 
    0.01550016f, -0.05656479f, 0.01544648f, 0.12408976f, -0.02647180f, 0.03719545f, 0.06425912f, -0.10055549f, 
    0.51723528f, -0.19694342f, -0.06009135f, -0.05433804f, 0.16437425f, 0.03999198f, -0.07169310f, -0.17133927f, 
    0.05589076f, -0.01776930f, -0.02421130f, 0.06438260f, 0.17000958f, -0.00319437f, -0.04354634f, -0.28777900f, 
    -0.11472621f, -0.02163500f, -0.07067037f, -0.07332489f, -0.01540400f, 0.01983063f, 0.07803509f, -0.02326002f, 
    0.24144892f, 0.07047816f, -0.25757965f, 0.05805406f, 0.05843763f, -0.05613377f, 0.18641767f, -0.10764262f, 
    -0.02787145f, 0.07398866f, 0.06875311f, -0.00030522f, -0.14698267f, 0.09887721f, 0.00132045f, -0.18103398f, 
    0.13476965f, 0.15181366f, -0.01782562f, 0.11278137f, 0.30110160f, 0.00748851f, 0.13159089f, 0.10705232f, 
    0.28956836f, 0.00423165f, -0.20024633f, -0.03166246f, -0.03690308f, 0.08573372f, -0.06164144f, -0.15723103f, 
    -0.04188113f, 0.04984352f, 0.02958990f, -0.15529351f, -0.37009740f, -0.18640801f, 0.10929981f, 0.21852501f, 
    0.00286494f, 0.04509412f, 0.12375143f, 0.21641962f, -0.17727552f, -0.02082647f, 0.17252304f, -0.04518289f, 
    -0.29670566f, -0.01119648f, 0.20476058f, 0.15057382f, 0.06312627f, -0.01487103f, 0.08369891f, 0.30084938f, 
    -0.05275049f, -0.01728988f, 0.19047399f, 0.07763531f, 0.70241553f, -0.18534523f, -0.21228606f, -0.34252059f, 
    -0.12103831f, -0.05525299f, 0.08553954f, 0.00497587f, -0.04380366f, -0.11743508f, -0.01280174f, -0.02235622f, 
    0.01190371f, 0.14628734f, -0.28564888f, -0.39345559f, 0.09073117f, 0.03069405f, -0.14568710f, -0.12999868f, 
    -0.03588222f, -0.05588724f, 0.13158105f, -0.05021291f, -0.11149397f, 0.10076135f, -0.23085836f, 0.18255517f, 
    -0.01819089f, 0.01608646f, -0.15162174f, 0.19450398f, 0.00645534f, -0.11017487f, -0.11740308f, -0.05042984f, 
    -0.21794289f, 0.00977924f, 0.31063530f, 0.19724603f, -0.35449359f, 0.11316925f, 0.05508293f, -0.11972044f, 
    -0.01135497f, -0.00680664f, 0.09130566f, -0.00449424f, 0.25746068f, -0.05215405f, -0.11634412f, 0.08741003f, 
    0.15195338f, -0.07288377f, 0.02393643f, 0.04499741f, -0.03750807f, -0.04324354f, -0.03537239f, -0.05672911f, 
    -0.06261598f, -0.11248641f, 0.11004865f, 0.22486630f, -0.02170571f, 0.02352175f, 0.05399192f, 0.02743251f, 
    -0.06010815f, 0.02972628f, -0.07391609f, -0.01175852f, 0.00251435f, 0.11712039f, 0.07439070f, -0.10542207f, 
    -0.05297185f, 0.02147322f, -0.01211894f, -0.01126699f, 0.08773090f, -0.00078395f, 0.11119585f, 0.17914467f, 
    -0.05254219f, 0.12256706f, -0.22734523f, 0.07268496f, 0.21465032f, 0.00489460f, -0.12884979f, 0.08198444f, 
    0.13725591f, 0.05323740f, 0.21115363f, 0.08603092f, 0.11444522f, 0.23157072f, -0.13877513f, -0.12676783f, 
    0.08989500f, -0.02008963f, 0.14039777f, -0.04911264f, -0.10659531f, 0.00884949f, 0.10668372f, 0.07412522f, 
    0.10002556f, -0.08170910f, 0.05593552f, -0.02524269f, 0.00896901f, 0.02357462f, -0.06962279f, -0.10223366f, 
    0.07916342f, 0.13988405f, 0.13285065f, 0.08439642f, 0.16194649f, 0.27903062f, 0.10793654f, -0.21244277f, 
    -0.09324513f, 0.19307247f, -0.00476381f, -0.00211341f, -0.09812371f, -0.02746127f, 0.10151763f, 0.22304310f, 
    -0.24555911f, -0.19079734f, -0.08325864f, 0.06365014f, 0.13168411f, 0.05454583f, 0.15184595f, 0.07557269f, 
    -0.00923292f, 0.00274441f, -0.10954664f, -0.12088941f, -0.16942035f, 0.14015748f, 0.23238795f, -0.01103512f, 
    -0.05860898f, 0.03392436f, -0.03536113f, -0.05953409f, -0.03122186f, -0.02145201f, 0.07359565f, 0.14160483f, 
    -0.08142023f, -0.11635876f, 0.00592683f, 0.16316999f, -0.09075559f, 0.00456003f, -0.02937239f, 0.02513925f, 
    0.00964738f, 0.01655459f, 0.03235304f, 0.00131873f, -0.17003188f, -0.04409518f, -0.01263558f, -0.22825871f, 
    -0.00807053f, -0.00613345f, -0.03047400f, -0.07759187f, 0.10805602f, 0.03964659f, -0.00967303f, 0.07968388f, 
    -0.20409796f, -0.23708360f, 0.19861452f, -0.07418250f, -0.05146091f, -0.16347927f, 0.09286853f, -0.02110538f, 
    -0.01384349f, 0.12059680f, 0.12787622f, 0.01455917f, -0.09528966f, 0.01063577f, 0.08067151f, -0.15506890f, 
    -0.08753443f, -0.01826440f, -0.05480469f, -0.08638407f, 0.13910666f, 0.15156825f, 0.05047956f, -0.00948425f, 
    0.08548868f, -0.15724221f, -0.06790535f, 0.23540150f, -0.06393931f, -0.13261934f, 0.01842908f, 0.26336136f, 
    -0.04783906f, 0.05149994f, 0.09161828f, 0.03913956f, 0.03978325f, 0.02538100f, 0.01822855f, -0.06480862f, 
    -0.00171083f, -0.06335235f, 0.18923365f, -0.05529400f, 0.15501137f, 0.04017083f, 0.29666325f, 0.19736950f, 
    -0.15181901f, -0.16043983f, -0.00886857f, 0.11747782f, -0.05773494f, -0.01394864f, 0.01089100f, 0.14910929f, 
    0.00691698f, -0.02001388f, -0.12867230f, -0.07108375f, 0.13806961f, 0.06381701f, 0.00248487f, 0.01703310f, 
    -0.02693331f, 0.08299590f, 0.01071180f, -0.10817868f, -0.03391185f, 0.18224187f, 0.05239634f, 0.14554758f, 
    0.06277471f, -0.08357558f, -0.15922688f, -0.14179780f, -0.05602543f, -0.08835738f, -0.07082167f, 0.03844476f, 
    -0.09818106f, -0.09233715f, -0.09856967f, -0.08188896f, -0.15318218f, -0.16589452f, 0.05153422f, -0.00829408f, 
    -0.01123583f, 0.00038125f, 0.12624758f, 0.36501932f, -0.07308490f, 0.19418758f, 0.05857188f, -0.03699198f, 
    -0.20880799f, 0.01150049f, 0.13586760f, 0.28112391f, -0.02630308f, -0.03721672f, 0.07971795f, 0.27120447f, 
    -0.12705617f, -0.09000339f, -0.02072005f, 0.01379102f, -0.07539307f, 0.07648434f, 0.13216096f, 0.13947704f, 
    -0.12287569f, 0.04613613f, 0.11600201f, 0.13681598f, 0.00967027f, 0.07482605f, 0.02840821f, -0.03589551f, 
    -0.32570359f, 0.41265872f, -0.00252746f, 0.09083985f, 0.19038157f, 0.15246369f, -0.00352915f, -0.12299822f, 
    0.09757008f, 0.02885652f, -0.08953675f, 0.10322522f, 0.09056550f, 0.11862385f, 0.05301092f, 0.00097729f, 
    -0.03206676f, 0.05624372f, 0.26842037f, 0.06692462f, 0.08181691f, 0.11104459f, 0.21323241f, 0.07302586f, 
    -0.09837557f, -0.14006761f, -0.05474259f, 0.25682911f, -0.08195426f, 0.04423986f, 0.17013498f, 0.05833883f, 
    -0.03295444f, -0.08087640f, 0.06077698f, 0.08354885f, -0.07713600f, 0.19989960f, 0.07628351f, -0.15114298f, 
    -0.04448604f, -0.08606631f, 0.00445837f, -0.13141157f, 0.21511270f, 0.00935102f, -0.07984447f, -0.07278227f, 
    -0.14659260f, 0.05489630f, 0.04438766f, -0.17659591f, 0.16992569f, -0.01506064f, 0.25538182f, 0.16774158f, 
    0.03869547f, -0.03143700f, 0.20004489f, 0.08347736f, 0.07470555f, -0.10609738f, -0.19501279f, -0.02971986f, 
    0.15778835f, -0.07381298f, 0.07142791f, 0.09236936f, 0.01792170f, -0.05546300f, -0.05417116f, -0.01042639f, 
    0.11838709f, -0.14542697f, -0.03043883f, -0.08830799f, 0.01360543f, 0.00800496f, 0.25326708f, -0.11639646f, 
    -0.10478153f, -0.00561510f, 0.05024069f, 0.01441651f, -0.00707219f, 0.10462521f, 0.04823474f, -0.21713163f, 
    0.14255038f, 0.15791631f, -0.08467973f, -0.09980164f, 0.00667118f, -0.00879832f, 0.07317896f, 0.03985805f, 
    -0.00681873f, -0.10678945f, 0.02973981f, 0.19748506f, -0.06736666f, -0.04815874f, 0.01165346f, 0.17782873f, 
    0.07098146f, 0.05944598f, -0.12407580f, 0.01108050f, -0.00719806f, -0.09071845f, 0.08212603f, 0.19412383f, 
    -0.00785812f, 0.09137870f, 0.14574364f, 0.07010797f, -0.01594816f, 0.20534277f, 0.11851254f, 0.01897831f, 
    -0.02947099f, 0.20989223f, 0.16207336f, -0.03111442f, -0.10200807f, 0.10810880f, -0.16827689f, 0.01497243f, 
    -0.02753203f, -0.03523877f, 0.07260648f, 0.01461177f, -0.13500573f, -0.17636050f, -0.14669152f, 0.03175866f, 
    0.14235449f, 0.00040555f, 0.02282260f, 0.08025351f, 0.07130901f, -0.00749209f, -0.00312744f, 0.04016393f, 
    0.20823684f, 0.16065432f, 0.00557480f, -0.15711488f, -0.10841869f, 0.05465268f, -0.06045869f, -0.07173213f, 
    0.01341995f, 0.01517873f, 0.01320477f, 0.00386355f, -0.13810797f, 0.02304321f, 0.14618914f, -0.01154649f, 
    -0.11769132f, -0.04458170f, 0.20370837f, 0.03696711f, 0.11910536f, -0.13032742f, 0.19505520f, 0.01558333f, 
    -0.14909369f, 0.11741991f, 0.11538482f, -0.14164133f, -0.07052521f, -0.04852935f, 0.00046982f, -0.04855258f, 
    0.16585112f, 0.11632890f, -0.07776441f, -0.08114541f, -0.20440122f, -0.19580451f, -0.01221801f, 0.18732430f, 
    0.06845653f, 0.17957765f, 0.04174226f, 0.24434082f, -0.12680420f, -0.02984786f, -0.00064414f, -0.02166676f, 
    -0.11608139f, -0.25926808f, -0.13782518f, 0.05959399f, 0.02412670f, -0.01113001f, 0.02271059f, 0.28415033f, 
    -0.00021915f, 0.06652762f, 0.04266251f, -0.09625782f, -0.10105422f, -0.12598887f, -0.01234435f, 0.19973826f, 
    -0.05713742f, -0.04780003f, 0.07703882f, 0.05611712f, 0.07876706f, 0.04845168f, 0.04428974f, 0.01513627f, 
    -0.20320466f, 0.46228305f, 0.25870329f, 0.10534841f, -0.17564265f, -0.18658952f, 0.07013538f, 0.00895569f, 
    -0.11420161f, 0.07263945f, 0.07153523f, 0.08478770f, -0.13450588f, -0.05549763f, 0.06975245f, 0.09862664f, 
    -0.07127561f, 0.05906335f, 0.00905965f, 0.08904371f, 0.06961834f, -0.08382350f, 0.12683980f, 0.08433788f, 
    0.13598728f, -0.25984851f, -0.25401342f, -0.02557604f, 0.01603370f, -0.06632496f, -0.06496041f, 0.09145159f, 
    -0.00059599f, 0.05739314f, 0.00959304f, 0.09129608f, -0.21038917f, -0.00055369f, 0.24381500f, 0.08178812f, 
    0.09292566f, -0.03952021f, 0.15347722f, 0.15772058f, 0.03051666f, -0.02584836f, 0.03590503f, -0.02638862f, 
    0.33347785f, -0.15954396f, -0.38941017f, -0.03836729f, -0.04448567f, 0.16652353f, -0.01940994f, -0.02214258f, 
    0.06043020f, -0.06737392f, 0.14104006f, 0.05205221f, 0.36887079f, 0.01517722f, -0.11492208f, -0.02991914f, 
    -0.02333258f, -0.10037593f, -0.05722568f, 0.03774156f, 0.04581317f, 0.06937288f, 0.16755943f, 0.08635441f, 
    0.21084444f, -0.11288998f, -0.14776842f, 0.06246363f, 0.13281366f, -0.15905309f, -0.06482191f, -0.09066991f, 
    -0.05030968f, 0.01739627f, 0.01295679f, 0.11668900f, -0.54011512f, 0.03663928f, 0.49884322f, 0.30295101f, 
    -0.00819833f, -0.03827896f, 0.20305045f, 0.07025922f, -0.08260246f, 0.01456823f, 0.04623195f, -0.04515050f, 
    0.12437097f, -0.01155682f, -0.16460517f, -0.14567024f, -0.06924004f, 0.00289740f, -0.11308812f, -0.00644470f, 
    0.01225711f, -0.12091748f, -0.00124930f, 0.15162994f, -0.31635359f, 0.21564029f, -0.42702872f, 0.20314762f, 
    0.02087118f, 0.13567868f, 0.00456883f, 0.04348697f, 0.19150676f, 0.16156870f, 0.05364076f, 0.15040363f, 
    -0.25829533f, -0.02145438f, -0.01605006f, 0.04731519f, 0.15162335f, 0.16237007f, 0.10732278f, -0.04584331f, 
    -0.01568430f, -0.01876380f, 0.01846109f, 0.05236509f, 0.13915373f, -0.41662771f, 0.16976796f, -0.16488257f, 
    0.12488538f, 0.05998810f, -0.10311519f, 0.05032390f, -0.10566770f, -0.08632380f, -0.14420912f, 0.05878146f, 
    -0.19565625f, 0.10340426f, -0.33916315f, 0.00526269f, 0.04844873f, 0.04642165f, 0.14483340f, 0.21533872f, 
    -0.11318231f, -0.12454955f, 0.01374423f, 0.02614386f, 0.11936542f, -0.14500463f, -0.02795138f, -0.16317685f, 
    0.05284210f, 0.04319623f, 0.01727223f, 0.11308499f, 0.13532470f, 0.17125598f, 0.05753249f, 0.10409950f, 
    0.27333754f, -0.27768841f, -0.06614873f, -0.03515115f, 0.00839097f, 0.19076017f, 0.27412656f, 0.00480967f, 
    -0.05040740f, -0.07206562f, 0.02357223f, -0.05683506f, -0.07348000f, -0.19185336f, -0.23764326f, -0.10936981f, 
    0.22153290f, 0.15975715f, 0.12773012f, -0.03712241f, -0.08186823f, -0.16763915f, -0.11118668f, -0.03550515f, 
    -0.16921030f, 0.00913134f, -0.12330368f, 0.14814469f, -0.00513621f, 0.05937294f, 0.04269556f, -0.19138730f, 
    0.19841310f, 0.03291063f, -0.29627150f, -0.10532477f, 0.00019214f, -0.11920305f, 0.36120746f, 0.19795237f, 
    0.04501002f, 0.13770698f, 0.02133409f, -0.08814725f, -0.19122718f, -0.10049594f, 0.03956557f, -0.04871901f, 
    -0.00147002f, -0.21344543f, 0.01259611f, -0.03758061f, 0.05605642f, 0.25001964f, 0.05628571f, 0.03505453f, 
    -0.00093786f, 0.09450410f, -0.04802018f, 0.16430378f, 0.09461880f, 0.39350921f, 0.01052747f, -0.24542537f, 
    -0.06783759f, 0.05336301f, -0.03946655f, 0.02452798f, 0.07012370f, -0.00802238f, -0.12150034f, -0.02392973f, 
    0.16836791f, 0.20729516f, 0.00694407f, -0.17911497f, -0.07264466f, -0.02924002f, -0.13468583f, 0.03742383f, 
    -0.04386477f, -0.07939991f, -0.04389568f, 0.02780736f, -0.27775028f, 0.07655184f, 0.20638981f, 0.13806127f, 
    -0.09364904f, 0.09933311f, 0.04048576f, 0.25723219f, 0.09641889f, -0.02132126f, 0.00072421f, 0.03325634f, 
    0.24557193f, -0.07587403f, 0.18377025f, 0.18226339f, -0.03932983f, 0.06745330f, -0.01710192f, -0.02042588f, 
    0.16571760f, 0.02372539f, 0.17002341f, 0.13788211f, 0.25831068f, -0.12095667f, -0.09115706f, -0.13148217f, 
    0.07618631f, -0.08284502f, -0.02131687f, 0.14859486f, -0.04340762f, -0.06151658f, 0.17238948f, -0.04425946f, 
    -0.01003561f, -0.13383223f, -0.30952746f, 0.14604796f, 0.03294107f, 0.02532053f, 0.11236854f, 0.10060017f, 
    -0.12238093f, 0.07690243f, -0.12602808f, -0.11141062f, -0.11687152f, -0.11291994f, -0.03547133f, -0.14718182f, 
    -0.07715476f, 0.20558234f, 0.05676597f, 0.27718416f, 0.09285933f, 0.00225639f, 0.01893821f, 0.16864216f, 
    0.01492589f, -0.07593859f, -0.17831631f, -0.26402441f, 0.03280524f, -0.09182241f, 0.04614509f, 0.15202941f, 
    -0.16082478f, -0.10216099f, 0.07810697f, -0.13963111f, 0.00359021f, 0.10425781f, 0.04488573f, -0.13124122f, 
    0.10403311f, 0.02186223f, 0.07865898f, -0.08846311f, -0.03898237f, -0.03172639f, -0.12888354f, -0.19659297f, 
    0.22585933f, 0.02669327f, 0.03205597f, -0.06197083f, -0.00072191f, 0.05656814f, 0.02073366f, 0.03375424f, 
    -0.01699244f, 0.07558765f, 0.12401623f, 0.12219913f, -0.07930325f, 0.03075615f, 0.18790726f, 0.00296831f, 
    -0.00759084f, 0.16389914f, -0.17060220f, 0.02254222f, 0.06760940f, -0.03731263f, -0.07428912f, -0.05110599f, 
    -0.19321811f, -0.06008898f, 0.09600905f, -0.25516960f, 0.00022832f, -0.12756161f, 0.13364129f, 0.08749215f, 
    -0.07353226f, 0.03261185f, 0.12859151f, -0.10451400f, -0.32637921f, -0.07872292f, 0.12457284f, 0.19071217f, 
    0.06713267f, 0.15211973f, -0.11308381f, -0.04479249f, -0.07017035f, 0.03654007f, 0.04175612f, -0.01233828f, 
    0.04487555f, -0.08607445f, -0.00337451f, -0.10563605f, -0.02963375f, 0.04989152f, 0.05823587f, -0.01760524f, 
    0.18997844f, 0.20115827f, -0.01078087f, 0.23893949f, -0.04148615f, 0.01449942f, 0.11316615f, -0.03941210f, 
    0.02306905f, -0.05539560f, -0.04509282f, 0.01349135f, 0.03116886f, -0.01726218f, 0.01696018f, -0.08691895f, 
    0.06260603f, 0.04662165f, -0.11189305f, -0.12345885f, 0.20398994f, -0.07588696f, 0.05790589f, 0.02526856f, 
    0.04228291f, -0.01130222f, -0.09244348f, 0.02788106f, 0.03017480f, 0.31744245f, 0.10206822f, -0.07449081f, 
    -0.08588659f, -0.07984085f, -0.14704953f, -0.03198813f, 0.02669654f, -0.05811112f, 0.14750029f, -0.02190662f, 
    0.25731760f, 0.09878177f, -0.01932606f, -0.11830469f, 0.06815893f, 0.15536965f, -0.17107497f, 0.15590657f, 
    -0.12440191f, 0.04839971f, -0.02662506f, -0.06353234f, -0.06113195f, -0.04396623f, -0.00645774f, -0.17679024f, 
    0.18981543f, 0.13045800f, 0.02295558f, 0.01518424f, 0.06869122f, 0.06260936f, -0.04344701f, 0.04795377f, 
    0.09794547f, 0.20625888f, 0.42796618f, 0.10313922f, -0.00957626f, -0.12968992f, 0.06347612f, 0.01773980f, 
    -0.08705820f, 0.10797373f, 0.04249110f, -0.03237670f, 0.02351248f, 0.41213304f, -0.02068100f, -0.04613657f, 
    0.05757361f, -0.16920094f, -0.12969367f, -0.04651497f, -0.05360926f, -0.03294298f, 0.02784715f, -0.09765267f, 
    0.02622639f, -0.03116711f, -0.28153217f, -0.31085989f, -0.10132542f, 0.02485537f, -0.06188076f, 0.02039686f, 
    0.02455915f, -0.14637035f, -0.04758013f, -0.05602363f, -0.03716272f, 0.00715312f, -0.09953343f, 0.01121028f, 
    -0.12049567f, -0.01624756f, 0.03821514f, -0.00051639f, 0.12637711f, -0.06264836f, -0.22839013f, -0.08346219f, 
    0.03368846f, -0.06244765f, 0.13908811f, 0.02732561f, -0.11462543f, 0.02724708f, 0.02547226f, 0.29608417f, 
    0.09585634f, 0.09910352f, -0.00035771f, 0.07598237f, 0.32947126f, 0.22927336f, 0.11034435f, -0.17305811f, 
    -0.05810226f, -0.09821355f, -0.05026509f, 0.02315485f, -0.00546094f, -0.10279228f, -0.04237963f, -0.00220240f, 
    -0.05663641f, 0.28538838f, -0.47341710f, 0.02839730f, 0.07555564f, 0.07018126f, 0.26086262f, 0.09320325f, 
    0.15778065f, 0.12288842f, 0.01561559f, 0.01818133f, -0.06367017f, 0.01489426f, -0.17744973f, -0.09315169f, 
    0.06834298f, -0.06261011f, 0.15046000f, 0.12118950f, 0.20544355f, 0.05808107f, 0.15593456f, 0.08025643f, 
    0.47896931f, -0.48565531f, 0.21612716f, -0.17792623f, 0.05665738f, -0.16116828f, -0.12038344f, 0.08289289f, 
    0.13755362f, 0.11668041f, 0.14235665f, -0.06060700f, -0.24336071f, 0.12410787f, 0.03880115f, 0.10655786f, 
    0.13234276f, 0.00613874f, -0.07784122f, -0.03578693f, -0.17223807f, -0.00599481f, -0.03583327f, -0.10807150f, 
    0.14279230f, 0.03860212f, 0.06842173f, -0.08472060f, 0.12959497f, 0.16815419f, 0.02503984f, 0.02890187f, 
    0.02934325f, 0.02358274f, 0.12595001f, -0.12623200f, 0.04785429f, -0.09959549f, -0.14238022f, -0.11782584f, 
    -0.02354879f, -0.05418530f, 0.08680299f, -0.06649125f, 0.22844599f, 0.10101167f, 0.06642158f, 0.08609548f, 
    -0.10560561f, 0.00579571f, -0.13275301f, 0.00291480f, -0.02773271f, 0.18253276f, 0.11021332f, 0.00400516f, 
    0.04241347f, -0.23274757f, -0.06303088f, -0.16703421f, 0.18119021f, -0.14183667f, -0.03715400f, -0.14693667f, 
    -0.16039298f, -0.01793293f, -0.10891619f, 0.06946205f, -0.05192696f, -0.05894889f, -0.01591101f, 0.12007249f, 
    0.08632696f, -0.21645264f, 0.04445111f, 0.02304112f, -0.05239014f, -0.04657546f, 0.01100501f, 0.16326760f, 
    0.06613448f, 0.06931803f, -0.00785054f, 0.05368060f, -0.01932717f, -0.30406666f, -0.10251807f, -0.05560059f, 
    0.18586342f, -0.00413310f, 0.24288239f, -0.10139206f, -0.06858864f, 0.01168875f, -0.17010716f, -0.02787130f, 
    0.10231713f, -0.02316644f, -0.08818975f, -0.09273525f, 0.17450967f, 0.06377573f, 0.13387978f, -0.11933667f, 
    0.04094323f, -0.08376436f, 0.06692049f, 0.02900852f, -0.15358369f, -0.12544432f, -0.00804224f, -0.28214386f, 
    -0.07601504f, -0.06521896f, 0.06457130f, 0.03482871f, 0.10066753f, 0.01786646f, -0.00671068f, 0.02265989f, 
    -0.12216911f, -0.12205102f, -0.08078424f, -0.21050197f, 0.01046312f, -0.07883247f, 0.30631524f, -0.02797284f, 
    0.12020999f, 0.00180673f, -0.02674174f, 0.19195530f, 0.12972680f, 0.02058880f, 0.29009885f, -0.15896243f, 
    0.04197898f, 0.05264071f, -0.01376782f, 0.10245531f, -0.02354761f, 0.03265950f, -0.05128082f, 0.04480276f, 
    -0.05634914f, -0.36086768f, -0.30415374f, 0.09471758f, -0.05547804f, 0.16588998f, 0.14993833f, -0.05460315f, 
    -0.02714881f, -0.03417017f, -0.06215497f, 0.06736711f, 0.04865180f, 0.02911003f, -0.43756041f, -0.01502194f, 
    -0.09157604f, 0.09937482f, -0.16880772f, 0.01782430f, -0.01701890f, 0.11733624f, 0.10649867f, 0.00118824f, 
    0.05123973f, -0.06233218f, -0.23675537f, -0.01046797f, -0.01584611f, 0.00484660f, 0.01704798f, 0.02324233f, 
    0.08929785f, 0.07597768f, 0.18246017f, 0.04868146f, 0.28704360f, 0.26525077f, -0.06262662f, -0.08256698f, 
    0.12238088f, -0.09710697f, 0.11079469f, 0.04407754f, 0.06131560f, 0.08882823f, 0.01732692f, -0.08375944f, 
    0.09117044f, -0.01833758f, -0.01604842f, -0.03659786f, -0.11876561f, -0.02607285f, -0.02785734f, 0.07359178f, 
    -0.00764649f, 0.02988051f, 0.07162236f, 0.14242539f, 0.15150510f, 0.13329026f, -0.01498645f, -0.20579782f, 
    0.02372363f, -0.01180382f, -0.04080182f, 0.05395280f, -0.00782339f, -0.03496636f, 0.03275787f, -0.00808041f, 
    -0.56271821f, 0.15077871f, -0.48211706f, 0.10342956f, 0.10307249f, 0.09289239f, 0.18610378f, -0.07662770f, 
    0.01637232f, -0.09180166f, 0.02743263f, 0.18040852f, 0.18291335f, 0.04361279f, 0.06355193f, 0.07267266f, 
    0.01612607f, 0.02581337f, 0.01080634f, -0.15970276f, 0.03893687f, 0.03503101f, 0.04134765f, 0.11010340f, 
    0.10578044f, -0.01225637f, 0.19367622f, -0.00912113f, -0.21640927f, -0.06424376f, -0.01478921f, 0.06010789f, 
    0.12893526f, 0.03392771f, -0.10523098f, 0.10402299f, -0.23826802f, 0.12648983f, -0.30547488f, -0.01687528f, 
    0.07929357f, 0.04472852f, 0.02457086f, -0.05973909f, -0.07920793f, -0.02004527f, -0.08883724f, -0.18244816f, 
    0.55606937f, -0.21050654f, 0.48893330f, 0.00846179f, 0.06867375f, 0.05070750f, -0.12477103f, -0.04193534f, 
    -0.07961594f, 0.09913200f, 0.04594197f, 0.04681785f, 0.15172696f, 0.07579905f, 0.25156343f, 0.08587379f, 
    -0.07303949f, -0.09936769f, -0.14971815f, -0.12639017f, 0.00732021f, -0.03926326f, 0.05499134f, 0.01533690f, 
    -0.01500515f, -0.09526900f, -0.13981684f, 0.07071020f, -0.01203741f, 0.13416992f, 0.10924810f, 0.07199406f, 
    0.04935892f, -0.02303437f, -0.13249327f, -0.19437534f, -0.18227407f, 0.03467238f, -0.25414869f, -0.12583746f, 
    0.06558719f, 0.10163745f, 0.14219084f, 0.07565966f, 0.04787156f, -0.11227724f, -0.00876270f, -0.06400042f, 
    -0.02331008f, 0.14809155f, -0.05251529f, -0.08145753f, 0.01226680f, 0.09387742f, 0.01781194f, -0.00555605f, 
    -0.03538488f, -0.01464665f, -0.04230396f, 0.03148681f, -0.20653337f, 0.14416786f, -0.10685553f, 0.29250225f, 
    0.12293892f, 0.04476745f, 0.04728295f, 0.04484080f, -0.13430427f, -0.08863479f, -0.12285123f, -0.02490390f, 
    -0.18091340f, -0.28848174f, -0.38218042f, 0.15867153f, 0.06137989f, 0.09490814f, -0.00166925f, -0.12170607f, 
    0.10460412f, -0.09614480f, 0.06009348f, -0.03038264f, 0.11034345f, -0.05345728f, 0.07538103f, -0.10575604f, 
    -0.00613756f, 0.07926027f, 0.11434945f, 0.07423875f, -0.08935860f, -0.00625211f, -0.14300856f, 0.01468373f, 
    -0.23251814f, -0.27544135f, -0.05264730f, 0.00383865f, -0.06858193f, 0.07545545f, -0.09720705f, 0.00008441f, 
    -0.03894695f, -0.20008917f, -0.05377522f, 0.06743155f, 0.32594693f, -0.11628301f, 0.00845454f, 0.00146540f, 
    0.04342024f, 0.01816295f, 0.02209860f, 0.15499547f, -0.04255553f, -0.09527358f, -0.18360379f, -0.16536570f, 
    -0.11437418f, 0.04240096f, 0.13800591f, -0.11026668f, 0.06676786f, 0.06230503f, -0.03022354f, 0.21358916f, 
    -0.03741226f, -0.00305490f, -0.02188641f, 0.00488216f, -0.39409652f, -0.44542548f, 0.00110273f, -0.07019928f, 
    0.21067582f, 0.10411569f, -0.01232736f, -0.04750656f, 0.00802763f, -0.02698737f, -0.05760616f, 0.04666429f, 
    -0.13089633f, 0.06139515f, 0.38596782f, 0.14783603f, 0.14494230f, 0.10888422f, 0.02197545f, 0.03561162f, 
    -0.00670857f, -0.04655667f, -0.10577793f, -0.00845381f, 0.05164656f, -0.28302675f, 0.07425258f, 0.08560104f, 
    0.02212612f, 0.06501880f, 0.05291454f, 0.01485337f, -0.00849723f, -0.03263680f, 0.02026740f, 0.08313522f, 
    0.01527038f, -0.27567160f, 0.24943946f, -0.02956956f, 0.05378157f, 0.10085169f, -0.05857718f, -0.03137109f, 
    -0.01298610f, 0.03366026f, -0.09973808f, -0.05692543f, 0.16331062f, 0.18524152f, 0.02053555f, -0.02677157f, 
    -0.04223252f, -0.03624295f, -0.05424293f, 0.14994261f, 0.06041482f, -0.12140844f, -0.04761042f, -0.05826778f, 
    0.36249167f, 0.25667498f, 0.16637707f, -0.06885509f, -0.00603146f, 0.07005861f, -0.07971795f, 0.17922227f, 
    0.13602789f, -0.05815881f, -0.20638184f, 0.08497056f, -0.57748789f, -0.09409174f, -0.17932731f, -0.26715252f, 
    -0.03759836f, 0.01984181f, 0.00843379f, 0.25269401f, 0.04070349f, -0.04349077f, -0.01557129f, 0.02246393f, 
    0.08859551f, -0.15670709f, 0.05282158f, 0.03202089f, -0.04872580f, -0.08669583f, -0.03131175f, 0.02697409f, 
    0.01387058f, 0.02997199f, 0.03984971f, 0.08878731f, 0.22660249f, 0.16011922f, 0.33537641f, 0.04878352f, 
    0.11986928f, 0.00737511f, 0.10556051f, 0.02529685f, -0.00857228f, -0.00373038f, 0.00406917f, -0.00343299f, 
    -0.09081881f, 0.10095243f, -0.40716767f, 0.02856180f, 0.06718132f, -0.13669096f, 0.09574285f, 0.27832431f, 
    0.01189105f, -0.05729225f, -0.06610009f, -0.01242925f, -0.05417269f, 0.18032520f, 0.08652824f, -0.19045331f, 
    0.03857251f, 0.02511017f, 0.04499926f, 0.06568355f, -0.06844122f, -0.03184585f, -0.14522991f, 0.06494189f, 
    0.16064222f, 0.19235614f, 0.01190698f, 0.00614310f, 0.12772188f, 0.01915412f, 0.08593826f, 0.08503285f, 
    -0.05563962f, -0.11275493f, -0.01632586f, 0.02809989f, -0.20287694f, -0.23998594f, -0.12811838f, -0.16802339f, 
    -0.00773541f, 0.05157749f, -0.10061641f, -0.08110812f, 0.06543324f, 0.09984930f, -0.01186739f, -0.10568657f, 
    0.11134966f, 0.04298832f, 0.23233308f, -0.02330078f, 0.01050885f, 0.07038114f, 0.08575492f, 0.00889986f, 
    -0.06835259f, 0.04311164f, -0.02637328f, -0.02930556f, 0.01575972f, -0.26440576f, 0.17611353f, 0.21792197f, 
    0.02470446f, 0.07864259f, -0.11081910f, 0.06855825f, 0.10278514f, 0.07982720f, -0.12818675f, -0.03556617f, 
    -0.17427804f, -0.26684967f, -0.11484659f, -0.07466677f, 0.05057359f, -0.07397830f, -0.00452809f, -0.00731098f, 
    0.07198624f, -0.18804297f, 0.08146456f, 0.06677987f, -0.08298586f, 0.00534555f, 0.03376114f, 0.26846576f, 
    0.07364077f, -0.04123797f, 0.03651279f, -0.01659833f, 0.06088822f, 0.03245875f, -0.08269942f, -0.08501370f, 
    0.00656849f, 0.08332337f, 0.04899470f, 0.03951048f, -0.01472479f, -0.03992267f, -0.04407831f, 0.01731415f, 
    -0.09044670f, -0.05312847f, 0.00846121f, 0.04890829f, 0.13750879f, -0.24022944f, -0.24771394f, 0.03451313f, 
    -0.10906032f, -0.09491921f, -0.10344017f, 0.02148384f, 0.09677432f, -0.18202697f, -0.05677266f, -0.06801715f, 
    0.23331961f, 0.27029318f, 0.29740787f, 0.14263432f, 0.21241885f, 0.02409962f, 0.06591652f, 0.25702184f, 
    -0.01032291f, 0.05287068f, -0.05713646f, 0.04825572f, 0.07040256f, -0.23662886f, -0.26622808f, -0.14141519f, 
    -0.08552832f, -0.00853318f, -0.16105832f, -0.01254520f, 0.16823068f, -0.03508424f, 0.09785698f, 0.04624231f, 
    0.06584695f, -0.19145773f, -0.02443085f, -0.14716573f, -0.06695166f, 0.16683161f, -0.13563846f, 0.22293694f, 
    -0.03484973f, -0.19122910f, -0.11700322f, 0.04023224f, -0.03059717f, -0.09603275f, -0.14386259f, 0.08759379f, 
    0.18583283f, 0.08341499f, -0.05531343f, -0.08304750f, -0.06757464f, -0.05113623f, 0.14759152f, 0.02296003f, 
    0.21716614f, 0.03547218f, 0.17951939f, 0.00135135f, -0.02176012f, 0.06965711f, 0.09641153f, 0.07571589f, 
    0.00237290f, -0.09653698f, 0.10824921f, -0.02116907f, -0.06915613f, 0.08507843f, -0.15609699f, 0.02906090f, 
    -0.05366015f, 0.11389129f, -0.07230516f, -0.03950450f, -0.04012806f, 0.04219295f, -0.10720872f, -0.02710825f, 
    0.19801702f, 0.14060614f, 0.00756464f, -0.09340014f, 0.12876740f, 0.12600952f, 0.03946254f, -0.00972263f, 
    0.04811021f, -0.08963217f, 0.02703411f, -0.00749980f, -0.17552075f, -0.21378280f, -0.08822112f, -0.02709752f, 
    -0.12747967f, -0.03379286f, -0.02102815f, 0.02569709f, 0.05493570f, -0.08858865f, -0.04688632f, 0.05294412f, 
    0.10960864f, -0.29542711f, -0.08712640f, -0.18111856f, -0.10875912f, -0.02287427f, -0.08807691f, 0.12497399f, 
    0.11754286f, -0.02724537f, 0.03790205f, -0.01491176f, 0.13273869f, 0.06932084f, 0.09805814f, -0.03500354f, 
    0.01626874f, 0.01787744f, 0.04735806f, 0.12640958f, 0.01481317f, -0.00868668f, 0.05415588f, -0.10848189f, 
    0.16843796f, 0.19029979f, -0.29116255f, 0.05394786f, -0.05468469f, 0.04246742f, 0.12040742f, 0.02368492f, 
    0.02919089f, 0.03537900f, -0.04842678f, -0.00474681f, 0.12584578f, -0.13626379f, -0.17996866f, 0.05988262f, 
    0.01571421f, -0.03375272f, 0.07425249f, 0.02258648f, 0.11138029f, -0.23398966f, -0.07394963f, -0.20208028f, 
    0.41138390f, -0.48905891f, 0.39549413f, -0.09503850f, -0.12333830f, -0.03540149f, 0.05098476f, -0.00594571f, 
    0.07669626f, -0.06018914f, -0.14763924f, -0.03470498f, -0.03396364f, 0.08250012f, -0.07083353f, 0.07102291f, 
    0.07715325f, 0.07399198f, -0.02039773f, -0.07558105f, -0.03743958f, 0.01852927f, -0.11569367f, 0.04667281f, 
    0.23204193f, 0.26311785f, 0.37008253f, 0.03904110f, 0.18070990f, 0.03796733f, -0.08941692f, 0.14537439f, 
    -0.00912067f, -0.03837669f, 0.09308673f, -0.06749550f, 0.02519379f, -0.28166649f, -0.16058558f, 0.05132623f, 
    0.00159354f, -0.04643419f, -0.01122821f, -0.08685170f, 0.04745875f, -0.21535839f, -0.00441610f, 0.02308282f, 
    -0.29577926f, -0.04977034f, -0.11944457f, 0.10000554f, 0.07217191f, 0.11210186f, 0.06420074f, 0.12270113f, 
    0.11695798f, 0.00405144f, -0.02119981f, 0.06515644f, 0.06765256f, 0.24343820f, 0.00801395f, -0.09985165f, 
    -0.09378183f, 0.12974846f, 0.07015855f, 0.10831641f, -0.02704414f, 0.01858117f, -0.01097193f, 0.03850313f, 
    -0.05790621f, -0.07926512f, -0.07369242f, -0.12021916f, -0.03639149f, -0.03712127f, 0.01867720f, 0.22401421f, 
    0.01734216f, 0.00669576f, 0.05778487f, 0.04290147f, -0.00767723f, -0.14858525f, -0.28265169f, -0.33059597f, 
    -0.03865656f, 0.03196479f, 0.16936064f, 0.07167882f, 0.08255624f, 0.12456357f, -0.03075570f, 0.08127064f, 
    0.13172492f, 0.13591173f, 0.23918726f, 0.07554450f, 0.14351030f, 0.00623622f, 0.16403006f, 0.06835927f, 
    -0.00697943f, -0.00372001f, 0.07151557f, 0.02543776f, -0.16918792f, 0.07408134f, 0.05169265f, -0.11257829f, 
    0.00914220f, 0.00064910f, 0.29291886f, 0.09739268f, 0.14657578f, 0.00307002f, 0.06438827f, -0.00999960f, 
    -0.02826776f, -0.26604518f, -0.04850611f, -0.12524341f, -0.01896294f, -0.18950588f, 0.10536643f, -0.02279097f, 
    -0.03732472f, 0.05239502f, -0.04948343f, -0.15339695f, 0.17158593f, 0.12697250f, 0.19624633f, 0.03422936f, 
    0.10154077f, 0.05423861f, -0.02060148f, 0.12304706f, 0.00843037f, -0.01758812f, -0.06946226f, 0.03455184f, 
    -0.37972036f, -0.28576213f, -0.30965778f, -0.00443509f, -0.03564736f, -0.13279361f, -0.04301269f, 0.05017400f, 
    0.05342139f, -0.08416177f, -0.10502848f, -0.04570888f, -0.27568561f, -0.18130179f, -0.42531970f, 0.02582321f, 
    -0.02876375f, 0.09090749f, -0.03215106f, -0.13149759f, 0.08597557f, 0.09417603f, -0.02043246f, 0.02768336f, 
    0.18288231f, -0.38854331f, -0.33377829f, -0.04706622f, -0.00158568f, -0.04792507f, -0.05111106f, -0.02237361f, 
    0.12391500f, -0.15662375f, 0.00034417f, -0.07850239f, 0.36259824f, 0.30229679f, 0.21897633f, 0.05456155f, 
    0.09886613f, -0.02370230f, 0.10639540f, 0.16623566f, -0.11712695f, 0.02317803f, -0.10412619f, 0.04570005f, 
    0.25431257f, 0.02524536f, -0.07334244f, -0.10956458f, 0.01030414f, 0.04069544f, -0.03891894f, -0.01868700f, 
    -0.02198496f, -0.14710839f, -0.10556858f, 0.00749264f, 0.14300223f, 0.22297439f, 0.31391177f, 0.03220112f, 
    0.05710599f, 0.00249130f, -0.05939464f, 0.07314573f, 0.01508826f, -0.12108624f, 0.02386714f, 0.09147040f, 
    -0.27917734f, -0.37219557f, -0.32079414f, 0.17844655f, 0.02084353f, 0.13839386f, 0.09066998f, -0.09215215f, 
    0.16832310f, -0.07511488f, -0.05310768f, 0.01807619f, 0.17885432f, 0.10445847f, 0.17772529f, 0.12061114f, 
    -0.00570558f, -0.01167689f, 0.12239766f, 0.11797208f, -0.09520043f, 0.01331707f, 0.01465053f, -0.06799874f, 
    -0.03096685f, 0.18778640f, 0.00287861f, -0.05861519f, -0.09370452f, 0.00735667f, 0.08259170f, 0.03934676f, 
    0.07416108f, 0.00894249f, -0.04678397f, -0.05205065f, 0.07074719f, 0.26107401f, -0.36520410f, -0.04685785f, 
    -0.01839393f, -0.08562239f, 0.07343666f, 0.09121617f, -0.02593321f, 0.13325816f, 0.02295865f, -0.03182294f, 
    0.08688138f, 0.01115164f, 0.36130059f, 0.03065661f, 0.01997146f, 0.04038930f, 0.06067430f, 0.14376748f, 
    0.08110397f, 0.04130812f, -0.17544493f, 0.05456540f, 0.09390885f, 0.01886042f, -0.07707822f, -0.05671192f, 
    -0.19983426f, 0.01867481f, -0.01893393f, -0.03555905f, 0.12038101f, -0.07016846f, -0.02272009f, 0.00326075f, 
    -0.03110197f, 0.09990067f, 0.16388078f, 0.08466210f, -0.02647584f, 0.21197227f, 0.08763942f, 0.28323454f, 
    -0.03335696f, -0.01785130f, 0.03082254f, -0.05068835f, 0.25774527f, 0.15507573f, -0.22103705f, -0.04360847f, 
    0.05296599f, 0.07477969f, 0.16204631f, 0.11415184f, 0.10919919f, -0.13892274f, 0.07332321f, -0.05254382f, 
    -0.01542926f, -0.00219643f, 0.02855705f, -0.02194366f, 0.01476713f, 0.01999731f, -0.02899756f, -0.02955096f, 
    -0.01024663f, 0.01756732f, -0.04136124f, 0.02411442f, -0.02440351f, 0.01095254f, -0.02954384f, 0.00873172f, 
    -0.00709996f, 0.01398144f, -0.02754616f, -0.01896967f, 0.01229570f, -0.03278193f, -0.00009473f, 0.01926987f, 
    0.00172378f, -0.02527922f, 0.00081851f, 0.00339988f, -0.00859110f, -0.02364844f, -0.02228784f, -0.03221042f, 
    -0.01079511f, 0.02750335f, -0.02750398f, -0.02515733f, -0.03938938f, -0.02695397f, -0.02447452f, -0.02028224f, 
    -0.01598340f, 0.02670182f, 0.00533198f, -0.00618191f, -0.03565672f, -0.02036251f, -0.02128511f, -0.00692606f, 
    -0.00607629f, 0.00944015f, 0.02122365f, -0.02996288f, -0.02769525f, -0.01882287f, 0.02884453f, 0.02556736f, 
    -0.01552015f, -0.02769351f, 0.01100420f, -0.03188638f, 0.01155832f, -0.03948850f, -0.02623434f, -0.03055642f, 
    -0.00284595f, -0.03645743f, -0.02885621f, 0.02457618f, 0.02596845f, 0.00912183f, 0.01364864f, -0.00354994f, 
    -0.02778519f, 0.01787002f, -0.02721914f, -0.02645404f, -0.03577796f, -0.03043863f, 0.00330316f, -0.04080233f, 
    -0.01601500f, 0.00328954f, -0.03976532f, 0.00065750f, 0.01242517f, 0.02941979f, -0.02887472f, -0.00295409f, 
    0.02392006f, -0.02101660f, -0.01660573f, -0.02956088f, 0.00909965f, -0.02346190f, 0.00614239f, 0.00920501f, 
    -0.01339465f, -0.00291065f, 0.02942829f, 0.01749936f, 0.01367336f, 0.02269965f, -0.00527185f, -0.01059328f, 
    0.02565926f, 0.00049140f, -0.01706948f, 0.01727111f, 0.03408764f, -0.02397662f, 0.01582267f, -0.00684120f, 
    -0.00801202f, -0.00939991f, 0.01438932f, 0.02691912f, 0.02515504f, -0.01800241f, 0.01982474f, -0.00706077f, 
    -0.02402990f, 0.00311977f, -0.01192364f, -0.02300909f, -0.03152430f, 0.00733742f, 0.02475135f, -0.02775681f, 
    -0.02306549f, 0.02114930f, 0.02408995f, 0.02322634f, -0.02676263f, 0.01661032f, 0.02112275f, 0.02126253f, 
    0.02999793f, 0.01843422f, -0.01201368f, -0.00006661f, 0.02793829f, -0.02900935f, -0.02483017f, -0.00171573f, 
    0.01389683f, -0.00762635f, 0.01236554f, -0.00874409f, 0.00248251f, -0.03249295f, -0.01218597f, 0.00327895f, 
    -0.02660526f, -0.02258700f, 0.00615296f, -0.02409308f, 0.01994520f, -0.02246694f, -0.00088358f, -0.02614188f, 
    -0.02890307f, -0.02195236f, -0.01234736f, -0.02428552f, -0.00109337f, 0.01337232f, -0.03955033f, 0.00365044f, 
    -0.01940704f, -0.03968218f, 0.02746466f, -0.00080875f, 0.00205295f, -0.04143874f, 0.01246072f, -0.01773838f, 
    -0.01113561f, -0.01792976f, -0.03415688f, -0.03352348f, -0.02725820f, 0.02829333f, -0.03328374f, 0.00221841f, 
    -0.00138115f, 0.00238735f, -0.01814828f, -0.02241208f, -0.01516105f, 0.02397828f, 0.01593043f, 0.01318360f, 
    0.02177722f, 0.02756304f, -0.01978523f, -0.04102157f, 0.01765073f, -0.02962645f, -0.01439581f, 0.00665032f, 
    -0.00891839f, -0.00638123f, -0.02102040f, 0.00870243f, -0.03279408f, 0.01219016f, -0.01031339f, -0.00085761f, 
    -0.03223070f, 0.01276904f, -0.02185613f, -0.04064349f, 0.00901048f, -0.01751438f, 0.00090490f, -0.00115569f, 
    0.01709378f, -0.01021823f, -0.02705531f, 0.00963482f, -0.01269418f, 0.02299364f, -0.02250530f, -0.03230434f, 
    0.01180485f, -0.02422960f, 0.02786053f, -0.03535097f, -0.00169537f, 0.00197396f, -0.03982376f, -0.01667741f, 
    -0.00775382f, 0.01302134f, 0.02465462f, 0.01842729f, -0.02666573f, -0.01308729f, -0.02831738f, 0.03156695f, 
    -0.01902110f, -0.04159622f, 0.02822273f, -0.03816563f, -0.01698205f, 0.00334237f, 0.01440990f, -0.02714624f, 
    -0.01709531f, 0.02460685f, -0.02998778f, -0.00782361f, 0.01073621f, -0.04165149f, -0.02355257f, 0.00202968f, 
    -0.02807176f, 0.00771927f, -0.02150309f, 0.00852263f, 0.01619184f, -0.03542464f, 0.00008550f, 0.00265139f, 
    0.02265563f, -0.02729520f, -0.03695550f, -0.02548804f, -0.02090686f, 0.00612325f, -0.01496883f, 0.00564327f, 
    -0.01469723f, 0.03004093f, 0.01893760f, -0.02032332f, 0.00316762f, -0.01156360f, 0.02330207f, 0.01803700f, 
    -0.04169984f, -0.03836677f, 0.02052019f, -0.00742529f, 0.02284974f, -0.03750597f, 0.00795801f, 0.00396438f, 
    -0.00706017f, 0.01226465f, 0.02807030f, 0.01107019f, -0.03974345f, 0.01719374f, -0.00816936f, -0.00281949f, 
    -0.02606072f, -0.02819324f, -0.02194111f, -0.00208728f, -0.03948737f, -0.00488332f, -0.01860860f, 0.02433084f, 
    0.02043222f, 0.01538875f, -0.00982549f, 0.02885165f, -0.02009229f, 0.01922761f, -0.03880708f, -0.03469770f, 
    -0.02522471f, 0.00400467f, -0.01852255f, -0.02060687f, 0.00095324f, -0.00237819f, -0.00339467f, -0.00695103f, 
    -0.01012667f, -0.03815663f, -0.01485299f, 0.01320541f, -0.00055279f, -0.03758135f, -0.04142094f, -0.03581260f, 
    -0.01062411f, -0.00994734f, -0.01075054f, -0.02158898f, 0.01336202f, -0.02140391f, -0.00571311f, -0.03593347f, 
    0.01175436f, -0.03632775f, -0.01351327f, 0.01041576f, -0.02894154f, -0.03656559f, -0.00093327f, 0.02839014f, 
    -0.00957026f, -0.03494456f, 0.01959091f, 0.00543785f, 0.01947489f, -0.02900575f, -0.01436685f, -0.02803394f, 
    0.00041219f, 0.01638617f, 0.01815431f, -0.00389404f, -0.02766293f, -0.01531611f, 0.02844415f, 0.02650727f, 
    -0.01916645f, -0.01551100f, 0.00888086f, -0.01862225f, 0.02423766f, 0.01591209f, 0.00628174f, 0.00943322f, 
    -0.00838848f, -0.00159043f, -0.02972223f, 0.01784378f, 0.00157963f, 0.00353374f, 0.02142479f, 0.01021759f, 
    -0.03202090f, -0.02901992f, -0.02073100f, 0.02130726f, -0.01718661f, 0.02351609f, 0.01770805f, -0.02453870f, 
    0.01499603f, 0.02993750f, 0.01396068f, -0.03273799f, -0.03016628f, -0.02810726f, 0.02141889f, -0.03414799f, 
    -0.00625848f, -0.01225198f, -0.00068932f, -0.00666142f, 0.02355578f, -0.03635399f, -0.00665418f, 0.01924394f, 
    0.02690641f, 0.02065569f, -0.02266953f, -0.02509077f, 0.01793710f, 0.02022041f, 0.03240833f, -0.01170318f, 
    -0.01586868f, -0.04083854f, -0.03349380f, 0.02364596f, 0.01383729f, 0.01571672f, -0.03557239f, -0.04181110f, 
    0.02805427f, -0.04052901f, -0.03982352f, -0.01213203f, -0.03322783f, 0.01593975f, -0.00684641f, 0.01157263f, 
    -0.00112361f, -0.03704155f, 0.00198692f, 0.01689532f, -0.02440884f, -0.03597272f, -0.03761267f, -0.03430774f, 
    -0.01157205f, -0.01373989f, 0.02844124f, -0.03860570f, 0.00294342f, -0.01807931f, -0.00333446f, -0.00669389f, 
    -0.03166699f, 0.02307216f, 0.02656564f, -0.03956818f, -0.03733939f, -0.01383954f, 0.02071456f, -0.01981268f, 
    -0.01402250f, -0.01237158f, -0.00710040f, 0.00528120f, 0.00624353f, -0.02573594f, -0.01948622f, 0.02204157f, 
    0.01599174f, -0.01400335f, -0.00997154f, 0.00502043f, -0.03655811f, 0.01442517f, -0.01633803f, -0.01809000f, 
    -0.03088490f, -0.01263471f, -0.03372632f, 0.01209188f, -0.02052194f, 0.02431252f, 0.02636989f, 0.01488971f, 
    0.02116114f, 0.00588821f, -0.02549170f, -0.02349237f, 0.02733587f, 0.00012833f, -0.03700466f, -0.01873987f, 
    -0.00951046f, -0.03939839f, -0.03907931f, -0.00880982f, -0.00677988f, 0.02150610f, -0.03283012f, -0.00986927f, 
    -0.02700166f, 0.00492570f, 0.01407024f, -0.00461050f, 0.00242903f, -0.03102708f, -0.02351486f, 0.00086227f, 
    0.02981334f, -0.01689546f, -0.01617388f, -0.00578781f, -0.01228713f, -0.03839917f, -0.02036539f, -0.02692453f, 
    -0.03247664f, 0.02848892f, -0.02302487f, -0.03257647f, 0.01236509f, 0.01416668f, 0.01894563f, -0.02016931f, 
    0.01904813f, -0.04004564f, -0.01544183f, 0.01202899f, -0.00758579f, 0.02063268f, 0.01816657f, 0.02056080f, 
    0.03151279f, -0.01792583f, 0.03451211f, -0.02947516f, 0.00521734f, -0.01742565f, 0.02587235f, 0.01510488f, 
    0.02945079f, 0.02067401f, 0.00323739f, -0.00014758f, -0.02045779f, 0.01523487f, 0.02214506f, 0.00725472f, 
    0.01847684f, -0.00493029f, -0.04123553f, -0.01601570f, 0.03117029f, -0.03788674f, 0.00957198f, 0.02235880f, 
    0.02966924f, -0.00239966f, -0.03832497f, 0.03048181f, -0.01379420f, -0.00048589f, 0.03069153f, -0.01842193f, 
    -0.02869075f, -0.00544804f, -0.00574516f, 0.00234916f, 0.02867821f, 0.00196449f, -0.00420606f, -0.04206637f, 
    0.02954849f, -0.01295188f, -0.01385344f, 0.00020852f, 0.01496881f, -0.02842706f, 0.01959953f, -0.02574167f, 
    -0.01685903f, -0.00915719f, -0.01975309f, -0.02953509f, 0.01286090f, -0.01448736f, -0.01028414f, -0.02030182f, 
    -0.02747203f, -0.01715826f, -0.01153542f, 0.02750985f, 0.00080998f, -0.02149224f, -0.04176159f, -0.04012848f, 
    -0.01066747f, 0.02521684f, -0.01137844f, -0.04107681f, 0.02725909f, -0.00319260f, 0.00263200f, 0.00833049f, 
    0.02143609f, 0.01975505f, -0.00117141f, 0.01820982f, -0.00496071f, -0.02152003f, -0.00101721f, 0.00949945f, 
    -0.00500694f, -0.03041633f, -0.03406288f, -0.01014286f, 0.01318014f, 0.01241289f, 0.00118710f, -0.00863281f, 
    0.02667872f, -0.01902179f, -0.03054424f, 0.01856571f, -0.03014343f, 0.02565620f, -0.02029699f, 0.00163171f, 
    -0.00752779f, -0.00502307f, -0.03389150f, 0.01281263f, -0.03444341f, -0.01028169f, -0.03233012f, 0.02537271f, 
    0.02156547f, -0.02033940f, 0.01305130f, 0.00625925f, 0.01829544f, -0.01712504f, -0.03708033f, 0.01663497f, 
    -0.04177435f, -0.03526103f, 0.00194504f, 0.01113165f, 0.01978106f, -0.01052081f, 0.02636177f, -0.01008893f, 
    -0.03033743f, -0.04018538f, 0.00282933f, -0.01552658f, 0.01763184f, 0.01534521f, 0.02745149f, 0.00593319f, 
    -0.04050337f, 0.02169729f, 0.00152227f, 0.00939358f, -0.01800452f, -0.00030702f, -0.00115509f, -0.00110610f, 
    -0.02006132f, 0.02549903f, 0.02089287f, 0.00897625f, -0.02884117f, -0.02202153f, 0.02079614f, 0.01588963f, 
    0.02008795f, -0.02903693f, 0.01564874f, -0.01915985f, -0.01982187f, 0.00818839f, 0.01823083f, 0.02277367f, 
    0.00936384f, 0.02198606f, -0.03144136f, -0.00193122f, 0.01411120f, -0.03703037f, 0.01131788f, -0.01139032f, 
    0.02137281f, -0.04197015f, 0.01263802f, 0.02590623f, -0.03918342f, -0.00937487f, -0.03274602f, -0.00337989f, 
    0.02584502f, -0.00879580f, 0.00363122f, -0.00591817f, -0.01137153f, 0.02531671f, -0.04200057f, -0.03271692f, 
    -0.02868601f, -0.03895431f, -0.00972385f, -0.03624197f, -0.01704536f, 0.00581473f, 0.02571932f, -0.03318920f, 
    0.02733684f, 0.01791351f, 0.01162345f, -0.04006968f, -0.01851287f, 0.00199882f, 0.01756271f, 0.01008297f, 
    -0.02214179f, 0.02996110f, 0.00749875f, -0.02254561f, 0.01736047f, -0.03357448f, -0.03618130f, -0.00830543f, 
    0.00516234f, -0.04151566f, 0.00732224f, -0.01458722f, -0.03061098f, -0.04160827f, 0.01989305f, 0.01416370f, 
    0.02715078f, 0.02404195f, 0.01559729f, -0.00641982f, 0.02185354f, 0.02735593f, -0.00959165f, -0.00548833f, 
    0.00302062f, 0.00129218f, 0.02395322f, 0.01964024f, -0.03395701f, 0.00255050f, 0.02353272f, -0.03251236f, 
    -0.01245791f, -0.01181653f, -0.01650237f, -0.01528511f, -0.01855577f, -0.01192668f, -0.00612061f, -0.03443016f, 
    -0.00320986f, -0.03267316f, -0.01821736f, -0.00507856f, 0.00217051f, -0.01871953f, -0.00062731f, 0.02090655f, 
    0.02073341f, -0.01315961f, 0.02123878f, 0.01111503f, -0.02951499f, 0.01325864f, -0.00072270f, -0.02175833f, 
    -0.00213356f, -0.01268186f, 0.02667800f, -0.01590228f, -0.04063476f, -0.00987258f, 0.03545101f, 0.00938600f, 
    0.01321958f, 0.00805818f, -0.02268425f, -0.01036073f, -0.02122863f, -0.02605765f, -0.02150859f, -0.01644813f, 
    -0.02502392f, -0.02999678f, 0.01891249f, 0.00257331f, 0.00871372f, -0.01071323f, -0.01337816f, 0.02418351f, 
    -0.01751661f, -0.00982508f, -0.03051827f, 0.00564842f, -0.02866965f, -0.04097467f, -0.02849652f, -0.01120696f, 
    -0.03393875f, -0.01907387f, 0.00737107f, -0.00436895f, -0.00577229f, -0.03858468f, -0.02370049f, -0.00179031f, 
    -0.02974683f, -0.02550626f, -0.01310724f, -0.03427206f, 0.00118671f, 0.01315729f, 0.00051452f, -0.02840445f, 
    0.00525605f, 0.02967191f, 0.01849165f, 0.01143762f, -0.02052933f, 0.01532359f, 0.00902739f, -0.03346719f, 
    -0.04160229f, -0.01050505f, 0.01125785f, 0.02644114f, 0.01071099f, 0.02423964f, -0.02200216f, -0.04082319f, 
    -0.03382703f, 0.00889417f, 0.01494359f, 0.02640254f, 0.02036278f, 0.01488169f, 0.02724139f, -0.02458366f, 
    -0.01387353f, 0.02484842f, 0.01355497f, -0.00652215f, -0.03599362f, 0.00615539f, -0.01417211f, -0.00237446f, 
    0.01716453f, -0.03327963f, -0.01545763f, -0.01854964f, 0.01861352f, -0.03967887f, -0.02557300f, 0.02381039f, 
    0.02469454f, 0.01714177f, 0.02105496f, -0.02515520f, 0.01766813f, -0.03467173f, 0.03594986f, -0.00331623f, 
    0.01595339f, -0.01290215f, -0.02291739f, -0.03377656f, -0.00200730f, 0.02127705f, 0.01468661f, -0.00437829f, 
    0.01955209f, -0.00024016f, 0.02718015f, 0.01758142f, -0.02202477f, -0.03856716f, 0.01482717f, -0.02302128f, 
    0.01014915f, -0.01347303f, -0.01556503f, -0.03960992f, 0.00297102f, 0.02144203f, 0.00874824f, 0.02680336f, 
    -0.01375055f, -0.03813623f, 0.02204149f, -0.00183700f, 0.00478692f, -0.02368016f, -0.00766637f, 0.00701743f, 
    -0.02265514f, -0.02923335f, 0.02983911f, -0.00685651f, -0.02924520f, -0.01917793f, 0.00089348f, -0.00307749f, 
    -0.02786410f, -0.03567576f, -0.00984123f, -0.02765226f, -0.02369746f, 0.01070769f, -0.02543061f, 0.00196921f, 
    0.02109421f, -0.03204439f, -0.02027201f, -0.03220478f, -0.01549978f, -0.03248224f, -0.00947577f, 0.01651746f, 
    0.02882360f, 0.02020746f, 0.01154073f, 0.01605457f, 0.00503424f, 0.01202909f, 0.01148597f, -0.01469481f, 
    -0.03746131f, 0.01896633f, 0.00816394f, 0.01597934f, 0.01373564f, -0.03465891f, -0.00853974f, -0.00367357f, 
    -0.03148496f, 0.01480253f, -0.00692142f, -0.01155950f, -0.01279842f, 0.00384398f, -0.02190589f, -0.01876529f, 
    0.01380742f, 0.02699613f, -0.00304248f, -0.01910196f, -0.01084172f, -0.01140040f, -0.00595278f, 0.01949145f, 
    0.01459488f, 0.01126366f, -0.01920811f, -0.01077559f, 0.02074163f, -0.02917181f, 0.02760241f, -0.00150614f, 
    0.03028261f, 0.02314349f, -0.03692505f, -0.01979654f, -0.01301247f, -0.02723430f, -0.03957272f, -0.01771586f, 
    0.01991717f, 0.01413040f, 0.01986061f, -0.04134704f, -0.02381036f, -0.00642294f, -0.03272317f, -0.01552088f, 
    0.01926757f, 0.00500516f, -0.02714008f, -0.01168127f, -0.01713354f, -0.03929926f, -0.00158197f, -0.02978360f, 
    0.02481490f, 0.03573501f, 0.02189964f, 0.00619339f, 0.00839896f, -0.02942685f, -0.03516077f, 0.00737923f, 
    0.01740593f, 0.00379098f, 0.01045668f, 0.02726452f, 0.02247596f, 0.02187429f, -0.03222800f, -0.03947821f, 
    0.02236277f, 0.02196588f, -0.00087030f, 0.02243057f, -0.01758991f, 0.00341656f, 0.03534628f, -0.01556775f, 
    -0.02006591f, -0.02759408f, 0.00773131f, -0.03778943f, 0.02881345f, 0.01157221f, -0.00512935f, -0.00974903f, 
    0.01167658f, -0.02396105f, 0.00184727f, 0.00112628f, -0.02717066f, 0.00484139f, -0.00726758f, -0.02128768f, 
    -0.02215665f, 0.02079803f, -0.02355302f, 0.01214315f, 0.01002964f, -0.03208704f, -0.01354265f, -0.03399061f, 
    -0.03329131f, 0.02472407f, 0.02193266f, 0.02718360f, -0.03120667f, 0.01470697f, -0.03957574f, 0.01397013f, 
    -0.04107346f, 0.00188675f, -0.02178693f, -0.01316101f, 0.01077159f, -0.00497521f, -0.03722301f, -0.00256810f, 
    -0.02298955f, 0.00122149f, -0.01586419f, -0.00047040f, 0.00108582f, 0.00719020f, -0.03997739f, 0.00979246f, 
    -0.03467416f, 0.01190225f, 0.02997172f, 0.02054414f, -0.01664731f, 0.00396262f, -0.03489189f, 0.00078115f, 
    0.01020774f, 0.01830455f, -0.04120254f, -0.03245596f, 0.01409108f, -0.02294872f, -0.00777970f, -0.03907759f, 
    -0.01654743f, -0.02717295f, -0.02212127f, 0.02638405f, -0.03846455f, 0.00408983f, 0.02842927f, 0.00732034f, 
    0.00553311f, 0.02002865f, -0.02904969f, -0.02286466f, -0.03532245f, 0.00181972f, -0.00537304f, 0.01722684f, 
    0.00416634f, -0.02162248f, -0.04055493f, -0.01780940f, -0.03751196f, -0.01662140f, 0.00182720f, 0.00535205f, 
    -0.04008104f, 0.00407376f, -0.01142932f, 0.02643457f, -0.03501566f, -0.01548606f, 0.03005856f, -0.00495112f, 
    -0.02588603f, -0.03973195f, 0.01081729f, -0.03362210f, 0.01229462f, -0.01605286f, -0.02422130f, 0.01267227f, 
    -0.00144308f, 0.01448314f, -0.02440757f, -0.03400339f, 0.00745932f, -0.00713832f, 0.02213037f, 0.00243162f, 
    0.00687273f, -0.02656378f, 0.01399267f, -0.01070751f, 0.00116640f, 0.03484252f, 0.01273212f, 0.00823647f, 
    0.03102835f, -0.01855086f, -0.03703585f, -0.03358334f, 0.01880809f, 0.02682181f, -0.01393817f, 0.01135010f, 
    -0.00467025f, -0.00055200f, -0.02037791f, -0.02604654f, 0.00219189f, -0.01252928f, 0.00291757f, -0.02530218f, 
    0.00113044f, 0.01684713f, -0.01675108f, -0.03901654f, 0.03004106f, -0.03273361f, -0.00029928f, -0.03944207f, 
    -0.00008546f, -0.03410268f, -0.01246874f, -0.00575947f, 0.00106041f, -0.03025648f, 0.00193952f, -0.02433679f, 
    0.02873885f, -0.00899638f, -0.02858135f, -0.03015861f, 0.00459315f, -0.02353432f, 0.01786407f, -0.01945411f, 
    0.00883918f, -0.01821160f, -0.00181997f, -0.01133914f, 0.02611382f, 0.00429876f, -0.00600673f, 0.02207581f, 
    0.02989953f, 0.02585756f, -0.03677087f, -0.02918199f, 0.02403270f, -0.02666217f, -0.00484201f, 0.02656992f, 
    -0.00993342f, -0.02863851f, -0.02353097f, 0.00532260f, -0.01891440f, 0.01612865f, 0.01569685f, -0.02523457f, 
    -0.02106168f, -0.00258803f, 0.00576959f, 0.02880158f, -0.03590541f, 0.03025176f, -0.01261600f, -0.02222653f, 
    0.02601442f, -0.02868441f, -0.02168592f, -0.03343421f, 0.02387248f, 0.00161917f, -0.03564879f, -0.02097040f, 
    -0.03619254f, -0.03705307f, -0.04044200f, -0.02837717f, 0.00228653f, -0.02663846f, -0.00880903f, -0.00866217f, 
    0.00386222f, 0.01081673f, -0.01440628f, -0.03620113f, 0.01157370f, -0.00232951f, -0.03744683f, 0.03026540f, 
    0.02835266f, -0.03326712f, -0.02351480f, 0.01381654f, -0.03857842f, 0.00163817f, -0.01559349f, -0.00929918f, 
    0.01159065f, 0.02428987f, -0.03402148f, -0.01711419f, 0.01496311f, 0.02709901f, 0.01204360f, 0.01742421f, 
    0.00489663f, -0.00854322f, 0.01164340f, -0.00802969f, -0.01151606f, 0.02056189f, -0.02887878f, -0.01920916f, 
    -0.02356201f, -0.02728872f, -0.00401794f, 0.01983436f, 0.01433352f, 0.01795949f, 0.02439713f, -0.00033611f, 
    0.02075706f, -0.01904448f, -0.01045102f, 0.00989166f, -0.03932276f, -0.03616839f, 0.02958610f, -0.01042263f, 
    0.01278373f, 0.00138762f, 0.01049385f, 0.01714725f, -0.01981505f, 0.02190833f, 0.01753949f, -0.00449969f, 
    -0.01641148f, 0.00010432f, -0.01195357f, 0.02245186f, -0.01336327f, 0.02050079f, -0.01663057f, -0.03550522f, 
    -0.02459648f, -0.02434610f, -0.01743891f, -0.03755700f, -0.00340847f, 0.02331894f, 0.00449497f, -0.01521508f, 
    0.02998128f, -0.00165315f, 0.00922771f, -0.02140081f, -0.03646712f, -0.00024147f, -0.03382403f, 0.01063749f, 
    0.01675202f, 0.02478660f, -0.02675423f, -0.00286449f, -0.02331368f, 0.01747266f, 0.01219565f, 0.01113042f, 
    -0.02123119f, -0.02483910f, -0.02415594f, -0.02029827f, 0.01701442f, 0.02302601f, -0.01753426f, -0.00704395f, 
    0.00920001f, -0.03316861f, -0.03540667f, -0.01880293f, -0.03265042f, 0.00668923f, 0.01096724f, 0.01195577f, 
    -0.03807968f, -0.03226485f, -0.00107092f, -0.03763252f, 0.02850001f, 0.00244606f, -0.02556887f, -0.03651204f, 
    -0.02070652f, -0.03393131f, -0.01761618f, -0.00586132f, 0.01416863f, 0.01756572f, 0.01549960f, -0.04068605f, 
    0.01104596f, -0.00950032f, -0.01686257f, -0.00569401f, -0.00691227f, -0.00325318f, 0.02600476f, -0.01376059f, 
    -0.02516505f, -0.00194004f, -0.01457336f, -0.01509690f, -0.00341950f, 0.02202864f, -0.02689179f, -0.02824930f, 
    -0.03597257f, -0.00552051f, -0.02337419f, -0.03716489f, 0.03209284f, -0.01552144f, 0.00637631f, 0.02247042f, 
    -0.03594269f, 0.01977796f, -0.01404928f, -0.00373245f, -0.03230857f, 0.00713344f, 0.01636878f, -0.02734156f, 
    0.01891014f, 0.01536084f, 0.00302336f, -0.01665714f, -0.02374782f, -0.01284120f, -0.03915618f, -0.01271019f, 
    -0.03734956f, 0.00000401f, -0.03120831f, -0.02720715f, 0.00586241f, -0.03038032f, 0.02694204f, -0.03295772f, 
    -0.01181594f, -0.00541252f, -0.02115765f, -0.01341378f, 0.01214446f, 0.01165780f, -0.00313754f, -0.02833439f, 
    0.01389814f, 0.00230038f, -0.00931042f, 0.01737763f, 0.01161711f, -0.00858872f, -0.00340465f, 0.01860375f, 
    -0.01673463f, 0.02709747f, -0.00314396f, -0.03978575f, 0.02725669f, -0.00391536f, 0.02475731f, -0.03456304f, 
    -0.00797043f, -0.01026851f, 0.02964799f, -0.00654074f, 0.00234641f, -0.04057777f, -0.02001576f, -0.00157686f, 
    -0.00385657f, 0.02910536f, -0.00488689f, -0.03725842f, -0.03381776f, -0.00295510f, 0.00779082f, 0.01729566f, 
    -0.04078836f, -0.01152412f, -0.01137784f, 0.02564732f, -0.03575742f, -0.02458996f, -0.00188747f, -0.02966732f, 
    -0.01376181f, 0.00132741f, 0.02291567f, -0.00130973f, -0.00926941f, 0.01505088f, -0.03158803f, 0.02738935f, 
    0.00230211f, 0.00905578f, 0.02363798f, 0.01936215f, -0.03346725f, -0.04136350f, -0.02928476f, -0.03186959f, 
    -0.03097972f, 0.00459672f, 0.02007591f, -0.03123924f, 0.02751605f, 0.00758398f, -0.03184668f, -0.03843505f, 
    -0.00063972f, 0.02849731f, 0.01706032f, -0.01062421f, -0.04081350f, 0.02918513f, 0.01918155f, -0.01025378f, 
    -0.01906467f, 0.02640260f, -0.00792237f, -0.01696504f, -0.00901803f, 0.00757990f, 0.01762780f, -0.01189327f, 
    0.02859691f, 0.01264687f, -0.01398257f, -0.03805208f, -0.02173679f, -0.03353635f, -0.03574495f, -0.03155154f, 
    -0.01715585f, -0.03663962f, -0.00622306f, 0.02973496f, -0.01292266f, 0.01284965f, 0.02810093f, -0.00969741f, 
    0.00754971f, -0.02908033f, -0.01345745f, 0.00553416f, -0.00232810f, 0.02892710f, -0.00118803f, 0.01978677f, 
    -0.03410069f, -0.03013468f, -0.00540590f, -0.03607354f, -0.02362038f, -0.00834451f, 0.01331291f, -0.02721804f, 
    0.00720950f, -0.01242923f, 0.00106701f, -0.01182026f, 0.00717180f, 0.03536047f, 0.00296564f, 0.00111892f, 
    -0.03594402f, -0.04090636f, 0.02239800f, -0.00106892f, -0.02304479f, -0.00630342f, -0.02924980f, -0.00859588f, 
    -0.01972670f, -0.01526376f, -0.01999231f, -0.01886518f, 0.02809406f, -0.02798092f, -0.02301232f, -0.03307423f, 
    0.02123402f, -0.03933140f, -0.01418225f, 0.00312786f, -0.02467343f, -0.02167313f, 0.01068884f, 0.00356413f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02221731f, 0.19548883f, 0.04633432f, 0.01046609f, 0.09281560f, -0.02250287f, -0.04297782f, -0.01912050f, 
    -0.02058738f, -0.02064339f, -0.01117683f, -0.01162673f, 0.00749116f, -0.01540677f, -0.02941470f, 0.11678018f, 
    -0.01339529f, -0.01354203f, 0.22311635f, -0.02610455f, -0.04511989f, 0.14287794f, 0.07598328f, -0.00004369f, 
    -0.07935579f, -0.08801546f, -0.00670569f, 0.03710366f, 0.00129009f, -0.00351620f, -0.00926915f, -0.00372535f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07339374f, -0.37793511f, 0.18306427f, -0.02368886f, -0.29600495f, -0.14737222f, 0.13597463f, -0.09068115f, 
    0.28537571f, -0.17120884f, -0.13531899f, 0.11019152f, -0.10204788f, -0.15079668f, -0.03275730f, -0.29316103f, 
    -0.19208507f, 0.09695187f, -0.22873995f, -0.18008663f, -0.07059950f, -0.10964598f, 0.23755635f, -0.13438225f, 
    0.19532834f, 0.35388446f, 0.15465498f, -0.48672009f, 0.20132490f, 0.17094642f, 0.12802854f, -0.00915478f, 
    0.00294154f, 0.08384267f, -0.14947793f, -0.00974077f, 0.33065537f, -0.14858069f, -0.07733056f, 0.13180797f, 
    0.00686964f, 0.08942091f, -0.03552275f, 0.01877592f, -0.06587028f, 0.01367056f, -0.07691325f, -0.07182053f, 
    -0.78623152f, 0.03146412f, 0.04132459f, -0.35094860f, -0.29828814f, 0.23472166f, 0.18439645f, 0.00345704f, 
    0.16363883f, 0.44602522f, 0.03434353f, -0.03645802f, -0.57427794f, 0.01972882f, 0.10133535f, -0.08381804f, 
    -0.03059493f, 0.22566971f, 0.22242491f, -0.00452215f, 0.23830560f, 0.03590344f, -0.13505439f, 0.13014719f, 
    -0.05108587f, -0.13978273f, -0.14164466f, 0.08732519f, 0.10039713f, 0.00818609f, -0.07965636f, -0.12501602f, 
    0.09722724f, 0.16724576f, 0.19725944f, 0.03650859f, -0.08117794f, -0.27356386f, -0.23360936f, -0.06833225f, 
    0.23520052f, -0.50406432f, -0.09042908f, -0.25428820f, -0.27481708f, -0.72042298f, -0.05592577f, -0.12428270f, 
    -0.11951115f, -0.38082784f, -0.16464838f, 0.00856779f, 0.15906709f, -0.03160080f, -0.08518555f, 0.05466604f, 
    0.08609804f, -0.03884988f, 0.02594846f, -0.11625868f, -0.15741128f, -0.17828007f, 0.11741066f, 0.02390349f, 
    0.33908489f, 0.09929270f, -0.27278048f, 0.39892542f, -0.04964520f, -0.43480814f, -0.03897900f, -0.16269934f, 
    0.19666065f, 0.04100313f, -0.04047880f, 0.14808157f, -0.36885297f, -0.27602553f, -0.03869852f, -0.17951147f, 
    -0.05495978f, -0.17706484f, 0.16397728f, -0.00799567f, -0.24618961f, 0.16463514f, 0.06281865f, -0.11937248f, 
    -0.28088278f, -0.18038914f, -0.12176112f, -0.03759279f, 0.12798373f, 0.02223415f, -0.01593990f, -0.10840320f, 
    0.27454841f, -0.12118515f, -0.06554572f, -0.21216998f, 0.32217062f, 0.31997028f, -0.37683797f, -0.03154852f, 
    0.20915659f, -0.01309128f, 0.02446607f, -0.27094966f, 0.06327471f, 0.22076245f, -0.11484019f, 0.02255706f, 
    0.01935475f, -0.11795262f, -0.29000869f, -0.00498403f, -0.25643077f, -0.12450512f, -0.02749616f, -0.05872930f, 
    0.15258910f, -0.02960806f, 0.12823319f, 0.03479339f, -0.09276094f, -0.10300612f, -0.17645569f, 0.27663273f, 
    -0.04125048f, -0.02377500f, -0.11281117f, -0.42114949f, 0.27403575f, 0.15554184f, 0.20214626f, 0.13437006f, 
    -0.19529557f, -0.23653272f, 0.15603492f, -0.15542032f, 0.02730202f, 0.35093835f, -0.10084513f, 0.14870057f, 
    -0.11353728f, -0.08078140f, -0.08153401f, -0.10759094f, 0.11184991f, 0.05688063f, 0.10404742f, 0.07337869f, 
    -0.30654898f, 0.10081476f, -0.04428944f, -0.14809391f, 0.14851864f, 0.00007290f, -0.18135796f, -0.03225415f, 
    0.02812632f, 0.16530807f, 0.23259792f, 0.36558098f, 0.08244473f, 0.16961126f, -0.82729900f, 0.03266111f, 
    -0.67440093f, -0.53581661f, -0.10075521f, -0.17187341f, 0.49118680f, -0.47313657f, -0.17992949f, 0.16329882f, 
    -0.04766145f, 0.27575973f, -0.77944994f, -0.02833609f, 0.25907448f, 0.01650321f, 0.13885683f, 0.09032495f, 
    -0.24221873f, -0.14947329f, 0.07436834f, 0.06988846f, -0.13069345f, -0.03883348f, -0.06247932f, -0.35979146f, 
    -0.27328134f, -0.16015415f, -0.45121667f, 0.32342315f, 0.19562213f, -0.07717657f, -0.12561178f, -0.04396956f, 
    -0.40840653f, -0.33425394f, -0.15224732f, 0.20483275f, 0.19102845f, -0.16352877f, 0.11974948f, -0.06131936f, 
    -0.11006446f, -0.11612114f, -0.16002926f, -0.06267041f, -0.41518459f, 0.12085103f, 0.06937195f, 0.03329580f, 
    0.09352381f, 0.01377753f, 0.10195274f, 0.01649117f, 0.11572680f, -0.12448290f, 0.01454295f, 0.08221410f, 
    0.02769827f, -0.14231640f, 0.10209132f, 0.11423028f, -0.78600276f, -0.15736356f, 0.39409426f, 0.10778578f, 
    -0.65174931f, -0.36101592f, -0.15208066f, 0.25328809f, -0.11530388f, -0.57410204f, 0.04706337f, -0.03215346f, 
    -0.07325773f, 0.02291078f, -0.30282542f, -0.09612389f, 0.20775265f, -0.01537032f, 0.05589553f, -0.05553237f, 
    -0.57374424f, 0.16275869f, -0.09833275f, -0.00079105f, 0.12838104f, -0.10159680f, 0.14347537f, -0.37462026f, 
    0.28498715f, 0.00513483f, 0.25885582f, -0.65311313f, 0.24826683f, -0.30930299f, -0.03624908f, -0.00886243f, 
    -0.16399343f, 0.24154861f, -0.12619025f, 0.01779876f, 0.43452078f, -0.21426950f, -0.10611451f, -0.14012557f, 
    -0.17054363f, -0.26331684f, 0.38163605f, 0.14719784f, 0.35297620f, 0.06905143f, 0.09424756f, 0.02315577f, 
    0.01364383f, 0.14746106f, 0.08606008f, 0.05994574f, -0.03261961f, -0.01906165f, 0.05429364f, 0.50743693f, 
    -0.13701074f, 0.02111405f, -0.12709558f, -0.04091826f, -0.43604201f, -0.06542664f, -0.55447555f, -0.13303934f, 
    -0.14189385f, -0.19713970f, -0.11422472f, 0.10980325f, -0.42406270f, -0.20644654f, 0.15601385f, -0.06967582f, 
    -0.08623292f, -0.25693589f, 0.48986062f, -0.05607950f, -0.51659799f, 0.10074733f, 0.08978012f, 0.05075647f, 
    -0.68718445f, -0.00041183f, -0.09311489f, 0.06723620f, -0.08695717f, 0.03608813f, 0.07137565f, 0.02579388f, 
    -0.45900097f, 0.12413468f, 0.13189098f, 0.41983864f, 0.25585112f, 0.12060298f, 0.01528443f, -0.16312580f, 
    -0.10396387f, -0.03341370f, -0.13299313f, 0.07479881f, -0.43595955f, -0.39863670f, -0.08758768f, -0.09322594f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.08805536f, 0.19480218f, 0.20661177f, -0.12156941f, 0.05516096f, -0.06277198f, -0.10171731f, -0.10171415f, 
    -0.23970364f, -0.05820277f, -0.10082541f, -0.20623060f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
